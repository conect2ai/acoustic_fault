#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.50638956f, 0.22738530f, 0.06895772f, 0.06855191f, -0.05836762f, -0.94582015f, 0.29621238f, -0.20894489f, 
    -0.49447036f, -0.04393575f, 0.40055367f, 0.20396359f, 0.15394013f, -0.11281138f, -0.05153949f, -0.00349553f, 
    0.03543483f, 0.01638171f, 0.07855628f, -0.12460523f, 0.15810576f, -0.10081740f, 0.08870202f, 0.10979807f, 
    0.20069531f, -0.49576533f, 0.14398246f, -0.37312138f, -0.75070345f, -0.40812922f, -0.15431221f, -0.01542523f, 
    -0.52535015f, -0.59708607f, 0.07547268f, 0.05433838f, 0.02874191f, 0.06013062f, 0.10787724f, 0.10379840f, 
    -0.01324723f, 0.04940990f, -0.03418838f, 0.09785548f, 0.31328180f, -0.34193376f, 0.19294013f, -0.02375972f, 
    -0.05531234f, 0.12100197f, -0.29313684f, 0.50459701f, 0.15558149f, -0.47353426f, 0.63542360f, -0.21473646f, 
    -0.47581491f, -0.57699877f, -0.36732587f, -0.47863770f, 0.31382701f, -0.37711075f, 0.27684936f, 0.05802730f, 
    -0.16263968f, 0.16396889f, -0.09058317f, 0.01193178f, -0.16964127f, -0.06008166f, 0.12598357f, 0.07639951f, 
    -0.01645184f, 0.02443464f, -0.11356974f, -0.47398314f, 0.61848491f, 0.77265835f, -0.00030938f, 0.19325155f, 
    -0.50295216f, 0.71463710f, -0.03038955f, -0.03146738f, 0.02340384f, -0.26056322f, 0.12860124f, -0.16689861f, 
    0.09238392f, 0.00338226f, -0.21113199f, -0.19833459f, -0.08645606f, -0.07564437f, 0.00482737f, 0.15527882f, 
    0.15472123f, 0.47569224f, 0.31526741f, -0.03740653f, -0.03467812f, -0.23329340f, 0.09797589f, 0.61939526f, 
    0.05738472f, 0.39928156f, 0.85474068f, 0.33278519f, -0.03548703f, 0.29511490f, -0.14942729f, 0.08221638f, 
    0.10045002f, -0.29140031f, 0.16107056f, -0.25703815f, -0.20333858f, -0.02791682f, 0.20553999f, -0.06572209f, 
    -0.00060946f, 0.28883752f, -0.17739302f, 0.09220988f, 0.01990288f, -0.59162730f, 0.52859628f, 0.59465915f, 
    0.49036902f, 0.18943118f, 0.20715253f, 0.51237601f, -0.08280656f, -0.09147454f, -0.27000967f, 0.25784108f, 
    -0.02560401f, -0.20589854f, -0.07404169f, 0.03986895f, 0.01218230f, -0.07067217f, 0.04212529f, -0.18390240f, 
    -0.00225141f, 0.04530990f, -0.00542754f, -0.32644972f, -0.04177588f, -0.09371987f, 0.34775457f, 0.54631394f, 
    0.47131866f, 0.65246350f, 0.47440842f, -0.08784837f, -0.03961580f, -0.55443209f, -0.09086195f, -0.01274430f, 
    -0.07997800f, 0.23849410f, 0.30466086f, 0.28539038f, -0.15202402f, -0.02706927f, 0.25934759f, 0.45103019f, 
    0.07835906f, 0.05973553f, -0.13702749f, -0.14526114f, -0.10395307f, 0.01622046f, -0.16517657f, -0.51795882f, 
    -0.56955880f, -0.17002611f, 0.07158736f, -0.14125127f, -0.13495989f, 0.32748014f, 0.54668063f, -0.19373973f, 
    0.08939105f, 0.39624503f, 0.09599037f, 0.13004778f, -0.09311516f, 0.44722307f, 0.48895335f, 0.05309924f, 
    -0.42256501f, 0.06156151f, -0.12821253f, -0.15483856f, -0.35294139f, -0.12012053f, -0.12039643f, 0.02434441f, 
    0.44375825f, 0.29280269f, 0.64569074f, 0.76849765f, 0.44788903f, 0.42219606f, -0.53995645f, -0.20090514f, 
    -0.62870657f, -0.15307644f, 0.26876047f, 0.06536444f, -0.18964970f, 0.24127924f, 0.00426757f, 0.07801151f, 
    0.10484023f, -0.16532095f, 0.19766547f, 0.01942118f, 0.24946460f, 0.10762074f, -0.01874875f, 0.01365757f, 
    0.18802802f, 0.88924754f, 0.43054426f, -0.38806024f, -0.47132725f, -0.92719257f, -0.03579625f, 0.24320629f, 
    -0.17245635f, -0.12701173f, 0.21386546f, 0.16044496f, -0.08007537f, 0.03446838f, -0.01662277f, 0.03565267f, 
    -0.02070012f, 0.23688588f, -0.11305828f, -0.03396411f, -0.06870306f, -0.07154115f, -0.22117807f, -0.00342511f, 
    0.11490935f, -0.01753969f, -0.42107883f, 0.09156304f, -0.15846559f, -0.30890977f, 0.43632847f, -0.21381675f, 
    -0.40868017f, -0.69811970f, -0.31374234f, 0.02019601f, -0.20214531f, 0.22633594f, -0.21371354f, 0.04666143f, 
    -0.38701433f, -0.29536003f, 0.08361146f, -0.07529252f, -0.18413717f, 0.09426980f, -0.14020482f, 0.30225196f, 
    -0.04812274f, -0.05386454f, -0.17919786f, 0.05114976f, 0.54936343f, -0.30507416f, -0.82004595f, 0.05195370f, 
    0.37414491f, -0.24014370f, -0.33937111f, -0.29356912f, -0.38357875f, 0.12450615f, 0.12564886f, 0.18565783f, 
    0.16970424f, -0.10371293f, 0.12682511f, 0.09462946f, 0.10088684f, 0.09479384f, 0.13987637f, -0.04082334f, 
    -0.26397979f, -0.09648333f, -0.19260399f, 0.26496047f, 0.03403734f, 0.28162345f, -0.32897088f, -0.39885935f, 
    0.38809037f, 0.15569845f, 0.11011911f, -0.43446261f, 0.12346822f, -0.15481581f, -0.22810587f, 0.44197494f, 
    -0.25749093f, -0.10192254f, 0.12835167f, 0.24572432f, -0.43009105f, -0.02438911f, 0.24742863f, 0.17831282f, 
    0.00034899f, -0.08240758f, -0.18867473f, -0.11605489f, -0.08857055f, -0.20093285f, -0.04703454f, -0.17084251f, 
    -0.35621336f, -0.07838381f, -0.15273836f, 0.39541367f, -0.05912843f, -0.04191907f, -0.24197152f, -0.10713763f, 
    0.48551229f, -0.43440068f, 0.14312921f, 0.58919215f, -0.30795309f, -0.27448955f, 0.24988285f, -0.30296743f, 
    -0.05832746f, 0.23124236f, 0.08750046f, -0.01178722f, 0.27195033f, 0.05438736f, 0.18343881f, -0.30046552f, 
    -0.66593742f, -0.65484607f, 0.08240137f, 0.12897854f, -0.54817718f, -0.00979874f, 0.19069040f, 0.04942760f, 
    -0.58222473f, -0.32414219f, -0.07805984f, 0.06081682f, -0.34868437f, -0.16360883f, -0.20872176f, 0.24240208f, 
    -0.03664437f, -0.16784310f, -0.17375027f, 0.09747019f, -0.09000613f, 0.33754262f, -0.00834496f, -0.68274504f, 
    -0.60660839f, -0.50253493f, -0.17172705f, -0.12159109f, 0.31154498f, 0.35875508f, 0.36025622f, 0.29699117f, 
    0.49843004f, 0.01553590f, -0.18202421f, 0.05489378f, 0.00612397f, -0.04919947f, 0.16101533f, 0.13438766f, 
    0.15756835f, 0.16656348f, -0.29442108f, 0.11052474f, -0.17550924f, -0.14423780f, 0.39810780f, -0.02640672f, 
    0.03671167f, 0.56424177f, 0.61987442f, 0.71908510f, -0.09336913f, 0.25160861f, 0.39115143f, 0.39349243f, 
    0.30369720f, 0.10205349f, -0.34606680f, -0.18170132f, -0.05735724f, 0.03102116f, -0.21278971f, -0.22819421f, 
    -0.01333719f, 0.01518911f, 0.07800077f, 0.02370077f, 0.36253977f, -0.28924370f, -0.27696848f, 0.14776312f, 
    0.30239335f, -0.13276014f, -0.21763979f, 0.14592242f, -0.49771681f, 0.51274633f, -0.74848992f, 0.31162062f, 
    -0.00468798f, -0.16536364f, 0.05576789f, -0.14924335f, -0.09447613f, -0.10431261f, -0.02272875f, -0.08679912f, 
    -0.05870396f, -0.16101891f, -0.24873902f, 0.21161801f, -0.09854393f, 0.14908803f, -0.11040907f, -0.38670641f, 
    -0.19037481f, -0.24270111f, -1.16277170f, 0.93906665f, -0.05412250f, -0.22278073f, -0.10944580f, 0.01790069f, 
    0.75465888f, -0.14466582f, 0.11756039f, 0.33086774f, -0.24795045f, 0.12517230f, 0.11132346f, -0.31622142f, 
    0.02978016f, 0.03360495f, 0.09646827f, -0.00976566f, -0.11317065f, -0.13170210f, -0.03500176f, -0.01964370f, 
    -0.06482834f, -0.07729034f, -0.04989456f, -0.07408666f, -0.19304889f, 0.51557070f, -0.04159514f, -0.42221960f, 
    -0.11693615f, -0.07387828f, 0.57055503f, 0.31787893f, -0.55473471f, -0.16220522f, -0.24642591f, -0.15983962f, 
    -0.19788790f, 0.11810508f, 0.08063176f, 0.15410991f, -0.08010070f, 0.08112085f, -0.02878905f, -0.01971818f, 
    0.02107500f, -0.15979880f, 0.04384540f, -0.51502043f, 0.26749152f, 0.13653238f, -0.36756358f, -0.02561957f, 
    0.17184238f, 0.27514234f, 0.14111038f, 0.15813829f, 0.39198852f, -0.21727543f, -0.35854253f, -0.32965776f, 
    -0.35889879f, -0.50079584f, -0.38425249f, -0.03827566f, -0.04593421f, -0.18950503f, -0.37999767f, -0.21050777f, 
    -0.05267437f, -0.34941554f, -0.13691704f, 0.07001323f, -0.29340115f, 0.44012573f, -0.37243962f, -0.08417720f, 
    0.08320840f, -0.20711160f, 0.74381119f, 0.73871648f, 0.51577985f, 0.47463039f, 0.07203533f, -0.05354400f, 
    0.00138310f, -0.14670788f, -0.13772118f, -0.16310692f, 0.08624685f, -0.08770683f, -0.08933711f, -0.12706453f, 
    0.08762828f, -0.31059796f, -0.19575539f, -0.30014288f, 0.00859090f, 0.12628704f, -0.23681784f, -0.11693197f, 
    0.02119684f, -0.10768312f, -0.19719687f, -0.53575790f, -0.42939773f, 0.11289252f, 0.16413245f, -0.27627796f, 
    0.00238862f, -0.05258425f, 0.19291511f, 0.46495602f, 0.05992810f, 0.04111812f, -0.32785657f, 0.06040733f, 
    0.26813918f, 0.28318664f, 0.10782997f, 0.35613889f, -0.07889503f, -0.17241606f, -0.08605955f, -0.71620321f, 
    -0.66025209f, 0.04813265f, 0.09044077f, -0.21403004f, 0.07595718f, -0.09085687f, 0.32920724f, -0.42628169f, 
    0.11049239f, 0.18222955f, 0.36644638f, -0.14541104f, -0.09443478f, -0.21159711f, -0.65139729f, 0.10461430f, 
    0.03172144f, 0.07433181f, -0.58783650f, 0.10108342f, -0.18663917f, -0.08782557f, 0.03423163f, -0.08928244f, 
    0.61613715f, 0.43788648f, 0.62428397f, -0.33807170f, 0.64164591f, 0.10866395f, -0.66694343f, 0.40224141f, 
    0.11505987f, 0.22893496f, -0.00736636f, 0.11269745f, -0.20050949f, 0.18072563f, 0.02385038f, 0.27970511f, 
    -0.05684586f, -0.35297015f, 0.00365789f, -0.17065720f, -0.00791244f, 0.00447107f, 0.03197642f, 0.11343627f, 
    0.15527225f, -0.20360243f, -0.51933318f, 0.25579956f, 0.49437928f, -0.21570605f, 0.13962567f, -0.26462388f, 
    0.41199040f, 0.04921701f, -0.06826814f, 0.04550952f, -0.19319853f, -0.10929857f, -0.31847209f, -0.22722572f, 
    0.47742581f, 0.35520515f, -0.12612151f, -0.15061808f, 0.00077300f, 0.06529187f, 0.33966869f, 0.46620476f, 
    0.26906535f, 0.19606747f, 0.31366861f, 0.26468486f, 0.30659497f, 0.45528126f, 0.21279727f, -0.45445213f, 
    0.19957049f, -0.56564444f, -0.23592573f, 0.36074892f, 0.33641690f, 0.16637725f, 0.01314836f, 0.21590661f, 
    -0.32151914f, -0.20893225f, -0.35171220f, -0.02067547f, -0.00927716f, -0.36883903f, 0.00843993f, 0.13510293f, 
    0.20016837f, 0.02262004f, 0.24843286f, 0.12496560f, 0.82258320f, -0.09088682f, 0.30259055f, -0.19767989f, 
    0.30112392f, -0.08233164f, -0.20346226f, 0.13221028f, -0.09184206f, 0.25573370f, -0.09076454f, 0.07706586f, 
    0.14720087f, 0.41770869f, -0.37001806f, -0.43708786f, 0.00700476f, -0.20989828f, 0.18493846f, -0.15566565f, 
    -0.18625189f, -0.17204711f, 0.37041244f, -0.02839055f, 0.75593346f, 0.61409670f, -0.74851567f, -0.53630167f, 
    -0.76978511f, 0.30818558f, -0.18953671f, 0.11779130f, 0.13180076f, -0.11127140f, -0.04812599f, 0.37712497f, 
    0.25580549f, 0.17100255f, -0.20719226f, 0.08302445f, -0.05661090f, 0.15790635f, 0.03229112f, 0.16814364f, 
    0.11239100f, 0.03644009f, 0.17795493f, -0.27581409f, 0.23194164f, 0.10707737f, -0.39633423f, -0.67001516f, 
    -0.50622785f, -0.51490718f, 0.32105345f, 0.80044633f, 0.28171545f, -0.09891503f, 0.22506893f, 0.09436972f, 
    -0.31626427f, -0.15297641f, -0.14443405f, -0.18527311f, -0.39182267f, 0.02899897f, 0.07408271f, 0.08172590f, 
    -0.21315053f, -0.11882443f, -0.02828220f, -0.06311299f, -0.17523493f, 0.05663910f, -0.76317203f, -0.50212574f, 
    0.50230706f, 0.77796739f, -0.22580709f, 0.43632510f, 0.34270963f, 0.10606002f, 0.21951735f, -0.30308101f, 
    -0.15856235f, -0.00032552f, -0.11107806f, 0.57674634f, 0.15107036f, -0.24514855f, 0.20552377f, -0.20872022f, 
    -0.30557671f, 0.16661292f, -0.25551224f, -0.06623375f, 0.12545741f, -0.19090377f, -0.13715029f, -0.07970173f, 
    -0.47587925f, -0.54926586f, -0.38461721f, -0.39951730f, -0.22208181f, 0.45468140f, 0.34132898f, -0.02114061f, 
    0.29847139f, 0.22999360f, 0.07809648f, -0.18066503f, -0.07192189f, -0.16214254f, 0.06850638f, -0.16229609f, 
    0.21138012f, -0.05210858f, 0.15067504f, -0.22754893f, 0.22778836f, 0.31926870f, 0.25793514f, -0.03272970f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.13026108f, 0.02070310f, 0.10954417f, 0.06405008f, 0.09648738f, 0.09464418f, -0.03678874f, -0.07810566f, 
    0.09994764f, -0.06647589f, -0.00297205f, 0.26623929f, 0.14893760f, 0.00521033f, 0.14905505f, -0.02552345f, 
    0.06963073f, 0.04213164f, 0.09709143f, 0.07213116f, -0.00996605f, 0.14870113f, 0.25600046f, 0.04522365f, 
    0.02555975f, 0.09580215f, 0.12609679f, 0.30159196f, -0.03197237f, 0.16653627f, 0.17613059f, -0.09473926f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.05963216f, 0.02518253f, 0.24490552f, 0.13682798f, 0.07764873f, -0.17606770f, 0.05929184f, 0.00559013f, 
    0.12039291f, -0.00371752f, 0.07001705f, 0.22372867f, -0.03636581f, -0.04159119f, 0.19611934f, 0.27953663f, 
    0.12057568f, -0.27328163f, -0.11513344f, -0.02839001f, -0.02022099f, 0.00928313f, 0.13835572f, 0.13405314f, 
    -0.06527907f, -0.05619691f, 0.11730239f, 0.53490984f, 0.03900931f, -0.11674534f, -0.00507675f, 0.02258858f, 
    -0.05819456f, 0.11094242f, 0.00980805f, 0.09787710f, -0.15913182f, 0.23849443f, 0.12899101f, -0.06061884f, 
    -0.11370005f, -0.00479832f, 0.10904250f, 0.04423695f, -0.04542992f, 0.16272779f, -0.13957940f, -0.11363698f, 
    -0.09931941f, 0.30510804f, 0.12661111f, -0.34298155f, -0.04646051f, -0.04402569f, -0.01485288f, 0.15918258f, 
    -0.06058078f, -0.02793084f, 0.07702920f, -0.32504359f, -0.21669298f, 0.03311971f, 0.33214423f, -0.02140296f, 
    0.14685696f, 0.03441902f, -0.01399300f, 0.12171628f, 0.01082225f, 0.05874741f, -0.04414963f, 0.15673606f, 
    0.14284509f, -0.03858628f, 0.18910149f, 0.02744612f, 0.03810728f, 0.09412713f, 0.11944190f, -0.10025466f, 
    -0.09918892f, -0.05887480f, 0.18177469f, 0.23458102f, -0.21978965f, -0.28230077f, -0.00759893f, -0.06131884f, 
    0.15355307f, 0.05153203f, 0.04394442f, -0.02200359f, -0.01789100f, 0.04757642f, -0.02471013f, 0.23728524f, 
    0.00485135f, 0.00429132f, 0.25318187f, 0.34229514f, -0.00167251f, 0.09060439f, -0.00400515f, -0.06748723f, 
    0.09610771f, 0.06706294f, 0.08133178f, 0.26151636f, -0.03818481f, 0.14354022f, -0.19575028f, 0.12712839f, 
    0.23091874f, 0.06128607f, 0.00357514f, 0.03762852f, -0.11909412f, 0.00533715f, -0.04266516f, -0.03338407f, 
    0.14393725f, 0.17906773f, 0.08701246f, 0.28563851f, 0.11581752f, -0.13405980f, 0.03649519f, 0.04567666f, 
    -0.08986557f, 0.02315435f, -0.14721280f, 0.06054396f, -0.11207096f, -0.03284930f, -0.01249824f, 0.28375545f, 
    0.07937204f, -0.06593778f, 0.02463688f, -0.01403094f, 0.02632201f, 0.07804912f, 0.10745946f, 0.17078282f, 
    0.13646510f, -0.12615387f, -0.01185867f, -0.10801493f, 0.04872644f, -0.12870505f, -0.10770392f, -0.12962221f, 
    -0.13951810f, 0.10288949f, 0.00782627f, 0.05955062f, -0.22278222f, -0.17706303f, -0.09022793f, 0.04302072f, 
    0.05770363f, -0.05763011f, 0.06373262f, 0.12465100f, -0.02024751f, 0.13486877f, -0.04874222f, -0.01712043f, 
    0.21554565f, -0.24090277f, -0.08507071f, 0.11737871f, 0.15951572f, 0.14470613f, -0.01934806f, 0.12997235f, 
    -0.09073714f, -0.03260212f, 0.16716059f, -0.18985054f, -0.36964598f, 0.05741075f, -0.01078373f, -0.08090438f, 
    0.16638270f, 0.07819967f, 0.04863871f, -0.08585682f, 0.06760395f, -0.16490205f, 0.03821553f, -0.07342003f, 
    0.27390271f, 0.24256682f, 0.13986415f, 0.01839855f, 0.07612403f, 0.05005088f, -0.16358413f, 0.06165598f, 
    -0.05853116f, 0.07245521f, 0.13526602f, 0.14440513f, 0.07489246f, -0.05193729f, 0.09016419f, -0.10453892f, 
    0.00983136f, 0.01087967f, 0.02426519f, 0.02283717f, -0.01292729f, 0.11020153f, 0.03721128f, -0.11584935f, 
    -0.51856983f, 0.05770516f, 0.08135726f, 0.06955504f, 0.04123596f, -0.05675495f, -0.03151022f, -0.16965590f, 
    0.02686254f, 0.04174847f, 0.02133913f, 0.01324662f, 0.23638497f, -0.11548540f, -0.12849000f, 0.17066087f, 
    0.01288356f, 0.01339013f, 0.04819623f, -0.01924770f, -0.16531949f, 0.01494503f, 0.02078251f, -0.10255542f, 
    0.28956109f, 0.06208057f, 0.11548631f, -0.03565582f, -0.00878478f, 0.01251569f, 0.11222545f, -0.16262972f, 
    -0.03386942f, 0.03428916f, -0.20354371f, -0.06669308f, -0.08484282f, 0.28630021f, -0.02886712f, -0.07483871f, 
    -0.06050666f, 0.07224788f, -0.09991685f, -0.41569018f, -0.05354764f, 0.06600147f, -0.12857579f, 0.13140161f, 
    0.19735937f, -0.03496515f, -0.06954014f, 0.30008972f, 0.05784612f, -0.00865822f, -0.13627699f, 0.08415487f, 
    0.14572263f, 0.12898487f, 0.22244011f, 0.01075942f, -0.35362849f, -0.05850111f, -0.04554379f, -0.15273570f, 
    0.14386560f, 0.08621037f, -0.08390597f, 0.08973336f, -0.01233827f, -0.10916789f, 0.04798416f, 0.01980917f, 
    -0.06082195f, 0.10218087f, 0.04904374f, 0.21016173f, 0.03011054f, -0.02246639f, -0.14719687f, -0.10216273f, 
    0.03509867f, -0.03663956f, -0.14715222f, 0.00251606f, -0.18478426f, 0.04245716f, -0.13245472f, -0.07399812f, 
    0.23172764f, 0.06079723f, 0.26837122f, 0.09423301f, 0.15189157f, 0.20478405f, -0.27968800f, 0.09751947f, 
    -0.07149916f, -0.10022213f, 0.15078005f, 0.07189885f, -0.09249280f, -0.05981139f, 0.08013535f, -0.00840593f, 
    0.00246947f, -0.37244940f, 0.13772450f, 0.03564160f, 0.04321671f, 0.11564446f, 0.03217834f, -0.03080242f, 
    0.00676383f, -0.00305491f, -0.01678432f, 0.08412321f, -0.11528589f, 0.03555511f, 0.02611013f, -0.12150382f, 
    0.07598177f, 0.20923047f, -0.25496051f, 0.13863142f, -0.15811756f, -0.05602207f, 0.01135038f, -0.03548755f, 
    0.00627709f, 0.02440477f, -0.05757713f, 0.04219574f, -0.25959072f, 0.17871074f, -0.23378100f, 0.06920855f, 
    -0.02949434f, 0.09647395f, -0.09170873f, 0.00426985f, 0.02056540f, -0.06340194f, 0.04214844f, 0.01869345f, 
    -0.54432923f, -0.09995279f, 0.20968440f, -0.25350294f, 0.13220173f, 0.05647951f, 0.01867059f, -0.01756623f, 
    -0.15616962f, 0.00248617f, -0.08662274f, -0.09375116f, -0.24738650f, -0.02753344f, -0.02306687f, 0.02181925f, 
    0.13671601f, -0.02327143f, 0.08657138f, 0.04928552f, 0.03982206f, 0.08774433f, -0.19486766f, 0.05220054f, 
    -0.13069543f, 0.08468373f, 0.25961784f, 0.08381768f, -0.04194547f, -0.08497774f, 0.07543834f, 0.04181781f, 
    -0.04032315f, 0.01067558f, 0.00604480f, 0.03724723f, 0.10902474f, 0.12954076f, 0.19301209f, 0.03684040f, 
    0.04001345f, -0.09389044f, -0.14889237f, 0.12652931f, 0.06849568f, -0.03869325f, -0.02897814f, 0.18138877f, 
    0.00343222f, 0.12579419f, 0.06477185f, 0.19188066f, -0.01494463f, 0.01470605f, -0.02934107f, 0.11835913f, 
    0.20231320f, 0.01695587f, -0.02201750f, -0.00894619f, -0.07042591f, -0.02449921f, 0.13382131f, -0.01258406f, 
    0.03278001f, -0.05791351f, -0.06079909f, 0.00792202f, 0.03168841f, -0.12031478f, -0.03041768f, 0.11334396f, 
    -0.20282336f, 0.20301490f, 0.05044476f, -0.02123554f, -0.04659814f, -0.12240949f, 0.03974374f, 0.00279963f, 
    0.01371321f, -0.00533389f, -0.00074666f, -0.08940794f, -0.22312477f, 0.05977188f, -0.02860685f, 0.14007293f, 
    0.07490044f, 0.00127541f, 0.03115117f, 0.07623239f, 0.04644218f, 0.14771263f, -0.10418071f, -0.02757300f, 
    -0.18644005f, -0.27895316f, -0.17696205f, 0.15103877f, 0.02875980f, 0.04365421f, 0.00169442f, 0.03356615f, 
    -0.00934630f, 0.03285354f, -0.10082627f, 0.08459962f, 0.26937887f, 0.11324161f, 0.14698461f, -0.06697423f, 
    0.11071717f, -0.11202516f, -0.03416051f, 0.05583359f, 0.02464159f, 0.08391318f, 0.01222318f, -0.00666130f, 
    -0.32593253f, -0.18071853f, -0.14745119f, 0.23404385f, 0.07326863f, -0.03135413f, -0.08329584f, -0.05268786f, 
    0.02588880f, -0.09853449f, 0.03381620f, -0.07481325f, -0.16429034f, -0.11886131f, 0.06934343f, -0.15493657f, 
    -0.20849691f, 0.00182726f, 0.02379212f, 0.02427938f, 0.07346502f, -0.05451594f, 0.09380112f, 0.03219049f, 
    0.00886183f, 0.12527904f, 0.10817917f, 0.14251468f, 0.01358095f, 0.08873726f, -0.04516499f, 0.01359563f, 
    -0.04141665f, 0.16151536f, -0.14444202f, 0.00310142f, 0.08399570f, 0.26621494f, 0.15141347f, -0.10020027f, 
    0.03263529f, -0.05509809f, -0.05494538f, 0.15747619f, 0.02277718f, 0.02175066f, -0.04274321f, 0.03655638f, 
    0.15733033f, 0.19058445f, 0.09578522f, 0.08445168f, -0.09691800f, -0.10953827f, 0.06789706f, 0.09313850f, 
    0.01468092f, 0.01849430f, 0.18421863f, 0.04099626f, 0.12706615f, 0.11932812f, 0.09091125f, 0.05357799f, 
    -0.01535923f, -0.08340359f, 0.11136423f, 0.06623729f, -0.05104651f, 0.04734441f, 0.04072989f, 0.04861436f, 
    0.13417257f, 0.26862013f, 0.05238945f, 0.20521280f, -0.08594957f, 0.06368058f, 0.03277503f, 0.03443297f, 
    -0.05812626f, 0.05143695f, 0.07140997f, 0.01845112f, -0.05041191f, 0.23145398f, 0.18038861f, 0.05718267f, 
    0.11135554f, 0.02627340f, 0.04602559f, 0.12521701f, 0.01248118f, -0.11454465f, 0.09253626f, 0.02319527f, 
    -0.19650912f, -0.11219370f, -0.07781825f, -0.00149004f, 0.04459316f, -0.10752761f, 0.07249910f, -0.12075839f, 
    -0.03065385f, 0.07553114f, 0.10875058f, 0.05990142f, -0.17605864f, 0.04015018f, 0.16020229f, 0.29135770f, 
    -0.00842306f, 0.15170029f, 0.08172841f, -0.00801713f, -0.05643626f, 0.15049112f, 0.12162688f, -0.02487245f, 
    0.40757573f, 0.31596425f, 0.26121479f, -0.06731038f, 0.07739855f, 0.09376737f, -0.05014129f, 0.12978873f, 
    0.10307313f, 0.11951759f, -0.05261654f, 0.01995137f, 0.33377472f, -0.06231925f, 0.24347246f, 0.15963075f, 
    0.14252310f, 0.10899206f, 0.12117533f, 0.07424647f, 0.02283047f, -0.00425787f, 0.04283213f, 0.02081365f, 
    0.43773621f, 0.16359916f, -0.01874379f, -0.09195511f, 0.03476096f, 0.05388499f, 0.07391909f, -0.00755086f, 
    -0.04350332f, 0.13204916f, 0.18144925f, -0.00290328f, -0.00452822f, 0.27894545f, 0.03251358f, -0.04272106f, 
    0.11031579f, -0.01217616f, -0.07424908f, -0.07390044f, -0.01493574f, 0.09343610f, 0.00510684f, -0.10547438f, 
    0.09139993f, 0.11582140f, 0.00982494f, 0.06671950f, -0.05288325f, -0.08147569f, -0.09041020f, -0.01844503f, 
    0.01209318f, -0.02690050f, 0.00847452f, -0.05368133f, 0.06843166f, 0.04049945f, 0.29827395f, -0.00760914f, 
    0.03321379f, 0.06871099f, 0.01526434f, 0.04206128f, -0.08692438f, 0.06911075f, 0.07430833f, 0.13131954f, 
    0.17174034f, -0.31874093f, -0.30842203f, -0.09879434f, -0.08153941f, 0.05524939f, -0.10552916f, -0.16708328f, 
    0.00350741f, 0.00625310f, -0.00729750f, -0.07974573f, 0.07245073f, -0.01494904f, -0.08009278f, 0.09041274f, 
    0.09687380f, 0.08873834f, -0.07246388f, 0.06592152f, -0.09246889f, 0.08208928f, -0.03877353f, 0.05004868f, 
    -0.29387015f, -0.26157057f, -0.04196747f, 0.05974219f, -0.02819610f, 0.03460009f, -0.11985558f, -0.04437858f, 
    -0.06773544f, 0.00141088f, 0.04321805f, -0.03240253f, -0.04591957f, 0.08220021f, -0.00477419f, -0.31820872f, 
    0.09660194f, 0.05873421f, 0.08561271f, -0.00417963f, 0.01934097f, -0.06937636f, 0.20089209f, -0.12319716f, 
    0.06163365f, 0.04528626f, 0.00087033f, -0.19210863f, -0.01651558f, 0.06881876f, -0.02438819f, 0.15133443f, 
    0.04013764f, 0.13299118f, -0.03167300f, -0.06967558f, -0.00978593f, 0.17344314f, 0.19447136f, 0.11488065f, 
    -0.03709476f, 0.03669636f, 0.08875752f, 0.08304331f, -0.05715493f, 0.07145779f, 0.07589200f, 0.01886661f, 
    -0.02396672f, 0.05322295f, 0.07114613f, 0.10296176f, 0.10608667f, -0.11940150f, 0.05697413f, 0.04111028f, 
    0.08990884f, -0.04941880f, -0.03541241f, 0.06903984f, 0.15186486f, 0.19917765f, 0.26585147f, 0.09259658f, 
    0.02446616f, 0.16371268f, 0.13945512f, 0.10357816f, 0.01729533f, 0.04055505f, 0.13273880f, 0.07027385f, 
    -0.01982938f, -0.03493632f, -0.01382401f, -0.06497486f, 0.00990739f, -0.04289460f, 0.02604936f, -0.04657498f, 
    0.03283880f, 0.02542191f, 0.02370062f, 0.00514598f, -0.04642065f, -0.00718980f, -0.02067127f, -0.01717564f, 
    0.02693682f, -0.05195804f, 0.01578868f, -0.00121150f, 0.02267542f, 0.02472906f, -0.00473331f, -0.04894576f, 
    -0.05186001f, -0.04142004f, -0.01442399f, 0.00952974f, 0.01875160f, 0.03537783f, 0.00894876f, -0.04429902f, 
    -0.02763142f, 0.02202000f, -0.01547005f, 0.02861352f, 0.02738846f, -0.05572071f, 0.00849704f, 0.02162217f, 
    0.03035241f, -0.04267248f, 0.00622073f, -0.03629553f, -0.01769472f, -0.02735809f, -0.01179053f, 0.02256904f, 
    0.04342897f, -0.02429549f, 0.03382094f, 0.00193962f, 0.01461185f, -0.05784538f, -0.00661451f, 0.02480215f, 
    0.03705699f, 0.02891729f, -0.00943842f, 0.00026666f, -0.02282047f, 0.01374262f, -0.03727499f, -0.04474491f, 
    -0.00634640f, 0.01143914f, -0.01998555f, 0.03366075f, 0.03762319f, 0.01492743f, 0.01965827f, 0.00626455f, 
    -0.05433952f, -0.01443486f, 0.02345051f, 0.01247769f, 0.02808711f, -0.04894812f, 0.04058944f, -0.02447358f, 
    -0.01555035f, 0.01335300f, -0.04122290f, 0.03293158f, 0.02876848f, -0.00174862f, -0.01367912f, -0.03444734f, 
    -0.05387443f, -0.00882022f, -0.03458211f, 0.01630997f, -0.05633953f, -0.01171460f, -0.01488714f, 0.02452869f, 
    0.00473118f, -0.02371292f, 0.01301657f, -0.01788089f, 0.01231208f, 0.00114524f, -0.05847350f, -0.00709523f, 
    0.02761386f, -0.05150902f, -0.01531488f, -0.01978077f, -0.02369136f, 0.03941720f, 0.00457856f, 0.02359360f, 
    -0.03011503f, -0.05542482f, -0.00231916f, 0.02465121f, 0.00556445f, -0.00175881f, -0.03954588f, 0.00476075f, 
    0.00257733f, -0.00390714f, -0.01789809f, 0.00745004f, -0.00919582f, -0.00119872f, -0.03516436f, -0.04078226f, 
    0.03113455f, 0.03831336f, -0.04119897f, -0.02119934f, -0.02573613f, -0.03030329f, -0.01643320f, -0.02948065f, 
    0.00959628f, 0.02217919f, -0.01257164f, 0.03167427f, -0.00113326f, -0.05272434f, 0.00403293f, -0.05912685f, 
    -0.02678941f, 0.01341988f, -0.02457483f, -0.06236850f, -0.00301785f, -0.04194903f, -0.02916227f, -0.00470131f, 
    0.01799051f, -0.02969310f, -0.01152339f, 0.04100327f, 0.02440888f, -0.04118761f, -0.00796918f, 0.02265986f, 
    -0.00451358f, -0.00642078f, -0.02521074f, -0.04757128f, 0.01270673f, -0.02539771f, 0.03398181f, -0.01493814f, 
    0.02254418f, 0.02949656f, -0.03108277f, 0.03113050f, 0.01758578f, 0.00321758f, 0.00554290f, -0.01926353f, 
    -0.02848508f, -0.02775637f, 0.02284846f, 0.02490128f, -0.04112400f, 0.01979505f, 0.01221392f, -0.01696771f, 
    -0.02033763f, -0.04633309f, -0.02314387f, -0.02104315f, -0.04101570f, -0.01063761f, -0.04621638f, 0.01706001f, 
    -0.00475876f, 0.00895640f, 0.01451095f, 0.01743022f, -0.03539114f, 0.03222967f, 0.01567379f, -0.02372454f, 
    -0.00775274f, -0.01180837f, 0.03478835f, -0.03976874f, -0.02161853f, -0.02884525f, -0.02692445f, -0.01346706f, 
    0.03762144f, -0.05640608f, 0.02359026f, -0.03481628f, 0.04281993f, -0.00503266f, -0.05767519f, -0.01092589f, 
    0.03327258f, -0.06254757f, -0.02343707f, 0.01253344f, -0.06369011f, 0.01302168f, 0.02140815f, -0.01676946f, 
    0.00503576f, 0.03706026f, -0.02526245f, -0.01075067f, 0.03912362f, -0.02364565f, 0.03781150f, 0.03018486f, 
    -0.00350191f, 0.03825391f, -0.03990863f, 0.02790482f, -0.00315235f, 0.01795203f, -0.02873521f, -0.03198034f, 
    -0.01327598f, -0.03453103f, -0.00941356f, 0.02359842f, -0.01005927f, 0.00938762f, 0.01240495f, -0.02374202f, 
    0.03621241f, -0.01911590f, -0.03520294f, -0.04683490f, 0.02498996f, -0.01510989f, -0.02447419f, -0.05261509f, 
    0.03299119f, 0.02685163f, -0.06010016f, 0.01578563f, -0.04506143f, 0.03859423f, -0.01706136f, 0.01727609f, 
    0.02992829f, 0.02968985f, -0.04470548f, -0.04445374f, -0.02311403f, 0.03326819f, -0.01106707f, -0.00389420f, 
    0.03897677f, -0.05443840f, 0.01567373f, 0.01100479f, -0.05205071f, 0.03268903f, -0.01375956f, -0.00950010f, 
    0.00999840f, -0.03971248f, 0.03400865f, 0.01186267f, -0.02653974f, 0.03623519f, -0.04051780f, -0.06008851f, 
    0.01063233f, -0.02804331f, -0.05925412f, 0.01859170f, -0.02884378f, 0.02516923f, -0.00362787f, 0.03452601f, 
    -0.06482946f, -0.00733643f, -0.05564992f, -0.01659460f, 0.00564347f, 0.03345773f, 0.01111797f, 0.01284981f, 
    -0.02832192f, -0.04807918f, -0.03898988f, -0.01902507f, 0.02835934f, -0.05559222f, -0.02737907f, -0.05485624f, 
    -0.00279166f, 0.00073208f, -0.01200085f, -0.02558977f, 0.01257036f, 0.03908942f, -0.02967910f, 0.01557736f, 
    -0.00245919f, 0.01948607f, -0.04405586f, 0.02180030f, -0.00229237f, -0.02681255f, 0.00781291f, -0.03501569f, 
    0.01076786f, 0.02161558f, 0.02532814f, -0.01799615f, -0.00961683f, -0.05532002f, -0.04004344f, 0.02921254f, 
    -0.03578257f, 0.04273914f, -0.00348106f, 0.01363698f, -0.01558858f, -0.00972724f, 0.02304474f, -0.00191660f, 
    -0.03131535f, -0.00964795f, -0.02254679f, -0.00739638f, 0.01790551f, -0.04171471f, -0.03174924f, -0.01152321f, 
    -0.02084390f, -0.01178660f, 0.01940842f, 0.01473525f, 0.03719966f, 0.01990920f, -0.05203320f, 0.03045673f, 
    0.04496511f, -0.04120788f, 0.00683441f, -0.02588682f, -0.04078402f, 0.02806356f, 0.00529690f, -0.01029329f, 
    -0.03514706f, -0.00048181f, -0.04341014f, -0.03476854f, -0.04007716f, 0.01309732f, -0.00905330f, -0.02299086f, 
    0.01131165f, 0.02096630f, -0.03892588f, -0.06168445f, 0.00614045f, 0.00645577f, -0.05350224f, -0.02804016f, 
    -0.04071517f, -0.00789025f, 0.02125747f, -0.01374958f, -0.01787059f, 0.03534613f, -0.03518120f, 0.00593376f, 
    0.04366526f, 0.01873378f, -0.00690551f, -0.05090525f, -0.00054406f, 0.04509958f, 0.03012652f, 0.00879042f, 
    -0.01754198f, 0.03591663f, -0.00382833f, 0.00612751f, -0.04620162f, -0.04097276f, 0.01211352f, 0.02933309f, 
    0.01651256f, -0.01503236f, 0.00279580f, -0.02296819f, -0.00816205f, 0.00499143f, -0.03894862f, -0.03255973f, 
    0.04358559f, -0.03811298f, -0.02160023f, -0.05546922f, -0.02343670f, -0.05009336f, 0.03785264f, -0.04269861f, 
    0.03490923f, 0.01206596f, 0.03256430f, 0.01413209f, 0.00072030f, -0.00624770f, 0.03340920f, 0.00821442f, 
    -0.00072285f, -0.04041812f, -0.00278306f, 0.00502872f, 0.00494746f, 0.01834753f, 0.00611517f, 0.02402535f, 
    0.00014036f, -0.00133988f, -0.01054385f, 0.01808679f, -0.03275965f, -0.01227875f, 0.00235960f, -0.01368085f, 
    -0.04080611f, -0.05538780f, -0.01133541f, 0.01373198f, 0.04420830f, -0.01110784f, 0.03841276f, 0.01129707f, 
    0.03100915f, 0.01394451f, -0.01961618f, -0.03031471f, -0.02516899f, 0.00614418f, -0.00424271f, -0.03867276f, 
    -0.03503011f, -0.02048293f, -0.01139072f, -0.04182934f, -0.03099235f, -0.00817402f, -0.00467031f, -0.03458873f, 
    0.00885980f, -0.02499119f, -0.00097108f, 0.02037205f, 0.02205960f, -0.00423710f, -0.00743304f, 0.01248049f, 
    0.03068485f, -0.02454814f, 0.00506789f, 0.02039835f, 0.01170982f, -0.03602640f, -0.01424988f, 0.02180329f, 
    -0.00141339f, -0.04829950f, -0.03550022f, -0.00839148f, -0.05314508f, 0.03756856f, -0.04680337f, 0.02394223f, 
    0.01990270f, 0.00173185f, 0.00015267f, -0.00037965f, -0.01101853f, -0.03349779f, 0.00407922f, 0.00787906f, 
    -0.03767201f, -0.02718827f, -0.02370457f, 0.03446950f, -0.01769854f, 0.02078243f, -0.02282589f, -0.03387318f, 
    -0.04700624f, -0.03850460f, 0.00275759f, -0.01720460f, 0.03992238f, -0.03226386f, 0.02489022f, -0.04949401f, 
    -0.02802934f, 0.03907596f, 0.02476275f, -0.03971479f, -0.03405218f, 0.02919818f, -0.00369453f, 0.02132044f, 
    0.02187329f, -0.04826877f, 0.04283535f, -0.01618221f, 0.04200501f, -0.05127371f, -0.03513853f, 0.00331241f, 
    -0.04504514f, -0.01148789f, -0.04522583f, -0.00182290f, 0.04328526f, 0.02972960f, 0.02841703f, 0.00734643f, 
    -0.05080657f, 0.02162871f, 0.00891390f, -0.02051375f, -0.02897828f, -0.05656863f, -0.02813797f, -0.00058235f, 
    -0.05547119f, -0.05122081f, 0.00317519f, -0.03997131f, 0.00888039f, 0.01474327f, 0.02988843f, 0.01723197f, 
    0.04262599f, -0.02910562f, -0.01771487f, -0.05149087f, 0.00902556f, -0.04858448f, -0.01307850f, 0.03649552f, 
    0.01358543f, -0.02838136f, -0.03479018f, -0.03273949f, -0.02210059f, -0.01779100f, 0.03153342f, -0.00254256f, 
    -0.02929421f, 0.01863563f, -0.03437516f, -0.01566515f, -0.03807427f, -0.03913820f, -0.03725081f, 0.00877168f, 
    0.03937245f, -0.03874115f, 0.01209669f, -0.02274719f, 0.00288149f, -0.05264145f, -0.01634203f, -0.01306148f, 
    0.01511038f, 0.00151634f, -0.04916632f, 0.04331575f, 0.01765063f, -0.03666614f, 0.02212867f, -0.00146817f, 
    -0.03277119f, -0.03385149f, 0.00271989f, -0.01436310f, 0.03647776f, -0.04774814f, -0.01291367f, -0.05071710f, 
    0.00493028f, -0.01189015f, 0.00766266f, -0.04240075f, 0.00220808f, -0.02768212f, -0.03892747f, -0.05622827f, 
    -0.04532604f, -0.02429987f, 0.03872815f, 0.00608542f, -0.02891393f, -0.01415690f, -0.00810845f, 0.01485764f, 
    -0.00589269f, 0.01764235f, -0.03353304f, 0.04270313f, -0.04913541f, -0.00546389f, -0.03449070f, -0.03788261f, 
    -0.00153091f, 0.03112241f, 0.04325008f, 0.01317859f, 0.00399634f, -0.03160292f, -0.03355171f, -0.03388159f, 
    0.01688127f, -0.04678677f, 0.00705481f, -0.02586169f, 0.01935668f, -0.05264957f, 0.01290674f, 0.01492147f, 
    -0.03128844f, -0.02631002f, -0.04645460f, -0.00221443f, 0.01090896f, -0.01774134f, -0.05059006f, -0.03410336f, 
    0.03125698f, 0.03138886f, 0.02239227f, 0.02698024f, 0.04231568f, -0.03343190f, -0.04184263f, -0.03788169f, 
    0.02429733f, 0.04220506f, 0.00217261f, 0.03138030f, 0.03688961f, -0.02877741f, -0.03756474f, -0.03975556f, 
    -0.01842991f, 0.04510912f, 0.00452226f, 0.00105070f, -0.01881338f, 0.01843705f, 0.02423774f, -0.05563493f, 
    -0.01523519f, 0.01890117f, 0.01891742f, 0.03579424f, 0.00844092f, 0.04375101f, -0.04784498f, -0.05007339f, 
    -0.04852586f, 0.01747141f, -0.03394187f, 0.01988020f, -0.05217244f, -0.00478835f, -0.01418601f, 0.01467452f, 
    -0.00356466f, -0.03224534f, 0.04351538f, 0.02833078f, 0.01605866f, -0.05595068f, -0.00800398f, 0.00002176f, 
    -0.04736779f, 0.04150360f, 0.01616084f, -0.02797824f, 0.04010214f, 0.04277676f, -0.01899345f, -0.02178565f, 
    -0.03281850f, 0.03689301f, 0.04160633f, 0.01912988f, 0.02834937f, -0.05277421f, -0.00894913f, -0.01326208f, 
    0.02934114f, 0.03033207f, -0.01402434f, -0.04112478f, -0.02753158f, 0.03765256f, 0.00915274f, 0.02502941f, 
    0.01242377f, -0.02551110f, 0.02736502f, -0.02203068f, -0.03118604f, -0.04507909f, 0.01717412f, -0.04817716f, 
    -0.05230328f, -0.04922586f, -0.05257490f, -0.01818652f, -0.03107477f, 0.01573954f, 0.03100504f, -0.00719381f, 
    0.00454536f, -0.03011720f, 0.03655654f, 0.03676619f, 0.00100418f, -0.01671075f, 0.04409042f, 0.03035663f, 
    -0.02800521f, -0.03602553f, -0.04445564f, -0.02155237f, -0.01022791f, -0.01334840f, -0.00132835f, -0.01489114f, 
    0.02522790f, -0.04933245f, -0.04875226f, -0.00931223f, -0.01063278f, 0.03567640f, -0.01218143f, -0.00651017f, 
    0.46449491f, 0.18309538f, 0.03515615f, -0.18016043f, -0.15054956f, 0.06155046f, -0.01248404f, 0.01822034f, 
    0.00580410f, 0.00630835f, 0.09596121f, 0.03409523f, -0.06349782f, 0.02835002f, -0.11157040f, -0.09277777f, 
    0.09497279f, -0.09377155f, -0.11568307f, -0.00092384f, -0.00619729f, 0.10089421f, 0.01740807f, 0.05086381f, 
    0.09600927f, 0.03146440f, -0.22302520f, -0.06932910f, 0.17243721f, -0.05267623f, 0.10133978f, -0.03876859f, 
    0.02694038f, 0.12019382f, -0.09107289f, 0.01219756f, 0.17930038f, -0.00011046f, -0.29155925f, 0.07492473f, 
    0.16252799f, 0.04904049f, 0.03405750f, -0.06396494f, 0.04494673f, 0.05376107f, -0.16168202f, 0.08107226f, 
    0.35325113f, 0.06495058f, 0.12615471f, -0.07200795f, -0.00289426f, -0.04902005f, -0.02727723f, 0.05390972f, 
    0.04554775f, 0.07324161f, -0.07149970f, -0.06185396f, 0.02249598f, 0.00565072f, -0.09388059f, 0.07084695f, 
    0.08453814f, -0.03555362f, -0.16322875f, -0.10006119f, -0.00773867f, -0.06091304f, -0.03580637f, 0.07753343f, 
    -0.14926709f, -0.17575344f, -0.20543440f, -0.04787942f, 0.12713239f, 0.10587874f, -0.05528492f, -0.10579816f, 
    0.02625195f, 0.00241799f, 0.02298625f, -0.12596236f, 0.45822230f, 0.12785131f, 0.22303486f, -0.09352363f, 
    -0.09230140f, -0.01403748f, -0.01556205f, 0.19782804f, -0.01627591f, 0.03932570f, -0.03313573f, 0.12660743f, 
    -0.43000919f, 0.14631823f, -0.04357984f, 0.06780617f, 0.18282825f, 0.04380003f, -0.06600023f, -0.08319268f, 
    0.04363671f, 0.04317341f, -0.09801870f, 0.06892514f, -0.13109450f, 0.00028426f, 0.13152392f, -0.22045198f, 
    -0.16720355f, -0.23140417f, 0.13413341f, -0.13737623f, 0.01019210f, -0.10784999f, 0.09521262f, -0.00964474f, 
    -0.05973015f, -0.08711398f, -0.24821365f, -0.24886289f, 0.00405845f, -0.05608606f, -0.03253910f, -0.05625114f, 
    -0.00406506f, 0.06525905f, -0.05591257f, -0.05991144f, -0.22572570f, 0.10917576f, -0.05735800f, -0.04639307f, 
    0.11886577f, -0.14271101f, 0.02268493f, -0.00267476f, -0.00618786f, 0.10029084f, 0.04052844f, 0.04984352f, 
    0.02326311f, -0.11232266f, -0.02739927f, 0.12218925f, -0.01185627f, -0.04299700f, -0.08116546f, -0.03632989f, 
    0.06121210f, 0.00237426f, 0.11675071f, -0.02101027f, 0.33276135f, 0.05793454f, -0.01159660f, -0.03887434f, 
    -0.03383398f, -0.07206915f, 0.00858734f, 0.11322673f, 0.10847216f, 0.16234452f, -0.05373041f, 0.06582082f, 
    -0.20580253f, 0.05930373f, -0.03898932f, 0.10463853f, 0.00603360f, 0.12963656f, -0.14759512f, 0.06882372f, 
    -0.00620445f, -0.02332934f, 0.00347419f, -0.01736023f, 0.17333469f, 0.06192673f, 0.29334268f, 0.27459878f, 
    -0.07475173f, -0.05498074f, 0.01023141f, 0.03193215f, -0.03220193f, -0.06803375f, 0.02174368f, -0.02911482f, 
    -0.09442835f, -0.14316860f, -0.07319275f, -0.15212779f, 0.03280408f, 0.19196731f, 0.00427882f, -0.09968776f, 
    -0.04649103f, 0.01781572f, 0.06252842f, -0.04678978f, 0.30099598f, -0.21595606f, -0.08630367f, 0.09951434f, 
    0.01667143f, -0.08226880f, 0.02458868f, -0.01699374f, -0.03516723f, 0.10775468f, -0.03505114f, -0.12916993f, 
    0.07850121f, 0.03142690f, -0.12946895f, 0.11387775f, 0.05970904f, -0.02575778f, -0.07906093f, 0.05303131f, 
    0.00337279f, 0.02517296f, -0.01197194f, -0.06143001f, -0.10563648f, 0.07454787f, -0.07704871f, -0.13449156f, 
    -0.13006051f, -0.10247264f, -0.01034470f, 0.17972352f, -0.03185327f, 0.07233422f, 0.00629119f, -0.06803909f, 
    0.15969321f, -0.01003233f, 0.06353286f, -0.07703122f, -0.04911596f, -0.03476733f, 0.07538258f, 0.02573022f, 
    -0.02433112f, -0.15194811f, -0.03996288f, 0.02773145f, 0.11345199f, 0.18907189f, 0.18672478f, -0.05010038f, 
    -0.06791174f, -0.11013277f, 0.01905947f, 0.11692896f, -0.04875084f, -0.02813266f, 0.05271252f, 0.04996143f, 
    0.06780818f, 0.09044296f, -0.07523397f, -0.09022136f, -0.01801243f, 0.00374958f, 0.04555276f, 0.00290043f, 
    -0.03415768f, 0.05799410f, -0.03519133f, -0.00178345f, 0.13934609f, -0.02700890f, 0.13754855f, 0.16279991f, 
    -0.17338547f, -0.06536315f, 0.05943067f, 0.01885180f, -0.09106867f, -0.06669585f, -0.05873242f, -0.09569236f, 
    -0.29552442f, 0.07821237f, 0.02730617f, 0.04615619f, 0.14907277f, 0.04464110f, 0.04197292f, -0.04052422f, 
    -0.12903972f, -0.10954478f, -0.01169205f, 0.12442371f, -0.11216369f, -0.12707923f, 0.06742834f, 0.00378721f, 
    -0.02200002f, -0.01434222f, 0.09628887f, -0.04473430f, 0.01840182f, -0.05935398f, -0.00108863f, 0.10817906f, 
    0.08784212f, 0.01760178f, 0.04142271f, -0.17741938f, 0.13739571f, 0.13043346f, -0.01282143f, -0.00523861f, 
    -0.02894022f, -0.12025691f, 0.03893314f, -0.02289763f, -0.19914390f, -0.05807702f, 0.01036195f, 0.06167179f, 
    0.05667599f, -0.01346037f, 0.01205501f, 0.02097773f, -0.07659476f, 0.12016401f, -0.11683497f, 0.04210475f, 
    -0.21985030f, 0.06879093f, -0.09738249f, -0.25498304f, 0.08328789f, -0.01710742f, 0.06283530f, -0.07566042f, 
    0.08060757f, 0.00743632f, 0.09400392f, -0.00215292f, 0.21056132f, 0.20933799f, 0.18898427f, 0.19999602f, 
    -0.10454267f, -0.18231514f, 0.00958251f, 0.02594010f, -0.10174381f, -0.03880840f, -0.00194541f, -0.06733814f, 
    0.35249579f, 0.03789015f, 0.01937368f, 0.02413628f, -0.12284214f, -0.03702853f, -0.08330768f, 0.02234680f, 
    0.04137724f, 0.14095236f, -0.06854044f, -0.16857900f, 0.25778687f, 0.03532413f, 0.15785685f, 0.24413209f, 
    -0.07501650f, -0.05256040f, 0.02173959f, -0.08880720f, -0.01848044f, -0.05397702f, 0.05858502f, 0.04083971f, 
    0.08105395f, -0.00431659f, 0.02407734f, -0.06476768f, -0.05985903f, -0.01257375f, 0.02708893f, -0.07111697f, 
    -0.07932240f, -0.03609993f, 0.03858677f, -0.03168830f, 0.12659505f, -0.14111151f, 0.14155145f, 0.01181839f, 
    -0.03686614f, 0.10654610f, 0.09158067f, 0.00132334f, -0.05680856f, -0.09620645f, -0.08542296f, 0.04276310f, 
    -0.14639321f, 0.05230103f, 0.05571077f, -0.02313752f, -0.08482962f, 0.02731635f, -0.04924894f, 0.00865407f, 
    0.24629390f, -0.03744614f, 0.07689005f, 0.03113992f, 0.09296671f, -0.12238576f, 0.00435160f, -0.05078419f, 
    -0.03127106f, 0.04914786f, -0.16011201f, -0.02781281f, 0.07083750f, -0.03980362f, 0.13539083f, 0.08204915f, 
    -0.14853053f, 0.09368975f, -0.13174085f, 0.03792338f, 0.11925548f, -0.02504385f, 0.09165401f, 0.01058334f, 
    -0.04179870f, -0.04354048f, 0.05150932f, 0.15615234f, -0.13939242f, 0.17703633f, -0.05768988f, -0.06756080f, 
    0.02898836f, -0.00577895f, 0.09901546f, -0.04157670f, 0.00157718f, 0.12083904f, 0.07007830f, -0.03332027f, 
    -0.21430202f, 0.02603652f, -0.06475954f, 0.01722350f, 0.03381123f, -0.03655053f, -0.05396144f, 0.08641480f, 
    0.07370690f, 0.09797285f, -0.15181352f, 0.00553062f, 0.29628193f, 0.18012090f, 0.00089353f, 0.00584377f, 
    -0.01338920f, 0.01482354f, -0.06807502f, 0.18302608f, 0.08758005f, -0.03380522f, 0.01651864f, -0.13564073f, 
    -0.19417095f, 0.19973868f, -0.04735644f, -0.11065207f, 0.08020604f, -0.09684265f, -0.11062566f, -0.03339732f, 
    0.04457579f, -0.00163218f, 0.02324767f, -0.07979102f, -0.37178525f, -0.15968104f, 0.25940922f, -0.19673057f, 
    -0.17881626f, -0.02696745f, 0.05636192f, -0.12492985f, 0.04373879f, -0.06269344f, 0.15131016f, 0.04389361f, 
    -0.18438092f, -0.06303485f, 0.11188747f, 0.02267861f, -0.12912966f, 0.00106988f, 0.00028025f, -0.00608063f, 
    0.01042053f, 0.11861187f, -0.05068156f, 0.03035687f, -0.17045075f, -0.05917552f, 0.15010111f, -0.15831470f, 
    -0.00980590f, -0.04197304f, -0.02163664f, 0.10594799f, 0.07926717f, -0.05698054f, -0.03298352f, -0.02083548f, 
    -0.11293042f, 0.11196706f, 0.09465582f, 0.05539611f, -0.07971545f, -0.01352779f, 0.18871814f, 0.07630659f, 
    0.06913853f, 0.01899823f, 0.19417465f, -0.04229535f, -0.03980935f, 0.04713398f, 0.01887386f, 0.04210773f, 
    -0.05891275f, -0.02970692f, 0.05410553f, 0.02581510f, 0.02569074f, -0.01680038f, 0.05092037f, -0.09921391f, 
    0.00958222f, 0.14702931f, 0.01058378f, 0.17999902f, 0.01314487f, -0.06234584f, -0.02486096f, -0.05575527f, 
    0.02984266f, 0.04303279f, 0.06758570f, 0.06988345f, 0.15289128f, 0.15215218f, -0.01111943f, 0.18191770f, 
    0.10610408f, 0.00027984f, 0.06642231f, 0.23402730f, 0.05554498f, 0.00082289f, -0.05410535f, 0.02496858f, 
    -0.20158495f, -0.06344901f, -0.06931704f, 0.00857305f, -0.00043038f, 0.08192763f, -0.00666751f, -0.11396721f, 
    -0.01333184f, 0.04205951f, -0.03974241f, 0.07251827f, -0.04605255f, -0.13779369f, -0.08206012f, 0.16405232f, 
    -0.00528442f, 0.04734124f, 0.00369039f, 0.01890754f, -0.05506782f, -0.02854850f, 0.12331542f, 0.03892851f, 
    0.64561325f, -0.08586291f, 0.13573967f, -0.05720543f, 0.06001195f, 0.09403528f, 0.06898147f, 0.06012443f, 
    0.01891979f, 0.09756260f, 0.01938794f, 0.00799134f, 0.15389183f, 0.03484597f, 0.17339870f, 0.13436449f, 
    0.06663961f, 0.08379535f, 0.05465270f, 0.04595615f, 0.07213461f, 0.01584518f, 0.04492977f, 0.03201218f, 
    0.16939187f, 0.03332997f, -0.14530329f, -0.08315943f, 0.03389669f, -0.04272446f, 0.01901281f, -0.00448624f, 
    0.02943097f, 0.04229700f, 0.24014182f, 0.02663328f, 0.00426417f, 0.04518418f, 0.03654119f, 0.06544728f, 
    0.21222252f, 0.02204451f, 0.09655172f, 0.18645500f, 0.05261869f, -0.04603337f, 0.03515172f, -0.01840050f, 
    0.06404833f, 0.00867367f, -0.03925648f, 0.05048585f, -0.02083407f, -0.04419090f, -0.08818770f, -0.07062452f, 
    0.01065870f, -0.05048877f, -0.20716526f, -0.02230869f, -0.10319888f, 0.13946702f, 0.08117288f, -0.09166051f, 
    -0.03433556f, -0.01361444f, -0.00104055f, 0.06158953f, -0.03333145f, 0.04873196f, -0.06584605f, 0.03507954f, 
    0.28444844f, -0.06712071f, -0.00774652f, -0.09518900f, -0.04192162f, 0.05849152f, -0.06890526f, 0.04707348f, 
    0.09482118f, 0.03458898f, 0.12329898f, -0.07386331f, 0.06138309f, 0.10314506f, -0.04588215f, 0.07702659f, 
    0.08985969f, 0.04807815f, -0.14017381f, -0.01902775f, -0.03503469f, 0.11061101f, 0.17494154f, -0.04830970f, 
    -0.13280284f, 0.01474526f, 0.05869624f, -0.05681706f, -0.07359774f, -0.04287756f, -0.12311603f, -0.02617139f, 
    -0.03591289f, 0.12062606f, -0.15757360f, -0.03893973f, -0.08203907f, -0.05099025f, 0.13991161f, -0.15882786f, 
    -0.01989542f, 0.12133451f, 0.02975672f, -0.01543097f, -0.02654134f, -0.00103505f, 0.06618959f, 0.06100384f, 
    -0.21757093f, -0.04105088f, 0.17716590f, -0.25131664f, -0.04780966f, 0.01702758f, 0.07607240f, -0.04661755f, 
    0.01739006f, 0.03574001f, 0.10714618f, -0.01021235f, -0.11680029f, 0.14421666f, 0.25041890f, 0.05367121f, 
    0.03958363f, 0.04859010f, 0.15312326f, -0.01722161f, -0.10848551f, 0.05162166f, 0.05592450f, 0.03167302f, 
    0.11906667f, 0.17414638f, -0.16656244f, 0.15997821f, 0.05111437f, 0.05809667f, -0.06156454f, 0.14995685f, 
    0.08840945f, 0.00349032f, -0.01311468f, 0.13907249f, 0.03426259f, 0.16166139f, 0.11716910f, 0.18099058f, 
    -0.02349484f, 0.13804492f, 0.05957037f, 0.06030300f, 0.03946188f, 0.01837711f, 0.16279672f, 0.03451929f, 
    -0.03088853f, 0.00305617f, 0.01938697f, -0.04651818f, -0.04393294f, -0.00201900f, -0.00207897f, -0.02683420f, 
    -0.01384471f, 0.02880209f, -0.02200545f, -0.00087453f, -0.03180268f, 0.03947151f, 0.01993059f, -0.03908484f, 
    -0.03807481f, -0.01229558f, -0.04226789f, -0.04586415f, -0.02127957f, 0.00842994f, -0.01662683f, -0.04160987f, 
    0.02276649f, 0.02205895f, -0.04287850f, 0.03002663f, -0.02869927f, 0.02643274f, 0.02960089f, 0.03751360f, 
    0.00287852f, 0.04427700f, -0.04251089f, -0.00117172f, -0.03254501f, 0.02397290f, -0.04555128f, 0.00179979f, 
    -0.04154430f, -0.02193763f, 0.02218995f, -0.04070564f, -0.03858318f, -0.01288590f, -0.01527542f, -0.00840132f, 
    -0.00672333f, 0.03120375f, 0.00797736f, -0.01119551f, 0.02010064f, 0.03063474f, -0.04898691f, -0.01338580f, 
    0.03069560f, 0.01078929f, 0.02340476f, -0.01445202f, 0.01879015f, 0.01653121f, -0.00945374f, 0.02511396f, 
    -0.00368001f, -0.02509537f, -0.02689473f, -0.03681440f, -0.04322108f, 0.00720794f, -0.01617736f, -0.05464574f, 
    0.03860478f, -0.03315131f, 0.00899459f, 0.02793195f, 0.02719213f, 0.01814876f, -0.02222131f, 0.02563117f, 
    0.04254386f, 0.03064943f, -0.02614618f, -0.00053010f, -0.00341284f, -0.02362973f, 0.03570285f, 0.03834497f, 
    -0.02870625f, 0.00341331f, -0.03906960f, 0.03339338f, 0.00782741f, -0.03350412f, -0.03033757f, 0.02861607f, 
    -0.01379822f, -0.03752523f, -0.04582750f, -0.04049772f, -0.01285794f, -0.03754439f, -0.05523448f, 0.04464466f, 
    0.00250534f, -0.01151920f, -0.04125104f, 0.02034677f, -0.05216713f, 0.03231202f, 0.02225231f, 0.03324484f, 
    -0.00815541f, -0.04880016f, -0.05781133f, -0.00832132f, -0.01432636f, 0.03144068f, 0.02974698f, -0.03924164f, 
    -0.03118396f, 0.01590582f, -0.03619923f, -0.02826785f, -0.00778833f, 0.02318740f, 0.01092910f, -0.00327449f, 
    0.00841718f, 0.02089527f, -0.01950125f, -0.00471534f, 0.01091681f, 0.04118488f, 0.01769987f, -0.03319109f, 
    -0.00892707f, 0.03107447f, 0.02928898f, 0.02575106f, 0.01662974f, -0.02225796f, -0.00210604f, 0.02004149f, 
    0.03119508f, 0.00099810f, 0.01104620f, 0.00129021f, 0.00373841f, 0.00959584f, 0.01585982f, 0.02398082f, 
    0.04108805f, 0.04138401f, 0.02619588f, 0.03909130f, -0.02056828f, 0.01608670f, -0.03613736f, -0.01842955f, 
    0.02180422f, 0.03964633f, -0.03608843f, -0.00205713f, 0.04968331f, 0.02581014f, 0.02966843f, -0.03271100f, 
    0.01145608f, 0.03042020f, -0.02659175f, 0.02127833f, 0.02316223f, 0.01031984f, -0.02086444f, 0.02402373f, 
    -0.05622533f, 0.04888828f, -0.05247984f, 0.01528696f, -0.00645667f, -0.03494876f, 0.00352780f, -0.03556696f, 
    -0.04025736f, 0.00579816f, 0.04405794f, -0.03887703f, 0.00603807f, -0.03930812f, -0.00970242f, -0.02016733f, 
    0.04010629f, -0.02695769f, -0.00227135f, 0.02168864f, 0.04554047f, 0.04578799f, 0.00133731f, 0.02137567f, 
    -0.03257272f, -0.05548618f, -0.01675442f, -0.01818789f, 0.00549846f, 0.01512547f, 0.00835618f, -0.04365601f, 
    0.04078116f, -0.00506137f, -0.05763525f, -0.02353355f, -0.04790445f, -0.04373861f, -0.00286791f, 0.03907898f, 
    0.04160175f, -0.03861617f, -0.00516159f, -0.03350358f, -0.00229488f, -0.00901738f, -0.02031477f, 0.00328839f, 
    -0.03649478f, -0.01092249f, -0.04189707f, 0.01782600f, 0.01899729f, 0.00002860f, -0.00612357f, -0.01400622f, 
    -0.01908371f, -0.04546611f, 0.02748511f, 0.02930919f, 0.03793016f, -0.00169032f, -0.00868933f, -0.01740560f, 
    -0.03213857f, -0.00191274f, -0.03813468f, -0.02231228f, -0.02323188f, -0.02828239f, -0.05354720f, -0.01427628f, 
    -0.01934670f, 0.01800619f, -0.01095225f, -0.03393213f, 0.04807169f, 0.04452696f, 0.01461830f, -0.04517658f, 
    -0.02313143f, -0.00503420f, -0.04013614f, 0.02894407f, 0.01835715f, -0.03495471f, 0.04566205f, -0.03401218f, 
    -0.01453499f, -0.00452628f, -0.02196236f, -0.05042678f, -0.05508784f, 0.02168424f, -0.04905662f, -0.00946026f, 
    0.00954448f, -0.01071688f, -0.02856518f, -0.00390306f, -0.03262345f, -0.01719373f, -0.04241992f, -0.02189940f, 
    0.00481813f, -0.04787776f, -0.03531709f, 0.00320910f, 0.01639715f, -0.03280906f, 0.01169629f, 0.05755799f, 
    -0.03639336f, 0.03896206f, 0.02505550f, 0.03033734f, 0.01826423f, 0.02345087f, -0.02484103f, 0.03770878f, 
    0.03645403f, -0.00788572f, -0.01639532f, 0.02364095f, -0.03260953f, 0.00098266f, -0.01466636f, 0.03529247f, 
    -0.05079831f, 0.00615497f, 0.04141426f, -0.00380676f, 0.04293611f, -0.00273480f, 0.02761654f, -0.02473509f, 
    -0.04521384f, 0.02011704f, -0.04757820f, 0.03887687f, 0.03960642f, -0.00897683f, -0.02176059f, -0.04876804f, 
    -0.02515114f, -0.03123815f, 0.03731674f, 0.03250096f, -0.00772366f, -0.02785883f, -0.01407541f, 0.00652855f, 
    0.03121054f, 0.00636021f, -0.01906959f, 0.02841638f, 0.00098926f, -0.01675722f, -0.04137706f, 0.03215126f, 
    -0.05797250f, 0.00152153f, -0.05389301f, -0.02317724f, 0.02845182f, -0.03734616f, 0.01532294f, -0.04844617f, 
    -0.04326082f, -0.04889829f, -0.02345780f, 0.01793198f, -0.04002672f, 0.03361433f, -0.02271926f, 0.03772439f, 
    0.00685893f, -0.03719869f, -0.03705964f, 0.00437366f, 0.02605277f, 0.03799266f, 0.04478105f, 0.02382557f, 
    0.02995850f, 0.00097017f, 0.04635958f, 0.04273534f, 0.03873181f, -0.05582299f, -0.05319319f, -0.03390668f, 
    -0.02718581f, 0.00788184f, 0.00299652f, -0.04519781f, -0.01011388f, -0.01102861f, -0.03389082f, -0.01658498f, 
    -0.04576255f, -0.00518086f, -0.01521655f, 0.03851327f, 0.00289621f, -0.01007592f, 0.03163650f, -0.03075208f, 
    -0.00064271f, -0.04079407f, 0.04339366f, -0.04159943f, -0.00273834f, -0.03609776f, 0.04209239f, -0.03096164f, 
    0.00869005f, -0.03925386f, -0.04717948f, -0.00130071f, -0.03733109f, -0.03330665f, 0.03238869f, -0.02236292f, 
    -0.03876377f, -0.02154543f, 0.03437569f, 0.01129034f, -0.04232782f, 0.03115581f, 0.04322292f, -0.01462031f, 
    0.01556177f, 0.03291790f, 0.00994610f, 0.03551269f, 0.02270539f, 0.02042449f, -0.04948161f, -0.01667365f, 
    0.04496166f, -0.02327270f, 0.03652418f, 0.02604238f, 0.00128599f, 0.02909973f, -0.04215257f, -0.01684445f, 
    -0.02628818f, -0.02609341f, 0.02264074f, 0.04444585f, -0.02952553f, -0.04350730f, 0.01612572f, -0.03614196f, 
    0.02300724f, 0.01074554f, -0.05523909f, 0.03221427f, -0.03135284f, 0.00233768f, -0.03663865f, -0.00738764f, 
    -0.00703119f, -0.01063596f, -0.03173844f, -0.01110983f, -0.04497069f, -0.00655319f, -0.01100489f, 0.00807223f, 
    0.01655000f, -0.00599323f, 0.04216415f, -0.04348043f, -0.02510743f, 0.03734277f, -0.04461529f, -0.05587751f, 
    -0.02849298f, -0.02746089f, 0.02026003f, -0.04689307f, -0.01325193f, 0.01017231f, 0.00604999f, -0.00889602f, 
    0.03609807f, -0.01401333f, -0.04067420f, -0.01192840f, 0.02035622f, -0.00189326f, -0.00639002f, 0.03136238f, 
    -0.01176244f, -0.00534836f, -0.03327998f, -0.03389356f, -0.03112937f, 0.02443594f, -0.02870148f, 0.04401632f, 
    -0.00383430f, -0.03171231f, 0.03504772f, -0.04701286f, -0.00263912f, 0.01585612f, 0.02757611f, -0.02754554f, 
    -0.00945724f, -0.01782377f, -0.03715910f, 0.03606419f, -0.01596581f, -0.05457900f, 0.04110499f, 0.03432234f, 
    -0.00579932f, 0.01785655f, 0.03118370f, 0.02496435f, -0.04301451f, 0.02606434f, -0.04768386f, 0.03467817f, 
    -0.00908604f, -0.03629297f, 0.00993339f, 0.01547455f, 0.00821564f, 0.02391598f, 0.03095307f, 0.02635451f, 
    0.03533328f, -0.00084684f, 0.01608002f, -0.04315377f, -0.02577399f, -0.03977948f, 0.00487476f, -0.01578418f, 
    -0.04915525f, -0.04525222f, 0.03790042f, -0.00898526f, -0.05361919f, -0.02289089f, 0.00205270f, -0.04926613f, 
    -0.05271382f, -0.01301082f, -0.00641966f, 0.00124080f, -0.03336639f, 0.01089632f, -0.03258025f, -0.03946902f, 
    -0.00704501f, -0.03784639f, 0.00534567f, -0.03437666f, -0.00232778f, 0.00591423f, 0.00367906f, -0.00717265f, 
    -0.03020270f, 0.00240417f, -0.00667719f, 0.01394451f, -0.01206073f, -0.02722806f, 0.02174522f, 0.01561355f, 
    0.01960170f, -0.00150346f, -0.03044493f, -0.02013091f, 0.00102084f, 0.00178661f, -0.00351445f, -0.05469485f, 
    -0.01351262f, 0.01113446f, -0.03943494f, -0.01497012f, 0.02129671f, -0.05185221f, -0.04090478f, 0.00632317f, 
    0.02622936f, -0.01600457f, -0.04685000f, 0.04209722f, 0.04609680f, -0.04276308f, -0.05038115f, -0.03778508f, 
    -0.00133422f, 0.01462815f, 0.01528384f, -0.00782704f, -0.00835388f, -0.01132743f, -0.05404215f, -0.03451758f, 
    0.00958719f, -0.04968091f, -0.04067494f, -0.01531336f, -0.03357306f, -0.02559663f, -0.03845267f, -0.02863413f, 
    -0.04339905f, -0.05608002f, 0.00499569f, 0.00408913f, -0.04563543f, 0.02749683f, -0.04880114f, -0.03207467f, 
    -0.04984267f, 0.02461700f, -0.05369651f, 0.02406074f, -0.00982086f, -0.04808639f, 0.02892197f, 0.00914931f, 
    0.00301074f, -0.05555055f, -0.00964899f, -0.04638865f, -0.02939965f, 0.02102277f, -0.05590979f, 0.01196940f, 
    -0.03984877f, -0.00710221f, 0.02609206f, 0.04353077f, 0.04304258f, 0.03356538f, -0.03748363f, 0.04427948f, 
    -0.02783729f, 0.01679976f, 0.03966038f, -0.04352654f, -0.01000930f, 0.02020751f, -0.02006586f, -0.00979480f, 
    -0.05475160f, 0.00212890f, -0.05253117f, 0.00783148f, -0.02800418f, -0.04837237f, -0.00289287f, 0.03317111f, 
    0.03340460f, 0.04096384f, -0.03487342f, 0.02883247f, -0.03565355f, -0.05221081f, -0.01673819f, -0.03627431f, 
    0.04274791f, -0.04873518f, -0.01003948f, 0.01860555f, -0.05282350f, -0.03195594f, -0.02595420f, -0.04554750f, 
    0.01076070f, -0.02486292f, -0.03291563f, 0.03548332f, 0.01537187f, -0.02481084f, 0.03112347f, 0.04232777f, 
    0.03772284f, -0.02996702f, -0.03144630f, -0.00577920f, -0.02313280f, -0.01938783f, 0.02509309f, -0.04726490f, 
    -0.03605881f, -0.04645307f, 0.02640915f, 0.01655315f, -0.01835266f, -0.01541108f, -0.03117419f, -0.02379267f, 
    0.01747265f, -0.02063406f, -0.03542781f, -0.01813336f, 0.03129514f, -0.02158248f, -0.00391174f, -0.04198131f, 
    -0.03793078f, -0.02531564f, -0.02726148f, -0.00844540f, -0.02147766f, -0.04262777f, -0.05455988f, 0.02451127f, 
    -0.01272460f, 0.00989901f, -0.04033209f, -0.04978788f, -0.05427795f, -0.04186895f, 0.00286541f, 0.01112165f, 
    0.03577197f, -0.04324176f, -0.03564168f, -0.03347377f, -0.03156356f, -0.03700390f, -0.00830956f, 0.04144982f, 
    -0.01362585f, -0.03318142f, 0.02551243f, 0.01083240f, 0.04568352f, 0.04279136f, -0.03593040f, -0.01399592f, 
    -0.03921476f, 0.04103927f, -0.00007846f, 0.00445672f, 0.02167401f, -0.00130911f, -0.04873873f, -0.00198971f, 
    0.04118430f, -0.04083175f, 0.03860775f, 0.04081002f, 0.04352726f, 0.03491038f, 0.01540617f, 0.01948320f, 
    -0.03121595f, 0.04093233f, -0.01272167f, 0.04363333f, 0.02928768f, 0.01480230f, -0.00121402f, -0.03429147f, 
    0.01202620f, -0.00208461f, 0.01310506f, 0.00977757f, 0.03671422f, 0.02301249f, -0.05552347f, 0.03006865f, 
    0.03866408f, -0.02532906f, 0.02747146f, 0.00694049f, 0.00455842f, -0.01437862f, -0.02404513f, 0.01528992f, 
    0.04219254f, -0.03036575f, -0.04153527f, 0.03766963f, 0.00030071f, -0.00392412f, -0.00907857f, 0.02315390f, 
    -0.02726559f, 0.02848265f, -0.00840652f, -0.01433976f, -0.03635503f, 0.00256593f, -0.02083465f, 0.01542354f, 
    -0.01213425f, 0.01734559f, -0.00315636f, 0.00369929f, -0.04604260f, -0.00034172f, -0.04470235f, -0.01077788f, 
    -0.00511236f, 0.02354736f, -0.00618942f, -0.04388322f, -0.02156749f, -0.03368654f, 0.01657196f, -0.01886149f, 
    -0.00957389f, 0.04725341f, 0.02550199f, 0.00129574f, -0.03709505f, -0.04977856f, -0.01072504f, 0.02214455f, 
    -0.00980514f, -0.01322289f, -0.04240430f, 0.02748204f, -0.05355554f, 0.01727440f, -0.01002242f, -0.00462621f, 
    -0.02155565f, 0.03394243f, 0.03300707f, 0.00683125f, -0.05106226f, -0.03314697f, -0.03151649f, 0.04294406f, 
    0.03786612f, -0.03564194f, 0.03947915f, 0.01206702f, 0.01720013f, -0.00319146f, 0.03710940f, 0.02285070f, 
    -0.03756025f, 0.01867597f, 0.04270822f, -0.03339006f, 0.01712397f, 0.00695488f, -0.02442835f, -0.02629641f, 
    0.03751567f, -0.03934075f, 0.02039950f, -0.05288286f, 0.00844253f, -0.03903865f, 0.00444647f, 0.02809371f, 
    0.04082154f, -0.00390697f, -0.03700775f, 0.02068732f, 0.03288962f, -0.01659330f, -0.01964438f, -0.03805353f, 
    -0.05049298f, 0.01203958f, -0.00595111f, -0.03063869f, 0.00581046f, 0.00244316f, 0.02821621f, -0.04347796f, 
    -0.01898257f, -0.00485464f, 0.01051204f, -0.03088186f, 0.02108319f, 0.00239764f, -0.00102503f, -0.00118909f, 
    -0.01920252f, 0.02279416f, -0.01798869f, 0.02338448f, 0.00495390f, -0.04721112f, -0.04311734f, -0.03259496f, 
    0.03488644f, 0.01643847f, 0.04777367f, -0.00869095f, 0.03225711f, -0.04702937f, -0.05356861f, -0.04025006f, 
    0.03639938f, 0.03255043f, 0.02242632f, 0.01208806f, 0.03353721f, -0.00930203f, 0.02122867f, -0.04662195f, 
    0.03900654f, -0.03006826f, -0.00086550f, -0.02273683f, -0.00841406f, 0.00276450f, -0.00945715f, -0.01230953f, 
    -0.01391790f, 0.00333770f, 0.02066945f, 0.02369797f, -0.02040054f, 0.03948938f, -0.02778517f, -0.02594238f, 
    0.00187274f, 0.01994415f, -0.02671394f, -0.00650899f, -0.02914492f, 0.01332990f, 0.01391615f, 0.02730884f, 
    -0.04077156f, -0.00230821f, 0.00900967f, -0.03792141f, 0.01846533f, -0.01870749f, 0.01932235f, -0.00723675f, 
    -0.00016688f, 0.01355442f, -0.01411087f, -0.01334185f, -0.02696465f, 0.00191639f, -0.01353888f, -0.00764889f, 
    0.02203757f, -0.01898624f, -0.05296220f, 0.01962293f, -0.04275168f, -0.05383938f, -0.01461198f, 0.02334724f, 
    -0.02750116f, -0.04345899f, 0.01787168f, -0.01085266f, -0.05215899f, 0.00092610f, 0.00890987f, -0.04628655f, 
    -0.05198124f, -0.03492184f, 0.02373607f, 0.04041772f, 0.00222541f, -0.02280373f, -0.04188230f, -0.03783109f, 
    -0.04964285f, 0.00467026f, 0.00717054f, -0.00647892f, -0.03871898f, -0.04556534f, -0.05198066f, 0.02281611f, 
    0.04513875f, 0.02917541f, -0.02813431f, 0.01295876f, 0.00926219f, -0.04601854f, -0.04428805f, 0.00257133f, 
    0.02545954f, -0.00174419f, -0.03855813f, 0.04284914f, -0.00681716f, 0.02844005f, 0.03016537f, 0.00440260f, 
    -0.03112717f, -0.01950344f, 0.00642299f, 0.03349674f, 0.00866927f, -0.00536613f, 0.00675514f, -0.03337194f, 
    -0.04906715f, 0.02347235f, 0.03472608f, -0.03393643f, -0.01167026f, 0.02563670f, -0.02748141f, 0.01042914f, 
    0.04191516f, -0.03286867f, -0.01144213f, 0.02979746f, -0.02892824f, 0.03448667f, 0.03204996f, -0.00527250f, 
    0.01670427f, -0.03688235f, -0.02822560f, 0.03168060f, -0.02711975f, 0.00485195f, -0.01504909f, 0.04130913f, 
    -0.04176876f, -0.03330398f, -0.02233126f, -0.01925115f, -0.02025670f, -0.00004835f, -0.00699450f, -0.03657655f, 
    -0.03507465f, -0.00567810f, 0.02724756f, 0.03358629f, -0.02425262f, 0.00337582f, 0.02545564f, 0.00989719f, 
    0.01338397f, -0.04345394f, -0.04337833f, 0.01242135f, 0.03905291f, 0.01906701f, -0.05113585f, -0.04180447f, 
    0.02030503f, -0.04592499f, -0.03560751f, 0.02886334f, 0.01535963f, -0.02697528f, 0.00117461f, -0.03495187f, 
    0.00855952f, 0.02075965f, -0.04422974f, -0.03207746f, -0.03495472f, -0.03532815f, -0.04388753f, 0.04114563f, 
    0.01034199f, -0.04603668f, -0.01687375f, 0.03371248f, -0.03926628f, 0.01377223f, -0.03398483f, -0.02682026f, 
    0.01918203f, -0.03117975f, 0.04545364f, -0.02635130f, 0.00991987f, -0.00546063f, -0.03176686f, -0.01562282f, 
    -0.04347195f, 0.00294795f, -0.03562066f, -0.03631594f, 0.01881944f, 0.02373101f, 0.00621858f, -0.05250222f, 
    0.00417432f, 0.04611437f, 0.02396263f, -0.01701637f, -0.01441574f, 0.03205309f, -0.05096278f, -0.03722080f, 
    0.01678810f, -0.01889799f, 0.00998939f, 0.01967341f, 0.03517825f, -0.04860417f, -0.01386260f, -0.03306255f, 
    -0.00094812f, 0.00080965f, -0.04145805f, -0.00138701f, 0.00670008f, 0.03894440f, 0.02843723f, 0.04027694f, 
    -0.02321060f, -0.03975727f, -0.00938256f, -0.00295168f, 0.04382655f, 0.02176583f, -0.01584940f, -0.02015672f, 
    0.02559954f, 0.00700656f, 0.01582212f, -0.00735145f, 0.04686748f, -0.02538274f, -0.01125247f, -0.05380232f, 
    -0.01858572f, 0.03502718f, -0.02548198f, -0.05088621f, 0.00706918f, 0.01722492f, 0.02692477f, 0.03696274f, 
    -0.03387709f, 0.03016151f, 0.02917021f, -0.05592818f, 0.00625457f, -0.00717533f, -0.03778507f, 0.00590265f, 
    -0.01217939f, 0.02906184f, 0.00042354f, -0.02130512f, -0.05217245f, 0.02046611f, 0.01087369f, -0.03025104f, 
    -0.04327293f, 0.04350967f, 0.04587871f, 0.00498807f, -0.02432171f, -0.03606644f, -0.01663078f, 0.02111264f, 
    -0.05176448f, -0.03398588f, -0.01579761f, -0.02403275f, 0.01200512f, -0.03922148f, -0.00717615f, -0.01583918f, 
    0.20955898f, 0.36011145f, -0.02461123f, -0.05133807f, -0.05301692f, 0.01346711f, 0.00000000f, 0.04530291f, 
    -0.09893828f, -0.03648498f, -0.13113312f, 0.02195559f, 0.30935383f, -0.02157742f, -0.12999605f, -0.09017529f, 
    -0.04130714f, -0.13898626f, -0.24355513f, -0.00185252f, 0.12073430f, 0.02428176f, -0.01576627f, -0.11241381f, 
    0.42390579f, -0.13978276f, -0.19365321f, 0.56296444f, 0.13148631f, 0.04078141f, -0.02507986f, 0.04451609f, 
    0.18461691f, -0.03306606f, -0.08127924f, -0.08869785f, 0.09528329f, 0.10617931f, -0.16950943f, 0.18061800f, 
    0.01747897f, -0.00344194f, 0.01285490f, 0.14257503f, -0.05687385f, 0.06162660f, 0.08931884f, -0.03601721f, 
    -0.10082914f, -0.08254005f, 0.08687366f, -0.07903655f, 0.11468968f, -0.03629844f, 0.03263804f, 0.08840503f, 
    -0.02190794f, -0.05115698f, 0.05641673f, -0.11369333f, 0.02610566f, -0.07177889f, -0.07915100f, -0.03036206f, 
    0.09530498f, 0.04494251f, -0.07662714f, 0.02092365f, 0.03096178f, 0.08797838f, 0.05787439f, 0.18292464f, 
    -0.06496064f, -0.18243912f, -0.23739190f, 0.08715654f, 0.08117751f, 0.01064459f, -0.05824073f, -0.01999287f, 
    -0.11882187f, 0.05137328f, 0.02608707f, 0.24402249f, -0.16066185f, 0.22459258f, 0.12642947f, -0.08826362f, 
    0.04863511f, 0.00977961f, 0.08229415f, -0.11185826f, 0.04430314f, 0.13619629f, -0.12507899f, 0.07361371f, 
    0.19073656f, -0.47938177f, -0.09036890f, 0.11821908f, 0.13201474f, 0.02844689f, 0.04050157f, 0.00335965f, 
    0.10782778f, 0.06380903f, -0.01554043f, 0.09859769f, 0.05915537f, 0.33440199f, 0.02708051f, -0.17242000f, 
    0.07341001f, -0.10875863f, -0.05400648f, 0.05114449f, 0.04832663f, 0.12425338f, -0.14489472f, -0.00419649f, 
    0.07081698f, 0.06870236f, 0.01006906f, 0.39297286f, -0.06967121f, -0.07024103f, -0.04855403f, 0.03387819f, 
    -0.00462275f, 0.09973009f, -0.10777452f, 0.03888877f, 0.27719626f, -0.23425937f, -0.10369203f, 0.19791804f, 
    0.13672331f, -0.01668597f, 0.03600896f, 0.08209561f, 0.08743722f, -0.14402577f, -0.10608307f, 0.07381299f, 
    0.30010316f, 0.00624565f, 0.02891889f, 0.17732483f, -0.02185979f, -0.06723703f, -0.02431704f, -0.01708003f, 
    -0.05028678f, -0.09630930f, 0.08598839f, -0.05835863f, 0.31125790f, 0.11881563f, -0.01023945f, -0.00378054f, 
    -0.21559601f, -0.03730996f, -0.03009721f, -0.00646874f, -0.08301743f, 0.15548308f, 0.09472485f, 0.10417921f, 
    0.18242313f, 0.12954594f, -0.06165165f, 0.09528056f, 0.04199000f, -0.12694804f, -0.11225698f, -0.10775841f, 
    -0.08763483f, 0.05538949f, -0.09584416f, -0.08659306f, 0.01148313f, 0.12157926f, 0.08093879f, -0.00937817f, 
    -0.12390658f, -0.02292318f, 0.01109082f, -0.01302463f, -0.09252901f, -0.02555327f, 0.06500399f, -0.14064847f, 
    -0.12961805f, -0.16407360f, -0.16246016f, -0.35259494f, 0.00989122f, 0.07971048f, -0.05555044f, 0.04760104f, 
    -0.03914455f, 0.03310070f, 0.03912279f, 0.02511999f, 0.00151431f, 0.07174531f, -0.03793999f, 0.24599499f, 
    0.06470000f, -0.13817132f, 0.20355350f, 0.02852000f, -0.08843994f, 0.02947713f, 0.21725368f, -0.09618063f, 
    -0.40317947f, 0.21018086f, 0.03191004f, 0.07151526f, -0.14436583f, 0.07585457f, -0.03065367f, 0.15299137f, 
    -0.07291860f, -0.00599666f, 0.02305701f, -0.10222363f, -0.04608093f, 0.00587521f, -0.00811175f, -0.09624214f, 
    -0.02683688f, 0.09014172f, -0.04529195f, -0.01952098f, -0.08042257f, -0.15321827f, -0.04031114f, -0.03849097f, 
    0.01328625f, -0.02915502f, -0.09796919f, -0.18048802f, 0.22949013f, -0.07275433f, 0.07795347f, -0.09278335f, 
    -0.16597159f, -0.00672192f, 0.11628947f, -0.00327230f, -0.21358852f, 0.06660819f, -0.02081873f, -0.14145261f, 
    0.02347278f, -0.03986075f, 0.18958409f, -0.06972519f, -0.17154412f, 0.09103888f, -0.09544365f, -0.14460230f, 
    0.11969539f, 0.24360406f, -0.16181803f, 0.02910161f, -0.02111804f, 0.08684156f, -0.02274161f, -0.01205132f, 
    0.15435931f, -0.00889922f, 0.00176534f, -0.09144870f, -0.14417323f, 0.16509585f, 0.03154651f, -0.10212510f, 
    -0.03866946f, 0.06204063f, 0.03060901f, -0.07070827f, 0.01014475f, 0.18619104f, -0.10243411f, -0.02655228f, 
    0.00971066f, -0.23223686f, -0.24673784f, 0.05886576f, 0.14962699f, 0.11726654f, 0.03721728f, 0.08572740f, 
    0.02576140f, 0.03670226f, -0.03129021f, 0.02464567f, -0.09705046f, 0.00777132f, 0.05409561f, -0.12282575f, 
    0.07168890f, 0.00338360f, -0.03344321f, 0.19754672f, 0.00513671f, -0.04951333f, -0.03005623f, -0.06907915f, 
    0.40364698f, -0.12185159f, -0.21542491f, -0.00146870f, 0.24258973f, 0.00031983f, 0.02437312f, -0.01062089f, 
    0.03843515f, -0.05143554f, 0.06943504f, 0.08899765f, 0.20984180f, -0.03130686f, -0.00488662f, 0.07306986f, 
    0.21554141f, 0.00730287f, -0.07047384f, 0.07197428f, 0.12736392f, 0.18041854f, 0.16204594f, -0.07003511f, 
    -0.10433444f, 0.34534785f, -0.21706297f, 0.07534963f, 0.13861352f, -0.05235482f, -0.10273530f, -0.03344186f, 
    0.03904498f, 0.05814480f, -0.02881549f, 0.01766207f, 0.06213933f, -0.07741890f, -0.05446606f, 0.08260539f, 
    0.03684931f, -0.03443961f, 0.10106798f, 0.02356532f, 0.01503927f, -0.01921407f, -0.14611660f, -0.11609649f, 
    -0.13565585f, -0.02903384f, 0.33951682f, -0.13044913f, 0.10195213f, 0.00915644f, -0.01443771f, -0.03051906f, 
    -0.06029340f, 0.03919550f, -0.00906647f, -0.03357098f, 0.14656186f, 0.19553623f, 0.20756005f, 0.01764076f, 
    0.04449394f, -0.18297687f, -0.04347562f, 0.07429851f, -0.02520301f, -0.00971725f, -0.01322550f, -0.22496346f, 
    0.04461429f, 0.21501304f, -0.18449599f, -0.07754617f, 0.07793599f, 0.10920129f, -0.03874749f, 0.01109054f, 
    -0.00450878f, 0.07777098f, 0.10566793f, -0.00157952f, 0.02131632f, 0.05532891f, -0.14922327f, -0.07125989f, 
    -0.03978496f, 0.06927919f, 0.12274101f, -0.02348444f, -0.00509547f, 0.13062300f, 0.02258570f, -0.02266946f, 
    0.00704247f, 0.05165380f, -0.10653260f, -0.08463547f, 0.12062464f, 0.00686598f, 0.04495556f, 0.04141737f, 
    -0.02004143f, 0.06545243f, 0.09846590f, 0.01122077f, -0.24786815f, 0.41155434f, -0.16557170f, 0.12032889f, 
    -0.01007088f, 0.04805173f, 0.10103542f, 0.04360924f, 0.06871083f, 0.05895106f, 0.19243765f, -0.04689283f, 
    0.23286699f, 0.05833120f, -0.01405422f, 0.17486934f, -0.05174808f, 0.09227072f, 0.08498052f, 0.11981275f, 
    0.06478119f, 0.09574526f, -0.02256308f, 0.16107191f, -0.02366649f, 0.12177840f, -0.02980183f, -0.05759133f, 
    -0.03209157f, -0.03536104f, -0.10716986f, -0.02799001f, -0.08740690f, -0.00205910f, 0.21889009f, 0.01410252f, 
    0.15825056f, -0.16935641f, -0.17150009f, 0.21146926f, -0.00832152f, -0.14876015f, -0.06032910f, 0.01639950f, 
    0.10643383f, -0.03969805f, 0.13301475f, -0.06919818f, -0.19746302f, 0.07177947f, 0.10129116f, 0.07527387f, 
    -0.02492407f, 0.02703852f, 0.12172980f, 0.09786156f, -0.19966468f, 0.02379341f, -0.11616565f, 0.12715234f, 
    0.15223812f, -0.00797424f, 0.27739713f, 0.20508991f, -0.10267935f, -0.06897859f, 0.00438343f, 0.04437902f, 
    0.13592260f, 0.12198238f, 0.06096694f, 0.12049709f, 0.30031562f, 0.11654147f, 0.00908654f, -0.18987480f, 
    0.15508412f, -0.05434820f, 0.02593079f, -0.11012872f, -0.01123262f, 0.11683774f, -0.05725837f, 0.12385083f, 
    0.06583527f, -0.08190946f, -0.07566688f, -0.11705685f, 0.05870246f, -0.15440650f, -0.00135464f, 0.08591072f, 
    0.08700485f, -0.02635742f, 0.17082770f, -0.13992579f, 0.11703008f, -0.03444250f, -0.17853791f, 0.07582022f, 
    0.06793617f, 0.16120422f, 0.08130506f, -0.04891370f, 0.01646703f, 0.00862804f, 0.10580601f, 0.01228475f, 
    0.09419513f, -0.06817707f, -0.00665399f, 0.02043952f, 0.03902173f, -0.05025895f, -0.16152652f, -0.00785799f, 
    -0.01862362f, -0.12662964f, -0.11191856f, 0.08798385f, 0.31644005f, -0.03570656f, -0.12666442f, -0.12720999f, 
    -0.05700556f, 0.09274439f, -0.11860406f, -0.00259830f, -0.02882802f, 0.07491025f, -0.08684289f, 0.13631201f, 
    -0.03262012f, -0.12455224f, 0.06761406f, -0.16970506f, 0.06665532f, -0.09914631f, 0.01351934f, -0.00455400f, 
    0.02817292f, 0.00476915f, -0.15479155f, -0.03751735f, 0.14447451f, 0.03608849f, 0.06970122f, 0.17576255f, 
    -0.10182808f, -0.04078053f, -0.10129400f, -0.06354227f, -0.01309047f, 0.19804919f, 0.01199710f, -0.04050937f, 
    0.23355600f, 0.09121670f, -0.09832968f, -0.04099738f, -0.05195947f, -0.03504489f, -0.10497276f, 0.17500539f, 
    0.01625885f, -0.03162300f, 0.10387477f, -0.13296564f, 0.17141958f, 0.04585594f, 0.00787476f, -0.09281234f, 
    0.04223775f, -0.05609700f, 0.00543597f, 0.17077899f, 0.10036850f, 0.02620633f, -0.11754066f, -0.06157081f, 
    -0.39006051f, 0.27056575f, -0.17040095f, -0.01695746f, 0.08367465f, 0.05107852f, -0.03079983f, -0.10743651f, 
    -0.08367345f, -0.04929694f, 0.07943100f, -0.09600186f, -0.39439535f, 0.06643698f, -0.02697195f, -0.08614352f, 
    -0.09154655f, 0.04296251f, -0.10348466f, -0.08654217f, 0.04186997f, 0.05751443f, -0.02600324f, 0.00400699f, 
    -0.15327848f, -0.17404446f, 0.09051225f, -0.02860212f, -0.01409576f, 0.07303791f, 0.05636546f, 0.00981225f, 
    -0.00758951f, -0.08868269f, -0.04648524f, 0.04192951f, 0.06250347f, 0.01329842f, 0.07424163f, -0.03752142f, 
    -0.10120179f, 0.03731577f, 0.02551860f, 0.06213297f, -0.01268257f, -0.03887804f, 0.02131199f, 0.09236693f, 
    0.03874017f, -0.02347674f, -0.04341559f, -0.06196620f, 0.16186218f, 0.10554864f, 0.03394926f, 0.11953805f, 
    0.00959186f, 0.06842583f, 0.11342347f, -0.00524754f, 0.03944828f, 0.08058202f, 0.00794805f, 0.05271777f, 
    -0.06843655f, -0.04204158f, 0.09161694f, 0.20316724f, -0.04365034f, -0.00474795f, -0.00638924f, -0.08723919f, 
    0.02411582f, -0.01137541f, 0.08791302f, 0.03852309f, 0.04574992f, -0.13234341f, -0.00339791f, 0.10581289f, 
    0.09110678f, 0.07756437f, -0.04215042f, 0.07594103f, -0.19687948f, -0.04163370f, 0.18279411f, 0.07425048f, 
    0.00972156f, -0.01091683f, 0.02461218f, 0.02233357f, 0.10782508f, -0.03124432f, -0.03634315f, 0.07987174f, 
    0.39172888f, 0.02235699f, -0.10274670f, 0.22713692f, 0.07983632f, 0.05405595f, 0.09422306f, 0.20321915f, 
    0.15233064f, 0.07544032f, 0.13389879f, 0.06819440f, 0.16394603f, -0.07328856f, -0.15751652f, 0.32582790f, 
    -0.07714624f, -0.04051915f, -0.09255060f, 0.02416347f, 0.18422908f, 0.14367263f, -0.07018225f, 0.17225368f, 
    0.00839683f, 0.02202269f, -0.19645204f, -0.11190882f, 0.07964826f, -0.03008684f, -0.00441979f, -0.01374063f, 
    0.12370483f, -0.01187110f, 0.00476919f, -0.01714466f, 0.22931136f, -0.00028418f, -0.06081654f, -0.11937332f, 
    -0.03993468f, -0.05491868f, 0.07671462f, -0.09229579f, 0.08418184f, -0.09758861f, 0.02909469f, -0.14106289f, 
    -0.10380286f, -0.01857843f, 0.00129349f, 0.15943606f, -0.06682727f, 0.01670080f, 0.06482281f, 0.04751405f, 
    -0.05684316f, 0.10242794f, 0.01333031f, 0.07303006f, 0.12721926f, 0.06892531f, -0.08942089f, -0.09339524f, 
    0.02710050f, -0.12490740f, 0.10693487f, -0.10661237f, 0.04907695f, -0.03081681f, -0.02691605f, -0.04927839f, 
    -0.06481554f, 0.19299813f, 0.05849144f, -0.13545552f, -0.01293785f, 0.00310776f, 0.09798709f, 0.05236141f, 
    -0.03338068f, -0.02545577f, 0.09885724f, 0.03403857f, 0.08660452f, 0.11637892f, 0.05138786f, -0.02231083f, 
    0.06400447f, -0.08374000f, -0.05058457f, 0.02274460f, 0.02096310f, 0.07380395f, 0.05110786f, 0.10304742f, 
    0.15523496f, 0.06327602f, -0.11921337f, 0.18116224f, 0.14325760f, -0.02891555f, 0.07436138f, -0.01796024f, 
    0.13137944f, 0.11155415f, 0.01053352f, -0.02015338f, -0.15454899f, 0.34967497f, -0.10909761f, 0.05417584f, 
    -0.08564350f, -0.02872742f, 0.10061911f, 0.06441688f, 0.03341750f, -0.02330446f, 0.05158271f, 0.02737164f, 
    0.04817167f, 0.10978083f, 0.13732012f, -0.08528806f, 0.03647829f, -0.12503652f, 0.07759837f, 0.03772331f, 
    -0.01626632f, 0.01092152f, -0.01141668f, -0.07088940f, -0.14685111f, 0.13299204f, -0.17531759f, -0.02383213f, 
    0.04848163f, 0.06944667f, -0.05500899f, 0.02050776f, -0.00837736f, 0.14665952f, 0.07927795f, 0.04650370f, 
    -0.07676090f, -0.35267824f, -0.17342943f, 0.16032130f, 0.09085357f, 0.06549998f, -0.04192494f, 0.00232466f, 
    -0.04733448f, -0.03975251f, 0.09362919f, 0.02397648f, 0.15558827f, 0.01946055f, 0.26205721f, -0.06347848f, 
    -0.02771373f, -0.14482361f, -0.00963126f, 0.12318605f, -0.15006205f, 0.00517915f, -0.08246578f, 0.16530575f, 
    -0.29662502f, -0.13796902f, 0.03068880f, 0.41550761f, 0.09650960f, 0.04446391f, -0.02991254f, -0.05898018f, 
    0.16245301f, 0.01510660f, -0.07138469f, 0.08062351f, 0.09944179f, -0.06734637f, -0.02902212f, -0.15445417f, 
    -0.08386676f, -0.01045326f, 0.09013940f, -0.07286125f, -0.02402993f, 0.08159824f, -0.02242920f, 0.09284480f, 
    0.17451346f, 0.10414205f, 0.02398625f, -0.03568057f, -0.06632667f, -0.04293658f, -0.09337303f, -0.04209995f, 
    -0.01093088f, 0.04661693f, -0.01354459f, -0.09412880f, 0.14959711f, 0.05074408f, 0.02586510f, 0.05751298f, 
    0.06266506f, 0.01633373f, 0.03170373f, 0.05311259f, 0.02750269f, 0.07743420f, 0.06464821f, -0.04432411f, 
    0.23396492f, 0.03964584f, 0.04093119f, 0.14540671f, -0.06280160f, -0.08253627f, -0.12406413f, -0.00630811f, 
    -0.10228428f, -0.03186686f, 0.01475509f, 0.03403272f, 0.42821386f, -0.03539623f, 0.03596562f, -0.07452165f, 
    -0.03127806f, -0.03429917f, -0.06635886f, -0.00678266f, 0.01489185f, 0.05021900f, -0.03294380f, 0.18394056f, 
    -0.11130407f, -0.00302228f, -0.06488714f, 0.29416484f, -0.14921367f, -0.00617843f, -0.12065276f, 0.06671540f, 
    -0.13789921f, 0.02312481f, -0.04846698f, -0.01476090f, -0.02925373f, 0.03925573f, 0.23106267f, 0.27803510f, 
    -0.10622647f, -0.05997721f, 0.09106118f, 0.03237450f, -0.13186879f, -0.13036378f, 0.02906319f, -0.06549340f, 
    0.06067339f, -0.01773414f, -0.10726076f, -0.19416997f, -0.02128393f, 0.03562983f, -0.02188449f, 0.03127574f, 
    0.00288681f, 0.06635802f, 0.23907831f, -0.05405599f, 0.02142676f, -0.04744830f, 0.03083833f, 0.15708965f, 
    -0.07382713f, -0.11609197f, 0.20079949f, 0.07017141f, -0.05878687f, 0.16765909f, 0.00135328f, -0.08125758f, 
    -0.41856429f, 0.33134687f, -0.00836699f, -0.06910548f, -0.07696966f, -0.04511186f, -0.06774780f, 0.09367149f, 
    -0.03698269f, -0.00893741f, 0.01603234f, -0.04337354f, -0.07041419f, 0.02579330f, 0.08221751f, -0.17833301f, 
    -0.07030460f, 0.09419786f, -0.02400526f, -0.00734573f, -0.10929433f, -0.01706143f, 0.00208623f, 0.14327370f, 
    0.11463037f, -0.07621406f, 0.03121968f, -0.00724446f, 0.03103045f, -0.03866307f, 0.02853962f, -0.00507034f, 
    0.00255590f, -0.05910028f, 0.10616932f, 0.00304152f, -0.11243984f, 0.16138543f, 0.15807244f, -0.02179235f, 
    -0.04435079f, -0.09529516f, 0.03493608f, -0.03177864f, -0.10228916f, 0.08030390f, 0.15889569f, -0.00413941f, 
    0.09478590f, 0.13648468f, -0.03761264f, 0.02310359f, 0.00362409f, 0.07186516f, 0.03002739f, 0.03970629f, 
    0.07838857f, -0.01534694f, 0.09837789f, -0.03224174f, 0.15018138f, -0.05467990f, 0.26924056f, 0.11528684f, 
    0.01608396f, -0.01033902f, -0.05287597f, 0.17900519f, -0.16806719f, -0.03078043f, 0.02204060f, 0.00306029f, 
    -0.10388027f, -0.12994508f, -0.30822596f, 0.02983833f, -0.05368013f, 0.03226012f, 0.01504488f, -0.07396210f, 
    0.07943328f, -0.00041491f, -0.11671391f, 0.16019943f, -0.08981807f, -0.10686553f, 0.06955141f, -0.02346888f, 
    -0.08460931f, -0.03976289f, -0.04544896f, 0.05352085f, 0.02171461f, -0.01350607f, -0.07527500f, 0.09401261f, 
    -0.02910700f, -0.11524170f, -0.01861687f, 0.06627499f, 0.20073019f, 0.17405234f, 0.00325986f, 0.08374963f, 
    0.14033481f, -0.09379889f, 0.13796352f, 0.00211836f, -0.07644310f, 0.00500148f, -0.06867226f, 0.00964385f, 
    0.12168501f, -0.01534762f, -0.12210716f, 0.09570816f, 0.08952358f, 0.12447589f, 0.03422493f, 0.01209710f, 
    -0.06165792f, 0.01923521f, -0.21587074f, -0.08218146f, -0.05106048f, 0.06678808f, -0.01650825f, 0.03844597f, 
    0.07012095f, 0.18084279f, 0.02636863f, -0.06627050f, 0.01458711f, -0.02736491f, 0.14403360f, 0.29348707f, 
    -0.07818823f, -0.03220037f, 0.07559220f, -0.03346463f, -0.10233469f, -0.10922961f, 0.06175591f, -0.11735749f, 
    -0.08499613f, 0.04859704f, 0.10417139f, -0.05828293f, -0.03441215f, -0.13691676f, 0.03883799f, 0.03720451f, 
    -0.11181793f, -0.01254419f, -0.02092827f, 0.04146840f, 0.22312093f, -0.01954177f, 0.17961411f, 0.23558570f, 
    -0.01758383f, -0.06720919f, 0.09989890f, 0.09699561f, 0.01284795f, -0.12151131f, -0.07889552f, 0.06983269f, 
    0.02597173f, 0.38995650f, 0.17675643f, 0.10139748f, 0.02867614f, -0.01619591f, -0.01021939f, 0.05060207f, 
    0.03330267f, 0.04086580f, 0.06266680f, 0.04030006f, -0.30477044f, 0.05444258f, -0.03647628f, -0.18445992f, 
    0.02193970f, -0.01548330f, 0.06111150f, 0.14826046f, 0.02879193f, 0.11071743f, 0.01017958f, 0.12359849f, 
    0.35228691f, 0.35197994f, 0.13263783f, -0.33008385f, 0.16619973f, 0.04159121f, 0.20248555f, 0.03925292f, 
    0.01118964f, 0.06780127f, -0.01717030f, 0.07585958f, -0.50462019f, 0.12833907f, -0.07566771f, -0.20681764f, 
    0.13906729f, -0.03147106f, 0.07549461f, -0.04670762f, 0.20289980f, 0.07846811f, 0.02586140f, 0.07525863f, 
    0.38996696f, 0.08693185f, -0.12515105f, -0.06112818f, -0.11859454f, 0.01920101f, 0.04456883f, 0.08412788f, 
    0.07359024f, 0.15508537f, 0.07868865f, 0.03390568f, -0.13790646f, 0.08152778f, 0.03970793f, -0.00053365f, 
    0.05542187f, -0.00387217f, -0.06963229f, 0.03420248f, 0.04962100f, 0.01492226f, -0.11732066f, -0.07598853f, 
    -0.12510680f, -0.36593834f, 0.04723657f, 0.00737360f, 0.06255820f, 0.04723183f, 0.04066744f, -0.07109825f, 
    0.03351227f, 0.08909294f, 0.25690177f, 0.07540790f, 0.38980705f, -0.17234507f, -0.09325045f, -0.13886680f, 
    -0.08445203f, -0.18439159f, -0.04089807f, -0.02150378f, 0.03084887f, -0.12215456f, -0.06404972f, 0.06096225f, 
    -0.35988790f, 0.01142621f, -0.01989294f, 0.18422881f, 0.14565343f, 0.12399746f, 0.02690637f, -0.04710159f, 
    0.03410904f, 0.04885267f, 0.03910568f, 0.06772486f, -0.29626259f, -0.29844588f, 0.14263064f, 0.09938640f, 
    -0.07066252f, -0.07609130f, 0.09972433f, -0.00018163f, 0.03632247f, -0.11886381f, -0.03257343f, 0.06353924f, 
    0.43783116f, 0.32724237f, 0.14420958f, -0.13181157f, 0.01534882f, -0.00179172f, 0.04135354f, -0.08967455f, 
    0.00832830f, 0.08458886f, 0.06366339f, -0.05382878f, 0.02464044f, 0.21305348f, 0.21991549f, -0.20021637f, 
    0.02141606f, 0.01437366f, 0.06821156f, -0.05533349f, 0.04389320f, 0.06235766f, 0.04623371f, 0.08988716f, 
    0.08404719f, 0.03509787f, 0.18003127f, -0.18293069f, -0.00523411f, 0.03929447f, -0.00634208f, -0.02474524f, 
    -0.02016316f, 0.00601259f, 0.07944990f, 0.12791757f, 0.17230926f, 0.00305546f, 0.01186102f, 0.03784509f, 
    -0.00395221f, 0.05948121f, -0.00367484f, 0.18095316f, 0.26157108f, 0.15661918f, -0.10606635f, 0.19227345f, 
    -0.35442781f, -0.14657234f, 0.19075170f, -0.06924633f, -0.11476701f, 0.03390778f, 0.05612360f, 0.06172791f, 
    0.14690687f, -0.02020971f, 0.02870253f, -0.03833843f, 0.13327475f, -0.09443025f, -0.05564204f, -0.16020037f, 
    -0.01825695f, -0.06297237f, 0.01066710f, 0.01249005f, 0.08118084f, 0.02513342f, -0.00042083f, 0.00499402f, 
    -0.26258487f, -0.02026407f, -0.24723269f, 0.05045656f, -0.01953801f, 0.05007103f, -0.13807146f, -0.01199919f, 
    0.01924667f, 0.09224784f, 0.16643031f, 0.02709225f, 0.10739355f, 0.20506971f, 0.12201716f, 0.01177326f, 
    0.04250553f, 0.06598557f, -0.10492159f, 0.00977852f, 0.10639172f, 0.14122084f, -0.13338310f, -0.07409520f, 
    -0.09616709f, 0.16856071f, -0.11029569f, -0.29793367f, -0.01983198f, 0.04958050f, -0.19634159f, 0.06316217f, 
    0.03424570f, -0.03443975f, -0.05255243f, 0.00982569f, -0.17327918f, 0.02658625f, -0.03135696f, 0.16416304f, 
    0.09578812f, -0.02107370f, 0.03110164f, 0.01996902f, -0.01063824f, 0.16401426f, -0.04785339f, 0.03661240f, 
    -0.22413836f, -0.00299656f, -0.02317470f, -0.05540720f, -0.13453548f, 0.19656314f, -0.06529266f, -0.06056302f, 
    0.06518413f, 0.00037241f, -0.12509683f, -0.14397863f, 0.20475005f, 0.10363007f, -0.15897642f, -0.18473174f, 
    -0.01496664f, 0.14487103f, -0.11020318f, -0.11563189f, -0.00014706f, 0.07914450f, 0.12480102f, -0.06261587f, 
    0.01732546f, 0.09738487f, 0.07545878f, 0.15927181f, 0.02222713f, 0.15265928f, -0.04424199f, 0.02465630f, 
    -0.08753088f, 0.21834271f, 0.18454248f, 0.12595823f, 0.18756288f, 0.00781547f, 0.10988522f, 0.23817660f, 
    -0.04887161f, -0.12889762f, 0.01365665f, 0.19027160f, -0.01078396f, -0.08913017f, -0.00866605f, -0.01997282f, 
    -0.53306305f, 0.00229313f, 0.13803725f, 0.04234916f, 0.09593739f, 0.06163487f, 0.07528871f, -0.07385170f, 
    -0.01411630f, 0.03535544f, 0.03200427f, 0.15005510f, 0.01003054f, -0.08986542f, 0.01890308f, 0.21171902f, 
    -0.04311622f, -0.10592017f, 0.12484924f, -0.07196657f, 0.20213024f, 0.09147620f, -0.02811907f, 0.09091846f, 
    -0.29686034f, -0.02217801f, 0.20815025f, 0.06548613f, -0.01000320f, 0.16191393f, 0.13626257f, 0.09589107f, 
    0.09906985f, 0.04986816f, 0.00946234f, -0.09261429f, -0.22510402f, 0.18093652f, -0.07630886f, -0.03395480f, 
    0.02786024f, 0.05328759f, 0.20223340f, 0.16088548f, -0.01415740f, 0.09454313f, -0.01442910f, 0.10812222f, 
    -0.19413599f, -0.31146705f, 0.19116640f, -0.05460739f, -0.09511128f, 0.07823538f, 0.11530837f, 0.14621481f, 
    0.10054394f, -0.01769298f, -0.04965406f, 0.12091091f, 0.21265429f, -0.00436796f, -0.16056156f, -0.08771670f, 
    -0.12635779f, -0.03006005f, 0.02629597f, 0.04004406f, -0.01272402f, -0.15836912f, -0.00403253f, -0.12781280f, 
    0.28175282f, 0.06500988f, -0.21942250f, 0.22391355f, -0.04161958f, 0.05047073f, 0.08040132f, 0.05364503f, 
    0.04597955f, 0.07605755f, -0.03519439f, -0.05569673f, 0.19311255f, -0.36035731f, -0.23967364f, -0.08301036f, 
    -0.19185792f, -0.16332166f, 0.07400475f, -0.04580279f, 0.15873452f, -0.05507679f, -0.17228355f, 0.11340787f, 
    0.01118839f, 0.02654406f, -0.00150514f, -0.04597609f, -0.00807113f, -0.05388078f, -0.02999710f, -0.04245857f, 
    0.02719690f, 0.03159661f, 0.00597376f, 0.01341040f, 0.02543120f, -0.04580450f, -0.00968575f, 0.03051699f, 
    -0.00934784f, 0.04050947f, -0.04700034f, 0.02565496f, -0.03175664f, -0.02142461f, 0.01756060f, 0.03860198f, 
    -0.00077715f, 0.01750132f, -0.05510973f, -0.03354003f, -0.00904366f, -0.02838668f, 0.01148844f, 0.04195158f, 
    -0.03223900f, -0.01980205f, 0.01327129f, -0.04224143f, -0.05307391f, -0.04323299f, -0.05353116f, -0.00633859f, 
    0.03901859f, 0.00087403f, 0.00300431f, -0.03751026f, -0.05257954f, -0.02442451f, -0.02155356f, 0.02129715f, 
    0.00797234f, -0.00551382f, -0.01477326f, 0.04489920f, 0.01931183f, -0.03233336f, 0.03458888f, -0.02695034f, 
    -0.01257926f, -0.03851633f, 0.00304299f, -0.04792028f, 0.01603338f, 0.01957448f, -0.03426170f, -0.01457081f, 
    -0.04285725f, -0.04487020f, -0.02024022f, 0.01955075f, 0.00535279f, 0.04341694f, -0.05689862f, 0.03603543f, 
    -0.01420671f, -0.03357868f, 0.01163894f, -0.02785168f, -0.03047356f, -0.03719388f, -0.03628595f, 0.02353109f, 
    -0.01553046f, -0.05427574f, -0.02138095f, 0.03604677f, -0.03143335f, 0.02788786f, 0.00220313f, 0.00171294f, 
    -0.02090020f, 0.03191527f, 0.03622902f, 0.00143805f, 0.03712997f, -0.01264985f, 0.04434022f, -0.02970152f, 
    -0.00122870f, -0.01065701f, -0.05669679f, 0.02908058f, -0.04979915f, -0.04624674f, 0.02614303f, -0.04009778f, 
    -0.04112702f, -0.01700387f, -0.02845404f, -0.02226755f, -0.04402701f, 0.03881027f, 0.01693342f, -0.01516875f, 
    0.02542456f, 0.02203466f, 0.01539370f, -0.03973321f, 0.03851689f, -0.05082718f, -0.03404689f, 0.03615274f, 
    0.03655010f, 0.02073207f, -0.04627443f, 0.01692750f, 0.00273984f, -0.04048131f, -0.02530416f, 0.03778708f, 
    0.00234021f, 0.00305701f, 0.01542892f, -0.04388711f, 0.04217957f, -0.04376395f, 0.02805295f, -0.02895896f, 
    0.01799657f, -0.02255308f, -0.00337734f, -0.04667133f, 0.01987490f, 0.03832938f, -0.03490776f, 0.03075660f, 
    -0.02385973f, -0.00819636f, 0.00293371f, 0.00673059f, -0.05644467f, -0.04592458f, 0.01514754f, -0.00348281f, 
    0.02938480f, -0.02223615f, 0.00949877f, 0.03128851f, 0.00559589f, 0.01819576f, 0.03240310f, 0.02296295f, 
    -0.04047710f, -0.04297419f, -0.05570258f, -0.02900638f, -0.02402482f, -0.02262926f, 0.02314253f, -0.04275444f, 
    -0.00293976f, 0.04021805f, -0.05215313f, 0.02811772f, 0.04656273f, -0.03749447f, -0.02166833f, -0.03151406f, 
    -0.03529487f, 0.00911603f, 0.02453634f, -0.02385389f, 0.01766955f, 0.04028827f, -0.05441977f, -0.00025815f, 
    -0.04629640f, -0.01866874f, -0.04725825f, -0.05392381f, 0.04128603f, 0.01366200f, -0.04054410f, 0.03386851f, 
    0.03544055f, -0.00715755f, 0.00595626f, 0.02221205f, -0.00207232f, -0.04773119f, -0.04221946f, -0.00013784f, 
    -0.03518916f, 0.02423844f, -0.05498475f, -0.03111397f, -0.05559739f, 0.02694773f, -0.01661456f, -0.02549328f, 
    -0.00627888f, -0.02783567f, -0.01267411f, -0.03821114f, 0.01354188f, 0.03245123f, -0.01446707f, -0.03763095f, 
    0.02564998f, -0.02755603f, 0.00667195f, -0.03933773f, -0.05483779f, 0.03555239f, -0.04100211f, -0.02089397f, 
    0.02869696f, -0.05277164f, -0.00365742f, -0.04869214f, 0.03313588f, -0.00616468f, -0.05176644f, -0.01973991f, 
    -0.02485326f, -0.01814885f, 0.03815924f, -0.01951362f, -0.01595573f, -0.00042612f, 0.01091785f, 0.01937382f, 
    -0.00640461f, -0.01979652f, -0.01577243f, 0.04100790f, -0.03390507f, 0.01501179f, 0.01088282f, -0.03290913f, 
    0.01682545f, -0.05391610f, -0.05476844f, 0.03486296f, -0.02250625f, -0.00221337f, 0.01776446f, 0.01165754f, 
    0.01732173f, 0.01147218f, -0.01607876f, -0.00984344f, 0.04001851f, -0.01684659f, 0.00337657f, -0.04084605f, 
    -0.02728149f, 0.00098126f, -0.03344616f, 0.02722362f, 0.02742364f, -0.00247567f, 0.02691430f, -0.00109236f, 
    -0.03317207f, 0.02507769f, -0.02448408f, -0.03229045f, 0.00404372f, -0.01770502f, -0.00798466f, -0.05640766f, 
    0.00558418f, 0.03467786f, 0.01349909f, -0.02199915f, -0.02114718f, 0.04241009f, -0.00194140f, -0.02161574f, 
    -0.02654035f, -0.03863329f, 0.05035233f, -0.02423969f, 0.00987885f, -0.05187168f, 0.03098522f, -0.03239091f, 
    0.02840576f, -0.03093774f, 0.00218279f, -0.05564583f, 0.04015609f, -0.01291378f, -0.05486799f, 0.01419112f, 
    0.03174398f, 0.02938074f, -0.02927373f, -0.04582085f, -0.03625101f, 0.01065105f, -0.03321290f, -0.03993846f, 
    0.03951626f, -0.05408404f, 0.02916398f, 0.02808116f, 0.00349810f, -0.03056226f, -0.02131963f, 0.02700269f, 
    0.04014171f, -0.04631752f, -0.01207128f, -0.05182004f, -0.01790258f, 0.03852461f, -0.01476555f, 0.03266057f, 
    -0.00053515f, 0.02836427f, -0.02275173f, 0.02584607f, -0.00179882f, -0.00172856f, 0.01861322f, 0.00318596f, 
    -0.00053061f, 0.00739189f, -0.05672503f, -0.02458769f, -0.00250374f, 0.03636612f, 0.02592487f, -0.02798354f, 
    -0.04232937f, -0.03876948f, 0.00326589f, -0.02738612f, -0.00183596f, -0.01384356f, -0.02518192f, 0.03012929f, 
    0.02507158f, -0.05122704f, 0.02145966f, 0.00230560f, 0.00700246f, -0.00035624f, 0.00664935f, -0.00760072f, 
    0.01051558f, 0.05660651f, 0.00516691f, 0.03215927f, -0.04805778f, -0.05382079f, 0.03424870f, -0.03029541f, 
    0.02707847f, 0.00147682f, 0.03120669f, -0.00603228f, -0.04689868f, 0.03886385f, 0.02275230f, -0.04939958f, 
    -0.01118751f, -0.00934018f, 0.00551827f, 0.03277827f, 0.03800719f, -0.04480925f, 0.00081463f, -0.01153025f, 
    -0.42763075f, 0.00801775f, 0.02624600f, 0.08004615f, 0.22008581f, -0.02437624f, 0.09146418f, 0.07310545f, 
    -0.04124558f, 0.04246484f, -0.16294816f, 0.05146402f, 0.04954449f, 0.14993392f, 0.04777350f, -0.05064535f, 
    -0.19926333f, -0.06536745f, 0.06530179f, 0.04941134f, 0.19282064f, -0.11871219f, -0.07653710f, 0.00589609f, 
    0.21032543f, 0.18813591f, 0.11155446f, 0.15541083f, 0.00041388f, -0.00187289f, -0.01208132f, -0.05371352f, 
    -0.06492061f, 0.08894071f, -0.00904076f, -0.10889279f, -0.11968000f, 0.39176846f, 0.16108745f, 0.17177679f, 
    0.12184952f, -0.07642958f, 0.09279943f, 0.13757196f, -0.10034813f, -0.00987740f, -0.09924175f, -0.03319169f, 
    -0.24852082f, -0.14898494f, -0.01941023f, -0.08287837f, -0.14099744f, -0.08094170f, 0.04506545f, 0.07329742f, 
    -0.04377331f, -0.11047887f, 0.00560492f, 0.02843909f, 0.34243640f, 0.02108503f, 0.04098770f, -0.01501670f, 
    0.03736036f, -0.01883456f, 0.16836704f, 0.15003501f, 0.04887396f, 0.10306007f, 0.07265308f, 0.01860579f, 
    0.13485686f, 0.10409290f, 0.22425123f, 0.13721766f, -0.09879285f, 0.04713092f, 0.05748912f, 0.00671987f, 
    0.10854884f, 0.06974575f, -0.17932831f, 0.01023019f, -0.25056335f, -0.23259802f, 0.01329779f, 0.06422732f, 
    0.02495382f, -0.09987411f, -0.03546102f, -0.09490051f, -0.06760815f, -0.06385079f, 0.07032426f, -0.07787605f, 
    0.10499052f, -0.12549056f, 0.06637939f, 0.09781270f, -0.06860571f, 0.09230883f, 0.03649156f, -0.01322849f, 
    0.05263439f, -0.16838862f, -0.02905732f, -0.06651269f, 0.15436015f, -0.13993928f, -0.29477587f, 0.26760820f, 
    0.12905733f, 0.26135626f, 0.06987688f, 0.04663346f, 0.08574168f, 0.06612351f, 0.00153800f, -0.08683188f, 
    0.24355674f, 0.20518833f, 0.10138645f, -0.01109026f, 0.07386386f, 0.01694015f, 0.00097734f, -0.00844549f, 
    0.09175505f, 0.00181388f, 0.07888775f, 0.09453823f, 0.32206488f, 0.11176244f, -0.08771531f, 0.09155936f, 
    0.02521321f, -0.08146915f, 0.14593759f, -0.01947644f, 0.04566704f, -0.13232146f, -0.09839934f, -0.18386313f, 
    0.19278383f, -0.06203058f, -0.00756431f, -0.08275314f, 0.00640943f, 0.04045417f, -0.02086142f, 0.03752906f, 
    0.02604434f, -0.11239467f, -0.04055702f, 0.03762450f, -0.00163659f, 0.07331277f, -0.03779870f, -0.19512576f, 
    0.01881906f, 0.04157439f, -0.04610958f, -0.16366230f, -0.07281344f, -0.12652126f, 0.09871373f, 0.11371836f, 
    -0.08223515f, -0.03005568f, 0.02214932f, 0.00117795f, -0.09429060f, -0.06847864f, 0.06487838f, -0.00103813f, 
    0.00109387f, 0.14654176f, -0.07825413f, -0.00125497f, -0.05572525f, -0.14789411f, 0.11341793f, -0.10555010f, 
    -0.09927645f, -0.16579096f, -0.06062087f, 0.01404180f, -0.03759041f, -0.00400750f, -0.00244429f, -0.01446363f, 
    0.25932598f, 0.12991714f, -0.01965494f, -0.02086043f, -0.02850197f, -0.15621355f, 0.13695848f, 0.20717385f, 
    0.06999061f, 0.08584264f, 0.00244735f, 0.03964246f, -0.16217023f, 0.22583389f, 0.18948893f, 0.19368856f, 
    0.08929067f, 0.03392978f, 0.06004926f, 0.11325224f, 0.10433180f, -0.15080743f, 0.06920852f, 0.17854586f, 
    -0.37607300f, 0.39853346f, -0.06807657f, -0.01114027f, -0.09656576f, -0.02401116f, 0.02560518f, 0.04780172f, 
    0.04865754f, -0.03834505f, -0.14391190f, 0.04985322f, -0.05036145f, -0.06185795f, 0.03190336f, -0.12058055f, 
    0.02027600f, 0.00451162f, 0.12536439f, -0.09037550f, -0.07182081f, -0.07406285f, 0.09208611f, 0.14909366f, 
    -0.02997910f, -0.19364287f, -0.04200824f, 0.02025039f, 0.04759498f, -0.02099285f, -0.00500405f, 0.10612044f, 
    0.05407952f, 0.02769749f, 0.18113750f, 0.13517125f, -0.30117011f, -0.19900188f, 0.01096243f, 0.08843348f, 
    -0.07117880f, 0.00695082f, -0.04546792f, 0.00752003f, -0.00613380f, -0.01772540f, 0.15344977f, 0.04758975f, 
    -0.01741040f, 0.18655109f, -0.02048174f, 0.03317255f, 0.11047381f, 0.04063728f, 0.15694556f, -0.06884982f, 
    0.08988043f, -0.20613247f, 0.08443301f, -0.07990920f, 0.26695019f, 0.03337222f, 0.14787734f, -0.23613705f, 
    0.09626327f, 0.11755794f, 0.00653532f, 0.08557514f, 0.13483997f, 0.18607013f, 0.03596238f, 0.09377872f, 
    -0.31046620f, -0.09576845f, -0.20438711f, 0.20438986f, -0.02869774f, -0.05201866f, -0.06017740f, -0.00938899f, 
    0.07799645f, 0.11050694f, -0.06006213f, -0.11641572f, 0.03840018f, -0.08561749f, -0.00107509f, -0.04810078f, 
    -0.16457117f, 0.05688183f, -0.10757117f, -0.02149839f, -0.14081921f, -0.07607418f, -0.00630458f, -0.14561671f, 
    -0.02132539f, 0.04258291f, 0.02191784f, 0.05249614f, 0.12075543f, 0.05561468f, 0.00960920f, 0.00301796f, 
    0.02859585f, 0.09256300f, 0.13731362f, 0.03077184f, 0.14221773f, 0.19923452f, -0.11082252f, -0.03987478f, 
    0.07343198f, -0.03742325f, -0.14652427f, -0.02240484f, -0.00329725f, 0.00982060f, 0.04845702f, -0.03466476f, 
    0.12383726f, -0.14346154f, -0.29288539f, 0.41350073f, -0.08448094f, 0.04857877f, 0.05028478f, 0.02831076f, 
    -0.01792544f, 0.07008670f, -0.07040706f, -0.07570572f, -0.27147949f, -0.23625588f, 0.03751874f, 0.06639308f, 
    -0.11128058f, -0.01126799f, -0.00113023f, -0.03537767f, 0.03708939f, 0.03531383f, 0.02150650f, 0.18685612f, 
    -0.06060265f, -0.18496104f, 0.06420061f, -0.34615225f, 0.13701327f, -0.04135975f, -0.05449298f, 0.00978577f, 
    0.04129041f, -0.03068639f, 0.02488263f, 0.05761899f, -0.14306846f, 0.01493348f, -0.06435433f, -0.08105704f, 
    -0.04904171f, 0.03223162f, -0.00406827f, -0.03627921f, -0.07876298f, 0.05949170f, 0.04049893f, -0.08500826f, 
    -0.30055147f, -0.14080711f, -0.08931914f, 0.02860644f, 0.18239386f, -0.09908040f, 0.02918625f, 0.07718212f, 
    -0.02878910f, 0.05142861f, -0.01586237f, 0.03864789f, -0.09041101f, -0.04886133f, 0.03942146f, -0.12000742f, 
    -0.17356989f, 0.03591631f, 0.12451715f, 0.06533645f, 0.10004225f, -0.07234538f, 0.05632597f, 0.07376754f, 
    0.02804366f, 0.12947157f, 0.06150841f, -0.12538400f, -0.04861257f, 0.11168575f, -0.00158807f, -0.00859187f, 
    -0.08199431f, -0.00819474f, -0.01381095f, -0.04715633f, 0.11962680f, 0.14262708f, 0.21193658f, 0.12011126f, 
    0.18119341f, -0.00580403f, 0.05230262f, 0.05925511f, -0.09837583f, -0.05847305f, 0.07230356f, 0.03244235f, 
    -0.14546531f, -0.11526157f, -0.04484392f, 0.20003736f, -0.02985838f, 0.09200961f, 0.05949245f, 0.09651747f, 
    -0.01732779f, -0.03070221f, 0.05160407f, 0.07013734f, 0.48986968f, -0.00049997f, 0.10457680f, 0.18664035f, 
    0.02071766f, 0.00157126f, 0.17134571f, 0.18172753f, 0.05727582f, 0.09098255f, 0.05842580f, -0.07694804f, 
    0.41657364f, 0.29075867f, 0.32489592f, 0.19251098f, -0.07793871f, 0.14362726f, 0.04910824f, 0.05454469f, 
    0.10062799f, 0.05136443f, -0.10650827f, -0.02283370f, -0.11631242f, -0.23148456f, -0.19447741f, 0.04479168f, 
    -0.03028366f, -0.03238599f, -0.01778308f, -0.07237348f, 0.08287771f, -0.00173025f, 0.17232834f, -0.05642241f, 
    0.25589409f, 0.06259691f, 0.10773888f, 0.11231335f, 0.04861358f, 0.08666758f, 0.06853753f, 0.07152034f, 
    0.03725548f, -0.09131658f, -0.01166659f, -0.08561088f, 0.27069283f, -0.05445285f, -0.04890873f, 0.26425165f, 
    0.10187919f, 0.25667444f, 0.02520048f, 0.14705740f, 0.05612506f, 0.08007315f, 0.05633980f, -0.04466556f, 
    0.01172931f, -0.02967224f, 0.07985242f, -0.09665688f, 0.05603359f, 0.05000842f, -0.00818943f, 0.07515392f, 
    -0.02224343f, 0.02410840f, 0.16477977f, 0.09042687f, 0.14958665f, 0.07367060f, 0.03617997f, -0.14532180f, 
    -0.08911522f, -0.03885255f, 0.10577466f, 0.04957863f, 0.10074775f, -0.06398515f, -0.00712934f, -0.13123974f, 
    0.03076781f, 0.01727728f, 0.05768386f, -0.17620620f, -0.03327420f, 0.13392492f, 0.08733585f, 0.12662435f, 
    0.07469309f, 0.01432052f, -0.01103479f, 0.04494713f, -0.22694999f, 0.03173179f, 0.05101100f, -0.10517210f, 
    0.13793403f, 0.01619067f, 0.01454506f, -0.10796334f, -0.04190872f, -0.20926723f, 0.07564047f, 0.15303990f, 
    -0.22566049f, -0.13376446f, 0.12543231f, -0.08837838f, -0.02123161f, -0.05636546f, 0.01466782f, 0.11550008f, 
    0.07861551f, 0.11284661f, 0.00933511f, 0.13953330f, 0.04130909f, -0.25603765f, -0.01148019f, -0.06620210f, 
    -0.10974585f, -0.06559715f, -0.02956348f, 0.01344646f, 0.08675275f, 0.13175738f, -0.01870704f, 0.10951894f, 
    0.34800673f, 0.20970304f, 0.06930085f, 0.29599541f, 0.06072928f, -0.02372806f, 0.16416769f, 0.17903882f, 
    0.00811897f, 0.05983906f, -0.09546154f, 0.05256363f, -0.18078646f, 0.23805957f, 0.10143773f, 0.03503117f, 
    0.11004650f, 0.09359206f, 0.03803692f, 0.05828381f, 0.06057242f, -0.09115107f, 0.01930399f, 0.24469042f, 
    0.16308497f, 0.06613576f, -0.01181800f, -0.04687205f, -0.06484091f, 0.03173108f, 0.07215486f, 0.06041976f, 
    0.08953404f, 0.02765731f, -0.06517442f, 0.18834592f, -0.02198717f, 0.08312010f, -0.05639664f, -0.13710245f, 
    0.01476496f, 0.03961177f, 0.04614849f, -0.01525921f, 0.07604195f, 0.05089837f, 0.11278607f, 0.17212789f, 
    -0.20198944f, -0.06755750f, 0.02615943f, 0.14534003f, 0.05349715f, 0.02489948f, -0.03079077f, 0.19833902f, 
    0.11894453f, 0.08176845f, 0.05003530f, 0.07027005f, -0.02217184f, -0.12198920f, 0.02549948f, 0.19365959f, 
    0.05970135f, -0.01472175f, -0.03434885f, 0.09351569f, 0.10770503f, 0.03014622f, 0.20063078f, 0.09027878f, 
    -0.25852031f, 0.00728093f, 0.04006637f, -0.04929487f, -0.00368115f, 0.08277823f, 0.14919269f, -0.00339337f, 
    -0.07203606f, -0.16078930f, 0.02646509f, 0.07400678f, 0.17993927f, -0.08012154f, 0.00655078f, -0.08529289f, 
    0.08213346f, 0.06451717f, -0.02340658f, 0.08203026f, 0.12551257f, 0.13199009f, 0.06901649f, 0.17169064f, 
    -0.06968749f, 0.07078870f, 0.07534417f, 0.16380645f, 0.00233881f, 0.03696278f, 0.08262033f, -0.02695128f, 
    0.00647532f, 0.13303778f, 0.06766941f, -0.08531929f, 0.12572350f, 0.02420555f, -0.03368361f, 0.05720708f, 
    -0.11810718f, 0.07137530f, -0.06447238f, 0.02563597f, -0.02519193f, -0.04204143f, -0.05125427f, -0.10340489f, 
    -0.13660125f, 0.19636026f, 0.12162446f, 0.14333737f, 0.00264661f, 0.04042973f, 0.01580044f, -0.02045144f, 
    0.02456146f, 0.08842022f, 0.07614068f, -0.04298060f, 0.26994473f, 0.24988608f, -0.09299987f, 0.00797253f, 
    0.02228099f, -0.00427137f, 0.09753135f, -0.03589441f, -0.01303954f, -0.05009655f, 0.08341425f, -0.04205484f, 
    0.26025176f, -0.17455566f, 0.15284790f, 0.31017751f, -0.08578323f, 0.07984135f, 0.14795755f, 0.09787185f, 
    0.03430648f, -0.06937351f, 0.03996182f, 0.04006412f, -0.23309350f, -0.25345409f, 0.10428003f, -0.05437894f, 
    0.05664174f, 0.07284234f, -0.12800722f, 0.09443021f, 0.06124280f, 0.09836949f, 0.04647570f, 0.23156428f, 
    0.20780538f, -0.09176919f, -0.11672486f, -0.15649013f, -0.03174618f, 0.04643476f, 0.02645521f, 0.01114733f, 
    0.01760845f, -0.01608196f, 0.07975255f, 0.15606010f, -0.24839765f, -0.16646577f, -0.17289524f, -0.00823889f, 
    -0.05546832f, 0.05605609f, -0.16237950f, 0.10229759f, -0.08046042f, 0.02803089f, 0.00210021f, 0.04114186f, 
    -0.03663771f, 0.01041363f, 0.02260458f, 0.01440311f, 0.03256732f, 0.04270846f, -0.00587337f, 0.02660094f, 
    0.00603251f, -0.04583452f, -0.00280471f, -0.03204329f, 0.00957899f, -0.02994308f, -0.03564790f, -0.02303299f, 
    0.01784032f, -0.03182281f, -0.02498449f, -0.04138895f, -0.05603503f, -0.01366733f, -0.01374019f, 0.02542200f, 
    0.03426210f, 0.05193135f, 0.01787266f, 0.01781806f, 0.00736661f, -0.00670816f, 0.03209582f, -0.02088332f, 
    0.03409818f, -0.05278664f, 0.02714866f, -0.03509349f, 0.01074923f, -0.06112007f, 0.01827314f, 0.05210122f, 
    0.00755541f, -0.01855232f, 0.01822990f, 0.03078720f, -0.03172150f, -0.05480748f, -0.05087281f, -0.01321706f, 
    -0.00701480f, -0.03983680f, 0.02309064f, -0.03626553f, 0.02038110f, -0.03592442f, -0.02890263f, -0.02189169f, 
    0.03883410f, -0.02054110f, 0.01965491f, -0.02149082f, 0.00238690f, -0.01489362f, -0.01017870f, -0.04862230f, 
    0.03789690f, 0.04418569f, 0.00280902f, 0.03511088f, 0.02596180f, -0.01248429f, -0.03925207f, -0.02946536f, 
    0.00471336f, -0.01760311f, -0.00018220f, -0.02745690f, 0.04545121f, -0.03494353f, -0.01108727f, -0.01227747f, 
    -0.02620229f, 0.01219543f, -0.02918312f, -0.02835144f, 0.05048512f, 0.04434700f, 0.01802052f, -0.01771815f, 
    0.01583540f, -0.03774413f, 0.03361578f, -0.00948665f, 0.00084965f, -0.03949490f, 0.04681514f, -0.00000467f, 
    0.00266685f, -0.03717190f, -0.04740486f, 0.04063658f, 0.02570890f, -0.04919483f, 0.04311127f, -0.00448922f, 
    -0.02907709f, -0.02190343f, 0.01900486f, -0.00860252f, 0.01969145f, -0.03820336f, 0.03001537f, 0.00222594f, 
    0.01826357f, -0.03973629f, -0.02495603f, -0.00848873f, -0.00165541f, 0.01909233f, -0.05257741f, 0.04199867f, 
    -0.00427633f, -0.01041915f, -0.04862593f, -0.05373948f, -0.05855630f, 0.01973516f, -0.00040202f, 0.01431502f, 
    -0.03904275f, 0.01565513f, -0.00098227f, -0.01033902f, 0.04499898f, -0.05281356f, 0.02648911f, 0.03614576f, 
    -0.04832123f, 0.01662851f, 0.03273145f, 0.01107547f, -0.03632049f, 0.00005619f, -0.03304107f, 0.01247316f, 
    0.03803534f, 0.01987360f, -0.01555915f, -0.02397249f, 0.05003527f, -0.03665425f, -0.00031600f, 0.00013257f, 
    0.02537913f, 0.03448952f, -0.04387071f, 0.03311986f, 0.02688135f, -0.00066856f, -0.00881186f, 0.02237074f, 
    -0.02617307f, -0.02960420f, -0.03590197f, 0.03420793f, -0.02587541f, 0.05297609f, 0.00100608f, -0.04894246f, 
    -0.02130337f, 0.02415355f, 0.02605644f, 0.01933142f, -0.02909807f, -0.05054815f, -0.00250987f, -0.05471786f, 
    0.01173342f, 0.00214154f, 0.00662143f, -0.00905410f, 0.02779411f, -0.03167516f, 0.05228786f, -0.02845085f, 
    -0.01140684f, 0.03427177f, -0.00993594f, -0.01114154f, 0.00188687f, -0.00318078f, 0.01834928f, -0.02582548f, 
    0.00318388f, -0.01346796f, -0.03714931f, 0.01753411f, -0.01954947f, -0.00980091f, -0.02399141f, -0.03379464f, 
    0.02067487f, 0.00575621f, -0.03683767f, 0.04776242f, -0.03191366f, 0.00597488f, 0.02817713f, -0.02685706f, 
    -0.02645073f, 0.04009568f, 0.00911621f, 0.04838017f, 0.02984576f, -0.04026731f, 0.04016441f, 0.01385374f, 
    0.00204677f, -0.01061205f, 0.00198192f, 0.01570222f, -0.02918847f, -0.04481089f, 0.02651990f, -0.04397697f, 
    -0.00046725f, -0.02680475f, -0.03439016f, -0.02613508f, -0.04544916f, -0.03254863f, -0.00756346f, 0.01006569f, 
    -0.03109119f, -0.01653668f, 0.00013875f, 0.02874470f, -0.00234749f, 0.03292329f, -0.04803661f, -0.02377844f, 
    0.00710580f, 0.03172145f, 0.03174965f, -0.00281976f, -0.01617454f, -0.03654220f, -0.01343622f, 0.02830458f, 
    0.04389200f, -0.04278903f, 0.00481726f, 0.03893686f, -0.03304083f, 0.02344985f, 0.02722686f, 0.01440399f, 
    -0.03390112f, -0.04426428f, -0.03671813f, -0.01286393f, 0.03231968f, -0.01298143f, 0.03403765f, -0.05285136f, 
    -0.01710527f, -0.00040792f, 0.01220209f, 0.03387755f, -0.03338259f, 0.00047266f, -0.00416248f, 0.00501730f, 
    -0.04523586f, -0.01114027f, 0.03441161f, -0.00796024f, -0.01533506f, 0.01039846f, -0.01032689f, -0.03997822f, 
    0.03662864f, 0.04377023f, 0.00093443f, -0.00241767f, -0.01783787f, 0.02792878f, 0.03057165f, 0.04965349f, 
    -0.03839128f, -0.03818011f, -0.05526369f, -0.03731071f, 0.02144151f, 0.02169407f, 0.00964853f, -0.02743947f, 
    -0.05147460f, -0.00050974f, 0.03465676f, 0.03568839f, 0.02288199f, -0.02441695f, -0.04791144f, 0.02348175f, 
    -0.02499885f, 0.03174386f, -0.02222066f, -0.01121999f, -0.01279665f, -0.04341961f, 0.04182114f, 0.03156903f, 
    -0.01823724f, 0.02697167f, 0.02612837f, 0.02251300f, -0.02348783f, -0.01379833f, -0.03533771f, 0.01757681f, 
    0.02139328f, -0.03135314f, -0.00294727f, 0.02643810f, -0.04198179f, -0.00202175f, 0.04264012f, 0.02639349f, 
    0.01441686f, -0.03023778f, -0.02661031f, -0.03942943f, -0.00630650f, -0.01275458f, -0.01122493f, 0.01547422f, 
    -0.05191177f, -0.00783864f, -0.03193299f, -0.02612292f, -0.04071179f, 0.03900819f, 0.01705100f, -0.02849928f, 
    -0.01732464f, 0.04840363f, -0.02261679f, 0.03992704f, 0.03502500f, -0.03484277f, -0.02249469f, 0.00668276f, 
    -0.00927495f, -0.04270740f, 0.02038975f, -0.00996034f, -0.01448858f, -0.01414926f, 0.04148196f, -0.05058073f, 
    0.00467653f, -0.01446034f, -0.02725846f, 0.01504380f, -0.05194172f, 0.01621387f, 0.02233035f, 0.01006811f, 
    -0.04379876f, -0.00052596f, -0.03069654f, -0.01972062f, 0.00701216f, -0.04241849f, -0.00543596f, 0.04279928f, 
    -0.03331864f, -0.01660654f, -0.01466597f, 0.01384512f, -0.03915899f, 0.02163744f, -0.02375990f, 0.02539125f, 
    0.07054207f, 0.12651743f, -0.20094927f, -0.06520830f, 0.03263687f, 0.22536707f, 0.09407659f, 0.07287049f, 
    0.01845303f, 0.09352980f, -0.04822915f, -0.15160811f, 0.27520204f, -0.15023705f, -0.04320772f, -0.00405254f, 
    0.08765479f, 0.11613371f, -0.00756359f, 0.04792470f, 0.12455813f, 0.01084179f, 0.10288284f, -0.05230022f, 
    0.49884066f, -0.05096295f, -0.07134113f, 0.47991374f, 0.04526307f, 0.20743017f, 0.11429268f, 0.04073824f, 
    0.03085928f, -0.03841707f, 0.02148405f, -0.01922969f, 0.07338062f, 0.09611881f, -0.18735117f, -0.07303690f, 
    -0.07447673f, 0.02102401f, -0.02867916f, 0.15378818f, -0.08861458f, 0.16190070f, 0.10783631f, 0.15817802f, 
    -0.11797249f, -0.25550550f, -0.00914741f, -0.14777228f, 0.14837895f, 0.05672739f, 0.09546261f, 0.04183726f, 
    -0.04480880f, -0.00392283f, -0.02315221f, 0.09156084f, 0.21724507f, -0.00181594f, -0.11862817f, -0.27740398f, 
    0.09492058f, 0.20305409f, -0.04775406f, -0.00769661f, -0.02672584f, 0.11402611f, 0.07541788f, 0.03790333f, 
    -0.18144555f, 0.10682111f, 0.03831140f, -0.17468616f, 0.03711616f, -0.00948577f, 0.00007373f, 0.01633330f, 
    -0.00414506f, -0.05871880f, -0.07350045f, 0.12736757f, -0.26212686f, 0.18531001f, -0.11130814f, 0.09983062f, 
    0.00256156f, 0.04875156f, 0.02901563f, 0.03171295f, -0.09599251f, -0.01061781f, -0.02420017f, 0.00491143f, 
    0.23629694f, -0.18015678f, -0.00622586f, -0.28482336f, 0.23480824f, 0.03454427f, -0.01120729f, 0.06819116f, 
    0.04747240f, 0.01063365f, -0.01649957f, 0.04690641f, 0.11360946f, -0.03201037f, 0.20748469f, 0.27541661f, 
    0.12857561f, -0.04967418f, 0.11687522f, -0.02603701f, 0.04571178f, 0.11564399f, -0.06604215f, -0.00186264f, 
    0.30787870f, 0.16895479f, 0.05359727f, 0.30041400f, -0.02333908f, -0.04505608f, 0.00674089f, 0.01320047f, 
    0.14718562f, -0.03216996f, 0.17307919f, 0.07348257f, 0.26366535f, -0.44409689f, 0.02419080f, 0.30206665f, 
    0.10068242f, 0.12112965f, 0.21142510f, -0.00672747f, -0.10693439f, 0.03575219f, -0.06041195f, -0.09496485f, 
    0.21367897f, -0.02495011f, 0.08777608f, 0.31862900f, 0.14159067f, 0.10015731f, 0.08555411f, 0.06622344f, 
    0.08029185f, 0.03411856f, 0.05796649f, 0.02132619f, 0.29464135f, -0.14371090f, 0.07571285f, -0.01543141f, 
    -0.00925832f, -0.04464932f, -0.12686059f, -0.02490822f, 0.08998410f, 0.01330602f, 0.17911741f, 0.04163902f, 
    0.14295314f, -0.09935366f, -0.17010622f, 0.30921751f, -0.09557986f, -0.08110893f, 0.00542386f, -0.01957607f, 
    0.12970148f, 0.14411144f, 0.04992843f, 0.13047326f, 0.09699797f, -0.01645521f, -0.14336045f, 0.07270928f, 
    -0.02261382f, -0.06435395f, 0.06269617f, 0.14572641f, -0.12427588f, 0.01161712f, 0.01613867f, -0.03785035f, 
    -0.11078957f, 0.00009070f, 0.00157765f, -0.45445818f, 0.01728035f, -0.00024047f, -0.00549308f, 0.11795131f, 
    -0.01635854f, 0.06379128f, 0.08703161f, 0.07675596f, 0.17327859f, 0.04398371f, -0.07919163f, 0.16343389f, 
    0.07606321f, -0.09496615f, 0.19238456f, 0.11805402f, -0.04214113f, 0.04376858f, 0.20809402f, 0.14282858f, 
    -0.62081307f, -0.04312858f, -0.12681350f, -0.07478981f, -0.10693222f, 0.06061866f, 0.07439131f, 0.18579191f, 
    -0.13225235f, 0.07637646f, 0.05057149f, 0.01974465f, -0.13806652f, 0.12950639f, -0.00617653f, -0.16768856f, 
    -0.07918085f, 0.13755520f, -0.03262548f, 0.03630656f, 0.02263568f, -0.11717237f, 0.02106656f, 0.18508133f, 
    -0.21821567f, -0.11489356f, 0.03060847f, -0.00837612f, 0.19888228f, -0.09335093f, 0.02208170f, 0.13363582f, 
    0.07555033f, -0.12842780f, 0.20343632f, 0.04940573f, -0.40100628f, -0.20512810f, 0.10660369f, -0.01876223f, 
    0.06881178f, 0.00524794f, 0.23980373f, 0.23350923f, -0.00849402f, -0.00302229f, 0.11630950f, 0.04209684f, 
    0.20857954f, 0.32529625f, 0.00413534f, 0.09772783f, 0.06669196f, 0.21533257f, 0.09421684f, 0.00023898f, 
    0.02885799f, -0.06789266f, -0.00076591f, 0.08163155f, 0.14104721f, 0.25346500f, -0.07149664f, 0.00702216f, 
    0.11729691f, 0.12164705f, 0.01436210f, 0.04101016f, -0.01060677f, 0.14383884f, 0.04531623f, 0.00463174f, 
    -0.14214227f, -0.08257557f, -0.09756614f, 0.01824547f, 0.11258717f, 0.06923916f, 0.11631887f, 0.07422818f, 
    0.02764659f, -0.02530501f, 0.03586011f, 0.17162600f, 0.06870398f, 0.06299981f, -0.02225384f, -0.09282613f, 
    -0.01009265f, -0.08279327f, -0.03804153f, 0.03183303f, -0.04863887f, -0.08394709f, 0.15575643f, 0.02006675f, 
    0.16243804f, 0.12742813f, 0.01479424f, -0.14743085f, 0.26104027f, 0.04056254f, 0.07019100f, 0.12308011f, 
    0.23182017f, 0.07709453f, -0.01469386f, 0.13724618f, 0.05817072f, -0.11213598f, 0.14898008f, 0.25179598f, 
    0.23612419f, 0.08161908f, -0.08246648f, 0.08540599f, 0.20500319f, 0.08815181f, 0.04032061f, 0.10886326f, 
    -0.14940716f, -0.10110215f, 0.08294041f, 0.32307738f, 0.16370431f, -0.01190508f, 0.03953874f, 0.01005890f, 
    0.06294549f, 0.15185529f, 0.03499869f, -0.00863086f, -0.02551099f, -0.31048369f, -0.04347109f, 0.22958927f, 
    0.01680167f, 0.02774073f, 0.12702966f, -0.00904703f, 0.07264073f, -0.02012444f, 0.03680027f, -0.03050765f, 
    0.02120043f, 0.18791738f, 0.08440626f, -0.15532355f, 0.10529667f, 0.05684603f, -0.01543858f, 0.12238091f, 
    -0.09605425f, 0.08910530f, 0.03588136f, 0.11631215f, 0.16237967f, -0.05198156f, -0.05621393f, 0.04325734f, 
    0.09600195f, 0.00700827f, 0.02052338f, 0.06066581f, -0.07088078f, -0.02708887f, 0.00029772f, -0.13894099f, 
    -0.02111950f, -0.02546774f, 0.19935295f, 0.05504509f, 0.06810243f, 0.02818726f, 0.13879824f, -0.02058503f, 
    0.03147455f, 0.03608457f, -0.01940807f, -0.02578640f, 0.10658525f, -0.03794525f, 0.00152583f, 0.19983774f, 
    -0.00372280f, 0.00356475f, -0.06423254f, -0.02570629f, -0.00415390f, -0.12796301f, -0.18965812f, 0.03199346f, 
    -0.09992170f, -0.04211436f, 0.04514536f, -0.10232031f, -0.05104956f, 0.01639330f, -0.07653999f, 0.18065223f, 
    0.18698016f, 0.05339625f, 0.13769297f, -0.03406474f, -0.02714493f, -0.33563259f, 0.16178285f, -0.06276318f, 
    0.13964404f, -0.06556187f, -0.08504345f, 0.03489732f, 0.01005985f, 0.00370147f, -0.14850159f, 0.00761599f, 
    -0.00486754f, 0.01011651f, -0.04666500f, -0.01109455f, 0.01608872f, -0.12468442f, 0.07228848f, -0.02921554f, 
    0.04178384f, -0.03075611f, 0.06455325f, 0.02265495f, -0.16240487f, 0.05533407f, -0.00950221f, 0.08777580f, 
    0.05520569f, -0.10442496f, -0.00330161f, 0.08104597f, 0.00887287f, 0.02226135f, -0.03004284f, 0.07433890f, 
    -0.26275566f, 0.01399315f, 0.07626916f, -0.18445803f, -0.07540999f, -0.07477877f, -0.08669051f, 0.06676237f, 
    -0.03197287f, 0.13173826f, -0.03745360f, 0.03965824f, 0.04758370f, 0.02640870f, 0.15875284f, 0.00501728f, 
    0.14503342f, 0.11930021f, 0.01659999f, -0.00997707f, 0.16921316f, 0.05229641f, 0.09951594f, 0.03314802f, 
    -0.11151171f, 0.06416294f, -0.13093156f, -0.26002839f, -0.07489137f, -0.13210221f, -0.05340504f, 0.00578018f, 
    -0.03001864f, -0.07659010f, 0.13694498f, -0.10962383f, -0.45010462f, 0.16689196f, -0.00432375f, 0.16044664f, 
    -0.10619754f, 0.11805716f, -0.09379995f, 0.01338860f, 0.16407280f, -0.16819349f, 0.08771354f, 0.03130901f, 
    -0.10366886f, 0.06494016f, 0.02450145f, 0.12621199f, 0.00463794f, 0.12318220f, -0.01056786f, 0.13822928f, 
    0.06899240f, -0.00410669f, -0.12690690f, 0.11734772f, 0.04347651f, 0.13216244f, -0.09725053f, -0.01601569f, 
    0.02141671f, 0.02576950f, -0.07171731f, 0.08670571f, 0.04107976f, -0.08844236f, -0.09505227f, 0.10881317f, 
    -0.05272281f, 0.15591696f, -0.11686540f, 0.19147222f, 0.02447189f, 0.04529950f, 0.17217486f, 0.09766139f, 
    0.13262008f, 0.01400856f, 0.04801839f, 0.06166040f, -0.06829832f, 0.03933034f, 0.00433366f, 0.10900553f, 
    -0.06175112f, 0.06043342f, 0.10192662f, -0.03126692f, 0.10834966f, 0.12926546f, 0.05071880f, -0.12610145f, 
    0.25571284f, 0.33828235f, 0.02099985f, 0.12596491f, -0.03846704f, 0.02840441f, 0.04983485f, 0.00092715f, 
    0.01653469f, 0.04294591f, 0.14867477f, -0.03236637f, -0.18832655f, 0.00419734f, 0.09922566f, -0.08161941f, 
    0.01786479f, 0.06943597f, 0.09892359f, 0.07315084f, -0.00656292f, -0.08921953f, 0.06180528f, -0.00938471f, 
    -0.11612231f, -0.07141631f, 0.12848900f, -0.03280772f, 0.06122215f, -0.07957180f, -0.04251524f, -0.15470535f, 
    -0.00524909f, -0.03726327f, -0.10614270f, 0.12639771f, -0.13560930f, -0.09752060f, 0.09120473f, 0.21544567f, 
    -0.00788666f, 0.09081864f, -0.00139192f, -0.04488668f, -0.06238003f, -0.01143951f, 0.29257658f, -0.02943689f, 
    0.32497048f, -0.07264324f, 0.27594650f, 0.29487768f, 0.04087736f, -0.03005131f, -0.01497273f, 0.02806664f, 
    0.05070338f, 0.12433733f, 0.04088294f, 0.10422780f, 0.44896677f, -0.22646046f, 0.25016171f, 0.23008393f, 
    0.25888368f, 0.10570502f, 0.05683915f, 0.03532265f, 0.00448089f, 0.03723647f, 0.06068090f, 0.02299595f, 
    0.27679384f, 0.11773840f, -0.12436941f, -0.08413383f, -0.08721588f, -0.00548328f, -0.02453083f, -0.08039845f, 
    -0.14234501f, 0.07838087f, 0.07492506f, 0.00699133f, 0.01916743f, 0.08883212f, -0.11121321f, -0.06538368f, 
    -0.04377219f, 0.12893857f, 0.00865999f, -0.10426283f, 0.03212366f, 0.00415393f, -0.06164827f, 0.01134771f, 
    0.23888013f, -0.17084709f, 0.09424366f, -0.00105076f, 0.03435215f, -0.17814633f, -0.00888765f, -0.02096479f, 
    0.16064253f, 0.07933427f, -0.04308053f, -0.06646808f, -0.14425664f, 0.16265023f, 0.05955115f, -0.20583200f, 
    -0.01988315f, 0.07784063f, 0.18128467f, -0.10344874f, 0.12765795f, 0.05097916f, -0.03893587f, 0.00169993f, 
    0.11232962f, -0.07585704f, -0.01605395f, -0.12676437f, -0.03442014f, -0.00674416f, -0.07897327f, 0.03156310f, 
    -0.00407091f, 0.11323451f, 0.13385558f, -0.06297190f, 0.13960557f, -0.01432172f, 0.03924943f, -0.07023525f, 
    0.16527338f, 0.00708723f, 0.08753117f, 0.07514438f, -0.05605882f, 0.11635167f, 0.10732641f, 0.04025733f, 
    -0.10645501f, -0.10957990f, -0.12883727f, -0.00031145f, -0.06940713f, -0.08858672f, -0.15901855f, -0.06041393f, 
    -0.13567331f, 0.07135646f, 0.07362378f, 0.05433980f, -0.14529940f, -0.04388467f, 0.14805992f, -0.06343552f, 
    0.09701429f, 0.11044565f, 0.00518220f, 0.01660439f, 0.03302656f, -0.03510356f, 0.11229287f, -0.04118659f, 
    -0.18842503f, 0.23045373f, 0.03408399f, 0.11354410f, -0.04204562f, 0.12836190f, -0.21571881f, 0.04000939f, 
    0.05835490f, -0.07066869f, -0.00649648f, 0.07250620f, -0.04645341f, 0.24944583f, 0.02897886f, 0.01723104f, 
    -0.01497488f, 0.07012995f, 0.15735443f, 0.00102594f, 0.05778342f, 0.14256124f, 0.02927896f, 0.07744646f, 
    -0.00368455f, -0.18491118f, 0.19444752f, 0.12418514f, 0.21122248f, -0.13011429f, 0.02247860f, 0.05069915f, 
    0.14134887f, 0.04856795f, -0.05975927f, 0.02300187f, -0.06904698f, 0.26596555f, 0.10262174f, -0.18800105f, 
    0.08022695f, 0.06597171f, 0.11070648f, 0.04668262f, 0.04298564f, 0.15659313f, 0.06345967f, -0.05871558f, 
    -0.18461828f, -0.22687183f, 0.11968219f, 0.23455097f, 0.07815234f, -0.01627952f, 0.00724823f, 0.04475183f, 
    0.01219438f, -0.01650868f, 0.01883312f, 0.06594165f, 0.10658874f, -0.02907684f, 0.28171733f, 0.33957946f, 
    0.01649879f, -0.01577183f, 0.07364476f, -0.04829150f, 0.05471466f, -0.04450254f, -0.04126761f, 0.06154190f, 
    -0.28917950f, 0.02193084f, 0.19973215f, 0.16227597f, -0.11620755f, -0.04235937f, -0.11992059f, 0.04325671f, 
    0.04881341f, -0.09321064f, -0.00578085f, 0.08632850f, -0.18452273f, 0.12552135f, 0.18251482f, -0.02637294f, 
    -0.06782630f, 0.00673883f, -0.02719679f, -0.04957006f, -0.04135422f, 0.00774760f, -0.00345992f, -0.04963132f, 
    -0.31531805f, 0.27621281f, 0.02713460f, -0.03239828f, -0.07727438f, 0.06465609f, 0.13422765f, 0.12539588f, 
    0.00260960f, 0.02517493f, 0.13422352f, -0.01873499f, -0.24321404f, 0.09599533f, 0.14216568f, -0.07507278f, 
    0.04043603f, 0.05634274f, 0.17721416f, 0.05543713f, -0.10085176f, 0.06256768f, 0.01130699f, -0.09420279f, 
    -0.06192799f, 0.15394737f, 0.13706273f, 0.02462060f, -0.14249747f, 0.05886811f, 0.14962676f, 0.02552529f, 
    0.03312427f, 0.10692783f, 0.02703236f, 0.15103547f, 0.01379841f, -0.00697846f, -0.16336459f, 0.04822671f, 
    0.08311108f, 0.09865046f, -0.08272526f, 0.15564883f, -0.08071490f, -0.00996517f, 0.00411557f, -0.05650805f, 
    0.06172927f, 0.14375955f, 0.15106176f, -0.07319625f, -0.03182631f, -0.06965194f, 0.01250542f, 0.05895240f, 
    -0.07608891f, 0.00000390f, 0.12725757f, 0.08117539f, -0.14292073f, -0.22379658f, 0.15851328f, -0.10605988f, 
    0.01366551f, 0.01495234f, 0.13024722f, 0.00889701f, 0.00068325f, -0.06129252f, 0.07719902f, -0.08121968f, 
    0.07007823f, 0.09187888f, 0.25782964f, 0.11681441f, 0.08041221f, 0.06282779f, 0.06590114f, -0.02367152f, 
    -0.04650719f, -0.03327366f, -0.07718731f, 0.06230218f, -0.18035431f, -0.08654286f, 0.22839783f, 0.04362633f, 
    -0.07196315f, -0.01330917f, 0.14831255f, 0.07434311f, 0.07440374f, 0.09135714f, 0.06492776f, 0.06006612f, 
    -0.04104212f, 0.03476212f, 0.10030980f, -0.09499474f, 0.07052609f, -0.02537019f, 0.16225250f, 0.03107178f, 
    0.10893203f, 0.05140182f, 0.00975843f, -0.02059895f, -0.33795556f, -0.09346240f, -0.00733549f, 0.00118807f, 
    0.13415633f, -0.02286529f, 0.03721983f, -0.01670967f, -0.07734992f, 0.02189561f, 0.08970024f, -0.19360484f, 
    0.28889102f, -0.08416219f, -0.01654373f, 0.05340642f, 0.19834211f, 0.08256032f, 0.11075899f, -0.05598107f, 
    0.02290453f, 0.00762505f, 0.11134372f, -0.08970077f, 0.01169272f, 0.16302620f, -0.22698286f, -0.01920639f, 
    0.35691369f, 0.08764832f, -0.00885707f, 0.20702809f, 0.17519245f, -0.05435920f, 0.06608391f, 0.02661254f, 
    -0.02090698f, 0.25935546f, 0.05886164f, 0.17095505f, -0.11572453f, -0.01342282f, 0.13200344f, 0.01836408f, 
    -0.12306317f, 0.04498334f, -0.01378828f, 0.03694118f, 0.02634810f, -0.11836957f, 0.04897097f, 0.03935301f, 
    0.02659255f, 0.14872837f, -0.00987924f, 0.07965264f, 0.08222495f, -0.06136688f, 0.07022966f, 0.03621272f, 
    0.32914844f, -0.01702640f, 0.19167857f, -0.03213845f, 0.08434542f, 0.06424856f, 0.10311694f, -0.08475024f, 
    0.04229230f, 0.08171593f, 0.01687854f, 0.05462715f, 0.26317334f, -0.01553723f, 0.05941954f, 0.29737809f, 
    0.03369562f, 0.08420144f, 0.12628199f, -0.01760834f, 0.06000188f, -0.01343971f, 0.04065242f, -0.04219256f, 
    0.22035334f, -0.00677855f, 0.00646468f, -0.01502394f, 0.06697895f, 0.00203173f, -0.00212575f, -0.00503907f, 
    -0.00859963f, 0.01811686f, 0.02163861f, 0.02246275f, -0.09216803f, 0.15638776f, 0.00056322f, 0.02200908f, 
    0.05521793f, 0.10567953f, 0.00338030f, -0.03906833f, 0.00719895f, -0.00307917f, -0.00671802f, 0.00822403f, 
    0.18281522f, -0.03953601f, -0.06690267f, 0.28533390f, 0.05837057f, -0.00284975f, -0.12515141f, 0.03395102f, 
    0.01773730f, 0.05144290f, -0.06457644f, 0.02368181f, -0.05948129f, 0.11441927f, -0.05277301f, -0.07063038f, 
    0.11796547f, 0.11174694f, -0.04734227f, 0.04090979f, -0.00214783f, 0.04346716f, -0.00744971f, -0.05248360f, 
    0.17306912f, -0.05145545f, 0.16116546f, -0.11146090f, -0.16293724f, -0.02547914f, -0.07020059f, 0.05134067f, 
    0.06124607f, -0.01363575f, 0.08911178f, -0.16856430f, -0.08099634f, 0.10648759f, -0.24864896f, 0.12660855f, 
    0.18183725f, 0.21020272f, -0.05529236f, -0.03088197f, 0.06011093f, 0.13380301f, -0.00055611f, -0.03432334f, 
    -0.21547522f, -0.06187911f, 0.23069854f, 0.10464358f, -0.22968678f, -0.09409118f, -0.11471144f, 0.03660376f, 
    0.00788868f, -0.11043717f, -0.12520756f, 0.02139934f, -0.04518393f, 0.06461909f, 0.20514987f, -0.15307564f, 
    -0.14156820f, 0.04820426f, 0.01803090f, -0.08048250f, -0.00506280f, -0.08269355f, 0.08034515f, 0.00697821f, 
    -0.04790463f, -0.21673231f, 0.19363831f, 0.01449657f, -0.13074897f, -0.04999807f, 0.18088946f, 0.03360425f, 
    -0.17753124f, 0.03443803f, -0.00444229f, -0.03096472f, -0.21393219f, 0.08698592f, 0.08563662f, 0.01012457f, 
    -0.00588949f, 0.03175722f, 0.10688233f, 0.01800169f, 0.01316515f, 0.00602667f, 0.06750588f, 0.08924973f, 
    -0.32143578f, 0.21790038f, -0.13758920f, 0.02545281f, 0.17915471f, 0.09260946f, 0.05695585f, 0.06286790f, 
    -0.04841453f, -0.06365671f, 0.03105286f, 0.05924564f, -0.14300634f, 0.11782911f, 0.06276003f, -0.01103256f, 
    0.15535896f, 0.11962065f, 0.11615597f, 0.08695591f, -0.00478063f, 0.15361990f, 0.07660067f, -0.01273937f, 
    0.02879489f, -0.00651565f, -0.02259743f, -0.01898080f, -0.02681600f, 0.02202061f, 0.04278012f, -0.03599172f, 
    -0.04382344f, -0.00356721f, 0.03643329f, -0.01425936f, -0.00743834f, 0.03258033f, -0.03888169f, 0.03313811f, 
    -0.02564250f, 0.01207463f, 0.01216609f, -0.02427640f, -0.00102440f, -0.00086173f, 0.01310630f, -0.00738112f, 
    -0.02604105f, -0.05299044f, 0.03898060f, -0.03397866f, -0.01793901f, 0.00719725f, -0.03125603f, -0.01866390f, 
    -0.02088862f, -0.04474111f, -0.05841985f, -0.03852498f, -0.00182098f, -0.05859432f, -0.00520646f, -0.01070422f, 
    0.02759225f, 0.00254626f, -0.02345117f, 0.01740238f, -0.01639738f, -0.04144734f, 0.03583786f, -0.03723007f, 
    -0.03543006f, -0.04466137f, 0.00593912f, 0.00445359f, -0.03966057f, -0.00912286f, -0.02185107f, 0.03901639f, 
    -0.00877228f, -0.00299174f, 0.02067550f, -0.03861883f, 0.00737264f, 0.03513867f, -0.00853836f, -0.05959991f, 
    0.02238916f, -0.04026375f, -0.01159809f, 0.01122185f, -0.05014424f, -0.03536135f, -0.05007313f, -0.03615375f, 
    0.02282419f, 0.02251290f, -0.03436565f, 0.00452135f, 0.01006034f, -0.00134349f, 0.02783926f, 0.01522632f, 
    -0.00050921f, -0.00956161f, -0.02801610f, -0.02751053f, -0.01391119f, -0.03390589f, -0.04380427f, -0.02122647f, 
    -0.02178435f, 0.01992022f, 0.00954573f, -0.04690405f, -0.00334201f, -0.02387174f, -0.01763277f, 0.03213960f, 
    0.02723680f, 0.03242380f, 0.03676989f, 0.03999483f, 0.02182242f, -0.01988477f, -0.02971315f, 0.01895787f, 
    -0.01009050f, -0.00186495f, -0.02378047f, -0.01088325f, 0.02995003f, 0.01091217f, -0.00890241f, 0.03977770f, 
    -0.02152809f, 0.00286823f, 0.02596243f, 0.03100893f, 0.02827246f, -0.00503945f, -0.04264249f, 0.00720932f, 
    -0.03103289f, -0.03032777f, 0.02205658f, -0.00058958f, 0.01476662f, -0.01827528f, 0.03199319f, 0.00207836f, 
    0.02980906f, -0.02940315f, -0.00255420f, -0.02947053f, -0.00305270f, -0.04106584f, -0.04828957f, 0.03452742f, 
    0.03850031f, -0.02876240f, -0.01861379f, 0.01396686f, 0.02586031f, 0.02102186f, -0.03774633f, -0.02877797f, 
    0.02655583f, -0.02703636f, -0.00731960f, -0.01064759f, -0.00506615f, 0.04379549f, 0.02257008f, -0.02585726f, 
    -0.03140461f, 0.03229887f, -0.01966957f, 0.01023091f, 0.01479504f, -0.04008085f, 0.02771872f, 0.00524867f, 
    -0.03431398f, 0.00338512f, -0.04329628f, -0.00343647f, 0.02393008f, -0.01319727f, -0.01444267f, -0.03644319f, 
    -0.04576790f, -0.04525800f, -0.04124896f, 0.00958540f, -0.02782529f, -0.01499748f, 0.02089790f, 0.02163212f, 
    -0.06035108f, -0.05075055f, 0.03721183f, -0.04684697f, 0.04050902f, 0.03788910f, -0.01251486f, -0.02104567f, 
    0.00390813f, -0.02778806f, -0.00157740f, -0.01075938f, -0.04599954f, 0.00358786f, 0.03067396f, -0.04211853f, 
    -0.01788819f, 0.02735374f, -0.01109329f, -0.05822342f, 0.03374782f, -0.05514744f, -0.03065327f, -0.05384595f, 
    0.03991900f, 0.00954713f, -0.04609732f, 0.04139383f, 0.03433920f, 0.01314505f, -0.04440207f, -0.03330975f, 
    -0.02868869f, -0.03937971f, 0.04514798f, 0.01495929f, 0.04128425f, -0.03892368f, 0.01349233f, -0.01386096f, 
    -0.00941937f, 0.00188447f, 0.03013003f, -0.01193954f, 0.04382940f, -0.01696033f, 0.02439798f, 0.03829762f, 
    0.03036270f, -0.04955598f, -0.06080599f, -0.03286907f, -0.02644014f, 0.03779163f, -0.05132306f, -0.00143982f, 
    0.00755987f, 0.01408425f, 0.02206911f, -0.02317323f, -0.03686184f, -0.04450650f, -0.04143674f, 0.03998761f, 
    -0.00538149f, 0.03548773f, -0.02647250f, 0.01120610f, 0.01871977f, 0.01600065f, -0.05039863f, -0.02708240f, 
    -0.05394652f, 0.00200861f, -0.04472665f, -0.01751818f, -0.02825956f, 0.03831786f, 0.00433230f, -0.03900189f, 
    -0.04564935f, -0.05456296f, -0.01909147f, -0.00474296f, 0.02621485f, -0.05611011f, 0.01780235f, -0.01016227f, 
    0.03159718f, 0.03465191f, 0.04674712f, 0.04380732f, 0.00444994f, -0.04183152f, -0.00754189f, -0.00305671f, 
    -0.04748312f, 0.03755259f, -0.02384828f, 0.03819712f, 0.00663157f, -0.02440685f, -0.04511596f, -0.05761668f, 
    0.02746981f, -0.03325440f, 0.00270394f, -0.04815518f, -0.04526273f, 0.00770582f, 0.02313286f, 0.03057884f, 
    0.02765000f, -0.02832814f, -0.00338173f, 0.03522575f, -0.03684539f, -0.03385137f, 0.03962096f, -0.03005796f, 
    0.02066659f, 0.03128430f, 0.00865750f, -0.03842940f, -0.03834553f, -0.03799457f, -0.03106937f, 0.02320710f, 
    -0.03065772f, -0.04338808f, -0.05150545f, -0.01857024f, -0.02291518f, -0.05900315f, -0.00821388f, 0.02745940f, 
    0.03539500f, -0.00324316f, -0.03846147f, 0.00054070f, -0.03729478f, -0.01857816f, 0.01233484f, -0.01687344f, 
    0.04054140f, -0.02230563f, -0.00063277f, -0.05198430f, 0.03459733f, -0.05257815f, -0.03565409f, 0.02141314f, 
    -0.01865709f, -0.02266294f, 0.01382898f, -0.06022887f, -0.04226228f, -0.02151197f, 0.03532638f, -0.00313262f, 
    0.02885645f, -0.04950320f, -0.01876811f, 0.03797651f, -0.03715631f, -0.05366135f, -0.05880298f, -0.01999283f, 
    -0.04301586f, 0.00313619f, -0.00978434f, -0.00921033f, -0.05915326f, 0.01626450f, -0.02496514f, 0.01529419f, 
    -0.04632585f, 0.00675029f, 0.03189706f, -0.05213955f, 0.03553852f, -0.00840918f, -0.05427609f, -0.01962185f, 
    0.02674269f, 0.02915403f, 0.03591271f, -0.03951603f, 0.00500933f, 0.03377358f, -0.02940701f, 0.03343352f, 
    -0.02352437f, -0.01590674f, 0.04061540f, 0.01972192f, -0.00427628f, -0.04659471f, 0.03198980f, -0.00379108f, 
    -0.02937939f, -0.02209186f, -0.04645061f, -0.05460899f, 0.03643951f, -0.03173069f, -0.02149760f, -0.02752702f, 
    -0.03153552f, -0.03537033f, 0.03887312f, 0.03458472f, 0.03757421f, -0.04822127f, 0.04363761f, -0.00590143f, 
    -0.01463718f, -0.05567662f, -0.01462276f, 0.02353811f, -0.01248670f, 0.03709603f, 0.02625567f, -0.04018691f, 
    -0.00485690f, -0.02624654f, -0.04956478f, 0.04221474f, -0.01216411f, 0.00937125f, -0.04789681f, -0.04322824f, 
    0.00369596f, 0.00726054f, -0.02890015f, -0.05626282f, -0.04104294f, -0.01401357f, -0.00890846f, 0.03744885f, 
    -0.02354674f, -0.04313245f, 0.03421381f, 0.01882941f, 0.01323888f, 0.00205364f, -0.03122933f, -0.04545296f, 
    -0.04036076f, 0.02448498f, -0.05455697f, -0.00895672f, -0.01888062f, -0.04273646f, 0.03797240f, 0.01217735f, 
    -0.04674705f, 0.03617381f, 0.01594421f, -0.02951709f, 0.02023886f, -0.02048378f, 0.00746457f, 0.02702169f, 
    -0.04739824f, 0.04076461f, -0.04570374f, 0.03816549f, 0.01987504f, -0.03160928f, 0.01260813f, 0.01334308f, 
    -0.03159491f, -0.01819927f, -0.02721144f, -0.04415575f, -0.05561858f, -0.04885233f, -0.03892264f, -0.03719689f, 
    -0.00956507f, 0.03705582f, -0.00274374f, 0.02501700f, -0.04664505f, -0.00796609f, 0.02089421f, 0.00271785f, 
    -0.05176061f, 0.03280320f, 0.00108436f, -0.01845507f, 0.00081720f, 0.02491114f, -0.00347007f, 0.02285479f, 
    0.04484520f, 0.01554810f, 0.04331136f, -0.03759047f, 0.02830566f, -0.00512339f, -0.00720349f, -0.00086533f, 
    -0.04962961f, 0.00620196f, -0.00606347f, 0.00965642f, 0.04440028f, 0.00138111f, -0.01480734f, -0.05233438f, 
    0.03865175f, -0.00120770f, 0.02796285f, 0.02094941f, -0.01137982f, 0.00349664f, -0.03724620f, -0.02745969f, 
    -0.00172815f, 0.01900226f, 0.02910358f, -0.02785354f, 0.02738963f, 0.00600360f, 0.02195485f, 0.01506074f, 
    -0.03370908f, -0.04146431f, -0.05047056f, -0.05612925f, -0.02963357f, -0.00746856f, -0.01127475f, -0.01781078f, 
    0.01479561f, -0.04086101f, -0.00070747f, -0.01971715f, -0.04757578f, 0.04039797f, -0.00628657f, -0.03484792f, 
    0.03970102f, -0.00055778f, 0.01486168f, 0.03166076f, -0.01896918f, -0.03084539f, -0.02672872f, -0.03338572f, 
    -0.03484780f, -0.04671335f, -0.04127105f, -0.05687607f, -0.00060642f, -0.04745714f, 0.03075224f, 0.04057565f, 
    0.02700922f, -0.01566529f, -0.04158658f, -0.03594408f, 0.04484692f, -0.03567271f, -0.03305905f, -0.01468890f, 
    0.01445874f, 0.03588156f, 0.01515743f, 0.02329046f, -0.03926711f, 0.03154410f, 0.01733352f, 0.02965599f, 
    0.04155421f, 0.01753649f, 0.02843432f, 0.03118530f, -0.04058335f, -0.04198266f, -0.00559105f, 0.03687001f, 
    -0.00428103f, -0.04709942f, -0.00981602f, -0.02082341f, -0.03202005f, -0.02233989f, -0.03484840f, 0.02432137f, 
    -0.03324621f, -0.04164016f, -0.04763755f, -0.00180776f, -0.02293470f, 0.01206825f, -0.04690046f, 0.01389372f, 
    0.04282083f, -0.03499793f, 0.01267851f, -0.02713775f, -0.02942694f, -0.01158800f, -0.01017923f, -0.02332016f, 
    0.03537314f, -0.03551738f, -0.00955939f, 0.04243176f, -0.03794853f, -0.01306401f, 0.03170514f, 0.00255471f, 
    -0.03665445f, 0.02904838f, -0.02138899f, 0.00285179f, 0.00285976f, -0.01443857f, 0.02930347f, 0.01561682f, 
    0.03247143f, -0.05207379f, 0.01512181f, -0.01589607f, 0.04103982f, 0.02043867f, -0.04130590f, -0.00555409f, 
    -0.00434349f, -0.04758362f, 0.03018864f, 0.02488744f, 0.01986277f, -0.05513881f, -0.00672573f, 0.02019015f, 
    0.04432295f, -0.02626085f, -0.01429173f, 0.03213499f, -0.05620890f, -0.05045776f, 0.02295155f, 0.01928091f, 
    0.04445447f, 0.02150445f, -0.01340242f, -0.02720249f, 0.03656932f, -0.01343891f, -0.05282623f, -0.03855117f, 
    0.01763717f, -0.04449265f, -0.00502699f, 0.03833711f, -0.04890784f, 0.02014653f, 0.03976803f, -0.04934513f, 
    -0.04817812f, -0.03041151f, -0.05160845f, -0.03228458f, -0.01811459f, -0.05023423f, -0.02266687f, -0.03246535f, 
    -0.05241605f, 0.00822204f, -0.04653795f, -0.01202616f, -0.00232654f, 0.03860686f, -0.01127350f, 0.04184937f, 
    -0.02994891f, 0.02412898f, -0.02389903f, 0.02474032f, -0.03270456f, -0.04248404f, -0.04678270f, -0.03843733f, 
    -0.05374425f, 0.02931680f, 0.02308313f, 0.02422829f, -0.05254243f, 0.01530229f, 0.02567835f, 0.01820005f, 
    0.00293553f, -0.03858657f, -0.02338104f, 0.04408502f, -0.05297371f, 0.03111268f, -0.04020436f, -0.03398572f, 
    0.01960879f, -0.04283499f, -0.04332284f, -0.04623036f, 0.03819393f, -0.04624341f, 0.01202653f, -0.04143136f, 
    -0.01747899f, 0.01444850f, 0.01292282f, -0.02988738f, 0.04243262f, 0.03922207f, 0.01500719f, -0.01969448f, 
    0.01357962f, -0.00867703f, 0.03278944f, -0.00199391f, -0.03387970f, 0.02000615f, 0.03298992f, -0.05493503f, 
    0.01103013f, -0.02610360f, 0.04483196f, -0.05534920f, -0.04437693f, 0.02143954f, -0.01563578f, -0.00215223f, 
    -0.03477710f, -0.00693617f, 0.01956915f, -0.01022631f, -0.00070450f, 0.04147477f, -0.00847293f, -0.01081593f, 
    -0.03289589f, -0.01207247f, 0.02864556f, -0.02399775f, -0.03469970f, -0.04980059f, -0.03371701f, 0.03096828f, 
    -0.00281535f, -0.04272658f, 0.01878530f, 0.03072933f, -0.02708664f, -0.03077284f, -0.01793703f, 0.02943638f, 
    -0.01181311f, 0.00698770f, -0.01602476f, -0.02619223f, 0.03932696f, -0.00591342f, -0.03226910f, -0.01096814f, 
    -0.04923747f, -0.04993323f, -0.00271229f, -0.04905682f, -0.00314031f, 0.01153709f, -0.01173157f, -0.01286849f, 
    -0.05465646f, -0.03572082f, 0.02392006f, -0.01258041f, 0.00664263f, -0.05215348f, -0.01070945f, -0.01432014f, 
    -0.02074785f, 0.00796882f, -0.04724020f, 0.02049088f, 0.04279361f, -0.00004511f, 0.02748876f, -0.02253165f, 
    0.12078367f, -0.26432246f, 0.04118531f, 0.06510288f, 0.03457075f, 0.00364652f, 0.11352524f, -0.10541791f, 
    -0.00373849f, 0.01568433f, 0.03775926f, 0.09411853f, 0.16382922f, 0.03254164f, 0.12543514f, 0.26863649f, 
    -0.02978512f, -0.02532078f, -0.01496674f, -0.09212711f, 0.05663265f, -0.13842592f, -0.03452515f, -0.03317913f, 
    -0.21573217f, -0.07624797f, -0.01438581f, 0.14371823f, -0.06804469f, -0.02712722f, -0.12109286f, 0.01489440f, 
    0.14481898f, 0.03392896f, 0.02727893f, 0.07408776f, 0.39663213f, -0.04693414f, 0.05082802f, 0.16750720f, 
    0.06348502f, 0.12437421f, -0.04706601f, 0.04095295f, 0.00164648f, 0.02691354f, 0.01117640f, 0.04602496f, 
    -0.19200836f, 0.00294428f, 0.01071312f, 0.07124487f, 0.14809287f, 0.00900392f, 0.08497120f, 0.09611455f, 
    -0.00377007f, -0.03714605f, 0.07194377f, 0.03405107f, 0.14672643f, 0.02259007f, -0.00978796f, 0.04538628f, 
    0.15888013f, 0.05232317f, 0.17189573f, 0.09762368f, 0.05450958f, 0.08485140f, -0.00034174f, 0.08668368f, 
    0.02101730f, 0.31979114f, 0.19757655f, 0.05338863f, -0.02564296f, 0.03883079f, 0.05114616f, 0.10012371f, 
    0.10561065f, -0.00400855f, -0.13908961f, 0.05438934f, 0.11462635f, 0.10548837f, 0.09350366f, 0.05936688f, 
    0.11984912f, 0.18448032f, 0.01341128f, 0.12616457f, 0.08045088f, 0.06552290f, 0.08130839f, 0.02500423f, 
    0.09400018f, 0.30219957f, 0.03050235f, -0.18853629f, 0.11858170f, -0.05054961f, -0.02257328f, 0.00329764f, 
    0.04272942f, -0.10433469f, 0.13888118f, -0.04898795f, -0.09993192f, 0.09229826f, 0.11254480f, 0.09082732f, 
    -0.04773425f, 0.05727118f, 0.10511273f, -0.06772913f, 0.10219613f, -0.02306064f, 0.14836814f, -0.02805195f, 
    -0.28006294f, -0.13233805f, -0.04986606f, 0.05480359f, 0.03715679f, 0.07610223f, -0.05398974f, 0.02597599f, 
    0.06514186f, -0.02303736f, -0.10743337f, 0.15421228f, -0.10362785f, 0.05778492f, -0.05037878f, 0.08545143f, 
    0.00841523f, -0.04892745f, 0.01865271f, 0.10178032f, 0.11478171f, -0.02434168f, 0.04190232f, -0.07450527f, 
    -0.02460108f, 0.09437991f, -0.10396390f, 0.11647177f, 0.06808125f, -0.04538560f, 0.11872877f, 0.09481142f, 
    0.13579634f, 0.07093569f, 0.14270400f, 0.00197569f, -0.14851862f, 0.08720620f, -0.01955413f, 0.07571975f, 
    0.06478378f, -0.02811133f, 0.07269785f, -0.08167835f, -0.03048477f, -0.03727411f, 0.20349695f, -0.12610130f, 
    0.02828579f, 0.09775139f, -0.13621978f, 0.27024862f, 0.03018739f, 0.01099390f, -0.00970680f, -0.00048016f, 
    -0.01059687f, 0.05680417f, 0.11155786f, 0.02537185f, -0.08559960f, 0.06438273f, 0.15112194f, 0.23672147f, 
    0.04032549f, -0.02246299f, 0.05284808f, 0.14019525f, -0.01837844f, -0.08234271f, 0.00881889f, -0.02700473f, 
    0.13286097f, 0.13634959f, 0.15386151f, 0.02108585f, 0.15596361f, 0.09005798f, 0.12866290f, -0.05868217f, 
    -0.02681286f, 0.04427743f, -0.06837407f, 0.14534782f, -0.14276986f, -0.10172172f, -0.11609702f, 0.05221010f, 
    0.02675216f, 0.04691232f, -0.02869957f, -0.00334826f, 0.04010743f, -0.05073624f, 0.15788189f, 0.02475852f, 
    0.52955145f, -0.10177519f, 0.15868618f, 0.27531210f, 0.01109888f, 0.06255148f, 0.19645587f, 0.03791735f, 
    0.01498330f, 0.20503035f, 0.08138706f, 0.03548116f, 0.33581951f, -0.07517407f, 0.10550687f, 0.02649782f, 
    0.06489910f, 0.05914510f, 0.09837283f, 0.07656872f, 0.06987556f, 0.03901638f, 0.11818265f, 0.04778882f, 
    0.18973370f, 0.03822131f, -0.09883086f, 0.05238015f, 0.15697418f, -0.11872286f, 0.08394810f, 0.06135521f, 
    0.00218295f, 0.05829926f, 0.19697742f, 0.14885056f, -0.09880918f, 0.11997386f, 0.09540995f, 0.22051740f, 
    0.14229512f, -0.02843717f, 0.05311343f, 0.05915965f, 0.05708096f, -0.01828591f, 0.07167578f, 0.09966872f, 
    0.10725045f, -0.07080387f, -0.03897556f, 0.06335343f, -0.01016248f, -0.14097366f, 0.01650804f, 0.01348653f, 
    0.14132701f, -0.06720761f, -0.03598180f, 0.03673670f, -0.08796896f, 0.04924858f, 0.09616151f, -0.26641074f, 
    0.09095617f, 0.17399997f, -0.04655729f, -0.01487092f, 0.05516243f, 0.02206274f, -0.04415948f, 0.03780330f, 
    0.28862017f, 0.17110024f, -0.00424069f, 0.09700289f, -0.00211911f, 0.02669211f, -0.03336237f, 0.04506778f, 
    0.08719568f, 0.05218272f, 0.16681182f, -0.08742726f, 0.14482546f, 0.04785632f, 0.02527003f, -0.07772226f, 
    0.06657320f, 0.10340907f, -0.08219571f, 0.06850330f, -0.04649147f, 0.05633589f, 0.05280080f, -0.01853501f, 
    -0.06792133f, 0.06205654f, 0.10369074f, -0.00426339f, 0.00754219f, -0.04530001f, -0.10955976f, 0.00696769f, 
    -0.00179333f, 0.02706368f, 0.03905796f, 0.05451015f, 0.09859836f, -0.00930082f, 0.17219454f, 0.00123249f, 
    0.10976052f, 0.12466846f, -0.02762711f, -0.07573952f, -0.03306593f, -0.01087414f, 0.09957214f, 0.03012095f, 
    0.02216438f, 0.17537078f, 0.01798631f, 0.07442943f, 0.02569219f, 0.00261555f, 0.09369875f, -0.12321855f, 
    0.04035873f, 0.00386919f, 0.04238270f, -0.05655053f, -0.30949867f, 0.20167524f, 0.24572514f, 0.25401050f, 
    0.06382184f, 0.01141519f, 0.05499254f, -0.01550715f, 0.07484910f, 0.07965816f, 0.05126628f, 0.12840174f, 
    0.05557692f, -0.00303939f, 0.01312694f, -0.16222169f, 0.11336646f, 0.08740754f, -0.03041856f, 0.15724906f, 
    0.01941637f, 0.02408186f, 0.01010149f, 0.04859832f, -0.17169696f, 0.28579861f, 0.21040559f, 0.23807852f, 
    0.05831853f, 0.13958339f, 0.07361213f, 0.13439661f, -0.04788935f, 0.13530640f, 0.14511889f, -0.04010845f, 
    0.44529378f, 0.12124921f, 0.05396876f, -0.23616311f, -0.06297815f, -0.06268651f, 0.01067093f, -0.01432687f, 
    0.03757095f, 0.02758798f, 0.03022821f, 0.07219481f, -0.09804208f, -0.04674608f, -0.22319393f, -0.05817873f, 
    0.04729423f, -0.08158773f, -0.12554754f, 0.01620674f, 0.03216154f, 0.07640380f, 0.03453673f, -0.08296148f, 
    0.25593707f, -0.12683427f, -0.22813800f, 0.00031828f, 0.08288909f, 0.05808272f, 0.10888475f, 0.02361955f, 
    0.02012272f, 0.11505140f, 0.06742904f, 0.01059383f, 0.44973725f, -0.37551379f, -0.07747886f, 0.04729555f, 
    0.23634857f, 0.05529836f, 0.00509098f, 0.08527900f, -0.01016118f, 0.14525552f, -0.06900647f, 0.01615529f, 
    0.38680351f, -0.28083345f, -0.02274089f, -0.14020447f, 0.14412209f, -0.07580689f, -0.16702184f, 0.02371286f, 
    0.09799895f, 0.03435218f, 0.02361719f, -0.02521256f, 0.28829294f, -0.09582095f, -0.09758021f, 0.05930424f, 
    0.09468213f, -0.02463071f, -0.15707234f, -0.06704172f, 0.20099883f, -0.09641453f, -0.07837321f, 0.15045965f, 
    0.01539596f, 0.08165839f, 0.10108872f, -0.24392527f, 0.27682281f, 0.07144051f, -0.02657618f, 0.01611760f, 
    -0.06144839f, 0.02418147f, 0.05511747f, -0.01813285f, -0.02474176f, -0.08838379f, 0.08782343f, -0.03237377f, 
    -0.03011274f, 0.08467934f, 0.22803058f, -0.17327584f, 0.17515971f, 0.02888916f, 0.07507372f, 0.08523674f, 
    0.01148290f, 0.10572896f, -0.09082481f, -0.22227527f, 0.17398100f, 0.05609181f, -0.03433254f, 0.04163776f, 
    0.06807826f, 0.01580646f, -0.01151633f, 0.09651005f, -0.12772833f, 0.42936426f, -0.07660439f, 0.37316921f, 
    0.09351669f, 0.10451107f, 0.01521482f, -0.04641415f, 0.03849622f, -0.05014008f, -0.02897735f, 0.02912929f, 
    -0.12359416f, -0.01327871f, -0.24200797f, 0.00304828f, -0.01150304f, -0.00695467f, 0.00797967f, 0.12712494f, 
    0.07639430f, -0.03444714f, -0.01594813f, 0.19505560f, 0.08723685f, -0.00521003f, -0.24159449f, 0.13110423f, 
    0.03849263f, -0.01751002f, -0.00226071f, -0.01180185f, -0.01266488f, -0.05395091f, 0.04401727f, 0.11035358f, 
    -0.01573168f, -0.07898329f, -0.14759219f, 0.26035368f, 0.05061664f, 0.11341560f, 0.02425938f, -0.00180508f, 
    0.06096429f, 0.05294553f, 0.06802456f, 0.10734222f, 0.28590986f, -0.02571660f, 0.03546493f, 0.22604108f, 
    -0.04234817f, 0.02696926f, 0.08947781f, 0.05048780f, 0.15469231f, 0.13035835f, -0.05332109f, -0.03152969f, 
    -0.20020834f, 0.05774903f, -0.03610055f, 0.20085284f, -0.09949095f, 0.01436332f, -0.07117324f, 0.09870471f, 
    0.13722485f, -0.03274601f, 0.13994940f, 0.07870664f, -0.22058104f, -0.39221212f, 0.15017322f, 0.06189253f, 
    -0.28117096f, -0.01286057f, 0.01315606f, -0.12150280f, -0.11894803f, -0.06523130f, -0.04225949f, -0.01955210f, 
    0.04846848f, -0.12550935f, 0.16860701f, -0.19870853f, 0.21739399f, 0.12394902f, -0.10534593f, -0.09078686f, 
    0.11845131f, -0.00742606f, 0.04153826f, 0.16424541f, 0.11266316f, -0.08553056f, -0.11584555f, -0.06565917f, 
    0.02068167f, -0.07770022f, 0.03788840f, -0.08852817f, -0.02130312f, 0.07206326f, 0.19220175f, -0.05378880f, 
    -0.25201347f, -0.27986979f, -0.10208587f, 0.26620483f, -0.13066146f, -0.12643224f, -0.01946033f, 0.07599439f, 
    0.00640435f, 0.03074753f, 0.07027975f, 0.01506935f, -0.01847413f, -0.01792239f, -0.08529127f, -0.21816312f, 
    0.07509600f, -0.07934057f, -0.03286528f, 0.15976430f, -0.01672945f, 0.06078243f, 0.04549963f, 0.02122439f, 
    -0.13467987f, 0.04038509f, -0.04414890f, 0.00378203f, 0.07762709f, -0.01112771f, -0.02263050f, -0.02360088f, 
    -0.00583507f, 0.02593413f, -0.10184706f, -0.02286298f, 0.06399302f, -0.04562801f, -0.03219028f, 0.01968236f, 
    -0.12073473f, -0.01329422f, 0.07360354f, -0.00812205f, 0.04431128f, 0.01770742f, -0.03412823f, 0.11335611f, 
    0.04175738f, -0.05526603f, 0.06167552f, -0.05743336f, -0.04635899f, 0.02022853f, 0.06171051f, 0.03797181f, 
    0.08513752f, 0.08419634f, 0.02223437f, 0.10429221f, -0.03573447f, -0.16349976f, 0.02367523f, -0.06951293f, 
    -0.12973659f, 0.00124546f, 0.12698241f, -0.18782088f, 0.19827774f, -0.08730345f, 0.07234801f, 0.00875680f, 
    -0.27795288f, 0.32408723f, 0.03609726f, 0.13083406f, 0.27839133f, 0.14724478f, 0.13230072f, -0.01940382f, 
    -0.07014840f, -0.00445127f, 0.03201987f, 0.21284994f, 0.11612051f, -0.08637376f, 0.17228913f, -0.18492423f, 
    -0.13515458f, -0.13453320f, 0.22988699f, 0.11780807f, 0.05139091f, -0.01329190f, 0.04422806f, 0.11453038f, 
    0.12549874f, 0.16968866f, -0.00091841f, -0.28566402f, 0.23976891f, 0.10485492f, 0.13994792f, 0.00664977f, 
    -0.02900247f, -0.01813963f, 0.15108408f, 0.05669802f, 0.02382234f, -0.01760207f, -0.03430638f, 0.19251481f, 
    0.30451351f, 0.09126245f, -0.02033977f, 0.03649943f, 0.06795838f, 0.15966283f, 0.02093269f, 0.02620822f, 
    -0.11985366f, 0.48450682f, -0.04863863f, 0.36533675f, 0.23561603f, 0.00212597f, -0.08642165f, -0.05040034f, 
    0.20201889f, -0.09653663f, 0.03198141f, 0.18512104f, 0.04529962f, 0.00393482f, -0.17604132f, 0.20248809f, 
    0.00545956f, -0.00626756f, -0.06862156f, 0.08819855f, 0.00302478f, 0.07438313f, 0.01462772f, -0.03592890f, 
    0.41160411f, -0.25029808f, 0.22569229f, -0.13089119f, -0.05057874f, -0.01548074f, -0.01690468f, -0.02076380f, 
    0.08527178f, 0.18492717f, -0.00377065f, -0.08917695f, -0.02288265f, -0.12460164f, -0.03643763f, 0.03502799f, 
    -0.01962753f, -0.17731687f, -0.09850981f, -0.07069407f, 0.05004566f, -0.11593323f, 0.00306010f, -0.04236361f, 
    0.11823726f, -0.20973161f, -0.20798545f, -0.01999924f, -0.02941100f, -0.03625036f, -0.04550122f, 0.05627825f, 
    0.09708200f, 0.06277923f, 0.05277450f, -0.04154620f, -0.18060100f, 0.02042475f, 0.03045892f, -0.02455760f, 
    0.04593360f, 0.21053326f, 0.22053300f, 0.01684154f, -0.02222419f, 0.06337249f, 0.11025704f, 0.01453756f, 
    -0.14917004f, -0.03422769f, 0.02126644f, -0.32585540f, -0.01723151f, 0.02837865f, 0.01599887f, -0.03915459f, 
    -0.01005889f, 0.01767807f, -0.04421120f, -0.01544805f, 0.23679049f, -0.04502724f, -0.05253994f, 0.00761853f, 
    0.07484586f, 0.15521301f, 0.01030955f, -0.05844658f, 0.03137438f, -0.05469408f, 0.20312834f, 0.06849645f, 
    0.10681833f, -0.00474114f, 0.00835420f, 0.21749556f, 0.10193818f, 0.13697532f, -0.01023989f, 0.01496996f, 
    0.03429418f, -0.00094249f, -0.00740025f, 0.16236889f, 0.21074866f, 0.03394859f, -0.02523609f, 0.07172471f, 
    0.05364678f, 0.07264122f, -0.03490014f, -0.02291490f, -0.02557747f, -0.09220836f, 0.08786306f, -0.09081852f, 
    0.27032581f, 0.13145135f, 0.01394266f, 0.11814830f, 0.03860946f, 0.06221191f, 0.02558572f, -0.07961097f, 
    0.12352069f, -0.11183348f, -0.03458656f, -0.10455955f, 0.24625431f, 0.06503510f, -0.14119199f, 0.05713727f, 
    -0.08827003f, 0.04237006f, -0.01001131f, 0.08296289f, -0.01361904f, -0.03787508f, 0.07408255f, -0.11259133f, 
    0.08163541f, 0.27177808f, 0.08837794f, -0.02781826f, 0.07098351f, 0.11507193f, -0.09519707f, -0.01791035f, 
    -0.06335682f, 0.04417514f, -0.01597451f, -0.05487829f, 0.20019740f, -0.05973969f, 0.17660734f, -0.13947996f, 
    -0.02780175f, -0.05595480f, 0.09916536f, -0.02297723f, -0.06883982f, 0.10099449f, 0.06131821f, 0.01028873f, 
    -0.24159084f, -0.24778999f, -0.07795504f, -0.21345857f, -0.02350840f, -0.01933281f, 0.02777838f, -0.01148506f, 
    0.02411426f, 0.00436568f, 0.08298174f, -0.07890674f, -0.28760153f, 0.02802828f, 0.14628731f, -0.19331098f, 
    -0.01196691f, -0.02255997f, 0.00560381f, -0.02948539f, 0.08760450f, 0.07712838f, 0.04336922f, -0.03743749f, 
    -0.23753366f, 0.05436427f, 0.04111635f, -0.08950583f, -0.03354425f, 0.04610933f, 0.05120363f, 0.01531853f, 
    0.05758591f, 0.06092596f, 0.05390742f, -0.10020706f, -0.18130545f, 0.06187261f, 0.01074785f, -0.00002929f, 
    0.05171251f, 0.05482095f, 0.08546870f, 0.00666142f, 0.02211200f, -0.16158512f, 0.03861346f, -0.01984175f, 
    -0.29110420f, -0.16870229f, 0.06739955f, 0.02373744f, 0.04774822f, -0.01896732f, -0.02352468f, 0.03259183f, 
    0.12057878f, -0.03853598f, 0.01382177f, 0.14447412f, 0.21215913f, -0.12354287f, -0.09025232f, 0.17758949f, 
    0.07592819f, 0.00028577f, 0.01135969f, 0.18129820f, 0.08874989f, 0.11999694f, -0.10800289f, 0.04193102f, 
    0.16865061f, 0.08054237f, 0.01065345f, 0.19820352f, 0.04408308f, 0.13200906f, 0.03461089f, -0.05114594f, 
    0.02206458f, -0.02930403f, -0.06045014f, -0.06797779f, 0.07592381f, 0.01704399f, -0.18294998f, -0.22049890f, 
    0.00544904f, 0.07056067f, -0.02056112f, -0.03371415f, 0.11037531f, 0.00935394f, -0.16549884f, 0.04843529f, 
    0.48472610f, -0.23503897f, -0.10348589f, -0.11160963f, 0.03244765f, 0.13637300f, 0.12156224f, 0.03236885f, 
    -0.02219095f, -0.03816841f, 0.08037645f, 0.11312427f, -0.12562974f, 0.14718755f, -0.14153408f, -0.07440601f, 
    -0.05701130f, 0.00435862f, -0.02687539f, 0.03177457f, 0.18491776f, 0.10317867f, 0.00543292f, 0.04646838f, 
    -0.13512796f, 0.09937124f, 0.04322034f, 0.16495708f, 0.07049596f, 0.06292595f, -0.00917671f, 0.10676526f, 
    0.17780651f, 0.06852604f, -0.05079719f, 0.07386312f, 0.19317330f, -0.06554352f, 0.09027659f, 0.09715215f, 
    0.15144026f, -0.02589278f, 0.01842374f, 0.21353766f, 0.09025029f, -0.08383754f, 0.08580299f, 0.04853727f, 
    -0.22872080f, -0.15906823f, 0.03726361f, -0.05348575f, 0.03185824f, 0.05673609f, 0.01554845f, -0.02836814f, 
    -0.13369769f, -0.00460032f, -0.09748375f, 0.05463286f, 0.04575334f, -0.04868066f, -0.07932495f, 0.13483199f, 
    -0.00827566f, -0.06374913f, -0.01436390f, 0.09122147f, -0.06582030f, -0.04165966f, 0.04249446f, 0.03814055f, 
    0.27583119f, 0.18147755f, 0.16037524f, -0.05020049f, 0.02926212f, 0.00855750f, 0.14604835f, 0.04382551f, 
    -0.01913713f, -0.00650245f, 0.13467599f, 0.05818927f, 0.09350662f, 0.05989203f, -0.04241718f, 0.07738660f, 
    -0.10212521f, 0.04871055f, -0.12214646f, -0.05033967f, 0.07738156f, -0.06034733f, 0.11658242f, -0.00330817f, 
    -0.01254015f, 0.18617651f, 0.19097818f, 0.04288018f, -0.01968196f, 0.01044609f, -0.00649239f, -0.05098476f, 
    0.04392519f, 0.08889832f, -0.08861087f, -0.03096456f, 0.07396776f, -0.00201617f, 0.06996037f, 0.03377897f, 
    -0.09899842f, 0.02090878f, 0.12888850f, -0.09353942f, -0.02019716f, -0.01309867f, -0.00615530f, 0.08748806f, 
    0.08091480f, -0.04144795f, 0.27830938f, -0.20603962f, 0.02340799f, -0.01643041f, 0.19432409f, 0.02211627f, 
    0.04570326f, -0.01197345f, 0.05651232f, 0.00268368f, -0.01790155f, -0.00615385f, 0.17846359f, 0.05173914f, 
    0.12947126f, 0.00417338f, -0.07385930f, 0.14349791f, 0.03280673f, 0.05961259f, 0.09375027f, 0.08612303f, 
    0.32465881f, 0.12381753f, -0.29852340f, 0.09945688f, -0.05713864f, 0.12849365f, -0.07319361f, 0.01589718f, 
    -0.00112550f, 0.00092577f, 0.09024448f, 0.12704675f, -0.09521097f, -0.16040319f, -0.04403741f, 0.19735442f, 
    -0.08647170f, 0.04562170f, -0.04613908f, 0.00481289f, -0.04364527f, -0.06839439f, 0.07712468f, 0.14101107f, 
    -0.03959585f, 0.03532498f, -0.03665447f, 0.00030927f, 0.02271248f, -0.02580100f, 0.03784991f, -0.05073440f, 
    -0.02446896f, -0.02879513f, -0.03658226f, 0.00046400f, -0.05456378f, 0.01235504f, 0.00440547f, 0.02060100f, 
    -0.00125821f, -0.03003830f, 0.01298406f, 0.03459465f, -0.04412739f, 0.03393370f, -0.00162276f, -0.02169102f, 
    0.01647831f, -0.04920802f, 0.01190746f, -0.01084722f, 0.01580868f, -0.00176741f, -0.00997462f, -0.05516181f, 
    -0.02975098f, 0.01536146f, 0.02115751f, -0.03019027f, -0.05486628f, 0.05338658f, -0.04606063f, -0.04951160f, 
    -0.01090482f, -0.02947835f, -0.01961170f, -0.01854501f, -0.00734697f, 0.04413736f, -0.03489709f, 0.01792576f, 
    -0.01781230f, 0.01009925f, -0.04341761f, -0.01185693f, 0.02566581f, -0.03217888f, 0.03299383f, -0.02536128f, 
    -0.04934068f, -0.00743714f, 0.03836874f, -0.00453296f, -0.05584664f, -0.04543518f, 0.01987576f, 0.00620752f, 
    -0.00140848f, 0.04255361f, -0.00840801f, 0.01692582f, -0.03610083f, 0.00126276f, -0.05506071f, 0.00906883f, 
    -0.02468968f, -0.00827668f, 0.01058617f, 0.01997349f, 0.03327807f, -0.01691039f, -0.03490852f, 0.02964109f, 
    0.02530983f, 0.02134092f, -0.02927671f, -0.01360291f, 0.01836493f, 0.02456406f, 0.02994270f, -0.00835715f, 
    0.03970087f, 0.03671790f, 0.04551961f, -0.02545020f, -0.05088926f, -0.03982191f, 0.02531309f, -0.02615084f, 
    0.00613094f, -0.05257895f, 0.03495050f, 0.00530478f, 0.01857810f, -0.04086528f, 0.04241061f, 0.03138790f, 
    -0.01384085f, -0.02095970f, -0.03514263f, -0.01477931f, 0.01750109f, 0.04413770f, -0.04093673f, -0.05073800f, 
    -0.05643343f, -0.02856821f, -0.03850141f, -0.02036832f, -0.00931101f, 0.03588331f, 0.00136085f, 0.03332525f, 
    0.00872768f, -0.00918030f, -0.05772201f, 0.00367555f, 0.00792181f, 0.01129683f, 0.00763181f, -0.00578354f, 
    0.02575908f, 0.01707819f, -0.03531251f, 0.00895210f, -0.03799334f, -0.02998075f, -0.05386553f, 0.02917539f, 
    0.01915515f, 0.02286540f, 0.02906058f, 0.03477721f, -0.02579104f, 0.03625842f, -0.05256764f, -0.00020320f, 
    -0.01302066f, 0.02622487f, -0.02133942f, -0.00906310f, -0.02754526f, 0.03036896f, -0.05601405f, 0.03786618f, 
    0.02125520f, -0.04908544f, 0.03537906f, -0.01445964f, 0.03203147f, -0.02414450f, 0.02581478f, 0.01438065f, 
    0.03122921f, -0.01005914f, 0.02989435f, -0.03535911f, -0.05280209f, -0.04802810f, -0.01302328f, -0.00691807f, 
    -0.02358028f, -0.00450018f, 0.01403590f, -0.03459577f, 0.00085896f, -0.00877790f, 0.00645881f, 0.00357689f, 
    0.03614336f, 0.01230508f, -0.03580358f, 0.02385650f, -0.00617203f, -0.01838935f, -0.01704989f, 0.01003551f, 
    -0.02998647f, -0.04157995f, 0.00862606f, 0.01723334f, -0.00025287f, 0.00129352f, -0.04045472f, -0.02147877f, 
    -0.04750453f, -0.04713835f, 0.03493798f, 0.02832500f, -0.04614775f, -0.02844024f, -0.00270905f, -0.04520173f, 
    0.05092796f, -0.00189243f, -0.00615645f, 0.03359126f, -0.02399088f, -0.01852797f, -0.03167643f, 0.03052018f, 
    0.02648371f, 0.00949239f, 0.03592957f, 0.00853285f, -0.03598651f, -0.01848675f, -0.03473708f, 0.00284820f, 
    0.02145349f, 0.02818913f, 0.02108743f, 0.00021552f, 0.04357232f, -0.02961334f, 0.01414351f, -0.03156915f, 
    -0.04450199f, 0.04584732f, 0.03240026f, -0.04253254f, 0.03058019f, 0.00032684f, 0.04679633f, -0.04918617f, 
    0.04631240f, 0.04429244f, 0.01210508f, -0.02574300f, -0.04647538f, -0.01537103f, 0.03504376f, -0.01202684f, 
    -0.01635416f, -0.01832379f, 0.01188762f, -0.00755680f, -0.05159373f, -0.02903519f, -0.03470888f, -0.01415932f, 
    -0.04954179f, -0.01832441f, -0.00681540f, 0.04458648f, -0.05171825f, -0.02448603f, 0.02515204f, 0.04324095f, 
    0.00117327f, 0.01711851f, -0.02538130f, 0.01978987f, -0.05146636f, -0.03987321f, 0.00891995f, -0.04681591f, 
    0.00490840f, 0.00266104f, 0.00413200f, 0.03977793f, -0.02146089f, 0.02087503f, 0.00878184f, 0.00395562f, 
    0.04740003f, -0.04962190f, -0.00373233f, 0.01524853f, -0.01893480f, 0.04366645f, 0.03682957f, 0.01584261f, 
    0.02522185f, -0.05013140f, 0.00788500f, 0.02158273f, -0.02667984f, -0.03505757f, 0.00907713f, 0.01931001f, 
    0.02200756f, 0.02079098f, -0.00445067f, 0.02644546f, 0.00270354f, 0.01728169f, -0.04052681f, -0.00771454f, 
    0.02789356f, -0.01036925f, 0.01504918f, -0.03967796f, 0.02085853f, 0.02967451f, -0.04410684f, -0.02458654f, 
    0.03337283f, -0.01141426f, 0.03232703f, -0.03505737f, -0.03006056f, -0.03051182f, -0.00966581f, -0.04898408f, 
    0.03953741f, -0.02843852f, -0.01097737f, -0.01418833f, 0.00163168f, -0.03207087f, -0.02136916f, -0.01742280f, 
    0.01007084f, -0.01292298f, 0.01376934f, -0.00158377f, -0.00024344f, -0.01456850f, -0.04713857f, -0.04862444f, 
    0.02456070f, 0.02354164f, 0.01272524f, 0.01310287f, 0.04102739f, -0.04668320f, 0.03222263f, -0.00367669f, 
    -0.02166803f, -0.00058483f, 0.02404875f, 0.02840116f, 0.03885761f, 0.01833136f, 0.00109594f, -0.04842545f, 
    -0.01342840f, -0.00036092f, 0.03550445f, 0.01447469f, -0.03320549f, -0.05341458f, -0.01638858f, -0.01704202f, 
    -0.01174119f, -0.03302612f, -0.03203150f, 0.01398164f, -0.04362759f, 0.05028251f, 0.00538596f, 0.03135965f, 
    0.00883400f, 0.03656879f, 0.01272071f, 0.01743578f, -0.03716535f, 0.00016635f, 0.00278241f, -0.00982112f, 
    0.00780955f, -0.04269211f, 0.03166302f, -0.03663531f, -0.05140935f, 0.04284995f, -0.00181107f, 0.03567392f, 
    0.05285165f, 0.04700088f, -0.05222337f, -0.05057061f, -0.02754054f, 0.05029125f, -0.04062739f, 0.03812541f, 
    -0.00763454f, 0.00861261f, 0.03734516f, 0.02687725f, -0.04574302f, -0.04945930f, 0.01288503f, -0.05023958f, 
    -0.05568384f, 0.01506603f, -0.04837023f, -0.03814406f, -0.02996981f, -0.01438243f, -0.04106206f, 0.04005683f, 
    0.03971292f, -0.05436981f, 0.04289084f, 0.03986952f, 0.02285758f, -0.00821248f, -0.02975886f, -0.02421054f, 
    -0.00147443f, -0.04548929f, 0.03281725f, -0.03009805f, -0.04589231f, -0.03508270f, 0.00061846f, -0.01181867f, 
    0.00015499f, 0.00106575f, -0.01093983f, 0.02294859f, 0.04275533f, -0.00250418f, -0.00961561f, 0.00592566f, 
    -0.03779976f, -0.03106484f, -0.00065273f, -0.01900295f, -0.03634607f, -0.01069492f, 0.00639686f, -0.04586966f, 
    0.00979464f, 0.03560519f, 0.04144172f, -0.01124679f, 0.02666834f, 0.00839320f, -0.02652559f, -0.04094898f, 
    -0.03986874f, -0.03316157f, 0.02428894f, 0.03202741f, 0.02857362f, -0.00560879f, -0.02366193f, -0.02616488f, 
    0.04171688f, -0.04163945f, -0.00045411f, 0.00812215f, 0.01899058f, -0.01588313f, -0.02629793f, 0.01790867f, 
    -0.03051012f, -0.00185510f, 0.03060819f, -0.01258055f, 0.02237039f, 0.01549364f, -0.01809765f, -0.01783177f, 
    -0.04982303f, -0.03454297f, -0.05377095f, -0.02018321f, -0.02345937f, -0.04740000f, -0.00939183f, 0.01326280f, 
    -0.01918396f, -0.01882280f, 0.02837714f, 0.03026364f, -0.00438419f, -0.02258195f, -0.02067776f, -0.00980421f, 
    0.04471647f, 0.02416589f, 0.03313878f, 0.01731560f, -0.01508871f, 0.04468906f, -0.00042365f, 0.04095000f, 
    0.02330241f, -0.01353288f, -0.03428208f, -0.03325118f, -0.03137991f, 0.04501300f, -0.03865155f, 0.01943625f, 
    0.03869621f, 0.01082960f, 0.04047097f, -0.00071595f, 0.04021970f, 0.00521608f, 0.00114949f, -0.04963272f, 
    -0.00950451f, -0.02431913f, -0.04027344f, 0.03970350f, -0.02434199f, -0.03983153f, 0.00876376f, -0.00401746f, 
    0.02836149f, 0.02540044f, -0.01995227f, -0.04492284f, -0.00829326f, -0.02176938f, -0.04726071f, 0.02902937f, 
    -0.00073898f, -0.01717639f, -0.02698871f, 0.03544552f, -0.03436300f, 0.04545673f, 0.03015199f, 0.03175814f, 
    0.03153020f, -0.00832095f, -0.05470031f, -0.02939244f, -0.00384507f, 0.01934836f, 0.04261160f, -0.01186087f, 
    -0.04643448f, 0.03851106f, 0.03153430f, -0.03990030f, -0.01776537f, 0.03935357f, -0.04438619f, 0.02705976f, 
    -0.00854322f, -0.05200982f, -0.01837204f, -0.01611079f, -0.00752122f, -0.03050361f, 0.03557888f, -0.05189651f, 
    -0.00476371f, 0.01743327f, 0.02512410f, 0.01208963f, 0.02984296f, -0.00628893f, -0.01249348f, 0.00205206f, 
    0.03113450f, 0.00173728f, -0.02662495f, -0.04578254f, -0.05194732f, 0.03764030f, 0.01237840f, -0.01495030f, 
    0.00117646f, 0.00005769f, -0.04957482f, 0.00544414f, 0.02990399f, 0.00565902f, 0.02018020f, -0.03092718f, 
    0.01223455f, -0.02129187f, 0.04014260f, -0.01935453f, -0.05269863f, 0.04513486f, -0.03918733f, -0.04400148f, 
    0.02597724f, 0.03851605f, 0.02984942f, -0.00745981f, -0.01780736f, -0.05273880f, -0.01964566f, -0.02037807f, 
    -0.04827702f, -0.04018622f, -0.04492209f, 0.01666613f, -0.02063051f, 0.03828342f, -0.03661220f, -0.00137919f, 
    -0.01854489f, -0.02723763f, 0.01654479f, 0.01760927f, 0.03871110f, -0.01019528f, -0.04372597f, 0.02424485f, 
    0.03852524f, -0.00227760f, -0.02889111f, 0.00632165f, -0.04232661f, -0.02099497f, -0.01694332f, -0.00727892f, 
    0.00634169f, -0.04196353f, -0.05224626f, -0.02693463f, 0.00829871f, -0.01666925f, -0.03826717f, -0.01177212f, 
    -0.02209812f, -0.00307714f, -0.02519872f, -0.04306076f, -0.00610342f, -0.00598579f, 0.02334976f, -0.05615813f, 
    -0.02156708f, -0.04759840f, -0.01785052f, -0.00476443f, -0.00919129f, -0.01472886f, -0.05589691f, -0.04850478f, 
    0.02226304f, 0.01827995f, -0.02596997f, -0.02710904f, -0.04453997f, -0.04359593f, -0.01523706f, -0.01599080f, 
    -0.02258666f, -0.00852735f, -0.03157824f, 0.00920286f, -0.02651305f, 0.00125845f, -0.00056428f, 0.00341860f, 
    0.01790369f, -0.05112569f, -0.00605990f, 0.03803568f, -0.01050960f, 0.01560351f, -0.05361312f, 0.03249450f, 
    -0.03269111f, 0.02190905f, -0.04674356f, 0.01978064f, -0.05484759f, -0.01502417f, -0.01758331f, -0.04311275f, 
    0.03844498f, 0.02507717f, 0.02904691f, -0.03516053f, 0.02192328f, 0.02731550f, 0.01994463f, -0.03934959f, 
    -0.02242572f, 0.00051494f, 0.03795969f, -0.04706684f, 0.02842851f, 0.03729194f, -0.03923456f, -0.02730261f, 
    0.03771829f, -0.05233979f, 0.01366218f, 0.02701329f, -0.01828814f, -0.01399495f, -0.01474156f, -0.00205595f, 
    0.00447577f, -0.05421401f, 0.04099197f, -0.04784978f, -0.03618564f, -0.03694418f, -0.01292091f, 0.02596312f, 
    0.02808368f, -0.04726103f, -0.02014259f, 0.00868752f, 0.00928969f, -0.03586255f, -0.00894202f, -0.02022072f, 
    -0.00666724f, 0.02860247f, -0.02995573f, -0.03850929f, 0.03757158f, -0.01949318f, -0.05416616f, 0.01290403f, 
    -0.00989260f, -0.03547315f, -0.05013520f, 0.00424625f, -0.03871726f, 0.01340642f, -0.04504590f, 0.01869207f, 
    0.01661304f, -0.01468269f, -0.05376088f, -0.01380399f, -0.03294293f, -0.03800820f, -0.04645432f, -0.01044834f, 
    -0.04425670f, -0.03925604f, -0.04444133f, 0.04305305f, 0.01974148f, -0.03584684f, -0.01090750f, -0.02238612f, 
    0.00964271f, -0.01248018f, 0.02819549f, -0.04357564f, -0.04867376f, -0.04086269f, 0.01339762f, -0.04543883f, 
    0.00192632f, -0.00034490f, 0.03890680f, 0.00224817f, -0.04921104f, -0.01530787f, 0.03707198f, -0.01429461f, 
    -0.04645475f, 0.03719774f, 0.01314931f, 0.02051478f, 0.03203483f, 0.03378638f, 0.00629740f, -0.01728783f, 
    0.01367464f, 0.01779440f, 0.02298333f, 0.03325035f, -0.06405207f, -0.02969051f, 0.02307856f, -0.02759017f, 
    -0.04211832f, -0.00929921f, 0.00344716f, -0.00952801f, 0.03342811f, 0.03168370f, -0.05437717f, 0.02008655f, 
    -0.00887886f, 0.00178915f, 0.02202726f, -0.01582091f, -0.03969131f, -0.03312382f, -0.01988058f, -0.02321748f, 
    -0.02372621f, -0.02887872f, -0.01854587f, 0.02377620f, -0.05222457f, -0.05728901f, 0.01179680f, 0.01440496f, 
    0.00747766f, -0.04407829f, -0.08416010f, -0.01134638f, -0.00483403f, 0.02734186f, -0.01423890f, -0.04481445f, 
    -0.06331501f, -0.04044021f, 0.03064293f, -0.01674058f, -0.00903130f, 0.00577866f, 0.00470381f, 0.00386300f, 
    -0.04586232f, 0.00279030f, 0.03795562f, 0.02262457f, 0.02555075f, -0.00515490f, -0.06223645f, -0.04192041f, 
    -0.02190752f, 0.01057715f, -0.07852811f, 0.00548625f, -0.04927434f, 0.00098910f, 0.03458789f, 0.00908715f, 
    -0.03784860f, -0.05961928f, -0.03750429f, -0.04079825f, -0.03948512f, -0.02927161f, -0.01816443f, -0.02702529f, 
    -0.03889049f, 0.01318287f, -0.03526431f, -0.00227871f, -0.00123881f, -0.03593631f, 0.00242212f, 0.01427146f, 
    0.01297680f, -0.04884611f, 0.02458403f, 0.04848730f, -0.04623526f, 0.03557953f, -0.02511472f, -0.00940856f, 
    -0.03612343f, -0.04559442f, 0.02570110f, -0.04264536f, -0.06628472f, -0.04470809f, -0.04192067f, 0.01765299f, 
    -0.00870280f, -0.01591140f, 0.01185334f, 0.02874151f, -0.04456325f, -0.02463309f, -0.02710644f, -0.06607848f, 
    0.01605862f, 0.01427829f, 0.01405523f, -0.04680452f, 0.02429764f, 0.04414518f, -0.03665874f, -0.04881421f, 
    -0.03669057f, -0.03683309f, 0.00811036f, -0.00519551f, -0.00182987f, 0.01359687f, 0.01102441f, 0.00681188f, 
    -0.03880116f, -0.06308755f, -0.02780629f, 0.04265560f, 0.02743286f, -0.00335040f, -0.04703265f, -0.00659687f, 
    -0.06146830f, -0.04933705f, -0.02905709f, -0.02317615f, -0.06258074f, 0.00646654f, -0.00917332f, 0.01921726f, 
    -0.01773190f, -0.01482156f, -0.05283918f, -0.05152392f, -0.03586249f, -0.01331213f, -0.03394029f, -0.04897304f, 
    -0.03905932f, -0.04705491f, -0.02637618f, -0.00413712f, -0.06242046f, -0.08394089f, -0.02993967f, 0.00461567f, 
    0.02068733f, -0.06660401f, -0.02033608f, 0.00708483f, -0.02692567f, -0.03285920f, -0.06964099f, 0.01837464f, 
    -0.05731541f, -0.02993354f, -0.03093309f, 0.01246847f, -0.05391374f, -0.04562986f, -0.08092447f, -0.07078578f, 
    -0.03295708f, 0.04316933f, -0.04915701f, 0.00602572f, 0.02513588f, -0.02933215f, -0.01725218f, -0.03574592f, 
    -0.04113226f, -0.00642025f, -0.05322988f, -0.02024841f, 0.01124462f, 0.05337274f, 0.01754034f, -0.00519159f, 
    -0.04916311f, -0.00534113f, -0.00605179f, 0.00589695f, -0.03473671f, -0.02968919f, -0.02590505f, -0.05315117f, 
    0.03017324f, -0.00371962f, -0.05729664f, -0.04986392f, -0.00238403f, 0.00778903f, -0.06896923f, -0.02691719f, 
    -0.05186496f, 0.01534304f, -0.00555856f, 0.00601120f, -0.01239631f, -0.06167860f, -0.07208221f, -0.04614520f, 
    -0.05283652f, -0.02778157f, -0.05162577f, -0.03364393f, -0.04808245f, -0.05025877f, -0.02271214f, -0.04436265f, 
    -0.07695451f, -0.03417537f, 0.00658855f, 0.02976543f, 0.01511000f, -0.04303585f, -0.00413894f, -0.01522087f, 
    -0.01868927f, 0.00298280f, -0.00776581f, -0.04321047f, 0.00701813f, -0.07888333f, -0.00028165f, 0.00844539f, 
    -0.01136318f, -0.02353822f, -0.02058431f, -0.05634832f, 0.00690913f, -0.01465545f, 0.02350648f, -0.04527852f, 
    0.02576070f, -0.00649030f, -0.04272665f, 0.01087461f, -0.00090739f, -0.05457513f, -0.04594255f, -0.05592022f, 
    -0.01516686f, 0.00463577f, -0.06892263f, -0.06557079f, -0.02326616f, -0.06872664f, -0.04132960f, 0.02112453f, 
    0.03062782f, 0.03702578f, -0.02651436f, -0.01274791f, -0.05725937f, -0.02485630f, -0.05807775f, -0.04266249f, 
    0.01338813f, -0.00428277f, -0.05751302f, -0.04588312f, 0.01163743f, -0.00919038f, -0.02675835f, -0.02345244f, 
    0.02777985f, 0.00400467f, -0.07539371f, -0.03326365f, -0.00854523f, -0.02627148f, 0.01056721f, -0.01329287f, 
    -0.01423602f, -0.03655396f, 0.00548923f, 0.01825857f, 0.00048229f, 0.00754144f, -0.00184766f, 0.03018039f, 
    -0.06410706f, -0.07455066f, 0.03224980f, -0.03326939f, -0.04780065f, -0.03791832f, -0.06390109f, -0.05469799f, 
    0.02059161f, -0.05588697f, -0.04891143f, 0.01491906f, -0.07111598f, 0.01462030f, 0.02486615f, -0.07256962f, 
    -0.03143118f, -0.06883495f, -0.05422034f, 0.03684729f, -0.04900617f, -0.04919139f, -0.02190991f, -0.02595958f, 
    -0.01055373f, 0.02864228f, -0.00419166f, 0.04277067f, 0.02421516f, -0.04487487f, -0.04175301f, -0.06881920f, 
    -0.06002422f, 0.01176383f, -0.01055128f, -0.04292905f, -0.00049602f, -0.05835537f, -0.03421308f, 0.03519173f, 
    0.01420443f, 0.01150586f, -0.02030310f, -0.02994637f, 0.01433625f, -0.04716136f, -0.04165317f, -0.04909096f, 
    0.03696298f, 0.03058836f, -0.06648818f, -0.00927511f, -0.00044315f, 0.02308319f, 0.02920413f, -0.05848853f, 
    -0.04349893f, -0.00046368f, 0.03031389f, 0.01842639f, -0.03220449f, -0.02711776f, 0.01311130f, 0.02824004f, 
    0.02245177f, 0.00913291f, 0.01986824f, -0.06532655f, -0.00526499f, -0.06157960f, -0.03767816f, -0.04636942f, 
    -0.00299424f, -0.05836933f, -0.06529254f, 0.00809794f, -0.06090925f, 0.02024544f, -0.02772799f, -0.01825853f, 
    0.01769319f, -0.04176192f, -0.00513091f, -0.01991944f, -0.05792726f, 0.03093878f, 0.01940451f, 0.03430168f, 
    0.02414276f, -0.01558230f, -0.02172006f, -0.00534201f, 0.03035727f, -0.06532375f, -0.01056238f, -0.07841250f, 
    -0.02011772f, -0.03048947f, 0.02934817f, -0.04582972f, -0.05034406f, -0.00003874f, 0.02881624f, -0.03906694f, 
    0.05085970f, 0.00990054f, -0.00904621f, 0.02825555f, -0.01162541f, -0.00906996f, 0.03698555f, 0.02320466f, 
    0.01936721f, 0.03945817f, -0.05436757f, 0.00410403f, 0.00472269f, 0.03194338f, -0.05281759f, 0.03372151f, 
    -0.00949891f, 0.02634855f, 0.01930111f, -0.05683513f, -0.02813652f, 0.02305541f, 0.01188228f, -0.03951963f, 
    -0.03992707f, 0.01242109f, -0.00968859f, -0.05743913f, -0.01845505f, -0.05754004f, -0.03234904f, -0.05604606f, 
    -0.04961872f, -0.03307107f, 0.03175785f, -0.03208171f, -0.02279190f, -0.01930149f, 0.01633294f, -0.03669613f, 
    0.03563276f, -0.02854858f, 0.02618692f, 0.00224791f, -0.03895159f, 0.02289936f, 0.01330936f, 0.01951707f, 
    -0.02544660f, 0.02603895f, -0.02151904f, 0.01926912f, -0.02831346f, 0.00260010f, 0.00781387f, 0.01952608f, 
    0.04065749f, -0.00185873f, 0.01665675f, -0.03900678f, -0.00367531f, -0.00607249f, -0.00193221f, -0.01001845f, 
    -0.04579516f, 0.02192279f, -0.03138317f, -0.01600900f, -0.00788074f, -0.00265956f, -0.02577038f, 0.03504767f, 
    0.00655053f, 0.00949878f, 0.04234411f, -0.01860777f, -0.04788977f, -0.02712709f, 0.03723986f, -0.01328745f, 
    -0.04098951f, -0.02431143f, 0.00933795f, -0.05543385f, -0.01193723f, 0.03163676f, 0.00253486f, 0.02215392f, 
    0.00565795f, -0.03471309f, -0.04846156f, -0.05397642f, -0.02023864f, 0.01182946f, 0.03388227f, -0.03668125f, 
    -0.03256396f, -0.05026141f, -0.03789058f, 0.00830125f, -0.04952223f, -0.03779828f, -0.01426141f, -0.02164345f, 
    0.00843950f, 0.00132842f, 0.00352175f, 0.02163375f, -0.05336310f, 0.02422207f, -0.02708561f, -0.04413643f, 
    -0.04037028f, 0.03512210f, 0.02936439f, -0.02840380f, 0.00219466f, 0.00432136f, -0.04344099f, 0.00711642f, 
    0.03877296f, -0.04099964f, 0.03061624f, -0.05739291f, 0.04282056f, -0.01103602f, -0.00994230f, -0.04556229f, 
    0.00309457f, -0.01307757f, 0.02468024f, -0.05656858f, 0.02683791f, -0.03449525f, -0.02491413f, 0.02422800f, 
    0.03262031f, -0.05228792f, -0.00245713f, -0.00604907f, -0.03759997f, 0.00241644f, 0.02099491f, -0.01406214f, 
    0.01801902f, -0.03752487f, -0.03752746f, 0.04075398f, 0.01983745f, -0.00741731f, -0.02161049f, -0.00082146f, 
    -0.05302584f, -0.01857181f, 0.02018771f, -0.03195386f, -0.04324724f, -0.04216256f, 0.02443008f, -0.01257959f, 
    -0.00198760f, -0.04913839f, -0.02165534f, 0.00884367f, -0.00973720f, 0.01291897f, -0.01729821f, -0.02558662f, 
    -0.04824329f, -0.01276281f, 0.01537890f, 0.03055333f, -0.02254288f, -0.02911485f, -0.04249893f, -0.01649518f, 
    -0.03423699f, 0.01718860f, -0.02331110f, -0.02168243f, 0.01994343f, -0.02606294f, -0.04148913f, 0.00834546f, 
    -0.03966234f, 0.03999224f, -0.03016565f, -0.03747677f, -0.02926342f, 0.03968433f, 0.03310452f, 0.03705551f, 
    -0.02209927f, 0.00537908f, -0.02106087f, -0.05531128f, 0.00293809f, -0.03956268f, 0.02712120f, 0.03317301f, 
    -0.01284154f, -0.05327371f, 0.02175348f, -0.02242880f, -0.01221337f, -0.00779343f, -0.02847820f, -0.02437855f, 
    0.01701377f, 0.01139330f, 0.00942696f, 0.03222634f, -0.00720003f, 0.00399566f, 0.00091934f, -0.02258510f, 
    0.00487056f, 0.00526295f, 0.03209767f, -0.02077187f, 0.01582256f, 0.01256141f, 0.02683617f, -0.04318263f, 
    0.02186316f, 0.03002955f, -0.02661574f, -0.01437197f, -0.01142747f, 0.01540469f, -0.03375007f, 0.02037852f, 
    -0.01636148f, -0.04378331f, -0.03413366f, 0.03307378f, 0.00303743f, -0.04619303f, -0.00115116f, 0.01149750f, 
    -0.04903645f, -0.00404742f, -0.03940099f, -0.02963900f, 0.01682113f, -0.04991082f, 0.01080484f, 0.03947085f, 
    0.03715232f, -0.05784734f, -0.02779024f, -0.01196994f, 0.03139629f, 0.02681952f, -0.00372476f, 0.02587585f, 
    0.00165176f, 0.02254671f, 0.02518598f, -0.05846234f, -0.04196766f, -0.05394356f, 0.02323272f, -0.00270523f, 
    -0.02944846f, 0.00517175f, -0.03704549f, -0.01397375f, 0.01673903f, 0.01907243f, -0.01354211f, 0.00746066f, 
    0.02511509f, -0.03138152f, -0.04359809f, -0.03005191f, -0.04379833f, -0.03280045f, 0.01019956f, 0.03427252f, 
    0.02308803f, 0.02481510f, -0.02963640f, 0.03749653f, 0.03448617f, -0.04069401f, 0.03764196f, -0.00116115f, 
    0.03960568f, -0.05819417f, -0.03021931f, -0.03383461f, 0.01933764f, -0.04807677f, 0.02854395f, 0.02085802f, 
    0.00749042f, -0.02118267f, 0.03282579f, 0.04001813f, -0.02704550f, -0.00042871f, -0.04882430f, -0.01741257f, 
    -0.05808270f, 0.03563492f, -0.04572034f, -0.02835505f, -0.03208745f, 0.03081857f, -0.04722560f, 0.04158388f, 
    -0.04929097f, -0.00409955f, 0.02977553f, -0.02617149f, -0.04663174f, -0.00308294f, -0.03351764f, 0.02551658f, 
    0.00763614f, 0.03385248f, 0.03028618f, 0.01756402f, -0.04154612f, -0.05619327f, -0.01297733f, 0.01842763f, 
    0.00978098f, -0.04370989f, -0.05403697f, 0.00404674f, -0.02532905f, 0.04932647f, -0.02333076f, 0.01462067f, 
    -0.04835965f, -0.04570952f, -0.02403005f, 0.01067506f, -0.02860562f, -0.04870173f, -0.04155040f, 0.02176901f, 
    0.02543127f, -0.01135131f, -0.00651949f, 0.03320080f, 0.02949520f, 0.02716138f, -0.04891899f, 0.02555426f, 
    0.00273189f, -0.01654174f, -0.03152458f, 0.00654055f, 0.02740071f, -0.00110260f, 0.01988567f, -0.01532817f, 
    -0.01936635f, -0.03184978f, -0.05605565f, -0.02603209f, -0.00971104f, -0.01784498f, 0.00149842f, 0.01403770f, 
    -0.01479028f, -0.04735497f, -0.00821529f, -0.01266281f, -0.03817417f, -0.04118775f, -0.05619691f, -0.00669815f, 
    0.01505120f, 0.10116556f, 0.01515865f, 0.06018332f, 0.06504925f, -0.07256914f, -0.09311055f, 0.10941081f, 
    0.06314139f, 0.03008808f, 0.07212844f, 0.09918657f, -0.19321467f, 0.15875223f, 0.05694231f, 0.01886345f, 
    0.09648689f, -0.02044768f, 0.06026907f, 0.06289174f, -0.01683020f, 0.18248081f, 0.15765794f, 0.12924789f, 
    -0.19313096f, 0.06223319f, -0.00278270f, -0.19863304f, 0.10977031f, -0.09477512f, 0.06898131f, -0.05716760f, 
    -0.04433250f, 0.14511052f, 0.06499973f, 0.07760765f, -0.26325434f, 0.27000508f, -0.10214156f, 0.08815257f, 
    -0.11512798f, 0.04079472f, 0.12891047f, -0.08181602f, 0.12812062f, 0.02620068f, 0.09043196f, -0.04295269f, 
    0.21873468f, 0.26843494f, 0.05930461f, 0.12006851f, -0.03330424f, 0.10580511f, -0.03925317f, 0.03814993f, 
    0.07441365f, 0.06190474f, -0.05432307f, -0.05067642f, -0.17177527f, -0.00761258f, 0.19031009f, 0.02122816f, 
    0.02499959f, 0.01465744f, -0.02002596f, -0.02054082f, -0.08826799f, -0.00518073f, 0.02051931f, -0.07725860f, 
    0.24568553f, -0.23347482f, -0.14434129f, 0.31121054f, -0.00497812f, -0.02979711f, 0.01663304f, -0.07333706f, 
    0.00768262f, -0.09833878f, 0.19615075f, -0.04540389f, 0.10880378f, -0.03215105f, 0.00775753f, 0.06350665f, 
    0.05949892f, -0.09935257f, 0.01527894f, 0.02448891f, -0.13721021f, -0.04145498f, -0.09986414f, 0.08630664f, 
    -0.10140423f, -0.00715580f, 0.23372070f, 0.46335229f, -0.09325957f, 0.11899202f, 0.00151230f, -0.00700389f, 
    0.09096345f, 0.13025108f, -0.01531396f, 0.19631109f, 0.33326048f, -0.05186326f, -0.13064626f, -0.38240054f, 
    0.00241338f, -0.10834596f, 0.00631921f, 0.04715291f, -0.13591689f, 0.06806687f, -0.01083453f, 0.03934700f, 
    0.03651498f, -0.04414488f, 0.06163759f, -0.18712780f, 0.01413202f, -0.09601304f, 0.03314031f, -0.01258533f, 
    0.04061155f, 0.03791701f, 0.09902279f, -0.19523291f, -0.13507587f, 0.19964482f, 0.01355205f, -0.10984813f, 
    -0.02673662f, 0.07061316f, 0.01918346f, -0.06679097f, 0.10007098f, 0.17285156f, 0.12971982f, 0.11520568f, 
    0.03258970f, -0.06608445f, 0.03661862f, -0.22931363f, 0.05969561f, -0.07814471f, -0.12442310f, -0.03686346f, 
    -0.06785292f, 0.04306737f, -0.11197560f, -0.01606236f, -0.01821120f, -0.03672560f, -0.10559632f, -0.03595646f, 
    0.08536052f, 0.02597775f, -0.01102657f, 0.13413267f, 0.01115161f, 0.08415526f, -0.12137057f, 0.17687920f, 
    -0.12997770f, -0.20225228f, 0.14282300f, -0.23063758f, 0.15726066f, 0.10873426f, 0.01482811f, 0.01542627f, 
    -0.01479449f, -0.01608877f, -0.04059570f, -0.07905779f, 0.08834342f, 0.06496596f, 0.10339808f, 0.05287476f, 
    0.18784820f, 0.08086717f, -0.02245376f, -0.01698687f, 0.06154529f, 0.03500384f, 0.00373824f, 0.01904729f, 
    0.28772321f, 0.16258164f, -0.05400575f, 0.26726282f, -0.03788802f, -0.02059733f, -0.02077760f, 0.00817131f, 
    0.05828584f, 0.06174999f, 0.11568216f, -0.12657301f, 0.07012982f, 0.11948883f, 0.08415649f, -0.17564751f, 
    0.03922295f, -0.02367109f, -0.09919306f, 0.10028869f, 0.09666467f, 0.15246364f, -0.24720457f, -0.13825992f, 
    -0.10402736f, 0.18540083f, -0.15647838f, -0.13126926f, 0.17394473f, 0.05362671f, -0.07053118f, -0.09191374f, 
    0.01329819f, -0.10416383f, 0.07071315f, -0.06273881f, -0.25493965f, 0.06625474f, -0.13925426f, 0.03970696f, 
    -0.14402145f, -0.06761473f, -0.06462952f, -0.08826090f, 0.03964440f, 0.08460900f, -0.14620470f, -0.03418174f, 
    -0.00235694f, 0.03290921f, 0.14279133f, 0.02390456f, 0.01445560f, 0.04993672f, 0.04277381f, -0.06308813f, 
    0.09290282f, 0.01564380f, -0.28116691f, -0.11024582f, 0.28581551f, 0.24867395f, 0.01655103f, -0.03412052f, 
    0.03898996f, -0.00562081f, -0.04446174f, -0.12037461f, -0.05225481f, 0.05729159f, -0.06884362f, 0.05013032f, 
    -0.12118825f, -0.10646674f, 0.00690301f, 0.01150449f, 0.02780038f, 0.07316948f, 0.00671145f, 0.11889898f, 
    -0.06049011f, 0.11660226f, 0.11446302f, 0.00046179f, -0.11541717f, -0.04813354f, 0.01891810f, 0.30430737f, 
    0.01873111f, -0.08537756f, -0.06533477f, 0.18245701f, -0.10589664f, -0.08270849f, 0.05184023f, 0.03996034f, 
    0.11052848f, -0.02258908f, 0.12391229f, 0.01234318f, 0.02761639f, 0.00352114f, 0.04260162f, -0.03516919f, 
    0.00282585f, -0.07400668f, -0.00071493f, 0.06580168f, -0.22575790f, -0.06241954f, 0.05028637f, 0.17624909f, 
    -0.01729243f, -0.04667121f, 0.03809520f, -0.02107851f, 0.08871923f, -0.00103086f, -0.18562312f, 0.06566458f, 
    0.11867354f, -0.14258528f, 0.04991666f, 0.30195951f, -0.07234111f, 0.11117046f, 0.13636848f, 0.06806174f, 
    0.08843441f, -0.06375407f, -0.01416467f, -0.02054493f, 0.09783310f, 0.00270249f, -0.12287761f, 0.03831659f, 
    -0.13407807f, -0.10798852f, 0.07498239f, 0.07035825f, 0.03552192f, 0.03186856f, -0.13723198f, -0.01666733f, 
    0.20300627f, -0.03376379f, -0.02925838f, -0.28559703f, -0.05126247f, -0.06445146f, 0.07602541f, 0.02870527f, 
    0.02540563f, 0.02405433f, 0.01551631f, 0.02910006f, 0.22164334f, 0.06911790f, -0.11578083f, -0.12112347f, 
    -0.00620945f, -0.00630767f, -0.04292157f, 0.04620713f, 0.03886651f, -0.06037327f, 0.00733512f, -0.06169555f, 
    -0.27016261f, 0.13231328f, -0.08660846f, 0.12436762f, -0.12031937f, 0.06154173f, -0.02180929f, -0.04097408f, 
    -0.13839649f, 0.00132078f, 0.04304940f, -0.06424788f, 0.04428820f, -0.15382259f, -0.05632676f, 0.01614412f, 
    -0.01929037f, -0.02284561f, 0.06730425f, -0.11597864f, 0.05110907f, 0.00351952f, -0.10844305f, 0.15035006f, 
    0.01973293f, 0.13965458f, -0.02526701f, 0.04722516f, 0.02834453f, 0.05903040f, -0.02416420f, 0.08475903f, 
    0.15080206f, 0.04954240f, 0.15238881f, -0.00723502f, -0.08940267f, 0.04769085f, -0.08331382f, 0.12296329f, 
    0.10782207f, 0.11955076f, 0.08946645f, 0.02843568f, -0.05431475f, 0.28353253f, 0.05902718f, 0.01119716f, 
    0.09640373f, -0.02447562f, 0.02645059f, -0.07008580f, 0.08944952f, -0.06340445f, 0.10387038f, 0.14155720f, 
    -0.08824940f, 0.08041436f, 0.09639415f, 0.07465543f, -0.33761919f, -0.01460246f, -0.04859364f, -0.15352614f, 
    -0.04695045f, 0.07269250f, 0.16572359f, -0.00815431f, 0.11619080f, 0.05248945f, 0.00204413f, -0.03082513f, 
    0.29996264f, 0.04728428f, 0.03811258f, -0.06361037f, -0.01178656f, 0.13401496f, -0.03562523f, 0.01311875f, 
    0.03496748f, 0.11544022f, -0.06989330f, 0.04821108f, -0.25532976f, -0.02434103f, 0.12341266f, -0.09488392f, 
    -0.05626400f, 0.05723549f, -0.16120827f, -0.00842223f, -0.08389784f, -0.19209756f, 0.08928647f, 0.09425807f, 
    0.04963821f, -0.10395883f, -0.09900754f, -0.16614790f, -0.03633889f, -0.13794413f, -0.04935248f, -0.07214434f, 
    -0.05137371f, -0.08510464f, 0.32291496f, -0.05438773f, -0.16029824f, 0.02512335f, -0.03810047f, 0.08383365f, 
    0.05630240f, 0.06711482f, 0.07310238f, -0.05665307f, -0.05519931f, 0.02510861f, -0.08546327f, 0.19246453f, 
    0.19889821f, -0.05222354f, 0.12446830f, 0.05340525f, -0.18751569f, -0.03378866f, 0.05738618f, 0.06130585f, 
    -0.04081532f, 0.19442856f, -0.01372781f, 0.20123364f, 0.24003984f, 0.12027585f, -0.08786198f, -0.02411997f, 
    0.24300085f, 0.00742512f, -0.02879894f, -0.03256192f, -0.06118319f, 0.05803495f, -0.12752514f, 0.09141643f, 
    0.14565857f, 0.12245014f, -0.04525441f, 0.02150563f, 0.11206732f, -0.09654418f, 0.14612287f, 0.05108375f, 
    0.01540698f, -0.05713907f, 0.18623018f, -0.10987361f, 0.03510474f, -0.03236985f, -0.01546312f, 0.10946785f, 
    0.09376839f, 0.16064090f, 0.00100504f, 0.01389993f, -0.02660622f, 0.15379679f, 0.08055390f, 0.15936849f, 
    -0.03166553f, -0.03823902f, -0.01250631f, 0.02072977f, 0.18005690f, 0.06459840f, -0.04737701f, -0.00912187f, 
    -0.00841366f, 0.01903075f, -0.14471817f, 0.06455959f, 0.02391669f, -0.13042282f, -0.03811945f, 0.13579525f, 
    0.02788032f, 0.09455279f, -0.03004536f, 0.18989401f, 0.11173144f, 0.20659423f, -0.12229550f, 0.04790553f, 
    0.15187733f, -0.12807740f, 0.07300784f, -0.22674562f, 0.19134282f, 0.16089232f, 0.05865699f, 0.02867264f, 
    0.12516306f, -0.05845911f, 0.03606036f, -0.12674262f, 0.05052900f, -0.02405044f, -0.11760921f, -0.18180214f, 
    0.12514172f, 0.10780808f, 0.03051063f, -0.18353994f, 0.02649396f, 0.14065661f, 0.09464448f, 0.04317793f, 
    0.09850849f, 0.11854251f, 0.05226504f, 0.07482397f, -0.05233992f, -0.03652246f, -0.08505169f, 0.05783051f, 
    0.08582266f, -0.03866801f, 0.11507811f, -0.03593112f, 0.23792142f, 0.03527962f, 0.10063579f, -0.15502961f, 
    0.06365386f, -0.06176344f, -0.13523208f, 0.12123978f, 0.08141030f, 0.10015681f, -0.15254161f, -0.11759134f, 
    -0.66073591f, -0.08504760f, -0.15907934f, -0.04053784f, 0.12704167f, -0.02375499f, -0.12220059f, -0.20065731f, 
    -0.00889173f, 0.00743142f, 0.06733267f, -0.04248100f, -0.24320701f, 0.01171134f, -0.02427003f, 0.15927136f, 
    -0.07148939f, -0.10667041f, -0.02217529f, -0.05307831f, 0.04125060f, 0.08149878f, -0.06950861f, -0.05283570f, 
    -0.06420577f, 0.04547485f, 0.21835205f, 0.04990738f, -0.10238852f, 0.14663891f, -0.03609969f, -0.07552593f, 
    -0.00960972f, -0.08876884f, -0.21317096f, -0.13427654f, 0.24985182f, 0.01080966f, -0.04300245f, -0.12338201f, 
    -0.03597629f, 0.15793993f, -0.03551817f, -0.15196007f, 0.08054895f, 0.08684118f, -0.11484060f, 0.10409693f, 
    0.09718324f, -0.07102458f, 0.08594412f, -0.03525225f, 0.07841098f, 0.12654993f, 0.09220140f, 0.17757568f, 
    -0.00010255f, 0.19169769f, 0.09569447f, 0.11236062f, -0.03969128f, 0.17525789f, -0.19708587f, 0.31552091f, 
    0.03860725f, -0.08863336f, 0.05515909f, 0.10558175f, 0.02467653f, -0.06698760f, 0.05591129f, -0.13046388f, 
    -0.00135410f, 0.04795876f, 0.25735742f, -0.07963774f, 0.06161156f, -0.04187468f, 0.05156097f, 0.04666957f, 
    0.02373571f, -0.15507014f, -0.00414120f, 0.15775727f, -0.13303551f, 0.05497699f, 0.03854518f, 0.11113074f, 
    0.16920160f, -0.06500792f, 0.24294674f, -0.04160117f, 0.17817202f, -0.02819465f, -0.03622274f, 0.13096039f, 
    0.26514259f, -0.01370230f, 0.01072673f, 0.12049849f, -0.04413838f, -0.00583224f, 0.08111095f, 0.16272312f, 
    0.13180026f, -0.11388987f, 0.06768326f, 0.02212994f, -0.07082839f, -0.03648223f, -0.02554261f, 0.22197594f, 
    -0.15378319f, -0.10925680f, -0.03268237f, 0.17963435f, 0.10536084f, 0.08431479f, -0.11984331f, 0.02653369f, 
    0.06223868f, 0.02485570f, 0.06937140f, -0.07200655f, 0.01751399f, 0.01470417f, -0.04600420f, 0.08340509f, 
    0.07499370f, 0.05796768f, 0.02083756f, 0.20041539f, 0.37298796f, 0.02421823f, -0.39331236f, -0.25552920f, 
    -0.00619677f, -0.02151410f, -0.07331649f, 0.05018715f, 0.21493714f, -0.08772517f, -0.09258593f, -0.09145001f, 
    -0.23467778f, 0.02421064f, 0.12392618f, 0.15636921f, -0.02144552f, 0.06722219f, 0.06431417f, -0.07870052f, 
    -0.17345922f, 0.04079820f, 0.06123789f, -0.03667140f, 0.07833037f, -0.07487818f, -0.27089846f, -0.27769095f, 
    0.14292064f, -0.06601262f, 0.08125593f, -0.13393569f, 0.13981336f, -0.01191783f, -0.16662039f, 0.00650961f, 
    0.15529585f, -0.12454752f, -0.19947067f, 0.08749211f, -0.05615126f, -0.07834268f, -0.06579918f, 0.00804679f, 
    0.14432366f, -0.01307361f, 0.07664922f, 0.03889898f, -0.20163640f, -0.06822428f, 0.05864137f, -0.02653784f, 
    0.05274375f, 0.05457026f, 0.06898929f, 0.03851575f, -0.00694581f, 0.06419061f, 0.06447559f, -0.06277267f, 
    -0.16684051f, -0.12190143f, 0.12359451f, -0.15365109f, -0.14502247f, -0.05343172f, 0.07616238f, -0.01925864f, 
    -0.08262490f, -0.01763506f, 0.05969596f, 0.14084116f, 0.22498976f, -0.27730468f, 0.04878117f, 0.01644000f, 
    0.03844596f, 0.10682252f, -0.04847533f, 0.00558479f, 0.01345102f, 0.03619978f, 0.05510211f, -0.07978477f, 
    0.08555949f, 0.07699163f, -0.03964378f, 0.00034628f, 0.06125190f, 0.12572761f, -0.08710790f, -0.01170970f, 
    0.09037104f, 0.06553647f, 0.04023225f, -0.00427687f, 0.02622144f, -0.14322045f, 0.26496056f, 0.13025445f, 
    0.01557515f, 0.04029811f, 0.01215862f, 0.03955931f, 0.07563065f, -0.17927419f, -0.00353121f, 0.00451987f, 
    0.35084459f, 0.16399230f, 0.06625241f, 0.09335531f, 0.03778002f, 0.00432252f, 0.06624893f, -0.08002333f, 
    -0.04853388f, 0.03281051f, 0.10815377f, 0.06998760f, -0.17306381f, -0.02899697f, -0.27812141f, -0.06463294f, 
    -0.01450026f, 0.18383242f, 0.13613102f, -0.05215634f, 0.12056874f, 0.12389793f, 0.07779890f, -0.06162623f, 
    0.37492973f, 0.19662000f, 0.09752917f, -0.05419939f, -0.01325373f, 0.07251011f, 0.04000765f, 0.02462196f, 
    -0.00987315f, 0.05320540f, 0.07804795f, 0.10472751f, 0.16180727f, 0.13283648f, -0.01401935f, -0.07115427f, 
    0.14574061f, -0.05643580f, 0.06143108f, 0.13417833f, -0.08846731f, -0.02713146f, 0.06063120f, -0.00717716f, 
    -0.27909839f, -0.18423796f, -0.02592143f, 0.00231976f, 0.03385134f, 0.00289058f, 0.12861793f, 0.01141593f, 
    -0.01400021f, -0.05811302f, 0.06884051f, 0.15879442f, -0.28955558f, -0.08796306f, 0.00996201f, -0.00716809f, 
    0.00672250f, -0.03467240f, 0.04207928f, -0.06671292f, 0.01325022f, 0.04800167f, 0.09377132f, 0.07914878f, 
    -0.19733383f, -0.01609654f, -0.02620483f, -0.19153902f, 0.06210038f, 0.04727354f, 0.05450120f, 0.00245982f, 
    0.03224477f, 0.03083501f, 0.01895866f, -0.00518818f, -0.35276234f, -0.04825905f, -0.02564089f, 0.06270660f, 
    0.14002362f, 0.07576057f, 0.11259623f, 0.13089904f, -0.01454183f, 0.01133509f, -0.06469603f, -0.07571866f, 
    0.04301186f, -0.16035487f, 0.02066769f, -0.20906609f, 0.16105311f, 0.03136920f, 0.07272206f, 0.05151810f, 
    0.03659829f, -0.04067697f, 0.10000480f, 0.01624413f, 0.03094529f, -0.09335066f, -0.18509842f, -0.15041018f, 
    0.15142223f, 0.19402577f, -0.04330345f, -0.02147184f, 0.07529721f, 0.08068147f, -0.10028284f, 0.02890109f, 
    0.17712092f, 0.10306232f, 0.10337207f, 0.31920248f, 0.07536314f, 0.15035063f, -0.02973178f, -0.07908539f, 
    0.01610286f, -0.01515897f, -0.05750741f, 0.06312849f, 0.12892903f, 0.04210571f, -0.18444131f, -0.33287805f, 
    0.09720222f, 0.03444104f, -0.07976528f, 0.01600658f, 0.07153590f, 0.02014239f, -0.14385639f, -0.00864704f, 
    0.32910490f, -0.39224991f, -0.06545579f, -0.00999041f, 0.05290279f, 0.13036528f, 0.05833835f, -0.07473921f, 
    -0.00756148f, -0.04528756f, 0.10195792f, 0.04398272f, 0.02532774f, 0.06150201f, -0.12913457f, 0.12023668f, 
    -0.08597998f, -0.08258434f, -0.04490671f, 0.12775521f, 0.11129790f, 0.09461935f, 0.05875369f, -0.10465154f, 
    -0.13082650f, 0.13533011f, 0.05247311f, 0.08892548f, 0.07687615f, 0.10535385f, 0.04038689f, -0.00976866f, 
    -0.00849716f, 0.16345449f, -0.14289920f, -0.04206340f, 0.29647848f, 0.01730177f, -0.05693477f, 0.00703586f, 
    0.07766365f, -0.04112806f, 0.06114520f, -0.01157270f, 0.06866308f, 0.09131820f, -0.05490800f, 0.11446957f, 
    -0.18269247f, -0.13807149f, -0.05246707f, 0.01442591f, 0.03334744f, -0.00566529f, -0.00112909f, 0.13382427f, 
    -0.01765906f, 0.09468685f, -0.03462398f, 0.08496390f, -0.31576115f, -0.02751593f, -0.20859243f, 0.04103504f, 
    0.00208195f, -0.05159631f, -0.03182257f, -0.02427226f, 0.11769303f, -0.08100336f, 0.07098528f, 0.03433461f, 
    0.27175498f, 0.34373122f, 0.36613384f, 0.06647359f, 0.11358490f, 0.02875957f, 0.07842495f, 0.03201817f, 
    -0.02613675f, -0.10970123f, 0.10276009f, -0.02118229f, -0.02951771f, 0.22684781f, -0.07079619f, 0.07748015f, 
    0.10848598f, 0.01393233f, 0.09196397f, 0.02503348f, 0.11094028f, -0.01987454f, -0.04358419f, -0.08262444f, 
    0.19158024f, 0.16026458f, 0.11750667f, 0.11319534f, -0.10668775f, -0.07137744f, 0.07504272f, 0.00529204f, 
    -0.10029448f, -0.02332383f, -0.11689399f, 0.00107559f, 0.15792392f, 0.02022999f, -0.02912243f, 0.07747882f, 
    -0.17126678f, -0.04444486f, 0.11401518f, -0.09845080f, -0.07406444f, -0.07900663f, -0.06825317f, -0.03020059f, 
    0.12110911f, 0.13528374f, 0.20238785f, -0.15971988f, 0.02959698f, -0.11077489f, 0.08072197f, -0.04853691f, 
    -0.07845034f, -0.10134169f, 0.04356247f, 0.10289252f, 0.01051109f, 0.00016925f, -0.20067129f, -0.19565320f, 
    0.18747447f, 0.03009908f, -0.09873290f, 0.20928992f, 0.04394464f, 0.01244530f, -0.02986708f, 0.11103462f, 
    -0.03197164f, 0.00044595f, -0.12271411f, 0.09056993f, -0.08790353f, 0.22873722f, -0.02627386f, -0.10227346f, 
    0.00726649f, 0.08175813f, 0.14584827f, -0.06822839f, -0.23240247f, -0.07584075f, -0.24284591f, -0.11229178f, 
    -0.02674516f, 0.06921269f, -0.10777078f, 0.00878310f, 0.02325412f, 0.03963649f, -0.09241319f, 0.10641969f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.07147641f, -0.04222701f, -0.01087920f, -0.03172004f, 0.00172222f, -0.03110559f, -0.03696986f, 0.01703021f, 
    0.03616711f, 0.02575909f, 0.08601345f, 0.03449599f, 0.04554478f, -0.03744926f, 0.05054882f, -0.04114547f, 
    -0.01596696f, 0.14956439f, 0.01643471f, 0.00248200f, -0.04049865f, 0.02840577f, -0.01901927f, 0.12522417f, 
    0.03227870f, -0.02905656f, -0.00719513f, -0.01007028f, 0.01300199f, 0.05909720f, 0.09881770f, -0.04956099f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.03592980f, 0.22900529f, 0.15465036f, 0.03976288f, 0.66296870f, 0.24266909f, -0.01167107f, 0.04162069f, 
    0.00786832f, 0.29325125f, -0.16486180f, 0.45597798f, 0.26963556f, 0.01171100f, -0.22756332f, -0.09820037f, 
    0.10506985f, 0.04654648f, -0.35973787f, -0.13343365f, 0.09464902f, 0.14084899f, 0.02275830f, 0.29324266f, 
    0.15162697f, -0.05785472f, 0.11789712f, -0.08602166f, 0.16395046f, 0.10139666f, -0.31870997f, -0.10216536f, 
    0.37808782f, -0.13029009f, -0.11917188f, -0.14933552f, 0.31626907f, 0.15742578f, -0.03516543f, -0.02951335f, 
    0.14721346f, 0.08909098f, -0.00785108f, -0.07865211f, -0.47289670f, 0.13033837f, -0.33546194f, -0.15574680f, 
    0.08626698f, 0.05380247f, 0.24959134f, 0.10356476f, 0.04771204f, 0.05626657f, 0.18381605f, 0.38041848f, 
    0.01505314f, 0.02224334f, -0.14993836f, 0.08034585f, 0.00432513f, -0.20239811f, 0.22985399f, 0.31622940f, 
    0.03964429f, 0.26275569f, -0.09868073f, -0.02594547f, -0.06576364f, 0.02413617f, 0.01908851f, -0.01101329f, 
    0.12742828f, 0.07265980f, -0.33407220f, 0.10068952f, -0.36818123f, -0.04341166f, -0.70205784f, -0.10714029f, 
    -0.16829525f, 0.20405219f, 0.14811814f, -0.01818691f, 0.01400704f, 0.05956599f, -0.00084656f, 0.30199847f, 
    -0.08134211f, -0.08033363f, -0.01821650f, 0.12671009f, 0.14474225f, -0.18825294f, 0.07139398f, 0.18265633f, 
    -0.12504680f, 0.28758290f, 0.08424591f, -0.08798993f, -0.29155731f, 0.39557183f, 0.04781997f, -0.17228216f, 
    -0.03073999f, -0.11735176f, 0.09560852f, 0.05072641f, -0.35991117f, -0.03688727f, 0.28075579f, 0.13603011f, 
    0.01878089f, -0.23268870f, 0.28863454f, 0.18790276f, 0.05513126f, -0.08832397f, 0.25745350f, -0.29018015f, 
    0.09628365f, 0.00024998f, 0.00316978f, 0.17476767f, 0.14182340f, -0.06174218f, -0.32491875f, -0.07152717f, 
    0.68995464f, 0.13187489f, -0.01540372f, 0.13634679f, -0.05013805f, -0.27195928f, -0.16096662f, 0.13590203f, 
    -0.11199030f, 0.08586575f, -0.22298767f, 0.44377610f, -0.08083378f, -0.08464695f, 0.46918774f, 0.01183777f, 
    0.07791325f, -0.02349175f, 0.27076015f, 0.11404546f, -0.07442582f, 0.06357596f, 0.20192866f, 0.01432304f, 
    -0.23525335f, -0.13210055f, -0.17120157f, 0.16769226f, -0.00155368f, 0.11103352f, -0.01035512f, -0.29813749f, 
    0.42610300f, 0.16753279f, 0.17290832f, 0.07724944f, 0.03226206f, -0.09967077f, 0.14332800f, -0.09008858f, 
    0.12362015f, -0.49247491f, -0.42953151f, -0.39683625f, 0.18844886f, -0.06803393f, -0.20081887f, 0.24599431f, 
    -0.10456428f, -0.25533172f, -0.06076571f, 0.28484213f, -0.00175347f, 0.13906859f, 0.17886335f, -0.04016326f, 
    0.38049710f, -0.13365701f, -0.01695195f, -0.04116084f, -0.13400346f, 0.38684356f, 0.17813592f, 0.31731319f, 
    -0.17115751f, 0.12618099f, 0.07606382f, -0.13820681f, 0.03347173f, 0.14380875f, -0.06320354f, -0.06326883f, 
    0.04500361f, -0.17859830f, -0.14318405f, -0.08539227f, -0.10501147f, -0.05379788f, 0.07357632f, -0.00036981f, 
    -0.00976529f, -0.06846936f, -0.03499911f, -0.11313479f, 0.00690363f, -0.09551618f, -0.08634618f, 0.03607323f, 
    -0.03349851f, -0.13032763f, -0.10307553f, -0.01834949f, -0.01777327f, -0.09843157f, -0.12127992f, 0.06329396f, 
    0.36048025f, 0.00438086f, -0.03261426f, -0.09284438f, -0.20635834f, 0.07550446f, 0.00650273f, -0.07440597f, 
    -0.09565969f, 0.26612911f, 0.30320504f, 0.08069844f, -0.04941458f, -0.02009607f, 0.47064516f, 0.18780558f, 
    -0.13061742f, 0.09059026f, -0.44776714f, 0.23377149f, -0.00912393f, -0.14248243f, 0.08774423f, -0.60380524f, 
    0.21965121f, 0.16361324f, 0.13170378f, 0.06090276f, -0.06461499f, 0.54370397f, -0.16456559f, 0.11035809f, 
    -0.52112705f, 0.25424618f, 0.02848166f, -0.08119352f, -0.26689592f, 0.38589692f, -0.06889454f, 0.08531051f, 
    0.13467979f, 0.15267101f, -0.19063529f, -0.21768332f, -0.19996518f, 0.15516129f, -0.05476841f, 0.12122963f, 
    0.15453537f, 0.25193986f, 0.23897207f, 0.06238004f, -0.14814617f, -0.09938069f, 0.23153587f, -0.17217870f, 
    0.18600346f, -0.12977460f, 0.14807644f, -0.02407300f, -0.09684985f, -0.33607158f, -0.34231701f, -0.00681079f, 
    0.04736074f, 0.03882951f, 0.06408403f, 0.14701849f, -0.05674260f, -0.16603903f, -0.07176837f, 0.01772108f, 
    0.00293632f, 0.01323928f, -0.16245078f, 0.10045671f, -0.11253138f, -0.14356384f, -0.10945024f, -0.00341867f, 
    0.13696112f, 0.00650542f, 0.03379539f, -0.03371917f, -0.09570984f, 0.04255968f, -0.01015233f, -0.03948366f, 
    -0.14490949f, 0.13762906f, -0.02071849f, 0.03497024f, -0.04092427f, -0.01907751f, -0.14987385f, -0.12761484f, 
    0.05139262f, -0.13491639f, -0.07596419f, 0.16431752f, -0.12586659f, 0.01283395f, -0.10650264f, -0.00233780f, 
    0.10845168f, -0.12888131f, -0.04997695f, -0.06074872f, -0.08480190f, -0.05223737f, -0.16957301f, -0.12238471f, 
    -0.13232298f, 0.01934351f, 0.06971860f, -0.07138173f, -0.02153550f, 0.00754922f, 0.11933486f, -0.03610175f, 
    -0.14210232f, 0.15525064f, 0.11801446f, -0.06521393f, 0.04516431f, 0.06154894f, -0.13432114f, 0.09003641f, 
    -0.06887861f, -0.05361443f, 0.15327498f, -0.04265586f, -0.02922988f, -0.18526566f, -0.09114617f, 0.13933545f, 
    0.03246631f, -0.27458206f, 0.21843761f, -0.08924357f, -0.30191132f, 0.15776581f, 0.04403023f, 0.25838262f, 
    -0.05267714f, -0.01230881f, -0.19707958f, -0.12049927f, -0.12012072f, 0.15862906f, 0.09273644f, 0.16719261f, 
    0.38475174f, 0.07777984f, -0.06534985f, -0.03768091f, -0.09719819f, 0.21380629f, 0.20534068f, 0.13879138f, 
    0.00784242f, 0.35926816f, -0.01933061f, -0.10073131f, 0.43773967f, 0.22398141f, 0.12632997f, 0.11230407f, 
    0.02180303f, 0.05234240f, -0.01886933f, 0.58552319f, -0.11144644f, -0.15308578f, 0.22763838f, -0.11846153f, 
    0.04583596f, 0.32536542f, -0.01987887f, 0.14253438f, 0.14215635f, 0.07075870f, 0.07974299f, -0.41458654f, 
    -0.13104720f, -0.04106865f, -0.07377311f, -0.04096024f, -0.00879693f, -0.10938993f, -0.13335606f, -0.48996168f, 
    0.57011175f, 0.37867379f, -0.09789664f, 0.01549687f, 0.29091734f, 0.09742413f, -0.01379342f, 0.03178412f, 
    0.06802695f, 0.13987374f, 0.31322268f, 0.14001127f, 0.34323549f, 0.11681020f, -0.06239731f, -0.10974957f, 
    0.08232296f, -0.29476097f, 0.30141422f, -0.02105759f, -0.03788250f, 0.02209323f, -0.03776014f, 0.07848767f, 
    -0.21313427f, 0.04927989f, -0.07262456f, -0.14286467f, -0.03679503f, 0.43871564f, 0.11286192f, -0.02920894f, 
    -0.09178516f, -0.18205984f, -0.01420261f, -0.01068368f, 0.02153074f, -0.17662050f, -0.09198794f, 0.12399171f, 
    -0.02250941f, 0.01703991f, 0.02506540f, 0.03746590f, -0.16306964f, 0.06903350f, -0.06129271f, -0.02400600f, 
    0.11567442f, 0.02891227f, -0.12784481f, -0.14906000f, 0.05337038f, 0.10708019f, 0.09996771f, -0.11686706f, 
    -0.14117561f, -0.00706105f, -0.16322933f, 0.16642287f, 0.05747703f, -0.15369332f, 0.09641106f, -0.14220399f, 
    0.04898620f, -0.07682736f, 0.10372923f, -0.11066605f, -0.18013181f, -0.14816763f, -0.11486884f, -0.12363946f, 
    -0.09112083f, -0.18999158f, -0.01368600f, -0.13448139f, -0.10878800f, -0.00894250f, 0.08096242f, -0.07729051f, 
    -0.10275526f, 0.05879185f, -0.07185459f, 0.11675498f, 0.08663793f, 0.04765407f, -0.03081110f, 0.05293422f, 
    -0.11458322f, 0.03698271f, -0.05273266f, -0.06596660f, 0.05915854f, -0.14028439f, -0.04740233f, -0.08873063f, 
    0.01882704f, 0.14140441f, -0.03934965f, -0.01738720f, -0.09261778f, -0.08795021f, -0.09890588f, 0.10745769f, 
    0.08295026f, -0.08838036f, -0.04836581f, -0.08891358f, -0.09063695f, -0.11509364f, -0.12810840f, -0.09596740f, 
    0.09891795f, -0.14250006f, -0.08164825f, 0.10911060f, 0.04811794f, 0.14234093f, 0.05933022f, -0.16683231f, 
    -0.16908208f, -0.10017395f, -0.15649940f, 0.06776933f, 0.00110107f, -0.10470788f, -0.17355362f, -0.14846770f, 
    -0.22541352f, -0.05278767f, 0.03579032f, 0.02470545f, -0.20135476f, 0.22832243f, 0.09162614f, -0.00296788f, 
    -0.11805951f, -0.36770043f, -0.21823260f, -0.25029868f, 0.19629101f, 0.06963108f, 0.30854923f, 0.37869754f, 
    0.15406086f, -0.11977874f, -0.02661160f, 0.13926187f, -0.02097580f, 0.16561307f, 0.25610980f, 0.12612557f, 
    0.38300556f, 0.01573717f, 0.07019389f, -0.07026275f, -0.08668309f, -0.10585924f, -0.06242893f, 0.22548155f, 
    0.00557602f, -0.06771886f, -0.03401646f, 0.07356636f, 0.67794240f, -0.05717386f, -0.03405847f, 0.16459048f, 
    0.12192967f, 0.41367844f, 0.33535135f, 0.22147025f, -0.23174807f, -0.11341204f, -0.23868623f, -0.31361452f, 
    0.04433553f, 0.22183712f, -0.20571490f, -0.03078213f, 0.15822582f, 0.10959905f, 0.18304120f, 0.24602452f, 
    0.00504469f, 0.00675300f, 0.09610949f, 0.12541842f, -0.04197741f, 0.03697667f, -0.00326625f, 0.02068903f, 
    -0.33692956f, -0.29219222f, 0.02357552f, -0.14704168f, 0.11567774f, 0.28744701f, 0.04180877f, -0.04248033f, 
    0.10904544f, -0.30208826f, 0.07979779f, -0.20771596f, -0.04272332f, 0.01389385f, 0.11055699f, 0.21385613f, 
    -0.04069918f, 0.19717367f, -0.10915326f, 0.03716117f, 0.07773913f, 0.17962167f, 0.24480829f, 0.36662117f, 
    0.41598728f, -0.06564053f, 0.00556065f, -0.11387835f, -0.13809261f, -0.34600189f, -0.44359854f, -0.04076220f, 
    -0.27958366f, 0.27693626f, 0.14556509f, -0.01102167f, 0.55894381f, 0.31802884f, 0.16402397f, -0.12047929f, 
    0.07907382f, -0.20537436f, 0.13024378f, 0.04600329f, 0.47093791f, -0.01676842f, -0.57338071f, -0.04841099f, 
    0.01979931f, -0.19146961f, 0.33634740f, -0.17526688f, 0.08011553f, -0.12428109f, 0.03654746f, 0.23670706f, 
    0.18826438f, -0.00457306f, 0.14686660f, -0.01004036f, -0.14466400f, 0.15532990f, 0.04447244f, -0.08657131f, 
    0.02161569f, 0.00418442f, -0.08961668f, 0.09906901f, 0.21042702f, 0.29925826f, 0.03375285f, -0.04449729f, 
    -0.06806786f, -0.07796939f, -0.02872522f, 0.14630322f, 0.35574174f, 0.15985541f, -0.46838763f, -0.20518431f, 
    -0.11186910f, 0.21178293f, -0.01145267f, 0.15716289f, -0.02059938f, -0.08452167f, -0.07701052f, -0.20218107f, 
    0.17781943f, -0.11345760f, 0.04876747f, -0.06106541f, -0.05996674f, 0.13489676f, 0.37131208f, -0.02457156f, 
    -0.02391662f, -0.28308046f, 0.08116627f, -0.01274703f, 0.05292941f, -0.27767408f, 0.17667691f, -0.06074381f, 
    0.18157099f, 0.30233094f, 0.40832856f, -0.03404286f, 0.21909888f, 0.10277058f, 0.18912777f, -0.14016645f, 
    0.09285571f, 0.27792278f, 0.09977808f, -0.28809798f, 0.05235018f, 0.12285750f, 0.04690269f, 0.54306650f, 
    -0.07271615f, -0.01027825f, -0.14466599f, 0.08071154f, 0.14204682f, 0.00680635f, 0.48365232f, -0.07761076f, 
    0.42277983f, 0.11032422f, -0.09543301f, -0.06513429f, -0.34610057f, 0.07474753f, -0.06429750f, -0.12130790f, 
    -0.05097630f, 0.51393735f, -0.40529862f, -0.34843636f, -0.41756633f, -0.03475485f, 0.00016216f, 0.09816179f, 
    -0.06542255f, 0.34591174f, 0.25610521f, 0.05575638f, 0.06713857f, 0.13939755f, 0.15187493f, 0.25646600f, 
    -0.04151060f, 0.01243539f, -0.02797782f, 0.18164699f, 0.17597422f, -0.50334615f, -0.25027508f, 0.08969523f, 
    -0.15893501f, 0.12858307f, -0.01342769f, -0.16327792f, 0.14429985f, -0.15182687f, 0.10626661f, 0.15056916f, 
    0.10904981f, 0.34647244f, -0.10760843f, 0.31892937f, 0.17453641f, 0.16592254f, 0.41100609f, 0.30510768f, 
    0.06292314f, 0.37105516f, 0.14952265f, -0.23216194f, 0.00427244f, -0.02686032f, -0.06503808f, 0.45702025f, 
    -0.05901596f, 0.00782921f, 0.12692614f, 0.07842994f, 0.15218100f, -0.37011346f, -0.17980354f, -0.09552468f, 
    0.00151223f, 0.21591865f, -0.13896815f, -0.01496694f, 0.16030274f, -0.14110516f, -0.11262029f, 0.14889576f, 
    -0.02576778f, 0.42306766f, 0.44413489f, 0.32596430f, -0.31081465f, -0.02321657f, 0.37128395f, 0.05897008f, 
    -0.13755606f, 0.03810347f, 0.10685872f, -0.12911239f, 0.09593276f, 0.04834115f, 0.10191977f, 0.17956911f, 
    -0.26317847f, -0.10775394f, 0.06609825f, -0.10866787f, -0.10638712f, 0.16869436f, 0.23646545f, -0.33738413f, 
    0.35688046f, -0.04389277f, 0.12218095f, -0.03578374f, -0.29833230f, -0.25167748f, 0.14477628f, 0.10301758f, 
    -0.06285193f, 0.08652136f, 0.28609613f, 0.14991260f, 0.32858083f, 0.08630412f, 0.50523537f, 0.25232461f, 
    0.01072799f, 0.35779566f, -0.29944509f, 0.03982681f, -0.04330332f, 0.00007412f, -0.12150094f, 0.16010422f, 
    -0.22741866f, 0.16634344f, -0.04025439f, 0.00093148f, 0.10072378f, 0.03074499f, 0.28716132f, -0.16240034f, 
    -0.17554742f, -0.01441308f, 0.12112163f, -0.16405106f, -0.15302189f, 0.10758549f, 0.01511846f, 0.07312217f, 
    0.16098918f, 0.02321941f, -0.03766843f, 0.13650507f, 0.07657555f, 0.06817368f, 0.11436947f, 0.02154003f, 
    -0.01048782f, -0.00627192f, -0.16536531f, -0.07986756f, 0.10322474f, -0.17514953f, -0.11430899f, -0.11854418f, 
    -0.08167268f, -0.02391713f, 0.00788132f, -0.08310074f, -0.08588003f, 0.00028264f, -0.13667278f, -0.04590750f, 
    0.01987967f, 0.01696720f, -0.08082986f, -0.14910699f, 0.08466151f, 0.09701300f, 0.15073290f, -0.03874806f, 
    -0.02201096f, -0.08457180f, -0.13309214f, 0.09778883f, -0.02135444f, -0.14133671f, -0.04964944f, -0.03925424f, 
    0.01909212f, -0.09692504f, -0.11054308f, -0.17039302f, 0.00573456f, 0.11936133f, -0.00841880f, -0.15591495f, 
    0.14989583f, -0.17610544f, -0.09767643f, 0.17658493f, -0.12620471f, -0.10902436f, -0.04787843f, 0.12933740f, 
    0.44877777f, 0.13656482f, -0.07213528f, 0.13641793f, -0.27102730f, 0.25300950f, 0.03261248f, -0.10155030f, 
    0.04898658f, -0.13364010f, -0.15342318f, -0.28504729f, 0.14113711f, -0.05106535f, -0.09175573f, -0.13078336f, 
    -0.04555333f, -0.03338466f, 0.52651900f, 0.34970868f, -0.11404485f, 0.15045062f, 0.19922400f, 0.02920841f, 
    -0.28999692f, -0.10397350f, 0.02516053f, -0.10226370f, -0.09123925f, -0.34976742f, 0.07828087f, 0.01003222f, 
    -0.08188218f, -0.13700578f, -0.04573076f, -0.11308768f, -0.28287143f, -0.06147702f, -0.12346334f, -0.15649873f, 
    -0.02633848f, 0.14937352f, 0.39013302f, -0.29468879f, -0.02343082f, -0.01826231f, -0.27462709f, 0.08803520f, 
    -0.05145380f, 0.27155808f, -0.13807315f, 0.19234774f, -0.16348490f, -0.01093916f, -0.00623040f, -0.26833689f, 
    0.27234039f, 0.16590688f, -0.07842705f, 0.12049135f, 0.08098245f, 0.39270627f, 0.59170848f, 0.40550739f, 
    -0.48159885f, 0.26500219f, 0.15108219f, 0.10899047f, 0.16457574f, 0.27095285f, -0.00722551f, -0.00735954f, 
    0.04204044f, 0.17217085f, -0.25424382f, -0.27384257f, 0.14642937f, -0.16149123f, 0.17445135f, -0.01751043f, 
    -0.07229656f, 0.25255832f, 0.38135114f, 0.17182156f, 0.17201966f, 0.08275469f, 0.17937028f, 0.07288639f, 
    -0.03902417f, 0.05384631f, -0.08797476f, -0.13182010f, -0.15537101f, -0.42292455f, -0.16877367f, -0.23178925f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.09785528f, -0.11716758f, 0.03997180f, 0.06298141f, -0.09390981f, 0.06336189f, 0.11363643f, 0.04137632f, 
    -0.00238922f, -0.11358304f, -0.11952148f, 0.15817802f, -0.03206116f, -0.08898857f, 0.16499560f, -0.19993907f, 
    -0.10172730f, -0.00555665f, 0.01632272f, 0.16718437f, 0.16163367f, 0.09742618f, 0.17098911f, 0.13887326f, 
    0.20140393f, 0.01945620f, 0.07845253f, -0.00954864f, -0.19071546f, 0.02651027f, 0.31926277f, 0.08415898f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.59313858f, -0.08597249f, -0.44050533f, 0.42543539f, -0.31246957f, 0.24506016f, -0.08951169f, 0.30022788f, 
    0.20267954f, -0.03800820f, 0.00282896f, 0.03514022f, -0.29602408f, 0.14899969f, 0.05137393f, 0.12139157f, 
    -0.14790593f, 0.09076374f, -0.51193541f, -0.20091747f, 0.13763064f, 0.13919120f, -0.38043484f, -0.30691233f, 
    -0.57728261f, -0.36046475f, -0.34016290f, 0.06034215f, -0.00737887f, 0.20314535f, 0.28944096f, -0.02440264f, 
    -0.16025649f, -0.18075299f, -0.13601854f, -0.20833476f, -0.26880461f, 0.20788936f, -0.12505394f, 0.28300560f, 
    -0.25989649f, 0.11758057f, -0.06837970f, 0.42495978f, 0.15919371f, -0.15771294f, -0.04792371f, 0.10973963f, 
    0.14913860f, 0.08766130f, 0.07788762f, -0.08496340f, -0.01853360f, 0.29635108f, -0.02432222f, -0.68325078f, 
    -0.29062024f, -0.07506821f, 0.28175604f, -0.12837601f, -0.17753713f, -0.49687263f, 0.30401418f, -0.48271161f, 
    0.56978393f, -0.00381163f, -0.20885253f, -0.14432718f, -0.68356830f, 0.08119184f, 0.13359444f, 0.17102429f, 
    0.05213752f, 0.13834518f, 0.13548346f, 0.01551431f, 0.10513798f, -0.15486957f, 0.11365296f, 0.05147657f, 
    0.03937843f, 0.16793007f, 0.32206631f, 0.26742741f, 0.18077254f, -0.06467667f, -0.21495990f, -0.33612052f, 
    0.07253558f, -0.41321775f, -0.41692808f, -0.17384006f, -0.16198403f, -0.49957126f, -0.14379114f, 0.04497569f, 
    0.21009454f, -0.95256054f, -0.41423619f, 0.07958802f, 0.17498969f, -0.14562544f, -0.03940403f, 0.28460008f, 
    0.03995212f, 0.11493196f, 0.05025805f, -0.72471201f, 0.20386288f, 0.06719100f, 0.13204293f, -0.06670025f, 
    -0.00793328f, -0.09568947f, -0.30613378f, -0.54086697f, -0.14678702f, -0.19379991f, -0.16666764f, 0.00206156f, 
    0.34825516f, 0.10760594f, 0.37778065f, -0.02281408f, -0.07163995f, -0.05855241f, -0.24596851f, 0.18728288f, 
    -0.15243120f, -0.08442626f, -0.24205799f, 0.41174388f, 0.22727109f, -0.03892466f, -0.07546982f, 0.38556406f, 
    0.17144176f, 0.13094355f, 0.13768716f, -0.09656715f, 0.21330144f, -0.16975564f, -0.10893088f, -0.03924204f, 
    -0.16064531f, 0.03993864f, -0.10256182f, 0.23063862f, -0.27940986f, -0.20829700f, -0.40719202f, 0.17641634f, 
    -0.02762855f, -0.20956123f, 0.01640637f, 0.10131282f, -0.08419108f, 0.18765664f, -0.19042607f, -0.10075228f, 
    0.07108953f, 0.32415873f, 0.19679669f, -0.38890970f, 0.17962337f, 0.30542684f, -0.16729099f, 0.18200475f, 
    -0.39185125f, -0.13674740f, -0.04656978f, -0.02119745f, -0.44622484f, 0.06928717f, 0.11108364f, -0.05642042f, 
    -0.01686763f, -0.04693677f, 0.07891353f, -0.30790716f, -0.31229115f, -0.11230673f, -0.00948475f, 0.33908135f, 
    -0.14538343f, -0.30052617f, 0.23387097f, -0.07285728f, -0.01439234f, 0.30796424f, 0.06861414f, -0.38880670f, 
    -0.74011159f, -0.03125988f, -0.25869268f, -0.00368501f, -0.15285105f, -0.00614015f, -0.14047138f, -0.01559033f, 
    0.06252401f, -0.07361403f, -0.03487216f, 0.28181124f, -0.88373303f, -0.47795993f, 0.17122020f, 0.04075030f, 
    0.00374789f, 0.28742373f, -0.29551744f, 0.33817890f, -0.32664549f, -0.75606000f, 0.15384458f, 0.13055304f, 
    0.27192825f, -0.18451872f, 0.26778132f, 0.11212087f, -0.04592108f, 0.07048228f, -0.05626826f, 0.14763683f, 
    0.03360004f, 0.17942809f, 0.41010931f, 0.21435004f, 0.19571331f, -0.05749343f, 0.07949601f, -0.15192468f, 
    0.03304746f, -0.13452651f, 0.15869993f, 0.11829223f, 0.30264586f, 0.07323570f, 0.09325435f, 0.09209325f, 
    -0.03121693f, -0.45867988f, 0.23177150f, -0.38938349f, 0.02600682f, 0.01842386f, -0.33955291f, 0.14593405f, 
    -0.23327781f, 0.07238832f, -0.49034914f, -0.17031986f, 0.10019896f, 0.17272320f, -0.40238127f, 0.25273237f, 
    0.09501492f, 0.27921718f, 0.03757909f, 0.13030727f, 0.19689299f, 0.03632697f, -0.02065640f, -0.23101237f, 
    -0.60278821f, 0.00815023f, -0.11503942f, 0.26176098f, -0.52371782f, 0.39741838f, 0.14231583f, -0.04547684f, 
    -0.10185958f, -0.22868048f, 0.25759426f, -0.15908548f, 0.28851971f, -0.42497903f, 0.12719198f, -0.33697364f, 
    0.10785817f, 0.32250029f, -0.21011846f, 0.14188094f, -0.08541295f, -0.37150151f, -0.15182796f, -0.53111088f, 
    -0.10156653f, 0.08100690f, 0.57798225f, 0.16835956f, -0.36447328f, 0.13277024f, 0.05560701f, -0.43905056f, 
    0.37450123f, -0.13797081f, 0.16265553f, -0.06657171f, -0.27661574f, -0.43711776f, 0.07120650f, -0.06967813f, 
    0.02000711f, 0.19660653f, -0.26432294f, 0.15776530f, 0.21354081f, 0.02428902f, -0.23999770f, 0.29493448f, 
    0.09655347f, -0.66607904f, -0.50638586f, -0.07629143f, 0.01527780f, 0.12714054f, -0.16740523f, 0.28570947f, 
    -0.05231181f, -0.10458750f, -0.20991743f, -0.52203029f, -0.14453827f, -0.31174448f, 0.13984647f, -0.24959984f, 
    -0.31898385f, 0.07954372f, 0.13751332f, -0.56368351f, 0.17300589f, 0.09810919f, -0.04364922f, 0.09236562f, 
    0.06903468f, -0.43468994f, 0.25907272f, -0.04687293f, 0.22410122f, 0.49664217f, 0.27440301f, -0.32467183f, 
    0.09455714f, 0.00204532f, 0.24486631f, -0.04337668f, 0.14428705f, 0.23428895f, 0.03129527f, 0.08385064f, 
    -0.17189331f, 0.22240812f, 0.28085142f, -0.00400216f, -0.23012292f, -0.55311394f, -0.06184940f, 0.16061701f, 
    0.20325826f, 0.06408902f, 0.05321288f, -0.04208647f, -0.07380193f, -0.35398823f, 0.16844410f, -0.07632067f, 
    0.13772529f, -0.36841831f, 0.45305642f, -0.08499945f, -0.38109159f, -0.13276055f, 0.12159378f, 0.34403464f, 
    0.10213996f, 0.26901454f, 0.11645672f, 0.04859863f, -0.19615254f, -0.22322634f, 0.17900307f, 0.00288456f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.18356325f, 0.03223984f, -0.15036820f, -0.04556836f, -0.07785691f, -0.04179188f, -0.05365381f, -0.31632224f, 
    0.03051497f, -0.16050047f, -0.01458941f, 0.10623566f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
