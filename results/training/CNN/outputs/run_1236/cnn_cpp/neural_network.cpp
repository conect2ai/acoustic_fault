#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.54764783f, -0.59022403f, 0.64781791f, -0.06929444f, -0.17966342f, 0.36651826f, -0.46163556f, 0.68517107f, 
    -0.59493792f, -0.55516130f, 1.29950500f, -0.98104203f, 0.30162376f, -0.07203884f, 0.11011723f, -0.24026875f, 
    0.34130433f, -0.09990683f, 0.12089716f, -0.35586959f, -0.65489215f, 0.54098642f, 0.69129676f, 0.48336685f, 
    -0.54035729f, 0.06815207f, -0.29262683f, 0.65480208f, -0.04698195f, 0.22708791f, -0.00962619f, 0.47200030f, 
    0.24711533f, 0.28011131f, 0.25059706f, 0.30778584f, 0.53233337f, -0.18358722f, 0.70377833f, -0.60087389f, 
    -0.44727913f, 0.10041831f, 0.15380229f, -0.16272224f, 0.33581290f, -0.13184375f, 0.51882380f, 0.61425418f, 
    0.13779622f, 0.42370886f, 0.60321367f, 0.23384126f, -0.01530408f, 0.28215408f, -0.65437686f, -0.32314315f, 
    -0.68982935f, 0.34330392f, 0.66532254f, 0.39080995f, -0.04792411f, 0.75951159f, -0.27053878f, 0.40318596f, 
    0.23328730f, -0.26985908f, 0.18049748f, 0.70676684f, -0.76357538f, 0.04221871f, 0.09268598f, 0.10869359f, 
    -0.34123129f, 0.40362599f, -0.20531794f, -0.26635149f, 0.02113691f, 0.53602183f, 0.56185222f, 0.39325801f, 
    0.71239614f, 0.02264808f, -0.22407110f, -0.77617848f, -0.47408959f, 0.01989042f, -0.48710367f, 0.07377630f, 
    0.30253375f, 0.37807664f, -0.26655871f, 0.56435645f, -0.35847202f, -0.58081478f, -0.54441535f, -0.32618997f, 
    0.38248396f, -0.62403852f, 0.61961639f, -0.01311995f, 0.29453725f, -0.07935135f, 0.72466040f, -0.72549868f, 
    -0.26704365f, -0.01951472f, -0.32905337f, 0.46531332f, 0.06607681f, -0.36691445f, 0.12821637f, 0.12868510f, 
    -0.15286243f, -0.04855649f, 0.28291175f, 0.01270610f, 0.81490403f, -0.12748890f, 0.47940359f, -0.04053423f, 
    -0.04515572f, -0.46962714f, -0.55517262f, -0.34692410f, -0.54687971f, -0.62818885f, -0.54212230f, 0.40366799f, 
    -0.61231506f, 0.19526733f, -0.10463661f, -0.48740870f, 0.45098040f, 0.40968263f, -0.20923097f, -0.29527023f, 
    0.03674217f, 0.00389226f, -0.58159667f, -0.88310421f, -0.42370710f, 0.19703402f, 0.46375203f, 0.42657581f, 
    -0.04626532f, 0.22295503f, -0.47099367f, -0.27670252f, -0.50804788f, 0.29406968f, 0.22059326f, -0.22441587f, 
    -0.38522470f, 0.92073101f, 0.10374740f, 0.30947304f, 0.17568465f, 0.44841295f, -0.38281530f, 0.26509699f, 
    0.38328058f, 0.24350847f, -0.54604161f, -0.48867539f, -0.46368885f, 0.57634282f, 0.06141582f, 0.26321942f, 
    -0.37122503f, -0.41933453f, -0.31008366f, -0.12078307f, 0.00059780f, 0.38795090f, 0.40979472f, 0.24234606f, 
    0.61622846f, 0.39988905f, -0.20827347f, -0.30526426f, -0.89331555f, 0.73037332f, -0.72501624f, -0.49873257f, 
    -0.19316620f, 0.56071007f, -0.55486411f, -0.15497705f, 0.08825023f, -0.40187728f, -0.28106993f, -0.00949701f, 
    -0.60808474f, -0.20949005f, -0.49726442f, 0.26691824f, -0.47046626f, -0.02144510f, 0.39613453f, 0.55927783f, 
    0.06328773f, -0.26274776f, -0.27331319f, -0.23338471f, 0.88257045f, -0.02816505f, -0.57644850f, 0.32698825f, 
    -0.16548884f, -0.10004898f, 0.30470881f, -0.26106751f, 0.23028003f, 0.58498836f, -0.40509042f, -0.18300544f, 
    0.21238986f, 0.23362277f, 0.50240022f, -0.23445815f, 0.51829457f, -0.49981704f, -0.03685450f, -0.59169531f, 
    -0.45515031f, -0.04931425f, 0.90730959f, 0.38115197f, 0.23250583f, -0.44166952f, -0.36363548f, -0.09125227f, 
    0.09927396f, 0.29759765f, 0.38470405f, 0.81269366f, -0.80431283f, -0.27297223f, -0.01851653f, -0.30635127f, 
    -0.25402614f, 0.42554411f, 0.00285929f, -0.67086869f, -0.82433593f, -0.10194217f, 0.31280735f, -0.27276191f, 
    -0.07537469f, 0.21328208f, -0.34114152f, -0.37853923f, -0.55441743f, -0.49145371f, -0.10384919f, 0.41708550f, 
    -0.03173653f, 0.42310143f, -0.45889863f, -0.40751404f, -0.46035138f, -0.61052138f, -0.45578769f, -0.11817779f, 
    0.08043649f, 1.00388837f, -1.19175243f, -0.22642587f, 0.04746144f, -0.01374536f, -0.65865546f, -0.00715286f, 
    0.84653938f, -0.10094067f, -0.80992395f, 0.79880148f, 0.33805558f, -0.10386817f, -0.39922667f, -0.56863344f, 
    0.49813870f, 0.49128503f, -0.46277976f, 0.02075364f, 0.09158029f, -0.07491338f, 0.55427951f, -0.27796772f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.08342957f, -0.01841497f, 0.13767225f, 0.12444878f, 0.17881007f, 0.23836243f, 0.36511633f, 0.09135035f, 
    0.17962782f, 0.17977639f, -0.03568071f, -0.09532788f, 0.07578606f, 0.20363860f, -0.20445995f, 0.00473602f, 
    0.60844851f, 0.17564149f, 0.06812382f, 0.22802427f, -0.05361218f, -0.04533763f, -0.06159615f, 0.39744246f, 
    0.04912454f, 0.33939061f, 0.05239844f, -0.00308723f, -0.12860447f, 0.31278789f, -0.09270730f, 0.15645310f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.64100665f, 0.13358438f, 0.07610017f, -0.14256048f, 0.17255177f, 0.02456055f, 0.11083722f, 0.29064506f, 
    -0.02073381f, -0.17093079f, -0.02888539f, -0.60176575f, -0.24408484f, 0.11001581f, 0.27072185f, -0.20597303f, 
    0.12776001f, -0.20514211f, -0.10641591f, 0.09227818f, -0.10842617f, 0.03623427f, -0.12339425f, -0.08122180f, 
    0.12419584f, 0.04876256f, 0.07175437f, -0.00531066f, -0.21609423f, 0.04523695f, 0.04340935f, -0.01034592f, 
    0.04713660f, 0.10356768f, -0.09576896f, 0.19809666f, -0.31676692f, 0.08329041f, 0.11104066f, -0.12433550f, 
    0.05219203f, 0.01989676f, -0.29998416f, 0.00823104f, -0.10976964f, 0.21814094f, -0.17542407f, 0.01750326f, 
    0.14605255f, -0.06586058f, 0.08202462f, 0.06017275f, 0.07135940f, 0.14397644f, -0.01506801f, 0.05395716f, 
    0.10089998f, 0.04588728f, -0.17133713f, 0.05075486f, -0.01460706f, 0.10048477f, 0.14476399f, -0.08047847f, 
    -0.10065073f, 0.14470543f, 0.04630986f, 0.00883441f, -0.11359359f, -0.14050812f, -0.00207306f, 0.04240110f, 
    -0.08999126f, -0.09883426f, -0.13248642f, 0.08597606f, 0.02805138f, 0.21197808f, 0.10777126f, -0.07680497f, 
    -0.37159216f, 0.17387609f, 0.25462645f, 0.10632472f, 0.09409762f, -0.04801999f, -0.09903048f, 0.10661175f, 
    0.01876855f, -0.19381033f, 0.10393815f, 0.31711179f, 0.24450071f, 0.01262186f, -0.00038875f, -0.03617275f, 
    -0.01375449f, -0.10544243f, -0.08365225f, -0.20226745f, 0.01584223f, 0.03792862f, -0.07228056f, 0.12689283f, 
    -0.10531042f, -0.03434506f, -0.04199162f, 0.01089641f, -0.02829708f, 0.09518331f, 0.12749544f, 0.15094070f, 
    0.14313845f, -0.07951561f, -0.19095035f, -0.25985786f, -0.10963348f, 0.10732820f, 0.07948596f, 0.09400258f, 
    0.01890341f, -0.16174355f, 0.06227334f, 0.03044108f, -0.08242478f, -0.02490455f, 0.26940867f, 0.10349268f, 
    0.12749490f, -0.07582562f, 0.00056703f, -0.04979740f, 0.20159797f, 0.20577185f, -0.00678537f, 0.24444209f, 
    0.26457539f, 0.09672730f, -0.02588962f, -0.09576712f, -0.19049872f, -0.04319142f, 0.00189315f, -0.16100955f, 
    0.07788872f, 0.13835204f, -0.02917334f, 0.12841751f, 0.00990679f, -0.00679246f, 0.10291439f, 0.11257218f, 
    0.07521458f, -0.06124794f, -0.28207272f, 0.04025294f, 0.10517997f, 0.10899317f, 0.05077478f, 0.04359209f, 
    -0.17840992f, 0.16067255f, 0.04084701f, 0.05179035f, 0.24978168f, 0.03726774f, 0.12666231f, -0.08093518f, 
    0.02077612f, -0.04728461f, 0.05649154f, 0.27584589f, -0.16287445f, 0.14230116f, 0.03764283f, 0.01441121f, 
    -0.05214033f, 0.12489917f, -0.04437571f, 0.06279135f, -0.30258426f, 0.17104869f, -0.19877388f, 0.04501209f, 
    0.11000036f, 0.11699668f, -0.00157530f, 0.05377700f, 0.00195757f, 0.16933545f, 0.09172909f, 0.19936541f, 
    -0.01120985f, -0.08369315f, -0.07847267f, 0.12290238f, -0.02046232f, 0.05490346f, -0.03912922f, -0.21349071f, 
    0.30750075f, 0.15731248f, 0.00374672f, 0.09546699f, 0.12972580f, -0.14824787f, -0.00713372f, -0.04304082f, 
    -0.09207600f, -0.03391039f, 0.18778227f, 0.06770781f, 0.06058823f, 0.06995794f, -0.10317735f, 0.02448247f, 
    0.24454337f, -0.05671556f, 0.05095743f, -0.09901698f, -0.10188717f, -0.04339728f, 0.19640753f, -0.16728669f, 
    -0.14604004f, -0.09654351f, -0.35448155f, -0.06793207f, 0.12557368f, 0.03312272f, 0.15058264f, -0.00963065f, 
    0.09646865f, -0.15017731f, -0.30668604f, -0.09295689f, -0.44186306f, 0.13087910f, 0.11544546f, 0.11099638f, 
    0.14406776f, 0.01951958f, -0.11438989f, 0.07007422f, 0.01618057f, 0.12934832f, 0.07913910f, 0.14806615f, 
    -0.13070603f, -0.01159060f, -0.11142323f, -0.01334397f, -0.02521942f, -0.02554096f, 0.17621537f, -0.11779004f, 
    0.14887661f, -0.00689857f, -0.01871283f, -0.06071330f, 0.06438617f, 0.15468164f, 0.17740612f, 0.45584366f, 
    -0.08886845f, -0.07149347f, -0.22474527f, 0.06869522f, 0.04797257f, 0.01687221f, -0.39412740f, 0.07097600f, 
    0.35313058f, 0.01948581f, -0.04375810f, -0.11511176f, 0.02329174f, -0.03845538f, 0.02888595f, -0.06141712f, 
    -0.15413484f, -0.00860211f, -0.12576798f, 0.22777733f, 0.10944113f, 0.09492749f, 0.14236765f, -0.02841906f, 
    0.00340483f, 0.04304334f, 0.00221956f, 0.03447620f, 0.04065984f, 0.04492468f, -0.03465839f, 0.01180059f, 
    0.01687442f, -0.01356734f, -0.05420704f, -0.01059915f, -0.05826059f, -0.02004586f, 0.01455994f, -0.01719444f, 
    0.02356533f, -0.02738287f, -0.00792491f, -0.03161427f, 0.01626734f, 0.00498634f, 0.03670705f, -0.05405559f, 
    -0.02795045f, -0.03551794f, -0.03610486f, -0.01760223f, 0.00389868f, 0.01777090f, -0.04285373f, -0.01575386f, 
    -0.01180320f, -0.02889574f, -0.00782654f, 0.05213400f, -0.00149378f, 0.02748008f, -0.03366074f, 0.04814705f, 
    -0.00809636f, -0.05896310f, -0.06125242f, 0.03568034f, -0.06263781f, 0.02321640f, -0.04962519f, -0.03812198f, 
    0.02935934f, -0.04614326f, 0.04446936f, -0.00176453f, 0.00530202f, -0.03500667f, -0.00498581f, -0.01750535f, 
    -0.04171558f, -0.00473213f, -0.05824321f, -0.05638823f, -0.05518713f, -0.06343154f, -0.02220161f, -0.06080072f, 
    -0.04065755f, -0.00970544f, -0.04159682f, 0.03482719f, -0.01396852f, 0.04417893f, -0.00387318f, -0.01779562f, 
    0.03533087f, 0.03765858f, -0.02189776f, 0.02800762f, 0.02729273f, -0.04393534f, -0.02371309f, 0.02043966f, 
    -0.06325758f, 0.01032446f, -0.03678584f, 0.02684247f, 0.03875896f, -0.02857588f, 0.00598948f, -0.00507557f, 
    -0.04123472f, 0.04243407f, -0.04469683f, -0.05780503f, 0.04084569f, -0.05291153f, 0.05847069f, 0.05005854f, 
    0.04348144f, -0.03892441f, -0.03469333f, 0.05042375f, 0.03307831f, 0.04826992f, 0.03488462f, -0.05268146f, 
    -0.03222116f, 0.05295898f, -0.02761694f, -0.04144572f, -0.00300569f, -0.02410937f, 0.00803092f, 0.03751640f, 
    -0.05921778f, 0.02565549f, -0.04572054f, -0.01891132f, -0.01751098f, 0.00133253f, -0.02017839f, 0.01929987f, 
    0.00528455f, -0.06244476f, -0.03220408f, -0.06292035f, 0.04556763f, -0.03535474f, -0.02035904f, -0.03429496f, 
    -0.02209939f, 0.01194317f, 0.00786922f, 0.00683568f, -0.01943647f, 0.00168648f, 0.01983755f, 0.01042091f, 
    0.00840976f, 0.00056938f, 0.01336079f, 0.05276104f, -0.03427588f, 0.02350006f, 0.04792929f, -0.06141211f, 
    -0.00192622f, -0.03774491f, -0.05843046f, 0.05206523f, 0.03621190f, -0.03141846f, -0.00988157f, 0.01099459f, 
    -0.00486507f, 0.01391634f, -0.05858213f, -0.05812996f, 0.02563584f, 0.05191793f, 0.02581357f, 0.00491852f, 
    -0.03808839f, -0.00560535f, -0.05760070f, -0.03384992f, -0.01637816f, -0.04935273f, 0.04474403f, 0.03040203f, 
    -0.00018789f, -0.04324897f, -0.04145713f, -0.06042394f, 0.04602847f, -0.06039008f, -0.05086045f, -0.01770888f, 
    0.04118510f, -0.05490202f, 0.04709467f, 0.01962484f, 0.00122349f, -0.03495673f, 0.01634869f, 0.00381744f, 
    0.01672688f, -0.03963576f, -0.00919287f, 0.02976273f, -0.02015266f, -0.01761045f, 0.00274357f, 0.03139737f, 
    -0.06013918f, -0.02544528f, -0.05859978f, -0.05564898f, -0.04183610f, 0.02169231f, -0.03621764f, -0.01680076f, 
    0.04601733f, 0.03656485f, -0.01219598f, 0.01054730f, 0.03439402f, -0.01254738f, 0.00733387f, -0.00550254f, 
    -0.01122418f, 0.03952562f, -0.01457937f, -0.01461408f, 0.04905492f, -0.03498357f, 0.01059543f, 0.05342076f, 
    -0.02612076f, 0.03213684f, 0.01094123f, 0.04865817f, -0.01043923f, -0.01777675f, 0.04258026f, -0.03661647f, 
    -0.00549240f, -0.01657820f, -0.06298418f, -0.04376490f, 0.03766590f, 0.01554932f, 0.03163620f, 0.01849366f, 
    -0.04046929f, 0.02799410f, -0.03511958f, 0.04181837f, -0.03969888f, -0.05208259f, 0.05293398f, -0.04980721f, 
    -0.06359667f, 0.00809964f, -0.05561978f, 0.04317500f, -0.03363092f, 0.04708129f, 0.03205105f, -0.01514853f, 
    0.00012240f, -0.03319671f, 0.01361039f, -0.05082927f, 0.00683132f, -0.01031294f, 0.00195277f, 0.00272331f, 
    -0.05997262f, 0.04932769f, -0.04326877f, -0.05540263f, 0.00877817f, -0.03996286f, -0.00176216f, -0.01350807f, 
    -0.02179142f, 0.02490168f, -0.04253962f, -0.00236190f, -0.03096009f, -0.04817803f, -0.03306074f, 0.04478380f, 
    0.01119654f, -0.01320719f, -0.00053595f, -0.04674616f, 0.01596819f, -0.02909299f, 0.00587496f, 0.00251742f, 
    0.02919562f, -0.04141207f, -0.01496618f, -0.04581812f, 0.04146050f, 0.00939705f, 0.01767999f, 0.04735680f, 
    0.04617215f, -0.27276754f, -0.63656157f, -0.05489170f, -0.02426835f, 0.19532835f, -0.18178402f, -0.10743846f, 
    0.07750238f, 0.12929055f, -0.38410449f, -0.42593706f, 0.23495097f, -0.05075145f, -0.00919266f, 0.24104647f, 
    -0.15030798f, -0.18538772f, -0.11535596f, 0.12856676f, 0.32327771f, -0.26881200f, -0.09068055f, -0.02805224f, 
    0.07242948f, -0.06719268f, 0.15832132f, 0.09217446f, 0.03061780f, -0.18627916f, -0.02998042f, -0.01426998f, 
    0.11594368f, -0.02361524f, 0.09884918f, -0.09376170f, 0.38602948f, -0.30270970f, -0.33361211f, -0.00830842f, 
    -0.02227501f, 0.09497275f, 0.15878880f, 0.08034784f, 0.18577552f, 0.04632496f, 0.05664421f, 0.02967338f, 
    -0.02853656f, 0.06789757f, 0.09437080f, 0.15554774f, 0.06866530f, -0.00220634f, -0.25684926f, 0.20623295f, 
    0.62628031f, 0.12457112f, 0.00110956f, -0.02397596f, -0.03822160f, 0.09107769f, 0.24655852f, 0.01254939f, 
    -0.17229974f, 0.10271224f, -0.18495859f, 0.14661509f, 0.08815407f, -0.00474259f, 0.16367681f, -0.02267295f, 
    -0.03426633f, 0.02857317f, -0.04847442f, -0.04286715f, -0.06686968f, 0.18410617f, 0.04914469f, 0.01864982f, 
    0.08681235f, -0.21126558f, 0.23544535f, -0.24802372f, 0.20399292f, -0.05150441f, -0.21749666f, -0.04619404f, 
    0.04885592f, -0.02803456f, -0.31713536f, -0.50818300f, -0.55392814f, 0.11079448f, -0.13246781f, -0.12099848f, 
    0.05391467f, -0.06698474f, -0.13962162f, -0.06068705f, -0.20925087f, 0.17158277f, -0.04115483f, 0.01840683f, 
    -0.07917032f, 0.08446570f, -0.08153939f, 0.00033553f, 0.20211476f, 0.04847120f, 0.00164495f, -0.10604526f, 
    -0.04981400f, 0.04438251f, 0.00215351f, -0.07640893f, 0.25908363f, -0.02230683f, -0.04154195f, -0.02945928f, 
    0.18430802f, 0.08546886f, -0.02046138f, -0.01392204f, -0.02745008f, 0.02429854f, -0.56368721f, -0.03300774f, 
    -0.09152748f, -0.09409067f, 0.03892374f, -0.17767900f, -0.00975581f, -0.06345097f, -0.03631774f, -0.12580973f, 
    -0.18777061f, -0.32712978f, -0.24750216f, -0.06027016f, -0.17794847f, -0.06345018f, -0.02730085f, -0.08432137f, 
    0.09737171f, -0.01179652f, -0.04702543f, -0.01171109f, 0.15649062f, 0.22486857f, 0.08161158f, 0.14471965f, 
    0.08469824f, 0.10209146f, -0.03194291f, -0.03271071f, -0.05810077f, 0.20873864f, 0.09682601f, 0.05204741f, 
    0.11736163f, 0.01342791f, 0.07538702f, 0.13941310f, 0.34158123f, -0.10574945f, -0.15440233f, -0.04853160f, 
    -0.00061667f, 0.01142752f, -0.04161695f, -0.03267039f, 0.12785099f, 0.02824467f, -0.01286948f, 0.04771810f, 
    0.07897440f, 0.13434049f, -0.09075556f, 0.17083485f, -0.37748820f, -0.09768295f, -0.02983627f, -0.12200505f, 
    -0.15206625f, -0.30862150f, 0.01324920f, 0.02554387f, -0.06276786f, -0.17659873f, -0.07985817f, -0.18390656f, 
    -0.02018218f, -0.01325933f, -0.11640359f, 0.14081872f, -0.02702690f, -0.14725697f, -0.08028524f, -0.36525431f, 
    -0.39631766f, -0.31141779f, 0.02176019f, -0.02054424f, 0.10923533f, 0.10172191f, 0.10707623f, 0.12062216f, 
    0.18176018f, 0.15198271f, 0.20532347f, 0.14400262f, 0.18263620f, 0.18366075f, 0.20903581f, 0.14469486f, 
    -0.33783108f, -0.16528107f, -0.11041791f, 0.08176591f, 0.05834303f, -0.01681411f, -0.05422738f, -0.09464344f, 
    0.17744583f, 0.00269747f, -0.33964443f, 0.06571098f, 0.04487317f, 0.22409669f, 0.10421456f, 0.09117813f, 
    0.19137332f, 0.02622044f, 0.34294975f, -0.32655686f, -0.44737810f, 0.16530809f, 0.08399924f, -0.09176613f, 
    0.01564293f, -0.05997401f, 0.07674609f, 0.15945260f, 0.13901599f, 0.40814629f, -0.02111141f, 0.01632694f, 
    0.13463938f, 0.04901619f, 0.00307839f, -0.00470801f, 0.21470377f, 0.01761513f, 0.18088391f, -0.03694536f, 
    -0.20917924f, 0.04310176f, -0.01754211f, 0.03156816f, 0.02611128f, -0.32895643f, -0.20669456f, 0.11884829f, 
    0.18912175f, 0.06019155f, 0.09233793f, 0.09621258f, 0.07756824f, 0.04544597f, -0.10442895f, -0.25956127f, 
    -0.11254387f, 0.08353299f, 0.01782249f, 0.15486987f, -0.06612802f, 0.09774641f, 0.09313512f, -0.12346520f, 
    -0.26114187f, -0.14348577f, -0.13281950f, 0.05717969f, 0.01342713f, 0.02408833f, 0.05642624f, 0.04886123f, 
    -0.01624475f, -0.05628333f, -0.06795556f, -0.02444338f, 0.04124334f, -0.06683908f, -0.05482114f, -0.03360192f, 
    0.03268965f, -0.03873445f, -0.04703184f, 0.04843481f, -0.03300050f, -0.01767095f, -0.06451033f, 0.04612393f, 
    0.00189393f, -0.03630137f, -0.01240952f, 0.02218850f, -0.03472043f, 0.02637358f, -0.06496307f, -0.03645896f, 
    0.00519207f, -0.03986282f, -0.00291816f, 0.01592436f, -0.00421348f, 0.00733066f, -0.00170678f, -0.05279789f, 
    0.05148503f, -0.02936593f, -0.03530960f, -0.00410693f, -0.05495039f, 0.02069520f, 0.01414734f, 0.02859853f, 
    -0.03294199f, 0.00418019f, -0.01671232f, -0.01445639f, -0.06928922f, 0.02704329f, -0.01028005f, -0.02870137f, 
    0.01909547f, -0.03623705f, 0.00013386f, 0.03042907f, -0.02556211f, 0.01987580f, -0.00640949f, -0.03373362f, 
    -0.06704339f, 0.04388238f, -0.05819715f, -0.02234543f, -0.06965479f, -0.01413053f, -0.05521519f, -0.04111747f, 
    0.04174630f, 0.02416945f, -0.05368067f, 0.00941857f, -0.01230065f, 0.00648237f, -0.06267683f, -0.02408904f, 
    0.02679485f, -0.05088708f, 0.01802238f, 0.00288077f, -0.06565932f, 0.03313268f, 0.01320466f, -0.02284970f, 
    -0.00773785f, -0.02395428f, -0.01144650f, -0.00902376f, -0.01062109f, 0.01789798f, 0.01260758f, -0.00215887f, 
    0.02528003f, 0.01071213f, 0.00573454f, 0.04803769f, -0.06360888f, -0.06429870f, 0.01836210f, 0.01449216f, 
    0.00398601f, -0.01919083f, -0.03977259f, 0.01367408f, 0.02382375f, -0.05536494f, -0.07119562f, 0.00552597f, 
    -0.02194960f, -0.03880155f, 0.02336064f, -0.03102189f, -0.03603591f, -0.05871617f, 0.00759053f, -0.00745340f, 
    -0.03445617f, -0.05334834f, 0.00233287f, 0.01332955f, 0.00737759f, 0.02699625f, -0.03074876f, 0.01335341f, 
    0.01303911f, 0.00012931f, 0.03401785f, -0.02398555f, -0.00791251f, -0.01102378f, 0.03581515f, 0.03667892f, 
    -0.03112468f, -0.05561288f, 0.03539785f, 0.02986170f, 0.01216150f, 0.00123030f, -0.03684157f, 0.04293650f, 
    0.03241105f, -0.04909906f, -0.00083801f, -0.07930119f, -0.03795795f, -0.00789188f, -0.02158804f, -0.04718676f, 
    -0.02479289f, 0.00194671f, 0.02812426f, -0.00501873f, 0.01490391f, 0.03188273f, -0.03613144f, 0.00604320f, 
    0.02563908f, -0.05741256f, -0.05934745f, -0.02381592f, 0.01784237f, 0.04450290f, 0.01638139f, -0.02898839f, 
    -0.03955941f, 0.04364768f, -0.00217420f, 0.00518707f, -0.00226697f, -0.04988411f, -0.01323636f, -0.07337596f, 
    -0.01719744f, 0.02970099f, -0.05828327f, -0.00258953f, 0.04253896f, -0.02542106f, -0.01063109f, 0.02426139f, 
    0.01916334f, -0.00258317f, -0.03458258f, -0.02810335f, 0.04107212f, -0.04755323f, 0.00998503f, -0.01948851f, 
    0.03457942f, -0.05651584f, -0.01158521f, 0.02510097f, -0.03313038f, -0.02549180f, -0.05581214f, 0.02311737f, 
    -0.01793302f, -0.05350683f, -0.04406818f, 0.02120717f, -0.03555630f, -0.04715388f, -0.00835334f, -0.05649785f, 
    0.00724318f, 0.01898300f, 0.01227584f, -0.01476678f, 0.03444609f, 0.01932029f, -0.05399607f, -0.06156965f, 
    -0.03187318f, 0.02692967f, 0.01949179f, 0.02665270f, -0.06207084f, -0.02521802f, -0.00653982f, -0.00863294f, 
    -0.01713201f, -0.02865172f, -0.01125272f, 0.04162373f, 0.03055358f, 0.03059780f, -0.03896281f, -0.02922099f, 
    -0.03062647f, 0.01644180f, -0.01504263f, 0.01049583f, -0.02463133f, -0.04707047f, 0.04278180f, -0.03364971f, 
    0.01032156f, -0.02713143f, 0.01455994f, 0.02470525f, -0.01607818f, -0.01085790f, 0.01753717f, 0.01714360f, 
    -0.01816035f, -0.04654278f, 0.00526799f, 0.05431736f, 0.02637340f, 0.01759234f, -0.05158282f, 0.03860910f, 
    -0.06870776f, -0.01487744f, 0.04246281f, 0.00054005f, -0.00449976f, -0.00720095f, -0.01939273f, -0.03957092f, 
    -0.03377863f, -0.07106819f, 0.03906984f, -0.01686113f, -0.06009977f, -0.02142053f, -0.06744912f, -0.06329691f, 
    0.04107504f, 0.02483722f, 0.04642820f, 0.01254485f, -0.01939803f, -0.03875237f, 0.01649372f, -0.06027209f, 
    -0.02329865f, 0.03205814f, -0.07899361f, -0.05964574f, 0.00958000f, -0.04394161f, -0.00023028f, 0.03315009f, 
    0.00751130f, -0.02920708f, -0.03778610f, -0.06028803f, 0.02911080f, -0.08857541f, -0.02626429f, -0.06817887f, 
    -0.00493713f, -0.05520555f, -0.02839593f, 0.02397189f, -0.00179527f, 0.02518130f, 0.02969650f, 0.03277461f, 
    0.02640643f, 0.00081608f, -0.05806702f, 0.04376820f, -0.00695570f, 0.02008417f, -0.01181825f, 0.00233730f, 
    0.01427650f, 0.04260785f, -0.04589836f, 0.00673190f, -0.04506149f, -0.03264966f, 0.05364877f, -0.03050573f, 
    -0.02854915f, 0.00412648f, -0.04680883f, 0.03214838f, -0.01275097f, 0.00234329f, -0.03489624f, -0.04344732f, 
    -0.05889040f, 0.05203656f, -0.02937037f, 0.03186194f, -0.06149429f, -0.00521081f, -0.01772043f, -0.01078377f, 
    0.04065709f, 0.01805241f, 0.00537790f, -0.01796407f, 0.05375629f, -0.01882810f, -0.05547175f, -0.00428715f, 
    0.02405746f, -0.01991178f, -0.02705695f, -0.04147834f, -0.02922877f, -0.04259196f, -0.00301837f, -0.04890640f, 
    -0.01267310f, 0.01748806f, 0.05331605f, -0.04633310f, -0.00734800f, -0.02621804f, -0.04374935f, -0.03676355f, 
    -0.04705036f, 0.01258463f, -0.04070575f, -0.04695771f, 0.00475058f, -0.01118970f, 0.01539121f, -0.03551900f, 
    0.02851111f, -0.02902415f, 0.01610160f, 0.03353881f, 0.04539236f, -0.04244580f, 0.01611400f, -0.00266140f, 
    0.01836538f, -0.04596738f, 0.00664231f, 0.02845971f, -0.01227046f, 0.01185333f, -0.00754030f, -0.02512566f, 
    -0.06210850f, -0.05384995f, 0.04791975f, -0.00537008f, -0.03425214f, 0.00173840f, 0.00302276f, 0.03743394f, 
    -0.00625103f, 0.03999029f, -0.04263560f, 0.04036129f, 0.05509761f, 0.01317252f, 0.03009857f, -0.05728048f, 
    0.02428891f, -0.03277472f, 0.02707083f, 0.02855531f, 0.02141541f, 0.01812104f, -0.03150840f, -0.03571345f, 
    -0.02927104f, -0.01442078f, 0.03199160f, -0.04514154f, -0.02435458f, -0.06208041f, -0.01088454f, 0.02690438f, 
    -0.00220266f, -0.03717582f, 0.05275594f, 0.03145907f, -0.03271524f, 0.02321589f, 0.05254197f, -0.01563996f, 
    -0.02594041f, -0.01072818f, 0.00247844f, -0.02787621f, -0.01036035f, 0.00358757f, 0.01974945f, 0.02813743f, 
    -0.05067205f, -0.02657991f, -0.05992525f, -0.02284541f, -0.00599808f, -0.05093952f, 0.00166636f, 0.00711068f, 
    -0.03111138f, -0.01324455f, 0.00355350f, 0.00955678f, 0.03340328f, 0.03298961f, 0.03867820f, -0.03341591f, 
    -0.02523859f, -0.00398282f, -0.06054848f, -0.01135229f, -0.05660494f, 0.01875217f, -0.01800326f, -0.06134688f, 
    0.02363697f, -0.05947793f, 0.05308949f, -0.01010220f, 0.03711805f, 0.05115583f, -0.04662491f, -0.05003062f, 
    -0.04714733f, 0.01716521f, -0.03610236f, 0.02372599f, -0.01004373f, -0.05653274f, 0.04945017f, -0.02506237f, 
    0.05251625f, -0.00008833f, -0.02882344f, 0.00462127f, -0.00362489f, -0.04317098f, 0.04957023f, -0.02129398f, 
    0.02320679f, 0.01809802f, -0.02037105f, 0.01552734f, -0.02941150f, 0.02295168f, -0.02003623f, 0.04120489f, 
    -0.01980520f, 0.02926404f, -0.02501787f, -0.05072723f, 0.01032107f, -0.02332812f, -0.05632588f, -0.05628688f, 
    0.02778748f, -0.02460842f, 0.01132313f, -0.04908247f, -0.00880573f, -0.01468269f, 0.00132927f, -0.06060572f, 
    -0.04679673f, 0.03792942f, -0.04592862f, 0.02083216f, 0.05274024f, 0.03267909f, 0.02297339f, 0.01936325f, 
    0.01156109f, -0.00965112f, -0.04676126f, 0.02184846f, -0.04658165f, -0.03352609f, -0.05910190f, 0.01396174f, 
    -0.06158948f, 0.02560914f, -0.03485413f, -0.03873309f, 0.02040674f, 0.04559291f, -0.00184366f, -0.03935402f, 
    -0.03677339f, -0.03106817f, -0.05089908f, 0.00261345f, 0.04034580f, -0.02957511f, -0.00760695f, -0.00914615f, 
    0.01483156f, -0.02755914f, -0.00936144f, 0.02937379f, -0.06365015f, -0.05423274f, -0.05285879f, -0.00225931f, 
    -0.04097698f, -0.00181960f, -0.02356826f, 0.01099545f, 0.04304637f, 0.00205558f, -0.00128718f, -0.00849637f, 
    -0.02220160f, -0.04707105f, -0.01180489f, 0.04628569f, -0.00766619f, -0.00124349f, -0.02040917f, -0.02405166f, 
    -0.03361431f, -0.01548499f, -0.04861192f, 0.00340667f, 0.01319954f, -0.04400221f, -0.00982134f, -0.03787232f, 
    -0.01983085f, -0.03578088f, 0.02505172f, 0.04177887f, -0.00597741f, 0.02295057f, -0.02467553f, 0.00304038f, 
    0.01038283f, -0.04955327f, -0.05210625f, -0.01848470f, 0.03292665f, 0.03139296f, 0.01057508f, 0.03155963f, 
    0.10689348f, 0.10253444f, 0.01372953f, -0.10371823f, 0.06860636f, 0.12658228f, 0.03093587f, 0.29859063f, 
    -0.01168445f, 0.28251842f, 0.48137480f, -0.09624813f, -0.16915382f, -0.09326252f, 0.17811678f, 0.06792507f, 
    -0.15417765f, 0.02865719f, 0.15197474f, 0.00990632f, -0.07010507f, -0.01154514f, -0.17491159f, -0.15603632f, 
    0.00627669f, -0.00407642f, -0.04733294f, 0.09406912f, 0.07807463f, 0.04938215f, 0.02012598f, -0.15861714f, 
    0.00072897f, -0.05389025f, -0.05782817f, 0.02514688f, -0.02699913f, -0.29744434f, 0.03380479f, -0.06401714f, 
    0.13006061f, 0.10477777f, 0.12012258f, -0.04663571f, 0.03921655f, -0.00485254f, 0.20299830f, 0.03776725f, 
    -0.09854059f, -0.17133220f, -0.14248368f, -0.04454977f, -0.02863405f, -0.13900235f, 0.23654909f, -0.05282746f, 
    -0.24562228f, -0.05164884f, -0.08570534f, -0.01250646f, 0.18024403f, -0.04246868f, -0.08319976f, 0.18923660f, 
    0.22957689f, 0.17916690f, 0.00846011f, -0.06143848f, -0.04368236f, 0.10466356f, 0.03837418f, 0.16152503f, 
    0.22662450f, 0.18291351f, 0.09770425f, 0.15458941f, -0.03612065f, 0.06242795f, 0.09083229f, -0.03109246f, 
    -0.12747078f, 0.09699930f, 0.04177589f, -0.52958977f, -0.06779575f, 0.00067804f, 0.16015299f, 0.07831036f, 
    -0.11749742f, -0.20208338f, -0.44428328f, -0.24737132f, 0.02686713f, 0.12746985f, 0.18282361f, 0.00543262f, 
    -0.04970780f, -0.00670912f, -0.09719740f, -0.03802203f, 0.19195075f, 0.31005976f, -0.00492286f, 0.08995937f, 
    0.14213988f, 0.28614268f, 0.06828654f, -0.04620014f, 0.18630926f, 0.14502093f, 0.06407188f, -0.00956094f, 
    0.06024805f, 0.19929539f, -0.02675894f, 0.08897018f, -0.07861935f, -0.23832636f, -0.16785711f, -0.16740276f, 
    0.01226109f, 0.09352989f, 0.16725110f, 0.14971079f, -0.20368282f, -0.06146483f, 0.02235614f, 0.31957522f, 
    0.06841639f, -0.06321183f, 0.03553548f, 0.03074034f, 0.11045879f, -0.04468984f, 0.03190313f, -0.08823454f, 
    -0.31342345f, 0.05985736f, 0.05900675f, 0.10258545f, 0.06057476f, 0.14665850f, -0.07516402f, 0.31804633f, 
    -0.20425105f, -0.12591198f, -0.22724029f, 0.00858288f, -0.13213882f, -0.08029005f, -0.18154114f, 0.16287076f, 
    -0.15164213f, 0.16607745f, 0.06345201f, 0.13513403f, 0.06959581f, 0.06530287f, -0.00793717f, -0.00289555f, 
    0.02253069f, 0.14640743f, 0.14487018f, -0.08791839f, -0.34254298f, 0.09270835f, -0.04586514f, -0.26650053f, 
    -0.00439068f, 0.00751235f, -0.07445101f, 0.25017092f, 0.20427021f, 0.07542554f, -0.31521338f, -0.26380405f, 
    -0.22382605f, 0.10365232f, -0.00558163f, -0.04691210f, 0.23597932f, 0.04361024f, -0.38576972f, 0.00878112f, 
    0.04565632f, 0.07390796f, 0.12616880f, -0.01431290f, -0.18059053f, -0.32719535f, -0.16269852f, -0.23912726f, 
    0.00189786f, 0.08753548f, -0.05911850f, 0.00452727f, -0.03027551f, 0.00228076f, 0.15233876f, -0.29475546f, 
    -0.04695566f, 0.11264367f, 0.03474354f, 0.04369767f, -0.07119677f, 0.06784290f, 0.01334699f, 0.13917550f, 
    0.06087736f, 0.12453867f, -0.02583168f, -0.03986179f, -0.15068653f, -0.05757492f, -0.03660746f, -0.03195272f, 
    0.16389936f, 0.12226154f, 0.03245071f, 0.09645231f, 0.14954655f, -0.00489390f, 0.20227228f, -0.08583514f, 
    0.18421540f, -0.32480657f, -0.12476114f, -0.04247268f, -0.02805918f, 0.05350667f, 0.07781136f, 0.05998706f, 
    0.06034619f, 0.30671903f, 0.12162738f, 0.07486244f, 0.18554357f, 0.03433249f, -0.11139189f, 0.20516586f, 
    0.10779136f, -0.02400383f, 0.12819077f, 0.04120761f, -0.26189768f, -0.30747607f, -0.07132488f, -0.08853120f, 
    -0.10670826f, 0.10065607f, -0.09120949f, -0.08295112f, 0.01892776f, -0.03724717f, -0.12197708f, 0.00677905f, 
    0.00068397f, -0.15236020f, -0.02309947f, 0.09542304f, 0.14205907f, 0.10895641f, -0.00475563f, -0.14024602f, 
    0.01171573f, 0.01946969f, -0.02006253f, 0.14954154f, -0.06998304f, -0.23063950f, -0.01234514f, 0.02077257f, 
    0.37675506f, -0.15020859f, -0.04070936f, 0.06609166f, 0.04662476f, 0.16658133f, -0.14947759f, -0.06101207f, 
    -0.08477508f, 0.31878915f, 0.03624814f, -0.09953341f, 0.08434138f, -0.06158897f, 0.09588879f, -0.14418133f, 
    -0.07180387f, 0.13777886f, 0.01002557f, -0.09133881f, -0.14827918f, 0.26584852f, 0.03842932f, 0.04999820f, 
    0.10934319f, 0.06244931f, -0.01236676f, 0.14570366f, 0.29678774f, 0.10849196f, 0.17402817f, 0.04247612f, 
    0.05601822f, 0.35638994f, -0.15198857f, -0.15355581f, 0.22674204f, 0.08605254f, -0.03019686f, 0.11193877f, 
    0.04150186f, 0.15811931f, 0.10611375f, -0.06416623f, -0.01244290f, 0.08176193f, -0.01875027f, -0.05036492f, 
    0.07922756f, -0.09406742f, -0.01664642f, -0.16871935f, 0.11230931f, 0.22349207f, 0.02692994f, -0.05296236f, 
    0.07494093f, -0.05070005f, 0.01903412f, 0.03652271f, -0.13589615f, 0.04253412f, 0.01391841f, 0.06717825f, 
    0.09742990f, 0.14758871f, -0.04098566f, 0.09531058f, -0.00480863f, -0.13651367f, 0.19001693f, -0.03120205f, 
    0.23243070f, -0.08539382f, 0.14428313f, 0.02825888f, -0.00428537f, -0.18528073f, -0.00920003f, -0.01484494f, 
    0.10695671f, 0.07597639f, 0.00117161f, -0.08541290f, 0.21402724f, -0.10154118f, 0.16382967f, -0.04161065f, 
    -0.20026341f, -0.09849077f, 0.05548338f, 0.06394032f, 0.04841811f, -0.19228993f, -0.10786173f, -0.30241159f, 
    -0.28885874f, 0.02659356f, 0.04883365f, 0.03218286f, 0.12802151f, 0.09480166f, -0.19375534f, -0.03412839f, 
    -0.12646157f, -0.15357217f, -0.03291387f, 0.09679206f, 0.06631967f, 0.14914131f, 0.06848750f, -0.15126140f, 
    -0.22362286f, -0.28778821f, -0.04831036f, 0.15287264f, 0.05406457f, 0.21106644f, 0.14491706f, 0.15079737f, 
    0.31187862f, 0.02515360f, 0.02268163f, -0.06334053f, -0.15565921f, -0.04056062f, -0.05406978f, 0.07916473f, 
    -0.09005874f, -0.23404847f, -0.16518739f, -0.07187759f, -0.27017501f, 0.22919668f, 0.20718229f, 0.18663096f, 
    0.06405271f, 0.06933600f, 0.13273284f, 0.16330488f, 0.07932618f, 0.13750836f, 0.22766916f, -0.24459520f, 
    0.02621041f, 0.08118588f, -0.01903168f, -0.17848913f, 0.08931152f, 0.02196116f, 0.06236900f, -0.01471597f, 
    0.04449604f, -0.14705452f, 0.25272810f, -0.03311644f, -0.12075800f, -0.18499838f, -0.33659208f, -0.41340533f, 
    0.09640519f, 0.07611314f, 0.22022527f, -0.01873635f, 0.01398964f, 0.07575665f, 0.09900044f, 0.12851548f, 
    0.26337141f, 0.13822596f, 0.13433236f, 0.07514239f, 0.00849648f, -0.13184769f, 0.09424710f, -0.16825150f, 
    0.08239304f, -0.28625694f, 0.17060818f, -0.04084050f, -0.04686190f, -0.02149935f, -0.00138004f, 0.11653675f, 
    0.10397855f, 0.17080876f, 0.16378902f, -0.02686101f, -0.03315683f, 0.20138696f, 0.03757526f, 0.17731604f, 
    -0.01201225f, 0.16382533f, 0.08358441f, -0.23732358f, 0.17368507f, -0.09330815f, -0.02296189f, 0.12919435f, 
    0.21471982f, 0.08372401f, -0.00687664f, 0.05041594f, 0.39584392f, 0.32596871f, 0.12388627f, 0.02149029f, 
    0.14539415f, -0.02965975f, 0.08688200f, 0.00052514f, -0.06242448f, 0.03676755f, 0.09851062f, 0.43328959f, 
    0.01987041f, -0.14821072f, -0.03522232f, 0.16856246f, -0.06911585f, 0.05228653f, -0.24404031f, 0.13366100f, 
    0.00261496f, 0.22362086f, -0.01839210f, 0.07914041f, 0.14464715f, 0.03952504f, 0.26488769f, 0.02151443f, 
    0.02019950f, 0.12598601f, -0.00005600f, -0.04416879f, 0.20818786f, -0.04355109f, 0.23309457f, 0.11708418f, 
    0.00301146f, 0.25068215f, 0.16801767f, 0.11890595f, 0.03092514f, 0.02185304f, 0.09875783f, 0.06563523f, 
    -0.03844973f, -0.19254921f, 0.02330603f, 0.16148667f, 0.36519575f, 0.00890685f, 0.10906990f, 0.11013516f, 
    0.09688710f, 0.09310563f, 0.03732618f, 0.25893071f, 0.10117237f, 0.05008557f, -0.04661028f, -0.08420052f, 
    0.18008627f, 0.08876318f, 0.14831674f, 0.00484158f, 0.15783715f, -0.02748329f, 0.03236907f, -0.01564360f, 
    -0.06118657f, 0.10963555f, 0.03991381f, 0.25944707f, 0.26654074f, 0.14903338f, 0.11741763f, -0.08248243f, 
    -0.12256167f, -0.13006347f, 0.11492390f, 0.10763840f, 0.00359446f, 0.22202680f, 0.49082366f, 0.48423406f, 
    -0.04471098f, -0.20678790f, 0.07755879f, 0.25197008f, 0.32811242f, 0.20957382f, -0.09914504f, 0.20265058f, 
    0.29573309f, -0.23719145f, -0.11282751f, 0.08160131f, 0.01164824f, 0.22454669f, -0.18117192f, -0.08188409f, 
    -0.09321108f, -0.08261887f, -0.03103126f, 0.03176108f, 0.22341488f, 0.03418468f, -0.00451002f, -0.02006866f, 
    -0.03094668f, -0.05861348f, 0.23216905f, 0.49223113f, 0.04748384f, 0.00648770f, 0.18483283f, -0.04967368f, 
    0.01208294f, 0.14493681f, 0.01332777f, -0.02901262f, -0.06252020f, 0.14367540f, 0.12860496f, 0.01370954f, 
    -0.10508303f, -0.17706223f, -0.04743493f, -0.04962724f, -0.01366909f, -0.12363976f, 0.21381830f, -0.07721782f, 
    0.08811922f, 0.07379116f, 0.06940082f, 0.17773992f, -0.13245106f, -0.03870686f, -0.09850756f, 0.13105553f, 
    0.17839617f, 0.11666447f, 0.16446443f, 0.08444075f, 0.20874189f, -0.15307936f, -0.14653935f, -0.03228723f, 
    0.04422178f, 0.05991527f, 0.03581484f, 0.02359458f, -0.00751339f, 0.14063846f, 0.10715143f, 0.03720510f, 
    -0.08318970f, 0.26876909f, 0.04574879f, -0.03065812f, -0.07217275f, -0.09451471f, -0.06814291f, -0.06972551f, 
    0.02788283f, 0.01684223f, 0.33100542f, 0.12413302f, 0.08301255f, 0.12941737f, -0.03271442f, 0.24831843f, 
    0.01910524f, 0.15773390f, -0.05507070f, -0.02922848f, 0.04343247f, -0.01009720f, 0.10116178f, 0.22240591f, 
    0.15957913f, 0.14907938f, -0.07091735f, 0.12605518f, -0.22796939f, -0.05784432f, -0.04453299f, 0.16655752f, 
    0.06612788f, 0.05406153f, 0.07028708f, 0.01561486f, 0.09909050f, -0.08731817f, 0.09718627f, -0.05952704f, 
    0.04705487f, 0.14788607f, -0.04140928f, -0.10520243f, 0.02057593f, 0.04113367f, 0.23717964f, -0.01622275f, 
    -0.13347042f, 0.01677825f, 0.15109421f, 0.34979010f, 0.08459684f, 0.08775457f, 0.01255934f, 0.05845927f, 
    0.02333235f, -0.04239532f, 0.33593279f, 0.22700819f, 0.26817200f, -0.03500500f, -0.04154496f, -0.23593417f, 
    0.04140429f, 0.01151688f, -0.08725532f, -0.03863715f, -0.29629660f, -0.32639611f, 0.05833160f, 0.09002176f, 
    0.25070858f, -0.06707527f, -0.27754080f, 0.04179364f, 0.06843004f, -0.02282476f, 0.04128141f, -0.00937575f, 
    -0.15602207f, -0.08135469f, 0.04340971f, -0.05161176f, -0.01114768f, 0.19258595f, 0.09919541f, 0.05342524f, 
    0.13336635f, 0.02728142f, 0.09494369f, -0.03966473f, -0.00762763f, -0.07539478f, 0.08860806f, 0.01810259f, 
    0.03236949f, -0.15707737f, -0.10353412f, -0.08357231f, 0.19009966f, 0.12584683f, 0.09146418f, 0.08602796f, 
    0.09303515f, 0.24050859f, 0.06788478f, -0.08440851f, -0.11310820f, 0.03931102f, -0.06063285f, -0.08671857f, 
    -0.09056789f, -0.10833431f, -0.29413462f, -0.08569230f, 0.10160039f, 0.01664533f, 0.20493928f, 0.09619409f, 
    0.08181275f, -0.18404518f, 0.09275175f, 0.10109052f, 0.24674118f, 0.08272341f, 0.48168746f, -0.25708756f, 
    0.09705466f, 0.00322394f, -0.03100963f, -0.08897918f, 0.08464740f, 0.21095605f, -0.03992872f, 0.00237766f, 
    -0.06755359f, -0.11235818f, 0.07916313f, 0.07958653f, -0.00211137f, -0.21498655f, -0.07157340f, -0.12911017f, 
    -0.01164007f, 0.06986809f, 0.11023346f, 0.14924194f, 0.05006669f, 0.00870917f, 0.19431435f, 0.00999690f, 
    0.10132092f, 0.03875849f, 0.11022979f, -0.09310962f, 0.05822886f, -0.01149363f, 0.06792554f, -0.10360002f, 
    -0.11227800f, -0.15313765f, -0.02397104f, -0.02445575f, 0.03560122f, -0.00680673f, -0.13461731f, -0.06936433f, 
    -0.05513044f, -0.15252160f, -0.01547654f, 0.01361013f, 0.08769970f, 0.18573435f, 0.11601277f, 0.10321912f, 
    0.07627790f, 0.04710454f, -0.28956601f, 0.06648822f, -0.17337199f, 0.02845950f, 0.11797756f, 0.18695067f, 
    0.11664020f, 0.11991226f, 0.10426360f, 0.23464999f, -0.00795362f, -0.03492533f, 0.01558915f, -0.04892518f, 
    -0.05217616f, -0.09399030f, -0.10060889f, -0.26861042f, 0.05541854f, -0.11259416f, -0.10378154f, -0.00156530f, 
    -0.07346392f, 0.03233763f, -0.21810962f, -0.08235009f, -0.35456973f, 0.31833366f, 0.05903680f, -0.03810211f, 
    0.08518044f, -0.05771915f, 0.04197659f, 0.00309353f, -0.03570144f, -0.05466111f, 0.14221506f, 0.21572478f, 
    0.05546191f, 0.12223209f, -0.01188077f, -0.08311904f, -0.10169216f, 0.20235197f, 0.09905539f, -0.06746581f, 
    0.18007877f, 0.16417550f, 0.03787999f, 0.21192726f, 0.06916454f, 0.02209032f, 0.02187118f, -0.01597665f, 
    -0.26154524f, 0.08138814f, 0.25994220f, -0.32079533f, 0.06170883f, -0.07865831f, -0.09208959f, 0.05717235f, 
    -0.13653706f, -0.67191333f, -0.17690845f, -0.18575087f, 0.19886485f, -0.01177595f, 0.24583386f, -0.08769747f, 
    -0.02960268f, -0.07094099f, 0.06314363f, -0.47489461f, -0.09309401f, 0.02638111f, -0.08083392f, -0.03536508f, 
    -0.16962719f, -0.11048809f, -0.02217945f, 0.12569603f, -0.15393056f, -0.16859771f, 0.01305610f, -0.02508986f, 
    0.15006791f, -0.00025923f, 0.18334526f, -0.01351532f, 0.07100146f, 0.35897496f, 0.02417318f, -0.26351389f, 
    0.14274523f, -0.00312791f, -0.00088775f, 0.00923837f, -0.01093805f, -0.06556416f, -0.03182895f, -0.32474506f, 
    -0.00076991f, -0.04917654f, -0.02768039f, -0.01214036f, 0.02381725f, -0.01676684f, -0.21003117f, -0.23236968f, 
    -0.05369210f, 0.13241570f, -0.08807307f, -0.02071849f, -0.10098632f, -0.06921533f, 0.11463239f, 0.17871538f, 
    -0.17094091f, -0.08149745f, 0.10937886f, -0.13657062f, 0.09201209f, 0.11851022f, 0.11115783f, -0.04655549f, 
    -0.23959081f, -0.01422576f, -0.19439235f, 0.14295749f, 0.11298210f, 0.17680824f, 0.18608704f, 0.15726580f, 
    0.08765773f, 0.10054399f, 0.22169302f, -0.12449928f, -0.03090570f, -0.09958304f, 0.08795633f, 0.11440148f, 
    0.12822188f, -0.00046138f, -0.33856657f, 0.08622112f, -0.10705817f, -0.34952620f, -0.07812420f, -0.11693366f, 
    0.05269493f, 0.01121890f, 0.02208128f, -0.24919464f, 0.16408326f, 0.40377131f, 0.07295152f, -0.03142856f, 
    -0.02616918f, 0.01978503f, -0.09668950f, 0.10200483f, -0.14349911f, 0.01798171f, -0.14160264f, 0.05314667f, 
    0.17043784f, -0.03838493f, -0.07231522f, 0.21229710f, -0.02393045f, -0.05249425f, -0.01407254f, -0.28236109f, 
    -0.02231191f, -0.04914337f, 0.15276517f, -0.00319652f, 0.02512821f, -0.06982742f, -0.41671363f, 0.34793594f, 
    0.16569132f, -0.13492976f, -0.17838311f, -0.20131905f, -0.14868221f, 0.10565212f, -0.19293672f, -0.31089899f, 
    -0.27702007f, 0.11988086f, -0.06341776f, -0.05625553f, -0.14421499f, 0.12751466f, 0.10430095f, 0.18608791f, 
    -0.22883730f, 0.25068861f, -0.10362798f, -0.11594519f, -0.01491420f, 0.01193618f, -0.01275011f, 0.15120113f, 
    -0.01964710f, 0.35130534f, -0.01669116f, -0.12729040f, 0.01816055f, -0.13902336f, 0.23337638f, 0.08015192f, 
    0.16670395f, 0.00273948f, -0.18682669f, 0.12226863f, 0.00417508f, -0.05366953f, -0.09033483f, -0.17587169f, 
    -0.08406585f, 0.03320458f, 0.16102277f, -0.12780511f, 0.08584138f, 0.11192773f, 0.02397775f, 0.12089634f, 
    -0.12848447f, -0.08180581f, -0.02584526f, 0.01202435f, -0.05650816f, 0.19766411f, -0.62154102f, 0.10510739f, 
    -0.05691731f, 0.22907621f, 0.31693831f, -0.04602693f, 0.10793796f, -0.00766003f, 0.09822339f, 0.18406400f, 
    -0.07403312f, 0.14385138f, -0.10928801f, 0.04319569f, 0.02596690f, -0.16514775f, -0.12164163f, 0.38909370f, 
    0.35654813f, -0.04830299f, -0.24454309f, -0.01491378f, -0.07213502f, 0.11401623f, 0.03928981f, -0.15712100f, 
    0.13812740f, 0.48684385f, -0.02635093f, 0.14687279f, 0.06815117f, -0.08906350f, 0.15699108f, 0.12670131f, 
    -0.04494979f, -0.12460734f, -0.02440562f, -0.12350418f, 0.12190613f, -0.33927906f, -0.05548755f, 0.23491886f, 
    -0.03798496f, -0.11082298f, 0.35393173f, -0.04864577f, 0.02966907f, -0.20296104f, 0.14550003f, 0.09630215f, 
    0.05366793f, 0.12783702f, -0.32008669f, -0.05841172f, 0.53009921f, 0.17622903f, 0.03662387f, 0.08238018f, 
    0.17250480f, 0.10030210f, -0.05743891f, -0.11094335f, 0.15648521f, 0.18028580f, -0.13504072f, 0.13389048f, 
    -0.14749050f, -0.03112932f, 0.08852965f, 0.03305072f, -0.33018738f, 0.28193742f, 0.07033640f, -0.00463413f, 
    0.01539565f, -0.05109248f, -0.19318262f, 0.00497071f, 0.28398290f, -0.03227888f, -0.14945813f, 0.53647900f, 
    0.05756735f, -0.09377530f, -0.25385109f, -0.28114107f, 0.01023765f, -0.04370514f, -0.47617686f, 0.57960153f, 
    0.38105786f, -0.05719670f, 0.12358888f, 0.01203170f, -0.36080709f, 0.10983187f, -0.14811884f, -0.15535021f, 
    0.09026599f, -0.04413664f, -0.02006193f, 0.11238660f, -0.11284705f, 0.03373609f, 0.13216397f, 0.08864566f, 
    -0.00540576f, -0.28525952f, 0.05819869f, 0.14439997f, -0.14056113f, 0.16918717f, -0.05219892f, -0.10890438f, 
    -0.31746408f, -0.01877483f, 0.06067889f, 0.19317257f, 0.04550745f, -0.05210499f, -0.13248590f, 0.12108646f, 
    0.00374579f, -0.18135893f, 0.15837577f, 0.16491802f, -0.11984790f, 0.03144608f, -0.02773050f, 0.11926208f, 
    -0.02421653f, -0.16761363f, -0.17367797f, -0.05531622f, -0.13461176f, 0.04862886f, 0.11885121f, 0.03442413f, 
    -0.00169034f, -0.12506214f, -0.02895314f, 0.08612078f, 0.00410810f, 0.15232924f, -0.14419609f, 0.13455471f, 
    -0.00948284f, -0.09619283f, 0.11956502f, 0.19523419f, 0.10797794f, -0.15223345f, -0.18888269f, 0.03773846f, 
    0.02619467f, -0.04432306f, 0.09944939f, -0.07031910f, -0.23049386f, -0.01256610f, 0.09725168f, 0.20478845f, 
    -0.07442307f, 0.20297568f, 0.16549186f, 0.03975859f, 0.00906071f, -0.16006823f, 0.03473081f, 0.10597114f, 
    -0.02537918f, 0.01649845f, 0.01628927f, 0.08299679f, -0.03365249f, -0.06699801f, -0.05611970f, 0.08197775f, 
    -0.03560393f, 0.04385415f, 0.05047394f, 0.05247161f, -0.07821189f, -0.04118644f, -0.02893190f, 0.18920799f, 
    0.23326585f, 0.02899504f, -0.06018819f, 0.02306978f, -0.11212080f, -0.09756944f, 0.15542032f, 0.21978253f, 
    0.19171315f, 0.12228542f, -0.23373783f, -0.00160878f, 0.10322264f, 0.00695545f, 0.09463978f, 0.06654412f, 
    0.06872068f, 0.20571731f, 0.11419190f, -0.10144386f, -0.29789004f, 0.03415152f, 0.27810964f, -0.16936776f, 
    -0.05502703f, -0.00039234f, 0.03852581f, 0.05930242f, -0.15477453f, -0.13762587f, 0.05314114f, 0.04929528f, 
    0.11859003f, -0.13446505f, 0.17420866f, 0.29440644f, 0.20062523f, -0.11852037f, -0.18631640f, -0.27344471f, 
    0.18836761f, -0.00490412f, 0.12210612f, -0.21346912f, -0.11704754f, -0.15434542f, -0.18773295f, 0.16946566f, 
    0.03408298f, -0.05141920f, -0.05567965f, -0.00780303f, 0.09329699f, 0.22286077f, -0.17807487f, 0.01401423f, 
    -0.06927863f, -0.10949136f, 0.20844708f, -0.18369026f, 0.11265787f, 0.24025598f, 0.13895768f, 0.21633002f, 
    0.05584886f, 0.09367538f, 0.07293203f, -0.04375395f, 0.04456339f, 0.04007249f, 0.00575326f, 0.05350319f, 
    -0.06531753f, 0.02329167f, -0.19339663f, 0.02121724f, -0.00336087f, -0.03611061f, -0.15427220f, 0.09365032f, 
    0.01639171f, 0.10948510f, -0.13993229f, -0.00877289f, -0.03530914f, -0.12769079f, -0.09331053f, -0.11567088f, 
    -0.12304389f, -0.25446752f, -0.20334926f, 0.00290651f, -0.09225383f, 0.05008719f, 0.03055863f, 0.10327149f, 
    0.30973062f, -0.04859789f, -0.21826851f, -0.13849510f, 0.32855177f, -0.01410911f, 0.27029863f, -0.28593785f, 
    0.03487409f, -0.00373279f, -0.08679754f, -0.19539882f, -0.24603148f, -0.19969152f, 0.08063058f, -0.07557026f, 
    0.16504958f, -0.01188182f, 0.13680208f, 0.07690345f, -0.00437473f, -0.01038167f, 0.01478149f, 0.13665017f, 
    -0.07792408f, -0.22358483f, -0.06565320f, 0.00620635f, 0.05636492f, 0.21698035f, 0.00085957f, 0.13132444f, 
    0.08259693f, 0.04759454f, -0.12888786f, -0.03261714f, 0.16409811f, -0.02667438f, 0.06192625f, -0.12144015f, 
    -0.05345545f, -0.19104043f, 0.00502281f, -0.06732097f, 0.13679577f, 0.28025037f, -0.16782685f, -0.12199578f, 
    -0.15717688f, -0.11025194f, 0.05650390f, 0.15231940f, 0.23211834f, -0.13358195f, 0.09356143f, 0.05188892f, 
    0.00793429f, -0.03290597f, 0.07670126f, -0.41353682f, -0.10366820f, 0.05371067f, -0.01159940f, 0.03812576f, 
    0.10005525f, 0.14909866f, 0.01701217f, -0.14553253f, 0.10910848f, 0.12287601f, -0.07649642f, -0.19092596f, 
    -0.02218363f, -0.09199898f, -0.15286748f, -0.12268185f, -0.17985809f, -0.01837629f, -0.04406058f, -0.14265755f, 
    -0.08789341f, -0.06333222f, -0.06695120f, -0.31406280f, -0.30866602f, 0.23451130f, -0.03633187f, 0.34563223f, 
    0.25302672f, 0.04229123f, 0.12229917f, 0.03412544f, -0.04734264f, 0.14273958f, -0.10637324f, -0.20728578f, 
    0.15025687f, 0.02587611f, -0.00957892f, 0.13522123f, -0.22487123f, 0.03058594f, 0.06823917f, -0.16320504f, 
    -0.09148881f, 0.30535129f, 0.10870222f, -0.10567832f, 0.03642441f, 0.09220722f, -0.08644795f, 0.08363478f, 
    0.02465399f, 0.01544265f, 0.00971335f, 0.03046235f, -0.04321755f, 0.03707284f, 0.04755106f, -0.02196728f, 
    0.03681798f, -0.02326669f, 0.04816976f, 0.01100185f, 0.02644312f, 0.01831256f, 0.04421872f, -0.01087097f, 
    -0.00646380f, 0.03907342f, 0.02840820f, -0.02168601f, -0.02950789f, -0.03388394f, -0.06845922f, -0.00856313f, 
    -0.04332861f, -0.03256663f, -0.01119448f, -0.06730605f, -0.05365521f, -0.02340124f, 0.01215232f, 0.00693151f, 
    -0.02962738f, -0.02099800f, -0.04060282f, -0.01554320f, 0.03607709f, -0.05154721f, -0.05174138f, 0.03024402f, 
    0.00666829f, 0.04126267f, -0.01955829f, -0.03323872f, -0.03839966f, 0.01812127f, 0.00791700f, 0.02039218f, 
    -0.04004827f, -0.02546259f, -0.06551214f, 0.04079011f, 0.03563919f, 0.01285200f, -0.05456511f, -0.05384220f, 
    0.00547931f, 0.03204092f, -0.03312743f, -0.01444022f, 0.00140396f, 0.01828512f, -0.05174016f, 0.04509974f, 
    0.00387088f, 0.04795662f, 0.02517838f, -0.00626037f, -0.02303030f, -0.00004789f, -0.00301974f, 0.02042115f, 
    -0.06405969f, 0.04623716f, 0.04439255f, 0.01533302f, 0.03885476f, 0.01174916f, 0.02699935f, 0.00857549f, 
    -0.01905194f, -0.03995546f, 0.03628578f, 0.01327178f, 0.01838374f, 0.05125218f, -0.06609603f, 0.05190841f, 
    -0.01944774f, -0.04562436f, 0.04612924f, -0.03756259f, -0.04048185f, -0.01794417f, 0.01070021f, -0.03773683f, 
    0.02550621f, 0.02119366f, -0.04752161f, -0.03787190f, -0.00820495f, -0.02130184f, -0.02903765f, -0.00383015f, 
    0.03309510f, -0.00414608f, 0.03556106f, 0.02572461f, -0.03407321f, 0.02362921f, 0.02449769f, -0.01970205f, 
    0.01152346f, -0.06090888f, -0.00633529f, 0.01522495f, -0.06796243f, 0.04187001f, -0.03215738f, 0.01159790f, 
    -0.00559472f, 0.01979315f, -0.03759180f, -0.03422061f, 0.01299541f, -0.02234379f, 0.05528390f, -0.04765153f, 
    -0.01389489f, -0.02183946f, -0.03842514f, 0.00816918f, -0.05795411f, 0.03927137f, 0.02750871f, -0.03514971f, 
    0.00204958f, -0.03747455f, -0.03876248f, 0.03174986f, 0.04113010f, 0.03963777f, 0.03060525f, 0.00076841f, 
    0.01635296f, 0.05262177f, -0.03506986f, -0.01535158f, 0.00951650f, -0.00982995f, -0.04899161f, 0.00032802f, 
    0.01546917f, 0.03984693f, -0.04622160f, -0.01602768f, -0.00343524f, -0.00204836f, 0.02113280f, -0.06935824f, 
    -0.01117116f, -0.01832682f, 0.00737382f, -0.02102501f, -0.02939566f, 0.04319691f, 0.05537939f, -0.00537262f, 
    0.02265665f, -0.01855110f, -0.02008964f, 0.02818300f, -0.02744113f, 0.04177644f, -0.02127113f, -0.01927551f, 
    -0.02344389f, 0.00749657f, -0.05919979f, 0.00451011f, -0.04184065f, 0.05864558f, 0.00443290f, 0.02720720f, 
    -0.02774697f, 0.02908996f, -0.03109165f, -0.04016741f, 0.03983970f, -0.00456950f, -0.00292657f, 0.03893006f, 
    -0.05402176f, 0.03885943f, -0.03401164f, -0.03275232f, -0.04194928f, -0.03524965f, 0.00717781f, 0.00025650f, 
    -0.05407825f, -0.06918206f, 0.03985409f, -0.02495331f, 0.03862622f, -0.03038597f, -0.00853591f, -0.02876567f, 
    -0.05899531f, 0.01394631f, 0.04522210f, -0.06418281f, -0.04748146f, 0.00644398f, -0.05377183f, -0.02672260f, 
    0.01606962f, 0.01790105f, 0.02960940f, -0.00959249f, 0.02481645f, -0.00570148f, 0.02181730f, -0.00847481f, 
    0.03804898f, 0.01223410f, -0.01150959f, -0.03522605f, -0.02600187f, 0.02625426f, -0.06765502f, -0.02940810f, 
    0.01110748f, -0.02425870f, -0.04199998f, 0.02757632f, -0.03877567f, -0.01663086f, -0.04463549f, 0.02060063f, 
    -0.05160964f, 0.03045961f, -0.01787955f, 0.05144876f, 0.04648333f, -0.05094990f, 0.01734702f, -0.04102037f, 
    0.01983484f, 0.00221749f, 0.00134859f, -0.05764819f, -0.03732677f, -0.02969010f, -0.00449466f, -0.01249878f, 
    0.00687863f, -0.00169312f, 0.04576946f, -0.01932300f, 0.01105200f, -0.05707562f, 0.04287335f, 0.05448714f, 
    -0.04300100f, -0.02097308f, 0.04473837f, -0.01526265f, -0.03708450f, 0.04751639f, 0.00130459f, 0.01625522f, 
    -0.00276870f, -0.05866616f, -0.01377017f, -0.06632257f, -0.01070375f, 0.02809419f, 0.00601142f, 0.02921440f, 
    -0.05636574f, -0.02369711f, -0.03428708f, 0.04448372f, -0.01718505f, -0.06669775f, -0.04063901f, 0.02227686f, 
    0.01236006f, -0.04460758f, -0.04191697f, -0.01317160f, -0.00423057f, -0.07233111f, 0.02028628f, -0.07928813f, 
    -0.08424427f, -0.04488723f, -0.03241899f, 0.01092654f, -0.01862800f, -0.03570889f, -0.01121300f, -0.02026223f, 
    -0.08932757f, 0.02078563f, 0.01943617f, -0.08573733f, -0.01015574f, 0.00855279f, -0.07721549f, -0.06975672f, 
    -0.08655051f, -0.04966328f, -0.01099250f, 0.00929877f, 0.00190726f, -0.07779083f, -0.04726577f, -0.02370874f, 
    -0.04090292f, -0.06929123f, -0.07787938f, -0.01685207f, -0.08367819f, -0.00125150f, 0.01910967f, -0.02385563f, 
    -0.08018094f, -0.00836696f, -0.04559451f, -0.01987785f, -0.08408549f, 0.01474981f, -0.08799674f, -0.03625480f, 
    0.01485876f, -0.03397133f, -0.02131408f, -0.07430559f, -0.06624538f, 0.00211498f, -0.08831130f, -0.07474656f, 
    -0.01374719f, -0.07174162f, -0.01762991f, -0.01016716f, 0.00250933f, -0.08048973f, 0.00590794f, 0.00254655f, 
    -0.01651084f, -0.00937768f, -0.04898862f, -0.06204934f, -0.04262421f, -0.08194300f, 0.03446570f, 0.00394567f, 
    -0.06853051f, -0.05848530f, -0.01492500f, -0.05840403f, -0.08662676f, -0.07637816f, 0.02719867f, -0.02510734f, 
    0.01719086f, -0.07460193f, -0.03621339f, -0.02449218f, -0.01759017f, -0.05312022f, -0.06518023f, 0.02080671f, 
    0.00875391f, -0.03306162f, -0.03381537f, 0.01520740f, -0.08434336f, -0.02440480f, -0.08719266f, -0.06990211f, 
    0.02301257f, -0.05210792f, -0.00857167f, -0.09498543f, -0.00503959f, -0.06747433f, -0.07755984f, -0.02363354f, 
    -0.02097738f, 0.00636470f, -0.02331627f, -0.04126185f, -0.01193218f, -0.05254021f, -0.07635307f, -0.02065559f, 
    -0.04633588f, -0.06772700f, -0.07675556f, 0.00184297f, -0.01566747f, 0.03589951f, -0.00897126f, -0.05077592f, 
    -0.05626558f, -0.06455205f, -0.06481194f, 0.00186256f, -0.04393872f, 0.01896229f, -0.05237369f, -0.00207990f, 
    0.00181025f, -0.03990601f, -0.00345326f, 0.01796369f, -0.04297446f, -0.07202528f, 0.02272027f, 0.02357409f, 
    0.03506800f, -0.04335158f, -0.02675709f, -0.05648678f, 0.02249648f, -0.07845923f, -0.03571126f, -0.03892823f, 
    0.01293417f, -0.05485275f, 0.01394481f, -0.01435134f, -0.02538921f, -0.06379525f, 0.02462633f, -0.07504150f, 
    -0.07917033f, -0.05015739f, -0.03886436f, -0.04583576f, -0.02023285f, -0.01042590f, -0.01522357f, 0.02061336f, 
    0.08677286f, 0.00814083f, -0.02028766f, -0.07386240f, 0.02574521f, -0.02165190f, -0.08446337f, 0.00975626f, 
    -0.05650384f, -0.07675042f, -0.04174270f, -0.07372920f, 0.01033720f, -0.07876147f, 0.01675162f, 0.00559652f, 
    -0.02249540f, -0.05435100f, -0.01271723f, -0.03701497f, -0.03127580f, -0.05205884f, -0.01118526f, -0.03758619f, 
    -0.00190022f, -0.06656733f, -0.04571269f, -0.08955517f, 0.00573786f, -0.05036590f, 0.00280618f, 0.00587200f, 
    -0.03475920f, -0.08142959f, 0.01658046f, -0.01640914f, -0.07874865f, -0.01108079f, -0.00690326f, -0.06278889f, 
    -0.01893603f, -0.01891776f, -0.08069827f, -0.05871689f, -0.02031289f, -0.04252148f, -0.08840739f, -0.03256017f, 
    -0.00011031f, -0.08209629f, -0.00196349f, -0.07194844f, -0.02337933f, -0.01387892f, -0.05338350f, -0.05330786f, 
    -0.03023485f, 0.03775648f, -0.04622119f, 0.02418536f, -0.01940240f, -0.07348428f, 0.01197559f, -0.01201725f, 
    -0.01745819f, -0.05450951f, -0.03170148f, -0.08141989f, 0.01752630f, -0.04760110f, 0.00048820f, -0.06889980f, 
    -0.07576794f, -0.02813799f, 0.00097192f, -0.09168977f, -0.07510609f, 0.00787964f, -0.08713979f, -0.02703154f, 
    -0.02984188f, -0.07024185f, 0.01830818f, -0.00777858f, -0.04883625f, 0.04904069f, -0.03060624f, 0.03108322f, 
    -0.07782807f, 0.01821312f, -0.06628119f, 0.01393374f, -0.04769475f, 0.02527347f, 0.01143591f, -0.08447158f, 
    -0.02447776f, -0.07652894f, -0.03413037f, 0.01116591f, -0.02817527f, 0.00421638f, -0.07723888f, -0.00877497f, 
    0.00367149f, -0.02019539f, -0.01940756f, -0.01804791f, -0.02129172f, -0.02041822f, -0.00394527f, -0.09405605f, 
    0.00424064f, 0.00843042f, -0.00351110f, -0.00085719f, 0.00530614f, -0.02838441f, 0.01820628f, -0.07488043f, 
    -0.00358377f, -0.00508774f, 0.01975371f, -0.09183779f, -0.00210917f, 0.01275393f, -0.02957759f, -0.02996665f, 
    -0.26754680f, -0.07552762f, -0.19378914f, 0.03433160f, -0.02603984f, -0.19240339f, 0.06079111f, -0.05927668f, 
    0.08904058f, -0.21676786f, -0.39435744f, -0.37349114f, 0.05527436f, -0.24385770f, 0.23599267f, 0.02771276f, 
    -0.12357770f, 0.10207975f, 0.08354761f, 0.38311127f, 0.13320290f, -0.18156821f, -0.36122978f, -0.05217109f, 
    0.04434097f, 0.08332001f, 0.10182886f, -0.00186807f, -0.03308325f, 0.14390382f, 0.09103731f, 0.05787230f, 
    -0.03827507f, 0.27175787f, 0.07679235f, 0.07532515f, -0.07910673f, -0.14137231f, -0.41853416f, 0.15239386f, 
    -0.00773242f, 0.07487501f, 0.04309808f, -0.08775195f, -0.11903677f, -0.09274597f, 0.03823467f, 0.17616822f, 
    -0.07620887f, 0.06627832f, -0.04532968f, 0.13758780f, 0.01564824f, 0.11168742f, 0.20450801f, 0.31355762f, 
    0.46785423f, -0.03469859f, -0.10936438f, -0.10230713f, 0.07396780f, 0.02480633f, 0.01544623f, 0.04777338f, 
    -0.16061842f, 0.11131267f, 0.05027929f, 0.01433148f, 0.12500383f, -0.11052254f, 0.06490691f, -0.08360221f, 
    -0.01477870f, 0.17845139f, -0.01946394f, 0.00953892f, -0.22664520f, -0.02763088f, 0.17809708f, 0.10155382f, 
    0.14185245f, -0.01063406f, 0.27653313f, 0.40350759f, -0.09754100f, -0.08230317f, 0.00991593f, -0.05237273f, 
    0.00094448f, 0.02329384f, 0.22341838f, 0.40636653f, -0.08208894f, 0.09767572f, -0.24543022f, -0.07712673f, 
    0.07862748f, 0.07296123f, 0.06153816f, -0.26312128f, -0.31060863f, -0.14412537f, -0.12073752f, 0.05712310f, 
    -0.09681025f, 0.14204417f, -0.10050287f, -0.02698178f, 0.24184103f, -0.15944770f, -0.00622772f, -0.10356963f, 
    0.07345251f, -0.19544178f, 0.15004642f, 0.03346521f, 0.07014314f, -0.14055932f, -0.01293439f, 0.13499884f, 
    0.04462491f, 0.00073775f, -0.01041660f, 0.09832962f, 0.20593682f, 0.06214519f, 0.10645913f, -0.11788281f, 
    0.00397723f, -0.04310950f, 0.03582538f, -0.08555372f, 0.04829954f, 0.02805265f, -0.08509130f, 0.31580424f, 
    0.52047569f, 0.14664127f, -0.03437563f, -0.10081778f, 0.03403574f, 0.12392020f, 0.05080178f, 0.01741111f, 
    -0.14528319f, -0.21624373f, 0.08307691f, -0.02624474f, 0.00639252f, 0.11667870f, 0.02326000f, 0.14626125f, 
    0.08618966f, 0.10954619f, -0.06984304f, 0.04825594f, 0.09695694f, 0.16245097f, -0.02953498f, 0.19598298f, 
    -0.17065549f, -0.04952426f, -0.04050488f, 0.01950582f, 0.26675588f, -0.03982953f, -0.04985311f, -0.01650064f, 
    -0.07491542f, -0.06306553f, -0.06901111f, 0.09279957f, 0.13408732f, -0.03892457f, -0.32633799f, 0.03341971f, 
    0.02549387f, -0.00788954f, 0.08893705f, 0.15932173f, -0.15210311f, -0.40810069f, -0.21435031f, 0.06805707f, 
    -0.05427866f, 0.12243601f, 0.05924452f, -0.07360590f, 0.08999920f, -0.05295476f, 0.06241912f, 0.30189967f, 
    0.08687611f, -0.08590025f, -0.00991669f, 0.09987316f, -0.04583453f, -0.00536344f, -0.16662653f, -0.18723135f, 
    -0.52372569f, 0.03820351f, 0.14505973f, 0.03663616f, 0.12588063f, 0.03182788f, -0.12398588f, -0.02244829f, 
    -0.05923918f, 0.05101676f, -0.06407757f, -0.13722226f, 0.04929018f, 0.12771031f, 0.05737600f, 0.03620838f, 
    -0.02349298f, -0.09988064f, -0.11051522f, 0.03478501f, -0.05945943f, -0.02622144f, 0.04388958f, 0.04227358f, 
    0.18835279f, -0.15140264f, 0.22417152f, -0.21101093f, 0.17654479f, 0.08438749f, 0.02231323f, 0.10704885f, 
    -0.04941336f, 0.00434262f, -0.12540235f, 0.09607459f, -0.15685588f, 0.04757902f, -0.11257548f, 0.06008046f, 
    0.09689437f, -0.00671236f, 0.08407868f, -0.17568779f, -0.10381369f, 0.33049783f, 0.02578454f, 0.07260391f, 
    -0.00629736f, 0.00114380f, -0.13612229f, 0.01497514f, 0.00536515f, -0.15495645f, 0.06922640f, -0.10222203f, 
    -0.09131199f, -0.13754587f, 0.05975136f, -0.10579061f, 0.06891576f, -0.50611705f, -0.28438050f, 0.22867230f, 
    -0.30259997f, 0.09462442f, -0.29003754f, -0.08288782f, -0.04362700f, 0.12339261f, -0.30611423f, -0.52961737f, 
    -0.32523569f, -0.14235084f, 0.11723844f, -0.04090610f, 0.01053870f, 0.11265285f, 0.07506356f, -0.34918952f, 
    -0.09885848f, -0.50990373f, -0.11310124f, 0.05266465f, -0.04956300f, 0.09361468f, 0.01063349f, 0.16208866f, 
    0.05246980f, 0.00650634f, -0.06975724f, -0.15034674f, 0.10340780f, -0.07952257f, 0.10363286f, -0.09536321f, 
    -0.03590593f, 0.35822660f, 0.11979709f, -0.27039576f, -0.02783577f, 0.14802797f, 0.19921540f, 0.01481917f, 
    -0.06328572f, -0.06456400f, -0.16661775f, -0.22020224f, -0.14340465f, 0.00005188f, 0.13665164f, 0.18305507f, 
    0.02690030f, 0.19414824f, 0.17444246f, 0.15511392f, -0.00352116f, -0.30652231f, -0.00571911f, -0.03527849f, 
    -0.11591201f, -0.10604482f, -0.00215107f, 0.01802604f, 0.24172018f, -0.20397118f, -0.03672175f, -0.01184266f, 
    0.10198967f, -0.16537942f, 0.04763322f, -0.09838331f, -0.10543851f, 0.19508253f, 0.09076361f, -0.10393453f, 
    -0.01931304f, -0.01004424f, -0.21310599f, -0.04576729f, -0.10055814f, -0.01441249f, 0.18608324f, -0.01927314f, 
    -0.05870183f, -0.08071614f, -0.03727232f, 0.08242997f, -0.00513211f, 0.03654556f, 0.14754964f, 0.22423778f, 
    0.33304924f, 0.13473061f, 0.05497588f, 0.08196330f, 0.12079179f, 0.15802810f, 0.00087951f, 0.03024208f, 
    0.25783587f, -0.21512081f, -0.26673865f, -0.04534176f, -0.08431205f, -0.11263216f, 0.03382145f, -0.23490685f, 
    0.03585800f, -0.14368087f, -0.04869821f, -0.18696041f, -0.12483995f, -0.03693814f, -0.04718319f, 0.02432960f, 
    -0.10188042f, -0.05596298f, 0.01730305f, -0.10337890f, -0.10633311f, 0.07417060f, -0.03546365f, -0.21875860f, 
    -0.03969920f, -0.23159117f, -0.03468297f, 0.33667040f, 0.27407491f, 0.26084802f, 0.04080564f, -0.10404953f, 
    0.09279800f, 0.04060132f, 0.03145582f, -0.17239796f, 0.06429750f, -0.14353798f, -0.17382477f, -0.10496771f, 
    0.00337264f, -0.04927466f, -0.35631737f, -0.09929170f, -0.34343746f, 0.06639240f, 0.16098353f, 0.16449113f, 
    0.15932980f, 0.01518296f, 0.04698456f, 0.06186533f, 0.05769147f, 0.23106390f, -0.43213651f, 0.09071534f, 
    -0.24266864f, 0.10828165f, -0.04626648f, -0.03860457f, 0.15612124f, -0.00551084f, 0.19473654f, -0.06340180f, 
    -0.11935283f, -0.07152325f, 0.02466209f, 0.01356745f, -0.07743381f, -0.08854814f, -0.26432508f, 0.08219806f, 
    -0.19423564f, 0.01776897f, 0.17020437f, 0.04837030f, 0.09146921f, 0.13067290f, 0.18971170f, 0.11218847f, 
    0.07633989f, 0.18350407f, 0.18669975f, -0.03108951f, 0.09062454f, -0.00288411f, 0.08486947f, 0.06655511f, 
    0.04625291f, -0.15037535f, -0.21743982f, -0.40967727f, -0.23750514f, 0.06524285f, -0.04718777f, 0.12328952f, 
    0.19781595f, 0.20398267f, -0.01661626f, 0.21517532f, 0.15034340f, -0.11540914f, -0.07671399f, -0.04678096f, 
    -0.06612431f, 0.04292423f, -0.15647264f, 0.06565628f, -0.39416075f, -0.24847588f, -0.25466552f, -0.03310884f, 
    0.03421472f, 0.34622824f, 0.05342692f, -0.06347115f, -0.20321573f, -0.08001310f, -0.06360210f, 0.04111296f, 
    0.07449105f, 0.05657565f, 0.07403794f, 0.02774961f, -0.03838783f, 0.13930908f, 0.16408949f, 0.02110819f, 
    -0.16775520f, 0.19509834f, -0.24965206f, -0.11419359f, 0.04737801f, 0.02721828f, 0.18986805f, 0.18729655f, 
    0.16615719f, 0.16235223f, 0.13309355f, -0.01978513f, -0.02148608f, 0.22133572f, -0.07644843f, 0.22002189f, 
    0.09471822f, 0.08299696f, 0.05372883f, 0.21326323f, -0.01098321f, -0.15626255f, 0.23238277f, 0.05535945f, 
    0.20525056f, 0.25017717f, -0.10028313f, 0.10290072f, -0.02137868f, -0.11561994f, 0.03863938f, -0.02662395f, 
    0.16377476f, 0.03688899f, 0.31820142f, 0.10366425f, 0.06729116f, -0.07410399f, 0.15721138f, 0.09706216f, 
    0.06419524f, -0.06295583f, 0.14100990f, -0.04385215f, -0.08707651f, 0.09926212f, 0.04881000f, -0.06509306f, 
    0.04666246f, 0.15946727f, -0.02149790f, 0.12162968f, -0.19838241f, -0.29485303f, -0.05807700f, 0.06034679f, 
    0.09278783f, 0.19626945f, 0.14032081f, 0.12510651f, 0.01937913f, -0.32015327f, -0.23136926f, 0.06341784f, 
    0.02582840f, -0.01395188f, 0.25812504f, -0.01789380f, 0.22111049f, 0.00584887f, 0.00028038f, -0.25283763f, 
    0.15525207f, 0.12693582f, 0.16100459f, 0.04731385f, -0.04526806f, -0.04090682f, 0.16697644f, 0.05674199f, 
    0.01085890f, -0.18675302f, -0.11361362f, -0.14137170f, 0.02388902f, -0.08182406f, 0.23994943f, -0.14164482f, 
    0.34558067f, -0.08674363f, -0.10173483f, 0.29453880f, -0.21033788f, 0.02163292f, -0.21791813f, 0.02906723f, 
    -0.20889266f, -0.07327608f, 0.11368030f, -0.14964375f, 0.15425521f, 0.04763397f, -0.00085207f, -0.18781824f, 
    -0.30839252f, 0.07870270f, -0.09689969f, 0.02342930f, -0.01917098f, 0.05401825f, 0.06742438f, 0.03324647f, 
    0.03144308f, -0.30522308f, -0.11448333f, -0.02809437f, 0.20167083f, 0.11424617f, 0.04911849f, -0.24577372f, 
    -0.06265656f, -0.05309497f, -0.13925193f, 0.09997416f, 0.23632430f, 0.23229371f, -0.14945841f, 0.11745489f, 
    0.16557793f, -0.00306930f, 0.01165182f, -0.02177711f, 0.17169493f, 0.01109284f, 0.28749302f, 0.14693247f, 
    -0.04670127f, -0.09927463f, -0.29819950f, 0.03587240f, -0.13455187f, 0.03172525f, 0.01884583f, 0.04494471f, 
    -0.00490967f, -0.00500530f, 0.05012311f, -0.06755482f, 0.01246633f, -0.07690279f, 0.03941337f, -0.06703185f, 
    0.01201574f, 0.21813549f, -0.14828016f, 0.01176240f, 0.17816396f, 0.03531693f, 0.08740246f, -0.00438252f, 
    0.05949512f, 0.11691749f, 0.15965228f, 0.11059845f, 0.02017345f, -0.14153208f, 0.16837373f, -0.09619034f, 
    0.10330393f, 0.00817186f, 0.05134978f, -0.12309761f, -0.12615336f, -0.08328274f, 0.04086140f, 0.10507823f, 
    0.22283930f, 0.19749710f, 0.13570108f, -0.10024682f, 0.00274228f, -0.05489088f, 0.18226746f, 0.01576018f, 
    0.21952203f, 0.03866408f, 0.05736978f, 0.29942465f, -0.12099718f, -0.12829040f, -0.18424781f, 0.08330596f, 
    -0.01765172f, 0.03394456f, -0.06775236f, -0.09203136f, -0.03246941f, 0.08404788f, -0.26942134f, 0.03501102f, 
    0.11309388f, 0.13762237f, -0.06884460f, 0.19482708f, 0.15836063f, 0.03028244f, -0.13337766f, 0.00979971f, 
    0.07192054f, 0.05228489f, 0.22134861f, -0.07741159f, -0.13743733f, 0.00792716f, -0.33980146f, 0.28195187f, 
    0.14955343f, -0.05685868f, -0.15099056f, -0.08948358f, 0.12108970f, 0.14214544f, -0.23485100f, -0.05317574f, 
    -0.13710538f, 0.09409581f, 0.13756953f, 0.10110460f, 0.09617607f, 0.07545816f, -0.07790463f, 0.28099951f, 
    -0.00807996f, 0.04963256f, 0.02050022f, 0.03151241f, -0.07116576f, -0.03030442f, -0.00874318f, 0.03337085f, 
    -0.00784923f, 0.08277707f, 0.14422388f, 0.18010172f, -0.00974455f, -0.13605943f, 0.09319366f, 0.04991923f, 
    0.01492307f, 0.23164716f, -0.37379166f, -0.03587966f, -0.01942742f, 0.01157953f, -0.00789147f, -0.05640744f, 
    -0.05199433f, -0.16050692f, -0.03006080f, 0.13080260f, 0.08493406f, 0.01771111f, -0.10293128f, 0.06040200f, 
    -0.04544341f, -0.01343019f, -0.09458916f, -0.02281558f, -0.06400537f, -0.01542629f, -0.01745086f, 0.02412720f, 
    -0.11373888f, -0.05571970f, 0.02471874f, -0.27365792f, -0.03034858f, -0.20087454f, 0.03272894f, 0.08277667f, 
    -0.11254756f, -0.10242730f, -0.06234845f, -0.06299990f, 0.10912309f, 0.02283930f, -0.05942080f, -0.11017772f, 
    0.23380394f, -0.04593492f, -0.01447767f, 0.09488895f, -0.15140752f, -0.02306480f, 0.18581292f, 0.10253987f, 
    0.08237744f, 0.08089669f, 0.13682012f, 0.12742031f, -0.00128299f, -0.07024577f, 0.04731559f, -0.07201155f, 
    0.14672500f, -0.11373182f, -0.08935308f, -0.07589760f, 0.08639704f, -0.03190801f, 0.03037424f, -0.32443070f, 
    -0.12852715f, 0.26355138f, -0.18505175f, 0.14502577f, -0.02471278f, 0.01571505f, 0.27610055f, -0.03942547f, 
    0.05862617f, 0.13380623f, 0.50898916f, -0.15421632f, -0.07533485f, 0.08637337f, -0.02441208f, 0.17258227f, 
    0.16443691f, 0.00527358f, 0.02702933f, -0.18310085f, 0.07059858f, 0.21050629f, -0.18498908f, -0.03045032f, 
    0.02851913f, -0.06906209f, -0.13175984f, -0.01785252f, -0.44302464f, -0.04396942f, -0.01115859f, -0.02119754f, 
    0.06286042f, 0.11151669f, -0.11132272f, -0.16966791f, -0.06775733f, -0.05748235f, 0.00820915f, 0.23993997f, 
    0.15315580f, -0.04622911f, -0.14741993f, -0.06195456f, -0.04341099f, -0.01749437f, -0.37062848f, 0.06509291f, 
    0.03472926f, 0.02155880f, -0.12322035f, 0.08073332f, -0.26297376f, 0.14841051f, -0.05235336f, 0.18260255f, 
    -0.30470225f, 0.54569328f, 0.06056274f, -0.04934840f, 0.18410937f, 0.01561423f, 0.10026845f, 0.15758051f, 
    0.05474788f, -0.34453714f, -0.38376364f, -0.17850411f, 0.27642375f, -0.20278822f, 0.06504363f, 0.02650695f, 
    -0.18445721f, 0.34740600f, -0.24768266f, 0.24299055f, 0.03098085f, -0.10731622f, 0.03495706f, 0.25106218f, 
    -0.08407459f, 0.02453164f, 0.20080121f, 0.06655584f, 0.08313874f, 0.00023348f, 0.09339187f, 0.32295248f, 
    -0.03323218f, -0.20112716f, -0.04816828f, 0.08064678f, -0.03578244f, -0.05422598f, 0.15488124f, 0.01186657f, 
    0.05351020f, 0.24614871f, 0.24911578f, 0.11594366f, 0.03645741f, -0.17682911f, -0.13496959f, 0.02190463f, 
    0.07545782f, 0.12270168f, 0.20038630f, 0.16223952f, 0.05888519f, 0.07557033f, -0.05421326f, -0.06583744f, 
    0.12642446f, 0.00376049f, 0.09407748f, 0.07453007f, 0.13208009f, 0.08810370f, 0.18185233f, 0.03353427f, 
    0.29303014f, 0.19602738f, 0.13357635f, 0.24770369f, -0.06560738f, 0.05897757f, 0.00325143f, -0.03423943f, 
    0.15806058f, -0.08800505f, 0.12820259f, -0.10290918f, -0.04690181f, 0.12987909f, -0.10802303f, 0.05837198f, 
    -0.00147666f, -0.19792557f, -0.02130790f, 0.06428943f, 0.05129558f, -0.06002476f, 0.02934258f, 0.18836726f, 
    0.15595707f, 0.01688683f, -0.02427669f, 0.36463618f, -0.05248874f, 0.13205861f, -0.03160845f, 0.00186428f, 
    0.11309376f, 0.11826184f, 0.12888567f, 0.07509849f, 0.02168471f, 0.08611902f, 0.09304332f, 0.06690827f, 
    0.04953601f, 0.11861715f, 0.15371045f, 0.13032255f, 0.24478701f, 0.14458515f, 0.02562861f, 0.23406553f, 
    0.00507879f, 0.16942300f, -0.17527652f, -0.02700576f, -0.12521100f, -0.19079132f, -0.09646361f, -0.08549028f, 
    0.04836655f, -0.02438939f, 0.30912480f, 0.26970908f, 0.17185529f, 0.13619101f, 0.03585231f, 0.20062974f, 
    0.05131959f, 0.11082003f, -0.05762686f, 0.22274296f, -0.05473013f, 0.05061908f, 0.01580170f, -0.09845316f, 
    0.28542301f, 0.06726310f, -0.01485235f, 0.13883212f, 0.04123729f, -0.03303389f, 0.14315291f, -0.05938822f, 
    0.04522527f, 0.20283331f, 0.03959668f, 0.11548387f, 0.07394403f, 0.10301726f, 0.00729000f, -0.03640039f, 
    -0.03610158f, -0.05354853f, 0.23330006f, 0.10840055f, 0.06749412f, 0.18342590f, -0.00557493f, -0.09662011f, 
    0.01527986f, 0.07775006f, 0.18766646f, -0.19003935f, 0.03319306f, -0.05791150f, -0.04519916f, 0.18005927f, 
    0.12076604f, 0.03181636f, -0.07888759f, 0.13953188f, 0.22868653f, 0.04965136f, -0.20003240f, 0.11310255f, 
    0.10035746f, 0.04621932f, -0.11026667f, 0.11733388f, -0.05385710f, -0.02173663f, 0.16894653f, 0.12956992f, 
    0.13844684f, -0.10558466f, 0.04804815f, -0.03753806f, 0.25508955f, -0.08582287f, 0.12559135f, 0.00505453f, 
    -0.18579665f, -0.08903092f, -0.09108201f, 0.03577379f, -0.11451760f, -0.03323979f, 0.05773645f, 0.27068025f, 
    0.03872391f, -0.07337593f, 0.16880974f, 0.16096364f, 0.15496190f, 0.03358367f, -0.21446668f, -0.12168775f, 
    -0.21892703f, 0.28539851f, -0.11993121f, -0.07260705f, 0.19272363f, -0.01183420f, 0.42584145f, -0.12771666f, 
    0.07416242f, 0.20628308f, 0.17875357f, 0.00683482f, -0.08163593f, 0.03725717f, 0.03559252f, 0.02586035f, 
    0.00722914f, -0.16290051f, -0.08332173f, 0.02474538f, -0.05687767f, 0.12901069f, -0.18227077f, -0.09072093f, 
    -0.10429218f, 0.17922278f, 0.15627229f, -0.02768032f, 0.04229406f, 0.03873251f, -0.08559829f, 0.19133376f, 
    -0.01382208f, -0.06831068f, 0.18856944f, 0.21276157f, 0.10374161f, -0.11587723f, -0.13904384f, 0.15277560f, 
    0.15839364f, -0.04422374f, -0.00507295f, -0.27490544f, 0.17613630f, 0.22248079f, 0.02177243f, -0.11250927f, 
    0.12526442f, 0.14465861f, 0.02831030f, 0.17158358f, -0.05693972f, 0.07278506f, 0.12534016f, 0.05540527f, 
    -0.02523970f, 0.05655190f, 0.12748320f, 0.04935494f, -0.18593591f, -0.30401388f, 0.22979493f, 0.19563687f, 
    0.01867707f, 0.01894981f, 0.02617847f, 0.21279022f, 0.14079981f, 0.04484920f, 0.05389110f, -0.59718579f, 
    -0.47671622f, 0.27107501f, -0.16066328f, -0.04609352f, -0.30181390f, 0.16456045f, -0.11971727f, 0.03838671f, 
    -0.03287240f, -0.16126680f, -0.00030216f, -0.15824519f, -0.05851313f, -0.12841390f, 0.00619056f, 0.14606924f, 
    0.54647809f, 0.05060026f, -0.13332669f, -0.34621105f, 0.03757849f, -0.03055082f, -0.09024207f, -0.10540977f, 
    0.17347799f, -0.33796817f, -0.22887662f, -0.67204219f, -0.19384168f, 0.03858266f, 0.29124412f, -0.05914751f, 
    0.18362805f, -0.12763833f, 0.21023338f, -0.17156810f, 0.12779570f, 0.07894938f, 0.16222067f, -0.07302867f, 
    0.05186609f, 0.04129579f, -0.11661445f, -0.36167508f, -0.08327370f, -0.20847693f, -0.08281478f, -0.00764549f, 
    0.06490036f, 0.00498855f, 0.01503755f, -0.02796023f, -0.26908994f, 0.19474997f, -0.05895434f, -0.24605729f, 
    0.13915402f, -0.10521224f, -0.07008600f, -0.00783618f, 0.10609166f, 0.06238325f, -0.36176383f, -0.66378182f, 
    -0.18490298f, -0.00320172f, 0.17015518f, 0.08847076f, 0.04914567f, -0.03957970f, -0.00833148f, -0.10011005f, 
    -0.09246071f, -0.09764453f, 0.08276795f, 0.15775837f, -0.08389930f, 0.04622143f, -0.03847818f, -0.43642822f, 
    -0.78435129f, 0.03636858f, -0.02839112f, -0.32486418f, -0.22914360f, -0.08410723f, 0.08143736f, 0.09597235f, 
    0.19580455f, -0.45294532f, 0.19883208f, 0.10514671f, 0.09264185f, 0.04903508f, 0.21330555f, -0.05386881f, 
    0.00977045f, 0.15174992f, 0.12745082f, 0.12090779f, -0.02569938f, -0.04700102f, -0.06603500f, 0.05392709f, 
    -0.01479251f, 0.18003061f, 0.00900290f, 0.21724972f, 0.23303588f, -0.07406172f, -0.05336085f, 0.02806926f, 
    -0.12753558f, -0.01633485f, 0.03824560f, -0.19850005f, -0.37919834f, -0.25424525f, -0.11016355f, -0.11304353f, 
    -0.18215030f, 0.02747572f, -0.04645121f, 0.06264331f, 0.08052391f, 0.12966755f, -0.17148529f, 0.03098454f, 
    0.17100590f, 0.15237230f, -0.10571814f, -0.10312536f, 0.31278542f, -0.06684794f, 0.05988322f, -0.30086812f, 
    0.19971773f, 0.04596118f, -0.06107441f, 0.05909888f, 0.04918449f, 0.00231879f, 0.22449060f, 0.42802140f, 
    0.19225551f, -0.07172391f, -0.01793340f, 0.02509363f, -0.05395420f, 0.20517102f, -0.11214951f, 0.01368097f, 
    0.17018564f, 0.27145800f, -0.12109634f, -0.08697182f, -0.11640202f, -0.16121913f, 0.18979524f, 0.11283854f, 
    -0.06377526f, 0.20881285f, 0.12041937f, 0.11887169f, -0.04922753f, -0.06287467f, -0.01103007f, 0.02272333f, 
    -0.16728511f, -0.58362079f, -0.54434484f, -0.28169420f, 0.11539114f, -0.01435124f, 0.08596558f, 0.10871780f, 
    0.06961361f, 0.10295876f, 0.12776721f, 0.12246509f, 0.26696602f, -0.01399420f, 0.16970152f, 0.15772694f, 
    0.13263960f, -0.03812021f, -0.05937629f, -0.44253442f, 0.09475922f, -0.03922048f, -0.29498395f, -0.14576280f, 
    -0.16903055f, 0.00880694f, -0.03471176f, 0.10627414f, -0.57392412f, 0.05285512f, 0.15132588f, -0.10959005f, 
    0.18115249f, 0.06048227f, 0.12863030f, -0.04314711f, -0.11209501f, 0.26657271f, 0.18281686f, 0.15210745f, 
    -0.10964451f, -0.02328783f, -0.11680555f, 0.01180089f, 0.01955068f, -0.06301684f, -0.05890341f, 0.08087807f, 
    0.25051105f, 0.06094087f, 0.03082674f, 0.13587350f, -0.01923945f, -0.07834983f, 0.05945763f, 0.16563934f, 
    -0.15479037f, -0.24157777f, -0.16768640f, -0.09451066f, 0.09036267f, 0.01208329f, -0.21495812f, -0.15340652f, 
    -0.06551626f, -0.28502214f, -0.07283476f, -0.10475183f, -0.06725378f, -0.14576371f, 0.17969748f, 0.02006050f, 
    -0.35955438f, -0.08976645f, -0.59844565f, -0.29295474f, 0.13893332f, -0.06950084f, 0.08914054f, 0.04583253f, 
    0.06399826f, -0.07657409f, -0.53765237f, -0.90836775f, -0.88557184f, 0.23041485f, -0.02308499f, 0.13058825f, 
    0.02544183f, 0.05392532f, -0.11812183f, 0.35826808f, 0.11639637f, 0.03805792f, -0.00459797f, 0.05709216f, 
    0.19665504f, 0.06390318f, 0.15080130f, -0.24343713f, 0.04769693f, 0.07454285f, 0.32005888f, -0.05031317f, 
    0.02004516f, 0.17220037f, 0.14548205f, 0.03226116f, -0.08838427f, 0.23429060f, 0.04980512f, 0.12251533f, 
    -0.02841577f, 0.04324622f, -0.02750554f, 0.05927671f, 0.01717418f, 0.10380634f, -0.77097708f, -0.44975689f, 
    0.15008643f, -0.06891561f, -0.13792473f, -0.11747844f, 0.07371879f, -0.15388438f, 0.17824265f, -0.47695851f, 
    -0.64790368f, -0.09371517f, 0.10841283f, 0.06661742f, 0.30694911f, 0.01918113f, 0.06240847f, -0.01739752f, 
    -0.09106441f, -0.35554671f, -0.03562628f, 0.32763365f, 0.12910177f, 0.06804343f, -0.11178444f, -0.07927738f, 
    0.15282184f, -0.41146195f, -0.07971919f, -0.79220420f, -0.04007133f, -0.12347130f, 0.27913740f, -0.02623619f, 
    -0.07468005f, 0.15537861f, 0.35188830f, -0.46069738f, -0.27115479f, -0.03296132f, -0.06589387f, 0.09386876f, 
    0.05649623f, 0.02321483f, 0.09630727f, 0.27574676f, -0.09097987f, -0.20979768f, -0.04170114f, 0.02404582f, 
    0.15566641f, -0.04541631f, 0.00849868f, -0.05072863f, -0.07988115f, -0.06947758f, 0.11579490f, -0.06442813f, 
    -0.04122266f, -0.16635883f, -0.02262949f, -0.02878720f, -0.08117609f, 0.31134593f, -0.12119992f, -0.13691431f, 
    0.04767288f, -0.07275454f, 0.12282416f, 0.03693546f, 0.00319104f, 0.08498832f, -0.13308157f, -0.37938508f, 
    -0.24539472f, 0.02664718f, 0.05895996f, 0.15087631f, -0.05718961f, -0.01079451f, 0.10262705f, -0.12658234f, 
    0.05416865f, -0.28246379f, 0.10510080f, -0.07646156f, -0.12603374f, -0.07579681f, -0.00369903f, 0.00971203f, 
    0.14073429f, -0.14347272f, -0.20049171f, 0.00216310f, 0.04718451f, -0.00864659f, 0.17705540f, 0.06586838f, 
    -0.03883100f, 0.04530360f, 0.20230120f, 0.01994088f, 0.00101240f, -0.23027593f, 0.08188892f, 0.16492286f, 
    0.14473554f, 0.11652711f, 0.18336992f, 0.18123184f, 0.08754698f, -0.18454576f, -0.19031832f, -0.04175461f, 
    0.12124310f, 0.04686672f, -0.06045308f, 0.08634198f, 0.25121829f, -0.45607874f, -0.02902649f, -0.14337215f, 
    0.04455505f, 0.15559189f, -0.04402286f, 0.12083261f, 0.00686523f, 0.13796382f, -0.15374260f, 0.04554132f, 
    0.03780083f, -0.04167195f, 0.03521699f, 0.29594758f, -0.00847443f, 0.04141833f, 0.16848485f, 0.15892912f, 
    -0.20637277f, -0.05379063f, 0.03905406f, 0.02207560f, -0.13140169f, -0.04497905f, 0.18603401f, 0.02931866f, 
    0.09648184f, 0.05995953f, -0.22820662f, 0.12330061f, -0.02589140f, 0.25830564f, 0.08209082f, 0.19299845f, 
    0.16985224f, 0.27033311f, -0.06134635f, -0.25883299f, -0.22608836f, -0.03211184f, 0.08681227f, 0.05624067f, 
    -0.10478485f, 0.11228897f, 0.03544887f, 0.09090259f, 0.03997746f, 0.12515348f, -0.00771187f, 0.09026434f, 
    -0.03067631f, 0.14211766f, -0.02803370f, -0.31979373f, -0.03279657f, -0.00129763f, -0.07107557f, -0.00720807f, 
    -0.00155559f, 0.08386497f, 0.29677421f, -0.21657705f, 0.16326253f, -0.08413027f, 0.00266517f, 0.05581233f, 
    -0.01463684f, 0.01011461f, 0.06407890f, 0.25388747f, -0.18619892f, -0.19473152f, -0.02150126f, -0.03688121f, 
    0.03183888f, 0.03815375f, -0.11628725f, 0.03765418f, -0.21818803f, 0.01010333f, 0.01867425f, -0.06443124f, 
    0.12588406f, 0.25076246f, 0.03636182f, -0.03063663f, 0.10546345f, 0.33035630f, 0.15245107f, 0.16766061f, 
    -0.09697177f, 0.06060677f, 0.12979926f, -0.01660480f, 0.03045940f, 0.02247346f, -0.12487782f, -0.00995025f, 
    -0.08681081f, 0.03696465f, 0.03938619f, -0.21810070f, -0.00267336f, 0.09214318f, 0.21290447f, -0.16031209f, 
    -0.00497136f, -0.22478004f, -0.04846868f, -0.09167675f, 0.18317613f, 0.02483897f, 0.05866550f, 0.05777963f, 
    0.01827776f, -0.05730151f, -0.04425173f, 0.07904666f, 0.01437374f, -0.02055032f, 0.08928241f, -0.12419879f, 
    -0.04613454f, -0.02817074f, -0.09607434f, -0.13897687f, -0.00707074f, -0.18797287f, -0.04178264f, 0.03810707f, 
    0.03884226f, 0.04165117f, -0.29621157f, 0.04896364f, -0.64737058f, 0.04744373f, -0.10111438f, 0.08606900f, 
    0.13439120f, 0.10946666f, -0.22133681f, 0.47032487f, 0.00588754f, 0.10352279f, 0.11316596f, -0.00053903f, 
    -0.02410744f, 0.06384929f, -0.08566842f, -0.05558690f, 0.30299428f, -0.14404385f, 0.15064554f, -0.17810258f, 
    -0.01106296f, -0.09849562f, -0.01606443f, -0.01629797f, -0.05751581f, 0.25442880f, -0.17403968f, -0.13602667f, 
    0.10682236f, -0.04747021f, 0.16311999f, -0.06140091f, 0.05147383f, 0.05895568f, -0.18705514f, 0.08774732f, 
    0.11503152f, 0.19904073f, 0.04592207f, -0.03002615f, 0.15464693f, -0.24854523f, 0.02501422f, 0.04526013f, 
    -0.24317759f, -0.16366673f, 0.02155594f, -0.20665500f, 0.02874485f, 0.05513011f, -0.03165568f, 0.18355544f, 
    0.03164473f, 0.01373801f, 0.04925690f, 0.04636351f, -0.00590926f, -0.01989411f, 0.00910376f, -0.02976994f, 
    0.04424080f, -0.02471731f, -0.00076586f, 0.04014948f, -0.00396998f, -0.00777207f, -0.01498175f, 0.02549046f, 
    0.01886143f, -0.06470492f, -0.03767323f, -0.01352606f, 0.02755588f, 0.00445460f, -0.02922156f, -0.04203534f, 
    -0.00198599f, 0.03978993f, -0.06212181f, -0.03142074f, 0.01923067f, -0.01058986f, -0.00774448f, 0.04942914f, 
    0.03980447f, 0.02567005f, 0.03532977f, 0.05359377f, 0.02460080f, -0.05118737f, 0.00914007f, -0.03394293f, 
    -0.01651395f, 0.03213787f, 0.01693922f, 0.02595665f, -0.04224581f, 0.04429678f, -0.06154127f, -0.02944272f, 
    -0.04521466f, -0.02527043f, 0.02711791f, -0.02837324f, 0.02307395f, 0.01961606f, -0.03309635f, 0.04978310f, 
    0.04658836f, -0.01196661f, -0.04972760f, -0.01384973f, -0.01797976f, -0.04486304f, -0.05821394f, -0.01739132f, 
    0.03605324f, 0.01177460f, -0.05649231f, -0.03678335f, -0.04692441f, -0.04451161f, -0.04502949f, 0.00392050f, 
    0.03179068f, -0.05712453f, -0.05876947f, -0.02497838f, -0.04044148f, -0.04075218f, 0.00908497f, 0.00243242f, 
    0.00028181f, -0.04670468f, -0.02588913f, 0.00563485f, 0.02089753f, -0.05957608f, -0.01607541f, -0.04431023f, 
    -0.05913196f, 0.02754346f, 0.02422500f, 0.03135825f, -0.05785981f, 0.04400581f, -0.03296273f, -0.05764588f, 
    0.01794257f, 0.03059893f, -0.03597791f, 0.02157779f, -0.01169463f, 0.01082378f, -0.04244256f, 0.04845368f, 
    -0.03981457f, 0.03635354f, -0.05088946f, -0.03699808f, 0.00188516f, -0.06096809f, 0.00274814f, 0.01037220f, 
    -0.06342634f, -0.00962411f, -0.01247779f, -0.00593114f, -0.00479517f, -0.05085585f, -0.06200209f, -0.05046395f, 
    0.03859549f, -0.02247213f, -0.06070749f, -0.03311617f, 0.03265254f, 0.04052921f, 0.00381777f, -0.05964822f, 
    -0.06403557f, 0.02193471f, -0.01598972f, -0.01384697f, -0.03032047f, 0.00334903f, -0.00204401f, 0.02427291f, 
    -0.04508694f, 0.03235199f, 0.00558856f, 0.04539789f, 0.01763536f, -0.06233692f, -0.01524181f, 0.02185011f, 
    0.01487716f, -0.00647227f, -0.00854600f, -0.04104076f, -0.03054872f, 0.03535268f, 0.04886602f, 0.02909542f, 
    0.00179706f, -0.05070675f, -0.03055950f, -0.02478983f, 0.00347265f, 0.04419371f, 0.03595604f, -0.04000100f, 
    0.05243065f, 0.03426609f, -0.00478563f, -0.00081221f, 0.03458208f, -0.04493979f, -0.04186190f, -0.00509190f, 
    0.00565000f, -0.04988845f, 0.03216550f, -0.05465358f, 0.03117555f, -0.02933898f, 0.01849754f, -0.02582049f, 
    -0.03035547f, 0.03534112f, 0.01133923f, -0.03154631f, 0.03080056f, -0.05892628f, -0.00479225f, -0.03162653f, 
    -0.05693690f, -0.00842305f, -0.04036058f, -0.02043561f, 0.02374569f, -0.06258076f, -0.03191466f, -0.01681525f, 
    -0.06535807f, 0.02772433f, -0.06211022f, 0.02061903f, 0.00420054f, 0.00414623f, -0.00875433f, -0.03867475f, 
    0.01517177f, -0.02224846f, -0.04154209f, -0.02731538f, -0.05874715f, -0.01336714f, 0.00958217f, -0.04412680f, 
    -0.06413291f, -0.01822058f, 0.02641763f, -0.02867286f, -0.06676789f, -0.04086294f, 0.04259874f, 0.04337899f, 
    -0.06082243f, 0.01725875f, -0.01967689f, 0.03924304f, 0.00578865f, -0.01954899f, -0.02801216f, -0.00805355f, 
    0.03269444f, 0.03332569f, -0.06221102f, 0.03520028f, -0.01876158f, -0.03082990f, 0.00994239f, 0.01440496f, 
    -0.03733679f, -0.06505218f, 0.01354646f, -0.05141816f, 0.01026370f, -0.05701889f, -0.00266731f, 0.04108010f, 
    -0.05279906f, -0.01273353f, -0.00549617f, -0.01706213f, 0.00627906f, -0.02162271f, -0.00643530f, -0.01361561f, 
    0.00535834f, -0.02984883f, 0.01034217f, 0.00094482f, 0.00779390f, -0.06073977f, 0.02642983f, -0.00929568f, 
    0.03283168f, -0.04047593f, 0.00946105f, -0.03135940f, -0.01479798f, -0.04630770f, -0.01929647f, 0.04606031f, 
    0.00182746f, 0.02354257f, 0.00490367f, 0.04422896f, -0.03808036f, -0.00300528f, 0.04341380f, 0.01442922f, 
    0.00455998f, -0.03003917f, 0.00309008f, 0.04740464f, -0.00531061f, -0.04067156f, -0.00042974f, 0.03950811f, 
    0.02929840f, 0.02534991f, 0.01851760f, -0.06178489f, 0.03048071f, -0.04519123f, -0.00690172f, -0.01647785f, 
    -0.08087966f, 0.03575541f, 0.17849840f, -0.09916072f, -0.20043658f, -0.23779874f, 0.21876223f, 0.14823583f, 
    0.11267484f, 0.31283841f, 0.25093281f, -0.09316447f, -0.10140357f, 0.33037946f, 0.14658952f, 0.19522345f, 
    0.08579248f, -0.08096897f, -0.03567541f, 0.14448810f, 0.03448980f, -0.19136687f, -0.10118935f, 0.11313807f, 
    -0.04451217f, 0.00453153f, 0.09089664f, -0.01896841f, 0.03581929f, -0.12866107f, -0.32124245f, -0.10112526f, 
    0.14693864f, -0.08857021f, 0.01464683f, 0.02212899f, -0.24577354f, 0.00613633f, 0.10241707f, 0.09569293f, 
    0.13488097f, -0.08039491f, -0.15066059f, -0.09704920f, -0.15357293f, 0.08108631f, 0.07037212f, -0.12730432f, 
    -0.18209560f, 0.10603483f, -0.13258150f, 0.04204019f, 0.12341035f, -0.02068564f, 0.29396522f, 0.14604008f, 
    0.05412035f, 0.26215300f, 0.13417615f, -0.05771601f, -0.06949381f, 0.04648735f, 0.07284625f, 0.06030708f, 
    0.27053484f, 0.20331298f, -0.30355993f, -0.13545664f, -0.09483562f, -0.09860440f, 0.01859790f, 0.03141608f, 
    0.21334495f, 0.14945228f, -0.28996700f, -0.21706803f, -0.07407453f, 0.02571106f, 0.16450885f, 0.14251514f, 
    -0.11224065f, 0.02592791f, 0.03416747f, 0.01309399f, 0.04804093f, 0.02805709f, -0.18166490f, -0.10656989f, 
    0.04441424f, -0.08661530f, -0.10952045f, 0.04834263f, 0.10308746f, 0.08184580f, 0.01785088f, -0.15609391f, 
    0.04078969f, -0.06598198f, -0.00298305f, 0.03456207f, -0.10298814f, 0.38596570f, -0.15768705f, 0.06879422f, 
    0.17931813f, 0.01222137f, 0.07465179f, 0.16192384f, -0.04906768f, 0.02206839f, -0.11072963f, 0.06963175f, 
    -0.10082073f, 0.08927008f, 0.08431689f, 0.06832699f, -0.26326105f, 0.01744062f, 0.00512806f, 0.15288162f, 
    -0.08009528f, -0.03217845f, -0.04911361f, 0.05867609f, -0.00891302f, 0.25978783f, 0.18477075f, 0.07867549f, 
    -0.03508973f, 0.14801800f, 0.32327917f, -0.25739142f, 0.09933362f, -0.06217226f, 0.09375591f, -0.15387076f, 
    0.36298659f, -0.04295466f, 0.04326292f, 0.17832059f, -0.09842428f, 0.07446785f, -0.07380830f, 0.11115836f, 
    -0.15823945f, -0.21513641f, -0.06206079f, -0.05283793f, 0.02377052f, 0.09050245f, -0.02020047f, -0.08084406f, 
    0.06386829f, 0.10046275f, 0.13875432f, 0.06306695f, -0.06388073f, -0.03891545f, -0.01246728f, -0.13178395f, 
    -0.13398921f, -0.07403662f, 0.19538705f, -0.17377126f, -0.15156792f, 0.04730811f, 0.07408466f, 0.07915679f, 
    -0.21572180f, 0.06041509f, 0.02174165f, 0.05000620f, 0.06978235f, 0.14472863f, -0.24757400f, 0.00758835f, 
    -0.11118536f, 0.13106567f, 0.09625182f, 0.02542851f, 0.15320122f, -0.15836710f, -0.24385524f, -0.04131076f, 
    0.08042976f, 0.17786080f, 0.03512589f, -0.12814140f, -0.30621195f, 0.06186135f, -0.12597205f, -0.09630683f, 
    0.01060142f, -0.04806476f, -0.02456751f, -0.20042351f, -0.39263684f, 0.13689950f, -0.05982371f, -0.01723724f, 
    0.23135339f, 0.15291061f, 0.17284128f, -0.20009653f, 0.14578725f, 0.06471775f, 0.19790040f, 0.02154894f, 
    -0.12395905f, 0.07423416f, -0.07747119f, -0.16004844f, 0.03600574f, -0.03113477f, 0.08863613f, 0.14988975f, 
    0.09385131f, 0.03856623f, 0.10482729f, -0.00911835f, -0.05540406f, -0.08444594f, 0.10344762f, 0.06029241f, 
    0.26691946f, -0.06026760f, 0.19642556f, 0.00130625f, -0.04444411f, -0.03922901f, -0.15561584f, 0.04581533f, 
    0.10882446f, 0.09100810f, 0.02923362f, 0.25088605f, 0.23765761f, 0.05059922f, 0.13192254f, 0.03644201f, 
    -0.10463317f, -0.00747234f, 0.06572691f, 0.16906759f, -0.24291737f, -0.04755998f, -0.06835338f, -0.06766684f, 
    0.10564603f, -0.00367196f, -0.09618651f, 0.06184531f, 0.24924558f, -0.08863992f, -0.11807672f, -0.08607634f, 
    -0.03432385f, 0.18704872f, -0.20168683f, 0.12107931f, 0.06435731f, -0.13348274f, -0.28506741f, 0.18238306f, 
    0.01558913f, -0.02777176f, -0.15315583f, -0.27199188f, 0.12309022f, 0.03042239f, 0.20308229f, 0.18186927f, 
    0.27074265f, -0.07332262f, 0.21234593f, -0.15693210f, -0.13239679f, -0.03444462f, 0.07495040f, -0.10714228f, 
    0.08174167f, -0.11254699f, 0.12957062f, -0.05981459f, -0.00637974f, -0.03577875f, 0.19676797f, -0.00215894f, 
    0.19093551f, -0.18412702f, 0.02842039f, 0.01537282f, -0.07890868f, -0.10312551f, -0.03125220f, 0.12140508f, 
    0.19548656f, 0.27222645f, -0.39228293f, 0.20086674f, 0.02245701f, -0.10362781f, -0.05734676f, -0.02178637f, 
    0.00427705f, 0.09971570f, 0.01814997f, 0.15776120f, 0.31786406f, -0.06866057f, -0.05707785f, 0.10627097f, 
    -0.03430800f, -0.10260299f, -0.10085271f, -0.05238862f, -0.00147968f, 0.03499788f, -0.22155342f, -0.00791210f, 
    -0.24010395f, -0.05513908f, -0.16602348f, 0.04965619f, 0.18213873f, 0.12549354f, 0.00665825f, -0.11145394f, 
    -0.16376030f, -0.09673837f, -0.08495307f, 0.26078227f, 0.17240062f, 0.08012258f, 0.00928566f, -0.09110297f, 
    -0.12023593f, -0.28606078f, -0.09140989f, 0.07712953f, -0.11770362f, -0.06258605f, -0.14273359f, 0.18174054f, 
    0.14313714f, -0.09487691f, 0.05870110f, 0.16239747f, 0.07046194f, -0.07572513f, 0.09216972f, -0.16868134f, 
    -0.13131061f, -0.04058613f, -0.05529159f, 0.01597131f, -0.24140568f, 0.00193242f, 0.00879427f, 0.00376016f, 
    -0.02530911f, -0.14955381f, -0.03550499f, -0.05876821f, 0.16606659f, 0.00073053f, 0.14474292f, 0.07499497f, 
    0.13533467f, -0.02621151f, -0.32222816f, 0.01934038f, 0.07096309f, 0.06417454f, -0.06689646f, 0.18257657f, 
    -0.06707978f, 0.08069314f, -0.20057681f, -0.45520779f, -0.06033105f, 0.07027937f, -0.07396854f, 0.11346022f, 
    0.09281677f, 0.15843114f, 0.05712406f, -0.21476209f, -0.35739350f, -0.08957890f, -0.04025310f, -0.10833481f, 
    -0.02459049f, 0.17496550f, -0.01042823f, 0.18992482f, -0.02965542f, -0.32130626f, -0.15203875f, 0.18357851f, 
    -0.01453265f, 0.03952042f, 0.11659881f, 0.07703156f, 0.21376085f, -0.22608170f, 0.08584961f, -0.08959837f, 
    0.08460014f, 0.08584643f, 0.00580127f, 0.25919193f, 0.25691941f, 0.20673074f, 0.14234611f, -0.45483059f, 
    -0.03585894f, -0.16142580f, 0.12104961f, -0.14049065f, 0.12038133f, 0.06453733f, -0.02075566f, -0.23527358f, 
    -0.24923734f, -0.30861551f, 0.09224577f, -0.01770597f, -0.15730059f, 0.02420123f, 0.06174731f, 0.10004783f, 
    0.16153051f, 0.11110601f, 0.02881606f, 0.14226694f, 0.10831951f, 0.02630440f, 0.14381322f, 0.05184161f, 
    0.10747495f, -0.14618464f, 0.00198861f, -0.07248031f, -0.03725982f, -0.16799495f, -0.20490181f, -0.03120473f, 
    -0.03968358f, 0.00050165f, -0.13800760f, 0.10709531f, 0.15722482f, -0.22942567f, -0.11740652f, -0.01470477f, 
    -0.09735595f, 0.02930742f, -0.02771657f, -0.09586807f, -0.00527575f, 0.10274598f, 0.19534591f, -0.13929904f, 
    -0.04416570f, 0.04817386f, -0.06544378f, 0.14167064f, -0.00524462f, -0.20507663f, -0.17862284f, -0.27488148f, 
    -0.04181334f, 0.06515276f, 0.04061130f, 0.04396042f, 0.04618113f, -0.24595368f, -0.30982524f, -0.20403221f, 
    -0.03738744f, 0.01646062f, -0.06886541f, 0.03237232f, -0.02064625f, 0.17972027f, -0.17561004f, 0.01539342f, 
    -0.13381808f, 0.06246927f, 0.01171648f, -0.22270085f, 0.03218817f, 0.13528451f, -0.03547722f, 0.00664710f, 
    -0.00505221f, 0.01806499f, 0.03174603f, 0.16744907f, 0.12873389f, 0.22293116f, 0.01661684f, 0.17488489f, 
    -0.14653811f, 0.00713690f, 0.12829764f, -0.02728146f, -0.08945350f, 0.02831469f, 0.00726170f, 0.21792223f, 
    0.12319851f, -0.00605068f, -0.02966053f, -0.01858735f, 0.16353716f, -0.20221314f, 0.05640756f, 0.11792186f, 
    0.15042669f, 0.01107406f, -0.14553346f, -0.48379743f, 0.07320076f, -0.03451521f, -0.05194823f, -0.19566974f, 
    -0.17220685f, 0.14688905f, 0.14788060f, -0.14739211f, -0.01287556f, -0.02047430f, -0.10711842f, -0.04139757f, 
    0.06433269f, -0.04476037f, 0.10752417f, 0.00348178f, -0.12452758f, 0.08753681f, 0.05046238f, -0.20251417f, 
    -0.14936078f, -0.10979795f, -0.12866791f, -0.08004622f, -0.06957944f, 0.00953696f, 0.19368687f, 0.25156602f, 
    -0.07922266f, 0.13950817f, -0.14320111f, -0.00166345f, 0.02959413f, -0.00776153f, 0.19223821f, -0.11389371f, 
    -0.34916538f, -0.16426827f, -0.04795372f, -0.00167639f, -0.15543242f, -0.09703010f, 0.06689443f, 0.38598484f, 
    -0.04617271f, 0.10513575f, -0.14158230f, -0.15691143f, 0.03312505f, 0.04685937f, 0.12914917f, 0.12919502f, 
    -0.04318644f, 0.02373495f, -0.04697787f, 0.03892954f, 0.01325782f, -0.01953892f, 0.00992233f, 0.02899328f, 
    0.01352916f, -0.01020069f, 0.03700019f, 0.01735291f, -0.01976707f, -0.01497471f, -0.01754712f, 0.01051451f, 
    0.04231290f, 0.02000087f, -0.02312900f, 0.05106226f, -0.06164718f, 0.04746751f, -0.01253746f, -0.03309928f, 
    -0.02641691f, 0.01994353f, -0.04458238f, 0.01200305f, 0.03668603f, 0.03928986f, -0.05523466f, -0.04296530f, 
    -0.05974024f, -0.00678457f, -0.04889453f, -0.03906386f, -0.04760191f, -0.00040275f, -0.06176415f, -0.01427031f, 
    -0.03352124f, -0.00534790f, -0.02394081f, 0.01253383f, -0.04727066f, -0.04285683f, 0.01210691f, 0.00860576f, 
    -0.03499768f, -0.05343804f, 0.01222976f, 0.04498826f, -0.05143905f, 0.01340742f, -0.02671267f, -0.06348977f, 
    -0.04457179f, -0.04813099f, -0.05879435f, -0.05041714f, -0.00495061f, -0.03092312f, -0.02020367f, -0.02064473f, 
    -0.03830284f, -0.02254338f, 0.01928700f, 0.00181014f, 0.03641481f, -0.03945791f, 0.02523966f, 0.02795774f, 
    -0.02077223f, -0.06361740f, 0.02926783f, 0.04344200f, 0.01716638f, -0.04002974f, -0.02703003f, 0.04478565f, 
    -0.02765940f, 0.01568667f, 0.04276133f, 0.01386391f, -0.03188754f, 0.00097748f, -0.00995079f, 0.01587224f, 
    -0.05587824f, -0.00182583f, -0.06057367f, 0.05033879f, 0.01855867f, 0.04983217f, 0.00581809f, 0.05182916f, 
    0.03482677f, -0.00808795f, 0.03105573f, -0.02703264f, -0.03345590f, -0.03496515f, 0.01597213f, 0.00791379f, 
    -0.02823599f, -0.04366523f, 0.03620069f, 0.00353489f, -0.01815766f, 0.02421564f, 0.01390497f, -0.01931790f, 
    0.01012873f, 0.03108621f, 0.00202667f, -0.05319030f, 0.01322423f, -0.01121728f, -0.01864662f, -0.05520438f, 
    -0.06419079f, 0.02058616f, -0.03924532f, 0.01690759f, -0.00852086f, -0.05046923f, 0.05094116f, -0.01558739f, 
    0.01727976f, 0.04962100f, -0.01301591f, 0.02394273f, -0.05733842f, -0.04374264f, -0.02596332f, -0.03894899f, 
    -0.05339167f, -0.02175072f, 0.03191369f, -0.01239210f, 0.00719689f, -0.05937824f, -0.00880447f, -0.02564184f, 
    0.03348670f, 0.02028188f, -0.00787758f, 0.03644555f, 0.00130634f, 0.00531701f, -0.02635884f, -0.02046987f, 
    -0.04982314f, 0.04350735f, -0.00930843f, 0.04502343f, -0.05712237f, 0.03518540f, 0.00637631f, -0.00638958f, 
    -0.00781797f, 0.04034751f, 0.02969856f, -0.05670275f, -0.05772086f, -0.05386424f, -0.05564416f, -0.02411049f, 
    0.04488103f, -0.00420171f, 0.03722182f, 0.04431329f, -0.04203822f, -0.00794799f, -0.03379625f, -0.05853131f, 
    0.00841649f, -0.06151248f, -0.06004359f, -0.03985064f, 0.03654416f, -0.05527440f, 0.03852346f, -0.00602780f, 
    0.03964404f, 0.00909619f, 0.01799402f, 0.02207283f, -0.00314859f, -0.04927114f, 0.02413367f, 0.00543746f, 
    -0.03523315f, -0.03658571f, -0.02454179f, 0.02799690f, 0.00567891f, -0.01671946f, 0.00621482f, -0.04896979f, 
    -0.01957075f, -0.02575157f, -0.00085405f, 0.00251929f, -0.00993852f, -0.04189896f, 0.03711161f, -0.02394841f, 
    0.00389891f, 0.01549546f, -0.00624447f, -0.04016611f, 0.02580086f, 0.02143141f, -0.03243228f, -0.04106345f, 
    -0.06130559f, 0.01487696f, 0.02845408f, 0.04236374f, 0.03278729f, -0.03751564f, 0.02898957f, 0.01525068f, 
    0.05204078f, -0.04336879f, -0.04362440f, 0.04766561f, 0.01373404f, -0.01152178f, 0.01298054f, 0.01417747f, 
    0.05083837f, 0.04811122f, 0.04767153f, 0.04889658f, 0.04096456f, -0.06020985f, 0.00776025f, -0.00739643f, 
    -0.01269184f, -0.05842910f, -0.02780535f, 0.03675974f, 0.00790409f, 0.04753986f, -0.04612608f, 0.04439075f, 
    -0.03744711f, -0.02160753f, 0.00773149f, -0.03701287f, 0.04355245f, -0.01975982f, -0.02342606f, -0.00355959f, 
    -0.01779755f, 0.03665851f, 0.04792250f, 0.01753881f, -0.04142999f, -0.03643590f, -0.01288553f, -0.06122684f, 
    0.04554283f, 0.00391460f, 0.00949060f, 0.04001705f, 0.03573039f, -0.05718869f, 0.02728407f, -0.04536046f, 
    0.02382958f, -0.04841362f, 0.03126031f, -0.03782813f, -0.00127047f, 0.05448971f, -0.00804534f, -0.03276250f, 
    -0.05847443f, -0.06325650f, 0.04789881f, -0.02184627f, -0.00603164f, -0.06439731f, -0.06107645f, -0.02337469f, 
    0.17180836f, -0.21603338f, 0.03107303f, 0.26400331f, -0.10328545f, 0.01930288f, 0.13687459f, -0.09739830f, 
    -0.16507374f, -0.40404549f, 0.16596669f, -0.30089125f, -0.07212275f, -0.18127969f, -0.00346840f, -0.16087860f, 
    0.18841885f, 0.00980962f, 0.60110253f, -0.15701903f, -0.23188931f, 0.06403355f, -0.08261071f, 0.06371362f, 
    0.13904861f, 0.04833798f, 0.06724355f, 0.07248232f, -0.02702371f, -0.19913813f, -0.04644678f, 0.06228758f, 
    0.07094150f, 0.02029908f, 0.16975999f, -0.10646486f, 0.07728273f, 0.06822737f, 0.00493949f, -0.09819259f, 
    0.05583247f, -0.22538231f, 0.06073033f, 0.12409341f, 0.03409055f, 0.09307668f, -0.18599051f, -0.27834171f, 
    -0.04344319f, -0.11885922f, 0.13135748f, -0.04924519f, 0.04213896f, -0.08592606f, -0.08039033f, -0.19466354f, 
    -0.22266781f, -0.03104370f, 0.13955075f, 0.14213362f, -0.03416341f, 0.03469343f, 0.16007331f, -0.04371659f, 
    -0.29414013f, 0.14817965f, 0.02604087f, 0.03531600f, -0.06237534f, 0.05022867f, 0.01927911f, 0.24366987f, 
    0.16864751f, -0.04812429f, -0.18205479f, 0.12698086f, -0.00576765f, 0.05479472f, 0.10124428f, 0.15255649f, 
    0.03928390f, 0.09820096f, 0.11883547f, 0.16377454f, -0.06914975f, 0.01805539f, 0.03969790f, 0.11912464f, 
    -0.02947924f, 0.03390337f, 0.29673848f, 0.15367310f, 0.10143115f, -0.05295871f, -0.02649494f, 0.09553532f, 
    0.02606892f, 0.07718050f, -0.04997840f, 0.01562221f, -0.18040323f, -0.38359880f, -0.01508475f, 0.10808775f, 
    -0.24223213f, 0.14265153f, 0.05297479f, 0.01578841f, 0.04054903f, 0.20191118f, -0.04943830f, 0.00744787f, 
    0.04442966f, -0.01262624f, -0.09254140f, -0.02755619f, -0.07354874f, -0.17078945f, 0.14471121f, -0.06165642f, 
    0.08187358f, 0.03257217f, -0.00240315f, 0.03420140f, -0.18581101f, -0.06844752f, -0.23672970f, 0.22288592f, 
    0.26817814f, -0.19087100f, -0.03350639f, 0.03482113f, 0.01970977f, -0.05776936f, -0.20662017f, 0.09343007f, 
    0.24616648f, 0.18251854f, -0.09827144f, -0.01460308f, -0.13346089f, 0.11850455f, -0.00856943f, -0.10929151f, 
    -0.04950372f, 0.19300425f, 0.17550796f, 0.14568555f, 0.02492283f, 0.02281396f, -0.01216085f, 0.10657694f, 
    -0.06081076f, 0.00008549f, -0.16061129f, -0.13515179f, 0.05997193f, 0.12084112f, 0.04392345f, 0.11662839f, 
    0.18362708f, 0.06618752f, 0.11483849f, 0.13541926f, 0.14834596f, 0.05641102f, 0.07179742f, 0.16749971f, 
    0.21396026f, -0.07309850f, 0.03827350f, -0.08509228f, 0.05105199f, -0.05879106f, -0.10692811f, -0.12168952f, 
    -0.19706033f, -0.10787334f, -0.18279114f, 0.06434537f, -0.46941301f, 0.18030132f, 0.25758973f, 0.07608353f, 
    -0.05462032f, -0.07307488f, 0.23176526f, 0.10069931f, -0.15217504f, 0.16363305f, 0.14980774f, 0.25104460f, 
    -0.12667710f, 0.06347375f, 0.03056481f, -0.00846184f, 0.00027385f, 0.03788286f, -0.51636368f, 0.08708777f, 
    0.00394457f, -0.17380625f, -0.06174666f, -0.24192624f, -0.14243929f, 0.07908295f, 0.11821654f, 0.04295275f, 
    -0.03147326f, -0.10393936f, 0.06458198f, 0.04813341f, 0.08342564f, 0.06157112f, 0.06396754f, 0.08171359f, 
    -0.07227509f, -0.35899013f, -0.01237199f, 0.07654028f, 0.14767326f, -0.04801668f, 0.02926667f, -0.06580643f, 
    -0.06510094f, -0.06623977f, -0.27263305f, -0.20013797f, -0.10834105f, 0.02553627f, 0.07656101f, 0.04442789f, 
    0.10065939f, 0.12083521f, -0.08039407f, -0.55659586f, -0.51749122f, -0.26046517f, 0.22412388f, 0.03763975f, 
    0.08594456f, 0.09951298f, 0.03420956f, 0.29451737f, 0.07672241f, 0.18172897f, 0.03771064f, 0.00710260f, 
    0.14050084f, 0.13948584f, 0.05724704f, -0.09021858f, 0.07355712f, 0.07191162f, 0.24625444f, 0.08660924f, 
    -0.05156734f, 0.09364168f, 0.16145077f, 0.02308555f, 0.00734814f, 0.39380765f, 0.00905178f, -0.03955378f, 
    0.10821946f, -0.02236842f, 0.23363656f, 0.08079880f, 0.08028070f, 0.19173586f, -1.10212731f, -0.14005139f, 
    0.28281730f, 0.12207336f, -0.17245586f, -0.07267718f, -0.07549583f, 0.18669291f, 0.13950020f, -0.17152400f, 
    -0.29961285f, -0.08094013f, -0.06465196f, -0.05663610f, 0.19857191f, -0.04851839f, 0.10590331f, -0.10656226f, 
    -0.14201126f, -0.19926612f, -0.23607123f, 0.22426774f, 0.14479734f, -0.07030695f, -0.13853996f, 0.06071657f, 
    0.14472069f, 0.05318177f, 0.28302658f, -0.21724890f, -0.05448209f, -0.18523012f, -0.00602700f, 0.24744894f, 
    -0.07664279f, 0.24872945f, -0.36082706f, -0.21780404f, -0.13746281f, -0.07368202f, 0.03512075f, 0.03323144f, 
    0.05185754f, 0.05452665f, 0.13784437f, -0.05609160f, 0.04924727f, -0.01241594f, 0.10095513f, -0.02668508f, 
    0.04873217f, -0.05917829f, 0.04496131f, -0.13639329f, -0.08051241f, -0.30237076f, -0.27134058f, 0.21028303f, 
    -0.02065952f, -0.00035653f, -0.08219787f, 0.01555773f, -0.06842361f, 0.19252667f, 0.01781237f, 0.00076836f, 
    0.07624277f, 0.02571372f, 0.10376246f, -0.09228526f, 0.17903452f, 0.02835225f, -0.39902225f, -0.18297882f, 
    0.02500278f, 0.06680629f, 0.05536796f, 0.09554769f, 0.08161005f, 0.02577681f, 0.28153101f, -0.05521332f, 
    0.10954746f, -0.08840294f, 0.00958538f, 0.02861872f, -0.12627445f, -0.06541531f, -0.13752721f, -0.03710090f, 
    0.05566342f, 0.02822593f, 0.03119356f, -0.01174891f, -0.00691924f, 0.00506332f, -0.16076587f, 0.01439338f, 
    -0.15890746f, 0.11320775f, 0.15698101f, 0.24633600f, 0.02037220f, 0.14545059f, 0.06804138f, -0.08209711f, 
    -0.07323559f, -0.15375601f, 0.20629472f, 0.17691839f, 0.20467925f, -0.00764817f, -0.00092037f, -0.08459584f, 
    -0.02339977f, -0.02544573f, -0.13687699f, 0.18683195f, -0.00601968f, 0.07508302f, -0.14193821f, -0.05159373f, 
    0.22318095f, 0.07637438f, 0.04564493f, -0.17729536f, 0.06018471f, 0.03915777f, -0.01626302f, -0.05995169f, 
    -0.03122994f, 0.00523777f, -0.10980488f, -0.01217932f, -0.26788530f, 0.34930104f, 0.27916694f, 0.39725128f, 
    -0.18432373f, -0.03361338f, 0.15245835f, 0.00759405f, 0.10865671f, 0.13548748f, 0.25924557f, 0.12564094f, 
    0.18268073f, 0.12458641f, 0.08154675f, 0.17618023f, 0.04728070f, -0.05897696f, 0.08409191f, 0.45010394f, 
    0.17542620f, 0.17216590f, -0.03718688f, -0.02785697f, -0.12652816f, -0.15764222f, -0.26652876f, -0.33924738f, 
    0.11116768f, 0.19041698f, 0.06652113f, 0.03095652f, 0.08185351f, 0.05407799f, 0.08204994f, 0.05096946f, 
    0.11266152f, -0.07103193f, 0.00563668f, -0.05344067f, 0.11918830f, 0.03918515f, 0.01343265f, -0.10461060f, 
    -0.20399217f, -0.11161869f, -0.10356047f, -0.15089302f, 0.01294142f, -0.01782372f, -0.00737865f, 0.08960404f, 
    0.14779550f, 0.00955376f, 0.04289967f, 0.17032717f, -0.06315086f, -0.19175331f, 0.04027396f, 0.10704462f, 
    -0.16316082f, 0.13730916f, -0.03271918f, 0.24729702f, 0.48385110f, 0.19026718f, 0.07960021f, 0.22415626f, 
    -0.08934534f, -0.01087551f, -0.00574476f, 0.12033723f, -0.07360129f, 0.02946789f, 0.15047020f, 0.36850840f, 
    0.10814569f, -0.10002719f, 0.17630889f, -0.03982574f, 0.07806112f, -0.00551594f, -0.15802811f, -0.06987714f, 
    -0.21242157f, 0.14838524f, -0.02516973f, 0.05136887f, -0.02947700f, 0.01160659f, -0.00930574f, -0.07956485f, 
    0.02843562f, -0.05540022f, -0.04672245f, -0.02757030f, 0.03020416f, 0.14037830f, -0.05018245f, 0.13272990f, 
    0.18134041f, -0.16844951f, 0.04905858f, 0.15507208f, 0.02772656f, -0.09870629f, 0.13252550f, -0.07428418f, 
    0.23045629f, -0.08837834f, -0.21339680f, -0.15033448f, -0.02493990f, 0.01025088f, 0.20530759f, 0.02796616f, 
    -0.07513610f, -0.15660018f, 0.22687843f, 0.32079783f, -0.08503484f, -0.09261595f, -0.01687094f, 0.02393512f, 
    -0.01002444f, -0.04163585f, -0.01285709f, -0.17054938f, 0.03749026f, 0.29539141f, 0.10521841f, -0.00549550f, 
    0.11971352f, 0.14551856f, -0.23310937f, 0.11207727f, -0.01996034f, -0.07414801f, 0.07496818f, -0.00838782f, 
    0.01102708f, 0.07333326f, 0.16407776f, 0.00090817f, 0.06591601f, -0.14711314f, -0.21058045f, 0.28552541f, 
    -0.02882283f, 0.14717141f, 0.06312155f, 0.04095192f, 0.19335750f, 0.09372233f, 0.45561883f, -0.19604374f, 
    -0.05167922f, 0.16605671f, 0.01823811f, -0.19631113f, 0.04623101f, 0.00252852f, 0.21091296f, -0.09607931f, 
    0.00471967f, -0.16742615f, 0.03120327f, -0.09588954f, 0.00910483f, -0.20388590f, -0.02240849f, 0.17923568f, 
    0.07456824f, 0.12369216f, 0.09088076f, -0.05096281f, -0.19600086f, 0.08622455f, 0.17150599f, 0.13591909f, 
    0.10505125f, 0.23294871f, -0.04294691f, 0.68346965f, 0.17101370f, 0.22651923f, -0.03775858f, 0.14432240f, 
    0.10838939f, 0.28562385f, -0.05758526f, 0.01028069f, 0.04026368f, 0.13811927f, 0.01694436f, 0.16707774f, 
    -0.08004681f, -0.00078885f, -0.01604013f, -0.03178616f, -0.03280716f, -0.02594470f, 0.02142308f, 0.01759527f, 
    -0.25507429f, 0.03828670f, -0.15154512f, -0.18367186f, 0.04844706f, -0.20504484f, -0.09891363f, -0.06766830f, 
    0.09034139f, 0.00338788f, 0.11331415f, -0.03197666f, 0.22993663f, -0.01198441f, -0.21876639f, -0.14198656f, 
    -0.16289389f, 0.08034058f, -0.13142540f, 0.07255597f, -0.09876767f, -0.39346665f, -0.31665194f, 0.18559434f, 
    0.17387179f, 0.19739723f, 0.08012667f, 0.24563380f, 0.00165953f, -0.08257739f, -0.07072725f, 0.19936651f, 
    -0.13703403f, -0.07682808f, -0.17262775f, 0.04294521f, 0.19077370f, 0.14215258f, 0.16056767f, 0.06113286f, 
    -0.01978621f, -0.05228413f, -0.02874262f, -0.08058698f, 0.02467769f, -0.14805926f, -0.10175949f, 0.01475905f, 
    0.11942245f, 0.19734824f, 0.24091049f, 0.25774613f, -0.15393229f, -0.09893151f, -0.02637339f, 0.06160472f, 
    -0.00442485f, 0.02498461f, 0.01108487f, 0.12420659f, 0.22143197f, -0.18565458f, 0.01394976f, -0.03435451f, 
    -0.04488071f, -0.05289394f, 0.27630937f, -0.16603097f, -0.12175449f, 0.26216775f, 0.25768155f, 0.20206955f, 
    0.05643703f, 0.23550877f, 0.07246074f, 0.25523064f, -0.20750318f, -0.16596557f, -0.16671623f, -0.18047227f, 
    0.00318568f, -0.22473821f, -0.08020184f, 0.03399475f, 0.22486115f, 0.09084333f, 0.04481021f, 0.06431907f, 
    0.09316474f, 0.08328671f, 0.09007550f, 0.01602077f, 0.02285374f, -0.08934231f, -0.17895640f, 0.30546016f, 
    0.40144438f, -0.28769472f, -0.07614587f, -0.24281493f, -0.12417445f, -0.08426281f, -0.06910456f, -0.10070887f, 
    -0.09226557f, 0.05997998f, -0.10696262f, -0.02012560f, 0.00667956f, -0.15370196f, 0.03110252f, -0.15621835f, 
    0.19393916f, 0.23923042f, 0.28958961f, -0.05395502f, 0.02449012f, 0.25098485f, 0.06070190f, 0.07322835f, 
    0.16184834f, -0.10203867f, -0.09342132f, -0.19001904f, -0.03660223f, -0.10239334f, -0.24598917f, -0.04430259f, 
    0.09693491f, -0.07263519f, -0.03309162f, 0.14361331f, 0.13216290f, 0.09792311f, -0.04476574f, 0.05007327f, 
    0.07234672f, -0.10501847f, -0.09804429f, -0.25279781f, -0.07647421f, -0.10055618f, 0.02012013f, 0.06765591f, 
    0.07281015f, 0.27053773f, 0.04284118f, -0.26750904f, 0.45067227f, -0.13088748f, 0.60505074f, -0.01820632f, 
    -0.02985170f, -0.15762629f, 0.01219606f, 0.04770138f, 0.13529204f, 0.10949351f, 0.15290253f, 0.11192402f, 
    -0.11701104f, 0.02116341f, -0.24992241f, -0.12952843f, 0.09231246f, 0.10897209f, -0.01482807f, -0.32599184f, 
    -0.15033488f, -0.20347013f, -0.02285912f, 0.16902395f, -0.03644674f, 0.05476706f, -0.03606722f, 0.04534483f, 
    0.32351297f, 0.09918087f, 0.14481859f, 0.09820884f, 0.27993536f, 0.32391658f, 0.18189828f, -0.02868422f, 
    -0.13772257f, 0.10090284f, -0.24401949f, -0.06705316f, 0.07437768f, -0.06135867f, -0.14668760f, -0.00826731f, 
    -0.03000542f, -0.00840560f, -0.12604536f, 0.13799302f, 0.03099411f, 0.16160342f, 0.17450385f, 0.20190428f, 
    0.10872555f, -0.02463037f, 0.11506526f, 0.14521909f, 0.06234168f, -0.07367343f, -0.02551026f, 0.11670344f, 
    -0.07682970f, 0.13019918f, 0.32019433f, 0.06834535f, 0.19210243f, 0.12392261f, 0.01760011f, 0.10651891f, 
    0.04820498f, 0.11551069f, 0.04925441f, 0.04717536f, 0.09335135f, 0.12672128f, 0.12801282f, 0.05524182f, 
    -0.04777039f, 0.04040437f, 0.12431263f, -0.07087289f, -0.09836286f, 0.28846356f, 0.36706805f, 0.06783571f, 
    0.22249943f, -0.13997179f, 0.29816300f, 0.22744432f, -0.06667917f, 0.10137050f, -0.02337224f, 0.04661773f, 
    0.27869648f, 0.03487129f, 0.01121541f, 0.24956521f, 0.24831145f, 0.15445650f, 0.08055092f, 0.12716378f, 
    0.02088407f, -0.10591414f, 0.01245839f, 0.01114478f, 0.12342927f, 0.03374010f, -0.08049714f, -0.00116981f, 
    -0.19465676f, 0.21455090f, -0.08774323f, 0.00797719f, 0.25871500f, 0.02886288f, 0.08421084f, 0.01166560f, 
    -0.26468536f, -0.11852057f, 0.52153474f, 0.12674069f, 0.10713100f, -0.08065689f, -0.03323680f, -0.19190559f, 
    0.18330857f, 0.05547526f, 0.03684084f, -0.00099809f, 0.01574305f, 0.11573331f, 0.00205880f, -0.11307603f, 
    -0.21857585f, -0.05818692f, -0.13894346f, 0.06800274f, 0.11117398f, 0.08148676f, 0.06208004f, -0.02704337f, 
    0.05549861f, -0.03068225f, 0.13803294f, 0.11136466f, -0.16418770f, 0.12289783f, 0.24700624f, 0.12357209f, 
    0.06714313f, 0.09807859f, 0.06664246f, -0.02595587f, 0.13226084f, 0.05129965f, 0.04553810f, -0.03083077f, 
    0.06349289f, 0.01072269f, 0.07878621f, 0.02166284f, 0.06986561f, -0.07885417f, -0.14738326f, 0.00439733f, 
    0.00188254f, -0.05128293f, 0.03194176f, -0.13976510f, -0.01470504f, -0.01464896f, -0.06675911f, -0.12044387f, 
    0.08314642f, 0.06117382f, 0.18983418f, -0.06246594f, 0.09007204f, -0.06040140f, 0.20674957f, -0.01764523f, 
    0.09030155f, 0.07880475f, 0.01817048f, -0.07783458f, -0.11238197f, -0.06824745f, 0.16093493f, 0.09348506f, 
    0.10840395f, 0.08786446f, 0.04327736f, 0.21148939f, -0.13772409f, -0.13041362f, -0.00327359f, 0.10403144f, 
    0.05717500f, 0.08894477f, 0.03373112f, 0.12828197f, 0.27118370f, -0.00056879f, 0.09204854f, 0.09750954f, 
    0.04051042f, 0.07573835f, 0.05927697f, -0.31451556f, 0.27991673f, -0.03899086f, 0.02283803f, 0.07172666f, 
    0.02213055f, -0.13788962f, 0.14855008f, 0.24750665f, 0.04944069f, 0.05826265f, 0.19648947f, -0.10897856f, 
    -0.23038132f, -0.02005848f, 0.10959788f, 0.05737781f, 0.15521103f, -0.25995147f, -0.03512584f, -0.25571898f, 
    0.10446534f, 0.17915638f, 0.01178374f, -0.00447272f, 0.05303283f, -0.22334601f, -0.07664100f, 0.19664587f, 
    0.42487064f, -0.20232062f, -0.08945201f, 0.15157774f, 0.02140756f, 0.15543261f, 0.05493717f, 0.00754535f, 
    -0.02448867f, -0.06021455f, -0.01828461f, -0.01592891f, 0.07965088f, 0.08741079f, 0.12826487f, 0.18097346f, 
    0.07726809f, -0.03679744f, 0.02582390f, -0.01233902f, -0.11151670f, 0.08782092f, -0.08227757f, 0.07932928f, 
    0.00316112f, -0.04583658f, 0.12199526f, 0.10564274f, 0.03839274f, 0.03047423f, 0.01637888f, -0.02008613f, 
    0.02388728f, 0.07345864f, 0.01735036f, 0.04175590f, -0.00267248f, 0.01641115f, -0.04666360f, -0.21989746f, 
    -0.07771623f, -0.17554697f, -0.13408354f, -0.08304419f, 0.11542773f, -0.04395271f, -0.00763077f, -0.06973371f, 
    0.04356091f, -0.05306238f, 0.09324093f, -0.20769651f, 0.04145272f, 0.14465526f, 0.28411430f, 0.20500569f, 
    -0.00811911f, 0.01314318f, 0.11453059f, 0.09017079f, 0.16355030f, 0.00648805f, -0.15183562f, 0.12644617f, 
    0.07022999f, 0.03554125f, 0.04477834f, 0.03231229f, 0.12812223f, 0.06206249f, -0.19692773f, 0.14518671f, 
    0.03936351f, 0.19432744f, 0.14322999f, 0.10315315f, -0.19547144f, -0.06562395f, 0.00666545f, -0.14115700f, 
    -0.03705822f, 0.03755156f, -0.11230241f, -0.06586348f, 0.00337190f, -0.22136842f, -0.08259888f, -0.23119961f, 
    -0.35977766f, -0.06161385f, -0.05286735f, -0.04888467f, -0.02962107f, 0.07355093f, -0.18892603f, -0.04123460f, 
    -0.11243994f, -0.04960404f, 0.11940402f, -0.05742451f, 0.19233735f, 0.19365385f, -0.06148547f, -0.15786372f, 
    -0.02833134f, 0.05363894f, 0.06006305f, 0.10458716f, 0.21119069f, 0.11417469f, 0.05054752f, 0.05123213f, 
    -0.11456422f, 0.09802297f, -0.06134761f, -0.13498306f, -0.29835334f, -0.02740981f, 0.05675898f, 0.08235192f, 
    -0.06590502f, 0.03105956f, -0.07398266f, -0.02620743f, 0.11262633f, 0.12778662f, -0.13039206f, 0.07849721f, 
    -0.12833434f, -0.16751833f, -0.10803696f, -0.18587355f, -0.26896954f, 0.14268677f, 0.00967050f, 0.19581077f, 
    0.03504613f, 0.03861013f, 0.00744915f, 0.03992397f, 0.13553603f, -0.13109024f, 0.07154422f, 0.29456976f, 
    -0.08500136f, 0.11301390f, -0.00545062f, -0.02685877f, 0.04182217f, 0.06847844f, 0.07107077f, 0.13312198f, 
    0.19226229f, 0.03243892f, 0.04293587f, 0.12669183f, -0.14256465f, -0.19788946f, 0.05397322f, 0.08210398f, 
    -0.07242048f, -0.12361421f, -0.19613791f, 0.00744944f, 0.15997812f, -0.08855183f, 0.01893498f, 0.06808577f, 
    0.08446127f, 0.48673543f, 0.37747979f, -0.68150485f, -0.28185120f, 0.22167782f, 0.16606055f, 0.04744804f, 
    0.23029485f, -0.09745449f, -0.31046450f, 0.06086351f, 0.13161735f, -0.08843233f, 0.07931200f, -0.07043744f, 
    0.11626061f, 0.05064953f, 0.02015257f, -0.11041889f, -0.23592654f, -0.13166946f, -0.12169236f, 0.02461450f, 
    0.07975011f, 0.04106052f, 0.02900177f, 0.14676172f, -0.13536111f, -0.33664173f, 0.00633388f, 0.10527793f, 
    -0.12804127f, 0.06241231f, -0.00804005f, 0.01677266f, 0.00015867f, 0.05090491f, 0.05362973f, -0.00533163f, 
    -0.25960821f, -0.01988801f, -0.13526963f, 0.23121925f, 0.12356545f, 0.08742985f, -0.02190645f, 0.49312550f, 
    0.30093518f, -0.04354826f, 0.04973182f, -0.03450330f, 0.04315561f, 0.00739479f, 0.10068070f, 0.02459939f, 
    0.17097427f, 0.04092710f, -0.21106002f, 0.04017278f, -0.00486886f, -0.02221104f, 0.23258720f, 0.07420156f, 
    0.09040429f, -0.14808705f, -0.07990111f, -0.14463827f, -0.14390500f, 0.12384370f, 0.01203092f, 0.04448411f, 
    0.00087527f, -0.02826995f, -0.04837885f, 0.08228387f, -0.10591017f, 0.01326034f, -0.16370298f, 0.00861188f, 
    0.05987351f, -0.07385923f, -0.32617339f, -0.05947259f, 0.03493315f, 0.11356673f, -0.03528301f, -0.19081157f, 
    -0.07646499f, -0.00706280f, -0.05550797f, -0.14730068f, 0.12495240f, 0.04908053f, -0.14068270f, -0.04942718f, 
    0.08317450f, 0.12353811f, -0.00593858f, 0.11870987f, 0.02167521f, -0.05374323f, -0.05175966f, -0.11221096f, 
    0.08199155f, 0.02354280f, 0.06738566f, -0.01834329f, 0.03050789f, 0.07450792f, 0.24616972f, 0.01657314f, 
    0.02923818f, 0.10674445f, -0.09731106f, 0.13604955f, 0.06205449f, 0.00701747f, -0.18050468f, 0.27979013f, 
    0.02580993f, -0.11682153f, -0.01577292f, -0.24384992f, -0.03085235f, 0.06474039f, 0.07463121f, -0.38783282f, 
    -0.39788693f, 0.15223625f, -0.06654535f, 0.05135605f, -0.35687047f, 0.02122539f, 0.05476454f, -0.11914235f, 
    0.20186210f, 0.10710159f, -0.05006776f, 0.05187706f, 0.08208340f, 0.17881800f, 0.16166624f, 0.05298552f, 
    0.05068420f, -0.07908307f, -0.01673695f, 0.06910777f, -0.03826508f, -0.04612833f, 0.12082589f, 0.00538384f, 
    0.09245382f, 0.15316823f, -0.26191375f, 0.05300939f, 0.03773326f, -0.00921848f, 0.03627452f, 0.07379494f, 
    0.16045058f, 0.01163105f, -0.02982427f, 0.11625667f, 0.07551547f, -0.04127181f, -0.35572886f, -0.09781394f, 
    0.05750915f, 0.19343676f, 0.03443526f, 0.04366028f, -0.17720345f, -0.05254280f, -0.15498367f, -0.21440475f, 
    0.02595766f, -0.04335894f, 0.20440130f, 0.06635046f, -0.05412899f, -0.31800255f, 0.00010703f, 0.10670868f, 
    -0.06403910f, -0.19786888f, -0.07801393f, 0.05562206f, 0.02873692f, 0.03457914f, -0.08402748f, 0.05674536f, 
    -0.59908980f, 0.09987622f, -0.15369675f, -0.27949718f, -0.01114034f, -0.07880275f, -0.06460481f, 0.26617715f, 
    0.29462034f, -0.09171483f, 0.17311442f, 0.03815113f, 0.22387181f, 0.19583218f, 0.04712690f, 0.13284563f, 
    -0.10028489f, 0.13644500f, -0.18735853f, -0.02756912f, -0.30396059f, -0.03354692f, -0.08672796f, -0.06365396f, 
    -0.06947992f, -0.04861094f, -0.31370330f, -0.16965325f, -0.05523492f, 0.03616384f, -0.09225681f, 0.08427311f, 
    0.07348536f, 0.14650322f, 0.54169267f, 0.11469920f, -0.44186032f, -0.09016769f, 0.24856037f, 0.00766539f, 
    0.12396176f, 0.13427973f, 0.00653789f, -0.28662899f, 0.17246877f, 0.12924476f, 0.03337647f, -0.09345077f, 
    0.01466089f, -0.04724192f, -0.01483214f, -0.06433751f, -0.34992713f, -0.14393966f, -0.05700943f, -0.00195389f, 
    0.09523262f, 0.13449559f, 0.11987498f, -0.04207098f, -0.08179390f, -0.60877013f, 0.15570118f, 0.35487685f, 
    -0.02850070f, 0.11637557f, 0.04840366f, 0.20734823f, 0.16339454f, -0.00362217f, -0.11391556f, -0.05737728f, 
    -0.28993797f, 0.06101157f, -0.05017616f, 0.07325850f, -0.18477365f, -0.03463383f, -0.01943347f, -0.38278049f, 
    0.01245194f, 0.01430735f, 0.03097603f, -0.06358176f, -0.06146007f, -0.08531283f, 0.06229855f, 0.14067820f, 
    0.28675935f, 0.23326190f, 0.09397624f, -0.07635998f, 0.00873062f, -0.04532072f, -0.13887256f, 0.13852848f, 
    0.05133510f, -0.51422989f, -0.14800775f, -0.12972511f, -0.03572999f, 0.01149723f, 0.31920749f, -0.01327411f, 
    -0.17084053f, 0.06360696f, -0.16486266f, -0.17270184f, -0.31501594f, -0.10820813f, -0.01158819f, 0.10474584f, 
    -0.19626392f, -0.23345594f, 0.00309412f, 0.12958887f, 0.11522055f, -0.09587424f, 0.01750445f, -0.11224759f, 
    -0.02125232f, -0.06748822f, 0.07655372f, -0.02718835f, 0.45773396f, 0.20498237f, 0.13410471f, 0.00316862f, 
    -0.07763957f, 0.01915912f, 0.11745379f, -0.01265879f, 0.01318971f, 0.07104103f, 0.23019111f, 0.01185431f, 
    -0.18244863f, -0.14051056f, -0.03351517f, -0.09179359f, -0.07101324f, -0.15826678f, -0.16750078f, -0.14777045f, 
    -0.21477173f, -0.06951240f, 0.00989618f, 0.01319099f, -0.06412531f, -0.11818840f, -0.02970221f, 0.18633468f, 
    0.10503945f, 0.12694037f, -0.09247569f, 0.02003560f, -0.09669247f, 0.07812635f, 0.17843099f, 0.04072841f, 
    -0.17358288f, -0.01407674f, -0.14286403f, 0.23119943f, -0.02861116f, 0.06134815f, -0.00787169f, -0.10408938f, 
    0.04890544f, -0.02395698f, 0.02856679f, -0.65180796f, 0.12204564f, 0.01634321f, 0.04638292f, 0.02279643f, 
    -0.00451599f, 0.05192707f, -0.25953859f, 0.07040572f, -0.21497004f, 0.08078929f, 0.14984350f, 0.03911285f, 
    0.04432840f, 0.04590466f, -0.09789088f, -0.27137539f, -0.02584303f, 0.25629053f, -0.02770542f, 0.05975228f, 
    0.16501917f, 0.23819150f, 0.01189897f, -0.23294131f, -0.16971709f, -0.00833873f, -0.08844041f, 0.11888988f, 
    0.04075808f, -0.03948006f, 0.08199679f, 0.11799601f, 0.18397948f, -0.01771890f, 0.01507765f, -0.04489997f, 
    -0.06945900f, -0.02812342f, -0.03321483f, 0.00458845f, -0.05058316f, -0.04787989f, -0.16690689f, 0.36896217f, 
    0.05597153f, -0.25494280f, 0.00701110f, -0.13273463f, 0.00141037f, 0.08402392f, -0.11419287f, -0.10781284f, 
    -0.28365296f, 0.07911720f, 0.25373694f, 0.08896029f, -0.04762217f, 0.08370302f, -0.12947573f, 0.15016191f, 
    -0.03877419f, 0.02945512f, 0.06224361f, 0.07807975f, -0.02808259f, 0.00743683f, 0.12933157f, 0.23067790f, 
    -0.07185716f, 0.32890981f, 0.19410595f, 0.01984613f, -0.15605423f, -0.21298015f, 0.02496216f, 0.01688096f, 
    0.17206140f, 0.13659930f, -0.10045342f, -0.05267434f, -0.52579510f, -0.21550621f, -0.16815223f, -0.03619773f, 
    -0.01767345f, -0.04998096f, 0.00895780f, -0.01587903f, 0.08513712f, 0.15453985f, -0.17355455f, 0.03906526f, 
    -0.01990260f, -0.03488286f, -0.13752617f, -0.05768103f, 0.00431900f, -0.09998171f, -0.51476139f, 0.05178412f, 
    0.06632610f, 0.03540071f, 0.12138148f, -0.03674082f, 0.03737232f, -0.09592724f, 0.00841989f, -0.18332550f, 
    -0.09608644f, 0.13900492f, -0.09337938f, 0.05257664f, 0.02248940f, -0.05679096f, 0.11352964f, 0.04832827f, 
    0.38178158f, -0.28569594f, -0.05946932f, -0.41635710f, 0.00362215f, 0.18800342f, -0.06160002f, 0.04696817f, 
    0.09975478f, 0.36152017f, -0.04166549f, 0.22738083f, -0.05379888f, 0.11018378f, 0.17320652f, 0.20366259f, 
    0.15553810f, 0.03868417f, 0.12813306f, -0.02787713f, 0.07220460f, -0.10753939f, -0.01465103f, -0.09014923f, 
    0.27561346f, 0.06352491f, 0.12758484f, 0.12939714f, 0.04454514f, 0.09290753f, 0.09025789f, 0.03357601f, 
    0.09601939f, 0.14610086f, -0.11981811f, -0.06035037f, 0.29062042f, 0.13452581f, -0.16676599f, 0.13851407f, 
    0.12905386f, -0.08050891f, 0.08725730f, 0.12933420f, -0.02325938f, -0.38000253f, 0.00362615f, -0.18190669f, 
    0.18362065f, -0.00441340f, -0.00000057f, 0.08006600f, -0.24199118f, 0.10819822f, -0.20820743f, -0.10647893f, 
    -0.01257462f, 0.08528016f, -0.09510016f, -0.00296689f, 0.18457113f, -0.02865157f, -0.27932006f, 0.08385576f, 
    0.01792102f, 0.02561603f, -0.01692481f, -0.01464502f, -0.00112576f, 0.03422825f, -0.36878332f, 0.13647498f, 
    0.33524290f, 0.01498211f, -0.08303643f, -0.04011123f, -0.21722569f, -0.11192311f, -0.10903985f, 0.05895534f, 
    0.02639525f, 0.26621410f, 0.01181340f, -0.15615371f, -0.04618027f, 0.22278251f, -0.12778929f, 0.08212943f, 
    0.07306444f, 0.01503453f, -0.26298502f, -0.20859583f, 0.06131284f, 0.20036364f, -0.06003112f, -0.01323993f, 
    0.13275243f, 0.19886343f, -0.41131788f, -0.10256829f, 0.33462617f, -0.12368893f, 0.25273293f, 0.20650803f, 
    -0.16440199f, -0.00885560f, -0.41922662f, -0.07652009f, 0.08669665f, 0.01656049f, 0.07395288f, -0.01546315f, 
    -0.02576063f, -0.07204024f, 0.08286890f, 0.16317797f, 0.06398506f, -0.29580277f, -0.13215850f, -0.08644003f, 
    0.11060222f, -0.00099240f, 0.06628288f, 0.01103474f, 0.52147597f, -0.09440410f, -0.35122666f, -0.00222668f, 
    0.16931520f, 0.14841817f, 0.00641875f, -0.00892506f, -0.15717323f, 0.29490513f, 0.09896325f, -0.15810883f, 
    -0.06970304f, -0.13581437f, 0.06954528f, 0.02080868f, 0.00908661f, -0.05979287f, -0.33355770f, -0.02896746f, 
    0.41153654f, 0.04907245f, 0.07810007f, 0.07625694f, -0.12804164f, -0.13418494f, -0.04536095f, 0.22941124f, 
    -0.02321385f, 0.18339419f, -0.10885189f, -0.00388003f, -0.06489325f, 0.10866636f, 0.08007011f, 0.09007920f, 
    0.05670163f, -0.02831934f, -0.09865497f, -0.03091656f, -0.02154941f, 0.14147078f, 0.06878325f, -0.07073482f, 
    0.02085738f, -0.17932120f, 0.08280285f, -0.26285756f, 0.21340837f, 0.09742537f, -0.24635018f, -0.07129113f, 
    -0.08214332f, -0.03605621f, -0.46789438f, -0.63805848f, -0.42284968f, 0.05862060f, -0.06473567f, -0.00188378f, 
    -0.02920404f, -0.16048408f, -0.25855085f, -0.36931404f, 0.29913196f, 0.30628866f, 0.00458062f, -0.03878995f, 
    -0.08502107f, 0.14004317f, -0.15556742f, 0.06299025f, -0.10313650f, 0.09792442f, -0.02641529f, 0.02740261f, 
    -0.02090851f, -0.20775479f, 0.07081144f, -0.08621366f, 0.14594464f, -0.00503479f, 0.14203633f, -0.12055541f, 
    -0.03552633f, -0.00443946f, 0.04003574f, 0.09690356f, -0.02774587f, 0.14754032f, -0.37292647f, -0.26590937f, 
    -0.14231119f, -0.26916987f, 0.12715913f, -0.07940768f, -0.17168055f, -0.01567286f, -0.02557510f, -0.47834334f, 
    -0.53705531f, -0.46364218f, -0.07965806f, 0.16899088f, -0.33930776f, -0.12995534f, -0.20022342f, -0.11428249f, 
    0.12679128f, 0.10044173f, -0.21644112f, -0.01671652f, 0.03125295f, 0.14733516f, 0.13649523f, 0.12901805f, 
    0.16583049f, 0.26453024f, 0.07231506f, -0.04720967f, -0.08069658f, -0.00632632f, 0.10432032f, -0.13150996f, 
    -0.02512496f, 0.06938820f, -0.12956128f, -0.06347414f, -0.09289535f, 0.10538433f, 0.03133978f, -0.07401160f, 
    0.03241082f, 0.13023616f, 0.06665601f, 0.19039661f, 0.16348894f, -0.06878773f, -0.03130540f, -0.07034398f, 
    -0.03294317f, 0.06999844f, 0.04910009f, 0.20325127f, 0.13274531f, -0.37172872f, -0.58706427f, 0.03529606f, 
    -0.19841042f, 0.18374106f, 0.24845707f, -0.09282516f, 0.09057082f, -0.39903188f, -0.32642552f, -0.23641559f, 
    -0.10124939f, 0.03313394f, -0.05448848f, 0.11179449f, -0.01141028f, -0.06566578f, 0.09141950f, -0.22602536f, 
    -0.19574673f, 0.00835699f, 0.05707977f, -0.09881164f, -0.06826139f, 0.06362282f, -0.05750347f, 0.01687275f, 
    0.23648642f, 0.24537463f, 0.24061343f, 0.08868836f, 0.03887669f, 0.04679067f, 0.11331893f, 0.22062622f, 
    -0.23930374f, 0.11179484f, -0.01610537f, 0.02258128f, 0.05759015f, -0.10859404f, 0.04030915f, 0.08763345f, 
    0.36183348f, 0.14051618f, -0.10649192f, -0.06868368f, 0.05032449f, 0.13514414f, 0.08788204f, 0.19014391f, 
    0.03112523f, 0.01691812f, 0.38764802f, -0.00762198f, 0.12519038f, 0.13973522f, -0.00390911f, 0.00423037f, 
    -0.02186643f, -0.05894879f, 0.06584772f, -0.03146083f, -0.03029731f, -0.02563922f, -0.17044438f, -0.01576947f, 
    0.10411754f, -0.06629340f, 0.01426133f, -0.00100293f, 0.13251352f, -0.03329157f, -0.16533898f, 0.07438029f, 
    0.04570235f, 0.01985913f, 0.03400138f, 0.00042680f, 0.12413625f, -0.05527445f, -0.18502587f, 0.44132233f, 
    0.08463646f, 0.10243496f, -0.12458742f, 0.01037847f, 0.06137031f, 0.09807540f, 0.26857877f, -0.08932781f, 
    -0.20456962f, -0.16466527f, 0.13485496f, 0.13470735f, -0.28681600f, -0.03122392f, -0.11110607f, 0.26628825f, 
    -0.22611533f, 0.11874694f, -0.01625306f, 0.05706285f, -0.14821649f, -0.01888913f, -0.06137753f, -0.05523881f, 
    -0.08576951f, -0.18878309f, 0.05295787f, 0.24240445f, -0.30516735f, 0.33957782f, 0.00081850f, -0.22545515f, 
    0.18057594f, 0.72040910f, -0.22482687f, 0.21606258f, -0.26676139f, -0.09102438f, 0.43275046f, 0.04313928f, 
    -0.11380311f, 0.16021343f, -0.27276051f, -0.12553582f, 0.02749893f, 0.16136524f, 0.04283530f, -0.13958916f, 
    0.07577331f, 0.09690972f, 0.06027411f, -0.30757418f, -0.19254905f, -0.00426835f, -0.26657209f, -0.08320017f, 
    -0.00771853f, 0.03655185f, -0.03288876f, -0.02733216f, -0.17909952f, -0.25719026f, -0.02732901f, -0.03823981f, 
    -0.19486885f, -0.01797739f, -0.20246857f, -0.03019316f, -0.10936642f, 0.03965631f, -0.43224058f, -0.12609623f, 
    0.02800777f, 0.03222577f, 0.01471277f, 0.05826264f, 0.18536781f, 0.15766935f, 0.15987696f, 0.06031161f, 
    0.13867599f, 0.04735316f, -0.00079291f, -0.15027948f, 0.06794241f, 0.08332647f, 0.10729905f, -0.15774292f, 
    -0.45882699f, 0.07026625f, -0.06518442f, -0.05660968f, -0.20863725f, 0.11279098f, 0.04538519f, 0.00609699f, 
    0.15000653f, -0.11372634f, 0.25961179f, -0.25499707f, 0.07166488f, -0.27333888f, 0.08583830f, 0.05281319f, 
    -0.04202265f, -0.03247014f, 0.04017060f, 0.14389667f, -0.08846330f, -0.01521279f, 0.05244285f, -0.04160170f, 
    -0.13533518f, 0.02346325f, -0.00557199f, -0.02798397f, 0.57102954f, 0.10186905f, 0.07421755f, 0.27016529f, 
    -0.04550733f, -0.16781136f, -0.07271745f, -0.03380126f, -0.40128553f, 0.38084301f, -0.07650182f, -0.32234719f, 
    -0.08980957f, -0.01766400f, 0.01703284f, 0.06912996f, -0.14653230f, -0.00829015f, 0.06863555f, -0.09879658f, 
    -0.12937360f, -0.27648914f, 0.12812278f, -0.14064094f, 0.11553189f, 0.12034827f, -0.01857302f, 0.02573214f, 
    0.00577531f, -0.10788253f, 0.07112315f, 0.02699584f, 0.12839313f, 0.04861617f, 0.17520177f, -0.01548613f, 
    0.35137597f, -0.15578923f, 0.04870464f, 0.16505492f, 0.01067199f, -0.04319333f, 0.00342306f, -0.14909141f, 
    -0.00492149f, 0.20942686f, -0.11144556f, -0.06188549f, -0.04455758f, 0.00166676f, -0.07608064f, 0.02434027f, 
    0.12022680f, 0.01341511f, 0.06550798f, 0.06835093f, 0.05519978f, 0.07213361f, -0.05152867f, 0.03578269f, 
    0.04277329f, -0.36191571f, -0.18449993f, 0.07157419f, -0.04670333f, -0.00711772f, 0.08582416f, -0.08625384f, 
    0.19501919f, -0.00527742f, -0.23530294f, 0.04168369f, 0.07580819f, 0.05056730f, 0.09295148f, -0.08356413f, 
    0.06631382f, 0.05048503f, -0.02973995f, -0.02686459f, -0.19602478f, -0.03395398f, -0.15184678f, -0.10851303f, 
    -0.13612394f, 0.12147356f, 0.02794105f, 0.10081241f, -0.22453253f, 0.03485322f, -0.10307737f, -0.20650108f, 
    0.03986534f, 0.16493332f, 0.02770494f, -0.06518286f, 0.04013594f, -0.17510691f, -0.00414455f, 0.18250968f, 
    -0.04112859f, -0.09204961f, 0.02782108f, -0.12117715f, 0.05524885f, -0.08065586f, -0.03424890f, -0.28208771f, 
    0.05296590f, 0.03048717f, -0.00118754f, 0.27412939f, -0.06241092f, 0.09172920f, -0.12734595f, 0.09331419f, 
    -0.06471322f, 0.06859257f, -0.04448329f, 0.13884372f, 0.03161884f, -0.11486714f, -0.01058674f, -0.02807544f, 
    0.04612169f, -0.22727239f, 0.14782755f, -0.11717122f, -0.07433838f, -0.01584030f, -0.09645078f, -0.07951445f, 
    -0.07531849f, 0.16094944f, -0.47871423f, -0.08613600f, -0.01004804f, 0.01493291f, -0.06143866f, 0.11360236f, 
    0.04486385f, 0.00310137f, 0.29574466f, -0.23212828f, 0.12040964f, 0.16555656f, -0.01203856f, 0.13248403f, 
    -0.09105897f, -0.08616297f, 0.25570738f, -0.19894074f, -0.03764334f, -0.08833397f, -0.01496582f, 0.08631085f, 
    -0.14588013f, -0.02435195f, -0.04439434f, -0.05967735f, -0.31530496f, -0.11571840f, 0.05484420f, 0.04013194f, 
    0.11449558f, -0.07128598f, 0.15528715f, -0.13227820f, -0.12391806f, -0.19426772f, 0.04705656f, 0.58345670f, 
    0.12513869f, 0.04820301f, -0.05519455f, 0.13513114f, 0.24954557f, 0.03376309f, -0.20424815f, -0.46843457f, 
    0.24422887f, -0.15258366f, -0.29172656f, -0.15239649f, 0.04511198f, -0.21066126f, -0.01675968f, 0.08669902f, 
    -0.48306558f, 0.56149399f, 0.06006887f, -0.12520364f, -0.06072005f, -0.08295823f, -0.00070639f, 0.11399744f, 
    -0.01823912f, 0.03173189f, -0.04262567f, -0.03124434f, 0.00064999f, 0.04412780f, -0.04143663f, 0.03131200f, 
    -0.06283484f, 0.03754462f, -0.01117231f, -0.01445387f, -0.06257346f, -0.04361590f, -0.03979815f, 0.02116839f, 
    0.01855674f, -0.06471138f, 0.02760820f, 0.03797999f, -0.03969292f, -0.03724850f, -0.05635373f, 0.03226506f, 
    -0.02002231f, -0.03496154f, -0.03182695f, -0.03140828f, 0.03676143f, -0.04315855f, -0.01815183f, -0.01755622f, 
    -0.04006641f, -0.01495716f, 0.05881000f, -0.06260239f, -0.01046841f, -0.00684482f, 0.02046137f, 0.03885069f, 
    0.04271866f, -0.06204575f, -0.04771713f, -0.01490592f, -0.02461963f, 0.00535073f, 0.00417732f, 0.03387605f, 
    0.00818699f, -0.00139729f, 0.02508152f, -0.03585137f, -0.02774470f, -0.03592932f, -0.03468448f, 0.00203261f, 
    0.04170015f, -0.01441994f, -0.06191389f, -0.03693782f, 0.03018502f, 0.02213759f, -0.03586705f, -0.00826825f, 
    -0.04353797f, -0.03726224f, -0.03131934f, 0.03065501f, 0.00243229f, 0.03522305f, -0.05335395f, -0.01404410f, 
    0.00337994f, 0.02376349f, 0.02765138f, 0.00755253f, -0.05811030f, 0.04058728f, 0.04129848f, 0.05898541f, 
    0.04112239f, -0.01391454f, 0.00401921f, 0.00590623f, -0.01633739f, 0.04397758f, -0.01486703f, -0.02196714f, 
    0.02199904f, 0.03961222f, -0.03349060f, 0.04334806f, -0.01902394f, -0.02760872f, -0.04284981f, -0.03373522f, 
    -0.00115173f, -0.06649020f, 0.03262478f, -0.06790334f, -0.04940216f, 0.02619465f, -0.05755926f, -0.03523427f, 
    -0.00846653f, -0.02203606f, -0.05515771f, -0.04542489f, 0.01752093f, -0.05566824f, 0.00069092f, 0.01054850f, 
    0.03101527f, -0.05278201f, -0.01258432f, -0.04036647f, 0.01259882f, -0.01789132f, 0.00670616f, 0.01044250f, 
    -0.03617105f, -0.06374068f, 0.02909822f, 0.03785781f, 0.01244527f, 0.04456959f, -0.03628064f, -0.02412060f, 
    -0.02876635f, -0.02971582f, 0.01923112f, 0.04422073f, 0.01218942f, 0.04523473f, -0.00125380f, -0.03652782f, 
    0.01689586f, 0.02730261f, 0.04641526f, 0.03097337f, -0.02625113f, 0.03791278f, 0.00192433f, 0.01088631f, 
    -0.02124545f, 0.04005126f, -0.06406692f, -0.00999701f, 0.03011438f, -0.05761722f, 0.02947651f, -0.05546884f, 
    0.04169502f, -0.02887206f, -0.05446812f, -0.05270644f, -0.01715300f, 0.05627884f, 0.03560334f, -0.04522191f, 
    -0.00571920f, 0.00727453f, -0.02482677f, 0.02710745f, 0.01592621f, -0.04769637f, -0.05272147f, -0.06460633f, 
    -0.05886879f, -0.05131611f, 0.01885044f, 0.02777464f, 0.02055556f, -0.04919206f, 0.04316049f, -0.05373074f, 
    -0.00258912f, 0.01574695f, -0.03539270f, 0.04994370f, -0.02828694f, 0.03788656f, -0.03830910f, -0.00988601f, 
    0.00730408f, 0.02879060f, 0.03581467f, 0.01426249f, 0.04605044f, -0.02834439f, -0.06619712f, -0.06899466f, 
    -0.03871878f, 0.03064215f, 0.03463729f, 0.02260743f, -0.01134045f, -0.03462869f, -0.05145346f, 0.04594544f, 
    0.04922131f, -0.05181954f, -0.02511142f, -0.04569359f, 0.01475573f, -0.01194801f, -0.04759564f, -0.05255268f, 
    0.00157208f, 0.03779115f, -0.04875286f, -0.01265234f, -0.00088594f, 0.02603096f, 0.04704928f, 0.00442081f, 
    -0.02974315f, 0.00601847f, -0.01228708f, -0.01802075f, -0.06275724f, -0.00299736f, -0.02812726f, 0.05032672f, 
    -0.00034820f, 0.00836347f, -0.02230188f, -0.01090724f, 0.02579240f, -0.00475506f, -0.05547014f, 0.01667740f, 
    0.00100756f, -0.04728147f, 0.00607427f, 0.03407802f, -0.00006754f, -0.01907473f, 0.01215014f, -0.04914846f, 
    -0.01779817f, -0.05765112f, 0.00118094f, 0.02579269f, -0.03248559f, 0.00242435f, -0.03308788f, -0.02750260f, 
    -0.03542516f, 0.02778593f, 0.00916292f, 0.01022164f, 0.02011080f, 0.04211270f, -0.01567983f, -0.03234147f, 
    0.04198387f, -0.02365706f, -0.05095282f, 0.02986756f, -0.02688726f, 0.02541224f, -0.06611436f, -0.05702240f, 
    -0.01853191f, -0.00797045f, 0.01376171f, 0.01468723f, -0.03381902f, 0.00643895f, 0.00495247f, 0.00323172f, 
    0.05106805f, -0.04899014f, 0.01463262f, -0.01008041f, 0.04657597f, 0.05811048f, -0.02612708f, -0.03984105f, 
    0.03301470f, -0.06119816f, 0.00187041f, -0.00758863f, 0.03623429f, 0.04732379f, -0.02956488f, 0.02305261f, 
    0.00077816f, -0.04711660f, -0.05373319f, 0.02387118f, 0.00254686f, 0.00772020f, 0.04156000f, -0.02228596f, 
    -0.00006334f, -0.05407453f, -0.06148136f, 0.02455524f, 0.00793233f, -0.03120963f, 0.00676997f, -0.03520905f, 
    0.01699974f, 0.04333902f, -0.06045015f, 0.01288138f, -0.03243024f, 0.04348670f, -0.04731112f, -0.01906493f, 
    -0.00970236f, -0.01795420f, -0.06201237f, -0.01140070f, -0.04218306f, -0.04693690f, 0.01839874f, 0.02957556f, 
    -0.04905947f, 0.03667805f, -0.04514585f, -0.05873043f, 0.00887292f, -0.02965346f, 0.01396568f, -0.01815149f, 
    0.01891898f, -0.00324472f, 0.02446822f, -0.05915799f, 0.01392490f, -0.05949235f, 0.00827858f, 0.02881622f, 
    -0.02174054f, -0.04574842f, 0.01359946f, 0.03861337f, -0.03353796f, -0.02024410f, -0.04596642f, 0.01751177f, 
    -0.05372224f, -0.01469499f, -0.04041370f, -0.01284339f, 0.04377119f, 0.03327516f, 0.02703301f, 0.04626455f, 
    0.04069080f, -0.03118036f, -0.04638631f, -0.00755620f, 0.04657767f, 0.01984392f, 0.00253556f, -0.04284769f, 
    -0.03249241f, 0.04882280f, 0.02361722f, 0.01370777f, 0.00790886f, -0.02954361f, -0.03376665f, -0.04757226f, 
    -0.02997624f, 0.04529136f, -0.01137258f, -0.03729790f, -0.00010718f, -0.02231422f, -0.00515626f, 0.00560805f, 
    -0.03366892f, -0.01590636f, -0.02135904f, 0.01519928f, 0.00072601f, -0.01711459f, -0.01806965f, 0.02359881f, 
    -0.00997181f, -0.05487916f, 0.04703247f, -0.05210775f, 0.04630342f, 0.01805690f, 0.00444287f, -0.02565298f, 
    -0.02411179f, -0.02610316f, 0.04654481f, -0.04820319f, -0.01943732f, 0.01568764f, -0.03451822f, -0.00613450f, 
    -0.02322185f, -0.04686355f, -0.01754773f, 0.00250330f, 0.01470625f, -0.03420647f, -0.01099810f, 0.00689035f, 
    -0.01104274f, 0.03509480f, 0.03223893f, 0.00500300f, -0.02927731f, 0.03110899f, -0.04850659f, -0.02362231f, 
    0.05107279f, 0.04775463f, 0.02888421f, -0.03799379f, -0.05716000f, 0.00779220f, 0.01941307f, -0.00173679f, 
    -0.01685582f, 0.02061611f, -0.04025616f, -0.00988844f, 0.02061649f, 0.01010150f, 0.01828811f, -0.04713697f, 
    -0.01592640f, -0.03621768f, 0.02439650f, 0.02618512f, -0.04111308f, -0.02710393f, 0.01240354f, -0.05493155f, 
    -0.05822197f, 0.03911693f, 0.00846709f, 0.02879270f, -0.02240896f, -0.05469725f, 0.02767520f, -0.02895318f, 
    -0.06914666f, 0.02529788f, 0.04593616f, -0.01496422f, -0.03026356f, -0.03800224f, -0.03762329f, 0.02664566f, 
    -0.02668123f, -0.05777489f, 0.02400749f, -0.00013471f, 0.00842645f, -0.03764356f, 0.00320786f, 0.04310064f, 
    -0.02442047f, 0.02480980f, 0.04445011f, -0.05380908f, 0.01905016f, -0.06494834f, -0.04507027f, 0.04565534f, 
    0.00532052f, 0.01375479f, -0.03214520f, 0.04275743f, -0.01681071f, -0.03124454f, 0.03595051f, 0.01239400f, 
    0.01953191f, -0.02534077f, 0.01711830f, -0.00727722f, -0.04998066f, -0.01023551f, -0.03776855f, -0.05183405f, 
    -0.05870415f, -0.05633804f, 0.02277098f, -0.06061331f, -0.01359739f, -0.04497977f, -0.03651636f, 0.01013940f, 
    0.02608404f, 0.04254726f, 0.03882847f, 0.01971425f, 0.03807015f, -0.05810416f, 0.01419907f, -0.06573763f, 
    -0.03927377f, -0.03051138f, -0.03718654f, 0.02885922f, -0.00995858f, 0.02326759f, 0.04312685f, 0.04355910f, 
    -0.01272120f, -0.04641867f, 0.00559448f, 0.00154396f, -0.01235440f, 0.00124098f, -0.00401211f, -0.04248327f, 
    0.02469089f, 0.04650632f, 0.02521651f, -0.03530255f, -0.06123662f, 0.01482426f, 0.02379654f, 0.05413692f, 
    -0.05777302f, 0.00927220f, 0.00578826f, -0.02430542f, 0.03900538f, -0.04556243f, -0.05112627f, -0.01613417f, 
    -0.02193257f, 0.03058282f, -0.05418123f, 0.00256217f, 0.00529243f, 0.04472984f, 0.01508831f, -0.02216393f, 
    -0.04288376f, 0.00788291f, 0.03944648f, -0.03789678f, -0.05682487f, -0.06763601f, 0.00288044f, 0.00474060f, 
    -0.05794523f, -0.01225918f, -0.03579761f, -0.00617195f, 0.03159783f, -0.02185792f, -0.04960669f, -0.05563604f, 
    0.03196599f, -0.05583308f, 0.03887925f, 0.01886067f, -0.01702042f, -0.04775578f, -0.05575575f, 0.01179343f, 
    0.02102411f, 0.02220672f, 0.02713756f, -0.06168378f, -0.04375428f, -0.00939243f, 0.01695195f, -0.05124344f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.09579135f, -0.01559219f, 0.25949964f, -0.02342247f, -0.03805034f, -0.09933576f, 0.05466084f, 0.17421499f, 
    0.14204189f, 0.11467414f, 0.02009097f, -0.05238111f, 0.02262229f, 0.08488208f, 0.18663849f, 0.11144800f, 
    -0.06826735f, -0.04220294f, 0.00279934f, -0.17094228f, 0.23430693f, 0.00107903f, 0.11720227f, -0.00202524f, 
    0.35862920f, -0.04418943f, 0.25673491f, 0.22428504f, 0.20724697f, 0.18041180f, 0.01784881f, -0.05360822f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.14027427f, -0.05323184f, -0.19775060f, -0.13568121f, 0.16301088f, -0.11774889f, 0.26755887f, 0.01884517f, 
    0.84192991f, -0.54870367f, 0.14220984f, -0.02812476f, -0.12063979f, -0.26429760f, -0.21194485f, 0.16959485f, 
    0.48830956f, 0.20675059f, -0.18131576f, -0.17087476f, 0.00718847f, -0.13611554f, 0.21865650f, 0.12279000f, 
    0.07015801f, 0.15727319f, -0.08261770f, 0.05351090f, 0.04627686f, 0.01065888f, 0.09650940f, -0.16226287f, 
    0.51209062f, 0.15440166f, -0.29739514f, 0.04534896f, -0.05647581f, -0.06343200f, 0.15493311f, 0.09206581f, 
    -0.06599312f, -0.27974144f, -0.05600591f, -0.09370886f, -0.35539061f, 0.34285647f, 0.06300904f, -0.17053226f, 
    0.25125450f, 0.30459517f, -0.07642876f, 0.53994507f, -0.19302484f, -0.14074360f, 0.11653560f, 0.25725183f, 
    0.12147422f, -0.31438747f, 0.56421179f, 0.31960118f, -0.12609862f, 0.01342732f, 0.11503131f, -0.05573145f, 
    -0.35476634f, 0.07779223f, 0.31355891f, 0.08976534f, 0.06430073f, -0.21928900f, 0.19642413f, 0.12621021f, 
    -0.27256033f, 0.33647877f, -0.00941661f, 0.06284180f, 0.30385351f, 0.17419176f, -0.16592601f, 0.17960741f, 
    -0.57242757f, -0.17968534f, 0.09914614f, -0.08201806f, -0.07992216f, -0.18195859f, -0.02870976f, 0.11827681f, 
    0.23868936f, -0.32287699f, -0.02926975f, 0.22120252f, 0.37882230f, -0.46922451f, -0.07234901f, 0.06878547f, 
    0.01302769f, -0.10056946f, 0.07878630f, 0.04378545f, 0.11162718f, -0.55318689f, 0.18689752f, 0.11794861f, 
    0.43047053f, 0.00792082f, -0.16945106f, 0.13124600f, 0.28175843f, -0.08772539f, -0.26883575f, 0.30513120f, 
    -0.20978057f, -0.07686523f, -0.15000540f, 0.06998808f, -0.08656871f, 0.04246737f, 0.23967315f, -0.06905400f, 
    0.20958063f, 0.08697394f, -0.27877375f, 0.02119736f, -0.02548471f, 0.05179720f, 0.07385927f, -0.08659333f, 
    -0.14263140f, -0.06017756f, -0.13761772f, -0.00876102f, 0.12611768f, -0.10772891f, 0.04938028f, -0.12016920f, 
    -0.02755062f, -0.09371735f, -0.08007243f, -0.08349885f, 0.02763329f, -0.17176569f, -0.11116420f, -0.13681759f, 
    -0.09693817f, 0.15816285f, -0.13468139f, -0.09526684f, -0.16649832f, 0.05634880f, 0.04502425f, 0.00349515f, 
    -0.08726073f, 0.10315506f, -0.04577259f, -0.14049780f, -0.17035221f, -0.08702578f, -0.11657546f, -0.03826759f, 
    0.21487451f, 0.04517828f, -0.30778199f, -0.08101968f, 0.04440161f, -0.00980086f, -0.00424509f, 0.22403157f, 
    0.10669284f, -0.00377055f, -0.04720668f, -0.09568363f, -0.02066048f, -0.45137334f, -0.01213872f, 0.21632142f, 
    0.00266670f, -0.40586957f, 0.16450548f, -0.13470092f, 0.23807822f, -0.07450269f, 0.03273805f, 0.00226614f, 
    -0.03553561f, 0.26544130f, 0.21167137f, -0.13570972f, -0.02392462f, 0.65320617f, -0.09202214f, -0.05461590f, 
    -0.08469915f, -0.05025314f, 0.02933056f, -0.15403779f, -0.03083082f, 0.01756025f, -0.16045433f, -0.08769503f, 
    0.11948707f, -0.14427172f, 0.00362166f, 0.12268629f, 0.02049426f, -0.00342285f, -0.05853084f, -0.07077450f, 
    0.01091374f, -0.10729759f, -0.00036069f, 0.07921492f, -0.02138573f, -0.05696677f, -0.09605349f, 0.05423100f, 
    0.13706532f, -0.09354088f, 0.02611315f, -0.10237855f, -0.02142661f, -0.02761065f, -0.01613927f, 0.01738812f, 
    -0.14217781f, 0.05319338f, 0.33368766f, -0.08979594f, 0.00817629f, -0.18417521f, -0.04006523f, 0.23013774f, 
    0.17997134f, 0.16961925f, 0.04056837f, -0.17044167f, -0.65365589f, -0.12152573f, 0.01570177f, 0.16972336f, 
    -0.11696952f, -0.08035509f, 0.10786312f, -0.47839260f, 0.41428795f, 0.01848548f, 0.18077810f, 0.33933717f, 
    0.27438399f, 0.00447056f, 0.23802592f, 0.36321682f, 0.16460378f, 0.16464318f, -0.05388326f, 0.07974279f, 
    0.12111626f, -0.05353271f, -0.15988044f, 0.15476279f, -0.07289523f, -0.01790156f, -0.15090561f, -0.14645967f, 
    0.06535311f, -0.14837758f, -0.14469750f, 0.02043650f, -0.17577332f, -0.06911997f, 0.13547342f, -0.08887331f, 
    -0.14779939f, 0.08176175f, 0.09479399f, 0.12189753f, 0.09275992f, -0.09977943f, -0.17164974f, -0.09505668f, 
    -0.06390931f, -0.01508332f, -0.03619337f, -0.15458311f, 0.11560855f, 0.07943874f, -0.08940057f, 0.15608487f, 
    0.40917867f, 0.02267928f, -0.42231047f, -0.01569279f, -0.13775638f, -0.05077248f, -0.19293125f, 0.15035857f, 
    -0.17588870f, 0.23308109f, -0.07601099f, -0.17693000f, 0.15568672f, 0.13470641f, 0.15484869f, 0.05823432f, 
    0.25421783f, 0.36587933f, 0.13254113f, 0.16299753f, -0.23814631f, 0.14420879f, 0.40261912f, 0.43913549f, 
    -0.01257395f, 0.03609584f, 0.30708262f, -0.00488473f, -0.55006146f, 0.39999303f, -0.12213001f, -0.13977489f, 
    -0.16800515f, -0.11777458f, -0.10571823f, -0.07429082f, -0.10075830f, 0.11382942f, -0.17130968f, 0.08394282f, 
    0.01290678f, 0.31009343f, -0.15356529f, 0.12647435f, -0.43979728f, 0.21927239f, 0.23978718f, 0.00401717f, 
    0.44880405f, 0.11449192f, 0.05809872f, -0.30800903f, 0.05406962f, 0.11059768f, 0.38882899f, -0.19905347f, 
    0.09385280f, 0.14619739f, -0.13642821f, 0.51029891f, 0.11252579f, -0.14146096f, 0.02303663f, 0.00347567f, 
    -0.00820111f, 0.09464041f, 0.04364035f, 0.13022797f, 0.12324779f, 0.09473412f, -0.07219421f, -0.04981866f, 
    -0.02344139f, -0.04951574f, -0.01112344f, -0.02557369f, 0.06254438f, -0.03363521f, -0.12847777f, -0.09261273f, 
    -0.02591945f, -0.10239895f, -0.18007201f, 0.01171635f, -0.08930307f, 0.13230683f, 0.09085678f, -0.06371094f, 
    0.01801878f, 0.09828735f, -0.02526904f, -0.18102659f, 0.10212845f, 0.13330919f, -0.00987632f, 0.16565211f, 
    -0.09650612f, 0.16841388f, 0.16122441f, 0.15822317f, 0.11851375f, -0.01009679f, 0.31473494f, -0.28517270f, 
    0.68149865f, -0.43485102f, -0.05439044f, -0.08030478f, 0.13314424f, 0.31569758f, -0.21137525f, -0.10229014f, 
    -0.18730591f, -0.06868594f, -0.05231849f, 0.34511882f, -0.53567106f, -0.13879266f, -0.13928281f, 0.00884265f, 
    0.19683997f, -0.00832052f, 0.19529232f, 0.02971279f, 0.30034989f, -0.10201246f, -0.05416296f, -0.15360242f, 
    0.24098791f, 0.08583608f, -0.41681802f, -0.13811065f, -0.10699256f, 0.02960602f, 0.16859107f, 0.26496628f, 
    -0.04830448f, -0.52029866f, -0.17645602f, -0.04466552f, -0.24434800f, -0.33164132f, -1.01856339f, -0.07954635f, 
    -0.23031071f, 0.36606821f, -0.11381315f, 0.06179996f, 0.09236009f, 0.01379163f, 0.12214144f, 0.07324380f, 
    0.20097938f, -0.04675327f, -0.55369473f, -0.05364534f, -0.23991455f, -0.31604272f, 0.11568515f, -0.05773922f, 
    -0.00513255f, -0.14804137f, -0.03723514f, 0.09901150f, 0.03683571f, -0.09261075f, -0.00146906f, -0.05819031f, 
    -0.04011440f, -0.17123702f, 0.02158102f, -0.12052871f, -0.16526292f, -0.09435207f, -0.07636966f, -0.15916826f, 
    -0.17674622f, -0.20430414f, -0.13845539f, 0.08557370f, -0.17725673f, -0.15162440f, 0.07298244f, -0.06299451f, 
    0.03946783f, 0.07675114f, -0.07161356f, 0.13294946f, -0.05523859f, 0.13177331f, 0.12618062f, -0.02438939f, 
    -0.30387187f, -0.11578409f, -0.00216545f, -0.17955023f, 0.16623512f, -0.24909309f, 0.03912383f, 0.23737977f, 
    -0.22137211f, 0.32628807f, -0.11660801f, 0.10978155f, -0.29843488f, -0.29284775f, 0.04477170f, 0.29689020f, 
    -0.38607815f, -0.04542797f, 0.04270335f, -0.02065861f, 0.37179497f, 0.16243894f, -0.14809838f, 0.18041342f, 
    0.12872876f, 0.22666100f, -0.39334688f, -0.13444439f, -0.24085027f, -0.07436337f, -0.00491311f, -0.08134919f, 
    0.19120434f, 0.10011408f, -0.25468713f, 0.02642956f, -0.15606108f, -0.50846255f, 0.25024322f, -0.02773742f, 
    -0.13843623f, -0.29752445f, 0.09213784f, 0.10506406f, 0.46299392f, -0.13044006f, -0.30533972f, 0.18817852f, 
    -0.15274259f, 0.22568692f, -0.11657578f, -0.22620858f, 0.14289185f, 0.08916898f, -0.01806583f, 0.25391224f, 
    0.11409460f, -0.01923474f, 0.15484510f, -0.70505285f, -0.26452091f, 0.24176209f, -0.12611279f, 0.05516839f, 
    0.28596410f, -0.16701987f, 0.13703710f, 0.11556909f, 0.01079607f, 0.39448217f, 0.24283648f, -0.11753619f, 
    0.36154991f, -0.05667003f, -0.14749518f, 0.18102133f, 0.16978067f, 0.08725663f, 0.15360591f, -0.04383047f, 
    0.55473715f, 0.36776271f, -0.14439912f, -0.07705098f, -0.28596556f, 0.13841116f, 0.29044750f, -0.14060886f, 
    -0.14309171f, -0.17205717f, -0.39256510f, 0.29475084f, -0.21893148f, -0.20210357f, -0.05880257f, -0.06231994f, 
    0.19855948f, 0.08000854f, 0.20997553f, 0.03281025f, 0.05988938f, -0.05684015f, 0.18482071f, -0.26000851f, 
    -0.44157040f, -0.12801833f, 0.04187952f, -0.09713725f, 0.52484423f, 0.28502405f, 0.00082410f, 0.17302629f, 
    -0.34255683f, -0.06537070f, -0.00877523f, 0.29399377f, -0.21462242f, 0.02698743f, -0.28356302f, 0.29591459f, 
    -0.12739100f, -0.09851231f, 0.43602386f, -0.46748209f, -0.11429293f, 0.18632367f, 0.08941911f, -0.00268607f, 
    0.00929108f, -0.11978851f, 0.17955804f, -0.01084689f, -0.16075736f, -0.02203152f, -0.02658123f, 0.21653222f, 
    -0.06982175f, 0.37702301f, 0.01713444f, -0.04213554f, -0.23673132f, -0.29909644f, 0.35129288f, -0.00172507f, 
    0.09346554f, -0.02841061f, 0.12721460f, -0.32218584f, 0.34092709f, 0.14506170f, 0.28781167f, -0.11848380f, 
    0.08059964f, -0.18081199f, 0.07574586f, 0.02427208f, 0.08237903f, -0.13334617f, -0.07366038f, -0.02636094f, 
    0.21956082f, 0.04921186f, -0.03314615f, -0.14735499f, 0.01511727f, 0.24709718f, -0.11083088f, 0.12525521f, 
    -0.06771379f, -0.14629613f, -0.06583685f, 0.00235513f, -0.57663327f, 0.00278117f, -0.04152232f, -0.12186106f, 
    0.50295168f, -0.36993617f, 0.10155008f, 0.00828956f, 0.11590882f, 0.03684027f, 0.16696855f, -0.25576949f, 
    0.24589412f, 0.25020626f, 0.45112917f, 0.20253222f, 0.33913431f, 0.63081050f, 0.10696974f, -0.02855255f, 
    -0.10407879f, -0.02915873f, 0.14264162f, 0.15433830f, -0.02275540f, 0.03891954f, -0.17323501f, -0.08934506f, 
    -0.14101082f, 0.02541541f, 0.06601640f, -0.00322291f, 0.14537884f, -0.12173816f, -0.09092870f, -0.08917931f, 
    0.00957077f, -0.06496123f, -0.12668698f, -0.05357216f, -0.10228208f, 0.13513106f, 0.07274003f, -0.05432986f, 
    0.08752412f, -0.10551204f, -0.12152705f, -0.12800206f, -0.07706429f, 0.12079126f, -0.13480476f, -0.09201685f, 
    -0.10096599f, 0.06036611f, 0.10481704f, 0.07061410f, -0.09621803f, -0.15912504f, -0.08890843f, -0.15750776f, 
    0.00477392f, 0.12924857f, 0.09714282f, 0.16140775f, -0.15217495f, 0.01983158f, 0.09342647f, -0.09739444f, 
    -0.08502297f, -0.07785243f, 0.02118527f, -0.02978034f, -0.13957806f, 0.00474350f, -0.02145807f, -0.09904752f, 
    0.14733875f, 0.03916100f, -0.10230309f, -0.10461424f, -0.07397782f, -0.00365042f, 0.11366889f, -0.13188525f, 
    0.14552729f, 0.16122049f, 0.62317097f, 0.03036435f, 0.10339782f, -0.17648244f, 0.09031441f, -0.09508511f, 
    0.31968513f, 0.03398595f, 0.06335721f, 0.05037004f, -0.25085613f, -0.08132024f, 0.11147111f, -0.06669468f, 
    0.09126183f, -0.39756832f, -0.16353163f, -0.19028920f, 0.28840435f, -0.07154704f, -0.02732569f, -0.13959748f, 
    0.20868069f, -0.26672095f, 0.27504289f, 0.17067422f, 0.54923236f, -0.01931629f, 0.13261114f, 0.14509599f, 
    0.10666334f, -0.15624355f, -0.27894178f, -0.08176265f, -0.06110768f, 0.00803810f, -0.07312847f, 0.08118712f, 
    0.53302068f, -0.20916739f, -0.08518330f, 0.00049910f, -0.53359175f, 0.13803905f, -0.30658695f, 0.01544816f, 
    -0.26810831f, 0.10028154f, 0.13054734f, 0.44009742f, -0.04787517f, -0.17301957f, -0.06819703f, -0.23224488f, 
    0.22334337f, 0.19310409f, -0.10736118f, -0.11182547f, 0.02441991f, 0.19426183f, 0.08883103f, 0.15359253f, 
    0.03906008f, 0.07920292f, 0.11625668f, 0.11640728f, 0.04763586f, 0.25183553f, 0.02683567f, 0.06360188f, 
    -0.06952487f, 0.10519381f, 0.03297924f, 0.12658899f, -0.47687602f, 0.13979442f, -0.19479765f, 0.04464638f, 
    -0.33506364f, -0.50487584f, -0.04623705f, 0.44011253f, 0.42045936f, 0.14688112f, -0.24045894f, -0.10735073f, 
    0.04635104f, 0.15211034f, 0.38867918f, -0.33569509f, 0.43664286f, 0.43719998f, -0.03194985f, -0.02498183f, 
    0.33180526f, -0.15527144f, 0.05537051f, 0.07189640f, 0.01320025f, 0.29404488f, 0.20458727f, -0.05276725f, 
    0.10737319f, -0.25108743f, -0.04926342f, -0.02237238f, 0.20228082f, 0.24646884f, 0.14994349f, -0.06100146f, 
    0.33743608f, 0.28802201f, -0.15292762f, 0.37539268f, -0.59418064f, 0.02591172f, -0.03777022f, -0.16701958f, 
    -0.13812616f, -0.19977181f, -0.03576348f, 0.06799431f, -0.00102139f, -0.26635975f, -0.12854312f, -0.12806545f, 
    -0.09567463f, -0.06931121f, 0.00920300f, -0.18212041f, 0.11274691f, 0.04758088f, -0.06613796f, -0.17024688f, 
    -0.17782532f, -0.15987898f, -0.01473234f, -0.04441029f, -0.08417794f, 0.04194754f, -0.11302868f, -0.00875987f, 
    -0.08068666f, 0.01722439f, 0.06662066f, -0.09697986f, 0.08262893f, 0.10887882f, 0.01131043f, -0.12731099f, 
    -0.08436784f, -0.09858432f, -0.13810529f, 0.14180242f, 0.14625351f, -0.03094902f, 0.10126884f, 0.08702919f, 
    0.07508495f, -0.10967419f, 0.14473312f, -0.08224770f, -0.07682778f, -0.14480510f, -0.06295924f, -0.16423832f, 
    0.04380313f, -0.04316119f, 0.13839701f, 0.15697189f, 0.01643525f, -0.13515565f, 0.07324054f, -0.07104778f, 
    0.05066793f, -0.06749240f, 0.03215023f, -0.05055961f, -0.05350827f, -0.07512903f, -0.14724837f, 0.12658165f, 
    -0.01685712f, 0.07224739f, -0.03741213f, -0.02599264f, 0.10632411f, 0.12319056f, 0.01794579f, 0.13449606f, 
    -0.20712683f, -0.15450402f, 0.25445396f, 0.06173442f, 0.13356009f, -0.27123532f, 0.30603558f, 0.06289537f, 
    0.29482111f, -0.11106366f, -0.02649063f, -0.13618183f, 0.30307302f, -0.15710729f, -0.17797603f, 0.17276521f, 
    -0.31625623f, -0.41129127f, -0.14344041f, 0.10982094f, 0.02952513f, -0.09836509f, -0.26847580f, -0.19687353f, 
    0.30836007f, 0.00710374f, -0.01619099f, -0.25379845f, 0.40864462f, 0.15319160f, -0.12089749f, 0.12859891f, 
    -0.21100980f, 0.15760306f, -0.57444733f, 0.08644952f, -0.00453091f, 0.17320900f, 0.02014403f, 0.10971577f, 
    0.23800813f, 0.13806069f, 0.12937331f, -0.20201479f, -0.05892561f, 0.12984629f, 0.01991465f, 0.23260120f, 
    -0.23132011f, -0.00277944f, 0.11893828f, 0.14278866f, -0.08361112f, -0.14637168f, -0.12306292f, -0.21473855f, 
    0.02886863f, 0.24468347f, -0.40201384f, 0.38262075f, 0.07399845f, 0.14135079f, -0.13294008f, 0.10895327f, 
    -0.03670627f, -0.11818126f, -0.01157368f, 0.12006013f, 0.16171154f, -0.08245353f, -0.07420783f, 0.14617036f, 
    0.05399762f, -0.16655363f, 0.07074478f, -0.08897584f, 0.12347975f, 0.10035276f, -0.12278516f, -0.16902155f, 
    -0.05982842f, 0.13970622f, 0.14482750f, 0.05587700f, -0.03259444f, -0.15602154f, -0.13908648f, -0.10778324f, 
    0.12081881f, -0.08225614f, -0.11328484f, -0.10277712f, -0.17152724f, -0.01887990f, -0.09862332f, 0.14882997f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.00663550f, 0.10213291f, 0.18771783f, 0.12116629f, -0.06165713f, 0.10157183f, 0.13706836f, 0.51875108f, 
    0.12883824f, -0.03167289f, 0.19322249f, -0.08861037f, -0.13251045f, -0.16545308f, -0.18390377f, 0.26589754f, 
    0.06536685f, -0.07225227f, -0.02681711f, 0.28489804f, 0.21589693f, 0.06192291f, -0.10076106f, 0.24891984f, 
    0.06619719f, -0.04018854f, -0.06888534f, 0.02158431f, -0.05046649f, 0.19932105f, -0.34317079f, -0.03374140f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.09490369f, 0.01229302f, -0.07828179f, -0.14518778f, -0.16419145f, -0.20134626f, -0.03988377f, 0.02453262f, 
    0.04011988f, -0.13341320f, 0.08725294f, 0.15370297f, -0.13903451f, 0.12259901f, -0.06893195f, -0.20655486f, 
    -0.17901303f, -0.17778726f, -0.14982913f, -0.03407014f, -0.02399583f, 0.07682521f, 0.15945649f, 0.09367824f, 
    -0.18034860f, 0.08515009f, -0.08428786f, -0.05450043f, 0.01078812f, 0.08913787f, 0.01702150f, 0.16244917f, 
    -0.10755134f, 0.13893759f, -0.15492445f, -0.09942817f, 0.00888805f, 0.21759561f, -0.10754601f, 0.23529390f, 
    -0.08662351f, 0.18968132f, 0.33527228f, -0.05196818f, -0.34798768f, -0.61005765f, -0.04969008f, 0.11459782f, 
    -0.09976451f, -0.09199254f, -0.08504001f, 0.39458218f, 0.32587582f, 0.04341673f, 0.04893162f, 0.36567479f, 
    -0.29460734f, 0.03829037f, 0.04193792f, -0.07519298f, 0.04190526f, 0.00962998f, -0.06180070f, -0.11540823f, 
    0.15050757f, 0.06888482f, -0.14792490f, 0.03375471f, -0.00360564f, 0.08606401f, -0.10209745f, -0.18499091f, 
    -0.07334652f, 0.15209784f, -0.48409596f, -0.04804626f, 0.09814661f, -0.08423056f, -0.01497645f, 0.00375353f, 
    0.11436106f, -0.39691117f, 0.56755757f, -0.28543881f, 0.25814927f, -0.13569859f, -0.06215763f, 0.04345139f, 
    0.47159648f, 0.45281526f, -0.09351569f, 0.06198552f, -0.01793420f, 0.17262281f, 0.06994632f, -0.10057084f, 
    0.16333334f, -0.03858168f, 0.23870631f, 0.15468186f, -0.10769921f, -0.09382477f, 0.04086402f, 0.10096293f, 
    0.02100432f, 0.04717973f, -0.09400394f, 0.01487248f, -0.10386617f, 0.44931415f, 0.03003400f, 0.32112378f, 
    0.18224502f, 0.27032587f, 0.14125055f, 0.12178156f, -0.53194469f, 0.10681742f, 0.15685251f, 0.31434125f, 
    -0.40742195f, -0.10769804f, -0.07132463f, 0.10803915f, -0.08381446f, 0.16721088f, -0.20834260f, -0.13282213f, 
    -0.15716411f, -0.20337245f, -0.02974892f, -0.08193779f, -0.11156835f, 0.08394949f, -0.09010596f, -0.08830604f, 
    -0.11743140f, 0.04649873f, -0.09542354f, 0.07903244f, -0.13365228f, 0.02524647f, 0.13380709f, 0.05666162f, 
    -0.01873896f, -0.14507662f, -0.10366680f, -0.10130242f, -0.03524368f, 0.00202882f, 0.13380125f, 0.04941786f, 
    -0.07599273f, 0.06736884f, -0.12746412f, 0.09518746f, -0.08273121f, -0.04728972f, -0.04113619f, -0.16055711f, 
    -0.19452232f, -0.06548800f, 0.03611359f, -0.23252527f, 0.12742782f, -0.09103168f, -0.14946462f, 0.09909166f, 
    0.04432110f, -0.09185810f, 0.14937393f, -0.11854781f, 0.03778795f, -0.32662326f, 0.09471014f, -0.14078799f, 
    -0.16520430f, 0.26956737f, 0.17842805f, -0.14942254f, -0.05506568f, 0.11725336f, -0.18483064f, 0.15953192f, 
    -0.39944553f, -0.00721634f, 0.04164791f, 0.06896322f, -0.09069669f, 0.02707242f, 0.28303406f, -0.18187127f, 
    -0.10757797f, -0.04194297f, -0.14675948f, 0.10381570f, -0.05156945f, -0.17615214f, 0.06057103f, -0.03753717f, 
    0.11657181f, -0.21080866f, -0.15868515f, 0.11792856f, -0.13526952f, -0.01623250f, -0.12279124f, -0.03700826f, 
    -0.02465327f, -0.09346712f, 0.06172661f, -0.19821733f, -0.15377450f, -0.12588844f, 0.18082280f, 0.08340847f, 
    0.02419436f, -0.04513564f, 0.09252444f, -0.17448106f, 0.17192329f, 0.12684442f, -0.14107379f, 0.09799939f, 
    -0.18180153f, 0.43531403f, 0.19226648f, -0.06958240f, 0.07180209f, -0.24342701f, -0.01747579f, -0.06879882f, 
    0.10541405f, 0.06157285f, 0.14116418f, -0.15838937f, 0.06361095f, -0.21131848f, -0.06363323f, 0.28864032f, 
    -0.13253072f, -0.20773265f, 0.07002929f, 0.04817991f, -0.05906355f, -0.14502859f, -0.04183606f, -0.35272548f, 
    0.42805526f, 0.07340693f, 0.05607390f, 0.14935409f, 0.06729908f, -0.21770735f, -0.09453691f, -0.16077389f, 
    0.33676493f, -0.00698727f, -0.01740528f, 0.24509171f, -0.01853627f, -0.06852314f, -0.04334656f, 0.29240268f, 
    0.17335859f, -0.13646553f, 0.38441950f, 0.14011312f, 0.21537136f, -0.05089621f, -0.00957297f, 0.12643066f, 
    -0.31861919f, 0.11763856f, -0.97121620f, 0.26634407f, 0.34265962f, -0.07094471f, 0.17254712f, 0.58710283f, 
    0.30753332f, -0.13734768f, -0.08684782f, -0.00924435f, 0.06926838f, -0.02989425f, -0.06544875f, -0.07309559f, 
    -0.25158638f, -0.02542676f, 0.43706763f, 0.23309796f, 0.14934255f, -0.10027593f, -0.14778830f, 0.27731583f, 
    -0.10401252f, -0.00064863f, 0.24521747f, 0.03186404f, 0.13018942f, -0.37703088f, -0.02890030f, -0.03569604f, 
    0.02214697f, -0.15180275f, 0.25965884f, -0.04486942f, 0.39651230f, -0.11353600f, 0.21582332f, 0.08285849f, 
    -0.45921469f, -0.01811724f, -0.09238535f, -0.08046013f, -0.03692530f, 0.38010398f, -0.15019237f, -0.07987695f, 
    0.05832589f, -0.13195084f, 0.02816101f, 0.25162622f, 0.08270986f, 0.23986763f, 0.08550563f, 0.37604824f, 
    -0.02132297f, 0.15456302f, 0.15220809f, -0.01839407f, -0.44573200f, -0.83625740f, 0.04262961f, 0.48656988f, 
    0.15991135f, -0.67087662f, 0.04808354f, 0.43846661f, 0.05508278f, -0.04097630f, 0.10756803f, -0.00471865f, 
    -0.18222286f, -0.11312447f, -0.77111322f, -0.06345990f, -0.08761314f, -0.02947859f, -0.18622383f, 0.04711130f, 
    0.00585702f, 0.31058693f, 0.06874599f, 0.02445853f, 0.04852493f, -0.21103536f, -0.03857033f, 0.15517338f, 
    0.10705908f, 0.22495401f, 0.18508537f, -0.07406656f, 0.30527246f, -0.24946140f, -0.05490705f, -0.44714335f, 
    -0.37218001f, 0.23110159f, -0.15690430f, -0.25011650f, 0.36301479f, 0.04428681f, -0.03212303f, 0.13197201f, 
    -0.15967354f, -0.02232316f, 0.25859088f, 0.04649012f, 0.05852140f, -0.17048801f, 0.04493856f, -0.04186495f, 
    0.16143359f, 0.00872287f, -0.26260239f, 0.13744831f, 0.15041971f, 0.17405710f, -0.08780185f, -0.02762894f, 
    0.11108939f, 0.04240564f, -0.09310412f, -0.15574937f, 0.32050803f, -0.45180106f, 0.00968911f, -0.29811198f, 
    -0.03387300f, 0.04595751f, 0.19233827f, -0.27025291f, 0.26287887f, -0.14428037f, -0.16052125f, 0.06363053f, 
    0.10258041f, -0.09589802f, -0.08850000f, -0.05205006f, -0.11512409f, 0.17698054f, -0.12019879f, 0.13310511f, 
    -0.06060925f, -0.01374988f, -0.05838804f, 0.00041779f, -0.06686267f, -0.19056074f, -0.12640956f, -0.13801982f, 
    0.06259726f, -0.12298612f, -0.00830070f, 0.14375624f, 0.13983360f, -0.04126393f, -0.15517887f, 0.02764870f, 
    0.07526989f, -0.17458449f, 0.15141992f, 0.02411128f, -0.08114385f, -0.15349050f, 0.08714955f, -0.12347712f, 
    -0.11766782f, -0.10362697f, 0.06885260f, -0.07513175f, 0.13085873f, -0.06143817f, -0.10613391f, 0.14307339f, 
    -0.13391531f, -0.12447338f, -0.13909310f, -0.17112057f, 0.09640122f, -0.18001506f, 0.17638156f, 0.06706912f, 
    0.11541912f, -0.14946973f, 0.00301630f, 0.02708516f, -0.05999671f, -0.06945748f, 0.15124205f, 0.14928269f, 
    -0.09692581f, 0.03465452f, 0.09134527f, 0.02232363f, 0.05541983f, -0.01125005f, -0.17453913f, -0.06421788f, 
    0.14417732f, -0.11409581f, -0.07642126f, 0.08854242f, 0.07842253f, -0.12536298f, 0.01421598f, -0.00483107f, 
    0.03160948f, 0.13046439f, -0.04374065f, 0.06224031f, 0.03800227f, 0.13458219f, 0.12655357f, 0.12539732f, 
    0.06782015f, -0.35361418f, -0.63604224f, -0.03405844f, 0.06330472f, 0.45876753f, 0.08882809f, 0.07725732f, 
    0.18300834f, -0.38431379f, 0.06201339f, -0.01106346f, 0.34840038f, 0.11359703f, 0.09100649f, 0.41058350f, 
    0.15975316f, 0.15762655f, -0.06413911f, -0.02564652f, -0.05760815f, -0.03174679f, -0.48020074f, 0.15670642f, 
    0.04611636f, 0.07546493f, 0.22057125f, 0.30328226f, -0.04969427f, 0.25543624f, -0.11238128f, 0.19920486f, 
    -0.12356476f, 0.34213957f, -0.14246559f, -0.08556990f, -0.12494203f, 0.00334771f, -0.04016538f, 0.45595828f, 
    0.34306160f, -0.33357233f, -0.00431703f, -0.08794113f, -0.52307332f, -0.12359457f, 0.18084739f, -0.36661416f, 
    -0.11926258f, -0.34721825f, -0.32713205f, 0.09756850f, -0.09204303f, 0.15054922f, 0.32664090f, 0.12335548f, 
    0.24579516f, -0.06052547f, -0.04334487f, 0.30549717f, 0.14379220f, 0.26207495f, 0.03760257f, -0.07829722f, 
    -0.06773580f, 0.25202334f, -0.40094325f, 0.16305046f, 0.17420912f, 0.44332799f, -0.14071259f, 0.09055514f, 
    0.27228743f, 0.02809126f, 0.21524669f, 0.08485522f, -0.33387440f, -0.03753097f, 0.06490956f, -0.24266841f, 
    0.02053770f, -0.48825517f, 0.03731243f, 0.01018075f, -0.16662706f, 0.02206517f, -0.14232798f, -0.01315727f, 
    -0.14681716f, -0.08121260f, 0.12469818f, -0.02820458f, -0.15187378f, -0.06846000f, -0.14643057f, 0.06291274f, 
    -0.12752740f, -0.15675385f, 0.02424314f, 0.15103006f, -0.03899767f, -0.08262607f, -0.09968324f, 0.05693308f, 
    0.15796110f, -0.06666185f, -0.11161747f, -0.01248768f, -0.05032338f, 0.04123384f, 0.02151337f, -0.07534122f, 
    -0.04423337f, -0.19847997f, -0.17125835f, 0.15375380f, -0.11830974f, 0.01120091f, -0.15542187f, 0.17549208f, 
    -0.05242030f, 0.17291568f, 0.00531313f, -0.10627251f, -0.01958977f, 0.14053342f, -0.06535971f, 0.23332152f, 
    0.02900970f, 0.09759163f, 0.36325589f, -0.03758202f, -0.23639788f, -0.38019636f, 0.19391508f, -0.13166194f, 
    -0.03784290f, -0.14974956f, -0.12000077f, 0.31605712f, 0.83958882f, 0.07139855f, 0.07678618f, 0.47776160f, 
    -0.38235968f, 0.19920447f, -0.26480433f, -0.01583300f, -0.02733137f, -0.03947763f, -0.28725925f, -0.10489906f, 
    -0.48488295f, 0.23357914f, -0.29313725f, -0.19595127f, -0.05926039f, -0.42403409f, -0.00709770f, -0.24932076f, 
    -0.09184864f, -0.32728916f, 0.10044535f, 0.06351205f, 0.20028397f, 0.08279493f, -0.02782715f, -0.14345768f, 
    0.00681749f, -0.13480073f, -0.20064302f, -0.31883550f, 0.18430051f, -0.04714135f, -0.04331551f, -0.13397191f, 
    0.32343248f, -0.07500684f, 0.15779567f, 0.07889799f, -0.07229426f, -0.22874156f, 0.05495750f, 0.02647753f, 
    0.14666350f, -0.15872701f, 0.07851025f, 0.20279647f, 0.03836318f, 0.20499042f, -0.08915818f, 0.12952299f, 
    -0.02304417f, -0.27826759f, -0.34296757f, 0.13482635f, 0.20139979f, 0.34542096f, 0.09856700f, 0.51545256f, 
    0.21761489f, -0.54142159f, -0.16896515f, -0.01601334f, 0.23377249f, -0.00564329f, 0.10263576f, 0.25671807f, 
    0.19977641f, 0.38505521f, -0.53557295f, 0.16786195f, -0.00019221f, 0.34134436f, 0.14104199f, 0.01703517f, 
    0.03053712f, -0.34273705f, 0.00456985f, 0.10299688f, -0.07827201f, -0.04218850f, 0.07053075f, -0.35425720f, 
    0.09827147f, 0.20244253f, -0.00537009f, 0.10907210f, -0.09392854f, -0.01323883f, 0.16346702f, 0.17540921f, 
    0.12976587f, 0.01473368f, -0.03463288f, -0.04867813f, 0.13703214f, -0.09360406f, -0.09717301f, -0.23439169f, 
    0.00006739f, 0.16253839f, 0.19307846f, -0.02366175f, 0.05029969f, 0.08764991f, 0.24921036f, -0.12963717f, 
    0.10621793f, 0.13111594f, -0.22542019f, 0.15845582f, -0.14456436f, 0.22954717f, -0.17462662f, -0.15980655f, 
    -0.09425534f, 0.11518541f, 0.14116210f, -0.11925090f, -0.15521096f, 0.26969609f, -0.14320035f, 0.12943490f, 
    0.08369093f, 0.03707437f, -0.31899494f, -0.13930142f, 0.62023753f, 0.00172922f, 0.13665381f, -0.41006330f, 
    0.83352196f, 0.25624713f, 0.10367774f, -0.00840172f, 0.13622983f, 0.06271046f, 0.33007368f, -0.07213901f, 
    -0.09803015f, 0.35144916f, 0.24039568f, 0.04246040f, 0.01416494f, -0.22145744f, -0.09479515f, -0.11266921f, 
    -0.08980071f, 0.30092680f, 0.10231268f, 0.10920972f, -0.03132812f, 0.48035860f, 0.02579270f, 0.11102214f, 
    0.26029921f, 0.17385973f, 0.38285756f, 0.05314540f, -0.43524531f, 0.08122180f, 0.01269917f, -0.18390416f, 
    0.00812376f, -0.17494997f, 0.20522577f, -0.00037815f, 0.07996174f, -0.22628772f, -0.28469121f, -0.15866819f, 
    0.37095919f, 0.20788622f, 0.04759317f, 0.06124058f, 0.17167033f, -0.12595582f, 0.05866247f, 0.03583507f, 
    0.15376423f, -0.18446958f, -0.37061486f, 0.07721900f, 0.53126222f, 0.24954054f, -0.10869488f, -0.26345640f, 
    0.34110105f, 0.34499156f, 0.15161856f, 0.00512914f, -0.26115626f, 0.08159442f, 0.12044945f, 0.32994634f, 
    0.15950385f, -0.08648374f, 0.39628330f, -0.08683468f, -0.13947251f, 0.25669932f, -0.20999275f, 0.00066676f, 
    0.32268164f, 0.24660219f, -0.13745274f, 0.20355959f, 0.10156727f, 0.00489773f, -0.16283840f, 0.26570198f, 
    -0.15349825f, 0.04035110f, 0.26884034f, -0.03590814f, -0.11982869f, 0.23126471f, 0.15292801f, 0.33542624f, 
    -0.09440445f, 0.01575626f, -0.59454107f, 0.03633329f, 0.12607592f, 0.03434595f, -0.09888124f, -0.08036724f, 
    0.26750582f, -0.03980329f, -0.21310326f, -0.15774260f, -0.08068211f, -0.07149780f, 0.14347652f, 0.03840625f, 
    0.00808811f, 0.07158954f, 0.47449008f, 0.19380213f, -0.00307027f, -0.00465132f, -0.02453143f, 0.33760756f, 
    0.05084349f, -0.08683325f, -0.18741904f, 0.13279594f, 0.26008579f, -0.04283703f, -0.01563258f, 0.45437720f, 
    -0.00070255f, -0.49117577f, 0.30118924f, -0.24553227f, -0.32574952f, -0.10766758f, 0.15483406f, 0.16276760f, 
    0.17171031f, 0.42202997f, -0.27662227f, 0.02687562f, -0.08843778f, 0.25689390f, -0.15889889f, -0.12982911f, 
    0.16709095f, 0.29537314f, -0.05840921f, 0.14491349f, 0.02998312f, -0.10566185f, -0.06454332f, -0.03504301f, 
    0.14580476f, 0.20390549f, -0.64463103f, -0.00086985f, 0.20624691f, -0.69383925f, 0.12835960f, -0.22191972f, 
    0.19949752f, -0.17498794f, 0.65776318f, -0.22499718f, 0.01904419f, 0.09638910f, 0.00141842f, 0.28634825f, 
    -0.08991046f, 0.21663991f, 0.09381846f, -0.09092876f, -0.02269180f, 0.06642640f, -0.49569884f, 0.04470559f, 
    0.08405485f, 0.30963495f, -0.34903249f, -0.19309393f, -0.06169230f, 0.21185248f, -0.12864286f, 0.22810887f, 
    -0.15001035f, 0.42536658f, -0.31233621f, -0.15629277f, 0.02530628f, 0.51963794f, 0.01655287f, -0.00807802f, 
    0.23559721f, 0.01385502f, 0.10700426f, -0.01609102f, 0.11018372f, -0.14104006f, 0.07345793f, -0.26731864f, 
    0.03646367f, 0.32043993f, -0.00328927f, -0.17350262f, 0.03041034f, -0.29593447f, -0.04083136f, 0.08221872f, 
    0.39664707f, 0.06623745f, -0.57273865f, 0.12932746f, 0.05196361f, 0.24438664f, -0.12937994f, 0.06457074f, 
    -0.09540980f, 0.48014569f, 0.06092624f, -0.06400619f, -0.34377292f, 0.00143596f, -0.06009608f, 0.05917919f, 
    0.31241065f, 0.49483404f, -0.00848756f, -0.06227840f, 0.36249498f, 0.04945796f, 0.15436983f, -0.44782197f, 
    0.23205632f, -0.32468534f, 0.03216642f, -0.10736367f, 0.00206560f, -0.43437308f, -0.32634640f, 0.03428055f, 
    -0.17567462f, -0.09940681f, -0.22881317f, 0.09578937f, 0.01393720f, -0.18723531f, 0.15109651f, 0.05736820f, 
    0.06692110f, -0.26199630f, 0.01695399f, 0.07112847f, -0.18966010f, -0.05072894f, 0.06355745f, 0.00370683f, 
    0.03931496f, 0.02843018f, 0.08362535f, 0.04283400f, -0.14737506f, -0.00931397f, -0.07766592f, -0.08079883f, 
    0.15326995f, -0.15090863f, 0.01097089f, 0.09022888f, 0.16591473f, -0.12746030f, 0.02520693f, -0.05649937f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.06465960f, 0.03055554f, -0.20651062f, 0.22295536f, 0.05205809f, 0.32017741f, 0.07567231f, 0.17820029f, 
    0.09636571f, 0.28116575f, 0.26644781f, 0.00249102f, 0.15236160f, -0.16576685f, 0.14874400f, 0.18789682f, 
    0.30366307f, 0.24117206f, -0.19228831f, 0.03871449f, -0.28401414f, 0.03592692f, 0.04696298f, -0.30889374f, 
    0.01122904f, 0.23774335f, 0.25779164f, 0.23584707f, 0.11281627f, -0.07521676f, -0.08544374f, -0.16596138f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.16107495f, -0.21740791f, -0.43180001f, 0.15726280f, -0.05661672f, -0.23814000f, -0.10174700f, -0.37998196f, 
    0.23499633f, -0.57291228f, -0.45107725f, 0.08164746f, -0.23367004f, -0.03051201f, -0.10959379f, -0.07781435f, 
    -0.28137335f, 0.04973859f, 0.06697550f, -0.04392773f, -0.28422096f, -0.56622601f, -0.12211254f, 0.18574674f, 
    0.26446128f, 0.04832033f, 0.23796487f, -0.75523603f, -0.32987359f, 0.13035163f, 0.33202371f, 0.01218373f, 
    -0.08908208f, 0.37890866f, -1.07184601f, 0.18559450f, -0.13325654f, -0.01199403f, 0.07510544f, -0.10164963f, 
    0.40105718f, 0.07151742f, 0.24162360f, 0.23891416f, -0.09311712f, -0.09007034f, 0.02032088f, -0.47329947f, 
    -0.19519730f, -0.19506221f, 0.13615407f, 0.41107282f, 0.44305092f, -0.40299806f, -0.00930869f, -0.12493552f, 
    -0.22867429f, -0.16644418f, 0.09693136f, -0.27662653f, -0.44746715f, -0.07148966f, 0.25232381f, -0.05461044f, 
    0.10186162f, 0.07483109f, 0.17860860f, 0.22363740f, -0.13516344f, 0.19941020f, -0.08848863f, -0.39782369f, 
    -0.40264171f, -0.07593425f, 0.37878972f, -0.59508675f, -0.23180348f, -0.08742178f, 0.02195842f, 0.51864409f, 
    -0.09328391f, -0.41116160f, -0.04797223f, 0.16192038f, 0.00410548f, 0.23772134f, 0.17145105f, -0.45220748f, 
    0.10044301f, 0.04975936f, -0.27063385f, 0.05922662f, 0.18443689f, -0.00340648f, -0.79594147f, -0.10315690f, 
    0.16468768f, -0.58714050f, -0.16217953f, 0.31215778f, 0.12500390f, -0.91419804f, 0.16526565f, 0.10965996f, 
    -0.34790698f, -0.15048322f, -0.07042707f, -0.69208020f, -0.36675191f, -0.13705854f, 0.16072613f, 0.21340369f, 
    0.26836747f, 0.28434014f, -0.10888503f, -0.80543965f, -0.10980952f, 0.30431214f, -0.11114870f, -0.02471711f, 
    -0.01897107f, 0.00477389f, 0.09090139f, 0.15496247f, -0.29240444f, 0.15195248f, 0.02339193f, -0.08158334f, 
    -0.07740521f, -0.23221381f, 0.16489923f, -0.16822295f, 0.15644535f, -0.09622107f, -0.14837001f, -0.47748578f, 
    -0.56790471f, -0.06739409f, -0.17024145f, 0.08419460f, 0.42690355f, 0.06103700f, -0.15413810f, 0.05137077f, 
    0.08010992f, 0.25871694f, -0.09689735f, -0.10041717f, -0.19161290f, -0.41990754f, 0.03774505f, 0.16499428f, 
    -0.07455355f, 0.10960042f, -0.15562603f, -0.44298598f, 0.10727732f, 0.01645174f, 0.27938673f, -0.04026407f, 
    -0.04060629f, 0.13135149f, -0.15827894f, -0.15002733f, -0.12559335f, 0.14631586f, 0.12580724f, 0.13625132f, 
    -0.21263053f, -0.00014358f, 0.42488223f, 0.29867482f, -0.13142979f, 0.07330146f, 0.03170057f, -0.22258741f, 
    0.20421824f, -0.06702792f, 0.16131844f, -0.04573921f, -0.18176711f, -0.05462781f, -0.09919816f, -0.17208014f, 
    0.01914134f, -0.31481311f, 0.03227293f, 0.08855577f, -0.04542943f, 0.19765703f, 0.10462495f, -0.15162709f, 
    -0.08658120f, -0.14959806f, 0.20338877f, 0.04345629f, -0.03150228f, 0.06520169f, -0.05027971f, -0.40269053f, 
    -0.15100889f, 0.12366550f, -0.81047064f, -0.10660034f, -0.12864248f, -0.13397013f, -0.17140940f, 0.57376009f, 
    -0.95468366f, -1.08308268f, -0.15067835f, 0.12732300f, 0.00473024f, 0.23450747f, 0.01035621f, -0.43582579f, 
    -0.16152428f, 0.21871862f, -1.00867748f, 0.33923966f, 0.13358854f, -0.57162482f, -0.33268148f, -0.07936794f, 
    0.13937889f, 0.03853331f, 0.30199993f, -0.82894289f, -0.17177123f, -0.23113956f, -0.14336684f, 0.29200765f, 
    -0.16888179f, 0.12735701f, -0.81270707f, 0.26621825f, 0.04174855f, -0.15101653f, 0.03912725f, -0.37146768f, 
    -0.57555848f, -0.38481992f, 0.08168146f, 0.01270702f, -0.50327981f, -0.57143599f, 0.08482675f, 0.20663580f, 
    0.02659700f, -0.03297096f, -0.04959938f, -0.02914526f, 0.28346661f, 0.13393131f, -0.32166681f, 0.01525134f, 
    0.12143535f, 0.09505383f, -0.52916276f, 0.01745331f, -0.14017668f, 0.16439034f, 0.04106808f, 0.16491729f, 
    0.15851200f, 0.26442835f, 0.38563350f, -0.17168562f, -0.55190045f, -0.07304848f, -0.04093936f, -0.25355554f, 
    0.26481357f, -0.77356112f, -0.01978602f, 0.26814193f, -0.08136439f, 0.26232463f, -0.25796181f, -0.00676375f, 
    -0.10801897f, -0.43365526f, 0.19691730f, 0.15791495f, -1.02537906f, -0.65323889f, -0.73656672f, -0.07150704f, 
    0.02114299f, -0.41659141f, -0.05870883f, 0.28510094f, 0.09725691f, -0.09256563f, 0.13911775f, 0.05271389f, 
    -0.55512792f, 0.27526391f, -0.15864010f, -0.09616181f, 0.21423723f, -0.04355654f, 0.02295035f, -0.27098498f, 
    -0.02950771f, 0.15671843f, -0.10420375f, -0.73143601f, -0.13151318f, -0.31879717f, -0.61980522f, -0.80855048f, 
    0.27404916f, 0.14290069f, -0.63528568f, 0.28017417f, 0.26619670f, -0.35461766f, -0.54637784f, 0.11163904f, 
    -0.01583991f, 0.08234174f, 0.39046896f, -0.34150568f, 0.00348096f, -0.65097046f, -0.08219633f, -0.22683671f, 
    -0.22141187f, -0.00552005f, 0.19656581f, -0.53916013f, 0.12758219f, 0.13816419f, -0.03843042f, 0.05266840f, 
    -0.09417538f, -0.55391032f, 0.10049568f, 0.17191672f, 0.09745600f, 0.41665420f, 0.29006073f, 0.41488180f, 
    -1.08230281f, -0.69961905f, 0.00397336f, 0.00513348f, -0.22331144f, 0.23322336f, -0.08859481f, 0.06487135f, 
    -0.03157005f, -0.22485797f, -0.28611079f, 0.03918975f, 0.12114479f, -0.25404456f, 0.11167902f, -0.51704353f, 
    0.47002232f, -0.09132367f, -0.42107013f, 0.05663881f, 0.35177281f, 0.02320010f, -0.11051589f, -0.04262265f, 
    0.09664989f, 0.15829396f, -0.05888687f, -0.32145742f, -0.56896371f, 0.26904988f, -0.21004003f, 0.08603634f, 
    -0.40809950f, 0.28470266f, 0.20330480f, 0.03394490f, -0.30423853f, -0.58095145f, -0.35519207f, 0.02343273f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.35187250f, 0.19658805f, 0.09927855f, 0.14049247f, -0.14861274f, -0.25652510f, 0.09025379f, -0.05837215f, 
    -0.11060949f, 0.18866311f, -0.16707465f, 0.14594543f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
