#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.10585061f, -0.19760773f, -0.28505111f, 0.95750010f, -0.74803680f, -0.09218374f, -0.00038048f, 0.69093686f, 
    -0.25163892f, 1.12006700f, -0.54552376f, -0.35156271f, 0.57195622f, 0.09889983f, -0.17993267f, -0.26992270f, 
    0.12098650f, -0.41826811f, 0.27774817f, -0.50632179f, 0.38966951f, 0.76015931f, -0.10852374f, -0.55429298f, 
    -0.03661058f, 0.00956664f, 0.20367123f, 0.73049867f, 0.84114552f, -0.70587909f, -0.69280332f, -0.03615003f, 
    -0.27906898f, 0.15510364f, 0.34265855f, 0.36691812f, 0.24250858f, -0.47886470f, 0.86425644f, -0.32142562f, 
    0.17557539f, 0.26340833f, 0.48684660f, 0.36523131f, -0.27615362f, 0.29256853f, 0.19974141f, 0.15262103f, 
    0.76531237f, 0.64920038f, 0.41068169f, 0.27471402f, 0.04215871f, 0.10848157f, -0.54487574f, 0.32085496f, 
    0.20222905f, -0.24333028f, -0.97218508f, -0.98603374f, 0.29640776f, 0.35723466f, 0.15909089f, 0.64621150f, 
    0.07965662f, 0.91232747f, -0.88610989f, -0.53619516f, 0.50958318f, -0.00241868f, 0.01853854f, 0.26880324f, 
    0.26863849f, 1.04843986f, -0.66112840f, -0.48457411f, -0.47437334f, 0.11268044f, -0.54667610f, -0.59090775f, 
    -0.31681132f, 0.57048815f, -0.29678929f, -0.44713125f, -0.78268862f, 0.87173671f, -1.05628228f, 0.37962997f, 
    -0.28309280f, 0.41803297f, -0.78836679f, -0.60671091f, -0.59040773f, -0.00353391f, -0.14239754f, 0.39429516f, 
    0.52524924f, -0.09055802f, 0.71670580f, -0.21263622f, 0.31003767f, -0.32362112f, -0.52752233f, -0.13726152f, 
    0.30215195f, -0.75062299f, -0.09005742f, 0.81472248f, 0.50811434f, 0.40837717f, 0.43600392f, 0.04428328f, 
    0.40352377f, 0.58293778f, -0.31500804f, -0.51013011f, -0.05244157f, -0.99909818f, 1.03548932f, -0.47169259f, 
    0.35543054f, 0.55761993f, -0.37427491f, 0.43643069f, -0.03802095f, 0.10175660f, -0.95878160f, -0.37387294f, 
    -0.43324962f, -0.13585426f, 0.34208521f, -0.34710634f, -0.49116635f, -0.39723134f, -0.32484731f, 0.37280822f, 
    -0.64744753f, -0.39562559f, -0.57463676f, -0.61567289f, -0.40158162f, -0.03227632f, 0.57434338f, 0.25394133f, 
    0.15054351f, -0.73584414f, -0.83226132f, -0.58590353f, -0.09378343f, -0.10047263f, -0.09786271f, -0.47989079f, 
    -0.46906355f, 0.02712022f, 0.94995904f, -0.11445159f, -0.24426900f, 0.41545197f, 0.15483360f, 0.00981401f, 
    0.55555969f, -0.01237617f, -0.43120015f, -0.77194905f, -0.44334885f, 0.99441439f, 0.73587841f, -0.12447032f, 
    -0.28542593f, -0.30479091f, -0.55426639f, -1.16219807f, 0.57940817f, 0.70079970f, 0.12570754f, 0.26839730f, 
    0.12515993f, -0.02791107f, -0.38839170f, -0.31677192f, 0.23840073f, -0.69453090f, 0.35708433f, -0.71392882f, 
    -0.42775720f, 0.15413190f, -0.27816978f, -0.49611720f, 0.55189401f, -0.46854395f, -0.45225710f, -0.06110639f, 
    0.11603811f, -0.59120268f, -0.53997552f, -0.36015984f, 0.52561069f, 0.01247260f, 0.37396780f, 0.14679366f, 
    0.25899473f, -0.69237369f, 0.54173803f, 0.35555819f, -0.21631052f, -0.57664734f, -0.29939476f, -0.44425583f, 
    1.06085539f, -0.72477144f, 0.52116549f, -0.03505424f, 0.44263840f, -0.04641097f, -0.27681300f, 0.44665989f, 
    -0.50992465f, -0.43993720f, -0.73106563f, 0.72863013f, 0.22354503f, -0.07667972f, 0.50466532f, -0.38748989f, 
    -0.37629768f, 1.21889293f, -0.76421547f, -0.65667760f, 0.21484520f, 0.41679192f, 0.22149925f, 0.00409229f, 
    0.16102013f, -0.04241814f, 0.70742697f, 0.05471851f, 0.39303994f, 0.14304262f, 0.55597639f, -0.25582176f, 
    0.74403131f, 0.26025608f, -0.01593005f, -0.05529835f, 0.20242190f, -0.23398718f, -0.54419303f, -0.43288997f, 
    -0.53366417f, -0.75270456f, 0.62678933f, -0.87066734f, -0.85734600f, -0.43849865f, -0.51731461f, 0.75294852f, 
    0.05238228f, 0.36020926f, 0.06343056f, -0.09845586f, 0.02570387f, 0.63894850f, 0.51623666f, 0.08076283f, 
    0.42972520f, -0.84482449f, -0.38262278f, -0.02743020f, 0.18637185f, 0.04388738f, -0.38411728f, 0.04544275f, 
    0.14428021f, -0.20112334f, -0.31212914f, 0.12722902f, 0.18805091f, 0.63235331f, 0.67224973f, 0.35180503f, 
    -0.33471560f, 0.64673400f, -0.10698921f, 0.17404878f, -0.62436622f, 0.06430266f, -0.32979861f, -0.12956627f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.21561889f, 0.10228571f, 0.48166406f, -0.03348663f, -0.26196596f, 0.11620493f, 0.27057120f, 0.29683664f, 
    -0.34699646f, -0.06816764f, 0.77041876f, 0.03750496f, 0.16812763f, 0.11802288f, -0.21319178f, -0.17096223f, 
    0.22452182f, 0.48066360f, 0.07677055f, 0.08765373f, 0.58069783f, -0.22427800f, 0.15198262f, -0.03638431f, 
    0.51764715f, 0.48832178f, -0.05169303f, 0.29577181f, -0.03956688f, 0.22652026f, 0.29118866f, 0.38552061f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.07992738f, -0.21998942f, 0.37771899f, -0.30265105f, -0.01290721f, -0.34442994f, 0.05592081f, 0.19785151f, 
    0.03248229f, 0.04671046f, -0.39074069f, 0.19734354f, -0.12118994f, -0.17914765f, -0.05684137f, 0.11659183f, 
    0.06699332f, 0.18761382f, -0.17226356f, -0.48510686f, -0.01973603f, -0.08869266f, 0.00776765f, -0.10212693f, 
    0.09265748f, 0.14794071f, -0.07964206f, -0.32681331f, 0.34489405f, 0.00000793f, 0.14057824f, 0.08404814f, 
    0.15801492f, 0.03770212f, 0.08869453f, -0.11732151f, -0.06926348f, -0.00358595f, -0.19424132f, -0.18354137f, 
    0.04481377f, -0.03095140f, 0.10322872f, 0.10919839f, -0.07858294f, 0.17602824f, 0.25495175f, 0.46584386f, 
    -0.14836478f, -0.13999715f, -0.03888167f, -0.16073306f, 0.00598623f, -0.02765609f, 0.46962351f, 0.43229732f, 
    0.01877898f, -0.19830179f, 0.10256033f, 0.04073531f, 0.04168202f, -0.08886036f, -0.03246198f, -0.34643701f, 
    0.04739394f, -0.48393232f, 0.19004400f, 0.12333731f, 0.13599057f, 0.03237565f, 0.07028977f, 0.09253795f, 
    -0.06510320f, -0.30174035f, -0.16528690f, 0.01433188f, -0.06850491f, 0.05943957f, -0.01408662f, 0.06706287f, 
    0.02496362f, -0.07288910f, 0.39809138f, 0.40046486f, -0.12168153f, 0.05020713f, 0.06349053f, -0.11591999f, 
    0.19191833f, -0.02708320f, 0.12714507f, 0.12772991f, 0.37600404f, 0.05603708f, -0.09303024f, -0.05504172f, 
    0.07266194f, 0.05893538f, 0.11086557f, -0.57072902f, 0.21072432f, -0.85601950f, 0.02348123f, -0.04415316f, 
    -0.19084184f, 0.07029109f, -0.03305579f, 0.17885421f, -0.19826269f, -0.04160994f, 0.12940924f, 0.05378785f, 
    -0.20028993f, 0.11452606f, 0.05819161f, 0.00672742f, 0.15664098f, -0.11323057f, -0.19596246f, -0.08108793f, 
    0.01794191f, 0.21719824f, -0.25363827f, -0.01336185f, -0.02608543f, 0.11154108f, -0.03700390f, -0.01531421f, 
    -0.06331981f, 0.07513218f, 0.11199623f, 0.06638836f, 0.16356191f, 0.04156620f, -0.01121494f, 0.03966834f, 
    0.42398578f, 0.41585550f, -0.18853219f, -0.31739762f, 0.09205359f, 0.00749532f, -0.09250282f, -0.06712604f, 
    0.04607240f, -0.09607786f, -0.02024050f, 0.10992142f, -0.04349982f, 0.05648657f, -0.02233823f, -0.11600403f, 
    -0.04348180f, -0.20215145f, 0.18876797f, -0.17392343f, 0.03195501f, 0.10881337f, 0.01232788f, 0.24391870f, 
    0.00242070f, -0.02025627f, 0.06500614f, -0.12210516f, 0.07359526f, -0.19327238f, -0.17453822f, -0.36613387f, 
    0.09864807f, -0.02868002f, 0.05963039f, -0.60370767f, 0.05712431f, -0.45682463f, -0.15702048f, 0.10022547f, 
    -0.15580179f, -0.01591226f, 0.00725595f, -0.02935649f, -0.26247939f, 0.34499991f, -0.07344799f, 0.01702526f, 
    0.03893280f, 0.05788267f, -0.08007295f, 0.15676363f, -0.06615809f, 0.09747422f, 0.21946383f, 0.16955419f, 
    -0.19267066f, -0.06510372f, 0.05682391f, 0.10473129f, -0.01194076f, 0.01029176f, -0.05734615f, -0.29570556f, 
    -0.10593665f, 0.12097549f, -0.09777791f, 0.07673223f, 0.04961482f, 0.06852175f, 0.03415091f, -0.03298517f, 
    0.07738822f, 0.15861540f, -0.26662517f, -0.08249431f, -0.08082297f, 0.06486433f, -0.10134135f, -0.16345258f, 
    0.18190208f, -0.07059915f, 0.32308385f, -0.04721734f, 0.01180605f, -0.21446316f, 0.00044190f, -0.03821160f, 
    0.13574059f, -0.15382130f, -0.21356994f, 0.10119221f, -0.09530939f, -0.18383890f, 0.06405716f, -0.02903305f, 
    0.10555102f, 0.20934349f, 0.11703338f, 0.00694660f, -0.04954435f, -0.14350657f, 0.13844809f, 0.01458602f, 
    0.17963673f, 0.10914119f, 0.06399980f, -0.08802133f, 0.24805133f, 0.18710625f, -0.01839745f, -0.01498250f, 
    -0.05659578f, 0.07770978f, 0.05136171f, -0.03889649f, -0.05335276f, 0.15930220f, 0.37529853f, -0.20997037f, 
    -0.19440669f, -0.28778905f, 0.06515718f, -0.10796688f, 0.00217530f, -0.18662289f, -0.11303428f, -0.09410215f, 
    0.15066974f, 0.05116351f, 0.03071668f, -0.00118928f, -0.02301540f, 0.02183273f, 0.09563212f, 0.14828403f, 
    -0.09715769f, 0.10003620f, -0.08874596f, 0.12795973f, 0.11385500f, -0.15534826f, -0.22549877f, -0.00093475f, 
    -0.19726084f, 0.04960436f, 0.00341963f, 0.15577006f, 0.07374343f, 0.12240381f, 0.15427443f, -0.02238986f, 
    -0.10135459f, 0.04518317f, 0.00784297f, 0.10625079f, 0.19425645f, 0.08798588f, 0.23904806f, -0.01421964f, 
    -0.16489123f, 0.20802242f, 0.14585288f, 0.12025716f, 0.13708568f, 0.02226479f, 0.06862483f, 0.04677724f, 
    0.33655310f, 0.16590120f, 0.23710564f, 0.12882648f, -0.03717300f, 0.18792222f, 0.14453778f, 0.10484604f, 
    0.12483571f, 0.13458568f, -0.12535599f, 0.11972059f, 0.09091461f, -0.21362174f, 0.01862980f, -0.03086121f, 
    0.03371436f, 0.08961785f, -0.11927017f, 0.01134354f, 0.21492079f, -0.04226871f, 0.00737195f, -0.04765852f, 
    -0.20565780f, 0.08866327f, -0.11501268f, 0.11086043f, -0.17683251f, 0.22567393f, 0.16804096f, 0.12753969f, 
    0.01624286f, -0.21324313f, -0.04652419f, 0.06593848f, -0.07725579f, -0.05589328f, -0.73608744f, -0.34222740f, 
    0.03441050f, 0.09811239f, 0.10791909f, 0.09711071f, -0.12636082f, -0.13792968f, 0.12322339f, 0.34466571f, 
    -0.10196282f, -0.02537478f, -0.01792534f, 0.01365291f, -0.02468680f, 0.08627632f, 0.04768823f, -0.02499590f, 
    -0.24694234f, -0.08937823f, 0.14951332f, -0.08162538f, 0.08284023f, 0.07974070f, 0.00152170f, -0.11455812f, 
    -0.01012046f, -0.25065467f, 0.48237422f, 0.02407022f, 0.08202004f, 0.06784713f, 0.02131802f, 0.00412590f, 
    0.02716663f, -0.05181269f, -0.10742175f, -0.23668920f, -0.35385358f, 0.09960040f, 0.12119420f, 0.11514702f, 
    0.06088275f, -0.07519737f, -0.04021392f, -0.07430888f, 0.10239748f, 0.12605354f, 0.12795474f, 0.08855394f, 
    -0.02009778f, -0.22432756f, 0.07465687f, 0.23887694f, 0.21258599f, 0.11814332f, 0.12653695f, 0.11013168f, 
    0.00057740f, 0.07617676f, 0.08849585f, -0.00490959f, 0.21155253f, 0.29543605f, 0.12992023f, -0.21791746f, 
    -0.20739524f, 0.33644578f, 0.15446922f, 0.12850241f, -0.06009598f, -0.02766144f, 0.20544362f, -0.46199948f, 
    -1.50970566f, -0.00697313f, -0.09963339f, 0.09679852f, 0.26554102f, -0.00310910f, -0.07852360f, 0.21235356f, 
    -0.10268915f, -0.30451614f, -0.02003671f, 0.04741415f, 0.12017805f, -0.08793736f, -0.11589067f, 0.08132342f, 
    -0.25304782f, -0.62886053f, -0.37510261f, 0.00037130f, 0.06281827f, 0.08665889f, 0.09388980f, 0.09618197f, 
    0.03651527f, 0.26085198f, 0.14656025f, 0.02909721f, -0.09255989f, -0.01377652f, 0.07777090f, 0.02709575f, 
    -0.06522962f, -0.05879386f, -0.30926496f, -0.65555155f, -0.47757134f, -0.13936371f, -0.15169062f, 0.17381710f, 
    0.00973088f, -0.00676651f, 0.04277116f, 0.00463433f, 0.14864567f, 0.02333774f, -0.16606231f, 0.05209578f, 
    0.07495584f, 0.15032926f, 0.04245918f, 0.10969336f, -0.03349933f, -0.18706100f, 0.03497994f, 0.03818956f, 
    0.24189967f, -0.06318603f, -0.02239657f, 0.04247735f, -0.02335355f, 0.03525114f, -0.36229599f, 0.04420359f, 
    0.01276993f, -0.00927182f, 0.00643017f, -0.07581130f, -0.18611920f, 0.19594529f, 0.14984386f, 0.20660461f, 
    0.09227617f, 0.08207539f, 0.12863424f, 0.10117553f, 0.14926533f, -0.03527462f, 0.26933405f, 0.10355413f, 
    0.00796588f, -0.17557205f, -0.18014587f, 0.01055660f, 0.08487046f, -0.12323201f, -0.03366285f, -0.05479599f, 
    -0.21801236f, -0.55545217f, -0.35379010f, -0.10320124f, -0.10998098f, 0.02383350f, 0.05537428f, 0.09822537f, 
    -0.05440123f, 0.20364168f, 0.14242856f, 0.19038510f, 0.07368218f, 0.00360727f, -0.00632543f, 0.16424331f, 
    0.12161706f, -0.02214794f, 0.24378870f, 0.13179058f, 0.02804303f, 0.04231011f, -0.11719075f, 0.05423773f, 
    0.12698111f, 0.04872060f, -0.12279624f, -0.27441677f, -0.10402475f, -0.11619061f, -0.00325217f, 0.04877992f, 
    -0.01647346f, 0.11596636f, -0.01675150f, -0.17472211f, -0.01461274f, -0.59383243f, -0.76300693f, -0.27398574f, 
    -0.23888573f, -0.13946268f, 0.10172457f, -0.11165066f, -0.04272822f, 0.11037488f, -0.00458442f, -0.04160700f, 
    0.03864641f, -0.03523488f, -0.00600427f, 0.20594096f, -0.00220166f, 0.01007788f, 0.05629919f, -0.09187273f, 
    0.03914373f, 0.00998365f, 0.09942713f, 0.06965375f, -0.07776655f, -0.08582927f, 0.05380499f, 0.26873043f, 
    0.05954482f, -0.08637401f, 0.03624232f, 0.12853578f, -0.03284074f, 0.08431350f, 0.06424589f, 0.03025566f, 
    -0.00102356f, -0.05089544f, 0.02309556f, -0.00130698f, 0.04552174f, 0.04002625f, 0.01213053f, 0.02243592f, 
    0.00350495f, -0.01192173f, -0.01319053f, -0.05809456f, 0.04360836f, 0.03826248f, -0.01408850f, 0.00098634f, 
    0.04968825f, -0.03193572f, 0.04829822f, 0.03069346f, -0.05240129f, 0.02692668f, 0.01885604f, -0.02501101f, 
    0.02553092f, -0.05942426f, -0.05924298f, -0.02186543f, -0.05035106f, 0.01366513f, 0.00943691f, -0.02321322f, 
    -0.06392688f, -0.01021050f, -0.01130836f, 0.02250625f, -0.03928436f, -0.01219120f, 0.01765748f, 0.02297419f, 
    -0.03019325f, 0.00268972f, 0.02613289f, -0.05390950f, -0.05484742f, 0.04911427f, -0.01668019f, -0.00636259f, 
    -0.03291230f, -0.02811915f, 0.00805961f, -0.03272907f, -0.00931485f, 0.01089062f, 0.04985268f, 0.04642930f, 
    0.04877615f, 0.04027401f, 0.02973177f, -0.01339699f, 0.04728624f, -0.05002782f, 0.03724286f, 0.01411642f, 
    0.03576197f, 0.04273139f, 0.04608145f, 0.01511304f, -0.02171951f, 0.01493865f, 0.00522990f, -0.00998859f, 
    0.04117661f, 0.01689956f, -0.01788317f, 0.03230644f, -0.02356118f, 0.01511184f, -0.01947670f, -0.04822909f, 
    0.01817243f, 0.05227800f, -0.05744810f, 0.05024348f, -0.00053153f, -0.04293666f, -0.01055909f, -0.00874309f, 
    -0.00001088f, -0.04698068f, -0.01460227f, 0.03723436f, 0.04856390f, -0.04032468f, -0.05022231f, 0.01598866f, 
    -0.04403266f, -0.00978856f, -0.03105628f, -0.06000967f, 0.04512246f, -0.03860554f, -0.06266259f, -0.05478991f, 
    -0.04848582f, 0.04893932f, -0.05534876f, -0.07080718f, 0.03915619f, -0.02982223f, -0.03994564f, -0.05234847f, 
    0.02246245f, -0.02779765f, 0.04533816f, -0.04618459f, 0.03897255f, 0.02988145f, 0.01659033f, -0.03684295f, 
    -0.03401331f, 0.00292919f, 0.03371963f, -0.00622273f, 0.02224107f, -0.01684090f, -0.00334744f, -0.02527591f, 
    0.02432308f, 0.04550467f, -0.05006706f, -0.05360428f, 0.04528735f, -0.05564997f, -0.04589645f, 0.03885948f, 
    -0.02837186f, 0.02572271f, 0.01194706f, -0.03888813f, -0.03835709f, 0.02671993f, -0.04999929f, -0.05739525f, 
    0.00769456f, -0.04654925f, 0.02059302f, -0.01285106f, 0.02387086f, -0.05303558f, 0.04744875f, 0.02458248f, 
    -0.00729256f, -0.01856394f, 0.02686019f, -0.01050938f, -0.05748420f, -0.01238715f, -0.05963896f, 0.02056718f, 
    -0.03544198f, -0.06587756f, -0.00363182f, -0.05292603f, -0.05173229f, 0.02892332f, -0.04187115f, -0.02655045f, 
    -0.05267137f, 0.02241947f, 0.00109678f, 0.03570260f, -0.02758361f, -0.00435796f, 0.03804638f, -0.02100994f, 
    -0.05654922f, -0.01979658f, 0.04344570f, 0.02332859f, 0.01933451f, 0.04965714f, -0.00824734f, -0.01193815f, 
    0.00596789f, 0.04013294f, -0.05116848f, 0.00940068f, -0.02522884f, 0.00202753f, -0.02892954f, 0.01035498f, 
    0.00405994f, 0.00737649f, 0.01992972f, -0.06253775f, -0.05650282f, -0.00620947f, 0.03286026f, -0.06581956f, 
    -0.03689393f, 0.02285678f, -0.01224558f, 0.04467823f, -0.02522022f, -0.05063717f, 0.00129966f, 0.01610164f, 
    -0.05364203f, -0.00051075f, -0.01849584f, -0.03155250f, -0.04137458f, 0.04702978f, 0.04534986f, 0.03905024f, 
    -0.05500529f, -0.03477448f, 0.02875229f, -0.05933771f, 0.03452615f, -0.03094769f, -0.01171450f, 0.01459796f, 
    -0.05241185f, -0.05893345f, 0.04633429f, -0.05492997f, -0.02830462f, 0.02076164f, 0.02329395f, 0.00670094f, 
    -0.03831996f, -0.02557787f, -0.02200440f, -0.02196199f, 0.00026219f, 0.00285544f, 0.01975439f, 0.03399523f, 
    -0.02465950f, 0.04645340f, -0.07085263f, 0.02356184f, -0.04982328f, -0.01995961f, -0.05824869f, -0.06250592f, 
    -0.06081515f, -0.03974827f, -0.03442687f, 0.03877976f, -0.06134147f, 0.04984754f, 0.03432888f, -0.01559589f, 
    0.05190879f, -0.04203493f, -0.00702909f, -0.06230595f, -0.03206731f, 0.01531936f, -0.03626691f, 0.03001975f, 
    -0.04239656f, -0.00305222f, -0.06364642f, 0.00488366f, 0.02640326f, 0.04844217f, 0.02166774f, 0.03965343f, 
    0.00771159f, -0.02153946f, -0.05573779f, 0.02575454f, -0.03784280f, 0.00101078f, 0.02927509f, -0.05689326f, 
    -0.04459716f, 0.01923051f, 0.03807585f, 0.04743953f, -0.00983109f, 0.02446253f, 0.04453834f, 0.00269493f, 
    -0.01503115f, -0.19800609f, 0.06551747f, 0.00825459f, -0.12527111f, 0.05631130f, -0.02918252f, 0.00959103f, 
    -0.22899882f, 0.82858616f, -0.75518805f, -0.70216525f, -0.08736879f, -0.14767227f, -0.20155823f, 0.17398782f, 
    -0.03955545f, -0.06845693f, -0.05542471f, -0.46009737f, -0.27598670f, -0.04474791f, -0.07273453f, 0.10186356f, 
    0.18088993f, 0.00374079f, 0.06656565f, -0.30157259f, -0.58937252f, -0.94338763f, 0.03566414f, 0.10502465f, 
    -0.01017066f, 0.05206602f, 0.07126996f, 0.12267905f, -0.25572202f, 0.24107972f, -0.50957423f, 0.03745142f, 
    0.15509389f, 0.12821601f, -0.01975146f, 0.08333481f, 0.04186877f, 0.31452650f, 0.27175832f, -0.50983620f, 
    -0.38916343f, -0.31192660f, -0.04443188f, 0.05336341f, 0.08637559f, 0.11778416f, -0.05741575f, 0.16985638f, 
    0.14037713f, -0.22059552f, -0.24677739f, -0.07158031f, -0.12940203f, 0.23089416f, 0.14639235f, 0.10727854f, 
    -0.11013383f, 0.21887515f, -0.07034412f, -0.06439222f, -0.11820146f, -0.02453290f, 0.04593822f, 0.02167295f, 
    -0.06842732f, 0.22436798f, 0.15048292f, 0.00951472f, 0.07375392f, 0.08481762f, 0.12300105f, 0.04402232f, 
    -0.18746856f, -0.26162291f, 0.03127234f, 0.09022987f, -0.07476978f, -0.09785238f, -0.19588998f, 0.08945222f, 
    0.05779114f, 0.12980931f, 0.13232419f, -0.04052426f, 0.01104376f, -0.05097088f, -0.03729808f, -0.01256994f, 
    -0.03438964f, 0.09077038f, 0.09994282f, -0.45979977f, -0.31688479f, 0.15198462f, -0.01111894f, -0.03777117f, 
    0.13190176f, 0.10046951f, -0.00147524f, 0.21049693f, 0.19461955f, 0.18810178f, -0.01077908f, -0.20002943f, 
    -0.26017982f, -0.11963615f, -0.04250244f, 0.13167821f, -0.02745840f, -0.41087833f, 0.07324575f, -0.06559899f, 
    -0.11230328f, -0.10022559f, 0.17556873f, 0.09159471f, -0.10408083f, 0.01902607f, 0.10352883f, 0.04705818f, 
    0.35154304f, -0.00867565f, 0.04396951f, 0.13936855f, 0.08348399f, 0.02279509f, -0.00855092f, 0.14602053f, 
    0.28290424f, 0.14826325f, -0.22525644f, -0.09197738f, -0.13151410f, 0.11819576f, 0.03253356f, 0.13523608f, 
    0.08102766f, 0.05241548f, 0.21228033f, 0.10758132f, 0.14649749f, 0.08146820f, 0.11818964f, -0.00231266f, 
    -0.15759826f, 0.09350736f, -0.77036971f, -0.24753809f, 0.06880822f, 0.23263969f, 0.22754970f, 0.11751381f, 
    0.22619480f, -0.00542279f, 0.15402086f, -0.15665387f, 0.12233486f, -0.00750637f, 0.01833945f, -0.03498720f, 
    0.25733155f, 0.07075221f, 0.12586085f, -1.14445281f, -0.63139063f, -0.20095341f, 0.04043410f, -0.20777991f, 
    -0.11645995f, 0.24019673f, 0.02950223f, -0.06431438f, -0.01526771f, 0.04915535f, 0.29266885f, -0.13418333f, 
    0.07138199f, -0.04508791f, -0.07079624f, -0.09637754f, 0.02564970f, 0.27092689f, 0.32434002f, 0.34973830f, 
    -0.13520434f, -0.04795487f, 0.05193574f, -0.14200714f, -0.08522586f, 0.01855258f, -0.08896045f, 0.10083348f, 
    0.11311679f, 0.06495603f, -0.07190976f, -0.12020337f, 0.14787278f, 0.09245519f, -0.18275526f, 0.04885653f, 
    -0.33548087f, -0.51295388f, -0.17463273f, -0.36771977f, 0.28237915f, -0.06375785f, 0.01180924f, 0.00640713f, 
    0.17510757f, -0.10074035f, -0.17768534f, 0.00131081f, 0.15968022f, 0.02222412f, 0.09156095f, 0.08967530f, 
    0.01169047f, 0.63625014f, -0.42959240f, -0.50213557f, 0.15292186f, -0.07904427f, -0.24285120f, -0.03475536f, 
    -0.01918844f, 0.02488811f, -0.37404436f, 0.45876306f, -0.42871830f, 0.17041904f, 0.15881406f, 0.15357353f, 
    -0.09080831f, 0.18640469f, 0.00689961f, -0.14323674f, 0.06041888f, 0.11905648f, -0.03205885f, 0.13183990f, 
    -0.06036012f, -0.01087002f, 0.05310339f, -0.04949412f, 0.36446559f, -0.02512014f, 0.09239516f, -0.11278667f, 
    0.06619666f, 0.16046219f, 0.05535740f, 0.09508357f, -0.05970225f, 0.17362212f, -0.57067132f, -0.60373884f, 
    -0.15639816f, -0.02155093f, -0.20560384f, -0.11364873f, 0.15612528f, 0.15093218f, -0.10475877f, 0.06204253f, 
    0.06952108f, 0.10561536f, 0.14050192f, 0.01581743f, 0.04341618f, 0.14361781f, 0.14241646f, 0.18627927f, 
    -0.31056923f, -0.58290148f, -0.16164802f, -0.21644107f, -0.10185125f, -0.01058559f, 0.02463215f, -0.11874063f, 
    -0.14894897f, -0.18239307f, 0.14168766f, -0.07270029f, -0.12751614f, -0.08390728f, -0.22915268f, -0.34057042f, 
    0.26569894f, 0.00172454f, -0.10616046f, -0.09249926f, 0.06787564f, 0.05939879f, -0.16916147f, 0.07047097f, 
    0.01177588f, 0.09504052f, -0.10775397f, -0.04425986f, -0.06926642f, 0.01760949f, 0.05112627f, 0.06001442f, 
    0.06366084f, 0.04900444f, 0.02363897f, 0.02584548f, -0.02389063f, -0.33170134f, -0.05306911f, 0.00632203f, 
    -0.01160711f, 0.03634593f, -0.23402625f, -0.39730397f, 0.16534995f, 0.16862801f, 0.13441595f, 0.03641839f, 
    0.04491155f, -0.23556711f, 0.00940501f, -0.19087264f, -0.03746158f, 0.02655229f, -0.20096059f, -0.41268846f, 
    -0.00391436f, -0.13688271f, -0.03788986f, -0.04417408f, -0.00187541f, 0.19290365f, 0.17674564f, 0.17479433f, 
    0.23721248f, -0.13607414f, -0.11430499f, -0.14598599f, -0.11261110f, -0.29839310f, -0.11136632f, -0.22911835f, 
    -0.22519663f, 0.04506000f, 0.05974742f, -0.13976350f, 0.04374816f, 0.01955652f, 0.13913310f, -0.00499643f, 
    -0.20370790f, 0.35666516f, -0.13825685f, 0.02092004f, -0.18472481f, 0.08716477f, 0.14365432f, 0.04203759f, 
    -0.10437123f, -0.12880337f, 0.26009065f, 0.25430754f, -0.24269088f, -0.02326867f, 0.14861703f, 0.00922175f, 
    -0.13440588f, -0.10167292f, 0.07918441f, 0.06873363f, 0.29699245f, 0.13871925f, 0.19081989f, 0.16244845f, 
    0.04579255f, 0.11429811f, -0.06480630f, -0.32614979f, -0.04476430f, -0.14754891f, 0.13351730f, 0.12563980f, 
    0.01275173f, 0.03335453f, 0.08264967f, -0.28601667f, 0.02621180f, -0.18512349f, -0.35754088f, 0.29671106f, 
    -0.08363869f, -0.00922326f, 0.07698271f, 0.13145693f, 0.14527236f, 0.05210601f, 0.03818738f, -0.03799510f, 
    -0.18870711f, 0.02825956f, 0.03936096f, -0.00588570f, 0.07294158f, -0.10237531f, 0.06516553f, -0.04944655f, 
    0.12696807f, 0.11039129f, 0.14282344f, 0.12905346f, -0.04049399f, 0.08175988f, 0.17080407f, 0.01786601f, 
    0.66926253f, 0.22878501f, 0.01462087f, 0.08602978f, -0.28375950f, 0.15844281f, -0.19456552f, -0.16252600f, 
    0.08037377f, 0.20919804f, 0.27301341f, 0.01014116f, 0.09615351f, -0.08955856f, 0.09133557f, 0.01368456f, 
    -0.06074416f, 0.02812887f, -0.23939012f, -0.19836061f, -0.02726205f, 0.04912475f, 0.09048104f, 0.09282549f, 
    0.01257478f, -0.10302304f, 0.08968467f, -0.16006042f, 0.01672413f, 0.15587968f, 0.07401104f, -0.13525331f, 
    0.11655688f, 0.08318272f, 0.17402810f, 0.00937391f, 0.06211998f, 0.15725264f, 0.00546392f, -0.25978664f, 
    0.07945034f, 0.16244161f, 0.14334004f, 0.20607971f, -0.07037622f, 0.44615403f, 0.13770063f, 0.18998568f, 
    0.17095335f, -0.08141749f, 0.04795148f, 0.18844658f, -0.11990626f, -0.08921497f, 0.14688925f, 0.27128965f, 
    -0.01431968f, 0.23371898f, -0.02229612f, -0.00515320f, -0.09869658f, 0.05669323f, -0.03014694f, -0.13344097f, 
    -0.03777508f, 0.19108434f, -0.05465638f, 0.04865140f, -0.01343623f, 0.06446116f, 0.15609924f, -0.06045711f, 
    -0.00055878f, -0.51319408f, -0.16463256f, -0.05883338f, 0.14692089f, -0.17201611f, 0.05013926f, 0.04263890f, 
    0.07485329f, 0.01684748f, 0.04188188f, 0.14805076f, 0.12075998f, 0.08662768f, 0.06685510f, 0.01367988f, 
    0.13015398f, -0.12299792f, -0.07528055f, -0.16665478f, 0.01635281f, -0.12432501f, 0.05771612f, 0.11735377f, 
    0.17910351f, 0.05328970f, -0.04534319f, -0.11976992f, 0.05495648f, 0.11116323f, 0.00759892f, -0.06776235f, 
    -0.05760968f, -0.28030160f, 0.06279873f, -0.22178863f, 0.14322144f, 0.28750527f, 0.04082124f, 0.13358165f, 
    0.11641003f, 0.04169580f, -0.03247395f, -0.05668986f, -0.01534023f, -0.19497104f, 0.23777151f, -0.01643058f, 
    0.14440911f, 0.15620816f, -0.08766042f, 0.10660924f, 0.05705367f, 0.02793133f, -0.21244653f, -0.09873709f, 
    -0.11995330f, -0.01709737f, 0.04010559f, -0.21164306f, -0.10310294f, -0.01606947f, 0.04445590f, 0.09345020f, 
    0.13680814f, -0.04135885f, -0.04745786f, -0.09621161f, -0.07281954f, -0.21174988f, -0.28326899f, 0.05106035f, 
    -0.14793676f, 0.12697408f, 0.04471880f, 0.10093178f, 0.11762983f, 0.06583077f, -0.11627464f, 0.00276499f, 
    0.01626630f, -0.00310039f, -0.02354823f, -0.00896731f, -0.03826492f, 0.02899709f, 0.03650753f, 0.02456809f, 
    0.00610241f, -0.06081310f, -0.03810881f, -0.03456043f, 0.03486539f, -0.00224507f, -0.00282770f, -0.06521369f, 
    0.01159476f, -0.06082373f, -0.00678368f, -0.00602718f, -0.00163940f, -0.01457982f, 0.01273986f, 0.02089752f, 
    0.05190661f, -0.05329978f, -0.03354977f, -0.00200890f, -0.05333477f, -0.03404014f, -0.00860386f, 0.03385073f, 
    -0.05502913f, -0.02711731f, 0.01127348f, -0.01850493f, -0.00083608f, -0.05463906f, -0.05441239f, 0.03305793f, 
    -0.02404206f, -0.03764043f, -0.00425273f, 0.04519138f, -0.03095480f, -0.01441563f, -0.03677524f, 0.02842355f, 
    -0.02785544f, 0.02954626f, 0.01248017f, -0.00720112f, 0.03572932f, -0.06793362f, -0.01503118f, -0.00323292f, 
    0.00377227f, 0.04090111f, 0.02680830f, 0.03891151f, -0.06110891f, 0.03387718f, -0.00921913f, -0.03648904f, 
    0.00677691f, -0.03664078f, -0.05683364f, -0.01729327f, -0.04880647f, -0.00103057f, -0.03933141f, -0.01043552f, 
    -0.06518863f, 0.01320165f, 0.00752123f, -0.01020330f, -0.04459478f, 0.03020746f, -0.03241618f, 0.01296085f, 
    -0.06407054f, 0.04799829f, 0.01058919f, -0.01707838f, 0.03821789f, 0.01570593f, -0.04078266f, -0.00101058f, 
    -0.00690621f, 0.00327971f, -0.05859838f, 0.01681205f, 0.03238941f, -0.00440055f, -0.06547626f, 0.04135706f, 
    -0.06476328f, -0.04616388f, -0.00365180f, -0.03696813f, 0.00081600f, -0.05400058f, -0.04027813f, -0.04083444f, 
    -0.03837813f, 0.00520946f, 0.02586628f, 0.03729116f, -0.03400964f, 0.02267232f, -0.04141154f, 0.01320777f, 
    0.04271141f, -0.02982366f, 0.02282323f, -0.06352762f, -0.03904365f, 0.03961941f, -0.01568775f, -0.03216154f, 
    -0.02244467f, 0.03736478f, 0.03599390f, -0.03306557f, 0.01858786f, 0.00708360f, 0.01855813f, 0.00611445f, 
    0.04931173f, -0.05792434f, -0.03162008f, 0.00897483f, 0.00180486f, -0.01449865f, 0.01951334f, 0.05039093f, 
    0.02553431f, -0.05061214f, -0.01417336f, 0.00229414f, -0.06842212f, 0.00306105f, -0.02050027f, 0.03861313f, 
    -0.02938771f, -0.04974897f, -0.02018789f, -0.01627294f, -0.00691596f, -0.02891988f, 0.00671885f, -0.04529407f, 
    0.02317243f, -0.01088994f, -0.05773377f, -0.01372647f, 0.00453254f, 0.03985108f, -0.00641116f, 0.05136336f, 
    -0.03742033f, 0.03854218f, 0.02396935f, 0.00321333f, 0.00186732f, -0.02049986f, -0.06158321f, -0.06457619f, 
    0.04289839f, 0.03647001f, 0.03568529f, 0.01003735f, -0.01641821f, 0.03844450f, 0.00075951f, -0.02284333f, 
    -0.00947835f, -0.06008588f, -0.02868695f, -0.00782574f, 0.01366416f, -0.05799843f, -0.02217940f, -0.03825381f, 
    -0.00552603f, -0.02011527f, -0.00330832f, 0.02342129f, -0.01434476f, 0.00638643f, 0.04569221f, -0.06119026f, 
    0.01537761f, -0.04729613f, -0.00533815f, -0.01506850f, -0.06703407f, 0.02971526f, -0.01019413f, 0.04776354f, 
    -0.03568598f, 0.04967831f, -0.03590569f, -0.02888234f, 0.04163181f, -0.05384342f, -0.05508715f, -0.01517187f, 
    0.00468960f, 0.02697300f, -0.02991187f, 0.05059585f, 0.05156067f, -0.00208877f, -0.04745930f, -0.04312350f, 
    -0.01099332f, 0.02218577f, 0.01585340f, -0.03088342f, -0.00162660f, -0.05855697f, 0.01534795f, -0.05808984f, 
    -0.03000658f, 0.04802724f, 0.00536847f, -0.01333396f, 0.01055064f, -0.03564545f, -0.02469057f, 0.02443745f, 
    0.04198338f, -0.03222297f, 0.00670832f, 0.04185403f, -0.02313754f, -0.06173363f, -0.06038919f, -0.00506362f, 
    0.01336283f, -0.00127927f, -0.03805914f, 0.04083634f, 0.01752227f, -0.06344950f, -0.02765539f, 0.01221573f, 
    0.04394008f, -0.02116635f, -0.02216961f, 0.02824775f, 0.02980832f, -0.01952357f, 0.01740776f, -0.05852444f, 
    0.01311172f, 0.03386635f, 0.04198683f, -0.01127035f, 0.04102883f, -0.04273304f, 0.04727338f, -0.06163419f, 
    -0.05338784f, -0.01784700f, -0.00070994f, -0.06281175f, -0.01221949f, 0.04703868f, 0.01068897f, 0.04835679f, 
    0.02919577f, -0.04997137f, -0.05969249f, -0.00202588f, 0.04629967f, -0.01161239f, -0.04246559f, -0.06391378f, 
    0.04080216f, 0.03701756f, 0.02298371f, 0.01427830f, -0.05069739f, 0.04679222f, 0.00843110f, -0.01721231f, 
    0.09006853f, 0.12443948f, -0.25061756f, 0.12419474f, 0.29121023f, 0.09191542f, -0.06667417f, 0.03705769f, 
    0.06253733f, 0.01597541f, -0.09247452f, 0.07735450f, 0.22100778f, 0.07807314f, -0.11761616f, 0.05164822f, 
    -0.27833995f, -0.13125931f, -0.02644810f, 0.10857300f, 0.12659964f, 0.06760195f, -0.12866946f, 0.16154875f, 
    -0.01862681f, -0.16277838f, 0.18548401f, 0.16026127f, 0.11186992f, 0.17651859f, -0.02870912f, 0.15894832f, 
    -0.05863811f, 0.02786365f, 0.22038235f, 0.04055399f, 0.02100872f, 0.43349633f, 0.20960882f, -0.13055420f, 
    0.16300884f, 0.00003878f, 0.05719189f, 0.19392662f, -0.16028941f, 0.02406973f, -0.04747116f, 0.03704191f, 
    0.09493308f, -0.03983090f, -0.02118182f, -0.07494780f, 0.13505752f, 0.00504387f, 0.17356382f, 0.21822518f, 
    -0.03431932f, 0.07413165f, -0.02362048f, 0.06636058f, 0.02298307f, 0.15546322f, 0.13237619f, -0.09246131f, 
    0.12332900f, 0.38850912f, 0.05381690f, 0.10883098f, 0.05923804f, 0.02528303f, 0.02214288f, -0.01930327f, 
    -0.03355425f, 0.09034620f, -0.11334855f, 0.13441691f, -0.02205165f, 0.08763630f, -0.17747065f, 0.08501052f, 
    -0.20290126f, 0.01079662f, -0.03329312f, -0.00180155f, -0.20825927f, 0.07982697f, 0.10555864f, 0.07772607f, 
    0.25067836f, 0.13946843f, -0.17651604f, -0.00248504f, -0.06896844f, -0.03441261f, -0.04643859f, -0.09108731f, 
    -0.03512484f, -0.06207702f, 0.12052384f, 0.30030516f, -0.04896316f, 0.25867748f, -0.02072600f, 0.11240517f, 
    -0.12991583f, 0.28466156f, 0.05778046f, 0.20598412f, -0.00146103f, -0.04374905f, 0.05822604f, 0.10981806f, 
    0.00880440f, 0.01441240f, -0.10110082f, 0.07448129f, -0.11481963f, 0.04818996f, 0.20812725f, 0.04731729f, 
    0.01739151f, -0.09860250f, 0.02233155f, -0.16471504f, 0.27917570f, -0.04298022f, 0.06687801f, -0.10633339f, 
    0.17876296f, 0.03175251f, 0.04516106f, -0.14891249f, -0.06235106f, -0.04007793f, -0.07394357f, 0.14529175f, 
    0.15894371f, 0.12044182f, 0.08694371f, -0.05509862f, 0.00880796f, 0.07362016f, -0.00826002f, 0.14115372f, 
    0.06777954f, -0.09818773f, 0.03913475f, -0.09202253f, -0.08530273f, -0.25554687f, -0.09232285f, -0.15670924f, 
    0.04518705f, 0.03599064f, 0.10415395f, 0.22290058f, -0.08898979f, 0.23849428f, -0.08467628f, -0.12501740f, 
    0.05878344f, -0.00894567f, 0.03837152f, -0.16979650f, -0.32559708f, 0.05440037f, -0.01818540f, -0.24007216f, 
    -0.22565997f, -0.23440751f, -0.24349046f, -0.09267530f, 0.08471271f, 0.11085025f, 0.04450523f, -0.13442218f, 
    0.01302769f, -0.05429802f, 0.12372434f, -0.19317111f, 0.13639729f, -0.03814528f, 0.36662039f, 0.04355801f, 
    -0.02788766f, -0.06112976f, 0.00164415f, -0.26668409f, 0.12590428f, 0.08006547f, 0.08367854f, -0.28727809f, 
    0.08767354f, 0.10693181f, -0.04341898f, -0.07323168f, -0.09773082f, 0.01516209f, -0.13955513f, -0.10243768f, 
    -0.00266742f, 0.11184391f, -0.09794930f, 0.06909797f, -0.05926419f, -0.02108829f, -0.25038290f, 0.07664262f, 
    0.43938118f, 0.08459818f, 0.02059251f, 0.06845476f, 0.05877974f, -0.12131435f, 0.27439722f, -0.16402729f, 
    -0.04406653f, 0.05051436f, -0.22785158f, -0.00472569f, -0.01828498f, -0.08533580f, -0.05896783f, -0.05226654f, 
    0.01439600f, 0.20480604f, -0.06984893f, 0.02988489f, -0.01234082f, 0.13757113f, -0.22428444f, -0.06213552f, 
    -0.18172711f, 0.25632560f, 0.05838785f, 0.11231290f, 0.20242056f, 0.13618961f, 0.04234044f, -0.08747022f, 
    -0.00435540f, 0.03475983f, -0.08769347f, -0.09384356f, 0.00518756f, -0.06092402f, -0.04934719f, 0.15472804f, 
    0.01657903f, -0.15630823f, -0.20502609f, -0.17989323f, 0.00643015f, 0.18563689f, -0.15396795f, 0.15174498f, 
    0.01994774f, -0.14239927f, -0.04556302f, -0.02882160f, 0.05923560f, -0.17416133f, 0.12270312f, 0.11528327f, 
    0.03456014f, 0.19122781f, 0.04108382f, 0.11101250f, 0.22107925f, -0.01725393f, 0.04977791f, 0.12632039f, 
    0.06247319f, 0.01846967f, -0.03445003f, -0.17989461f, 0.19655924f, 0.11389495f, 0.35474208f, -0.18502554f, 
    0.26431772f, 0.13085893f, 0.02176335f, -0.05080069f, 0.16037290f, -0.09812363f, 0.02863034f, -0.16654339f, 
    -0.06557643f, -0.01765803f, -0.22740637f, -0.01541064f, -0.03682273f, -0.20330718f, 0.23354091f, 0.20114231f, 
    0.37000743f, 0.06786986f, 0.09365529f, -0.19262390f, -0.12301882f, 0.10265070f, -0.02078157f, 0.12875101f, 
    -0.12233317f, -0.07075825f, 0.13116203f, 0.20374611f, 0.04412418f, 0.10892784f, 0.23885584f, 0.15171535f, 
    0.24693882f, 0.10042371f, 0.29210874f, -0.12584093f, -0.42088607f, 0.07756767f, 0.10262445f, 0.08273360f, 
    0.05160283f, 0.13136366f, 0.03758439f, 0.18539359f, 0.16730897f, -0.01613864f, 0.04512010f, -0.20474285f, 
    -0.11869501f, 0.09513219f, -0.20248714f, -0.04537840f, 0.13643722f, -0.02344470f, -0.00539237f, 0.02999793f, 
    0.26036444f, 0.03032828f, 0.00041727f, -0.02732784f, -0.09233885f, -0.00263024f, -0.16112682f, -0.36025709f, 
    0.01452200f, 0.19930473f, -0.00924231f, 0.06560951f, 0.17279290f, 0.25204888f, -0.01505839f, 0.09316000f, 
    0.09506791f, 0.01877567f, 0.03076006f, 0.07194853f, 0.04032898f, 0.12193760f, 0.14584073f, 0.04600000f, 
    0.04396435f, -0.29353365f, -0.34114015f, 0.10592239f, 0.07568739f, -0.00294089f, -0.08957727f, -0.27695218f, 
    -0.39372367f, -0.31188351f, -0.43100530f, -0.32274389f, -0.16557059f, 0.23251788f, 0.15378925f, 0.16284814f, 
    0.28951007f, 0.15472198f, -0.08044844f, -0.07787850f, -0.06732491f, -0.11733083f, 0.07931816f, 0.03481102f, 
    0.09861741f, 0.11394226f, -0.00125103f, 0.22841357f, -0.11396444f, 0.08173680f, 0.26670012f, 0.06662006f, 
    -0.07145823f, 0.48328656f, -0.06833982f, 0.23918451f, 0.01703675f, -0.07332768f, 0.01055991f, 0.01282260f, 
    -0.11540900f, -0.03385521f, -0.10827959f, -0.14675415f, -0.07173383f, -0.00636687f, 0.05363570f, 0.03485298f, 
    0.09919190f, -0.19972001f, 0.14678915f, 0.09031665f, -0.06294703f, 0.20352593f, -0.56971264f, -0.15143095f, 
    0.32978916f, -0.09646861f, -0.22011697f, -0.15820172f, -0.15348393f, -0.08936340f, 0.19360217f, -0.12535785f, 
    -0.24844174f, -0.41866252f, 0.10557269f, -0.07004952f, -0.09994917f, 0.12644792f, -0.00568630f, 0.07060577f, 
    -0.24650320f, 0.15011200f, -0.02009855f, -0.07518090f, 0.06892626f, -0.15096742f, 0.02497692f, -0.03503567f, 
    0.09877587f, 0.00402638f, 0.00707174f, 0.16478561f, 0.06275078f, -0.03093633f, 0.03536704f, 0.01090927f, 
    -0.02675796f, 0.15538447f, -0.19613320f, 0.15676300f, -0.08523194f, -0.01077395f, -0.11248638f, -0.12810363f, 
    -0.20577288f, -0.43107283f, -0.20189978f, 0.01825360f, -0.09276906f, 0.20062675f, -0.05257476f, -0.12427894f, 
    0.06485067f, 0.18230022f, -0.27981102f, -0.05572575f, 0.27764621f, 0.28727657f, -0.10661913f, 0.17157143f, 
    0.19816861f, 0.04302679f, 0.21060662f, 0.26648900f, -0.09693401f, -0.24611881f, -0.19761537f, -0.01603082f, 
    -0.11181325f, -0.14907931f, -0.17281838f, 0.10404097f, -0.04314982f, -0.01687766f, -0.02342024f, -0.09071176f, 
    -0.05373757f, -0.04050730f, -0.00708684f, -0.03144170f, -0.07536870f, -0.10573890f, -0.08072063f, -0.11416561f, 
    0.03442989f, -0.04055550f, 0.14597943f, -0.27974364f, 0.01521367f, -0.02052704f, -0.11864249f, 0.06427360f, 
    -0.13349196f, 0.15107392f, 0.01459919f, 0.08100817f, 0.05325354f, 0.13971582f, -0.06887856f, -0.15643850f, 
    0.07657903f, 0.42258567f, 0.22476603f, -0.02132401f, 0.03323276f, 0.22185916f, 0.09439776f, 0.00333085f, 
    -0.23364839f, 0.18228698f, -0.03297333f, 0.02093840f, -0.01854441f, -0.08656949f, -0.09163730f, 0.00315577f, 
    -0.05937752f, -0.00809668f, 0.27662888f, -0.17608848f, -0.26491711f, 0.15761690f, 0.19897012f, 0.10623651f, 
    0.19220985f, 0.09436988f, 0.02151258f, -0.06628955f, -0.25164232f, 0.07002036f, -0.21684617f, -0.13220660f, 
    -0.19788648f, -0.19850533f, -0.02392190f, -0.10345384f, 0.00995877f, -0.04424840f, -0.21992618f, 0.13534202f, 
    0.07477184f, 0.15601477f, 0.01523684f, 0.46500912f, 0.21534845f, 0.07052787f, 0.04653042f, -0.07149156f, 
    0.08852842f, 0.05939395f, -0.01843215f, 0.07166975f, 0.17523658f, 0.14769982f, 0.01573108f, 0.06769151f, 
    0.12407207f, 0.08648606f, 0.03691049f, 0.03628505f, 0.09505025f, 0.04222303f, 0.20044403f, 0.36658564f, 
    -0.14103431f, -0.21913758f, 0.34434721f, -0.21362807f, 0.22191398f, -0.18615779f, 0.10711615f, 0.23007445f, 
    -0.04308446f, 0.40318754f, -0.40192324f, 0.21167739f, 0.06844768f, -0.03035703f, 0.22516468f, -0.05569491f, 
    -0.16628119f, 0.20389354f, 0.06084133f, 0.11375340f, 0.27559999f, -0.04390585f, 0.19677411f, 0.04679643f, 
    0.18116193f, 0.00039901f, 0.02620243f, 0.08954287f, 0.11911184f, 0.05808838f, 0.29415056f, 0.10968600f, 
    0.15566979f, 0.04864473f, 0.05639814f, 0.23490162f, -0.18018559f, 0.02389988f, 0.17332900f, -0.13043590f, 
    0.17110242f, -0.03447316f, -0.31062627f, 0.05418529f, -0.09965713f, 0.05032931f, -0.13687432f, -0.00144459f, 
    -0.03507846f, -0.06407184f, -0.09767058f, 0.03811185f, -0.12571616f, -0.04009184f, -0.23095217f, 0.13064085f, 
    0.32243326f, -0.25124398f, -0.06567501f, -0.14127377f, 0.15038802f, 0.12092260f, 0.06719524f, 0.07674959f, 
    0.16078140f, 0.17256539f, 0.05656059f, -0.05840482f, -0.22423758f, -0.01229798f, 0.03700814f, 0.14214639f, 
    -0.23991634f, -0.14304124f, -0.26991105f, -0.00920823f, -0.07986547f, 0.06570052f, -0.11096940f, -0.14044820f, 
    -0.24707922f, -0.16331375f, 0.12611817f, 0.37517619f, -0.01297910f, 0.21070173f, 0.09218669f, -0.09019728f, 
    0.27412096f, -0.08937111f, -0.11021115f, 0.03123672f, 0.01684676f, 0.13973796f, 0.12619078f, 0.14048076f, 
    0.06504440f, 0.13792248f, -0.05675580f, 0.02352225f, 0.43228319f, -0.07611772f, -0.05245613f, 0.07372299f, 
    0.21378258f, 0.42264906f, 0.00242188f, 0.17067400f, -0.01420396f, 0.01500643f, 0.02827978f, -0.01228618f, 
    -0.16620021f, -0.12375460f, 0.06421649f, -0.03767218f, 0.09827137f, -0.09206481f, -0.02773938f, 0.09219059f, 
    0.05141422f, -0.03640908f, 0.22055733f, 0.03496115f, 0.12855639f, 0.00143773f, -0.20642343f, 0.03669720f, 
    0.13867870f, -0.17144787f, 0.06039666f, -0.10093272f, -0.06887670f, 0.01350673f, 0.01169295f, -0.13526557f, 
    0.15199730f, 0.11840077f, -0.18468340f, -0.06329282f, 0.16546528f, 0.11331113f, -0.03753132f, -0.01573350f, 
    -0.28116181f, 0.03125994f, -0.29795748f, -0.09917944f, -0.03674912f, 0.20368376f, -0.04604458f, 0.03994634f, 
    -0.18102598f, 0.09038174f, -0.07624681f, 0.14443998f, 0.12536587f, -0.09833062f, -0.01073991f, 0.04125814f, 
    -0.03771149f, 0.02013604f, -0.06610070f, -0.36592415f, -0.26440433f, 0.06935481f, 0.00144252f, -0.13752884f, 
    -0.26944032f, -0.20522445f, 0.11517027f, -0.42345768f, -0.06503180f, 0.15005957f, 0.09406232f, 0.00179943f, 
    -0.05488934f, -0.04684683f, 0.24654366f, -0.08833548f, -0.25258473f, 0.43593025f, 0.12049013f, -0.13294955f, 
    0.04520988f, -0.04985982f, 0.02974002f, 0.05765055f, 0.10225541f, 0.08913834f, 0.18191460f, 0.13707221f, 
    -0.20817132f, -0.12625115f, -0.11153384f, 0.09079137f, -0.03109850f, -0.01898284f, 0.16803555f, 0.10098593f, 
    0.37943590f, -0.09013386f, -0.09677590f, -0.23806284f, -0.04823618f, 0.02539050f, -0.02882661f, -0.18271744f, 
    0.14161795f, -0.37033966f, -0.01459657f, -0.02014896f, 0.20355716f, 0.03353566f, -0.14442669f, -0.15625772f, 
    0.06950020f, 0.08391768f, -0.04229955f, 0.01370855f, 0.03230187f, -0.11192849f, -0.15934440f, 0.16736364f, 
    0.00285739f, 0.33589941f, -0.49650541f, 0.09867555f, -0.02291699f, 0.07204192f, 0.38159239f, -0.14665762f, 
    -0.11103619f, -0.08412090f, 0.14606477f, -0.02124978f, 0.06236042f, -0.07171538f, -0.00802017f, 0.03315488f, 
    0.00585243f, 0.03726044f, 0.02934208f, -0.31159270f, -0.14399590f, -0.08595828f, 0.02219793f, 0.05790373f, 
    0.01796037f, -0.01128813f, 0.03665708f, -0.13999838f, -0.05713878f, -0.07512166f, -0.43484667f, -0.12765683f, 
    -0.25547054f, -0.26353213f, -0.10620478f, 0.01211380f, -0.29549804f, 0.19504437f, 0.19795264f, 0.23996668f, 
    -0.07937557f, -0.25619525f, -0.07210194f, 0.03387060f, 0.16754943f, 0.03179558f, 0.03338413f, 0.05575536f, 
    -0.08235622f, 0.26012757f, 0.14123859f, 0.04738495f, 0.28721845f, 0.05177093f, 0.06520770f, 0.03195723f, 
    0.37112573f, 0.20224358f, -0.19514467f, 0.17717801f, -0.14658017f, 0.10339083f, 0.20933162f, -0.01132324f, 
    0.09573974f, -0.00578204f, -0.20003147f, -0.02094221f, 0.10316334f, -0.17298287f, -0.01690384f, 0.30426371f, 
    0.24724816f, -0.05379872f, 0.00810939f, -0.19455466f, 0.16533855f, -0.00351604f, -0.07170391f, -0.13029978f, 
    0.10461394f, 0.12965369f, 0.08166362f, -0.03365285f, -0.22201543f, -0.01345783f, 0.03493124f, -0.09131143f, 
    -0.12064155f, -0.03012741f, 0.28138688f, -0.05716491f, 0.10464637f, 0.00736207f, -0.01925389f, -0.07242592f, 
    0.13184102f, 0.02596542f, -0.28689465f, 0.09445399f, 0.25523943f, -0.00892360f, 0.04653435f, 0.10761872f, 
    0.01288232f, 0.11482447f, 0.34008643f, 0.13462056f, 0.06052918f, 0.11219984f, -0.09858465f, 0.05801700f, 
    0.17203529f, 0.04400809f, 0.18608876f, -0.03776025f, 0.11620663f, 0.14842999f, 0.10502556f, -0.13399637f, 
    -0.03228032f, 0.08700659f, 0.10836552f, -0.14705379f, 0.06308413f, -0.13723707f, -0.04064723f, -0.30643055f, 
    -0.16325356f, -0.14708658f, 0.22494660f, 0.04947699f, 0.16767150f, -0.01398420f, 0.09929645f, 0.08891413f, 
    0.18297492f, -0.18693207f, -0.33065739f, 0.19634865f, -0.09246651f, -0.06390013f, 0.00526465f, 0.22373715f, 
    0.25576928f, -0.21602453f, 0.07448147f, -0.09793566f, 0.09737126f, -0.14724228f, 0.08907294f, -0.05627527f, 
    -0.14312339f, 0.03691043f, -0.00571773f, 0.04024672f, -0.17203380f, -0.00301084f, 0.20445924f, -0.11054870f, 
    0.13893801f, -0.08115162f, -0.03432738f, -0.39043522f, -0.09920398f, -0.30054611f, 0.03906590f, 0.12146028f, 
    -0.18200405f, -0.30069387f, 0.00361799f, 0.08843253f, 0.04265818f, -0.20834202f, -0.16157551f, 0.18889394f, 
    0.15486971f, 0.16234492f, 0.07567795f, 0.22260593f, 0.02179167f, 0.23490609f, -0.10322645f, 0.05166535f, 
    0.02150659f, 0.03012602f, 0.15111353f, -0.34300956f, -0.21520746f, -0.07531442f, 0.10806826f, 0.21517003f, 
    0.21053095f, 0.21935275f, -0.25577119f, -0.32594836f, 0.09001161f, -0.03500759f, 0.10450479f, -0.03411345f, 
    0.12016863f, -0.10703958f, 0.07101808f, -0.01392448f, -0.12834515f, 0.05974433f, 0.09054513f, 0.08627362f, 
    0.26512107f, 0.26304737f, -0.10210945f, 0.07125375f, -0.02199719f, -0.34760764f, -0.09198337f, 0.09107769f, 
    0.14753115f, 0.01834576f, 0.00550705f, 0.01968234f, -0.05282817f, 0.16202506f, 0.16432941f, -0.00364334f, 
    -0.04938607f, -0.08874385f, -0.01018342f, 0.23763512f, 0.04166059f, -0.03400556f, -0.12022013f, -0.07844234f, 
    0.07965291f, 0.02812014f, 0.18703206f, -0.03047481f, -0.09409039f, -0.03692697f, -0.14542459f, -0.02403181f, 
    0.04809978f, 0.03040716f, 0.18042803f, 0.02722643f, -0.15582559f, -0.23196845f, -0.25534847f, -0.05851488f, 
    0.04414571f, -0.00747859f, -0.27046719f, 0.01554722f, -0.07397854f, -0.00954333f, -0.17914471f, 0.15598848f, 
    0.13592158f, 0.06708326f, -0.16961743f, 0.11486375f, -0.02696349f, 0.02078682f, -0.26733243f, -0.48523563f, 
    -0.70417374f, 0.15271501f, 0.01252940f, 0.04646669f, 0.17554745f, 0.14113925f, 0.07226409f, 0.09207254f, 
    -0.08157501f, -0.11718560f, 0.15317595f, -0.01096793f, 0.13326299f, -0.06154441f, 0.02745410f, 0.06462968f, 
    -0.03687339f, 0.00507175f, -0.20235045f, -0.03879404f, -0.04017612f, 0.09762491f, 0.01585130f, 0.00083429f, 
    0.03641933f, -0.18761589f, -0.07835658f, 0.02530456f, 0.08618619f, -0.00917063f, -0.07439758f, 0.11024457f, 
    -0.09116413f, 0.26997760f, 0.15107499f, -0.00679012f, 0.13645639f, 0.12316792f, -0.00293572f, 0.17869797f, 
    0.09217560f, -0.13684325f, 0.09290031f, 0.14680916f, 0.01464652f, 0.07566967f, 0.14406136f, -0.23626052f, 
    0.00839875f, -0.06041529f, 0.02715749f, 0.08885688f, 0.04989466f, 0.16225016f, 0.08021317f, 0.17970739f, 
    0.14070301f, 0.08481251f, 0.17919613f, 0.09959385f, 0.23880099f, -0.12507807f, 0.10405058f, -0.11802229f, 
    0.25614369f, -0.03239426f, 0.22074123f, 0.08606857f, 0.10960493f, 0.08691129f, 0.01218963f, 0.02386345f, 
    0.01739143f, -0.11917331f, 0.18977445f, 0.15192112f, 0.15727955f, -0.21242581f, -0.14682189f, -0.25372502f, 
    -0.11430426f, -0.37696332f, 0.16694441f, -0.11388701f, 0.10172576f, -0.01325399f, 0.16742577f, 0.16544358f, 
    0.03858405f, 0.00481092f, -0.03576340f, -0.05479280f, -0.03706694f, -0.04086608f, 0.05291485f, 0.00385682f, 
    -0.02835037f, 0.05420964f, -0.00671154f, 0.01340375f, -0.04427168f, -0.01006257f, 0.03659470f, -0.05048833f, 
    -0.01967820f, -0.05461160f, -0.03651195f, -0.05752141f, -0.05566106f, -0.03229865f, 0.03623173f, 0.03518948f, 
    0.00619446f, 0.04277704f, -0.04185798f, -0.05047760f, -0.03959764f, -0.00030469f, 0.00618307f, -0.01917431f, 
    -0.06539239f, 0.02195718f, -0.03395366f, 0.05023686f, -0.00309433f, 0.03427731f, -0.03489588f, -0.01902183f, 
    0.03755857f, 0.00701402f, 0.01466874f, 0.04066419f, 0.03715474f, 0.01942249f, -0.02491714f, -0.02264947f, 
    -0.02005175f, -0.00873263f, 0.05507527f, 0.05273334f, 0.01940506f, -0.03593836f, -0.01658416f, -0.02614904f, 
    -0.05478015f, -0.06688757f, -0.06053885f, -0.01481385f, 0.02614003f, 0.03056917f, -0.00367340f, -0.03767430f, 
    0.00702803f, -0.02708990f, 0.02890540f, 0.05321280f, -0.02472750f, -0.04510496f, -0.03648620f, -0.05378938f, 
    -0.02283120f, -0.06553074f, -0.00268931f, -0.04313878f, 0.00598610f, -0.02580262f, 0.00547157f, 0.04044094f, 
    0.01803303f, -0.00297768f, -0.05375782f, 0.01081948f, -0.02954541f, 0.02849330f, 0.03199088f, -0.06146489f, 
    -0.03700049f, -0.03826050f, -0.02758487f, -0.01262657f, -0.00746357f, -0.04290827f, -0.00445016f, 0.04374106f, 
    -0.05573778f, -0.01216308f, -0.01390283f, 0.03690479f, -0.02608565f, -0.01335029f, -0.03299700f, -0.04697163f, 
    -0.05202981f, 0.04761929f, 0.01466522f, -0.00602547f, -0.02197105f, 0.01897285f, -0.03749456f, -0.00704357f, 
    -0.03949616f, 0.02863952f, 0.04585814f, 0.03360162f, 0.03394578f, -0.01262359f, 0.01499811f, -0.03663646f, 
    -0.00290364f, -0.02230915f, 0.01156584f, -0.03532851f, 0.01945687f, -0.01211328f, 0.02193669f, -0.03342200f, 
    -0.04002534f, -0.04668631f, -0.03291534f, 0.01071817f, -0.02999850f, -0.00575017f, 0.01439543f, -0.04485586f, 
    0.03478922f, -0.04470295f, -0.06547335f, -0.00062935f, 0.04677482f, -0.05545945f, -0.02950981f, 0.03500147f, 
    -0.02139329f, -0.02726768f, 0.03925547f, -0.06481522f, -0.03805735f, -0.01389364f, -0.00173286f, 0.04485917f, 
    0.00777994f, 0.00304904f, 0.00829806f, -0.00582916f, -0.03884114f, -0.03770185f, -0.05567204f, 0.04465939f, 
    -0.03373219f, -0.02897971f, -0.01345738f, -0.03185443f, -0.03021150f, 0.04738646f, 0.00791882f, 0.03736155f, 
    -0.05364566f, -0.02793337f, 0.04545426f, -0.00862783f, -0.01645013f, 0.00703135f, -0.05343235f, -0.03032091f, 
    -0.03475825f, -0.00969785f, -0.04479806f, 0.02918155f, 0.03239868f, 0.02754484f, 0.00287618f, -0.06614628f, 
    0.03972068f, -0.01923312f, -0.05222619f, 0.00737873f, -0.06120452f, -0.00787657f, -0.03200396f, 0.03990300f, 
    0.02866812f, -0.04677439f, 0.04307273f, 0.01974446f, 0.02523643f, 0.00042324f, -0.04301671f, 0.00895715f, 
    0.01326358f, -0.04446523f, -0.02978271f, -0.02484892f, 0.03253957f, -0.01610760f, -0.05954794f, 0.03034355f, 
    -0.00578397f, 0.01799405f, -0.01397918f, -0.01141957f, -0.01028067f, -0.04650596f, 0.03805865f, -0.01618968f, 
    -0.01335863f, 0.04400424f, 0.04199459f, -0.06828521f, 0.02929903f, -0.00434536f, 0.02648859f, -0.00378340f, 
    -0.04898981f, -0.02123709f, 0.00263207f, -0.03413451f, -0.04861890f, -0.04769779f, 0.02549446f, 0.03135883f, 
    -0.00814097f, -0.05157172f, -0.01503624f, -0.00821458f, -0.04709873f, 0.04685457f, 0.05119681f, -0.01718562f, 
    0.05532242f, -0.03555828f, 0.04521354f, 0.04042433f, 0.03104514f, -0.01318690f, 0.03722072f, 0.00164202f, 
    -0.00267960f, 0.00764975f, 0.00041445f, -0.04396479f, -0.05284875f, -0.01599644f, 0.03764518f, -0.06142272f, 
    -0.04490911f, 0.03623651f, -0.01276464f, 0.03863502f, 0.04013302f, 0.03881078f, 0.01982663f, -0.05913656f, 
    -0.04290735f, -0.05599550f, -0.01317086f, -0.00819409f, 0.02440299f, -0.03635856f, -0.05200611f, 0.03651532f, 
    0.03386160f, 0.00045034f, -0.03188645f, 0.00988263f, -0.04739243f, 0.00562881f, 0.03654469f, -0.00737416f, 
    -0.00733197f, 0.04218275f, -0.01528758f, -0.04304268f, 0.02346643f, -0.02302328f, 0.01557431f, 0.01109520f, 
    -0.12111922f, -0.45357412f, -0.36483428f, -0.10615028f, -0.07241280f, -0.01271558f, 0.02288470f, 0.04448380f, 
    0.41418800f, -0.25959465f, 0.07819390f, -0.00613724f, 0.29142413f, -0.00390471f, -0.28091988f, 0.17527521f, 
    -0.06234488f, -0.14918920f, -0.12310360f, -0.20724405f, -0.14356992f, -0.19127311f, 0.05174314f, 0.07129467f, 
    0.08510154f, 0.04291397f, -0.03915177f, 0.78061217f, -0.23821442f, -0.44310850f, 0.06846451f, -0.10682630f, 
    0.17870785f, -0.09356377f, 0.12918186f, -0.05941954f, 0.39258286f, 0.14726634f, 0.07097224f, 0.12975131f, 
    -0.17122628f, -0.17845578f, 0.05208269f, -0.23075947f, 0.10583119f, -0.05756326f, -0.45760047f, -0.81343991f, 
    0.03560349f, -0.26785672f, -0.15589027f, 0.15629070f, -0.00152236f, 0.00516696f, 0.27493355f, -0.07595499f, 
    0.31642815f, 0.06956720f, 0.03829521f, 0.07065208f, -0.02984173f, 0.04736437f, -0.26197606f, -0.32474113f, 
    -0.57520419f, -0.46856213f, -0.00091520f, -0.27604246f, -0.11282933f, -0.09835241f, 0.17864141f, 0.02291624f, 
    0.75240076f, -0.25508705f, -0.02319151f, 0.05714480f, -0.21908087f, -0.07696176f, 0.03917694f, 0.21684007f, 
    -0.03403338f, -0.17191778f, -0.14285435f, 0.30941200f, 0.05705082f, 0.10631005f, -0.18673158f, -0.10847791f, 
    -0.10926905f, -0.08323956f, 0.20780210f, 0.11608314f, 0.18531559f, 0.01319770f, -0.09148813f, 0.07430467f, 
    0.03509214f, 0.05278996f, -0.13072315f, 0.00384744f, 0.07184062f, -0.31528565f, 0.19976766f, -0.02573748f, 
    -0.15043560f, 0.11938344f, 0.14017338f, -0.14486876f, 0.02662622f, -0.25233901f, -0.06568098f, 0.10720745f, 
    -0.17211059f, -0.10524403f, 0.08299539f, -0.15197302f, -0.09920477f, -0.28890938f, 0.23743472f, -0.14849401f, 
    -0.05141355f, -0.18670851f, 0.00112353f, 0.40078855f, -0.01491560f, 0.09895362f, -0.42611456f, -0.01875116f, 
    0.03267753f, 0.03820254f, -0.10638158f, 0.05631436f, -0.03626786f, 0.11227716f, 0.04273896f, 0.23486507f, 
    0.07469381f, 0.39514151f, -0.12777163f, 0.12336052f, -0.09974452f, 0.12396622f, -0.14816754f, -0.14368764f, 
    0.10614595f, 0.00126027f, 0.05186853f, 0.01068270f, 0.04410684f, -0.09995514f, -0.01265472f, -0.02483658f, 
    0.13536997f, 0.10113603f, -0.39424458f, -0.54874486f, -0.04853091f, 0.01540537f, -0.03109366f, -0.05965447f, 
    0.12438028f, 0.27943400f, -0.25435066f, 0.05894123f, -0.42607108f, 0.05500829f, 0.03793362f, -0.06256244f, 
    -0.05901576f, 0.03201416f, 0.12443954f, -0.02366008f, 0.56310982f, 0.35978034f, -0.16685000f, -0.17482580f, 
    0.05485942f, -0.02427063f, -0.16041216f, -0.06485496f, 0.28127721f, 0.06109040f, 0.05594715f, 0.17468700f, 
    0.11996727f, -0.03587579f, 0.17036559f, 0.05108257f, 0.05864911f, -0.13926104f, -0.21407126f, 0.21342629f, 
    0.07455184f, 0.10161117f, -0.02038834f, 0.06741615f, -0.13541047f, 0.04880753f, 0.08572211f, -0.36267892f, 
    -0.27262932f, -0.01395795f, -0.10423343f, 0.00329610f, 0.08671604f, -0.06939271f, -0.02043359f, 0.61583948f, 
    0.16188005f, -0.55645889f, -0.37606022f, 0.11782671f, -0.10675371f, 0.07622118f, 0.09045812f, -0.30021963f, 
    -0.22587454f, 0.05173649f, -0.02278463f, 0.11064127f, 0.03078873f, 0.12027688f, 0.12642063f, 0.05403762f, 
    0.29133561f, -0.25920257f, -0.16634811f, -0.18753846f, 0.09815498f, -0.19850655f, -0.11742875f, 0.04492491f, 
    0.17112976f, 0.06901091f, -0.12992871f, -0.43434086f, -0.37432802f, 0.30602244f, -0.24214916f, -0.23681679f, 
    0.15810741f, -0.11754544f, 0.19107254f, 0.00099761f, 0.14059043f, 0.44640774f, -0.03806115f, 0.02470504f, 
    0.24689248f, -0.05793713f, -0.06150830f, 0.19337924f, -0.64229208f, -0.00580149f, -0.30119058f, 0.04423320f, 
    -0.04414431f, -0.01655982f, -0.02417802f, -0.09068087f, 0.15416171f, 0.34614357f, -0.18823016f, -0.19432370f, 
    -0.20752108f, 0.09506189f, 0.13549905f, 0.17978553f, 0.24855155f, 0.15475431f, -0.05621656f, 0.05375954f, 
    0.05375662f, -0.11950646f, -0.09558610f, -0.16190760f, 0.21421665f, -0.13026080f, -0.20345746f, -0.04397703f, 
    -0.05473426f, 0.17513184f, -0.10913106f, 0.16218516f, 0.02639340f, 0.10802200f, -0.13722241f, -0.15892333f, 
    0.07961745f, 0.13680726f, 0.09197818f, 0.11972843f, 0.14530814f, -0.08876132f, -0.06075699f, 0.14186856f, 
    0.11053728f, 0.12906110f, -0.01166272f, -0.06960247f, 0.06939220f, 0.18126525f, -0.01081074f, -0.06197912f, 
    -0.31096703f, -0.13236903f, 0.15362498f, 0.04784460f, 0.04354428f, -0.07126088f, -0.10678745f, 0.06445894f, 
    0.01196287f, 0.06245969f, 0.02740775f, -0.35490033f, 0.02636298f, -0.12059642f, -0.10677826f, 0.11844892f, 
    0.21578377f, -0.29855633f, -0.05144727f, 0.09278131f, -0.08574039f, -0.02501022f, 0.01488831f, -0.15981454f, 
    0.12601559f, 0.21505138f, -0.18814632f, 0.05946559f, -0.01538506f, -0.16375804f, -0.28058711f, -0.08496110f, 
    -0.09547213f, -0.05342877f, -0.16942348f, -0.19302085f, -0.10499002f, -0.04549797f, -0.01643778f, 0.45670354f, 
    0.07427714f, 0.00560549f, 0.05446560f, 0.20874634f, 0.03915830f, 0.12376267f, -0.07666045f, -0.23773000f, 
    -0.16473587f, 0.02766012f, 0.06849663f, -0.04198892f, 0.05759039f, -0.17028111f, 0.22286734f, 0.09039087f, 
    -0.06613079f, 0.08662146f, 0.11439569f, 0.15550478f, 0.04529418f, 0.18108690f, -0.11986182f, -0.19923361f, 
    -0.39125365f, -0.28585678f, 0.25310355f, 0.40766668f, -0.15950654f, 0.18092966f, 0.11730650f, -0.18435545f, 
    0.09754635f, 0.00978552f, 0.05256960f, 0.20633966f, 0.02478311f, -0.09736659f, -0.12814139f, -0.03235392f, 
    0.09239784f, 0.13456035f, 0.11275068f, 0.08270444f, 0.00538887f, 0.45108861f, 0.06675253f, 0.12844265f, 
    -0.01184780f, 0.04593427f, 0.02885559f, 0.25518313f, -0.01589312f, -0.14636344f, 0.02267495f, -0.06193193f, 
    0.04319959f, -0.05654509f, -0.03107485f, -0.13456826f, -0.09318759f, 0.05104806f, 0.00975574f, 0.27241796f, 
    -0.17267205f, -0.09201181f, 0.37544644f, -0.01720778f, 0.13085669f, -0.08180307f, -0.01614431f, -0.02479642f, 
    0.07172552f, 0.07810380f, 0.03006089f, 0.08359297f, -0.01466725f, 0.03602648f, 0.08474892f, -0.03337913f, 
    0.13551827f, -0.23592547f, 0.00496854f, 0.04031370f, 0.16745563f, 0.11466993f, 0.04443613f, 0.02136316f, 
    -0.05567344f, 0.09877252f, -0.09008139f, -0.05698990f, 0.04595137f, 0.02963724f, 0.21642187f, 0.05723895f, 
    -0.06618451f, -0.12134611f, -0.16355303f, 0.07010356f, -0.13496755f, 0.16544256f, 0.12750900f, 0.07648864f, 
    0.05373202f, 0.01127598f, -0.10889699f, -0.01297049f, -0.23697624f, 0.23704731f, 0.00805769f, -0.12881814f, 
    -0.09443408f, -0.21922721f, -0.06137608f, -0.22736877f, -0.12249629f, 0.22760575f, 0.07634786f, 0.03119061f, 
    0.13423298f, -0.13700773f, -0.09343565f, -0.16806468f, 0.08774144f, 0.08884861f, 0.24995351f, 0.11122293f, 
    -0.02063191f, 0.12172622f, 0.14270644f, 0.05062409f, -0.14737439f, -0.10538992f, 0.21795905f, -0.19813211f, 
    -0.09030155f, -0.01699943f, 0.09544744f, 0.05573022f, 0.02358670f, 0.04900900f, -0.08428304f, -0.10212604f, 
    0.09842648f, 0.00310389f, -0.01970671f, 0.06723765f, -0.28275877f, 0.01054408f, 0.00444520f, -0.12346756f, 
    0.10056563f, 0.06850769f, 0.02548481f, 0.06785914f, 0.21242049f, -0.02653762f, 0.00337881f, -0.10129722f, 
    0.11485963f, 0.10964148f, -0.10762876f, -0.00556208f, 0.12651452f, 0.02467795f, -0.04091363f, -0.01925225f, 
    -0.03136253f, 0.16016364f, -0.05308348f, -0.12075265f, 0.08664502f, 0.06599942f, -0.13671282f, 0.05131467f, 
    -0.05626186f, 0.09368546f, -0.13148013f, -0.07492492f, -0.05335679f, -0.24902968f, 0.08291972f, 0.02940593f, 
    -0.14538808f, 0.16710523f, 0.00474196f, -0.06858451f, 0.29481548f, 0.19990283f, -0.00110989f, 0.13428651f, 
    0.06506751f, 0.09799579f, 0.00302595f, -0.02626759f, 0.16194354f, 0.02952626f, -0.19814746f, 0.04187021f, 
    0.10444999f, -0.01257514f, -0.00015975f, 0.03279557f, 0.11217029f, -0.11243554f, -0.10741729f, -0.10290815f, 
    -0.00343802f, -0.02539941f, -0.01974064f, -0.12117936f, -0.01875320f, 0.04511271f, -0.05124443f, 0.16790786f, 
    0.17543775f, -0.00669734f, -0.14171781f, 0.03360971f, 0.18415165f, 0.08906376f, 0.14190081f, -0.07779597f, 
    0.02095519f, 0.03134302f, -0.02476554f, 0.12367905f, 0.12444653f, -0.21762076f, 0.12614740f, -0.06103884f, 
    0.04780563f, -0.00116219f, -0.37325668f, 0.04680922f, 0.09616728f, 0.08807195f, -0.16678745f, -0.17958386f, 
    0.06467991f, 0.14963195f, -0.00498011f, -0.10983763f, 0.11027636f, 0.25659743f, -0.01304861f, -0.06990832f, 
    0.09632900f, 0.13293482f, 0.04606486f, -0.08668767f, -0.13099211f, -0.08141074f, 0.08360670f, -0.03973309f, 
    -0.03582315f, 0.20058249f, -0.06347346f, -0.28386486f, -0.02216485f, -0.15832512f, 0.03603506f, -0.00452180f, 
    -0.14501540f, -0.05405157f, 0.05824742f, 0.00153605f, 0.07538965f, 0.00259835f, -0.39102012f, -0.04295678f, 
    -0.02930357f, -0.03821613f, -0.09208385f, 0.05662084f, 0.01085033f, -0.12715103f, -0.24259819f, -0.32891855f, 
    0.19333163f, 0.02184244f, 0.19476300f, -0.11961477f, -0.00977064f, -0.11438914f, 0.31133664f, 0.03616248f, 
    0.09558254f, -0.03647310f, -0.15037167f, -0.10272142f, -0.04961242f, -0.06078462f, 0.02548664f, -0.05625487f, 
    -0.28334355f, -0.22137915f, 0.24991873f, -0.07929916f, -0.28091112f, 0.08432966f, 0.12371519f, 0.03735998f, 
    -0.36995202f, 0.16418673f, -0.01311347f, 0.03978576f, -0.06231187f, -0.09286031f, 0.04040051f, -0.16654007f, 
    -0.07656869f, -0.11087754f, 0.09664422f, 0.05799986f, 0.04854506f, 0.05485693f, 0.03930803f, -0.02509620f, 
    -0.01498381f, 0.09445891f, 0.03048621f, -0.09700955f, -0.02273373f, 0.11828585f, 0.18964547f, 0.05825602f, 
    0.15817738f, 0.13375379f, -0.01022590f, 0.06405637f, 0.02621423f, -0.25234321f, 0.05245518f, 0.20347100f, 
    0.22289664f, 0.21629396f, -0.06819523f, -0.23167445f, -0.15390737f, -0.30297992f, -0.29548761f, 0.17478228f, 
    0.03911160f, 0.16709439f, 0.11698285f, -0.01051721f, -0.03549544f, 0.00088526f, -0.00095206f, -0.24967819f, 
    0.01852597f, -0.04242270f, 0.17017514f, 0.11035677f, -0.17175907f, 0.03355874f, 0.26678422f, -0.13003741f, 
    0.14698382f, 0.16288170f, 0.16235347f, 0.00343366f, 0.12117823f, 0.08693591f, 0.00551962f, 0.28482291f, 
    0.18739387f, 0.05148249f, 0.12431116f, 0.02429411f, 0.00680967f, 0.13051957f, -0.10051037f, -0.02454015f, 
    0.10239182f, 0.06639875f, 0.19345036f, -0.09188223f, 0.21043848f, -0.08449622f, 0.06438418f, -0.05708356f, 
    -0.05146339f, 0.04498806f, -0.24201599f, -0.18985091f, -0.02348156f, -0.13650103f, -0.01341455f, 0.13253960f, 
    -0.08029611f, -0.09106795f, 0.22035550f, 0.18995486f, 0.26372293f, 0.16031249f, 0.16674808f, -0.01033467f, 
    -0.01441853f, 0.06080953f, -0.05420237f, 0.16283637f, 0.06337005f, 0.13870817f, 0.16318282f, -0.04972734f, 
    0.01523954f, -0.00142353f, -0.13166282f, 0.19637507f, 0.22932266f, 0.09047741f, -0.23020920f, 0.19024108f, 
    0.19448844f, -0.07267338f, 0.10532179f, -0.06861132f, -0.04833473f, 0.08217264f, -0.07820010f, 0.05161416f, 
    0.04985471f, -0.14997154f, 0.18874471f, 0.11462782f, -0.02385259f, 0.04569694f, -0.20445745f, 0.06463617f, 
    0.03879220f, 0.06738087f, 0.03878916f, 0.10427772f, 0.10089327f, -0.01505548f, 0.02099949f, -0.17043833f, 
    0.14996766f, -0.45466298f, -0.03923228f, -0.00994589f, 0.03460164f, 0.17804302f, -0.01211945f, -0.03390303f, 
    0.08493873f, 0.09911610f, 0.16923195f, 0.17273174f, 0.20758285f, 0.05581546f, 0.06774514f, 0.07943935f, 
    0.03707197f, 0.17624162f, 0.30405045f, -0.23953678f, 0.01799836f, 0.15195580f, 0.01244393f, -0.01960061f, 
    0.08041419f, 0.05526422f, -0.11642832f, -0.18731068f, -0.26218632f, 0.10223944f, 0.01973279f, 0.03928849f, 
    0.05166388f, 0.10228634f, 0.00515909f, -0.06556755f, -0.05758974f, -0.04831993f, 0.04621532f, 0.01940351f, 
    -0.00556696f, -0.10851777f, -0.13144194f, -0.10625740f, -0.05585648f, -0.03224039f, 0.24403803f, 0.26627985f, 
    0.30173042f, 0.00033101f, -0.08875564f, 0.23781507f, -0.04658206f, -0.27157551f, -0.18982112f, -0.11840194f, 
    -0.05370926f, 0.07474668f, -0.22356009f, 0.01918423f, 0.08811814f, 0.12552048f, 0.08951244f, -0.00543103f, 
    -0.06961614f, 0.07626401f, 0.02143411f, 0.10475450f, -0.12167650f, -0.00459060f, -0.04695520f, -0.25226057f, 
    -0.09824903f, -0.12277547f, 0.15846130f, -0.06797279f, -0.11507812f, 0.08575826f, 0.06440126f, -0.06058431f, 
    -0.15609244f, -0.07405672f, -0.16261686f, -0.00887367f, 0.11423802f, 0.02474880f, 0.24838884f, 0.01140871f, 
    -0.09113479f, 0.02193932f, -0.20742625f, -0.17450738f, -0.02639957f, 0.05604611f, 0.06449769f, 0.08836250f, 
    -0.07477927f, -0.13331233f, 0.06734309f, 0.01628975f, -0.05925187f, -0.00455152f, 0.04329150f, 0.13360058f, 
    0.28104210f, 0.10504379f, 0.10244702f, -0.57928300f, -0.08221504f, -0.10368036f, -0.00862502f, -0.06292431f, 
    0.16084982f, 0.16329567f, 0.05034958f, 0.08355965f, 0.05092969f, -0.09632758f, -0.06457754f, 0.02711624f, 
    -0.00325092f, -0.36560801f, 0.12738693f, 0.08673791f, 0.00334916f, 0.09057461f, 0.11651577f, 0.23398778f, 
    -0.22417094f, -0.09694842f, -0.01919705f, -0.02043422f, -0.07508241f, -0.05884856f, 0.15552488f, 0.01324380f, 
    0.40863460f, -0.07670612f, -0.01409731f, -0.01433389f, 0.06788353f, 0.18372644f, 0.02310724f, -0.17448710f, 
    -0.09723771f, 0.09029021f, 0.17386737f, 0.04214748f, 0.02796084f, 0.04894812f, -0.00718506f, 0.06622641f, 
    -0.31613278f, -0.15825394f, 0.22038211f, -0.03520808f, -0.13014051f, 0.06083925f, -0.04229383f, -0.19719476f, 
    -0.21209888f, 0.03685315f, -0.23149477f, -0.43517217f, 0.09150007f, -0.01739419f, 0.10604963f, 0.01569022f, 
    0.00579034f, 0.06031703f, 0.48869738f, -0.00380769f, -0.15758285f, -0.07016047f, -0.14556955f, -0.04060667f, 
    -0.04790090f, 0.09886505f, 0.07538167f, -0.21761847f, -0.32935420f, 0.05649630f, 0.02321222f, 0.06779399f, 
    -0.24590608f, 0.07938799f, -0.18774685f, 0.23376644f, -0.08538549f, -0.09708507f, 0.27226591f, -0.06590091f, 
    0.08913121f, 0.07809912f, -0.06868599f, -0.00833264f, 0.01983594f, 0.43814746f, 0.07842807f, -0.00510399f, 
    -0.17837618f, -0.12937029f, 0.08225616f, 0.20829301f, -0.08938359f, -0.04536667f, 0.15731427f, 0.05000935f, 
    -0.05196563f, -0.05647141f, -0.25200972f, -0.25531015f, 0.09408262f, -0.04279327f, 0.02627113f, 0.26515913f, 
    0.10168935f, -0.51862633f, -0.11476681f, -0.07413096f, 0.02560735f, 0.00240888f, -0.01976077f, -0.02153623f, 
    -0.11467239f, 0.18110242f, -0.43920779f, -0.18457326f, -0.07910889f, 0.15796630f, 0.03075104f, 0.16978738f, 
    -0.08139956f, 0.12071794f, 0.07018378f, 0.26201534f, 0.07968751f, -0.08994367f, 0.10245296f, 0.28096053f, 
    0.00074312f, 0.10349757f, 0.15506439f, -0.15322280f, 0.10034793f, -0.14572322f, -0.07610292f, 0.01239832f, 
    -0.06223517f, -0.14939982f, -0.09333778f, 0.01059872f, -0.15695800f, 0.14968008f, -0.02820746f, -0.12536003f, 
    -0.00065369f, -0.07743526f, -0.07144405f, -0.24806827f, 0.00216778f, 0.14535476f, -0.32703757f, 0.17483285f, 
    0.09788121f, -0.11900923f, -0.03696560f, 0.08847652f, 0.03265475f, -0.06222320f, 0.14882493f, -0.00230682f, 
    -0.30425271f, -0.13898388f, -0.07534489f, 0.08345853f, -0.00261526f, 0.03520276f, -0.26533937f, -0.24012169f, 
    0.25048566f, 0.03746094f, 0.07287844f, 0.09597997f, -0.22884037f, 0.14445096f, 0.04517952f, 0.17062204f, 
    -0.04663118f, -0.08940801f, -0.04620474f, -0.05644136f, -0.04083302f, 0.03147166f, -0.16008553f, -0.12982374f, 
    0.31521875f, -0.09625673f, -0.07079462f, -0.09242234f, -0.12190633f, 0.09601970f, 0.00009580f, -0.09638837f, 
    -0.14780340f, 0.14673574f, -0.08226054f, -0.00445509f, -0.09655991f, 0.02595527f, -0.02539434f, 0.07567126f, 
    0.07668345f, -0.01192453f, -0.01875698f, -0.00149924f, 0.07120998f, 0.01368707f, -0.15863658f, -0.02765570f, 
    0.25158551f, 0.22208859f, 0.09862120f, -0.00114738f, -0.01264792f, -0.11624192f, 0.09344808f, -0.03397742f, 
    -0.00382278f, 0.07431137f, 0.00899933f, 0.11387268f, 0.56007016f, -0.01067132f, 0.02038014f, -0.06264647f, 
    -0.25352326f, 0.01473609f, 0.07106800f, -0.02384664f, 0.03476376f, -0.39419413f, -0.22292773f, -0.02519185f, 
    0.08106627f, -0.00620841f, 0.02840770f, -0.12998176f, -0.07379477f, 0.09529335f, 0.15512520f, -0.11312061f, 
    0.02887766f, -0.03369275f, 0.04859838f, -0.02303214f, 0.30806828f, 0.23937686f, 0.24963929f, -0.03653347f, 
    -0.08602094f, 0.04308593f, 0.07773799f, 0.09217756f, -0.07333806f, -0.09294536f, -0.08873868f, -0.11143824f, 
    0.04417238f, 0.53893554f, -0.18901992f, 0.05782009f, 0.17452472f, -0.14617971f, 0.33277664f, 0.11356336f, 
    -0.22600789f, 0.06253693f, 0.03522486f, -0.34675956f, -0.09386967f, 0.11049791f, -0.08193151f, -0.05630583f, 
    -0.20298843f, -0.35368612f, 0.01816825f, 0.09897586f, -0.19468756f, -0.05981870f, 0.02611424f, -0.05297523f, 
    0.12643282f, 0.14771250f, -0.08976091f, 0.14197694f, 0.01086661f, -0.27910107f, 0.33267796f, 0.09794607f, 
    0.11582900f, 0.15791482f, 0.16649044f, -0.04261865f, 0.17281651f, -0.08346432f, -0.13656907f, 0.27019960f, 
    -0.05558282f, 0.01032386f, 0.05571094f, 0.03295926f, 0.01892422f, 0.04908724f, 0.10044498f, -0.14506534f, 
    -0.05779572f, 0.07539715f, 0.11391000f, 0.05710452f, 0.11204246f, 0.01566015f, 0.11612318f, 0.12783405f, 
    0.35848495f, 0.14440794f, 0.02917605f, -0.06287658f, 0.16780414f, 0.12501152f, -0.16299583f, 0.00071652f, 
    -0.26214355f, -0.25235435f, 0.14226235f, 0.11794113f, 0.03595216f, -0.12049592f, -0.09707811f, 0.11012638f, 
    0.35442361f, -0.17981648f, -0.15409549f, 0.17656709f, 0.00869269f, -0.02090543f, -0.06823207f, -0.18556406f, 
    -0.32082006f, -0.11677448f, 0.04842585f, -0.49614275f, 0.03276393f, 0.16940498f, -0.08723653f, -0.01230167f, 
    0.01502907f, -0.01266355f, 0.04366883f, -0.06977392f, 0.07722118f, 0.13195224f, -0.28306335f, -0.19071522f, 
    0.07515501f, 0.08431111f, 0.06898018f, 0.12457053f, 0.01388071f, 0.13101773f, 0.21537900f, -0.22328408f, 
    -0.12550446f, 0.12454744f, -0.15957788f, 0.00346513f, 0.03771039f, -0.04059133f, -0.02742957f, -0.02319352f, 
    0.01169062f, -0.03313754f, -0.00027462f, 0.11625569f, -0.04701013f, 0.10897373f, 0.14239155f, 0.05201780f, 
    0.12399599f, 0.04127258f, -0.26809731f, 0.19344942f, 0.21407008f, -0.00243128f, -0.49721479f, 0.04036808f, 
    0.04312355f, -0.11785582f, -0.17583640f, -0.02237977f, 0.06898689f, 0.03766879f, 0.00196200f, -0.01138293f, 
    0.32923648f, 0.12004467f, 0.03535962f, 0.07709812f, -0.03599259f, 0.06515471f, 0.08244797f, -0.22319680f, 
    -0.08557306f, 0.13828062f, 0.05665515f, -0.02669882f, 0.00788297f, -0.07571790f, 0.02195187f, 0.22514661f, 
    -0.05187286f, 0.10522204f, -0.00720850f, -0.02298260f, 0.17271301f, -0.00141091f, 0.00602996f, -0.00583262f, 
    0.30430436f, 0.11633968f, -0.22387122f, 0.37006268f, 0.30042383f, -0.11785606f, -0.03752303f, 0.07718274f, 
    -0.11166569f, -0.21754970f, -0.11557639f, 0.01788421f, -0.26684114f, -0.06713426f, -0.02802072f, -0.04994224f, 
    0.08648828f, 0.01900580f, -0.34783226f, -0.33258757f, 0.23282985f, 0.13708462f, -0.07267759f, 0.08363234f, 
    0.01559172f, 0.08922272f, -0.01868000f, -0.03319923f, -0.01014821f, -0.04000293f, 0.25448102f, 0.29512182f, 
    -0.18074511f, -0.08757400f, -0.08816245f, -0.00853521f, 0.02457439f, -0.00010667f, 0.10256013f, -0.13247526f, 
    -0.17697556f, 0.11348566f, -0.00088914f, -0.04605070f, -0.16173138f, -0.24788623f, -0.07545499f, 0.27445221f, 
    -0.03951719f, 0.05570814f, -0.04334258f, 0.04396584f, -0.04003467f, 0.22543512f, 0.03193196f, -0.04590905f, 
    -0.12507248f, 0.40382466f, 0.22001417f, -0.00215347f, -0.12173194f, -0.02324781f, -0.08208276f, -0.17886943f, 
    -0.03231679f, -0.07214881f, 0.06423428f, -0.47771269f, 0.05349892f, 0.11146751f, 0.13739845f, -0.01216340f, 
    -0.01420919f, -0.12688102f, 0.05368575f, 0.00898184f, -0.19663636f, 0.06299862f, -0.03021454f, -0.05704011f, 
    0.04489661f, 0.08273718f, 0.11704641f, -0.03096252f, -0.05904377f, 0.25393528f, 0.17095137f, 0.05992743f, 
    0.01982179f, 0.08103068f, 0.23741493f, -0.01347935f, -0.31740099f, 0.01150208f, 0.33746278f, 0.02222458f, 
    -0.29197472f, 0.06590365f, 0.02866893f, -0.01974142f, 0.09617058f, 0.14318766f, -0.12394839f, -0.25033429f, 
    0.14830108f, 0.07700817f, -0.11378835f, 0.19791356f, 0.08708473f, -0.13875878f, 0.01811440f, -0.09736782f, 
    -0.07799560f, 0.16276538f, -0.01622135f, -0.01067435f, 0.17491308f, 0.17115355f, 0.01147167f, 0.07696384f, 
    -0.26308683f, -0.07700840f, 0.03695781f, 0.02303509f, -0.11547557f, -0.10984499f, -0.17370623f, -0.28862295f, 
    -0.05030623f, 0.05760774f, 0.00436701f, -0.02068658f, 0.00832699f, -0.04417751f, 0.03040595f, -0.04644886f, 
    -0.04805967f, -0.01955046f, -0.01082584f, 0.01904660f, -0.00914117f, -0.03165323f, -0.00110794f, -0.05101268f, 
    0.02587500f, -0.00727668f, 0.03253559f, 0.00846574f, -0.01270037f, -0.00363320f, 0.02218342f, 0.04494070f, 
    0.02585262f, -0.04936361f, 0.00276098f, 0.01209751f, -0.02622902f, -0.02381678f, 0.00990007f, -0.02591242f, 
    -0.03098467f, 0.00007456f, 0.01077515f, -0.01432129f, 0.01929057f, -0.01405585f, 0.01569171f, -0.02415494f, 
    0.00680671f, -0.02854859f, 0.03414461f, -0.04794146f, -0.01049199f, -0.05997722f, -0.05257340f, -0.05173532f, 
    -0.04184128f, -0.00225258f, 0.03954457f, -0.02686031f, -0.03110446f, -0.02824352f, -0.01777393f, 0.00895530f, 
    -0.04907179f, 0.05077914f, 0.00946488f, -0.01379637f, -0.03313340f, -0.00831670f, 0.01991385f, 0.02383460f, 
    -0.03698900f, -0.00049712f, -0.04088011f, -0.05619726f, -0.01709421f, 0.02252150f, -0.04422059f, 0.02214475f, 
    -0.04298872f, 0.01381925f, 0.02137846f, 0.01230542f, -0.01783192f, -0.03114088f, -0.02870049f, -0.04397186f, 
    -0.05156688f, 0.01069156f, 0.04477003f, -0.03477821f, -0.01218951f, -0.05517472f, 0.01316291f, 0.00066325f, 
    0.02477477f, 0.00148039f, 0.03979171f, 0.04618459f, 0.03734028f, -0.03802137f, 0.02022382f, -0.01411105f, 
    0.03683085f, 0.03575964f, -0.06739346f, 0.00040186f, 0.03731288f, -0.01462048f, -0.05952367f, -0.04046632f, 
    0.03078007f, 0.01465749f, -0.06495514f, -0.03381874f, -0.02427637f, -0.00267525f, -0.00101651f, -0.01926740f, 
    -0.03511747f, -0.00485764f, -0.02381709f, 0.03393566f, -0.02826304f, -0.01882273f, -0.03563766f, -0.02760231f, 
    0.02625152f, 0.01484191f, 0.05504198f, -0.03018975f, -0.04167030f, 0.01007776f, 0.03921100f, 0.05240722f, 
    0.05296649f, -0.01873808f, -0.04787748f, -0.04648443f, 0.00322077f, -0.01826008f, -0.03355512f, 0.05660791f, 
    -0.05881529f, 0.01001974f, 0.04735481f, 0.00049294f, -0.03648425f, 0.04502562f, 0.02745243f, -0.05533805f, 
    -0.00852500f, -0.03438797f, -0.04156504f, -0.05357781f, -0.03958561f, 0.02974305f, -0.01718034f, -0.00683535f, 
    -0.01046876f, -0.03548465f, -0.00989939f, -0.02117907f, 0.04267918f, -0.01458591f, 0.02197675f, 0.04209198f, 
    -0.06330393f, 0.04971180f, -0.03267899f, -0.01157488f, -0.03402556f, 0.04805081f, 0.02910428f, -0.02910360f, 
    -0.00466889f, -0.01591981f, -0.01296740f, -0.05433336f, 0.04227871f, -0.04700640f, 0.00608248f, 0.01346378f, 
    0.01325262f, 0.01836118f, -0.04016891f, -0.02162532f, 0.03415672f, -0.00622048f, 0.01410124f, -0.05395737f, 
    0.00869561f, -0.02181164f, -0.02024787f, -0.01606117f, -0.03913172f, -0.05797471f, 0.00773565f, 0.00987680f, 
    -0.00003988f, 0.02000700f, -0.05306848f, -0.01918277f, 0.03207827f, 0.00030858f, 0.03130510f, -0.04139838f, 
    -0.05047664f, -0.02334133f, -0.02367239f, -0.03528316f, -0.05756965f, -0.03073760f, 0.00339499f, -0.00805844f, 
    -0.04790993f, -0.05777061f, 0.02185799f, 0.03571067f, 0.03587151f, 0.01511662f, -0.05590890f, -0.03893650f, 
    -0.01121302f, -0.02250011f, 0.00043603f, -0.04995068f, -0.02744840f, 0.04277416f, 0.00021938f, 0.02436831f, 
    -0.00457087f, -0.06127143f, -0.01128454f, 0.02967859f, -0.01800923f, 0.04878344f, -0.00483479f, -0.06359577f, 
    -0.00943698f, -0.01214819f, -0.04345540f, 0.00813350f, -0.04611352f, 0.00718630f, -0.04394988f, -0.01116437f, 
    -0.03155071f, -0.01667797f, 0.01997187f, 0.03066731f, 0.04428410f, -0.04177886f, 0.05367452f, 0.04848680f, 
    -0.04666386f, -0.05197547f, 0.03686113f, -0.01759072f, 0.04794382f, 0.00487819f, -0.03397122f, 0.04824438f, 
    -0.04325720f, -0.00053941f, 0.00834869f, 0.01524567f, -0.02722422f, -0.05218947f, -0.00700607f, -0.01114586f, 
    -0.01209306f, 0.03286165f, -0.03113873f, -0.00223753f, 0.02368065f, -0.02852301f, 0.03000803f, 0.00672414f, 
    0.02239804f, 0.02996120f, -0.02658825f, -0.05687831f, 0.01790928f, 0.04033342f, -0.03827178f, 0.01807124f, 
    -0.00963091f, 0.04720650f, -0.00600368f, 0.02780753f, -0.06190076f, -0.04558296f, 0.03244579f, -0.03721637f, 
    0.10408475f, -0.33378011f, 0.37933087f, 0.17483836f, -0.02266240f, -0.13440652f, -0.06414689f, -0.09878527f, 
    -0.00877745f, 0.02716259f, -0.62090498f, -0.20054133f, 0.13722800f, -0.14498407f, -0.07053670f, 0.07028903f, 
    -0.07902545f, 0.00246907f, -0.39073944f, 0.03652308f, 0.06272489f, 0.03730778f, 0.06147442f, -0.05005451f, 
    0.25454563f, 0.22307925f, 0.12401820f, -0.25810435f, -0.44322997f, -0.06212441f, 0.19421542f, -0.16494489f, 
    0.12067556f, 0.03677584f, 0.27079466f, 0.23512167f, -0.04180891f, -0.26065639f, -0.13139845f, 0.05015190f, 
    -0.00860377f, 0.06777975f, -0.02461439f, 0.19037932f, -0.22522584f, -0.17951700f, -0.11792739f, -0.05140143f, 
    -0.03782612f, 0.06422512f, 0.12515914f, 0.09459585f, 0.14323264f, -0.02964430f, 0.14200377f, 0.21091452f, 
    0.40884843f, 0.06868737f, 0.00527274f, 0.10238092f, 0.03108441f, 0.06159332f, 0.06373866f, -0.12898774f, 
    -0.21732377f, -0.33422536f, 0.14464419f, -0.06451467f, 0.11070497f, 0.05057526f, 0.09049036f, 0.05042775f, 
    0.30518448f, -0.29568106f, -0.04640681f, 0.04420649f, 0.10618659f, 0.11624536f, -0.00065027f, -0.16590561f, 
    -0.13639362f, -0.23342925f, -0.03206627f, -0.08233272f, -0.04180829f, 0.00495279f, -0.01043842f, -0.08086647f, 
    0.05412385f, 0.28829110f, 0.04175843f, -0.11543235f, 0.08622285f, 0.00977120f, -0.01105632f, 0.06322938f, 
    -0.00250884f, 0.04997521f, 0.13211480f, 0.02491125f, 0.00379719f, -0.27774704f, -0.24002765f, 0.02504318f, 
    0.09644794f, 0.31689999f, 0.05911888f, 0.03984310f, -0.25919461f, -0.15785682f, -0.12812972f, -0.05346935f, 
    -0.01661334f, 0.04339847f, 0.05074748f, -0.15496270f, -0.05819752f, 0.11387161f, -0.21021116f, -0.08840084f, 
    0.11325678f, -0.12580070f, -0.16303863f, -0.13702798f, 0.24924898f, 0.05581442f, -0.22717786f, 0.24850398f, 
    0.18186700f, 0.05345014f, -0.00833081f, -0.05299326f, 0.07360629f, 0.02301244f, -0.06494112f, -0.02611461f, 
    0.14815886f, 0.20153421f, 0.15722667f, -0.05526429f, 0.08485946f, 0.11114392f, 0.09306329f, -0.07295171f, 
    -0.08339165f, 0.21786369f, 0.11426777f, 0.01510129f, -0.03939730f, -0.06416926f, 0.14787763f, 0.04950433f, 
    -0.00466935f, -0.18579800f, -0.15023817f, -0.04772632f, -0.00793932f, 0.04770207f, -0.05852385f, -0.10226228f, 
    0.21679065f, 0.07714212f, -0.15783370f, 0.16013972f, 0.30983323f, 0.00533623f, -0.10691322f, 0.07959538f, 
    -0.04669253f, -0.14630777f, -0.04098154f, -0.46612769f, -0.49483046f, -0.15799053f, 0.02543963f, -0.12632370f, 
    -0.02512604f, -0.15548611f, -0.14863278f, 0.03506886f, 0.06791493f, 0.18440980f, -0.10534378f, -0.02393404f, 
    0.28012496f, 0.08065968f, 0.03766097f, 0.02474337f, -0.05173698f, -0.00406589f, 0.14264542f, 0.31116700f, 
    -0.24110772f, -0.03375129f, 0.00667618f, -0.03298257f, 0.07097754f, 0.01945029f, -0.01796278f, -0.27277705f, 
    0.02149579f, 0.00445770f, 0.06711523f, 0.07989059f, 0.02752293f, -0.12284327f, -0.16785721f, -0.19220042f, 
    -0.00045849f, -0.05625475f, 0.11393025f, -0.18948504f, -0.05884099f, 0.09751141f, -0.06685792f, 0.04784372f, 
    0.05585093f, 0.21981078f, 0.25078049f, 0.09741860f, -0.13399029f, 0.17584494f, -0.01736989f, -0.02782804f, 
    0.03661681f, -0.00484815f, -0.23989387f, 0.03597246f, -0.05536537f, -0.05751980f, 0.03825724f, -0.02022316f, 
    0.06273232f, 0.12758966f, -0.17796691f, -0.05468931f, -0.16003096f, -0.00182368f, 0.03177278f, 0.05234447f, 
    0.12508540f, 0.23660484f, 0.15347201f, 0.04462664f, 0.07826270f, 0.08414478f, 0.13551179f, 0.17226161f, 
    -0.04306947f, 0.07942681f, 0.14706275f, -0.20035909f, -0.01045066f, -0.08417812f, 0.31791744f, -0.02944195f, 
    -0.24853384f, 0.18575808f, 0.02988598f, 0.06027257f, -0.02176388f, -0.17388739f, -0.43372127f, -0.34267980f, 
    0.13832054f, -0.09139363f, 0.19699918f, -0.01873806f, 0.04548528f, 0.18339929f, -0.02476872f, -0.02254887f, 
    0.20915195f, 0.20077051f, 0.10835904f, 0.04232188f, -0.02845871f, 0.22721149f, 0.23159651f, -0.26689383f, 
    -0.13577670f, -0.09840749f, -0.09271212f, 0.04459893f, 0.10577474f, 0.03383019f, 0.10257382f, 0.04422608f, 
    -0.16801772f, -0.23926748f, -0.67359024f, -0.20923191f, -0.02415904f, -0.09380154f, 0.23633853f, 0.38156828f, 
    -0.09839795f, 0.01225112f, 0.20234847f, -0.01533310f, -0.18753318f, -0.14316002f, 0.00792088f, 0.07887134f, 
    0.21280274f, 0.12110308f, 0.06567544f, 0.17850283f, -0.07052831f, 0.03606000f, -0.10988040f, 0.06691810f, 
    0.17175989f, 0.20967591f, 0.07310608f, -0.29130325f, -0.19943257f, -0.11683327f, 0.18048431f, 0.01784883f, 
    -0.03529483f, -0.06099546f, -0.08236390f, 0.08883663f, 0.01445552f, -0.13412367f, -0.15622777f, 0.06117889f, 
    0.04799784f, -0.00474687f, 0.17952357f, 0.08160508f, 0.08742568f, -0.00577532f, 0.05873189f, -0.09748626f, 
    -0.07231705f, 0.07635510f, 0.05022144f, 0.22040752f, 0.08856744f, 0.02378712f, 0.17181820f, -0.04961892f, 
    0.02069594f, 0.26090333f, 0.04803975f, 0.10689310f, 0.03348174f, -0.04501473f, -0.00033295f, 0.12928936f, 
    -0.09242094f, -0.11677280f, 0.10477623f, -0.00666364f, -0.07823654f, -0.08489548f, 0.07949426f, 0.14056513f, 
    0.15147252f, -0.20366430f, 0.10930546f, -0.17945506f, -0.21668053f, -0.13224240f, -0.02743080f, 0.19317299f, 
    0.10365918f, 0.39527351f, -0.07223129f, -0.35283563f, 0.30397123f, 0.15670523f, 0.05124027f, 0.21743810f, 
    0.06549726f, -0.11739690f, -0.12213869f, -0.32587707f, 0.01136598f, 0.06650440f, 0.06422895f, 0.13040030f, 
    -0.18056273f, -0.09825522f, 0.01980028f, -0.04520213f, 0.08104700f, 0.18492708f, 0.07087056f, 0.02445917f, 
    0.12442449f, 0.05078687f, 0.15999092f, -0.04413739f, 0.04324789f, 0.04111732f, -0.05846235f, -0.17735274f, 
    -0.13883306f, -0.13918020f, 0.11696312f, 0.04863569f, 0.12903582f, -0.05776595f, -0.25214633f, -0.20386410f, 
    -0.00284680f, 0.11213121f, 0.03560980f, 0.17151822f, -0.05751032f, 0.09535921f, 0.20426969f, 0.22541618f, 
    0.13577682f, -0.00511055f, 0.02267346f, 0.03898014f, -0.10263526f, -0.20445906f, -0.01492974f, 0.07034209f, 
    -0.09707633f, -0.23240991f, 0.11507519f, 0.05696300f, -0.05282201f, -0.13616824f, 0.07531798f, -0.19852749f, 
    0.22008796f, 0.26787952f, 0.27279198f, 0.05035491f, -0.00427061f, 0.08559979f, -0.15220791f, 0.10458868f, 
    0.01144708f, -0.00404385f, 0.03741620f, -0.09403887f, 0.05418428f, 0.00477582f, -0.12484039f, 0.09544451f, 
    0.04459033f, 0.10023378f, 0.03267202f, 0.01734901f, -0.08878665f, 0.00543819f, 0.11589270f, 0.28527939f, 
    0.15227470f, -0.03795425f, -0.03438206f, 0.25193986f, 0.11776850f, -0.04962765f, -0.37171608f, -0.06182335f, 
    0.16296060f, 0.20792931f, -0.11457523f, 0.19120188f, 0.35435337f, -0.03708415f, 0.06315599f, 0.10557692f, 
    0.07402052f, 0.02613051f, -0.01864069f, 0.24657202f, 0.13332438f, 0.11363098f, 0.05226510f, 0.00484090f, 
    0.13259476f, -0.01568288f, -0.00587603f, -0.14829591f, 0.20112580f, -0.06133796f, 0.06247223f, -0.01138231f, 
    0.01140299f, -0.20424321f, -0.13605930f, -0.22761598f, 0.05230422f, 0.04210094f, 0.00686532f, -0.09693439f, 
    -0.13831881f, -0.03761464f, -0.05102317f, 0.20851952f, -0.11478333f, 0.08928116f, -0.03312032f, -0.02268353f, 
    0.05007422f, 0.06462079f, 0.03730614f, 0.03059024f, 0.23460589f, 0.20465310f, 0.04234849f, -0.05036483f, 
    0.06220993f, -0.04426789f, 0.23669742f, 0.09681203f, 0.22152595f, 0.14573771f, 0.18680410f, 0.17639676f, 
    0.00081444f, 0.00952500f, 0.05892882f, -0.03374051f, -0.08778841f, -0.05029793f, 0.01948134f, -0.01119886f, 
    0.13902168f, 0.19181715f, 0.05496968f, 0.31890091f, 0.02931272f, 0.14304228f, 0.00412190f, -0.00102729f, 
    0.09498046f, 0.26077709f, 0.10583998f, 0.27356929f, -0.29022864f, -0.26439318f, -0.08368960f, 0.02278185f, 
    0.11874521f, 0.12370390f, -0.07233711f, -0.14243570f, -0.08628879f, -0.14637454f, -0.03297981f, 0.04640985f, 
    0.07671333f, 0.05457494f, -0.03965283f, 0.06499954f, 0.08947587f, 0.10405580f, -0.10274596f, -0.22425447f, 
    -0.12222965f, 0.00616675f, 0.03274701f, 0.07546246f, 0.13716355f, 0.05421885f, 0.13000934f, -0.06870548f, 
    -0.08210664f, -0.08198462f, -0.01435367f, 0.00287810f, -0.06174490f, -0.05533472f, 0.18853328f, 0.25708386f, 
    -0.90295762f, -0.32897380f, -0.30423722f, 0.01584130f, -0.35719502f, 0.02089146f, -0.02155905f, -0.10760842f, 
    0.12039780f, -0.12604666f, 0.24632551f, -0.10817011f, -0.06637119f, -0.08883001f, -0.00349011f, -0.00365318f, 
    0.12290643f, 0.19901775f, 0.09857371f, -0.03718384f, -0.03126298f, 0.11496419f, 0.03148397f, 0.11729237f, 
    0.19773509f, 0.26649475f, -0.04893812f, 0.16854475f, -0.31975275f, -0.74846172f, 0.06474208f, -0.05401448f, 
    0.21711351f, -0.11767039f, -0.20479566f, -0.21114916f, 0.02214132f, -0.29600227f, -0.38864368f, -0.12864521f, 
    -0.35489798f, -0.03338954f, 0.07150915f, -0.00918615f, -0.14407627f, -0.10330151f, -0.00595533f, -0.15604597f, 
    -0.09617523f, -0.10455287f, -0.16924797f, 0.03688127f, -0.11829358f, 0.00627169f, -0.12889765f, -0.79189742f, 
    -0.42728937f, -0.01560814f, 0.05737317f, -0.12646563f, 0.17249773f, -0.05138383f, -0.07031398f, 0.07562383f, 
    -0.07476509f, -0.16681540f, -0.19937773f, 0.11618063f, 0.11185685f, -0.03351484f, 0.07695313f, 0.05587061f, 
    -0.62357664f, -0.49713874f, -0.17480887f, -0.21661778f, -0.12364192f, -0.02668757f, 0.05223283f, 0.00876791f, 
    -0.03789471f, -0.34680852f, -0.12789130f, -0.24914758f, 0.13160573f, 0.08542491f, 0.04277773f, 0.23871881f, 
    -0.03142299f, -0.01408154f, -0.11941050f, 0.64297152f, 0.59758526f, 0.07223958f, 0.15355885f, 0.09350541f, 
    0.08747040f, 0.07322156f, 0.17331433f, -0.21646577f, -0.42346460f, -0.12003148f, 0.00951436f, -0.02851342f, 
    -0.08623409f, 0.00547049f, -0.03024873f, 0.27325457f, -0.23880796f, 0.00389613f, 0.00714614f, -0.17186135f, 
    -0.01452887f, -0.09722652f, 0.08426863f, -0.09108187f, 0.17654142f, 0.11781733f, -0.34173515f, 0.15718393f, 
    -0.02595218f, -0.04184869f, 0.17927673f, 0.09669019f, -0.02387965f, 0.07846864f, -0.26480344f, -0.09813142f, 
    0.23358437f, -0.20612159f, -0.13728946f, -0.02200420f, -0.12722556f, -0.03969333f, 0.04832097f, -0.49532872f, 
    -0.36918533f, -0.95744699f, -0.13913490f, -0.03946852f, -0.50043339f, -0.01020996f, -0.17693120f, -0.16985643f, 
    0.03166591f, 0.04548184f, -0.02479132f, 0.09160523f, 0.02275668f, -0.00853582f, 0.17479965f, 0.04586449f, 
    -0.04822843f, 0.28452405f, -0.12676707f, -0.05250831f, -0.03726733f, -0.03027286f, 0.07115857f, 0.12315868f, 
    0.07317866f, 0.02116898f, -0.14541587f, 0.04796873f, 0.52669913f, -0.15489261f, -0.14179265f, -0.12184311f, 
    0.12255347f, 0.13547713f, 0.11643762f, 0.08118618f, 0.06822287f, -0.08578397f, -0.03639910f, -0.12397216f, 
    -0.22766843f, 0.04154574f, 0.05034348f, 0.16906637f, 0.20456921f, 0.02482991f, -0.19536904f, 0.03369194f, 
    0.12694736f, 0.11046572f, 0.02711293f, -0.02972398f, 0.11257602f, -0.15648244f, -0.34569874f, 0.12424380f, 
    0.02160999f, -0.11317082f, -0.42155465f, 0.00743956f, -0.17024903f, 0.01348357f, -0.40861803f, -0.11893488f, 
    -0.19554961f, -0.02558970f, 0.01526436f, 0.02987796f, 0.16066496f, -0.00579776f, 0.18518960f, 0.32350338f, 
    -0.49876252f, -0.32391259f, 0.03082143f, -0.29620957f, 0.06302533f, -0.12244350f, 0.06204388f, -0.05209764f, 
    -0.05773802f, -0.07464529f, 0.37171441f, 0.02312424f, -0.08901234f, 0.09982930f, 0.14842094f, 0.19616722f, 
    0.21156150f, 0.14690448f, 0.65995115f, 0.03281595f, -0.06235187f, 0.00082981f, 0.17852333f, -0.03825231f, 
    0.06292173f, 0.09598865f, 0.01734309f, -0.09320979f, -0.07555185f, -0.01781527f, -0.08709173f, -0.10616641f, 
    -0.05438145f, 0.05598412f, -0.15939614f, 0.04385874f, -0.15010336f, -0.07377469f, 0.05854477f, 0.04802703f, 
    0.08989663f, 0.05614664f, -0.00787340f, 0.20255420f, -0.37903157f, 0.23211528f, 0.53217643f, -0.27504998f, 
    -0.06252602f, 0.05573320f, -0.06422959f, 0.05182723f, 0.02703576f, 0.02557744f, -0.08362094f, 0.09694793f, 
    0.08263502f, 0.02104350f, 0.02697922f, 0.25183845f, 0.09002734f, -0.01767596f, 0.07073433f, -0.00939391f, 
    -0.07952200f, 0.02737954f, -0.00145081f, -0.05309227f, 0.10399887f, -0.00589607f, 0.06283817f, 0.07014100f, 
    -0.20203368f, -0.07074932f, 0.16706966f, 0.09726798f, 0.19785155f, 0.15556929f, 0.00273797f, 0.16608849f, 
    0.02384792f, 0.05856217f, -0.03584329f, 0.04951527f, 0.01484977f, 0.04955940f, 0.03595627f, 0.02695306f, 
    -0.02141215f, 0.01426200f, -0.04399932f, -0.02814366f, -0.01578053f, -0.04759065f, -0.00204488f, 0.04392770f, 
    0.00641357f, 0.05284117f, -0.01331656f, -0.04522146f, 0.01306644f, -0.03753939f, 0.03245290f, -0.00136507f, 
    -0.04232595f, -0.00173527f, -0.02518080f, 0.05342629f, 0.03932882f, -0.04067740f, 0.03303126f, -0.01151155f, 
    -0.05840092f, 0.02833398f, 0.04070245f, -0.01320586f, -0.04466794f, -0.05134682f, -0.02756927f, -0.05792083f, 
    0.00035062f, 0.04603462f, 0.05007983f, -0.06140304f, 0.01059675f, -0.01647668f, 0.00002572f, 0.01678822f, 
    -0.05745585f, -0.06249006f, -0.02612404f, -0.06062965f, 0.02430318f, 0.02337439f, -0.02979746f, -0.04351473f, 
    -0.05252360f, -0.00917467f, -0.04514765f, -0.02812446f, 0.01954214f, 0.03984038f, -0.03082684f, 0.04786001f, 
    -0.03895112f, -0.04753124f, -0.01302970f, -0.00271028f, 0.02413482f, -0.01784021f, 0.02401476f, -0.06227019f, 
    -0.04335002f, -0.05260951f, 0.00178576f, -0.00778995f, 0.05428280f, -0.00395309f, -0.04255366f, -0.00848561f, 
    0.02558096f, -0.06071802f, -0.04522133f, -0.02529395f, 0.02363060f, -0.02911975f, 0.03930033f, 0.00290292f, 
    0.04400844f, 0.01574179f, 0.00521229f, -0.04411465f, -0.05657573f, -0.04029178f, -0.03657020f, 0.03532690f, 
    -0.04868257f, 0.04595181f, -0.01212932f, 0.01759016f, -0.01489066f, 0.03071978f, 0.00306413f, 0.02138150f, 
    0.03895715f, 0.05056801f, -0.01868611f, 0.01832511f, -0.04136710f, 0.02673339f, 0.02745798f, 0.03496432f, 
    -0.04353705f, -0.04794517f, -0.04012138f, -0.00591754f, 0.04998881f, -0.01181417f, 0.02650282f, 0.01429160f, 
    -0.01107812f, 0.04938298f, 0.01562085f, 0.05209427f, -0.02763152f, 0.01125861f, 0.01810004f, -0.04626524f, 
    -0.03025407f, -0.06245258f, -0.02712307f, 0.05339191f, -0.04725777f, -0.05204476f, 0.04408805f, 0.00477686f, 
    0.03203400f, -0.03450983f, -0.04894144f, 0.03255330f, -0.03493306f, 0.00906216f, 0.05039714f, 0.01513464f, 
    -0.03707728f, -0.01390587f, 0.04484921f, 0.00436831f, -0.05093640f, -0.02917848f, -0.05148394f, 0.05123523f, 
    -0.03104385f, -0.02607958f, -0.04261118f, 0.03435284f, -0.01068358f, -0.03890672f, -0.03839019f, 0.03691667f, 
    -0.04708480f, -0.00897317f, -0.04106515f, 0.00958644f, -0.04236221f, 0.00883633f, 0.05321825f, 0.01737978f, 
    -0.04297220f, -0.05002241f, -0.00186023f, -0.00801032f, -0.03529233f, -0.06202120f, -0.05332887f, -0.02230708f, 
    -0.01807533f, -0.01051641f, -0.00384979f, 0.05294621f, -0.00871514f, -0.02340080f, 0.03400613f, -0.04082682f, 
    -0.05485490f, 0.01324126f, -0.02050740f, -0.00497912f, -0.02957794f, 0.02113674f, 0.02690651f, -0.03979049f, 
    0.00322631f, -0.00515674f, -0.00981024f, -0.03422092f, -0.03967629f, 0.02759870f, -0.03567184f, 0.01876134f, 
    -0.05256322f, -0.02438296f, -0.04758916f, 0.05318510f, -0.02013203f, -0.04136368f, -0.00546088f, -0.05147902f, 
    -0.00864660f, 0.01376476f, -0.06002617f, 0.04933196f, -0.06319807f, -0.04644106f, 0.02134403f, 0.03365399f, 
    -0.00349584f, 0.02442276f, -0.02274842f, 0.03006239f, -0.02260606f, 0.00958452f, 0.00157726f, 0.03358223f, 
    -0.06246509f, -0.05564724f, -0.00909660f, -0.01120543f, -0.02028271f, 0.01643374f, -0.05149157f, 0.01665312f, 
    -0.04810437f, -0.05698688f, -0.02775741f, -0.04893388f, -0.04718414f, -0.04854586f, -0.04297864f, -0.03320105f, 
    0.05097739f, 0.05315000f, 0.02876943f, 0.02712872f, 0.01319122f, -0.05510064f, 0.03071820f, -0.06198581f, 
    0.00042115f, -0.05271004f, -0.05348060f, -0.02067575f, -0.01732058f, 0.01945821f, 0.00013817f, 0.04669397f, 
    0.00767235f, 0.00139916f, 0.00224221f, -0.02128452f, -0.02411532f, 0.02297955f, -0.03286045f, -0.03589848f, 
    -0.05675794f, 0.02147836f, -0.06208466f, -0.01329945f, 0.03015138f, 0.01668954f, -0.03662521f, -0.04232384f, 
    0.05129182f, 0.05351838f, 0.00865779f, 0.00827288f, -0.04387226f, -0.01919680f, -0.03773144f, 0.03028247f, 
    -0.00399338f, -0.00207750f, -0.02818535f, -0.03786472f, 0.05379939f, 0.04934853f, 0.04213249f, -0.03036765f, 
    -0.29521289f, 0.56094253f, -0.23874807f, 0.07239150f, 0.15095669f, 0.05170656f, 0.06147386f, -0.17409857f, 
    -0.06147530f, -0.12292586f, 0.21345292f, 0.04456316f, -0.12262761f, 0.20443779f, -0.04733138f, -0.13906081f, 
    0.05687911f, 0.12807640f, 0.18360570f, 0.09788930f, -0.33344305f, 0.03441182f, 0.12983373f, 0.01108031f, 
    0.04040044f, 0.01530494f, -0.05633752f, 0.20540297f, 0.29925436f, -0.12344746f, -0.00444657f, 0.15647940f, 
    0.09046728f, 0.13976908f, 0.04207954f, 0.03866727f, 0.11181901f, 0.01204683f, -0.10014307f, -0.12929359f, 
    0.06094571f, 0.11333021f, -0.07205572f, -0.02872629f, 0.07277235f, 0.08656370f, 0.11842678f, -0.00328997f, 
    -0.40643799f, -0.18124241f, 0.02934409f, -0.01208573f, -0.01328389f, 0.05100692f, -0.44668573f, 0.19837891f, 
    0.34740445f, 0.03291191f, 0.05190200f, -0.19339214f, 0.11807616f, 0.06149846f, -0.09351611f, 0.02086115f, 
    -0.06993955f, 0.04556495f, 0.02372458f, -0.01072349f, -0.05099736f, 0.16757289f, -0.19612209f, -0.05040491f, 
    0.36431578f, -0.22152293f, 0.01729332f, -0.10525768f, 0.04760780f, -0.04640816f, -0.11647030f, 0.00870741f, 
    0.14493668f, -0.26631024f, 0.55358708f, -0.17324686f, 0.15680097f, 0.04959266f, -0.00900768f, 0.19650370f, 
    0.13175184f, -0.15753865f, -0.03971414f, 0.05664275f, 0.00528971f, 0.20699970f, -0.00770505f, 0.11213859f, 
    -0.04020631f, -0.03701448f, -0.16603741f, 0.14214602f, -0.06835623f, 0.19719285f, 0.03329338f, 0.16424605f, 
    -0.13571668f, -0.09192054f, 0.17408057f, -0.01169595f, 0.13493580f, -0.00023420f, 0.13433279f, -0.02369503f, 
    -0.03087751f, -0.18193653f, -0.05014892f, 0.19786648f, 0.08267083f, 0.12787335f, -0.02664947f, -0.25277919f, 
    -0.24384683f, 0.11606356f, -0.01744138f, -0.01401519f, 0.16321801f, 0.02585455f, 0.16692850f, -0.35203344f, 
    -0.72355473f, -0.04199608f, -0.06896498f, 0.12341518f, -0.10222856f, 0.08748078f, 0.13640279f, 0.27691567f, 
    -0.05446737f, -0.02626183f, -0.04072694f, 0.25981766f, -0.09690674f, 0.01705301f, -0.15426154f, 0.19405212f, 
    0.07770071f, -0.34747380f, -0.19468199f, 0.00221070f, 0.01093872f, -0.03228198f, -0.01465625f, 0.03031126f, 
    0.16064368f, 0.16372150f, 0.03352209f, -0.01603616f, -0.14482151f, -0.00116495f, -0.13839939f, -0.12914966f, 
    0.17691913f, -0.10436167f, -0.36972874f, 0.17160401f, -0.04769362f, 0.02709543f, 0.03077603f, 0.22823171f, 
    -0.05713253f, 0.07428067f, 0.29838899f, 0.04100370f, 0.12585396f, 0.02858993f, 0.05872565f, 0.04608123f, 
    0.05161495f, -0.08593032f, 0.14094999f, -0.04231781f, -0.11823720f, -0.09750247f, 0.09218258f, 0.13519190f, 
    0.02939318f, -0.09748232f, -0.07593214f, -0.08825952f, 0.12287142f, 0.26304397f, 0.35583284f, -0.12805583f, 
    0.01875408f, 0.06083046f, -0.09498542f, -0.07104710f, -0.24054377f, 0.12898825f, 0.07772820f, 0.04227826f, 
    0.08432933f, 0.03882849f, 0.06324742f, -0.07390143f, 0.12454864f, 0.17889598f, -0.03030620f, 0.14203344f, 
    -0.31833789f, -0.15512568f, -0.18938203f, -0.00194310f, -0.01690543f, -0.02230484f, 0.23348315f, 0.08829065f, 
    -0.42439157f, -0.01890062f, -0.22551730f, 0.01297634f, -0.03870615f, 0.20141225f, -0.02979389f, -0.14144963f, 
    0.10454740f, -0.27797884f, 0.07589512f, 0.02178883f, -0.39751351f, 0.17686196f, -0.00064815f, 0.03071622f, 
    0.20511621f, -0.10994768f, 0.15022612f, 0.17237896f, -0.13589630f, -0.27385840f, -0.19465567f, 0.08089862f, 
    -0.10979469f, -0.07975613f, -0.03615347f, -0.17446035f, -0.15902604f, 0.08818200f, -0.13685435f, -0.07703187f, 
    -0.16046332f, 0.06645769f, -0.03532616f, 0.17861131f, -0.31642026f, -0.32640880f, 0.28817955f, 0.11613368f, 
    -0.09369348f, 0.18894993f, -0.05355233f, -0.25818920f, 0.01416793f, 0.12504417f, 0.15337127f, -0.14181980f, 
    -0.09305764f, 0.03745533f, 0.01182172f, 0.07997963f, 0.05635757f, 0.06612027f, 0.03316822f, -0.13875562f, 
    0.06236908f, -0.13458681f, 0.15831988f, -0.09923470f, 0.02213179f, 0.11455276f, -0.16759036f, 0.00454268f, 
    0.01467531f, -0.09845734f, 0.03790347f, 0.07849410f, -0.06332530f, -0.11579403f, -0.08395340f, 0.04741370f, 
    -0.01954002f, -0.12400253f, 0.06870304f, -0.05303205f, -0.27222517f, -0.13731658f, 0.08775410f, 0.16403078f, 
    0.07255331f, 0.25987613f, -0.14856924f, 0.02201335f, 0.01708571f, -0.02689525f, 0.13802505f, 0.00666454f, 
    0.07706244f, -0.01701727f, 0.12350259f, -0.00347283f, 0.21126311f, 0.00513192f, 0.04282737f, 0.13042282f, 
    0.03229792f, -0.04106364f, -0.14732620f, 0.23341362f, -0.00850996f, -0.08588664f, 0.21273154f, 0.00515121f, 
    -0.05941294f, -0.15202522f, 0.00048608f, -0.13030334f, 0.19041987f, -0.08840839f, -0.00324553f, 0.04775508f, 
    0.15327957f, -0.01446215f, -0.03375348f, -0.14463660f, -0.18389566f, 0.19057852f, 0.00215855f, -0.06689112f, 
    0.10374375f, 0.13799833f, -0.02331649f, 0.04238302f, 0.16192193f, 0.00153568f, -0.25300264f, -0.11192863f, 
    -0.17588852f, -0.06788992f, -0.31690606f, -0.20771040f, 0.05607762f, -0.30852044f, -0.03169049f, 0.17179839f, 
    0.05473731f, -0.03569717f, 0.01369182f, -0.08512408f, -0.01705876f, 0.05504521f, -0.11561719f, -0.00438257f, 
    0.08804934f, -0.33908430f, -0.02228597f, 0.20626000f, -0.13160053f, 0.11411016f, 0.01758068f, 0.06218025f, 
    0.03651000f, 0.00890016f, -0.05632387f, -0.28595346f, 0.25759962f, -0.28176066f, -0.37741461f, 0.00486678f, 
    -0.07372477f, -0.12694219f, -0.19396873f, 0.30823153f, 0.31279334f, 0.17674845f, 0.04039678f, -0.14891098f, 
    -0.20732687f, -0.01437483f, -0.12637161f, -0.20250121f, 0.05915869f, -0.51266563f, 0.14872193f, -0.18861429f, 
    0.08409501f, 0.12149281f, -0.13536625f, -0.03119396f, 0.21595289f, 0.23342581f, 0.16501613f, 0.00459476f, 
    0.01192458f, 0.02896433f, 0.05166939f, 0.02177423f, -0.22009255f, -0.29780665f, -0.12497154f, 0.22144096f, 
    0.13319147f, -0.03105785f, 0.00769284f, 0.09258050f, 0.15591939f, -0.05041869f, -0.04303931f, 0.01966260f, 
    -0.11941436f, 0.13160396f, 0.18972635f, 0.07082162f, -0.02260221f, 0.12483120f, 0.23633611f, -0.28451794f, 
    -0.01541955f, 0.00791773f, 0.11962632f, -0.14335939f, -0.14804430f, -0.16620900f, -0.04882826f, 0.00196493f, 
    0.02850319f, -0.06121156f, 0.20431216f, 0.14497626f, -0.04971850f, 0.17861666f, 0.07474664f, 0.05261771f, 
    0.18861935f, 0.08146229f, -0.09279669f, 0.05024296f, 0.05209981f, 0.10945658f, 0.01322425f, -0.02331963f, 
    0.03260122f, -0.00841230f, -0.01579265f, 0.11918449f, 0.23907591f, -0.05718687f, 0.11956445f, -0.01267873f, 
    0.05547562f, 0.00459076f, 0.40602499f, -0.38293508f, 0.06535584f, -0.04831861f, -0.00257972f, 0.11729998f, 
    -0.00220019f, -0.02811079f, -0.05046777f, 0.31457940f, -0.01785980f, 0.04951496f, -0.01127020f, 0.13048455f, 
    -0.12394287f, -0.05220101f, -0.00977883f, -0.15504588f, 0.12995315f, -0.03097063f, 0.02641278f, -0.08431197f, 
    -0.16142450f, 0.00407924f, -0.00708083f, 0.03181751f, -0.06958299f, 0.08932960f, 0.25732613f, 0.09073333f, 
    0.06894778f, -0.02916096f, 0.04231354f, -0.00477046f, 0.14398591f, 0.02187292f, -0.11236787f, -0.11904717f, 
    -0.08696148f, 0.09252656f, 0.14472170f, -0.11539705f, -0.08065653f, 0.15703411f, -0.13226861f, -0.19009233f, 
    -0.05716521f, 0.05991843f, 0.30047289f, -0.14832622f, 0.09387299f, -0.04361874f, -0.05467628f, 0.07259042f, 
    0.32530919f, 0.19358906f, -0.13841861f, 0.00288753f, -0.11480578f, 0.03419662f, 0.25685731f, 0.00294382f, 
    0.00952124f, 0.07989398f, 0.33022502f, -0.07729366f, -0.06559530f, 0.14912617f, 0.08625937f, -0.00647144f, 
    -0.07870486f, 0.14377008f, -0.29144999f, -0.13522133f, -0.28910992f, -0.16309817f, 0.12852117f, -0.13513596f, 
    0.01490684f, 0.08669812f, 0.08036338f, 0.09895254f, -0.33366695f, 0.13421433f, 0.21126302f, -0.09168407f, 
    -0.16921042f, -0.22291075f, -0.00215564f, -0.21364211f, 0.24279638f, 0.44553158f, -0.15611494f, 0.15197800f, 
    0.09538729f, -0.16563952f, -0.00783192f, 0.02205030f, -0.04898515f, 0.03114789f, -0.11807979f, 0.04700601f, 
    -0.01894730f, 0.06367928f, 0.04184445f, -0.15189731f, -0.13365118f, -0.38440424f, -0.29274529f, 0.15170811f, 
    -0.11157482f, -0.10460841f, -0.05176215f, 0.18753780f, -0.07634523f, 0.13413267f, 0.13098232f, -0.01096443f, 
    0.03459049f, -0.05711890f, -0.00964560f, -0.04694629f, -0.00757310f, -0.03041503f, -0.03984066f, 0.00770093f, 
    0.01448565f, -0.01182643f, -0.04155812f, 0.01081291f, 0.02649240f, 0.02600932f, -0.03579487f, 0.04814133f, 
    0.01910586f, -0.04748695f, 0.03645849f, 0.02501131f, 0.00148017f, 0.01956878f, -0.00329162f, 0.04787559f, 
    0.01393801f, 0.00585484f, -0.06293855f, 0.05097529f, -0.05866326f, -0.03896761f, 0.04284476f, 0.03047073f, 
    -0.04094777f, -0.04674031f, -0.00041454f, -0.03834420f, -0.03927380f, -0.02266927f, 0.02640374f, 0.02855901f, 
    -0.03400382f, -0.04963386f, -0.05247110f, -0.04394919f, 0.02088071f, -0.02261763f, -0.02462132f, 0.01968489f, 
    0.01246430f, -0.03760123f, 0.04144682f, -0.05106337f, -0.02767280f, -0.03792692f, 0.01438989f, -0.05163160f, 
    -0.03048708f, -0.04763319f, -0.03841412f, -0.03140227f, 0.00431568f, -0.05265877f, -0.05610726f, 0.02877281f, 
    -0.00725061f, -0.02657105f, -0.04634859f, 0.01381301f, 0.04365298f, -0.04847178f, -0.04593114f, 0.04214773f, 
    -0.01853665f, 0.04046304f, 0.03310270f, 0.04130600f, 0.04633379f, -0.05157360f, -0.05028445f, 0.02453655f, 
    -0.04230599f, 0.04751177f, -0.01016068f, -0.00743841f, -0.06174651f, -0.02415789f, -0.00214688f, 0.02509543f, 
    0.03727644f, -0.02209407f, -0.05902585f, -0.03145899f, -0.02308224f, -0.06146845f, 0.01549302f, -0.02086385f, 
    -0.01719390f, 0.01472969f, -0.05117038f, 0.00895941f, -0.02675784f, 0.04175310f, -0.05833920f, -0.00473994f, 
    0.01938622f, -0.03973983f, -0.02681898f, -0.05300983f, 0.01649961f, 0.05117220f, -0.04637801f, -0.01476831f, 
    0.00616829f, -0.02623869f, -0.03750136f, 0.00877414f, -0.05961285f, 0.03989192f, -0.00751598f, -0.04022991f, 
    -0.04484557f, 0.01272092f, 0.04061601f, 0.00432785f, -0.05184712f, -0.04683083f, 0.00588240f, 0.02009905f, 
    -0.05428818f, 0.00886504f, 0.01773588f, -0.05833888f, 0.02079458f, 0.04629934f, 0.03741416f, 0.00661554f, 
    -0.05105693f, 0.05073425f, 0.00295655f, 0.00796033f, -0.02204693f, 0.00529467f, 0.04379065f, -0.00395078f, 
    -0.03012887f, -0.02458928f, -0.04439734f, -0.05773710f, 0.01690490f, -0.04021278f, 0.01696588f, -0.06433623f, 
    -0.03313570f, -0.04093055f, 0.03213583f, 0.00465356f, -0.04414423f, -0.02136354f, -0.05698718f, 0.00568241f, 
    -0.03718109f, -0.05415061f, -0.00403280f, -0.02101764f, 0.01505503f, -0.02614156f, -0.01387257f, -0.06464522f, 
    0.05034297f, 0.04473725f, 0.01658845f, -0.05989616f, -0.04274805f, -0.01523825f, 0.02723724f, -0.04960358f, 
    0.02019673f, 0.01840318f, -0.02286883f, 0.03257849f, 0.03660608f, -0.03149501f, 0.05845769f, -0.03016532f, 
    -0.02222644f, -0.05478137f, -0.04041887f, 0.00885426f, -0.05725854f, 0.05158854f, -0.01290703f, 0.00610045f, 
    0.05207920f, -0.02270201f, -0.05877033f, -0.02272100f, -0.00848671f, -0.02271297f, 0.00957752f, 0.00946666f, 
    -0.05788197f, -0.01949687f, -0.03852356f, -0.01633568f, -0.05078286f, 0.02406654f, 0.04316076f, 0.00798956f, 
    0.03321386f, -0.02417814f, -0.04562733f, 0.00663603f, -0.00868736f, -0.03032200f, 0.04116200f, 0.00343950f, 
    0.00383546f, 0.02101963f, 0.05225661f, 0.00033572f, 0.02946386f, 0.05232927f, -0.05095325f, -0.02300154f, 
    0.03733948f, -0.06322926f, 0.03389816f, -0.01048717f, 0.02846973f, -0.05770703f, 0.04822478f, -0.01543148f, 
    0.03889198f, 0.03058752f, -0.02655594f, -0.01863050f, 0.04419055f, -0.03775540f, -0.00236460f, -0.03134548f, 
    0.00071836f, 0.03595609f, 0.01194475f, -0.05528794f, 0.04387012f, -0.06026215f, 0.00044497f, 0.00399882f, 
    -0.05451357f, -0.04924622f, 0.03544347f, 0.00935796f, 0.00419924f, -0.02600160f, 0.02943218f, -0.01030207f, 
    -0.04921679f, -0.00902775f, 0.03624646f, -0.04811131f, -0.05545607f, 0.03657957f, -0.02794278f, 0.01683423f, 
    -0.02372179f, -0.03843759f, 0.02656180f, -0.05373857f, 0.01639164f, 0.00503142f, -0.00992793f, -0.05887251f, 
    0.01492987f, -0.04700940f, -0.03941194f, 0.00434046f, 0.00046155f, -0.03152069f, 0.01559304f, 0.03604445f, 
    -0.02540208f, -0.06041916f, -0.02147850f, -0.04754400f, 0.02122018f, -0.02323014f, 0.03506650f, -0.01829985f, 
    -0.05702916f, 0.03729133f, 0.22236627f, -0.10975493f, -0.12154040f, -0.18743555f, 0.24606149f, 0.06776321f, 
    0.10590190f, 0.05080876f, -0.22828147f, 0.10495696f, -0.18548800f, -0.07783348f, 0.01267565f, 0.04254765f, 
    0.05581504f, -0.01929425f, 0.08933486f, -0.20825642f, 0.06459197f, -0.16530095f, 0.07311854f, -0.01618680f, 
    0.09864634f, -0.26291108f, -0.05801954f, -0.01706869f, 0.07261396f, 0.24057765f, -0.23240209f, -0.02606636f, 
    -0.21523976f, 0.01405902f, -0.04597435f, -0.08356905f, 0.09210341f, 0.08928928f, -0.19728640f, -0.04351832f, 
    0.11840481f, 0.04446369f, 0.14517166f, 0.07341685f, -0.04409096f, -0.05400342f, 0.03700670f, 0.11792760f, 
    -0.06739908f, -0.01287076f, -0.05845095f, 0.15474235f, 0.14541845f, 0.12710315f, 0.03290152f, 0.08815664f, 
    0.01316307f, 0.07884017f, 0.18618958f, -0.05870118f, 0.09820252f, 0.00358419f, 0.09195965f, -0.31746283f, 
    0.03440977f, -0.08785528f, -0.09097162f, 0.05226714f, 0.04144385f, -0.06261437f, 0.08059343f, -0.00575060f, 
    -0.09083618f, -0.39423722f, -0.18840465f, 0.06905051f, 0.08374290f, -0.02133477f, 0.08844395f, 0.01751518f, 
    0.04243111f, -0.12591897f, 0.21476962f, 0.71814930f, 0.07868028f, -0.32623446f, -0.09621187f, -0.03223322f, 
    0.12222219f, 0.09737126f, -0.25292650f, 0.22814269f, 0.24464703f, 0.09460391f, -0.09054588f, -0.21047311f, 
    0.13314742f, 0.04324389f, 0.08692169f, -0.15409899f, 0.07935736f, -0.26096356f, -0.08873914f, -0.07419739f, 
    -0.04635195f, 0.17057998f, -0.01212212f, 0.13417377f, -0.25454026f, 0.07611523f, -0.01585426f, -0.00521465f, 
    -0.01729900f, -0.02949551f, 0.00454787f, 0.03724658f, 0.14373969f, -0.19520940f, -0.07901824f, 0.07919101f, 
    0.08244760f, 0.27826759f, -0.12206056f, -0.00233077f, -0.01246637f, -0.03298844f, 0.03402707f, -0.12475462f, 
    0.08757453f, -0.16517676f, -0.13785727f, 0.05613045f, -0.00521858f, -0.04797884f, -0.01004645f, -0.01162602f, 
    -0.28313884f, 0.32655302f, -0.17209259f, -0.16822815f, 0.01953591f, 0.08989394f, -0.09307167f, 0.03821975f, 
    0.15883048f, -0.36743441f, 0.14980264f, -0.09928048f, -0.01908125f, 0.02376859f, 0.00058638f, -0.05850850f, 
    -0.02103627f, -0.10481319f, 0.15275350f, -0.19224304f, -0.02385948f, 0.05648724f, -0.00858225f, 0.00047328f, 
    -0.03027086f, 0.05229948f, 0.20456384f, -0.22192392f, 0.11006668f, -0.17459258f, -0.21128337f, -0.24789818f, 
    0.04150599f, 0.05118600f, 0.22663644f, 0.11389805f, 0.22978047f, -0.67795008f, -0.03999594f, -0.10337402f, 
    -0.19259475f, -0.15498479f, -0.00876716f, 0.21041870f, -0.19396889f, 0.14882477f, 0.26000300f, -0.19410388f, 
    -0.11216524f, 0.33003420f, 0.01882841f, 0.03149251f, -0.04621447f, -0.13114369f, -0.07638391f, 0.21755055f, 
    0.08821183f, -0.02629369f, -0.08151609f, 0.16822928f, 0.03074031f, 0.11871011f, -0.27794942f, -0.26344800f, 
    -0.31572214f, 0.01508489f, -0.08101064f, -0.03679506f, -0.04301235f, -0.10480522f, 0.03065902f, -0.24523276f, 
    -0.03901901f, 0.05115680f, 0.09368706f, 0.17571160f, -0.00382190f, 0.03998313f, -0.01873333f, 0.01908946f, 
    0.00210188f, -0.04539383f, 0.31312722f, 0.03109280f, -0.04847537f, 0.02132296f, 0.00060863f, 0.10294576f, 
    0.06040680f, -0.11857111f, -0.09390497f, -0.15469193f, -0.03450524f, -0.01735134f, 0.11144481f, -0.01414322f, 
    0.05839967f, 0.28595534f, 0.08779569f, 0.13317840f, 0.02592390f, -0.00969836f, 0.05090222f, 0.03183034f, 
    0.17548648f, -0.11531943f, -0.09036887f, 0.16225293f, 0.56338179f, 0.45919573f, -0.09432466f, 0.03531741f, 
    -0.06068620f, -0.00559501f, 0.10178959f, 0.14720541f, -0.43711340f, -0.05210262f, 0.17421618f, -0.01257143f, 
    -0.04250268f, 0.03761864f, 0.08717477f, 0.02459057f, 0.16961308f, -0.13161531f, 0.19917257f, 0.42802778f, 
    -0.03680950f, 0.06965590f, -0.13481671f, -0.00773036f, 0.08404876f, -0.02303177f, -0.00077418f, -0.00400484f, 
    -0.20621911f, -0.09051301f, -0.10586374f, -0.04241647f, 0.16593032f, 0.06613994f, 0.06833840f, -0.17470312f, 
    0.45475218f, 0.33206257f, -0.00016863f, 0.14204171f, -0.00632878f, 0.09437553f, 0.00470419f, -0.11614320f, 
    0.05874427f, 0.16108474f, 0.06592418f, 0.00748234f, 0.06371056f, -0.26507759f, 0.10050032f, 0.24164192f, 
    -0.04542221f, -0.07659266f, -0.13907972f, 0.02138115f, -0.08757005f, -0.04624955f, -0.00548556f, 0.06978192f, 
    0.02114059f, -0.16076428f, 0.04457299f, 0.17015767f, 0.11342441f, 0.18818296f, 0.01445362f, 0.12245521f, 
    -0.02988165f, 0.23986545f, 0.01368153f, -0.20704977f, -0.20147772f, -0.27847070f, -0.05697445f, -0.04957890f, 
    0.12294766f, -0.02920989f, 0.12735862f, 0.26513404f, 0.03205453f, -0.03430125f, -0.14953142f, -0.05044130f, 
    0.03308665f, -0.07608731f, -0.13924798f, 0.03011247f, -0.01877035f, -0.19249728f, 0.03093227f, -0.09029300f, 
    0.23453788f, 0.12591945f, -0.01318644f, 0.04953015f, -0.08728375f, -0.11450546f, -0.06405445f, -0.14946555f, 
    -0.10014887f, 0.27447903f, -0.04496608f, 0.03140026f, 0.24955800f, 0.18351971f, 0.26679769f, 0.15398930f, 
    0.16171719f, -0.00297261f, -0.01423402f, 0.07370061f, -0.04034356f, 0.02691538f, -0.11121604f, 0.05896113f, 
    0.12249415f, 0.01128588f, -0.13867985f, 0.00318178f, -0.03665920f, 0.10422424f, -0.46982807f, 0.01783776f, 
    -0.17452009f, -0.06415159f, 0.01137810f, -0.03884710f, -0.04298540f, -0.03033431f, 0.03400826f, 0.08279404f, 
    0.31199178f, 0.09074865f, 0.07230265f, 0.15127560f, 0.12960654f, -0.11793731f, -0.04167002f, -0.09406950f, 
    -0.01521193f, -0.03344226f, 0.12868346f, 0.27098832f, 0.26430881f, 0.07131779f, -0.06701244f, -0.03898627f, 
    0.17271397f, 0.12348635f, -0.15703399f, 0.14804456f, -0.11603513f, 0.01229813f, -0.14691022f, -0.22727603f, 
    -0.15136820f, 0.07652102f, 0.12045793f, 0.10676436f, -0.24175580f, -0.04026324f, 0.15124826f, 0.17026609f, 
    0.16176127f, -0.00998245f, 0.09371881f, -0.07367933f, 0.05154703f, 0.01225393f, -0.22362256f, 0.00533533f, 
    0.14361356f, -0.01218204f, -0.03734261f, -0.15420601f, -0.25550494f, -0.34845793f, -0.25241587f, 0.22090770f, 
    -0.53212458f, -0.04950598f, 0.00267083f, -0.03774025f, -0.00214199f, 0.09004454f, -0.01687146f, 0.12079757f, 
    -0.00464398f, -0.03398877f, 0.22252403f, -0.00442851f, -0.01716028f, -0.07046197f, -0.19919826f, -0.10399577f, 
    0.15893152f, -0.00557988f, 0.07898729f, -0.00173050f, 0.03052341f, 0.09184577f, -0.12436271f, -0.11679196f, 
    0.05796643f, -0.09071901f, -0.25707179f, -0.10711153f, 0.06743491f, 0.19980355f, -0.05430480f, 0.12231058f, 
    -0.04586665f, -0.29814735f, -0.34319735f, -0.08462875f, -0.05645517f, 0.02104436f, 0.06932432f, 0.04535066f, 
    -0.00260115f, -0.05921204f, -0.06596036f, -0.15203066f, 0.18468353f, 0.01429986f, 0.08115361f, 0.04415857f, 
    0.09594075f, 0.12766393f, 0.09785708f, -0.02256991f, 0.22368495f, 0.26946390f, -0.29492825f, 0.06773330f, 
    -0.09750386f, 0.06639067f, -0.08059733f, 0.05288158f, 0.05021208f, 0.06940988f, -0.05099647f, -0.15052126f, 
    -0.15092437f, -0.18463518f, -0.16044919f, 0.08588051f, -0.14679162f, -0.06209148f, -0.21735838f, -0.10054395f, 
    0.22467467f, 0.04089009f, 0.26328099f, -0.06116143f, -0.07153335f, 0.14156349f, 0.20076010f, -0.08842011f, 
    0.09300794f, 0.17198230f, 0.27513838f, 0.14096144f, -0.06122540f, 0.13867763f, -0.11981682f, 0.02233088f, 
    -0.11386131f, 0.15432878f, 0.24875623f, 0.04720622f, 0.27639461f, 0.10031982f, 0.12188164f, 0.07804981f, 
    -0.04230888f, 0.05032297f, -0.17319195f, -0.03417079f, 0.04399392f, -0.00436881f, 0.13506620f, -0.12484411f, 
    -0.25623834f, -0.05633873f, 0.06222751f, 0.22312842f, -0.25512856f, -0.06053934f, 0.06383504f, 0.20127819f, 
    0.12466164f, 0.02910911f, 0.16665459f, -0.04547339f, -0.09655754f, 0.19719730f, 0.29206678f, 0.13225967f, 
    -0.04150769f, -0.05321109f, -0.08039355f, 0.01627982f, -0.09246135f, -0.28806427f, 0.03160570f, -0.05189604f, 
    0.21763456f, 0.03248286f, 0.13387826f, 0.03911271f, 0.22773555f, 0.00080481f, -0.02003756f, 0.00588006f, 
    -0.01989898f, 0.08635819f, 0.02819521f, -0.21102993f, 0.07049889f, 0.25753137f, 0.24162260f, 0.02797744f, 
    0.10604608f, -0.06508680f, -0.16352282f, 0.13563728f, 0.08485369f, -0.22541066f, 0.11004829f, -0.03119138f, 
    0.03009747f, 0.05295464f, -0.02040497f, 0.06789321f, 0.16810156f, 0.19317991f, 0.02817435f, 0.03588526f, 
    -0.03387808f, -0.45737433f, 0.30489355f, 0.34632775f, 0.08833896f, 0.12077415f, 0.28810284f, 0.11805991f, 
    0.12193497f, 0.27742895f, 0.14460427f, 0.08150125f, -0.07577768f, 0.04705555f, 0.07171120f, 0.09837317f, 
    -0.07957840f, -0.04752933f, -0.13692069f, -0.13031824f, 0.20556094f, 0.04732642f, 0.06382572f, -0.05594578f, 
    -0.29051477f, 0.05513545f, 0.04184866f, -0.21962640f, 0.06368357f, -0.04443849f, -0.10092010f, 0.09152815f, 
    0.10329847f, -0.03125083f, -0.08992718f, -0.10121578f, -0.02676346f, -0.02483487f, 0.10735057f, 0.02223645f, 
    0.06147099f, 0.00298722f, 0.00885138f, -0.13330670f, 0.02065579f, -0.09354216f, 0.16255967f, -0.16059546f, 
    -0.05002546f, 0.21102089f, -0.04968321f, 0.02153903f, -0.14948754f, -0.11902668f, 0.03125953f, 0.27868217f, 
    0.33913937f, -0.17949009f, -0.20242260f, -0.01251439f, -0.15092549f, 0.05897830f, 0.02315048f, -0.10095751f, 
    0.13109392f, 0.31898278f, 0.25147110f, -0.04047514f, -0.03084196f, 0.04201484f, 0.23365757f, 0.17683475f, 
    0.09431189f, 0.06945515f, 0.25267616f, 0.19046830f, 0.35657078f, 0.02219599f, -0.10425799f, 0.01807199f, 
    0.08922213f, -0.10049995f, 0.26788342f, -0.10923987f, 0.06473798f, 0.04451456f, 0.04095949f, -0.01243270f, 
    -0.01167029f, -0.01380660f, -0.21287844f, -0.14314727f, 0.12263159f, 0.23166282f, -0.07263766f, 0.14480780f, 
    0.17237516f, -0.12648986f, -0.26337585f, -0.26169422f, -0.05232435f, 0.08403847f, -0.02718261f, 0.11244427f, 
    0.10852669f, -0.05491783f, 0.05419877f, -0.04950540f, -0.04605275f, 0.08084584f, 0.00873075f, -0.09091357f, 
    0.02986576f, 0.00382212f, 0.12556794f, -0.03139305f, 0.02383726f, -0.06932713f, 0.13664420f, -0.03997722f, 
    0.03563178f, -0.04524582f, -0.06717911f, 0.09889971f, 0.05751273f, 0.11395724f, 0.32796526f, -0.23560068f, 
    -0.28310686f, 0.24418411f, 0.22390623f, 0.13175319f, -0.01068998f, -0.05804648f, -0.00228800f, -0.06918775f, 
    -0.06560741f, 0.09007377f, 0.27833247f, 0.10814654f, 0.02892634f, 0.07081537f, 0.07104596f, 0.17008455f, 
    0.23836379f, -0.06742373f, 0.04233279f, -0.03043334f, -0.01749576f, 0.03531343f, 0.01385993f, -0.05986132f, 
    -0.10665834f, -0.08379225f, 0.09894307f, -0.08183601f, 0.00623667f, -0.00004337f, 0.38499746f, 0.29414958f, 
    0.12604952f, 0.32047483f, 0.29105121f, 0.38460118f, 0.29359078f, -0.28409579f, -0.02584483f, 0.16673312f, 
    0.24486953f, 0.23489754f, -0.05781450f, 0.03338637f, 0.08554503f, 0.02271877f, 0.13806468f, 0.10138203f, 
    -0.00055197f, 0.07320278f, 0.07556994f, 0.06317323f, -0.12155135f, 0.08147385f, -0.03768387f, 0.20165521f, 
    0.25147334f, 0.04733003f, 0.15060128f, -0.08416735f, 0.03705585f, -0.01340119f, 0.07007193f, 0.29514244f, 
    -0.03374025f, -0.01468987f, 0.07783685f, -0.07948479f, 0.25877455f, 0.02764521f, 0.05906102f, 0.06600440f, 
    -0.07045437f, -0.13416006f, 0.12548210f, 0.04820773f, 0.17085320f, -0.07404021f, 0.03422838f, -0.15269139f, 
    0.09987408f, -0.01324426f, 0.10474706f, 0.01781293f, 0.11170054f, 0.22028923f, 0.01537149f, 0.12883252f, 
    0.25732434f, -0.37229449f, 0.24390079f, 0.20511758f, 0.03890641f, 0.09477912f, 0.23087233f, -0.03365302f, 
    -0.02814728f, 0.08116269f, 0.01079699f, 0.14811969f, -0.09506562f, 0.01327616f, -0.12190913f, 0.00140009f, 
    -0.07181181f, 0.09949630f, -0.17317213f, 0.17490375f, 0.07550391f, 0.13276495f, 0.10600219f, 0.04898741f, 
    0.07581426f, 0.07075971f, 0.08934239f, 0.18456870f, 0.28874227f, -0.40795657f, -0.08513918f, -0.03651968f, 
    0.06821296f, 0.23074529f, 0.03887874f, 0.11431125f, 0.18125460f, 0.33047944f, 0.22125122f, 0.03201640f, 
    -0.15383720f, -0.18620685f, -0.03361157f, -0.03222508f, 0.14194487f, -0.13527499f, -0.06938517f, -0.11938253f, 
    -0.12351434f, 0.06868110f, -0.04172505f, -0.19312425f, -0.16460857f, -0.36380467f, -0.35338414f, 0.25132781f, 
    0.20015171f, 0.11591119f, 0.04497655f, -0.05261170f, -0.00791417f, 0.20750611f, 0.06123362f, -0.01050753f, 
    0.01077898f, 0.03535283f, 0.01384887f, 0.01193436f, -0.05175868f, -0.03681391f, 0.04919610f, 0.00977473f, 
    -0.05603589f, 0.02417963f, -0.03735100f, -0.02402168f, 0.05660218f, 0.00222282f, 0.03903352f, 0.00332513f, 
    -0.02022086f, -0.05426026f, 0.01775173f, -0.01960190f, 0.03394897f, 0.02771270f, -0.01992674f, -0.01055318f, 
    -0.03780572f, 0.01843810f, -0.00316207f, -0.00469265f, 0.02209938f, -0.03672927f, 0.04233712f, -0.05621064f, 
    0.04007001f, 0.00946609f, 0.02488673f, 0.00873360f, -0.04113283f, -0.06001234f, 0.01414882f, 0.01314263f, 
    -0.05773593f, -0.03019436f, 0.01936877f, -0.03559515f, -0.01592080f, 0.03383735f, -0.01158739f, -0.03909127f, 
    0.01323519f, -0.04162348f, 0.05075114f, 0.03406969f, -0.00855508f, 0.00555304f, 0.02136542f, -0.04939712f, 
    0.02468289f, -0.03167863f, -0.02693335f, 0.04988683f, -0.00782897f, 0.01668482f, 0.03066358f, -0.02707274f, 
    -0.04508039f, -0.04137712f, -0.01194859f, -0.04972002f, -0.00259440f, 0.03421792f, 0.00130928f, -0.02848307f, 
    0.03353089f, -0.02336271f, -0.04820769f, -0.00026996f, 0.04730510f, 0.02689991f, -0.03971925f, -0.01592163f, 
    -0.03799315f, 0.04807150f, -0.01770501f, -0.03904225f, 0.01674203f, -0.02874919f, 0.04177123f, 0.02984401f, 
    -0.04661780f, 0.01684903f, -0.06017243f, -0.03872539f, -0.03875751f, -0.04612592f, 0.03049838f, -0.02551466f, 
    0.01576507f, -0.05347865f, -0.03025034f, -0.04905231f, 0.00826179f, -0.03079223f, -0.02092825f, -0.03176828f, 
    -0.05813448f, -0.06651563f, -0.01402427f, -0.03707804f, -0.01876673f, 0.01617831f, -0.02640792f, -0.06378262f, 
    -0.05563170f, -0.04539992f, -0.05740068f, -0.06110901f, 0.04447891f, 0.01660981f, 0.04086386f, -0.01911126f, 
    0.01638829f, 0.03944939f, -0.05748722f, -0.06147436f, 0.00190294f, 0.04413091f, 0.00620081f, -0.02346878f, 
    -0.05072537f, 0.02779940f, 0.02481250f, -0.04156284f, -0.04653284f, -0.02671629f, 0.00562594f, -0.05819464f, 
    0.04896407f, -0.02685536f, -0.03432815f, 0.04901754f, -0.06413548f, -0.05035723f, -0.04835322f, -0.05739522f, 
    -0.00349435f, 0.01745263f, -0.00677746f, 0.01287608f, 0.04635581f, -0.06021506f, -0.00543915f, -0.06389292f, 
    -0.04139522f, 0.05141675f, 0.05230290f, -0.05633161f, 0.01664711f, 0.00296111f, -0.02061205f, 0.04767577f, 
    -0.05026665f, -0.06768952f, -0.00697311f, -0.02559956f, -0.01329445f, -0.00670687f, 0.00942419f, -0.06363391f, 
    -0.00836741f, -0.04209049f, 0.01876389f, 0.02388394f, 0.01942785f, -0.05615154f, -0.00417165f, -0.06083664f, 
    0.04588574f, -0.04248348f, 0.04421120f, 0.02109371f, 0.01592867f, -0.06516512f, -0.04571810f, 0.01722599f, 
    -0.02489665f, -0.01926471f, -0.02891861f, 0.04622646f, 0.03504050f, -0.06495181f, -0.01618435f, -0.05604830f, 
    0.00853739f, 0.02264589f, 0.02318968f, 0.00082016f, 0.04468569f, 0.02060324f, 0.02287387f, 0.00821806f, 
    -0.02715906f, -0.04664625f, -0.00293889f, -0.03258973f, -0.00223419f, 0.00433617f, -0.04615782f, -0.03937704f, 
    -0.02958992f, -0.01362079f, 0.04785125f, 0.01553576f, 0.02934136f, -0.05244845f, 0.04507465f, 0.04246584f, 
    0.01262074f, 0.02581465f, -0.05546835f, 0.03354363f, -0.06140866f, -0.03229146f, -0.01954649f, 0.00899408f, 
    -0.04872786f, -0.04884723f, 0.03361067f, -0.03303172f, -0.02896990f, -0.00435527f, 0.03889516f, 0.04343295f, 
    0.03977195f, 0.00212879f, 0.00161693f, 0.02942281f, -0.04496135f, -0.04112368f, -0.04086069f, -0.05348920f, 
    -0.03552374f, -0.06236009f, -0.05393620f, 0.00363630f, 0.04617902f, 0.03547540f, -0.03529543f, -0.01586809f, 
    -0.04315975f, -0.00373745f, -0.04485209f, -0.05972234f, 0.03599461f, 0.01026439f, -0.04145897f, 0.03291879f, 
    -0.02195215f, -0.01673929f, 0.02633692f, -0.00579151f, -0.03027216f, -0.05369883f, 0.00019763f, 0.03736617f, 
    -0.02209208f, -0.07094611f, 0.03797404f, 0.02741598f, -0.03441766f, 0.04166819f, 0.04843510f, 0.04758912f, 
    0.02906638f, 0.00229438f, -0.01805939f, -0.02323911f, 0.04100668f, -0.02792572f, -0.04127702f, 0.04013900f, 
    -0.05693641f, -0.03620654f, 0.00580329f, -0.03151114f, -0.01510041f, -0.01255196f, 0.04225509f, -0.00216972f, 
    0.01221717f, -0.03821195f, -0.05529974f, 0.03909166f, -0.03402903f, 0.05081154f, -0.03359088f, 0.04371639f, 
    0.02431502f, -0.05294712f, 0.02096235f, -0.05729878f, 0.00914507f, 0.00522604f, -0.03242746f, 0.01953542f, 
    0.01789390f, 0.04194631f, 0.02083961f, 0.00538272f, 0.01355922f, -0.05068032f, 0.01496575f, -0.01436494f, 
    -0.05500602f, 0.03034085f, 0.03628452f, 0.04960847f, -0.03666564f, 0.02014355f, 0.02512364f, -0.00475024f, 
    -0.00358231f, 0.00499578f, -0.04428531f, -0.06125722f, -0.04123107f, 0.02561063f, -0.03518697f, 0.04308559f, 
    0.01544532f, -0.04190914f, 0.02234135f, 0.03948404f, 0.00591049f, -0.04899675f, -0.04745795f, -0.06322625f, 
    0.01623113f, 0.02702940f, -0.05987194f, -0.06333526f, -0.03787367f, -0.01016842f, 0.03776321f, 0.03030451f, 
    -0.02091582f, -0.03785754f, 0.00185167f, -0.01837272f, -0.00180630f, 0.02349297f, 0.02341957f, -0.01841206f, 
    -0.01284245f, -0.02582067f, 0.04183199f, 0.01927647f, -0.02549874f, 0.02587880f, 0.02829858f, 0.02311421f, 
    0.01279391f, -0.05998991f, -0.04644958f, -0.06094387f, 0.01171883f, -0.03293039f, -0.04956760f, 0.02454204f, 
    0.04356382f, 0.02927757f, 0.01884711f, -0.01680654f, 0.04755710f, -0.02208458f, 0.04835762f, -0.06526256f, 
    -0.05381437f, -0.02066004f, 0.02637498f, -0.05130325f, 0.01548580f, -0.01402046f, -0.04490181f, 0.04818104f, 
    -0.05575283f, -0.04475290f, -0.05922478f, 0.03554942f, 0.04263864f, -0.00290800f, -0.05239332f, -0.04074762f, 
    -0.03321426f, -0.03462178f, -0.04423116f, -0.00916977f, 0.02028169f, 0.04106762f, -0.06250812f, 0.00155165f, 
    -0.05863212f, -0.03983784f, -0.04731097f, 0.02320730f, 0.03362985f, -0.05503952f, 0.01553178f, -0.03494155f, 
    -0.02929779f, -0.06737347f, 0.04634025f, 0.01258398f, 0.04014371f, 0.00870638f, -0.05201757f, 0.00666047f, 
    -0.01849351f, -0.02736857f, -0.03777462f, 0.05229292f, -0.03823180f, -0.04777992f, 0.00128029f, -0.00474199f, 
    -0.06006303f, -0.05030252f, -0.01913427f, -0.01019415f, -0.01290018f, 0.03808901f, -0.06376567f, 0.01560081f, 
    -0.03167056f, 0.00445655f, -0.03857911f, 0.00504414f, 0.00735802f, 0.05132108f, 0.02294216f, 0.02813064f, 
    0.03795330f, 0.02593976f, 0.00228982f, 0.00380299f, 0.03036581f, -0.05913790f, 0.03896431f, -0.00939506f, 
    0.05064658f, -0.00150741f, 0.03977417f, -0.00058871f, 0.00376872f, -0.04945732f, 0.02761497f, 0.04697590f, 
    0.04607880f, -0.01866089f, -0.06605131f, -0.02790764f, -0.05175246f, -0.02082864f, -0.06452996f, 0.04393450f, 
    -0.04322479f, -0.01280149f, 0.02816717f, -0.02375199f, -0.02440173f, -0.00340525f, -0.03853167f, 0.03106985f, 
    0.04267758f, -0.05087633f, -0.05400689f, 0.00801327f, -0.01781654f, 0.01213645f, 0.01222995f, 0.02826571f, 
    -0.00218695f, 0.00151071f, -0.02815704f, -0.03425486f, -0.02142547f, -0.02218678f, -0.01110760f, -0.00835747f, 
    0.02338676f, 0.04007862f, -0.03538143f, -0.05764189f, 0.04070941f, -0.01401192f, -0.01475478f, 0.01245540f, 
    -0.04718389f, -0.02374222f, 0.04395540f, -0.04047957f, -0.03752779f, -0.00610262f, 0.00516047f, 0.04613419f, 
    -0.05253111f, -0.05226558f, -0.04628136f, 0.04234250f, -0.01701822f, -0.00799345f, -0.02886466f, 0.00019659f, 
    -0.02695762f, 0.01855284f, 0.04272822f, 0.04158089f, -0.00505689f, -0.06085511f, -0.05947044f, -0.04598165f, 
    0.00486996f, 0.03671250f, -0.02308282f, 0.01376431f, -0.05779270f, 0.02046071f, -0.03562176f, -0.06394049f, 
    -0.05658654f, -0.05209521f, 0.01024340f, -0.04174319f, -0.05077826f, 0.03225117f, -0.02195590f, -0.06002231f, 
    -0.02845535f, -0.02839525f, -0.02836714f, -0.02326798f, -0.05228394f, -0.04086724f, 0.01864404f, -0.05577099f, 
    0.00442216f, -0.05290430f, -0.03719482f, -0.02653329f, 0.04207922f, 0.04034027f, -0.04607339f, 0.01006107f, 
    -0.02842120f, -0.00207901f, -0.04829928f, -0.05075146f, -0.03403445f, 0.04838121f, -0.00447823f, -0.02190797f, 
    -0.02762918f, -0.01999736f, 0.00604997f, 0.01898534f, 0.00918255f, -0.00888834f, -0.05333719f, 0.01723052f, 
    -0.04153925f, -0.03388167f, -0.04907432f, 0.03629826f, 0.00628298f, 0.03584765f, -0.03741166f, -0.04104872f, 
    0.04404631f, -0.03212835f, -0.06087419f, 0.02009500f, -0.05326691f, -0.00308409f, -0.00911715f, -0.04992818f, 
    0.03748767f, -0.01921834f, -0.04575009f, -0.01302478f, -0.02436703f, 0.02850910f, -0.05228506f, -0.05821594f, 
    0.03675972f, 0.04116508f, -0.00391807f, 0.00336279f, 0.05285374f, 0.03648994f, -0.03898817f, 0.01354590f, 
    0.01737654f, -0.03096116f, 0.03199857f, 0.04118622f, -0.05960983f, -0.02787712f, -0.03922709f, 0.04084906f, 
    -0.05239278f, -0.00882096f, 0.03170194f, 0.01304074f, 0.03345173f, 0.01007071f, -0.03747284f, -0.03820597f, 
    -0.04349786f, -0.01488172f, -0.04576469f, -0.06139828f, -0.01294182f, -0.06026066f, 0.03813282f, -0.05887926f, 
    0.00685692f, 0.04504447f, -0.01764185f, -0.01388921f, -0.04609234f, 0.00115385f, 0.02809297f, -0.00652130f, 
    -0.00976553f, -0.05045766f, 0.03518070f, 0.01059528f, -0.06158711f, 0.03359639f, -0.06080062f, -0.06093935f, 
    -0.02962814f, -0.03326919f, -0.01566515f, 0.04471646f, 0.01837575f, -0.02077813f, 0.01775247f, -0.04131600f, 
    -0.01281686f, 0.01756005f, -0.01264810f, 0.03234863f, 0.03528339f, 0.03933128f, 0.00742614f, -0.01417910f, 
    0.01589113f, -0.04181891f, 0.04172365f, -0.00072163f, 0.04528885f, 0.03455048f, 0.01541505f, 0.00284755f, 
    -0.02234812f, -0.00580710f, 0.00667015f, 0.04767168f, -0.03052070f, -0.01273439f, -0.00813620f, -0.01660938f, 
    -0.01168878f, -0.05836154f, -0.05940482f, 0.05064779f, 0.03129506f, -0.01079209f, 0.02340202f, 0.03139846f, 
    0.03468356f, 0.03808850f, -0.04419116f, -0.01749327f, 0.01807907f, 0.00719788f, -0.04979191f, -0.04414285f, 
    -0.01484097f, -0.03923378f, -0.01411377f, 0.01471613f, -0.00762458f, -0.05533720f, 0.03332173f, -0.01638052f, 
    -0.00898659f, -0.01708665f, 0.00625300f, -0.01559432f, 0.04102027f, 0.00068383f, -0.06148859f, -0.03270278f, 
    -0.03320535f, 0.01783567f, -0.02313512f, -0.05991705f, -0.03188837f, -0.01960977f, -0.00600867f, -0.06152962f, 
    -0.01784709f, -0.06015142f, 0.02275870f, 0.02979429f, -0.02937786f, -0.00137824f, -0.00291349f, -0.05156476f, 
    -0.00683496f, -0.04830350f, -0.00932013f, 0.01304377f, 0.05003399f, -0.00037842f, -0.02546846f, -0.00196908f, 
    -0.01231017f, -0.01750069f, 0.03130295f, 0.03322458f, -0.01520229f, 0.03730786f, -0.04665986f, -0.00616792f, 
    -0.00406852f, -0.04096027f, -0.06181215f, 0.04337709f, -0.02531420f, -0.02540603f, 0.02487491f, -0.03405394f, 
    -0.06466594f, 0.00670703f, 0.03832930f, -0.04575881f, -0.03846182f, -0.00500235f, 0.02200596f, 0.00343536f, 
    -0.02120564f, -0.05923332f, -0.00521707f, 0.03734792f, -0.04254025f, -0.04155846f, -0.00018023f, -0.04119040f, 
    -0.01546538f, 0.03630373f, 0.04286230f, 0.01149244f, -0.04359438f, 0.01728939f, 0.01531286f, -0.01885272f, 
    0.04223109f, 0.02657239f, -0.01941113f, 0.02121876f, -0.04234423f, 0.00226102f, -0.01960923f, -0.04021963f, 
    0.01595237f, 0.04712730f, 0.01320155f, -0.00750668f, -0.03683966f, -0.02665287f, -0.05041253f, -0.01182705f, 
    0.00216523f, -0.03691313f, -0.03170153f, -0.01282370f, 0.05092655f, -0.00526309f, 0.04909781f, -0.01453772f, 
    -0.06078585f, 0.00814277f, -0.03148730f, 0.03804734f, 0.02302827f, -0.01589944f, -0.00755090f, 0.03134404f, 
    -0.00086294f, 0.05196022f, 0.02969804f, -0.04432470f, -0.02518658f, 0.00797504f, -0.01955536f, -0.01262728f, 
    -0.01126143f, 0.05349152f, -0.00518800f, -0.02236200f, 0.04401517f, 0.04422544f, 0.00288658f, 0.01776229f, 
    0.01936460f, 0.00366393f, 0.00301872f, 0.01306388f, -0.02799817f, -0.01099687f, 0.01541047f, -0.05110182f, 
    -0.01108237f, -0.05125370f, -0.04347472f, -0.02563757f, 0.01737738f, 0.02966660f, 0.01391458f, 0.03803367f, 
    -0.00118216f, 0.01021706f, 0.05129437f, -0.06306460f, 0.02901366f, -0.05095541f, -0.05291858f, -0.00677089f, 
    0.00007918f, 0.01384465f, 0.00259498f, 0.03699314f, 0.03042086f, 0.03246921f, -0.03101023f, -0.06059299f, 
    -0.04400450f, -0.00609675f, -0.01777089f, -0.01933122f, -0.03480626f, -0.04629296f, 0.04751606f, -0.01238354f, 
    -0.01157743f, 0.04113445f, -0.01279356f, 0.01557726f, -0.03098460f, 0.04439725f, 0.02633889f, 0.02162223f, 
    -0.05535191f, -0.68664467f, -0.00712662f, -0.13067539f, -0.01561154f, 0.04386506f, 0.00588824f, 0.26517993f, 
    0.22463657f, 0.10320808f, -0.01330185f, 0.23934734f, -0.05809502f, -0.23717068f, -0.02803722f, 0.14812107f, 
    -0.11121839f, 0.03436966f, -0.07125266f, -0.10578881f, -0.30115670f, -0.21060461f, -0.19194981f, 0.01124429f, 
    -0.00804505f, -0.13517427f, 0.18168171f, -0.41320166f, -0.08088774f, 0.00823094f, 0.02486367f, -0.09412361f, 
    -0.08366933f, 0.03492144f, 0.13165288f, 0.11236221f, -0.56559223f, -0.41075563f, -0.01737206f, 0.04279859f, 
    0.17734307f, 0.14728147f, 0.12862398f, -0.09464556f, 0.26476139f, 0.02537555f, -0.49467754f, -0.14200243f, 
    0.04099270f, -0.17213754f, -0.08170118f, -0.15788342f, -0.04023432f, -0.05555250f, 0.30916041f, 0.16853152f, 
    -0.13248228f, -0.17942788f, -0.09672489f, -0.04660179f, -0.00029902f, 0.01229082f, 0.00677343f, -0.58795041f, 
    -0.23367487f, 0.39826575f, -0.08644330f, -0.00317160f, -0.14319135f, 0.03412597f, 0.20394421f, 0.09197292f, 
    -0.15069753f, 0.05279774f, 0.41054276f, -0.17648982f, -0.03691266f, 0.00272255f, 0.20218591f, -0.10502154f, 
    0.03315172f, 0.01975431f, 0.43872985f, -0.12974337f, -0.09223658f, -0.18797757f, 0.20109361f, 0.03548205f, 
    0.23862144f, 0.00836130f, 0.10520940f, 0.08276510f, -0.06745471f, 0.10440266f, -0.00985599f, 0.03231892f, 
    -0.08036632f, 0.10703307f, 0.06209480f, -0.16361141f, 0.04061463f, 0.00668709f, -0.05513997f, 0.26683190f, 
    -0.14595769f, 0.34509221f, 0.09663660f, -0.37221152f, -0.10362929f, -0.26500496f, 0.01429833f, 0.29797375f, 
    0.06789167f, -0.19006976f, 0.14844127f, -0.00572016f, -0.12228014f, 0.18507992f, -0.42579165f, -0.02577492f, 
    0.16692097f, -0.21492001f, -0.12805487f, 0.03472056f, -0.12747279f, -0.06727714f, 0.50875556f, 0.12871972f, 
    0.08870906f, 0.09976264f, 0.13933925f, 0.13301322f, 0.00414300f, 0.16024584f, -0.06157619f, 0.27909997f, 
    0.21784358f, -0.25090405f, 0.07170385f, -0.13737087f, 0.10821464f, 0.00779780f, 0.02485368f, -0.04782313f, 
    0.26276571f, 0.11879774f, 0.02267019f, -0.02993411f, 0.03495491f, 0.05995776f, -0.04952437f, -0.01762328f, 
    0.06392599f, 0.05163156f, 0.10619670f, 0.12489040f, 0.07221598f, -0.25321105f, -0.12415154f, 0.06197010f, 
    0.03647206f, -0.08365822f, 0.38503569f, -0.00159459f, -0.37222216f, -0.02955209f, 0.06526843f, 0.15094310f, 
    -0.10272888f, 0.04248314f, -0.05848681f, 0.23870951f, 0.45544916f, 0.21664059f, -0.20039782f, 0.01151079f, 
    -0.17949073f, 0.02006913f, -0.04100020f, -0.11703870f, -0.13322164f, 0.16771345f, 0.11007210f, -0.08066701f, 
    -0.04196149f, -0.20029952f, -0.10579220f, 0.05077779f, -0.08085323f, 0.37978113f, 0.14604461f, -0.10215598f, 
    0.05874253f, -0.01042935f, 0.24259739f, 0.04701895f, 0.08834326f, 0.05028319f, -0.30156180f, -0.12990652f, 
    0.40287021f, -0.02867327f, -0.08708411f, -0.02350813f, 0.04631547f, 0.05465506f, -0.10642141f, 0.01831720f, 
    -0.31893808f, 0.00290322f, -0.04272421f, -0.35824376f, 0.16547215f, 0.12542225f, -0.05065080f, 0.11810017f, 
    0.16568072f, -0.07649042f, -0.27845332f, -0.03784595f, 0.06838613f, 0.03779619f, -0.02138584f, 0.04308859f, 
    0.01353375f, 0.08956415f, 0.30455437f, -0.34863490f, -0.02495928f, -0.16246946f, -0.17915247f, -0.08653472f, 
    0.08405216f, -0.21795942f, -0.37312129f, -0.30276957f, 0.31820387f, 0.09954320f, 0.14358683f, 0.04992077f, 
    0.02766591f, 0.22987029f, 0.09366690f, 0.03130945f, 0.02148918f, -0.06363305f, 0.08043651f, -0.16154617f, 
    -0.10502155f, -0.05472497f, -0.16487218f, 0.11834356f, 0.37001318f, 0.06684860f, -0.04016040f, 0.01959664f, 
    0.07677449f, 0.18365167f, -0.20186538f, 0.10814496f, 0.05624294f, -0.53422064f, -0.50035387f, -0.14420490f, 
    -0.43233892f, 0.02170637f, -0.03142602f, 0.21523926f, 0.10175373f, 0.05067747f, -0.05204625f, 0.09607241f, 
    0.07616322f, 0.01939254f, -0.07589881f, -0.04479488f, 0.12024020f, 0.05853280f, -0.10563044f, -0.48460162f, 
    -0.35654557f, -0.03275505f, -0.11943539f, -0.02219089f, 0.04791046f, 0.05272858f, -0.09704998f, 0.06567025f, 
    -0.30520701f, -0.63177478f, -0.02954778f, -0.15755495f, -0.17078030f, -0.31862223f, 0.17018998f, -0.12117428f, 
    0.00531733f, -0.20830213f, -0.03909820f, -0.10246889f, -0.16244756f, 0.01740485f, 0.21346928f, -0.02712264f, 
    -0.04196059f, 0.11235473f, -0.21182214f, -0.03832866f, 0.09475966f, -0.08507868f, 0.12035548f, -0.07340494f, 
    0.09988262f, -0.04778767f, 0.10470834f, 0.35074687f, 0.01160117f, -0.12043045f, -0.06552584f, -0.05644676f, 
    0.00161514f, -0.05332341f, 0.10219523f, -0.33531389f, 0.26748773f, -0.07759087f, -0.19093663f, -0.33112761f, 
    -0.10837120f, -0.13913091f, -0.01152934f, 0.10489372f, 0.06383900f, -0.27541819f, 0.11353607f, -0.02992715f, 
    -0.16535147f, -0.03090997f, -0.02847719f, 0.01210632f, 0.08850297f, 0.18245274f, -0.50814193f, -0.22576235f, 
    -0.05329979f, -0.01374863f, 0.05856961f, -0.11555182f, 0.16954075f, 0.03412825f, 0.07505083f, 0.63484621f, 
    -0.03770231f, -0.00431316f, -0.00680108f, -0.02902894f, 0.05417925f, -0.01361149f, 0.09526820f, -0.06184249f, 
    0.06172953f, -0.18665923f, -0.41264495f, -0.23937856f, -0.13351636f, 0.11285398f, 0.10472097f, 0.02696416f, 
    -0.02288743f, -0.53433758f, -0.44456363f, 0.24685369f, 0.16429782f, 0.06272113f, -0.29015899f, 0.05176330f, 
    -0.05277951f, -0.08095247f, -0.17323929f, -0.16028205f, 0.20251037f, 0.00048445f, 0.15562361f, 0.09138846f, 
    0.02982490f, 0.07241211f, 0.02373116f, -0.01256126f, 0.02259571f, -0.15160677f, 0.00809977f, -0.06664543f, 
    0.15291306f, 0.19973710f, 0.24707547f, 0.06496400f, -0.11520986f, 0.28874266f, -0.04585423f, -0.16530088f, 
    -0.06826977f, -0.15519214f, -0.07056198f, 0.01671999f, 0.09398104f, -0.57475549f, -0.17465730f, -0.29543853f, 
    -0.08849659f, 0.10956453f, 0.14353672f, 0.14429685f, 0.09899398f, -0.03931422f, -0.26409894f, 0.02664427f, 
    -0.00914713f, -0.21464524f, 0.23534507f, -0.04475115f, -0.05438234f, 0.06934492f, 0.14232923f, -0.13578083f, 
    -0.20117962f, -0.15314500f, -0.21539904f, -0.11308807f, -0.13926312f, -0.19346718f, -0.14025857f, -0.16494386f, 
    0.07121951f, -0.08186197f, -0.26548660f, -0.03741842f, 0.06266393f, 0.17092533f, 0.08322063f, 0.01103578f, 
    0.25221226f, 0.25844517f, 0.11713111f, -0.05227816f, 0.15700179f, 0.00672522f, -0.04098743f, -0.09052538f, 
    0.13840307f, -0.00004692f, -0.09335724f, -0.08638554f, 0.00893384f, -0.02478787f, 0.10431627f, 0.00278493f, 
    0.10278040f, 0.06613562f, 0.16109218f, -0.28853059f, 0.04265785f, -0.24810115f, -0.09504650f, 0.03931350f, 
    -0.04547752f, 0.00032094f, 0.06456701f, 0.15326668f, 0.24492119f, 0.01353623f, 0.21827868f, 0.02175511f, 
    -0.06860895f, 0.16311480f, 0.12598577f, 0.17997102f, -0.01125624f, 0.11882007f, -0.19910008f, 0.02753432f, 
    -0.17184663f, -0.12575708f, -0.21260355f, -0.13874827f, -0.08295665f, 0.05785900f, -0.02958129f, -0.05943019f, 
    -0.06971630f, -0.09686641f, -0.05779405f, -0.10670692f, -0.10297475f, 0.09979222f, 0.05270426f, -0.33705950f, 
    -0.22238898f, -0.47205332f, -0.04404540f, -0.13367021f, 0.16051237f, 0.07209069f, -0.19302993f, -0.11015284f, 
    -0.02372720f, 0.19498752f, 0.22308201f, 0.08813869f, 0.22920583f, 0.21680489f, 0.04320048f, 0.18333054f, 
    0.10659053f, -0.09977980f, 0.01675149f, -0.15379511f, 0.02780889f, 0.15985474f, 0.19085972f, 0.01431928f, 
    0.00653077f, 0.10342018f, 0.07976574f, 0.14453357f, 0.13727155f, -0.15512100f, -0.07650339f, -0.17466292f, 
    -0.18578589f, 0.05961031f, 0.10917999f, 0.14948551f, -0.06106866f, 0.21304645f, -0.12237566f, 0.08195607f, 
    0.09518564f, 0.12082635f, 0.05125504f, 0.26607859f, -0.53556246f, -0.22237673f, -0.34884816f, -0.19495732f, 
    -0.02103591f, 0.11955328f, -0.07411308f, 0.14182395f, -0.04544991f, 0.19028257f, 0.02867046f, 0.05275422f, 
    -0.03139021f, 0.12476105f, -0.22434820f, 0.18514083f, 0.04521461f, 0.10918440f, 0.05113499f, -0.05452783f, 
    -0.14037640f, 0.02570014f, 0.04589592f, 0.08150689f, 0.15262063f, 0.08004589f, 0.01405126f, 0.02980862f, 
    0.09053084f, 0.17790377f, -0.06650834f, 0.20380014f, 0.08376901f, 0.18173486f, -0.05476183f, 0.11111456f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.05907240f, 0.17755701f, -0.02644186f, -0.00288586f, 0.12719683f, -0.01202847f, -0.08109061f, 0.35576195f, 
    0.14674011f, -0.06596476f, -0.01381172f, 0.17801151f, 0.04170833f, 0.08524995f, 0.16344912f, 0.06611706f, 
    -0.05471347f, 0.13846168f, 0.10463855f, 0.27346939f, -0.06061867f, -0.02447231f, 0.08573872f, 0.00714132f, 
    0.02357321f, 0.13462955f, -0.03312605f, 0.00549728f, 0.00511388f, -0.03262651f, -0.16150664f, 0.27169666f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.35773191f, -0.52343613f, -0.14411294f, -0.07718068f, 0.22715002f, 0.10374462f, 0.49281973f, 0.15132800f, 
    0.51223516f, -0.14826217f, 0.07281733f, 0.60906196f, 0.16554463f, -0.06273967f, -0.50356060f, 0.06255640f, 
    -0.13897476f, 0.30363107f, -0.02876603f, -0.75399804f, 0.00540300f, -0.10778152f, -0.06674913f, 0.00527904f, 
    0.42351553f, 0.29379106f, -0.12272917f, -0.12353138f, -0.05613283f, -0.09329173f, -0.30548689f, 0.55110914f, 
    0.06026047f, -0.06668435f, -0.08981392f, -0.26858494f, 0.18371318f, -0.15153484f, 0.09889449f, -0.16977224f, 
    -0.25995341f, -0.02128429f, -0.05643393f, 0.25623837f, 0.19520298f, 0.20820099f, -0.01352184f, -0.17310756f, 
    0.01074010f, -0.28136554f, 0.17242391f, -0.21223441f, 0.02077406f, 0.45007402f, -0.12976481f, 0.08543931f, 
    -0.21955967f, -0.18005757f, 0.18098649f, 0.13769057f, 0.08972012f, -0.03544540f, 0.77247286f, -0.33313188f, 
    -0.14956288f, -0.29121715f, -0.06606605f, -0.32777014f, -0.09077358f, 0.10638490f, -0.40627012f, 0.30873287f, 
    -0.15128042f, -0.07459107f, -0.02700190f, -0.14579645f, -0.13781649f, -0.18461649f, -0.03838700f, 0.14570558f, 
    0.02901927f, 0.40432701f, 0.37497240f, 0.57820857f, 0.07053210f, -0.20595974f, 0.16860135f, 0.09075942f, 
    0.04679151f, 0.39112443f, 0.25326085f, -0.03656048f, -0.02685428f, 0.07583676f, -0.51724833f, 0.41037926f, 
    -0.14425921f, -0.00946079f, 0.15371722f, -0.45146099f, -0.19085029f, -0.01247935f, -0.12221717f, -0.02945533f, 
    0.01075237f, -0.02983687f, 0.04433387f, 0.07070646f, 0.09824754f, 0.05086319f, 0.22164974f, -0.02427529f, 
    0.09074410f, 0.09719207f, 0.22376628f, -0.31322798f, -0.03986502f, 0.44630307f, -0.37220600f, -0.00132114f, 
    -0.15560216f, 0.26483360f, 0.01675584f, -0.01346998f, 0.02374712f, 0.03377674f, 0.04079093f, 0.16245362f, 
    -0.19458520f, 0.14660893f, 0.02416323f, -0.19969356f, -0.06453417f, -0.13718811f, -0.15679917f, -0.22402976f, 
    0.34910205f, 0.09434326f, 0.05283367f, -0.39413691f, -0.08800367f, 0.06162905f, -0.03011215f, -0.13011326f, 
    -0.15009135f, -0.55087483f, 0.19472691f, -0.02964543f, -0.06183707f, 0.56390411f, 0.03652389f, -0.15954864f, 
    -0.21704502f, -0.05026984f, 0.23565850f, -0.17000827f, -0.00601666f, 0.10010078f, -0.35624379f, 0.09021598f, 
    -0.26630020f, 0.39941549f, -0.11604661f, 0.89666420f, 0.24043153f, -0.11824724f, -0.14381234f, 0.24211870f, 
    0.09420535f, -0.16182260f, -0.16099164f, -0.18980895f, -0.03322909f, 0.15991229f, 0.00826711f, 0.24025351f, 
    -0.05198523f, 0.20272397f, -0.04714884f, 0.12206782f, -0.03138138f, 0.10411360f, 0.33316830f, 0.12786715f, 
    -0.36102560f, 0.13871604f, -0.06755263f, -0.05414507f, -0.13448231f, -0.10742116f, -0.37444642f, 0.27204701f, 
    0.42949179f, 0.03331268f, 0.11270573f, -0.14624918f, 0.15503839f, 0.12190131f, -0.26902434f, -0.10697722f, 
    0.22194400f, 0.23260073f, -0.12323675f, 0.34050658f, -0.07988587f, 0.30817997f, 0.21222992f, 0.12194403f, 
    0.07171794f, 0.34238154f, -0.01066221f, -0.58552772f, -0.05719959f, 0.05947877f, 0.17350851f, 0.00533254f, 
    0.02745149f, -0.40190980f, 0.17676826f, -0.00837976f, 0.16354899f, 0.08905184f, 0.04410597f, -0.47573727f, 
    -0.11904119f, -0.02153564f, -0.10345365f, -0.09188852f, 0.01009914f, 0.07629813f, -0.09718797f, -0.06045603f, 
    -0.03880434f, -0.02081601f, -0.05304061f, -0.05498050f, -0.10678716f, -0.00126506f, -0.07439765f, 0.00140866f, 
    -0.13969789f, -0.04780618f, -0.08783099f, -0.05016685f, -0.02718954f, -0.11908094f, 0.01656622f, 0.04492683f, 
    -0.10105965f, -0.08389194f, 0.07729182f, 0.15315741f, 0.12318959f, -0.08505434f, -0.11864751f, -0.00477538f, 
    -0.02830325f, -0.11227661f, -0.05955755f, 0.24497904f, -0.27825621f, 0.14862506f, 0.05449187f, 0.22970505f, 
    0.35344344f, -0.12532391f, 0.15547734f, -0.66043168f, 0.06640159f, -0.23210709f, -0.08850265f, 0.04085505f, 
    0.14215329f, 0.21315737f, 0.36447918f, 0.57643354f, 0.14381641f, -0.33748940f, 0.23609976f, 0.06319936f, 
    0.03499524f, 0.25500587f, -0.04450201f, -0.03564427f, -0.13841054f, 0.05885945f, -0.15704684f, 0.57577091f, 
    0.12239724f, -0.08277302f, 0.16682287f, 0.03937169f, 0.03611957f, 0.11995430f, -0.05968384f, 0.12561631f, 
    -0.15666446f, -0.00866331f, -0.04418633f, -0.13028388f, -0.05119485f, 0.02769555f, -0.06640077f, 0.00085657f, 
    0.07662917f, -0.11908437f, -0.12946300f, -0.20082052f, -0.14516254f, -0.01822238f, -0.04544357f, 0.12857939f, 
    0.00787076f, 0.05431617f, -0.00373571f, -0.05939677f, 0.02349270f, 0.05069103f, -0.05950172f, -0.15671304f, 
    -0.08415930f, 0.16798952f, 0.02744490f, 0.54624182f, -0.08786239f, 0.03212772f, 0.06914017f, -0.03642720f, 
    0.07691131f, -0.15135905f, -0.13627343f, 0.20757388f, 0.36660001f, 0.36366746f, 0.28587133f, 0.38621321f, 
    -0.00057445f, -0.00235555f, 0.04363523f, -0.72569793f, 0.15460429f, 0.47432786f, -0.47696808f, -0.08096814f, 
    -0.30538321f, 0.33846354f, -0.15801513f, -0.08496076f, -0.15632118f, -0.06792312f, 0.42107418f, 0.11921272f, 
    0.43479607f, 0.23943299f, 0.12918881f, -0.10414268f, -0.35994428f, 0.15362991f, 0.07690672f, -0.10771910f, 
    0.06126630f, 0.09915731f, -0.13899532f, -0.27048475f, -0.41128406f, -0.22377846f, 0.09022015f, -0.28919822f, 
    -0.08895880f, -0.25700241f, -0.12729436f, -0.07156668f, 0.12578702f, 0.16729377f, -0.08262425f, 0.12288843f, 
    -0.07307861f, -0.05692981f, -0.09096982f, 0.04838181f, -0.10769007f, -0.06577065f, -0.25720215f, -0.05750250f, 
    0.69940418f, -0.15110470f, 0.07574643f, 0.39068928f, 0.55511069f, 0.09091298f, -0.14631274f, 0.08443242f, 
    0.09708972f, -0.04073775f, -0.00634431f, 0.70478505f, -0.11471334f, 0.27896708f, 0.08907492f, 0.02350462f, 
    0.11230444f, 0.39121294f, 0.00110968f, -0.53004700f, -0.05508049f, -0.20615691f, 0.06243006f, 0.02506803f, 
    -0.12050775f, -0.25036985f, 0.19869356f, 0.10301287f, -0.04700983f, -0.01262923f, -0.08687422f, -0.39802262f, 
    -0.22121774f, 0.23909321f, 0.15958016f, -0.04829730f, 0.13185674f, -0.04689451f, -0.15713368f, 0.18945293f, 
    0.16702040f, 0.06136810f, -0.00683639f, -0.40396976f, -0.09906978f, 0.45901245f, 0.01710028f, -0.33035672f, 
    0.11464192f, 0.04209806f, 0.30009466f, -0.02776472f, 0.03798139f, 0.03434645f, -0.16915856f, -0.03600612f, 
    -0.36875096f, 0.04634582f, -0.12879366f, -0.06757843f, 0.06658950f, 0.06916042f, 0.38922125f, -0.15847130f, 
    0.55254954f, -0.15110943f, -0.11603458f, -0.07060113f, 0.23252022f, -0.13721609f, -0.56610733f, -0.51289290f, 
    0.26451135f, -0.15706475f, 0.02191029f, -0.11730968f, -0.50638509f, -0.05802254f, -0.29946807f, 0.00846978f, 
    -0.08959308f, -0.19343184f, 0.10606003f, 0.65596896f, -0.13190766f, 0.39359477f, 0.31246105f, 0.09316071f, 
    0.32078007f, -0.12129238f, 0.52727169f, -0.18218672f, -0.12019759f, -0.10083241f, -0.11885273f, 0.04006347f, 
    -0.03077067f, 0.08470035f, -0.08129505f, -0.12927401f, 0.03883614f, 0.09229919f, -0.07529838f, -0.10832550f, 
    -0.07492559f, -0.18007819f, 0.05483235f, -0.10276901f, 0.07438041f, -0.11826637f, -0.17976512f, -0.06935472f, 
    -0.08779681f, 0.02404894f, 0.04613008f, -0.08394023f, 0.05556501f, 0.06109020f, -0.14582577f, 0.02099313f, 
    0.11319924f, 0.00615983f, -0.06282791f, -0.15729800f, -0.12947449f, -0.08273030f, -0.09561209f, -0.09469534f, 
    0.04306028f, -0.04198579f, -0.09128448f, 0.38910857f, 0.18179567f, 0.12788844f, 0.21150951f, 0.05088564f, 
    -0.24606983f, 0.10194964f, -0.10733819f, 0.19150978f, 0.33859634f, -0.01021297f, 0.24780513f, -0.18573029f, 
    -0.04401261f, -0.14954875f, 0.06895220f, 1.25075006f, -0.00900229f, -0.37374392f, -0.33530167f, 0.00767422f, 
    -0.01483743f, 0.02057211f, 0.11692636f, 0.06122035f, 0.02391733f, -0.09791104f, 0.43270430f, -0.34710261f, 
    -0.35533047f, 0.03885881f, 0.07885462f, -0.53734964f, -0.08052946f, 0.12238194f, 0.22134271f, 0.14577925f, 
    0.23126185f, 0.09485283f, 0.06925949f, -0.00062545f, -0.06093479f, -0.12257069f, -0.13808756f, -0.32559025f, 
    0.09905826f, -0.14927287f, -0.02222577f, 0.31657439f, 0.09980685f, -0.01902231f, 0.40238163f, -0.05656126f, 
    -0.03459790f, 0.13822517f, -0.00454292f, 0.15215722f, -0.05462080f, -0.00011291f, 0.23064089f, -0.02470591f, 
    0.29244059f, -0.24454425f, 0.03653854f, 0.09606604f, 0.07832003f, -0.13921535f, -0.25514132f, -0.01029060f, 
    -0.21997298f, 0.12321982f, -0.10922942f, -0.24134964f, 0.29560471f, 0.36881787f, 0.23096292f, 0.09201854f, 
    -0.15663436f, 0.52489334f, -0.04408727f, 0.11599919f, 0.10500335f, -0.59342277f, -0.24218860f, 0.11778054f, 
    0.27111268f, 0.12917031f, -0.04609197f, 0.04658484f, 0.10694976f, 0.06805003f, -0.44011652f, -0.08400575f, 
    -0.02817420f, 0.16762888f, -0.07853805f, 0.83161467f, 0.29389560f, 0.13576378f, 0.26070589f, 0.22342326f, 
    0.31766629f, -0.06043121f, 0.14603591f, -0.21514969f, 0.40677398f, 0.06916010f, 0.05093198f, -0.19611897f, 
    0.17759036f, 0.06842973f, -0.25200233f, -0.28128093f, 0.12543233f, -0.16604170f, -0.15380713f, 0.15672708f, 
    0.08172894f, 0.16578095f, -0.17116646f, -0.00107518f, -0.03121746f, 0.08929952f, 0.13514903f, -0.11856080f, 
    -0.19464195f, -0.26720732f, 0.09439830f, -0.65520960f, 0.25695702f, 0.03977369f, 0.02306723f, 0.06636492f, 
    -0.18889797f, 0.31768465f, 0.15962559f, 0.68800539f, -0.14774735f, -0.08552639f, -0.10543465f, 0.17144567f, 
    -0.03691944f, -0.31876057f, 0.15821922f, 0.69688410f, 0.00940511f, 0.45450050f, -0.01972918f, -0.13960211f, 
    0.24891782f, -0.23980051f, 0.25634354f, 0.15244380f, -0.00521632f, -0.05428945f, 0.00052001f, -0.12637861f, 
    -0.64060283f, -0.55453950f, 0.16487963f, 0.32929906f, 0.46980745f, 0.10124568f, -0.04551186f, 0.31628111f, 
    -0.19822966f, 0.34368566f, -0.14767046f, 0.69375801f, 0.03623924f, 0.12566456f, 0.26584050f, 0.09715421f, 
    -0.00904208f, 0.08081432f, 0.12791611f, 0.72020978f, -0.16571870f, 0.10814527f, -0.11635904f, -0.09761077f, 
    -0.23655258f, 0.10305315f, -0.29754826f, -0.17828591f, 0.12420999f, 0.06566577f, -0.00756416f, -0.20098223f, 
    -0.11212756f, -0.10333329f, 0.03070163f, 0.03768037f, 0.05503953f, -0.03974956f, 0.01033852f, -0.18558297f, 
    0.07644549f, 0.08904468f, 0.15575807f, -0.02705518f, -0.16573650f, 0.04086746f, -0.07324968f, -0.18197654f, 
    -0.16341576f, -0.13012217f, -0.03363414f, -0.03704846f, -0.01809946f, 0.07851198f, -0.07289197f, 0.00433765f, 
    -0.20763701f, 0.11058068f, -0.19267133f, -0.12025338f, -0.06485648f, -0.03492428f, 0.01198518f, 0.06231585f, 
    -0.03900823f, 0.14615050f, -0.02704501f, 0.00387972f, 0.20002437f, -0.09742089f, 0.17511022f, 0.13444397f, 
    0.12498379f, -0.35189447f, -0.12405762f, 0.06833114f, 0.39467087f, 0.21536846f, 0.13568111f, -0.13142309f, 
    -0.15463348f, 0.12494260f, 0.21495071f, -0.63156819f, -0.00330572f, -0.18207176f, -0.49077660f, -0.04176483f, 
    0.22022472f, 0.16508725f, -0.27903897f, -0.14906716f, 0.10130982f, -0.04420002f, 0.70465511f, 0.07113609f, 
    0.06012240f, -0.37524614f, 0.03934702f, -0.63958073f, -0.30057880f, -0.06910115f, 0.13089249f, 0.26070115f, 
    0.20356278f, 0.15483430f, -0.14595269f, -0.01270422f, 0.25781530f, 0.11503376f, -0.42600304f, -0.30842322f, 
    -0.13608915f, -0.10158296f, 0.19861151f, 0.40004283f, 0.06478205f, -0.33494732f, -0.07989481f, -0.10524429f, 
    0.31404290f, 0.17823061f, 0.01934302f, 0.13885699f, 0.07657190f, -0.08331688f, 0.16787499f, 0.52595192f, 
    0.73728138f, 0.09105183f, 0.15938893f, -0.05314424f, 0.05974720f, -0.10258298f, 0.10569532f, -0.26981899f, 
    -0.10551811f, -0.02996390f, -0.11993308f, -0.49652562f, -0.24922410f, -0.33235896f, 0.06007744f, -0.01896288f, 
    -0.12573981f, 0.00869243f, 0.22241870f, 0.43159953f, 0.10784341f, -0.15605159f, 0.00770804f, -0.17177179f, 
    0.24544984f, 0.10717382f, 0.26169956f, 0.04563444f, 0.05430366f, 0.02884294f, 0.31667632f, -0.09649655f, 
    -0.00414598f, -0.03037894f, 0.17310330f, -0.19655757f, 0.06199798f, 0.04774361f, 0.02073778f, -0.09748743f, 
    -0.15353490f, 0.02710796f, -0.05737139f, -0.16250677f, -0.03954285f, -0.02461147f, -0.14073338f, -0.10843967f, 
    -0.15454787f, 0.05175135f, -0.04644183f, 0.03189926f, -0.14083026f, 0.04997185f, -0.13913639f, 0.05295581f, 
    -0.00188550f, 0.06460867f, -0.03163591f, -0.12496684f, 0.05883479f, -0.08871513f, 0.03871059f, -0.14578962f, 
    0.07436826f, -0.13458782f, 0.07268249f, 0.13285641f, -0.12100507f, 0.07815389f, -0.11546651f, -0.00194301f, 
    -0.03881625f, -0.16121446f, 0.06563977f, -0.10280282f, -0.05510646f, -0.10199670f, 0.11463108f, 0.08531673f, 
    -0.15944450f, -0.14671817f, -0.17374794f, -0.10404950f, 0.07470826f, 0.09369904f, 0.00419953f, 0.09337063f, 
    -0.01228294f, -0.04757022f, -0.16177991f, 0.03560920f, -0.00787967f, -0.09302732f, -0.00431192f, -0.02536869f, 
    0.24416353f, 0.06215355f, 0.08393669f, -0.66021049f, -0.05457184f, -0.01761480f, -0.20544736f, -0.00858177f, 
    -0.35219553f, 0.26706210f, -0.08669348f, -0.02858416f, -0.20912004f, 0.19652075f, 0.46503985f, 0.33510876f, 
    0.08067887f, 0.01835554f, 0.16440594f, -0.14570761f, 0.04114287f, 0.25283539f, -0.36538535f, -0.03239805f, 
    -0.03340615f, 0.20791107f, 0.05303770f, -0.03922063f, 0.00401217f, 0.05306358f, 0.31743318f, 0.08407256f, 
    -0.03883186f, 0.10084797f, -0.14409563f, -0.17266448f, 0.15647905f, -0.04638227f, -0.09172191f, -0.07452523f, 
    -0.15732686f, -0.07934957f, -0.05444131f, -0.00668337f, -0.17030798f, -0.06082793f, -0.10422312f, 0.00253593f, 
    0.01087087f, -0.16385584f, -0.02646967f, 0.16358748f, -0.06477406f, -0.11937153f, 0.14469634f, 0.06630234f, 
    0.01577074f, 0.03075472f, -0.16991344f, 0.08967350f, 0.13274424f, -0.16920882f, 0.06220514f, 0.00074813f, 
    -0.37009704f, -0.25553066f, 0.10858393f, -0.30368811f, -0.18658014f, 0.00021422f, -0.10021991f, 0.13127246f, 
    -0.08527698f, 0.16747560f, 0.09855645f, 0.57935655f, 0.19201832f, -0.23535867f, -0.00049812f, 0.30321997f, 
    -0.15488523f, -0.06462795f, 0.21094343f, 0.24078286f, -0.13491359f, -0.12285816f, -0.01561514f, -0.08739784f, 
    0.35094762f, 0.32623515f, -0.10151513f, -0.00122717f, -0.08750845f, 0.07929380f, -0.21190491f, 0.65896225f, 
    0.28790995f, 0.12198216f, -0.06215394f, 0.38862759f, 0.07540504f, -0.11051180f, -0.23589070f, 0.18997614f, 
    0.26059026f, -0.21321720f, -0.09318256f, 0.40975255f, -0.08025135f, -0.12896697f, 0.02193472f, 0.38255751f, 
    0.08609555f, 0.23876220f, -0.10013692f, -0.67905408f, 0.05479866f, 0.37751418f, 0.19159229f, -0.07582532f, 
    -0.08964904f, -0.15128194f, 0.08557349f, -0.10716032f, -0.10178017f, -0.06168419f, -0.47554678f, 0.37912551f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.15903659f, -0.02433753f, 0.34605113f, -0.08187922f, -0.28508309f, 0.14142884f, 0.17457655f, -0.22096071f, 
    0.31950530f, -0.18704681f, -0.26395774f, 0.13600157f, 0.31458026f, 0.35165799f, 0.29514149f, -0.08103281f, 
    0.26560295f, 0.03180603f, 0.32319802f, 0.13236575f, 0.11653832f, 0.16241284f, -0.17047237f, 0.36367497f, 
    0.12671718f, -0.06848805f, -0.06182871f, -0.04330331f, 0.06794230f, 0.13516733f, -0.09534040f, 0.24164887f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.29259926f, 0.53235161f, -0.68081665f, -0.50241143f, -0.03362075f, -0.01392591f, -0.02755135f, -0.16157545f, 
    -0.22944808f, -0.11120542f, 0.24325524f, -0.43332687f, 0.09431514f, 0.06343108f, -0.15598279f, -0.05812802f, 
    0.43045527f, -0.03521619f, -0.10126598f, 0.19020751f, -0.30236310f, 0.16857392f, 0.03356321f, 0.20641674f, 
    -0.43406627f, 0.12429360f, 0.10452226f, 0.07337248f, 0.04571609f, -0.17017102f, -0.42623124f, -0.38588533f, 
    -0.22226362f, -0.78997129f, -0.04070419f, -0.31078261f, 0.02363401f, 0.44036058f, -0.03200174f, -0.08645274f, 
    0.26758260f, 0.12325662f, 0.00888709f, 0.13086997f, 0.12968659f, 0.49620250f, -0.58758193f, -0.04810326f, 
    0.09979261f, 0.05773503f, 0.16249782f, 0.32624546f, -0.62477958f, 0.12917623f, -0.00320842f, 0.26586723f, 
    -0.12585393f, -0.33836019f, 0.10326003f, 0.13555124f, -0.23219372f, 0.14830698f, -0.14519463f, 0.09970547f, 
    -0.31105894f, -0.48344141f, 0.27912530f, -0.10050880f, -0.37975720f, -0.18365903f, -0.15217584f, -0.14798981f, 
    -0.04652633f, 0.11206168f, -0.29666573f, 0.48652506f, -0.46144617f, 0.16126800f, -0.03863386f, 0.06673188f, 
    0.29040918f, 0.07054606f, 0.24040791f, -0.13973303f, 0.29289109f, 0.83344150f, 0.08557814f, -0.97597599f, 
    0.09644700f, -0.17520735f, 0.17135860f, -0.06769580f, 0.19765554f, 0.01167964f, 0.18735759f, -0.65817094f, 
    -0.04464865f, 0.37464896f, -0.18282549f, 0.12991059f, -0.16419166f, -1.00102282f, 0.28722364f, 0.04536396f, 
    -0.49521577f, 0.05412009f, -0.12739165f, -0.08420592f, 0.19759515f, 0.27010882f, -0.03613223f, -0.13465172f, 
    -0.12620589f, -0.75647008f, 0.10885057f, -0.44237113f, 0.46256307f, -0.01493555f, 0.09159800f, 0.21260010f, 
    0.17717753f, 0.00878980f, 0.02732401f, 0.09971150f, 0.34960684f, -0.00297091f, 0.08873201f, -0.44819376f, 
    0.14023240f, -0.40041476f, -0.11855965f, -0.57666183f, 0.07926226f, 0.19573736f, 0.24318866f, -0.04933693f, 
    -0.43594497f, 0.08487175f, -0.05532392f, -0.22346018f, 0.38720703f, -0.66213667f, 0.31783709f, -0.14776504f, 
    -0.16916813f, 0.17538762f, 0.30125341f, 0.00011287f, -0.13771720f, -0.00945723f, -0.14777760f, -0.27975315f, 
    -0.56133908f, -0.01828510f, 0.04893086f, 0.03973565f, -0.08690182f, 0.10139930f, -0.11786278f, 0.30005354f, 
    0.33591145f, -0.15823202f, -0.19940160f, -0.01525616f, 0.07155075f, 0.08295939f, -0.11737743f, -0.05372305f, 
    -0.18648048f, -0.08051474f, 0.11116545f, -0.52866405f, 0.10530726f, -0.47376931f, -0.79435265f, -0.15450390f, 
    0.07472932f, -0.03131473f, -0.14522667f, 0.07693841f, 0.43034637f, 0.40881434f, -0.16010308f, 0.03546097f, 
    -0.07977231f, -0.55697799f, 0.06998434f, -0.04976710f, -0.16189484f, 0.11218303f, 0.33703902f, 0.22568247f, 
    -1.03812528f, -0.41135398f, 0.26034504f, -0.35051933f, 0.27828449f, 0.07374322f, -0.43978769f, 0.06724489f, 
    0.26450253f, 0.15345965f, -0.41962254f, 0.04386290f, -1.20612669f, -0.02457006f, 0.36520001f, 0.03289973f, 
    0.12624355f, 0.16477510f, -1.04042995f, -0.46260294f, 0.41990241f, -0.20260008f, -0.17237745f, -0.71741879f, 
    0.26952755f, 0.14920709f, -0.09333616f, -0.04865881f, -0.21645227f, 0.16552456f, 0.26878035f, -0.53864914f, 
    -0.60604769f, 0.22156473f, -0.26346031f, 0.44670600f, 0.36182079f, 0.18183868f, 0.08364459f, -0.05070626f, 
    -0.24327345f, 0.15302566f, 0.42032629f, -0.13581336f, -0.00034216f, 0.25679752f, 0.43063551f, 0.01487526f, 
    -0.22715722f, -0.22005531f, -0.48993129f, 0.01449190f, -0.04805709f, -0.61768895f, -0.11324990f, -0.17104203f, 
    -0.63498044f, -0.18821001f, 0.08389980f, 0.00900069f, 0.13395907f, 0.15135710f, -0.27172065f, 0.26589176f, 
    -0.11774486f, -0.83407265f, 0.33885986f, 0.27570471f, -0.31739175f, 0.18286721f, -0.40139538f, -0.16559181f, 
    0.27341986f, 0.09462224f, 0.40870574f, -0.16147961f, -0.69503284f, -0.14214693f, -0.61895597f, -0.13183565f, 
    -0.25792044f, -0.25440326f, 0.22122033f, -0.12007009f, -0.55742818f, -0.58178383f, -0.12957254f, 0.18021856f, 
    0.07149827f, 0.01093876f, 0.16676928f, -0.17434932f, 0.32269898f, 0.04622406f, 0.41463420f, 0.04679887f, 
    -0.44479343f, -0.15999591f, 0.23519531f, -0.32532942f, -0.04542611f, 0.06275868f, 0.10356671f, -0.11077376f, 
    0.07670897f, -0.01274821f, -0.52214444f, -0.31372285f, 0.36901009f, -0.19272405f, 0.41580606f, -0.18657747f, 
    0.01049783f, -0.13651681f, -0.12428784f, -0.44034490f, 0.03580702f, -0.55067015f, 0.15777896f, -0.91931343f, 
    -0.28310379f, 0.44800887f, -0.04315780f, -0.12549464f, 0.07395580f, -0.15716326f, -0.12119271f, 0.37898251f, 
    0.49580178f, -0.77436644f, -0.21201587f, -0.36707896f, -0.60605532f, -0.76646525f, -0.34535950f, 0.03465123f, 
    0.15089385f, -0.02322033f, -0.15504114f, -0.23520654f, -0.22284117f, -0.66710228f, -0.36101991f, -0.01414361f, 
    0.28160167f, -0.39119077f, 0.17470309f, 0.34859523f, -0.18216799f, -0.49517921f, -0.17430809f, 0.45191401f, 
    0.39402789f, 0.36147851f, 0.12472174f, -0.12359296f, -0.28143671f, -0.08667406f, 0.04863491f, -0.45154530f, 
    0.68451631f, -0.78995824f, 0.09135385f, -0.14385135f, 0.19025397f, -0.05501375f, -0.03948249f, -0.01654968f, 
    0.35551390f, -0.10918240f, -0.33313861f, -0.31939593f, -0.03453267f, 0.01239646f, 0.22910815f, 0.01165292f, 
    -1.17356622f, 0.28043079f, -0.52929300f, -0.11997955f, -0.26956815f, -0.57765716f, 0.09493920f, -0.59905976f, 
    0.34400585f, -0.10729890f, 0.16127436f, -0.11502187f, -0.43201485f, -0.15398754f, 0.06363066f, 0.22319113f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.18601812f, 0.28003699f, -0.00452153f, 0.17198631f, -0.19875078f, -0.05193799f, 0.09186243f, -0.00833998f, 
    -0.03348503f, 0.16140828f, -0.04224560f, 0.11049864f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
