#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.61345911f, -0.57377076f, -0.43529460f, 0.55691677f, 0.14048326f, -0.52182555f, 0.45901197f, 0.42613602f, 
    -0.18748637f, 0.35194224f, -0.35892975f, -0.01284678f, -0.63936400f, -0.04892495f, -0.35790601f, 0.07121649f, 
    0.32552364f, -0.27126306f, -0.42013234f, -0.05480236f, -0.18649828f, 0.08639733f, 0.00272518f, -0.11067721f, 
    0.08605316f, -0.90771765f, 1.07813644f, -0.03193456f, -0.64708745f, 0.91759431f, 0.49258292f, -0.25573364f, 
    -0.20686188f, 0.25610173f, -0.42457175f, -0.15086497f, -0.12650011f, -0.36932245f, 0.42128626f, -0.20211956f, 
    -0.04963419f, -0.06832838f, -0.13756213f, -0.16140237f, -0.13663687f, -0.09138668f, 0.12982658f, -0.18770133f, 
    0.19852738f, -0.12580861f, -0.49210781f, -0.49436069f, 0.39306346f, 0.81095350f, -0.63496220f, -0.25320950f, 
    0.48135251f, 0.17807291f, -0.02710117f, -0.55503494f, -0.05394336f, 0.34109396f, 0.26085594f, 0.40469965f, 
    0.28136376f, -0.36912602f, -0.16356499f, -0.10119245f, -0.42863894f, -0.40648186f, 0.27518117f, -0.15765020f, 
    0.07015614f, 0.28602225f, -0.36416423f, -0.62652338f, 0.25079665f, 0.27560487f, -0.30970094f, -0.38105062f, 
    -0.32460585f, 0.04980771f, 0.49605799f, -0.21489947f, -0.73097509f, -0.02718215f, 0.11931871f, -0.44528106f, 
    -0.26784137f, -0.09839774f, -0.11784122f, 0.26389152f, -0.29634079f, 0.27090040f, 0.23589864f, 0.22735196f, 
    0.17899463f, -0.05938553f, 0.14204504f, -0.35195398f, -0.09352439f, -0.60171294f, -0.63125247f, -0.03594609f, 
    -0.05122066f, -0.15399139f, -0.54498810f, -0.30459020f, -0.08886518f, 0.04312800f, 0.39976829f, 0.04764042f, 
    -0.00516272f, 0.20666140f, 0.30425760f, 0.09452732f, 0.26332054f, 0.03424276f, -0.12903331f, 0.50425905f, 
    -0.30054739f, 0.29545832f, 0.06609069f, -0.35443544f, -0.03120020f, -0.00123784f, 0.68353152f, -0.34620646f, 
    -0.38318902f, -0.46109396f, 0.25793755f, -0.29964983f, -0.66513848f, -0.77757531f, -0.46057430f, -0.04079756f, 
    0.40533018f, 0.36606839f, 0.19575624f, -0.01382744f, 0.29826835f, -0.34029862f, 0.26521188f, 0.29791453f, 
    0.00476737f, 0.07036542f, 0.22076572f, -0.21101722f, 0.09853463f, 0.21811223f, 0.11170472f, 0.03321509f, 
    -0.40359405f, 0.72763997f, -0.40773165f, 0.38108408f, 0.62100255f, -0.05574030f, 0.13300084f, -0.14476962f, 
    0.22185178f, 0.26874760f, 0.16840491f, -0.28879189f, 0.35043207f, -0.06875919f, 0.15934038f, 0.47172141f, 
    -0.11629615f, 0.03649966f, 0.29037273f, -0.15883963f, -0.17177270f, 0.23662564f, -0.04327372f, -0.34744698f, 
    0.88605899f, 0.87886918f, -0.26330537f, 0.23339565f, -0.69125092f, 1.00007010f, -0.21432191f, -0.14598046f, 
    0.34130839f, -0.24849613f, 0.40915328f, 0.23321292f, -0.07594061f, 0.08303851f, -0.25392479f, -0.17407508f, 
    -0.20000952f, -0.21688804f, -0.10409171f, 0.19089754f, -0.01604755f, 0.00811804f, 0.15725207f, 0.02655942f, 
    -0.61957574f, -0.60589916f, 0.54180652f, 0.19067214f, -0.33111009f, 0.10719585f, 0.65100175f, 0.48252714f, 
    -0.74488205f, 0.26987007f, -0.18705206f, 0.19618428f, 0.24522595f, -0.23612009f, -0.31937107f, -0.33569831f, 
    -0.15344888f, 0.01927901f, 0.28335565f, -0.24940486f, -0.16925073f, -0.01173146f, 0.35951912f, 0.28587943f, 
    0.10713361f, 0.71680510f, 0.49159980f, 0.48299661f, 0.46777618f, 0.42131567f, 0.40997806f, -0.25079516f, 
    0.23931569f, 0.23649590f, 0.49770680f, -0.00874919f, -0.07234086f, 0.00571720f, -0.30855143f, -0.11871106f, 
    0.33968306f, 0.00096836f, -0.20205511f, -0.37546092f, 0.10726184f, -0.13429275f, -0.28774545f, 0.46827349f, 
    -0.06771100f, -0.20866396f, 0.78616685f, 0.31370023f, 0.05475300f, 0.01399897f, 0.92734236f, 0.34649247f, 
    -0.07291310f, 0.19415170f, -0.27212650f, 0.15951222f, -0.35785362f, -0.05641869f, 0.26771992f, 0.42362696f, 
    0.25356930f, 0.22016978f, -0.09204683f, 0.02996140f, 0.05380378f, 0.36027139f, 0.49776706f, 0.35585514f, 
    -0.21741477f, -0.19923738f, -0.03779095f, 0.83180887f, -0.07803878f, 0.37352043f, 0.73500472f, 0.74668497f, 
    0.20170617f, -0.05277193f, -0.18877886f, 0.30418068f, 0.00492520f, 0.16058463f, 0.39123166f, -0.19426101f, 
    0.09418879f, -0.19037783f, 0.20536157f, 0.09174996f, 0.25190631f, 0.00331652f, -0.27897307f, -0.09940289f, 
    -0.04286315f, 0.07683281f, 0.22912128f, 0.29466078f, -0.17472500f, 0.69047874f, -0.55145496f, -0.71212333f, 
    -0.42231616f, 0.49530911f, -0.37163970f, -0.65821761f, -0.26532233f, 0.16755338f, -0.15510353f, -0.22838843f, 
    0.28539276f, 0.27171916f, -0.24597739f, 0.03172025f, 0.30669209f, 0.10463724f, -0.10869696f, 0.39906117f, 
    0.00011232f, -0.05344618f, 0.35658157f, -0.01393093f, 0.13817234f, -1.11190939f, -0.56020033f, 0.38844490f, 
    0.38587499f, 0.72946960f, 1.04255056f, 0.18428166f, -0.16000219f, 0.25390065f, -0.43560007f, 0.08520139f, 
    0.14611161f, 0.24460769f, 0.49359292f, 0.18432835f, 0.00537207f, 0.02120812f, -0.12157519f, -0.04971227f, 
    0.12383313f, -0.06421340f, 0.00960026f, -0.15319714f, -0.12505771f, -0.29533690f, 0.14736654f, -1.10122538f, 
    -0.35552469f, -0.21890506f, -0.41964135f, -0.35084629f, 0.83014244f, 0.34667757f, 0.43794954f, 0.02241822f, 
    -0.15965778f, -0.25985309f, -0.28771085f, 0.06055076f, -0.18145473f, -0.13818423f, -0.08748680f, -0.16970409f, 
    -0.06131774f, -0.17769498f, -0.10097755f, 0.10367078f, 0.02659122f, -0.07665965f, 0.00317714f, 0.86526728f, 
    0.27738452f, 0.35208958f, -0.84993541f, -0.71546012f, 0.34148258f, 0.51539898f, -0.14230135f, -0.43483803f, 
    0.27197012f, 0.47859809f, 0.26186913f, -0.41639316f, -0.07813901f, 0.01129864f, 0.36826503f, 0.03755678f, 
    -0.23612496f, 0.10096344f, 0.03165217f, 0.16197993f, 0.36935824f, -0.05128238f, 0.13178760f, 0.36395985f, 
    0.35386670f, -0.66939813f, -0.25939110f, -0.52853858f, 0.13343987f, 0.63397944f, -0.10259178f, -0.55747646f, 
    0.03433590f, -0.24597144f, -0.27445766f, 0.01003552f, -0.15268137f, -0.24409737f, -0.17533605f, -0.00829403f, 
    0.44995013f, -0.11520852f, 0.08242623f, 0.19453031f, 0.33630410f, -0.21119517f, 0.24530403f, 0.31513080f, 
    -0.14929099f, -0.92193693f, 0.43461755f, 0.06750400f, -0.63640779f, -0.54875815f, -0.03096215f, 0.08485555f, 
    -0.21353889f, 0.18381269f, 0.16111431f, 0.10726947f, 0.24160372f, -0.11675432f, 0.33259210f, 0.07730117f, 
    0.29514137f, 0.20687376f, 0.20888585f, 0.01592288f, 0.20351499f, -0.37669230f, -0.25747740f, -0.11200476f, 
    -0.46976748f, -0.00525338f, -0.29003212f, 1.01826203f, -0.38181990f, -0.24511136f, 0.18584824f, -0.51399910f, 
    -0.64815259f, -0.56598425f, -0.38670170f, -0.13747780f, -0.00397485f, -0.25673342f, -0.07380777f, -0.22667968f, 
    -0.08437062f, -0.07645867f, 0.02395633f, -0.39131409f, -0.33168098f, -0.40746385f, 0.18238054f, 0.37580523f, 
    0.49231514f, -0.00697163f, 0.04987993f, -0.78651184f, -0.54471695f, -0.18172841f, 1.00472677f, 0.43769217f, 
    0.66997457f, 0.62992334f, -0.21321213f, 0.13994615f, -0.55271071f, -0.34299415f, -0.22833967f, -0.46649113f, 
    -0.27889553f, 0.14385323f, -0.17585719f, 0.01810677f, -0.01942047f, -0.21164751f, -0.18147217f, 0.08949278f, 
    0.15276945f, -0.05930362f, -0.14569302f, -0.15375465f, -0.42041990f, 0.56311876f, -0.43773219f, -0.64546818f, 
    0.31188679f, -0.56771833f, 0.78510141f, 0.74611151f, 0.25817090f, 0.78786331f, -0.36330861f, -0.03386636f, 
    0.17031039f, -0.48451746f, -0.21979231f, -0.03213517f, 0.04784516f, 0.04047211f, 0.37377051f, -0.02868584f, 
    -0.06775033f, 0.11407156f, -0.33110240f, -0.32280263f, 0.18508427f, 0.79077691f, 0.46529716f, 0.86595947f, 
    0.27399641f, 0.68923032f, -0.37157354f, 0.18383315f, -0.27392587f, 0.23046781f, -0.10483052f, 0.00047386f, 
    0.03888801f, 0.33032328f, 0.09257142f, 0.43386143f, -0.09712557f, 0.29093793f, -0.27335727f, -0.07387307f, 
    -0.05281664f, -0.16327956f, -0.09193266f, -0.01794328f, -0.14432658f, -0.07095952f, -0.14420435f, -0.05501813f, 
    0.40893334f, 0.10800618f, 0.60097885f, -1.08594012f, -0.47667173f, -0.70759469f, -0.76579678f, -0.52840680f, 
    0.31682721f, 0.43495464f, -0.18528782f, 0.06907348f, -0.09051254f, -0.12375778f, -0.14470318f, 0.11531118f, 
    -0.42071119f, 0.42621163f, 0.13852145f, 0.00185023f, 0.15023285f, 0.08878469f, -0.33631629f, 0.36788401f, 
    0.62551600f, -0.97011709f, 0.58432597f, 0.82871115f, -0.13040426f, 0.14615670f, 0.28992316f, 0.25312331f, 
    -0.50279939f, -0.15534678f, -0.26969415f, -0.04978975f, -0.11043795f, 0.40192685f, -0.08345284f, -0.13612019f, 
    0.23201059f, -0.13222715f, 0.27205783f, 0.18117897f, -0.25992447f, -0.27447188f, 0.07447077f, 0.26561856f, 
    0.13363144f, -0.22535728f, -0.81031710f, -0.40601251f, 0.05269241f, -0.24507642f, -0.39107981f, 0.30010912f, 
    -0.02891551f, 0.35614547f, -0.72675526f, 0.04412777f, -0.10101300f, -0.39219111f, -0.54552984f, -0.14936684f, 
    -0.26029119f, 0.06759675f, 0.00560863f, -0.40565568f, -0.10568304f, -0.03336638f, -0.31005305f, -0.22675262f, 
    0.01852692f, -0.27158639f, 0.11165878f, 0.35805720f, -0.68533438f, -0.57599562f, -0.14532477f, -0.35178187f, 
    0.05752562f, 0.06153652f, 0.23264359f, 0.02821448f, -0.11071882f, -0.08351296f, 0.59850597f, 0.18545172f, 
    0.42526639f, -0.11194219f, -0.13238239f, 0.17291360f, 0.21198477f, -0.40417564f, -0.02541423f, 0.03264478f, 
    -0.21982358f, 0.49220422f, -0.12435473f, -0.16440970f, -0.36595711f, -0.12987298f, 0.22897729f, 0.19225298f, 
    0.53834587f, 0.58922029f, -0.11300299f, 0.14460637f, -0.04546444f, 0.26985931f, -0.25920734f, -0.15951066f, 
    -0.28005913f, -0.39649487f, 0.09623123f, 0.14483465f, -0.03146108f, 0.38140064f, 0.18728207f, 0.18434982f, 
    0.45196384f, 0.28256571f, 0.16704081f, 0.53147155f, -0.49723589f, 1.00556493f, 0.76199120f, 0.23118885f, 
    0.36895412f, -0.12368170f, -0.32366887f, -0.52773744f, -0.67713803f, 0.13427624f, -0.39356223f, -0.13035424f, 
    0.07509039f, -0.13187529f, -0.18652254f, 0.26291433f, 0.10585245f, -0.06266634f, 0.27417010f, -0.07884853f, 
    0.02907088f, -0.03841056f, 0.22262238f, -0.02131617f, -0.37696937f, -0.22207159f, 0.84857619f, 0.32153776f, 
    -0.41358778f, -0.25189561f, -0.03758967f, 0.19930626f, 0.13352293f, -0.23301063f, -0.22209427f, 0.14672075f, 
    -0.08738539f, 0.14615099f, -0.29709733f, 0.28917852f, 0.47136700f, 0.04677662f, -0.19287233f, 0.03216738f, 
    -0.33530274f, -0.66219598f, 0.10125782f, -0.14318056f, 0.33538014f, -0.45447275f, -0.31419232f, -0.57045156f, 
    -0.39726257f, -0.52497071f, 0.77907008f, 0.62654233f, 0.14509460f, 0.11678915f, 0.08010469f, -0.44765761f, 
    -0.20887114f, 0.01152807f, -0.02762591f, -0.05641573f, -0.16084726f, -0.07030961f, 0.24344914f, -0.28086191f, 
    0.11797663f, -0.19964704f, -0.09708837f, 0.21826626f, 0.27381197f, 0.34419248f, -0.40484613f, -1.09249198f, 
    -0.61840147f, 0.00336343f, 0.09039257f, -0.03924933f, 0.72305059f, -0.03724236f, -0.34009278f, 0.37264889f, 
    0.24008621f, 0.02001314f, -0.26134923f, -0.07461618f, 0.06805956f, -0.10042646f, -0.05988750f, -0.04813728f, 
    0.04591198f, -0.10779843f, -0.03615056f, -0.04449064f, -0.13229646f, 0.04974721f, -0.23195753f, -0.63762534f, 
    0.27449486f, 0.11037415f, -0.57727665f, -0.04531983f, -0.42463723f, -0.44073409f, -0.11595841f, -0.05672291f, 
    -0.60034949f, -0.36572668f, 0.23820890f, -0.10748568f, 0.15973622f, -0.36794579f, -0.38342392f, -0.19288611f, 
    -0.13452616f, -0.57075465f, -0.34898385f, -0.15187831f, 0.05870710f, 0.05193251f, 0.45406097f, 0.26428902f, 
    0.26394281f, 0.52312756f, 0.63547754f, 0.67861921f, 0.34149152f, 0.52768785f, 0.07171780f, -0.72445202f, 
    0.43113336f, 0.00917145f, 0.23186775f, -0.36239728f, 0.07358158f, 0.27072832f, -0.66115385f, -0.22164576f, 
    -0.30539930f, -0.01759352f, -0.23018564f, -0.27845162f, -0.19137612f, -0.10509151f, 0.00946486f, -0.12998031f, 
    -0.06135884f, 0.02982790f, -0.12026688f, -0.06981733f, 0.94533318f, 0.03927682f, 0.43227729f, -0.16273127f, 
    -0.21612896f, 0.42847723f, 0.30031160f, 0.23952839f, -0.20752907f, -0.42790288f, 0.24519902f, 0.09512807f, 
    -0.10118029f, 0.05097530f, 0.14677654f, -0.23842487f, 0.42029446f, 0.07941989f, 0.47226259f, 0.44734317f, 
    -0.07246435f, -0.18779150f, 0.18274511f, 0.22747016f, -0.41780964f, -0.85993791f, -0.22528107f, 0.80016893f, 
    0.12269779f, 0.54049438f, 0.24762625f, -0.22751303f, 0.17053287f, -0.02099607f, -0.01736373f, -0.00170280f, 
    0.02179743f, -0.07729271f, -0.38846529f, -0.14735994f, 0.19900061f, 0.42070708f, 0.03448402f, -0.21753296f, 
    -0.16470501f, -0.23515961f, -0.06891315f, 0.96953166f, 0.47574261f, -0.55776817f, 0.05697216f, -0.19147228f, 
    0.12565520f, 0.31015041f, 0.04146385f, -0.24709123f, -0.42984089f, -0.00157656f, -0.07413569f, -0.13685919f, 
    0.36386904f, 0.05924734f, 0.25653854f, 0.14339978f, -0.18212140f, -0.33583117f, 0.23960645f, -0.22277038f, 
    0.17791623f, 0.20027797f, 0.24280757f, -0.42387852f, 0.81997025f, 0.25044763f, 0.12025639f, -0.76698589f, 
    -0.40486538f, -0.09822900f, -0.40818626f, 0.07285437f, 0.11431440f, -0.01698650f, 0.13386147f, 0.47879162f, 
    -0.01523575f, -0.11046676f, 0.47297528f, 0.21284297f, 0.12224644f, 0.20275579f, 0.17573072f, 0.21622728f, 
    0.39163464f, 0.04020224f, 0.00185037f, -0.08766918f, 0.32038781f, -0.79328948f, -0.03449902f, 0.38485798f, 
    -0.03947733f, 0.28887603f, 0.32038322f, 0.62740201f, 0.67464083f, 0.28489637f, 0.32097572f, 0.20958470f, 
    0.23719092f, 0.28502145f, -0.39229885f, -0.55823314f, 0.10961077f, -0.17580160f, 0.00340412f, -0.05348039f, 
    -0.11588334f, 0.10074759f, -0.23745739f, 0.06501947f, -0.37116671f, -0.33386502f, -1.64897645f, 0.23976102f, 
    0.30541942f, -0.09095080f, -0.65191460f, 0.60695541f, 0.59808248f, -0.21917246f, 0.36878905f, -0.18035820f, 
    0.02650082f, -0.33510619f, 0.23546833f, 0.12054893f, 0.11789230f, -0.22589275f, -0.32806489f, -0.12562026f, 
    -0.19976178f, -0.32864389f, 0.09198613f, 0.06578583f, 0.28980002f, 0.14241943f, 0.11250824f, 0.85651660f, 
    0.12069900f, -0.24151179f, 0.39785033f, 0.59964830f, -0.16169679f, 0.29381770f, 0.62312603f, 0.43031636f, 
    0.48215941f, -0.50267130f, -0.43904090f, 0.05389618f, 0.03207522f, -0.20419022f, 0.11424650f, -0.21864136f, 
    -0.00316319f, -0.19062978f, -0.20280796f, 0.46474588f, -0.15942962f, -0.06259605f, 0.04562264f, 0.03776965f, 
    0.14175825f, -0.47238851f, -0.02244327f, 0.84736478f, -0.07944509f, -0.29922974f, -0.32740167f, -0.09935277f, 
    -0.56265837f, 0.43494838f, 0.05847216f, 0.07905366f, -0.17534776f, 0.24071012f, -0.02465826f, -0.49871415f, 
    0.16049697f, 0.40879083f, -0.03428160f, -0.44721907f, -0.31198668f, -0.15385850f, -0.18188941f, 0.15998212f, 
    -0.20949696f, 0.74962103f, 0.22536607f, -0.56444585f, 0.14217117f, 0.61509967f, -0.59113520f, 0.20863648f, 
    0.13372600f, -0.14176916f, 0.00655377f, -0.33633807f, 0.04762919f, 0.32424489f, -0.43227732f, 0.19956177f, 
    0.11625471f, -0.20185925f, -0.07743896f, 0.33403763f, 0.14845735f, -0.35761499f, -0.36124998f, -0.28673080f, 
    0.16378489f, -0.23086327f, -0.29239899f, 0.40945747f, -0.55501217f, -0.77132833f, 0.46918359f, 0.21860521f, 
    -0.33071539f, -0.21503387f, -0.13304608f, -0.08691429f, -0.08610801f, -0.31048989f, 0.08262292f, -0.08201504f, 
    -0.01016345f, -0.16344817f, 0.29868478f, 0.10715333f, 0.18309729f, -0.50531346f, 0.03799354f, -0.27898335f, 
    0.14552832f, 0.33998334f, 0.54104698f, 1.12373269f, 0.26538405f, -0.04704275f, 0.53479570f, 0.71766603f, 
    0.46982297f, 0.33465287f, 0.04909080f, 0.38163713f, -0.28392780f, -0.41858789f, -0.04662392f, 0.09376732f, 
    -0.06187190f, -0.29190016f, -0.07854628f, 0.04892869f, 0.31062075f, -0.03079410f, -0.13892464f, 0.36487100f, 
    0.29079881f, 0.15145649f, 0.07219370f, 0.15029350f, 0.90238094f, 0.65877169f, 0.81238306f, -0.42231756f, 
    -0.62488222f, -0.39574668f, -0.34955987f, -0.04570533f, 0.30988047f, -0.00914427f, 0.27170056f, 0.14346723f, 
    -0.10648974f, 0.12410845f, -0.11908837f, -0.04186195f, 0.06866720f, 0.06897384f, 0.05046768f, -0.01614198f, 
    0.13731724f, 0.08199779f, -0.03260632f, 0.27380043f, -0.15000120f, 0.62436485f, -0.48450607f, -0.35882959f, 
    -0.31401131f, -0.84539843f, 0.05526286f, -0.58129710f, -0.41119164f, 0.33402550f, -0.17652427f, 0.63693058f, 
    0.45533550f, 0.03156465f, 0.27404025f, -0.18278383f, 0.26026204f, 0.02614849f, 0.20217185f, -0.04402770f, 
    0.16303261f, -0.14641403f, 0.11320004f, -0.00271351f, 0.25383618f, 0.22852862f, 0.28874758f, 0.08664805f, 
    -0.56703967f, -0.67090255f, -0.48775437f, 0.44737494f, 0.64556623f, -0.21508464f, 0.17420480f, 0.17134263f, 
    -0.01508063f, 0.19970493f, -0.12345619f, 0.13678814f, 0.28326696f, -0.10868949f, 0.13330734f, 0.31974426f, 
    0.37207261f, 0.09777004f, -0.33574855f, -0.23955792f, 0.06243224f, -0.09689128f, -0.22317548f, -0.52816206f, 
    0.20757309f, 0.17220707f, 0.00143469f, 0.26752204f, -0.91729635f, 0.39072952f, -0.44467041f, -0.60239106f, 
    -0.55967087f, 0.03601231f, 0.42690769f, -0.05808093f, -0.15412039f, -0.12531206f, 0.09943454f, 0.27040708f, 
    0.19986716f, 0.08130226f, -0.22508316f, 0.06716527f, -0.16130738f, -0.03342224f, -0.21799363f, 0.30461523f, 
    -0.58223903f, -0.75517768f, -0.72322756f, -0.04681153f, -0.33696136f, -0.10485061f, -0.12365838f, -0.37443271f, 
    0.46843648f, 0.19178571f, -0.01117373f, 0.04039361f, -0.08612256f, 0.09351706f, 0.21224958f, 0.23924223f, 
    -0.16053870f, 0.35746145f, -0.16908231f, -0.00270993f, -0.11731786f, 0.15185593f, -0.01833545f, 0.31444204f, 
    0.20840544f, -0.69496822f, -0.38963720f, -0.60868090f, -0.56087196f, -0.42579800f, -0.06147672f, 0.82415438f, 
    0.19575050f, 0.24446687f, 0.46439144f, 0.10757009f, -0.54361147f, 0.02584335f, -0.16734023f, -0.03791302f, 
    0.02412404f, 0.30277774f, 0.25453356f, 0.21480155f, -0.29168671f, 0.09272613f, 0.11901758f, 0.00622654f, 
    -0.20972115f, -0.07139187f, -0.29173842f, -0.55413139f, -0.44765002f, -0.49023789f, -0.03714982f, -0.53084886f, 
    0.41787919f, -0.01498734f, -0.15894283f, 0.17739004f, -0.07980561f, 0.35075861f, 0.03579835f, 0.00877956f, 
    0.48284701f, -0.24488769f, -0.33606595f, 0.33868641f, -0.35717466f, -0.12860210f, 0.43125618f, 0.15518257f, 
    -0.07603195f, 0.16869625f, -0.19669949f, -0.77427411f, -0.53945118f, -0.60825324f, -0.04846662f, 0.30113533f, 
    -0.81229210f, 0.45817706f, 0.43623957f, -0.41024026f, -0.45270926f, 0.18466531f, 0.01276868f, -0.02064505f, 
    -0.17735960f, 0.42889428f, 0.00768586f, 0.60016102f, 0.12023093f, 0.37372673f, -0.17812270f, 0.21088824f, 
    -0.13275346f, -0.08727288f, 0.03506378f, 0.25537735f, -0.41210589f, 0.16372281f, -0.71728528f, -0.08450371f, 
    -0.55429786f, 0.66174561f, -0.57773727f, -0.02995484f, -0.04829778f, -0.55776423f, 0.04621605f, -0.01090014f, 
    -0.21711268f, 0.45069143f, 0.16371197f, -0.16295153f, -0.07153024f, -0.39490509f, -0.42184386f, -0.07696021f, 
    0.12742065f, -0.14782789f, 0.26033953f, -0.22988473f, -0.08878434f, 0.02329460f, -0.94150233f, -0.16337365f, 
    0.42171496f, -0.18658781f, -0.66270667f, -0.30675608f, 0.55170047f, -0.64328700f, -0.13150053f, 0.41387826f, 
    0.20352305f, 0.39070910f, -0.09214642f, 0.34604001f, -0.37646621f, 0.23101369f, -0.14987090f, -0.14645821f, 
    0.25786519f, 0.36485228f, 0.09272583f, 0.16963035f, -0.01593062f, -0.16562738f, 0.86512423f, 0.87642980f, 
    0.81543791f, 0.93232489f, 0.79219651f, -0.05482037f, -0.04728825f, -0.54817796f, -0.24600092f, 0.20050678f, 
    0.28271145f, 0.01030950f, -0.09337541f, 0.26880130f, -0.25421706f, 0.04234380f, 0.28232312f, 0.45334882f, 
    0.10932013f, 0.40286270f, 0.27376366f, 0.01504434f, 0.15706386f, -0.07381560f, 0.37402284f, -1.04016519f, 
    0.34766591f, -0.25904894f, -0.78216934f, -0.63273984f, 0.75262827f, -0.03279265f, -0.29102358f, 0.60700542f, 
    0.56252128f, 0.07374427f, -0.21064097f, 0.18920359f, -0.06297918f, -0.21892203f, 0.18015134f, 0.24208356f, 
    0.18862295f, 0.02742971f, 0.10096932f, 0.11259699f, -0.22942738f, -0.11383045f, -0.10665926f, -0.12113887f, 
    0.82606232f, 0.81221664f, 0.64331532f, 0.08194654f, 0.12017833f, -0.23623800f, -0.34587732f, 0.16238560f, 
    -0.21458842f, 0.32533139f, 0.45782328f, -0.11547875f, -0.14054805f, 0.03159835f, -0.14687026f, -0.34157541f, 
    -0.00200245f, -0.18055561f, -0.07464969f, -0.21995145f, 0.02517461f, 0.28631419f, -0.07193012f, 0.32993516f, 
    -0.00773341f, -0.36923593f, -0.87393224f, 0.27221465f, -0.61012524f, -0.77350914f, 0.05192799f, -0.40006569f, 
    0.26050964f, 0.12210327f, -0.18002188f, -0.08884482f, -0.30141357f, -0.36156940f, -0.00381272f, 0.08439084f, 
    -0.06909264f, 0.00078414f, -0.08057273f, 0.15191005f, -0.38178748f, 0.56404769f, 0.07768238f, -0.05907977f, 
    0.05690566f, 0.07424011f, -0.26304507f, -0.39998341f, 0.87144721f, 0.14782740f, -0.44123703f, -0.46894574f, 
    0.42457524f, 0.48744211f, 0.48967564f, -0.23888950f, -0.20751148f, -0.30790725f, 0.21433534f, -0.03914431f, 
    0.05694019f, 0.15632087f, -0.23657583f, 0.11984094f, -0.05265476f, 0.36469156f, 0.15489846f, 0.37229455f, 
    0.10484027f, -0.35214612f, 0.31913978f, 1.06632805f, 0.55560517f, 0.44733539f, -0.57574296f, -0.29854381f, 
    0.07549557f, -0.25103560f, -0.47608480f, -0.20674804f, 0.13801977f, -0.32114846f, 0.19849855f, -0.05233022f, 
    0.15470736f, -0.15054531f, -0.42267087f, 0.04970774f, 0.03822189f, -0.27462751f, 0.07828283f, 0.02640360f, 
    0.34037668f, -0.20704995f, -0.24930641f, 0.15954143f, -0.44989768f, -0.45609909f, -0.57830477f, -0.52795261f, 
    0.02485716f, -0.47693086f, -0.20990559f, -0.21581852f, -0.02155195f, 0.55648571f, 0.47514138f, 0.13195002f, 
    0.14233989f, -0.14609337f, -0.19042672f, -0.02025471f, 0.23645435f, 0.07368820f, -0.21870838f, 0.35133916f, 
    0.07573497f, -0.07953235f, -0.38264850f, 0.35945618f, -0.37067613f, 0.52339691f, 0.14567563f, -0.58030760f, 
    -0.68729305f, -0.52191544f, 0.33480003f, -0.34529722f, 0.41799629f, -0.00502581f, 0.20684181f, -0.24885926f, 
    -0.01910713f, 0.24639799f, 0.29633850f, -0.23079878f, 0.04053245f, 0.10396516f, -0.25671390f, -0.14600576f, 
    -0.19526100f, -0.36067486f, 0.36331028f, -0.31193113f, 0.01320405f, 0.15265314f, 0.12008782f, -0.31799099f, 
    -0.81827199f, 0.00118203f, 0.16614281f, -0.30619594f, 0.51046413f, 0.55227607f, -0.11545099f, 0.15132631f, 
    0.26066899f, -0.04921856f, -0.22726037f, -0.15893017f, 0.29941630f, 0.10110719f, -0.39239904f, -0.61646390f, 
    -0.21579397f, -0.44554996f, -0.12134615f, 0.26521769f, 0.04402785f, 0.38299099f, 0.01303456f, -0.28016114f, 
    0.26195285f, 0.24355115f, 0.34178612f, 0.25757149f, 0.57684398f, -0.52639639f, -0.61756980f, -0.70472217f, 
    -0.60156125f, 0.23678012f, 0.37313265f, 0.28274816f, -0.17630132f, -0.58506572f, -0.37080690f, 0.25830370f, 
    0.19105600f, -0.10997104f, 0.05407160f, -0.06322529f, -0.11426270f, -0.28385818f, -0.24537295f, -0.22110374f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.00910299f, -0.01507262f, -0.01536907f, 0.22683877f, 0.22295524f, 0.16794857f, 0.29927751f, 0.17182608f, 
    0.05036657f, 0.32595772f, 0.02503795f, 0.23750295f, 0.20536177f, 0.15541606f, 0.07607660f, 0.09536141f, 
    0.04127273f, 0.14479373f, 0.19343680f, -0.01796518f, 0.23200427f, 0.14196561f, 0.06749175f, 0.04481625f, 
    0.11606368f, 0.23456970f, 0.02743247f, 0.02921884f, 0.11132007f, -0.07158194f, 0.09603263f, 0.21369424f, 
    0.16524431f, 0.02829879f, 0.18894860f, 0.18478414f, 0.24466956f, -0.07535423f, 0.07504773f, 0.15634803f, 
    0.21383692f, -0.06624511f, 0.12559722f, 0.05912894f, 0.26898170f, 0.12121034f, 0.32350966f, 0.20033264f, 
    0.02521823f, 0.10098462f, 0.16426153f, 0.22981460f, 0.08950746f, 0.04429987f, 0.13799316f, 0.15073618f, 
    0.23645818f, -0.09051822f, 0.02844757f, 0.10322972f, 0.23972587f, -0.06103477f, 0.13094798f, 0.15091704f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.13489163f, 0.14044113f, -0.05186477f, 0.05401974f, -0.02774382f, 0.14683877f, -0.19450185f, 0.06788726f, 
    -0.03753861f, 0.08497343f, 0.03184790f, 0.05625434f, -0.20421985f, 0.04582402f, 0.32260588f, -0.25245693f, 
    0.06344406f, 0.00071821f, 0.09103857f, -0.04930980f, 0.12037595f, 0.02441115f, -0.05523794f, -0.01545072f, 
    -0.07813847f, 0.09255142f, -0.11168569f, 0.19197072f, 0.10143656f, 0.03714182f, 0.09316918f, -0.07227298f, 
    0.04003222f, 0.08104486f, 0.09536118f, -0.04625270f, -0.33837992f, 0.24502295f, 0.08028398f, 0.15561949f, 
    -0.02396434f, -0.00576004f, 0.00451503f, -0.03570466f, 0.00447929f, -0.06931715f, 0.12464157f, -0.11990446f, 
    -0.06814713f, -0.36891851f, -0.03518106f, 0.10779280f, -0.02289302f, -0.00918471f, 0.02436882f, 0.03852620f, 
    -0.12307392f, -0.05262235f, -0.03762225f, 0.00349390f, -0.24444650f, 0.11717273f, 0.13579506f, -0.21381329f, 
    -0.14227566f, 0.02886396f, 0.07810226f, -0.07060004f, -0.03967274f, -0.01300466f, -0.22019833f, 0.05025486f, 
    -0.03379289f, 0.14850548f, -0.07904857f, 0.00040105f, -0.05682416f, -0.01217768f, -0.13593970f, -0.07395883f, 
    0.00853794f, -0.00970533f, -0.06087374f, -0.00221047f, -0.03996092f, -0.10407740f, 0.11613590f, -0.08881418f, 
    -0.03311889f, -0.02744126f, -0.04572556f, -0.16025081f, -0.05376161f, -0.06311821f, 0.04581303f, 0.02295603f, 
    -0.29436526f, 0.20767781f, 0.06198342f, 0.04084690f, -0.01392001f, 0.08209638f, 0.00065899f, -0.04952932f, 
    0.00729755f, 0.07053898f, -0.04754186f, 0.03781556f, 0.03617042f, -0.17046487f, 0.07019110f, 0.13291956f, 
    -0.27258152f, 0.07411590f, 0.00256915f, 0.03154068f, -0.02089916f, -0.03146251f, -0.08901828f, -0.13318363f, 
    0.23888519f, -0.18439148f, 0.08256528f, -0.27927899f, 0.07611396f, 0.07683081f, -0.01215888f, 0.07027712f, 
    0.06596182f, 0.01069366f, -0.01442416f, 0.02410483f, 0.12442263f, -0.11871619f, -0.01420297f, 0.23060419f, 
    -0.07044220f, -0.08690055f, 0.06045741f, 0.08781867f, 0.00845006f, 0.03066088f, -0.01535378f, -0.05948415f, 
    0.09485264f, 0.02019493f, -0.03005949f, -0.27068028f, 0.02531483f, 0.01638710f, 0.02695765f, -0.00317103f, 
    0.01598281f, 0.00388740f, -0.02330303f, -0.00673639f, -0.53512341f, -0.22352985f, 0.09419162f, 0.08186936f, 
    -0.02452978f, -0.03193335f, -0.03264730f, -0.05637540f, -0.00141862f, -0.02606331f, 0.07502927f, -0.04545331f, 
    -0.10345964f, 0.09035785f, -0.08174279f, -0.07020757f, 0.01281582f, 0.02146371f, 0.05657786f, 0.02374644f, 
    0.00266720f, -0.04181148f, -0.03305359f, 0.05109657f, -0.25549310f, 0.11862218f, 0.12063979f, -0.22372369f, 
    -0.02195852f, 0.05268793f, 0.05753339f, -0.01370969f, -0.10373717f, 0.05847466f, 0.01267350f, 0.12111506f, 
    -0.14389195f, 0.04205941f, 0.16764115f, -0.16695392f, 0.01548620f, -0.02132836f, 0.01499906f, 0.08050782f, 
    -0.22934473f, -0.00247576f, 0.10151970f, 0.16193269f, 0.10974247f, -0.00944838f, -0.03871115f, -0.01947615f, 
    0.13977550f, 0.06968366f, -0.00230445f, 0.11235204f, 0.03880850f, 0.04258982f, -0.09655713f, -0.11149059f, 
    0.03608862f, -0.00388751f, 0.10370351f, -0.10928217f, 0.09273299f, -0.07157511f, -0.00435041f, -0.05939039f, 
    -0.02545473f, 0.01222937f, 0.05559966f, -0.07463749f, -0.24595983f, 0.17601821f, 0.20171241f, 0.18439516f, 
    0.08933704f, 0.08751982f, 0.05861490f, 0.04494932f, -0.07225747f, -0.10527026f, 0.09547491f, 0.00457627f, 
    0.08648051f, 0.17635913f, -0.01172000f, -0.27049473f, 0.10013537f, -0.01970163f, 0.00995983f, 0.00027102f, 
    -0.01077878f, -0.02851117f, -0.07658776f, 0.01641131f, 0.10259982f, -0.02172942f, -0.11643356f, 0.00472089f, 
    -0.26222691f, -0.10283884f, 0.02668045f, 0.04131301f, -0.00603882f, -0.05505800f, -0.00060924f, -0.07370865f, 
    0.08379942f, -0.11680661f, -0.09019996f, 0.04166339f, -0.01531466f, -0.05740494f, -0.04879002f, -0.04634725f, 
    0.09727663f, -0.25362059f, 0.03923890f, -0.01901766f, 0.09428861f, 0.17890236f, 0.11721113f, 0.01761672f, 
    -0.31767169f, -0.03254986f, 0.05780566f, 0.09775221f, -0.01278066f, 0.06353994f, 0.08002305f, 0.03788857f, 
    -0.00487699f, -0.14723285f, 0.03950854f, -0.18383315f, -0.02286652f, -0.04399623f, 0.06055779f, -0.03694934f, 
    -0.08061166f, 0.04067342f, -0.10441846f, 0.04412140f, -0.16058971f, 0.05641824f, -0.05163608f, -0.18985145f, 
    -0.00095409f, -0.01199690f, -0.11357523f, 0.12674679f, 0.04726487f, 0.01004321f, -0.08902317f, 0.05303561f, 
    -0.11979969f, 0.11821513f, 0.03706682f, -0.15824974f, 0.04395058f, 0.13065843f, 0.04760917f, 0.09764150f, 
    -0.10843942f, 0.05723434f, -0.03115229f, -0.06431124f, 0.15850978f, -0.03942765f, -0.06442443f, 0.23968682f, 
    -0.09288482f, -0.08157513f, 0.13476615f, 0.05168390f, -0.11204410f, -0.06450674f, -0.07898375f, 0.01920561f, 
    -0.11723043f, 0.12027708f, -0.20910980f, 0.24372102f, 0.05708937f, -0.06472618f, 0.13237768f, 0.06240818f, 
    0.10045148f, 0.07611085f, -0.12935331f, -0.04917203f, 0.22789346f, 0.09194922f, -0.03381119f, -0.18134983f, 
    0.14113139f, 0.10069042f, -0.03053863f, 0.08907153f, -0.04228114f, 0.01049148f, -0.05385632f, 0.07270450f, 
    -0.12185644f, -0.05297549f, 0.07431510f, -0.06421658f, 0.04975335f, -0.00513460f, -0.05902279f, -0.01224676f, 
    0.00791539f, -0.03700661f, 0.07890626f, 0.00519399f, -0.36365744f, 0.07246506f, 0.05057077f, 0.06178793f, 
    0.06043141f, 0.01522077f, -0.02050625f, 0.00613532f, 0.02889896f, 0.02840119f, 0.02541629f, -0.03316798f, 
    0.10765793f, -0.00697588f, -0.06508097f, 0.22519490f, -0.12309705f, 0.01711675f, -0.09262705f, 0.08792599f, 
    0.02988373f, 0.05953702f, -0.11642989f, 0.01052329f, 0.08828133f, -0.00370504f, -0.13723856f, 0.29314408f, 
    0.01707055f, 0.15625075f, -0.12698352f, -0.02113955f, 0.01300242f, -0.03834948f, -0.11583966f, 0.01258762f, 
    0.02991038f, -0.10643815f, -0.02899578f, -0.26130033f, -0.02685491f, 0.01387212f, 0.10973545f, -0.02745094f, 
    0.04614749f, -0.01752458f, 0.02230725f, 0.13699341f, 0.05779652f, 0.09966155f, -0.00356356f, -0.21029513f, 
    -0.27013069f, -0.02127479f, -0.20537210f, 0.03565978f, -0.01965220f, -0.01177961f, -0.08047379f, -0.18212534f, 
    -0.10209009f, 0.04976096f, 0.13616195f, -0.22371472f, 0.12748185f, -0.02559680f, -0.00034519f, 0.01633737f, 
    0.04899785f, -0.05392449f, -0.02445483f, 0.03015477f, 0.02680161f, 0.12346153f, 0.09414349f, -0.04685238f, 
    -0.02232902f, 0.05545124f, -0.00663797f, 0.03360502f, 0.06418397f, 0.03733789f, -0.02388866f, -0.16945586f, 
    0.54731780f, 0.01320087f, 0.15262797f, -0.00804290f, 0.01843105f, 0.05761983f, -0.10083164f, 0.02675859f, 
    0.06269276f, -0.02074450f, 0.15325691f, 0.07846119f, 0.02477787f, 0.04513108f, -0.00886582f, 0.19492218f, 
    -0.00469511f, 0.09848619f, -0.05629069f, 0.03955212f, -0.05512232f, 0.05518306f, 0.13394630f, -0.03120988f, 
    0.02587612f, -0.03558686f, -0.15121104f, 0.16384643f, -0.06313416f, -0.02667692f, 0.07051194f, -0.02389031f, 
    -0.05732997f, 0.04117988f, -0.16694742f, 0.05332543f, 0.07842234f, -0.03890103f, 0.01829975f, -0.00635581f, 
    -0.17801315f, -0.00530812f, -0.08062868f, 0.18642707f, 0.05760654f, 0.00223480f, 0.06267709f, -0.02134963f, 
    0.00207771f, -0.11122672f, 0.16430455f, -0.21022449f, 0.03676751f, -0.09671412f, -0.09281959f, 0.00366327f, 
    -0.00554540f, -0.02052390f, -0.03738999f, -0.00287867f, 0.14432237f, 0.02161051f, -0.02623362f, 0.16249540f, 
    0.04618446f, 0.01765732f, -0.03492319f, 0.01291599f, -0.03756640f, 0.08596125f, -0.06478254f, -0.05584214f, 
    -0.04572257f, 0.12995592f, -0.04686211f, 0.01575262f, -0.07233877f, -0.09254832f, -0.03401768f, -0.06847764f, 
    -0.00803403f, -0.00426528f, -0.01812512f, -0.06925210f, -0.16092275f, -0.36695829f, 0.05771736f, 0.08485013f, 
    -0.07554463f, -0.03361028f, -0.01241630f, -0.04746051f, 0.10265905f, -0.02501125f, -0.08745356f, 0.09432454f, 
    0.06005982f, -0.04593477f, 0.03033752f, -0.36694527f, -0.02941322f, 0.02785395f, 0.01010101f, -0.01598827f, 
    0.04442579f, 0.02741421f, -0.02577967f, 0.03546852f, -0.27656487f, -0.07356706f, -0.03734576f, 0.04365799f, 
    -0.04728098f, 0.00325210f, -0.00045813f, -0.01031579f, -0.06557619f, 0.00469524f, -0.11081707f, 0.00964857f, 
    0.12270047f, -0.12443403f, -0.32696238f, -0.10834655f, 0.05497429f, -0.00218311f, 0.09915823f, -0.06710147f, 
    0.04273158f, -0.05192539f, 0.03111978f, -0.05291190f, 0.25995117f, 0.15812895f, 0.07225200f, -0.30461764f, 
    0.08896112f, 0.08541846f, -0.01026856f, 0.05727217f, -0.02217830f, 0.03292244f, -0.02098468f, 0.09944495f, 
    -0.31137839f, -0.11361820f, -0.04561858f, -0.01774232f, 0.04647107f, -0.04710156f, -0.05376739f, 0.03287657f, 
    0.00673964f, -0.01187825f, -0.04466973f, 0.00532544f, -0.40067494f, 0.16730623f, -0.06094926f, 0.06699781f, 
    0.10499849f, -0.01253167f, -0.08090374f, 0.11026295f, 0.05095767f, -0.02400962f, -0.06409605f, 0.08553070f, 
    0.12910111f, -0.09515397f, -0.15897140f, -0.09277381f, 0.02497168f, 0.06904677f, 0.06081160f, -0.00413567f, 
    -0.07982779f, -0.06866986f, -0.00135477f, 0.04326927f, -0.04734198f, -0.14949195f, -0.16464783f, 0.16363265f, 
    0.02490159f, 0.02414907f, -0.08015919f, -0.07471437f, -0.05665419f, -0.03275634f, -0.03946541f, 0.04750575f, 
    0.07776208f, -0.01264229f, 0.04537317f, 0.10846329f, -0.25047851f, -0.10464268f, 0.01558705f, 0.06796859f, 
    0.01778776f, 0.01738093f, -0.11087561f, -0.01624007f, 0.53395993f, -0.05176920f, -0.07794993f, -0.12017631f, 
    0.00433218f, -0.02858714f, 0.00825406f, -0.02383243f, 0.01287013f, -0.03298943f, -0.07203572f, -0.09007484f, 
    0.13802791f, 0.06910510f, 0.09047292f, -0.16343215f, -0.11755256f, -0.10194336f, -0.00137853f, -0.04378669f, 
    -0.10472724f, -0.07439893f, 0.04860715f, 0.01336560f, -0.24340785f, -0.12736477f, -0.01975040f, 0.09025977f, 
    -0.00229418f, 0.07275122f, -0.07409739f, 0.04283485f, 0.13139196f, 0.15600805f, -0.08837883f, 0.01278991f, 
    -0.01038590f, 0.09324928f, -0.01762732f, 0.23850994f, -0.13468637f, 0.02396491f, 0.09081922f, 0.00672837f, 
    0.05414384f, -0.02501656f, -0.03363517f, 0.01068480f, 0.05992673f, 0.12590083f, 0.13668716f, -0.27965155f, 
    -0.01890011f, -0.10597791f, 0.09999775f, 0.06226780f, -0.12668584f, -0.05434635f, -0.11947069f, 0.06808098f, 
    -0.05789421f, -0.13926384f, -0.11533494f, 0.00316168f, -0.07996308f, 0.05223421f, -0.02575723f, 0.02924860f, 
    -0.04523036f, -0.04690787f, 0.02289119f, -0.10614971f, 0.11351580f, -0.18319814f, -0.05524643f, -0.38107258f, 
    0.00082241f, -0.03000274f, 0.16168351f, -0.13111404f, -0.12482841f, 0.01572052f, 0.03051694f, 0.00772766f, 
    -0.10345387f, 0.17937519f, -0.01620338f, -0.15257578f, 0.00607365f, -0.07171665f, -0.01175733f, -0.14898598f, 
    -0.06857716f, 0.05208773f, 0.04426749f, -0.02193592f, -0.07822206f, -0.01158118f, -0.06660997f, -0.15468346f, 
    -0.08952126f, 0.03913594f, 0.12195875f, -0.03153129f, 0.01375665f, 0.07242906f, -0.07948935f, 0.01941200f, 
    0.03056675f, -0.24608117f, -0.15766801f, 0.08574113f, -0.01263743f, 0.01789615f, -0.07628910f, -0.01607817f, 
    0.10245480f, 0.02332888f, -0.04025536f, -0.10034400f, -0.11965927f, 0.04523197f, -0.36251789f, -0.17952363f, 
    -0.06917754f, 0.04342343f, 0.02255481f, -0.02136996f, 0.01694587f, 0.04244128f, -0.04394328f, -0.04578209f, 
    -0.13612226f, -0.01651510f, -0.15363944f, 0.12588055f, -0.24138655f, 0.08545454f, -0.02455725f, 0.00527081f, 
    0.06266429f, -0.32827643f, -0.05289697f, 0.08613633f, -0.09717133f, 0.06293354f, -0.29023877f, -0.07221672f, 
    0.01158143f, -0.09197520f, -0.08995774f, -0.11070686f, 0.03579911f, -0.02358622f, -0.22820003f, 0.04670791f, 
    0.07188025f, 0.11355538f, 0.01443465f, 0.00043097f, 0.09599583f, 0.07703117f, 0.02374907f, 0.01290647f, 
    0.01816641f, 0.14422511f, 0.15097940f, 0.10130432f, -0.07606871f, -0.11069989f, -0.06741293f, -0.14385089f, 
    0.01634587f, 0.07268789f, 0.05209286f, 0.04157744f, 0.02044293f, 0.08326819f, 0.06784680f, 0.03469146f, 
    0.08171512f, -0.06743655f, -0.01588636f, 0.15402263f, 0.00997865f, 0.05537599f, 0.10105363f, 0.05944967f, 
    -0.01693124f, 0.01750843f, 0.04033886f, 0.13901365f, -0.07523991f, 0.27506468f, -0.05553155f, -0.10270995f, 
    -0.09542903f, 0.04585918f, 0.08051553f, -0.02191314f, 0.06442555f, -0.05216622f, 0.03903459f, -0.08213406f, 
    -0.10548898f, 0.10367525f, -0.24290648f, 0.18639944f, -0.09804555f, -0.05634041f, -0.08022331f, -0.05619707f, 
    -0.05710838f, -0.10371896f, 0.05376265f, -0.02584667f, 0.22409908f, 0.07962994f, 0.16468063f, 0.13433172f, 
    -0.04774343f, -0.05914543f, 0.05782818f, -0.01504567f, -0.05156549f, -0.08566611f, -0.00188377f, 0.08144160f, 
    0.15257390f, -0.04952307f, -0.03101702f, 0.04605622f, -0.22993574f, -0.09365894f, -0.07856133f, 0.02251625f, 
    0.05838175f, 0.02066262f, -0.03939032f, 0.04855514f, 0.15591639f, -0.02012906f, 0.15172787f, 0.21178018f, 
    -0.09494539f, -0.00294725f, -0.09238310f, 0.00817316f, 0.00706474f, -0.04659101f, -0.06064877f, 0.02553822f, 
    -0.32318816f, -0.15082799f, 0.10876315f, -0.29435536f, -0.04772587f, -0.06291572f, 0.08664944f, -0.00158413f, 
    0.03793528f, 0.02716351f, 0.10838410f, -0.07584291f, 0.21678428f, 0.31158605f, -0.16775399f, 0.01415588f, 
    -0.10470184f, 0.02870364f, -0.09622091f, -0.03307982f, -0.10716327f, 0.04429590f, 0.02395904f, -0.01974024f, 
    0.20474592f, -0.26324576f, -0.10419735f, -0.04246024f, 0.02647366f, -0.15809456f, 0.00196708f, -0.00599213f, 
    0.05189387f, 0.02280511f, -0.10866674f, -0.04382692f, 0.16309157f, 0.04205308f, -0.17624727f, -0.26024020f, 
    -0.12214237f, -0.03706780f, -0.10188185f, -0.05141844f, -0.07605021f, -0.03344340f, -0.06442182f, -0.01813736f, 
    0.21288271f, -0.09219945f, 0.18234541f, -0.15488632f, 0.02441821f, -0.03717278f, 0.08072927f, 0.01616130f, 
    0.21089584f, -0.01365450f, -0.02837752f, -0.00667420f, -0.41508508f, 0.06508154f, -0.05269694f, -0.03599150f, 
    -0.08266312f, 0.02547682f, 0.09816089f, -0.08754605f, 0.09085765f, 0.01619196f, 0.03414135f, 0.00983579f, 
    -0.09903646f, -0.08129402f, -0.16316029f, -0.44915721f, 0.11426716f, -0.01897393f, 0.09903266f, -0.01981438f, 
    0.03899991f, -0.03675672f, -0.01030315f, -0.01750824f, 0.08222969f, 0.04364979f, -0.32240599f, 0.09635997f, 
    0.07483635f, 0.05397907f, 0.02312621f, -0.01311101f, -0.15280341f, 0.10123383f, -0.00394855f, -0.04204684f, 
    0.12213040f, 0.10416942f, -0.01964015f, -0.17887911f, 0.14183974f, -0.00544018f, -0.00210809f, 0.06298904f, 
    0.06840666f, -0.04462356f, 0.00261006f, -0.02706757f, 0.20778361f, 0.08115181f, 0.01180629f, 0.19117653f, 
    -0.01195240f, -0.01802579f, 0.01275340f, -0.03695234f, 0.05095107f, 0.06489059f, -0.04514250f, -0.00482731f, 
    -0.37312737f, -0.19196934f, -0.05713759f, -0.11260388f, 0.08530717f, -0.03844314f, -0.00609416f, 0.02700594f, 
    0.02026141f, 0.08523323f, 0.09233793f, -0.08699413f, -0.04787652f, -0.06698222f, -0.07595539f, 0.21051024f, 
    0.14882585f, 0.01465053f, -0.18497545f, 0.15223159f, -0.08470736f, 0.05960770f, -0.07842077f, -0.05152761f, 
    -0.03931519f, -0.03878274f, 0.16194795f, -0.32208487f, 0.04490288f, -0.10593707f, -0.10590065f, 0.01300670f, 
    0.04601589f, -0.21335654f, -0.04105012f, -0.04860701f, -0.32985416f, 0.09673781f, -0.05307068f, -0.00811365f, 
    0.06910013f, -0.00863450f, 0.11647280f, 0.03273937f, -0.09487697f, 0.10639162f, 0.00909796f, -0.04865158f, 
    0.03241450f, -0.04698370f, 0.03301756f, -0.05292441f, -0.06018584f, 0.01468818f, -0.12379636f, -0.05884340f, 
    0.15782629f, -0.05168019f, 0.00524275f, 0.06940094f, -0.17469589f, 0.02637490f, 0.06983664f, 0.07651196f, 
    -0.07379074f, 0.10765840f, -0.02358915f, 0.00433024f, 0.12907620f, 0.02165752f, 0.02275994f, -0.01943910f, 
    -0.17343721f, 0.09337308f, -0.15382041f, -0.05908893f, -0.00941559f, 0.12328533f, -0.03617320f, -0.14927037f, 
    -0.04540345f, -0.09559215f, 0.10411731f, 0.00624324f, -0.19382702f, -0.14531480f, -0.10547137f, -0.13683815f, 
    0.10894129f, -0.01214152f, -0.00744615f, -0.07371091f, -0.00404045f, -0.00956441f, 0.01647826f, 0.05601364f, 
    0.36574891f, 0.02208992f, -0.19561300f, 0.01679713f, 0.00207827f, -0.06951123f, -0.01914770f, -0.01828002f, 
    0.04921417f, -0.04300344f, -0.08733195f, 0.08017192f, -0.11497450f, -0.03610516f, -0.21159272f, -0.28889620f, 
    -0.01481724f, -0.07989550f, 0.05692231f, 0.12193372f, 0.00546817f, -0.06663882f, -0.09512222f, -0.06730282f, 
    0.12271439f, -0.02001917f, 0.14616001f, 0.06130424f, -0.04132314f, 0.01562776f, 0.02829929f, 0.03433309f, 
    -0.10101058f, -0.08737137f, 0.08175478f, -0.13388951f, 0.18529496f, 0.01764294f, 0.03879061f, 0.11746587f, 
    0.14372782f, -0.11192852f, 0.02293080f, 0.05261092f, -0.00411115f, 0.01340458f, 0.08460802f, 0.11237790f, 
    -0.02965398f, -0.18103793f, 0.06993761f, -0.14918904f, -0.01042126f, 0.00424988f, -0.03544751f, 0.00195980f, 
    -0.14720707f, 0.03045256f, 0.02139846f, -0.05485649f, 0.19528739f, -0.09226807f, 0.07316029f, -0.01630975f, 
    -0.00026072f, -0.09335735f, 0.14827019f, -0.00897499f, -0.00763775f, 0.07017449f, -0.08556778f, 0.10821081f, 
    0.14795318f, -0.11350929f, 0.00025392f, -0.09202517f, 0.03397889f, 0.02444732f, -0.00890405f, 0.14109898f, 
    -0.10124788f, 0.13116542f, 0.07524068f, 0.01333713f, -0.07891639f, 0.05131657f, -0.04891438f, 0.03669414f, 
    0.07747804f, 0.04110757f, -0.05271667f, 0.08189289f, -0.00181923f, -0.03952315f, 0.05030014f, -0.02341679f, 
    -0.75737804f, 0.05203504f, -0.04412226f, 0.01045963f, 0.03627089f, 0.03237564f, -0.00041935f, 0.03078323f, 
    -0.00837043f, 0.00349592f, -0.08843258f, 0.02187026f, 0.25048301f, -0.00505161f, 0.10253140f, 0.07699011f, 
    -0.04759622f, -0.05228353f, -0.11900207f, 0.03339991f, 0.03341175f, 0.03833650f, -0.12823169f, -0.01777764f, 
    -0.22407027f, 0.00322475f, -0.13734011f, 0.27236721f, -0.00840443f, -0.05689814f, -0.03021969f, 0.06023097f, 
    0.06652791f, -0.22707573f, 0.09162800f, 0.00436596f, 0.29156113f, -0.03942961f, 0.17853422f, -0.10945612f, 
    0.04696082f, 0.10933805f, -0.04283734f, -0.00316859f, -0.05649981f, -0.02076918f, -0.20902754f, 0.04794788f, 
    -0.00830192f, 0.06853790f, -0.05283602f, -0.44278142f, -0.02968539f, 0.01191070f, 0.08273783f, -0.02192909f, 
    0.00799349f, -0.08610259f, 0.00442230f, 0.04038456f, 0.23341064f, -0.13269173f, 0.16616754f, 0.20307815f, 
    -0.17966002f, -0.04700085f, -0.09865706f, -0.03515474f, -0.06425676f, -0.01442853f, 0.02756429f, 0.03907692f, 
    0.00162835f, 0.04284179f, -0.12748046f, -0.04601474f, 0.00251432f, -0.15917580f, 0.02951512f, 0.04236929f, 
    0.00892186f, 0.00848004f, 0.03148802f, 0.04738447f, 0.18122299f, -0.17773204f, -0.08816350f, -0.00144840f, 
    0.01876277f, 0.10200933f, 0.04774747f, 0.15861090f, -0.04757420f, 0.15976095f, 0.03589362f, 0.05245908f, 
    0.11773753f, -0.10657224f, 0.07040308f, -0.13975330f, 0.04122500f, 0.00414783f, 0.01001118f, 0.01508679f, 
    -0.10674511f, 0.04756820f, -0.01024967f, 0.01544526f, -0.16055804f, 0.07251976f, -0.25201142f, -0.18615478f, 
    0.05445290f, 0.01091370f, 0.01518462f, 0.04425998f, 0.06047838f, 0.04732316f, 0.06070616f, -0.00824237f, 
    0.20555681f, 0.02124323f, -0.01477142f, -0.01964762f, 0.01173776f, -0.09775888f, 0.00894361f, 0.11395925f, 
    -0.04582734f, -0.12707947f, -0.02783260f, 0.13411537f, 0.15043269f, 0.04260465f, -0.13706873f, -0.15545502f, 
    0.03961422f, -0.04770926f, -0.04555184f, 0.12148291f, 0.11236224f, 0.00116999f, 0.02265178f, -0.09973562f, 
    0.15920673f, -0.07512805f, -0.05754123f, -0.05291391f, 0.10594110f, 0.03728856f, -0.02268054f, 0.07459683f, 
    -0.06178615f, -0.02379718f, 0.03108163f, 0.09848763f, 0.21110010f, 0.01713808f, -0.01144295f, 0.01622083f, 
    0.04846467f, 0.14367159f, -0.07969126f, -0.08616363f, 0.02682370f, -0.06820989f, 0.03388464f, -0.05888731f, 
    -0.24812737f, 0.02085825f, -0.03886100f, 0.00445219f, -0.13174051f, -0.13462807f, 0.05620852f, 0.01808799f, 
    0.01347027f, 0.03967247f, -0.11706717f, -0.07494303f, -0.18077938f, -0.04447959f, 0.01047415f, 0.09677742f, 
    0.06115419f, -0.01612392f, -0.07245956f, -0.00970930f, 0.01967671f, 0.09671467f, 0.11117964f, -0.09871770f, 
    0.30089530f, -0.03895574f, 0.18352906f, 0.18333648f, -0.13498189f, -0.03156096f, 0.02109667f, -0.00052202f, 
    -0.05756687f, -0.01130620f, 0.11509309f, -0.00164653f, -0.45002577f, -0.04258598f, 0.13253109f, -0.08991338f, 
    0.08189779f, -0.04024964f, 0.03980422f, 0.11228480f, 0.08324333f, 0.06101835f, 0.05312147f, -0.01589247f, 
    0.10796815f, 0.05358768f, 0.13121758f, 0.25856251f, -0.08696268f, -0.04694770f, 0.12956606f, 0.03385878f, 
    0.02978971f, 0.03878544f, 0.03316090f, 0.03796092f, -0.04069841f, 0.13186051f, 0.08048390f, 0.18995880f, 
    0.07681954f, 0.03199513f, 0.10375232f, 0.06994394f, 0.10038044f, 0.00000349f, -0.02163670f, 0.03917425f, 
    -0.42045039f, -0.02074064f, -0.15112229f, 0.07728819f, 0.02675459f, -0.12987515f, -0.04664008f, -0.02068370f, 
    -0.02685764f, -0.02520299f, 0.00157235f, -0.01979889f, 0.25303003f, 0.02118455f, -0.01856241f, -0.02389507f, 
    -0.06490747f, -0.02108290f, 0.08864122f, 0.02040936f, -0.06301104f, -0.07112314f, 0.12601222f, -0.10900415f, 
    0.17995240f, -0.00897946f, 0.00798344f, -0.18311265f, 0.02595466f, -0.02653631f, 0.06793269f, 0.07334671f, 
    0.01547112f, -0.06734533f, 0.06066248f, 0.08129080f, 0.12655412f, -0.11127942f, 0.02175733f, -0.25126508f, 
    0.00621927f, -0.07873446f, -0.05853776f, 0.11199017f, -0.09643885f, -0.08485886f, 0.09768705f, -0.10247679f, 
    0.16782464f, -0.15457900f, 0.02873344f, -0.05702068f, -0.01876611f, 0.11379126f, -0.04337646f, 0.00709434f, 
    0.05505957f, -0.07403029f, -0.24133885f, 0.05411970f, -0.00962791f, -0.12302151f, -0.09008060f, -0.03876928f, 
    0.03025621f, 0.00056403f, -0.07350411f, -0.07692952f, -0.00287729f, -0.10480271f, 0.04070438f, -0.12180343f, 
    0.23448837f, -0.16088486f, -0.19766231f, 0.04559970f, -0.11707123f, 0.05308383f, 0.00829460f, -0.01206782f, 
    0.02620431f, 0.02009082f, 0.01682716f, 0.02811935f, 0.06577453f, -0.04561113f, -0.06975724f, 0.01183516f, 
    -0.03184981f, 0.09840170f, 0.10513069f, -0.14214441f, -0.03867109f, 0.05897794f, -0.02483170f, 0.00436783f, 
    0.19068269f, 0.07841418f, -0.14608842f, -0.19887637f, -0.13420707f, 0.01857977f, -0.05181518f, -0.01978074f, 
    0.07480552f, 0.05263463f, -0.03758719f, -0.10545824f, 0.01947086f, -0.02841046f, -0.22465672f, -0.00387241f, 
    -0.09728497f, 0.03639153f, -0.02188948f, -0.01312403f, -0.03370467f, 0.04067234f, 0.08048058f, -0.00555465f, 
    0.01631823f, -0.04298086f, 0.05655438f, -0.01920326f, -0.03066913f, -0.00444321f, -0.01026712f, 0.04456108f, 
    -0.02435105f, -0.12786798f, 0.00042765f, -0.04330308f, -0.44304112f, -0.01377560f, -0.08051810f, -0.29979670f, 
    -0.00860830f, -0.07118184f, 0.03238363f, 0.08018609f, -0.00615917f, -0.01602642f, -0.05665850f, -0.03376574f, 
    0.08746793f, 0.00096578f, 0.03826860f, -0.05263164f, 0.03675415f, -0.03893834f, -0.02408480f, 0.05424983f, 
    -0.07252467f, -0.09475739f, -0.06750718f, -0.02027341f, 0.22923921f, 0.04555561f, -0.05936289f, -0.03307778f, 
    0.01178866f, 0.04716462f, 0.00437462f, -0.02711000f, 0.03426975f, 0.06094597f, 0.05343578f, -0.09312630f, 
    0.23795018f, -0.04792032f, 0.03103999f, -0.04957308f, -0.06328627f, -0.11482987f, -0.01031396f, 0.05885307f, 
    0.04980244f, 0.08272852f, -0.05636884f, -0.07444128f, 0.06912602f, 0.00839428f, -0.04623878f, 0.01824259f, 
    0.05717311f, 0.04303215f, 0.04454613f, 0.02988756f, -0.08856908f, 0.00891179f, 0.04097200f, -0.10791690f, 
    -0.24686497f, -0.01355037f, 0.07153863f, -0.12494252f, 0.12752581f, 0.04428303f, 0.05106417f, -0.12843452f, 
    0.05519875f, -0.02627976f, -0.02816462f, 0.07955834f, -0.00193337f, -0.01045445f, -0.06421343f, 0.05557501f, 
    0.02368040f, 0.03065497f, 0.02882970f, 0.05226474f, -0.04959637f, -0.01270036f, -0.00824606f, -0.08311339f, 
    -0.18780422f, 0.13906753f, -0.00320382f, -0.17369099f, 0.05435012f, 0.08587375f, -0.01292839f, -0.01640843f, 
    0.02843452f, -0.01106203f, 0.00489191f, 0.03269642f, 0.35432342f, -0.10539491f, 0.06228949f, 0.05575449f, 
    -0.16606610f, 0.02855651f, -0.02013195f, -0.02629498f, -0.05020115f, -0.00180659f, -0.13090882f, 0.02007685f, 
    0.15127642f, 0.06369223f, -0.00506536f, 0.19982953f, -0.10519813f, -0.12202555f, 0.03943164f, 0.06702149f, 
    0.03812904f, -0.04191900f, 0.02810897f, -0.02383239f, -0.05309912f, -0.10678528f, 0.14002798f, -0.13454245f, 
    -0.02341792f, -0.07204324f, 0.05658562f, -0.03828711f, 0.05791681f, -0.04293711f, 0.07066802f, -0.02598554f, 
    -0.29132572f, -0.22177638f, 0.09884885f, -0.07387269f, 0.03523592f, 0.04189976f, -0.04663783f, -0.15113062f, 
    -0.01449177f, -0.10399146f, 0.08232035f, 0.02680296f, 0.16116457f, 0.05523282f, -0.13651207f, -0.06593882f, 
    0.05515181f, -0.05132824f, -0.01164690f, -0.02890170f, -0.13953635f, 0.04953170f, -0.10855460f, -0.07872219f, 
    -0.13057071f, -0.05419951f, -0.06262122f, -0.35169274f, 0.01753813f, -0.02291955f, 0.03256923f, -0.12225241f, 
    -0.03282164f, 0.02469349f, -0.02046139f, -0.04414998f, -0.04575320f, -0.37904805f, 0.04132552f, -0.04940777f, 
    -0.12306996f, 0.01853445f, -0.12519467f, -0.05394790f, 0.11393604f, -0.05725009f, -0.09396776f, 0.06417313f, 
    0.09942154f, 0.07959573f, -0.09029929f, 0.10660447f, -0.00648902f, 0.04036264f, 0.08133843f, 0.07725120f, 
    -0.03845984f, -0.03577833f, -0.06125676f, 0.05635518f, 0.03203626f, 0.05641190f, -0.10685451f, 0.03172170f, 
    0.13577802f, 0.02970731f, -0.00415544f, -0.05892779f, 0.01845818f, -0.02897822f, -0.12246196f, -0.03836798f, 
    0.10387424f, 0.01608424f, -0.20149082f, 0.06817536f, 0.07304475f, 0.01827823f, -0.01350771f, -0.01376505f, 
    -0.03858757f, 0.03218283f, 0.03071108f, -0.04403684f, 0.09921180f, -0.32209450f, -0.19363904f, -0.25830352f, 
    0.10067284f, -0.07782235f, 0.01158743f, -0.03590490f, 0.03168012f, 0.00927826f, -0.04723304f, 0.10551787f, 
    0.03303222f, -0.12074143f, -0.08874315f, 0.06643628f, -0.01877772f, 0.01021022f, 0.07950752f, 0.00826735f, 
    0.08825354f, 0.12498770f, -0.07781443f, -0.01840837f, -0.15191913f, 0.14589562f, -0.13226476f, 0.00350131f, 
    0.01006180f, 0.05704735f, -0.13588642f, 0.02304635f, -0.17656529f, -0.05845878f, -0.04935446f, 0.00973525f, 
    0.11644021f, 0.11612140f, 0.09097081f, 0.06292738f, -0.07007307f, -0.06401309f, -0.08143147f, -0.09540728f, 
    -0.03524148f, 0.02074270f, 0.00173794f, 0.10465056f, -0.18389270f, -0.04013271f, -0.08519787f, 0.02991813f, 
    -0.01314355f, 0.01595465f, -0.01820395f, 0.02881452f, 0.00723203f, 0.00298316f, -0.10254163f, -0.05485927f, 
    0.07694129f, -0.06052572f, -0.23753843f, 0.07996663f, 0.00827022f, -0.03592889f, -0.01771984f, 0.00323671f, 
    0.01589813f, 0.04336709f, -0.13762617f, -0.09460608f, 0.17158465f, 0.09190769f, 0.18618821f, 0.20151535f, 
    -0.02480162f, -0.19068459f, -0.11765298f, 0.10374114f, 0.02530988f, -0.05220066f, 0.01448476f, 0.01095519f, 
    0.21455754f, -0.25318047f, 0.18340194f, 0.01657747f, -0.09273250f, 0.06126905f, -0.05614917f, 0.07625754f, 
    0.01501931f, 0.01749325f, 0.06524340f, -0.01651769f, -0.07129094f, -0.00510314f, -0.27822140f, -0.12771118f, 
    0.07072468f, -0.00804409f, -0.12256958f, -0.05066930f, 0.00345556f, 0.05095020f, 0.04243498f, -0.02462450f, 
    0.11113573f, -0.09069234f, -0.08435051f, -0.00120917f, 0.08497277f, -0.03319637f, -0.01458510f, 0.02554156f, 
    -0.04314782f, 0.17895995f, -0.02706652f, 0.00329967f, 0.06222086f, -0.05914241f, 0.02205959f, -0.00225638f, 
    -0.00898553f, 0.02766226f, -0.10882099f, -0.05312148f, 0.01762879f, 0.06653993f, -0.04749177f, 0.05065028f, 
    0.04288748f, 0.17618464f, 0.07183828f, 0.14029750f, -0.04461351f, -0.07350593f, -0.00792199f, 0.03156845f, 
    -0.06840524f, -0.04104709f, -0.00895989f, -0.07245997f, -0.02321794f, -0.03949794f, -0.08034798f, -0.11988045f, 
    0.04032988f, -0.04282900f, 0.08120312f, 0.00888717f, 0.02347571f, 0.06687627f, 0.10044338f, -0.09589697f, 
    -0.25120902f, 0.00632530f, 0.12387431f, -0.12842984f, -0.01462076f, -0.04090727f, 0.07550985f, 0.01166916f, 
    0.00240086f, -0.07718705f, 0.05236876f, -0.02875265f, 0.26703823f, 0.08173417f, 0.06656139f, 0.10657654f, 
    -0.19457908f, -0.04910781f, 0.04248066f, 0.00921842f, -0.07901244f, 0.03185400f, -0.07394383f, -0.09413460f, 
    0.36528143f, 0.08771187f, -0.03834299f, -0.19405922f, 0.03797109f, -0.02870782f, -0.11134847f, -0.01104509f, 
    -0.02576996f, 0.04038353f, 0.02993378f, -0.02012502f, -0.00124877f, 0.03812888f, -0.08672289f, -0.03516538f, 
    0.03989213f, -0.05653163f, 0.03506341f, 0.02258504f, -0.03021936f, -0.00080326f, 0.03240633f, -0.07653555f, 
    0.08065532f, -0.06431479f, -0.01611258f, -0.04484435f, -0.07877056f, 0.13164946f, -0.01615930f, 0.07470107f, 
    -0.04369160f, 0.06689935f, -0.00872026f, -0.01386020f, 0.10128111f, 0.03546114f, 0.04246276f, -0.10538405f, 
    0.09301138f, 0.12409687f, 0.05080120f, -0.02159931f, 0.03989460f, 0.01887718f, 0.08415968f, -0.07735422f, 
    -0.19991790f, -0.18167600f, -0.06563684f, -0.00029018f, 0.05754796f, -0.07858414f, -0.03650894f, -0.02187170f, 
    -0.06263904f, 0.05462503f, -0.00375346f, 0.03297408f, -0.04939399f, 0.05312337f, 0.13835829f, -0.09581220f, 
    0.17394552f, -0.05505529f, 0.00508693f, -0.00310022f, -0.02692151f, 0.04190364f, -0.03404325f, 0.03616607f, 
    -0.22499564f, 0.05208657f, 0.04328197f, -0.07006098f, -0.02966326f, 0.10094813f, 0.07177354f, -0.01014805f, 
    -0.03040938f, -0.04736672f, 0.01858508f, -0.07190660f, -0.35517871f, -0.12560602f, 0.12645224f, -0.14998336f, 
    -0.04830332f, -0.00967734f, 0.00545367f, -0.01887443f, 0.00924551f, 0.02656279f, 0.00843844f, -0.08885226f, 
    0.09141672f, 0.07404877f, 0.04507475f, -0.02253577f, -0.00524868f, -0.05296001f, 0.07202312f, 0.02645635f, 
    -0.09244560f, -0.13381207f, 0.02526357f, -0.01993488f, 0.24109471f, -0.03639557f, -0.19041702f, -0.16513731f, 
    0.04138739f, -0.06820075f, -0.06923285f, -0.08318347f, -0.10536642f, -0.01397425f, -0.10227259f, -0.02800592f, 
    -0.06950308f, -0.12147073f, 0.08006824f, 0.12324659f, -0.10723732f, -0.17863099f, -0.08791212f, 0.02723601f, 
    -0.02985820f, 0.07387860f, -0.05852307f, 0.00337848f, 0.09476726f, 0.01131967f, 0.11767320f, 0.20217746f, 
    -0.07420832f, -0.03780329f, 0.00380203f, 0.03313042f, -0.05113943f, -0.06484479f, -0.01475517f, -0.03328218f, 
    0.24975249f, 0.04267109f, -0.01304541f, -0.07162663f, -0.08340217f, -0.00170679f, -0.06258445f, 0.02259529f, 
    0.04307121f, -0.13684554f, 0.01936144f, 0.03335100f, 0.40304655f, -0.05129040f, -0.18280266f, 0.05165602f, 
    -0.03190960f, -0.05018868f, 0.02451410f, 0.03604234f, -0.06704742f, 0.04998718f, 0.01616627f, -0.05668257f, 
    -0.10130265f, 0.06722205f, -0.11408309f, -0.10674115f, -0.03536527f, -0.03237708f, 0.07695370f, 0.02347736f, 
    0.01975390f, -0.02537944f, -0.06065878f, -0.03056049f, 0.50329471f, -0.06718259f, -0.11242047f, -0.04251526f, 
    -0.20174693f, 0.06040435f, 0.00714004f, -0.04285638f, -0.02290414f, -0.02928071f, 0.03584162f, -0.07157649f, 
    0.07881409f, -0.01330705f, -0.02779676f, 0.08537736f, 0.11923575f, 0.06586090f, -0.02219781f, -0.03801658f, 
    -0.03758995f, -0.02391343f, -0.05673137f, 0.01891567f, 0.18863119f, 0.15875450f, 0.12740403f, 0.05206243f, 
    0.00186627f, 0.00779472f, -0.00843896f, 0.01302722f, -0.09553862f, 0.12191434f, -0.04909873f, -0.03899990f, 
    -0.08745180f, 0.17091461f, 0.01114453f, -0.04310613f, 0.00507434f, -0.03123465f, 0.07548379f, 0.04747598f, 
    -0.01355814f, 0.00421256f, 0.03181595f, 0.04795626f, -0.34765923f, -0.00955005f, -0.12317737f, -0.10312489f, 
    -0.18354644f, 0.03177186f, -0.00969842f, 0.00933592f, 0.06489313f, -0.00456632f, 0.03948604f, 0.00287197f, 
    -0.08361974f, 0.04543306f, -0.11352514f, 0.05550856f, -0.19799787f, 0.05242081f, 0.06484823f, 0.08160516f, 
    -0.06761145f, -0.03866047f, 0.02226318f, -0.04610538f, -0.15697558f, -0.02811846f, 0.05688298f, -0.25835666f, 
    0.05224673f, 0.04960462f, 0.03973528f, -0.04999843f, 0.00033155f, 0.14559343f, -0.04688011f, -0.02555643f, 
    0.03440852f, -0.18871808f, 0.13983344f, -0.04289920f, -0.12082680f, 0.08049603f, 0.00723557f, 0.04964273f, 
    0.00451267f, 0.00941506f, 0.02337113f, -0.04109460f, -0.18549493f, 0.15276812f, 0.13004600f, 0.05845415f, 
    0.01983070f, -0.11135591f, 0.04870965f, 0.01802644f, -0.00430178f, 0.09416828f, -0.03458827f, 0.01856539f, 
    0.17430305f, 0.02973128f, 0.04653407f, 0.18918519f, -0.10917000f, -0.03763645f, -0.03285547f, -0.01901625f, 
    0.14655688f, 0.01649237f, 0.11086246f, -0.05924935f, -0.05685255f, -0.07618866f, -0.01721156f, 0.01756896f, 
    -0.04012762f, -0.01375760f, 0.02990391f, -0.05471487f, -0.08496439f, 0.03872132f, -0.08868901f, -0.00353810f, 
    -0.10770202f, 0.14165908f, 0.16475151f, 0.04274433f, -0.04408791f, -0.05789389f, 0.12082475f, 0.06011712f, 
    -0.12489176f, -0.04241018f, 0.11500521f, 0.00152358f, 0.60465318f, 0.09021966f, 0.00374142f, 0.07900716f, 
    0.01769359f, -0.04268406f, -0.03592084f, 0.07960907f, 0.00469176f, 0.02226487f, 0.02781909f, -0.10540200f, 
    -0.10446852f, 0.17825922f, 0.09582714f, -0.11053590f, -0.06256409f, -0.05301541f, -0.02794956f, -0.03633762f, 
    -0.04796018f, 0.05185382f, 0.00960715f, 0.02709305f, -0.05524196f, 0.18766828f, 0.20674624f, -0.06606732f, 
    -0.00893622f, 0.04687684f, -0.00802014f, 0.02616660f, 0.02366954f, 0.07753338f, -0.03045171f, 0.02176872f, 
    0.18070506f, 0.10316991f, -0.14016262f, 0.02182023f, -0.06943884f, 0.03698409f, 0.00986657f, 0.06179379f, 
    0.07615051f, -0.02200198f, 0.06010458f, -0.06767660f, 0.20416927f, 0.04763582f, 0.10263085f, 0.09198251f, 
    -0.01721298f, -0.00536226f, -0.03095055f, 0.03091853f, -0.08122493f, 0.03923203f, -0.06280051f, 0.06696405f, 
    0.10972854f, -0.08675223f, -0.15256172f, -0.08344157f, 0.04679555f, -0.05739425f, 0.03840674f, -0.03648301f, 
    -0.00000620f, -0.04670628f, 0.03306073f, -0.06860519f, -0.31386632f, 0.21856873f, 0.11223770f, 0.04519040f, 
    -0.01307082f, 0.06315022f, 0.09926382f, -0.00099542f, -0.03082464f, 0.05071860f, -0.01615332f, 0.06853705f, 
    0.08187400f, 0.08041238f, 0.13737373f, -0.11033367f, 0.01779882f, -0.02189406f, -0.02139648f, 0.06884227f, 
    -0.05999296f, -0.08702412f, -0.00319449f, 0.05718363f, -0.24366164f, -0.21758872f, -0.23261552f, 0.05676560f, 
    -0.11118492f, -0.04627317f, 0.03868329f, -0.03728623f, 0.06427564f, 0.08428377f, -0.06073156f, -0.02653103f, 
    -0.21389629f, -0.18624566f, -0.17089650f, 0.11209900f, -0.13044871f, 0.11163240f, -0.02815451f, -0.08320811f, 
    0.01959503f, -0.07466008f, -0.01972656f, -0.02967457f, -0.22890417f, -0.24516337f, -0.02140904f, 0.14528725f, 
    -0.03288909f, 0.04870808f, 0.00592755f, -0.02729606f, -0.00279566f, 0.04882968f, -0.06076386f, 0.03114550f, 
    0.24953759f, 0.14261129f, 0.00322520f, -0.05317559f, -0.06385207f, -0.03783135f, -0.01006833f, -0.01364392f, 
    0.04618247f, -0.06065533f, -0.02013798f, 0.04719048f, 0.15482424f, -0.06264266f, 0.04889251f, 0.11717559f, 
    0.01967678f, 0.07338593f, -0.02332698f, 0.04716327f, 0.09305373f, 0.00160844f, 0.02553982f, -0.03425610f, 
    0.10993046f, -0.04485578f, -0.09441126f, 0.11238149f, -0.07842192f, 0.01774652f, -0.00788056f, -0.04942141f, 
    -0.04825443f, 0.00662148f, -0.04630210f, -0.00600596f, -0.12255068f, 0.03396295f, -0.03489702f, 0.05421009f, 
    -0.07846416f, -0.05585597f, -0.02331293f, 0.06712321f, -0.09200465f, 0.02865366f, 0.01663609f, -0.12678331f, 
    0.00856299f, -0.03684984f, -0.01454591f, 0.09619529f, -0.03579377f, -0.04554317f, 0.00546327f, 0.04102902f, 
    -0.02233589f, 0.02685414f, 0.10964884f, -0.01339135f, -0.15296976f, 0.10340433f, 0.04774682f, -0.13860177f, 
    -0.03232145f, 0.03006523f, 0.00120202f, 0.05890366f, 0.05285896f, -0.02323158f, 0.00209078f, 0.06796861f, 
    0.24972139f, 0.12527063f, 0.00005435f, -0.01793004f, 0.04570719f, 0.04637967f, -0.07141311f, -0.02799699f, 
    0.06528843f, 0.06706601f, 0.01236032f, -0.03714487f, -0.09244133f, -0.00708617f, -0.09164602f, 0.12167364f, 
    -0.04333108f, -0.10679218f, 0.03674810f, 0.10596346f, 0.07018822f, -0.02039704f, 0.01785897f, -0.02027288f, 
    -0.42814615f, 0.11229830f, -0.14225508f, -0.16337951f, 0.01811594f, -0.05734264f, -0.06804250f, 0.08561325f, 
    -0.04741820f, 0.02355419f, -0.07417533f, -0.02080448f, -0.35338077f, -0.24810906f, 0.00095828f, 0.10439481f, 
    -0.08673717f, 0.04046386f, 0.11349107f, -0.01728305f, -0.02044771f, -0.06960770f, -0.06879693f, -0.00608062f, 
    -0.08971044f, 0.22995253f, 0.15282041f, 0.19858401f, 0.13365145f, 0.15476444f, -0.05255119f, -0.05691807f, 
    -0.09983982f, 0.03298391f, -0.00839736f, -0.21665917f, 0.05116856f, 0.03468613f, -0.01440225f, -0.13882044f, 
    -0.00509645f, 0.02485107f, 0.09995882f, -0.12235888f, 0.02320539f, -0.07512986f, 0.12141068f, -0.08912814f, 
    0.08625985f, 0.09140615f, -0.02674093f, 0.07617050f, -0.02918346f, -0.04922054f, 0.04214322f, 0.02624732f, 
    -0.04440762f, 0.11301465f, 0.01377476f, 0.04455667f, -0.04407087f, -0.15644221f, 0.04467480f, -0.14426559f, 
    0.04545897f, -0.03137188f, 0.02643966f, 0.01817656f, 0.08969891f, 0.01074414f, 0.10830579f, -0.03569067f, 
    -0.08555692f, -0.00975137f, -0.02333799f, -0.04691722f, -0.05444314f, -0.05191538f, 0.14457902f, 0.06065513f, 
    -0.08528655f, -0.01494941f, -0.00212344f, 0.03701600f, -0.15558535f, -0.42757326f, 0.04078338f, 0.27706453f, 
    0.02368697f, 0.00115470f, -0.04541364f, 0.05634941f, -0.02260266f, 0.00057397f, 0.02969529f, -0.02378842f, 
    -0.10718935f, 0.09784701f, 0.04557427f, 0.04843209f, -0.06146567f, -0.12122985f, 0.04812281f, 0.10335897f, 
    -0.06531091f, -0.00607769f, -0.03986678f, -0.09486578f, -0.09762958f, -0.01671372f, -0.13328072f, -0.11268419f, 
    -0.06741786f, -0.03835174f, 0.13834368f, 0.05323112f, -0.13832828f, -0.08538856f, -0.04943762f, -0.05741413f, 
    0.01009740f, -0.03642045f, -0.02359335f, 0.03994928f, -0.09716439f, -0.05408621f, 0.03231177f, 0.00693567f, 
    -0.06586671f, 0.04127660f, 0.02341705f, -0.02924881f, 0.11637732f, 0.12029756f, 0.07333929f, -0.00486154f, 
    -0.00024025f, -0.08101103f, -0.01663801f, -0.01053042f, -0.07450939f, 0.08541363f, 0.03593279f, 0.00006535f, 
    0.27270302f, -0.10812551f, -0.20558435f, 0.09305355f, -0.00548551f, 0.00318392f, -0.06819835f, 0.00047420f, 
    0.11632019f, 0.10749169f, 0.05207553f, 0.07499282f, 0.08861912f, 0.16612253f, -0.20511793f, 0.00855632f, 
    0.02826627f, -0.03280447f, 0.08896381f, 0.02661022f, 0.03008856f, 0.01324530f, 0.08541439f, -0.03538687f, 
    -0.17558560f, 0.03610746f, -0.05705497f, -0.09810222f, -0.01322869f, 0.01091759f, -0.03374027f, 0.02795328f, 
    -0.02826929f, -0.11656977f, 0.03246658f, 0.07479060f, 0.13466986f, -0.22824164f, -0.02309058f, 0.01037321f, 
    -0.12232424f, 0.01430538f, 0.00002178f, 0.15508229f, -0.00351547f, -0.05995241f, 0.04716207f, -0.06545485f, 
    -0.11693328f, -0.19618295f, 0.00224248f, 0.00194241f, -0.01197606f, 0.02422586f, -0.01181112f, -0.02434083f, 
    0.09432216f, -0.02331349f, -0.08759781f, -0.06775355f, -0.20491938f, 0.07087443f, -0.04678915f, -0.15484670f, 
    -0.07212485f, -0.12729524f, -0.01698226f, -0.02500206f, 0.04448435f, 0.08975307f, -0.01886501f, -0.06602626f, 
    -0.04380462f, 0.21926452f, -0.01585867f, -0.02702568f, 0.03424883f, -0.04616327f, -0.05343541f, 0.06113371f, 
    -0.03653954f, -0.06475131f, -0.04044970f, 0.00576224f, -0.04714507f, -0.20945652f, -0.13726841f, -0.09568790f, 
    -0.11391930f, 0.00170358f, -0.00210130f, -0.15273294f, -0.12985802f, 0.04756284f, -0.00858152f, -0.06508521f, 
    0.06566025f, -0.06660164f, 0.12522724f, 0.09958813f, -0.03334402f, -0.02741620f, 0.15797839f, 0.00989646f, 
    0.09189923f, 0.03598363f, 0.00342800f, 0.04719900f, 0.06874209f, -0.09253874f, 0.18932700f, -0.06885566f, 
    0.01584574f, 0.05246699f, 0.10188088f, -0.00811818f, 0.02497186f, 0.05364615f, 0.06318634f, 0.03391486f, 
    0.20652473f, 0.16145512f, 0.12197082f, 0.00735513f, -0.04756462f, -0.19003052f, -0.05520421f, -0.01788368f, 
    0.06557147f, -0.04348157f, -0.17130442f, 0.04291027f, -0.27806807f, -0.30718929f, -0.18911369f, -0.14319593f, 
    0.03580258f, -0.00156073f, -0.01785105f, -0.01016493f, 0.05340254f, -0.02919218f, -0.04358231f, 0.03384560f, 
    -0.13977855f, -0.12404585f, -0.24598674f, -0.02972239f, -0.00622647f, 0.02376312f, -0.01300671f, 0.12022199f, 
    0.01989493f, -0.00155227f, 0.03496929f, -0.01006432f, 0.12328698f, -0.18187754f, -0.11655711f, 0.09054986f, 
    -0.09229885f, 0.06023464f, 0.08348914f, 0.07627337f, 0.05915591f, 0.07181185f, -0.06949785f, -0.08573442f, 
    -0.06544355f, -0.09332148f, -0.04040508f, -0.03792694f, -0.13633840f, -0.06021771f, -0.11783294f, -0.02165888f, 
    -0.05816657f, -0.12421779f, 0.01891081f, 0.11360684f, -0.24912155f, 0.31974217f, 0.16871683f, 0.08037876f, 
    0.09415643f, -0.05606394f, 0.01952254f, 0.01714141f, -0.05591904f, 0.01295524f, -0.18588296f, -0.03113541f, 
    0.19327776f, 0.00605844f, 0.02605748f, -0.10966816f, -0.25914523f, -0.11135027f, 0.00648727f, -0.07260656f, 
    0.00990224f, -0.02210107f, -0.07369517f, -0.01623225f, -0.14499231f, 0.06850504f, -0.08946976f, -0.15227200f, 
    -0.12007047f, -0.07081339f, -0.01108849f, -0.03584298f, 0.02219255f, -0.10188752f, -0.11371117f, 0.03382425f, 
    0.08307933f, 0.16019236f, 0.01244736f, 0.09387706f, -0.05780675f, -0.00724422f, -0.12549981f, -0.10025893f, 
    -0.00175480f, 0.07952637f, 0.00853207f, 0.11890579f, -0.13486968f, 0.11811168f, 0.07064535f, 0.00886961f, 
    -0.05742287f, -0.21813545f, 0.11627976f, -0.02936856f, -0.05973485f, -0.02013489f, -0.21071710f, 0.06802469f, 
    0.15914445f, 0.15541527f, -0.12115362f, 0.05084143f, -0.05784865f, 0.02242605f, -0.03655858f, 0.05711968f, 
    0.03537256f, 0.06442104f, 0.05384051f, -0.08455269f, 0.27138853f, 0.04695628f, 0.15791076f, 0.03352598f, 
    -0.03468353f, 0.04415799f, -0.09202672f, -0.03586159f, -0.12122184f, 0.01204477f, 0.04525587f, -0.03156790f, 
    -0.35123616f, -0.42820919f, -0.10507757f, 0.17360725f, -0.00191901f, 0.02951202f, -0.06874757f, -0.07372794f, 
    -0.05643808f, -0.08115853f, 0.04939843f, 0.02270819f, -0.04835568f, 0.19753194f, -0.05952757f, -0.19206853f, 
    -0.00351706f, -0.03114980f, -0.00723330f, -0.03890238f, 0.01742815f, -0.09936234f, -0.02148130f, 0.01443239f, 
    -0.20781074f, -0.47852984f, -0.29321355f, 0.07125258f, -0.06628011f, 0.00184845f, -0.02035702f, 0.00012266f, 
    -0.03672302f, 0.03244985f, 0.04111798f, -0.00659622f, 0.20039368f, -0.10658083f, 0.18328208f, -0.10450611f, 
    -0.11984225f, 0.04241820f, -0.07003486f, -0.01027154f, -0.00984186f, 0.11604159f, -0.01815035f, 0.07911747f, 
    -0.09858568f, 0.02516893f, -0.02935641f, -0.05241521f, -0.04843383f, -0.07843883f, 0.01034371f, 0.05260259f, 
    -0.07778326f, -0.07267442f, 0.04509622f, 0.00077058f, 0.02855941f, -0.07712211f, -0.10678891f, 0.05900226f, 
    -0.01949969f, -0.02206730f, -0.05648817f, 0.06065673f, 0.00689142f, 0.05900783f, -0.07737298f, 0.05208212f, 
    -0.15684092f, 0.14932306f, -0.05146553f, 0.07202370f, -0.02981229f, -0.07703440f, 0.00318117f, -0.01065953f, 
    -0.06130284f, -0.00195687f, -0.05343441f, 0.08309789f, 0.08540872f, -0.07378151f, -0.06641465f, 0.11518577f, 
    -0.06673258f, -0.08891017f, -0.00940436f, 0.10493435f, -0.02477066f, 0.08475041f, -0.01141048f, 0.01889696f, 
    0.08407939f, -0.11896629f, 0.00955498f, 0.01715769f, 0.02420042f, -0.03133389f, -0.02238564f, -0.09393013f, 
    -0.05046282f, 0.05408929f, -0.00893872f, -0.02582432f, 0.25092027f, -0.00433498f, 0.08492820f, 0.30836421f, 
    0.06373473f, 0.04052573f, 0.02542008f, 0.08389487f, -0.05813478f, 0.08250010f, -0.16201323f, -0.02345153f, 
    -0.15230054f, -0.03026498f, -0.02688221f, 0.00748602f, 0.05403629f, 0.06824873f, -0.01341792f, 0.05227264f, 
    -0.03889685f, 0.04420487f, 0.01988365f, 0.14117604f, 0.39584547f, 0.14785126f, -0.25897118f, -0.20275000f, 
    -0.05571822f, 0.00493155f, -0.00577743f, -0.04955836f, -0.01843257f, -0.02625076f, 0.01147150f, 0.01447964f, 
    -0.27440417f, -0.04076312f, -0.09756372f, -0.15792835f, 0.07531517f, -0.08414550f, -0.06617565f, -0.00728980f, 
    -0.20781277f, -0.02668037f, 0.00135353f, 0.11330599f, 0.18609323f, -0.05645434f, -0.03056917f, -0.11316717f, 
    -0.04776411f, -0.03258684f, 0.09629972f, 0.00703896f, -0.04197609f, -0.04113712f, 0.10910917f, 0.03599545f, 
    -0.03422723f, 0.04571798f, -0.04044805f, 0.16613780f, -0.01365339f, 0.03626500f, 0.05116122f, 0.05872353f, 
    0.07170644f, -0.12875621f, -0.03166207f, -0.04134572f, -0.19847256f, -0.01151527f, 0.04011665f, -0.11107275f, 
    0.05714693f, -0.01674292f, -0.00266795f, -0.01535670f, 0.06792995f, -0.01309713f, -0.00204636f, 0.04239820f, 
    -0.20476820f, -0.07290626f, -0.12240883f, -0.11035697f, -0.12719531f, -0.03336689f, -0.04914904f, -0.13352326f, 
    -0.08000115f, -0.02102506f, -0.00895981f, -0.04176294f, -0.35452792f, 0.12979251f, -0.00819567f, 0.07621730f, 
    -0.08023597f, -0.13472755f, 0.00501864f, -0.01069286f, 0.01524257f, 0.02753689f, -0.05449552f, -0.08606191f, 
    -0.29960680f, -0.04357261f, 0.05140119f, -0.26158231f, 0.09341146f, -0.05901094f, -0.11068749f, 0.07737172f, 
    -0.04402823f, -0.09448692f, -0.01650092f, 0.02128287f, -0.02996502f, -0.01175643f, -0.08024646f, 0.02870630f, 
    -0.06433938f, 0.01250240f, -0.03179026f, 0.06252801f, 0.01241573f, 0.03728783f, -0.00772287f, 0.02984773f, 
    0.16849487f, -0.13189830f, -0.11952968f, 0.21738227f, -0.02041998f, -0.08244559f, 0.02152379f, -0.06420050f, 
    -0.01616537f, 0.03413448f, -0.00729720f, -0.05263600f, 0.03829465f, 0.01309169f, 0.05683238f, 0.04888515f, 
    -0.08549298f, 0.02000174f, 0.06911788f, 0.00676260f, 0.06430381f, -0.02724953f, -0.07349142f, -0.08779616f, 
    0.03768014f, -0.26943588f, -0.06443264f, 0.22408479f, -0.02630446f, 0.02568562f, 0.07407071f, 0.05445459f, 
    -0.05102004f, 0.09598837f, -0.07523558f, 0.01545029f, -0.23258004f, 0.30139431f, -0.04551757f, -0.29601699f, 
    0.03610020f, -0.09618333f, 0.13983786f, 0.09265060f, 0.10607997f, -0.08032360f, -0.11211246f, -0.03961827f, 
    -0.64092356f, 0.08411758f, 0.20979699f, 0.10378036f, -0.04029467f, 0.15774859f, -0.02771611f, 0.10014272f, 
    0.02409843f, -0.01727735f, 0.09621028f, 0.07421791f, -0.22047479f, -0.11193708f, 0.18708715f, -0.20288846f, 
    0.03759135f, 0.02678154f, -0.05592788f, -0.07586291f, 0.08663211f, -0.00805223f, -0.10155571f, -0.15128210f, 
    -0.08656720f, 0.08374283f, 0.02605211f, 0.14103296f, 0.10454419f, 0.01587833f, -0.02490973f, -0.14511569f, 
    0.03360883f, -0.11371246f, -0.06850938f, 0.03208648f, 0.33002615f, 0.06544253f, 0.05900852f, -0.07043012f, 
    0.03403301f, 0.00143179f, 0.03097951f, 0.08736626f, -0.06589191f, 0.05959664f, 0.01541355f, 0.10961345f, 
    0.01241105f, -0.01915007f, 0.01442702f, 0.15177411f, -0.09201886f, -0.09877668f, 0.03949320f, -0.06334665f, 
    0.03759102f, 0.13847348f, -0.03134175f, 0.12255110f, -0.09990241f, -0.04146747f, -0.18021230f, -0.38324830f, 
    -0.06683200f, 0.06448463f, 0.03853178f, -0.04412911f, 0.05952208f, -0.00505295f, -0.00239726f, 0.06515750f, 
    -0.14439344f, -0.07169187f, 0.10079731f, 0.11756759f, -0.07961177f, -0.06607053f, 0.06839626f, -0.10602894f, 
    -0.07022294f, -0.03710679f, -0.02037474f, 0.03799208f, -0.05731043f, -0.00201324f, 0.07500914f, 0.10413277f, 
    0.00086691f, -0.05791993f, -0.00259556f, 0.05316805f, -0.00427641f, 0.08789983f, -0.01549530f, 0.02105362f, 
    -0.32470366f, -0.15076929f, 0.28462803f, 0.08603262f, 0.02328476f, -0.07634185f, -0.00855609f, -0.17549393f, 
    -0.02021137f, 0.04338417f, -0.05306927f, 0.02295977f, 0.44630170f, -0.04388095f, -0.05811993f, -0.01721037f, 
    0.03722023f, -0.07525622f, 0.08308108f, -0.12637550f, 0.02661427f, -0.05246247f, 0.04980896f, -0.11875806f, 
    -0.15201597f, -0.14811566f, 0.02657939f, 0.16720353f, 0.10336556f, -0.08379325f, 0.03334457f, -0.00579964f, 
    -0.11890094f, 0.09215479f, 0.03940229f, 0.05854884f, 0.38984331f, -0.17000395f, 0.07080150f, 0.04305271f, 
    -0.01659776f, 0.03067813f, -0.05143021f, -0.00673760f, -0.05816634f, -0.07631310f, -0.01654477f, -0.06619202f, 
    -0.15337653f, -0.07977428f, 0.00968585f, 0.00098387f, 0.07288672f, 0.05142019f, -0.01588595f, -0.10824426f, 
    -0.13600047f, 0.01440837f, 0.06301000f, -0.11663917f, 0.01259181f, 0.27517968f, 0.11930579f, -0.22719827f, 
    0.10397990f, 0.01631759f, 0.00916946f, 0.05403063f, 0.01962246f, 0.00538541f, -0.03570991f, -0.01421499f, 
    0.21162812f, -0.08209632f, -0.09552708f, -0.25323424f, -0.03496678f, 0.02313101f, -0.08990450f, 0.10362035f, 
    -0.09830631f, -0.05276021f, 0.04471908f, 0.05530874f, -0.41455904f, -0.18191703f, -0.02189808f, 0.13822736f, 
    0.04838095f, -0.12790862f, 0.00402184f, 0.07633875f, 0.00352222f, 0.00953881f, -0.02875131f, 0.01867750f, 
    -0.60484004f, 0.07604066f, 0.00667899f, 0.18438391f, -0.02454741f, 0.00405753f, 0.05964380f, 0.03031477f, 
    0.02576916f, 0.04108081f, 0.09798403f, 0.02721883f, 0.22732629f, 0.00581384f, 0.13317308f, -0.14247087f, 
    -0.11296519f, 0.04164532f, 0.10678358f, -0.01182092f, 0.05855925f, -0.02220934f, 0.01425200f, -0.01432014f, 
    -0.09859058f, 0.23287982f, -0.01222331f, -0.01912357f, -0.08035856f, -0.00088394f, -0.00403238f, 0.03961264f, 
    -0.03428681f, -0.02796407f, 0.04760407f, 0.03407015f, -0.01807540f, 0.06596635f, -0.02493813f, -0.06999947f, 
    -0.08875118f, 0.14213452f, -0.04102903f, -0.01969979f, -0.08260242f, -0.27655903f, -0.00696585f, 0.01003678f, 
    -0.03367249f, 0.08710109f, -0.03967772f, 0.13456862f, 0.08101901f, 0.01072906f, -0.03295945f, -0.09492891f, 
    0.02762133f, 0.00588918f, 0.05090187f, -0.04511119f, 0.15906377f, 0.02867562f, 0.01774177f, -0.10273282f, 
    0.00289902f, -0.02254704f, -0.01271758f, -0.06904307f, -0.10606259f, 0.03884301f, 0.05537984f, 0.12813549f, 
    0.02531770f, -0.08610551f, 0.01276793f, -0.08654839f, -0.18706906f, 0.04474055f, 0.07794012f, -0.08195656f, 
    0.08743027f, -0.10313326f, -0.02258992f, -0.09622698f, -0.08455720f, 0.21521839f, 0.04986484f, 0.04678719f, 
    0.04078956f, 0.11673877f, 0.09417535f, 0.14627096f, 0.02154889f, 0.09181817f, -0.00234843f, 0.01846814f, 
    0.09172074f, 0.07407564f, -0.13568883f, -0.25949305f, 0.07369671f, -0.00488109f, 0.05316449f, -0.03483002f, 
    0.04831732f, -0.10008530f, -0.09566119f, -0.07410265f, 0.16640346f, -0.09914683f, 0.01799976f, 0.12015428f, 
    -0.10661101f, -0.03735125f, 0.13940357f, -0.09379730f, 0.00870941f, 0.02884647f, 0.01712705f, 0.10002647f, 
    -0.12781648f, -0.03929771f, 0.10254392f, 0.00064445f, 0.01706951f, 0.00377808f, -0.11719611f, -0.06769703f, 
    0.00577901f, -0.01943860f, -0.08765546f, 0.05960295f, 0.15638313f, -0.05333236f, -0.20575958f, 0.07435720f, 
    -0.08326001f, -0.10236819f, 0.06968736f, -0.03480929f, 0.01875522f, 0.03177814f, 0.11041699f, -0.13595179f, 
    0.16488744f, -0.01021529f, -0.09123173f, 0.05969869f, -0.07768842f, -0.09794661f, 0.08224270f, 0.12843174f, 
    -0.06639602f, 0.05529057f, 0.02246560f, 0.01073224f, 0.31954020f, 0.05034646f, -0.12118155f, -0.07561070f, 
    -0.10466862f, -0.04733148f, 0.03859879f, -0.00082151f, -0.09841163f, 0.00528777f, -0.00576349f, 0.06304697f, 
    -0.09877533f, -0.24315655f, 0.05241264f, -0.08157868f, -0.09817881f, -0.00213584f, 0.05132672f, -0.01827705f, 
    0.08709871f, 0.01630670f, 0.05328008f, 0.01857372f, 0.03091568f, 0.16756466f, 0.09485035f, 0.10424127f, 
    -0.08553869f, 0.12358556f, 0.08368788f, -0.02385418f, -0.01835158f, -0.10127430f, 0.08787657f, 0.02118120f, 
    -0.17136426f, 0.04288798f, 0.26045570f, 0.16494039f, -0.08931044f, -0.01033473f, 0.07310188f, 0.05304629f, 
    0.01989195f, 0.04445311f, -0.05557839f, 0.04762989f, -0.04575391f, 0.01528296f, 0.18980350f, -0.00248449f, 
    0.09700454f, 0.07020406f, -0.03932050f, 0.01897481f, 0.08914075f, 0.04022148f, 0.01145872f, -0.06522936f, 
    -0.00312306f, 0.04044614f, 0.05700953f, 0.18496062f, 0.11890124f, 0.14008090f, -0.12120111f, 0.14108691f, 
    -0.00364886f, -0.13869302f, 0.04494809f, 0.05120965f, -0.31530726f, -0.11748573f, 0.15194000f, 0.17925903f, 
    -0.04646945f, 0.08945505f, 0.11383013f, 0.02136876f, -0.02508672f, -0.02251029f, 0.01630531f, 0.01931711f, 
    -0.12583803f, 0.10456108f, 0.04781064f, -0.08620244f, 0.02628912f, 0.04873967f, 0.05308982f, -0.00341551f, 
    -0.01144940f, -0.00686443f, -0.00756627f, -0.04093457f, -0.26524693f, 0.06490541f, 0.02880567f, -0.04405755f, 
    -0.03376543f, -0.06491891f, 0.00750152f, 0.11097661f, -0.01300665f, 0.04544168f, 0.05922383f, -0.07632315f, 
    0.04979443f, -0.01025181f, -0.10535095f, -0.17798308f, 0.11294297f, 0.01349041f, 0.06457750f, 0.04906302f, 
    -0.08000547f, -0.11488794f, 0.04765863f, 0.03386508f, -0.28759217f, -0.03701849f, -0.13492534f, -0.03105840f, 
    -0.00435156f, 0.01769745f, -0.09621684f, 0.01083736f, -0.03992513f, 0.00698711f, -0.18092111f, -0.00110354f, 
    -0.10302299f, -0.01178818f, 0.05018962f, 0.10875402f, -0.06843220f, 0.05804459f, 0.03667782f, 0.09579208f, 
    0.01700911f, 0.03775745f, -0.07640797f, -0.15798105f, 0.05824406f, 0.11133339f, 0.12448972f, 0.15636706f, 
    0.03100192f, 0.00882052f, 0.01775801f, 0.05627415f, -0.05826733f, 0.05210465f, 0.06456909f, 0.06453735f, 
    -0.10132650f, -0.10850238f, 0.11966117f, 0.05810322f, -0.12458459f, -0.01651961f, -0.06076542f, -0.01478772f, 
    0.09598505f, 0.04227566f, -0.12532195f, -0.05968461f, 0.08814997f, -0.11856105f, 0.05072033f, -0.10194714f, 
    -0.07064284f, 0.03449047f, 0.06302078f, 0.08578172f, -0.15394424f, -0.06791554f, -0.15581122f, 0.02049583f, 
    -0.00844451f, -0.08281369f, -0.07702071f, -0.11094142f, -0.03694285f, 0.04179082f, -0.03131112f, -0.02553618f, 
    0.00230050f, -0.02809131f, -0.06492055f, -0.00733397f, -0.24213557f, -0.18280429f, 0.15173164f, -0.01924981f, 
    -0.09589664f, 0.11205083f, -0.06525612f, -0.01629839f, 0.07694434f, -0.01416117f, 0.00333064f, 0.02648844f, 
    0.17170979f, 0.00919206f, 0.04751259f, 0.23207954f, 0.02584930f, 0.08353545f, -0.00092938f, 0.14084846f, 
    0.02723586f, 0.10251554f, 0.07594299f, -0.07444330f, -0.08722994f, -0.18205985f, -0.09782552f, 0.11301776f, 
    0.03608153f, 0.03325322f, -0.05291159f, 0.06865890f, -0.04425415f, 0.09233107f, -0.01076282f, 0.01531029f, 
    -0.15490805f, -0.00876502f, -0.18337259f, 0.00913236f, -0.03114573f, 0.05240248f, -0.00583403f, 0.07994053f, 
    -0.06402587f, -0.04998563f, -0.02110736f, 0.01635018f, -0.22939532f, 0.09809221f, 0.14236760f, -0.07358647f, 
    0.05661674f, 0.02178783f, -0.01232563f, 0.03116702f, 0.00016541f, -0.04942681f, 0.03525284f, 0.14678776f, 
    -0.11399162f, 0.32712391f, -0.08606324f, -0.22178535f, 0.07435479f, -0.01041942f, 0.21854790f, -0.04617548f, 
    0.03454373f, -0.05383904f, -0.18540093f, -0.10437010f, -0.07633181f, -0.15106179f, 0.37682918f, 0.20943786f, 
    -0.15495685f, -0.06370854f, 0.03757351f, -0.02950419f, -0.02735317f, -0.04860116f, -0.06738961f, 0.05733597f, 
    -0.19688229f, 0.01730626f, -0.01875017f, -0.04539043f, 0.09850225f, -0.05596261f, -0.03199760f, 0.22689803f, 
    -0.05665281f, 0.08001521f, 0.01374768f, -0.14426684f, -0.12988913f, -0.24838382f, -0.06799437f, 0.09874553f, 
    -0.01914486f, -0.06065067f, 0.02945711f, 0.12890883f, 0.06674772f, 0.10539055f, -0.07809376f, 0.01929059f, 
    -0.22590378f, -0.12956452f, -0.08403050f, 0.08788350f, 0.00472718f, -0.06844466f, -0.14287618f, -0.07361922f, 
    0.00509913f, 0.10743400f, -0.02885587f, 0.06427117f, -0.05248618f, 0.01021465f, 0.10261038f, 0.22095668f, 
    -0.09895184f, 0.02885734f, -0.07456464f, 0.00196050f, -0.09351686f, -0.04934869f, 0.18653217f, -0.02823476f, 
    -0.09643244f, 0.18419608f, 0.19071235f, -0.10018180f, -0.02691913f, 0.08272624f, -0.08514914f, 0.09035026f, 
    0.05946533f, -0.08293831f, 0.11049153f, -0.05175151f, -0.12116702f, -0.09068466f, -0.05200606f, 0.00859632f, 
    0.01974750f, 0.04047779f, 0.04069741f, 0.10148553f, -0.02371970f, 0.07448719f, -0.07774361f, -0.01858503f, 
    -0.17591551f, -0.03201521f, -0.11311571f, -0.09530202f, -0.06112243f, -0.10728706f, 0.09115252f, 0.07081094f, 
    0.10887859f, -0.04318079f, 0.09775377f, -0.15936214f, 0.11085898f, 0.06916182f, 0.00756850f, 0.05749606f, 
    0.04267302f, -0.08361636f, 0.00650729f, -0.11090606f, 0.06247346f, -0.00557265f, -0.11740740f, -0.05778755f, 
    -0.01761207f, 0.16344680f, 0.26275009f, -0.04071673f, 0.12325886f, 0.00726498f, 0.08539668f, 0.06661819f, 
    -0.11061594f, 0.05180274f, 0.10657537f, 0.11022243f, -0.09255242f, 0.10427522f, 0.01167366f, -0.06724028f, 
    0.13349554f, 0.07715707f, 0.08940158f, -0.06782380f, 0.04829214f, -0.00288161f, 0.07849795f, 0.09564082f, 
    -0.13334376f, -0.02589407f, 0.04549920f, 0.03464356f, -0.05804103f, -0.02202376f, 0.01335270f, 0.04623627f, 
    -0.04413284f, -0.05261459f, -0.06687795f, 0.02276810f, -0.54574805f, -0.25552362f, 0.18564269f, -0.14212643f, 
    0.07643843f, 0.11860488f, 0.02870931f, -0.04829973f, -0.03651652f, 0.05780943f, 0.04051661f, 0.11052419f, 
    -0.25009844f, 0.08511089f, -0.28112420f, -0.00404584f, 0.15701903f, 0.09908265f, -0.07467246f, -0.04987941f, 
    0.01172860f, -0.07474688f, -0.06253295f, -0.03603467f, 0.03372306f, -0.12041435f, -0.09898604f, 0.18467166f, 
    -0.01577059f, -0.04678594f, 0.02199068f, 0.12360187f, 0.00005717f, 0.10638691f, -0.08720201f, 0.09588628f, 
    -0.00937077f, -0.01138841f, -0.06477470f, -0.05359026f, 0.01958992f, 0.00464217f, 0.10273380f, 0.09209050f, 
    0.13148077f, 0.10817351f, -0.02789296f, -0.11835288f, -0.10803790f, -0.19569738f, 0.10420260f, -0.02933332f, 
    0.02294865f, -0.03949779f, -0.06564148f, -0.09951612f, -0.02082704f, 0.09982600f, 0.13137569f, 0.07587413f, 
    -0.04612975f, 0.05927644f, 0.10496233f, 0.41826913f, -0.09748111f, 0.04875563f, 0.10096394f, 0.11035315f, 
    0.02312216f, -0.02786554f, -0.17039900f, -0.06801962f, -0.32275409f, 0.39547154f, 0.31275779f, -0.28754267f, 
    0.00721790f, -0.02382678f, -0.01148945f, 0.01186085f, 0.05326685f, 0.03421582f, -0.09230210f, -0.23389554f, 
    0.04642576f, -0.11952949f, -0.03342875f, -0.08059704f, -0.11703914f, 0.07182196f, -0.14064482f, -0.15358901f, 
    0.02892871f, 0.04426994f, 0.09228471f, -0.05143481f, 0.15053394f, 0.08816075f, 0.15016416f, -0.02952268f, 
    0.08237502f, 0.14305396f, 0.13291316f, 0.02047092f, -0.13495675f, -0.12135539f, 0.04925339f, 0.06974813f, 
    0.11208378f, 0.03256248f, 0.00174533f, 0.09055382f, -0.07447892f, -0.11218918f, 0.08668824f, 0.06904192f, 
    -0.14032973f, 0.04320407f, 0.00124330f, 0.22229065f, -0.06629540f, 0.13973984f, 0.20934871f, -0.31369546f, 
    -0.20832522f, 0.04570232f, -0.07511279f, -0.10142376f, -0.01921609f, -0.10137697f, -0.02598290f, 0.13025790f, 
    0.15577959f, -0.04217732f, -0.00521909f, -0.04512015f, 0.14167811f, 0.17929021f, -0.09854734f, 0.04991641f, 
    0.01385203f, -0.12069190f, 0.05335641f, -0.17860825f, -0.13914014f, -0.02098772f, -0.02300343f, 0.05917967f, 
    -0.11578806f, 0.06673739f, -0.08681320f, -0.13199650f, -0.06492266f, 0.04200944f, 0.15738535f, 0.04545772f, 
    0.06355710f, 0.09949020f, 0.05132759f, -0.08642372f, 0.04602078f, -0.04507167f, 0.15534301f, 0.11722903f, 
    0.08788312f, -0.06448333f, 0.09869263f, -0.00225335f, -0.04532003f, -0.05428389f, 0.02142936f, 0.15053499f, 
    -0.09647571f, 0.06160805f, -0.11574039f, -0.04478058f, -0.01945883f, 0.11545215f, 0.04358737f, 0.11926521f, 
    -0.03341193f, 0.05967131f, 0.05980897f, -0.04358169f, 0.09033056f, 0.03090551f, 0.00471070f, -0.02856409f, 
    0.06167948f, -0.10333841f, -0.10738747f, 0.09237396f, 0.03589116f, 0.13797155f, -0.03557970f, -0.01952467f, 
    -0.04115587f, 0.12306457f, 0.06874610f, -0.07271343f, 0.01948212f, -0.00608390f, -0.01813500f, -0.11672394f, 
    -0.34438041f, 0.00560511f, -0.17849743f, -0.19424596f, 0.13517044f, 0.03034761f, 0.01191130f, 0.02267732f, 
    -0.17317422f, -0.05366794f, -0.05384590f, -0.08329662f, -0.00356847f, 0.01662975f, 0.01587226f, 0.38004550f, 
    0.06797644f, -0.02844856f, 0.00240552f, 0.11781386f, -0.10367698f, -0.09453242f, -0.03194793f, -0.04875479f, 
    -0.10368720f, -0.11980518f, 0.09928615f, 0.01217462f, -0.01753421f, -0.01579240f, 0.07524493f, -0.12437803f, 
    -0.00346071f, -0.13481148f, -0.12037631f, -0.06505302f, -0.18409243f, 0.02742730f, -0.02521049f, -0.07106163f, 
    0.06774836f, -0.07723229f, 0.07378060f, -0.00991847f, 0.07433058f, 0.08594654f, 0.01236040f, -0.10831464f, 
    0.13935608f, 0.01728078f, -0.07448951f, -0.04912402f, 0.10641215f, -0.03199239f, -0.17526220f, -0.01836823f, 
    0.02516339f, 0.13455001f, -0.08649109f, -0.05452162f, 0.08150939f, 0.08314701f, 0.09517392f, 0.12641107f, 
    -0.05971102f, -0.00494375f, 0.12041491f, -0.08492055f, 0.05977465f, 0.02686949f, -0.00437712f, 0.03974965f, 
    0.08193208f, 0.02558060f, 0.00590326f, 0.13052589f, -0.07881165f, -0.17192151f, 0.00024744f, 0.01975891f, 
    -0.01582475f, 0.05537302f, 0.01845719f, 0.09807224f, -0.01717945f, -0.07786391f, 0.02561085f, -0.14894482f, 
    0.02532859f, -0.12149476f, -0.04047709f, -0.23958942f, 0.08040830f, -0.11785647f, 0.08453142f, 0.04617202f, 
    -0.66908813f, -0.25763437f, 0.08081147f, 0.09830678f, -0.06877535f, -0.01223590f, 0.16114673f, 0.02948067f, 
    -0.01158260f, -0.03021164f, -0.00645420f, -0.11117791f, 0.09413011f, 0.09013292f, 0.15037335f, -0.37433445f, 
    0.02571333f, 0.00341056f, -0.00305666f, -0.01030605f, 0.09343854f, -0.09597471f, -0.06585641f, -0.02734820f, 
    0.17485027f, 0.10593922f, -0.09276053f, -0.26633084f, 0.10971200f, 0.01829862f, -0.12649201f, 0.04579889f, 
    -0.05784085f, -0.01159627f, 0.16179362f, -0.10945725f, -0.05862740f, -0.10237671f, 0.13141759f, -0.15163560f, 
    -0.03112180f, -0.06269243f, -0.04152759f, -0.16436078f, -0.19754183f, -0.03490448f, 0.01400094f, -0.00178520f, 
    -0.12867782f, 0.00755914f, 0.11646558f, 0.16469562f, 0.09689950f, 0.12156844f, 0.05717966f, -0.00230529f, 
    0.08218407f, -0.11326133f, 0.11052376f, -0.15290204f, 0.04931328f, 0.03216923f, 0.16859269f, -0.11478363f, 
    -0.03205352f, 0.01680864f, 0.02975642f, 0.07293036f, 0.21466941f, -0.04312548f, 0.04213287f, 0.02830687f, 
    0.08751696f, 0.06255100f, -0.02901430f, 0.07697114f, -0.10651675f, -0.06537158f, -0.00489234f, 0.09806389f, 
    -0.01195192f, -0.03251611f, 0.03946178f, 0.03765421f, -0.14250188f, 0.12577805f, -0.06838645f, 0.13269994f, 
    -0.03905019f, -0.12632242f, 0.09883893f, -0.03464982f, 0.08921137f, -0.15896048f, 0.06478216f, 0.10914970f, 
    0.00456338f, -0.02063343f, -0.23361847f, -0.07361988f, 0.06672258f, -0.04799885f, 0.06843926f, -0.07314365f, 
    -0.00235245f, -0.00710242f, 0.03932123f, 0.00491189f, 0.19370601f, -0.11846431f, -0.04581314f, -0.00061971f, 
    0.01454569f, 0.02861498f, 0.09446225f, -0.05608481f, 0.00546621f, -0.03980538f, 0.16504744f, 0.12500477f, 
    -0.37691268f, -0.05990826f, -0.08822206f, -0.00027695f, 0.07925238f, 0.10756192f, 0.09357261f, -0.00214971f, 
    0.16724254f, 0.16448620f, 0.13503605f, -0.09042194f, -0.16044682f, -0.03117067f, -0.11996369f, -0.07864491f, 
    0.06117392f, 0.06766188f, -0.07841809f, -0.06080609f, 0.10124726f, -0.13038817f, 0.03212110f, 0.06426539f, 
    -0.44085100f, -0.18274030f, -0.03446715f, -0.01125065f, -0.00239068f, -0.04222905f, 0.07910760f, 0.11528768f, 
    0.02370251f, 0.06005295f, -0.01145934f, -0.11496803f, -0.26947263f, -0.15419160f, -0.16106109f, -0.18885764f, 
    0.10314239f, 0.11233521f, -0.08308186f, 0.03770177f, 0.11796870f, 0.02233401f, 0.01253279f, 0.07993283f, 
    -0.26418942f, -0.19135578f, 0.09432505f, -0.01268165f, 0.07646829f, 0.07222789f, -0.01827331f, 0.00908886f, 
    0.09387096f, 0.15925278f, 0.02418293f, -0.04460037f, -0.14579150f, -0.23380685f, -0.07729965f, -0.01124334f, 
    0.13335747f, -0.02256838f, -0.02149203f, 0.14653768f, 0.01363522f, -0.03955311f, 0.05088067f, 0.09429864f, 
    0.01476070f, -0.06131569f, 0.05316330f, -0.09771062f, -0.03029491f, 0.01310407f, 0.01019715f, -0.01583994f, 
    0.08187848f, 0.05543368f, 0.11474311f, 0.21363418f, 0.02359978f, -0.16729912f, -0.06698662f, -0.07209994f, 
    0.05469662f, -0.04903619f, -0.11913091f, -0.22779723f, 0.07841060f, -0.07004674f, 0.07817132f, -0.04048385f, 
    -0.00376016f, -0.01131549f, 0.04510800f, 0.15366007f, -0.05112838f, 0.01732365f, -0.09318856f, 0.00123808f, 
    0.00437662f, -0.12005641f, -0.06242635f, -0.14586811f, -0.03412958f, -0.11541037f, -0.29503348f, 0.04761227f, 
    0.19213092f, -0.04357692f, 0.10644718f, 0.06110072f, 0.05738363f, -0.04318228f, 0.03215906f, -0.05870980f, 
    0.02856241f, 0.08646577f, -0.00694118f, 0.12933756f, 0.09738819f, -0.05212954f, -0.02994162f, -0.08356796f, 
    0.10241676f, -0.02329498f, -0.01665174f, 0.03774271f, -0.03589496f, -0.02162939f, 0.01848194f, 0.11878025f, 
    0.05041538f, -0.13887420f, 0.06684290f, -0.03279309f, 0.02401892f, -0.11763974f, 0.00027455f, -0.08888713f, 
    -0.28345171f, -0.09155538f, -0.18166040f, 0.03715177f, 0.11562390f, -0.03154837f, -0.00347201f, -0.02361491f, 
    -0.03838748f, 0.03616993f, -0.09664918f, 0.04566728f, -0.13886851f, 0.07804842f, -0.06905165f, -0.10594563f, 
    0.03353034f, -0.03485889f, -0.04878994f, -0.14517052f, -0.00539690f, -0.13241805f, -0.08004055f, -0.00707003f, 
    -0.21816139f, 0.02099379f, 0.00256422f, -0.25393707f, -0.01692360f, -0.06103784f, 0.11590990f, 0.02112851f, 
    -0.05170908f, -0.05139904f, -0.12015944f, -0.04550125f, -0.07817424f, -0.09501991f, 0.08861151f, 0.09926609f, 
    0.04292476f, 0.13932461f, 0.02959451f, -0.00700306f, -0.05811936f, 0.08194108f, 0.13939482f, 0.15223354f, 
    0.07797879f, -0.27726889f, 0.07394715f, -0.12193844f, 0.08088902f, 0.03196173f, 0.07583988f, -0.06296284f, 
    -0.19657429f, -0.10517582f, 0.17067997f, 0.12510653f, -0.16092080f, -0.13474233f, 0.11916210f, -0.02785688f, 
    0.18974145f, -0.01707773f, 0.00816118f, 0.00529419f, -0.03449850f, 0.24849047f, -0.05648741f, 0.05536960f, 
    0.28248388f, -0.10337726f, 0.23567003f, -0.16385481f, -0.02502962f, -0.03447798f, 0.08316907f, -0.09893988f, 
    0.06422234f, 0.02165248f, 0.10802609f, 0.08237144f, 0.04713035f, -0.06041510f, -0.07105575f, 0.01330227f, 
    -0.02775590f, 0.09831782f, 0.05739655f, -0.08767164f, -0.01412311f, 0.02680230f, 0.08083790f, 0.05578747f, 
    -0.18509784f, 0.05334209f, -0.17607173f, -0.11921609f, -0.09481885f, -0.07201887f, 0.02919081f, 0.00599823f, 
    0.00285068f, -0.11397672f, 0.06749944f, -0.01666187f, 0.08088434f, -0.18280317f, -0.04659973f, 0.15518601f, 
    0.08585671f, -0.02894594f, 0.03432919f, 0.03733625f, -0.05429738f, -0.14878234f, 0.02565745f, 0.00413937f, 
    0.00136748f, -0.10376889f, 0.16576441f, 0.09168642f, -0.02692673f, -0.00219648f, 0.15238345f, 0.05369074f, 
    0.04662175f, -0.04180906f, -0.03160324f, -0.05447062f, 0.01535981f, -0.02495557f, 0.10086215f, 0.13341522f, 
    0.07977359f, -0.07768760f, -0.04763883f, -0.06244035f, -0.02578210f, -0.01944504f, -0.00119096f, 0.13800098f, 
    0.19473630f, -0.27960107f, -0.08517563f, 0.06938163f, 0.08381744f, 0.20651200f, -0.01929964f, -0.06041306f, 
    0.05867780f, 0.07745692f, -0.05272336f, 0.14920738f, -0.22390021f, 0.21868035f, 0.21062185f, -0.01585231f, 
    -0.05828114f, 0.03442529f, 0.08165750f, 0.09675746f, -0.02210203f, 0.06446670f, 0.08649953f, 0.06887159f, 
    -0.02458722f, -0.03842398f, 0.18070854f, -0.15359384f, 0.00301376f, 0.09341133f, -0.06104766f, -0.01646282f, 
    -0.01106758f, -0.20547941f, 0.01598307f, -0.21328327f, 0.06206120f, 0.10407648f, 0.11621995f, -0.32719606f, 
    -0.14159054f, 0.01923280f, 0.02663452f, 0.07459284f, 0.04918331f, 0.05359199f, 0.04840861f, -0.04631457f, 
    0.22615127f, -0.06551155f, -0.06226899f, 0.17358430f, -0.00188710f, 0.08439302f, 0.01969967f, 0.04992493f, 
    -0.04790989f, 0.06186441f, 0.03953290f, -0.01922078f, 0.27048320f, -0.45348248f, -0.10183749f, 0.11646573f, 
    -0.05326832f, 0.06612753f, 0.01956827f, -0.02174691f, 0.05572721f, 0.03338297f, -0.10152024f, -0.12483460f, 
    0.14045581f, -0.19678132f, 0.01454675f, -0.24600211f, 0.03456589f, -0.01039622f, 0.02722032f, -0.12229872f, 
    -0.03869350f, -0.03129146f, 0.22152632f, 0.13780504f, -0.11352087f, 0.05859645f, -0.26802105f, 0.29158121f, 
    0.00574877f, 0.07417116f, 0.00252576f, -0.04856482f, -0.01164339f, -0.17269190f, 0.05278262f, -0.13467616f, 
    0.00202347f, 0.01868419f, -0.11804451f, -0.11466089f, -0.13176297f, 0.02981173f, -0.03897437f, 0.05429081f, 
    -0.10092129f, -0.06442693f, 0.07077783f, 0.01848493f, 0.05307140f, -0.16637732f, -0.09099130f, 0.15458210f, 
    -0.10825396f, -0.04264683f, 0.12331401f, 0.03613521f, 0.03722611f, -0.04112421f, -0.03085497f, -0.09538304f, 
    -0.17377609f, 0.04258802f, -0.05048626f, 0.01842831f, 0.02077709f, -0.07891680f, -0.09603173f, -0.01673648f, 
    -0.23768272f, 0.11093193f, 0.06750496f, 0.04652938f, 0.43121523f, -0.41942969f, -0.08750387f, 0.07619165f, 
    0.10854071f, 0.07258782f, -0.09037489f, 0.01962617f, 0.07773133f, -0.01269357f, 0.04095836f, 0.10385001f, 
    -0.47331250f, -0.10090784f, -0.00397483f, 0.10501024f, 0.07557873f, -0.02633454f, 0.06759268f, -0.05601407f, 
    0.09332501f, -0.05580703f, -0.05073858f, 0.03532161f, -0.01251377f, 0.26190415f, 0.13637377f, -0.13594165f, 
    -0.04652866f, -0.12296241f, -0.00160276f, -0.04178951f, 0.00367272f, 0.04481983f, 0.07603951f, -0.03341521f, 
    0.18880121f, 0.14820342f, -0.20991051f, -0.21854511f, -0.01838938f, 0.28603673f, 0.01404652f, 0.06302536f, 
    -0.12370853f, -0.09246729f, -0.14686890f, 0.08222733f, -0.23025925f, 0.17313977f, -0.00397505f, 0.19830878f, 
    0.02575199f, 0.07426950f, 0.14242715f, -0.00670857f, 0.10592598f, -0.19963600f, -0.10527982f, -0.06348999f, 
    -0.11903272f, -0.11693878f, -0.03439447f, -0.15743953f, -0.04010594f, -0.07121310f, 0.01080718f, -0.05930775f, 
    0.05639290f, 0.10020316f, -0.00369953f, 0.09178801f, -0.05045333f, 0.02988656f, -0.21212359f, 0.15467630f, 
    -0.03715575f, 0.01445123f, 0.11452211f, -0.04077217f, 0.06613808f, -0.14880273f, -0.04349987f, -0.11670107f, 
    0.02254969f, -0.14810447f, -0.01546995f, 0.01417427f, 0.09412686f, -0.01955182f, -0.12479898f, -0.04959063f, 
    0.00929749f, 0.01489320f, -0.08523454f, 0.00018008f, 0.19288169f, -0.06454770f, 0.03084148f, -0.30984017f, 
    0.09858990f, 0.03321654f, 0.06579220f, 0.12191257f, 0.01948880f, -0.13606241f, 0.04550232f, -0.05393381f, 
    0.02569503f, -0.03492092f, 0.00513500f, -0.11321528f, -0.07082862f, 0.00491739f, 0.12677312f, 0.05144065f, 
    0.13063639f, 0.03938198f, -0.02027902f, -0.20269762f, 0.16359533f, -0.16467047f, -0.18368842f, -0.08841010f, 
    -0.16033465f, -0.07414494f, 0.00889820f, -0.11743484f, -0.03881485f, 0.04287052f, -0.04809655f, 0.16899423f, 
    0.15856494f, -0.10488524f, -0.07760060f, -0.17061296f, -0.01969010f, 0.02071811f, 0.00013869f, 0.00818821f, 
    -0.01998266f, 0.06749211f, 0.05875709f, 0.11115198f, -0.03811801f, -0.15741061f, -0.11299304f, -0.05226348f, 
    -0.06193942f, -0.00871557f, -0.05009278f, -0.03449383f, 0.07586961f, 0.10614330f, -0.04082965f, 0.09142104f, 
    0.12784189f, 0.08805176f, -0.00489044f, -0.06847502f, -0.06394911f, -0.05825743f, 0.01800429f, 0.13155660f, 
    0.07682129f, 0.05944066f, 0.08861964f, 0.17894892f, 0.11096320f, -0.03763203f, -0.06011141f, -0.16839145f, 
    -0.16007188f, 0.02861929f, 0.06632327f, -0.05234358f, -0.07542307f, -0.04476910f, -0.05209880f, -0.06767473f, 
    -0.06314018f, -0.30243361f, -0.30910912f, 0.21142708f, -0.04524063f, 0.05378035f, 0.10466605f, -0.04674003f, 
    0.05933257f, -0.06675092f, 0.07139678f, 0.07480180f, -0.07892747f, 0.06739405f, -0.01586880f, 0.15753217f, 
    0.06284365f, 0.09140593f, -0.22885808f, 0.00813137f, 0.01507438f, 0.11306914f, 0.06691924f, -0.02552187f, 
    -0.09999015f, -0.09327962f, -0.16212857f, 0.27443805f, 0.02791369f, 0.04947161f, 0.09199986f, -0.01064636f, 
    0.05784835f, -0.00366480f, 0.06418288f, -0.14854449f, 0.00282445f, -0.38294342f, -0.17946784f, 0.08744843f, 
    -0.05224785f, -0.00867928f, 0.10676155f, 0.03499429f, -0.02193885f, 0.02182521f, 0.02984713f, 0.16953854f, 
    0.49232167f, -0.14913204f, 0.04847483f, 0.01687880f, -0.04256593f, 0.09513305f, -0.10346068f, 0.03164649f, 
    -0.14089763f, 0.07307782f, -0.03934745f, -0.01284330f, -0.21111475f, 0.04374637f, 0.22751361f, 0.00099091f, 
    -0.00594428f, -0.06821109f, 0.00062215f, 0.04630794f, -0.12971659f, -0.04211977f, 0.03868391f, 0.08213146f, 
    0.25756404f, 0.05077397f, 0.01976732f, -0.19500220f, -0.08728613f, 0.06726486f, 0.12228371f, 0.04087562f, 
    0.06099537f, 0.07614434f, -0.19546464f, 0.06636420f, -0.18062924f, 0.11560448f, 0.11002348f, -0.06476421f, 
    -0.06673566f, 0.13756496f, 0.03441100f, 0.10599377f, 0.07575312f, -0.07224552f, 0.00884522f, -0.00771795f, 
    -0.09256812f, -0.10187070f, -0.07660387f, -0.03050597f, -0.05212805f, -0.01511914f, -0.17807227f, -0.08673964f, 
    -0.08008286f, 0.08883028f, -0.10303799f, -0.09965743f, -0.27537981f, -0.00514723f, 0.02554118f, -0.09186229f, 
    -0.00295449f, 0.02320708f, 0.03423162f, 0.02587949f, -0.11120397f, 0.00474699f, 0.06281640f, -0.05218004f, 
    -0.39016441f, 0.12152428f, 0.08076140f, 0.25158647f, 0.07428619f, -0.00980595f, 0.00525890f, -0.07048570f, 
    0.02405207f, 0.04177682f, -0.14817470f, -0.09092893f, -0.23421112f, 0.00851348f, -0.15824443f, 0.12375646f, 
    0.02750571f, 0.00259101f, -0.18020085f, -0.13304032f, -0.07877280f, -0.00540946f, -0.17613801f, -0.03068705f, 
    -0.09913012f, -0.11986173f, -0.09327544f, 0.18152019f, 0.01759576f, 0.05697536f, -0.08819805f, 0.01560994f, 
    0.09631710f, 0.03150203f, -0.01533427f, -0.03719046f, 0.11521378f, -0.14164367f, -0.07142950f, -0.02778691f, 
    0.03838177f, -0.00992766f, -0.02125535f, 0.02011704f, -0.05289490f, -0.04924564f, -0.06453377f, -0.02496131f, 
    -0.20804402f, 0.03947377f, -0.11266690f, -0.36011940f, -0.09827153f, 0.05965684f, -0.14785480f, -0.21259153f, 
    -0.15301493f, -0.02939587f, -0.14707150f, -0.04022899f, -0.26425090f, -0.27136853f, -0.16047615f, -0.11567575f, 
    -0.01629434f, 0.01836233f, 0.03522338f, -0.02581735f, -0.02010665f, 0.02999495f, 0.02688867f, -0.00537585f, 
    -0.04035611f, 0.03198422f, 0.03831305f, -0.06462645f, 0.04575660f, -0.11453258f, -0.03290482f, -0.05553862f, 
    -0.02536053f, -0.09368632f, 0.09021015f, 0.12052075f, -0.06612625f, -0.06362098f, 0.06020645f, 0.14951444f, 
    -0.06739555f, 0.03697809f, 0.14148998f, 0.05772817f, -0.05787241f, 0.06580478f, 0.03485251f, -0.03284732f, 
    0.17076571f, 0.12870693f, -0.04091865f, 0.22295700f, -0.04784640f, 0.04262808f, -0.14327933f, -0.09695800f, 
    -0.06262911f, -0.05494333f, -0.03285380f, 0.13943505f, 0.02315176f, 0.06237496f, 0.11748870f, -0.12956157f, 
    -0.00961740f, -0.05422443f, 0.14123043f, 0.00191448f, 0.02963768f, -0.07122137f, -0.10696246f, -0.04362007f, 
    0.02301310f, 0.24994083f, 0.16172372f, -0.46665594f, -0.00887695f, -0.00370449f, -0.05097222f, 0.04647232f, 
    0.09531445f, -0.07332072f, -0.10230272f, -0.11483978f, -0.01289833f, -0.08012766f, -0.18715034f, 0.08662707f, 
    -0.09606440f, 0.02917731f, 0.04246857f, -0.00441715f, -0.04313819f, 0.19837856f, -0.08608487f, 0.07842167f, 
    -0.18358241f, 0.23924558f, 0.02127880f, -0.02748358f, 0.03967489f, -0.01628901f, -0.01525247f, 0.05150088f, 
    -0.01219384f, 0.10398182f, 0.03912009f, 0.19645941f, -0.28240463f, 0.02885141f, -0.20411231f, -0.10505416f, 
    -0.10498696f, -0.10136373f, -0.18047792f, -0.13918531f, -0.22168456f, 0.02440900f, 0.03712676f, -0.07117410f, 
    0.26306969f, -0.21421282f, 0.03211526f, -0.04111087f, 0.08645088f, 0.06398211f, 0.06677119f, 0.04789418f, 
    0.03083453f, -0.07872667f, 0.05105828f, -0.10706374f, -0.18251991f, 0.04375648f, -0.10972117f, 0.23968914f, 
    -0.06081753f, 0.02088341f, -0.09510893f, 0.06553765f, -0.02546692f, 0.08550787f, 0.07926510f, -0.02648309f, 
    -0.15058720f, 0.05032649f, -0.19420995f, -0.10636635f, 0.02019702f, -0.00174996f, -0.09345576f, -0.04689665f, 
    -0.03139278f, 0.04381005f, 0.04630947f, 0.06587987f, -0.01610458f, 0.05960189f, -0.08120196f, 0.24235778f, 
    -0.10390428f, 0.13867132f, -0.03105565f, -0.02637799f, 0.07913782f, 0.03291345f, 0.03705322f, 0.03691608f, 
    -0.04899592f, -0.05370354f, 0.11495037f, -0.00103677f, 0.13945930f, -0.03131141f, 0.07514438f, -0.08556677f, 
    0.07831230f, -0.05516027f, 0.22500843f, -0.01899682f, 0.26633391f, -0.10111862f, -0.04048805f, 0.01374824f, 
    -0.06997858f, 0.02245178f, 0.01318429f, 0.00612709f, 0.15272002f, -0.14018977f, -0.06920851f, 0.03107365f, 
    0.22116226f, -0.11374296f, 0.13890296f, -0.07041796f, 0.03829474f, 0.06462804f, -0.08463323f, 0.06562966f, 
    -0.01753150f, 0.04587224f, -0.02182574f, -0.04713484f, -0.17060170f, 0.19394414f, 0.01915988f, -0.00964816f, 
    0.02934557f, -0.03151933f, -0.02412083f, -0.10632684f, -0.00070604f, 0.01290115f, 0.00980336f, -0.04561796f, 
    0.19833490f, -0.09825850f, 0.04948965f, -0.02204825f, -0.00184595f, -0.04694583f, 0.00344855f, -0.04562403f, 
    0.03377531f, -0.00492968f, -0.00702136f, -0.04427091f, 0.17818172f, -0.06220357f, 0.10790790f, 0.12513584f, 
    0.09044845f, 0.03556142f, -0.02816863f, -0.03677559f, -0.10956824f, -0.04982546f, -0.02621703f, -0.15006813f, 
    -0.03971676f, 0.03240957f, 0.00611805f, -0.00185889f, -0.05892518f, -0.04497742f, -0.12665378f, -0.05482434f, 
    -0.07265247f, -0.00812521f, -0.10309191f, -0.08551378f, 0.02882962f, 0.07540322f, -0.04047072f, 0.14206074f, 
    -0.11094382f, -0.07182478f, -0.01649334f, 0.01656339f, -0.01934643f, 0.00409132f, -0.08073795f, 0.00887190f, 
    -0.10775073f, -0.01702888f, 0.04106704f, -0.07851136f, -0.14303437f, -0.05431581f, -0.07253774f, -0.02629955f, 
    -0.01710614f, 0.04131382f, -0.03347940f, -0.01144732f, 0.21648476f, -0.23692107f, 0.10485410f, -0.08909074f, 
    0.02673743f, -0.00559561f, -0.01130789f, -0.02881274f, -0.11625996f, -0.05017533f, -0.05611878f, -0.03157938f, 
    0.23546897f, 0.01440761f, 0.07584734f, -0.02516920f, 0.09959637f, 0.02827722f, 0.04558490f, 0.02067336f, 
    0.00176044f, 0.03888788f, -0.05520320f, -0.02148645f, -0.10398594f, 0.02800316f, -0.05445116f, -0.20279628f, 
    -0.01641879f, 0.03186852f, -0.06115821f, -0.06100906f, -0.04510414f, -0.02347194f, -0.05045757f, -0.06552382f, 
    -0.12596840f, 0.08814100f, -0.10157333f, -0.04258560f, -0.03188779f, 0.00482038f, 0.04303692f, -0.03804960f, 
    -0.06174536f, -0.08880153f, 0.00659830f, -0.06276564f, -0.23710102f, 0.04510190f, -0.20778748f, -0.13127814f, 
    -0.03320459f, -0.06322297f, -0.05205519f, -0.13261423f, -0.11848162f, -0.06040233f, -0.03095087f, -0.03568787f, 
    0.02028418f, 0.14725253f, 0.04254939f, 0.15524735f, 0.02018539f, -0.07604638f, -0.06655774f, -0.00765435f, 
    0.01745525f, 0.03444122f, -0.03413974f, -0.03250309f, -0.15271857f, 0.00813745f, 0.06800924f, -0.08888293f, 
    0.00902130f, -0.00117470f, 0.01170737f, -0.11722003f, -0.06538427f, 0.02326972f, 0.03701492f, -0.12513030f, 
    0.12172500f, 0.12440303f, 0.16016145f, 0.06392036f, -0.01829331f, 0.04430044f, 0.07146297f, 0.00733454f, 
    -0.06943194f, -0.00170019f, -0.01412039f, -0.03143061f, -0.16116619f, 0.02824136f, -0.05965326f, 0.04303927f, 
    0.02730221f, -0.01618287f, -0.01820494f, 0.03450634f, 0.03288335f, -0.07119550f, -0.05374251f, -0.01783805f, 
    0.07528022f, 0.10643084f, -0.07845479f, 0.09649102f, 0.05612260f, 0.05124414f, 0.00056277f, -0.01054030f, 
    -0.01826891f, -0.00668125f, -0.00876378f, 0.05529407f, 0.13761684f, 0.00716601f, 0.05763719f, 0.07834350f, 
    0.18427242f, -0.03463329f, -0.08067885f, 0.02777278f, -0.11645652f, -0.07940588f, -0.09761686f, -0.04171254f, 
    -0.14233635f, -0.04629489f, 0.11257540f, 0.11475118f, -0.00369442f, -0.10504671f, -0.13811606f, -0.04799203f, 
    -0.05415420f, 0.01672369f, 0.02883980f, -0.02733746f, -0.18595867f, 0.05410462f, 0.31845799f, -0.08754105f, 
    0.00068042f, 0.00020146f, -0.02886157f, 0.00020166f, 0.02172713f, -0.02617748f, 0.04970581f, -0.00678763f, 
    0.07190101f, -0.04082613f, 0.10693803f, 0.02733213f, -0.06256872f, -0.07158450f, -0.10534772f, -0.10141245f, 
    0.01197953f, 0.05907074f, -0.05401159f, -0.05542278f, -0.14266755f, -0.14076594f, -0.09355899f, -0.12761231f, 
    -0.03020198f, 0.03778156f, -0.05112981f, -0.01034487f, -0.11254517f, -0.05443498f, 0.04794732f, -0.04309998f, 
    0.09363359f, -0.31830880f, 0.02983221f, 0.04838506f, -0.16688846f, -0.05114732f, -0.06623589f, -0.02040922f, 
    -0.07864282f, -0.02926919f, -0.08846347f, -0.04900588f, -0.17593274f, 0.06690837f, 0.10019298f, -0.09055696f, 
    0.01195431f, -0.03396072f, -0.04946041f, -0.11341143f, 0.00214567f, -0.01258464f, -0.01999353f, 0.01725706f, 
    0.19661590f, 0.06929838f, 0.08682378f, 0.15495737f, 0.00988836f, 0.01571391f, -0.00598161f, -0.01688207f, 
    -0.04880831f, 0.01911854f, -0.03728869f, -0.02855238f, 0.11642428f, -0.00782221f, 0.03912666f, 0.20725301f, 
    0.08321526f, -0.05127937f, -0.05918705f, 0.01396948f, 0.06563826f, -0.08100260f, -0.09979203f, -0.05191011f, 
    0.04689403f, -0.02554042f, 0.06442482f, -0.01608063f, 0.03840210f, -0.02593406f, -0.00238327f, 0.05673873f, 
    -0.02977807f, 0.07888492f, 0.00848195f, -0.15540981f, 0.02430689f, -0.08112953f, 0.02811014f, -0.00754080f, 
    -0.14523531f, -0.08248900f, 0.02938523f, -0.05777625f, 0.02323638f, 0.03490077f, -0.00734318f, -0.05034453f, 
    0.09570497f, -0.19251516f, 0.00270269f, -0.02168777f, -0.01639124f, -0.01289553f, 0.02805954f, 0.05719444f, 
    -0.06604385f, 0.03416918f, -0.06415962f, -0.00293168f, -0.00735519f, 0.14100145f, 0.09829603f, 0.15389559f, 
    0.08836859f, 0.05384084f, -0.01764285f, 0.07211489f, -0.01077165f, -0.01926510f, 0.02591433f, -0.00493972f, 
    -0.01243691f, 0.17169428f, 0.16022171f, -0.00396210f, 0.02857511f, 0.06248746f, 0.03532704f, -0.04898909f, 
    0.03311524f, 0.10844302f, -0.01656498f, 0.00100023f, 0.08194641f, -0.04889238f, 0.10501798f, 0.13380888f, 
    0.10515784f, 0.01392176f, -0.04275730f, -0.06533024f, -0.03871884f, 0.04374853f, -0.00386967f, -0.08047961f, 
    -0.29280183f, 0.04072680f, -0.15149780f, -0.20405301f, -0.11962511f, 0.03820383f, -0.04017150f, -0.10574989f, 
    -0.07567044f, 0.10683835f, 0.01450617f, -0.00953806f, -0.18366796f, 0.10187856f, 0.03205538f, -0.06093936f, 
    -0.09634248f, 0.01423910f, -0.14184192f, -0.05337251f, -0.04405115f, -0.00905154f, 0.04347240f, -0.09635706f, 
    0.08012220f, 0.12654805f, -0.10181375f, 0.03444775f, 0.02641193f, -0.04325743f, -0.01545877f, -0.00059405f, 
    0.07025705f, 0.02686507f, -0.04545899f, -0.03311820f, -0.22182694f, 0.01319555f, -0.04184982f, -0.01788273f, 
    -0.07839410f, 0.01654256f, -0.07680313f, 0.02196904f, 0.05386987f, 0.01292545f, -0.08782647f, -0.06162866f, 
    -0.09192344f, 0.08586112f, -0.15056932f, 0.08556009f, 0.01101110f, -0.13328496f, -0.11447032f, -0.04938108f, 
    0.04898793f, -0.11091549f, -0.05559011f, -0.08188355f, 0.01345020f, -0.08477071f, 0.01697531f, -0.01248970f, 
    0.03962466f, -0.05656953f, -0.04948224f, -0.09968046f, 0.02747396f, -0.03489207f, 0.01700560f, 0.04057458f, 
    0.11705075f, 0.07196101f, 0.05017337f, 0.10732434f, 0.13708197f, 0.02352616f, -0.01675026f, 0.03049041f, 
    -0.02912678f, 0.00293822f, 0.01931123f, -0.00970069f, 0.02979760f, 0.00488089f, -0.11491141f, -0.08857710f, 
    -0.06944285f, 0.00828381f, 0.00428608f, -0.10526630f, -0.04043496f, -0.00410318f, -0.04186009f, -0.08175213f, 
    0.13371550f, 0.00207951f, 0.04870430f, -0.05079476f, -0.05595889f, -0.02270529f, -0.05143609f, -0.12445921f, 
    -0.05592873f, 0.02212842f, -0.03896838f, -0.14450976f, 0.02561456f, 0.08176546f, 0.04157035f, 0.01019685f, 
    -0.03234425f, -0.04157133f, -0.00035148f, -0.00121910f, -0.09600943f, -0.04676448f, -0.10356493f, -0.14959036f, 
    -0.06112687f, 0.11058824f, 0.00272698f, 0.20041721f, 0.06998312f, 0.01555087f, 0.00523020f, 0.06401232f, 
    -0.00249373f, -0.01766566f, 0.05465551f, -0.01652661f, 0.02160567f, 0.14473045f, -0.01778334f, -0.06571275f, 
    -0.10874892f, 0.02957018f, 0.01177588f, -0.12593988f, -0.03651632f, 0.05941049f, -0.01397388f, -0.06310463f, 
    -0.10973784f, -0.21340825f, -0.11627856f, -0.08011019f, -0.01436066f, -0.09440954f, -0.07389215f, -0.03008439f, 
    -0.05508580f, -0.03946077f, -0.02383613f, -0.06442152f, -0.00071442f, 0.23931238f, -0.04391431f, 0.11704990f, 
    -0.07604258f, -0.02787237f, -0.06642174f, -0.00906692f, -0.04704216f, 0.03668972f, -0.02039742f, -0.08037388f, 
    -0.15439415f, 0.12825134f, -0.12751547f, 0.01128829f, 0.03632607f, 0.00911982f, -0.00577191f, -0.00214942f, 
    0.00103850f, 0.03518244f, -0.05069469f, -0.05200257f, 0.10434117f, -0.32301694f, 0.17978680f, 0.09252852f, 
    0.02102455f, -0.06294558f, -0.03946237f, -0.08365306f, 0.02152682f, 0.06477050f, -0.03007497f, -0.04234296f, 
    -0.06962521f, 0.12927194f, 0.10435455f, 0.05755435f, 0.11534359f, 0.08040469f, 0.01539752f, -0.09108571f, 
    -0.05362467f, -0.01009759f, -0.00193872f, -0.03882252f, -0.06031947f, 0.20673665f, 0.15973769f, 0.15932630f, 
    0.09032442f, 0.07257193f, 0.04890830f, 0.01421228f, -0.02856084f, 0.00261221f, 0.05633824f, -0.04869237f, 
    0.13229291f, -0.00651940f, 0.15487668f, 0.06882292f, 0.00434352f, 0.00189064f, -0.04577983f, -0.06652311f, 
    -0.07865359f, -0.04917011f, -0.00551526f, 0.05004283f, 0.20468056f, -0.11184065f, 0.23319861f, -0.05976339f, 
    0.02597994f, 0.01132208f, -0.10725079f, -0.05303819f, -0.01038664f, 0.06478327f, 0.01015498f, 0.00015166f, 
    0.04077892f, 0.14335804f, -0.03377651f, 0.17616884f, 0.00093217f, 0.00268498f, 0.00886686f, -0.01405242f, 
    -0.04493188f, -0.05954444f, -0.08331316f, -0.00607377f, 0.20772187f, 0.07397351f, 0.11436029f, 0.02269401f, 
    -0.12212302f, -0.06009288f, -0.02327057f, 0.03867873f, -0.02221902f, 0.03928436f, -0.05668724f, 0.08766432f, 
    -0.24356396f, 0.02000134f, -0.14107677f, -0.22812954f, -0.06983838f, 0.02349203f, -0.04801749f, -0.03489874f, 
    -0.05235797f, 0.02924198f, -0.00487167f, -0.06597226f, -0.05428421f, 0.16117565f, -0.02899347f, 0.20972584f, 
    0.13460906f, 0.03990469f, 0.04236790f, 0.02608245f, 0.02728462f, -0.02115359f, 0.03693245f, -0.07354383f, 
    -0.14157620f, -0.13648751f, -0.14717360f, -0.21727587f, 0.01191942f, -0.02345919f, 0.02079644f, -0.05737697f, 
    -0.12932517f, -0.01834602f, -0.01923228f, -0.07289273f, 0.07043218f, 0.14728853f, 0.06629243f, 0.24835905f, 
    0.09628700f, 0.07261793f, 0.10538556f, 0.01511940f, -0.01797992f, -0.12179551f, -0.06166368f, -0.05448968f, 
    0.21340331f, -0.19260509f, -0.02201414f, -0.24403417f, -0.08207645f, 0.03076902f, -0.07072116f, -0.10619460f, 
    0.02650197f, -0.03230651f, 0.01496675f, -0.02178711f, -0.02333997f, -0.11836352f, -0.22893110f, 0.08003039f, 
    -0.03477288f, -0.09945659f, -0.03934090f, 0.01669499f, -0.07648943f, 0.02167615f, -0.00112749f, 0.02494971f, 
    -0.09019677f, 0.09134716f, 0.12873057f, 0.10888581f, 0.03310710f, -0.04475826f, -0.02692669f, -0.07414684f, 
    0.05263001f, 0.01779259f, 0.00766304f, -0.12077399f, -0.04305479f, 0.03775652f, 0.03956877f, 0.11671346f, 
    -0.02787985f, -0.03661435f, -0.00648293f, 0.02180191f, -0.00248684f, -0.01626989f, -0.03824570f, -0.02096257f, 
    0.10201439f, -0.04959440f, 0.06386106f, -0.00722402f, -0.04454481f, 0.00466026f, -0.03699289f, -0.00984345f, 
    0.01613129f, 0.00550291f, 0.02199252f, -0.02497612f, -0.16867125f, -0.03452843f, -0.01568464f, 0.11731592f, 
    -0.01265575f, -0.06921358f, -0.03464102f, -0.00454804f, -0.01955503f, 0.01614021f, 0.05691276f, -0.07404328f, 
    -0.21557342f, -0.02594687f, 0.11041703f, -0.00067109f, 0.02942722f, -0.09992027f, 0.06420646f, -0.15368055f, 
    0.10351541f, -0.09121085f, -0.24286915f, -0.00522181f, -0.11786838f, -0.08257879f, -0.14105697f, 0.01155837f, 
    0.03554675f, -0.10022069f, -0.21577542f, -0.01368876f, 0.03407504f, 0.01846830f, 0.05785014f, 0.03630522f, 
    0.13445887f, -0.17133640f, 0.09541672f, -0.00973410f, -0.00149127f, -0.00522866f, 0.02543890f, 0.01149902f, 
    -0.03587044f, 0.11016773f, 0.02989298f, -0.01151974f, -0.10523472f, -0.05460448f, 0.02015177f, -0.25148952f, 
    0.00382079f, -0.05594781f, -0.01681778f, -0.01600658f, 0.02881206f, 0.04842158f, -0.03792774f, 0.11435634f, 
    -0.19428761f, 0.05737871f, 0.09655949f, -0.20179045f, -0.06815471f, -0.02792360f, -0.07957809f, 0.05448771f, 
    -0.04084810f, 0.08387060f, -0.08411143f, 0.07780282f, 0.07825205f, 0.06521426f, -0.28007486f, -0.16801450f, 
    0.05832822f, -0.07398971f, -0.09697612f, -0.02249834f, 0.06763093f, 0.02595750f, 0.10879871f, 0.00022384f, 
    0.16914843f, 0.00642768f, -0.11392040f, 0.01912472f, -0.09266987f, -0.02868864f, 0.01087289f, -0.00718913f, 
    -0.03944313f, 0.00685942f, 0.01015908f, -0.00115704f, 0.16868646f, 0.06697574f, -0.11831389f, 0.08131357f, 
    0.05722472f, 0.03875381f, -0.07028149f, -0.03674989f, 0.07592442f, 0.00738712f, -0.01904660f, -0.02610969f, 
    0.06796018f, -0.20388812f, 0.08141544f, -0.00753726f, 0.06260458f, -0.00602246f, 0.11396423f, -0.20137995f, 
    -0.04701192f, -0.13861383f, 0.01059637f, 0.03621541f, 0.13151081f, 0.00233944f, 0.02860051f, 0.04755341f, 
    0.04954125f, -0.03101958f, -0.02022920f, -0.09124980f, 0.02201322f, 0.14418598f, -0.07152267f, 0.04803110f, 
    0.06216898f, 0.05733915f, -0.04863610f, 0.10882389f, -0.04575654f, 0.03510430f, -0.13758808f, 0.06128023f, 
    0.04804045f, 0.05975458f, 0.01889864f, -0.05612443f, -0.05820684f, -0.05154304f, 0.12259047f, 0.13082419f, 
    0.09072506f, -0.00219441f, -0.00659377f, -0.07381421f, -0.01034420f, -0.05448140f, 0.08667416f, 0.04526672f, 
    -0.12601289f, 0.16598463f, -0.09872551f, -0.21869329f, 0.00056509f, -0.18773529f, -0.06783523f, -0.04486021f, 
    0.00964478f, -0.02159388f, 0.05159021f, -0.02994900f, -0.13495293f, -0.20570232f, 0.07927949f, 0.04515459f, 
    -0.20206618f, -0.12008031f, -0.05668357f, -0.02862239f, 0.04998492f, 0.08518963f, -0.00312083f, -0.02406400f, 
    -0.12076570f, 0.04894137f, 0.14155616f, -0.05649442f, 0.01601902f, -0.02328370f, -0.06318358f, 0.05733803f, 
    -0.01931590f, -0.05887487f, -0.11803526f, -0.22418331f, 0.17237675f, 0.22924073f, -0.20007575f, -0.02356160f, 
    -0.01326713f, 0.00362072f, 0.01888087f, -0.05445989f, 0.04655747f, 0.01410343f, 0.01733442f, 0.08811764f, 
    -0.10532229f, -0.04770246f, 0.06782009f, -0.15265119f, -0.10505451f, -0.02681883f, 0.10663645f, 0.02875801f, 
    0.02266829f, 0.04335493f, -0.07040478f, -0.01879415f, -0.00427196f, -0.03218140f, -0.02510212f, -0.05028506f, 
    0.04738799f, -0.00640528f, -0.08290134f, 0.00756533f, 0.00437474f, 0.05462845f, 0.05103882f, 0.05191411f, 
    -0.23897161f, 0.07660569f, -0.07254468f, -0.15964368f, 0.08334327f, -0.01591456f, -0.00862264f, 0.00764214f, 
    0.13281955f, -0.03000206f, -0.02788714f, -0.06942975f, 0.03345427f, -0.16631308f, -0.05985370f, 0.00898068f, 
    -0.11645152f, -0.17206162f, -0.03457779f, -0.03041613f, 0.07360558f, 0.02349629f, -0.11396597f, -0.00412078f, 
    0.18955699f, 0.19149737f, 0.02421105f, 0.12045782f, -0.12670097f, -0.00886993f, -0.15036061f, -0.02898007f, 
    -0.02498473f, 0.00838517f, 0.03938297f, -0.13260220f, -0.00342963f, -0.22953829f, 0.00638219f, 0.09599885f, 
    0.12634386f, 0.00941781f, -0.05553802f, -0.01774789f, 0.00597161f, -0.00019171f, -0.02265859f, 0.02958300f, 
    -0.15296821f, -0.17434889f, -0.32894439f, -0.18614542f, -0.01912577f, 0.00165780f, 0.07792004f, 0.06805926f, 
    0.02255977f, 0.14313868f, 0.04790596f, 0.03220472f, 0.02452021f, -0.13818848f, -0.04791147f, 0.08802687f, 
    0.05054909f, 0.04104513f, -0.11176803f, -0.04371607f, 0.03988807f, 0.09871703f, 0.03999104f, 0.05360327f, 
    -0.16934876f, 0.03175384f, -0.12237353f, 0.06119795f, -0.02806585f, -0.00375986f, -0.16936117f, -0.01257757f, 
    0.02253497f, -0.08565087f, 0.02192370f, -0.14895010f, 0.06000653f, -0.06048125f, 0.01237472f, -0.11931566f, 
    0.01989125f, 0.05304497f, -0.08962542f, -0.10013865f, 0.01881495f, -0.02770699f, 0.10055374f, -0.00088829f, 
    0.06557332f, -0.02721152f, -0.00627166f, 0.10500461f, -0.14658327f, -0.00316178f, 0.07379957f, 0.02285384f, 
    -0.00171922f, -0.05257715f, -0.06366878f, 0.04256098f, -0.14944461f, 0.06441675f, 0.03902741f, 0.28228348f, 
    0.05956560f, -0.07090386f, -0.00261034f, -0.12655145f, 0.00229049f, 0.13500398f, 0.10052531f, 0.09648442f, 
    -0.06371385f, -0.17596944f, 0.08649883f, -0.00395811f, -0.10553762f, 0.02451483f, -0.04495426f, -0.19294161f, 
    -0.01030095f, -0.12348306f, -0.09765229f, 0.14677441f, 0.02083303f, 0.03148664f, 0.16194707f, -0.13350709f, 
    -0.09874014f, 0.06494848f, 0.03112234f, -0.09710656f, -0.08662978f, -0.03079059f, 0.01081591f, -0.08814881f, 
    -0.23339182f, -0.01695425f, 0.12585585f, 0.06796884f, -0.06066224f, -0.00821332f, -0.10104283f, -0.10936531f, 
    0.05170958f, -0.02061633f, -0.08386611f, 0.05801272f, -0.17260911f, -0.07214987f, -0.04228464f, -0.34156990f, 
    0.07556782f, 0.09108191f, 0.04163599f, 0.03463368f, 0.02105041f, -0.12754798f, 0.05168916f, 0.05564041f, 
    0.06270272f, -0.09251443f, 0.08392958f, 0.22252962f, 0.09025872f, 0.00817817f, -0.03339078f, -0.01457522f, 
    0.11565843f, -0.06813399f, 0.15807649f, -0.11671881f, 0.03039613f, -0.17803700f, 0.10881604f, 0.12624955f, 
    -0.03677723f, -0.17644320f, -0.00778611f, 0.05506496f, 0.04142793f, 0.12651287f, -0.10673181f, 0.00925905f, 
    0.03987485f, 0.25577778f, -0.04660234f, 0.08432633f, -0.03295877f, -0.03193187f, -0.06589822f, -0.00105085f, 
    -0.05533528f, -0.04869701f, 0.01384754f, 0.08094376f, 0.04689652f, 0.10048625f, -0.11905828f, 0.05712375f, 
    -0.00422185f, -0.05318591f, 0.00442192f, -0.03967301f, 0.05498539f, -0.00922358f, 0.02716824f, -0.01338311f, 
    0.01131745f, 0.13185169f, -0.22549690f, -0.17716794f, -0.01714873f, 0.04388012f, -0.04147824f, -0.04087574f, 
    0.07664730f, 0.03764620f, -0.02095159f, 0.10913873f, 0.19416521f, -0.07140650f, 0.15810660f, 0.15346152f, 
    -0.07018988f, 0.02510737f, -0.02689508f, -0.05928079f, -0.01074092f, -0.07681061f, 0.04427972f, 0.00129924f, 
    0.00259483f, -0.18135968f, 0.03657986f, -0.12342210f, -0.05161238f, -0.06183412f, 0.06333973f, -0.06627907f, 
    0.05649174f, 0.02046966f, 0.00172922f, -0.08914914f, 0.16182682f, -0.00177860f, 0.00906389f, -0.02807479f, 
    -0.01069634f, 0.02270409f, -0.08400661f, 0.01810585f, 0.00005436f, 0.00561324f, -0.02493684f, -0.06207424f, 
    -0.06905133f, -0.14925413f, 0.01245327f, -0.09419330f, -0.13305287f, -0.07426301f, 0.00347228f, 0.02312392f, 
    -0.02629713f, -0.06603190f, 0.16969134f, -0.11529016f, -0.07987530f, 0.12177713f, -0.13801242f, 0.01634470f, 
    -0.01444807f, -0.07620689f, 0.03713822f, -0.12363628f, -0.07414681f, -0.01680467f, 0.03656149f, -0.04163999f, 
    -0.14911295f, 0.01438692f, 0.01917673f, -0.05729933f, 0.01260037f, 0.10104758f, -0.08909979f, -0.01544282f, 
    -0.05157989f, -0.05550484f, 0.11364139f, -0.00686446f, 0.15930931f, -0.07280052f, 0.20410134f, 0.10956520f, 
    0.07689297f, 0.01867012f, -0.03533188f, 0.00019823f, 0.05133320f, 0.00002672f, 0.09538227f, -0.14135201f, 
    0.20882517f, 0.00864819f, -0.22272031f, -0.12921149f, 0.13693689f, 0.01811008f, -0.01741946f, -0.03573828f, 
    0.04190156f, -0.05084604f, -0.01646510f, 0.04107445f, 0.06543732f, 0.18089007f, 0.10130645f, -0.13622080f, 
    -0.04357836f, 0.01161806f, -0.00554758f, -0.08006952f, 0.04618515f, -0.05344418f, 0.11592335f, 0.07229756f, 
    0.05723875f, 0.18730187f, -0.11147458f, 0.11891605f, -0.06648957f, -0.00391192f, -0.04713837f, -0.07999563f, 
    -0.03661923f, -0.01961770f, 0.05552693f, -0.03875976f, -0.16691965f, -0.06844289f, -0.21815383f, -0.12101432f, 
    -0.11127161f, -0.01686644f, -0.07338410f, -0.10741502f, 0.06482249f, 0.00181753f, -0.08674897f, 0.10221080f, 
    -0.10258019f, 0.02895271f, 0.24119130f, 0.02218468f, -0.00771271f, 0.04897458f, 0.00653243f, -0.00176984f, 
    0.01547651f, 0.07930260f, 0.00263467f, -0.01994199f, -0.13374837f, -0.07494207f, 0.08455369f, 0.13038592f, 
    -0.02984204f, -0.03194452f, -0.05854019f, -0.09922193f, -0.00106565f, -0.04806096f, 0.03878079f, -0.04401497f, 
    -0.11327127f, 0.14220713f, -0.08713930f, 0.00099904f, -0.04474097f, 0.05676373f, 0.06175318f, -0.00738630f, 
    0.00072517f, 0.05086385f, -0.02542253f, -0.02135402f, -0.25902528f, -0.10196965f, -0.03959878f, -0.11826836f, 
    -0.05491965f, -0.06896669f, -0.02281952f, -0.06208773f, 0.02483536f, 0.02549649f, 0.05910685f, 0.12588699f, 
    -0.06471771f, 0.00766743f, 0.11225896f, -0.26314181f, 0.06653959f, -0.08966800f, -0.04655635f, -0.16424569f, 
    -0.01276905f, 0.09516934f, -0.11472182f, -0.12134020f, -0.02566022f, 0.00392768f, 0.00703079f, -0.15137902f, 
    -0.03221595f, 0.02445823f, 0.04425095f, 0.06112473f, 0.06197209f, 0.07651147f, 0.05420548f, 0.04086139f, 
    -0.01922019f, -0.08037359f, 0.01298241f, 0.17313521f, 0.12267508f, 0.07212758f, -0.01787343f, -0.01977637f, 
    -0.01139336f, 0.03847792f, 0.13927147f, 0.08610188f, -0.04235362f, -0.02659876f, 0.11450455f, 0.01437645f, 
    -0.00007943f, -0.08629280f, -0.01604436f, 0.01548485f, 0.02992336f, 0.01402852f, 0.06687659f, 0.04472329f, 
    0.07845587f, -0.06896836f, -0.10758472f, 0.06244237f, 0.15000787f, 0.03335067f, -0.03495596f, -0.04382193f, 
    0.03916365f, -0.01391865f, -0.07376815f, -0.04656950f, -0.22105995f, -0.10269062f, 0.15223524f, -0.16636421f, 
    -0.06991300f, 0.14357272f, 0.03043180f, 0.15616091f, 0.00352429f, 0.00678627f, 0.13867378f, -0.10917154f, 
    0.12106554f, -0.09372073f, 0.09462098f, -0.00605197f, -0.07699891f, 0.00909227f, 0.01066706f, 0.02567456f, 
    -0.01628857f, 0.02180437f, -0.05852334f, -0.10612864f, 0.11070921f, 0.00054083f, -0.17454959f, -0.06268998f, 
    0.00775219f, 0.10986052f, -0.06042258f, -0.04010449f, 0.02424143f, 0.03902950f, 0.02826724f, -0.00119578f, 
    -0.25804612f, 0.03064939f, 0.02285096f, -0.00810195f, 0.04350812f, -0.04763384f, -0.07291570f, -0.01802901f, 
    0.02988397f, -0.09654528f, -0.07379321f, 0.08926870f, -0.07161272f, 0.19910693f, 0.00354874f, -0.05828258f, 
    0.05757647f, 0.01896225f, -0.15026750f, 0.09876861f, 0.11950754f, -0.01530544f, 0.02422435f, 0.03789004f, 
    0.00356991f, 0.13377945f, 0.00601346f, 0.09649976f, 0.05988846f, -0.01804544f, 0.01152074f, -0.04283695f, 
    0.08727577f, -0.05549273f, -0.15054964f, -0.00931279f, -0.08789935f, -0.07001015f, -0.11806942f, -0.10269371f, 
    -0.00092657f, 0.00079563f, -0.09383174f, 0.07009881f, 0.08450104f, -0.03997606f, -0.01994039f, -0.00634374f, 
    0.05724979f, -0.20993559f, 0.07392943f, 0.07593492f, -0.12028509f, 0.03632215f, -0.00662755f, 0.00870878f, 
    0.13202734f, 0.03394200f, 0.16670388f, 0.02666222f, -0.24862415f, -0.12943289f, -0.26287919f, 0.00217024f, 
    -0.08281427f, 0.03098863f, 0.04116606f, 0.06066497f, -0.09135258f, -0.16488905f, 0.08662731f, -0.05962001f, 
    0.07188187f, 0.04679122f, -0.04017713f, 0.12895374f, -0.01160406f, 0.00891955f, -0.07042138f, -0.04674845f, 
    0.11498193f, 0.06528598f, -0.17052187f, 0.07813440f, 0.17773579f, -0.08033075f, -0.09024686f, 0.03610115f, 
    0.02531144f, 0.03117468f, -0.07959713f, 0.00983970f, 0.01623264f, -0.07462713f, 0.01832497f, 0.00145573f, 
    -0.01389973f, -0.13070473f, 0.17119215f, -0.02967751f, 0.06639861f, 0.10282323f, 0.05863449f, -0.14873222f, 
    -0.05028732f, -0.06374082f, -0.03390084f, -0.10925934f, -0.14369459f, 0.07983338f, 0.18915439f, -0.09948589f, 
    0.05460207f, -0.01327332f, 0.06089709f, -0.04632972f, -0.00642085f, 0.07014128f, -0.15903984f, -0.08077647f, 
    -0.17890842f, 0.07882825f, -0.03205172f, 0.08693732f, 0.15314461f, 0.06280175f, 0.12030620f, -0.09814317f, 
    -0.00609685f, 0.09301166f, -0.07362282f, 0.09272909f, 0.39727908f, -0.43463615f, 0.23815532f, -0.21985832f, 
    0.03595310f, 0.03021885f, 0.04490723f, -0.03274168f, -0.06538265f, -0.01840849f, 0.03181684f, 0.01749054f, 
    0.27054796f, -0.16187738f, 0.02051361f, -0.06114101f, 0.01329067f, 0.07041453f, -0.01034711f, -0.05792018f, 
    -0.09488747f, 0.06144331f, -0.06757212f, 0.07516121f, -0.04004353f, 0.14555210f, -0.05898365f, -0.16544971f, 
    0.06400400f, 0.06508473f, -0.00612738f, -0.09214630f, 0.05031322f, -0.06134431f, 0.09910692f, -0.05815818f, 
    -0.13082489f, 0.27137488f, -0.38510826f, 0.01591344f, 0.01713282f, 0.15352555f, 0.04009317f, -0.06253160f, 
    -0.13189726f, -0.10383401f, -0.03519809f, -0.06440476f, -0.05420071f, 0.25303999f, -0.20647934f, -0.24497241f, 
    0.11511935f, -0.10154459f, -0.02311413f, -0.11397703f, -0.05559092f, 0.00578739f, 0.03322528f, -0.10978010f, 
    -0.13161059f, -0.10314558f, 0.17177655f, -0.13191259f, -0.03454942f, 0.08528809f, -0.07577101f, 0.06192463f, 
    0.02639491f, -0.18460333f, -0.07219928f, 0.01748108f, 0.18969615f, 0.21832468f, -0.26318380f, 0.12320432f, 
    0.14264302f, -0.19428566f, 0.02796161f, 0.02592384f, 0.02762484f, -0.02676473f, 0.06555629f, 0.05976639f, 
    0.02501018f, 0.05512482f, -0.05407831f, 0.11282258f, -0.01611580f, -0.00864290f, -0.11233556f, 0.03369858f, 
    -0.06880160f, 0.11391649f, -0.07169455f, 0.08171998f, 0.23472027f, 0.07943725f, 0.12938352f, 0.20185032f, 
    0.11317930f, -0.00406785f, -0.07542882f, 0.01181931f, -0.05884600f, 0.06755710f, 0.09370743f, 0.08770447f, 
    -0.05128414f, 0.08661212f, -0.16854545f, 0.08628009f, 0.09238155f, 0.07529945f, -0.15918167f, 0.06885140f, 
    -0.07089971f, 0.03472924f, 0.09706232f, 0.00841685f, -0.16542223f, -0.28884509f, 0.05699932f, -0.01470212f, 
    -0.01744581f, 0.06539476f, 0.00872398f, 0.10642857f, -0.01313344f, -0.12586804f, 0.02845436f, -0.06073801f, 
    0.07872555f, -0.33786869f, 0.03023412f, -0.21513627f, -0.17691955f, 0.12226059f, -0.00720190f, 0.00257821f, 
    -0.02865698f, -0.15851723f, 0.11066323f, 0.03908713f, 0.02722104f, 0.13555941f, -0.16776098f, 0.36654395f, 
    0.11536271f, -0.04363662f, 0.05022012f, -0.00384974f, -0.08492257f, -0.07184102f, -0.03485873f, 0.08680554f, 
    0.42460915f, -0.40688455f, 0.01605312f, 0.05995485f, 0.06823201f, -0.02171972f, 0.08664319f, 0.09968936f, 
    -0.10037600f, 0.07452895f, 0.06767766f, -0.02849416f, -0.10288040f, -0.10190865f, -0.00749941f, -0.24182747f, 
    0.04558041f, 0.08929596f, -0.12407566f, -0.02315270f, 0.02330261f, -0.06618471f, 0.08255199f, -0.03411663f, 
    -0.13017201f, -0.11849344f, -0.05181109f, -0.29060942f, -0.10817508f, 0.04896195f, 0.01962330f, -0.01944223f, 
    0.15252832f, -0.00963313f, 0.05342289f, -0.08292691f, -0.20430999f, -0.04729063f, -0.09061617f, -0.04690766f, 
    0.10634063f, -0.05296158f, 0.08761016f, 0.05950676f, 0.00784393f, 0.00632765f, -0.00111143f, -0.01008279f, 
    0.01330508f, 0.01064028f, -0.06943665f, -0.01804703f, -0.18427001f, -0.00771924f, 0.08530503f, 0.06613884f, 
    -0.05523515f, 0.07529715f, -0.03171369f, 0.07778500f, -0.03894820f, -0.15192679f, 0.14679776f, -0.26869023f, 
    0.07155777f, -0.06402046f, -0.02649077f, -0.00386289f, 0.09037088f, 0.05018111f, -0.00252972f, 0.11490373f, 
    -0.04057888f, -0.04033299f, -0.12607886f, 0.04480601f, 0.00541769f, 0.03998471f, -0.14123923f, 0.04060126f, 
    -0.03172608f, 0.01168978f, -0.00503420f, -0.08804028f, 0.31503090f, 0.18065348f, -0.33041820f, -0.34357646f, 
    0.03187153f, -0.05118734f, -0.09043251f, 0.07591625f, -0.11989564f, -0.15706028f, -0.11342298f, -0.05021705f, 
    0.30029312f, -0.03503853f, 0.22488634f, 0.01501762f, 0.08808901f, -0.04109501f, -0.04792279f, 0.05587799f, 
    0.02835293f, 0.13659598f, 0.10877241f, -0.08463129f, -0.23664851f, -0.03886222f, 0.13048397f, 0.03419004f, 
    0.16294371f, 0.09082000f, -0.07476530f, 0.01123535f, 0.14298245f, -0.04989482f, 0.06501034f, 0.07025015f, 
    -0.13025713f, -0.31851101f, -0.05060609f, -0.01667081f, -0.00078212f, 0.05153339f, -0.09997904f, -0.07729095f, 
    0.10261621f, 0.02286546f, 0.05060494f, 0.00340897f, 0.05187714f, -0.17922725f, -0.10111047f, 0.03908858f, 
    -0.00653996f, -0.00458573f, -0.05540845f, -0.00716459f, -0.06191357f, 0.01529720f, 0.13613917f, 0.12082041f, 
    -0.20476945f, 0.14001420f, 0.04912936f, -0.29102966f, 0.10079281f, -0.01932566f, -0.07164379f, -0.07648728f, 
    0.01177078f, 0.03609434f, -0.10438675f, -0.01945219f, -0.22065377f, 0.18239893f, 0.14703278f, -0.13704497f, 
    -0.01004524f, 0.10554773f, -0.00173320f, -0.05788312f, 0.04437903f, -0.03379197f, 0.04319778f, -0.06420516f, 
    -0.25424895f, 0.07739644f, 0.21253625f, 0.02605785f, -0.02272671f, 0.02540918f, -0.00928226f, 0.15676956f, 
    0.08982715f, -0.01267550f, 0.06566888f, -0.06967185f, -0.25595543f, 0.19674602f, 0.03542900f, 0.05111424f, 
    0.07366382f, 0.12847392f, -0.03032931f, 0.05821827f, -0.02978751f, -0.13063517f, 0.06567808f, -0.02047819f, 
    0.20623851f, 0.08911607f, 0.07781354f, 0.06430994f, 0.00955912f, 0.09393062f, -0.01458777f, -0.02351463f, 
    -0.14772521f, -0.02142842f, -0.10463961f, -0.15698946f, 0.11924635f, -0.21576598f, -0.00909318f, 0.08289047f, 
    0.09607646f, 0.04432353f, -0.06642223f, -0.01202064f, -0.01717130f, 0.06954750f, -0.04538152f, -0.12222411f, 
    -0.04637969f, -0.11342567f, -0.01064597f, 0.18655030f, 0.07239359f, -0.00241492f, -0.07472362f, -0.06407095f, 
    0.09610578f, -0.02240694f, 0.07954967f, 0.16381842f, -0.13831881f, 0.14394282f, -0.13592495f, 0.05697205f, 
    0.06597340f, 0.06906316f, -0.00950145f, -0.01323173f, 0.03282972f, -0.01552848f, 0.09958138f, 0.00975346f, 
    -0.27303442f, 0.05174101f, 0.02741809f, -0.09198172f, 0.04702628f, 0.00846373f, 0.05383534f, 0.08279225f, 
    -0.02071607f, 0.12555851f, 0.00531065f, -0.04515066f, -0.19491790f, 0.04052142f, -0.25394443f, 0.04500780f, 
    0.00388243f, -0.10505585f, 0.09111268f, 0.07262297f, 0.13049740f, 0.06514366f, 0.02689251f, 0.06973501f, 
    -0.07958450f, -0.19088195f, 0.00319065f, -0.07088689f, -0.06842013f, 0.05360631f, 0.05478107f, 0.04636216f, 
    -0.06266550f, -0.05584112f, -0.01224287f, 0.09489496f, -0.42548469f, 0.40315863f, -0.31700790f, -0.02279206f, 
    0.10710096f, -0.01650697f, 0.02717970f, -0.07222395f, -0.02622655f, -0.08049889f, -0.12715204f, -0.00394314f, 
    0.35999173f, -0.10233020f, 0.26676080f, -0.04729337f, -0.02067144f, 0.15044886f, -0.00945882f, -0.00949908f, 
    -0.12563631f, -0.00892991f, -0.04131140f, -0.05813478f, 0.18429214f, 0.05914213f, 0.14231029f, -0.16137265f, 
    0.06921688f, -0.05034460f, 0.01761854f, -0.01511257f, -0.08755618f, 0.06387321f, -0.04848057f, -0.19814068f, 
    -0.21671212f, -0.01741161f, 0.13173346f, 0.04325645f, 0.06899237f, 0.02237280f, -0.03509876f, 0.11380620f, 
    0.10762347f, -0.07451981f, -0.01124513f, -0.00935752f, 0.00701115f, -0.10355255f, 0.00275134f, -0.05453702f, 
    -0.09136568f, -0.00979162f, -0.01146461f, 0.03183101f, 0.04541499f, 0.01359926f, 0.07886068f, -0.10384718f, 
    -0.26014122f, -0.28284681f, -0.08786511f, 0.05839029f, -0.06891824f, -0.02887862f, 0.00786425f, -0.06011627f, 
    0.00453100f, 0.00094285f, -0.06426875f, 0.02913677f, -0.00542320f, -0.26286864f, -0.10156242f, 0.02008107f, 
    0.03109700f, -0.07098469f, -0.05739029f, 0.08813018f, -0.09614802f, 0.05541621f, 0.00369028f, 0.11028949f, 
    -0.07798424f, -0.26214203f, -0.10243063f, 0.15652359f, -0.03760938f, 0.06042008f, 0.00610959f, -0.06723809f, 
    0.09784361f, 0.00092834f, -0.06782759f, -0.05097227f, 0.18300001f, -0.23601973f, -0.19055352f, 0.11972108f, 
    -0.06224756f, 0.05335826f, 0.01289444f, -0.00386434f, -0.03108734f, -0.10154735f, 0.00471443f, -0.13000435f, 
    -0.31207666f, -0.06033279f, 0.23148318f, 0.18218094f, -0.05431655f, -0.02131118f, -0.01788149f, 0.16067274f, 
    0.03155857f, 0.01409017f, 0.06334753f, 0.07468548f, -0.21268626f, 0.03219645f, -0.00889444f, 0.08443899f, 
    0.03175997f, 0.02923792f, 0.00228821f, -0.03638990f, -0.19036756f, 0.06945600f, -0.01149091f, -0.00873308f, 
    -0.34966776f, 0.21034575f, -0.09803922f, -0.25018671f, 0.12052485f, 0.00030680f, -0.05428120f, -0.01972933f, 
    -0.07669159f, -0.02546719f, -0.17801666f, -0.16971080f, -0.23621309f, -0.20752321f, -0.01102532f, -0.25495771f, 
    -0.04715021f, 0.03606368f, 0.02263211f, 0.06400393f, -0.02677192f, -0.09390654f, -0.03122707f, 0.07906268f, 
    0.05126436f, -0.03231065f, 0.05738380f, -0.07026956f, 0.02670570f, 0.09198268f, 0.06439465f, -0.09214684f, 
    -0.02943503f, -0.07993963f, 0.07365153f, 0.00405130f, 0.42797253f, 0.00663298f, -0.06872732f, -0.09310002f, 
    -0.02612835f, -0.12794365f, 0.11842466f, -0.12225358f, 0.00289480f, -0.03538295f, 0.08554995f, 0.08838341f, 
    0.19851080f, 0.09805126f, 0.12160124f, -0.02560103f, 0.03984618f, 0.00444084f, -0.03817521f, -0.21024734f, 
    -0.04146078f, 0.08983430f, -0.02306063f, 0.24672215f, 0.09303690f, 0.17562543f, 0.07228740f, -0.08716264f, 
    0.05195336f, 0.08379414f, 0.00846421f, -0.08165389f, -0.11951995f, -0.01584290f, -0.06804787f, 0.12592033f, 
    -0.14807573f, -0.41221634f, 0.12462787f, -0.05294133f, 0.11995928f, 0.09754948f, 0.02950713f, -0.09043436f, 
    -0.04559461f, -0.01801917f, -0.07097850f, -0.07393347f, -0.06841748f, 0.13677786f, 0.16260377f, 0.13605563f, 
    -0.02052866f, 0.01375371f, 0.18369259f, 0.00086497f, 0.02586709f, 0.01883224f, -0.03307248f, 0.07409658f, 
    0.01276814f, 0.05385484f, -0.08144611f, 0.12426795f, -0.07269226f, 0.09355369f, -0.06968242f, 0.13161470f, 
    0.04029937f, 0.18360573f, 0.13973098f, 0.05608946f, -0.10046526f, 0.25899756f, -0.22417305f, -0.20411238f, 
    0.01330971f, -0.09359067f, 0.02486335f, 0.11775984f, -0.03035276f, 0.06080356f, 0.04067679f, -0.05399957f, 
    0.18828280f, -0.09756200f, -0.14077273f, 0.05400138f, 0.02004806f, -0.17586742f, -0.08493635f, 0.02375103f, 
    -0.03168431f, -0.06023851f, -0.13287951f, -0.02140278f, -0.31979004f, -0.08272877f, -0.13528843f, -0.05495648f, 
    0.18297565f, -0.00200572f, -0.09138466f, 0.05960145f, 0.04560457f, 0.08519575f, -0.03438618f, 0.07576966f, 
    -0.01319179f, 0.04106915f, -0.05529735f, 0.07726771f, 0.04460998f, 0.00285931f, 0.13624571f, 0.00826091f, 
    0.02335169f, -0.04276808f, -0.00733422f, -0.00388028f, -0.03701729f, 0.01903690f, 0.01722873f, -0.01028868f, 
    0.06026945f, -0.01058020f, 0.00814274f, 0.04516654f, -0.00252607f, -0.03360356f, -0.04207296f, 0.05589704f, 
    0.21406011f, 0.04946385f, 0.02358667f, -0.04769034f, 0.00152703f, -0.02323386f, 0.03706188f, -0.10034634f, 
    -0.01185507f, 0.06958504f, 0.00258243f, 0.03432494f, 0.11134256f, -0.09579287f, -0.10509488f, -0.08234148f, 
    -0.00103380f, 0.13355505f, -0.06139272f, -0.03905421f, 0.02025483f, 0.04231867f, 0.09464813f, -0.02810838f, 
    0.01553673f, -0.01401071f, -0.03324407f, 0.10781953f, 0.02932457f, 0.04145035f, -0.02032229f, 0.11622332f, 
    0.05783129f, 0.10556507f, 0.08505813f, 0.09971932f, -0.35262460f, 0.03528197f, -0.20111594f, -0.07771795f, 
    0.03200225f, 0.05569449f, -0.11575881f, -0.03089626f, 0.08207139f, 0.03503366f, -0.01671221f, -0.08081926f, 
    0.02511363f, 0.11297695f, -0.00646569f, 0.11732367f, -0.12863679f, 0.02929904f, 0.00198728f, -0.00677499f, 
    0.07758328f, 0.04117512f, 0.03416628f, -0.07665446f, -0.39547101f, -0.32180345f, -0.15247621f, -0.16201438f, 
    0.09688898f, -0.03752939f, -0.01615482f, -0.04753685f, -0.06205269f, -0.09317183f, 0.01615528f, 0.12086490f, 
    -0.16741197f, -0.27122796f, 0.07137147f, -0.10946579f, 0.07096108f, -0.09190264f, 0.07475705f, 0.11883924f, 
    0.06358523f, 0.14286071f, 0.04048561f, 0.14169180f, -0.23620141f, -0.22704487f, -0.12431477f, -0.18653274f, 
    0.05328236f, 0.03040050f, -0.02895196f, 0.04456259f, 0.01309400f, 0.05603160f, 0.12370552f, 0.08647269f, 
    -0.08095694f, -0.00897857f, -0.12102665f, 0.06197489f, 0.03573024f, 0.04182914f, 0.00570720f, -0.08578918f, 
    0.02987008f, 0.13795911f, 0.03394368f, -0.02652663f, 0.06206542f, 0.18247046f, -0.17327487f, -0.00463913f, 
    0.02640415f, -0.13823320f, -0.04401575f, 0.13088390f, 0.04440905f, -0.13173023f, 0.01651514f, -0.05073522f, 
    0.25422177f, -0.16368078f, -0.00582340f, -0.14044628f, -0.08246650f, -0.01383462f, 0.07440418f, -0.00982083f, 
    -0.02172536f, -0.02711685f, -0.10942513f, -0.08641291f, -0.21428163f, -0.20453952f, 0.04388603f, 0.09330101f, 
    0.09319455f, 0.02887367f, 0.01833802f, 0.02826517f, 0.09789623f, 0.02500783f, 0.01094367f, 0.10330898f, 
    -0.02383889f, 0.11682518f, -0.02608128f, 0.10124664f, 0.01042643f, 0.04021472f, -0.00390033f, -0.06657925f, 
    0.04499927f, 0.02430152f, 0.00690034f, -0.10614818f, 0.01821235f, 0.01198301f, -0.11957429f, -0.03285830f, 
    -0.03004534f, -0.13704613f, -0.00212749f, -0.17085332f, -0.09982306f, 0.04993952f, -0.02072291f, 0.04610613f, 
    -0.01740063f, 0.17666352f, 0.06822170f, 0.12129402f, 0.09158897f, 0.02559201f, 0.04106370f, 0.04891773f, 
    0.01960882f, -0.01665513f, 0.06602687f, -0.07766895f, 0.44493911f, -0.06033330f, -0.12713866f, 0.07881609f, 
    -0.04552722f, -0.29616946f, -0.03151727f, -0.00842661f, -0.15650564f, -0.10435719f, -0.04827181f, -0.14313893f, 
    0.10776018f, 0.04814794f, -0.00042633f, 0.03816063f, -0.01223540f, 0.05583790f, -0.04391498f, 0.05463406f, 
    0.01599447f, 0.07842068f, 0.05742674f, -0.05542418f, -0.58217174f, -0.22788042f, -0.08602569f, -0.20611505f, 
    0.03801137f, 0.01022226f, -0.09877381f, 0.02993727f, 0.04412099f, 0.03879614f, 0.03856528f, 0.03868166f, 
    0.30650806f, 0.26421607f, 0.08726901f, -0.19400281f, 0.00306911f, -0.05691367f, 0.11144384f, 0.13798784f, 
    0.00372411f, 0.02606660f, -0.04197885f, 0.08793171f, -0.06873572f, -0.41504404f, -0.12173475f, 0.25884485f, 
    -0.17209153f, -0.02649895f, -0.15379041f, 0.15398523f, 0.02477717f, 0.21203537f, -0.00653833f, 0.08053134f, 
    -0.03127605f, 0.11926849f, 0.02841333f, 0.03440553f, -0.05737681f, 0.02106558f, -0.06722855f, 0.01320990f, 
    0.06525657f, -0.17846733f, -0.03808358f, -0.19055089f, 0.08178647f, 0.06042760f, 0.05942260f, -0.02035991f, 
    -0.02790226f, 0.02627356f, 0.04142135f, -0.03744552f, -0.03965895f, 0.01802298f, -0.02716598f, 0.06266908f, 
    0.16424553f, -0.00770798f, -0.07702619f, 0.05951541f, -0.07628359f, -0.06985279f, -0.00994194f, 0.04897086f, 
    0.08574510f, 0.07461680f, 0.02198956f, 0.04651519f, -0.23876181f, 0.19518341f, -0.03692426f, -0.23844956f, 
    0.00169473f, 0.03780385f, -0.03535826f, -0.02214789f, 0.07529590f, 0.08651707f, -0.00185438f, 0.01821204f, 
    -0.12061576f, 0.04169398f, 0.04164751f, -0.02293161f, -0.01501007f, 0.05393169f, -0.07866964f, -0.07289446f, 
    0.05152583f, 0.00914658f, 0.08627229f, 0.10027351f, 0.16406007f, 0.14773878f, -0.14243507f, -0.03729814f, 
    -0.18731408f, -0.00575712f, -0.06668623f, -0.08335227f, 0.17878906f, 0.02406874f, 0.04888303f, -0.07156099f, 
    0.30781502f, 0.04078093f, -0.11424191f, 0.02229110f, -0.09211924f, -0.23181356f, -0.00630020f, 0.01992075f, 
    -0.00520437f, -0.16177391f, -0.19894788f, 0.00954562f, 0.17900324f, 0.12717932f, 0.01906174f, -0.06122342f, 
    0.06453685f, 0.15520433f, 0.02830103f, 0.01350245f, 0.10180361f, -0.08425189f, -0.05003175f, -0.08657626f, 
    -0.36541393f, -0.15663050f, 0.06371381f, -0.25986362f, 0.14005296f, 0.03494188f, -0.05771895f, -0.03289024f, 
    0.05120653f, -0.14643008f, -0.08213028f, -0.06251963f, -0.07801202f, -0.17404714f, -0.04341567f, -0.01841619f, 
    -0.04271864f, -0.23567037f, 0.03218680f, 0.15106273f, 0.02239005f, 0.11067445f, 0.03864001f, 0.20786344f, 
    0.17791496f, -0.12232953f, 0.07805628f, -0.19498298f, -0.06498653f, -0.04576876f, 0.05556160f, 0.07201102f, 
    0.05189633f, 0.06073442f, -0.13929099f, -0.03461888f, -0.38207614f, -0.19442433f, 0.01115166f, 0.06846044f, 
    0.05032827f, 0.05318817f, 0.04946641f, -0.10347413f, 0.08979546f, 0.01597000f, -0.03434324f, 0.00294291f, 
    -0.15454882f, -0.10680050f, 0.07860253f, 0.03888429f, 0.11932641f, -0.01433529f, -0.04732225f, 0.10170768f, 
    0.02448901f, 0.14024250f, 0.07349963f, 0.20232314f, -0.02247869f, 0.13304467f, -0.13404673f, -0.16218697f, 
    0.01603150f, -0.02654247f, -0.16174126f, 0.05824700f, -0.08587712f, -0.14293283f, -0.03021858f, 0.02440160f, 
    0.06152171f, 0.02215667f, -0.19232492f, 0.07840136f, -0.11127812f, -0.05031680f, 0.03059881f, -0.08580586f, 
    0.09597660f, -0.01079337f, 0.02162315f, -0.11781705f, -0.29830840f, -0.24256724f, -0.11674792f, 0.00455108f, 
    0.01895444f, 0.02784808f, 0.00670602f, 0.09783832f, 0.10548454f, -0.02120235f, -0.00486211f, 0.07820110f, 
    0.04209576f, 0.05615501f, 0.04150772f, 0.22261360f, -0.04626824f, 0.04380720f, -0.09018005f, 0.04893182f, 
    -0.06006211f, -0.03828451f, 0.05272391f, 0.04520875f, -0.20437527f, -0.33293518f, -0.20134123f, 0.12258567f, 
    -0.05093524f, -0.01407133f, -0.17592026f, -0.01682905f, -0.03805389f, -0.02768690f, -0.14467521f, -0.04017561f, 
    -0.02220147f, -0.01308934f, -0.08352488f, 0.04347911f, 0.06817465f, 0.15556151f, -0.01785105f, -0.06199803f, 
    0.03091380f, 0.08362418f, -0.01417463f, -0.01233403f, -0.45735976f, -0.40431613f, -0.06158261f, -0.09022455f, 
    -0.04178043f, -0.01400397f, 0.06314148f, 0.05231160f, 0.00584705f, 0.06105401f, 0.10817173f, 0.05295017f, 
    -0.38394132f, -0.08494582f, 0.20679277f, 0.00802209f, 0.10107920f, -0.03562855f, -0.03751097f, -0.04992441f, 
    0.01879662f, 0.08702613f, -0.04689177f, 0.10433273f, -0.02116058f, 0.01963797f, 0.14442815f, -0.11793490f, 
    0.17654055f, -0.02375702f, -0.04855282f, -0.01956722f, 0.05353678f, 0.00192970f, 0.08562151f, 0.08047571f, 
    0.01827042f, -0.00333075f, -0.10299282f, -0.05017317f, -0.02350367f, 0.03551891f, 0.07283099f, 0.02172446f, 
    0.01004161f, -0.00206375f, 0.02060718f, -0.05255218f, 0.12887856f, 0.08948062f, -0.08955626f, 0.01126496f, 
    -0.04112233f, 0.08333313f, 0.00632517f, 0.00950589f, 0.02450553f, 0.00027717f, 0.10040081f, 0.06429824f, 
    0.13827194f, 0.04584454f, -0.05754000f, 0.06594875f, 0.08065702f, -0.04002866f, 0.00370089f, -0.06284463f, 
    0.01935718f, 0.05976333f, 0.09572193f, 0.07211195f, 0.25284630f, -0.01479462f, -0.01774444f, -0.06226180f, 
    -0.10648707f, -0.08751372f, 0.00221812f, -0.09112778f, -0.03767509f, 0.02028253f, 0.06573466f, -0.08805539f, 
    0.19561470f, -0.08282086f, -0.05528741f, -0.02426633f, -0.01863838f, 0.00314840f, 0.14007911f, 0.04551985f, 
    -0.00765975f, 0.12601377f, 0.06901087f, -0.02392580f, 0.05308936f, -0.02095681f, -0.01878749f, 0.03976292f, 
    -0.05430723f, 0.15664840f, -0.04446945f, 0.06359253f, -0.04218642f, 0.07350413f, 0.04115987f, 0.04316800f, 
    0.03536873f, -0.17840689f, 0.07816393f, 0.03620131f, 0.01576677f, 0.00383357f, -0.03139294f, -0.00704777f, 
    -0.02108666f, 0.02674998f, -0.13770624f, -0.03620069f, -0.02866952f, 0.18529479f, 0.00352304f, -0.00870168f, 
    0.03867733f, 0.10423104f, 0.12460504f, -0.03679074f, 0.10058928f, 0.02759260f, 0.01795022f, 0.08980549f, 
    -0.38577494f, -0.17549054f, -0.19117962f, -0.36174440f, 0.06395414f, -0.09292930f, 0.00272953f, 0.03337697f, 
    0.04203191f, 0.14438124f, 0.15477002f, 0.10200156f, -0.01400927f, 0.02531764f, -0.07015718f, 0.04413451f, 
    -0.09115130f, -0.10041028f, 0.03356868f, 0.01363144f, -0.00996615f, 0.03030220f, 0.04787911f, 0.00363821f, 
    -0.50267184f, 0.00193338f, -0.07464271f, 0.01127542f, 0.07070196f, 0.13033736f, 0.01120637f, -0.06830837f, 
    0.07559656f, 0.05932687f, -0.01204322f, 0.06093552f, 0.03120009f, -0.06700617f, -0.05311494f, -0.05257200f, 
    0.07872011f, 0.01740208f, 0.04363343f, -0.00712645f, 0.04405255f, 0.01289257f, -0.03041474f, -0.14232755f, 
    0.04189387f, -0.16345336f, -0.05821727f, -0.17955551f, -0.00763406f, 0.00875430f, -0.06748056f, -0.03243478f, 
    0.04503435f, 0.12783282f, -0.02768287f, 0.04771653f, -0.57745641f, -0.20445372f, 0.17913871f, -0.03315711f, 
    0.05168346f, 0.05639516f, -0.03006224f, -0.01536261f, 0.11463418f, -0.09243281f, -0.06807848f, -0.03835297f, 
    0.25244379f, 0.09515904f, -0.01087687f, -0.17023337f, 0.02158190f, -0.07864638f, 0.00043436f, -0.03477143f, 
    0.06889341f, -0.03000509f, 0.02999200f, -0.00888163f, -0.13031691f, 0.03856037f, -0.04942802f, -0.07675315f, 
    -0.02345452f, 0.10851788f, 0.02148234f, -0.08062753f, 0.11917207f, -0.19619910f, -0.00847998f, -0.17863409f, 
    0.19632123f, -0.06776085f, -0.07161804f, 0.05691605f, -0.03861827f, 0.01112531f, 0.01571274f, 0.09803040f, 
    0.06879763f, -0.01874955f, -0.15408787f, 0.01957210f, 0.05125022f, 0.07591904f, -0.03544967f, -0.10266843f, 
    0.00807946f, -0.10845721f, -0.05223810f, -0.00209395f, 0.07675321f, -0.12357670f, 0.09218059f, -0.08911227f, 
    -0.06824458f, 0.20835187f, -0.12911731f, -0.07508364f, -0.17966217f, -0.06581049f, -0.06842045f, -0.01839663f, 
    0.06926440f, 0.08244282f, 0.01269432f, -0.04581501f, -0.22882530f, 0.00123769f, 0.12076730f, 0.24850047f, 
    0.03052283f, 0.02573025f, 0.00419062f, 0.10461977f, 0.04734066f, -0.05313991f, 0.12881024f, 0.07483504f, 
    -0.20588525f, 0.11510177f, 0.09867281f, -0.03068841f, -0.00681703f, 0.03087414f, -0.13957790f, -0.07888704f, 
    0.00042940f, 0.03662592f, 0.06288915f, -0.05248506f, -0.19962887f, 0.03732237f, 0.08547904f, 0.03920708f, 
    -0.08973027f, 0.03305516f, -0.01485269f, -0.01936646f, -0.01049968f, 0.01659258f, -0.07325824f, -0.09551051f, 
    0.11690999f, 0.01805587f, 0.00567132f, -0.09287452f, 0.04170685f, -0.07676614f, -0.04285752f, 0.00975846f, 
    -0.01099870f, -0.02717750f, -0.02798641f, -0.00061386f, 0.14358939f, -0.10176012f, -0.14566083f, 0.22303391f, 
    0.01453435f, -0.04695617f, 0.05099811f, 0.05615263f, 0.13625157f, -0.10628729f, -0.02126744f, -0.07728259f, 
    -0.08003807f, -0.21952432f, 0.10435989f, -0.05187656f, 0.04619652f, -0.01785537f, -0.00619785f, -0.05085921f, 
    -0.04882069f, 0.00062907f, -0.10786168f, -0.07173057f, 0.16950870f, -0.09494683f, -0.13978121f, 0.01170395f, 
    -0.07425377f, 0.01019128f, 0.01312967f, 0.12980634f, 0.03309467f, 0.07828220f, 0.08533968f, 0.08427633f, 
    -0.42558047f, -0.00217065f, -0.05510049f, 0.06136132f, -0.13030282f, -0.04088658f, -0.02912800f, 0.04736876f, 
    0.03336186f, 0.05704033f, -0.03796015f, -0.06092195f, 0.11932916f, -0.17370945f, -0.12442280f, -0.27193260f, 
    0.03978420f, 0.02525750f, -0.05555738f, 0.06275516f, -0.04019078f, 0.00848684f, 0.07379718f, 0.02932317f, 
    -0.01541543f, 0.00996248f, -0.04627601f, 0.08985554f, 0.01761475f, -0.02347143f, 0.06426420f, -0.01601932f, 
    -0.00525430f, -0.05504033f, -0.05597251f, 0.02684065f, 0.06675556f, -0.15337226f, -0.14783376f, -0.05192471f, 
    -0.00329597f, -0.00002909f, -0.05489798f, 0.08838768f, -0.03896595f, 0.03385539f, -0.05946481f, 0.01612512f, 
    0.15272157f, -0.00710990f, -0.22625346f, 0.05599300f, 0.03445339f, 0.03954831f, -0.15410821f, -0.04305401f, 
    -0.02234226f, -0.05178527f, -0.04281307f, 0.08047660f, 0.00519755f, -0.00639685f, 0.17159741f, 0.09414283f, 
    -0.07576396f, 0.07916646f, 0.00034412f, 0.05029334f, -0.06218890f, -0.00192510f, 0.02887129f, 0.17099719f, 
    -0.27758795f, 0.12798806f, 0.00306905f, -0.00500224f, 0.06100628f, -0.13059194f, -0.05123819f, -0.03917640f, 
    0.06667325f, 0.00587767f, 0.06263387f, -0.07293580f, 0.20120360f, -0.13864402f, 0.00144088f, 0.04116886f, 
    0.04988811f, -0.03924346f, 0.05039292f, -0.00367547f, 0.08038332f, 0.02230675f, 0.10603011f, -0.04596143f, 
    0.11467219f, -0.14359425f, -0.07415488f, 0.17014317f, -0.14151016f, -0.06294125f, -0.02831223f, -0.02137638f, 
    -0.10504735f, 0.03589310f, -0.09951608f, -0.06250801f, 0.04470217f, 0.09812246f, 0.05269954f, 0.18164784f, 
    -0.06138911f, -0.02431677f, -0.00638994f, -0.01386022f, 0.09528046f, -0.07340546f, -0.11160700f, 0.00458598f, 
    0.23810542f, 0.04221000f, -0.21283180f, 0.05393280f, -0.12142482f, 0.12436152f, -0.07202690f, -0.03952067f, 
    0.05507040f, 0.02130944f, 0.05075141f, 0.02083415f, 0.02668809f, -0.28788716f, 0.12153701f, -0.17319764f, 
    0.00794157f, 0.05071326f, -0.01126336f, -0.12695745f, -0.00051777f, -0.00362709f, 0.09292503f, 0.15910220f, 
    -0.23209770f, 0.12813438f, -0.11601780f, 0.08059749f, -0.03087809f, 0.00988311f, 0.09710006f, 0.06514052f, 
    0.02347706f, 0.03388777f, -0.00833419f, -0.05804601f, 0.19259162f, 0.05806617f, -0.21764341f, 0.00743064f, 
    -0.05752512f, -0.07730491f, 0.01760550f, -0.01541314f, 0.12236225f, 0.12739925f, -0.01865441f, 0.05708043f, 
    0.05676604f, -0.00542293f, -0.24521224f, 0.20982733f, 0.03519298f, -0.11421426f, -0.04244488f, 0.12905174f, 
    0.05409661f, -0.00112094f, 0.01577594f, -0.14912228f, -0.17722698f, 0.14849098f, -0.00557543f, 0.11769322f, 
    0.14902173f, 0.03010126f, 0.08108220f, 0.02034801f, -0.03221490f, 0.06993064f, -0.01705471f, -0.01707952f, 
    0.00512064f, 0.24300067f, -0.24963906f, 0.12299675f, 0.03811489f, -0.06293450f, -0.02759095f, -0.12452658f, 
    0.14509092f, 0.04772779f, 0.05020405f, 0.04611541f, 0.06997066f, 0.09320760f, -0.03414750f, 0.20457083f, 
    -0.13579297f, -0.05603871f, 0.03466095f, 0.05603557f, 0.05337434f, -0.04360873f, -0.02724552f, 0.05131554f, 
    -0.20415728f, -0.03452844f, -0.01997889f, -0.00506739f, -0.04507963f, 0.01116334f, 0.04081567f, -0.09947402f, 
    -0.09530582f, 0.01038123f, -0.06277637f, -0.04696006f, 0.04638872f, -0.19650444f, -0.01006709f, -0.05688689f, 
    0.06494528f, -0.11885963f, -0.01996043f, -0.09457520f, -0.04039767f, 0.01059021f, -0.06480721f, 0.00591644f, 
    -0.27819628f, 0.12282395f, 0.15820964f, -0.02796502f, -0.04712125f, 0.00308020f, -0.10732093f, -0.00424096f, 
    -0.10337532f, 0.03767646f, 0.01811573f, -0.11282523f, 0.05444932f, -0.18135977f, 0.00788270f, 0.08746938f, 
    -0.06324019f, -0.02167950f, -0.04943022f, 0.05976059f, -0.07743555f, -0.06136708f, -0.01378454f, -0.05566232f, 
    0.04650652f, 0.05719806f, -0.03328235f, 0.03435550f, 0.02155414f, 0.08497532f, 0.14510760f, 0.04597266f, 
    -0.02482533f, -0.07131200f, -0.02869497f, -0.02272069f, -0.17820005f, 0.04523768f, 0.07921775f, 0.06852137f, 
    -0.01041439f, -0.05469111f, -0.01151338f, -0.07864361f, 0.01792338f, 0.11239120f, -0.06248223f, -0.00394754f, 
    0.22718246f, -0.17474551f, -0.17360443f, -0.22420597f, 0.03092954f, -0.03586161f, -0.02998196f, -0.00015859f, 
    0.03482841f, 0.03227382f, 0.01616072f, 0.08800523f, 0.19411442f, -0.19082323f, 0.08284289f, -0.13929352f, 
    0.07179741f, -0.00417504f, 0.09413616f, 0.09949870f, -0.03653568f, -0.00605825f, -0.02173105f, -0.04686568f, 
    -0.16282055f, -0.31994554f, 0.00549386f, 0.18931079f, -0.00223115f, 0.09152441f, 0.03283344f, -0.05311326f, 
    -0.04055244f, -0.03696249f, 0.00230848f, 0.04517037f, 0.04243664f, 0.00139269f, -0.00896324f, -0.10119656f, 
    0.09643184f, 0.04053046f, -0.00861919f, -0.04161974f, 0.01031524f, -0.05403730f, 0.01120414f, -0.01052621f, 
    0.05528506f, 0.23564515f, -0.02347746f, -0.02886148f, 0.05938772f, 0.06496768f, -0.09426437f, -0.11774027f, 
    -0.05854198f, -0.03044502f, -0.11423955f, -0.05090094f, -0.47830546f, 0.04657650f, -0.04876655f, -0.26817903f, 
    -0.04241319f, 0.12286938f, 0.01347129f, 0.11677275f, 0.04362812f, 0.01942817f, -0.03963006f, -0.03926981f, 
    -0.17491375f, -0.19516575f, -0.07906879f, 0.09884202f, -0.02969483f, 0.09426077f, -0.05598716f, 0.01631621f, 
    -0.03600544f, 0.01950267f, 0.05104408f, 0.16711822f, -0.41645071f, 0.08685619f, -0.21240035f, -0.07163505f, 
    0.10604646f, -0.02077429f, 0.07732008f, 0.11138032f, 0.07413329f, -0.01944223f, -0.01287478f, 0.02665597f, 
    0.03076692f, 0.06575463f, -0.06864639f, -0.03015407f, 0.18915746f, 0.00422952f, 0.08546979f, -0.13916589f, 
    0.02275302f, -0.04179545f, -0.07921991f, -0.02230510f, -0.31508070f, 0.23823172f, -0.15919912f, 0.19778666f, 
    0.16523328f, -0.03657597f, 0.01742718f, -0.03227041f, 0.05455244f, -0.02796865f, -0.02481120f, -0.00020769f, 
    0.10993772f, -0.06905115f, -0.07381506f, 0.29364777f, -0.11406067f, 0.07290276f, -0.00321461f, 0.07472163f, 
    0.00461678f, 0.04582226f, 0.06059157f, 0.01320533f, -0.18999538f, -0.23377956f, 0.00179514f, -0.10892093f, 
    0.07487015f, 0.07936165f, -0.00688977f, -0.04276618f, -0.00267867f, 0.02233289f, -0.07855800f, -0.09898093f, 
    0.43013489f, 0.16421069f, -0.04177335f, -0.10182723f, 0.02670328f, 0.02335017f, -0.07756241f, -0.05632387f, 
    0.10911553f, 0.00956470f, 0.01852813f, 0.08168898f, 0.05871375f, -0.11035353f, -0.10032026f, -0.21913864f, 
    0.11591345f, -0.09866083f, -0.19803929f, -0.07384375f, -0.09915488f, 0.09241559f, -0.10019534f, -0.09962258f, 
    0.11419126f, -0.15828139f, -0.10814065f, 0.10285056f, 0.05151008f, 0.05339191f, -0.03870441f, -0.05752338f, 
    -0.02365270f, 0.08046301f, 0.00597498f, 0.00217804f, -0.09978191f, 0.07448600f, 0.02292562f, 0.07295530f, 
    -0.08023290f, -0.04361864f, 0.04307385f, 0.05387520f, -0.09607898f, -0.03658614f, 0.03983030f, -0.01088903f, 
    0.23345111f, 0.06487258f, -0.08365066f, -0.12965091f, -0.06616051f, -0.09980947f, 0.02902053f, -0.06976576f, 
    0.00571986f, 0.07545410f, -0.08685150f, -0.04445691f, 0.04841803f, 0.04702449f, 0.08284288f, 0.11023061f, 
    -0.06517538f, -0.08483296f, -0.03448842f, -0.10180955f, -0.09048988f, 0.04765379f, -0.02298128f, -0.11475754f, 
    0.03169305f, 0.12803791f, -0.00248748f, -0.01509743f, -0.04776985f, -0.08257302f, -0.04378508f, -0.11086722f, 
    0.04859160f, -0.06081138f, 0.02063199f, 0.02506861f, -0.16934542f, 0.22952037f, 0.12693965f, -0.01148724f, 
    -0.04356593f, -0.06095595f, 0.03658476f, -0.09773736f, -0.12848023f, -0.02586542f, 0.06684385f, -0.09197125f, 
    0.09843443f, -0.15191184f, 0.01267362f, -0.04218706f, 0.09692419f, -0.06236216f, -0.00367678f, -0.08503968f, 
    0.00379858f, 0.02280384f, 0.20260598f, 0.06070634f, -0.39153066f, 0.17103802f, 0.02091249f, -0.05703051f, 
    0.03264798f, -0.04350106f, 0.10267875f, -0.11773928f, 0.12353815f, -0.11621700f, 0.07958361f, -0.09091183f, 
    0.33154696f, -0.02355422f, -0.32485980f, 0.00309792f, 0.06057202f, -0.04220893f, -0.02691072f, -0.04255693f, 
    -0.06316601f, -0.06119030f, -0.03543355f, -0.04623972f, 0.10542868f, -0.14859159f, -0.02831862f, -0.02880311f, 
    -0.04025599f, 0.07037120f, -0.02681357f, 0.01737616f, -0.06582292f, -0.07603695f, -0.13429429f, -0.03224016f, 
    0.48860064f, 0.10045974f, -0.14618668f, -0.21103561f, 0.05365312f, -0.04850316f, -0.08058224f, 0.09403285f, 
    0.03332578f, 0.08155991f, 0.02336071f, -0.02703340f, -0.21347292f, 0.08339088f, 0.00788556f, -0.10409760f, 
    -0.09433901f, -0.02472680f, -0.12382179f, -0.14963180f, 0.03845130f, -0.06757300f, 0.05674015f, 0.04135027f, 
    -0.38431680f, 0.23465610f, 0.14055808f, -0.09280882f, 0.01422703f, 0.01817249f, -0.05242091f, 0.15370731f, 
    0.02990320f, -0.10310411f, 0.04008947f, -0.14933079f, 0.41802907f, 0.13353026f, -0.17787859f, 0.08421144f, 
    -0.06078166f, -0.00194510f, -0.02464827f, 0.00938219f, 0.14868616f, 0.06602065f, 0.06950358f, 0.04420941f, 
    0.18038706f, 0.03647236f, -0.07189816f, -0.04669010f, -0.07763921f, 0.04369565f, 0.01894303f, -0.04518148f, 
    0.02071989f, 0.03861978f, -0.02659423f, -0.06673227f, 0.06139188f, -0.03265034f, -0.16764189f, 0.01723332f, 
    0.07136374f, -0.04313942f, -0.08983390f, 0.01017421f, 0.01725554f, 0.06855404f, 0.03881226f, -0.03754878f, 
    -0.29432961f, 0.07441092f, 0.00839815f, 0.05898375f, 0.06343490f, -0.00245697f, 0.04321727f, 0.06141040f, 
    -0.04983594f, -0.02048559f, 0.09603920f, -0.01227259f, 0.04791975f, -0.14847220f, 0.00633860f, 0.00158147f, 
    0.04202111f, 0.00327487f, 0.06475982f, -0.07138342f, 0.03693011f, 0.05978088f, -0.01316328f, 0.00550535f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.02311770f, 0.01679749f, -0.06600659f, 0.03485389f, -0.02296783f, 0.01891153f, -0.02319500f, -0.07735407f, 
    -0.03353335f, -0.00742021f, 0.07758465f, -0.00328195f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
