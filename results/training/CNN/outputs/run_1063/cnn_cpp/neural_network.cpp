#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.05831130f, -0.46691421f, -0.05771849f, 0.24427722f, -0.43211538f, -0.50178808f, -0.11596070f, -0.14843825f, 
    -0.07576951f, 0.18689351f, 0.39115015f, -0.25866434f, -0.31266415f, -0.10890366f, 0.02953003f, -0.45491046f, 
    -0.30852354f, -0.27425861f, -0.19390611f, -0.61894649f, -0.21171036f, -0.37621373f, -0.29226106f, -0.33466434f, 
    -0.34314334f, 0.35911790f, 0.64753854f, 0.36680976f, -0.14122567f, 0.05786670f, -0.39604339f, -0.17825204f, 
    0.18943456f, 0.25328413f, -0.09149154f, 0.18609323f, 0.11865761f, 0.07933848f, -0.04218297f, -0.06679258f, 
    -0.05598274f, -0.10987783f, -0.14229530f, 0.07469396f, -0.31462833f, -0.06397270f, 0.32260919f, 0.19197196f, 
    -0.13578579f, -0.05489049f, 0.23517016f, 0.25072524f, -0.26272589f, -0.22421037f, 0.26862550f, -0.07833648f, 
    -0.08069832f, 0.16896725f, -0.29868856f, -0.24878164f, 0.24560438f, 0.03269741f, -0.23203495f, -0.04510610f, 
    0.15010722f, -0.22960459f, 0.51977652f, -0.01016490f, -0.06696863f, 0.01860472f, -0.29144973f, -0.35841194f, 
    0.22468160f, 0.33991110f, -0.14082958f, -1.00288498f, -0.56375253f, -0.86868000f, -0.73709482f, -0.71988904f, 
    0.17577681f, 0.44467828f, 0.15407777f, -0.50011826f, -0.33881459f, -0.18423082f, -0.35252875f, -0.37844425f, 
    -0.21067798f, -0.24786058f, -0.01124519f, -0.12540027f, -0.38941169f, -0.05906212f, -0.27015081f, -0.20845243f, 
    -0.00751418f, 0.04746452f, 0.09563114f, -0.35409388f, -1.14590883f, -0.10164490f, 0.29094890f, -0.08678814f, 
    0.48824856f, 0.42583278f, -0.08599447f, -0.44167289f, 0.31396902f, 0.08545577f, -0.14603880f, 0.11240217f, 
    -0.13693999f, -0.17946212f, -0.09962610f, 0.19260144f, 0.08460362f, 0.01664334f, 0.07771797f, -0.01634994f, 
    -0.01885285f, -0.03543814f, -0.26908454f, -0.15064782f, -0.21571982f, -0.29700676f, 0.29328895f, 0.27909714f, 
    0.45245579f, -0.74302435f, -0.02266056f, -0.57033253f, -0.31197926f, -0.71918982f, -0.79900473f, 0.63005567f, 
    0.05960554f, -0.23015308f, -0.19109520f, 0.47772664f, 0.04352772f, -0.06767295f, -0.05606540f, -0.30439681f, 
    -0.10026932f, -0.09920324f, 0.25775248f, -0.03408512f, 0.17714651f, -0.21240605f, -1.11593354f, -0.55106974f, 
    0.40899590f, -0.56551641f, -0.57304770f, 0.44689929f, 0.26752302f, 0.00961465f, 0.16760243f, 0.30120683f, 
    -0.14276648f, -0.04295016f, -0.10558255f, 0.29958048f, 0.03928481f, -0.13984066f, 0.02773121f, -0.17839164f, 
    -0.25017101f, 0.04042664f, 0.05453649f, 0.10438309f, 0.36682755f, -0.03368266f, -0.07897376f, -0.78786123f, 
    -0.82258111f, -0.50137269f, 0.42502314f, 0.70172358f, 0.10526328f, -0.11825683f, -0.40623966f, 0.15510072f, 
    0.39702055f, -0.04511241f, -0.06961580f, -0.31842247f, 0.00190071f, -0.09828900f, 0.30508104f, 0.02746794f, 
    -0.00033456f, 0.37313870f, 0.21135528f, -0.06093312f, -0.45778745f, -0.27504104f, -0.02245654f, -0.29713762f, 
    -0.59573525f, -0.11581397f, 0.32923269f, 0.00095784f, 0.33140352f, -0.59278071f, 0.19568750f, 0.66473734f, 
    0.06547771f, -0.25696248f, -0.10468805f, 0.06311274f, -0.25297707f, 0.29312125f, -0.03683798f, 0.18561363f, 
    -0.12725568f, -0.25488666f, -0.04421180f, -0.08452594f, -0.23981483f, 0.23176184f, 0.32243207f, 0.16511360f, 
    -0.13316524f, -0.37884602f, 0.07676488f, -0.17938824f, 0.45865589f, 0.15123320f, 0.01436985f, -0.10748645f, 
    0.05777319f, -0.08685950f, 0.13666172f, -0.02241533f, -0.01625152f, -0.13966595f, -0.15951918f, -0.04888260f, 
    -0.07352467f, 0.47954762f, 0.07593539f, -0.26133227f, -0.06725223f, -0.49213272f, 0.33158538f, -0.25902152f, 
    -0.13658419f, -0.03917547f, 0.36916941f, -0.94278330f, -0.12159261f, 0.21962102f, 0.44641051f, -0.07039528f, 
    0.38924193f, 0.16186894f, 0.08261965f, -0.23081850f, -0.38009524f, -0.52746111f, 0.34191275f, 0.00739944f, 
    0.10964489f, -0.25113764f, -0.19071253f, 0.17442812f, -0.04185813f, 0.07905795f, 0.02397367f, -0.22032063f, 
    0.01911702f, -0.08142105f, 0.28297389f, -0.42179772f, -0.01550642f, 0.03923870f, 0.19593589f, 0.12283573f, 
    -0.06991174f, 0.32948038f, 0.21071741f, 0.17060946f, 0.04640986f, -0.29464126f, 0.31165522f, 0.32947618f, 
    -0.22798310f, -0.32069531f, -0.20396382f, -0.02543654f, -0.00834014f, -0.14982109f, -0.01546730f, 0.20097549f, 
    0.24659845f, 0.17821069f, -0.27077845f, 0.18668371f, 0.69554901f, 0.42661974f, -0.23902813f, -0.67438555f, 
    0.02417136f, 0.16210848f, 0.42005745f, 0.35124338f, -0.42337486f, -0.51321644f, -0.41435474f, 0.54785144f, 
    -0.34905070f, -0.13289304f, 0.41293380f, 0.42213091f, -0.01392412f, 0.12325499f, -0.35970297f, -0.17840677f, 
    0.02898328f, -0.30599064f, -0.09375986f, 0.18992254f, 0.11682156f, -0.32783177f, -1.02472079f, -0.93147612f, 
    -0.22501138f, -0.36295378f, 0.81670988f, 0.77855885f, -0.01628060f, -0.00143495f, 0.01027901f, 0.14056173f, 
    0.04629286f, 0.26124811f, -0.26879671f, 0.34449854f, -0.20021592f, 0.15258655f, -0.06766602f, 0.23264438f, 
    -0.10949551f, -0.18762486f, -0.33057147f, -0.09199525f, 0.04011272f, 0.03775204f, 0.41721472f, -0.16245003f, 
    0.22449104f, 0.38858137f, -0.69428742f, 0.08952770f, -0.42148411f, -0.16107157f, -0.24161933f, -0.16106790f, 
    0.25290549f, -0.39834160f, -0.45761639f, 0.00726854f, 0.40009400f, -0.16096543f, -0.27437401f, -0.02510719f, 
    0.16445109f, 0.32046130f, -0.04578699f, -0.15874301f, -0.22796491f, -0.18267094f, 0.07348030f, 0.06125733f, 
    0.21812034f, -0.13170341f, -0.25663456f, 0.24419786f, 0.13524893f, 0.15599586f, 0.04908925f, -0.08446973f, 
    0.19680744f, -0.04144783f, 0.12580061f, -0.11055957f, 0.01988136f, -0.10285606f, -0.12085089f, -0.03025648f, 
    -0.01276064f, -0.24850313f, 0.23208411f, 0.03509384f, -0.28487995f, 0.18020220f, 0.30280375f, -0.22874840f, 
    0.36981839f, 0.19355120f, -0.19417930f, -0.10504725f, -0.43584621f, 0.13003337f, 0.02600213f, -0.12785931f, 
    0.17875130f, 0.39201343f, -0.07572719f, -0.04240393f, -0.25145799f, -0.21589780f, -0.12539178f, 0.09798362f, 
    -0.11862092f, 0.13370335f, 0.05658877f, -0.24888939f, -0.34475341f, -0.31227553f, -0.38582721f, -0.40875700f, 
    -0.25969830f, 0.07121126f, -0.03504593f, -0.22257255f, -0.49608290f, -0.37652928f, 0.66265565f, -0.19238302f, 
    0.39565468f, -0.35935557f, -0.41987821f, -0.03750729f, -0.05363101f, -0.09606419f, -0.28377306f, -0.30615374f, 
    -0.23830123f, -0.15625408f, -0.12603071f, 0.33826807f, 0.05137782f, 0.24823920f, 0.17228906f, 0.03057869f, 
    0.15106463f, 0.05348127f, -1.01120937f, -0.23129222f, 0.16902019f, -0.23310766f, 0.03724660f, 0.26087573f, 
    -0.23893753f, -0.44590226f, 0.06883560f, -0.16293052f, 0.66011733f, 0.18096207f, 0.22910929f, 0.15688905f, 
    -0.15974002f, -0.27087837f, -0.26143470f, -0.06144658f, -0.13759127f, -0.24933456f, 0.27160886f, 0.15870681f, 
    0.02418076f, -0.09090541f, -0.06376025f, -0.84024715f, -0.32715979f, -0.39147791f, 0.52593493f, 0.21698828f, 
    -0.07919557f, 0.15232901f, 0.12712443f, 0.43799469f, 0.48448625f, 0.16419737f, -0.14167632f, -0.15385436f, 
    0.20997122f, 0.05543745f, -0.08285011f, -0.17416194f, 0.26001653f, -0.02631310f, -0.14124307f, -0.13061531f, 
    0.06233247f, 0.09927025f, 0.01954423f, 0.00231810f, 0.31761754f, 0.20425044f, -0.08626281f, -0.43194535f, 
    0.11135634f, -0.28698722f, 0.09455141f, -0.01835182f, 0.09218377f, -0.26983717f, 0.07620530f, 0.00335095f, 
    0.19366816f, -0.21378607f, -0.14806208f, 0.18908152f, -0.13402195f, -0.31471500f, -0.05313124f, -0.19284403f, 
    -0.14601597f, 0.03986402f, -0.44581860f, -0.39533368f, -0.34544897f, 0.37640932f, -0.46893623f, 0.40950701f, 
    0.02769553f, -0.12860484f, -0.22587807f, 0.36629552f, 0.59376729f, -0.51545709f, -0.54307920f, -0.02444368f, 
    -0.35679543f, 0.38585734f, -0.19442745f, 0.10030285f, -0.23514518f, 0.12135347f, 0.06940904f, 0.14212449f, 
    -0.25322899f, 0.22776906f, -0.33618739f, -0.38297409f, -0.11174700f, -0.11164095f, 0.93794584f, 0.75451607f, 
    -0.38925254f, 0.48682573f, -0.86359560f, -0.35427174f, -0.45486778f, -0.15020818f, 0.21036781f, -0.13791777f, 
    0.25188258f, -0.14134571f, 0.12290844f, 0.06265114f, -0.06976804f, -0.14270435f, 0.01568117f, -0.01716978f, 
    0.16236039f, -0.21549635f, 0.01750714f, 0.07605231f, -0.17646928f, 0.00327968f, -0.16370133f, -0.56036389f, 
    -0.67784548f, -0.41740364f, 0.24487948f, -0.31508815f, -0.07798672f, -0.31627020f, -0.12424278f, -0.35230201f, 
    -0.14358458f, -0.09690652f, -0.04443774f, -0.04856374f, 0.16801471f, -0.24853997f, 0.06710632f, 0.21261141f, 
    0.14753450f, 0.16052227f, 0.12916261f, 0.21609071f, -0.14409700f, -0.01501216f, 0.06158205f, -0.13374734f, 
    -0.54334807f, -0.15316458f, 0.24903934f, 0.30167311f, -0.14884694f, -0.31426042f, -0.09211195f, -0.30819800f, 
    0.16456847f, 0.48476326f, -0.21750225f, -0.08615005f, 0.15199545f, 0.14754702f, 0.21223761f, 0.10202939f, 
    -0.33006036f, -0.11330595f, 0.12866440f, -0.36195323f, 0.38717511f, 0.35183242f, -0.06402097f, 0.17913932f, 
    -0.12546317f, -0.10240531f, 0.14485961f, -0.05456261f, 0.23215145f, 0.34054044f, 0.17493549f, 0.07817763f, 
    -0.01513746f, 0.21785899f, 0.21457615f, 0.18211149f, 0.11530402f, -0.23026127f, -0.39083102f, 0.40663341f, 
    -0.01312920f, -0.17522551f, -0.15347658f, -0.03519615f, -0.21307564f, 0.33448011f, 0.08844775f, -0.14233851f, 
    0.10252119f, -0.20561063f, -0.07683799f, 0.03303080f, 0.18851261f, -0.04503752f, 0.06343691f, -0.29671627f, 
    0.04808280f, -0.27406618f, 0.16133697f, 0.19246376f, 0.14561945f, -0.07502283f, 0.13032350f, -0.12606323f, 
    0.02241240f, 0.17609295f, 0.10846774f, -0.13316742f, -0.06000664f, -0.21521312f, -0.30922484f, 0.52749765f, 
    -0.22421378f, 0.12122862f, -0.08124152f, -0.66803515f, 0.77249354f, 0.62791210f, -0.03148176f, -0.28211224f, 
    -0.13154019f, -0.11871263f, 0.14923780f, 0.23369879f, 0.15806638f, -0.30537724f, -0.16002932f, -0.01900348f, 
    0.01661066f, -0.08500041f, 0.15104987f, -0.00400520f, -0.22055364f, -0.14203392f, 0.10949112f, -0.21184278f, 
    -0.06345959f, -0.22946152f, -0.08037840f, -0.52152890f, -0.26977971f, -0.01127499f, -0.53363109f, -0.46665522f, 
    -0.08420099f, 0.32672977f, -0.28410277f, -0.28466630f, -0.01998197f, 0.07161640f, -0.12756421f, 0.16104883f, 
    -0.13165401f, -0.11440711f, -0.21899430f, -0.14052740f, -0.07293612f, -0.12597947f, 0.06437299f, -0.19485414f, 
    0.15001039f, 0.26445082f, 0.34269089f, 0.31148574f, 0.31888548f, 0.21071768f, 0.19281159f, 0.21080917f, 
    0.18727814f, 0.10520044f, -0.28940803f, -0.17250921f, -0.21347605f, 0.01008550f, 0.21724033f, 0.13852371f, 
    0.08550210f, -0.25588349f, -0.40678376f, 0.04407696f, 0.13291794f, 0.13591315f, -0.13034935f, 0.04328105f, 
    -0.04495931f, -0.00116915f, -0.16153832f, 0.09299348f, -0.04758659f, -0.04209913f, -0.08915229f, 0.07048552f, 
    0.04163744f, 0.32813874f, -0.10852370f, -0.02250596f, 0.19073200f, -0.26359996f, -0.14955889f, 0.29777104f, 
    0.45381376f, -0.36481380f, -0.06803959f, 0.23732680f, -0.03546012f, -0.19679376f, 0.06157375f, -0.01798397f, 
    0.12197947f, -0.21517207f, 0.07650967f, -0.02839445f, -0.12137508f, 0.25756857f, -0.22815906f, 0.45645744f, 
    0.53145844f, 0.01914137f, -0.02923001f, 0.12578532f, -0.49944761f, -0.48415247f, -0.14671114f, -0.55855584f, 
    -0.63573664f, -0.08213558f, 0.06575911f, 0.08335458f, 0.35802004f, -0.18376549f, 0.02944715f, -0.09714863f, 
    0.04008521f, -0.08564734f, 0.08913571f, -0.29758814f, 0.07385471f, -0.10692396f, -0.27772591f, -0.30099714f, 
    0.19577128f, 0.08205170f, 0.31255075f, 0.15222771f, 0.06554724f, -0.21615915f, -0.34732556f, -0.18252902f, 
    0.24778482f, -0.23377773f, -0.26397130f, -0.16460821f, 0.06716249f, 0.14871758f, 0.33861426f, -0.02109431f, 
    -0.19996680f, -0.07234181f, 0.22224914f, -0.16246226f, 0.02378972f, 0.05591023f, 0.15473664f, -0.17352504f, 
    -0.11692525f, 0.36828312f, 0.71204835f, 0.12606765f, -0.57602853f, 0.04097291f, -0.50048167f, -0.08551569f, 
    -0.20785531f, -0.30854526f, -0.08811534f, 0.18574007f, 0.15580523f, 0.11522779f, 0.19047576f, 0.32385108f, 
    -0.05757073f, -0.20180951f, -0.08927208f, -0.12516750f, 0.01003238f, 0.18105859f, 0.14008181f, 0.18088484f, 
    -0.04671136f, 0.02402483f, -0.22403309f, -0.15132044f, 0.09762792f, -0.22164713f, 0.34119865f, -0.72654116f, 
    -0.83188957f, -0.76483536f, -0.47948289f, -0.49735716f, -0.00697759f, -0.16239448f, -0.04499248f, -0.32167974f, 
    -0.08157156f, 0.07295319f, 0.04128918f, -0.16647983f, -0.28499457f, -0.20834030f, -0.26648661f, 0.05592004f, 
    0.07791131f, -0.20160022f, -0.07812821f, 0.83264863f, -0.23279448f, -0.17152597f, 0.16068250f, -0.00757224f, 
    0.01206711f, -0.28839505f, 0.26015785f, 0.47207272f, 0.09333850f, -0.18763554f, 0.08219428f, -0.16480562f, 
    -0.12700303f, -0.12993750f, -0.20644732f, 0.10258465f, 0.24888334f, -0.22333057f, -0.35299414f, -0.14967857f, 
    0.33809856f, -0.10282602f, -0.13539657f, -0.24109983f, -0.50205880f, -0.66169053f, -0.22582014f, -0.06030504f, 
    -0.10365776f, -0.34763467f, -0.49318564f, -0.24090102f, -0.00885848f, 0.09329687f, -0.24152078f, -0.14077225f, 
    -0.05478716f, 0.49463689f, -0.25968972f, -0.08693841f, -0.30041865f, -0.05299195f, 0.12602331f, -0.13473433f, 
    -0.23160803f, -0.21142213f, -0.31284001f, -0.30773589f, -0.16141035f, -0.40882000f, -0.59302080f, -0.64936382f, 
    -0.80919540f, -0.46484140f, 0.01207754f, 0.27069598f, 0.38511741f, 0.25947917f, 0.37673244f, -0.03020851f, 
    0.26771823f, -0.08055764f, -0.25715473f, -0.14560531f, -0.51167589f, -0.23216276f, 0.11159915f, -0.19124538f, 
    -0.01967437f, -0.07704350f, 0.08138316f, -0.18122992f, 0.18789659f, 0.27129030f, -0.73000604f, 0.03826621f, 
    -0.50289625f, -0.06358878f, -0.43293840f, 0.20535108f, 0.02892605f, 0.07200190f, 0.48149922f, 0.63856512f, 
    0.10837656f, 0.14017683f, -0.28108478f, 0.42067090f, -0.20221220f, -0.32414320f, 0.16334844f, 0.00561717f, 
    0.06225010f, -0.26692548f, 0.16993649f, 0.02571360f, 0.27091357f, -0.07684657f, -0.06301955f, 0.36798045f, 
    0.13615014f, -0.07668958f, 0.25891778f, -0.31976697f, -0.13147308f, 0.06845819f, 0.16177531f, -0.08139341f, 
    0.03621615f, 0.12212196f, -0.08706679f, -0.27002978f, 0.07133286f, 0.21543854f, 0.26587638f, -0.17863391f, 
    -0.20533778f, -0.00464460f, 0.04284055f, -0.23938034f, 0.34741780f, -0.01409556f, -0.05585827f, 0.00021222f, 
    -0.02281153f, 0.10135584f, 0.10527647f, 0.16373873f, 0.10695549f, -0.07287060f, 0.03513508f, -0.02384237f, 
    0.41485691f, -0.29276496f, -0.00929112f, -0.26612276f, 0.11370748f, 0.25465319f, -0.23857078f, 0.10432805f, 
    -0.00168082f, -0.28639385f, -0.00387239f, -0.01280629f, 0.33201727f, -0.17797783f, 0.12742823f, -0.24359569f, 
    -0.11292975f, -0.49536651f, 0.71987319f, 0.59034872f, 0.03425065f, -0.22510511f, 0.31097388f, -0.26840991f, 
    0.10336313f, -0.34090742f, -0.21325649f, -0.13863474f, 0.10729705f, -0.25143796f, 0.08940179f, -0.09858194f, 
    0.19268875f, 0.08167063f, 0.11852707f, 0.01048620f, 0.17056961f, 0.13629164f, -0.09718294f, -0.14054428f, 
    -0.15559767f, -0.26388037f, 0.45089510f, -1.07115757f, -0.40164569f, 0.27104920f, 0.70721012f, -0.24665448f, 
    -0.14142925f, 0.17367814f, 0.15228575f, -0.11076387f, 0.42349193f, -0.38910198f, -0.35459358f, -0.50476801f, 
    -0.02636167f, 0.20168883f, -0.02184048f, -0.03064282f, -0.25899720f, -0.06741444f, -0.14691056f, 0.05002109f, 
    0.15025367f, 0.03615595f, -0.11247389f, 0.47609943f, 0.38998300f, 0.25137067f, -0.63316435f, -0.78533381f, 
    0.48816982f, 0.24841626f, -0.17303222f, -0.13576114f, -0.41345742f, 0.24285093f, -0.17619233f, 0.16159143f, 
    0.16499686f, 0.08766609f, -0.21167380f, 0.26976752f, -0.24306403f, -0.24269253f, 0.06993834f, -0.32037675f, 
    0.02666231f, 0.40982771f, -0.11474812f, -0.11983114f, 0.61828077f, 0.77442926f, 0.04198726f, -0.63494503f, 
    -0.31303993f, -0.19660148f, -0.12199782f, 0.01302736f, 0.00091336f, -0.16068621f, -0.02571062f, 0.10273512f, 
    0.37630764f, -0.32726574f, 0.25643983f, -0.38585609f, 0.13170020f, 0.13014179f, -0.05968537f, -0.04370764f, 
    0.06834118f, 0.18522438f, -0.25589690f, 0.07191645f, -0.19285370f, -0.70342243f, -0.98021287f, -0.37658563f, 
    0.50416636f, 0.12970005f, 0.46400365f, 0.30399215f, 0.18274936f, -0.04763282f, 0.03209900f, -0.07063028f, 
    -0.23057298f, 0.07789090f, -0.27237087f, -0.15246452f, 0.06140548f, 0.22073761f, -0.13670190f, -0.01537886f, 
    0.04057130f, -0.34994203f, -0.19934796f, -0.08298516f, -0.11469559f, -0.36282727f, 0.27371931f, -0.36382377f, 
    -0.01025013f, -0.06484707f, -0.63711566f, -0.03694156f, 0.08695089f, -0.17450611f, -0.11007889f, -0.41235277f, 
    -0.23313512f, -0.34381586f, -0.22676571f, 0.45627415f, 0.33330339f, -0.00212769f, -0.11414452f, -0.21101065f, 
    -0.22445087f, -0.17019303f, -0.16924104f, -0.38959575f, 0.07155519f, 0.04866049f, -0.33240134f, -0.40562972f, 
    -0.23996449f, -0.14064012f, 0.28924295f, 0.25376037f, 0.35094568f, -0.18868545f, 0.06389166f, 0.34398526f, 
    -0.11414934f, 0.16905192f, -0.02402258f, 0.02211938f, 0.18266560f, -0.24060291f, -0.25893381f, 0.30358529f, 
    -0.12491639f, -0.13548608f, -0.02818344f, 0.12174071f, 0.16007432f, -0.04729412f, -0.16632964f, 0.22243594f, 
    -0.63965327f, -0.05184286f, -0.38275495f, -0.24453373f, 0.55152714f, 0.18583620f, -0.05619341f, 0.12779415f, 
    -0.16250366f, 0.34800565f, -0.06056683f, -0.42931670f, 0.39112115f, 0.25849271f, 0.00246159f, -0.20882186f, 
    0.19504698f, -0.05246919f, -0.08281086f, -0.11308344f, 0.20743413f, -0.08694480f, -0.08333828f, 0.20546359f, 
    0.01584418f, 0.04568138f, 0.27012888f, -0.02546342f, -0.64756656f, -0.14618830f, 0.68267608f, -0.26808265f, 
    -0.01272900f, -0.04495937f, -0.03880861f, -0.27010429f, 0.54244965f, -0.21315046f, -0.02325242f, -0.17898490f, 
    -0.07871068f, -0.02627832f, 0.23368558f, 0.03636778f, -0.23295128f, -0.12657031f, 0.19019748f, -0.32078350f, 
    0.05590673f, 0.34356573f, 1.05373883f, -0.86686528f, -0.73060161f, 0.28922281f, -0.16703054f, 0.40040541f, 
    0.36381832f, -0.04767403f, 0.12455200f, -0.35666361f, -0.17942214f, 0.13867906f, 0.13875066f, -0.30270046f, 
    0.17072268f, 0.01053988f, -0.18019874f, -0.17745045f, 0.05842138f, 0.16304541f, 0.19483557f, -0.03025279f, 
    -0.03869538f, 0.05609549f, -0.08353268f, -0.42584482f, 0.52384794f, 0.40290442f, -0.10657790f, 0.18093155f, 
    -0.22658302f, -0.19057834f, 0.05743592f, -0.12240712f, 0.15978850f, 0.22394301f, 0.06553411f, -0.30533758f, 
    -0.25996751f, 0.15718907f, 0.16895275f, -0.39303142f, 0.21457042f, 0.17274332f, -0.17790261f, 0.08087574f, 
    0.19698368f, -0.14051636f, -0.06332886f, -0.30475777f, -0.31248477f, -0.44364187f, -0.24098392f, -0.45245945f, 
    -0.61257392f, -0.03589908f, -0.27104029f, -0.59844226f, -0.57046014f, -0.38376412f, -0.03311149f, 0.14403456f, 
    0.26415715f, 0.44808105f, 0.27376908f, 0.05828809f, -0.03116162f, -0.18020490f, -0.24413978f, -0.26083267f, 
    -0.34230390f, 0.22763330f, 0.03866811f, -0.06703735f, 0.06531441f, 0.45628625f, -0.38934341f, -0.29340556f, 
    0.21414034f, -0.20575450f, -0.16605410f, 0.15264811f, 0.19826674f, -0.03337254f, 0.05366932f, -0.17099740f, 
    0.40173346f, -0.01946648f, -0.23220076f, 0.05241334f, -0.42432567f, 0.09795915f, 0.24708055f, 0.00663686f, 
    0.01009286f, -0.19665487f, 0.12386425f, -0.10611433f, 0.44756657f, -0.20707606f, -1.05423248f, -0.19645260f, 
    0.40295815f, -0.53109896f, -0.35005862f, 0.04741329f, 0.30259737f, 0.05452071f, 0.45674136f, 0.45970613f, 
    0.22480531f, 0.26138824f, -0.04304522f, -0.20995361f, -0.31802893f, -0.17405438f, 0.02199925f, -0.16308481f, 
    -0.06435230f, -0.10402618f, -0.04618467f, -0.14089255f, -0.01357798f, -0.26593786f, -0.01450384f, -0.42712599f, 
    -0.04528670f, -0.16424261f, -0.09560920f, -0.39749971f, -0.34791857f, -0.02374363f, 0.53042138f, 0.40882695f, 
    0.25965878f, -0.34217727f, -0.30082211f, -0.06914945f, 0.26052415f, -0.22227196f, 0.25144222f, 0.25943157f, 
    0.27250567f, -0.16550256f, 0.16416478f, -0.39253291f, -0.34268710f, -0.09752311f, -0.07339552f, -0.17349128f, 
    0.41185483f, 0.85959208f, -0.10846770f, -0.20137596f, -0.18764138f, -0.43702871f, -0.14946677f, 0.27157524f, 
    -0.09572554f, -0.27541730f, -0.31798375f, -0.35219470f, 0.29540387f, 0.09589576f, -0.49216160f, 0.23172046f, 
    0.20603935f, 0.02501260f, -0.11991889f, -0.01726535f, -0.10276589f, 0.21179640f, -0.00887900f, 0.20983250f, 
    0.06887230f, -0.84029490f, -0.45498008f, 0.04206710f, 0.43794900f, -0.08681402f, -0.76916164f, -0.00416944f, 
    -0.46935010f, 0.38016954f, -0.11485630f, -0.27565095f, 0.86373359f, -0.11586810f, 0.38987845f, -0.36053479f, 
    -0.27176884f, 0.12863897f, 0.21689697f, -0.52944344f, 0.00493951f, 0.28584948f, 0.10466855f, -0.47367090f, 
    0.26726720f, 0.17021637f, 0.36273250f, 0.03355612f, 0.27410620f, 0.05623515f, -0.11391994f, -0.38103768f, 
    -0.28751981f, 0.37388161f, 0.09685940f, -0.35675821f, -0.05941288f, -0.18006961f, -0.00476059f, -0.20162094f, 
    0.26860806f, 0.19998784f, 0.26896793f, -0.08055622f, -0.18601134f, 0.21422201f, -0.18342938f, -0.22962438f, 
    -0.14528415f, 0.31016544f, -0.09380015f, -0.08579603f, -0.50458312f, -0.57758474f, -0.66096276f, -0.73812062f, 
    -0.18330002f, -0.49214065f, 0.17466149f, 0.29073477f, 0.02680295f, -0.36866894f, -0.13189691f, 0.30476752f, 
    -0.54322278f, -0.35183153f, -0.03140424f, -0.04843764f, -0.20119852f, 0.19037241f, -0.06983846f, -0.06017394f, 
    0.14910766f, -0.08038175f, -0.15266773f, 0.09005801f, -0.91567343f, -0.28808334f, -0.14322282f, 0.42675704f, 
    0.26080140f, 0.50847489f, -0.13572282f, -0.20192780f, 0.22118904f, 0.38428345f, -0.10954478f, 0.24394816f, 
    -0.24979945f, 0.10844618f, -0.19733390f, 0.03278019f, -0.15614384f, -0.21248090f, -0.01905341f, -0.37571916f, 
    0.03490888f, 0.05444752f, 0.12239791f, 0.41137227f, 0.25324750f, -0.84602720f, -0.57207024f, 0.15328389f, 
    0.24055190f, 0.20479776f, -0.48585755f, -0.25951743f, -0.35384575f, -0.68276876f, -0.52334559f, -0.02820130f, 
    -0.04510660f, -0.19639808f, 0.08769608f, -0.33625951f, 0.15317683f, 0.20669794f, -0.07277182f, -0.07865351f, 
    0.00061719f, 0.11136636f, 0.10292882f, 0.21841700f, 0.18947968f, 0.34581101f, -0.10395075f, 0.22865367f, 
    0.14819340f, 0.43907812f, 0.31751981f, 0.37361461f, -0.10099644f, -0.38592762f, -0.27070743f, 0.06671619f, 
    -0.17617720f, -0.09861836f, 0.01581051f, -0.16208261f, 0.08978919f, -0.17531712f, -0.14038292f, 0.17938443f, 
    0.20977050f, 0.06009904f, -0.09897830f, -0.31877917f, -0.02968793f, -0.14864491f, -0.27054358f, -0.05325718f, 
    -0.30780402f, -0.00922631f, 0.07235647f, 0.38822722f, -0.28459924f, 0.24577184f, 0.20600857f, 0.16378438f, 
    -0.43972492f, -0.01268050f, -0.36146346f, -0.21121083f, 0.13931446f, 0.05364418f, 0.04751429f, -0.08464892f, 
    0.09521359f, 0.00850643f, -0.29031587f, 0.25240746f, -0.22211856f, -0.25760716f, 0.18753630f, 0.31575191f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.14798208f, -0.05199174f, 0.23417513f, -0.35093543f, 0.05436380f, 0.19309445f, 0.27667171f, 0.05069099f, 
    0.18745528f, -0.10022622f, 0.27261040f, 0.11203717f, 0.31759113f, 0.21338958f, 0.10765666f, 0.31354305f, 
    0.01084516f, -0.20797504f, 0.20835249f, 0.02531199f, -0.06308981f, -0.07196292f, 0.25321686f, -0.12388509f, 
    0.00416038f, 0.03128311f, 0.29224229f, 0.13175601f, -0.23223470f, -0.03769501f, -0.14717628f, -0.20947960f, 
    0.15312691f, 0.16149692f, -0.04832147f, 0.24258213f, -0.16897929f, 0.22938387f, -0.02211571f, -0.06750374f, 
    0.04237277f, 0.11915210f, 0.14319974f, 0.25648907f, 0.36539102f, -0.15606248f, -0.12361303f, 0.12544656f, 
    -0.08061147f, 0.17724107f, 0.28149396f, 0.04729658f, -0.31192654f, 0.29924911f, 0.09254501f, -0.06609272f, 
    0.16627817f, 0.23169109f, 0.05498827f, -0.02854175f, 0.09819760f, -0.00114881f, 0.04035549f, 0.11050174f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.15390733f, 0.17737000f, 0.14900577f, -0.03680010f, -0.07131494f, -0.19564880f, -0.13969268f, -0.19621658f, 
    -0.24272038f, -0.08062920f, 0.08020089f, 0.18220972f, -0.27252969f, -0.35083514f, -0.18239662f, 0.06475811f, 
    0.10315137f, 0.08639099f, -0.00251783f, 0.02685765f, 0.02607023f, -0.00096460f, 0.00397162f, -0.01849529f, 
    0.01731840f, 0.01038256f, -0.13301742f, -0.01839766f, 0.07908981f, 0.02304525f, -0.21528551f, -0.03490755f, 
    -0.11756318f, 0.07068895f, -0.02588050f, -0.03299024f, 0.28815687f, 0.07938763f, -0.08526376f, -0.04719121f, 
    0.17965928f, 0.19112901f, 0.17182356f, 0.13215636f, -0.02907488f, -0.09756405f, -0.03235783f, 0.08656645f, 
    0.30271736f, 0.36573288f, -0.10934483f, -0.19888362f, -0.16864140f, 0.12490130f, 0.01379160f, -0.02205023f, 
    0.04172728f, 0.11469848f, 0.04204725f, -0.10695728f, 0.06281801f, -0.04450441f, -0.23908412f, -0.24855046f, 
    -0.05585646f, -0.01393829f, -0.21649072f, -0.00386396f, -0.01665003f, 0.05017692f, 0.05681745f, -0.09945320f, 
    0.05494286f, -0.18785517f, 0.01607104f, -0.15199266f, 0.04927452f, 0.14110629f, -0.02107894f, -0.02400877f, 
    -0.06114764f, -0.01700592f, -0.09739032f, 0.01984086f, 0.24948406f, 0.20192754f, 0.03523602f, -0.02895172f, 
    0.12875453f, 0.04315086f, 0.06040851f, -0.09179802f, 0.04604296f, 0.00563763f, -0.01867853f, 0.05862866f, 
    -0.40247387f, 0.03263787f, 0.13723931f, -0.00312954f, -0.05609038f, -0.10483875f, 0.07038485f, -0.02595186f, 
    -0.06621291f, -0.03661186f, -0.19250345f, 0.08984821f, -0.07039579f, 0.02748627f, 0.02938270f, 0.00638435f, 
    -0.01779938f, -0.03156814f, 0.03536715f, -0.02897661f, -0.12200298f, 0.06447523f, -0.11680230f, -0.01567595f, 
    0.12598707f, -0.34718224f, 0.27627152f, -0.17421357f, -0.07187014f, 0.01762500f, 0.09542429f, -0.02621591f, 
    0.04903840f, -0.04882320f, 0.01885875f, -0.07854310f, -0.09325306f, 0.01992428f, 0.00431734f, -0.08676851f, 
    0.00583969f, -0.04360998f, 0.06911439f, 0.01645548f, -0.07222509f, -0.00502049f, 0.10760556f, -0.11348926f, 
    -0.04045172f, -0.27968720f, -0.28817546f, 0.24805531f, -0.04322330f, -0.14043242f, -0.09708144f, -0.18388143f, 
    -0.02031181f, -0.04222044f, 0.01421900f, -0.32554457f, 0.24583337f, 0.11997526f, -0.31868553f, 0.01497222f, 
    0.15842867f, 0.14145525f, 0.03913947f, -0.28399935f, -0.04429775f, -0.06043270f, -0.10344756f, 0.10264704f, 
    -0.03530063f, -0.03066953f, -0.10986789f, -0.39662248f, -0.07142903f, -0.10643582f, -0.05326235f, -0.04237852f, 
    -0.04713624f, -0.01013723f, 0.05353796f, 0.03171502f, -0.27014342f, -0.25172570f, -0.20005439f, 0.10081017f, 
    0.03222639f, 0.00993190f, 0.05833822f, 0.03838059f, -0.03085800f, -0.10979274f, -0.06105302f, -0.09216362f, 
    -0.29874042f, 0.02581415f, -0.01049733f, 0.02400360f, 0.07459595f, 0.05455993f, 0.00314613f, -0.00559444f, 
    -0.03288768f, 0.04056842f, -0.01960767f, 0.15267837f, 0.17940207f, 0.07506696f, -0.34965491f, -0.11539298f, 
    0.00442008f, 0.12302084f, 0.03531514f, 0.04053386f, 0.03664359f, -0.03723193f, -0.04529899f, 0.02011378f, 
    0.19195452f, 0.26853225f, -0.06789824f, -0.29985890f, -0.05459855f, 0.10174707f, 0.02453366f, -0.00680031f, 
    0.14362033f, -0.05497270f, -0.03143387f, -0.03733260f, 0.00698247f, 0.11688284f, 0.07736551f, 0.01590309f, 
    0.06213160f, 0.02385181f, 0.05050820f, 0.01216657f, 0.03321487f, -0.02981111f, -0.13932770f, -0.07357495f, 
    -0.19755377f, -0.14830048f, -0.12921739f, 0.11495788f, -0.04857805f, -0.04094116f, -0.07973501f, -0.00261058f, 
    -0.10833517f, -0.05208044f, 0.11108298f, 0.16264714f, -0.08526086f, -0.53101540f, 0.04542097f, -0.12009495f, 
    -0.07184101f, -0.05541730f, -0.08920761f, 0.08540858f, 0.06566750f, 0.00466463f, -0.04600496f, 0.11507869f, 
    -0.28797498f, -0.34077922f, 0.08910480f, -0.17243196f, 0.00870549f, 0.05251149f, -0.18632826f, -0.00316034f, 
    -0.01616589f, 0.02753399f, -0.04053706f, 0.04676429f, 0.37998590f, 0.12581912f, -0.09192322f, -0.15917683f, 
    0.17228507f, 0.10834912f, 0.10388518f, 0.05326924f, -0.02204770f, 0.03551998f, 0.02107934f, 0.05724461f, 
    -0.12386529f, 0.23735344f, 0.15171383f, -0.03207035f, 0.08211071f, -0.11721274f, 0.11332612f, -0.09534768f, 
    0.05228909f, -0.11890203f, -0.12137041f, -0.13539962f, -0.13607380f, -0.13745859f, -0.21091765f, 0.04173389f, 
    -0.00626353f, 0.02682307f, 0.10942248f, -0.02542927f, -0.01019993f, -0.04063397f, 0.05090815f, -0.12438546f, 
    -0.12617110f, -0.00760807f, 0.09233493f, -0.12553515f, -0.17695768f, -0.03282315f, -0.02681669f, -0.21759349f, 
    -0.10865363f, -0.17144385f, -0.16407225f, 0.00936734f, -0.91239727f, -0.33385119f, 0.20891617f, 0.04316029f, 
    -0.00031098f, -0.03100185f, -0.00035002f, 0.05894981f, 0.10136046f, -0.09652297f, 0.00615143f, 0.00996135f, 
    0.20950994f, 0.09834097f, -0.07988229f, -0.14536835f, 0.10741343f, 0.18046217f, -0.07085543f, -0.19164041f, 
    -0.04350046f, -0.06388000f, -0.02047980f, -0.00167933f, -0.11871308f, 0.07087451f, -0.04035018f, 0.00399557f, 
    0.00038742f, -0.00453611f, -0.03792068f, 0.05766692f, -0.03410454f, -0.04470184f, 0.01583283f, 0.06454708f, 
    -0.15176861f, -0.01595900f, 0.09741695f, 0.04508344f, 0.04203295f, -0.01009369f, 0.03129181f, 0.01565503f, 
    0.02869496f, -0.11791924f, -0.03500814f, 0.08429937f, 0.08758434f, 0.05307917f, -0.10390709f, -0.00762893f, 
    0.06732214f, -0.02411194f, 0.00191254f, 0.11835884f, 0.03380237f, 0.03556703f, 0.01741903f, -0.00826232f, 
    -0.32674897f, 0.00975056f, 0.16354950f, -0.11859410f, 0.03598590f, -0.06556147f, 0.03458612f, 0.00145880f, 
    0.05818748f, -0.01366335f, 0.02122499f, -0.01613352f, 0.04597560f, 0.05455510f, -0.08031330f, 0.00414579f, 
    -0.04016782f, -0.12432975f, 0.01792552f, -0.07130924f, -0.03213602f, -0.01043128f, -0.04978342f, -0.13807859f, 
    0.29853037f, 0.23248547f, 0.04070213f, -0.10869146f, 0.06528967f, 0.04157750f, -0.06732617f, 0.05587247f, 
    0.00163568f, -0.00705695f, -0.01329515f, -0.00159396f, -0.71803141f, -0.24763888f, -0.34836388f, -0.03963692f, 
    0.02609574f, 0.06610831f, 0.03719333f, 0.01600546f, -0.04774535f, 0.05476268f, -0.03538511f, -0.02597739f, 
    0.26238978f, 0.20157780f, 0.09030848f, -0.10495532f, 0.12394305f, 0.08797868f, 0.12445148f, 0.03677186f, 
    -0.01929933f, -0.12603140f, -0.05819358f, -0.06755011f, 0.08969506f, 0.03753017f, -0.03958319f, -0.02811378f, 
    0.11713585f, 0.16182420f, -0.04526757f, -0.08911053f, 0.00530320f, -0.01224645f, 0.00061202f, -0.03524510f, 
    -0.21885866f, -0.10605927f, 0.12879817f, -0.00020454f, 0.09010651f, 0.08060978f, -0.00762164f, -0.02195696f, 
    0.01318438f, 0.12339576f, -0.06575700f, -0.07622989f, -0.11881308f, -0.02858530f, 0.03239733f, 0.01692468f, 
    0.04932062f, 0.02819404f, 0.03643098f, -0.05043993f, -0.04481556f, 0.01396779f, -0.02442960f, -0.01637302f, 
    -0.28324917f, -0.20278612f, 0.10693746f, 0.17095941f, 0.00195577f, 0.03632009f, -0.01141320f, 0.03614843f, 
    0.03495841f, 0.00267529f, -0.03952149f, 0.02685488f, -0.10394255f, 0.04842497f, -0.09630521f, 0.01230896f, 
    0.04522448f, -0.10214436f, -0.17859755f, -0.03454140f, -0.05479093f, -0.07849390f, 0.00901764f, -0.01985233f, 
    0.35210454f, -0.30037063f, -0.06581293f, -0.10147554f, -0.13136679f, -0.01688364f, 0.05952724f, -0.01748238f, 
    -0.02832964f, 0.01605127f, -0.09229277f, -0.01348766f, 0.25112721f, -0.78250891f, -0.47959185f, 0.09027430f, 
    -0.01970063f, 0.03609572f, -0.22671109f, 0.01518797f, -0.24349003f, -0.17930618f, -0.09533629f, -0.13852251f, 
    0.05677449f, -0.39225581f, -0.49438387f, 0.29462904f, -0.02813981f, 0.01067911f, -0.11582986f, 0.04160118f, 
    0.02311876f, -0.03209553f, -0.14220375f, -0.02834252f, 0.37866488f, -0.09228881f, -0.11104083f, -0.02536852f, 
    0.04121902f, 0.04379262f, 0.09208624f, -0.10125277f, -0.02637352f, 0.08071542f, 0.03703918f, 0.15578088f, 
    0.20180224f, -0.06051173f, 0.00300769f, -0.13878502f, 0.03679029f, 0.00422690f, -0.09819305f, -0.06641933f, 
    -0.00538808f, -0.02613961f, -0.01417428f, 0.09420075f, -0.01953654f, 0.11628763f, 0.07591221f, -0.01945851f, 
    -0.03275613f, 0.01769514f, 0.05832043f, 0.00817344f, -0.20105401f, -0.18042780f, -0.17590420f, -0.35098526f, 
    0.02982941f, 0.12239572f, 0.07180262f, -0.07710349f, 0.00314613f, 0.11274176f, 0.02141228f, 0.04628516f, 
    -0.17546771f, 0.00875046f, -0.04431969f, -0.15495183f, -0.02915579f, -0.22580437f, -0.34248945f, -0.12513699f, 
    -0.22578308f, 0.06075697f, -0.13206770f, -0.01338910f, 0.02039128f, -0.13423277f, 0.01261173f, -0.18708543f, 
    -0.06710507f, -0.07615713f, -0.24605584f, 0.12469314f, 0.03075432f, -0.13979158f, -0.01916430f, -0.07891465f, 
    -0.13947652f, -0.04181803f, -0.17246708f, -0.01850882f, -0.32270020f, 0.06181607f, 0.08107838f, 0.08228989f, 
    -0.00747136f, 0.04399123f, 0.05297514f, -0.02636178f, -0.00382933f, -0.03473968f, 0.01046582f, 0.04472771f, 
    0.28911635f, 0.08921506f, -0.18535343f, -0.21387616f, -0.00823543f, 0.04978599f, 0.02182730f, -0.12372895f, 
    -0.05552295f, -0.02402009f, 0.02362855f, 0.02386290f, -0.12707829f, -0.07899845f, -0.04239081f, 0.08900761f, 
    -0.05009382f, 0.00276118f, -0.04595455f, -0.05483494f, -0.03465134f, -0.04173398f, -0.14037472f, 0.06120652f, 
    0.03533598f, 0.04952465f, 0.14242196f, -0.07881118f, 0.01878059f, 0.06900242f, 0.05879402f, 0.08277141f, 
    0.00353094f, 0.07269108f, 0.01925359f, -0.07478747f, -0.10553305f, 0.09805506f, 0.16407165f, -0.02919355f, 
    0.10813722f, 0.11225457f, 0.03620279f, 0.10493086f, -0.12150604f, 0.09355475f, 0.15090071f, 0.06556176f, 
    -0.15316139f, 0.03022194f, 0.04309734f, 0.10744624f, -0.02707089f, -0.09256710f, -0.02878588f, -0.00723165f, 
    0.02043226f, 0.00898244f, 0.00549344f, -0.00197153f, 0.22504412f, 0.30071661f, 0.07484780f, -0.42843702f, 
    0.06936051f, -0.01794161f, 0.12736323f, -0.00260462f, 0.03207747f, -0.14204325f, -0.02822423f, -0.10562695f, 
    -0.03424040f, -0.04672543f, 0.08639801f, -0.07466408f, 0.02814486f, 0.07068469f, -0.00565651f, -0.02014743f, 
    0.00778050f, 0.05364932f, -0.00009646f, 0.04438064f, 0.20007917f, 0.05358425f, 0.05110387f, -0.05487993f, 
    0.14875311f, 0.10564479f, 0.02600260f, 0.03708719f, -0.01080101f, -0.03668169f, -0.01991933f, 0.06664958f, 
    0.03712657f, 0.15486942f, 0.20602377f, -0.26229790f, -0.05729745f, -0.03535866f, 0.13135137f, 0.00634858f, 
    -0.08191069f, -0.04239417f, -0.04722270f, -0.31728762f, 0.40315056f, 0.15882744f, -0.09744987f, -0.39270043f, 
    0.11077303f, -0.03717219f, 0.09776847f, 0.09731730f, -0.03039001f, -0.01161691f, -0.06567558f, -0.11442243f, 
    -0.25602689f, 0.13155328f, -0.09857285f, 0.05880624f, 0.02273969f, -0.04017106f, 0.01619335f, -0.01323322f, 
    0.01902175f, -0.01433042f, 0.03086228f, 0.12904604f, -0.04202752f, -0.28842589f, 0.03338302f, -0.01978953f, 
    -0.10200358f, 0.02192825f, 0.01118348f, 0.06823192f, 0.01099532f, 0.00833861f, -0.06172959f, -0.03136803f, 
    -0.06212292f, 0.04425887f, -0.04675692f, -0.35863551f, 0.01344997f, 0.01551342f, -0.03058836f, 0.06938343f, 
    -0.09721336f, -0.20690182f, -0.08335882f, -0.31514969f, 0.29775113f, 0.10395554f, 0.15906529f, 0.01310481f, 
    0.00137966f, -0.01880967f, -0.05920223f, 0.01378093f, -0.04639972f, -0.00537461f, -0.07119857f, 0.08188728f, 
    -0.00027829f, -0.01336477f, 0.01023793f, 0.11659367f, -0.14236370f, 0.02023226f, 0.21186866f, -0.04486283f, 
    0.02649140f, 0.19178091f, 0.01355045f, 0.07833125f, 0.33867589f, 0.15316571f, 0.32031876f, 0.10436203f, 
    0.18900916f, 0.01220633f, 0.11540990f, -0.11019859f, 0.00219844f, 0.01281985f, -0.03457135f, -0.00547230f, 
    -0.06302667f, 0.01550535f, -0.08351243f, 0.00553181f, 0.02434232f, 0.02634772f, -0.04217798f, 0.04063535f, 
    0.09463771f, -0.10911728f, -0.23465550f, -0.02350705f, -0.30159000f, -0.28972360f, -0.03275555f, -0.36036605f, 
    -0.05280072f, -0.32002878f, -0.07713746f, 0.19847266f, -0.04825155f, 0.02921361f, -0.03302365f, 0.10435847f, 
    -0.08802766f, 0.00192483f, 0.07030783f, -0.37267229f, -0.01156620f, 0.00929318f, -0.04165593f, 0.10269135f, 
    -0.12201358f, -0.04713338f, 0.13376445f, -0.10226312f, -0.04089969f, 0.05813511f, -0.06813910f, 0.00936319f, 
    -0.02168406f, 0.02640934f, 0.01616920f, -0.06009248f, 0.21170391f, -0.25819385f, -0.10534579f, -0.06828061f, 
    -0.21436863f, -0.26632953f, 0.10730269f, -0.00485662f, 0.04962704f, -0.01148397f, 0.08254115f, 0.07859648f, 
    -0.05150173f, 0.07074129f, 0.12570500f, 0.05009321f, -0.11867707f, 0.06011744f, 0.02631195f, -0.00815840f, 
    -0.01664606f, 0.08528768f, -0.03414808f, -0.00542536f, -0.10119927f, -0.31250530f, -0.47145846f, 0.16691197f, 
    0.25600764f, 0.04953743f, 0.28635472f, 0.19550711f, -0.02791555f, 0.06012628f, -0.03964528f, -0.09286334f, 
    0.10373516f, 0.01646886f, 0.06761917f, -0.09055223f, -0.03954342f, 0.02763855f, 0.07983635f, 0.08510684f, 
    -0.07954917f, 0.00906666f, 0.03162733f, 0.00686843f, -0.03187819f, 0.05505702f, -0.11591718f, 0.05908301f, 
    0.62828505f, -0.23045905f, 0.00094269f, 0.02864793f, -0.03120156f, 0.13156036f, 0.13396256f, -0.21088792f, 
    0.15034920f, 0.12845996f, -0.18592443f, 0.06712197f, 0.31146950f, -0.14595242f, -0.06826036f, -0.07940356f, 
    0.03494636f, 0.02652840f, 0.02188355f, -0.21041210f, 0.28801075f, 0.01276836f, 0.02410269f, -0.16066611f, 
    0.21564667f, -0.09843470f, -0.21705894f, -0.39478669f, 0.00606838f, -0.12383559f, 0.01045417f, -0.01411388f, 
    0.03527199f, 0.04799323f, 0.04579584f, -0.09331256f, 0.20091081f, -0.02880579f, 0.15487659f, 0.04734907f, 
    -0.00285838f, -0.02178933f, 0.05516792f, -0.01225541f, 0.13365953f, 0.06518443f, -0.02128208f, -0.17110404f, 
    0.07917751f, 0.04106393f, 0.02745244f, -0.04932608f, 0.03601763f, -0.01723591f, -0.12326642f, -0.04541743f, 
    -0.14062543f, -0.37306386f, -0.07982202f, -0.19854921f, 0.24660119f, 0.05347478f, -0.15667771f, -0.13374598f, 
    0.07040174f, 0.04104373f, 0.01220190f, 0.04761153f, -0.02618079f, -0.00479937f, -0.05566668f, 0.03648932f, 
    -0.47909239f, -0.35189477f, -0.34523338f, 0.08312154f, -0.00573595f, -0.03051966f, 0.02816718f, 0.20694883f, 
    -0.11196112f, -0.02105286f, 0.12209019f, 0.05594910f, -0.09228098f, 0.14597614f, -0.04844883f, -0.01444285f, 
    -0.05826296f, -0.05226596f, 0.01855031f, -0.03006714f, -0.11186015f, -0.00577928f, -0.11346920f, 0.14036992f, 
    0.03906096f, -0.13013580f, 0.04473316f, 0.00046368f, 0.02218452f, -0.01227758f, -0.03195047f, 0.02977691f, 
    -0.12968171f, 0.02562553f, -0.20995383f, -0.01355724f, 0.16321860f, -0.05355990f, 0.11271814f, -0.13492781f, 
    -0.05533770f, 0.04519600f, 0.10664343f, -0.27333173f, 0.12531379f, -0.33821088f, 0.06786279f, -0.00329696f, 
    -0.10591431f, -0.09104742f, 0.19517851f, -0.16972861f, -0.00895064f, -0.16850954f, -0.10044030f, 0.08738093f, 
    -0.02051468f, -0.06477778f, 0.04919669f, 0.09327317f, 0.01275939f, 0.15061788f, 0.23103927f, 0.02584735f, 
    -0.20300236f, -0.11637008f, 0.00476286f, -0.03942801f, -0.01912011f, -0.08282795f, 0.01043473f, -0.03740337f, 
    -0.34589604f, -0.02434680f, 0.07070436f, 0.02047132f, -0.13713765f, 0.05997054f, 0.09138534f, 0.18793868f, 
    -0.10353760f, -0.02445416f, 0.13574025f, -0.05655904f, 0.21748726f, 0.16297735f, 0.11970959f, 0.31984210f, 
    -0.04774145f, -0.04507368f, -0.06817916f, -0.00666252f, 0.02691028f, -0.06045809f, -0.05831718f, 0.00921367f, 
    0.02458227f, -0.07306698f, 0.00964884f, 0.02622967f, 0.02467026f, 0.01401387f, -0.09531232f, 0.13012125f, 
    -0.06799334f, 0.14070864f, 0.01360467f, 0.03840439f, -0.06059060f, 0.05552234f, 0.06038690f, -0.01214124f, 
    0.02903473f, -0.02651927f, -0.06190340f, -0.00315659f, -0.10833848f, -0.02855521f, 0.01851277f, -0.20203008f, 
    0.24740566f, 0.18599564f, 0.05772894f, 0.26483634f, 0.10020897f, 0.14571740f, 0.11076482f, 0.12039089f, 
    -0.04629115f, 0.00621594f, -0.05770599f, -0.08467878f, 0.13297489f, 0.10033678f, 0.09611426f, 0.12930501f, 
    0.00629520f, 0.01225092f, -0.03806057f, -0.10265698f, -0.05076102f, -0.04476701f, -0.02888736f, 0.04803345f, 
    0.09955585f, 0.10417026f, 0.00851204f, -0.03775277f, -0.09804579f, 0.00313468f, -0.07606924f, 0.03471687f, 
    0.07010938f, -0.10395351f, 0.13396885f, -0.11116940f, 0.05951335f, 0.02959065f, -0.35594538f, -0.14112368f, 
    -0.09874553f, -0.19270140f, -0.05910210f, 0.02171426f, -0.11189293f, 0.05131038f, -0.03676037f, 0.06104930f, 
    0.27558234f, 0.06531427f, -0.04132630f, -0.03117188f, -0.03419198f, -0.03484117f, -0.01820947f, 0.00184743f, 
    -0.02781661f, 0.05533753f, 0.07513637f, -0.04380761f, 0.09401773f, -0.12658823f, -0.05383738f, -0.03974041f, 
    0.07915925f, 0.05979669f, -0.03442783f, 0.07360245f, -0.01260644f, -0.04987533f, -0.00442185f, 0.11886460f, 
    -0.05310732f, -0.10133940f, -0.32968625f, -0.17743894f, -0.07428076f, -0.13080366f, 0.09944149f, 0.07326864f, 
    -0.03667218f, 0.07729653f, 0.00442116f, -0.00011868f, 0.49669105f, 0.41887864f, 0.20560776f, 0.02114931f, 
    -0.03498647f, 0.00210148f, -0.04668606f, 0.00202681f, 0.04462041f, 0.18400811f, 0.00226704f, 0.02626776f, 
    -0.03843077f, 0.00081457f, -0.06103697f, 0.19553669f, -0.08371043f, 0.02278251f, 0.10423360f, -0.00167380f, 
    0.06399458f, -0.05472600f, 0.07882863f, -0.03251757f, 0.05359130f, 0.03272229f, -0.19684389f, -0.25562945f, 
    -0.01012879f, 0.15052992f, -0.00861783f, 0.03539068f, 0.05728355f, 0.02672735f, -0.10540011f, -0.08785586f, 
    -0.52127367f, 0.00214468f, -0.07227941f, -0.33269355f, -0.09369525f, -0.00684243f, -0.02251557f, 0.13464856f, 
    -0.06435810f, -0.15635905f, 0.03352464f, -0.12582012f, 0.11722352f, 0.02905672f, 0.12472490f, 0.09609921f, 
    -0.02856843f, 0.05480557f, -0.07421354f, -0.05838202f, -0.02173886f, 0.04289698f, -0.01013452f, 0.00324696f, 
    0.16674493f, 0.17112336f, 0.13141648f, 0.18103984f, -0.03314348f, -0.05396674f, -0.05494677f, 0.03302148f, 
    -0.04368825f, -0.01951584f, 0.08967162f, -0.07408428f, -0.08528034f, -0.00379757f, 0.06277492f, -0.09349978f, 
    0.03964688f, -0.18040925f, -0.00363140f, 0.15485555f, 0.05139499f, -0.00615656f, 0.06095136f, -0.03883856f, 
    -0.33347386f, 0.09957252f, -0.20036867f, 0.13651499f, -0.01837477f, 0.05329502f, -0.04776071f, -0.11780862f, 
    0.08442786f, 0.14239348f, -0.17053832f, 0.11875476f, 0.23250817f, -0.06117169f, 0.15510976f, -0.10093891f, 
    -0.02249361f, -0.05016742f, -0.04461421f, 0.04999077f, -0.07408766f, 0.07978106f, -0.05753042f, -0.04043725f, 
    0.23307720f, -0.26858273f, 0.07140610f, -0.10430874f, 0.10239185f, 0.05826255f, 0.02905647f, -0.01012643f, 
    -0.05476489f, 0.02838201f, -0.05244120f, 0.19181451f, 0.02485061f, -0.05742273f, -0.01986854f, 0.01203073f, 
    0.04013935f, -0.04037071f, -0.00365650f, -0.11677318f, 0.07910295f, -0.30518651f, -0.16858761f, -0.27838141f, 
    0.16910778f, -0.05654198f, 0.35802811f, -0.13286093f, 0.12046648f, -0.04054137f, 0.16516265f, -0.12556833f, 
    0.08101118f, 0.02526220f, 0.04254792f, -0.14505091f, -0.01449612f, 0.08245165f, -0.01462199f, 0.07435372f, 
    -0.03259112f, -0.03688502f, 0.00682618f, 0.01554481f, -0.00229249f, -0.03541578f, -0.03506064f, -0.10293225f, 
    -0.31742099f, -0.13768044f, 0.05221673f, 0.08084349f, -0.05261770f, 0.01608886f, 0.06701577f, -0.02295880f, 
    -0.00364554f, -0.05662802f, 0.11692441f, -0.19710684f, 0.15716095f, 0.04140371f, -0.05187261f, -0.06114692f, 
    0.08666220f, 0.04370810f, 0.07309668f, -0.10213519f, -0.05711177f, 0.19050744f, -0.05670241f, 0.09162331f, 
    0.78070056f, -0.11517195f, -0.22706623f, 0.04610394f, 0.01576194f, -0.01254335f, 0.00254707f, 0.03270998f, 
    0.09939741f, -0.01817914f, 0.11888588f, -0.04251873f, 0.03585265f, 0.01029947f, 0.00955899f, 0.08291431f, 
    0.03871387f, -0.09592652f, 0.07862294f, 0.04768308f, -0.02345495f, -0.07955543f, 0.05557951f, -0.10935997f, 
    0.01003791f, 0.12039049f, 0.24845034f, 0.33428729f, 0.19717215f, 0.04403316f, -0.06242600f, -0.04255448f, 
    -0.01929338f, 0.08726855f, -0.02752390f, 0.03156794f, 0.20878263f, 0.05960457f, -0.00198012f, -0.01952472f, 
    0.07282697f, -0.10844895f, 0.00492082f, 0.06103175f, -0.14017114f, 0.07647622f, 0.02327498f, -0.03294358f, 
    0.12055823f, -0.02909525f, -0.14619891f, -0.25543571f, -0.05416004f, 0.01673548f, -0.06238556f, 0.02772308f, 
    -0.08100226f, -0.11499271f, -0.11116252f, 0.00670115f, -0.12858449f, -0.01794648f, 0.05022541f, -0.01132432f, 
    0.17980446f, -0.05797219f, -0.05388795f, -0.25451246f, 0.18427640f, 0.01972385f, -0.17219852f, -0.16355886f, 
    0.11112580f, -0.05650933f, 0.14414218f, -0.13328126f, 0.00438081f, -0.19983563f, 0.03282359f, -0.07660789f, 
    -0.07866018f, 0.01688790f, -0.00383246f, 0.07184786f, -0.47494492f, -0.08194833f, -0.17199491f, -0.09416400f, 
    0.01701380f, 0.05140148f, -0.14054134f, -0.05894281f, -0.01961479f, 0.01852574f, -0.07607318f, 0.06386312f, 
    0.03790838f, 0.06378505f, 0.10420600f, 0.03304657f, 0.03268360f, -0.01298478f, 0.05715834f, -0.10486749f, 
    -0.01476689f, 0.07242407f, -0.05699138f, 0.02671701f, 0.14337693f, 0.26956123f, -0.07351612f, 0.05409866f, 
    -0.14519973f, 0.10153271f, -0.05887824f, -0.19237579f, -0.00100483f, -0.00700106f, -0.02653120f, -0.01916035f, 
    -0.12132721f, 0.14152682f, -0.07686457f, 0.07027102f, -0.05086099f, -0.01423899f, 0.07909848f, 0.01065114f, 
    0.06758045f, -0.01873668f, 0.08210629f, 0.08856466f, 0.02619380f, 0.00316289f, 0.18127191f, 0.01249223f, 
    -0.06909645f, -0.02324504f, 0.13573168f, -0.05499201f, 0.02834668f, 0.01404387f, 0.00202848f, 0.02189405f, 
    0.11477645f, 0.11187455f, 0.06354323f, 0.08286455f, -0.05820809f, 0.00790493f, -0.03899361f, -0.01231808f, 
    0.08681628f, 0.04882945f, 0.10488065f, -0.03592872f, -0.24897888f, 0.07718188f, 0.17910847f, 0.01093493f, 
    -0.04988949f, 0.05890374f, 0.04845571f, -0.06651777f, 0.03710212f, 0.00812129f, -0.07502361f, -0.05685582f, 
    -0.29263362f, 0.09169762f, 0.11254795f, -0.12280712f, 0.01804223f, -0.02982443f, -0.01554786f, -0.01777392f, 
    -0.04081936f, 0.03396323f, -0.02107895f, 0.09607717f, -0.30990759f, -0.47534734f, 0.17579870f, -0.03360218f, 
    -0.02968532f, 0.01804955f, -0.00278225f, -0.04083770f, -0.02040603f, -0.01605281f, 0.02482059f, 0.03472639f, 
    0.01366496f, -0.06517702f, 0.07215539f, -0.02689683f, -0.05680657f, -0.22945943f, 0.19314185f, -0.13996916f, 
    0.05014479f, -0.00549490f, -0.05033487f, 0.04941508f, -0.55926847f, 0.18175671f, 0.51741350f, 0.03304880f, 
    -0.14414820f, -0.16459113f, 0.13963853f, 0.03867383f, 0.01449048f, -0.01039561f, 0.02069499f, -0.08464453f, 
    0.09640998f, -0.02169481f, -0.24606067f, 0.22504120f, 0.08461870f, -0.08544612f, -0.08961480f, 0.10598188f, 
    -0.03731473f, 0.00457853f, 0.00708421f, 0.02228805f, -0.48842853f, 0.12921591f, -0.05285108f, -0.40079671f, 
    0.14057319f, -0.13919246f, -0.05652634f, -0.03810322f, 0.06849542f, 0.03804595f, -0.14091134f, 0.03922553f, 
    0.31724784f, 0.11523207f, 0.50114286f, 0.44159710f, 0.02967399f, 0.00634811f, 0.11472353f, -0.02088075f, 
    0.08360943f, -0.11047725f, -0.02024733f, -0.00244114f, 0.02417692f, -0.06240838f, -0.00272118f, 0.13115907f, 
    -0.00000395f, -0.08632830f, -0.03326820f, 0.13956119f, 0.02410326f, 0.02207691f, 0.06701129f, 0.07241273f, 
    0.28605953f, -0.15732658f, -0.23461843f, 0.09335994f, -0.12144320f, 0.07946599f, 0.06682444f, -0.07217685f, 
    -0.00178921f, 0.05936317f, -0.03799334f, 0.05678571f, 0.01150977f, -0.09587362f, -0.04487969f, 0.02918019f, 
    0.06534149f, -0.03903819f, -0.02864194f, 0.00804812f, 0.06136973f, 0.07957847f, -0.21224974f, 0.04554965f, 
    0.07186349f, 0.18172292f, -0.12162499f, 0.14403987f, 0.01654329f, -0.00399579f, 0.00791156f, 0.01432541f, 
    -0.07780184f, 0.11539840f, 0.00908798f, -0.17124899f, 0.05105915f, -0.10224479f, -0.22480410f, -0.07414792f, 
    -0.00875219f, -0.00109770f, 0.04194504f, 0.02913387f, 0.03699446f, -0.10218666f, 0.07413616f, -0.06509640f, 
    0.05426935f, -0.04714129f, 0.22588581f, -0.10722523f, -0.14977385f, -0.28867254f, 0.03515548f, -0.05470299f, 
    0.00588531f, -0.02589076f, -0.21569306f, 0.01247359f, -0.05051161f, 0.01791113f, 0.46793759f, 0.11628307f, 
    -0.09247078f, -0.01708497f, 0.07045693f, 0.12482961f, -0.01012462f, 0.05909711f, 0.11045291f, 0.02760335f, 
    -0.57112008f, 0.24392048f, -0.17039099f, -0.23965612f, -0.08530466f, 0.07591178f, -0.10130383f, -0.10602579f, 
    0.03481257f, 0.02098405f, -0.05545474f, 0.02026931f, 0.07296687f, -0.09812322f, 0.05887566f, -0.00352167f, 
    0.02420656f, -0.08199591f, 0.09402002f, 0.02784137f, 0.00537213f, 0.01979035f, -0.05772591f, -0.02962766f, 
    0.02356511f, 0.07477307f, 0.03689663f, -0.01486668f, 0.03791527f, 0.02895980f, -0.05644879f, -0.14678752f, 
    0.07474288f, 0.17958272f, 0.14318097f, 0.10915570f, -0.31509879f, -0.08248106f, -0.05074742f, -0.41736144f, 
    0.11279749f, -0.03629722f, -0.02753131f, 0.14936453f, 0.00395670f, -0.00504207f, 0.02719985f, -0.14632030f, 
    0.26714343f, -0.06400311f, -0.01356119f, 0.03298554f, 0.14235570f, -0.08509493f, -0.07241379f, 0.08406996f, 
    -0.03831232f, -0.02683979f, 0.03565759f, 0.02712301f, -0.18306994f, -0.00537000f, 0.08699240f, 0.04578126f, 
    -0.01609208f, 0.04010119f, -0.01514825f, 0.06418742f, -0.07994202f, 0.05296335f, 0.06893916f, -0.04984222f, 
    -0.02572576f, -0.02383490f, -0.02207472f, 0.01271063f, -0.03189160f, 0.00106581f, 0.02072975f, -0.05000240f, 
    0.04436490f, 0.01147354f, 0.07042412f, 0.17994133f, 0.07462486f, 0.00780751f, -0.22458743f, -0.09572181f, 
    0.01343719f, -0.04923468f, -0.04730776f, 0.07896861f, -0.00685066f, 0.10830007f, 0.11956479f, -0.17079936f, 
    -0.52537465f, 0.19955616f, 0.33532628f, -0.08069149f, -0.02630752f, 0.14416081f, -0.16328715f, -0.20225513f, 
    0.03888254f, -0.04327916f, 0.00697396f, 0.10429405f, -0.22653097f, -0.38301536f, 0.06484962f, 0.00967387f, 
    -0.05571498f, -0.01319474f, 0.12254493f, 0.01014711f, 0.02310518f, -0.00172095f, 0.01378442f, 0.00444083f, 
    0.18534513f, -0.17838779f, -0.08735027f, 0.23362629f, 0.09066825f, 0.00311030f, -0.03823218f, 0.03234268f, 
    -0.11127730f, -0.18785141f, -0.08071018f, 0.03146448f, 0.02378842f, -0.43672597f, -0.13213848f, 0.08073264f, 
    0.00903196f, 0.01867099f, 0.03345579f, 0.07406595f, -0.01162982f, -0.00377539f, -0.13483365f, 0.11890095f, 
    0.05155487f, -0.03433532f, 0.04036926f, 0.06057692f, 0.11643480f, 0.02618622f, -0.06262632f, 0.14494357f, 
    0.14121228f, -0.10741874f, -0.10101344f, 0.15938538f, 0.18317980f, -0.02004267f, -0.12963437f, -0.00882176f, 
    -0.01803542f, 0.02112964f, -0.00436094f, 0.01151751f, -0.05469762f, 0.08509770f, 0.07665998f, -0.01603504f, 
    -0.15998143f, -0.21190873f, -0.03334532f, -0.09802771f, -0.01479810f, 0.06576048f, -0.14130044f, 0.02595972f, 
    -0.03060398f, -0.06793009f, -0.05501745f, -0.02616026f, -0.21468928f, -0.18549801f, 0.12453582f, 0.00589724f, 
    -0.02176791f, 0.03361211f, 0.03100024f, 0.05578394f, -0.00493187f, -0.03489202f, -0.03729189f, 0.00372055f, 
    -0.01829374f, 0.00715298f, -0.00796593f, 0.04074170f, 0.02221664f, -0.04653459f, 0.03347329f, 0.05181832f, 
    -0.17751002f, -0.10178111f, 0.19205987f, 0.06899597f, -0.29048422f, -0.15894787f, 0.16754349f, -0.19815671f, 
    -0.12032124f, -0.05518229f, -0.19624694f, -0.32692856f, 0.01432284f, -0.04666804f, 0.04565368f, 0.03316260f, 
    -0.28217864f, 0.16848981f, -0.09627987f, 0.14317256f, 0.01137519f, 0.00307911f, -0.01612045f, -0.00291393f, 
    -0.00806930f, -0.00695224f, -0.01979268f, -0.00330659f, -0.14658023f, -0.19622312f, 0.03091622f, 0.01264000f, 
    -0.00899575f, -0.17105621f, -0.23377901f, -0.16318138f, 0.04111798f, 0.03638157f, -0.05145211f, -0.04394975f, 
    -0.75692821f, -0.35780761f, -0.12785049f, -0.15328275f, -0.02866004f, -0.03721085f, -0.08950049f, -0.00980981f, 
    0.01644018f, -0.02330469f, -0.05149935f, 0.01163001f, -0.38268721f, 0.09928900f, -0.02158674f, 0.17095861f, 
    -0.02262180f, -0.00857632f, 0.01458184f, 0.02015083f, 0.01924735f, -0.02784215f, 0.05505149f, 0.03537745f, 
    -0.25593165f, -0.11259523f, 0.05269461f, 0.12449060f, -0.00276599f, -0.07906564f, -0.15460910f, -0.01295250f, 
    -0.01458523f, -0.00768463f, 0.07779472f, -0.04041319f, -0.03850134f, 0.57591194f, 0.31134570f, 0.21784610f, 
    -0.05452918f, 0.05298520f, -0.04071233f, -0.03020940f, -0.04729304f, -0.01097165f, -0.07226843f, -0.06971062f, 
    -0.02115301f, 0.20648438f, 0.16176865f, 0.18031976f, -0.00895983f, 0.07641719f, -0.00041606f, 0.00023327f, 
    -0.01820467f, -0.20064947f, -0.14409792f, 0.26454300f, -0.12707458f, -0.06254165f, -0.04747269f, 0.07145169f, 
    -0.03353044f, -0.00256737f, -0.01692413f, 0.02657316f, 0.01954337f, -0.04150026f, -0.14645013f, 0.21032283f, 
    0.01253217f, 0.10773408f, -0.26999301f, 0.00398156f, -0.01912608f, 0.03359523f, 0.02254579f, 0.06294678f, 
    -0.04252223f, 0.02013419f, 0.06067536f, -0.00608581f, 0.11392553f, 0.04230733f, -0.03010955f, -0.35893825f, 
    0.03589214f, 0.02663310f, -0.18822578f, -0.02230228f, -0.00960527f, 0.06284817f, 0.01538623f, 0.05757725f, 
    -0.10075173f, 0.13282131f, 0.04043492f, 0.42601913f, 0.04940698f, -0.07814335f, 0.01635597f, -0.08608274f, 
    -0.02344874f, 0.05176467f, -0.05358925f, 0.12342630f, 0.03568565f, 0.11558404f, 0.07281799f, -0.35620332f, 
    0.04508946f, -0.18032984f, 0.02344065f, -0.09592270f, 0.00505080f, -0.00092358f, -0.10182597f, 0.04176204f, 
    -0.13332419f, -0.00906941f, 0.38201144f, -0.10900516f, 0.05545935f, -0.06408358f, -0.14744401f, -0.12229332f, 
    0.04009270f, 0.01866321f, -0.02069197f, 0.07028374f, 0.00926320f, -0.05941090f, 0.13790391f, 0.07952397f, 
    -0.07575452f, -0.02894220f, 0.09319872f, 0.03554728f, -0.03678936f, 0.06933365f, 0.11609804f, -0.01105206f, 
    -0.38267013f, -0.09844103f, 0.07725725f, -0.20547001f, -0.04857465f, 0.08497399f, 0.11977228f, -0.30371103f, 
    -0.00125376f, 0.01586508f, 0.01695145f, -0.14516306f, -0.03041428f, -0.05565584f, -0.13359562f, 0.04126833f, 
    0.01451418f, 0.02692140f, -0.01283160f, 0.09823731f, 0.00719676f, -0.04389549f, -0.12978022f, 0.12421111f, 
    -0.09600013f, -0.25086781f, -0.03880785f, 0.21435608f, 0.00963639f, 0.02350228f, -0.00275618f, 0.05577802f, 
    0.11406877f, -0.09298725f, -0.01591778f, -0.05504861f, 0.10935456f, 0.04898980f, -0.04664174f, -0.03839573f, 
    0.19311322f, -0.01814819f, -0.19062649f, 0.17679271f, -0.01375792f, 0.04440575f, -0.08661765f, 0.09420109f, 
    -0.26257718f, 0.17812882f, 0.22555505f, 0.05041798f, -0.08670748f, -0.04981257f, 0.03316243f, 0.02299023f, 
    0.14186198f, 0.09164362f, 0.04292110f, -0.02965067f, 0.11945775f, -0.03386531f, 0.05313304f, -0.02732018f, 
    0.01716051f, 0.07041796f, -0.07932615f, 0.04510722f, 0.01232101f, -0.14971469f, -0.03061318f, 0.02713243f, 
    -0.45535812f, -0.57570124f, 0.00360108f, -0.39155316f, -0.13532400f, 0.02139808f, -0.11571349f, -0.15046144f, 
    0.04710296f, -0.01685677f, -0.03269969f, -0.02253395f, -0.19251913f, 0.10856912f, 0.09012154f, 0.03825657f, 
    -0.09243064f, -0.02285097f, 0.01857226f, -0.02257134f, -0.02421938f, 0.04688478f, 0.05733844f, -0.06064712f, 
    0.39393380f, 0.35536748f, -0.01427184f, 0.21663390f, 0.04888366f, 0.04518302f, -0.03200478f, -0.03036347f, 
    -0.01512072f, 0.05645400f, 0.07843089f, 0.11078954f, -0.03773268f, 0.11309385f, -0.00792428f, 0.09288400f, 
    0.03111376f, 0.03591252f, 0.07248449f, -0.06706698f, 0.00181674f, 0.07485773f, 0.13554654f, 0.03014171f, 
    0.02008226f, -0.23712714f, 0.20415266f, -0.29008827f, -0.06465577f, 0.05038417f, -0.01275260f, 0.05063006f, 
    -0.00910620f, -0.05213547f, -0.00742523f, -0.00315228f, 0.12708731f, -0.27864853f, -0.29769289f, -0.05971158f, 
    0.00819268f, 0.03383676f, -0.06602661f, 0.17896715f, 0.03814724f, -0.01419782f, -0.02045919f, 0.00880740f, 
    -0.11499085f, 0.05614486f, -0.09337916f, 0.04563180f, -0.03001552f, -0.04996049f, 0.11662712f, -0.11157921f, 
    -0.03244438f, 0.03992780f, -0.03700757f, 0.00195023f, -0.39775980f, 0.43454555f, -0.02397329f, 0.35460448f, 
    -0.16880552f, 0.10115163f, 0.14816716f, -0.06618787f, 0.02841414f, -0.01009505f, -0.00701002f, 0.01806938f, 
    -0.10218943f, -0.27537048f, -0.14027408f, 0.05396002f, 0.12495731f, -0.03759713f, -0.03895603f, -0.02327895f, 
    -0.05067590f, -0.20078936f, -0.27026129f, -0.03609961f, -0.25087902f, -0.29671246f, -0.45602641f, -0.28283119f, 
    -0.04320457f, 0.10669678f, 0.14136444f, 0.09330179f, 0.02131093f, -0.02560345f, -0.04333488f, -0.00448946f, 
    -0.04043003f, 0.06421693f, -0.07758462f, -0.20245162f, 0.01626125f, -0.01766494f, -0.01739468f, 0.06019399f, 
    0.04367334f, 0.01104256f, 0.05364701f, -0.09722952f, 0.01709586f, 0.01752264f, -0.19259995f, 0.22952911f, 
    0.03992150f, -0.00524939f, 0.07798019f, 0.04650427f, -0.03701773f, 0.04402808f, -0.00065333f, -0.03664603f, 
    -0.07319220f, 0.00885764f, 0.06222833f, 0.09632328f, -0.04245832f, -0.01914185f, -0.11430990f, -0.07584050f, 
    0.00812760f, 0.09489738f, 0.05048920f, 0.01137038f, -0.21345705f, -0.15219730f, 0.20660409f, -0.00253322f, 
    -0.04712139f, 0.02763060f, -0.31994087f, 0.00925613f, -0.10932916f, 0.00180044f, 0.06041002f, -0.09325544f, 
    -0.00207643f, -0.25327536f, 0.10977674f, 0.23829964f, -0.02165676f, -0.11335531f, 0.07961456f, -0.18731111f, 
    -0.00660903f, -0.12929618f, -0.13318217f, 0.17592169f, -0.00079359f, -0.15873209f, -0.01504197f, 0.22111066f, 
    0.05381652f, -0.07035591f, 0.04263057f, -0.01001978f, 0.04295253f, 0.02239264f, 0.04328224f, 0.06753473f, 
    0.26460791f, 0.37557048f, -0.18873486f, -0.24430813f, 0.03598241f, 0.08006158f, 0.01996930f, -0.00424789f, 
    -0.13124137f, -0.07733291f, -0.07324906f, 0.07533518f, 0.10865111f, -0.16761154f, 0.19231422f, 0.19485918f, 
    0.12105829f, -0.00399547f, 0.00812845f, 0.12122329f, -0.00876335f, -0.02524628f, -0.10904790f, 0.05275755f, 
    0.24704976f, -0.00892824f, 0.11078158f, 0.09558252f, 0.07737181f, 0.03642705f, -0.05067662f, -0.04569165f, 
    -0.09987590f, 0.09818099f, -0.04662924f, -0.01153312f, -0.12487799f, 0.30030319f, -0.30837321f, -0.14566590f, 
    0.00296327f, 0.00251453f, 0.06159059f, -0.06478215f, -0.06199423f, 0.04471025f, -0.04831049f, 0.03378745f, 
    0.34871393f, 0.19232950f, -0.09905481f, -0.40688539f, -0.03076733f, -0.03715316f, -0.13025326f, -0.00907652f, 
    -0.14857765f, -0.18472286f, 0.06335650f, -0.08727539f, -0.03930089f, 0.19344771f, -0.04401711f, -0.20285825f, 
    -0.02344162f, -0.09243093f, -0.01474948f, 0.19880210f, -0.16209877f, 0.15903027f, -0.05638951f, -0.02764130f, 
    -0.27787691f, 0.84204018f, -0.65671945f, -0.32757649f, 0.25261939f, -0.06635012f, 0.03870379f, -0.12194212f, 
    -0.01600661f, -0.04582612f, -0.12807441f, -0.34401250f, 0.00918685f, -0.10316171f, -0.00510619f, -0.34633392f, 
    0.01051250f, 0.09346069f, -0.02372700f, 0.10964302f, 0.06915031f, -0.01652221f, -0.07615513f, 0.04781190f, 
    -0.17706852f, -0.10792760f, 0.19265106f, 0.17256537f, 0.05514244f, -0.13516453f, 0.01109864f, -0.05310987f, 
    -0.24725091f, -0.08304679f, 0.10141121f, -0.03398246f, -0.28830209f, 0.12603368f, -0.05015006f, 0.12038380f, 
    0.20960324f, 0.01768911f, 0.06690279f, -0.09982917f, -0.08529285f, 0.06194082f, -0.01643132f, -0.00391250f, 
    -0.27567109f, -0.21079263f, 0.22381566f, 0.22421370f, -0.02169254f, 0.01394056f, -0.02649955f, 0.03348570f, 
    0.01304432f, -0.12754735f, -0.15241946f, -0.01857786f, -0.09635381f, 0.08928730f, -0.18974936f, -0.26004463f, 
    0.03031399f, -0.02724395f, 0.03651882f, -0.06686392f, -0.06774709f, -0.00975200f, -0.02989512f, 0.07486450f, 
    -0.05117531f, -0.13723411f, -0.00523341f, 0.17480755f, -0.09253387f, 0.04166036f, -0.08586574f, 0.00818332f, 
    0.00593206f, 0.06889481f, 0.10081954f, -0.11323197f, 0.05016220f, 0.07676794f, 0.04162280f, 0.15458103f, 
    0.04916144f, 0.05827761f, -0.07930923f, 0.13160154f, 0.13860905f, -0.01683654f, 0.17927040f, -0.01615419f, 
    -0.05076180f, -0.10007668f, -0.13240613f, -0.02660988f, 0.13788630f, 0.11343146f, -0.08873019f, -0.01986616f, 
    -0.11487409f, 0.07694722f, -0.07986687f, 0.05624016f, 0.16798881f, -0.02269019f, -0.03506180f, -0.35323691f, 
    0.26072887f, 0.04309276f, 0.01461359f, -0.15279859f, -0.11922334f, -0.04110989f, 0.05694403f, -0.11226977f, 
    -0.04353661f, 0.07943363f, 0.15274738f, 0.00022488f, 0.01451560f, -0.00405467f, -0.12053166f, 0.05665400f, 
    -0.13262689f, 0.03932090f, 0.04780423f, -0.06570556f, -0.14457516f, 0.46196637f, -0.15417355f, 0.30252296f, 
    0.01455414f, 0.01326847f, 0.06528119f, 0.16195135f, 0.03987353f, 0.04667396f, 0.09197804f, 0.02663088f, 
    -0.44120148f, -0.02558529f, 0.08232288f, -0.00895718f, -0.08577917f, 0.03555846f, -0.08539855f, -0.00181752f, 
    -0.04231863f, 0.05321459f, 0.00316479f, -0.04630620f, -0.16055995f, 0.01293515f, -0.09531005f, 0.11744604f, 
    -0.02583625f, -0.00481656f, -0.04402389f, -0.11546029f, -0.05611376f, 0.01018513f, -0.00028050f, 0.05524591f, 
    0.27502266f, 0.06334782f, 0.01184044f, -0.17847902f, -0.06313597f, -0.08307624f, -0.00355218f, -0.11222416f, 
    0.11747476f, -0.10772213f, 0.02232659f, 0.06595006f, 0.03087376f, -0.05146643f, -0.15599471f, -0.31138083f, 
    0.11614094f, 0.04643112f, 0.01360517f, -0.04922235f, -0.08186967f, 0.17127596f, -0.05200943f, 0.03004266f, 
    -0.03397905f, -0.17949867f, -0.07806436f, -0.23816900f, -0.20257115f, -0.03972280f, 0.07266805f, 0.04863638f, 
    -0.04820152f, -0.12139276f, -0.00795090f, -0.14357246f, 0.40315238f, 0.39690843f, 0.25306928f, -0.14079545f, 
    -0.23815422f, -0.00352717f, 0.04631278f, -0.03079523f, 0.04046945f, -0.02265273f, 0.10089574f, 0.04932374f, 
    0.08621172f, -0.07383444f, 0.01178926f, 0.21724264f, 0.04667346f, -0.12944451f, -0.04050009f, -0.16742517f, 
    0.01123353f, 0.10338768f, 0.02835355f, 0.02545535f, -0.34229586f, -0.19802007f, -0.08863055f, -0.20517088f, 
    -0.31107649f, -0.03380584f, -0.06134595f, 0.04567904f, 0.12145499f, 0.14269756f, 0.01843393f, 0.08460376f, 
    -0.02377431f, -0.29387677f, -0.01933220f, -0.27255726f, -0.08008055f, 0.09479582f, 0.17169747f, -0.14677727f, 
    0.16663752f, -0.05689871f, 0.26556700f, 0.13359673f, 0.05830279f, -0.19987886f, 0.26401818f, 0.15942515f, 
    0.01401763f, 0.01654576f, -0.04832708f, 0.12864116f, 0.13983598f, -0.03971379f, 0.10121342f, 0.10560609f, 
    -0.06844532f, -0.34467936f, 0.13531137f, -0.06270895f, -0.16268721f, 0.05058054f, -0.09819178f, -0.09671944f, 
    0.03090544f, -0.09770247f, 0.13496634f, 0.02066079f, -0.12436255f, 0.03117452f, 0.35461786f, 0.11315908f, 
    0.05872975f, 0.09513195f, -0.03269189f, 0.06957254f, -0.08124337f, -0.19276562f, 0.01231611f, 0.00256950f, 
    -0.01956466f, -0.09644093f, 0.03585108f, 0.07546354f, -0.02529470f, 0.07850011f, 0.04370380f, 0.09252253f, 
    -0.01320270f, -0.02842537f, -0.10425493f, -0.06048281f, -0.41874021f, -0.15872018f, 0.13491385f, -0.02845974f, 
    -0.07325374f, -0.07158080f, -0.18943711f, -0.03498646f, -0.01143866f, 0.20807016f, -0.13994288f, 0.05006670f, 
    -0.12751612f, -0.08309408f, -0.07588559f, 0.04740350f, 0.05179577f, 0.04588030f, -0.02470293f, -0.00440098f, 
    -0.10897751f, -0.05062322f, 0.17848954f, 0.02249493f, 0.13346724f, -0.04513510f, -0.04386274f, 0.18469077f, 
    0.08696494f, -0.02146877f, 0.06824238f, 0.01918481f, 0.08045942f, 0.09227797f, 0.07377877f, 0.07244977f, 
    0.42268133f, -0.24436647f, 0.03849453f, 0.17932184f, 0.12529412f, 0.11971161f, 0.06519694f, -0.22732659f, 
    0.02586861f, -0.02744096f, -0.04194421f, 0.11479004f, -0.52383947f, -0.22482190f, -0.07655601f, -0.08715641f, 
    0.05968651f, 0.04687557f, -0.11660138f, 0.07595658f, -0.07912331f, -0.21594037f, 0.13908572f, -0.10465895f, 
    0.12976478f, -0.38986745f, -0.06565974f, -0.33965191f, 0.07220459f, 0.06215254f, -0.00155836f, 0.07087170f, 
    0.06243538f, 0.08256189f, 0.16288155f, -0.29147458f, 0.12679793f, 0.38760573f, 0.21998769f, 0.02493817f, 
    -0.09815077f, 0.04680095f, 0.08641027f, -0.13937791f, 0.04578404f, 0.03375777f, -0.02267601f, 0.05153988f, 
    -0.29250947f, 0.65107727f, -0.10165334f, -0.04781362f, -0.06654215f, -0.05759990f, -0.07366652f, -0.08888772f, 
    -0.14091718f, 0.16252317f, 0.02955736f, -0.01039504f, -0.20140785f, -0.15773800f, 0.22283140f, 0.22002375f, 
    0.04182921f, -0.00001790f, -0.11761418f, -0.03909619f, 0.03848523f, 0.15945943f, -0.08463594f, 0.03367233f, 
    -0.47551042f, 0.03855741f, 0.30307642f, 0.03720298f, -0.17140903f, -0.16507483f, -0.14150870f, -0.04068242f, 
    -0.07669157f, 0.02748731f, -0.22438064f, 0.03543627f, -0.30012003f, 0.47207871f, -0.05553222f, -0.15574902f, 
    0.12843549f, 0.09862414f, 0.11864045f, 0.06681274f, -0.17520046f, 0.01395289f, -0.06791151f, 0.01360977f, 
    -0.17776178f, -0.16381933f, 0.02316297f, 0.18226168f, -0.13590115f, 0.01862092f, 0.06204676f, 0.06711089f, 
    0.02767320f, 0.09479424f, 0.03638833f, -0.02821236f, -0.05794896f, -0.16697781f, 0.00791895f, -0.59729052f, 
    0.15015368f, 0.05917927f, -0.03477252f, 0.12733977f, -0.09785178f, 0.04103102f, -0.05102719f, -0.02311975f, 
    0.17846727f, -0.08851306f, -0.23156032f, -0.24863118f, 0.20497647f, -0.09086789f, 0.12030233f, -0.24149436f, 
    0.09058727f, -0.11090915f, 0.08580544f, 0.05436154f, 0.13531780f, -0.05272382f, 0.00926206f, 0.09556884f, 
    0.04546749f, -0.04941745f, -0.19404329f, -0.03306713f, -0.14080358f, 0.04713233f, 0.00290185f, -0.07593832f, 
    -0.57509297f, 0.42501763f, -0.23595950f, 0.08291027f, 0.02388566f, -0.01485799f, -0.04096563f, -0.21479431f, 
    -0.06484403f, -0.07345086f, 0.04155858f, -0.12872440f, 0.31475174f, -0.13399079f, -0.01604599f, -0.24798366f, 
    -0.02587266f, -0.17845383f, -0.00033511f, -0.07010253f, 0.12458242f, -0.01301426f, 0.04103427f, 0.06050735f, 
    -0.08970566f, -0.14182907f, 0.01282702f, 0.24822997f, 0.03307929f, 0.07115242f, 0.00040980f, 0.19257249f, 
    0.00357195f, 0.08032811f, -0.12289310f, -0.01294960f, -0.55648446f, -0.05957660f, -0.00117999f, -0.14612979f, 
    -0.00895955f, -0.18498048f, 0.13219777f, -0.12814586f, -0.02487974f, 0.09644607f, -0.09086195f, 0.01419887f, 
    0.32547262f, -0.13377240f, 0.04807487f, 0.05459388f, 0.15050334f, 0.01465820f, -0.09288000f, -0.12724282f, 
    -0.03909284f, -0.01152330f, -0.09097879f, -0.00001170f, 0.53191715f, -0.16797686f, 0.03558287f, -0.12271101f, 
    -0.09240482f, -0.00248226f, 0.08066505f, -0.06326964f, -0.13072795f, 0.02627315f, 0.05448817f, -0.10537108f, 
    0.03941691f, -0.11645497f, 0.25914091f, 0.10999569f, -0.26177096f, -0.13314104f, -0.00594107f, -0.13212349f, 
    0.02501567f, -0.00886796f, 0.16537189f, -0.07577202f, 0.08788371f, -0.01876416f, -0.08150771f, -0.24546209f, 
    -0.00185536f, -0.02426910f, -0.02821238f, 0.04796458f, -0.08970165f, 0.23283221f, -0.17557278f, 0.03022005f, 
    0.06545414f, -0.26477930f, 0.11998211f, 0.03554422f, -0.27106532f, -0.33565491f, -0.21265553f, 0.01227742f, 
    0.08107187f, 0.16368447f, -0.10049125f, -0.01379713f, 0.02992960f, -0.07964014f, -0.05451496f, 0.20494191f, 
    -0.05442603f, -0.11706541f, -0.00039388f, -0.04555252f, -0.01353796f, 0.02034924f, -0.00566099f, 0.13774015f, 
    0.00783520f, 0.25390208f, 0.01112575f, -0.20180546f, 0.12056009f, 0.17000163f, -0.00949591f, -0.06353927f, 
    -0.22351433f, 0.02165055f, 0.02780747f, 0.10869261f, -0.04425191f, 0.12126347f, -0.10761563f, 0.14746603f, 
    -0.02752634f, 0.13166842f, -0.04016005f, 0.04212892f, -0.09651595f, -0.01842777f, -0.04534789f, -0.05476832f, 
    -0.25929329f, 0.29225731f, 0.01534704f, 0.12087950f, -0.10947613f, 0.14166796f, -0.08841123f, -0.10586229f, 
    0.10513449f, 0.09795313f, -0.09037030f, 0.05976677f, 0.10697245f, 0.38498572f, -0.32056937f, -0.05271559f, 
    0.02746290f, -0.17565309f, 0.02947581f, 0.02148251f, -0.15281339f, 0.07267503f, -0.11521785f, -0.02764996f, 
    0.06288768f, 0.09842369f, -0.02424319f, 0.10952042f, 0.01592480f, -0.02087274f, 0.04326757f, 0.01713256f, 
    0.00484140f, 0.10206359f, -0.05519770f, 0.18325920f, -0.01514379f, 0.06674159f, 0.00396882f, 0.11355133f, 
    0.01147663f, 0.01543332f, 0.12052102f, -0.00594734f, 0.07805403f, -0.02139796f, 0.05800738f, 0.00600233f, 
    0.12382378f, 0.17393559f, -0.07660697f, -0.04823878f, -0.15348907f, -0.19887209f, -0.08361594f, 0.05898708f, 
    -0.14317182f, -0.15753567f, 0.10775729f, -0.17745440f, -0.17440060f, -0.02897962f, 0.01576043f, 0.09540181f, 
    -0.03518571f, -0.04513231f, -0.06159824f, -0.04340996f, 0.00112457f, 0.02218036f, 0.02864125f, 0.06539962f, 
    -0.10978633f, -0.48170170f, 0.07129487f, 0.23445930f, -0.12567928f, -0.14861926f, 0.00045249f, -0.15096135f, 
    -0.08521659f, 0.05563200f, 0.06088851f, 0.07999316f, 0.07558776f, 0.30938882f, 0.12543629f, 0.20085455f, 
    0.08390056f, 0.05178420f, 0.00281948f, -0.04271855f, -0.07931886f, -0.02536986f, -0.00357840f, -0.07240871f, 
    0.06134099f, 0.11061835f, 0.01806674f, 0.13200039f, -0.09505236f, -0.18094468f, 0.04202597f, -0.22833368f, 
    0.04747085f, -0.05309931f, 0.01055166f, 0.00030413f, -0.05946435f, -0.15973142f, 0.10694494f, 0.10960551f, 
    -0.15303750f, 0.05395624f, -0.21456145f, -0.05177633f, -0.27379665f, 0.03636212f, -0.05867378f, -0.01661239f, 
    -0.01423796f, -0.19092198f, 0.09876684f, -0.00802477f, 0.00765670f, 0.05068549f, -0.02680373f, -0.06926084f, 
    0.01804961f, -0.19745156f, -0.02273045f, -0.02606286f, 0.14354794f, -0.05354441f, -0.01344938f, -0.01600808f, 
    -0.07477977f, 0.00144672f, 0.02740958f, -0.07050416f, 0.03010825f, 0.16164474f, 0.11162820f, 0.01679706f, 
    -0.36453679f, -0.58451307f, 0.03483933f, -0.37460822f, 0.02777257f, 0.04921721f, -0.06188416f, 0.09533826f, 
    -0.14293700f, -0.10101776f, -0.13029177f, -0.00060094f, 0.09552741f, 0.05504223f, -0.09174456f, -0.03908939f, 
    0.05427248f, 0.07570712f, 0.03114003f, 0.05889038f, 0.02741199f, -0.07338190f, -0.20086223f, -0.23709600f, 
    0.08241027f, 0.22015524f, -0.51597708f, -0.04976259f, 0.07794340f, 0.12446640f, -0.06324751f, -0.04822718f, 
    0.01151465f, 0.11436843f, 0.04904903f, -0.09770661f, 0.04331986f, -0.13765723f, 0.08724365f, 0.11407769f, 
    -0.11155619f, -0.03062005f, -0.04805633f, 0.01834562f, -0.06480060f, -0.06304440f, -0.02941883f, 0.05157048f, 
    0.05653159f, 0.20542648f, -0.10052844f, -0.04948044f, -0.07132198f, 0.09750820f, -0.09787367f, 0.01616785f, 
    -0.09298337f, 0.00525307f, -0.12021017f, -0.01687960f, -0.12549733f, 0.03957221f, -0.25302359f, -0.06537578f, 
    0.05167466f, 0.02073425f, -0.03601499f, -0.00133413f, -0.10507502f, -0.01190891f, -0.06218324f, -0.04489598f, 
    0.08451565f, -0.06218772f, -0.12745877f, 0.02912653f, 0.01152495f, 0.01788129f, 0.04943612f, -0.06789085f, 
    0.08758787f, 0.10730293f, 0.04189968f, 0.20838116f, -0.05615201f, -0.00246632f, 0.04710938f, 0.15199846f, 
    0.18083733f, -0.09432741f, -0.10508328f, -0.16035774f, 0.01292286f, 0.00193523f, -0.07313097f, 0.00690940f, 
    0.09328181f, 0.13546093f, 0.07111724f, 0.15750045f, 0.01654248f, -0.08372433f, 0.00879100f, -0.16882600f, 
    0.13126123f, -0.04689761f, -0.03772168f, -0.01768823f, 0.04360703f, -0.05934113f, -0.04979305f, 0.02467689f, 
    -0.02775805f, 0.00616477f, 0.08204614f, 0.05772623f, -0.03840338f, 0.04009175f, -0.13607791f, 0.03267643f, 
    -0.02043758f, 0.00239426f, 0.03568912f, -0.01220874f, 0.02802557f, -0.01436837f, 0.06382429f, -0.13139060f, 
    0.20521408f, -0.12346739f, 0.11214887f, 0.23358195f, -0.11681182f, -0.05878584f, 0.03832626f, -0.16537468f, 
    0.07809395f, -0.02208412f, 0.05479772f, -0.03867604f, 0.04774447f, -0.05356853f, -0.15235452f, 0.13100292f, 
    -0.10532559f, 0.00431085f, -0.02754819f, 0.19011262f, -0.03515703f, -0.04051601f, -0.04260516f, -0.06820955f, 
    0.04398941f, 0.04414516f, -0.01114720f, -0.03271665f, 0.03575935f, -0.01150401f, 0.19161861f, 0.11612149f, 
    -0.17213415f, -0.11310301f, -0.01918821f, -0.02245487f, 0.02711849f, 0.00930748f, -0.03100691f, 0.03736619f, 
    -0.04088990f, 0.01726267f, -0.09389000f, 0.06411190f, -0.10962985f, 0.07063791f, -0.05245812f, 0.01670337f, 
    -0.03748256f, 0.10173691f, -0.05055616f, -0.01967923f, 0.00629150f, -0.08741259f, -0.04603659f, -0.11732457f, 
    0.10638998f, 0.01123659f, 0.03093209f, -0.00678770f, -0.01138369f, -0.10629841f, -0.18185319f, 0.09804191f, 
    -0.00092239f, -0.00836934f, -0.06894409f, -0.00728539f, -0.12735359f, 0.01745565f, 0.02799711f, -0.18576676f, 
    0.05224900f, -0.11090026f, -0.12833577f, -0.13815224f, 0.29305765f, -0.25130266f, -0.22108549f, -0.02747011f, 
    -0.00050402f, -0.01987523f, -0.01707641f, -0.01115277f, 0.14152078f, -0.01562778f, 0.15458693f, 0.18232517f, 
    -0.08925471f, 0.05210507f, 0.03363255f, 0.11932566f, 0.03579731f, -0.00087579f, -0.08276797f, 0.00565024f, 
    0.02357838f, 0.01493778f, 0.03928310f, -0.00742805f, 0.04757075f, -0.05317393f, 0.01207992f, 0.01939808f, 
    0.00054429f, 0.03016257f, 0.09685975f, 0.03141641f, 0.06898714f, 0.05117815f, 0.03486100f, -0.01419622f, 
    -0.02570407f, -0.07196140f, -0.05774867f, 0.08673617f, 0.05062345f, 0.01773752f, 0.03316425f, -0.02455308f, 
    0.01311996f, 0.05503744f, -0.34728721f, 0.12273093f, -0.00486872f, 0.25839883f, 0.18683513f, 0.19882713f, 
    0.11007482f, 0.08544866f, -0.01620330f, -0.11727310f, 0.03461141f, 0.01277283f, 0.05006253f, -0.01201132f, 
    -0.05613345f, -0.13001056f, 0.02321685f, 0.18494295f, -0.12128347f, -0.00715383f, 0.10163256f, 0.00057383f, 
    0.00951421f, 0.01292438f, -0.05673499f, 0.06995948f, -0.01151581f, 0.06309959f, -0.05950726f, 0.12838407f, 
    0.00700917f, 0.13257326f, 0.02904826f, 0.02706239f, 0.02324501f, -0.00438261f, -0.01582232f, -0.05163291f, 
    0.10152093f, 0.16554350f, 0.19477293f, 0.13455001f, -0.02967840f, 0.05254908f, 0.01448273f, 0.06393222f, 
    -0.00841804f, -0.11829621f, 0.04725045f, -0.01753437f, -0.06315103f, -0.66983092f, -0.24094468f, -0.23807789f, 
    0.07618505f, 0.07194342f, 0.03973727f, 0.01361447f, -0.00545258f, -0.13616930f, 0.05115262f, 0.07400154f, 
    -0.01265773f, 0.03028735f, 0.15647502f, 0.06977906f, -0.05556342f, 0.08707857f, -0.04257647f, -0.10377208f, 
    -0.04548725f, 0.14171484f, -0.03692231f, 0.20339529f, -0.05238823f, 0.12367435f, 0.12236416f, 0.09633791f, 
    -0.07903858f, -0.11723649f, -0.01696731f, -0.08795564f, -0.03183467f, -0.06173320f, -0.07224003f, -0.04223610f, 
    0.13061368f, 0.27184734f, -0.24409172f, 0.09428724f, 0.04256783f, 0.00691727f, 0.08246144f, 0.01662496f, 
    0.13038947f, -0.09101407f, -0.19118616f, 0.14718625f, 0.00684371f, -0.04742230f, -0.01364315f, 0.01291828f, 
    0.05756232f, -0.02744907f, 0.03884795f, 0.04224948f, 0.11832431f, 0.04310976f, -0.08044276f, -0.06644572f, 
    -0.28798819f, -0.23424728f, -0.02521761f, -0.05972064f, 0.02357984f, 0.08335399f, -0.04186807f, -0.02182348f, 
    0.01126855f, -0.04133726f, -0.06818202f, 0.10899869f, 0.30608073f, -0.15943502f, -0.06500277f, 0.29293022f, 
    0.06145532f, -0.08012787f, -0.09209269f, -0.07694142f, 0.05658957f, -0.05608975f, -0.08551294f, 0.09788235f, 
    -0.06253900f, -0.43771017f, -0.02364480f, -0.57325774f, -0.03996213f, -0.02005293f, -0.05109711f, 0.12072971f, 
    -0.06572887f, -0.13556600f, 0.03028440f, -0.06954616f, -0.09720534f, 0.17205410f, -0.03358793f, -0.01845164f, 
    0.06650799f, -0.00329596f, -0.14940430f, 0.00033142f, -0.05324205f, -0.23592728f, 0.11625765f, -0.08185204f, 
    -0.00476146f, 0.10810637f, -0.14606717f, 0.04312111f, 0.06714825f, 0.03218660f, 0.00522221f, -0.15484814f, 
    0.01887390f, -0.05913637f, 0.10690031f, -0.18893416f, -0.01009942f, -0.29973331f, 0.06110026f, -0.00687132f, 
    -0.15453574f, -0.11043641f, 0.03660376f, 0.02325555f, 0.01326101f, 0.17884989f, 0.09412708f, 0.12705900f, 
    0.05007809f, 0.19989406f, -0.09190842f, 0.02884259f, -0.11665419f, -0.03245557f, 0.03151323f, 0.01321399f, 
    -0.03342100f, 0.06173759f, -0.05710816f, 0.17478351f, 0.15590778f, -0.05961738f, 0.00039430f, -0.01788290f, 
    -0.01393157f, 0.01687117f, 0.00892447f, 0.00871566f, 0.11528391f, 0.00945982f, -0.21923098f, -0.14640343f, 
    0.04478512f, -0.01681825f, -0.08827270f, -0.04769967f, -0.05082544f, 0.01340716f, -0.07596287f, 0.08420479f, 
    0.14801373f, 0.03282429f, 0.01873134f, -0.04588176f, 0.00551123f, -0.06662340f, -0.08196894f, 0.06195107f, 
    -0.09591427f, -0.16494258f, 0.07053387f, -0.03578118f, -0.07305887f, -0.12912789f, 0.03261715f, -0.36216131f, 
    0.04317807f, -0.33913627f, 0.24408430f, -0.33123434f, -0.05273374f, -0.01986118f, -0.06233953f, -0.05350417f, 
    0.00819316f, -0.15878838f, -0.13539025f, 0.14867499f, 0.08182014f, -0.07530205f, 0.02063238f, 0.11534022f, 
    0.07870489f, -0.00327937f, -0.07689492f, -0.18138991f, 0.05777863f, 0.00694201f, 0.02695190f, 0.11855591f, 
    0.20428410f, 0.26697186f, 0.16759939f, 0.08573721f, -0.09948664f, -0.12073886f, 0.02894293f, 0.07301630f, 
    0.09499618f, 0.03139265f, 0.06018034f, 0.04885539f, 0.02872556f, -0.08891985f, 0.00118783f, -0.15679322f, 
    0.03295443f, -0.02571697f, 0.00006546f, -0.03967224f, -0.08148701f, -0.02281430f, -0.15215181f, -0.26989836f, 
    -0.05626445f, 0.09209687f, -0.12375284f, 0.13787495f, -0.03553892f, -0.02688405f, 0.06698889f, -0.06779676f, 
    -0.05648980f, -0.04332376f, 0.08774762f, 0.04917533f, -0.13742049f, 0.01965947f, 0.03587194f, -0.03490590f, 
    -0.02052893f, -0.00069678f, 0.05654316f, 0.05096788f, -0.09383070f, 0.01486480f, -0.07727319f, 0.19497257f, 
    0.03612653f, 0.08644411f, -0.09317208f, 0.07484636f, -0.00657531f, 0.15009624f, -0.08792235f, 0.10657740f, 
    0.09704832f, -0.02320801f, -0.01720375f, -0.12654559f, -0.01776483f, -0.05696523f, 0.16559821f, 0.28835094f, 
    -0.11149412f, -0.05919613f, 0.06915487f, -0.25113401f, -0.03229134f, -0.03203072f, -0.01327973f, -0.13282487f, 
    0.02518015f, 0.08635772f, -0.04773516f, -0.02859351f, -0.06313168f, 0.06247681f, -0.00333626f, 0.07252625f, 
    -0.01755590f, -0.01670964f, 0.01137273f, -0.00024293f, -0.15346126f, 0.01964184f, 0.01583488f, -0.00259672f, 
    -0.10235155f, -0.00009086f, -0.02092636f, 0.01208226f, 0.02580614f, -0.00517422f, 0.01527534f, -0.08807553f, 
    0.20776013f, -0.06024176f, -0.28639457f, 0.26517773f, -0.07519256f, 0.12722972f, -0.01663515f, 0.03649245f, 
    -0.05404228f, -0.15937586f, -0.17701641f, -0.20218557f, 0.03468622f, -0.00819083f, 0.22089815f, 0.24350120f, 
    -0.04258964f, 0.06951299f, -0.01166373f, -0.07332008f, 0.03356769f, -0.00410134f, -0.02405861f, -0.03870073f, 
    0.13339064f, -0.19741535f, 0.03082775f, 0.16500546f, 0.06803951f, 0.00162629f, 0.07854024f, -0.03774494f, 
    -0.08386836f, 0.02514981f, 0.01569605f, 0.14342435f, -0.19115801f, -0.24669223f, 0.06908610f, -0.19130038f, 
    0.02310950f, 0.11600694f, -0.11485945f, 0.03948794f, -0.03984204f, -0.07340155f, -0.10770637f, -0.12921304f, 
    0.21692275f, -0.10089600f, 0.06363773f, 0.17124224f, 0.10728552f, 0.03489478f, 0.01089561f, -0.01736153f, 
    0.08154653f, -0.19795297f, -0.17826386f, -0.17959565f, -0.43945247f, -0.15772100f, -0.16496451f, 0.16076973f, 
    -0.03949954f, -0.07822555f, -0.05469181f, 0.02370527f, 0.04546836f, 0.07117762f, 0.01761242f, -0.02193106f, 
    -0.16758639f, 0.03316288f, -0.03191531f, -0.26496688f, 0.27732462f, 0.16428332f, -0.07513280f, 0.08633993f, 
    -0.03388763f, -0.08252208f, 0.11257546f, 0.06323484f, -0.17003717f, 0.22167107f, -0.23246492f, -0.23810771f, 
    -0.00298048f, 0.01179564f, -0.06838739f, -0.11119463f, 0.08404420f, 0.03281285f, -0.04619219f, -0.07308814f, 
    -0.48312208f, -0.15075406f, 0.36597183f, -0.18063977f, -0.02285498f, -0.03748527f, -0.04084770f, 0.10129230f, 
    -0.04948927f, -0.13296032f, 0.00613262f, -0.08708791f, 0.29022095f, 0.12177671f, -0.01523562f, -0.01946289f, 
    -0.06318389f, 0.11240023f, 0.07359697f, -0.12578568f, 0.10284313f, -0.06072755f, 0.11278531f, 0.00027294f, 
    -0.38698527f, -0.23988263f, -0.23079781f, -0.05634337f, 0.03563089f, 0.00794754f, 0.10936940f, 0.04360181f, 
    0.20387670f, 0.10258968f, -0.08402250f, -0.08215529f, -0.18238604f, -0.09226862f, 0.22553977f, -0.09799636f, 
    0.05358180f, -0.15910825f, 0.05673179f, 0.11672451f, -0.14872481f, 0.07707374f, 0.04816203f, 0.00455827f, 
    -0.02560630f, 0.00632254f, 0.04114651f, 0.22387457f, -0.05579192f, -0.20005047f, -0.01114539f, -0.10686313f, 
    0.15475838f, 0.02778149f, -0.16330105f, -0.08835874f, -0.00679426f, -0.12673265f, 0.01983822f, 0.03569869f, 
    0.02638220f, -0.07293063f, 0.05674101f, 0.11760282f, -0.03546109f, -0.30674016f, 0.28398567f, -0.06958561f, 
    0.19669159f, -0.07216173f, 0.11079666f, 0.00039165f, -0.07420976f, -0.09608313f, -0.01734009f, -0.02212143f, 
    -0.05154093f, 0.12899271f, -0.11227318f, 0.05070310f, -0.06957464f, -0.09226653f, -0.06719492f, 0.24263586f, 
    -0.00283042f, -0.14674850f, 0.01323467f, -0.01138817f, 0.00479915f, 0.02690823f, 0.35067964f, 0.10031769f, 
    -0.39791217f, 0.20074262f, -0.37460569f, -0.19150980f, 0.14625968f, 0.00400472f, -0.17903233f, 0.21231693f, 
    0.06540956f, -0.19456737f, 0.08456091f, 0.20873834f, -0.18080272f, 0.04388933f, -0.20394072f, -0.39939114f, 
    -0.04884436f, -0.00560194f, 0.05020077f, 0.12965769f, -0.03217486f, 0.11233333f, -0.15920417f, -0.07251030f, 
    0.13702622f, -0.02645396f, -0.01516427f, 0.32305661f, 0.15859522f, -0.00333333f, 0.00783084f, 0.08988664f, 
    -0.04412151f, 0.01882291f, -0.00632648f, 0.08736835f, -0.17134333f, 0.09858882f, -0.26299658f, 0.23504931f, 
    -0.07365049f, 0.05105551f, -0.09686353f, 0.06954648f, -0.07955955f, -0.12886776f, 0.02235886f, 0.17437376f, 
    0.11362383f, -0.09848658f, -0.12913008f, -0.04460256f, -0.03208116f, 0.00505237f, 0.10364591f, 0.11739754f, 
    0.04377088f, -0.22669774f, -0.30776489f, -0.14003463f, -0.10404291f, 0.17453673f, 0.01160243f, -0.13649260f, 
    -0.25712365f, -0.00145904f, 0.00546254f, -0.17829350f, 0.01077080f, 0.09565094f, 0.10902738f, -0.03184092f, 
    0.19253819f, 0.22938794f, 0.25527358f, -0.18976404f, -0.08823543f, 0.03295782f, 0.06031880f, -0.00182550f, 
    0.17787537f, 0.04203543f, 0.00628761f, -0.10438555f, -0.07569626f, -0.40119615f, 0.00328278f, 0.03206502f, 
    0.00562423f, -0.08346255f, -0.03215305f, 0.05245576f, 0.02991504f, -0.09037196f, 0.13479748f, -0.10097175f, 
    0.05306226f, 0.03452598f, -0.18833713f, 0.00275408f, 0.03659705f, 0.09967694f, 0.04111326f, 0.03507256f, 
    0.04303296f, -0.10439924f, -0.10657788f, -0.27309340f, 0.17310812f, -0.13409480f, -0.20862143f, 0.02133885f, 
    0.03644436f, -0.01404882f, -0.12379584f, 0.13830817f, -0.30962211f, 0.13546579f, -0.04946103f, -0.31659213f, 
    0.63682652f, -0.09210399f, -0.40474531f, 0.04603719f, 0.08935366f, 0.13254461f, 0.02249424f, -0.02167356f, 
    -0.00896233f, 0.06454480f, -0.03262302f, -0.13375182f, 0.05130479f, 0.06235383f, -0.06788968f, 0.01721984f, 
    0.31463099f, 0.21120176f, 0.04808218f, 0.11888262f, 0.01649123f, 0.09054822f, 0.01620013f, 0.06322533f, 
    0.02465520f, -0.13599426f, 0.11678687f, -0.08465479f, 0.09223813f, -0.08265048f, -0.22301799f, 0.03720716f, 
    0.00783665f, 0.07314017f, 0.00923685f, -0.01673394f, -0.31727988f, 0.19579260f, 0.06452158f, -0.02260614f, 
    -0.03670403f, -0.06080157f, -0.11935036f, 0.03727179f, 0.04306356f, 0.07168218f, 0.22001085f, -0.02403219f, 
    -0.13027611f, -0.04247982f, -0.01883597f, 0.01729119f, 0.05991906f, 0.03672548f, 0.08541031f, 0.05621123f, 
    0.08360121f, -0.03586163f, 0.13863623f, 0.17062812f, -0.40808785f, -0.21550238f, -0.07074280f, 0.22968194f, 
    -0.01431878f, 0.05315797f, 0.01971033f, 0.06216212f, -0.06579364f, -0.12259703f, -0.54864722f, -0.26273015f, 
    -0.15938962f, -0.03567592f, 0.02444794f, -0.28554988f, -0.05126470f, 0.07213213f, 0.05903840f, -0.17111565f, 
    0.09430542f, 0.01060051f, 0.06287652f, 0.07476182f, -0.10038533f, 0.04232712f, 0.00588773f, 0.00080863f, 
    0.08870527f, -0.07362466f, -0.01599844f, 0.09398279f, 0.04932277f, -0.00525754f, 0.04107986f, -0.04527543f, 
    -0.04805810f, -0.01500852f, 0.08644287f, 0.05116771f, 0.12002134f, -0.03432832f, -0.03213954f, 0.02488230f, 
    -0.18964060f, 0.07930584f, -0.11067536f, -0.21722879f, 0.02667036f, 0.00434550f, -0.03071381f, 0.02169053f, 
    -0.01919527f, -0.07051679f, 0.02356659f, -0.03032292f, -0.01657462f, -0.02069563f, -0.08008228f, -0.12691116f, 
    -0.27002653f, -0.06425998f, -0.00304754f, 0.14142331f, 0.09004731f, 0.04221120f, -0.04001970f, 0.08800225f, 
    -0.05411423f, 0.01282309f, -0.05695053f, 0.03711811f, -0.11964237f, 0.07280900f, -0.03334640f, -0.10977788f, 
    -0.06365617f, -0.12023149f, 0.01043716f, -0.00247487f, -0.11520343f, 0.08535418f, -0.02627012f, -0.04200470f, 
    0.07303701f, 0.14902775f, 0.25805566f, -0.02967682f, 0.13224675f, 0.09905353f, 0.02977015f, -0.03690218f, 
    0.00997312f, -0.02061294f, 0.04701561f, -0.00810317f, 0.09820821f, -0.37368798f, -0.00237451f, 0.06141565f, 
    0.01084897f, 0.03417661f, -0.00100781f, 0.01412099f, 0.14504212f, -0.21139216f, 0.05653992f, -0.16424465f, 
    0.07175889f, -0.01390352f, 0.15561734f, -0.07197127f, 0.04800942f, -0.02333192f, -0.16957715f, -0.03684845f, 
    0.01188264f, -0.03425091f, -0.11546649f, -0.11624600f, -0.02408318f, -0.23742320f, -0.11568061f, -0.03187416f, 
    0.00313305f, 0.05077102f, -0.02174385f, -0.06096274f, 0.02235453f, -0.01155800f, 0.06477459f, 0.09421152f, 
    -0.31439975f, -0.39943108f, -0.08887591f, -0.16398995f, -0.06774489f, -0.08893131f, -0.04429370f, -0.00570458f, 
    -0.10678028f, 0.12245865f, 0.22322619f, -0.14748605f, -0.05936842f, -0.14056315f, -0.00484938f, -0.04300872f, 
    0.14330226f, -0.07378164f, -0.03224878f, 0.03056140f, -0.01477194f, 0.00952994f, -0.10497924f, 0.11149604f, 
    -0.00461182f, -0.16127716f, -0.08208910f, 0.05664837f, -0.01269021f, -0.03197625f, 0.05943600f, -0.01763708f, 
    -0.06397370f, -0.05914611f, -0.01604146f, 0.05559207f, -0.21696290f, 0.00673933f, -0.06202761f, 0.11012563f, 
    -0.06792047f, 0.01495152f, -0.03743125f, 0.12794219f, 0.07086247f, -0.01116946f, 0.03601888f, -0.19960476f, 
    0.51385999f, -0.03226017f, 0.23306128f, -0.06658641f, 0.00691888f, 0.07764327f, 0.05472803f, -0.06129485f, 
    -0.07330635f, -0.10762387f, 0.03783801f, 0.07542622f, -0.14715245f, 0.09456056f, -0.68508697f, -0.12986444f, 
    0.14024948f, 0.11152145f, 0.14408554f, -0.00557485f, 0.26116723f, 0.03706513f, 0.05664963f, 0.04654198f, 
    0.08765579f, 0.09397326f, -0.46638212f, -0.00567889f, 0.00876747f, 0.04830357f, -0.10712269f, 0.10579146f, 
    0.01006797f, -0.08913659f, 0.18437262f, -0.20897871f, -0.07899840f, -0.04602717f, 0.05510780f, -0.17543210f, 
    -0.01074400f, 0.04588709f, -0.03420569f, 0.06834038f, -0.08313584f, -0.11500885f, -0.19967607f, -0.06546372f, 
    0.11424730f, 0.08264831f, -0.17590898f, 0.02603637f, 0.04736911f, -0.02380770f, -0.27838296f, 0.02320936f, 
    -0.03440966f, -0.00690979f, -0.07796651f, -0.10794675f, 0.02367162f, -0.10254907f, 0.00571173f, 0.15947367f, 
    -0.02962907f, -0.03304604f, 0.02470874f, -0.07169240f, -0.05076720f, 0.08250251f, 0.26281253f, 0.21058764f, 
    0.07600878f, 0.12224256f, 0.16714016f, -0.05987675f, 0.00843692f, -0.08461189f, -0.05402933f, 0.09352446f, 
    -0.08577213f, 0.00577040f, -0.14024806f, 0.18465550f, -0.42561492f, 0.19789225f, -0.21687578f, -0.29579172f, 
    0.06444498f, 0.10471864f, -0.12001427f, 0.04705339f, 0.22160062f, -0.18128347f, 0.21049625f, 0.12903859f, 
    -0.10526135f, 0.02990978f, 0.01418379f, -0.07924542f, 0.01928193f, -0.03222620f, 0.06986206f, -0.05920016f, 
    0.03885981f, 0.19690223f, -0.00606229f, -0.17075385f, -0.37438995f, 0.10717779f, 0.01037209f, -0.00457442f, 
    0.01540901f, -0.16893481f, -0.00331225f, 0.18957631f, -0.00942093f, 0.12744993f, -0.12233225f, 0.03369283f, 
    0.03702440f, 0.06986206f, -0.00872630f, -0.29735729f, 0.15642193f, 0.11356062f, 0.07193392f, -0.21778566f, 
    0.02924022f, -0.12225339f, -0.00684776f, 0.01181495f, 0.14012581f, -0.23618424f, -0.09875394f, 0.07538734f, 
    0.09613208f, 0.30017558f, -0.05082190f, -0.02904510f, 0.22480641f, -0.18312600f, 0.16218510f, 0.05464935f, 
    -0.63159245f, -0.30905735f, -0.15787020f, 0.04327872f, 0.01524944f, -0.06547442f, 0.03143420f, 0.09752303f, 
    0.04483512f, -0.09601551f, 0.02837123f, 0.07268220f, 0.09148393f, -0.17059530f, -0.16137512f, 0.04905566f, 
    -0.20548770f, 0.00138616f, -0.13656393f, 0.06364007f, -0.14044401f, -0.22502828f, -0.02355743f, -0.00879916f, 
    0.27122882f, 0.17863433f, -0.30002880f, 0.13523135f, 0.23080824f, 0.23597428f, -0.04938319f, -0.04223571f, 
    0.06106633f, 0.01629448f, 0.05196777f, 0.03366458f, 0.31839842f, -0.00416686f, 0.15501373f, 0.20478672f, 
    0.15047716f, 0.20409757f, 0.06872574f, 0.08714610f, 0.07771996f, -0.07009543f, 0.13776074f, 0.00668067f, 
    -0.16956350f, -0.13787214f, -0.09303653f, 0.04800159f, 0.05842448f, 0.08269776f, -0.17096980f, 0.15662733f, 
    0.00322981f, -0.15116161f, 0.09527262f, -0.00692928f, 0.18929398f, -0.06173201f, 0.13749629f, -0.02497880f, 
    0.18188553f, 0.01244152f, -0.07862324f, 0.09488235f, 0.03530494f, 0.03295540f, 0.07190241f, 0.09133374f, 
    -0.36870006f, -0.24443258f, 0.39682820f, -0.18969330f, -0.16383100f, -0.05765399f, -0.10906846f, -0.09247443f, 
    0.20056163f, 0.01594028f, 0.05205154f, 0.17928107f, 0.04751201f, 0.12206931f, 0.08220918f, -0.02394878f, 
    0.14425337f, 0.05985739f, 0.05595368f, 0.15756685f, 0.12800774f, 0.02447510f, 0.03919274f, 0.10232240f, 
    -0.10672141f, -0.16753972f, 0.13950768f, -0.07105172f, -0.01204867f, 0.00038007f, 0.01135579f, 0.07589264f, 
    0.02069496f, -0.07004995f, -0.12229256f, -0.17765467f, 0.08432849f, -0.15031062f, 0.00263558f, 0.01403325f, 
    0.00126056f, -0.12038779f, 0.04907372f, -0.02849260f, -0.05637662f, -0.00829515f, 0.21005769f, 0.23589946f, 
    -0.09324527f, -0.01940879f, -0.26730976f, -0.27309003f, -0.01111655f, 0.01210365f, 0.03356202f, 0.01364547f, 
    0.04251076f, 0.16661072f, 0.15711279f, 0.00571877f, 0.14594002f, -0.10094950f, -0.24458413f, -0.20357835f, 
    -0.03120123f, 0.01578275f, 0.01954241f, 0.02715452f, -0.04790778f, -0.03971078f, -0.10325072f, -0.14079703f, 
    -0.08503176f, -0.04214279f, -0.04469161f, -0.02805893f, 0.11947202f, 0.01628050f, -0.05963207f, 0.03281636f, 
    0.01236183f, -0.14424448f, -0.05860051f, 0.00473757f, -0.50498879f, -0.63835561f, -0.04716283f, -0.21403448f, 
    -0.22902521f, -0.16819140f, -0.21864949f, -0.18313071f, -0.06778873f, -0.02072042f, 0.01530034f, -0.02805928f, 
    0.01388735f, -0.07851185f, 0.01223763f, 0.01084132f, 0.00143736f, -0.02586058f, 0.08456875f, -0.00404618f, 
    0.12672544f, 0.09766966f, 0.19094326f, 0.10406694f, -0.25264305f, -1.00278616f, -0.02163757f, 0.01171665f, 
    -0.07115097f, 0.08268064f, 0.06652223f, -0.36214450f, 0.08874974f, -0.07497735f, 0.12493175f, -0.08877673f, 
    -0.15570571f, -0.15186913f, 0.41236639f, 0.10800099f, -0.00492164f, -0.04694120f, -0.15885536f, -0.13170312f, 
    -0.06562778f, 0.02121950f, 0.07002583f, 0.09330346f, -0.06137383f, -0.02061289f, 0.02948884f, 0.07511652f, 
    -0.00732683f, -0.04057989f, 0.08761732f, 0.18638767f, 0.07548293f, 0.07900696f, 0.18115281f, -0.08347527f, 
    -0.01485511f, -0.03150157f, -0.01402705f, -0.29011375f, 0.00452917f, 0.02683342f, -0.08467366f, 0.11319548f, 
    -0.03806221f, 0.05421932f, 0.07170100f, -0.13042064f, -0.02553442f, 0.00040959f, 0.03218648f, 0.04514614f, 
    0.03746887f, -0.01679414f, 0.01269596f, 0.08535040f, 0.02898468f, 0.13964257f, 0.16873519f, 0.14096735f, 
    -0.32059756f, 0.04056986f, -0.02989055f, 0.08365589f, 0.03965216f, 0.00714752f, -0.05263278f, 0.10319005f, 
    -0.00486922f, -0.14463075f, -0.09812707f, 0.25805664f, -0.01079732f, 0.04641199f, 0.04728726f, -0.10134248f, 
    0.06997800f, -0.04075488f, -0.04400193f, -0.00138500f, 0.04620440f, -0.03432682f, -0.08770443f, 0.08397213f, 
    0.32452574f, -0.08155226f, 0.25760671f, -0.37666726f, 0.02641100f, 0.02666607f, 0.08945420f, -0.06118312f, 
    -0.00679498f, 0.02343940f, 0.23185799f, -0.19922267f, -0.70078009f, 0.45877996f, 0.34513113f, 0.05740757f, 
    -0.08009094f, -0.12224811f, 0.03545846f, 0.00893949f, -0.05738623f, 0.11729971f, 0.10238950f, 0.15416262f, 
    0.06333717f, -0.35310179f, -0.08698271f, 0.37420705f, 0.14605655f, 0.08731725f, 0.17916393f, -0.18644994f, 
    -0.00395662f, -0.11114395f, 0.07611462f, 0.08209413f, 0.03415821f, -0.04812737f, 0.10096324f, 0.04178628f, 
    -0.00241439f, -0.01229078f, -0.08379553f, 0.03746781f, 0.01299840f, -0.05085841f, 0.00831619f, 0.09503305f, 
    0.12356704f, -0.00422954f, -0.01899969f, 0.05431442f, 0.03067806f, 0.00074243f, 0.11071768f, 0.08323008f, 
    0.10883219f, 0.28168231f, 0.11564200f, -0.02081299f, -0.21322571f, -0.05620294f, 0.31948090f, -0.11981387f, 
    -0.16186602f, -0.19574693f, -0.13276505f, -0.07785674f, -0.04168752f, 0.01199850f, -0.08793940f, 0.07757666f, 
    -0.46347964f, 0.05425031f, 0.49275210f, -0.21630931f, -0.07656821f, -0.00295997f, -0.01973797f, -0.10470708f, 
    0.10025012f, -0.01076643f, -0.02673756f, 0.01166170f, -0.20497249f, 0.04720277f, 0.04460133f, 0.04211320f, 
    -0.04124912f, -0.00348687f, -0.01965982f, 0.12819585f, 0.05115872f, 0.06512034f, 0.10298926f, 0.03998885f, 
    0.15535058f, 0.11914290f, -0.11890140f, -0.03249420f, -0.00360367f, 0.01516345f, 0.06738310f, 0.07097892f, 
    0.01729460f, 0.17107457f, -0.02018091f, -0.13167705f, -0.03757573f, 0.18794329f, -0.06077283f, -0.28163159f, 
    0.07187279f, 0.02671895f, 0.02139229f, 0.01808063f, 0.02467397f, 0.12138045f, -0.07907496f, 0.16548775f, 
    0.55575520f, -0.01422629f, -0.21315719f, -0.38687965f, -0.01270811f, -0.03324430f, 0.33745942f, 0.06236001f, 
    0.07333203f, 0.10890952f, -0.06507833f, -0.03105072f, -0.53655827f, -0.38284868f, -0.42358413f, -0.09074023f, 
    -0.07093628f, -0.01667947f, -0.00501204f, -0.24664810f, -0.00157218f, 0.03935743f, -0.04021079f, -0.03271708f, 
    -0.00139711f, -0.18930447f, -0.17754048f, 0.02487843f, 0.09993194f, -0.08414651f, 0.15809262f, -0.10158849f, 
    0.02533896f, 0.02865581f, -0.02600511f, 0.02212413f, 0.10166081f, -0.10768306f, -0.09274291f, -0.07438385f, 
    -0.00901547f, 0.01006040f, 0.03337764f, -0.03766501f, 0.01074765f, -0.04765227f, 0.03720059f, -0.09497976f, 
    0.18851158f, -0.01353431f, -0.05829353f, -0.06549277f, -0.09132083f, 0.00859604f, -0.05139679f, 0.10042751f, 
    -0.03685668f, 0.10059373f, 0.01864667f, -0.24432658f, 0.08593351f, 0.03382348f, -0.08346683f, -0.08861870f, 
    -0.05568155f, 0.03091607f, 0.00600708f, 0.03870219f, 0.00881849f, 0.07992776f, 0.16434991f, -0.00873688f, 
    -0.29371789f, -0.33592302f, -0.28836080f, -0.03774948f, -0.16245703f, -0.42478013f, -0.18188018f, 0.16256873f, 
    0.00277538f, -0.05742585f, -0.08439932f, -0.05883013f, 0.07693877f, -0.12839554f, -0.15584528f, -0.02974867f, 
    0.03540893f, 0.10040274f, 0.04382854f, 0.00841264f, -0.03254854f, -0.04791665f, 0.01207792f, -0.06465173f, 
    0.14091840f, -0.01500596f, -0.02343610f, -0.08874813f, -0.00982277f, 0.00396369f, 0.04227850f, 0.08671708f, 
    -0.06429593f, 0.04643931f, -0.00900967f, -0.04870047f, -0.23812899f, -0.32665634f, -0.19170213f, -0.05898344f, 
    -0.00155522f, 0.15209602f, 0.11205232f, -0.06724939f, 0.01895915f, -0.00978530f, 0.06081309f, 0.08725887f, 
    -0.13126856f, -0.10450144f, -0.05910318f, 0.09024876f, -0.05410141f, 0.06183733f, 0.02366105f, 0.03605823f, 
    -0.03231069f, -0.09413707f, -0.06751406f, 0.04182547f, 0.19924396f, -0.16412675f, -0.06480510f, 0.00420638f, 
    -0.02822000f, -0.06963105f, 0.14381333f, -0.04052650f, -0.01032008f, -0.11472194f, -0.01159613f, -0.03223369f, 
    -0.52165520f, -0.46398962f, -0.58593130f, 0.03965835f, -0.10223222f, 0.03887733f, 0.01714938f, -0.18992473f, 
    0.00430203f, -0.03844020f, 0.04456035f, 0.04037572f, -0.02605345f, 0.14159785f, -0.12910400f, -0.10159329f, 
    -0.01958472f, -0.00213223f, -0.00591822f, 0.01696020f, -0.07179302f, 0.03500675f, -0.06502856f, -0.00393452f, 
    -0.18377985f, -0.36402932f, -0.21993540f, -0.08622712f, -0.22943272f, 0.05812895f, 0.16169468f, -0.13685945f, 
    -0.03007484f, 0.04840159f, -0.02121187f, 0.05395665f, -0.26602042f, 0.32833034f, 0.24256861f, 0.41690058f, 
    -0.10467014f, -0.16819286f, -0.07396702f, 0.17072164f, 0.02782719f, 0.00263582f, -0.07936186f, 0.06778525f, 
    -0.39289793f, 0.19101483f, 0.32827756f, 0.38878739f, -0.01133402f, -0.00703938f, -0.08672044f, 0.08744836f, 
    0.04161732f, 0.16311270f, 0.01473355f, 0.03222011f, 0.16227542f, 0.07796030f, -0.12902373f, -0.00056014f, 
    -0.03027914f, -0.04617002f, 0.06535521f, 0.03831719f, -0.00732479f, -0.09872817f, 0.08554861f, -0.32425308f, 
    -0.01024795f, 0.16779961f, 0.06494038f, -0.06384595f, -0.00349332f, 0.01636543f, -0.07722094f, -0.04995753f, 
    0.00504863f, 0.04396581f, 0.00535044f, -0.16833989f, -0.07416145f, -0.12403538f, -0.05733709f, 0.09279794f, 
    0.03510861f, 0.16989069f, -0.01511188f, -0.17129965f, 0.03065576f, 0.07548296f, 0.07399720f, -0.02704256f, 
    -0.16220145f, -0.10695655f, -0.35878894f, -0.01903491f, 0.03428695f, 0.04672032f, -0.13796417f, 0.15670311f, 
    0.12697831f, -0.04869030f, 0.08956312f, -0.18628533f, 0.23335817f, 0.08636988f, 0.30322129f, -0.02211199f, 
    0.13512245f, 0.01105555f, -0.04443428f, -0.14972045f, 0.03821391f, -0.06782608f, 0.04603263f, 0.19580609f, 
    0.42828792f, -0.13251300f, -0.06509647f, -0.28758597f, -0.00184837f, -0.13605605f, 0.22636451f, 0.08349279f, 
    0.01800975f, -0.01523951f, -0.02009449f, -0.02371683f, -0.17708504f, 0.12207334f, 0.14346848f, -0.04442444f, 
    -0.07398175f, 0.04066743f, -0.02356530f, 0.05552088f, 0.02714431f, 0.05104592f, 0.10035314f, 0.14759651f, 
    -0.14033230f, -0.43629330f, -0.13303401f, -0.19951788f, 0.02996412f, -0.00519227f, -0.02413279f, -0.10436833f, 
    -0.00974989f, -0.06736771f, 0.03383142f, 0.13938184f, -0.07438378f, 0.01297131f, 0.13134825f, -0.12112614f, 
    -0.03848221f, -0.01404667f, -0.03714903f, -0.00838774f, 0.03674640f, -0.01684262f, 0.04484764f, 0.01769948f, 
    -0.08211337f, 0.18583626f, 0.11579265f, -0.13108519f, -0.01739679f, -0.11052493f, 0.03687395f, 0.06160091f, 
    -0.11483423f, 0.15943350f, -0.00405325f, 0.28793433f, 0.00283234f, -0.04803962f, 0.15955529f, -0.00369368f, 
    0.09286486f, -0.01045262f, 0.17820360f, -0.12160519f, 0.02216088f, 0.07055019f, -0.25949296f, -0.05445208f, 
    -0.11947413f, 0.38399693f, -0.15138578f, 0.18244871f, -0.00099500f, 0.21417731f, -0.01249979f, -0.07691181f, 
    0.14412531f, -0.05920680f, 0.13294166f, 0.06224022f, 0.08793858f, -0.00431362f, -0.13150024f, 0.07940163f, 
    0.08483960f, -0.00999111f, 0.02533735f, 0.00636733f, -0.02592758f, 0.01460170f, 0.01117330f, -0.06546217f, 
    -0.59819907f, -0.30299053f, -0.35585132f, -0.31060225f, -0.16709478f, -0.22107899f, -0.03804262f, -0.35202348f, 
    -0.05493918f, -0.00714022f, 0.08726779f, 0.05200759f, -0.08663452f, 0.16220832f, -0.01630125f, 0.05165757f, 
    0.01547942f, 0.00165035f, 0.03449082f, 0.06523663f, -0.04942348f, -0.05930694f, -0.17006227f, -0.00626388f, 
    -0.23913793f, 0.09904186f, 0.34495771f, 0.23017648f, -0.01985198f, -0.00950243f, -0.01102262f, 0.01709543f, 
    0.06485193f, 0.22716579f, 0.08916426f, 0.05278231f, -0.01692563f, 0.07757865f, 0.02816033f, 0.07390023f, 
    -0.13553701f, 0.06244035f, 0.06228409f, 0.31285793f, 0.04479017f, 0.01282497f, 0.00436261f, -0.02600985f, 
    -0.13219385f, -0.09660602f, -0.14143445f, -0.48367476f, -0.26753780f, 0.05468334f, 0.18634018f, 0.10207142f, 
    0.00030187f, 0.00570104f, -0.03890973f, -0.08974102f, -0.41475490f, -0.37888965f, 0.11289749f, 0.38098079f, 
    -0.17283142f, -0.16657752f, -0.00482628f, -0.22288501f, -0.00385173f, 0.00791247f, -0.03078285f, -0.04861231f, 
    -0.04283610f, -0.05523663f, -0.09175456f, -0.05692428f, -0.05601057f, 0.08278403f, 0.12337325f, -0.00025282f, 
    -0.02863982f, -0.06984682f, 0.01433574f, -0.01346802f, -0.72136682f, -0.58984745f, -0.37575158f, 0.02554825f, 
    0.00191836f, -0.08612867f, -0.10903367f, -0.08848399f, -0.00160948f, 0.01096226f, -0.05327411f, 0.04368849f, 
    -0.06533135f, -0.35144964f, 0.04535965f, 0.26660240f, -0.04221367f, -0.19594182f, -0.04602453f, 0.06102883f, 
    -0.02761158f, 0.22068998f, -0.08234030f, -0.15809697f, -0.43962827f, -0.52575129f, -0.43160033f, -0.00636149f, 
    -0.17880587f, -0.33619222f, -0.20691982f, -0.41644889f, -0.03118302f, -0.01351707f, -0.05916379f, -0.02655730f, 
    -0.09614376f, -0.11790744f, -0.02725282f, 0.17382476f, 0.05329306f, 0.05153120f, 0.00441201f, 0.06610546f, 
    -0.03692377f, -0.02536647f, 0.04147639f, 0.08451632f, -0.10368600f, -0.01170039f, 0.04670354f, -0.14994097f, 
    0.16485167f, -0.07374207f, 0.02915661f, -0.04907565f, -0.05607235f, 0.06204681f, 0.00771507f, 0.10402872f, 
    0.07548840f, -0.34384796f, 0.03047440f, 0.21081583f, -0.15032351f, -0.09375394f, -0.03433894f, -0.07457133f, 
    0.08823193f, -0.01985081f, 0.09685349f, 0.10317061f, -0.05200982f, 0.03525127f, 0.00609058f, 0.06799170f, 
    0.02916002f, -0.01647418f, -0.01085299f, -0.00065400f, 0.04572821f, 0.03062131f, -0.00229325f, -0.08191197f, 
    0.02548552f, 0.08440646f, 0.06315813f, 0.02644880f, -0.03022992f, -0.09428829f, -0.03987429f, -0.08280133f, 
    0.02515091f, -0.06942631f, 0.08515555f, -0.03541884f, -0.18489726f, -0.11496072f, -0.31275606f, -0.31024054f, 
    0.09877314f, -0.15475303f, 0.05540968f, 0.20980313f, -0.01901523f, -0.06068563f, -0.01998190f, 0.05981034f, 
    0.31003788f, -0.08858482f, 0.07797435f, -0.19230986f, -0.02467215f, -0.03629814f, -0.14084619f, -0.08926418f, 
    -0.00946966f, -0.10856767f, 0.01135693f, -0.18268156f, -0.45347044f, 0.27439821f, 0.09028134f, 0.27269223f, 
    -0.04096043f, 0.04115548f, -0.00445759f, 0.04174709f, 0.04802943f, -0.00880265f, 0.00479939f, -0.09314629f, 
    0.49172723f, -0.58952534f, -0.46716478f, -0.65288109f, -0.12953261f, -0.00724359f, -0.32703152f, 0.07241072f, 
    0.04556594f, 0.03123034f, 0.02223165f, 0.04731559f, 0.25584027f, -0.17143725f, 0.07459008f, -0.25650698f, 
    -0.01595036f, 0.14712667f, -0.11290517f, 0.07209743f, -0.05609748f, -0.06501796f, -0.05197924f, -0.01811793f, 
    -0.01651205f, 0.18255830f, -0.18437980f, 0.15306169f, -0.03974537f, -0.06090202f, 0.02707771f, -0.04603567f, 
    0.00875930f, 0.03029271f, -0.06925716f, -0.08940986f, 0.15592951f, 0.02567724f, 0.06438860f, -0.05867428f, 
    0.01063380f, -0.03548979f, 0.00077840f, -0.10893558f, 0.02792384f, -0.09331703f, 0.16064841f, -0.28531000f, 
    0.03538136f, -0.28924632f, -0.03637826f, -0.06897986f, 0.05365837f, 0.02737994f, 0.13118972f, -0.11395970f, 
    -0.04802481f, 0.02636780f, -0.00515193f, -0.15139446f, 0.16890043f, 0.07179228f, -0.06308531f, -0.01526298f, 
    0.02113919f, 0.04234371f, 0.01525702f, -0.02781034f, -0.00762118f, 0.04671723f, -0.07351018f, -0.12123057f, 
    -0.34434417f, 0.36187661f, -0.01321452f, 0.20299110f, 0.07479386f, -0.12161640f, 0.10199501f, 0.03757958f, 
    -0.02021037f, 0.05775480f, -0.02710754f, 0.02343520f, 0.00391918f, -0.56748760f, -0.24879025f, -0.09991165f, 
    -0.19065489f, -0.08485378f, -0.01473589f, 0.11853359f, 0.03520731f, -0.03465164f, 0.00929867f, 0.04364045f, 
    0.19441551f, 0.16568707f, 0.03885952f, -0.22101913f, -0.11422659f, 0.06663742f, 0.01957067f, -0.00515517f, 
    0.00074438f, 0.05013867f, 0.00218036f, 0.04387803f, 0.02648869f, 0.03318372f, -0.04331177f, 0.00140287f, 
    0.03873791f, -0.04211631f, -0.01203469f, -0.05462496f, 0.03654916f, 0.00411172f, 0.00272462f, -0.26169384f, 
    -0.03109166f, 0.02454684f, 0.14329441f, 0.01187252f, -0.00583310f, -0.00386316f, 0.00580813f, -0.02141865f, 
    -0.01033332f, 0.05612012f, 0.02687900f, 0.10132046f, -0.35470122f, 0.39341035f, -0.15024465f, -0.31784311f, 
    -0.05019811f, 0.03876022f, 0.17821956f, 0.14418559f, 0.04880068f, -0.06401805f, -0.03424335f, -0.00240093f, 
    0.31738862f, -0.15607682f, 0.23834842f, 0.01290995f, 0.09678065f, 0.12272210f, 0.00963799f, 0.03570703f, 
    -0.03473860f, -0.08312992f, 0.12068429f, 0.02339273f, 0.30982441f, 0.01409788f, -0.01107129f, -0.23022662f, 
    0.04446222f, -0.01841098f, -0.01246603f, -0.10329782f, 0.00707817f, -0.06616253f, -0.00084265f, -0.21400975f, 
    -0.03972251f, -0.06066170f, -0.10684878f, 0.04990381f, -0.03267917f, -0.07707129f, 0.04719256f, -0.04718141f, 
    0.07454235f, 0.07939859f, 0.10244296f, -0.07602617f, -0.06890790f, 0.18831573f, -0.11095453f, 0.19052425f, 
    -0.10217561f, -0.07121950f, -0.05436749f, 0.02314496f, -0.08292255f, 0.17283592f, 0.01983720f, -0.14413895f, 
    -0.07330728f, 0.14182450f, -0.02658817f, -0.08177420f, -0.03626824f, -0.03337400f, -0.14189526f, 0.05912860f, 
    0.03424025f, 0.03229678f, 0.00705150f, 0.03892136f, -0.12440792f, -0.39729673f, -0.12802462f, -0.22591454f, 
    0.21044622f, 0.14385478f, -0.05752455f, 0.12413509f, 0.05072294f, 0.00257563f, -0.01763984f, -0.03587078f, 
    0.25879380f, -0.08717580f, 0.05583417f, 0.07591883f, -0.09738567f, 0.00860677f, -0.05554424f, -0.16294737f, 
    -0.03676627f, 0.10698889f, -0.00287232f, 0.00411935f, 0.17107356f, -0.11824013f, 0.11765441f, -0.22986500f, 
    -0.00258233f, -0.00966147f, -0.02604079f, 0.02275749f, 0.01967052f, 0.00542766f, -0.12659487f, -0.29860309f, 
    -0.02052962f, -0.04061149f, -0.00621180f, 0.01462635f, -0.02589829f, 0.07616102f, -0.01668032f, -0.17330913f, 
    -0.05629491f, -0.12084944f, -0.10378736f, -0.11652726f, 0.12789676f, 0.04372708f, -0.01000741f, 0.07737838f, 
    -0.02930757f, 0.00870779f, -0.07014885f, -0.02579362f, -0.04837026f, 0.11395759f, -0.13466145f, 0.14059645f, 
    -0.17413983f, -0.24866432f, 0.08393196f, -0.05857163f, -0.23265760f, 0.04247666f, 0.18106335f, -0.01581971f, 
    0.01474964f, -0.01200263f, -0.00165363f, 0.00864460f, 0.03097794f, 0.01449665f, 0.13020101f, -0.10570420f, 
    0.05766185f, 0.02275551f, -0.06710824f, -0.02315163f, 0.06627917f, 0.00363562f, 0.04532005f, 0.05956398f, 
    0.07239968f, 0.02467339f, 0.07152272f, -0.16657723f, -0.04910706f, 0.04383864f, -0.02674541f, -0.03006574f, 
    0.05988233f, -0.03353494f, -0.19808635f, 0.00184448f, -0.33318058f, 0.24109356f, -0.21556199f, 0.02430074f, 
    -0.01438763f, 0.01223373f, 0.02969366f, 0.10605059f, 0.08793975f, -0.00624049f, 0.04361628f, 0.01650018f, 
    -0.01948727f, 0.11020248f, 0.02728448f, -0.02857025f, -0.03531100f, -0.02700060f, -0.00517031f, -0.02045158f, 
    0.09125400f, 0.05106573f, -0.00508720f, -0.02407344f, -0.19453381f, 0.13840531f, 0.07933579f, 0.08213758f, 
    -0.01378192f, -0.10904640f, 0.00362901f, 0.09101709f, 0.01960025f, -0.01255068f, -0.00196368f, -0.00691012f, 
    -0.49939719f, -0.08653873f, 0.27087048f, 0.33054057f, 0.10354466f, 0.03583461f, -0.00539990f, 0.01443384f, 
    -0.00036869f, -0.08075427f, -0.03471773f, -0.03474996f, -0.01052433f, -0.18309528f, 0.15186201f, -0.13151368f, 
    0.05587718f, -0.00615496f, -0.03196849f, -0.07246404f, 0.06162294f, -0.17426957f, 0.01853736f, -0.09120157f, 
    0.12081789f, -0.46942723f, -0.01480163f, -0.04667199f, 0.10140324f, 0.07431135f, 0.19167492f, 0.16227669f, 
    0.00616488f, -0.02696360f, -0.15589102f, -0.00141777f, 0.01175164f, -0.57943434f, -0.56478024f, -0.57066923f, 
    0.04553054f, -0.14113225f, 0.08775697f, -0.05704864f, -0.03311848f, 0.00479418f, 0.01124682f, -0.02843016f, 
    0.60111171f, -0.23023331f, -0.01037234f, -0.49843583f, -0.04160749f, -0.02314500f, -0.10326781f, -0.02441658f, 
    -0.07465620f, 0.00052707f, 0.02186795f, -0.13254741f, 0.04943123f, 0.03489940f, 0.05561394f, 0.03641101f, 
    -0.01615695f, 0.02155086f, -0.04322859f, 0.00050401f, 0.04830323f, -0.03538648f, -0.07372109f, -0.00912371f, 
    0.02502219f, 0.02801249f, -0.03809170f, -0.05881811f, -0.00101469f, 0.02638534f, -0.02945176f, -0.04519113f, 
    0.03287290f, 0.03971729f, -0.15757665f, 0.02118452f, 0.05085976f, 0.09665139f, -0.13362083f, -0.00642362f, 
    -0.02381381f, -0.00768837f, 0.00623889f, 0.11126579f, -0.12463123f, 0.04849983f, 0.04845627f, 0.04793972f, 
    0.03880600f, -0.57027310f, 0.08804195f, -0.24277742f, 0.06778686f, -0.14666741f, 0.08760528f, -0.02748586f, 
    0.08263331f, -0.00593983f, 0.02206078f, -0.11375766f, -0.09566011f, 0.22484404f, 0.04840263f, 0.08812380f, 
    -0.03700782f, 0.04481955f, 0.13928163f, 0.00782432f, -0.01627883f, -0.13285036f, 0.00383985f, -0.04695505f, 
    -0.26641461f, 0.21350713f, -0.17504081f, 0.13733591f, -0.04003948f, 0.00541795f, 0.07099047f, -0.03191939f, 
    0.08524431f, -0.03399807f, 0.06905469f, -0.08987302f, 0.24523571f, -0.06397784f, -0.19902681f, -0.24445806f, 
    -0.00996502f, -0.07469723f, -0.08075839f, 0.04803734f, 0.14909030f, 0.09002259f, 0.14395490f, -0.10487028f, 
    -0.14693691f, 0.19299616f, -0.09724076f, -0.02469300f, 0.06671955f, 0.13673286f, 0.07610356f, 0.06414419f, 
    -0.10647622f, 0.01646890f, -0.05006469f, -0.00700470f, 0.13142727f, 0.07506604f, -0.04598695f, -0.15529473f, 
    0.00221918f, 0.10052076f, -0.05438171f, 0.00491438f, -0.18040325f, -0.05799289f, -0.09673546f, -0.07062741f, 
    0.29784131f, 0.03860516f, -0.14873874f, -0.18048951f, 0.01665168f, -0.01291096f, -0.02925454f, -0.12539293f, 
    0.00397463f, 0.17992154f, 0.01174388f, 0.02578999f, 0.02739462f, 0.00476090f, 0.17263044f, -0.25166824f, 
    -0.11731827f, 0.01116242f, 0.09246688f, -0.04860499f, 0.04798005f, -0.08467358f, -0.00117668f, 0.01154471f, 
    -0.20057300f, -0.00681855f, 0.12754184f, 0.04818420f, 0.02110904f, -0.03845538f, 0.10229809f, 0.03093222f, 
    -0.27646494f, -0.06050768f, 0.05911532f, 0.01015838f, 0.09994808f, -0.06312214f, 0.00838064f, -0.05953695f, 
    -0.08609817f, 0.05396529f, 0.05383535f, -0.04706409f, -0.03105604f, 0.03739469f, 0.04218210f, 0.00845138f, 
    -0.38485578f, -0.28285033f, 0.19884256f, -0.00007786f, 0.07655665f, -0.00404788f, 0.13135116f, 0.10881896f, 
    -0.04112177f, -0.05960083f, 0.00895868f, -0.05364856f, -0.04212173f, -0.08049494f, 0.03165643f, -0.11242659f, 
    -0.02825341f, 0.00851025f, 0.00593014f, -0.04803535f, -0.19592547f, -0.04996056f, 0.10592008f, -0.13633691f, 
    0.31191325f, -0.11557730f, -0.02232501f, -0.21692145f, 0.03094445f, 0.00924222f, -0.07987451f, -0.03674287f, 
    0.12120981f, 0.09116748f, 0.00547308f, -0.12485760f, 0.03231943f, 0.09245373f, 0.01276626f, 0.06711685f, 
    0.00213911f, 0.10498626f, 0.03430846f, -0.01222660f, -0.06802106f, -0.01323368f, -0.05903770f, -0.00687602f, 
    -0.55333370f, 0.12264801f, -0.28840977f, 0.12358229f, 0.11150701f, 0.08262199f, 0.11098937f, -0.11529619f, 
    0.05093087f, -0.02488767f, 0.01230204f, -0.00023323f, -0.22325113f, -0.33199781f, -0.16555929f, 0.26634160f, 
    0.00352629f, -0.15814181f, -0.18155780f, 0.04149359f, -0.02735753f, -0.05075597f, 0.03305062f, -0.03188686f, 
    0.04204264f, 0.07744697f, 0.00755727f, 0.03370458f, -0.05176822f, -0.00411518f, -0.02882170f, -0.13237675f, 
    -0.02670763f, 0.00451315f, 0.01864090f, 0.06170160f, -0.50922042f, -0.34245351f, -0.23626925f, -0.19429223f, 
    0.04451443f, 0.02382639f, 0.14258070f, 0.07476939f, 0.04010830f, -0.04148926f, -0.10787046f, -0.00520775f, 
    0.45055541f, -0.08338009f, 0.11907559f, -0.36947373f, 0.03726075f, 0.14696892f, 0.02328787f, 0.13150486f, 
    -0.12199623f, 0.01219223f, 0.16797262f, -0.11867929f, -0.25081745f, -0.55387467f, 0.02665870f, 0.34200922f, 
    0.04376895f, -0.12533778f, -0.13473439f, 0.18194145f, 0.02091735f, 0.04304243f, -0.02661054f, -0.07284505f, 
    0.11061233f, 0.05611262f, -0.01972921f, -0.07092641f, 0.00138834f, -0.02483084f, -0.01208556f, 0.00081682f, 
    0.00711325f, 0.05362752f, 0.05966451f, -0.00959016f, 0.18903662f, 0.03028058f, -0.06769092f, 0.03274328f, 
    -0.02375161f, -0.01151273f, 0.01356832f, 0.00775684f, -0.02840264f, 0.06163222f, -0.06463508f, -0.03329575f, 
    0.26595923f, -0.02587794f, -0.09432489f, -0.36023200f, 0.06701348f, 0.04135168f, 0.12095819f, 0.10792901f, 
    0.15766355f, -0.07050597f, 0.00759679f, -0.41821015f, -0.12717402f, 0.19842386f, -0.06907790f, -0.06168944f, 
    0.02479241f, -0.00856757f, -0.07895525f, 0.03785443f, -0.04105970f, 0.08992190f, 0.08546942f, 0.11954292f, 
    -0.09397843f, 0.04429908f, -0.04664190f, 0.04390098f, -0.00548348f, -0.02523324f, 0.03432896f, 0.12153595f, 
    0.21164910f, -0.06099446f, 0.00014030f, -0.02515255f, 0.04656014f, -0.47716358f, -0.40357000f, -0.22357197f, 
    -0.28091219f, 0.01688020f, 0.06789917f, -0.04025841f, -0.00821160f, -0.00279181f, -0.00332045f, -0.01791324f, 
    0.17847410f, 0.24752954f, -0.06411288f, -0.30475909f, 0.08961970f, -0.12869523f, 0.08676273f, 0.00498424f, 
    -0.02999444f, 0.16905898f, -0.10827898f, -0.12553427f, -0.11975925f, 0.00010892f, -0.00663920f, -0.21850137f, 
    -0.00531693f, 0.07624801f, -0.04802116f, 0.11083929f, 0.01721023f, 0.18121828f, -0.01451740f, 0.03592442f, 
    -0.28978100f, -0.23278365f, -0.22154227f, 0.16823094f, 0.00745334f, 0.18043497f, 0.04895862f, 0.16952108f, 
    0.08635870f, 0.04116492f, -0.03362703f, 0.07217488f, 0.21725567f, 0.04816066f, -0.21722876f, -0.13184336f, 
    0.11395638f, 0.09224109f, 0.15403341f, -0.11965171f, 0.00105331f, -0.10008715f, -0.01139755f, -0.27611607f, 
    0.25298977f, 0.09773827f, -0.19050203f, -0.10132611f, 0.10192611f, 0.05852172f, -0.07638554f, 0.00803628f, 
    0.12887968f, 0.06881121f, 0.06017548f, 0.16520362f, -0.01346425f, 0.10195807f, -0.12369194f, -0.17751496f, 
    -0.05275944f, -0.02702023f, 0.00387844f, -0.10622608f, 0.03178155f, -0.00945291f, -0.10428496f, -0.11908159f, 
    0.30983806f, -0.07303903f, 0.09062002f, -0.04124543f, -0.07953148f, -0.00070322f, -0.05742820f, -0.08344140f, 
    -0.02214107f, -0.02122147f, 0.06750789f, 0.16503207f, -0.00608233f, 0.05731300f, -0.03063374f, -0.03045558f, 
    -0.06118459f, -0.05896864f, -0.02677495f, -0.04604100f, -0.00949641f, 0.04211864f, 0.00853626f, 0.15913557f, 
    -0.74380928f, -0.16536488f, 0.23399185f, 0.08590116f, -0.10405428f, 0.01693483f, -0.03995186f, 0.20134917f, 
    0.05441703f, 0.01949538f, 0.12251464f, 0.02739558f, -0.05767662f, -0.30319360f, -0.31974098f, 0.19802424f, 
    -0.09468624f, -0.00214668f, 0.17548746f, 0.22050534f, -0.09904312f, -0.24530083f, 0.02850115f, -0.04823696f, 
    -0.15144514f, 0.17882477f, 0.20201656f, 0.08926432f, 0.12349834f, 0.08658336f, 0.10145178f, -0.10174597f, 
    -0.00014615f, -0.07756279f, 0.14243002f, -0.08027089f, 0.01539125f, -0.00629483f, 0.16259123f, -0.06797176f, 
    -0.11843729f, -0.00286946f, 0.00061166f, -0.02553006f, -0.02930994f, 0.10477993f, 0.04972935f, 0.07644255f, 
    -0.25001267f, -0.11152314f, 0.06857479f, 0.03517332f, -0.00083474f, -0.01213395f, 0.03530743f, 0.01205984f, 
    -0.28080487f, 0.12130623f, -0.12495848f, -0.32860520f, -0.02886407f, -0.43560669f, -0.00040930f, 0.18742564f, 
    -0.10765587f, -0.01628939f, 0.15869008f, -0.04586061f, 0.01643256f, -0.00872534f, 0.13536106f, 0.04893319f, 
    0.07826072f, -0.23793735f, -0.43512818f, -0.22571261f, -0.06823150f, 0.01292038f, 0.05400790f, -0.09195492f, 
    -0.08834382f, 0.07146281f, 0.10044770f, -0.06979561f, 0.02149025f, -0.14402582f, -0.24342562f, -0.22907440f, 
    0.02813905f, 0.04525877f, 0.01002494f, 0.00247824f, 0.12620758f, 0.06143448f, -0.01348113f, 0.01700862f, 
    -0.02356477f, 0.05200952f, -0.02054271f, -0.01281435f, -0.06049009f, -0.00023719f, -0.03194137f, -0.01545423f, 
    -0.27233860f, 0.02688615f, -0.10233644f, -0.25791711f, 0.07966483f, -0.11838429f, 0.01508077f, 0.19248939f, 
    -0.07525568f, 0.09824584f, 0.04102405f, 0.02325962f, -0.01928282f, 0.06453431f, -0.12660800f, 0.04858061f, 
    -0.41929457f, 0.11871520f, 0.06504192f, 0.19442122f, 0.09656336f, -0.02340953f, -0.09877760f, -0.02529553f, 
    -0.08838047f, -0.04854107f, -0.01741780f, -0.13606206f, 0.12161013f, -0.15340549f, -0.40903798f, -0.05870318f, 
    -0.06326095f, -0.00566951f, -0.00860800f, -0.08916729f, -0.02226438f, -0.06761076f, -0.00005010f, 0.00459747f, 
    0.18132570f, -0.08745851f, -0.14336683f, -0.15585953f, 0.10205688f, 0.06171542f, -0.00628580f, 0.00428064f, 
    0.02506366f, 0.05156292f, 0.12206228f, 0.10702734f, -0.01445321f, -0.17198019f, 0.21488053f, -0.41929644f, 
    -0.11532273f, -0.03341105f, 0.00703802f, -0.12979868f, -0.13067286f, 0.03979429f, 0.04389909f, 0.09475575f, 
    0.09063680f, 0.06881154f, 0.05948143f, -0.06979334f, 0.07443315f, -0.03349836f, -0.07504337f, 0.01771936f, 
    -0.00842679f, 0.13093182f, 0.05855912f, 0.13811773f, 0.17159772f, 0.08619606f, 0.06209034f, -0.07154620f, 
    -0.06355746f, -0.10656672f, -0.06844483f, 0.03922425f, -0.09358286f, 0.01281710f, 0.04350817f, 0.02502315f, 
    -0.23664068f, -0.34858456f, -0.20925942f, 0.10238151f, 0.03983058f, -0.14709637f, -0.10734158f, 0.09816131f, 
    -0.04090903f, 0.01475573f, 0.09158605f, 0.09401929f, -0.06225926f, 0.06309418f, 0.12492750f, -0.10587104f, 
    -0.03292639f, -0.09407206f, -0.04441869f, -0.05143286f, -0.04290313f, 0.04480194f, -0.03345528f, -0.04602690f, 
    0.01882580f, -0.01383188f, -0.07908466f, -0.13513137f, -0.00220232f, -0.05259005f, 0.07780741f, -0.04809508f, 
    -0.04718399f, 0.06487997f, 0.11520988f, -0.04320785f, -0.16775712f, 0.03087200f, -0.04787101f, -0.05650651f, 
    0.14372241f, 0.11034449f, -0.08383058f, -0.00005608f, -0.10092641f, -0.07986846f, -0.01839264f, -0.14158724f, 
    0.06005060f, 0.04071988f, 0.07162201f, -0.06895945f, 0.07620966f, 0.03871580f, -0.06316084f, -0.00009260f, 
    0.00781721f, 0.00257764f, -0.01410232f, 0.04336637f, -0.15541746f, -0.05666450f, 0.04684857f, -0.04381271f, 
    -0.00325289f, 0.02408909f, -0.00634138f, 0.04996917f, -0.00938619f, 0.11618478f, 0.14358918f, 0.06507536f, 
    0.23319869f, 0.02178147f, 0.07214554f, -0.26854798f, -0.06815811f, -0.18951079f, -0.23338227f, -0.16846648f, 
    0.05379736f, 0.09392390f, 0.05084086f, 0.06123567f, -0.32206115f, 0.29781261f, -0.05163326f, -0.17738293f, 
    -0.02193688f, -0.07995363f, -0.02970532f, -0.12725997f, -0.02813735f, 0.02040735f, -0.19425331f, 0.00325819f, 
    0.18305257f, -0.05390705f, -0.17254989f, -0.16350490f, 0.11502909f, 0.02158062f, 0.02094138f, 0.08493725f, 
    -0.06495366f, -0.19949043f, -0.07534548f, -0.19571669f, -0.18701030f, -0.30993387f, -0.21577507f, 0.32043099f, 
    0.08995946f, 0.14727253f, 0.19914161f, 0.11923916f, 0.09788568f, 0.01414973f, 0.10125358f, 0.09466675f, 
    -0.27415684f, -0.25498962f, -0.20879965f, 0.03858436f, 0.07529171f, 0.06774450f, 0.09415162f, 0.04072369f, 
    0.16271442f, 0.08132858f, -0.12089582f, 0.03007340f, -0.22346568f, 0.09436493f, 0.05306461f, -0.09074322f, 
    0.00223152f, 0.02587889f, -0.02901673f, 0.01571018f, 0.03506822f, 0.00565288f, 0.07535665f, 0.04190302f, 
    0.08753582f, 0.04810064f, 0.11093336f, -0.26463079f, -0.06811915f, -0.06604508f, 0.01663170f, -0.13364525f, 
    -0.08653571f, -0.00440852f, -0.03432535f, 0.07969499f, -0.12397892f, 0.03467777f, 0.06837952f, -0.11809453f, 
    0.08275565f, -0.01085314f, -0.09402709f, -0.00198657f, -0.15062918f, -0.00471803f, -0.09547807f, -0.05416117f, 
    0.37028903f, 0.07340977f, -0.08817770f, -0.39346758f, -0.11418305f, 0.00341528f, 0.09497195f, -0.00919963f, 
    0.07338181f, 0.03108163f, 0.05484635f, 0.06905279f, -0.38343078f, -0.04881198f, -0.00711364f, 0.10857324f, 
    -0.11201125f, 0.01569882f, -0.07934216f, 0.16848218f, 0.07735234f, 0.18965292f, -0.03254958f, -0.01811149f, 
    -0.46515900f, 0.06560465f, 0.12654494f, 0.26032934f, 0.06442206f, -0.03538639f, 0.01952609f, 0.18308353f, 
    -0.05247936f, 0.01814683f, 0.06060505f, 0.01880391f, 0.06995168f, 0.03227484f, -0.34397885f, -0.01166547f, 
    -0.00014409f, 0.03117801f, 0.01642871f, 0.03864840f, -0.01668525f, -0.21601048f, -0.19308092f, -0.22698642f, 
    -0.18993331f, -0.28965032f, -0.08123678f, -0.00174945f, 0.16651955f, -0.06237650f, 0.06398578f, 0.08788291f, 
    0.00396602f, -0.07577251f, -0.04224373f, -0.16695942f, -0.04315272f, -0.00115847f, -0.09434263f, -0.11782142f, 
    -0.01957922f, -0.00424974f, 0.02696458f, -0.05022389f, 0.06951671f, 0.07788553f, 0.08124623f, 0.11442797f, 
    0.02879050f, -0.18849844f, -0.18626711f, -0.07531871f, 0.09165904f, -0.03618077f, 0.05623977f, -0.01570324f, 
    0.02049821f, 0.03051612f, 0.02467788f, 0.04067007f, -0.13354155f, -0.01466789f, 0.10318024f, 0.22223979f, 
    -0.04912107f, -0.00965472f, 0.02456236f, 0.04422395f, 0.06580026f, 0.16308482f, -0.05464221f, 0.02926937f, 
    -0.10216419f, -0.19563854f, 0.03106528f, 0.07181354f, -0.09235856f, 0.15203534f, 0.05136168f, -0.09696665f, 
    0.03369199f, 0.08867026f, 0.04690979f, 0.16552827f, 0.12396641f, -0.00865612f, 0.16243842f, -0.14929029f, 
    -0.02548992f, -0.06463542f, -0.08814117f, 0.01237428f, -0.12662433f, 0.07581560f, -0.05330320f, -0.08566850f, 
    -0.41391310f, -0.60489762f, -0.45925921f, -0.20477547f, -0.01128699f, -0.01948286f, -0.04236209f, 0.13009290f, 
    -0.10005990f, 0.05168902f, -0.10183814f, -0.02776692f, -0.02412758f, 0.04647937f, 0.03376115f, 0.17995818f, 
    -0.03380574f, -0.02306455f, 0.06913307f, 0.01875322f, 0.19174761f, 0.02352460f, -0.07797708f, 0.18322432f, 
    -0.25181878f, -0.06430860f, -0.15473700f, 0.17921731f, 0.02934184f, 0.06377952f, 0.03859330f, 0.01267713f, 
    0.01804356f, -0.01122650f, -0.03309548f, -0.25627267f, -0.01653977f, -0.15760669f, -0.16359405f, -0.10933197f, 
    0.01553004f, 0.04800488f, -0.02955791f, -0.01606171f, 0.11814318f, -0.12912999f, 0.00498915f, -0.18009831f, 
    -0.55804026f, 0.06915721f, 0.13847561f, 0.29610074f, 0.09101018f, -0.04445291f, -0.13628167f, -0.02178476f, 
    0.00919553f, 0.03157663f, 0.12990475f, 0.07486198f, 0.32338172f, 0.09489527f, -0.40285096f, 0.01407657f, 
    0.18169908f, 0.12110855f, 0.06296325f, 0.17533180f, 0.05716361f, 0.00694405f, 0.03682061f, 0.12268813f, 
    -0.09595064f, 0.05734958f, 0.00881248f, 0.03771842f, 0.10988829f, -0.10858184f, -0.00155564f, 0.00692692f, 
    0.09542020f, -0.13582155f, 0.03309557f, -0.00880988f, -0.01393978f, -0.56389606f, -0.52525401f, 0.01288131f, 
    0.07228751f, -0.00061993f, -0.02169707f, -0.06003715f, -0.00885760f, 0.01203852f, 0.05757005f, 0.06896275f, 
    0.15477429f, -0.18437640f, -0.20801756f, -0.14293170f, -0.04547291f, -0.12304965f, -0.01554998f, -0.03174749f, 
    0.17233184f, 0.19354169f, 0.17798416f, 0.11759000f, 0.15942323f, -0.07899423f, -0.26422432f, -0.19311026f, 
    -0.09473645f, -0.14318587f, -0.14644001f, -0.07477369f, 0.05460215f, 0.08775956f, -0.00651609f, 0.13316853f, 
    0.05697962f, -0.06591118f, 0.01256249f, -0.24484363f, -0.02017244f, -0.06741472f, 0.00057696f, -0.04226437f, 
    -0.12156976f, -0.15711381f, -0.19672796f, -0.06563905f, 0.15920712f, 0.13196965f, 0.03869520f, -0.01798275f, 
    -0.02274710f, -0.03679574f, -0.00974026f, 0.01237182f, 0.07872723f, 0.01231601f, 0.16216885f, 0.05400155f, 
    -0.02976847f, -0.25554770f, 0.06070221f, 0.06258774f, -0.02555837f, 0.05248203f, 0.02210180f, -0.06869572f, 
    -0.01602666f, 0.15581457f, 0.14359890f, 0.06992270f, -0.22860867f, 0.13224857f, -0.29470706f, 0.12583767f, 
    0.06087818f, 0.03292303f, 0.20259902f, -0.06393979f, 0.11301545f, -0.04515248f, -0.00758749f, -0.11761910f, 
    0.19466054f, -0.24507144f, -0.06037645f, -0.07083387f, 0.16413462f, 0.05809027f, -0.08922114f, 0.10593480f, 
    -0.03094729f, -0.03087985f, -0.18451646f, -0.12110955f, -0.31915593f, 0.00172790f, -0.10898228f, -0.05605425f, 
    -0.06739401f, 0.08008486f, 0.00211088f, 0.07603373f, 0.03909102f, 0.02187777f, 0.12741470f, -0.02107317f, 
    -0.35908973f, -0.05784087f, -0.03540449f, 0.28071988f, 0.00910762f, 0.11138752f, -0.19143744f, -0.10909519f, 
    0.17823052f, 0.09604433f, 0.04289753f, 0.04777426f, 0.31488764f, -0.12594743f, -0.14377195f, -0.13438179f, 
    0.05575720f, 0.08137947f, -0.09065113f, -0.00897689f, 0.02618268f, -0.04314538f, -0.10201158f, -0.02362703f, 
    -0.21735789f, 0.32412809f, -0.49994186f, 0.01396524f, -0.11108804f, 0.01141941f, -0.23794232f, -0.11133567f, 
    0.03975101f, -0.16090542f, 0.02738272f, 0.02538686f, -0.04633955f, -0.10911280f, 0.20925915f, 0.34757620f, 
    -0.06217555f, -0.02104783f, -0.22635646f, 0.00947529f, 0.17091854f, 0.08738697f, 0.00814870f, 0.13653715f, 
    -0.44920146f, 0.26740494f, -0.05622377f, 0.35400015f, 0.25924870f, -0.16455667f, -0.09846571f, 0.02459211f, 
    0.01421315f, -0.17632905f, 0.06069676f, -0.16255809f, 0.04356501f, -0.17442437f, 0.06387381f, 0.20423082f, 
    0.02986740f, 0.08923718f, -0.11835489f, -0.21532956f, 0.22634506f, 0.12963104f, -0.00005572f, -0.08901907f, 
    0.03815806f, -0.24606873f, 0.00559324f, -0.01916621f, 0.12313983f, -0.04912391f, 0.03591292f, -0.05863139f, 
    -0.04832036f, 0.06164042f, -0.00628004f, 0.05531158f, -0.09793049f, -0.03871658f, 0.11494907f, 0.32356569f, 
    0.12732451f, 0.08335762f, -0.06200048f, 0.03868584f, 0.05578383f, -0.03148631f, -0.17204064f, 0.02165259f, 
    -0.30461845f, 0.04370299f, 0.03213239f, -0.46003062f, 0.03526774f, -0.13526455f, 0.10060801f, 0.04677856f, 
    0.02834029f, -0.03262434f, -0.10995953f, -0.07936998f, 0.44247365f, -0.21414974f, 0.07413694f, 0.05648870f, 
    -0.02353723f, -0.02281149f, -0.25137597f, 0.02085748f, -0.00865449f, -0.04350103f, 0.06123351f, 0.11777564f, 
    0.14028288f, -0.32560259f, -0.03958083f, -0.30733579f, -0.13750063f, -0.08081945f, -0.03673803f, 0.03623398f, 
    -0.09833224f, -0.05194521f, -0.03704291f, 0.14394955f, 0.02825407f, -0.02058040f, 0.16963978f, -0.13535824f, 
    0.03681323f, 0.00205792f, -0.03558537f, -0.16790181f, -0.01468776f, -0.03718709f, 0.03430048f, 0.01634570f, 
    0.02091224f, -0.05797671f, 0.10157086f, -0.10800552f, -0.04199480f, -0.05948820f, 0.10626309f, -0.01407440f, 
    -0.01209231f, 0.06218227f, 0.09682630f, 0.14140545f, -0.15427990f, -0.10221148f, -0.18586825f, -0.37201101f, 
    0.04750419f, 0.06348965f, 0.01365694f, 0.04771550f, 0.06938726f, -0.08562468f, 0.08501735f, 0.02901964f, 
    -0.11223388f, 0.06055739f, 0.08609149f, 0.24108820f, -0.00439205f, -0.01214055f, -0.20156513f, -0.14027746f, 
    -0.13408969f, 0.01265813f, -0.00424271f, 0.07654961f, 0.11844683f, 0.23516425f, 0.33514550f, 0.45360380f, 
    0.14073633f, -0.12664101f, -0.06276304f, -0.19912460f, 0.11770070f, 0.03699207f, -0.04504180f, 0.08341216f, 
    -0.21691628f, 0.16308339f, 0.18539238f, -0.07728135f, 0.02849376f, -0.04877532f, 0.04476573f, 0.00247135f, 
    0.07535934f, 0.06283990f, 0.13566238f, 0.13310881f, -0.36545974f, -0.15688874f, -0.06376179f, 0.05729052f, 
    0.06250539f, 0.04600308f, 0.09771068f, -0.12513979f, -0.03718096f, -0.01909827f, -0.16705438f, 0.09296145f, 
    -0.07223049f, 0.27366835f, -0.45921302f, 0.09005258f, -0.00889436f, 0.09704261f, 0.07236664f, 0.01839316f, 
    0.06659617f, -0.03537762f, 0.06731126f, -0.05949863f, -0.15567742f, -0.01491346f, -0.09772879f, 0.16260016f, 
    -0.23118371f, 0.05635079f, -0.00559320f, 0.18099682f, 0.09504011f, -0.05891271f, -0.00604850f, -0.00930930f, 
    0.14093114f, 0.03702855f, -0.12160917f, 0.05491532f, -0.16359475f, -0.06167478f, -0.09923266f, -0.03479180f, 
    0.13679683f, -0.16858259f, -0.07972245f, -0.03354454f, -0.00642091f, -0.10260240f, 0.12277742f, 0.19039497f, 
    -0.01209006f, 0.11991744f, 0.03213310f, -0.09144427f, 0.01737636f, 0.17323667f, 0.03611425f, -0.07119391f, 
    -0.03494432f, 0.09997176f, -0.21814096f, 0.09662943f, 0.12687062f, 0.06790108f, -0.06043133f, -0.17119589f, 
    0.08842652f, -0.08202862f, -0.15345255f, -0.03706492f, -0.20941225f, 0.15824886f, -0.26985699f, 0.14363225f, 
    0.05946713f, -0.00953664f, 0.10261185f, -0.03209321f, -0.03808112f, 0.02111364f, 0.17775057f, 0.16944355f, 
    0.07648674f, -0.07853624f, 0.10432559f, -0.32369739f, -0.12162930f, -0.10213785f, 0.17719986f, 0.03270441f, 
    0.01285022f, 0.01493131f, 0.02497427f, 0.00855176f, -0.11458118f, -0.37501103f, -0.34960121f, 0.01333175f, 
    0.12730354f, 0.23753409f, 0.10993938f, 0.05265309f, 0.11061183f, -0.00011716f, 0.04465673f, -0.03865292f, 
    -0.05284335f, -0.30001700f, -0.19685954f, 0.10424206f, -0.01200084f, 0.09930528f, -0.05462492f, -0.10210031f, 
    -0.01564110f, 0.04041125f, -0.12680306f, -0.02717155f, 0.11278306f, 0.16020785f, -0.44606742f, -0.04181610f, 
    0.05485443f, 0.01316515f, 0.22392970f, 0.06820229f, 0.06396191f, 0.00555714f, 0.01144052f, -0.05090831f, 
    0.23347913f, -0.04683733f, -0.28264257f, -0.02294246f, 0.12628521f, 0.08184064f, 0.07821950f, -0.00346286f, 
    0.07141661f, -0.06574784f, 0.04747095f, 0.00513246f, 0.09213090f, 0.41074848f, -0.06771976f, -0.17886581f, 
    0.10335229f, -0.01797883f, 0.15968841f, -0.00694324f, 0.19714037f, -0.00782208f, -0.13225649f, -0.06218781f, 
    -0.00828962f, -0.20040403f, -0.19337808f, -0.02623278f, 0.04394708f, -0.02888737f, 0.06341739f, 0.10452899f, 
    -0.01479528f, 0.03404735f, 0.00899504f, -0.10705318f, 0.08790303f, -0.23012201f, 0.08324532f, -0.03054612f, 
    0.00735400f, -0.03449346f, 0.06197016f, -0.05483737f, 0.10892720f, 0.01286484f, 0.10251164f, -0.00100775f, 
    -0.24244536f, -0.10911340f, -0.06648512f, 0.17666784f, -0.12457573f, -0.14969194f, 0.02036801f, 0.04333811f, 
    0.02437568f, 0.11068011f, 0.09118363f, 0.01044804f, 0.23841526f, -0.08027676f, 0.26616290f, -0.21583487f, 
    0.03545754f, -0.29513970f, 0.00228876f, -0.08602244f, -0.06876271f, -0.02651096f, 0.03879142f, 0.12671007f, 
    0.37187746f, -0.01793702f, 0.06992521f, 0.00621790f, -0.03744332f, -0.13560259f, -0.11924671f, -0.32102856f, 
    0.00653420f, -0.08126820f, 0.02820883f, 0.07260180f, 0.08622081f, -0.12813759f, -0.06375874f, -0.16113344f, 
    0.06670307f, 0.13796328f, -0.04769281f, 0.08283723f, 0.03643180f, -0.01363306f, 0.04341331f, -0.08245025f, 
    -0.32020137f, -0.00342471f, -0.27912572f, 0.22103144f, 0.21629584f, -0.06725613f, 0.05121028f, -0.06063939f, 
    0.13986833f, 0.00880781f, -0.04827587f, 0.05808281f, -0.16482981f, 0.07608267f, -0.24457870f, -0.11354572f, 
    0.02061033f, 0.08709254f, 0.14527640f, -0.05149323f, 0.07283916f, -0.03421812f, -0.01783094f, 0.05915025f, 
    -0.12904778f, -0.12049823f, 0.34482267f, -0.06618030f, 0.12636213f, -0.12152414f, 0.08920734f, 0.06858112f, 
    -0.11422340f, -0.05081895f, -0.00262558f, -0.17670564f, 0.02630672f, 0.22228740f, -0.16734441f, -0.30997849f, 
    -0.09689645f, -0.05030553f, 0.09776451f, 0.17039213f, 0.01903008f, 0.03546563f, 0.02962313f, -0.13264808f, 
    -0.19893804f, 0.48392057f, -0.48193559f, -0.18679473f, -0.08112284f, -0.01143085f, 0.09937356f, 0.01683858f, 
    0.10002532f, 0.02108556f, -0.18255553f, -0.02936641f, 0.04063442f, 0.08462363f, 0.17364733f, 0.44109094f, 
    0.02764549f, -0.07154052f, -0.24125560f, 0.06843615f, 0.21151827f, 0.00582887f, 0.07853159f, 0.12659815f, 
    0.05803369f, 0.16551046f, -0.12513068f, 0.24031055f, -0.10923281f, -0.06138653f, -0.07288606f, 0.04439586f, 
    0.03985121f, 0.10277213f, 0.08531830f, 0.01616314f, 0.06490387f, 0.04759568f, 0.09425329f, 0.29727814f, 
    0.21691720f, -0.04058651f, -0.04714835f, -0.02359065f, -0.03228302f, -0.07941045f, -0.01583021f, 0.01211220f, 
    0.21975112f, -0.11011456f, 0.07948890f, 0.51705635f, 0.03594343f, -0.05701409f, -0.22535574f, -0.28436089f, 
    -0.01833869f, -0.12701954f, 0.01462099f, -0.10359258f, 0.12940547f, -0.08620755f, 0.02444870f, -0.44745848f, 
    -0.00309542f, -0.09937897f, 0.05194797f, -0.06659868f, 0.09607526f, 0.05252827f, -0.10232019f, -0.00482710f, 
    0.02228273f, -0.28187418f, 0.19515291f, -0.70479608f, 0.00195312f, -0.22991617f, -0.20896457f, 0.05354909f, 
    -0.10213488f, -0.06026300f, -0.07644130f, 0.18601684f, -0.12217529f, -0.17498529f, -0.23195806f, 0.06347915f, 
    -0.13520366f, 0.29014954f, 0.05148702f, -0.09284998f, 0.16194344f, 0.04399497f, -0.03841260f, -0.11900512f, 
    -0.12888628f, 0.19716755f, 0.13542029f, 0.03752911f, -0.18411025f, -0.00457492f, 0.04972895f, 0.18723714f, 
    0.05825090f, 0.06948869f, 0.04799595f, -0.01246731f, 0.14198251f, -0.21501261f, 0.21020220f, -0.30105722f, 
    0.01337244f, -0.12152018f, -0.12260116f, 0.01854370f, 0.01976070f, -0.07264547f, -0.01418833f, 0.10076602f, 
    -0.15648299f, 0.07603151f, 0.18525203f, 0.11590131f, 0.02877901f, -0.09047680f, -0.12708838f, -0.07262547f, 
    -0.04694673f, 0.01613029f, -0.03525303f, -0.01536834f, 0.04101410f, 0.05326295f, -0.18513174f, 0.11390005f, 
    -0.00548912f, -0.28954461f, -0.03320499f, -0.22995698f, 0.18854146f, 0.06174215f, 0.09144106f, 0.09618925f, 
    -0.50913125f, 0.28352070f, -0.55359566f, -0.14364459f, 0.23597634f, -0.19232395f, 0.15264285f, -0.01325378f, 
    -0.03733636f, 0.03319917f, -0.05805464f, -0.09602372f, -0.50547850f, 0.11116560f, -0.34666073f, -0.20284265f, 
    -0.06637243f, -0.21686061f, 0.06876554f, 0.00876149f, -0.02950179f, -0.04559049f, 0.00441441f, 0.05587244f, 
    -0.24724902f, -0.12202201f, -0.41185004f, 0.00776664f, 0.23926882f, 0.01804777f, 0.14184596f, 0.08539677f, 
    -0.10839071f, -0.12600742f, -0.04363166f, -0.02569118f, -0.04626060f, 0.24585873f, 0.11744376f, -0.49912119f, 
    -0.13570219f, -0.07320810f, 0.05923291f, 0.09053555f, -0.00635033f, 0.03661624f, 0.00229304f, -0.07978894f, 
    0.04515611f, 0.11521244f, 0.13648789f, 0.13152562f, -0.08588836f, 0.12077151f, -0.05889716f, -0.07241292f, 
    -0.13987175f, -0.13437383f, -0.08385351f, -0.18272148f, -0.57694590f, -0.32468963f, -0.13362247f, -0.06175600f, 
    -0.00700569f, -0.00231528f, -0.11427773f, 0.15470062f, 0.00309380f, -0.02567762f, 0.06946759f, -0.07935367f, 
    0.09679253f, -0.36543015f, 0.12929030f, -0.04081858f, 0.05291956f, 0.11900672f, 0.10681666f, 0.03897091f, 
    -0.16906366f, -0.00708633f, 0.03534906f, 0.09255277f, -0.09210952f, -0.00656861f, -0.08565443f, 0.02102286f, 
    0.12792102f, 0.02867294f, 0.05346388f, 0.04480064f, -0.05423600f, -0.07138588f, -0.06908466f, -0.22887237f, 
    -0.16615939f, -0.00539200f, -0.24598835f, 0.13681449f, 0.05160158f, 0.17032342f, 0.03321652f, 0.05701450f, 
    -0.03078198f, -0.03387766f, -0.23496427f, -0.34906301f, -0.16128004f, -0.27227178f, -0.26600134f, -0.30178958f, 
    -0.15944771f, -0.22124593f, 0.10869016f, -0.05848043f, -0.11023602f, 0.06551000f, 0.04177340f, 0.14651553f, 
    -0.11586820f, -0.07082218f, 0.07320236f, 0.03771179f, 0.00684704f, 0.01347288f, -0.13077120f, -0.04707538f, 
    -0.05412488f, 0.12173064f, 0.00301620f, 0.02525400f, -0.03167574f, -0.54866362f, -0.22099078f, -0.02157929f, 
    -0.06647795f, 0.01110883f, -0.21259457f, 0.11458553f, 0.05647872f, 0.06937943f, -0.08836532f, -0.13871337f, 
    0.26177678f, 0.01478378f, -0.11921694f, -0.06129896f, -0.04184993f, 0.05972332f, 0.19645390f, -0.00827837f, 
    -0.19961683f, -0.08764576f, -0.03206246f, -0.11265895f, 0.00443480f, -0.38017145f, -0.00018991f, 0.10880002f, 
    0.04041942f, 0.18685077f, 0.18829679f, -0.04096727f, 0.03206920f, 0.11678858f, -0.08884533f, -0.01478572f, 
    0.24554679f, 0.24527583f, 0.04547977f, -0.03385471f, 0.09321284f, -0.18533003f, 0.10300772f, 0.12299786f, 
    -0.15627792f, 0.13554169f, -0.05944594f, -0.09385644f, -0.41537517f, 0.13767835f, -0.13170233f, -0.22438809f, 
    0.01198821f, 0.20865895f, -0.15081955f, -0.05545818f, -0.16228724f, -0.09432864f, -0.17434891f, -0.25273958f, 
    0.08628541f, 0.10054485f, 0.19896202f, -0.11479925f, -0.06474546f, 0.05167286f, 0.11252803f, 0.21289945f, 
    0.09089872f, 0.08044060f, -0.03433033f, 0.14570493f, -0.09169962f, 0.02971495f, 0.12767544f, -0.02212811f, 
    -0.04849669f, 0.04533134f, -0.06293873f, 0.09410787f, -0.23868971f, -0.17256321f, -0.01976830f, -0.16134113f, 
    -0.60896093f, 0.25561118f, -0.06310288f, 0.14056550f, -0.09713092f, -0.03127445f, 0.04105443f, 0.18562272f, 
    0.11739755f, -0.05932433f, 0.27951705f, 0.05220932f, -0.09693310f, -0.03599281f, 0.15434623f, -0.19809479f, 
    -0.15710798f, -0.07077364f, 0.00631538f, 0.04002588f, -0.01057457f, -0.17610711f, 0.05890995f, 0.11126858f, 
    0.00007414f, 0.05166139f, 0.35276669f, -0.04403068f, 0.07896233f, 0.08523450f, -0.00612773f, 0.12985580f, 
    -0.04025657f, -0.07051963f, 0.02920144f, 0.01878745f, -0.06134087f, 0.31106037f, 0.11698537f, 0.11486566f, 
    0.01875219f, 0.04090556f, -0.14053221f, 0.01319231f, -0.06062550f, 0.16836368f, 0.05514645f, -0.09598614f, 
    -0.03041602f, 0.07079902f, -0.07184685f, 0.03433238f, -0.04549546f, -0.00798698f, -0.21199526f, -0.12150322f, 
    0.08192664f, 0.10015578f, -0.00201096f, -0.07070120f, -0.01066953f, 0.06347495f, 0.26705918f, -0.04313735f, 
    -0.06033614f, 0.12734267f, 0.04443782f, -0.06061373f, 0.00112829f, 0.00274334f, 0.01072163f, 0.02476955f, 
    -0.05274976f, 0.14649047f, -0.06328660f, -0.01845079f, -0.02783458f, -0.04895626f, -0.08740937f, -0.02224446f, 
    0.03935097f, -0.13057120f, -0.18840256f, -0.05953761f, 0.21088721f, -0.32612363f, 0.24329665f, 0.41296187f, 
    0.02081908f, -0.07468419f, -0.00129373f, 0.06829719f, -0.04157944f, -0.02807995f, -0.10466903f, -0.03282191f, 
    0.12114329f, 0.07115409f, -0.00437332f, 0.04898083f, 0.02604895f, -0.05331386f, 0.05351416f, -0.03764888f, 
    0.01332739f, 0.13428394f, -0.09810185f, 0.04099933f, -0.29205716f, 0.14656152f, -0.06146025f, -0.12394705f, 
    -0.05503927f, 0.00390009f, 0.02335254f, -0.03137293f, 0.06370603f, 0.01331808f, -0.00532874f, -0.07223035f, 
    0.04066837f, 0.00087956f, 0.04285837f, 0.09207862f, 0.05975874f, 0.05080174f, 0.02949825f, 0.05956002f, 
    -0.08022993f, -0.11079475f, -0.42857283f, -0.28605700f, 0.03517234f, -0.23091257f, 0.15231590f, 0.12015930f, 
    -0.11360011f, 0.03415622f, -0.10650899f, 0.27062070f, 0.14761034f, -0.18180852f, 0.09524336f, -0.04086100f, 
    -0.09894490f, -0.01992710f, -0.31786063f, 0.18562868f, 0.01683565f, 0.03407037f, 0.19487815f, 0.00441202f, 
    -0.08815024f, -0.00458528f, -0.13425662f, -0.03651888f, -0.38915551f, 0.03133982f, -0.18908633f, 0.04146481f, 
    0.07919689f, 0.18574649f, -0.19865383f, 0.12484398f, -0.11706823f, 0.05601188f, 0.02073150f, -0.02502237f, 
    -0.28036571f, 0.06521789f, 0.22272773f, -0.18576020f, -0.18228716f, 0.11982158f, -0.10682068f, -0.00752744f, 
    -0.01568892f, 0.04687965f, 0.16077530f, 0.09312740f, -0.28839290f, 0.09481024f, -0.03491351f, -0.21797048f, 
    -0.08040414f, -0.00903216f, -0.00921992f, -0.07002989f, 0.05557462f, -0.15028329f, 0.03131893f, -0.08377384f, 
    -0.05761587f, 0.06549482f, 0.07962617f, -0.03714889f, -0.03343675f, -0.00228740f, 0.16016148f, 0.05823119f, 
    -0.14955707f, 0.07322767f, -0.03247904f, -0.01336983f, 0.26197720f, -0.05466574f, 0.11640517f, -0.23754773f, 
    -0.17642833f, 0.03265135f, 0.03759405f, 0.05445530f, 0.01451535f, -0.10027655f, -0.34043616f, -0.23131029f, 
    0.06900229f, 0.01597289f, 0.02322722f, 0.07964554f, -0.13401711f, -0.00400607f, 0.22284913f, 0.08381353f, 
    0.01654682f, 0.12050188f, 0.11318135f, 0.12197208f, -0.12504379f, -0.07017554f, -0.24068804f, -0.16966857f, 
    -0.11460975f, -0.11172162f, -0.05726543f, -0.09541378f, -0.15424229f, -0.01401796f, 0.03845699f, -0.02173239f, 
    -0.12146527f, -0.16790816f, -0.00031353f, -0.04483969f, -0.14526170f, 0.06519539f, 0.01898582f, -0.00378743f, 
    0.03155002f, 0.13716772f, -0.26295355f, -0.14254823f, -0.06183681f, -0.09422245f, -0.07477452f, -0.05584994f, 
    -0.04729093f, -0.02258321f, 0.09742109f, -0.04120299f, -0.06049003f, 0.03266836f, -0.11439009f, -0.13175878f, 
    -0.28126696f, 0.05456629f, 0.02234481f, -0.11767227f, -0.06302372f, -0.10812760f, 0.01323186f, 0.05449964f, 
    0.00417673f, 0.05265131f, -0.06052616f, -0.09944701f, -0.16197918f, -0.28100860f, 0.02850110f, 0.08609596f, 
    -0.02386597f, 0.05732529f, 0.17994972f, -0.01101599f, -0.07987814f, 0.04645612f, 0.14271228f, 0.10065312f, 
    -0.19335948f, -0.27549270f, -0.29109466f, 0.00045521f, -0.04787749f, 0.11720692f, 0.11000493f, 0.01085159f, 
    0.04960958f, 0.11501872f, 0.02459697f, 0.05313197f, -0.43870983f, 0.28332457f, -0.48512304f, 0.05884836f, 
    -0.09864656f, -0.08976428f, 0.05932798f, 0.05282702f, -0.14218992f, -0.10436651f, 0.04066849f, 0.01035159f, 
    -0.14743148f, 0.23640679f, -0.09019838f, -0.10819970f, 0.00318523f, -0.04381389f, -0.04724439f, 0.03271477f, 
    -0.04807042f, 0.08118544f, -0.17616600f, -0.21074343f, -0.07897533f, 0.00127716f, 0.09751117f, -0.11831801f, 
    -0.07758375f, 0.04059663f, 0.06384169f, -0.03833833f, 0.04415841f, -0.08477853f, -0.06628615f, -0.17126930f, 
    -0.09052142f, 0.34710270f, -0.09371084f, -0.29334462f, -0.02483477f, -0.07414562f, 0.12239192f, 0.11986864f, 
    -0.08208645f, 0.15723401f, -0.10180479f, -0.08681710f, -0.00667409f, -0.18050596f, -0.05626601f, -0.29448569f, 
    -0.17317152f, -0.08191518f, 0.08228324f, 0.01258333f, -0.09714510f, 0.12410680f, -0.11218058f, -0.06731721f, 
    -0.01600838f, 0.31254461f, 0.03638576f, -0.26364663f, -0.25762102f, -0.07661550f, -0.09504429f, -0.02795761f, 
    0.01570446f, 0.03144081f, -0.25023964f, 0.05244901f, 0.21259215f, -0.19583803f, 0.13603710f, 0.11287645f, 
    -0.09426212f, 0.01326196f, 0.03752076f, -0.03279297f, -0.10897233f, -0.04284583f, 0.00426356f, -0.06648030f, 
    -0.64429510f, 0.13505638f, -0.20845360f, 0.41629022f, 0.11681864f, 0.04168848f, -0.01413830f, 0.05760361f, 
    -0.11458279f, -0.07422654f, -0.09126211f, -0.00797161f, 0.16090691f, -0.24376933f, 0.03145770f, 0.25403741f, 
    -0.14303176f, -0.06639651f, -0.02127289f, -0.05738202f, -0.19923688f, 0.04300826f, -0.10555134f, -0.00822046f, 
    0.03293700f, -0.17312963f, 0.17435421f, 0.23949948f, -0.10164338f, 0.00052478f, 0.04949377f, -0.04389005f, 
    -0.05710297f, 0.01492692f, 0.12586157f, 0.13409923f, -0.25224909f, 0.06570917f, -0.08913899f, -0.11206964f, 
    0.02517578f, 0.12136730f, -0.18046987f, 0.01545096f, -0.14473641f, -0.08345859f, -0.29255548f, -0.18949151f, 
    -0.14402008f, 0.11464471f, -0.15048565f, 0.06556316f, 0.05983658f, 0.11388990f, -0.04942337f, 0.11324483f, 
    0.02493245f, -0.04964066f, -0.12714718f, -0.17768213f, -0.13228860f, 0.31276700f, -0.14051551f, -0.10213152f, 
    -0.01522327f, 0.05887625f, 0.08920404f, -0.06089038f, 0.05426845f, 0.02164054f, 0.02343352f, 0.08837670f, 
    -0.07356228f, 0.11273746f, 0.11179008f, 0.16968332f, -0.11882096f, 0.06501097f, 0.02270333f, 0.02710318f, 
    0.02175357f, -0.03816728f, -0.02883666f, -0.07696036f, 0.24226639f, 0.04637665f, 0.31517369f, 0.45491707f, 
    -0.04325777f, 0.06856465f, 0.19799945f, -0.03652501f, 0.00028075f, -0.02217799f, 0.05322535f, 0.08535154f, 
    -0.32340372f, 0.37305647f, 0.08890149f, 0.04571400f, 0.01544392f, 0.05023478f, -0.05906986f, 0.15970606f, 
    -0.02718499f, -0.06590938f, 0.00963884f, -0.05549033f, -0.08265167f, -0.20656486f, 0.13082612f, -0.12964919f, 
    -0.10175762f, -0.00040576f, 0.04975625f, 0.05217882f, -0.10966410f, -0.02023734f, -0.13265455f, 0.06060047f, 
    -0.26775038f, -0.07511447f, -0.15677428f, 0.03789862f, 0.05541205f, -0.03157729f, -0.04950749f, -0.01157541f, 
    0.01486286f, 0.17668016f, -0.01998441f, -0.06085689f, -0.18958777f, 0.14597182f, 0.08897626f, 0.07788278f, 
    -0.02647774f, 0.15975359f, -0.02425089f, 0.03083681f, -0.01525138f, 0.05646997f, 0.17557742f, 0.11020400f, 
    0.32005975f, -0.03074630f, 0.08283854f, -0.28582427f, -0.02960559f, -0.04719013f, 0.08973831f, -0.01372990f, 
    -0.12923072f, -0.28415802f, -0.22430021f, -0.03655652f, -0.07813348f, 0.06832518f, 0.14832130f, -0.04630670f, 
    -0.00094733f, -0.00033237f, -0.11524588f, 0.09247497f, -0.03292486f, -0.05849673f, -0.06946324f, -0.18468912f, 
    0.10274687f, -0.19409211f, -0.25643983f, 0.09655433f, -0.28650206f, 0.26836231f, 0.17473136f, 0.01446911f, 
    -0.02449126f, 0.04653252f, -0.04177698f, 0.10367814f, -0.29328483f, 0.22723104f, 0.28991443f, 0.22455381f, 
    -0.06476417f, 0.13285267f, -0.02519756f, -0.08046867f, -0.04255718f, 0.09549338f, 0.18467070f, 0.11709544f, 
    -0.12216130f, -0.06798504f, 0.04655151f, -0.29673895f, -0.16727585f, 0.02685984f, -0.13886008f, 0.15068229f, 
    -0.11529236f, 0.06338084f, 0.19440682f, -0.11559192f, -0.15700570f, -0.21031722f, 0.16000591f, 0.04078577f, 
    -0.04354260f, -0.04384107f, -0.06126457f, 0.09131099f, 0.07712890f, 0.11444166f, -0.04981535f, -0.07257076f, 
    -0.17107737f, 0.31850904f, -0.00445583f, 0.02644881f, 0.03443456f, 0.02614273f, 0.08375680f, 0.01638167f, 
    0.00874949f, 0.04810445f, 0.17319806f, 0.13166618f, -0.25068790f, 0.07631207f, -0.16825223f, 0.14029638f, 
    0.02802155f, 0.09657075f, 0.04467892f, 0.18006030f, -0.04761806f, 0.07643942f, 0.03735639f, 0.11769065f, 
    -0.26755565f, 0.03197180f, -0.13929966f, -0.03526370f, -0.17962123f, 0.05463714f, -0.00511052f, -0.08933550f, 
    0.15021195f, -0.17256154f, -0.20742244f, -0.14348139f, -0.14118452f, 0.17688835f, 0.00436251f, -0.04159030f, 
    -0.05965610f, 0.11009225f, -0.04847442f, 0.12011722f, 0.26443118f, -0.01021953f, 0.16521117f, 0.15325555f, 
    -0.37134519f, -0.25506604f, -0.22946857f, 0.05282351f, 0.04693784f, -0.04121160f, -0.00032547f, -0.03493371f, 
    0.02715914f, -0.01450755f, 0.10487571f, 0.18153997f, 0.33210009f, 0.03490180f, 0.24457245f, -0.15484966f, 
    0.00317690f, 0.15363660f, -0.09796159f, 0.10727654f, -0.13539745f, -0.06345819f, 0.04791562f, -0.09454593f, 
    0.16160296f, 0.04293471f, 0.10471413f, -0.07492563f, -0.12158415f, 0.18931626f, -0.11376112f, 0.10430499f, 
    -0.01842939f, -0.02609268f, -0.05700333f, -0.06450475f, 0.01875212f, -0.15236045f, -0.01803430f, 0.03480705f, 
    -0.24029319f, 0.10250886f, 0.01178919f, -0.02153980f, -0.00447067f, 0.02907318f, 0.00498738f, -0.04705613f, 
    -0.33101425f, -0.16575161f, 0.07577789f, 0.04718420f, 0.07261176f, 0.09436537f, 0.18109123f, -0.10028967f, 
    -0.04380317f, -0.02238395f, 0.18901305f, 0.04024495f, -0.23272198f, 0.45365995f, -0.01859493f, 0.11732178f, 
    -0.13818908f, -0.11688505f, 0.03473540f, -0.10741886f, 0.06365533f, 0.01371282f, 0.01091104f, 0.01337110f, 
    -0.32062292f, -0.06754207f, -0.00908896f, 0.01056022f, -0.00623402f, -0.03589571f, 0.21696523f, -0.25873682f, 
    -0.07826647f, -0.14080521f, -0.18702483f, -0.02417440f, -0.14236048f, 0.00493295f, -0.18293905f, 0.09326335f, 
    0.13083731f, -0.10269949f, 0.11600886f, -0.06017736f, 0.05858040f, 0.16472311f, 0.14563057f, 0.10797708f, 
    0.18800662f, -0.00437600f, 0.15809134f, -0.03810807f, 0.03229458f, 0.16726899f, -0.01954215f, -0.02250238f, 
    -0.06512689f, -0.11567307f, -0.03195745f, 0.02697951f, -0.15364088f, 0.10827301f, -0.12026744f, -0.17523724f, 
    -0.00429305f, -0.03520745f, 0.03885395f, 0.03302550f, 0.15825906f, 0.15767229f, 0.22320884f, -0.18045762f, 
    -0.22323418f, -0.10945842f, -0.31001621f, 0.19232196f, 0.13163914f, 0.07411742f, 0.00616708f, 0.07968570f, 
    0.00397216f, -0.02182264f, 0.03484976f, 0.14832097f, 0.02577400f, -0.00418279f, -0.09947641f, -0.08062018f, 
    0.02809287f, 0.07677332f, -0.09170523f, -0.00943369f, 0.00621201f, 0.04323345f, 0.02865794f, -0.16436753f, 
    0.03077596f, -0.03105722f, -0.16088630f, 0.24556261f, -0.11725949f, 0.15538375f, -0.15215556f, 0.11836383f, 
    -0.24857825f, 0.00838173f, 0.07093174f, 0.11322829f, -0.47358981f, 0.01429901f, -0.10510989f, 0.19521892f, 
    -0.01246582f, -0.08308303f, -0.01890608f, 0.01135070f, -0.15405631f, 0.01258918f, -0.03165814f, -0.07182402f, 
    0.12822346f, 0.13244456f, 0.42077196f, 0.24732240f, -0.05311465f, -0.00957366f, 0.10876532f, 0.04702489f, 
    0.16648769f, -0.07095125f, 0.04452149f, 0.01865250f, 0.00290684f, -0.03217590f, -0.12785769f, -0.02840110f, 
    0.02614416f, 0.11614425f, -0.01566991f, 0.05962079f, -0.14336510f, 0.15232956f, 0.00020533f, 0.01147601f, 
    -0.03817498f, 0.08530063f, 0.05210053f, 0.02988428f, -0.06513035f, 0.01009485f, -0.00380832f, 0.05550372f, 
    -0.00671809f, -0.02681320f, 0.00465298f, 0.09947031f, 0.00409103f, -0.11196242f, 0.22319140f, -0.06457409f, 
    0.02045024f, 0.24534060f, -0.02595006f, -0.15583564f, 0.01216284f, -0.03130711f, -0.06818605f, -0.09549093f, 
    -0.31278810f, -0.34835082f, -0.18784249f, 0.29631090f, -0.09775884f, -0.14708863f, -0.00037656f, -0.07835414f, 
    -0.04826219f, -0.06771982f, -0.06664379f, -0.12311280f, -0.21467111f, -0.19242053f, -0.27022982f, 0.10525904f, 
    0.11413991f, -0.01311303f, 0.02238707f, -0.04264007f, 0.04247299f, 0.04761476f, 0.02204165f, 0.02965597f, 
    0.12335603f, -0.08155537f, 0.14114481f, -0.10246670f, -0.00154638f, 0.18815637f, -0.15369293f, -0.03697006f, 
    0.02929315f, 0.03125214f, 0.17096955f, -0.00269569f, -0.07886510f, 0.31080124f, 0.29569256f, -0.02834957f, 
    0.02426190f, 0.00580099f, 0.07060098f, 0.07027867f, 0.07326927f, 0.05421197f, 0.12021160f, 0.08615585f, 
    0.26467794f, -0.01915421f, 0.29619330f, 0.28678733f, -0.04931638f, -0.04793847f, 0.11572018f, 0.09050012f, 
    -0.18437721f, 0.01534836f, 0.03998028f, 0.05640326f, 0.09808505f, 0.11312316f, -0.00718329f, -0.14588372f, 
    0.02110085f, -0.03071984f, 0.00491806f, -0.03538300f, -0.00115140f, -0.01878897f, -0.01823017f, -0.10858797f, 
    -0.13656570f, 0.22007202f, -0.21610349f, 0.09374694f, 0.20811939f, -0.06040338f, 0.11081017f, -0.11631113f, 
    0.12836339f, 0.06875373f, -0.07226924f, -0.02014097f, -0.31983954f, 0.35795024f, -0.27134508f, 0.03500174f, 
    0.01095124f, 0.01380760f, 0.04818761f, -0.01768768f, -0.03345587f, -0.01099597f, 0.01638994f, 0.01377171f, 
    -0.01866221f, 0.16817060f, 0.09448794f, 0.04856563f, 0.09523323f, -0.00589519f, 0.10879598f, 0.02153228f, 
    -0.00290848f, -0.08520542f, 0.12672779f, -0.13057750f, 0.16035978f, -0.13495338f, 0.10658551f, -0.26230159f, 
    0.10536509f, 0.09638831f, 0.06514693f, 0.05952893f, 0.04670557f, 0.17489834f, 0.05212647f, 0.02594347f, 
    0.00099513f, 0.16836725f, -0.04563309f, -0.14480639f, 0.09505874f, 0.06109605f, -0.20014571f, 0.01474598f, 
    -0.01001103f, 0.00500500f, -0.25043797f, -0.18427822f, 0.22301517f, 0.16873758f, -0.07398503f, 0.08155423f, 
    -0.08128528f, -0.11906770f, 0.00331966f, -0.00265803f, -0.09459770f, 0.02700460f, -0.06527989f, -0.08326343f, 
    -0.18669820f, 0.00172851f, -0.00616328f, 0.20100331f, 0.10615186f, -0.16076742f, 0.11210745f, -0.03977473f, 
    0.11058352f, 0.02544521f, 0.07477828f, 0.10804427f, 0.37966409f, -0.13217646f, 0.34333736f, -0.32690674f, 
    -0.10184585f, 0.02788765f, -0.41237417f, 0.00824120f, -0.00028059f, 0.05201022f, 0.05672970f, 0.09646102f, 
    0.24243656f, 0.06032618f, 0.05971916f, -0.09640548f, 0.14182012f, -0.04197939f, 0.01773351f, 0.00141664f, 
    -0.02559787f, 0.00969889f, 0.07788347f, 0.00381370f, 0.27061233f, 0.10853302f, 0.27889836f, -0.08097247f, 
    -0.00868543f, 0.14417979f, -0.22054689f, -0.00422360f, -0.17618607f, -0.08399989f, 0.02886361f, 0.02877459f, 
    0.02546010f, -0.11412158f, 0.14347167f, -0.17735083f, -0.32411486f, -0.08657650f, -0.05890867f, -0.20886457f, 
    -0.02703761f, 0.03596229f, 0.04233101f, -0.04265416f, 0.10331350f, -0.07625130f, 0.01618516f, 0.26689342f, 
    0.02498906f, -0.01136325f, -0.02255577f, 0.10485269f, -0.05773693f, 0.02804455f, 0.10269666f, -0.06676412f, 
    0.09355014f, -0.26104173f, -0.10200185f, -0.26377326f, 0.08074334f, -0.21841678f, -0.13403820f, 0.02935273f, 
    0.08496967f, 0.08059437f, 0.11160398f, 0.03845507f, -0.02510603f, -0.01643272f, -0.27999088f, -0.49437115f, 
    0.03384238f, -0.10933834f, -0.09360469f, 0.01371279f, -0.14077100f, 0.08007778f, 0.07261467f, -0.11821028f, 
    -0.18957649f, 0.06752024f, -0.04972457f, 0.02216941f, 0.08283022f, -0.08291779f, 0.00673689f, 0.00035449f, 
    -0.01523806f, 0.12567408f, 0.02374173f, -0.10140182f, 0.08464427f, 0.12813795f, -0.05079824f, 0.08440270f, 
    -0.05730443f, -0.02428837f, 0.08616636f, 0.08593859f, 0.01245817f, -0.04238704f, 0.00174995f, -0.04627336f, 
    0.06773034f, -0.19558769f, 0.19149385f, -0.09194656f, 0.03983187f, -0.00254075f, 0.03537278f, -0.03979432f, 
    0.11310146f, 0.05497894f, 0.18356191f, -0.04729283f, 0.01241533f, -0.05728244f, 0.19600415f, -0.15718453f, 
    -0.06460785f, 0.10009813f, 0.13418286f, 0.14255601f, -0.12777337f, 0.00992910f, 0.00051091f, 0.04913782f, 
    -0.33324227f, -0.14498471f, -0.09270214f, 0.38168383f, -0.01306114f, 0.13220833f, -0.09109907f, 0.02855338f, 
    -0.05471312f, 0.13216220f, 0.11549957f, 0.01380637f, -0.32487798f, -0.06715325f, 0.27128586f, 0.06216796f, 
    -0.13095318f, 0.10940286f, 0.02285639f, -0.16019401f, -0.02621501f, -0.00007714f, 0.07183062f, 0.07994206f, 
    0.08917902f, -0.02875478f, 0.48951510f, -0.07594587f, -0.04239218f, 0.06376904f, -0.18199418f, -0.04259327f, 
    -0.02590921f, 0.06146308f, -0.00928496f, -0.07808305f, -0.26162091f, -0.06735674f, -0.04699243f, 0.07149602f, 
    0.08481909f, 0.00394664f, 0.05134823f, -0.02910770f, -0.08143336f, 0.06640384f, 0.22341424f, 0.04549498f, 
    -0.24716200f, -0.02725188f, 0.17555477f, 0.15435205f, -0.21089621f, -0.14115764f, 0.04332137f, 0.02195536f, 
    0.05911223f, 0.06587086f, 0.02939405f, 0.14987165f, -0.12038556f, -0.23947482f, 0.00542966f, 0.21168151f, 
    0.09739109f, -0.01075266f, 0.02174641f, 0.02813439f, 0.07824430f, -0.06593266f, 0.02553875f, -0.08435787f, 
    -0.25650650f, 0.08206471f, -0.02825885f, -0.01240590f, -0.00709248f, 0.01648729f, -0.03186501f, 0.11774257f, 
    0.09513193f, -0.00579374f, -0.03636518f, 0.07301813f, -0.21990865f, -0.00846517f, 0.15039620f, 0.22074856f, 
    -0.19441247f, 0.09360705f, 0.04963079f, 0.00559655f, -0.15012690f, -0.04086050f, -0.04884264f, -0.14682555f, 
    -0.39075521f, -0.22698294f, 0.03079507f, 0.35458508f, -0.05425526f, -0.00665529f, 0.06850751f, 0.40838531f, 
    -0.11238939f, 0.02271801f, -0.19357222f, -0.16411740f, 0.00135521f, 0.17563991f, -0.04720644f, -0.15480649f, 
    -0.02587781f, 0.05077529f, -0.02197612f, 0.06487649f, -0.03048199f, -0.05357432f, 0.07025905f, 0.02862928f, 
    -0.53408092f, -0.33372098f, -0.13067603f, -0.17272513f, -0.12838826f, -0.11815701f, -0.15595202f, -0.05957233f, 
    0.05631862f, -0.02707409f, -0.03245667f, 0.00517845f, 0.06083093f, 0.05437548f, -0.22306588f, 0.22254550f, 
    -0.06717181f, 0.02894775f, 0.08200038f, 0.19927788f, -0.06798539f, 0.04859891f, -0.01890888f, -0.13151324f, 
    -0.09430600f, 0.02956171f, -0.32124570f, -0.34534958f, 0.00592991f, -0.03651575f, 0.07909748f, -0.10083515f, 
    0.01542372f, 0.14846128f, 0.06316727f, 0.00861359f, 0.21232073f, -0.09953010f, 0.13637435f, -0.11985470f, 
    0.01237635f, -0.11501531f, 0.04187867f, 0.06379381f, -0.04206876f, 0.06592970f, 0.15066251f, 0.08233222f, 
    0.52815819f, -0.20435682f, 0.51926750f, -0.23143274f, -0.06890320f, -0.05815511f, -0.40758231f, 0.07014148f, 
    -0.07706386f, 0.02779561f, -0.04779145f, -0.06568285f, 0.08803701f, -0.46573299f, -0.14306730f, -0.00794428f, 
    0.03787439f, -0.25830069f, 0.03004775f, 0.05582645f, 0.17681427f, 0.06786561f, 0.03395636f, -0.08490215f, 
    0.40019223f, 0.01301345f, 0.12770830f, -0.09968453f, -0.02311070f, -0.03583110f, -0.08424013f, 0.14660510f, 
    0.08754656f, 0.07258386f, -0.14741336f, 0.00462083f, 0.22965531f, -0.16528049f, 0.09111094f, -0.52191037f, 
    0.06309739f, -0.13727379f, 0.00032794f, 0.07949252f, 0.08873262f, 0.11181541f, 0.04662858f, -0.10170894f, 
    -0.52340430f, -0.00596349f, -0.43371710f, 0.14449127f, 0.32483366f, -0.14156383f, -0.13574483f, -0.06820944f, 
    -0.22927800f, -0.05451546f, -0.16630863f, -0.00319459f, -0.14137603f, -0.04875948f, 0.22435915f, 0.00711412f, 
    -0.09840597f, -0.01188136f, -0.09417032f, -0.28180096f, -0.02538842f, -0.08431776f, -0.02511781f, -0.16609882f, 
    -0.02445254f, 0.11553542f, -0.20316936f, -0.09438272f, -0.02691888f, -0.08832265f, 0.11755970f, -0.04805347f, 
    0.06920534f, 0.08934587f, -0.08784736f, -0.04218167f, 0.20502384f, 0.00536587f, -0.14223328f, 0.03419925f, 
    -0.03859282f, -0.02843918f, -0.03838551f, -0.06098839f, 0.07113173f, -0.07998821f, -0.12314495f, 0.06459291f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.13941951f, 0.06861690f, 0.02821562f, -0.07187646f, -0.11210515f, 0.04752912f, 0.02862981f, -0.11974065f, 
    0.07256157f, 0.00288607f, 0.01120613f, -0.03104941f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
