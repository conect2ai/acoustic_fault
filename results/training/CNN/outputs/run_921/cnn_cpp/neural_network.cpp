#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.18040401f, -0.73650646f, -0.78858912f, -0.48192289f, -0.51833546f, -0.93658549f, 0.17491923f, 0.51502633f, 
    -0.39865047f, -0.02250994f, 0.75086647f, -0.04322050f, 0.57243478f, -0.07297553f, 0.44684952f, -0.01334462f, 
    0.10723064f, -0.43347731f, -0.07669322f, 0.13162188f, 0.16386501f, -0.01752693f, 0.12244003f, 0.31499875f, 
    0.24261773f, 0.94669795f, 1.18028176f, -0.45305714f, -0.34766167f, -0.92657822f, -0.60269523f, -0.68690920f, 
    -0.68883860f, -0.51952463f, 0.20626542f, 0.08912522f, -0.18648599f, 0.14526735f, -0.10198247f, -0.33709326f, 
    -0.64573342f, -0.21787415f, -0.22310629f, -0.31303909f, -0.19016731f, 0.18001574f, -0.01891805f, 0.38453895f, 
    0.05649451f, -0.11695194f, 0.42830667f, 0.01678715f, -0.32452279f, 0.25694701f, 0.63219166f, 0.47546074f, 
    0.46480811f, 0.76091981f, 0.43981168f, 0.60375643f, 0.24600668f, -0.60195351f, 0.11227348f, -0.31410575f, 
    -0.30102870f, 0.35017008f, -0.01648092f, -0.51891005f, -0.20196049f, -0.24194022f, -0.15167636f, 0.06009248f, 
    -0.19847429f, 0.70551038f, -0.01013420f, -0.82169271f, -0.63035440f, -0.42522305f, -0.19926190f, 0.29313731f, 
    -0.70841813f, -0.64491373f, -0.74895304f, -0.60997462f, 0.33085686f, 0.29524958f, -0.06168817f, 0.07768279f, 
    0.21093032f, 0.34122014f, -0.55887133f, -0.10743313f, -0.43459907f, -0.21923763f, -0.16965894f, 0.15816483f, 
    -0.37493354f, -0.22252117f, 0.08742869f, -0.04112392f, -0.50438505f, 0.51159495f, 1.18461120f, 0.56313658f, 
    -0.00436502f, -0.98752218f, 0.35749021f, 0.21548747f, -0.14138854f, 0.56995386f, -0.45126504f, 0.39677122f, 
    0.21043137f, -0.17021295f, -0.22978193f, 0.59271973f, -0.40469474f, 0.10353481f, -0.09565353f, 0.00323832f, 
    -0.57074142f, -0.27971339f, -0.06463082f, -0.20627482f, -0.01324309f, -0.61344117f, -1.10120201f, -0.96231371f, 
    -0.33445036f, -0.20151241f, -0.42795822f, -0.09050173f, -0.02176782f, -0.26340187f, 0.48213315f, 0.75834841f, 
    0.09966055f, 0.14501968f, -0.05947627f, 0.10571181f, -0.32825583f, 0.46923774f, 0.39841899f, 0.41726995f, 
    -0.28905296f, 0.07820255f, 0.15046641f, -0.12706806f, -0.13006626f, -0.30260131f, -0.16954190f, -0.22498466f, 
    0.05391676f, 1.06112242f, -0.82751685f, -0.13831410f, -0.72238243f, 0.06077178f, -0.40487483f, -0.85006708f, 
    -0.73186970f, 0.08058178f, 0.17535205f, -0.05631898f, -0.17952049f, -0.42280895f, -0.12555403f, -0.18958360f, 
    0.18756729f, 0.25202885f, 0.40148398f, 0.04273965f, -0.12990586f, 0.11365934f, -0.48812088f, -0.61200464f, 
    0.85718989f, -0.07955151f, 0.02746159f, 0.61333621f, -0.93235958f, -0.26786926f, -0.96322536f, -0.77775389f, 
    -0.84057599f, 0.13356227f, -0.07125228f, 0.33573237f, -0.03637795f, 0.25391304f, 0.23131010f, 0.32204854f, 
    -0.00758502f, 0.09416991f, 0.05870106f, -0.03198186f, 0.01885817f, 0.10556938f, 0.06681314f, 0.16292864f, 
    0.41451806f, -1.56678808f, 0.46867946f, 1.12453175f, 0.06558241f, -0.42316577f, 0.00926431f, 0.85169119f, 
    -0.53633797f, -0.06610914f, 0.33717459f, -0.06220221f, -0.36226919f, -0.27333295f, -0.00327199f, -0.33160400f, 
    -0.09266043f, 0.03156831f, 0.01395514f, -0.13888207f, -0.25740886f, -0.06341502f, -0.02929964f, -0.04520317f, 
    0.04185340f, 1.40324152f, 0.62652516f, -0.28381473f, 1.29433274f, 0.58590657f, 0.45231402f, 0.57332313f, 
    0.22335863f, 0.42385578f, 0.26020288f, -0.60916525f, -0.36746457f, -0.18790521f, -0.23734291f, -0.35033798f, 
    -0.05388530f, 0.03136298f, -0.15815943f, -0.19070241f, -0.02986617f, -0.12436724f, -0.05705652f, -0.19510004f, 
    -0.36840212f, -0.01085969f, -0.16758892f, 0.02531086f, 0.32284695f, -1.03348720f, -0.91277033f, 0.15149364f, 
    -1.18451107f, -0.15438657f, 0.68576550f, 0.43431059f, 0.00178877f, 0.20202668f, 0.07933098f, 0.12673886f, 
    0.21591590f, 0.45327565f, 0.30519450f, -0.17033468f, -0.11130869f, 0.13817282f, 0.08215040f, 0.02963624f, 
    0.32276458f, -0.42787388f, 0.29198182f, -0.77696484f, -0.90213424f, 0.00709165f, 0.97461194f, 0.18118104f, 
    0.81871629f, 0.02537346f, 0.21082142f, 0.04250181f, -0.79154229f, -0.12917334f, 0.18229403f, -0.47333783f, 
    0.22695291f, -0.04609935f, -0.16927573f, 0.28933489f, -0.58626199f, -0.02352771f, -0.11910834f, 0.05162492f, 
    0.01780207f, -0.02571024f, 0.33917606f, -0.36632651f, -0.77781552f, 0.22930124f, -0.78722769f, -0.99179560f, 
    -0.87090313f, 1.10270429f, 0.51255864f, -0.23214002f, 0.25880143f, 0.72351277f, 0.11731300f, -0.19648576f, 
    0.04955682f, 0.05359809f, -0.29003829f, 0.29865238f, 0.04848932f, 0.12840019f, 0.12067434f, 0.36845782f, 
    0.01075651f, -0.44064900f, -0.11220927f, -0.19716664f, 0.19206139f, 0.04397136f, 0.89072788f, 0.67652690f, 
    0.55084205f, 0.79404908f, 0.98274934f, -0.39010891f, -1.21133614f, 0.19874136f, -0.37124178f, -0.08693337f, 
    -0.25285009f, -0.47658992f, 0.14135709f, -0.66491902f, 0.12405679f, 0.05573159f, -0.20892172f, -0.33764139f, 
    -0.16492003f, 0.07811774f, 0.59542841f, 0.34026983f, 0.06272520f, 0.08297346f, -0.41245013f, 0.90667570f, 
    0.30030683f, -0.35771933f, -0.93614352f, -0.68649542f, -0.06461931f, 0.11723119f, -0.27149934f, -0.09689988f, 
    -0.17848590f, 0.09935702f, -0.45988247f, 0.00716250f, 0.26711991f, 0.41459480f, 0.20516531f, 0.88585669f, 
    0.26047957f, -0.14855336f, 0.36454695f, 0.46311793f, -0.16268358f, 0.32396320f, 0.21443848f, 1.16518974f, 
    1.20556629f, 1.22302747f, 0.68669581f, 0.05073923f, 0.27614677f, -0.21550272f, -0.43322402f, -0.56972224f, 
    0.02797988f, 0.13403121f, 0.31020400f, -0.05209294f, 0.00966013f, 0.02741301f, 0.47051734f, -0.10577832f, 
    0.23632376f, 0.47818354f, 0.01976365f, 0.20321649f, 0.08184060f, -0.18654019f, -0.20969468f, 0.47778893f, 
    -0.63010728f, -0.32946455f, 0.15371737f, 0.49025139f, 0.41061035f, -0.89960915f, 0.54397714f, 0.64484239f, 
    0.30164245f, 0.58237731f, -0.54289883f, -0.15260752f, 0.28926229f, 0.36846977f, 0.10386685f, 0.31953916f, 
    0.22318828f, 0.22973979f, -0.01938981f, -0.19767934f, 0.23541749f, 0.22655837f, -0.10614288f, -0.19220261f, 
    -0.13496895f, -1.10564959f, -0.50837630f, -0.81754684f, -0.29940823f, 0.32158858f, -0.20613885f, 0.67267329f, 
    0.51781350f, -0.07352644f, 0.55534303f, -0.21215363f, -0.09285177f, 0.03608559f, -0.15282032f, 0.13789245f, 
    0.23178318f, -0.22355169f, -0.25584123f, -0.13499025f, 0.23911457f, 0.23134275f, 0.38300177f, 0.25160050f, 
    0.57402748f, -0.04053891f, -1.45346797f, 0.75670648f, 0.49434322f, -0.49276504f, 0.43619105f, 0.79209632f, 
    -0.21426240f, -0.75430959f, 0.08259616f, -0.84654295f, 0.57660747f, 0.14643331f, -0.21718198f, 0.33466852f, 
    -0.31046018f, -0.16884783f, 0.09896601f, 0.05251648f, -0.20104529f, 0.27916193f, 0.16625920f, 0.01521435f, 
    -0.09736187f, 0.14885969f, 0.02377509f, 0.64832222f, 0.07609104f, 0.68707871f, -0.28499937f, -0.24693815f, 
    -0.67787313f, -0.51762402f, -0.46309498f, 0.14791884f, -0.71451885f, -0.25208655f, -0.03355632f, -0.21532272f, 
    -0.35046420f, 0.25247434f, -0.44739333f, -0.38065079f, -0.37046516f, -0.06648536f, 0.47460926f, 0.23682342f, 
    0.19022191f, -0.34029660f, 0.47102049f, 0.12860934f, -0.83992553f, -0.90621912f, -1.03596997f, 0.74263507f, 
    0.69988978f, 0.54265738f, 0.74432719f, -0.52354312f, 0.54731488f, -0.06661873f, 0.18341003f, 0.06870648f, 
    -0.02566628f, 0.08170574f, -0.12229190f, -0.40204141f, 0.15495206f, -0.40705153f, -0.30172065f, -0.48718116f, 
    -0.16467999f, -0.30246156f, 0.14635591f, -0.22988975f, -0.07807879f, -0.41246951f, -1.12284923f, -0.74447966f, 
    -0.59529078f, -0.51064771f, -0.37925914f, 1.12667215f, 0.75989717f, -0.15805018f, 0.67286164f, -0.06291605f, 
    -0.28946379f, -0.12324779f, -0.42115283f, 0.00874611f, -0.20042267f, 0.00929709f, -0.25766477f, -0.08137278f, 
    -0.15552223f, -0.16035239f, 0.09956124f, 0.03994114f, -0.10353292f, 0.18318626f, 0.02794868f, 1.44309378f, 
    -0.85295433f, -0.88252550f, 0.01411233f, -0.33651984f, 0.43170434f, 0.75943118f, 0.03753500f, 0.42744145f, 
    0.06565309f, -0.03464703f, -0.08523659f, -0.28950897f, -0.45694095f, 0.20902234f, 0.01212438f, -0.05572292f, 
    -0.06113926f, -0.19064637f, -0.22436108f, -0.07117390f, -0.37284535f, -0.12879676f, 0.39114109f, 0.41598243f, 
    -0.10029996f, 0.33932972f, 0.57250220f, 1.15022457f, -0.35852224f, -0.94576979f, -0.37345725f, -0.41584101f, 
    0.05752100f, 0.69064498f, 0.53080231f, 0.08633447f, 0.17698142f, 0.06993018f, 0.16139980f, 0.36979869f, 
    -0.22355448f, 0.47381377f, 0.14533328f, 0.51177466f, 0.42870501f, -0.15794130f, -0.38330197f, -0.15643562f, 
    0.66553181f, 0.16964044f, 1.12324667f, 0.32803461f, -0.60236597f, -0.12088753f, -1.04610062f, 0.45840517f, 
    0.29799852f, 0.49131313f, 0.62762654f, -0.04871438f, -0.03985504f, -0.08597054f, -0.04833500f, -0.08311429f, 
    -0.01853968f, -0.05430027f, 0.11103036f, -0.22070229f, 0.45189670f, 0.36867490f, 0.17080206f, 0.04022298f, 
    0.20971903f, 0.84751725f, -1.21033144f, 0.61729819f, 0.53989774f, 0.93341804f, -1.14075518f, 0.57523561f, 
    -0.26008627f, -0.52170217f, 0.47021455f, 0.40024531f, 0.16095781f, -0.07471941f, -0.02306861f, 0.38404244f, 
    -0.31818479f, -0.04486486f, 0.05574674f, 0.03283281f, 0.20673183f, -0.13542302f, -0.15013230f, -0.04349580f, 
    0.18540469f, -0.09804375f, -1.11429119f, -0.16737609f, -0.11778772f, -0.77168679f, -0.54235613f, -0.21866383f, 
    -0.31658798f, 0.13450676f, 0.36214903f, -0.61889631f, -0.31957343f, -0.12833405f, -0.03098426f, -0.09969213f, 
    -0.05526098f, 0.11105208f, -0.02689823f, 0.09077735f, -0.10316728f, -0.16865110f, 0.54090023f, -0.17115539f, 
    0.44544038f, 0.38515374f, 0.06427284f, 1.31402493f, 0.68062454f, 0.90614420f, 0.54561919f, 1.01001692f, 
    0.71502942f, -0.09260144f, -0.01890538f, 0.35627896f, 0.32024643f, 0.19801819f, 0.21156542f, -0.19119769f, 
    0.33928639f, -0.15656094f, -0.10467277f, 0.19523950f, 0.30440202f, -0.03222415f, -0.33370659f, -0.02810878f, 
    -0.02596782f, 0.16853832f, 0.04516178f, 0.42324162f, 0.23653394f, 0.05381848f, 0.30415362f, -0.97882468f, 
    -0.05210200f, -0.25032005f, 0.74810117f, -0.40495417f, 0.10449937f, -0.01071311f, 0.44675314f, -0.13304655f, 
    -0.56975776f, -0.52536255f, -0.10754424f, -0.26999921f, 0.59930158f, 0.40513018f, -0.21968605f, -0.14636450f, 
    -0.29016790f, -0.12926811f, 0.37060332f, 0.05582414f, -0.17216541f, 0.64683944f, -0.31514037f, -1.00299180f, 
    -1.29673982f, 0.47110790f, 0.33319837f, -0.04658116f, -0.04092216f, 0.49100488f, 0.69031954f, -0.51028639f, 
    -0.00543307f, -0.48121724f, -0.32548559f, -0.19134369f, -0.08067799f, 0.15453485f, 0.03628557f, 0.17682828f, 
    0.06906307f, -0.09495103f, -0.08741583f, -0.30781627f, 0.02114868f, -0.44253141f, 1.27104521f, 0.18035252f, 
    -0.92864400f, -0.89521527f, -0.31082472f, 0.39094806f, -0.59209824f, -0.23303777f, -0.49858138f, -0.25838780f, 
    -0.43147251f, 0.04749300f, 0.05658988f, 0.13073407f, -0.02020896f, -0.15018316f, -0.12696190f, -0.17911208f, 
    0.19517191f, -0.19465035f, 0.46394548f, 0.27450314f, -0.12804034f, -0.08397006f, 0.15732104f, 1.18933535f, 
    -0.90160453f, 0.41502663f, 0.65387774f, 0.23160239f, 0.69279265f, -1.11999702f, 0.19728540f, 0.24874093f, 
    0.42829153f, -0.00356990f, 0.06898985f, -0.48774561f, 0.04709597f, 0.06356666f, 0.16021936f, 0.36958092f, 
    0.30504644f, -0.12574433f, 0.18081957f, -0.07811578f, -0.18918903f, 0.09480301f, -0.12451924f, -0.07515805f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.54467463f, 0.44160077f, 0.14781220f, 0.31879166f, 0.07334605f, 0.10427750f, 0.29068434f, -0.03847044f, 
    0.06994939f, 0.10221022f, 0.44066128f, 0.25332317f, 0.16315939f, 0.21924660f, 0.23321295f, 0.23105727f, 
    0.32689920f, 0.19309081f, 0.11956421f, 0.15897393f, 0.16894493f, 0.30169243f, 0.13563250f, 0.12880912f, 
    0.26659831f, -0.05127281f, -0.16580398f, 0.23885088f, -0.12053433f, 0.04168829f, 0.22036976f, 0.29089385f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.64394450f, -0.16082291f, -0.06318251f, 0.05622457f, 0.09075029f, 0.00383272f, 0.04136540f, -0.08999307f, 
    -0.06288892f, -0.09065276f, 0.01129519f, 0.01686384f, -0.07555939f, -0.01438420f, 0.06423485f, -0.14000607f, 
    -0.10685983f, -0.05969506f, 0.00611565f, 0.02771875f, -0.00233077f, -0.05210119f, 0.03967512f, -0.02356979f, 
    0.07215621f, 0.22449130f, -0.05356951f, 0.11926050f, 0.05308467f, 0.11138911f, -0.12433342f, 0.01383074f, 
    -0.18413056f, -0.00734686f, 0.15886715f, -0.23685446f, -0.41075507f, -0.41768944f, 0.08876531f, 0.18037415f, 
    0.00497318f, -0.11405799f, -0.08511587f, 0.02349059f, 0.03308202f, -0.00933624f, -0.11148534f, 0.16532129f, 
    -0.09314416f, 0.00359463f, -0.09732852f, 0.26337680f, -0.03822047f, 0.04233558f, 0.03326194f, 0.05064483f, 
    0.13875203f, 0.10650775f, 0.11592591f, 0.05049489f, -0.40629578f, -0.40068433f, -0.14924371f, 0.17143954f, 
    0.19048241f, -0.08951348f, 0.06321525f, 0.03198456f, -0.13297532f, -0.03749544f, -0.07617407f, 0.02084701f, 
    -0.08638150f, 0.13108335f, -0.14572790f, 0.30029923f, 0.09961913f, 0.02791751f, 0.05457109f, -0.10610707f, 
    0.07034735f, -0.22415149f, -0.16174315f, 0.00088734f, -0.30003390f, 0.25543681f, 0.07997862f, 0.05390039f, 
    0.01856369f, -0.15357864f, 0.02935824f, 0.06751994f, 0.01153453f, 0.09367572f, -0.09697860f, -0.08711747f, 
    0.07009588f, -0.07222604f, -0.16790523f, 0.36919248f, -0.20652643f, 0.21454121f, 0.06779309f, -0.09165546f, 
    -0.02124587f, 0.11557069f, -0.18000771f, 0.04354881f, 0.11252651f, -0.03104237f, -0.02212435f, 0.44098532f, 
    -0.23830751f, 0.08767302f, 0.05412384f, 0.05398865f, 0.03852576f, 0.07291882f, 0.08165313f, 0.01261789f, 
    0.03506606f, -0.12045188f, -0.18724439f, -0.15926671f, 0.09382154f, -0.07869568f, -0.04912686f, -0.04087253f, 
    -0.04452790f, -0.13115172f, -0.05055398f, 0.00770747f, -0.55743158f, 0.01118352f, -0.04748433f, 0.19600533f, 
    0.15018284f, -0.05395589f, -0.11461151f, 0.13156851f, 0.10353094f, -0.04333156f, 0.19839108f, -0.30913147f, 
    0.73461270f, 0.02674738f, -0.09211945f, -0.43619415f, 0.14206389f, -0.06180066f, -0.03927331f, -0.02156213f, 
    0.12737370f, 0.00249237f, -0.04866632f, -0.00809581f, -0.09989430f, 0.00401864f, 0.06283426f, 0.10214055f, 
    -0.00108498f, -0.12912568f, -0.10938277f, -0.12052139f, -0.06391568f, 0.02807067f, -0.18430604f, -0.00569310f, 
    -0.29650649f, 0.32173672f, -0.08033095f, 0.06693111f, 0.10575457f, 0.07671756f, 0.00822711f, -0.04711048f, 
    -0.10949690f, 0.04934408f, 0.04730089f, -0.04592913f, 0.16113633f, 0.11504812f, -0.14892812f, -0.18505327f, 
    -0.17563501f, -0.10034500f, -0.01042889f, 0.08316375f, 0.09265225f, -0.05052176f, -0.19017848f, 0.09312994f, 
    -0.17803709f, 0.17523724f, -0.07080144f, 0.19476907f, 0.02947749f, 0.16455591f, -0.11343297f, 0.02138108f, 
    -0.00406883f, -0.01457108f, -0.02403178f, 0.08662342f, 0.09916014f, 0.34800574f, -0.08971777f, -0.32020640f, 
    0.03360845f, -0.03517753f, -0.06409895f, -0.01994686f, -0.00652722f, 0.02862075f, -0.01639290f, -0.00959686f, 
    -0.49530062f, -0.13552092f, 0.16656923f, 0.01864517f, -0.10970987f, -0.09632314f, 0.13600641f, -0.07303607f, 
    0.12378182f, 0.12212867f, 0.13244015f, 0.05709277f, 0.30407599f, 0.21077190f, 0.08072908f, -0.16503118f, 
    0.02818312f, -0.06789863f, -0.12724344f, -0.09839732f, 0.06959274f, -0.19995508f, -0.15890634f, 0.04228926f, 
    -0.22145931f, 0.31039745f, 0.01582581f, 0.22417346f, 0.05597150f, -0.01584072f, -0.21207173f, -0.02504935f, 
    -0.10543810f, -0.00721756f, -0.07421663f, 0.11687399f, -0.21929660f, 0.37621242f, -0.01503213f, -0.44171771f, 
    0.12720871f, 0.01434349f, -0.03367313f, 0.05653572f, 0.10428226f, -0.08736980f, 0.03213930f, 0.20583670f, 
    -0.00681969f, 0.17117541f, 0.16552740f, -0.58193749f, -0.03229462f, -0.07946956f, 0.16756850f, -0.12585278f, 
    0.00473342f, 0.01050317f, -0.08763211f, -0.16950665f, 0.29532555f, -0.11736985f, -0.02563550f, 0.00814255f, 
    -0.01151602f, 0.09696852f, -0.01443510f, -0.12773637f, -0.06128749f, 0.04472743f, 0.15582547f, 0.01812385f, 
    0.05834992f, -0.04532242f, -0.19353500f, 0.29493830f, -0.09650118f, -0.06920619f, -0.10314731f, -0.24572304f, 
    -0.12659706f, -0.04805734f, -0.11114968f, 0.02773225f, 0.55821633f, -0.21521397f, -0.21000607f, 0.36871642f, 
    -0.30352738f, -0.16649503f, 0.05129768f, -0.00119010f, 0.07009626f, -0.03358334f, -0.16148959f, 0.00606321f, 
    0.18798086f, 0.13243417f, -0.27127084f, -0.14546987f, 0.08977918f, 0.08694059f, -0.01711947f, 0.07232030f, 
    0.01182213f, 0.21425359f, 0.05192161f, -0.09180042f, 0.29856080f, -0.22546712f, 0.11284042f, 0.11330688f, 
    -0.25735977f, -0.07519674f, -0.04247310f, 0.04460503f, 0.05048792f, 0.07001514f, 0.04096261f, -0.10580159f, 
    -0.42765659f, 0.04021395f, 0.20575538f, -0.44229946f, -0.09336883f, 0.10768886f, 0.01813408f, -0.04841202f, 
    -0.00177567f, 0.21204159f, 0.02565535f, -0.07632421f, 0.26350915f, 0.06765909f, 0.14161277f, -0.40070158f, 
    -0.01616992f, 0.10324840f, 0.17913933f, -0.12910455f, -0.24397533f, 0.05525515f, 0.00698959f, 0.16712360f, 
    -0.00511723f, -0.23998971f, 0.20044728f, -0.45900279f, 0.13760541f, -0.01336444f, -0.03007423f, -0.02455433f, 
    -0.24803691f, -0.05414946f, -0.10341381f, 0.04233600f, 0.50583792f, -0.64276433f, -0.03563096f, 0.37605336f, 
    -0.10662689f, -0.00412753f, 0.04800022f, 0.05860356f, -0.14573775f, -0.07278741f, -0.13096105f, -0.01909178f, 
    0.30307376f, -0.34217751f, -0.16793108f, -0.05892344f, 0.01900281f, 0.03429636f, -0.05724966f, 0.16592573f, 
    -0.01062776f, 0.10741126f, 0.00522138f, -0.00458014f, 0.25888494f, -0.17333107f, -0.10175012f, -0.35474133f, 
    0.00821540f, -0.04263476f, 0.12277956f, 0.09537626f, -0.23647511f, 0.02922023f, 0.08046046f, -0.02171074f, 
    0.23922123f, -0.08219992f, 0.22404213f, 0.11130800f, -0.05381235f, 0.06740423f, -0.10033310f, 0.10377946f, 
    0.20569284f, -0.01825974f, -0.18234353f, 0.23450106f, 0.16153316f, 0.04793887f, -0.04863074f, -0.05753233f, 
    -0.11380123f, -0.06541477f, -0.16956989f, -0.06665917f, -0.10084607f, -0.12366805f, -0.15230297f, -0.12977704f, 
    -0.12619074f, 0.05613214f, -0.02619741f, -0.13014795f, 0.06970741f, 0.14805302f, -0.07246169f, -0.15532526f, 
    -0.02502269f, -0.33684102f, 0.00613757f, -0.18225008f, 0.35094398f, 0.24653687f, -0.17117526f, 0.04855818f, 
    -0.07952696f, -0.08848547f, 0.10212713f, 0.01278411f, 0.20864935f, -0.12607999f, 0.08099315f, 0.20546524f, 
    -0.48422429f, -0.18100362f, -0.29979539f, 0.09654149f, -0.04942919f, -0.05757476f, -0.20942572f, -0.01592432f, 
    -0.05987784f, 0.03453946f, 0.08246632f, 0.00938507f, -0.20650657f, -0.07092461f, -0.11820689f, -0.44948903f, 
    0.06649064f, 0.13568909f, 0.01871828f, -0.10435183f, 0.04719288f, -0.01731419f, 0.08412691f, 0.07430526f, 
    -0.60523885f, -0.02041182f, 0.02533188f, 0.31181309f, -0.11783296f, -0.19796009f, -0.03512400f, 0.03662243f, 
    0.01803475f, -0.22972903f, 0.15422173f, -0.03527859f, 0.47156602f, -0.06994434f, 0.06225515f, 0.18099901f, 
    0.04931803f, 0.09724041f, -0.05925202f, 0.10517491f, 0.05631636f, 0.01217094f, 0.00585185f, -0.22943835f, 
    -0.62703800f, 0.11609013f, 0.08990876f, 0.08905214f, 0.09407382f, 0.05936998f, 0.03271227f, 0.12916847f, 
    -0.07686460f, 0.15540053f, 0.18680677f, -0.03379029f, 0.07806386f, 0.04818007f, -0.37412000f, 0.21715304f, 
    0.02033426f, 0.10057288f, 0.06736478f, -0.17435591f, -0.07869733f, 0.01552017f, -0.04199653f, 0.16717647f, 
    -0.37578884f, -0.23138350f, 0.21032907f, -0.26380339f, 0.09629267f, -0.10719067f, 0.07215222f, 0.04255360f, 
    0.00952525f, 0.08684079f, -0.02775006f, -0.03471224f, 0.25361943f, -0.15365137f, 0.22417821f, -0.03492307f, 
    -0.08091312f, 0.07585754f, 0.07728323f, 0.02786455f, -0.04359975f, 0.03485181f, 0.20507492f, -0.16738489f, 
    -0.39620239f, -0.03127064f, -0.45957947f, 0.10249589f, -0.04928282f, 0.05931490f, -0.01638430f, 0.04785216f, 
    0.12948325f, -0.00187596f, 0.03826472f, 0.09488423f, 0.23835054f, -0.01425743f, 0.28183657f, 0.23571154f, 
    -0.18450157f, -0.11495062f, -0.02559371f, -0.02618890f, 0.02711367f, -0.00371218f, -0.03268744f, 0.03426094f, 
    -0.02660590f, -0.01869378f, -0.16286004f, -0.12634566f, -0.06966299f, -0.13452590f, -0.13990578f, 0.01810901f, 
    0.01139988f, 0.11626898f, 0.01347600f, -0.08180361f, 0.09966189f, 0.00017909f, -0.18184952f, -0.25794831f, 
    -0.00619037f, -0.02384407f, -0.04646890f, 0.07004651f, 0.09398738f, 0.04882184f, -0.00234759f, 0.05267570f, 
    -0.39855707f, -0.13934380f, -0.16290259f, -0.02969435f, -0.03917261f, 0.02084474f, -0.06059262f, 0.05987743f, 
    -0.16569342f, 0.01117096f, -0.03750176f, -0.20339689f, -0.14934838f, -0.04949437f, -0.26226547f, 0.11827789f, 
    -0.07381584f, 0.00539444f, -0.03833436f, 0.12080199f, -0.04302188f, 0.02487708f, -0.05487278f, -0.06267545f, 
    0.27528554f, 0.01958341f, -0.35863128f, -0.01821690f, 0.28356561f, 0.12410256f, -0.10752310f, 0.13644925f, 
    -0.11132210f, -0.02059011f, 0.09275695f, -0.21095346f, 0.40842500f, -0.22607091f, -0.17414975f, -0.11708224f, 
    -0.05618251f, -0.01337897f, 0.04549999f, 0.06971462f, 0.09100883f, -0.00021845f, -0.11210253f, -0.03566649f, 
    0.28963009f, 0.18935426f, 0.00102462f, -0.54465622f, -0.05803217f, -0.10909648f, -0.15522064f, 0.12605548f, 
    0.17027153f, -0.18426381f, 0.07499426f, -0.04308793f, -0.25160196f, -0.21505278f, 0.19939825f, 0.05670194f, 
    -0.09446432f, -0.04763955f, -0.08286665f, 0.10887921f, -0.07137892f, 0.17400947f, 0.07417924f, 0.05030498f, 
    -0.16566285f, 0.27839532f, 0.12214997f, 0.18741597f, 0.00851677f, -0.16652367f, -0.00724621f, 0.05703212f, 
    0.06792869f, -0.02700383f, 0.01924379f, -0.04912209f, -0.12901665f, -0.36087641f, 0.17973363f, 0.06495754f, 
    -0.03904746f, 0.07366905f, -0.03585670f, 0.13666804f, 0.13359365f, 0.02041752f, 0.14557429f, -0.03135844f, 
    -0.10435635f, -0.02916390f, 0.32949546f, -0.10825870f, -0.12154290f, -0.15806545f, 0.04001298f, 0.13290827f, 
    0.17866331f, -0.13387989f, -0.08020467f, 0.11512724f, 0.26659161f, 0.04738934f, 0.15624225f, 0.20957741f, 
    -0.22925171f, -0.06746310f, -0.06962722f, 0.04934030f, -0.12394454f, -0.12468003f, -0.02844778f, 0.04053899f, 
    -0.09735427f, -0.14142521f, -0.44593158f, -0.31280673f, -0.03747924f, -0.04251906f, 0.04588337f, -0.29982290f, 
    0.30358765f, -0.12695251f, -0.04259180f, -0.06705414f, 0.20113750f, -0.20193337f, 0.29894921f, -0.42785144f, 
    0.24760540f, -0.12623540f, -0.03605631f, 0.01013498f, 0.16154121f, -0.10620041f, -0.01543423f, -0.03133227f, 
    0.23395936f, -0.11343277f, 0.13957852f, -0.39515454f, -0.04200727f, -0.01443213f, 0.01215625f, -0.01166187f, 
    0.01869100f, -0.10064428f, 0.13478248f, -0.04649222f, 0.30583724f, 0.20728590f, 0.19204681f, -0.04082998f, 
    -0.05400883f, 0.14604113f, -0.02848265f, -0.04058216f, 0.10690406f, -0.09937660f, 0.14281417f, -0.02956239f, 
    0.60771960f, 0.05924715f, -0.06700174f, -0.09686757f, -0.10859994f, -0.05806694f, -0.11534035f, -0.01063713f, 
    -0.08145323f, -0.11296804f, 0.00501956f, -0.17835477f, -0.30717564f, 0.20113504f, -0.02243965f, -0.46987608f, 
    -0.00818297f, -0.01367195f, 0.15840288f, -0.22987436f, -0.08748172f, 0.10724296f, 0.06234085f, 0.03537735f, 
    0.01490792f, 0.18991370f, -0.01414055f, 0.10830905f, 0.00870437f, -0.26684269f, 0.04383682f, 0.04748122f, 
    0.05677452f, -0.04047620f, -0.02786688f, -0.07347368f, 0.30486524f, -0.32747433f, -0.06562024f, -0.08466820f, 
    0.05836158f, 0.07756051f, -0.19026060f, -0.03331850f, 0.11538851f, 0.03447285f, 0.08573111f, -0.02149010f, 
    0.36152577f, -0.08992308f, -0.35692063f, 0.04592822f, -0.04144193f, 0.07784881f, 0.07082485f, 0.01520014f, 
    -0.01594196f, 0.00207776f, -0.09303195f, -0.09510830f, 0.32980165f, -0.49541605f, 0.22189373f, 0.10253690f, 
    -0.33265409f, -0.03029063f, 0.14522852f, -0.07357170f, -0.14720900f, 0.00012456f, -0.09989389f, -0.10619096f, 
    -0.55131865f, -0.18078105f, -0.43660480f, -0.13129385f, -0.24826698f, 0.17816332f, -0.05160494f, -0.08561394f, 
    0.03034124f, 0.01960102f, -0.08585504f, -0.05865401f, 0.08061210f, -0.03217250f, -0.29147238f, -0.22313237f, 
    0.14908645f, -0.06677176f, -0.05987056f, -0.12327833f, -0.22641493f, -0.00799205f, -0.06770550f, -0.16513598f, 
    0.54895908f, -0.07148664f, -0.14380297f, -0.11803208f, -0.09373502f, 0.05790422f, -0.07987545f, 0.02005013f, 
    0.08497164f, 0.05588675f, 0.09081633f, -0.13476421f, 0.26932651f, -0.24747837f, -0.00271364f, -0.24523205f, 
    0.18619956f, -0.00744198f, 0.03338462f, 0.01232206f, 0.00076291f, 0.06191056f, 0.03664440f, 0.00802248f, 
    -0.54108971f, -0.00782921f, 0.06622140f, -0.00016970f, 0.10675237f, 0.09885173f, 0.05109570f, -0.01009824f, 
    -0.01117759f, -0.01086268f, -0.05275650f, -0.12116445f, -0.15124957f, -0.39502650f, 0.03133043f, -0.13632876f, 
    -0.18857375f, 0.06258450f, -0.19098972f, -0.09490106f, 0.18863516f, -0.20200266f, -0.10815397f, -0.06166786f, 
    0.34621638f, 0.24647874f, 0.23022722f, 0.06853105f, -0.03902839f, -0.02587839f, 0.04886705f, 0.11329749f, 
    -0.09094992f, 0.10442515f, 0.03882351f, -0.14852203f, 0.14416397f, -0.39104602f, -0.10317715f, 0.14151068f, 
    0.13760568f, -0.02551818f, -0.01242300f, -0.24470997f, 0.04317220f, 0.09358514f, -0.03596021f, 0.03136763f, 
    -0.16111091f, -0.11536324f, 0.01387744f, -0.25819632f, 0.03584893f, -0.04806794f, 0.02118379f, -0.01403194f, 
    -0.12619738f, -0.18193819f, -0.03122978f, 0.14750132f, -0.13235068f, -0.03425531f, 0.04653813f, -0.11584611f, 
    0.00895341f, 0.12443652f, 0.02956256f, -0.03812505f, 0.00425060f, 0.01220620f, -0.09350311f, -0.15268826f, 
    0.39254400f, -0.20602128f, -0.09110478f, 0.09182356f, -0.09318142f, 0.10953540f, -0.03823306f, -0.14926429f, 
    0.08468905f, -0.02198259f, -0.11303768f, 0.09635155f, 0.31310567f, 0.02246409f, -0.02213220f, 0.27407584f, 
    -0.30779257f, -0.03253312f, -0.28377181f, -0.11582728f, -0.04895097f, -0.06545389f, 0.05148550f, 0.05612049f, 
    0.41132024f, 0.03171815f, -0.19357099f, 0.15419571f, -0.02049060f, 0.02995663f, 0.13250948f, -0.02247330f, 
    -0.03481657f, -0.11449717f, -0.02191013f, -0.05595569f, -0.37032670f, 0.17845343f, -0.26070663f, -0.37231666f, 
    0.01472885f, -0.05425012f, -0.02048155f, 0.05865933f, 0.19628596f, 0.01262436f, 0.09757255f, 0.04380590f, 
    0.31799999f, -0.28970870f, 0.21964210f, 0.02691952f, -0.02528847f, -0.09737236f, -0.18056960f, 0.20092291f, 
    0.04552215f, 0.06657246f, -0.10237892f, 0.07085378f, 0.43297935f, 0.14454031f, 0.20266879f, 0.42485785f, 
    -0.13897656f, -0.11962171f, 0.07394592f, 0.23265888f, 0.03296858f, 0.04655340f, 0.03817289f, 0.00707036f, 
    -0.00201524f, 0.09211484f, -0.12121046f, 0.14745581f, -0.07020210f, -0.07793940f, 0.09997401f, -0.07882987f, 
    -0.00603191f, -0.01374702f, 0.21666218f, 0.02098633f, -0.05155556f, 0.09069787f, -0.01257822f, 0.04127881f, 
    0.11889975f, 0.02110568f, 0.03783014f, -0.27887142f, 0.02346065f, -0.25328007f, 0.12566787f, -0.07337451f, 
    -0.26277828f, 0.02679385f, -0.09204476f, -0.06029449f, -0.14876312f, 0.02599519f, 0.09690718f, -0.08514392f, 
    -0.02783338f, 0.03412301f, -0.02889046f, 0.04624400f, 0.45884699f, 0.10598028f, 0.00654954f, -0.16052213f, 
    0.14091603f, 0.02729273f, -0.01022660f, 0.02204280f, -0.06302016f, -0.04228805f, -0.03957526f, 0.03923373f, 
    -0.13427882f, 0.04002366f, -0.39519262f, -0.11970105f, -0.02314941f, 0.13596749f, -0.17024009f, 0.02100668f, 
    0.08210704f, 0.15730958f, -0.05391285f, 0.02300913f, 0.09373999f, 0.03823380f, -0.07418395f, 0.00375496f, 
    0.09093787f, 0.05662354f, 0.05338087f, -0.02489699f, -0.07539935f, 0.08780399f, 0.00327614f, 0.07061029f, 
    -0.08684318f, -0.16213641f, 0.15698498f, -0.25849703f, 0.04625984f, 0.09104070f, 0.11278249f, 0.20213102f, 
    -0.04154225f, 0.02697783f, -0.06905114f, -0.14279434f, -0.19065891f, -0.03546200f, -0.15390550f, 0.06774679f, 
    -0.01611271f, 0.19354934f, 0.21836963f, 0.07008229f, 0.09076918f, -0.11610185f, -0.06751540f, 0.08118957f, 
    -0.39799556f, -0.21876863f, -0.18362537f, -0.32620332f, -0.03431898f, -0.09996002f, 0.14072557f, -0.06633072f, 
    -0.07182732f, 0.08068049f, -0.10281667f, 0.11374214f, -0.36423481f, 0.07056174f, -0.01053393f, -0.08888467f, 
    0.01754053f, 0.01285880f, -0.21043214f, 0.14132331f, 0.01830877f, -0.04249363f, 0.03438684f, -0.09613576f, 
    0.16084498f, -0.08255558f, -0.07245587f, -0.05157757f, -0.11067933f, -0.11105130f, -0.12788406f, 0.05655419f, 
    -0.05069915f, 0.04283741f, 0.04479198f, -0.00072994f, 0.23155351f, -0.28598964f, -0.09136797f, 0.04539428f, 
    -0.05668820f, 0.12822278f, -0.07405446f, 0.01977997f, 0.15624726f, 0.05071751f, -0.06271123f, -0.03154100f, 
    -0.28862846f, 0.12159356f, -0.21717827f, -0.30241987f, -0.19743225f, -0.06475868f, 0.03354340f, -0.06925202f, 
    -0.11180454f, 0.00782614f, 0.05597669f, -0.03296144f, 0.01563526f, 0.26429030f, 0.09167033f, 0.17295161f, 
    -0.05804387f, -0.00655569f, -0.02339378f, -0.01681338f, -0.02686769f, 0.03249151f, 0.14200510f, -0.08974785f, 
    -0.76114583f, 0.25548032f, 0.01950265f, 0.16574496f, 0.00264531f, 0.01624878f, 0.04961873f, 0.14092368f, 
    -0.10810604f, -0.01050056f, -0.09480929f, 0.16282853f, 0.01387545f, 0.03899798f, -0.07426448f, -0.21177103f, 
    -0.32099056f, -0.01904367f, -0.09610625f, 0.09168493f, -0.09540533f, -0.04396987f, -0.05976496f, 0.03505098f, 
    0.41108555f, 0.02156982f, 0.15801866f, 0.26550463f, 0.01607834f, -0.03915091f, 0.01027295f, 0.10797600f, 
    -0.03655051f, -0.00844231f, -0.05106157f, 0.07128404f, 0.12576321f, 0.10493968f, 0.17567959f, 0.05096376f, 
    0.15183413f, 0.03670172f, -0.01182050f, 0.07779773f, 0.00372800f, -0.05014451f, -0.11562260f, -0.04661639f, 
    0.34798026f, -0.10662887f, 0.32060212f, -0.10096072f, -0.03565641f, 0.24712433f, -0.00535663f, 0.07700522f, 
    -0.15377608f, 0.07467882f, -0.06789025f, -0.12103818f, -0.22026861f, -0.52817214f, -0.19330028f, -0.02974244f, 
    -0.12820157f, -0.02191778f, 0.02136629f, -0.09683511f, 0.01669327f, 0.01213270f, 0.10206615f, 0.06866240f, 
    -0.00529693f, -0.11082471f, 0.05141786f, 0.02306303f, 0.09211096f, 0.05614582f, -0.06800497f, 0.12043946f, 
    0.12166811f, 0.10819881f, -0.09005713f, -0.01709733f, 0.09455527f, 0.00412852f, -0.03622966f, 0.05344935f, 
    0.03890328f, -0.05032033f, 0.04778565f, 0.12604487f, 0.09537279f, -0.06575150f, 0.07240424f, -0.06600606f, 
    -0.20740347f, 0.12468507f, -0.19125439f, -0.30969891f, -0.07226706f, -0.03930777f, 0.05104113f, 0.07210585f, 
    0.02007977f, -0.22446446f, -0.04925974f, -0.01292064f, 0.68910635f, -0.25580451f, -0.20932817f, 0.33717558f, 
    -0.03447274f, -0.00820999f, -0.13434879f, 0.17156821f, -0.09016540f, 0.17658220f, -0.07645425f, -0.10860615f, 
    -0.31049567f, 0.03982780f, 0.11558948f, -0.19657314f, 0.01721010f, -0.03830956f, -0.25348210f, -0.02813705f, 
    -0.04244036f, -0.08000270f, 0.02451677f, -0.03916250f, -0.36751562f, -0.77084351f, -0.36174995f, 0.35444975f, 
    -0.09376794f, -0.05482309f, 0.05843142f, -0.05303239f, -0.11157094f, -0.09232936f, -0.03923814f, -0.06576688f, 
    -0.20962757f, 0.17518170f, 0.06606112f, 0.03167222f, -0.03055212f, -0.07250798f, 0.08841001f, -0.16844437f, 
    -0.20022596f, 0.02300269f, -0.19942778f, -0.02141726f, 0.03250439f, 0.22212259f, -0.06273779f, 0.02483286f, 
    -0.09789112f, -0.26730108f, 0.04046716f, 0.00140508f, -0.09169477f, -0.07728902f, -0.12381787f, -0.11878722f, 
    0.66696292f, 0.25377926f, 0.16802779f, -0.06406068f, 0.20105791f, -0.09870750f, -0.01757165f, 0.00664500f, 
    -0.11064024f, -0.03042866f, -0.03074069f, -0.11124839f, 0.02487624f, -0.00476850f, 0.05404650f, -0.04496749f, 
    0.04613863f, 0.01883509f, 0.18164980f, 0.04428031f, -0.01079966f, -0.12531134f, 0.12835091f, -0.04951462f, 
    0.21528898f, 0.21904999f, -0.15041262f, -0.02750125f, -0.05498735f, -0.02090592f, 0.06892247f, 0.00534484f, 
    0.08981848f, 0.17628524f, 0.07841846f, -0.02033572f, 0.11182392f, -0.17974333f, -0.00166884f, -0.13595478f, 
    -0.02538280f, 0.00266487f, -0.00706886f, -0.14873378f, -0.09944328f, -0.07749560f, -0.01167501f, 0.05049664f, 
    -0.21617283f, -0.00755994f, -0.06859227f, -0.01629249f, -0.06266508f, 0.03784148f, 0.02198968f, 0.20127790f, 
    -0.06535009f, 0.15860000f, 0.02093714f, 0.05269263f, -0.19296649f, -0.10236672f, 0.02312451f, 0.31856096f, 
    0.09067062f, 0.30196702f, 0.07718054f, -0.21596777f, 0.02156340f, -0.06708829f, -0.06377392f, -0.07825100f, 
    -0.18493462f, -0.51460165f, -0.22942260f, 0.22854054f, -0.02496902f, 0.14103861f, 0.02577205f, -0.05974835f, 
    -0.16852523f, 0.05001823f, -0.04905239f, -0.04795979f, -0.57811028f, 0.04791367f, 0.16756339f, 0.24811406f, 
    0.10444541f, 0.13910189f, -0.02643174f, -0.03883436f, 0.00145326f, 0.11250568f, -0.02953058f, -0.01522041f, 
    -0.07611889f, 0.24192545f, 0.09816804f, -0.00287625f, -0.20189270f, -0.08941545f, 0.03834367f, 0.05946830f, 
    -0.01004674f, 0.00621312f, 0.01738871f, -0.14736935f, -0.61816251f, -0.38727212f, -0.45215484f, -0.12356007f, 
    -0.12138193f, -0.00959615f, 0.03560123f, -0.11970268f, 0.05383560f, 0.02073667f, -0.02135454f, 0.05160262f, 
    -0.24004568f, 0.08288477f, 0.12082682f, 0.07390632f, -0.14626174f, 0.09497505f, -0.18978602f, 0.18946436f, 
    0.04230526f, -0.02745575f, -0.08336449f, 0.16678964f, -0.16085958f, 0.09338191f, 0.02763689f, -0.05096041f, 
    -0.24528143f, -0.05919418f, 0.01927596f, -0.11402239f, -0.12318590f, 0.05203428f, 0.06430051f, 0.11763789f, 
    0.21015236f, -0.11342351f, 0.09535291f, 0.15877941f, 0.07752418f, 0.01906849f, 0.01358089f, 0.00684598f, 
    -0.07557021f, 0.11525556f, -0.07257769f, 0.05865475f, 0.15724599f, -0.00289494f, -0.17338133f, 0.09317971f, 
    0.01254931f, 0.21446691f, -0.01070565f, -0.12509753f, -0.00464281f, -0.01543712f, -0.06342588f, -0.00497760f, 
    0.07717299f, -0.06137083f, -0.15973580f, -0.07027967f, 0.01180182f, -0.05137926f, 0.07047682f, 0.06739071f, 
    -0.06592728f, -0.10838941f, -0.13767509f, -0.04110766f, -0.37567654f, -0.35718748f, 0.04453490f, 0.05593516f, 
    -0.16606407f, 0.02880862f, 0.09466667f, -0.17074139f, 0.13331231f, 0.03711025f, -0.06837313f, -0.03643311f, 
    0.00779442f, -0.25681549f, -0.11624669f, 0.03214467f, -0.01661548f, 0.06813686f, -0.08023222f, -0.07196749f, 
    -0.07208178f, -0.01043253f, -0.05809507f, -0.00754911f, -0.04108922f, -0.08101805f, 0.08093546f, 0.12907432f, 
    0.07978418f, -0.07840266f, 0.09046359f, 0.07939177f, 0.09443521f, 0.02008988f, 0.00517354f, 0.08561192f, 
    -0.21326083f, -0.02206457f, -0.02601760f, -0.00432843f, -0.04335884f, 0.16742405f, 0.09016959f, 0.13669923f, 
    -0.20861642f, 0.13192245f, -0.03829537f, 0.05610326f, -0.07950155f, -0.00896614f, -0.07313147f, 0.16928081f, 
    0.14730088f, 0.03145475f, 0.05525256f, 0.09795558f, 0.13873546f, 0.23810253f, 0.08200823f, -0.15461546f, 
    0.12004575f, -0.08895008f, -0.01722943f, -0.12989338f, 0.09224228f, 0.15811650f, 0.05559068f, 0.00508435f, 
    -0.18189861f, 0.03239382f, 0.14412364f, 0.12456652f, -0.39949566f, 0.07328756f, 0.35195762f, 0.22681634f, 
    0.01512504f, 0.10244387f, -0.05872933f, -0.09650423f, 0.21288428f, 0.05338770f, 0.02909433f, -0.00137489f, 
    -0.49576208f, 0.13131434f, 0.07642765f, -0.15030609f, 0.12109314f, -0.04952735f, -0.04227397f, -0.07240695f, 
    -0.01880290f, 0.04268691f, -0.12292058f, -0.02917815f, 0.41444439f, 0.12344825f, -0.09120264f, 0.12296854f, 
    0.02468539f, 0.05978946f, 0.23654340f, 0.04892685f, -0.09382799f, 0.05680792f, 0.13632703f, 0.17395443f, 
    0.67249697f, -0.15807191f, -0.08404197f, -0.03816052f, -0.18607986f, 0.02498092f, 0.02567252f, 0.08615784f, 
    -0.07303354f, 0.00773220f, 0.02577719f, 0.03299753f, -0.22982723f, 0.03767183f, -0.14353491f, -0.39925718f, 
    -0.01422054f, 0.07360348f, 0.05607015f, 0.10472950f, 0.10062802f, -0.09597901f, 0.01257631f, -0.01336024f, 
    -0.06509700f, -0.10463952f, 0.20143688f, 0.39751410f, 0.06560123f, -0.05872905f, -0.01621055f, 0.00723896f, 
    -0.15074810f, 0.09445492f, 0.02881211f, 0.05057839f, 0.16511868f, 0.32456136f, 0.22480412f, 0.05501670f, 
    -0.26152894f, 0.11458109f, -0.23091777f, 0.14305151f, -0.14942370f, -0.13099723f, -0.03131400f, 0.27019930f, 
    0.26922557f, -0.10060877f, 0.17002329f, -0.13345799f, 0.05725287f, -0.22761077f, 0.28075653f, 0.16159846f, 
    0.22540532f, -0.09687633f, -0.18503328f, 0.03929931f, -0.36998263f, 0.24181008f, 0.23492055f, -0.06660572f, 
    -0.15600857f, -0.06280839f, -0.11708133f, 0.16214676f, 0.19029751f, -0.13602205f, 0.07652898f, -0.12749146f, 
    -0.21202147f, 0.14453462f, 0.07056366f, 0.24127245f, 0.04589742f, 0.14811018f, 0.16333711f, -0.10330252f, 
    0.06716572f, -0.01496163f, -0.03119381f, 0.00777921f, -0.24535136f, -0.10685216f, -0.13918540f, 0.13269202f, 
    -0.06590291f, 0.11549166f, -0.00355969f, 0.06399240f, -0.07264265f, -0.14155829f, 0.09942172f, -0.04854039f, 
    0.23901717f, 0.56001788f, -0.10625449f, -0.69167829f, 0.12083921f, 0.10878614f, -0.01788071f, -0.04289632f, 
    0.03444645f, 0.02901372f, 0.05445910f, -0.04185991f, -0.03550769f, -0.19501974f, 0.15439191f, 0.17234932f, 
    0.06994266f, 0.12403360f, 0.09984735f, -0.24309544f, 0.00732060f, 0.05955238f, 0.21219875f, -0.13642469f, 
    -0.31629664f, -0.04050362f, -0.03900209f, -0.15593047f, -0.11534236f, 0.02132655f, 0.05817214f, 0.00173197f, 
    0.08037008f, -0.05607258f, 0.06001326f, 0.11367799f, -0.80286872f, -0.00217466f, 0.13177831f, 0.21779397f, 
    0.05431068f, 0.05228636f, 0.07363386f, 0.08099870f, -0.07287998f, -0.09035918f, 0.08152404f, 0.12453587f, 
    0.03441124f, -0.33230391f, -0.04304754f, 0.12996233f, -0.03798387f, -0.23411201f, 0.16890065f, -0.09195092f, 
    0.02928441f, 0.06279574f, -0.04581147f, 0.03331397f, -0.28767765f, -0.34167495f, 0.00100150f, 0.27971390f, 
    0.03498697f, -0.00364522f, -0.13243960f, -0.24809943f, 0.13797675f, -0.16170169f, -0.13523591f, -0.11405922f, 
    -0.16866104f, -0.25327963f, 0.15829638f, -0.20854680f, -0.11662344f, -0.13023852f, -0.18460271f, -0.06098110f, 
    0.13422816f, 0.11131372f, -0.14229092f, -0.06927548f, -0.56759822f, 0.00476637f, 0.16973314f, -0.23233485f, 
    -0.02434790f, -0.04809249f, -0.01414980f, -0.06547022f, 0.09138694f, -0.10505735f, -0.08063991f, -0.10516940f, 
    0.46445408f, -0.07011364f, -0.05322211f, -0.07802874f, 0.08515257f, -0.16617379f, 0.19263953f, 0.09401059f, 
    -0.05303531f, -0.21213518f, -0.21999700f, 0.12355541f, -0.04787898f, -0.13835202f, -0.08758574f, -0.05383503f, 
    -0.10456053f, -0.07597233f, -0.04951834f, 0.14884238f, 0.08476560f, 0.03236566f, -0.19307484f, 0.01931406f, 
    -0.25936261f, 0.03227278f, 0.37370333f, -0.28724757f, -0.04723489f, -0.03153126f, 0.02911211f, 0.08682222f, 
    -0.03499007f, 0.08053288f, 0.09847867f, 0.06794323f, -0.24586844f, -0.28067848f, -0.01781423f, 0.25912645f, 
    0.15570524f, -0.05771137f, 0.13929382f, 0.05676336f, -0.05539183f, -0.02919725f, 0.16643488f, -0.06954580f, 
    -0.05787873f, -0.13426271f, -0.05096954f, -0.04837865f, -0.13913801f, -0.06887716f, 0.04806554f, -0.05787474f, 
    -0.09338208f, -0.01569227f, 0.02129506f, -0.03849547f, -0.10257289f, 0.03478760f, -0.12571225f, -0.15482405f, 
    0.02469685f, 0.08151329f, 0.09389064f, -0.12282066f, 0.03830296f, -0.11368916f, -0.08525734f, -0.04223866f, 
    -0.36574635f, -0.08138097f, 0.05518057f, 0.18874839f, -0.01217333f, -0.07391506f, 0.00759605f, 0.13973837f, 
    -0.00291014f, 0.08967429f, -0.09793118f, 0.16216324f, -0.04035701f, 0.16926038f, 0.13830075f, 0.32023659f, 
    -0.00681618f, -0.11681886f, 0.08519363f, 0.09275294f, -0.00373234f, -0.23698519f, -0.08617331f, -0.14062354f, 
    0.06895364f, 0.26571152f, 0.13741365f, -0.19270280f, 0.05357647f, -0.01209052f, 0.05101345f, -0.17276011f, 
    0.04822218f, -0.02548921f, -0.32727274f, -0.09751665f, -0.08572336f, 0.08466062f, -0.16611063f, 0.20445032f, 
    0.18474630f, -0.00042193f, 0.07794070f, 0.02936370f, -0.18874684f, 0.17490134f, 0.20353381f, 0.04605494f, 
    0.33869231f, -0.05922249f, -0.11596671f, 0.01598192f, -0.16630751f, -0.20552824f, 0.15244429f, -0.00495057f, 
    0.04758611f, 0.06335179f, 0.09742682f, 0.08598941f, -0.41026723f, -0.24727948f, -0.17478980f, -0.05721051f, 
    0.29464850f, 0.01776811f, -0.14278619f, -0.04080821f, 0.10329628f, -0.09798061f, -0.01105538f, 0.06376567f, 
    0.16359882f, -0.00565888f, 0.04945670f, -0.17231375f, -0.10539819f, -0.05302482f, -0.03109177f, 0.15465361f, 
    -0.09891691f, 0.16408627f, 0.14838603f, -0.14348289f, 0.20805247f, -0.03569859f, -0.00377103f, 0.30310157f, 
    -0.00761976f, -0.12840049f, 0.10554813f, -0.07270858f, -0.07544687f, 0.02152276f, 0.18698527f, 0.34165472f, 
    -0.34785223f, 0.02777726f, -0.13348065f, -0.21368936f, 0.06819437f, 0.06601835f, -0.13720226f, 0.06568541f, 
    0.04971981f, -0.12902799f, 0.08135690f, -0.15194041f, -0.09872459f, 0.18784267f, 0.30665329f, -0.27930796f, 
    -0.16800551f, -0.13036780f, -0.23561813f, -0.09826843f, -0.01946645f, -0.08413769f, -0.08454394f, 0.05603917f, 
    -0.13551553f, 0.00345912f, -0.01688094f, 0.06989945f, 0.03702556f, -0.23859614f, 0.05109975f, -0.32092595f, 
    0.09696800f, 0.06806010f, -0.20638038f, 0.17238912f, -0.47260740f, 0.09980778f, 0.07428766f, -0.29982969f, 
    -0.10709662f, 0.03513115f, 0.11709277f, -0.09643889f, -0.05519788f, 0.21211095f, -0.13697168f, 0.08875347f, 
    0.03361785f, 0.02294667f, -0.19391397f, -0.07023408f, 0.00074602f, 0.01329609f, -0.10385259f, -0.15066531f, 
    0.15423469f, -0.08827941f, 0.09734584f, -0.09727746f, -0.12687998f, 0.03484159f, 0.06610737f, 0.06991737f, 
    -0.00588078f, -0.03500727f, 0.24527207f, 0.08923808f, 0.19120042f, 0.02968651f, -0.31872454f, -0.05258163f, 
    -0.02826628f, -0.07531163f, -0.10897669f, -0.14552645f, 0.13684373f, 0.12931602f, -0.07986300f, 0.12341356f, 
    0.23112901f, 0.07789411f, 0.18285234f, -0.00259241f, -0.04639047f, 0.03173717f, 0.03781705f, 0.14151837f, 
    0.01114515f, 0.20976935f, 0.15796316f, 0.03241572f, -0.22270127f, 0.17147310f, 0.24646427f, 0.26574129f, 
    0.11154900f, 0.22100331f, -0.00867317f, -0.19159664f, 0.09032407f, -0.05266950f, 0.03676722f, -0.04535704f, 
    0.20962244f, -0.02439317f, 0.14376532f, -0.13709706f, -0.44610363f, -0.05418517f, -0.13034083f, -0.18553455f, 
    0.05286831f, 0.11341646f, 0.30604574f, 0.03895972f, -0.01578119f, 0.14960523f, -0.17626408f, -0.06334866f, 
    -0.28535324f, -0.55866116f, 0.25449723f, 0.25617811f, -0.14484785f, 0.09060761f, -0.04899309f, -0.10040662f, 
    -0.05162790f, 0.08460525f, -0.19150069f, 0.23001513f, 0.07113863f, -0.07460762f, 0.07061630f, 0.33651409f, 
    -0.12399255f, -0.07746819f, 0.07724693f, -0.02403082f, -0.19856501f, 0.05864478f, 0.02462626f, 0.02285565f, 
    -0.58099669f, 0.02624595f, 0.12131034f, -0.58282572f, -0.18688673f, 0.14660580f, 0.12322208f, -0.11431795f, 
    -0.03786543f, -0.25472584f, -0.12714365f, -0.10693121f, -0.44381624f, -0.04703998f, -0.45695087f, -0.19542672f, 
    0.03136763f, 0.05969877f, -0.10703692f, -0.03707563f, -0.02458695f, 0.06291160f, -0.08856969f, -0.08448339f, 
    0.07408107f, -0.19371256f, -0.11002909f, 0.20349446f, -0.10742836f, 0.14608103f, -0.17392609f, -0.15034972f, 
    -0.13561951f, -0.13050173f, -0.04045527f, 0.11422706f, 0.11418492f, -0.03809803f, 0.06824180f, -0.07231226f, 
    -0.07481626f, -0.09976784f, -0.04138864f, 0.15720531f, -0.05018891f, 0.11791341f, -0.09502462f, 0.24190482f, 
    0.22352406f, -0.14690672f, -0.03869679f, 0.06948991f, -0.09453551f, 0.00365092f, 0.01203669f, 0.21519171f, 
    0.17015475f, -0.13386065f, 0.00859685f, 0.07408977f, -0.11460490f, 0.13908094f, 0.07719614f, -0.25078616f, 
    -0.01993722f, 0.04454099f, 0.11869064f, -0.09413726f, -0.10058197f, -0.04792951f, 0.07451037f, -0.04071764f, 
    -0.34722531f, -0.35557923f, -0.01654953f, 0.29506224f, 0.20696850f, 0.08646814f, 0.11709741f, 0.01758314f, 
    0.10648540f, 0.03182181f, 0.04374523f, -0.15654854f, 0.00792619f, 0.08666445f, 0.08789796f, 0.09065013f, 
    0.12515998f, 0.09187016f, 0.14238162f, -0.11756603f, -0.02439089f, -0.08427884f, -0.05565052f, 0.10995327f, 
    0.38077244f, 0.05158884f, -0.04696158f, 0.12799481f, -0.02152963f, -0.02714050f, 0.10907180f, 0.02039301f, 
    -0.06300885f, -0.27990162f, -0.18827663f, 0.10314258f, 0.39505005f, -0.34280747f, -0.04983794f, -0.18400337f, 
    0.01148482f, -0.01837281f, -0.18540964f, -0.10927886f, 0.02233316f, -0.07331525f, -0.04270159f, -0.12801184f, 
    -0.01049759f, -0.04012524f, 0.06200084f, 0.12104816f, 0.07197771f, -0.09069116f, -0.09100234f, 0.20380107f, 
    0.22583455f, 0.02481473f, 0.16921839f, -0.12997366f, -0.30731198f, -0.02268478f, -0.06928334f, 0.20517875f, 
    0.09835112f, -0.14656857f, -0.20211065f, -0.02520328f, 0.08625367f, 0.14455990f, 0.11222263f, 0.09258183f, 
    -0.35487583f, -0.14314768f, -0.02224435f, -0.05897386f, 0.03588650f, 0.02761784f, -0.01589534f, -0.16392143f, 
    0.11915121f, -0.12860626f, 0.08907265f, -0.18279096f, -0.08493684f, -0.02412141f, -0.22032043f, 0.23499243f, 
    0.10040531f, 0.15210699f, -0.35628471f, 0.09354893f, -0.01410217f, 0.10227060f, -0.02092857f, 0.07743353f, 
    -0.23367277f, -0.32021371f, 0.27116606f, -0.07820714f, -0.10905092f, 0.07984931f, 0.10943668f, -0.07894173f, 
    -0.04061900f, 0.10986663f, 0.19783555f, 0.11911788f, -0.28016680f, 0.02284463f, -0.00923341f, -0.13581711f, 
    -0.07498809f, 0.07007489f, 0.04463002f, -0.02153349f, 0.20246759f, -0.09072111f, -0.07341599f, 0.11846767f, 
    0.07450947f, 0.09893553f, 0.11034621f, 0.04849719f, -0.00209186f, -0.11813278f, 0.14252125f, 0.07966851f, 
    0.08754064f, 0.08965205f, 0.10912346f, -0.15164690f, -0.16848949f, -0.00179702f, -0.17491618f, -0.17942536f, 
    -0.15109046f, -0.09705895f, 0.22138587f, -0.04830048f, -0.09216487f, -0.00658172f, -0.07269285f, -0.04692486f, 
    -0.04427420f, 0.16521616f, 0.11251345f, -0.21120805f, 0.08853547f, 0.09189181f, 0.10876369f, -0.05554002f, 
    0.17919338f, -0.09687471f, -0.06972890f, 0.18053626f, 0.13718413f, 0.05619579f, -0.06418510f, -0.12317774f, 
    -0.00586227f, 0.00279645f, 0.04051781f, 0.06482559f, -0.23773880f, -0.08278739f, -0.20584626f, -0.13675278f, 
    0.78916341f, -0.44859403f, 0.18904665f, -0.19666183f, 0.15996692f, 0.00028229f, 0.17229110f, 0.06691793f, 
    -0.02731525f, 0.13590127f, -0.10594727f, -0.01279814f, -0.44820255f, 0.28931472f, 0.09437644f, -0.19310400f, 
    -0.20819342f, -0.05067328f, 0.04825057f, 0.04838241f, -0.02442697f, -0.07660698f, 0.06123530f, 0.00449712f, 
    -0.37725821f, 0.03784976f, -0.18727723f, 0.25010622f, -0.04599287f, 0.09133644f, 0.12195670f, -0.06528334f, 
    0.00776362f, 0.09564546f, 0.10998174f, -0.25871181f, 0.46725884f, -0.17272106f, 0.04403596f, -0.08626146f, 
    -0.16164038f, 0.13882995f, 0.08598929f, -0.02375822f, 0.06600454f, -0.08258483f, -0.04101769f, -0.10544917f, 
    -0.08768096f, -0.18949068f, -0.42171648f, 0.17428286f, -0.12973981f, 0.12242725f, -0.04457328f, -0.00480726f, 
    -0.11905381f, 0.09840470f, -0.08247916f, 0.05681653f, 0.06021189f, 0.00750505f, -0.20992619f, -0.31979635f, 
    0.06886695f, -0.00307469f, 0.00201175f, 0.08418150f, -0.03514363f, 0.08272713f, 0.11377853f, 0.06122556f, 
    0.02147970f, -0.04973016f, 0.07099018f, 0.20800325f, -0.19003017f, -0.23253615f, 0.23349118f, -0.12197919f, 
    -0.08343752f, -0.03360197f, -0.21397451f, -0.29653710f, -0.00354100f, 0.21942529f, 0.05760358f, -0.06671087f, 
    -0.01078865f, 0.07651572f, 0.00956233f, 0.07241502f, 0.09600870f, -0.02479306f, -0.07147173f, -0.12574320f, 
    -0.18154791f, -0.43621454f, 0.28251088f, -0.04291512f, 0.02323302f, -0.00602239f, 0.04806089f, -0.08276028f, 
    -0.12607870f, -0.03697942f, -0.08565179f, 0.05401111f, -0.11151885f, -0.22885028f, 0.05738678f, -0.18188958f, 
    0.12149385f, 0.01014663f, 0.02338683f, -0.22894143f, 0.03153627f, -0.05933799f, 0.02563499f, 0.04560305f, 
    0.30129936f, -0.34818241f, 0.02056334f, 0.06927016f, -0.01296159f, 0.08226473f, -0.06817489f, 0.04572667f, 
    0.09369987f, -0.07939513f, -0.09046086f, 0.00552738f, -0.21504053f, -0.11322594f, -0.13533731f, -0.16779412f, 
    0.14773762f, 0.01689042f, 0.08245880f, 0.12115045f, -0.02527923f, -0.04128876f, 0.07106092f, 0.06276087f, 
    0.12222589f, -0.19152232f, 0.06685419f, 0.16542175f, -0.10216708f, -0.01477452f, 0.05404590f, 0.05219718f, 
    0.12378026f, 0.02686234f, 0.14453872f, 0.10145238f, -0.01794657f, -0.26878572f, 0.02288258f, -0.37650847f, 
    0.11068001f, 0.09427871f, -0.07443439f, -0.13033378f, 0.01398079f, -0.14461473f, 0.22192855f, 0.19678754f, 
    -0.60220426f, -0.00435818f, -0.18056691f, 0.24963856f, 0.20206706f, -0.00260441f, 0.17495844f, -0.09364347f, 
    0.15062033f, -0.05625360f, -0.04428672f, 0.13003905f, 0.28190908f, 0.21138316f, 0.02762744f, -0.39495900f, 
    0.01123334f, 0.12684378f, 0.12709068f, -0.06437372f, 0.08205489f, -0.20441566f, -0.11987879f, -0.14704435f, 
    -0.42372429f, 0.07297943f, -0.00443426f, -0.05341745f, 0.14370613f, 0.11862001f, 0.02822739f, 0.05726746f, 
    -0.09325612f, 0.06085707f, 0.04022605f, -0.09642618f, 0.59964120f, 0.28050330f, 0.21078353f, 0.05031045f, 
    -0.23726624f, -0.08219001f, -0.07497358f, 0.07883361f, 0.01737035f, -0.04029678f, -0.00021531f, 0.17246276f, 
    -0.14324233f, -0.02621520f, -0.34686667f, -0.26091388f, -0.23207246f, -0.13788274f, -0.21742959f, -0.29927599f, 
    -0.11512551f, 0.14479248f, -0.03661548f, -0.01921314f, -0.18214473f, 0.27673289f, 0.24098900f, -0.25634742f, 
    -0.34480301f, -0.28244817f, 0.06916174f, 0.19435681f, 0.19849521f, 0.14646128f, 0.10864624f, -0.04916750f, 
    0.02620870f, -0.15156095f, -0.03101399f, 0.31151900f, 0.07733162f, -0.14092384f, -0.01338557f, 0.14287868f, 
    -0.01389178f, 0.07296687f, 0.01587935f, -0.06837688f, -0.53245264f, -0.00900136f, -0.08553195f, -0.06658477f, 
    -0.02329813f, 0.02692203f, -0.00023863f, 0.05600946f, 0.01308197f, 0.13022253f, 0.11280067f, 0.14387715f, 
    0.26764584f, -0.21608986f, -0.43197513f, 0.25152966f, -0.05705911f, 0.19606639f, -0.05177154f, 0.00084980f, 
    0.05535582f, -0.18757728f, -0.06652394f, 0.02052219f, 0.08632236f, 0.11626897f, 0.10559461f, -0.26604569f, 
    -0.05808015f, -0.01496023f, 0.09983067f, 0.02800057f, 0.03233990f, -0.11534999f, -0.20212835f, -0.09225987f, 
    0.18516287f, 0.13817188f, 0.23924294f, 0.04303655f, -0.10614402f, -0.01246720f, -0.06017251f, -0.05121052f, 
    0.00501324f, 0.00253651f, -0.06683829f, -0.01864040f, -0.25990111f, 0.05512244f, -0.07211300f, 0.07335229f, 
    -0.10724431f, -0.10538349f, -0.15201943f, -0.02948476f, -0.04697213f, -0.04652959f, 0.03229944f, -0.00014711f, 
    -0.08458636f, -0.01472738f, -0.05222790f, -0.16015923f, -0.13825442f, -0.07310300f, -0.20687048f, 0.04966941f, 
    -0.07820589f, -0.09725194f, -0.02807412f, -0.06836502f, -0.09337262f, -0.00705158f, 0.02238782f, -0.02821893f, 
    0.03071403f, -0.06892541f, -0.04504796f, -0.03999038f, 0.04113881f, -0.06595245f, -0.06288520f, -0.03203349f, 
    0.12190218f, -0.32534274f, -0.07784265f, -0.16397728f, 0.00179096f, 0.05720280f, -0.02786354f, -0.04544762f, 
    -0.08342873f, 0.04857570f, -0.05240610f, -0.00940007f, 0.11988480f, 0.18531990f, 0.20843092f, 0.02489365f, 
    0.08562396f, 0.06307065f, -0.02326546f, -0.09553120f, 0.01457453f, 0.06668307f, 0.03294097f, -0.06807321f, 
    0.18529327f, 0.00971931f, 0.02714443f, 0.27137995f, -0.09279973f, 0.01040550f, -0.06011997f, -0.06710006f, 
    0.03552813f, -0.03365606f, -0.02752424f, -0.20556264f, -0.04947265f, -0.23398332f, 0.10692685f, 0.22633699f, 
    0.03893652f, -0.14410765f, -0.09607509f, -0.02755957f, 0.05864011f, 0.11836532f, -0.01793804f, -0.09457482f, 
    0.41404417f, 0.11177371f, -0.02150619f, -0.04044291f, -0.14815235f, -0.06596129f, 0.01657515f, 0.00342527f, 
    -0.11645284f, 0.10514690f, 0.00400211f, 0.00328182f, -0.17931516f, 0.15810223f, 0.07709009f, -0.13244431f, 
    -0.08270640f, 0.00401322f, -0.04731262f, -0.05192770f, 0.01074533f, -0.05111925f, -0.10595597f, -0.09262850f, 
    0.09826099f, 0.17104793f, -0.12685277f, 0.18034226f, 0.08219486f, -0.12300373f, -0.03954449f, -0.05056527f, 
    0.09292359f, -0.09193877f, -0.04308296f, -0.15156054f, 0.09976824f, 0.01298594f, 0.16363403f, 0.11070728f, 
    -0.00903436f, -0.06414632f, 0.03482417f, -0.04627496f, -0.05008170f, -0.01186836f, -0.00706795f, -0.09098709f, 
    -0.13182865f, 0.30888891f, -0.06558983f, 0.27281460f, 0.14448789f, -0.01677742f, -0.00667210f, 0.10004071f, 
    0.14076672f, -0.04111745f, 0.00955824f, -0.06877883f, -0.39494282f, 0.22205453f, -0.09827107f, 0.00924280f, 
    -0.08628850f, -0.01217966f, -0.04357151f, -0.07676833f, -0.07658178f, 0.07202683f, 0.07375275f, 0.15420805f, 
    0.32730499f, -0.00217230f, 0.01756718f, 0.02668628f, 0.16397995f, -0.05496149f, -0.09679597f, -0.05914981f, 
    -0.11140709f, -0.09978957f, 0.08441115f, -0.03597502f, -0.34032428f, -0.09388213f, -0.25858358f, -0.08846635f, 
    0.00817945f, -0.08150279f, 0.04193101f, 0.01913508f, -0.06628691f, -0.12547459f, -0.09890316f, 0.02929335f, 
    0.09043077f, -0.14014804f, 0.07674794f, -0.28555784f, -0.05310091f, 0.12756103f, 0.03703980f, -0.10275462f, 
    -0.09965540f, -0.03082031f, -0.09330769f, 0.02116233f, -0.09686149f, -0.11068482f, 0.26481566f, 0.11230225f, 
    0.18842667f, 0.07964116f, 0.05757745f, 0.11795662f, -0.06762224f, 0.06179446f, 0.01826245f, 0.00478861f, 
    0.00099916f, 0.13630331f, -0.01377356f, 0.08615815f, 0.03237723f, -0.01268864f, 0.09075364f, -0.09258718f, 
    0.03981439f, -0.07271361f, -0.04393647f, -0.13303442f, 0.07101878f, -0.19364670f, -0.14504156f, 0.06237063f, 
    -0.08429148f, -0.10514459f, -0.05146941f, -0.08308127f, -0.14097905f, -0.03157138f, -0.00534328f, -0.02869043f, 
    -0.44704583f, 0.04728230f, 0.20963348f, -0.16230345f, 0.05108750f, 0.02417415f, -0.07317874f, 0.05798800f, 
    -0.13547496f, 0.08775698f, -0.10567949f, -0.12452651f, 0.22917026f, 0.17023404f, 0.20462093f, 0.02713818f, 
    0.05845639f, 0.04332641f, 0.04109114f, -0.04828855f, -0.09455320f, 0.10730834f, -0.04560837f, -0.06610462f, 
    0.02652816f, 0.05328665f, 0.18300830f, 0.15365201f, 0.10577506f, -0.11925725f, -0.06195815f, -0.08114274f, 
    0.12917919f, 0.00777837f, -0.08323900f, -0.01664345f, -0.29115450f, -0.04186159f, -0.35398266f, 0.00763101f, 
    -0.01472655f, 0.02623277f, -0.07218028f, -0.03906008f, -0.12766384f, 0.00121496f, 0.05281825f, 0.02951146f, 
    -0.00063970f, 0.09069227f, -0.27993485f, -0.45794275f, -0.03961441f, -0.00473009f, -0.08169685f, -0.16358209f, 
    -0.10268427f, -0.09382059f, 0.05824481f, -0.03691588f, 0.40806362f, -0.17955829f, -0.25085756f, -0.09884275f, 
    -0.23403411f, -0.08422324f, -0.00868942f, -0.05345131f, -0.05801533f, 0.04370120f, -0.10835066f, -0.00287598f, 
    0.15861566f, 0.19282150f, 0.10270377f, 0.27963677f, 0.18418309f, 0.13489202f, 0.08264659f, -0.04346588f, 
    -0.08857150f, -0.06966202f, 0.06735987f, -0.12724705f, -0.34355879f, 0.16187610f, -0.12202360f, -0.07983440f, 
    0.07450959f, 0.03891285f, -0.03458914f, -0.05147054f, -0.13000913f, -0.00500794f, -0.09029726f, -0.11639366f, 
    0.06932681f, 0.29877138f, 0.18270466f, 0.20594662f, 0.01175599f, 0.03133949f, 0.03117327f, 0.03592825f, 
    -0.00922112f, 0.08233457f, -0.02208535f, 0.09370758f, 0.07577118f, 0.23306321f, -0.02302785f, 0.24069725f, 
    0.06622928f, 0.06471980f, -0.02270303f, -0.05147721f, 0.03857915f, 0.00132723f, 0.01086385f, -0.04232984f, 
    -0.06108123f, 0.09136602f, -0.23625284f, 0.15165403f, -0.07988965f, -0.01004320f, -0.08216099f, -0.02222155f, 
    -0.08982582f, -0.00034992f, 0.04121949f, 0.02305898f, -0.26903370f, 0.16046366f, -0.28351614f, -0.09361146f, 
    -0.13609000f, 0.01000324f, -0.07218025f, -0.05569830f, -0.17222606f, -0.02783387f, -0.12318008f, -0.24274421f, 
    0.06106506f, 0.21333458f, 0.00986388f, -0.31264284f, 0.09433358f, 0.01137169f, 0.14727110f, 0.10215528f, 
    0.03504116f, -0.07309339f, 0.14091650f, 0.18929942f, -0.06521875f, 0.11156832f, -0.42160556f, -0.32923970f, 
    0.04861744f, -0.11247110f, -0.01611541f, 0.03438404f, 0.05463671f, -0.01952121f, -0.03958742f, -0.24897881f, 
    0.27928540f, -0.03595475f, 0.02008297f, 0.09468047f, -0.18049467f, -0.05793872f, 0.09401412f, -0.14275448f, 
    -0.02488201f, -0.05401932f, -0.36141127f, -0.01120693f, -0.07296583f, 0.12442968f, 0.09524749f, -0.23938011f, 
    -0.01213743f, 0.15183239f, -0.10020253f, 0.05610712f, -0.10574498f, -0.00117486f, 0.04304393f, -0.13034984f, 
    0.31290627f, -0.12904732f, -0.01580284f, 0.15046598f, 0.02018121f, -0.09305309f, -0.03345256f, -0.13435780f, 
    -0.09775246f, 0.07863478f, 0.00072384f, 0.08902747f, -0.33331949f, 0.00879000f, 0.32237464f, -0.29516807f, 
    -0.01286122f, 0.12630610f, -0.23455329f, -0.05953733f, 0.01254687f, -0.04910697f, 0.07229272f, 0.11604039f, 
    -0.22128534f, -0.18790238f, -0.01765241f, -0.24824980f, 0.00249879f, -0.27049997f, 0.00068881f, 0.16325161f, 
    0.03502108f, 0.15304714f, 0.00396703f, -0.10001013f, -0.23835464f, -0.17054275f, -0.23457080f, -0.45545661f, 
    -0.03408752f, -0.05339820f, -0.10927317f, -0.17766957f, 0.16366751f, 0.05971731f, 0.04837493f, 0.10920712f, 
    -0.28582996f, -0.06622104f, 0.03348724f, -0.14623955f, 0.10057321f, -0.22514181f, 0.00206909f, -0.15997554f, 
    0.09037127f, -0.05092292f, -0.02723486f, 0.09151454f, 0.42556348f, -0.05591681f, 0.05659414f, 0.19114108f, 
    0.16759598f, -0.13831657f, -0.16943851f, -0.04614462f, 0.05815062f, 0.09766421f, 0.03098165f, -0.03103139f, 
    0.00715465f, 0.08487207f, 0.03739356f, -0.04052104f, 0.05028036f, -0.12909991f, 0.03871251f, -0.01483459f, 
    0.02922270f, 0.03400387f, -0.05339382f, 0.14535840f, -0.20932201f, -0.22035277f, 0.19358501f, -0.23039594f, 
    -0.26799038f, -0.16395679f, 0.13967521f, 0.03512780f, -0.03794351f, -0.06487078f, -0.29744440f, -0.04837198f, 
    -0.13213694f, 0.23054627f, 0.03423341f, 0.15902758f, -0.10645030f, 0.00026524f, -0.07448559f, 0.13195218f, 
    -0.07429902f, -0.07412697f, -0.00897731f, 0.10595273f, -0.03693236f, -0.13263628f, 0.06579193f, 0.24069208f, 
    0.16648462f, 0.00686783f, -0.07200742f, 0.00264430f, 0.22644237f, 0.01743056f, 0.03393659f, -0.00918667f, 
    -0.21139602f, 0.00186468f, -0.03285132f, -0.35348040f, -0.04681255f, -0.01549705f, 0.03533630f, 0.03859881f, 
    -0.08664651f, -0.02124481f, 0.05389664f, 0.03903805f, 0.11735266f, -0.03647638f, -0.13321772f, 0.26750138f, 
    0.16302694f, 0.11065966f, -0.04530764f, -0.10440789f, -0.10252520f, 0.12466663f, 0.14430679f, 0.07320832f, 
    0.15857503f, -0.01810300f, 0.17557941f, 0.07364339f, -0.06990057f, -0.06677965f, -0.05332146f, 0.00807153f, 
    0.06932785f, -0.06114110f, 0.06096186f, -0.14400283f, -0.14270248f, -0.12957999f, 0.28676823f, 0.18286313f, 
    -0.14556006f, -0.07373167f, 0.15098667f, -0.15643443f, 0.03015967f, 0.00006533f, -0.16248582f, -0.16403551f, 
    -0.05723875f, -0.21571906f, -0.17185374f, -0.19846193f, 0.12226865f, -0.17927699f, -0.10619829f, -0.05869589f, 
    0.14533429f, 0.06241501f, -0.07950732f, 0.19953978f, 0.06349781f, -0.35718429f, 0.08525337f, -0.43909696f, 
    0.15745939f, 0.05258019f, -0.08929357f, -0.07781815f, 0.02423934f, 0.08067726f, 0.02677957f, -0.08124109f, 
    -0.09347999f, -0.10023577f, 0.31883991f, 0.03164781f, -0.12518704f, 0.00134639f, -0.03718267f, -0.28391498f, 
    0.02399679f, -0.05460572f, -0.18200490f, -0.05143698f, -0.28712583f, 0.04514358f, 0.12907636f, -0.04252389f, 
    -0.17669904f, -0.04385364f, 0.02824671f, -0.05522587f, -0.02289185f, -0.00646810f, -0.14575721f, -0.11482636f, 
    0.18782161f, 0.50966895f, -0.15426110f, 0.13382237f, 0.09399041f, -0.03273967f, -0.49250188f, -0.05100339f, 
    -0.17089412f, 0.05745291f, 0.15369593f, -0.01020823f, -0.08146201f, -0.06714790f, -0.06522874f, 0.05928567f, 
    -0.12421370f, -0.04937257f, -0.10033373f, 0.17921619f, -0.04058323f, 0.15592815f, 0.01801252f, 0.02290005f, 
    0.05520107f, -0.15278946f, -0.07620947f, -0.03154038f, 0.17452219f, 0.08938627f, 0.02573116f, 0.11277323f, 
    -0.08424527f, 0.10937427f, -0.00645427f, -0.04525234f, -0.12424498f, 0.08821605f, -0.44875604f, 0.06550317f, 
    0.11562467f, -0.06779758f, -0.10574070f, -0.12787022f, 0.02609063f, 0.10541506f, 0.15016745f, -0.11202186f, 
    -0.24080476f, -0.09242824f, 0.19208328f, -0.33619833f, -0.02171304f, 0.09292740f, 0.09124590f, -0.05884035f, 
    -0.01267460f, -0.01109623f, 0.05782270f, 0.05708596f, 0.05534887f, -0.00927117f, 0.04565616f, 0.28479859f, 
    0.26668581f, 0.12046854f, -0.02927298f, -0.16254078f, 0.00348260f, -0.01432795f, 0.19094133f, -0.01535887f, 
    0.27426165f, 0.03520733f, -0.24941564f, -0.04405522f, 0.19084603f, 0.03471814f, 0.17750357f, -0.23188813f, 
    -0.16693467f, -0.04818194f, 0.06366016f, 0.04605690f, -0.27280146f, 0.37420544f, -0.00447522f, 0.05981732f, 
    -0.18690258f, -0.10964997f, -0.12881772f, 0.08364777f, 0.05218168f, 0.02289491f, 0.09096541f, -0.03789363f, 
    -0.19445178f, 0.26617861f, -0.21288718f, -0.36436629f, -0.14387386f, -0.03669542f, -0.07187703f, 0.09881666f, 
    0.14349540f, 0.02937450f, -0.01217124f, -0.08412586f, -0.39621675f, 0.21583787f, 0.12153693f, -0.00495261f, 
    -0.11179309f, -0.03285447f, 0.00537079f, -0.26894957f, 0.10830291f, 0.16832919f, -0.01643246f, 0.05262784f, 
    -0.04633816f, -0.00290781f, -0.00513877f, 0.31348184f, -0.09205537f, 0.03756876f, -0.16387917f, -0.06160512f, 
    -0.14430185f, 0.05234574f, 0.02161380f, 0.06599170f, -0.12848249f, 0.05304116f, 0.23857765f, 0.00606829f, 
    0.01342246f, 0.06965164f, 0.12547548f, -0.20399351f, -0.11442128f, -0.08668148f, 0.06331255f, 0.14568849f, 
    0.07193037f, 0.13675541f, -0.15923613f, 0.20715395f, 0.25172418f, -0.09754026f, -0.12047724f, 0.12782608f, 
    0.05204009f, 0.03384553f, 0.43201229f, 0.04966998f, -0.27544025f, -0.19955412f, -0.00644017f, -0.07033171f, 
    -0.02943767f, 0.09599514f, 0.17025183f, -0.17417826f, 0.05660453f, 0.03093275f, -0.03160252f, -0.05973398f, 
    0.11366212f, -0.25861669f, 0.36859646f, -0.07518339f, 0.17746836f, 0.05824682f, -0.05611715f, -0.07696316f, 
    0.08631045f, -0.03499528f, -0.11342297f, -0.01273928f, -0.07868951f, -0.50821334f, 0.01303267f, 0.00372355f, 
    -0.13412866f, 0.09476079f, -0.18608446f, -0.00819345f, -0.04360235f, 0.05812104f, 0.07761507f, -0.04475259f, 
    -0.17531350f, 0.17618425f, -0.12054851f, 0.00843829f, -0.01290214f, -0.17825924f, 0.00777397f, -0.04266138f, 
    0.00600916f, 0.04201364f, -0.08173248f, 0.05584458f, 0.23889196f, -0.39370829f, -0.19103396f, -0.42962238f, 
    -0.31049967f, 0.08929507f, -0.00096707f, 0.22859637f, 0.07869826f, -0.03645872f, 0.00336009f, -0.13813509f, 
    0.25323224f, 0.13994902f, -0.07896189f, -0.08800959f, -0.07993617f, -0.02692659f, 0.04681045f, 0.07597564f, 
    0.07728513f, 0.01266346f, 0.14335839f, 0.20328970f, -0.53201479f, 0.22289018f, -0.30116534f, -0.11572338f, 
    0.11571272f, -0.04997939f, 0.09268021f, -0.13296890f, 0.01427911f, 0.02539635f, 0.02872526f, 0.07093618f, 
    0.12791228f, -0.15448751f, 0.26535210f, -0.38577825f, 0.04256796f, 0.08403927f, -0.05121252f, 0.16941084f, 
    -0.01791733f, -0.07496992f, -0.02762161f, 0.02134360f, 0.32867262f, 0.09298676f, -0.15008384f, 0.36771420f, 
    0.14777943f, -0.06164252f, -0.11438160f, 0.19904971f, -0.00314561f, 0.10977408f, 0.20810840f, 0.08890838f, 
    -0.54852778f, -0.36517829f, 0.22028945f, -0.23128124f, 0.10457011f, 0.04357741f, 0.00348049f, 0.12849037f, 
    0.09685965f, -0.20753404f, 0.03570805f, 0.00001816f, -0.46614003f, 0.24122062f, -0.02841651f, -0.48293263f, 
    0.10836401f, 0.09153719f, -0.16931112f, -0.13764170f, -0.07691500f, -0.22033927f, -0.03849097f, -0.19986361f, 
    0.17363706f, -0.26479504f, 0.21431325f, 0.13393320f, 0.07057320f, 0.06996781f, -0.21402292f, -0.27929193f, 
    -0.25245157f, -0.02801184f, 0.11866919f, -0.15718961f, -0.16333199f, 0.11726338f, 0.01475270f, -0.30228040f, 
    0.12527257f, -0.07122306f, -0.06418853f, -0.02046514f, -0.13368207f, 0.08104050f, -0.06122176f, -0.23550217f, 
    0.30131698f, -0.30406588f, 0.05277985f, -0.06441130f, -0.07785869f, -0.11401164f, 0.04454540f, 0.07919675f, 
    -0.19984877f, -0.00120627f, 0.11051573f, 0.08724061f, 0.27048984f, -0.53034514f, 0.05636968f, 0.07273775f, 
    0.01689327f, -0.09073617f, -0.29848346f, 0.07194133f, -0.03056104f, -0.09495005f, 0.17044587f, -0.03722936f, 
    -0.18365982f, -0.02431938f, -0.26723921f, -0.00724212f, 0.02270935f, -0.14883113f, -0.00297093f, 0.01979837f, 
    -0.00547849f, -0.14839967f, 0.10865134f, -0.13455313f, 0.10674318f, 0.00715621f, -0.16642854f, -0.15771329f, 
    -0.14264034f, 0.01277605f, -0.09706072f, -0.00346220f, 0.02988386f, -0.04455373f, -0.00213986f, 0.18856846f, 
    -0.43050668f, -0.09750875f, -0.06148412f, 0.38562635f, 0.12275758f, -0.01391170f, -0.08906466f, -0.03187888f, 
    0.05331660f, 0.23426197f, 0.02840724f, -0.10924974f, -0.10639793f, -0.17460780f, -0.14538366f, 0.05029834f, 
    0.10233083f, 0.02483888f, 0.01052995f, 0.02559754f, 0.03552444f, 0.13067777f, -0.07088773f, -0.04658628f, 
    0.42160514f, -0.46829703f, 0.33439276f, -0.07946438f, -0.07727230f, -0.02045134f, 0.04177200f, 0.19242054f, 
    -0.21989541f, 0.13271867f, 0.04014981f, 0.05523612f, -0.15481505f, 0.27837113f, -0.01425724f, -0.34322888f, 
    -0.00687243f, 0.02244552f, 0.12467747f, -0.05411358f, 0.07066396f, 0.06540533f, -0.07466867f, -0.11921321f, 
    0.41636220f, 0.14788316f, 0.18468361f, -0.31770754f, -0.12248974f, 0.10195504f, 0.15326472f, -0.27049103f, 
    -0.01516051f, -0.06064523f, -0.11972082f, -0.00670062f, -0.47596005f, -0.10663259f, -0.13940230f, -0.08935092f, 
    0.22659954f, 0.02782622f, 0.03478343f, -0.01969103f, -0.08369065f, -0.06076165f, 0.03426380f, 0.17281592f, 
    -0.08066326f, -0.24806669f, 0.05912288f, 0.30119756f, 0.04944798f, 0.03592259f, -0.02377145f, 0.11610959f, 
    0.03283687f, -0.11675599f, 0.13430034f, 0.01452770f, -0.09359638f, 0.35045266f, -0.10158288f, -0.30606782f, 
    0.19184808f, 0.04532037f, -0.06373815f, -0.11504286f, -0.15192132f, -0.10316292f, -0.06758782f, -0.13386735f, 
    -0.01739813f, -0.19560789f, -0.09136488f, 0.21498542f, 0.06399337f, -0.01424342f, -0.16738652f, 0.19897600f, 
    -0.11299466f, -0.11273014f, 0.18772152f, 0.00842610f, -0.13788268f, 0.41248444f, -0.09198352f, 0.13704941f, 
    -0.16182110f, 0.17716956f, -0.04223243f, 0.24428867f, 0.02918523f, -0.04349996f, 0.09536210f, 0.00159233f, 
    -0.20259596f, 0.47492003f, 0.31480032f, 0.20671092f, 0.18434490f, 0.14460091f, -0.00859975f, -0.10477051f, 
    -0.15369141f, 0.01552070f, -0.10885956f, 0.13759571f, 0.25624737f, 0.15900245f, -0.04087617f, -0.19189540f, 
    -0.08575396f, 0.06769799f, 0.13489343f, 0.10138460f, -0.09514562f, 0.05305038f, 0.03023356f, -0.10240510f, 
    -0.04978749f, 0.12279075f, 0.12195859f, -0.17691472f, 0.10938727f, 0.21229555f, 0.06909233f, -0.06245632f, 
    0.04084032f, 0.05502056f, 0.10775794f, 0.03960258f, -0.22384927f, 0.10216266f, 0.23061548f, 0.08602888f, 
    0.15423398f, 0.00968102f, 0.06118469f, 0.00834912f, 0.03257502f, 0.03217804f, 0.03336193f, -0.06611560f, 
    0.13947092f, -0.18006973f, -0.19785418f, -0.02814481f, 0.04427016f, 0.03365912f, 0.05575971f, -0.02482350f, 
    0.06380595f, -0.09211552f, -0.08818581f, 0.11369989f, 0.45982009f, 0.23110402f, -0.09357975f, -0.04192962f, 
    -0.02119484f, -0.00030893f, -0.00866503f, 0.01520927f, -0.07448022f, -0.10356753f, -0.07072015f, -0.04783488f, 
    -0.52291924f, 0.08648232f, -0.19489019f, -0.25477597f, 0.10106500f, -0.07061975f, -0.14392558f, -0.17313778f, 
    0.04189010f, 0.00689148f, 0.04839410f, 0.05129032f, 0.21918520f, 0.19080462f, -0.10526072f, -0.14176670f, 
    0.04087501f, -0.06369277f, 0.06984688f, -0.04789843f, -0.12373944f, 0.02210438f, 0.06049200f, 0.06239770f, 
    0.22073303f, 0.11070751f, 0.13108982f, -0.04222503f, -0.05662027f, 0.01403101f, 0.10766125f, -0.12082007f, 
    0.03354299f, 0.07636911f, -0.05118733f, 0.08238799f, 0.27591792f, 0.18485045f, -0.19079810f, -0.05313840f, 
    -0.04916190f, 0.05885392f, 0.03745583f, 0.06404971f, -0.00242653f, 0.02144977f, 0.15884848f, 0.11913370f, 
    -0.24113885f, 0.05386432f, -0.01883886f, 0.11304320f, 0.14146745f, -0.12913711f, -0.07421079f, -0.11519217f, 
    -0.04751444f, -0.08607206f, -0.07470958f, 0.03847728f, -0.72637677f, -0.52194643f, -0.32105425f, -0.38048926f, 
    0.03935116f, -0.02273371f, -0.10165600f, -0.06201545f, 0.12448398f, -0.14921358f, -0.11325197f, -0.05563841f, 
    -0.07788745f, 0.15859810f, 0.05923065f, 0.02051020f, 0.16149728f, 0.01884169f, 0.04381423f, -0.04271798f, 
    -0.08362208f, 0.02997741f, 0.08284161f, 0.13377912f, 0.35888141f, 0.02803584f, 0.08904088f, 0.10257973f, 
    0.07208731f, -0.22014602f, 0.12497047f, 0.00056059f, 0.08591900f, -0.07100584f, -0.04157051f, -0.05584787f, 
    0.13287860f, 0.07477155f, -0.11560690f, 0.03583161f, -0.12853414f, -0.07259996f, 0.06886405f, -0.12609850f, 
    -0.03852514f, -0.00913766f, 0.03687606f, 0.04950451f, -0.50839782f, -0.00609196f, -0.01671337f, -0.39172438f, 
    0.21333309f, -0.08330695f, 0.06300110f, 0.01843908f, 0.05382589f, -0.07661076f, -0.02071440f, 0.07683441f, 
    -0.31272534f, 0.31062460f, 0.08375501f, 0.18659981f, -0.02677470f, 0.09739271f, -0.05955036f, 0.02743068f, 
    0.02262836f, 0.14635807f, 0.14374155f, 0.00634399f, -0.81352806f, -0.46678585f, -0.26482272f, -0.36688888f, 
    0.06872393f, -0.08832062f, -0.09875140f, -0.09508500f, 0.10121652f, 0.01803672f, 0.07318816f, 0.09070896f, 
    0.16041809f, 0.01259631f, -0.14050898f, -0.06186527f, 0.02905238f, -0.00946202f, -0.09176369f, 0.19331580f, 
    0.03799447f, 0.12659200f, 0.19730143f, 0.01278397f, 0.19593145f, -0.14113763f, -0.00484981f, -0.03710105f, 
    -0.19519536f, 0.03324368f, 0.00258864f, 0.00440411f, 0.10995539f, 0.26654646f, -0.00644911f, 0.15322952f, 
    -0.20572715f, 0.01807684f, -0.27949995f, -0.02257223f, 0.16619134f, 0.08873747f, -0.04409933f, 0.11553347f, 
    0.19377084f, 0.12561296f, 0.08616844f, 0.10714875f, -0.11618704f, 0.15911460f, 0.27419633f, -0.11404092f, 
    0.11169858f, 0.03038634f, -0.05383556f, 0.04797792f, 0.13303629f, 0.28953093f, -0.30144992f, 0.13795117f, 
    0.42885950f, 0.04774944f, -0.17817983f, 0.30503002f, -0.11615952f, -0.16933507f, -0.07990333f, 0.09735227f, 
    0.00318448f, -0.16532135f, -0.20373189f, -0.18069077f, 0.40702876f, 0.07504785f, -0.08099761f, 0.01389450f, 
    -0.17369950f, -0.07925581f, 0.03994044f, -0.01377340f, 0.09229401f, 0.02713117f, -0.17962880f, -0.09216879f, 
    -0.20743273f, 0.03421845f, -0.09884033f, -0.00588027f, 0.07659181f, 0.09992553f, -0.07684354f, -0.02881172f, 
    -0.06250215f, -0.29370254f, -0.05566242f, -0.12457313f, 0.29452732f, 0.05713095f, -0.13447934f, -0.26822481f, 
    0.13089913f, -0.10329676f, 0.01250447f, 0.11994564f, -0.08567124f, 0.14648701f, 0.23143318f, 0.13204554f, 
    -0.31447175f, 0.16837490f, 0.04500383f, 0.15425435f, 0.10044394f, -0.05050316f, 0.06089113f, 0.06286471f, 
    0.06764582f, 0.16403332f, 0.09906866f, 0.11528362f, -0.33377284f, -0.14307609f, 0.00063400f, -0.00739421f, 
    -0.11052153f, 0.00637509f, 0.01624281f, 0.18701690f, -0.08083691f, 0.05745361f, -0.04717661f, -0.01877701f, 
    0.17566876f, -0.11122549f, -0.06346476f, -0.38923889f, -0.00268735f, 0.17982577f, -0.04583308f, -0.18100947f, 
    -0.05393010f, 0.07153557f, 0.08202531f, -0.04915638f, -0.78262049f, -0.54317582f, -0.16677278f, -0.19289377f, 
    0.08112472f, 0.01923417f, 0.02415365f, -0.02645596f, 0.00373837f, -0.00156017f, 0.05864449f, 0.14516108f, 
    -0.28776091f, -0.00364979f, -0.11578125f, -0.04046731f, -0.06035042f, -0.01283440f, 0.09325422f, -0.26787844f, 
    -0.11512332f, -0.05336735f, -0.03992741f, -0.13787153f, -0.06524465f, -0.25325185f, -0.13277666f, 0.17592415f, 
    0.01104424f, -0.05468763f, 0.01498377f, 0.00251431f, 0.05587560f, -0.15132312f, -0.11249581f, -0.15885256f, 
    -0.33770400f, -0.29856634f, -0.00678634f, 0.06798125f, 0.05525620f, 0.09263356f, -0.08835049f, 0.04004566f, 
    0.12858836f, -0.03929501f, 0.06805808f, 0.05303366f, -0.69688439f, -0.43706250f, 0.13500088f, 0.15315686f, 
    0.09229647f, -0.11665042f, 0.11392321f, 0.01830461f, -0.01265693f, 0.10798772f, 0.04183102f, 0.06377261f, 
    -0.33810675f, 0.21384017f, 0.09162461f, -0.00210676f, 0.15970714f, -0.00299916f, 0.05343803f, -0.15472893f, 
    0.04547028f, 0.09527846f, 0.00968801f, -0.09968669f, 0.50527382f, 0.22989234f, -0.28512508f, -0.02658459f, 
    0.09030204f, 0.00337460f, -0.15116398f, 0.02845434f, 0.12543547f, 0.10654870f, 0.17710765f, 0.04554860f, 
    -0.52052414f, -0.23420553f, -0.02701799f, -0.14227569f, 0.04632332f, 0.01008466f, 0.11317027f, 0.17856278f, 
    -0.05475212f, 0.04779828f, -0.03842622f, -0.13453063f, 0.19465515f, -0.09928236f, -0.29938173f, -0.24469008f, 
    -0.03995269f, 0.15492992f, 0.08357720f, 0.08336298f, 0.08274541f, -0.06084785f, -0.01231038f, 0.02836477f, 
    -0.19124801f, 0.36012995f, 0.09993371f, -0.13114949f, -0.19759868f, -0.06382091f, -0.00364455f, 0.16915250f, 
    0.03932178f, 0.15742595f, -0.13453269f, 0.07762953f, 0.08688091f, 0.22876765f, -0.12015507f, -0.07305216f, 
    -0.18588856f, -0.07122369f, -0.01823037f, -0.24264406f, -0.10958227f, 0.06051313f, -0.19014911f, -0.21621509f, 
    -0.06090416f, 0.02706625f, 0.22798629f, -0.07742734f, 0.08756201f, 0.00364975f, 0.03879534f, -0.09212408f, 
    0.17426781f, -0.15106793f, 0.12314697f, -0.21309116f, -0.17347030f, -0.21977837f, -0.25045744f, 0.28215435f, 
    -0.11661977f, -0.04966781f, 0.03919145f, 0.00118886f, -0.06084910f, -0.12160799f, 0.00489996f, -0.21306211f, 
    -0.65412599f, 0.12397418f, -0.23206636f, -0.24671166f, 0.06148132f, -0.03029581f, -0.02869598f, -0.05207456f, 
    0.03481458f, 0.01919247f, 0.09433400f, 0.22077215f, -0.46998134f, -0.22756812f, -0.11992017f, -0.30368364f, 
    0.08814079f, 0.02577966f, 0.13836333f, -0.02314157f, 0.10303691f, 0.04445506f, -0.03311256f, 0.04323940f, 
    0.21349536f, 0.05806455f, -0.00863138f, 0.00986652f, -0.20562044f, 0.19847715f, -0.09866354f, -0.08990561f, 
    -0.03934264f, -0.13576744f, -0.00493561f, -0.04078322f, 0.06470096f, -0.16736536f, 0.14204130f, -0.33194327f, 
    0.01726452f, -0.08088975f, -0.06035161f, -0.10928960f, -0.13701400f, 0.08995923f, 0.02540543f, 0.03555837f, 
    0.15708274f, -0.34280169f, -0.07769188f, 0.11424123f, -0.12200856f, 0.11462007f, -0.16301653f, -0.05384072f, 
    0.00007667f, -0.02289952f, -0.17911199f, -0.09848515f, 0.15565413f, -0.14499065f, -0.14901336f, 0.08160967f, 
    -0.08516633f, 0.05827359f, 0.15448180f, -0.05772394f, -0.01380510f, 0.00121557f, 0.07962305f, -0.05136340f, 
    0.29901990f, 0.15561868f, -0.02011204f, 0.06955139f, -0.37911305f, 0.06140455f, -0.07128505f, -0.09810971f, 
    -0.01096367f, -0.05624039f, -0.02294112f, -0.08229858f, 0.68367445f, -0.06731018f, -0.22122963f, -0.05285501f, 
    0.08943136f, -0.13298771f, 0.02698087f, -0.09326170f, -0.02902451f, 0.04592106f, -0.03940352f, -0.06236606f, 
    -0.47931767f, 0.31097105f, -0.10963009f, -0.18554349f, 0.05838244f, -0.05706826f, -0.04529951f, 0.12173481f, 
    0.01967143f, -0.08383793f, -0.14676197f, -0.08094225f, -0.32537481f, 0.16392438f, -0.03177497f, 0.07985613f, 
    0.01685439f, -0.12435763f, -0.02186012f, 0.05596092f, -0.07031757f, -0.05911262f, 0.05548150f, -0.21513417f, 
    -0.07987176f, -0.09485602f, 0.10157347f, 0.39151189f, -0.11850733f, 0.08141618f, -0.05827034f, 0.05242863f, 
    -0.15068009f, -0.01961477f, -0.01079027f, 0.06975333f, 0.15442090f, 0.20363352f, -0.04935306f, 0.05193216f, 
    -0.02263094f, -0.00412113f, -0.11917162f, 0.18287587f, 0.05796861f, -0.02511507f, -0.12385567f, -0.06782559f, 
    0.43493521f, -0.12473191f, -0.00063406f, -0.16772781f, 0.13099582f, -0.17317952f, 0.27471510f, 0.01593213f, 
    0.02868763f, 0.15097018f, 0.20686738f, 0.19171773f, -0.26666942f, 0.18645525f, -0.03582884f, 0.21815003f, 
    -0.02703524f, -0.00977461f, 0.02404906f, -0.02868222f, 0.03506241f, 0.06638286f, 0.13270657f, -0.02735891f, 
    -0.32139620f, 0.06741936f, 0.00415984f, 0.25347903f, 0.09829979f, 0.06538170f, 0.08529247f, -0.00678255f, 
    0.04635040f, 0.09330134f, -0.03937601f, 0.00175325f, 0.04077091f, 0.05999681f, -0.17859066f, 0.17192833f, 
    0.01941133f, -0.17412046f, 0.12595317f, 0.12027963f, -0.02928257f, 0.02049852f, -0.00299846f, -0.13207218f, 
    0.38302436f, 0.07145195f, -0.09665024f, -0.46349078f, 0.15222797f, -0.00480670f, -0.03893963f, 0.20109640f, 
    -0.04413945f, 0.08615020f, -0.02331699f, 0.01079287f, -0.18330315f, 0.25550005f, -0.28604776f, 0.00332112f, 
    0.31138408f, 0.04132128f, 0.08721709f, -0.01969914f, -0.16712144f, -0.02772621f, -0.02554453f, 0.07289562f, 
    -0.33933118f, 0.16602814f, -0.11769289f, -0.12154149f, -0.30772117f, -0.05703562f, -0.18250072f, -0.08225500f, 
    -0.17000124f, 0.02986159f, -0.04026912f, -0.01341389f, 0.35270756f, -0.28334752f, -0.36285233f, -0.10366917f, 
    0.03696430f, -0.04395554f, -0.03907958f, 0.07095896f, -0.06818042f, 0.01247792f, -0.09399430f, -0.04762214f, 
    0.17518231f, -0.07726902f, -0.00141645f, 0.30258211f, -0.01969401f, -0.12202505f, -0.06379588f, 0.16430894f, 
    -0.14114507f, 0.15697528f, 0.24625526f, -0.11768544f, 0.10698207f, 0.07052713f, -0.28448579f, 0.11821812f, 
    -0.09547625f, -0.12618777f, 0.01486463f, -0.11071091f, -0.10513802f, 0.06603474f, -0.10915432f, 0.05266745f, 
    0.13292468f, 0.28906798f, -0.18868914f, 0.14147198f, 0.17913696f, -0.04031458f, 0.09062200f, -0.15861647f, 
    -0.05780881f, 0.09034216f, -0.01200502f, 0.05036161f, 0.16288258f, -0.16920365f, 0.03686080f, -0.28555068f, 
    0.02719318f, -0.24092303f, -0.00169680f, 0.20959723f, -0.05386034f, 0.01932129f, 0.03651500f, 0.06469407f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.06434137f, 0.06543420f, -0.09133361f, -0.01105969f, -0.01991927f, 0.01626914f, 0.00544015f, -0.04204617f, 
    -0.03068261f, -0.04301320f, 0.10485702f, 0.02633234f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
