#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.77612191f, 0.35369772f, 0.77820009f, 0.01180453f, -0.46965677f, -0.17707784f, -0.40134868f, -0.25484338f, 
    0.03502585f, 0.26378462f, 0.63421929f, -0.22526807f, 0.81287861f, -0.44555014f, -0.41583312f, -0.19578308f, 
    -0.12560213f, -0.17038852f, -0.27947360f, 0.23745377f, -0.40356922f, -0.68808585f, -0.79759240f, -0.11641158f, 
    0.38651085f, -0.28468302f, -0.45091063f, -0.52952248f, -0.66890508f, -0.48118004f, 0.55583990f, 0.97274774f, 
    -0.12651776f, -0.03731539f, 0.07743774f, -0.43306658f, 0.37149549f, 0.21849170f, -0.34865290f, -0.71910268f, 
    0.08997955f, -0.56127030f, 0.29766759f, 0.54981643f, 0.45993495f, -0.52505535f, -0.27116334f, -0.89910412f, 
    0.06099097f, 0.59924269f, 0.52035296f, 0.51006794f, -0.18548724f, 0.27717474f, -0.53071541f, -0.03244124f, 
    -0.24709186f, 0.55010527f, -0.36262885f, 0.03137048f, -0.57268578f, -0.55842078f, -0.45639595f, -0.17608956f, 
    0.14772059f, -0.10091721f, -0.67844355f, 0.21615921f, 0.62253654f, -0.00191899f, -0.54283178f, 0.54856271f, 
    -0.79302949f, -0.14354575f, 0.22576001f, -0.67718655f, 0.30797166f, -0.35791606f, 0.33043203f, 0.13566111f, 
    0.07744515f, 0.20349640f, 0.58250129f, 0.62707400f, 0.18316832f, -0.22969803f, 0.59412766f, -0.18798535f, 
    0.42825359f, 0.36224127f, 0.74356520f, 0.61576360f, 0.36421356f, 0.01494964f, -0.62209654f, 0.44957483f, 
    0.30096075f, 0.28293788f, -0.07137909f, -0.89146262f, 0.79632801f, -0.20488511f, 0.27532360f, -0.18360998f, 
    -0.22468019f, -0.23439321f, 0.27688882f, -0.35406473f, -0.70752978f, -0.57519114f, -0.50926936f, 0.39908645f, 
    -0.03697507f, 0.65589964f, -0.01719734f, -0.30115932f, -0.08990940f, 0.42723835f, 0.87630272f, -1.03057742f, 
    0.50040168f, 0.57517171f, -0.34354097f, 0.16087951f, -0.09843902f, -0.09862848f, -0.34808919f, -0.81697613f, 
    0.69165897f, -0.05398161f, -0.32238728f, 0.15063822f, 0.43822119f, 0.34822100f, 0.36292568f, -0.36837721f, 
    -0.74389446f, -0.73017395f, -0.73439622f, 0.42653859f, 0.11431231f, -0.09056734f, 0.08102912f, 0.04701672f, 
    0.29532537f, 0.16531360f, -0.02322266f, -0.29153144f, -1.13916314f, -0.67626554f, 0.41904047f, -0.01272942f, 
    0.33423635f, -0.64337862f, -0.51956087f, -0.23726609f, 0.40024692f, -0.47271094f, -0.69365829f, 0.59264749f, 
    0.07924317f, 0.24378307f, 0.45142162f, -0.46547794f, -0.57450181f, -0.06728113f, 0.29516953f, 0.06892350f, 
    -0.51634592f, 0.23128648f, 0.60416478f, -0.74310791f, -0.14388706f, 0.41785792f, -0.69701225f, -0.41771898f, 
    0.48788321f, -0.39864022f, 0.03699317f, 0.10768604f, 0.58082348f, -0.90695363f, 0.57298702f, 0.64546335f, 
    -0.62016976f, 0.33449882f, 0.30891484f, -0.56459737f, -0.13694288f, -0.01455014f, 0.82697254f, -0.14248364f, 
    -0.59515607f, -0.21522881f, -0.62910229f, -0.01665932f, 0.03238301f, -0.06102745f, 0.61606848f, 0.61402255f, 
    0.18434888f, -0.49252534f, 0.81549060f, -0.46380249f, -0.06827386f, 0.14537036f, 0.25454780f, 0.49607962f, 
    -0.54106498f, -0.64337152f, -0.53509742f, -0.58318686f, -0.28828448f, -0.18617821f, 0.42576268f, -0.28930882f, 
    -0.61658210f, 0.77664417f, 0.41942337f, 0.71841139f, 0.15600297f, -0.33765504f, 0.10021932f, -0.25494075f, 
    0.29082406f, 0.65752399f, 0.52855921f, 0.47234756f, 0.65101439f, 0.47435972f, 0.24977095f, 0.34036472f, 
    0.23664346f, -0.14763729f, -0.33525902f, -0.33375978f, -0.13121463f, 0.54108733f, -0.87141097f, -0.12627719f, 
    -0.36733374f, -0.24513599f, 0.48403102f, 0.56930494f, -0.21656755f, 0.59522843f, 0.93346459f, 0.56541651f, 
    -0.17419875f, -0.28491285f, -0.48864025f, 0.11889990f, 0.53424525f, -0.36755976f, 0.31687677f, -0.97129464f, 
    0.43577299f, -0.60205740f, 0.02987228f, -0.26200202f, 0.01237798f, -0.68838543f, 0.68800509f, -0.39134398f, 
    -0.49079353f, 0.61094868f, -0.28061974f, -0.15625043f, -0.26369330f, -0.00147770f, 0.28867519f, -0.23055865f, 
    -0.52476680f, 0.24360651f, -0.50101870f, 0.51282340f, -0.28893730f, -0.15814452f, 0.13429105f, 0.71557760f, 
    -0.31102693f, 0.19581741f, 0.14923434f, 0.42235893f, 0.85832036f, -0.25961286f, -0.60019648f, -0.50158912f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.01292511f, -0.22568911f, 0.26604038f, 0.05566717f, -0.38305137f, -0.09946521f, -0.10047221f, 0.22837381f, 
    0.22135252f, 0.17715053f, 0.43263641f, -0.09298884f, -0.23129748f, -0.42541930f, 0.03344763f, -0.16964892f, 
    -0.17222480f, -0.35917157f, -0.06745786f, 0.06323008f, -0.21071126f, 0.35843214f, -0.12774533f, 0.18981396f, 
    -0.33903375f, -0.10549285f, -0.00481656f, 0.03572230f, 0.40282246f, -0.17364867f, -0.27161348f, -0.17464992f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.00340259f, 0.01802585f, 0.00270502f, 0.03023772f, -0.00143774f, 0.04168912f, 0.04275128f, -0.01152613f, 
    0.05630583f, 0.05131932f, 0.04209511f, -0.01356941f, -0.00574152f, -0.04883400f, -0.02612555f, -0.05653389f, 
    -0.00594165f, 0.00114795f, -0.02123137f, -0.02547232f, -0.05516734f, -0.03585894f, -0.01119870f, 0.01609665f, 
    0.01476616f, 0.00181823f, -0.01092642f, 0.04757928f, -0.01623333f, -0.05234605f, -0.04276679f, -0.01812804f, 
    -0.01519660f, -0.01871948f, 0.02388685f, 0.04301062f, 0.03631732f, 0.01462903f, 0.05725568f, 0.02268079f, 
    -0.06130881f, 0.00580345f, 0.02868603f, -0.00848718f, -0.04480463f, -0.01433414f, -0.05206088f, 0.03471168f, 
    0.02218684f, -0.01666382f, -0.06228848f, 0.01849909f, 0.03569729f, 0.03589692f, -0.04530863f, 0.00081530f, 
    0.00778253f, -0.01245353f, -0.01507870f, -0.00588786f, -0.03259492f, -0.03402634f, -0.04254558f, -0.02709600f, 
    0.03276728f, -0.04152571f, 0.03246614f, 0.00515414f, 0.00105675f, 0.01446753f, 0.04512570f, -0.03019355f, 
    -0.00992594f, -0.01586446f, -0.05991718f, -0.03528989f, -0.01057165f, 0.00584763f, 0.05376606f, 0.03409309f, 
    0.02961593f, 0.03469711f, 0.03740090f, 0.01188947f, -0.01822333f, -0.05732470f, 0.03038083f, 0.05017904f, 
    -0.01813037f, -0.05331874f, -0.04865457f, -0.00356414f, 0.05084138f, 0.01588366f, -0.05553044f, -0.01341842f, 
    0.02702925f, 0.01965364f, -0.05506607f, 0.00622473f, 0.00784921f, -0.05660539f, -0.05641429f, -0.01039603f, 
    0.00494015f, 0.02028465f, 0.02593051f, -0.06137897f, -0.02306815f, -0.01453566f, -0.00871359f, 0.04103715f, 
    0.03302718f, -0.05573097f, 0.04526118f, -0.03094643f, 0.05143548f, -0.04949246f, -0.04047543f, -0.01442287f, 
    0.02267008f, -0.02403810f, 0.02324214f, -0.00094283f, 0.03767132f, -0.00609555f, -0.06618717f, -0.02443673f, 
    0.00964302f, 0.04442761f, -0.03100970f, 0.01899362f, 0.03207811f, 0.00623988f, 0.00575890f, 0.00777136f, 
    0.04519496f, 0.02444224f, -0.03333561f, -0.01447249f, 0.02504157f, 0.02391903f, -0.04462949f, 0.04887360f, 
    -0.04662206f, 0.02457525f, 0.05294466f, -0.06036974f, -0.02082800f, -0.05248583f, -0.02824395f, -0.02632633f, 
    0.05034998f, -0.00763251f, 0.03351119f, 0.00138244f, 0.00763557f, -0.03143473f, -0.02653767f, 0.00658959f, 
    -0.00887604f, 0.02565596f, -0.05821484f, -0.06424682f, 0.00036863f, -0.02182775f, -0.01025262f, 0.02673787f, 
    -0.02805648f, -0.06509647f, 0.02535461f, 0.01247623f, -0.04620550f, 0.01169743f, 0.00781959f, -0.04966760f, 
    -0.03991346f, 0.00569635f, 0.03090690f, -0.04541282f, -0.01544514f, -0.03297738f, 0.01958757f, -0.00127470f, 
    0.03370076f, 0.02929783f, 0.03264794f, -0.05215058f, 0.04468595f, -0.04556276f, 0.00448063f, -0.01070117f, 
    -0.05147852f, 0.01036064f, 0.01596068f, -0.05427129f, -0.05920972f, -0.00341127f, -0.05117180f, -0.03374463f, 
    -0.06258175f, -0.01950330f, -0.02448922f, -0.01219769f, 0.04405952f, -0.01043139f, 0.04168108f, -0.01402172f, 
    -0.06378637f, 0.05294859f, -0.02732665f, -0.01455387f, -0.05217231f, -0.01900302f, 0.02976536f, -0.01738591f, 
    -0.03176611f, -0.02984470f, -0.05214803f, -0.02382696f, -0.05831237f, 0.02226196f, -0.02891249f, -0.02736454f, 
    0.00210583f, 0.00883318f, 0.01599182f, 0.02865358f, -0.02894721f, -0.05674448f, 0.05480358f, 0.00598991f, 
    -0.04681037f, -0.06505165f, 0.01797990f, -0.05314897f, -0.00341737f, 0.01222710f, -0.02017456f, -0.00690106f, 
    -0.05559219f, 0.02334842f, 0.01199680f, 0.04686730f, -0.04170285f, 0.02617794f, -0.04936504f, 0.01330089f, 
    -0.01459969f, -0.01255842f, 0.03851242f, -0.02698999f, -0.00676531f, -0.02021071f, -0.01812708f, 0.00544942f, 
    0.00907108f, -0.05192177f, 0.00808143f, 0.01157904f, -0.01622557f, -0.06197471f, -0.04176560f, -0.01675854f, 
    -0.05571852f, -0.03888028f, 0.04956143f, 0.04682394f, -0.06089351f, 0.02084371f, -0.00287274f, -0.03358178f, 
    0.02507757f, -0.00439418f, -0.04079673f, -0.01447887f, -0.00266084f, -0.04714560f, -0.00240243f, 0.04564859f, 
    0.05111133f, -0.00413791f, 0.04348470f, -0.03654754f, -0.03989018f, -0.05764007f, -0.06203697f, -0.04927082f, 
    -0.04623899f, -0.04159114f, 0.04877804f, 0.02454453f, 0.02763633f, 0.01752510f, -0.00533359f, 0.04562422f, 
    -0.00762872f, 0.03147753f, -0.03956520f, -0.02305247f, -0.05577888f, 0.03831238f, 0.03952773f, 0.02145105f, 
    0.02305703f, -0.03638843f, -0.04623566f, 0.03625903f, 0.03314075f, -0.01274749f, -0.04742170f, 0.04042463f, 
    -0.06159483f, 0.05234535f, 0.01717841f, 0.03280591f, -0.05927458f, -0.01146432f, -0.02164017f, -0.03562133f, 
    -0.03255617f, -0.05432219f, -0.04399403f, 0.00955896f, -0.01729649f, -0.01648385f, -0.05374911f, 0.03713341f, 
    -0.01534126f, -0.06700914f, 0.03853362f, -0.04899197f, -0.03787277f, 0.02028636f, -0.06707896f, 0.00589472f, 
    -0.03427539f, -0.00866760f, -0.03337403f, -0.04375708f, 0.03178383f, -0.03028702f, -0.02355572f, 0.02886575f, 
    0.01416389f, -0.02844456f, -0.02600142f, -0.03376791f, 0.01588755f, -0.02218236f, -0.06982400f, -0.01347843f, 
    -0.02351309f, -0.00473362f, -0.02210964f, 0.05321061f, 0.00502220f, 0.03293337f, -0.00993174f, -0.01165699f, 
    0.02293667f, -0.05415651f, 0.01641862f, 0.01441443f, -0.00058711f, 0.04512721f, 0.03198094f, -0.00611741f, 
    0.04247843f, -0.05404716f, 0.03093895f, -0.02188549f, -0.04003464f, -0.07137879f, 0.04771829f, -0.00634345f, 
    0.04776308f, -0.00054472f, -0.05108895f, -0.06856547f, -0.01888387f, -0.03955970f, -0.04121364f, 0.03302690f, 
    -0.01760053f, -0.05515897f, 0.02102435f, -0.01689925f, -0.00865183f, -0.04546671f, -0.04850280f, -0.02154915f, 
    -0.04783420f, -0.04602179f, 0.03028373f, 0.01767138f, 0.00286848f, 0.02701088f, 0.02888499f, 0.00229568f, 
    0.01410136f, 0.02364347f, -0.01019647f, 0.02810092f, -0.01570206f, -0.05788868f, -0.02784380f, -0.04856312f, 
    -0.02064312f, 0.03974434f, -0.05624387f, -0.02260471f, 0.00036132f, 0.00758495f, -0.03551708f, 0.00540236f, 
    0.04093616f, -0.05278655f, -0.03493003f, -0.00269533f, -0.05068023f, 0.04257020f, -0.03155360f, -0.03338061f, 
    0.01540834f, -0.01728866f, -0.00242099f, -0.03471634f, -0.00276788f, -0.06928509f, -0.01672531f, -0.03389867f, 
    -0.03016394f, -0.08605231f, -0.00940588f, 0.05187609f, 0.05006789f, 0.01580109f, -0.02659979f, 0.00106693f, 
    -0.00478043f, -0.05543396f, -0.04263379f, -0.05564170f, -0.03221865f, -0.00893624f, 0.01469729f, -0.08174049f, 
    -0.04393520f, 0.05484566f, -0.01498115f, 0.00689590f, 0.06109293f, 0.06305185f, 0.04593904f, 0.01095685f, 
    0.02152389f, 0.02325088f, 0.04023559f, 0.01639919f, 0.03511631f, -0.05143350f, -0.00643246f, -0.01403490f, 
    0.03974873f, 0.03812839f, 0.00220187f, -0.03947605f, 0.03435963f, 0.00098009f, -0.03985742f, -0.00754669f, 
    -0.04605763f, -0.04647370f, -0.02846455f, 0.05160535f, -0.00421861f, 0.00857080f, -0.02689792f, -0.01038521f, 
    0.02547555f, -0.05636578f, -0.04669608f, -0.05099852f, -0.01709357f, 0.00284540f, -0.04083802f, 0.01205076f, 
    -0.01201168f, 0.02805413f, 0.03132689f, 0.02670375f, -0.00440912f, -0.03143319f, 0.02374353f, 0.03567164f, 
    -0.03748055f, -0.04886712f, -0.03063110f, -0.00727698f, 0.02017238f, 0.02730612f, -0.02673265f, 0.00715685f, 
    -0.03074826f, -0.06111380f, -0.05271072f, -0.00770909f, -0.04840866f, 0.02804744f, -0.03767865f, -0.04941152f, 
    -0.00116345f, 0.03009511f, 0.01448870f, -0.03344914f, 0.00596726f, -0.06074772f, 0.01990641f, -0.02877157f, 
    0.03482653f, 0.04304727f, -0.06845070f, -0.01390742f, -0.05846542f, 0.04406372f, -0.04906917f, -0.02890210f, 
    0.04333350f, -0.01638540f, -0.02067025f, -0.05587896f, -0.00154150f, 0.05395900f, -0.06069308f, -0.00680539f, 
    -0.07098192f, -0.06639740f, -0.01215860f, -0.00146061f, -0.02903552f, -0.00625246f, -0.04815728f, -0.03396094f, 
    -0.03556415f, 0.01098455f, -0.01667605f, 0.02358221f, -0.02552543f, -0.00082948f, -0.03580000f, -0.01574882f, 
    0.02830729f, 0.01309556f, 0.01475257f, 0.02097178f, -0.01988224f, -0.03058695f, -0.00441522f, 0.01375029f, 
    -0.02779480f, 0.04309383f, -0.01703087f, -0.00719205f, -0.01732460f, -0.03857954f, -0.00893159f, 0.02183123f, 
    -0.01843331f, -0.00483302f, -0.03017519f, -0.04169260f, -0.04522463f, 0.02462090f, -0.01057211f, -0.03281346f, 
    -0.05685586f, -0.01176556f, -0.05236124f, -0.02261952f, 0.00049455f, -0.01956085f, 0.01631066f, 0.01754778f, 
    -0.05745646f, -0.03740758f, 0.00134551f, -0.02343519f, 0.00040214f, -0.04547497f, -0.01615087f, 0.03389369f, 
    0.00664262f, -0.05484567f, -0.05464989f, 0.03053558f, -0.05624421f, 0.05283100f, 0.02941114f, 0.04836082f, 
    0.04029353f, 0.03745992f, -0.06406952f, 0.05200602f, 0.01202740f, -0.00860746f, 0.00708452f, -0.04386594f, 
    0.01330853f, -0.05656759f, -0.03042779f, -0.02224964f, -0.03389184f, -0.00652224f, -0.04891127f, 0.01440421f, 
    0.03705613f, -0.06401849f, -0.04118084f, 0.04297654f, 0.03228479f, -0.01977818f, -0.06276171f, -0.01994343f, 
    -0.02285164f, -0.04478532f, -0.03557483f, -0.04920211f, 0.03831749f, -0.04257954f, 0.04189383f, 0.02847727f, 
    -0.02629947f, -0.01429241f, -0.05781220f, -0.02605832f, -0.01335495f, -0.05864371f, -0.02384096f, 0.03265849f, 
    0.01157507f, -0.02266710f, 0.00832621f, -0.02558739f, -0.04545239f, 0.00291013f, 0.00295110f, 0.02393267f, 
    0.01576689f, 0.02903520f, -0.00070306f, -0.01456926f, -0.01361455f, -0.04510768f, -0.01211984f, -0.05364072f, 
    -0.01357983f, -0.02410915f, -0.00520425f, -0.02544865f, -0.01588500f, -0.02678943f, -0.04731007f, 0.02348010f, 
    -0.03027302f, 0.02558724f, -0.05792866f, -0.04043464f, -0.03092061f, -0.03890087f, -0.02159334f, -0.01498467f, 
    -0.01993041f, -0.06067497f, 0.01427955f, -0.00330535f, -0.02145822f, -0.05235501f, -0.01974500f, 0.04885309f, 
    0.03496173f, -0.01740154f, -0.01337297f, -0.03584414f, 0.01445949f, 0.02828295f, -0.01925119f, -0.02808520f, 
    0.01959668f, 0.05967663f, -0.01050233f, 0.03098224f, 0.02930779f, 0.00786455f, 0.01793152f, -0.05144026f, 
    -0.01294780f, 0.02897818f, 0.04285367f, -0.04485271f, -0.03174260f, 0.01405648f, -0.05507213f, -0.01429739f, 
    -0.03289431f, 0.03119636f, 0.00469673f, -0.05282058f, -0.00034509f, 0.01122603f, -0.03733073f, -0.03092686f, 
    -0.04015885f, -0.01742018f, -0.03685687f, -0.04170002f, -0.03040356f, 0.06080261f, 0.01742993f, -0.04549873f, 
    -0.04299278f, 0.00374431f, 0.01971467f, -0.00697470f, -0.04881701f, -0.04833973f, -0.05341682f, 0.01537260f, 
    -0.00550278f, 0.04424087f, -0.03036927f, -0.00131442f, 0.03228270f, 0.02682106f, -0.03902381f, 0.04574102f, 
    0.01185310f, 0.05079494f, 0.01456910f, -0.06923337f, -0.00917284f, 0.04399431f, -0.00742854f, 0.01828331f, 
    0.00193612f, 0.00871056f, 0.03015547f, -0.00670170f, -0.00790519f, 0.03811771f, 0.05011586f, -0.01341425f, 
    -0.02946467f, 0.03242334f, 0.02951273f, -0.03363983f, 0.02957306f, 0.04541233f, 0.04483284f, 0.00430571f, 
    -0.05157021f, -0.06135672f, 0.01295174f, -0.04509119f, 0.04082414f, -0.03389884f, -0.02415489f, 0.05918108f, 
    -0.01549131f, 0.01765938f, -0.04436704f, 0.03367152f, 0.02727343f, 0.02175123f, -0.04107725f, -0.00160672f, 
    -0.01248397f, 0.01990485f, 0.04932104f, -0.01312647f, 0.00073418f, -0.03841068f, -0.00391418f, 0.00323221f, 
    0.05236936f, -0.03894967f, 0.01110895f, -0.01473872f, 0.05529032f, 0.02285776f, -0.06406417f, -0.03666259f, 
    -0.05313597f, 0.01542765f, -0.01940719f, -0.05201343f, 0.04445701f, -0.04436477f, 0.05369920f, -0.01637362f, 
    0.02728363f, 0.01006862f, 0.04769598f, -0.05702322f, -0.03635534f, -0.06268398f, 0.05078150f, -0.03614812f, 
    -0.01654232f, -0.05217928f, -0.03169322f, 0.04480681f, 0.00885991f, 0.05199791f, 0.05392556f, -0.03311263f, 
    0.01519813f, -0.04995201f, -0.01917785f, -0.05158540f, 0.04260199f, -0.01012029f, -0.04804818f, 0.04646036f, 
    -0.04205089f, 0.01475698f, -0.02804535f, -0.00769074f, 0.02711475f, -0.05434458f, 0.00939693f, 0.05597549f, 
    0.04069324f, -0.03682346f, 0.00363858f, -0.02779024f, 0.01432291f, -0.03701174f, -0.04052557f, -0.00499373f, 
    0.02956292f, -0.02441794f, 0.04745732f, 0.02934907f, 0.02571015f, -0.04555006f, -0.01497182f, -0.05305114f, 
    0.04966006f, -0.03745362f, -0.02603306f, -0.06555936f, 0.04052778f, -0.00671158f, -0.02298764f, 0.00542101f, 
    0.02977429f, 0.03092439f, 0.02679702f, 0.01683937f, -0.01441514f, -0.00150855f, -0.01105638f, 0.03059522f, 
    0.03357949f, 0.29068321f, 0.23390268f, -0.01962226f, 0.17692763f, -0.08638991f, 0.04892997f, -0.11143455f, 
    0.01098041f, -0.10023639f, -0.01470068f, 0.07323509f, 0.15802917f, 0.07388163f, -0.03567016f, 0.06000797f, 
    -0.01391866f, -0.00878120f, 0.03389960f, 0.08245794f, 0.15940127f, -0.06013784f, 0.06729729f, 0.04973643f, 
    0.21773583f, 0.18636303f, -0.04473892f, -0.02894954f, -0.32012746f, -0.57358873f, 0.04979974f, 0.08181538f, 
    0.10088602f, 0.02483360f, -0.00686775f, -0.14577097f, 0.09349862f, -0.17373975f, 0.00785931f, 0.12195868f, 
    0.06203724f, 0.01135222f, -0.11059052f, -0.22841431f, 0.04467348f, -0.29005206f, -0.18673702f, 0.11899570f, 
    0.04462699f, -0.05541690f, -0.04907544f, -0.00161817f, 0.12223297f, -0.18877476f, -0.08865036f, -0.00899097f, 
    0.03453040f, -0.11359110f, 0.06228007f, 0.14527895f, 0.15226828f, 0.04068805f, -0.01703009f, -0.01074308f, 
    0.17401916f, 0.24142005f, 0.09905062f, -0.00149991f, 0.20323005f, 0.02574463f, -0.00653624f, -0.14199850f, 
    0.23892403f, -0.08890310f, 0.04690223f, -0.13802670f, 0.23500155f, 0.02463748f, 0.11098026f, -0.01153893f, 
    -0.13481107f, 0.26154885f, 0.15922180f, 0.11841013f, 0.06309054f, 0.10196513f, 0.12616828f, 0.18957037f, 
    0.01941739f, 0.00998490f, 0.26766425f, 0.30542263f, 0.19470109f, -0.01252819f, 0.06694653f, 0.18026371f, 
    0.22433580f, 0.14478335f, -0.00852422f, -0.22449706f, -0.30799288f, 0.05758502f, -0.04068295f, -0.03906859f, 
    -0.15334532f, -0.11734620f, -0.08835500f, -0.09271881f, 0.09950901f, -0.02131103f, -0.31537405f, 0.02959362f, 
    0.01774923f, 0.03444173f, 0.01027544f, -0.13486813f, 0.05164840f, -0.31855497f, 0.16784933f, 0.62088543f, 
    -0.00525641f, -0.03285195f, -0.16278571f, 0.04855867f, -0.11890884f, -0.03205436f, 0.05925985f, -0.08952659f, 
    -0.04022878f, -0.09715183f, -0.13982958f, 0.04248611f, 0.04898038f, -0.11329807f, -0.02538809f, -0.20656398f, 
    0.03791455f, -0.57445735f, -0.16778243f, -0.04288825f, -0.01044908f, -0.04466923f, -0.03158808f, -0.13776602f, 
    0.02494853f, 0.14754254f, -0.24296345f, 0.07454860f, -0.05131269f, -0.08656534f, -0.09349410f, 0.07054549f, 
    0.08829429f, -0.09281483f, 0.14601047f, -0.22987488f, 0.00168486f, 0.06732524f, -0.07278709f, 0.03974431f, 
    0.04476294f, 0.33686656f, -0.58798075f, -0.02845441f, 0.00033653f, -0.06256153f, -0.02849204f, -0.04373400f, 
    -0.06011536f, -0.06616637f, 0.03796275f, -0.24979244f, -0.28596786f, -0.39805150f, -0.12000076f, -0.05523913f, 
    -0.00557766f, -0.03093100f, 0.05348821f, 0.07869629f, 0.40645227f, 0.01259049f, -0.30646813f, -0.02541579f, 
    0.06415018f, 0.24789619f, 0.24370651f, -0.15402500f, -0.05112910f, 0.27644596f, 0.05874770f, -0.04419361f, 
    -0.00523353f, -0.05092662f, 0.05535174f, -0.07917710f, 0.06106735f, -0.02816675f, 0.06014764f, 0.22898409f, 
    0.17947467f, 0.03150417f, 0.29271507f, -0.00839496f, -0.15358981f, -0.06946229f, 0.10795628f, 0.09506067f, 
    -0.05910997f, -0.23650971f, 0.08564622f, -0.13058825f, -0.02680364f, 0.04403195f, 0.01440589f, -0.07266902f, 
    -0.07471184f, -0.35007197f, -0.09529878f, 0.00905206f, -0.11018323f, -0.08170131f, 0.11367247f, -0.06576040f, 
    -0.06812332f, 0.04096460f, 0.01109111f, 0.13763876f, -0.07518505f, 0.16614713f, 0.02755264f, -0.16147262f, 
    0.15453617f, -0.16559947f, 0.07747009f, -0.04185026f, -0.07072690f, 0.02201166f, 0.14333473f, -0.15573457f, 
    0.01253350f, 0.03258736f, -0.00920059f, -0.00758905f, -0.28621334f, -0.21019380f, -0.00326841f, 0.04813579f, 
    0.10697154f, -0.00453979f, -0.00342274f, 0.07950144f, -0.13978165f, 0.03445544f, -0.04106911f, 0.12078213f, 
    0.01741500f, 0.11738459f, -0.12153986f, 0.00887720f, 0.08167685f, 0.10993577f, -0.41527745f, 0.21012837f, 
    -0.22984479f, -0.05800069f, -0.07543433f, 0.05531558f, 0.06942600f, 0.11270145f, -0.41168642f, 0.02878247f, 
    0.00026953f, -0.05097890f, 0.03944362f, -0.08398268f, -0.16395047f, -0.19214006f, 0.09565065f, 0.10651466f, 
    0.00794405f, -0.21217035f, -0.07429457f, 0.19251786f, -0.00644445f, 0.03191578f, 0.10680453f, -0.04715808f, 
    -0.04477000f, 0.02435403f, -0.05857536f, -0.02204490f, -0.03474371f, -0.05718169f, -0.03253623f, -0.04097291f, 
    -0.04560403f, -0.04110860f, -0.04515438f, -0.03616722f, -0.05317602f, -0.02139495f, -0.05805546f, 0.03897330f, 
    0.01885642f, -0.03436812f, 0.03709049f, 0.03514905f, 0.02217902f, -0.04299764f, 0.05596204f, -0.05782137f, 
    -0.01078494f, 0.04637598f, 0.02190599f, -0.02533231f, 0.04881053f, -0.00604939f, 0.04565246f, -0.05291635f, 
    -0.01886768f, -0.01009426f, -0.03744050f, -0.02141587f, -0.04510808f, 0.03886485f, 0.00214264f, -0.02103188f, 
    -0.02689167f, -0.06125728f, 0.00555272f, -0.04088139f, 0.00645912f, -0.04930843f, 0.02419857f, -0.05504912f, 
    0.02551208f, -0.00835435f, -0.01526224f, 0.03993661f, -0.05452976f, -0.05270328f, 0.05099965f, -0.00873159f, 
    0.01333091f, 0.04619179f, 0.05076478f, -0.00023058f, -0.05422414f, -0.00213631f, -0.00045898f, -0.05065935f, 
    -0.05977280f, -0.03710153f, -0.01113080f, -0.01590275f, 0.02879363f, 0.04319132f, -0.05576741f, -0.06278726f, 
    0.02524532f, -0.06451720f, -0.02862010f, 0.03739298f, -0.00261792f, -0.03746023f, -0.05283062f, 0.02343952f, 
    -0.02726652f, 0.02827261f, 0.00350406f, -0.03455325f, -0.05822532f, -0.02896229f, -0.00901651f, 0.01925104f, 
    -0.00538945f, -0.02024475f, 0.00915956f, -0.00538301f, -0.05300267f, -0.01305059f, 0.03704784f, 0.03598100f, 
    0.00805168f, -0.04410706f, -0.00828643f, -0.05046130f, 0.01225416f, -0.01229127f, 0.04038383f, -0.06508498f, 
    0.03320304f, 0.01203764f, -0.03009436f, -0.01283777f, -0.02866879f, 0.04843469f, -0.00246359f, -0.04540182f, 
    -0.03751766f, 0.00572359f, 0.01263696f, 0.00825176f, 0.04299664f, -0.02912261f, 0.04778168f, 0.03003243f, 
    -0.06270792f, 0.04507033f, 0.01101102f, 0.04959445f, 0.01061940f, 0.01665518f, -0.05132912f, 0.01968424f, 
    0.04891023f, -0.01921638f, 0.04961677f, 0.04586416f, 0.00563898f, -0.01152171f, -0.05737389f, -0.03279346f, 
    -0.05698343f, -0.01374966f, 0.04652476f, -0.00814759f, -0.01615863f, -0.02406283f, -0.05554277f, 0.05148872f, 
    0.01661248f, -0.02783861f, -0.00930907f, -0.00785889f, -0.01439056f, 0.02654745f, 0.00055109f, -0.05097632f, 
    0.03462348f, 0.05793813f, -0.00442200f, -0.03220649f, 0.02164554f, -0.03028766f, -0.01404394f, 0.05574194f, 
    -0.01454319f, 0.01168914f, -0.00757799f, 0.02182054f, -0.00296233f, 0.03136602f, 0.00611815f, 0.02101196f, 
    -0.04769014f, -0.03476987f, 0.01346653f, 0.02476066f, 0.02219016f, -0.01150937f, 0.06031806f, -0.04291462f, 
    -0.00489048f, -0.03036113f, 0.04655435f, 0.01678027f, -0.02762140f, 0.00658488f, -0.04629800f, -0.04643080f, 
    0.04112177f, -0.01014287f, -0.05521691f, 0.03138395f, -0.05476309f, 0.03825619f, 0.00915788f, 0.05271632f, 
    0.02009498f, 0.01369259f, -0.06579399f, 0.02505327f, 0.03247758f, 0.03218872f, 0.00971721f, -0.01849300f, 
    -0.06591317f, -0.02035502f, 0.00555245f, -0.01144910f, -0.01739134f, -0.03965926f, 0.04163500f, 0.01684669f, 
    -0.00929932f, -0.02025841f, -0.04511361f, -0.06312919f, -0.00226215f, -0.04301419f, 0.03150759f, 0.04070441f, 
    -0.02320486f, 0.01275699f, -0.01983340f, -0.03625125f, -0.04566811f, -0.05758207f, 0.03037341f, -0.01074933f, 
    -0.01636062f, -0.00326709f, -0.06097503f, -0.01765422f, 0.03591258f, -0.02157893f, -0.02826676f, 0.00325806f, 
    0.05247341f, 0.02355882f, -0.02213645f, -0.00044729f, 0.03504150f, -0.01943612f, 0.03182457f, -0.04077735f, 
    -0.04060032f, 0.01199382f, -0.00125707f, -0.04836318f, 0.01579801f, -0.02660305f, -0.03385364f, -0.01280059f, 
    0.04951081f, 0.03039954f, -0.06410272f, -0.02344922f, -0.01973209f, -0.04853802f, -0.03418409f, -0.00909406f, 
    -0.00489477f, -0.06440444f, -0.06334592f, 0.01211037f, 0.03895470f, -0.03577897f, 0.01365508f, 0.04478327f, 
    0.04863927f, -0.02511027f, -0.05945548f, 0.01854579f, -0.03064089f, 0.04254462f, -0.01487127f, 0.04146728f, 
    -0.00946716f, -0.00669227f, -0.00700640f, -0.00225222f, 0.02249985f, -0.05838737f, 0.02332190f, 0.05450560f, 
    0.03535193f, -0.00534372f, -0.04579971f, -0.02419060f, -0.04846638f, -0.05996810f, -0.03883759f, -0.04488652f, 
    -0.06108438f, -0.02325389f, 0.01532997f, 0.01705122f, -0.03957728f, -0.02214898f, -0.02851788f, -0.02098526f, 
    -0.04382228f, -0.05348169f, 0.01783684f, 0.02418984f, 0.00161593f, -0.02595914f, -0.04850525f, -0.06045441f, 
    -0.03398660f, 0.04116306f, 0.00240596f, 0.00712325f, -0.04632429f, -0.00574540f, -0.03687375f, -0.03393186f, 
    -0.01291876f, 0.04182827f, -0.02260588f, -0.05783269f, -0.04858702f, -0.02434461f, -0.06460328f, 0.00620712f, 
    0.02243664f, -0.01392961f, 0.03636165f, -0.02087865f, 0.03522293f, 0.02827222f, 0.01277146f, 0.00439137f, 
    -0.06045765f, -0.02277354f, 0.04776699f, -0.05141737f, -0.02996284f, -0.00590259f, -0.01255297f, 0.02060892f, 
    -0.01520900f, -0.01597770f, 0.04230334f, 0.04138687f, 0.03896319f, 0.00421162f, -0.03668426f, -0.02867275f, 
    -0.04601653f, 0.04488507f, 0.03353466f, 0.01442785f, 0.02934301f, -0.02708203f, 0.02719580f, -0.02731602f, 
    0.04439594f, 0.04802215f, -0.00685547f, -0.02928044f, 0.04190298f, 0.02738918f, -0.00180200f, 0.03051648f, 
    -0.01489816f, 0.03248061f, -0.04072076f, 0.02522264f, -0.01207559f, -0.04950312f, -0.06280337f, -0.02425970f, 
    -0.05936364f, -0.01884641f, 0.03323651f, 0.00033447f, -0.04028263f, 0.04486980f, -0.03256111f, 0.01849159f, 
    -0.02421777f, 0.02056487f, -0.02994968f, -0.03220650f, -0.02811508f, 0.00775053f, 0.03246398f, -0.03800571f, 
    -0.00154695f, 0.02054385f, -0.01915222f, -0.01150787f, -0.02487491f, -0.06075304f, -0.04279732f, 0.00715661f, 
    -0.02128020f, -0.03506426f, -0.00902739f, 0.01207180f, -0.03904600f, -0.04538134f, -0.06099127f, 0.00945253f, 
    0.01167144f, -0.03048597f, 0.03733867f, -0.06546977f, -0.06421295f, -0.00305845f, 0.04708232f, -0.02793650f, 
    0.03591052f, -0.02808991f, -0.05739975f, -0.04083965f, 0.02838419f, 0.01095799f, 0.04858223f, -0.01767040f, 
    -0.01458677f, -0.01583228f, -0.05973011f, 0.02935294f, 0.04880732f, 0.00708759f, -0.00279226f, 0.03071490f, 
    0.03376835f, -0.01856622f, 0.03321799f, 0.02073074f, 0.04452863f, 0.04381195f, -0.06182943f, -0.00306767f, 
    -0.03226497f, 0.05138005f, -0.00122909f, -0.03786074f, 0.03172207f, -0.04729734f, 0.02554058f, 0.01974828f, 
    0.04172702f, -0.02952115f, -0.00102735f, -0.03328637f, -0.00001954f, 0.01850208f, -0.05319607f, -0.04804157f, 
    -0.03106843f, 0.04799216f, 0.03343418f, -0.05300269f, 0.01052812f, 0.00885430f, 0.02616465f, 0.04366204f, 
    0.03051031f, -0.06063851f, 0.04535889f, -0.00765677f, 0.00828720f, 0.03902977f, -0.00152502f, -0.04821150f, 
    0.05569349f, 0.04143497f, 0.03749648f, 0.01451209f, -0.06197337f, -0.06763472f, 0.04127718f, -0.01489117f, 
    -0.04250094f, -0.04253371f, -0.05983980f, -0.04342018f, 0.03164952f, -0.05393755f, -0.02861775f, -0.03711474f, 
    0.02078827f, 0.00305345f, 0.04085264f, -0.05809439f, -0.04847727f, 0.02295567f, 0.04713291f, 0.02307780f, 
    0.04373392f, -0.01585981f, 0.01639401f, -0.05542505f, 0.04397047f, -0.00988400f, -0.01704463f, 0.04169011f, 
    0.01043862f, 0.03770933f, -0.04422738f, 0.03326330f, 0.04222566f, -0.02020114f, -0.05453571f, -0.00462907f, 
    -0.06556885f, -0.02666178f, -0.01646500f, -0.01859803f, 0.00260682f, -0.01182039f, 0.00126291f, -0.00770122f, 
    -0.06575916f, -0.00197445f, -0.02973213f, -0.02328749f, 0.02897639f, -0.01032034f, -0.05670945f, -0.02665462f, 
    0.04030294f, 0.04734392f, 0.04351499f, -0.01192853f, 0.00409388f, -0.00485211f, -0.04993251f, 0.03317950f, 
    0.01461047f, -0.02392900f, -0.05429657f, -0.01325996f, -0.05878524f, 0.02702006f, -0.01614468f, -0.02510291f, 
    -0.03603015f, -0.05106297f, -0.06334043f, -0.05120175f, -0.02451255f, 0.00479819f, -0.00719324f, -0.01813732f, 
    -0.03621829f, -0.00101691f, 0.00828660f, 0.01190968f, -0.00024626f, -0.01269372f, -0.05940963f, 0.05322646f, 
    -0.00327701f, -0.03217582f, -0.04394411f, 0.02860077f, 0.03650290f, 0.02083523f, -0.06273609f, -0.02534709f, 
    0.04582254f, -0.05112691f, -0.00705624f, -0.06052846f, -0.02245964f, 0.04503045f, 0.01805243f, 0.02333641f, 
    0.03138425f, -0.03378755f, 0.02260214f, 0.01224988f, 0.02219980f, -0.03916731f, 0.01184071f, -0.04137099f, 
    0.02981081f, 0.00974716f, 0.05270552f, -0.02114258f, -0.03100536f, -0.03776461f, 0.02311903f, -0.05683441f, 
    -0.04727979f, -0.04030016f, -0.01609587f, 0.05503433f, 0.02512300f, -0.00645201f, 0.01477961f, -0.02990566f, 
    0.00461219f, -0.06370194f, 0.00511263f, -0.03694994f, -0.05488476f, -0.05287387f, 0.01275073f, -0.05857472f, 
    -0.05729131f, -0.00239991f, 0.02191440f, 0.00957105f, 0.01831680f, -0.01409475f, 0.02421455f, 0.01529155f, 
    -0.04359690f, -0.00103601f, 0.01701952f, -0.01594752f, -0.02287785f, -0.05267346f, -0.00489377f, 0.02711390f, 
    -0.01636444f, 0.04035641f, 0.00434823f, 0.00934822f, -0.01705321f, -0.02942005f, -0.03525886f, 0.01747824f, 
    -0.03441366f, -0.05718471f, -0.01647539f, -0.06030807f, -0.03486034f, -0.05178226f, 0.05138734f, -0.02758119f, 
    -0.02603491f, -0.04545637f, 0.02294290f, -0.01420995f, -0.01917914f, 0.04923783f, 0.02943265f, -0.00374057f, 
    -0.03188261f, -0.05496698f, -0.05684570f, -0.04828438f, 0.02770452f, -0.05137635f, -0.00488147f, -0.05565345f, 
    0.03706234f, -0.06516002f, 0.04883907f, -0.00142878f, 0.03315313f, 0.05014547f, 0.03326117f, -0.00299205f, 
    -0.03612039f, 0.00779251f, -0.00208099f, -0.04649394f, -0.01986685f, -0.01874353f, 0.06004870f, -0.06095489f, 
    0.03384555f, 0.05644266f, 0.00921369f, -0.04378641f, -0.00843775f, -0.01732826f, -0.00652456f, -0.04624365f, 
    -0.06653123f, 0.00701592f, -0.00863458f, -0.03479090f, -0.03505968f, 0.01432803f, -0.03521626f, -0.06414992f, 
    0.04854520f, -0.03211651f, -0.03539398f, -0.02561198f, -0.00632963f, 0.00039062f, 0.02628742f, 0.00141094f, 
    -0.00427880f, 0.00588094f, -0.03659475f, 0.04495088f, -0.00490870f, 0.02366215f, 0.04057887f, 0.03726823f, 
    0.01189763f, 0.01670841f, 0.05113805f, -0.02580355f, -0.05222609f, -0.00020733f, -0.04929447f, -0.02185414f, 
    0.04459375f, -0.04514304f, -0.06545311f, 0.00345062f, -0.03640791f, -0.01561103f, 0.01056968f, 0.03882368f, 
    0.04446749f, -0.04965542f, 0.01374448f, 0.02629473f, 0.00617182f, -0.01988877f, -0.03789932f, -0.00812339f, 
    0.04326188f, -0.01208253f, -0.04972933f, 0.01822719f, 0.02659443f, 0.00933477f, -0.06033492f, -0.00272578f, 
    0.00852004f, -0.00816307f, 0.02081868f, 0.00014052f, 0.00263040f, -0.02502088f, 0.05622846f, -0.02657217f, 
    0.02300817f, 0.03379573f, 0.04514592f, -0.05619251f, 0.03859809f, 0.04743331f, 0.04659129f, 0.05615381f, 
    0.03435277f, -0.04362177f, -0.01887109f, -0.01559969f, -0.00889162f, -0.04290895f, 0.03208454f, -0.01054913f, 
    -0.00961052f, -0.00460548f, 0.01209744f, 0.04953028f, 0.02523917f, 0.00776623f, -0.05547874f, 0.02496606f, 
    0.02700518f, 0.00183187f, 0.02106710f, 0.01569153f, -0.05112405f, 0.04818603f, 0.05239156f, 0.00312865f, 
    -0.02380586f, -0.02320319f, 0.01068392f, -0.03908582f, 0.05598217f, 0.02864005f, -0.04320164f, 0.04770217f, 
    0.04010561f, -0.03754263f, -0.03200326f, -0.02296108f, -0.00142860f, 0.04984284f, -0.00464039f, -0.02442051f, 
    -0.01862658f, 0.00919867f, -0.06698050f, 0.02071194f, -0.06404179f, -0.05508036f, 0.03726384f, -0.01699550f, 
    0.04566264f, 0.05767056f, 0.01675838f, 0.03486614f, 0.00545727f, -0.01107901f, -0.01632800f, -0.00630467f, 
    -0.05619844f, -0.05587199f, -0.04817537f, 0.00289769f, 0.05422289f, 0.02177413f, 0.04650347f, -0.01151242f, 
    -0.05786376f, 0.02993100f, -0.04030748f, -0.06146756f, 0.00289127f, 0.00539556f, -0.00813144f, -0.01210952f, 
    -0.04480673f, 0.00651392f, 0.03637594f, -0.04119520f, 0.01952386f, -0.03442794f, 0.00715354f, 0.01139592f, 
    0.02311596f, -0.06017679f, -0.00478560f, -0.03117231f, -0.05466887f, 0.03527082f, -0.00998617f, 0.00206659f, 
    -0.00927925f, -0.02297344f, -0.01925460f, -0.00449287f, -0.01761944f, -0.01944500f, -0.05009703f, 0.04942096f, 
    0.01372229f, 0.00404078f, 0.03272769f, 0.00926601f, -0.00722598f, 0.00461022f, 0.01118837f, -0.04975872f, 
    0.01105003f, -0.06402390f, -0.03594472f, -0.00631708f, -0.05725662f, 0.03355312f, -0.05348453f, 0.02446592f, 
    -0.02769826f, 0.03635124f, 0.04917786f, 0.02246902f, -0.00417988f, -0.05123104f, -0.00161382f, -0.00262729f, 
    -0.05961434f, 0.05299919f, 0.24037264f, -0.03345018f, -0.21901742f, -0.09978104f, -0.03365195f, 0.22898266f, 
    0.08854403f, -0.26950705f, -0.09724422f, 0.11639215f, -0.00667977f, 0.07638559f, 0.00914440f, -0.00724168f, 
    0.21579650f, -0.12157537f, -0.13575612f, 0.08049094f, 0.37822634f, -0.14206694f, 0.00077395f, 0.26795387f, 
    0.04175400f, 0.16561711f, 0.09326602f, -0.06179858f, -0.07338341f, -0.08515692f, 0.33170259f, 0.05481835f, 
    -0.01418238f, 0.06650104f, -0.00533303f, -0.05453550f, -0.03557738f, -0.09120549f, -0.05921547f, -0.16628490f, 
    -0.05595432f, -0.07333770f, -0.23802477f, 0.08838780f, 0.00004141f, -0.08657692f, 0.01851653f, -0.09165116f, 
    0.23537444f, 0.10909944f, 0.13876279f, -0.06467014f, 0.11731914f, 0.01082922f, 0.19346306f, 0.07987586f, 
    -0.05021397f, 0.02825714f, -0.06073898f, -0.15447478f, 0.25755313f, 0.00468066f, 0.02631739f, 0.10157188f, 
    0.00804892f, -0.10345958f, -0.09023634f, 0.04690612f, 0.03664843f, 0.24459973f, -0.06846420f, -0.05919101f, 
    -0.17310791f, -0.30348489f, 0.22515649f, 0.13020772f, 0.07310587f, 0.10798661f, 0.11324742f, 0.01017095f, 
    -0.08877842f, -0.34499651f, 0.12950622f, 0.19399358f, 0.02399917f, -0.15876161f, -0.02036203f, -0.16849300f, 
    0.03567678f, -0.08980183f, -0.05022682f, 0.16001415f, 0.33902249f, -0.02741957f, -0.23427445f, 0.05995908f, 
    -0.14557452f, -0.01084147f, 0.10228395f, 0.06695387f, -0.24913482f, -0.10355814f, 0.13682112f, 0.14481558f, 
    -0.02451104f, -0.02787521f, -0.11326184f, 0.17346989f, -0.19123647f, 0.00564582f, -0.07290823f, 0.05430586f, 
    0.09369821f, -0.02111891f, -0.03930711f, -0.08394714f, -0.13124721f, -0.07278986f, 0.00219556f, 0.03459468f, 
    -0.23059127f, -0.07791255f, -0.01012016f, 0.14528275f, 0.02686937f, -0.13668394f, -0.30773517f, -0.25507990f, 
    -0.11650874f, 0.13048467f, -0.02844469f, -0.02203534f, 0.15616164f, -0.04675285f, 0.04677569f, -0.47321469f, 
    0.01303834f, -0.19623131f, 0.00376392f, 0.07440495f, 0.08517040f, -0.26378912f, -0.13392204f, 0.06372717f, 
    0.07486422f, 0.13176215f, 0.21185583f, -0.12006600f, 0.00626865f, 0.04060107f, 0.03570420f, 0.07895046f, 
    0.13034110f, -0.31589103f, -0.09671772f, -0.15388426f, 0.42145067f, 0.08477017f, 0.01522133f, 0.05276585f, 
    0.20035337f, 0.00574720f, -0.15105680f, -0.21856755f, -0.15280841f, -0.12082417f, -0.00473899f, 0.05911094f, 
    -0.04929498f, -0.08036707f, -0.01488309f, -0.23518609f, -0.25145540f, 0.03046953f, 0.05327684f, -0.25714886f, 
    0.03110681f, 0.23974432f, 0.00677240f, 0.28827435f, 0.30327356f, -0.07489871f, -0.06837896f, 0.08695770f, 
    -0.01468002f, 0.04821254f, -0.08373230f, 0.00322903f, 0.14019297f, 0.12989561f, 0.10635204f, 0.11950120f, 
    -0.03092025f, -0.02586566f, 0.04950374f, -0.24397884f, 0.11350048f, 0.06960808f, -0.01496979f, 0.02543743f, 
    0.02057608f, -0.01329231f, -0.12804356f, -0.01289285f, -0.13577738f, 0.09851662f, 0.06792749f, -0.20633446f, 
    -0.06206297f, 0.09459837f, -0.10519988f, 0.04676517f, 0.04789202f, 0.01359044f, 0.14469796f, 0.14801522f, 
    -0.11303851f, 0.10257068f, 0.03689883f, 0.10613002f, -0.02401840f, 0.14173149f, 0.04339855f, 0.13621774f, 
    -0.02982214f, 0.03702302f, 0.06838828f, -0.15588577f, -0.04353044f, 0.02226513f, -0.06938262f, 0.16348049f, 
    -0.00678368f, 0.09845082f, -0.48097983f, -0.19212814f, -0.16030459f, 0.20578925f, 0.09563974f, -0.09538622f, 
    0.10954954f, -0.07956903f, 0.02517243f, 0.31072348f, 0.11058933f, 0.04119968f, -0.12169454f, -0.11254331f, 
    -0.22680871f, 0.11841025f, 0.20736790f, 0.25956202f, -0.05516755f, 0.11877654f, 0.08000369f, -0.03472484f, 
    0.05625632f, 0.11780185f, -0.02925266f, -0.07032780f, 0.09262138f, 0.37002927f, -0.27668226f, 0.09594199f, 
    -0.01403394f, 0.04223301f, 0.18634421f, -0.04841601f, -0.06655882f, -0.10113254f, -0.33590445f, -0.03958772f, 
    -0.17753667f, 0.19871850f, -0.01929578f, 0.02857178f, -0.03054721f, -0.05554036f, -0.05061162f, 0.47884578f, 
    0.11864296f, -0.12685782f, -0.16110094f, -0.08535704f, -0.06340195f, 0.08632720f, -0.26738659f, 0.26513129f, 
    -0.05525315f, -0.02588518f, 0.04819469f, 0.02092446f, 0.03055593f, 0.00079177f, 0.01907697f, -0.02134996f, 
    0.01743234f, 0.03827745f, -0.03456879f, -0.01804446f, 0.02789462f, -0.01045404f, -0.01086771f, 0.01599167f, 
    0.04893404f, -0.00714758f, 0.01093851f, -0.03221628f, -0.04009018f, 0.03751197f, -0.01259107f, -0.04751433f, 
    -0.02029592f, 0.01689337f, 0.00436447f, 0.05016079f, -0.04546752f, 0.03331443f, -0.03297267f, -0.03225457f, 
    0.01437858f, 0.00256219f, -0.01755858f, 0.00597767f, 0.02903068f, -0.02388767f, 0.02868238f, 0.01380144f, 
    -0.03756145f, -0.04180927f, 0.04542722f, -0.04845699f, 0.02153026f, 0.00967701f, 0.03619944f, -0.06695846f, 
    0.04060754f, 0.02114473f, -0.00442260f, 0.00100543f, -0.04627148f, -0.05875427f, 0.03571516f, 0.00891693f, 
    -0.05053397f, -0.05613178f, -0.02571180f, -0.05401753f, -0.00391285f, -0.04713898f, -0.01523779f, -0.06148455f, 
    -0.03094407f, -0.01735319f, -0.05505615f, 0.03576697f, 0.02334428f, -0.05115736f, -0.05570700f, -0.05349522f, 
    -0.00158039f, -0.04187357f, 0.05043682f, -0.03922864f, -0.02985962f, -0.05320482f, 0.00254764f, -0.02457323f, 
    0.01537716f, -0.02943932f, -0.00152799f, -0.00543875f, -0.03640779f, -0.02332754f, 0.01933683f, -0.05621444f, 
    -0.00869075f, 0.04563919f, -0.02826623f, -0.05541017f, -0.00105726f, 0.04431599f, -0.04140293f, 0.04202595f, 
    0.02326293f, -0.04112047f, -0.02580940f, 0.00643876f, -0.02363929f, 0.00940824f, -0.01593876f, -0.03373733f, 
    -0.05052708f, 0.02340880f, -0.02813539f, -0.01138256f, 0.01322452f, -0.01458110f, -0.00301449f, -0.02931844f, 
    -0.00717339f, 0.03246185f, 0.02982234f, 0.05739972f, -0.01177361f, -0.04138492f, 0.04544312f, -0.04086890f, 
    -0.04881770f, 0.02501645f, -0.04724715f, 0.04266211f, 0.04353202f, -0.00677172f, 0.05123710f, 0.05005412f, 
    -0.03238435f, -0.01619663f, -0.01801319f, -0.06257635f, 0.01729148f, 0.02053613f, -0.02077749f, 0.03427391f, 
    0.01955778f, 0.04439245f, -0.04016706f, -0.05567522f, -0.01319017f, -0.04534571f, -0.01707360f, -0.00123078f, 
    -0.00742926f, 0.00119204f, 0.02073663f, -0.01170826f, 0.00773529f, 0.04130847f, 0.03538364f, -0.01304956f, 
    -0.03335352f, 0.02229937f, -0.01285904f, -0.02052847f, -0.01253038f, -0.03914115f, -0.00014728f, -0.03395077f, 
    -0.02033023f, -0.01940385f, 0.00660740f, -0.05293401f, -0.00049315f, -0.02378684f, -0.03390013f, 0.04994310f, 
    0.00736206f, -0.00928973f, -0.00957652f, 0.02815122f, -0.01428848f, 0.01428587f, -0.04198699f, -0.03087352f, 
    -0.05755428f, -0.05572588f, -0.04231293f, -0.01128385f, 0.04934921f, -0.05344467f, -0.03622093f, 0.00358970f, 
    -0.03148676f, -0.04296208f, -0.05295921f, -0.05616585f, -0.02431444f, -0.04749665f, 0.02147004f, -0.00141160f, 
    -0.01080473f, -0.05887445f, 0.04296311f, -0.04523120f, 0.04181047f, 0.02784386f, 0.03862840f, -0.03817603f, 
    0.00097545f, -0.03109786f, -0.03554127f, -0.02229765f, -0.04987253f, -0.03882898f, -0.04467237f, -0.03513138f, 
    0.03757850f, -0.04751080f, -0.01276335f, 0.00604228f, 0.01003131f, 0.00276411f, 0.03434569f, 0.03649180f, 
    -0.04072905f, 0.01773196f, -0.00133001f, 0.04355008f, -0.00179386f, -0.04856239f, -0.00501518f, -0.05269222f, 
    0.01447063f, 0.03298695f, -0.00558061f, 0.04955711f, 0.02098497f, 0.03589081f, 0.00244609f, -0.05157718f, 
    -0.04323495f, -0.03754455f, -0.03942931f, 0.03968382f, -0.06217171f, 0.01807301f, -0.03071824f, -0.03711841f, 
    -0.05220184f, -0.02766776f, 0.00342491f, 0.03609838f, 0.03815766f, -0.02205997f, 0.00272585f, 0.02648167f, 
    0.02007860f, 0.03599254f, 0.01689675f, -0.01584434f, 0.01745206f, -0.00786280f, -0.05013525f, -0.05891723f, 
    0.01428176f, 0.00187754f, -0.01523331f, -0.05743509f, -0.00902280f, -0.06053980f, -0.02693392f, 0.04330643f, 
    0.02880948f, -0.00095396f, -0.04232731f, 0.02017215f, 0.00404564f, 0.00376160f, -0.05312752f, -0.05196689f, 
    0.01200346f, -0.06502281f, 0.01988175f, -0.03281427f, 0.01946955f, -0.03953778f, -0.01994502f, 0.00332845f, 
    -0.04944883f, -0.05842867f, -0.03698533f, -0.03775492f, -0.04679665f, 0.02351765f, -0.06479315f, -0.03783137f, 
    -0.04467091f, 0.04012747f, 0.00658348f, -0.02898998f, -0.03705899f, 0.01399069f, -0.03700128f, -0.03741979f, 
    -0.01013248f, -0.00306977f, 0.04585221f, -0.02466999f, -0.02555612f, -0.03902531f, -0.01244472f, -0.02485097f, 
    0.04999851f, 0.03115400f, -0.06151898f, 0.05429433f, 0.04668381f, -0.05644680f, 0.01747798f, -0.03099240f, 
    -0.01467560f, 0.03096455f, 0.03021461f, -0.04337363f, 0.04551405f, -0.05134758f, 0.03454969f, -0.04443909f, 
    0.00345231f, -0.03326573f, 0.00441471f, 0.01727996f, -0.05156605f, -0.00362934f, -0.02478614f, -0.00896775f, 
    -0.04136489f, -0.01358420f, -0.00949280f, -0.03032401f, 0.01687640f, 0.00610753f, 0.01021315f, -0.04555042f, 
    0.00464441f, -0.05371166f, -0.04531457f, 0.01577738f, -0.02360054f, -0.01163929f, 0.04508442f, -0.05906020f, 
    -0.03321825f, 0.01859447f, 0.04880375f, 0.02407317f, 0.05186469f, 0.03973038f, 0.01617890f, 0.00771186f, 
    0.04138419f, 0.02362336f, 0.04455062f, 0.02422408f, -0.05617344f, 0.02449320f, -0.02486538f, -0.00526087f, 
    -0.00633328f, -0.00064985f, -0.01835804f, 0.01844005f, -0.01682859f, -0.05339777f, -0.01992535f, 0.03019969f, 
    -0.01593609f, -0.02387223f, 0.03199288f, 0.03270373f, 0.00508507f, -0.00169049f, -0.01612869f, -0.02742131f, 
    0.03398487f, -0.00589370f, -0.00397203f, 0.00417706f, 0.00047083f, 0.04481203f, 0.04851355f, 0.02074587f, 
    -0.03171618f, -0.06637558f, -0.03726072f, 0.00287826f, -0.03616498f, -0.06618842f, 0.01275443f, -0.05496951f, 
    -0.02395174f, -0.05501597f, -0.02882418f, -0.04318421f, 0.04323072f, -0.04992139f, 0.01360475f, -0.01801712f, 
    -0.00964181f, -0.03328709f, -0.02347513f, -0.04010895f, -0.01964853f, -0.01332203f, -0.02921613f, -0.06326149f, 
    -0.04042638f, 0.00589672f, -0.05241483f, 0.03624798f, -0.00254995f, 0.01588859f, 0.00336081f, 0.01412698f, 
    -0.02659054f, 0.01949784f, -0.03813627f, -0.01252505f, 0.04076944f, -0.04779557f, -0.01412646f, -0.03824304f, 
    0.02849977f, 0.04976335f, -0.01400665f, 0.02944896f, -0.04352191f, 0.01137982f, -0.04094251f, -0.00737709f, 
    0.03040908f, 0.05801192f, -0.06973356f, -0.01469140f, 0.04587495f, -0.00894963f, -0.05253763f, -0.04203114f, 
    -0.00385934f, -0.03832407f, 0.03354167f, -0.06261677f, -0.01368105f, -0.04732955f, 0.01671018f, -0.03393680f, 
    -0.02037794f, 0.00696285f, 0.01576360f, -0.04315712f, 0.05826979f, 0.04516092f, -0.04913890f, 0.03888609f, 
    0.00817122f, 0.05423294f, 0.00331655f, -0.00507119f, -0.02375028f, -0.02340817f, -0.06255201f, -0.02011599f, 
    -0.01419908f, 0.03625191f, 0.01907811f, -0.03441819f, -0.03153918f, -0.05058359f, -0.06660943f, -0.06296320f, 
    0.02472370f, 0.03610764f, -0.05147832f, 0.00816746f, -0.02121625f, -0.05549285f, -0.04571740f, -0.01109159f, 
    0.02205786f, 0.00897825f, 0.05230930f, 0.03598805f, -0.01396405f, -0.03009317f, 0.02119427f, 0.02001862f, 
    0.02555222f, 0.00217367f, -0.04749534f, 0.04117284f, 0.00465803f, -0.00684789f, 0.04361790f, 0.05680950f, 
    -0.00788771f, -0.01907209f, 0.04016807f, 0.04851528f, -0.04134042f, -0.06526099f, -0.00736910f, -0.05051645f, 
    -0.03206170f, -0.01750519f, 0.04568240f, 0.01724390f, 0.04569001f, -0.01548335f, 0.00793504f, 0.03626578f, 
    0.00592466f, -0.02459537f, 0.01535542f, -0.05195441f, -0.02983098f, -0.03983775f, 0.02346865f, 0.04007945f, 
    -0.00699290f, 0.04182637f, -0.01741474f, 0.05357773f, -0.01502619f, 0.02172935f, 0.02436222f, -0.03688236f, 
    0.03559415f, -0.06075216f, 0.02313498f, -0.05306656f, 0.04834572f, -0.00728132f, -0.05458052f, -0.04085102f, 
    -0.00816506f, -0.00919684f, 0.00780760f, 0.01332753f, 0.05144777f, 0.00600561f, 0.00696683f, 0.02967149f, 
    -0.00807358f, 0.01517076f, -0.05630076f, -0.04147383f, -0.05186110f, 0.03934229f, -0.06300908f, -0.05183632f, 
    -0.05453972f, 0.00606312f, -0.02154476f, -0.05664970f, 0.01567787f, -0.02087437f, 0.02210094f, -0.03303388f, 
    0.03879163f, 0.04587575f, -0.06194776f, 0.04558455f, -0.00835683f, -0.05379914f, -0.01606264f, 0.01766274f, 
    -0.04626506f, -0.02382671f, -0.06830725f, 0.04550090f, -0.02845106f, -0.01513405f, -0.02193688f, -0.02486509f, 
    -0.06957499f, -0.00022415f, -0.01162533f, 0.01264806f, -0.02543371f, 0.02467468f, -0.02487142f, -0.03071608f, 
    -0.03091877f, 0.06568842f, -0.03821642f, -0.00170209f, -0.04661601f, 0.05467916f, 0.00928670f, -0.00271513f, 
    0.01399070f, 0.06579316f, 0.01524520f, -0.05103903f, 0.04534224f, -0.01054683f, -0.01813091f, -0.06308425f, 
    0.04505111f, -0.01590671f, 0.00095486f, 0.05537439f, 0.00969821f, 0.01505045f, -0.03679935f, -0.06156749f, 
    -0.01447794f, -0.03710394f, -0.01466574f, -0.04291970f, -0.00640471f, 0.03728484f, -0.06329834f, -0.02224036f, 
    -0.07234608f, -0.07103795f, -0.04226657f, -0.00640592f, -0.02915222f, 0.00499107f, -0.02449678f, 0.00304420f, 
    -0.07584386f, -0.03480408f, -0.00488032f, -0.02060934f, 0.01216294f, 0.03393917f, 0.01560451f, 0.00753035f, 
    0.03419851f, -0.03577615f, -0.04022478f, 0.03140981f, -0.04731316f, 0.00497218f, 0.02023978f, -0.00319066f, 
    -0.06626568f, 0.05062998f, 0.04313650f, 0.01123810f, 0.00034141f, 0.02214068f, 0.01585067f, -0.04532460f, 
    -0.06474535f, -0.04075664f, 0.02389772f, -0.05234449f, -0.01448413f, 0.01816251f, -0.03300126f, 0.02623225f, 
    -0.01463918f, -0.06460664f, -0.05838088f, 0.02068921f, 0.02233834f, 0.04358485f, 0.01744167f, -0.01935669f, 
    -0.01428796f, 0.03245625f, 0.00293583f, -0.02868616f, 0.03827646f, 0.04810255f, -0.01531489f, 0.03178311f, 
    0.05046452f, 0.00859159f, 0.04726221f, 0.03406961f, -0.02978252f, -0.04246557f, -0.00445740f, -0.06718787f, 
    -0.02895996f, 0.04476179f, -0.06150123f, 0.01496986f, 0.03371908f, -0.01853695f, -0.03662268f, 0.01317285f, 
    0.00157360f, -0.00921109f, 0.02520214f, -0.05042486f, -0.04281655f, 0.04577701f, 0.03063733f, -0.02629849f, 
    0.06217895f, 0.00263990f, -0.00856929f, -0.01996543f, -0.06547756f, 0.02113485f, 0.02227798f, -0.00270424f, 
    -0.03489283f, -0.04379787f, -0.01749558f, -0.05804792f, 0.04618005f, -0.02459912f, -0.04781160f, -0.02015495f, 
    0.07087275f, 0.03855528f, -0.06283661f, -0.02525524f, 0.04459284f, -0.03361971f, 0.05289748f, -0.07016410f, 
    0.01465562f, -0.05364876f, -0.03534524f, 0.04119347f, 0.01508006f, 0.03945978f, -0.01034372f, 0.00847873f, 
    -0.01897272f, 0.01904086f, -0.03845681f, -0.03030379f, 0.02242747f, -0.06940261f, -0.02355981f, -0.03642852f, 
    -0.05061893f, -0.01064529f, 0.05499681f, 0.04903527f, -0.02916288f, -0.04322363f, -0.05637095f, -0.00152099f, 
    -0.04458553f, -0.02746317f, 0.03305528f, -0.07383114f, 0.06254970f, 0.03268040f, 0.02985175f, 0.03944502f, 
    -0.01694400f, 0.03968124f, -0.03584772f, -0.00408923f, -0.01797640f, -0.05247693f, 0.02725007f, 0.00864103f, 
    0.01694113f, 0.00936995f, -0.00944951f, 0.03325662f, 0.04187842f, 0.02776813f, -0.03334392f, 0.02050516f, 
    -0.02640673f, -0.00412894f, -0.01109411f, -0.01775616f, 0.02066055f, -0.04570348f, -0.03380889f, -0.08814172f, 
    -0.05888547f, -0.05046764f, -0.01145705f, 0.02885051f, 0.04896543f, 0.00163428f, 0.04500351f, -0.00209889f, 
    0.01860898f, -0.03267115f, 0.03480772f, 0.01572939f, -0.00649611f, 0.02780514f, -0.00026625f, -0.00536647f, 
    0.02695523f, -0.01476859f, -0.02421581f, -0.02232017f, 0.02646536f, 0.02813755f, -0.04668864f, 0.01373500f, 
    0.01562599f, -0.04485654f, -0.02970064f, -0.02276829f, -0.05350046f, -0.06137359f, 0.04501612f, 0.04118021f, 
    -0.00073994f, 0.01415275f, -0.05048693f, -0.02279645f, 0.03576598f, -0.02270319f, -0.03351713f, -0.05518328f, 
    0.02331557f, 0.02341817f, -0.00984037f, -0.00704499f, -0.08989915f, 0.00914375f, 0.03822353f, 0.00126484f, 
    -0.02760253f, -0.04289033f, -0.01571351f, -0.05300818f, -0.06422740f, 0.04786553f, 0.01419461f, 0.01530471f, 
    -0.03332797f, 0.03360481f, -0.05815409f, 0.00257232f, -0.01402101f, -0.02350813f, -0.00176317f, -0.04829868f, 
    -0.05651144f, -0.01234998f, 0.02899094f, 0.00030307f, -0.05870655f, 0.00331208f, 0.01771486f, 0.00738801f, 
    0.01704240f, -0.04916438f, 0.03590271f, -0.02438332f, -0.05095499f, -0.00796387f, -0.01556091f, -0.02027091f, 
    -0.06367253f, -0.01370382f, 0.02695655f, 0.01168662f, -0.02987288f, -0.01015345f, -0.04069849f, 0.00508589f, 
    -0.01129020f, 0.04989678f, -0.04022498f, 0.02301941f, 0.03020803f, -0.04597364f, 0.02957481f, 0.02137999f, 
    0.00750247f, 0.00930246f, -0.06063404f, -0.03338285f, -0.03351463f, 0.01068470f, -0.04240558f, 0.03984611f, 
    -0.00092583f, -0.00659300f, -0.05847847f, 0.03235154f, -0.02352977f, -0.04857107f, -0.03984588f, 0.01618754f, 
    -0.05057913f, -0.04539450f, 0.02437221f, 0.03521566f, 0.01863737f, -0.05353908f, -0.02267496f, -0.01459006f, 
    0.01738654f, -0.03535616f, 0.03058084f, -0.01370462f, -0.02616712f, -0.02732029f, -0.03893832f, -0.02764958f, 
    -0.02275513f, -0.03642091f, 0.00013841f, 0.03429693f, -0.01658884f, -0.01021776f, 0.01752589f, -0.01306311f, 
    -0.01754532f, 0.02973378f, 0.04052186f, 0.03903909f, 0.04847939f, 0.05136970f, -0.03573621f, 0.04622077f, 
    -0.00488835f, 0.04270804f, -0.05999199f, -0.04743717f, 0.02159325f, -0.04170132f, -0.05544469f, -0.03501153f, 
    -0.03592562f, 0.04817880f, 0.05085319f, -0.02239840f, 0.01883180f, 0.04699733f, 0.02390951f, 0.01218902f, 
    0.02559182f, -0.04178869f, 0.05237710f, -0.01537620f, 0.00789581f, 0.00659984f, 0.04030382f, -0.03146194f, 
    0.03650884f, 0.02167854f, -0.01895260f, -0.01185193f, 0.02390345f, -0.01979290f, 0.01276408f, 0.00780577f, 
    0.02678540f, -0.00306621f, 0.01162249f, 0.01339887f, 0.01628258f, -0.02263926f, -0.01426307f, -0.00231833f, 
    -0.04890664f, -0.02047325f, -0.02923850f, 0.02944898f, 0.03884637f, -0.03143301f, -0.03787847f, -0.01945549f, 
    -0.04514731f, 0.04837166f, -0.05848963f, 0.04631429f, 0.01346267f, -0.01666103f, 0.03617753f, -0.01501622f, 
    -0.00393708f, 0.01119936f, 0.01909532f, -0.05113925f, -0.01439404f, 0.00882113f, -0.03429583f, 0.02695691f, 
    0.01128410f, -0.05428225f, -0.00746622f, -0.06906822f, -0.00968793f, -0.02715150f, 0.01603281f, -0.07205954f, 
    0.01488633f, -0.06752769f, -0.03676092f, 0.02828394f, 0.01276086f, -0.00072401f, 0.00752931f, -0.03379185f, 
    -0.02357495f, -0.04063526f, -0.03882031f, -0.03374683f, -0.06620996f, -0.05462942f, -0.02972321f, -0.06109125f, 
    -0.01250170f, 0.02195586f, 0.00735144f, 0.04153356f, 0.03233635f, -0.02613846f, -0.00043590f, 0.01587704f, 
    0.02932423f, 0.04804960f, -0.02023088f, 0.00429155f, -0.01217458f, -0.03119791f, -0.00075321f, -0.01951884f, 
    -0.03878796f, -0.03294912f, -0.07394855f, 0.00778084f, 0.04821951f, 0.00963215f, -0.04805383f, 0.02143440f, 
    0.03485466f, -0.02541744f, 0.04272213f, -0.04365259f, 0.01795248f, -0.00958936f, -0.01210034f, 0.04255191f, 
    0.02549774f, -0.00292000f, 0.05376415f, 0.04037207f, 0.01224390f, -0.06645527f, -0.03008870f, -0.02794902f, 
    0.00449233f, 0.01626132f, -0.00114975f, -0.01992005f, -0.01399531f, -0.03346232f, 0.01404100f, 0.00390503f, 
    -0.07040285f, -0.02436458f, 0.04202370f, 0.04414165f, -0.05903478f, -0.04159228f, -0.00646191f, -0.03814539f, 
    0.02246128f, -0.02951531f, -0.00995743f, -0.02276275f, -0.01383693f, 0.05477779f, -0.01132852f, -0.05450919f, 
    -0.06202013f, -0.03374380f, 0.04231037f, -0.02410447f, -0.02015172f, 0.00947446f, -0.00992409f, -0.03297944f, 
    -0.04403161f, -0.03518848f, -0.00456864f, 0.00817823f, 0.04243415f, 0.02766074f, -0.05561969f, -0.02807559f, 
    -0.02276110f, 0.03009698f, -0.03324446f, -0.05306815f, 0.00819419f, 0.02008758f, -0.02457707f, -0.03210541f, 
    -0.05598907f, -0.05491341f, -0.02257896f, 0.04035769f, 0.03122345f, 0.04564795f, -0.00720139f, -0.02844230f, 
    -0.02871234f, -0.06258820f, -0.01280938f, -0.04486504f, -0.05866840f, -0.00555247f, 0.03509685f, 0.04205222f, 
    -0.06753027f, 0.02245376f, -0.05161869f, 0.02421645f, 0.03499923f, -0.05823253f, 0.04173326f, 0.04570622f, 
    0.02484223f, 0.02744682f, -0.05794090f, 0.02519809f, 0.00319061f, -0.02583480f, -0.06301598f, -0.02895914f, 
    -0.00067479f, -0.03477506f, 0.01257093f, 0.01727830f, -0.01279618f, 0.04734428f, -0.06214650f, 0.02517791f, 
    0.03402717f, 0.00954055f, 0.03902948f, -0.04442489f, -0.04321753f, 0.03476331f, 0.01678883f, -0.03395737f, 
    0.00682876f, -0.01940658f, -0.01953163f, -0.03217604f, -0.04788245f, -0.04096244f, -0.04181450f, 0.02935877f, 
    -0.01200532f, -0.04809831f, 0.00969212f, 0.00086196f, 0.04482595f, 0.01196536f, -0.00787345f, -0.03545031f, 
    0.02240572f, -0.04043324f, 0.04251151f, -0.02236272f, 0.03273283f, -0.00231927f, 0.03221081f, 0.03170722f, 
    0.03713496f, 0.05139415f, 0.02194357f, -0.06316546f, 0.04780485f, -0.04938618f, 0.03784233f, -0.02748020f, 
    0.01056785f, -0.01660852f, -0.00135530f, 0.00793521f, -0.00764596f, 0.01883087f, -0.02590169f, -0.06558555f, 
    0.01446684f, 0.02315337f, 0.04657888f, -0.00807452f, -0.04124938f, -0.02094763f, -0.03026639f, -0.04859248f, 
    0.02406802f, -0.03142223f, 0.01809470f, -0.02898827f, 0.00580873f, -0.03945017f, -0.05117940f, -0.05945186f, 
    0.02771772f, -0.05255022f, -0.00509790f, -0.03894719f, 0.03723306f, 0.00271067f, 0.04262583f, -0.03074486f, 
    -0.01768013f, 0.02471118f, -0.01475342f, 0.03165889f, 0.03598761f, 0.00827823f, 0.00569514f, -0.04440485f, 
    -0.04377867f, 0.00502266f, -0.02332213f, 0.03809277f, 0.02514470f, -0.03143941f, 0.00380440f, 0.00952028f, 
    -0.06319855f, 0.03624553f, -0.03756559f, 0.04095185f, 0.04802317f, -0.02521432f, -0.04655807f, 0.00539975f, 
    -0.01560819f, 0.00849060f, -0.02046793f, -0.05903916f, 0.02793107f, -0.02198257f, -0.06501498f, -0.05876494f, 
    0.04548947f, -0.06305499f, -0.00621686f, -0.04405825f, -0.00978081f, 0.03887868f, 0.04793458f, 0.01985708f, 
    -0.01529525f, 0.02425475f, 0.01140247f, -0.05519321f, -0.05369811f, 0.03980001f, 0.02910936f, 0.02206723f, 
    -0.03898750f, -0.00243423f, -0.04398775f, 0.01162457f, -0.02057829f, 0.01583618f, -0.01336660f, -0.02911130f, 
    0.00275352f, -0.05462484f, 0.00242511f, 0.02883779f, -0.04809618f, 0.02305704f, 0.03322503f, -0.06846406f, 
    0.04770283f, -0.02696056f, -0.06426504f, -0.00226122f, -0.06594588f, -0.00760656f, 0.01941750f, -0.06223136f, 
    0.04532851f, -0.06312312f, -0.01274039f, -0.05868703f, -0.02776399f, 0.02439495f, 0.04757392f, 0.00062438f, 
    -0.03364107f, -0.06036828f, -0.01537598f, -0.03780542f, -0.03947897f, -0.01345982f, -0.01376370f, -0.00901616f, 
    -0.04842540f, 0.00438432f, -0.03395919f, 0.02739644f, -0.05327572f, 0.00126861f, -0.03990230f, -0.00597613f, 
    -0.01754264f, 0.01763965f, -0.06096958f, 0.03592542f, -0.05358313f, 0.03358490f, -0.01687527f, -0.00818206f, 
    -0.05868262f, 0.02732223f, 0.00865966f, -0.00325123f, 0.03416430f, -0.03538566f, -0.01443986f, 0.04755322f, 
    0.01218409f, -0.04493469f, -0.03252894f, 0.03950312f, 0.03236643f, -0.02902905f, -0.01791981f, -0.04576294f, 
    0.00574692f, 0.01113661f, 0.00092647f, -0.03952084f, -0.01538853f, -0.02006664f, -0.04767129f, 0.00368681f, 
    0.03088467f, -0.01512305f, -0.00767750f, -0.05659367f, 0.00986940f, -0.01366857f, -0.00708058f, 0.02007971f, 
    -0.03272860f, -0.04087321f, -0.06520473f, -0.02546980f, -0.03248632f, -0.00671015f, 0.00437194f, 0.01137747f, 
    -0.01805966f, 0.02637382f, 0.04025913f, -0.05196970f, 0.00290989f, 0.03644728f, 0.02766172f, -0.00862833f, 
    0.04328495f, -0.03712855f, -0.03675089f, -0.06390709f, 0.01898452f, -0.03105657f, 0.00849116f, 0.03938575f, 
    -0.06455711f, -0.05509410f, -0.03491281f, 0.03206106f, 0.04408377f, 0.01616876f, -0.03163717f, 0.03500526f, 
    0.03541287f, -0.06476003f, 0.02332797f, -0.01116473f, 0.01118275f, 0.03090751f, -0.06692688f, 0.04644697f, 
    -0.02756274f, -0.05116250f, -0.06263702f, -0.06329536f, -0.04981542f, 0.01100305f, -0.01949141f, 0.03132409f, 
    -0.04706874f, -0.04199785f, -0.02831365f, -0.00064871f, -0.04145573f, 0.02436407f, -0.06818929f, -0.06810825f, 
    0.03555061f, 0.01074050f, -0.00215508f, -0.02849394f, -0.03151551f, 0.02002763f, -0.05514692f, -0.01820134f, 
    0.01853710f, 0.00567908f, 0.04599084f, -0.04678201f, 0.03608059f, 0.01242548f, -0.03656596f, -0.02094876f, 
    -0.01154299f, -0.04372844f, -0.05174375f, -0.04474261f, -0.01329572f, -0.01936140f, 0.02146109f, -0.00570777f, 
    -0.04705374f, 0.04217083f, -0.03413885f, 0.00221554f, -0.06787156f, -0.05072261f, 0.04636322f, -0.05174888f, 
    -0.02335911f, -0.06082389f, 0.00416759f, 0.01759017f, -0.05418349f, -0.01691912f, -0.02241992f, 0.04987273f, 
    0.05283815f, -0.05867922f, -0.10300861f, 0.12598273f, -0.00619807f, -0.08575524f, 0.10211509f, -0.05998558f, 
    0.00582436f, -0.40621260f, 0.20256579f, -0.23775342f, -0.04306041f, 0.12701088f, -0.11450045f, -0.06753770f, 
    -0.04100972f, 0.12222806f, -0.22523198f, 0.10656623f, -0.07469355f, 0.02573295f, -0.00702668f, -0.08304973f, 
    0.11089368f, -0.01051171f, -0.07445922f, 0.11484119f, 0.11408475f, 0.19100371f, -0.14757547f, -0.12199480f, 
    0.08100169f, -0.05530539f, -0.07484383f, 0.00240226f, 0.36793587f, 0.08617440f, -0.29647568f, 0.17589846f, 
    0.19537890f, -0.12367721f, -0.08416345f, 0.10994346f, -0.25734019f, 0.08335029f, 0.12113956f, 0.28644550f, 
    -0.19767520f, -0.14172080f, -0.06239368f, -0.00522440f, -0.07165965f, 0.02533832f, 0.32425877f, -0.06733424f, 
    -0.07021044f, 0.07318921f, 0.02538618f, 0.17295232f, 0.01649316f, 0.09907459f, 0.17420550f, -0.06590390f, 
    -0.25019503f, 0.02390123f, -0.01618973f, -0.00504445f, 0.02815523f, -0.00638968f, 0.28584579f, 0.01384462f, 
    -0.11804358f, -0.26426405f, -0.08053485f, -0.03694438f, -0.00653574f, 0.08977185f, 0.17233400f, -0.22867706f, 
    0.03110510f, 0.01922368f, -0.02766197f, 0.04304154f, 0.00284161f, 0.03792093f, 0.09795248f, 0.04467300f, 
    -0.03348554f, -0.12607236f, 0.11679806f, 0.13509016f, 0.01972298f, 0.02612451f, 0.12764794f, 0.04740154f, 
    0.17303087f, 0.13372847f, -0.03917950f, -0.24243064f, -0.06676141f, -0.08166303f, -0.22151154f, 0.14125742f, 
    -0.15939412f, 0.08152836f, 0.17802505f, 0.00097856f, 0.31387872f, 0.05138250f, 0.32851964f, -0.03953661f, 
    -0.04700536f, -0.03430923f, -0.13023731f, -0.00867036f, 0.06443519f, -0.29295158f, 0.08557560f, -0.05468916f, 
    -0.06640442f, -0.09307378f, 0.12595978f, 0.03041218f, 0.09175062f, 0.09252437f, -0.21873847f, 0.03597222f, 
    0.08378602f, -0.07211829f, 0.00551473f, -0.16047262f, 0.00553680f, 0.06554891f, -0.03109513f, 0.10441112f, 
    0.20424439f, 0.42190370f, -0.13896914f, -0.10890044f, -0.01066171f, -0.12293579f, 0.00383003f, 0.05633489f, 
    0.05989439f, 0.17898776f, -0.08651685f, 0.06956553f, 0.02295920f, -0.14400461f, 0.08027741f, 0.12248699f, 
    -0.00584081f, 0.03293940f, -0.18429779f, 0.01284667f, 0.04333058f, -0.45085782f, -0.10057741f, 0.03662791f, 
    0.09537302f, 0.14880632f, -0.01711354f, 0.28597760f, 0.10555962f, -0.11602116f, 0.07733256f, -0.15056707f, 
    -0.15222229f, 0.04961668f, -0.07661664f, -0.15903786f, -0.27277204f, -0.04696002f, 0.01017451f, 0.19723852f, 
    -0.07445081f, 0.06630091f, -0.12865725f, 0.03693118f, 0.30060321f, 0.13854508f, 0.05731701f, -0.10024036f, 
    -0.19955595f, -0.09579919f, -0.05285888f, 0.06842773f, -0.11060250f, -0.13661222f, -0.01842941f, -0.49727720f, 
    -0.04360811f, -0.05672328f, -0.11539008f, -0.05726211f, 0.16279574f, -0.19150423f, 0.27915898f, 0.03348762f, 
    -0.52793956f, 0.17605214f, 0.12643777f, 0.08449209f, -0.19166613f, -0.05239104f, -0.12680052f, 0.11160937f, 
    0.21554847f, -0.13367411f, 0.00987792f, 0.00026107f, 0.03592082f, -0.02633028f, -0.01921908f, -0.08080524f, 
    0.17924495f, -0.25303546f, 0.01322331f, 0.03035594f, -0.02904812f, -0.10074539f, 0.06178208f, 0.07485694f, 
    0.19188182f, 0.27505529f, 0.05605184f, -0.23882769f, -0.18653509f, 0.14079502f, -0.03135656f, -0.00465262f, 
    -0.00970679f, 0.15685488f, 0.27636817f, 0.10056218f, -0.17956634f, -0.16800344f, -0.02786585f, 0.03553479f, 
    0.07554333f, -0.02816556f, -0.11906496f, -0.03262262f, 0.20974991f, -0.16281286f, -0.06078196f, 0.09747203f, 
    -0.00415377f, -0.03120148f, -0.09944423f, 0.05800498f, 0.09623009f, -0.09013849f, -0.39470851f, -0.04356815f, 
    0.08654018f, 0.03384547f, -0.11626668f, 0.00175553f, 0.06791037f, -0.06321728f, -0.43829155f, -0.04869202f, 
    0.21323083f, -0.08037984f, 0.04657514f, -0.21063338f, 0.00057356f, -0.04112920f, -0.00361694f, 0.11045615f, 
    0.26103911f, -0.00351966f, 0.16026986f, 0.11995547f, -0.08706157f, 0.08157197f, -0.03139911f, 0.13517959f, 
    0.01261231f, -0.06852975f, -0.13792674f, -0.07549229f, 0.09941468f, 0.08677751f, 0.12541838f, 0.10028222f, 
    -0.14604783f, -0.38241348f, 0.05215859f, 0.02646287f, 0.07919712f, 0.07694069f, -0.14392704f, -0.22150412f, 
    -0.01934916f, 0.14085117f, -0.29588041f, 0.11673246f, 0.09524292f, 0.14760147f, -0.11727557f, -0.07877175f, 
    -0.12545581f, -0.06545371f, 0.17089061f, -0.00443417f, 0.01728121f, 0.17798245f, -0.13430750f, -0.00014691f, 
    -0.02028940f, -0.04808082f, 0.18224841f, 0.12399444f, 0.08183192f, -0.07595129f, -0.16226304f, 0.03551921f, 
    -0.00948306f, 0.16041037f, 0.01341575f, -0.16234241f, 0.17159539f, -0.17390119f, 0.02259038f, 0.05438919f, 
    -0.25087428f, 0.17427966f, -0.04034720f, -0.17453569f, 0.05431652f, 0.29955649f, 0.15913117f, -0.05730335f, 
    -0.07283113f, 0.01854603f, -0.26160917f, 0.13514590f, 0.06037534f, 0.10134229f, -0.12999530f, -0.02798439f, 
    -0.09858478f, 0.17394467f, 0.16586912f, 0.07001874f, -0.22861469f, -0.10788876f, 0.09357709f, -0.03564084f, 
    -0.22411254f, -0.01160750f, 0.05692489f, 0.03704318f, -0.06788928f, 0.00352875f, -0.10138261f, -0.01949198f, 
    -0.03052108f, 0.17054412f, 0.00032517f, -0.01759502f, -0.03135863f, 0.09705858f, 0.03232482f, 0.04331491f, 
    -0.09165739f, -0.46023041f, -0.23389508f, -0.00714590f, 0.07044797f, 0.04508734f, -0.07110295f, 0.08708538f, 
    -0.01427962f, 0.12340210f, -0.13595890f, -0.35464725f, 0.08283069f, 0.11556903f, -0.14044040f, 0.14907719f, 
    0.09783307f, 0.11367691f, 0.00851364f, -0.01860459f, -0.16418274f, -0.15657569f, 0.00379234f, 0.00064052f, 
    -0.01207617f, -0.09172429f, 0.10533783f, -0.26224998f, 0.32582596f, 0.35770538f, -0.11484497f, -0.17413743f, 
    0.14076711f, -0.05469218f, -0.12730877f, 0.20061783f, 0.15612105f, 0.17747024f, -0.09155091f, -0.02388342f, 
    -0.09789326f, 0.12570424f, 0.03435953f, -0.04110332f, 0.00943317f, 0.03930166f, 0.01825646f, 0.22924075f, 
    0.15951972f, 0.01034370f, -0.10484835f, -0.20930627f, -0.08491457f, 0.17594542f, 0.27062604f, 0.09504031f, 
    -0.06559916f, -0.02650599f, 0.16419776f, -0.09909684f, -0.06449068f, 0.01596701f, 0.23158282f, 0.01339891f, 
    0.40408054f, -0.02478538f, 0.03689502f, 0.01029158f, 0.01971769f, 0.18249869f, 0.08654677f, 0.04144910f, 
    -0.12035140f, -0.02331533f, -0.03810897f, 0.04256325f, -0.10572242f, -0.04431567f, 0.06282420f, 0.04578211f, 
    -0.09471580f, -0.00724901f, 0.33095056f, 0.05541237f, 0.12544021f, -0.16504398f, -0.04768607f, -0.12579092f, 
    0.11499406f, 0.08375996f, 0.12470745f, 0.03632824f, 0.02502056f, -0.18588258f, -0.13761720f, -0.04657122f, 
    0.06951480f, -0.09928637f, 0.08264963f, 0.18720025f, -0.03561570f, 0.18535356f, -0.01777482f, 0.17118728f, 
    0.04313027f, 0.02147166f, 0.03926074f, 0.20765480f, -0.12768172f, 0.20995405f, -0.17702988f, -0.01314510f, 
    0.02698774f, -0.04210899f, 0.04934648f, -0.04866743f, -0.05519958f, -0.05574297f, -0.21973041f, -0.26533020f, 
    -0.25266567f, -0.00875304f, 0.05400770f, 0.14633584f, 0.13418733f, -0.09563173f, 0.12395760f, 0.12740326f, 
    0.10405582f, -0.01685902f, 0.00792792f, -0.11989730f, 0.10450488f, -0.03214507f, -0.18919279f, -0.23721507f, 
    -0.10568848f, -0.11554845f, -0.25613707f, 0.06624111f, -0.10083765f, 0.13530558f, 0.01000031f, 0.04670927f, 
    0.14004838f, -0.32193276f, -0.16712788f, -0.31037131f, 0.00029394f, 0.01044528f, 0.10475776f, -0.02104644f, 
    0.13486078f, 0.02505197f, -0.22566733f, -0.08119226f, 0.08185936f, -0.09225711f, 0.01184724f, 0.10672016f, 
    0.04610814f, 0.18399559f, -0.04546408f, -0.16415662f, 0.11165895f, -0.23093177f, 0.04693141f, 0.04611152f, 
    -0.04116125f, 0.02428134f, 0.05765696f, 0.03666084f, 0.06529009f, 0.03294434f, 0.14533958f, 0.13977103f, 
    -0.09385929f, 0.09384887f, -0.02581893f, -0.09836540f, -0.02365072f, -0.23070711f, -0.27840394f, -0.18331616f, 
    0.07438672f, 0.06947421f, 0.05637071f, -0.18252409f, -0.15220091f, -0.19737229f, 0.08642417f, 0.13331144f, 
    0.04787977f, 0.08307923f, 0.12395161f, 0.17515683f, -0.19295402f, -0.11068975f, 0.11899679f, 0.14460160f, 
    -0.21139427f, 0.22009628f, -0.01338592f, 0.09440555f, -0.22801687f, -0.02320753f, 0.11839655f, 0.09145986f, 
    -0.03539906f, 0.02306798f, 0.01010908f, -0.05388016f, -0.01286945f, -0.04060843f, 0.04110599f, 0.02015219f, 
    0.03979070f, 0.02016526f, 0.02541053f, 0.01246767f, 0.02122598f, -0.06702781f, -0.03430957f, -0.03062415f, 
    -0.02439256f, -0.05086577f, -0.01417959f, 0.05394768f, -0.04763793f, 0.04453721f, -0.06655693f, 0.03862228f, 
    -0.05018635f, -0.00110710f, -0.00990441f, 0.01408478f, 0.02762265f, -0.05984186f, -0.06139667f, 0.01484669f, 
    0.02406492f, -0.00763845f, -0.05138192f, 0.00804186f, -0.05641742f, -0.03200272f, 0.04029164f, 0.01842152f, 
    -0.01464131f, 0.01944637f, 0.01200347f, 0.02967348f, -0.05119058f, -0.04467094f, 0.02873693f, -0.06423351f, 
    0.00545649f, 0.02926300f, 0.00795749f, 0.00308744f, -0.00903452f, -0.00153794f, 0.03918309f, -0.02574621f, 
    -0.05816691f, 0.04930248f, 0.01708945f, 0.02173392f, -0.01430123f, 0.04906026f, 0.01524293f, 0.00597878f, 
    0.04878804f, -0.01547580f, -0.05154476f, 0.02481705f, -0.04125878f, 0.04738662f, 0.00250202f, -0.04510301f, 
    0.01632742f, -0.02531070f, 0.01911169f, 0.02407337f, 0.01753132f, 0.01593295f, -0.01120496f, -0.02691170f, 
    -0.05704245f, 0.01131143f, -0.00804221f, -0.01512360f, 0.03802479f, -0.04620412f, 0.01979536f, -0.01438177f, 
    -0.01658805f, -0.02547181f, 0.01920983f, -0.04716605f, 0.04379348f, -0.03427694f, -0.03418514f, 0.04562096f, 
    -0.03797115f, 0.04143079f, 0.04642373f, -0.01182032f, -0.01548799f, 0.02766827f, 0.02536395f, 0.01682812f, 
    0.01096748f, 0.01445586f, -0.00055685f, -0.01302839f, -0.02120068f, -0.01873641f, -0.00432770f, -0.06672744f, 
    -0.05295232f, -0.05604509f, 0.04147301f, 0.05180534f, -0.03968237f, -0.05969234f, -0.05892703f, 0.02158594f, 
    -0.04593066f, 0.00920980f, -0.05745838f, 0.01836048f, -0.03058129f, -0.00111439f, 0.03271897f, -0.06329527f, 
    -0.05940007f, -0.00341360f, -0.02597927f, -0.02619173f, -0.06799275f, -0.03181555f, -0.01614539f, -0.06701361f, 
    -0.04646078f, 0.01650464f, 0.02440877f, 0.04110118f, 0.00535145f, 0.00350086f, 0.04585627f, -0.06291769f, 
    -0.00912700f, -0.03083446f, -0.04418891f, -0.01039270f, 0.04692801f, 0.01606599f, -0.03822123f, 0.00983405f, 
    0.01829421f, -0.03540160f, 0.00319797f, -0.01320969f, 0.01484101f, 0.03960120f, -0.03630068f, 0.02505142f, 
    0.01943711f, 0.03057901f, -0.01961111f, -0.06678092f, 0.00056368f, -0.02988322f, 0.03585741f, -0.03922971f, 
    -0.05781864f, 0.02253922f, -0.00561659f, -0.01772442f, 0.01696029f, -0.02289592f, -0.06089011f, -0.01947553f, 
    0.03225635f, -0.02843749f, -0.04526408f, -0.05134962f, 0.00598276f, -0.04658729f, 0.00318605f, -0.03067207f, 
    0.01504351f, 0.00662375f, -0.01194003f, -0.00634227f, -0.03207151f, -0.02121883f, -0.03586527f, -0.04609852f, 
    -0.06247062f, -0.01719385f, -0.06239954f, -0.00093043f, 0.04027750f, -0.01175474f, 0.00059360f, 0.05133486f, 
    -0.02542903f, 0.02700044f, -0.01696996f, 0.02082544f, -0.02291856f, 0.04514045f, -0.01696455f, -0.01014143f, 
    0.01516155f, -0.03096679f, -0.02052852f, 0.01037004f, 0.03808697f, 0.00938099f, 0.00980459f, 0.02096798f, 
    0.03146714f, -0.05496714f, -0.01977376f, -0.03635657f, -0.02318130f, -0.05779471f, 0.02009143f, 0.02886626f, 
    -0.00155486f, -0.05979668f, 0.03634549f, 0.02410388f, -0.03624839f, 0.02788464f, -0.05708829f, 0.04924798f, 
    -0.02281917f, 0.05268674f, 0.02579976f, -0.04247789f, -0.00399139f, -0.04770911f, -0.01003563f, -0.03985531f, 
    -0.02683570f, 0.02489570f, -0.02502489f, 0.00393599f, 0.02949652f, -0.05988567f, -0.02031846f, -0.02199107f, 
    0.02992343f, 0.00041500f, -0.03658441f, -0.06528734f, -0.04587574f, 0.03279062f, -0.00105984f, -0.05554344f, 
    0.00594914f, 0.00516861f, -0.06004084f, -0.06111138f, -0.01735344f, -0.02966202f, 0.03353869f, -0.05710508f, 
    -0.04425531f, -0.01417789f, 0.03223582f, -0.02744306f, 0.00691132f, -0.06056972f, -0.03949584f, 0.04219565f, 
    -0.02620194f, 0.02290231f, -0.01948807f, 0.03695225f, -0.01959891f, -0.01566360f, 0.00405666f, 0.04331638f, 
    -0.00632344f, 0.01576901f, -0.04833951f, 0.00166158f, 0.03321755f, -0.04848649f, -0.02882662f, -0.01396349f, 
    0.02060579f, 0.03007611f, 0.03529876f, -0.00966199f, -0.05888784f, -0.03884355f, 0.03565330f, -0.01890876f, 
    -0.06402738f, 0.00729020f, -0.02401426f, -0.01891821f, 0.00263877f, 0.02098018f, 0.01501482f, 0.04395722f, 
    0.01316295f, 0.04089857f, -0.03879463f, 0.02734203f, -0.05100146f, -0.04674895f, 0.00897349f, 0.01071054f, 
    -0.03070674f, 0.03195475f, 0.01334581f, -0.02723991f, -0.01288109f, -0.03616553f, -0.01592445f, -0.06142141f, 
    -0.04927340f, -0.01394031f, 0.00226877f, 0.00011040f, 0.03010335f, 0.02168185f, -0.03247255f, -0.02234498f, 
    -0.00500572f, -0.05736821f, 0.01453529f, 0.03520285f, 0.04472085f, 0.03565835f, 0.00410131f, -0.04233329f, 
    -0.03447414f, -0.04583752f, -0.01928916f, -0.05331729f, 0.00768933f, 0.01889350f, 0.00770933f, 0.04705375f, 
    0.03328474f, -0.01686784f, -0.03238651f, -0.06160189f, -0.02444103f, 0.03485787f, 0.03285784f, -0.06636240f, 
    -0.05637775f, 0.04417615f, 0.03330052f, -0.02319219f, 0.01582291f, 0.01252081f, -0.02201017f, -0.06113802f, 
    -0.00186594f, -0.04528649f, 0.02435614f, -0.03633309f, -0.05669262f, -0.01581828f, 0.04795454f, -0.03296668f, 
    -0.04898347f, 0.02380334f, -0.01202404f, -0.06505688f, 0.03088753f, -0.00311657f, 0.02034291f, -0.00082298f, 
    -0.03215906f, -0.06254748f, 0.01545419f, -0.00662404f, -0.00360323f, 0.01738360f, -0.06513447f, 0.01645162f, 
    0.04866928f, -0.02992341f, -0.01756630f, 0.03138163f, 0.04575388f, -0.02627372f, -0.05022635f, 0.05125223f, 
    -0.02812104f, 0.03379466f, 0.04439384f, 0.00468018f, -0.01854058f, 0.04242684f, 0.02238991f, -0.03873612f, 
    -0.06202372f, -0.01372420f, -0.02669643f, 0.04134843f, -0.05033173f, -0.02370623f, -0.03745913f, 0.05089758f, 
    -0.00792753f, -0.05202720f, -0.02875710f, 0.00704448f, 0.01550049f, -0.01642015f, 0.02574303f, 0.02375167f, 
    -0.02609750f, 0.03041112f, -0.04711640f, -0.04731456f, -0.05413184f, -0.02993662f, -0.05977675f, 0.02393586f, 
    -0.00411326f, 0.04605421f, -0.05525086f, -0.06772617f, -0.05349271f, -0.02290023f, 0.00344394f, -0.00165931f, 
    0.03045432f, -0.01458581f, 0.02338398f, 0.04624798f, -0.01817978f, -0.04548635f, -0.04580462f, -0.03771604f, 
    0.05230476f, 0.04474063f, 0.05218485f, -0.02313953f, -0.04453100f, -0.05733379f, -0.02358548f, 0.00924125f, 
    0.05906198f, -0.01820418f, -0.01519099f, 0.00742165f, -0.02503554f, -0.04642009f, -0.01206739f, -0.04028539f, 
    -0.05803664f, -0.01501941f, -0.05230766f, 0.04915667f, -0.03199080f, -0.01902136f, 0.04022487f, 0.03801842f, 
    -0.01210157f, -0.04085956f, -0.00811884f, -0.03029109f, -0.03826940f, -0.04643948f, -0.05050636f, -0.04095046f, 
    -0.06555004f, -0.04509743f, 0.04215382f, -0.00658613f, 0.03338948f, 0.00874715f, 0.03127027f, -0.02683322f, 
    -0.05486334f, 0.03397546f, -0.05389630f, 0.02590317f, -0.06331339f, -0.04731198f, -0.02403748f, 0.03632068f, 
    0.03653988f, 0.00235340f, 0.01029070f, 0.02705197f, -0.02859476f, 0.03072194f, -0.05394327f, 0.00286933f, 
    -0.06470224f, -0.03256254f, -0.05331965f, 0.03245368f, 0.05062457f, -0.00510505f, -0.03323766f, -0.04611388f, 
    -0.05540221f, -0.05789263f, -0.01451444f, -0.06283543f, 0.02139782f, 0.00511320f, -0.05002679f, 0.01433078f, 
    -0.02037583f, -0.05550459f, -0.04115091f, 0.05033901f, -0.01532899f, -0.05719337f, -0.00031707f, -0.00221910f, 
    -0.01173296f, 0.01547410f, -0.02371180f, 0.03752696f, 0.02318763f, 0.02158952f, 0.04568374f, 0.03806014f, 
    0.03012526f, -0.04112658f, -0.01939234f, -0.02626857f, -0.00322927f, 0.02781562f, 0.00673547f, 0.03656080f, 
    0.02686479f, 0.03876347f, 0.04226195f, 0.00858719f, -0.06026551f, 0.04203971f, -0.04172790f, -0.00442650f, 
    -0.03173693f, 0.04097020f, -0.05863509f, 0.01132793f, -0.01723491f, 0.00197482f, 0.01587452f, 0.04990907f, 
    -0.00479847f, -0.00037285f, -0.04392010f, -0.05620877f, 0.01363307f, 0.04166669f, 0.04597733f, -0.00932235f, 
    0.01374218f, 0.05332376f, -0.01441708f, -0.03800732f, -0.02492641f, 0.00957388f, -0.02925109f, -0.01449428f, 
    -0.05458280f, -0.00512162f, -0.06032126f, -0.06473527f, -0.05983936f, -0.00801763f, -0.05943730f, -0.02841168f, 
    0.02374585f, 0.16808031f, -0.10341081f, -0.03481885f, -0.21032982f, 0.06609739f, -0.12166368f, -0.08431680f, 
    0.03184702f, -0.08352987f, -0.44724008f, 0.03688488f, 0.24038512f, 0.07394228f, -0.02926935f, -0.13327090f, 
    -0.02022055f, 0.00373255f, 0.13339403f, 0.04089614f, 0.00788546f, 0.09280012f, 0.06940451f, 0.12860146f, 
    -0.17341830f, -0.18764928f, 0.07682508f, 0.01307594f, -0.26311377f, -0.22639748f, -0.12646186f, -0.10520053f, 
    -0.09528964f, 0.08593231f, 0.02359335f, -0.13791950f, 0.08974468f, 0.09493311f, -0.09383181f, 0.04412936f, 
    -0.08720890f, -0.00172651f, -0.01813017f, 0.12727518f, -0.07846751f, 0.36669290f, -0.04032372f, 0.05495916f, 
    -0.12579623f, -0.01951137f, 0.01891248f, 0.08302661f, -0.08549011f, -0.07103752f, -0.10707710f, -0.00495650f, 
    -0.04179605f, -0.09468154f, 0.03457134f, -0.04970327f, 0.02285815f, 0.01462737f, -0.15085557f, 0.00360241f, 
    0.11624356f, -0.04152127f, 0.03426980f, 0.14542939f, 0.02811387f, 0.24003616f, 0.00447410f, 0.30965698f, 
    0.18168814f, -0.01437229f, -0.18504989f, -0.09754088f, 0.28334475f, 0.05472558f, 0.06135482f, -0.04082797f, 
    -0.12745488f, 0.17222638f, 0.17273284f, -0.20217945f, 0.08818001f, -0.00447023f, -0.22130263f, 0.09285173f, 
    -0.08334568f, 0.24062008f, 0.14031918f, 0.30975139f, -0.07908227f, 0.18164483f, -0.05150170f, -0.02713324f, 
    -0.02637847f, 0.03136608f, 0.31271294f, -0.15853380f, -0.06277501f, -0.16368559f, -0.00175351f, -0.00771600f, 
    -0.01429447f, 0.09000444f, -0.09627129f, 0.02794551f, -0.10218176f, 0.38215238f, -0.09290904f, 0.03352534f, 
    -0.09585748f, -0.14862606f, -0.08474425f, -0.10361799f, -0.18237069f, 0.19693561f, -0.16567244f, -0.06568908f, 
    0.08200530f, 0.00456391f, 0.00155270f, -0.00887520f, -0.04479422f, 0.07930742f, -0.03171941f, 0.07055894f, 
    -0.05233366f, -0.03476822f, -0.07345737f, 0.08942460f, 0.11045373f, 0.13134590f, 0.10416317f, 0.19685659f, 
    -0.08752707f, 0.07132818f, 0.16366041f, 0.08443711f, 0.10384758f, -0.06236672f, -0.04957004f, -0.16421509f, 
    -0.10574613f, 0.02322888f, -0.05931628f, 0.08121058f, 0.12458587f, 0.10347390f, -0.11581801f, 0.08521903f, 
    -0.09894778f, 0.04636645f, -0.12849046f, -0.13346365f, -0.09210557f, 0.04628610f, -0.13130847f, 0.21716683f, 
    -0.04375857f, -0.14269270f, -0.28852862f, -0.22041517f, -0.16864726f, 0.08042126f, -0.10427764f, 0.04005288f, 
    0.02492284f, 0.09681759f, 0.32906738f, -0.03450429f, -0.00598410f, -0.13582906f, -0.08056545f, -0.06408783f, 
    0.06544840f, -0.11171761f, 0.03094677f, -0.05703693f, -0.28735089f, 0.33410063f, 0.19028097f, 0.00847782f, 
    0.01651617f, -0.07836568f, 0.10046722f, 0.08137288f, 0.13129935f, 0.16705206f, -0.16688949f, -0.27413887f, 
    0.13962537f, 0.05352384f, 0.12460057f, -0.24804309f, -0.02561561f, -0.03584303f, 0.13317604f, 0.11695313f, 
    0.03234353f, -0.00827078f, -0.08655968f, 0.08977904f, 0.03351320f, -0.00043486f, 0.08965147f, -0.02263571f, 
    0.07089269f, -0.06281991f, 0.17019187f, 0.02867671f, 0.13659419f, -0.04244260f, -0.03614679f, -0.18988551f, 
    -0.25253463f, -0.10520146f, 0.01956078f, 0.11489198f, 0.05505176f, -0.11393872f, -0.01912155f, 0.14979516f, 
    0.12663426f, 0.15026940f, 0.01552884f, 0.06415364f, 0.08929260f, 0.09997641f, -0.15507309f, -0.14485711f, 
    0.12872992f, -0.05001691f, -0.13441302f, 0.14621964f, 0.02850357f, -0.00705443f, 0.07171169f, 0.08350592f, 
    -0.07829800f, 0.16934742f, 0.00602427f, -0.18238822f, 0.09638275f, 0.21250172f, -0.00978365f, -0.00908807f, 
    -0.27319166f, 0.10422811f, 0.10654557f, 0.07762893f, 0.17990048f, -0.07349134f, 0.12781927f, -0.01108936f, 
    -0.00448712f, 0.23559362f, -0.06359800f, 0.12365507f, -0.10363942f, -0.32770783f, 0.06142820f, -0.10476551f, 
    0.09173267f, 0.08412179f, 0.09230638f, 0.00799950f, -0.05381421f, -0.21329819f, -0.05750897f, -0.12588826f, 
    -0.29353002f, -0.05063345f, -0.04160272f, 0.02509785f, 0.07166956f, -0.13386127f, -0.04740299f, -0.08442993f, 
    0.03809313f, -0.26172337f, 0.06818195f, -0.08580260f, 0.00704794f, -0.04152296f, 0.05356174f, -0.31523240f, 
    0.13661250f, 0.01063302f, 0.06040715f, -0.03741886f, -0.14917776f, -0.02684437f, -0.01732933f, 0.11866707f, 
    0.10092124f, -0.34775239f, -0.45207947f, 0.10805579f, -0.01733151f, -0.03102909f, 0.04568903f, 0.01923975f, 
    0.05327665f, -0.09247873f, -0.10784593f, 0.01417821f, -0.00862485f, -0.00426869f, -0.13965803f, 0.11799552f, 
    0.04532881f, 0.22468400f, 0.15044186f, 0.36458197f, 0.20252468f, -0.10933213f, -0.04651156f, 0.14401282f, 
    0.10528167f, 0.15194812f, -0.01045321f, -0.18483073f, -0.03404660f, -0.32162082f, -0.04466707f, -0.28271255f, 
    -0.04464082f, -0.02779644f, 0.16189419f, -0.06103158f, 0.00312496f, 0.23111160f, 0.41822147f, -0.35722998f, 
    0.18851009f, 0.00988755f, -0.03740809f, 0.02108028f, 0.09765460f, -0.17868103f, 0.27194443f, -0.04758341f, 
    -0.16867058f, 0.19831884f, -0.03032104f, 0.02662045f, 0.06490103f, 0.17759408f, -0.21054514f, -0.20983127f, 
    0.13858242f, -0.14335117f, 0.00120945f, 0.02979250f, -0.15878336f, 0.11337566f, 0.07159121f, -0.00184523f, 
    -0.25952289f, -0.02923757f, -0.03877566f, -0.05623206f, 0.00203450f, 0.09772182f, 0.02245695f, -0.09989610f, 
    -0.03459454f, -0.14124778f, 0.11964282f, -0.07210534f, 0.09918205f, -0.01466449f, 0.02317242f, -0.06056479f, 
    -0.05510735f, 0.06844620f, 0.11741949f, 0.08632859f, -0.00776853f, 0.20556320f, -0.14349581f, 0.00387243f, 
    0.00133948f, -0.04437184f, 0.07403321f, 0.23641051f, -0.09905912f, -0.08693551f, 0.11265770f, 0.02937645f, 
    0.03014532f, 0.02933776f, -0.09880918f, -0.06439977f, -0.00145629f, 0.54859591f, -0.20244075f, 0.06273505f, 
    0.01779054f, 0.06174985f, -0.09538547f, 0.00501704f, 0.01681615f, 0.20675367f, -0.35125816f, -0.15840004f, 
    -0.13390811f, 0.10761578f, 0.02720223f, -0.21376045f, 0.18831438f, -0.07041102f, -0.31654015f, -0.01260025f, 
    -0.18330638f, -0.04235400f, 0.21264845f, -0.11077086f, -0.05826928f, 0.02864529f, 0.02892612f, -0.43170381f, 
    0.31289369f, -0.17803617f, 0.05967147f, -0.11351110f, 0.06641717f, -0.06105416f, 0.15673280f, 0.08306760f, 
    0.04425745f, -0.35863063f, 0.18082763f, -0.00748570f, -0.06742957f, -0.00804670f, 0.10011970f, -0.23670588f, 
    0.21232355f, -0.43334043f, -0.21500522f, -0.24426346f, -0.04209228f, -0.04962290f, -0.13028660f, 0.00084546f, 
    0.06068356f, -0.05893648f, 0.18692808f, -0.17609891f, -0.04774923f, -0.01390108f, -0.03059923f, 0.09214285f, 
    -0.02176385f, -0.06053364f, 0.10451478f, -0.34582841f, 0.27862141f, -0.32088372f, 0.04172355f, -0.08445703f, 
    0.03573954f, -0.11387131f, 0.09227252f, 0.09617551f, 0.10048506f, -0.18540996f, 0.14346808f, 0.00284391f, 
    0.13131630f, 0.14953591f, -0.06884717f, 0.02051316f, -0.09226552f, -0.05632743f, -0.03697168f, 0.05223405f, 
    -0.04126522f, -0.06850618f, -0.03711966f, -0.05873526f, 0.02679270f, -0.15299103f, -0.13059449f, 0.02895377f, 
    -0.15556870f, -0.08357388f, 0.00333255f, -0.21818924f, -0.10079200f, 0.13257873f, 0.02114365f, -0.03440109f, 
    -0.27988708f, 0.22507408f, 0.11560699f, -0.04436219f, -0.13504376f, -0.10590751f, -0.21726814f, -0.02355933f, 
    0.19351652f, -0.06351092f, 0.36419147f, -0.09204759f, -0.20330794f, -0.07683194f, -0.13854830f, 0.06154168f, 
    0.15994319f, -0.05592196f, 0.08934557f, 0.17014389f, 0.30023032f, -0.12537844f, 0.00951278f, -0.01105460f, 
    0.06733383f, -0.02659271f, -0.26885751f, -0.28195485f, -0.00705902f, -0.04189424f, 0.09268350f, 0.03011784f, 
    -0.11767843f, 0.09976604f, -0.07481261f, 0.07316777f, 0.21506163f, 0.04468784f, -0.10172731f, 0.11113012f, 
    -0.11041485f, 0.09362039f, 0.06051642f, 0.09673076f, 0.17438869f, -0.11052420f, -0.08363076f, 0.08443566f, 
    0.11550988f, 0.08970450f, 0.13857886f, 0.01676266f, -0.10321858f, 0.38210183f, 0.08884683f, 0.12528069f, 
    0.00725658f, 0.14808761f, -0.08645051f, 0.14943506f, -0.21869501f, -0.11951910f, 0.42339391f, -0.13555278f, 
    -0.29184723f, 0.20929536f, -0.04462224f, 0.22117196f, 0.04330149f, 0.06130609f, -0.05670252f, -0.04120556f, 
    0.13651285f, -0.17903465f, -0.11780369f, -0.13752639f, -0.04309686f, -0.04815863f, 0.05921081f, 0.13228391f, 
    -0.35866854f, -0.02952546f, 0.09891296f, 0.15763842f, 0.17726909f, 0.06373528f, -0.12690330f, -0.03446378f, 
    0.19461928f, -0.09182482f, 0.01355222f, -0.22600217f, -0.11088336f, 0.03592848f, -0.20166193f, -0.03035720f, 
    -0.23106973f, 0.06251080f, -0.26356634f, -0.24980231f, -0.23474248f, 0.02134063f, 0.08521432f, 0.08521921f, 
    -0.01771278f, 0.22881803f, 0.16777539f, -0.12008681f, -0.25991642f, 0.22164743f, 0.00697849f, 0.09981072f, 
    0.06756052f, -0.00255603f, -0.17143981f, 0.04601646f, -0.00743938f, 0.20621482f, -0.53696233f, -0.09162937f, 
    -0.05866728f, -0.03626432f, 0.12150680f, -0.23453391f, 0.17346887f, -0.24867904f, -0.08379085f, 0.16199347f, 
    -0.25095436f, 0.15069798f, 0.06634796f, -0.01759275f, 0.11749370f, 0.13085721f, 0.10683946f, 0.03724134f, 
    0.14982435f, 0.11616004f, -0.02957371f, -0.01500373f, 0.15929675f, -0.01645239f, 0.05851758f, 0.36936674f, 
    -0.11971241f, -0.00839210f, -0.13399568f, -0.06679313f, 0.03770195f, -0.02481011f, 0.15368830f, 0.22111672f, 
    -0.53965634f, 0.04229559f, -0.13770525f, 0.16489816f, 0.22603324f, 0.09669013f, 0.05088000f, -0.03774732f, 
    0.02329798f, 0.04045877f, 0.13420951f, 0.04388928f, 0.13504156f, 0.06939434f, 0.06227883f, 0.10092345f, 
    -0.06583972f, 0.02463401f, -0.07107537f, 0.11206263f, 0.23464116f, 0.19675350f, -0.00378852f, -0.06905217f, 
    0.06318548f, 0.07052976f, -0.04178479f, -0.52158570f, -0.29735282f, -0.25238764f, -0.05296766f, 0.06918157f, 
    0.00562204f, 0.01722161f, 0.00643461f, -0.11477423f, -0.23351073f, -0.14002925f, 0.36121154f, 0.04131308f, 
    -0.01755661f, 0.05474702f, -0.09160405f, -0.02361059f, -0.11838794f, 0.27310902f, 0.20191236f, -0.38533252f, 
    0.08648489f, -0.09281133f, -0.14993775f, -0.03487413f, 0.03780302f, 0.07729428f, 0.23652771f, -0.15517198f, 
    -0.13682349f, -0.01797517f, 0.06794927f, 0.08691370f, -0.03341959f, -0.00892368f, 0.07677685f, -0.38615263f, 
    0.15338391f, 0.17882469f, -0.14413929f, 0.07914844f, -0.08764524f, 0.02285648f, -0.03410663f, -0.05394440f, 
    0.05357417f, 0.06672420f, -0.23200738f, 0.11306967f, -0.03183914f, -0.10359106f, -0.01042014f, 0.09104782f, 
    0.10803615f, -0.37673691f, -0.22656815f, 0.31633538f, 0.02700981f, -0.17209452f, 0.01363500f, -0.22603050f, 
    0.09233063f, 0.10650010f, 0.20644030f, 0.12729502f, 0.11229220f, -0.12237342f, -0.26032999f, -0.00949521f, 
    0.08748284f, -0.01733083f, -0.03547377f, -0.14829156f, 0.05039290f, 0.02775584f, -0.04118170f, 0.03460711f, 
    -0.12161009f, 0.00437219f, -0.09096161f, 0.13549244f, 0.15368877f, 0.21719262f, 0.12983447f, -0.05560078f, 
    0.18940918f, -0.10443944f, 0.10552300f, 0.17273512f, -0.04446227f, -0.17991230f, -0.00105325f, -0.32995000f, 
    0.01983886f, 0.03991320f, 0.02119488f, 0.12569715f, 0.06870607f, 0.14082085f, 0.04573495f, -0.09344190f, 
    -0.24428570f, 0.03375188f, -0.02692508f, -0.03749111f, -0.01634792f, -0.10175461f, 0.01647728f, -0.14135873f, 
    0.02161637f, 0.08631559f, 0.16363497f, -0.02314710f, 0.04236876f, -0.04014118f, -0.04462661f, -0.12755251f, 
    -0.23739070f, -0.02890587f, -0.24567632f, -0.06902716f, -0.11341622f, -0.18746601f, 0.10382783f, -0.11500862f, 
    0.08864687f, 0.08209490f, 0.24949305f, 0.18292774f, 0.15790969f, -0.10007143f, -0.02406810f, 0.07112742f, 
    0.09027826f, 0.06154444f, -0.19810399f, -0.13257562f, 0.07599650f, -0.06254350f, -0.15365021f, 0.07621867f, 
    0.15962771f, -0.21945827f, 0.02694640f, 0.13552509f, -0.03740711f, -0.13957199f, -0.08818676f, -0.10322713f, 
    0.02545552f, -0.09795951f, 0.07339905f, -0.14475861f, -0.33327931f, 0.01290292f, -0.24190189f, 0.22247878f, 
    0.23526126f, 0.14543243f, 0.11852997f, -0.07803051f, 0.10694595f, -0.36008313f, -0.03509181f, -0.49932876f, 
    -0.04095451f, -0.06307359f, 0.07223374f, 0.08328428f, -0.02107413f, -0.20298935f, -0.11377999f, 0.00269789f, 
    -0.00361150f, -0.08384383f, -0.13084504f, -0.03226998f, 0.10390286f, 0.10830145f, -0.00127174f, 0.03503926f, 
    0.01868461f, 0.05624544f, 0.09324842f, 0.10738617f, -0.20990339f, 0.22009663f, 0.15599358f, 0.02017979f, 
    -0.08307188f, 0.09805570f, 0.07378253f, 0.07685617f, 0.10312916f, 0.32327053f, -0.01996580f, 0.18518269f, 
    0.01697617f, -0.06437416f, 0.04981391f, 0.05795502f, 0.10859086f, -0.04085638f, 0.18752514f, 0.06808572f, 
    0.02171770f, -0.00523300f, 0.27531990f, -0.11331186f, -0.33070123f, 0.16126831f, -0.05622045f, -0.05255776f, 
    -0.08627568f, 0.01536695f, -0.09369101f, 0.01597145f, 0.02255869f, -0.29366851f, 0.01928070f, -0.07516181f, 
    0.17612992f, -0.02962722f, -0.05293268f, -0.15795738f, -0.10944525f, -0.32152009f, 0.26623899f, -0.05469282f, 
    0.02857580f, 0.05328421f, -0.02679979f, -0.26633418f, 0.12487803f, 0.19576788f, 0.10372758f, -0.13164715f, 
    0.05349888f, -0.11011487f, -0.09086448f, 0.20509522f, 0.03109081f, -0.02037274f, 0.02892229f, 0.30456874f, 
    0.09037500f, 0.20188868f, 0.17703035f, 0.01390972f, 0.05314799f, 0.15101050f, -0.08482330f, 0.24686393f, 
    -0.08359298f, -0.01713157f, 0.00084000f, 0.01711449f, 0.17844951f, 0.15520707f, -0.09882642f, 0.22685277f, 
    0.09444133f, 0.11794115f, -0.09043451f, -0.00114062f, 0.20735000f, 0.28101379f, 0.07535002f, 0.11780179f, 
    -0.13562119f, -0.14010437f, -0.06141203f, 0.23946810f, 0.15122887f, -0.01571951f, 0.07362146f, 0.19432992f, 
    0.16668855f, 0.22098494f, -0.06459532f, 0.09873323f, 0.02995897f, 0.09745634f, -0.04970030f, -0.03296512f, 
    0.18087284f, 0.05853088f, 0.18109533f, -0.07325061f, -0.05347354f, -0.20069779f, 0.14257272f, 0.19436346f, 
    -0.03563571f, -0.14812435f, -0.17065898f, -0.11463514f, -0.04639688f, 0.37763625f, -0.05767531f, 0.08418100f, 
    0.25716791f, -0.07632198f, 0.03074373f, -0.19065934f, -0.04496180f, -0.32808262f, -0.57934123f, -0.11320911f, 
    -0.27567703f, -0.03053840f, -0.12727965f, -0.12548749f, 0.16015567f, -0.05095128f, -0.28538600f, -0.05725657f, 
    0.18354265f, -0.03156566f, 0.04118806f, 0.01722462f, 0.06712315f, 0.05481479f, -0.03183345f, -0.48119691f, 
    -0.02958488f, -0.08040589f, 0.51295292f, -0.01680408f, 0.12475681f, -0.14080779f, 0.24193701f, -0.09166290f, 
    -0.05989709f, 0.10503167f, 0.08699687f, -0.32291290f, -0.08803437f, -0.03303711f, 0.13452113f, -0.12058218f, 
    0.20290890f, 0.22718911f, 0.17775752f, -0.29494309f, -0.27454981f, 0.25375703f, -0.14434882f, 0.22432342f, 
    0.01444617f, -0.09598370f, -0.28436482f, -0.14486425f, -0.09571709f, 0.07925853f, -0.04189892f, -0.21538939f, 
    0.11860234f, -0.04971195f, 0.13936119f, 0.12945266f, -0.02460556f, -0.22894780f, -0.06046319f, 0.03307971f, 
    0.03430008f, -0.17735203f, 0.06783891f, -0.09698724f, -0.67395294f, -0.31622803f, 0.01757074f, 0.20455565f, 
    0.16440366f, 0.06656291f, 0.07627695f, -0.00316687f, -0.00406121f, 0.17061105f, -0.11612450f, 0.06871700f, 
    -0.22345728f, -0.02470680f, 0.18164228f, -0.17576957f, -0.22397773f, 0.06868135f, -0.34142074f, 0.19846316f, 
    0.13714427f, -0.19368143f, 0.24838962f, -0.10021328f, -0.14318117f, -0.00257727f, 0.11605724f, -0.05528254f, 
    -0.05132186f, -0.39294446f, 0.06823533f, -0.22358826f, 0.13845946f, 0.05955127f, 0.05449346f, 0.07874776f, 
    -0.27533308f, -0.05177279f, 0.17805597f, 0.15540300f, -0.04005113f, -0.10205237f, 0.06048281f, 0.07254099f, 
    -0.00869452f, 0.08336498f, 0.05418092f, 0.04193645f, 0.07299844f, 0.11992583f, -0.27824196f, 0.15585135f, 
    0.02353746f, 0.01693555f, 0.15919541f, -0.14108680f, -0.05050867f, -0.01336492f, 0.18802841f, 0.12161015f, 
    0.12638767f, 0.28670946f, 0.03051044f, 0.09909612f, -0.04278981f, 0.24529891f, -0.16222866f, 0.33665487f, 
    -0.17319351f, 0.09141194f, 0.06978694f, 0.07811049f, -0.05843133f, 0.05332675f, 0.00855532f, 0.04804201f, 
    0.16462789f, 0.11573099f, -0.09854843f, -0.02556597f, -0.17866540f, -0.44583160f, 0.00190099f, -0.11762773f, 
    0.17616935f, 0.18240541f, 0.02744105f, -0.16743711f, -0.19200614f, -0.28079835f, 0.06012237f, -0.20715094f, 
    -0.16907175f, -0.17507797f, 0.08445932f, -0.08955582f, 0.05002342f, -0.03058247f, 0.00109554f, -0.11268187f, 
    0.15224953f, 0.10777590f, 0.14202857f, 0.20445906f, -0.25555521f, -0.06284761f, 0.07329603f, -0.11738364f, 
    -0.03145144f, -0.00252407f, -0.05993878f, 0.02956053f, 0.00422821f, -0.05890577f, -0.06304093f, -0.02339524f, 
    0.02165972f, 0.05240769f, -0.02224865f, 0.02160242f, 0.00895111f, -0.03376497f, -0.03622385f, -0.03878858f, 
    -0.01404017f, 0.01096840f, -0.04155768f, 0.01421370f, -0.03587523f, 0.01398542f, -0.03988703f, 0.02098295f, 
    0.05144976f, -0.04890330f, -0.00612810f, 0.00611499f, 0.00402021f, -0.02399803f, 0.01251266f, 0.00611354f, 
    -0.01377013f, 0.02459836f, 0.01846969f, 0.02846977f, 0.04932102f, -0.02842827f, -0.05077858f, 0.03098218f, 
    -0.04939894f, 0.04762564f, 0.04392394f, 0.03248370f, 0.00234946f, 0.01343482f, 0.02734308f, -0.03417297f, 
    0.00921958f, -0.05361908f, -0.01695992f, -0.03444774f, -0.01549285f, -0.02739333f, 0.04117667f, -0.05212752f, 
    0.03674479f, -0.04728976f, -0.02629668f, -0.02945845f, -0.05510284f, 0.00249499f, 0.03075402f, 0.01912401f, 
    -0.05108486f, 0.01807475f, -0.06322774f, 0.05198239f, 0.02022740f, 0.02785252f, -0.02452261f, 0.01361811f, 
    0.03983371f, -0.05733147f, -0.00214903f, -0.01746420f, -0.05724229f, -0.02601841f, 0.00601016f, 0.01483040f, 
    -0.03289317f, -0.01333846f, 0.01653347f, -0.01245243f, 0.01587278f, -0.01452375f, 0.01557385f, 0.04162765f, 
    -0.04597905f, -0.01195781f, -0.02266617f, 0.04445239f, 0.01174668f, 0.00567521f, -0.00597479f, -0.01647699f, 
    -0.03388568f, 0.02415547f, -0.01062897f, 0.02230912f, 0.01336850f, 0.02240123f, -0.04970096f, 0.00128845f, 
    -0.04340208f, 0.03906512f, 0.03829305f, -0.00963101f, -0.01322211f, 0.02483108f, -0.00270138f, -0.00806650f, 
    -0.03587731f, -0.05591777f, -0.01226796f, -0.00894628f, 0.03939638f, 0.04004363f, -0.00668367f, 0.02918806f, 
    0.03791055f, -0.05509827f, 0.04844201f, -0.01429498f, -0.06171718f, -0.03437698f, -0.01963373f, 0.03362997f, 
    -0.02477037f, 0.04809580f, -0.02014030f, 0.04645823f, -0.03742261f, -0.02473912f, -0.00941319f, 0.02026216f, 
    0.03730306f, -0.04252996f, -0.02543759f, -0.05195431f, 0.02985866f, 0.05489818f, 0.05211913f, -0.06456982f, 
    0.00622103f, -0.02536650f, 0.01610995f, 0.03587456f, 0.02031399f, 0.04155951f, 0.03404446f, -0.00932153f, 
    -0.06312829f, 0.04105945f, -0.00239910f, 0.01656777f, 0.05573196f, 0.01451784f, 0.00993156f, 0.02900811f, 
    0.05611167f, -0.00086080f, -0.03552682f, -0.04308743f, 0.04514506f, 0.00342622f, -0.03126679f, -0.01900622f, 
    0.05817243f, 0.02225509f, 0.04779345f, 0.02003286f, -0.01073354f, -0.01044399f, -0.02569588f, -0.04162775f, 
    0.05514009f, -0.03250115f, -0.02035635f, 0.04950607f, 0.03671867f, -0.03987943f, 0.02004092f, -0.01097203f, 
    -0.03090959f, -0.00152402f, -0.02198733f, -0.05109761f, -0.00704522f, -0.05927111f, -0.05181466f, 0.02146789f, 
    0.04179599f, -0.04053999f, 0.01501885f, -0.02369858f, -0.05803330f, -0.01100548f, -0.05181566f, 0.04262466f, 
    0.04445091f, -0.03785387f, -0.05470789f, -0.03828533f, -0.06446397f, -0.02313782f, 0.04298083f, 0.01150255f, 
    0.04394655f, 0.01861805f, -0.03578751f, -0.03651472f, 0.01733453f, -0.03927557f, -0.04411289f, 0.05192336f, 
    -0.00789917f, -0.03113528f, 0.04905873f, -0.05929884f, -0.01891832f, -0.05376352f, -0.04200714f, 0.01448746f, 
    -0.03655753f, -0.02557116f, -0.02650427f, -0.01509921f, -0.00284476f, -0.00717261f, -0.00557910f, -0.05219443f, 
    -0.04066331f, -0.00002145f, -0.05458511f, -0.02082916f, 0.00631265f, 0.00324311f, -0.00686850f, -0.01698591f, 
    -0.00136399f, 0.03004482f, 0.02926266f, -0.05300720f, 0.03095294f, -0.04644775f, -0.02919231f, 0.03856725f, 
    0.00872375f, -0.04752186f, -0.03150038f, -0.03002084f, 0.03231969f, -0.06094928f, 0.04258022f, -0.04136033f, 
    -0.06053856f, -0.04160419f, -0.06152286f, -0.00680248f, -0.02737597f, 0.00983542f, -0.01718189f, 0.02630347f, 
    -0.02567027f, -0.02450712f, -0.01668655f, -0.02562537f, 0.03002297f, 0.03139445f, -0.02806849f, -0.05240889f, 
    -0.03666347f, -0.02522317f, -0.01326319f, -0.05553402f, 0.00781147f, -0.00704450f, 0.03491587f, -0.01520492f, 
    -0.01478809f, -0.01987500f, 0.00869901f, -0.05379464f, -0.06108363f, -0.02762279f, -0.00702879f, -0.05602384f, 
    -0.51292396f, -0.33089122f, 0.24695154f, 0.05904222f, -0.15375091f, 0.03084978f, 0.00607688f, 0.04941230f, 
    0.04149787f, 0.37922898f, 0.11214972f, -0.02278367f, 0.07499330f, -0.29802543f, 0.03740138f, 0.06721103f, 
    0.10037442f, -0.02912821f, 0.08064546f, 0.13454558f, -0.25491267f, -0.01118633f, 0.13428973f, 0.15008493f, 
    0.04125547f, 0.08029661f, -0.02052902f, 0.10239899f, 0.34524629f, -0.03306722f, 0.05840562f, 0.03602952f, 
    0.07829968f, 0.08089104f, -0.02655257f, 0.00438742f, -0.30255291f, -0.05572015f, -0.05209169f, -0.05212694f, 
    -0.01254211f, 0.05962613f, 0.01156593f, 0.07424866f, 0.05698241f, 0.16198914f, 0.12373699f, 0.16750218f, 
    -0.02887630f, 0.01288415f, 0.12121585f, 0.00712954f, 0.10923523f, 0.20920165f, 0.24777752f, -0.27988660f, 
    0.05498599f, 0.05576859f, 0.00054181f, -0.09191486f, 0.03855033f, -0.07612328f, -0.20002343f, 0.07889933f, 
    -0.33149794f, -0.17213896f, 0.06696673f, 0.17351304f, -0.07006321f, 0.15155560f, -0.06146072f, 0.09324342f, 
    -0.07105077f, 0.02400285f, -0.04672804f, 0.02382928f, -0.13502274f, -0.04840870f, -0.22805016f, -0.08231682f, 
    -0.05157926f, -0.17451856f, -0.13422561f, -0.09291848f, 0.02647929f, 0.02438205f, 0.05815393f, 0.06554621f, 
    0.09824062f, -0.12592188f, -0.28376129f, -0.24737269f, -0.10763927f, -0.00120969f, 0.11495944f, 0.08933853f, 
    -0.10073730f, -0.06485763f, -0.02120676f, 0.45013306f, -0.00434946f, -0.22428890f, 0.05980301f, 0.07397126f, 
    -0.10161109f, 0.04266044f, 0.01960581f, -0.14119068f, 0.14023143f, 0.14135310f, 0.25897908f, -0.06307168f, 
    0.00112511f, 0.14634551f, -0.02892504f, 0.08943639f, -0.01170851f, -0.03329046f, 0.17079467f, -0.39224759f, 
    -0.10563332f, -0.13305588f, -0.08926215f, 0.03488809f, 0.08039498f, 0.10970743f, 0.13588482f, -0.20158587f, 
    -0.10227300f, -0.19170983f, -0.22922726f, 0.07613003f, 0.05853616f, -0.03185998f, 0.07396483f, -0.07156929f, 
    -0.03380359f, 0.09133803f, 0.18672532f, -0.13256092f, -0.07456346f, -0.02789247f, 0.20493734f, -0.15519808f, 
    0.08213469f, 0.11048693f, -0.26246727f, 0.02322778f, 0.20722263f, -0.14092685f, -0.14625572f, 0.01317898f, 
    0.10712475f, -0.00782427f, 0.28003401f, -0.06811290f, -0.17196026f, -0.14917538f, 0.07577535f, 0.01059859f, 
    -0.11544617f, 0.01828316f, -0.01393966f, 0.06612248f, 0.10551593f, 0.02700809f, -0.09184907f, 0.13070345f, 
    0.01481565f, 0.32046032f, 0.11439861f, 0.04238871f, -0.08242112f, 0.14080591f, -0.05747240f, 0.02326022f, 
    0.00908504f, 0.24316543f, -0.07851448f, -0.08001214f, 0.11321107f, -0.26655599f, -0.08247721f, -0.02764500f, 
    0.07018890f, -0.01795265f, -0.04005792f, 0.15663581f, 0.12845382f, 0.03670854f, 0.05218662f, -0.19743460f, 
    0.07577465f, 0.03407510f, 0.02149073f, -0.24353887f, 0.08223682f, -0.01929803f, -0.68879473f, -0.16780411f, 
    -0.03797783f, 0.08761518f, 0.24678352f, 0.10515464f, -0.04447303f, 0.03216428f, -0.08345480f, -0.03224557f, 
    0.12358578f, 0.07586379f, -0.19581392f, -0.03982237f, -0.04474071f, -0.15839934f, 0.04287395f, -0.06307637f, 
    0.29814276f, -0.00387905f, -0.07974216f, 0.12634563f, -0.02276980f, -0.03703349f, 0.13276277f, 0.03897936f, 
    0.05963037f, -0.54996550f, -0.13364634f, 0.07245050f, -0.16531010f, -0.06551187f, 0.00140631f, 0.03609355f, 
    -0.05076859f, 0.00754770f, 0.17730674f, -0.03624178f, 0.14408407f, -0.01983029f, -0.19895710f, 0.05624701f, 
    0.08953748f, 0.09320656f, 0.06576455f, -0.26738945f, -0.14708892f, -0.30553630f, 0.08346872f, -0.13171913f, 
    -0.02109536f, 0.10403460f, 0.06097019f, -0.00174851f, -0.14141226f, 0.08220519f, 0.16509403f, -0.02052881f, 
    0.19116911f, -0.04722726f, -0.00005680f, 0.03667144f, -0.01687682f, -0.09182929f, 0.07370222f, -0.01396892f, 
    0.02563755f, 0.02406551f, -0.02375402f, 0.05812403f, -0.15781392f, -0.04729550f, 0.05330459f, 0.00413244f, 
    0.19826290f, 0.01968122f, 0.10330987f, -0.10792031f, -0.06655995f, 0.09783274f, -0.09130005f, -0.03471674f, 
    -0.35580507f, -0.12171366f, 0.09152108f, 0.14682229f, -0.16039915f, 0.03624459f, -0.05713546f, 0.05119720f, 
    0.16276181f, -0.05923040f, -0.00292420f, -0.10218301f, 0.11050005f, -0.05909798f, -0.00728311f, 0.07608967f, 
    -0.04441601f, 0.25332230f, 0.26172262f, 0.21051748f, -0.16325487f, -0.01908971f, -0.00548789f, 0.08645602f, 
    -0.05673676f, -0.01420944f, 0.00934195f, -0.11269568f, 0.14360401f, -0.08911180f, 0.01888545f, -0.06436704f, 
    0.09282763f, 0.09873103f, 0.10923423f, -0.29719275f, 0.02223814f, 0.16715989f, 0.17763852f, 0.07287952f, 
    0.02926650f, 0.33700785f, -0.03513384f, 0.11637621f, -0.28910756f, 0.24907190f, -0.13988951f, -0.08369704f, 
    0.08931032f, -0.17966822f, -0.23890556f, 0.04636996f, 0.08781567f, -0.00516540f, -0.02811685f, -0.05209964f, 
    0.14009637f, 0.06573524f, 0.13356952f, -0.12249464f, -0.17098872f, 0.19921571f, 0.33590013f, 0.10666643f, 
    0.02433631f, 0.09743353f, -0.02664326f, 0.07096522f, 0.05695048f, -0.03465397f, 0.06746718f, 0.02237391f, 
    0.00149657f, -0.12248289f, -0.08067214f, -0.12466680f, 0.06354430f, 0.13943836f, 0.12673706f, -0.19025621f, 
    -0.14513268f, -0.12086413f, 0.19388485f, 0.11876927f, -0.03396833f, 0.12014495f, -0.00107113f, -0.01736788f, 
    -0.06477262f, -0.09885658f, 0.08776505f, -0.03601074f, -0.12777033f, -0.00177353f, -0.06894463f, -0.00181976f, 
    0.01980658f, 0.04430113f, -0.30549029f, -0.02878391f, -0.09197721f, -0.07713778f, 0.08930790f, -0.06973976f, 
    -0.00319718f, -0.01519904f, -0.06988037f, 0.28163895f, -0.14071591f, -0.25713986f, -0.02631854f, -0.05745282f, 
    0.07572220f, 0.10009035f, -0.01406056f, 0.26812702f, -0.17820998f, 0.15283482f, 0.14788622f, 0.17375150f, 
    0.02043959f, 0.10939598f, -0.08811846f, -0.11521322f, 0.06012790f, -0.25735483f, 0.02329882f, 0.23165718f, 
    -0.00242316f, -0.25011522f, 0.03178446f, 0.23846897f, 0.20709634f, -0.17265151f, 0.26311842f, -0.15755770f, 
    -0.21263461f, 0.01799832f, -0.11642848f, 0.03860686f, 0.00957908f, 0.19863832f, -0.16689643f, -0.00402627f, 
    0.04607482f, 0.12622285f, 0.12485723f, -0.06168392f, -0.06640937f, 0.12072289f, 0.02874605f, 0.03885435f, 
    -0.16430612f, 0.08276383f, 0.12600155f, -0.11721580f, 0.05195136f, -0.30822319f, -0.08614694f, -0.05392259f, 
    0.14053863f, -0.35548952f, 0.06152980f, -0.01646249f, 0.16244489f, 0.12446041f, 0.02943718f, 0.30560929f, 
    0.05909176f, -0.03311154f, 0.10240272f, 0.06180423f, -0.13897733f, 0.14225383f, 0.13582093f, -0.04118263f, 
    -0.03303484f, -0.11672005f, -0.12416838f, 0.18310043f, -0.09869017f, 0.01698582f, -0.04848568f, 0.12731831f, 
    -0.07870550f, 0.01923715f, 0.06195892f, -0.03048805f, 0.11454421f, 0.10706488f, -0.23357193f, -0.05487917f, 
    0.08840731f, 0.06702445f, -0.00887085f, -0.07562527f, -0.15927322f, -0.20330061f, -0.00048015f, 0.07638621f, 
    -0.23276615f, -0.04944503f, -0.09068904f, 0.01705045f, -0.07841816f, 0.08380388f, -0.20195913f, 0.05052930f, 
    -0.23201044f, 0.00543013f, -0.03546696f, 0.04491846f, 0.13459703f, -0.00569306f, -0.05062112f, 0.10981552f, 
    0.12328892f, -0.15534167f, -0.31085113f, 0.16691071f, -0.13817818f, -0.01750032f, -0.05120728f, 0.01314240f, 
    0.08624178f, -0.02409402f, -0.12273683f, 0.02298505f, 0.13154300f, -0.06605495f, 0.00669819f, 0.10774245f, 
    -0.17252474f, -0.29041710f, 0.05139634f, 0.07448498f, 0.21927497f, 0.10534184f, 0.14305942f, 0.19944765f, 
    -0.02363151f, -0.19656065f, -0.02251048f, 0.13652627f, 0.10766782f, 0.02576646f, -0.08193780f, 0.20510729f, 
    -0.04473085f, -0.03575424f, 0.10752099f, 0.28775138f, 0.17368218f, -0.08066476f, 0.01686099f, -0.05287859f, 
    0.23502515f, 0.06761264f, 0.00376443f, -0.05914351f, 0.19251595f, -0.09849943f, -0.12192575f, -0.29451835f, 
    -0.06756454f, -0.10238936f, -0.11730980f, -0.05805083f, 0.10017528f, 0.31416053f, -0.04829419f, 0.20822357f, 
    0.09641184f, 0.05776092f, -0.17449339f, -0.06611747f, -0.02067820f, 0.07144175f, 0.28981829f, -0.03248127f, 
    0.21101888f, -0.03577005f, -0.09315345f, 0.06362735f, 0.02464678f, 0.02079454f, -0.07710859f, 0.11272217f, 
    -0.03631743f, 0.09079430f, -0.13356830f, -0.02865754f, 0.21414390f, 0.02664276f, -0.08406123f, 0.08178338f, 
    -0.14935398f, 0.25287390f, 0.19862677f, -0.14592609f, 0.16369134f, 0.16859069f, -0.02271230f, 0.02361129f, 
    0.08329585f, -0.09558094f, -0.33255893f, 0.08710058f, -0.12946928f, 0.14080496f, 0.16776554f, -0.05248231f, 
    0.05349750f, -0.15405986f, -0.23704880f, 0.00992801f, 0.02737786f, 0.10817623f, -0.12720557f, 0.04986461f, 
    0.04062856f, 0.11624052f, 0.11914151f, 0.20501496f, -0.45815995f, -0.01391899f, 0.15959114f, -0.00147152f, 
    -0.00915449f, 0.08472398f, 0.14880772f, 0.16857325f, 0.33714184f, 0.08993879f, -0.17266652f, 0.06117766f, 
    0.08653226f, -0.08173916f, -0.15890081f, -0.05636119f, -0.27769214f, 0.48544237f, 0.17533311f, -0.06310049f, 
    -0.00343771f, 0.11915904f, -0.00858809f, 0.06028420f, -0.07863417f, 0.11968493f, 0.11502398f, 0.00962820f, 
    -0.18322070f, 0.00484688f, 0.08419461f, -0.09678075f, 0.00770411f, 0.07001054f, -0.02168710f, 0.10924271f, 
    -0.00691367f, -0.27456978f, 0.10321473f, -0.15312438f, -0.00475071f, 0.00441895f, -0.08325277f, -0.15544002f, 
    -0.22086419f, -0.00925167f, -0.13488379f, 0.15707265f, -0.11143815f, 0.08766801f, -0.06938446f, 0.01670116f, 
    0.00271513f, -0.04775026f, 0.26072651f, 0.02482568f, -0.08042837f, -0.00157388f, -0.06602383f, -0.06257074f, 
    0.04860430f, 0.02464085f, -0.08198448f, 0.06531999f, -0.02096146f, 0.05572668f, -0.09897283f, 0.13393688f, 
    0.01791803f, 0.03158526f, 0.05264416f, 0.25424543f, -0.38207754f, -0.38491327f, -0.09016573f, 0.11790245f, 
    -0.01221950f, 0.28387100f, 0.06006036f, 0.02387601f, 0.19872430f, 0.14548862f, 0.05038870f, 0.13308769f, 
    -0.12602992f, -0.16373456f, 0.05948092f, 0.04264893f, 0.11820089f, 0.25153789f, -0.44152325f, 0.15745610f, 
    -0.22790287f, -0.11030316f, 0.07716259f, -0.18033080f, 0.08216291f, 0.01452648f, -0.08495867f, -0.20175681f, 
    0.06890458f, -0.03985540f, -0.00612468f, -0.05691935f, -0.13277456f, -0.01980769f, -0.05529506f, 0.54541677f, 
    -0.09231187f, 0.10891089f, -0.08449049f, 0.17711443f, 0.16087328f, -0.06529251f, -0.04220699f, 0.02695275f, 
    -0.28903240f, -0.10987857f, 0.35928023f, -0.10163005f, 0.01208626f, -0.05967347f, -0.08573764f, 0.03956863f, 
    0.22523412f, 0.11944360f, -0.06689589f, 0.03592503f, 0.14787094f, 0.11858249f, -0.13126837f, -0.07153293f, 
    0.01385897f, -0.30448359f, -0.01015110f, -0.27379212f, 0.02964360f, -0.21129285f, -0.06994477f, -0.16951181f, 
    0.06497200f, 0.02923435f, -0.00652729f, -0.27912259f, -0.25316980f, 0.18198256f, 0.12561184f, 0.04395036f, 
    0.10897382f, -0.16117276f, 0.08306869f, -0.05822576f, -0.48357561f, 0.08385186f, 0.11557763f, 0.00225288f, 
    0.08676082f, 0.01177467f, 0.08628835f, -0.04511162f, -0.13701740f, -0.20552824f, -0.08425205f, -0.17383453f, 
    0.02442523f, 0.02904184f, 0.05153210f, -0.05024961f, 0.09285781f, -0.04951703f, 0.19997011f, 0.29976267f, 
    -0.06279369f, -0.10090345f, -0.06679354f, 0.03641374f, -0.06417982f, -0.01673118f, -0.11314330f, -0.24399437f, 
    0.04587723f, -0.02722827f, 0.12732926f, 0.16505980f, 0.11721519f, -0.15304792f, 0.04813356f, -0.00130692f, 
    0.32849529f, 0.12140105f, -0.04697722f, -0.19001648f, 0.20310786f, -0.09625261f, 0.02098984f, -0.02848762f, 
    -0.27306378f, -0.12745652f, -0.01149502f, 0.23577861f, -0.00127080f, -0.03485710f, 0.04861309f, -0.19784427f, 
    -0.03398323f, 0.05007106f, -0.12378942f, 0.04471989f, -0.18582836f, -0.00015732f, 0.07103083f, -0.02247002f, 
    0.00901457f, 0.06902052f, 0.07227636f, -0.27313530f, -0.12078848f, 0.24278735f, 0.09497873f, 0.06158732f, 
    0.04352625f, 0.08472059f, 0.11274720f, 0.02018728f, 0.39469835f, -0.14310552f, -0.21224310f, -0.04223427f, 
    -0.01527209f, -0.01506237f, 0.10067981f, 0.03605468f, 0.11692338f, -0.10023254f, 0.01104691f, -0.49534443f, 
    0.07165294f, 0.07881087f, 0.28180408f, -0.11172581f, 0.00645427f, -0.12348232f, -0.54865533f, -0.18402529f, 
    -0.13575646f, 0.10506716f, 0.07049717f, -0.02993044f, 0.02089980f, 0.07482227f, 0.16664177f, -0.12554991f, 
    0.17768423f, -0.17801094f, 0.25537041f, -0.26706666f, 0.06826799f, 0.09991290f, -0.04140970f, 0.06607604f, 
    0.34821951f, 0.09972210f, -0.08146247f, 0.19636790f, 0.36840686f, 0.08902599f, 0.02117005f, 0.13224776f, 
    -0.09893616f, 0.20219241f, -0.22311158f, -0.06374842f, 0.12136695f, -0.03099814f, 0.02658954f, -0.06147695f, 
    -0.03298226f, -0.04382378f, 0.20615271f, 0.15237123f, -0.14666705f, 0.13774769f, 0.13490626f, -0.03231764f, 
    0.11837851f, 0.14953123f, 0.15305308f, -0.08318631f, 0.11036983f, 0.11683071f, -0.14414015f, -0.25381374f, 
    0.16598754f, -0.35068142f, 0.09866983f, 0.15738384f, 0.02795443f, 0.19596979f, -0.02926642f, 0.03676749f, 
    -0.24813454f, -0.20023490f, 0.10773516f, 0.26793033f, -0.12376267f, 0.10821848f, 0.01546542f, 0.24287872f, 
    -0.24497500f, 0.17425525f, -0.08896845f, -0.01980320f, 0.01649367f, 0.03464253f, -0.05128760f, -0.28220195f, 
    0.00801796f, -0.01338450f, 0.04547430f, 0.15404794f, -0.13498746f, 0.13758802f, -0.03808457f, -0.34001341f, 
    0.03527925f, -0.00083188f, -0.05027572f, 0.12016123f, -0.00912774f, 0.00442655f, 0.05808288f, -0.27610371f, 
    -0.03834852f, 0.27580243f, 0.19332959f, -0.01327031f, -0.08975605f, -0.00621102f, 0.13501677f, 0.03533070f, 
    0.15621395f, -0.08722522f, -0.42088178f, 0.03788410f, 0.33972260f, 0.37327698f, 0.14288624f, 0.19224039f, 
    0.09083235f, -0.23597871f, 0.15416528f, -0.22810589f, 0.10582539f, 0.34774703f, 0.24947470f, 0.05718911f, 
    0.09131116f, 0.04425277f, -0.16193408f, 0.39465982f, -0.07048550f, 0.06894904f, -0.26173636f, -0.03649781f, 
    -0.11662973f, -0.03334177f, -0.02168958f, -0.10305315f, 0.03144015f, -0.11598175f, 0.04381383f, -0.35119689f, 
    -0.07307100f, -0.05601946f, -0.09180457f, -0.01974670f, 0.13089558f, 0.15452839f, -0.16305418f, -0.00747890f, 
    0.12512466f, 0.06118346f, 0.03512107f, -0.25030068f, 0.06347148f, -0.28376490f, 0.36352468f, 0.19857861f, 
    -0.26174405f, -0.12460600f, 0.01714596f, 0.07167254f, -0.00156636f, -0.16651003f, -0.17624219f, -0.13174608f, 
    -0.10599996f, 0.01408554f, -0.14040299f, -0.20405099f, -0.08110613f, 0.08637084f, -0.00238503f, 0.03197844f, 
    0.59390509f, 0.14848810f, 0.13130672f, 0.28796643f, -0.10574437f, -0.16707262f, 0.13177994f, 0.06062604f, 
    0.06174569f, 0.22938575f, 0.07706152f, -0.10487172f, -0.00781372f, 0.06722005f, -0.16173197f, -0.12664722f, 
    -0.15023066f, 0.20671146f, 0.15781313f, -0.00054964f, -0.05266513f, 0.03235861f, 0.07012875f, 0.00592660f, 
    0.29867044f, 0.08919267f, -0.23365834f, -0.40580580f, 0.21553575f, -0.03189925f, -0.12305745f, -0.02678373f, 
    -0.13713723f, 0.08960712f, 0.15013531f, 0.08714934f, -0.18049686f, 0.23641251f, -0.15440577f, 0.06081855f, 
    0.13224535f, 0.14797963f, -0.00441615f, -0.12232267f, -0.29008317f, 0.51323897f, 0.24588193f, 0.00638114f, 
    0.20454986f, 0.06974914f, -0.07161944f, 0.18033244f, 0.01350593f, 0.14112648f, -0.04122079f, 0.34166402f, 
    0.00795054f, 0.14504792f, 0.03149687f, 0.12938452f, 0.13274212f, -0.11911696f, 0.14221503f, 0.17285837f, 
    0.09464686f, -0.02464530f, 0.12897842f, 0.14085615f, 0.10317661f, 0.27049571f, 0.14628363f, 0.16708601f, 
    0.34197354f, -0.06694477f, -0.22208595f, -0.01998762f, -0.21747221f, 0.01855014f, -0.11119653f, -0.13615555f, 
    -0.36194572f, -0.07756992f, -0.33832738f, -0.20218194f, 0.38715786f, 0.24279048f, 0.22448091f, 0.13887654f, 
    0.06730784f, -0.07282044f, 0.09223513f, -0.18160699f, 0.10039797f, 0.08820579f, -0.00529947f, 0.11331772f, 
    0.00109599f, 0.09706247f, 0.02453116f, -0.46898270f, -0.13076670f, -0.32406464f, 0.06040796f, 0.09830776f, 
    0.28706428f, 0.12701327f, 0.21816787f, -0.02246430f, -0.07704728f, 0.26491559f, 0.02739483f, 0.27371281f, 
    0.09150996f, 0.06419762f, 0.07879618f, 0.16241080f, 0.26997861f, -0.07932013f, -0.00931479f, -0.08775035f, 
    -0.34271201f, -0.17966762f, -0.08132545f, 0.08572394f, 0.11652732f, -0.01604689f, 0.21817176f, 0.06377437f, 
    0.25905901f, -0.08583650f, -0.05455764f, 0.03365665f, 0.23829879f, 0.02183753f, -0.16269453f, -0.10173582f, 
    -0.05046654f, -0.04095368f, -0.09384897f, 0.16431212f, 0.21090995f, 0.02638156f, 0.09017716f, -0.15606393f, 
    -0.04737980f, -0.05165102f, -0.05812382f, 0.05073737f, 0.02246745f, -0.00450955f, -0.06239300f, -0.05381659f, 
    -0.02326800f, -0.06163095f, 0.04353767f, 0.01420016f, -0.02968719f, -0.02428961f, -0.04866042f, -0.03664245f, 
    0.01767589f, -0.01141746f, 0.02753822f, -0.02041991f, 0.01786789f, -0.05289556f, 0.01114152f, 0.00399657f, 
    -0.03244301f, -0.03936563f, 0.01012584f, 0.03283827f, -0.02904757f, -0.01361778f, 0.00634040f, 0.02117910f, 
    0.03011924f, -0.03621395f, 0.00120476f, -0.01700464f, -0.06258351f, 0.03244096f, 0.01885984f, -0.03803280f, 
    0.03595725f, -0.01620578f, 0.00656584f, 0.02216421f, -0.06188434f, -0.04947767f, 0.00901165f, 0.04333502f, 
    -0.01754172f, -0.01705004f, -0.05197927f, 0.02434891f, 0.01174758f, 0.02655178f, 0.01112791f, -0.01889210f, 
    -0.04420160f, -0.00486904f, -0.01800893f, -0.05757334f, -0.00838089f, -0.06079708f, 0.03855190f, -0.02900799f, 
    -0.00046227f, -0.01642157f, 0.01343551f, -0.00839146f, -0.02904769f, -0.03330906f, 0.02255556f, 0.04008365f, 
    -0.04495716f, -0.01926950f, -0.06458271f, -0.02996946f, -0.03753304f, -0.04653261f, -0.03259226f, -0.02369921f, 
    -0.04769320f, -0.00274614f, -0.00592684f, -0.01547265f, -0.04806030f, -0.00960057f, -0.04438891f, 0.02377078f, 
    0.03500503f, 0.02377431f, 0.01332063f, 0.04438336f, 0.03054645f, 0.02847727f, 0.00724725f, -0.04368415f, 
    -0.01340653f, 0.02093685f, 0.02136509f, 0.01299863f, 0.05133282f, -0.05212479f, -0.03621439f, 0.01714346f, 
    0.00715945f, 0.00301605f, -0.02078431f, -0.02359783f, -0.01047151f, -0.05282360f, 0.02024421f, 0.02040511f, 
    -0.04322942f, 0.00091353f, 0.02642544f, -0.03044152f, -0.04206268f, 0.02766085f, -0.02042814f, -0.05113429f, 
    -0.05116183f, -0.02591962f, -0.03249074f, -0.01515425f, -0.00628832f, 0.01180704f, -0.05447820f, -0.02903420f, 
    -0.02833291f, -0.01590966f, -0.03395944f, 0.02996477f, -0.06170802f, -0.03460556f, 0.03923537f, 0.04707767f, 
    -0.00133085f, -0.02170781f, -0.01761671f, -0.02944016f, 0.04832846f, -0.02907255f, 0.01043824f, -0.03870287f, 
    -0.03770747f, -0.00461547f, -0.00586317f, -0.03330269f, -0.03954924f, -0.04226558f, -0.02854204f, -0.02962791f, 
    0.04714182f, 0.04491864f, -0.01827602f, -0.00095526f, 0.01917662f, -0.01901962f, -0.05100580f, -0.01394016f, 
    -0.01594198f, 0.04521455f, 0.02189479f, -0.04106223f, -0.02448465f, 0.04218087f, -0.04439196f, -0.02072288f, 
    0.02712794f, -0.02035245f, 0.04580149f, 0.04403701f, -0.00099562f, -0.03793089f, 0.04912769f, -0.06024794f, 
    0.03204567f, -0.02790513f, 0.03435525f, 0.00394010f, -0.01903148f, -0.05101227f, -0.02514481f, 0.05159536f, 
    0.00254354f, 0.03045294f, -0.04885522f, 0.00599906f, -0.01421521f, 0.02079995f, -0.01583973f, 0.04436123f, 
    -0.03281030f, -0.04250266f, 0.02774658f, -0.03338394f, -0.05984795f, -0.02840330f, -0.01276611f, 0.00263797f, 
    0.04074600f, -0.01631960f, 0.03213974f, 0.05033577f, -0.01966980f, -0.01422194f, -0.05037554f, -0.01086349f, 
    0.02339279f, -0.03334494f, 0.03759231f, 0.03798793f, -0.05014145f, 0.04168689f, -0.05245314f, 0.04654607f, 
    -0.04974532f, 0.05262176f, 0.04653485f, -0.02895630f, -0.04750163f, 0.03267867f, -0.03469427f, -0.05360952f, 
    -0.04195072f, 0.01483898f, -0.04734141f, -0.00260690f, -0.05214876f, 0.03445073f, 0.04009223f, 0.04208581f, 
    -0.02922119f, -0.04315921f, 0.00703725f, -0.05515942f, -0.05985931f, 0.02504273f, 0.00600008f, -0.00369633f, 
    -0.02457145f, -0.03556503f, 0.01734522f, 0.00171468f, -0.02485223f, 0.02717412f, -0.05356883f, -0.04233981f, 
    -0.03000681f, -0.04797900f, -0.00116285f, 0.00401241f, -0.02765747f, 0.00868089f, 0.00550099f, -0.01939952f, 
    -0.01666978f, -0.03594564f, 0.03402176f, -0.05704511f, 0.03937787f, 0.03025253f, 0.01084448f, 0.02590736f, 
    0.01286433f, -0.04288332f, -0.00298501f, 0.00701009f, -0.04576979f, 0.00390044f, 0.01904373f, 0.04098326f, 
    -0.01663568f, -0.01270089f, 0.02152464f, -0.00838956f, 0.01093255f, 0.05255532f, -0.03776971f, 0.00377702f, 
    -0.06490583f, -0.01307114f, 0.02710544f, -0.00053571f, 0.00715179f, 0.04501874f, 0.01055311f, -0.03698418f, 
    -0.00899041f, -0.00220188f, -0.06169040f, -0.00096629f, 0.00682433f, 0.00829174f, 0.01690752f, -0.07868724f, 
    -0.03838982f, -0.05213528f, -0.03549017f, 0.01087458f, -0.00023275f, 0.02495811f, -0.00535387f, -0.05221555f, 
    -0.04066398f, -0.01035948f, -0.08804791f, -0.02779407f, -0.03638748f, -0.02867203f, -0.04182305f, -0.08243094f, 
    -0.01449033f, -0.00221328f, 0.00887893f, -0.03072252f, -0.03620940f, -0.00026510f, -0.03866953f, -0.01578015f, 
    -0.07861198f, 0.01786992f, 0.00106490f, 0.00932136f, -0.07822990f, -0.00164744f, 0.00119438f, 0.00557161f, 
    -0.01131662f, -0.09059644f, -0.04207487f, -0.01815386f, -0.00735686f, -0.07228142f, -0.07531559f, -0.05881504f, 
    -0.04773477f, -0.03245295f, 0.00151485f, -0.03303042f, -0.00161461f, -0.02270540f, 0.00631171f, -0.08390615f, 
    -0.01192862f, -0.08726124f, -0.05320406f, -0.02784670f, -0.06416786f, -0.08604213f, -0.06439570f, -0.02337786f, 
    0.00746068f, 0.01976092f, -0.02613910f, -0.01346405f, -0.08317422f, -0.09639329f, -0.02462851f, 0.01738873f, 
    -0.01152715f, -0.08073981f, -0.07692583f, -0.00193860f, 0.00498058f, -0.09291311f, -0.04534808f, -0.08708928f, 
    -0.03278150f, -0.00520812f, -0.09583396f, -0.02296836f, -0.05098926f, -0.06316181f, -0.08913568f, 0.02584882f, 
    -0.00449458f, -0.01969896f, -0.02556706f, -0.08437797f, -0.02745885f, -0.04584676f, -0.07618842f, -0.03527346f, 
    -0.08339924f, -0.00929750f, -0.02130738f, -0.05606990f, -0.04702907f, -0.01974878f, 0.01064399f, -0.06416316f, 
    -0.08095328f, 0.01187844f, -0.08292891f, -0.05236676f, -0.04135565f, -0.03463041f, -0.00629884f, -0.01478000f, 
    -0.05692684f, -0.01427479f, -0.02246159f, -0.00169164f, -0.02972832f, 0.00694973f, -0.06344007f, -0.09571055f, 
    0.01453278f, -0.01208619f, -0.07487820f, 0.02617447f, 0.01543330f, -0.01587360f, -0.02156645f, -0.06897116f, 
    -0.00790770f, -0.04844863f, -0.07885800f, -0.03985577f, -0.08007357f, -0.03480693f, -0.03682756f, -0.07804279f, 
    0.01706411f, -0.06641093f, -0.09495229f, -0.08015823f, -0.00907888f, 0.01839874f, 0.01688118f, -0.08248982f, 
    -0.01961779f, -0.01994088f, -0.09740215f, 0.00616971f, -0.07870656f, -0.06079590f, -0.06164470f, -0.07881259f, 
    -0.00099045f, -0.02156152f, -0.04470891f, 0.00749369f, -0.09610182f, -0.01975620f, -0.02582988f, -0.08288970f, 
    -0.02950551f, -0.00540635f, -0.07828960f, 0.01376009f, -0.06314392f, -0.06140122f, 0.00912145f, -0.04887011f, 
    -0.00517545f, -0.00939754f, -0.01246040f, -0.02690801f, -0.02767776f, 0.03922862f, -0.04250016f, -0.03679661f, 
    -0.03669496f, -0.08504082f, -0.01223183f, -0.03401070f, -0.09934313f, -0.00003119f, -0.02244409f, -0.02657322f, 
    -0.02056991f, -0.08387944f, -0.03824956f, -0.07398538f, -0.03537425f, -0.04910735f, -0.05889765f, -0.04911468f, 
    -0.01471782f, -0.04510331f, -0.04402558f, -0.05093362f, -0.00281359f, -0.06535241f, -0.06368741f, -0.05785097f, 
    0.00276148f, -0.05210667f, 0.01217025f, -0.04768894f, -0.02424373f, 0.00316781f, -0.02345418f, -0.01302192f, 
    -0.00868478f, -0.04320457f, -0.01818450f, -0.02275146f, -0.00243636f, -0.05936607f, -0.07809751f, -0.04879980f, 
    -0.04513612f, -0.06934156f, -0.01211916f, -0.04509383f, -0.02689670f, -0.01522962f, 0.02345955f, -0.02985966f, 
    -0.01895296f, -0.01528006f, -0.01307280f, -0.03241357f, -0.05181628f, 0.00485968f, -0.06710538f, 0.03534451f, 
    -0.05981816f, -0.06446319f, 0.01805210f, -0.08133187f, -0.01928580f, 0.00908277f, -0.08819605f, -0.08293608f, 
    -0.02262946f, -0.03474374f, -0.02463356f, -0.01490918f, -0.03435536f, 0.00239499f, 0.01368783f, -0.05376538f, 
    0.02302461f, 0.00332597f, -0.00929916f, 0.01458557f, 0.01145325f, -0.01496262f, -0.02588244f, -0.06085782f, 
    -0.02150799f, -0.00292961f, -0.08822276f, -0.07958668f, -0.01980264f, -0.01072799f, -0.03757989f, -0.02654725f, 
    0.01602679f, -0.00452068f, -0.02762703f, -0.04531902f, -0.06498248f, -0.01766925f, 0.02268364f, -0.06069997f, 
    -0.02725952f, 0.00924921f, -0.00804455f, -0.02690941f, -0.01774531f, 0.00704950f, -0.06921467f, -0.02546783f, 
    -0.05857203f, -0.09807605f, -0.02755729f, -0.06736034f, 0.00930798f, 0.00119520f, -0.09834846f, 0.00184331f, 
    -0.01006881f, -0.01835821f, 0.00236439f, -0.08694491f, -0.00917971f, -0.08461557f, -0.01623529f, -0.01225589f, 
    -0.04167136f, -0.01533990f, -0.08164071f, 0.00787302f, 0.00929651f, -0.01954869f, -0.06182845f, -0.06022356f, 
    -0.01575796f, -0.08305048f, -0.03328246f, -0.08407269f, -0.03665518f, 0.01448937f, -0.08420758f, -0.01748086f, 
    -0.00437021f, -0.05556302f, -0.03198542f, -0.06202837f, 0.01366938f, 0.02594305f, 0.00394594f, -0.02228362f, 
    -0.08874479f, -0.01630831f, -0.08659074f, -0.09066451f, -0.04879660f, -0.01218279f, -0.03605626f, 0.01247831f, 
    -0.00166050f, -0.00070705f, -0.08705600f, -0.05959191f, -0.04598917f, -0.09729725f, 0.02616319f, -0.06199929f, 
    -0.06913071f, -0.03784391f, -0.01415941f, -0.08808831f, -0.00435745f, -0.02764296f, -0.01538777f, -0.08095332f, 
    0.00325037f, -0.06566508f, -0.00145560f, 0.00858798f, -0.02698066f, -0.06947771f, -0.02690488f, -0.04912120f, 
    -0.03697191f, -0.05406876f, -0.05105003f, -0.08952933f, -0.08777951f, -0.02967112f, 0.00776094f, -0.03752285f, 
    -0.03252872f, -0.07404439f, 0.02365381f, -0.04922685f, -0.08726340f, 0.00985203f, -0.07787430f, -0.08802667f, 
    -0.07887856f, -0.06710377f, -0.03409748f, -0.08454356f, 0.00764614f, 0.01827225f, -0.03644164f, -0.06449131f, 
    -0.03696214f, -0.01988745f, -0.05758943f, -0.03891356f, -0.00165901f, -0.08742942f, -0.01814854f, -0.07675611f, 
    -0.07897659f, -0.01937697f, -0.05336080f, -0.09385012f, -0.00979404f, -0.03043360f, -0.08320714f, -0.04739991f, 
    0.01213344f, 0.02414091f, -0.02867958f, -0.09083320f, -0.03007798f, 0.03321173f, 0.01757903f, 0.01230722f, 
    -0.06509115f, -0.01645969f, 0.01708169f, -0.05101635f, -0.05156042f, -0.01410331f, -0.01377863f, -0.08724183f, 
    -0.02530887f, -0.03654955f, -0.06367502f, -0.02649421f, -0.03348856f, -0.03738075f, -0.05418933f, -0.00281768f, 
    -0.06876408f, 0.00948342f, -0.01837756f, -0.03543693f, -0.06979644f, 0.01719192f, -0.04516315f, 0.03088371f, 
    0.01324617f, -0.02348589f, 0.00811970f, 0.01070203f, 0.01149783f, 0.01175895f, 0.01521039f, -0.03025245f, 
    -0.06619764f, -0.01824585f, -0.05212653f, -0.06533837f, -0.04271858f, 0.00505852f, -0.01937195f, 0.01408779f, 
    -0.04092422f, 0.01303648f, -0.09595679f, 0.02402687f, -0.00500698f, -0.08754335f, -0.01418973f, -0.02577383f, 
    -0.04214866f, -0.06737126f, -0.09684635f, 0.00347223f, 0.01908527f, -0.09382160f, -0.04080039f, -0.04534651f, 
    0.03559115f, -0.01033260f, -0.08733921f, -0.05977693f, -0.08861713f, -0.01935254f, 0.01622060f, 0.04275325f, 
    -0.00454467f, 0.00470917f, -0.03923014f, -0.00155418f, -0.07203285f, -0.02524626f, -0.03888620f, -0.01686838f, 
    0.04124861f, 0.00813817f, -0.01768247f, -0.04098763f, -0.06885538f, -0.00518926f, -0.01090566f, -0.08950386f, 
    -0.07227483f, -0.06526757f, -0.05048432f, 0.00191320f, -0.01808826f, 0.01778608f, -0.01331528f, -0.05391798f, 
    -0.01924737f, 0.01560491f, -0.04844438f, -0.00764145f, -0.07209665f, -0.05923522f, -0.04545532f, -0.03169009f, 
    -0.07013908f, -0.07958482f, -0.04350572f, -0.04454059f, -0.07714774f, 0.00551055f, -0.00605548f, 0.02335960f, 
    -0.05245656f, -0.01294570f, 0.00282452f, -0.05129215f, -0.08141688f, -0.06812330f, 0.00270462f, 0.01254651f, 
    -0.00606814f, -0.02174295f, -0.05846307f, -0.01661531f, -0.02658364f, 0.00332785f, -0.01122838f, -0.02682779f, 
    -0.00847618f, -0.05019823f, -0.01951366f, 0.02408196f, 0.00359612f, 0.01426259f, -0.02425306f, -0.06885181f, 
    -0.04993095f, -0.04650037f, 0.01894439f, 0.01466004f, -0.07756259f, -0.05318792f, -0.03599613f, -0.08018803f, 
    0.01189585f, 0.02024875f, 0.01025234f, -0.04635053f, -0.01759666f, -0.08508940f, -0.00770275f, -0.06823158f, 
    -0.02469073f, 0.01763696f, -0.02584561f, -0.05573200f, 0.02150605f, 0.01079531f, -0.04371202f, 0.00446936f, 
    -0.07682270f, -0.03714360f, -0.04094188f, 0.00136898f, 0.00132439f, -0.04150137f, -0.05028492f, -0.04111974f, 
    -0.06703851f, 0.00737038f, -0.06620510f, 0.01172736f, -0.03788853f, -0.09342410f, 0.01777522f, -0.02961389f, 
    -0.01530967f, 0.01250617f, -0.07868255f, -0.09461831f, -0.04202075f, -0.01623191f, -0.03532894f, -0.07708197f, 
    0.24495028f, -0.19622248f, -0.03943589f, -0.14811316f, 0.14997596f, 0.09484206f, -0.06277518f, -0.03184315f, 
    -0.07959504f, 0.54624629f, 0.07968277f, -0.10860732f, -0.20435353f, -0.10077190f, 0.12031746f, -0.00155570f, 
    0.06616670f, -0.02358668f, -0.11669859f, -0.17902459f, -0.13333604f, -0.17551672f, -0.11309852f, 0.09021427f, 
    -0.04720527f, 0.13979319f, -0.14958571f, 0.11094420f, 0.32549608f, 0.05381160f, 0.02393655f, 0.18933564f, 
    -0.13742062f, 0.09574450f, -0.01463575f, 0.15683874f, 0.10854416f, -0.04253237f, -0.00741503f, 0.11721231f, 
    -0.03806148f, 0.11925720f, -0.04269153f, -0.00197667f, -0.04394257f, 0.15372962f, 0.01230129f, -0.05948845f, 
    0.18939818f, -0.06604242f, -0.00141333f, -0.05585270f, 0.09749900f, -0.09536618f, 0.31560674f, 0.14616597f, 
    0.21128629f, -0.06963481f, 0.12935910f, 0.04016645f, 0.05557361f, 0.00234360f, 0.14443567f, -0.22646329f, 
    -0.12042310f, -0.14431983f, 0.00765761f, -0.08720266f, -0.00266217f, -0.15696371f, 0.03891178f, -0.12053156f, 
    -0.15122253f, -0.14126492f, 0.00133595f, -0.09788387f, 0.08372917f, -0.02600230f, -0.10401981f, -0.06618478f, 
    -0.00381711f, 0.12159922f, -0.12285715f, -0.05575089f, -0.17050394f, -0.05138018f, 0.07436785f, 0.03057309f, 
    0.05143558f, -0.15706228f, 0.11546760f, -0.15699805f, -0.30791575f, -0.06458326f, -0.03363127f, 0.09992078f, 
    0.03242950f, -0.05499798f, -0.06202962f, 0.27474511f, 0.05735625f, -0.00584107f, -0.12226006f, 0.03478124f, 
    -0.11221510f, -0.09717768f, 0.03439993f, -0.16678187f, 0.30664152f, 0.17267054f, 0.25235084f, 0.43211612f, 
    0.05634438f, 0.10094742f, -0.08521208f, 0.22319466f, 0.21034963f, 0.10632867f, 0.26228023f, -0.01265103f, 
    -0.07445128f, -0.16938433f, -0.17398562f, -0.11468478f, 0.06612912f, 0.09096552f, -0.08619101f, 0.02681767f, 
    0.13229984f, -0.11158973f, -0.13669123f, 0.19990182f, 0.06944507f, -0.04132413f, 0.14266914f, -0.02499487f, 
    0.18797506f, -0.16761187f, 0.07025781f, -0.10328606f, 0.07764916f, 0.05119068f, 0.00765501f, 0.05612192f, 
    0.33225268f, -0.14247085f, -0.10423253f, -0.11061504f, -0.03912165f, -0.21019095f, 0.05963060f, 0.00452636f, 
    -0.01486506f, -0.00541344f, 0.24233781f, 0.20247042f, 0.04452576f, -0.17782611f, 0.16811876f, 0.16248222f, 
    0.12012937f, 0.01141342f, -0.02014982f, 0.08629405f, -0.30594352f, -0.00388583f, 0.06104963f, 0.01326072f, 
    -0.09234324f, 0.02129112f, 0.05131793f, -0.08575547f, -0.11944661f, 0.13985035f, -0.04620121f, 0.05734673f, 
    -0.03380550f, -0.23388094f, 0.02388467f, 0.07984276f, 0.13806680f, -0.06632820f, -0.34657598f, -0.03204596f, 
    0.13225164f, -0.07167839f, 0.06955960f, 0.08254612f, 0.02661506f, -0.09345747f, -0.00544035f, -0.18986218f, 
    -0.18513089f, -0.15548040f, 0.07635987f, -0.04522640f, -0.15317801f, -0.01066182f, -0.06810051f, -0.20476571f, 
    -0.14810289f, 0.17174487f, -0.07125258f, 0.17745669f, -0.14175543f, -0.03755859f, -0.14543651f, 0.04387398f, 
    0.25317347f, 0.06678365f, 0.01059191f, -0.12437778f, -0.19921990f, 0.07430338f, -0.06989509f, -0.19722220f, 
    0.04705469f, 0.12042314f, 0.07181785f, 0.09352694f, 0.01044657f, 0.03449897f, 0.02115599f, 0.03908470f, 
    0.02320964f, -0.11644706f, 0.28863618f, 0.16215201f, 0.07185251f, 0.00551847f, 0.01053141f, -0.02209828f, 
    -0.00612127f, -0.01730890f, 0.27771133f, 0.05660541f, 0.05349528f, -0.03454599f, -0.01427124f, 0.04308135f, 
    -0.11250154f, 0.12517928f, -0.12218622f, -0.32513380f, -0.28297460f, -0.01698388f, -0.06667911f, -0.14476751f, 
    0.00189000f, -0.02306071f, 0.04535796f, -0.12768455f, -0.06476934f, 0.08747167f, -0.11971810f, -0.17671405f, 
    0.14143853f, 0.09439859f, -0.13952337f, -0.17366992f, -0.02899124f, 0.07258367f, 0.01074894f, 0.20249414f, 
    0.01776039f, -0.02573664f, 0.01340478f, 0.07212284f, -0.16264187f, -0.07405724f, 0.42927018f, 0.09083431f, 
    0.28174564f, -0.09662387f, -0.16952731f, 0.02351483f, 0.25985271f, -0.06117683f, -0.09429578f, -0.06943430f, 
    0.03650100f, -0.02815237f, 0.09027997f, 0.11051106f, -0.08171774f, -0.04424411f, 0.08190866f, 0.30307665f, 
    -0.00361584f, -0.05178523f, -0.00711857f, 0.04285454f, -0.00225559f, -0.04193326f, -0.05827376f, 0.02456339f, 
    -0.02299938f, -0.02023601f, -0.02424146f, -0.00837669f, -0.05465904f, 0.02876771f, -0.06035178f, 0.03988602f, 
    0.02031881f, -0.01275408f, -0.03480585f, 0.02523440f, 0.05517424f, 0.00972302f, 0.00181499f, 0.01307852f, 
    -0.01951898f, 0.03492351f, -0.00348816f, -0.06861743f, 0.02154101f, 0.03757332f, -0.04559088f, 0.03677125f, 
    0.00031281f, -0.01813126f, -0.00386070f, -0.00618483f, -0.02700592f, -0.05340843f, 0.02803443f, -0.00368767f, 
    -0.01024570f, 0.00540791f, -0.00544669f, 0.03140576f, 0.02076349f, 0.04953935f, -0.03827064f, 0.00837570f, 
    -0.05352312f, 0.00479350f, -0.06592949f, -0.02285144f, -0.05330807f, 0.01061777f, 0.03881026f, 0.01897005f, 
    -0.05217917f, -0.02907424f, -0.03292546f, -0.00098143f, 0.00711752f, 0.04825910f, 0.02018758f, 0.02524255f, 
    0.02094149f, 0.00020254f, -0.05959858f, -0.02664370f, -0.04458320f, 0.05356202f, -0.05945000f, -0.06256206f, 
    -0.06166108f, -0.02456106f, 0.03449703f, -0.04582677f, 0.04587322f, 0.04709678f, -0.05267058f, -0.01297116f, 
    -0.01153045f, -0.03992972f, -0.00396286f, -0.04846784f, -0.01044425f, -0.05940599f, 0.02618633f, -0.06282739f, 
    0.00688348f, -0.05587685f, -0.02136822f, -0.03143807f, -0.06112557f, 0.03791309f, 0.03985947f, -0.03402939f, 
    -0.00616869f, -0.03240820f, 0.03188175f, -0.00580962f, 0.04923871f, 0.01360810f, 0.03971046f, -0.00176484f, 
    -0.02221737f, 0.00466716f, 0.00100612f, -0.02049206f, -0.04739318f, 0.01691444f, -0.02572492f, 0.01709998f, 
    -0.03372328f, -0.03877643f, -0.01162800f, -0.03993747f, 0.02621666f, -0.00412518f, -0.00188184f, 0.00872258f, 
    -0.01920800f, -0.03683427f, 0.00133023f, 0.04561274f, 0.03509770f, 0.03173663f, -0.05812559f, 0.00739551f, 
    0.05132435f, 0.02170330f, -0.03983828f, 0.02260039f, -0.06115554f, 0.02721518f, 0.03330493f, 0.03232068f, 
    0.03768903f, 0.01474682f, 0.02982877f, -0.03702602f, -0.03493600f, 0.02313776f, 0.00394411f, -0.02520035f, 
    -0.05129847f, 0.00619384f, -0.04335004f, -0.04088815f, -0.05974498f, -0.02280699f, -0.01847583f, 0.03204534f, 
    0.01816219f, 0.00179296f, -0.02437365f, -0.02052373f, 0.00869061f, 0.00242934f, -0.05161795f, 0.00530863f, 
    -0.00365951f, -0.05401500f, -0.04024698f, 0.04312089f, -0.00347024f, -0.02160058f, 0.01574215f, 0.00661850f, 
    -0.03857625f, -0.00940285f, 0.00109145f, 0.03618217f, 0.03896271f, -0.00728745f, -0.02326871f, 0.04674342f, 
    0.04955894f, -0.02618367f, -0.03973041f, -0.05270772f, 0.02723002f, 0.00093910f, 0.03746338f, -0.00256549f, 
    0.01362878f, -0.04651098f, 0.04868621f, -0.00741282f, -0.05255067f, 0.00823122f, -0.03214771f, -0.03605294f, 
    0.02894265f, 0.04469660f, -0.06000958f, -0.04262207f, 0.00000903f, -0.04758185f, 0.00507387f, 0.02553248f, 
    0.00027969f, -0.01421782f, 0.01494046f, -0.06593583f, -0.04255734f, -0.03684688f, 0.03628119f, 0.01875214f, 
    -0.02254873f, -0.01447342f, -0.02312448f, -0.01246557f, 0.02307510f, -0.04580694f, -0.03760328f, 0.00611848f, 
    0.02736469f, -0.03365555f, 0.05437108f, -0.03909495f, 0.01040148f, -0.00180795f, -0.04675271f, 0.00837023f, 
    -0.00128508f, 0.01500973f, 0.04371897f, 0.05097679f, 0.03363622f, -0.00311825f, -0.02106933f, -0.03737909f, 
    0.03083768f, -0.01768857f, -0.04237147f, 0.02370622f, 0.05397277f, -0.03847978f, -0.02454744f, 0.04038970f, 
    0.03614437f, -0.04353032f, 0.01859446f, -0.03792338f, 0.00399666f, -0.04841691f, -0.05549349f, -0.04659482f, 
    -0.03426901f, -0.01724206f, -0.03795064f, 0.02160277f, 0.01825234f, -0.05268731f, -0.06119472f, -0.02091163f, 
    0.02591151f, -0.05369337f, 0.03212341f, -0.00415020f, 0.05466669f, -0.02442499f, -0.03523555f, 0.03524736f, 
    -0.06562197f, -0.02985280f, 0.01809661f, 0.02829161f, 0.04737695f, 0.02002071f, -0.03736465f, -0.03444542f, 
    -0.02285571f, 0.03748725f, 0.01812341f, 0.00892513f, -0.01774037f, -0.06544369f, -0.00874218f, -0.00518731f, 
    0.00712307f, -0.00514992f, -0.01378738f, -0.03921400f, -0.02089262f, 0.04407728f, 0.01152987f, -0.00915851f, 
    -0.01781727f, -0.02092415f, -0.01208205f, -0.01406752f, -0.02936240f, -0.00120437f, -0.02382322f, -0.05699105f, 
    -0.04954085f, -0.02790734f, 0.02536291f, -0.02200999f, 0.05090320f, -0.02311048f, 0.04831026f, 0.04290293f, 
    0.04143452f, 0.00598968f, 0.03280610f, -0.05102559f, 0.00436106f, 0.01414759f, -0.00337949f, -0.04145509f, 
    -0.04446829f, 0.01279400f, 0.01397207f, -0.02520609f, 0.01316534f, -0.03160081f, -0.04949464f, -0.04843755f, 
    -0.04944866f, -0.00860115f, -0.06234977f, -0.02314058f, 0.04900940f, 0.04814504f, 0.03424170f, 0.02756709f, 
    0.03587869f, -0.03623692f, 0.00320511f, -0.01829289f, 0.04379037f, 0.04074249f, -0.03400797f, 0.04839911f, 
    0.02236841f, 0.02373493f, 0.04089764f, -0.05540670f, 0.03457539f, 0.04010728f, -0.05059718f, -0.04670754f, 
    -0.04561665f, -0.04604125f, -0.02415885f, -0.02281904f, -0.03688379f, -0.03198212f, 0.03099595f, 0.01867884f, 
    0.03673216f, 0.03015554f, -0.02484528f, -0.00492466f, -0.02666662f, -0.01886245f, -0.02469043f, -0.03930946f, 
    0.02700965f, 0.03509432f, 0.02355250f, 0.03508765f, 0.04207764f, 0.05215804f, -0.05933700f, 0.04490874f, 
    -0.03537828f, -0.02252446f, -0.03464543f, -0.03619580f, -0.00271071f, -0.06299492f, -0.00758185f, -0.05106667f, 
    -0.00129957f, -0.05796033f, -0.01858309f, 0.03385014f, 0.03948247f, -0.01685090f, -0.05628372f, 0.04631439f, 
    -0.02903718f, -0.04745768f, 0.00075515f, 0.04542643f, -0.01453621f, -0.01770585f, -0.04528837f, -0.02286185f, 
    0.02448231f, -0.04592614f, -0.03772119f, 0.04410121f, 0.01678201f, -0.02786399f, 0.00079357f, -0.03508167f, 
    -0.00589443f, -0.00722622f, -0.04559286f, 0.00688555f, -0.01146437f, 0.01384968f, -0.04789568f, -0.04980676f, 
    -0.01827763f, 0.05095820f, 0.00434710f, -0.01273801f, 0.02704728f, -0.00440881f, -0.01644868f, 0.05155979f, 
    0.01112659f, -0.00484645f, -0.06424498f, -0.04311372f, 0.03695732f, -0.05199891f, -0.05831528f, -0.03889995f, 
    0.01690276f, -0.04336341f, 0.04973973f, 0.02370356f, 0.03873455f, -0.02255497f, 0.04358449f, 0.02292714f, 
    -0.04193672f, 0.04376690f, 0.04644029f, -0.06266358f, 0.04812956f, -0.04442656f, -0.06207383f, -0.04803109f, 
    -0.04729506f, 0.04032680f, -0.03562379f, -0.00735723f, -0.02268600f, -0.00677814f, 0.00525639f, -0.06180174f, 
    0.00941728f, -0.06127598f, 0.05242845f, -0.05794739f, 0.00678647f, -0.04307730f, -0.01656361f, 0.00358159f, 
    -0.00473221f, -0.05931309f, -0.03718582f, -0.02126721f, 0.01879375f, -0.03930116f, -0.06478975f, -0.04754155f, 
    0.04780192f, 0.01742744f, 0.03443604f, -0.00084477f, -0.06029004f, -0.03820858f, -0.02236174f, 0.03334724f, 
    0.03021704f, -0.04269779f, 0.00075386f, 0.00526509f, 0.01934911f, -0.00711317f, -0.02500434f, -0.02233993f, 
    -0.00260204f, -0.01648081f, -0.01576738f, -0.02815869f, -0.01829993f, 0.00926574f, -0.06145174f, 0.03463710f, 
    0.03907230f, -0.03092050f, -0.01847328f, -0.02091080f, 0.04729680f, -0.04901464f, -0.03881204f, -0.01313836f, 
    0.02256970f, 0.00668226f, 0.04873712f, 0.01607070f, -0.06504250f, 0.04410775f, -0.02506017f, 0.05085283f, 
    0.01581083f, 0.04107249f, -0.05549330f, 0.03641937f, 0.04279858f, -0.02270696f, 0.04478693f, 0.04319213f, 
    0.04083839f, 0.05213603f, 0.00085798f, 0.05029725f, -0.05888939f, -0.03643415f, 0.03629538f, -0.03127390f, 
    -0.06057359f, -0.05661343f, 0.02936005f, -0.03358886f, 0.00120837f, 0.02076673f, -0.03669185f, -0.03982597f, 
    -0.06249240f, 0.01747084f, 0.00101594f, -0.01868036f, -0.00656509f, -0.00393997f, -0.03949215f, -0.05731022f, 
    -0.06331352f, 0.01549234f, -0.02916219f, 0.01962106f, -0.03995541f, 0.02578956f, -0.01102403f, -0.03545630f, 
    -0.00989585f, 0.03136830f, -0.00351041f, -0.02613759f, -0.06467821f, 0.01012674f, -0.02475112f, 0.02871998f, 
    0.02135497f, 0.00069728f, -0.04343238f, 0.01378004f, -0.00555854f, -0.04385648f, -0.03817775f, -0.01528527f, 
    0.00217766f, 0.01533670f, -0.03213485f, -0.05705188f, 0.00554089f, -0.04118929f, 0.02496889f, -0.04907582f, 
    0.00354560f, -0.04477224f, -0.02913473f, -0.01008729f, 0.04798079f, 0.02826814f, -0.01656749f, -0.00711077f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.05026682f, 0.03897670f, -0.04264454f, 0.05055330f, -0.04797662f, 0.00765120f, -0.00404945f, 0.02790868f, 
    -0.05685370f, -0.03649481f, -0.04577844f, -0.04229981f, -0.00130520f, -0.05000085f, 0.10198244f, 0.03208541f, 
    0.04754475f, 0.12653889f, 0.04112688f, 0.11609465f, 0.19082202f, 0.00356450f, -0.06073724f, -0.06777354f, 
    -0.04340330f, 0.19038805f, 0.03253212f, -0.08670983f, -0.03959075f, -0.25009665f, 0.02268066f, -0.05808675f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.07534818f, -0.16300979f, 0.10039718f, 0.53533655f, 0.06644777f, 0.12685534f, 0.08214013f, 0.23060133f, 
    -0.04428140f, 0.17270561f, -0.09372480f, 0.01863715f, 0.15007478f, -0.38740358f, 0.27474236f, 0.10135044f, 
    0.16254559f, 0.44199032f, 0.21090522f, -0.54974157f, 0.28226805f, -0.02932711f, -0.04012970f, -0.17638181f, 
    -0.19703379f, 0.04771345f, 0.04616334f, 0.12001961f, 0.06617663f, -0.13956122f, 0.14350128f, -0.00309882f, 
    -0.04427218f, -0.03974818f, -0.08460229f, -0.43859765f, -0.13573222f, -0.16412348f, 0.03537211f, -0.08922429f, 
    -0.14206351f, 0.00574621f, -0.03630445f, 0.08963227f, 0.09036925f, 0.46975604f, -0.26771730f, -0.17181377f, 
    0.10063910f, -0.10668985f, 0.36933979f, 0.44257730f, -0.19636425f, -0.10583186f, 0.12341527f, 0.29107526f, 
    -0.24782781f, 0.23142710f, 0.12457372f, -0.02405366f, -0.08270764f, 0.37696695f, 0.01780495f, 0.14287589f, 
    -0.00556652f, -0.15917604f, 0.09198969f, 0.01788631f, -0.10852280f, 0.12107104f, -0.09560237f, 0.23618078f, 
    -0.00836551f, 0.05769187f, 0.10118130f, 0.14734182f, 0.16315232f, 0.62584496f, -0.47424012f, 0.00357301f, 
    0.14206080f, -0.13514496f, 0.18602349f, 0.07860953f, -0.25268266f, 0.07980229f, -0.54902053f, 0.27383763f, 
    -0.49649799f, 0.28058410f, -0.15289223f, 0.11753679f, 0.08948048f, -0.34509557f, 0.09420930f, 0.05621368f, 
    -0.13604812f, 0.11324850f, -0.15862070f, 0.24646343f, 0.05161128f, -0.10256189f, 0.11110851f, 0.00431227f, 
    0.00304113f, 0.09817018f, -0.04892438f, -0.16327059f, -0.10913935f, 0.22183719f, 0.37542748f, -0.08162750f, 
    -0.15221830f, 0.35770234f, -0.10613849f, 0.66687012f, -0.29807362f, 0.07352756f, -0.53125304f, -0.17438576f, 
    -0.38940156f, 0.16527697f, -0.02289910f, 0.09856763f, 0.09668611f, 0.19109263f, -0.05648891f, 0.14013080f, 
    -0.01903739f, -0.08293378f, 0.00395786f, -0.08899602f, -0.06190485f, 0.15684848f, -0.08980040f, -0.22306000f, 
    0.05399898f, 0.03421180f, 0.11139150f, -0.15746628f, 0.07214727f, -0.07682250f, -0.12770437f, -0.14819154f, 
    -0.00507031f, 0.04943635f, -0.17196222f, 0.31931165f, 0.14840816f, -0.06146610f, -0.74250287f, 0.12276374f, 
    -0.25258064f, 0.24344476f, 0.00172707f, 0.00695128f, -0.09681505f, -0.08585696f, -0.06228063f, -0.16027626f, 
    -0.04860349f, 0.00799328f, -0.14919987f, -0.29133460f, -0.10672858f, -0.04667632f, 0.09553345f, 0.15729156f, 
    0.00980266f, 0.13541688f, 0.16208731f, -0.14076865f, -0.04383544f, 0.46011049f, 0.29660493f, -0.01804800f, 
    0.03960295f, 0.50310868f, 0.75195211f, 0.35040662f, 0.08403791f, -0.08218358f, -0.20012298f, -0.17853633f, 
    0.51053345f, -0.19654812f, -0.12742697f, -0.16285062f, -0.08808897f, 0.26373628f, 0.03028717f, 0.14678048f, 
    -0.15672228f, -0.04634622f, -0.07290030f, 0.11587402f, -0.05760498f, -0.16608088f, -0.01698381f, -0.06252901f, 
    0.11944825f, -0.16090569f, 0.03036785f, -0.03077473f, -0.08742649f, -0.15357609f, -0.04164698f, -0.14438333f, 
    0.10753764f, -0.15987083f, 0.13787806f, 0.08774443f, 0.04354289f, 0.01609523f, 0.14261182f, -0.09954191f, 
    -0.01130392f, -0.16670236f, 0.13654546f, 0.12521297f, 0.02505975f, 0.12462379f, 0.08109433f, -0.03166128f, 
    -0.10802104f, -0.04755859f, -0.01277368f, -0.03566080f, 0.12081926f, -0.02385350f, 0.08828943f, 0.07439288f, 
    0.07243865f, -0.01922722f, 0.04794264f, 0.12974149f, -0.02715627f, 0.10554171f, -0.12702583f, 0.00815790f, 
    0.02176741f, -0.36249655f, 0.09471417f, -0.12040435f, -0.40456802f, 0.00619544f, 0.53756899f, 0.36307478f, 
    0.46128547f, 0.19414656f, 0.05548283f, 0.16694778f, 0.19591607f, 0.01128382f, 0.09468447f, 0.04568945f, 
    0.12964799f, -0.02208941f, -0.14074959f, -0.20185541f, 0.14225067f, -0.06390744f, -0.05750998f, -0.24914807f, 
    -0.13270091f, 0.07951507f, -0.03593357f, 0.09612445f, -0.16417092f, 0.01967519f, 0.52645022f, 0.14130615f, 
    0.03016140f, -0.07191714f, -0.54774755f, 0.54991347f, 0.12407944f, -0.16135366f, 0.28818992f, -0.16733274f, 
    0.34016052f, 0.33663452f, -0.09886127f, 0.15530384f, -0.13415410f, -0.45062757f, 0.09986615f, 0.06232271f, 
    -0.13226636f, 0.08668310f, -0.06294351f, -0.01709986f, 0.06476888f, -0.03679902f, -0.02907437f, 0.03005932f, 
    -0.02746392f, 0.11093461f, 0.11458425f, 0.05788189f, 0.05337141f, 0.01392663f, -0.15607071f, 0.08886198f, 
    0.05604262f, -0.09792319f, 0.07361303f, -0.14619678f, -0.05429983f, -0.09947211f, -0.01334090f, -0.09552536f, 
    -0.07286628f, -0.03189935f, 0.10922893f, 0.10678608f, 0.14855437f, -0.03666384f, -0.03576752f, -0.12174380f, 
    -0.02837246f, -0.05577137f, 0.11708913f, -0.05128903f, 0.01050523f, -0.05923737f, -0.11407401f, -0.01132225f, 
    0.03263243f, -0.12531810f, 0.02712573f, -0.11588137f, 0.06389785f, -0.04669418f, 0.14468977f, -0.08366396f, 
    0.05623435f, -0.15219258f, 0.01717865f, -0.09329312f, -0.15692553f, 0.13640700f, -0.07458856f, -0.10685688f, 
    0.09935321f, -0.06026843f, -0.07155574f, -0.03036236f, -0.16984196f, -0.14834090f, 0.10772780f, 0.04704073f, 
    -0.12082322f, -0.10193975f, 0.15254973f, -0.10570722f, 0.11878590f, 0.11590531f, -0.04212108f, -0.00806767f, 
    0.06796220f, -0.15616021f, -0.11629899f, -0.03365893f, 0.00082531f, -0.03468300f, -0.09661786f, 0.08531546f, 
    -0.10891558f, -0.12625238f, -0.05144660f, -0.04800913f, 0.03402840f, -0.12410100f, -0.07607488f, -0.01333129f, 
    -0.10183497f, -0.03835027f, 0.14662367f, 0.05336425f, -0.09389036f, -0.01710927f, 0.15834659f, -0.08129054f, 
    -0.04282851f, -0.03747613f, -0.04677164f, -0.12552203f, -0.03624700f, -0.08607683f, 0.05715136f, 0.10200835f, 
    0.02073138f, 0.14282645f, 0.11366700f, -0.15464321f, -0.11140455f, -0.08568513f, 0.01690478f, 0.08597750f, 
    -0.05724206f, 0.00119143f, 0.10482800f, 0.04877876f, -0.08080845f, 0.12511776f, -0.16665274f, -0.12550110f, 
    -0.02741334f, -0.14152902f, 0.04448180f, 0.02622027f, -0.17206016f, -0.10601047f, 0.02475158f, -0.13313511f, 
    -0.14577259f, -0.13995934f, 0.02280219f, -0.56085438f, 0.01003689f, 0.05960294f, -0.15556832f, 0.13405773f, 
    0.08896657f, -0.02646406f, -0.00376891f, 0.09248116f, -0.04005955f, 0.17076409f, 0.12217839f, -0.12143678f, 
    0.15769599f, 0.39592907f, 0.39557004f, 0.34622726f, 0.57309914f, 0.01047859f, -0.41133484f, -0.19720101f, 
    -0.44869632f, 0.01801162f, -0.04865839f, 0.08352504f, -0.08320473f, -0.03039631f, -0.17832375f, -0.08616976f, 
    0.15305282f, 0.07759492f, 0.05623659f, 0.03053257f, -0.08326874f, -0.05313230f, 0.05257353f, 0.28175351f, 
    -0.02571951f, -0.04391937f, -0.10741322f, -0.02574304f, -0.03075282f, -0.34232876f, 0.37401113f, -0.07242532f, 
    -0.09573268f, 0.38459817f, -0.03053021f, 0.70259190f, 0.21525228f, -0.08111335f, 0.13071297f, -0.35973871f, 
    0.29244933f, 0.10735542f, 0.06017872f, 0.03676527f, 0.02863448f, -0.40477476f, 0.02717019f, 0.15700743f, 
    0.14103907f, -0.07191748f, 0.01763226f, 0.13576053f, -0.02194603f, 0.06155987f, 0.01842953f, -0.10640621f, 
    -0.00371014f, -0.04985428f, -0.06490064f, -0.08995834f, -0.14764269f, 0.05694127f, -0.12130583f, -0.00907930f, 
    0.12446622f, -0.07805879f, -0.25907442f, 0.07263602f, -0.06758901f, -0.05300103f, -0.08104138f, -0.06109666f, 
    0.07435493f, 0.00874294f, -0.11135910f, -0.08205704f, 0.06129764f, -0.22457550f, 0.03919096f, -0.00517399f, 
    0.05748705f, -0.02658417f, -0.18618393f, 0.01466691f, -0.16608275f, -0.01982611f, -0.02192643f, 0.01841371f, 
    -0.17422856f, -0.11850140f, -0.14610937f, -0.17144305f, -0.09715236f, 0.15498982f, 0.18493916f, -0.08668439f, 
    -0.13596056f, 0.43473431f, -0.35360697f, -0.56058502f, 0.08120865f, 0.10688683f, -0.13615738f, -0.19798197f, 
    -0.13252243f, 0.31139341f, -0.05960519f, -0.04082065f, -0.03221907f, -0.52418232f, 0.15994512f, -0.09941185f, 
    -0.12058757f, -0.06660831f, -0.16209213f, -0.03322402f, 0.05072751f, -0.16178051f, 0.03933359f, -0.26644999f, 
    0.05592101f, -0.11935019f, 0.12348419f, -0.13605173f, -0.14605577f, -0.23642001f, 0.20706043f, -0.16788419f, 
    0.04561345f, 0.13530153f, -0.54392350f, -0.48272899f, 0.49738225f, -0.01963708f, -0.26880383f, -0.26510414f, 
    0.00287035f, 0.37938106f, -0.17237201f, -0.14403845f, 0.11197907f, -0.23498170f, -0.01602819f, 0.17412302f, 
    -0.04110872f, -0.10795692f, 0.05795843f, 0.04207044f, -0.05620098f, -0.07573611f, 0.16716114f, 0.07280694f, 
    0.03772565f, 0.04346682f, 0.01098001f, 0.00184795f, 0.16824034f, 0.15261608f, -0.25929922f, -0.16970856f, 
    0.15748949f, 0.21839701f, -0.03299848f, 1.04454076f, 0.03299422f, 0.10075697f, -0.73544854f, -0.05234373f, 
    0.11198148f, 0.10537323f, -0.15729541f, -0.05321744f, 0.18800470f, -0.48648953f, 0.00638813f, 0.05563446f, 
    -0.05268670f, -0.02040295f, 0.04137921f, 0.48530903f, 0.15757924f, 0.12220947f, 0.16346744f, 0.41664180f, 
    -0.03114174f, 0.11433952f, -0.10056972f, 0.06750162f, -0.02591128f, 0.11555532f, -0.38003272f, -0.01573294f, 
    -0.07289438f, -0.18275379f, 0.24786586f, -0.11461055f, 0.24880777f, 0.12396237f, -0.09483112f, 0.46437871f, 
    -0.30459538f, -0.10359221f, -0.13212465f, 0.01042920f, -0.06192429f, 0.52552766f, -0.12171645f, -0.05675732f, 
    -0.09506873f, -0.15512492f, 0.07357668f, 0.07771861f, 0.10923319f, -0.10913964f, -0.00383662f, 0.08865392f, 
    -0.11105639f, 0.06679007f, -0.09854750f, -0.17232996f, -0.17518950f, 0.17761108f, -0.56882596f, 0.02675574f, 
    -0.04224756f, -0.48680013f, 0.34047976f, 0.51032734f, -0.05540765f, 0.02750524f, 0.29332227f, 0.51993215f, 
    -0.58614010f, 0.10554117f, 0.07259811f, 0.02730546f, 0.12031738f, 0.02888483f, -0.13901341f, -0.15656367f, 
    -0.13044026f, 0.05482190f, 0.16715342f, -0.06290251f, 0.01146329f, -0.06375141f, 0.16457473f, 0.42166418f, 
    0.10027365f, -0.00028682f, 0.09275033f, 0.15277061f, 0.13167499f, 0.53697312f, -0.40991426f, -0.02608366f, 
    -0.04752053f, 0.07932520f, -0.04139874f, 0.44545305f, -0.22999857f, 0.11871112f, 0.26906711f, 0.45478860f, 
    0.34962058f, -0.07844786f, -0.16073789f, -0.17231034f, -0.03626495f, -0.26447788f, 0.12424122f, -0.07725850f, 
    -0.10288099f, 0.13784735f, -0.09908391f, 0.08143977f, 0.04121214f, 0.01052755f, -0.17318638f, 0.18151090f, 
    0.06112498f, -0.00151686f, -0.13862063f, -0.15011403f, 0.11631086f, -0.02724029f, 0.15418296f, -0.01175220f, 
    -0.15556706f, -0.19417007f, 0.63257235f, -0.22505803f, -0.21330257f, -0.10361686f, 0.13461764f, -0.01540393f, 
    -0.13676579f, -0.05687951f, -0.14441158f, 0.06953977f, -0.15731429f, -0.01341561f, -0.01592696f, -0.16163333f, 
    -0.17595866f, 0.03121653f, 0.07068755f, 0.23091778f, -0.11492083f, 0.14861162f, -0.14934421f, -0.09801930f, 
    0.12860958f, 0.11058053f, -0.06435897f, -0.02049452f, 0.01700927f, -0.32009494f, -0.32356375f, -0.13853484f, 
    0.00738114f, -0.02706360f, -0.35612768f, -0.69513804f, 0.13398071f, -0.05312519f, 0.07291987f, 0.09294579f, 
    -0.07858262f, 0.23461871f, -0.00228198f, -0.11613426f, -0.12338588f, -0.27723590f, -0.16976069f, -0.05657295f, 
    -0.16835639f, -0.01726206f, -0.05059218f, 0.19646072f, 0.13575251f, -0.05305507f, -0.11129998f, 0.08584591f, 
    -0.06573186f, 0.06435638f, 0.06523233f, 0.11243414f, -0.05777602f, -0.05866433f, 0.52912438f, 0.02713982f, 
    0.13872206f, -0.24578354f, 0.02157713f, -0.00486513f, 0.20584358f, 0.09657588f, 0.15936768f, -0.21699704f, 
    0.21773325f, -0.21309899f, -0.05877557f, 0.00335530f, -0.04043069f, 0.12712692f, -0.13029432f, -0.12310728f, 
    -0.09523520f, 0.05295016f, -0.16656409f, 0.43128499f, 0.02693660f, 0.03585528f, -0.01094869f, -0.04184996f, 
    -0.05158738f, 0.15086181f, 0.14155731f, -0.10155326f, 0.05671482f, -0.06912449f, 0.32744709f, -0.01186705f, 
    -0.12510830f, 0.22636554f, -0.64868671f, -0.06470121f, 0.34969357f, 0.05404147f, 0.35314861f, -0.22008812f, 
    -0.29983073f, 0.17217220f, 0.06745864f, 0.06507516f, 0.03697629f, 0.35110202f, -0.04622153f, -0.13036431f, 
    0.07529604f, 0.16127446f, 0.02210533f, -0.02030542f, -0.14213245f, 0.16321485f, 0.11241406f, -0.05187215f, 
    -0.02828941f, -0.01390957f, -0.04288005f, -0.01714606f, 0.02624863f, -0.14400908f, -0.06713212f, 0.11222912f, 
    -0.08830761f, 0.12814465f, 0.08449684f, 0.10092829f, -0.12224771f, 0.16874781f, 0.00086553f, 0.02706647f, 
    -0.05105232f, -0.14540854f, 0.09347086f, -0.16134764f, -0.15842496f, 0.04570967f, 0.15957263f, 0.05350114f, 
    0.10753559f, 0.14061028f, -0.10476726f, -0.20932393f, -0.04168949f, -0.05528449f, 0.09487333f, -0.57463509f, 
    0.09805087f, -0.10957204f, 0.00934682f, 0.02565327f, 0.01279077f, 0.33708951f, 0.01905481f, 0.13549413f, 
    0.11667377f, 0.00581740f, 0.10722875f, -0.13892046f, -0.22182195f, -0.08874939f, 0.17717883f, 0.21701145f, 
    0.06285528f, 0.07610209f, 0.02683026f, 0.09651379f, 0.07052615f, 0.66546184f, 0.15801758f, 0.07279935f, 
    -0.14995444f, -0.12182980f, -0.10450195f, -0.35644040f, -0.02733088f, 0.03144505f, 0.17198683f, -0.03632548f, 
    0.01692478f, -0.11980239f, -0.16971029f, -0.04093508f, 0.00867799f, 0.47933725f, 0.13045461f, -0.12235378f, 
    0.00811420f, 0.02340058f, -0.41873792f, 0.00334234f, -0.11792607f, -0.15844010f, -0.45741484f, 0.00236034f, 
    0.33651564f, 0.34825486f, 0.00428499f, 0.08476856f, 0.17289731f, -0.21576862f, -0.15474707f, 0.13071109f, 
    0.05828849f, -0.06214343f, -0.15132156f, 0.07350858f, 0.09991395f, -0.15330113f, -0.05003005f, 0.20585176f, 
    0.09215195f, -0.15859316f, -0.11902194f, -0.02138354f, 0.07617582f, -0.14084107f, -0.49511203f, 0.14671898f, 
    -0.02669601f, 0.18579639f, 0.54368770f, -0.76318216f, -0.06208003f, -0.06372973f, -0.25005093f, 0.03154721f, 
    0.59449691f, 0.09645306f, -0.01083582f, 0.03504746f, 0.03260926f, -0.43473321f, -0.04581311f, -0.13699163f, 
    0.07251916f, -0.04628100f, 0.16226476f, -0.02423531f, 0.17488411f, -0.12337313f, -0.05272679f, -0.07707679f, 
    0.09432863f, -0.08285418f, 0.16728108f, 0.01400402f, 0.16646537f, 0.05826861f, -0.11320546f, 0.06285678f, 
    0.14873570f, -0.16675980f, 0.07539928f, -0.07784043f, 0.04588655f, -0.12697446f, -0.00181092f, -0.03083498f, 
    -0.15212646f, -0.09811845f, 0.04459244f, 0.13931632f, 0.10276923f, -0.05067304f, -0.14999460f, 0.11743886f, 
    0.03342532f, 0.01731468f, -0.00394416f, -0.52265674f, -0.00161051f, 0.15935180f, 0.02750494f, 0.19134562f, 
    -0.18004115f, 0.01300108f, -0.01362852f, -0.03606213f, 0.16578603f, 0.08322965f, -0.47197524f, -0.08552355f, 
    -0.03875051f, -0.13095503f, 0.32960171f, 0.19460464f, -0.00944809f, -0.07830524f, 0.04162342f, 0.25828063f, 
    0.32489693f, -0.01900194f, 0.00191011f, -0.01059837f, -0.06426843f, -0.02298371f, -0.06524368f, 0.11073010f, 
    -0.12072510f, -0.10628195f, -0.02159472f, 0.27789330f, -0.06725229f, 0.01854663f, -0.01847664f, -0.13559787f, 
    0.09188255f, -0.08319059f, 0.07966623f, 0.08682919f, -0.17531468f, -0.47606671f, -0.00003211f, -0.06340216f, 
    0.00360676f, -0.44633991f, -0.14005169f, -0.18159483f, -0.02809417f, -0.06126415f, 0.05105305f, 0.28548670f, 
    -0.19468589f, 0.39581659f, 0.15561882f, 0.02338911f, 0.00797227f, 0.07587846f, 0.00470629f, 0.16167901f, 
    0.13860826f, -0.00921561f, -0.16622652f, -0.02801964f, -0.03126873f, -0.06972147f, 0.02264773f, -0.38465244f, 
    -0.13189435f, -0.07293788f, -0.08832750f, 0.14360228f, -0.02549990f, -0.35416925f, 0.50535530f, 0.12768096f, 
    -0.01422144f, 0.05429288f, 0.16347747f, 0.06989687f, -0.00827726f, 0.06631912f, 0.54315555f, -0.15941949f, 
    0.29686558f, 0.20840555f, -0.11958456f, 0.03034752f, -0.02701867f, -0.18926926f, 0.16249184f, -0.06361879f, 
    -0.09924502f, -0.07649084f, 0.00131931f, 0.01756545f, -0.10713965f, 0.04284905f, 0.07136185f, -0.04633242f, 
    -0.09494502f, 0.15685284f, 0.13978168f, 0.15869069f, -0.11042047f, -0.15527625f, 0.01493447f, 0.06397742f, 
    -0.04934253f, -0.15421326f, 0.06884344f, 0.05600403f, -0.17407732f, -0.16342318f, -0.02631253f, -0.00127433f, 
    -0.16621159f, -0.03311166f, 0.08649710f, 0.06933636f, 0.02225026f, -0.07935458f, 0.09636008f, -0.10889631f, 
    0.15861697f, -0.10306469f, 0.13033588f, 0.03678705f, 0.02689631f, 0.14002250f, 0.15905079f, -0.31869259f, 
    0.14892782f, -0.01862770f, 0.11549284f, 0.03977159f, 0.03454879f, -0.26455274f, 0.23225860f, -0.13718860f, 
    -0.01932071f, -0.42339948f, -0.08857899f, -0.19454639f, 0.03324469f, 0.08532444f, 0.18460368f, -0.00895163f, 
    -0.02098935f, 0.39013496f, -0.02103231f, 0.05762631f, -0.13148023f, 0.06146673f, 0.12849069f, 0.01947579f, 
    0.11057905f, -0.17723213f, 0.05747613f, 0.59683746f, -0.10396034f, -0.06053510f, 0.00472270f, 0.55318272f, 
    -0.06906576f, -0.11549237f, -0.06525742f, 0.14807917f, 0.02860917f, -0.19556604f, -0.66665548f, -0.10915344f, 
    0.03938629f, -0.19144769f, -0.13821219f, 0.13383380f, 0.02619271f, -0.14970559f, 0.08688587f, 0.35582995f, 
    -0.19320697f, 0.00546581f, 0.10127988f, 0.07308917f, 0.07540690f, -0.46659598f, 0.05688766f, 0.12569040f, 
    0.08174509f, -0.04804112f, 0.10962684f, 0.25648069f, 0.02224876f, 0.14131914f, -0.10440645f, -0.28304181f, 
    0.14054438f, -0.05585387f, -0.05353859f, 0.10950097f, -0.06285466f, 0.07605667f, 0.07782987f, -0.01033597f, 
    0.16721186f, -0.09348209f, -0.10587643f, -0.04670411f, -0.06256162f, -0.12486771f, 0.07492042f, 0.12474724f, 
    0.17778727f, -0.07086904f, 0.16135274f, 0.06963573f, 0.12105115f, 0.71566880f, 0.02792352f, -0.14288159f, 
    -0.11251203f, 0.05296291f, 0.16905926f, 0.10705900f, 0.07207959f, -0.15380783f, -0.08892009f, 0.36364669f, 
    -0.12574226f, -0.01377358f, 0.10842178f, -0.00740072f, -0.06253055f, -0.12063502f, -0.31975570f, 0.12981386f, 
    0.18122929f, -0.36292845f, 0.03865450f, 0.26765656f, -0.01977401f, 0.10081847f, 0.56873047f, 0.55837363f, 
    -0.28328341f, -0.09323566f, 0.10553598f, -0.07978695f, 0.03270682f, 0.36013442f, -0.12049238f, 0.00495429f, 
    0.11503341f, -0.14265545f, 0.00138749f, 0.56366688f, 0.11640771f, -0.16299897f, -0.02883112f, 0.26207104f, 
    0.15354607f, -0.12783267f, 0.07270714f, -0.12615342f, -0.00262813f, -0.20911132f, -0.25135690f, -0.06893153f, 
    0.01908427f, -0.05282246f, 0.38615465f, 0.01399352f, 0.14615764f, 0.12632760f, -0.39097661f, 0.10348401f, 
    0.24389878f, 0.00853067f, 0.06346121f, 0.01115993f, 0.09119053f, 0.87143534f, 0.12718554f, -0.06077697f, 
    0.12591724f, 0.12541896f, -0.08303921f, -0.11339281f, 0.17509116f, -0.16866790f, -0.06808751f, -0.01212430f, 
    -0.09285857f, -0.04117100f, -0.00225219f, 0.06785780f, 0.13284265f, 0.09087598f, -0.08420370f, -0.16737652f, 
    -0.03303187f, -0.08821982f, -0.13197006f, -0.10010677f, 0.05267676f, 0.05474603f, -0.02542046f, 0.05493043f, 
    -0.06101640f, -0.11597521f, -0.06126416f, 0.03026572f, -0.01871464f, 0.05163512f, 0.02209763f, 0.05818840f, 
    -0.14552146f, -0.13837999f, -0.04819446f, -0.13329321f, 0.17238985f, -0.15757281f, -0.15998310f, -0.01573687f, 
    0.02941140f, -0.12247915f, 0.14088860f, 0.16198073f, 0.02860412f, -0.20226854f, -0.00427570f, -0.15069377f, 
    0.16924004f, -0.33024269f, -0.74366724f, -0.38480768f, 0.31195608f, 0.17098315f, -0.01363807f, 0.24110509f, 
    0.35186851f, -0.05733091f, 0.16358985f, 0.03543740f, -0.12764327f, 0.35885403f, 0.03157250f, 0.15114409f, 
    -0.03181566f, -0.03238314f, -0.17156953f, 0.31394911f, 0.13181472f, 0.09945995f, -0.00489324f, -0.06767644f, 
    0.16554251f, 0.01346703f, -0.01749895f, 0.15732054f, 0.06168459f, -0.14053228f, -0.33037585f, -0.03336458f, 
    -0.01818581f, -0.32776365f, -0.04487472f, -0.43773630f, -0.19877440f, 0.01207352f, -0.13242497f, 0.29362470f, 
    0.35369250f, 0.30243775f, -0.08081955f, 0.04964513f, -0.09549511f, 0.21767326f, -0.00216894f, 0.05883330f, 
    -0.05032817f, -0.03582358f, -0.00605200f, 0.22817731f, -0.05977604f, 0.08450866f, 0.10928948f, 0.09234813f, 
    -0.14488827f, -0.01716154f, -0.04408295f, 0.15568897f, -0.17037396f, -0.38673592f, -0.11055640f, 0.15648708f, 
    0.14645459f, -0.14022170f, 0.28329545f, 0.26242492f, 0.50609004f, 0.13852715f, 0.51299131f, 0.05315961f, 
    -0.37566558f, 0.02016272f, 0.05261450f, -0.08189436f, 0.16146672f, 0.38181192f, 0.12199158f, -0.05302275f, 
    -0.16279559f, 0.06200920f, 0.12632741f, 0.50007486f, -0.10144466f, -0.02141403f, -0.01742933f, 0.32654199f, 
    -0.13070293f, 0.14215952f, 0.16919585f, -0.11286918f, -0.00032134f, -0.34316522f, 0.11077222f, 0.07622940f, 
    -0.08013555f, 0.25667071f, -0.32545090f, 0.39200830f, 0.25882486f, 0.17276819f, -0.26641017f, -0.20809275f, 
    -0.38078281f, 0.22664152f, 0.14354822f, 0.14097153f, 0.06028299f, -0.14966187f, -0.15942776f, 0.10986040f, 
    0.06063745f, 0.04046296f, -0.15519935f, -0.55736285f, -0.06858867f, -0.10306801f, -0.11565331f, 0.02210659f, 
    -0.00981992f, 0.12729307f, 0.17090872f, 0.16022632f, -0.05538718f, -0.16661310f, 0.08323657f, 0.15289044f, 
    -0.02584005f, -0.30938315f, 0.04906243f, 0.06648209f, -0.03796094f, -0.07338505f, 0.79543656f, 0.43031934f, 
    -0.05272405f, 0.03006079f, -0.04396537f, -0.13282596f, 0.08010571f, 0.01434779f, 0.05040507f, 0.01749711f, 
    0.08908075f, -0.01638282f, -0.03404402f, -0.23777713f, 0.07496113f, 0.12153060f, -0.17938265f, 0.18621010f, 
    -0.16116679f, -0.01231553f, 0.01027750f, 0.05781698f, -0.05671932f, -0.01378849f, -0.25855902f, 0.01619176f, 
    0.11412138f, -0.24552277f, -0.19042408f, -0.18931331f, 0.10722923f, 0.04267899f, -0.50131810f, 0.34618056f, 
    0.39420104f, 0.18921106f, 0.09294457f, 0.00386256f, 0.02374308f, -0.41574675f, -0.11972549f, 0.05028281f, 
    -0.01425331f, 0.15070808f, -0.10707213f, 0.06990109f, -0.07607952f, -0.06869735f, 0.03269080f, 0.36277142f, 
    -0.12705563f, -0.15444715f, -0.11503787f, 0.15032585f, -0.03729878f, -0.05094505f, -0.08799380f, 0.15913133f, 
    0.03856879f, 0.22268274f, 0.57628995f, 0.45907336f, 0.29304370f, -0.00208317f, -0.42868820f, 0.02325851f, 
    -0.07287083f, 0.04631762f, -0.05319732f, -0.08020207f, 0.10474878f, -0.20189290f, -0.04511232f, 0.05840030f, 
    0.15406618f, 0.12058976f, 0.02824963f, -0.23387380f, -0.06209328f, 0.00871546f, 0.09147450f, -0.19839694f, 
    -0.07502753f, -0.02696072f, 0.09461208f, 0.09242886f, 0.09205913f, -0.04203158f, 0.26657325f, -0.11884888f, 
    0.01054090f, 0.42084491f, 0.78052968f, -0.28340793f, 0.50381601f, 0.11464991f, -0.04981240f, 0.00631511f, 
    0.50134742f, -0.01084095f, 0.09704244f, -0.12758891f, -0.05854116f, 0.16986936f, 0.14682256f, 0.02503422f, 
    0.17266084f, 0.13616095f, 0.02297762f, -0.27729410f, -0.02245916f, -0.03354796f, 0.12356678f, 0.21344431f, 
    0.05348230f, -0.09393670f, -0.14755879f, 0.07433239f, -0.14384022f, 0.31286854f, 0.22143300f, 0.07084853f, 
    -0.09444556f, 0.38155171f, 0.09787232f, -0.38504392f, 0.22114576f, -0.13533798f, -0.16421491f, 0.10156162f, 
    0.68981802f, -0.06497306f, -0.14112443f, 0.08553618f, 0.03907108f, -0.61672455f, 0.04255024f, 0.05238588f, 
    -0.02624548f, -0.07975004f, 0.04086745f, -0.20171209f, 0.17096421f, 0.12775859f, -0.15082785f, 0.24809781f, 
    -0.09134773f, 0.17289291f, -0.04057224f, 0.09681629f, -0.03668865f, 0.35454276f, 0.07925102f, -0.00561368f, 
    0.00977629f, 0.34011301f, 0.31707332f, 0.71111542f, -0.00466905f, 0.03734461f, 0.04220124f, 0.30813944f, 
    0.13023970f, -0.27484119f, 0.08996050f, 0.03759279f, 0.13387308f, 0.28971958f, -0.05670544f, 0.00320251f, 
    -0.05813541f, 0.06258254f, -0.02880131f, -0.45798096f, 0.16284280f, -0.06295361f, -0.16354913f, -0.12797579f, 
    0.05076805f, 0.08831074f, 0.10512536f, -0.18087673f, -0.04360809f, 0.49518615f, 0.00564207f, -0.04123813f, 
    -0.00311126f, -0.10826122f, 0.03840500f, 0.51730424f, -0.14317223f, 0.17181930f, -0.00828599f, 0.12507702f, 
    -0.06352902f, 0.25086302f, 0.17253135f, -0.04787218f, 0.05272632f, 0.11837976f, -0.04728051f, 0.00322681f, 
    -0.08491940f, -0.11687481f, 0.16562787f, 0.17532797f, 0.03875857f, 0.00590462f, -0.00394022f, 0.05223449f, 
    0.12841329f, -0.14815903f, -0.01201381f, 0.00908651f, -0.04593702f, 0.76550412f, -0.27743170f, -0.10914589f, 
    -0.09475397f, 0.27075788f, 0.20891726f, -0.16961916f, -0.33741087f, -0.16977215f, -0.16785783f, 0.41369945f, 
    0.46915886f, -0.00121260f, 0.08819345f, -0.03020925f, 0.09076762f, 0.09093582f, -0.06560036f, 0.06149090f, 
    -0.13889974f, -0.14533369f, 0.02083727f, 0.31907970f, -0.08198434f, -0.00820694f, 0.11558114f, -0.04903206f, 
    -0.10343205f, 0.00492736f, 0.01379477f, 0.11658652f, -0.13897997f, -0.02161189f, -0.43915471f, 0.05200848f, 
    0.03880631f, -0.10320915f, -0.38980716f, -0.55207962f, 0.08549001f, -0.04039225f, -0.31901246f, 0.30994132f, 
    0.01549926f, 0.27873808f, 0.06732726f, 0.05011779f, 0.11687808f, 0.25568959f, -0.09722694f, 0.07218286f, 
    0.03397685f, -0.05435215f, 0.06164073f, -0.40036932f, 0.16654074f, -0.13781957f, 0.00859298f, -0.16672078f, 
    -0.15668038f, -0.09702512f, 0.10848160f, 0.09541101f, 0.07598169f, 0.07140742f, 0.56537360f, 0.01459498f, 
    -0.05501125f, 0.29038277f, 0.25122684f, 0.50491667f, 0.11051436f, -0.02989691f, 0.62706780f, -0.41841996f, 
    -0.44851059f, 0.14511013f, -0.07497608f, 0.03559478f, 0.10482322f, -0.29503244f, 0.16631788f, -0.08945483f, 
    -0.15801471f, -0.14576887f, -0.01567651f, 0.37766138f, -0.14960825f, -0.16697478f, -0.05254077f, 0.20247430f, 
    -0.06061145f, 0.16767375f, 0.06435942f, -0.08340120f, 0.12060916f, -0.13583694f, -0.40270814f, 0.07485559f, 
    -0.12495118f, -0.38507101f, -0.26228595f, -0.24561228f, -0.20185554f, 0.01916197f, 0.48007134f, 0.17872018f, 
    -0.30540881f, 0.29498062f, -0.10746970f, 0.03093651f, 0.15984660f, 0.10179135f, 0.14066422f, 0.18016468f, 
    -0.14010984f, -0.16028194f, -0.09297655f, 0.28213015f, 0.16054353f, 0.17613275f, -0.12237231f, 0.00838221f, 
    0.09014078f, 0.04788919f, 0.09015255f, 0.07905365f, -0.07434195f, -0.69033712f, 0.35776615f, 0.14418240f, 
    0.04083890f, 0.15654363f, -0.05026344f, 0.00694582f, 0.04827254f, 0.04859992f, 0.63228458f, -0.06636145f, 
    0.08216432f, 0.08528949f, 0.02497847f, -0.03226409f, -0.06689855f, 0.03478969f, -0.12470248f, -0.16742410f, 
    -0.02799770f, 0.06608426f, 0.05583026f, -0.51001954f, 0.10214101f, -0.16298616f, 0.04212190f, 0.25152305f, 
    0.13216946f, -0.10029298f, -0.14736752f, 0.17131357f, -0.12916216f, 0.04595088f, -0.26869473f, -0.09462301f, 
    -0.15542538f, -0.65505904f, 0.28839016f, -0.45603150f, 0.25911099f, 0.04883699f, 0.50517935f, 0.21469612f, 
    0.05195587f, -0.03763976f, 0.17396310f, 0.09296731f, 0.17905553f, 0.63245511f, 0.14852123f, 0.15189113f, 
    0.11589444f, -0.02223241f, 0.05975794f, -0.22535975f, -0.16825609f, -0.06807532f, 0.03227250f, -0.15492521f, 
    0.17795359f, 0.12509237f, 0.08400431f, -0.13915709f, 0.16741577f, 0.46237504f, 0.25934044f, -0.01860006f, 
    0.09900685f, 0.34199974f, 0.17421031f, 0.58665305f, 0.26474780f, 0.08316063f, -0.35834613f, -0.25657117f, 
    0.47946566f, -0.02476707f, -0.00055968f, 0.00847424f, -0.04208875f, -0.05067873f, -0.08300238f, 0.10841570f, 
    0.10674285f, -0.07157709f, 0.12227391f, 0.11801393f, 0.15019803f, 0.14029036f, 0.12367021f, -0.08295505f, 
    -0.12725574f, -0.17973596f, 0.09214191f, -0.00988787f, -0.10725287f, -0.52786165f, 0.26160225f, 0.01371557f, 
    -0.07907071f, -0.06579012f, -0.08432740f, -0.24690600f, 0.31401032f, 0.08788680f, 0.49331850f, 0.15657076f, 
    -0.23949140f, 0.21434388f, 0.09530186f, -0.13044955f, 0.11432463f, -0.24616531f, -0.04481680f, 0.11206116f, 
    0.04728114f, -0.14632346f, -0.00164190f, 0.64361501f, -0.12233748f, -0.17116387f, 0.05698412f, 0.37849495f, 
    -0.12742135f, -0.07511856f, -0.03161024f, 0.16206089f, 0.06293504f, 0.50942451f, 0.11510120f, -0.05803794f, 
    -0.06980774f, 0.53657466f, -0.13073355f, -0.00413582f, -0.28555912f, 0.15925667f, -0.16334380f, -0.11385953f, 
    0.44357792f, -0.15904912f, -0.15453704f, -0.12267391f, -0.07975319f, -0.30961156f, 0.05384774f, -0.01897192f, 
    0.16107929f, 0.03994851f, -0.02088707f, 0.07660060f, 0.14976811f, 0.14250304f, 0.11903901f, -0.11857494f, 
    -0.17385204f, 0.07477999f, 0.09195743f, 0.00972102f, 0.02176432f, -0.07999939f, 0.05118220f, -0.15804231f, 
    -0.02155733f, -0.01435487f, -0.03688795f, 0.12558229f, -0.20092621f, -0.01969838f, 0.09359922f, -0.19548708f, 
    0.02452352f, -0.09793416f, 0.10471671f, 0.05901235f, -0.13908873f, -0.09878340f, 0.16314611f, 0.07978782f, 
    -0.06133998f, -0.01341637f, -0.13069692f, -0.30661777f, 0.15436281f, 0.09536370f, 0.08734266f, -0.22024350f, 
    0.06053573f, -0.01911118f, -0.12411850f, -0.14040080f, -0.04609118f, -0.21342313f, 0.18913503f, -0.06298602f, 
    -0.10863005f, -0.26034421f, 0.94827473f, 0.23533855f, 0.23574498f, -0.09094267f, -0.17299296f, -0.08796223f, 
    0.05172673f, 0.20221511f, -0.05655289f, 0.01866127f, 0.15293410f, 0.19961445f, 0.16895017f, -0.09620240f, 
    0.15326819f, -0.03187206f, 0.04335857f, 0.03182319f, 0.12364783f, 0.03095380f, -0.15586680f, -0.08559918f, 
    0.13552944f, -0.00865850f, -0.03665674f, -0.09895530f, 0.06107563f, -0.08734011f, 0.10809495f, 0.00459679f, 
    0.00294847f, 0.11247445f, -0.17200480f, 0.06101631f, -0.17313917f, 0.05516723f, -0.15335955f, 0.11815389f, 
    0.01699789f, -0.09176300f, -0.06062200f, 0.10594746f, 0.06354573f, -0.02167296f, 0.17268267f, 0.12952211f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.16206880f, -0.24911188f, 0.00673264f, -0.10614709f, 0.13622613f, 0.04690199f, -0.12152755f, -0.16676904f, 
    0.28205869f, 0.18082380f, -0.06763867f, 0.10068948f, -0.12637974f, 0.03352892f, 0.49420339f, -0.01688552f, 
    0.36272368f, 0.14356343f, 0.26739517f, 0.13910760f, 0.28426832f, 0.08042258f, -0.08238652f, 0.09903392f, 
    0.12907514f, -0.06403299f, -0.00679011f, -0.28605828f, -0.01477284f, 0.35326591f, -0.18127941f, 0.32553124f, 
    0.33460978f, 0.00167979f, 0.12142397f, 0.24774262f, 0.32399762f, -0.36598471f, 0.02841761f, 0.15725051f, 
    0.08649477f, -0.31014508f, 0.24552673f, 0.03786849f, 0.40680793f, 0.15528399f, 0.29085764f, 0.30654910f, 
    -0.00011778f, 0.40584713f, 0.01505571f, 0.04422146f, 0.06794298f, 0.25625655f, -0.09659094f, 0.17010997f, 
    -0.01983484f, -0.05392145f, 0.26667416f, 0.44306004f, -0.19342791f, -0.15705112f, 0.17848854f, -0.17310040f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.01852901f, 0.27043891f, 0.23099919f, -0.30540296f, -0.35163334f, 0.20841597f, -0.01412846f, 0.13791457f, 
    -0.71444458f, -0.10471333f, -0.06950678f, 0.04886148f, 0.09898943f, 0.19167471f, -0.14436430f, 0.02551422f, 
    -0.18768868f, -0.74104738f, -0.52295142f, 0.15918145f, 0.32015893f, 0.17109439f, 0.48746410f, -0.58974987f, 
    -0.46418902f, -0.77197957f, 0.10770427f, -1.07206571f, -0.19721076f, 0.39661649f, -0.07212119f, 0.35561457f, 
    -0.14106488f, -0.19069122f, -0.09060532f, -0.11016415f, -0.10169615f, -0.31604227f, 0.05692661f, -0.08814632f, 
    -0.01718923f, 0.37037030f, 0.04699713f, -0.13361578f, -0.33448809f, 0.30422673f, 0.07526585f, 0.14307663f, 
    0.21007288f, 0.20034014f, 0.18740955f, 0.06666316f, 0.20155933f, -0.13744256f, 0.09971499f, -0.03112730f, 
    -0.12626153f, 0.37247020f, -0.04176504f, -0.02566302f, -0.09259593f, 0.07248562f, 0.36938882f, 0.08499503f, 
    0.15618603f, -0.33879188f, -0.56054771f, -0.16688445f, -0.28146797f, 0.38113695f, -0.04302554f, -0.05752536f, 
    -0.05163402f, 0.01216584f, -0.10008210f, 0.06712404f, -0.05603902f, -0.07923295f, 0.29142934f, -0.08550362f, 
    -0.17996074f, -0.40717348f, 0.26496771f, -0.12878269f, -0.71522790f, 0.07020944f, 0.02184054f, -1.28046751f, 
    0.24704292f, -0.17472678f, -0.02103310f, 0.07496583f, -0.15716301f, 0.20973472f, 0.04800569f, -0.01982101f, 
    -0.46816164f, 0.18367721f, -0.10749327f, -0.40109605f, 0.04642860f, -0.00068168f, -0.41630453f, 0.14866325f, 
    0.01368054f, -0.38969785f, -0.13330691f, -0.24743326f, 0.01917120f, 0.00384963f, 0.04146957f, 0.19347887f, 
    0.33783603f, 0.30052924f, 0.27036992f, -0.29449925f, 0.07377832f, -0.30882999f, -0.04437343f, -0.83861411f, 
    0.10219342f, -0.33964100f, 0.36133370f, -0.16602959f, 0.28777057f, -0.02146101f, 0.10829420f, 0.03092222f, 
    -0.23679458f, 0.07241346f, 0.16770570f, -0.00169191f, -0.47028056f, 0.23639013f, 0.04536374f, 0.16478808f, 
    0.15198553f, -0.02482472f, -0.03975858f, 0.10438777f, -0.11421297f, -0.09979495f, -0.04563427f, 0.05981692f, 
    0.20670117f, 0.06909038f, 0.14500584f, -0.21877989f, -0.85055465f, 0.27867597f, 0.13317162f, -0.32296067f, 
    -0.67307121f, 0.02771041f, -0.04883497f, -0.63745683f, 0.51275927f, 0.19402720f, -0.04308103f, 0.33065876f, 
    -0.45689148f, -0.33427936f, -0.01349145f, -0.12027403f, -0.28040111f, -0.08967892f, -0.81297719f, -0.09624130f, 
    0.00194293f, -0.97434705f, 0.16449511f, -1.32921135f, -0.12076336f, -0.53188145f, 0.28008205f, -0.09420584f, 
    -0.13252714f, 0.30309090f, 0.11572193f, 0.25511864f, 0.55030531f, 0.15714045f, -0.63266480f, -0.21257301f, 
    -0.48316219f, -0.24972364f, 0.31354484f, -0.52096713f, 0.40135327f, 0.00206939f, -0.67339742f, 0.01275827f, 
    0.00031025f, 0.10777964f, -0.53544599f, -0.12621666f, -0.59130758f, -0.11222528f, -0.06957139f, 0.22539920f, 
    0.26033509f, 0.06488385f, -0.03626311f, -0.01366009f, -0.06844722f, -0.41256753f, 0.12141591f, 0.03327848f, 
    -0.24387394f, 0.18682206f, -0.24677014f, -0.40374097f, -0.14810883f, -0.65300506f, 0.20171261f, -0.08355962f, 
    0.10341816f, 0.23060325f, 0.07611446f, 0.07660148f, -0.14746851f, -0.61438698f, 0.10662646f, -0.21496624f, 
    0.25241846f, 0.39796612f, -0.07482717f, 0.35455865f, -0.47591662f, -0.08007886f, -0.11034399f, -0.01465133f, 
    0.06341076f, -0.08775132f, 0.22912405f, 0.10178751f, -0.08478322f, 0.18043798f, -0.46368948f, -0.30690944f, 
    -0.14128305f, -0.46187633f, -0.45463091f, 0.06555479f, -0.57684034f, -0.06766906f, 0.21614283f, 0.22286564f, 
    0.31451663f, -0.01675102f, -0.27386045f, 0.18156795f, -0.55070144f, -0.03018016f, 0.33422720f, -0.10502012f, 
    -0.36185947f, 0.01909246f, 0.13961501f, -0.57658201f, 0.11238176f, -0.31104243f, 0.09908440f, 0.10966439f, 
    0.16105445f, 0.06851946f, -0.08077079f, -0.08817530f, 0.07512365f, 0.04632499f, 0.06499203f, -0.13947767f, 
    -0.18403956f, 0.16292967f, 0.17178373f, 0.01195696f, 0.40015012f, 0.14024399f, -0.43233383f, 0.10883714f, 
    0.12443496f, -0.21432705f, 0.01727796f, -0.92105192f, 0.11175330f, -0.04464893f, 0.08862542f, 0.29827973f, 
    0.16577965f, -0.17612436f, -0.03863807f, 0.04277863f, 0.29804334f, 0.21717896f, 0.11305477f, -0.06793424f, 
    -0.04655295f, 0.43753365f, 0.05845461f, 0.01613105f, -0.02363682f, 0.18284978f, 0.35669765f, 0.05463777f, 
    -0.20967163f, 0.08470528f, -0.12439132f, 0.09463014f, -0.21714930f, 0.05728231f, -0.24765024f, 0.14994806f, 
    -0.20892756f, 0.34157532f, -0.00096517f, 0.02648695f, -0.57274002f, 0.06688991f, 0.03332760f, 0.09796189f, 
    0.35298881f, -0.28155607f, -0.29405332f, -0.16234684f, 0.01359287f, -0.04642312f, 0.03783921f, -0.47675958f, 
    -0.54522431f, 0.07010581f, 0.04339255f, 0.08917185f, 0.03730969f, 0.42880055f, 0.08750382f, -0.12153706f, 
    -0.12371730f, 0.02657603f, 0.09053761f, 0.45181289f, -0.14000659f, -0.20359761f, -0.03408063f, -0.44046247f, 
    0.29258546f, 0.37386847f, 0.02860289f, 0.63400513f, -0.51875305f, -0.16804878f, -0.06764690f, -0.29146063f, 
    -0.17218857f, -0.42409423f, 0.05732977f, -0.38540971f, 0.30331212f, -0.26832348f, 0.12260032f, 0.22154814f, 
    0.09496763f, -0.22268994f, -0.21502335f, 0.33210731f, 0.18146025f, -0.03884948f, -0.12178718f, 0.20242094f, 
    0.08130290f, 0.01579891f, 0.10406300f, -0.54304111f, -0.29483390f, 0.06647763f, -0.43280721f, -0.05709767f, 
    0.02438908f, 0.49454582f, -0.00761177f, 0.09563281f, 0.04163402f, -0.04968014f, -0.21089703f, 0.02274333f, 
    0.33759084f, -0.56946105f, 0.09626690f, -0.23595826f, -0.61550099f, -0.38960102f, -0.09793017f, 0.01696719f, 
    -0.30774885f, -0.03214489f, -0.01478614f, -0.04783138f, -0.07155547f, -0.48580611f, 0.04819093f, -0.19486077f, 
    0.26638675f, 0.13468622f, -0.24985485f, 0.09047709f, -0.41468704f, -0.02478429f, 0.05744909f, 0.53711700f, 
    -0.40547422f, 0.09517834f, -0.01886121f, -0.08778612f, -0.09628204f, 0.40068570f, -0.00579796f, -0.43263543f, 
    0.20611428f, -0.07497966f, -0.00673321f, -0.05534151f, 0.34233946f, 0.18544261f, -0.24964878f, 0.17352583f, 
    -0.10022756f, 0.29832125f, 0.30333719f, -0.03400581f, 0.16427585f, -0.76860166f, 0.13494684f, -0.00623576f, 
    -0.15961611f, 0.06633902f, -0.56043494f, -0.70539081f, 0.00228545f, 0.30191278f, -0.48573464f, 0.33790985f, 
    0.03587213f, -0.63726366f, -0.44646993f, 0.06357068f, 0.25621718f, 0.08648997f, -0.51774949f, -0.03485078f, 
    -0.60958594f, 0.29368654f, -0.07817730f, -0.24154893f, -0.73006535f, -0.01337819f, 0.09442920f, 0.25941372f, 
    -0.36506373f, 0.03733096f, -0.03712389f, -0.06328107f, 0.02347302f, -0.49987820f, -0.79429036f, 0.06238234f, 
    -1.08374691f, -0.56574249f, 0.11821359f, 0.21654429f, 0.30581790f, 0.11009638f, -0.23051618f, 0.10585421f, 
    -0.00629424f, 0.13330148f, -0.02544794f, 0.47202727f, -0.48139739f, -0.13364582f, -0.08525778f, -0.00775847f, 
    -0.03234220f, 0.06233246f, 0.01843517f, 0.02927964f, -0.09572060f, 0.42999026f, 0.48142338f, 0.00523983f, 
    0.00281898f, 0.25710839f, 0.08704579f, 0.21100400f, -0.75181192f, 0.24202064f, -0.32406402f, -0.57539326f, 
    0.04577890f, -0.39513314f, 0.24554247f, 0.07995185f, 0.17357580f, 0.09636872f, 0.00644898f, 0.21474965f, 
    -0.02609648f, 0.32161877f, -0.13334557f, -0.04537883f, -0.06549364f, -0.11497290f, -0.17260364f, -0.11094810f, 
    -0.11958658f, 0.26255813f, 0.20900829f, 0.36644283f, -0.16481836f, 0.44905999f, 0.06347749f, -0.43061143f, 
    -0.19277963f, 0.09931489f, 0.05258125f, -0.12099529f, 0.03771968f, 0.50317949f, 0.21175836f, -0.20561431f, 
    -0.10268284f, -0.52642101f, 0.21485880f, -0.11401583f, -0.14946243f, 0.13730653f, -0.14208511f, -0.17456208f, 
    -0.07243063f, -0.07768559f, -0.06659643f, -0.41757819f, -0.00657214f, -0.58446813f, -0.04092088f, -0.02891337f, 
    -1.03007078f, -0.44556653f, -0.00059074f, -0.84866130f, -0.30735013f, -0.18020812f, 0.03046067f, 0.06605956f, 
    -0.04229384f, -0.05023536f, -1.05504405f, 0.08786405f, 0.19120000f, -0.23595642f, -0.51383591f, 0.24182102f, 
    -0.02209566f, -0.15517464f, 0.40102613f, 0.25747141f, -0.09428138f, -0.76505780f, 0.53425795f, -0.49821782f, 
    -0.31060049f, -0.05370529f, 0.22868155f, -0.62188059f, 0.21614659f, -0.05219994f, 0.12945876f, 0.06520587f, 
    -0.04959632f, 0.06821845f, 0.34440354f, 0.43723851f, -0.05924144f, -0.53158098f, -0.00592215f, 0.14252423f, 
    -0.25639659f, -0.00972601f, -0.05026813f, 0.07410076f, 0.02223372f, -0.45679864f, -0.03957333f, 0.01360028f, 
    -0.12107588f, -0.71735573f, 0.15698703f, 0.32892042f, 0.49526048f, 0.28670216f, -0.19332656f, -0.19044740f, 
    -0.20453508f, 0.01490966f, 0.08900820f, -0.04555579f, -0.08497291f, -0.35215139f, -0.01807472f, -0.33585671f, 
    0.23965566f, -0.56832188f, 0.02896716f, -0.07863550f, 0.47782484f, 0.09828761f, 0.36162710f, 0.06407310f, 
    0.00226283f, -0.60463113f, 0.16972040f, -0.08676850f, 0.21371903f, -0.12786241f, -0.00161578f, 0.09230814f, 
    -0.97826982f, -0.39295039f, 0.07856034f, 0.04911779f, 0.10481629f, 0.11135826f, -0.41173312f, 0.34697375f, 
    -0.07602157f, -0.40457097f, -0.51190811f, -0.08426209f, 0.18358639f, 0.04665458f, -0.55460483f, 0.04766196f, 
    0.16517721f, -0.17381978f, -0.62612075f, -0.01517446f, -0.38552636f, -0.18729550f, -0.06250934f, -0.18078418f, 
    0.57893234f, -0.09924643f, -0.02319409f, -0.00392462f, 0.00896400f, 0.17162965f, 0.29468015f, 0.02069030f, 
    0.33603868f, 0.40479094f, -0.70824498f, -0.88912153f, -0.32458749f, -0.16939312f, -0.52101469f, 0.29294246f, 
    -0.10613081f, 0.35052744f, 0.01785451f, -0.49061033f, 0.02707009f, -0.33632246f, 0.07606431f, -0.35562897f, 
    -0.03108520f, 0.32558548f, 0.04866021f, 0.10871410f, -0.83304781f, -1.22926331f, -0.45982423f, -0.87651598f, 
    -0.04486125f, -0.35923171f, -0.48317423f, -0.04401398f, 0.12610357f, 0.18443018f, -0.18296163f, -0.14323203f, 
    -0.01441609f, 0.18275107f, -0.13230003f, 0.10534859f, -0.45580262f, -0.21696483f, 0.55037272f, -0.15267597f, 
    0.19645546f, -0.47777697f, 0.10363743f, 0.30053815f, 0.15293755f, 0.06043445f, -0.16201857f, 0.00458005f, 
    0.09587951f, 0.13933350f, 0.09469425f, 0.16152048f, 0.53522295f, -0.09570410f, -0.06645942f, -0.32457975f, 
    0.07467552f, -0.08505590f, 0.10475184f, -0.05006059f, 0.12019068f, 0.28281638f, -0.14177305f, -0.00114304f, 
    0.09113266f, 0.48776409f, -0.19987687f, -0.23474471f, -0.31217173f, -0.79904985f, -0.36572120f, 0.26735079f, 
    -0.69154072f, 0.03651416f, -0.12009520f, 0.02213210f, 0.23148584f, -0.13979425f, 0.04324410f, -0.63055795f, 
    0.27012697f, 0.02829631f, 0.09223033f, 0.36151528f, -0.69574541f, 0.04435664f, -0.87984717f, 0.08386694f, 
    -0.10929560f, -0.25647366f, 0.17522715f, -0.09514537f, 0.12467671f, -0.62550294f, 0.20439057f, -0.00602536f, 
    0.15888619f, -0.20836040f, -0.41181016f, 0.18066189f, -0.20468105f, 0.25585920f, -0.03526419f, -0.14077280f, 
    -0.19739132f, -0.34584031f, 0.09478541f, 0.03704246f, -0.49281198f, 0.06948619f, 0.46153569f, 0.11920080f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.00920963f, 0.18657677f, -0.10018010f, 0.00228301f, 0.00181182f, -0.07392371f, 0.04763538f, -0.24054725f, 
    -0.30401713f, -0.04758580f, 0.18437652f, 0.11763194f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
