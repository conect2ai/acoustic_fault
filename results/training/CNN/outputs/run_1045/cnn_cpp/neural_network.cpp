#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.37855324f, 0.43361792f, 0.35826111f, -0.20088612f, 0.25759754f, -0.31113479f, -0.27168566f, 0.30745089f, 
    0.16512704f, -0.45986339f, -0.26635540f, -0.42110220f, -0.39901510f, -0.74565703f, -0.45048961f, 0.17338505f, 
    0.24269314f, 0.26829419f, -0.37063611f, 0.45673481f, -0.74105793f, -0.18456310f, -0.15437897f, -0.41107208f, 
    -0.47062626f, 0.43268499f, 0.27821267f, 0.62475282f, 0.58346945f, -0.68305242f, -0.39405283f, -0.12930696f, 
    -0.19972076f, -0.42255315f, -0.38042358f, -0.64906669f, -0.26736861f, -0.34903523f, -0.32570365f, -0.30949587f, 
    -0.70850682f, -0.81326371f, 0.44626588f, 0.15028965f, 0.09049536f, 0.90255278f, -0.48702663f, -0.40850389f, 
    -0.15609486f, 0.47781551f, -0.25220320f, -0.50034976f, 0.48099214f, 0.08114762f, -1.04070091f, 0.65585554f, 
    0.06129379f, 0.25695273f, 0.27361819f, -0.16945376f, -0.19432402f, -0.00818057f, 0.16950765f, 0.05028231f, 
    0.40416375f, 0.28633705f, 0.06596931f, 0.00184092f, 0.30892318f, 0.23019113f, -0.15552878f, -0.18753000f, 
    0.49656138f, -0.64738208f, 0.14929071f, -0.47236770f, -0.41239366f, -0.47959840f, -0.09120539f, 0.35223576f, 
    -0.06776143f, -0.09513105f, -0.05882764f, 0.46466798f, 0.40521714f, -0.14706179f, 0.10740342f, 0.57539719f, 
    -0.40854403f, -0.40411562f, 0.59927094f, -0.37951970f, -0.50606239f, 0.03377176f, -0.39996845f, 0.31833515f, 
    0.26571718f, 0.17122544f, 0.10361901f, 0.62296945f, -0.04701097f, -0.31100786f, 0.34011537f, -0.24411219f, 
    -0.55879110f, 0.21390879f, 0.06453836f, 0.33584240f, -1.03914058f, -0.71847856f, 1.06134963f, -0.08602946f, 
    -1.03435814f, -0.41338268f, 0.16837007f, 0.05609392f, 0.37602937f, -0.99271929f, 0.89106917f, 0.29116499f, 
    -0.63473934f, -0.16769837f, 0.40772858f, -0.36572218f, 0.07004721f, -0.31793067f, 0.59521896f, -0.58072811f, 
    0.52114928f, -0.17365514f, -0.08858200f, -0.10599743f, 0.17341909f, -0.14182958f, -0.01425336f, -0.48981243f, 
    -0.37853041f, -0.25206023f, -0.27010974f, -0.15382253f, 0.02830782f, -0.16653566f, -0.33467317f, -0.45342401f, 
    -1.27416503f, 0.52804637f, 0.61540312f, -0.47823146f, 0.32999533f, 0.17357616f, 0.27641368f, -0.01338435f, 
    -0.26189700f, 0.48301598f, 0.15335938f, 0.31154957f, -0.29497474f, -0.22153531f, -0.29605228f, 0.22901838f, 
    0.16611432f, 0.26943946f, -0.30497566f, -0.70612526f, 0.60127187f, 0.54510570f, 0.01461525f, -0.31550094f, 
    0.00396961f, -0.17454274f, 0.18060045f, 0.23033559f, 0.24869218f, 0.32171226f, -0.22345233f, -0.33760908f, 
    0.25557405f, -0.24921113f, -0.08773505f, 0.43265530f, 0.66465127f, 0.70257533f, 0.32858303f, -0.90959877f, 
    -0.23257534f, -0.12210158f, -0.00302748f, -0.31533039f, 0.18960758f, 0.78046119f, -0.66149628f, -0.93703973f, 
    0.40864953f, 0.49920133f, 0.24867730f, -0.38181046f, 0.39151135f, -0.15310615f, 0.36898944f, -0.28197449f, 
    -0.80531633f, 0.43454808f, 0.61778116f, 0.56256241f, -0.46423972f, -0.33344293f, -0.09896308f, -0.79891104f, 
    -0.66980231f, -0.11285558f, 0.73146814f, 0.62269825f, -0.02511423f, 0.06357292f, -0.34925804f, -0.13057075f, 
    -0.39923143f, -0.65798658f, 0.24994138f, -0.04464315f, 0.06935119f, 0.21516009f, -0.64217800f, -0.54161501f, 
    -0.68349487f, 0.31115174f, -0.22543696f, -0.62777191f, -0.25608516f, 0.13927308f, 0.00758110f, 0.29387516f, 
    0.15187967f, 0.24668278f, -0.91619390f, -0.05280606f, 0.76176065f, 0.10075769f, 0.46920490f, -0.30381188f, 
    -0.21680476f, 0.26170614f, -0.54583752f, 0.00388247f, 0.24705055f, -0.07374380f, 0.03655808f, 0.46781671f, 
    -0.34088486f, 0.50977468f, -0.35816175f, -0.12031493f, -0.05354768f, 0.12245958f, 0.58042479f, -0.50057507f, 
    -0.52977008f, -0.36852461f, 0.22230326f, 0.26701602f, 0.44438207f, -0.26611754f, -0.52390659f, -0.11357322f, 
    0.14620979f, 0.37119424f, 0.19276653f, -0.50468230f, 0.32014519f, -0.51158738f, 0.53545696f, -0.04446323f, 
    -0.34237289f, 0.51213074f, 0.14035721f, -0.58464068f, 0.44591784f, -0.05658617f, -0.36220905f, 1.06168652f, 
    -1.28759718f, -0.18963023f, -0.37633064f, 0.26823148f, 0.29290318f, -0.28163636f, -0.26287347f, -0.01809229f, 
    -0.16499899f, 0.05973272f, 0.10618117f, 0.21912321f, -0.22820213f, 0.10841917f, -0.08505194f, 0.31378618f, 
    -0.10811924f, 0.62440068f, -0.19140127f, -0.31418103f, 0.30108914f, -0.04551402f, 0.09067619f, -0.49148461f, 
    -0.11161690f, 0.35422495f, -0.53286773f, 0.87782323f, -0.05510597f, -0.53723043f, 0.11326969f, -0.49057233f, 
    -0.08464042f, 0.44717363f, -0.23577505f, 0.30037811f, -0.49003300f, 0.37068489f, -0.54490793f, 0.60430968f, 
    0.60660744f, -0.34178457f, -0.40767267f, -0.23681907f, -0.65790093f, -0.63592285f, 0.52889973f, 0.63204640f, 
    0.18803190f, -0.45399106f, 0.04941453f, -0.40139765f, -0.49245715f, -0.66300863f, -0.12538475f, 0.43738666f, 
    0.40135196f, 0.33893991f, -0.04856640f, -0.24229965f, 0.17562589f, 0.00323403f, -0.82877278f, 0.25332928f, 
    0.26817131f, -0.67360836f, -0.64785475f, -0.52917540f, 0.39980280f, -0.66696000f, -0.58254963f, -0.20281446f, 
    0.58513325f, -0.70578867f, -0.50485766f, -0.41558939f, -0.37701732f, -0.32638693f, -0.35557073f, -0.09712125f, 
    0.04775324f, -0.28723162f, 0.09872167f, -0.66631490f, -0.24465032f, -0.36884600f, 0.02874892f, -0.42128649f, 
    0.28640389f, 0.29875210f, -0.19139177f, -0.41819784f, -0.20210215f, 0.92090386f, -0.76666772f, -0.42750669f, 
    0.28457275f, 0.13536353f, -0.56197751f, -0.33210689f, -0.16060297f, -0.25404480f, -0.36517537f, 0.49435437f, 
    0.02638522f, 0.23612359f, 0.38013360f, 0.13846652f, -0.47879189f, 0.18446101f, 0.36608365f, -0.46336517f, 
    -0.57161665f, 0.22278200f, 0.35343772f, 0.38095754f, -0.72022015f, -0.10270126f, -0.35691744f, 0.86095589f, 
    -0.19376865f, -0.72715545f, -0.07692998f, -0.14399680f, 0.27936026f, -0.48966795f, -0.45777169f, -0.11404234f, 
    -0.15733707f, -0.71843010f, -0.28663224f, 0.13528609f, 0.45076096f, -0.03894931f, 0.91361290f, -0.13472827f, 
    -0.88780236f, -0.11895815f, -0.04645549f, 0.13939527f, -0.01396944f, 0.22857517f, -0.00983376f, -0.85485083f, 
    -0.09718093f, -0.74377364f, 0.23093264f, 0.22997342f, 0.32164088f, 0.15352407f, 0.06999397f, 0.05176410f, 
    -0.70320332f, 0.01913825f, 0.18644956f, -0.30910325f, 0.05590980f, 0.02949417f, 0.16696918f, 0.52038693f, 
    -0.12489558f, -0.20831093f, 0.42736128f, 0.13247216f, 0.27141121f, -0.04705071f, -0.28766298f, -0.41953331f, 
    0.56077594f, -0.39432517f, -0.33438075f, 0.05240933f, -0.87394077f, -0.18410935f, 0.08897916f, -0.59005487f, 
    -0.49164984f, -0.52297658f, -0.18617693f, -0.08884237f, -0.26946700f, 0.29210272f, 0.41925189f, 0.28916472f, 
    -0.44986382f, -0.42293248f, -0.06768753f, 0.43951055f, 0.25539738f, -0.49235669f, -0.19972520f, 0.33385473f, 
    0.08678770f, 0.02731770f, 0.23238568f, 0.18924357f, -0.30569309f, 0.67433196f, -0.77736336f, -0.29329455f, 
    0.09706663f, -0.77135468f, -0.29417440f, -0.58788437f, -0.06064869f, -0.34152141f, -0.62726974f, -0.77886558f, 
    -0.40492466f, -0.09196826f, 0.42101505f, -0.17501579f, 0.06126171f, -0.40730637f, -0.53725290f, 0.24940248f, 
    0.44960204f, -0.36139894f, -0.38652173f, 0.53309274f, -0.13090678f, 0.09532776f, 0.08044634f, -0.04457643f, 
    0.06952102f, 0.10635092f, -0.09143391f, 0.00964448f, -0.14426889f, 0.08707387f, 0.09788907f, -0.44128701f, 
    0.38139859f, 0.32982919f, 0.01038442f, 0.37829787f, 0.16946667f, 0.38092443f, 0.36113307f, 0.12698689f, 
    0.10851212f, -0.20446451f, -0.79809678f, -0.22693452f, -0.68522340f, 0.20090091f, 0.24323779f, 0.27630693f, 
    0.26125169f, 0.21567228f, 0.03204931f, -0.40944058f, -0.18859547f, 0.63972032f, 0.05609760f, -0.55971557f, 
    0.15508263f, 0.19261892f, -0.03357419f, 0.07483365f, 0.44970334f, -0.51271266f, -0.35781518f, 0.59125620f, 
    -0.59501308f, 0.32827294f, -0.37122250f, 0.32119662f, -0.09372311f, -0.74033529f, 0.14079189f, -0.62011290f, 
    0.25843182f, 0.26495725f, -0.27199036f, 0.37922609f, 0.04488051f, 0.33787730f, 0.74797094f, 0.69026542f, 
    -0.82358384f, -0.14919326f, -0.16600494f, -0.17240588f, 0.06642912f, 0.35499057f, -0.37838525f, 0.60360318f, 
    -0.15158051f, -0.09393124f, 0.39642733f, 0.42961073f, -0.40842274f, -0.17219479f, -0.34839183f, -0.12047355f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.15250051f, -0.21012954f, -0.11901745f, -0.00867264f, -0.13479096f, 0.07381137f, 0.01110425f, -0.13946638f, 
    0.26599708f, -0.17286307f, -0.16098373f, -0.04933245f, 0.03102011f, 0.18890482f, 0.20961294f, 0.02052272f, 
    0.02752422f, -0.10423466f, 0.03272691f, -0.01636270f, 0.21227904f, 0.10458624f, 0.10108398f, -0.04484416f, 
    -0.12703279f, 0.16294903f, -0.01282527f, -0.03306669f, 0.03772560f, 0.01450605f, 0.23139310f, 0.08260885f, 
    0.12770075f, 0.13719910f, 0.08672187f, 0.13278620f, 0.06013774f, 0.13820022f, -0.18631317f, -0.06981982f, 
    0.26041144f, -0.02344903f, 0.31441924f, 0.09366354f, 0.00086566f, -0.16872516f, 0.09235401f, 0.26547241f, 
    -0.02390125f, 0.04326475f, -0.46328047f, 0.13518609f, 0.12628473f, 0.00584764f, -0.22242726f, 0.18356194f, 
    0.04302669f, -0.27952123f, 0.19220652f, -0.08512321f, 0.14844063f, 0.10106175f, 0.16599149f, 0.27874514f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.05969533f, -0.10298484f, -0.06245467f, 0.08407520f, -0.11579269f, -0.03208960f, -0.13538449f, 0.03215051f, 
    0.09178599f, -0.01366547f, -0.00059925f, 0.08474032f, -0.01591169f, -0.03072910f, -0.09366999f, -0.12328079f, 
    0.01284646f, 0.02272670f, -0.06260172f, -0.11844252f, 0.35429180f, 0.31863269f, 0.01879292f, -0.33080167f, 
    -0.14293514f, 0.06846846f, 0.07210928f, -0.00075829f, 0.04460535f, 0.07450242f, 0.03019569f, -0.00536790f, 
    0.02642334f, 0.02875806f, 0.00796729f, -0.00351828f, -0.04598026f, 0.03377752f, -0.06823551f, 0.04402169f, 
    0.16691497f, 0.12143138f, -0.16578856f, -0.08278978f, -0.29230210f, 0.12438338f, 0.17285620f, 0.13727716f, 
    0.04481842f, 0.11850209f, -0.05404320f, -0.00477336f, 0.01235079f, 0.00670319f, 0.05474199f, -0.04990917f, 
    -0.00552112f, -0.05454476f, -0.10082735f, 0.03474756f, -0.07965371f, 0.17388369f, 0.19671121f, -0.07259921f, 
    -0.36966175f, -0.07519244f, -0.06793243f, -0.08173747f, 0.05569100f, 0.04198996f, 0.00207202f, -0.03891243f, 
    -0.00383988f, 0.03182551f, 0.05814187f, 0.07082029f, 0.05430057f, 0.10340317f, 0.04528615f, 0.10086922f, 
    0.28308734f, 0.28027219f, -0.01345002f, -0.28304878f, -0.14195998f, 0.06883365f, 0.10957199f, -0.04773300f, 
    0.06639040f, 0.11929742f, 0.06879890f, 0.00569322f, 0.02412461f, 0.01639464f, 0.02606195f, 0.01913081f, 
    -0.01117505f, -0.00289970f, 0.01866613f, 0.10618459f, -0.26513717f, -0.02137293f, 0.06135483f, 0.04960980f, 
    -0.11152330f, -0.10710838f, -0.03631664f, -0.09040433f, -0.26089072f, -0.03580438f, -0.12046116f, -0.05159302f, 
    -0.03955242f, -0.13048896f, -0.14155547f, -0.15313041f, 0.03720765f, 0.07652386f, -0.13569345f, 0.07854797f, 
    -0.07871171f, -0.00325620f, -0.12148353f, -0.04966910f, 0.07740086f, -0.01999964f, -0.00374422f, 0.05386858f, 
    0.05291571f, -0.01217771f, -0.04108983f, -0.02860396f, -0.02803155f, -0.03206625f, 0.01745656f, -0.06916911f, 
    0.00836837f, 0.05558930f, -0.09419118f, -0.03898785f, -0.01589961f, -0.07871903f, -0.04502877f, 0.03258359f, 
    -0.02022012f, 0.01652245f, 0.01405824f, -0.00080437f, 0.04985738f, 0.01142000f, 0.00471314f, 0.02997745f, 
    0.02637121f, 0.04280046f, 0.04442926f, -0.10993195f, -0.09612054f, 0.04206676f, -0.02265813f, 0.02394772f, 
    0.05822118f, 0.14515540f, -0.11631662f, -0.25569165f, -0.12576307f, 0.02242421f, 0.01069027f, 0.01987157f, 
    -0.05028560f, 0.01281884f, -0.01493604f, 0.02358189f, 0.02998286f, 0.00262721f, -0.02523504f, -0.01153938f, 
    -0.01196309f, -0.01082296f, 0.05048785f, 0.05580341f, -0.12428421f, -0.18914652f, -0.12980747f, -0.07252754f, 
    -0.02550948f, -0.01314128f, 0.02210893f, 0.00425293f, 0.03690026f, 0.01999195f, 0.00967539f, 0.02505702f, 
    -0.00998731f, 0.05549181f, 0.09506006f, -0.01920325f, -0.17687120f, -0.02420733f, 0.03097825f, 0.12417137f, 
    0.11114345f, 0.03219341f, -0.05293463f, 0.01064788f, 0.04351735f, 0.02581498f, 0.01211269f, 0.02281091f, 
    0.06386656f, -0.03193960f, -0.09060413f, 0.12479855f, -0.00564113f, 0.02019436f, -0.00051866f, -0.03553905f, 
    -0.03180600f, 0.01733991f, -0.00095052f, 0.02641342f, 0.09370558f, 0.02308673f, -0.08022745f, 0.10973982f, 
    -0.01089697f, -0.05626316f, -0.02646521f, -0.05900001f, 0.10548015f, -0.01865789f, -0.03912826f, 0.04967012f, 
    -0.02465393f, 0.01220507f, -0.01256534f, -0.04279196f, -0.01212067f, -0.14459713f, -0.08977795f, -0.14578362f, 
    0.43446320f, 0.35485908f, 0.20779368f, -0.57102942f, 0.02638785f, -0.01108817f, 0.05235359f, 0.03751866f, 
    -0.00115455f, 0.06629600f, 0.11024774f, -0.07806059f, -0.00560963f, -0.00991105f, -0.03565838f, 0.03171367f, 
    -0.01780996f, -0.02640602f, 0.00849687f, -0.07567348f, -0.44296607f, 0.13793668f, 0.18974440f, 0.05566342f, 
    -0.07521397f, -0.32600549f, -0.18438253f, -0.04064055f, -0.05446094f, -0.14469132f, -0.00549196f, 0.00332582f, 
    -0.01239164f, 0.00730694f, 0.01562963f, -0.04156750f, 0.11989667f, -0.04493146f, -0.15637349f, -0.00372643f, 
    -0.33369684f, -0.20968862f, 0.04098664f, -0.37365136f, 0.10365342f, -0.07076371f, 0.00885931f, 0.02980042f, 
    -0.02431178f, 0.01467597f, -0.01271869f, -0.00723101f, 0.05212372f, 0.03121877f, 0.02343464f, -0.12004144f, 
    -0.05415358f, -0.13916188f, -0.14963830f, -0.02500676f, 0.23398933f, 0.14326300f, 0.11361532f, -0.11569274f, 
    -0.03040854f, 0.07795843f, 0.12770610f, 0.09000627f, -0.02280716f, 0.04193885f, -0.01981707f, -0.00262396f, 
    -0.03170003f, -0.13311745f, -0.05342008f, 0.06674992f, -0.16379726f, -0.06565679f, 0.02529795f, 0.00654941f, 
    -0.49320239f, 0.04786624f, 0.51626790f, -0.02375707f, -0.08284888f, -0.30501157f, 0.10411479f, 0.18707615f, 
    0.10383987f, -0.16884813f, -0.14572598f, 0.00196674f, -0.16343603f, -0.06654126f, 0.00955975f, 0.01053837f, 
    -0.03476167f, 0.02394064f, -0.15730010f, 0.05148612f, 0.00819837f, 0.01484938f, -0.03329245f, 0.00858096f, 
    -0.01594238f, -0.18909858f, -0.13686392f, 0.01078680f, 0.08146074f, 0.00686390f, 0.03422265f, 0.03584259f, 
    0.08134194f, 0.07040490f, -0.00446734f, -0.00666760f, 0.01671326f, -0.06718943f, -0.10195025f, -0.04839652f, 
    0.22130658f, -0.01269721f, -0.18029006f, -0.15338594f, 0.04015773f, -0.00909614f, 0.00294191f, 0.02451937f, 
    -0.02088743f, -0.04208177f, 0.04170500f, -0.07969124f, -0.06493771f, -0.09826680f, 0.02766559f, -0.05674066f, 
    0.05542148f, 0.04432095f, -0.01990074f, -0.04663328f, -0.09207825f, -0.07142638f, 0.06984600f, 0.01192810f, 
    0.00881314f, 0.03046402f, -0.01260520f, -0.02074285f, 0.00045846f, 0.01647265f, 0.04324643f, 0.03698370f, 
    0.03483332f, 0.05554745f, 0.03112846f, -0.08490048f, -0.08007411f, -0.06736907f, 0.01588031f, -0.05310071f, 
    -0.56082982f, -0.13903083f, 0.26222971f, -0.21378762f, -0.27262262f, 0.03177362f, -0.08038034f, -0.11032760f, 
    -0.02080814f, 0.03647182f, 0.01474683f, 0.02280368f, -0.01023932f, 0.05469975f, 0.08652335f, 0.07091685f, 
    0.09255789f, -0.12500782f, -0.06772913f, -0.06574713f, -0.04087285f, -0.31145433f, -0.51848131f, 0.16174309f, 
    0.06737506f, 0.10929208f, -0.00705054f, -0.02221437f, -0.09590209f, -0.00381792f, -0.02364667f, -0.03037524f, 
    -0.19210188f, -0.21492408f, -0.11997554f, -0.00029595f, 0.07376933f, -0.02480926f, -0.03862525f, 0.02543643f, 
    0.14289241f, -0.34316763f, -0.43801257f, 0.11851838f, -0.06936912f, 0.00841390f, 0.05238111f, 0.05197261f, 
    0.03781011f, 0.04344197f, -0.03980451f, 0.01015888f, -0.00668547f, 0.05552000f, -0.05819584f, 0.02325701f, 
    0.06761888f, 0.02220651f, 0.03964381f, -0.00659874f, 0.42538172f, 0.09370020f, -0.38047102f, -0.08728926f, 
    -0.02439851f, 0.06996992f, 0.08750236f, 0.02593924f, -0.08286096f, -0.01280157f, -0.01567735f, 0.03255768f, 
    -0.02595843f, 0.03962042f, 0.02272235f, 0.02601352f, 0.07250506f, 0.07568335f, 0.02361592f, 0.02478399f, 
    0.26653507f, 0.08896259f, 0.25916204f, -0.10201825f, 0.01465893f, -0.06329542f, -0.03571592f, 0.08183722f, 
    -0.06684607f, -0.07467193f, 0.01049314f, 0.00279121f, 0.03066661f, -0.07087708f, -0.19658305f, 0.05649996f, 
    -0.07271875f, 0.03141231f, 0.06827220f, 0.03938350f, 0.09897043f, 0.13094802f, -0.08865178f, 0.00620366f, 
    -0.02687799f, 0.05451448f, -0.00829193f, 0.01719688f, -0.01851836f, -0.06579490f, -0.09479459f, -0.00688883f, 
    -0.09125419f, 0.04049246f, 0.01182263f, -0.04198274f, -0.02421245f, -0.03109924f, -0.03134871f, -0.03841323f, 
    0.29456848f, -0.02286858f, 0.03420158f, -0.34527653f, 0.02162351f, -0.12107711f, -0.08984081f, 0.15475319f, 
    0.13966657f, 0.06691926f, -0.06290310f, 0.05237841f, -0.14261238f, -0.14569233f, -0.24353890f, 0.12665397f, 
    0.00899448f, -0.04897701f, 0.03685575f, 0.13869318f, -0.13721465f, -0.11780433f, -0.05451294f, 0.05611371f, 
    -0.03802011f, -0.06005310f, 0.00862839f, -0.00654831f, 0.04664724f, 0.03611799f, -0.04231680f, 0.03693820f, 
    -0.01737182f, 0.06049065f, -0.00432115f, -0.10107522f, -0.03723356f, 0.01599260f, -0.00788571f, 0.00263887f, 
    0.11657856f, 0.09134245f, 0.07022118f, -0.03256852f, -0.00450902f, -0.13060135f, -0.03857176f, -0.06091050f, 
    -0.05044168f, -0.07759022f, 0.02759713f, 0.02502165f, 0.02099452f, 0.00174717f, -0.05709189f, -0.02569452f, 
    -0.02404282f, -0.00021649f, -0.10219794f, -0.16673046f, 0.20400681f, -0.01688324f, -0.10944569f, -0.07546579f, 
    -0.08052727f, -0.04213608f, -0.08104799f, 0.18129504f, -0.04806553f, -0.04933476f, -0.01649820f, 0.03629192f, 
    0.01968269f, -0.04239539f, -0.06963272f, 0.02706386f, 0.01722967f, 0.03830618f, 0.04291572f, 0.05026337f, 
    -0.09170864f, -0.19825190f, -0.28060669f, 0.18518752f, 0.01060174f, -0.09292487f, -0.06008514f, -0.11717223f, 
    -0.02255245f, 0.00783383f, -0.07923497f, -0.10752312f, 0.03747998f, -0.05394571f, -0.08424326f, -0.09602695f, 
    -0.07964141f, 0.00049315f, -0.13717027f, 0.01974235f, 0.19020675f, -0.03828107f, 0.07700387f, -0.06091285f, 
    -0.13021471f, -0.00509532f, -0.08859985f, 0.09587578f, -0.26620063f, 0.02825976f, -0.04484888f, 0.04258586f, 
    -0.11900858f, -0.18557666f, -0.04869014f, -0.04234874f, -0.01381199f, 0.01117978f, -0.00557355f, 0.04186580f, 
    -0.01913300f, -0.06111361f, 0.06706899f, 0.00171485f, 0.02604251f, -0.00105986f, 0.01232793f, 0.04496298f, 
    0.02057878f, 0.01798530f, -0.20459348f, 0.03495836f, -0.07323305f, -0.08282713f, -0.02868558f, -0.02694312f, 
    -0.02285244f, -0.05103470f, -0.04624302f, -0.01931845f, -0.37769845f, -0.28032684f, 0.04381676f, 0.06550767f, 
    0.00841167f, 0.01480767f, 0.02032224f, -0.04369574f, 0.02009038f, -0.01806832f, 0.08211078f, -0.09385777f, 
    -0.01937729f, -0.01954062f, -0.04745183f, -0.07238174f, 0.01439809f, -0.17041612f, 0.05393621f, -0.14336210f, 
    -0.02801935f, 0.11310134f, -0.12190299f, -0.04378786f, -0.21707968f, -0.03627153f, -0.02103329f, -0.08088291f, 
    0.03736398f, 0.03646413f, 0.02337510f, 0.03047476f, -0.03983812f, 0.00551842f, -0.02463216f, -0.10724078f, 
    0.05847929f, -0.03519447f, -0.15709962f, 0.05368801f, -0.04755884f, -0.29513672f, 0.31793833f, 0.00214936f, 
    -0.06323972f, -0.00950490f, -0.00882974f, 0.02619092f, 0.05621491f, 0.07119595f, 0.07156071f, 0.02031358f, 
    0.03484641f, 0.01944171f, -0.01159570f, -0.03590095f, 0.05051082f, -0.01883804f, -0.11320911f, -0.00774528f, 
    0.37441853f, 0.10660914f, -0.11773680f, -0.24843688f, -0.01737451f, -0.15268971f, -0.06987104f, 0.01508914f, 
    -0.02062399f, -0.04682819f, 0.00336741f, 0.04304369f, -0.09372584f, -0.03977206f, -0.03079468f, -0.07310612f, 
    -0.02750665f, 0.09462696f, 0.00171718f, 0.03901250f, 0.01733904f, -0.09027086f, -0.08834141f, -0.04397248f, 
    0.02126480f, -0.03220594f, -0.02296837f, 0.06371969f, 0.04080314f, 0.00593782f, -0.11969474f, -0.04488499f, 
    -0.07418957f, -0.08850165f, -0.09767753f, -0.00569933f, 0.03974069f, 0.01008698f, -0.02846789f, 0.00342240f, 
    0.16820985f, 0.31819808f, 0.23326850f, -0.30994517f, 0.02189616f, 0.05385358f, 0.20022555f, -0.07551469f, 
    0.04824610f, 0.08902492f, -0.00128623f, -0.02743486f, 0.00454286f, -0.03616845f, 0.00271341f, -0.11950145f, 
    -0.04855125f, -0.05418595f, 0.00212085f, 0.14276274f, 0.00719936f, 0.21365036f, 0.12098507f, -0.09635274f, 
    -0.14393587f, 0.01163218f, 0.11013566f, 0.05762267f, -0.07218171f, 0.01866901f, -0.01819319f, -0.06553358f, 
    0.00920568f, 0.01694210f, 0.01540826f, -0.08425008f, -0.02313783f, -0.00450360f, -0.06678460f, 0.02570458f, 
    0.14159735f, 0.14129944f, 0.07158761f, -0.24614820f, -0.04905777f, 0.02224472f, 0.02438693f, 0.03051235f, 
    -0.07375620f, -0.01343257f, -0.03782402f, -0.01391599f, -0.00104145f, -0.01230566f, -0.06260094f, -0.02762377f, 
    -0.04190333f, 0.00941893f, 0.00913750f, -0.10067356f, 0.04738736f, 0.17320129f, -0.06206369f, 0.08919000f, 
    -0.18702085f, 0.09448826f, -0.10029914f, 0.12864579f, -0.18770610f, 0.15763965f, -0.09481603f, 0.01829041f, 
    -0.01861785f, -0.08394398f, -0.03434072f, -0.08776359f, -0.02235823f, 0.01394148f, -0.18901354f, 0.05560226f, 
    0.15226828f, 0.12900957f, 0.14982434f, -0.11345655f, -0.04103535f, 0.04437675f, 0.04110533f, 0.07935678f, 
    -0.16338542f, -0.17408067f, -0.11633769f, -0.12457531f, 0.03712238f, 0.01442859f, 0.03869691f, -0.01300985f, 
    -0.07394264f, -0.00616072f, -0.01327272f, -0.05864335f, 0.14959067f, 0.14608061f, -0.03273538f, -0.03490550f, 
    0.01591120f, -0.09198467f, 0.08935300f, -0.06850789f, -0.13426316f, -0.06914845f, 0.07892318f, -0.04250135f, 
    0.01615578f, 0.02388266f, -0.02347888f, -0.02912902f, 0.00481585f, -0.08141398f, -0.03720301f, 0.03230395f, 
    0.27580008f, 0.25805295f, -0.23147148f, -0.16052088f, -0.10802581f, -0.11637388f, 0.01804783f, -0.00013982f, 
    0.02293797f, -0.01802467f, 0.01332985f, -0.06319088f, 0.04489677f, -0.02645076f, 0.09815113f, -0.05245376f, 
    0.02634030f, -0.00636081f, 0.00083338f, 0.00996591f, 0.31459242f, 0.28889754f, 0.01591550f, -0.37316933f, 
    -0.08771740f, 0.12206864f, 0.07340612f, 0.05089737f, 0.02353459f, -0.00483198f, 0.03228256f, -0.02191577f, 
    0.01261226f, 0.03942365f, -0.00373854f, -0.00474379f, -0.07409530f, -0.04161116f, -0.09181351f, 0.02506524f, 
    -0.02805254f, 0.11043011f, -0.25364828f, -0.03757190f, -0.07882661f, -0.05990291f, -0.05433153f, -0.05308082f, 
    0.08511636f, -0.15019765f, -0.06901480f, -0.11206959f, -0.11011428f, 0.06564301f, -0.00576408f, -0.03226885f, 
    -0.06752070f, 0.01759581f, 0.00518578f, 0.03113708f, 0.14898109f, 0.09019426f, -0.06786542f, -0.06679007f, 
    0.04344071f, 0.09555465f, 0.09255102f, 0.08263390f, -0.12286005f, -0.07033308f, -0.07563341f, -0.08986624f, 
    -0.03693890f, 0.01622955f, 0.03198166f, -0.00304310f, 0.01596542f, -0.03105948f, 0.00563847f, 0.00376837f, 
    0.15092161f, 0.17407741f, 0.16613561f, -0.05491510f, 0.01810558f, -0.04387701f, 0.08410025f, 0.11251161f, 
    0.01597449f, -0.15765615f, -0.02092796f, -0.04334473f, -0.00361868f, 0.01461941f, -0.02105278f, -0.02209899f, 
    -0.04278205f, -0.04767597f, -0.02248117f, 0.03017161f, -0.25242388f, -0.03333240f, -0.28258333f, 0.01660760f, 
    -0.10259216f, 0.02569291f, 0.01442783f, 0.04954023f, 0.09917548f, 0.08292210f, -0.09259985f, 0.06371575f, 
    0.01720272f, -0.04058100f, -0.01061767f, -0.16473915f, 0.06601592f, -0.08341613f, -0.02591543f, 0.01246137f, 
    0.24337204f, 0.22638436f, 0.16157392f, -0.00988466f, -0.06464780f, 0.15909694f, 0.19743675f, 0.10704356f, 
    -0.01328010f, 0.06530972f, -0.03592878f, -0.02017418f, 0.00717846f, -0.09867774f, -0.01837384f, -0.13423929f, 
    -0.10056784f, 0.02145424f, -0.03797347f, 0.01915028f, 0.09335930f, -0.07436595f, -0.12558529f, -0.02873187f, 
    0.03574532f, -0.01374487f, -0.04920717f, -0.05507008f, 0.02171046f, -0.01275369f, -0.02835475f, -0.10078868f, 
    -0.00524655f, -0.04410540f, -0.04371997f, -0.15046196f, 0.05187957f, -0.04181100f, 0.00978420f, -0.04846799f, 
    -0.03226256f, -0.01371516f, -0.15734911f, 0.08622532f, 0.05437192f, 0.01206416f, 0.00265991f, -0.00149658f, 
    -0.00062965f, 0.04211015f, -0.03804635f, -0.03365122f, -0.11448989f, 0.00747140f, -0.08363643f, -0.01358458f, 
    0.05067114f, 0.05538488f, -0.03463888f, 0.03186887f, 0.13963774f, 0.15132089f, 0.04179583f, -0.21137688f, 
    0.02643311f, 0.07991911f, 0.03983043f, 0.12492847f, -0.13630858f, 0.02972539f, -0.07661244f, -0.03699170f, 
    -0.00174516f, -0.02264135f, -0.11508415f, -0.04526132f, -0.03971373f, 0.00115572f, 0.07874402f, 0.08214558f, 
    0.33070797f, 0.11529280f, -0.05435987f, -0.10083759f, -0.06726871f, 0.18679938f, 0.09950497f, 0.18862931f, 
    0.03592243f, 0.06006795f, 0.01601306f, 0.01308453f, -0.04821282f, 0.04440187f, 0.00647186f, 0.01949088f, 
    -0.02253606f, -0.14120701f, -0.07248414f, 0.00232025f, -0.15353106f, -0.12669042f, -0.06799287f, 0.08354437f, 
    -0.02811801f, 0.00286342f, 0.01738675f, -0.01756422f, 0.01294051f, 0.03817192f, -0.04080280f, 0.02293345f, 
    -0.04993228f, 0.00041711f, 0.01291041f, -0.15358475f, -0.07420504f, -0.05537533f, -0.07209390f, -0.00945161f, 
    -0.18658502f, -0.34232250f, 0.15191276f, -0.21595424f, -0.06729081f, 0.06212477f, -0.00740674f, 0.02593162f, 
    0.04345463f, -0.02403462f, 0.04317925f, 0.04676765f, -0.01403120f, -0.05140066f, -0.07254336f, -0.20127313f, 
    -0.22532490f, -0.01282043f, -0.03959008f, -0.31764129f, -0.06998684f, -0.06887033f, -0.01067212f, 0.06092739f, 
    0.01332150f, 0.01419567f, 0.05672266f, 0.05712138f, 0.03609717f, 0.02635498f, 0.01815861f, -0.01624764f, 
    0.03471368f, 0.02158290f, -0.06306221f, -0.03714577f, -0.07626693f, 0.05933088f, 0.01480024f, 0.03043960f, 
    0.22904544f, 0.17147276f, -0.07694579f, -0.00844695f, 0.06661618f, 0.11722183f, 0.12088143f, 0.07222904f, 
    -0.14507212f, -0.16872340f, -0.04537443f, -0.12094586f, -0.09350717f, 0.04697209f, 0.06884532f, 0.00279931f, 
    0.01354492f, -0.02495844f, 0.02054475f, -0.01495802f, 0.01169850f, 0.04949835f, 0.27064791f, -0.08946623f, 
    0.04683933f, 0.01337339f, 0.04813886f, 0.06671648f, -0.02320034f, 0.06525851f, 0.16210596f, -0.08698495f, 
    -0.08736817f, -0.03343517f, -0.04095151f, 0.02135877f, 0.01218184f, -0.03004066f, -0.07772128f, -0.02412110f, 
    0.07097089f, -0.02141579f, -0.09146560f, -0.13560042f, 0.02829789f, -0.05134768f, 0.02319924f, -0.04091924f, 
    -0.24145269f, -0.07156172f, -0.05953321f, 0.02455124f, 0.06116463f, -0.05277533f, 0.02117270f, -0.04841026f, 
    -0.01645456f, -0.09763209f, -0.05562490f, 0.02059524f, 0.21294254f, 0.18149471f, -0.09749881f, -0.00677976f, 
    0.05449721f, 0.06168830f, 0.06910834f, 0.01751755f, -0.09700900f, -0.14679515f, -0.02998085f, -0.12994169f, 
    -0.06077268f, 0.00022489f, 0.05507855f, -0.03146474f, 0.01182313f, -0.05105617f, 0.00654270f, -0.03879339f, 
    -0.29523283f, -0.15493900f, -0.68701774f, -0.04936964f, -0.23516725f, -0.03340187f, -0.03245877f, -0.12991355f, 
    0.02456795f, 0.11083610f, -0.02974249f, -0.00198938f, -0.02231793f, 0.04394944f, 0.02076605f, -0.11089677f, 
    -0.05138012f, -0.02210144f, -0.08685946f, -0.00424710f, -0.01037411f, -0.24114990f, -0.23950052f, 0.08750606f, 
    -0.01793988f, 0.00231769f, -0.03420208f, 0.01789043f, 0.02617609f, 0.02274556f, 0.00198142f, 0.00457271f, 
    -0.00098410f, 0.09817865f, -0.01160804f, -0.16560335f, -0.01464438f, 0.02264535f, -0.06096857f, 0.01010848f, 
    0.05467471f, 0.02810650f, 0.06369147f, -0.03885118f, 0.07598465f, 0.00695854f, -0.05332726f, 0.02217859f, 
    -0.04631903f, 0.07796665f, 0.01063925f, -0.02833943f, 0.07753279f, -0.04280640f, 0.02747063f, -0.11356434f, 
    0.08131436f, 0.01340749f, 0.01789401f, -0.02251468f, -0.19455609f, 0.07385249f, -0.01694210f, 0.32016721f, 
    0.06389829f, -0.01009207f, 0.01500654f, -0.15859735f, -0.04968565f, -0.04612955f, -0.03452990f, 0.00627983f, 
    0.03075983f, 0.01468020f, -0.00141077f, 0.00104244f, -0.00897287f, 0.02843016f, -0.08336084f, 0.01275879f, 
    -0.14720982f, -0.08480351f, -0.02459110f, 0.16889536f, -0.18263179f, -0.08981287f, -0.04768124f, -0.52726930f, 
    0.01829486f, -0.01002717f, 0.06828262f, -0.02174539f, 0.02013530f, 0.02573692f, -0.01714577f, -0.03410867f, 
    0.00515835f, -0.09444141f, 0.03283739f, 0.00229544f, 0.10878968f, 0.08691452f, -0.11168082f, -0.08845289f, 
    -0.43423188f, 0.01730315f, -0.04626758f, -0.02781413f, -0.09623875f, 0.01112835f, -0.02562402f, -0.02832510f, 
    -0.04105589f, 0.00970897f, 0.02050366f, -0.05911339f, -0.29695511f, -0.20114362f, -0.10604397f, -0.18181023f, 
    -0.14645027f, 0.09390976f, 0.00604803f, 0.23527160f, 0.02057678f, -0.05525870f, -0.07636537f, -0.07860092f, 
    0.01064257f, -0.11028144f, -0.01802414f, 0.00282651f, 0.03485367f, 0.03163918f, 0.01758105f, -0.01670871f, 
    0.00623222f, 0.02686071f, -0.20912029f, 0.03846678f, 0.63766599f, -0.01095916f, -0.27414078f, -0.07714490f, 
    -0.24786326f, -0.02135882f, 0.10373874f, -0.00519797f, -0.05807547f, 0.08043519f, 0.00102449f, 0.08012616f, 
    0.03739544f, 0.05834389f, 0.03267083f, -0.10976511f, 0.07514582f, -0.11789049f, 0.15583602f, 0.11223526f, 
    -0.11797828f, -0.08446947f, 0.06536878f, 0.05902741f, 0.07130122f, 0.05362649f, 0.00651862f, 0.01242970f, 
    -0.05027485f, -0.00712312f, -0.00122680f, -0.12226601f, -0.14930812f, 0.09285650f, 0.04218487f, 0.02191618f, 
    0.01814016f, -0.00590174f, -0.07331312f, -0.08827513f, 0.16676934f, 0.10201484f, 0.09000210f, 0.08737366f, 
    0.09955935f, -0.01587158f, -0.01677522f, -0.00697499f, -0.03219996f, -0.02580049f, 0.01891554f, -0.02858069f, 
    0.03395549f, 0.00081760f, 0.04329302f, 0.04226588f, -0.05904879f, -0.08414354f, 0.03016259f, -0.07791287f, 
    -0.27348381f, 0.06265634f, -0.27347186f, -0.07665803f, -0.01325466f, -0.08548275f, -0.03925209f, -0.21795429f, 
    -0.05324138f, 0.03466462f, -0.02608150f, 0.02505467f, -0.00398598f, 0.03169456f, 0.06596325f, 0.03539309f, 
    0.03500575f, -0.00081946f, -0.06916428f, -0.01307132f, 0.09166871f, 0.06351681f, 0.00406689f, 0.12773259f, 
    0.11449261f, -0.00762574f, -0.03285789f, 0.00813351f, -0.03567274f, 0.01058136f, 0.08124625f, 0.05061650f, 
    -0.02510344f, -0.03182746f, 0.10530066f, -0.01975103f, -0.13032234f, 0.00439936f, 0.09580000f, -0.20251347f, 
    0.04140968f, -0.00156349f, -0.02344707f, -0.04268570f, -0.07034887f, -0.00337551f, 0.03060101f, 0.01920562f, 
    -0.05032736f, 0.01707518f, 0.15901124f, 0.00489059f, -0.14946073f, -0.02175149f, -0.00392348f, -0.07071466f, 
    -0.04782289f, -0.02912267f, -0.05061956f, 0.04642630f, -0.05737276f, -0.00812603f, -0.10107411f, -0.05381310f, 
    -0.08439569f, 0.08619352f, -0.09736467f, 0.00849868f, 0.02957970f, -0.11612305f, -0.05582226f, 0.05488615f, 
    0.04888747f, 0.02592093f, 0.00309524f, -0.02595757f, -0.02321861f, 0.03202466f, 0.17548081f, -0.02771535f, 
    -0.72100353f, 0.20601368f, -0.26828802f, 0.22164631f, 0.22144940f, -0.09104123f, 0.03074049f, 0.02900591f, 
    0.16726615f, -0.01288843f, -0.06680941f, -0.02132421f, 0.09473354f, 0.01759639f, -0.02544647f, -0.08217337f, 
    0.01674490f, 0.03802035f, -0.15870020f, 0.05235388f, -0.45481843f, -0.45245588f, 0.00548704f, -0.33974609f, 
    -0.00957584f, 0.09845814f, -0.00342661f, -0.05426089f, -0.04073068f, -0.09445444f, 0.08108082f, 0.01934424f, 
    -0.01186327f, -0.02532476f, 0.01269907f, -0.00280633f, 0.00551944f, -0.08053137f, 0.00860004f, -0.00545183f, 
    -0.04279967f, 0.17378989f, -0.04401495f, -0.05616054f, 0.12261285f, -0.09742289f, 0.04084927f, -0.09540442f, 
    -0.01327616f, 0.01526649f, -0.01629218f, -0.02996944f, 0.03447071f, 0.01056137f, -0.01217568f, 0.07548875f, 
    0.02534646f, 0.10464801f, -0.00923105f, -0.06087663f, 0.04469835f, 0.17974178f, 0.16109793f, 0.01736124f, 
    0.04376449f, 0.08284277f, -0.07433141f, 0.02083841f, 0.05969089f, 0.03483224f, -0.01312147f, 0.03230322f, 
    -0.02655261f, -0.02380634f, 0.06070114f, 0.01174600f, 0.01177395f, 0.08387472f, -0.07044563f, -0.00533273f, 
    -0.36236298f, -0.81892252f, 0.01043762f, -0.27376488f, 0.27414396f, -0.09964934f, 0.03493980f, -0.03231926f, 
    0.09269270f, 0.06507961f, 0.00746485f, 0.04301646f, 0.03437280f, 0.06640700f, -0.13423859f, 0.10635695f, 
    -0.00965675f, 0.04337231f, 0.19490564f, 0.00945992f, 0.00590854f, -0.00357839f, 0.01479431f, 0.00182337f, 
    0.00597931f, -0.00658543f, -0.00306490f, -0.10330530f, -0.01991304f, -0.03372533f, -0.03024860f, -0.03413841f, 
    0.05530552f, 0.07003971f, 0.01537983f, -0.02359763f, -0.06837609f, -0.06507202f, 0.09048662f, -0.00468253f, 
    0.07323603f, -0.05282324f, 0.01711824f, 0.04007726f, 0.06016017f, 0.01582956f, -0.07250463f, 0.10696615f, 
    0.06931119f, -0.02729928f, -0.06204533f, -0.03405154f, 0.10113495f, -0.01093872f, -0.23939541f, 0.04807674f, 
    -0.01254634f, -0.00251987f, -0.06947746f, -0.04800376f, 0.08625072f, 0.05071732f, 0.02652365f, 0.02425766f, 
    0.07032490f, -0.00506069f, -0.03916704f, -0.01211562f, -0.07775508f, 0.00774906f, -0.00466039f, 0.03069354f, 
    0.02017183f, 0.02454743f, -0.05241526f, 0.04931131f, 0.10397695f, -0.03631816f, 0.01152912f, 0.01219737f, 
    0.33501646f, 0.08693076f, 0.02779412f, -0.06244846f, -0.06273733f, -0.04075685f, -0.11938012f, -0.03261907f, 
    -0.07775927f, 0.03402221f, -0.01928937f, 0.01730098f, 0.01403059f, 0.02478162f, -0.00865466f, 0.04741060f, 
    0.09174149f, -0.05320878f, 0.04803247f, 0.07636682f, 0.90310049f, -0.05765681f, -0.14503284f, 0.01223515f, 
    -0.18332922f, -0.02342532f, 0.04309544f, -0.00335495f, -0.01296055f, -0.00034924f, 0.08861162f, -0.00254085f, 
    -0.07258599f, -0.07442401f, -0.01892001f, 0.00616616f, -0.00734680f, -0.11654125f, 0.04445854f, 0.03866973f, 
    0.54652131f, -0.14060757f, 0.26138142f, 0.14515688f, -0.20855729f, -0.02183714f, -0.04486252f, 0.00966754f, 
    0.00636064f, -0.06941371f, 0.11907903f, -0.15585308f, -0.06258608f, -0.14810346f, -0.07994965f, 0.14264423f, 
    0.00113086f, -0.15873711f, -0.02460214f, -0.03429230f, 0.31250969f, -0.23757723f, 0.03642682f, -0.02066898f, 
    -0.05758793f, 0.03607390f, 0.01016765f, -0.01392350f, 0.01246108f, -0.21291080f, 0.19167346f, -0.10790345f, 
    0.03087777f, -0.08668522f, -0.08494183f, 0.03098270f, -0.06863306f, -0.06440164f, -0.01959851f, -0.05158646f, 
    -0.21874736f, 0.15025014f, 0.12696204f, -0.07376105f, -0.07129922f, 0.08828818f, -0.03740761f, 0.02631014f, 
    0.05760685f, -0.02097308f, 0.04661078f, 0.03305390f, 0.03716360f, -0.06614697f, 0.02916599f, -0.02858102f, 
    -0.29273066f, -0.21240579f, 0.17465924f, -0.07199540f, -0.03537410f, -0.07550133f, -0.15037155f, -0.06709716f, 
    -0.12307812f, -0.01911735f, 0.08060818f, 0.06923529f, -0.00235978f, 0.03411065f, 0.16425420f, 0.00910645f, 
    0.01579264f, 0.05300986f, 0.02653992f, -0.03995019f, 0.01026085f, 0.02384915f, -0.02174723f, 0.04525466f, 
    0.02069910f, -0.52552819f, 0.02385700f, -0.14455743f, 0.35069677f, -0.11953622f, 0.01469151f, -0.08471456f, 
    0.01693612f, -0.04881693f, 0.15733929f, 0.10186819f, 0.15633772f, 0.12346546f, 0.22946683f, -0.08510841f, 
    -0.07719344f, 0.02163779f, 0.06591414f, -0.18091898f, 0.10011545f, 0.08764446f, 0.04898461f, 0.00047382f, 
    0.01503409f, -0.07366732f, 0.02140211f, 0.02020364f, -0.04570641f, 0.03307405f, 0.00238888f, -0.03229504f, 
    0.10827350f, -0.03833410f, -0.01007778f, 0.05796034f, -0.04168452f, -0.05418298f, 0.01697390f, -0.01135325f, 
    -0.11498582f, -0.01175873f, -0.04356026f, -0.04738678f, 0.01788938f, 0.07929280f, 0.05099502f, -0.10944983f, 
    0.00879293f, -0.00625409f, -0.06395539f, -0.05627389f, 0.06249919f, 0.09462912f, 0.06052051f, 0.00539324f, 
    -0.00611540f, -0.01048569f, 0.12351802f, 0.03005272f, -0.18634118f, -0.16739495f, -0.06558158f, -0.16662778f, 
    -0.19121124f, -0.20562196f, 0.06367709f, -0.07897288f, 0.08338922f, 0.05206648f, 0.11748043f, -0.01222221f, 
    -0.11115829f, -0.06368104f, -0.07373334f, 0.01695707f, -0.04211017f, -0.11857662f, 0.07651886f, 0.03037844f, 
    0.31781802f, 0.08304741f, -0.10221390f, 0.16449986f, -0.19592825f, -0.02489728f, -0.01230714f, -0.05471110f, 
    0.04443879f, -0.13840792f, 0.00517662f, 0.09077341f, -0.04546862f, -0.08806250f, 0.09422856f, 0.08745272f, 
    -0.08143141f, 0.05663207f, 0.14101635f, -0.01837473f, 0.33443812f, 0.29308781f, -0.00352705f, 0.32934380f, 
    -0.16862595f, -0.04483845f, 0.18482028f, -0.05406122f, -0.18219225f, 0.12650289f, -0.02803902f, -0.11491998f, 
    0.14014748f, 0.01504881f, -0.08033228f, -0.00453133f, -0.05159473f, 0.02024980f, -0.15798129f, -0.14892474f, 
    0.00128714f, 0.00826159f, 0.01441690f, 0.00550427f, 0.04297745f, 0.01715405f, -0.02627468f, 0.03004191f, 
    0.07404029f, 0.00769188f, -0.04364482f, 0.01029131f, 0.01207049f, 0.02460900f, -0.00000774f, -0.10461660f, 
    0.03354185f, 0.04725773f, 0.02779021f, -0.02503579f, 0.66908199f, 0.07839698f, 0.09254929f, 0.09862325f, 
    0.01841716f, 0.02820553f, -0.00597852f, -0.01972880f, 0.02815202f, -0.04177121f, -0.07536069f, -0.00554428f, 
    0.07149734f, 0.01571336f, -0.13770431f, 0.19495475f, 0.23370512f, 0.01721619f, 0.09499347f, 0.08679118f, 
    -0.11332456f, -0.23631765f, -0.14023978f, -0.11940090f, -0.23035632f, -0.08211848f, 0.09607987f, -0.28222170f, 
    0.03444034f, 0.08836950f, 0.02436164f, -0.05307572f, 0.04043536f, 0.00630451f, -0.01319724f, -0.08164027f, 
    0.07173057f, -0.32046121f, 0.09373022f, -0.08132035f, 0.11365627f, 0.15951660f, 0.21911013f, 0.11570190f, 
    0.20185137f, -0.03042530f, -0.01111118f, 0.00669065f, -0.05067838f, 0.03475902f, -0.04468275f, 0.04540601f, 
    -0.02879996f, -0.02116190f, 0.00234813f, 0.14712761f, -0.05739031f, 0.01195779f, 0.12779513f, -0.01872293f, 
    0.16727106f, -0.13270268f, -0.13405898f, -0.11694425f, 0.08631317f, 0.06205922f, -0.07400350f, 0.00065047f, 
    0.14431433f, -0.04111657f, 0.13441338f, -0.00331203f, 0.08286660f, -0.01383492f, -0.03327024f, 0.09261990f, 
    -0.01139881f, -0.08689814f, -0.05935633f, -0.22862495f, 0.00969981f, -0.05671541f, 0.12227850f, 0.07888396f, 
    0.07689065f, -0.01205802f, -0.01267592f, 0.03445872f, 0.02300422f, -0.02166555f, 0.04403685f, -0.02701072f, 
    -0.02986139f, 0.11597013f, 0.11949292f, 0.01644712f, -0.02938004f, -0.03838353f, -0.02582580f, -0.06689186f, 
    -0.16266565f, 0.00603833f, -0.25222594f, -0.27763093f, 0.18434663f, 0.13385552f, -0.13926160f, -0.10438628f, 
    -0.06375308f, 0.08673766f, 0.00835873f, 0.03745249f, 0.01012720f, -0.02165045f, 0.12578714f, -0.04676972f, 
    0.00461357f, 0.23686814f, -0.34781584f, -0.34442043f, -0.18187505f, 0.03082652f, -0.04557572f, 0.07703852f, 
    -0.31284654f, 0.01237484f, 0.02856154f, -0.22343166f, -0.31004238f, 0.10684943f, -0.00036328f, 0.03030088f, 
    0.02473070f, 0.06900257f, 0.03433581f, -0.07359610f, -0.00100818f, -0.05759254f, -0.27711001f, -0.21988794f, 
    -0.07492699f, 0.12668006f, -0.15589473f, -0.10905767f, -0.00712637f, -0.12061360f, -0.08465306f, 0.09835383f, 
    -0.09933831f, 0.05528478f, 0.00262495f, 0.02393120f, 0.02430030f, -0.02303988f, 0.07249783f, 0.04643726f, 
    0.02894846f, 0.08503383f, -0.20407145f, -0.12443668f, 0.31309813f, -0.29823372f, -0.27773786f, -0.11245684f, 
    -0.19028437f, -0.08546315f, 0.14834033f, -0.16244599f, 0.13745010f, 0.00572031f, 0.11879369f, -0.00131336f, 
    0.03870940f, 0.05370590f, 0.04129545f, -0.07173098f, 0.05609325f, -0.20706044f, 0.12266865f, 0.11455566f, 
    -0.33016351f, -0.09347816f, -0.10072160f, -0.04538007f, -0.00364231f, 0.04502495f, 0.14703257f, 0.15211366f, 
    -0.03201610f, 0.00893557f, -0.01397240f, 0.03663360f, 0.00432606f, 0.03414955f, 0.00393901f, -0.01635364f, 
    0.04817374f, 0.00662501f, -0.02492930f, 0.04352933f, -0.12824963f, -0.00479292f, -0.08155532f, -0.09863948f, 
    -0.00815442f, 0.09426013f, 0.00874517f, 0.09732339f, 0.11446200f, -0.08980744f, -0.01827456f, -0.01609731f, 
    -0.02134652f, 0.02262397f, -0.03246411f, -0.05745050f, -0.00406290f, 0.03047389f, 0.05732591f, 0.01046025f, 
    -0.09689584f, 0.20149675f, 0.04392103f, 0.07002438f, 0.11681668f, 0.05500485f, -0.05424850f, -0.08402731f, 
    0.06170769f, -0.21591637f, 0.04248942f, 0.01271006f, -0.04408484f, -0.08889994f, -0.08320654f, -0.01340210f, 
    0.10070100f, 0.07347067f, 0.03560819f, 0.00318016f, -0.21574327f, 0.08868510f, -0.10626530f, 0.30194756f, 
    0.18088800f, -0.12713371f, 0.06088456f, -0.07708403f, 0.21701543f, -0.13795510f, -0.08822624f, -0.02309140f, 
    -0.00406766f, -0.00952754f, -0.00620744f, 0.02169440f, 0.01215584f, 0.00688969f, -0.09137168f, -0.00609499f, 
    0.23679841f, 0.00262965f, 0.02521115f, -0.08931734f, -0.19586830f, 0.01052588f, 0.06374657f, -0.01842749f, 
    -0.08730879f, 0.03374780f, 0.10252787f, -0.03914957f, -0.01121193f, -0.03187341f, 0.10603254f, 0.00102316f, 
    -0.02064957f, -0.04092115f, 0.03328435f, 0.02733949f, -0.19524617f, -0.15306047f, -0.06160543f, -0.03224558f, 
    -0.11884766f, 0.01863752f, 0.07093810f, 0.07386588f, -0.07128033f, -0.11640195f, 0.03341591f, 0.05986077f, 
    0.02300622f, -0.03385824f, -0.01448579f, 0.01403682f, -0.00193488f, -0.04968136f, 0.04153426f, 0.01036721f, 
    -0.31760332f, -0.17665602f, -0.16442764f, -0.02746896f, 0.09593470f, -0.10628808f, 0.12693308f, 0.06848654f, 
    0.19489722f, -0.07917450f, -0.05107471f, 0.03258546f, -0.07393745f, 0.10063013f, 0.01007076f, -0.01174447f, 
    0.00048189f, -0.04295726f, 0.07538120f, 0.08435259f, 0.05266891f, 0.01256903f, 0.00651385f, 0.05113635f, 
    0.04956607f, 0.01832065f, 0.01595864f, -0.02507878f, 0.07945295f, -0.08637559f, 0.01715008f, 0.00078312f, 
    0.00849061f, -0.03808161f, 0.05985731f, -0.09997541f, 0.13979064f, 0.03786404f, 0.06765669f, -0.09315450f, 
    0.03698712f, 0.16484076f, 0.31698817f, 0.09280908f, -0.06114032f, 0.12074693f, -0.09737508f, -0.06012387f, 
    0.02791441f, -0.00827712f, 0.02399881f, 0.00489179f, 0.01262811f, 0.01354359f, -0.05703203f, -0.11471396f, 
    -0.03251170f, -0.25242454f, -0.06860652f, 0.11493183f, 0.00603340f, -0.04663649f, 0.17277029f, 0.10870833f, 
    0.04927467f, 0.04561550f, 0.04559575f, 0.13436279f, -0.01439288f, -0.10918850f, -0.06480493f, -0.00731125f, 
    0.07149536f, -0.01908191f, -0.19030391f, 0.17427641f, 0.09341410f, 0.02517648f, -0.05929446f, -0.04200334f, 
    0.18763998f, -0.04665507f, -0.09932409f, 0.04914725f, -0.06422468f, -0.06172606f, 0.00283310f, 0.02623598f, 
    0.02775930f, 0.01471150f, 0.03888654f, 0.06461089f, 0.02936964f, 0.04736835f, -0.00974691f, -0.02200954f, 
    0.01789886f, -0.04833999f, -0.01772166f, 0.03602410f, 0.16802426f, 0.25238073f, -0.22322828f, 0.09501982f, 
    -0.22161376f, 0.04195299f, 0.00539887f, -0.10049186f, -0.09584028f, 0.02237728f, 0.02915546f, 0.00426109f, 
    0.03787788f, 0.04617716f, 0.06034186f, -0.14988628f, 0.01426570f, -0.02096249f, -0.15219954f, 0.03314481f, 
    0.26290250f, 0.18829967f, 0.22603177f, -0.02488822f, -0.00524904f, 0.03731377f, -0.15014265f, -0.05338668f, 
    0.04131872f, 0.02316732f, 0.02311275f, 0.00019244f, 0.00913761f, -0.07210836f, -0.03875190f, 0.11775799f, 
    -0.02724438f, -0.11708935f, -0.07523610f, -0.02373857f, 0.00963908f, -0.05360921f, 0.09310541f, -0.00263504f, 
    -0.01763324f, -0.03218519f, -0.01665454f, 0.01259502f, 0.03013845f, -0.01855322f, 0.01997515f, 0.05610800f, 
    0.01549709f, 0.04650950f, 0.01799099f, -0.06850976f, -0.04035740f, -0.09382544f, 0.03045631f, 0.00857899f, 
    -0.06389528f, 0.11410975f, 0.02474238f, 0.01633597f, 0.09291365f, 0.02871461f, -0.06095871f, 0.01477150f, 
    -0.05998608f, -0.14856119f, -0.06177513f, 0.13555220f, 0.00540577f, -0.03326293f, -0.05189127f, 0.10051832f, 
    0.08219326f, -0.03240350f, 0.00032612f, 0.05084034f, 0.18112211f, 0.07404535f, 0.12071873f, 0.13055868f, 
    0.09848589f, -0.04339132f, -0.05443968f, -0.00932582f, -0.04393570f, -0.05158020f, 0.00939892f, 0.03607520f, 
    0.01429059f, -0.00336108f, -0.01717418f, -0.19217813f, -0.11070059f, -0.04067804f, -0.00779111f, -0.02904137f, 
    -0.15785748f, -0.24067593f, -0.14025094f, -0.04084687f, -0.08631834f, 0.01321657f, 0.07789879f, 0.04719640f, 
    0.03054608f, -0.05528445f, -0.02710705f, 0.02132823f, 0.00791858f, 0.03503681f, -0.02483867f, 0.00522801f, 
    0.00363151f, -0.03194130f, -0.00283131f, 0.04794369f, -0.13336228f, 0.02610731f, -0.03454025f, -0.15416317f, 
    0.03159696f, -0.07763167f, -0.02398510f, 0.03449599f, 0.07561487f, 0.02823732f, -0.09003851f, 0.10781953f, 
    0.01681549f, 0.08277588f, -0.07637254f, -0.17646985f, -0.02716198f, 0.05422425f, 0.07609812f, 0.07390469f, 
    0.55656761f, 0.17096412f, -0.33667651f, -0.09810695f, -0.14754353f, -0.07993016f, 0.12854865f, -0.09874998f, 
    0.17338715f, 0.10838815f, -0.03113054f, 0.00515806f, -0.05846033f, -0.05476376f, -0.02204185f, -0.05076380f, 
    0.13191617f, 0.10171795f, -0.02318582f, 0.12516795f, -0.12139523f, -0.16898061f, -0.12011017f, -0.02333620f, 
    -0.07826968f, 0.02098425f, 0.00969257f, 0.08157372f, 0.12178101f, -0.13680854f, -0.11219465f, 0.01850575f, 
    0.02723086f, 0.00222913f, -0.00957004f, 0.01601049f, 0.03546814f, -0.03336943f, 0.01376161f, 0.04154091f, 
    0.02590418f, -0.03233697f, 0.13082226f, 0.00641078f, -0.30015174f, 0.02219526f, -0.09735658f, 0.02173183f, 
    -0.04646720f, -0.11800611f, -0.06249796f, -0.03970615f, -0.03050964f, 0.03113523f, -0.00362002f, 0.01885708f, 
    0.03233724f, 0.09238554f, 0.14749607f, -0.02000480f, 0.43223709f, -0.06496623f, 0.07037035f, 0.18495302f, 
    0.10568524f, -0.02145711f, -0.03765833f, -0.00342016f, 0.00648287f, -0.04970525f, -0.03476562f, 0.05995028f, 
    0.05566989f, -0.01312286f, 0.04099713f, 0.20319843f, -0.04772977f, -0.03874459f, 0.09366904f, 0.03469579f, 
    0.03820436f, 0.00626888f, 0.06621978f, -0.09009443f, 0.09152125f, 0.02266155f, -0.00344004f, -0.06421026f, 
    -0.00365021f, 0.07742040f, 0.00217937f, -0.00248127f, 0.04382374f, -0.04554571f, 0.01209660f, 0.07860896f, 
    0.01525968f, -0.05307139f, 0.05518959f, 0.01889346f, -0.37389281f, -0.34819070f, -0.38394725f, 0.05162915f, 
    -0.32068956f, 0.01878640f, -0.02436073f, -0.00454236f, -0.08135425f, -0.22268061f, -0.01023110f, 0.05171249f, 
    0.02719451f, 0.01020558f, -0.03197498f, 0.00918373f, -0.01217895f, 0.02090369f, -0.08957023f, -0.09280958f, 
    0.26683792f, -0.81430042f, -0.26317531f, 0.07873984f, -0.19583543f, 0.10297190f, -0.00514076f, -0.00078431f, 
    -0.04432052f, -0.24643546f, 0.01178787f, 0.01851555f, 0.00559060f, 0.00908025f, 0.01217053f, -0.01577000f, 
    0.00683161f, -0.00284586f, 0.13608345f, -0.05723773f, -0.00442907f, -0.35702261f, 0.23344447f, 0.03116818f, 
    -0.29275206f, -0.01283379f, 0.02251672f, -0.01389136f, -0.00811757f, 0.04752675f, 0.02924822f, -0.02059146f, 
    0.00015818f, 0.00636886f, 0.01195158f, 0.10070278f, 0.06404543f, 0.06471265f, 0.07578348f, 0.10068395f, 
    -0.44982415f, -0.53910881f, -0.36918667f, -0.10083961f, -0.40511110f, 0.06357311f, 0.01844239f, -0.10741392f, 
    -0.02275719f, -0.28193936f, 0.00487219f, 0.05078959f, -0.02221111f, 0.01927751f, -0.03637858f, 0.00518695f, 
    0.02312721f, 0.00968709f, -0.12245728f, -0.09484679f, -0.26553819f, 0.19623861f, -0.15835671f, -0.18390134f, 
    -0.04068186f, -0.07630999f, -0.04956101f, -0.13860288f, -0.05476440f, 0.02782372f, 0.11341569f, -0.05937241f, 
    0.01918624f, 0.03120288f, 0.09691628f, -0.00071657f, -0.02604866f, -0.14892668f, 0.12336656f, -0.02010827f, 
    0.21790795f, -0.11231893f, -0.03164956f, 0.07557235f, 0.11361705f, 0.06645256f, -0.04954781f, 0.00187259f, 
    0.00100101f, 0.03047656f, -0.15781796f, 0.09171829f, 0.09134827f, 0.05446459f, -0.00981162f, -0.00232941f, 
    0.00337564f, 0.00277337f, 0.08918532f, -0.05993331f, -0.10856352f, -0.19367598f, -0.09130727f, -0.14700717f, 
    0.05429215f, 0.02496803f, -0.03653344f, 0.01383800f, -0.00232714f, 0.04956995f, 0.01467832f, -0.01694370f, 
    -0.02188147f, 0.03769590f, -0.04315814f, 0.02712521f, -0.01850908f, 0.01683325f, 0.00844280f, -0.02691299f, 
    -0.25345755f, 0.00321178f, -0.12710899f, 0.06186467f, -0.25956255f, 0.02159274f, 0.11879293f, -0.08489688f, 
    -0.02522092f, -0.05520283f, 0.05739443f, 0.04094818f, -0.03166074f, -0.00031681f, -0.03611501f, 0.00432368f, 
    0.00270961f, -0.01482916f, -0.03164617f, -0.00718590f, -0.12743430f, 0.01206686f, -0.33785474f, -0.32042810f, 
    0.23246223f, 0.02166626f, -0.01810661f, 0.00787007f, 0.04408593f, -0.01395563f, -0.03051780f, 0.04300452f, 
    -0.04566649f, 0.05340089f, -0.08528776f, -0.01567825f, 0.16096549f, 0.02784125f, -0.00363643f, -0.06605285f, 
    -0.10024678f, 0.10428550f, -0.03313173f, 0.10701666f, 0.02566111f, 0.01095352f, 0.00949474f, -0.01871937f, 
    -0.10293008f, -0.11084610f, -0.08908930f, -0.06193289f, -0.10616268f, 0.01885773f, 0.00840827f, -0.03098535f, 
    -0.00485027f, 0.00303012f, -0.05369075f, -0.03863482f, -0.19626825f, 0.09823740f, 0.07095236f, -0.06097408f, 
    0.01690117f, 0.03781903f, -0.21555841f, -0.35370791f, -0.05762497f, 0.03795130f, 0.04512527f, -0.00739707f, 
    0.02446115f, -0.01060451f, -0.09764389f, 0.00131880f, -0.02582479f, -0.04306558f, -0.00899514f, 0.04607899f, 
    0.54032409f, -0.21301210f, -0.44183850f, 0.36491168f, -0.05836099f, -0.00805557f, 0.07713222f, -0.21437667f, 
    0.09911488f, 0.11877070f, -0.02192310f, 0.01410785f, 0.03117435f, -0.01358069f, -0.06196722f, -0.02541852f, 
    0.01531091f, 0.08030654f, -0.24159478f, -0.17547716f, 0.25255150f, 0.05926821f, 0.04334315f, -0.00253773f, 
    0.03077128f, -0.03584061f, 0.08599366f, -0.00861354f, -0.04409729f, 0.12161535f, 0.02211360f, -0.01740412f, 
    0.01529476f, 0.04427203f, -0.06259207f, -0.04018709f, 0.08993997f, 0.01354027f, 0.10633603f, 0.04934464f, 
    -0.28360218f, 0.14657922f, -0.04362374f, 0.00633036f, -0.14662884f, -0.00179221f, -0.05477170f, -0.04939925f, 
    -0.01206017f, 0.01867498f, 0.01821617f, 0.00283449f, 0.01094067f, 0.00058667f, -0.02014891f, -0.00884843f, 
    -0.03269868f, 0.02945665f, -0.01675257f, -0.01117938f, -0.15815477f, -0.02355565f, 0.17450893f, 0.19990046f, 
    0.08920443f, -0.01922949f, 0.03879671f, 0.03546958f, 0.03479455f, 0.02740016f, -0.00695783f, 0.01127188f, 
    0.01674058f, 0.01985677f, -0.03990997f, -0.01890855f, -0.01066917f, -0.03340000f, -0.05611663f, 0.05450974f, 
    0.46405905f, -0.12106191f, -0.29809314f, -0.21104161f, 0.25194180f, 0.01744193f, 0.10522126f, -0.12075602f, 
    -0.05882045f, 0.10371219f, -0.15366152f, 0.02392324f, -0.01527744f, 0.12257563f, -0.27545837f, 0.07381223f, 
    -0.02491212f, -0.03587828f, 0.08359243f, 0.11445039f, -0.23438685f, -0.05586744f, 0.08571377f, -0.06894051f, 
    0.01547400f, -0.11991178f, -0.08939993f, -0.25214282f, -0.07173184f, 0.09120512f, 0.05023706f, -0.05795432f, 
    0.01548156f, 0.00275284f, -0.07532155f, -0.00280157f, -0.07512789f, -0.03383699f, -0.03551213f, -0.02931329f, 
    0.27953383f, 0.08079739f, 0.15147175f, 0.09851386f, 0.05878298f, 0.05992720f, -0.05208846f, -0.05118808f, 
    0.06958520f, 0.03542029f, 0.01565990f, -0.01509648f, 0.04995774f, -0.06637100f, -0.00188384f, -0.04655520f, 
    -0.03765034f, -0.01651428f, 0.01970549f, -0.06804773f, -0.12553023f, -0.04984567f, 0.00902773f, -0.07570896f, 
    0.09885558f, -0.02607182f, 0.01240225f, 0.01342298f, -0.02370910f, 0.03024814f, -0.02140560f, -0.00569922f, 
    0.02245697f, -0.03128028f, 0.00352034f, -0.12599367f, -0.11741066f, -0.00579815f, -0.02972509f, -0.00572441f, 
    -0.67545873f, -0.45568061f, 0.15939099f, -0.19183514f, -0.14325979f, -0.00444453f, 0.06990175f, -0.00748880f, 
    -0.02898924f, 0.03706795f, 0.00981993f, -0.01164614f, -0.01850005f, 0.02641652f, -0.00422878f, -0.02635076f, 
    -0.05814050f, -0.04018717f, -0.01190586f, -0.01644967f, -0.21497670f, 0.22962651f, 0.39203033f, -0.01543710f, 
    0.06340104f, -0.04410675f, -0.06002822f, 0.06564865f, -0.03901555f, 0.12502417f, 0.05884267f, -0.03839266f, 
    -0.07795418f, 0.05631360f, 0.09513056f, 0.00769666f, -0.00326224f, 0.03914680f, 0.06374813f, -0.06827699f, 
    -0.16526768f, 0.05268290f, 0.39813977f, 0.02365065f, 0.07225230f, 0.01998810f, -0.06803315f, -0.01849830f, 
    -0.04010772f, 0.00733435f, 0.09505698f, -0.04149822f, 0.02164099f, -0.11177017f, 0.08534288f, -0.05036580f, 
    0.04383478f, 0.10418029f, 0.05647368f, -0.06120148f, -0.22492857f, -0.19839288f, 0.60455346f, 0.22646856f, 
    0.30331045f, -0.04726537f, -0.03285766f, 0.00542837f, 0.16689241f, -0.25482222f, 0.05200034f, 0.01888707f, 
    0.02972867f, -0.12552205f, 0.12041090f, 0.01694993f, 0.02326329f, 0.00192551f, 0.01060704f, 0.00491479f, 
    -0.20948538f, -0.15031476f, 0.18032275f, 0.23986654f, 0.17234316f, -0.06607740f, -0.01372364f, -0.05161225f, 
    -0.07095251f, 0.01039270f, 0.00840547f, -0.01196479f, -0.01076162f, 0.00259739f, 0.02340478f, 0.14169799f, 
    0.11669391f, 0.08111542f, -0.05603382f, 0.08901553f, 0.00682277f, 0.05916844f, 0.10512833f, 0.05656449f, 
    0.10059690f, -0.00742301f, 0.02001809f, -0.01985254f, -0.01797741f, -0.18753849f, 0.00738614f, 0.01331158f, 
    0.05140584f, -0.00596587f, 0.05199414f, 0.00967720f, -0.01803846f, -0.04461733f, -0.01406703f, -0.07034904f, 
    0.40480295f, 0.11592689f, -0.10873900f, 0.00123656f, 0.18950388f, -0.01094678f, -0.00480150f, -0.06219414f, 
    0.04312021f, -0.04732359f, -0.10659350f, 0.01430307f, -0.04879477f, -0.09360206f, 0.03050855f, 0.02246091f, 
    -0.00317485f, 0.02452662f, 0.09871387f, 0.02615611f, 0.07403678f, -0.17364752f, -0.11781090f, -0.19536889f, 
    0.09847847f, 0.07469254f, -0.01655890f, -0.01649933f, 0.01939226f, 0.03984919f, -0.02143842f, 0.01217131f, 
    -0.04889935f, 0.05187567f, -0.01664587f, 0.13964163f, 0.06873745f, -0.14494224f, 0.05101716f, -0.05679763f, 
    -0.03593076f, -0.05262857f, 0.00052410f, -0.02175796f, 0.02140980f, 0.07328998f, 0.00359788f, -0.19638203f, 
    -0.10392685f, 0.09223425f, 0.04619475f, -0.05283900f, 0.04278445f, 0.01111329f, -0.03219951f, 0.01692165f, 
    -0.04690154f, -0.00673436f, -0.09996308f, -0.02478682f, 0.00304538f, -0.08031892f, 0.34317875f, 0.03524954f, 
    0.19259210f, -0.10587615f, -0.01365633f, -0.07846411f, -0.04358828f, 0.06693783f, 0.03037906f, 0.01857870f, 
    -0.08470802f, 0.01482811f, 0.08074347f, 0.04674783f, -0.01875383f, -0.00325108f, 0.04403404f, 0.02658897f, 
    -0.07762654f, 0.05415051f, -0.04431433f, -0.31236175f, -0.06575690f, 0.00124146f, -0.07809263f, -0.09675587f, 
    0.09667710f, -0.01090098f, 0.01909428f, -0.04094737f, -0.01594503f, 0.00099561f, -0.07957698f, 0.07706919f, 
    0.00618033f, -0.14152785f, 0.10009976f, 0.07221732f, -0.02183327f, 0.39352965f, 0.35679412f, 0.25107157f, 
    -0.08404791f, 0.00293604f, -0.03839909f, -0.15995355f, -0.13334949f, 0.24464689f, 0.03580393f, -0.03153408f, 
    0.06633464f, -0.03967409f, -0.09181015f, 0.12484995f, -0.02048549f, -0.11138453f, 0.07143351f, -0.03033823f, 
    0.03564731f, 0.00339621f, -0.04887570f, 0.00729117f, 0.05581430f, 0.05729255f, -0.07079751f, -0.00307738f, 
    0.00919477f, -0.01631478f, -0.07139602f, -0.08193817f, -0.16571864f, 0.07600398f, -0.06271531f, 0.04219927f, 
    -0.06186386f, -0.00555895f, 0.06121346f, -0.03251384f, -0.34856379f, 0.15678792f, -0.07475358f, -0.08339241f, 
    -0.12815653f, 0.02631504f, -0.02755620f, 0.02557178f, -0.05452503f, -0.00263550f, 0.04011226f, 0.13422129f, 
    0.05324829f, -0.07149041f, -0.04365370f, -0.06609692f, 0.04575538f, 0.12813823f, 0.04646144f, -0.01764622f, 
    0.35324296f, -0.28706157f, 0.21335283f, -0.18033856f, 0.04936239f, 0.09469270f, -0.05567578f, -0.15611625f, 
    -0.03488818f, 0.02711964f, 0.00339731f, -0.04644870f, 0.01990594f, -0.00192257f, 0.00587824f, 0.06099794f, 
    -0.04134652f, -0.13724655f, 0.09144355f, 0.04333559f, 0.05410468f, -0.17908968f, -0.33080509f, -0.07129748f, 
    -0.03777538f, 0.00964088f, -0.00738049f, 0.00491455f, -0.01066292f, 0.06496809f, -0.02863198f, 0.02504701f, 
    -0.01567665f, -0.00118054f, -0.03625489f, 0.05111210f, 0.07051972f, 0.09449768f, 0.10160004f, -0.00480482f, 
    0.06907942f, 0.08111564f, 0.31054276f, 0.28407502f, 0.15723898f, 0.03410843f, 0.00135322f, -0.11715120f, 
    0.12913604f, -0.06711154f, -0.01253603f, 0.01053526f, -0.00108090f, -0.09609380f, 0.04513401f, 0.00952403f, 
    0.04885093f, 0.02501955f, -0.12151923f, -0.00469757f, 0.09851722f, -0.06857884f, 0.03942621f, 0.06893615f, 
    0.06474150f, 0.04128665f, -0.00755856f, 0.02013233f, 0.07403088f, 0.01207504f, -0.10481455f, 0.02689261f, 
    0.04121978f, 0.03468423f, 0.04819418f, -0.00296872f, -0.00717799f, 0.01115118f, 0.02237638f, 0.00076005f, 
    -0.38958061f, -0.45425791f, -0.36288282f, -0.10247920f, -0.33114067f, -0.07179292f, -0.01088347f, -0.02129040f, 
    0.06403909f, 0.04177003f, -0.05183456f, -0.01025246f, -0.05226956f, 0.03505195f, -0.09589154f, -0.01875209f, 
    -0.01859761f, 0.00519853f, 0.00441560f, 0.16817543f, 0.05031916f, -0.64286214f, 0.07431000f, -0.04011079f, 
    -0.15610874f, 0.09128861f, -0.08192904f, -0.02635253f, 0.01520371f, -0.05066316f, -0.01767786f, 0.00630631f, 
    0.02194022f, -0.04955713f, 0.00144082f, 0.03163394f, -0.02642687f, -0.04635847f, 0.13121851f, 0.09848691f, 
    -0.24989055f, -0.20563106f, -0.13006252f, 0.04335613f, -0.12461854f, -0.00125666f, 0.03796772f, 0.06694625f, 
    -0.02970369f, 0.05414785f, 0.01711963f, -0.01610562f, -0.00544095f, -0.02831125f, -0.02467406f, -0.02421598f, 
    0.02683523f, 0.01798784f, -0.04694286f, 0.09103605f, 0.09324691f, -0.44793424f, -0.16494182f, -0.27593347f, 
    -0.19032165f, 0.05425927f, 0.03258973f, -0.01291843f, -0.00074885f, -0.10884038f, -0.00734765f, -0.10353679f, 
    0.05180609f, -0.00654309f, 0.05131920f, 0.05637449f, 0.00098830f, -0.25390917f, 0.17968349f, -0.18280773f, 
    0.03825959f, 0.11767021f, -0.02891737f, 0.15898274f, 0.14349863f, -0.05337105f, -0.03630316f, 0.10095061f, 
    -0.06835783f, -0.00316445f, -0.01381839f, 0.03856824f, 0.04641897f, -0.01117824f, 0.03675705f, 0.00555231f, 
    0.01697907f, 0.03545533f, -0.06323709f, 0.01450045f, 0.01620857f, 0.00095452f, -0.03353380f, 0.01860348f, 
    0.04057125f, 0.05852666f, -0.14320755f, -0.16390948f, -0.01404754f, 0.04945484f, 0.00475409f, 0.02223010f, 
    0.02619268f, -0.01869157f, -0.04575575f, -0.02010849f, -0.00904062f, 0.05250111f, 0.08427364f, -0.07291468f, 
    0.22918010f, -0.44714525f, 0.15270174f, 0.44529855f, -0.02529672f, 0.17390554f, -0.03985704f, -0.08483750f, 
    0.14367336f, -0.11154932f, -0.02685881f, 0.05889470f, 0.01018528f, -0.03400040f, -0.01278311f, -0.00933828f, 
    0.00320059f, -0.02888506f, 0.07453580f, -0.07094954f, -0.12018903f, -0.31711060f, -0.40905711f, 0.12123576f, 
    -0.41401339f, -0.06105705f, 0.03473000f, -0.00447533f, 0.01969076f, -0.16923302f, 0.00427359f, 0.03245578f, 
    -0.03971083f, -0.00057117f, -0.04935906f, 0.02086047f, -0.00664656f, 0.03085431f, -0.06674332f, 0.00660262f, 
    -0.32794696f, 0.15932074f, 0.08374313f, 0.08079653f, -0.00809745f, 0.00732481f, 0.01763567f, -0.11678953f, 
    -0.19242612f, -0.02596064f, 0.02325195f, 0.11987177f, -0.06053080f, -0.03286158f, 0.02430816f, 0.06176109f, 
    0.05809342f, -0.01510409f, -0.00663082f, -0.05654862f, 0.00143007f, 0.13901180f, 0.30152997f, 0.20218839f, 
    0.22347312f, -0.02936063f, 0.00229590f, 0.06744906f, 0.09564728f, -0.02604949f, 0.06222890f, 0.03994405f, 
    0.03118588f, 0.05679237f, 0.04050374f, 0.03678505f, -0.00357030f, -0.01569326f, -0.00718116f, -0.02450558f, 
    0.16999839f, 0.06502663f, -0.09455497f, 0.06154454f, 0.08025922f, -0.03425551f, 0.02578135f, -0.07920747f, 
    -0.05202963f, 0.00388181f, -0.07606737f, 0.01905643f, -0.09897256f, 0.04946055f, -0.03098414f, 0.01996536f, 
    -0.04888386f, -0.00633590f, -0.07108209f, 0.02222154f, 0.10409870f, 0.03297545f, -0.13392569f, -0.32183936f, 
    0.00592625f, 0.01433661f, -0.03024506f, -0.03332473f, 0.06792739f, 0.01460472f, 0.00637508f, -0.04365839f, 
    0.04128163f, 0.01888558f, 0.06196942f, 0.08437520f, 0.01521007f, -0.04693123f, 0.06110510f, 0.11079694f, 
    -0.52687472f, -0.84545648f, -0.28345239f, 0.16181511f, -0.29943666f, -0.05392776f, -0.17883225f, -0.01920464f, 
    -0.04544960f, -0.14457200f, -0.00534533f, -0.04927065f, -0.00560243f, -0.06849199f, 0.04530787f, -0.01373659f, 
    0.01193651f, -0.12171651f, 0.00675984f, 0.05295371f, 0.01250095f, 0.10808994f, 0.02608994f, -0.01543133f, 
    -0.00996593f, 0.06513081f, -0.04266188f, 0.03527870f, 0.05988764f, -0.00445231f, -0.05557254f, 0.06232966f, 
    0.11081404f, -0.03119052f, 0.10570901f, -0.02113203f, -0.06209282f, -0.02149517f, 0.07829643f, -0.09334725f, 
    -0.01443931f, 0.00537765f, 0.11998724f, -0.04682034f, 0.11094011f, -0.02081453f, -0.04443280f, 0.01637031f, 
    0.09848601f, -0.06537400f, -0.06119186f, -0.04141240f, -0.03709660f, 0.01638179f, 0.03629407f, 0.03978318f, 
    -0.03371306f, 0.03007661f, 0.00769876f, -0.04338875f, -0.39221621f, 0.24781348f, -0.16401157f, 0.18467455f, 
    -0.55787283f, -0.11915269f, -0.02207852f, -0.12335143f, -0.03641409f, -0.01341284f, 0.01650982f, 0.02680084f, 
    -0.00605796f, -0.06767959f, 0.00745803f, -0.02523595f, 0.01376969f, 0.04437774f, 0.04581420f, 0.02290183f, 
    -0.28236806f, -0.19848612f, 0.44708607f, 0.07252666f, 0.23540533f, -0.10071496f, 0.01857090f, -0.06840346f, 
    0.12405949f, 0.01486965f, -0.00085934f, 0.03814560f, 0.03515784f, -0.01944672f, 0.03750739f, 0.00419687f, 
    -0.04153116f, -0.04778291f, 0.00785432f, 0.05128602f, 0.02763545f, -0.10855795f, 0.03409534f, -0.11084083f, 
    0.03866459f, 0.02929127f, -0.03689658f, -0.01025571f, 0.01987484f, 0.03372411f, -0.00095112f, -0.04653835f, 
    0.00332464f, 0.04985687f, -0.01436627f, 0.00179955f, -0.09923514f, -0.10062242f, 0.09899625f, -0.04587878f, 
    -0.14830038f, -0.06244293f, -0.19059269f, -0.03173369f, -0.03268696f, 0.02663692f, -0.08260149f, 0.05272719f, 
    -0.12464332f, 0.05388205f, 0.00705425f, 0.09121212f, 0.06106474f, -0.01786004f, -0.03055854f, 0.07497813f, 
    -0.05497334f, -0.07078679f, -0.01196994f, 0.05681501f, -0.14886610f, -0.27066237f, -0.12091485f, -0.04630136f, 
    0.02346361f, -0.01058410f, -0.02087767f, -0.00986493f, -0.01148129f, 0.03491862f, -0.06593291f, -0.05967399f, 
    -0.02686103f, 0.02114301f, -0.00772924f, 0.03908801f, 0.04500103f, 0.06118111f, 0.01174612f, -0.02135394f, 
    0.00056769f, 0.15131924f, 0.30712515f, 0.13163988f, 0.20025155f, -0.02953652f, -0.04563607f, 0.05087037f, 
    0.11298762f, -0.05301234f, 0.05124389f, -0.02020569f, -0.02759043f, 0.05024814f, 0.03362731f, 0.01992121f, 
    -0.02324390f, -0.00376914f, -0.01655790f, -0.03857592f, 0.15726741f, 0.02252504f, -0.11334727f, -0.00125309f, 
    0.05828839f, 0.01346003f, -0.09836055f, -0.11982760f, 0.02898443f, 0.04964986f, -0.08302543f, -0.09698097f, 
    0.09234063f, -0.01337409f, -0.05819375f, -0.06292225f, -0.01948066f, -0.00425436f, 0.01495453f, -0.08389188f, 
    -0.08016015f, 0.22556104f, -0.02618743f, 0.10858745f, -0.19428177f, 0.05370053f, 0.01377946f, 0.05072188f, 
    -0.01039833f, -0.00747608f, 0.05450603f, 0.08269887f, -0.04770697f, 0.07539089f, -0.01245423f, 0.03990838f, 
    -0.04896334f, 0.01945872f, 0.09111713f, -0.06630377f, 0.16865620f, -0.03363638f, 0.18211499f, 0.12484056f, 
    0.05763458f, -0.00587276f, -0.06785661f, 0.00091897f, 0.04781290f, -0.16890758f, -0.00302359f, -0.00809819f, 
    0.05269352f, 0.03318620f, 0.01074733f, 0.01250875f, -0.02968602f, -0.04832941f, 0.04766991f, -0.04868687f, 
    -0.22579674f, -0.15672860f, 0.15767686f, -0.17556234f, -0.25138676f, 0.04496538f, -0.02580561f, -0.06712545f, 
    -0.01034198f, 0.07473420f, 0.02039541f, 0.01802897f, -0.02320485f, 0.10196681f, 0.01430494f, 0.10632937f, 
    -0.11395101f, -0.08787685f, 0.00665647f, 0.07033721f, -0.23647925f, 0.07520420f, -0.08101060f, -0.09311738f, 
    -0.12757224f, 0.02716843f, -0.01538580f, -0.02457385f, -0.02775420f, 0.02334113f, -0.00383171f, 0.02220277f, 
    0.04861940f, -0.03824886f, 0.03114199f, 0.08541895f, 0.10301802f, -0.00129807f, 0.14719754f, -0.02663871f, 
    0.07186200f, 0.32732165f, 0.10475626f, -0.47994614f, 0.05384373f, -0.13418417f, -0.09786899f, 0.00581450f, 
    -0.16963808f, -0.01527183f, -0.11295330f, -0.11337946f, 0.00335381f, 0.10460515f, 0.05556672f, -0.08161732f, 
    0.05691836f, -0.05110738f, -0.05605621f, 0.00690226f, 0.06016096f, -0.10960842f, -0.25543585f, 0.01102892f, 
    0.18788846f, 0.08164823f, 0.02071349f, 0.02370934f, 0.11070275f, 0.13032173f, -0.01654299f, -0.02844794f, 
    -0.03027521f, -0.01094320f, 0.00922219f, -0.01926961f, -0.09031998f, 0.13105272f, -0.10115165f, 0.04693724f, 
    0.01426041f, -0.08845490f, 0.03925782f, -0.11306930f, 0.25421047f, 0.07806621f, 0.02570762f, -0.03864200f, 
    -0.05062876f, 0.08502591f, 0.06065965f, -0.06519817f, -0.03882482f, 0.11609574f, -0.05427512f, -0.09416090f, 
    0.01482073f, 0.14593241f, -0.09686211f, -0.04700286f, 0.01271043f, -0.24866724f, 0.12849002f, 0.16968504f, 
    0.27359182f, -0.11055031f, 0.01675094f, 0.03432781f, 0.09929338f, 0.01869020f, 0.06212741f, 0.00071227f, 
    0.00624458f, -0.06543252f, 0.04005201f, -0.04093028f, 0.02905886f, -0.00513063f, 0.07162284f, 0.03099284f, 
    0.01912838f, -0.08345481f, -0.24836816f, 0.02114769f, 0.17745832f, 0.03852703f, 0.11573088f, 0.03565227f, 
    0.09345247f, 0.13980451f, 0.05294438f, -0.11338814f, -0.02596653f, 0.02004361f, -0.01920131f, -0.00716277f, 
    -0.07811004f, 0.01450686f, -0.09691263f, 0.10755784f, -0.31622067f, 0.12472757f, -0.05616890f, 0.28136984f, 
    0.02698711f, -0.02084557f, -0.33489212f, 0.20572385f, -0.01113735f, -0.12772737f, 0.03458446f, 0.00477200f, 
    0.03074956f, 0.05768206f, -0.10216170f, 0.05191550f, -0.00915741f, -0.06193048f, -0.07357803f, -0.22092775f, 
    0.51540512f, 0.43787506f, -0.00699439f, -0.00971047f, -0.19240294f, 0.18823716f, 0.10748155f, -0.05213737f, 
    -0.26103088f, -0.03341856f, -0.22262278f, -0.06792746f, 0.07894101f, -0.05205131f, -0.02496907f, -0.12187266f, 
    -0.07494429f, -0.14066172f, 0.00158032f, -0.05963419f, -0.30208835f, -0.25662354f, -0.12147775f, 0.03897482f, 
    -0.27613318f, 0.10772362f, -0.01246308f, -0.01936400f, 0.08246056f, -0.05880769f, -0.02307773f, 0.04338229f, 
    0.05919092f, -0.04927979f, -0.04713291f, -0.05357617f, -0.05560740f, 0.02190763f, -0.12990691f, -0.05360823f, 
    -0.07358959f, -0.07100999f, -0.08907380f, 0.08925213f, 0.07989045f, -0.04737179f, -0.01987497f, 0.10210910f, 
    -0.02149808f, 0.07617706f, 0.04582008f, -0.00345892f, -0.00610225f, 0.00058415f, -0.01590631f, -0.07236711f, 
    -0.13544932f, 0.07783496f, -0.08283258f, -0.04583700f, 0.00604069f, -0.14598781f, 0.05032038f, -0.24786486f, 
    -0.32979265f, 0.01044838f, 0.17132732f, 0.16972667f, -0.00303286f, -0.08645245f, 0.11236443f, 0.06174456f, 
    0.08421143f, -0.05709099f, -0.09334975f, -0.01663854f, 0.01174551f, -0.00812364f, -0.15534928f, -0.04281425f, 
    -0.32431397f, 0.05457057f, 0.20772511f, 0.18212295f, 0.19195902f, -0.05746617f, 0.02894792f, 0.15259840f, 
    -0.05185531f, 0.07710467f, -0.05132355f, 0.06610730f, -0.07916125f, 0.02554833f, -0.03716074f, 0.19227619f, 
    0.03797764f, 0.14640532f, -0.06073329f, 0.00430278f, -0.27681634f, 0.15795030f, 0.02870937f, 0.17940666f, 
    0.14722410f, 0.04278437f, 0.10852929f, 0.13247642f, -0.10741277f, 0.05054546f, -0.01797132f, 0.03562965f, 
    -0.09327265f, 0.03469317f, -0.05544302f, 0.06514319f, 0.01489845f, 0.17567116f, 0.09034524f, -0.11741031f, 
    -0.12551220f, 0.11643292f, -0.07710642f, -0.09846483f, 0.32392502f, 0.14343482f, 0.01937151f, -0.12478156f, 
    0.10379656f, -0.19882992f, -0.01092285f, 0.09136516f, -0.19917279f, 0.04854247f, -0.05021729f, 0.01170767f, 
    -0.01897921f, 0.10927801f, -0.13049218f, -0.07004987f, 0.44866246f, 0.12109722f, 0.09926199f, -0.47776851f, 
    0.06334516f, -0.05459708f, -0.05040785f, 0.08151011f, -0.05074995f, -0.01191022f, -0.02773681f, -0.05596809f, 
    -0.03025810f, 0.00077001f, 0.01622501f, -0.04963060f, -0.01675753f, -0.02442685f, 0.05794105f, 0.03890366f, 
    -0.58977258f, -0.02968271f, 0.06133147f, 0.24671005f, -0.14781480f, 0.04829838f, -0.03531022f, -0.10481386f, 
    -0.12355243f, -0.16944043f, 0.01394636f, 0.10071844f, -0.03601570f, -0.01523549f, -0.03856721f, 0.03579498f, 
    0.03957611f, 0.12486140f, -0.04785834f, -0.19004288f, 0.03895703f, -0.01628735f, -0.12229621f, -0.06696381f, 
    0.12766969f, -0.01003141f, 0.05840634f, -0.04163912f, 0.02547633f, -0.02210187f, -0.05736215f, -0.00163526f, 
    0.05314625f, 0.03157118f, 0.05754087f, -0.07266800f, 0.07215013f, 0.05277257f, -0.07166568f, 0.01533217f, 
    0.76999372f, 0.55937606f, 0.06928534f, -0.67935991f, 0.05942654f, 0.06739866f, -0.11658905f, -0.01644048f, 
    -0.23937984f, -0.14302556f, -0.07010522f, -0.07035339f, 0.08019778f, -0.13171937f, -0.04310898f, -0.01182651f, 
    0.03052883f, -0.14493033f, 0.15546824f, 0.10148492f, -0.03264263f, -0.16791187f, 0.08965744f, -0.04329996f, 
    0.12195141f, -0.00113016f, 0.03633353f, 0.10969310f, 0.04105172f, -0.01365508f, 0.09795201f, 0.08287211f, 
    -0.04491632f, 0.03753513f, 0.12449788f, -0.00704475f, 0.02300720f, 0.08543444f, 0.00208389f, -0.15333891f, 
    -0.89971191f, 0.48076111f, 0.13140860f, -0.23840399f, 0.05378851f, 0.08488263f, 0.04161166f, -0.03021020f, 
    -0.03595415f, -0.15913619f, -0.16201982f, -0.00540537f, -0.06144375f, -0.05623291f, 0.07762437f, -0.09470102f, 
    0.07920870f, -0.04930687f, -0.00886582f, -0.18338631f, -0.14813676f, -0.17325942f, 0.10562228f, -0.27738512f, 
    -0.16086040f, -0.04248688f, -0.09438173f, -0.14583902f, -0.07943365f, -0.14983493f, 0.12192342f, 0.06478037f, 
    0.07670466f, -0.00869832f, 0.09946910f, 0.02336628f, 0.03448097f, 0.03181256f, -0.11480059f, -0.20234968f, 
    -0.35021853f, -0.36245075f, 0.32637775f, 0.09806087f, 0.19681807f, -0.16708179f, -0.07339980f, -0.01697931f, 
    0.13981301f, -0.08502388f, 0.09854414f, 0.05773637f, 0.08595289f, 0.01132734f, 0.03954835f, -0.11028885f, 
    0.02104240f, -0.05791211f, 0.09096465f, -0.11716206f, -0.05649197f, 0.40757340f, -0.01316615f, 0.18119022f, 
    0.26040077f, 0.05496112f, 0.00513719f, 0.06881437f, -0.06527245f, -0.09634698f, -0.07237972f, -0.01272930f, 
    0.11561475f, -0.01964145f, -0.04158224f, -0.02423028f, -0.09969427f, 0.03716271f, -0.01341177f, -0.07542616f, 
    0.38016072f, 0.43201396f, -0.01958086f, 0.07807808f, -0.02517062f, 0.16011325f, 0.12430382f, -0.00522339f, 
    0.12921090f, -0.00015369f, -0.05748478f, -0.08259109f, 0.00257308f, -0.04545110f, 0.07095711f, -0.09997904f, 
    -0.03042238f, -0.05895163f, 0.04628380f, -0.07116733f, -0.24887340f, 0.33040643f, -0.04545161f, -0.10555536f, 
    0.22693393f, 0.21700808f, 0.12217245f, 0.04191820f, -0.04277601f, 0.02842157f, -0.18665580f, -0.01501133f, 
    0.01620405f, -0.03536075f, 0.09851116f, -0.05102320f, 0.08368428f, -0.02349339f, 0.11166774f, 0.08751789f, 
    -0.07469752f, 0.10599406f, -0.08858796f, -0.13935138f, 0.07622913f, 0.00743197f, 0.07317361f, 0.04418239f, 
    0.07327032f, 0.10300959f, -0.06080613f, 0.00121162f, 0.05641402f, -0.00659090f, 0.02364418f, -0.00031276f, 
    0.05646506f, 0.02148362f, -0.02136063f, 0.00401793f, -0.13840026f, 0.06706659f, -0.06122345f, 0.12886091f, 
    0.14522885f, -0.02856358f, -0.02763538f, 0.04563042f, -0.01495439f, 0.05988293f, -0.02081490f, 0.01436042f, 
    0.01243038f, -0.07739704f, -0.04782383f, 0.07979511f, -0.01204820f, 0.00661982f, 0.00161799f, -0.03032720f, 
    0.22484133f, 0.86506623f, -0.29783934f, -0.29377168f, -0.16219909f, 0.07622771f, 0.04488792f, -0.05666267f, 
    -0.07641530f, 0.04533853f, -0.11557683f, -0.15645628f, 0.06803676f, -0.05369120f, 0.09355449f, -0.06359769f, 
    -0.01090475f, 0.02113535f, 0.10868033f, 0.12948486f, -0.08767785f, -0.07565982f, -0.15399025f, -0.09255511f, 
    -0.28740418f, 0.01835692f, 0.01415624f, 0.05958311f, 0.06023822f, -0.02602036f, 0.04223107f, -0.05801008f, 
    0.16954668f, -0.16258742f, -0.13024668f, -0.12584651f, 0.02906992f, -0.02520847f, 0.12490981f, 0.03548529f, 
    0.13842309f, 0.00247899f, 0.11676297f, -0.08396814f, 0.15849639f, -0.02109084f, 0.05976616f, 0.01850121f, 
    0.10043515f, 0.02783772f, 0.10874052f, -0.00285501f, -0.05099511f, -0.05112636f, 0.06468350f, -0.03113134f, 
    -0.05900058f, 0.03051939f, -0.11476031f, -0.04326620f, -0.12975924f, 0.13143995f, -0.12119403f, -0.01627380f, 
    0.11367850f, 0.07395345f, 0.04480328f, 0.09264019f, 0.02720017f, -0.04945729f, -0.18937144f, 0.03905262f, 
    0.00569451f, 0.00772799f, 0.02987222f, -0.02542586f, 0.03866338f, 0.00970640f, 0.01544622f, 0.04801022f, 
    -0.29282340f, 0.06539976f, -0.13106048f, 0.05518625f, 0.04860814f, -0.12834278f, -0.05520313f, 0.01945043f, 
    -0.09992194f, -0.00330639f, -0.00410178f, -0.05891437f, 0.07936645f, 0.02783267f, -0.12519096f, -0.02470766f, 
    -0.00172838f, -0.02003925f, -0.00353744f, 0.01503246f, -0.51977181f, 0.39448500f, -0.11102653f, 0.10293328f, 
    0.28295401f, -0.13055390f, -0.06233300f, -0.01986671f, -0.10871228f, 0.01996682f, -0.13685682f, 0.05977745f, 
    -0.00297302f, -0.10564546f, -0.03041833f, 0.01131173f, 0.02312369f, 0.05589039f, -0.05939120f, -0.05461039f, 
    -0.12123284f, 0.09465609f, -0.20964201f, -0.07985961f, -0.24732207f, 0.01515114f, -0.08286485f, -0.05019037f, 
    -0.01762784f, -0.12436578f, -0.01699088f, -0.08973103f, -0.11837775f, -0.06040243f, -0.16884503f, 0.04944815f, 
    -0.04058737f, 0.10410580f, -0.08739095f, -0.09129310f, -0.18485545f, 0.02355153f, -0.29338974f, 0.01986541f, 
    -0.15006407f, 0.04258185f, 0.14400738f, -0.01756755f, -0.00903157f, 0.01228129f, 0.01879847f, -0.05665775f, 
    -0.06018224f, -0.08412137f, 0.04358094f, -0.12433626f, -0.03172170f, -0.07430425f, -0.00365274f, -0.02744323f, 
    0.09774249f, 0.08380016f, 0.10505470f, -0.20049085f, 0.18988445f, -0.10057161f, -0.01611805f, -0.04424952f, 
    -0.05050945f, 0.01455370f, -0.07166593f, -0.09850955f, -0.01018341f, 0.01773452f, 0.09759847f, -0.05748735f, 
    0.00403282f, -0.11172945f, -0.02197846f, 0.01927656f, -0.31112590f, 0.43657613f, -0.06577998f, -0.22977136f, 
    -0.41548732f, 0.10810184f, 0.00919313f, 0.07043560f, 0.08805328f, 0.05305387f, -0.00254804f, -0.09623316f, 
    -0.01163019f, -0.06143635f, -0.05208557f, -0.04479394f, -0.01266367f, -0.07426106f, 0.01545721f, -0.07231836f, 
    -0.20993990f, 0.25858688f, 0.03659417f, -0.07942776f, 0.11050690f, 0.04133706f, 0.03022855f, -0.03578122f, 
    -0.01096808f, -0.01430048f, -0.12321864f, 0.02976017f, -0.03815690f, -0.05139855f, 0.05014320f, -0.03492955f, 
    -0.00317647f, 0.03557475f, 0.06441707f, -0.00380321f, -0.10840219f, 0.52479511f, -0.15903243f, -0.07671727f, 
    -0.19749752f, 0.16187695f, 0.03267966f, -0.03131972f, 0.03024033f, -0.09879410f, -0.17507927f, -0.06076493f, 
    -0.04133398f, -0.05802908f, 0.03247718f, -0.10836362f, -0.02089698f, -0.10897568f, 0.03917707f, -0.03491540f, 
    0.19799389f, -0.04953670f, 0.02630192f, -0.18559042f, 0.30851787f, -0.01706256f, 0.13276841f, 0.06546915f, 
    0.01133591f, 0.02755719f, -0.01709694f, -0.00848729f, -0.06683803f, -0.06144192f, -0.02806123f, -0.11850322f, 
    -0.04426556f, -0.04832331f, 0.07255968f, -0.04288236f, 0.09685933f, -0.15226178f, -0.07686706f, -0.01254033f, 
    0.28422233f, -0.07202780f, 0.08215880f, -0.00218038f, -0.04407650f, -0.00187859f, -0.01590391f, -0.03935172f, 
    -0.05815073f, -0.07028084f, -0.02657593f, 0.01279250f, -0.01212656f, 0.01596301f, 0.05772382f, -0.06695607f, 
    0.02716814f, -0.03186500f, -0.10314172f, -0.01450815f, 0.09127374f, -0.01463430f, -0.02546343f, -0.01822809f, 
    0.03167272f, 0.07251108f, -0.02517219f, -0.00983191f, -0.05429501f, -0.07484344f, -0.01912778f, -0.06426942f, 
    -0.08325237f, -0.02272893f, -0.02978889f, -0.05474865f, -0.02087763f, 0.11043645f, -0.13280448f, 0.04607917f, 
    0.02995485f, 0.03246569f, -0.21137764f, 0.12897915f, -0.03606556f, 0.03104564f, 0.00826931f, 0.02671174f, 
    -0.09798356f, 0.05028914f, -0.03006730f, 0.04547499f, 0.01001067f, -0.01791565f, -0.00139585f, -0.16285786f, 
    -0.00949209f, -0.03658378f, -0.15440138f, -0.08527912f, 0.18376003f, 0.04921408f, -0.04078843f, 0.00340266f, 
    0.02679648f, -0.02618776f, 0.00013369f, 0.03354172f, -0.03547414f, 0.02114844f, 0.00073599f, 0.01699991f, 
    -0.06246490f, 0.07783748f, -0.03018640f, -0.01537774f, -0.19722867f, -0.09975589f, -0.24193116f, 0.06074589f, 
    0.06509580f, 0.05401684f, 0.01701583f, 0.10769870f, 0.11424798f, 0.03380996f, -0.09442263f, -0.02736994f, 
    -0.14304096f, 0.03334298f, -0.02576098f, -0.01608307f, -0.09652613f, 0.16396929f, -0.02161315f, -0.12277360f, 
    -0.07233658f, -0.05330933f, -0.20430002f, -0.00839241f, 0.18714224f, 0.14790830f, 0.03398072f, -0.05959245f, 
    -0.06103122f, -0.03569189f, -0.09640881f, 0.09959782f, -0.12865615f, 0.05025731f, 0.06692552f, -0.14025284f, 
    -0.11359029f, 0.13830079f, 0.13959773f, -0.04640036f, -0.00736802f, -0.10721327f, -0.22389150f, -0.05268080f, 
    0.15779163f, 0.10969052f, 0.01988210f, 0.03598862f, 0.10782134f, 0.06716388f, 0.05526295f, -0.02784485f, 
    -0.01882365f, 0.04727906f, -0.02085974f, -0.00750428f, -0.01404087f, 0.17937455f, -0.14416724f, 0.08669668f, 
    -0.13966200f, 0.06208205f, 0.05769939f, 0.34268856f, 0.18763070f, -0.07824053f, -0.08748583f, 0.07025019f, 
    -0.06713598f, -0.05481215f, 0.01998379f, 0.00666582f, 0.07107882f, -0.03265030f, -0.03892587f, 0.03552045f, 
    0.00755297f, 0.06542557f, 0.01844553f, 0.01914725f, 0.06336801f, -0.12891948f, -0.06398339f, 0.04924539f, 
    0.21539815f, 0.08732694f, -0.01474587f, -0.02580754f, -0.08935266f, -0.12830980f, -0.06878594f, 0.01472526f, 
    0.05556692f, 0.06878787f, 0.05214366f, 0.00060460f, -0.00177952f, 0.05719717f, -0.03494181f, 0.00160534f, 
    0.26971740f, 0.06564126f, -0.20415205f, -0.29469019f, 0.13833913f, 0.04099083f, -0.05989759f, -0.00470129f, 
    -0.07873125f, -0.00097410f, -0.00687763f, -0.00740175f, -0.02224966f, -0.06577586f, 0.02718055f, 0.18008024f, 
    0.08794256f, 0.03751377f, 0.12563547f, 0.17405742f, -0.07638168f, 0.43897259f, 0.07628766f, -0.23458467f, 
    -0.31103092f, -0.13907316f, 0.02879142f, -0.02135399f, -0.05578307f, 0.00932989f, 0.02077631f, -0.10270531f, 
    -0.01495603f, 0.10297878f, 0.02062587f, -0.02000434f, -0.07293931f, -0.01212252f, 0.00689760f, 0.06188819f, 
    0.16179524f, -0.10481392f, -0.27349406f, 0.07766322f, 0.15017486f, -0.06318633f, 0.06757148f, -0.05368901f, 
    -0.00706207f, 0.14464477f, -0.04785477f, 0.05029579f, -0.05187800f, -0.07727806f, -0.01337587f, 0.11997982f, 
    0.08072776f, 0.08086690f, 0.10707845f, -0.07817476f, -0.42024803f, 0.26125214f, -0.07355652f, -0.16544853f, 
    -0.32062891f, 0.09297288f, 0.06963361f, 0.04419382f, 0.00123535f, 0.01967301f, -0.08157754f, -0.05132695f, 
    -0.09565438f, -0.13805738f, 0.03556625f, -0.09471568f, -0.14535320f, 0.04460796f, -0.01833291f, -0.17009670f, 
    -0.37405753f, 0.10527232f, -0.00570940f, -0.06774720f, 0.11733498f, 0.09029472f, -0.05129045f, 0.05776973f, 
    -0.08440693f, -0.04684081f, -0.13860083f, 0.05896183f, 0.04022602f, -0.00222105f, -0.01200338f, -0.00086203f, 
    -0.01457254f, -0.03840077f, 0.00420660f, -0.00580014f, -0.25038064f, -0.03939159f, -0.13674843f, 0.08703974f, 
    0.13728829f, -0.09637844f, -0.01135583f, 0.03279232f, -0.04068969f, 0.07808472f, -0.02563506f, 0.07090484f, 
    -0.04802204f, -0.11024369f, 0.02811105f, 0.02032584f, 0.02040642f, 0.07741438f, -0.05456438f, -0.00466879f, 
    -0.10571796f, 0.08204611f, -0.06888352f, -0.08224577f, 0.22461151f, 0.07904988f, 0.03457223f, 0.00305327f, 
    -0.00692062f, 0.06557658f, -0.00715177f, 0.06777588f, 0.06214956f, 0.09603012f, 0.18980755f, -0.03662604f, 
    0.02223984f, 0.06570248f, -0.00733708f, 0.06185731f, -0.42703912f, 0.17310591f, -0.14385886f, 0.06674945f, 
    -0.11434320f, -0.05688134f, -0.15451010f, -0.10418112f, 0.00753598f, -0.19124441f, -0.10356549f, -0.04968082f, 
    -0.00638800f, -0.16249092f, -0.04135988f, -0.05900046f, 0.04373887f, -0.02194214f, 0.06220889f, -0.05262201f, 
    -0.04119194f, -0.01631259f, -0.12490562f, -0.22256753f, -0.06860839f, -0.23155059f, -0.01752020f, -0.20677926f, 
    -0.10413598f, -0.02023348f, 0.19397746f, 0.06014453f, 0.19084805f, -0.20119432f, -0.10452111f, 0.07358768f, 
    0.04727845f, 0.07799784f, -0.03759748f, -0.23862790f, -0.38522878f, -0.27935147f, -0.24365982f, -0.06379478f, 
    -0.28400093f, 0.20201701f, 0.08613109f, 0.11008992f, 0.03423493f, -0.02214483f, -0.09563980f, -0.01025268f, 
    -0.01520964f, -0.06693990f, -0.12301674f, -0.04009636f, -0.06298376f, -0.13740341f, -0.03900286f, -0.04613968f, 
    -0.03081398f, -0.17280646f, -0.12064906f, 0.04501224f, 0.27274439f, 0.12714757f, -0.04230823f, 0.00747485f, 
    -0.07221529f, -0.08344582f, -0.12749574f, 0.02440278f, 0.08294800f, 0.05401257f, 0.02222750f, 0.04565025f, 
    0.04089924f, -0.01215191f, 0.00519513f, 0.04161118f, 0.21309873f, 0.04779824f, -0.04377925f, -0.27835521f, 
    0.26200017f, -0.06572128f, 0.12194140f, -0.11558679f, 0.02841296f, -0.23134038f, 0.03850372f, 0.01826486f, 
    -0.15547734f, -0.04549907f, -0.00064571f, 0.25497538f, 0.08699508f, 0.00672011f, -0.10232424f, -0.19703181f, 
    -0.17428949f, -0.08108380f, -0.00476064f, -0.15056786f, 0.18841028f, 0.05156907f, 0.00796090f, 0.05003547f, 
    -0.04909189f, -0.05587962f, -0.00174009f, 0.00393490f, -0.01798477f, -0.02635238f, -0.00357160f, -0.05783657f, 
    -0.01201344f, 0.15962748f, -0.00771476f, 0.00682824f, -0.01993020f, -0.14980552f, -0.14745992f, 0.00763207f, 
    0.20197792f, 0.14428705f, 0.09309039f, 0.04307986f, -0.10688671f, 0.00725790f, -0.07650059f, 0.02143076f, 
    0.04296093f, -0.03956053f, -0.04776489f, 0.02093534f, -0.01611215f, 0.00017787f, 0.07423077f, -0.02960143f, 
    -0.23078255f, 0.09079678f, 0.42306867f, 0.25323287f, 0.32841188f, -0.07134693f, -0.01639437f, -0.07469991f, 
    0.00129543f, -0.27681866f, 0.06953338f, -0.01077208f, -0.03690722f, 0.02607140f, -0.02118794f, 0.06136536f, 
    -0.00416844f, 0.03296149f, -0.04664639f, 0.05284302f, -0.28375879f, 0.18280125f, -0.09634375f, 0.08025383f, 
    -0.29256368f, 0.04830316f, 0.06600950f, 0.08505031f, 0.04328971f, 0.08185643f, -0.01849870f, -0.04213579f, 
    0.03167029f, -0.12721951f, -0.05222147f, -0.03172373f, -0.05196177f, -0.02336309f, 0.04068852f, 0.02163441f, 
    -0.01598091f, -0.04948704f, -0.07055973f, 0.06978483f, -0.02729510f, 0.17198178f, 0.02715959f, -0.10262007f, 
    -0.06324764f, 0.03699361f, 0.05129532f, 0.00053732f, -0.09694660f, -0.06639683f, 0.06394405f, 0.03481108f, 
    -0.10315521f, -0.05392001f, -0.09617721f, -0.02648638f, 0.10222659f, 0.16102347f, 0.28404900f, 0.25740626f, 
    0.19253774f, -0.13076390f, -0.05488356f, 0.08162867f, 0.02849953f, 0.16362020f, 0.07996529f, 0.02667852f, 
    0.00221811f, 0.00081219f, 0.03721269f, -0.00188709f, -0.02266256f, -0.06437477f, 0.04212157f, -0.12667823f, 
    0.13351049f, 0.17998093f, 0.14430314f, 0.10015962f, 0.09819926f, -0.12398838f, -0.07145198f, -0.03263303f, 
    0.02501712f, 0.11622293f, 0.06660565f, 0.05256599f, 0.03743003f, -0.06913409f, 0.05157902f, 0.00006594f, 
    -0.05158658f, -0.00725466f, -0.00088291f, -0.10476528f, -0.22069226f, 0.17264369f, -0.24867968f, -0.06234307f, 
    0.04620948f, 0.01179409f, -0.01227447f, -0.01001316f, 0.03136719f, 0.02999936f, 0.05952825f, 0.03986601f, 
    0.00407123f, 0.04792257f, -0.04279199f, 0.14455114f, 0.16812329f, 0.22766437f, 0.00972494f, 0.34500840f, 
    0.10855927f, 0.20097871f, 0.28182170f, 0.19730276f, 0.20443138f, -0.03990445f, -0.02867711f, -0.04863163f, 
    -0.02358013f, 0.14933354f, 0.01473544f, 0.05176786f, 0.01608849f, 0.02541367f, 0.02609960f, 0.02209749f, 
    -0.03483825f, -0.14161812f, 0.04858082f, -0.20532174f, 0.22579272f, -0.27115613f, 0.06294841f, -0.23363587f, 
    -0.05358188f, 0.19776139f, -0.00665746f, 0.04737649f, -0.12719887f, -0.10863592f, -0.05944984f, 0.02374028f, 
    -0.02915842f, -0.16253775f, -0.03171599f, 0.07114112f, -0.10231365f, 0.03079146f, -0.12580633f, -0.17479700f, 
    0.20461763f, -0.25823766f, -0.09339413f, -0.04403071f, -0.05499686f, 0.01489389f, -0.13263002f, -0.06728029f, 
    -0.01893803f, -0.05237748f, 0.08846001f, -0.05570462f, -0.08238396f, -0.15149434f, 0.06162776f, 0.07238609f, 
    -0.03402912f, 0.01731053f, -0.11777487f, -0.04785610f, 0.05577878f, 0.02666308f, -0.04584035f, -0.02270958f, 
    -0.01410043f, 0.07896738f, 0.00204045f, 0.03294711f, 0.08047597f, 0.03852596f, 0.10346810f, 0.03340981f, 
    0.02280586f, 0.02376764f, 0.04868978f, 0.08302870f, 0.02852636f, -0.01818696f, 0.00963220f, 0.10168087f, 
    0.11263872f, 0.08024608f, 0.28172660f, 0.06958040f, 0.19199117f, 0.00570605f, 0.08538462f, 0.06435955f, 
    0.00707114f, 0.03115879f, 0.01819228f, -0.01241211f, 0.00804870f, -0.04402823f, -0.00736130f, -0.00480259f, 
    -0.01372606f, -0.11971212f, 0.01351129f, -0.04648050f, 0.08310249f, -0.06619545f, 0.09160191f, -0.02058583f, 
    -0.18104374f, 0.06717589f, 0.00752764f, 0.00358198f, 0.06467441f, -0.01699235f, 0.01388530f, 0.00497637f, 
    -0.10366702f, -0.10731902f, -0.09271282f, 0.06073661f, 0.07217959f, -0.09669445f, -0.02046867f, 0.14580373f, 
    0.14682269f, -0.02527089f, 0.13615654f, -0.02212006f, -0.00616582f, 0.03263516f, 0.02226734f, 0.04879202f, 
    -0.08099695f, -0.01295050f, 0.02004226f, -0.09304662f, -0.00021483f, 0.00036290f, -0.00952393f, 0.04227629f, 
    -0.02239741f, -0.07291555f, -0.06700509f, -0.04493283f, 0.10010210f, 0.02413215f, 0.04896012f, -0.16912834f, 
    0.02964914f, 0.14209163f, 0.08383318f, 0.07967857f, -0.00656477f, 0.09546018f, 0.01335106f, -0.04026804f, 
    0.06062228f, 0.03876748f, -0.03529884f, -0.01375922f, -0.07579146f, -0.23155318f, -0.19730103f, -0.07549673f, 
    0.04936436f, 0.10447491f, -0.05821687f, 0.29034510f, -0.03486551f, -0.12846048f, 0.02736974f, 0.11557014f, 
    -0.18741247f, -0.02055141f, -0.11292543f, 0.01585429f, 0.00783889f, 0.06716195f, 0.07007382f, -0.00949595f, 
    -0.10479873f, -0.03074144f, -0.08834296f, -0.09253093f, 0.30474040f, -0.24497223f, -0.23776373f, 0.34844518f, 
    0.04530356f, 0.06791779f, -0.02134977f, 0.00865112f, 0.02304866f, -0.05736410f, 0.05381704f, -0.13774729f, 
    0.01005283f, 0.01710346f, 0.04370017f, -0.06972993f, 0.01718622f, -0.01178905f, -0.05343526f, 0.03062538f, 
    0.11978938f, -0.13067017f, -0.00854315f, 0.06884368f, 0.14837764f, -0.03120495f, 0.00278401f, 0.00351324f, 
    0.08472733f, -0.09401493f, 0.04227569f, 0.01041142f, -0.01434115f, -0.02526782f, 0.00707926f, -0.02795081f, 
    -0.01007481f, -0.16532868f, -0.08632434f, 0.06056720f, -0.15593792f, -0.10080883f, -0.03662573f, 0.04288597f, 
    0.04287871f, -0.09861933f, 0.01929623f, -0.03044492f, -0.08767091f, -0.05156256f, 0.00954283f, 0.02334599f, 
    -0.04204918f, 0.08062837f, 0.05452444f, 0.08030429f, 0.09125436f, 0.00489162f, 0.01138190f, 0.08325714f, 
    -0.10008859f, -0.55992723f, -0.41659749f, 0.29195309f, -0.32478213f, 0.04354822f, -0.13734692f, -0.17987205f, 
    -0.20627552f, -0.07131985f, 0.05622606f, -0.15609887f, 0.11217523f, 0.09643695f, -0.02267873f, 0.00721371f, 
    -0.04769481f, -0.04226739f, -0.32978109f, -0.00647119f, 0.04112713f, 0.05470653f, 0.06139256f, 0.05323049f, 
    0.12862439f, 0.14899588f, 0.20119232f, 0.08836175f, -0.00275015f, 0.07305557f, 0.07816156f, 0.05728238f, 
    0.00739684f, -0.00023625f, 0.03108045f, 0.01367957f, -0.06169691f, -0.10151843f, -0.05078114f, -0.05026683f, 
    0.14939041f, -0.14304906f, -0.19122933f, 0.01483188f, -0.01835855f, -0.00659971f, -0.07255837f, 0.03565543f, 
    -0.07137340f, 0.02318490f, -0.13581862f, 0.05279053f, 0.01138736f, -0.04476685f, -0.07197616f, 0.01476736f, 
    -0.11061873f, 0.06473591f, 0.00664739f, 0.01074900f, -0.00254864f, 0.01535850f, -0.04730119f, -0.01195276f, 
    0.06147017f, -0.04615928f, 0.04577916f, 0.02844373f, 0.04033250f, 0.00860421f, 0.04272056f, 0.01735666f, 
    -0.01262140f, -0.03770242f, 0.05577759f, -0.05966144f, -0.10036102f, 0.00702169f, 0.03296591f, -0.01927393f, 
    0.10500439f, 0.19481809f, -0.08754946f, 0.20411842f, 0.26282766f, -0.10259151f, 0.08741887f, -0.01930129f, 
    0.08466469f, 0.00740520f, 0.12217375f, -0.02465444f, -0.00513517f, 0.00571605f, 0.03757128f, -0.08529222f, 
    -0.02761394f, 0.05307604f, -0.05056032f, -0.04177243f, -0.28046700f, -0.12937644f, 0.17836644f, -0.07287838f, 
    -0.04148200f, -0.07072251f, -0.01815481f, -0.06788904f, 0.01942301f, -0.02987839f, -0.01460970f, -0.15562414f, 
    -0.05976909f, 0.14745970f, 0.02827192f, 0.03123688f, 0.08815011f, -0.04357103f, -0.05550240f, -0.06806625f, 
    -0.61264324f, -0.17645948f, 0.12131100f, -0.28212956f, -0.05414718f, 0.04004531f, 0.06228700f, -0.07011641f, 
    0.04895649f, 0.14514290f, -0.08951375f, -0.04770002f, -0.00398559f, -0.00315452f, -0.02761746f, -0.05853929f, 
    0.05380510f, 0.03370886f, -0.07503264f, 0.02452482f, -0.06909604f, -0.28411868f, 0.20513558f, 0.12654246f, 
    0.01791218f, -0.22057205f, -0.15515260f, -0.01119037f, -0.09222836f, 0.20372592f, -0.03561426f, 0.03209753f, 
    0.00355483f, -0.08464982f, -0.10881453f, -0.00879106f, 0.03930486f, 0.05865395f, -0.04974413f, 0.01326343f, 
    -0.25379092f, -0.09828522f, -0.10154343f, -0.07440108f, 0.00694419f, -0.16298635f, 0.02149206f, 0.00709309f, 
    -0.05940202f, -0.04962282f, 0.01534142f, -0.00671505f, -0.07747003f, 0.00692850f, 0.05348279f, -0.01837383f, 
    0.21683457f, 0.07491215f, 0.10434821f, 0.14200427f, 0.15978570f, -0.04043801f, 0.11780251f, -0.01702561f, 
    0.04631272f, 0.01697695f, -0.02738087f, -0.05029706f, -0.11108019f, 0.00086748f, 0.06482062f, -0.05578557f, 
    0.05410431f, -0.00221012f, 0.00771894f, 0.01091288f, -0.04986269f, -0.02033612f, -0.03645088f, -0.07941767f, 
    -0.19408606f, -0.83076131f, -0.10271835f, 0.33381304f, -0.06020393f, 0.11069066f, -0.05033576f, 0.08683044f, 
    -0.21953049f, 0.10367398f, -0.06342902f, 0.00510961f, -0.06076340f, 0.02480043f, -0.13240929f, -0.18006736f, 
    -0.13461366f, 0.03390025f, -0.26796836f, 0.11711542f, 0.01306056f, -0.02436841f, -0.00827180f, -0.05787786f, 
    -0.13577746f, 0.07711051f, -0.02239660f, 0.00390491f, 0.03458627f, 0.07124244f, 0.02723324f, -0.00423745f, 
    -0.04434688f, 0.07793181f, -0.05422748f, -0.05462005f, 0.12848683f, 0.04007586f, -0.09194242f, 0.01504012f, 
    -0.09806005f, 0.05580074f, 0.04912805f, 0.13837409f, 0.11060894f, -0.04038558f, -0.02904296f, -0.05624028f, 
    -0.02987068f, 0.10871844f, -0.01481594f, -0.01056451f, -0.00272732f, -0.01951249f, 0.03223158f, -0.01478473f, 
    -0.08954543f, -0.09307351f, -0.05924205f, -0.19009373f, -0.06648094f, -0.10496993f, 0.10001162f, -0.02086799f, 
    0.08266133f, -0.05636252f, 0.09761649f, -0.17250423f, -0.01285501f, 0.06743044f, 0.06273557f, -0.04397577f, 
    -0.02114620f, -0.13464022f, -0.04075157f, -0.06188261f, 0.01747473f, -0.01099375f, -0.05687556f, -0.00074529f, 
    0.08956309f, -0.01491442f, -0.08301190f, -0.12489407f, -0.16035739f, 0.18271527f, -0.02569733f, 0.00661508f, 
    0.02361693f, -0.01066723f, -0.02229833f, -0.03240638f, -0.09371041f, 0.00278089f, -0.07999989f, -0.03349147f, 
    0.07044221f, -0.21148185f, -0.14604399f, -0.00886043f, -0.14201583f, -0.26561689f, -0.02054852f, -0.36813474f, 
    0.07378295f, -0.10968227f, 0.09177008f, -0.00858638f, 0.13612698f, -0.26041090f, -0.04995524f, -0.03869839f, 
    -0.09230798f, 0.11769554f, -0.00070252f, -0.10725724f, 0.15864648f, -0.09608451f, 0.02162547f, -0.06401507f, 
    0.04688557f, -0.03013849f, -0.03828591f, 0.04628273f, -0.02722490f, 0.01177783f, -0.00932880f, 0.01030897f, 
    -0.01751746f, 0.01187163f, -0.03074517f, -0.04039197f, -0.05163000f, -0.03192712f, 0.00061152f, 0.03406224f, 
    -0.03523530f, 0.01152286f, -0.03152310f, -0.05705728f, -0.11702698f, -0.08426570f, 0.10489990f, -0.24337497f, 
    -0.14599793f, -0.00490297f, 0.04631218f, 0.03440277f, 0.00380865f, 0.05538975f, -0.01134052f, -0.02779538f, 
    0.00817114f, 0.02803635f, 0.00410352f, -0.21464190f, -0.01130938f, -0.02965627f, -0.17485443f, -0.04720705f, 
    0.17273164f, 0.00860978f, -0.08287442f, 0.31588528f, 0.07438567f, 0.03857798f, -0.00488383f, 0.06887840f, 
    -0.06590050f, 0.07715408f, 0.00359152f, -0.05182312f, -0.00406045f, -0.09868439f, 0.00258935f, -0.01626836f, 
    -0.03351245f, 0.00883993f, -0.06209571f, 0.00897544f, -0.50026351f, -0.02676206f, -0.22506483f, -0.40824223f, 
    -0.32189706f, 0.05851943f, 0.01383057f, 0.01268953f, 0.09884806f, 0.06674308f, 0.03230460f, -0.01054851f, 
    -0.02030135f, -0.06960478f, 0.03517058f, -0.05212850f, 0.09899037f, 0.02534352f, 0.02347711f, 0.10903021f, 
    -0.14517771f, -0.23371625f, -0.01254037f, 0.06714841f, 0.02647929f, -0.04130091f, -0.02011018f, 0.02886476f, 
    -0.25666466f, -0.00515475f, -0.10606664f, 0.05219998f, -0.02009136f, -0.10205962f, -0.21838747f, -0.12843071f, 
    -0.03077191f, 0.02971406f, 0.01052146f, 0.19707648f, 0.12827712f, -0.22231720f, 0.07961427f, -0.00839042f, 
    -0.00685565f, -0.03760168f, -0.09683856f, 0.01331090f, -0.06317327f, 0.07238664f, 0.00429713f, -0.01847923f, 
    -0.02658693f, -0.06048780f, -0.09958103f, 0.00228392f, -0.01554367f, 0.02279583f, -0.01554867f, -0.06610639f, 
    0.03565000f, -0.04252580f, -0.04082954f, 0.30987537f, -0.10879539f, 0.01185180f, -0.03910510f, 0.01621678f, 
    0.05658511f, 0.01446532f, 0.00309192f, -0.01630556f, -0.00471183f, 0.04397797f, -0.01450181f, 0.06806494f, 
    0.14471805f, -0.10196882f, -0.01531752f, 0.21829541f, 0.02462598f, 0.03263425f, 0.12855268f, 0.11708788f, 
    0.01892955f, -0.01638066f, 0.08200128f, 0.01612679f, 0.15520634f, 0.04341306f, 0.01855847f, 0.01473268f, 
    -0.01575947f, -0.01217488f, -0.01150210f, 0.00478691f, 0.03580938f, 0.02441141f, 0.08194998f, 0.15297179f, 
    -0.01739229f, 0.08539904f, 0.12473619f, 0.18175007f, 0.04845034f, -0.13010892f, 0.12100070f, -0.03451590f, 
    0.07043092f, 0.04626238f, 0.02106697f, -0.01970286f, -0.05444704f, 0.00087893f, -0.00571850f, -0.05352974f, 
    0.04000199f, -0.11427765f, 0.00658522f, -0.00713700f, 0.09602886f, -0.07387798f, 0.07057235f, 0.03429102f, 
    0.03477915f, 0.04694199f, 0.08935364f, 0.05981065f, -0.03079787f, -0.09014332f, -0.10986540f, -0.03677674f, 
    0.01873320f, -0.03460956f, 0.02505103f, 0.01754145f, -0.14350079f, 0.08063677f, -0.24815795f, -0.31334862f, 
    0.02246425f, 0.02900709f, 0.07098415f, 0.09930420f, 0.01955083f, -0.06835062f, -0.07980146f, -0.08326843f, 
    0.02396487f, -0.04180158f, 0.09652749f, -0.01853792f, -0.00998976f, 0.00379367f, 0.05055423f, -0.01924527f, 
    -0.05743473f, -0.03719999f, 0.01581450f, -0.07266101f, 0.10175727f, 0.04707014f, 0.09989282f, -0.03429761f, 
    0.02059102f, 0.11688774f, -0.02778980f, 0.01310903f, -0.04541624f, 0.04605342f, -0.01869127f, 0.02934250f, 
    0.03047533f, 0.06553878f, 0.02048617f, 0.02364514f, -0.06329025f, -0.09986225f, -0.12806073f, -0.18280067f, 
    0.10569250f, -0.00120358f, 0.21864292f, 0.10132138f, 0.02904570f, -0.13796607f, -0.12896372f, 0.01859050f, 
    -0.09055481f, -0.06109429f, -0.02107570f, -0.06081235f, 0.04789977f, 0.00773889f, 0.02902884f, 0.03661738f, 
    0.03026768f, -0.14171864f, -0.12004833f, -0.07604159f, 0.13767923f, 0.14587121f, 0.22969076f, 0.21646649f, 
    0.17340295f, -0.11049496f, -0.04397865f, 0.02640188f, 0.00369076f, 0.15668102f, 0.02732942f, 0.01518693f, 
    -0.00051544f, 0.00323707f, 0.05029365f, 0.03344492f, -0.03029313f, -0.03004652f, 0.05956199f, -0.10523777f, 
    0.02684038f, -0.17768745f, 0.14219852f, -0.17136104f, 0.00480067f, 0.06005492f, 0.02306065f, -0.00336539f, 
    -0.24884699f, -0.01140161f, -0.05265344f, -0.08161671f, 0.11325914f, -0.04754792f, -0.11101435f, 0.01926045f, 
    -0.05491275f, 0.00267121f, -0.07303990f, -0.10315646f, 0.13522984f, 0.01479467f, 0.13755469f, 0.07028415f, 
    0.09435625f, -0.11551962f, -0.06337149f, -0.09135425f, 0.06650670f, 0.07333963f, -0.00300181f, 0.01767000f, 
    -0.07232595f, 0.00608622f, 0.01647686f, 0.02232508f, -0.03025961f, 0.02380692f, 0.02514007f, -0.01768389f, 
    -0.01415495f, 0.04923573f, 0.03652618f, 0.18497598f, -0.09593210f, 0.07903249f, -0.10235041f, -0.05026727f, 
    -0.09599994f, -0.01074421f, 0.07722753f, -0.04336372f, 0.09009452f, -0.01260565f, 0.00631539f, -0.04490625f, 
    -0.09737463f, 0.00557578f, -0.15334891f, -0.02921772f, 0.30096751f, -0.30639073f, -0.21369314f, 0.13974006f, 
    -0.03654269f, 0.09491605f, -0.02637146f, 0.05930659f, -0.00497895f, 0.05905293f, -0.03333438f, 0.01442730f, 
    -0.04579100f, -0.05648872f, 0.04983796f, -0.03535243f, -0.09089132f, 0.00500311f, -0.09123866f, -0.06383833f, 
    -0.20016941f, -0.05279997f, 0.10214783f, 0.06079580f, 0.11191889f, -0.08640450f, 0.09554157f, -0.02501642f, 
    0.06057786f, 0.02235451f, -0.02622941f, -0.00316432f, 0.05263289f, 0.02260318f, 0.05197279f, 0.01699052f, 
    0.13329709f, 0.00330276f, -0.02201615f, 0.24421407f, 0.10764886f, -0.20040302f, -0.03506019f, -0.10366886f, 
    -0.06593873f, -0.00617311f, -0.04541439f, 0.05082715f, -0.00676557f, 0.01787664f, -0.01248815f, -0.08616293f, 
    -0.03470369f, -0.00505801f, -0.08932021f, -0.09280798f, -0.09533320f, 0.04538336f, -0.03635472f, -0.15829216f, 
    0.08619240f, -0.02002870f, 0.02882054f, 0.02144698f, -0.01122904f, -0.02273706f, -0.00570273f, -0.02029554f, 
    -0.00430541f, -0.01699282f, 0.05573315f, -0.04935525f, -0.12215822f, -0.00689870f, -0.05087338f, 0.10843627f, 
    0.02099993f, -0.01040443f, -0.04758656f, -0.01554586f, 0.08083644f, -0.04400241f, 0.25988248f, 0.02927902f, 
    0.11567588f, -0.05659344f, 0.17431042f, 0.01766267f, 0.02391038f, -0.01046523f, -0.00520086f, -0.02458165f, 
    -0.06241555f, 0.05224852f, 0.03572448f, 0.00441560f, 0.08005790f, -0.11064651f, -0.00524240f, 0.12113481f, 
    -0.13431828f, -0.06390197f, 0.08317355f, 0.11035278f, 0.14670552f, -0.12359881f, 0.01418947f, -0.06992411f, 
    -0.16498679f, -0.12470336f, 0.01170348f, 0.00756008f, -0.01837611f, 0.03624261f, -0.06156398f, -0.01577414f, 
    0.05085270f, 0.05867531f, 0.00536661f, 0.07504439f, 0.00310630f, -0.06180688f, -0.13673258f, -0.10353893f, 
    -0.07315849f, 0.07838574f, 0.01442479f, 0.02699860f, -0.03172005f, 0.00434812f, 0.09847236f, 0.01110552f, 
    0.03988000f, 0.00536689f, 0.03011218f, 0.00485246f, -0.08287404f, 0.05573218f, -0.14105012f, 0.00047060f, 
    -0.07091669f, -0.10616944f, -0.00404610f, 0.01777003f, -0.14365530f, -0.09095658f, 0.13167278f, -0.10747781f, 
    0.05131766f, -0.03406571f, -0.00009847f, -0.10987985f, -0.06963491f, -0.01111270f, 0.06260960f, -0.17725025f, 
    -0.10805065f, -0.08304949f, 0.02000410f, -0.14826547f, 0.08630985f, 0.11081730f, -0.02510585f, -0.01444404f, 
    -0.00028623f, 0.07736295f, 0.05212680f, 0.02546135f, 0.05447070f, 0.09301946f, 0.15666838f, 0.06516867f, 
    0.04513302f, 0.00273201f, 0.06522124f, 0.12187630f, 0.03344318f, -0.05238736f, 0.01282681f, 0.06724021f, 
    0.12958646f, -0.00656041f, 0.14612275f, 0.05035856f, 0.08734660f, -0.09071317f, -0.06586044f, -0.10120720f, 
    0.02821524f, 0.03797496f, 0.11634977f, 0.00715242f, -0.00072732f, -0.02108975f, 0.04208506f, 0.04709760f, 
    0.02107762f, 0.05485876f, -0.03545321f, -0.04546368f, -0.04718933f, 0.04193386f, -0.05104347f, 0.03432894f, 
    -0.05189962f, 0.01744205f, 0.06552943f, 0.01236029f, -0.04292697f, -0.00510756f, -0.21427941f, 0.03053227f, 
    0.04921100f, 0.00855461f, 0.06662297f, 0.05737140f, -0.13809882f, -0.03755122f, -0.05774069f, -0.00057011f, 
    0.02578326f, -0.07976505f, 0.23294802f, 0.14417405f, -0.15670541f, -0.06899416f, 0.01964202f, -0.01782061f, 
    -0.03313912f, -0.06468138f, 0.03012831f, -0.14293259f, -0.10246886f, 0.05898034f, 0.03278416f, -0.06138147f, 
    -0.05221773f, -0.03729082f, -0.13225639f, -0.05239013f, 0.04291600f, 0.07233859f, 0.06391606f, 0.13920178f, 
    0.04669499f, -0.04198183f, -0.07040605f, -0.11428828f, -0.00786513f, 0.03404590f, 0.14125496f, 0.00239945f, 
    -0.02764766f, 0.04376059f, 0.08995191f, 0.04546826f, 0.03772552f, 0.00156070f, -0.11457330f, -0.02961508f, 
    -0.22729072f, -0.02748859f, -0.12661162f, -0.09550678f, 0.19004084f, -0.05569431f, 0.00318579f, 0.07458255f, 
    -0.08100352f, 0.02178061f, -0.00705922f, -0.02088892f, 0.08572486f, -0.07947905f, -0.00991334f, 0.00070018f, 
    0.01596587f, 0.00462380f, -0.04389955f, 0.01233511f, -0.00743229f, 0.05364764f, 0.05855875f, -0.23607264f, 
    -0.10419551f, 0.09070961f, 0.02646902f, -0.01398675f, 0.02998522f, 0.06382871f, 0.04228383f, 0.05209803f, 
    -0.03378862f, 0.03364701f, -0.09101884f, -0.09665653f, -0.01987603f, -0.02139912f, -0.06051052f, -0.01318517f, 
    -0.15174158f, -0.09957764f, -0.06465288f, 0.14293960f, 0.02147565f, -0.04380054f, -0.06034371f, -0.04362705f, 
    0.11164673f, -0.08837239f, 0.01246064f, -0.02393872f, 0.10232479f, 0.10566006f, -0.01063097f, 0.10061270f, 
    -0.07809846f, 0.00643290f, 0.05505195f, 0.11079806f, -0.02964926f, -0.09654859f, 0.17831941f, -0.08756937f, 
    -0.17025343f, 0.10891187f, 0.12732418f, 0.10825769f, -0.07686475f, -0.15242504f, 0.04555314f, -0.03565110f, 
    0.01567400f, 0.01431298f, -0.01938506f, -0.00421039f, 0.04399236f, 0.01584885f, 0.10282103f, 0.10795746f, 
    0.06452446f, 0.13933162f, 0.14384224f, 0.07625917f, 0.07246614f, 0.07096590f, -0.00479847f, 0.22851923f, 
    -0.06731699f, -0.13527046f, -0.09592182f, -0.04257903f, 0.02227965f, 0.00242006f, -0.01466275f, 0.11751807f, 
    -0.01149813f, 0.04278016f, -0.12325361f, 0.20266512f, 0.35234979f, 0.08711838f, 0.00114666f, -0.11149573f, 
    0.19186281f, 0.07538568f, 0.04264959f, -0.04283363f, 0.00335704f, -0.03258135f, 0.04149661f, 0.04248515f, 
    -0.01651707f, -0.00963873f, 0.00674019f, -0.22992581f, -0.08511686f, -0.26008555f, -0.03075543f, -0.31845093f, 
    0.00426249f, -0.09980606f, 0.26694256f, -0.14555077f, -0.11332147f, 0.15475146f, 0.09097254f, 0.06649816f, 
    -0.07671788f, -0.12484169f, 0.04336404f, 0.01066392f, -0.00033136f, -0.00988758f, 0.01074804f, 0.00173009f, 
    0.03752004f, -0.03441556f, 0.12922636f, 0.07121136f, -0.11159328f, -0.07846301f, -0.17470695f, 0.05822762f, 
    0.13268386f, 0.00117469f, -0.00925898f, -0.00584262f, -0.00133915f, -0.00906382f, 0.13437080f, -0.16679960f, 
    0.02344454f, 0.02060603f, -0.08137318f, 0.11538421f, -0.10511936f, 0.02730716f, -0.04262645f, 0.00171662f, 
    -0.33416206f, 0.30739182f, -0.03965184f, -0.02780532f, -0.08260475f, -0.06287363f, -0.01904133f, -0.09771763f, 
    0.06101217f, -0.01550046f, 0.09706334f, 0.06557522f, 0.10811051f, -0.09650663f, -0.17443857f, -0.04449537f, 
    -0.05938403f, -0.01043173f, 0.22633560f, 0.16635482f, -0.15108089f, -0.10047299f, -0.06369887f, 0.02053266f, 
    0.01269814f, 0.04756448f, 0.00597340f, -0.08793553f, 0.00214578f, 0.03554643f, -0.01001556f, -0.00743813f, 
    -0.08058171f, 0.01352261f, 0.00696066f, -0.15013537f, 0.08488971f, 0.09579653f, -0.00133207f, -0.00988833f, 
    0.23365927f, 0.01490537f, 0.18481871f, 0.05183201f, -0.12104189f, 0.07181431f, 0.10826029f, 0.03172022f, 
    -0.01693319f, 0.02857513f, 0.02622478f, -0.02336979f, 0.03777581f, 0.02934957f, 0.00399945f, -0.06310759f, 
    0.00441636f, 0.01675243f, 0.01353682f, 0.08962400f, -0.02751934f, -0.00035270f, -0.09591185f, -0.08664846f, 
    0.04574644f, 0.06461576f, 0.00766292f, -0.05018654f, -0.01903179f, -0.01715552f, -0.09606963f, -0.15712991f, 
    0.06884503f, 0.13382545f, 0.00890505f, -0.02923725f, 0.05523629f, 0.07251677f, -0.08240385f, -0.01218175f, 
    0.05003130f, -0.02886809f, 0.02142895f, -0.02896625f, 0.01040280f, 0.05895770f, 0.02752652f, -0.05804840f, 
    -0.04356088f, 0.05591949f, -0.10796718f, 0.01605927f, 0.10352216f, -0.02128990f, -0.08620970f, 0.03918049f, 
    0.11099160f, 0.03440895f, 0.05762365f, 0.02117220f, 0.06485723f, -0.01950374f, 0.02325731f, -0.09497408f, 
    0.08799103f, -0.16784188f, 0.18445361f, 0.06239535f, -0.11043061f, -0.00984217f, 0.09318724f, -0.14855716f, 
    -0.06655523f, -0.06255484f, -0.03180435f, 0.02241176f, 0.06120540f, -0.07428889f, -0.03232884f, 0.12611999f, 
    0.03714506f, -0.41467810f, 0.37886652f, -0.12376690f, -0.45369998f, 0.13736682f, -0.00764649f, -0.08320737f, 
    -0.06698981f, 0.07353424f, 0.10748425f, 0.02796897f, -0.02405193f, -0.00954949f, 0.10695598f, -0.00737183f, 
    0.03346447f, -0.02050817f, 0.16354461f, 0.08594229f, -0.53603232f, 0.28390864f, 0.16201614f, 0.23968661f, 
    -0.18354270f, 0.06176231f, -0.07423524f, -0.10298835f, 0.08728010f, 0.17325248f, -0.10095759f, 0.09767612f, 
    -0.04452967f, -0.03434050f, -0.05695761f, 0.03723712f, -0.14973937f, 0.11773900f, -0.10146891f, -0.10226260f, 
    0.21479104f, -0.18601328f, -0.02878037f, 0.05138722f, -0.10764842f, 0.18803135f, -0.02918840f, 0.04133792f, 
    -0.09096457f, 0.03312754f, 0.03658600f, 0.00629096f, 0.00372059f, -0.00884585f, 0.07192574f, -0.04536577f, 
    -0.00094987f, 0.07315408f, 0.15857929f, 0.05459298f, -0.03091273f, -0.00150715f, 0.03397045f, 0.08996646f, 
    -0.12129498f, -0.00987768f, -0.03843201f, 0.00845412f, -0.02527252f, -0.03813554f, 0.04422961f, 0.00774291f, 
    -0.00207467f, 0.02203959f, 0.03311278f, -0.10736845f, -0.04444209f, -0.10972219f, -0.06281918f, -0.15681204f, 
    -0.51436013f, 0.48711061f, -0.00288732f, 0.42783090f, -0.53338295f, 0.11245417f, -0.25927800f, -0.15606759f, 
    0.16032782f, 0.01129917f, 0.10287045f, -0.04967184f, -0.15295288f, -0.05600255f, 0.15144865f, -0.04625743f, 
    0.03352246f, 0.09866770f, -0.12903622f, -0.09163464f, -0.04385449f, 0.02730624f, -0.05654513f, -0.00296835f, 
    0.04614341f, 0.04988762f, 0.00580177f, 0.04131919f, 0.00005448f, 0.00981249f, -0.03244301f, -0.06536996f, 
    -0.06309653f, -0.09343701f, -0.00523251f, 0.03881526f, 0.06349476f, 0.18655068f, -0.06993002f, 0.02428589f, 
    -0.09663238f, -0.16120125f, 0.05598990f, -0.03760526f, -0.18123659f, -0.07799850f, 0.05212965f, -0.09037708f, 
    -0.01864822f, 0.13298529f, 0.10808702f, 0.00880074f, -0.12404332f, 0.08511077f, 0.16190812f, 0.03193779f, 
    0.04036684f, -0.03375359f, 0.04788890f, 0.12075309f, -0.04306830f, -0.17626715f, -0.10926197f, 0.06390084f, 
    0.01322420f, 0.04173576f, 0.06285334f, 0.00353641f, 0.06757318f, 0.06331196f, -0.04215490f, -0.02660041f, 
    0.00905305f, -0.03659834f, 0.06749179f, 0.00702882f, -0.04751739f, 0.07063814f, -0.08211231f, 0.05818119f, 
    0.02735936f, -0.14344656f, -0.37388462f, 0.12195803f, 0.02446351f, 0.14041495f, 0.03950233f, -0.00405624f, 
    -0.05331198f, 0.04697559f, -0.00689718f, -0.01874540f, -0.00681032f, 0.00895577f, -0.03082782f, -0.01714598f, 
    -0.08265729f, 0.24363720f, -0.09261647f, -0.05961271f, -0.53964221f, -0.07366639f, -0.18186593f, -0.27266535f, 
    0.02338616f, 0.04202850f, -0.03723127f, 0.00244961f, -0.03395676f, -0.07092912f, -0.03413845f, 0.12605724f, 
    0.07045095f, -0.16820799f, -0.00349919f, -0.05888019f, -0.05556488f, 0.14861658f, -0.01885590f, 0.01667107f, 
    -0.29978931f, 0.09854419f, -0.46406591f, -0.26786247f, 0.15283918f, -0.05283132f, -0.04511590f, -0.00549089f, 
    -0.07300693f, 0.00984087f, -0.03986783f, 0.05358949f, -0.03666978f, -0.00883450f, 0.02942577f, -0.12475036f, 
    -0.07765312f, 0.12862557f, -0.01392605f, 0.03497697f, -0.53895122f, 0.14393030f, -0.27554676f, -0.29362246f, 
    -0.18987404f, -0.09238723f, -0.02086754f, 0.03027260f, -0.02544172f, 0.01098599f, -0.00843461f, 0.09957773f, 
    -0.16440293f, 0.10449128f, 0.05927098f, -0.09442899f, -0.08127001f, 0.04097755f, 0.01919345f, 0.00645711f, 
    0.23713210f, -0.09163829f, 0.00918968f, -0.01208824f, -0.15868989f, 0.03484388f, -0.05664395f, -0.04986418f, 
    -0.11667216f, -0.03263002f, -0.01408642f, -0.00039971f, -0.02467127f, -0.05110845f, 0.02398532f, -0.18820164f, 
    -0.18846324f, -0.15493977f, -0.38100937f, -0.22541721f, 0.08800000f, -0.02545016f, 0.02445431f, -0.05595786f, 
    -0.05590142f, 0.04083716f, -0.01618122f, -0.02421445f, -0.01173766f, 0.07547354f, -0.17882021f, 0.00505714f, 
    -0.09602275f, 0.01389799f, -0.06911156f, 0.03612993f, 0.09071703f, 0.04392112f, -0.02278196f, 0.05357898f, 
    -0.33497021f, -0.01178997f, 0.17742421f, 0.05150394f, -0.33436301f, 0.07094136f, -0.12772954f, 0.02045999f, 
    0.15378337f, -0.04193690f, 0.02712128f, -0.12824047f, -0.13085274f, -0.06041306f, -0.04427392f, 0.12256052f, 
    0.10353411f, 0.02380675f, -0.02490739f, -0.13364923f, -0.04823509f, 0.06175358f, -0.15498333f, -0.06108524f, 
    0.13565680f, 0.10501197f, -0.01852206f, -0.01878829f, -0.03468747f, -0.11929192f, 0.03547196f, 0.00028843f, 
    -0.15593626f, 0.08243115f, 0.15287851f, -0.04997081f, -0.02056196f, 0.02589289f, -0.01388365f, 0.00269015f, 
    -0.03700366f, -0.01539392f, 0.05692868f, 0.05317256f, -0.10308597f, -0.02302212f, -0.05749429f, 0.02661669f, 
    0.12628852f, -0.03175690f, -0.03295076f, -0.04033023f, -0.05987132f, -0.07940249f, 0.04485264f, 0.03516396f, 
    0.04641832f, 0.06412245f, -0.08701212f, 0.14215390f, 0.10235786f, -0.04355511f, 0.02111916f, -0.04051014f, 
    -0.02107958f, 0.11881704f, -0.14850269f, 0.05557365f, -0.12328496f, -0.11429445f, -0.11481779f, -0.03752111f, 
    0.01150513f, 0.05863152f, 0.09529066f, -0.03343504f, -0.08443353f, 0.04861704f, 0.01548158f, -0.06606938f, 
    -0.07672592f, 0.13583978f, 0.03081487f, -0.52239645f, 0.23877785f, 0.05766087f, 0.09695676f, 0.01532762f, 
    -0.01673156f, -0.09117021f, 0.11042344f, 0.04731440f, -0.05219578f, 0.07356337f, 0.06398438f, 0.02807377f, 
    0.06964529f, -0.04565430f, 0.03067251f, -0.09039567f, 0.28278476f, -0.13146068f, 0.15299739f, -0.25493047f, 
    -0.24049450f, 0.05097985f, -0.10055395f, -0.06438597f, 0.01079106f, 0.03956199f, 0.09201120f, 0.08066884f, 
    -0.03368122f, -0.07758951f, 0.06046338f, -0.14784978f, -0.10793024f, -0.03247128f, 0.05001049f, 0.19832611f, 
    -0.01131649f, -0.02304386f, -0.02892113f, 0.03477008f, -0.00080245f, -0.04212942f, 0.03653598f, -0.08834587f, 
    -0.05572180f, 0.02133312f, 0.20195808f, 0.01971227f, 0.14718974f, -0.00243572f, 0.04026095f, 0.03187466f, 
    0.00355843f, -0.03188584f, 0.04470794f, 0.01991708f, -0.21301240f, -0.01920280f, -0.13570802f, 0.01617288f, 
    0.11040541f, -0.05707215f, 0.01091051f, -0.00290961f, -0.07739351f, 0.11965543f, 0.06241814f, 0.03345609f, 
    -0.07345546f, -0.06790537f, 0.14016376f, -0.01159932f, -0.20817298f, 0.00019259f, 0.09762638f, 0.17476223f, 
    -0.25290915f, 0.21485098f, 0.16243945f, 0.00617495f, 0.03895479f, -0.00383046f, -0.13514160f, 0.18595172f, 
    0.09125042f, -0.15699509f, -0.10721693f, 0.07094432f, -0.07669026f, 0.03130440f, 0.01887561f, 0.13521662f, 
    -0.06578388f, 0.28116819f, -0.00873209f, -0.08127606f, 0.55943751f, -0.42784908f, -0.08230144f, -0.06142389f, 
    0.19806705f, 0.00270835f, -0.03927250f, -0.01801963f, -0.04820963f, 0.00547537f, 0.02094913f, 0.02386404f, 
    0.02608900f, 0.10179087f, 0.11802252f, -0.16694006f, -0.04039378f, 0.02666648f, -0.02132190f, -0.00387703f, 
    -0.20154238f, 0.00930725f, 0.14828949f, -0.03557405f, -0.19802020f, -0.06595416f, 0.03771754f, 0.09047886f, 
    -0.05749337f, -0.07143792f, -0.05737062f, -0.06541939f, -0.08571639f, 0.06575519f, 0.05800936f, -0.00187670f, 
    -0.07612484f, -0.10472067f, -0.00501612f, -0.02744740f, -0.15497178f, -0.03209701f, -0.24579491f, -0.06019957f, 
    -0.08355596f, 0.01224263f, -0.05646367f, -0.06781316f, 0.00647192f, -0.04234766f, 0.08912201f, 0.07734971f, 
    0.03371223f, 0.00119177f, -0.02002681f, 0.02886813f, -0.01261616f, 0.06955713f, 0.03238542f, 0.07741797f, 
    -0.07234216f, 0.04292548f, 0.37396497f, 0.16025051f, -0.34106347f, -0.09716010f, -0.01392836f, 0.10777953f, 
    0.07854135f, -0.09254834f, 0.02504104f, 0.02939257f, -0.01133645f, 0.02582251f, 0.01280722f, 0.03018127f, 
    -0.07849541f, -0.06623746f, -0.03839024f, -0.15872160f, 0.15854788f, 0.15970846f, 0.12450870f, 0.08717965f, 
    0.00186058f, 0.08068494f, -0.05139880f, 0.10512801f, 0.11001383f, 0.01191182f, 0.04215021f, -0.00562030f, 
    0.05766742f, 0.05376503f, 0.03937051f, 0.11951055f, -0.00855351f, -0.02917104f, -0.10877614f, -0.03737652f, 
    0.09891754f, 0.02923051f, 0.23469175f, 0.05645455f, -0.18616000f, 0.15301713f, 0.08730064f, -0.06273437f, 
    0.04303544f, -0.04001201f, 0.04607387f, -0.01619741f, 0.02517588f, 0.09865578f, 0.02338740f, -0.01756498f, 
    0.02455996f, -0.08702160f, -0.07858606f, 0.14382297f, -0.16114502f, 0.28716803f, 0.09172819f, -0.10996740f, 
    0.15814981f, -0.03640642f, -0.23735963f, 0.00407078f, -0.08462154f, 0.03520318f, 0.05610307f, 0.02011181f, 
    0.01302980f, 0.00710335f, -0.07404516f, 0.06875738f, -0.01760459f, 0.14233023f, 0.08994499f, 0.12121072f, 
    0.07045846f, -0.08808154f, 0.03613416f, 0.07574673f, -0.14077532f, 0.03442015f, -0.02505087f, -0.04103570f, 
    0.09196153f, 0.10471622f, 0.02179047f, -0.01952055f, -0.01528352f, -0.00938771f, -0.04267305f, 0.04112677f, 
    0.07028474f, -0.01154813f, -0.00562317f, 0.07830819f, 0.11531183f, -0.02392953f, 0.09507356f, -0.06744657f, 
    -0.00693148f, -0.17145702f, 0.03898231f, -0.07847743f, -0.06317942f, 0.02725003f, 0.03228178f, -0.03470189f, 
    0.11279189f, 0.00132634f, 0.02140511f, 0.05423172f, 0.06793848f, -0.07570986f, 0.04230721f, 0.12172387f, 
    -0.37315884f, -0.02369946f, 0.14978103f, -0.17287114f, -0.17138830f, 0.05029388f, 0.05966853f, 0.03211321f, 
    -0.04261497f, 0.14735603f, 0.05060838f, 0.00227936f, -0.02644777f, 0.05879046f, 0.04609168f, 0.06542297f, 
    -0.11886601f, -0.06074585f, -0.03243033f, 0.16154027f, 0.03944650f, -0.11152424f, 0.18050665f, -0.07386415f, 
    -0.20486851f, 0.14050248f, 0.10426586f, 0.02547947f, -0.27510446f, -0.07541071f, 0.01598083f, -0.02707186f, 
    -0.00657051f, 0.01020707f, 0.03193129f, -0.01448186f, 0.00534677f, -0.00302624f, 0.11109419f, 0.10773858f, 
    0.18426813f, -0.10066051f, -0.16423281f, -0.16424696f, 0.02464777f, 0.03859369f, 0.03720736f, 0.03492022f, 
    0.01028654f, 0.08191413f, 0.04889505f, 0.07377696f, -0.01596652f, -0.05584249f, -0.05303579f, 0.05589349f, 
    0.07708196f, -0.03062095f, 0.03173696f, 0.04350761f, -0.35781562f, 0.20393242f, -0.21217303f, -0.14056557f, 
    -0.10110545f, -0.03237930f, -0.01982671f, 0.10484853f, 0.00779365f, 0.14961307f, 0.06723519f, -0.03535602f, 
    -0.00669493f, -0.01224283f, -0.04657457f, -0.07118322f, 0.00040463f, 0.04037085f, -0.03513774f, -0.03361250f, 
    -0.03789140f, -0.02154353f, 0.08505230f, 0.08939551f, -0.18400644f, 0.01869494f, -0.06408936f, -0.09829388f, 
    0.01641706f, 0.09227716f, 0.08231663f, 0.00479459f, 0.00227026f, -0.05554280f, 0.03930884f, 0.02556043f, 
    0.07009758f, 0.10918032f, -0.02356310f, 0.01383246f, -0.16557947f, 0.05650049f, -0.05493698f, 0.04938019f, 
    0.05440596f, -0.04981671f, -0.07981227f, -0.10066774f, -0.08136817f, -0.05102205f, 0.13678940f, 0.01380458f, 
    0.05780445f, 0.11880818f, -0.09871104f, 0.12752549f, -0.20051870f, -0.06416724f, 0.07482076f, 0.05134241f, 
    -0.06683031f, 0.11740905f, -0.03571490f, 0.01970689f, 0.01165738f, 0.07157923f, -0.22627036f, 0.05312267f, 
    -0.01905156f, -0.00155029f, -0.00875036f, -0.01489416f, 0.04298349f, 0.08928346f, -0.04242495f, 0.13583125f, 
    -0.08672170f, -0.10094442f, -0.11735427f, -0.32642177f, 0.04055905f, -0.14393288f, -0.12547076f, -0.01162572f, 
    0.05973855f, -0.16736822f, -0.08928506f, -0.14840272f, -0.07385541f, 0.03946046f, 0.14767779f, 0.12818578f, 
    -0.06571282f, -0.01737043f, 0.13163574f, -0.04697864f, -0.06499261f, -0.04260097f, 0.08356016f, 0.30068326f, 
    -0.00523255f, -0.02924400f, -0.02147066f, -0.10084548f, 0.04012496f, 0.03937373f, 0.07178153f, -0.03583268f, 
    -0.04824452f, -0.01382981f, 0.07680368f, -0.01563976f, 0.02006126f, -0.08539570f, -0.06382985f, -0.00888632f, 
    0.01738149f, 0.05833870f, 0.03399189f, -0.02004798f, 0.05124910f, 0.04694071f, 0.25424251f, -0.02305610f, 
    0.04016334f, 0.05464634f, 0.06305711f, -0.11036526f, 0.14111552f, 0.06555984f, 0.08360257f, -0.00678755f, 
    0.11265662f, -0.04427097f, -0.02768717f, -0.00691627f, -0.11784231f, -0.24692704f, -0.02099910f, -0.20829228f, 
    -0.14920881f, -0.03343286f, -0.06388577f, 0.03295302f, -0.17606236f, -0.01564157f, -0.01032051f, 0.07116058f, 
    -0.07001959f, -0.04273240f, 0.03884137f, -0.04412916f, -0.04063529f, -0.02533769f, 0.02179340f, -0.17335565f, 
    -0.03593445f, 0.02712223f, 0.06277633f, -0.14761721f, 0.25448179f, 0.03025715f, -0.24737445f, 0.02948411f, 
    0.16923091f, 0.06605854f, -0.00946724f, -0.02381555f, -0.13997506f, -0.02652746f, 0.00616839f, -0.07225029f, 
    -0.03523584f, 0.02247121f, -0.03678448f, 0.07097057f, 0.08783145f, 0.08815020f, 0.03022591f, -0.07940233f, 
    0.19250402f, -0.03616420f, -0.09079225f, 0.01893188f, 0.15896140f, 0.01676262f, 0.05283390f, -0.06923788f, 
    -0.00287870f, 0.18712299f, -0.00271321f, -0.11505351f, 0.03263052f, 0.21570562f, 0.11513837f, 0.08356004f, 
    -0.03162473f, 0.03946333f, -0.07132677f, 0.28764257f, -0.01029470f, -0.05060945f, -0.13183676f, 0.00632399f, 
    0.03594985f, 0.01154708f, 0.00327589f, -0.05466061f, -0.06427569f, -0.00144489f, -0.03317957f, -0.10877448f, 
    -0.09339422f, 0.07868164f, 0.05290940f, 0.04296921f, 0.16416991f, 0.13438718f, 0.02834608f, -0.06149552f, 
    -0.41832379f, 0.17260467f, -0.20174044f, -0.13458288f, -0.16451463f, 0.00691095f, -0.00144252f, 0.05700851f, 
    0.01926031f, 0.09888491f, 0.03828695f, -0.00248516f, -0.05845730f, -0.06092935f, -0.04037919f, -0.05906931f, 
    0.03442613f, 0.02258687f, -0.04732807f, -0.02887247f, 0.04954062f, -0.02261363f, 0.05211718f, 0.16796781f, 
    -0.13737169f, 0.07760044f, -0.03564884f, -0.06864831f, -0.06239938f, 0.10437696f, 0.09828627f, -0.11090455f, 
    -0.01116905f, -0.09789307f, 0.15046868f, 0.01668520f, -0.00518168f, -0.01166812f, -0.03074197f, 0.00071184f, 
    -0.28959200f, 0.05743378f, 0.13914709f, -0.04763392f, 0.08566946f, 0.11268868f, -0.01166099f, -0.02372848f, 
    -0.07256373f, -0.04040188f, 0.09105859f, 0.09633738f, 0.10161578f, -0.01559094f, -0.02773478f, 0.08879808f, 
    -0.11517943f, -0.15051350f, 0.20629112f, -0.07024253f, -0.25477186f, 0.17828630f, 0.01448163f, -0.22468667f, 
    -0.11934870f, -0.04183720f, 0.07370672f, 0.09402009f, 0.04504860f, 0.10501706f, 0.05905420f, 0.00643264f, 
    -0.05566284f, -0.01224585f, -0.01610627f, -0.01888300f, 0.02185744f, 0.06921770f, 0.00016553f, 0.05378557f, 
    0.58548075f, 0.14992134f, -0.38152140f, -0.38148165f, 0.23082624f, 0.13994996f, 0.07239569f, -0.06588218f, 
    -0.07700892f, 0.06694061f, 0.03324360f, 0.09112628f, -0.06612667f, -0.05168426f, -0.00834627f, 0.06175303f, 
    -0.03564516f, -0.11564571f, 0.00577584f, -0.11827683f, -0.02260741f, 0.22710626f, -0.16300872f, -0.33458245f, 
    0.09078273f, -0.01367970f, 0.01377345f, -0.01217843f, -0.02334130f, -0.04495639f, 0.07411355f, -0.01614037f, 
    -0.05740561f, 0.01048467f, 0.02116501f, -0.16624175f, -0.01473640f, 0.04735343f, 0.03910159f, -0.04897575f, 
    -0.04358424f, -0.17380869f, 0.00372691f, 0.01340556f, 0.10900201f, 0.01166803f, 0.10855018f, 0.05174422f, 
    -0.01619560f, 0.03462850f, 0.00367964f, -0.00193500f, -0.06631193f, -0.00006635f, 0.03669532f, -0.02390310f, 
    0.04526216f, -0.05197692f, 0.06394305f, -0.00801531f, -0.60883111f, -0.55036294f, -0.41636458f, -0.40650508f, 
    -0.10713153f, -0.26505986f, -0.05279478f, -0.19376114f, -0.10657080f, -0.25584033f, 0.01159225f, -0.02829637f, 
    -0.06301575f, 0.00066501f, 0.00357628f, -0.01999387f, -0.03132992f, 0.02800148f, 0.04072587f, -0.10753886f, 
    -0.63521254f, -0.24895377f, -0.42789334f, -0.36454865f, 0.01412500f, 0.06498972f, 0.11102194f, -0.06696484f, 
    0.03051188f, -0.15519489f, 0.00093834f, 0.01011242f, -0.04707817f, 0.02527603f, 0.00162943f, -0.03571027f, 
    0.03343014f, 0.10369036f, -0.03222642f, -0.04829568f, -0.37462419f, -0.08151963f, -0.07849044f, -0.18942834f, 
    -0.22757499f, 0.02447925f, 0.06093513f, 0.04877400f, 0.03115020f, -0.11477189f, -0.00486580f, -0.01791571f, 
    0.00437121f, -0.00669309f, 0.02766331f, 0.09372140f, 0.04355283f, 0.07461455f, 0.11472421f, 0.01600833f, 
    -0.69654495f, -0.59919393f, -0.46571600f, -0.22451861f, 0.08623178f, -0.15467229f, -0.09111062f, -0.25491449f, 
    -0.08405698f, -0.44766426f, -0.00618816f, -0.04490948f, -0.00836215f, -0.06048263f, 0.00878898f, 0.00013552f, 
    -0.01962915f, 0.10069396f, 0.04966900f, -0.01804969f, -0.10173117f, 0.29494807f, -0.02668621f, 0.10164268f, 
    -0.00758324f, 0.08092160f, 0.02690943f, 0.01111087f, 0.01067860f, -0.07140934f, -0.01921299f, 0.09201261f, 
    -0.06766747f, 0.03310125f, 0.03572451f, 0.08491994f, -0.05373937f, 0.02176849f, -0.14254965f, -0.10080779f, 
    -0.21425234f, -0.00583701f, 0.28528678f, -0.11969616f, -0.02096616f, -0.01417422f, -0.01418389f, 0.07100659f, 
    -0.04624030f, 0.12857388f, 0.11958652f, 0.02726686f, -0.05839242f, 0.08715114f, -0.00739276f, -0.02321128f, 
    0.01534067f, -0.03127069f, -0.07536636f, 0.09270996f, -0.00682853f, 0.08374547f, -0.06983031f, -0.00026399f, 
    -0.03435279f, -0.00878073f, 0.02115921f, -0.02010353f, -0.03846701f, 0.01504400f, -0.04741595f, -0.02875669f, 
    -0.04360715f, -0.06614659f, -0.03567999f, -0.03158118f, -0.08859263f, -0.13808949f, 0.03136715f, 0.03097332f, 
    -0.20150526f, -0.44797084f, -0.58679700f, -0.05553487f, 0.06424213f, -0.01309695f, 0.11493128f, -0.02696449f, 
    -0.03072268f, -0.21066035f, 0.02943377f, -0.03397422f, -0.03918986f, -0.03162343f, 0.02303562f, -0.00680437f, 
    -0.00937675f, 0.08550207f, 0.08603969f, 0.00610737f, 0.01223773f, 0.17018171f, 0.02279715f, 0.08527493f, 
    -0.16676842f, 0.02440804f, 0.03357739f, -0.12223977f, -0.04953548f, 0.08459993f, -0.05054409f, -0.02631357f, 
    0.05468267f, -0.05653505f, -0.14138600f, -0.08124118f, -0.00990836f, -0.08875864f, 0.01167374f, 0.06350476f, 
    0.03977615f, 0.28135431f, -0.06648978f, -0.04568535f, 0.03040131f, -0.10382685f, -0.01445761f, -0.10071223f, 
    0.06425735f, 0.10312357f, 0.08851065f, -0.11749274f, 0.00643162f, -0.02653070f, 0.05595392f, 0.01874158f, 
    -0.06893649f, -0.04240791f, 0.00693053f, -0.08753821f, 0.16403598f, 0.08136804f, -0.06922496f, 0.00517987f, 
    0.06026584f, 0.02283105f, -0.08192937f, 0.04921082f, -0.01107666f, -0.10701724f, 0.09045660f, -0.00756132f, 
    -0.17361549f, -0.00159449f, 0.01631016f, -0.01871414f, -0.05826999f, 0.05036157f, -0.21518596f, -0.15996267f, 
    -0.80022842f, -0.70676863f, -0.01797508f, 0.18263628f, 0.07114274f, 0.02187618f, 0.04449177f, -0.22494122f, 
    -0.16653788f, -0.18403882f, -0.02859856f, -0.00288102f, -0.05427841f, 0.00564528f, 0.02236908f, 0.03658769f, 
    -0.01563142f, -0.01064512f, 0.10796707f, -0.03818806f, -0.24580172f, 0.00811935f, -0.52490228f, -0.18468355f, 
    0.28265125f, -0.06929541f, 0.14171886f, 0.05187970f, -0.01705478f, 0.09279758f, 0.01594938f, 0.05512247f, 
    0.06832084f, 0.01505582f, 0.06606240f, 0.03503766f, -0.02605865f, -0.02998471f, 0.14859292f, -0.00467694f, 
    0.12017845f, -0.13152112f, -0.16888455f, -0.11108612f, 0.08558899f, 0.01383255f, 0.09607925f, 0.09007041f, 
    0.03415365f, 0.08660638f, 0.03256664f, -0.01312631f, -0.02457059f, 0.05068145f, 0.04806735f, -0.00716383f, 
    0.03862075f, -0.00235996f, 0.02858064f, 0.13233452f, -0.18353543f, -0.37968561f, -0.58841723f, -0.07966759f, 
    0.18473545f, -0.14663066f, -0.04226727f, -0.03891883f, -0.08856995f, -0.08468667f, 0.00710295f, 0.01157551f, 
    -0.01310852f, -0.03277078f, -0.12526035f, -0.02526653f, -0.05331440f, 0.00308178f, 0.13807680f, -0.00938406f, 
    -0.44434610f, -0.19431762f, 0.14511406f, -0.05424249f, 0.32800889f, -0.25240567f, -0.07365473f, -0.01054415f, 
    -0.08472524f, 0.17450690f, 0.02134531f, 0.02551752f, 0.09945291f, -0.06615595f, 0.16022000f, -0.13399407f, 
    -0.02036926f, -0.08129222f, 0.03672056f, -0.19995658f, 0.15694048f, -0.17641081f, -0.21728598f, -0.10742226f, 
    0.10429729f, -0.06796036f, 0.00534218f, 0.16139606f, 0.09629387f, -0.00975365f, -0.03341313f, -0.02533573f, 
    -0.11898696f, -0.05723841f, 0.07437961f, -0.07218318f, -0.02574925f, 0.05098454f, -0.00537662f, 0.01473773f, 
    -0.10322990f, -0.00258326f, 0.23889059f, -0.01979021f, -0.01190991f, -0.00373150f, 0.05632976f, -0.08155525f, 
    0.01398052f, 0.13607602f, 0.02808414f, 0.03736853f, -0.00573358f, 0.08567169f, -0.06151146f, 0.04767113f, 
    0.04351153f, -0.02614717f, 0.00122362f, 0.07044411f, 0.10501563f, -0.04481042f, -0.08098814f, -0.07555977f, 
    0.11353379f, -0.08170501f, 0.08314636f, 0.07009374f, 0.12344977f, 0.04805955f, -0.01526215f, -0.06355068f, 
    -0.09726869f, -0.01054832f, 0.02855206f, -0.08762696f, -0.08867156f, -0.17601633f, 0.01147291f, 0.00298180f, 
    0.22134009f, -0.34357348f, -0.44484639f, -0.30116820f, 0.09183221f, -0.05321044f, 0.06884497f, 0.21027596f, 
    -0.02186338f, -0.08115297f, -0.00014673f, 0.01019614f, -0.02803560f, -0.02688201f, 0.05630711f, -0.06654062f, 
    -0.03912187f, 0.01934720f, 0.08104791f, 0.11782381f, -0.13206606f, 0.39192009f, 0.14822519f, 0.00289354f, 
    0.22129464f, 0.05139134f, 0.00169597f, -0.03787829f, 0.03283313f, -0.04180125f, 0.00473965f, 0.05643578f, 
    0.09344832f, 0.03691383f, 0.02754781f, 0.05421162f, -0.04418018f, -0.00233541f, -0.07510635f, 0.02253921f, 
    -0.07139847f, 0.14349055f, 0.09118981f, -0.04427904f, 0.26407760f, -0.00843839f, -0.04575532f, -0.05150279f, 
    0.05235759f, 0.00085042f, 0.06487781f, 0.15078759f, 0.10814256f, 0.08813669f, -0.01729716f, 0.03664629f, 
    0.01211876f, 0.01669401f, 0.01603010f, 0.00304311f, -0.26419657f, 0.01356387f, 0.37882975f, -0.12004103f, 
    0.32104740f, -0.09136111f, -0.13353920f, -0.02895127f, -0.12949434f, 0.26055524f, -0.09944686f, 0.10218698f, 
    0.07477761f, 0.04968537f, -0.04106951f, 0.00880443f, 0.06582678f, 0.00055555f, 0.03710977f, 0.05648246f, 
    0.04044298f, -0.07188614f, -0.31365779f, -0.19813156f, 0.27758139f, -0.05217505f, 0.00777090f, -0.05943741f, 
    0.03374203f, 0.09456754f, -0.04361941f, 0.01502142f, 0.00631091f, 0.02524771f, -0.07976979f, 0.00454836f, 
    0.03668588f, 0.10558415f, 0.15622997f, -0.05450471f, 0.00387906f, 0.28203335f, 0.05446231f, -0.06656136f, 
    0.03121887f, -0.09154861f, -0.01835423f, -0.13862166f, 0.01078952f, 0.03279822f, -0.00718397f, -0.00632404f, 
    -0.03424666f, -0.02325970f, -0.00404684f, 0.00955817f, -0.08664652f, -0.00080996f, -0.01308122f, -0.04895525f, 
    -0.05809353f, 0.00784199f, 0.17090042f, 0.26241490f, -0.15357086f, -0.01416109f, 0.00683828f, -0.08150776f, 
    -0.08992337f, 0.08921827f, -0.08340638f, 0.02102057f, 0.04807884f, 0.07586010f, -0.17845637f, 0.03317518f, 
    0.09076298f, -0.03486256f, 0.14385028f, 0.02512445f, 0.00022572f, -0.06507978f, 0.08878232f, -0.01572975f, 
    -0.09200690f, 0.06815801f, -0.03301587f, 0.00914987f, 0.02028258f, 0.03130645f, -0.04125119f, -0.04291013f, 
    -0.01645294f, -0.04815857f, -0.05945662f, -0.05323657f, 0.09318877f, 0.02778817f, -0.11298525f, 0.01871800f, 
    0.02184015f, -0.25840861f, -0.21153429f, -0.05398362f, 0.17058195f, -0.06990059f, 0.11939714f, 0.04533776f, 
    0.12227125f, -0.08191901f, 0.00124282f, 0.02695159f, -0.08879623f, 0.01317586f, 0.01463129f, -0.01141252f, 
    0.01471858f, 0.02267005f, 0.16253167f, -0.05638592f, 0.03578812f, -0.04331255f, 0.25684470f, 0.21462807f, 
    0.37736955f, -0.04786557f, 0.03783749f, 0.01220809f, 0.07312029f, 0.14267115f, 0.04798523f, 0.08436459f, 
    0.19415641f, 0.00992116f, -0.10217775f, 0.04885827f, 0.04318530f, 0.09617553f, 0.02054084f, -0.03180465f, 
    0.06057891f, -0.03505777f, 0.07323693f, 0.00715783f, -0.22663082f, 0.16551086f, 0.10154952f, 0.06133790f, 
    -0.02896304f, -0.11473281f, -0.00382075f, 0.04501560f, -0.07758722f, 0.04173223f, 0.03278823f, 0.09328476f, 
    0.07246607f, 0.08614340f, -0.18307592f, 0.01148010f, -0.46994326f, 0.30473745f, -0.40934387f, -0.29858166f, 
    0.25344399f, -0.23652063f, 0.09309075f, 0.09868753f, 0.15358163f, 0.01291000f, 0.13265942f, -0.01340943f, 
    0.02946639f, 0.05511157f, -0.03716539f, 0.09012632f, 0.10252697f, 0.09893695f, 0.07099079f, 0.06395761f, 
    -0.02124657f, -0.01443196f, 0.09757560f, 0.07057831f, -0.07257770f, -0.00713102f, -0.00524383f, -0.02102980f, 
    0.00958104f, 0.09811050f, 0.06326662f, -0.02560708f, 0.10056433f, 0.02776165f, 0.01558807f, 0.05756196f, 
    -0.01608709f, -0.05850926f, -0.03879643f, -0.01661154f, -0.08442549f, 0.16737494f, 0.10655694f, -0.15761054f, 
    0.11581662f, -0.00078976f, -0.04125516f, 0.03074051f, 0.04539373f, -0.09296129f, -0.03705020f, 0.00407005f, 
    0.00747009f, 0.06711877f, 0.05874678f, 0.04157746f, 0.00911030f, -0.02389183f, -0.15932119f, -0.00199146f, 
    -0.33148518f, -0.34260941f, -0.14909236f, 0.05518045f, 0.15674527f, -0.02498993f, 0.12198226f, 0.02434549f, 
    0.03707584f, -0.14775816f, 0.02687977f, 0.00446930f, 0.02164160f, -0.02964621f, 0.05932833f, 0.01081740f, 
    0.01989588f, 0.18794525f, 0.14395432f, 0.02629180f, -0.24645700f, 0.09443112f, -0.07661628f, -0.19822672f, 
    -0.00984041f, -0.02377945f, 0.00571575f, 0.01640994f, -0.03590941f, 0.05567389f, 0.04312063f, -0.07013290f, 
    0.05137461f, 0.05735817f, -0.04363532f, 0.04925567f, 0.16654424f, -0.08683958f, 0.02701651f, 0.14337666f, 
    0.13965933f, -0.01560302f, -0.01972841f, 0.02991719f, -0.06611622f, 0.03708830f, 0.06777804f, -0.14710343f, 
    -0.03052725f, 0.13946788f, -0.10185820f, 0.05962150f, 0.04672499f, -0.00588600f, -0.17294501f, 0.03418037f, 
    0.15263590f, -0.01345248f, 0.04984686f, 0.02436630f, -0.06654861f, -0.01507585f, 0.15154502f, 0.02565950f, 
    -0.01887127f, 0.02331829f, -0.01135641f, -0.02230756f, -0.06296749f, 0.12773907f, -0.00640852f, 0.03580956f, 
    0.05602930f, 0.03454234f, -0.04713926f, 0.02060728f, -0.01937157f, -0.03069516f, -0.06062415f, 0.03419824f, 
    -0.59851199f, -0.40985125f, -0.61692190f, -0.16604854f, 0.27047816f, -0.09781408f, -0.01989368f, -0.06625436f, 
    -0.20606560f, -0.32220212f, -0.00805128f, -0.05245685f, 0.01085193f, -0.01928871f, 0.05574774f, 0.05888787f, 
    0.00503772f, 0.02580924f, 0.11529845f, 0.02260544f, -0.44056547f, -0.32656866f, -0.49375707f, -0.25928873f, 
    0.02772136f, -0.14543533f, 0.04684008f, -0.13713817f, 0.03716063f, -0.22551726f, 0.01689766f, -0.03266734f, 
    -0.02774509f, 0.00720600f, 0.01707525f, -0.01523007f, -0.01259391f, 0.09569426f, 0.07537078f, 0.02090252f, 
    -0.36455017f, -0.63576394f, -0.65236050f, -0.12766913f, 0.16892825f, -0.08837672f, 0.01340587f, -0.05189318f, 
    -0.09070368f, -0.17403594f, 0.04411121f, -0.03778609f, -0.06813692f, 0.00310951f, 0.00098946f, 0.00421226f, 
    -0.01026044f, 0.08204186f, 0.14307322f, 0.06751903f, -0.45637900f, -0.03420754f, 0.08215428f, 0.41621393f, 
    -0.09409817f, -0.02084458f, 0.13738722f, -0.02823241f, 0.02848408f, -0.28994548f, 0.04057738f, 0.08705499f, 
    -0.03768209f, 0.02373587f, 0.00430939f, 0.04023685f, -0.05299592f, 0.09969648f, -0.14749195f, -0.00999440f, 
    -0.25401193f, 0.29642615f, 0.12620139f, -0.01373379f, 0.03879585f, -0.14107844f, -0.00145514f, -0.07938870f, 
    0.02961956f, 0.14318532f, -0.06095388f, 0.02755659f, -0.01039601f, 0.02980741f, 0.02119653f, 0.00445416f, 
    -0.01149352f, -0.04373352f, 0.04643647f, -0.05802811f, -0.05654442f, 0.02544340f, 0.04522468f, 0.04800301f, 
    0.00582886f, -0.04456244f, -0.02655976f, -0.09436445f, 0.08033210f, -0.07463496f, 0.04237719f, -0.12774280f, 
    -0.04898263f, 0.01138442f, 0.03788371f, 0.00396927f, -0.05448968f, 0.06246767f, -0.08943506f, -0.13971677f, 
    -0.42984939f, -0.11774822f, 0.29563597f, -0.07179701f, -0.13390188f, -0.04174281f, -0.18318331f, -0.02440245f, 
    -0.03166354f, -0.08909684f, -0.00338177f, 0.03584550f, -0.03380557f, 0.10240790f, -0.02047244f, -0.04621947f, 
    -0.01475547f, 0.07526790f, -0.12259684f, 0.03801005f, -0.61060327f, -0.55617619f, -0.40494052f, 0.03784274f, 
    -0.19223048f, -0.18497619f, -0.09834840f, -0.12181988f, -0.16790210f, -0.20389618f, -0.02627035f, -0.04097516f, 
    0.01172412f, -0.00990647f, 0.02650418f, -0.01839141f, -0.01127844f, 0.04646748f, 0.09744820f, -0.16436030f, 
    0.30067042f, 0.30899015f, -0.31318444f, -0.17626761f, 0.06540582f, -0.01143733f, 0.11613591f, -0.01913863f, 
    0.06637465f, -0.08205859f, 0.00638835f, -0.04437654f, 0.02058239f, -0.02304893f, -0.00459202f, -0.00683921f, 
    -0.04439943f, 0.00809562f, -0.03926796f, -0.05976164f, -0.59167916f, 0.39910427f, 0.32997438f, 0.02864709f, 
    0.24618931f, -0.15070508f, -0.00051330f, -0.00630513f, 0.02978919f, 0.15453768f, -0.07007684f, 0.06698343f, 
    0.06395158f, 0.05544416f, 0.04216795f, -0.01228081f, 0.00430389f, 0.01681731f, 0.03275083f, 0.00961221f, 
    -0.39726290f, -0.10653111f, 0.30812415f, 0.07554872f, -0.00926758f, -0.20252448f, -0.10293259f, -0.01750440f, 
    -0.14107001f, 0.13496098f, 0.02836856f, -0.00380624f, 0.06554323f, -0.04523871f, 0.05264586f, -0.02834904f, 
    -0.06135402f, -0.00977634f, 0.03070806f, -0.05822114f, -0.04015213f, -0.15062337f, 0.04349362f, 0.03594238f, 
    -0.14307387f, 0.02090373f, 0.06973411f, -0.00024414f, -0.06708013f, 0.02113037f, 0.03414910f, -0.02568902f, 
    0.03747224f, -0.02750977f, -0.00552966f, 0.01821607f, 0.06437897f, 0.04615065f, -0.02295896f, 0.05320396f, 
    -0.28790122f, -0.39797622f, -0.66825324f, -0.17107333f, -0.00903781f, -0.12541392f, 0.06012099f, -0.17041951f, 
    -0.00502703f, -0.21536413f, 0.01090275f, 0.00422488f, -0.02878843f, 0.03176543f, 0.03937491f, -0.10057799f, 
    -0.07716282f, 0.18736941f, 0.01832222f, 0.01277114f, -0.02840128f, 0.00361912f, 0.00375738f, -0.04210126f, 
    -0.02187959f, 0.01249076f, -0.02001214f, 0.00532500f, 0.04906780f, 0.03050769f, 0.05594346f, 0.02772734f, 
    -0.00717684f, 0.12588476f, -0.04665605f, 0.02603854f, -0.00371378f, 0.02202256f, -0.00680402f, 0.10045639f, 
    -0.07310116f, 0.13255918f, 0.17232674f, 0.03579355f, 0.04715849f, 0.00496410f, -0.00632375f, 0.00969313f, 
    -0.09482979f, 0.07132531f, 0.00169976f, 0.00566364f, 0.06529080f, 0.04671054f, 0.09480274f, 0.02103055f, 
    0.01264353f, -0.03806577f, -0.03596535f, -0.03320774f, -0.38638327f, -0.80972075f, -0.42868987f, -0.07592053f, 
    -0.18003576f, -0.00326969f, -0.00217363f, 0.00330154f, -0.05576277f, -0.25255820f, -0.00105225f, -0.01912717f, 
    -0.04026090f, 0.05362252f, 0.08536032f, -0.05002462f, -0.02448532f, 0.20556860f, 0.12995416f, 0.12981194f, 
    -0.41648182f, -0.45141119f, -0.47067422f, -0.15459861f, 0.16023155f, -0.25204751f, -0.09872910f, -0.11661509f, 
    -0.10207753f, -0.01961870f, 0.03202439f, 0.01763837f, 0.02310387f, -0.02014053f, -0.09680094f, 0.00648281f, 
    -0.00488359f, 0.00817937f, 0.12274241f, -0.05069494f, 0.13771543f, -0.05796686f, 0.09294268f, 0.02623899f, 
    -0.01861301f, 0.04601112f, -0.06997201f, 0.09062222f, 0.04104450f, -0.01802076f, 0.05718616f, 0.01536329f, 
    0.00458554f, -0.13896979f, 0.00510552f, -0.05806192f, -0.06418628f, -0.05711547f, -0.08843300f, 0.01897510f, 
    0.04579500f, 0.12480359f, -0.12446821f, 0.10784487f, 0.16808917f, -0.08125192f, -0.02710493f, 0.01500586f, 
    0.16012129f, -0.07264108f, -0.00023335f, -0.03187750f, -0.05712218f, 0.04968289f, -0.01309133f, -0.01169257f, 
    0.09888370f, -0.20746037f, -0.04796451f, -0.06601205f, -0.02267193f, 0.03739400f, -0.09619042f, -0.08433089f, 
    -0.04945843f, 0.03308188f, -0.00863331f, -0.01760306f, -0.07869651f, -0.00964544f, -0.07715058f, -0.04021875f, 
    -0.07397552f, -0.04251593f, -0.03277566f, -0.03963293f, -0.06289784f, -0.09898272f, -0.01619517f, 0.01527013f, 
    -0.62526488f, 0.34864950f, 0.41545612f, 0.01819587f, 0.04365159f, -0.12872097f, -0.04041500f, -0.04864553f, 
    -0.00939880f, 0.21860737f, -0.08633120f, 0.05125276f, 0.06710606f, 0.04674119f, 0.06392729f, -0.03401310f, 
    -0.01924104f, -0.03920694f, 0.00216870f, -0.02075692f, -0.16507529f, -0.11761510f, -0.01714879f, 0.10571880f, 
    0.08175941f, -0.09541275f, 0.16337241f, -0.08765645f, 0.01146601f, 0.06028950f, 0.13256040f, 0.01572534f, 
    0.00819631f, -0.01461219f, 0.01848590f, 0.04298513f, -0.03769755f, -0.09289432f, 0.06187320f, -0.09073766f, 
    -0.13496321f, 0.29596439f, -0.04588963f, 0.12826933f, 0.14262246f, -0.00427080f, 0.06317746f, -0.01409788f, 
    0.06464655f, 0.04058100f, 0.01305502f, 0.02055733f, 0.06407142f, 0.05391251f, -0.01642168f, 0.01442440f, 
    -0.00838077f, 0.13106073f, -0.05882723f, 0.05753854f, -0.47067720f, 0.17618597f, 0.37906465f, -0.11878436f, 
    -0.08105779f, -0.08880150f, -0.08009188f, -0.00577496f, -0.08626299f, 0.10396054f, -0.05694076f, 0.10183577f, 
    0.01392076f, 0.04458039f, 0.05287055f, 0.01145111f, -0.03456177f, -0.02888255f, -0.06783014f, -0.03864799f, 
    0.35555547f, -0.05534524f, -0.28893045f, -0.14430554f, -0.17311399f, 0.11848717f, 0.00390768f, 0.13293748f, 
    0.06433187f, -0.19533925f, 0.03655253f, -0.01313396f, -0.02629201f, -0.08802892f, 0.06354138f, 0.02193004f, 
    -0.04112138f, -0.03050232f, -0.07248761f, 0.09582661f, -0.11182228f, -0.06078881f, 0.01939170f, 0.01799190f, 
    -0.09814522f, 0.01872854f, 0.06492455f, 0.00002839f, -0.00631677f, -0.06203062f, 0.04914781f, -0.03796111f, 
    0.00193803f, 0.01957085f, 0.05071148f, 0.15152894f, 0.06912696f, 0.01543269f, -0.07897986f, 0.08621418f, 
    0.00912900f, 0.07599353f, -0.04706326f, 0.00345924f, -0.13158508f, 0.01796293f, 0.03584732f, 0.08425973f, 
    0.01541299f, -0.03061042f, -0.03611687f, 0.05379931f, 0.04427824f, -0.04484899f, -0.06627242f, 0.03435784f, 
    -0.05561305f, 0.03806673f, -0.07159115f, -0.02815886f, 0.13706577f, -0.40626985f, 0.04037803f, 0.22423458f, 
    0.02398226f, -0.03269263f, 0.11925048f, -0.04305475f, 0.08717477f, 0.07315826f, 0.03291892f, -0.01260679f, 
    0.00627041f, -0.02977759f, -0.00656582f, 0.02640688f, -0.00604807f, -0.03468472f, -0.02256371f, -0.04379487f, 
    -0.14597926f, -0.39740229f, -0.17797205f, -0.00746935f, -0.04562798f, -0.10069597f, 0.09189848f, 0.16656408f, 
    -0.01626154f, 0.04326121f, 0.03686628f, -0.07098198f, 0.02497810f, 0.01202259f, -0.02483875f, 0.01896662f, 
    0.00465276f, -0.06703938f, -0.09425036f, 0.03821123f, -0.19286802f, 0.19464479f, 0.10247816f, 0.16018516f, 
    0.09400179f, -0.02230724f, 0.05032537f, 0.06829648f, -0.03685937f, -0.00963018f, 0.04865036f, -0.00080452f, 
    0.05282759f, 0.02844988f, 0.02014426f, 0.10114077f, 0.07283976f, 0.05349740f, -0.05785839f, -0.06227947f, 
    -0.09953039f, -0.41036934f, 0.26037213f, 0.22103956f, 0.01369565f, -0.06430711f, 0.15952556f, -0.04713150f, 
    0.12042765f, 0.14659822f, 0.02015028f, -0.00404752f, -0.01253280f, -0.00562219f, 0.03013140f, -0.00876638f, 
    0.03728080f, -0.05058916f, 0.08973462f, -0.08483597f, -0.29114649f, -0.14180276f, 0.33336344f, 0.01378025f, 
    0.17516601f, -0.10090262f, 0.03663263f, 0.06653465f, -0.01154426f, -0.01986483f, -0.02535889f, 0.00952407f, 
    0.01454949f, -0.02704201f, -0.04946150f, 0.02760953f, -0.06707256f, 0.05232539f, -0.11596733f, 0.01260186f, 
    0.21963808f, 0.12765522f, -0.07683576f, -0.07865980f, -0.09824682f, -0.04158212f, 0.03106953f, -0.00256940f, 
    -0.02106375f, -0.07449426f, -0.07315339f, -0.09336963f, 0.11235066f, 0.03313842f, 0.00317031f, -0.02033417f, 
    0.03225746f, 0.01529851f, -0.00888949f, 0.01123449f, 0.00073074f, 0.06045340f, 0.07606910f, -0.01084440f, 
    -0.04683567f, 0.00440800f, 0.03802259f, -0.01692334f, -0.02655373f, -0.03280099f, -0.00001818f, 0.02469868f, 
    0.00933969f, -0.03678627f, -0.00859584f, -0.06360548f, -0.04919073f, 0.05944638f, 0.02436612f, -0.00719447f, 
    -0.48000300f, -0.45690006f, 0.12697108f, 0.05764497f, 0.22498004f, -0.08465877f, -0.07993226f, 0.03368745f, 
    -0.05529549f, 0.00031196f, 0.00614245f, -0.03506877f, 0.00365245f, -0.04827132f, -0.00737847f, 0.01888675f, 
    0.03486297f, -0.09553210f, -0.00962063f, -0.06077155f, 0.05970056f, 0.03609576f, 0.13932250f, -0.10114633f, 
    -0.04269017f, -0.00740768f, 0.08308569f, -0.00849889f, 0.02546004f, -0.04146333f, 0.05086459f, 0.03690387f, 
    0.00148417f, -0.02251729f, -0.03035702f, -0.04231913f, -0.08915686f, -0.05665936f, 0.06544894f, -0.00726108f, 
    -0.00145730f, -0.08361252f, -0.11270563f, 0.03201860f, -0.00091584f, 0.03891031f, -0.01048882f, 0.07013604f, 
    0.04643763f, 0.01421589f, -0.19294922f, 0.01999735f, 0.07578967f, 0.10216032f, 0.03701926f, 0.03373935f, 
    0.01786016f, 0.02061091f, -0.00456859f, -0.00152359f, -0.08314900f, 0.00383814f, 0.15530367f, -0.04918193f, 
    0.07841870f, -0.06301928f, -0.00131037f, -0.03685673f, 0.05676603f, 0.05973665f, -0.01082764f, -0.02584892f, 
    0.00212669f, 0.07715106f, 0.00019506f, -0.00303203f, -0.01974906f, -0.08968943f, 0.02613613f, 0.01713615f, 
    0.32420313f, -0.70345199f, 0.29384729f, 0.47263116f, 0.21230279f, -0.03985832f, 0.10926988f, -0.07516016f, 
    0.08399876f, -0.10025299f, 0.09389167f, 0.03083157f, 0.00470535f, -0.01771823f, 0.00371604f, 0.03784837f, 
    0.01333665f, 0.02431848f, 0.03244016f, -0.01612042f, 0.14147995f, 0.16510031f, -0.36947185f, 0.23961516f, 
    -0.26760921f, -0.04234548f, 0.06090368f, -0.04381048f, -0.13517791f, -0.03391110f, -0.03098875f, 0.03690762f, 
    -0.01539729f, -0.05265216f, 0.00217074f, -0.06865706f, 0.01304598f, 0.06103813f, -0.00099096f, 0.01559953f, 
    0.05744021f, -0.01009814f, 0.09105472f, -0.01733810f, 0.00973159f, -0.00197833f, -0.04153936f, -0.02990366f, 
    -0.10774897f, -0.01662740f, 0.04865703f, 0.00906245f, 0.00627073f, -0.03003690f, -0.04924289f, -0.10930949f, 
    -0.11639530f, -0.04928218f, 0.01183720f, -0.03033811f, 0.05533803f, -0.26596019f, -0.31752920f, -0.20299202f, 
    -0.14654684f, 0.03597837f, 0.02999108f, -0.05527969f, 0.03049250f, 0.00384014f, 0.03066778f, 0.00799262f, 
    -0.06043121f, -0.01057822f, 0.00167827f, -0.02505038f, -0.01092043f, -0.02633096f, 0.01603467f, 0.00293883f, 
    0.43802530f, 0.45233539f, -0.00811994f, 0.12498751f, -0.41555771f, 0.17146195f, 0.02141624f, 0.21273959f, 
    -0.01138441f, 0.00816196f, -0.18565114f, 0.06767972f, -0.12529778f, -0.01307425f, -0.00958842f, -0.15289268f, 
    -0.00110588f, 0.01939438f, -0.11561888f, -0.15179326f, -0.06073224f, -0.01961661f, 0.04279055f, 0.05806012f, 
    -0.03745149f, 0.02540983f, -0.02467585f, 0.04571551f, 0.03080584f, 0.00349492f, 0.05149499f, 0.03760016f, 
    0.01215929f, 0.04469142f, -0.04317385f, 0.00246296f, -0.03611446f, -0.05988297f, 0.05380385f, 0.03710581f, 
    0.08394707f, 0.04384178f, 0.02555379f, -0.13347009f, 0.06655919f, -0.07464177f, 0.08262856f, -0.14437537f, 
    0.01042617f, -0.07250030f, 0.02702829f, 0.05026326f, -0.02019380f, -0.01864464f, 0.06326626f, -0.00430616f, 
    0.04268476f, 0.00777151f, 0.04805290f, 0.01484692f, 0.03258606f, 0.06041559f, -0.04197720f, 0.04362493f, 
    -0.04162417f, 0.00106318f, 0.03017758f, -0.02524523f, -0.00223818f, -0.06779288f, 0.01102683f, 0.00013407f, 
    0.02870984f, 0.01145602f, -0.02307538f, -0.11018898f, -0.12480623f, 0.04659997f, -0.02393525f, 0.01853091f, 
    -0.06284195f, 0.09174303f, 0.01086996f, -0.00549992f, -0.15740678f, -0.03427123f, 0.05725288f, -0.04534095f, 
    -0.06352334f, -0.02665626f, 0.04434405f, 0.05163587f, 0.02429009f, -0.00539894f, -0.02039172f, -0.02385119f, 
    -0.04392590f, -0.14201990f, -0.01314162f, 0.02170226f, -0.12250621f, -0.10927216f, 0.01420152f, 0.05293214f, 
    0.01148128f, -0.00844499f, -0.01884099f, 0.04639344f, -0.00206578f, -0.02260629f, -0.15544707f, -0.03966308f, 
    0.06735915f, 0.02884462f, -0.01799911f, -0.00357761f, 0.00856789f, 0.04849801f, 0.00617490f, 0.03423594f, 
    -0.00545190f, -0.02019367f, -0.21376735f, 0.06909695f, -0.10394806f, 0.00724645f, 0.00311583f, 0.08184509f, 
    0.02602326f, 0.02059301f, -0.03184040f, 0.04859911f, -0.08693361f, 0.00606130f, 0.01131205f, 0.00937886f, 
    -0.05732660f, -0.03850276f, 0.05903205f, 0.06622253f, 0.47370359f, -0.36412767f, -0.43618006f, -0.16768438f, 
    -0.16005802f, 0.09392172f, 0.02279766f, -0.14206137f, 0.12716950f, 0.02308295f, 0.03507514f, 0.01050910f, 
    -0.04040128f, -0.04577909f, 0.00519532f, 0.00854421f, 0.03003041f, -0.03943852f, 0.07421789f, 0.07894947f, 
    -0.02301434f, -0.29516390f, -0.23221309f, 0.09729920f, -0.10390885f, 0.03041680f, -0.06618476f, -0.10955708f, 
    0.01183415f, -0.02084575f, 0.01713466f, -0.02139529f, -0.06764722f, -0.01452485f, -0.03736595f, 0.06786402f, 
    0.08239960f, -0.08993451f, 0.08569984f, 0.08647723f, -0.09171088f, -0.13828716f, -0.06443401f, -0.02788409f, 
    0.00203466f, 0.01907268f, -0.04330093f, 0.02766885f, 0.04629883f, 0.01875238f, -0.11488030f, 0.07343499f, 
    0.00938501f, 0.02225585f, 0.01937440f, 0.02638775f, -0.00204352f, 0.03020271f, -0.01733053f, 0.01293498f, 
    0.21716098f, -0.02372824f, -0.09477890f, -0.09980126f, -0.20353980f, 0.12069155f, 0.04295371f, -0.02787590f, 
    0.03137852f, 0.03223080f, -0.07833718f, 0.06470783f, -0.07166632f, -0.25390673f, -0.16075724f, -0.03448740f, 
    -0.04616655f, -0.05689683f, 0.00257032f, 0.03229983f, 0.01231295f, 0.05907344f, 0.08881182f, -0.02124189f, 
    -0.03613718f, -0.06765940f, 0.01816482f, 0.00507277f, 0.02034218f, -0.03184744f, 0.03353376f, -0.00995842f, 
    -0.06939729f, -0.04373953f, -0.06896492f, 0.00571821f, -0.04800621f, -0.01428615f, 0.00699086f, -0.01918480f, 
    -0.15199861f, -0.08758150f, -0.01891303f, 0.13220289f, -0.10305237f, 0.07589849f, 0.04584602f, 0.08541599f, 
    0.02947720f, 0.00608857f, 0.02428205f, 0.01419882f, 0.00079743f, 0.03423046f, -0.04089895f, 0.03126758f, 
    0.02445428f, -0.07196471f, -0.02409096f, 0.00964103f, -0.00300335f, -0.33619595f, -0.22429416f, -0.16758935f, 
    -0.25532585f, 0.05003254f, -0.00676609f, 0.05889821f, 0.11273000f, -0.00283147f, 0.05557973f, -0.00238601f, 
    0.07947057f, -0.04932749f, -0.02168572f, -0.05402527f, -0.05053237f, -0.03503919f, -0.00532300f, 0.02135225f, 
    -0.12592995f, -0.00194290f, 0.14982593f, -0.14574628f, 0.17910649f, -0.05467528f, -0.01619684f, 0.00224664f, 
    0.00849829f, 0.03389279f, 0.05653194f, -0.05794819f, 0.04376679f, -0.01585049f, -0.05833043f, -0.15843077f, 
    -0.03969345f, -0.03914797f, 0.08356104f, -0.10905351f, -0.57251859f, -0.52748746f, -0.01126119f, 0.12572460f, 
    0.25316432f, 0.11649005f, -0.10281101f, 0.27129707f, -0.24237916f, -0.03904185f, -0.07518510f, 0.09527308f, 
    -0.05034567f, 0.02099307f, 0.02589910f, 0.01552858f, 0.01938436f, 0.00012429f, -0.03449053f, -0.01758751f, 
    0.07250562f, 0.05178102f, 0.01689149f, -0.04582120f, -0.06413744f, -0.00241264f, 0.04654311f, 0.02320396f, 
    -0.01130760f, -0.05862494f, -0.09631021f, -0.10090370f, 0.08947148f, -0.05512904f, 0.02594049f, 0.02233965f, 
    0.01578290f, 0.01488679f, 0.02157081f, -0.00070781f, -0.00015866f, -0.00951863f, 0.02846498f, 0.06055788f, 
    0.03873759f, 0.00868936f, 0.05362710f, 0.06361922f, -0.01556696f, -0.03277710f, -0.00335718f, -0.05037615f, 
    0.01932120f, -0.02224869f, -0.05838747f, -0.19599000f, 0.01347082f, -0.06587992f, -0.12639542f, 0.03757798f, 
    0.08261286f, -0.17927377f, -0.17860027f, 0.12204280f, -0.21124838f, -0.00456099f, -0.03943856f, -0.03717139f, 
    -0.08414266f, -0.00703587f, -0.01165342f, -0.01467571f, 0.00138214f, -0.01131566f, -0.02037723f, 0.01330378f, 
    -0.03324189f, 0.06973496f, -0.12519801f, -0.07072706f, -0.00848591f, 0.04474123f, -0.13565190f, 0.13688514f, 
    -0.21175453f, 0.04149703f, 0.03975572f, 0.04951674f, -0.04631741f, 0.01529718f, -0.02771221f, 0.05929031f, 
    0.02634784f, -0.01599238f, 0.00316056f, -0.02321303f, -0.09207644f, -0.02481093f, -0.08984186f, 0.08580284f, 
    0.16759621f, -0.42802429f, 0.00592147f, -0.22867803f, -0.02245189f, -0.07086312f, -0.05989349f, -0.17612112f, 
    0.11037244f, 0.02517281f, 0.00256315f, -0.01127675f, -0.10566124f, -0.04814022f, -0.00093642f, -0.02126841f, 
    0.02922125f, -0.09694384f, 0.09321408f, -0.00802988f, 0.13613182f, 0.08669357f, -0.00382194f, -0.06411479f, 
    -0.07864197f, -0.03563745f, 0.02687925f, -0.03672981f, 0.00257796f, -0.04899947f, -0.06035011f, 0.00297183f, 
    0.00649659f, -0.16206625f, -0.13764977f, -0.01196827f, 0.00869201f, 0.01232764f, 0.01417844f, 0.00301127f, 
    -0.08778641f, -0.53532481f, 0.14850436f, 0.59666687f, -0.18481563f, 0.01004559f, 0.14181538f, -0.06940492f, 
    0.11503080f, 0.20173429f, -0.00435808f, -0.01970683f, -0.04981544f, -0.07101382f, -0.03782322f, -0.08196476f, 
    0.04381080f, -0.23047078f, 0.12937656f, -0.00514116f, -0.26036176f, -0.17800666f, -0.22056048f, 0.19570430f, 
    0.00765433f, 0.06382120f, 0.00713959f, 0.09448665f, -0.00733408f, 0.10600954f, 0.02455578f, -0.04511097f, 
    -0.01943990f, -0.09407657f, -0.07486949f, 0.02086972f, 0.00501088f, -0.09718578f, 0.05623958f, 0.02930572f, 
    -0.41720879f, -0.41116768f, -0.16340974f, 0.23517428f, 0.00700952f, 0.10779504f, 0.04896329f, -0.00608744f, 
    0.01846172f, 0.05297029f, -0.01223003f, -0.02596375f, 0.00134810f, -0.06471901f, -0.02075492f, -0.00402369f, 
    -0.02198630f, -0.06420569f, 0.04086012f, -0.05338762f, -0.50757265f, -0.34885579f, 0.38044393f, -0.20681988f, 
    0.25914073f, 0.04044939f, -0.05064983f, 0.05161021f, 0.01505126f, -0.05425774f, -0.04110143f, 0.05143853f, 
    0.04353793f, -0.07999737f, -0.05593200f, -0.01174600f, -0.04852613f, 0.12029517f, -0.16592228f, 0.01303569f, 
    0.36203280f, -0.35246599f, -0.22944465f, -0.12686445f, -0.13780735f, 0.05919150f, -0.06428669f, -0.04652882f, 
    -0.01375213f, -0.09170699f, -0.00949957f, -0.06089656f, 0.03426437f, -0.01645333f, -0.00095548f, 0.00133094f, 
    -0.04888544f, 0.04520112f, -0.01744105f, -0.00730312f, -0.15460430f, -0.07946274f, 0.08837879f, 0.05756368f, 
    0.06607915f, -0.02450401f, 0.07185390f, -0.02635008f, 0.02943812f, 0.00083732f, 0.01439926f, -0.03028046f, 
    0.04550668f, 0.00755706f, 0.04187825f, 0.02866860f, -0.00420838f, -0.01970234f, -0.02745075f, -0.03789335f, 
    0.36129919f, -0.46096972f, 0.27275547f, -0.30378318f, -0.24290262f, -0.19140694f, 0.06718162f, -0.07256451f, 
    0.14778122f, -0.10072303f, 0.04585792f, -0.00533764f, 0.04778682f, 0.01178429f, 0.01029315f, -0.02167836f, 
    0.01256424f, -0.09046794f, -0.04356758f, 0.00855786f, 0.24508983f, -0.44115514f, 0.12040800f, 0.14433017f, 
    0.04297776f, 0.03278923f, 0.09715117f, -0.00724222f, 0.14110261f, 0.11686786f, 0.02932806f, 0.01226292f, 
    0.03496768f, -0.03944250f, 0.00733574f, -0.01952360f, 0.01046002f, -0.03126250f, 0.00243128f, -0.08375666f, 
    -0.26280221f, -0.07988295f, 0.04373223f, 0.02404650f, 0.20060818f, 0.00691490f, -0.08703521f, 0.02298142f, 
    -0.01421085f, 0.07517247f, -0.06029862f, 0.05825604f, -0.00987857f, 0.00895480f, 0.00433387f, 0.05606406f, 
    0.01246677f, 0.01255778f, -0.06527310f, 0.00456050f, 0.61686110f, -0.27796420f, -0.36511001f, -0.18863934f, 
    -0.24370973f, -0.03172470f, -0.14534461f, -0.12819429f, -0.00661393f, -0.12667307f, -0.03592544f, -0.01595276f, 
    0.00680793f, 0.00587042f, 0.00937626f, 0.00660922f, -0.00180855f, 0.01226697f, 0.01935489f, 0.00402990f, 
    0.43028745f, -0.06834529f, -0.22345097f, -0.01771214f, -0.16766784f, 0.18130706f, -0.09739994f, 0.05912627f, 
    -0.04081516f, 0.15225185f, 0.06412759f, 0.03041305f, 0.15537088f, -0.02880713f, 0.02874717f, 0.00686260f, 
    0.02563017f, 0.00596855f, -0.02177071f, -0.05488022f, 0.02931530f, 0.03218850f, 0.04789917f, -0.03184086f, 
    -0.02805870f, 0.01085743f, -0.01066543f, 0.03565484f, 0.00854474f, -0.04717370f, -0.03434177f, 0.00964408f, 
    0.01425770f, -0.01270519f, -0.02257133f, -0.11499550f, -0.11300854f, 0.13096923f, -0.09124161f, -0.04633441f, 
    -0.38196987f, -0.27903858f, -0.28331915f, -0.18825707f, -0.05978825f, 0.11367301f, -0.02651419f, 0.03767894f, 
    0.03003656f, 0.06164151f, 0.00321446f, -0.04205777f, -0.05754129f, -0.04442031f, -0.03906283f, -0.00396613f, 
    0.05866981f, 0.05720773f, -0.01060264f, -0.01400709f, 0.08294116f, 0.14488855f, 0.00430705f, -0.06941774f, 
    -0.01271283f, 0.03321696f, 0.06835910f, -0.03436730f, -0.02202024f, -0.00555275f, -0.07662233f, -0.01808242f, 
    0.07979225f, -0.07400607f, -0.05506027f, -0.08596084f, 0.04716728f, 0.04196429f, -0.06291681f, 0.01011982f, 
    0.01809451f, -0.01151941f, 0.05243196f, -0.10521837f, -0.02584576f, -0.00685338f, 0.00363715f, -0.01485599f, 
    0.03941599f, -0.02506157f, -0.05258830f, -0.09517486f, -0.06027723f, 0.00721277f, 0.07572883f, 0.01195443f, 
    0.01777245f, -0.02656936f, 0.01760885f, -0.03785466f, -0.59139502f, -0.56043166f, 0.45624557f, -0.17710045f, 
    0.26444030f, 0.07732473f, -0.01848605f, 0.13034059f, 0.00207050f, 0.02685586f, -0.02930261f, -0.01337038f, 
    -0.09731496f, -0.04397806f, -0.04930798f, 0.10921337f, 0.02872296f, 0.05782400f, 0.05412013f, -0.08832975f, 
    0.27405593f, -0.50293213f, -0.42406768f, -0.40779153f, -0.20245053f, -0.00897101f, -0.12787470f, 0.06109155f, 
    0.18489902f, 0.01737238f, 0.01755930f, 0.01809060f, -0.04202570f, -0.01980847f, 0.04034198f, -0.07813741f, 
    -0.01386512f, -0.01537787f, 0.02503567f, 0.01233246f, -0.01310194f, 0.07426002f, 0.06250803f, 0.02258665f, 
    -0.00598557f, -0.00819446f, 0.00953818f, -0.00765993f, -0.01833963f, -0.05373726f, 0.05367657f, -0.02485835f, 
    0.02540186f, 0.00769940f, -0.00323352f, -0.03151761f, -0.03589042f, 0.08233131f, -0.04305550f, 0.00740737f, 
    0.04708776f, 0.05542207f, -0.06857086f, 0.03567489f, -0.01996236f, 0.04620923f, 0.03673766f, -0.07598826f, 
    0.01174638f, 0.03237969f, -0.01053389f, -0.06026589f, -0.00274054f, -0.05188659f, -0.00838566f, -0.07962999f, 
    -0.05761077f, -0.00497040f, 0.05570232f, -0.02660391f, 0.04534230f, 0.05034075f, 0.01624995f, 0.00719372f, 
    -0.07265069f, -0.01690915f, 0.04387108f, 0.00791357f, -0.01220178f, -0.03415202f, 0.00084871f, -0.00777680f, 
    -0.03950509f, -0.07027275f, -0.04638777f, -0.00583519f, -0.01385656f, -0.01977728f, 0.03875706f, 0.03355693f, 
    0.58472258f, -0.23661377f, -0.31631014f, -0.18253335f, -0.26566151f, 0.00799701f, -0.11250342f, -0.04835545f, 
    -0.00191234f, -0.01059063f, 0.01247269f, -0.01298912f, 0.05864613f, 0.04033494f, 0.05344463f, 0.02305751f, 
    -0.01987437f, -0.00838120f, 0.03261959f, 0.01269367f, 0.05238605f, 0.02441719f, -0.06545610f, 0.13575216f, 
    -0.02764367f, 0.03462642f, 0.05569308f, 0.00863376f, -0.01352123f, -0.07897902f, -0.08926451f, 0.05224045f, 
    -0.05016336f, 0.04706840f, 0.01512523f, -0.02086782f, 0.05311645f, 0.06771984f, -0.01967141f, 0.01897221f, 
    -0.38225919f, -0.46855861f, 0.24579568f, -0.34173152f, 0.14320947f, -0.12100732f, 0.02922149f, 0.07858708f, 
    0.03724222f, -0.02965765f, 0.00385813f, 0.00006754f, 0.01644362f, -0.06127961f, -0.00158256f, -0.06002336f, 
    -0.05659902f, -0.02608443f, 0.02063978f, -0.00470171f, 0.47818431f, -0.21001112f, -0.17958988f, -0.14331666f, 
    -0.07630485f, 0.04343702f, -0.01267327f, -0.05154397f, -0.06469292f, 0.00262436f, 0.05354367f, -0.00377525f, 
    0.05526417f, 0.05572094f, 0.04012684f, 0.01050700f, -0.01616389f, 0.00956437f, -0.00208156f, 0.02756853f, 
    -0.19049253f, 0.10394239f, 0.05708419f, 0.02447977f, 0.07583980f, -0.04022196f, -0.00495261f, -0.01011884f, 
    -0.05772905f, 0.07162732f, 0.05186250f, -0.02131770f, 0.00273718f, 0.00146730f, 0.02476031f, -0.01196853f, 
    -0.13347124f, -0.08735488f, -0.04467754f, -0.01856929f, 0.02093565f, -0.01363824f, 0.04023867f, 0.03768720f, 
    0.01842412f, 0.04355433f, 0.01947943f, 0.05111563f, -0.00645107f, 0.00101136f, 0.04718341f, -0.00217271f, 
    0.01288156f, 0.00901371f, -0.01425700f, 0.01154129f, -0.09092354f, -0.09753209f, -0.02937771f, -0.04243322f, 
    0.13567886f, 0.03884446f, 0.02269867f, -0.02957715f, -0.16063654f, -0.06130291f, -0.01826274f, -0.03443880f, 
    0.01265788f, -0.04718625f, 0.00193527f, 0.01842419f, -0.05734973f, -0.00171014f, 0.04593058f, 0.02039600f, 
    0.14890184f, 0.01361369f, 0.06290672f, 0.02699760f, -0.15841806f, -0.43878645f, -0.33414486f, -0.22635762f, 
    -0.10776601f, -0.09903191f, -0.08611453f, -0.09058184f, -0.02708878f, -0.08989311f, -0.06793663f, -0.03643949f, 
    -0.03721576f, -0.02716021f, -0.00607145f, -0.00612618f, 0.05931356f, 0.04614285f, 0.04382006f, 0.11801453f, 
    -0.06926860f, -0.36196268f, -0.32786176f, -0.14290395f, -0.10923782f, -0.00428716f, -0.11682072f, 0.00960052f, 
    0.08908127f, -0.10952894f, -0.03543537f, -0.00901204f, -0.05037234f, -0.01539678f, 0.04046122f, -0.02979034f, 
    0.12011525f, 0.02422080f, 0.15726016f, 0.01700249f, -0.42037678f, -0.09392589f, 0.28560802f, 0.15256861f, 
    0.08813846f, -0.00900622f, 0.00277944f, -0.01739794f, -0.03695361f, -0.07787231f, -0.01616568f, -0.03715381f, 
    -0.03755491f, -0.04792152f, -0.01580844f, -0.11892028f, -0.15885974f, -0.05418374f, -0.09345559f, -0.23639126f, 
    0.01228651f, -0.36268628f, -0.31252730f, -0.18715721f, -0.05844828f, -0.03431831f, -0.09261034f, -0.01197729f, 
    0.02919406f, -0.08438564f, -0.04633576f, 0.00153508f, 0.04016326f, -0.04259573f, 0.03033245f, -0.00425384f, 
    0.03102336f, 0.12205442f, 0.05778904f, 0.07842086f, -0.10572851f, -0.32424924f, 0.03057925f, 0.10781838f, 
    0.12310489f, 0.07369480f, 0.15246597f, -0.09930043f, -0.10602612f, 0.14119573f, 0.03092305f, 0.04911696f, 
    0.00314248f, 0.09535714f, -0.01920080f, -0.01611357f, 0.14367849f, -0.08094657f, 0.09083940f, 0.08048203f, 
    0.08925556f, -0.08281420f, -0.10794476f, -0.11978573f, -0.16271448f, -0.07404264f, -0.03655159f, 0.07751371f, 
    0.04359024f, 0.01995255f, 0.11119574f, 0.02234116f, -0.07950380f, 0.11867487f, 0.08373976f, -0.02308839f, 
    0.03760130f, -0.01770566f, -0.00792550f, 0.10696442f, -0.11680974f, 0.10417409f, 0.04677844f, -0.04902276f, 
    -0.09170447f, -0.05154849f, -0.03066507f, -0.01518179f, -0.01223055f, -0.03777802f, -0.09510924f, -0.04428738f, 
    0.00162891f, -0.07114575f, 0.02980592f, 0.00992046f, 0.05277527f, -0.07351165f, 0.00597804f, -0.01693994f, 
    0.56498194f, -0.20832308f, -0.01963092f, 0.08604268f, -0.08159022f, 0.07612470f, 0.00517801f, -0.00255265f, 
    0.02547449f, 0.03804718f, 0.03193677f, 0.02366194f, 0.06325155f, 0.01157585f, 0.06155929f, 0.03022695f, 
    0.05010055f, 0.04744370f, 0.00116569f, -0.00859646f, -0.06581236f, 0.10025527f, 0.00661663f, -0.11147875f, 
    -0.12843934f, -0.01866179f, -0.05754128f, -0.01464588f, 0.03489236f, -0.09377330f, -0.05877680f, 0.04708618f, 
    0.02002227f, -0.06213696f, 0.05142258f, -0.07114727f, 0.10852288f, -0.05474172f, 0.04247811f, 0.05285482f, 
    -0.08327736f, -0.09797521f, -0.10258243f, 0.02987994f, -0.02608928f, -0.02379409f, -0.04200409f, -0.06503449f, 
    -0.00961839f, 0.03426136f, 0.10815606f, 0.06131207f, 0.04294436f, -0.01191696f, -0.02215664f, -0.04755795f, 
    0.07704305f, 0.06002314f, 0.03451027f, 0.10734045f, -0.08452217f, -0.08800464f, -0.03284448f, 0.04062884f, 
    -0.04962428f, -0.00641387f, -0.02564296f, -0.07879549f, -0.02955670f, -0.01385190f, 0.02835982f, 0.06957683f, 
    0.08022916f, -0.00048083f, 0.07835563f, -0.00126953f, 0.09794632f, 0.16300291f, 0.05488551f, 0.14794157f, 
    0.23745902f, -0.13941051f, -0.43293154f, -0.41078916f, -0.11296941f, 0.06445307f, -0.28301999f, -0.02374652f, 
    -0.01830798f, 0.07072728f, -0.00182045f, 0.01988873f, 0.01474970f, 0.03192447f, -0.01597894f, 0.00383562f, 
    0.04725824f, -0.00885236f, 0.02545297f, 0.05469859f, 0.55659401f, 0.22751164f, 0.08577897f, -0.00382110f, 
    -0.01432084f, 0.15682930f, 0.13918641f, 0.00376585f, 0.10446993f, -0.09924801f, 0.07809383f, 0.02694611f, 
    0.01047895f, 0.00874244f, 0.02765291f, 0.10361678f, -0.04995035f, -0.23083422f, -0.00368273f, -0.07860689f, 
    0.23309463f, 0.10391997f, 0.12099885f, 0.10445886f, -0.05285259f, 0.03765552f, -0.04274441f, -0.09738268f, 
    -0.01370301f, 0.03680372f, 0.05055198f, 0.02445773f, -0.02413317f, -0.00587593f, -0.02084380f, -0.06387983f, 
    0.05592638f, 0.01227313f, -0.09120278f, 0.01247127f, 0.03934885f, -0.05033736f, -0.33461475f, -0.18325640f, 
    0.00677917f, -0.02329230f, -0.04853899f, 0.05124732f, 0.00546589f, -0.12905374f, 0.00618579f, -0.03301934f, 
    -0.00529401f, 0.04871485f, 0.02004638f, 0.09796055f, -0.00641138f, 0.01957522f, -0.05561085f, -0.10803692f, 
    0.43454018f, 0.05488715f, -0.20415036f, -0.42876592f, -0.09093150f, 0.05373136f, 0.19832167f, -0.00844107f, 
    0.04660694f, -0.21653920f, 0.00892547f, 0.07978393f, 0.17535919f, 0.06464081f, 0.16597617f, -0.08264970f, 
    -0.04726077f, -0.06584530f, 0.12928379f, 0.08366240f, 0.01450167f, -0.00760789f, -0.00700843f, 0.03027000f, 
    -0.10719392f, -0.03986027f, -0.11008666f, -0.11435550f, -0.09735303f, -0.06801170f, -0.05320486f, -0.01825394f, 
    0.03061480f, 0.01376272f, 0.04198692f, 0.01399353f, 0.09865347f, 0.11477615f, 0.06443265f, 0.08161028f, 
    0.08407743f, -0.01565517f, -0.16012473f, -0.08743985f, -0.08285511f, 0.01353718f, -0.05212589f, 0.03072797f, 
    0.09740204f, 0.02001291f, 0.14210562f, 0.00690009f, 0.01670852f, -0.02064123f, 0.07658839f, -0.03439213f, 
    0.04049826f, -0.01016761f, -0.00487050f, 0.06410721f, -0.08462595f, 0.08515818f, 0.04397754f, 0.06271289f, 
    -0.14818646f, 0.01180245f, -0.01164007f, -0.01341673f, 0.01034239f, -0.05120312f, -0.01838901f, -0.05347938f, 
    -0.01583277f, 0.03308645f, -0.01075085f, 0.12283754f, 0.03877456f, 0.01200077f, 0.05801184f, 0.01970555f, 
    -0.34841642f, 0.24190250f, 0.13151954f, 0.15125142f, -0.07761270f, 0.07381828f, -0.02743353f, -0.05113977f, 
    -0.02356053f, -0.07469286f, -0.03619640f, -0.01307795f, 0.02566112f, -0.00334295f, -0.04212159f, 0.01979011f, 
    -0.01407786f, 0.04190998f, -0.06147008f, -0.05085926f, -0.26527959f, -0.32127264f, 0.05274115f, 0.02791729f, 
    0.07661968f, -0.02887752f, 0.11576031f, 0.07139220f, -0.03235238f, 0.05538074f, 0.05215795f, 0.05547313f, 
    0.01754484f, 0.10396512f, 0.04413360f, -0.05581884f, 0.03939342f, -0.06108190f, 0.06191646f, -0.00659155f, 
    -0.15437086f, -0.25622651f, 0.11563531f, 0.02785399f, 0.08711207f, -0.07304769f, -0.00710322f, -0.00972639f, 
    -0.04458867f, -0.06643236f, 0.02712710f, 0.00420492f, 0.02308831f, 0.07419338f, 0.00848336f, -0.05793137f, 
    -0.04106501f, -0.00439993f, -0.00669156f, -0.06980965f, -0.04058534f, -0.21831676f, -0.48472202f, -0.13711414f, 
    0.03901540f, -0.06582492f, 0.06731989f, 0.18466999f, 0.17661349f, 0.01756752f, 0.05959836f, -0.03546071f, 
    -0.02781616f, 0.01964101f, -0.01774591f, -0.03690812f, -0.04340563f, -0.00217789f, -0.07788203f, -0.09174766f, 
    0.25287718f, 0.06596550f, -0.19764468f, -0.14161746f, -0.03410821f, 0.03117696f, -0.04236580f, -0.04814301f, 
    0.06379858f, 0.00596077f, 0.01720412f, -0.03250059f, 0.01454377f, 0.02806806f, 0.00991667f, -0.07954529f, 
    -0.08329462f, -0.08795242f, -0.25900716f, -0.44431326f, -0.06318011f, -0.14117210f, -0.10041522f, 0.01173867f, 
    0.11061504f, -0.04939961f, 0.02442321f, 0.02144147f, 0.07308488f, 0.06846729f, 0.04229305f, 0.02538034f, 
    -0.05673766f, -0.01558824f, -0.04975010f, -0.02270762f, 0.08582932f, 0.07291548f, 0.06239233f, 0.04711141f, 
    -0.03674151f, 0.29160339f, -0.03044951f, -0.04021854f, -0.27345476f, -0.03064010f, 0.02101547f, -0.09052953f, 
    0.09372891f, -0.14759639f, 0.00414714f, 0.03523448f, 0.02466158f, 0.05216932f, 0.05278571f, -0.20150970f, 
    0.01574944f, -0.09325767f, -0.12099335f, -0.20279014f, -0.07144885f, 0.02872807f, -0.00562416f, 0.02365401f, 
    -0.01344160f, -0.04658442f, 0.02243937f, 0.00334901f, 0.02403931f, -0.00448810f, -0.08855943f, 0.06841847f, 
    0.03443320f, -0.06354750f, 0.12357990f, -0.07530434f, -0.03256908f, 0.01705050f, 0.01194695f, 0.03334118f, 
    0.17092447f, 0.00608337f, -0.01961681f, -0.02025809f, -0.16462870f, -0.04287701f, -0.09776745f, -0.08731978f, 
    -0.12670155f, -0.13934043f, -0.03718128f, 0.06512222f, 0.04353514f, -0.04785830f, -0.01339434f, 0.00073957f, 
    0.05103128f, 0.12911354f, 0.19124399f, 0.09361192f, 0.13066150f, 0.01279115f, -0.20556241f, -0.04297721f, 
    0.13922495f, -0.01731713f, 0.13449290f, 0.02018209f, 0.07819989f, 0.03005204f, 0.05735806f, -0.03789810f, 
    -0.01436275f, -0.01769069f, -0.02466669f, 0.07416609f, 0.08338822f, -0.00962906f, -0.06742293f, -0.13696443f, 
    -0.18094160f, -0.09671541f, 0.04430338f, 0.10771240f, 0.06084551f, 0.05349884f, -0.05421373f, 0.13929945f, 
    0.07968317f, 0.03046394f, 0.00357222f, -0.03701364f, 0.08399177f, 0.03932608f, 0.06013595f, -0.11935113f, 
    -0.02855819f, 0.08642691f, -0.02149279f, 0.12924856f, 0.62912780f, -0.66396010f, -0.14613648f, -0.05216230f, 
    0.51404554f, 0.11689863f, 0.17799798f, -0.09888505f, -0.11187107f, 0.16151878f, 0.08262432f, 0.03435547f, 
    0.01827500f, 0.10519549f, 0.00918775f, -0.00866156f, -0.04453969f, 0.02953452f, -0.21889029f, -0.16515949f, 
    0.00047114f, -0.04520003f, -0.04244869f, -0.01509217f, -0.04589115f, -0.02658863f, 0.01178490f, 0.03720847f, 
    0.01236587f, 0.02208382f, 0.02658255f, 0.07631438f, 0.01333122f, 0.04535662f, 0.01659580f, 0.00292889f, 
    0.05794162f, -0.00925123f, 0.07406590f, 0.07738262f, -0.30797738f, -0.24572511f, 0.02637348f, 0.08491810f, 
    0.09368854f, 0.04203019f, -0.03180161f, -0.01834946f, -0.08976413f, -0.00806767f, -0.03438067f, 0.01047379f, 
    0.05060549f, 0.11652887f, 0.04961060f, 0.12528658f, -0.08307560f, 0.09285495f, -0.08623998f, 0.03326748f, 
    0.44338715f, 0.18737254f, 0.09036846f, -0.02954784f, -0.09621208f, 0.04040838f, 0.11307960f, 0.04447033f, 
    0.04150387f, -0.14589007f, -0.00160066f, 0.10000413f, -0.01425575f, -0.00096615f, 0.04632069f, 0.04564836f, 
    0.04485111f, -0.01359491f, 0.07146364f, -0.12894255f, 0.02555478f, 0.16317694f, 0.27060005f, 0.00824090f, 
    -0.15234412f, -0.07729515f, -0.02137518f, -0.11044522f, -0.03245144f, 0.00213580f, -0.01725660f, 0.00702920f, 
    0.01070233f, -0.04722799f, -0.01942677f, -0.17546573f, -0.09459639f, -0.11258446f, -0.17064549f, -0.33157730f, 
    0.08248662f, 0.17811956f, -0.18078172f, -0.08738325f, -0.05800400f, 0.09687416f, -0.08330947f, 0.00864302f, 
    0.14963339f, 0.01691044f, 0.01257193f, -0.03203293f, -0.01712062f, 0.07064645f, 0.08792514f, -0.00828564f, 
    0.03522379f, 0.04717553f, -0.16569275f, -0.06170655f, -0.01426298f, -0.00941279f, -0.12724836f, -0.07583312f, 
    -0.07655584f, -0.03398121f, 0.00400871f, 0.03532475f, 0.03290775f, 0.01662197f, 0.12212799f, 0.05380463f, 
    0.06988300f, 0.06370172f, 0.02350550f, 0.00326143f, 0.03429584f, -0.02112135f, 0.04978213f, 0.03998602f, 
    0.23075844f, 0.03379626f, -0.15693249f, -0.33269191f, -0.22196023f, 0.01797965f, -0.14773867f, -0.03855427f, 
    -0.16062246f, -0.38320163f, 0.02313719f, 0.03424713f, 0.02493579f, 0.09477380f, 0.02010113f, 0.05469753f, 
    0.04606843f, 0.13102153f, -0.08587444f, -0.21690758f, 0.03465594f, -0.24761313f, -0.07159639f, -0.13506471f, 
    -0.08242068f, 0.06576423f, -0.11249437f, -0.03943426f, -0.05827620f, -0.25810760f, 0.03440672f, 0.00111079f, 
    0.00858011f, 0.02165313f, 0.07770384f, 0.07929715f, 0.02602581f, 0.03390234f, -0.02541696f, -0.18914782f, 
    0.22701818f, -0.13282458f, -0.12838548f, -0.02901857f, 0.05502343f, 0.09479149f, -0.05742271f, 0.03053330f, 
    -0.05398940f, -0.11215714f, 0.01547705f, 0.02224853f, -0.02450512f, 0.03106117f, 0.04241919f, 0.03811819f, 
    0.05051786f, 0.07484291f, -0.04269706f, 0.04468000f, -0.06829523f, -0.47312373f, -0.08360057f, 0.27169576f, 
    -0.03108220f, 0.04815041f, 0.24794528f, -0.04362344f, -0.02080968f, 0.03154473f, 0.03774009f, 0.08500363f, 
    0.01523041f, -0.00941985f, 0.03948348f, 0.04782696f, 0.08201810f, -0.19979200f, 0.12295928f, 0.03432472f, 
    0.08025716f, -0.22532961f, -0.27349910f, -0.03538900f, 0.05187861f, -0.01863101f, 0.02755074f, 0.04353004f, 
    0.04738487f, 0.05995402f, -0.00322806f, -0.06769396f, -0.07078789f, -0.03546232f, -0.04432632f, 0.01736549f, 
    0.03128515f, -0.02146945f, 0.05193974f, 0.04261007f, 0.20978986f, -0.08366969f, -0.04607614f, -0.00770700f, 
    -0.07770342f, -0.03314608f, -0.06397223f, -0.06718640f, -0.03134005f, 0.04548673f, -0.02417886f, 0.11560267f, 
    -0.01991365f, -0.05846404f, 0.07092913f, 0.01555841f, 0.10190243f, 0.11082961f, 0.10318991f, 0.10683828f, 
    0.00689078f, -0.16931891f, -0.51081669f, -0.18962944f, -0.08353712f, 0.11064440f, -0.08055343f, 0.24168427f, 
    0.05384261f, 0.12008866f, 0.01725651f, 0.00157251f, -0.03411416f, 0.00837107f, 0.03718502f, -0.00318022f, 
    0.02662957f, 0.13268122f, -0.01268566f, 0.04926623f, -0.14626710f, -0.31444126f, -0.44487581f, -0.20130560f, 
    -0.09037910f, -0.06618199f, -0.05914004f, 0.02052835f, -0.01830174f, 0.00810348f, -0.05634728f, -0.04232331f, 
    -0.02640119f, -0.02731656f, 0.00938534f, 0.00570121f, 0.06137706f, 0.04984202f, 0.05063964f, 0.10806940f, 
    -0.33405873f, -0.25286961f, -0.06874976f, 0.10356008f, 0.20945138f, 0.07631152f, 0.06390984f, -0.08015328f, 
    -0.03242386f, 0.03083166f, 0.07425824f, -0.03818250f, 0.09385320f, 0.05019262f, -0.06436516f, -0.03881676f, 
    0.03539696f, 0.00325365f, 0.03186468f, 0.09802534f, 0.03806062f, -0.51661897f, -0.54468197f, -0.20300874f, 
    0.15582323f, 0.03454358f, 0.16130692f, 0.13070948f, 0.09708147f, 0.06643404f, 0.01232805f, -0.03500726f, 
    -0.04865554f, -0.07288675f, -0.07355491f, 0.00818467f, 0.00364553f, -0.05836251f, -0.01861451f, -0.01872289f, 
    0.13633317f, -0.06595648f, -0.15591197f, -0.08923461f, -0.10681116f, 0.03282660f, 0.03407392f, 0.00408007f, 
    0.00472278f, -0.01730292f, -0.03555038f, -0.08630119f, -0.08743598f, -0.01988176f, -0.05591305f, -0.04158083f, 
    0.02542985f, -0.00454359f, 0.08394604f, 0.02593269f, -0.11338736f, 0.06901749f, 0.09326565f, 0.03620991f, 
    -0.13578182f, -0.02355726f, 0.01311053f, 0.00180014f, -0.00137746f, -0.04275617f, -0.04096153f, 0.01039635f, 
    -0.08891595f, 0.01740126f, -0.01567835f, 0.01432218f, 0.02433868f, -0.05283758f, -0.05153058f, -0.09361897f, 
    0.11276002f, -0.39729938f, -0.37874997f, -0.46790415f, -0.09430705f, -0.10888777f, -0.00003482f, 0.00472882f, 
    -0.02054815f, -0.16145307f, 0.00593114f, -0.04353648f, 0.00349141f, -0.02997194f, 0.04797763f, 0.06436902f, 
    0.04096160f, -0.01701125f, -0.06421002f, -0.18572183f, 0.00982552f, -0.00967096f, -0.04548157f, 0.05271717f, 
    -0.11567207f, -0.06428241f, 0.00848920f, 0.06475751f, 0.04486277f, 0.04111753f, 0.09415711f, -0.04356326f, 
    -0.04831310f, 0.07159166f, 0.04836100f, 0.11953912f, 0.05840672f, -0.00694157f, -0.01321821f, 0.03320062f, 
    -0.09245881f, -0.11894344f, -0.06902918f, -0.03757169f, -0.03097709f, -0.02847965f, 0.04431147f, 0.07158877f, 
    0.01513194f, 0.07553381f, 0.06257683f, -0.01723400f, 0.03564595f, -0.02304686f, 0.01216384f, 0.00472839f, 
    0.05608382f, 0.05088730f, 0.02779314f, 0.04423374f, 0.47775844f, -0.53321952f, -0.30871174f, -0.13245164f, 
    -0.05333155f, 0.04870493f, -0.28321111f, 0.06687437f, -0.08779407f, -0.09692234f, 0.02332072f, -0.02218444f, 
    0.07099541f, 0.04989105f, 0.09588395f, 0.06244629f, 0.02984171f, 0.04005155f, -0.21233484f, -0.31543660f, 
    -0.10064033f, -0.23545063f, -0.48742256f, -0.36513865f, -0.08783163f, -0.13116543f, 0.08853812f, 0.08928379f, 
    0.02126515f, -0.14180386f, -0.00421534f, -0.05802501f, -0.03996268f, 0.03133002f, 0.06376358f, 0.07169630f, 
    -0.03494075f, 0.04001789f, -0.09287850f, -0.03600244f, -0.18678880f, 0.08950988f, 0.07506960f, 0.04538532f, 
    -0.01136891f, -0.06003240f, 0.05847941f, -0.04544698f, 0.02891185f, 0.01031635f, -0.02863033f, 0.01646886f, 
    0.03902751f, -0.01109212f, 0.02349967f, 0.03736182f, 0.01255806f, 0.03097086f, 0.07298739f, 0.02511391f, 
    -0.14514427f, -0.03803425f, -0.10114533f, 0.10897093f, -0.02507770f, 0.14678355f, 0.03748171f, 0.07452109f, 
    -0.03790522f, 0.00806747f, -0.07496728f, 0.00825668f, -0.05890357f, -0.01235937f, -0.00293685f, 0.00632380f, 
    -0.05859940f, 0.10373899f, -0.01090786f, 0.08944567f, -0.18639956f, -0.01980430f, 0.02510248f, -0.10719862f, 
    -0.13035935f, -0.08567484f, -0.06305996f, -0.03224932f, -0.03332570f, -0.06070393f, -0.04825724f, -0.02542169f, 
    0.01301964f, 0.03298220f, 0.06501038f, -0.02999307f, 0.02383558f, -0.00639476f, 0.01519473f, 0.02189818f, 
    -0.02911192f, -0.38732031f, -0.37444559f, -0.20190665f, 0.02041193f, -0.07258895f, 0.11073688f, 0.13657308f, 
    0.05933388f, 0.06298005f, 0.02069810f, -0.06212951f, -0.04505814f, -0.05634612f, -0.07852960f, 0.00569632f, 
    -0.00133515f, -0.02180143f, -0.01830071f, -0.01120670f, 0.14480795f, -0.08579027f, -0.04455154f, -0.13197261f, 
    -0.02809821f, -0.01151792f, -0.06204664f, -0.10075474f, -0.04402759f, -0.02176250f, 0.00987931f, 0.01143500f, 
    0.21106149f, -0.03429829f, 0.05162758f, -0.04184409f, 0.08806448f, -0.04107592f, 0.11036378f, 0.03474401f, 
    0.12708659f, -0.26871037f, -0.30703142f, 0.14438066f, 0.12793386f, 0.08310305f, -0.00576469f, 0.14612959f, 
    0.05107082f, 0.10453919f, 0.04098551f, -0.04061132f, 0.01421381f, 0.01400126f, 0.07907677f, 0.02505843f, 
    0.11259641f, -0.07527942f, -0.11929043f, 0.00146576f, -0.03560412f, -0.21606067f, -0.26828843f, -0.17937104f, 
    0.01000367f, -0.06714791f, 0.02558119f, 0.08168602f, 0.06870786f, 0.14623430f, -0.04027076f, 0.02555158f, 
    -0.06844789f, -0.04979550f, -0.03133409f, -0.00539908f, 0.01025540f, 0.01065173f, 0.01412275f, 0.02398757f, 
    -0.53642046f, -0.05382578f, 0.14175165f, 0.16125837f, 0.06031784f, -0.00737263f, -0.02876248f, -0.01165729f, 
    -0.00275927f, -0.03112229f, -0.07004309f, -0.05328333f, -0.02284519f, 0.01055254f, -0.02563942f, -0.07085804f, 
    -0.01931561f, 0.07480852f, 0.03235995f, 0.04515969f, -0.22480075f, -0.03673485f, 0.19515358f, 0.13194321f, 
    -0.02817249f, -0.06002839f, -0.02641950f, -0.07222260f, -0.01991509f, 0.00479922f, -0.03907022f, -0.05435348f, 
    -0.00804969f, 0.03798847f, -0.00113177f, 0.00024293f, -0.16997650f, -0.03879442f, -0.26480106f, -0.02683777f, 
    -0.12113392f, 0.02055128f, -0.14633396f, -0.03253295f, -0.02686826f, 0.00357360f, 0.10060637f, -0.01581002f, 
    0.01484258f, -0.00788226f, -0.02691604f, -0.04005066f, -0.07249508f, -0.00624363f, -0.02487771f, 0.16264059f, 
    -0.12944791f, 0.00834707f, -0.02968462f, -0.05795178f, -0.22059450f, -0.06553497f, 0.13267671f, 0.04395020f, 
    -0.19641083f, -0.02495328f, -0.17178994f, 0.10886963f, 0.13523072f, 0.20574616f, -0.04095470f, -0.00936663f, 
    -0.00602245f, -0.02718760f, -0.03879088f, 0.02409508f, -0.00229909f, -0.00509688f, -0.06129900f, -0.16881742f, 
    -0.45172387f, 0.04010083f, 0.00046084f, -0.10980839f, -0.12994066f, -0.14418820f, -0.13881916f, -0.04690821f, 
    0.01003125f, 0.16002730f, -0.03750873f, -0.05450956f, 0.05150318f, -0.04514795f, -0.00488229f, 0.00357438f, 
    -0.03620919f, 0.00063215f, -0.08637220f, -0.22359532f, 0.02234862f, -0.32272056f, -0.48840117f, -0.15765451f, 
    0.15281844f, 0.02227665f, -0.01171780f, 0.14490442f, 0.07233015f, 0.07689079f, -0.03757166f, 0.01925440f, 
    -0.00361251f, 0.01429088f, -0.01014118f, 0.04282140f, 0.13568832f, 0.14163503f, -0.03823189f, 0.16280104f, 
    -0.00005808f, -0.16474395f, 0.08687674f, 0.08633078f, -0.22520216f, -0.08627085f, -0.11195861f, 0.18422318f, 
    0.08321946f, 0.26381356f, -0.02526456f, 0.02611036f, -0.01366799f, -0.01807144f, -0.07678545f, 0.05695282f, 
    -0.00731537f, 0.00312378f, 0.06739793f, -0.10794688f, -0.08749912f, -0.10479938f, 0.28621340f, -0.57326347f, 
    -0.09079447f, 0.05523007f, -0.06390109f, 0.02880779f, -0.00615877f, -0.06775554f, 0.03889547f, 0.00648410f, 
    -0.02120466f, 0.07710273f, 0.05544930f, -0.03587036f, -0.03214135f, -0.06560731f, -0.14709719f, 0.01510076f, 
    -0.42894676f, 0.05012051f, 0.05907517f, 0.26803899f, 0.19922343f, -0.15551306f, 0.11867626f, -0.13956536f, 
    -0.09983482f, -0.00505966f, 0.05502698f, -0.05418086f, 0.07686619f, -0.03557272f, -0.01861517f, 0.11924834f, 
    -0.02653536f, -0.00852136f, -0.08528077f, -0.07684725f, -0.18557173f, -0.10249268f, -0.18097378f, -0.01527944f, 
    0.15196320f, -0.00766905f, 0.08192885f, 0.16822107f, 0.03673036f, -0.01203145f, 0.03138323f, 0.03611736f, 
    0.00925753f, -0.04736897f, -0.00074312f, -0.01200947f, 0.14331917f, 0.04146163f, 0.03144874f, 0.06959971f, 
    0.15821154f, 0.02909101f, 0.18231188f, -0.07428207f, -0.13458931f, -0.01871463f, -0.13313669f, 0.09753363f, 
    -0.00577249f, 0.08024845f, -0.03517862f, -0.01102343f, -0.01200750f, -0.03091317f, -0.09427889f, 0.02657261f, 
    0.02425633f, 0.02345586f, -0.03464795f, -0.05378117f, -0.12070405f, -0.24270783f, -0.12016642f, 0.08109032f, 
    0.18067573f, -0.10386784f, 0.12266246f, -0.02006787f, 0.02223089f, -0.09457691f, -0.06704956f, -0.06705035f, 
    -0.02504329f, -0.13147798f, -0.03934221f, 0.09934179f, 0.14372842f, 0.03433269f, -0.09039234f, 0.02991363f, 
    -0.02592993f, 0.07676872f, 0.43533304f, -0.06020311f, -0.14452384f, 0.07250707f, -0.07618783f, -0.08584677f, 
    0.04750997f, -0.04566044f, -0.02637298f, -0.03434872f, 0.07006343f, -0.04815840f, 0.00233336f, 0.04170763f, 
    -0.04915527f, -0.05608767f, -0.09179479f, -0.04805049f, 0.23474106f, 0.05575358f, 0.04703723f, -0.03667567f, 
    -0.13168713f, 0.03416824f, 0.11030625f, -0.03508211f, 0.06717013f, 0.07258818f, -0.02118287f, -0.02575290f, 
    -0.01028383f, -0.06204479f, 0.08211469f, 0.03882050f, -0.00820340f, 0.00288542f, -0.09457976f, -0.05973894f, 
    -0.17690583f, -0.19527772f, -0.35159305f, 0.02589538f, -0.37642762f, -0.23557217f, 0.06764737f, -0.00232220f, 
    0.02319895f, -0.00888270f, -0.00940349f, -0.06345475f, -0.03882407f, -0.02013052f, 0.04384401f, 0.03988856f, 
    0.03587670f, -0.04124417f, 0.08438830f, -0.11253901f, -0.50581491f, 0.08977500f, -0.72240549f, 0.08173555f, 
    -0.11964104f, 0.04368620f, -0.10129053f, 0.06522181f, -0.14386997f, 0.07530499f, -0.00275241f, -0.01862403f, 
    0.04046243f, 0.00351546f, -0.06136478f, 0.03914385f, -0.01734710f, 0.06615200f, 0.10777496f, 0.12968838f, 
    0.05305486f, -0.16615032f, -0.15495573f, -0.05860334f, -0.02172816f, 0.10872260f, 0.08762952f, -0.00931903f, 
    -0.00575752f, -0.02180260f, 0.05227783f, -0.05806844f, -0.03608460f, -0.03369249f, -0.06672994f, 0.04025457f, 
    0.02449404f, -0.09086042f, -0.08441740f, -0.00668223f, 0.04601374f, 0.04161976f, 0.16831265f, 0.29670551f, 
    -0.27133262f, 0.00724407f, -0.12539776f, -0.05870473f, 0.05088007f, 0.08510274f, 0.02699035f, 0.03737959f, 
    0.03351149f, 0.01515748f, 0.03805657f, -0.08029108f, 0.05431928f, 0.08975237f, 0.09677701f, 0.07825383f, 
    -1.02966237f, -0.12464838f, -0.30030259f, 0.44245428f, -0.03105959f, 0.08692461f, 0.09537961f, -0.20370865f, 
    -0.11782900f, -0.06231717f, 0.08546984f, -0.01481100f, 0.01440712f, -0.15652916f, 0.00570516f, 0.04423574f, 
    -0.07653849f, -0.08514155f, 0.02108255f, 0.02799802f, 0.08922026f, 0.05608534f, -0.21206321f, -0.07912777f, 
    -0.08783182f, 0.15167421f, 0.13313717f, 0.20772989f, 0.00805639f, 0.00876464f, 0.06841910f, -0.12060863f, 
    -0.08745185f, -0.11052017f, -0.07337542f, 0.12745665f, -0.05878955f, -0.16369566f, 0.01575600f, 0.00618745f, 
    -0.11444680f, -0.08138758f, -0.05606840f, 0.15114121f, 0.05728168f, -0.07203615f, 0.18044774f, -0.17711988f, 
    -0.02066927f, -0.18790703f, 0.01964570f, -0.02088109f, 0.03028007f, 0.00077779f, 0.05285161f, 0.06871896f, 
    0.07558013f, -0.02819449f, -0.06926595f, -0.01462004f, -0.15110943f, 0.06600304f, -0.30017403f, 0.01324160f, 
    -0.14071518f, 0.14015949f, -0.02187414f, 0.15077597f, -0.03528846f, -0.05217093f, 0.00705670f, -0.04001823f, 
    0.00773740f, -0.01817698f, -0.01298864f, -0.01399301f, 0.04367951f, -0.02355079f, 0.00858427f, 0.06484098f, 
    -0.27779925f, 0.25035653f, -0.67910469f, -0.12082748f, 0.10049427f, 0.16892359f, 0.08502743f, 0.21099009f, 
    0.06925218f, 0.10141812f, 0.04484757f, -0.01047118f, -0.06818402f, 0.02275185f, -0.00860394f, -0.03113580f, 
    -0.02616644f, -0.08902719f, 0.00890915f, 0.00101548f, 0.12496483f, -0.10639992f, 0.30366898f, -0.28875628f, 
    -0.18172297f, -0.06349711f, -0.18110473f, -0.10508607f, 0.11284436f, -0.15568689f, -0.05691168f, 0.07070244f, 
    0.01304870f, 0.11431345f, 0.01603314f, 0.07215610f, 0.06259299f, 0.00645945f, -0.01427506f, 0.07209536f, 
    0.08288212f, 0.09124946f, -0.00927040f, 0.08159949f, -0.08265404f, -0.00348258f, -0.14367399f, -0.03240780f, 
    0.03140133f, -0.11050208f, -0.06492371f, 0.07587329f, 0.02782738f, 0.02209733f, -0.06104588f, 0.11264589f, 
    0.03554837f, 0.01914173f, -0.00113941f, 0.14269704f, 0.04228882f, 0.17093168f, 0.06835233f, 0.49075350f, 
    -0.24073008f, -0.19327328f, 0.02995068f, -0.34267774f, -0.04142717f, -0.19457987f, 0.06682871f, -0.06127139f, 
    0.10852778f, 0.12422388f, 0.02941286f, 0.07700393f, 0.05435782f, 0.00222029f, 0.05856355f, 0.01715877f, 
    0.08153296f, 0.08714567f, -0.11387943f, 0.34120682f, -0.14591616f, 0.06055979f, -0.03582382f, -0.04443749f, 
    0.11357154f, -0.00915521f, 0.01369317f, -0.01989722f, 0.07667472f, -0.02320983f, 0.03317437f, 0.07624414f, 
    0.08083562f, 0.11811406f, 0.17879377f, 0.23489723f, -0.00101218f, 0.15600522f, 0.37793237f, -0.10398103f, 
    -0.19591632f, 0.04490820f, -0.12129884f, -0.02240219f, -0.02106114f, 0.02510356f, -0.01304952f, 0.02578975f, 
    0.06340656f, 0.02776875f, 0.01947885f, -0.00825788f, -0.02377096f, -0.01551871f, -0.00519726f, -0.03117741f, 
    -0.64303070f, -0.03557594f, -0.12924348f, 0.05952502f, 0.23179784f, -0.18380862f, 0.22396812f, -0.24535486f, 
    0.07700109f, 0.04902375f, 0.10969169f, -0.07490906f, -0.07062773f, -0.11838995f, 0.00733990f, 0.13041407f, 
    0.02350527f, -0.05774076f, -0.02194995f, 0.01689125f, 0.03118645f, -0.13499458f, 0.02482825f, -0.01332019f, 
    0.08975632f, -0.08634909f, 0.12849931f, 0.04926217f, -0.07613954f, 0.00441793f, -0.00613381f, 0.07118921f, 
    0.01910764f, -0.15866134f, -0.07382048f, 0.08610458f, -0.01597193f, 0.04827112f, -0.13227180f, -0.00995733f, 
    0.14260505f, 0.24032231f, -0.29293084f, 0.10567692f, -0.12656018f, -0.01854391f, 0.09937313f, 0.11734760f, 
    -0.03695263f, 0.00237080f, 0.06760846f, -0.05347118f, -0.09242233f, -0.11826696f, -0.05961340f, 0.02306029f, 
    -0.07634494f, -0.02218978f, -0.00878100f, -0.13737349f, 0.07251684f, 0.22434334f, -0.04469071f, 0.13459615f, 
    -0.12586862f, 0.05621260f, -0.04797039f, -0.10419353f, 0.04705567f, -0.08526712f, 0.01978705f, 0.02179254f, 
    -0.05878960f, 0.05279685f, 0.05245886f, 0.09285850f, 0.04938432f, 0.01591746f, 0.04424300f, 0.08912962f, 
    0.26040867f, -0.30672121f, 0.06331175f, 0.02031115f, 0.10492261f, -0.21683551f, -0.06652585f, -0.02132429f, 
    0.00475605f, 0.23444015f, -0.06134489f, 0.01751527f, 0.05718845f, -0.07881141f, 0.00470048f, 0.04834993f, 
    0.06240169f, 0.10630637f, -0.08791815f, -0.01143757f, -0.18130083f, -0.70690465f, -0.05216852f, -0.17987633f, 
    -0.39244106f, 0.21542141f, -0.27240098f, 0.03349081f, 0.02404008f, -0.14111325f, -0.04853399f, 0.05396093f, 
    0.01372416f, -0.00942015f, 0.09451694f, 0.00491726f, -0.01248996f, -0.10395840f, 0.01629178f, 0.06407353f, 
    0.02004544f, 0.08314961f, 0.02141739f, 0.05623830f, 0.17834215f, 0.03203426f, 0.02338645f, -0.06426236f, 
    -0.08424903f, -0.07568910f, 0.03565754f, 0.01636149f, -0.01460329f, -0.00144321f, 0.03078739f, 0.06390869f, 
    -0.00096790f, -0.08763697f, -0.01708093f, 0.05248944f, -0.05769184f, -0.03200546f, -0.12950882f, -0.15363343f, 
    -0.02859611f, 0.06464265f, -0.08658332f, 0.08952378f, -0.01257081f, 0.01256176f, 0.02975427f, 0.01709730f, 
    -0.05995182f, 0.02018891f, -0.06330775f, -0.02715206f, -0.03381390f, 0.08737195f, -0.05276145f, -0.01077589f, 
    -0.36077368f, 0.11107648f, -0.39946201f, -0.15096690f, -0.08634061f, -0.03820625f, 0.02593463f, 0.00502538f, 
    -0.11288635f, 0.13328180f, 0.05692942f, -0.01655320f, -0.01163592f, -0.00231931f, -0.02958184f, 0.08178824f, 
    0.02970916f, -0.01919266f, -0.01076255f, 0.01469704f, -0.17571105f, -0.03460610f, -0.19375294f, -0.04414251f, 
    0.16872951f, 0.07254142f, -0.00284656f, 0.01613071f, 0.07650883f, -0.09474652f, 0.04021614f, -0.00591459f, 
    0.03285685f, -0.09110475f, -0.05607905f, 0.06234313f, 0.00530024f, -0.05982408f, 0.02806706f, 0.11648929f, 
    -0.33471712f, -0.10937081f, -0.01556583f, 0.23079211f, -0.04252199f, -0.08847538f, 0.15100263f, -0.15174995f, 
    0.09678062f, 0.04515302f, 0.07055636f, -0.07608579f, 0.00485388f, 0.02128099f, 0.02020755f, 0.08539803f, 
    0.06065783f, 0.06458419f, 0.02678704f, 0.06385957f, -0.08956898f, 0.12256189f, 0.10336372f, 0.16301890f, 
    0.20736209f, -0.10577031f, 0.10740449f, -0.19106622f, -0.00786577f, -0.05316553f, 0.04426636f, -0.01620496f, 
    -0.04525995f, 0.00636148f, -0.04833832f, 0.07468208f, 0.01513122f, -0.02161181f, 0.00850290f, -0.00866519f, 
    -0.33268708f, -0.27242571f, -0.21712163f, 0.20287502f, -0.21674035f, 0.08644760f, -0.12457979f, 0.10591906f, 
    -0.11705776f, 0.16570581f, 0.01412595f, 0.04778371f, 0.02738361f, 0.08682282f, -0.04733254f, -0.01999300f, 
    0.01979356f, 0.03908755f, 0.19255541f, 0.13216114f, -0.24015850f, 0.10994187f, -0.21444902f, 0.00288007f, 
    -0.08512604f, 0.03841276f, -0.14080091f, -0.03887374f, -0.05068683f, 0.17375228f, -0.02339791f, 0.05920494f, 
    0.00404550f, 0.01933000f, 0.00153800f, -0.04780162f, -0.00241665f, 0.16809636f, 0.04194003f, 0.07733820f, 
    0.10381110f, 0.10402124f, -0.15300082f, -0.02666595f, -0.14009324f, 0.06285491f, -0.09585205f, 0.07210091f, 
    0.06750020f, 0.11257985f, 0.00328185f, 0.03161483f, 0.03249712f, -0.05842287f, -0.00838820f, -0.02516394f, 
    -0.00091073f, 0.06669395f, 0.05188243f, -0.03427088f, 0.02627475f, -0.10130114f, 0.06306238f, -0.65617883f, 
    -0.03242311f, -0.12129698f, -0.04719602f, -0.06164918f, 0.00235465f, -0.00498125f, -0.07917877f, -0.00617494f, 
    -0.02358822f, 0.05258597f, -0.05826028f, -0.08689775f, 0.06734888f, -0.00820263f, -0.08909965f, 0.04164572f, 
    -0.05895152f, 0.02049251f, 0.15124293f, 0.12348923f, -0.15284182f, -0.07604259f, -0.13544010f, -0.14071031f, 
    -0.03515495f, -0.03687852f, 0.01514103f, -0.02022242f, 0.04795652f, 0.02894538f, 0.04328508f, -0.04543167f, 
    -0.04425166f, -0.00527966f, 0.03128940f, -0.00722427f, 0.15833627f, -0.02222798f, 0.06097789f, 0.06689048f, 
    -0.03317857f, -0.01428165f, 0.10306603f, 0.02546461f, -0.00860647f, -0.03698223f, -0.04486137f, 0.00253954f, 
    0.02534386f, -0.04735275f, 0.02744763f, 0.06109761f, -0.02775872f, -0.06305314f, -0.12774792f, -0.03252433f, 
    -0.10915996f, -0.29170814f, -0.19764747f, -0.16834752f, -0.20002720f, -0.37023902f, 0.20650324f, -0.04446954f, 
    -0.09691517f, 0.10862338f, 0.06185291f, -0.03700080f, 0.02201417f, -0.06077395f, 0.01551011f, 0.03152270f, 
    0.00398000f, 0.04861374f, -0.03169261f, -0.17052743f, -0.28857636f, -0.30083874f, 0.17098175f, -0.02668011f, 
    -0.16811752f, 0.00438364f, -0.19330092f, 0.15836036f, 0.08390042f, 0.17664716f, 0.02542787f, -0.03153035f, 
    -0.00323255f, 0.02371090f, -0.04442732f, 0.03641734f, 0.00663143f, -0.01732390f, -0.03847866f, -0.11542559f, 
    -0.15330777f, 0.07654724f, 0.49729335f, -0.32900557f, -0.37433919f, -0.02356030f, -0.12056171f, 0.04914843f, 
    0.12144315f, 0.06811888f, -0.01832708f, -0.05418977f, 0.03142137f, -0.06878819f, -0.01056116f, -0.00698933f, 
    0.06130501f, -0.00309547f, -0.08672734f, -0.08947577f, 0.11704528f, 0.03791589f, 0.28345776f, 0.23672508f, 
    -0.38558385f, 0.10205416f, -0.10917100f, -0.21427205f, -0.09853929f, -0.06906132f, 0.07332667f, -0.01298760f, 
    0.04969776f, 0.05889995f, 0.07035048f, 0.04344460f, 0.02000740f, 0.03694075f, 0.03203398f, -0.01136273f, 
    -0.33799508f, 0.02731103f, 0.05176384f, 0.12129299f, -0.07104769f, 0.13274559f, -0.11148156f, -0.09397409f, 
    -0.15163063f, -0.02248543f, 0.05660716f, -0.04644885f, -0.00463213f, 0.02581062f, -0.04400879f, 0.09227522f, 
    -0.00514447f, -0.05787423f, 0.05283802f, -0.10128536f, -0.08943073f, -0.14187789f, -0.06154737f, -0.17194922f, 
    0.14926139f, 0.02955575f, 0.10754387f, 0.09481366f, -0.04884868f, 0.07518992f, 0.05041501f, -0.04794667f, 
    -0.04098573f, -0.01000971f, -0.05293821f, 0.12042244f, 0.14288525f, 0.04836543f, -0.00494725f, 0.04087349f, 
    -0.00807789f, -0.23945743f, -0.04995451f, -0.06252795f, -0.22171742f, -0.05007716f, -0.06959976f, -0.16675963f, 
    0.01707097f, 0.10739197f, 0.03027975f, 0.02020170f, 0.02498360f, 0.05971409f, -0.01303630f, -0.14137295f, 
    0.01756021f, 0.18287916f, 0.08024451f, 0.10786444f, -0.08942599f, -0.03542753f, 0.08055577f, 0.07296052f, 
    0.09446774f, -0.08380206f, 0.11722597f, -0.09937747f, 0.02191438f, -0.07322139f, 0.03824713f, -0.00918847f, 
    -0.01103305f, 0.04336870f, 0.00103497f, 0.04663809f, 0.02823600f, 0.02677852f, -0.13193379f, -0.04713190f, 
    0.12010080f, 0.05023482f, 0.17293140f, 0.11275108f, -0.02406856f, 0.09204002f, -0.03427781f, -0.17854507f, 
    -0.00600303f, -0.07940023f, 0.00190391f, 0.03104900f, 0.00554678f, 0.03255938f, 0.06432048f, 0.01963578f, 
    -0.01738454f, -0.04435625f, -0.00349465f, 0.03454772f, 0.24834228f, -0.72850239f, -0.19905812f, -0.08943566f, 
    -0.11456503f, -0.11003184f, -0.14955346f, 0.10072242f, 0.03642048f, 0.04540663f, -0.03319233f, 0.04956555f, 
    0.04152011f, 0.00307929f, 0.02222745f, -0.03537376f, 0.01182500f, 0.05559584f, 0.04647311f, 0.00346520f, 
    -0.06809113f, -0.01002408f, 0.19399115f, 0.32201520f, -0.63981605f, 0.04798176f, -0.02019090f, -0.08881362f, 
    0.10680556f, 0.03596146f, 0.05146731f, -0.03736581f, 0.03815883f, 0.00440610f, -0.02802273f, 0.03222648f, 
    0.08534834f, 0.00161552f, 0.00777339f, 0.00098803f, -0.12283394f, 0.10942087f, -0.08300626f, -0.29416823f, 
    0.13845907f, 0.01069193f, 0.09224625f, 0.10011135f, 0.00656435f, 0.04405130f, 0.06528899f, 0.04228362f, 
    -0.08852793f, -0.00384717f, 0.02219893f, 0.07194795f, 0.07839541f, -0.04894921f, -0.00133052f, 0.03359908f, 
    -0.06376608f, 0.12389362f, -0.22925130f, -0.18838146f, -0.17678703f, 0.03611457f, -0.04931379f, 0.16300113f, 
    -0.06585439f, 0.00648741f, -0.00701430f, 0.06017839f, -0.14729938f, -0.08018565f, 0.12746631f, -0.18038514f, 
    0.01336461f, 0.17603201f, -0.01204016f, -0.01295346f, -0.17215754f, -0.08149002f, -0.03185046f, -0.05236275f, 
    0.19591027f, -0.01539647f, 0.08115506f, 0.01907759f, -0.00306492f, -0.04807556f, 0.08603086f, 0.15895042f, 
    0.13176621f, -0.03834277f, -0.07301846f, 0.19773434f, -0.00625587f, 0.07322937f, 0.02298330f, 0.04707341f, 
    0.13667847f, 0.08656724f, 0.30895370f, 0.22986437f, -0.30351919f, 0.15507241f, -0.13229525f, -0.29119360f, 
    -0.15337090f, -0.10410286f, 0.04733109f, 0.02021490f, 0.09954555f, 0.04960926f, 0.06318200f, 0.03038042f, 
    -0.00254526f, 0.01325434f, 0.00335614f, 0.00073522f, 0.05825368f, -0.05766981f, -0.13677800f, 0.03667989f, 
    -0.09706078f, -0.12198448f, 0.04959924f, 0.02274967f, -0.05486008f, -0.16179238f, -0.03480172f, 0.00468143f, 
    -0.13253102f, 0.02797910f, 0.01407130f, 0.02675087f, -0.05953356f, -0.11546699f, -0.00842352f, -0.04266376f, 
    0.10155192f, -0.21552792f, 0.02387732f, -0.22856981f, -0.27035227f, 0.02216922f, -0.15257379f, 0.05944955f, 
    0.01193916f, -0.12932079f, -0.02719537f, -0.05308292f, -0.01085282f, 0.02735241f, -0.04527811f, 0.01587873f, 
    0.00881641f, 0.01113733f, -0.07838938f, -0.00694977f, 0.02407045f, 0.03890055f, 0.10657445f, 0.04149745f, 
    -0.08770980f, 0.01447888f, 0.03703934f, -0.23047657f, -0.16895324f, -0.02549335f, 0.05857483f, -0.01257019f, 
    0.09462294f, 0.01790648f, 0.04063878f, 0.03464398f, -0.05276328f, -0.03892261f, -0.01331154f, -0.06285350f, 
    -0.03626167f, 0.07325155f, -0.08529518f, -0.31752449f, -0.02382273f, -0.18965580f, 0.08655868f, 0.10467891f, 
    0.07368305f, 0.12989205f, 0.00953439f, 0.03873551f, 0.02078664f, -0.08556093f, -0.05669897f, 0.02263649f, 
    0.20364498f, -0.04045497f, -0.00567206f, -0.03217701f, 0.06070636f, -0.31195661f, 0.03141660f, -0.12555720f, 
    0.12711486f, 0.01013991f, 0.03929963f, 0.08029721f, 0.03409501f, 0.03382154f, -0.05145512f, 0.00778622f, 
    0.03686210f, -0.00579866f, -0.11112822f, -0.03210658f, 0.09212283f, 0.08257842f, -0.04313165f, 0.04149418f, 
    0.00456356f, -0.31407729f, 0.14977349f, -0.07312187f, -0.01254534f, -0.03303338f, -0.01608218f, 0.08031222f, 
    0.00891040f, -0.04908250f, 0.08045494f, 0.00327256f, 0.02792712f, 0.04275658f, 0.00884437f, -0.00388969f, 
    0.08473766f, 0.01333351f, 0.06516322f, -0.00946917f, -0.34974334f, -0.03403900f, -0.23085605f, -0.15758526f, 
    0.07627821f, 0.03280037f, -0.03646070f, 0.08190066f, -0.04911457f, -0.08625783f, -0.05354522f, 0.03042616f, 
    0.03197148f, 0.06290047f, -0.00719646f, 0.02155085f, 0.01621563f, -0.05230616f, 0.05941690f, 0.12341577f, 
    -0.16414016f, -0.00626324f, 0.10795825f, -0.09612529f, 0.06028270f, 0.06687763f, 0.12867905f, 0.14127415f, 
    0.12938532f, -0.07402401f, -0.01351430f, -0.00400837f, 0.02529025f, -0.06673921f, -0.02722370f, -0.03306138f, 
    0.05037283f, 0.09879924f, 0.16015153f, -0.05070107f, -0.02105582f, -0.02861904f, -0.08572186f, -0.03089792f, 
    -0.06919125f, -0.09369241f, 0.02883224f, 0.04515842f, -0.18070740f, -0.09934432f, 0.05535862f, 0.04608565f, 
    -0.09327994f, 0.04733210f, -0.00901347f, -0.01866654f, -0.13216639f, -0.18449879f, -0.40835235f, -0.16171846f, 
    -0.32604221f, -0.02882510f, -0.49676803f, -0.06584740f, 0.06471229f, -0.06240348f, -0.07996695f, 0.07349080f, 
    -0.15915832f, -0.07462582f, -0.00818087f, 0.09003091f, 0.02418106f, 0.08189889f, -0.01270064f, 0.08612797f, 
    -0.01539499f, -0.10917724f, -0.03960145f, 0.04465649f, -0.34724030f, 0.19202527f, 0.12363213f, 0.18543096f, 
    0.05031698f, 0.06137108f, 0.03688033f, -0.16606405f, 0.12435909f, 0.17838882f, -0.13925850f, -0.08164102f, 
    -0.03159770f, 0.01288372f, 0.06951737f, -0.05824306f, 0.11701680f, 0.00269412f, 0.14036146f, 0.08864442f, 
    0.44919822f, -0.26034537f, 0.20674470f, -0.08707411f, -0.09641951f, 0.08823845f, 0.03305947f, 0.10126008f, 
    0.08602330f, 0.09425377f, -0.04860468f, 0.12855178f, -0.00088444f, -0.07001222f, -0.01443830f, 0.00696935f, 
    0.04410829f, 0.03588273f, 0.09466452f, -0.01799375f, -0.04351305f, -0.33135036f, -0.08026951f, -0.11766307f, 
    -0.25532535f, -0.10232081f, -0.09104848f, -0.01486276f, -0.07146315f, -0.03706691f, -0.00465517f, -0.00460840f, 
    -0.11539108f, 0.03497738f, -0.00565571f, 0.05281015f, -0.05371514f, -0.01611003f, -0.00030160f, -0.02581612f, 
    -0.33288562f, 0.08185981f, -0.00002923f, 0.03954630f, 0.04796463f, 0.06353330f, -0.09840936f, -0.07796922f, 
    0.12719844f, 0.00425143f, -0.07471487f, 0.05762293f, 0.03319425f, -0.00531199f, 0.02294401f, 0.02067603f, 
    0.04153407f, -0.12714244f, -0.04199893f, 0.07764220f, -0.01574127f, -0.40531728f, -0.05725206f, 0.11304837f, 
    0.02472476f, -0.08975575f, -0.08589739f, 0.02808868f, -0.04854441f, 0.03220944f, -0.01501847f, -0.02979123f, 
    -0.18718822f, 0.06666188f, 0.08827992f, -0.11918613f, -0.20601243f, 0.06151017f, 0.04680904f, 0.13057657f, 
    -0.18292318f, -0.09573277f, -0.15232791f, 0.17703304f, 0.00788282f, -0.10189588f, -0.00375532f, -0.06742194f, 
    0.13770303f, 0.02164603f, 0.06016931f, -0.09686780f, 0.00614907f, 0.01850367f, 0.05055073f, 0.02602420f, 
    0.00721247f, -0.10961823f, 0.14965479f, 0.11878058f, -0.08565513f, -0.08413199f, -0.39451289f, 0.17245361f, 
    -0.10705920f, -0.01827583f, -0.07846496f, 0.08934094f, 0.07321464f, 0.07034097f, -0.13593359f, 0.02224480f, 
    0.07268723f, 0.07456658f, -0.00560803f, 0.03505418f, -0.01640555f, -0.08976474f, 0.13731147f, 0.12019230f, 
    -0.24832609f, 0.10463386f, 0.22880910f, -0.07103330f, 0.20309530f, -0.04367381f, -0.05403772f, 0.14296865f, 
    -0.09876501f, 0.09500372f, -0.20764488f, 0.04452220f, -0.04537101f, 0.11112703f, 0.06985205f, 0.04222059f, 
    -0.00650041f, -0.02990044f, 0.00299463f, 0.05395206f, 0.15068074f, -0.19413255f, 0.18578592f, 0.01334575f, 
    0.06733495f, -0.11997140f, 0.09048197f, 0.11315995f, 0.09455760f, -0.03214639f, -0.04363561f, 0.06919942f, 
    -0.01099895f, -0.02300396f, 0.04626854f, 0.06279659f, -0.02304008f, -0.05560539f, -0.08011071f, -0.24114168f, 
    -0.26723424f, -0.04473771f, -0.14642243f, -0.01232222f, -0.11500622f, 0.01958006f, -0.04125613f, 0.13204539f, 
    0.21522784f, 0.09214810f, -0.14950751f, 0.03039676f, -0.00303221f, -0.04512770f, -0.01492388f, -0.02722346f, 
    -0.09774263f, 0.04446177f, 0.14217390f, 0.06388685f, -0.19620115f, -0.00685431f, -0.11598509f, -0.00908287f, 
    0.02671117f, -0.02696879f, -0.02557863f, -0.04860259f, 0.00106536f, 0.01724823f, -0.04401870f, 0.01355998f, 
    -0.02736178f, -0.07878028f, -0.06373666f, 0.03072702f, -0.06008654f, -0.00808187f, -0.06484544f, -0.08749616f, 
    0.35404739f, -0.14825094f, 0.34326100f, -0.22788221f, 0.11685192f, -0.21361975f, -0.04827048f, 0.11720815f, 
    -0.00285700f, -0.05870439f, -0.03709874f, -0.05674911f, -0.18810387f, 0.02148400f, 0.08120995f, -0.04394067f, 
    -0.07796527f, 0.04091595f, -0.10737763f, 0.01757893f, -0.26718789f, -0.41026360f, -0.22708361f, -0.04796137f, 
    -0.08627821f, -0.02797428f, -0.01795182f, 0.05485876f, 0.14123154f, -0.03978264f, -0.13364407f, 0.02898140f, 
    0.01026848f, 0.03141173f, -0.09401220f, 0.11961638f, -0.03001167f, 0.13904825f, 0.17917904f, 0.12206945f, 
    -0.00391700f, 0.07367015f, 0.01649045f, 0.06815430f, 0.05690967f, 0.07070592f, -0.06836156f, 0.04169349f, 
    -0.03421545f, 0.10172911f, -0.14178200f, -0.01050222f, -0.05848437f, -0.00950102f, 0.06589537f, -0.10540934f, 
    -0.01466357f, -0.08511347f, -0.00848357f, 0.01691412f, -0.17582233f, -0.31606609f, 0.05720818f, -0.03625955f, 
    -0.18026783f, -0.12088450f, -0.12843032f, 0.03431654f, 0.07275272f, -0.04745839f, -0.07884161f, -0.02362227f, 
    0.01826064f, 0.00468845f, -0.01518952f, 0.05348150f, -0.00597617f, 0.06636830f, 0.12187679f, -0.00722498f, 
    -0.10884999f, -0.33378482f, -0.08804130f, 0.07390736f, -0.08223523f, -0.18817182f, -0.05384718f, 0.02638008f, 
    -0.04094565f, -0.15953076f, -0.18251392f, 0.07256280f, 0.00744676f, -0.01253553f, 0.01017491f, 0.10598858f, 
    -0.06914491f, -0.04079793f, 0.00398117f, -0.11304316f, -0.19857171f, 0.18194413f, -0.00447054f, 0.08830135f, 
    -0.01635143f, 0.07396977f, -0.09638713f, -0.08116765f, 0.05563024f, 0.10820004f, -0.02676383f, -0.00467419f, 
    -0.08450550f, 0.03316390f, -0.04925383f, -0.09796578f, 0.00730382f, 0.00314778f, 0.04716485f, -0.08873147f, 
    -0.06045900f, -0.02561041f, 0.05645961f, 0.03650498f, -0.05915743f, 0.01539208f, -0.01667296f, 0.04387255f, 
    0.00445843f, 0.00296537f, 0.09158882f, 0.09606987f, -0.12905301f, 0.00328981f, -0.11647861f, 0.02900261f, 
    -0.09553365f, -0.01850560f, -0.03706006f, -0.12459085f, 0.18139832f, 0.08215871f, 0.04595790f, 0.01686295f, 
    0.09491790f, 0.14644903f, -0.08129164f, -0.03241643f, -0.02509970f, 0.02092286f, -0.19305570f, 0.13226278f, 
    -0.12660161f, -0.09857700f, -0.09312800f, 0.03251117f, -0.06683646f, -0.02770677f, -0.03304918f, -0.08954612f, 
    -0.22623844f, -0.04467644f, -0.13474631f, 0.08028486f, -0.04555568f, -0.00847615f, 0.08258416f, 0.04651828f, 
    -0.00033140f, -0.06039104f, 0.02302243f, 0.04258165f, -0.02370410f, -0.01266033f, -0.07998817f, 0.03703246f, 
    -0.18024631f, -0.06375786f, -0.13413925f, -0.15016147f, -0.07461789f, -0.02085206f, -0.04184382f, 0.12713696f, 
    -0.01559027f, -0.05790605f, 0.04682952f, -0.05337730f, 0.01830049f, -0.01997272f, 0.08200355f, -0.10840053f, 
    0.00452324f, 0.03624153f, 0.02096916f, -0.00694226f, -0.00469235f, 0.04025558f, 0.06807462f, 0.11770467f, 
    0.42351761f, -0.04879325f, 0.27298504f, 0.13021770f, -0.19615357f, 0.18045360f, -0.12773426f, 0.10377424f, 
    0.00858188f, -0.10207783f, 0.08171248f, -0.00876828f, 0.18898362f, 0.03276598f, 0.05673964f, 0.00385270f, 
    -0.12360079f, 0.00182985f, -0.10324096f, -0.07844695f, 0.03033935f, -0.22681695f, 0.25987321f, 0.20207043f, 
    -0.06010146f, -0.09870835f, -0.09624323f, 0.02913341f, -0.07670508f, -0.06429403f, 0.00199907f, -0.05347904f, 
    -0.12938522f, 0.12725970f, 0.09060817f, -0.06125468f, 0.00484253f, 0.14275494f, -0.05530041f, 0.07554817f, 
    -0.32658720f, -0.25021666f, 0.11098533f, -0.07981282f, 0.01400291f, 0.03076351f, -0.01249070f, 0.11335079f, 
    0.00567903f, 0.02304715f, 0.01370910f, 0.04282846f, 0.02181217f, 0.08070046f, 0.00494614f, 0.07169299f, 
    0.03139710f, 0.06154788f, 0.11156063f, 0.11179534f, -0.06252923f, 0.11804961f, 0.06716362f, 0.11444741f, 
    -0.11526812f, 0.08642592f, 0.02046910f, -0.03972938f, 0.00894913f, -0.04997911f, -0.09795100f, -0.01317039f, 
    0.01817252f, -0.02769910f, -0.10828129f, -0.03467482f, -0.05402066f, -0.07051966f, -0.11519780f, -0.15049836f, 
    0.11886656f, 0.10154098f, 0.06666064f, 0.17452960f, 0.05152229f, -0.05314577f, -0.07246805f, -0.02311091f, 
    -0.04737022f, 0.05928551f, -0.00542951f, -0.00716730f, -0.11590979f, 0.02682357f, 0.08906417f, -0.04620253f, 
    -0.02278022f, 0.10578968f, 0.02118166f, 0.08766551f, -0.74039656f, 0.23186046f, -0.30620950f, 0.09552012f, 
    -0.04720077f, 0.07492583f, 0.10542211f, -0.09595864f, 0.25414345f, -0.06562409f, 0.00351270f, 0.03382969f, 
    -0.04207983f, -0.06258691f, 0.14351335f, 0.06537463f, -0.10367408f, -0.10927579f, -0.01943032f, -0.12010177f, 
    0.08412557f, -0.05698388f, 0.07261007f, 0.10806999f, -0.02824356f, -0.06707167f, 0.03290537f, -0.01487108f, 
    -0.01455064f, 0.07483396f, -0.09915160f, 0.01904899f, 0.05962449f, -0.03989375f, 0.02219662f, -0.02857160f, 
    -0.01355972f, 0.04710427f, 0.06703505f, 0.01309679f, -0.13970442f, 0.12345582f, -0.17466989f, 0.14046589f, 
    -0.05689641f, -0.04988898f, -0.00661647f, -0.02257545f, 0.12062392f, 0.08501459f, 0.01197450f, 0.00791397f, 
    0.02903048f, 0.04730067f, -0.04353549f, 0.03559049f, 0.06364428f, -0.11544257f, 0.13264388f, -0.05037522f, 
    -0.01929034f, -0.08991194f, 0.26556849f, -0.01473151f, 0.12195897f, 0.03646561f, -0.02227705f, 0.17400827f, 
    0.04676476f, -0.06790987f, 0.08449907f, 0.02784823f, 0.11474767f, 0.01292582f, 0.00338904f, 0.04097543f, 
    -0.05369247f, 0.02914549f, -0.04669694f, -0.03123675f, -0.22971261f, -0.16361356f, 0.06733533f, -0.02706131f, 
    -0.04072134f, -0.05867940f, 0.01326165f, 0.01985322f, 0.07697574f, -0.07918549f, -0.02194546f, 0.01588099f, 
    -0.08297224f, -0.02409880f, -0.01630163f, 0.00288831f, -0.11104307f, 0.02062053f, -0.19841023f, -0.28884441f, 
    0.03877847f, 0.01709656f, -0.08754034f, 0.01300596f, 0.04810316f, 0.13030361f, -0.06048388f, 0.04026080f, 
    -0.02523823f, -0.01297463f, -0.03201818f, -0.00880854f, -0.00565963f, -0.01190071f, 0.05296132f, -0.03979832f, 
    -0.16239581f, -0.11158629f, -0.04125074f, -0.08782274f, 0.31357920f, -0.04675986f, 0.08509203f, 0.03240306f, 
    -0.13469891f, 0.06217087f, -0.01570034f, 0.02497131f, -0.06273928f, 0.01308569f, -0.04370840f, 0.05496878f, 
    -0.03426758f, -0.04161982f, 0.01558517f, -0.03581144f, -0.01822932f, -0.00869273f, 0.04425346f, -0.06957362f, 
    -0.21487235f, -0.09339456f, -0.50450057f, -0.16499069f, 0.12137676f, 0.06452759f, -0.02296491f, 0.06507163f, 
    -0.06024842f, -0.07078727f, -0.08512283f, 0.07018740f, -0.04209669f, 0.09676000f, 0.02648260f, 0.18414167f, 
    -0.09891564f, -0.10386483f, -0.30119619f, -0.19086210f, -0.04691598f, -0.05322591f, -0.16716667f, -0.06021775f, 
    0.04483158f, -0.03967001f, 0.03804029f, 0.22895522f, 0.02723129f, -0.04676241f, 0.00908549f, 0.03453432f, 
    -0.04826696f, 0.02822148f, -0.02400614f, -0.00520516f, -0.05801015f, -0.00066726f, -0.15610437f, -0.11852073f, 
    -0.16779295f, 0.01855784f, 0.09652703f, 0.07182042f, 0.06134321f, -0.03173275f, -0.01144762f, -0.14572631f, 
    -0.00458069f, -0.08861256f, -0.03504487f, 0.06860324f, 0.03770914f, 0.09371550f, 0.00341839f, 0.04598655f, 
    -0.03964139f, -0.16134487f, -0.06078842f, -0.03976721f, -0.19531028f, 0.18420084f, 0.28470775f, 0.20853822f, 
    -0.00083673f, 0.05367226f, 0.16364838f, -0.18912709f, -0.01267161f, -0.02620827f, -0.13064334f, -0.03747080f, 
    -0.01615019f, 0.01843371f, 0.03900211f, -0.01095063f, 0.11855366f, 0.12385263f, 0.03908431f, 0.14381555f, 
    0.01278004f, -0.00284291f, 0.08868003f, -0.01008284f, 0.06570485f, -0.00767199f, 0.06726939f, -0.07159489f, 
    0.07049809f, -0.00188675f, -0.04680969f, 0.02710163f, -0.04410192f, 0.01977065f, -0.00683419f, 0.05392736f, 
    0.08046535f, -0.01606404f, 0.15435712f, 0.06692061f, -0.36973250f, 0.04006479f, -0.12564330f, 0.05310761f, 
    0.00069603f, -0.01606575f, -0.03139377f, 0.07928763f, 0.00673967f, 0.08725008f, -0.00572725f, 0.00446965f, 
    -0.02237295f, 0.01380990f, -0.02908241f, -0.03233321f, 0.09658446f, 0.04882845f, 0.08801600f, 0.20976935f, 
    0.08703712f, 0.04080431f, -0.09040664f, 0.09729826f, 0.23454018f, 0.09646773f, 0.03593869f, 0.14645208f, 
    -0.10620104f, 0.08204922f, -0.10026654f, 0.05522106f, 0.06552880f, -0.04172816f, -0.02135248f, 0.02815160f, 
    0.03423603f, -0.10467254f, 0.03224025f, -0.01388123f, -0.37105358f, 0.08142430f, -0.08174098f, -0.15331925f, 
    0.09275269f, -0.05683019f, -0.05230912f, -0.08302017f, -0.01435693f, -0.05355487f, -0.12717314f, 0.02685557f, 
    0.03516288f, 0.03464993f, 0.00160047f, 0.00470257f, -0.01673410f, -0.06678309f, 0.06859798f, 0.08243949f, 
    -0.05067614f, -0.02897219f, 0.04227908f, 0.07504848f, -0.01436954f, -0.00297033f, -0.05463845f, -0.06965335f, 
    0.09423710f, 0.00740376f, 0.04087283f, -0.01325309f, 0.00974493f, 0.03982150f, 0.10747246f, 0.00282195f, 
    -0.08312082f, -0.05841435f, 0.02693425f, 0.05822565f, 0.18148483f, 0.02488733f, 0.05287263f, -0.06915753f, 
    0.06660399f, 0.00871069f, 0.02758487f, 0.00388703f, 0.08606622f, 0.00500635f, -0.05011133f, 0.09594281f, 
    -0.05069777f, -0.12743242f, -0.14048643f, 0.02674762f, -0.00956035f, 0.00210673f, 0.05883200f, -0.01465904f, 
    0.06864093f, 0.06576632f, 0.16309574f, -0.16418993f, -0.01247179f, -0.14002325f, 0.01878599f, 0.00427350f, 
    0.12569563f, 0.00940566f, -0.03592841f, 0.08811135f, 0.03209787f, -0.02804640f, 0.07530520f, 0.07578152f, 
    0.09715517f, 0.03083054f, 0.09578569f, 0.04842946f, 0.09999565f, -0.18206635f, 0.29261377f, 0.15680557f, 
    0.06796112f, -0.16015072f, -0.04510804f, 0.06532632f, -0.10497176f, -0.08025240f, -0.00423288f, -0.03210119f, 
    0.15439016f, 0.12266763f, 0.10025248f, -0.14422770f, -0.01259716f, -0.06902039f, 0.00682131f, -0.00887917f, 
    -0.06218367f, -0.18385349f, -0.06796053f, -0.04895467f, -0.01827179f, -0.02766604f, 0.00896725f, 0.12327255f, 
    -0.03661504f, -0.14231181f, 0.04032012f, 0.05913010f, -0.01905159f, 0.01245303f, -0.04611377f, -0.03612337f, 
    -0.06459352f, 0.01074750f, -0.12173458f, -0.16846634f, 0.04117164f, -0.07866954f, 0.12100823f, -0.02918285f, 
    -0.07590608f, 0.01233730f, -0.03154548f, -0.10267162f, 0.02944601f, 0.04736049f, -0.07499076f, 0.04260315f, 
    0.03516332f, 0.00799637f, 0.06360956f, -0.07269072f, 0.13344483f, -0.03152406f, 0.06422404f, -0.07677006f, 
    -0.03766410f, 0.08868142f, 0.00137936f, 0.07747365f, -0.00778405f, -0.04365068f, 0.01797032f, -0.05319871f, 
    -0.03131758f, 0.05194872f, -0.09883063f, -0.02216157f, 0.03844533f, -0.09520316f, -0.02675759f, -0.03022373f, 
    -0.04990125f, -0.03697880f, 0.02765601f, 0.01059236f, -0.43578392f, 0.07561360f, -0.62724912f, 0.15261561f, 
    -0.01530894f, 0.04943604f, -0.02101411f, -0.02381357f, 0.11725607f, 0.01752114f, 0.02517843f, 0.03133267f, 
    -0.03504094f, -0.01918257f, -0.04439360f, -0.04205242f, 0.01675246f, -0.27673215f, -0.14209910f, -0.03951316f, 
    -0.33777705f, -0.00273756f, -0.08521616f, 0.05644988f, 0.01251420f, 0.01157838f, -0.12860906f, -0.09026776f, 
    -0.00643268f, 0.01100894f, -0.03187701f, 0.03146292f, -0.04416166f, -0.12032305f, -0.07884533f, 0.02638760f, 
    -0.07140051f, 0.01531664f, -0.08605652f, -0.07233301f, -0.02834668f, -0.22172679f, 0.18138894f, 0.10110012f, 
    -0.11173022f, -0.02308038f, -0.00788991f, 0.10227460f, 0.00992170f, -0.10232400f, -0.05006253f, 0.00726091f, 
    -0.02289233f, 0.02023969f, 0.01527294f, -0.00530167f, 0.05467336f, 0.11211993f, -0.03466881f, 0.03435453f, 
    0.11326038f, -0.07706732f, 0.12991627f, 0.33961672f, 0.05798353f, -0.09006570f, -0.12763736f, 0.04930402f, 
    -0.05957398f, -0.08275742f, -0.15128534f, -0.09295805f, -0.00496523f, 0.06541197f, 0.08722949f, 0.05851761f, 
    -0.03264043f, -0.02989726f, 0.01799191f, 0.12451299f, -0.11495230f, -0.34586546f, -0.14323454f, -0.23669194f, 
    -0.28842986f, -0.01456304f, -0.16100150f, -0.01445706f, 0.05464970f, -0.02310019f, 0.01854673f, 0.03325721f, 
    -0.00332551f, -0.06751970f, 0.02739412f, 0.11640409f, -0.01508566f, 0.01401859f, 0.01820890f, -0.07151229f, 
    0.13285793f, -0.02340791f, 0.03248643f, -0.02505108f, -0.00761643f, -0.04374358f, 0.01855576f, -0.10375880f, 
    0.10505611f, 0.00375444f, 0.00087604f, 0.04947920f, -0.04483569f, -0.10713203f, -0.13197400f, 0.02337112f, 
    0.00563345f, 0.04091794f, 0.04808020f, 0.02100736f, -0.21727374f, -0.12121828f, 0.08007154f, 0.02626866f, 
    -0.00201518f, -0.08261722f, 0.03417061f, 0.14342470f, -0.10473032f, 0.02678491f, 0.01745061f, -0.00417255f, 
    -0.18788348f, 0.12548111f, 0.05373048f, 0.04956796f, -0.02267388f, 0.14067706f, 0.01716887f, 0.19306423f, 
    -0.23250334f, 0.13711517f, -0.03524269f, 0.25271738f, 0.15318741f, 0.08190547f, -0.05890119f, -0.01640067f, 
    -0.01118398f, 0.04957387f, -0.11828760f, 0.01264542f, 0.08861441f, -0.08692804f, -0.08664283f, -0.02752668f, 
    0.07455182f, -0.16545950f, -0.00152086f, 0.05453491f, 0.09422984f, -0.01550930f, 0.10056524f, 0.08611370f, 
    0.13487548f, -0.00417589f, 0.03235605f, 0.05065189f, 0.02844024f, 0.04019582f, -0.07728156f, 0.06343384f, 
    0.03220696f, -0.02909437f, -0.05943830f, 0.04084481f, 0.07927538f, 0.10758273f, 0.05738224f, 0.07561684f, 
    0.00031493f, -0.09174056f, 0.28683433f, -0.04346346f, -0.14680123f, 0.05822694f, -0.12039638f, 0.10789936f, 
    0.03664679f, -0.04715134f, -0.03621516f, 0.05730531f, 0.04479576f, -0.02298995f, 0.12544307f, -0.03553952f, 
    -0.12096079f, 0.15678680f, -0.10752367f, 0.02928186f, -0.03668096f, -0.01804237f, 0.10078683f, 0.06560025f, 
    -0.11153542f, -0.08556186f, 0.00542068f, -0.03835810f, 0.00739005f, -0.04319904f, -0.02884913f, -0.02163654f, 
    -0.10076866f, 0.02096313f, 0.02540044f, -0.09353312f, 0.00413839f, -0.06781536f, -0.06956177f, -0.08699388f, 
    0.10029805f, 0.06424563f, 0.02896000f, -0.03500929f, -0.01290042f, 0.03075723f, 0.10303773f, 0.02492600f, 
    -0.03912580f, 0.00162620f, -0.08640103f, 0.12880030f, -0.01986347f, 0.02735406f, -0.05072118f, -0.07554860f, 
    0.01472225f, 0.01224311f, -0.06398397f, 0.04645943f, -0.00596992f, -0.20345432f, -0.14466602f, -0.16493271f, 
    -0.09893336f, 0.01798610f, -0.19219923f, -0.02776064f, -0.18328416f, -0.14825240f, 0.02355307f, 0.01804293f, 
    -0.02460003f, -0.04452096f, -0.05485488f, 0.00968672f, 0.00119655f, -0.00792200f, -0.09552076f, -0.12297223f, 
    -0.19924182f, -0.06460220f, 0.22382689f, -0.05389401f, 0.18504721f, -0.07569814f, -0.09125627f, -0.08759753f, 
    -0.03472643f, -0.02061178f, 0.08515240f, 0.04786243f, -0.04606861f, 0.00142285f, -0.00552390f, 0.03368256f, 
    -0.04978602f, -0.01361679f, 0.05866928f, 0.00249129f, 0.23870231f, -0.31138766f, -0.06043328f, 0.12472996f, 
    0.10932940f, 0.03241478f, 0.01970603f, -0.12842654f, 0.05235004f, -0.04281837f, -0.06305560f, 0.04267484f, 
    0.06808310f, -0.01477429f, -0.00635076f, 0.02757876f, -0.06700365f, -0.06022351f, 0.09394112f, -0.02824946f, 
    -0.08354723f, -0.25981683f, -0.25345245f, 0.04001516f, -0.04495310f, -0.17840202f, -0.26842681f, 0.01266516f, 
    -0.26638430f, -0.12797531f, 0.02666866f, -0.00635255f, -0.08862942f, -0.02388328f, -0.03805003f, 0.03849269f, 
    0.01101927f, 0.00541503f, -0.07793506f, -0.12772249f, 0.08936776f, 0.16304506f, -0.30517834f, 0.36654347f, 
    0.18341050f, -0.10536730f, 0.14220259f, -0.01493520f, 0.33843201f, 0.00537452f, -0.14302263f, 0.07988792f, 
    -0.00969403f, -0.04044070f, 0.08860116f, 0.01160436f, -0.04221939f, 0.21682855f, 0.07022769f, 0.00933554f, 
    -0.35737956f, -0.25806144f, -0.10480022f, -0.01121706f, 0.19783983f, 0.08183472f, 0.13497341f, -0.00350091f, 
    0.03717177f, 0.11131385f, -0.10817287f, 0.10893577f, -0.02249793f, 0.04330671f, -0.00982499f, -0.00860996f, 
    -0.04174849f, -0.02330746f, 0.02635574f, -0.04879141f, 0.17381042f, -0.05817291f, 0.05694620f, -0.03799111f, 
    -0.08034428f, -0.00716187f, 0.04100360f, -0.06274176f, 0.08738885f, 0.01942372f, -0.10209618f, -0.00110215f, 
    0.03951555f, -0.06108392f, -0.08953099f, 0.05751933f, 0.00474651f, -0.01155609f, -0.07084641f, 0.00682890f, 
    -0.16012034f, -0.00312472f, -0.07704323f, 0.17061611f, 0.00296036f, -0.02692676f, -0.18703277f, 0.04214739f, 
    0.05865805f, -0.12331427f, -0.04921477f, 0.05468350f, 0.02050162f, -0.00249055f, 0.07237603f, 0.00292993f, 
    -0.04994053f, 0.09140965f, 0.07987635f, -0.05295583f, -0.09493595f, -0.05467781f, 0.02747450f, 0.15899219f, 
    -0.17963320f, -0.00277979f, -0.07851127f, 0.15473388f, -0.07202009f, 0.04861967f, 0.11501881f, 0.01623599f, 
    0.11241519f, 0.03960324f, 0.02383464f, 0.05007504f, 0.01100421f, 0.06308327f, 0.02250017f, -0.06479116f, 
    -0.04174250f, -0.20935579f, -0.03379100f, 0.08619098f, 0.02649453f, -0.02920154f, -0.00678893f, 0.06891638f, 
    0.10952609f, -0.09673623f, -0.03524679f, 0.03529359f, -0.07457329f, 0.00855489f, 0.02998470f, -0.12775566f, 
    -0.11192157f, 0.08133238f, -0.09906858f, -0.14567301f, 0.01228696f, 0.02975969f, 0.12147865f, 0.19634205f, 
    -0.05793463f, -0.18545835f, 0.06598160f, 0.08747512f, -0.00510107f, 0.08761363f, -0.08567408f, 0.04873442f, 
    -0.00110558f, 0.09757056f, 0.04529537f, -0.11059711f, 0.04429768f, 0.14291772f, -0.07606574f, -0.21073593f, 
    -0.19224998f, -0.52127773f, -0.09082490f, 0.10280831f, 0.08968335f, 0.10690615f, -0.29879656f, 0.22227986f, 
    -0.17057845f, -0.03629041f, 0.04646046f, -0.05777325f, 0.00051373f, -0.00108237f, -0.10102807f, 0.03774745f, 
    -0.09179824f, 0.01950471f, -0.04922342f, -0.06147967f, 0.20241301f, -0.41062263f, 0.23315728f, -0.36271355f, 
    0.10938460f, 0.03698843f, 0.02166583f, -0.05956952f, 0.16494378f, -0.01621868f, -0.09956697f, 0.02252796f, 
    0.00084840f, 0.06553756f, 0.02842649f, 0.06055501f, 0.15202607f, 0.06585724f, -0.11069057f, 0.03939110f, 
    0.06166140f, 0.21920307f, 0.21035808f, 0.16001549f, -0.19381966f, 0.00981590f, -0.12863064f, 0.09327409f, 
    0.00800145f, -0.09173933f, -0.03850001f, -0.06497595f, 0.01020942f, -0.03650589f, -0.01267192f, 0.08045049f, 
    -0.05085330f, -0.08763593f, 0.03055546f, -0.03990444f, 0.11443105f, -0.20223297f, 0.02465781f, -0.29169717f, 
    -0.10914746f, 0.01201116f, 0.00359823f, 0.03562508f, 0.00025661f, -0.05240166f, -0.04124004f, 0.01069746f, 
    0.08970449f, 0.03936660f, 0.01554095f, 0.06180240f, 0.04946787f, -0.00645092f, 0.11375749f, 0.03777846f, 
    -0.22209091f, -0.10982990f, -0.05406854f, -0.20381205f, 0.39489108f, 0.03434949f, 0.18801299f, 0.15116841f, 
    -0.00732388f, 0.21158557f, -0.03990429f, 0.13650021f, 0.10826163f, -0.04871350f, -0.00010073f, 0.13111897f, 
    0.13766463f, 0.00856702f, -0.03657639f, 0.04673871f, 0.26580402f, 0.20613262f, 0.31656173f, 0.01354485f, 
    -0.18230908f, -0.00846335f, 0.00245743f, -0.05376582f, 0.01173212f, -0.05771853f, -0.11320312f, 0.01277903f, 
    0.02872344f, 0.02459278f, 0.04405393f, -0.05866066f, -0.06277549f, -0.06819552f, -0.05263990f, 0.05169172f, 
    -0.37251350f, -0.01749695f, -0.07365277f, 0.28940788f, -0.15076767f, 0.10762870f, -0.05160558f, 0.17940368f, 
    -0.12889037f, -0.01175561f, 0.04130951f, -0.08340121f, 0.07495730f, 0.03368099f, 0.00064792f, 0.07050035f, 
    -0.08457001f, 0.00930405f, 0.06904686f, -0.13288414f, 0.27847901f, 0.07517190f, 0.27987632f, -0.13330887f, 
    -0.13500734f, 0.07132482f, 0.08096530f, -0.02889233f, 0.07533236f, -0.01261313f, -0.01478848f, 0.05946059f, 
    0.02647759f, -0.03632607f, -0.02041058f, 0.03824075f, 0.09410097f, -0.05353771f, -0.03186328f, 0.00490530f, 
    0.53794706f, 0.11684223f, 0.49638411f, 0.03767347f, -0.09654851f, -0.01518142f, 0.00743823f, -0.21252005f, 
    0.06651264f, -0.10359576f, -0.15000029f, 0.01504244f, -0.00075845f, -0.04063082f, -0.08041181f, -0.00922204f, 
    0.04053500f, -0.10195543f, 0.09568218f, 0.12769884f, -0.41917837f, 0.06651492f, -0.44357818f, 0.31247514f, 
    0.00862023f, -0.02871883f, 0.17532617f, 0.00947171f, 0.20044319f, 0.03019412f, -0.09797347f, -0.12790254f, 
    0.01434544f, 0.06705840f, 0.01044746f, 0.01136969f, -0.01574915f, 0.06471868f, -0.14737220f, 0.05060461f, 
    -0.25154752f, 0.10424909f, -0.11042578f, -0.02069445f, -0.01743726f, -0.00707271f, 0.11159748f, -0.01190277f, 
    -0.02231647f, -0.03204130f, -0.18166253f, -0.05692162f, 0.07561691f, 0.09689286f, 0.08965909f, 0.04842494f, 
    -0.09680817f, -0.04265301f, -0.03131379f, 0.07123587f, -0.60665661f, -0.03737294f, -0.39062464f, 0.15584981f, 
    -0.39720127f, 0.12318541f, 0.11727951f, 0.12034179f, -0.12088906f, 0.10440210f, -0.11445615f, -0.17701203f, 
    0.10788187f, 0.03519784f, 0.03455533f, -0.02188901f, 0.01782028f, 0.02428572f, 0.04299906f, 0.06497541f, 
    0.03598824f, -0.36191565f, 0.08120415f, -0.06699750f, -0.01050668f, 0.10100478f, 0.10819207f, 0.10569837f, 
    -0.04458989f, -0.06961546f, -0.00131019f, -0.05542162f, 0.09541865f, 0.11246841f, 0.07564452f, 0.03839179f, 
    0.06003977f, 0.09015258f, -0.04117679f, 0.05389480f, -0.11522111f, -0.15908955f, -0.04865751f, 0.15153582f, 
    0.07985172f, -0.06643215f, 0.04004524f, 0.06700072f, 0.08794867f, -0.09779314f, -0.01696558f, 0.02739058f, 
    -0.02819252f, -0.09117635f, 0.03439469f, -0.06926555f, -0.06032389f, -0.01645085f, -0.06096177f, -0.02724284f, 
    -0.36342290f, -0.22509983f, -0.36556095f, -0.08420660f, 0.24265373f, 0.04814080f, 0.18490927f, 0.17784303f, 
    -0.24868773f, 0.06060980f, 0.07726114f, 0.13407736f, 0.00156303f, 0.16020344f, 0.23468187f, 0.05056304f, 
    0.10019781f, 0.08850599f, -0.02870051f, 0.04955343f, -0.15744524f, 0.06102649f, -0.07860946f, 0.08096270f, 
    -0.00224337f, -0.06818495f, 0.06899796f, -0.03162532f, 0.04748569f, 0.04810937f, 0.02896253f, -0.02739817f, 
    0.10051560f, 0.00363104f, -0.04994825f, 0.08640578f, -0.09575732f, 0.11221893f, 0.11076029f, -0.08151501f, 
    0.21847758f, 0.10377792f, 0.19191994f, -0.00934464f, -0.02445915f, -0.02385835f, 0.01258641f, 0.02094672f, 
    -0.12647654f, -0.06816680f, -0.07930803f, 0.06420223f, -0.02304881f, 0.01874345f, -0.06897621f, -0.04962393f, 
    -0.12496252f, -0.13325024f, -0.10850374f, 0.07455235f, 0.03541711f, 0.11630491f, -0.20050289f, 0.05289413f, 
    -0.27552065f, 0.19517475f, 0.08063599f, -0.00347142f, -0.05512812f, 0.02048097f, -0.02057821f, -0.09533945f, 
    0.03347103f, 0.19663069f, 0.00173276f, -0.01910186f, 0.02488338f, 0.04328692f, -0.06540462f, 0.13507858f, 
    -0.37538299f, 0.15181148f, 0.02527152f, 0.26307416f, -0.00472419f, -0.05219033f, 0.06337819f, 0.12059336f, 
    -0.03136897f, 0.14646102f, -0.03472159f, -0.04290287f, 0.13060236f, 0.08349875f, -0.04920731f, 0.02165321f, 
    -0.01645544f, 0.14147674f, -0.05006777f, -0.07620164f, -0.53825408f, -0.45313987f, -0.20935528f, 0.38011009f, 
    -0.29487440f, 0.05081610f, 0.09287880f, -0.10130598f, 0.19662565f, -0.21745373f, -0.15574381f, -0.02913285f, 
    0.02323391f, 0.08794601f, 0.00845786f, 0.15415812f, -0.04305487f, 0.14938822f, 0.09869000f, 0.19484524f, 
    -0.05683418f, 0.00403965f, -0.06171202f, 0.00783885f, -0.01693960f, 0.04232746f, 0.00997914f, 0.04506752f, 
    -0.02130884f, 0.01908837f, 0.01012804f, -0.01846647f, -0.03911568f, 0.03607115f, 0.02351752f, 0.06441315f, 
    -0.03085286f, 0.01957295f, -0.06417930f, -0.02139404f, 0.05538217f, 0.00937107f, 0.02072622f, 0.05037616f, 
    -0.04742227f, -0.05950550f, 0.04341144f, -0.03974801f, 0.08993268f, 0.06303433f, -0.08967443f, 0.02355686f, 
    -0.05307120f, -0.11611733f, 0.04821537f, 0.11082128f, 0.01021524f, 0.05244317f, 0.03598155f, -0.20810136f, 
    0.17595710f, -0.06280350f, -0.00074558f, 0.09390928f, 0.10031245f, -0.06270110f, -0.02865875f, -0.06086162f, 
    -0.03960796f, 0.00903977f, 0.06921651f, 0.11199228f, 0.01306572f, 0.05997277f, 0.01064700f, 0.03116647f, 
    -0.05058672f, -0.03441515f, -0.09030530f, 0.16451007f, 0.00695702f, -0.14277202f, -0.02081939f, 0.12420199f, 
    0.14611682f, 0.03013712f, 0.01102408f, 0.03847318f, -0.03522889f, -0.18988673f, -0.08084663f, -0.10578494f, 
    -0.03669619f, -0.02295320f, -0.03300379f, 0.13282417f, -0.00953833f, 0.06160486f, -0.02141662f, 0.00869174f, 
    -0.26937249f, -0.12063557f, -0.10927536f, 0.12415362f, -0.03153004f, 0.12708417f, 0.05080000f, 0.18035500f, 
    -0.18824244f, 0.01400911f, 0.04824590f, -0.01319161f, 0.14758080f, 0.08079758f, 0.08346067f, 0.04319787f, 
    -0.00992518f, 0.10514847f, 0.16116895f, 0.06983076f, -0.26793027f, -0.13280630f, -0.19717540f, 0.00722225f, 
    0.02225156f, 0.10170692f, 0.08048088f, 0.07109226f, -0.04508222f, 0.08293691f, -0.02191874f, -0.05445852f, 
    0.04354592f, 0.09647732f, 0.13260892f, 0.02382069f, -0.03430555f, -0.03554580f, 0.03052856f, 0.00376415f, 
    0.12694080f, -0.31513745f, -0.29969606f, -0.03043596f, 0.24583100f, -0.28547400f, -0.32383344f, -0.10985166f, 
    0.06945454f, -0.07062925f, 0.08093154f, -0.01238637f, 0.07204556f, -0.12806915f, -0.06755688f, 0.07559652f, 
    -0.05608435f, -0.00096761f, 0.12602647f, -0.04349416f, 0.05434062f, -0.21269722f, -0.12468669f, -0.30537361f, 
    0.10466059f, -0.13623202f, -0.27721578f, -0.10195856f, 0.08377712f, -0.12817463f, 0.01257306f, 0.00810863f, 
    0.05196939f, -0.00947023f, -0.03091741f, 0.01576591f, 0.02926781f, -0.07690449f, 0.19447319f, -0.02055958f, 
    0.05864541f, -0.23816447f, 0.06757513f, 0.02911797f, 0.05900624f, -0.06576270f, -0.30095831f, -0.01237116f, 
    -0.02086207f, -0.16865765f, -0.01098095f, -0.01253408f, 0.03147143f, 0.01974394f, -0.03994736f, 0.01904287f, 
    -0.02144511f, -0.01084868f, 0.21497491f, 0.02262762f, -0.13540639f, 0.22031139f, -0.36003834f, 0.31856102f, 
    0.26257059f, -0.03317348f, 0.07292904f, -0.02040825f, 0.09291050f, 0.05323196f, -0.04810913f, 0.02938865f, 
    -0.04977304f, 0.02589336f, 0.03719081f, 0.04085584f, -0.03478818f, 0.01780304f, 0.01531593f, 0.03743846f, 
    0.03230746f, -0.22121814f, 0.09883286f, -0.08866695f, 0.02577946f, 0.09488080f, 0.05359813f, -0.07446845f, 
    0.00193112f, -0.06170956f, -0.02719294f, 0.01080854f, -0.00295407f, -0.06460450f, 0.02329547f, -0.04563386f, 
    0.02896204f, -0.01205312f, -0.07029025f, -0.10546546f, -0.11734548f, 0.01601519f, -0.05416105f, 0.21670611f, 
    -0.08298184f, -0.08384773f, -0.11330686f, 0.12760223f, -0.15758552f, -0.00697588f, -0.04436727f, -0.01734732f, 
    -0.15806067f, -0.00916988f, -0.01878347f, -0.00114510f, -0.11303154f, -0.05236039f, -0.09271585f, -0.17608406f, 
    -0.30862570f, -0.02068978f, -0.02469760f, 0.39653170f, -0.05545924f, 0.03875919f, -0.11773529f, -0.00024185f, 
    -0.04917881f, 0.06613960f, -0.04366646f, -0.03112911f, -0.08084363f, -0.01754583f, -0.08108049f, 0.06860932f, 
    -0.00478102f, 0.04720213f, 0.04202311f, -0.04777293f, 0.00143737f, -0.23681763f, -0.15653725f, -0.07251307f, 
    -0.05048101f, 0.01300350f, -0.21804093f, -0.15905619f, -0.21678635f, -0.10412452f, 0.00429570f, 0.03020585f, 
    -0.09447885f, -0.02288214f, -0.05272602f, -0.02281776f, -0.00731679f, 0.09625686f, -0.07948606f, -0.14474542f, 
    -0.01606832f, -0.29804683f, -0.06143456f, 0.40677109f, 0.10727072f, -0.03908114f, 0.06569682f, 0.03050060f, 
    0.23136543f, -0.08946501f, -0.08518879f, 0.03264177f, -0.08441719f, 0.02306418f, 0.06410056f, -0.13890184f, 
    -0.05248454f, 0.13697065f, 0.02606398f, 0.00545212f, -0.26596001f, -0.16971193f, -0.09105782f, 0.02060187f, 
    -0.27227855f, 0.03395213f, -0.05384223f, -0.16749401f, 0.00894759f, -0.03220041f, -0.03700739f, -0.02575283f, 
    -0.02254188f, -0.08909426f, -0.05406531f, 0.01395761f, -0.02765395f, -0.02549211f, 0.01959661f, 0.02674509f, 
    0.01885707f, -0.15507352f, -0.27364895f, -0.06504079f, 0.17432490f, 0.07685564f, 0.08680226f, -0.09697770f, 
    -0.08773595f, -0.05986802f, 0.04986116f, 0.08742499f, -0.04176611f, -0.02053829f, -0.06236274f, 0.06608862f, 
    -0.07701600f, 0.01192557f, -0.19802675f, -0.06309574f, -0.02462568f, 0.04875627f, -0.13115862f, 0.01447422f, 
    0.15473263f, -0.04760296f, 0.10952619f, -0.01284839f, 0.01070354f, 0.04541782f, -0.11573415f, 0.08796621f, 
    -0.11861645f, 0.06383882f, 0.03069023f, 0.06816678f, -0.05570561f, 0.16079023f, -0.01480641f, 0.10715791f, 
    -0.07976519f, -0.07562620f, -0.43687111f, -0.05377962f, 0.01170184f, -0.19898573f, -0.06068532f, 0.05835319f, 
    -0.07874145f, -0.06254197f, -0.00411009f, 0.08608498f, 0.07417701f, 0.00743260f, -0.03729159f, 0.09108906f, 
    -0.02108158f, -0.04169539f, 0.05459487f, 0.06107597f, -0.23898186f, 0.05749581f, -0.07757119f, 0.06579236f, 
    -0.04621290f, 0.09884621f, -0.00044676f, 0.13562989f, -0.10661720f, 0.04542768f, -0.01374554f, -0.05197031f, 
    -0.07565448f, 0.04547820f, 0.03161402f, 0.00535005f, -0.03012318f, 0.00732955f, 0.09370909f, -0.12600571f, 
    -0.19290224f, 0.06500094f, -0.18296117f, 0.11594229f, -0.16177049f, 0.01732983f, 0.02101953f, 0.04284516f, 
    0.04028692f, 0.01454972f, -0.01031646f, -0.01212502f, 0.02962704f, 0.03842502f, -0.07491972f, -0.03151140f, 
    0.01929239f, -0.01225240f, -0.09467418f, 0.01500406f, -0.30316225f, -0.25907424f, -0.12950796f, 0.23489377f, 
    -0.21397206f, -0.02202114f, -0.13562927f, -0.05657919f, -0.03405917f, -0.15082374f, -0.02579482f, 0.05154982f, 
    -0.00377028f, 0.06864735f, -0.03886337f, 0.13169684f, 0.00490885f, 0.15917242f, 0.07780776f, -0.11345851f, 
    -0.08651097f, -0.09376207f, -0.21927097f, -0.01875566f, -0.36665845f, -0.09202289f, 0.14572565f, 0.02240652f, 
    -0.11259986f, 0.01020877f, -0.02790790f, 0.02524978f, 0.12342995f, 0.06715223f, -0.06950044f, -0.03249721f, 
    0.10784332f, 0.05428053f, 0.06825662f, 0.07073578f, 0.18171658f, 0.06776360f, 0.02629449f, 0.14676411f, 
    0.06715731f, -0.02087457f, 0.14430815f, -0.05267698f, 0.04461751f, 0.00375066f, -0.10602994f, 0.04558164f, 
    0.00932076f, -0.03952932f, -0.01482318f, 0.07292910f, -0.02584066f, -0.02992077f, -0.03810176f, 0.05074955f, 
    0.22291511f, -0.08751455f, 0.34581923f, -0.10581275f, -0.11362540f, 0.00756643f, 0.00659306f, -0.07085682f, 
    0.15026861f, 0.08757877f, 0.07757317f, -0.03969469f, 0.03432314f, -0.01624976f, -0.03873501f, -0.04131889f, 
    0.12786974f, 0.11281301f, 0.15142146f, -0.28903350f, -0.09561855f, -0.05217829f, -0.03180953f, -0.05456157f, 
    -0.07745348f, -0.03132929f, -0.00995220f, 0.04285827f, 0.04210046f, -0.03989814f, -0.13065070f, -0.02772880f, 
    -0.00759071f, -0.02661937f, -0.04381667f, 0.03877212f, 0.01816231f, -0.00194556f, -0.13277619f, -0.04105738f, 
    -0.24334872f, -0.12318603f, -0.21053432f, 0.07288723f, -0.18112911f, 0.02702458f, -0.03786960f, -0.05115087f, 
    -0.01095191f, -0.02332446f, -0.09397944f, -0.06068254f, -0.01475444f, -0.09410504f, -0.09021579f, 0.01513803f, 
    -0.05819261f, -0.03807925f, -0.06747551f, 0.03326464f, -0.05126897f, -0.00314448f, 0.06038602f, 0.03755710f, 
    0.00149785f, 0.14053917f, -0.06525751f, 0.09868781f, -0.02844988f, -0.03975051f, 0.13980839f, 0.00778189f, 
    0.00133580f, -0.01908463f, -0.05637658f, 0.07637538f, -0.04311720f, -0.06357160f, -0.19330361f, -0.04799924f, 
    -0.26961651f, -0.01899616f, 0.15296201f, 0.20453335f, -0.26564351f, 0.02314206f, -0.12671286f, 0.04837295f, 
    -0.01376495f, 0.04477458f, -0.02814002f, -0.04908121f, -0.06548265f, -0.08198924f, 0.02845796f, 0.08494272f, 
    0.00412002f, 0.07103899f, 0.07974477f, -0.05265445f, -0.29618275f, -0.11923325f, -0.16667144f, 0.25883824f, 
    -0.01084479f, -0.05939808f, -0.03248747f, -0.08666274f, -0.02606811f, 0.07709929f, -0.00352303f, -0.04929688f, 
    -0.05292443f, -0.10200147f, -0.09550620f, 0.00041125f, -0.08191151f, -0.07674122f, -0.03899468f, -0.03457796f, 
    0.26854891f, -0.03031160f, 0.06116433f, 0.44305447f, 0.15427990f, -0.04270567f, 0.15345815f, -0.13451776f, 
    0.14811982f, 0.08732976f, -0.07368973f, -0.05606034f, 0.05697770f, 0.05237268f, 0.00128563f, -0.08574773f, 
    0.03672306f, 0.01229008f, 0.02195695f, 0.02969539f, -0.10655726f, 0.10933883f, -0.11163744f, 0.07397284f, 
    0.07634716f, -0.04194854f, -0.00874621f, 0.02258817f, -0.06228096f, -0.02679089f, -0.08482442f, -0.03080611f, 
    -0.02271492f, -0.01858949f, -0.02970450f, 0.08987988f, 0.02610482f, 0.06400712f, 0.05912188f, -0.06820331f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.10999774f, 0.05241625f, 0.03588650f, -0.07677901f, -0.02224982f, 0.06342950f, 0.01372507f, -0.05501036f, 
    0.01009250f, 0.03613971f, 0.00943617f, -0.01575189f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 5120);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
