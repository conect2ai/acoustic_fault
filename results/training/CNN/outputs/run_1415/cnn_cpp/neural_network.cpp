#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.75973952f, -0.58455622f, -0.34316358f, 0.17861728f, -0.25276181f, 0.38125485f, -0.48558819f, 0.32788816f, 
    0.35026896f, 0.67982703f, 1.03067625f, -0.39864808f, -0.24703890f, 0.22745122f, -0.65278882f, 0.08065207f, 
    0.10854576f, 0.14317134f, -1.03573191f, 0.18031608f, 0.22396615f, 1.07818079f, -0.41863540f, -0.68698144f, 
    -0.13445482f, -0.35454398f, -0.11338290f, -0.88597864f, -0.48359662f, -0.49141553f, 0.17397128f, -0.09436269f, 
    -0.38427594f, 0.35240617f, -0.27503690f, 0.37747601f, 0.21601115f, -0.30056679f, -0.28803566f, -0.53936332f, 
    -0.19201274f, -0.61720449f, 0.34994569f, 0.64533967f, 0.77189541f, -0.37933901f, 0.42920545f, -1.25182652f, 
    0.26515847f, 0.86827660f, -0.24906045f, 0.32410592f, -0.18252026f, 0.03897270f, 0.58885205f, 0.06021952f, 
    0.73984301f, -0.23350327f, 0.23514582f, 0.54587382f, 0.10138994f, 0.03145711f, 0.20962206f, -0.79214525f, 
    -0.74950695f, -0.35097021f, 0.71673399f, 0.34008068f, -0.04106061f, -0.43860108f, -0.16231215f, -0.58792704f, 
    0.95013273f, -0.35451093f, -0.19062947f, 0.39718759f, 0.43511820f, -0.29294765f, -0.39244181f, -0.13626769f, 
    -0.44799852f, 0.49279568f, 0.29415959f, 0.34577462f, 0.20907781f, -0.16738895f, -0.39660516f, -0.48720232f, 
    0.37912831f, 0.27692199f, -0.00277677f, 0.48432437f, 0.40589255f, -0.30102652f, -0.67083055f, -0.90180838f, 
    -0.26248622f, -0.36801702f, -0.40568483f, -0.50121194f, -0.10409682f, 0.78189236f, 0.64683980f, 0.04308257f, 
    0.35081342f, 0.43455330f, 0.45212460f, 0.22964001f, 0.34687722f, 1.10361195f, -0.63169444f, 0.19848321f, 
    -0.54823083f, -0.17522942f, -0.12000364f, 0.27656937f, 0.07249418f, -0.51190805f, 0.67424542f, -0.58410245f, 
    -0.61374873f, -0.58898097f, -0.74334228f, 0.22996345f, 0.13939399f, -0.34649858f, 0.02455696f, 0.25687099f, 
    0.33422977f, -0.07432490f, 0.47353011f, 0.52998841f, -0.37536380f, -0.71471757f, 0.49284235f, -0.40263659f, 
    0.52471650f, 0.10281380f, -0.14964208f, -0.43509263f, -0.06019047f, 0.51388633f, -0.13016586f, 0.71706438f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.20759641f, 0.29264206f, 0.26889578f, 0.49203977f, -0.10502037f, -0.07581231f, 0.52966511f, 0.20466165f, 
    0.07751738f, 0.42024714f, -0.14694518f, -0.26729140f, 0.17988303f, 0.24167284f, -0.12983319f, 0.12030213f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.51931185f, 0.38406616f, -0.04557892f, -0.13102888f, -0.07228765f, 0.00293781f, 0.02288706f, 0.02303028f, 
    -0.20606525f, 0.40368912f, -0.23625687f, 0.11471858f, 0.02363650f, 0.02608441f, 0.11781559f, -0.03811878f, 
    0.02418049f, -0.06911094f, -0.22908774f, -0.04111390f, 0.25845477f, -0.06141221f, 0.13744396f, 0.03772501f, 
    -0.10471029f, 0.05738308f, -0.13022909f, -0.35964176f, 0.36916777f, 0.18570431f, -0.00782805f, 0.19088857f, 
    -0.06380482f, 0.05555705f, 0.22765790f, -0.01784006f, 0.17992142f, 0.07623844f, -0.38022801f, 0.03976045f, 
    0.02717926f, 0.03113175f, -0.06071214f, -0.07698105f, -0.09273773f, -0.46766177f, 0.10707425f, -0.00223070f, 
    -0.06477600f, -0.11802914f, 0.17189974f, -0.05394649f, -0.15159261f, -0.05840972f, 0.18939601f, 0.18694410f, 
    0.02340691f, 0.02657232f, 0.08107291f, -0.06041195f, -0.04055014f, 0.07260354f, 0.00664738f, -0.11208409f, 
    0.15327708f, -0.13690719f, 0.16462214f, -0.00892122f, -0.18071716f, -0.22184284f, 0.09434199f, 0.25367409f, 
    0.06068388f, -0.07928521f, 0.17529754f, 0.11646324f, 0.03350620f, 0.23878174f, 0.12679796f, 0.05509810f, 
    0.18461162f, 0.29695025f, -0.04872240f, 0.04439030f, 0.02692639f, 0.07250979f, 0.00044102f, 0.20684780f, 
    0.18456978f, 0.03765028f, -0.37401292f, -0.30105954f, -0.27335650f, 0.05314574f, 0.09129090f, -0.00555876f, 
    0.04315314f, 0.06905900f, 0.15919867f, -0.25444347f, 0.00811454f, 0.29193434f, -0.02251576f, -0.03345264f, 
    0.05382143f, 0.00212002f, -0.00543250f, 0.03351996f, 0.40071878f, -0.06084818f, 0.24335329f, -0.04700744f, 
    -0.10731454f, 0.06020615f, 0.08845414f, -0.00463255f, -0.12266353f, -0.55344856f, -0.29823685f, -0.38012144f, 
    -0.04818482f, -0.03823916f, 0.02061010f, -0.06059637f, 0.05867639f, -0.08065839f, -0.20802012f, 0.19029945f, 
    0.17425913f, 0.02791779f, -0.21670650f, -0.12130068f, 0.08117198f, -0.06125689f, 0.01693791f, -0.13657455f, 
    0.10502774f, 0.11728930f, 0.02528242f, 0.03113098f, 0.05233565f, -0.01698628f, -0.28738090f, -0.14500666f, 
    0.06749070f, -0.26899239f, 0.10995494f, -0.00497435f, 0.00879514f, -0.16806041f, 0.23217499f, -0.06834780f, 
    0.07720835f, -0.20114149f, -0.09580141f, -0.28245112f, 0.04021914f, 0.25444740f, 0.02955651f, 0.19400693f, 
    0.04769497f, 0.04738916f, -0.23875061f, -0.07740542f, 0.32023874f, 0.01716077f, 0.15036014f, -0.09623381f, 
    0.02578451f, -0.24629569f, -0.11507788f, -0.07144530f, 0.03073231f, 0.05893358f, 0.05262470f, 0.18036148f, 
    -0.04228028f, 0.13372579f, -0.08068591f, -0.04349328f, -0.09443447f, 0.00050704f, 0.05431776f, 0.00340776f, 
    0.09716970f, -0.08879239f, 0.12976468f, 0.09817097f, -0.01338916f, -0.20622113f, 0.37859306f, 0.21302362f, 
    -0.18859194f, 0.04002383f, 0.21544993f, -0.10563624f, 0.24166718f, 0.09577680f, -0.38864142f, -0.12706043f, 
    0.09739533f, 0.07791004f, 0.14218473f, -0.01621843f, 0.00084406f, -0.13626410f, 0.05531896f, -0.18245053f, 
    0.00721850f, 0.00531467f, 0.10020273f, -0.00482043f, -0.07194192f, -0.04340640f, -0.20665587f, -0.19692822f, 
    0.17066678f, -0.17056589f, -0.18267277f, 0.04435819f, -0.18072923f, 0.16157681f, -0.24263649f, -0.06292029f, 
    -0.21332015f, -0.10846125f, -0.40077245f, -0.00540161f, -0.08661271f, 0.15041675f, 0.05851384f, 0.07659691f, 
    0.04295639f, 0.03219774f, -0.15523073f, -0.26475155f, 0.06570336f, 0.18463527f, -0.07633206f, -0.01990234f, 
    -0.06038276f, -0.07729676f, -0.02656846f, -0.14971726f, 0.07472792f, -0.09248882f, 0.32468486f, -0.13702677f, 
    -0.19761322f, -0.05961226f, 0.13320489f, -0.03626370f, 0.02908086f, -0.02618850f, -0.06864356f, 0.09795181f, 
    0.20384350f, -0.08218083f, -0.09094699f, 0.18885073f, 0.14194240f, -0.08321805f, 0.39291680f, 0.29807058f, 
    0.04747433f, 0.26290357f, 0.19589679f, -0.04243512f, 0.17151645f, 0.07800215f, -0.12025645f, -0.05219259f, 
    -0.00415923f, -0.12706091f, -0.00850363f, -0.02151539f, 0.05859173f, 0.04677809f, -0.10782638f, -0.01341076f, 
    0.39055720f, 0.02459296f, 0.13051039f, 0.16708891f, 0.08058777f, 0.02914818f, 0.20692264f, -0.04533286f, 
    0.13815029f, 0.29570222f, -0.15129836f, 0.03555148f, 0.10254131f, 0.02139235f, -0.05327297f, 0.05030120f, 
    0.15624361f, 0.07126693f, -0.07100374f, -0.10260058f, 0.07229237f, 0.18690085f, 0.11748867f, -0.01756878f, 
    0.04831674f, -0.01437297f, -0.31039542f, -0.08422027f, -0.02153955f, -0.01261256f, -0.03904264f, 0.02132224f, 
    0.10817895f, 0.12426417f, 0.00510216f, -0.27556869f, 0.20797175f, 0.45988080f, 0.08207327f, 0.02796236f, 
    -0.06314459f, 0.00511959f, 0.11338655f, 0.14250490f, -0.03288675f, -0.14307411f, -0.35076496f, -0.14073813f, 
    -0.22190413f, -0.19308385f, 0.07317696f, 0.10733072f, -0.13695078f, -0.42216793f, 0.09740072f, -0.05866915f, 
    -0.09689357f, 0.06158349f, 0.16671091f, -0.08799447f, 0.00048173f, 0.04974828f, 0.19066601f, -0.03358382f, 
    -0.06463379f, 0.07231536f, 0.23728429f, -0.00675129f, 0.08231994f, 0.14002627f, 0.14553522f, 0.14279620f, 
    0.20440002f, 0.32821742f, -0.05277299f, -0.14464250f, 0.20456098f, -0.09748104f, 0.05154807f, 0.05575291f, 
    -0.47844625f, -0.17750444f, -0.26567519f, -0.17628074f, -0.10979481f, -0.07290938f, -0.05613251f, 0.02900524f, 
    0.21337020f, -0.12303007f, -0.07850213f, 0.28554228f, 0.16382539f, 0.16873623f, -0.16302843f, 0.06000303f, 
    -0.08857655f, 0.10232932f, -0.51858914f, -0.49611452f, -0.05904248f, 0.12072819f, 0.09816458f, -0.01681542f, 
    -0.09035189f, -0.07509526f, 0.06633056f, -0.13897435f, -0.16101344f, -0.14379105f, 0.04188972f, -0.00794972f, 
    0.06352685f, 0.01392269f, 0.02523595f, 0.04733894f, 0.08625830f, -0.12042043f, -0.01399490f, 0.06232537f, 
    0.08478714f, -0.09824865f, 0.36602005f, -0.04535270f, 0.03089428f, -0.04406117f, -0.25131091f, -0.56234193f, 
    -0.08306170f, -0.01869398f, 0.03396242f, 0.17528526f, 0.21031973f, -0.05549764f, -0.01666362f, -0.07336403f, 
    0.05591473f, -0.23263177f, -0.17009999f, 0.03892231f, 0.01707283f, -0.07248408f, 0.08945587f, -0.07973243f, 
    -0.58588743f, -0.56533599f, 0.14869210f, 0.06770698f, -0.03222241f, 0.31259879f, -0.00715590f, 0.00065647f, 
    -0.03369985f, 0.12954681f, -0.18879880f, 0.11753688f, 0.04652370f, -0.00783748f, 0.08375270f, 0.08159053f, 
    0.05087909f, -0.38089001f, -0.21478528f, -0.08562484f, -0.26425317f, -0.18535997f, 0.08375517f, -0.01386137f, 
    0.04165656f, 0.02733234f, 0.43317226f, 0.51329410f, -0.04548806f, -0.11318181f, 0.06008546f, 0.15608776f, 
    0.09780550f, 0.09987520f, 0.18031260f, 0.27909487f, 0.09159856f, -0.08832642f, 0.08555099f, 0.04812044f, 
    0.06667665f, 0.08354091f, 0.06711606f, -0.04939222f, 0.19935550f, 0.43089402f, -0.11651132f, 0.19489095f, 
    0.01730185f, 0.17932144f, 0.03861721f, 0.07474566f, 0.13620380f, -0.23519030f, -0.36067575f, -0.70042574f, 
    0.16614072f, 0.07112915f, 0.08738630f, 0.01675157f, 0.10003021f, -0.02958208f, 0.10852618f, -0.20144652f, 
    -0.27859938f, 0.10714223f, -0.04543103f, -0.05240825f, 0.10857692f, 0.17981960f, 0.17193082f, 0.32759249f, 
    0.13981281f, -0.10406924f, 0.10248148f, 0.03598015f, 0.01672053f, -0.12321232f, 0.10609265f, -0.09760839f, 
    0.21265522f, 0.11514524f, 0.09013235f, -0.13435699f, -0.06244473f, -0.10854802f, -0.07159903f, -0.20587282f, 
    -0.20769343f, -0.10077014f, -0.27828938f, 0.28114417f, -0.04743424f, 0.02135805f, -0.06228882f, 0.03841689f, 
    0.07855261f, -0.08948251f, -0.18540971f, 0.04020379f, 0.06322824f, -0.20217675f, -0.16337837f, -0.15303373f, 
    0.09422524f, 0.05205217f, 0.16042936f, 0.14255665f, -0.07566740f, -0.30033538f, -0.07131080f, 0.02751430f, 
    -0.08047606f, 0.06259782f, -0.00069555f, -0.14155914f, -0.40141580f, -0.00616456f, -0.11662913f, -0.08218583f, 
    -0.07324824f, -0.08516545f, 0.05368486f, 0.00491980f, -0.02772877f, 0.25016221f, 0.20885664f, -0.02088383f, 
    -0.01638950f, -0.11277130f, -0.00944595f, -0.00077117f, -0.14381543f, 0.15687539f, 0.07029042f, -0.13370822f, 
    -0.08651778f, 0.18221392f, -0.07308286f, -0.18004428f, 0.01727978f, 0.18296994f, 0.09738404f, 0.11516177f, 
    0.15961790f, 0.16735092f, 0.00945697f, -0.10149342f, -0.06435503f, 0.02443056f, 0.16534387f, 0.19566950f, 
    -0.07161980f, -0.01636738f, 0.04466069f, -0.05427792f, -0.07300895f, 0.01657471f, -0.07213265f, -0.05143744f, 
    0.00412750f, -0.07785261f, 0.07348356f, -0.02213588f, 0.00013968f, -0.06037292f, 0.06428704f, 0.06054448f, 
    0.01631716f, -0.01930871f, -0.04993204f, 0.06151094f, -0.03309477f, -0.01328237f, -0.05176231f, 0.03993139f, 
    -0.05689771f, 0.04497655f, 0.01325732f, -0.02507288f, -0.07808387f, -0.08847325f, -0.02577805f, -0.06629448f, 
    -0.01750480f, -0.08435814f, 0.03954337f, -0.07917486f, -0.04578850f, 0.04279803f, -0.04146058f, 0.01202749f, 
    -0.02127172f, 0.02669663f, 0.00863048f, 0.05844413f, -0.05874219f, -0.04838227f, -0.06229270f, -0.00483117f, 
    -0.01088376f, 0.04880179f, 0.04221302f, 0.03630983f, -0.05361441f, -0.07454542f, -0.05579091f, -0.03508992f, 
    -0.04450537f, -0.03471657f, 0.02159394f, -0.02277681f, 0.01606055f, -0.01625071f, -0.01401695f, -0.04595817f, 
    -0.01715337f, 0.00147058f, -0.08250804f, 0.06648357f, -0.04861549f, -0.04678356f, 0.05916241f, -0.06092546f, 
    0.03108846f, 0.01572668f, 0.03619597f, -0.04704104f, -0.01428829f, -0.00982151f, 0.04385800f, 0.01832722f, 
    -0.04213429f, -0.04903655f, 0.06340831f, -0.08205853f, -0.08254369f, 0.02583080f, 0.00269844f, -0.04173954f, 
    0.04546716f, -0.05306326f, -0.07464675f, 0.05568192f, 0.08252926f, 0.01998078f, 0.07079709f, -0.07962140f, 
    0.06972598f, -0.06607401f, -0.01292269f, -0.05526447f, 0.06457255f, 0.05405372f, -0.05063219f, 0.02501357f, 
    -0.08237670f, 0.03980165f, -0.03339875f, 0.05179741f, -0.06903102f, -0.06740177f, -0.00010113f, 0.05270590f, 
    -0.07352793f, 0.03265961f, 0.01297424f, -0.01498368f, 0.02090218f, 0.02524284f, 0.05935552f, 0.04476338f, 
    -0.04554791f, -0.02043531f, 0.03564650f, -0.03290849f, -0.00897464f, -0.04379681f, 0.04687575f, 0.05462604f, 
    -0.04286218f, 0.05627458f, -0.06151135f, 0.03760508f, -0.08838334f, -0.00067408f, 0.01515075f, 0.02372834f, 
    0.03047645f, -0.09608345f, -0.07821220f, -0.08921783f, -0.01323157f, 0.00632651f, -0.00132599f, 0.00988472f, 
    -0.07652054f, 0.05762314f, -0.10921289f, 0.10567919f, 0.06388476f, 0.13473806f, 0.07266730f, 0.08019133f, 
    -0.04619860f, 0.14707589f, -0.05015482f, -0.05426245f, 0.30312252f, -0.07675288f, 0.08428328f, 0.01391260f, 
    0.01678397f, 0.16928217f, 0.16223232f, -0.31238738f, -0.24748488f, -0.29434136f, -0.02693732f, -0.13926236f, 
    0.19946088f, -0.00503291f, 0.05274735f, -0.19749117f, -0.61155838f, -0.25589055f, 0.09635509f, 0.13669339f, 
    0.02710061f, 0.03224806f, 0.08576310f, 0.01206548f, -0.16759105f, 0.08891080f, 0.04937113f, 0.07257614f, 
    -0.12330011f, 0.00097124f, -0.02514451f, -0.09408215f, -0.00557633f, -1.10789371f, -0.20207538f, -0.12543486f, 
    0.07059664f, 0.14485659f, 0.03334146f, -0.02264479f, -0.10751759f, -0.02195640f, 0.37364444f, 0.11474415f, 
    -0.00648153f, 0.12138738f, -0.02372272f, 0.04105378f, -0.01585817f, 0.01138266f, 0.07919973f, 0.16306789f, 
    -0.99731952f, -0.17114158f, -0.30194092f, -0.19687101f, 0.21540196f, 0.03188916f, 0.00326996f, -0.04292606f, 
    -0.20888972f, 0.38169917f, 0.22312966f, 0.15044637f, -0.09335453f, -0.04226621f, -0.00986371f, 0.07793054f, 
    0.16444655f, 0.05010265f, 0.09823337f, 0.04778349f, 0.07153419f, -0.17258528f, 0.02646567f, 0.16052730f, 
    -0.09718224f, 0.18746682f, -0.28745243f, 0.50118786f, -0.16222374f, -0.17014931f, -0.16428857f, -0.22142704f, 
    0.03406676f, -0.06159415f, 0.11631187f, -0.04248719f, -0.09792514f, 0.00531388f, -0.19920504f, -0.19472966f, 
    -0.02569822f, 0.03937207f, -0.13267033f, -0.04469566f, -0.05516818f, 0.22365412f, -0.10052574f, 0.17328146f, 
    0.07726058f, 0.19716907f, -0.06412759f, -0.00456366f, -0.02683017f, -0.44208503f, -0.31397697f, -0.20973670f, 
    0.04086144f, 0.33199951f, -0.10516514f, 0.11958084f, 0.16604842f, 0.10896768f, 0.13642098f, 0.19295458f, 
    0.13047160f, -0.05693157f, -0.11492341f, -0.04933924f, 0.05197188f, -0.08638713f, 0.08288579f, -0.11157554f, 
    -0.15516634f, -0.20132329f, 0.08829384f, 0.10741208f, -0.05499879f, 0.00976534f, -0.05833926f, 0.02714328f, 
    -0.01065432f, 0.03688847f, -0.01047504f, -0.08320776f, -0.02013773f, -0.11264268f, -0.09551321f, 0.00449917f, 
    -0.08064277f, -0.00531901f, -0.05984574f, -0.04598184f, 0.00191015f, -0.03845030f, -0.05960154f, 0.03774521f, 
    -0.04900726f, -0.10913198f, -0.08491433f, 0.02145739f, -0.06619782f, -0.06738628f, -0.01261862f, -0.08072824f, 
    0.00309132f, -0.03136113f, -0.00509929f, -0.00234509f, -0.04259812f, -0.09016711f, -0.04862605f, 0.01679140f, 
    0.02684178f, -0.08275141f, -0.08604285f, 0.05316892f, 0.04816644f, -0.08941149f, 0.01371112f, -0.00865978f, 
    -0.05529630f, -0.12889120f, 0.03906734f, -0.04024120f, 0.03792233f, -0.02434521f, -0.07763849f, -0.07681514f, 
    0.03188582f, 0.02362937f, 0.02879047f, -0.01531520f, -0.00760402f, 0.05218980f, 0.02086174f, -0.07499911f, 
    -0.03878683f, 0.02271101f, -0.01013390f, -0.08646479f, -0.00515653f, -0.00359226f, -0.02994988f, -0.02441689f, 
    -0.02673849f, -0.04092871f, -0.06914788f, -0.07075138f, -0.01508718f, -0.05690106f, -0.08159913f, -0.10571384f, 
    0.01298396f, -0.05791270f, -0.00332635f, -0.04960257f, -0.00395015f, -0.06133297f, -0.10942128f, -0.06269704f, 
    -0.10798893f, -0.08865146f, -0.06022827f, -0.05171501f, -0.03541121f, -0.06386773f, 0.03161009f, -0.04131366f, 
    0.00960788f, -0.02322636f, -0.03561785f, -0.01290813f, 0.03953806f, 0.04330114f, 0.05919806f, 0.00062493f, 
    -0.01186244f, -0.04640489f, -0.06626803f, 0.05164272f, -0.10155846f, 0.03675266f, -0.01811376f, -0.03630196f, 
    0.03142804f, -0.01943554f, 0.03641993f, -0.06797567f, -0.08431317f, -0.06344876f, -0.03085097f, 0.03215254f, 
    0.01785596f, -0.10270218f, -0.06882767f, -0.10033344f, 0.06548209f, -0.00183964f, -0.06274890f, -0.09621747f, 
    -0.09659368f, 0.05859923f, -0.00522007f, -0.03738925f, 0.05244791f, -0.09882051f, -0.09105635f, -0.09384636f, 
    -0.05025619f, -0.09557601f, 0.04054107f, 0.01010915f, -0.00597825f, 0.01234199f, 0.00751155f, -0.04726643f, 
    -0.01818730f, 0.01454993f, -0.08744489f, -0.05624517f, 0.03033154f, -0.02661960f, -0.00414095f, 0.00043792f, 
    -0.01055933f, -0.21687190f, 0.09854594f, 0.08229346f, 0.09201759f, 0.17848015f, -0.11605410f, 0.19379872f, 
    0.00503051f, -0.11665913f, 0.42537972f, 0.06139669f, 0.09521136f, 0.00655664f, 0.04209959f, -0.15688144f, 
    -0.03871549f, -0.23381150f, 0.11721528f, 0.00786426f, 0.22893797f, -0.10079471f, 0.21231668f, -0.05830357f, 
    0.23840052f, -0.00298564f, 0.00373071f, 0.00041967f, 0.10341553f, 0.40078259f, 0.02750060f, 0.11107744f, 
    0.04676799f, 0.05112228f, 0.12575753f, 0.12157333f, 0.08416513f, 0.15742473f, 0.43753409f, 0.02202460f, 
    0.00665327f, -0.01439185f, -0.07523538f, -0.24935238f, -0.28999910f, -0.76765007f, 0.01784522f, 0.60719419f, 
    -0.27287051f, 0.10492260f, -0.08841951f, 0.20872612f, -0.00465966f, 0.13695508f, -0.36667767f, 0.11059294f, 
    -0.20418598f, -0.01209453f, 0.17807247f, -0.01399110f, 0.24209897f, 0.09327153f, -0.12332028f, -0.05466997f, 
    -0.17477350f, 0.21232381f, -0.10340538f, -0.02555043f, 0.02922308f, 0.14386044f, 0.24139681f, 0.03209271f, 
    0.22596717f, 0.08291288f, 0.28336543f, 0.02661487f, 0.00518645f, 0.13031338f, 0.16254467f, 0.10592502f, 
    0.20500083f, -0.42010814f, -0.06480502f, -0.01841378f, -0.07902040f, 0.23581712f, 0.20702228f, 0.02840070f, 
    0.00614214f, 0.13981906f, -0.11025602f, 0.05205033f, 0.46754849f, -0.02744193f, 0.06088540f, -0.23844253f, 
    0.12200172f, -0.14840597f, -0.02252034f, -0.31340832f, 0.08166199f, -0.02549990f, -0.22384134f, -0.03588815f, 
    -0.19149578f, 0.07861923f, -0.01764772f, 0.10001806f, -0.17754766f, -0.06074591f, 0.20154057f, 0.02080722f, 
    0.12183981f, 0.02649182f, -0.14365105f, 0.03621012f, -0.18306223f, 0.01765615f, 0.15040867f, 0.24936309f, 
    -0.02348458f, 0.07973645f, 0.03869872f, 0.08721118f, 0.07063504f, -0.04164921f, -0.47663835f, 0.11365776f, 
    -0.40467387f, 0.02348518f, -0.22514325f, -0.05842644f, 0.02507663f, 0.36177537f, 0.01086333f, -0.08049655f, 
    0.20011102f, -0.29025823f, 0.05396758f, 0.10617524f, 0.01261682f, 0.06906513f, 0.31609154f, 0.11860146f, 
    -0.33779848f, 0.01567635f, 0.18218905f, 0.15279873f, 0.10715032f, -0.03725755f, 0.10474505f, -0.05515258f, 
    -0.07973871f, 0.34167132f, 0.14388898f, -0.01715842f, -0.04432627f, 0.09791493f, -0.07199936f, -0.04444584f, 
    0.20338018f, 0.04555815f, -0.57020146f, 0.23428322f, -0.30309832f, 0.12834147f, 0.03982671f, 0.11088806f, 
    0.04604200f, 0.08536597f, 0.06348059f, 0.08961576f, -0.07445113f, -0.33757406f, 0.22705877f, -0.07468680f, 
    0.15715043f, 0.05314256f, 0.11149520f, -0.00431678f, -0.30836347f, -0.08162194f, 0.10295134f, -0.11082756f, 
    -0.02988516f, 0.15070052f, 0.06325413f, -0.04624664f, -0.01344048f, -0.48825678f, -0.15413265f, -0.64830351f, 
    -0.13161305f, 0.02986616f, -0.24879529f, -0.00752135f, -0.22900477f, 0.02080713f, 0.24299189f, 0.14876564f, 
    0.14213398f, -0.09713721f, -0.00214815f, -0.09767938f, 0.02544136f, 0.02323957f, 0.07617956f, -0.07399128f, 
    -0.31596172f, -0.63489372f, 0.04642944f, -0.26615953f, 0.11905960f, 0.00856153f, -0.13592160f, -0.11655934f, 
    -0.19100983f, 0.22998273f, -0.26772872f, 0.02141919f, 0.20926689f, -0.00603805f, 0.05833778f, 0.00686533f, 
    0.01295066f, 0.29091471f, 0.32526046f, -0.09828625f, 0.01991415f, -0.06225499f, 0.06078107f, 0.13105462f, 
    0.10001076f, -0.01549954f, 0.13659017f, 0.16495770f, 0.31818467f, -0.01782271f, -0.04035237f, -0.08426569f, 
    0.05561581f, -0.06355142f, 0.13912460f, 0.31327933f, 0.02597619f, -0.23601268f, 0.00005049f, 0.01355037f, 
    0.02482431f, 0.04009630f, -0.16257879f, -0.18028352f, 0.27232236f, -0.02494379f, -0.11648469f, -0.02601737f, 
    0.21540813f, -0.20945826f, 0.11515155f, -0.02077179f, 0.02974829f, -0.34586394f, -0.31528085f, 0.24155289f, 
    -0.07354836f, -0.10163567f, -0.21006493f, 0.05342652f, 0.09582794f, -0.04598709f, 0.05116461f, -0.20486735f, 
    0.27291450f, -0.07142647f, -0.02329133f, -0.27639064f, -0.02074624f, 0.08464185f, 0.11291925f, -0.02574901f, 
    -0.03766669f, 0.23312955f, 0.06608397f, -0.05590249f, -0.06152868f, 0.07071631f, 0.25160474f, 0.00700747f, 
    -0.15683819f, -0.22083898f, -0.02955539f, -0.22929116f, -0.11697099f, -0.13127162f, -0.13789576f, 0.10424060f, 
    -0.02182994f, -0.42968261f, -0.56044948f, 0.07778299f, 0.05357860f, 0.00243865f, -0.02445002f, -0.01837337f, 
    0.29525730f, 0.01890145f, 0.06713098f, -0.34440175f, 0.05157285f, -0.15909766f, -0.09022138f, -0.06979628f, 
    0.01715951f, 0.10228346f, 0.01589448f, 0.37667853f, 0.29650411f, 0.08827110f, -0.05492485f, -0.01249656f, 
    -0.09163447f, 0.08099125f, 0.19557793f, -0.09350470f, 0.16336738f, 0.29450235f, 0.10015202f, -0.12454875f, 
    -0.09485412f, 0.05197547f, 0.03603892f, -0.01308466f, 0.04464815f, -0.14420332f, -0.00884047f, 0.32843444f, 
    0.01703802f, -0.29544786f, 0.22949295f, -0.02904234f, 0.00431685f, 0.09191849f, -0.31837991f, -0.19272490f, 
    -0.06358574f, 0.06014768f, -0.25874647f, -0.15873903f, -0.14279686f, 0.18044037f, 0.00729411f, 0.09813871f, 
    0.16149481f, 0.20742647f, -0.01582664f, 0.06172828f, -0.12131420f, 0.02624885f, -0.11215021f, -0.02692207f, 
    -0.14695269f, -0.03066852f, 0.00778910f, 0.07628931f, -0.23135455f, 0.03956712f, 0.07529218f, -0.06799632f, 
    0.21200988f, -0.28267631f, -0.22942254f, -0.41984040f, -0.31360736f, 0.05853516f, -0.01326043f, 0.04520275f, 
    0.12970774f, -0.23882538f, 0.26055172f, -0.02178755f, -0.06975561f, 0.04936054f, 0.00943836f, -0.02035272f, 
    0.00565935f, -0.06232160f, 0.21355599f, 0.33222887f, 0.00401031f, -0.14666201f, -0.19905876f, 0.11951552f, 
    0.12536106f, 0.11699288f, 0.00405892f, 0.07807389f, -0.38292864f, -0.74047643f, -0.03429541f, -0.04887260f, 
    -0.00924606f, 0.20897123f, 0.03862476f, -0.11327822f, -0.10449272f, 0.26000711f, 0.02190255f, 0.24623950f, 
    0.05746661f, 0.11247829f, 0.07745384f, -0.10480364f, 0.17691141f, -0.14788330f, 0.24857503f, -0.33566985f, 
    0.26741278f, -0.14466965f, -0.17503105f, 0.08770119f, -0.03443580f, -0.10829823f, -0.09126330f, -0.21267615f, 
    0.24393174f, 0.29134414f, 0.10947639f, -0.02738128f, -0.08437850f, -0.11587944f, 0.20339797f, 0.13296007f, 
    0.07589631f, 0.18548903f, -0.12352788f, 0.11644024f, 0.12436793f, 0.05908525f, -0.01320702f, 0.04213587f, 
    0.18075538f, 0.33477736f, -0.10296744f, 0.12810217f, -0.00912559f, 0.01787760f, -0.17159054f, -0.00832725f, 
    -0.02842856f, 0.10738637f, 0.14032547f, -0.10196613f, -0.14232673f, -0.04711189f, -0.12862343f, -0.05750527f, 
    0.12440240f, 0.17634523f, 0.13032517f, -0.24089718f, 0.38177904f, 0.43773192f, 0.09618815f, -0.05182023f, 
    0.00467166f, -0.07090754f, -0.02885359f, 0.11618657f, -0.44056541f, -0.36224863f, -0.41361660f, 0.01818180f, 
    0.00095918f, -0.26190650f, 0.11374974f, 0.10210745f, -0.17941079f, -0.47070777f, -0.42846978f, 0.02323317f, 
    -0.17947122f, 0.04398321f, 0.05777961f, -0.05306615f, -0.02703654f, 0.08351260f, 0.40236372f, 0.14915486f, 
    0.03103348f, -0.14191045f, -0.18524393f, 0.25977877f, 0.02326564f, 0.07389446f, -0.03684402f, -0.28067958f, 
    -0.14478239f, 0.23151340f, -0.14592716f, 0.07130166f, -0.02916059f, -0.03109967f, -0.06901783f, -0.00438978f, 
    -0.14156486f, 0.10467001f, -0.01968867f, 0.05483638f, -0.15242897f, -0.13865595f, -0.04908507f, -0.06852882f, 
    0.12469107f, 0.11469687f, -0.07626829f, 0.21050647f, -0.04250861f, 0.23987316f, 0.03914075f, 0.01370747f, 
    0.03733164f, 0.14968567f, -0.31107521f, -0.05259112f, 0.08101834f, -0.16479360f, -0.01532252f, -0.13323480f, 
    0.04045660f, 0.02143898f, 0.13605706f, -0.10251018f, -0.03279987f, -0.09566834f, -0.25541100f, -0.14888515f, 
    0.18419586f, 0.10572077f, -0.02371625f, -0.02229887f, 0.24430637f, 0.05581907f, 0.11229847f, -0.03185868f, 
    -0.18137333f, -0.01127617f, 0.11338437f, -0.03290704f, 0.14196594f, -0.20679723f, -0.48647511f, -0.22556119f, 
    -0.02646523f, 0.08407785f, -0.25273225f, 0.01117560f, -0.18194655f, 0.01982895f, -0.08548743f, 0.04553682f, 
    -0.15964498f, 0.13582455f, 0.15237683f, -0.23135555f, -0.17460164f, 0.20364736f, 0.16913909f, 0.14063178f, 
    -0.20483848f, 0.27016428f, 0.10323786f, -0.12093819f, -0.00852121f, 0.13778475f, 0.12926224f, 0.22729303f, 
    -0.04434756f, -0.03279116f, 0.26690629f, 0.24892882f, -0.00062100f, 0.15369257f, 0.12899661f, -0.19247040f, 
    -0.06936117f, -0.02184322f, -0.05074454f, 0.11986048f, -0.01551885f, 0.02108046f, 0.00876761f, -0.03368435f, 
    0.26853520f, 0.09972107f, 0.09372964f, 0.10212369f, 0.08931494f, 0.29916790f, -0.13948101f, 0.06256082f, 
    -0.19985856f, 0.01103633f, -0.02957258f, -0.16605797f, -0.02501164f, -0.07028023f, 0.00939745f, -0.08711965f, 
    0.11089089f, 0.09747425f, -0.04037556f, -0.01971692f, 0.05939170f, 0.03827825f, -0.01773200f, -0.13190438f, 
    -0.01562248f, -0.13389525f, 0.25551519f, 0.13289219f, 0.28880015f, 0.30669025f, 0.21987362f, 0.26885417f, 
    0.09738798f, -0.04086460f, 0.06725217f, 0.01542680f, 0.17444709f, -0.01213076f, -0.10790565f, 0.08867144f, 
    0.07180338f, -0.06814673f, 0.08300389f, 0.06138366f, -0.02797359f, -0.08428645f, 0.06535324f, 0.05984231f, 
    0.06194654f, -0.16876876f, 0.13977306f, 0.04766147f, -0.06085846f, -0.12596779f, -0.38219991f, -0.20730674f, 
    -0.15599747f, -0.28687027f, 0.02138465f, 0.17604226f, 0.18278657f, 0.02675555f, -0.18303718f, -0.26736227f, 
    -0.23780337f, -0.23443049f, -0.17253594f, 0.17245756f, -0.09090927f, 0.17528673f, -0.09629793f, 0.07835805f, 
    0.03552287f, 0.14187364f, -0.20219426f, -0.18258443f, 0.15524715f, 0.10144574f, 0.05435209f, 0.01043441f, 
    -0.03573479f, -0.10303785f, -0.28523129f, -0.15140839f, -0.10662474f, -0.07190889f, 0.33628485f, 0.10270479f, 
    0.04628383f, -0.09408715f, -0.09247026f, 0.02433257f, 0.00597389f, 0.05796731f, 0.22991091f, -0.05506787f, 
    -0.02341270f, 0.24026611f, 0.00614079f, 0.19894214f, 0.03055824f, -0.26374838f, 0.05589918f, -0.16352893f, 
    0.13659096f, -0.00565182f, 0.21371685f, 0.12166019f, 0.20845734f, 0.11500579f, -0.18674198f, -0.25776091f, 
    0.05722439f, -0.00602730f, 0.22191547f, 0.10715972f, 0.06613757f, -0.26667082f, -0.17026192f, 0.07143641f, 
    0.05619930f, 0.09327520f, 0.06017641f, -0.04141714f, 0.05910780f, -0.03296260f, 0.32033759f, 0.22858088f, 
    0.09870797f, -0.07847682f, -0.39644280f, 0.00208781f, -0.22575770f, 0.03691688f, 0.13994530f, 0.09828396f, 
    0.08998328f, 0.09130218f, 0.01263035f, 0.10050947f, 0.09242158f, -0.07392173f, 0.32723230f, 0.05850063f, 
    -0.01856012f, -0.01422776f, -0.52868962f, -0.65076584f, -0.47262490f, -0.31287315f, 0.12317797f, -0.21175958f, 
    0.21190354f, -0.04318835f, -0.00556228f, -0.27861610f, 0.02577332f, 0.19955079f, 0.11394928f, 0.09024248f, 
    -0.23758206f, 0.16763818f, 0.04024202f, 0.19637623f, 0.13624346f, 0.14440089f, 0.21942529f, -0.08590812f, 
    0.07343893f, -0.04137019f, 0.02829831f, -0.06648644f, 0.10680683f, 0.43967932f, 0.06246718f, -0.17684089f, 
    -0.01051638f, -0.33497661f, -0.22338039f, 0.01237968f, 0.03070821f, -0.12343638f, -0.08122949f, -0.05343682f, 
    0.04189881f, 0.15118788f, 0.04479709f, 0.06980662f, 0.12843096f, 0.12716714f, 0.03343431f, 0.10893823f, 
    0.20840330f, 0.41605845f, -0.14231248f, -0.04270941f, -0.24258275f, 0.19077367f, -0.03328132f, 0.09818768f, 
    0.43751967f, -0.30642653f, 0.19732153f, 0.13831490f, -0.18664381f, -0.14933333f, 0.01588990f, 0.14339527f, 
    0.14457189f, 0.04650825f, -0.31510168f, -0.02567099f, 0.19577052f, 0.01228707f, 0.07372398f, 0.11970039f, 
    0.01435297f, 0.05038360f, -0.12856959f, -0.18260942f, 0.00606246f, -0.17259564f, -0.02001888f, -0.16186488f, 
    0.07854925f, 0.17199971f, 0.09306642f, 0.26879787f, 0.11224668f, 0.03801818f, -0.02464161f, -0.08657394f, 
    -0.00040215f, 0.17880251f, 0.10821801f, -0.07057756f, 0.15142338f, 0.14403920f, -0.45960319f, 0.00730591f, 
    0.02377969f, 0.21253508f, 0.07162856f, -0.14497328f, -0.10885009f, -0.13935477f, -0.07985175f, -0.30962387f, 
    -0.11584024f, 0.03516162f, -0.08902832f, -0.07939909f, 0.09617183f, -0.09182007f, 0.06198877f, 0.00847166f, 
    -0.13708751f, -0.19192497f, -0.15741305f, -0.06010945f, -0.09466362f, 0.38053325f, 0.13908924f, 0.03496679f, 
    -0.03964031f, -0.21847685f, -0.17775914f, -0.01367718f, -0.00517621f, 0.09617335f, -0.11084192f, 0.01872246f, 
    0.70493305f, -0.28319719f, -0.09072124f, 0.13720410f, 0.03096140f, 0.14624725f, -0.00185813f, 0.07699063f, 
    0.18612443f, -0.47130352f, -0.06283201f, -0.22434039f, -0.10241107f, -0.03827369f, 0.00783915f, -0.02111046f, 
    0.20200333f, 0.03143280f, 0.08818321f, 0.07517485f, 0.23026140f, -0.01749418f, 0.01585139f, 0.03354005f, 
    -0.06300352f, -0.05599858f, -0.05953684f, -0.04900490f, 0.36104915f, 0.06553396f, 0.07242354f, 0.20261940f, 
    0.14992693f, 0.02331300f, 0.09814361f, 0.10309670f, -0.15091765f, -0.61738622f, -0.18847048f, -0.03407945f, 
    -0.12676737f, -0.13481851f, -0.01447947f, 0.03444431f, 0.15598887f, -0.35877880f, 0.10757173f, -0.02498361f, 
    -0.11375956f, 0.04214358f, -0.09663721f, 0.01060325f, -0.02335398f, 0.04181738f, -0.05392644f, -0.00589277f, 
    0.04539951f, -0.18695465f, 0.18472736f, 0.00819295f, 0.09952592f, 0.11598386f, 0.11770560f, -0.13266745f, 
    0.45707890f, 0.18350129f, -0.08169381f, -0.03183298f, -0.03473964f, 0.06910037f, 0.04577166f, -0.20459698f, 
    0.41285062f, -0.07112028f, 0.08106222f, 0.05850131f, 0.22103368f, -0.22754860f, 0.05424152f, 0.10036162f, 
    0.07014141f, 0.03738917f, 0.16685666f, -0.00533084f, -0.05839815f, -0.18277846f, 0.11658802f, 0.06505784f, 
    0.04719483f, 0.07596453f, -0.45293048f, 0.25199488f, -0.51269466f, 0.16808246f, -0.19392850f, 0.05621602f, 
    0.12584783f, -0.08828102f, 0.16272834f, 0.00190511f, -0.00307926f, -0.00666152f, -0.40968120f, -0.11493535f, 
    0.12263598f, -0.10070040f, -0.00161938f, 0.00395946f, -0.31361899f, -0.21750380f, -0.13363081f, -0.02077890f, 
    -0.23474699f, 0.03797485f, 0.00630596f, -0.04741132f, 0.01809211f, -0.27740762f, -0.03532412f, -0.09093029f, 
    0.05215808f, -0.09222338f, 0.13111338f, 0.07885798f, 0.06912994f, -0.07581453f, -0.12206694f, -0.06619364f, 
    -0.07248239f, -0.28075621f, 0.07487980f, -0.10115726f, 0.12818053f, -0.00203746f, -0.12280560f, -0.08530588f, 
    -0.09444695f, 0.15908234f, -0.16234402f, -0.04661976f, 0.03162936f, -0.06094956f, 0.09964414f, 0.26421240f, 
    0.00286052f, 0.14451323f, 0.17027318f, 0.07852856f, 0.01237637f, -0.11960183f, -0.08342943f, 0.01109171f, 
    0.02198960f, 0.31605312f, -0.31259063f, -0.53280199f, 0.11420035f, -0.09283411f, -0.12763594f, -0.11590909f, 
    0.01568688f, 0.07701496f, -0.39492923f, 0.08455256f, -0.05716404f, -0.20364779f, 0.00698100f, 0.19369571f, 
    0.13751321f, 0.10322254f, -0.05346237f, 0.33524910f, 0.22763145f, 0.16482665f, 0.02333789f, 0.03103293f, 
    0.05852134f, 0.07461581f, -0.00528009f, 0.14667365f, 0.27943516f, 0.32195568f, 0.24030118f, -0.30373055f, 
    -0.03375360f, -0.11689444f, -0.06250314f, -0.11740586f, -0.09743686f, -0.50192350f, -0.06957699f, -0.57160306f, 
    -0.05786754f, -0.16545345f, 0.41409743f, 0.08933570f, 0.20081562f, 0.00128360f, 0.05899700f, -0.27794650f, 
    -0.32840478f, -0.17559709f, -0.19450679f, -0.06053374f, 0.01657654f, 0.01813469f, 0.08559021f, 0.10420669f, 
    -0.06936122f, 0.01294201f, -0.01071444f, -0.03511908f, -0.11001373f, 0.13798432f, 0.05105359f, 0.17504531f, 
    0.29053873f, -0.45267868f, 0.05187062f, -0.01928442f, -0.19248727f, -0.26462206f, 0.17692184f, 0.06043509f, 
    -0.10599428f, 0.00392687f, -0.23808627f, 0.22374500f, -0.04503578f, 0.05127176f, -0.05341605f, 0.05316863f, 
    -0.03218509f, -0.00636110f, -0.04080386f, 0.07479190f, 0.16152850f, 0.05563361f, 0.04811026f, -0.09964668f, 
    0.10258523f, -0.08797364f, 0.02390720f, -0.35496607f, -0.05112738f, -0.42506000f, 0.01980855f, -0.26276413f, 
    0.06067016f, 0.08714146f, 0.11351736f, 0.21625943f, 0.43373957f, -0.08026603f, -0.78563881f, -0.03715307f, 
    0.07107201f, 0.02564857f, 0.07980201f, 0.12009495f, -0.03734025f, -0.05584200f, 0.25864184f, 0.22721569f, 
    0.00146600f, 0.05325396f, 0.05563898f, 0.08363534f, -0.03624649f, -0.05369573f, 0.04441007f, -0.56353074f, 
    0.17226067f, -0.22778213f, 0.10426372f, -0.22485043f, 0.03771660f, 0.10092942f, 0.00631148f, -0.20993268f, 
    0.11646508f, 0.13576387f, -0.04934341f, 0.07185315f, 0.04087060f, -0.14576937f, 0.07854085f, 0.09074470f, 
    -0.28898337f, -0.04136079f, 0.28650814f, 0.25901046f, 0.01886547f, 0.02725025f, -0.04788658f, -0.06690561f, 
    -0.12994656f, 0.29053721f, 0.16810167f, -0.13862300f, 0.03056765f, 0.05184691f, -0.02318927f, -0.06907791f, 
    0.09819902f, -0.03250714f, 0.27258709f, -0.11860381f, -0.00098866f, -0.08329890f, -0.16531029f, 0.16399287f, 
    0.05840260f, -0.03260868f, 0.11146715f, 0.06832647f, -0.29355034f, -0.02057131f, 0.17980908f, -0.07245800f, 
    0.08059319f, -0.11571065f, 0.13793886f, -0.03009498f, -0.09135559f, -0.05805716f, -0.05053526f, 0.04144456f, 
    0.15006015f, -0.21452379f, -0.01883002f, -0.26336420f, -0.48013809f, -0.19279864f, -0.08673108f, 0.10892282f, 
    0.02366725f, 0.35071182f, 0.08550555f, -0.22290908f, -0.13716723f, 0.25230402f, 0.17167020f, 0.06796190f, 
    -0.15802178f, 0.04708827f, 0.06255788f, -0.00774299f, 0.18607262f, -0.09358185f, -0.18546808f, -0.16469933f, 
    -0.12006750f, -0.20911868f, -0.05059290f, 0.06556294f, 0.27179641f, -0.14836884f, 0.13759783f, 0.37450215f, 
    -0.30149829f, 0.29617301f, 0.10612927f, 0.23194456f, 0.07224163f, 0.04279401f, 0.13998711f, 0.18073571f, 
    0.22126819f, 0.01774006f, 0.03662695f, -0.04981115f, -0.15879641f, -0.01381336f, 0.12609048f, 0.21187727f, 
    -0.07143580f, -0.15896200f, 0.47921801f, 0.31213999f, 0.29335019f, 0.17309225f, 0.14079830f, -0.02710968f, 
    0.03682468f, 0.17719908f, 0.13961090f, -0.04628719f, -0.20479321f, -0.04199916f, -0.03467750f, 0.17430070f, 
    0.05547975f, -0.09516699f, -0.29124066f, -0.30404884f, 0.22348878f, 0.02829498f, -0.08509547f, 0.08683270f, 
    0.03460351f, 0.04259436f, 0.14562796f, -0.07740301f, -0.00908085f, 0.04232370f, -0.10147879f, 0.12391341f, 
    0.19316958f, 0.09582593f, -0.07281895f, 0.09798092f, -0.03645133f, 0.26731774f, 0.02378407f, 0.04335195f, 
    -0.28477275f, 0.02598861f, 0.13494718f, 0.11946232f, 0.15221263f, 0.04016926f, -0.08605810f, 0.12478141f, 
    0.13164119f, -0.15561371f, 0.17004545f, -0.07688231f, -0.05458054f, 0.08870921f, 0.00232761f, -0.42762911f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.07753982f, 0.05819895f, 0.40110204f, -0.01086267f, -0.08805949f, 0.35813916f, -0.11550365f, 0.11734423f, 
    0.10309993f, -0.05491597f, 0.18426652f, -0.05839345f, 0.15820858f, 0.29960015f, 0.03843386f, 0.06786349f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.05398905f, -0.25877920f, 0.51414621f, -0.21701214f, -0.11849003f, -0.01861985f, 0.10133506f, -0.10345246f, 
    -0.34346068f, 0.23197095f, 0.12186923f, -0.04880168f, 0.27911869f, 0.26214662f, -0.17743912f, 0.19555745f, 
    0.14227559f, 0.20258972f, -0.41514346f, 0.02547712f, 0.00302457f, -0.06481001f, -0.05339575f, 0.14674270f, 
    0.07602338f, 0.54512542f, 0.06886422f, 0.26852131f, -0.41520360f, -0.30258086f, -0.28371152f, -0.03714767f, 
    0.04783553f, -0.05613642f, -0.02296056f, -0.23083659f, -0.17907067f, 0.08519362f, -0.17188719f, -0.07600144f, 
    -0.16136193f, 0.22573572f, -0.12418330f, -0.22334804f, 0.22210206f, 0.20062728f, 0.17918266f, -0.19158420f, 
    -0.17425200f, 0.32948703f, -0.16551308f, -0.18501557f, -0.19820729f, -0.06463937f, -0.18392763f, 0.34167296f, 
    0.38897276f, 0.29832119f, -0.31297114f, -0.00035861f, 0.25405651f, -0.69354278f, 0.04612783f, 0.05133724f, 
    -0.32979611f, -0.08794080f, 0.59315997f, 0.06422557f, -0.15491247f, -0.26579952f, -0.08157890f, 0.33893830f, 
    -0.31289127f, -0.36917916f, 0.17261468f, -0.25176495f, -0.29722995f, -0.31735465f, -0.21015370f, 0.36806110f, 
    -0.24482478f, -0.24696386f, 0.60156631f, 0.04626186f, -0.03982927f, 0.01564761f, 0.18617392f, 0.30077380f, 
    -0.66663682f, 0.17296506f, -0.13830502f, -0.40277958f, 0.51766568f, 0.02385272f, -0.28821573f, 0.42010885f, 
    0.34745428f, -0.27490467f, 0.53117085f, -0.20211518f, 0.23582475f, -0.18627551f, -0.08486177f, 0.11186673f, 
    -0.38290539f, -0.42922166f, -0.05978775f, 0.00417532f, 0.16827999f, 0.42673543f, 0.01333381f, 0.04682757f, 
    -0.17425780f, -0.26205030f, 0.31845188f, -0.13305812f, -0.22301690f, -0.08772115f, -0.27179366f, 0.43528548f, 
    -0.80598527f, -0.19594762f, 0.55107749f, -0.35447896f, -0.55861473f, 0.06114351f, -0.22368662f, 0.38243470f, 
    -0.02681123f, -0.01961436f, 0.09983642f, 0.11812373f, 0.07778138f, -0.21910062f, -0.04057720f, -0.06364716f, 
    -0.21379176f, -0.08457310f, 0.00342986f, -0.25038403f, 0.15973258f, -0.20939085f, -0.27170587f, -0.23710155f, 
    -0.32887763f, -0.30791578f, 0.04285116f, -0.20193605f, -0.04592914f, -0.46765476f, 0.04994640f, 0.31403634f, 
    -0.07693176f, 0.04497046f, -0.21944526f, -0.40084156f, 0.30120435f, 0.03624057f, 0.02577701f, 0.43941036f, 
    -0.59982491f, 0.36591896f, 0.05317292f, -0.37759107f, -0.22399740f, 0.22301884f, 0.21553817f, 0.35107017f, 
    -0.17570342f, 0.05714700f, 0.06468566f, 0.13085233f, -0.20883201f, 0.26625401f, 0.01720541f, -0.09853913f, 
    0.02035123f, -0.10389038f, -0.66238505f, 0.25357145f, 0.20311537f, -0.25051096f, 0.06753131f, 0.25730273f, 
    -0.08947861f, 0.41466567f, -0.06723244f, -0.24252573f, -0.74667871f, -0.24244873f, -0.26523548f, 0.09092222f, 
    -0.01060549f, -0.50571942f, 0.46895254f, 0.07091168f, -0.18308708f, -0.22528297f, 0.02960465f, 0.20291126f, 
    -0.34786895f, -0.08000065f, 0.10892172f, -0.22964753f, 0.29328436f, -0.45229948f, 0.46510524f, 0.30354461f, 
    -0.28964236f, -0.18106154f, 0.59523320f, 0.08597815f, 0.13938040f, -0.16620892f, -0.13358895f, 0.09218650f, 
    0.40487769f, -0.38488680f, -0.25579026f, -0.28254789f, 0.20926711f, 0.02262354f, 0.46710804f, 0.06766195f, 
    0.11143342f, 0.10773848f, 0.42934355f, 0.23352839f, 0.17807768f, 0.45204812f, -0.02761291f, 0.01735007f, 
    -0.10072894f, -0.03293802f, -0.50856709f, 0.06152142f, 0.09160438f, 0.43542328f, -0.07287376f, -0.33026460f, 
    0.35999754f, -0.30577013f, 0.05528840f, 0.04799957f, -0.23217875f, 0.10321772f, 0.18087527f, -0.05736677f, 
    -0.34350854f, 0.07174568f, 0.24522273f, -0.17147462f, 0.05668380f, 0.47448227f, 0.50725406f, 0.17048639f, 
    0.31079921f, 0.00558631f, 0.46158609f, -0.31458697f, 0.08355681f, -0.12110548f, 0.02256409f, 0.23897514f, 
    -0.05020334f, 0.02934610f, 0.00215779f, -0.33016029f, -0.44756287f, -0.40351275f, 0.29583055f, 0.19687442f, 
    0.32280496f, -0.10988373f, 0.45414248f, 0.21917710f, 0.23839679f, 0.18454972f, -0.16702367f, 0.26546815f, 
    -0.10866098f, -1.14874566f, 0.03193190f, -0.19196898f, -0.20954335f, -0.73063397f, 0.06797068f, -0.04009540f, 
    -0.31197682f, 0.12647341f, 0.22709996f, 0.13609609f, -0.09417300f, 0.29352337f, -0.11838518f, 0.13304181f, 
    0.66069543f, -0.50952828f, -0.01593123f, 0.31330612f, -0.71581805f, 0.23385872f, 0.10233124f, -0.14315021f, 
    -0.00087884f, 0.13001792f, -0.01343010f, 0.22422324f, 0.19678622f, -0.09303453f, -0.17878215f, -0.19240542f, 
    0.36631590f, 0.26484230f, -0.03022345f, 0.06178355f, -0.09020066f, -0.26159602f, 0.51714939f, 0.07598509f, 
    -0.10210463f, -0.17718911f, 0.09876410f, -0.00594213f, -0.00922412f, 0.05421146f, -0.09717929f, -0.21329167f, 
    -0.10766776f, -0.10141272f, -0.18727578f, -0.11028166f, -0.07577080f, -0.24688230f, -0.24554530f, 0.05749278f, 
    -0.17789730f, 0.45934880f, 0.24130917f, 0.26227039f, -0.03343144f, -0.11329849f, 0.21500225f, 0.01135103f, 
    -0.05743482f, 0.45601952f, -0.51403886f, 0.07088462f, 0.07379937f, -0.31582987f, 0.68252188f, -0.17372195f, 
    0.28313664f, -0.06575778f, 0.04287548f, -0.04244745f, 0.14816059f, -0.42580250f, 0.03351072f, 0.35875586f, 
    0.30398208f, 0.32695508f, 0.09632299f, 0.19349089f, -0.21140157f, -0.16509163f, -0.52093190f, -0.26560199f, 
    0.27558023f, 0.02887000f, -0.30826655f, -0.09540074f, 0.15220635f, -0.03981797f, 0.03937389f, 0.24983194f, 
    0.36445567f, -0.61430240f, 0.23036411f, -0.13811277f, -0.18678117f, 0.03750714f, -0.15758686f, 0.16129749f, 
    -0.57965189f, -0.49272498f, 0.15244082f, 0.52814692f, -0.05642206f, 0.18287463f, -0.23575559f, -0.06567929f, 
    0.41972730f, 0.11108958f, -0.13813061f, -0.21371186f, -0.15123209f, -0.06887050f, 0.11304376f, 0.03352956f, 
    0.16792201f, -0.09325754f, 0.09578723f, -0.06248248f, -0.16266030f, 0.30322260f, 0.17239325f, 0.23977110f, 
    0.33279049f, 0.11715575f, 0.23620124f, -0.02850293f, -0.14632195f, -0.11153463f, -0.36085612f, -0.17457668f, 
    0.01577734f, 0.04212160f, 0.26394266f, -0.10835387f, -0.22609352f, -0.02043847f, 0.05905962f, -0.11705051f, 
    -0.37883085f, -0.15868661f, 0.00944475f, 0.05531727f, 0.15626410f, 0.35497266f, 0.35310304f, 0.14140412f, 
    0.04109888f, 0.18552886f, -0.30868793f, -0.04911273f, 0.13763680f, -0.42805031f, 0.22400604f, 0.21716504f, 
    0.33379075f, 0.24175620f, 0.47887719f, -0.47744930f, -0.31074926f, 0.22786568f, -0.03689022f, 0.20662436f, 
    0.18143715f, -0.08260655f, -0.37157735f, -0.09286125f, 0.15622745f, -0.98157549f, -0.05475926f, 0.44962409f, 
    -0.16744322f, 0.17443451f, 0.24718378f, 0.05983230f, 0.08097682f, -0.42418644f, 0.06141905f, 0.04366905f, 
    0.12903406f, -0.15539794f, -0.10835927f, 0.34459710f, -0.18205042f, -0.28973824f, 0.22221209f, 0.06582304f, 
    -0.01104135f, -0.33520976f, 0.11279239f, 0.06672555f, 0.29520601f, -0.11813489f, 0.18996017f, -0.00844010f, 
    -0.15025820f, -0.21355228f, -0.17092112f, 0.07447287f, -0.15769726f, 0.00096495f, 0.13077278f, -0.00069559f, 
    0.23637152f, -0.13725540f, -0.12309441f, -0.06047931f, -0.06833541f, 0.02963233f, 0.04663617f, -0.24692710f, 
    -0.05788124f, 0.04394078f, -0.21767089f, -0.07357281f, -0.11813796f, -0.18108681f, -0.05460009f, -0.08913076f, 
    0.24675173f, -0.16577628f, -0.13615048f, -0.21181485f, 0.03113326f, 0.10830384f, 0.03879759f, -0.07315007f, 
    0.29075623f, -0.09968302f, -0.09474139f, 0.48360097f, 0.17909113f, -0.26685223f, 0.15224591f, -0.20370096f, 
    0.11029828f, 0.05630938f, 0.20012546f, -0.24539378f, -0.02230547f, -0.25825289f, 0.46072245f, 0.26189646f, 
    -0.27588391f, 0.20854318f, -0.03337227f, -0.07619333f, -0.01299748f, 0.12837952f, 0.21406251f, 0.21943805f, 
    0.03396477f, -0.47683534f, 0.31680161f, 0.17805906f, -0.26324022f, -0.00065745f, 0.10457936f, -0.03057760f, 
    -0.72421634f, 0.20179069f, 0.18798882f, 0.40128800f, 0.07192269f, 0.48325843f, 0.19440947f, 0.06067742f, 
    0.14273705f, -0.36196837f, 0.17673591f, 0.21094082f, -0.58476305f, 0.14059745f, -0.39506948f, 0.00477404f, 
    0.34498343f, -0.09056544f, 0.16260299f, -0.20679255f, -0.03303377f, -0.05650542f, 0.00827602f, 0.16451934f, 
    0.02089495f, -0.06716829f, 0.01784096f, -0.09145289f, -0.44274786f, 0.04947391f, -0.49805808f, 0.27940294f, 
    0.18163869f, 0.02980591f, -0.15692286f, -0.27876651f, 0.10910792f, 0.04873467f, -0.18028763f, 0.18394631f, 
    0.12607780f, 0.11764388f, -0.03803257f, 0.31812268f, -0.49054441f, 0.30922192f, 0.01366056f, -0.05856923f, 
    0.05407470f, -0.17286403f, -0.10280645f, 0.00052552f, 0.08728438f, -0.26387686f, -0.18193822f, -0.19187412f, 
    -0.04535500f, -0.12669200f, -0.10672957f, 0.07427642f, -0.25064611f, 0.05711451f, 0.03633197f, -0.07027574f, 
    0.35663521f, 0.36370963f, 0.53817803f, -0.24825817f, 0.14425662f, 0.14923987f, 0.07001086f, 0.07959097f, 
    -0.17801924f, -0.11491566f, 0.22031963f, -0.22501965f, -0.01693966f, -0.04565929f, 0.20104955f, 0.06266015f, 
    0.00989878f, -0.39893058f, 0.48568606f, -0.05994938f, -0.02578456f, -0.29688013f, 0.01137395f, 0.39991567f, 
    0.16168128f, -0.27691728f, 0.33225748f, -0.41621369f, -0.45434687f, -0.27288911f, -0.27845514f, 0.29133639f, 
    0.00698029f, 0.11974251f, -0.21667556f, -0.43574694f, 0.18859302f, -0.17422569f, 0.11428995f, 0.16862556f, 
    0.27239931f, 0.33525738f, 0.24754302f, 0.02405908f, -0.33987772f, 0.11033539f, -0.20753238f, 0.14193158f, 
    -0.11511605f, 0.30367306f, -0.27324852f, -0.22951709f, -0.20664722f, -0.10327163f, -0.10853181f, 0.34344929f, 
    0.18956378f, 0.24104631f, 0.01080658f, -0.09407147f, 0.21611309f, -0.48807573f, 0.18729766f, -0.08659820f, 
    -0.24631631f, 0.20962298f, 0.07499543f, -0.17566839f, -0.21194288f, 0.10518754f, -0.21843356f, -0.20352870f, 
    0.24440888f, -0.06651154f, -0.10458988f, -0.15039891f, -0.11007220f, -0.15223759f, 0.14724874f, -0.13100380f, 
    -0.27055418f, -0.05596215f, 0.35479280f, -0.37749833f, 0.15926339f, -0.27251476f, 0.13477980f, 0.52792799f, 
    -0.46623683f, -0.12299478f, 0.26793399f, -0.33147231f, 0.53139079f, 0.44099924f, 0.04810011f, 0.13658184f, 
    -0.02131924f, -0.03036208f, -0.55228615f, 0.17117077f, 0.19409034f, 0.24408501f, -0.07778998f, 0.17573026f, 
    0.27514020f, -0.88476264f, 0.06328272f, -0.22264564f, 0.15513600f, 0.39678973f, 0.05920453f, 0.11431552f, 
    -0.03770974f, 0.34136850f, 0.09242031f, -0.04109853f, 0.03025608f, 0.33313850f, -0.19687396f, -0.25733569f, 
    0.24279441f, 0.16476452f, 0.12105078f, 0.05116028f, -0.08513799f, 0.00598106f, 0.44069046f, -0.16613446f, 
    -0.25933683f, -0.14626911f, 0.18958327f, -0.16378357f, 0.06140354f, 0.23156577f, -0.17875960f, 0.31527764f, 
    0.01470291f, 0.16346103f, -0.25439063f, 0.07645258f, 0.21503036f, 0.18419771f, -0.44637176f, -0.07332631f, 
    -0.16672608f, -0.12028971f, 0.50304520f, 0.08950675f, 0.03293321f, 0.35817519f, -0.11453257f, 0.01694258f, 
    -0.44811979f, -0.05223426f, 0.18105967f, -0.05569818f, 0.23133922f, -0.01229615f, -0.29358003f, 0.27092755f, 
    -0.06259365f, 0.32855138f, -0.13262951f, -0.06922773f, 0.25399828f, 0.38056362f, 0.19272530f, -0.00185767f, 
    -0.02798193f, 0.00573587f, 0.17195554f, 0.26616180f, -0.64502209f, 0.21443944f, -0.29255098f, 0.10652344f, 
    0.28392464f, 0.21730441f, 0.33274576f, -0.48141041f, 0.19592175f, -0.49983871f, 0.20068544f, 0.26315361f, 
    -0.09776858f, 0.15167044f, 0.34800455f, -0.17890649f, 0.10399386f, 0.11819714f, 0.07928070f, -0.01168113f, 
    0.26077190f, -0.26228413f, 0.13814460f, -0.03322793f, 0.05479010f, -0.04050046f, -0.00877440f, -0.52694547f, 
    0.12274778f, -0.33127224f, -0.04686379f, 0.14215848f, -0.08523269f, -0.35285753f, -0.11239090f, 0.14727360f, 
    -0.04818942f, 0.45914233f, 0.38060963f, -0.38933393f, -0.14927351f, 0.29528815f, -0.00436199f, 0.37009615f, 
    -0.04018971f, -0.24224679f, -0.33532208f, 0.16349357f, -0.02755903f, 0.05142114f, 0.06260160f, -0.27618131f, 
    -0.25008136f, 0.18851380f, -0.29234838f, 0.44382769f, -0.17215908f, 0.26129612f, 0.04593835f, 0.03346383f, 
    -0.35787842f, 0.19245259f, -0.22040991f, 0.15352234f, 0.31002343f, 0.51953316f, 0.66479856f, 0.07948292f, 
    -0.23390928f, 0.21658838f, 0.25825265f, -0.30750942f, 0.22820012f, -0.01574338f, 0.16841841f, 0.27053994f, 
    -0.38102683f, -0.39157313f, 0.16514891f, 0.16697037f, 0.10988681f, -0.07047289f, -0.11788142f, 0.34745783f, 
    0.11176781f, -0.21615617f, -0.00651819f, 0.35355875f, 0.16373391f, 0.09325301f, -0.07282805f, 0.14772561f, 
    0.19893853f, 0.58182132f, -0.12212121f, -0.37425339f, 0.03518176f, 0.39114386f, 0.16056988f, -0.24488850f, 
    -0.00249381f, -0.00714504f, -0.11488548f, -0.21946929f, -0.24347502f, -0.04508227f, 0.22999176f, 0.17637239f, 
    0.03003572f, 0.02791799f, 0.02192082f, -0.20365493f, 0.05534490f, -0.12273810f, -0.20385920f, -0.17895029f, 
    -0.16999026f, -0.03481698f, 0.18191448f, -0.35541993f, -0.22313039f, -0.14700250f, 0.09587141f, 0.46658069f, 
    0.16979691f, 0.25335082f, -0.10831710f, 0.21398853f, -0.02731262f, -0.44810322f, -0.45413968f, 0.12562017f, 
    0.02235866f, -0.02364687f, 0.10461651f, -0.05922630f, -0.17502247f, -0.16524069f, -0.24850500f, 0.10659435f, 
    -0.25778267f, -0.08518419f, 0.13504669f, 0.01841227f, 0.07237601f, -0.12190393f, -0.30918366f, 0.21101917f, 
    -0.16252433f, -0.13135047f, 0.35631222f, 0.49190149f, 0.19985507f, 0.51879275f, 0.18447909f, -0.02591371f, 
    -0.55176586f, -0.29811743f, 0.47308362f, -0.05222598f, -0.46519256f, 0.12877224f, -0.15472755f, 0.09601979f, 
    0.05522548f, -0.11589975f, -0.06985375f, 0.37144056f, -0.02324852f, 0.04183564f, 0.08061338f, 0.11627050f, 
    -0.35647035f, -0.10662667f, -0.30045426f, 0.23448737f, -0.04478600f, 0.09252470f, -0.41249055f, -0.32439077f, 
    0.01426417f, 0.03911499f, -0.44339374f, 0.42753699f, -0.08327658f, -0.20283274f, 0.14863977f, 0.00798565f, 
    0.27848628f, 0.49329805f, 0.00432317f, -0.00622325f, -0.16217710f, -0.58004606f, 0.44592777f, 0.23231378f, 
    0.03554235f, 0.30936176f, -0.27688625f, 0.27087161f, 0.27234399f, -0.64673352f, 0.20695625f, 0.18513285f, 
    -0.29774421f, 0.38390428f, -0.59866107f, 0.36309129f, 0.12016542f, -0.04527153f, 0.43335381f, -0.39431286f, 
    -0.77314419f, 0.36549276f, 0.55516708f, -0.21850830f, 0.17927112f, 0.09622554f, 0.05187638f, 0.38156399f, 
    -0.53913647f, -0.08279178f, -0.20275262f, -0.05276125f, 0.07248668f, -0.15481888f, -0.19943614f, 0.24638461f, 
    -0.19944070f, -0.22419108f, 0.28428924f, -0.35884568f, 0.15311322f, -0.30769229f, 0.02498213f, 0.01080061f, 
    0.10067053f, -0.58955204f, 0.25177869f, 0.01997930f, -0.11602322f, 0.27961364f, 0.07558168f, 0.52991027f, 
    0.17092210f, 0.28192845f, 0.28046045f, 0.10528803f, -0.14180306f, 0.18387155f, -0.17584744f, -0.05391303f, 
    -0.09232640f, -0.12220953f, -0.27649716f, 0.07378840f, -0.02239587f, -0.08203007f, -0.06667892f, -0.17115644f, 
    -0.05604922f, 0.10335694f, 0.09293602f, -0.11033896f, -0.03353138f, 0.14532250f, 0.08602989f, 0.04638920f, 
    -0.13442943f, -0.05963006f, -0.07625833f, -0.24182849f, -0.03898945f, -0.17412458f, -0.10808026f, -0.26088282f, 
    -0.00878966f, -0.36863902f, 0.61099386f, -0.10117757f, -0.19797474f, -0.09399566f, -0.07761648f, -0.07062385f, 
    -0.18554786f, -0.17207751f, -0.07258014f, -0.21721151f, 0.28968269f, 0.07340370f, 0.19531846f, 0.40390149f, 
    -0.04954357f, -0.03094655f, -0.12826903f, 0.12592286f, 0.16596438f, -0.90307015f, 0.09885700f, 0.44010842f, 
    -0.43151233f, 0.01778956f, 0.10558712f, -0.18526360f, -0.19453038f, 0.45939749f, -0.33905709f, -0.00265501f, 
    -0.20226842f, -0.19659987f, -0.24169242f, -0.05993238f, -0.10814303f, -0.10338828f, -0.02909359f, 0.05486709f, 
    -0.06674677f, -0.00472626f, -0.16954926f, -0.17058572f, 0.02921116f, -0.18743843f, -0.01041278f, -0.23749989f, 
    0.01054995f, 0.05811556f, -0.48289937f, -0.12640725f, 0.21163362f, 0.12702939f, -0.16775621f, 0.37762746f, 
    -0.59876043f, 0.53668714f, -0.33325550f, -0.65170085f, 0.12996283f, -0.15122281f, 0.21975137f, 0.07212107f, 
    -0.03264183f, 0.19158264f, -0.04949899f, -0.33199799f, 0.08240255f, -0.34482500f, 0.03390689f, -0.08684959f, 
    0.16193491f, 0.02958786f, 0.44996604f, 0.27421483f, -0.21854600f, 0.03487680f, 0.45529318f, -0.03211652f, 
    0.11573724f, -0.06927872f, -0.18839903f, 0.32678634f, 0.05801707f, -0.34496477f, 0.01731018f, 0.29045278f, 
    -0.68905276f, 0.34444574f, -0.32369134f, 0.33071867f, -0.24203333f, 0.76172394f, -0.26752070f, -0.39030764f, 
    -0.01539483f, 0.15006964f, -0.15104859f, -0.10486603f, 0.04543995f, -0.73245853f, 0.05866636f, 0.43368500f, 
    -0.05074655f, 0.17804579f, 0.01749634f, 0.25953841f, -0.05615157f, -0.53271395f, 0.38814491f, -0.07649468f, 
    0.23927014f, -0.20365083f, -0.15256263f, 0.10282359f, 0.22237164f, 0.47588703f, -0.15926160f, 0.04932319f, 
    0.01196890f, 0.21113676f, 0.36732996f, -0.30107450f, -0.12244034f, 0.22935709f, 0.11350299f, -0.32880440f, 
    -0.34856623f, 0.16135551f, -0.14234142f, 0.48160723f, -0.14093214f, -0.37686095f, -0.11315475f, -0.05517276f, 
    -0.09177092f, -0.31009462f, 0.04595038f, 0.09317693f, -0.07389133f, -0.50148523f, 0.15576671f, 0.32280713f, 
    -0.26189750f, 0.36637560f, 0.07880599f, -0.40860745f, -0.04310707f, -0.02644682f, 0.21199672f, 0.32148257f, 
    0.04097280f, -0.26158834f, 0.07485703f, 0.12490877f, -0.03636653f, 0.08703579f, 0.04684483f, 0.01160466f, 
    -0.21012503f, -0.16195765f, -0.19948938f, 0.18384773f, -0.11838490f, 0.15011904f, -0.03727317f, -0.12941208f, 
    -0.24856788f, 0.07669079f, 0.16849038f, -0.12160674f, -0.05226845f, -0.09951109f, -0.05870000f, -0.13176337f, 
    -0.33334932f, 0.40713876f, 0.10891809f, -0.33201435f, 0.20186181f, -1.15000045f, -0.18930182f, 0.22558597f, 
    -0.13114049f, -0.16884151f, 0.04811994f, -0.15938200f, 0.16846928f, 0.23999779f, 0.38486138f, 0.03163121f, 
    0.14593950f, -0.24830654f, 0.05922570f, 0.42003796f, -0.08869976f, 0.22074033f, -0.15539132f, 0.43488494f, 
    -0.60784799f, -0.30333167f, 0.44156516f, 0.00385398f, -0.39836785f, 0.51568365f, -0.44479683f, -0.26242796f, 
    0.18305068f, -0.17999433f, 0.51845789f, -0.41901207f, 0.23257996f, -0.48617697f, -0.15883946f, 0.19546162f, 
    0.27361268f, 0.03635279f, -0.04397209f, -0.31765032f, 0.00518901f, -0.23866582f, -0.24854475f, 0.35148323f, 
    -0.31098995f, -0.63166583f, 0.24634881f, 0.27830088f, -0.23967066f, -0.05060280f, -0.06218759f, 0.25661972f, 
    0.22841807f, 0.24636909f, -0.25691929f, -0.13902389f, -0.10442691f, -0.48154631f, -0.23486176f, 0.25544757f, 
    -0.29946980f, 0.14528027f, -0.04125651f, -0.26061797f, 0.10415240f, -0.07286356f, -0.12029642f, -0.12321772f, 
    0.12899241f, -0.18112530f, -0.23133843f, 0.07283842f, -0.09434420f, -0.09817600f, -0.13797340f, -0.28266886f, 
    0.01187296f, -0.27100527f, 0.06309865f, 0.13349567f, 0.22618224f, -0.16303624f, -0.24510524f, 0.10005204f, 
    -0.15112910f, -0.02953635f, 0.00268801f, -0.21373942f, -0.23897481f, 0.00321173f, -0.09230970f, -0.25541076f, 
    -0.24250913f, 0.38994756f, -0.17600153f, -0.03329048f, -0.05282138f, 0.03401509f, 0.13730465f, 0.33648551f, 
    0.15911385f, -0.61276466f, 0.02493507f, -0.04877218f, 0.15217327f, 0.35277417f, -0.00713727f, -0.18195200f, 
    -0.13522306f, 0.37841320f, -0.76457334f, 0.40634570f, -0.02472137f, 0.30521992f, 0.04277290f, 0.38131315f, 
    0.42846504f, 0.44450927f, 0.08873960f, -0.24080147f, -0.36655489f, 0.07213034f, -0.32937813f, -0.07206116f, 
    -0.46852106f, 0.17603940f, 0.37208760f, 0.24645774f, 0.13785818f, 0.32562369f, -0.17382202f, -0.10650145f, 
    -0.47197041f, -0.48925787f, 0.28333580f, 0.22707883f, -0.37775090f, 0.32297599f, 0.12187549f, -0.10237636f, 
    -0.14535718f, 0.20920768f, -0.57298464f, 0.30999875f, -0.07231145f, -0.50879967f, 0.11047867f, 0.03311255f, 
    -0.18166076f, 0.23398811f, -0.24612278f, 0.07930359f, 0.24547359f, -0.06065638f, 0.26113251f, 0.03846658f, 
    -0.46874103f, 0.22650191f, 0.07841730f, -0.18843095f, 0.10087055f, 0.10932088f, 0.18664597f, 0.39589462f, 
    -0.17494236f, -0.20921730f, -0.51764476f, 0.34963229f, 0.06663074f, 0.18831286f, -0.24253865f, -0.07886721f, 
    0.31424439f, 0.20237643f, 0.65309495f, -0.17475381f, -0.20729122f, 0.30007666f, -0.22615883f, -0.13123602f, 
    -0.31173429f, 0.17624789f, -0.14121798f, -0.22542441f, 0.29207334f, 0.37799746f, 0.42507520f, 0.05384089f, 
    -0.72583860f, -0.17044686f, -0.11117327f, 0.39829397f, 0.24540119f, 0.11142109f, 0.13273685f, -0.17517960f, 
    -0.00011714f, 0.28217703f, 0.20527539f, 0.27840817f, -0.03196112f, -0.44359195f, 0.35853544f, -0.25043187f, 
    -0.04786366f, -0.02988208f, 0.19989344f, 0.14735934f, 0.16185665f, 0.14550376f, 0.02694684f, 0.12139659f, 
    0.36181161f, -0.32406473f, 0.21982154f, -0.14765918f, -0.41957900f, -0.41406628f, -0.42766502f, 0.14514205f, 
    0.30421922f, -0.02679426f, -0.21729398f, -0.22748575f, 0.15069589f, -0.04245009f, 0.07838714f, -0.03402215f, 
    -0.00072692f, -0.20459381f, 0.15352792f, -0.20651384f, 0.02347536f, 0.06940806f, -0.07444809f, 0.37286606f, 
    0.09322017f, -0.05250110f, 0.69488549f, -0.03630241f, 0.09644803f, 0.30248606f, 0.10513759f, -0.00930743f, 
    -0.27822450f, -0.45902371f, -0.11268573f, -0.11621977f, 0.07264029f, -0.47240165f, 0.15448451f, 0.06425912f, 
    -0.38739336f, 0.00287955f, -0.05594584f, 0.14760233f, -0.10495830f, -0.00137354f, -0.23066664f, 0.41463280f, 
    0.19698299f, -0.04345098f, -0.15497650f, 0.00254736f, 0.06583407f, -0.25538227f, -0.51501906f, 0.20201878f, 
    -0.50558019f, -0.21183856f, 0.33035722f, 0.06318466f, 0.14387694f, -0.04137320f, 0.00247110f, 0.03528132f, 
    0.24726684f, -0.06778810f, 0.34630752f, -0.34625226f, -0.02312278f, 0.34081668f, 0.19987971f, 0.13069592f, 
    -0.24014965f, 0.22481221f, -0.07092842f, -0.15803917f, -0.13801768f, -0.19453736f, -0.24099082f, 0.48019931f, 
    0.42203787f, 0.02433558f, -0.37119824f, -0.14756951f, -0.25708300f, -0.54673457f, 0.03235789f, 0.10005721f, 
    -0.06336472f, -0.24690641f, 0.25834459f, 0.03060624f, -0.23252046f, 0.31169698f, -0.07317545f, -0.29012060f, 
    -0.23160812f, -0.10333174f, 0.36590520f, 0.13662450f, 0.03579486f, 0.41201681f, 0.58808768f, 0.01661883f, 
    -0.30153540f, 0.05685869f, 0.28345793f, 0.32947469f, 0.07360449f, -0.06647979f, -0.07159504f, -0.31145057f, 
    0.02797576f, 0.08038002f, -0.39694983f, 0.22114284f, 0.36292586f, 0.00054124f, -0.37072808f, -0.24607499f, 
    0.23845518f, -0.18702729f, 0.16081101f, -0.02800128f, -0.04307577f, 0.23890668f, 0.00889826f, 0.11172740f, 
    0.00140965f, 0.00363724f, 0.36910939f, -0.33308902f, -0.10068252f, 0.38551804f, -0.04482284f, -0.12446525f, 
    0.08719902f, 0.33778733f, 0.13060381f, 0.22085728f, -0.19653200f, 0.24155651f, -0.19532345f, -0.35797292f, 
    -0.10556091f, -0.17229681f, 0.23141274f, -0.08127831f, 0.16076423f, 0.27601916f, 0.68663710f, -0.16287543f, 
    -0.05516940f, 0.27279538f, -0.10675032f, 0.31110638f, -0.24119809f, 0.38603795f, 0.23040748f, 0.16208588f, 
    0.06626660f, -0.11583797f, 0.14415017f, 0.05283312f, -0.48026460f, 0.63562733f, -0.22897577f, -0.26703772f, 
    0.20638448f, 0.03558571f, 0.21153872f, -0.14455912f, 0.07491392f, 0.08459032f, -0.09497177f, -0.12684189f, 
    0.06409824f, 0.37906802f, 0.40061018f, 0.31241110f, -0.44563758f, 0.16193007f, 0.26794782f, -0.05234079f, 
    0.26286262f, 0.03105542f, 0.29456985f, 0.07439284f, -0.22415133f, 0.33169433f, -0.21176191f, -0.29717252f, 
    -0.06512035f, 0.21322751f, 0.11446909f, 0.20408918f, -0.19285440f, 0.39920244f, 0.41753024f, -0.05951744f, 
    -0.11329750f, 0.00326065f, 0.25805584f, 0.38781807f, 0.23704700f, 0.28805265f, 0.16409415f, -0.44872862f, 
    -0.24157098f, 0.23565267f, 0.13143916f, 0.36966476f, 0.14067838f, 0.30081841f, -0.55701607f, 0.01428579f, 
    -0.09488679f, -0.03433242f, 0.10543133f, 0.37408492f, 0.06945660f, 0.06762136f, 0.15845630f, 0.24785788f, 
    0.30075893f, 0.40715674f, -0.52389175f, -0.10780308f, -0.09332021f, -0.43357077f, 0.15008344f, 0.00052089f, 
    0.20575501f, 0.04250782f, 0.06577492f, -0.17663920f, -0.05806163f, 0.01804802f, -0.21368253f, -0.87505221f, 
    -0.06411514f, -0.15067776f, 0.24449435f, 0.25086528f, 0.07632890f, -0.53549290f, -0.04640684f, 0.20105547f, 
    -0.23291673f, -0.17055386f, -0.04473361f, -0.07685156f, 0.12077758f, 0.24027526f, 0.15447833f, 0.07163159f, 
    0.19237001f, 0.05376166f, 0.31627634f, -0.06354097f, 0.04399307f, 0.31943330f, -0.15859884f, 0.16970317f, 
    -0.37470502f, 0.45512152f, 0.47910601f, -0.37219465f, -0.23208828f, -0.07549090f, -0.18365444f, 0.34848768f, 
    0.04514956f, -0.38736817f, -0.28832296f, 0.39597961f, -0.19268745f, 0.04584130f, 0.17198607f, -0.28147414f, 
    -0.31551990f, -0.20376529f, 0.00746336f, 0.02375187f, 0.22118002f, 0.20535982f, 0.03903345f, 0.12477600f, 
    0.15668568f, -0.43705755f, -0.33595333f, -0.01199910f, 0.39110959f, -0.18068871f, 0.43403113f, 0.13092130f, 
    -0.37954926f, 0.18767683f, -0.00847182f, 0.16056526f, 0.01880257f, 0.22331646f, -0.16967681f, 0.08747502f, 
    0.31029481f, 0.24301951f, -0.33768260f, 0.14596164f, 0.34854457f, -0.37820312f, 0.52978909f, 0.00837643f, 
    0.20468521f, 0.34783271f, 0.29537177f, -0.23753232f, -0.07650447f, -0.11435015f, -0.15550834f, 0.15594706f, 
    -0.42681143f, -0.02473212f, 0.33405992f, 0.30340821f, -0.69075364f, -0.14537114f, -0.19640544f, 0.04695115f, 
    -0.25992513f, -0.19411859f, -0.12370889f, -0.06751040f, -0.19782577f, 0.30089116f, 0.15121941f, 0.25346735f, 
    0.18931444f, 0.33819443f, 0.08820810f, 0.23206033f, 0.01823644f, 0.47452652f, -0.50366580f, -0.19620310f, 
    0.41640991f, -0.09517679f, 0.30500782f, 0.05497323f, -0.12608059f, 0.38455680f, -0.17543682f, 0.07437418f, 
    0.15158795f, -0.02321108f, 0.29291072f, -0.26997688f, -0.52421993f, -0.24662879f, 0.00143645f, -0.10923175f, 
    0.26229933f, 0.28004739f, -0.43554559f, -0.38967350f, -0.11510346f, -0.21853122f, -0.05490305f, 0.19262597f, 
    -0.27211845f, 0.36125356f, 0.12164433f, 0.07646845f, -0.07111168f, 0.25743422f, -0.27811164f, 0.06879693f, 
    -0.27158731f, 0.26260269f, 0.22529629f, 0.13403681f, -0.13594562f, 0.11885146f, 0.23424779f, -0.19189474f, 
    0.23941708f, -0.78505898f, 0.01975884f, -0.29919907f, 0.37276384f, -0.20022176f, -0.03791101f, 0.19330522f, 
    -0.31803805f, -0.22437049f, -0.27953759f, 0.32866028f, 0.09356419f, -0.07862400f, 0.04644066f, 0.36955741f, 
    0.54076755f, 0.55834591f, -0.51038963f, -0.41776460f, 0.47120425f, -0.64095002f, -0.04165320f, 0.08961175f, 
    -0.13455531f, -0.20090634f, -0.31419146f, -0.18272588f, 0.16091987f, -0.11463103f, -0.18963143f, 0.18503672f, 
    -0.23425388f, 0.20059183f, 0.09919633f, -0.04055034f, 0.15629219f, -0.05679445f, -0.22782822f, -0.31874755f, 
    -0.17380868f, 0.31004927f, 0.27425864f, 0.22254421f, 0.24248111f, -0.41969520f, -0.10465475f, -0.16135430f, 
    -0.23387712f, 0.10653443f, 0.67556477f, 0.15933530f, 0.12430886f, -0.55585319f, 0.01085697f, -0.37922823f, 
    0.16455454f, -0.26387033f, -0.03603038f, -0.20538926f, 0.13084094f, -0.39203230f, 0.12821341f, 0.02534033f, 
    -0.26151079f, 0.34570837f, 0.04868120f, 0.20793910f, -0.33322763f, 0.26647380f, 0.08833462f, -0.13848498f, 
    -0.76379281f, 0.32682028f, 0.51659304f, 0.28967300f, -0.11795495f, -0.27818736f, 0.11926586f, 0.00888473f, 
    -0.25329420f, -0.47909838f, 0.33123550f, -0.07876488f, -0.16531217f, 0.00804877f, -0.04826188f, 0.09093735f, 
    -0.22589704f, 0.22374690f, 0.18878627f, 0.15829404f, 0.11173291f, -0.43860260f, -0.14706033f, 0.04179487f, 
    -0.21448453f, 0.30286473f, -0.63555491f, 0.27743125f, 0.27134192f, 0.09681335f, 0.47615606f, -0.09664029f, 
    0.12861292f, -0.15273400f, -0.13770650f, 0.19966120f, 0.07999541f, 0.18996365f, 0.19191290f, -0.10417821f, 
    0.12384021f, 0.25711879f, -0.03190558f, -0.08340159f, -0.11301497f, -0.21794541f, 0.85008937f, 0.23135234f, 
    -0.21891589f, 0.25002277f, 0.11576675f, -0.24106996f, 0.09387738f, -0.21431929f, 0.13521175f, -0.07106804f, 
    -0.22304340f, 0.12334608f, 0.48338050f, -0.16416140f, 0.02479896f, 0.09701452f, 0.29599762f, 0.21184936f, 
    -0.07143746f, -0.26876226f, -0.27979383f, 0.33063164f, 0.03044971f, 0.04763489f, -0.15292326f, -0.10058092f, 
    0.14556392f, -0.14391968f, -0.05282698f, -0.01740826f, -0.10474263f, 0.16344407f, 0.56287897f, 0.08721756f, 
    0.30007741f, -0.17535698f, -0.10377167f, 0.11222187f, -0.03415331f, 0.31533629f, 0.13177440f, 0.07341023f, 
    0.10776433f, -0.17296374f, 0.15119457f, -0.39435160f, 0.06439942f, 0.22052947f, -0.24439971f, 0.11766457f, 
    -0.47864598f, 0.28909987f, 0.09054095f, -0.14547870f, -0.17069075f, -0.69098473f, -0.15990862f, 0.21942560f, 
    -0.27916297f, -0.25438279f, 0.65423572f, 0.42465058f, -0.12952210f, 0.54481220f, -0.01558565f, -0.39157546f, 
    -0.06216880f, -0.08728179f, -0.40395769f, 0.59942788f, -0.05624165f, 0.14515226f, -0.19986741f, -0.10476895f, 
    0.45386600f, 0.42323229f, 0.29146987f, 0.20149472f, -0.28516772f, -0.13539498f, 0.39353511f, -0.07169259f, 
    0.08395419f, -0.26502705f, -0.29981792f, -0.25183865f, 0.11335216f, 0.13535909f, 0.07291037f, 0.28589338f, 
    -0.06388070f, 0.13122185f, -0.20020129f, 0.20722012f, 0.17390211f, 0.22411336f, 0.22215870f, -0.41637796f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.15508522f, -0.08573326f, -0.13743277f, -0.39881319f, 0.18936472f, 0.05939376f, 0.34289128f, 0.26969823f, 
    -0.16814917f, 0.46715662f, -0.18967985f, 0.29867497f, 0.40711483f, 0.28735256f, 0.10731633f, -0.12768357f, 
    0.20860329f, 0.33253935f, 0.31793466f, -0.17153434f, 0.08905932f, 0.50310624f, -0.34920472f, -0.37039563f, 
    -0.07823338f, -0.00288978f, 0.06455846f, -0.32609460f, 0.23285161f, -0.37456289f, 0.05428218f, -0.14005846f, 
    0.08259597f, -0.15316065f, 0.05452232f, -0.24672355f, 0.06517445f, -0.02517972f, 0.16237749f, 0.45909816f, 
    0.05480035f, -0.13420947f, -0.24683565f, 0.22180073f, 0.02441751f, 0.18919675f, 0.22571723f, -0.11581794f, 
    0.13613975f, -0.11693115f, -0.33608323f, 0.51530886f, 0.02483586f, 0.17640212f, -0.02027219f, -0.06337888f, 
    0.29639193f, 0.17470115f, -0.04024500f, -0.02714588f, -0.11230824f, -0.13409919f, 0.24875590f, 0.11400774f, 
    0.43317556f, 0.18796524f, 0.09718555f, 0.06345869f, -0.09007254f, 0.14844681f, 0.23069032f, -0.11760820f, 
    0.17471196f, 0.08941837f, 0.03721981f, 0.45052695f, -0.16399601f, 0.39694807f, -0.15357523f, 0.17888750f, 
    0.35065132f, 0.11833485f, 0.14331794f, 0.12356015f, 0.17699568f, 0.06608128f, -0.33786151f, 0.11261132f, 
    0.24098213f, -0.12102961f, 0.10338788f, 0.27186328f, 0.28467992f, -0.09968504f, 0.28852949f, -0.07384237f, 
    0.36571747f, -0.11454916f, 0.08769915f, 0.00111467f, 0.14938633f, 0.03894893f, 0.07471842f, -0.29409811f, 
    0.00935316f, -0.19809966f, 0.19861424f, 0.36925098f, -0.04567822f, -0.21680042f, 0.09189395f, 0.21939540f, 
    -0.04324003f, -0.13049485f, 0.01492000f, -0.04350875f, -0.24409394f, 0.15519592f, -0.25002447f, 0.04164832f, 
    0.40736985f, -0.08996382f, 0.04650997f, 0.11017777f, -0.22530322f, 0.45563549f, -0.08428191f, -0.07822142f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.08682379f, 0.11459531f, -0.05948161f, 0.02468443f, -0.49597606f, -0.03676971f, 0.18526500f, -0.30166978f, 
    0.05324580f, -0.02383307f, -0.34081703f, 0.31582892f, 0.14383937f, -0.13913836f, -0.03765842f, 0.09067888f, 
    -0.36716682f, -0.34054950f, -0.21387675f, 0.23125774f, -0.08240224f, 0.12271080f, -0.02992835f, -0.18139225f, 
    0.43637526f, -0.31310821f, 0.01682295f, 0.02586948f, 0.03521907f, 0.17018455f, -0.08016779f, 0.00221309f, 
    0.20408264f, -0.50289673f, -0.32932228f, -0.25388274f, -0.15029141f, 0.02337676f, -0.27119771f, -0.14089395f, 
    -0.25132012f, -0.04605839f, 0.04217807f, -0.34432325f, -0.19934845f, -0.02032304f, -0.20937701f, 0.02398803f, 
    -0.24029359f, -0.24868713f, 0.06877340f, -0.72339267f, 0.12784533f, -0.35153362f, 0.18413943f, 0.00518952f, 
    -0.33368796f, -0.15549763f, 0.16385575f, -0.15193412f, 0.23882140f, 0.19053805f, -1.06520259f, -0.19825019f, 
    -0.18160352f, 0.07396026f, -0.02891861f, -0.01891312f, -0.03107817f, 0.05892605f, -0.02721227f, 0.11328278f, 
    0.06320269f, -0.49032664f, 0.19181632f, -0.44712600f, -0.00272681f, -0.21415527f, -0.17282480f, -0.08473577f, 
    0.11085838f, -0.05882791f, -0.00117568f, -0.71591771f, 0.14283247f, -0.21745469f, 0.13086496f, -0.77452350f, 
    -0.00740009f, 0.72960329f, -0.77139425f, -0.13798195f, 0.07004762f, -0.42711195f, -0.01592467f, -0.25665191f, 
    0.08707561f, -0.06611131f, 0.36424443f, 0.07508872f, -0.08407220f, -0.04176046f, 0.03257404f, 0.09474951f, 
    0.19103432f, 0.10940474f, -0.25546339f, -0.68537951f, 0.02671349f, 0.13059963f, -0.38414991f, -0.25015983f, 
    -0.35800570f, -0.17009357f, 0.04632319f, 0.09734452f, 0.05688762f, -0.94899899f, -0.07630840f, -0.36968267f, 
    0.09968212f, 0.16758418f, -0.00952188f, 0.15084234f, -0.17188230f, -0.37320110f, 0.23623972f, -0.11241037f, 
    -0.12978718f, -0.05130259f, 0.04713551f, -0.30102938f, -0.60350251f, -0.34068647f, -0.02428304f, -0.90275830f, 
    -0.10393596f, -0.43019131f, -0.09997045f, -0.55919880f, -0.32931313f, -0.10737542f, 0.25968099f, 0.16249129f, 
    -0.25238106f, 0.43300647f, 0.14038262f, -0.01212722f, -0.07320301f, 0.11608712f, -0.14317258f, -0.02226415f, 
    -0.82212317f, 0.06771120f, 0.06275117f, -0.04369498f, -0.20071360f, -0.10530520f, -0.01529758f, -0.02175205f, 
    -0.01441763f, -0.02892457f, -0.27221799f, -0.14777325f, 0.05919260f, -0.00211994f, 0.03351646f, -0.11790101f, 
    -0.03338443f, -0.21025100f, 0.00755137f, -0.05164199f, 0.09925318f, 0.12979098f, -0.01326875f, -0.20800354f, 
    -0.04842589f, -0.20633793f, 0.11296830f, 0.11853211f, 0.19927551f, -0.15914880f, 0.41631746f, -0.04213403f, 
    -0.29022926f, -0.06176139f, -0.07454532f, 0.12891208f, -0.13829462f, 0.22548997f, -0.66479170f, -0.67634523f, 
    0.14003755f, 0.05982222f, -0.24505576f, 0.00878355f, 0.06098822f, -0.41666457f, -0.04299932f, 0.34500459f, 
    0.01077120f, 0.62370563f, -0.52073109f, -0.00725172f, 0.04310231f, -0.10437590f, 0.19380507f, -0.12331522f, 
    -0.89722478f, -0.03486959f, 0.00719030f, 0.10900006f, 0.15906101f, 0.00923443f, 0.03612688f, -0.02142825f, 
    0.18014295f, -0.47846276f, 0.22056484f, 0.00944191f, 0.14972226f, -0.32680774f, -0.11213262f, -0.34011379f, 
    0.12532593f, 0.07006340f, 0.30691364f, 0.19069052f, 0.32264629f, 0.07418121f, 0.14397755f, -0.05029196f, 
    0.02653888f, 0.14876984f, -0.02593708f, 0.11630483f, -0.09192820f, -0.02438125f, -0.20150851f, 0.03773139f, 
    0.38929453f, -0.02436521f, 0.04953406f, -0.82993388f, 0.03477313f, -0.31558654f, 0.26255208f, -0.28317672f, 
    0.15234613f, 0.02965563f, -0.37653020f, 0.07575561f, 0.13295521f, 0.18644613f, 0.13774502f, -0.28804746f, 
    0.17627324f, -0.23944549f, 0.01876931f, -0.42539382f, 0.06216027f, 0.28587118f, 0.22562322f, 0.39830056f, 
    0.05025270f, 0.25742418f, 0.17426573f, -0.91001439f, 0.17182389f, 0.07809268f, -0.14467683f, 0.10396311f, 
    -0.22850442f, -1.08982015f, -0.15738377f, -0.23542495f, 0.05728921f, -0.43848869f, -0.21276262f, -0.25048086f, 
    -0.05235661f, -0.29859582f, 0.12650938f, 0.15102966f, -0.08074737f, -0.02124928f, -0.08944231f, 0.05857713f, 
    -0.07030562f, -0.06704566f, 0.12875226f, -0.17489715f, -0.10722648f, -0.06086206f, -0.04954546f, 0.25455865f, 
    -0.04444041f, -0.17813037f, 0.01640272f, 0.53276497f, -0.07875126f, -0.16805939f, 0.08202121f, 0.12852225f, 
    -0.16171461f, 0.08505432f, 0.25846931f, -0.19334175f, -0.12163371f, 0.07004616f, 0.08428137f, -0.05665914f, 
    -0.09051409f, 0.07990383f, 0.23583581f, -0.46642113f, -0.49850965f, -1.06094813f, 0.20851034f, 0.21917558f, 
    -0.15773034f, 0.07308415f, 0.16887878f, 0.29955795f, -0.01556212f, -0.44246051f, 0.11624034f, -0.07789391f, 
    -0.46508807f, -0.24216694f, -0.55732334f, 0.00746417f, -0.06425356f, 0.36876819f, 0.18029425f, -0.00165177f, 
    -0.31882820f, 0.02367062f, -0.01570115f, 0.07086473f, -0.18155344f, 0.09161416f, -0.40374467f, 0.01474005f, 
    0.03407880f, -0.41343924f, -0.56190228f, 0.01069721f, -0.07456531f, -0.09355790f, 0.48612243f, -0.76174206f, 
    0.27416351f, 0.10592478f, 0.25374442f, -0.02725304f, 0.10465109f, 0.00742610f, 0.04575860f, 0.10282938f, 
    -0.86396843f, 0.29936647f, 0.18015957f, -0.05044027f, -0.01204277f, -0.18851791f, -0.18036059f, 0.10600018f, 
    -0.47168553f, 0.00666535f, 0.05772284f, -0.32985011f, 0.00821438f, -0.55719799f, -0.14102595f, 0.31602558f, 
    -0.04791042f, -0.16429733f, 0.25002006f, 0.00815513f, -0.17807400f, 0.42095938f, -0.23166920f, -0.27289033f, 
    -0.11345758f, -0.05047323f, 0.04727356f, 0.01067290f, 0.38458297f, 0.27795196f, -0.31937429f, 0.40824220f, 
    -0.03161241f, 0.14429760f, -0.05442754f, 0.24217562f, 0.03431664f, -0.10560834f, -0.10678386f, -0.12160934f, 
    -0.09418027f, -1.17110455f, -0.09631377f, -0.21483642f, -0.04092401f, -0.10944304f, -0.07723216f, -0.28194511f, 
    0.27363855f, -0.32582760f, -0.11900827f, 0.01499955f, 0.11895247f, 0.07198209f, -0.02476561f, -0.00076347f, 
    0.01172345f, -0.03279319f, 0.30719662f, -0.32919669f, -0.30640024f, -0.09103416f, -0.38043651f, 0.13391875f, 
    -0.15582862f, 0.02102028f, 0.08304894f, 0.05304522f, 0.02704591f, -0.61382550f, 0.10000836f, 0.19095194f, 
    -0.14156847f, -0.61459470f, -0.10640228f, -0.23004223f, 0.03356785f, -0.00964377f, 0.00552654f, 0.08100031f, 
    0.08328229f, 0.01877476f, 0.33227828f, 0.18213943f, 0.00012461f, -0.02355072f, 0.13783276f, -0.06186980f, 
    -0.06294356f, 0.07051630f, -0.04688014f, 0.22382233f, 0.05743954f, 0.08136768f, -0.81814420f, 0.05179152f, 
    0.02750993f, -0.47319311f, 0.27267647f, -0.13223107f, 0.03397071f, -0.12008621f, 0.32609582f, -0.33920258f, 
    0.51726043f, -0.01284394f, -0.01019075f, -0.00570857f, 0.21342349f, 0.01018707f, 0.03068999f, 0.00814036f, 
    -0.53476727f, -0.08387616f, -0.49704841f, -0.54510039f, -0.74351484f, 0.39209101f, 0.01336207f, 0.04316500f, 
    -0.22531101f, 0.69786972f, -0.53900665f, -0.28703785f, -0.02752750f, -0.51691586f, -0.44671422f, 0.59170449f, 
    0.04845113f, -0.55131656f, 0.04890072f, -0.23414747f, 0.15080245f, 0.00759882f, -0.12835459f, -0.00683204f, 
    -0.40490168f, -0.12958176f, 0.21608993f, 0.36503673f, -0.04029095f, 0.44861341f, 0.08024999f, 0.21158780f, 
    0.01403099f, -0.07069775f, -0.26171955f, 0.04675052f, -0.61466110f, -0.03044041f, 0.04483372f, -0.09774967f, 
    -0.05903240f, 0.13690381f, 0.01229848f, 0.24897003f, -0.31090492f, 0.24193157f, -0.38833565f, 0.04321564f, 
    0.00265698f, 0.27713627f, 0.05968714f, 0.16247612f, 0.05231658f, -0.19381779f, -0.21564062f, 0.05270096f, 
    0.13102081f, -0.49214023f, -0.66692984f, 0.06568185f, -0.04459035f, 0.15662885f, 0.04956890f, 0.00599733f, 
    -0.43597379f, 0.06253563f, -0.03825461f, 0.25467020f, 0.13056016f, -0.14347778f, -0.06737407f, -0.02074230f, 
    0.07533827f, -0.22972164f, -0.90014690f, 0.01679777f, -0.10309946f, -0.06006268f, 0.14445549f, -1.31291592f, 
    0.19022326f, 0.19412008f, -0.04516143f, 0.16297017f, -0.03968410f, 0.05529375f, -0.24722883f, -0.17901523f, 
    0.06819586f, 0.17360304f, -0.07521284f, -0.20977290f, 0.02747845f, -0.16685300f, 0.11428270f, 0.03424138f, 
    0.05806553f, -0.05963764f, -0.68806219f, -0.02711168f, 0.17588347f, 0.04341382f, 0.05884185f, -0.15054457f, 
    -0.06318434f, -0.02058252f, -0.01445574f, 0.02181656f, 0.01606094f, 0.42717645f, -0.09321748f, -0.07820147f, 
    0.14699702f, -0.71612060f, -0.08296335f, -0.06434941f, -0.01313181f, 0.16925782f, -0.83058560f, -0.23485172f, 
    -0.20172735f, 0.01254125f, -0.02171221f, -0.29107043f, 0.12802842f, -0.55511153f, 0.16559744f, -0.10040211f, 
    0.11812530f, -1.07340431f, -0.28429991f, -0.02657547f, -0.03375896f, -0.02601853f, -0.09279601f, 0.17502357f, 
    -0.15437807f, -0.24755698f, -0.44645321f, -0.03116985f, -0.31830585f, 0.00647051f, 0.02114859f, 0.15394951f, 
    0.07066534f, -0.06008936f, 0.03488152f, -0.19862369f, -0.10360505f, 0.10179801f, 0.05009087f, -0.14410809f, 
    -0.03447695f, 0.14459233f, -0.01013239f, 0.21909691f, -0.01023313f, 0.35913515f, -0.21281593f, -0.37138113f, 
    0.13794640f, 0.10838968f, 0.26049051f, -0.07656811f, 0.10964207f, -0.37472677f, 0.08250472f, -0.59885454f, 
    -0.15153447f, -0.10110960f, 0.02367479f, -0.00220398f, -0.20326777f, -0.41213015f, -0.10041033f, -0.47297126f, 
    -0.03467976f, -0.23524100f, 0.07641537f, -0.65192074f, 0.07884174f, 0.13720195f, -0.12657969f, 0.03307700f, 
    -0.18383300f, -0.04126173f, 0.22089849f, 0.03282419f, 0.05293390f, 0.07383677f, -0.29699087f, 0.18068314f, 
    0.16984485f, -0.09660421f, 0.09443557f, -0.16684397f, 0.05882716f, -0.00670820f, -0.13496658f, 0.03190387f, 
    0.08045364f, 0.18209487f, 0.00288346f, -0.04469262f, -0.06142564f, 0.06038215f, 0.16990347f, -0.75623780f, 
    -0.09532581f, 0.16409875f, -0.03917887f, 0.02911413f, 0.30950820f, 0.14275478f, -0.19665977f, -0.17378891f, 
    -0.04828845f, -0.01912961f, -0.13737385f, 0.07945634f, 0.07324700f, 0.08282650f, -0.27604386f, 0.04702935f, 
    -0.17011726f, -0.02916713f, -0.06221608f, -0.76415527f, 0.00167187f, 0.02486486f, -0.07124912f, 0.15114829f, 
    -0.01444794f, 0.01648016f, -0.02115063f, -0.18751766f, -0.05826678f, -0.38362426f, 0.17645344f, -0.15115321f, 
    0.09601947f, -0.92788154f, 0.11530853f, 0.14361301f, -0.02906644f, 0.23023884f, -0.39544755f, -0.19761176f, 
    -0.58969128f, 0.04824180f, -0.01865731f, 0.15307432f, -0.11413685f, 0.32759342f, 0.01551369f, -0.08553483f, 
    0.07237482f, 0.76676202f, -0.26631477f, 0.12427459f, -0.27064282f, -0.20935850f, 0.05430460f, 0.03976385f, 
    0.14348908f, -0.73593700f, -0.03284067f, 0.30953670f, -0.05670829f, 0.00226822f, 0.04891464f, -0.27515528f, 
    -0.08475855f, -0.14001486f, -0.01142952f, 0.16062623f, 0.14664507f, 0.11561499f, 0.04275142f, -0.30888170f, 
    -0.34978873f, -0.07852747f, -0.02131011f, 0.18499589f, 0.03859480f, 0.40863323f, -0.30628234f, 0.30551553f, 
    0.01985545f, 0.11573553f, 0.23365685f, 0.10808234f, 0.19865392f, 0.26463947f, 0.00407535f, -0.37793016f, 
    0.22069824f, -0.26645651f, -0.10240813f, -0.29171145f, 0.35404840f, 0.25576925f, 0.28805462f, 0.45938492f, 
    0.05763500f, -0.34553698f, -0.24170813f, -0.33356825f, 0.15571412f, -0.08738078f, 0.00406856f, 0.31165814f, 
    0.27489656f, 0.23225152f, -0.72729826f, -0.31418377f, -0.03811038f, -1.10884714f, -0.06885320f, 0.02367145f, 
    -0.08186022f, -0.01926480f, 0.10809508f, -0.14357384f, -0.18046208f, -0.01677702f, -0.07709963f, -0.03760325f, 
    0.09454424f, -0.04833017f, -0.24960317f, 0.14098538f, -0.01012032f, -0.07589824f, 0.20176649f, 0.22682361f, 
    0.03634399f, -0.30897990f, 0.05543368f, 0.02223929f, -0.15806553f, -0.15268128f, 0.00873215f, 0.28059122f, 
    -0.10357848f, 0.21291803f, -0.23319960f, -0.07570126f, -0.34266919f, 0.20473133f, -0.47766048f, -0.06820870f, 
    0.04264449f, 0.19112904f, 0.50947338f, -0.23151207f, -0.40020567f, -0.88193220f, -0.14726767f, 0.15523328f, 
    0.04647623f, -0.06415778f, 0.24261382f, -0.31664303f, 0.00834632f, -0.13080725f, -0.14377727f, -0.75846070f, 
    -0.82401568f, -0.19017483f, -0.48732683f, -0.01918454f, -0.05350525f, -0.65326113f, 0.48959899f, 0.14552821f, 
    -0.09932000f, -0.03060898f, 0.07722599f, -0.14359659f, -0.97165322f, -0.05790251f, -0.37443706f, -0.60864294f, 
    0.22674000f, -0.11277323f, -0.08774623f, 0.13849816f, 0.31618977f, -0.05466047f, -0.17624904f, -0.70540565f, 
    0.03071445f, -0.24232081f, 0.04707515f, -0.21230470f, -0.15242691f, 0.00984875f, 0.08091331f, -0.09110302f, 
    -0.53321797f, -0.13468146f, 0.01025951f, -0.48829204f, -0.10164758f, -0.34462351f, 0.29759642f, -0.18026905f, 
    0.06748533f, 0.08892936f, -0.07488701f, -0.52905899f, -0.08994086f, -0.46626884f, -0.16076325f, -0.24322565f, 
    -1.14114118f, -0.09368850f, 0.07395487f, -0.13665602f, 0.12729466f, -0.83919770f, -0.57964385f, 0.21229477f, 
    -0.20877731f, 0.14067370f, -0.04298450f, 0.29780439f, 0.06565247f, -0.78185600f, -0.39192891f, 0.08632877f, 
    0.02188342f, 0.28100353f, -0.07927147f, 0.44374272f, -0.82982135f, 0.16648878f, -0.11032648f, -0.42859477f, 
    -0.06434288f, -0.34850511f, 0.34811619f, 0.05267615f, 0.04534827f, -0.89263827f, 0.14614777f, 0.16136631f, 
    0.50684434f, 0.12465407f, -0.22159895f, 0.44070721f, -0.27282110f, 0.03107458f, 0.02023048f, 0.08104377f, 
    -0.04501222f, 0.18075143f, 0.14999045f, 0.01848532f, 0.04998101f, -0.06390526f, -0.17112708f, 0.22529584f, 
    0.16596863f, 0.31050262f, -0.05070395f, -0.70999402f, 0.15364091f, 0.10286974f, 0.13397408f, -0.41878346f, 
    0.04983882f, -0.03764442f, -0.21732126f, -0.04243151f, -0.63283217f, -0.11987790f, 0.06092952f, 0.05246498f, 
    0.09276306f, -0.04892383f, -0.70478535f, -0.12534195f, 0.06144105f, -0.79422933f, -0.07104000f, 0.17250413f, 
    -0.16203660f, -0.00309632f, -0.09850469f, 0.05970714f, -0.08236510f, -0.15932883f, 0.05892383f, -0.34759882f, 
    -0.61397892f, -0.29291028f, 0.18410031f, 0.08268177f, -0.06126197f, -0.31785303f, -0.79672176f, 0.10444438f, 
    0.33862847f, -0.04525882f, -0.00130388f, 0.29817811f, 0.39090309f, -0.20062050f, -0.38466910f, -0.02159687f, 
    -0.37556869f, 0.61071318f, 0.06334000f, -0.02962467f, -0.30007493f, 0.22315076f, 0.13986985f, 0.51797479f, 
    -0.20125051f, -0.11257166f, -0.23390153f, -0.15988098f, 0.03531468f, -0.08262349f, -0.05566081f, 0.06473926f, 
    0.12055192f, 0.06554203f, 0.11006774f, -0.65384406f, 0.03928914f, 0.15287958f, -0.45045561f, 0.10475279f, 
    -0.16985296f, 0.01317887f, -0.04071927f, 0.28851059f, 0.02812097f, 0.16703358f, 0.04403926f, -0.90193242f, 
    -0.95039594f, -0.04076578f, -0.07293228f, 0.06282848f, -0.01921059f, -0.62216485f, 0.13010764f, 0.08625364f, 
    0.01146863f, 0.11921171f, -0.02271109f, -0.14617588f, -0.22424142f, -0.25938120f, -0.12584502f, -0.12026925f, 
    0.02481738f, -0.62752408f, 0.24713705f, -0.35669479f, -0.66380256f, -0.30735320f, 0.20873274f, -0.40234968f, 
    -0.17476185f, 0.19839366f, 0.31421468f, -0.19277728f, 0.02216136f, -0.01704878f, -0.16319016f, -0.27382666f, 
    0.22183682f, 0.04423249f, -0.01006525f, -0.78282303f, -0.98681349f, -0.44913203f, -0.07414532f, -0.05097639f, 
    -0.30404192f, 0.13707234f, 0.62055695f, 0.00868888f, 0.07568390f, 0.00935692f, 0.02285728f, -0.42841005f, 
    0.00287502f, -0.35345712f, -0.07631996f, -0.59454679f, -0.30790946f, 0.10410408f, 0.17918311f, 0.24427167f, 
    0.34300593f, -0.34552866f, -0.00898272f, 0.14343876f, 0.07068683f, 0.08870039f, -0.38095522f, 0.03880199f, 
    0.15693301f, 0.06351674f, 0.29563940f, 0.14041984f, -0.25618786f, -0.58575290f, 0.44824544f, -0.11627056f, 
    0.13165016f, -0.01064443f, -0.02199851f, -0.85511780f, 0.08213140f, -0.08944172f, -0.08847573f, 0.14477247f, 
    -0.75519925f, 0.15469486f, 0.05601600f, 0.06811607f, 0.06500562f, -1.41517007f, 0.11304991f, -0.19515446f, 
    -0.60948342f, 0.03355576f, 0.05449786f, -0.08000415f, 0.05476563f, 0.51571143f, -0.31384909f, 0.39509469f, 
    0.01995984f, -0.24420658f, 0.09654231f, -0.14071092f, 0.30169749f, 0.12846567f, -0.17092037f, -0.27698898f, 
    0.16158134f, -0.11520898f, -0.12373112f, -0.02639222f, 0.25247627f, 0.10216522f, 0.14071758f, 0.19469944f, 
    0.06533305f, -0.07199401f, 0.12526537f, 0.13853776f, 0.00471385f, 0.04601511f, 0.27856728f, 0.15906909f, 
    0.06674293f, -0.12104306f, -0.00052034f, -0.43462020f, -0.01749217f, -0.01834000f, -0.21143642f, 0.41941121f, 
    -0.04412412f, -0.11289713f, -0.13600564f, -0.12777758f, -0.17245311f, -0.04629834f, -0.03969477f, 0.35067236f, 
    0.03779963f, -0.70939165f, -0.08160342f, 0.13179626f, 0.31044021f, 0.32002339f, 0.09410619f, -0.14695008f, 
    0.03620583f, 0.38591740f, -0.12513565f, -0.65160066f, 0.38176274f, 0.45366782f, 0.23002113f, -0.10699556f, 
    0.16690356f, 0.13669527f, -0.10776458f, -0.13547046f, 0.00567747f, 0.26526168f, -0.12061568f, -0.19188060f, 
    -0.67524284f, -0.06975695f, 0.00857565f, -0.31306589f, -0.20637426f, -0.06163965f, -0.06939391f, -0.03910857f, 
    -0.05217765f, -0.11371996f, -0.66001832f, -0.15948920f, -0.21399152f, 0.01192251f, 0.12161271f, 0.18295592f, 
    -0.14991181f, 0.00742805f, -0.00919464f, 0.27408704f, -0.18979272f, -0.12919016f, 0.20694458f, 0.00538251f, 
    -0.47883847f, 0.02558637f, -0.49260771f, 0.32521358f, -0.22144820f, 0.04669482f, -0.17215325f, 0.05307411f, 
    0.20035756f, 0.03610102f, -0.21277457f, -0.27400717f, -0.33613646f, -0.28558645f, 0.35000244f, 0.12534758f, 
    0.09194189f, -0.07840332f, 0.27805799f, -0.41598228f, -0.06988470f, -0.33049518f, -0.08207130f, -0.63895649f, 
    -0.17800575f, -0.07668199f, -0.15598838f, 0.10503136f, -0.00914572f, 0.12372531f, -0.80553657f, 0.24248536f, 
    0.60107780f, -0.01179073f, 0.06824527f, 0.05925897f, -0.83883035f, -0.30518794f, -0.47876254f, 0.02502706f, 
    0.24981847f, -0.21626630f, -0.08355211f, -0.13797447f, 0.26682428f, 0.05185337f, 0.12213539f, 0.12006678f, 
    -0.10513159f, -0.12248120f, -0.21568851f, -0.07532104f, -0.86810380f, -0.25916320f, -0.13403420f, -0.38168612f, 
    0.29417419f, -0.35061967f, 0.00526388f, 0.17723273f, 0.35246131f, 0.16120264f, -0.33455175f, -0.07549984f, 
    -0.28905421f, -0.31335247f, 0.13004054f, 0.01876974f, -0.06886587f, -0.18121032f, -0.01190717f, 0.04543276f, 
    0.19753751f, -0.10576504f, -0.00386585f, -0.13812140f, -0.07098360f, -0.62857801f, -0.52571797f, -0.17358939f, 
    -0.13691771f, 0.26556891f, -0.10099913f, 0.22705796f, -0.10701527f, -0.09777604f, -0.04498838f, -0.07608293f, 
    -0.01316697f, -0.38961533f, 0.20776933f, -0.08779864f, -0.37569004f, -0.62865162f, 0.07720650f, -0.44036919f, 
    -0.40599447f, -0.24009822f, 0.00486769f, -0.58992058f, 0.00168487f, -0.08567681f, 0.23808035f, -0.33451018f, 
    -0.30915001f, -0.13556637f, -0.02079715f, -0.08484026f, 0.20076133f, -0.15010393f, 0.05388247f, 0.05209954f, 
    -1.05149949f, 0.04562869f, -0.16245691f, -0.04026050f, 0.17892498f, 0.00293477f, -0.03448706f, -0.37382150f, 
    0.14654441f, 0.25261283f, -0.07071999f, 0.17843011f, 0.19863184f, -0.33436227f, 0.19619747f, -0.23174524f, 
    0.08769897f, 0.23925148f, -0.24437013f, 0.28496432f, -0.03027294f, 0.11600795f, -0.45502153f, 0.01047310f, 
    0.25850400f, 0.03558587f, -0.39085573f, 0.09765235f, -0.46863988f, 0.25021803f, 0.14315256f, -0.35404465f, 
    0.05062389f, -0.00422794f, -0.44687188f, 0.24541330f, -0.07649077f, -0.14106870f, -0.03706106f, 0.38195929f, 
    0.15572937f, -0.69292229f, -0.55878806f, 0.15704958f, 0.03653718f, 0.16956973f, 0.24556388f, -0.30767533f, 
    -0.58045232f, -0.03363626f, -0.07801741f, 0.17058797f, 0.07467878f, 0.04069242f, -0.03596437f, 0.37719658f, 
    -0.16534230f, -0.73996824f, -0.56542468f, -0.23553436f, -0.06572348f, 0.06035734f, -0.75095958f, 0.11814018f, 
    -0.59750378f, -0.35404217f, -0.61057132f, -0.47905734f, 0.12979256f, -0.11798976f, -0.23650770f, -0.39274237f, 
    -0.20337039f, -0.54014206f, -0.26329508f, 0.34344083f, 0.02983280f, -0.09719153f, 0.20944895f, 0.13526320f, 
    -0.75892806f, 0.30406967f, -0.38038996f, -0.45006648f, 0.03372522f, -0.35564283f, 0.24374421f, -0.33558217f, 
    0.13288102f, -0.98356128f, 0.01250551f, -0.76947147f, -0.18011278f, 0.34956729f, -0.52409589f, 0.34223804f, 
    -0.12753835f, 0.41031647f, 0.06316841f, -0.18784797f, 0.14554588f, -0.58868623f, 0.07975393f, 0.03189903f, 
    -0.01541439f, -0.28865820f, -0.12317918f, -0.30424809f, -0.07244188f, -0.23066558f, -0.32166135f, -0.09440202f, 
    0.30178502f, 0.11381301f, 0.18146934f, -0.02688073f, 0.04117101f, 0.06272203f, 0.36593801f, 0.16845791f, 
    -0.36930120f, 0.17544001f, -0.19207250f, 0.20699212f, 0.21790044f, -0.06219803f, -0.09664994f, 0.01874137f, 
    0.14095743f, 0.02471847f, 0.02599899f, 0.31850317f, 0.29245365f, -0.05943331f, 0.08304098f, 0.32737270f, 
    0.28460109f, -0.24281470f, 0.00921807f, -0.75538105f, -0.21140754f, -0.12198395f, -0.14825332f, -0.30317360f, 
    0.17020534f, 0.15631244f, -0.30978528f, -0.05101418f, -0.83688200f, -0.04464916f, -0.27430227f, 0.01013278f, 
    0.20031747f, 0.07901872f, 0.04218768f, 0.12443613f, 0.04436197f, -0.35309270f, -0.06154825f, 0.28963631f, 
    -0.01847206f, -0.07808302f, -0.08082261f, 0.08849109f, 0.06475078f, -0.05669235f, 0.35907131f, -0.41346851f, 
    0.35897040f, 0.17890224f, 0.22335494f, 0.00940727f, 0.04157302f, 0.28700784f, -0.11406802f, 0.28118312f, 
    -0.02683478f, -0.07809059f, -0.00400688f, -0.18323956f, -0.18605378f, -0.52208334f, -0.43920371f, -0.13517025f, 
    -0.29394773f, 0.04398312f, 0.21043704f, 0.12320476f, -0.17604734f, 0.01371998f, -0.07732524f, 0.01998642f, 
    -0.11892908f, 0.10656463f, 0.10783689f, -0.39769819f, -0.02228250f, 0.25744644f, 0.02383715f, -0.41967675f, 
    -0.13815340f, -0.64293301f, 0.00120621f, 0.08726100f, -0.57189310f, -0.44594029f, 0.40938205f, -0.02206952f, 
    0.23188289f, 0.13982441f, -0.58090585f, -0.84236521f, 0.02700498f, 0.46537557f, 0.02452419f, 0.17829624f, 
    -0.22758101f, -0.03180430f, -0.06749441f, -0.09118710f, 0.03998090f, 0.00606986f, 0.11519086f, 0.36308891f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.18938446f, 0.23623811f, -0.02872526f, -0.01911814f, -0.11545368f, 0.04856374f, -0.12903211f, -0.27397594f, 
    0.16001086f, 0.19543844f, -0.04256859f, -0.02822474f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
