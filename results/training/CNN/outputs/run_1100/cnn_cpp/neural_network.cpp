#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.61872876f, -0.30386582f, 0.46841064f, -0.10849959f, -0.29029867f, -0.00951316f, 0.14230622f, -0.13515547f, 
    0.21787785f, 0.57285553f, 0.03345437f, 0.12708333f, -0.30444121f, 0.06945705f, 0.53655463f, -0.42008156f, 
    0.29793859f, -0.60803741f, -0.43096650f, -0.75017905f, 0.10708931f, 0.52410245f, 0.54709935f, 0.47056562f, 
    0.21996395f, 0.64118445f, 0.70252776f, 0.23807123f, -0.02489178f, -0.01401651f, -0.70727581f, -0.06312682f, 
    0.21512388f, 1.26524007f, -0.86721301f, -0.75170928f, -0.43266952f, 0.00706103f, 0.01893307f, -0.32551107f, 
    0.09341375f, -0.03688796f, 0.00722207f, -0.17495528f, 0.21559368f, -0.40678963f, 0.04357478f, 0.11319561f, 
    0.02188260f, 0.01297840f, -0.38410097f, -1.28117359f, 0.31839493f, 0.54907501f, 1.09066105f, -0.33911163f, 
    0.68180698f, 0.28619623f, 0.37319049f, -1.01845443f, -0.21688606f, -0.73961329f, 0.16219608f, 0.18838856f, 
    0.06656706f, -0.20753680f, -0.22104977f, 0.07306515f, 0.14216968f, 0.04867445f, 0.01303812f, -0.21155982f, 
    -0.17841496f, 0.17422631f, 0.32640052f, -0.98947513f, -0.90433002f, 0.18854132f, -0.21923046f, 0.51960027f, 
    0.72008157f, 0.75143170f, 0.29211718f, -0.08467513f, 0.19690084f, -0.19914052f, -0.36349100f, 0.38183758f, 
    0.10792026f, 0.19149087f, -0.33375362f, -0.15567452f, -0.31712756f, 0.07463494f, 0.31859535f, 0.03512869f, 
    -0.30119753f, 0.32582203f, 0.31171060f, 0.33401957f, -1.57080638f, 0.19891702f, 0.30011868f, -0.17425866f, 
    0.24107409f, 0.76265818f, 0.84618092f, 0.48800611f, 0.19550574f, 0.18205030f, -0.30742154f, -0.33494762f, 
    -0.07124332f, 0.33751640f, -0.51626849f, 0.29048374f, -0.00646935f, -0.21395932f, -0.19027029f, -0.36445686f, 
    0.00641763f, 0.25435197f, 0.04835270f, -0.00450298f, -0.44012016f, -0.78410810f, -0.86849713f, -1.18342185f, 
    -0.11505867f, 0.54463702f, 0.57892388f, -1.31663847f, -0.52983880f, -0.63432145f, -1.37694824f, -0.43903425f, 
    0.72937471f, -0.44566092f, 0.26721755f, -0.67022538f, -0.32191440f, -0.82623571f, -0.16802676f, -0.06590217f, 
    -0.17354628f, -0.12082072f, 0.15580840f, -0.19774731f, -0.03226898f, 0.20050099f, 0.61331910f, 0.73921317f, 
    0.69447035f, 0.67285323f, 0.01225134f, -0.73555017f, -0.71305114f, -0.46830606f, -0.32744062f, -0.08588194f, 
    0.07021268f, 0.00215493f, 0.23951060f, 0.49155113f, -0.29522881f, 0.17294092f, -0.16263002f, 0.32513496f, 
    -0.13266478f, 0.34727544f, -0.21889204f, 0.31473014f, 0.12130367f, -0.05078914f, 0.11561935f, 1.67948472f, 
    -1.19279993f, -1.17147231f, -0.92444152f, -1.16383469f, 1.06504333f, 0.65066451f, 0.36563388f, 0.41154438f, 
    0.09361863f, -0.10071642f, 0.11334529f, 0.13458155f, -0.38171500f, 0.33458588f, 0.12368640f, 0.10250178f, 
    -0.06248050f, -0.03239843f, 0.03888410f, 0.40095782f, -0.33098900f, -0.13516480f, 0.17666990f, 0.14018643f, 
    1.44410419f, 0.06481688f, -0.12052964f, -0.15870072f, 0.74620306f, -0.00468954f, -0.11941825f, -0.79042363f, 
    -0.48831969f, -0.71211082f, -0.19542406f, 0.25707644f, 0.33522379f, -0.47420618f, -0.22118336f, -0.33582264f, 
    0.16303712f, 0.11925998f, 0.16712077f, -0.05474999f, -0.12642427f, -0.23746957f, 0.04895869f, -0.03731088f, 
    0.05374023f, 0.59577221f, 0.49282423f, -0.05749541f, -0.34198353f, -0.00262645f, 0.43141446f, 0.17129673f, 
    -0.29574031f, -0.38375017f, -0.12302104f, 0.20056312f, 0.71524382f, -0.37190485f, 0.03817777f, 0.22394340f, 
    0.25717378f, 0.15568912f, 0.23487680f, 0.19377664f, -0.21829191f, -0.14676706f, 0.31517375f, 0.14989243f, 
    0.33847252f, 0.46997643f, -1.05009210f, 0.44805405f, 0.03047465f, 0.74952239f, 1.08035874f, 0.04842034f, 
    0.30092224f, 0.15527226f, 0.34772685f, 0.14996129f, 0.31183809f, 0.29066074f, 0.11777045f, -0.38615534f, 
    0.07190410f, 0.15874816f, 0.18332624f, -0.09311976f, -0.05047627f, -0.28794506f, 0.27708784f, -0.08581835f, 
    0.18497734f, -0.14169586f, -0.18755960f, 0.43157569f, 1.06678891f, 0.24124141f, -0.41203216f, -0.28036991f, 
    -0.59154254f, -0.23788089f, 0.30767718f, 0.50374216f, 0.16528650f, 0.04557716f, -0.23446508f, -0.34347364f, 
    -0.14181502f, -0.46936688f, 0.03670471f, 0.37927955f, 0.07779012f, 0.33079109f, 0.00166099f, 0.10037941f, 
    0.01773908f, -0.48807299f, -0.41059998f, 0.00348776f, -1.24582672f, -1.43201613f, -0.81688666f, 0.84755504f, 
    0.46247014f, 0.84569347f, 0.33051494f, -0.13659230f, -0.01207962f, 0.73950046f, 0.16072252f, -0.55461913f, 
    -0.58656901f, 0.15559308f, 0.42665714f, 0.17051308f, 0.32149917f, 0.10534335f, 0.35111019f, -0.21630301f, 
    -0.20758951f, -0.44376835f, -0.18792787f, -0.14679302f, -0.34703583f, -0.01007250f, 0.42433885f, 0.16742936f, 
    0.32004839f, -0.05694282f, -0.39857149f, 0.06888476f, 0.24247552f, 0.16659209f, 0.63105303f, -0.11001905f, 
    0.27164513f, 0.03332071f, -0.03603155f, -0.14330259f, -0.31064805f, -0.30071938f, -0.19323789f, -0.30360779f, 
    0.33594823f, -0.07809913f, -0.33632964f, 0.43027708f, 0.38001221f, -0.40827724f, -0.71243757f, -0.81119817f, 
    0.15714392f, -0.46883932f, -0.71736228f, 0.00925302f, -0.07025945f, -0.26108870f, 0.24711452f, 0.54639804f, 
    -0.30441600f, -0.52117175f, 0.35861677f, 0.41542679f, 0.03991859f, -0.10309805f, -0.19006900f, -0.05490444f, 
    0.27434090f, -0.19663538f, -0.59166938f, -0.05108653f, -0.44528770f, -0.76304185f, -0.70062578f, -1.36868358f, 
    -0.83215511f, -1.00403476f, -1.11639917f, -0.25262892f, -0.00141154f, -0.61771894f, -1.12561464f, -1.24279642f, 
    -0.43482181f, -0.16510159f, -0.31635398f, -0.10028300f, -0.09975568f, -0.16999668f, 0.17756036f, 0.00203914f, 
    -0.22252651f, 0.28131834f, 0.08022448f, 0.00866980f, 0.13330778f, 0.30741957f, 0.00537877f, 0.09346528f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.12204246f, 0.64784223f, 0.92950141f, 0.51934451f, 0.76321727f, 0.77358168f, 0.38624436f, 0.57716930f, 
    0.33029214f, 0.55046177f, 0.32804763f, 0.38013014f, 0.23948459f, 0.95290571f, 0.13779913f, -0.78360569f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.04965345f, -0.07433453f, 0.15891185f, -0.13661312f, 0.04847926f, 0.11455430f, -0.00712468f, -0.10151301f, 
    -0.18673111f, -0.06070889f, -0.32113624f, -0.19016883f, -0.43916914f, 0.16693150f, 0.58171570f, 0.16442096f, 
    -0.00359516f, -0.04796828f, -0.09138414f, 0.06634840f, 0.16827828f, 0.01510599f, 0.03469531f, -0.09142081f, 
    0.27471042f, -0.77327526f, 0.24957575f, -0.49649352f, -0.07793763f, -0.02445928f, 0.13073376f, 0.02096696f, 
    -0.04487626f, -0.09245126f, -0.07982538f, -0.05084804f, 0.07144709f, 0.00622265f, 0.01900868f, 0.02560536f, 
    0.09522825f, 0.04319683f, 0.13251247f, -0.11373686f, -0.17823523f, -0.21940082f, -0.10832278f, -0.14821613f, 
    -0.03974161f, -0.32951209f, -0.18590093f, -0.13828182f, -0.02720826f, 0.05223596f, 0.19171472f, 0.16639408f, 
    -0.22326814f, 0.09487931f, -0.23041517f, -0.04862707f, 0.51409614f, 0.20388149f, -0.48781383f, -0.22211620f, 
    -0.07727738f, -0.07876777f, 0.01898232f, -0.07271253f, -0.16386437f, -0.31021330f, -0.05163712f, -0.36689335f, 
    -0.05662240f, -0.03502952f, 0.15891984f, -0.03097577f, 0.03664942f, -0.10097767f, -0.04122950f, -0.19179022f, 
    -0.03690997f, 0.04330184f, 0.00213053f, -0.01072615f, 0.05202568f, -0.25055617f, -0.61854815f, 0.13031998f, 
    0.26239920f, 0.20441043f, -0.21935076f, -0.04097046f, -0.07756504f, -0.01015236f, -0.02464799f, 0.14269036f, 
    -0.15076321f, -0.13723919f, -1.11985767f, 0.43948427f, 0.04455432f, -0.11942408f, 0.02177311f, -0.21489234f, 
    -0.12865801f, 0.08421029f, 0.05408987f, -0.01364394f, 0.05318739f, -0.03098556f, -0.02802931f, 0.18689418f, 
    -0.24325755f, -0.11460442f, -0.23149195f, -0.19314799f, -0.22983059f, -0.06294546f, -0.08723073f, -0.11554535f, 
    -0.15343210f, 0.03689472f, 0.10844732f, 0.05487854f, -0.01007813f, 0.00836477f, 0.13746858f, -0.01497877f, 
    -0.10755385f, -0.05282168f, 0.13506910f, 0.04266949f, -0.81668901f, -0.36704135f, -0.07750329f, 0.17629601f, 
    0.11237427f, 0.14590600f, -0.09527916f, 0.00353532f, 0.05812341f, -0.02553849f, 0.00499719f, -0.01698484f, 
    0.32060447f, 0.20792830f, -0.03987332f, -0.07082640f, 0.04264830f, 0.22020133f, 0.18348771f, -0.04439922f, 
    0.14417675f, 0.13710628f, 0.10146865f, 0.11212011f, -1.27409184f, -0.97169840f, 0.05575395f, -0.21285908f, 
    0.05394655f, -0.12352098f, -0.01152468f, 0.09866776f, -0.05802612f, -0.07757160f, -0.01781024f, -0.14209509f, 
    0.21863335f, 0.16820863f, 0.20795643f, -0.10605292f, 0.21602449f, 0.18979286f, 0.03552514f, -0.18988666f, 
    0.16098566f, 0.09891896f, -0.08739509f, 0.25559631f, 0.79537576f, 0.55612677f, -0.29746926f, -0.16210827f, 
    0.29272646f, 0.34083566f, 0.09033909f, 0.09822764f, -0.08002868f, -0.02470689f, -0.05424680f, -0.07432456f, 
    -0.19721098f, 0.15208898f, 0.16824117f, -0.20963883f, -0.07772968f, 0.09454205f, 0.18344639f, 0.16668443f, 
    -0.08764704f, 0.02168573f, 0.10674765f, -0.06610730f, 0.29617703f, 0.19314028f, 0.19162607f, 0.12028845f, 
    -0.11091550f, -0.14239283f, 0.06168183f, -0.15423681f, -0.12238282f, 0.03041818f, -0.06929732f, -0.01040829f, 
    -0.36929050f, 0.05080313f, 0.35889497f, 0.14343774f, -0.07006332f, -0.05822732f, 0.04603651f, -0.15962112f, 
    0.23091085f, 0.04402076f, -0.00144615f, -0.05069583f, -0.02644591f, -0.14515623f, -0.01596384f, 0.05199162f, 
    -0.02777855f, 0.03857140f, 0.13546555f, -0.11900132f, 0.23681353f, 0.03565625f, 0.17705433f, -0.08312481f, 
    0.06221718f, -0.39997384f, 0.32370207f, 0.20239499f, -0.08905839f, -0.04854442f, -0.03843584f, 0.04635934f, 
    -0.07968211f, -0.19361345f, -0.24024437f, 0.10231601f, -0.40285748f, -0.21067980f, -0.54471219f, 0.31166455f, 
    -0.02307202f, -0.00659590f, 0.05737847f, 0.02555529f, 0.11832056f, 0.05949383f, -0.10174287f, 0.10788150f, 
    0.11198434f, 0.19548623f, -0.05653774f, -0.29550183f, 0.02208408f, -0.12830895f, -0.16013193f, -0.08741653f, 
    -0.12148227f, 0.07924715f, -0.07140951f, 0.05219866f, 1.10402882f, -0.50195104f, -0.55359638f, -0.21949279f, 
    -0.05649897f, 0.05536442f, 0.17417777f, -0.30762035f, 0.13317665f, -0.13268586f, -0.00991326f, -0.28870678f, 
    0.43518931f, 0.11281792f, -0.60483366f, 0.02060131f, -0.16661461f, -0.07613135f, -0.29289126f, -0.23631321f, 
    -0.13147828f, -0.04181818f, -0.05923156f, 0.14133888f, 0.18451101f, -0.01051242f, -0.08740183f, 0.06601638f, 
    0.09676746f, -0.02066428f, 0.04623571f, 0.04773715f, -0.20116116f, 0.09092931f, -0.15375398f, 0.13130879f, 
    0.11213579f, -0.03314014f, 0.11916140f, 0.29068226f, -0.07728543f, 0.05388768f, -0.03901707f, 0.00194735f, 
    -0.03493152f, -0.01825165f, -0.03944084f, 0.27629253f, 0.02025698f, 0.04629076f, 0.38130480f, -0.11540357f, 
    0.04652762f, -0.01526156f, -0.14351608f, 0.00161188f, 0.15818036f, -0.24114309f, 0.00877456f, 0.04593735f, 
    -0.03591974f, 0.04528432f, -0.22774550f, 0.05179942f, -0.08421158f, 0.00891990f, -0.10973461f, 0.13920209f, 
    0.34770724f, -0.18478435f, -0.04853036f, -0.20509224f, 0.37754282f, 0.14240254f, 0.26064405f, 0.03727540f, 
    -0.01211525f, -0.01901797f, 0.00061848f, -0.14658961f, 0.13645503f, 0.06884567f, 0.02862433f, -0.16105813f, 
    -0.24500419f, 0.04138997f, -0.02113948f, 0.10926325f, 0.06214538f, 0.02377859f, -0.17920560f, -0.29623523f, 
    -0.44708085f, -0.10243169f, 0.37332502f, -0.54793614f, 0.33254224f, 0.24250937f, 0.32035509f, 0.44944972f, 
    -0.03356652f, 0.07399447f, -0.11776004f, -0.38028803f, 0.00570246f, 0.04415638f, 0.01254164f, -0.01606231f, 
    0.06804171f, -0.48487559f, -0.15965937f, 0.27045539f, -0.00598158f, -0.02064339f, 0.01159101f, -0.05781672f, 
    -0.12192608f, -0.01801984f, -0.55923241f, 0.39478466f, -0.25245687f, -0.54635054f, 0.08846448f, -0.17677063f, 
    -0.12663674f, -0.00058006f, 0.11232866f, 0.07866140f, -0.19556987f, 0.11190952f, -0.01564498f, -0.00987933f, 
    0.18842638f, 0.23961800f, -0.82955551f, 0.30175927f, -0.04191731f, -0.08910520f, 0.05098074f, 0.04933404f, 
    -0.11460038f, 0.18486241f, -0.00976483f, -0.11386565f, 0.05701687f, -0.09803234f, 0.19901384f, 0.16568923f, 
    -0.02323902f, 0.07894849f, 0.04936205f, 0.12553638f, -0.09064433f, 0.00642210f, 0.08357479f, -0.31881845f, 
    -0.29843852f, -0.47938284f, 0.25813615f, 0.40685803f, 0.01107182f, 0.05534727f, 0.06025386f, 0.05344675f, 
    0.19131908f, -0.20168434f, 0.19027250f, 0.18566428f, 0.08418159f, 0.14266963f, -0.04571157f, -0.01044286f, 
    0.20503870f, 0.02066254f, -0.02673565f, 0.18511929f, -0.05539844f, 0.01581438f, -0.09287681f, 0.01919477f, 
    -0.63987434f, -0.04696712f, 0.07627714f, -0.20165114f, -0.14094825f, -0.11536323f, -0.05355686f, 0.07718370f, 
    -0.02312553f, -0.17756048f, -0.03050896f, -0.10170907f, -0.21627340f, 0.93589205f, 0.61017662f, 0.09909649f, 
    -0.10749890f, 0.11108594f, 0.10049935f, -0.35860977f, 0.08063025f, 0.12104570f, -0.04333735f, 0.04768401f, 
    -0.88414836f, -0.21807313f, 0.20250641f, -0.30863097f, -0.11388553f, 0.08881714f, -0.03788089f, 0.10416062f, 
    0.07169352f, -0.13051857f, 0.00748048f, -0.14971490f, -0.04225461f, -0.07350300f, 0.10442910f, -0.05512493f, 
    -0.03303528f, -0.28560385f, -0.08409976f, 0.10461378f, 0.01222408f, -0.05679322f, -0.01646251f, 0.02179630f, 
    0.06131577f, -0.08338701f, -0.30411130f, 0.19908421f, 0.02777317f, -0.12663406f, 0.07050047f, 0.15805037f, 
    -0.03464834f, -0.12687312f, 0.01900793f, 0.00307496f, -0.23906331f, -0.16793147f, 0.15399991f, -0.07013770f, 
    0.00787433f, -0.07489984f, -0.12212067f, 0.14171480f, 0.02729031f, -0.10242476f, 0.05404140f, 0.11961658f, 
    0.02507764f, -0.22819060f, 0.39905089f, 0.07787360f, 0.04536059f, 0.04617806f, -0.04119219f, 0.12358642f, 
    0.03932408f, 0.04518883f, 0.00724354f, 0.04542754f, -0.15625882f, 0.13607836f, 0.07796799f, 0.04814655f, 
    -0.01545579f, -0.15152098f, 0.10051052f, 0.03877984f, 0.06467395f, 0.04157595f, -0.07439491f, 0.19854686f, 
    0.13969883f, 0.04154119f, 0.15879637f, 0.42581382f, 0.02530289f, -0.11799987f, 0.02165459f, 0.01225852f, 
    0.05288859f, -0.07342541f, 0.24017552f, -0.08404837f, -1.59215212f, -0.86384475f, 0.20155981f, 0.06586334f, 
    -0.19892053f, -0.19379056f, 0.02905559f, 0.00350208f, -0.07346551f, -0.05319390f, -0.01140411f, -0.09544082f, 
    0.39477390f, 0.18386769f, 0.25166026f, 0.32822308f, -0.02513002f, -0.08796059f, -0.02574165f, 0.02614392f, 
    0.06356677f, -0.00562587f, -0.12200117f, 0.27559274f, 0.33789930f, -0.88164735f, 0.12124836f, -0.48898202f, 
    -0.34598953f, -0.40818030f, -0.18199751f, 0.22107902f, -0.04052232f, 0.18622760f, 0.04515698f, -0.09432992f, 
    -0.40845454f, 0.93705028f, -0.99700201f, -0.78857338f, 0.08935707f, -0.10642788f, -0.24313918f, 0.02334841f, 
    -0.09573583f, -0.07632419f, 0.09282944f, 0.01048729f, -0.50053775f, 0.58145869f, -0.18400523f, -0.60089916f, 
    0.49575904f, 0.21138747f, -0.27338961f, -0.16498567f, -0.12022493f, -0.12753731f, 0.09163088f, -0.18494369f, 
    1.20389295f, 0.63791853f, -0.14130142f, -0.44560218f, 0.20685975f, 0.30602971f, -0.02406570f, 0.09816719f, 
    -0.19172248f, -0.02014891f, -0.06223791f, -0.09199010f, 0.10810269f, 0.03272986f, -0.03547069f, 0.06573856f, 
    0.23534982f, -0.00469564f, -0.07843786f, 0.16141288f, -0.09237524f, -0.13835111f, 0.06922759f, -0.14621155f, 
    -0.02377809f, -0.12677516f, 0.31546149f, 0.00734158f, -0.05462534f, -0.13895082f, -0.12659952f, 0.01045070f, 
    0.22631991f, 0.02176454f, -0.02860261f, 0.14985397f, -1.06400251f, 0.26058191f, 0.24427286f, 0.69888914f, 
    0.05694710f, 0.14580263f, 0.29819322f, -0.23295674f, 0.02022161f, 0.03393967f, 0.01833657f, 0.22964019f, 
    -0.62303567f, 0.46774143f, 0.38147512f, 0.60947466f, -0.16054644f, -0.18167372f, 0.14674675f, -0.31029272f, 
    0.22826359f, 0.17470193f, -0.17466505f, 0.11304089f, -0.46554241f, -0.03171631f, -0.36469942f, 0.23078549f, 
    0.02706749f, -0.01336007f, -0.37293670f, -0.41848060f, -0.07560989f, -0.21036902f, -0.15261994f, -0.47927028f, 
    -0.32752904f, -0.03917669f, 0.10233771f, -0.43989804f, -0.01769748f, 0.07954691f, 0.00607818f, -0.07640799f, 
    -0.10914622f, 0.25926301f, -0.12226142f, 0.09894118f, 0.11385560f, -0.37492248f, 0.26440647f, -0.24835277f, 
    -0.33415008f, 0.21733192f, -0.23862219f, 0.16689155f, 0.00310698f, 0.11171921f, -0.08683808f, -0.16298160f, 
    -0.13522574f, 0.81818396f, -0.18428840f, -0.58155239f, 0.37050417f, 0.13150935f, 0.16734552f, -0.19906718f, 
    -0.45088625f, -0.03665999f, 0.10675426f, 0.04995335f, -0.32067865f, 0.05974761f, 0.04178539f, -0.79784387f, 
    -0.00124298f, -0.20021094f, -0.16208640f, -0.22867306f, 0.02192169f, 0.05245101f, -0.21673012f, 0.20625246f, 
    0.27833501f, -0.11027122f, 0.18720686f, 0.26650250f, -0.12683481f, 0.08790229f, 0.02439166f, 0.08763979f, 
    0.04899024f, -0.17318475f, 0.02426125f, 0.03560856f, -0.04163362f, -0.33525181f, -0.26837301f, 0.37087816f, 
    0.07615346f, 0.02806850f, 0.08111928f, 0.04689491f, 0.08608910f, 0.01930136f, -0.14310895f, 0.00699066f, 
    0.27502891f, -0.04857085f, -0.06225992f, 0.41677490f, 0.01344847f, -0.03919867f, 0.03298724f, -0.12959002f, 
    -0.08964214f, -0.44495672f, -0.16647929f, -0.25044334f, -0.44568381f, -0.10275766f, -0.15600383f, -0.19078818f, 
    0.04537209f, 0.16807272f, -0.01506197f, 0.08301768f, 0.07185405f, -0.01091313f, 0.03870650f, -0.11187711f, 
    -0.23409685f, -0.99292248f, 0.40642336f, -0.11400685f, 0.09835850f, 0.08317472f, -0.06061021f, 0.04082543f, 
    -0.11558811f, -0.09565955f, -0.05969613f, -0.04663623f, 0.28005239f, -0.08335217f, 0.07746962f, 0.00625513f, 
    -0.27060872f, -0.17264375f, 0.09624918f, -0.10968686f, -0.05529916f, -0.03850048f, -0.10039025f, -0.11133784f, 
    0.12655771f, -0.62419546f, 0.36245990f, -0.46206695f, 0.08261447f, -0.04672452f, 0.06358893f, 0.03387856f, 
    0.13918972f, -0.09340385f, -0.01610560f, -0.22387764f, 0.20197028f, -0.21716335f, 0.50605756f, 0.16687351f, 
    -0.05057179f, 0.04410677f, -0.14384459f, -0.05510433f, 0.02667665f, 0.09095509f, -0.13088159f, 0.05079813f, 
    0.12288661f, 0.12240005f, 0.23223482f, 0.49374413f, -0.19490135f, 0.27868718f, 0.16451305f, 0.18108776f, 
    0.05411436f, -0.08817822f, -0.06327469f, -0.05962589f, -0.10032779f, -0.03940809f, 0.38818577f, 0.07139901f, 
    0.07051152f, -0.16781081f, -0.19825841f, -0.05559139f, -0.07977583f, -0.01287372f, -0.09539593f, 0.17013904f, 
    0.52802771f, -0.02809645f, 0.57859218f, -0.31566209f, 0.17337985f, 0.00629011f, 0.02852110f, 0.11902530f, 
    -0.00415050f, 0.02888309f, 0.08240639f, -0.16497152f, 0.10794470f, 0.15253648f, 0.04084635f, 0.14601620f, 
    0.21361145f, 0.06449029f, 0.10319082f, 0.07185685f, -0.01811237f, -0.12236165f, -0.16481720f, -0.08968107f, 
    0.10471124f, -0.15139922f, -0.10713400f, -0.12915917f, 0.13408267f, -0.20541438f, -0.03400838f, 0.05970751f, 
    0.08042741f, -0.05411546f, -0.06744069f, 0.09852010f, 0.41404644f, 0.11626226f, -0.56815410f, 0.03955431f, 
    0.06344840f, 0.04742661f, 0.09221777f, 0.10359548f, 0.27177101f, -0.05768050f, 0.02116634f, 0.02252234f, 
    0.18978456f, -0.26197004f, -0.09404398f, 0.06273203f, -0.27281353f, -0.07317384f, 0.01861918f, -0.13758749f, 
    -0.12914249f, 0.15580747f, -0.33663908f, 0.14617918f, -0.67787164f, -0.46082798f, -0.50792700f, -0.32455105f, 
    0.08780186f, -0.03551822f, -0.04196806f, -0.00266380f, -0.13559192f, -0.09696198f, -0.11678223f, -0.09214867f, 
    -0.38419783f, 0.08806495f, -0.00981285f, -0.02248988f, -0.11430924f, 0.03063705f, 0.18648198f, -0.07343588f, 
    0.05223585f, 0.06930548f, -0.01327309f, 0.50307637f, 0.06855256f, 0.03149009f, 0.31656894f, 0.26465270f, 
    0.01721059f, -0.01564900f, 0.01835279f, 0.07305714f, 0.03460976f, -0.02207731f, -0.02121859f, 0.02740993f, 
    -0.12673934f, -0.31004816f, -0.08027671f, -0.07826029f, -0.27248228f, -0.26647255f, -0.20345633f, -0.05934665f, 
    0.24399170f, 0.08879462f, 0.02619619f, -0.07659554f, 0.61691064f, -0.04576066f, -0.38890439f, 0.28991878f, 
    0.06647401f, 0.18330632f, -0.06738533f, 0.07176265f, 0.16407773f, -0.10023831f, -0.00505448f, -0.03528408f, 
    0.67423403f, -0.26323032f, 0.22284168f, 0.24388185f, -0.03541492f, -0.11149778f, -0.02496055f, 0.05986656f, 
    -0.14224353f, -0.02789722f, -0.21834847f, 0.00043220f, -0.18167321f, -0.08913662f, -0.18473084f, 0.08417329f, 
    0.01526372f, 0.04330985f, -0.13303585f, 0.10073250f, 0.17830202f, 0.27287290f, -0.28876275f, 0.18999092f, 
    -0.86467040f, 0.17078578f, -0.28048217f, 0.01618663f, 0.06548558f, -0.19699825f, 0.00026609f, -0.13676532f, 
    0.10370871f, -0.02628337f, 0.12314510f, -0.04956252f, 0.07399927f, 0.60219944f, 0.15946047f, -0.39373609f, 
    0.09715329f, 0.19539657f, 0.17037255f, -0.33472061f, 0.12405610f, 0.06418310f, 0.06647483f, 0.02091059f, 
    -0.15013811f, -0.20316367f, -0.24924193f, 0.26520309f, 0.09668805f, -0.04344198f, 0.14301232f, -0.06202745f, 
    0.07439885f, 0.02121892f, 0.04436624f, 0.08258898f, -0.11955015f, -0.63670564f, -0.23781601f, -0.44256222f, 
    0.10136133f, -0.00290093f, -0.17451830f, 0.31201893f, 0.11273768f, 0.00354804f, 0.06587625f, -0.09216528f, 
    0.08016177f, -0.02743545f, -0.16491188f, -0.35162070f, 0.17490929f, 0.23764758f, 0.18519509f, 0.19063617f, 
    0.15194219f, -0.03472731f, 0.02682757f, -0.01331948f, -0.07577559f, -0.02211045f, -0.18981378f, -0.13267206f, 
    0.09433320f, 0.29163587f, -0.10815351f, 0.05984330f, 0.30410364f, 0.04100829f, 0.14331549f, 0.16621146f, 
    -0.37243080f, 0.05554390f, 0.06647155f, 0.08976057f, -0.01364832f, -0.13291931f, -0.02866409f, -0.00799418f, 
    0.05389622f, -0.25161371f, 0.30084020f, 0.01418117f, 0.09780506f, -0.04310546f, -0.40773496f, 0.24978012f, 
    0.02466392f, -0.10452692f, 0.09456452f, 0.01168486f, -0.01327880f, 0.19058354f, -0.06566728f, -0.00612613f, 
    -0.41777092f, 0.10823742f, 0.22919612f, -0.25326613f, -0.01682865f, -0.12260184f, -0.01963880f, 0.10091869f, 
    -0.07966941f, -0.26280046f, -0.19648384f, -0.08056773f, -0.05870693f, -0.30120519f, -0.27004567f, 0.72539145f, 
    -0.00260531f, -0.01813440f, -0.00552556f, 0.09202746f, -0.06107476f, 0.02736449f, 0.16153197f, 0.00582050f, 
    -0.05202272f, -0.26946932f, 0.06803281f, -0.28347903f, -0.01760656f, -0.00952189f, -0.10462803f, 0.12224433f, 
    0.00372424f, -0.04508684f, -0.20829043f, -0.41278327f, -0.26680678f, 0.27001643f, 0.31326240f, -0.30701694f, 
    0.11475770f, 0.10652870f, 0.04911835f, -0.10181829f, 0.07961120f, 0.02149574f, -0.02068654f, 0.09739871f, 
    -0.20015179f, -0.22355029f, -0.05983184f, 0.08343408f, 0.03206524f, 0.00663927f, -0.11775739f, 0.10233933f, 
    0.09865402f, 0.03087131f, 0.47358561f, -0.32938516f, -0.41574579f, 0.20244996f, 0.34563619f, -0.38890612f, 
    0.00876295f, 0.04504559f, 0.04863863f, -0.05777280f, -0.17240532f, -0.05470422f, 0.05573796f, 0.03723729f, 
    -0.23371679f, 0.01578088f, -0.11048309f, -0.01764185f, 0.18171872f, -0.03537385f, -0.17040673f, 0.07762604f, 
    0.05350469f, -0.11039840f, 0.10492548f, 0.12513396f, -0.19670697f, 0.03286794f, 0.27117354f, 0.23150881f, 
    -0.00206540f, -0.14291272f, -0.09335820f, 0.20929226f, -0.20678653f, 0.03236088f, -0.15246969f, 0.30524927f, 
    -0.07244011f, -0.09379882f, 0.40870646f, -0.24453823f, -0.01131266f, 0.07836577f, -0.03427066f, -0.08593410f, 
    0.03297267f, 0.33586904f, 0.11570148f, 0.23232761f, -1.86862957f, -1.44678390f, 0.16716881f, 0.21803461f, 
    0.09353153f, -0.24029811f, 0.08803318f, -0.42186159f, -0.11245476f, 0.07997976f, -0.02759268f, 0.11988112f, 
    0.25534075f, -0.65742213f, -0.43680748f, 0.18743144f, -0.44214520f, 0.31264782f, 0.27085316f, -0.09622262f, 
    -0.07259098f, -0.12420635f, -0.18756527f, -0.03604392f, 0.28020230f, 1.01929057f, -0.38112247f, 0.25192329f, 
    -0.13816719f, -0.18215184f, 0.00741075f, 0.11390733f, 0.08203481f, 0.05075572f, 0.05193717f, -0.04231574f, 
    -0.67073178f, -0.82741600f, -0.10086780f, 0.14618638f, 0.28329110f, 0.28659070f, 0.11087161f, -0.21954146f, 
    -0.00547620f, 0.11336800f, -0.05201726f, 0.11181492f, 0.15979582f, -0.00741264f, 0.00155028f, 0.07677211f, 
    -0.23228429f, -0.17655522f, 0.24908085f, -0.20057161f, -0.13871291f, -0.22603680f, -0.10750946f, -0.22498265f, 
    0.03914149f, -0.14445484f, 0.01568608f, -0.08791666f, 0.13564608f, 0.05730896f, 0.00084726f, 0.07826594f, 
    0.32257849f, -0.24458326f, -0.19045971f, -0.67602259f, 0.31416982f, 0.08911958f, -0.20064491f, -0.05295349f, 
    -0.03670320f, 0.09244558f, 0.28317079f, -0.31478986f, 0.04441366f, 0.14533988f, 0.21808821f, -0.04071166f, 
    -0.27678305f, 0.02795261f, -0.00489106f, 0.14702050f, -0.03043403f, -0.05642311f, 0.00100060f, 0.03970466f, 
    -0.03402158f, -0.00264984f, 0.33483878f, -0.06975969f, -0.01606047f, 0.16511071f, 0.04600486f, 0.26455918f, 
    -0.02822678f, 0.10567912f, -0.07860387f, 0.08044655f, -0.05057638f, 0.04564792f, 0.03832924f, 0.03173533f, 
    -0.16949321f, 0.02541230f, 0.04148474f, -0.10424086f, -0.22680980f, 0.12622230f, 0.10929925f, 0.03486359f, 
    0.32226378f, 0.18093255f, -0.16623595f, 0.49653885f, -1.45019984f, -1.35110724f, -1.47571838f, -0.38816553f, 
    -0.14549911f, -0.33330145f, -0.24166319f, -0.49948272f, -0.08266409f, 0.04067384f, -0.04554048f, -0.09284726f, 
    0.14049411f, -0.04427212f, 0.14972611f, -0.04444402f, -0.05748216f, 0.07162406f, 0.08980388f, -0.02910854f, 
    0.04470649f, 0.11923914f, 0.15852752f, -0.04401892f, -0.33465239f, 0.35409492f, -0.25127456f, 0.13614759f, 
    0.03526088f, 0.06078877f, 0.07220727f, -0.09884936f, -0.00166852f, 0.13563202f, 0.10422689f, -0.05500465f, 
    0.21852876f, -0.30778682f, -0.19181032f, -0.09091993f, 0.02157058f, -0.06329682f, 0.09466070f, -0.01551113f, 
    -0.12198771f, 0.13994260f, -0.15938333f, -0.15734424f, 0.31460232f, 0.13612959f, -0.37028474f, -0.35401830f, 
    -0.10718503f, 0.08246833f, -0.06290504f, 0.00659099f, -0.09487329f, 0.08068785f, 0.11596030f, 0.17156751f, 
    0.49962968f, 0.31959963f, -0.46796152f, -0.12712285f, -0.02492428f, 0.05188533f, -0.11302274f, 0.11870359f, 
    -0.15431336f, -0.20326540f, -0.26131067f, -0.19905138f, -1.22370374f, 0.02764892f, 0.74913538f, -0.23427941f, 
    0.11929261f, -0.11030254f, 0.06003747f, 0.28157094f, -0.15417849f, -0.17689264f, -0.00206733f, 0.07749060f, 
    -0.15120570f, -0.06345769f, 0.00019937f, -0.03930029f, -0.02709193f, -0.09020091f, -0.23335959f, 0.22692904f, 
    0.05271760f, 0.08173592f, -0.00284884f, 0.00630760f, -0.37002662f, -0.52951580f, -0.14066938f, -0.14298533f, 
    -0.25703305f, 0.01624010f, 0.11685845f, -0.09340011f, 0.03374099f, 0.04190284f, -0.05620933f, 0.09857235f, 
    -0.44684976f, 0.37005579f, 0.43524966f, -0.45680687f, 0.09828290f, -0.56601268f, -0.03034070f, 0.08536859f, 
    0.03695398f, 0.02051981f, 0.06093026f, -0.02174449f, -0.06734925f, 0.09160813f, 0.12243046f, -0.07862405f, 
    -0.05831875f, -0.18116535f, 0.03461789f, 0.08066227f, 0.00826331f, -0.01586303f, 0.10508987f, -0.07197873f, 
    0.45201942f, 0.10161065f, 0.06224113f, -0.28842705f, -0.02550683f, -0.01280642f, 0.06556976f, -0.10754356f, 
    -0.00103182f, -0.00198719f, -0.16400616f, -0.20933273f, -0.09115525f, 0.20116617f, 0.18911219f, 0.18560334f, 
    0.12583621f, 0.06014441f, -0.01009047f, -0.28049472f, -0.13844524f, 0.11747067f, 0.14705308f, 0.11322007f, 
    0.73623550f, -0.42667019f, 0.14167662f, -0.41229516f, 0.03614407f, -0.04223628f, -0.01317338f, -0.03582108f, 
    0.05088728f, 0.19602631f, 0.13765053f, -0.01830855f, -0.01547512f, 0.01967129f, -0.17952670f, -0.15548691f, 
    -0.04429495f, -0.13007480f, -0.11341930f, -0.11801677f, 0.03329150f, 0.07380742f, 0.05957348f, -0.13359058f, 
    0.16404085f, -0.56952327f, -0.22885598f, -0.55681348f, -0.26259899f, 0.09348971f, -0.02944808f, 0.15361995f, 
    0.20757927f, -0.07250101f, -0.02450754f, 0.14645068f, -0.55449551f, -1.18860209f, -0.64990574f, -0.79283345f, 
    0.18372910f, -0.07984725f, -0.03140946f, 0.41226676f, 0.07146554f, 0.01745530f, -0.07212006f, -0.04506722f, 
    -0.26545361f, -0.05868303f, -0.08930986f, -0.30625242f, 0.09613047f, 0.32118127f, -0.13064504f, 0.10417531f, 
    0.12852031f, 0.29077601f, 0.27667579f, 0.37915123f, -0.34005103f, 0.20345487f, 0.33121845f, 0.24480504f, 
    0.07344914f, -0.18495588f, -0.15452601f, 0.03219005f, 0.06956072f, -0.23488042f, 0.09637970f, 0.20079981f, 
    0.63790518f, 0.20195360f, -0.20891964f, -0.30838519f, -0.13177121f, -0.07512432f, 0.08230787f, 0.06383132f, 
    0.01926748f, 0.12786984f, 0.16493298f, 0.08952354f, 0.02513510f, -0.23672886f, -0.11837976f, -0.06420380f, 
    -0.21197242f, -0.08249274f, -0.03876975f, 0.15347750f, 0.28944659f, -0.00582878f, 0.12885119f, 0.01677832f, 
    -0.14974789f, -0.14263630f, -0.12199456f, -0.17337583f, -0.19922186f, -0.06003267f, 0.00720415f, 0.10784972f, 
    0.12025474f, 0.38740394f, -0.09883400f, 0.04449673f, 0.73771769f, -0.73972023f, -1.03916979f, -0.25292251f, 
    -0.13747777f, -0.04685660f, 0.08320875f, -0.12053455f, 0.17433707f, 0.24407630f, 0.07733858f, 0.05873121f, 
    -0.17404392f, 0.28913516f, 0.14277907f, 0.00507121f, 0.10191377f, -0.25069475f, -0.18721662f, -0.27020720f, 
    -0.00120367f, 0.13487370f, 0.18268318f, -0.01604942f, -0.61984080f, -0.50544846f, 0.15133540f, 0.36760768f, 
    -0.01427554f, 0.36293602f, 0.14847872f, -0.02900817f, -0.09759854f, -0.14122121f, 0.17970335f, 0.14033575f, 
    -0.39286298f, -0.08559079f, 0.00984290f, 0.39089599f, 0.09293524f, 0.02544079f, -0.05553917f, -0.16725950f, 
    0.14233841f, 0.13297987f, -0.18990958f, 0.06912944f, -0.40563017f, -0.11798253f, -0.01186544f, -0.07149911f, 
    -0.21959476f, -0.05413547f, -0.04383085f, -0.02444724f, 0.14786492f, 0.20528898f, 0.13567752f, 0.22221194f, 
    0.37016809f, 0.04214765f, 0.03291526f, -0.58827698f, -0.19606130f, -0.06669771f, 0.03725661f, -0.30989167f, 
    -0.10902872f, 0.13744594f, -0.00570469f, 0.12418953f, -0.68400288f, 0.09993495f, 0.11481350f, -0.06012430f, 
    -0.11037298f, -0.06543644f, -0.15450218f, 0.13811415f, -0.43089864f, -0.29071066f, -0.11290793f, -0.29556280f, 
    -0.15744278f, -0.27770880f, -0.47414175f, -0.42904961f, 0.09371448f, -0.17485176f, 0.07494737f, -0.02822855f, 
    -0.13732333f, -0.21761033f, -0.04145906f, -0.06673742f, 0.54426616f, 0.36349887f, 0.10447100f, -0.00412937f, 
    -0.07932289f, -0.00923699f, 0.00429999f, -0.07939450f, 0.11939972f, 0.07433435f, 0.13351889f, 0.09794538f, 
    0.21029010f, -0.25462890f, -0.14800496f, 0.20801981f, 0.33666208f, 0.07677183f, 0.08534116f, 0.29749295f, 
    -0.47785482f, -0.25379795f, -0.37581849f, -0.67680359f, 0.21664423f, -0.76890582f, -1.15897310f, -0.19920032f, 
    -0.15982942f, -0.05269655f, 0.27040187f, -0.21788034f, 0.01455725f, -0.13677923f, 0.08042686f, -0.10177461f, 
    0.22499529f, 0.33712447f, -0.04678062f, -0.07937036f, 0.04313802f, -0.21474636f, -0.10258037f, -0.13869061f, 
    -0.08245543f, 0.07037666f, -0.17486362f, -0.35578397f, -0.83017063f, -0.18639758f, -1.05542338f, -0.08614825f, 
    0.35083562f, -0.20929873f, 0.34067875f, 0.01206437f, 0.01374952f, -0.04530953f, 0.12135561f, 0.01731212f, 
    -0.53910536f, -0.25576854f, 0.22616433f, 0.18558447f, 0.28447992f, -0.06106447f, -0.11663450f, 0.15914187f, 
    -0.02627792f, 0.12466272f, 0.19502582f, -0.00945692f, 0.03668474f, 0.15644950f, 0.04498067f, 0.27683043f, 
    0.06784016f, 0.00587525f, -0.39611888f, -0.28642598f, -0.18121287f, -0.30566499f, 0.05314745f, 0.10189670f, 
    -0.18527338f, 0.37143466f, -0.15719545f, 0.75870585f, -0.08991343f, -0.04013073f, -0.31007934f, -0.15596692f, 
    0.05972226f, -0.07457145f, 0.11364301f, -0.09307135f, -0.77211607f, -0.23511322f, -0.02113261f, -0.00322328f, 
    0.07339275f, -0.29255632f, -0.08679447f, 0.29276276f, -0.00765566f, 0.18292171f, 0.03991533f, -0.00687567f, 
    0.38030750f, 0.10997240f, -0.55971777f, 0.08000884f, 0.33971402f, 0.34472746f, 0.41919488f, 0.10433094f, 
    -0.04365321f, -0.27455947f, -0.31078848f, -0.06595826f, 0.14914288f, -0.29952052f, 0.68968248f, -0.94326133f, 
    -0.11245327f, -0.28453496f, -0.25295037f, -0.20301831f, -0.10118227f, -0.06048105f, 0.04609840f, 0.01746146f, 
    0.40318772f, -0.84597629f, -0.11517696f, -0.43577605f, 0.22957988f, -0.07520012f, 0.15280397f, -0.14803289f, 
    -0.02114169f, -0.02313242f, -0.06797066f, 0.00398942f, 0.05175995f, -0.15508629f, 0.04578726f, -0.01934876f, 
    -0.02943345f, -0.03146249f, 0.15659599f, 0.29977837f, 0.22415715f, 0.04239819f, -0.27564850f, -0.07729967f, 
    -0.40306744f, -0.05746460f, 0.22818378f, 0.46508995f, 0.20126715f, 0.49749818f, -0.08880232f, -0.20554245f, 
    -0.03669848f, -0.02700104f, -0.04021456f, -0.14771341f, -0.28564554f, 0.11976466f, -0.53562313f, 0.12964378f, 
    -0.00934484f, 0.03175746f, 0.41895995f, -0.25244668f, -0.19938837f, 0.00394635f, -0.19713686f, 0.15719488f, 
    0.42907751f, -0.37765861f, 0.35126480f, 0.84723425f, -0.17009994f, 0.14595394f, -0.35046375f, -0.36988130f, 
    0.21451724f, 0.00517004f, 0.11985286f, 0.07339182f, -0.24480483f, -0.22639723f, -0.07605506f, -0.01464768f, 
    0.01525069f, 0.25726864f, 0.08749416f, -0.22563173f, 0.27872053f, -0.12534675f, 0.08670563f, 0.02453827f, 
    0.08066618f, 0.03805752f, 0.03302065f, 0.10988399f, -0.15570529f, -0.06199929f, -0.10584645f, 0.08970125f, 
    0.15914065f, -0.05320311f, 0.15231659f, 0.14161375f, -0.65000361f, -0.34197849f, 0.46828437f, -0.40472016f, 
    -0.29721093f, 0.05727984f, 0.05116483f, 0.52416575f, 0.10837421f, -0.02657772f, 0.11571506f, -0.05431864f, 
    -0.12874885f, 0.41209584f, -0.10543394f, -0.40833643f, -0.11472368f, -0.04491018f, 0.12769081f, -0.04222444f, 
    -0.05187418f, 0.29909056f, 0.27879420f, 0.11048946f, -0.24209702f, 0.56838214f, 0.14646372f, -0.03158620f, 
    -0.42882648f, 0.06542995f, -0.14774765f, 0.07595302f, 0.05006392f, -0.10898925f, 0.04188930f, -0.07934546f, 
    -0.77669382f, 0.51158184f, 0.35405791f, -0.08680062f, -0.21203771f, 0.28745428f, 0.01463604f, 0.15812208f, 
    0.15802313f, -0.19892049f, 0.14641908f, 0.29880485f, 0.20657477f, 0.00243611f, 0.28691179f, 0.05664097f, 
    -0.13384923f, -0.03050980f, 0.03845349f, -0.04428473f, 0.17092744f, 0.38411421f, 0.09421065f, -0.05705038f, 
    0.63173765f, 0.50845909f, 0.14702637f, -0.21893549f, -0.05921804f, -0.05943158f, 0.08454380f, -0.10674816f, 
    -0.11085851f, 0.15984675f, -0.28667042f, -0.12034460f, -0.02519062f, 0.16872789f, 0.36116984f, 0.50851178f, 
    -0.16821066f, 0.07076848f, -0.01821794f, 0.13530816f, 0.01639436f, -0.06182844f, 0.13417229f, -0.15346114f, 
    -0.47676918f, -0.25861299f, -0.63740402f, -0.46963093f, -0.29793793f, 0.14710088f, 0.20043433f, -0.17852595f, 
    -0.18417068f, 0.30357796f, 0.02354763f, -0.07507438f, -0.28789163f, 0.51755553f, -0.15285231f, 0.26402459f, 
    -0.14118068f, 0.10281923f, -0.20986144f, 0.28866255f, -0.15430191f, -0.09498098f, 0.19724691f, -0.37670198f, 
    -0.26132894f, 0.29568243f, 0.08797101f, 0.23245962f, -0.22211468f, -0.13089973f, -0.27360669f, 0.53778833f, 
    0.01641808f, -0.15210846f, 0.09044503f, 0.01282481f, 0.15812060f, -0.23471686f, 0.35938498f, 0.05990196f, 
    -0.20664826f, 0.03723812f, 0.24701311f, -0.13178076f, -0.11907861f, 0.23424380f, 0.53082132f, 0.17062646f, 
    -0.21605498f, -0.17878917f, 0.14490408f, -0.62360144f, -0.15524898f, 0.14811982f, -0.08768935f, -0.05845273f, 
    -0.06646747f, -0.04736430f, -0.04675961f, -0.03535892f, 0.16157153f, 0.08902515f, -0.33142367f, -0.00156988f, 
    -0.19405441f, -0.26996750f, -0.19072179f, -0.30404955f, -0.00918476f, 0.13735734f, -0.18403254f, -0.06295303f, 
    -0.97509140f, 0.40921021f, -0.46501932f, -0.10880462f, 0.37084278f, 0.07127759f, -0.25657180f, -0.07698366f, 
    -0.41423446f, 0.07258489f, 0.06545085f, -0.31912097f, -0.43623480f, 0.03999938f, 0.48843238f, -0.68140584f, 
    -0.06267732f, 0.09035494f, 0.05744612f, 0.00457512f, 0.06602151f, 0.07737804f, 0.10605181f, -0.00660492f, 
    -0.07294654f, 0.29722258f, 0.04445245f, -0.30627126f, 0.23189111f, -0.57150763f, 0.04675466f, 0.01953610f, 
    -0.14323117f, -0.16011564f, -0.48542932f, -0.63768589f, -0.07231794f, -0.52684313f, -0.77174747f, -0.00822776f, 
    -0.24404916f, -0.57890981f, -0.06558330f, 0.05547998f, -0.00817180f, 0.17869282f, 0.16354305f, -0.00112157f, 
    -0.53866011f, 0.34185669f, -0.34622246f, -0.03320901f, 0.15713507f, 0.01863227f, 0.08336633f, -0.15981473f, 
    -0.15823677f, -0.12804911f, -0.37919658f, -0.04709991f, 0.75151724f, -0.51253146f, 0.27759516f, -0.12200926f, 
    -0.18249573f, -0.13297881f, -0.30328837f, 0.12865689f, -0.02265519f, -0.00363228f, -0.16062661f, -0.00274941f, 
    -0.17557411f, 0.02662616f, -0.07437805f, 0.12222251f, 0.31500971f, 0.04528876f, -0.01136230f, -0.02306515f, 
    0.02052676f, -0.05695250f, 0.08891027f, 0.16839612f, -0.55901945f, 0.11491206f, -0.26503372f, -0.00652321f, 
    0.14992632f, 0.00217598f, -0.01195180f, -0.04076927f, -0.15625171f, -0.12666318f, -0.23641878f, 0.08903285f, 
    -0.28593105f, -0.31218523f, -0.22682694f, 0.08733469f, -0.00027955f, -0.02736924f, 0.17488062f, -0.17510389f, 
    0.01699190f, -0.16893688f, 0.33221155f, 0.00522583f, -0.36380100f, -0.85880500f, 0.33740741f, 0.12340619f, 
    -0.18063311f, -0.02382040f, -0.08813987f, 0.04194105f, 0.10670704f, -0.03874581f, 0.08194785f, 0.10234278f, 
    0.60334647f, 0.31408125f, 0.85701638f, -0.38319707f, 0.09031504f, -0.04319381f, -0.13882807f, 0.11017262f, 
    -0.21673755f, -0.14535390f, 0.06382632f, -0.14131412f, -0.82823819f, -0.34548104f, 0.16342296f, 0.07250844f, 
    -0.08860729f, -0.10676627f, 0.22498472f, 0.25412148f, -0.32132611f, -0.07268529f, -0.20601469f, -0.05242154f, 
    0.43823102f, 0.54484820f, 0.36551213f, 0.19863331f, -0.43788052f, 0.21409558f, -0.26732147f, 0.32873982f, 
    -0.10962837f, 0.22468266f, -0.04652280f, -0.07317006f, 0.00498015f, 0.16193783f, -0.11283120f, 0.11570784f, 
    0.03722807f, 0.30456123f, -0.07620441f, 0.09074535f, -0.25107488f, -0.01107004f, -0.18289921f, -0.23493062f, 
    -0.48028517f, 0.34704167f, -0.34073129f, -0.06626254f, 0.07336753f, 0.20940712f, 0.00683134f, 0.30228329f, 
    0.06631006f, 0.34991395f, 0.04017324f, -0.43363401f, 0.51987052f, -0.26535845f, 0.33010283f, -0.15432817f, 
    -0.15460198f, -0.05330046f, -0.10962654f, 0.22130540f, -0.15369271f, -0.06012626f, 0.12932706f, -0.01720796f, 
    -0.53053707f, 0.34145585f, -0.62536854f, 0.42011499f, 0.19403374f, -0.29721212f, 0.23586582f, -0.07577372f, 
    -0.06120501f, 0.09896940f, 0.50823629f, 0.20310128f, 0.41513914f, 0.20451653f, 0.20381789f, -0.02769365f, 
    -0.12738696f, 0.10517831f, 0.06267626f, 0.13508053f, -0.24003510f, 0.29384461f, 0.07739247f, -0.03381869f, 
    0.13724265f, 0.00675442f, -0.56801331f, -0.12901606f, -0.01237802f, -0.23393527f, 0.00017699f, 0.02089706f, 
    -0.00839260f, 0.13564718f, 0.16920976f, 0.14395721f, 0.33075276f, -0.24009146f, -0.12665878f, -0.41843417f, 
    -0.68096906f, -0.02336216f, 0.04883387f, -0.35235679f, 0.00640889f, 0.02729050f, -0.06837624f, -0.11259259f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.18251611f, -0.00719315f, 0.16620080f, -0.07759450f, -0.19274236f, 0.27329189f, 0.09818988f, -0.29804778f, 
    0.24817032f, 0.02783245f, 0.01746706f, -0.03831640f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
