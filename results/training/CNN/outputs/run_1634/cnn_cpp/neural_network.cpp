#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.02669394f, -0.88954949f, -0.77497071f, -0.19706523f, 0.46369538f, 0.63797641f, -0.40196872f, 0.03709704f, 
    -0.33905616f, -0.85911387f, 0.31290963f, -0.57322830f, -0.12594232f, 0.17279425f, 0.79149598f, -0.41300577f, 
    -0.28482643f, -0.49727669f, -0.58934104f, -0.75218034f, -0.03910116f, 0.28287882f, -0.20165448f, -0.25294125f, 
    -0.25967503f, -0.27512184f, -0.40582544f, -0.40108603f, -0.88899601f, -0.06744379f, 0.39321238f, -0.18894862f, 
    -0.14385965f, 0.52009559f, 0.69701868f, -0.07667089f, 0.43404248f, 0.52242768f, 0.46386701f, 0.09975004f, 
    -0.47483310f, -0.16889083f, 0.45567331f, -0.25273174f, 0.17658041f, -0.51470852f, 0.96767122f, -0.31575790f, 
    -0.17344776f, 0.27291685f, 0.26962012f, -0.50366443f, 0.27278766f, 0.49090528f, -0.12311027f, -0.50006974f, 
    0.62220758f, -0.81367666f, 0.27001324f, -0.14233701f, -0.26378798f, 0.64561915f, -0.19320557f, 0.66039675f, 
    -0.27916273f, 0.17412451f, -0.23393808f, 0.01614457f, 0.04122270f, 0.14196120f, 0.25550008f, 0.06322760f, 
    -0.43350959f, 0.29008093f, 0.37054282f, -0.35384911f, -0.66332310f, 0.54474032f, -0.28033993f, -0.52310634f, 
    -0.07421380f, 0.32770085f, 0.74349087f, 0.16974741f, 0.22991720f, -0.09232191f, -0.24656390f, -0.40287143f, 
    -0.19382441f, 0.59662211f, 0.49872690f, 0.13011003f, 0.03561714f, 0.63938808f, 0.36204177f, 0.37973878f, 
    -0.06521305f, -0.36268422f, -0.22488734f, -0.04079463f, -0.58041656f, 0.73071241f, -0.09078164f, -0.47915131f, 
    -0.80003554f, 0.36364484f, 0.34006080f, 0.20650770f, -0.45375165f, -0.04353102f, 0.19616024f, -0.24202554f, 
    -0.35031909f, -0.73522389f, -0.27221832f, -0.05968883f, -0.44220951f, -0.75953507f, -0.46025068f, 0.29640019f, 
    -0.50336975f, -0.69023812f, 0.64678377f, -0.09592348f, -0.19845368f, 0.58238214f, -0.89248908f, 0.22640787f, 
    -0.91440135f, 0.32852459f, 0.42479995f, 0.70831156f, 0.37825224f, -0.16290741f, 0.05909045f, 0.82556409f, 
    -0.79574299f, -0.06796940f, -0.63005656f, -0.10170601f, -0.38679281f, -0.33665615f, -0.52913165f, 0.25491777f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.02787112f, 0.10368644f, -0.32390842f, -0.04164279f, -0.22926600f, 0.33427775f, 0.01340533f, 0.18332995f, 
    0.22871117f, -0.05709555f, -0.26757720f, 0.05547151f, -0.08588982f, -0.12340658f, 0.02464679f, -0.17381445f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.03955435f, -0.04373233f, 0.00769159f, 0.03807369f, 0.02362420f, 0.02295393f, -0.00449385f, 0.01706145f, 
    -0.04687994f, 0.02343964f, -0.05516623f, -0.02566531f, -0.02529038f, 0.02553222f, -0.04294220f, -0.02319754f, 
    -0.03395061f, -0.04947062f, -0.04099840f, 0.02216037f, 0.01546663f, -0.02842918f, 0.05087683f, -0.05326716f, 
    -0.01643559f, -0.04403299f, -0.04559384f, -0.04933973f, -0.00495326f, -0.00774059f, 0.00699315f, 0.02833380f, 
    0.04264960f, 0.01749822f, 0.02239364f, 0.04264841f, 0.01392923f, 0.04173199f, -0.04415939f, -0.04363472f, 
    0.00477651f, 0.00008057f, 0.00631628f, -0.05009206f, -0.00134810f, -0.00944494f, -0.04705818f, -0.01846880f, 
    -0.01821564f, 0.01972569f, 0.00305625f, 0.03479530f, -0.01194223f, -0.00889947f, 0.03002404f, 0.01248160f, 
    0.03380661f, -0.04573952f, 0.01907314f, -0.03137882f, 0.03921485f, -0.02712811f, 0.02250701f, 0.03360873f, 
    0.04554188f, 0.02755295f, 0.01026659f, -0.01451288f, 0.02979578f, 0.03217381f, 0.02275282f, -0.01572615f, 
    -0.05169575f, -0.01146539f, -0.01110001f, -0.00944908f, 0.01878854f, 0.00327707f, -0.01298354f, -0.00351831f, 
    -0.00134933f, 0.02929156f, -0.02129509f, 0.03029252f, 0.03964226f, -0.01367138f, -0.00129233f, 0.04809659f, 
    -0.00607363f, -0.03822545f, -0.04391431f, -0.01166293f, -0.06304909f, 0.03872875f, -0.01583580f, -0.00759861f, 
    0.04783933f, 0.00566311f, 0.01515027f, 0.01252235f, 0.03845935f, -0.01925290f, -0.00392091f, -0.03250216f, 
    -0.00446000f, -0.02663698f, -0.02691039f, -0.00812093f, 0.00761637f, -0.05143770f, 0.01284528f, 0.01238196f, 
    0.00927648f, 0.03162990f, 0.05001885f, -0.03499329f, 0.01623033f, -0.04042844f, -0.03963470f, -0.01358171f, 
    -0.05691965f, 0.00545988f, 0.00514140f, -0.03315382f, -0.04951618f, -0.04452540f, 0.02082935f, 0.03060859f, 
    -0.00526075f, -0.03528051f, 0.04156272f, 0.04052725f, 0.00719429f, 0.04215997f, 0.02564804f, -0.04951759f, 
    -0.05359486f, -0.00257656f, -0.05458813f, -0.05415299f, -0.03820596f, 0.01041370f, -0.04363002f, 0.02218472f, 
    0.03319508f, 0.00274762f, 0.00491733f, 0.03063884f, -0.01594566f, -0.00068543f, -0.05229636f, -0.06318513f, 
    0.03905483f, -0.02001256f, -0.01684741f, -0.00726050f, 0.01092522f, 0.01240046f, -0.04952848f, -0.01951016f, 
    -0.00002619f, 0.02479579f, 0.00229993f, -0.03642516f, 0.00359617f, 0.00877348f, -0.00198622f, 0.00894934f, 
    0.03609885f, -0.02861100f, 0.04222524f, -0.03398796f, 0.00402352f, -0.02174607f, 0.04456040f, 0.00147393f, 
    -0.05806605f, -0.00574119f, 0.00494900f, -0.04157655f, -0.06225092f, -0.04129025f, -0.06019330f, 0.01971133f, 
    -0.02233850f, -0.00661031f, 0.00184586f, -0.02548347f, 0.02635664f, 0.00809437f, 0.01360781f, -0.00647323f, 
    -0.04268516f, -0.03545870f, 0.03509199f, -0.06452897f, -0.00790373f, -0.00407670f, -0.04094843f, -0.03134439f, 
    0.00866284f, 0.03078889f, 0.04052487f, 0.02330006f, 0.04809177f, 0.04040027f, -0.03640237f, -0.04254345f, 
    0.00221131f, 0.03117293f, 0.01591469f, -0.04680940f, 0.01791847f, 0.04444992f, -0.04726248f, 0.02158435f, 
    -0.03759296f, 0.02736034f, 0.02922948f, 0.02534057f, -0.02042005f, -0.05057086f, 0.04061313f, 0.05025835f, 
    -0.04204570f, 0.02749777f, -0.03532163f, -0.03922988f, -0.00473914f, -0.03502838f, 0.00238812f, -0.01076477f, 
    -0.05407001f, -0.04488074f, -0.03795893f, 0.00879896f, 0.03261247f, -0.04624169f, 0.03184117f, -0.02756050f, 
    -0.04353982f, -0.03297078f, -0.00936788f, -0.02395079f, 0.00309493f, -0.05356410f, 0.03340315f, 0.02561554f, 
    -0.04672646f, -0.01745230f, -0.04085010f, -0.05056277f, -0.03942976f, -0.04271901f, 0.00911569f, 0.00520422f, 
    -0.03110651f, -0.01200907f, 0.02273171f, -0.01542246f, 0.03244863f, 0.03060321f, 0.02158671f, -0.04583213f, 
    -0.00647515f, -0.01444015f, -0.02952623f, -0.00723760f, 0.00357153f, -0.05775673f, 0.00081129f, -0.00371120f, 
    -0.00635467f, 0.04412679f, 0.03469265f, 0.03262615f, -0.05143061f, -0.03737137f, 0.00596461f, -0.02758125f, 
    0.01560493f, 0.02971044f, -0.00294682f, 0.05039348f, -0.00565942f, 0.02978408f, 0.02337732f, -0.03622358f, 
    -0.02677485f, 0.02028250f, 0.02347182f, 0.00314672f, 0.01264307f, -0.00758104f, 0.02733009f, -0.04775243f, 
    -0.04568637f, -0.00300134f, -0.03635537f, 0.00555883f, 0.02177458f, -0.03626806f, -0.05462760f, -0.04049557f, 
    0.04632894f, -0.05661277f, 0.03024445f, -0.01114232f, -0.01961739f, 0.01086770f, 0.05121661f, -0.00538231f, 
    -0.03743606f, -0.01158334f, -0.05544543f, 0.00318805f, 0.04369549f, -0.03482042f, -0.02047179f, -0.01239097f, 
    -0.01455098f, -0.00701549f, -0.05096785f, -0.01936798f, -0.04547146f, 0.02496648f, 0.02592253f, 0.00369796f, 
    0.04980404f, 0.01269600f, -0.00951784f, -0.04453445f, -0.01775968f, -0.00145780f, 0.03352220f, 0.02832786f, 
    0.01399847f, 0.02506102f, -0.01604249f, -0.04643109f, -0.04003436f, 0.01352416f, 0.00469183f, 0.02685281f, 
    0.03243935f, -0.03238770f, -0.01268239f, 0.05072014f, -0.05939371f, -0.01502122f, -0.05150133f, -0.02630328f, 
    0.03058643f, 0.03431742f, -0.00596048f, 0.03070808f, -0.03426638f, -0.05582842f, -0.05014648f, 0.03619625f, 
    -0.01354328f, -0.04117124f, 0.02714082f, -0.04859076f, -0.05922934f, 0.02112857f, 0.04537410f, 0.00333698f, 
    0.02949023f, -0.06075826f, 0.01772880f, 0.02044677f, 0.02469801f, 0.03201884f, 0.01754510f, 0.00862113f, 
    0.02606249f, -0.01226480f, -0.03445354f, 0.00868115f, 0.00644057f, 0.02631410f, -0.00570537f, -0.00930997f, 
    -0.05466750f, -0.01923447f, 0.04036424f, 0.02979881f, 0.04506043f, -0.03897836f, -0.01530086f, 0.00142629f, 
    -0.05690975f, 0.02280317f, -0.04197348f, -0.02076511f, -0.05049913f, 0.04174375f, 0.02434992f, 0.02983955f, 
    -0.03185417f, -0.06330427f, 0.01581412f, 0.01778712f, 0.04210747f, -0.03709199f, 0.00534451f, 0.02436267f, 
    -0.05515350f, -0.01311769f, 0.01074397f, 0.00187122f, -0.03043937f, -0.05002607f, -0.02358766f, 0.04739771f, 
    -0.05747687f, 0.01989037f, 0.03562208f, -0.02851089f, -0.03258391f, 0.03908205f, 0.04397465f, 0.03274773f, 
    -0.05293917f, 0.02392247f, -0.04840806f, 0.01475400f, -0.03420689f, -0.01648414f, -0.05163797f, 0.03281509f, 
    0.03814106f, 0.00403710f, -0.02335956f, -0.01602589f, -0.03141134f, -0.05941766f, 0.04463570f, 0.00540097f, 
    0.03580762f, -0.00041665f, -0.01587561f, -0.06188277f, -0.03476333f, -0.01697804f, -0.03226966f, -0.01578359f, 
    -0.05068825f, 0.02490686f, 0.00457752f, -0.00634177f, 0.04105677f, -0.03776144f, -0.03741397f, -0.03993292f, 
    0.01813190f, -0.04341804f, -0.03533480f, -0.01566280f, -0.03907415f, 0.01330942f, 0.04990613f, -0.01499379f, 
    0.00307351f, -0.03051427f, 0.02820788f, 0.04365386f, -0.00306328f, -0.05089489f, -0.05089893f, -0.05813905f, 
    -0.00293142f, -0.05302025f, 0.00446446f, -0.04252991f, -0.03535105f, -0.00236613f, 0.01255340f, -0.05608817f, 
    0.00247547f, 0.02887186f, -0.04151585f, 0.04782923f, -0.03503036f, -0.00510252f, -0.05690256f, -0.02424198f, 
    -0.03408082f, -0.01523751f, -0.05182691f, 0.03533085f, 0.02722795f, 0.02917946f, -0.03995355f, 0.03469144f, 
    0.00213487f, -0.04719022f, 0.03567805f, -0.03776661f, 0.01484813f, -0.00706907f, -0.02922695f, -0.05626075f, 
    -0.02733337f, -0.05057031f, 0.03151338f, 0.01803973f, 0.00084313f, 0.01238384f, -0.03605353f, -0.00912264f, 
    -0.04102466f, -0.05451247f, 0.02616940f, -0.02960425f, -0.02559031f, -0.03496108f, 0.00188034f, 0.03194503f, 
    -0.03759636f, 0.01378053f, -0.02785531f, 0.02491799f, -0.05474389f, -0.05247338f, -0.01141499f, 0.02718335f, 
    -0.02322479f, -0.01548614f, 0.02034557f, 0.02130981f, -0.01563006f, 0.03412483f, 0.04849658f, -0.06163161f, 
    -0.02926623f, -0.02692639f, 0.00548732f, -0.05744048f, 0.03998101f, 0.01685045f, -0.05390864f, 0.04208258f, 
    0.01957851f, -0.05789094f, -0.04343029f, -0.06165492f, -0.00042535f, -0.05735100f, -0.03860339f, 0.02510604f, 
    -0.00924331f, -0.01690466f, 0.01627014f, -0.01097592f, 0.04294461f, -0.05254517f, 0.03687947f, -0.00356837f, 
    -0.03861221f, 0.03780107f, 0.01031601f, 0.03080371f, 0.00583233f, 0.02940157f, -0.03833602f, -0.02287109f, 
    -0.00480286f, 0.04339150f, 0.05147866f, 0.02336292f, -0.04841836f, -0.00817165f, -0.04943729f, 0.04237820f, 
    -0.01496649f, -0.01967686f, 0.05081975f, 0.04759389f, -0.05152057f, -0.05740156f, -0.00764887f, -0.06749143f, 
    -0.03979233f, -0.05074231f, -0.00451961f, -0.01319489f, -0.06338596f, 0.04447452f, -0.01616378f, 0.00750108f, 
    -0.04304032f, -0.04761069f, -0.01558475f, 0.02017972f, 0.00606227f, 0.03850013f, -0.03412795f, 0.03983899f, 
    0.02737650f, 0.02804035f, 0.02964764f, -0.00193613f, -0.02482764f, -0.04702084f, -0.06580452f, 0.01005736f, 
    -0.03367293f, -0.06070792f, -0.01138309f, -0.01209671f, 0.01767849f, 0.03271767f, -0.02040471f, -0.01725927f, 
    0.03172875f, 0.03153135f, -0.00671214f, -0.04954525f, 0.01732164f, 0.00701185f, -0.01302185f, 0.01970743f, 
    0.02328316f, 0.04858718f, -0.02813165f, -0.05746233f, 0.01725450f, -0.02127687f, -0.01298918f, -0.01939081f, 
    -0.02490515f, 0.04950760f, 0.03005329f, -0.01858749f, 0.02581869f, 0.03782687f, 0.02960992f, -0.00384352f, 
    -0.06383624f, -0.01065130f, -0.06489588f, 0.03288005f, 0.02628073f, -0.02473924f, -0.04107609f, -0.05324739f, 
    -0.04782449f, -0.01643655f, -0.00950663f, -0.01873995f, -0.00899796f, 0.01572414f, -0.00130905f, -0.01569139f, 
    -0.02798937f, 0.00973733f, 0.04619903f, -0.01836470f, -0.00257060f, -0.03767847f, 0.02642685f, -0.05877298f, 
    0.02511899f, 0.04221384f, 0.01694193f, 0.00052275f, 0.03231895f, -0.03756418f, -0.05447762f, -0.03425158f, 
    0.02219080f, -0.01170421f, 0.01809678f, -0.00137839f, 0.04090997f, 0.03520672f, -0.01239484f, 0.00919930f, 
    0.01107300f, -0.01987621f, -0.02805067f, -0.03782197f, 0.00685152f, -0.00697350f, -0.00091223f, 0.02207981f, 
    -0.05842198f, 0.01582221f, -0.02710774f, 0.01268569f, -0.00800361f, 0.03568365f, -0.00381429f, 0.04208649f, 
    0.01629376f, -0.05517286f, 0.04464174f, -0.01887836f, -0.00476098f, 0.03094393f, 0.03443478f, -0.00245189f, 
    -0.04578521f, -0.04658608f, 0.03605921f, 0.03981668f, 0.00176015f, -0.02570032f, 0.02065010f, 0.00237257f, 
    -0.03417452f, 0.04295454f, 0.03102547f, 0.03854058f, -0.00911314f, -0.01711914f, -0.01870632f, -0.04459183f, 
    0.02732074f, -0.02845396f, -0.02149092f, 0.00503595f, -0.00448028f, -0.04136730f, -0.04184125f, -0.02885944f, 
    0.00719225f, 0.05400980f, 0.00394022f, -0.02655899f, -0.00198226f, 0.05256381f, -0.02765405f, -0.05057641f, 
    -0.03690501f, -0.05850488f, -0.00078977f, 0.00532375f, 0.01944873f, -0.02429445f, 0.04281589f, -0.02455777f, 
    -0.01927113f, 0.03058743f, -0.02620870f, 0.00329766f, -0.01267269f, 0.05617337f, 0.00620866f, 0.04943562f, 
    -0.04083689f, 0.03322638f, -0.01503214f, 0.02087061f, 0.00333986f, -0.05653788f, -0.04162990f, -0.05918724f, 
    -0.06081403f, 0.04660340f, 0.04657734f, -0.04809871f, 0.02791749f, -0.03556889f, 0.03716522f, -0.03407412f, 
    -0.00831836f, -0.02312321f, 0.04313080f, -0.01746920f, 0.03976782f, -0.04466106f, 0.01389892f, 0.03269092f, 
    -0.03065818f, -0.02995102f, 0.00788653f, -0.00502622f, -0.03146546f, -0.04986174f, 0.02694218f, 0.00776519f, 
    -0.01883056f, 0.00765691f, 0.01558454f, 0.02173508f, 0.03276137f, -0.04747591f, -0.01910266f, -0.00258690f, 
    -0.05271454f, -0.00729183f, 0.00692338f, -0.03645721f, -0.01458864f, -0.04865910f, -0.00405817f, 0.00365929f, 
    0.03909718f, -0.04456401f, 0.04637218f, 0.00093184f, -0.04364318f, 0.03454056f, -0.01321484f, -0.00572725f, 
    -0.00092786f, -0.02799003f, -0.00789762f, 0.00939921f, -0.04490018f, -0.00539809f, 0.04497169f, 0.01222267f, 
    0.04128186f, -0.04103643f, -0.03090679f, 0.03033495f, -0.00019713f, -0.04525492f, 0.00998373f, 0.02583702f, 
    -0.04729016f, 0.01677963f, 0.04842608f, 0.04315318f, 0.02742756f, -0.02570353f, 0.02075165f, 0.03533871f, 
    -0.02675939f, -0.04608492f, 0.04251946f, 0.04152334f, -0.05190032f, -0.04720828f, -0.05805589f, 0.01686862f, 
    0.04917879f, -0.00214076f, -0.02417349f, -0.03330076f, 0.02133813f, 0.01989219f, -0.01162473f, -0.01363398f, 
    -0.00616351f, 0.03383023f, -0.04897933f, -0.05960204f, -0.04617611f, -0.04355915f, 0.04684455f, 0.03483655f, 
    -0.01256107f, 0.04635417f, -0.02275987f, 0.00759983f, 0.01209474f, 0.04104025f, -0.03219585f, 0.04951913f, 
    0.04819329f, 0.00363730f, 0.01499580f, -0.04512520f, -0.01272518f, -0.02389774f, -0.00358338f, -0.00064618f, 
    -0.03235922f, 0.01628390f, -0.02822085f, 0.02184284f, -0.00877163f, -0.01129358f, -0.03506000f, 0.04932952f, 
    -0.05279019f, -0.05058289f, -0.01959446f, 0.01889699f, -0.00680069f, -0.05702682f, -0.05585366f, 0.00199759f, 
    -0.04565261f, 0.02417457f, -0.00266708f, -0.01781868f, -0.04438433f, -0.03018800f, -0.02507286f, 0.02191764f, 
    -0.03270334f, 0.04090989f, -0.04750131f, 0.02119927f, -0.05331539f, -0.00984754f, -0.03039775f, -0.01496256f, 
    0.01630268f, -0.05211831f, 0.00236874f, -0.00546923f, 0.03875341f, 0.02853823f, -0.04459625f, 0.00129055f, 
    -0.00324222f, 0.02860796f, 0.03703288f, -0.04616074f, -0.00915658f, -0.01556476f, 0.00882959f, -0.06122593f, 
    0.01693587f, 0.01528785f, 0.04250548f, -0.05330056f, -0.05190884f, 0.05068188f, -0.00781082f, -0.00137135f, 
    0.03966530f, 0.02156847f, -0.06136151f, -0.01722973f, -0.05025159f, -0.03601113f, 0.03135612f, -0.06223343f, 
    -0.03725246f, -0.00435720f, 0.02170289f, 0.02731574f, -0.05049925f, -0.06035941f, -0.04984630f, 0.00082185f, 
    -0.01254454f, -0.03386247f, -0.05445151f, -0.01614996f, 0.02111514f, 0.00249623f, 0.00931953f, 0.02045247f, 
    -0.03817561f, 0.00000240f, 0.02352059f, 0.04659196f, 0.03343099f, 0.05439733f, 0.05317205f, 0.03470241f, 
    -0.02471077f, -0.02421826f, 0.14170505f, -0.01443216f, 0.17810546f, 0.00224015f, -0.03446629f, -0.12074128f, 
    0.16183071f, 0.13818696f, 0.01172317f, 0.04736362f, 0.08891936f, -0.07415556f, 0.01802546f, 0.14389515f, 
    -0.03753524f, -0.01357874f, -0.05781679f, -0.04763038f, 0.10745323f, 0.12234755f, -0.26117274f, 0.17135756f, 
    0.11130964f, 0.21156949f, -0.00446976f, -0.03357195f, 0.18041298f, 0.09400932f, 0.03048571f, -0.02113120f, 
    0.07309446f, 0.01689074f, 0.03634389f, 0.18157181f, 0.10242484f, 0.09808144f, 0.01391027f, -0.19740346f, 
    -0.48304430f, -0.09787861f, -0.09440007f, 0.14572108f, 0.04753394f, -0.00909050f, -0.06525882f, -0.17144993f, 
    0.01683207f, 0.02413492f, 0.16048346f, -0.00083238f, 0.01939001f, -0.07225378f, 0.15206225f, 0.09453289f, 
    0.14336416f, -0.00766156f, -0.21047950f, -0.03747268f, -0.26316500f, -0.25693464f, -0.03563098f, -0.01005407f, 
    -0.09246211f, -0.19198416f, -0.09202745f, -0.07438982f, -0.08671072f, 0.17681324f, 0.03459508f, -0.19397780f, 
    -0.19513118f, 0.02608229f, -0.08694095f, -0.03043304f, 0.09610084f, 0.02957030f, 0.09757477f, 0.04628264f, 
    -0.13716017f, 0.05151949f, -0.06467138f, -0.02847540f, -0.12729505f, -0.00842303f, -0.04447128f, 0.05467509f, 
    0.03045831f, -0.14386061f, 0.01386949f, -0.11426611f, -0.01033764f, -0.03642401f, 0.02858903f, 0.13104455f, 
    0.05222402f, 0.07580308f, 0.06711630f, 0.03181278f, 0.05226231f, 0.11672523f, 0.08696183f, -0.01741143f, 
    -0.12357034f, -0.08088331f, 0.06663820f, -0.09882733f, 0.00734759f, -0.03371051f, 0.07330395f, 0.13983507f, 
    0.30743966f, 0.15864463f, 0.02418216f, 0.06830705f, 0.10335225f, 0.10344379f, 0.27829829f, 0.06694051f, 
    0.21552800f, -0.06580888f, -0.12187944f, 0.23229693f, -0.23934729f, 0.11665781f, 0.06366192f, -0.03427995f, 
    0.14065504f, 0.06515646f, -0.02566540f, -0.05288124f, -0.04071089f, 0.04634685f, 0.06511495f, 0.04779396f, 
    0.10663892f, 0.16924204f, 0.04582766f, 0.13371396f, 0.06949469f, 0.07524152f, -0.01297513f, 0.10391442f, 
    -0.04180582f, 0.10675704f, -0.03710466f, -0.02173176f, -0.01541521f, -0.06732514f, 0.06142828f, -0.08899572f, 
    -0.07499225f, -0.00172759f, -0.01339195f, 0.07464755f, 0.14738114f, 0.05463823f, 0.10847671f, 0.05007091f, 
    0.24022108f, -0.04807637f, -0.17903179f, 0.13007386f, 0.02706273f, 0.39384675f, 0.03657947f, 0.23966068f, 
    0.08904129f, 0.17518677f, 0.06545203f, 0.17005037f, 0.05118734f, 0.04581296f, 0.09075215f, 0.03502823f, 
    -0.02456234f, 0.06842982f, -0.04382457f, 0.01536045f, -0.21141322f, -0.03696876f, 0.11371830f, 0.03136161f, 
    -0.12606454f, 0.00541230f, 0.01835237f, 0.07602648f, -0.12111053f, -0.06463432f, -0.01581983f, -0.14252383f, 
    -0.07591327f, -0.04544307f, -0.03923916f, 0.13996010f, -0.00642665f, -0.00534936f, 0.05523028f, -0.01357016f, 
    -0.34347123f, -0.05419778f, 0.24044687f, 0.01430724f, -0.05051930f, -0.20872298f, -0.15648487f, -0.12604617f, 
    -0.11358447f, -0.20107912f, -0.22278272f, -0.10565829f, -0.00822239f, 0.02376532f, 0.06266582f, 0.15920310f, 
    0.02487732f, 0.07075737f, 0.05847427f, -0.05766711f, 0.31954199f, -0.19215117f, -0.10922601f, 0.27357742f, 
    -0.07952043f, -0.02357461f, -0.06499375f, 0.00924876f, 0.09424762f, 0.03782729f, -0.04432480f, -0.05955279f, 
    -0.17807935f, -0.00030429f, 0.10095929f, 0.03370700f, 0.05757460f, 0.12121440f, -0.11283009f, 0.16022027f, 
    -0.17732410f, -0.10377518f, 0.01109244f, 0.13992484f, 0.03308715f, -0.06325135f, 0.02942441f, -0.05619386f, 
    0.02554899f, -0.03465978f, 0.08118992f, 0.11170869f, 0.01357984f, 0.02383423f, 0.03994836f, 0.11199597f, 
    0.14153798f, 0.02866502f, -0.13925934f, -0.19346514f, -0.24910866f, -0.34316146f, -0.37238404f, 0.29774833f, 
    -0.27633348f, 0.03875587f, -0.09932590f, 0.03228394f, 0.14553095f, 0.21891794f, -0.09782987f, 0.09032108f, 
    -0.01381877f, -0.03372962f, 0.13860029f, 0.09746476f, 0.08095352f, 0.09293593f, -0.00152867f, 0.09946229f, 
    -0.16518676f, 0.10615759f, 0.01332241f, -0.07949945f, -0.04590489f, 0.03174449f, 0.02581424f, -0.09342146f, 
    -0.16082408f, -0.01346492f, 0.13011517f, 0.14285094f, 0.05524642f, 0.17281367f, -0.02359086f, -0.01335679f, 
    0.01088099f, -0.04811193f, 0.02718689f, -0.08178430f, 0.11693170f, -0.11096472f, -0.29749903f, 0.39219245f, 
    0.09523613f, 0.15619825f, -0.14499483f, 0.01418994f, 0.03783033f, 0.20320588f, 0.09171761f, 0.07289530f, 
    -0.00805173f, 0.01497169f, 0.02358452f, 0.15704352f, -0.02118587f, 0.02293545f, -0.15526575f, -0.04171522f, 
    -0.30867541f, -0.16647050f, 0.06356455f, -0.10146188f, 0.08617724f, 0.01144132f, 0.24871597f, -0.26592231f, 
    0.15540458f, 0.03198311f, 0.06870786f, -0.09495311f, 0.13501143f, 0.04202147f, -0.00439897f, -0.04648633f, 
    0.03384396f, 0.00615800f, 0.02393651f, -0.00252877f, -0.37322667f, 0.04576850f, 0.09311443f, -0.03463040f, 
    0.21851999f, -0.06792088f, 0.05895913f, -0.01494590f, 0.09034284f, 0.09845110f, -0.06142095f, -0.07610609f, 
    -0.00071905f, 0.04764187f, -0.02226754f, -0.06574821f, -0.05314454f, -0.00939589f, 0.09325376f, -0.11629011f, 
    -0.19883090f, -0.22482812f, 0.04162845f, 0.17605557f, -0.15623119f, -0.03046389f, 0.03322335f, -0.03906837f, 
    -0.19691850f, -0.13885511f, -0.01925596f, -0.06751888f, 0.03302403f, -0.00220545f, -0.10080282f, 0.02276160f, 
    0.05752571f, -0.21939752f, -0.04253534f, -0.16157106f, 0.11875357f, 0.18325415f, 0.13578007f, 0.30459106f, 
    -0.20038570f, -0.08547158f, 0.10159841f, -0.04255700f, -0.15745872f, 0.06989864f, 0.03130040f, -0.10355508f, 
    0.08186309f, -0.09519800f, -0.20344017f, -0.01020886f, -0.00805020f, -0.11508278f, -0.26503283f, -0.35834229f, 
    0.14807996f, -0.15142445f, -0.06399575f, -0.06921697f, 0.10882869f, 0.30350703f, 0.05294579f, 0.05073084f, 
    -0.00853657f, 0.19724201f, 0.01086573f, -0.05277688f, 0.06954885f, -0.03595652f, 0.02511015f, 0.07885082f, 
    -0.06825442f, 0.02363221f, -0.04473474f, -0.05265163f, 0.13521546f, -0.14969264f, -0.04936828f, -0.15060093f, 
    0.16469677f, 0.12184148f, -0.01693515f, -0.02491591f, 0.22378542f, -0.06002204f, 0.08741819f, 0.06330649f, 
    0.21979202f, -0.05768892f, 0.14273584f, 0.02545085f, -0.10290372f, 0.09305720f, 0.07796592f, 0.22748494f, 
    0.04773945f, -0.33085403f, 0.29019096f, 0.33912984f, 0.02208524f, 0.09176765f, 0.06959791f, 0.02035780f, 
    0.00622535f, -0.08789252f, -0.02848476f, 0.08317658f, 0.10149623f, -0.00197032f, 0.05691717f, -0.02549682f, 
    -0.07829817f, 0.02810112f, -0.01149805f, 0.04104959f, 0.29459271f, 0.07875490f, -0.18696183f, 0.01642939f, 
    0.20137690f, 0.10380128f, 0.09329004f, 0.02906578f, -0.00896837f, 0.08631970f, 0.14621064f, 0.04208696f, 
    0.06348443f, 0.02128454f, 0.18566847f, 0.05121651f, 0.05223673f, 0.09272768f, 0.01696774f, -0.01430762f, 
    0.04348780f, 0.02495157f, -0.00844033f, 0.22268711f, 0.01938170f, 0.09911996f, 0.01928319f, 0.03756621f, 
    0.02087237f, 0.11988587f, -0.06260902f, 0.00681261f, 0.07843670f, 0.06901433f, -0.03382153f, -0.07005811f, 
    -0.05094129f, 0.00388855f, 0.03273756f, 0.08487481f, 0.23086990f, -0.07323613f, -0.01263438f, -0.11023536f, 
    0.01274054f, -0.11233524f, 0.29926476f, 0.13490140f, 0.06424650f, -0.00608227f, -0.06765784f, -0.01464605f, 
    0.04444329f, -0.10617319f, 0.01903897f, -0.02991754f, -0.09971835f, 0.07867127f, 0.18882515f, 0.00270763f, 
    -0.37591192f, 0.04664404f, -0.07811397f, -0.23080462f, -0.10209920f, -0.08159532f, -0.13754776f, -0.26761943f, 
    -0.23580702f, -0.09928184f, 0.04928930f, 0.13924320f, -0.09192572f, 0.04945214f, 0.10165564f, 0.12704290f, 
    -0.02298775f, 0.11054837f, 0.13975726f, -0.05595609f, 0.02044959f, -0.25406119f, 0.06513408f, 0.10262460f, 
    -0.10289835f, -0.01162776f, -0.06498899f, -0.00998040f, -0.13246705f, -0.06528142f, -0.06692245f, 0.05056178f, 
    -0.00761050f, -0.01893353f, 0.12315697f, -0.09139003f, 0.15486901f, 0.06632391f, 0.07584644f, 0.23009212f, 
    -0.05800631f, -0.16564752f, 0.20385680f, 0.08578766f, -0.08480562f, 0.01798629f, -0.03792423f, -0.00048830f, 
    0.05599612f, -0.19430257f, -0.03710598f, 0.01167241f, 0.02270844f, -0.06330020f, 0.08089186f, -0.11086997f, 
    0.16839641f, -0.00005066f, -0.00023392f, -0.04482166f, -0.03231565f, -0.28523439f, 0.09729350f, 0.21416327f, 
    -0.02283407f, -0.08729514f, -0.01248011f, 0.00991959f, -0.06554449f, 0.33582211f, -0.05271368f, -0.03369538f, 
    0.01253209f, -0.16584730f, 0.07893792f, -0.11246289f, -0.05593858f, -0.01290512f, -0.12568547f, 0.23603657f, 
    -0.87431455f, 0.04672609f, 0.08922857f, -0.09021483f, 0.17938858f, -0.08431178f, 0.11013762f, -0.15602370f, 
    0.18375587f, 0.23782641f, 0.14898293f, 0.13864666f, 0.00504128f, 0.05834560f, -0.02323462f, -0.05814310f, 
    -0.02816366f, 0.16207871f, -0.00770667f, -0.04880282f, 0.27281296f, -0.04473611f, 0.15591040f, -0.05027107f, 
    0.12882473f, -0.02193450f, 0.08144762f, -0.14140207f, 0.06908321f, -0.12706460f, 0.13091229f, -0.12592138f, 
    0.01113896f, 0.00931176f, 0.06580498f, -0.00522790f, -0.01290316f, -0.05780813f, -0.07627851f, 0.05682809f, 
    0.04329137f, -0.00645951f, -0.01348257f, 0.03410746f, 0.03044324f, -0.01760961f, -0.02070270f, -0.02611385f, 
    -0.01258562f, -0.00587512f, -0.04337415f, 0.04952519f, -0.05685572f, -0.05336675f, 0.03624989f, -0.01775810f, 
    0.03353368f, -0.05905322f, 0.02837783f, 0.00907886f, -0.01865361f, 0.03044936f, 0.00633474f, 0.00900351f, 
    -0.02619446f, 0.00152412f, 0.02288109f, -0.04027279f, -0.01041764f, -0.04186804f, 0.01175955f, -0.04251897f, 
    0.00026148f, 0.00505291f, -0.01834315f, -0.01657344f, -0.02231309f, 0.03630200f, 0.01769522f, -0.05804163f, 
    0.00303165f, -0.03269992f, 0.02076698f, -0.04211219f, 0.04832871f, 0.04569368f, 0.01460263f, 0.00498891f, 
    -0.04984257f, -0.06071059f, -0.04324663f, -0.04317956f, -0.05450393f, -0.01125425f, 0.01916726f, -0.02082259f, 
    0.02559885f, 0.03366370f, -0.04992058f, 0.04367225f, -0.04523495f, -0.01552748f, -0.02820372f, -0.02665354f, 
    -0.01209330f, 0.00383853f, -0.00748451f, 0.03082924f, 0.00715756f, -0.01501411f, 0.00607613f, 0.01137498f, 
    -0.04917074f, -0.01801008f, 0.01108091f, -0.06076865f, -0.00043967f, 0.01880107f, 0.01430891f, -0.01600436f, 
    -0.03457906f, 0.02954566f, -0.00030614f, 0.00113016f, -0.04966382f, -0.03945686f, 0.03746256f, -0.03138569f, 
    0.02950867f, -0.01056921f, 0.03483139f, 0.02652677f, -0.03146896f, 0.03402447f, -0.03309957f, -0.02605389f, 
    -0.01693736f, -0.02248997f, -0.00036045f, 0.03923535f, -0.05220102f, -0.05111244f, 0.00800719f, 0.04389172f, 
    -0.04889991f, -0.05320120f, -0.00202950f, 0.02202161f, -0.02698158f, 0.03692486f, 0.00052967f, -0.02022336f, 
    -0.05862275f, -0.04359118f, 0.02421511f, 0.03079635f, -0.01944051f, -0.02805405f, -0.05485541f, -0.00499035f, 
    -0.01482644f, 0.00042575f, 0.02701212f, 0.04470859f, -0.02883507f, -0.05554422f, -0.03184642f, -0.00375163f, 
    0.00634110f, -0.02111016f, 0.01489467f, -0.01250689f, -0.02496473f, 0.04002451f, -0.05043998f, 0.02247222f, 
    -0.03677306f, -0.03290928f, 0.04359080f, 0.04767522f, 0.04384722f, -0.02940908f, 0.04015221f, -0.00860302f, 
    -0.02683353f, 0.02001065f, -0.01911027f, 0.04741194f, 0.04186316f, -0.02851025f, 0.03226292f, -0.05644885f, 
    -0.01685903f, -0.04150235f, 0.00011597f, -0.04464640f, -0.05062453f, -0.03906964f, 0.00998534f, -0.03676372f, 
    0.02216830f, -0.00189451f, -0.03607076f, 0.03745468f, 0.01871496f, 0.01936547f, -0.03389059f, -0.03446944f, 
    -0.05792486f, -0.06002210f, -0.05253783f, -0.01183738f, -0.01134844f, -0.01952556f, -0.03944038f, -0.00941171f, 
    -0.03457499f, -0.05108785f, 0.01797791f, -0.02626496f, -0.00849288f, 0.04498108f, -0.00654525f, -0.00063886f, 
    -0.04410077f, -0.03099790f, -0.02739309f, -0.00678170f, -0.05894895f, -0.00910954f, -0.00210380f, 0.00850324f, 
    -0.02492745f, -0.05575985f, 0.00751943f, -0.03051306f, -0.04289271f, 0.01250705f, -0.02279506f, 0.03050976f, 
    -0.01785499f, -0.02355222f, 0.02225235f, -0.00579841f, 0.02551225f, 0.02983600f, 0.02017508f, -0.00130753f, 
    0.04943005f, 0.02451551f, -0.06125495f, -0.01600082f, 0.03630114f, -0.00001062f, -0.01241372f, -0.01418731f, 
    0.00840386f, 0.04607613f, -0.02542730f, -0.04707633f, 0.04353369f, 0.01071651f, -0.05318443f, -0.02901239f, 
    -0.05252521f, 0.02582043f, -0.01565182f, -0.05435233f, -0.03687088f, -0.01451861f, -0.03316026f, -0.03801541f, 
    -0.03957034f, -0.02736065f, 0.03051239f, 0.03118439f, -0.04412417f, 0.00101611f, -0.00019179f, 0.03416696f, 
    0.02516254f, 0.02588126f, 0.03528045f, 0.00254789f, -0.02222700f, 0.00829744f, -0.05153892f, 0.03567886f, 
    0.01583052f, 0.02849485f, -0.04037333f, 0.00797452f, -0.04118853f, 0.01651181f, 0.02143663f, 0.01936474f, 
    0.01664927f, 0.00909198f, 0.02076450f, -0.01901014f, 0.04612109f, -0.03126517f, -0.04010527f, -0.05388382f, 
    -0.01127716f, -0.03235400f, 0.02097940f, -0.04851423f, 0.00771134f, 0.00611635f, -0.04599617f, -0.00953456f, 
    -0.04112313f, -0.03008037f, -0.01098796f, -0.00695800f, -0.03898511f, -0.01073266f, 0.01683029f, 0.01020220f, 
    -0.05271775f, -0.04714497f, -0.02940373f, -0.04046677f, 0.00930083f, 0.04394757f, -0.01047837f, 0.04430900f, 
    0.01557834f, -0.01821785f, -0.00663005f, -0.02547190f, -0.05014614f, -0.00546966f, -0.00249918f, -0.03266118f, 
    -0.02142278f, 0.03503827f, 0.03857228f, -0.01058319f, 0.01173355f, 0.02743620f, -0.03888535f, -0.01422952f, 
    0.00409997f, 0.04284520f, -0.04715869f, -0.04690218f, 0.04747420f, -0.02404259f, 0.04513347f, 0.02974192f, 
    -0.04507035f, -0.00351073f, 0.00313990f, -0.00577751f, -0.05308116f, 0.02153473f, -0.05003762f, -0.02302406f, 
    -0.05405333f, -0.00626210f, 0.04379063f, 0.01171437f, -0.03213995f, -0.01907643f, 0.01415274f, 0.02020352f, 
    -0.05809570f, 0.03537421f, -0.01648585f, -0.00722452f, 0.01429742f, 0.02634309f, -0.01634860f, -0.06053451f, 
    0.01134101f, 0.01910194f, -0.03742051f, -0.03769678f, -0.03818069f, -0.05343157f, -0.05562756f, 0.04229463f, 
    0.02158745f, -0.06104849f, 0.03314451f, -0.00721036f, 0.03695462f, 0.01526387f, 0.04371137f, -0.02193101f, 
    -0.05789056f, -0.04950241f, 0.03481299f, -0.02565284f, -0.01696827f, 0.03887620f, 0.00876484f, -0.00281299f, 
    -0.00571233f, 0.04148361f, 0.02601208f, -0.01766771f, -0.06239773f, -0.01436483f, 0.00386154f, -0.00623298f, 
    -0.04529810f, -0.00042012f, -0.03941164f, -0.03019884f, 0.03266328f, 0.04111230f, 0.00836430f, -0.03117448f, 
    -0.03377584f, 0.02943140f, -0.00196468f, -0.04581439f, 0.01332925f, -0.03294359f, -0.02555576f, -0.00011974f, 
    -0.01498895f, 0.02429142f, -0.03269140f, -0.06065777f, -0.04369969f, 0.00541210f, -0.05156180f, 0.01034730f, 
    -0.00456389f, -0.06388944f, 0.02039443f, -0.05039016f, -0.00336574f, 0.03856283f, -0.05096798f, 0.05192934f, 
    -0.01985544f, -0.00883661f, 0.00629468f, 0.01111778f, -0.00846138f, -0.01153922f, -0.04092658f, -0.05656737f, 
    0.02673867f, -0.05023482f, -0.05220835f, -0.04839182f, -0.03571082f, -0.03927561f, -0.03132214f, -0.03947844f, 
    -0.05948937f, -0.03225455f, -0.01117082f, -0.00725399f, 0.01513918f, -0.06266829f, -0.00401562f, 0.03614578f, 
    0.03415922f, -0.01143030f, 0.00631088f, 0.04529533f, -0.06050179f, -0.06121862f, 0.00242085f, -0.03307015f, 
    0.01998973f, -0.04523745f, -0.04553670f, 0.00156936f, -0.01443232f, 0.03199053f, -0.05160112f, -0.01747387f, 
    -0.00137172f, 0.03822507f, 0.03945806f, 0.01021029f, 0.02708633f, -0.05866605f, -0.01327752f, 0.01578588f, 
    0.01219018f, -0.01534773f, -0.02652149f, 0.03385218f, -0.05480058f, 0.03487909f, 0.00945120f, 0.04813926f, 
    -0.04280822f, -0.05979252f, -0.02798395f, 0.00049698f, 0.04241366f, 0.00368964f, -0.02597494f, 0.00186537f, 
    0.00975564f, -0.02271209f, -0.00355560f, -0.03614441f, -0.03880195f, -0.05981935f, -0.04362704f, -0.04127113f, 
    0.01625561f, -0.01962985f, 0.03409965f, 0.00200844f, -0.05716867f, 0.02232855f, -0.03798386f, -0.04860847f, 
    0.04254528f, -0.02720355f, -0.03831556f, -0.02420329f, -0.02156973f, -0.04438575f, 0.01375855f, 0.03930569f, 
    0.00487698f, 0.02063254f, -0.00634934f, -0.01711576f, -0.05644608f, 0.01168632f, 0.04065665f, -0.01222917f, 
    0.01076973f, 0.02725518f, -0.04261836f, 0.01860298f, 0.04075434f, -0.00768849f, 0.03151679f, 0.03683290f, 
    -0.01261250f, 0.00907920f, 0.00627110f, 0.02645698f, -0.06166221f, 0.04078692f, 0.00709560f, -0.00032956f, 
    0.01856771f, 0.00228848f, 0.03604177f, -0.05182062f, -0.02860088f, 0.02369168f, -0.04212097f, -0.05514294f, 
    -0.00625643f, -0.04462486f, -0.00390373f, -0.03277028f, 0.00109837f, 0.00272787f, 0.03620037f, -0.05431520f, 
    -0.03956644f, -0.02827874f, 0.02874154f, -0.02934512f, 0.03527465f, -0.04660506f, -0.01282607f, -0.01173011f, 
    0.01727908f, -0.01654519f, -0.05894072f, -0.02859717f, -0.00548460f, -0.05449824f, 0.00033904f, 0.02930033f, 
    0.01238823f, 0.00139947f, -0.01095453f, 0.00852080f, -0.02171737f, 0.02840161f, -0.04789409f, -0.05395737f, 
    -0.05667582f, 0.01427950f, 0.03304706f, -0.05639536f, 0.01967748f, -0.00590017f, -0.00903482f, -0.03996857f, 
    0.00020807f, 0.00646551f, -0.03369202f, -0.03341485f, -0.03615134f, 0.03818101f, -0.04621330f, 0.03045358f, 
    0.04129654f, 0.00107511f, -0.05146649f, 0.00933648f, -0.00848155f, -0.03181065f, 0.03550151f, 0.03915715f, 
    -0.00665693f, -0.06133210f, 0.04470612f, 0.00968197f, -0.03574650f, 0.03561301f, 0.05348045f, -0.04160295f, 
    0.01259651f, 0.00599405f, 0.00161815f, 0.03136973f, 0.03453158f, 0.01466026f, -0.00181175f, -0.01670601f, 
    -0.01713548f, -0.04359407f, -0.04974569f, 0.04351250f, -0.05640366f, -0.04198356f, -0.05460218f, -0.02657452f, 
    -0.01198994f, -0.01719973f, -0.02688606f, 0.03482203f, 0.00600689f, -0.04423310f, -0.01749974f, 0.04495222f, 
    -0.05010932f, -0.04158990f, -0.04491113f, -0.05896918f, 0.03903848f, -0.02327556f, -0.02249383f, 0.02911616f, 
    -0.00320958f, -0.01498113f, 0.02570515f, 0.04778093f, 0.01154289f, -0.02596541f, -0.03812908f, 0.02620840f, 
    0.03463599f, -0.03209043f, -0.04846615f, 0.00687498f, 0.02609800f, 0.01940163f, -0.01599864f, -0.02846438f, 
    -0.02531269f, 0.03778891f, 0.04340543f, -0.03708318f, -0.04925451f, -0.02902619f, -0.01008497f, -0.00542887f, 
    -0.46530280f, -0.33405778f, 0.03343072f, -0.24935764f, 0.07601351f, 0.09816680f, 0.07531724f, -0.11546928f, 
    0.09622035f, -0.05454637f, -0.04062654f, 0.03216590f, 0.11296135f, 0.00114999f, 0.11165854f, -0.01062471f, 
    0.01622414f, 0.04873637f, 0.08783145f, 0.10399111f, -0.13814506f, 0.10568449f, -0.11841796f, 0.13136882f, 
    0.04094646f, -0.02849455f, -0.02569563f, -0.12898700f, 0.13363512f, 0.13591319f, -0.04346034f, -0.09000047f, 
    0.11222503f, 0.12602863f, 0.03904878f, -0.07622559f, -0.00665450f, 0.05803569f, 0.05025139f, 0.02805456f, 
    -0.41931164f, -0.38385633f, 0.03209433f, 0.19451794f, -0.22104658f, -0.08753920f, 0.06180063f, -0.10164278f, 
    -0.04493934f, -0.03364131f, -0.11757410f, -0.09856875f, -0.01303139f, 0.01380561f, -0.00680704f, 0.01586358f, 
    0.17794709f, -0.05432190f, -0.06085129f, -0.02910755f, 0.09056604f, -0.05515403f, 0.26237997f, 0.31977725f, 
    -0.13807476f, 0.08392236f, -0.03222364f, -0.04565893f, -0.11858782f, 0.02933312f, 0.01417072f, -0.14946534f, 
    0.05006329f, -0.11315938f, -0.11574466f, 0.08659763f, -0.02646447f, -0.07330325f, -0.12740812f, -0.22495553f, 
    0.05543460f, 0.04233819f, 0.00496761f, -0.17909825f, -0.22968070f, 0.09945289f, 0.10409020f, 0.07574262f, 
    -0.05361381f, 0.12828691f, 0.04571424f, -0.19577074f, 0.01832661f, -0.07672846f, -0.02944072f, -0.02383647f, 
    -0.01176460f, -0.01553473f, -0.05102885f, -0.08912901f, 0.05934729f, 0.24020062f, -0.17759196f, -0.00176366f, 
    0.09607204f, 0.09913931f, -0.01261464f, -0.06083794f, -0.02917490f, -0.07758953f, 0.05704129f, 0.11932377f, 
    0.20526157f, 0.06286494f, 0.10357662f, 0.13096783f, -0.00969446f, 0.05170878f, 0.07125507f, 0.17429657f, 
    0.10028395f, -0.37805337f, 0.06921892f, 0.43827638f, -0.05832668f, 0.13237694f, 0.10622256f, 0.03822082f, 
    0.07344706f, -0.12746765f, -0.02801504f, 0.06638924f, 0.11416340f, -0.04320188f, 0.02289140f, 0.08480339f, 
    -0.05731137f, 0.07673057f, 0.05953794f, 0.05400669f, 0.08437091f, 0.00777715f, -0.04131977f, 0.06938845f, 
    0.09680489f, 0.03278547f, 0.01407337f, -0.02120130f, -0.10611888f, 0.00800777f, 0.06706765f, -0.05567192f, 
    0.05142101f, -0.02869403f, 0.09979592f, 0.14225200f, -0.04077529f, -0.04281077f, -0.09971475f, -0.13826853f, 
    0.16731781f, -0.09616932f, -0.15477577f, 0.26613727f, -0.02660592f, 0.06163733f, 0.02374990f, 0.09966698f, 
    0.08092982f, 0.14039777f, -0.01035918f, -0.00079209f, 0.10682014f, 0.06269046f, -0.07501180f, -0.00541624f, 
    0.11530060f, -0.03777970f, 0.06604160f, 0.13534343f, -0.13446014f, -0.05626303f, 0.09812310f, -0.27207097f, 
    -0.11602576f, -0.07203796f, 0.24628143f, 0.09700533f, 0.03240425f, 0.17676266f, -0.08990988f, -0.00430740f, 
    0.05813288f, -0.13694368f, 0.04306701f, -0.13334398f, -0.09445507f, 0.07105906f, 0.12748033f, 0.06273624f, 
    -0.39794528f, -0.00240703f, -0.09766530f, -0.22854537f, -0.01949922f, -0.07373461f, -0.06218261f, -0.06983674f, 
    -0.11785989f, -0.08163430f, -0.06881063f, 0.08530609f, -0.09361717f, 0.04484895f, 0.04664721f, 0.08158207f, 
    0.07395320f, 0.20846148f, 0.11893714f, -0.07650400f, 0.27311197f, -0.31331909f, 0.08635891f, 0.38063517f, 
    -0.06289439f, -0.07024915f, 0.09882250f, -0.00069605f, -0.15981632f, -0.04086487f, 0.00869572f, 0.05368761f, 
    -0.03700582f, -0.14275277f, 0.08116041f, -0.07708017f, 0.04712198f, 0.04334631f, -0.05261834f, 0.12576264f, 
    -0.08107638f, -0.22971800f, 0.23924921f, 0.16045131f, -0.08814687f, -0.04504978f, -0.00759190f, 0.06387368f, 
    0.00268642f, -0.01371055f, 0.01191905f, -0.00569469f, -0.08295233f, 0.01424893f, -0.00983767f, -0.02177048f, 
    0.18336479f, 0.07376228f, 0.12951978f, 0.07854806f, 0.11122265f, -0.36344844f, -0.15258916f, 0.32046583f, 
    -0.19640902f, 0.07736642f, -0.00307039f, -0.11928415f, 0.00616553f, 0.21603517f, 0.00327800f, -0.05656940f, 
    -0.03505727f, -0.03722977f, 0.03683281f, -0.10805570f, -0.03210923f, -0.04881184f, -0.00774331f, 0.11306781f, 
    -0.42825815f, 0.42302230f, 0.20449807f, -0.03403774f, 0.07980620f, -0.00522146f, 0.01578748f, -0.27017418f, 
    0.02290226f, 0.19270028f, 0.04016008f, 0.03454150f, 0.09338912f, 0.05223769f, 0.00486863f, -0.17782371f, 
    -0.04942920f, 0.10869173f, 0.01452152f, 0.10502782f, 0.31138569f, -0.08933747f, 0.15593126f, 0.13536786f, 
    0.14433798f, 0.01385365f, -0.00118362f, 0.03558372f, 0.07270324f, -0.01860429f, 0.10236561f, -0.05458785f, 
    -0.02587442f, -0.07501811f, 0.04266618f, 0.04038190f, -0.00376267f, -0.04617592f, 0.11383988f, 0.09335510f, 
    -0.18884164f, 0.17357998f, 0.40611404f, 0.15140484f, -0.17651720f, -0.09529658f, 0.01373968f, 0.13727109f, 
    -0.07153335f, 0.01871823f, -0.14566916f, -0.13550802f, 0.01980438f, 0.11457401f, 0.19050331f, 0.15036397f, 
    0.02495908f, -0.02110241f, -0.05033430f, 0.14845617f, -0.00401879f, -0.24954711f, 0.17664151f, 0.09932210f, 
    -0.01988969f, 0.12405995f, 0.05593726f, 0.13230602f, 0.02062030f, 0.00447041f, -0.00818417f, 0.02329433f, 
    -0.03420727f, 0.09280796f, 0.22846895f, 0.12319798f, 0.08028151f, 0.18456937f, 0.24029405f, 0.31616578f, 
    -0.25108618f, -0.18669349f, -0.12717953f, 0.20893064f, -0.06707807f, -0.05049054f, -0.09551700f, -0.07094677f, 
    0.11919595f, 0.03519640f, -0.04822242f, -0.08644694f, 0.04121895f, -0.14422771f, -0.05690227f, 0.19201073f, 
    0.09698726f, 0.17801791f, 0.10911345f, 0.16488907f, -0.12739718f, -0.13764800f, 0.24318098f, 0.29109949f, 
    0.01190512f, -0.10656673f, -0.26021814f, -0.17412904f, 0.10353621f, -0.11577396f, -0.01905541f, 0.07167400f, 
    -0.00466864f, -0.00224396f, 0.09224497f, -0.00829285f, -0.28958619f, -0.06481881f, 0.03526838f, -0.35748327f, 
    0.12471433f, -0.06307764f, 0.12792219f, -0.24566828f, -0.07094019f, -0.06884740f, -0.04837595f, 0.05223059f, 
    0.04173319f, -0.13447620f, -0.02056961f, 0.03939355f, -0.02325075f, 0.00388946f, -0.18642029f, -0.11969560f, 
    -0.14552160f, -0.15673177f, -0.02551309f, 0.03510925f, 0.27195588f, 0.13422547f, 0.17996016f, -0.08253349f, 
    0.28424427f, 0.04602427f, -0.00320207f, 0.07346737f, 0.02158989f, -0.06146843f, 0.05142881f, 0.21471962f, 
    -0.05104123f, 0.15733801f, 0.23259132f, 0.06395951f, 0.06220322f, -0.02910042f, 0.01273366f, -0.09735211f, 
    0.00783266f, -0.17279153f, -0.41213802f, -0.04987014f, 0.10302713f, -0.11373106f, -0.14003208f, -0.02507596f, 
    -0.00645768f, 0.15678468f, 0.05094809f, 0.01646934f, -0.01789781f, 0.11506291f, -0.13054134f, 0.05469305f, 
    -0.05384955f, -0.04005390f, 0.09062961f, 0.06251524f, -0.00501624f, 0.22560608f, 0.08086834f, -0.06649099f, 
    0.06714927f, -0.01212802f, 0.05457992f, 0.05541548f, -0.01288165f, -0.02802016f, 0.05577181f, 0.04001216f, 
    -0.03368830f, 0.13548341f, -0.04596581f, 0.07573586f, -0.10342006f, -0.14667231f, -0.19158146f, -0.02661834f, 
    0.20128122f, -0.10222746f, -0.25383595f, 0.08684950f, 0.03920916f, 0.08317943f, 0.01017937f, 0.09043302f, 
    -0.01056334f, 0.06408326f, -0.08998829f, -0.09317034f, 0.02206914f, 0.13155594f, 0.04230387f, 0.04295877f, 
    0.34489766f, 0.08817529f, 0.22530924f, 0.22405329f, 0.21025673f, 0.15571539f, 0.30332217f, -0.23133458f, 
    0.23412469f, 0.07032438f, -0.24202037f, -0.07815190f, -0.09420274f, 0.10782259f, -0.07752194f, 0.21236293f, 
    0.02530086f, -0.05856330f, -0.02611568f, 0.17647621f, 0.14924359f, 0.10095332f, -0.01203665f, -0.12551497f, 
    0.07063435f, -0.14980899f, -0.03780441f, -0.13599096f, -0.26636285f, -0.07084101f, -0.03247138f, 0.22113909f, 
    0.01540213f, -0.01769687f, 0.06583320f, 0.13250987f, 0.37677214f, 0.01923421f, -0.01264163f, 0.14069720f, 
    -0.06432017f, -0.17632382f, -0.09997402f, -0.02231085f, -0.19998087f, -0.37373453f, -0.04766174f, 0.18299064f, 
    0.03580491f, 0.06454629f, 0.01832023f, -0.10488778f, 0.07553625f, 0.02596112f, -0.02762380f, -0.04641356f, 
    -0.02832374f, -0.12000221f, -0.15914105f, -0.08559718f, -0.32390010f, -0.08335540f, 0.02521655f, -0.17119913f, 
    -0.20646581f, -0.26066414f, -0.28938860f, 0.03764537f, -0.07240503f, 0.03206228f, 0.01975492f, -0.01453674f, 
    0.02559870f, 0.05674466f, -0.06562620f, -0.01967994f, 0.03220746f, -0.02912382f, -0.03216060f, 0.16062027f, 
    0.07524806f, 0.11787644f, 0.07055966f, 0.24116701f, 0.03295428f, 0.05441701f, -0.42249140f, 0.23994066f, 
    0.08100670f, -0.24413908f, -0.04082873f, 0.04491612f, -0.07516835f, -0.02627094f, -0.00986516f, -0.02378553f, 
    0.00458890f, 0.04119579f, -0.25749809f, 0.00134035f, 0.00887881f, 0.15123415f, -0.16606176f, -0.04051057f, 
    0.15617183f, 0.19961101f, 0.73596960f, 0.22975640f, 0.12464029f, -0.05829440f, -0.18056190f, 0.03727368f, 
    -0.05899897f, -0.24414758f, 0.07670688f, 0.05580788f, 0.16258997f, 0.14095509f, 0.18937890f, 0.01063592f, 
    -0.21397234f, 0.01099250f, 0.13075770f, -0.05154726f, -0.50425136f, -0.12914696f, -0.38798240f, 0.16448820f, 
    -0.19310056f, -0.03505735f, -0.10944565f, 0.15305004f, -0.01242285f, -0.20728675f, 0.07293762f, -0.11581741f, 
    -0.05465851f, -0.04481482f, -0.06422158f, 0.18837279f, 0.08452230f, 0.17164047f, 0.17347170f, 0.08611643f, 
    -0.29006112f, 0.09167036f, -0.03712591f, 0.15925212f, 0.10086793f, 0.04329808f, 0.26930031f, -0.06320640f, 
    0.02327779f, 0.15610147f, 0.07059599f, -0.02773739f, 0.09305884f, -0.03911737f, 0.13820496f, -0.06874696f, 
    -0.08496213f, -0.01745948f, 0.01193427f, 0.03502646f, -0.14925654f, -0.05028204f, 0.14958605f, -0.19159801f, 
    0.18062636f, -0.01829582f, 0.08722594f, 0.03253201f, 0.12464006f, 0.06183044f, 0.06454671f, 0.01521586f, 
    0.02407915f, 0.10392877f, 0.00574161f, 0.02038938f, -0.04498628f, -0.04995306f, 0.05034089f, -0.00504950f, 
    -0.21426103f, -0.24675708f, -0.04526354f, 0.02647923f, -0.20260049f, 0.02147864f, -0.02948933f, -0.03137394f, 
    -0.01853296f, -0.10563524f, -0.02408950f, -0.08902410f, 0.02042774f, -0.00862074f, -0.00928783f, 0.08375659f, 
    -0.14168008f, -0.04085842f, -0.07802952f, -0.18934318f, 0.12100221f, -0.07528888f, -0.32074800f, 0.14755298f, 
    -0.14615116f, -0.19957446f, 0.01603515f, 0.06094130f, 0.04814680f, 0.10053261f, -0.04777754f, -0.10209341f, 
    -0.07405428f, -0.10821243f, -0.10268525f, 0.09567866f, 0.05895438f, 0.06580529f, -0.11159675f, -0.13390824f, 
    0.15585327f, 0.14228003f, 0.38753802f, -0.12894346f, -0.18007627f, -0.01627400f, -0.28912866f, -0.28504813f, 
    -0.08467641f, -0.04621363f, -0.16221587f, -0.01657227f, -0.02997340f, 0.06605802f, -0.12079745f, -0.02953568f, 
    -0.08637623f, 0.09262510f, -0.11658325f, 0.10363311f, 0.28431746f, -0.05646818f, 0.15873864f, 0.02244149f, 
    0.13084801f, 0.05080173f, 0.08524127f, -0.02242572f, 0.20750923f, 0.02569456f, -0.05686768f, 0.09317207f, 
    0.04060088f, 0.01815753f, 0.07363129f, -0.09540017f, 0.02684725f, 0.09073278f, 0.03151670f, 0.12579738f, 
    0.18874313f, -0.32870263f, -0.00492343f, 0.23256291f, -0.04775685f, 0.14430499f, 0.14327326f, 0.11464863f, 
    0.26897743f, -0.02273142f, -0.01336146f, 0.14065424f, 0.03386676f, 0.05809438f, 0.12207841f, -0.04218547f, 
    -0.09077094f, -0.00958079f, 0.16833566f, 0.05989784f, 0.10084388f, 0.20067592f, 0.05052179f, 0.21575387f, 
    -0.01177026f, -0.01013409f, 0.03227811f, -0.16236556f, 0.16577473f, 0.02095129f, -0.10081613f, 0.00590128f, 
    -0.01801991f, 0.01335906f, 0.09793911f, 0.05112415f, 0.06169687f, 0.10394291f, -0.04479531f, -0.01153852f, 
    0.16547747f, -0.09191254f, 0.30541176f, 0.06770696f, 0.06485727f, 0.08239532f, 0.06098773f, 0.00149253f, 
    0.17313565f, 0.07611586f, -0.02931184f, 0.03174335f, 0.02998603f, -0.07362666f, -0.04876081f, 0.10932020f, 
    0.03690491f, -0.14539127f, 0.13865136f, 0.01236848f, 0.38031650f, 0.11060392f, 0.39337650f, -0.03718623f, 
    0.06171767f, -0.07997552f, 0.02942755f, -0.04781504f, 0.11620372f, -0.13852456f, -0.04918374f, 0.05166442f, 
    0.00602431f, -0.02048677f, -0.07001106f, -0.10562915f, 0.07545899f, 0.04494313f, 0.11235984f, 0.08600862f, 
    -0.16960230f, -0.11263176f, -0.11632958f, 0.13746619f, -0.13783054f, -0.05733167f, -0.06455625f, -0.21404859f, 
    -0.15190326f, -0.20030639f, -0.08221772f, -0.05629462f, -0.14302379f, 0.00868557f, -0.02277288f, 0.00245385f, 
    -0.00908883f, 0.12574261f, 0.03573928f, -0.13703576f, -0.26460457f, -0.34190845f, 0.03731924f, -0.11728956f, 
    -0.12796640f, 0.08751432f, -0.12263539f, 0.07819422f, -0.09929641f, -0.04835863f, 0.05425822f, 0.02009744f, 
    0.20226605f, 0.10597380f, 0.09658627f, 0.02735301f, 0.00797637f, -0.00874560f, 0.11911159f, 0.23063464f, 
    -0.03410818f, -0.15571751f, 0.11941578f, -0.11098424f, -0.18396112f, 0.01766680f, -0.18451366f, 0.05500096f, 
    0.01996131f, -0.20109378f, 0.01389236f, -0.04694971f, -0.05808608f, -0.04974453f, 0.07259764f, 0.05635897f, 
    -0.04829336f, -0.08618058f, -0.08333025f, -0.07759329f, 0.38672984f, -0.28478006f, 0.27801427f, -0.03541451f, 
    -0.16820548f, 0.10204344f, 0.19637991f, -0.27588859f, 0.08780923f, 0.10021637f, 0.11894092f, -0.01494919f, 
    0.08023889f, -0.04534857f, -0.06731153f, 0.10965140f, 0.13016315f, -0.03786097f, -0.01394198f, 0.07359147f, 
    -0.39247164f, -0.12089715f, -0.17917611f, -0.34892562f, 0.06599324f, -0.26198015f, -0.04640406f, -0.10349414f, 
    0.11474326f, 0.18755293f, 0.03267458f, -0.00834181f, -0.01380242f, 0.04496804f, -0.05721752f, -0.10355917f, 
    0.00410530f, 0.25974858f, -0.00207048f, 0.00855485f, 0.06070192f, 0.13057554f, 0.10976152f, 0.20607880f, 
    -0.09362715f, 0.04255103f, -0.00962414f, -0.15998237f, 0.01812476f, -0.06772802f, -0.04979545f, -0.02550710f, 
    0.06307492f, -0.06521560f, -0.02613080f, 0.18725602f, -0.07699981f, -0.11859662f, 0.15364389f, 0.09557369f, 
    0.32863098f, 0.21566895f, 0.15301484f, 0.23524232f, -0.20784809f, -0.07186349f, 0.18849611f, -0.02023719f, 
    0.03375417f, 0.02887560f, 0.05159191f, -0.13563612f, -0.00779276f, 0.05615809f, -0.17831917f, -0.00480725f, 
    0.03305840f, -0.18379481f, -0.01747931f, -0.07796219f, -0.18674694f, 0.16936421f, 0.39348501f, 0.11226019f, 
    -0.02554603f, 0.03085231f, 0.04527522f, 0.03896534f, -0.12204284f, -0.00876850f, 0.07387506f, 0.10339903f, 
    -0.11644601f, -0.14034289f, -0.02884488f, 0.10418850f, -0.13154085f, -0.02760757f, -0.08244676f, -0.10203913f, 
    0.40594044f, 0.11263742f, 0.31691307f, 0.24696070f, 0.11907609f, 0.02671736f, -0.02904788f, 0.09031065f, 
    -0.06452372f, -0.07712263f, 0.13344392f, -0.01761504f, 0.04889582f, -0.10862802f, -0.10032645f, -0.02562052f, 
    -0.04363080f, -0.14483623f, -0.05454399f, -0.15480497f, 0.18264213f, 0.21817727f, 0.14192836f, 0.05322811f, 
    0.04649073f, -0.28199726f, -0.05281709f, -0.03040993f, 0.04749835f, 0.08167715f, 0.08431943f, 0.09502722f, 
    0.12807409f, -0.02522046f, -0.02731225f, -0.10983966f, -0.07905952f, 0.06402966f, 0.05774882f, -0.03206984f, 
    -0.38312221f, -0.31307471f, -0.27287745f, 0.01407508f, -0.22779673f, -0.05588058f, 0.04203494f, 0.12573512f, 
    -0.01703996f, 0.03745557f, -0.14647317f, 0.08550343f, 0.02610378f, 0.03942055f, -0.02474676f, 0.01549298f, 
    -0.07523504f, -0.15493043f, 0.05032529f, 0.11464364f, 0.12101860f, -0.31267154f, -0.02983079f, -0.11587338f, 
    -0.07993115f, -0.02398703f, 0.05490909f, 0.01592841f, 0.18543583f, -0.09141354f, 0.04563926f, -0.10752658f, 
    -0.10212752f, -0.18537168f, 0.06093227f, -0.10213155f, 0.05303471f, -0.02762480f, 0.03822899f, -0.01192829f, 
    -0.13634147f, 0.21923937f, 0.26512715f, 0.07667118f, 0.21065672f, -0.07233451f, 0.01422890f, 0.05592235f, 
    0.02182392f, 0.07809363f, 0.07373466f, 0.12411971f, 0.04011586f, 0.01324689f, -0.01762944f, 0.06801982f, 
    -0.00529639f, -0.09134675f, -0.05480879f, -0.06497958f, -0.07040861f, -0.07412883f, -0.02517908f, -0.46020848f, 
    -0.11782350f, -0.13480113f, 0.01655852f, 0.14761108f, 0.14344226f, 0.06656393f, -0.05376796f, -0.03222724f, 
    0.09267094f, -0.04503291f, 0.03374541f, -0.16705136f, -0.07965387f, 0.07696406f, 0.18219158f, 0.21967801f, 
    -0.37364763f, 0.03360001f, 0.04950592f, 0.18370394f, 0.03622102f, 0.17251509f, 0.10356662f, -0.10151647f, 
    -0.13953412f, -0.00032763f, 0.07955503f, 0.11182684f, -0.07806160f, -0.00178221f, -0.06433920f, 0.07516088f, 
    0.05622225f, 0.02316460f, -0.02651169f, -0.06094404f, 0.00105584f, -0.17635362f, -0.56200570f, -0.18590866f, 
    -0.38405991f, -0.06704772f, 0.09592681f, 0.02630598f, 0.00644793f, -0.06271880f, -0.16039351f, 0.05017183f, 
    0.06507036f, -0.02906773f, -0.01735324f, 0.01836653f, 0.00020032f, -0.07262599f, 0.07510851f, 0.02385219f, 
    0.29281077f, -0.01693690f, -0.20892011f, -0.05367365f, -0.31475386f, -0.21263406f, -0.11440841f, -0.06034473f, 
    -0.07507902f, -0.09728865f, -0.08710677f, 0.11575514f, -0.00636160f, 0.07745442f, -0.02025379f, 0.04983462f, 
    0.02889034f, 0.04296951f, 0.05678189f, 0.08904237f, -0.23897791f, 0.21432027f, 0.18765160f, -0.17202757f, 
    0.11207440f, -0.06700051f, -0.12039386f, 0.00237919f, 0.06873524f, -0.05101410f, -0.05843137f, 0.03007527f, 
    0.14283976f, 0.04608620f, -0.02006330f, -0.05930538f, 0.01361541f, -0.01812359f, 0.19361596f, 0.02563543f, 
    0.02202850f, -0.11412172f, 0.06894239f, 0.20585574f, -0.05264269f, 0.10976807f, -0.05454100f, -0.08152104f, 
    0.03425581f, 0.01150674f, 0.12717691f, 0.07378783f, 0.00453042f, -0.06463819f, 0.10381979f, 0.08557668f, 
    0.00460920f, -0.15761867f, -0.20488448f, -0.04164774f, -0.21399236f, 0.21477184f, 0.30234811f, 0.25174990f, 
    0.35821906f, -0.02473192f, 0.10368948f, 0.18008257f, -0.03017988f, 0.03432734f, 0.30179617f, -0.00026359f, 
    0.12666716f, -0.13441527f, -0.02213592f, -0.01100896f, 0.21663044f, 0.04992128f, -0.15369555f, -0.02213934f, 
    -0.03309870f, -0.04427220f, 0.06295450f, 0.11522239f, -0.13104117f, -0.15419722f, -0.09208981f, 0.13199322f, 
    -0.02965481f, -0.01425982f, 0.14069080f, 0.08301464f, -0.07253811f, -0.11195804f, 0.05928547f, 0.05624364f, 
    -0.03388417f, 0.00819724f, -0.10291561f, 0.04106322f, 0.01347680f, 0.12344031f, 0.25396308f, -0.16985014f, 
    -0.09675733f, 0.10076771f, 0.03223700f, -0.02780733f, 0.14150931f, -0.11972890f, 0.08991879f, 0.04010823f, 
    0.06347268f, 0.05232874f, 0.03529777f, 0.02434167f, 0.09330335f, -0.04552961f, -0.04025635f, -0.10982113f, 
    0.01079345f, -0.04267469f, -0.03822727f, 0.01624415f, -0.00345441f, 0.04018820f, -0.01043709f, 0.02412367f, 
    -0.01171077f, 0.01568575f, 0.00495502f, -0.01027695f, 0.03951501f, -0.00368636f, 0.01988543f, -0.03455927f, 
    0.00392835f, 0.01325546f, -0.05955458f, 0.01952017f, 0.04132742f, 0.00172459f, -0.02276798f, -0.02494084f, 
    -0.00419419f, -0.04308984f, 0.04280822f, 0.03080739f, 0.00470203f, -0.04922176f, 0.01262010f, -0.03059467f, 
    -0.02501194f, -0.05581057f, -0.02596657f, -0.01071432f, 0.04162437f, -0.01820387f, -0.04917286f, -0.01115009f, 
    -0.03311713f, 0.01768356f, 0.04364801f, 0.02944147f, 0.00484552f, -0.04123838f, -0.04422180f, 0.03232312f, 
    0.01982962f, 0.02482064f, -0.04306373f, -0.03232679f, -0.00190278f, 0.01385933f, -0.02789861f, -0.03914443f, 
    0.04050532f, -0.03655000f, -0.03640011f, 0.04761552f, 0.03185018f, -0.01865697f, -0.01288561f, -0.03264377f, 
    -0.03145597f, 0.03387788f, -0.01114789f, -0.03941700f, 0.04496135f, -0.02816462f, -0.00012834f, -0.04397746f, 
    0.00076527f, -0.00478916f, -0.00226494f, -0.03508323f, -0.05574311f, 0.02878088f, -0.00726149f, 0.01326566f, 
    -0.05503153f, 0.03197424f, -0.03132288f, -0.04156257f, -0.01935173f, 0.01786861f, -0.03282618f, 0.02087669f, 
    0.01461352f, -0.03498652f, -0.01580228f, -0.02489435f, 0.01716590f, -0.03955531f, -0.02766748f, 0.01242845f, 
    0.03396595f, -0.01692178f, 0.04127990f, 0.04313285f, -0.04780409f, 0.03649535f, -0.01363199f, -0.03882279f, 
    0.01843035f, 0.04018650f, -0.04758125f, -0.04039098f, 0.00521206f, -0.04854365f, -0.03955676f, 0.00485017f, 
    -0.04661102f, -0.01426500f, 0.02229004f, -0.04929349f, -0.01082965f, -0.03602329f, -0.03177234f, -0.00157017f, 
    -0.04308370f, -0.05459096f, 0.04863413f, -0.00368310f, 0.04729473f, -0.01143137f, 0.02747954f, -0.00914215f, 
    -0.05521480f, 0.00546387f, 0.02106774f, -0.02518212f, 0.03530309f, -0.05343952f, -0.04600487f, -0.06133995f, 
    0.00499751f, -0.01141203f, 0.04309281f, -0.02458167f, -0.01234219f, 0.04226191f, -0.00017782f, 0.03604802f, 
    -0.01821611f, 0.02172429f, 0.04454760f, -0.03002282f, -0.01913871f, -0.03891398f, 0.01533132f, -0.05145739f, 
    -0.02459608f, -0.04673770f, -0.04438309f, 0.00554208f, -0.04007947f, 0.02458248f, 0.02274587f, -0.05050872f, 
    0.00050762f, -0.00780026f, -0.02388968f, -0.04479317f, -0.06129406f, -0.00028655f, 0.00862419f, 0.02177700f, 
    -0.04569535f, -0.04508958f, -0.02910986f, -0.00180370f, -0.05078691f, -0.01843997f, -0.04404793f, 0.02531257f, 
    -0.05345101f, 0.02514156f, 0.04901942f, -0.01789317f, 0.01024437f, -0.04655759f, -0.01481787f, -0.00028613f, 
    -0.04593425f, 0.01502011f, -0.03345827f, 0.04423789f, -0.00191207f, 0.01663961f, -0.04995877f, -0.05051164f, 
    0.02476078f, 0.04371155f, -0.04837610f, -0.03882668f, 0.03860467f, 0.00677299f, 0.02480029f, 0.03615756f, 
    -0.01606066f, 0.01985583f, -0.03693231f, 0.00504346f, -0.01425174f, 0.00329411f, 0.05499963f, -0.04771025f, 
    0.01771975f, -0.00038980f, 0.04320612f, -0.05934436f, -0.02469975f, 0.00842191f, -0.03977655f, -0.06077540f, 
    -0.04114982f, 0.02166293f, 0.02309724f, -0.02544982f, -0.02750448f, -0.03571031f, -0.00095636f, 0.01225058f, 
    -0.04295413f, 0.03292940f, 0.00781011f, -0.00031057f, -0.04180161f, 0.04127398f, 0.01537373f, -0.02453017f, 
    -0.04617284f, -0.01816843f, -0.00166417f, 0.00408081f, -0.01024122f, -0.02845898f, -0.05187126f, 0.04738918f, 
    0.04202976f, 0.03554158f, -0.03225864f, 0.04801920f, 0.03563907f, 0.02976102f, -0.02764199f, -0.00890986f, 
    -0.03869697f, -0.03107208f, -0.00831259f, -0.05405739f, 0.01258732f, -0.00147035f, 0.00579406f, -0.02994406f, 
    -0.02164158f, -0.04608733f, -0.00805079f, -0.04312315f, -0.05592612f, -0.04568518f, -0.05012602f, 0.00494240f, 
    0.04897821f, 0.04556986f, -0.00583559f, -0.01829817f, 0.03740011f, 0.05275956f, 0.04177434f, -0.01158092f, 
    0.03116051f, 0.03158657f, 0.04537330f, -0.02759049f, -0.03780542f, 0.00719941f, 0.01432079f, 0.01981312f, 
    0.04528253f, 0.00848799f, 0.01105482f, 0.01299607f, -0.00667031f, -0.02861668f, -0.02131331f, 0.02194350f, 
    -0.03397362f, 0.02194899f, -0.05922322f, -0.01421153f, -0.01835914f, 0.02536332f, -0.04420248f, -0.02508051f, 
    -0.03228761f, 0.02115743f, -0.04235203f, -0.05269570f, 0.02871960f, -0.02489782f, -0.06026630f, 0.03887420f, 
    -0.04771640f, -0.00895592f, 0.04238212f, 0.00198126f, 0.04745139f, -0.02477260f, -0.00581286f, -0.02497858f, 
    0.04271581f, 0.03852358f, 0.03993921f, -0.05249748f, -0.04283340f, 0.04125510f, 0.04616612f, 0.03157604f, 
    -0.18705581f, 0.22220045f, -0.24643961f, 0.15677321f, 0.24031462f, -0.01410136f, 0.09134827f, 0.32345071f, 
    -0.07063538f, 0.09956991f, -0.01721578f, 0.05732549f, -0.02298584f, 0.06687677f, 0.14280255f, 0.03564601f, 
    -0.02031279f, 0.19427165f, 0.05491843f, 0.03733117f, 0.35655355f, -0.31945574f, -0.32131654f, -0.21611455f, 
    0.00116133f, 0.03338186f, 0.02145981f, 0.08149014f, 0.10431673f, 0.11340646f, -0.00746911f, -0.02960849f, 
    -0.14130414f, 0.03165255f, -0.02030956f, -0.05198059f, -0.06887808f, 0.03440186f, 0.19277014f, 0.09840980f, 
    -0.09756869f, 0.04781796f, 0.01812187f, -0.30039603f, 0.29724249f, 0.19009122f, 0.07185670f, -0.00144348f, 
    0.26141095f, 0.12776794f, -0.14192635f, -0.01042746f, -0.12411243f, 0.00359950f, 0.11819696f, -0.03051330f, 
    -0.03664888f, 0.15195920f, 0.29301423f, 0.08923282f, -0.12612434f, -0.16788605f, -0.21090201f, -0.27272037f, 
    -0.00828265f, 0.16317593f, 0.10827249f, -0.01573770f, 0.05898417f, -0.02201173f, -0.02301259f, 0.21801916f, 
    0.05904561f, 0.09144408f, 0.16628005f, -0.03188887f, 0.06006977f, -0.09626310f, -0.02846377f, -0.09736613f, 
    0.20306891f, 0.10791992f, 0.12319393f, -0.04702757f, 0.02704646f, 0.03187651f, 0.03975403f, -0.09439637f, 
    -0.00972649f, 0.06796522f, 0.11333837f, 0.10493884f, 0.00253373f, -0.03080855f, 0.09669952f, -0.08961665f, 
    -0.06780807f, 0.20954731f, 0.04450474f, -0.05496684f, 0.21151976f, 0.18764806f, -0.05448371f, -0.02427080f, 
    -0.16880099f, -0.03865498f, 0.09543646f, 0.04505340f, -0.12898266f, -0.06151979f, -0.11074112f, -0.08668556f, 
    -0.10826015f, 0.08733649f, -0.11269564f, -0.05354038f, -0.14983185f, 0.01596751f, -0.22482793f, -0.12069459f, 
    -0.08548786f, -0.10533357f, -0.26253524f, -0.06078656f, 0.21214674f, -0.07619428f, 0.00574233f, 0.08365081f, 
    -0.06317376f, 0.00290288f, 0.19614106f, 0.01361637f, 0.02543618f, -0.08666751f, 0.06217687f, -0.06362103f, 
    0.03100011f, 0.09970082f, -0.01855048f, 0.07639115f, 0.12606032f, 0.10110985f, 0.06027323f, 0.06129401f, 
    0.00168253f, 0.03562393f, -0.07821808f, -0.04183595f, 0.03311249f, 0.06174590f, 0.00187333f, 0.06798690f, 
    -0.04988944f, 0.02431046f, 0.01918239f, -0.04577793f, 0.04926918f, -0.05100759f, -0.00624235f, -0.07885735f, 
    0.22775611f, 0.01338729f, 0.13846730f, -0.07548341f, -0.01701994f, -0.13078700f, 0.18016741f, -0.16652864f, 
    0.09764769f, 0.01400891f, -0.03060826f, -0.02197150f, -0.08625933f, -0.01065088f, 0.08940699f, -0.02103045f, 
    0.01664958f, -0.06015522f, 0.00598474f, -0.08248422f, 0.18582883f, 0.24450178f, 0.20143464f, 0.14689443f, 
    0.09951403f, -0.05623880f, -0.09437366f, -0.05875584f, 0.02940961f, -0.04625336f, 0.08302407f, 0.12726760f, 
    0.04945097f, 0.04621883f, -0.03703491f, -0.04613006f, -0.06827606f, 0.17473160f, -0.07215194f, -0.03717453f, 
    0.13019402f, 0.16007434f, 0.10715605f, 0.18050635f, -0.01988800f, 0.10420648f, 0.09363827f, 0.00439976f, 
    -0.01465493f, -0.01207233f, 0.07225587f, -0.04465801f, 0.05565126f, -0.10930315f, -0.06266774f, 0.01868450f, 
    -0.00764262f, -0.27297890f, -0.15174283f, -0.03818334f, -0.50613511f, -0.29344568f, 0.09943242f, 0.12303094f, 
    0.30469358f, 0.12600698f, 0.07575210f, -0.01007948f, 0.03199612f, -0.04637313f, 0.12936865f, 0.07630595f, 
    -0.07152552f, 0.01476834f, 0.07374910f, -0.01310524f, -0.04826046f, -0.06777982f, -0.16309673f, -0.00414950f, 
    0.11907569f, 0.05660738f, 0.09921955f, 0.05563134f, 0.19486243f, -0.00648959f, 0.09706254f, -0.00040288f, 
    0.11484741f, 0.08734950f, -0.11499207f, -0.09478300f, -0.10558957f, 0.04976632f, -0.03374752f, -0.04089567f, 
    -0.11217582f, -0.00987877f, 0.11536440f, 0.03147495f, 0.53697097f, -0.06873854f, -0.22493264f, -0.25433645f, 
    0.05195609f, 0.15612198f, 0.09744217f, -0.03723233f, 0.11485039f, -0.11078139f, 0.06191581f, 0.06717262f, 
    -0.02821879f, 0.03108902f, 0.02202514f, -0.04790064f, -0.11636171f, -0.01161592f, -0.02901426f, -0.15094621f, 
    0.47206348f, 0.02056414f, -0.45233947f, -0.31890282f, -0.07186519f, 0.04386163f, -0.09584045f, 0.00565958f, 
    -0.20406517f, -0.11105286f, -0.20606641f, -0.01821571f, -0.06706327f, 0.14625689f, 0.04238491f, 0.06029313f, 
    -0.00084167f, -0.10810218f, 0.08576892f, 0.02164378f, -0.31120375f, 0.07108843f, -0.14709054f, 0.37057269f, 
    0.18948381f, -0.00248397f, 0.16721554f, 0.14047074f, -0.07876466f, 0.07628845f, -0.08524612f, 0.01403683f, 
    -0.09555349f, 0.07705835f, -0.04831543f, -0.01858034f, 0.13483620f, 0.15500931f, -0.03149471f, -0.04707631f, 
    0.32687941f, -0.12931424f, -0.24607447f, 0.01346128f, 0.23115602f, -0.03639730f, -0.07634988f, 0.08619044f, 
    -0.00602627f, -0.03827661f, -0.01346635f, 0.01433294f, 0.07824478f, -0.01590180f, 0.00426568f, -0.02751404f, 
    0.02195194f, 0.02005692f, 0.04958952f, 0.10527888f, 0.52906716f, -0.04075342f, -0.14072822f, -0.14485082f, 
    0.11781932f, 0.13521312f, 0.09612789f, 0.02865260f, 0.04764276f, -0.09120145f, -0.08909188f, -0.09984757f, 
    0.08926870f, 0.11749316f, 0.03530949f, 0.11987461f, 0.15389287f, -0.01032195f, -0.10269012f, 0.01057419f, 
    0.12865585f, 0.22267351f, -0.24962200f, -0.35947174f, 0.14418919f, 0.14679945f, -0.10542678f, 0.17842686f, 
    0.01526681f, 0.07183895f, -0.16545884f, -0.04080806f, -0.08272527f, 0.14873695f, 0.17190002f, 0.19361743f, 
    -0.11031972f, 0.16895600f, -0.02981947f, -0.08224429f, -0.31219944f, -0.24318264f, -0.39566520f, 0.00432640f, 
    -0.01627675f, -0.00923107f, 0.06982743f, 0.19215485f, 0.10797416f, 0.16448429f, -0.10033399f, -0.05907036f, 
    -0.10104194f, -0.21794541f, -0.22088367f, -0.21197812f, 0.01594932f, 0.12454850f, 0.10691952f, -0.00179979f, 
    0.15866202f, 0.15249859f, 0.27397108f, 0.05487716f, -0.17601539f, -0.04151092f, -0.01212390f, 0.07838833f, 
    0.00454274f, -0.07523610f, -0.04482459f, 0.05857952f, 0.02565234f, -0.04489413f, 0.09398633f, 0.07353213f, 
    0.23792592f, 0.11969537f, -0.03641041f, -0.04725160f, -0.21281728f, 0.02923393f, 0.22323687f, -0.00492997f, 
    -0.00266725f, -0.07647142f, 0.05597197f, -0.05267181f, 0.11595354f, 0.19119473f, -0.00311829f, 0.19856803f, 
    -0.00693625f, 0.27086380f, -0.02348931f, -0.09373677f, 0.06275461f, -0.00916494f, -0.04058969f, 0.00164268f, 
    0.29929841f, 0.30521592f, -0.20980039f, -0.06076599f, -0.08920352f, -0.02639511f, 0.03146705f, 0.01090156f, 
    0.11424315f, -0.07283134f, 0.14932466f, -0.03291816f, 0.00092287f, -0.01096328f, 0.07797257f, 0.01900554f, 
    0.06529899f, 0.15161446f, 0.24722911f, 0.14833228f, 0.16828713f, 0.11245575f, 0.09016457f, 0.24887767f, 
    -0.20883971f, 0.04838726f, -0.01217454f, -0.08664339f, 0.06564262f, 0.00496172f, -0.05606546f, 0.08049838f, 
    -0.04354687f, 0.13883434f, -0.02981119f, -0.03068518f, 0.17533715f, 0.08116423f, -0.07048375f, -0.00032881f, 
    0.40466166f, -0.01697748f, 0.35277113f, -0.29381633f, 0.16171718f, 0.02795413f, -0.14912792f, 0.07368556f, 
    0.06718073f, -0.08899128f, 0.02575604f, 0.02230694f, 0.01794951f, -0.07197955f, 0.00024372f, 0.01966376f, 
    -0.10906456f, -0.02798580f, -0.11910731f, -0.22873412f, -0.16009958f, 0.10048088f, 0.37393716f, 0.12495006f, 
    -0.16189945f, -0.01083627f, -0.01060023f, 0.02518489f, 0.16915587f, -0.00430615f, 0.06540737f, 0.01798422f, 
    -0.16670419f, 0.12089043f, -0.00547694f, 0.14606497f, 0.21090597f, -0.10604350f, -0.14818963f, -0.02021873f, 
    -0.34404764f, -0.02746392f, 0.09920893f, 0.07746202f, 0.06256569f, -0.02474807f, 0.03531542f, 0.03217374f, 
    0.02549369f, -0.06647690f, 0.01261047f, -0.12277753f, 0.19901821f, 0.11914814f, 0.22882256f, -0.07699344f, 
    -0.04496655f, 0.04140534f, -0.18088827f, -0.11628220f, 0.41452518f, 0.13943343f, -0.11457452f, 0.16386753f, 
    0.00021307f, 0.01713428f, -0.11581799f, 0.12557906f, 0.03804172f, -0.04962364f, 0.17180489f, 0.06171646f, 
    -0.00505776f, -0.04417711f, 0.02291773f, -0.14967559f, -0.16087534f, 0.01975640f, 0.06875849f, 0.16099563f, 
    0.23809074f, 0.24891201f, -0.10773256f, -0.24173251f, 0.18549439f, -0.14973813f, -0.15957788f, 0.09710505f, 
    -0.10873639f, -0.06804162f, 0.00744493f, 0.00469353f, 0.05148329f, 0.00716392f, 0.02445514f, 0.12852964f, 
    -0.14549235f, 0.09965025f, -0.00281370f, -0.21951148f, 0.02568645f, -0.06573228f, -0.17634791f, -0.51407856f, 
    -0.00532220f, 0.19009966f, -0.00312746f, -0.05038374f, 0.02433319f, -0.02798770f, -0.07393885f, -0.15273456f, 
    0.09031543f, -0.00941963f, -0.02983891f, 0.06471334f, -0.00444860f, -0.02305452f, 0.10028006f, 0.04997366f, 
    -0.12272873f, -0.24186556f, -0.41214034f, -0.19602819f, -0.00178248f, 0.12889209f, 0.21620400f, 0.07851394f, 
    0.22204706f, 0.02933249f, 0.00209985f, -0.01887441f, 0.10954437f, -0.01699187f, -0.12500031f, -0.14528534f, 
    -0.08899401f, -0.11794875f, -0.06667508f, -0.05806345f, 0.08995521f, 0.00610626f, -0.26977065f, 0.08518415f, 
    0.10387674f, -0.06206694f, -0.22483243f, 0.12150662f, -0.00677759f, -0.02869778f, 0.01541304f, 0.12210978f, 
    0.01200703f, -0.06995237f, -0.06284482f, 0.04508148f, -0.06464186f, 0.10650580f, -0.01338715f, 0.00059716f, 
    -0.05518449f, -0.03154819f, -0.02629448f, -0.02957869f, -0.02504240f, 0.00006928f, -0.04544257f, -0.01962189f, 
    0.01414246f, -0.04446742f, 0.01035585f, -0.05621683f, 0.05140963f, -0.01953960f, 0.00520038f, 0.04684308f, 
    -0.04888671f, 0.02109238f, 0.02156245f, -0.00529670f, -0.01350032f, 0.00084275f, 0.00857743f, 0.04774607f, 
    -0.01398387f, -0.03920716f, 0.03356052f, 0.03238688f, 0.02131664f, 0.00948702f, 0.01249178f, 0.00760243f, 
    0.01717242f, 0.00994192f, 0.01746001f, 0.02422272f, -0.03849527f, -0.02296701f, 0.00612110f, -0.05753354f, 
    0.03751865f, -0.02875799f, 0.04666667f, -0.05534801f, 0.01528133f, -0.07414225f, 0.04392677f, 0.00826194f, 
    0.00195348f, 0.01703930f, -0.04215710f, 0.02762017f, -0.01676160f, -0.05689795f, -0.03025517f, -0.05505504f, 
    0.01674402f, -0.04161049f, 0.04260540f, 0.05656122f, 0.01615396f, -0.04567814f, 0.01224319f, -0.04665371f, 
    -0.01116853f, -0.00528584f, -0.02009906f, -0.01933954f, -0.05100206f, 0.01273583f, -0.01076732f, 0.00156270f, 
    0.00214649f, -0.02648433f, -0.01415433f, -0.02107156f, 0.03662890f, -0.04007329f, -0.01914604f, -0.05687211f, 
    0.00023414f, -0.05405893f, -0.04180912f, -0.00634922f, 0.05073342f, -0.01454010f, -0.05292459f, 0.03608135f, 
    0.04594363f, -0.05249008f, 0.05108273f, -0.01418771f, -0.01948199f, 0.03084487f, -0.03935907f, -0.04955941f, 
    0.01303724f, -0.01411461f, -0.01809711f, 0.01943210f, 0.02641383f, -0.02765300f, -0.01310644f, 0.00128216f, 
    -0.03626167f, -0.01798687f, 0.01972983f, 0.01751173f, -0.03134942f, 0.03523494f, -0.01495531f, -0.04903976f, 
    -0.02392856f, 0.02650358f, 0.02853218f, -0.00146810f, 0.01752410f, -0.06093193f, 0.03583381f, -0.04331542f, 
    -0.06290066f, 0.00132993f, 0.01186341f, 0.01648967f, 0.01136321f, -0.03388263f, 0.03711903f, 0.02955774f, 
    -0.05282964f, -0.05212526f, -0.00232880f, 0.00944574f, -0.03013085f, -0.05305565f, 0.03057246f, 0.03575419f, 
    -0.02958972f, -0.03799973f, 0.02215788f, 0.00084715f, 0.01318089f, -0.02715264f, -0.01586995f, -0.06015620f, 
    -0.05490640f, -0.04312452f, -0.06539585f, -0.03596282f, 0.01325930f, 0.03452384f, -0.04957326f, 0.02035677f, 
    0.00657239f, 0.00368416f, -0.03144657f, -0.03497699f, -0.00716242f, -0.05977220f, -0.01858680f, 0.00162997f, 
    0.03793037f, -0.04338664f, 0.03020362f, 0.02840391f, -0.01268656f, -0.04056573f, 0.04216921f, 0.04669782f, 
    -0.02679504f, -0.02298239f, 0.03252690f, 0.04732696f, -0.01616396f, 0.02999629f, 0.02484097f, 0.02985276f, 
    0.01029486f, -0.03271094f, 0.00652311f, 0.01102489f, -0.01700349f, 0.05342902f, -0.04676266f, 0.01799869f, 
    -0.00336229f, -0.03565009f, 0.04246496f, -0.02947545f, 0.04508382f, -0.05136119f, 0.01784565f, 0.03289353f, 
    0.00135589f, -0.01245094f, 0.00415127f, -0.00394338f, 0.04756593f, -0.00784801f, -0.03483457f, 0.02151913f, 
    -0.01018813f, 0.05293169f, -0.02899952f, -0.00078048f, 0.02600900f, -0.01992083f, -0.06337392f, -0.04067399f, 
    -0.04100977f, -0.02079619f, -0.04175843f, 0.02280630f, 0.00280511f, -0.04378365f, -0.01588457f, 0.00760308f, 
    0.01019663f, 0.04734180f, -0.05665166f, -0.06257790f, -0.04924562f, -0.02102543f, 0.04322092f, -0.04937991f, 
    0.04654296f, 0.05283877f, 0.02679471f, -0.01650913f, -0.00944960f, 0.03974063f, -0.00089596f, -0.05738880f, 
    0.01227912f, -0.05796801f, -0.01618035f, -0.00042646f, 0.03659846f, -0.02413028f, -0.00532034f, 0.01620810f, 
    0.04514557f, 0.03093877f, 0.00915354f, -0.00467052f, -0.04609112f, 0.01657000f, -0.03447463f, 0.03925408f, 
    0.05688625f, 0.00803677f, -0.02680111f, 0.03436035f, 0.03137513f, -0.04878756f, 0.01684730f, -0.06087361f, 
    0.03175253f, 0.02179550f, -0.01252745f, -0.00908687f, -0.05777234f, -0.00113982f, -0.06308800f, -0.04147208f, 
    -0.00806491f, -0.05237960f, 0.01974352f, -0.05129516f, 0.01362989f, -0.02989789f, -0.02936782f, 0.02146899f, 
    -0.01215484f, -0.01463680f, 0.04365295f, 0.01046923f, 0.04745312f, -0.04899640f, -0.05527721f, -0.03492411f, 
    0.04448257f, 0.04632518f, -0.03215483f, 0.02540619f, -0.04289947f, -0.02825033f, 0.02764442f, 0.00496232f, 
    -0.05309162f, -0.06133702f, -0.01725230f, -0.03705776f, 0.01561933f, -0.04098124f, 0.00262589f, 0.01836013f, 
    0.02381480f, 0.03104529f, -0.04957736f, 0.03495856f, -0.02132981f, 0.00845374f, -0.00450190f, -0.00349455f, 
    0.04491121f, -0.01341614f, -0.02296398f, 0.03683237f, 0.01447297f, -0.03844693f, 0.04122740f, -0.05603313f, 
    -0.04318490f, 0.04331728f, -0.06309738f, -0.00380917f, -0.01933924f, -0.04810891f, 0.03642662f, -0.01973389f, 
    0.29050177f, 0.10212100f, -0.00198370f, 0.22924547f, -0.27734351f, 0.02725086f, 0.09761479f, -0.07821514f, 
    0.03211575f, -0.10403556f, -0.01116361f, -0.14962265f, 0.03712348f, -0.00643447f, 0.06217933f, 0.08804430f, 
    -0.03480227f, 0.12754250f, 0.02717819f, 0.05688189f, -0.30565318f, 0.15759130f, 0.34104064f, -0.07069306f, 
    0.04543609f, -0.03560968f, 0.05902975f, 0.10542849f, -0.13301042f, -0.14900146f, -0.05532987f, 0.01341149f, 
    -0.15846990f, 0.11857001f, -0.02456118f, 0.10742048f, -0.14217146f, -0.05058374f, 0.00333370f, -0.17743237f, 
    0.31420419f, 0.05565501f, 0.17691672f, -0.03670237f, -0.20348705f, 0.07566678f, -0.06373035f, 0.14827837f, 
    -0.10139591f, -0.12767339f, 0.03042849f, -0.08339760f, -0.07232577f, -0.10862169f, 0.05837630f, 0.02444687f, 
    -0.10075525f, -0.05760041f, -0.07985952f, -0.15427479f, 0.06309916f, 0.22411217f, -0.17532577f, -0.04221996f, 
    -0.08476803f, -0.19136930f, 0.03663598f, 0.31319270f, 0.11522794f, 0.03801760f, -0.09474788f, -0.21928659f, 
    -0.06493236f, -0.04061481f, -0.09298209f, -0.03832559f, 0.03840186f, 0.09208395f, -0.02875807f, 0.07157452f, 
    -0.06533031f, -0.08143181f, -0.03931533f, 0.00742038f, 0.05535525f, -0.02904963f, -0.11516605f, -0.12301896f, 
    -0.04985536f, -0.04277498f, -0.05739260f, -0.02702157f, 0.04854135f, 0.08823792f, -0.06797066f, 0.00444790f, 
    0.02006909f, -0.13408022f, -0.02714043f, -0.01838683f, 0.02697894f, -0.38237062f, 0.04486762f, -0.06934193f, 
    0.15276778f, 0.05308926f, 0.04832800f, -0.02006393f, 0.08819387f, 0.12341838f, -0.03559274f, 0.05530167f, 
    -0.10859022f, 0.07915746f, -0.12252577f, -0.10695114f, -0.03864978f, -0.04336820f, 0.06318624f, 0.08994838f, 
    0.03754148f, 0.04729664f, 0.17174093f, 0.17178197f, 0.06895605f, -0.02271672f, 0.12334543f, 0.07603706f, 
    0.15147611f, 0.01632815f, -0.06049334f, 0.06539177f, -0.00672214f, 0.05642968f, 0.01844482f, -0.07586490f, 
    -0.02598272f, -0.04175666f, 0.25258020f, 0.06438855f, -0.01763373f, -0.06029505f, -0.07098227f, -0.04581780f, 
    -0.03933683f, -0.15546462f, 0.02543494f, -0.04409783f, 0.02568255f, -0.01078984f, -0.20170349f, -0.01892420f, 
    0.03683675f, 0.00255900f, 0.03389258f, -0.08882437f, -0.00478334f, 0.07460938f, 0.06167939f, 0.08603046f, 
    -0.30260557f, 0.12056475f, 0.28097203f, 0.07552771f, 0.07059886f, 0.13685468f, -0.12571305f, -0.20344079f, 
    -0.18555151f, -0.01603377f, -0.04282754f, 0.01969044f, -0.04805774f, -0.02703556f, -0.01288423f, 0.06812461f, 
    -0.10730000f, -0.10900394f, 0.06175135f, -0.05926934f, 0.19832519f, -0.20330743f, -0.02325226f, 0.01009425f, 
    0.08865862f, 0.00445085f, -0.00799069f, -0.14418958f, -0.05596530f, -0.11524690f, -0.10570206f, 0.06102471f, 
    0.02341520f, 0.06984381f, -0.01571321f, 0.05514695f, 0.10025057f, -0.20514593f, 0.04447523f, -0.03858257f, 
    0.03287813f, -0.11655238f, -0.23442109f, 0.02402217f, -0.04105934f, -0.06708157f, -0.04578992f, -0.09295290f, 
    -0.08629537f, -0.05827250f, 0.08005942f, 0.09194624f, 0.12055360f, 0.14470211f, 0.21997130f, -0.18458471f, 
    -0.07432377f, -0.11831722f, 0.05223461f, -0.03275910f, -0.22125377f, 0.12370244f, 0.09960525f, -0.40529099f, 
    -0.12588593f, -0.05193296f, -0.09565181f, 0.13511133f, -0.00725797f, 0.05473083f, 0.01835893f, -0.14192347f, 
    0.20626794f, 0.07386682f, 0.11909693f, 0.00963046f, 0.04044915f, 0.02439143f, 0.13687326f, 0.00805897f, 
    0.06313341f, -0.00735239f, 0.06495700f, -0.00969225f, -0.23531759f, 0.02568654f, -0.08622707f, -0.04705465f, 
    0.06413709f, -0.12998149f, 0.03671744f, 0.00844966f, 0.09189559f, -0.08001935f, 0.02536141f, -0.13713743f, 
    -0.04244382f, -0.02125619f, -0.13037668f, -0.01841848f, -0.02818578f, 0.10324477f, 0.51155537f, -0.05385837f, 
    0.08589529f, 0.00511308f, 0.21850203f, -0.03812123f, 0.01062021f, 0.10788322f, 0.06395291f, -0.09768460f, 
    -0.00097053f, 0.01301672f, -0.02316889f, 0.02904206f, 0.07442324f, 0.05186546f, 0.08672991f, 0.12883005f, 
    -0.60229415f, -0.28820276f, -0.22748017f, -0.05230490f, 0.01763837f, -0.05778607f, 0.06453642f, 0.12904756f, 
    0.18650436f, 0.22720985f, -0.06134862f, -0.01669290f, 0.04339604f, -0.13645618f, -0.20665976f, -0.10474939f, 
    -0.00237326f, 0.05537402f, -0.02265881f, 0.05677004f, 0.11563285f, 0.03334479f, 0.29784483f, -0.18390837f, 
    -0.21400529f, -0.06101421f, 0.00427318f, -0.16561967f, 0.01075119f, -0.06951964f, -0.06599450f, 0.00648118f, 
    0.15678750f, 0.05169301f, 0.00452338f, 0.20382693f, -0.17837872f, 0.02910287f, 0.03669106f, 0.04609928f, 
    -0.15066366f, 0.15786622f, -0.08651932f, 0.23296189f, 0.03459783f, 0.02370363f, 0.29554385f, -0.27005273f, 
    0.17942026f, -0.13045658f, -0.07372922f, -0.09179489f, -0.10308571f, 0.10706963f, 0.04138473f, -0.04869348f, 
    -0.11651678f, -0.04537263f, -0.01991273f, -0.00099985f, -0.04027371f, 0.04108490f, 0.29554459f, -0.26715487f, 
    0.11770538f, -0.06000964f, 0.21333691f, -0.05118707f, 0.08469523f, -0.11661732f, 0.02275198f, 0.05203417f, 
    -0.18334386f, 0.03032912f, -0.05981617f, -0.03726452f, -0.27819830f, -0.05569756f, 0.06741917f, -0.15267420f, 
    0.00236133f, -0.08133160f, -0.16482618f, 0.18960835f, 0.10246395f, -0.04469846f, 0.05083998f, 0.15338020f, 
    -0.24836728f, -0.06239099f, -0.00070485f, 0.04138935f, -0.01690046f, 0.13988149f, 0.24151018f, 0.36912024f, 
    0.07425142f, -0.03092679f, 0.13362446f, 0.10182950f, 0.15811634f, 0.28784162f, -0.19032706f, 0.16442843f, 
    -0.03482702f, -0.08453384f, 0.13565099f, 0.24680509f, 0.05266852f, 0.04788190f, -0.08009193f, -0.22032149f, 
    0.03421313f, -0.10223420f, -0.13548835f, 0.10161334f, 0.03016012f, 0.05267759f, -0.03204614f, 0.00921883f, 
    0.01405414f, 0.00972868f, 0.11579286f, 0.17245552f, -0.00594413f, 0.12290666f, -0.07602873f, -0.10133910f, 
    -0.14209954f, -0.07054917f, -0.08843240f, 0.09567526f, 0.08597568f, 0.06077731f, 0.06674473f, 0.14225084f, 
    0.06236078f, 0.04474090f, -0.11364862f, -0.04988230f, 0.04014604f, -0.38059583f, 0.11202190f, -0.08630589f, 
    -0.02592900f, 0.01825788f, 0.07874501f, -0.00318660f, 0.13919562f, 0.04566026f, -0.16851828f, 0.04782408f, 
    -0.14590357f, -0.12662540f, -0.00118763f, -0.10634832f, -0.03829097f, 0.18975748f, -0.01858867f, -0.01228173f, 
    0.03724371f, -0.04425911f, 0.46311221f, 0.30965936f, 0.14514536f, 0.01017026f, 0.10540035f, 0.15512012f, 
    0.07525378f, -0.09689950f, -0.12462334f, 0.20483232f, 0.11003418f, 0.04512377f, 0.08758743f, -0.08289016f, 
    0.03286325f, 0.11082204f, 0.15862802f, 0.00755426f, -0.03227041f, -0.09075899f, 0.00753198f, 0.01350900f, 
    -0.07556235f, -0.01057023f, 0.02192368f, 0.03546054f, 0.03875298f, 0.03304733f, -0.25827399f, 0.08208275f, 
    0.08510303f, -0.19614924f, 0.12558609f, 0.04641264f, -0.06080387f, 0.02808634f, -0.00911622f, 0.05165373f, 
    0.05631207f, 0.00779333f, 0.37304646f, 0.09915297f, 0.10965678f, 0.00990970f, -0.05773956f, -0.21261342f, 
    0.03927425f, -0.02613652f, 0.01317904f, 0.02138302f, 0.00826330f, 0.04176467f, 0.03072506f, 0.22705573f, 
    0.01911684f, -0.02347381f, 0.01636761f, -0.03218638f, 0.22226146f, -0.12889104f, 0.16534136f, 0.19959360f, 
    -0.09958662f, -0.06714073f, 0.11034559f, -0.05313224f, -0.02894226f, 0.00162525f, -0.05151681f, 0.14550835f, 
    0.03072926f, 0.04415175f, -0.00249700f, -0.02965585f, 0.05149628f, -0.04436239f, -0.02320555f, -0.06388428f, 
    -0.01144484f, -0.11556236f, -0.14787810f, 0.10167138f, -0.17204352f, 0.05524512f, 0.01132087f, -0.10839503f, 
    -0.02706507f, 0.04369057f, 0.11147643f, 0.10970650f, 0.01237574f, 0.20413223f, 0.03873988f, 0.03455455f, 
    -0.07422058f, -0.07544219f, -0.17590927f, -0.09419531f, -0.19295454f, 0.30755118f, 0.12825674f, -0.10504295f, 
    0.03873028f, -0.00780831f, -0.05251129f, 0.24314103f, -0.07989833f, 0.07289466f, -0.02763558f, 0.01397666f, 
    0.19921552f, 0.05544490f, 0.05136330f, 0.00687831f, 0.01321592f, -0.04736774f, 0.14173536f, 0.18323351f, 
    0.04377591f, -0.14272530f, 0.13795330f, 0.15260030f, 0.05683136f, 0.01171644f, -0.07640230f, 0.12649827f, 
    -0.10526628f, -0.14890067f, 0.06636588f, 0.00132481f, 0.08509088f, 0.05417398f, 0.07900313f, 0.07004943f, 
    0.10096640f, -0.09330960f, -0.08507154f, -0.00325469f, 0.00876705f, -0.01609040f, 0.69777608f, 0.07033724f, 
    0.31820980f, -0.05406988f, 0.12087464f, -0.13026279f, 0.00514032f, 0.15460259f, -0.03492287f, -0.06129265f, 
    0.04537730f, 0.00401567f, 0.00372882f, -0.00300076f, 0.13453087f, 0.00449506f, 0.14195459f, 0.21195270f, 
    -0.40219691f, -0.43549338f, -0.09406549f, 0.06062149f, -0.10420549f, 0.02087680f, 0.12506017f, 0.05881791f, 
    0.22311038f, 0.25536126f, -0.00366136f, 0.07813724f, -0.06572303f, -0.11050732f, -0.13650046f, -0.14313605f, 
    -0.04227344f, 0.11353822f, -0.16947930f, 0.00537962f, -0.01805830f, 0.26806274f, 0.30646652f, -0.00665633f, 
    0.12651414f, -0.09153222f, 0.12766986f, -0.18238816f, 0.33721122f, -0.08158930f, -0.12275073f, -0.01321825f, 
    0.11578210f, 0.04683482f, 0.07651849f, 0.25610456f, -0.07884429f, -0.09576774f, 0.11319027f, -0.03744151f, 
    0.44904444f, 0.39365447f, 0.19136672f, 0.36083558f, 0.10172441f, -0.05668147f, -0.05691722f, 0.05655738f, 
    -0.03928860f, 0.27197713f, 0.09372091f, 0.04971564f, 0.07583325f, -0.08761393f, -0.02865595f, 0.20687294f, 
    0.01017477f, 0.10943098f, 0.10688685f, 0.01152727f, 0.33517644f, 0.10500326f, 0.17129892f, 0.11493474f, 
    0.04967738f, 0.07183887f, 0.00037869f, 0.19243950f, 0.01120971f, -0.01507475f, -0.01799474f, 0.04793771f, 
    -0.02162437f, -0.02705862f, 0.03670875f, 0.24657220f, 0.14538151f, 0.09043001f, -0.00381182f, 0.00938156f, 
    0.08174124f, 0.20865813f, -0.07996204f, -0.04961161f, 0.06195279f, 0.04203449f, -0.13038780f, -0.03312277f, 
    0.10203265f, -0.02614416f, -0.00255435f, -0.03983190f, -0.04330728f, -0.12957740f, 0.12641506f, -0.06875272f, 
    -0.15691245f, 0.05924869f, -0.01723550f, 0.03243934f, -0.37967321f, -0.15935619f, -0.24140683f, -0.20034160f, 
    0.21972853f, -0.18711628f, -0.07808030f, -0.00119740f, 0.20820177f, -0.00330656f, -0.14910398f, 0.06161669f, 
    -0.08793501f, 0.12886631f, -0.05183295f, -0.07699946f, 0.00913924f, 0.11167052f, 0.18438987f, 0.10600407f, 
    -0.27227360f, -0.10111814f, 0.11533710f, -0.21180195f, -0.17933549f, -0.16556004f, -0.17083445f, -0.07410172f, 
    0.00884217f, -0.24140084f, -0.14482184f, 0.00865803f, -0.09038378f, 0.00409934f, -0.19001557f, -0.06643394f, 
    -0.01547497f, 0.02351061f, 0.06397493f, 0.01537602f, 0.13824697f, -0.14548141f, 0.41297972f, 0.00136507f, 
    -0.05582733f, -0.07101991f, -0.03960912f, 0.06049739f, 0.00406744f, 0.07504582f, 0.03281036f, 0.15202561f, 
    0.07568932f, 0.22638580f, -0.03296631f, -0.02500376f, 0.12661301f, -0.03412509f, 0.15476365f, -0.06708115f, 
    0.23711701f, 0.26631862f, -0.26605868f, -0.18687825f, -0.04884335f, -0.11552264f, 0.02562235f, 0.00181941f, 
    0.14721099f, 0.14165610f, -0.02291044f, -0.00618054f, -0.03815755f, 0.02772475f, 0.01419295f, 0.11728361f, 
    0.23930606f, 0.02504048f, 0.13381201f, 0.13085595f, -0.09782262f, 0.12846832f, 0.09037898f, 0.04216089f, 
    -0.28030750f, -0.10735087f, -0.09238090f, -0.13174865f, 0.03787034f, -0.08927219f, -0.04691204f, 0.00406785f, 
    -0.09951838f, 0.01562122f, -0.19497384f, -0.17845809f, 0.12666681f, 0.10714149f, 0.23160054f, 0.03706573f, 
    0.02701117f, 0.10427900f, 0.01286664f, -0.04377827f, 0.14974496f, 0.18463717f, 0.03960061f, 0.08209857f, 
    0.05628664f, 0.04521614f, 0.01803424f, 0.08627158f, -0.08478395f, 0.02247116f, 0.13818076f, 0.13908333f, 
    0.00468699f, -0.00867264f, 0.02599736f, -0.08507825f, -0.33158720f, -0.10972938f, 0.23296191f, -0.15607095f, 
    -0.08603183f, 0.04473585f, -0.22726569f, -0.12262678f, -0.15421683f, -0.21450123f, 0.00429176f, 0.03012155f, 
    -0.09369032f, -0.01209689f, -0.13290526f, 0.21914823f, 0.19092058f, -0.06397880f, -0.02664741f, 0.00928503f, 
    -0.33390984f, -0.18622293f, 0.10625593f, 0.02844894f, -0.24875475f, -0.09351029f, -0.08913227f, -0.05159890f, 
    -0.03171498f, -0.22391032f, -0.02129737f, -0.08186775f, 0.19540848f, -0.00081591f, -0.00491910f, 0.00415208f, 
    0.05051635f, -0.18426198f, -0.07482766f, -0.11450994f, 0.08879935f, -0.02619001f, -0.19298859f, -0.16411601f, 
    -0.00148090f, 0.10219476f, 0.02763114f, -0.03309648f, 0.26150841f, -0.11197120f, 0.09248084f, -0.13412705f, 
    0.01210932f, 0.10754834f, 0.03604644f, 0.00021029f, 0.12310666f, 0.22359264f, 0.04262706f, 0.09364318f, 
    0.02446402f, 0.11216107f, -0.16368079f, -0.13528582f, -0.03330403f, 0.01322292f, -0.02009012f, -0.01853465f, 
    0.07930817f, -0.12000833f, -0.06124279f, 0.04746545f, -0.08251197f, 0.05981416f, 0.09766133f, 0.02541082f, 
    -0.05192815f, 0.02111227f, -0.10752660f, -0.09599047f, -0.04474932f, 0.08382782f, -0.31176555f, -0.10108955f, 
    -0.04456721f, -0.03991151f, 0.04373895f, 0.11472327f, 0.09228592f, 0.04661185f, -0.10191470f, 0.01674939f, 
    -0.05266976f, -0.07530836f, 0.03133906f, 0.16500467f, 0.16677889f, 0.02102234f, -0.12570424f, 0.06993198f, 
    0.04964435f, -0.17958045f, 0.09224555f, 0.02246527f, 0.12599444f, 0.11066391f, -0.03060258f, 0.30479071f, 
    -0.01103150f, -0.29794461f, 0.06042486f, 0.04959728f, 0.04998970f, 0.11439040f, 0.12672770f, 0.18664344f, 
    0.04446543f, -0.12514840f, 0.07814745f, -0.05379302f, -0.33880147f, -0.06162168f, -0.30079839f, 0.23028655f, 
    -0.23773563f, -0.04717860f, -0.09183908f, 0.11389256f, -0.12827452f, 0.09464448f, -0.03811574f, -0.05333320f, 
    -0.04214154f, 0.01512388f, 0.02870353f, 0.08663679f, -0.00133086f, 0.13211508f, -0.01888058f, 0.07855486f, 
    -0.44834086f, 0.12252174f, -0.00909151f, -0.06686699f, 0.31534493f, -0.13436806f, 0.17908706f, -0.00351098f, 
    -0.01298804f, -0.15706186f, -0.02647736f, -0.13957097f, 0.07360499f, 0.19294982f, -0.02817113f, 0.03244877f, 
    0.19057237f, -0.03943395f, -0.03397317f, 0.00603168f, 0.19242214f, -0.17101225f, -0.07100613f, -0.06350135f, 
    0.23173496f, -0.01712047f, 0.04045044f, -0.04511701f, 0.21063761f, 0.19333947f, -0.03842317f, 0.01491411f, 
    0.14167939f, 0.03186247f, 0.05492697f, -0.03649548f, 0.15037347f, -0.03980168f, 0.09789935f, 0.09076343f, 
    -0.40331462f, -0.24674493f, -0.22409706f, 0.20221962f, 0.12590478f, -0.15868685f, 0.00693704f, -0.01261705f, 
    -0.04820846f, 0.05138910f, -0.10527148f, 0.01813667f, 0.04708910f, 0.11000044f, -0.12319695f, 0.07930964f, 
    0.22834656f, 0.21304585f, 0.14978887f, 0.08294843f, -0.32528538f, 0.10196210f, 0.30053544f, 0.36810660f, 
    0.04064493f, -0.01001157f, -0.05703951f, -0.15374619f, -0.07690383f, -0.05676185f, -0.08918571f, 0.10638131f, 
    0.10390562f, -0.12622330f, 0.06033766f, 0.15854980f, -0.17782398f, -0.16888744f, -0.09018879f, -0.21628945f, 
    0.13818447f, -0.22918013f, 0.06358468f, -0.19431031f, -0.13486946f, -0.03361346f, 0.17553620f, -0.04405390f, 
    -0.18114872f, -0.02690046f, -0.06533328f, -0.01382369f, 0.07761163f, -0.07684825f, 0.04680250f, -0.02999736f, 
    0.03734032f, -0.07901934f, -0.25581139f, 0.00909091f, 0.09727494f, 0.02906905f, 0.00971479f, -0.35338637f, 
    0.04393504f, 0.00707548f, -0.05469867f, 0.10340659f, -0.03403973f, -0.04633968f, 0.01949218f, 0.17657341f, 
    -0.00315104f, 0.04525451f, 0.23502795f, 0.08218466f, -0.07159129f, -0.04121146f, -0.03474672f, -0.09873557f, 
    0.01938854f, -0.08465730f, -0.09290478f, 0.15504152f, 0.20243156f, -0.03509163f, -0.00468941f, 0.04413243f, 
    -0.22841392f, 0.03413309f, 0.13982934f, 0.06121903f, 0.01422351f, 0.00290223f, 0.12782587f, -0.02169280f, 
    0.04292174f, 0.04988004f, 0.10451782f, -0.00060966f, 0.12273166f, -0.01235194f, -0.06980476f, -0.15707895f, 
    -0.06432572f, 0.01340675f, 0.01759396f, 0.17231995f, -0.11532779f, -0.10574270f, -0.03297552f, 0.11721520f, 
    -0.06262359f, -0.08701716f, 0.11537535f, 0.03300387f, 0.00817044f, -0.10038869f, -0.21496734f, -0.12886940f, 
    0.40566811f, -0.08110381f, -0.18635473f, 0.06402217f, 0.11269815f, -0.01538236f, 0.04954106f, -0.03440926f, 
    0.11705470f, 0.08360928f, 0.01211799f, -0.09476070f, 0.07083750f, 0.03127300f, 0.01080302f, 0.00840510f, 
    0.22324356f, 0.00717669f, 0.11707103f, 0.14599636f, -0.13627794f, -0.09810127f, 0.10712470f, -0.25465363f, 
    -0.03698520f, -0.05081037f, 0.05020377f, -0.01245728f, -0.14206474f, 0.05493782f, -0.09930019f, 0.06195931f, 
    0.02942877f, -0.02622199f, 0.06963325f, 0.07055102f, 0.18140407f, 0.15493825f, -0.09803187f, -0.15208966f, 
    -0.20823643f, 0.20782016f, 0.06789818f, -0.28987071f, -0.20027448f, 0.05633552f, -0.01098828f, 0.03934366f, 
    -0.04463984f, 0.16226110f, -0.10120036f, 0.07148153f, 0.24406087f, 0.02824721f, 0.05965512f, 0.09822442f, 
    0.00859722f, 0.00963319f, -0.15402028f, 0.12112045f, -0.14441863f, -0.23794951f, -0.10883084f, 0.35577652f, 
    0.21148258f, 0.02938186f, 0.13161576f, 0.02562486f, -0.06655221f, -0.00960060f, 0.03381992f, 0.04234825f, 
    -0.08025011f, -0.12976377f, -0.00231028f, -0.00525261f, -0.07114896f, 0.06961995f, -0.06813764f, -0.05305561f, 
    -0.06975210f, -0.20427600f, -0.13584428f, 0.07040712f, 0.22323193f, -0.07489970f, 0.09222986f, 0.06928893f, 
    -0.16058148f, 0.00599324f, 0.01289314f, 0.04611057f, 0.00516588f, 0.02640125f, -0.00523233f, 0.07271659f, 
    0.08124173f, 0.12818794f, 0.21058112f, 0.12190101f, 0.06679908f, -0.08576439f, -0.16766082f, 0.09052454f, 
    0.15423614f, -0.07779361f, -0.14746726f, 0.06735793f, -0.06022241f, 0.08439703f, -0.04962325f, -0.06310658f, 
    -0.05704070f, 0.07843540f, -0.00015095f, -0.02484865f, -0.13817538f, -0.04787741f, 0.24127527f, -0.01319810f, 
    0.10280749f, 0.23402350f, 0.58900714f, 0.06957799f, 0.34046310f, -0.04896634f, -0.03356039f, -0.19011378f, 
    0.21291709f, 0.32622993f, 0.00901301f, 0.03486404f, 0.11692671f, -0.02032351f, 0.05310912f, -0.00385987f, 
    -0.14648968f, -0.07734141f, 0.01455262f, -0.04134628f, -0.15789551f, -0.04666737f, -0.12049650f, 0.02125375f, 
    0.20526010f, -0.06463717f, 0.17005654f, 0.11459454f, 0.12854283f, -0.25530189f, -0.02152693f, -0.07725741f, 
    -0.13626821f, 0.04867573f, 0.10449781f, -0.02513032f, -0.02872989f, 0.34310475f, 0.11630972f, 0.06370564f, 
    0.03058222f, -0.41884542f, -0.13609347f, -0.13883027f, -0.34542742f, 0.23328619f, -0.13272749f, -0.03135200f, 
    0.19792227f, -0.00023321f, -0.03937220f, 0.11173220f, -0.01101042f, -0.01519926f, 0.04451848f, -0.06765738f, 
    -0.03283941f, 0.07605714f, 0.06656136f, 0.09486700f, -0.32161570f, 0.30586854f, -0.03175928f, 0.11268866f, 
    -0.26956916f, -0.06033845f, -0.06454112f, -0.01420404f, -0.00589695f, 0.04459327f, 0.01213691f, -0.05726103f, 
    -0.00685634f, 0.08441539f, 0.06137308f, -0.00156623f, -0.02359208f, -0.01097874f, -0.04859838f, 0.05261867f, 
    0.24289799f, 0.02528209f, 0.12111280f, 0.06129647f, -0.30893290f, 0.02779525f, 0.02345371f, -0.02850450f, 
    0.03712505f, -0.01259540f, 0.04219390f, -0.02551234f, 0.09105431f, 0.07044271f, 0.02255798f, 0.05800215f, 
    0.12217238f, -0.26046404f, 0.01463312f, -0.01870403f, 0.34699044f, -0.16088691f, 0.20272417f, -0.22593960f, 
    -0.35445398f, 0.05503730f, 0.12565513f, 0.02872925f, -0.18733516f, 0.13002659f, 0.10635353f, 0.03650510f, 
    0.17076838f, -0.08413436f, -0.08229556f, -0.06745937f, 0.01282831f, -0.05805525f, 0.01202073f, 0.17496710f, 
    -0.10803781f, 0.19173694f, -0.43793142f, 0.37661338f, -0.03169344f, 0.04308314f, 0.01996686f, 0.23325372f, 
    -0.09723409f, 0.01382173f, -0.03326320f, -0.06531984f, -0.05781834f, -0.02882518f, 0.01657644f, 0.18973115f, 
    0.07964842f, -0.07444862f, -0.01110509f, -0.18270023f, -0.26012930f, 0.16122979f, -0.18262674f, 0.30454922f, 
    -0.03265828f, 0.02584821f, -0.05268635f, -0.10495755f, -0.19524352f, -0.11884025f, 0.10273919f, -0.02741907f, 
    0.00055300f, 0.03857202f, -0.17877398f, 0.00531850f, -0.04120428f, 0.09480572f, -0.10463417f, 0.06524491f, 
    -0.28415906f, -0.05137308f, 0.45568928f, 0.09514462f, -0.26755148f, 0.23300710f, 0.00693189f, 0.11440789f, 
    0.12247764f, -0.05568523f, -0.16822678f, -0.03986983f, 0.07370029f, -0.05847387f, -0.09332494f, 0.08383749f, 
    0.00515277f, -0.06091229f, 0.04040647f, -0.03804121f, -0.10551815f, -0.18412262f, 0.04430753f, 0.04822490f, 
    0.08766317f, 0.00278198f, 0.07715768f, 0.00742064f, -0.05901904f, -0.06249118f, 0.05823211f, -0.04924337f, 
    0.11559398f, -0.13763577f, -0.00559284f, 0.08284295f, -0.00576950f, -0.05476776f, -0.05131500f, -0.07423237f, 
    -0.30933103f, 0.03702623f, -0.01387797f, 0.21415079f, -0.13593516f, 0.04106985f, 0.05144475f, 0.16670711f, 
    0.02489669f, 0.15544277f, 0.02496998f, 0.05806744f, -0.01509782f, 0.08840923f, -0.01801613f, 0.08389287f, 
    -0.10179602f, 0.06040804f, 0.03674599f, 0.13741243f, 0.04591989f, -0.00962943f, -0.30094659f, 0.30205458f, 
    -0.08435141f, 0.01374514f, 0.14595085f, 0.11643180f, -0.13353620f, 0.05586540f, 0.11999625f, -0.19068046f, 
    0.13750245f, -0.03884064f, 0.06081482f, -0.10926487f, -0.11450060f, 0.02193978f, 0.05704398f, 0.07640284f, 
    0.33447722f, -0.07327550f, -0.08529584f, 0.13956399f, 0.34353182f, -0.23960084f, -0.08190163f, -0.10460062f, 
    -0.13183750f, -0.31982934f, 0.04735657f, 0.12466093f, -0.31210470f, 0.07988930f, 0.06390786f, -0.01154735f, 
    0.13590918f, 0.14242083f, 0.16906404f, -0.14136042f, 0.21383789f, 0.34629178f, 0.21594881f, -0.10801495f, 
    -0.26469490f, -0.02948220f, 0.15909256f, 0.22707348f, -0.01514318f, 0.20707142f, -0.05951926f, -0.05182706f, 
    -0.00149528f, 0.07422078f, -0.03135440f, 0.04357655f, -0.00504844f, -0.05027005f, 0.14805868f, 0.16055088f, 
    -0.02169463f, 0.01222209f, 0.28839129f, 0.07217143f, -0.07738002f, 0.03780393f, 0.00661104f, 0.05165172f, 
    0.12977518f, 0.20947607f, -0.05283106f, -0.02522934f, 0.07435409f, 0.04531851f, 0.01413815f, 0.08516467f, 
    -0.03076068f, -0.06087205f, 0.00421381f, -0.00644428f, -0.10932774f, 0.01291328f, 0.43699062f, 0.20499803f, 
    -0.37167102f, 0.12476003f, -0.05963859f, -0.03009870f, 0.10856853f, 0.10025256f, 0.00725032f, 0.00994071f, 
    -0.14004689f, -0.11794931f, 0.02829331f, -0.01246935f, 0.03487081f, -0.00798477f, 0.07802081f, 0.06356824f, 
    0.08880398f, 0.16319430f, -0.20968452f, 0.15927173f, -0.53086036f, -0.02083117f, -0.04706965f, -0.17421670f, 
    -0.16108969f, -0.05412079f, 0.13237013f, 0.00879397f, -0.03200098f, 0.11253202f, -0.05687934f, -0.17867449f, 
    0.09884434f, 0.17107177f, -0.11651720f, 0.07111449f, 0.36211887f, 0.05001952f, 0.34977546f, -0.16079907f, 
    -0.00199365f, 0.16382654f, -0.01468951f, -0.06279214f, 0.21169110f, 0.32137209f, 0.05522377f, -0.01706612f, 
    0.11875073f, 0.07950544f, -0.04795521f, 0.08210529f, 0.15126976f, -0.24557227f, -0.10566729f, 0.07772192f, 
    -0.04509280f, 0.17046027f, 0.34139910f, -0.23801285f, -0.39206749f, 0.31745222f, -0.46068221f, -0.36683545f, 
    0.20385452f, 0.14877029f, -0.12911218f, -0.06449658f, 0.18155971f, 0.18490869f, -0.06021479f, -0.30805936f, 
    -0.13271418f, 0.03796269f, 0.16163601f, -0.07320680f, 0.13517767f, 0.02279191f, 0.27163211f, 0.05442026f, 
    -0.45142770f, 0.31175828f, -0.10325345f, 0.00277836f, -0.03090525f, -0.13339172f, -0.04710015f, -0.16194288f, 
    -0.01092867f, 0.00026477f, -0.44436309f, -0.23077953f, -0.14886864f, -0.09254692f, 0.14298986f, 0.11951847f, 
    0.44798884f, -0.07335573f, -0.08709635f, -0.25537211f, -0.36060473f, -0.04152793f, -0.16634649f, 0.16993447f, 
    0.12667952f, -0.25620157f, -0.18726476f, -0.23698534f, -0.04316536f, -0.24858440f, -0.36639845f, -0.17268074f, 
    0.24558638f, 0.10929627f, -0.33988574f, -0.20038243f, -0.22455917f, -0.14856581f, 0.07497870f, -0.10566801f, 
    0.08599818f, 0.09115160f, 0.10972228f, 0.11235359f, 0.01107313f, -0.04783385f, -0.12870800f, -0.20760822f, 
    -0.16507667f, 0.05206877f, 0.00055535f, -0.04542818f, -0.10345795f, 0.01085673f, -0.02452746f, -0.00715963f, 
    0.00279503f, 0.00271451f, 0.08693167f, 0.08507181f, 0.09698574f, -0.01675717f, -0.06305569f, -0.04636295f, 
    0.00452234f, 0.11911598f, 0.04596592f, 0.08330103f, 0.06341220f, 0.04511531f, 0.12049812f, 0.02431909f, 
    -0.00686236f, -0.09280561f, -0.11740167f, -0.04608323f, -0.04616513f, 0.13221300f, 0.04465975f, 0.08653024f, 
    0.13111243f, 0.09375321f, 0.06220967f, 0.13969788f, 0.16770954f, 0.14426067f, 0.05641497f, 0.07212704f, 
    -0.02041902f, -0.03553272f, -0.07789748f, -0.15209888f, -0.12479965f, -0.03077922f, -0.01862972f, -0.00099347f, 
    -0.23081146f, -0.02456467f, 0.19726127f, 0.18146926f, -0.05980520f, 0.27312508f, -0.04679277f, -0.35401487f, 
    -0.05820312f, 0.00764857f, -0.18478222f, -0.14213499f, -0.27318823f, 0.10438389f, -0.08172648f, -0.10344744f, 
    -0.10904356f, -0.06812404f, 0.58690304f, 0.12116303f, 0.10174692f, 0.06725224f, 0.05184060f, 0.09899856f, 
    0.12737963f, 0.09644007f, 0.03317923f, 0.06535435f, 0.04576560f, 0.10587011f, 0.02683979f, 0.06683068f, 
    0.03116856f, 0.06447825f, 0.13760692f, -0.03187961f, 0.03479663f, -0.02834584f, 0.00314548f, -0.07557529f, 
    0.33844113f, -0.00857913f, -0.11121198f, -0.08253987f, 0.12408718f, -0.29406354f, -0.13151103f, 0.09101401f, 
    -0.03618833f, -0.17676423f, 0.08111227f, -0.14913864f, -0.10912757f, 0.02516639f, -0.11179279f, -0.06033801f, 
    -0.10399362f, -0.29598397f, -0.00601389f, -0.25726211f, 0.04034473f, 0.12640494f, 0.07701469f, 0.09915350f, 
    0.21037167f, 0.00472013f, 0.03774064f, 0.05108085f, 0.00837896f, 0.00861298f, 0.12600040f, 0.07745882f, 
    0.04829162f, 0.09942922f, 0.08749957f, -0.09742916f, -0.03224118f, -0.12156497f, -0.07309379f, -0.03553073f, 
    0.16623740f, 0.11377338f, 0.13705663f, 0.05757125f, 0.07071379f, 0.05163425f, 0.08261733f, 0.03127266f, 
    0.13784173f, 0.07502399f, 0.14910378f, 0.17067121f, 0.03017028f, 0.00436017f, 0.09953742f, -0.28707907f, 
    -0.20234723f, -0.07770965f, 0.04341660f, -0.06886467f, -0.29788634f, -0.04860357f, 0.11125146f, -0.42438117f, 
    -0.08787697f, 0.23190090f, 0.01365462f, 0.07712966f, 0.29449749f, 0.15466224f, 0.09988783f, 0.00088397f, 
    0.00902704f, 0.05083947f, -0.11915407f, 0.05529285f, -0.03251876f, -0.03226803f, -0.10911790f, 0.08804259f, 
    0.02660777f, -0.19438197f, -0.36670992f, -0.10857585f, -0.16800931f, -0.01073534f, -0.03428405f, -0.12921238f, 
    -0.02117264f, -0.10637426f, -0.09818163f, -0.10590088f, 0.05012508f, -0.24700086f, -0.23178455f, -0.17789727f, 
    -0.11467955f, -0.05278078f, -0.14805804f, -0.13084227f, -0.08168966f, -0.10467326f, -0.18746997f, -0.05398302f, 
    0.10016798f, -0.05778850f, -0.22167730f, -0.42502958f, -0.00374517f, -0.36702010f, -0.00173971f, -0.29357091f, 
    -0.11629186f, -0.03829241f, -0.18585466f, -0.17960055f, -0.08491665f, -0.07090390f, 0.05662406f, -0.03928856f, 
    -0.10842395f, -0.18424088f, -0.04799623f, 0.05835165f, 0.00765924f, -0.02046201f, 0.13129510f, 0.10151324f, 
    0.19276556f, 0.13339244f, -0.17339265f, -0.17578316f, 0.10405049f, -0.00274849f, 0.01856793f, -0.10775169f, 
    -0.13591111f, 0.03334625f, -0.05831624f, -0.04733428f, -0.10902699f, -0.05723305f, 0.12742506f, -0.35127023f, 
    -0.37418419f, -0.17941177f, -0.03465430f, -0.00533824f, 0.14758076f, -0.07646449f, -0.14969827f, -0.15236568f, 
    -0.07852277f, -0.05864083f, -0.14995131f, -0.23103969f, 0.08317540f, 0.04753121f, -0.02249438f, -0.27659208f, 
    0.48562968f, 0.25446236f, 0.05814526f, 0.21316354f, 0.03762893f, 0.07280544f, -0.03166171f, 0.18151267f, 
    -0.02868030f, 0.30465236f, 0.16505723f, 0.12660085f, -0.03111267f, -0.04699344f, 0.09849052f, -0.01500543f, 
    -0.15916409f, 0.13766101f, 0.12804033f, 0.07386556f, -0.05274985f, 0.18834379f, 0.06668481f, 0.06355219f, 
    -0.09192250f, 0.01447648f, 0.06640884f, 0.19627829f, 0.03268576f, -0.01524213f, -0.00512364f, 0.02117906f, 
    -0.03542782f, -0.01398040f, 0.06096191f, 0.00902885f, -0.01940507f, 0.03391123f, -0.04500825f, 0.02233693f, 
    0.13936964f, 0.14077350f, 0.42610487f, -0.20471826f, -0.04231728f, 0.12813351f, -0.02658815f, 0.07915281f, 
    0.17758535f, -0.10693793f, 0.05249927f, 0.00724548f, -0.05960241f, -0.01912875f, 0.06435282f, -0.01194032f, 
    -0.08580580f, -0.03131968f, -0.09712246f, -0.11296643f, 0.02736711f, -0.19791357f, -0.42691645f, -0.46815792f, 
    0.01348030f, 0.03320683f, 0.03249737f, 0.01956705f, 0.13900934f, -0.06985383f, 0.10279462f, 0.02384561f, 
    0.00838736f, 0.12627043f, 0.02169949f, 0.00404506f, 0.09203958f, 0.04274872f, -0.00293601f, 0.19187765f, 
    -0.53720343f, 0.04951999f, 0.08154993f, -0.06812833f, 0.19031434f, -0.09075426f, -0.35324636f, -0.28271928f, 
    -0.12699819f, -0.19685327f, -0.05426145f, -0.11833696f, -0.09717434f, -0.03465295f, -0.12381846f, 0.05413422f, 
    0.07978828f, 0.12715164f, 0.05460270f, 0.02399469f, -0.08694023f, -0.09854435f, -0.29892573f, 0.37305841f, 
    0.02690293f, -0.10095433f, -0.06147351f, -0.23545289f, -0.05708701f, 0.03068120f, 0.03855404f, -0.00719218f, 
    0.02889346f, 0.12894365f, -0.08884457f, -0.02401242f, -0.06212367f, -0.08985443f, 0.16211975f, 0.24375781f, 
    0.24817887f, 0.13145678f, -0.12051681f, 0.01472515f, -0.23340771f, 0.06832332f, 0.10826130f, -0.00448987f, 
    0.30628699f, 0.08008009f, 0.02461462f, -0.00766789f, -0.05495942f, 0.09101833f, -0.02849626f, 0.08300876f, 
    0.06972533f, 0.00308448f, 0.07562318f, 0.19547713f, -0.33310500f, -0.12786072f, -0.10065742f, -0.03317586f, 
    -0.05669789f, -0.07781611f, -0.12974851f, -0.31040353f, -0.21279716f, -0.00426515f, 0.06185351f, -0.04189430f, 
    -0.07755615f, 0.06661237f, -0.10242316f, -0.04436085f, 0.04657520f, 0.20340917f, 0.09620102f, 0.20099680f, 
    -0.26168767f, 0.17008099f, 0.11673564f, -0.06715745f, -0.02286964f, 0.07284050f, 0.04412874f, 0.08904520f, 
    0.00401926f, 0.11802350f, 0.04605274f, 0.09715489f, -0.07692086f, -0.02007579f, 0.00322078f, -0.05171813f, 
    -0.10878082f, 0.05389108f, 0.00651631f, -0.06661666f, -0.04385216f, 0.04484818f, -0.14251713f, 0.09377437f, 
    0.15755542f, 0.12990241f, -0.17808451f, -0.33607921f, -0.01103444f, -0.07436955f, 0.11199607f, -0.09358429f, 
    -0.01505229f, -0.01747639f, -0.00362081f, -0.02611320f, 0.03044314f, -0.03726444f, 0.05250668f, 0.13832991f, 
    0.18232493f, 0.06670734f, -0.20029761f, 0.01622943f, 0.11390565f, -0.22798535f, -0.08620200f, -0.23029745f, 
    -0.12160793f, -0.33852929f, 0.08644267f, -0.17033359f, -0.09263082f, -0.04550572f, 0.01235528f, -0.04065973f, 
    0.11673658f, 0.09312287f, 0.02990986f, -0.16946970f, 0.15373449f, 0.17236687f, 0.09257767f, -0.30560455f, 
    -0.08843722f, 0.07086938f, 0.00986131f, -0.05516222f, 0.10890988f, 0.06607736f, 0.04324181f, -0.05609025f, 
    0.22661665f, 0.11826828f, -0.01055377f, 0.00603811f, 0.11603991f, 0.00714456f, 0.10203343f, 0.08380403f, 
    0.06761424f, 0.09436229f, 0.24780621f, -0.06021010f, -0.18449204f, 0.02032301f, 0.01527745f, 0.00705770f, 
    0.24479054f, 0.04054590f, -0.02984110f, -0.01252282f, 0.11462481f, 0.02787078f, 0.03912077f, -0.09180897f, 
    -0.00913304f, 0.09208619f, -0.16093346f, -0.05684080f, 0.00298533f, -0.00222150f, -0.08561295f, -0.10372903f, 
    0.00455659f, 0.13251743f, 0.15950145f, 0.04701509f, 0.10597758f, 0.03379374f, -0.05114686f, 0.02511589f, 
    0.00369433f, 0.00724033f, 0.08954025f, 0.11331923f, 0.15390132f, 0.04052139f, -0.19992183f, 0.12052874f, 
    -0.14921473f, -0.00826951f, -0.70323849f, -0.27996367f, -0.04822593f, -0.04321900f, -0.03389367f, 0.13859658f, 
    -0.09005646f, -0.13315898f, 0.02800469f, 0.02396707f, 0.03046264f, 0.13307993f, 0.14050239f, -0.01850236f, 
    0.05026487f, -0.00529533f, -0.01805426f, 0.10299927f, 0.00300329f, 0.05313809f, 0.16906077f, 0.03087413f, 
    -0.23546705f, 0.13640641f, -0.13250928f, 0.06965757f, -0.18181311f, 0.20893721f, -0.01945510f, 0.01081515f, 
    0.09989341f, -0.01163362f, -0.18552735f, 0.09897421f, 0.12726624f, -0.02096685f, -0.12784109f, 0.10368089f, 
    -0.31704402f, -0.32459280f, -0.05088751f, -0.18049408f, 0.34853792f, 0.18892799f, -0.09693144f, 0.15699573f, 
    -0.01778501f, -0.19216810f, -0.09631719f, 0.05976421f, 0.10521025f, 0.05599680f, 0.15236725f, -0.08013119f, 
    -0.08256365f, 0.08635954f, 0.05074257f, 0.00429311f, 0.23954308f, 0.01328834f, -0.38680425f, 0.10519341f, 
    -0.02847016f, 0.07074331f, -0.06729432f, -0.07123084f, 0.06805269f, -0.02052818f, -0.07666343f, -0.10931168f, 
    0.12245724f, 0.03899774f, 0.15915823f, -0.15827970f, 0.06569209f, -0.05719211f, -0.08015613f, 0.03811044f, 
    -0.37604532f, -0.14037612f, 0.01533922f, -0.11844936f, -0.00181182f, 0.02050996f, 0.08451544f, -0.01402432f, 
    0.15922594f, 0.04477638f, -0.01576363f, 0.00545783f, -0.02416750f, 0.10369462f, 0.10544092f, 0.06829061f, 
    0.05740574f, 0.13614264f, 0.00726196f, 0.02181760f, 0.08542900f, -0.37457976f, -0.07250667f, 0.17278287f, 
    -0.07761067f, 0.16116299f, 0.08921452f, 0.10121235f, -0.08604651f, 0.13427702f, 0.17382559f, -0.07479221f, 
    -0.13461077f, -0.19119278f, -0.09664499f, -0.02559985f, 0.03617496f, -0.03029334f, 0.04920058f, -0.07840794f, 
    -0.06386147f, 0.19446453f, 0.12665337f, -0.08046418f, -0.14450082f, 0.05834509f, 0.00889216f, -0.01726434f, 
    0.09671612f, -0.05995103f, 0.14331570f, -0.02013548f, 0.06278633f, -0.10857885f, 0.02386032f, 0.09991147f, 
    0.09573727f, 0.08368267f, -0.07815868f, -0.12485784f, -0.05039782f, 0.30881381f, -0.18851084f, 0.12834348f, 
    -0.16889521f, -0.09398299f, 0.02593471f, -0.05718162f, -0.18046872f, -0.05520193f, -0.05244374f, 0.00695535f, 
    0.19732177f, 0.07717924f, -0.00178375f, 0.12566307f, -0.09146083f, 0.03346913f, -0.04268679f, 0.07093342f, 
    0.31613061f, -0.25717059f, -0.06766466f, 0.34007493f, -0.07031034f, 0.17261364f, 0.03308435f, 0.12045816f, 
    -0.02488290f, -0.14980984f, 0.09366785f, 0.03918660f, -0.01562508f, -0.05811803f, -0.01976416f, -0.00785401f, 
    0.01109474f, 0.08023333f, -0.03075513f, 0.00304888f, -0.08856095f, -0.00047537f, 0.00605980f, 0.20708498f, 
    -0.06020862f, 0.09864243f, -0.07120577f, -0.11619480f, -0.08985871f, -0.04569224f, 0.07098971f, -0.05600212f, 
    0.01398515f, 0.00272370f, 0.01845424f, 0.02436325f, 0.04304463f, 0.06238468f, -0.12030951f, -0.16371307f, 
    0.41127944f, 0.01948610f, 0.06151026f, 0.10522664f, -0.09728268f, 0.03858596f, -0.09397658f, 0.05840237f, 
    0.06683924f, 0.14519449f, 0.15532583f, -0.01113702f, 0.13338375f, -0.05121308f, 0.01525470f, -0.05206458f, 
    0.00250760f, -0.06329569f, -0.04469722f, 0.00433191f, -0.37945855f, 0.08005977f, 0.21821022f, -0.01055176f, 
    -0.17843121f, -0.01721681f, 0.04894819f, -0.01833762f, 0.02301209f, 0.06991269f, 0.08331800f, -0.08312853f, 
    -0.00438961f, -0.03314309f, 0.07572033f, 0.05602898f, -0.05917782f, 0.00733590f, -0.10900573f, 0.03107368f, 
    -0.42327642f, 0.04654044f, 0.12797932f, -0.09695019f, 0.00418435f, -0.02220802f, 0.00976276f, 0.06248765f, 
    -0.06083563f, -0.12875307f, -0.03180603f, -0.03039668f, 0.07290144f, 0.00013552f, 0.04650586f, -0.02614300f, 
    0.05285369f, 0.12868527f, 0.03637011f, -0.03031578f, 0.46271843f, -0.12108167f, 0.31308901f, 0.52047640f, 
    0.03112199f, -0.03299252f, 0.05637113f, 0.07204534f, -0.06363524f, -0.05560347f, 0.10302460f, 0.06984263f, 
    -0.10155344f, -0.20121507f, 0.05918818f, -0.07991377f, -0.00415475f, 0.01047025f, -0.10146367f, 0.14341958f, 
    0.04475188f, 0.02572322f, 0.31913167f, 0.03722208f, 0.14285222f, -0.05414966f, 0.00453578f, 0.08557674f, 
    0.02322968f, 0.12486079f, 0.00377352f, 0.03735998f, 0.01987749f, -0.04537884f, -0.05521990f, 0.03612496f, 
    0.08801139f, 0.12262116f, 0.01029540f, 0.00338639f, 0.46750429f, -0.20106278f, -0.21788599f, 0.06968606f, 
    -0.27292264f, 0.27446306f, -0.02520610f, 0.02727954f, 0.00747003f, 0.01135673f, -0.03271565f, 0.01077793f, 
    -0.02207424f, -0.02567727f, 0.03602732f, -0.05079450f, -0.13644469f, -0.04028094f, 0.08067501f, 0.01374477f, 
    0.24694407f, 0.21809463f, -0.37191543f, -0.22096571f, -0.13117988f, 0.10389009f, 0.07077800f, -0.08210193f, 
    -0.03037669f, 0.07473584f, 0.05060377f, 0.10376596f, 0.14426380f, 0.05338680f, -0.11240879f, -0.17962559f, 
    0.00911867f, -0.01442777f, 0.07889943f, 0.00118325f, 0.27609041f, 0.03619960f, 0.05262538f, 0.27168518f, 
    0.38462865f, 0.16373584f, -0.10745626f, 0.09447215f, -0.01290280f, 0.16510421f, 0.06192981f, 0.05164900f, 
    -0.07473461f, -0.04813667f, 0.01803860f, 0.00396033f, 0.02966143f, 0.00655309f, -0.08753767f, -0.00286514f, 
    0.02069744f, 0.04637749f, 0.01566863f, -0.00740841f, -0.02039546f, -0.05479729f, -0.00149162f, 0.00946456f, 
    0.03217388f, -0.03299059f, 0.01691678f, -0.02952648f, -0.03426066f, 0.04155379f, -0.00202346f, -0.00379011f, 
    0.00273601f, -0.05030049f, -0.02937118f, -0.03186520f, 0.00063626f, 0.02406075f, -0.02219382f, -0.02412364f, 
    -0.01283852f, 0.03963234f, -0.01440457f, -0.03903382f, -0.02991598f, 0.04238902f, 0.03653464f, -0.00611186f, 
    -0.01566508f, 0.02803874f, 0.03339912f, -0.03018061f, -0.05902943f, -0.03809212f, -0.04263353f, -0.05235646f, 
    0.03368927f, 0.03462803f, -0.02670930f, 0.02440345f, -0.01792699f, -0.01659420f, 0.01256842f, -0.04554999f, 
    0.05516159f, 0.03794019f, 0.03321867f, -0.01090516f, 0.04391787f, 0.04844736f, 0.03494792f, -0.01018031f, 
    0.03384458f, -0.03861638f, -0.01856409f, 0.01137284f, 0.01559626f, -0.02819890f, 0.01901175f, -0.04038201f, 
    -0.03386777f, -0.05418534f, -0.04360418f, -0.05035767f, -0.05090007f, 0.01121495f, 0.02008662f, -0.01275772f, 
    0.02413801f, -0.01324008f, 0.04278775f, 0.04542814f, -0.00930253f, -0.00479163f, -0.04353882f, 0.04003805f, 
    -0.05801283f, -0.02094496f, -0.03193443f, -0.05987084f, -0.02633800f, 0.00265292f, -0.05852507f, -0.01637430f, 
    -0.04755979f, -0.02767505f, 0.03943412f, -0.00660922f, 0.02148509f, -0.04135232f, 0.02428981f, 0.02707904f, 
    0.02646416f, 0.00039414f, 0.03786525f, 0.02268396f, -0.00003727f, -0.02045761f, -0.01485428f, -0.04540048f, 
    -0.04498309f, 0.02716322f, -0.01844664f, -0.04667135f, -0.05559582f, 0.03701407f, -0.01115823f, -0.05329280f, 
    -0.02214726f, 0.00177467f, -0.00472476f, 0.02219287f, -0.05991443f, -0.05319536f, -0.02265610f, -0.02340547f, 
    -0.03001753f, -0.04162699f, -0.00040976f, 0.00361251f, 0.03188613f, 0.04299174f, -0.02591499f, 0.02655631f, 
    -0.01693166f, 0.03098376f, -0.02980252f, 0.03104637f, -0.01015494f, -0.00075501f, -0.02625913f, 0.04124331f, 
    -0.03792261f, -0.05895709f, 0.00301406f, -0.04552704f, 0.02949321f, 0.03811886f, -0.03820431f, 0.03538749f, 
    -0.05960240f, 0.04361288f, -0.03515645f, 0.03336160f, 0.03802874f, 0.02512622f, 0.02373507f, 0.01308123f, 
    -0.02974661f, -0.04100679f, 0.00536290f, 0.01655293f, 0.04109861f, 0.00976784f, -0.01034230f, 0.00707910f, 
    -0.01695033f, -0.04759149f, -0.01810594f, -0.00164851f, -0.04596464f, 0.00388749f, 0.02559965f, -0.01271252f, 
    0.00953677f, -0.00763046f, -0.01689641f, 0.00769894f, 0.00871532f, -0.04933542f, 0.00127457f, -0.03224760f, 
    0.01706461f, -0.03033192f, 0.02868643f, -0.00757095f, 0.04242183f, 0.03113962f, 0.01521119f, -0.05931015f, 
    -0.03839907f, -0.04327079f, -0.01791748f, -0.02190407f, -0.04309141f, 0.04154024f, -0.06260721f, -0.04066049f, 
    -0.05362801f, 0.00635788f, -0.04764184f, -0.00496384f, -0.04568755f, -0.02648207f, 0.01540019f, 0.02563057f, 
    -0.00671685f, 0.02554912f, -0.06297667f, -0.01283736f, -0.04694774f, -0.01261858f, -0.00158315f, -0.00683191f, 
    -0.01844824f, -0.01033200f, 0.00600849f, -0.01625143f, 0.04343393f, 0.03657872f, -0.03163312f, -0.04617862f, 
    0.00918647f, -0.02387773f, -0.00975863f, -0.05180079f, -0.00826352f, 0.00061594f, -0.06412744f, 0.02654708f, 
    -0.06035609f, 0.03222316f, -0.05367050f, -0.03891096f, -0.00590049f, 0.00159984f, 0.04816615f, -0.05372087f, 
    -0.05478429f, 0.00160209f, -0.05095883f, 0.01108498f, 0.03604127f, -0.02528901f, 0.01981611f, -0.03901340f, 
    -0.00657532f, -0.03484640f, 0.04240519f, -0.05401448f, -0.02036899f, -0.02008224f, 0.01131192f, 0.01525666f, 
    -0.03324621f, 0.01294352f, -0.02610722f, -0.06056295f, -0.04335618f, -0.01419818f, 0.01623374f, 0.02188660f, 
    -0.03884210f, 0.03377596f, 0.00969633f, -0.03573571f, -0.01915922f, -0.02342974f, 0.01531221f, -0.06029117f, 
    -0.02374123f, 0.00405962f, 0.03940458f, -0.05030929f, -0.03542454f, 0.00371616f, 0.01010446f, -0.04854858f, 
    -0.00739292f, -0.00172029f, 0.00913448f, 0.03197676f, 0.04717775f, -0.01624654f, -0.00711536f, -0.02803382f, 
    0.01086882f, -0.05972202f, -0.00122992f, 0.04057572f, 0.00637235f, 0.02635760f, 0.01145221f, -0.03908818f, 
    0.02623563f, -0.04195542f, 0.01209488f, -0.01305551f, 0.01106115f, 0.02575117f, 0.01400905f, 0.00600127f, 
    0.02154652f, 0.04726436f, -0.02597110f, 0.00665230f, 0.05617284f, 0.02701571f, 0.00741642f, -0.01436405f, 
    0.02224932f, -0.01262593f, -0.03225992f, 0.01116778f, -0.00594411f, 0.00930887f, -0.04968829f, -0.05672634f, 
    0.04677266f, -0.05364358f, -0.03268043f, 0.00599506f, 0.02509077f, -0.02550755f, -0.02687012f, 0.00025446f, 
    -0.01232499f, -0.22713841f, -0.08275873f, 0.00883951f, -0.03606207f, 0.06107036f, -0.17375405f, 0.10119059f, 
    -0.12194413f, -0.10748426f, -0.01912857f, 0.05208840f, -0.04907652f, -0.00726837f, 0.10500710f, 0.11695833f, 
    0.09924000f, 0.12531509f, 0.15095115f, 0.05319418f, 0.23337007f, -0.16377988f, 0.08469257f, 0.18424419f, 
    -0.05570710f, 0.12577063f, -0.08045068f, 0.06819515f, 0.00234269f, -0.07843009f, 0.05043437f, 0.02995387f, 
    0.21243227f, 0.03150916f, 0.09909524f, 0.14310281f, 0.17036591f, 0.03698311f, 0.04084769f, 0.13507549f, 
    0.20497568f, 0.07139722f, -0.00464214f, -0.09209759f, 0.05251529f, 0.08525728f, 0.11560052f, 0.20038450f, 
    -0.00788772f, 0.12589163f, 0.07540232f, -0.07706134f, 0.03617816f, 0.12252723f, -0.01795130f, -0.08078463f, 
    0.19702590f, 0.19947161f, 0.16265510f, 0.30406925f, 0.17562242f, 0.20744932f, -0.04468306f, -0.28258187f, 
    0.07997709f, -0.03696159f, -0.14949611f, -0.14814390f, -0.06055621f, -0.17365994f, 0.15739842f, 0.19690852f, 
    -0.00975803f, -0.01622382f, 0.10781857f, 0.06520917f, -0.13221863f, -0.17222537f, -0.01309496f, 0.00752275f, 
    -0.05030002f, -0.04842636f, -0.30701190f, 0.20893198f, 0.07125312f, -0.08129028f, 0.06974609f, -0.06465205f, 
    -0.19133657f, -0.02383542f, -0.07716453f, -0.17838052f, -0.12200756f, -0.25339290f, 0.01216296f, -0.13722044f, 
    0.15381645f, -0.16367897f, -0.08773936f, -0.28196815f, -0.26996145f, -0.10387447f, -0.16539708f, 0.03321547f, 
    0.00254155f, 0.07221063f, -0.09700322f, -0.25538975f, -0.14412872f, -0.15451266f, 0.02352578f, 0.08740999f, 
    -0.05282206f, 0.04200119f, -0.02554776f, 0.00590605f, -0.03867575f, -0.06199114f, -0.13215873f, -0.25285786f, 
    0.15767419f, 0.35202178f, 0.08885915f, -0.15271831f, -0.03175454f, -0.00989902f, -0.08889661f, -0.04023327f, 
    0.03861337f, -0.06657136f, 0.16911484f, -0.10319060f, -0.01782572f, -0.05873996f, -0.04109670f, 0.05127763f, 
    0.04185685f, -0.05161420f, -0.04283169f, 0.01524310f, -0.21175915f, -0.20917153f, -0.00985153f, 0.05818602f, 
    0.04327368f, -0.08650269f, 0.07339210f, -0.06725234f, -0.26240253f, -0.33291167f, -0.07963677f, -0.06831511f, 
    -0.09629037f, -0.03982844f, -0.14238186f, -0.04210167f, -0.13154818f, -0.12937550f, -0.27145925f, -0.22582427f, 
    0.04102330f, 0.02574670f, 0.10761278f, 0.00004286f, 0.01037636f, -0.03586268f, -0.05660332f, 0.09493721f, 
    0.12406851f, -0.08111278f, 0.13128538f, -0.05831594f, 0.05669613f, -0.01034826f, 0.00848798f, -0.05304578f, 
    0.16408226f, 0.00949236f, 0.00469570f, 0.08726374f, -0.18596762f, -0.24207377f, -0.23093830f, -0.09482566f, 
    0.08439822f, 0.20646733f, 0.00418304f, -0.28792584f, -0.18599816f, -0.03547159f, -0.08251461f, -0.11674074f, 
    -0.14484742f, -0.07101106f, -0.02812904f, 0.20577182f, 0.05071266f, -0.07668645f, -0.06928177f, -0.08902849f, 
    -0.05441063f, -0.23390369f, -0.40342879f, -0.30263042f, 0.20437200f, -0.02231555f, -0.04298688f, -0.08389951f, 
    -0.15956771f, -0.20481506f, 0.11424587f, 0.13687819f, 0.13373341f, 0.07491093f, 0.03952229f, -0.12214994f, 
    0.05182603f, -0.02449042f, -0.17529224f, 0.07562083f, 0.30901140f, 0.32678708f, -0.02040354f, -0.02916875f, 
    -0.06941576f, -0.02807758f, -0.02755257f, -0.08502233f, 0.08336872f, 0.10286250f, 0.03076622f, 0.03707153f, 
    0.04837299f, -0.16960070f, -0.13909137f, -0.08982387f, -0.03818184f, -0.19995341f, -0.05636879f, -0.09688018f, 
    0.22259028f, 0.20096533f, -0.06209571f, -0.02258182f, 0.05917023f, 0.07584558f, 0.01148618f, 0.22234298f, 
    0.00398896f, 0.27565384f, -0.00384990f, -0.02800320f, 0.07144946f, -0.05114422f, -0.09716649f, 0.02280605f, 
    0.03784313f, 0.10904577f, 0.06230708f, 0.10560977f, 0.14003667f, 0.33053792f, 0.05417762f, -0.21854107f, 
    0.09983037f, 0.11737667f, -0.13596660f, 0.13218690f, 0.00813788f, -0.14050390f, 0.06435591f, -0.05813956f, 
    0.02354107f, 0.14453360f, -0.09458639f, -0.02168795f, -0.05689567f, 0.00457167f, 0.10250442f, -0.18446647f, 
    0.28863943f, -0.14699386f, -0.06090891f, 0.12426678f, -0.06262287f, 0.01394738f, -0.21972413f, -0.22381733f, 
    -0.11123353f, -0.31881681f, 0.05069197f, -0.00672834f, 0.09495125f, -0.06604376f, 0.01366611f, 0.14784591f, 
    0.08111618f, -0.08223084f, -0.00920966f, -0.04061157f, 0.03203917f, -0.00016448f, 0.19118327f, -0.16553013f, 
    0.10798566f, 0.07472932f, 0.07073925f, 0.16358042f, 0.07857887f, 0.12224445f, 0.01716024f, 0.07696374f, 
    0.08818182f, 0.06147952f, -0.06594846f, 0.07718650f, 0.03473439f, -0.00044986f, 0.06975406f, 0.04358995f, 
    -0.05008665f, 0.03528669f, 0.00935051f, -0.03124244f, 0.03757363f, 0.01398322f, -0.05890461f, -0.02535999f, 
    0.02203245f, -0.03769217f, -0.05498273f, -0.00342117f, -0.03420315f, 0.01148793f, 0.03138857f, -0.05837502f, 
    0.00093223f, 0.02347286f, -0.04231681f, -0.00481263f, 0.00577165f, 0.01880697f, 0.02547237f, 0.00891800f, 
    -0.06415061f, -0.02736895f, -0.06475863f, -0.05701191f, -0.05139970f, 0.02747435f, -0.01713608f, 0.01633091f, 
    0.03057371f, -0.02133328f, -0.04388183f, 0.03991237f, -0.01858653f, -0.06664243f, -0.00044925f, -0.04112416f, 
    -0.00807480f, -0.04170828f, -0.01487260f, 0.03581666f, 0.00185853f, -0.04030699f, 0.04319429f, 0.01311574f, 
    0.01596278f, -0.04751683f, -0.01223808f, -0.02055980f, -0.00541074f, 0.04504699f, -0.06463670f, 0.04049258f, 
    0.00507689f, 0.04288220f, -0.04295881f, -0.04096559f, 0.01539595f, 0.03682579f, -0.06397582f, 0.02589937f, 
    -0.00908484f, -0.01947798f, -0.03564546f, -0.02160041f, -0.03555432f, 0.00480303f, 0.00131968f, 0.02201636f, 
    -0.03527094f, -0.01432549f, 0.00063369f, -0.04367403f, -0.00427958f, -0.06087144f, 0.01754309f, -0.03954616f, 
    -0.04255177f, 0.02050508f, 0.03149173f, 0.00473805f, 0.02109482f, -0.05183963f, 0.05112701f, 0.01989076f, 
    -0.01066858f, -0.02495586f, -0.04246746f, -0.00337296f, -0.04144678f, 0.04288121f, 0.03718881f, 0.03541072f, 
    -0.05576677f, -0.05366614f, -0.02441687f, 0.02138778f, 0.03425665f, -0.00938777f, 0.02269484f, -0.03474589f, 
    -0.02367281f, -0.03839815f, 0.03301871f, -0.02386331f, -0.01370395f, 0.02527920f, -0.03087443f, 0.03161848f, 
    0.01469768f, 0.03416667f, 0.00280683f, -0.05346008f, -0.05327392f, 0.00697637f, -0.01882859f, -0.01730310f, 
    0.00108787f, -0.06652871f, 0.01422405f, 0.01837241f, 0.04232566f, 0.00745770f, 0.01340653f, 0.02867548f, 
    0.02139407f, 0.00747211f, 0.00797197f, 0.00670785f, 0.02213205f, 0.01906973f, -0.04125617f, -0.06347706f, 
    0.03437191f, -0.06570414f, -0.05442224f, 0.02712927f, 0.03666244f, -0.04689913f, -0.00226951f, -0.01079189f, 
    0.00690292f, 0.01202842f, -0.04829298f, -0.04041811f, -0.01308837f, -0.06423936f, 0.02104197f, -0.04005689f, 
    -0.02518505f, -0.01159445f, 0.03848393f, -0.05341066f, -0.02247288f, -0.05514979f, -0.01888146f, -0.01001825f, 
    0.01468534f, 0.03315739f, 0.03707963f, -0.01537949f, -0.00596158f, -0.04691811f, -0.05503982f, -0.02245030f, 
    -0.03633941f, -0.04853481f, -0.01153657f, 0.04355912f, 0.00206720f, 0.02917144f, -0.04519076f, -0.03195696f, 
    -0.04954389f, 0.00295438f, 0.01103673f, -0.03054356f, 0.03404731f, 0.03023145f, 0.04807224f, 0.04627985f, 
    -0.03674614f, 0.00275584f, 0.04352600f, -0.01995373f, -0.05396066f, -0.06010471f, 0.00272953f, -0.00417193f, 
    -0.02314669f, 0.01022885f, 0.02171739f, 0.03703365f, 0.02341206f, -0.01214180f, -0.04434906f, 0.00499684f, 
    -0.00296388f, 0.01260828f, 0.05279457f, 0.05122445f, -0.01105364f, -0.04092441f, 0.03621900f, -0.03192307f, 
    -0.01803106f, -0.05092103f, 0.00418261f, 0.01463869f, -0.02852762f, -0.03625247f, -0.04577154f, -0.04091502f, 
    -0.02100311f, -0.02542881f, 0.02001350f, -0.06069804f, -0.04470804f, 0.02095008f, 0.00625108f, -0.04417735f, 
    -0.02107893f, 0.00306238f, 0.01910269f, 0.04021220f, 0.02010190f, -0.04302997f, -0.02863095f, -0.04245709f, 
    0.04267580f, -0.03323577f, -0.02397271f, -0.06018560f, 0.04198502f, -0.05445939f, 0.03299094f, 0.04075548f, 
    0.02208392f, -0.03908166f, 0.00389878f, 0.02861832f, 0.03901764f, -0.00177239f, 0.00164270f, -0.01731959f, 
    0.00070840f, 0.01249031f, -0.02665830f, -0.02441766f, -0.05670937f, -0.04320479f, 0.03312564f, 0.03616697f, 
    -0.05052342f, 0.02549764f, -0.01638500f, 0.00041408f, -0.06674917f, 0.03249824f, 0.03340222f, 0.03631600f, 
    0.01952982f, 0.02146639f, -0.01516950f, -0.01913118f, -0.02307307f, -0.00176493f, 0.04859097f, 0.04514039f, 
    0.04301043f, -0.04515444f, -0.02740077f, -0.00668185f, -0.01648733f, -0.02857114f, -0.06653854f, -0.04113808f, 
    -0.02162747f, 0.00749021f, -0.01615294f, -0.02180512f, -0.05140286f, -0.00401984f, -0.04777759f, -0.06050018f, 
    -0.01399916f, -0.00708180f, 0.00791616f, -0.00974314f, -0.02022734f, 0.03909161f, -0.00506110f, 0.01228972f, 
    0.03072319f, -0.00813593f, -0.01602062f, 0.02448234f, 0.02753472f, 0.03847950f, -0.01781046f, 0.01351503f, 
    -0.01571191f, -0.00249136f, -0.06856614f, 0.03917217f, 0.00458217f, 0.05091128f, -0.04670263f, -0.03601991f, 
    -0.05424906f, -0.04968808f, -0.00652478f, -0.02679955f, -0.00282362f, -0.02830289f, -0.05746165f, 0.03609379f, 
    -0.27577060f, 0.28010333f, 0.15007629f, 0.09971016f, -0.08315815f, 0.16908056f, -0.06647769f, 0.03402792f, 
    -0.00392042f, -0.09271570f, -0.07357809f, 0.12805627f, 0.09061784f, 0.02195720f, 0.12433825f, 0.09489863f, 
    -0.02111490f, 0.10159755f, -0.03368881f, 0.00040529f, 0.10939465f, -0.10012734f, -0.02514766f, 0.01115501f, 
    0.03093305f, 0.20960343f, -0.03265391f, 0.09964676f, 0.00686506f, 0.03037408f, 0.00913056f, 0.06077932f, 
    0.03580330f, 0.02425925f, 0.15413666f, -0.12567253f, 0.15053718f, 0.04253533f, 0.05254126f, 0.14291006f, 
    -0.46771589f, -0.14986771f, -0.18592867f, 0.25993556f, -0.03013049f, 0.00380952f, 0.04533292f, -0.14700983f, 
    0.04184656f, 0.04845731f, -0.04532164f, 0.06884140f, 0.16686361f, -0.06004936f, -0.09291938f, 0.07069473f, 
    0.04541308f, 0.05692904f, 0.05363563f, -0.04508006f, -0.13657627f, -0.20997508f, 0.04536504f, 0.33888841f, 
    0.04112729f, 0.07027861f, -0.16928846f, -0.19457604f, 0.00085975f, -0.08582928f, -0.04273289f, 0.15351515f, 
    0.05133383f, 0.06652875f, 0.05799953f, 0.09903194f, -0.05925976f, -0.12221827f, -0.02112188f, -0.16475774f, 
    0.21238844f, 0.01223418f, 0.01313597f, -0.16859116f, -0.20171627f, -0.16080138f, -0.05172998f, 0.07790775f, 
    -0.06444702f, -0.02329316f, 0.00530708f, 0.00699334f, -0.07292090f, -0.02398675f, -0.12068195f, 0.02026399f, 
    -0.09329963f, -0.06176588f, 0.01515149f, -0.02936043f, 0.11762288f, 0.16673324f, 0.20745684f, -0.05124179f, 
    0.13139018f, 0.03567394f, -0.02205131f, 0.02338080f, 0.02233599f, -0.00920926f, 0.05272304f, 0.14555429f, 
    0.04311731f, 0.19138771f, 0.20829383f, 0.07424694f, -0.05008453f, 0.09134901f, -0.00403749f, -0.13577580f, 
    -0.17863303f, -0.15131266f, -0.25347748f, 0.13256679f, 0.09486127f, -0.04840789f, -0.07993807f, -0.00987213f, 
    -0.01399617f, 0.06993201f, 0.01065444f, 0.03898109f, -0.03618043f, 0.05591005f, -0.01350223f, 0.02758486f, 
    0.01578221f, 0.08542074f, 0.08578244f, 0.11383992f, 0.02936779f, 0.12293132f, 0.08961446f, 0.08258059f, 
    0.02658131f, 0.02843067f, -0.00763501f, -0.01193465f, 0.00584052f, -0.08091730f, -0.00703137f, 0.08243475f, 
    -0.10958528f, 0.04255643f, 0.04027281f, 0.11675370f, -0.01415267f, 0.02016449f, -0.06013932f, -0.10215437f, 
    0.29107171f, -0.09215809f, -0.07830179f, 0.06170771f, 0.05885531f, -0.01537794f, 0.05090827f, 0.18792975f, 
    0.06771122f, 0.10297666f, 0.02915751f, -0.04271468f, 0.05552702f, 0.05679139f, -0.07005052f, 0.05015613f, 
    0.18386887f, 0.15738277f, 0.13389714f, 0.16164421f, 0.14320654f, 0.16493371f, 0.22608829f, -0.24614008f, 
    0.04309369f, -0.02928526f, -0.05175311f, -0.02565232f, -0.05724147f, 0.04885688f, -0.02797577f, 0.03337705f, 
    -0.02191618f, -0.11835425f, -0.02131583f, 0.07601717f, 0.20790955f, 0.13314772f, 0.11419831f, -0.00205288f, 
    -0.03686015f, -0.23795670f, -0.22436611f, 0.02386300f, -0.01956064f, -0.01553824f, -0.05824088f, -0.05891037f, 
    -0.15282528f, -0.11185315f, -0.15800837f, 0.09899960f, 0.07094458f, -0.07019167f, -0.20766197f, 0.31807372f, 
    0.00356755f, -0.02036807f, 0.06971468f, 0.02222843f, -0.29402915f, -0.26542887f, -0.12160785f, 0.42143163f, 
    0.02944703f, 0.18877232f, -0.01354122f, 0.05062284f, -0.08777082f, 0.07636236f, 0.02816368f, 0.00563272f, 
    -0.07924352f, 0.00618538f, -0.06877442f, 0.03960882f, -0.13417016f, -0.02988524f, -0.20760140f, -0.10221491f, 
    -0.19894636f, -0.11411640f, -0.14116073f, 0.19593140f, 0.14607300f, -0.02793811f, 0.03162671f, 0.03533782f, 
    -0.02833917f, 0.09893791f, -0.00670769f, -0.04086027f, 0.07704217f, 0.00308481f, -0.00293445f, -0.05740497f, 
    -0.07876562f, -0.09637758f, 0.04562028f, 0.09646620f, -0.03847267f, -0.06950660f, 0.01157471f, 0.21047474f, 
    -0.09854305f, 0.02688389f, -0.17703784f, -0.05110813f, -0.05252199f, -0.02674311f, 0.04008047f, 0.04572372f, 
    0.12135503f, 0.08068885f, 0.00412066f, -0.04624351f, 0.01847246f, 0.06049939f, -0.12683323f, -0.08658406f, 
    0.04515481f, 0.29880160f, 0.43653956f, 0.11769007f, -0.03133208f, -0.01528746f, -0.13360047f, -0.17583092f, 
    -0.09091429f, -0.17185174f, -0.02884061f, 0.02309464f, 0.10960885f, 0.19376701f, 0.10128186f, 0.05183014f, 
    -0.06957415f, 0.04610840f, 0.11235370f, 0.08469158f, -0.27334180f, 0.02795593f, -0.32374820f, 0.38817620f, 
    -0.02185517f, -0.10574572f, -0.13714318f, 0.09972516f, 0.10034414f, -0.12331232f, 0.03222634f, 0.06829509f, 
    0.02543581f, 0.00199202f, -0.02573358f, -0.12730420f, -0.07010064f, -0.00445691f, 0.17260876f, 0.02299233f, 
    0.03649028f, -0.03354928f, 0.03041647f, 0.01756657f, -0.05497243f, -0.01364159f, 0.00422204f, 0.04700194f, 
    -0.02871764f, 0.00971098f, 0.04614865f, -0.01029265f, 0.01754699f, -0.05466413f, -0.01411842f, 0.03745652f, 
    -0.04488982f, -0.01539779f, 0.00936965f, -0.01281672f, -0.02218356f, -0.04505819f, -0.01818457f, -0.00573882f, 
    -0.05743408f, 0.02548556f, 0.00906976f, -0.04342933f, -0.01755711f, 0.04236543f, 0.00984406f, -0.04016172f, 
    -0.04002712f, 0.01670408f, -0.02338973f, 0.01401619f, 0.04473810f, -0.03814517f, 0.01504578f, -0.03496054f, 
    0.01946874f, -0.03594613f, 0.02137625f, 0.04005694f, 0.02934802f, -0.04664717f, -0.03373763f, -0.04283059f, 
    0.01412027f, 0.03330852f, -0.00902340f, -0.00278351f, 0.01949643f, -0.00003733f, -0.05802066f, 0.00795836f, 
    0.00602919f, 0.00247428f, 0.02027040f, -0.04520357f, -0.02445228f, -0.00029046f, -0.01549530f, 0.01905970f, 
    0.02255224f, -0.05096933f, -0.01058161f, 0.03268136f, -0.02734364f, -0.00361648f, -0.01713904f, 0.03163451f, 
    -0.02421994f, -0.02993907f, 0.03167034f, 0.03660856f, 0.02729555f, 0.03025363f, -0.03012727f, -0.00330506f, 
    0.03284756f, -0.00365636f, -0.03335633f, 0.04959683f, -0.00256699f, 0.01532275f, 0.05266770f, 0.05040338f, 
    -0.00277334f, 0.02768899f, -0.02421030f, 0.05724885f, -0.03008736f, 0.01862314f, 0.01981580f, 0.01480471f, 
    -0.04566232f, -0.03181510f, -0.04286205f, -0.05141055f, -0.01514035f, -0.03841100f, -0.04996864f, -0.04655067f, 
    0.04061954f, -0.01455672f, 0.01042523f, -0.05242571f, -0.00034908f, -0.03022858f, -0.01505905f, -0.03368225f, 
    -0.03741657f, 0.03726511f, 0.02523168f, -0.05944826f, 0.00072109f, -0.00982127f, -0.01454463f, -0.00017158f, 
    -0.02923411f, 0.01358836f, 0.01573693f, 0.00291877f, -0.02910453f, -0.03601423f, -0.01820390f, -0.01004706f, 
    0.03174872f, -0.02249023f, 0.04550865f, -0.01022085f, 0.03996601f, 0.03795349f, -0.00554925f, -0.00564613f, 
    -0.04363867f, 0.00722033f, -0.01579227f, 0.01788850f, -0.02133833f, -0.00243132f, 0.02859429f, -0.04723226f, 
    0.00297412f, -0.05613851f, -0.05652413f, -0.00465830f, 0.04609314f, -0.04225894f, -0.01012207f, 0.01695748f, 
    -0.03786645f, -0.03215659f, -0.01031901f, -0.01919130f, -0.03282031f, 0.04081005f, 0.02546507f, -0.04186901f, 
    -0.04704428f, 0.04366226f, -0.05608470f, -0.05688310f, -0.02797298f, -0.00059586f, 0.00361636f, -0.05491900f, 
    -0.02013737f, -0.06123450f, -0.01146573f, -0.00051230f, 0.04164714f, 0.03375558f, -0.03408085f, 0.04507210f, 
    0.00259894f, -0.04230590f, -0.05666885f, 0.01030361f, 0.01529598f, -0.01226978f, 0.01304562f, -0.02230473f, 
    -0.01893394f, 0.02518835f, 0.02544925f, 0.04248355f, 0.00558794f, 0.03755863f, 0.04381573f, 0.00288329f, 
    -0.01205869f, -0.02719697f, 0.00212613f, -0.00820605f, 0.01756218f, 0.03010013f, -0.01260820f, 0.03006835f, 
    -0.04547929f, -0.03695434f, -0.05131466f, 0.03276908f, -0.01085313f, 0.04084430f, -0.00498184f, -0.04997288f, 
    -0.04482273f, -0.04478178f, 0.01045361f, 0.04141696f, 0.01857078f, 0.00981250f, 0.04322346f, 0.00765345f, 
    -0.02806279f, -0.01554325f, 0.00870611f, 0.03185791f, -0.02730817f, 0.02308594f, 0.02228564f, -0.05527194f, 
    0.02620918f, -0.03478388f, -0.04875939f, 0.03385342f, -0.05357038f, -0.05905873f, 0.00111864f, -0.00311272f, 
    -0.00290242f, 0.03147151f, 0.00779248f, -0.02168853f, -0.05117681f, -0.06091607f, -0.04631761f, 0.04042014f, 
    0.04378726f, -0.03595715f, 0.03438326f, 0.00846211f, -0.02174557f, 0.03845101f, -0.05082589f, 0.04559333f, 
    0.02786125f, -0.00847690f, 0.00333046f, -0.03402279f, -0.05668296f, -0.01236861f, -0.00541378f, 0.01516427f, 
    -0.01983308f, 0.02089198f, -0.05794873f, -0.01790293f, 0.03452825f, 0.03199007f, -0.01718893f, -0.04752468f, 
    -0.04754418f, 0.00659477f, -0.04407502f, 0.00095283f, -0.01767657f, 0.03576824f, 0.01995253f, -0.01717835f, 
    -0.02489549f, -0.05015707f, 0.02111105f, 0.04240474f, 0.04782990f, -0.04884957f, 0.00768572f, -0.05889009f, 
    0.00778437f, -0.02400850f, 0.00782988f, 0.03120949f, -0.01618206f, -0.01904127f, -0.02521207f, -0.04576599f, 
    -0.05851349f, -0.05329149f, 0.00738899f, -0.04135679f, -0.04689965f, -0.03998954f, -0.03323216f, -0.01728629f, 
    0.00323460f, 0.00205086f, 0.02799839f, 0.03667820f, 0.00783670f, 0.02175660f, -0.01187858f, 0.01996161f, 
    -0.00125281f, -0.01152658f, -0.04291862f, -0.05886254f, 0.00749511f, -0.03779767f, -0.00153157f, -0.04416602f, 
    0.02723162f, 0.02171369f, -0.03496137f, 0.00829896f, 0.03841406f, 0.03623416f, 0.01020012f, 0.01072437f, 
    0.04325182f, -0.31194016f, 0.19472131f, -0.28403980f, 0.10164791f, 0.00070620f, -0.16201530f, 0.13065800f, 
    -0.02824236f, -0.05100466f, 0.19672590f, 0.01712873f, 0.07064024f, 0.00663883f, -0.08715539f, 0.05683276f, 
    0.04190246f, 0.04430824f, 0.10511196f, -0.01287436f, -0.20211893f, 0.03475175f, -0.05425029f, 0.20206149f, 
    0.04098859f, -0.03915298f, -0.09379698f, 0.07184780f, 0.02190240f, 0.12720175f, 0.06923148f, -0.02859910f, 
    0.20307690f, 0.03137484f, 0.12255429f, -0.03245691f, 0.17904699f, -0.00426582f, 0.03023790f, 0.06674884f, 
    0.26217142f, -0.18296126f, 0.38450241f, -0.07238491f, -0.20689426f, -0.16832794f, -0.00337418f, -0.05296908f, 
    -0.05061675f, -0.02294416f, 0.09585296f, 0.02044765f, 0.06509662f, 0.01144966f, -0.28009892f, -0.15717141f, 
    -0.01205375f, 0.05863130f, 0.01353735f, -0.05568997f, 0.07619464f, 0.06799515f, 0.30411607f, -0.01849348f, 
    -0.07157120f, 0.14099720f, -0.01498001f, -0.18096815f, -0.16113222f, -0.01652382f, 0.07366733f, 0.11726194f, 
    0.11319879f, 0.06675647f, 0.10651067f, 0.07780758f, -0.06818458f, 0.02267672f, -0.03015344f, 0.00565686f, 
    0.07214019f, -0.13687359f, -0.17945912f, -0.20957424f, 0.19638960f, 0.00611647f, -0.02145414f, 0.02703316f, 
    0.10163451f, 0.12618847f, 0.05341869f, -0.06199272f, -0.02737159f, -0.00046104f, -0.01428180f, -0.05478847f, 
    0.01604665f, 0.01913443f, 0.07712628f, -0.02636842f, -0.19680037f, 0.10593206f, -0.21342406f, 0.13835055f, 
    0.27020153f, 0.15392531f, -0.16824751f, -0.09534164f, -0.00759564f, -0.00967725f, 0.13889712f, 0.03922835f, 
    0.01817018f, -0.01757552f, 0.20174164f, 0.06927654f, 0.10455240f, -0.15282054f, 0.03706644f, 0.13300489f, 
    0.04313574f, -0.11642274f, -0.05969242f, -0.02001614f, -0.08067636f, 0.11871963f, 0.01277697f, -0.09875348f, 
    -0.02947892f, 0.11679087f, 0.12976013f, 0.04115288f, -0.01469915f, -0.04070008f, -0.08835953f, -0.00114399f, 
    -0.06571251f, -0.10197424f, -0.00732277f, 0.00679373f, 0.08830396f, 0.10125644f, -0.08792395f, -0.15337817f, 
    0.25519487f, 0.09420887f, -0.03657547f, 0.01678503f, -0.03932318f, -0.02132605f, 0.20445973f, 0.00162141f, 
    -0.02124656f, 0.02296803f, 0.02588073f, 0.05473132f, -0.08541019f, -0.07265724f, -0.09985498f, -0.04002939f, 
    -0.06829810f, 0.05125829f, -0.24712038f, -0.00916578f, -0.03054102f, -0.07818112f, 0.13623878f, 0.17662178f, 
    -0.04193759f, 0.12516327f, 0.08919735f, -0.03413109f, 0.18394063f, 0.05878246f, -0.07000989f, -0.18234727f, 
    0.14764166f, -0.00731818f, 0.07661493f, 0.22306025f, -0.19497097f, -0.03877818f, -0.21565607f, -0.12520573f, 
    0.16622324f, 0.01728786f, 0.06343468f, 0.00474179f, -0.01053142f, 0.09034181f, 0.03227922f, -0.05960981f, 
    -0.08690028f, 0.03061591f, 0.06775391f, -0.03218163f, -0.04099131f, -0.00903217f, 0.00102052f, 0.10809167f, 
    -0.10728079f, 0.07562921f, 0.03742926f, -0.29859570f, 0.27271357f, 0.05566115f, 0.03292174f, -0.04277312f, 
    0.05550178f, 0.04894744f, -0.02667952f, -0.16994070f, 0.10387386f, 0.03997206f, -0.10087974f, -0.09581713f, 
    0.06088020f, 0.14762092f, 0.07340364f, 0.14153320f, 0.46760690f, -0.03556865f, -0.05757635f, 0.07546135f, 
    -0.04834776f, -0.03094014f, 0.20346759f, -0.10253182f, -0.03536300f, -0.04634800f, 0.07260799f, 0.10253260f, 
    -0.00496306f, -0.03068629f, -0.03932700f, -0.01698510f, 0.04283752f, -0.01370827f, 0.05128079f, -0.15182126f, 
    0.07587930f, -0.02719937f, 0.00398551f, -0.11694288f, -0.17978072f, 0.00356049f, -0.03154751f, -0.06037509f, 
    0.02233075f, 0.02267070f, 0.09368096f, -0.04513601f, -0.03776492f, -0.00386081f, 0.00066781f, -0.08128885f, 
    0.04252169f, 0.10298868f, 0.17507945f, 0.13100019f, -0.07170521f, 0.01171830f, -0.40094247f, 0.04944316f, 
    -0.05139877f, 0.00181259f, -0.01361593f, 0.24684542f, -0.21539952f, 0.09505174f, 0.03904226f, 0.08212417f, 
    0.03399219f, 0.05861426f, -0.05484584f, 0.00028602f, -0.09032911f, 0.00286889f, 0.02004219f, 0.04755237f, 
    -0.34826145f, 0.31351107f, 0.19340864f, 0.06866616f, 0.25460416f, 0.04290667f, -0.01771201f, -0.13860592f, 
    -0.03480640f, -0.04552906f, 0.01944853f, -0.00293521f, 0.05096811f, -0.01138806f, 0.25400221f, 0.12484385f, 
    0.12143961f, -0.05647698f, 0.05011290f, -0.01296148f, 0.47120601f, -0.19141452f, 0.13703492f, -0.40069437f, 
    -0.04615017f, 0.02349058f, 0.07314643f, 0.00604191f, -0.31072065f, -0.07173189f, 0.13419391f, 0.01509649f, 
    -0.06226569f, 0.00064331f, 0.05221399f, -0.21897031f, -0.00172919f, 0.12131947f, -0.03180783f, 0.13186346f, 
    -0.03092377f, -0.01933799f, 0.29470718f, 0.08459055f, 0.01916731f, 0.02730762f, 0.09714181f, 0.05771129f, 
    -0.15465567f, 0.11700775f, 0.10701491f, 0.02622081f, -0.00747252f, 0.04339971f, 0.04474796f, 0.09512556f, 
    0.10554314f, -0.13184169f, 0.11704576f, 0.01546411f, -0.22512138f, -0.04304802f, 0.15522936f, 0.03967433f, 
    -0.02046167f, -0.05171627f, 0.07061943f, 0.09900501f, -0.04121295f, 0.17069113f, 0.05792402f, -0.01016195f, 
    -0.02866895f, -0.05054033f, 0.13954826f, 0.11550120f, 0.09142524f, 0.12668957f, -0.01343862f, 0.19959748f, 
    0.15876991f, -0.14395848f, 0.34274089f, 0.14726223f, 0.03967031f, -0.13042174f, 0.12634537f, 0.10978914f, 
    -0.00102164f, -0.04543746f, -0.09220602f, -0.07099941f, 0.01160522f, -0.04535589f, -0.06534000f, 0.02456926f, 
    0.21184067f, 0.06507736f, 0.03227681f, 0.11171576f, 0.54328591f, 0.15906982f, 0.06225371f, 0.09852075f, 
    0.03735533f, 0.00187969f, -0.17220849f, -0.08185405f, 0.10043575f, -0.03271258f, 0.18990530f, 0.08940393f, 
    0.00980558f, 0.05266654f, -0.07615556f, 0.11852533f, -0.15003081f, -0.16567147f, -0.15237081f, -0.24227981f, 
    -0.68988895f, -0.21351627f, 0.30289322f, 0.00908337f, 0.25074610f, 0.21485440f, -0.00802225f, -0.22119901f, 
    -0.11970655f, -0.00651166f, 0.01182998f, -0.10100952f, 0.16088969f, -0.03940778f, 0.03516821f, -0.04819866f, 
    0.00687476f, -0.25443983f, -0.14262946f, -0.12526309f, 0.33773860f, -0.12999506f, -0.30999944f, 0.08465704f, 
    -0.11793669f, -0.00314223f, -0.35309264f, -0.06372731f, -0.03705624f, -0.29792285f, 0.04167047f, -0.02501252f, 
    0.04093526f, -0.21611641f, 0.26342240f, 0.04135034f, -0.07746938f, -0.12790009f, -0.08437865f, -0.04315088f, 
    0.21275669f, -0.13802493f, 0.15935630f, 0.08304650f, -0.02144110f, 0.08222403f, 0.01274895f, -0.00601822f, 
    0.04363055f, -0.00202078f, -0.07083129f, 0.03586721f, -0.01299507f, -0.05595389f, -0.11958767f, 0.02543354f, 
    -0.20103975f, -0.11137145f, -0.15169656f, 0.05610180f, -0.60787272f, -0.20913497f, -0.15477450f, -0.27221411f, 
    0.36936086f, -0.16671194f, -0.15287960f, -0.11014783f, -0.10702572f, -0.10482128f, 0.20737278f, -0.01063964f, 
    0.01573999f, -0.02540224f, 0.13743602f, 0.05173137f, -0.21383032f, -0.10921996f, -0.33124784f, -0.17614321f, 
    -0.10144705f, 0.06159681f, 0.03792873f, 0.11700878f, -0.03853189f, -0.10456396f, 0.10068633f, 0.00030447f, 
    -0.03367771f, 0.04452970f, 0.06239874f, -0.06883751f, 0.04567952f, -0.09248810f, -0.13733181f, -0.08925475f, 
    0.22664076f, 0.09569526f, 0.06121729f, 0.21906249f, 0.12667249f, 0.09545371f, -0.21703078f, -0.18784103f, 
    0.31328344f, -0.09205473f, -0.20341502f, -0.28821495f, 0.13707012f, -0.05078598f, -0.03251009f, -0.03006211f, 
    0.08753504f, -0.09362791f, 0.15971199f, -0.01290225f, 0.02311631f, -0.10386148f, -0.00246205f, -0.04776160f, 
    0.36299178f, 0.04499061f, -0.28264067f, -0.39104605f, -0.28367618f, -0.07417956f, -0.45393768f, -0.11761322f, 
    -0.00055794f, 0.19320172f, 0.18572336f, 0.18783137f, 0.07793301f, 0.15489663f, 0.12241564f, -0.05679688f, 
    0.19678085f, 0.14636198f, 0.13448244f, 0.03098217f, 0.05052256f, 0.04845027f, 0.21687764f, 0.00846902f, 
    -0.08043002f, 0.13061352f, 0.01300931f, -0.13685116f, -0.05441056f, 0.13915449f, -0.07010562f, 0.05602262f, 
    0.13061555f, -0.02905826f, -0.15382910f, 0.01910318f, -0.22344805f, -0.21434918f, 0.05451980f, -0.03389733f, 
    0.02359791f, -0.09630772f, 0.21730343f, 0.09356096f, -0.08412229f, -0.00817706f, 0.09149258f, 0.06050646f, 
    0.03483315f, 0.13516028f, -0.00502422f, -0.06337355f, 0.01249788f, -0.07277701f, 0.05295161f, 0.01522141f, 
    0.27018830f, 0.06788258f, 0.01416810f, 0.24594513f, 0.27713650f, 0.07020467f, 0.00383447f, 0.21085794f, 
    0.13856214f, -0.05361831f, 0.04016099f, 0.15732583f, -0.06136635f, 0.02429248f, -0.14458567f, -0.09950361f, 
    0.02423820f, 0.03169734f, -0.02519088f, -0.02018449f, -0.06923290f, 0.04359662f, -0.18953933f, -0.00103611f, 
    0.07018320f, 0.07968592f, 0.18755466f, -0.03149031f, 0.19002585f, -0.24682400f, -0.21682623f, 0.01122669f, 
    0.12649190f, 0.05494579f, 0.08207444f, -0.06805760f, -0.06436211f, -0.07350530f, 0.10846942f, -0.06555452f, 
    0.02554019f, 0.05307257f, 0.06283080f, 0.05213409f, 0.14093812f, 0.03944510f, 0.53991914f, -0.22279954f, 
    0.02429137f, -0.09133197f, 0.25520051f, 0.00028284f, -0.15987140f, 0.03607859f, -0.07255350f, -0.04152849f, 
    -0.01525844f, -0.02684125f, 0.05729312f, 0.11640198f, 0.20682032f, -0.06649020f, 0.06563598f, 0.08773935f, 
    0.39293894f, -0.10978957f, 0.13284415f, 0.14805250f, -0.41654506f, 0.10287751f, 0.02635971f, -0.11258273f, 
    0.23738050f, 0.00125036f, -0.13420939f, -0.09600242f, 0.02761180f, 0.00441413f, 0.13256197f, 0.02056352f, 
    0.05194642f, 0.03779113f, 0.10085890f, 0.08574244f, -0.38394716f, -0.57875544f, 0.21102655f, -0.30451554f, 
    0.05328526f, 0.08932960f, 0.16570514f, 0.01296517f, 0.00317021f, 0.09485047f, -0.00457012f, -0.00584109f, 
    0.04179865f, 0.04835517f, 0.14830534f, 0.11122312f, 0.04428126f, 0.02977247f, 0.15814482f, 0.18226255f, 
    -0.24113481f, -0.11469152f, -0.25892168f, 0.20211937f, -0.24269150f, 0.04063533f, 0.07387837f, 0.03837676f, 
    -0.20323035f, 0.19233212f, -0.06354466f, -0.00247940f, 0.09766334f, 0.03793400f, 0.01701597f, 0.01703141f, 
    0.21371615f, -0.01866733f, 0.00067165f, 0.11361368f, -0.09076520f, -0.45160812f, -0.63302779f, -0.06576996f, 
    -0.09070725f, -0.04040548f, -0.04064066f, 0.02159499f, 0.12731846f, 0.09789370f, -0.04788087f, 0.17094488f, 
    -0.15770343f, -0.01208159f, -0.03571023f, 0.01354404f, 0.07794282f, 0.05318895f, -0.16102193f, -0.08683816f, 
    0.20443560f, 0.23707478f, 0.10475346f, 0.05269456f, -0.00317761f, -0.00183059f, -0.10565482f, -0.15235870f, 
    -0.11781427f, 0.01319575f, 0.04280107f, 0.04243084f, -0.00447933f, 0.06288303f, -0.01482617f, 0.13302441f, 
    0.09580038f, -0.15146545f, 0.00878367f, 0.00496083f, 0.01054423f, -0.07285628f, 0.23562685f, 0.06298497f, 
    0.12557189f, -0.03060725f, -0.07151351f, -0.09076371f, 0.07397211f, -0.02937706f, 0.10271747f, 0.15044563f, 
    0.00212897f, 0.21697895f, 0.11303554f, -0.10615786f, -0.01552809f, -0.12778141f, -0.02261173f, -0.09580061f, 
    -0.09455051f, 0.21032506f, -0.16292079f, -0.07143722f, -0.02320721f, 0.02234919f, 0.20097028f, -0.14398225f, 
    0.29930165f, 0.00687445f, -0.05581542f, 0.14400311f, -0.19384617f, 0.05902969f, 0.07599448f, 0.01423440f, 
    -0.09524717f, 0.15441421f, 0.03895129f, 0.16342817f, 0.09625117f, 0.08261531f, 0.06837483f, 0.13606705f, 
    0.13514318f, -0.03736274f, 0.04004665f, -0.09083716f, -0.00930246f, -0.01338723f, 0.04485310f, 0.01568232f, 
    -0.01828111f, 0.06241330f, 0.07879415f, 0.12382761f, 0.13268201f, -0.02654901f, -0.06871130f, -0.04126270f, 
    0.24605441f, -0.42076528f, 0.37198934f, -0.22868855f, -0.00258336f, 0.01887953f, -0.00328804f, 0.18552944f, 
    0.09376045f, 0.09549402f, 0.04202956f, 0.09793350f, 0.02763219f, -0.11738094f, -0.01246853f, 0.04700546f, 
    0.20498723f, 0.05921221f, 0.07470269f, 0.13966934f, 0.40516171f, 0.14953345f, 0.21307954f, 0.09982304f, 
    0.09923648f, -0.08722175f, -0.04282984f, -0.09181239f, -0.03780449f, -0.02235033f, 0.06509777f, 0.05938440f, 
    -0.00947033f, -0.04142452f, -0.00263626f, 0.10983977f, 0.10393126f, -0.11566313f, 0.01856915f, 0.02274467f, 
    0.17120576f, -0.03297561f, -0.00546159f, 0.13060437f, 0.11722495f, -0.05554473f, -0.12891501f, -0.02715951f, 
    -0.08986218f, -0.09412190f, 0.03275429f, 0.14219525f, -0.01170088f, -0.01334449f, -0.01884115f, 0.20301571f, 
    -0.01671720f, -0.12183855f, -0.13750564f, -0.17006779f, -0.22235198f, 0.45077354f, -0.21794248f, -0.12303199f, 
    -0.11074587f, 0.29882509f, -0.14735788f, 0.04802090f, 0.07997774f, 0.23224033f, -0.13018109f, -0.01929222f, 
    -0.02161358f, -0.00697319f, -0.02240750f, -0.00029204f, 0.00325175f, -0.08917590f, -0.08590239f, 0.07030014f, 
    -0.01560466f, -0.13083057f, -0.30402628f, -0.31134030f, -0.05514091f, -0.01513254f, -0.15934889f, 0.12416877f, 
    -0.10263968f, 0.08762710f, -0.02439266f, 0.02045713f, 0.10104506f, -0.05722937f, 0.03550598f, -0.03694865f, 
    -0.02451878f, -0.06585241f, -0.07872871f, 0.09022381f, -0.32250944f, -0.30573371f, 0.25533605f, -0.45784226f, 
    -0.01909140f, -0.15250492f, -0.11812019f, -0.31121376f, -0.21230678f, -0.05960846f, -0.12783910f, -0.01077740f, 
    0.08407594f, -0.04238304f, 0.05392852f, -0.13322122f, 0.17831217f, -0.01746162f, -0.26811460f, 0.15130860f, 
    -0.37925157f, -0.26750830f, -0.04311489f, 0.02792121f, -0.21682452f, -0.01096738f, -0.13310103f, -0.13453209f, 
    0.00654556f, -0.07361382f, -0.05554427f, -0.10464151f, 0.03827332f, 0.10931635f, 0.08222862f, -0.03361805f, 
    -0.06675388f, -0.03598235f, -0.04111150f, 0.02123397f, -0.14782493f, 0.44846055f, 0.07004124f, -0.05376993f, 
    -0.36123428f, -0.14399123f, -0.19326231f, -0.17107937f, 0.05787690f, 0.08595145f, -0.00372374f, -0.06864210f, 
    0.04046726f, -0.07927881f, -0.16907139f, -0.02254699f, 0.09594359f, -0.04092108f, 0.08924656f, 0.01102229f, 
    -0.02914834f, 0.01559858f, -0.05850359f, -0.07112025f, 0.01163195f, -0.00729389f, -0.04955009f, 0.04774911f, 
    -0.01477997f, -0.00087992f, -0.03733696f, -0.05836904f, 0.01741919f, -0.05477859f, -0.06139472f, -0.00382991f, 
    0.02510352f, -0.03809916f, -0.00617042f, -0.00558405f, 0.03669867f, -0.05493889f, -0.01089199f, -0.06812845f, 
    -0.00430725f, 0.01157191f, -0.04439049f, -0.04747738f, -0.02652742f, 0.01181027f, 0.04430769f, -0.04896076f, 
    -0.02205195f, -0.05168261f, 0.01389780f, -0.00402333f, -0.00738383f, 0.00964174f, -0.05695792f, -0.03123059f, 
    -0.00721169f, 0.00679980f, -0.01025980f, 0.04200209f, 0.02847947f, -0.01414999f, 0.01772915f, 0.04074955f, 
    0.05448856f, -0.04551322f, -0.04539880f, -0.01746455f, -0.05770547f, -0.04906043f, 0.04665202f, 0.02972323f, 
    0.03087337f, -0.03421657f, 0.02333399f, 0.00711951f, 0.04567372f, -0.05707189f, -0.01972299f, 0.01663765f, 
    -0.04094348f, 0.04543760f, 0.02797071f, 0.01948607f, -0.01390151f, -0.00338446f, -0.01024097f, 0.01961901f, 
    0.00306265f, -0.01974394f, -0.02384183f, -0.02555325f, 0.03442002f, 0.00092238f, -0.05761370f, 0.03092404f, 
    0.02365142f, 0.04670899f, 0.03820918f, 0.01217680f, 0.02742750f, 0.01240838f, 0.01988744f, 0.01538588f, 
    0.05403903f, 0.02504938f, 0.00479088f, -0.01417373f, -0.00433640f, -0.05213569f, -0.05323223f, -0.04786761f, 
    -0.05660369f, 0.04809557f, 0.01997770f, -0.02815618f, -0.01434239f, -0.06119022f, -0.01543293f, 0.03553562f, 
    0.02450563f, -0.00827616f, -0.01879833f, 0.00185522f, -0.01089308f, 0.00055393f, 0.02029840f, 0.00383387f, 
    -0.05985532f, 0.00836391f, -0.02841046f, -0.01383116f, -0.02479033f, -0.01148803f, 0.01899172f, 0.04820444f, 
    -0.00322912f, -0.05181612f, 0.01559831f, 0.01069667f, 0.03662553f, -0.07100209f, -0.04859965f, -0.01443634f, 
    0.01382845f, -0.07781118f, -0.01278307f, -0.06163004f, 0.05090411f, -0.01953011f, 0.02430436f, -0.04811448f, 
    -0.05644435f, -0.03217960f, -0.03413054f, -0.06178680f, -0.01579783f, -0.04190537f, -0.00650678f, 0.04906962f, 
    -0.03824825f, -0.01947558f, -0.01574852f, -0.01141334f, -0.02234258f, 0.01721173f, -0.00912650f, -0.04866943f, 
    -0.05491639f, -0.01376440f, -0.06017150f, -0.04547440f, 0.01748395f, -0.04087913f, 0.03758262f, -0.01618292f, 
    0.03214400f, 0.03196175f, -0.04184218f, -0.04850593f, -0.05350225f, 0.00801021f, 0.00778225f, 0.00532635f, 
    -0.03288218f, -0.03970005f, -0.01943711f, 0.02572438f, -0.03624773f, -0.03591702f, -0.02833491f, -0.00500444f, 
    -0.00382353f, 0.01898453f, -0.04229196f, -0.06970301f, -0.05518490f, -0.04189396f, -0.00937749f, 0.02002396f, 
    0.00191048f, -0.01626854f, 0.04435094f, 0.02659689f, -0.00435773f, 0.04573998f, -0.00761775f, -0.00301191f, 
    0.03820482f, 0.03199286f, 0.02456362f, 0.00711255f, 0.01267337f, 0.02702811f, 0.03172871f, 0.01998683f, 
    -0.02072768f, -0.03536456f, -0.03369407f, -0.00796990f, -0.04593256f, -0.02263350f, 0.02258536f, 0.00533861f, 
    0.03106938f, 0.03142574f, -0.02932267f, -0.01981968f, -0.04744262f, -0.01666391f, -0.04742567f, 0.01801661f, 
    0.00630598f, 0.05835357f, 0.02071165f, -0.03812176f, 0.04290417f, -0.02365532f, -0.00151769f, 0.04015065f, 
    -0.01582910f, -0.04543053f, 0.02712139f, -0.06857934f, 0.03204964f, -0.05945629f, -0.00385772f, -0.06167093f, 
    0.04221990f, 0.00801899f, -0.01530850f, 0.01765724f, 0.01980310f, 0.04335368f, 0.03669317f, -0.03588867f, 
    -0.05840544f, 0.03490967f, -0.01748806f, -0.01801381f, -0.04194701f, -0.03994365f, -0.05570736f, -0.04277121f, 
    -0.05483567f, -0.01929896f, -0.03093973f, -0.01019477f, 0.03958919f, 0.03302269f, 0.04013649f, -0.01514272f, 
    0.02605188f, 0.00389273f, -0.04764638f, -0.01044484f, -0.05905532f, 0.01368012f, -0.05954542f, -0.04288322f, 
    -0.03966973f, -0.06599057f, -0.02400251f, 0.01433025f, -0.06476223f, -0.05580289f, 0.01745778f, -0.01226943f, 
    -0.03953665f, 0.04044947f, 0.04145894f, -0.05241826f, -0.02955041f, -0.00582246f, -0.03535697f, 0.04036909f, 
    -0.04374418f, 0.03758761f, -0.06388546f, 0.04231175f, -0.02058744f, -0.00971033f, 0.03874131f, -0.06053412f, 
    0.00368593f, -0.04452688f, 0.03333833f, 0.03078016f, 0.03292650f, -0.03981069f, 0.00005897f, -0.02327677f, 
    -0.02294355f, -0.03846603f, 0.03387785f, -0.01396237f, -0.00978606f, -0.02021518f, 0.02522025f, -0.03093847f, 
    -0.06124493f, -0.02601551f, -0.00517197f, -0.04805476f, 0.04719579f, -0.00761889f, 0.00098103f, -0.03930847f, 
    0.03419212f, -0.00159214f, 0.02093041f, -0.02816812f, 0.03817131f, -0.06440810f, -0.06462388f, -0.01371399f, 
    0.43454599f, 0.30100188f, 0.17427550f, 0.22346103f, -0.00973563f, -0.01746895f, -0.01008105f, 0.18015751f, 
    -0.08262765f, 0.00227323f, -0.03765882f, -0.04485857f, 0.01927588f, 0.08975904f, 0.06624319f, 0.11974864f, 
    0.03371802f, 0.06885251f, 0.02612132f, 0.03794872f, 0.19192751f, 0.03378534f, 0.14149059f, 0.13624129f, 
    -0.01379189f, 0.06834484f, 0.08052257f, 0.19480364f, -0.00768034f, -0.01510746f, 0.03911928f, 0.05148399f, 
    0.01706592f, 0.11261638f, 0.16936266f, 0.12704365f, 0.11866263f, 0.16295677f, 0.05654959f, 0.20080760f, 
    0.28142211f, 0.14759356f, 0.54688811f, 0.02788007f, 0.17751861f, 0.08023159f, -0.02498613f, 0.17580442f, 
    0.03861958f, 0.07852761f, 0.03213958f, -0.04252975f, 0.00096806f, 0.12443518f, 0.04959152f, 0.01676778f, 
    0.03346375f, 0.12895600f, 0.01753506f, 0.16253796f, 0.01609382f, 0.16960943f, -0.12904681f, 0.06393994f, 
    0.21843082f, 0.06776472f, -0.19525583f, -0.04465313f, 0.12998582f, -0.06870368f, 0.11143356f, 0.14805134f, 
    -0.02155877f, 0.13395031f, 0.01047165f, 0.09242735f, -0.07669871f, -0.05663553f, 0.01182875f, -0.12382451f, 
    -0.10165174f, -0.06345897f, 0.11563659f, -0.32410413f, -0.10402129f, -0.24453934f, -0.08784568f, -0.00332491f, 
    0.03568574f, -0.20438182f, -0.09913389f, -0.01476638f, -0.01544014f, -0.11799280f, -0.16568367f, -0.06487616f, 
    -0.04540583f, 0.00556053f, -0.09554122f, -0.20167550f, -0.20396540f, -0.16768457f, -0.20212933f, -0.03228361f, 
    0.03997548f, 0.02901669f, 0.04192254f, -0.26807919f, -0.13997972f, -0.08289979f, 0.10233270f, 0.06140020f, 
    0.04521090f, 0.07278284f, 0.08210242f, 0.02926998f, 0.03025581f, -0.28671369f, -0.12616064f, -0.23138139f, 
    0.26491052f, 0.33147985f, -0.11987164f, -0.05614299f, -0.00482293f, -0.08371886f, -0.04966467f, -0.09977668f, 
    -0.05896846f, 0.03522471f, 0.11069244f, 0.02706348f, -0.17055109f, 0.03643057f, -0.08786606f, 0.06592929f, 
    -0.05268846f, 0.06335541f, -0.18097779f, 0.15777405f, -0.30879739f, -0.09347223f, -0.09851296f, -0.11940463f, 
    -0.16951607f, -0.14014758f, -0.05314194f, -0.07227661f, -0.23299868f, -0.16475371f, -0.04751752f, 0.02155596f, 
    0.02500269f, -0.00067864f, -0.13848706f, -0.04477606f, -0.12572542f, -0.06839730f, -0.26545763f, -0.09954512f, 
    -0.01051480f, 0.06562517f, 0.13677113f, -0.09195477f, 0.04370141f, 0.01317858f, -0.03333636f, 0.02450582f, 
    -0.06356971f, -0.09901153f, 0.09613611f, 0.02812516f, -0.03954161f, -0.08040340f, 0.00681455f, -0.11901468f, 
    0.17174172f, 0.06867926f, 0.03391806f, 0.09144065f, 0.00405053f, -0.06763042f, -0.26405534f, -0.47311446f, 
    0.13624476f, 0.20663778f, -0.21735229f, -0.34173164f, 0.10401679f, -0.11575617f, 0.04225455f, 0.09691275f, 
    -0.00526434f, -0.01267262f, 0.08082342f, 0.18012965f, 0.14414777f, -0.06705319f, -0.17422810f, -0.08641376f, 
    -0.04284783f, -0.26042169f, -0.65640926f, -0.49244854f, -0.17857361f, -0.02089161f, 0.00588134f, 0.21754181f, 
    0.09346090f, -0.04490172f, 0.07438838f, -0.07838135f, 0.22607540f, 0.02648007f, 0.06221239f, -0.08736602f, 
    0.09692206f, 0.07913126f, -0.00828250f, -0.02815306f, 0.14281417f, 0.32768622f, 0.11910249f, 0.11679078f, 
    -0.02146189f, 0.00332149f, -0.09147053f, -0.11339090f, 0.09297624f, 0.02540714f, 0.16065371f, 0.01230013f, 
    -0.04653274f, 0.03615337f, -0.05944539f, -0.07638040f, -0.15783416f, -0.02128424f, -0.00183781f, -0.19384167f, 
    0.21757032f, 0.17287225f, 0.14225043f, 0.10169208f, 0.06406201f, 0.01530970f, -0.08454582f, 0.02108007f, 
    -0.01458625f, 0.13653524f, 0.06970371f, 0.00561135f, 0.10621698f, 0.04883240f, 0.03802657f, -0.07112070f, 
    -0.01149624f, 0.11126442f, -0.02117964f, 0.18109936f, 0.19106834f, 0.25266141f, -0.13314877f, -0.01144842f, 
    0.24838082f, 0.20015639f, -0.01054698f, 0.12284458f, -0.06488615f, -0.09292900f, 0.03955903f, -0.00781960f, 
    0.01748964f, 0.02143973f, -0.09157597f, 0.08985578f, 0.12509860f, 0.11204456f, -0.23237003f, 0.06020448f, 
    -0.09681077f, 0.01264100f, -0.13739666f, 0.00386777f, 0.05756120f, 0.22641447f, -0.00479443f, 0.26106966f, 
    0.00493432f, -0.17273499f, -0.07868232f, -0.06225779f, -0.02094379f, 0.00362820f, 0.11573733f, 0.06665359f, 
    -0.01328193f, -0.07355448f, -0.02465478f, -0.03146686f, -0.01926936f, 0.13458708f, 0.18142214f, -0.05891879f, 
    0.02279528f, -0.09115783f, -0.06705954f, 0.09911898f, -0.25446606f, -0.03322704f, -0.09611737f, 0.00500089f, 
    0.03541591f, -0.06384814f, -0.05030512f, -0.04605773f, -0.03072726f, 0.06170335f, 0.20197366f, 0.05513956f, 
    -0.39154384f, -0.20304017f, -0.17135948f, -0.05375675f, 0.14532113f, 0.05034055f, -0.07283479f, 0.20041689f, 
    0.07799979f, -0.09998313f, -0.08243941f, -0.03869788f, -0.00251461f, 0.10788341f, 0.14932460f, 0.09271845f, 
    0.07105380f, 0.09222004f, 0.08216527f, 0.16163629f, 0.36735672f, -0.04222816f, -0.23983578f, 0.04123482f, 
    -0.06679182f, 0.00302095f, -0.08968337f, 0.00259625f, 0.09486052f, 0.15224935f, -0.04692443f, -0.13694966f, 
    0.13069727f, 0.05929395f, 0.02071179f, 0.04372327f, 0.25548053f, -0.04006995f, 0.01504254f, 0.17906006f, 
    -0.12017639f, -0.05166004f, -0.01064031f, -0.15162297f, 0.03577361f, 0.08055625f, 0.17087737f, -0.02109931f, 
    0.07184263f, 0.24529494f, -0.00180453f, 0.06676938f, 0.02358455f, 0.17682566f, -0.06764042f, -0.04115216f, 
    0.20997928f, 0.25183734f, 0.09459820f, 0.22248739f, 0.12062428f, 0.02888413f, 0.24708523f, -0.00058316f, 
    0.00039047f, 0.18059385f, -0.05248290f, 0.06252418f, -0.13415559f, 0.02368338f, 0.16650005f, 0.15156145f, 
    -0.04797962f, -0.06867839f, 0.05131821f, -0.01169646f, -0.11564705f, -0.24944930f, -0.19433556f, -0.19625811f, 
    0.14839539f, 0.03964123f, 0.12416714f, -0.02183564f, -0.17505145f, 0.01339175f, 0.23630531f, -0.05563480f, 
    -0.08912008f, 0.05340702f, 0.02385593f, -0.15810490f, -0.03950704f, -0.15876931f, 0.12646070f, 0.09516372f, 
    0.07650110f, -0.01429283f, -0.23682356f, -0.17136692f, -0.02297249f, 0.29065421f, -0.37235427f, 0.13567139f, 
    -0.10803079f, -0.03971576f, -0.00096865f, -0.03630055f, -0.29081902f, -0.24424638f, 0.03324787f, 0.18410163f, 
    0.08527149f, 0.00103679f, 0.04420781f, 0.08939550f, -0.16406494f, -0.07581741f, -0.20648272f, -0.23995860f, 
    -0.01155546f, -0.04107688f, 0.05436940f, 0.11199863f, 0.01106789f, 0.09705797f, -0.04426800f, 0.10724030f, 
    -0.05554314f, 0.02125895f, 0.06652759f, -0.11423361f, -0.04063727f, -0.10011779f, -0.05380724f, -0.11297677f, 
    0.00014895f, 0.01185232f, -0.12640366f, 0.04568432f, -0.07449494f, -0.07920624f, -0.00108972f, 0.03789454f, 
    0.05553668f, 0.05315137f, -0.07826386f, 0.03283091f, -0.15658918f, -0.17564975f, 0.02220732f, 0.07661591f, 
    0.00375841f, -0.07110980f, 0.02420528f, 0.08233836f, -0.04308551f, -0.13968098f, -0.39736480f, -0.33527860f, 
    0.36820558f, 0.04287319f, 0.04889895f, 0.02690075f, -0.05682230f, -0.06456389f, 0.01664126f, -0.02033884f, 
    0.06768204f, 0.02495893f, 0.10615759f, -0.06779850f, 0.04013217f, -0.07099774f, -0.04627454f, -0.01320321f, 
    0.25094700f, 0.07194799f, 0.00364960f, 0.20177081f, -0.14719969f, 0.09397986f, 0.08820185f, 0.00841930f, 
    -0.09154110f, 0.11568151f, 0.08010731f, -0.07252663f, -0.21677154f, 0.11593540f, -0.02918044f, 0.00954208f, 
    0.04240393f, 0.00030415f, 0.13964956f, -0.03329703f, -0.00552679f, 0.06170757f, -0.11322415f, -0.13046959f, 
    0.03818581f, 0.11682126f, 0.02915575f, -0.10237725f, 0.13950732f, 0.12643014f, 0.09119795f, 0.18676110f, 
    -0.08128461f, 0.16784999f, -0.08231309f, -0.00253194f, 0.00179481f, 0.01672074f, 0.00455208f, -0.07455102f, 
    0.03955823f, 0.07092968f, -0.04226770f, 0.17073798f, 0.26408616f, 0.15828460f, 0.34444115f, 0.37222680f, 
    0.04054715f, 0.04084324f, 0.18906325f, 0.04254432f, -0.09958698f, 0.14385889f, 0.17741361f, 0.05974760f, 
    -0.22523725f, -0.15135238f, -0.05731378f, -0.00110693f, -0.15977468f, -0.11308833f, -0.27565461f, -0.12322638f, 
    0.25699458f, 0.13972107f, 0.18638541f, 0.09144122f, 0.19545601f, -0.02434944f, 0.14887594f, 0.10420209f, 
    -0.07928016f, 0.21611291f, 0.07445990f, -0.03336990f, -0.15295811f, -0.09562287f, -0.23385206f, 0.10442789f, 
    0.08095615f, 0.13011956f, 0.22435887f, 0.19035633f, 0.53358150f, 0.15349089f, 0.01530466f, -0.06613850f, 
    -0.09093872f, 0.30020872f, -0.03519960f, -0.00385424f, 0.02554611f, -0.13713951f, 0.00199402f, -0.01751171f, 
    -0.08381580f, 0.07131400f, 0.06507803f, -0.12750955f, -0.14412427f, -0.13312593f, 0.08083458f, -0.15946537f, 
    0.43784291f, 0.29861376f, -0.02765052f, -0.06616719f, -0.05787545f, 0.11491631f, -0.00883987f, -0.17122729f, 
    -0.08441040f, -0.02818784f, -0.06177711f, -0.00654118f, 0.14713754f, -0.02256445f, 0.12459704f, -0.08074011f, 
    -0.01609140f, -0.10700405f, 0.01109081f, -0.09583890f, 0.17255498f, 0.08002006f, 0.16496669f, -0.00817277f, 
    0.31191716f, 0.09378631f, 0.04522300f, 0.09207830f, 0.04559025f, 0.02831699f, 0.04134838f, 0.02021112f, 
    -0.09939541f, -0.11498702f, 0.03524802f, 0.08201056f, 0.10817757f, 0.09286702f, 0.11774594f, 0.01591881f, 
    -0.02045587f, 0.11232974f, -0.02527271f, -0.33257914f, -0.01561695f, 0.07483032f, -0.04473681f, 0.16545637f, 
    -0.03839004f, 0.00544450f, 0.05333723f, -0.03120731f, 0.07221672f, -0.03658981f, -0.06837946f, 0.03162339f, 
    0.20899838f, 0.14793713f, 0.11762757f, 0.03009013f, -0.40035424f, 0.01579116f, -0.15156011f, 0.05738702f, 
    0.00179132f, -0.00077872f, -0.02818959f, 0.20564765f, 0.00265671f, 0.07311249f, -0.08473971f, 0.00582241f, 
    0.01176771f, 0.04341244f, -0.06855450f, 0.07517749f, 0.08350665f, 0.02851850f, 0.14315955f, 0.09220757f, 
    0.16682416f, -0.11214800f, -0.21057050f, -0.43977845f, -0.22365858f, 0.01589260f, -0.10818752f, -0.19949576f, 
    0.18333662f, -0.03785401f, 0.05039798f, -0.07275289f, -0.01059922f, -0.07131350f, -0.17240050f, -0.07226577f, 
    0.04278759f, -0.03325669f, 0.23347588f, 0.03300509f, -0.06655422f, -0.09141774f, 0.48457614f, -0.00636869f, 
    -0.17007555f, 0.02781122f, 0.04151445f, 0.00869967f, 0.01351995f, -0.03743548f, 0.14119896f, 0.02294620f, 
    -0.00271821f, 0.00742208f, -0.04736040f, -0.20684759f, 0.00713994f, -0.02877951f, 0.03866479f, 0.07963600f, 
    0.14443016f, -0.04815090f, -0.09354181f, -0.00970504f, 0.17240497f, 0.01675778f, 0.04829941f, 0.01707799f, 
    -0.00540650f, 0.06523768f, 0.11758094f, -0.02831363f, -0.03607342f, -0.09076476f, -0.06583450f, 0.03553516f, 
    -0.13247840f, -0.15011570f, -0.11064329f, -0.15280478f, -0.00678534f, 0.22795738f, -0.01047178f, 0.12268245f, 
    0.11995669f, 0.03548598f, -0.04131164f, 0.15712588f, -0.11889915f, 0.06353614f, 0.17164797f, -0.01422944f, 
    -0.01539571f, 0.08343618f, -0.05334247f, 0.01799683f, -0.13290580f, -0.10164055f, -0.03614336f, -0.06626715f, 
    -0.72551507f, -0.12750924f, 0.32787731f, -0.10677838f, 0.20400549f, 0.02003180f, -0.02526061f, 0.08310546f, 
    -0.08011653f, 0.21684393f, 0.09930649f, -0.01515510f, -0.02159474f, 0.11737111f, -0.17506605f, -0.16568537f, 
    -0.06949416f, -0.03443954f, 0.12780234f, 0.05341255f, 0.16154402f, -0.02957829f, -0.01028452f, -0.07504329f, 
    0.18098754f, 0.04895320f, 0.01281398f, 0.07587063f, -0.00868317f, 0.09338959f, 0.11761201f, 0.02142254f, 
    0.00361442f, 0.04999044f, -0.05712472f, -0.04629241f, -0.12699011f, -0.11542498f, -0.08229677f, -0.11171013f, 
    -0.41033047f, 0.38847283f, -0.26810214f, -0.09006319f, 0.01938083f, -0.07212123f, 0.22042751f, 0.09776632f, 
    -0.02628492f, 0.01346606f, -0.13881716f, 0.05331831f, 0.02233322f, 0.11433615f, 0.05418243f, 0.01478531f, 
    -0.06360722f, -0.05869064f, 0.05795632f, 0.17030358f, 0.22712064f, 0.21443808f, -0.07104339f, 0.15669565f, 
    0.17109564f, -0.07091974f, -0.06991242f, 0.08220323f, -0.04428843f, 0.00140333f, 0.01068300f, 0.02706146f, 
    0.04614428f, 0.11190084f, -0.03803446f, 0.03569673f, -0.02075681f, 0.01476460f, -0.07709055f, -0.17272393f, 
    0.34580135f, 0.23907520f, 0.16321923f, 0.07154945f, 0.08874851f, -0.06476884f, -0.08378248f, 0.01991001f, 
    -0.03751346f, 0.04281737f, 0.13451192f, 0.10710746f, -0.01650854f, -0.01135043f, 0.09844895f, -0.11672989f, 
    -0.14975661f, -0.16112889f, -0.00972571f, -0.03319245f, -0.43490261f, -0.37655139f, 0.00617324f, 0.00640623f, 
    0.27780208f, 0.17517522f, 0.38453716f, -0.03500091f, 0.13732725f, 0.14041285f, 0.03290161f, -0.06249566f, 
    -0.09215010f, -0.02395186f, -0.00947248f, -0.08429830f, 0.10387772f, 0.13760665f, 0.04713325f, 0.03584100f, 
    -0.45580909f, -0.18842189f, -0.35575187f, 0.00817044f, -0.00621730f, 0.22452359f, 0.29332837f, 0.00962893f, 
    0.09052589f, 0.03242677f, -0.08788289f, -0.05800968f, -0.01555559f, 0.10743146f, -0.05491539f, -0.17847706f, 
    -0.04583411f, 0.03502617f, 0.12099063f, 0.07516629f, -0.30663583f, -0.04116401f, -0.08846053f, 0.04399985f, 
    -0.27366105f, -0.05341607f, 0.13126478f, 0.05674580f, -0.09242018f, 0.04598833f, -0.05120327f, 0.10054652f, 
    -0.14993562f, 0.01499045f, -0.10217118f, -0.23177406f, -0.15960208f, -0.00437041f, 0.10207151f, 0.15610184f, 
    0.22451757f, 0.33263135f, 0.29017308f, 0.05297900f, -0.09254009f, -0.06442387f, -0.09685009f, -0.01976899f, 
    -0.04178921f, 0.01432817f, -0.01918227f, -0.01390446f, 0.05397069f, 0.10377358f, -0.06345753f, -0.13328561f, 
    -0.02503344f, -0.03376072f, -0.02851802f, -0.07452574f, -0.21645777f, -0.15852615f, -0.53553545f, -0.16290325f, 
    -0.24608228f, 0.22890879f, 0.27134982f, 0.09659421f, -0.05774154f, 0.04221727f, 0.00035174f, -0.12549412f, 
    -0.19496939f, 0.07065821f, -0.05119953f, -0.13977179f, 0.19970731f, 0.18175055f, -0.18495874f, 0.10478187f, 
    -0.33037758f, 0.06556518f, -0.16887452f, 0.10902596f, 0.05166429f, 0.17915893f, 0.18833590f, 0.10075384f, 
    0.02569226f, 0.16127937f, -0.06465643f, 0.00505268f, 0.04766179f, 0.03162811f, 0.12120391f, -0.14465520f, 
    -0.10958050f, -0.02302419f, 0.06261110f, 0.04416161f, 0.05879956f, 0.13270275f, -0.02598878f, -0.14117955f, 
    -0.13102686f, -0.04355132f, 0.11401054f, 0.07471918f, 0.02338317f, 0.01315760f, -0.05423379f, -0.01935844f, 
    -0.14709808f, 0.01935931f, -0.03903874f, -0.16580954f, -0.14479916f, 0.01328339f, -0.02275347f, 0.01562686f, 
    -0.16994062f, -0.00735297f, 0.00133451f, -0.10632499f, 0.00220361f, 0.05549744f, 0.10072129f, -0.02293253f, 
    0.04527588f, -0.11168221f, -0.03083871f, 0.00991013f, -0.09733489f, 0.03902978f, 0.09511589f, 0.09776375f, 
    0.13817200f, -0.05734408f, -0.03244763f, -0.07075438f, 0.33067134f, -0.05354268f, -0.29627424f, -0.22421284f, 
    0.04309868f, 0.04463568f, 0.07325993f, 0.11256809f, 0.10792211f, 0.03895327f, 0.23848720f, -0.03203186f, 
    -0.01430513f, 0.00492857f, -0.04983997f, 0.07256784f, 0.04560045f, -0.03972206f, 0.05740864f, 0.04313266f, 
    -0.21475875f, 0.10191504f, 0.11731038f, 0.13762744f, -0.10025899f, 0.00980152f, -0.09128824f, -0.00858159f, 
    -0.09795077f, 0.03388929f, 0.08003436f, 0.06249372f, 0.01857252f, -0.00232831f, 0.07097793f, 0.13967720f, 
    0.09077366f, 0.22324717f, 0.01123695f, 0.02424288f, 0.25514317f, 0.07227940f, -0.21773978f, 0.05835443f, 
    -0.31154525f, -0.04551732f, 0.01157924f, 0.06844659f, -0.09042354f, -0.08485067f, -0.10979056f, -0.14834580f, 
    0.09113289f, -0.06176278f, 0.02830669f, 0.05575211f, -0.12806126f, 0.25246724f, -0.13932084f, 0.06340162f, 
    0.01474922f, -0.20378707f, 0.42204928f, 0.40575692f, 0.00046786f, 0.10792239f, 0.08127796f, 0.21853510f, 
    0.08019914f, -0.13449040f, 0.01419721f, 0.06497356f, 0.13104504f, -0.04384460f, -0.01219009f, 0.01001351f, 
    0.01132137f, -0.01288776f, 0.01365525f, 0.10181250f, -0.16430561f, -0.12804304f, 0.08985173f, 0.12224132f, 
    -0.12978570f, -0.03631055f, -0.00594781f, -0.11630405f, 0.02118674f, -0.04410146f, -0.05717251f, -0.00320358f, 
    0.08949470f, -0.07638855f, 0.04696753f, 0.08580109f, 0.08924935f, 0.09600150f, 0.09507088f, -0.01587530f, 
    -0.06872845f, 0.11769444f, 0.39756373f, 0.19842501f, -0.16574307f, -0.01984352f, -0.02535427f, -0.19560371f, 
    0.07668540f, 0.04665332f, 0.04874660f, 0.02008349f, -0.11680662f, 0.00424436f, -0.03916360f, 0.04680702f, 
    -0.12779984f, 0.13403122f, -0.07028113f, -0.01482438f, 0.15003636f, 0.13655837f, 0.06224794f, 0.18292965f, 
    -0.07917292f, -0.13180453f, 0.01030068f, -0.12672052f, 0.04131711f, -0.07070342f, 0.06028305f, -0.05096337f, 
    0.17965743f, 0.01219774f, 0.05707951f, -0.18198572f, -0.09058370f, 0.05465488f, 0.05932582f, 0.02491708f, 
    0.03320246f, -0.04525817f, -0.11642887f, 0.20377974f, -0.14353524f, 0.03025385f, -0.04744472f, -0.09223448f, 
    -0.04588975f, -0.05770567f, 0.04292813f, 0.04017719f, -0.19085807f, 0.09625459f, 0.02234900f, -0.14689875f, 
    -0.00092389f, -0.06678030f, 0.21497978f, 0.04220546f, -0.33294177f, 0.07840279f, 0.37771443f, 0.05847659f, 
    0.06034517f, 0.15857352f, 0.04635295f, 0.18212831f, -0.04496108f, 0.20893168f, 0.12184704f, 0.04964770f, 
    0.07806195f, 0.03287509f, -0.03878196f, 0.02104819f, -0.02482338f, 0.00965087f, 0.12533034f, 0.18419062f, 
    0.03131653f, 0.11503196f, 0.47640923f, 0.23772646f, 0.02150869f, 0.03650967f, 0.00867440f, 0.08402094f, 
    0.09402749f, 0.09385531f, 0.00305938f, -0.07187600f, -0.01585530f, -0.07283130f, -0.09876548f, 0.01845742f, 
    0.03661715f, -0.00291604f, -0.12592115f, 0.01919087f, 0.56779623f, 0.08836304f, 0.62699234f, 0.08983918f, 
    0.14333700f, 0.14679502f, 0.19600886f, -0.12188372f, 0.23947425f, -0.13065796f, 0.06377024f, 0.05684279f, 
    0.01384144f, -0.01513518f, -0.00574219f, 0.02858918f, -0.09356599f, 0.08105546f, -0.06766405f, 0.02446929f, 
    0.47007343f, -0.16293126f, -0.47163031f, -0.30906641f, -0.37215152f, -0.12324746f, -0.09539238f, 0.04353989f, 
    -0.04493660f, 0.11658332f, -0.00590580f, -0.11668020f, -0.07648493f, 0.01577768f, -0.10680357f, -0.10306629f, 
    0.02220581f, 0.14403483f, -0.03605821f, 0.02944621f, -0.10446601f, 0.22884783f, 0.66998523f, 0.27920246f, 
    0.22710377f, 0.08350712f, 0.10284863f, 0.01772746f, 0.23329186f, 0.19295049f, -0.06821784f, 0.06330942f, 
    0.04377174f, -0.01766148f, -0.10090068f, 0.12399996f, 0.15022740f, -0.25390923f, 0.04231993f, -0.11601920f, 
    0.01962170f, -0.05354023f, -0.03928246f, -0.07040104f, -0.06513686f, 0.02950543f, -0.05965422f, -0.06749632f, 
    -0.03801044f, 0.01952336f, -0.06147726f, 0.01462538f, -0.01035577f, -0.02580293f, -0.01575037f, 0.03231893f, 
    0.01699175f, 0.00848506f, 0.02982228f, -0.02613874f, -0.04976055f, -0.01410719f, -0.04573711f, -0.03392109f, 
    -0.06548958f, -0.03396305f, -0.08532124f, -0.06714574f, -0.00431007f, -0.02927821f, 0.03621907f, -0.08374223f, 
    -0.01335365f, -0.03436686f, 0.01613109f, 0.02899940f, 0.04431016f, -0.05070167f, -0.06843720f, -0.02936069f, 
    0.01066254f, -0.05829176f, -0.04834070f, -0.00271605f, -0.04109628f, -0.05858239f, -0.05301181f, -0.08377622f, 
    0.03109404f, 0.02087162f, 0.01249642f, -0.06599665f, -0.01679652f, 0.00672238f, 0.01393178f, 0.05626576f, 
    -0.00772400f, 0.01803035f, 0.00588520f, 0.04649845f, -0.02541661f, -0.03799428f, -0.03683338f, -0.01685070f, 
    -0.07902707f, 0.02080213f, -0.04328706f, -0.04704435f, -0.05901577f, 0.03280904f, -0.08363497f, -0.02242450f, 
    -0.02193612f, -0.07198300f, 0.00741319f, -0.03058497f, 0.01992384f, 0.00614788f, 0.00925049f, 0.00115274f, 
    0.02927653f, -0.05139104f, 0.01539201f, 0.03175728f, -0.04667799f, -0.00216724f, -0.05774886f, -0.02184067f, 
    0.04314011f, -0.05232366f, -0.01204353f, -0.02257991f, -0.00665128f, -0.06032474f, -0.02748078f, -0.05112170f, 
    0.01488370f, -0.01179206f, 0.00846417f, -0.07405508f, -0.06776842f, -0.03744551f, -0.06130365f, 0.01326678f, 
    -0.04130374f, -0.01698877f, -0.04934502f, -0.00076997f, -0.01827389f, 0.00643481f, 0.02031116f, 0.02583977f, 
    -0.05208709f, 0.03220977f, 0.01477101f, 0.01829318f, -0.03211782f, -0.06881728f, -0.01516861f, -0.03246728f, 
    -0.07414446f, -0.07600053f, -0.04487094f, 0.01999224f, -0.03210239f, -0.04920626f, -0.03053820f, 0.02095662f, 
    -0.07562922f, 0.02024452f, -0.00013336f, 0.02017417f, -0.02769902f, 0.00764672f, -0.03429931f, -0.06862921f, 
    -0.04214670f, -0.04913015f, -0.01505737f, 0.00108771f, -0.02522092f, -0.00397936f, -0.01872656f, 0.00455448f, 
    -0.05702984f, -0.03282462f, 0.03962812f, 0.02560740f, -0.06257546f, -0.00090463f, -0.05380561f, 0.02000965f, 
    -0.01082995f, 0.00696015f, 0.02626307f, -0.04482896f, -0.03189729f, -0.04179339f, 0.00106411f, -0.05177267f, 
    -0.02535715f, -0.08053040f, 0.02924778f, -0.05423821f, 0.00279901f, -0.04989360f, -0.06493999f, -0.05747852f, 
    0.02344110f, -0.01576491f, -0.05100824f, -0.05741530f, 0.02771421f, -0.04129755f, -0.04213933f, -0.05415563f, 
    -0.05547655f, -0.06126579f, -0.04031057f, -0.05918172f, -0.01678899f, 0.03587828f, -0.04931920f, -0.00646001f, 
    0.02734209f, -0.02757470f, -0.05178702f, 0.00457107f, 0.01709969f, -0.05758489f, 0.00443387f, -0.05949556f, 
    -0.01697220f, -0.01853813f, -0.03258081f, 0.01318687f, 0.00541037f, -0.01867606f, -0.06651697f, -0.03892784f, 
    0.02472921f, -0.01636137f, 0.02228468f, 0.02450483f, -0.01830384f, 0.02637677f, -0.00241769f, -0.05250635f, 
    0.03776540f, -0.03722245f, -0.00192713f, -0.04128576f, -0.08509737f, -0.00170560f, -0.02228428f, -0.08763571f, 
    -0.08342360f, 0.01073295f, -0.02975621f, -0.04561158f, -0.03397722f, -0.03464635f, 0.01136784f, 0.01464047f, 
    -0.02545294f, -0.05944443f, 0.02764680f, -0.01365215f, 0.01500807f, -0.04632803f, -0.06519534f, -0.01626967f, 
    -0.06357831f, -0.02106100f, -0.01165418f, -0.00711560f, -0.00384025f, -0.00799284f, -0.02856183f, -0.05703093f, 
    -0.06307451f, 0.02714415f, 0.00939845f, -0.02971827f, -0.06023050f, 0.00938367f, 0.01274913f, -0.05598917f, 
    -0.05335079f, -0.02904021f, 0.03087623f, 0.00663583f, 0.01347682f, -0.02960860f, -0.01003954f, -0.02954256f, 
    -0.03630978f, 0.00488258f, 0.05032137f, 0.03679647f, 0.02826050f, -0.03595154f, -0.03261610f, -0.06333195f, 
    -0.07789609f, -0.02966400f, -0.00989044f, 0.01112675f, -0.00010087f, -0.02552516f, 0.03402109f, -0.04093950f, 
    -0.02642119f, 0.02234970f, 0.04286192f, 0.00107990f, 0.00684242f, -0.03613381f, -0.04271483f, 0.00857151f, 
    0.03449028f, -0.03273638f, 0.00162831f, -0.02868956f, 0.00681761f, -0.06419840f, -0.02717788f, -0.05270188f, 
    0.00267500f, -0.02644370f, -0.04314011f, -0.03271039f, -0.03127831f, 0.01250600f, 0.01473522f, -0.02538063f, 
    -0.04469473f, -0.02464768f, -0.00635048f, -0.05510782f, -0.05221459f, -0.07671255f, -0.07259432f, 0.00058846f, 
    -0.01048535f, 0.03161322f, 0.02194829f, -0.03263501f, -0.04764213f, -0.02253408f, -0.03936331f, -0.00025577f, 
    -0.07325955f, 0.00102700f, -0.01690943f, 0.03382657f, -0.04121324f, -0.00186727f, -0.01285078f, 0.04160503f, 
    -0.33722323f, 0.01306652f, 0.07096082f, -0.00305779f, 0.44418946f, -0.02714889f, 0.18110612f, -0.22237982f, 
    0.13781485f, 0.00522327f, -0.03581016f, 0.00929451f, 0.10470034f, 0.03842826f, 0.03805868f, -0.09000056f, 
    0.00328079f, -0.09319259f, -0.00986340f, -0.12402553f, 0.18986104f, 0.04536205f, -0.12124678f, -0.07267905f, 
    0.16256259f, 0.02928033f, 0.06793644f, -0.09605082f, 0.13917483f, 0.07469891f, -0.06858911f, -0.08379032f, 
    0.04227590f, 0.06659833f, -0.04460005f, -0.07260094f, -0.03345739f, -0.02887617f, -0.01275867f, -0.07326265f, 
    -0.48056808f, -0.15995324f, -0.36321715f, 0.19606246f, 0.18208233f, -0.06641120f, 0.00623162f, 0.03055879f, 
    -0.10648277f, -0.07054340f, -0.04226952f, -0.03301371f, -0.04380979f, 0.00301206f, 0.07877763f, 0.09894749f, 
    0.15121301f, 0.02765717f, -0.04029212f, -0.01913098f, -0.10768692f, -0.11386202f, -0.20641300f, 0.15745901f, 
    -0.03743358f, -0.07457329f, 0.02243007f, 0.04409244f, -0.06513462f, 0.18354602f, -0.14212424f, -0.10676814f, 
    -0.09992390f, -0.13939984f, -0.12314805f, 0.03261110f, -0.04742911f, -0.03452136f, 0.03501841f, 0.01970370f, 
    -0.16588551f, -0.09119158f, 0.02643199f, -0.03878998f, -0.15543647f, 0.09661567f, -0.05253664f, -0.14503813f, 
    -0.07855073f, -0.13316470f, -0.13390109f, -0.05756187f, -0.08269430f, -0.04318714f, 0.03732365f, 0.09773652f, 
    0.05877445f, -0.00178908f, -0.03236312f, -0.03062103f, 0.17947537f, -0.03533153f, 0.06290647f, -0.13738871f, 
    -0.28131318f, -0.06897748f, 0.06924562f, 0.00297919f, 0.10111220f, 0.02860541f, 0.08976890f, 0.11166463f, 
    0.08892611f, 0.00076849f, 0.10658685f, 0.00714320f, 0.06233320f, 0.15364859f, 0.13197689f, 0.05582396f, 
    0.30535078f, -0.17416249f, 0.07262872f, 0.37122953f, -0.01676009f, 0.04463656f, 0.07181854f, 0.09965450f, 
    0.07680599f, -0.04947450f, -0.05081027f, 0.09183708f, 0.05485358f, -0.05183619f, 0.12735939f, 0.00937550f, 
    0.04507386f, 0.17266561f, 0.11370857f, 0.07655882f, -0.07105646f, 0.02784428f, -0.02744781f, 0.06010955f, 
    -0.10193422f, 0.05731075f, -0.05856382f, -0.05537669f, -0.05092003f, 0.02161959f, -0.07653822f, 0.02270778f, 
    -0.03531272f, -0.08568311f, 0.10540028f, 0.08250269f, 0.12516554f, 0.10467055f, 0.11959843f, 0.00717866f, 
    0.43652347f, -0.07250928f, -0.00792956f, 0.18217550f, 0.12915365f, 0.04248620f, 0.06301037f, 0.01832812f, 
    0.16445136f, 0.07316237f, 0.05422368f, 0.05134558f, 0.08465602f, 0.08197733f, 0.01031447f, 0.13109328f, 
    -0.04078973f, -0.08628128f, -0.01756896f, -0.03548741f, -0.33571866f, -0.11601544f, 0.24414746f, 0.11162231f, 
    -0.24466464f, -0.15432426f, 0.00179873f, -0.04095998f, -0.12316249f, -0.09917682f, -0.04796587f, -0.13134006f, 
    -0.04456403f, -0.05526215f, -0.02270710f, -0.00022947f, 0.04733984f, 0.03243113f, -0.03127484f, -0.04911080f, 
    -0.51822007f, -0.05573735f, 0.17661418f, 0.00906857f, -0.26472279f, -0.03868841f, -0.09797602f, -0.21696831f, 
    -0.13035385f, -0.12721679f, -0.00814678f, 0.06149898f, 0.05501346f, 0.08008888f, 0.23153588f, -0.00534568f, 
    0.03273201f, 0.04334531f, -0.15332206f, -0.08056070f, 0.19400999f, -0.25556371f, -0.11187899f, 0.24569149f, 
    0.05129329f, 0.08063681f, 0.07606019f, 0.17929590f, -0.05114896f, 0.04797845f, -0.05585609f, 0.07087979f, 
    0.04565884f, 0.03353214f, 0.08060903f, 0.03518853f, 0.07014619f, 0.20185599f, 0.04652127f, 0.25749254f, 
    -0.15283290f, -0.18031514f, 0.08869853f, 0.08239934f, 0.20836648f, -0.10814405f, 0.05833828f, 0.02931705f, 
    -0.07570164f, -0.22498627f, 0.04665197f, 0.07052197f, -0.03239513f, 0.05457646f, 0.10069770f, 0.12092575f, 
    0.20583518f, 0.04196779f, -0.03882251f, -0.12258712f, 0.03882033f, -0.30024359f, -0.07050475f, 0.05379375f, 
    -0.04505896f, -0.07732475f, -0.09318407f, -0.07341661f, 0.16881786f, 0.24328271f, -0.13246027f, 0.03267516f, 
    -0.03340459f, -0.00853262f, 0.07455409f, -0.00991009f, -0.03059780f, 0.00710795f, 0.16034432f, 0.15273324f, 
    -0.16206618f, -0.27909482f, -0.09394746f, -0.11468955f, 0.05118936f, 0.04114145f, 0.08455233f, -0.02921441f, 
    0.03475853f, 0.23293586f, 0.03212765f, 0.12598179f, 0.04833468f, 0.05809971f, -0.01626243f, -0.12206548f, 
    -0.06486858f, 0.00761658f, -0.05108195f, -0.02830421f, 0.05286770f, -0.09320308f, -0.17626981f, 0.31845236f, 
    0.32220981f, -0.04880379f, 0.08645713f, -0.00133542f, 0.23736590f, -0.05204240f, -0.02883395f, 0.06642864f, 
    -0.03619804f, 0.07533541f, 0.11679655f, 0.12852463f, -0.04696365f, -0.05335001f, -0.06912437f, -0.03188211f, 
    -0.04937913f, 0.02422979f, -0.02056556f, -0.02010983f, 0.03469104f, 0.03461931f, -0.03063322f, 0.04311902f, 
    0.03702688f, 0.04474193f, -0.03235040f, -0.01047322f, 0.00663484f, 0.00919713f, 0.04774844f, -0.02685714f, 
    -0.01221765f, 0.03811246f, 0.04638501f, -0.02946742f, -0.02613559f, -0.02214713f, 0.01662332f, -0.04943611f, 
    0.01001029f, -0.01332872f, -0.03160861f, -0.00742177f, 0.02682901f, -0.05218609f, -0.02239584f, -0.05419696f, 
    -0.03222388f, 0.02742738f, -0.02193229f, 0.01585867f, -0.02543290f, 0.02709983f, -0.02637361f, 0.02827158f, 
    0.02584942f, 0.04654430f, 0.04673238f, -0.00294566f, -0.04536574f, -0.05482361f, 0.04774282f, 0.03987934f, 
    -0.04892251f, 0.03864069f, -0.01024351f, -0.02854446f, -0.02179777f, 0.04353466f, -0.03528704f, -0.04024536f, 
    -0.05398631f, -0.00571486f, -0.05508441f, 0.02258998f, 0.03956281f, -0.04187902f, 0.04705122f, 0.03718651f, 
    0.00896460f, 0.01665083f, -0.03871041f, 0.00486386f, 0.04531493f, 0.02940291f, -0.01492869f, 0.02240010f, 
    -0.04924759f, -0.01833751f, 0.01452009f, -0.01122721f, 0.02679529f, 0.04526425f, -0.03620522f, -0.06224208f, 
    0.01582157f, -0.03378570f, 0.02037494f, 0.01910159f, -0.01431636f, 0.02030215f, -0.00718303f, 0.03545686f, 
    -0.04635883f, -0.00691780f, -0.02575455f, -0.05176612f, -0.01041433f, -0.02754183f, -0.01894741f, -0.02516153f, 
    -0.04848790f, 0.01690250f, -0.04868531f, -0.02002463f, 0.00825430f, -0.05038185f, -0.05129299f, -0.00068381f, 
    0.04578654f, -0.04797696f, -0.00946784f, 0.04596608f, -0.03268072f, 0.02150274f, -0.04202778f, 0.00968109f, 
    0.03311773f, -0.03389456f, -0.01690205f, 0.03367194f, -0.00905120f, 0.04242378f, 0.00297151f, 0.04356128f, 
    0.03903240f, -0.02295176f, 0.02189379f, 0.03475257f, 0.02493214f, -0.00928043f, -0.01691912f, -0.01755581f, 
    0.04458268f, 0.01723214f, 0.02064237f, -0.03726944f, -0.04315865f, -0.02783539f, 0.02613143f, -0.00825422f, 
    0.01814643f, -0.03309047f, -0.05198428f, 0.02923695f, -0.02326731f, -0.03752275f, -0.04699693f, 0.04571370f, 
    -0.02607615f, -0.01602747f, -0.02883383f, 0.00800893f, -0.02014378f, -0.01757427f, -0.01732818f, 0.02211364f, 
    -0.00918394f, 0.04618972f, -0.05410615f, -0.02100115f, 0.04412536f, -0.01401711f, 0.00969154f, -0.00205857f, 
    0.03470706f, -0.00521395f, -0.05960134f, -0.04207510f, 0.03372361f, 0.00369908f, -0.05971787f, 0.02607076f, 
    -0.01932926f, -0.01760831f, -0.01723027f, -0.00191323f, -0.04569047f, -0.03659801f, -0.00939829f, -0.02236489f, 
    -0.01556176f, -0.02633495f, -0.03154658f, 0.04458121f, -0.03097480f, 0.01433729f, -0.04835436f, -0.01936277f, 
    -0.06419621f, 0.01110791f, 0.04522846f, 0.02055618f, 0.03389426f, 0.01240158f, 0.02563727f, -0.05496013f, 
    -0.05750527f, -0.04204031f, 0.01093026f, 0.04820713f, -0.00371845f, -0.02114539f, 0.02148997f, 0.04152261f, 
    -0.03937325f, -0.03790621f, -0.03175710f, 0.03021132f, -0.05048990f, 0.02191941f, -0.05144693f, -0.04110591f, 
    -0.06002107f, -0.00069582f, -0.00035408f, -0.04971280f, 0.04400670f, -0.05231187f, -0.03711537f, -0.00774850f, 
    0.03864053f, -0.03899551f, -0.03911918f, -0.00236760f, -0.01693230f, 0.00246506f, 0.02081517f, -0.01305196f, 
    -0.01295698f, -0.00647708f, -0.05995011f, -0.04785658f, 0.02220785f, 0.03814735f, -0.03604399f, -0.03929004f, 
    -0.05213986f, 0.04402704f, -0.06061159f, -0.04813842f, -0.03561339f, 0.01666385f, 0.00468004f, -0.02914397f, 
    -0.05437684f, -0.01654191f, -0.03898489f, -0.03142856f, 0.02346929f, -0.00864121f, -0.03266044f, -0.02178931f, 
    0.00577778f, -0.02199103f, -0.01427620f, 0.01052419f, -0.05205910f, 0.00253001f, 0.03734514f, 0.01821763f, 
    -0.05537625f, -0.02312117f, 0.02875466f, 0.04045786f, -0.00346172f, -0.03181948f, 0.02711552f, -0.03926493f, 
    -0.05772822f, 0.01414893f, 0.02527227f, 0.03250375f, 0.00545651f, -0.01861039f, -0.03417251f, -0.05804323f, 
    -0.05589390f, -0.02678615f, 0.03024705f, -0.00383488f, 0.04289323f, -0.05632656f, -0.05267813f, -0.05887124f, 
    -0.02959244f, 0.01337172f, -0.06432657f, -0.06749318f, 0.00446226f, -0.06150853f, 0.04254910f, -0.00861225f, 
    0.03620156f, -0.00749820f, -0.01871185f, -0.04642527f, 0.04276348f, -0.03759443f, -0.04605187f, -0.01939513f, 
    0.03544634f, -0.03503163f, 0.01518621f, 0.04323117f, 0.01340866f, 0.02501472f, -0.01578282f, -0.05984256f, 
    -0.02569535f, 0.02541497f, 0.01278631f, 0.02558514f, -0.03233933f, -0.04581201f, -0.01492515f, -0.05129305f, 
    0.04482910f, 0.03032340f, -0.05966545f, 0.03710328f, -0.00345619f, 0.01100797f, -0.05039201f, -0.00839361f, 
    -0.04381208f, -0.04841834f, -0.03220526f, -0.02720192f, -0.04072318f, -0.01270734f, -0.02743540f, 0.04156564f, 
    0.04112595f, 0.04622528f, -0.02466984f, -0.05791299f, -0.06042574f, -0.02255255f, 0.02382859f, -0.02900300f, 
    0.00712844f, 0.03547296f, -0.00328305f, -0.05941677f, -0.04630813f, -0.05865313f, -0.06286910f, -0.00426875f, 
    -0.00776174f, 0.01609887f, 0.02611730f, 0.03188166f, -0.04696457f, -0.00346189f, -0.02754949f, 0.02758911f, 
    -0.04928012f, -0.03510330f, -0.01009890f, -0.00217738f, -0.06259897f, 0.02447229f, -0.02338894f, 0.03077090f, 
    0.00220141f, -0.03449951f, -0.05829583f, -0.00412903f, -0.00182062f, 0.01926616f, -0.03192797f, -0.05055574f, 
    -0.00964433f, -0.05606518f, -0.00017193f, -0.01373711f, -0.02064522f, -0.00045475f, -0.01315141f, 0.04714606f, 
    -0.05408198f, -0.04574455f, -0.01050871f, -0.00483727f, -0.00512074f, -0.04763892f, 0.00530384f, -0.03895813f, 
    0.00743963f, -0.01690326f, -0.04787863f, 0.01774796f, 0.01314980f, -0.01709165f, -0.03098775f, -0.03604192f, 
    -0.03009399f, 0.00769608f, 0.00325829f, -0.05558716f, -0.02282388f, 0.01454094f, -0.02850461f, 0.00613003f, 
    -0.02076055f, -0.03200110f, 0.02056275f, -0.02886967f, -0.01703936f, -0.04077758f, 0.01656153f, 0.00521494f, 
    0.02875254f, -0.05349555f, 0.03510765f, 0.00237043f, 0.00319267f, -0.00379497f, 0.03150567f, -0.06000709f, 
    -0.00765969f, -0.05376853f, 0.04257217f, -0.01129721f, 0.03822481f, -0.03768463f, 0.01562515f, -0.02057955f, 
    -0.00460676f, -0.03033522f, -0.03545118f, -0.04078693f, -0.03970131f, 0.02361272f, 0.02156349f, -0.05797046f, 
    -0.05317753f, -0.02509755f, 0.01777411f, -0.02364087f, 0.04410036f, 0.03121630f, 0.01008645f, -0.05592011f, 
    -0.06068728f, 0.03891614f, -0.00665813f, 0.03605970f, -0.05451805f, 0.00933278f, -0.01022345f, -0.02257786f, 
    -0.03768294f, 0.01052265f, -0.03216212f, -0.04024639f, -0.05842361f, -0.05888958f, -0.02928833f, -0.05099428f, 
    -0.05869885f, -0.02183304f, 0.03816142f, -0.01801394f, -0.05976662f, -0.06104439f, -0.03922286f, 0.02987631f, 
    -0.04571120f, 0.04091474f, 0.03979553f, 0.02341089f, -0.00429248f, 0.03230984f, 0.03187362f, -0.00405048f, 
    -0.02572834f, -0.05211302f, 0.02997821f, 0.03141659f, 0.03908151f, -0.04839300f, -0.04644280f, 0.04228750f, 
    0.02151474f, 0.04685363f, -0.03299275f, -0.04458458f, -0.04720184f, 0.03044924f, -0.04805930f, -0.02658403f, 
    -0.05136298f, 0.01067142f, -0.01451990f, 0.00111726f, 0.04346662f, 0.04082787f, -0.04827796f, -0.00569538f, 
    0.03984103f, 0.04099010f, 0.02389021f, -0.01222855f, 0.01565371f, -0.04159728f, -0.03135693f, -0.01725974f, 
    -0.05397969f, 0.03563379f, -0.05452820f, -0.01489795f, -0.04480595f, 0.01136712f, -0.01952209f, -0.01962162f, 
    -0.03505424f, 0.04426161f, -0.01570416f, -0.01414395f, 0.00142966f, 0.04045168f, -0.02618968f, -0.05143682f, 
    0.01922894f, 0.04853131f, -0.00599010f, 0.02199863f, -0.03018493f, 0.02955031f, -0.03827563f, -0.01186321f, 
    -0.04016962f, -0.04163523f, -0.05150420f, -0.01078793f, 0.00853572f, -0.01685107f, 0.01482012f, -0.03686085f, 
    0.03733303f, -0.02538338f, 0.00161304f, 0.00098515f, 0.02299677f, -0.02447830f, 0.00439741f, -0.05057135f, 
    0.00355521f, 0.01180724f, -0.03823033f, 0.02468628f, -0.01838057f, -0.02409426f, 0.03830657f, -0.00975269f, 
    0.01255322f, 0.00439044f, -0.03905908f, -0.00415887f, -0.00588566f, 0.03388433f, 0.01078683f, 0.02916878f, 
    -0.06120630f, -0.04653193f, 0.00892159f, -0.00031981f, 0.04082572f, -0.05178476f, -0.00860364f, -0.01114262f, 
    0.02181590f, 0.04315088f, -0.00121581f, 0.02019637f, -0.02416901f, -0.02085699f, -0.00738234f, -0.02327332f, 
    -0.02644751f, 0.03260824f, 0.02123451f, 0.01859596f, 0.02169275f, -0.00639578f, 0.01334346f, 0.04667108f, 
    -0.05832620f, 0.03852170f, 0.03506424f, 0.00743693f, 0.00282913f, 0.00849857f, 0.00047736f, 0.01472394f, 
    -0.00451999f, -0.04917096f, -0.05394592f, 0.03543131f, -0.01605228f, -0.03155454f, -0.02099116f, -0.01371830f, 
    -0.03017870f, 0.01615992f, -0.01245034f, 0.03326729f, -0.03627531f, 0.04036714f, -0.04949979f, 0.00123963f, 
    0.01031934f, -0.03441147f, 0.04004107f, 0.04157604f, -0.02792721f, -0.05150270f, -0.03429761f, -0.03135985f, 
    0.04029519f, 0.01033393f, -0.03299321f, -0.00599626f, 0.01300390f, -0.00785108f, 0.02516821f, 0.04975953f, 
    -0.02428111f, 0.01911031f, -0.00451503f, 0.00640816f, 0.02762292f, -0.03681640f, -0.03624897f, 0.03418783f, 
    -0.02089541f, 0.03369887f, -0.05530418f, -0.04544685f, 0.03497409f, -0.05668533f, 0.02318614f, -0.00758067f, 
    -0.05321213f, 0.03082733f, -0.02700563f, -0.00938806f, 0.02345125f, 0.03428505f, 0.00944732f, 0.03034615f, 
    -0.05561892f, -0.02424800f, -0.04349253f, -0.00858071f, -0.04204511f, -0.04813610f, 0.00309732f, -0.01991767f, 
    -0.03813631f, -0.04020045f, 0.04490412f, -0.06339541f, -0.04895902f, -0.05413215f, -0.01303597f, -0.01257467f, 
    -0.02573253f, 0.02916680f, -0.04352663f, 0.01171688f, -0.03302306f, -0.05936898f, 0.02135601f, 0.03051916f, 
    0.03750515f, 0.01304648f, 0.02346494f, -0.02120563f, 0.04348572f, -0.05130316f, -0.01232022f, 0.04021896f, 
    0.01762561f, 0.03031567f, 0.04633021f, -0.01518154f, -0.01994769f, 0.03679265f, 0.04002154f, 0.00442085f, 
    0.01532251f, 0.02314012f, 0.00985338f, -0.05103956f, -0.04421639f, 0.03326786f, 0.04098061f, 0.04054794f, 
    -0.00875963f, -0.02968176f, 0.00201193f, -0.05110597f, -0.02163159f, -0.06072107f, 0.03061660f, 0.01352483f, 
    -0.01564167f, -0.05581142f, -0.03429535f, -0.00304702f, 0.00214337f, -0.06208383f, 0.00483231f, -0.04204215f, 
    0.02178812f, 0.03402598f, -0.00816893f, 0.03095603f, -0.06222754f, -0.01165606f, -0.03613567f, -0.05522424f, 
    0.00020682f, 0.02912078f, -0.00539143f, -0.05060908f, -0.03747803f, -0.04911363f, -0.00385837f, -0.05265458f, 
    0.05131768f, -0.03980457f, -0.05737930f, 0.02558636f, 0.00499565f, -0.01796885f, 0.01691967f, -0.00230100f, 
    -0.01630721f, 0.04008150f, 0.02055874f, 0.00750664f, -0.05621292f, -0.02799080f, 0.01590455f, -0.01724526f, 
    0.03881359f, -0.02374972f, 0.04664411f, -0.04419234f, -0.02240045f, 0.00644736f, -0.00701685f, -0.01230511f, 
    -0.01010205f, 0.02159468f, 0.03893601f, 0.03614857f, -0.06397747f, -0.03043226f, -0.04313743f, 0.02561806f, 
    0.00248097f, 0.02800855f, -0.02981166f, -0.03453678f, 0.03556484f, 0.01260454f, -0.02838341f, -0.03905087f, 
    -0.01349899f, -0.00466959f, 0.01763294f, -0.05948521f, -0.05298591f, 0.02948974f, 0.01646648f, -0.05975755f, 
    -0.02576938f, 0.01826984f, -0.03860479f, -0.05135660f, -0.01366289f, 0.00892046f, -0.05634470f, 0.02551444f, 
    -0.01282818f, -0.05436444f, 0.02486159f, -0.05635194f, -0.01413661f, 0.04771772f, -0.04091566f, 0.02001668f, 
    -0.05815584f, -0.02620836f, -0.04629228f, -0.03325617f, -0.01697250f, 0.01074618f, -0.02330904f, 0.01342886f, 
    0.02296287f, -0.01445541f, 0.02638818f, 0.00001614f, -0.00703287f, -0.03384310f, 0.03332248f, 0.02494923f, 
    0.04303214f, -0.01190935f, 0.01794215f, -0.00234125f, -0.05276939f, -0.01296968f, 0.02771984f, -0.02345501f, 
    0.04036675f, 0.00794270f, -0.05060276f, -0.01411099f, -0.01597576f, -0.04671037f, 0.00359677f, 0.01942646f, 
    0.03406933f, 0.04334709f, 0.00602351f, -0.06152921f, -0.04277089f, 0.00736793f, -0.05793076f, -0.05882193f, 
    0.02516559f, -0.05818499f, -0.04253585f, 0.01327313f, 0.04005055f, -0.03129176f, -0.04440670f, 0.03609172f, 
    0.01290502f, -0.01432051f, -0.02518427f, -0.03389658f, 0.01818037f, -0.01941151f, 0.04896196f, -0.02840009f, 
    -0.01832689f, 0.04493971f, 0.01480744f, -0.01298598f, -0.03280730f, 0.01516762f, 0.01942668f, -0.04668304f, 
    -0.01951613f, 0.04045486f, -0.01611986f, -0.01825380f, -0.01135000f, 0.04017660f, 0.04542173f, -0.01610615f, 
    -0.04265736f, -0.02547175f, 0.03251545f, 0.01328585f, -0.00657364f, -0.02042225f, -0.04766662f, -0.02881327f, 
    0.01489937f, -0.05526601f, -0.00915226f, -0.00434754f, 0.03423041f, -0.00801644f, -0.04568766f, 0.00400453f, 
    -0.03211287f, 0.02593073f, 0.04458670f, -0.02143144f, -0.03242193f, 0.01616832f, -0.04262792f, 0.03255253f, 
    -0.02736930f, 0.03665450f, 0.04538627f, 0.01133001f, -0.04942054f, -0.00385412f, -0.05214062f, 0.01106816f, 
    -0.06384277f, -0.06179562f, -0.03173034f, 0.02098504f, -0.06245965f, -0.05336540f, -0.01972887f, 0.02290048f, 
    -0.05486435f, -0.00313420f, -0.01122238f, 0.01335995f, -0.00080540f, -0.00312729f, -0.03291998f, -0.01729970f, 
    0.02955216f, 0.02515198f, 0.01269872f, 0.00706506f, -0.04275683f, -0.02373758f, 0.04512227f, -0.01851231f, 
    -0.00652899f, 0.02377487f, 0.03362416f, 0.04080648f, 0.02914128f, 0.04639032f, 0.02077819f, -0.05588020f, 
    -0.01880426f, 0.02526440f, -0.04416044f, 0.03716421f, 0.03798373f, -0.02749403f, -0.00842324f, -0.05494076f, 
    0.02732672f, -0.05582331f, -0.05882910f, -0.02420535f, -0.01436227f, -0.06139855f, -0.04368648f, -0.02463746f, 
    -0.03824811f, 0.03793862f, -0.05333718f, -0.05665431f, -0.00418151f, -0.03382554f, 0.01215188f, 0.00448737f, 
    -0.01013711f, -0.01356948f, 0.00974389f, -0.05452332f, -0.05856454f, -0.05844872f, 0.03526982f, 0.02549279f, 
    0.30679128f, -0.00868727f, -0.08998515f, 0.01444291f, -0.12773806f, 0.04489711f, -0.19820607f, 0.13484173f, 
    0.08389696f, -0.08686367f, -0.13171737f, -0.00693443f, 0.06493996f, 0.09828208f, 0.15482143f, -0.17568968f, 
    -0.05941557f, 0.07241752f, -0.06066515f, 0.10068650f, 0.25583720f, 0.22224829f, -0.05487793f, 0.12175468f, 
    -0.07667746f, 0.00109550f, -0.12817918f, 0.05611802f, 0.10821816f, 0.12525438f, -0.08569663f, -0.04009575f, 
    0.02124028f, 0.09312209f, 0.06046671f, -0.09789183f, -0.01080631f, -0.01303231f, -0.02302507f, 0.06187812f, 
    0.22471166f, 0.15390290f, 0.28629816f, -0.08990619f, -0.02178076f, 0.08657904f, -0.05388627f, 0.05335533f, 
    -0.02646453f, 0.11791298f, -0.02255049f, -0.08050030f, 0.01785503f, 0.03135286f, 0.01616218f, 0.07020231f, 
    0.02803290f, 0.20548587f, 0.06398411f, 0.05242077f, -0.12357877f, 0.02339451f, 0.03908752f, -0.21312062f, 
    0.18740933f, 0.20827687f, 0.10644978f, 0.01569563f, -0.08922056f, -0.04135460f, -0.08326799f, 0.00306251f, 
    -0.02108070f, -0.01218352f, 0.10728265f, 0.14152922f, 0.06726026f, 0.09380756f, -0.08754282f, 0.04849548f, 
    -0.02161453f, -0.20578259f, -0.37606725f, 0.00221260f, -0.04044874f, -0.14764068f, 0.19434245f, 0.07859225f, 
    0.05343740f, 0.06168409f, 0.08660793f, -0.02838933f, -0.02759856f, -0.03563494f, 0.12719028f, 0.17993622f, 
    0.20242739f, 0.23650749f, -0.03969991f, -0.12783915f, -0.42022726f, -0.06154782f, -0.40219665f, 0.01682895f, 
    -0.10802396f, 0.06517900f, 0.00791463f, -0.18617466f, -0.21084705f, -0.07416373f, 0.09986027f, 0.02312642f, 
    -0.01751622f, 0.21529077f, -0.01201727f, 0.11018181f, 0.08893295f, -0.11656705f, -0.11339941f, -0.03020967f, 
    -0.14359936f, 0.36622640f, 0.21514112f, 0.01732194f, 0.15464067f, 0.09440358f, 0.02952992f, -0.12566346f, 
    0.02210240f, -0.07481091f, 0.01580513f, -0.00510229f, -0.06636813f, -0.07105157f, -0.15279043f, -0.00728628f, 
    -0.04268609f, 0.00736145f, 0.07251585f, 0.01216604f, -0.03617276f, -0.25207919f, -0.14627773f, -0.13446441f, 
    -0.06101711f, 0.08073751f, -0.01684429f, 0.09826950f, -0.14042616f, -0.05477119f, 0.00078230f, 0.03756696f, 
    0.05493540f, 0.02367046f, 0.07080641f, 0.10004444f, 0.14786303f, 0.04182838f, -0.05447269f, -0.04327597f, 
    -0.13734703f, 0.08117237f, 0.10296224f, -0.08150285f, -0.11220355f, -0.18661901f, -0.13498807f, -0.07488430f, 
    -0.08709948f, -0.00691738f, 0.03912388f, -0.04264718f, -0.06161975f, -0.14950070f, -0.01383533f, 0.00438611f, 
    0.07535622f, -0.02224701f, -0.08371555f, -0.09303900f, -0.17848088f, -0.45844242f, -0.51451361f, -0.02074572f, 
    -0.13961042f, 0.01417232f, 0.12331907f, -0.03060903f, -0.09320497f, 0.10262268f, 0.12073951f, -0.02325990f, 
    -0.14061803f, 0.13956778f, 0.05348263f, 0.02111286f, 0.07729928f, 0.01760181f, -0.10338417f, 0.07949311f, 
    0.15610079f, -0.19203971f, -0.40772441f, -0.35903364f, 0.18024378f, 0.06949745f, 0.11261448f, 0.11625031f, 
    -0.01855464f, 0.09093523f, 0.13112853f, 0.05408346f, 0.13056336f, 0.13675897f, -0.00908485f, -0.09375218f, 
    0.03675132f, 0.06047280f, -0.05927974f, 0.15242206f, 0.25103217f, 0.49936417f, 0.22327681f, 0.05049539f, 
    0.06335431f, 0.07157958f, 0.15245193f, 0.02083184f, 0.06527058f, 0.02040110f, 0.11535786f, -0.04683059f, 
    -0.12638587f, -0.00263816f, 0.02300899f, -0.03180855f, -0.06291121f, 0.05634298f, 0.02972764f, -0.01623361f, 
    0.02983821f, 0.13510822f, 0.15591384f, 0.12888178f, 0.12968898f, -0.09991846f, 0.05824526f, 0.04020359f, 
    -0.03577451f, 0.15598522f, 0.02773580f, -0.06425914f, -0.04798622f, -0.04651592f, -0.06740970f, -0.07894515f, 
    -0.06707731f, 0.18166912f, 0.01599140f, -0.05993592f, -0.13743745f, 0.35388780f, 0.20013118f, 0.00393363f, 
    0.10727634f, 0.09491123f, 0.03050575f, 0.00343132f, 0.01102412f, -0.11296332f, -0.02967988f, -0.14988390f, 
    -0.11473110f, -0.07895532f, -0.06139992f, -0.02989825f, 0.06800348f, -0.10430750f, 0.11358996f, -0.18099360f, 
    0.08085983f, 0.13282271f, -0.37272337f, -0.08087808f, -0.21085881f, 0.13528545f, -0.00897710f, -0.11203842f, 
    -0.05637026f, 0.10726788f, -0.09560435f, -0.00395941f, 0.18136223f, 0.13418753f, 0.08070516f, -0.01022492f, 
    0.04052811f, -0.02364032f, -0.07022066f, 0.04827265f, 0.10086409f, 0.08917012f, 0.18481131f, -0.26105282f, 
    0.12546577f, 0.03164755f, -0.06126294f, 0.14731213f, -0.11094119f, 0.15476678f, -0.08862610f, -0.02274337f, 
    0.04099205f, -0.11314209f, -0.02388884f, 0.00482226f, -0.07161283f, -0.01538035f, -0.03010495f, -0.02041807f, 
    -0.06169823f, 0.00085051f, -0.00579444f, -0.01549114f, -0.00861081f, -0.03277519f, -0.05695708f, 0.00838155f, 
    0.02217192f, -0.01438574f, 0.01498383f, -0.03640500f, -0.03580588f, -0.05200232f, 0.04351300f, -0.01522238f, 
    -0.04622155f, 0.03344452f, -0.00868091f, -0.01849494f, -0.00773009f, -0.02506720f, 0.03101240f, 0.03609683f, 
    -0.04217994f, -0.04862062f, 0.02287934f, 0.00382797f, -0.02605676f, -0.02094784f, 0.01746102f, -0.02861737f, 
    0.02026793f, 0.03110086f, 0.01058717f, -0.03641257f, -0.05051606f, -0.03403588f, -0.01257796f, 0.01954568f, 
    -0.01553107f, -0.04100236f, -0.04224862f, -0.01280283f, -0.00857033f, 0.03405014f, -0.05854871f, -0.00348619f, 
    0.03027140f, -0.00911193f, 0.03217452f, 0.00612484f, 0.01251644f, -0.06201960f, -0.04350514f, -0.06197965f, 
    -0.05207654f, -0.02954616f, -0.05585124f, -0.01639608f, -0.05905693f, 0.02848415f, -0.01399574f, -0.05088157f, 
    -0.04281924f, 0.03421732f, 0.01078628f, -0.03523598f, -0.01961094f, 0.03790834f, 0.03552871f, -0.04059662f, 
    0.04275783f, -0.01838565f, 0.04125296f, -0.03707384f, 0.01327207f, -0.04597351f, 0.03958555f, -0.01839370f, 
    -0.03551297f, 0.04093586f, -0.01974580f, 0.02529605f, -0.01864439f, -0.03587436f, 0.01648929f, 0.02912339f, 
    0.00646088f, -0.04566980f, 0.02398985f, -0.03686636f, -0.04449962f, -0.05674915f, 0.02844847f, 0.03580987f, 
    -0.04077915f, -0.01913179f, -0.02261462f, 0.04817066f, 0.02144723f, 0.04298986f, -0.03581706f, 0.03596337f, 
    -0.04758343f, -0.01745487f, -0.03114241f, 0.00671510f, -0.04166840f, -0.01962711f, -0.05667710f, 0.01133502f, 
    0.01640646f, -0.02658816f, 0.01662583f, 0.04261632f, 0.03956791f, 0.01186400f, -0.05711937f, -0.00542649f, 
    -0.04298344f, -0.02419330f, -0.03313423f, -0.02371056f, -0.01309956f, 0.02740525f, 0.04008327f, -0.05452091f, 
    -0.05268199f, -0.02494024f, -0.03580509f, 0.00287565f, -0.01660974f, -0.02382644f, -0.02135740f, -0.05788226f, 
    -0.04610153f, -0.05170905f, 0.04013457f, -0.06344680f, 0.04075668f, -0.00988361f, 0.00401241f, 0.01371640f, 
    -0.01848336f, 0.01547696f, 0.02452166f, 0.01134986f, -0.04134538f, -0.04021941f, -0.01999653f, -0.00266248f, 
    0.01395686f, 0.02770144f, -0.02233741f, -0.04429498f, -0.02173805f, -0.00704590f, -0.05093088f, -0.00854705f, 
    -0.04858933f, -0.02486537f, -0.05062733f, 0.03229356f, -0.02291334f, -0.02387884f, 0.02163281f, 0.01961752f, 
    -0.05903075f, -0.03480973f, -0.02327076f, 0.03256289f, -0.03863667f, -0.00994053f, -0.04021909f, -0.06181816f, 
    0.03745229f, -0.03959656f, -0.06126898f, 0.00198187f, 0.04503436f, -0.05568144f, 0.02385061f, -0.05452980f, 
    0.02971280f, 0.04245904f, 0.03524959f, 0.04155245f, -0.03505977f, 0.03676330f, 0.01534878f, -0.06416222f, 
    -0.03629444f, -0.06012330f, -0.05315935f, -0.03997860f, -0.01580020f, -0.04639083f, 0.00171893f, -0.04364238f, 
    -0.03248620f, -0.05188293f, 0.00639064f, 0.00445571f, -0.03483543f, 0.03671488f, -0.02326965f, -0.05356904f, 
    0.02307668f, 0.04305782f, 0.01692294f, 0.02013114f, -0.01977206f, -0.01667550f, 0.01601863f, -0.00404133f, 
    -0.02434216f, -0.01383353f, -0.03946760f, 0.01534274f, -0.02068180f, 0.00417908f, -0.05615829f, -0.02467223f, 
    0.02793560f, -0.00559844f, -0.03872258f, -0.04204977f, 0.01740035f, 0.01355184f, 0.04702733f, 0.02482902f, 
    -0.00329095f, 0.04906578f, 0.04466514f, 0.00083334f, -0.05957728f, 0.04609258f, 0.00076846f, -0.01625918f, 
    0.00076022f, 0.00283928f, 0.00655769f, 0.01991717f, 0.00216816f, 0.00882787f, 0.00440455f, 0.03193007f, 
    0.01244460f, -0.01223295f, -0.01683872f, 0.03181408f, -0.01079680f, -0.04799823f, 0.00124069f, -0.02338637f, 
    -0.02476663f, 0.03902376f, -0.03355594f, -0.00191971f, 0.02500461f, 0.00410846f, 0.03140700f, -0.02830024f, 
    0.00101430f, 0.02128773f, 0.01441551f, 0.01663918f, 0.01748196f, 0.02308161f, -0.00633124f, 0.02160106f, 
    0.00093768f, -0.06211035f, 0.03120924f, 0.03821606f, -0.03152151f, 0.02263594f, -0.01863808f, 0.00030047f, 
    -0.05338698f, 0.00465197f, 0.01051118f, -0.00097739f, -0.03092692f, -0.02018597f, -0.04771529f, 0.00313075f, 
    -0.01438852f, -0.00140545f, -0.03476825f, -0.00363959f, -0.01096917f, 0.03869606f, 0.02594354f, -0.02784189f, 
    -0.05557361f, 0.02758414f, -0.05474903f, 0.04247264f, -0.03398276f, -0.04610350f, -0.05136269f, 0.02362932f, 
    -0.04627289f, -0.00250739f, 0.04446372f, -0.03897153f, -0.05926437f, 0.00597835f, 0.04178901f, 0.03900890f, 
    0.03778042f, 0.03768027f, 0.04334573f, 0.00275416f, 0.03358601f, -0.03044399f, -0.03765394f, 0.04429467f, 
    -0.26921856f, -0.18559219f, 0.06696756f, -0.32324824f, 0.26259622f, 0.05485730f, -0.06749290f, -0.06525002f, 
    0.06932894f, 0.00212476f, 0.13685092f, 0.05620648f, 0.07954182f, 0.05886354f, -0.07067813f, -0.05302959f, 
    0.07032085f, -0.02731961f, 0.13863809f, 0.00796830f, 0.11647072f, 0.18024939f, -0.26072127f, 0.26440847f, 
    0.07889009f, -0.01605785f, -0.03690249f, 0.02671782f, 0.14379053f, 0.11744057f, -0.02568655f, -0.07777049f, 
    0.05046242f, -0.06417094f, 0.00548328f, -0.11599962f, 0.03761946f, 0.01302721f, -0.04172047f, -0.04230819f, 
    -0.39690867f, -0.15422568f, -0.16333441f, 0.07424341f, 0.07789913f, -0.17544474f, 0.09619970f, -0.06549857f, 
    -0.02499953f, -0.06007971f, 0.06328271f, -0.01335867f, -0.08716934f, 0.07620661f, 0.05818287f, 0.07363775f, 
    0.16581216f, 0.02468730f, 0.04854798f, 0.13333613f, -0.10427388f, -0.04837890f, 0.25382572f, -0.19304428f, 
    -0.11915240f, 0.13859761f, -0.03188407f, -0.03264229f, -0.11895620f, 0.08032126f, 0.07101347f, 0.02035519f, 
    0.10152532f, -0.01685441f, -0.03921431f, 0.04421810f, 0.04579390f, -0.11860955f, 0.14659859f, 0.08414123f, 
    -0.38699996f, -0.23447745f, -0.21021381f, 0.00080719f, 0.07197998f, 0.15980235f, 0.04893052f, -0.03478453f, 
    -0.15843792f, -0.12095530f, 0.02851027f, -0.21814752f, -0.06978439f, -0.06492788f, 0.08855822f, 0.14110358f, 
    0.14614810f, -0.00689826f, -0.09587012f, -0.04216788f, -0.04883638f, 0.28703052f, -0.13983569f, 0.21002546f, 
    -0.16989136f, -0.09221081f, -0.13621230f, 0.00667411f, -0.15215829f, -0.04043761f, 0.09984946f, -0.02571468f, 
    0.15381877f, 0.08667850f, -0.01308430f, 0.14463603f, -0.08681712f, 0.07228984f, 0.16575034f, 0.06903132f, 
    0.12452628f, -0.08782770f, 0.13379134f, 0.08958568f, -0.23662400f, 0.12067243f, 0.01806681f, 0.08316258f, 
    -0.07941180f, -0.04816646f, -0.03384153f, -0.00654157f, 0.05304608f, 0.00379367f, 0.01681333f, -0.02098070f, 
    0.03745558f, 0.05977897f, 0.04533944f, 0.01789106f, -0.17667615f, -0.17243296f, -0.14419773f, -0.07661780f, 
    0.02674613f, 0.07688358f, -0.16860119f, -0.00532188f, -0.20352380f, -0.04372048f, 0.06147314f, -0.12220294f, 
    -0.02908202f, -0.08857767f, 0.01048945f, 0.07594366f, -0.05366453f, -0.01991662f, -0.04693390f, -0.12337235f, 
    0.19137847f, 0.13709985f, -0.28298110f, 0.15230483f, -0.03613981f, -0.01637386f, 0.11809994f, 0.15787527f, 
    0.08357383f, 0.12528680f, 0.05729707f, 0.02364556f, 0.11897938f, 0.06045134f, 0.10009973f, -0.02139767f, 
    -0.11289999f, 0.12892564f, 0.03230688f, 0.08432680f, -0.53129393f, -0.08445534f, -0.13862446f, 0.08765642f, 
    -0.15889472f, 0.01473100f, 0.00317863f, 0.01920046f, -0.14643748f, -0.03147692f, 0.04230937f, -0.27144524f, 
    -0.10347395f, -0.11591767f, 0.06125854f, -0.03184880f, -0.13181326f, 0.05617828f, 0.04226455f, -0.00250930f, 
    -0.09995372f, 0.18625459f, 0.28231621f, -0.17939803f, 0.10842541f, 0.01243801f, -0.03084347f, -0.17711788f, 
    -0.01607161f, -0.01083133f, 0.01500413f, 0.02709026f, -0.02439159f, 0.06754042f, 0.17039500f, 0.01478895f, 
    0.09515664f, 0.09603640f, 0.00924735f, -0.01535232f, 0.46675238f, -0.24487840f, -0.08705915f, -0.02322279f, 
    0.03401788f, 0.06193696f, 0.19060796f, -0.07427344f, 0.04125471f, 0.07163829f, 0.06698134f, 0.11763161f, 
    -0.06376786f, 0.07284106f, 0.03868762f, 0.08354865f, 0.01243696f, 0.03971496f, -0.00060757f, 0.14788713f, 
    -0.10627886f, -0.00502922f, 0.18303756f, 0.03245898f, 0.09228096f, -0.06422100f, 0.25411281f, 0.05922307f, 
    0.01572465f, 0.01077665f, 0.03328652f, 0.04099841f, 0.03963084f, 0.09706996f, 0.05015480f, 0.09854665f, 
    0.24796404f, 0.11988349f, 0.05839965f, 0.05655873f, -0.08215480f, -0.17493328f, -0.33454305f, 0.13798796f, 
    -0.15364432f, -0.00802147f, -0.06337105f, 0.11622688f, 0.08807214f, 0.11997062f, -0.15731004f, 0.04683910f, 
    -0.08606698f, 0.05572520f, 0.06987185f, -0.06157937f, -0.16268563f, -0.04102563f, 0.21876517f, 0.07340872f, 
    0.18850088f, 0.31079197f, 0.27576697f, 0.13283502f, 0.20025036f, 0.05565811f, -0.08810276f, -0.17863663f, 
    -0.09528427f, 0.10306177f, -0.03395316f, 0.09687565f, 0.07354544f, 0.01446241f, 0.01269534f, -0.11970060f, 
    0.04222929f, 0.03889303f, -0.03364396f, -0.08961072f, 0.17462498f, -0.11278552f, -0.07662090f, 0.12994047f, 
    0.35957924f, 0.00065044f, 0.07560318f, 0.07880689f, 0.09082028f, 0.13553445f, 0.05960619f, 0.09276835f, 
    -0.02225651f, 0.03462775f, 0.10965122f, -0.03670894f, 0.09727468f, 0.01023734f, -0.15951093f, 0.07638418f, 
    0.02758012f, -0.02866107f, -0.04688470f, -0.03573373f, 0.03138395f, 0.02934782f, 0.04472851f, 0.04044696f, 
    -0.00700548f, -0.00013569f, -0.00441810f, -0.05342532f, 0.01562440f, -0.00670732f, -0.00710507f, -0.03858471f, 
    0.02117847f, -0.03829082f, -0.00755593f, 0.00884698f, 0.00909196f, 0.04392900f, 0.00820762f, -0.01004465f, 
    0.01458837f, -0.01360197f, 0.02434275f, -0.04826840f, -0.02808976f, -0.03174444f, -0.05801164f, 0.01952150f, 
    -0.04792887f, -0.04534668f, -0.05037031f, 0.00981759f, -0.03974926f, -0.04712860f, 0.01967645f, 0.00961366f, 
    -0.03162213f, 0.00612481f, 0.05558972f, 0.00073844f, -0.03945368f, -0.03628035f, 0.02270728f, -0.04791024f, 
    0.03258121f, 0.03861396f, 0.02917083f, -0.04110594f, 0.01073263f, 0.00000930f, 0.03602960f, 0.01022992f, 
    0.01799237f, 0.03102732f, 0.03692318f, -0.02998604f, -0.00467812f, 0.01528909f, -0.01740569f, -0.03787424f, 
    0.00912220f, -0.05325504f, -0.01460062f, -0.01150900f, -0.02448309f, 0.03813233f, -0.04705187f, 0.00270378f, 
    -0.02965618f, -0.04523523f, -0.01684351f, 0.00558523f, -0.05219754f, 0.01134963f, 0.02258329f, 0.05150076f, 
    -0.04003384f, 0.05010417f, 0.02921442f, -0.03529180f, -0.03349546f, -0.02818809f, -0.03602678f, -0.03468823f, 
    -0.00842879f, 0.03608847f, -0.05610985f, -0.05702627f, -0.02104475f, -0.02895525f, -0.00350556f, 0.00640749f, 
    0.02371902f, -0.00549541f, -0.03107276f, 0.03812008f, -0.03396470f, -0.03141284f, 0.00680092f, -0.03418003f, 
    0.02584214f, 0.01272495f, 0.02380465f, 0.04303928f, -0.02631355f, 0.02078195f, -0.02225678f, -0.04942056f, 
    -0.00356984f, -0.04494470f, -0.03301839f, -0.00523773f, 0.04330360f, -0.00312098f, 0.03467150f, 0.03124072f, 
    -0.04408162f, 0.02517464f, 0.00904005f, -0.03913974f, -0.00671261f, -0.02414566f, -0.05868349f, -0.01453095f, 
    -0.05307053f, 0.01803124f, 0.03237959f, -0.05090237f, 0.02104069f, 0.04543167f, 0.00135494f, 0.05065726f, 
    -0.00625212f, -0.04901952f, -0.03630861f, 0.03175515f, 0.00199565f, 0.03973144f, -0.01178141f, 0.03623244f, 
    0.01538925f, 0.03181483f, -0.03176313f, -0.04189615f, 0.02426714f, -0.02340370f, 0.00951120f, -0.01574840f, 
    -0.05069748f, -0.05228658f, 0.00400709f, -0.05799403f, -0.02266286f, -0.03533397f, 0.02119643f, -0.04753728f, 
    0.00143682f, -0.05943505f, -0.04661232f, -0.05305649f, -0.04969498f, 0.02616562f, -0.00637494f, -0.03202295f, 
    0.00821758f, 0.00538610f, 0.00974789f, -0.02207581f, 0.00671061f, -0.04314819f, -0.02924807f, -0.06164371f, 
    0.04646485f, -0.03575468f, -0.04906991f, -0.04646108f, -0.02576035f, -0.01073979f, -0.04600343f, -0.04275659f, 
    -0.01831887f, 0.05127383f, 0.01365449f, -0.02779274f, 0.02243482f, -0.01141289f, 0.02028553f, 0.03662566f, 
    -0.00012570f, -0.00127424f, -0.01665188f, 0.02084596f, -0.03005295f, -0.00227883f, -0.04296963f, -0.01247036f, 
    0.03487129f, -0.04189194f, -0.00422100f, -0.00516926f, 0.03813080f, 0.01303536f, 0.00920162f, -0.02638149f, 
    0.04296925f, 0.02066935f, -0.00053075f, 0.05910416f, -0.05735480f, -0.00427442f, 0.02610883f, 0.04470435f, 
    -0.00178035f, -0.00534167f, 0.03029288f, -0.02862516f, 0.03950364f, 0.00346118f, -0.01768545f, 0.00451376f, 
    0.02380011f, -0.04668542f, 0.04909766f, 0.01856602f, 0.00245934f, -0.02774301f, 0.00342781f, 0.02286571f, 
    -0.02728061f, -0.00474233f, -0.03695774f, -0.00477103f, 0.03197065f, -0.02057130f, -0.03192315f, -0.00078473f, 
    0.00257955f, -0.01105997f, 0.05240092f, -0.03461312f, -0.03741474f, -0.02181216f, -0.03769091f, 0.02571907f, 
    -0.05361829f, -0.03121932f, 0.05023410f, 0.01884387f, -0.03823543f, 0.01225551f, 0.03381592f, 0.04869668f, 
    0.01381653f, 0.04433704f, -0.01597313f, -0.03120342f, 0.02085044f, 0.01915363f, -0.00545975f, 0.04227109f, 
    -0.04615548f, -0.01316431f, -0.00120501f, -0.01051010f, 0.03954918f, -0.00005534f, 0.03051829f, -0.02544623f, 
    -0.04650678f, 0.03403778f, -0.05521036f, -0.05435998f, -0.04310469f, -0.05056922f, 0.00014968f, -0.05412304f, 
    -0.01627813f, -0.01783809f, -0.00052829f, 0.01202219f, -0.05667691f, 0.01200615f, 0.02973555f, 0.00317873f, 
    -0.04534882f, -0.02977395f, 0.00770421f, -0.01212007f, 0.00606404f, -0.01997237f, 0.00418960f, -0.05556690f, 
    -0.03446888f, 0.01541449f, -0.05963364f, 0.02381181f, 0.01688758f, 0.05144627f, -0.01310533f, -0.01871928f, 
    -0.00504636f, 0.00165295f, 0.05193435f, 0.01521534f, -0.00538247f, 0.00625473f, 0.04293853f, -0.01363838f, 
    0.02070116f, -0.05924158f, -0.03630680f, -0.00531109f, 0.03747222f, -0.06054851f, -0.01143970f, 0.02314221f, 
    0.03896500f, 0.01609659f, 0.01764912f, -0.01491940f, 0.03292005f, -0.01702897f, -0.02250368f, -0.02606576f, 
    -0.05087507f, -0.01374978f, 0.02225066f, -0.02523647f, -0.05830337f, -0.02380124f, -0.00348286f, 0.04136272f, 
    0.03330076f, -0.03532183f, 0.03574279f, -0.03009836f, -0.03065184f, 0.00090445f, 0.04568361f, 0.04684347f, 
    0.02742396f, -0.04438017f, -0.00385896f, -0.02218305f, -0.05379453f, -0.01495923f, 0.03619224f, -0.02515600f, 
    0.01560516f, 0.02333672f, -0.04352992f, -0.02346406f, -0.01625509f, -0.03228308f, -0.03244618f, 0.00796345f, 
    0.02783217f, 0.04028369f, 0.03945301f, -0.03886634f, -0.05049089f, 0.02360832f, 0.04784576f, -0.00550320f, 
    -0.02335019f, -0.03823400f, 0.00227681f, 0.03072214f, -0.04184822f, 0.00321730f, -0.04266358f, -0.05357717f, 
    -0.04354792f, -0.02109757f, 0.00350708f, -0.03582798f, -0.00237228f, -0.05735165f, -0.01176689f, -0.01936077f, 
    0.01209297f, 0.00065945f, -0.04990554f, 0.03855219f, -0.00552588f, 0.00187137f, -0.04243357f, -0.01858394f, 
    0.04082413f, 0.01464623f, -0.01902013f, -0.02193310f, 0.03565480f, -0.05896501f, -0.03923746f, -0.05483589f, 
    -0.03101955f, -0.05220469f, 0.04201131f, 0.01672566f, 0.00519484f, 0.04305947f, -0.04353668f, -0.05561371f, 
    -0.03462663f, -0.03913482f, 0.02994974f, 0.01960430f, -0.05966450f, 0.02103297f, -0.00420414f, 0.01866530f, 
    0.01361545f, 0.00964404f, 0.01562640f, 0.04407278f, -0.01957795f, -0.00019030f, 0.00227012f, -0.06156977f, 
    0.04630807f, -0.00377820f, 0.02260715f, 0.00258491f, 0.00949096f, -0.03939055f, 0.04108167f, 0.00150050f, 
    -0.00398877f, 0.02762752f, -0.01126239f, -0.01313477f, 0.04720730f, 0.00637889f, 0.01723839f, 0.01071238f, 
    0.04046175f, 0.03395642f, 0.01948788f, -0.05673252f, -0.02290238f, 0.01577128f, -0.04258357f, -0.03787344f, 
    -0.01546934f, 0.01090977f, -0.02059780f, 0.00021108f, -0.01749374f, -0.02803631f, -0.04236370f, 0.03620402f, 
    0.03440562f, -0.04748755f, -0.04688570f, -0.05963183f, -0.02718459f, 0.03967860f, -0.04758461f, 0.00596235f, 
    -0.05078127f, 0.01508923f, -0.05232628f, -0.00359045f, -0.01477635f, 0.02797536f, -0.06118106f, -0.01866226f, 
    -0.04338119f, -0.05053736f, -0.02211657f, -0.05516050f, -0.03116768f, 0.03634756f, -0.06190428f, 0.03165838f, 
    -0.05129745f, -0.05661562f, 0.00934575f, 0.01755273f, 0.03977863f, -0.00951497f, -0.00248577f, -0.04140057f, 
    0.02041177f, 0.04340898f, -0.03015281f, 0.04725475f, 0.01251534f, -0.01826099f, 0.02713564f, -0.03264325f, 
    -0.05810811f, 0.03512952f, -0.00864025f, 0.02547260f, 0.02094544f, 0.01243845f, 0.04496984f, -0.00681749f, 
    0.00442617f, -0.01988851f, -0.02417455f, -0.06065426f, -0.01470665f, 0.00941473f, -0.02263779f, -0.02624806f, 
    -0.02645963f, 0.03816858f, -0.01470658f, -0.05928102f, -0.02252145f, -0.05427958f, 0.01188485f, -0.02962644f, 
    0.04039623f, -0.01009951f, 0.01352155f, 0.04846964f, -0.06004610f, -0.02777031f, 0.01239471f, -0.00444181f, 
    -0.00342299f, 0.01178869f, 0.01570822f, -0.04618268f, 0.00205844f, -0.01811557f, -0.01742990f, -0.04078535f, 
    -0.04352783f, 0.01023025f, 0.02284667f, 0.02443141f, -0.04125144f, 0.03969502f, -0.04299471f, -0.01214934f, 
    -0.02610493f, -0.03648680f, -0.01934542f, -0.05370409f, -0.02535758f, -0.00794627f, -0.06059515f, 0.01382650f, 
    0.01044837f, 0.02204542f, -0.00808400f, 0.04014873f, 0.02900823f, -0.00423389f, 0.03606246f, -0.00657595f, 
    0.02093369f, -0.04453746f, -0.01695501f, 0.02278337f, -0.01168060f, -0.04863760f, -0.02088172f, -0.00190902f, 
    -0.00381715f, -0.01107922f, -0.03064544f, -0.01143374f, -0.01516202f, 0.00452854f, 0.01900803f, -0.05954964f, 
    0.04744343f, -0.03815762f, -0.04725973f, 0.00371454f, -0.02280009f, -0.01054895f, 0.04069033f, -0.01489595f, 
    0.02176136f, 0.02093381f, -0.02795717f, -0.01140555f, -0.01309831f, -0.06165663f, -0.03752318f, -0.03049808f, 
    -0.03090682f, -0.01911649f, -0.00823359f, -0.03280360f, -0.03923776f, 0.02004307f, -0.00021217f, -0.01582585f, 
    0.00477745f, -0.02336429f, 0.01226867f, 0.00463799f, 0.02517051f, -0.01068337f, 0.03693978f, -0.02325913f, 
    -0.03898418f, 0.02481057f, 0.03485271f, -0.00446891f, -0.06118819f, 0.00676680f, -0.02428007f, -0.03118739f, 
    0.00180960f, -0.01739189f, -0.04169058f, -0.03204406f, -0.00857388f, 0.01939091f, 0.02682704f, -0.06066725f, 
    -0.06079422f, -0.04041799f, -0.01152519f, 0.02456451f, -0.02334576f, 0.03381988f, -0.02877115f, 0.02008395f, 
    0.00250528f, 0.00590847f, -0.02501492f, -0.00343203f, 0.01594253f, -0.01774522f, -0.04152809f, -0.05679597f, 
    0.39952871f, -0.01225233f, 0.15582372f, -0.13902815f, -0.07205828f, -0.02418652f, 0.01022971f, 0.00869790f, 
    0.04695040f, 0.00525156f, -0.01949941f, -0.07616440f, 0.10382850f, 0.04141771f, -0.10162176f, 0.00843608f, 
    -0.04402107f, 0.04477990f, -0.08379874f, -0.01783866f, -0.43169969f, 0.22403200f, 0.08362059f, 0.14948031f, 
    0.11788137f, 0.14287606f, 0.04461517f, 0.05428309f, -0.01310177f, 0.09781912f, 0.04188062f, -0.06190387f, 
    -0.06589901f, 0.01650049f, 0.10929739f, 0.07184939f, -0.03435272f, 0.00218215f, 0.13054575f, -0.10680405f, 
    0.07243609f, -0.02719996f, 0.21921797f, 0.24982622f, -0.12296682f, -0.07179902f, -0.08326734f, -0.07972474f, 
    0.01592530f, -0.01146787f, 0.16762701f, -0.01164361f, 0.05651950f, -0.16155952f, -0.01473916f, 0.04435199f, 
    -0.15332344f, -0.25186899f, 0.06079246f, -0.10605285f, -0.20030063f, -0.15976922f, 0.05340211f, 0.11325092f, 
    -0.29318762f, -0.12872291f, -0.02869057f, -0.08431280f, -0.06147846f, 0.06283550f, -0.11003768f, 0.00508972f, 
    0.01490748f, -0.06928472f, -0.03452719f, -0.11701249f, 0.03448582f, 0.15056188f, -0.01873575f, -0.04075495f, 
    0.15404063f, 0.04261783f, -0.24700834f, -0.14060611f, -0.02418304f, -0.12815794f, -0.04052332f, -0.03064877f, 
    0.00659355f, -0.10049854f, -0.05001281f, -0.08605297f, -0.06417186f, -0.00979954f, -0.10242765f, 0.09416590f, 
    0.01912984f, -0.12742655f, 0.09610039f, -0.01688350f, -0.18846437f, -0.02749373f, 0.09868426f, -0.08241519f, 
    0.14871737f, 0.05056311f, 0.02034512f, -0.06874058f, -0.01501159f, -0.07831033f, 0.20939352f, 0.12990251f, 
    0.00568807f, 0.08197185f, 0.08657514f, 0.02506904f, 0.11919018f, -0.08182203f, 0.23328929f, 0.08116780f, 
    -0.02589579f, -0.00570229f, 0.00915289f, 0.13542835f, -0.02464623f, 0.05631649f, 0.06614590f, -0.07798849f, 
    0.05966808f, 0.07189956f, -0.04254317f, 0.11521295f, 0.01516960f, 0.09479699f, 0.03019205f, 0.01850511f, 
    0.00132201f, 0.03752734f, 0.08378441f, -0.02708410f, 0.14580683f, 0.08374831f, -0.16356370f, -0.09129364f, 
    0.05918262f, 0.05105042f, -0.01870303f, -0.01452483f, -0.02476614f, 0.02730261f, 0.22536340f, -0.04335244f, 
    -0.00167634f, 0.13953207f, 0.06124999f, -0.01647313f, 0.10415968f, 0.00107323f, 0.13447069f, -0.01523489f, 
    -0.17170362f, 0.09125356f, -0.26202679f, 0.13945408f, 0.09687456f, 0.16298328f, 0.05949049f, 0.26718208f, 
    -0.02946887f, 0.10689516f, -0.00156067f, 0.08276951f, 0.10670526f, 0.14724484f, 0.01757389f, -0.02698741f, 
    -0.02038238f, -0.09464470f, 0.02217967f, 0.07587229f, 0.11737514f, 0.05041711f, -0.08147994f, -0.00508238f, 
    -0.01137258f, -0.12967822f, 0.00806568f, 0.00880537f, -0.13583432f, -0.17363624f, 0.06304032f, -0.09234389f, 
    -0.06013149f, -0.03743502f, -0.16529818f, 0.09207190f, 0.02025154f, -0.06948605f, -0.01215118f, -0.07063731f, 
    0.11760961f, 0.03107835f, 0.14906885f, -0.12362412f, 0.01715639f, -0.16774617f, -0.15735663f, -0.09497726f, 
    -0.09057087f, -0.16541126f, -0.00258707f, 0.04913376f, -0.03470716f, -0.01891002f, 0.03061481f, 0.17463902f, 
    -0.05258452f, -0.10493606f, -0.06581222f, -0.13312423f, 0.07167836f, -0.19441971f, -0.09525389f, 0.08635233f, 
    -0.11342122f, -0.05321679f, -0.01816362f, -0.08235394f, 0.06901735f, -0.05606260f, -0.07828074f, -0.02160703f, 
    -0.00454343f, 0.01738966f, 0.11363777f, -0.07995977f, 0.10420828f, 0.07939013f, 0.10435788f, 0.07453132f, 
    -0.15738344f, -0.13933110f, 0.07832921f, 0.14262994f, -0.07327441f, 0.16005149f, -0.00530435f, -0.06350406f, 
    0.04296212f, -0.07248556f, -0.01081222f, 0.08214845f, 0.12512259f, 0.07045894f, 0.14027876f, -0.06911696f, 
    -0.00615394f, -0.00170200f, 0.01314921f, -0.13940232f, -0.55721778f, -0.14795867f, -0.12855324f, 0.42604023f, 
    -0.19348302f, -0.03373247f, 0.03469193f, 0.20077023f, -0.17378311f, 0.28140932f, 0.06763364f, -0.00894656f, 
    0.01288703f, -0.20777690f, -0.00386938f, -0.08658893f, 0.03748325f, -0.03923432f, -0.01426988f, 0.17961991f, 
    -0.58110905f, 0.03096127f, 0.12174524f, 0.01309991f, -0.21692517f, -0.03409953f, 0.03791129f, -0.11390506f, 
    -0.06898388f, 0.02209607f, 0.07803728f, 0.20959374f, 0.10678678f, 0.04778548f, 0.03547061f, 0.04243641f, 
    -0.02922821f, -0.05306398f, -0.03484799f, -0.03491941f, 0.36642230f, -0.08755700f, -0.13240494f, -0.05263571f, 
    -0.11242788f, 0.07650761f, -0.12004568f, -0.00616691f, -0.08856246f, 0.06899340f, 0.07362650f, -0.11441918f, 
    0.04756678f, 0.04172591f, 0.04611228f, -0.03480126f, 0.06305717f, 0.06601713f, -0.23220837f, 0.03659986f, 
    0.02110271f, 0.00792343f, -0.04766436f, 0.01181825f, -0.02306674f, 0.03471487f, -0.03195421f, -0.02405232f, 
    -0.00153492f, -0.01725807f, -0.00161459f, 0.04112111f, 0.04782721f, -0.04903725f, 0.03844279f, 0.02356515f, 
    -0.01147759f, 0.02923079f, 0.03373310f, 0.04601393f, -0.01947903f, -0.01880138f, -0.04456974f, -0.01986522f, 
    -0.01318957f, -0.05288381f, -0.01979552f, 0.03151299f, -0.00242764f, 0.03872895f, 0.04999693f, -0.05684443f, 
    0.02030001f, 0.03163618f, 0.03233517f, 0.04574168f, -0.06029079f, -0.05637695f, -0.05783315f, -0.02562182f, 
    -0.00222318f, 0.04204059f, -0.00081543f, 0.05745154f, -0.03939926f, 0.02522187f, -0.00521843f, -0.05975547f, 
    0.02947368f, 0.01016803f, -0.00203429f, 0.01811793f, -0.00273179f, -0.00272259f, -0.03628490f, 0.01517339f, 
    0.01790170f, -0.00207109f, -0.05211358f, -0.02468110f, 0.01387095f, 0.03287512f, 0.05171980f, -0.00685308f, 
    -0.03433543f, 0.01705872f, 0.03326833f, -0.02042012f, 0.02157602f, 0.00958257f, -0.00054226f, -0.01743462f, 
    0.04743698f, 0.02918400f, -0.01526897f, -0.04952792f, -0.01601240f, -0.02856664f, 0.03869926f, -0.01904526f, 
    -0.04963454f, 0.00815393f, -0.05379849f, 0.03680765f, 0.01408910f, 0.02971117f, 0.03000644f, 0.04170978f, 
    0.04676051f, 0.00087411f, 0.02052746f, 0.04372957f, 0.00897860f, 0.00276966f, 0.02203410f, 0.00054530f, 
    -0.05977811f, 0.02091508f, -0.05092005f, 0.02057891f, -0.01745497f, -0.00383908f, 0.00707942f, -0.06175181f, 
    0.03615265f, -0.03772295f, -0.03978448f, -0.02460768f, -0.04545933f, 0.01888317f, 0.03796871f, 0.02539754f, 
    0.01522177f, -0.00793135f, 0.00526240f, 0.00733717f, 0.04143918f, 0.01436010f, -0.01390705f, 0.03719354f, 
    0.03267903f, 0.02628363f, -0.02483866f, 0.01150566f, 0.04560328f, -0.05074062f, -0.04487257f, -0.04494299f, 
    0.02967799f, -0.01062120f, 0.03893519f, 0.04802839f, -0.02198623f, -0.00879915f, -0.01179425f, -0.05885761f, 
    -0.00897121f, -0.05337241f, 0.01612225f, -0.00265564f, -0.03417347f, -0.03657557f, 0.03586311f, 0.03089547f, 
    0.01682023f, -0.05845343f, -0.05711305f, -0.02692492f, -0.05357569f, -0.01773206f, 0.02114852f, -0.04131412f, 
    -0.00297775f, 0.02963288f, -0.05159427f, -0.03113931f, 0.04825404f, -0.02182295f, -0.05009952f, -0.02690203f, 
    -0.04864927f, 0.04234491f, 0.03492076f, 0.00764054f, -0.05941222f, -0.03708377f, 0.01513050f, -0.05055130f, 
    0.02323461f, -0.04249789f, -0.04882636f, -0.05190076f, -0.03090727f, -0.00326277f, 0.01369201f, 0.02119364f, 
    -0.02862610f, 0.01315994f, 0.01288247f, -0.01015708f, -0.06187247f, -0.02447962f, 0.02181771f, 0.02203174f, 
    -0.03239658f, 0.00703227f, -0.03965570f, -0.01267609f, -0.06056947f, 0.00824679f, 0.02638938f, -0.03938149f, 
    -0.05876866f, 0.02704723f, 0.02580309f, -0.00462387f, -0.05365946f, -0.05448699f, 0.03523897f, 0.01156110f, 
    -0.05537828f, 0.00187704f, -0.04142711f, 0.03404589f, 0.00257856f, -0.05016919f, -0.03307709f, -0.02278377f, 
    -0.03804322f, -0.03525436f, -0.04317357f, 0.03236267f, -0.00197417f, 0.01820504f, 0.01888269f, -0.00198799f, 
    0.01582680f, -0.01659037f, 0.05293226f, 0.02639060f, -0.00913708f, 0.00757818f, -0.01861611f, -0.01007748f, 
    0.00157927f, -0.04015731f, -0.03254152f, -0.02673274f, -0.01010029f, -0.03687179f, -0.00775291f, 0.03427520f, 
    0.04245834f, -0.02828627f, -0.05720076f, -0.02160138f, -0.00405883f, 0.03257181f, -0.00017070f, -0.03292263f, 
    -0.05748760f, 0.01071281f, 0.04306387f, -0.04167989f, -0.03277030f, 0.04472166f, -0.02756331f, 0.04288462f, 
    -0.00399398f, -0.04294446f, -0.00348530f, -0.01362910f, -0.00131597f, 0.02484946f, -0.03836537f, -0.03920767f, 
    -0.03577213f, -0.00425035f, -0.05230538f, -0.02389213f, 0.04234074f, -0.01348566f, -0.02494679f, -0.00256181f, 
    -0.02628796f, -0.05048825f, -0.06028593f, -0.04542384f, 0.02869654f, 0.01916779f, 0.00666408f, -0.04606901f, 
    -0.01042025f, -0.04982067f, -0.00718181f, -0.00692807f, 0.00087606f, 0.00123736f, -0.03301395f, 0.03482841f, 
    0.03290882f, 0.00103803f, 0.02660199f, -0.01465962f, -0.03309598f, -0.04728056f, -0.04623330f, -0.05580605f, 
    0.00844644f, -0.03712108f, 0.03811458f, -0.00569507f, -0.00288338f, -0.01149329f, -0.03120838f, 0.02785504f, 
    -0.01296473f, -0.00990594f, -0.01479977f, -0.05334261f, -0.03216889f, 0.03727377f, 0.02627731f, -0.02415738f, 
    0.03115548f, 0.03871502f, 0.04388110f, -0.01077411f, 0.02805596f, 0.00670477f, -0.05903961f, -0.03350813f, 
    0.00121761f, -0.03058142f, -0.05055251f, -0.04481583f, -0.06117463f, 0.04514650f, -0.05056839f, 0.00556835f, 
    -0.11959384f, 0.48532820f, 0.03628535f, 0.12038086f, 0.39504731f, -0.02402683f, 0.13289453f, 0.04225148f, 
    -0.10097163f, 0.10696878f, 0.04603451f, 0.02439957f, -0.01592857f, 0.02038543f, -0.05951443f, -0.17689224f, 
    -0.00191128f, -0.01344114f, -0.05681141f, -0.13140103f, 0.15392996f, -0.05245081f, -0.13320915f, -0.06038402f, 
    0.21413372f, -0.01048264f, 0.06974699f, 0.14459085f, -0.01372527f, 0.08276907f, 0.01078171f, 0.01444871f, 
    -0.18235439f, -0.10155519f, -0.07073782f, -0.00256234f, -0.10659524f, 0.07045861f, -0.00686609f, -0.15097499f, 
    -0.35803697f, -0.01587038f, -0.23848397f, 0.07124759f, 0.35698128f, -0.01303623f, 0.00518417f, -0.02064846f, 
    0.13421357f, -0.14607406f, -0.07154623f, 0.00083517f, -0.15316644f, -0.04202260f, 0.11646280f, 0.00688076f, 
    -0.06204748f, 0.06497792f, 0.01648884f, -0.12781219f, -0.09560009f, -0.12419192f, -0.07991482f, -0.13303955f, 
    0.00252828f, 0.01323949f, 0.03027018f, -0.02751012f, 0.16365753f, 0.08049206f, -0.12537378f, 0.04841558f, 
    0.06616812f, 0.00071291f, 0.03883717f, 0.06181376f, 0.12191393f, 0.06307384f, 0.03463706f, 0.00604243f, 
    -0.04389330f, -0.00263225f, -0.00694286f, 0.06262783f, 0.05688312f, 0.00185917f, -0.05339984f, 0.00236087f, 
    0.04831260f, -0.01075030f, 0.02080267f, 0.08193778f, -0.01698588f, 0.03932429f, -0.04432069f, -0.07429871f, 
    -0.09218990f, 0.06156068f, 0.14848991f, 0.12056860f, 0.26059666f, 0.02143499f, 0.13056752f, -0.12292794f, 
    -0.21094079f, -0.10171490f, 0.08094629f, 0.18011311f, -0.09966622f, 0.02005740f, 0.03439398f, -0.04821817f, 
    0.00661893f, 0.09792295f, -0.00385692f, 0.01268928f, 0.05293683f, 0.16001168f, 0.06305402f, 0.00596414f, 
    0.00451473f, -0.04830701f, 0.06193992f, 0.12660408f, 0.02276547f, -0.04443467f, -0.03788648f, 0.09381707f, 
    -0.06250780f, 0.12493338f, 0.02564415f, -0.01124644f, 0.12146627f, -0.02925657f, 0.06950623f, -0.09693296f, 
    0.12475841f, 0.01440347f, -0.01726278f, 0.06972360f, 0.02066538f, 0.05318617f, 0.04738621f, -0.03109730f, 
    -0.03400883f, 0.02406813f, -0.03389858f, -0.02476777f, -0.01064946f, 0.06098146f, 0.11654623f, 0.00486489f, 
    -0.01198094f, 0.02546214f, -0.02014335f, -0.07596315f, 0.16150576f, 0.16607131f, 0.28352886f, 0.13330948f, 
    0.06173610f, 0.02346859f, -0.08051515f, 0.05604028f, 0.12215248f, -0.05890230f, 0.16149044f, -0.04706221f, 
    0.05760319f, -0.05030331f, -0.06380093f, 0.00817149f, -0.02107761f, 0.04761312f, 0.09010597f, 0.07594486f, 
    -0.13141572f, -0.00071360f, 0.00034611f, -0.18889548f, -0.01316859f, 0.20965636f, 0.18152085f, 0.21007006f, 
    -0.13884574f, -0.17554687f, -0.12800530f, 0.00676760f, -0.07109738f, -0.13773111f, 0.00034610f, -0.02097628f, 
    0.13953049f, 0.00055493f, -0.12167203f, 0.06381568f, 0.04403984f, 0.09930149f, 0.03817553f, -0.03014100f, 
    -0.03592549f, 0.22503181f, 0.26757053f, 0.23252417f, -0.28501281f, 0.01257096f, -0.11499257f, -0.04849006f, 
    -0.07024204f, -0.06824739f, 0.15044315f, 0.04546789f, 0.04256109f, -0.04813233f, 0.19488136f, -0.03404143f, 
    -0.09962868f, -0.10183264f, 0.00457318f, 0.04929635f, -0.44376707f, -0.50872147f, -0.11884037f, 0.05662328f, 
    0.19918826f, 0.14066173f, 0.05667387f, 0.05321365f, 0.12664776f, -0.09388488f, -0.06598677f, 0.02337922f, 
    0.06105429f, 0.00153633f, 0.01342418f, 0.02019252f, 0.05709605f, 0.12762062f, 0.10042308f, 0.22554161f, 
    -0.15696552f, -0.10212591f, -0.08298982f, 0.15344711f, 0.12624644f, -0.00058914f, 0.12858899f, -0.06127293f, 
    0.08521227f, -0.18238193f, -0.08296005f, -0.00041954f, -0.06074558f, 0.03373723f, 0.11381181f, 0.06640138f, 
    0.01807720f, -0.01376927f, -0.10531227f, -0.11531347f, 0.08850319f, -0.22915995f, -0.10673937f, 0.13396347f, 
    0.17785053f, -0.18507113f, -0.02617478f, 0.06048490f, 0.15716521f, 0.11150367f, -0.15307462f, 0.07996996f, 
    -0.04460055f, 0.01253068f, -0.09063440f, 0.01961031f, -0.02978726f, 0.05032770f, 0.08365779f, 0.01069619f, 
    0.47583231f, -0.13598262f, 0.10294279f, -0.17928474f, 0.07054169f, -0.17267717f, -0.06258442f, 0.14043234f, 
    -0.16539277f, 0.01680622f, 0.11749174f, 0.10523173f, -0.19746800f, -0.05770509f, -0.07286883f, -0.00395472f, 
    -0.07084636f, -0.02093362f, 0.02923974f, -0.05417145f, -0.28038424f, 0.02427087f, -0.28652498f, 0.43768430f, 
    0.11750965f, 0.05488566f, 0.15198532f, 0.10651948f, 0.03111062f, 0.06382242f, -0.01080534f, 0.08441365f, 
    -0.04121538f, 0.06706879f, -0.03577216f, 0.02902017f, 0.05323265f, 0.00058634f, -0.18616208f, -0.15706164f, 
    -0.00758860f, -0.01799210f, -0.00857390f, -0.03625295f, 0.00954599f, -0.01296969f, -0.00451114f, -0.01879695f, 
    -0.04630389f, -0.01567174f, 0.01099531f, 0.03131779f, -0.05479552f, -0.05838849f, 0.03624729f, -0.02556532f, 
    -0.05910482f, -0.05042580f, -0.02628853f, 0.01532676f, -0.01879876f, -0.00623963f, 0.02070223f, -0.03101160f, 
    -0.04165113f, 0.01512646f, -0.00647273f, -0.00115374f, 0.03992588f, -0.01843072f, -0.00589116f, 0.03301836f, 
    0.03050510f, -0.03569792f, -0.04555516f, -0.05978091f, -0.05624456f, 0.04056515f, 0.00619032f, 0.02154827f, 
    -0.02190138f, -0.01002470f, -0.02176562f, -0.04123469f, -0.00563090f, -0.04745670f, -0.02585229f, 0.01092403f, 
    -0.03422332f, -0.03433012f, -0.01015777f, -0.05884628f, -0.01628267f, 0.01444774f, 0.05196743f, -0.02795728f, 
    -0.05447128f, 0.04556861f, -0.03115123f, 0.04325305f, 0.04924465f, 0.04226764f, 0.04501845f, 0.04797805f, 
    -0.01133983f, 0.00221830f, -0.04647012f, -0.01106569f, -0.01186126f, -0.03698028f, -0.02962111f, 0.02391904f, 
    0.04942922f, -0.05815057f, -0.04821965f, 0.04829482f, -0.00820116f, -0.01341122f, 0.02220080f, -0.00563281f, 
    -0.04824961f, -0.04260265f, 0.03819283f, -0.05445583f, -0.02745046f, 0.02193948f, -0.02017756f, 0.02239553f, 
    -0.05587805f, -0.03128286f, -0.00935270f, 0.03460282f, -0.05139543f, 0.02226044f, -0.03447853f, -0.01455314f, 
    -0.00855780f, 0.04306789f, -0.05532274f, -0.03608232f, -0.00426020f, -0.04635116f, 0.03023602f, -0.04850836f, 
    -0.04085602f, -0.06042256f, -0.02886916f, -0.03735243f, -0.01687787f, -0.01883695f, -0.02556944f, 0.00362544f, 
    0.04074124f, 0.03627681f, 0.03347579f, 0.00596909f, 0.00583025f, 0.03455577f, -0.04908810f, -0.04515913f, 
    -0.02730418f, 0.01091542f, -0.05959816f, -0.03490404f, -0.01898709f, 0.00249222f, 0.00385305f, 0.02933994f, 
    0.03955901f, 0.01188105f, 0.00983771f, -0.04501535f, -0.04124063f, -0.02096051f, 0.01014701f, 0.00506040f, 
    -0.03793963f, -0.02113298f, 0.05022646f, 0.04651759f, -0.03069334f, -0.03845557f, -0.00725252f, -0.01261992f, 
    0.01567032f, -0.04927383f, -0.02664998f, -0.00325237f, 0.02695019f, 0.03742708f, -0.01868978f, -0.00215931f, 
    -0.01926371f, -0.01899156f, 0.03196254f, -0.00334015f, 0.03225195f, -0.00810099f, 0.04813119f, 0.03968684f, 
    0.01739513f, -0.03391813f, -0.03648959f, 0.04116304f, 0.04402927f, -0.02160855f, -0.01070097f, 0.00996839f, 
    -0.01899404f, 0.01536514f, -0.04866421f, 0.03370754f, 0.00276801f, 0.00296801f, -0.02544616f, -0.02535336f, 
    -0.03446542f, -0.04764533f, 0.02676688f, 0.01017716f, -0.04162498f, -0.00479120f, 0.03270573f, -0.00129622f, 
    -0.02756991f, -0.05644802f, 0.04144730f, 0.00585258f, 0.00684410f, -0.00586560f, -0.02125970f, 0.00157081f, 
    -0.00305586f, -0.02073054f, -0.03635891f, -0.05471092f, 0.01488917f, -0.05079140f, 0.02783190f, -0.06082836f, 
    -0.04721933f, 0.03423800f, -0.03521999f, 0.03196631f, -0.04613145f, -0.01286667f, 0.01120693f, -0.01404968f, 
    -0.04900565f, -0.05402365f, 0.04513767f, -0.00177801f, -0.01749381f, -0.01656194f, -0.02954664f, -0.04080778f, 
    0.04567106f, -0.03903432f, -0.01125650f, -0.04855504f, -0.01104164f, -0.06113063f, -0.03062125f, -0.03584883f, 
    -0.03430581f, 0.04949115f, -0.01436592f, -0.01120405f, -0.06070002f, -0.04379867f, 0.02927861f, -0.05914370f, 
    -0.00359629f, 0.02472048f, -0.03631069f, -0.00634651f, -0.03134677f, 0.00833295f, -0.01086593f, -0.01682342f, 
    0.03672249f, -0.03695306f, 0.03098749f, -0.05760634f, 0.03869375f, 0.03172097f, 0.01754281f, -0.01044961f, 
    -0.03059210f, 0.02308676f, -0.05015006f, -0.00152298f, 0.00454567f, -0.04207323f, -0.02097375f, -0.02043531f, 
    0.04964234f, -0.05117993f, -0.02806842f, -0.04139566f, 0.01962795f, -0.03377399f, 0.04600676f, -0.05267913f, 
    -0.05751528f, -0.04844293f, 0.02969152f, 0.03185982f, -0.00484340f, 0.04621435f, -0.01834031f, 0.03704663f, 
    0.01320623f, -0.03677826f, -0.00514092f, -0.04944401f, -0.01046468f, -0.02819348f, 0.00889160f, -0.03487387f, 
    -0.00805171f, -0.03969730f, 0.01627227f, 0.00626848f, 0.03120208f, -0.01301404f, -0.00800387f, 0.00378871f, 
    -0.05730825f, -0.04776011f, 0.02684052f, 0.01736552f, -0.03702125f, 0.01747678f, -0.01513606f, -0.03500972f, 
    0.00864525f, -0.01071810f, -0.00807081f, -0.04012500f, 0.02343007f, 0.03089552f, 0.00796826f, -0.05414617f, 
    -0.00347598f, -0.03545893f, 0.00621287f, -0.02106558f, -0.03153211f, -0.05945171f, 0.03018576f, -0.05337337f, 
    -0.01712826f, -0.02253651f, 0.01189519f, 0.01832955f, -0.03131033f, 0.02665370f, -0.01864529f, -0.04931766f, 
    -0.00792063f, -0.03548506f, -0.02752938f, 0.02378156f, -0.02831594f, 0.00997119f, -0.02131548f, 0.00785826f, 
    0.01803689f, 0.00000989f, -0.04481480f, -0.01201558f, -0.01267405f, 0.02458606f, -0.03037705f, -0.00752837f, 
    -0.04658350f, 0.00187934f, 0.01339043f, -0.04864016f, -0.03149824f, -0.05032938f, -0.01193136f, -0.04043759f, 
    -0.05467583f, -0.04803600f, 0.00119392f, -0.05433811f, 0.04496146f, 0.02936176f, -0.05082062f, 0.00455154f, 
    -0.05154790f, 0.01833345f, 0.01797856f, 0.01364838f, 0.00207181f, 0.04242248f, -0.03979512f, 0.02770521f, 
    0.02441159f, 0.02672235f, -0.01230756f, -0.00739503f, 0.05091386f, -0.00921616f, -0.02711190f, -0.04981873f, 
    0.05218087f, 0.03333111f, -0.00609460f, 0.01562367f, -0.02840054f, -0.00224098f, -0.03109063f, 0.04785813f, 
    0.01523505f, 0.04131998f, -0.00819679f, -0.04118784f, -0.02337392f, 0.03492164f, -0.04112326f, -0.02972355f, 
    0.00322595f, -0.04525248f, -0.04749472f, -0.04589814f, 0.02197637f, -0.02133095f, -0.00687440f, 0.03582763f, 
    0.02829667f, -0.00868124f, 0.00226921f, -0.02772838f, 0.02347959f, -0.02413315f, -0.01406087f, -0.03030802f, 
    0.00953426f, -0.02736165f, 0.03967247f, -0.04401267f, -0.01079378f, 0.00125096f, 0.04897701f, -0.02380284f, 
    -0.03913514f, 0.00382279f, -0.04885835f, 0.00765842f, -0.00423040f, 0.01575209f, -0.05359041f, -0.00602948f, 
    0.04219174f, 0.03373817f, 0.00685872f, 0.00246821f, -0.03839992f, -0.02381689f, 0.00340053f, -0.03666743f, 
    -0.03234808f, 0.04630190f, 0.03906170f, 0.01472406f, 0.04693059f, -0.00737799f, -0.02766683f, 0.03085961f, 
    -0.05459363f, 0.04515515f, 0.04909230f, 0.01942540f, 0.02832218f, -0.04144961f, -0.05931831f, 0.02955915f, 
    0.01848863f, -0.01361890f, 0.00230724f, -0.01654298f, 0.02282233f, -0.04066402f, -0.03568945f, -0.01343706f, 
    0.04135265f, 0.01390265f, 0.01768768f, 0.01767529f, -0.02793937f, -0.02464263f, 0.00884799f, -0.05043997f, 
    0.04463176f, 0.04070191f, 0.01239812f, 0.02767637f, -0.01847173f, -0.04987318f, -0.00208633f, 0.00126862f, 
    -0.05477183f, -0.03539077f, -0.05790776f, 0.01703929f, 0.03895883f, -0.05227742f, 0.01311505f, 0.03734993f, 
    -0.04805288f, -0.02122057f, -0.04683335f, -0.00272333f, -0.02910023f, 0.03880744f, 0.04300860f, -0.00711692f, 
    -0.03074371f, 0.03212603f, -0.05589973f, -0.02822519f, -0.02492429f, -0.05376273f, 0.01874964f, -0.01844401f, 
    0.02020786f, -0.00093492f, -0.04795314f, 0.04731390f, -0.05449446f, -0.00323539f, 0.01957994f, -0.02756420f, 
    -0.00438508f, -0.05879015f, -0.01739073f, 0.02701260f, -0.00738130f, -0.04068508f, 0.00058613f, -0.03798360f, 
    -0.00474484f, -0.03609845f, -0.00568095f, 0.04730754f, -0.03683168f, -0.02282547f, -0.04200922f, -0.00150746f, 
    0.01844109f, -0.05460945f, 0.01822575f, -0.02332113f, 0.00817484f, -0.01791797f, -0.05527150f, 0.00660838f, 
    -0.03015998f, 0.01214325f, 0.00743632f, 0.01935256f, 0.02984890f, -0.00547575f, 0.05848227f, 0.04861811f, 
    0.05921457f, -0.04485660f, 0.00009127f, 0.00257896f, 0.03691471f, -0.03330365f, -0.01529617f, 0.04848016f, 
    0.01060401f, -0.03667118f, -0.04395661f, -0.01653399f, -0.04797643f, -0.01116066f, -0.03221521f, 0.02767655f, 
    -0.01529859f, 0.01985427f, 0.01463685f, 0.03840431f, 0.05331183f, 0.01692641f, -0.04725555f, -0.02930890f, 
    0.03021787f, -0.01148478f, -0.05900182f, 0.01368933f, -0.01887554f, 0.00124443f, 0.00044410f, -0.00032612f, 
    -0.02622367f, 0.04922601f, -0.03280374f, -0.05415656f, -0.04020861f, -0.00232285f, -0.03819500f, -0.00224011f, 
    -0.05003966f, 0.01292718f, -0.03964332f, 0.01293511f, -0.00662927f, -0.00345581f, -0.00067450f, -0.02965198f, 
    -0.03384559f, -0.01020220f, 0.02798682f, -0.05958523f, 0.02623806f, 0.03757079f, -0.05719201f, -0.04969554f, 
    0.03835444f, -0.02665905f, 0.01955551f, 0.04442167f, -0.03138426f, -0.01200773f, 0.04922187f, -0.01764469f, 
    -0.01811351f, 0.04192648f, 0.00324106f, 0.02128113f, -0.01881427f, 0.04958105f, 0.03223153f, -0.00755734f, 
    0.03455887f, -0.05176419f, 0.02631532f, -0.01350866f, 0.04240647f, 0.02417571f, 0.02078719f, -0.05493824f, 
    -0.02553041f, 0.04829518f, 0.03629601f, 0.03771481f, -0.05931395f, -0.02460322f, -0.04911657f, -0.04827625f, 
    -0.02367957f, -0.05054043f, 0.02110825f, 0.04885852f, -0.04133241f, -0.02870966f, -0.04252038f, -0.02259923f, 
    0.04606434f, 0.00364290f, -0.00572132f, 0.04862897f, -0.00598820f, -0.02321007f, 0.00537638f, 0.01982534f, 
    -0.04373556f, 0.01890491f, -0.03507873f, -0.04269541f, -0.05461441f, 0.02125590f, -0.04233221f, -0.04814348f, 
    -0.37841034f, 0.09601744f, -0.06387413f, -0.07647727f, 0.06928518f, 0.14476117f, -0.10918296f, 0.09268502f, 
    0.02898566f, -0.08220319f, -0.12826414f, 0.09480232f, 0.05753480f, 0.04434460f, 0.10664055f, -0.00284417f, 
    -0.03417267f, 0.15696540f, -0.06001324f, 0.14540936f, 0.23639415f, -0.08505870f, -0.18387392f, -0.08477683f, 
    -0.09848417f, 0.16771919f, -0.03248979f, -0.00994613f, 0.06709679f, 0.03365618f, 0.07120053f, 0.02383685f, 
    -0.01755123f, 0.06055779f, -0.01489489f, -0.19417331f, 0.10184453f, 0.12708287f, 0.14954010f, 0.28526515f, 
    -0.40417975f, -0.16226165f, -0.27313769f, 0.15745288f, 0.13716118f, 0.01290973f, 0.03306352f, -0.08010389f, 
    0.06455546f, 0.10056006f, -0.10147092f, 0.02793756f, 0.12626541f, 0.11908016f, -0.01773190f, 0.15828954f, 
    0.18041402f, 0.13244154f, 0.08053201f, 0.03540919f, -0.16225883f, -0.28995946f, 0.07082830f, 0.31299385f, 
    0.05971803f, 0.20801722f, -0.01898878f, -0.20508628f, -0.12523620f, -0.02916265f, -0.06940303f, 0.06076055f, 
    0.15908389f, 0.01448814f, 0.05957815f, 0.11253432f, -0.09884709f, -0.05237054f, -0.00765983f, -0.15941989f, 
    0.27174580f, 0.06083355f, 0.05292834f, -0.09847981f, -0.21823341f, -0.08420671f, 0.02381904f, 0.09077644f, 
    -0.02170316f, 0.00665724f, 0.07334035f, 0.01765915f, -0.09800369f, -0.13252319f, -0.03417943f, -0.02694070f, 
    -0.08092607f, 0.15045078f, -0.06508880f, 0.03177324f, 0.01738226f, 0.26603085f, 0.02457051f, -0.06479033f, 
    -0.00925554f, 0.07649656f, 0.09426975f, -0.04230987f, -0.05884868f, -0.03507080f, -0.04892857f, 0.04460329f, 
    0.01279021f, 0.02295381f, 0.03852753f, -0.07754950f, -0.15021585f, 0.09278194f, -0.14977804f, -0.11901356f, 
    -0.20690623f, -0.16665168f, -0.11389754f, 0.17797990f, 0.13643208f, 0.01928231f, -0.01507136f, 0.05247085f, 
    -0.08550479f, -0.07498537f, 0.08081196f, 0.04633909f, 0.11485760f, -0.03451872f, 0.01753844f, 0.02725610f, 
    -0.06418943f, 0.13230745f, -0.02031324f, -0.02074209f, 0.10269804f, -0.03244620f, 0.08536554f, 0.02916025f, 
    -0.03744608f, 0.04322331f, 0.03885920f, 0.06366392f, -0.03541115f, -0.04369802f, 0.04514919f, 0.05065772f, 
    -0.13052192f, -0.07400282f, -0.02968958f, 0.03910915f, -0.03046280f, -0.13896516f, -0.05721486f, -0.09940422f, 
    0.40061155f, -0.11915644f, -0.05940011f, -0.01502459f, 0.00930310f, -0.09770187f, 0.09679636f, 0.05914451f, 
    0.18422864f, 0.06742337f, 0.03979863f, -0.01004121f, 0.09258384f, 0.00865344f, -0.02377159f, 0.06403851f, 
    0.22089463f, 0.10784625f, 0.01262102f, 0.00376391f, 0.06022288f, 0.08809753f, 0.08186175f, -0.08711684f, 
    -0.01836123f, -0.08302053f, -0.06956747f, 0.03447698f, -0.01145371f, 0.02134555f, 0.07133808f, 0.03490586f, 
    -0.07313028f, -0.01972150f, -0.03684554f, -0.01079069f, 0.07383860f, 0.21004346f, 0.02002496f, -0.00805225f, 
    0.02573286f, -0.06316673f, -0.10348777f, 0.04504240f, -0.07526667f, 0.06458528f, -0.03580283f, 0.09009626f, 
    -0.08253432f, -0.00631976f, -0.04526200f, 0.09814512f, 0.06449392f, -0.23617727f, -0.12465710f, 0.05706010f, 
    -0.23623247f, 0.02728983f, -0.06588387f, 0.02691351f, -0.33840188f, -0.16445272f, -0.02619318f, 0.46746004f, 
    0.07176600f, 0.06207522f, -0.02894877f, 0.14022028f, -0.09860367f, -0.03368028f, 0.05723426f, 0.14058205f, 
    -0.03813883f, -0.01733369f, 0.03784338f, 0.08450679f, -0.15761387f, -0.01063167f, -0.17399848f, -0.04836776f, 
    -0.08920045f, -0.07640814f, -0.06278648f, 0.27846146f, 0.21648096f, -0.00174027f, -0.02065196f, -0.03523981f, 
    -0.06737630f, 0.14116040f, -0.00487745f, 0.01918801f, -0.03765549f, 0.09018353f, -0.01929457f, 0.12744385f, 
    0.03550371f, -0.07536900f, 0.13666920f, 0.00906678f, 0.15960963f, -0.01587111f, -0.03642394f, 0.10826127f, 
    -0.01682935f, 0.10537311f, -0.02903802f, -0.14886186f, 0.04346484f, -0.05343970f, 0.09469443f, -0.01221538f, 
    0.16779067f, 0.05992725f, 0.04216295f, 0.00719842f, -0.04631681f, 0.11505979f, -0.04268425f, -0.09446312f, 
    0.30299696f, 0.24002203f, 0.22578478f, 0.02221934f, -0.17177373f, 0.03821600f, -0.13238625f, -0.20585768f, 
    -0.09762194f, 0.02715719f, -0.02308262f, -0.02857672f, 0.01405636f, 0.14784575f, 0.02643515f, -0.08412581f, 
    -0.13314454f, 0.00024450f, 0.04991870f, 0.04696640f, -0.26599592f, 0.03708747f, -0.29263651f, 0.31206039f, 
    0.18034597f, 0.00160525f, -0.06782616f, 0.14095058f, 0.12984788f, -0.15321182f, -0.04322624f, 0.02639736f, 
    -0.04121387f, 0.02708705f, 0.03532645f, -0.01942961f, 0.03791394f, 0.00370337f, 0.12912007f, -0.08728949f, 
    0.42975247f, 0.29410592f, 0.14013396f, 0.22785336f, 0.25526869f, -0.15485173f, 0.08919967f, -0.03231221f, 
    -0.05832498f, 0.29784915f, 0.12620269f, -0.03808279f, 0.07393391f, -0.09318201f, -0.05340627f, 0.01318381f, 
    0.04937036f, 0.04302382f, 0.12100688f, 0.00652923f, 0.16744426f, -0.02753569f, 0.13346021f, -0.07803343f, 
    0.20812055f, -0.00098445f, 0.15849099f, 0.16432872f, 0.02762554f, 0.05024947f, 0.01698667f, 0.06317186f, 
    0.01842183f, 0.03951106f, -0.00519079f, 0.19405168f, 0.01299298f, 0.00711114f, 0.04511385f, -0.08612726f, 
    0.23743266f, 0.21519198f, 0.04578200f, -0.35165608f, 0.09186842f, 0.10674747f, -0.14958495f, 0.08344354f, 
    0.04787167f, -0.13444866f, -0.06880064f, -0.03784228f, -0.04132775f, -0.08941051f, 0.11538234f, -0.06090489f, 
    -0.14298293f, 0.13453212f, -0.05447420f, 0.02790495f, -0.15847215f, 0.01914727f, -0.29321206f, -0.24661180f, 
    0.05633824f, -0.06876498f, -0.04225758f, 0.01735236f, 0.10900781f, 0.07680617f, -0.01222599f, 0.09217842f, 
    -0.06422156f, 0.04349864f, -0.04715004f, -0.16790590f, 0.02405668f, 0.07728645f, 0.03354331f, 0.06780874f, 
    -0.04791002f, -0.02204469f, 0.15444195f, -0.09265808f, 0.13254717f, -0.03417058f, -0.21002610f, -0.10420231f, 
    0.03420911f, -0.08153662f, -0.02504734f, -0.04142254f, -0.02601445f, -0.02847270f, -0.11510933f, -0.11812070f, 
    -0.09267096f, 0.07908706f, 0.07646731f, 0.02000532f, 0.07421133f, -0.25754222f, 0.28030944f, 0.04091892f, 
    0.09707948f, -0.07897217f, -0.00600156f, -0.00594992f, 0.09431593f, 0.12170936f, 0.01931932f, 0.02298146f, 
    -0.02646724f, 0.10962500f, 0.00900719f, -0.03674836f, 0.08307884f, -0.07238787f, 0.10625063f, 0.08381891f, 
    0.39222783f, 0.25311995f, -0.25938407f, -0.23161800f, -0.01022583f, -0.09341799f, 0.07970732f, 0.00309591f, 
    0.09031866f, 0.17259769f, 0.15199012f, 0.01833207f, -0.10406913f, 0.01274431f, 0.12088796f, 0.01207897f, 
    0.06889468f, -0.04703071f, 0.17878832f, 0.10073360f, -0.01449691f, 0.16298968f, -0.00785838f, 0.09129377f, 
    -0.03707054f, -0.06351813f, -0.03227184f, -0.16771223f, 0.01774250f, 0.00508357f, -0.10044909f, -0.01905520f, 
    0.00335551f, 0.07193463f, -0.02959670f, -0.10210373f, 0.12079263f, 0.01880906f, 0.03932719f, 0.06519849f, 
    0.03234138f, 0.12180713f, 0.21686375f, -0.24910372f, 0.13768174f, 0.06033691f, -0.04872301f, 0.00544593f, 
    0.00176848f, 0.02931299f, 0.02290915f, -0.00727243f, -0.05766952f, 0.03811305f, 0.05460012f, 0.04623568f, 
    -0.02426190f, -0.02135141f, 0.00131267f, -0.06182715f, -0.10168625f, -0.00988888f, 0.23296422f, 0.04999631f, 
    0.08182761f, 0.01179701f, -0.20816255f, -0.09106612f, 0.07458347f, -0.15700455f, 0.05348472f, 0.00315249f, 
    -0.14855193f, -0.02166667f, -0.05057634f, 0.18169351f, 0.07175325f, -0.08782852f, -0.06380230f, -0.03506039f, 
    -0.14985280f, 0.04990810f, 0.06999404f, 0.07421436f, -0.04429089f, -0.03186634f, -0.07544404f, -0.09682171f, 
    0.02081253f, -0.02907274f, 0.02557361f, -0.13994257f, -0.00016080f, -0.08456989f, 0.11015842f, 0.01366869f, 
    -0.04119354f, -0.09402682f, -0.12366280f, -0.13372508f, 0.15157910f, -0.01381389f, -0.28266343f, -0.32844260f, 
    0.07858587f, 0.07673447f, -0.12578036f, -0.09128407f, 0.22458349f, -0.02340254f, 0.08323207f, 0.04651547f, 
    0.15318067f, 0.09777992f, 0.04230260f, -0.10769045f, 0.05324442f, 0.10524600f, 0.08055327f, 0.08719863f, 
    0.10377135f, 0.12994429f, -0.18599512f, -0.36912009f, -0.16082388f, 0.05605716f, -0.02950167f, -0.08402412f, 
    0.06636544f, -0.26389661f, -0.09886832f, 0.00095860f, 0.06024053f, 0.06065934f, 0.13153824f, -0.02835350f, 
    -0.04635071f, 0.05018796f, -0.07624494f, -0.10689694f, 0.01639779f, 0.05873846f, -0.19351146f, -0.33038545f, 
    0.13042364f, 0.01309129f, 0.10653969f, 0.07456876f, 0.01580572f, -0.01972190f, -0.02189154f, -0.00806926f, 
    0.04711712f, 0.00518705f, -0.01818654f, 0.08679189f, 0.01908592f, 0.00942894f, -0.16111106f, 0.19244090f, 
    -0.20743245f, -0.36619762f, -0.16923264f, -0.08561268f, 0.34834525f, 0.01215528f, 0.07496198f, 0.28669104f, 
    0.07694360f, -0.09654993f, 0.02451874f, 0.03324528f, 0.03979405f, -0.01717851f, 0.18168060f, 0.06660388f, 
    -0.03548042f, -0.07364625f, 0.00838071f, -0.12832014f, -0.13388830f, -0.05671224f, -0.14200723f, -0.05038244f, 
    -0.28567916f, 0.00792743f, -0.06572781f, 0.04349550f, -0.32247937f, -0.06177417f, -0.06382404f, -0.00589996f, 
    0.06811954f, -0.01607944f, -0.03877696f, -0.06022585f, -0.01725399f, 0.17311302f, 0.02179464f, 0.10159828f, 
    0.01212313f, 0.04785144f, 0.02077993f, -0.03814000f, -0.04066467f, -0.02394771f, 0.02489816f, 0.01006631f, 
    -0.03208724f, -0.04043036f, 0.03938270f, 0.01770428f, -0.04861554f, -0.04281844f, 0.03520296f, 0.01945748f, 
    -0.02750535f, -0.01740068f, -0.04182307f, -0.04600898f, -0.01327953f, -0.03873090f, -0.00647963f, -0.04242239f, 
    0.01239110f, 0.03767794f, 0.03017855f, -0.05695834f, 0.04427472f, 0.01377444f, 0.01044946f, 0.02549459f, 
    -0.00378439f, -0.05486342f, 0.03899575f, -0.03275442f, -0.04402669f, -0.01578674f, 0.02311334f, 0.01213272f, 
    0.03944330f, -0.02466098f, 0.04541216f, -0.03012799f, 0.00629725f, -0.05904165f, 0.03271097f, -0.01112272f, 
    0.04133926f, -0.00808732f, -0.05170801f, -0.05609045f, 0.03363621f, 0.01348214f, -0.02233341f, 0.01735833f, 
    -0.03765330f, -0.01577052f, -0.01642437f, 0.00460892f, 0.01102377f, 0.03379348f, 0.01000343f, 0.04182854f, 
    -0.03340397f, -0.04277530f, -0.04666798f, 0.02291087f, -0.05670521f, -0.04164354f, -0.02263087f, -0.04514949f, 
    -0.06057394f, 0.01643273f, -0.03383385f, 0.05190026f, -0.03504482f, -0.00550911f, -0.03286122f, 0.00975050f, 
    0.03388114f, 0.04291547f, -0.02024886f, -0.05112480f, -0.00526691f, -0.05180110f, 0.03539392f, 0.02171198f, 
    -0.05399896f, 0.01411006f, -0.05511013f, -0.02005677f, -0.01422769f, -0.00671852f, -0.01152699f, 0.02132380f, 
    0.01500293f, -0.02899929f, 0.00897810f, -0.02125967f, -0.01331175f, -0.00595342f, -0.04023832f, -0.05057182f, 
    0.00319427f, 0.01982199f, -0.05036860f, 0.02451120f, 0.02986949f, 0.00200202f, 0.01747656f, -0.02514520f, 
    0.03686837f, -0.04892146f, 0.03584184f, -0.02142763f, -0.02795223f, 0.04479669f, -0.00332054f, -0.05476741f, 
    -0.01643215f, 0.02254327f, -0.04402257f, -0.02810984f, -0.00781000f, 0.00204996f, 0.03529929f, -0.05678501f, 
    -0.05722297f, -0.04137781f, -0.00972947f, 0.00405962f, -0.05416417f, 0.01939820f, -0.03989437f, 0.02877003f, 
    0.03140219f, 0.03279079f, -0.02521359f, -0.01337440f, 0.00244732f, -0.05383579f, -0.01668778f, -0.00422562f, 
    -0.03744029f, 0.00421559f, -0.01962338f, -0.05887422f, -0.00921227f, -0.05276538f, -0.04019102f, -0.05706086f, 
    -0.01971349f, -0.04611063f, 0.01450747f, -0.02680909f, -0.01032141f, 0.00734015f, 0.02268727f, -0.03278939f, 
    -0.04088674f, 0.02777655f, -0.05026063f, -0.00037757f, 0.02912174f, 0.04290315f, 0.02634927f, -0.02838901f, 
    -0.01200930f, 0.02968958f, 0.04484587f, -0.04363706f, 0.03637543f, 0.03136698f, -0.01669154f, -0.03950699f, 
    -0.04268296f, -0.05168847f, 0.01229127f, -0.05458126f, -0.00670678f, 0.01790603f, -0.00454504f, -0.01859800f, 
    0.01869748f, 0.01027647f, 0.04490199f, 0.03795052f, -0.03442478f, 0.00070175f, -0.03542021f, 0.01996530f, 
    0.03193058f, 0.05013203f, -0.02978673f, -0.00246305f, 0.01665069f, 0.04557127f, 0.00948647f, -0.02757298f, 
    -0.01527302f, -0.03801877f, -0.00923655f, -0.04566339f, 0.03130176f, 0.01706775f, -0.03092449f, -0.01156114f, 
    -0.02568388f, -0.01310868f, -0.01720180f, -0.01866334f, -0.04643342f, -0.03573374f, -0.05328508f, -0.02410853f, 
    -0.03965890f, -0.02297866f, -0.03966171f, 0.03326244f, 0.01170787f, -0.01676248f, -0.03362035f, -0.03301691f, 
    0.01872782f, 0.00244248f, -0.03539733f, 0.02866774f, -0.03789292f, -0.04472217f, -0.00436337f, -0.00220341f, 
    -0.00727405f, -0.03088885f, 0.02392105f, 0.01415233f, -0.01750392f, -0.01037636f, -0.00479523f, 0.03805365f, 
    0.02610936f, -0.03796106f, -0.05983420f, -0.01454275f, 0.00368355f, 0.01304243f, 0.02098132f, -0.00916765f, 
    -0.01772571f, 0.00302547f, -0.02991843f, -0.01395719f, -0.00278540f, 0.03931938f, 0.01191357f, -0.04216414f, 
    -0.00225223f, -0.02603306f, 0.01975644f, 0.00243183f, -0.01626823f, 0.01229572f, -0.00007686f, -0.03781712f, 
    -0.00244999f, -0.03299538f, -0.05454200f, -0.00544684f, 0.04350821f, 0.03743304f, 0.04656051f, 0.02875997f, 
    -0.02844689f, 0.01382802f, -0.01655458f, -0.04796534f, -0.01870567f, -0.03709549f, -0.01107425f, 0.02373322f, 
    -0.05901814f, 0.04539533f, -0.03552866f, -0.00994195f, 0.02497818f, -0.05510742f, 0.01522255f, 0.04177214f, 
    -0.00238923f, 0.00202011f, -0.02238488f, 0.00350709f, 0.03427636f, -0.01725289f, 0.03924186f, -0.04903697f, 
    -0.04654242f, -0.03818734f, -0.04858651f, -0.03451167f, -0.04316449f, 0.01719781f, -0.02090210f, 0.02604542f, 
    -0.05794894f, 0.05006579f, -0.05724721f, -0.04552804f, 0.03080212f, 0.00730023f, -0.05532873f, 0.00483039f, 
    0.00009346f, -0.05421137f, -0.01098628f, 0.03459465f, -0.03629078f, 0.03468109f, -0.02343318f, -0.04074556f, 
    0.02042745f, -0.02916813f, 0.03742025f, -0.04454998f, 0.00956887f, 0.00118872f, -0.03094319f, -0.04689642f, 
    0.03357961f, -0.01127531f, 0.04397291f, -0.01663833f, 0.03903280f, 0.02641380f, 0.01689493f, -0.03794389f, 
    0.00818377f, 0.01356649f, 0.00391321f, -0.05660852f, 0.03707374f, -0.05498348f, -0.00147323f, -0.05649413f, 
    -0.00580993f, 0.05091916f, -0.05980186f, 0.01582770f, -0.01354271f, 0.00211074f, -0.01911875f, 0.03989051f, 
    -0.04236768f, -0.00219234f, 0.04810253f, 0.00975206f, -0.04704059f, -0.04952113f, -0.06277660f, 0.04498636f, 
    0.05973759f, -0.03681006f, 0.00609491f, 0.03121238f, -0.02792227f, 0.01044016f, 0.06364913f, -0.06201828f, 
    -0.03864983f, 0.00300712f, 0.01126710f, -0.02823124f, -0.04901024f, -0.05309771f, -0.02080402f, 0.01195058f, 
    -0.01844544f, 0.04807692f, 0.00383238f, -0.01292576f, -0.02529189f, 0.04155842f, -0.02832146f, 0.03995977f, 
    0.03557777f, -0.03793818f, 0.02886266f, -0.02103958f, -0.03053004f, -0.01168664f, -0.06162015f, -0.02978551f, 
    -0.04418387f, -0.02951685f, -0.01740216f, -0.02262820f, 0.00584651f, -0.02700667f, -0.00101500f, 0.00276453f, 
    -0.02640822f, 0.03707268f, -0.01662431f, 0.02685013f, -0.00432633f, -0.00340700f, 0.03431564f, -0.00075964f, 
    -0.05584227f, 0.02513719f, -0.06154207f, 0.01507633f, 0.03707127f, -0.05446948f, 0.01501178f, 0.02543815f, 
    0.02068436f, 0.03252691f, -0.05687942f, 0.03403558f, 0.00166816f, -0.02482718f, -0.03531911f, -0.01643253f, 
    -0.03958702f, -0.01346743f, 0.03702440f, 0.00208340f, 0.03964745f, -0.05071747f, 0.04336212f, -0.01017808f, 
    -0.04254083f, -0.05175129f, -0.02833122f, -0.00865745f, -0.05670052f, -0.04329066f, 0.04154133f, 0.00312694f, 
    0.04512955f, -0.03039143f, 0.03964941f, -0.03048641f, 0.02397196f, -0.06486408f, 0.02853080f, 0.02298359f, 
    0.01897924f, 0.03079931f, 0.01683439f, 0.02546599f, -0.04113377f, -0.04558665f, -0.06241868f, -0.00027814f, 
    -0.03394313f, -0.01028782f, -0.05821356f, -0.05925444f, -0.00281253f, -0.03027535f, -0.01112307f, 0.03982071f, 
    -0.00405439f, 0.02655536f, 0.00055964f, -0.00158908f, 0.00254001f, -0.02414781f, -0.00866937f, -0.06185618f, 
    -0.03258500f, 0.00174251f, 0.02820941f, 0.01173565f, -0.01967804f, 0.00679809f, 0.02657556f, 0.04063392f, 
    -0.00813814f, -0.02012007f, 0.02197370f, -0.01584393f, 0.02466557f, -0.06551064f, 0.02734573f, -0.00725307f, 
    -0.02934388f, 0.03448316f, 0.00924906f, -0.00267250f, 0.01752447f, -0.00888926f, -0.05570988f, 0.00544421f, 
    0.00538126f, -0.02828920f, -0.02986270f, -0.05441880f, -0.00158949f, -0.05287698f, -0.03271128f, 0.02005166f, 
    -0.06437402f, -0.01110042f, -0.01265797f, -0.02045161f, -0.01697414f, 0.01613195f, -0.05607497f, -0.02169421f, 
    0.04320050f, -0.00505303f, -0.00037511f, 0.00331670f, -0.06341160f, -0.00777021f, -0.00453574f, -0.02692387f, 
    0.04056721f, -0.06319176f, 0.04227552f, -0.03362558f, 0.04852544f, -0.03374101f, -0.01928356f, 0.01129740f, 
    -0.00204283f, 0.00036213f, -0.01742682f, -0.01717974f, -0.03074158f, 0.00746712f, -0.05958162f, 0.01350639f, 
    0.00405345f, -0.02198013f, -0.03648242f, -0.00273165f, 0.01876706f, -0.03934234f, -0.01608634f, 0.01629005f, 
    0.00124402f, -0.03041530f, 0.04100624f, 0.03431418f, -0.00396487f, -0.05652795f, -0.06104664f, -0.00741700f, 
    -0.03614770f, -0.05046350f, -0.01646648f, -0.03077268f, 0.02536628f, 0.01861250f, -0.01613971f, -0.00543423f, 
    -0.01673288f, 0.03408446f, -0.04290088f, -0.02062148f, -0.04123262f, -0.05251173f, 0.01252948f, 0.00739173f, 
    -0.01176010f, 0.00017094f, 0.03834648f, -0.03444895f, -0.02258566f, -0.02092386f, -0.04495493f, 0.01151658f, 
    0.04300247f, 0.04125311f, 0.03965656f, 0.03813344f, -0.05175179f, 0.01593984f, -0.01092673f, -0.04984771f, 
    -0.05310476f, -0.04467733f, -0.04720313f, -0.02329411f, 0.04617010f, -0.02881371f, -0.02595479f, 0.00331372f, 
    -0.04997264f, 0.01494648f, -0.03313739f, 0.02649955f, 0.03291848f, 0.01484058f, -0.06145293f, -0.02218732f, 
    -0.05861918f, -0.02583694f, -0.01486208f, 0.02299681f, 0.02020267f, -0.03069527f, 0.00890233f, 0.03394134f, 
    0.03151746f, -0.03423828f, 0.02571158f, 0.04521613f, 0.01462900f, -0.05379161f, 0.01230934f, -0.03477679f, 
    -0.04958209f, 0.02353474f, -0.04955423f, 0.02392813f, 0.03614467f, -0.02390806f, 0.04950894f, 0.05039663f, 
    -0.04386850f, -0.00014200f, 0.03206458f, 0.01783111f, -0.00870148f, -0.03768264f, -0.05332056f, 0.00043624f, 
    -0.02764077f, 0.02439146f, -0.03493633f, -0.00601125f, 0.01265374f, -0.02854964f, -0.05931036f, -0.05307494f, 
    -0.27061343f, -0.38445336f, -0.09174408f, -0.20114626f, -0.03294139f, 0.12892710f, 0.00642734f, -0.06008357f, 
    0.18646693f, -0.05584658f, 0.06402209f, -0.03428965f, -0.05500282f, 0.16449867f, -0.05127919f, 0.01537112f, 
    0.10931709f, 0.05796033f, 0.06295069f, 0.05075588f, -0.31853947f, 0.09982176f, -0.02315590f, -0.03787504f, 
    0.02505185f, -0.13717131f, -0.04285095f, -0.03480285f, 0.12158053f, 0.09210119f, -0.02447220f, -0.02994260f, 
    0.04168833f, 0.04499629f, -0.05822775f, 0.05247283f, -0.06135974f, 0.00433294f, 0.09286571f, -0.00613295f, 
    0.19030857f, -0.17750530f, 0.05064299f, 0.05055251f, -0.15098679f, -0.03668702f, 0.06207338f, 0.01955010f, 
    -0.17157328f, 0.03502389f, 0.07190660f, -0.06787236f, -0.00240151f, 0.16560775f, -0.03046994f, 0.05744692f, 
    0.15257674f, -0.02085912f, 0.21055296f, 0.05309758f, 0.18668564f, 0.27571490f, 0.36122298f, 0.06085671f, 
    -0.26181942f, -0.01678906f, 0.03041193f, 0.01563316f, -0.21800210f, -0.00160655f, 0.15187439f, -0.04031188f, 
    0.13742667f, -0.01661227f, -0.02957516f, -0.01087461f, -0.01485544f, -0.20167656f, -0.14989440f, 0.02127056f, 
    0.01909084f, -0.16820836f, -0.43806541f, 0.21951300f, 0.04168434f, 0.20943350f, 0.10384864f, 0.14648141f, 
    -0.03829131f, 0.12818894f, 0.01070055f, -0.08555537f, -0.02367157f, -0.02843351f, 0.01128846f, 0.13386132f, 
    0.02408132f, -0.01712145f, -0.01091010f, -0.02471990f, -0.12878670f, 0.07009827f, -0.26924518f, -0.04293859f, 
    -0.09110533f, 0.11655767f, -0.12964301f, 0.02445234f, 0.03027524f, -0.11108217f, 0.05346269f, -0.01251002f, 
    -0.02326491f, -0.14065176f, -0.03095599f, 0.03899872f, -0.04632760f, -0.04168966f, -0.04159976f, -0.01325967f, 
    -0.18592066f, -0.10679427f, 0.45886520f, 0.17318434f, 0.03708301f, 0.09892001f, 0.02544205f, 0.07998845f, 
    -0.01961011f, -0.06287269f, 0.04894030f, 0.04720033f, 0.06226524f, -0.13007838f, -0.00966460f, -0.02377109f, 
    -0.09569895f, -0.17843014f, 0.06791904f, -0.07503901f, 0.12484962f, -0.20212080f, -0.21049979f, -0.26969934f, 
    0.15933919f, -0.05617022f, 0.08572224f, 0.14767423f, -0.02055975f, -0.05102573f, 0.03623961f, 0.00811932f, 
    0.10206739f, -0.10970176f, 0.12695529f, 0.11009324f, -0.03267543f, -0.08785457f, -0.03543431f, 0.01133778f, 
    -0.16564421f, 0.07253144f, -0.07768609f, 0.12748915f, -0.12239628f, 0.03664049f, 0.04257165f, 0.07561430f, 
    0.05605549f, 0.04695858f, 0.07658815f, -0.10969360f, 0.01233782f, 0.08794586f, -0.08703788f, -0.00921171f, 
    -0.03109665f, -0.02719618f, 0.06528576f, 0.12321635f, -0.04174990f, -0.23349664f, -0.55901599f, 0.15872906f, 
    -0.13829221f, -0.11088277f, 0.19330333f, 0.08029126f, -0.05244721f, 0.05987233f, -0.14950286f, -0.08067027f, 
    0.04514505f, -0.02783921f, -0.04794098f, -0.15942806f, -0.16078840f, -0.00109672f, 0.04907159f, 0.06096918f, 
    0.10966169f, 0.21062787f, 0.11891726f, -0.13475083f, 0.17292202f, -0.00387235f, -0.02294864f, -0.08756680f, 
    -0.05294361f, 0.03655947f, 0.02597322f, 0.09868019f, -0.16188508f, 0.20249967f, -0.01722297f, -0.04541467f, 
    0.05526952f, 0.15084164f, 0.02695147f, 0.14136916f, 0.14025013f, 0.04032230f, 0.15977924f, -0.12719767f, 
    -0.06389403f, -0.08360101f, 0.10582195f, 0.05572062f, -0.09774502f, 0.05377100f, 0.01219489f, 0.11299553f, 
    0.04075819f, 0.04855551f, 0.10627640f, -0.03192752f, 0.00141074f, -0.01944544f, 0.15651137f, 0.13057342f, 
    0.03179166f, -0.09097888f, 0.02660438f, -0.00191764f, -0.12779874f, 0.03572153f, 0.06572507f, 0.02514723f, 
    -0.07352035f, 0.04395955f, 0.06538106f, -0.08747228f, 0.03161418f, 0.08452871f, 0.05770485f, 0.06234053f, 
    0.10927030f, 0.05954874f, 0.21174698f, 0.04274311f, -0.00044234f, 0.10607452f, 0.26624966f, 0.20621996f, 
    -0.06177554f, -0.06884118f, -0.01531583f, 0.11603243f, -0.09800965f, -0.03326803f, 0.15486483f, -0.15104632f, 
    -0.07623092f, -0.08243112f, 0.05092467f, -0.08495957f, -0.15105778f, -0.16732189f, 0.30125266f, -0.13207896f, 
    -0.03063704f, 0.15381381f, 0.09597965f, -0.01954214f, -0.14788382f, -0.17985210f, -0.04491537f, -0.18294516f, 
    0.09867257f, 0.34143740f, 0.09602568f, 0.03678391f, -0.00890464f, -0.00820768f, -0.02957177f, -0.14547639f, 
    0.08083662f, 0.07348756f, -0.05896703f, -0.00990961f, 0.30805567f, -0.04222062f, 0.32368368f, -0.34940112f, 
    0.06187638f, 0.18129998f, 0.12275761f, -0.08003215f, 0.10636157f, -0.07102031f, -0.00011939f, -0.03232657f, 
    -0.05641446f, 0.01086872f, 0.12151302f, 0.12135414f, 0.06477446f, 0.01182323f, -0.03178324f, 0.03218870f, 
    0.06011623f, 0.47109529f, -0.02014406f, 0.11110308f, 0.04026746f, -0.02869033f, 0.02398898f, -0.00913338f, 
    0.00039882f, 0.04998120f, -0.07135714f, -0.03238977f, 0.04199312f, 0.07103553f, 0.04983577f, 0.01645682f, 
    0.24757034f, 0.04244969f, -0.13505135f, -0.09034915f, 0.44094512f, -0.09225264f, 0.18205798f, -0.09063808f, 
    0.00401450f, -0.01386120f, -0.05983023f, 0.07609966f, -0.00700038f, -0.05702919f, -0.08154403f, 0.05817443f, 
    0.02995538f, 0.01114484f, 0.02023348f, -0.04501336f, 0.15791185f, 0.12249514f, -0.11119262f, 0.09640872f, 
    -0.01704830f, 0.21918884f, -0.11662381f, 0.10136204f, 0.33374333f, 0.09473330f, 0.02126741f, 0.16872321f, 
    0.05457997f, 0.17453131f, -0.12187758f, -0.03350480f, -0.07441957f, 0.05561057f, 0.16095494f, -0.09783240f, 
    0.00720212f, 0.16588905f, -0.00932770f, 0.14304081f, -0.05228400f, 0.20870443f, -0.18246599f, 0.18823023f, 
    0.49531770f, 0.14911368f, -0.03072806f, 0.05807112f, -0.06982507f, -0.07505901f, -0.06066403f, 0.20452181f, 
    -0.00449464f, 0.08434736f, -0.00882575f, 0.04647730f, -0.11166735f, 0.02122847f, 0.02267085f, 0.09190320f, 
    -0.13015863f, -0.17024526f, 0.12218429f, -0.00647991f, -0.28757352f, -0.12867433f, 0.03463749f, 0.05888265f, 
    -0.09594944f, -0.08297373f, 0.03839897f, 0.20828111f, 0.08356068f, 0.12089844f, 0.04664407f, -0.01771369f, 
    0.03570292f, -0.00474669f, -0.11162854f, -0.01181505f, -0.00326401f, -0.27153462f, 0.22720361f, -0.15050536f, 
    -0.12259959f, 0.01540187f, 0.11721781f, 0.03441491f, -0.01948528f, 0.01083151f, -0.09620985f, -0.08833054f, 
    0.14288290f, -0.08025988f, -0.03518371f, -0.04156110f, -0.02933187f, -0.00401110f, 0.00217467f, -0.20935555f, 
    0.04946768f, 0.28796056f, -0.16926256f, -0.19085363f, 0.19742019f, -0.11740522f, -0.07636436f, 0.01002765f, 
    -0.11507332f, 0.12294912f, 0.04749565f, 0.01033835f, -0.03439259f, 0.03807015f, -0.06185596f, -0.04471710f, 
    0.08057422f, 0.04637782f, -0.11723436f, 0.03848650f, -0.19660851f, -0.10808226f, 0.20065860f, 0.04149751f, 
    -0.26320794f, -0.15356739f, -0.01221148f, 0.08564595f, 0.09765911f, -0.07042861f, -0.10275266f, 0.03210665f, 
    0.02830272f, 0.06259021f, -0.08882465f, -0.07242946f, -0.04058041f, 0.03900090f, 0.04191621f, -0.00133007f, 
    0.20987010f, -0.06062664f, 0.08625203f, -0.14347076f, 0.13747609f, -0.07873421f, -0.20748441f, -0.13830866f, 
    0.06846680f, -0.07159863f, -0.01491916f, -0.10016470f, -0.09572815f, -0.06793410f, 0.01126270f, 0.06927913f, 
    -0.00542520f, 0.12915617f, -0.01977207f, -0.02374005f, -0.02378671f, -0.23299612f, 0.00634392f, -0.34625131f, 
    -0.02995669f, 0.15465030f, -0.11567417f, -0.08278462f, 0.04256373f, 0.10768503f, 0.00754166f, 0.13582602f, 
    0.10305449f, 0.01313995f, 0.08997767f, 0.01231073f, 0.10894389f, 0.05591696f, 0.03249681f, -0.09078218f, 
    -0.10220078f, -0.40702423f, -0.57386404f, 0.26268947f, -0.30395800f, 0.19187669f, 0.16762576f, 0.16506518f, 
    0.14201219f, 0.12646334f, -0.11848055f, 0.07643605f, 0.07858402f, -0.18196855f, -0.04509798f, -0.04973771f, 
    0.05060695f, -0.06641958f, -0.01291784f, 0.01843735f, -0.15568821f, 0.35581228f, -0.14553005f, 0.11150017f, 
    0.19407155f, 0.07208220f, -0.03565108f, 0.02140344f, 0.03683870f, 0.05468046f, 0.09933929f, 0.08359876f, 
    -0.05693773f, 0.08171289f, -0.17169109f, -0.04536035f, -0.16257359f, 0.07001250f, -0.11881214f, -0.02782726f, 
    0.03596541f, 0.20681694f, -0.13908127f, 0.09713899f, 0.30116194f, 0.00696706f, 0.07519965f, 0.03675972f, 
    -0.10474061f, 0.10611971f, -0.07237154f, 0.02924756f, -0.05998604f, -0.02964803f, -0.06378650f, -0.11225249f, 
    -0.10163818f, -0.03414832f, -0.02153310f, 0.13216741f, 0.07428166f, 0.30616578f, 0.13607992f, -0.28590560f, 
    0.33869138f, 0.00140737f, -0.01988151f, -0.03848306f, 0.00484882f, -0.14581750f, 0.00813389f, -0.04796011f, 
    0.10196202f, 0.00691660f, 0.04294484f, -0.04022055f, -0.06501953f, 0.07788604f, -0.22169873f, -0.09122856f, 
    0.34850907f, -0.19573209f, 0.34709609f, 0.21941410f, 0.14232647f, 0.11540927f, 0.10242137f, 0.12987629f, 
    0.03894548f, 0.02736915f, -0.12435375f, -0.00655615f, 0.01235100f, 0.04308983f, -0.01276304f, 0.04047363f, 
    -0.01771463f, -0.06105827f, -0.00069268f, -0.07949417f, -0.43858194f, 0.09975512f, -0.11462539f, 0.22546680f, 
    0.04599011f, -0.21587579f, 0.07531598f, 0.10826647f, 0.12135367f, -0.00426603f, -0.16635691f, -0.00901976f, 
    0.01456507f, -0.01338207f, -0.01030294f, -0.11768007f, -0.14679894f, -0.05679054f, 0.16518809f, 0.00798603f, 
    -0.02714822f, -0.42992228f, -0.47194830f, -0.06293306f, -0.18540898f, 0.10244294f, 0.10099352f, 0.15759212f, 
    0.11264249f, 0.02984852f, 0.03322500f, -0.12142745f, 0.04323465f, -0.00549269f, -0.00361835f, 0.11016900f, 
    0.04742357f, 0.27542278f, 0.01123488f, 0.26891553f, -0.28117719f, -0.03491438f, 0.02677154f, -0.25393933f, 
    0.03126595f, -0.01043608f, 0.07391630f, -0.03427479f, 0.13449377f, 0.05343798f, -0.03041798f, -0.05579674f, 
    0.14655761f, 0.09449965f, -0.10482558f, 0.13911785f, 0.07390860f, 0.02444736f, 0.14461371f, 0.07167079f, 
    0.53570783f, -0.11206764f, -0.02137406f, -0.31775722f, -0.30620790f, 0.07734169f, 0.11370227f, 0.04960817f, 
    -0.15250686f, 0.11008117f, 0.04711638f, -0.10853336f, 0.10743032f, 0.16914840f, -0.01728058f, 0.11946397f, 
    0.01197636f, -0.08496378f, 0.20379536f, 0.11554649f, -0.09314236f, 0.03480893f, -0.04726427f, 0.01523878f, 
    -0.36228105f, -0.18239890f, 0.09429165f, -0.04252952f, -0.08817840f, 0.09319677f, -0.00359158f, 0.05633538f, 
    0.04814505f, -0.06953216f, 0.01120411f, -0.00932790f, 0.01426331f, 0.01592640f, -0.22968611f, -0.13551037f, 
    0.40596235f, 0.09164792f, 0.08715861f, 0.07413008f, 0.02477309f, -0.11273853f, -0.03539808f, -0.06749982f, 
    -0.10685357f, -0.00406055f, -0.10294893f, -0.09712032f, -0.11007052f, 0.06357975f, -0.02329704f, 0.06207011f, 
    0.00023644f, 0.07669751f, -0.02655997f, -0.05804249f, -0.14240639f, -0.03116972f, -0.04641952f, 0.03605451f, 
    0.14192846f, 0.06809133f, -0.03658850f, -0.11360329f, 0.07519758f, 0.00776654f, 0.07902453f, 0.16007511f, 
    -0.05618601f, -0.04672910f, 0.01924306f, -0.12665936f, -0.02871884f, -0.14989871f, -0.14240792f, -0.09602132f, 
    -0.31244698f, -0.08428760f, 0.28839728f, 0.07378942f, 0.12148771f, 0.11322838f, 0.04303226f, 0.12255347f, 
    -0.01275644f, -0.10484876f, 0.04028637f, 0.13812533f, 0.03730405f, -0.00380225f, -0.07133021f, -0.00508328f, 
    -0.08307203f, 0.08796982f, 0.06817918f, 0.02603618f, 0.25990081f, 0.09849592f, 0.01801820f, 0.06859984f, 
    0.07124956f, -0.00285552f, 0.00058681f, 0.00918179f, 0.04714308f, -0.05948504f, -0.07070644f, 0.03607928f, 
    -0.04541692f, -0.03352297f, -0.00692051f, -0.04493018f, -0.06500310f, -0.03460138f, -0.12114398f, -0.07226312f, 
    -0.06855621f, 0.00574761f, 0.28087249f, -0.16172759f, 0.11924477f, 0.12436172f, 0.08046526f, 0.04188367f, 
    0.11754446f, 0.03294282f, -0.03436298f, -0.01805214f, 0.04706642f, -0.03239515f, -0.01815759f, 0.00015702f, 
    0.13716801f, 0.01513915f, 0.00011837f, 0.01403652f, 0.41100502f, 0.03359406f, 0.06549425f, 0.04043050f, 
    0.18688235f, -0.05399420f, 0.11294156f, 0.04604091f, 0.07676088f, -0.07566836f, -0.02791752f, 0.04140268f, 
    -0.09794442f, 0.06725511f, -0.06868996f, -0.12813777f, 0.03910227f, -0.09728377f, 0.03964478f, -0.06792911f, 
    0.13648476f, 0.02127600f, -0.02396302f, 0.03034679f, 0.18958314f, -0.04111045f, 0.03656650f, 0.02024664f, 
    0.01066540f, -0.02501431f, -0.01596105f, -0.07197610f, -0.04001292f, 0.09745155f, 0.09780505f, 0.01116220f, 
    0.00254359f, -0.03165096f, -0.04457161f, -0.20709018f, -0.20432965f, 0.01780439f, 0.13063931f, -0.04522849f, 
    -0.07561018f, -0.07079194f, 0.00479714f, 0.16571803f, -0.20039319f, -0.08080848f, 0.10026239f, -0.08220208f, 
    0.09486665f, -0.02139810f, 0.07702550f, 0.02130130f, 0.06043707f, -0.08041484f, 0.09189437f, 0.05365821f, 
    0.23338561f, 0.07205744f, -0.07235779f, -0.10609440f, -0.05487936f, 0.01844684f, -0.09449778f, 0.04797868f, 
    -0.00697668f, 0.03535090f, 0.07489224f, -0.11409968f, 0.05032207f, -0.05028637f, 0.02733540f, -0.04188075f, 
    -0.01074701f, -0.04623307f, 0.15643510f, 0.03973113f, 0.19987729f, 0.11566974f, 0.55764896f, -0.38134697f, 
    -0.15062501f, 0.28777963f, 0.13742617f, -0.04483456f, -0.14589457f, 0.05884034f, 0.13556993f, 0.04552300f, 
    0.09064708f, -0.05708475f, 0.11431289f, -0.06115815f, 0.07439073f, -0.15151344f, 0.09266877f, -0.01521267f, 
    -0.45713684f, 0.03133669f, -0.24441218f, -0.23059985f, -0.25185305f, -0.08992483f, 0.03697461f, -0.15075892f, 
    0.13094240f, 0.03076482f, -0.17203352f, -0.03683800f, 0.11490960f, 0.05566422f, 0.04890394f, -0.05184202f, 
    -0.03127360f, -0.05552911f, -0.00487553f, 0.02450079f, 0.33989769f, 0.11990608f, 0.22997384f, -0.44723323f, 
    0.01161535f, -0.01504263f, 0.00231415f, -0.04459997f, -0.03306512f, -0.10099244f, 0.05159796f, -0.06756965f, 
    0.05945502f, 0.02417563f, 0.10795330f, 0.08371212f, 0.03181632f, 0.29075354f, 0.06175329f, 0.08291644f, 
    0.43834850f, -0.04826199f, 0.18460876f, 0.00394845f, -0.34009641f, 0.08283315f, -0.15204176f, -0.06124929f, 
    0.06710070f, -0.07629429f, -0.04804254f, 0.06709608f, 0.01508621f, 0.12181060f, 0.04611651f, 0.04125348f, 
    -0.02420896f, -0.07459534f, -0.04574377f, 0.03571579f, -0.13684084f, 0.28980392f, 0.15870148f, 0.35976303f, 
    -0.14926822f, 0.12043731f, -0.06682342f, -0.02125767f, -0.05834104f, 0.00287848f, -0.04703189f, -0.05513061f, 
    -0.15417184f, 0.01017179f, 0.16838910f, 0.04364517f, -0.09590533f, 0.13044824f, -0.02705353f, 0.08329327f, 
    0.11356930f, -0.07078913f, 0.36847419f, 0.36670309f, -0.03744126f, 0.05236644f, 0.00970436f, 0.00531734f, 
    -0.01367834f, 0.13115217f, 0.05080451f, -0.09459138f, -0.01540894f, -0.02669992f, 0.02336361f, 0.08859335f, 
    0.16166155f, -0.09635462f, 0.03411781f, 0.13309446f, 0.09881067f, 0.01743216f, 0.11017854f, -0.07756824f, 
    0.10948785f, -0.00698360f, -0.09434792f, -0.04242122f, -0.01541641f, 0.02141079f, 0.05633134f, 0.20525099f, 
    0.16559404f, 0.13525006f, 0.00333107f, 0.15597673f, -0.02936703f, 0.02200567f, -0.08734510f, 0.01964411f, 
    -0.22285192f, -0.18908581f, -0.51368040f, 0.04798942f, 0.01439189f, 0.01235696f, 0.20435248f, 0.19674443f, 
    0.00870290f, 0.00190369f, 0.05429173f, 0.00666289f, 0.03668612f, -0.02718577f, 0.07220609f, 0.18888441f, 
    0.13635767f, -0.06231061f, 0.08237804f, -0.18388641f, -0.30328485f, -0.02538971f, -0.14219564f, 0.07822106f, 
    -0.09442612f, -0.00711892f, -0.02567863f, -0.27898782f, -0.23120868f, -0.04956199f, 0.04850253f, 0.01605744f, 
    0.08285975f, 0.00504846f, 0.00086902f, 0.11736046f, 0.05263637f, -0.06082628f, -0.02263966f, -0.06925074f, 
    -0.26879561f, 0.32362354f, 0.15707245f, 0.09125690f, 0.00109358f, 0.10734608f, -0.04872358f, -0.15031433f, 
    -0.00299079f, 0.08019295f, -0.10477199f, -0.01193439f, -0.03491908f, 0.02048499f, -0.06267336f, 0.11181074f, 
    -0.06075910f, 0.01799470f, -0.06412604f, 0.01962012f, -0.24383932f, -0.20071544f, -0.06431994f, -0.29946825f, 
    0.11480438f, 0.06214034f, 0.13034645f, 0.06638466f, -0.13971934f, -0.08859391f, 0.16074724f, 0.00145614f, 
    0.07090893f, 0.08336187f, -0.00041334f, 0.06198275f, 0.01102680f, -0.00677253f, 0.05365467f, -0.00918425f, 
    -0.43362340f, -0.09617266f, -0.19324203f, 0.12533152f, -0.07998416f, 0.02799617f, -0.00703625f, 0.09412911f, 
    -0.15483384f, 0.00839982f, 0.10888002f, 0.06933007f, -0.05286468f, -0.06320878f, -0.10891017f, 0.05116515f, 
    0.06598748f, 0.15165192f, 0.01421748f, 0.10370010f, -0.16412370f, -0.38491794f, -0.52903575f, -0.19345938f, 
    -0.08882923f, 0.09916668f, 0.04255007f, 0.01273897f, -0.11203015f, 0.07523386f, 0.05626596f, -0.01665732f, 
    0.08152836f, -0.08465752f, 0.06003828f, 0.04751452f, 0.01503918f, -0.01052778f, 0.03907194f, 0.05659410f, 
    0.24684477f, -0.25495222f, -0.30199286f, -0.22203901f, 0.10737788f, -0.09646483f, -0.01487376f, 0.03312056f, 
    -0.08726446f, -0.03365947f, 0.04925881f, 0.13648134f, 0.06748194f, 0.01128533f, -0.01884254f, 0.09902520f, 
    0.08472841f, 0.01555010f, 0.04442405f, 0.10719046f, 0.23180176f, 0.56243759f, 0.05174299f, 0.05434028f, 
    -0.00289765f, -0.00917604f, 0.06399807f, 0.07001188f, 0.11806311f, 0.14809470f, -0.07706039f, -0.04143777f, 
    -0.04780124f, 0.05027198f, -0.05250785f, -0.04077142f, -0.16413556f, 0.05000973f, -0.02858756f, -0.15236761f, 
    -0.15380505f, -0.09094603f, 0.08093444f, 0.31132707f, 0.03203841f, 0.04627217f, 0.00251488f, 0.03024129f, 
    -0.01373145f, 0.29986942f, 0.05449194f, -0.02620526f, 0.03362096f, -0.03304822f, 0.02276001f, 0.00374477f, 
    0.06701440f, -0.00247200f, -0.00791659f, 0.11984724f, -0.67363524f, 0.13055475f, 0.02246370f, 0.41132146f, 
    0.08229445f, -0.06738537f, -0.19135259f, 0.16913533f, -0.02284519f, -0.00684659f, 0.00810060f, 0.02500831f, 
    -0.02493198f, 0.00311757f, -0.00450791f, 0.00019239f, -0.00953447f, -0.02121263f, -0.06986763f, -0.05818654f, 
    0.06487021f, 0.21979403f, 0.02852265f, 0.21844171f, -0.31866190f, 0.10426339f, -0.18640719f, -0.12247503f, 
    -0.15311474f, -0.06740594f, -0.01673306f, 0.03994404f, 0.11290341f, 0.01575194f, 0.05330405f, 0.11810452f, 
    -0.00133550f, -0.00711117f, -0.02916174f, 0.01713284f, 0.05973208f, -0.10136101f, 0.20812264f, -0.15561858f, 
    0.11507864f, 0.05500109f, -0.03155852f, -0.00194327f, 0.08596821f, 0.11313669f, 0.01135104f, -0.04031139f, 
    0.05298122f, -0.10953163f, -0.03517651f, -0.07079437f, 0.07666270f, -0.16780002f, -0.05756829f, 0.03554421f, 
    -0.03170995f, 0.03157008f, 0.01623951f, -0.03054020f, -0.01320191f, -0.01633865f, -0.03195054f, 0.01438489f, 
    0.02858741f, 0.01837406f, 0.03191667f, 0.03238199f, -0.01221441f, 0.01067236f, 0.00262138f, -0.03651772f, 
    -0.05884805f, -0.01166576f, 0.03791699f, -0.02325501f, 0.02188955f, -0.02335580f, -0.01019113f, 0.02893120f, 
    0.03170519f, -0.03788062f, -0.04350190f, -0.05436084f, -0.01203237f, -0.04710481f, -0.06058051f, -0.03568462f, 
    0.02190194f, -0.02076521f, -0.03473867f, -0.02003709f, -0.04243694f, -0.00776525f, 0.04236444f, 0.00459314f, 
    -0.01119977f, -0.04605129f, -0.03854790f, -0.02153911f, 0.05744825f, -0.00761039f, -0.03502628f, 0.00873468f, 
    0.04401613f, 0.01841095f, -0.02029788f, 0.04193470f, -0.01451017f, 0.01434814f, -0.02990555f, -0.03634290f, 
    -0.01865290f, -0.03405451f, -0.03889047f, 0.03442648f, 0.03342506f, -0.04938092f, -0.02678456f, 0.03035552f, 
    0.00239351f, -0.05811727f, -0.01331103f, 0.03032394f, 0.03903192f, -0.05850623f, 0.04556089f, 0.02793023f, 
    -0.02628991f, -0.05735243f, 0.01227471f, -0.02480306f, -0.00832953f, -0.04802398f, 0.04419527f, 0.03138725f, 
    -0.03903128f, 0.04048481f, 0.04406772f, -0.00784378f, 0.00525365f, -0.00480989f, 0.03917286f, -0.05262265f, 
    0.01780356f, -0.01147384f, -0.04101442f, -0.01449052f, -0.01634741f, 0.01704156f, 0.02021939f, 0.03165210f, 
    0.00800151f, 0.04246265f, -0.03459435f, -0.06313171f, -0.01856725f, -0.06361850f, 0.03213561f, 0.01708345f, 
    0.01079891f, -0.01027022f, -0.06450576f, -0.05879771f, -0.01525649f, -0.05035060f, -0.05211428f, 0.03185889f, 
    0.04048159f, 0.03101391f, 0.02460860f, -0.03338555f, -0.05123584f, -0.04811985f, -0.01833830f, 0.02708298f, 
    0.00545784f, -0.02300750f, -0.01488531f, -0.05878992f, -0.05805876f, 0.03335233f, -0.02818991f, -0.01959502f, 
    -0.03037669f, -0.03229204f, 0.01023601f, -0.04174952f, 0.01554802f, -0.01272374f, 0.01487122f, -0.01482675f, 
    0.02784655f, -0.03449230f, 0.00605368f, -0.03980263f, -0.03744235f, 0.02775772f, 0.00629295f, 0.00056286f, 
    0.04125661f, 0.03615379f, -0.05691081f, 0.02946902f, -0.04696061f, -0.00379724f, -0.01860576f, -0.06533527f, 
    0.01412481f, -0.02889298f, 0.00846642f, -0.05621313f, -0.01478979f, -0.01897014f, 0.04120466f, 0.02439966f, 
    0.00405588f, -0.04592692f, 0.04090825f, -0.03414073f, -0.00470733f, 0.01590014f, -0.04434052f, 0.01653209f, 
    -0.05533998f, -0.00883372f, -0.05633009f, -0.03726947f, -0.03509787f, 0.02965846f, -0.02511042f, -0.04408954f, 
    -0.04098287f, -0.00104709f, -0.04345412f, 0.05301043f, 0.03895157f, 0.00118121f, -0.05335096f, -0.01189076f, 
    -0.03110158f, -0.03960850f, -0.00771733f, -0.06099942f, -0.03168143f, -0.04372008f, -0.00782592f, -0.05085234f, 
    -0.03159205f, -0.00516836f, 0.01241962f, 0.01074432f, 0.03069527f, -0.05360331f, -0.01726160f, -0.02930131f, 
    -0.03090312f, 0.03780115f, -0.05393021f, 0.00061837f, 0.00961642f, -0.03350093f, -0.05357735f, 0.01753723f, 
    0.03956444f, 0.04251632f, 0.01721174f, 0.01035705f, 0.03215944f, -0.05554309f, -0.00283678f, -0.01609408f, 
    0.04204750f, -0.00098231f, 0.01384143f, 0.00260201f, -0.04324445f, 0.01993076f, -0.04347024f, 0.00541992f, 
    0.00992068f, -0.00403158f, -0.02684291f, -0.00665935f, -0.05639299f, -0.00269753f, 0.04334313f, -0.06184585f, 
    -0.01180731f, -0.03780736f, -0.01326640f, 0.04202477f, -0.04271711f, -0.03379996f, 0.00999459f, -0.05940402f, 
    -0.04499814f, 0.02513411f, -0.02551016f, 0.03307323f, 0.02556814f, -0.04821356f, 0.04317442f, 0.03422693f, 
    0.03932606f, -0.04583447f, -0.05533100f, -0.03934078f, 0.03906158f, 0.02165660f, 0.06187413f, 0.04370771f, 
    -0.03132303f, -0.01212122f, -0.04763987f, 0.04481676f, -0.04513896f, 0.04471389f, -0.04932642f, 0.00631414f, 
    0.03684460f, 0.02587951f, -0.05570940f, 0.04637707f, -0.01227046f, 0.03255690f, -0.05327955f, 0.03122724f, 
    0.01285865f, -0.06052982f, -0.00380277f, -0.00662096f, -0.02518025f, 0.03401893f, -0.06096290f, 0.05565083f, 
    -0.03812928f, 0.02144116f, 0.04089393f, -0.03401757f, 0.03069090f, 0.03599463f, 0.00989227f, 0.02505601f, 
    0.04024899f, -0.01398215f, -0.04222505f, 0.00236115f, 0.01534837f, 0.02526549f, 0.02389937f, 0.03642255f, 
    0.02785259f, 0.01674779f, 0.01663759f, 0.00328564f, -0.02702240f, -0.01878387f, -0.02385550f, 0.01036480f, 
    0.05537677f, 0.01605637f, -0.00157754f, -0.02000559f, -0.01535002f, -0.01911042f, 0.02293337f, -0.02313170f, 
    0.04657229f, -0.02811414f, -0.01667998f, -0.03003002f, -0.02915521f, -0.03076777f, -0.02959084f, -0.03436471f, 
    0.50194800f, -0.10901275f, 0.14523287f, -0.02581316f, -0.08146643f, -0.00323233f, -0.17715754f, 0.08355427f, 
    0.01848760f, 0.19694196f, 0.07744361f, 0.06425422f, 0.07794788f, -0.09739106f, -0.00173900f, -0.03291106f, 
    -0.03250426f, 0.11021632f, 0.09500996f, 0.12305606f, -0.13148713f, 0.30462283f, -0.02086496f, 0.16426137f, 
    -0.02843435f, 0.06589872f, -0.05562108f, 0.01220897f, 0.05544207f, 0.06660881f, -0.00613232f, -0.05874749f, 
    0.06118904f, -0.00151340f, 0.11400905f, 0.02489435f, -0.03787562f, 0.03867427f, 0.07471856f, 0.00962227f, 
    0.39509103f, 0.08647356f, 0.36610025f, -0.20009673f, -0.28247350f, 0.10323884f, -0.12661698f, -0.03465615f, 
    0.11369310f, -0.08096279f, 0.17964697f, -0.07217406f, -0.13309115f, 0.00257876f, 0.03248351f, -0.01070825f, 
    -0.13248606f, -0.16048409f, -0.07154106f, -0.02090186f, -0.12365194f, -0.25898686f, 0.02086573f, -0.30493635f, 
    -0.20225050f, 0.04872354f, 0.05348009f, 0.00464433f, 0.04667550f, 0.02331622f, 0.06388891f, 0.00158423f, 
    0.02079476f, 0.03650923f, -0.07077236f, -0.18820067f, 0.09200200f, 0.00683178f, 0.07669523f, 0.08382044f, 
    -0.00416771f, 0.04454782f, -0.12720788f, 0.09841107f, 0.20833839f, -0.00521762f, -0.07819832f, 0.04992624f, 
    0.02063565f, -0.01233098f, 0.07460079f, -0.13495703f, -0.05805434f, -0.01732932f, -0.10986836f, 0.03020921f, 
    0.01846909f, 0.04724802f, 0.08611961f, -0.07592617f, -0.37635675f, 0.09285212f, -0.08484155f, 0.26064914f, 
    0.23404431f, -0.01328724f, -0.09714746f, -0.09584326f, -0.11159466f, 0.10359266f, 0.17358220f, 0.01822968f, 
    0.07760620f, 0.17558248f, -0.12370415f, -0.02401874f, 0.02227187f, -0.13767651f, 0.07107206f, 0.17684194f, 
    0.10688337f, 0.09420259f, -0.06005436f, -0.12412872f, -0.24635793f, 0.09876762f, 0.09534207f, 0.01037885f, 
    0.12027152f, 0.08867240f, 0.06981651f, -0.02352865f, -0.14416015f, 0.05587719f, 0.00804261f, 0.07464232f, 
    0.06581535f, -0.05224432f, 0.04797892f, 0.01515619f, 0.01895589f, 0.05626748f, -0.09219602f, 0.04227060f, 
    0.10833660f, 0.04741101f, -0.04303847f, -0.09073053f, -0.16291967f, 0.05181587f, 0.21521725f, -0.06096123f, 
    -0.00688114f, 0.17887038f, 0.00658194f, -0.05457908f, 0.05107148f, 0.03272801f, 0.09137387f, 0.02396476f, 
    -0.30781189f, 0.19920959f, -0.03973006f, -0.05823429f, -0.04723669f, 0.06899142f, -0.02828770f, 0.24284810f, 
    -0.07161596f, 0.12929270f, 0.04918460f, 0.07519192f, -0.05023567f, 0.04059632f, 0.00482148f, -0.08935418f, 
    -0.11556390f, 0.01832017f, -0.01856186f, 0.01115938f, -0.12760700f, 0.03169476f, -0.09330080f, 0.12174780f, 
    0.09685116f, 0.01611584f, -0.10164091f, 0.06250573f, -0.04816682f, -0.08011626f, 0.11748833f, -0.11468887f, 
    -0.04428721f, 0.08032744f, -0.09690283f, 0.07879218f, -0.01509519f, -0.11622693f, -0.02576727f, 0.09509005f, 
    0.08718972f, 0.15651621f, 0.25860241f, -0.09903909f, 0.26943445f, -0.14864394f, -0.07925508f, -0.06420483f, 
    -0.03154175f, -0.15145399f, 0.10177559f, -0.04588218f, -0.08104824f, 0.02589687f, 0.05554084f, -0.10778040f, 
    0.05843597f, 0.06319544f, -0.02965257f, -0.13658348f, 0.44891912f, -0.04892013f, 0.05388477f, -0.21457873f, 
    -0.18542060f, -0.05767930f, 0.02354581f, -0.12755117f, 0.21842788f, -0.04999636f, 0.05063800f, -0.04387367f, 
    0.02364228f, -0.01977455f, 0.06380268f, -0.06937494f, 0.13097589f, 0.02284900f, 0.16780423f, 0.05096318f, 
    0.08797468f, 0.12972073f, 0.16425093f, -0.13229331f, -0.27138576f, 0.09106983f, -0.03427464f, -0.11661600f, 
    0.20028253f, 0.01543781f, -0.05466913f, -0.00913899f, 0.01568214f, 0.02603498f, 0.05071361f, -0.09298059f, 
    0.04057390f, 0.15119396f, -0.02286680f, -0.19075121f, -0.19540915f, 0.06002383f, -0.24397933f, -0.04309374f, 
    -0.17672859f, 0.18132380f, 0.09712828f, 0.11714569f, -0.05495339f, 0.04861126f, -0.01982172f, 0.01763251f, 
    -0.06095602f, -0.06562325f, 0.01700387f, 0.02378064f, 0.02581882f, -0.01983045f, -0.08893892f, 0.06992060f, 
    -0.38116381f, 0.17220502f, -0.18597817f, -0.09210902f, -0.03177305f, 0.02867147f, -0.01345342f, -0.03834940f, 
    -0.05767666f, 0.00407869f, 0.05114867f, 0.01843649f, 0.14343621f, 0.05800371f, 0.18606745f, 0.01831158f, 
    0.00692717f, -0.15589580f, 0.03693018f, -0.01757332f, 0.33679563f, -0.02353621f, 0.00712943f, -0.17247875f, 
    -0.33943695f, 0.13626985f, -0.11728911f, 0.03978722f, -0.32888728f, 0.22130768f, 0.06854919f, -0.06329732f, 
    0.03469505f, -0.07728785f, 0.02732996f, 0.04843518f, 0.09507789f, 0.03635873f, -0.17556460f, 0.06839968f, 
    -0.00297444f, -0.02272104f, -0.02048570f, -0.06279388f, -0.01724149f, 0.03726232f, 0.04132591f, -0.00198343f, 
    -0.02149714f, -0.05964151f, -0.03176260f, 0.00410165f, 0.04344891f, -0.04434751f, 0.01758955f, -0.03739454f, 
    -0.05282857f, -0.03672550f, -0.04807680f, 0.00786641f, 0.02382067f, -0.01315785f, -0.00628010f, 0.03228886f, 
    -0.03008524f, 0.02266158f, 0.03643953f, -0.00681806f, -0.05847070f, 0.02628265f, 0.00152271f, -0.00926384f, 
    -0.03690644f, 0.04824364f, -0.03017920f, -0.03261035f, -0.05144099f, -0.06201271f, 0.02690109f, -0.05336734f, 
    -0.03061767f, 0.05363491f, -0.06109584f, -0.01365416f, 0.00494688f, 0.02979491f, 0.00185165f, -0.01495328f, 
    0.04280166f, -0.00527156f, -0.02127912f, 0.03218289f, 0.04650392f, -0.05795000f, 0.03640789f, -0.04561491f, 
    0.01262813f, 0.01456699f, -0.01010607f, -0.00830055f, 0.03568554f, 0.02773831f, 0.03919615f, -0.01738307f, 
    0.02246787f, 0.02263703f, -0.05878467f, -0.03408694f, -0.00517650f, -0.00716033f, 0.04162563f, -0.01067607f, 
    0.04078264f, 0.03636584f, -0.03119666f, 0.02200920f, 0.01605013f, -0.01456136f, -0.02612747f, -0.00913868f, 
    -0.05399486f, 0.00366641f, 0.03785656f, 0.01105943f, 0.04959132f, 0.04072020f, -0.04686065f, -0.00348762f, 
    0.03408762f, -0.04448608f, 0.02306312f, -0.06234407f, 0.04917103f, 0.01954744f, -0.03895370f, -0.05483720f, 
    -0.05051726f, 0.04718530f, -0.05132775f, -0.00332457f, 0.02419719f, -0.01954515f, 0.02493070f, -0.03332988f, 
    -0.02576898f, 0.03747834f, -0.03884977f, -0.02860009f, -0.04404698f, -0.01228387f, -0.05613716f, -0.04542059f, 
    0.01113184f, -0.03638308f, 0.02813050f, 0.03408701f, -0.01054524f, -0.03452179f, -0.04610630f, -0.02155974f, 
    -0.05706788f, 0.01202936f, -0.00344454f, 0.04373922f, 0.02989659f, 0.02531268f, -0.06115842f, -0.00183735f, 
    0.02360328f, -0.05934303f, 0.03755608f, 0.00635508f, -0.01953885f, -0.05675368f, 0.03162226f, 0.02512567f, 
    -0.05755306f, 0.04737196f, -0.02541230f, -0.00356131f, 0.01806344f, 0.00674138f, 0.03088942f, -0.03886303f, 
    0.00033038f, 0.01222587f, -0.01839730f, 0.00927001f, -0.00490126f, 0.01804952f, -0.03034475f, -0.03427646f, 
    0.01067742f, -0.05084823f, 0.00564583f, 0.00509730f, -0.01128582f, 0.01819117f, 0.00363230f, -0.04611425f, 
    0.01093656f, 0.02760521f, -0.01211142f, 0.02038920f, 0.01570630f, -0.01434076f, 0.01064530f, -0.03554541f, 
    0.01346257f, -0.00448419f, 0.04239200f, -0.04826215f, -0.02304434f, -0.04735855f, 0.03559348f, 0.03581483f, 
    -0.05782184f, -0.01423254f, -0.01114814f, -0.00493401f, 0.01868355f, 0.01706278f, -0.04494374f, 0.01830477f, 
    -0.01476062f, 0.00177512f, 0.04445711f, -0.02695734f, 0.02685720f, 0.02332410f, -0.02189853f, -0.02119121f, 
    0.02502804f, -0.04969057f, 0.03644232f, 0.00056677f, -0.00457391f, 0.02680599f, -0.05333974f, -0.01822146f, 
    -0.01640484f, 0.03356696f, 0.01919329f, 0.00067517f, 0.01056029f, 0.03294669f, 0.01734138f, -0.03862866f, 
    0.00820269f, -0.04560648f, 0.03224680f, 0.04032927f, -0.00410645f, 0.02760202f, -0.02796767f, -0.00591561f, 
    -0.01384385f, -0.02234670f, 0.00317463f, 0.03072691f, -0.06131588f, 0.01303611f, 0.01920167f, 0.03560559f, 
    -0.04439512f, -0.01015968f, -0.00517986f, -0.06148212f, 0.02907943f, 0.01698392f, 0.01753510f, -0.04543145f, 
    -0.00208730f, 0.00320816f, -0.01408260f, -0.02273342f, 0.04514407f, -0.00901255f, 0.00469063f, -0.01044979f, 
    -0.03683811f, 0.01253147f, -0.01639570f, -0.03640869f, 0.00291334f, -0.00092277f, 0.04767413f, -0.00053722f, 
    -0.04165373f, -0.02022576f, -0.02068434f, -0.00534027f, -0.01745406f, -0.02390819f, -0.00658949f, -0.01312476f, 
    0.04603595f, 0.03195604f, -0.03671413f, -0.05162236f, 0.04974812f, -0.03601016f, 0.04304734f, 0.01757875f, 
    -0.05311348f, -0.03058044f, -0.03452203f, 0.00677051f, 0.02762088f, -0.01684772f, -0.05525176f, -0.03009347f, 
    0.03091001f, -0.01304361f, 0.03770544f, -0.05529363f, 0.02004967f, -0.00586692f, -0.05759634f, -0.01342308f, 
    -0.04601720f, -0.00361994f, -0.05131773f, 0.03125082f, 0.02203939f, -0.04348269f, 0.03638718f, 0.01086213f, 
    -0.02855198f, 0.01737987f, -0.04993355f, -0.02491246f, -0.02063992f, 0.04305032f, 0.01866397f, -0.03482051f, 
    -0.04775455f, 0.01505416f, -0.02833353f, -0.00548412f, -0.01127904f, 0.05512780f, -0.04875739f, -0.05682549f, 
    -0.05293295f, 0.00026594f, -0.06182092f, -0.03795129f, 0.00342408f, -0.03270379f, 0.01020218f, 0.02810823f, 
    -0.01702027f, 0.04446815f, 0.04829851f, -0.06126173f, -0.04328299f, 0.00621665f, 0.03359595f, -0.04709537f, 
    0.30643857f, 0.39245859f, 0.26431441f, 0.22020954f, -0.26938015f, 0.02290154f, 0.01702036f, -0.16485207f, 
    0.09223554f, 0.05957710f, -0.02913236f, -0.09129220f, -0.06886365f, 0.13133319f, 0.10166753f, 0.14260635f, 
    0.08046906f, -0.08200732f, -0.06121384f, -0.01148912f, -0.09172134f, -0.11806662f, 0.45743719f, 0.10964543f, 
    0.01096229f, 0.14194912f, -0.01997481f, 0.05657917f, -0.02409415f, 0.05373933f, -0.00368353f, 0.07068640f, 
    -0.01441104f, 0.05706380f, 0.17142567f, 0.11846459f, 0.10094607f, 0.07041608f, 0.01992261f, 0.20051488f, 
    0.04488390f, 0.05111673f, 0.05241792f, 0.32172903f, 0.10448616f, 0.00351386f, -0.08701240f, 0.11010528f, 
    -0.08052597f, 0.16643666f, -0.09789278f, -0.03892618f, 0.07230974f, -0.02138928f, -0.03391255f, 0.01957519f, 
    -0.02141512f, 0.11891492f, 0.00111982f, 0.17422286f, -0.02552650f, 0.22631261f, -0.07127381f, 0.19559063f, 
    0.22548921f, -0.09849880f, -0.12266754f, -0.09144142f, -0.00434877f, -0.08519425f, -0.03528574f, 0.15083341f, 
    0.05437874f, 0.15308076f, -0.04550594f, 0.03601625f, -0.16026880f, -0.10833826f, -0.06119363f, -0.10067507f, 
    0.06955903f, -0.10942200f, -0.03167581f, -0.01898566f, -0.02484896f, 0.01649683f, 0.06923520f, 0.14347422f, 
    -0.03424534f, 0.03796535f, 0.02197107f, 0.10142197f, 0.07537219f, 0.13020729f, 0.03168432f, -0.02293313f, 
    -0.13910630f, -0.16726397f, 0.00171903f, -0.01445269f, -0.04726365f, -0.17092910f, 0.22319651f, -0.11308113f, 
    0.10875536f, 0.05559194f, 0.10394762f, -0.03893656f, 0.06077932f, 0.03686991f, 0.06839853f, -0.02667026f, 
    -0.02704769f, 0.03022175f, 0.13940434f, -0.01563857f, 0.16648163f, -0.09655924f, 0.09430687f, -0.22306852f, 
    -0.13472052f, 0.27420366f, -0.03635135f, -0.15175459f, 0.21403375f, -0.07733368f, -0.02934537f, -0.08035190f, 
    0.07907628f, 0.12240651f, -0.02181891f, 0.03922205f, -0.00043826f, 0.07133369f, -0.01503474f, 0.01088457f, 
    -0.11825845f, -0.10030004f, -0.01751393f, 0.13941181f, -0.06066317f, 0.06286401f, -0.00395870f, -0.13097097f, 
    0.09162921f, -0.08312695f, 0.07787628f, -0.00137114f, 0.08552152f, 0.05911829f, 0.02048811f, 0.11446935f, 
    0.07938489f, 0.07016595f, 0.01789448f, 0.00216608f, -0.01152815f, -0.00036313f, -0.04731543f, -0.09711896f, 
    -0.01135607f, -0.16418169f, -0.02030823f, -0.01647406f, 0.10287964f, 0.06244621f, 0.00326339f, 0.08022884f, 
    -0.04077614f, -0.10806262f, -0.08931100f, 0.00057549f, 0.02044813f, 0.03102109f, -0.08924396f, 0.14734273f, 
    0.14675649f, 0.20718005f, 0.18638256f, 0.19889954f, 0.18284155f, -0.15569542f, -0.07190708f, -0.28092390f, 
    0.12146092f, 0.03147078f, 0.03837718f, -0.00387582f, -0.01717734f, 0.03078910f, 0.00176353f, 0.07697868f, 
    0.03872615f, -0.03681368f, 0.04194725f, 0.11570519f, 0.09200221f, 0.06611040f, 0.01293717f, -0.13586625f, 
    0.24938263f, -0.27762687f, -0.32664281f, -0.01768364f, -0.07415933f, 0.02361070f, -0.05174028f, 0.00509484f, 
    -0.00640420f, 0.04439577f, 0.00107094f, 0.07469623f, 0.10577160f, 0.05201826f, -0.03708532f, 0.09644949f, 
    0.05317376f, 0.05651675f, 0.03284552f, -0.09408695f, -0.20951056f, 0.35476974f, -0.18721732f, -0.03315662f, 
    -0.01440743f, 0.07976116f, -0.06319089f, 0.03999877f, 0.12544489f, 0.18910402f, -0.03628008f, -0.06875121f, 
    0.05510093f, 0.08394849f, -0.16209283f, -0.03871718f, -0.15149683f, -0.06510215f, 0.01296593f, 0.06733391f, 
    -0.03649202f, -0.06111763f, -0.21959458f, 0.15210564f, 0.05159504f, 0.07563985f, -0.00721177f, 0.05766882f, 
    0.01187604f, 0.10944749f, -0.14295985f, 0.01062210f, -0.00827599f, -0.05441420f, -0.02258107f, 0.05108384f, 
    -0.01951905f, -0.06164406f, -0.06624913f, 0.27468094f, -0.45349982f, 0.25379953f, 0.13592306f, 0.15954895f, 
    0.34714445f, -0.14090551f, -0.11118374f, 0.11991627f, -0.07397727f, -0.10454948f, -0.01292238f, -0.02268148f, 
    0.12914880f, -0.04630066f, -0.04612898f, 0.02696654f, 0.04274889f, 0.03266327f, -0.22795647f, -0.07498139f, 
    -0.07247201f, -0.06172765f, 0.63499147f, 0.41980031f, 0.04343852f, 0.03772410f, -0.09402744f, 0.07718705f, 
    0.10615479f, -0.12318788f, -0.00881951f, -0.08641572f, 0.00932596f, 0.08422830f, 0.03725676f, -0.00819193f, 
    -0.06712490f, -0.01064789f, 0.00087336f, -0.06110228f, -0.30303484f, 0.19624339f, 0.00756367f, -0.11573144f, 
    -0.16125920f, -0.16495882f, -0.05309723f, 0.03524142f, 0.21795167f, -0.07991376f, -0.12728591f, -0.07415047f, 
    0.01729584f, -0.04236221f, -0.07508374f, -0.02313592f, -0.04613230f, -0.06161460f, 0.15992953f, 0.02030980f, 
    0.02077976f, 0.04129600f, -0.05683003f, -0.04288274f, -0.02475800f, 0.02597399f, 0.03898648f, 0.04877766f, 
    0.00309112f, -0.04193828f, 0.01028049f, -0.01620273f, -0.05593420f, -0.04777993f, -0.04999841f, 0.04824497f, 
    -0.04531610f, 0.01944406f, -0.06115708f, -0.05661654f, -0.01290905f, -0.01218592f, -0.03576491f, -0.05592880f, 
    0.00933352f, -0.03171240f, 0.02390589f, -0.04909435f, -0.02890719f, -0.03257230f, 0.00288442f, 0.00670473f, 
    0.00873752f, -0.01094309f, 0.00891385f, -0.00511836f, -0.05378108f, 0.04754227f, 0.03232773f, -0.04610325f, 
    -0.00511060f, 0.01530231f, -0.02745367f, -0.00389197f, 0.03366947f, -0.05256687f, -0.00397841f, 0.04789412f, 
    0.01167155f, -0.05172643f, -0.04959759f, 0.02298437f, -0.04914558f, 0.02458050f, 0.03275520f, -0.06098599f, 
    0.04976606f, 0.02577375f, -0.04736832f, 0.03250826f, 0.00131731f, 0.04712062f, 0.03901563f, 0.03151094f, 
    -0.02491521f, -0.04863390f, 0.00859889f, 0.01078359f, 0.02328815f, 0.02890942f, -0.03024405f, 0.00301272f, 
    0.02662011f, 0.02528854f, -0.04667282f, 0.04734199f, 0.01007798f, -0.04912973f, 0.04117306f, 0.04932839f, 
    0.00463312f, -0.01183945f, -0.05176155f, 0.00119726f, -0.05769024f, -0.04622212f, -0.00924699f, 0.01763805f, 
    -0.03656203f, 0.03195207f, 0.03106619f, 0.05004666f, -0.04229501f, 0.03658209f, -0.02554112f, -0.03029413f, 
    0.04273804f, 0.04066695f, -0.02850364f, -0.05372962f, -0.02027682f, 0.01086235f, 0.00768057f, 0.03965970f, 
    0.03769540f, 0.02227445f, -0.04292364f, -0.00852822f, 0.00203915f, 0.01100404f, -0.04660122f, -0.05239171f, 
    0.00626752f, 0.04379547f, -0.01098146f, 0.00334984f, -0.01895952f, -0.00414433f, 0.02248880f, -0.00548486f, 
    -0.05597505f, -0.04016248f, -0.02146376f, 0.04756040f, -0.04390002f, -0.00740606f, -0.04878148f, -0.06118472f, 
    -0.02851586f, -0.05761886f, -0.01198035f, -0.02190538f, 0.03506018f, -0.02380542f, -0.02603942f, -0.05462762f, 
    0.00783432f, -0.05593419f, -0.02950351f, -0.04927479f, 0.00526643f, -0.01313707f, -0.01415167f, -0.00757726f, 
    -0.00642693f, -0.01423215f, -0.03594698f, 0.02307266f, -0.05578435f, 0.03826999f, -0.04154274f, -0.02790462f, 
    -0.04877779f, -0.01143903f, -0.01452550f, -0.02712900f, -0.00938286f, -0.03295492f, -0.01598871f, -0.03685914f, 
    -0.03622304f, 0.00298440f, -0.03029447f, 0.01672537f, 0.00605468f, -0.02166284f, 0.00912200f, -0.05417152f, 
    -0.04630431f, 0.00200389f, -0.04166442f, -0.01116807f, 0.02745439f, -0.01077161f, -0.02169858f, -0.00487965f, 
    -0.00855752f, 0.03346656f, 0.03015966f, 0.02130044f, 0.02427102f, 0.00853977f, -0.05729529f, 0.02600799f, 
    -0.01364348f, -0.04372262f, 0.02372822f, 0.03040165f, 0.04866147f, 0.04881718f, -0.01441021f, -0.03271537f, 
    -0.01194537f, -0.05358416f, -0.01135236f, -0.02196582f, 0.02890097f, -0.02105238f, -0.00483786f, -0.01258816f, 
    -0.04580250f, -0.05313804f, 0.03190991f, -0.04157669f, 0.04561456f, -0.05809843f, -0.02077649f, -0.00307913f, 
    0.02773531f, 0.05427971f, -0.02135471f, -0.02776892f, -0.05063926f, -0.03379426f, -0.03148923f, 0.00484070f, 
    -0.02905156f, 0.00914214f, 0.02396550f, 0.01137208f, -0.05373447f, -0.02242699f, -0.00769885f, -0.03835009f, 
    -0.05535039f, 0.02874331f, -0.00085899f, 0.03068437f, 0.03204132f, -0.02313161f, -0.01070460f, 0.04061225f, 
    -0.02332427f, -0.01878100f, -0.03842947f, -0.05718258f, 0.04486823f, -0.04895239f, -0.03790988f, -0.02722482f, 
    0.01577640f, -0.01680415f, -0.00311194f, -0.04434972f, -0.06054756f, -0.03569894f, 0.00311454f, -0.00474452f, 
    -0.00637541f, 0.01252119f, -0.02009755f, -0.04355294f, 0.04944904f, 0.04341036f, -0.05584003f, -0.04464860f, 
    0.03643069f, 0.01838760f, 0.03761729f, -0.02236792f, 0.00792319f, 0.01199099f, 0.01204755f, -0.00766638f, 
    -0.00771197f, -0.04053625f, 0.00753742f, -0.04391986f, 0.04042791f, -0.02563318f, 0.00985121f, 0.00392901f, 
    -0.03294137f, 0.01589920f, -0.01241596f, 0.01358287f, 0.01240885f, 0.00329983f, -0.04812859f, 0.00252812f, 
    0.03531302f, -0.02887406f, -0.01517381f, 0.02846172f, 0.03176855f, -0.03348628f, 0.00245653f, -0.04510866f, 
    -0.02917358f, -0.04743146f, -0.03161832f, 0.05019318f, 0.02586628f, -0.02823744f, -0.01601445f, -0.00794529f, 
    -0.01826294f, -0.00752232f, -0.00479250f, -0.01102787f, 0.01897777f, -0.04106813f, 0.01127930f, -0.04134447f, 
    -0.04810337f, -0.00273976f, 0.04312083f, 0.04341487f, 0.00977104f, 0.02644094f, 0.02460799f, -0.04361634f, 
    -0.05235077f, 0.02228962f, -0.02988800f, -0.02002241f, -0.04854062f, 0.02810366f, -0.03590415f, -0.04321784f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.00170706f, -0.00865833f, 0.00876972f, 0.15815027f, 0.15704511f, -0.02075493f, 0.02192822f, 0.14658417f, 
    0.16891955f, 0.10022300f, -0.01826791f, -0.02178613f, -0.05077136f, -0.01089214f, -0.03763796f, 0.08390137f, 
    0.04271189f, 0.10482385f, 0.02327654f, 0.01065092f, 0.27722147f, 0.05367768f, -0.01985290f, 0.01066161f, 
    -0.05782776f, -0.02233710f, 0.14025663f, -0.04387154f, 0.06450057f, 0.03276613f, 0.31338310f, 0.02206668f, 
    -0.08614599f, -0.12509590f, 0.13978021f, -0.10168930f, 0.00614957f, 0.15941952f, 0.00216112f, -0.01264627f, 
    0.02431624f, -0.01712750f, 0.03854199f, 0.07829413f, -0.04825254f, -0.00891226f, 0.27689859f, 0.01947830f, 
    0.01442901f, 0.00131675f, 0.04321490f, 0.02220904f, 0.09804747f, 0.04728157f, -0.00493832f, 0.00548132f, 
    -0.06617405f, 0.08146137f, 0.04284940f, 0.04258110f, 0.15368412f, 0.03689878f, 0.09700324f, -0.01342455f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.07621146f, 0.02279925f, -0.06112733f, 0.11915907f, -0.18934289f, -0.09913854f, -0.06055003f, 0.05310181f, 
    0.32743672f, -0.05048016f, -0.15144844f, 0.01154576f, -0.15232341f, 0.12818295f, 0.00111136f, -0.16634299f, 
    -0.24418469f, 0.08406833f, 0.40419617f, -0.30210593f, 0.00952759f, -0.24824490f, 0.09544066f, 0.08571329f, 
    0.22232497f, 0.01732160f, 0.07889557f, 0.11255242f, 0.14743869f, 0.16409062f, -0.06015455f, -0.08216246f, 
    -0.00064169f, 0.19659603f, 0.07861716f, -0.27762246f, 0.06946661f, 0.03402475f, 0.04663540f, 0.02493010f, 
    0.01288235f, 0.13364756f, 0.10099325f, 0.27812225f, 0.08179957f, 0.11247023f, 0.00188688f, -0.11433363f, 
    -0.10489543f, 0.07262779f, 0.09983660f, 0.10692616f, 0.11594793f, 0.09550870f, 0.09546792f, -0.12640706f, 
    0.11308739f, -0.12549165f, 0.01044595f, -0.01827633f, -0.02695891f, -0.03977387f, 0.12282860f, 0.10513213f, 
    -0.07515027f, 0.07333352f, 0.01743917f, -0.02710476f, 0.28229165f, 0.01362576f, 0.00369586f, 0.00605762f, 
    0.10832333f, 0.19883935f, 0.03177193f, 0.03399913f, 0.05183203f, 0.06687050f, 0.05212394f, 0.24383228f, 
    0.12856460f, 0.19841821f, 0.01363962f, -0.28190067f, 0.11928184f, 0.18968856f, -0.20383576f, -0.08506521f, 
    -0.20614699f, 0.01899694f, -0.05819680f, 0.02596214f, 0.01651362f, 0.07788235f, 0.35041654f, -0.04705567f, 
    0.08340989f, -0.26920789f, -0.05037300f, -0.05795151f, -0.10346926f, 0.04063320f, -0.04487639f, -0.04824370f, 
    -0.09023605f, -0.31588683f, -0.05837555f, -0.12241126f, 0.11686276f, -0.11878026f, 0.04633280f, -0.02988522f, 
    -0.10081020f, 0.00813438f, 0.06173813f, 0.05694918f, 0.36852536f, -0.09109294f, -0.11390156f, -0.19347028f, 
    0.04952472f, 0.25272024f, -0.17368594f, 0.02641979f, 0.13443193f, 0.00161411f, 0.21916306f, 0.07923933f, 
    -0.12417058f, 0.01949099f, 0.12448061f, -0.01514555f, -0.11889894f, 0.07014471f, -0.05050589f, -0.04686827f, 
    -0.08888133f, 0.10808928f, 0.01032434f, 0.08737585f, -0.14007644f, -0.12469628f, 0.00351300f, -0.00997121f, 
    -0.10597711f, -0.07335234f, -0.04755425f, -0.11965895f, -0.01693788f, 0.05022066f, 0.03147964f, -0.04520259f, 
    0.01380725f, -0.09439519f, -0.14332274f, -0.00153561f, -0.07577367f, 0.07414546f, 0.07358739f, 0.00577325f, 
    -0.03359761f, -0.02060519f, -0.03921388f, -0.01339857f, 0.10645895f, -0.01918964f, 0.08327504f, -0.03151777f, 
    -0.08411938f, -0.11696982f, 0.08728362f, -0.00669559f, 0.04157379f, -0.12253214f, -0.09595798f, 0.05112717f, 
    0.03493436f, -0.02250125f, 0.06587853f, 0.01409513f, 0.06258051f, 0.05113345f, -0.09103503f, 0.05220246f, 
    -0.01800838f, 0.04040967f, 0.05162065f, 0.08726493f, -0.13830462f, -0.12403344f, 0.02634547f, 0.03617038f, 
    -0.01641696f, 0.01560794f, 0.12786277f, 0.11941628f, -0.03683172f, -0.03705128f, -0.10881335f, 0.06062014f, 
    -0.02060324f, -0.25630784f, -0.13934337f, 0.09677934f, 0.08198494f, 0.02357980f, -0.01572275f, -0.18490590f, 
    -0.22608782f, -0.15191726f, -0.11366399f, 0.33476120f, -0.21665801f, 0.09001622f, 0.40253308f, 0.08273979f, 
    0.31808183f, -0.00737288f, 0.08621970f, -0.08377261f, -0.02660934f, -0.08818788f, -0.25983897f, -0.03056136f, 
    0.09661426f, 0.37622446f, -0.02344006f, 0.07775740f, 0.11611477f, -0.13414451f, 0.01583230f, -0.05928157f, 
    -0.07680295f, 0.25949922f, 0.02988396f, 0.18937075f, 0.05424101f, 0.00166775f, -0.13617000f, -0.00452434f, 
    -0.23418202f, -0.08544441f, 0.02334680f, 0.12901725f, -0.51914597f, -0.04738518f, 0.10644104f, 0.18610930f, 
    0.00824562f, 0.11849810f, 0.14237858f, -0.04587775f, -0.02328383f, 0.01976378f, 0.01637838f, 0.09663852f, 
    -0.05064062f, 0.03807762f, 0.10558479f, 0.16307685f, 0.35668567f, 0.02383042f, -0.05241502f, 0.28303424f, 
    -0.26846445f, 0.04168277f, 0.14027691f, -0.04004028f, -0.08657077f, -0.04518205f, -0.03782186f, 0.11746811f, 
    0.11696022f, -0.06030709f, -0.16474237f, 0.15633975f, -0.00124861f, 0.00473528f, 0.30940980f, -0.10945433f, 
    -0.11165375f, 0.02091767f, -0.04399368f, -0.10144628f, 0.16122380f, -0.03120677f, 0.13216673f, 0.12229794f, 
    0.02042390f, -0.14206153f, 0.14927882f, -0.11737613f, -0.02523796f, 0.11997865f, 0.01688340f, -0.03449724f, 
    -0.08926380f, 0.13005707f, -0.09261631f, -0.11153969f, -0.03815408f, -0.04977038f, 0.32049683f, -0.04908222f, 
    -0.07675594f, -0.03548117f, -0.06480514f, 0.02763098f, -0.27541271f, 0.10715640f, 0.03363729f, 0.13949633f, 
    -0.23564585f, 0.19521569f, 0.19103606f, 0.00209156f, 0.18842220f, 0.02194515f, -0.04762701f, -0.11428038f, 
    -0.10035825f, -0.09184210f, -0.11576115f, -0.09540712f, -0.30427343f, 0.02065770f, 0.04331492f, -0.36492169f, 
    -0.20923094f, 0.07192740f, 0.19250920f, 0.06684624f, -0.08578289f, 0.29422417f, 0.04044012f, 0.14254451f, 
    0.14096406f, 0.03538631f, 0.03465649f, -0.05888126f, 0.06408519f, 0.07265383f, -0.06348146f, -0.12612142f, 
    0.03612981f, -0.10281910f, -0.07636318f, 0.02567755f, -0.02769777f, -0.03325833f, 0.16516154f, 0.03889160f, 
    -0.01239230f, -0.07622619f, 0.02109082f, 0.14434890f, 0.00342412f, 0.02521640f, 0.05524839f, 0.04678586f, 
    -0.09859763f, 0.00973046f, -0.11483803f, 0.00392774f, 0.08581039f, 0.11428034f, -0.20909134f, -0.07616089f, 
    0.14684795f, -0.06185018f, -0.11670974f, -0.16772304f, 0.13236777f, -0.08272129f, -0.10446730f, -0.12439986f, 
    0.09576734f, -0.14802505f, -0.16870931f, -0.03302784f, -0.04122538f, 0.11213520f, 0.08379420f, 0.06474677f, 
    0.08662165f, -0.11997536f, 0.05001028f, 0.12228287f, 0.04413597f, -0.01488051f, 0.04517514f, 0.14914274f, 
    0.16448019f, 0.22361945f, -0.27199066f, 0.11974289f, -0.17171913f, 0.21978295f, -0.12438417f, -0.08293258f, 
    0.09805322f, -0.08840772f, -0.01800138f, 0.03726378f, -0.07962682f, -0.00915038f, -0.02971554f, 0.00633766f, 
    0.31585923f, -0.10482223f, -0.01747608f, 0.00279636f, -0.00536821f, -0.27344659f, 0.21536280f, 0.06096832f, 
    0.03273058f, -0.02585590f, -0.29334277f, -0.15759248f, 0.08508824f, -0.00322112f, -0.01660330f, 0.05092443f, 
    -0.09647614f, -0.07210830f, 0.10513797f, -0.20663543f, -0.01089180f, 0.05591130f, 0.15702264f, -0.10795333f, 
    -0.16166988f, -0.09308270f, -0.07209645f, 0.08650622f, -0.12953126f, 0.11103843f, 0.00145681f, 0.01938533f, 
    -0.08549404f, 0.06504626f, -0.15770787f, -0.06763298f, -0.18074909f, -0.09556372f, -0.02345335f, -0.06745259f, 
    0.02476695f, 0.11019568f, -0.01507765f, -0.04208893f, 0.30227125f, -0.07485171f, -0.09719115f, 0.03647565f, 
    0.07941940f, 0.11627901f, 0.20082460f, -0.01998784f, -0.02297047f, -0.36757252f, 0.02420695f, -0.01005562f, 
    0.10048299f, -0.12477920f, -0.06082199f, 0.09333587f, 0.17346655f, 0.10952777f, 0.00417731f, -0.01978031f, 
    -0.05032192f, -0.04777445f, -0.04021762f, -0.01005708f, 0.08566900f, 0.23956527f, -0.13173102f, -0.11128658f, 
    -0.13581857f, -0.16014704f, 0.11657039f, -0.00586483f, -0.07115825f, 0.05151838f, -0.06831823f, 0.03773588f, 
    0.05682877f, 0.02704019f, -0.05111937f, 0.11011761f, 0.11052193f, 0.01324604f, 0.15516689f, -0.01995122f, 
    0.15737039f, -0.05132481f, -0.03132458f, -0.08954657f, -0.18709947f, 0.05301075f, 0.07136874f, 0.16435942f, 
    -0.12065829f, -0.14124495f, 0.07646779f, -0.01479603f, -0.12843762f, 0.03770685f, 0.09484868f, -0.01743041f, 
    -0.02007948f, -0.08879860f, 0.02288689f, -0.02227984f, -0.08381893f, 0.12041163f, 0.03102426f, -0.26946947f, 
    -0.13159132f, -0.01982466f, 0.01546108f, 0.02382137f, -0.07045618f, 0.41585571f, 0.01455543f, 0.09080514f, 
    -0.07359713f, 0.10349794f, -0.28482869f, 0.08959907f, 0.02579387f, 0.29316533f, -0.17727457f, -0.07299776f, 
    -0.06927946f, 0.03902832f, -0.05050943f, -0.06867327f, 0.11712860f, -0.05852652f, 0.27305931f, -0.04843187f, 
    0.19820999f, -0.22092038f, 0.21261062f, -0.07125908f, 0.04404082f, 0.02963089f, 0.09946509f, -0.11748134f, 
    0.07575331f, -0.00981966f, 0.07228301f, 0.00144263f, -0.09990387f, -0.08350239f, 0.05121202f, -0.10008253f, 
    0.03262575f, -0.05983754f, -0.06044988f, -0.12441473f, 0.32909405f, -0.03938216f, -0.04498746f, -0.01497224f, 
    0.12314560f, 0.09277669f, 0.08650960f, -0.11527706f, 0.22467144f, 0.08273442f, -0.08239706f, -0.02152097f, 
    -0.11649606f, 0.06618918f, 0.08525597f, 0.07535890f, 0.02385813f, -0.07317480f, 0.01932511f, 0.16587156f, 
    0.38314176f, 0.06911148f, -0.11215661f, 0.00478278f, 0.36232653f, -0.27892634f, -0.00534984f, -0.27319923f, 
    -0.07403767f, -0.02841225f, 0.38320509f, -0.29606009f, 0.21610068f, -0.01436174f, 0.18058679f, 0.13039713f, 
    0.00127925f, 0.07575086f, 0.12509263f, 0.02939440f, -0.06678716f, 0.17468244f, 0.04645616f, 0.05121010f, 
    0.16640961f, 0.23940037f, 0.16200705f, -0.01424889f, 0.02196923f, 0.06547081f, 0.03578036f, -0.08987880f, 
    0.09942478f, -0.10864677f, -0.07152919f, 0.05056835f, 0.05246989f, -0.01221142f, -0.07548433f, -0.00450453f, 
    0.13754413f, 0.03507942f, -0.12669489f, 0.23664011f, -0.00899935f, 0.03983016f, -0.07803737f, -0.43874800f, 
    0.16344467f, -0.40136987f, 0.09760126f, 0.06896592f, -0.37678638f, -0.04550300f, 0.12854689f, -0.01427308f, 
    0.12171347f, -0.06020817f, -0.00280672f, -0.01791328f, -0.12239321f, 0.00743277f, 0.10698457f, -0.30112591f, 
    0.13002454f, -0.07327367f, 0.32054144f, 0.09103566f, -0.21237710f, -0.03173135f, 0.00342064f, 0.07049840f, 
    0.08480682f, 0.12895651f, -0.19475888f, 0.08671729f, -0.10117595f, 0.07420239f, -0.45582995f, 0.03738870f, 
    -0.07977249f, -0.02460571f, -0.04762089f, -0.05055344f, -0.27711862f, 0.09571613f, -0.23277220f, -0.11724211f, 
    0.02104101f, -0.20495670f, 0.01939365f, 0.12691383f, -0.07669760f, -0.18398361f, -0.07906239f, -0.09129460f, 
    0.03122719f, 0.08088043f, 0.02557826f, -0.12785329f, 0.01960773f, 0.01079008f, -0.02462200f, -0.04591696f, 
    -0.05464685f, -0.03926431f, 0.05913918f, -0.21118850f, 0.15496933f, 0.11138926f, -0.04620555f, 0.01231588f, 
    0.10070481f, -0.14709668f, 0.05230967f, -0.08143660f, 0.01122615f, -0.02481766f, 0.22932085f, -0.03951453f, 
    -0.12094948f, -0.10846730f, 0.10439077f, 0.05514958f, 0.03257397f, -0.02381836f, -0.09907094f, 0.17159243f, 
    -0.10634520f, 0.04572725f, -0.21035469f, 0.00932254f, 0.18599050f, 0.27969924f, -0.01573811f, -0.04392231f, 
    0.08176534f, 0.18259539f, 0.24540661f, 0.10760533f, -0.19266722f, 0.20125341f, 0.36908263f, 0.03887347f, 
    -0.31445071f, 0.08020777f, -0.13297684f, -0.02008697f, -0.21560629f, -0.34479773f, -0.22313480f, 0.10009611f, 
    -0.42938200f, 0.23056124f, -0.04742412f, 0.29760259f, 0.09432948f, 0.27282742f, -0.03446211f, 0.03749119f, 
    -0.04961338f, -0.15723610f, 0.02817840f, 0.24794072f, -0.12791747f, 0.12529923f, -0.06157228f, 0.09616634f, 
    0.17033048f, -0.01862029f, 0.08435328f, 0.03667043f, 0.19136323f, 0.04539008f, 0.12250473f, 0.30459222f, 
    -0.06591064f, 0.02496494f, -0.31092083f, -0.05889028f, -0.01621385f, 0.03239266f, -0.32074380f, -0.00525367f, 
    0.02961959f, 0.01014271f, -0.09487364f, 0.15993974f, 0.28526932f, 0.08020961f, 0.11180697f, 0.28134221f, 
    -0.16404903f, 0.08340076f, -0.07777532f, 0.02871375f, 0.20347375f, -0.11883225f, 0.11617525f, -0.12132398f, 
    0.10216669f, -0.02810034f, 0.31326455f, 0.11311457f, -0.09150653f, -0.13682070f, 0.25767910f, 0.06674805f, 
    -0.18152440f, 0.07761867f, 0.10346076f, -0.06836904f, -0.17833190f, -0.04381546f, -0.40525743f, -0.03491385f, 
    -0.17211306f, 0.07333779f, 0.03429070f, 0.21952994f, -0.02079571f, 0.33590221f, 0.07785385f, -0.07956165f, 
    0.05699697f, 0.00465969f, -0.08464544f, 0.26412684f, -0.10056570f, 0.07820226f, 0.01018028f, 0.02348134f, 
    0.26906067f, -0.04016754f, 0.04321927f, 0.23610777f, -0.14655238f, 0.01282903f, -0.04029287f, 0.10495146f, 
    0.09062430f, -0.28296226f, -0.00473723f, 0.12524340f, -0.24350114f, -0.00777583f, -0.13158239f, -0.08290339f, 
    -0.00353580f, 0.08630927f, 0.05314729f, 0.26921609f, 0.29706502f, -0.01080141f, -0.03627563f, 0.23337699f, 
    -0.11555939f, 0.24727112f, 0.06938811f, -0.08108065f, -0.14589415f, -0.12314111f, -0.01547303f, 0.18557005f, 
    -0.01804439f, 0.21959035f, -0.33217642f, 0.35220489f, 0.12637165f, 0.28280509f, 0.14415343f, -0.03732312f, 
    -0.40608978f, 0.07898253f, -0.03158251f, -0.02412667f, -0.15131266f, -0.12501550f, -0.30789667f, -0.05920843f, 
    -0.13445064f, -0.19037889f, 0.00840212f, 0.15835924f, 0.03829164f, 0.05319216f, 0.01299427f, -0.11108874f, 
    -0.06116819f, -0.09334186f, -0.10028502f, 0.10558600f, 0.09466612f, -0.08492841f, 0.30493248f, 0.12193888f, 
    0.12985182f, -0.06431835f, 0.00651695f, -0.07456280f, 0.09371466f, 0.11820978f, 0.10913105f, -0.07669445f, 
    -0.19459388f, -0.16151902f, 0.07154403f, -0.10791642f, 0.39791188f, 0.11136897f, -0.04400188f, -0.04963427f, 
    -0.01749711f, -0.05169071f, 0.04436181f, -0.05354167f, 0.11721720f, -0.11414759f, 0.11014076f, -0.12204973f, 
    -0.32769248f, 0.04322502f, 0.13663463f, -0.05811167f, 0.13551135f, -0.00755254f, -0.06412871f, 0.17066509f, 
    0.12422018f, -0.01370919f, -0.38874257f, 0.23477308f, -0.04941285f, 0.36808553f, -0.14958058f, 0.10436480f, 
    0.06103456f, -0.00824310f, 0.01647607f, -0.06252385f, 0.05518648f, 0.14809145f, 0.20499295f, -0.04497628f, 
    0.21722698f, -0.13955089f, 0.11933442f, 0.18205364f, 0.06996959f, -0.23763819f, -0.10909262f, -0.01152231f, 
    0.02954927f, 0.16765293f, 0.01737739f, 0.05955606f, 0.08311943f, -0.04548681f, 0.08382200f, -0.05868877f, 
    -0.07442351f, 0.00860826f, 0.06623415f, -0.20174576f, 0.19477084f, -0.05983419f, 0.11259913f, -0.01057623f, 
    -0.03950521f, 0.10392093f, 0.12612993f, -0.07621613f, 0.30564287f, 0.06713612f, -0.08102292f, 0.07949347f, 
    0.06542167f, -0.07552727f, 0.07741823f, -0.06364495f, -0.25205401f, 0.01506339f, 0.07053763f, -0.19034569f, 
    0.04331066f, 0.12324861f, 0.28287694f, -0.10422919f, 0.27662355f, -0.24407382f, 0.11047821f, 0.14354210f, 
    0.01922071f, 0.14591986f, -0.16128981f, 0.16873787f, 0.05378857f, 0.34894672f, -0.15011524f, 0.06983975f, 
    0.09809335f, 0.06491279f, 0.01640721f, 0.07379951f, -0.09649651f, 0.14215110f, 0.25283328f, 0.05833674f, 
    0.22620319f, 0.01467008f, 0.14977920f, 0.22117437f, 0.04947151f, -0.01142688f, 0.06464139f, 0.07711685f, 
    -0.08735843f, 0.10406845f, 0.11719244f, -0.15356027f, 0.03061642f, 0.11215673f, -0.08474365f, -0.04036044f, 
    0.15445870f, -0.01044571f, 0.03368659f, -0.00929487f, 0.19313374f, 0.03816541f, 0.05049887f, -0.12118905f, 
    0.27084208f, -0.09598100f, 0.17166092f, 0.05592779f, 0.05398367f, 0.02393612f, 0.15419355f, 0.01688931f, 
    -0.10576385f, -0.11776019f, -0.06572279f, 0.02226399f, 0.14478137f, -0.01011517f, -0.05223100f, 0.23617940f, 
    0.36504290f, -0.12485118f, 0.07007597f, -0.01429944f, -0.22740573f, -0.60451955f, -0.02089090f, -0.10452469f, 
    -0.11672091f, 0.08240100f, 0.25349542f, 0.01490215f, 0.06456185f, 0.22900392f, -0.07933341f, 0.07924989f, 
    0.08257660f, -0.09063989f, 0.06316878f, -0.04006875f, -0.06567687f, 0.40127090f, 0.03892724f, 0.06161403f, 
    0.09911707f, 0.09660269f, 0.07882955f, 0.17373969f, -0.08096946f, -0.01205065f, -0.04808487f, 0.03229780f, 
    0.10660369f, -0.10249224f, -0.03619310f, 0.13702093f, -0.11287275f, -0.12695669f, 0.11913727f, 0.09998082f, 
    -0.02045881f, 0.07161324f, 0.09952463f, -0.10173707f, -0.21515265f, -0.06652627f, 0.04056830f, 0.17224018f, 
    0.01376171f, -0.14790787f, 0.25317726f, 0.07157063f, 0.07401828f, -0.00336094f, 0.20109412f, 0.06589490f, 
    -0.03305852f, 0.01541138f, 0.03312833f, -0.08071674f, 0.17464130f, 0.00125111f, -0.04934859f, 0.17925192f, 
    -0.28439018f, -0.08943324f, 0.21276982f, -0.09495042f, -0.15403044f, 0.04832039f, -0.09013743f, 0.17202424f, 
    0.07474893f, -0.14991973f, 0.03512331f, 0.25454402f, -0.08670853f, 0.17542492f, 0.14406914f, 0.10143228f, 
    0.12528284f, -0.06887217f, -0.17476514f, -0.02450454f, -0.02735698f, 0.13117918f, 0.19348624f, 0.12979282f, 
    0.31037685f, 0.10811754f, -0.07317693f, 0.12329727f, -0.09257283f, -0.06865732f, -0.02383157f, -0.10814030f, 
    0.03070344f, 0.25403380f, 0.02081531f, -0.14123051f, -0.09445947f, -0.07059485f, 0.13579060f, -0.10548177f, 
    -0.36589590f, -0.10425287f, -0.00232198f, -0.04078711f, -0.25252554f, -0.01752251f, -0.07203697f, 0.20063014f, 
    -0.02430290f, 0.25184131f, 0.30518591f, -0.01652103f, 0.11446424f, -0.07798799f, 0.01006908f, 0.02445732f, 
    -0.05445746f, 0.07741708f, -0.12125210f, 0.11953870f, -0.03463884f, 0.08533318f, 0.07562587f, -0.17096737f, 
    0.14582014f, 0.09639493f, 0.16851480f, -0.03206498f, 0.06484355f, 0.02165242f, -0.03975888f, -0.02854898f, 
    0.03886436f, 0.26794016f, -0.17859685f, 0.00382435f, 0.11676700f, 0.15656863f, -0.32807565f, -0.12339522f, 
    -0.11854260f, 0.11189760f, 0.15560693f, -0.11908138f, -0.30722618f, -0.21035923f, 0.39039835f, -0.09387519f, 
    -0.04335608f, -0.44657594f, 0.13878018f, 0.10344042f, -0.04666735f, -0.04412058f, 0.02843950f, 0.04557763f, 
    0.05372140f, -0.08972055f, 0.11879151f, -0.19945604f, 0.00128838f, 0.01934767f, 0.13886030f, 0.11405354f, 
    0.09886199f, -0.03395417f, -0.01621181f, -0.03472846f, 0.14540805f, 0.01711011f, -0.09124780f, -0.40414011f, 
    0.18796468f, 0.01769348f, 0.10338956f, 0.07067946f, -0.08255962f, -0.07997382f, 0.22829448f, -0.00807467f, 
    -0.01055555f, -0.08658741f, 0.06340377f, -0.01527439f, 0.32323456f, 0.08435763f, -0.06340630f, 0.18203413f, 
    0.18718784f, 0.36314568f, 0.13061981f, 0.09954485f, -0.22036169f, -0.27727911f, -0.06459060f, 0.09003150f, 
    0.07594698f, 0.00920025f, -0.10791312f, 0.08695909f, -0.10740586f, 0.17921580f, -0.12334891f, -0.01664792f, 
    -0.22101510f, 0.07854310f, 0.17769669f, 0.10398900f, -0.27985740f, -0.00133849f, 0.14668518f, 0.11187147f, 
    -0.05572538f, -0.26269099f, -0.26284406f, 0.23604728f, -0.12981905f, 0.11324970f, -0.09956242f, 0.11966186f, 
    0.00127341f, -0.19224599f, -0.06540070f, 0.01238716f, 0.06526545f, 0.05042280f, 0.13792899f, -0.04334122f, 
    0.16874228f, 0.04115656f, -0.11972440f, 0.14747055f, -0.05729078f, 0.11780097f, -0.05910652f, -0.01980268f, 
    0.07824641f, -0.03453065f, -0.03198991f, 0.00485916f, -0.11084808f, 0.00277088f, 0.13399732f, 0.13063970f, 
    -0.03796209f, -0.07172187f, 0.13710348f, -0.12423845f, 0.02631229f, 0.08836357f, -0.01152326f, 0.06521291f, 
    -0.06325670f, 0.19017425f, -0.02032602f, -0.01888567f, 0.00768812f, 0.12569581f, 0.11121394f, 0.15215023f, 
    0.27283826f, -0.09924839f, 0.02499191f, 0.23248695f, -0.17995347f, -0.11767512f, 0.08039936f, -0.07912132f, 
    0.41018596f, 0.06874039f, 0.10429311f, 0.00648846f, -0.04151475f, 0.28892213f, 0.27046028f, -0.03670895f, 
    0.08584254f, 0.32001626f, -0.40853888f, 0.19860193f, -0.02360128f, 0.13060048f, 0.00000735f, -0.04893481f, 
    -0.11268733f, 0.30232343f, -0.01094035f, 0.11939720f, 0.11505678f, -0.08991901f, -0.23536579f, -0.04131510f, 
    -0.12547614f, -0.08378571f, 0.04608143f, 0.03069136f, -0.03304082f, 0.06392896f, 0.06643515f, -0.02795080f, 
    0.17255093f, 0.07336934f, 0.18339919f, 0.02431034f, -0.23837359f, 0.03149445f, 0.19447835f, -0.02130312f, 
    0.00154538f, -0.06511163f, 0.03559034f, 0.00032292f, -0.25616315f, 0.10513678f, -0.05818876f, 0.09206428f, 
    -0.13034509f, -0.03844600f, -0.25326556f, 0.06206015f, -0.06012920f, 0.08742096f, 0.06789051f, -0.01537051f, 
    0.13013960f, -0.05886588f, -0.06906120f, 0.33372217f, -0.19776258f, 0.02384791f, 0.25438398f, 0.10883158f, 
    0.41378936f, -0.06053149f, 0.07289568f, -0.05945835f, -0.16061558f, 0.04076988f, 0.12367605f, 0.01098205f, 
    0.20672989f, 0.42886335f, -0.04680892f, 0.20593563f, -0.07558640f, -0.05783602f, 0.08837328f, -0.00647717f, 
    -0.09448466f, 0.40875468f, -0.13006568f, 0.06378149f, 0.00258226f, -0.03050842f, -0.09415419f, 0.02758157f, 
    -0.23965152f, -0.02984806f, 0.01165986f, 0.25873652f, -0.35669136f, -0.04514557f, 0.06367910f, 0.22332627f, 
    0.24452071f, 0.12383774f, 0.21188562f, -0.07759625f, -0.09553105f, -0.01949647f, 0.12084650f, -0.03249636f, 
    -0.04073700f, 0.04081414f, 0.11976282f, -0.09310249f, -0.00801577f, -0.00559586f, -0.05474946f, -0.09103885f, 
    -0.09162542f, 0.01420525f, -0.13986932f, 0.03617837f, -0.21893014f, 0.04721753f, -0.04944897f, 0.00717665f, 
    0.00405103f, -0.35841635f, 0.12446585f, -0.12552561f, 0.07361475f, 0.10791198f, 0.07494781f, 0.11171072f, 
    -0.11656126f, 0.02364573f, -0.04468652f, -0.04327780f, 0.16678938f, 0.00134356f, 0.06795181f, -0.00502533f, 
    -0.10478278f, -0.13441037f, 0.02496231f, -0.14010966f, -0.02137371f, -0.11673885f, 0.11085346f, 0.05220117f, 
    -0.03052337f, -0.21378802f, -0.11139754f, -0.09544544f, -0.01317043f, 0.06794170f, -0.09520222f, 0.01830460f, 
    0.00958074f, 0.00330164f, -0.00819117f, -0.09375241f, 0.04733589f, -0.01001518f, 0.10524531f, -0.06322596f, 
    0.21963634f, -0.19584709f, -0.02326822f, -0.10475865f, -0.02135500f, -0.03113762f, 0.14133838f, -0.06586705f, 
    -0.00831242f, -0.08121139f, -0.05545209f, 0.05869380f, 0.21736328f, -0.04407009f, 0.06011096f, -0.02246032f, 
    -0.01094426f, 0.04381854f, 0.00171339f, -0.02873192f, 0.15737759f, 0.15675598f, -0.04540662f, 0.06318853f, 
    0.23153982f, 0.01388144f, 0.00104913f, -0.11447024f, -0.23440148f, -0.04334456f, 0.03845423f, 0.12004586f, 
    -0.09104193f, -0.04737574f, 0.16738945f, 0.04563876f, -0.38714543f, -0.13685861f, 0.21360952f, -0.03477908f, 
    -0.03827492f, -0.10194130f, -0.28736982f, 0.24536882f, -0.05011950f, 0.17397086f, 0.08631624f, 0.12079890f, 
    0.08005361f, -0.01972060f, 0.07551947f, -0.04785053f, 0.01944202f, 0.06653285f, 0.06734259f, -0.09875380f, 
    0.19578843f, -0.00092131f, -0.00183741f, 0.08689106f, 0.06901753f, -0.02797353f, -0.06169866f, -0.06274816f, 
    0.14094035f, -0.07097502f, -0.13849057f, -0.02783776f, -0.39717364f, -0.07275309f, 0.11201282f, -0.01931849f, 
    -0.00912019f, -0.02416785f, -0.11169280f, 0.17281139f, -0.09744002f, 0.09867229f, 0.00556449f, -0.04297013f, 
    -0.12024168f, 0.00945059f, 0.01232379f, -0.07493843f, -0.17612322f, 0.30884403f, 0.00082549f, 0.04453014f, 
    0.24668713f, 0.22715826f, -0.08523084f, 0.54853189f, -0.04242496f, -0.02130050f, -0.13681307f, 0.00726435f, 
    -0.02034183f, -0.07413321f, -0.07283849f, -0.05753957f, -0.16964185f, -0.32131156f, -0.00186792f, -0.07179897f, 
    -0.30034202f, -0.06118543f, 0.06452353f, 0.13424899f, 0.08031078f, 0.12357665f, 0.07890108f, -0.04870380f, 
    -0.06069987f, 0.09835627f, 0.06662522f, 0.06997745f, 0.09733231f, -0.07335498f, 0.03799196f, 0.05766236f, 
    -0.00671534f, -0.00124229f, -0.06244701f, 0.06703047f, -0.09512512f, 0.04911789f, 0.07629175f, 0.45396310f, 
    -0.03000518f, 0.15207946f, 0.23666312f, 0.05187375f, -0.07310769f, 0.07454544f, -0.04471423f, 0.08889359f, 
    -0.08434806f, 0.12610345f, -0.10420370f, 0.06186714f, -0.10201319f, -0.06531365f, 0.02118018f, 0.05880525f, 
    0.37233314f, -0.20706584f, -0.23304403f, -0.07490329f, 0.04335956f, -0.18642238f, 0.10849700f, -0.23899658f, 
    -0.31017449f, 0.11713521f, 0.18152057f, 0.11601575f, -0.02779934f, -0.06901987f, 0.11752903f, -0.02083128f, 
    0.15973240f, -0.08371641f, 0.23767613f, -0.05503040f, 0.11063400f, -0.08847709f, -0.35808676f, 0.04435863f, 
    -0.09734336f, 0.15792364f, 0.17889258f, -0.28726134f, 0.06676787f, -0.16415650f, 0.09390188f, -0.12112731f, 
    0.02516770f, -0.06425311f, -0.11074542f, 0.16099453f, 0.04455643f, -0.03192264f, 0.18399733f, -0.09066522f, 
    0.01974921f, 0.06359546f, 0.07678793f, 0.11008798f, -0.22648013f, -0.10500745f, 0.03613902f, 0.19897501f, 
    -0.08211911f, -0.03446377f, 0.08051518f, -0.01890604f, 0.21023658f, 0.04648567f, -0.05344790f, -0.05734083f, 
    0.03545521f, 0.08158046f, -0.06027441f, -0.00930477f, 0.27259213f, -0.05831350f, -0.11919543f, 0.05182111f, 
    -0.05316887f, 0.12102069f, 0.31554705f, 0.10316326f, -0.11316747f, -0.03784190f, 0.04625610f, 0.00153260f, 
    -0.01206421f, 0.10301279f, 0.02312319f, 0.11642340f, 0.04603369f, -0.03858987f, -0.47614247f, -0.11605042f, 
    -0.24872652f, -0.05288761f, 0.21766677f, -0.09064940f, -0.09493832f, -0.36145106f, 0.35573560f, 0.05233105f, 
    -0.03863575f, -0.25391582f, 0.07597355f, -0.19480123f, 0.05237892f, 0.05825514f, 0.01010366f, 0.02080031f, 
    -0.02803707f, 0.03938313f, 0.12275448f, 0.01403499f, 0.07254809f, 0.02114765f, 0.06737902f, -0.12247312f, 
    -0.08537614f, -0.00008045f, 0.05893631f, -0.00063147f, 0.08956538f, -0.05372432f, -0.07430503f, 0.14135656f, 
    -0.12744525f, 0.18393880f, 0.13233075f, -0.03928404f, -0.01145545f, 0.05241521f, 0.27031806f, 0.00670227f, 
    -0.05579751f, 0.07553325f, -0.10168841f, 0.07036231f, -0.00385491f, 0.11069112f, -0.09286842f, 0.04569679f, 
    0.03817544f, 0.33581573f, -0.28086910f, 0.11229759f, 0.16828786f, 0.36770493f, -0.07701124f, -0.02292010f, 
    0.02905226f, 0.22389789f, -0.06794065f, -0.19601656f, -0.32475221f, 0.05634707f, 0.03829523f, 0.12007023f, 
    -0.13038194f, -0.10239824f, 0.02597813f, 0.07960011f, -0.18127608f, 0.03003226f, 0.09904635f, 0.07020930f, 
    0.07409494f, 0.12200896f, -0.16713654f, -0.00369426f, -0.01879892f, 0.08538257f, -0.06075222f, -0.01476280f, 
    -0.03848552f, -0.04329949f, 0.05199623f, -0.06936389f, -0.12179656f, -0.02102220f, -0.00823597f, 0.10867883f, 
    0.01420065f, 0.05573229f, -0.12451012f, 0.08395555f, 0.27139452f, -0.05532494f, 0.04626809f, -0.30779248f, 
    0.00062320f, 0.22448432f, -0.33650082f, -0.04772476f, -0.01613954f, 0.08679967f, -0.00599663f, 0.11643331f, 
    0.05041081f, 0.04234181f, -0.04707511f, -0.05234460f, 0.04146719f, 0.08819288f, -0.04876110f, -0.11144263f, 
    -0.15201586f, -0.06347550f, -0.04022214f, 0.07981817f, -0.17445146f, -0.15033594f, 0.01976791f, 0.09270775f, 
    -0.06978766f, -0.09244110f, -0.24514608f, -0.01010598f, 0.10800910f, 0.02219872f, -0.00964549f, 0.01264423f, 
    -0.05958215f, 0.08727090f, 0.14039665f, 0.06079718f, -0.09023952f, -0.03087170f, -0.01445001f, -0.12414982f, 
    0.10565167f, -0.03633713f, 0.05560394f, -0.10757739f, 0.00007017f, -0.10334402f, 0.00013384f, 0.11745980f, 
    -0.09103914f, 0.04512254f, -0.05802532f, -0.23477393f, 0.11771032f, -0.10890523f, -0.05290956f, -0.01038365f, 
    0.10154341f, -0.03046359f, -0.05160487f, -0.08350760f, -0.17448674f, -0.08062637f, -0.02336815f, -0.00664445f, 
    0.05191192f, -0.03670881f, -0.20286582f, 0.07439397f, 0.02421246f, 0.07587861f, -0.03338140f, -0.10522196f, 
    -0.10781373f, 0.12105055f, -0.03676681f, -0.19568148f, 0.10901245f, -0.07736947f, 0.01756665f, 0.08366378f, 
    -0.32102078f, 0.05736506f, -0.15243322f, -0.02695408f, 0.06805957f, -0.08961034f, 0.11454874f, -0.07914099f, 
    -0.11306982f, -0.15354039f, -0.13091505f, 0.21892048f, -0.07312940f, -0.03368137f, 0.21044019f, -0.02572424f, 
    -0.12343063f, 0.00193059f, -0.13842402f, -0.08002391f, 0.11015286f, -0.02259455f, -0.02861037f, 0.06155347f, 
    -0.09943373f, 0.17173845f, -0.27348447f, -0.21634848f, -0.01482078f, -0.13092986f, 0.08006330f, -0.07104383f, 
    -0.00624003f, 0.01976023f, 0.06049654f, -0.16735359f, -0.09174226f, -0.11279261f, -0.02658216f, -0.05618605f, 
    -0.28453788f, 0.07267231f, 0.11784086f, -0.14561009f, 0.16134170f, -0.04756738f, 0.06789669f, 0.23270786f, 
    0.00256344f, 0.26520687f, 0.14126527f, -0.01249529f, 0.08299707f, 0.04726987f, 0.17742285f, -0.10127120f, 
    -0.04216458f, 0.02436371f, 0.01037120f, 0.04891536f, 0.04003045f, 0.01148873f, 0.10437696f, 0.07785640f, 
    0.01334590f, -0.00039159f, -0.20924765f, -0.04681590f, 0.12207266f, 0.16758290f, -0.04835611f, -0.17855103f, 
    -0.08709831f, -0.11868194f, 0.14357351f, -0.03880029f, -0.09811156f, -0.12282651f, 0.06522600f, 0.06281238f, 
    0.04970231f, -0.09931339f, 0.11709788f, -0.10863105f, -0.11018021f, -0.33378035f, 0.42673534f, -0.03779806f, 
    0.02104009f, 0.09677807f, -0.01645176f, -0.20062539f, -0.06608103f, -0.01336248f, 0.09269711f, 0.04571157f, 
    0.03938403f, 0.21204150f, 0.09122674f, -0.21513532f, -0.10078485f, -0.03775714f, -0.05551401f, -0.06491505f, 
    -0.08228925f, -0.06990536f, 0.12418442f, 0.28234705f, -0.15331836f, 0.06988320f, 0.03476706f, -0.21840346f, 
    -0.00781611f, 0.25149518f, 0.03839209f, -0.09865206f, -0.13454060f, -0.05028075f, 0.01365116f, -0.08815590f, 
    -0.00428441f, -0.09531731f, 0.03919594f, 0.10580611f, -0.14902242f, 0.02902339f, 0.01022041f, 0.02650443f, 
    -0.06082601f, 0.13005869f, -0.26471063f, -0.07088432f, 0.22769992f, 0.03971992f, -0.03624201f, -0.00035169f, 
    -0.05192882f, -0.07867127f, -0.32201692f, 0.08030491f, -0.00466354f, -0.04112895f, 0.08403032f, 0.04817784f, 
    0.12921147f, 0.08369251f, 0.19236293f, 0.03429395f, -0.09150098f, -0.23960881f, 0.47925982f, 0.01401632f, 
    -0.01451517f, -0.09200642f, 0.15333281f, 0.29311332f, 0.17724101f, -0.02765190f, 0.06992827f, 0.10659404f, 
    -0.12156282f, -0.19811265f, 0.07199056f, -0.32624024f, 0.11918084f, -0.00900033f, 0.20069496f, 0.11100456f, 
    0.01546527f, 0.02706079f, -0.05083907f, 0.14606319f, 0.04879715f, -0.05609335f, 0.04380183f, -0.25484729f, 
    0.03523539f, 0.16909136f, -0.25028136f, -0.09985147f, 0.02579247f, 0.01909462f, -0.23297872f, 0.08281709f, 
    -0.03736339f, -0.04949226f, -0.12022089f, 0.11196580f, 0.28983331f, 0.08711328f, 0.07697257f, 0.11108651f, 
    -0.01157682f, 0.32189220f, -0.04996955f, -0.07003962f, -0.26933229f, 0.26349056f, -0.09284578f, 0.15357871f, 
    0.21897078f, -0.02627302f, 0.00611567f, 0.07250882f, -0.32107037f, 0.12674984f, 0.13440917f, 0.08688544f, 
    -0.01118403f, -0.10820290f, 0.03938124f, 0.06633625f, -0.12983398f, 0.16856344f, 0.25633368f, -0.07655695f, 
    -0.17719716f, -0.00942797f, -0.35190344f, 0.09770886f, -0.09404039f, 0.04646131f, -0.07847015f, -0.07660924f, 
    -0.06249165f, -0.00747464f, 0.08387695f, 0.06696113f, -0.12308580f, 0.09064576f, -0.22540234f, 0.03111535f, 
    -0.05744246f, 0.02152411f, 0.03762705f, -0.12726335f, 0.20608829f, 0.11833752f, -0.07104217f, -0.06567145f, 
    0.00395824f, 0.07977293f, -0.14696436f, 0.03134979f, -0.07765084f, 0.00300231f, 0.04757908f, 0.08738805f, 
    -0.06488396f, -0.02649629f, -0.08404260f, -0.02496687f, -0.29717204f, -0.10776544f, 0.07861925f, -0.10649581f, 
    0.32354277f, -0.20875369f, 0.20044297f, 0.07034291f, -0.26448214f, -0.01908460f, 0.07583292f, 0.18323028f, 
    0.01015211f, 0.19547178f, -0.06513254f, 0.20128603f, 0.16287203f, 0.15001160f, -0.00163482f, 0.08228298f, 
    0.27395076f, -0.08157907f, 0.17718704f, 0.02650636f, 0.00864201f, 0.22007853f, 0.06709849f, 0.07043321f, 
    0.32754698f, -0.04527841f, -0.15148754f, 0.00947255f, -0.02999019f, -0.02785740f, -0.12595946f, 0.03856453f, 
    -0.02575369f, 0.22658359f, 0.05037029f, 0.04131586f, 0.05349947f, 0.08845525f, -0.01766735f, -0.01072451f, 
    -0.14102070f, 0.04376996f, -0.06448828f, 0.04223447f, -0.02279191f, -0.05052454f, 0.05899576f, -0.21357282f, 
    0.42236456f, -0.23028713f, 0.17349435f, 0.01361370f, -0.06387152f, -0.10361214f, 0.27525648f, 0.05108282f, 
    0.07346745f, -0.07929473f, 0.09864523f, -0.24688061f, -0.19044976f, 0.03131807f, 0.08423232f, -0.03203145f, 
    0.10876078f, -0.00236711f, -0.04896571f, 0.03029345f, 0.24804071f, 0.25921428f, -0.06633208f, 0.07291459f, 
    -0.14256452f, 0.06602941f, 0.13613069f, -0.40743977f, -0.10648493f, 0.01938993f, 0.07188808f, -0.04927157f, 
    0.32583499f, -0.08830092f, -0.07472488f, 0.08919539f, 0.17100435f, 0.23644570f, -0.03219558f, -0.06114104f, 
    0.22689021f, 0.43966049f, 0.14133072f, 0.03418751f, 0.08222169f, -0.06080947f, 0.09478245f, -0.00300579f, 
    -0.08550608f, 0.14215976f, -0.04646422f, -0.02673215f, -0.02575496f, 0.01406143f, -0.02386030f, -0.09087049f, 
    -0.11313979f, 0.11553027f, 0.06805462f, -0.08053147f, 0.18028678f, -0.06579035f, 0.06328449f, -0.09431023f, 
    0.08045001f, 0.25024962f, -0.17145050f, -0.12309614f, 0.07966956f, -0.06837790f, -0.12283356f, 0.10037710f, 
    0.08515188f, 0.11443369f, 0.00402784f, -0.01802077f, 0.03926396f, -0.00788486f, 0.12084648f, -0.01307942f, 
    0.05828587f, -0.02208460f, -0.05750089f, -0.08865039f, -0.05991368f, 0.20242169f, 0.04992200f, -0.04098895f, 
    -0.09091000f, -0.17727132f, -0.03251312f, -0.15082492f, 0.05432708f, -0.15801512f, 0.17245468f, -0.04392931f, 
    0.01720674f, -0.10797593f, -0.12037260f, 0.02619064f, 0.00002780f, -0.04010075f, 0.12673455f, 0.00393827f, 
    0.06643591f, 0.03329407f, 0.09228508f, 0.02420893f, -0.01551971f, -0.02291157f, 0.04154746f, -0.07140374f, 
    0.10341349f, -0.27651644f, 0.07262190f, -0.07764091f, -0.03618570f, -0.06168044f, -0.03626749f, -0.00097342f, 
    -0.09216331f, -0.10971768f, 0.10969454f, -0.04428604f, -0.25131607f, -0.00382932f, 0.05838174f, 0.01615827f, 
    0.24378870f, -0.05337318f, -0.11675068f, 0.09427473f, -0.21954097f, -0.04244506f, -0.07844459f, -0.05273235f, 
    -0.07995711f, 0.06783411f, -0.01794583f, -0.03828050f, -0.10541625f, 0.09875096f, -0.01776679f, -0.01616606f, 
    -0.03579865f, -0.07402858f, 0.06251306f, 0.09551622f, -0.09286579f, -0.10242776f, 0.01289192f, -0.06945571f, 
    0.10426978f, 0.12289776f, -0.07737054f, -0.06002402f, -0.20224731f, -0.05560961f, 0.00945540f, 0.05613905f, 
    -0.10517668f, 0.11915302f, -0.20643906f, -0.11929438f, 0.00378376f, -0.02331957f, -0.07518886f, 0.11756293f, 
    0.00769904f, -0.01595932f, -0.10917521f, -0.07652372f, -0.03677515f, 0.06544675f, 0.02804899f, -0.07370761f, 
    0.07892942f, -0.11245336f, 0.02788535f, -0.12559080f, -0.09794041f, 0.02963623f, 0.11069627f, -0.01532236f, 
    0.15908717f, -0.04601043f, -0.01306404f, 0.04809142f, 0.09352919f, -0.09035055f, -0.01819354f, 0.00456003f, 
    -0.04154092f, -0.12152122f, 0.05383085f, 0.01402074f, 0.13334124f, -0.08486348f, -0.05619280f, 0.08407682f, 
    -0.00532051f, 0.06347702f, 0.10215151f, 0.08663900f, -0.16575445f, 0.06197781f, 0.09034981f, 0.20494682f, 
    0.10604519f, -0.13947465f, 0.00270167f, 0.08089752f, -0.26092002f, 0.08278270f, 0.08586664f, 0.01818162f, 
    -0.01840826f, -0.01948500f, -0.17067418f, 0.32020977f, 0.12144237f, 0.25727245f, 0.24008164f, 0.03995602f, 
    0.11353447f, 0.10257548f, -0.09234279f, 0.01446323f, 0.16896550f, 0.32119814f, 0.25283951f, -0.07421938f, 
    0.31964293f, 0.22141956f, -0.09391499f, 0.04530597f, 0.07240489f, -0.03137581f, 0.10471360f, 0.07599781f, 
    0.01905455f, 0.17886382f, 0.06219324f, 0.12850688f, -0.03173240f, -0.08465498f, -0.11767816f, -0.00754665f, 
    -0.25322741f, -0.10410393f, 0.12320629f, -0.07331937f, -0.06167068f, -0.02994820f, 0.07512324f, -0.20804207f, 
    0.01156900f, -0.21645850f, 0.28849566f, -0.12075417f, 0.33727419f, 0.03508918f, -0.04640687f, 0.10099868f, 
    0.00636039f, -0.08627737f, 0.05488223f, 0.07176197f, 0.39402601f, -0.03200106f, -0.04602087f, 0.31031317f, 
    0.02595507f, 0.04868249f, 0.16029547f, -0.05927685f, -0.32679144f, -0.29639077f, 0.00316340f, 0.20429076f, 
    0.16527329f, -0.03431022f, 0.03670928f, 0.34133628f, -0.36617550f, -0.08336689f, -0.22944742f, 0.00976612f, 
    -0.06613731f, 0.11133146f, 0.02771785f, 0.08796834f, 0.13018514f, 0.01315332f, -0.18676959f, 0.06086798f, 
    -0.10075141f, -0.08194077f, 0.22613977f, -0.04400225f, 0.02482517f, 0.04048365f, 0.09561586f, -0.02078127f, 
    0.12291460f, 0.02260419f, 0.00798368f, 0.09498709f, 0.11029675f, 0.01448152f, 0.24556969f, 0.10841156f, 
    -0.11745448f, 0.07472038f, -0.07911075f, 0.09029495f, -0.13657384f, -0.02507305f, -0.00578165f, 0.38713989f, 
    -0.20782192f, 0.20764053f, 0.00971836f, 0.02094111f, 0.10447976f, -0.06786732f, 0.17146219f, 0.07361275f, 
    -0.10264400f, -0.02691765f, 0.11556362f, 0.05687133f, 0.25589409f, -0.05011041f, 0.00503276f, 0.24358624f, 
    0.09643066f, -0.07099953f, -0.00466853f, 0.06579781f, -0.21231787f, 0.05028575f, -0.07901064f, 0.18120873f, 
    -0.13895962f, 0.03198141f, -0.01892340f, 0.04450930f, 0.02595853f, 0.11890165f, -0.16928524f, -0.07511804f, 
    -0.04596117f, 0.08544701f, 0.01484178f, 0.12895964f, 0.29127920f, 0.09181185f, -0.07593869f, 0.12040593f, 
    0.16669255f, -0.17131457f, 0.16891393f, -0.25971496f, -0.01475082f, -0.01672025f, 0.06635517f, 0.00556209f, 
    0.09207702f, 0.05077891f, 0.11009246f, 0.13017082f, 0.12990981f, 0.00345611f, 0.21275659f, -0.01769372f, 
    -0.10988136f, 0.00364518f, 0.03107824f, -0.09069294f, 0.22365578f, 0.03616474f, 0.00757752f, 0.16354585f, 
    -0.35214144f, 0.05788823f, 0.01455589f, 0.01697559f, 0.45987126f, 0.10034914f, 0.12239092f, -0.00246552f, 
    0.04797538f, 0.06172976f, 0.04978807f, -0.01742247f, 0.01837302f, -0.09703045f, 0.11811948f, -0.00230157f, 
    -0.12826079f, 0.02522472f, 0.34155190f, 0.01491501f, -0.07772588f, -0.30149201f, -0.05074636f, 0.09982621f, 
    0.19747712f, 0.10074141f, -0.13779609f, 0.20443253f, 0.31175330f, -0.00611354f, -0.27143013f, 0.02542203f, 
    0.01637876f, -0.07027785f, -0.17183605f, 0.09740433f, 0.01816116f, 0.22678684f, 0.13628210f, 0.02631305f, 
    -0.07175934f, -0.21413563f, -0.02210012f, 0.10747856f, 0.11139041f, 0.11853933f, -0.02996949f, -0.06090290f, 
    -0.10550794f, -0.00944752f, -0.05251241f, 0.06996132f, 0.03521318f, 0.04124523f, -0.08451111f, -0.03622876f, 
    0.30099928f, 0.03156911f, -0.01175708f, -0.12059129f, 0.06423095f, 0.07288493f, -0.08281813f, 0.28919250f, 
    0.02178969f, -0.20659883f, 0.15819120f, -0.09900488f, -0.08235075f, 0.10991678f, 0.01829180f, -0.09389741f, 
    -0.05963618f, 0.09465630f, 0.05263506f, -0.06834636f, 0.05791930f, 0.05973294f, -0.05589344f, -0.05879067f, 
    -0.00701769f, 0.07840209f, -0.11435531f, 0.10456817f, 0.12591608f, -0.07230318f, -0.07699558f, -0.10540887f, 
    -0.07365695f, -0.09102396f, 0.05770744f, -0.03306467f, -0.11725231f, 0.04818377f, 0.00813815f, -0.00213102f, 
    -0.07355732f, 0.08747025f, -0.07968912f, 0.04788017f, -0.12712982f, 0.05363313f, -0.05683189f, -0.10063444f, 
    0.11854108f, -0.05905474f, -0.09742697f, -0.05383104f, 0.09634915f, -0.01786990f, -0.04754919f, 0.11708626f, 
    -0.11769377f, -0.01903541f, 0.02241541f, -0.04103603f, 0.07766889f, 0.00053290f, 0.00550348f, -0.01870629f, 
    0.01281805f, 0.02323471f, -0.02277957f, -0.03771276f, -0.01799828f, -0.09871718f, 0.03958192f, -0.03539164f, 
    0.10541247f, -0.10834642f, -0.14964738f, -0.05920167f, -0.11697969f, -0.04016481f, -0.07002353f, 0.12438245f, 
    -0.10812581f, -0.02567768f, 0.03454321f, 0.26760149f, -0.05590464f, -0.01652466f, 0.10100283f, 0.14452666f, 
    -0.06515948f, 0.07746760f, -0.05873976f, 0.01387993f, 0.16489559f, 0.18113127f, 0.06785613f, 0.11499998f, 
    0.00859825f, 0.15941840f, -0.10420570f, -0.05850441f, -0.09050602f, 0.19243205f, 0.09824736f, -0.04927725f, 
    -0.05051190f, -0.06229524f, 0.19149588f, 0.10132147f, -0.26363504f, -0.14996716f, -0.14698493f, -0.09227756f, 
    -0.01615007f, -0.14746317f, 0.11253841f, 0.12475083f, -0.10340232f, 0.08746964f, -0.06501018f, -0.06255642f, 
    0.05454393f, 0.13844053f, 0.07653937f, -0.02577315f, -0.07604606f, -0.01681097f, 0.23326650f, -0.09342549f, 
    0.24339874f, -0.10347217f, -0.08562158f, 0.23514864f, 0.00257043f, -0.10433833f, 0.00445810f, -0.26917845f, 
    -0.05603898f, 0.03647186f, 0.06054307f, -0.02759721f, 0.12892720f, -0.09972759f, -0.10430794f, -0.07058286f, 
    0.10343137f, -0.12425812f, 0.10566095f, 0.08936008f, 0.05839432f, 0.00821363f, -0.11064981f, 0.01766354f, 
    0.07231702f, 0.21565686f, -0.37600672f, -0.08489153f, -0.08816919f, 0.32766181f, 0.01786979f, 0.08607220f, 
    -0.07350322f, 0.06005245f, -0.02119850f, -0.24442007f, 0.26370868f, -0.13452916f, 0.21484303f, -0.00832190f, 
    -0.02766749f, -0.07711869f, 0.02569216f, -0.05678427f, 0.00976171f, -0.32785922f, 0.19845569f, 0.11834580f, 
    -0.22423431f, -0.11148061f, -0.43179160f, 0.20917872f, -0.06787196f, 0.00000082f, 0.00181289f, 0.05866641f, 
    -0.02893276f, 0.04255930f, -0.08909138f, -0.31021464f, -0.06867839f, -0.08035703f, -0.10075136f, 0.03700493f, 
    -0.04394780f, -0.08343644f, -0.06044038f, 0.10076410f, 0.12062635f, 0.09788615f, 0.07517629f, -0.06877186f, 
    0.05952201f, -0.06841718f, -0.22530563f, -0.12023546f, 0.00714972f, -0.06222474f, 0.00106142f, -0.04646675f, 
    -0.11703543f, -0.00617679f, -0.12486300f, 0.07404009f, 0.34666944f, 0.09939843f, -0.00275210f, 0.39181116f, 
    0.02077194f, 0.26070210f, -0.10492201f, 0.04730855f, -0.09817977f, 0.04289963f, -0.00826539f, -0.13507465f, 
    0.10163622f, 0.08043185f, 0.23737849f, -0.14123583f, -0.14954323f, -0.01787045f, 0.43972284f, -0.03627573f, 
    -0.17081793f, 0.02473754f, 0.14485897f, 0.06464456f, 0.02968301f, 0.13178740f, -0.08973938f, -0.12967105f, 
    -0.01571816f, 0.14383848f, -0.19366767f, 0.05745099f, 0.02209738f, 0.29651406f, 0.04833332f, 0.10852113f, 
    -0.09096351f, -0.18383445f, -0.02807143f, 0.17928763f, 0.10503893f, 0.10955524f, -0.06385381f, 0.09664835f, 
    -0.07006210f, -0.02997914f, 0.05563891f, 0.16336091f, -0.06715748f, -0.02466360f, 0.11683138f, -0.12147700f, 
    -0.24952039f, -0.10469094f, -0.12101343f, -0.00243439f, -0.03997397f, -0.01808259f, -0.18746458f, -0.00082491f, 
    -0.07167463f, -0.00480351f, 0.08236850f, 0.07223523f, -0.27047479f, -0.02519772f, -0.03364794f, 0.11253879f, 
    0.21354470f, -0.00862197f, -0.12864238f, -0.06162103f, -0.14994916f, -0.22921313f, 0.08688063f, -0.07607131f, 
    -0.37732375f, 0.04892521f, -0.18314393f, 0.45579362f, -0.17941670f, 0.09862639f, 0.31919715f, -0.00669768f, 
    0.02814801f, -0.09218563f, 0.23974922f, -0.03078337f, -0.04500537f, 0.02579195f, -0.08265514f, -0.00883689f, 
    -0.11400268f, 0.13548079f, 0.15779424f, 0.23247688f, -0.05686152f, -0.04831513f, -0.10528755f, 0.05053023f, 
    -0.05704737f, 0.01159897f, -0.04587210f, -0.03771766f, -0.10730942f, 0.10254188f, 0.11790074f, 0.08346344f, 
    -0.10101116f, -0.06420267f, -0.00695236f, 0.16448191f, -0.38745904f, -0.03921678f, -0.11059927f, -0.10862164f, 
    -0.22430597f, -0.11376824f, 0.28562495f, -0.11439566f, 0.05198729f, 0.03013011f, -0.19846496f, 0.09904659f, 
    0.03320216f, 0.01671769f, -0.07536470f, 0.23308170f, 0.33977807f, 0.03986320f, 0.06460320f, 0.29868290f, 
    0.41023174f, 0.03858244f, -0.03788634f, 0.00704389f, -0.17680234f, -0.00733118f, 0.00911252f, 0.03489280f, 
    -0.02706308f, 0.05890598f, 0.36205503f, -0.04693042f, -0.06155126f, -0.22725458f, -0.08053528f, 0.00824962f, 
    -0.15862821f, 0.04595478f, 0.31739491f, -0.09052321f, -0.13276461f, -0.12813558f, 0.08439150f, 0.09330650f, 
    -0.04567769f, 0.13765824f, 0.10297789f, -0.18203332f, 0.05593399f, 0.09575333f, 0.02566458f, -0.08694506f, 
    -0.10276674f, 0.15088171f, -0.07053808f, -0.03438094f, 0.01265612f, -0.00172609f, 0.36569631f, -0.03803568f, 
    -0.03538633f, 0.03327848f, -0.06557144f, 0.27608570f, -0.10167097f, -0.05992171f, -0.06700797f, -0.06559477f, 
    -0.08518931f, 0.02851524f, 0.10270339f, -0.10114110f, -0.00406277f, -0.06457742f, 0.13751185f, -0.09261550f, 
    -0.01953266f, 0.05933569f, 0.07863986f, -0.00001119f, 0.12581062f, 0.09974900f, 0.08106111f, 0.04499810f, 
    0.01574353f, -0.04073060f, -0.16690086f, 0.05277784f, 0.04225187f, 0.18765825f, -0.01176996f, -0.12781800f, 
    -0.09252345f, -0.11107638f, -0.01789071f, 0.21042962f, 0.14856751f, -0.41307202f, -0.18087874f, 0.01683540f, 
    0.05494194f, -0.01821081f, -0.03757865f, 0.03600653f, -0.00819886f, -0.59996247f, 0.40440467f, 0.01479868f, 
    -0.26899186f, 0.04407387f, 0.31887925f, -0.28672060f, 0.00558452f, -0.12145863f, 0.03232442f, -0.07532353f, 
    -0.13179517f, 0.11585815f, -0.11965489f, 0.08497813f, -0.11549685f, -0.09445870f, 0.22899705f, 0.07977539f, 
    0.06180540f, -0.05683842f, 0.04011591f, 0.18798700f, 0.03703938f, -0.11469693f, 0.03039498f, 0.14006115f, 
    -0.15689807f, 0.12031036f, 0.24306045f, 0.01521103f, 0.19604342f, 0.01759837f, 0.13781570f, -0.01745504f, 
    -0.10700659f, 0.03708385f, -0.09019220f, 0.04060629f, -0.15076676f, 0.03807575f, 0.11438914f, -0.09264123f, 
    -0.11160088f, -0.02157838f, -0.09772632f, 0.00649047f, -0.08999529f, 0.02419596f, -0.01094392f, -0.14728758f, 
    -0.14326890f, -0.04208031f, -0.09178986f, 0.06017085f, 0.06075015f, -0.01890442f, 0.04204575f, 0.08463816f, 
    0.08393865f, -0.03895306f, 0.00405708f, -0.06057718f, -0.12244124f, -0.00749047f, -0.14007209f, 0.09590657f, 
    0.05061851f, 0.03163344f, -0.01713666f, -0.12060146f, -0.10068814f, -0.00501878f, -0.06775242f, 0.10158839f, 
    -0.00175408f, 0.05443938f, -0.11709638f, -0.01323766f, 0.08279042f, -0.00370980f, -0.05712708f, 0.04779141f, 
    -0.10062055f, -0.08359601f, -0.01660402f, -0.00138696f, 0.11637612f, 0.06256160f, -0.03694423f, -0.02362261f, 
    0.00380609f, -0.11813693f, -0.02453254f, -0.08382445f, -0.02984818f, 0.11003016f, -0.04181967f, -0.08051546f, 
    -0.04599765f, 0.09392687f, 0.08053394f, -0.06341266f, -0.19592351f, 0.11597316f, -0.07443528f, -0.10271306f, 
    -0.30370045f, -0.43224198f, 0.33846751f, -0.09162496f, 0.15897685f, 0.06937315f, 0.09704842f, -0.14381555f, 
    0.06821427f, 0.15665561f, 0.00530669f, -0.09046131f, 0.17530957f, 0.04505992f, -0.02317237f, 0.13066114f, 
    0.31436768f, 0.06001894f, -0.13897356f, -0.06691597f, -0.18142912f, 0.01362748f, 0.00529228f, 0.01032192f, 
    0.23065667f, 0.08586668f, -0.06414824f, 0.14489536f, -0.13601144f, 0.11303848f, -0.03869108f, 0.01655252f, 
    -0.00554887f, 0.20836355f, -0.00496719f, 0.20932955f, -0.03905313f, -0.02598245f, -0.07068855f, -0.03795160f, 
    0.09279728f, 0.01703981f, 0.03119254f, 0.07247658f, 0.02598235f, -0.02358875f, -0.05378678f, 0.02920876f, 
    0.09140985f, -0.01897791f, 0.22552304f, -0.09160411f, 0.05886414f, 0.08521627f, 0.10454673f, -0.10449217f, 
    0.07069623f, 0.05543915f, -0.10560537f, 0.19966632f, -0.28963348f, -0.12924464f, -0.08046140f, -0.28485286f, 
    0.09949648f, -0.11908426f, -0.06911474f, 0.03736030f, 0.04283807f, 0.34842256f, 0.09113330f, 0.04502663f, 
    0.01425285f, 0.18339130f, -0.01479441f, -0.22468628f, 0.08063550f, 0.05727161f, 0.03812575f, -0.03608203f, 
    -0.02419239f, 0.01970273f, -0.07885709f, -0.06763063f, -0.04241630f, -0.11179268f, 0.32089397f, -0.10616212f, 
    0.12918736f, -0.12565219f, 0.05895768f, 0.02866360f, -0.01417528f, 0.02886576f, 0.04442311f, -0.02500919f, 
    0.11316385f, 0.04543552f, -0.07839597f, 0.08892753f, -0.08403360f, -0.05907282f, 0.12426183f, -0.05936671f, 
    -0.01972307f, -0.02170772f, 0.11790219f, 0.02434691f, 0.20472990f, 0.03181099f, 0.00617823f, -0.62247276f, 
    0.23518816f, -0.26439527f, -0.02121212f, -0.00962992f, 0.02460675f, -0.03528707f, 0.11080454f, -0.10734057f, 
    -0.04978957f, 0.07531604f, -0.00972220f, 0.31812453f, 0.23961926f, 0.00624192f, 0.05588116f, -0.01648165f, 
    0.13562378f, -0.16367528f, 0.10387995f, 0.10857829f, -0.23729558f, -0.19388139f, -0.00968735f, -0.05292077f, 
    -0.15156561f, 0.11681828f, -0.05092143f, 0.13843676f, -0.17799659f, 0.07336536f, -0.00327135f, 0.10053977f, 
    0.03375657f, 0.09046749f, 0.03364120f, 0.02537052f, 0.09407060f, 0.07281376f, 0.00525786f, 0.07786363f, 
    0.10229060f, -0.23416018f, -0.09071458f, -0.18643476f, 0.07054446f, 0.22668459f, 0.10786150f, 0.06711070f, 
    0.06756228f, 0.04483335f, -0.02917071f, 0.27738053f, -0.05593552f, 0.04946626f, 0.23315172f, 0.06798796f, 
    0.21413967f, 0.12020493f, 0.12089300f, -0.18119824f, 0.09119844f, -0.04425775f, -0.13179916f, -0.10381318f, 
    -0.20359464f, -0.34546649f, 0.26949060f, -0.07549320f, 0.22843020f, 0.01055191f, 0.06979490f, 0.07878855f, 
    -0.04528407f, -0.06704244f, 0.04003292f, -0.12538490f, -0.10130863f, 0.08288725f, 0.07682086f, 0.11724132f, 
    0.00537328f, -0.11295533f, 0.10283037f, -0.02824783f, 0.02748870f, -0.19660984f, -0.05553894f, -0.16790383f, 
    -0.12493004f, -0.05172376f, -0.11809538f, 0.00862367f, 0.04510926f, -0.07412966f, 0.05382008f, 0.08023670f, 
    -0.06994753f, -0.06371968f, 0.02099857f, -0.08583491f, -0.13040812f, 0.01593835f, -0.09861844f, 0.04300917f, 
    -0.00770865f, -0.05137866f, -0.07032079f, 0.02281315f, 0.04863823f, 0.05947502f, 0.02158234f, 0.00214565f, 
    -0.04008568f, -0.01765451f, -0.03397718f, -0.10415068f, -0.10834277f, -0.11013721f, 0.08725303f, 0.00289357f, 
    -0.05833287f, -0.11133592f, 0.06389372f, 0.07189079f, 0.08791120f, 0.05962993f, 0.03926254f, -0.06241237f, 
    0.01230740f, -0.07037070f, 0.06493118f, 0.09412699f, -0.02171416f, 0.08041596f, -0.00380370f, -0.04204561f, 
    0.06233007f, -0.10932219f, -0.07802381f, -0.01692715f, -0.14894152f, 0.04281202f, -0.09221216f, 0.10341477f, 
    0.45782107f, -0.01110898f, 0.00620530f, -0.03666060f, -0.03372571f, -0.11312432f, 0.10956358f, -0.09865247f, 
    -0.02141078f, 0.06215741f, 0.42540500f, -0.23775320f, -0.08496304f, -0.18865314f, -0.31484637f, -0.11245912f, 
    0.25343218f, -0.01198572f, 0.23774426f, -0.12951949f, -0.04147662f, 0.04255186f, 0.09660822f, 0.07144458f, 
    0.15416141f, -0.01254508f, 0.06284454f, -0.03276490f, -0.01580203f, 0.13067828f, -0.10467108f, 0.12330061f, 
    -0.06731520f, -0.00168033f, -0.00606199f, -0.03497601f, -0.10292830f, 0.01276667f, 0.02538915f, -0.03417408f, 
    0.00596612f, 0.12641571f, -0.08829938f, 0.37195739f, -0.13968404f, 0.02427219f, 0.09731958f, 0.05197810f, 
    0.21561827f, -0.09012752f, 0.02286475f, -0.04261929f, -0.46494153f, 0.01368176f, 0.25122002f, 0.10842315f, 
    0.02874579f, 0.07159004f, -0.05063379f, -0.09647419f, -0.02876609f, 0.01153810f, 0.05183727f, -0.09621472f, 
    0.03659511f, -0.11977852f, -0.09830611f, 0.11712552f, 0.49824867f, -0.08268920f, -0.09684499f, -0.00778568f, 
    -0.02806027f, -0.06049915f, 0.07579894f, -0.01401880f, 0.08125534f, -0.21117102f, -0.13269420f, -0.09283231f, 
    -0.21434630f, 0.03655992f, 0.07549839f, -0.10510023f, 0.09920555f, -0.20663269f, -0.20788187f, -0.11152498f, 
    -0.55693477f, 0.13888079f, 0.44370222f, 0.20815533f, 0.02954998f, -0.15612760f, 0.01114541f, 0.09564752f, 
    0.10946807f, 0.29605776f, 0.03863467f, 0.09504856f, -0.02143819f, -0.00914045f, -0.03581450f, -0.07783104f, 
    0.18660299f, 0.07208773f, -0.07383822f, 0.25502497f, -0.18830222f, 0.02122524f, 0.03037741f, 0.04179939f, 
    -0.13709167f, 0.17043832f, -0.22065751f, 0.05746952f, 0.09628896f, -0.10657497f, -0.17863631f, 0.09802665f, 
    -0.06359199f, 0.05170450f, -0.00677879f, 0.06251767f, 0.25262085f, -0.08237023f, -0.05195946f, 0.23398058f, 
    0.30705759f, 0.22298031f, -0.23724630f, -0.10851355f, 0.03204650f, -0.03484548f, 0.03432180f, 0.04126048f, 
    -0.17191800f, 0.22207952f, -0.06170873f, -0.16734949f, -0.06700693f, 0.09174315f, 0.22877385f, 0.07292679f, 
    -0.09457091f, -0.09640974f, 0.09280138f, -0.03253561f, 0.16937694f, 0.16129670f, -0.32561019f, -0.07521080f, 
    0.01475633f, 0.06329290f, 0.14826411f, 0.09724052f, -0.05700307f, -0.14079598f, -0.09460229f, -0.11170850f, 
    -0.03083321f, -0.23367307f, -0.03187901f, -0.11800405f, -0.10735271f, -0.09744148f, -0.05828976f, -0.09212068f, 
    -0.05747958f, 0.05658612f, -0.03004468f, -0.06461421f, 0.20382515f, 0.01336893f, 0.06204391f, -0.06329434f, 
    -0.26257113f, -0.00636157f, -0.24446872f, -0.01839133f, 0.23587866f, -0.07102834f, -0.08519629f, -0.09233707f, 
    -0.02700382f, 0.11228576f, -0.09079514f, 0.32004240f, -0.08049754f, -0.05312462f, 0.12687182f, -0.02813174f, 
    -0.25555807f, -0.15305285f, -0.03640234f, -0.07312153f, -0.13065484f, 0.37803346f, 0.06085823f, 0.07441092f, 
    -0.00023757f, 0.16560274f, -0.25844508f, -0.06814757f, 0.10119458f, 0.31809559f, 0.23977613f, 0.04960641f, 
    -0.05485374f, 0.08382437f, -0.04219359f, -0.11095610f, -0.13702945f, -0.22385374f, 0.16705972f, -0.12183737f, 
    -0.07192980f, -0.29465336f, -0.09286091f, -0.00832001f, -0.01799626f, 0.19398043f, 0.08446652f, -0.11043347f, 
    0.07367069f, 0.02094307f, -0.00186133f, 0.09395424f, -0.00887193f, -0.11358644f, 0.16997959f, -0.04261668f, 
    0.28606692f, -0.00672342f, 0.06649959f, -0.09373569f, 0.04851367f, -0.00074990f, 0.11970021f, -0.42064929f, 
    0.01933848f, -0.33243310f, 0.01280586f, -0.02698962f, 0.21965635f, -0.11841097f, 0.01730378f, 0.01181262f, 
    -0.04001245f, -0.06312115f, 0.12780178f, -0.05797524f, 0.32927838f, -0.00821868f, -0.10816336f, -0.06214088f, 
    -0.01277789f, 0.00475967f, 0.12053533f, -0.06520988f, -0.00457210f, -0.30572668f, -0.01793133f, 0.10363527f, 
    0.07672957f, -0.17719008f, 0.27437621f, -0.01479687f, 0.23450425f, -0.15843064f, -0.06220949f, -0.06787147f, 
    -0.01693125f, 0.02394079f, 0.05885632f, 0.09669442f, 0.07896272f, 0.17833181f, -0.01960123f, -0.00361748f, 
    -0.07368482f, -0.05106491f, 0.21548894f, 0.03902756f, -0.07225012f, 0.00497939f, -0.03583075f, 0.10397980f, 
    -0.02601666f, 0.00599121f, -0.00461897f, -0.03068996f, 0.00503938f, -0.06152772f, 0.16462737f, 0.09452364f, 
    0.11926083f, -0.01163093f, -0.08671231f, 0.10485898f, -0.27139902f, 0.00594112f, 0.05916339f, 0.26120186f, 
    -0.08145063f, 0.22477883f, -0.03004752f, -0.05139834f, -0.32683042f, -0.00165888f, -0.01621788f, 0.07994518f, 
    0.11998910f, 0.07764586f, -0.13068601f, -0.06153170f, -0.11021034f, 0.09822054f, -0.04468654f, -0.01327977f, 
    0.02710774f, 0.00044707f, -0.15154055f, -0.02120033f, 0.21717355f, -0.10699002f, -0.11771601f, -0.25673452f, 
    -0.20931651f, -0.16920938f, -0.27072850f, 0.42247358f, 0.20489760f, 0.11428045f, 0.22646315f, 0.02756719f, 
    0.22104327f, -0.03501237f, 0.13886155f, -0.03314925f, -0.12863915f, -0.07903700f, 0.40681207f, 0.08411323f, 
    -0.08752819f, -0.01343953f, 0.05435497f, 0.10521067f, -0.03071006f, -0.22593215f, 0.04562972f, -0.02239948f, 
    0.01274284f, -0.08486955f, -0.11906505f, 0.00225226f, 0.06194621f, -0.02627024f, 0.06127026f, 0.09924266f, 
    0.06548449f, -0.09182699f, 0.11636870f, 0.06706790f, -0.06829266f, -0.07573633f, -0.02578657f, -0.23920368f, 
    -0.21421047f, 0.05477145f, 0.23741563f, 0.06552316f, 0.03426106f, -0.01031135f, -0.04947808f, -0.04754670f, 
    -0.06211761f, 0.05611400f, -0.01943435f, -0.31090105f, -0.10643476f, 0.09546681f, -0.12428328f, -0.16502629f, 
    -0.09340730f, -0.17010306f, -0.28670475f, -0.08231255f, 0.46278059f, -0.12465154f, -0.07298528f, -0.02425764f, 
    -0.13963987f, 0.01072476f, 0.03446919f, 0.19677164f, -0.00874142f, 0.04939398f, -0.06569749f, -0.06724399f, 
    -0.14425839f, 0.06316844f, -0.02021157f, -0.10811841f, 0.09234148f, -0.09692086f, -0.13105804f, 0.03862433f, 
    -0.09997163f, 0.03223022f, -0.07013156f, -0.15923931f, 0.07238554f, -0.05270377f, -0.08158799f, 0.01640998f, 
    0.07477586f, -0.17866042f, 0.09760061f, 0.06835582f, -0.02112445f, -0.02335934f, -0.02366915f, 0.06489535f, 
    0.16984233f, -0.11757937f, 0.04901293f, 0.17806515f, 0.21785791f, -0.09493589f, 0.05852501f, -0.15036708f, 
    -0.15991388f, 0.03484103f, -0.08407114f, -0.10491475f, -0.14494988f, 0.07874346f, -0.30462241f, 0.06077118f, 
    0.05513050f, -0.03377376f, 0.03726919f, 0.05128733f, 0.15925553f, 0.02735549f, 0.00737185f, 0.15607859f, 
    0.39589229f, 0.16133758f, -0.35360807f, 0.10333644f, -0.26682782f, 0.17299296f, 0.04039441f, -0.17210829f, 
    -0.11917950f, -0.02877862f, 0.11259059f, 0.09332467f, -0.13519366f, -0.42576224f, 0.24454950f, 0.06387622f, 
    0.15865991f, 0.00141488f, 0.34027717f, 0.06604803f, 0.17020543f, -0.17383757f, 0.16264473f, -0.02432546f, 
    -0.15322492f, 0.01984128f, 0.15170185f, -0.14375563f, 0.11220846f, -0.03927391f, 0.07348070f, -0.00254608f, 
    -0.01245611f, -0.11459329f, -0.10752559f, -0.06640367f, -0.02525580f, -0.03740720f, 0.21529390f, -0.07447376f, 
    -0.05573124f, -0.11683691f, -0.03420198f, 0.05794309f, -0.14779325f, 0.00186087f, -0.10356177f, 0.15170899f, 
    -0.22698452f, 0.20893815f, -0.13487591f, 0.03776902f, 0.15004599f, 0.04523171f, 0.08938540f, 0.00017286f, 
    0.07663675f, -0.03397720f, 0.01952614f, -0.03855401f, 0.15546435f, -0.07226896f, -0.12814198f, 0.01164879f, 
    -0.35352364f, 0.12082486f, -0.11905298f, -0.04749332f, 0.05239770f, -0.00202983f, -0.04739247f, -0.02151846f, 
    -0.06767099f, -0.15650713f, -0.33931118f, 0.23727769f, 0.09056834f, 0.30721670f, 0.39352825f, 0.07267788f, 
    0.05737123f, 0.03917523f, -0.02205723f, 0.04420350f, -0.03159834f, 0.08835193f, -0.17993721f, 0.08798541f, 
    0.07747723f, 0.16175067f, 0.06770750f, 0.27761215f, 0.11301695f, 0.06404444f, -0.04435533f, -0.05894023f, 
    -0.04520330f, -0.02520404f, -0.02544213f, 0.02713128f, -0.01163148f, -0.10095572f, 0.08280687f, 0.10078776f, 
    0.07332578f, -0.05809899f, -0.05978262f, -0.14163135f, 0.21463025f, 0.06262087f, 0.01633869f, 0.16498332f, 
    -0.31891116f, 0.14793989f, -0.11243595f, -0.08155948f, 0.16728206f, 0.07714526f, -0.30368280f, 0.11931309f, 
    -0.11487837f, -0.02829857f, -0.05632389f, -0.34653676f, -0.04837463f, 0.07627831f, -0.08227871f, -0.08548126f, 
    -0.07104989f, -0.04431832f, -0.10961483f, 0.00105153f, 0.12539004f, 0.07384162f, 0.07611923f, -0.06425122f, 
    0.09960493f, -0.19578555f, 0.09293842f, -0.10641087f, -0.02924040f, -0.13329840f, -0.00509650f, 0.09712154f, 
    -0.03629151f, 0.00930673f, -0.04646966f, -0.11570922f, -0.02128396f, -0.01117751f, -0.11173698f, 0.06875022f, 
    -0.21300310f, -0.12895428f, -0.12796552f, -0.26210934f, 0.04578091f, -0.24274895f, 0.03777395f, 0.00252150f, 
    -0.10909134f, -0.02077806f, -0.09601833f, -0.24815667f, 0.08563331f, 0.10965011f, -0.03783803f, -0.04375805f, 
    -0.14697294f, -0.06208506f, -0.10042273f, -0.21202713f, -0.06379031f, -0.03181598f, 0.00425568f, 0.05191880f, 
    0.17796728f, 0.07282138f, -0.12411845f, -0.08282545f, -0.06391495f, 0.02121897f, 0.22343166f, 0.05970977f, 
    -0.00501854f, -0.02138541f, 0.12763113f, 0.25640410f, 0.23729183f, -0.05906105f, 0.07321797f, 0.06342467f, 
    0.05787405f, -0.17728336f, -0.01658645f, 0.00206150f, -0.23438226f, 0.24936542f, -0.01177987f, -0.13912119f, 
    -0.13040991f, 0.21798967f, 0.17556927f, -0.16911800f, -0.07788119f, -0.17275654f, 0.15745039f, -0.09668507f, 
    0.08055232f, -0.02629672f, 0.11547966f, -0.01405114f, 0.22216539f, -0.20305829f, 0.15246965f, 0.10882659f, 
    0.17514631f, -0.14767261f, 0.04082026f, -0.31996310f, 0.03374677f, 0.20942137f, 0.10609295f, 0.05685513f, 
    0.08502313f, -0.13679023f, -0.01851994f, 0.21280095f, -0.11040346f, -0.00092643f, 0.27463794f, -0.03951884f, 
    0.06306344f, 0.06597777f, 0.03008904f, -0.01126417f, 0.18746434f, -0.08876555f, -0.10387524f, -0.08976784f, 
    -0.22311254f, -0.11702528f, 0.09546246f, -0.03671300f, 0.20493428f, -0.11806398f, -0.00672108f, 0.02290288f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.08170666f, 0.10835343f, -0.15564096f, -0.04246260f, 0.24553952f, -0.21100360f, -0.07844367f, 0.22027805f, 
    0.00225151f, 0.13922347f, -0.01743894f, 0.02356278f, 0.14884005f, 0.08921817f, -0.09397298f, 0.17787856f, 
    0.08130717f, -0.06605578f, 0.21627402f, 0.10310911f, -0.23475392f, -0.11682682f, 0.19030844f, 0.14844704f, 
    0.17297462f, 0.16132666f, 0.03895502f, -0.08371134f, -0.03321908f, -0.09276817f, -0.12709527f, -0.01793995f, 
    0.10629312f, -0.02172943f, -0.26151365f, -0.10850002f, -0.00406386f, -0.11075986f, 0.27823779f, 0.15100335f, 
    0.18060511f, -0.09112832f, -0.00900348f, 0.09990707f, -0.01267597f, -0.07539748f, 0.20800003f, 0.16788666f, 
    0.03287166f, -0.06097193f, 0.12214593f, 0.05192949f, -0.12709856f, 0.01535774f, 0.21932504f, -0.03153019f, 
    0.12747951f, 0.13350056f, 0.06859919f, 0.01807863f, 0.04003091f, -0.15425491f, -0.14612862f, 0.20784242f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.10230931f, 0.01591987f, -0.13943954f, 0.13748738f, -0.24471562f, 0.17340688f, -0.02345090f, -0.07998274f, 
    0.19974731f, -0.55816460f, 0.15259406f, -0.22208323f, -0.60551387f, -0.19323614f, 0.20443508f, 0.16562285f, 
    -0.02795627f, 0.16373774f, -0.34674326f, -0.25292215f, 0.18245925f, 0.15966356f, 0.10099646f, -0.24758099f, 
    0.09241448f, 0.12345217f, -0.12402921f, 0.04598121f, -0.01882672f, -0.07715649f, -0.16649207f, -0.17865561f, 
    0.09928487f, 0.14674591f, 0.15314667f, 0.02907407f, 0.02320110f, 0.15727453f, -0.03769332f, 0.03069707f, 
    0.07416543f, 0.00356360f, -0.32471788f, -0.29305980f, -0.54118150f, -0.21583900f, -0.54532278f, -0.34731814f, 
    0.06143882f, 0.12852420f, -0.04387991f, -0.27845371f, -0.02766638f, -0.05218254f, -0.43410090f, -0.01723494f, 
    -0.29563394f, -0.17671344f, -0.32094938f, -0.38298488f, -0.01291738f, 0.22388089f, 0.14421892f, -0.32879212f, 
    -0.22103176f, 0.16339514f, -0.03071922f, -0.50164306f, 0.15789054f, -0.03961692f, -0.03139736f, 0.05478154f, 
    0.21860446f, -0.20576341f, 0.22168739f, -0.49813876f, -0.32863811f, 0.17028619f, 0.16155192f, 0.21888736f, 
    -0.07830042f, 0.09702276f, 0.35643795f, 0.07186490f, -0.11952586f, -0.20489773f, 0.06570080f, -0.01345819f, 
    -0.07648008f, -0.23537531f, 0.16213422f, -0.17724183f, -0.02345331f, -0.22108532f, 0.03775404f, 0.19390702f, 
    -0.13043053f, 0.16911581f, -0.11091971f, -0.05913930f, 0.10540228f, -0.00093809f, -0.00486308f, 0.11465705f, 
    0.12673040f, -0.11241020f, 0.13475110f, 0.02355037f, -0.34102508f, -0.13057114f, -0.10403733f, 0.15316907f, 
    -0.02271676f, 0.16532746f, 0.11663665f, 0.15382925f, -0.09648906f, -0.01514765f, 0.11973112f, -0.11129212f, 
    0.15686698f, 0.09661307f, 0.16465962f, -0.13703224f, -0.00463621f, -0.06522222f, -0.21708879f, -0.01053251f, 
    0.16635194f, 0.12729007f, 0.05715987f, -0.39402193f, -0.16588868f, -0.04029015f, -0.09890624f, 0.13574247f, 
    0.02326034f, 0.26530620f, -0.37515321f, -0.28261641f, -0.19756009f, 0.10481250f, -0.14835334f, 0.07667214f, 
    0.25843933f, -0.46275717f, 0.14131033f, 0.29532847f, -0.13549751f, -0.24738990f, -0.02437278f, -0.15961850f, 
    -0.67245358f, 0.10462110f, -0.16116585f, 0.03791984f, -0.01006372f, 0.05808792f, -0.33838609f, -0.31480846f, 
    0.06937055f, 0.14768811f, -0.03393465f, 0.00089104f, 0.07751119f, 0.14716573f, -0.01827711f, 0.18245783f, 
    0.04012674f, -0.14416169f, -0.09294180f, -0.12869291f, 0.14162476f, 0.02004692f, 0.02808307f, -0.55059355f, 
    0.03358300f, -0.62447590f, 0.03748731f, 0.17580682f, 0.04811363f, 0.10920458f, -0.43300450f, 0.22763488f, 
    -0.05163609f, -0.13752651f, -0.08939327f, -0.36692181f, 0.00138109f, -0.19494221f, 0.08119076f, 0.03789711f, 
    0.14274037f, 0.00505218f, 0.06910428f, 0.15430652f, -0.24292132f, 0.20596509f, -0.37073177f, -0.28005186f, 
    0.06303273f, 0.30394667f, -0.17158058f, 0.08050784f, 0.03353814f, -0.33091944f, -0.07190786f, 0.09573440f, 
    -0.07896491f, -0.04627737f, 0.01370423f, -0.25598416f, 0.12229325f, 0.16180257f, -0.62278301f, 0.04450396f, 
    -0.12391841f, -0.02169436f, -0.25520340f, 0.06825260f, 0.02568842f, -0.45339406f, 0.28696936f, -0.36386359f, 
    0.01911936f, 0.15105207f, 0.07620920f, -0.64205778f, 0.00108004f, 0.04450237f, -0.79908794f, -0.20070268f, 
    -0.11219894f, -0.10787833f, 0.17365423f, -0.11111166f, 0.01973930f, 0.01310373f, -0.15105006f, -0.40321144f, 
    -0.05422004f, 0.18879585f, 0.23734769f, -0.08189760f, -0.14294305f, 0.20373453f, -0.20204037f, -0.13183026f, 
    0.19124895f, -0.39596307f, 0.14329714f, -0.90076590f, -0.44191739f, -0.11333354f, -0.47547439f, -0.06862354f, 
    0.01164619f, -0.09868285f, -0.01020777f, 0.13467376f, 0.05613023f, -0.11896747f, -0.21173154f, 0.25221121f, 
    -0.29161409f, 0.09888838f, -0.09449647f, -0.10768985f, 0.09902550f, -0.51016730f, -0.10532592f, -0.07097826f, 
    0.21626799f, 0.16809984f, -0.38921711f, -0.02971429f, 0.17904565f, 0.16367869f, -0.29045630f, -0.04465668f, 
    -0.11640269f, -0.36832583f, -0.18000773f, -0.39689690f, -0.17287078f, -0.20724817f, -0.11677026f, 0.10858755f, 
    0.03539706f, -0.02236260f, -0.01940284f, -0.18457231f, 0.03749955f, 0.02268004f, 0.14695682f, -0.05581158f, 
    0.18406761f, -0.15690026f, -0.39550349f, 0.08378147f, -0.02009699f, -0.12512031f, -0.15254332f, 0.07877771f, 
    -0.02858655f, 0.09563758f, -0.13641524f, -0.01989489f, -0.03910456f, 0.20574304f, 0.18925826f, -0.21202292f, 
    -0.36429328f, 0.33819783f, 0.24714962f, 0.12988493f, -0.38801101f, 0.09118045f, -0.01046462f, -0.14334655f, 
    -0.41112429f, 0.00001831f, -0.06525593f, 0.14558813f, 0.29011115f, -0.14413621f, -0.11792102f, 0.10855915f, 
    -0.02894529f, -0.42580366f, -0.22113325f, 0.09313057f, 0.04015348f, 0.26596767f, 0.16829447f, -0.02466112f, 
    -0.06358393f, 0.18357024f, -0.26631546f, 0.09716419f, 0.04238974f, 0.09551414f, 0.01717241f, -0.09024937f, 
    0.07139013f, -0.19406459f, -0.03143045f, -0.06350374f, -0.06854650f, 0.14937672f, -0.10966481f, -0.17199056f, 
    0.11165685f, -0.18201779f, -0.19835275f, -0.09449002f, 0.12004721f, 0.09871826f, 0.23748794f, 0.13845684f, 
    0.03731626f, -0.12841420f, 0.14170673f, -0.36908522f, 0.15548725f, 0.11400931f, -0.07867195f, -0.17893021f, 
    -0.02788854f, -0.05132065f, -0.21559705f, 0.02538334f, -0.03587644f, -0.51647383f, 0.01670904f, 0.01610374f, 
    0.07897482f, -0.09550764f, -0.03691443f, 0.19212708f, -0.21652997f, 0.28077772f, -0.16307949f, -0.08980200f, 
    0.23831509f, 0.05513115f, -0.16461124f, -0.22899625f, 0.00557874f, -0.18922316f, -0.13727665f, -0.10859154f, 
    -0.03536718f, 0.02530684f, -0.08641450f, 0.10550766f, 0.06233166f, -0.00403680f, 0.00195499f, -0.53433079f, 
    -0.09405570f, -0.26621601f, -0.06502109f, -0.08172560f, -0.46713880f, -0.36666870f, -0.08664852f, -0.15525313f, 
    -0.17425026f, 0.22749023f, 0.12128712f, 0.00772047f, -0.13842791f, -0.19318821f, 0.11564053f, -0.42751476f, 
    -0.21196298f, -0.78238106f, 0.10473727f, -0.08946710f, -0.02244944f, -0.59377092f, 0.21229230f, 0.28354564f, 
    -0.35071158f, -0.24674168f, 0.03668023f, -0.28582400f, 0.06922614f, -0.52625847f, 0.22895916f, 0.17823446f, 
    -0.03320615f, -0.14698483f, -0.14809288f, -0.03859593f, -0.05177075f, 0.17203857f, 0.19023144f, 0.11281174f, 
    -0.37597331f, 0.20463276f, -0.55804181f, -0.07948662f, 0.15187483f, -0.42585036f, -0.24448311f, 0.17154722f, 
    -0.10838431f, -0.23564981f, -0.08650903f, 0.30658916f, -0.02184860f, 0.07171609f, -0.17080531f, 0.07725762f, 
    -0.24065317f, 0.15419367f, -0.03694876f, 0.25610122f, 0.21234639f, 0.15219112f, -0.04615450f, 0.12034584f, 
    -0.09033767f, -0.08442613f, -0.09133615f, -0.00179639f, -0.20702317f, 0.07623261f, 0.10889570f, -0.01347185f, 
    -0.08021937f, 0.23716237f, -0.65583038f, 0.00843142f, 0.08119775f, 0.19056071f, -0.08361042f, 0.04484662f, 
    -0.41289553f, -0.43549228f, 0.08095568f, 0.00453848f, -0.07115999f, -0.17075972f, -0.19393773f, -0.22293498f, 
    -0.03447720f, 0.12821537f, 0.15721658f, -0.07613987f, 0.04311623f, 0.35562494f, -0.07809038f, -0.32000673f, 
    0.08088260f, -0.04879944f, -0.14226457f, -0.40943906f, -0.02716434f, -0.05480623f, 0.25473544f, 0.18191499f, 
    -0.29588997f, 0.05152480f, 0.01262709f, -0.00092548f, 0.06296422f, 0.12124924f, 0.23496418f, -0.27956861f, 
    0.07232480f, 0.02831987f, 0.06079042f, -0.16080132f, 0.08822577f, -0.03415026f, 0.00007872f, -0.23075065f, 
    0.18868953f, -0.31336886f, -0.28861427f, 0.45074904f, 0.07789165f, 0.19912595f, -0.22489476f, -0.46032789f, 
    -0.83055890f, -0.31772000f, -0.06620593f, -0.08365966f, -0.22638546f, -0.51613796f, -0.39309040f, 0.10281204f, 
    0.18435389f, -0.07449635f, -0.20888460f, 0.21141212f, -0.13900660f, -0.24595912f, -0.23384057f, -0.13207416f, 
    0.12161291f, -0.46133256f, -0.12623805f, -0.03670212f, 0.08018459f, -0.07839864f, -0.32311890f, 0.10606641f, 
    0.02555755f, -0.21844374f, 0.04625519f, 0.09779164f, 0.20582972f, -0.25184903f, -0.13069299f, -0.07041635f, 
    0.08935541f, -0.26993868f, 0.13979883f, 0.17730707f, -0.03601699f, -0.29120353f, -0.20953208f, 0.13398360f, 
    0.31275082f, -0.20911454f, -0.06459126f, -0.34985796f, 0.08564521f, 0.22086403f, -0.08561497f, 0.22329728f, 
    0.13693072f, -0.58911437f, 0.08005682f, 0.37042427f, 0.08487983f, -0.06974936f, -0.03488649f, -0.10953284f, 
    -0.17533067f, -0.06310458f, -0.08744318f, -0.30273443f, -0.12219337f, -0.02141235f, -0.50851184f, -0.32388893f, 
    0.02459139f, -0.05049710f, -0.15722379f, -0.19609593f, -0.19666420f, 0.23056585f, -0.31468058f, -0.41151851f, 
    0.04536273f, 0.31734249f, 0.00594758f, -0.36337298f, -0.04628163f, -0.40994146f, 0.09807348f, -0.04625618f, 
    -0.34598327f, 0.11004354f, -0.23389919f, -0.12237987f, -0.24405368f, 0.06236841f, 0.15587144f, 0.10989713f, 
    -0.30606988f, -0.21327308f, -0.04490682f, -0.19416443f, -0.11110517f, 0.28136238f, 0.13281094f, 0.35321960f, 
    -0.04235672f, -0.05650783f, -0.01689269f, 0.13453554f, -0.01370741f, 0.18777901f, -0.06764503f, -0.11873619f, 
    -0.08803597f, -0.17025648f, 0.09316580f, -0.22418916f, 0.19335002f, -0.31480569f, -0.26983726f, 0.13430668f, 
    -0.23515305f, -0.00549414f, -0.09979695f, -0.32428747f, -0.26473051f, -0.02327211f, -0.32154381f, -0.00582750f, 
    -0.16672836f, -0.16978788f, 0.25689775f, 0.19508716f, 0.30410138f, 0.19659047f, -0.22368458f, 0.13911848f, 
    -0.24638800f, -0.31044918f, 0.33158958f, 0.33763474f, 0.00705392f, -0.04717930f, -0.36688325f, 0.32601804f, 
    0.38534242f, -0.18655615f, 0.25028604f, -0.11301301f, -0.18115683f, -0.49838281f, -0.16267222f, -0.50215864f, 
    0.11687108f, 0.03516002f, -0.62005579f, -0.46743396f, -0.12276566f, -0.42210853f, 0.13964434f, -0.40170056f, 
    0.21934055f, -0.05355825f, 0.12837176f, -0.20601659f, -0.13973606f, -0.16352421f, -0.03228243f, -0.19721407f, 
    -0.07887595f, 0.02344336f, -0.05884458f, -0.04008948f, -0.11665948f, 0.16274996f, -0.12782434f, -0.39730743f, 
    -0.01491653f, 0.03007078f, -0.41049623f, -0.10682614f, -0.26918763f, -0.37582043f, -0.29890904f, -0.25365984f, 
    -0.00648984f, 0.20512916f, 0.03128522f, 0.05022151f, 0.07781463f, -0.53869975f, 0.34946272f, -0.43546587f, 
    -0.24305269f, -0.01243393f, -0.25708812f, -0.11124465f, -0.06715694f, -0.10862325f, -0.40938050f, -0.17483149f, 
    -0.31559303f, 0.14301512f, 0.14144421f, 0.17754948f, 0.12579492f, 0.17305924f, 0.08168133f, 0.19298300f, 
    -0.04628054f, -0.33061114f, 0.05509713f, 0.31521824f, -0.00272280f, 0.01129356f, 0.27196681f, 0.09498265f, 
    0.16933082f, -0.06333195f, 0.03190491f, -0.23447941f, -0.03636367f, -0.17408715f, -0.06469858f, -0.12234154f, 
    -0.49603826f, -0.01352055f, 0.04117177f, 0.31404608f, 0.16194294f, -0.18436554f, 0.21306625f, -0.03930103f, 
    0.04473548f, -0.35971099f, 0.00225732f, -0.49386957f, -0.11090418f, 0.13169041f, -0.21119507f, -0.00208479f, 
    -0.17284563f, 0.01321387f, -0.16989772f, -0.40378731f, 0.18555330f, -0.26505581f, -0.04064909f, -0.04620972f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.14647791f, 0.12951770f, 0.12456708f, -0.00793301f, 0.01609459f, 0.06884626f, 0.07836443f, -0.04776456f, 
    -0.00184540f, 0.03456080f, 0.00860925f, -0.11210267f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
