#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.02413499f, -0.80371052f, -0.43973362f, 0.22407901f, -0.28770813f, -0.67298579f, 0.81337410f, 0.06269211f, 
    0.38462257f, -0.71877718f, 0.07830923f, 0.75019753f, 0.87722480f, -0.38624880f, 0.42916620f, 0.12057557f, 
    -0.55506170f, -0.61351132f, 0.70234877f, 0.51620889f, 0.22193825f, -0.44149527f, -0.20624028f, 0.41706812f, 
    0.93177766f, -0.90667886f, -0.39460120f, 0.56206977f, -0.48767942f, 0.54930627f, 0.15594156f, 0.08954649f, 
    0.13262928f, 0.45917919f, 0.12413473f, -0.06444346f, 0.28281438f, 0.83347631f, -0.60394090f, -0.98276520f, 
    0.22342026f, 0.56491590f, -0.49475655f, 0.37368143f, 0.56969118f, 0.52327168f, 0.97179002f, -0.66810089f, 
    0.29859346f, 0.02798434f, -0.47881240f, -0.45465729f, 0.05146229f, 0.61732370f, 0.71160120f, -1.17889774f, 
    1.01079869f, -0.35755417f, -0.10093378f, 0.24079213f, 0.01195083f, -0.04367759f, 0.24797079f, 0.52299184f, 
    0.65918595f, -0.38820514f, -0.56842303f, 0.38999048f, 0.05766432f, 0.57949328f, 0.01500862f, 0.70681792f, 
    -1.62648487f, -1.22103000f, -0.85305423f, 0.96321398f, 0.57638758f, -0.53823918f, -0.37977985f, -0.76438117f, 
    -0.12008513f, -0.32877672f, -0.07203399f, 0.07448987f, -0.83324444f, -1.05979288f, -0.69779348f, -0.52377206f, 
    -0.85965753f, 1.12636065f, -0.84082490f, 0.48527804f, 0.71446478f, -0.33136392f, 0.22907472f, -1.05096257f, 
    -0.58478791f, -0.40086466f, -0.96375096f, 0.06896901f, -0.10286707f, -0.44527096f, -0.14721525f, 0.14221783f, 
    0.43016827f, 0.45940101f, 0.34040689f, 0.46656498f, -0.79173297f, -0.48427114f, -0.14552887f, 0.54647589f, 
    0.01063826f, 0.62831950f, -0.15367360f, 0.60024798f, 0.42334732f, -0.88883090f, 0.31748727f, 0.50207776f, 
    -0.33748004f, -0.88294733f, -1.20874393f, 0.51109946f, 0.98540586f, -0.29416308f, 0.56317097f, 0.58363551f, 
    0.53513056f, -0.21898359f, -0.62921518f, 0.08737177f, 0.00396180f, -0.09155291f, 0.04749510f, -0.12192680f, 
    0.63283706f, 0.03651410f, 0.65251797f, 0.83626390f, 0.28703722f, 0.32208279f, -0.15370648f, 0.22739035f, 
    1.32305765f, 0.71528798f, 0.36106506f, -0.69506699f, -0.64747548f, -0.75489974f, 0.15015766f, 0.58458382f, 
    0.16993302f, -0.95491743f, -0.00777210f, -0.38473874f, -0.32118097f, -0.16530485f, -0.43300021f, 0.52968693f, 
    0.65912360f, 0.65100616f, 0.02854160f, -0.21131809f, 0.94354451f, -1.06816947f, -0.33895358f, 0.37773851f, 
    -0.11227912f, 0.35166752f, 0.72489524f, -0.91219682f, 0.86568320f, -0.25083300f, -0.73397905f, -0.95264465f, 
    -0.57717603f, -0.18344766f, -0.75594449f, -0.19878240f, -0.78548431f, 0.24317999f, -0.20926310f, -0.90411317f, 
    1.02594483f, -1.45221293f, 0.09370382f, -0.01167051f, 0.07489452f, 0.17241579f, 0.58985800f, 0.08013080f, 
    0.39025360f, -0.31322044f, -0.07398909f, -0.31524876f, 1.13802123f, -1.00410521f, 0.32979774f, -0.33293635f, 
    -0.19004619f, -0.19975936f, -0.32714620f, -0.59678417f, 0.13200267f, 0.40469858f, 0.95808649f, -1.21758485f, 
    -0.00132786f, 0.71730959f, -0.43781102f, 0.07556959f, 0.90984237f, 0.16810140f, -0.27913946f, 0.51358986f, 
    0.55963767f, -0.09271477f, 0.00429884f, -0.07129207f, -0.54942304f, 0.60431486f, 0.10286006f, 0.26106966f, 
    -0.25437665f, -0.60929763f, 1.20102012f, -0.67165256f, 0.31272101f, -0.17381565f, -0.43631610f, 0.61462605f, 
    0.59306318f, -0.06668495f, -0.29431447f, 0.72642642f, 0.43130851f, -0.21161769f, 0.12835069f, 0.36328217f, 
    -0.62840921f, -0.62548715f, -0.24010983f, 0.07954896f, 0.15014160f, 0.21353053f, 0.47953194f, 0.21697447f, 
    0.37668389f, 0.35346293f, -0.56103867f, 0.18964167f, 0.00115015f, -0.62209314f, -0.45654592f, 0.51849610f, 
    0.92764467f, 0.55002326f, -0.37507969f, -0.65976143f, -0.59798121f, -0.89773440f, -0.62917405f, -0.59292215f, 
    -0.38341126f, -0.87103689f, -0.77055871f, -0.01971511f, 0.17868063f, 0.05252646f, 0.74061644f, 0.15455787f, 
    -0.10554977f, 0.43327639f, 0.43801537f, 0.08456397f, 0.01443118f, 0.78365815f, -0.22950360f, 1.20264578f, 
    -0.72293895f, -0.36111277f, 0.26194647f, 0.19767596f, 0.13990502f, 0.28260398f, 0.65279526f, -0.99093926f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.15793180f, 0.36458126f, -0.11302095f, 0.53180534f, 0.62219203f, -0.23427357f, 0.26055044f, 0.20888615f, 
    -0.09798412f, -0.05030289f, -0.19331354f, 0.36202198f, -0.03224433f, 0.09996284f, 0.61586988f, -0.03748217f, 
    0.06440258f, 0.14003208f, 0.19657651f, -0.32849842f, 0.77874625f, -0.25750703f, 0.05693453f, 0.15236735f, 
    0.51032847f, -0.11341442f, 0.37978107f, 0.45279750f, 0.37366626f, 0.06645733f, -0.26959085f, 0.28710052f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.03432956f, -0.01100293f, -0.02405503f, 0.04214270f, 0.04655410f, 0.02405008f, -0.03240503f, 0.02555455f, 
    -0.02896407f, -0.00452590f, 0.03272058f, -0.05211884f, 0.01028231f, 0.04345103f, -0.00745931f, 0.04146539f, 
    -0.02120503f, 0.04149389f, -0.06491391f, -0.02774750f, 0.00079238f, -0.03741561f, -0.05920323f, 0.05030942f, 
    -0.03949961f, -0.03526010f, -0.05540454f, -0.06233163f, 0.03804489f, -0.00349710f, 0.01843423f, 0.05094896f, 
    -0.04570203f, -0.05897266f, -0.05052296f, -0.05327975f, 0.02668692f, -0.04070980f, -0.01413179f, -0.01968332f, 
    0.05284974f, 0.00818665f, 0.00563519f, -0.01601855f, 0.02524448f, -0.01748377f, -0.02681829f, 0.02625433f, 
    0.01494923f, 0.04840688f, -0.00977140f, 0.00336508f, -0.00484661f, 0.04383870f, 0.01561848f, 0.04563055f, 
    0.01765351f, -0.01543193f, -0.02180289f, 0.02770225f, -0.03065814f, 0.00453754f, -0.02622459f, 0.03806514f, 
    -0.05155344f, -0.05241795f, -0.01136944f, 0.03388241f, -0.01612643f, -0.01965634f, 0.00533265f, -0.02585470f, 
    -0.03381587f, -0.02732572f, 0.00215767f, -0.01887864f, -0.00177900f, -0.03532697f, 0.01530149f, 0.01015575f, 
    0.05092313f, -0.04095261f, -0.02160732f, -0.02300069f, -0.00228567f, -0.02274913f, -0.00807558f, -0.00447384f, 
    -0.02149531f, -0.03214677f, -0.04873162f, -0.00365234f, 0.01973351f, 0.00077272f, 0.01260355f, 0.03225619f, 
    -0.01125928f, -0.03579929f, -0.04275518f, -0.02025249f, 0.00730479f, -0.02509785f, 0.04301667f, 0.00098919f, 
    -0.03536160f, -0.00804483f, -0.05958077f, 0.01937585f, -0.06289400f, 0.00841726f, -0.01256031f, 0.03437142f, 
    -0.04093498f, -0.02369237f, -0.06075877f, 0.00353967f, -0.02540742f, 0.03191745f, 0.00988918f, -0.05626474f, 
    -0.02959356f, 0.03918804f, 0.04364554f, 0.00059448f, -0.03728986f, -0.02778180f, 0.00000955f, -0.05024768f, 
    -0.02828500f, -0.05570878f, 0.02381284f, 0.00944790f, -0.01382587f, -0.05404780f, 0.03611464f, -0.06292765f, 
    -0.04011381f, -0.03535512f, -0.05858204f, -0.04203895f, 0.04698884f, 0.00557265f, -0.02470542f, 0.04466305f, 
    -0.04831658f, 0.04586584f, 0.01813530f, 0.05363555f, -0.01739975f, -0.03641531f, -0.00439117f, 0.00953487f, 
    -0.05325840f, 0.04856949f, 0.04741577f, -0.01087805f, -0.03397179f, -0.04604661f, 0.03240559f, -0.01418087f, 
    -0.00286116f, 0.03793794f, -0.06017683f, -0.06276323f, -0.02155359f, -0.05115541f, -0.01809874f, -0.05619504f, 
    -0.04095571f, 0.04284119f, 0.03535470f, 0.03115599f, 0.00985424f, -0.06007520f, -0.05257823f, -0.05715539f, 
    0.05029031f, -0.00563055f, -0.04505783f, 0.04735321f, -0.03347240f, 0.00953815f, 0.03720613f, -0.03110824f, 
    -0.05104193f, -0.00784558f, 0.03281966f, 0.03820235f, 0.02373664f, 0.05172752f, 0.00759383f, 0.02953795f, 
    -0.05021453f, -0.03215341f, 0.03595798f, 0.03091506f, 0.05219823f, 0.04322463f, 0.03097131f, -0.02231160f, 
    -0.04827295f, 0.01752123f, -0.04516689f, -0.03634897f, -0.02741247f, 0.02810836f, 0.05031814f, -0.04803512f, 
    0.02373485f, -0.02127987f, -0.03864878f, -0.01759220f, -0.02732575f, -0.05474954f, 0.04075809f, 0.05293715f, 
    -0.05435548f, -0.02086318f, 0.04532614f, 0.03327908f, -0.05170207f, -0.04921135f, -0.02204771f, 0.04960362f, 
    -0.04574389f, 0.01357794f, 0.02650246f, -0.06356928f, -0.02760098f, 0.05238723f, 0.01489437f, 0.00587400f, 
    0.02471901f, -0.01298421f, 0.03573602f, -0.05030632f, -0.03760500f, -0.02189277f, -0.03081909f, -0.03792980f, 
    -0.04269950f, 0.00997391f, 0.02815660f, 0.04931304f, 0.02976261f, 0.03860891f, 0.01046568f, 0.05366025f, 
    0.00029528f, -0.05793202f, 0.01444873f, 0.01928551f, 0.05184160f, -0.01935514f, -0.02002640f, -0.05299919f, 
    -0.03344030f, -0.04641189f, 0.00766144f, 0.00446835f, 0.00517587f, -0.03267238f, 0.01884761f, 0.02181957f, 
    -0.04319530f, -0.04532765f, 0.00295195f, 0.02715849f, -0.01654062f, 0.03627776f, 0.00360481f, 0.03170815f, 
    0.00210025f, 0.02203276f, 0.01061948f, 0.01300313f, 0.01542030f, 0.00703851f, -0.01979662f, -0.05100480f, 
    -0.05837413f, -0.03008739f, 0.03640807f, 0.01100601f, -0.04796981f, -0.03178373f, 0.03537575f, -0.01201640f, 
    -0.05223807f, -0.01792048f, -0.04334185f, 0.05182717f, 0.02484885f, 0.03288427f, 0.04742020f, 0.02764858f, 
    -0.00444263f, -0.04902072f, -0.04739610f, -0.04727292f, -0.01665729f, -0.03258485f, 0.03231911f, -0.01437106f, 
    0.03466328f, 0.00458758f, -0.03609895f, 0.02903463f, 0.00142039f, 0.04038785f, -0.01433089f, 0.03675904f, 
    -0.04400086f, -0.00194735f, 0.01498937f, -0.00886106f, 0.01691687f, -0.00149619f, 0.00643320f, 0.03635105f, 
    0.02001459f, -0.02338304f, -0.02724327f, -0.06533997f, -0.01465147f, -0.00946856f, 0.04364369f, -0.04824275f, 
    -0.03772957f, 0.04160097f, -0.06172759f, -0.02413547f, -0.05895979f, 0.00642797f, -0.00810253f, 0.03775480f, 
    -0.02454715f, -0.02381477f, -0.02108727f, -0.04279441f, 0.04776152f, -0.01105521f, -0.03767600f, -0.03376400f, 
    -0.00157207f, -0.02809986f, 0.00195475f, 0.01259295f, -0.06485666f, 0.00367227f, 0.04622749f, 0.00753451f, 
    -0.05439968f, 0.03616694f, -0.03594940f, 0.04006107f, -0.03143281f, -0.01228051f, -0.04970915f, 0.02640290f, 
    0.04070786f, 0.02052562f, -0.02949329f, 0.01305503f, -0.01062578f, 0.02665997f, -0.04873874f, -0.00220244f, 
    -0.06007046f, -0.01633489f, -0.06214227f, 0.00539798f, -0.03421555f, 0.01757997f, -0.02954471f, -0.01853287f, 
    0.03974036f, -0.02410204f, 0.01057816f, -0.01461418f, -0.00284538f, -0.01554717f, -0.05442289f, 0.00697294f, 
    -0.03468509f, 0.01858469f, -0.02673182f, -0.03111224f, 0.02161715f, -0.02619545f, -0.00498664f, 0.00742035f, 
    0.00252754f, 0.00745269f, -0.04577794f, -0.05903118f, -0.07027587f, 0.03566944f, 0.03547151f, -0.02744491f, 
    0.04743871f, 0.03040120f, -0.00327690f, -0.03313194f, -0.04676339f, -0.00904024f, 0.03879822f, -0.02395084f, 
    0.02777940f, 0.00552582f, -0.02001859f, -0.05228382f, -0.01997349f, 0.05272639f, -0.00984757f, -0.04062841f, 
    0.03638927f, -0.05329385f, -0.00864244f, 0.02375506f, -0.00479537f, -0.03845572f, -0.03412589f, 0.04422072f, 
    0.02874726f, 0.00113753f, 0.02639484f, 0.00364603f, -0.01640610f, 0.02890957f, -0.02750380f, -0.05282556f, 
    0.03286887f, -0.05062547f, -0.03880443f, 0.01043279f, -0.02629966f, -0.00006063f, -0.01747311f, 0.00799719f, 
    0.01890293f, 0.04943139f, 0.00349465f, -0.00327383f, 0.01269829f, -0.04555674f, -0.00355939f, 0.00444061f, 
    0.01998125f, 0.01441515f, -0.06678001f, 0.02670660f, 0.04614781f, 0.01740445f, 0.03558377f, 0.02012892f, 
    0.01402770f, -0.05593131f, 0.00424136f, -0.05379423f, -0.02027044f, -0.05357828f, 0.04389235f, 0.00869678f, 
    -0.00737415f, 0.00137417f, -0.05225049f, 0.04173187f, 0.01840014f, 0.03307312f, 0.01433784f, -0.04676258f, 
    0.03712623f, -0.03703937f, 0.02409839f, -0.01497778f, 0.00558847f, -0.01364954f, -0.03522299f, -0.03386393f, 
    0.01391093f, -0.05178680f, 0.03245816f, 0.01959985f, -0.00053197f, -0.04162677f, 0.04176407f, 0.04337402f, 
    0.01545098f, 0.01767927f, 0.01084001f, -0.02601276f, -0.05502236f, -0.02345097f, 0.00734025f, -0.06084478f, 
    -0.00385148f, -0.00504421f, -0.01451980f, -0.01648603f, -0.04374979f, -0.06348213f, -0.02628986f, 0.04525629f, 
    -0.02132179f, -0.03572015f, 0.04686525f, 0.02210605f, 0.03609277f, -0.05790132f, -0.05976402f, -0.02013323f, 
    -0.04508351f, 0.00374062f, 0.00666458f, -0.01659560f, 0.03443284f, -0.05201815f, 0.02978582f, -0.01318338f, 
    0.00944307f, 0.02758549f, 0.04637352f, -0.00364768f, 0.04657690f, 0.01827615f, 0.03801263f, -0.03491189f, 
    -0.01518824f, -0.03325097f, 0.03019917f, -0.07276257f, -0.01072027f, -0.05869747f, 0.04665984f, 0.04082979f, 
    -0.04850887f, -0.05799747f, 0.04593144f, 0.02291690f, 0.01552501f, 0.04193133f, 0.02585133f, -0.00256781f, 
    -0.01914112f, -0.05144176f, 0.04265058f, 0.05019056f, -0.05564389f, 0.02676174f, 0.01815586f, -0.03702247f, 
    0.02211287f, 0.03561988f, -0.00181890f, -0.06032850f, -0.05045751f, 0.01913323f, 0.02952136f, 0.04164900f, 
    -0.00748835f, 0.01335429f, 0.01820889f, -0.04532314f, -0.02265014f, 0.03919399f, -0.03669649f, 0.01984339f, 
    -0.02651700f, -0.04106145f, -0.01535949f, 0.03122419f, -0.02595328f, -0.01349549f, -0.02561891f, -0.04371545f, 
    0.10556186f, -0.51676154f, 0.02876008f, -0.24083047f, -0.01968397f, 0.26239929f, 0.09741379f, 0.05577734f, 
    -0.03215342f, -0.47739163f, -0.04550257f, 0.26619101f, -0.06229931f, -0.00736396f, -0.33695683f, 0.05141766f, 
    -0.19461218f, -0.19135867f, 0.01937658f, -0.03859928f, 0.24395806f, 0.12270219f, -0.03394393f, -0.15860920f, 
    -0.10470861f, -0.25889450f, 0.21808350f, -0.05002630f, 0.00655243f, -0.08470916f, -0.03303893f, 0.02363942f, 
    0.17073444f, 0.12219715f, -0.06891599f, -0.02540972f, -0.48929971f, -0.31167611f, -0.21691975f, 0.15562660f, 
    0.08434306f, -0.06900011f, -0.14007272f, -0.00626220f, 0.06046599f, 0.17924908f, -0.32070029f, -0.08435111f, 
    -0.01715197f, 0.08078636f, -0.03197708f, -0.06489072f, 0.13782018f, 0.30722657f, -0.02082340f, -0.23547025f, 
    -0.19524692f, -0.01740396f, 0.00853917f, 0.32634804f, 0.03553479f, 0.06216735f, -0.23622219f, -0.07065131f, 
    -0.06488340f, 0.03736388f, 0.15212154f, 0.12608306f, -0.12905788f, -0.03678643f, -0.06495023f, 0.06913225f, 
    0.27567166f, 0.08167324f, 0.02476624f, 0.02603064f, 0.02143105f, 0.01823694f, 0.17737974f, -0.04984282f, 
    -0.13538468f, 0.13527800f, 0.49863508f, 0.22253500f, 0.11640023f, -0.13021840f, -0.07705631f, -0.00910103f, 
    0.01512541f, 0.11635633f, -0.31061429f, -0.24875820f, -0.35156432f, -0.02619110f, -0.14877757f, -0.10318730f, 
    0.06665716f, -0.10336919f, -0.10287132f, -0.02921618f, 0.05279591f, 0.07081160f, -0.09756216f, -0.05638547f, 
    0.06624831f, 0.04194532f, 0.12297210f, 0.09247859f, 0.01639481f, 0.02019378f, 0.03154071f, -0.12652789f, 
    -0.20210022f, 0.01313756f, 0.05754131f, 0.08306210f, 0.02230057f, -0.06105379f, 0.17430274f, 0.12743273f, 
    -0.24318241f, 0.22677097f, -0.03344969f, 0.02434373f, 0.23538971f, 0.03911413f, 0.17540953f, -0.35570499f, 
    -0.04613534f, 0.07100848f, -0.08472701f, 0.02585986f, -0.04019582f, -0.12723774f, -0.01725833f, 0.02530554f, 
    0.08891781f, 0.10307767f, 0.05449466f, -0.13786034f, -0.07191622f, 0.07217148f, -0.15916321f, 0.22949144f, 
    -0.33690155f, -1.05692589f, -0.89563435f, 0.05060326f, -0.03323472f, 0.10061342f, 0.04842880f, -0.10769964f, 
    0.04719445f, 0.16334337f, 0.10199309f, 0.24541438f, -0.04728734f, -0.08189628f, 0.10200114f, 0.07621507f, 
    0.20088553f, 0.05056746f, -0.40193909f, 0.15300572f, -0.12258282f, 0.02512027f, 0.00201368f, 0.10981579f, 
    -0.16555533f, 0.09195561f, 0.04877223f, 0.16691233f, 0.05574609f, -0.01717654f, 0.11683672f, 0.14395955f, 
    -0.09517074f, -0.02025117f, 0.10102439f, 0.12533042f, -0.07303077f, 0.28129566f, 0.23225367f, -0.05837280f, 
    -0.15889709f, -0.20836842f, -0.04828022f, 0.01010230f, 0.22677997f, 0.02881382f, 0.46988815f, 0.09708703f, 
    -0.15026790f, 0.12532224f, -0.15759881f, -0.02990120f, 0.12159926f, -0.26634577f, 0.17984338f, 0.15279965f, 
    -0.17330448f, 0.04792472f, 0.07844049f, 0.01381776f, 0.05394600f, 0.19820943f, 0.03856468f, -0.30222178f, 
    0.30501139f, 0.08035879f, -0.11372626f, -0.07560102f, 0.02014667f, -0.09772615f, 0.05460758f, 0.07812439f, 
    0.03960085f, -0.03378142f, 0.03765312f, -0.00054473f, -0.03227439f, -0.10004368f, -0.02356599f, 0.24654333f, 
    -0.12225042f, -0.21054129f, -0.05211413f, 0.18151927f, -0.13544852f, 0.23470123f, 0.20894037f, 0.09050588f, 
    0.20609178f, -0.13858201f, -0.26762936f, -0.33209753f, -0.07284415f, -0.01917513f, -0.09665877f, -0.08986165f, 
    0.15437146f, -0.17776582f, -0.01528750f, 0.00309642f, 0.05238341f, 0.24812752f, -0.01267217f, -0.24302809f, 
    -0.19540960f, -0.10377371f, -0.19999295f, 0.00605719f, -0.41047806f, -0.02112084f, 0.15239486f, 0.12254310f, 
    0.02516395f, 0.02381027f, 0.21429104f, -0.22739403f, 0.16161811f, 0.35527202f, 0.42008972f, 0.21369521f, 
    -0.11910398f, -0.03927838f, 0.02303174f, -0.02241518f, 0.16387783f, 0.00902810f, 0.06914037f, 0.14706074f, 
    0.00299746f, 0.07581317f, -0.20282467f, -0.02826875f, 0.06692189f, -0.17314045f, -0.01436365f, 0.03010157f, 
    -0.05704952f, -0.13499403f, -0.02238199f, -0.30035540f, 0.00842916f, -0.12906140f, 0.04230123f, -0.24284166f, 
    0.21340936f, 0.08734990f, -0.08125075f, -0.13393943f, 0.23827410f, -0.03701289f, -0.05162374f, 0.14718340f, 
    -0.06381616f, -0.41413262f, 0.03657411f, 0.01849249f, 0.08690543f, -0.01159581f, -0.09860721f, 0.05810048f, 
    0.03146886f, 0.17556173f, -0.05355363f, 0.08357208f, 0.29987663f, -0.02404519f, -0.21418877f, 0.15660536f, 
    0.01899225f, 0.00526642f, -0.07396525f, 0.03564213f, -0.04967209f, 0.19588222f, 0.01928313f, 0.09473517f, 
    0.03345581f, -0.09583297f, -0.09593137f, 0.13786533f, -0.24225454f, 0.13715084f, -0.00424174f, -0.27294424f, 
    -0.10564575f, 0.03561354f, 0.13443865f, -0.00111148f, -0.16742201f, -0.12997639f, 0.27213708f, -0.09527585f, 
    0.32213676f, -0.02007733f, -0.01259735f, 0.17579265f, 0.20016050f, -0.12384981f, -0.05160212f, 0.08224238f, 
    0.22591850f, -0.20761256f, 0.08547398f, 0.19531916f, 0.01887027f, -0.23245411f, 0.20072842f, -0.00410634f, 
    0.13501473f, -0.05481555f, -0.04885377f, 0.01967202f, -0.01977460f, -0.10737969f, 0.05353875f, -0.17841373f, 
    0.46275911f, 0.20006286f, -0.22778933f, -0.01505660f, 0.01637680f, 0.28244221f, 0.04834387f, 0.03533483f, 
    -0.06827905f, 0.15744671f, 0.23990412f, 0.19799188f, -0.03034335f, -0.13642800f, -0.00329117f, -0.10691512f, 
    0.04076960f, -0.06156486f, -0.23487227f, 0.39322305f, -0.06929771f, -0.13720438f, -0.05039106f, -0.28136125f, 
    0.14261094f, -0.02755285f, -0.00896228f, 0.05755749f, 0.01064688f, -0.15108258f, 0.12906787f, 0.13443324f, 
    0.02096023f, 0.19775197f, 0.28927273f, 0.09905555f, -0.03017485f, 0.04761597f, 0.01568676f, 0.05337367f, 
    0.13796559f, 0.03735561f, 0.28657630f, 0.10167025f, 0.28625771f, 0.08475401f, 0.33801347f, 0.10792132f, 
    -0.12330915f, 0.20553957f, -0.39752054f, -0.02431951f, 0.00507129f, -0.12045930f, -0.24363938f, 0.08078142f, 
    -0.08216739f, -0.03769436f, -0.07149156f, -0.06863706f, 0.05248771f, -0.02669036f, -0.06296809f, 0.05216217f, 
    -0.04352170f, 0.01288719f, 0.04034643f, -0.05569847f, 0.12629099f, -0.01851073f, 0.06992382f, 0.29803625f, 
    0.05257730f, 0.11971030f, 0.14838479f, -0.17591114f, -0.01016336f, -0.11586346f, 0.01015637f, 0.01770907f, 
    0.06647173f, 0.19516483f, 0.21075244f, -0.05681144f, 0.05635959f, 0.04235445f, -0.14071894f, 0.23129213f, 
    0.12497088f, 0.05039390f, -0.16505925f, 0.22541481f, 0.23993057f, -0.15124236f, 0.03939870f, -0.06895514f, 
    0.06048151f, -0.01939466f, -0.02432584f, -0.27202627f, 0.41450027f, 0.05017442f, -0.17983930f, 0.08440556f, 
    0.13995822f, -0.02752938f, 0.01016837f, 0.03053504f, 0.13979967f, 0.06511655f, 0.38496709f, -0.34371310f, 
    -0.10098391f, -0.10570372f, -0.06364034f, -0.04977501f, 0.03296954f, -0.18603940f, -0.27957407f, 0.25206399f, 
    0.04337576f, -0.01555135f, 0.13046630f, 0.07020527f, 0.02829638f, 0.11595298f, 0.21262039f, 0.34686145f, 
    -0.04503827f, 0.08103072f, -0.21705087f, -0.01881514f, 0.20399807f, 0.09506669f, 0.06210202f, -0.17616120f, 
    0.04811171f, 0.11528916f, 0.00033866f, -0.09358331f, 0.22963737f, 0.10239369f, 0.08500694f, -0.13654038f, 
    -0.18888892f, -0.28332147f, -0.03792734f, -0.08948020f, -0.06333504f, -0.00637557f, 0.11930706f, -0.02395278f, 
    -0.06008388f, 0.02682396f, -0.21223661f, -0.10225369f, 0.18049845f, -0.03200197f, 0.04587177f, 0.02576199f, 
    0.30358240f, -0.03597871f, -0.60859811f, 0.02230186f, 0.23451194f, 0.12900592f, -0.07804436f, -0.07850125f, 
    0.12344230f, 0.16117857f, -0.05539593f, -0.24684787f, 0.03621403f, -0.03300194f, 0.10274965f, -0.13493048f, 
    -0.06026645f, -0.02641091f, -0.10360666f, -0.10096993f, -0.21881147f, -0.59154701f, -0.38772389f, 0.13571759f, 
    -0.08254750f, 0.00147250f, 0.03794955f, -0.04156202f, 0.13571616f, 0.39700392f, 0.48654836f, -0.01694552f, 
    -0.23235123f, 0.02221221f, 0.04424496f, 0.07918427f, -0.05998999f, -0.08892468f, -0.05640664f, -0.10923856f, 
    0.25951144f, 0.12165197f, 0.00078560f, 0.12624617f, -0.35621691f, -0.02461949f, 0.12994230f, -0.32291842f, 
    -0.45336097f, 0.25262916f, 0.12662867f, -0.11575188f, 0.15590487f, -0.10073251f, -0.19025269f, 0.03423328f, 
    0.13451768f, 0.54293710f, 0.07161585f, -0.03327041f, 0.04715826f, 0.14699818f, 0.23865601f, 0.10123082f, 
    -0.00176433f, -0.02381150f, -0.32499748f, -0.21690941f, -0.17413740f, -0.20418131f, 0.15750074f, 0.19254395f, 
    -0.16134784f, 0.02406136f, -0.80297184f, -0.24239980f, 0.24599855f, 0.04161568f, -0.02084550f, 0.11538331f, 
    -0.13318853f, 0.27351180f, -0.23420918f, -0.18913186f, -0.34623331f, -0.29465425f, -0.13907704f, -0.04362657f, 
    -0.21581176f, 0.03664970f, 0.07611526f, 0.02137866f, -0.54366785f, -0.26395836f, -0.80739796f, -0.06575993f, 
    -0.19468181f, -0.16491278f, 0.14634760f, 0.01302682f, -0.28327420f, -0.83122873f, -0.69538480f, -0.66365463f, 
    0.20331675f, -0.12023857f, -0.27098951f, 0.04823855f, -0.04084021f, -0.00748308f, -0.31187874f, -0.45306602f, 
    -0.91992909f, 0.04525867f, 0.02593155f, -0.10956290f, 0.00902063f, -0.00079226f, -0.07725463f, 0.31517795f, 
    -0.27550581f, -0.60508627f, 0.17576873f, -0.28450826f, -0.06415212f, 0.11219676f, -0.01945893f, -0.06206350f, 
    0.39210612f, 0.08777095f, 0.62607253f, 0.04051523f, 0.06236671f, 0.17498066f, 0.28769535f, 0.02465052f, 
    0.14354761f, 0.17286581f, 0.32608303f, 0.22331794f, -0.07649411f, 0.33458567f, 0.05118899f, 0.26813132f, 
    0.05034686f, 0.13976043f, 0.25809631f, -0.20978093f, 0.20088057f, 0.07640680f, 0.05029597f, 0.02018560f, 
    0.14587945f, -0.13421251f, -0.11273289f, 0.07346117f, -0.06157537f, -0.11976092f, -0.10184865f, -0.05373683f, 
    0.06054967f, 0.00293675f, 0.05081271f, 0.09080435f, -0.27998140f, -0.14719208f, 0.16714440f, -0.02061673f, 
    0.08594990f, 0.11481003f, -0.30703837f, 0.05289457f, 0.06351380f, 0.09729181f, -0.19204946f, 0.64543509f, 
    -0.22178721f, -0.15525694f, -0.08131375f, -0.23417760f, 0.15967560f, -0.01938995f, -0.04196329f, -0.21973574f, 
    0.14833719f, 0.04515655f, -0.15421325f, 0.00637511f, -0.00569291f, 0.03257618f, -0.04088131f, 0.25059515f, 
    0.00345041f, -0.28332701f, -0.09470753f, -0.10139546f, 0.16729492f, -0.18365675f, 0.07792937f, 0.23235877f, 
    -0.00685266f, -0.42808565f, 0.11988112f, -0.07281752f, -0.22150400f, -0.28819025f, 0.02204000f, -0.10165216f, 
    -0.15179718f, 0.22471535f, 0.09016871f, 0.40120932f, -0.03871801f, 0.20981643f, -0.06010946f, -0.10798293f, 
    -0.08078734f, 0.15360788f, 0.19515838f, 0.14714962f, -0.59913975f, 0.09140707f, -0.23433919f, 0.04423461f, 
    -0.07101709f, -0.12412182f, -0.08629692f, 0.41009858f, 0.08279022f, 0.28313696f, 0.02689138f, -0.17244630f, 
    -0.18405972f, -0.07678723f, -0.02624590f, -0.06242680f, 0.12201381f, -0.30319223f, 0.10052525f, -0.05059581f, 
    0.14895006f, -0.09931782f, 0.11273651f, -0.06435183f, 0.19665113f, -0.17760542f, -0.77990663f, -0.10508139f, 
    -0.10997798f, -0.09972557f, 0.32026693f, -0.04537011f, 0.00504253f, -0.19159208f, 0.21764418f, 0.45815688f, 
    -0.05593846f, 0.09326050f, 0.11056239f, -0.19154972f, 0.02765020f, 0.11112360f, 0.10587934f, -0.51601112f, 
    -0.19635865f, -0.35032395f, -0.11590081f, 0.29207531f, 0.07611097f, 0.02773062f, 0.04431172f, 0.25466624f, 
    -0.03190438f, 0.05977861f, -0.04020750f, 0.08105745f, 0.05876770f, 0.06533469f, 0.05247347f, 0.22473748f, 
    -0.00997374f, 0.37807113f, -0.53988642f, -0.50540364f, 0.19980036f, -0.02138043f, -0.22147097f, 0.05028432f, 
    0.00404776f, 0.20190077f, -0.12504527f, -0.11735561f, -0.02522885f, 0.25356674f, 0.06013475f, 0.21977521f, 
    0.24046350f, -0.00337793f, -0.03946643f, 0.00548493f, -0.19369815f, -0.06994781f, -0.09642879f, 0.08209005f, 
    0.04045810f, -0.16953529f, 0.05947084f, 0.33270210f, 0.06409900f, 0.15156482f, 0.24606933f, 0.06005751f, 
    0.06035634f, 0.24839635f, 0.21153755f, 0.01863980f, 0.38219589f, 0.13552684f, 0.39893171f, 0.29985312f, 
    -0.09948537f, 0.04413363f, -0.05475370f, 0.04683449f, -0.01142364f, 0.08471554f, 0.08568956f, -0.28646415f, 
    -0.53162080f, -0.21524556f, -0.03051934f, -0.04072344f, 0.30818450f, 0.26128817f, 0.08825617f, 0.18267331f, 
    -0.28306013f, -0.21363725f, -0.06782245f, 0.09323142f, 0.08588665f, 0.04051681f, 0.14097862f, 0.19298781f, 
    0.21251118f, -0.35442632f, 0.52975833f, -0.16399238f, 0.11103646f, 0.25377271f, 0.01905749f, 0.08840293f, 
    0.21588920f, -0.26609969f, 0.01451270f, -0.01177648f, -0.25846446f, 0.09022477f, -0.06896216f, 0.27819288f, 
    -0.12799436f, -0.12500134f, -0.20939548f, -0.14549352f, -0.34996054f, -0.25793740f, -0.02359195f, -0.12327197f, 
    -0.29765895f, 0.07994215f, -0.13640144f, 0.06644452f, -0.01941391f, -0.01993629f, -0.04255347f, -0.05064628f, 
    -0.18769063f, -0.11205385f, 0.11354528f, 0.16938169f, -0.27528971f, 0.45792589f, -0.13256738f, 0.17276633f, 
    -0.21500435f, 0.32920760f, 0.32486361f, 0.29758862f, 0.18274698f, -0.29985163f, -0.17996734f, -0.09190910f, 
    -0.09286416f, -0.10915398f, 0.00664571f, 0.23876186f, 0.11072315f, -0.09583333f, 0.10044423f, -0.04230923f, 
    -0.22312570f, 0.27072763f, -0.08386665f, -0.13885489f, -0.01592851f, 0.07659375f, 0.28744781f, -0.06638281f, 
    0.19280331f, 0.00932461f, 0.22512840f, -0.08540871f, 0.10863700f, 0.22019623f, 0.08509140f, 0.20756908f, 
    0.21539102f, -0.17954227f, -0.47914732f, -0.15306100f, -0.11594771f, -0.25284693f, 0.05892751f, -0.19167817f, 
    0.01850032f, 0.25022483f, 0.08077096f, -0.54186505f, -0.07883945f, 0.08669370f, -0.15096945f, 0.13048275f, 
    0.25333133f, 0.08725892f, -0.50048971f, -0.37646642f, -0.37543195f, 0.02600487f, 0.10996644f, -0.06144005f, 
    -0.02685319f, -0.02248936f, -0.13570671f, -0.12522097f, 0.12383201f, 0.08100035f, 0.18039447f, -0.14186086f, 
    0.02864650f, -0.01766999f, 0.07694112f, 0.14749505f, -0.21396676f, -0.06812165f, -0.27555263f, -0.02127674f, 
    -0.09811045f, -0.29275027f, 0.17677002f, -0.11680551f, 0.11280993f, 0.09926137f, 0.21293059f, 0.04854169f, 
    -0.15414245f, 0.11097613f, 0.07722947f, -0.00111922f, -0.00956479f, 0.14649384f, -0.03191236f, -0.09386746f, 
    -0.32266310f, 0.08410487f, 0.05067835f, 0.09577122f, 0.00272333f, 0.02662062f, 0.00626554f, -0.17141218f, 
    0.02915127f, 0.14163218f, -0.02384823f, -0.02987578f, -0.19355081f, 0.04114975f, -0.09892626f, -0.05552401f, 
    0.29136232f, -0.19623148f, -0.44579726f, 0.08824166f, 0.03954269f, 0.07435169f, -0.00479032f, 0.09450421f, 
    0.31960046f, -0.24984631f, -0.12514660f, 0.08836510f, 0.07519726f, 0.04487433f, 0.07848933f, -0.01267800f, 
    -0.02077779f, 0.20307639f, 0.19646199f, 0.15690191f, -0.47128475f, 0.30908695f, 0.02841042f, 0.22033882f, 
    0.09716729f, -0.00242410f, 0.26282400f, -0.32251656f, -0.13824366f, -0.34845921f, 0.00864394f, 0.08703887f, 
    -0.03687382f, 0.11919181f, 0.20150903f, 0.03906158f, -0.10540272f, 0.23796172f, 0.22316638f, 0.16160250f, 
    0.13203023f, 0.04018783f, 0.06776296f, 0.17741403f, 0.11731122f, -0.14380860f, -0.23474881f, 0.02203478f, 
    -0.29834786f, 0.09695719f, -0.20223580f, 0.00642776f, -0.18015103f, 0.07875142f, 0.10307428f, 0.08520169f, 
    0.19230656f, -0.11308371f, 0.32119107f, 0.13704281f, 0.15487881f, 0.09189557f, 0.30319411f, -0.12792870f, 
    0.01779450f, -0.39523777f, 0.06657168f, -0.20051292f, -0.00899595f, -0.14525776f, 0.10311912f, 0.08825794f, 
    0.11362671f, -0.03231639f, -0.03992113f, 0.12640564f, 0.09220023f, 0.10643515f, -0.19170897f, 0.08905355f, 
    0.14644957f, -0.12872894f, 0.00420207f, 0.19059698f, -0.14389947f, -0.00320649f, 0.09262230f, 0.09754495f, 
    0.33802018f, 0.03590720f, -0.25386572f, -0.02905649f, -0.07114984f, -0.12635450f, -0.09311653f, 0.03046867f, 
    -0.03986131f, -0.15332867f, -0.10529826f, -0.00248010f, 0.07427817f, 0.16090100f, -0.06067389f, 0.11658699f, 
    -0.00421233f, -0.04692335f, 0.01853813f, -0.15678813f, 0.08804280f, 0.01641702f, 0.10230587f, -0.05011371f, 
    -0.10026344f, -0.11891884f, -0.11383364f, -0.32930070f, -0.09691376f, -0.22746901f, -0.16021591f, 0.60172290f, 
    -0.22658245f, 0.06908430f, -0.03453082f, -0.00626879f, 0.11366723f, -0.02391982f, -0.12846813f, -0.07540414f, 
    0.09261597f, -0.16566071f, 0.02909013f, -0.12038799f, -0.06359553f, -0.15541428f, 0.02054030f, 0.16739601f, 
    -0.24827844f, 0.32586351f, 0.03819153f, -0.00330536f, -0.07646221f, -0.36012456f, 0.39362732f, -0.00037824f, 
    -0.33409342f, -0.10682134f, -0.44606301f, -0.00080845f, -0.03740605f, -0.04776116f, 0.10809208f, 0.20361087f, 
    0.10598885f, -0.02701135f, 0.03709061f, -0.16625167f, -0.20440337f, 0.05252823f, 0.24106972f, 0.05875491f, 
    -0.15976402f, -0.33818305f, 0.17000328f, 0.23222402f, 0.06517286f, 0.05501159f, 0.03126903f, -0.02170220f, 
    -0.16199058f, -0.11590638f, 0.04379437f, 0.33596456f, 0.10683545f, -0.05794334f, 0.02530703f, -0.25739104f, 
    0.08553510f, -0.00423819f, -0.06448819f, 0.21463151f, 0.46816552f, -0.17086315f, 0.03131836f, -0.05073979f, 
    0.01604696f, 0.09983387f, 0.13130383f, 0.03305316f, 0.08792754f, 0.42891467f, -0.12899749f, 0.12129235f, 
    -0.09813191f, -0.09146447f, -0.13763338f, -0.01177255f, 0.01994184f, -0.14724562f, 0.72578537f, -0.00353460f, 
    -0.10637422f, 0.15279809f, -0.13664338f, 0.02789258f, 0.01017970f, 0.30163208f, 0.03732174f, 0.17399140f, 
    -0.06321677f, -0.07621884f, 0.15195873f, -0.14578463f, -0.01622117f, -0.11856566f, 0.13319886f, 0.10231806f, 
    -0.47799754f, 0.23282853f, 0.41057974f, -0.21317263f, -0.04414323f, -0.04776652f, -0.04664004f, -0.07877179f, 
    -0.22189686f, 0.19442669f, -0.06787492f, 0.19725162f, 0.00939581f, 0.08677436f, -0.11651968f, 0.16205144f, 
    -0.06434093f, 0.25280806f, -0.47790489f, -0.03813444f, 0.01844895f, -0.01059344f, -0.06736454f, 0.02581912f, 
    -0.09026089f, 0.08091344f, -0.07136294f, 0.04925131f, -0.23516572f, 0.00496653f, 0.15360844f, 0.05464477f, 
    -0.01266830f, 0.17491838f, 0.21624814f, 0.10731485f, -0.12328158f, -0.04547630f, -0.12661649f, -0.29366472f, 
    0.17988741f, -0.10121243f, 0.15388869f, 0.12888980f, 0.01370802f, -0.08069330f, -0.35329089f, 0.22157577f, 
    0.06969697f, -0.16131298f, -0.11966921f, 0.04522336f, 0.10304902f, 0.23233187f, 0.14036863f, -0.02494354f, 
    -0.06070204f, 0.11616574f, -0.00495255f, -0.09748480f, 0.03447840f, 0.17752618f, 0.10591789f, 0.12348867f, 
    0.01270688f, -0.15041400f, -0.16622467f, -0.37760586f, 0.02888350f, 0.08526308f, 0.02098493f, -0.00185000f, 
    0.07972627f, -0.19653836f, 0.04820469f, -0.04347308f, -0.04734626f, -0.22644618f, 0.27491882f, -0.00670285f, 
    0.26821527f, 0.03649687f, -0.39194474f, -0.01615705f, -0.06108914f, -0.10780822f, -0.07989355f, 0.17499018f, 
    0.10880818f, 0.00817404f, 0.24175784f, -0.06894011f, 0.09327526f, 0.09554028f, 0.04466406f, -0.03443012f, 
    0.19118467f, 0.15305938f, -0.12725972f, -0.48113981f, -0.15332088f, -0.13263246f, -0.06824398f, -0.04476118f, 
    -0.04888234f, 0.04079302f, 0.20419376f, -0.10404278f, -0.09201384f, -0.04558562f, 0.16244636f, 0.17138934f, 
    -0.02012952f, 0.23911887f, 0.05585944f, -0.11617470f, 0.42592004f, 0.05730051f, -0.18372120f, -0.05758512f, 
    0.01933385f, -0.04447973f, -0.07910755f, -0.19556740f, 0.10643777f, 0.30623430f, -0.29605353f, -0.41728178f, 
    -0.13018107f, 0.04161818f, -0.14604867f, -0.21899092f, 0.07705437f, 0.08476391f, 0.09321050f, 0.27261692f, 
    -0.32461971f, -0.21206452f, -0.06530035f, 0.10259755f, 0.12974229f, 0.11175045f, 0.23735268f, 0.09996109f, 
    0.39361992f, 0.05453327f, -0.05954178f, 0.20206366f, -0.08853418f, -0.08413863f, 0.09646696f, 0.00271275f, 
    -0.12169484f, 0.05723868f, -0.23049089f, -0.24657464f, -0.13256095f, -0.13307464f, 0.00416115f, 0.03219068f, 
    0.24713032f, 0.17901875f, 0.08479247f, -0.01982141f, -0.02663955f, 0.06810933f, 0.09821925f, 0.01460802f, 
    -0.23065174f, 0.16706492f, -0.15499157f, 0.08572641f, 0.04038570f, 0.03127037f, -0.19649664f, -0.32756761f, 
    -0.16087887f, 0.04482661f, 0.00367847f, -0.05236649f, -0.05156869f, -0.08594519f, 0.09086100f, 0.07219791f, 
    0.07178579f, -0.01033850f, 0.03139028f, -0.24659561f, -0.23945977f, 0.14094691f, -0.02650995f, 0.15682928f, 
    -0.04510497f, -0.01477995f, -0.03291770f, 0.06890211f, 0.00666569f, 0.00060462f, -0.14072180f, 0.13546056f, 
    0.01414640f, 0.08628082f, -0.10768201f, -0.11475072f, -0.03490695f, 0.14228746f, 0.02013602f, 0.26723301f, 
    -0.04482652f, -0.11713505f, 0.06512427f, -0.12722054f, -0.19078270f, 0.08186743f, -0.36109528f, -0.01528450f, 
    -0.03010561f, -0.00914850f, 0.02880974f, 0.00176579f, -0.06001785f, 0.01129292f, 0.00882024f, -0.05349277f, 
    0.04686654f, -0.05935055f, 0.04609754f, 0.02258177f, -0.03639477f, -0.00714274f, 0.03534523f, 0.03472204f, 
    -0.03825735f, -0.03848264f, 0.02336718f, -0.05354204f, -0.03128668f, -0.05663247f, -0.05010734f, -0.04500718f, 
    0.04077042f, 0.05184060f, -0.03430296f, -0.05648964f, -0.06440692f, -0.03190769f, -0.00604174f, 0.01269972f, 
    -0.02740164f, 0.06038688f, -0.02176108f, -0.01527296f, 0.01060934f, 0.02790063f, -0.02209593f, 0.01028153f, 
    -0.02254503f, -0.05038899f, -0.00582650f, -0.05745511f, 0.03181907f, -0.05754559f, -0.01033486f, -0.06179640f, 
    0.04623960f, -0.05355000f, 0.02662504f, -0.04349300f, 0.05232669f, 0.04412258f, -0.05926700f, -0.05519423f, 
    0.03976592f, 0.00605655f, -0.02827433f, -0.03501614f, 0.02998012f, 0.01079694f, -0.04862138f, 0.03583588f, 
    -0.04732917f, 0.01524384f, 0.01994366f, -0.01514870f, -0.00767886f, -0.02970664f, -0.02332330f, 0.03620771f, 
    -0.01729664f, -0.05504075f, 0.02798164f, -0.06312294f, -0.03042465f, -0.05803300f, -0.01965967f, 0.00605306f, 
    -0.01301344f, -0.03161645f, 0.03471865f, -0.06241569f, -0.01574817f, 0.01080369f, -0.00674069f, 0.02530091f, 
    -0.03787591f, -0.03684347f, 0.00298773f, -0.02944714f, 0.03990372f, 0.00354322f, -0.02735309f, -0.05027011f, 
    0.05221222f, -0.00063994f, -0.02343272f, 0.04431292f, -0.01161191f, -0.02082622f, 0.04810658f, -0.02545699f, 
    -0.02476737f, 0.01601897f, -0.06055572f, -0.03079642f, -0.03031231f, -0.03107091f, 0.03957842f, -0.02358661f, 
    -0.04487309f, -0.03400980f, -0.05593136f, -0.03786783f, -0.00409089f, 0.03038328f, 0.04544996f, 0.01913584f, 
    -0.02088843f, -0.00671137f, 0.02593757f, -0.01732182f, -0.02925204f, 0.03083241f, -0.03480822f, -0.04527786f, 
    -0.04199142f, -0.04603769f, 0.01431610f, 0.00234301f, -0.01199695f, 0.02624363f, 0.00724860f, 0.00958892f, 
    0.03391892f, 0.03403888f, -0.06322004f, 0.00789418f, 0.03129001f, 0.04639214f, -0.00226662f, -0.04788277f, 
    -0.00967328f, 0.02135718f, -0.02069728f, -0.04807821f, 0.03108967f, 0.01937863f, -0.03827941f, -0.01120565f, 
    0.02788329f, -0.02082140f, -0.03830984f, -0.01598830f, -0.01347437f, -0.06323923f, 0.01486690f, 0.02602347f, 
    0.01904587f, -0.02633278f, -0.03485571f, -0.00487635f, 0.02935306f, -0.00849405f, -0.02714247f, 0.01243563f, 
    0.03245187f, -0.01419688f, -0.00771658f, 0.02175602f, -0.03778069f, 0.00618552f, -0.00392593f, -0.05517478f, 
    -0.01666365f, 0.03908482f, -0.01941737f, -0.02011772f, -0.02198748f, -0.02366604f, 0.00016784f, 0.00239948f, 
    -0.00101227f, -0.01695298f, 0.03743137f, 0.02854886f, 0.03846993f, -0.03655359f, -0.03300205f, 0.05204238f, 
    0.04000700f, -0.02725040f, 0.00024274f, -0.02881166f, -0.04747349f, -0.04588858f, 0.00159828f, -0.01209725f, 
    0.04237820f, 0.03570765f, -0.01803365f, 0.04428600f, -0.04266325f, -0.04422766f, -0.02465858f, 0.04422278f, 
    0.04652499f, 0.03160432f, 0.02255030f, -0.04042915f, -0.04947181f, -0.00643419f, 0.00279089f, -0.02503689f, 
    0.03085265f, -0.04182991f, -0.02821064f, -0.03575034f, 0.02588675f, -0.01745935f, 0.04639643f, -0.03571080f, 
    -0.02034833f, -0.04721770f, -0.04155963f, 0.01667972f, -0.03493359f, -0.00350740f, -0.01565668f, 0.03577108f, 
    -0.04525585f, 0.03195423f, 0.02490358f, -0.05232051f, 0.04093401f, 0.01824602f, -0.03866046f, -0.03571438f, 
    -0.04638652f, 0.03604661f, 0.03832845f, -0.03823994f, 0.00522882f, -0.03465756f, 0.02198187f, -0.06118540f, 
    0.01085429f, -0.05015625f, -0.02278380f, -0.04838963f, -0.00234750f, 0.01346317f, 0.01439995f, 0.02158666f, 
    -0.00844477f, -0.00023846f, 0.03982860f, -0.03435154f, -0.00194698f, 0.01453184f, 0.01076647f, -0.00358369f, 
    0.04560074f, -0.04803890f, -0.01181855f, -0.00062323f, -0.03169468f, -0.03231252f, 0.02980736f, -0.01996760f, 
    0.03529266f, -0.05411707f, 0.03383899f, -0.01969507f, 0.04391989f, -0.05308532f, 0.02245594f, 0.01950421f, 
    -0.02842157f, -0.03402288f, 0.02720933f, -0.04102625f, -0.06178674f, -0.05248920f, 0.02028982f, -0.03630552f, 
    -0.75977683f, 0.37588209f, 0.14645466f, 0.00097293f, 0.11066855f, 0.00576520f, 0.05937847f, 0.10362968f, 
    -0.18986125f, 0.02956063f, 0.09650741f, -0.05816711f, 0.16874860f, 0.06658646f, -0.05171038f, 0.10533923f, 
    0.21204679f, 0.22519006f, -0.00441568f, 0.13775674f, 0.02160030f, -0.05594401f, -0.04313121f, -0.08903287f, 
    0.17619731f, -0.03816570f, 0.28346938f, 0.02436909f, 0.18826678f, -0.07084917f, 0.06600372f, -0.10651962f, 
    0.22555405f, 0.12751251f, 0.04906993f, -0.03249789f, 0.50718969f, -0.19204991f, 0.10394154f, 0.15170477f, 
    0.10020645f, 0.21456063f, 0.14185239f, 0.09421400f, -0.09155025f, -0.05482799f, -0.11615205f, 0.17122415f, 
    -0.04003168f, 0.03060110f, 0.15923122f, -0.11901499f, -0.14140077f, -0.09035832f, 0.39761305f, -0.05478805f, 
    -0.27892485f, -0.06646163f, 0.06000859f, 0.23099183f, -0.01521954f, 0.00708161f, 0.01515439f, 0.22772849f, 
    0.03817665f, -0.02912382f, -0.02210403f, 0.01407580f, 0.08285358f, 0.02163243f, -0.05632689f, 0.02014294f, 
    -0.61301345f, -0.28558409f, 0.42358696f, 0.04846027f, 0.19287147f, 0.00371247f, -0.20888160f, -0.14442660f, 
    0.14998937f, -0.69219583f, -0.68857998f, 0.19015807f, 0.02574806f, 0.01165634f, -0.12678730f, -0.08088130f, 
    -0.10317965f, 0.06172770f, 0.17624728f, 0.30487028f, -0.44450140f, -0.07798140f, -0.00847114f, 0.05968761f, 
    0.10057115f, 0.03100093f, 0.46026450f, -0.05866532f, 0.15418452f, 0.11174459f, -0.12701720f, -0.00299052f, 
    0.00861618f, 0.00346912f, -0.05805266f, 0.05146287f, -0.40712935f, 0.15915646f, 0.11335999f, -0.16222136f, 
    0.25554574f, 0.02142242f, -0.00333724f, 0.04956440f, 0.02923346f, -0.39192551f, -0.54568332f, -0.48943925f, 
    0.02443990f, 0.24678123f, -0.02789138f, 0.10331059f, 0.18526441f, -0.31414425f, 0.26466635f, -0.08812107f, 
    0.03597156f, -0.00548117f, 0.19825800f, 0.05669993f, 0.06116212f, -0.03650314f, 0.04096489f, -0.08406585f, 
    -0.08623816f, -0.12022533f, -0.05673626f, -0.01573574f, 0.11353146f, 0.17978647f, -0.06945775f, 0.01543292f, 
    0.30626470f, -0.14530368f, -0.23592041f, 0.04429531f, 0.14951344f, 0.00813313f, -0.05259447f, -0.19148250f, 
    -0.14251341f, -0.57395905f, -0.19423826f, -0.18396512f, -0.13076746f, 0.06827161f, -0.03437715f, -0.03637858f, 
    0.02618109f, -0.07484988f, 0.75841987f, -0.18977912f, -0.34576195f, -0.02491864f, 0.09750351f, 0.11369346f, 
    0.01892925f, -0.01701877f, -0.00583713f, -0.47537845f, -0.41325769f, -1.07000470f, -0.23482066f, -0.02813903f, 
    -0.07196316f, 0.00080848f, -0.12965204f, 0.27384141f, -0.19796278f, -0.34250695f, -0.03038042f, 0.16710548f, 
    0.24515651f, 0.03427069f, 0.07131542f, -0.13277465f, 0.26269943f, 0.02620375f, 0.00943168f, -0.18641366f, 
    -0.01534164f, 0.08095057f, -0.02201235f, 0.06404418f, -0.05379112f, -0.02129223f, -0.30576503f, 0.09066310f, 
    -0.15299326f, 0.00575948f, -0.04434948f, -0.14939675f, -0.12347991f, 0.02765215f, -0.27914181f, 0.08321897f, 
    -0.00773746f, -0.07763594f, 0.05536697f, 0.27768442f, 0.01736236f, -0.06845412f, -0.02225239f, 0.10722872f, 
    0.15898666f, 0.31476900f, 0.08304953f, 0.01004328f, 0.06988675f, 0.18589003f, 0.10597511f, 0.02234319f, 
    0.30625960f, 0.14352347f, -0.46903017f, -0.10416965f, -0.01344959f, -0.01829483f, 0.04266335f, 0.21893549f, 
    -0.24875580f, -0.09218272f, 0.00535435f, 0.18203394f, -0.02757597f, -0.08850583f, 0.07055312f, 0.00741124f, 
    -0.02710367f, 0.19531722f, 0.20719102f, 0.02395424f, 0.15839358f, 0.11622058f, 0.05944794f, 0.02891946f, 
    0.02822141f, 0.14182527f, 0.06186888f, 0.03011090f, -0.20307775f, 0.09590067f, 0.09857520f, -0.00087967f, 
    0.23395012f, -0.00462069f, 0.11206974f, 0.05418004f, 0.28248841f, -0.70003283f, -0.34694812f, -0.05827864f, 
    -0.02584412f, 0.01070470f, -0.10857821f, -0.10996777f, -0.00077520f, 0.04204497f, -0.25240365f, 0.08207602f, 
    -0.12003373f, 0.01856679f, -0.02054968f, -0.04157085f, -0.07192446f, 0.06634805f, 0.04188574f, -0.26747248f, 
    0.15417154f, -0.00424741f, 0.04386279f, 0.00993176f, 0.19689901f, 0.23707941f, 0.09350239f, 0.19785939f, 
    0.00712376f, -0.03100174f, -0.05173966f, -0.04092028f, 0.01101319f, 0.01595313f, -0.05061833f, 0.04816361f, 
    -0.01796970f, -0.02151916f, -0.01836747f, 0.00664716f, -0.06669737f, -0.01967248f, 0.01383704f, 0.04047091f, 
    0.00379015f, 0.03622501f, -0.05095617f, 0.03365389f, 0.04630503f, -0.05512356f, -0.00257097f, -0.04075761f, 
    -0.04971140f, 0.01254627f, -0.05150180f, 0.01892751f, 0.03780420f, 0.00927845f, 0.01765424f, -0.03296098f, 
    0.04625563f, 0.01540316f, -0.05523734f, 0.04407271f, -0.01184837f, -0.04583817f, 0.02913800f, 0.00913995f, 
    -0.00220168f, -0.02544304f, 0.02384547f, -0.00308379f, -0.03854971f, -0.03434202f, 0.04601896f, -0.01022716f, 
    -0.04926750f, -0.05135591f, -0.02305057f, 0.00087175f, 0.00647383f, -0.00522880f, -0.06252132f, -0.06096481f, 
    0.04466724f, 0.02217390f, 0.01613210f, -0.02714767f, 0.03413662f, 0.00747339f, -0.05921621f, -0.01335744f, 
    0.03392787f, 0.04955209f, 0.03399895f, -0.05061376f, -0.00855621f, -0.04281444f, 0.00735971f, -0.04521721f, 
    0.04315688f, -0.00568669f, 0.02382722f, 0.04946032f, -0.06186387f, -0.06471850f, -0.02228043f, -0.06099544f, 
    -0.02584991f, -0.00749370f, 0.03030106f, 0.01418553f, 0.01616729f, -0.06521476f, -0.03226656f, -0.03767604f, 
    -0.03796998f, 0.02786361f, 0.02488791f, -0.04509982f, -0.04536698f, -0.03399833f, 0.01603619f, -0.04326591f, 
    0.03428296f, 0.02803917f, 0.00529701f, -0.05607958f, -0.05238329f, -0.02107839f, 0.03624752f, -0.03520841f, 
    0.04506889f, -0.02657895f, 0.02785549f, -0.01486315f, 0.01120407f, -0.06158266f, 0.00784318f, -0.04877520f, 
    0.01874134f, -0.04590071f, -0.01336784f, -0.02302497f, 0.04334228f, 0.01680613f, -0.04040945f, -0.05159883f, 
    0.00268424f, -0.03537054f, -0.04431719f, -0.05311843f, -0.00564648f, -0.03237205f, -0.04478839f, 0.00664125f, 
    -0.03218208f, -0.01948612f, 0.02262340f, -0.06302942f, -0.03236639f, -0.03397394f, -0.00204893f, 0.02263713f, 
    0.04406383f, 0.04387324f, -0.06187949f, 0.03764208f, -0.02376771f, -0.01864317f, 0.02963136f, -0.04581309f, 
    0.05015226f, -0.04034315f, -0.02164830f, 0.04700825f, 0.02956217f, 0.00700010f, 0.01973717f, -0.00502161f, 
    0.02220550f, -0.06146783f, -0.03832125f, -0.04525487f, 0.00593226f, -0.00676433f, 0.02644432f, -0.05410266f, 
    0.02777595f, -0.02403831f, -0.04746279f, 0.04693477f, -0.00281623f, 0.01444911f, 0.03037325f, 0.01528798f, 
    -0.02330651f, -0.03334335f, 0.01304619f, -0.03950257f, 0.01920328f, -0.03665152f, 0.00956586f, -0.00748043f, 
    -0.00884155f, 0.01083862f, 0.04846741f, -0.05299276f, -0.05367246f, -0.00462291f, -0.00423302f, 0.02494312f, 
    -0.06270486f, 0.03900960f, 0.03231305f, 0.03856441f, -0.03408353f, 0.00079720f, -0.06166185f, 0.00470101f, 
    -0.02874137f, 0.00628768f, -0.01838827f, -0.02265776f, -0.00363232f, -0.04455314f, 0.00227754f, -0.03843141f, 
    -0.03472842f, -0.02963126f, 0.04723404f, -0.03413942f, 0.02432931f, 0.02497662f, -0.02552250f, -0.01735448f, 
    -0.02376674f, -0.06606454f, 0.01126691f, -0.00780130f, -0.06598829f, 0.01069633f, -0.00746974f, -0.06297294f, 
    0.01543563f, 0.04952333f, -0.05372856f, -0.05019897f, 0.01626625f, -0.06070596f, 0.04978406f, -0.01044810f, 
    -0.05556086f, -0.06715785f, 0.00252445f, -0.01231148f, -0.03146071f, -0.06560675f, -0.05280519f, 0.04855599f, 
    -0.00082014f, -0.03528018f, -0.03129281f, 0.04750431f, -0.03520554f, -0.02467185f, -0.06329577f, 0.01847044f, 
    0.04260105f, -0.00896475f, -0.06588584f, -0.02707595f, 0.02374322f, -0.01767138f, -0.02108689f, 0.03266018f, 
    -0.04402617f, 0.04984934f, -0.06265812f, 0.03389148f, 0.01976515f, -0.05393254f, -0.04107145f, -0.01673322f, 
    0.00643523f, -0.05548717f, -0.01134749f, -0.01537768f, 0.00057807f, 0.02512055f, -0.04031113f, 0.02262299f, 
    -0.02455943f, 0.00593435f, 0.01960687f, -0.00851042f, 0.03250801f, 0.03010867f, 0.02394597f, 0.00981658f, 
    -0.03858730f, 0.03240826f, -0.04361765f, 0.01981503f, 0.01831372f, -0.03913285f, 0.00557977f, -0.04509657f, 
    -0.00409248f, -0.01553958f, -0.02268982f, 0.02735008f, 0.03805767f, -0.04101474f, -0.05556487f, 0.00862517f, 
    -0.13944450f, 0.09677301f, -0.10827771f, 0.04453531f, -0.08080293f, 0.07775306f, 0.00240640f, -0.01871296f, 
    0.04890128f, -0.13859659f, -0.25651124f, -0.28339979f, 0.16633332f, -0.36618918f, -0.10045116f, -0.12748733f, 
    0.11312306f, -0.19424196f, 0.16838509f, -0.03293016f, -0.10435370f, -0.41965133f, -0.07377084f, 0.01921892f, 
    -0.04226003f, -0.22275442f, 0.08447503f, -0.19002320f, -0.17570785f, -0.16321626f, -0.07225281f, -0.07362051f, 
    0.18463491f, 0.01706262f, 0.05777771f, 0.00430260f, 0.23712142f, -0.17091374f, 0.03921330f, 0.04831196f, 
    0.28217232f, 0.16517547f, 0.33452380f, 0.06786943f, 0.03747778f, -0.07636885f, -0.21184242f, 0.25211185f, 
    -0.17837642f, 0.02611672f, -0.18750212f, -0.16895059f, 0.23293217f, -0.00586957f, 0.12183879f, -0.26690522f, 
    -0.40296862f, -0.15429136f, 0.20387028f, 0.22907680f, -0.16289839f, 0.13446915f, 0.14940947f, -0.14875603f, 
    -0.21953990f, -0.06912868f, -0.09939256f, 0.19035088f, -0.02379037f, 0.15955016f, -0.02066329f, 0.15671031f, 
    -0.42863691f, -0.11887757f, 0.45060188f, 0.03632268f, 0.00470494f, -0.11588623f, 0.04838404f, -0.06537515f, 
    -0.02550069f, -0.13341638f, -0.04577708f, 0.36986917f, -0.12699451f, 0.18076305f, 0.20016654f, -0.04359068f, 
    -0.11698929f, 0.11909521f, -0.10541166f, -0.17512378f, 0.13111095f, 0.08781068f, 0.05254471f, 0.04131585f, 
    0.08129983f, -0.04163950f, -0.33036315f, -0.08188713f, 0.11573838f, 0.25665504f, -0.09667320f, 0.15679881f, 
    0.00183215f, 0.24033281f, 0.04368401f, -0.04805071f, -0.15663671f, 0.18289989f, 0.03726746f, -0.01563098f, 
    -0.04776701f, 0.22527106f, 0.10457323f, -0.04563129f, -0.08809988f, -0.36579674f, 0.05722505f, 0.31269601f, 
    -0.11167078f, 0.07556014f, 0.15290314f, -0.08001050f, -0.11369735f, 0.21206608f, 0.26603726f, -0.32219681f, 
    0.09950487f, -0.14468813f, 0.28670028f, 0.08729087f, 0.00013988f, 0.08781657f, -0.06503133f, -0.20064184f, 
    -0.08788792f, -0.24363963f, -0.01566703f, -0.05061005f, -0.27775541f, 0.10285113f, -0.12697043f, 0.04224873f, 
    -0.08668776f, -0.45715719f, 0.19764616f, -0.12931211f, 0.03434276f, 0.20866953f, -0.02861709f, 0.11080436f, 
    0.22549698f, -0.23798123f, 0.19806568f, 0.21745890f, 0.11797445f, 0.07918623f, -0.13595340f, -0.00656647f, 
    0.05267984f, -0.02907118f, 0.17508456f, -0.33923852f, -0.17062850f, 0.30157587f, 0.07670767f, 0.09446277f, 
    -0.08007660f, 0.05208803f, 0.18622813f, 0.13269988f, -0.30244249f, 0.01078801f, -0.05788915f, 0.11576364f, 
    0.03139778f, -0.05241578f, 0.19224225f, -0.12653370f, -0.28966701f, -0.01279748f, 0.21313375f, 0.13132450f, 
    0.11306605f, 0.05706568f, 0.28000084f, -0.05382414f, 0.02016693f, -0.22978814f, -0.18095127f, 0.09163318f, 
    -0.25217637f, -0.07622860f, 0.00222331f, 0.00373865f, -0.31560463f, 0.17035641f, -0.16612872f, 0.18975067f, 
    0.10193989f, 0.08785157f, -0.15092765f, 0.03904923f, 0.03940219f, 0.00984092f, 0.34975415f, -0.14198740f, 
    -0.26498649f, -0.16293958f, -0.00911376f, 0.09660596f, 0.02246061f, 0.13373917f, 0.03778546f, 0.17221443f, 
    0.29255307f, 0.15952143f, 0.02386595f, 0.03523117f, 0.04709240f, 0.19708289f, 0.10927558f, -0.00234057f, 
    0.12863965f, 0.25563478f, -0.05163499f, -0.24097833f, -0.03020414f, 0.13605841f, 0.24859539f, -0.02777385f, 
    0.10289843f, -0.06385215f, 0.08402022f, 0.20796360f, -0.37555096f, -0.13877578f, -0.04469949f, -0.12100994f, 
    0.27374300f, -0.12358312f, -0.17319907f, -0.30832407f, -0.10035870f, -0.09679419f, -0.00270743f, -0.12275054f, 
    -0.23311946f, 0.00149961f, -0.07530328f, 0.04920729f, -0.36126676f, 0.19802567f, 0.10300703f, 0.02633858f, 
    -0.16980046f, -0.21013790f, 0.13382837f, 0.00142814f, 0.06237439f, -0.23025346f, 0.04800687f, 0.18262979f, 
    -0.08081871f, 0.03388435f, -0.17786634f, -0.05314942f, 0.09342240f, 0.01293245f, -0.15906587f, -0.08303676f, 
    0.04370902f, 0.03000907f, -0.07936211f, -0.24660671f, -0.11385766f, 0.06472221f, -0.08370849f, 0.61828452f, 
    -0.01163006f, -0.01593082f, 0.12716600f, 0.15421207f, -0.01045996f, -0.10137963f, -0.14263090f, 0.07813418f, 
    -0.04046131f, 0.17802194f, 0.21015947f, 0.27891776f, 0.13230489f, 0.01333974f, -0.18890670f, -0.08120161f, 
    -0.25996518f, -0.03621301f, 0.17389373f, -0.18228473f, 0.16141710f, 0.18226969f, 0.03069980f, 0.18489538f, 
    0.16797212f, 0.21390606f, 0.06491622f, 0.41982508f, -0.06996110f, 0.00007141f, -0.00624402f, 0.13464603f, 
    0.26777649f, 0.07828593f, 0.02338528f, 0.06328180f, -0.03209764f, 0.12708829f, -0.00701595f, 0.03245768f, 
    -0.04660471f, 0.00741510f, 0.08049869f, -0.20047894f, -0.30041644f, 0.10551888f, -0.07797032f, -0.15640204f, 
    -0.05020999f, 0.02536708f, 0.45473632f, -0.08190744f, -0.06751744f, 0.02408343f, 0.30234289f, 0.00384784f, 
    0.24958953f, -0.07348844f, 0.02701973f, 0.23200722f, -0.08070756f, 0.00561337f, -0.18278654f, 0.18852058f, 
    0.05607433f, 0.09912508f, 0.11647735f, -0.17548312f, 0.21242681f, -0.09336772f, -0.22399788f, -0.07391546f, 
    0.10459500f, 0.01614228f, 0.02782163f, -0.10083590f, -0.07435414f, 0.05110157f, -0.35673082f, -0.32255596f, 
    0.04467916f, -0.14439453f, 0.38932618f, 0.03232155f, 0.00050370f, 0.08550916f, 0.37712383f, 0.23416653f, 
    0.11309185f, -0.24112800f, -0.01519274f, 0.18445249f, 0.14557308f, 0.25613180f, 0.26544127f, -0.04663454f, 
    -0.13523014f, 0.00142789f, 0.28438509f, 0.02589832f, 0.07997752f, 0.31911543f, 0.24346519f, 0.29542279f, 
    0.12112471f, 0.09852292f, 0.07130814f, -0.01119814f, -0.04791949f, -0.01204165f, 0.06388602f, 0.04467700f, 
    0.03252084f, -0.42793366f, -0.35902339f, -0.43180439f, 0.08382666f, 0.05961713f, -0.02853126f, 0.12585674f, 
    -0.02378294f, 0.11679728f, -0.17981321f, -0.28378674f, 0.07041483f, -0.09230646f, -0.22322430f, -0.19500738f, 
    -0.04538791f, -0.26320723f, 0.11095390f, -0.21487717f, -0.16641644f, -0.16230522f, 0.22718544f, 0.37733123f, 
    -0.15810119f, -0.15432374f, -0.06329186f, 0.05828435f, 0.09308013f, 0.01850119f, -0.00255964f, -0.08363185f, 
    -0.16251965f, -0.05632052f, 0.20673782f, 0.01658109f, 0.19205618f, -0.27991256f, 0.02115755f, -0.30986470f, 
    0.28725117f, 0.29137692f, 0.00641649f, -0.23851067f, -0.19313382f, -0.16009764f, 0.08609444f, -0.19639495f, 
    -0.14866182f, 0.01457993f, 0.02511229f, -0.05337603f, 0.11659603f, 0.08414569f, -0.01033119f, 0.03151760f, 
    -0.09513155f, -0.21849912f, -0.11505924f, 0.30134931f, -0.13271117f, -0.24952057f, -0.13602084f, -0.20196067f, 
    0.03743530f, -0.58927703f, -0.20144950f, -0.03001863f, -0.08101093f, -0.04456653f, 0.32061183f, 0.37215883f, 
    0.02538226f, -0.06636435f, -0.10082502f, 0.06745315f, 0.07067239f, -0.10546202f, -0.24100344f, -0.00088938f, 
    0.05836492f, 0.13125740f, 0.15236235f, -0.04765674f, -0.13803805f, 0.43836766f, -0.02264979f, -0.08159815f, 
    0.13640830f, 0.00877242f, 0.17079966f, 0.11400520f, -0.05928104f, 0.08783413f, -0.11143928f, 0.15405864f, 
    -0.02158096f, 0.17418905f, 0.12975483f, -0.12218852f, -0.65540403f, -0.46210304f, -0.18941212f, -0.05366190f, 
    0.25634533f, -0.00214028f, 0.09603254f, 0.31281507f, 0.16670789f, 0.35426089f, 0.20782800f, -0.27677369f, 
    0.00831368f, 0.28823870f, 0.00339681f, 0.04802408f, 0.07086220f, -0.08020389f, 0.13263203f, -0.13490193f, 
    -0.21357121f, 0.19949250f, -0.09582160f, 0.00991450f, 0.30932927f, -0.13501546f, 0.05714674f, -0.01040280f, 
    -0.29957619f, -0.20801614f, -0.05461755f, 0.04547708f, -0.36063409f, 0.33326712f, 0.09792118f, 0.05962948f, 
    0.12994115f, 0.22283694f, 0.04778827f, 0.05273489f, 0.07626186f, -0.09438292f, 0.05916733f, 0.18601790f, 
    0.08124768f, -0.03633310f, 0.10165459f, 0.03795133f, -0.36022332f, -0.09436692f, 0.16786145f, 0.36431718f, 
    0.07826146f, 0.08176785f, -0.06150146f, 0.18061784f, 0.17093211f, 0.05293646f, -0.05457988f, 0.20175658f, 
    0.04890027f, 0.31166616f, 0.08512785f, 0.08675210f, -0.08372726f, 0.03124009f, -0.05104951f, -0.23181655f, 
    0.00802205f, 0.22041495f, 0.11702824f, 0.23265029f, 0.20366351f, -0.20823716f, -0.30700871f, -0.23118743f, 
    -0.01028803f, 0.31322458f, -0.01863166f, 0.22753581f, 0.18609548f, 0.24574421f, -0.06965110f, 0.18490742f, 
    -0.39813000f, 0.37322718f, 0.19144855f, -0.01433207f, 0.25716081f, -0.01070572f, -0.27758834f, -0.18457930f, 
    -0.15028533f, -0.01934956f, 0.18839079f, -0.13078469f, 0.08844934f, 0.00571245f, -0.01091684f, 0.03436182f, 
    0.07180157f, 0.33704260f, -0.34568334f, 0.06318803f, -0.08694868f, 0.21504340f, -0.05568486f, -0.15508577f, 
    0.09260492f, 0.09967250f, 0.13485423f, -0.22901776f, -0.06541340f, -0.47708344f, 0.18740079f, -0.21313155f, 
    -0.14807901f, -0.04084957f, 0.14663808f, 0.18092048f, 0.25593969f, 0.13897480f, -0.13728608f, -0.17036033f, 
    -0.19691065f, -0.04956246f, 0.15868275f, 0.12052163f, -0.03631638f, 0.34259006f, -0.24931854f, 0.06109021f, 
    -0.26790226f, 0.20592549f, -0.04038283f, -0.00565449f, -0.25409791f, 0.08767314f, -0.09827510f, -0.57729155f, 
    -0.76720613f, 0.04606804f, -0.31968114f, -0.07433495f, 0.04609688f, 0.31581506f, 0.08625901f, 0.30067900f, 
    -0.14337061f, -0.50839758f, -0.09754845f, -0.02691497f, 0.21741614f, 0.14906906f, 0.17347835f, -0.03261393f, 
    -0.63042384f, -0.07079221f, 0.17188922f, 0.17178491f, -0.22314790f, 0.06665752f, 0.01914209f, 0.26133120f, 
    0.02918962f, 0.17863347f, 0.06830017f, 0.21542937f, 0.00985027f, -0.03409259f, 0.09117471f, -0.07057221f, 
    0.07437738f, -0.03965078f, 0.20948415f, 0.03658015f, 0.44053650f, -0.02079775f, -0.03394899f, 0.17299132f, 
    0.00222414f, -0.06269996f, 0.13786419f, 0.09772812f, -0.01649746f, -0.00165733f, -0.08768503f, -0.20053065f, 
    -0.01220376f, 0.01245157f, 0.10943422f, 0.14928493f, -0.05984024f, -0.36901045f, 0.02885272f, 0.19170628f, 
    -0.12276423f, -0.17345162f, -0.21169703f, 0.10370243f, 0.20807044f, 0.33333087f, -0.06622759f, 0.26211351f, 
    0.00213524f, 0.06976478f, 0.12845010f, -0.09982008f, -0.42047554f, -0.07509378f, -0.09396563f, -0.48781630f, 
    0.18010688f, -0.05129423f, 0.02381118f, -0.23745911f, 0.09089831f, 0.08059971f, 0.09430455f, 0.02242745f, 
    -0.08364645f, 0.13422745f, -0.06166497f, -0.12365087f, 0.16467944f, -0.15405875f, 0.02725156f, 0.24946792f, 
    -0.18099163f, 0.14376986f, 0.44890404f, -0.00942741f, -0.13304970f, 0.08921025f, -0.10242073f, -0.16262318f, 
    -0.19066441f, 0.17207031f, -0.19143924f, 0.19619404f, 0.32290366f, -0.00339384f, 0.08904314f, -0.07141636f, 
    -0.08717270f, -0.06263538f, 0.29519093f, -0.45764166f, -0.12835182f, -0.10472400f, -0.22990963f, -0.00640392f, 
    -0.19564357f, 0.02932265f, -0.02435824f, 0.26540577f, 0.12759030f, 0.28059876f, -0.08226128f, -0.10842127f, 
    0.03935261f, -0.02855339f, -0.06480359f, 0.01532211f, 0.10649335f, 0.20853132f, 0.10614357f, 0.03087485f, 
    -0.04188927f, 0.08725878f, -0.07808314f, 0.01362650f, -0.14629486f, -0.11255226f, 0.04241620f, 0.17595053f, 
    0.04718674f, 0.08882460f, 0.39567685f, -0.09069138f, -0.06513875f, -0.08423898f, -0.19125436f, 0.35361746f, 
    0.15606342f, 0.00272645f, 0.04719647f, 0.06807974f, 0.00380576f, -0.15157495f, -0.43083492f, 0.25239766f, 
    -0.58652645f, -0.11819971f, 0.15186085f, 0.05158231f, 0.03982476f, -0.08388584f, -0.01188332f, 0.14696451f, 
    -0.19586335f, 0.09165049f, -0.12160717f, 0.14609070f, -0.02275721f, -0.28892553f, 0.00875229f, 0.07913675f, 
    -0.14384231f, 0.21052240f, 0.23369890f, -0.52559143f, 0.26741055f, 0.17008558f, -0.08561497f, 0.16387935f, 
    -0.20218921f, 0.32636458f, 0.52848691f, -0.13857222f, 0.12453965f, 0.15322171f, 0.04954139f, 0.08330991f, 
    -0.03852767f, 0.02537349f, 0.23823550f, -0.18715996f, 0.09977873f, -0.03537862f, 0.13457473f, 0.06042518f, 
    -0.02793051f, 0.11391940f, 0.02766714f, 0.25467405f, -0.08650148f, 0.12214620f, 0.06869323f, -0.03821622f, 
    0.09613720f, 0.14663869f, -0.00031626f, 0.07852443f, 0.18717842f, -0.13908109f, 0.10228383f, 0.23145786f, 
    0.09821916f, -0.01529558f, -0.06271739f, 0.02479329f, 0.07667717f, -0.20114033f, -0.17719427f, 0.21673022f, 
    -0.24703494f, -0.09846359f, -0.14841299f, 0.23100385f, 0.21681541f, 0.06341624f, 0.06576611f, -0.84126222f, 
    0.14819515f, -0.24407178f, 0.09865016f, 0.01777719f, -0.17993762f, 0.00684449f, -0.04651752f, -0.02184541f, 
    0.27104548f, -0.06804232f, 0.01999118f, -0.20692466f, -0.33706501f, 0.14829008f, 0.08002816f, -0.17906317f, 
    -0.14365058f, -0.18925311f, 0.17391363f, 0.36652485f, 0.03027653f, 0.09541772f, -0.22497156f, -0.19191895f, 
    0.15407847f, 0.08419591f, -0.01916005f, -0.34636992f, 0.08535438f, -0.05023490f, -0.21533768f, -0.08253744f, 
    0.08476446f, 0.00039284f, 0.12000985f, -0.08627462f, 0.00238540f, 0.11212369f, 0.16468728f, 0.17814708f, 
    0.22014213f, 0.15893750f, -0.09468920f, -0.18695687f, 0.00851297f, -0.00457963f, -0.15541482f, 0.01733852f, 
    0.26165783f, -0.08178145f, 0.18742312f, 0.04708522f, -0.15780196f, 0.26019081f, -0.29998702f, -0.29772872f, 
    0.13265356f, 0.16235782f, -0.06903121f, 0.02827839f, -0.16572128f, -0.11462206f, -0.15103796f, -0.14958774f, 
    -0.06124593f, -0.04581027f, 0.26513612f, 0.37285268f, 0.01549145f, -0.12657095f, -0.04764180f, 0.05176739f, 
    0.03092065f, -0.05158631f, -0.12848724f, 0.06166459f, 0.06030779f, -0.06186983f, -0.02473669f, -0.17418288f, 
    -0.61719137f, 0.09415998f, 0.05016622f, -0.21337593f, 0.31327134f, 0.00636059f, -0.02428875f, 0.11837197f, 
    0.20633367f, -0.36237738f, 0.40566891f, 0.02037376f, -0.13723576f, -0.12070907f, -0.28878403f, -0.04806034f, 
    -0.09139910f, 0.10856212f, -0.45942852f, 0.24541660f, 0.16468400f, -0.13520639f, -0.06691965f, 0.03391903f, 
    -0.00003017f, 0.20386192f, -0.02932058f, 0.07659751f, 0.14657161f, 0.12168743f, -0.04245543f, -0.12704587f, 
    0.01156169f, -0.06767193f, -0.02380531f, 0.08168087f, -0.05732024f, 0.23168087f, -0.00914699f, 0.05457421f, 
    -0.09522538f, -0.04837920f, 0.16353947f, 0.04222658f, 0.04533204f, -0.34327185f, -0.07685577f, -0.38237917f, 
    -0.23352087f, 0.00121386f, -0.17069723f, 0.12008709f, -0.16240038f, 0.29845384f, -0.11186090f, -0.05577696f, 
    -0.26421323f, -0.05526686f, 0.14769484f, -0.00606350f, 0.00105415f, -0.00816821f, 0.04974245f, -0.00239365f, 
    -0.15695061f, -0.10145863f, 0.06215352f, 0.01070130f, -0.09871368f, 0.16604069f, 0.03087629f, 0.27971229f, 
    0.15727223f, -0.18454106f, -0.31518883f, -0.41975689f, 0.16512489f, 0.04112243f, -0.02234164f, -0.13180196f, 
    -0.01246781f, 0.01445197f, 0.29987666f, 0.03140621f, 0.11172788f, -0.08679759f, -0.12714288f, 0.10735415f, 
    0.05524438f, -0.01554335f, -0.30484778f, 0.15821199f, -0.06166795f, -0.09586377f, 0.05534104f, -0.01109889f, 
    -0.12656529f, -0.24564922f, -0.14069359f, -0.30403262f, -0.09790098f, 0.18135265f, -0.15823776f, 0.16478173f, 
    -0.08895715f, 0.07428139f, -0.06011100f, 0.03882469f, -0.51871008f, 0.31968281f, 0.50433952f, 0.01391689f, 
    -0.03184372f, -0.01370579f, -0.07294714f, 0.04074731f, 0.26784080f, -0.58056623f, 0.19588444f, -0.05302165f, 
    0.23940638f, -0.17543770f, -0.21423237f, 0.01413743f, 0.18988398f, 0.29357371f, 0.19459563f, 0.21112347f, 
    -0.07530514f, -0.29274216f, -0.37581781f, -0.19341238f, 0.02518960f, -0.21324040f, -0.23251845f, -0.30057725f, 
    0.32944518f, 0.17284206f, 0.01065416f, 0.12022354f, -0.08548307f, -0.06940373f, 0.11512130f, 0.04327178f, 
    0.03126499f, -0.04486204f, -0.04126256f, 0.05986979f, -0.06088470f, 0.11970394f, -0.01002116f, 0.18141142f, 
    0.03016913f, -0.03450789f, -0.04779732f, -0.10833213f, 0.00863464f, 0.05168188f, 0.19225876f, 0.05167959f, 
    -0.15178768f, 0.08724673f, 0.00824236f, 0.12485240f, -0.20896576f, 0.05051871f, -0.05269633f, -0.06591152f, 
    0.13072887f, -0.03791001f, 0.08274414f, -0.07831348f, -0.09639988f, 0.19233204f, 0.05767350f, -0.03075803f, 
    -0.17961226f, 0.12947001f, -0.06721245f, 0.09021724f, 0.16495900f, 0.06492536f, -0.35184813f, -0.06069320f, 
    0.11079650f, -0.01630401f, 0.35049129f, 0.19096372f, 0.46802655f, -0.18839328f, -0.00524560f, 0.08815449f, 
    0.26785222f, 0.05225622f, -0.05533534f, -0.07380781f, -0.05771514f, -0.02041356f, 0.01887593f, -0.15245615f, 
    0.00890479f, 0.14173549f, -0.15573137f, -0.00407629f, 0.03231629f, -0.00472755f, 0.03263411f, 0.16167314f, 
    0.03397252f, 0.22529694f, 0.26110071f, -0.01609446f, 0.09951040f, 0.04415135f, 0.01949101f, 0.08605616f, 
    -0.02301772f, -0.00516308f, -0.02879223f, 0.04873063f, -0.00794213f, -0.05841361f, -0.00632064f, 0.02410422f, 
    0.04443960f, -0.03503630f, -0.06353008f, -0.03422386f, -0.05574582f, 0.05134450f, 0.01311165f, 0.05076000f, 
    -0.02598046f, -0.05715370f, -0.04105829f, -0.03446327f, 0.03581134f, -0.02746042f, -0.01563905f, -0.04846375f, 
    -0.00581605f, -0.02955300f, -0.06077049f, -0.02368792f, -0.03774412f, 0.01133415f, -0.03736634f, 0.01913055f, 
    -0.04002278f, -0.06041985f, 0.00167281f, 0.00649544f, 0.02804754f, -0.03759065f, -0.06001665f, -0.05086263f, 
    0.02168410f, 0.02458473f, 0.05317778f, -0.03145228f, -0.06432077f, 0.02248552f, 0.04855983f, -0.02318773f, 
    -0.04325315f, 0.01529883f, 0.02061641f, 0.04017425f, -0.05453178f, -0.02885053f, -0.05763485f, 0.03128002f, 
    0.02431838f, 0.01254360f, -0.05611125f, 0.01926663f, -0.02515132f, 0.00726000f, -0.02040247f, -0.06219782f, 
    -0.04103021f, -0.02456073f, -0.00582544f, 0.01269891f, -0.03191121f, 0.01542457f, 0.03184250f, -0.02378989f, 
    0.04841861f, 0.02572474f, -0.05213826f, 0.02953856f, -0.00876384f, -0.00074828f, -0.04666343f, -0.02708939f, 
    -0.04993395f, -0.03253394f, -0.02136912f, 0.02626617f, 0.04759438f, 0.01449236f, -0.00514209f, 0.02427584f, 
    -0.05178668f, -0.04300598f, 0.00149644f, -0.03253992f, 0.05977365f, 0.01658545f, -0.00627661f, -0.03067230f, 
    -0.02155827f, -0.02475430f, -0.05296216f, -0.00381111f, 0.00812584f, 0.03076581f, -0.05327614f, 0.00177905f, 
    -0.04790316f, 0.02003000f, 0.03741742f, -0.00852817f, -0.01242631f, 0.04460999f, -0.00828319f, 0.00567380f, 
    -0.03336311f, 0.01047643f, 0.03522619f, -0.04937444f, -0.05997149f, -0.05597960f, 0.02621688f, 0.04394533f, 
    0.00371958f, -0.04814818f, 0.03987050f, 0.05066118f, -0.01492378f, -0.00045029f, -0.00910478f, -0.05903590f, 
    -0.03816790f, 0.02579167f, -0.05571039f, 0.03815190f, 0.02612998f, -0.03987101f, -0.03830499f, -0.04295342f, 
    -0.06285464f, 0.04312520f, -0.03295784f, 0.00238400f, -0.03551712f, 0.04100547f, 0.02015003f, 0.00052762f, 
    -0.05205263f, 0.06052495f, -0.04279967f, 0.04098688f, 0.02679028f, 0.00906436f, 0.01924586f, -0.05953864f, 
    -0.01674714f, -0.06697341f, -0.01483495f, -0.06773239f, -0.04124244f, -0.03045334f, -0.06522416f, 0.04227388f, 
    0.04369071f, -0.02623290f, -0.04073110f, 0.02965301f, -0.03262826f, -0.01881544f, -0.06551413f, -0.02902445f, 
    0.03851435f, -0.06090020f, 0.04416827f, -0.02555255f, 0.04375218f, -0.01569813f, 0.00834545f, -0.04728875f, 
    0.00651438f, 0.01639690f, 0.05055551f, -0.03845651f, 0.01307677f, -0.03264777f, 0.00269133f, -0.04832048f, 
    0.04758385f, -0.05107900f, -0.02873114f, 0.00897374f, 0.02597579f, 0.01375196f, 0.05474097f, 0.05154328f, 
    0.04623633f, 0.03755549f, -0.03578429f, 0.01834743f, 0.05909324f, 0.04240401f, -0.05295443f, 0.03287219f, 
    -0.02051820f, 0.00741923f, -0.04894755f, 0.02879315f, -0.03023973f, 0.04439282f, -0.01188691f, 0.04980957f, 
    0.00271431f, 0.01516068f, 0.04816185f, -0.05290726f, -0.01170613f, 0.02100449f, 0.02995742f, -0.05159442f, 
    -0.02673163f, -0.04829464f, -0.01755419f, 0.04960878f, 0.03152962f, 0.01943301f, -0.03447068f, 0.02608958f, 
    -0.05387058f, -0.05288674f, -0.02345061f, -0.01870288f, 0.02097603f, -0.05925575f, -0.00489853f, -0.02290296f, 
    0.00880199f, 0.02714297f, 0.01368132f, 0.04129552f, -0.01563938f, 0.02473478f, -0.05463949f, -0.01678771f, 
    -0.04391938f, -0.02810575f, -0.04330419f, 0.02959079f, -0.01391968f, 0.05025682f, 0.00062444f, 0.03435995f, 
    -0.05493427f, -0.04347899f, 0.01765580f, -0.02125904f, 0.01576731f, -0.02671682f, 0.04775364f, -0.04354613f, 
    -0.02120424f, 0.03419867f, 0.03710525f, -0.01221139f, 0.01439890f, 0.01939455f, 0.04045483f, -0.05547430f, 
    -0.05546685f, -0.01183462f, -0.06470509f, 0.01587523f, 0.00728221f, 0.02274826f, -0.00500134f, -0.01422475f, 
    0.02954341f, 0.02388493f, 0.00069543f, 0.00180752f, 0.01473320f, 0.04937386f, 0.00910839f, -0.06023404f, 
    0.02089506f, 0.01220081f, -0.05446034f, 0.02813001f, -0.00300809f, 0.03021979f, -0.01713542f, 0.02758583f, 
    0.39885178f, 0.23497181f, -0.24879774f, 0.23687573f, 0.14622355f, 0.06079903f, 0.11496207f, -0.20765524f, 
    -0.04088000f, -0.01252460f, 0.27921262f, 0.06870601f, 0.09241576f, 0.00948268f, -0.08239281f, 0.27476129f, 
    -0.03070420f, 0.07045627f, 0.18101801f, -0.00235860f, 0.04267469f, 0.14267837f, 0.00873195f, -0.17551808f, 
    -0.01676119f, 0.19254814f, 0.13041107f, 0.28834090f, -0.03519476f, -0.00529336f, 0.06149276f, 0.09997879f, 
    0.02575907f, -0.18906060f, -0.12222541f, -0.11436879f, -0.04165213f, 0.05536023f, -0.28207546f, -0.12714903f, 
    0.11186827f, 0.21207902f, 0.37467748f, 0.01812330f, 0.02940756f, 0.24650683f, 0.07161313f, -0.27482209f, 
    -0.03980035f, 0.12748119f, 0.11841759f, 0.04791404f, -0.17569831f, 0.07519604f, 0.15275201f, -0.17997138f, 
    -0.18156743f, -0.03060823f, 0.19482714f, -0.03557166f, 0.01301855f, -0.06653180f, -0.16015084f, 0.14312138f, 
    0.04371348f, -0.18581071f, 0.00682942f, 0.11339214f, 0.09718587f, 0.16238835f, -0.07336193f, -0.18838222f, 
    -0.02563166f, -0.35501021f, -0.73581696f, -0.02651786f, -0.43035236f, -0.14676970f, 0.08596833f, 0.07944329f, 
    0.04967388f, -0.33819288f, -0.57648051f, -0.40538853f, 0.18394099f, 0.14648154f, 0.00569709f, 0.01436298f, 
    -0.00115736f, 0.03383788f, -0.11884099f, 0.00983805f, 0.01995530f, 0.13925388f, 0.03331869f, -0.09734146f, 
    -0.11915959f, -0.07582223f, 0.04939760f, 0.03893265f, 0.08058499f, -0.29352850f, 0.12808700f, 0.02435284f, 
    -0.07240991f, 0.02857886f, -0.04512919f, 0.05577480f, -0.02111940f, -0.05573106f, -0.15009235f, -0.14652941f, 
    -0.14410011f, -0.11170782f, 0.03491872f, -0.04129332f, 0.02635257f, -0.40643701f, 0.01808967f, 0.19588928f, 
    -0.04512631f, -0.03131300f, -0.20871542f, -0.18287817f, 0.08209646f, 0.09228092f, 0.25168800f, -0.00669911f, 
    0.04908239f, 0.04868007f, 0.06645632f, -0.09810569f, 0.07057758f, 0.05567150f, 0.05044048f, 0.14677054f, 
    0.18004709f, 0.03065795f, -0.13191272f, -0.11009520f, -0.09361635f, -0.11996318f, -0.15490629f, -0.23942855f, 
    0.33196476f, 0.09175208f, -0.18227001f, -0.06180455f, 0.02684818f, -0.10239866f, -0.02553225f, -0.00043793f, 
    -0.11880200f, -0.38004249f, 0.14488205f, -0.17235619f, 0.17404126f, 0.13819754f, -0.02132328f, -0.05654772f, 
    -0.10200708f, 0.02518518f, -0.14436886f, -0.09640097f, -0.13613005f, -0.05711970f, 0.20324275f, -0.00269719f, 
    -0.00782254f, 0.04030769f, -0.11629466f, -0.65849161f, -0.23485145f, 0.23982258f, 0.00079318f, 0.09842087f, 
    -0.02936767f, 0.06653504f, -0.00889903f, -0.02180531f, -1.17555726f, -0.33177751f, -0.56036663f, 0.04629347f, 
    0.05383742f, 0.04129946f, 0.05143720f, 0.00610189f, -0.08559295f, 0.03761990f, 0.19782521f, -0.04533272f, 
    0.02336803f, -0.05032086f, -0.09056931f, 0.01523411f, 0.41961217f, 0.11837389f, 0.00449736f, 0.19119856f, 
    -0.22445002f, 0.15108341f, 0.12896962f, 0.10377903f, 0.01699805f, -0.16079640f, 0.09324671f, -0.16817689f, 
    0.07087808f, 0.06133261f, -0.16738448f, -0.03211933f, -0.12836923f, 0.16422731f, 0.05565866f, -0.23541425f, 
    0.16389398f, 0.02252489f, 0.08200784f, 0.03621278f, 0.10391945f, -0.00925638f, 0.17329231f, 0.16593866f, 
    -0.01456485f, -0.13966623f, 0.08449083f, -0.22102776f, 0.13188297f, 0.07580952f, -0.00072129f, -0.00709197f, 
    0.09939227f, 0.20012546f, -0.13122354f, 0.02383972f, 0.10520764f, 0.03661076f, 0.14234871f, -0.03673200f, 
    0.04400098f, 0.23837580f, 0.26438662f, 0.11073802f, 0.24584593f, 0.24067676f, -0.04229932f, -0.00777730f, 
    0.02415431f, -0.06095437f, -0.08855829f, -0.04105473f, -0.01284276f, 0.08966591f, 0.00461646f, -0.02341991f, 
    -0.03503507f, 0.13419852f, -0.08303554f, 0.19065697f, -0.12780276f, -0.52332610f, -0.03930864f, -0.63386196f, 
    -0.04388994f, 0.12354272f, -0.05361004f, -0.00933868f, -0.06508848f, 0.04241399f, 0.38493654f, 0.17302090f, 
    -0.13011900f, 0.10762183f, -0.15315913f, -0.01651971f, -0.14043428f, 0.05849411f, -0.20142388f, 0.52076524f, 
    0.21587899f, -0.20489500f, 0.18773536f, -0.01916399f, 0.22178067f, 0.02925845f, 0.04474513f, 0.01849191f, 
    0.39537853f, 0.41897818f, -0.15114699f, 0.18790612f, 0.03933544f, -0.06355699f, 0.03360909f, -0.19624734f, 
    0.08345907f, 0.13184880f, 0.22211367f, -0.16953795f, -0.15195327f, -0.18180218f, -0.00167558f, 0.11020118f, 
    0.00669097f, -0.19445753f, 0.03327440f, 0.25307554f, -0.08738908f, 0.16582230f, 0.01135467f, 0.00694165f, 
    -0.23650375f, 0.00031062f, -0.10567594f, 0.09094290f, 0.07059333f, -0.10287446f, -0.14538315f, 0.09433935f, 
    -0.19485421f, -0.06644201f, 0.06085082f, 0.08965848f, -0.07545686f, -0.21755220f, -0.25248051f, -0.34874102f, 
    0.25377190f, -0.04088405f, 0.21647355f, 0.20884669f, -0.09309124f, 0.20407049f, 0.08642552f, 0.05036886f, 
    -0.08936282f, 0.39847332f, 0.15407126f, -0.21249759f, 0.28402340f, 0.05940559f, -0.09793014f, -0.24041601f, 
    0.01461629f, -0.05113435f, 0.08500899f, 0.02131665f, 0.03111124f, 0.05493198f, 0.15327641f, -0.06021558f, 
    -0.05908221f, -0.01761697f, -0.35426703f, -0.11886614f, -0.07568870f, 0.09520553f, 0.17006795f, 0.00675518f, 
    -0.19081749f, -0.16467462f, -0.95130122f, -0.08553568f, -0.10641430f, 0.04409637f, 0.00858607f, 0.05903279f, 
    -0.12201463f, -0.00432873f, -0.10321904f, 0.16635172f, -0.00144545f, 0.05404372f, -0.02756911f, -0.05253248f, 
    0.03418552f, -0.08299714f, -0.34101716f, -0.17824811f, 0.33383566f, 0.11133876f, -0.08316571f, -0.07115534f, 
    0.07992391f, -0.27693853f, 0.12288822f, 0.00362205f, -0.21330906f, -0.16199897f, -0.17465471f, -0.06417184f, 
    -0.01281538f, -0.02270075f, -0.12901239f, 0.07959229f, 0.30870321f, -0.15198055f, -0.20588537f, 0.01800153f, 
    -0.01775299f, 0.05292067f, -0.08285021f, 0.07415558f, 0.12057126f, -0.85974920f, 0.34821233f, 0.46154690f, 
    0.25365391f, 0.10865023f, -0.01774728f, -0.02687259f, 0.12885645f, 0.20371617f, -0.12019113f, -0.03480927f, 
    -0.13152887f, 0.05109395f, -0.09908488f, -0.03603289f, -0.07649613f, 0.02896420f, 0.09897246f, 0.23109004f, 
    0.02229308f, -0.10265566f, -0.38467512f, -0.28961471f, 0.07330190f, -0.09523541f, 0.09951562f, -0.06025616f, 
    -0.30503052f, 0.06276595f, -0.03981328f, -0.05261300f, 0.02409915f, -0.12994269f, 0.16381939f, -0.08198668f, 
    0.15713598f, -0.11170348f, 0.41018894f, 0.23648696f, 0.09338814f, 0.07503843f, 0.09293336f, 0.01393968f, 
    -0.06873024f, 0.02640265f, -0.34609181f, -0.30043295f, 0.01489071f, -0.00038547f, -0.01906295f, 0.06405329f, 
    0.09350795f, 0.18738292f, 0.23666541f, -0.21849625f, 0.13549379f, 0.30516729f, 0.01455775f, -0.06827053f, 
    0.05863890f, 0.17866404f, -0.00525612f, -0.13671196f, -1.26869023f, 0.26961857f, 0.65107465f, -0.07296202f, 
    0.00109053f, 0.17577307f, 0.12158948f, 0.19781326f, -0.09312294f, 0.00035568f, 0.46712437f, 0.01686262f, 
    0.00932058f, 0.15502685f, -0.10357013f, -0.07595569f, 0.08513062f, 0.10247941f, 0.09506258f, -0.04405433f, 
    0.38090146f, -0.02158789f, -0.17609045f, 0.05450158f, 0.01163133f, -0.22533983f, 0.17539079f, 0.18241714f, 
    0.10784233f, -0.19903654f, -0.30261302f, 0.16256639f, -0.05266330f, -0.05122233f, 0.17026225f, 0.07518048f, 
    -0.06503513f, 0.02495575f, -0.13798933f, -0.00618074f, 0.08716296f, -0.17615460f, 0.03509685f, 0.14740400f, 
    0.00349096f, -0.14672513f, 0.44192713f, 0.10929514f, 0.12653893f, 0.06994148f, 0.03642781f, -0.11413756f, 
    0.48176801f, 0.19460598f, -0.00633859f, 0.07321230f, 0.11460981f, 0.15526022f, 0.14793994f, -0.01705412f, 
    0.15857087f, 0.00642008f, -0.16540088f, 0.08692367f, 0.09447841f, 0.03946755f, -0.05719615f, -0.23204972f, 
    0.04716124f, -0.10092091f, -0.04959099f, -0.00269964f, -0.01042012f, -0.06959634f, -0.07594161f, -0.04578776f, 
    0.08470905f, 0.05712385f, -0.00589878f, 0.19960278f, 0.10633446f, -0.63635397f, -0.70599371f, -0.49031222f, 
    -0.04131003f, -0.11943876f, -0.00118224f, 0.06364456f, -0.10647698f, 0.10135145f, 0.03926469f, 0.17103405f, 
    -0.09015484f, -0.36420038f, -0.06668640f, -0.36847723f, 0.24880567f, 0.06519108f, 0.09968369f, 0.02292599f, 
    0.08178227f, -0.06609498f, 0.15020214f, 0.60984933f, -0.71822423f, 0.28429142f, 0.21476528f, 0.22942121f, 
    -0.53915316f, -0.51743108f, 0.25900045f, -0.16233040f, 0.37834471f, 0.10659929f, 0.18557771f, 0.09455844f, 
    0.05980099f, -0.16393410f, -0.08864252f, 0.23433058f, 0.07224555f, 0.05852914f, -0.02752581f, 0.08326694f, 
    -0.10583949f, 0.20439340f, -0.03995918f, 0.33685559f, 0.63533115f, -0.06693589f, -0.26147896f, -0.06352908f, 
    -0.10915140f, 0.16971494f, 0.10003684f, 0.17229302f, 0.05220567f, 0.20588091f, -0.02329391f, 0.07085764f, 
    -0.06668893f, 0.06303392f, 0.02613501f, -0.06920533f, -0.15095961f, 0.26631528f, -0.10548896f, 0.23148374f, 
    -0.15799771f, 0.20384376f, -0.08736567f, -0.07302883f, 0.15478395f, 0.16884667f, 0.40772125f, -0.16571385f, 
    0.04848154f, -0.17234379f, -0.11649680f, 0.13079302f, 0.11039366f, -0.05898332f, 0.26554629f, -0.02755051f, 
    -0.14492613f, 0.20626111f, 0.25330204f, -0.10038293f, -0.00183400f, 0.11115821f, -0.19353415f, -0.03207478f, 
    0.26137406f, -0.09967861f, 0.11825622f, -0.03254791f, 0.08975280f, -0.02628965f, -0.19008540f, 0.04708583f, 
    0.35332459f, -0.15481131f, -0.61037302f, -0.26074630f, 0.02593722f, 0.02439911f, -0.01541178f, -0.03429003f, 
    -0.05835383f, -0.26378906f, 0.43533695f, -0.11902180f, -0.02935642f, -0.01297893f, 0.10928743f, -0.05051113f, 
    0.09895868f, 0.04620316f, -0.43689364f, -0.15379454f, 0.09340528f, -0.05750497f, -0.04693899f, -0.24007197f, 
    0.05598897f, -0.02588226f, -0.11717656f, -0.09297993f, -0.14681415f, -0.22487424f, 0.10961826f, -0.01253534f, 
    0.05478770f, 0.20833692f, -0.08704329f, 0.04085640f, -0.03956365f, -0.23533386f, -0.26742825f, -0.04414326f, 
    -0.07622152f, 0.05270742f, -0.07358014f, -0.05800823f, -0.22700442f, -0.12707497f, -0.25419131f, 0.38209715f, 
    -0.09139747f, 0.03836583f, -0.02719976f, -0.10902163f, 0.26100814f, 0.10812413f, 0.10906626f, 0.28177747f, 
    -0.03235183f, -0.05839169f, -0.18217814f, -0.08702644f, 0.06494153f, 0.08313474f, 0.09288979f, 0.25212884f, 
    0.15371288f, -0.09876727f, 0.09618374f, -0.09444508f, -0.11379193f, -0.13564472f, -0.14671358f, -0.18287604f, 
    0.00220257f, 0.41198730f, 0.45664999f, -0.00280276f, -0.07910492f, 0.00991620f, 0.04639840f, 0.09021886f, 
    0.05911575f, -0.10772642f, -0.59069252f, -0.22254999f, -0.25302988f, -0.11157756f, -0.05695728f, 0.01993804f, 
    -0.02375461f, 0.12059896f, 0.04682807f, -0.03506924f, -0.09901101f, 0.26522860f, 0.15683568f, -0.09389190f, 
    0.05516839f, 0.20636161f, 0.00096055f, -0.60771072f, -0.70015389f, 0.20224507f, -0.21694995f, -0.14982978f, 
    0.09984066f, -0.04323993f, 0.04244736f, -0.07443155f, -0.14978874f, -0.42681393f, 0.39862829f, -0.07137457f, 
    -0.14421108f, -0.02625317f, 0.09308665f, 0.11176519f, -0.16647518f, 0.20801026f, 0.08018862f, 0.54153925f, 
    -0.00475893f, -0.20596978f, -0.13487485f, 0.08160249f, 0.04391200f, 0.30346516f, -0.39992860f, -0.19133748f, 
    0.17907278f, -0.17205900f, 0.08584939f, -0.01040607f, -0.11626831f, 0.20116191f, -0.01427982f, 0.08036330f, 
    -0.06998467f, -0.38191807f, 0.15319751f, -0.07841463f, -0.04505637f, 0.12606741f, 0.03956047f, -0.03240564f, 
    -0.04326511f, 0.03366197f, 0.18105140f, -0.07591933f, -0.04806554f, -0.04895391f, -0.05825220f, 0.02407626f, 
    0.16446690f, 0.12079594f, -0.24086507f, -0.21840778f, 0.21339084f, -0.01499171f, -0.02007396f, 0.08838211f, 
    0.02925776f, -0.02878602f, -0.11013347f, -0.02289118f, 0.18058862f, -0.00470185f, -0.09974430f, -0.03622604f, 
    0.04373492f, -0.04127914f, 0.09518366f, 0.07905439f, 0.13968578f, 0.07994369f, 0.00978956f, -0.00030297f, 
    -0.13117138f, -0.04745826f, 0.02670466f, -0.22551467f, -0.03251826f, -0.50590539f, -0.17442489f, 0.04235543f, 
    -0.00786835f, -0.00622441f, -0.32390228f, -0.05703282f, 0.04174432f, 0.17133999f, 0.12781298f, 0.11443033f, 
    -0.41571197f, -0.02867763f, -0.03699856f, -0.00629499f, 0.00820593f, -0.07941542f, 0.21735458f, -0.05625864f, 
    0.39948165f, 0.05258669f, -0.18780689f, 0.14233077f, 0.01417091f, -0.02194332f, -0.04877472f, 0.34544304f, 
    -0.43965882f, 0.35176325f, 0.11786765f, -0.15829901f, 0.36914262f, 0.05953072f, 0.05984189f, 0.23170397f, 
    0.00727227f, 0.07725271f, -0.00871282f, 0.23878966f, 0.09644787f, -0.00033928f, 0.06107494f, 0.07480826f, 
    -0.14658366f, 0.16034527f, 0.14942919f, -0.31593975f, -0.07033823f, 0.14397451f, 0.00506015f, 0.11689955f, 
    -0.14566238f, -0.06416841f, -0.32082647f, -0.07959478f, -0.14324595f, -0.06610338f, 0.01542382f, 0.00606178f, 
    0.10006972f, 0.21701510f, -0.09613131f, -0.09412416f, 0.11844770f, 0.05400413f, 0.03337768f, -0.00186380f, 
    -0.08852496f, -0.05663060f, 0.00665508f, -0.11063363f, -0.23882447f, -0.05672718f, 0.05871808f, -0.00685419f, 
    0.21786286f, -0.17467414f, -0.02176243f, -0.09178174f, -0.01865866f, -0.23110250f, 0.15519008f, -0.01101256f, 
    -0.02351536f, -0.02805838f, 0.04023240f, 0.16379826f, 0.24485987f, -0.13928573f, -0.03793908f, 0.05540638f, 
    -0.00963983f, 0.01159470f, 0.05010810f, -0.20291452f, 0.11041494f, 0.01275813f, 0.00369598f, -0.19564255f, 
    0.08408214f, 0.04148071f, 0.15724485f, 0.05663185f, -0.11076150f, -0.17971310f, 0.05005744f, -0.13613513f, 
    0.08003335f, -0.13096023f, -0.46856076f, -0.25711176f, -0.03618275f, 0.19690777f, -0.10231616f, 0.11335895f, 
    0.26273045f, 0.26671025f, 0.30069590f, 0.12843351f, -0.09114656f, -0.05369255f, 0.02637254f, -0.12684217f, 
    -0.15087686f, 0.00846987f, 0.46904027f, 0.38855779f, -0.11751346f, -0.09143852f, 0.08295041f, -0.05117477f, 
    0.05353421f, 0.06116463f, 0.12396977f, -0.06152032f, -0.08150492f, -0.04496687f, 0.14190592f, 0.06483360f, 
    -0.15489773f, -0.22868802f, -0.55637872f, -0.12447765f, 0.04218877f, 0.02301804f, 0.02528186f, 0.03351855f, 
    -0.03744226f, -0.12058796f, -0.16811930f, -0.34754038f, -0.05514756f, 0.20261160f, -0.12702124f, -0.30143854f, 
    0.32057881f, 0.44912481f, 0.23620832f, 0.00062568f, 0.04658601f, -0.10117676f, -0.11238346f, -0.00684778f, 
    -0.07872147f, -0.17257534f, 0.01702836f, -0.02472022f, 0.09045628f, 0.12079727f, -0.04643667f, 0.03884190f, 
    0.05222901f, 0.05404689f, 0.03065110f, 0.04323044f, 0.04991451f, -0.31674021f, -0.33962867f, -0.31998628f, 
    -0.00342873f, 0.18920934f, -0.00724388f, -0.01161409f, 0.17686501f, 0.33686709f, 0.18115653f, 0.21392800f, 
    -0.08522642f, 0.03037812f, 0.00783162f, -0.16138920f, 0.21390851f, 0.11165010f, -0.48661706f, 0.34229663f, 
    -0.54081231f, -0.15322953f, 0.10195787f, -0.03961157f, -0.02525411f, -0.13730966f, 0.20734411f, 0.05585986f, 
    -0.04348306f, -0.00258345f, -0.06486912f, 0.47498220f, 0.27532068f, 0.29576942f, -0.22304592f, -0.03393864f, 
    0.03794280f, -0.15206353f, -0.01473636f, 0.11876364f, 0.07493439f, 0.13443556f, -0.04161852f, 0.00529546f, 
    0.23515148f, -0.04243039f, -0.09422527f, 0.04041379f, -0.03863621f, -0.04143117f, 0.11931074f, -0.09964374f, 
    -0.03133557f, -0.04350057f, 0.28273827f, 0.06326196f, 0.29990211f, -0.14258206f, 0.08915153f, -0.07440233f, 
    -0.00591808f, 0.17927001f, -0.02814030f, -0.25165632f, 0.08567137f, -0.40376395f, -0.22363554f, 0.36177304f, 
    0.00585820f, -0.09563976f, 0.06358851f, 0.09358922f, -0.16870607f, 0.12862299f, 0.04052965f, -0.08050752f, 
    -0.03885009f, -0.02419805f, -0.01800988f, 0.00076904f, 0.13697253f, 0.04655597f, -0.03749326f, 0.09434238f, 
    -0.03036917f, -0.07557445f, -0.06888979f, -0.13628380f, -0.04488165f, 0.15397604f, 0.04082029f, -0.18660678f, 
    -0.07461990f, -0.34852308f, 0.07425243f, -0.02311260f, -0.28157261f, -0.01849441f, 0.06421274f, 0.02598536f, 
    0.20840292f, 0.04022314f, 0.00625724f, 0.10585754f, 0.07855675f, -0.10793664f, -0.03473198f, 0.07911806f, 
    -0.01661600f, 0.06579086f, -0.09774297f, -0.19570673f, -0.12408741f, 0.08624465f, -0.10296516f, 0.03951843f, 
    0.16776630f, 0.25384822f, -0.03537311f, 0.26477659f, 0.00105359f, 0.25694311f, -0.11728320f, -0.21622558f, 
    0.06050381f, -0.08215357f, -0.00541093f, -0.07716212f, -0.05736972f, -0.02685235f, -0.13926050f, 0.18120390f, 
    0.06360307f, 0.02292380f, 0.08868223f, 0.11444487f, -0.12630232f, -0.13861743f, 0.08971781f, -0.36245716f, 
    0.33159801f, 0.04097522f, 0.00109319f, 0.15604316f, 0.12372277f, 0.10932238f, -0.08536787f, 0.16919287f, 
    0.05417769f, 0.02094957f, -0.03714609f, 0.01902979f, -0.02046001f, -0.02909840f, 0.05672631f, 0.01736070f, 
    -0.02120154f, 0.04715749f, 0.02307655f, 0.05020587f, -0.02130720f, -0.00074436f, -0.05995099f, 0.00332928f, 
    -0.00994554f, 0.03465986f, -0.02295805f, -0.05351009f, -0.01015097f, -0.03116578f, -0.03288658f, 0.02807047f, 
    0.05035039f, 0.03614767f, 0.03858682f, -0.04367110f, -0.02953341f, 0.02893729f, -0.01101145f, 0.04742628f, 
    0.02592950f, -0.05980599f, -0.05147406f, -0.03360812f, 0.03928408f, -0.06174428f, -0.02818536f, -0.05760946f, 
    0.01064242f, -0.04375773f, 0.05183302f, -0.05469091f, 0.04266902f, 0.03504102f, -0.04690382f, 0.02893967f, 
    0.04310436f, 0.04177372f, 0.03600726f, 0.03485024f, -0.01929826f, 0.04452522f, -0.02749469f, -0.02274184f, 
    0.01567710f, -0.00110887f, -0.01943299f, 0.00759367f, 0.00067802f, -0.05610183f, -0.04681407f, 0.04411339f, 
    0.02948042f, 0.04163362f, -0.02018304f, -0.00201452f, -0.01245443f, 0.01280771f, -0.01001387f, -0.02261608f, 
    -0.00662862f, -0.00842036f, 0.01151043f, -0.04596915f, 0.03956245f, 0.03012071f, -0.00580363f, 0.04401799f, 
    -0.03106478f, 0.00741057f, 0.04571326f, -0.01373011f, -0.02128669f, -0.02148644f, -0.04666774f, 0.00562120f, 
    0.01738488f, 0.02268272f, 0.00905699f, -0.04313418f, -0.05542753f, 0.00230198f, 0.00804127f, -0.03367842f, 
    0.05230243f, 0.01043087f, -0.02150106f, -0.00524131f, -0.00892272f, 0.00627786f, 0.05221677f, -0.05522713f, 
    -0.04815517f, -0.03433788f, 0.03110215f, 0.01642713f, -0.05703839f, 0.04604511f, -0.03799870f, -0.02852410f, 
    0.00477669f, 0.05070575f, -0.04686352f, -0.01669995f, 0.00897691f, -0.03524011f, -0.01913526f, -0.00199440f, 
    0.04504790f, -0.01488602f, -0.02300094f, 0.03711234f, -0.00395693f, 0.00112681f, -0.02534990f, -0.05869651f, 
    0.04461052f, -0.01745413f, -0.00181702f, 0.00047377f, -0.04873028f, 0.00758777f, -0.01415784f, 0.01915086f, 
    0.03145887f, -0.04348847f, -0.01678427f, -0.04049610f, 0.02789514f, 0.02927288f, -0.03992027f, 0.01754559f, 
    -0.04986740f, -0.05718796f, -0.01071753f, -0.04822502f, -0.03379421f, -0.00556125f, -0.05441428f, 0.00392937f, 
    -0.04026798f, -0.05379103f, -0.05035828f, 0.02463350f, -0.02744742f, 0.05908516f, 0.01337490f, -0.02498242f, 
    -0.01212843f, 0.02090896f, -0.04635341f, 0.03403333f, -0.05596952f, -0.04726685f, -0.03132191f, 0.02385756f, 
    0.00900751f, -0.03474065f, 0.04185687f, -0.04032064f, -0.03779850f, 0.02458207f, 0.04585258f, 0.01540829f, 
    0.05787590f, 0.01333570f, -0.04639972f, 0.04377665f, -0.01916306f, 0.00509089f, -0.05721693f, -0.02988715f, 
    -0.03456819f, 0.00306763f, 0.04718141f, 0.03024069f, 0.03674757f, -0.00583718f, -0.00557252f, 0.05933313f, 
    -0.06525221f, -0.04032588f, -0.05247000f, 0.00035621f, 0.04824205f, -0.04700705f, -0.04035350f, -0.02194324f, 
    -0.06018189f, 0.05223442f, -0.01674571f, -0.04630904f, 0.01204272f, 0.01903781f, 0.01783725f, 0.04154146f, 
    0.00092239f, -0.06616548f, 0.05082726f, 0.02009322f, -0.05566111f, 0.02015931f, -0.01864059f, -0.00458822f, 
    0.02213773f, -0.00394601f, -0.03526374f, -0.04295451f, 0.03658307f, 0.03466486f, -0.00735160f, -0.05201428f, 
    -0.00867251f, -0.04209612f, -0.04474620f, 0.02953557f, 0.04298863f, 0.00012443f, 0.03476195f, -0.01890192f, 
    0.02026359f, 0.04641756f, -0.00744023f, -0.02928085f, -0.02962425f, 0.02276283f, -0.06198401f, -0.01806389f, 
    -0.03281889f, -0.05785064f, -0.03338629f, 0.00055254f, -0.05597529f, 0.01850018f, -0.02062959f, -0.00754690f, 
    0.01895073f, -0.05927791f, 0.02722020f, -0.01940398f, 0.03308279f, -0.03393467f, 0.00749040f, -0.06562877f, 
    -0.01731468f, -0.05469147f, 0.00059067f, 0.04228384f, -0.02027769f, -0.02937381f, 0.01921697f, -0.01934778f, 
    -0.00929244f, 0.01518971f, 0.04974868f, -0.02659835f, -0.01083368f, -0.03783465f, -0.04392276f, 0.04776937f, 
    -0.04988935f, 0.04998377f, 0.02315331f, -0.04416251f, -0.04457767f, 0.02021230f, -0.04097284f, -0.03378060f, 
    -0.02042225f, -0.03691464f, -0.02803377f, -0.05870109f, 0.02408677f, -0.00864550f, -0.00510634f, -0.01142872f, 
    -0.04924994f, -0.11528027f, 0.07417456f, 0.09723313f, 0.27540970f, 0.09322612f, -0.08821016f, -0.13368182f, 
    0.10254728f, -0.24324811f, 0.04773623f, 0.10989512f, 0.02459928f, -0.04679004f, -0.05162077f, -0.15748079f, 
    -0.16353856f, -0.26420712f, -0.01677211f, 0.03465817f, 0.07512882f, 0.01259654f, 0.07314637f, -0.07515331f, 
    0.08301102f, -0.02007916f, -0.01906326f, 0.01312254f, 0.13826333f, 0.13833193f, 0.17535116f, -0.02997387f, 
    0.05009133f, -0.09559903f, 0.05241062f, -0.01789132f, 0.05533700f, 0.10840222f, 0.10387637f, 0.17502758f, 
    0.15699793f, 0.20265260f, -0.09078932f, -0.07795238f, 0.06217861f, 0.04409148f, -0.14431518f, 0.04173533f, 
    0.03999952f, 0.14127494f, 0.00018295f, 0.22258924f, -0.08264319f, -0.02859967f, -0.04356758f, 0.27294984f, 
    0.21510501f, 0.21826908f, -0.00336245f, 0.31369981f, -0.14487807f, 0.17394131f, -0.01985820f, -0.00889312f, 
    -0.03193067f, 0.16938725f, 0.29685694f, 0.18637645f, 0.06741899f, -0.16689882f, -0.11513775f, 0.11024392f, 
    -0.13523276f, -0.06046041f, -0.03949041f, -0.00729280f, 0.00824186f, -0.26390213f, -0.18867423f, -0.04909112f, 
    0.16236070f, -0.19517791f, 0.19459942f, 0.01095289f, 0.07470773f, 0.17089182f, 0.15304816f, 0.01661717f, 
    0.12785174f, -0.40235519f, -0.47969526f, -0.23551196f, 0.16767390f, 0.14361501f, 0.07371128f, 0.01361933f, 
    -0.05853198f, -0.50097978f, -0.68592870f, -0.02439949f, 0.04221836f, 0.09630295f, 0.10005197f, 0.13563280f, 
    0.07851259f, 0.06500932f, -0.03526136f, -0.04057115f, -0.06396332f, 0.06108420f, 0.06973830f, -0.06827029f, 
    -0.11429238f, 0.06258811f, 0.14211915f, 0.02554457f, -0.10089196f, -0.31187767f, 0.19745152f, 0.09792970f, 
    0.05609212f, -0.07846265f, 0.20725614f, -0.03053653f, 0.23472983f, -0.17064342f, -0.04527127f, -0.19679157f, 
    0.18915451f, 0.03801635f, 0.09631928f, 0.04667756f, -0.12330630f, 0.08744264f, 0.04904670f, 0.03066872f, 
    -0.12749141f, 0.06078093f, 0.33574381f, 0.01413422f, 0.21207076f, -0.15766335f, -0.09136804f, 0.04981637f, 
    -0.14077960f, -0.56051815f, -0.12413618f, -0.01601643f, 0.05635629f, 0.01730515f, -0.08579686f, 0.29780346f, 
    0.19499426f, -0.00894825f, 0.13461185f, 0.19583051f, 0.12538531f, 0.10464446f, 0.08762138f, 0.07209769f, 
    -0.02198983f, 0.02049889f, -0.07406108f, 0.17138617f, 0.18954526f, 0.13148001f, 0.17521359f, 0.12080698f, 
    -0.00883004f, 0.02266394f, -0.05110941f, -0.49797532f, -0.05286800f, -0.00919578f, 0.11176379f, 0.23281321f, 
    0.06676397f, 0.13113898f, 0.18286654f, -0.58364272f, -0.01108928f, 0.24052358f, 0.06616022f, 0.15501729f, 
    0.05516176f, 0.01470777f, -0.01712947f, 0.09749816f, -0.03043534f, 0.09044357f, -0.04404071f, 0.16200484f, 
    -0.08076593f, 0.12295435f, 0.00554237f, 0.00450606f, 0.16960357f, -0.16075578f, 0.06951317f, -0.10674345f, 
    0.00525808f, 0.10562614f, 0.20770729f, 0.04222518f, 0.03975030f, -0.02525814f, 0.00032278f, -0.21312314f, 
    0.13623227f, 0.20345680f, 0.03180592f, -0.07818774f, 0.13283950f, -0.05391851f, 0.02600998f, 0.03881710f, 
    0.12540339f, 0.01066936f, 0.14811587f, 0.01161715f, 0.14188536f, 0.08912350f, -0.02257280f, 0.06562061f, 
    0.03892852f, 0.07485134f, 0.20026897f, 0.13410617f, 0.19161868f, -0.00150844f, 0.11871450f, -0.00528925f, 
    0.13200776f, 0.02759048f, -0.07209149f, -0.01403591f, 0.00671540f, 0.01552818f, -0.01669453f, 0.07855186f, 
    -0.09719876f, -0.17300043f, -0.21418060f, 0.03292489f, -0.08279135f, 0.06305642f, 0.10796953f, 0.00095449f, 
    -0.02869172f, -0.07929311f, -0.08351980f, -0.06863540f, -0.02568774f, -0.03281215f, -0.15980214f, -0.03464442f, 
    -0.25764817f, -0.20549247f, -0.21794242f, -0.09263328f, -0.26562428f, -0.29995406f, 0.25198993f, 0.05579161f, 
    0.01706546f, 0.16803302f, 0.06870708f, 0.10881243f, 0.05587636f, -0.04643619f, 0.06810359f, -0.00883780f, 
    0.09522870f, 0.21247336f, 0.07768681f, -0.01589516f, -0.25733849f, -0.08391570f, -0.00849620f, 0.29300529f, 
    0.02353223f, 0.01699220f, -0.01992745f, 0.16445629f, 0.01236405f, -0.06111068f, 0.04306788f, -0.19537602f, 
    0.02040267f, 0.03336656f, 0.00770094f, 0.01857442f, 0.03436154f, 0.00553595f, 0.00767410f, -0.03557009f, 
    0.04747876f, 0.03902505f, 0.00481004f, 0.00838597f, -0.06611780f, 0.00549754f, 0.04010244f, 0.03454173f, 
    0.04423283f, 0.03783089f, 0.00789939f, -0.02044805f, -0.04966750f, -0.03540464f, -0.05590139f, -0.03675696f, 
    0.03835965f, 0.04897525f, 0.01007471f, 0.02456561f, 0.03122158f, -0.05980403f, -0.05593755f, -0.04455463f, 
    -0.05648883f, -0.00234268f, 0.01108570f, -0.02736377f, 0.03740231f, -0.04674308f, -0.02260539f, -0.00465383f, 
    -0.04293128f, -0.00424610f, 0.02051648f, -0.05837944f, 0.01631615f, 0.00625462f, 0.04456618f, -0.01875844f, 
    -0.04302970f, -0.06565951f, 0.02530554f, -0.02331872f, 0.03815009f, 0.01878493f, 0.00208996f, -0.05276829f, 
    0.01317680f, -0.01304754f, -0.01925513f, -0.02970364f, -0.04101287f, 0.04037211f, -0.00686776f, 0.02996043f, 
    -0.05826151f, 0.01667912f, 0.01630526f, -0.05998386f, -0.02613956f, -0.05851287f, 0.02606114f, -0.01001659f, 
    0.05726433f, 0.04905457f, -0.01180111f, -0.04250090f, 0.01563721f, 0.01905762f, -0.04445653f, 0.02364974f, 
    -0.02009815f, 0.02304396f, -0.02264088f, 0.03272553f, -0.01321868f, -0.00450505f, -0.00454955f, 0.01192460f, 
    0.01342470f, 0.01056705f, -0.04452460f, -0.01330637f, 0.00996941f, -0.01151125f, 0.01478984f, -0.02411250f, 
    -0.04792083f, -0.01823486f, -0.05745010f, 0.00383197f, 0.00147338f, -0.05164595f, -0.02097774f, -0.01531314f, 
    -0.05298766f, -0.03660603f, 0.04040111f, -0.03190578f, -0.03930172f, 0.04414316f, 0.00045053f, -0.03018639f, 
    0.01966250f, -0.04937149f, -0.00922320f, 0.02556978f, -0.02864474f, -0.05470727f, -0.02265295f, -0.06656569f, 
    -0.06072301f, -0.05326742f, -0.02379190f, -0.05373231f, 0.03642181f, -0.01435133f, -0.02653656f, -0.01792940f, 
    0.03264519f, 0.00617973f, -0.01899183f, 0.01933193f, 0.03626648f, -0.02253071f, -0.03560644f, 0.01866792f, 
    -0.04922467f, -0.00373266f, 0.05520540f, -0.02378776f, -0.03101168f, -0.01682235f, 0.02408921f, -0.01302391f, 
    -0.02611258f, 0.00304024f, 0.03619610f, 0.03306799f, -0.00468768f, -0.00778418f, 0.03364261f, 0.01129828f, 
    -0.02174893f, 0.01789300f, -0.05595528f, 0.00553328f, 0.02112058f, -0.05957597f, 0.04002669f, -0.03378766f, 
    -0.05222472f, -0.06603571f, 0.01575624f, 0.01188038f, -0.05345017f, -0.01716591f, -0.01621461f, 0.00442219f, 
    -0.03332118f, 0.02771897f, -0.01437166f, -0.03183015f, -0.05830231f, -0.04417466f, 0.02569575f, 0.02787898f, 
    0.03863276f, -0.02417664f, 0.02783110f, -0.05776343f, 0.00875389f, -0.02469009f, -0.05686375f, 0.04300216f, 
    -0.01320085f, 0.03456625f, 0.04604385f, 0.00341011f, 0.02616989f, 0.00400055f, 0.00931783f, 0.02367643f, 
    0.03869187f, -0.01799439f, -0.04305462f, 0.00283636f, 0.00252287f, -0.05078885f, -0.02488749f, 0.04216107f, 
    -0.01629670f, -0.06561310f, 0.04714920f, 0.03057356f, -0.05906352f, -0.01788990f, 0.00008511f, -0.00441455f, 
    -0.06117127f, -0.05668160f, -0.03911281f, 0.04514121f, -0.01008629f, -0.06143209f, 0.03365425f, -0.02982438f, 
    -0.04368310f, -0.04973140f, -0.07059305f, -0.05155260f, 0.00083983f, -0.00368121f, -0.05039537f, 0.01781155f, 
    0.03264927f, 0.01394741f, -0.05740153f, -0.04484274f, -0.04771677f, 0.01027571f, 0.01098019f, -0.06074848f, 
    0.01599147f, 0.03680675f, 0.02877136f, 0.01764529f, 0.03895700f, 0.01208964f, -0.00084127f, -0.00882717f, 
    0.05053454f, -0.06491768f, 0.00382563f, -0.05922681f, 0.04465485f, 0.02829059f, -0.06532326f, -0.05637061f, 
    0.00541943f, -0.04635193f, 0.02661453f, -0.04997972f, -0.06855319f, 0.01924234f, -0.00304806f, -0.03289599f, 
    -0.04067215f, -0.02640213f, -0.02818000f, -0.00902115f, 0.01914081f, -0.02941143f, 0.02662466f, 0.02809536f, 
    0.00550342f, -0.04086162f, -0.06474683f, -0.05476266f, 0.01762831f, 0.03329698f, -0.03459208f, -0.03609690f, 
    -0.05220874f, -0.01424951f, -0.01872184f, 0.03611345f, 0.03386797f, 0.00497864f, 0.00289667f, 0.03579312f, 
    -0.06117201f, -0.05510040f, 0.02047641f, 0.02384488f, 0.03759233f, 0.00009682f, -0.06813322f, -0.05048321f, 
    0.39351574f, 0.23882701f, -0.24998975f, -0.07317758f, -0.20132487f, -0.06316547f, -0.04831786f, -0.03506754f, 
    -0.03534677f, -0.19765285f, 0.16292207f, 0.09314278f, -0.04763981f, -0.00704439f, -0.03914743f, 0.32559431f, 
    -0.02452193f, 0.38835007f, 0.09422449f, -0.25891909f, -0.27263966f, 0.18022345f, 0.02596115f, 0.14718127f, 
    0.00076348f, 0.12712930f, 0.09598403f, 0.11126323f, -0.01434409f, -0.02060604f, 0.24224362f, 0.20544684f, 
    0.12721372f, 0.03833927f, 0.10637768f, 0.13849694f, -0.20404889f, 0.03241857f, -0.08287642f, 0.22965497f, 
    -0.01048606f, 0.02339647f, 0.14985895f, 0.16537882f, 0.26212615f, 0.03427177f, -0.37992305f, -0.23597048f, 
    0.00398399f, -0.00028653f, 0.17101108f, -0.09870141f, -0.07672624f, -0.19735962f, 0.05942387f, 0.04436563f, 
    -0.21224371f, 0.06301136f, 0.00730835f, 0.33598506f, 0.20537995f, -0.12127622f, 0.13053550f, 0.20481746f, 
    0.13961491f, -0.10797259f, 0.13365887f, 0.05010360f, 0.14049681f, 0.17740498f, 0.06014033f, -0.18284552f, 
    -0.15132552f, 0.11889771f, 0.27204677f, -0.00282856f, -0.08321968f, -0.41631383f, -0.04758131f, 0.09692207f, 
    0.12307125f, 0.08343276f, -0.23433472f, -0.84739584f, -0.28745139f, -0.20543873f, 0.11166975f, -0.12744069f, 
    0.02382452f, 0.00418543f, -0.60893124f, -0.51319027f, -0.09415741f, 0.06688955f, 0.05225655f, 0.10279294f, 
    -0.16703166f, -0.10429393f, 0.01516351f, 0.14208655f, 0.24616274f, 0.31694382f, 0.01001436f, -0.02453923f, 
    0.02217632f, 0.09132488f, 0.20034365f, -0.17685460f, -0.08091307f, 0.10693056f, 0.15135725f, -0.15622805f, 
    -0.04597819f, -0.15750864f, 0.09639281f, -0.00209302f, -0.16596347f, -0.28435129f, -0.38551173f, -0.49622303f, 
    -0.21544871f, -0.20216693f, -0.21491015f, -0.05597155f, 0.02651682f, -0.11110534f, 0.35845855f, -0.09615970f, 
    0.22221729f, 0.15742441f, 0.13111539f, 0.20747685f, 0.09494070f, 0.15797025f, 0.01573743f, -0.06028431f, 
    0.04311090f, 0.14893526f, -0.07304282f, -0.05604390f, -0.03405467f, 0.04846692f, 0.13072038f, -0.07378988f, 
    0.55006516f, -0.31342506f, -0.43250608f, -0.02379238f, 0.09905522f, -0.00161832f, 0.02311766f, 0.07463838f, 
    -0.16131032f, -0.42987922f, 0.22342117f, 0.07700235f, -0.05678391f, 0.07070735f, -0.28716177f, -0.01261161f, 
    -0.08714730f, -0.23499352f, 0.01034289f, -0.04694525f, -0.35101762f, 0.04814379f, -0.04626594f, 0.07867115f, 
    0.04094151f, -0.15717719f, -0.13524346f, -0.22296402f, 0.06749171f, -0.64314806f, -0.21508336f, -0.09738234f, 
    -0.11227088f, -0.03499524f, -0.08353894f, 0.00170332f, -0.78909391f, -0.49144897f, -0.44553885f, 0.20073292f, 
    0.12054637f, 0.09149977f, 0.04856697f, 0.02630221f, 0.16914353f, 0.01179915f, -0.57289010f, -0.24056587f, 
    -0.07950719f, -0.08486752f, 0.11691194f, 0.20184763f, 0.07749283f, 0.07906631f, 0.16976504f, 0.12929127f, 
    -0.30561769f, -0.03773657f, -0.11439572f, -0.16665196f, -0.22838099f, -0.19443254f, -0.01009612f, -0.38605475f, 
    0.15698174f, 0.31560141f, -0.06567200f, -0.11597770f, -0.06774782f, 0.13576895f, -0.03113231f, 0.00734719f, 
    0.10489141f, -0.02261646f, 0.11286198f, 0.01472120f, 0.19942473f, 0.08149906f, 0.25114682f, 0.23770945f, 
    0.13943709f, -0.27567980f, -0.05061794f, -0.15771540f, -0.13851702f, -0.20198530f, -0.10119125f, 0.19810610f, 
    0.06546377f, -0.03911900f, -0.04017475f, 0.04534433f, -0.04286819f, 0.14138609f, 0.08076681f, 0.14647415f, 
    -0.12336779f, 0.05253600f, 0.20852973f, 0.01497410f, 0.08839072f, 0.13623972f, 0.07635053f, 0.06987263f, 
    0.20595336f, 0.05507744f, 0.09768312f, 0.13870995f, 0.10740242f, 0.19860005f, 0.14798769f, -0.00155401f, 
    0.00545154f, -0.08840239f, 0.34957984f, 0.20088182f, 0.36717135f, -0.30075148f, 0.51145190f, 0.34418234f, 
    0.03151768f, -0.04997752f, -0.07808864f, -0.05401060f, 0.08185989f, -0.04425962f, 0.17958367f, -0.00415737f, 
    -0.01014657f, 0.00710010f, 0.03940048f, -0.01985439f, -0.06429583f, 0.12692587f, 0.02423797f, 0.31932697f, 
    -0.16272171f, 0.19710775f, -0.00430749f, -0.12876014f, 0.00750825f, 0.10168164f, 0.04395507f, 0.17231257f, 
    0.28488970f, -0.01260238f, 0.49018112f, -0.03838604f, -0.00664481f, 0.33375964f, 0.10960815f, -0.18478526f, 
    0.05124983f, -0.17424282f, 0.13521740f, 0.20805097f, -0.22425197f, -0.04217668f, -0.14447564f, -0.13136032f, 
    -0.11228821f, -0.05973490f, -0.18037024f, -0.03723713f, 0.17383017f, -0.06547474f, -0.15863998f, -0.09970211f, 
    -0.19772123f, -0.02613213f, -0.00830606f, -0.14382626f, -0.11044092f, -0.01357296f, -0.06378717f, 0.02743683f, 
    -0.00634677f, 0.23072580f, 0.03719981f, -0.07730256f, -0.46654007f, 0.06802135f, -0.28347844f, 0.10072943f, 
    0.05776628f, 0.00214971f, -0.05947732f, -0.04668457f, -0.15139884f, -0.22317372f, 0.05769691f, -0.14284955f, 
    0.02970003f, 0.09923565f, 0.06284500f, 0.08600581f, 0.11425880f, -0.18216296f, -0.57598484f, -0.04464573f, 
    -0.32806188f, -0.04116535f, 0.06654399f, 0.21861081f, -0.13666295f, 0.04999474f, -0.06803651f, -0.05972651f, 
    0.16768664f, 0.04043823f, 0.09161162f, -0.06819503f, -0.11947256f, -0.18042822f, 0.10974670f, 0.02868475f, 
    0.32613158f, -0.50228769f, -0.06273997f, -0.05435754f, -0.12766963f, -0.23774642f, 0.03699498f, 0.11948171f, 
    0.11901987f, -0.06591866f, 0.60788327f, -0.00789053f, -0.25551912f, 0.09475025f, -0.15992142f, 0.11149641f, 
    -0.03844319f, -0.02190356f, 0.01088244f, 0.02502425f, 0.11331227f, -0.02470925f, 0.08849102f, -0.11209784f, 
    0.13760588f, 0.02448861f, 0.11635095f, -0.15056752f, 0.18071657f, 0.17341375f, -0.14622654f, 0.06732836f, 
    -0.00139430f, 0.13304019f, -0.04471733f, 0.01671527f, -0.06272820f, 0.06090197f, 0.06612222f, -0.16586986f, 
    0.01726372f, -0.13906245f, 0.08290400f, -0.07498122f, -0.00141559f, 0.39368463f, 0.34895971f, 0.24240336f, 
    -0.22199269f, 0.26528385f, -0.21542652f, 0.12599863f, -0.01049633f, -0.03726783f, -0.27222309f, -0.08003008f, 
    -0.36696461f, -0.05417106f, -0.00595180f, 0.00130182f, 0.01393072f, 0.03995419f, -0.13808209f, 0.09558938f, 
    0.10885929f, 0.03157784f, -0.34329405f, -0.06390857f, -0.10577702f, 0.02155028f, 0.08092659f, 0.00135620f, 
    -0.03106424f, 0.40131801f, 0.33968121f, 0.00164488f, 0.00693122f, 0.17416696f, -0.03040160f, -0.00087880f, 
    -0.06572855f, 0.42427659f, 0.33266425f, 0.24553968f, 0.00953528f, 0.15036345f, 0.07178637f, 0.12814911f, 
    -0.07179879f, -0.04489942f, -0.43893108f, 0.39636636f, -0.03343918f, -0.12156180f, -0.03964290f, 0.03654176f, 
    0.00309796f, -0.10323101f, 0.16215521f, 0.02838618f, -0.15786631f, 0.09535730f, -0.18361029f, 0.20787138f, 
    -0.02574589f, 0.21679518f, -0.01906120f, 0.08072785f, -0.09333435f, 0.18484534f, 0.42824787f, -0.26451916f, 
    -0.12847765f, -0.23064052f, -0.00981824f, 0.07347136f, -0.05490450f, -0.24885245f, 0.52135235f, 0.32567438f, 
    -0.20058756f, -0.18726340f, -0.19095694f, -0.24162942f, 0.42837355f, -0.00457350f, 0.20179157f, 0.54274058f, 
    0.31158891f, -0.17118768f, 0.09264078f, 0.16021687f, 0.17740445f, -0.04655281f, -0.15665953f, -0.30984730f, 
    0.38681573f, -0.12456629f, -0.10935483f, -0.14057712f, -0.00562589f, -0.01031420f, 0.01953461f, -0.00007309f, 
    -0.30417734f, -0.06426517f, -0.04348201f, 0.00731660f, -0.25667337f, -0.10234778f, 0.03168614f, 0.31363332f, 
    -0.23532608f, 0.15027755f, 0.13774724f, -0.15569435f, -0.02480864f, 0.48458830f, -0.01974300f, 0.20075473f, 
    0.27001351f, -0.14541706f, -0.16142052f, -0.00639216f, -0.17364916f, 0.00780349f, 0.02676101f, -0.03711699f, 
    0.12848629f, -0.17444861f, 0.12910570f, -0.00457927f, 0.06058198f, 0.23339519f, -0.19489062f, -0.11207306f, 
    -0.19305018f, -0.02404241f, 0.07016242f, -0.05026942f, 0.29225680f, 0.13711654f, -0.01228031f, -0.09883758f, 
    -0.43863150f, 0.01366500f, -0.03323260f, -0.14862813f, 0.16098876f, 0.00710460f, -0.05668383f, 0.25961521f, 
    -0.02100003f, -0.12385996f, -0.00213994f, -0.00263916f, 0.01350289f, -0.05761450f, 0.00916448f, -0.02856622f, 
    0.07055407f, -0.01889219f, -0.36203435f, 0.03142007f, 0.39965054f, 0.09857196f, -0.00450729f, -0.09153972f, 
    0.11083291f, 0.14886315f, -0.19391802f, 0.03377705f, -0.04158404f, 0.25748995f, 0.17943861f, 0.01424515f, 
    -0.04226462f, 0.05152043f, -0.02226718f, -0.05865374f, 0.04453599f, 0.00715381f, 0.04169614f, -0.00699039f, 
    -0.02510624f, -0.05842962f, -0.05391948f, -0.02804527f, -0.04770657f, -0.02761842f, 0.04872268f, -0.03431672f, 
    0.03770697f, -0.00529468f, -0.04490501f, -0.02266374f, -0.06181471f, -0.02725073f, 0.03254557f, 0.04858382f, 
    -0.04375666f, 0.00970125f, 0.01511133f, -0.00127935f, -0.02209327f, 0.02673624f, 0.04521530f, 0.01745026f, 
    -0.03562000f, -0.04176856f, -0.05498808f, 0.02195488f, -0.03315389f, -0.03653657f, -0.04205340f, 0.03887565f, 
    0.01702341f, 0.02412727f, -0.02980582f, -0.03427832f, 0.01739031f, 0.05491665f, 0.00542629f, -0.02956136f, 
    0.03560219f, -0.04042008f, -0.04772627f, -0.01423716f, -0.00713555f, 0.00648666f, 0.01314273f, -0.03395590f, 
    0.00331850f, -0.05582800f, -0.06125103f, -0.06347139f, -0.05226068f, 0.05502303f, -0.02631604f, -0.05262123f, 
    0.01415344f, -0.01149700f, 0.01905693f, 0.03599204f, 0.03856161f, -0.04137610f, -0.00479870f, 0.04880457f, 
    0.01285230f, 0.03025268f, -0.04311114f, 0.04616500f, -0.06128509f, 0.02331759f, 0.00028218f, -0.00731657f, 
    0.03212598f, -0.04728356f, 0.01725582f, -0.00086537f, -0.04345209f, 0.02438763f, -0.03388922f, 0.00387870f, 
    0.04539157f, 0.02811620f, 0.01750559f, -0.06098593f, 0.02467896f, -0.05883720f, 0.02688178f, -0.03533039f, 
    -0.05986905f, 0.02998316f, -0.02828362f, 0.00692366f, -0.03160602f, -0.01467820f, -0.00761160f, -0.03161285f, 
    -0.01145577f, -0.05133358f, 0.04451560f, -0.01222260f, 0.04740112f, -0.06392132f, 0.05149757f, -0.04005454f, 
    -0.03419657f, 0.05069361f, -0.05749705f, 0.02609004f, -0.00547702f, -0.01354275f, 0.02152656f, 0.02712491f, 
    -0.04720471f, -0.04814494f, -0.00819314f, -0.05771228f, 0.02493345f, -0.04396339f, 0.03292973f, -0.05246491f, 
    -0.00133396f, -0.01180243f, 0.02414606f, -0.06476647f, -0.01222517f, -0.00908056f, -0.04028803f, -0.00679430f, 
    -0.00992699f, 0.01789205f, -0.01701300f, 0.02331445f, -0.05609363f, -0.01037393f, -0.05900138f, -0.03124403f, 
    0.03134482f, 0.04273129f, -0.03646347f, -0.02661113f, 0.02453647f, 0.02642429f, -0.03342082f, -0.01341917f, 
    0.01104156f, -0.01643465f, 0.04371994f, 0.00860686f, -0.04107740f, -0.02594632f, -0.03505437f, -0.00669728f, 
    0.01199664f, 0.01427772f, -0.01754637f, 0.02437279f, 0.04609577f, -0.05387425f, -0.01182175f, -0.02667600f, 
    -0.02942093f, -0.03785360f, 0.00046856f, 0.00012680f, 0.04394667f, -0.01616167f, 0.00247933f, 0.04987999f, 
    0.01722433f, 0.04356063f, -0.01622584f, -0.06107002f, 0.03572639f, 0.01514960f, 0.04237487f, -0.02108009f, 
    -0.06056853f, -0.04236253f, -0.01472116f, 0.00615768f, -0.01839395f, 0.04992806f, 0.00016531f, 0.00003393f, 
    0.00825543f, -0.05483094f, 0.03810749f, -0.02720776f, 0.04816104f, -0.00794823f, -0.00601860f, 0.00847388f, 
    -0.03138041f, -0.02009314f, -0.00236007f, 0.03206735f, -0.00368572f, -0.03928787f, 0.04543308f, -0.02994564f, 
    0.00833583f, -0.03021514f, 0.02613944f, 0.00361187f, -0.01985287f, -0.01534486f, 0.01154379f, 0.04267491f, 
    -0.04549748f, -0.06445357f, 0.05248429f, -0.01439239f, 0.02299923f, -0.04633440f, -0.03592627f, -0.06324413f, 
    0.01054452f, 0.03189708f, -0.05118982f, 0.03407203f, -0.01993572f, -0.00108058f, -0.03092778f, -0.03408301f, 
    0.04106722f, -0.04587548f, -0.05733631f, -0.00600202f, -0.03750872f, -0.05673183f, -0.00961268f, -0.05446785f, 
    -0.03966967f, -0.00085628f, 0.04841800f, 0.01168793f, -0.04246627f, 0.01512705f, -0.05224771f, -0.06185341f, 
    -0.02445119f, -0.02325494f, -0.00046811f, 0.00927210f, -0.04849267f, 0.00208274f, 0.03074734f, 0.00514720f, 
    -0.01389045f, -0.02496004f, -0.06045155f, 0.02517406f, -0.03571513f, 0.05013848f, 0.04511170f, -0.01006052f, 
    0.04546930f, -0.04020875f, -0.02387479f, -0.04156157f, -0.00589356f, -0.01022529f, -0.00516357f, -0.04645600f, 
    -0.01822551f, 0.02382652f, -0.05019418f, -0.06146722f, -0.00946185f, 0.05092838f, -0.03716861f, 0.04021153f, 
    0.00693363f, -0.02337776f, -0.06257886f, -0.01454887f, -0.05114888f, 0.02177141f, 0.01534185f, -0.00821722f, 
    0.13466282f, -0.34721047f, 0.45545831f, -0.19810858f, -0.16932422f, 0.05639209f, -0.14493027f, -0.07287896f, 
    -0.08662108f, -0.25320449f, 0.22083721f, 0.07315549f, -0.06703820f, -0.01060215f, 0.12456453f, 0.11361817f, 
    0.02374054f, 0.22838338f, 0.04335181f, -0.10180084f, 0.00785573f, -0.20808499f, -0.10218889f, -0.05283055f, 
    -0.04233522f, 0.15143050f, 0.15616095f, 0.04881473f, -0.07951984f, -0.02061410f, -0.06567585f, 0.08171504f, 
    -0.06274334f, 0.05387743f, -0.05869851f, -0.10221430f, 0.32319039f, 0.26712188f, -0.16842990f, 0.18204579f, 
    0.05356678f, 0.18876788f, 0.07669555f, 0.37100080f, -0.19959271f, 0.15756808f, 0.01978273f, 0.15831786f, 
    -0.13879701f, 0.03331920f, 0.05767869f, 0.10134558f, 0.09734169f, -0.50199795f, 0.33496866f, -0.14815089f, 
    -0.17990065f, 0.16723420f, -0.15177830f, 0.09421687f, 0.20343891f, -0.03322448f, -0.15199128f, 0.13871171f, 
    0.08204968f, -0.17233501f, -0.03920812f, 0.00801275f, 0.07432118f, 0.01084909f, 0.12784052f, -0.18831557f, 
    -0.55075449f, -0.43509579f, -0.19522302f, -0.17070596f, 0.23668551f, 0.23694305f, -0.10259154f, 0.02306687f, 
    0.27939028f, -0.08490361f, 0.03143019f, 0.17822520f, -0.00102348f, -0.07018448f, -0.09418160f, 0.18057300f, 
    -0.05804570f, 0.12451848f, -0.44547394f, 0.13194798f, 0.51209038f, -0.12528989f, 0.07300853f, 0.05216175f, 
    0.07156509f, 0.06478188f, -0.01045325f, 0.04191937f, 0.14481229f, -0.05911702f, 0.01108963f, 0.00999320f, 
    0.07805300f, 0.01708821f, 0.01161275f, -0.10319805f, -0.10787136f, 0.04820544f, -0.19893996f, 0.04620958f, 
    0.07572741f, -0.17061713f, 0.08033344f, -0.00468804f, 0.04668237f, -0.51007921f, -0.14396901f, -0.00558586f, 
    -0.00316283f, 0.16534358f, -0.41225737f, 0.11994309f, 0.04229534f, 0.26316446f, 0.19666724f, -0.04273615f, 
    -0.15555757f, -0.03165832f, 0.03603175f, 0.01803823f, -0.02949069f, 0.07273518f, -0.01614020f, -0.18883371f, 
    0.10233017f, -0.13598934f, -0.19004202f, -0.11149710f, -0.01187125f, 0.08241016f, 0.10728383f, -0.18128967f, 
    0.50811464f, -0.15979278f, -0.05590321f, 0.02459883f, -0.04790331f, -0.10191991f, -0.12752059f, 0.17062156f, 
    -0.04425051f, -0.33007294f, -0.00470030f, -0.03968357f, -0.05511745f, -0.09944613f, -0.27461180f, -0.00990386f, 
    -0.03283975f, -0.04211159f, -0.08675080f, 0.10410365f, -0.40353656f, -0.01938694f, 0.05689994f, -0.15928702f, 
    0.03789126f, 0.06922577f, -0.05846047f, -0.25324070f, -0.10608448f, 0.07287221f, 0.01487424f, -0.21561266f, 
    0.11370701f, 0.23792025f, -0.03636308f, 0.13557914f, -0.19197215f, -0.22843902f, 0.73631507f, -0.03325260f, 
    0.03687485f, 0.13695414f, 0.19723512f, 0.11771661f, 0.18740800f, -0.21435814f, -0.10345333f, 0.04465045f, 
    0.06068758f, 0.02113899f, -0.42584452f, 0.10999424f, 0.03820067f, 0.12568618f, -0.15313721f, -0.05649775f, 
    0.28289995f, -0.14741719f, -0.11957860f, -0.33137611f, 0.20487796f, -0.18905973f, -0.11940888f, -0.13818620f, 
    0.13506232f, -0.30568907f, 0.09195348f, -0.07661769f, 0.06003600f, 0.10439949f, 0.07642089f, -0.11995637f, 
    0.29085520f, -0.25362480f, 0.18717171f, 0.01004728f, -0.12562719f, -0.13941227f, 0.21727316f, 0.08125281f, 
    0.21381995f, -0.33322793f, -0.03104148f, -0.08761256f, -0.17308940f, 0.04998317f, -0.15887953f, 0.18284421f, 
    0.22544423f, -0.00911347f, -0.00244247f, 0.16775084f, -0.01278471f, -0.07651169f, -0.04285033f, 0.02592362f, 
    0.01605258f, -0.10813988f, 0.03216228f, -0.03854521f, 0.16005661f, 0.07539250f, -0.13284130f, -0.07567388f, 
    0.04614358f, -0.00817872f, 0.05627831f, -0.00612174f, -0.00916736f, 0.14961219f, 0.00108268f, -0.05020453f, 
    0.14935973f, 0.09510314f, 0.09865406f, 0.18171252f, 0.41887873f, 0.09715905f, -0.27313364f, 0.07929032f, 
    0.06743672f, 0.01307615f, 0.08860403f, 0.11340435f, -0.12167025f, 0.03689797f, -0.10550132f, 0.10040554f, 
    -0.04785687f, -0.13167696f, 0.01499243f, -0.01965988f, 0.03649106f, 0.13988285f, -0.07655998f, -0.23258224f, 
    -0.06058079f, 0.26841703f, 0.07121760f, 0.09205186f, 0.17049508f, 0.07762014f, -0.02892239f, 0.20012552f, 
    -0.00914593f, 0.02075015f, -0.04709554f, -0.04698790f, -0.02424881f, -0.02075484f, 0.03043350f, -0.00418359f, 
    0.02453212f, -0.05289149f, -0.07114822f, 0.03738734f, 0.02501761f, -0.02438816f, -0.02826539f, -0.02545631f, 
    -0.06410163f, -0.05273287f, -0.04799619f, 0.04225787f, -0.00082011f, 0.03118161f, 0.01072732f, 0.02122589f, 
    -0.05329904f, -0.06942058f, 0.02520829f, -0.06513620f, 0.00399717f, -0.00795092f, 0.00844484f, -0.05224087f, 
    0.00191840f, 0.01855750f, -0.00192884f, -0.03494683f, 0.03285747f, 0.02267586f, 0.04325898f, -0.01354027f, 
    0.03543265f, -0.02688427f, -0.00444033f, -0.01491887f, -0.02842286f, -0.04532766f, 0.00987724f, -0.02469396f, 
    -0.00784021f, 0.00207474f, 0.01277702f, -0.01679044f, -0.00854676f, 0.01475565f, -0.00564810f, -0.01660168f, 
    -0.03742070f, 0.04887498f, -0.04594015f, -0.00482667f, -0.02437685f, -0.02545532f, 0.02842324f, -0.05777766f, 
    -0.04066406f, -0.03173939f, -0.05150005f, 0.04216552f, -0.03310489f, 0.01060500f, -0.04025799f, -0.04438987f, 
    0.03607191f, -0.00611179f, -0.00956346f, -0.00649050f, -0.06330252f, 0.00820820f, -0.01724564f, 0.00424695f, 
    -0.03805176f, -0.05696700f, 0.00590760f, 0.02730738f, -0.05299417f, -0.01135502f, 0.04474784f, -0.02009941f, 
    -0.03453309f, -0.04604755f, 0.00922524f, -0.06383942f, 0.04287587f, 0.03590154f, 0.00711544f, -0.00117891f, 
    -0.05218001f, -0.05641272f, 0.01204094f, -0.00966995f, 0.03340009f, 0.04878095f, -0.00290839f, -0.02378027f, 
    -0.05984566f, -0.05277788f, -0.04399163f, -0.04833755f, -0.06763361f, 0.02622439f, -0.02473436f, -0.00751591f, 
    -0.04426564f, -0.04618233f, 0.02645865f, 0.03547778f, 0.01841919f, 0.04708017f, 0.00714728f, 0.04940902f, 
    -0.02240818f, 0.00615792f, 0.02383885f, 0.01537459f, -0.03147230f, -0.04649827f, -0.00968662f, -0.04318405f, 
    0.04346997f, -0.04925613f, 0.01901163f, -0.04986177f, -0.05957813f, 0.03036435f, 0.03477564f, -0.02139644f, 
    0.02162835f, -0.02743725f, 0.03324628f, 0.00263616f, 0.00936306f, -0.05411313f, 0.05731760f, -0.00682635f, 
    -0.00575388f, -0.05157230f, 0.00580009f, 0.00433659f, 0.02579099f, -0.02458511f, 0.00500880f, -0.03198880f, 
    -0.03047529f, -0.01404406f, -0.04943975f, 0.02952606f, -0.03038997f, -0.06036301f, 0.03252625f, 0.01612818f, 
    -0.06389526f, 0.03704543f, 0.02122273f, -0.02200867f, -0.00219403f, 0.00622138f, -0.01278888f, -0.06466536f, 
    0.04305472f, -0.04047636f, -0.03702005f, 0.01082225f, -0.01912623f, -0.01425276f, 0.03564019f, 0.00247789f, 
    0.03672892f, -0.05467948f, -0.06936142f, -0.05434188f, -0.03107230f, 0.01620623f, 0.00656722f, -0.03673798f, 
    0.03467355f, 0.02312503f, -0.01807862f, 0.03334217f, 0.05205195f, 0.03618439f, 0.02239448f, -0.05252083f, 
    0.01254854f, 0.01230412f, -0.04900878f, 0.02992924f, 0.00523535f, -0.01961124f, -0.04925414f, -0.01053299f, 
    -0.01914828f, 0.04544068f, -0.02279614f, 0.01409123f, -0.00973759f, 0.01996536f, 0.05732092f, 0.03433229f, 
    -0.03403585f, 0.04082939f, 0.04176402f, 0.02912230f, 0.01852196f, 0.01200988f, -0.05642740f, 0.03302760f, 
    -0.02421732f, -0.01224413f, 0.03340472f, 0.03308798f, 0.04693041f, -0.02911662f, 0.01817634f, -0.02051556f, 
    0.00133473f, 0.00818862f, -0.03892002f, -0.04253053f, -0.05670056f, -0.01321593f, 0.03415525f, -0.05342935f, 
    0.00060016f, 0.03103175f, -0.00190297f, -0.02507990f, -0.04726550f, 0.01926536f, 0.04390825f, -0.06405315f, 
    -0.03629065f, 0.01615969f, 0.03002816f, 0.04297682f, -0.00549888f, 0.03048761f, -0.06065027f, -0.02554978f, 
    -0.00657292f, -0.01599047f, 0.01208586f, 0.05209750f, 0.00569900f, 0.01353611f, 0.01759731f, -0.02615868f, 
    -0.02065832f, 0.00682977f, 0.00930220f, -0.03684900f, -0.05436147f, -0.04260780f, 0.02799726f, -0.01564454f, 
    0.03237945f, -0.02480075f, 0.04124193f, 0.00054962f, 0.03046059f, 0.01718477f, -0.05556346f, 0.01488787f, 
    -0.00014928f, 0.03996367f, -0.02025326f, 0.04773482f, -0.02309925f, -0.05068579f, 0.04875596f, 0.02197227f, 
    0.01211772f, 0.04814860f, 0.02591704f, 0.03001570f, -0.00720992f, 0.04418829f, 0.01251475f, 0.01259134f, 
    -0.30069593f, 0.08366167f, -0.26276404f, 0.08690481f, -0.05024229f, 0.10807145f, 0.00869116f, -0.04261178f, 
    0.33020717f, 0.08934736f, -0.05840237f, 0.18651697f, 0.15572907f, 0.15609013f, -0.59249490f, 0.06570084f, 
    0.09855828f, 0.04147145f, -0.06982426f, 0.06279527f, 0.07703971f, -0.10766499f, -0.04554377f, -0.06140879f, 
    -0.27968884f, 0.03590694f, -0.03262549f, 0.06068491f, 0.12821552f, 0.03473778f, 0.07240512f, 0.16443405f, 
    0.12858099f, 0.08612097f, -0.01010136f, 0.20882735f, -0.08617103f, -0.01737599f, -0.06521709f, 0.00183490f, 
    0.10067070f, 0.15931438f, 0.04538179f, 0.15309343f, 0.27411568f, -0.14132912f, -0.16656893f, 0.19119556f, 
    -0.10017975f, -0.08892807f, 0.04404316f, -0.03150222f, -0.06728980f, -0.12838365f, -0.01179807f, -0.07256261f, 
    -0.28348401f, -0.04394621f, 0.11157299f, 0.05667106f, 0.10146419f, 0.16563933f, 0.02391585f, -0.19843499f, 
    0.00411880f, 0.15192813f, 0.05591863f, 0.07667059f, 0.02699892f, -0.05800716f, 0.03668993f, 0.06561994f, 
    0.54906464f, 0.04571398f, 0.81657815f, -0.10426097f, -0.09345733f, -0.19509532f, 0.15742742f, 0.10130917f, 
    -0.07681064f, -0.34039149f, -0.45489523f, -0.05533326f, 0.04580078f, -0.01309203f, -0.24286360f, 0.05808723f, 
    -0.01943181f, 0.02830534f, -0.13298242f, 0.04897663f, -0.21533339f, 0.00611785f, -0.10739640f, -0.22524288f, 
    -0.01908369f, -0.01956141f, -0.06400374f, -0.04936024f, -0.06770964f, 0.04798371f, 0.13167559f, -0.02100905f, 
    0.08846547f, 0.15554422f, -0.04479066f, 0.04580888f, 0.11320644f, 0.02478153f, -0.11084630f, -0.40663761f, 
    -0.03619030f, -0.10530360f, 0.12510405f, -0.10456454f, 0.12540738f, -0.09038997f, -0.49298659f, 0.05099550f, 
    0.05814025f, -0.18124211f, 0.16283849f, 0.03077044f, 0.03888372f, 0.13118565f, -0.10406516f, -0.04585202f, 
    0.19257474f, -0.01119821f, -0.00323697f, 0.09183647f, 0.06320315f, 0.21339433f, 0.13558190f, 0.08810447f, 
    0.11691189f, 0.07169337f, -0.38051373f, -0.15548620f, -0.20530985f, -0.03172374f, -0.20335692f, -0.04511381f, 
    -0.73929083f, -0.72509617f, 0.14284393f, -0.02620020f, -0.05794418f, 0.05794639f, -0.08128588f, -0.16049014f, 
    0.07995792f, 0.38764018f, -0.09986899f, -0.27098027f, 0.15067998f, 0.15449461f, 0.01975257f, -0.06298029f, 
    -0.04641539f, 0.03248043f, -0.16906032f, -0.32114306f, -0.21531107f, -0.00368216f, 0.12572958f, 0.09315367f, 
    -0.01667296f, -0.06437697f, 0.23454954f, -0.26354617f, -0.42197788f, -0.31683922f, 0.08103125f, -0.08240629f, 
    -0.18343273f, -0.01789184f, 0.12944403f, 0.12829892f, 0.05857327f, -0.16966735f, -0.07549124f, 0.06972314f, 
    0.09128904f, -0.00805160f, 0.03352426f, 0.01160896f, -0.04606506f, 0.11483551f, 0.08346079f, 0.31031045f, 
    -0.18964417f, -0.05891709f, -0.15005481f, -0.25549436f, -0.09004061f, -0.28247306f, -0.57996666f, -0.17269860f, 
    -0.02172192f, 0.19066951f, 0.09486396f, -0.02145205f, -0.01762884f, -0.09032752f, 0.22650233f, 0.48606992f, 
    0.05743883f, -0.21570431f, 0.03307669f, 0.11933733f, 0.14076947f, -0.01943593f, 0.19023430f, 0.06138398f, 
    -0.00689025f, 0.08853493f, 0.06382115f, 0.08394134f, -0.08523212f, 0.15158707f, 0.15735100f, 0.02777939f, 
    0.17708656f, 0.30835950f, -0.40298590f, -0.01619011f, -0.03133565f, 0.26650518f, 0.30445185f, 0.09467547f, 
    -0.24043778f, -0.12699746f, -0.03733032f, 0.15205558f, 0.05690959f, 0.04481002f, 0.01978976f, 0.05411499f, 
    0.29549956f, -0.23880753f, -0.17082271f, -0.00999416f, 0.09899438f, 0.18331803f, 0.01736101f, 0.06038274f, 
    -0.16892767f, -0.00055242f, 0.05488868f, 0.11193194f, -0.11868057f, 0.06600904f, 0.21400183f, 0.07686714f, 
    0.09432300f, -0.37903818f, 0.26573521f, 0.03228828f, -0.17731825f, 0.17773865f, -0.07888705f, -0.11853575f, 
    -0.09646898f, 0.01854114f, -0.07486031f, 0.01515093f, -0.01642592f, -0.12859441f, -0.07076532f, 0.08181100f, 
    0.15719043f, -0.20604497f, -0.20254780f, -0.48219034f, 0.02279049f, -0.20106417f, 0.10113008f, 0.45887312f, 
    0.08140017f, 0.13230199f, -0.17900740f, -0.21063554f, -0.16170354f, 0.17288086f, 0.10390706f, 0.12953646f, 
    -0.28774095f, -0.43260968f, 0.01987562f, 0.11936070f, -0.19400091f, -0.37475908f, 0.19294259f, 0.18358625f, 
    0.20582032f, 0.37101564f, 0.06680968f, 0.04539119f, 0.17238370f, 0.20914407f, 0.04696006f, 0.12392166f, 
    0.14749692f, -0.01644297f, -0.06898956f, 0.03073792f, -0.34474215f, -0.07413610f, -0.14265750f, -0.08820918f, 
    0.31791708f, 0.25228044f, 0.08182538f, 0.00671879f, 0.02473569f, -0.12210613f, 0.22479840f, -0.15540870f, 
    0.19215162f, 0.06406701f, 0.11767517f, 0.16991338f, 0.14325549f, 0.03117484f, 0.19975126f, -0.22528756f, 
    0.25707871f, 0.12280174f, 0.17015146f, 0.16499868f, 0.39628068f, -0.51606709f, -0.21663560f, 0.04702485f, 
    -0.01354324f, 0.00105634f, -0.37693787f, 0.11954120f, -0.29926214f, -0.06106006f, 0.27266201f, -0.10925438f, 
    -0.31168106f, 0.24600253f, -0.12456153f, 0.15677443f, 0.18541206f, 0.15244175f, 0.02020846f, -0.04935430f, 
    -0.22071604f, -0.04230988f, -0.23635034f, 0.00728789f, -0.18385756f, 0.03952409f, 0.09875157f, 0.05486422f, 
    -0.20001073f, -0.05641404f, -0.03034948f, 0.02434387f, -0.00481075f, -0.03165074f, -0.15749480f, -0.22492000f, 
    0.05313690f, -0.09184693f, -0.32160342f, -0.19390006f, -0.03903706f, 0.03555369f, -0.22453719f, 0.09921234f, 
    0.23351066f, 0.25138739f, 0.33680278f, 0.20507289f, 0.15718560f, -0.10526263f, -0.00616701f, 0.16528729f, 
    0.07954086f, 0.09676079f, 0.04062664f, -0.13731293f, -0.09735824f, -0.01571489f, 0.06415897f, 0.14195879f, 
    -0.06368864f, 0.08030692f, 0.09054397f, 0.15685315f, -0.21742445f, -0.03363048f, -0.08299843f, -0.16922905f, 
    -0.15972883f, 0.01377345f, -0.02893835f, -0.05405603f, 0.02019789f, 0.28354988f, -0.20072643f, -0.28444216f, 
    0.24369206f, -0.00407852f, 0.05796873f, 0.02123546f, 0.29893455f, 0.09479168f, -0.12289608f, 0.16410604f, 
    0.14445390f, -0.01378403f, 0.04663039f, 0.08953997f, 0.05697633f, 0.17506684f, 0.10537325f, -0.17474943f, 
    -0.16556655f, -0.23519252f, 0.06550843f, -0.06316145f, 0.09486683f, -0.07869078f, 0.03221000f, 0.10317200f, 
    -0.51540953f, -0.02163019f, 0.27961263f, -0.15929759f, 0.10829242f, -0.02035271f, -0.01327389f, -0.08638237f, 
    0.03589704f, -0.21416193f, -0.26356998f, -0.23265462f, -0.11075952f, -0.06239525f, 0.01663366f, 0.01395376f, 
    0.07900662f, 0.16293377f, 0.17025039f, -0.21500392f, -0.33927962f, -0.09514683f, 0.01171180f, -0.10286311f, 
    0.24935447f, 0.10728601f, -0.06304763f, -0.14762673f, -0.44568196f, -0.18456227f, -0.11172240f, 0.08291611f, 
    -0.06899217f, -0.03156297f, 0.20905620f, -0.12730104f, 0.32600603f, 0.18001863f, 0.34757721f, 0.20095418f, 
    0.25465244f, 0.18559198f, 0.12548326f, 0.29587796f, 0.35374540f, -0.20048776f, -0.07889890f, -0.11813623f, 
    -0.00030137f, -0.15203799f, -0.32984897f, 0.20580295f, 0.12896053f, 0.49376118f, -0.31874835f, -0.52523744f, 
    -0.33616498f, -0.17308414f, -0.12335888f, -0.15825012f, 0.15464106f, 0.10373789f, 0.12715285f, 0.22020996f, 
    -0.18764858f, -0.34675846f, 0.25124216f, 0.08695243f, -0.28777462f, -0.10587481f, 0.31661329f, -0.07739546f, 
    -0.07386949f, 0.16844320f, -0.00357199f, 0.01564313f, -0.03720108f, 0.23142679f, 0.24907084f, 0.16746157f, 
    0.21225902f, -0.21810216f, -0.51741683f, -0.19424736f, 0.02077373f, -0.18223974f, 0.00588994f, 0.05930828f, 
    -0.13402550f, 0.12288383f, 0.22532944f, 0.22289236f, -0.00532589f, -0.20165278f, -0.00011539f, -0.03128147f, 
    -0.05227998f, -0.13215144f, 0.18532634f, -0.00218230f, -0.05249822f, 0.04038453f, 0.18228222f, 0.02663441f, 
    0.27258605f, 0.00262779f, 0.27569631f, 0.16180915f, 0.17646807f, 0.16441284f, 0.05703861f, 0.03410551f, 
    -0.08810896f, 0.27038637f, -0.12714595f, -0.05464000f, -0.02379290f, -0.04269620f, -0.25218707f, 0.01823464f, 
    0.14033921f, -0.08453383f, 0.05275784f, 0.03991041f, 0.13695996f, 0.14515069f, -0.15709564f, -0.20325087f, 
    -0.18930665f, -0.34754238f, 0.02889714f, -0.61367989f, -0.19034639f, 0.06052132f, 0.17836356f, 0.04267820f, 
    0.08436961f, 0.13775581f, 0.04751111f, -0.21570450f, 0.06128976f, 0.05643855f, 0.22613965f, 0.55452251f, 
    -0.13056320f, 0.63986659f, -0.57368052f, -0.21320428f, -0.11969425f, -0.05615562f, -0.26364362f, 0.01026484f, 
    -0.15471210f, -0.04796170f, 0.54807931f, 0.10524767f, -0.01222217f, -0.11124246f, -0.38227624f, -0.08076078f, 
    0.10095252f, -0.15829352f, -0.32618305f, -0.48480791f, -0.15287340f, 0.10171899f, -0.14254513f, 0.11241020f, 
    0.04912221f, 0.00287462f, 0.29018399f, -0.20249052f, -0.27801621f, 0.00845638f, 0.04696025f, 0.25299558f, 
    0.20904636f, -0.08801802f, 0.04944120f, 0.22622545f, 0.23659311f, -0.45659223f, 0.18712470f, -0.11801489f, 
    0.21915364f, 0.40709040f, 0.41630352f, 0.03103740f, 0.09454568f, -0.10623056f, -0.67880297f, -0.58115351f, 
    0.11584703f, 0.34933782f, 0.12003067f, -0.10119865f, 0.26743346f, -0.13482802f, -0.39808542f, -0.28214347f, 
    0.01447068f, 0.11679395f, 0.27865189f, -0.05687183f, -0.04697532f, -0.10125795f, 0.04028712f, 0.19265145f, 
    -0.46715859f, -0.02898227f, -0.10421428f, 0.10963447f, 0.19168720f, 0.01341841f, 0.13639745f, 0.14225581f, 
    0.76352584f, 0.31013438f, -0.15404265f, 0.36531293f, 0.25268704f, 0.24130477f, 0.10496864f, 0.01432550f, 
    -0.09838669f, 0.27598968f, 0.39428559f, -0.00962241f, -0.08894438f, -0.10203522f, -0.19123192f, -0.02658535f, 
    0.16926180f, 0.11030477f, -0.06060669f, 0.53905404f, -0.00547964f, -0.17291999f, -0.03376129f, -0.00195350f, 
    -0.04302555f, -0.08142402f, -0.15251648f, -0.00709376f, -0.34506908f, -0.45785069f, 0.23164251f, 0.05808137f, 
    0.07129391f, -0.05874244f, 0.07898002f, -0.17021659f, -0.69679183f, -0.56745434f, -0.75078851f, 0.26559076f, 
    -0.15538780f, 0.04774692f, -0.07261599f, 0.19739786f, 0.42790854f, 0.08895821f, 0.32788059f, -0.07361221f, 
    -0.24916218f, -0.14460598f, 0.02446281f, -0.07331642f, 0.16377065f, 0.39476103f, -0.69654500f, -0.34647787f, 
    -0.28651032f, -0.32987961f, -0.15268460f, 0.14290750f, 0.11692203f, 0.21765906f, 0.12366937f, -0.40646881f, 
    -0.82833689f, -0.06186205f, -0.03325146f, -0.30697551f, -0.14592695f, -0.02121621f, 0.18286628f, 0.18150733f, 
    -0.60391945f, -0.42180929f, -0.25071332f, -0.37297660f, -0.35743609f, 0.21330512f, -0.10824522f, 0.26862407f, 
    0.19963005f, 0.04639066f, 0.22333279f, 0.03600498f, -0.05149109f, -0.18949850f, 0.32841507f, -0.27363700f, 
    0.01886441f, -0.03808003f, 0.18144904f, 0.21980414f, 0.48109508f, -0.16998751f, -0.03046195f, -0.26217270f, 
    0.17893672f, 0.20480677f, 0.01913033f, -0.20294844f, 0.35803786f, -0.03653370f, -0.06286301f, -0.20400521f, 
    0.02517102f, -0.01593087f, 0.00303906f, 0.23002487f, 0.30385199f, 0.32295257f, 0.08532421f, -0.02854789f, 
    0.00753540f, 0.04054810f, -0.11334803f, 0.06613841f, -0.06198484f, 0.30883276f, -0.62733090f, 0.63214374f, 
    0.13454153f, -0.08684380f, -0.28815505f, -0.13908957f, 0.29057002f, 0.31239870f, -0.07919189f, 0.64189577f, 
    -0.01849591f, -0.12121224f, -0.02372647f, 0.03747506f, -0.25019842f, -0.11424841f, -0.01307121f, -0.34988198f, 
    -0.13825788f, 0.04749735f, -0.00487025f, -0.01601884f, -0.07219939f, 0.01067938f, 0.20963006f, -0.04229565f, 
    -0.09307719f, 0.02385876f, 0.14195946f, -0.01625280f, -0.05678933f, -0.00319526f, 0.00287076f, -0.03414954f, 
    0.02099223f, 0.10775764f, -0.18315923f, 0.40862024f, -0.02546465f, -0.05921873f, -0.01080639f, -0.15854715f, 
    -0.17249568f, -0.07428742f, -0.77991802f, -0.08639292f, 0.25379905f, -0.08483347f, -0.26338762f, -0.13025820f, 
    0.11397035f, -0.03538487f, -0.32854211f, -0.26895261f, 0.11903550f, -0.21183573f, 0.01367394f, -0.19448669f, 
    -0.36531401f, 0.09653099f, 0.19034307f, 0.08520344f, 0.65914291f, -0.12951037f, 0.01559682f, 0.03199384f, 
    -0.11366511f, -0.14294170f, 0.09166596f, 0.12903902f, -0.05146176f, 0.32351282f, 0.22362660f, -0.00660673f, 
    0.07003319f, 0.05715941f, 0.17130445f, 0.03477697f, -0.15019421f, 0.01446132f, 0.18612887f, -0.15733354f, 
    -0.33953649f, 0.15540850f, -0.17270859f, -0.15250303f, 0.08321296f, 0.07053141f, 0.09621246f, 0.26399523f, 
    -0.26896301f, -0.08414055f, 0.28806841f, 0.04764120f, 0.06015293f, -0.01432471f, 0.00333720f, 0.04427350f, 
    0.35280433f, -0.00599257f, -0.28983179f, 0.19068103f, -0.01976426f, 0.07125011f, 0.09620504f, -0.01954279f, 
    -0.07546406f, -0.14586839f, -0.08633820f, -0.08224001f, 0.14501303f, 0.12194107f, 0.09036877f, -0.46364951f, 
    -0.48102745f, -0.42252004f, 0.02961748f, -0.09973480f, 0.04203481f, 0.15588698f, 0.08512239f, 0.00940867f, 
    -0.10120119f, -0.12698132f, -0.01870945f, 0.16167249f, -0.07838105f, -0.10759582f, 0.23465177f, 0.18189831f, 
    -0.02680502f, -0.11207557f, 0.12390690f, 0.19951816f, -0.03532029f, 0.10011335f, -0.19967873f, 0.03140303f, 
    0.16396689f, -0.23576052f, 0.05937783f, 0.09872090f, -0.01714175f, 0.02134797f, -0.00708473f, -0.09781801f, 
    0.00470452f, 0.09229243f, 0.11740490f, 0.22256467f, -0.01939076f, -0.17668921f, 0.21510571f, -0.06675292f, 
    -0.27564558f, 0.28993273f, -0.10020466f, 0.08855922f, 0.19001842f, 0.10142757f, 0.00201269f, -0.01920651f, 
    0.05424798f, -0.09203782f, -0.01338836f, 0.01505190f, -0.02812525f, 0.00487603f, 0.12853329f, 0.11759336f, 
    -0.10386066f, -0.11545271f, -0.48075542f, 0.01492220f, -0.06490014f, 0.05895687f, -0.07924185f, -0.01220825f, 
    -0.07661286f, 0.37578067f, 0.05958652f, 0.68598998f, 0.10044130f, 0.15647262f, -0.14898312f, 0.06029392f, 
    0.00913193f, -0.18143976f, 0.02344347f, -0.00089596f, 0.06597982f, 0.14055625f, 0.06626651f, 0.03606895f, 
    0.06629261f, 0.07448136f, -0.73834330f, 0.09144889f, 0.08095705f, -0.14563572f, 0.16633761f, -0.14263159f, 
    -0.18396692f, 0.07178534f, 0.19463481f, 0.21892411f, -0.04608315f, 0.11351514f, -0.09154545f, 0.16862623f, 
    -0.01519696f, -0.38875514f, 0.00143889f, 0.18362185f, 0.24124314f, 0.29208589f, 0.21855475f, 0.19371158f, 
    -0.10801973f, 0.02339243f, 0.15602735f, 0.02768004f, 0.11471133f, -0.13976234f, -0.04860291f, -0.18188444f, 
    -0.13469714f, 0.05186100f, 0.05538441f, -0.02399240f, -0.07775901f, -0.00659905f, -0.01904948f, 0.10541665f, 
    -0.00054999f, 0.01140244f, 0.13727526f, -0.08536754f, 0.04308953f, -0.02679114f, 0.05069260f, 0.02151624f, 
    -0.37610137f, -0.16580044f, -0.37021676f, 0.14122385f, 0.14946407f, 0.06035189f, 0.02161381f, 0.16653575f, 
    -0.03502320f, 0.26208398f, 0.11642729f, 0.22277725f, 0.06164644f, -0.01857241f, -0.06001491f, 0.19061515f, 
    0.16451201f, 0.17741995f, -0.18289985f, -0.13770737f, 0.02260870f, 0.06713095f, 0.11409766f, -0.13887101f, 
    0.06680701f, 0.18400617f, -0.04149880f, 0.26969391f, 0.62739468f, 0.78222293f, 0.12182104f, 0.17217590f, 
    0.09559322f, 0.14419705f, 0.11054325f, -0.59110713f, 0.37392780f, 0.34107658f, 0.41535148f, 0.00159745f, 
    0.07610310f, 0.11864679f, -0.06519391f, 0.16203316f, 0.13456960f, -0.11573370f, -0.01085517f, 0.05109202f, 
    -0.09349771f, 0.10727719f, -0.01834871f, 0.12224983f, -0.39683494f, -0.36233377f, 0.22672035f, -0.00457086f, 
    -0.04415061f, 0.01352161f, 0.09963603f, -0.09891487f, 0.13797846f, 0.05384614f, 0.15444790f, 0.18319634f, 
    -0.06764431f, 0.15977609f, -0.00702622f, -0.36075249f, -0.38178435f, 0.09842604f, -0.00675898f, 0.00694333f, 
    -0.17674248f, -0.12920621f, -0.23146476f, -0.02475540f, 0.07261949f, -0.15537500f, 0.03019347f, 0.19501914f, 
    0.14447878f, -0.20473841f, 0.14112009f, 0.02511759f, -0.30606607f, -0.19401993f, 0.12398987f, 0.00790024f, 
    0.35003522f, 0.14998555f, 0.00855698f, -0.16699100f, 0.06374243f, 0.02175261f, 0.07434249f, 0.07284828f, 
    -0.37474674f, 0.04350187f, -0.39106393f, -0.10908740f, -0.11146746f, -0.01122465f, 0.13019526f, 0.00614970f, 
    -0.04404385f, -0.24313965f, -0.18699341f, 0.01226563f, 0.01650229f, -0.25776893f, -0.29894394f, -0.17306836f, 
    0.01522115f, 0.10476708f, -0.19334793f, -0.26179779f, -0.56204617f, 0.23052458f, 0.31581369f, 0.43679169f, 
    0.02618157f, 0.02242631f, 0.04842882f, 0.11989233f, 0.02517080f, 0.01283619f, -0.04245934f, 0.13972774f, 
    0.05313997f, 0.31353107f, 0.16074686f, -0.13874805f, 0.16575938f, 0.05652321f, -0.01839473f, -0.32118255f, 
    -0.29235160f, -0.18280886f, 0.26860532f, 0.17763057f, -0.15182619f, 0.08377875f, -0.27607408f, -0.14580058f, 
    -0.02564365f, -0.05887928f, 0.02984805f, 0.03967954f, -0.00954042f, 0.08035606f, -0.23233363f, -0.07741766f, 
    0.00792960f, -0.34945843f, -0.06285889f, 0.04498233f, -0.03308231f, 0.09859052f, 0.07832795f, 0.07676247f, 
    -0.03491508f, 0.18783462f, 0.46413159f, -0.04754891f, 0.03020783f, -0.10461080f, -0.12302815f, -0.23818034f, 
    -0.14215854f, -0.01241408f, 0.15991856f, 0.11235081f, 0.06568739f, 0.00649348f, -0.02477141f, 0.01985449f, 
    0.08689708f, 0.09177314f, -0.02668440f, -0.02785673f, 0.28044406f, 0.11301809f, 0.21363817f, 0.15428939f, 
    0.23472197f, 0.04496566f, 0.07292124f, 0.34212893f, 0.01834043f, 0.21129830f, -0.00236029f, 0.11304437f, 
    -0.30470371f, -0.06494352f, -0.01999863f, 0.04312396f, 0.01080253f, -0.22632527f, 0.09259117f, 0.02131560f, 
    -0.15180507f, -0.03537994f, -0.10003255f, 0.28279796f, -0.14071070f, 0.04857128f, -0.12202395f, 0.24906981f, 
    0.14979725f, -0.07081042f, -0.08778346f, 0.09120186f, -0.07446828f, -0.10459106f, 0.11586767f, -0.18500745f, 
    -0.27100289f, -0.80109578f, -0.69500905f, -0.20417844f, 0.16962408f, 0.07873020f, 0.00681848f, 0.07521291f, 
    0.12949832f, -0.15116625f, -0.30220369f, 0.04065467f, -0.05823186f, -0.33787563f, -0.03728016f, 0.06905972f, 
    0.09870933f, 0.12501994f, -0.04213134f, 0.20926592f, -0.22501643f, 0.11007083f, 0.10876494f, 0.13095948f, 
    0.07141479f, -0.00151059f, 0.05503631f, -0.04348157f, 0.11807396f, 0.00211282f, 0.05261852f, 0.06283607f, 
    -0.08945508f, 0.15643901f, 0.15509233f, 0.10841277f, -0.38220522f, 0.01635802f, -0.01552374f, 0.05043829f, 
    0.07414059f, -0.11335883f, 0.14718483f, -0.11443806f, -0.02970880f, -0.47397777f, -0.25792828f, -0.26227796f, 
    -0.12709443f, 0.02068221f, 0.07095742f, 0.13273221f, -0.12103589f, -0.03229911f, 0.59168315f, 0.05549046f, 
    0.10119675f, -0.09640823f, 0.08517305f, 0.03867904f, 0.09009786f, 0.09440712f, 0.03828643f, -0.30494729f, 
    -0.03385307f, -0.20307790f, -0.09003301f, -0.04567671f, -0.07621768f, 0.07280765f, 0.07731421f, 0.02080005f, 
    0.73403925f, 0.04277607f, 0.07443005f, -0.21205971f, -0.22077003f, -0.02088736f, -0.18650384f, 0.09722887f, 
    -0.02296086f, -0.45863786f, 0.03657546f, 0.10628949f, 0.07077315f, -0.02283054f, 0.14302655f, 0.03428791f, 
    -0.08001575f, 0.02828504f, 0.21862552f, -0.03988760f, -0.05678450f, 0.05865425f, 0.09920643f, 0.15176801f, 
    -0.19944458f, 0.09816935f, 0.06007701f, -0.33470884f, -0.11381832f, -0.87083316f, -0.00746679f, -0.34166473f, 
    -0.07143184f, 0.17015098f, 0.09631993f, 0.01497407f, -0.68578953f, -0.57774568f, -0.10652287f, 0.26668936f, 
    0.25226063f, 0.10389050f, 0.19362089f, 0.02242468f, 0.01856476f, -0.10767766f, -0.06221069f, -0.18879692f, 
    -0.03705579f, -0.09921010f, -0.19114755f, 0.04291622f, -0.05853545f, 0.05388274f, -0.09541909f, 0.02573660f, 
    0.09793043f, 0.09190155f, -0.38311806f, 0.03418756f, 0.03890456f, -0.23910855f, 0.03401098f, -0.18696882f, 
    -0.16013139f, 0.14225401f, 0.06525948f, 0.15929204f, -0.03216082f, 0.08045978f, 0.01833978f, -0.08533993f, 
    0.18451460f, -0.09821767f, 0.15287067f, 0.05683055f, -0.06344067f, 0.02184966f, -0.04363381f, 0.07605924f, 
    0.03790713f, -0.46479920f, -0.09139812f, -0.20232798f, -0.23972462f, 0.23396872f, -0.05734968f, 0.34054697f, 
    0.03669875f, -0.15932193f, 0.20304498f, 0.05877616f, 0.14667340f, -0.03066031f, -0.00552732f, 0.03338673f, 
    -0.01213107f, 0.00488512f, 0.13417496f, -0.01673081f, 0.03015601f, 0.00327073f, -0.06505492f, 0.03178270f, 
    -0.01877611f, -0.00524519f, 0.04266058f, 0.10126147f, -0.28825846f, -0.05215436f, -0.14251213f, -0.10026739f, 
    0.05417434f, -0.06547078f, -0.08694556f, -0.15967141f, 0.20838386f, 0.26346925f, -0.28899509f, -0.44642872f, 
    0.15062101f, 0.21648370f, -0.04434232f, 0.11869536f, 0.06885280f, 0.01631030f, 0.14722160f, 0.00833001f, 
    -0.10619514f, -0.17889090f, -0.09538724f, 0.02608495f, -0.03000924f, -0.01056834f, 0.05035998f, 0.21034640f, 
    -0.02237104f, -0.20651218f, 0.00452481f, -0.02467968f, 0.14653087f, 0.02591729f, -0.00639996f, 0.39852354f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.02645049f, 0.02724632f, -0.03137066f, -0.09792926f, 0.15269160f, 0.28599247f, 0.16249132f, 0.02388473f, 
    0.15288465f, -0.05950582f, 0.31326917f, 0.00802996f, 0.12464945f, 0.20756707f, -0.04798996f, 0.21772967f, 
    0.02185390f, 0.10627649f, -0.21372861f, -0.01738630f, 0.12712678f, 0.01181109f, 0.54155368f, -0.01742238f, 
    -0.00471510f, 0.22400802f, 0.02887368f, 0.21918176f, 0.36222085f, -0.03166270f, 0.03733406f, 0.18292391f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.14521749f, -0.09723124f, 0.43307409f, 0.40927085f, 0.07594368f, -0.23144896f, -0.20088248f, 0.01283224f, 
    -0.07275786f, -0.16897883f, -1.13603425f, 0.01861809f, -0.46536547f, -0.18682463f, -0.00311735f, -0.11150542f, 
    0.05295341f, -0.50482684f, 0.17935827f, 0.04273301f, -0.09104415f, 0.05593400f, -0.01071905f, 0.01186132f, 
    0.02608583f, -0.53430849f, -0.15376747f, -0.04365172f, -0.41261587f, 0.62104619f, 0.16593905f, -0.20489541f, 
    -0.16938554f, -0.14436994f, 0.16633475f, -0.16327791f, 0.34803382f, 0.20615329f, -0.02578938f, -0.16580957f, 
    -0.13561514f, -0.15526438f, 0.38811326f, -0.10306776f, -0.30860433f, -0.31199330f, -0.03631848f, 0.36563554f, 
    -0.08604649f, 0.21644941f, -0.56064868f, -0.03037030f, 0.27127817f, -0.01750294f, 0.13386790f, -0.43584082f, 
    0.00898734f, -0.33128601f, -0.07337121f, 0.22831768f, -0.11643656f, 0.50772250f, -0.19155632f, 0.32296044f, 
    0.12353151f, -0.14846011f, -0.24001205f, -0.11776581f, -0.17418908f, -0.35222143f, 0.34019500f, 0.05320704f, 
    0.38569760f, 0.02704998f, 0.32851976f, 0.21697851f, 0.21330883f, 0.11792795f, 0.06555085f, -0.47498590f, 
    -0.18969819f, -0.46477202f, -0.07143274f, 0.11051713f, -0.13028058f, 0.04319707f, 0.16946901f, -0.63456398f, 
    0.12629598f, -0.09690417f, -0.00787847f, 0.53091395f, 0.32570735f, -0.46988627f, -0.31329933f, -0.87978095f, 
    0.08753502f, 0.13569194f, -1.11683464f, -0.19042332f, -0.01321263f, 0.12733690f, -0.66648459f, 0.12149533f, 
    -0.44142488f, 0.07350878f, -0.41007999f, 0.06527581f, 0.60033041f, -0.59619623f, -0.08005680f, -0.12663662f, 
    -0.36771059f, 0.31696409f, 0.48121938f, 0.13643000f, -0.52376419f, 0.13145247f, -0.31307510f, 0.42424467f, 
    -0.01050829f, -0.48592818f, -0.06955303f, -0.04757625f, 0.60938746f, 0.14791742f, 0.16059448f, -1.04822838f, 
    -0.02771509f, -0.02414838f, 0.31993675f, 0.00083434f, 0.54429221f, -0.39762029f, -0.15225574f, 0.15602854f, 
    -0.17768954f, 0.14977500f, 0.22965634f, 0.20313159f, 0.05336651f, 0.12588389f, -0.14036931f, -0.04752555f, 
    0.03928664f, 0.15249896f, 0.00088681f, -0.16205402f, -0.07720291f, -0.15303752f, 0.15838517f, 0.33416891f, 
    -0.16452536f, -0.10606979f, -0.07512079f, -0.26132503f, -0.50647658f, -0.38076296f, 0.07965005f, -0.00733621f, 
    -0.07879981f, -0.04474095f, 0.02087866f, 0.09167781f, -0.20929874f, -0.11809882f, 0.46306002f, 0.02566062f, 
    -0.52539706f, -0.11772176f, -0.10911129f, -0.26275033f, 0.33263087f, 0.31528255f, 0.03471506f, 0.24400651f, 
    0.10721965f, -0.06011667f, -0.30864677f, 0.14832377f, 0.05158497f, 0.14131293f, 0.05061129f, -0.26210117f, 
    0.01315908f, 0.15215810f, -0.02273241f, -0.52193582f, 0.03557752f, 0.26933795f, 0.33290562f, -0.35786524f, 
    -0.07503510f, 0.11526407f, 0.01775327f, -0.29231188f, -0.90664881f, -0.26288149f, -0.20953543f, 0.10764383f, 
    0.55814046f, 0.14862642f, 0.28966370f, -0.02156545f, -0.36450967f, 0.30158988f, 0.08362692f, 0.24907483f, 
    0.27492210f, -1.04121315f, 0.36799234f, 0.14788088f, -0.35284093f, 0.09521130f, 0.51015323f, -0.54253501f, 
    -0.05158760f, 0.22276336f, -0.09922370f, -0.16020425f, 0.09576048f, -0.50834221f, -0.44746682f, 0.17492993f, 
    0.04905000f, -0.04179883f, -0.32275909f, -0.23481239f, 0.37038374f, 0.03025405f, 0.05450296f, -0.16155002f, 
    0.00931442f, -0.02880809f, -0.30123687f, -0.07982685f, 0.17372964f, -0.54739678f, 0.09611259f, 0.15169580f, 
    0.52955151f, 0.45290998f, 0.26635817f, 0.16925475f, -0.18016230f, -0.07855523f, -0.42693707f, 0.13301624f, 
    -0.02211771f, 0.03306511f, -0.12778988f, 0.37677732f, -0.36053216f, -0.26572472f, -0.14740437f, -0.26418117f, 
    -0.04374188f, -0.07676673f, 0.10866109f, 0.10436860f, -0.48224708f, 0.35954797f, 0.13288924f, -0.06479806f, 
    0.43666545f, -0.01868028f, 0.14062451f, -0.57939643f, -0.28658497f, -0.88822949f, -0.00806889f, -0.39650065f, 
    -0.30070379f, 0.27226129f, 0.01472967f, 0.01367132f, 0.08963888f, 0.13415003f, -0.27870861f, -0.67154777f, 
    0.09125800f, 0.11926520f, -0.11690675f, -0.09336252f, 0.38047746f, -0.37231988f, 0.40412751f, 0.31409386f, 
    0.11857826f, 0.13079914f, -0.02999197f, -0.22590381f, 0.40121356f, 0.60970300f, -0.33399430f, 0.08253984f, 
    -0.23428881f, 0.09447061f, -0.54686737f, 0.40904883f, 0.32040915f, 0.05871784f, -0.15495065f, 0.29654932f, 
    -0.40311924f, -0.37487042f, -0.08948398f, -0.14090075f, -0.27200913f, -0.05613646f, 0.64856589f, 0.05333609f, 
    0.14498004f, 0.24591205f, -0.08328097f, -0.11283697f, -0.07541635f, -0.64603323f, -0.41064429f, -0.27622384f, 
    0.02347421f, 0.14099106f, 0.78641713f, 0.05089973f, -1.03371942f, 0.17069499f, -0.31607115f, 0.11771736f, 
    -0.38902166f, 0.12493115f, 0.24595879f, -0.52487648f, -0.41852689f, 0.54895461f, 0.07213220f, -0.36081460f, 
    0.34183094f, -0.61465949f, -0.55949783f, 0.13771509f, 0.20071253f, 0.06521036f, -0.32996374f, 0.58639121f, 
    0.09092088f, 0.31984675f, 0.15990418f, 0.26559737f, 0.03370532f, 0.13290432f, 0.03078851f, -0.16962573f, 
    0.03297830f, -0.18068971f, -1.06535161f, 0.52780730f, -0.19480415f, 0.10203227f, -0.02067537f, -0.07912275f, 
    0.17675248f, 0.08296180f, 0.27677873f, 0.11778290f, -0.51607805f, 0.17969871f, 0.00400233f, -0.45776799f, 
    -0.80542719f, 0.54425418f, -0.09744074f, -0.00906695f, -0.06174061f, 0.00209520f, -0.22091846f, -0.00709313f, 
    -0.03247053f, 0.44119793f, 0.14396650f, -0.68822753f, 0.02588543f, -0.45061827f, -0.48824358f, 0.79188609f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.15202686f, -0.19668917f, 0.17759797f, 0.23343755f, -0.11489454f, -0.08159551f, -0.05169183f, -0.22757515f, 
    0.25202373f, 0.08252328f, 0.16004354f, 0.00375925f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
