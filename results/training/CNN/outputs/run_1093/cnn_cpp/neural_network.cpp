#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.62863660f, 0.07460520f, -0.19110323f, -0.62278765f, -0.18668878f, -0.42447937f, 0.46376243f, 0.41329032f, 
    -0.22258085f, 0.42742580f, 0.22688253f, 0.11041225f, -0.06575844f, 0.73208606f, -0.80240798f, 0.03551523f, 
    0.11318127f, 0.11016610f, -1.10034549f, -0.30375472f, -0.37631497f, 0.80857283f, 0.70218277f, -0.17148134f, 
    0.12727900f, -0.25255460f, -0.42096978f, -0.58268875f, 1.35854590f, -0.61937380f, 0.04920158f, 0.04753539f, 
    0.38675633f, 0.23009905f, -0.08588918f, 0.54280192f, 1.06309605f, 0.32410410f, 0.51203775f, 0.29867375f, 
    0.30676302f, 0.23330611f, 0.34575900f, 0.34588224f, 0.77419257f, 0.71333146f, -0.86383694f, -0.31744877f, 
    -0.46594027f, 0.15544146f, -0.30193755f, -0.45210451f, -0.41989121f, -0.13775733f, -0.33118501f, -0.01273300f, 
    0.16335461f, 0.39597988f, -0.39196533f, 0.07053167f, 0.27519962f, 0.51378751f, 0.58508563f, -0.54775631f, 
    -0.83813965f, 0.97079575f, 0.26746380f, -0.35117295f, 0.82374388f, 0.10682946f, -0.07626102f, -0.01846592f, 
    -0.00351431f, -0.39372024f, -0.26599145f, 0.52638507f, 0.33391267f, 0.73613948f, -0.51847768f, -0.38456953f, 
    -0.36009511f, -0.10128497f, 0.72442126f, 0.53000623f, 0.07491165f, 0.55534595f, 0.33695868f, 0.41549042f, 
    -0.44866261f, -0.19141717f, -0.13099496f, 0.53089911f, 0.17238361f, 0.25710055f, -0.65680164f, 0.22833258f, 
    -0.21032740f, -0.21628247f, 0.59261781f, -0.23597252f, -0.63855499f, -0.86571419f, -0.30948126f, 0.68928510f, 
    -0.54799557f, 0.16543587f, 0.31237057f, 0.00527976f, -0.00374904f, 0.09833901f, -0.22258155f, -0.46270141f, 
    -0.35875872f, -0.25327206f, 0.05107548f, 0.48414963f, 0.72286838f, -0.49097195f, 0.00851285f, 1.03559625f, 
    -0.41386685f, 0.37234247f, -0.43125278f, 0.02058884f, 0.27428597f, -0.19186796f, 0.75769591f, 0.58933252f, 
    -0.61237228f, -0.04717505f, -0.21703525f, 0.13659026f, -0.26891574f, 0.46437189f, -0.43297037f, -0.11490569f, 
    -0.45221278f, 0.12826313f, -0.57339895f, -0.54624939f, -0.62067896f, -0.13091658f, -0.79260820f, -0.05339888f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.26115146f, 0.28418007f, 0.07954299f, 0.19377609f, 0.34373617f, 0.11551945f, 0.27901259f, -0.26264486f, 
    0.00635969f, -0.22212601f, 0.40798664f, -0.25038245f, 0.38239184f, -0.18302445f, 0.08714686f, 0.14581664f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.38312951f, -0.56658471f, 0.19066130f, -0.06061545f, -0.00075392f, 0.19754656f, -0.09232012f, 0.02805808f, 
    0.14127843f, 0.19853632f, 0.32376444f, 0.17188661f, -0.11816213f, -0.07166360f, -0.28694656f, 0.12917338f, 
    0.11594577f, 0.25171337f, 0.60303652f, -0.08197425f, -0.37370798f, -0.09038893f, 0.13061348f, -0.24020025f, 
    0.07401346f, -0.04249341f, 0.09124823f, 0.32729986f, 0.04279823f, -0.27155590f, 0.21929894f, -0.03061501f, 
    0.08081648f, -0.14429614f, -0.06710105f, 0.06745013f, -0.02235955f, 0.10147052f, 0.19097787f, 0.10396975f, 
    -0.02208924f, 0.04802554f, 0.01985914f, -0.16667128f, 0.04729626f, -0.11185279f, -0.17346850f, 0.15398267f, 
    -0.05557885f, -0.03563206f, 0.12644449f, -0.01136355f, -0.06706714f, -0.15276738f, 0.36133257f, 0.02163584f, 
    -0.05962881f, -0.01671786f, -0.00994504f, -0.18590249f, 0.03147184f, -0.10318344f, -0.19797580f, 0.11879511f, 
    0.20213729f, -0.15318389f, -0.10576703f, -0.00736960f, 0.01247706f, 0.32963592f, 0.07364509f, -0.23642589f, 
    0.05962774f, 0.20827913f, 0.03206938f, 0.15683080f, -0.04438102f, -0.03089804f, 0.09439973f, -0.04816210f, 
    -0.19184348f, -0.16300856f, 0.06828749f, 0.27990088f, -0.18276912f, 0.07765789f, 0.05157277f, -0.03562313f, 
    -0.18375769f, 0.03498274f, -0.09630417f, 0.10675695f, -0.04957959f, -0.07120352f, 0.20237997f, -0.13134392f, 
    0.31926477f, 0.14594541f, -0.01156371f, 0.14157835f, -0.17252019f, 0.10833091f, -0.02505051f, -0.11732076f, 
    0.16721007f, 0.00781587f, 0.05066673f, -0.20483394f, 0.00223365f, -0.02540484f, 0.16332534f, 0.03294697f, 
    -0.00536742f, 0.17330202f, -0.06047876f, -0.17921947f, 0.01922076f, -0.42838329f, 0.35859343f, -0.44933993f, 
    0.03359831f, 0.21204655f, 0.28604534f, -0.02381897f, 0.16158611f, 0.10354625f, -0.12306810f, 0.08818392f, 
    0.33159441f, -0.19587721f, -0.23571163f, 0.36014554f, -0.01440220f, 0.15573344f, 0.14844254f, 0.07725634f, 
    -0.06295743f, 0.11711449f, 0.11507328f, 0.22147627f, 0.12957729f, -0.17134807f, 0.13213915f, -0.12900668f, 
    0.07361059f, 0.20770633f, 0.02450676f, 0.05580192f, -0.08530208f, -0.00763600f, 0.23461786f, -0.01797117f, 
    -0.12166463f, -0.05023196f, 0.19331235f, -0.03749097f, -0.00685525f, -0.04053636f, 0.02553598f, -0.22992180f, 
    -0.04897529f, 0.02851898f, -0.49803534f, -0.18721589f, 0.06695713f, -0.01518542f, 0.19600841f, -0.03591367f, 
    0.00879303f, -0.03786951f, 0.27133957f, -0.16804285f, 0.32691881f, 0.14030118f, -0.00790559f, 0.14731120f, 
    -0.04545445f, 0.00715368f, 0.17892949f, -0.11931135f, -0.06918236f, 0.03289203f, 0.17135496f, 0.02553030f, 
    -0.12730601f, -0.04071765f, -0.10515124f, -0.04220228f, -0.10389315f, 0.12202201f, 0.35623625f, 0.18305139f, 
    0.13555843f, -0.06412663f, -0.06829377f, -0.00672158f, 0.01603927f, 0.03591106f, -0.06961484f, -0.15644941f, 
    -0.04393804f, 0.01414603f, -0.04211405f, 0.10784112f, 0.15946719f, -0.11961719f, -0.10572627f, 0.09091209f, 
    -0.02219654f, -0.03900614f, 0.20999427f, 0.02170400f, -0.03703157f, -0.02667127f, -0.00984240f, -0.30709815f, 
    -0.46297127f, -0.12982824f, -0.08254392f, 0.14963263f, -0.20025039f, 0.19319879f, -0.14268973f, 0.25295171f, 
    -0.06497268f, 0.17094423f, 0.09552410f, -0.07160425f, 0.01278555f, 0.13524361f, -0.25360629f, 0.03891996f, 
    0.00753446f, 0.07750661f, 0.03197776f, 0.47173509f, 0.13536464f, -0.04527365f, -0.08099180f, 0.03864037f, 
    0.17374004f, -0.08368266f, -0.06619473f, -0.17649393f, 0.16483344f, 0.17017658f, 0.09518049f, 0.10406880f, 
    -0.15170349f, -0.06827544f, 0.04092517f, 0.19749123f, -0.02870164f, 0.13964838f, 0.11949448f, -0.05199983f, 
    -0.15144169f, -0.11978430f, -0.08101498f, -0.15418439f, -0.14696181f, 0.55873656f, -0.08539873f, 0.42731652f, 
    0.06640735f, 0.19114780f, -0.17322512f, -0.03986008f, -0.05631843f, 0.12941064f, 0.03312027f, 0.22611302f, 
    0.13392542f, -0.01725504f, -0.01447886f, -0.00667587f, 0.04564970f, -0.12759873f, 0.19640745f, 0.28601995f, 
    0.18280858f, 0.39773190f, 0.24318747f, -0.05058284f, 0.05728282f, 0.04515557f, -0.07496992f, 0.03401359f, 
    -0.04656423f, -0.04667962f, -0.12943840f, 0.06005288f, -0.01410702f, 0.28642404f, 0.07104417f, 0.36023596f, 
    0.01013555f, 0.01335765f, -0.00914316f, -0.13241619f, 0.05011087f, -0.08894999f, 0.02180598f, 0.10367529f, 
    0.06982598f, 0.13250144f, -0.14937757f, 0.19708015f, 0.00428757f, 0.04653111f, 0.03555650f, -0.03832727f, 
    -0.16566861f, -0.19730140f, -0.24511455f, 0.25475875f, 0.09051093f, 0.18125659f, 0.15075105f, -0.00217544f, 
    0.19358434f, 0.20684482f, 0.07591267f, -0.11544581f, 0.04008166f, 0.16258693f, 0.14914930f, 0.19229244f, 
    0.04668939f, 0.07863854f, -0.09688254f, -0.11932532f, 0.23857717f, 0.13763002f, 0.02590442f, 0.22250293f, 
    0.17778654f, 0.12239733f, -0.02955121f, -0.29850349f, -0.07746020f, -0.22428420f, 0.03503307f, 0.01040739f, 
    0.09504093f, -0.10302997f, -0.09198815f, -0.13112974f, -0.03430779f, 0.16310835f, 0.16103749f, -0.12728301f, 
    0.04986493f, 0.07424168f, 0.24821804f, 0.03567015f, 0.04870497f, -0.01168112f, 0.13075542f, -0.05999012f, 
    -0.03737240f, -0.08878351f, -0.17041001f, 0.25846472f, 0.03771423f, 0.05008530f, -0.19104674f, -0.19213355f, 
    -0.27055001f, -0.05882439f, -0.00042079f, 0.10815026f, 0.03147333f, -0.01125697f, 0.04155130f, -0.10651907f, 
    -0.08928876f, 0.00966723f, -0.01344310f, -0.14676656f, -0.02444910f, 0.06376612f, 0.22752328f, 0.06179813f, 
    0.01546642f, -0.12286314f, -0.00410151f, -0.11861883f, 0.01724835f, 0.24570082f, 0.02300313f, 0.01517673f, 
    -0.28884059f, -0.09604082f, -0.02476560f, -0.19803914f, 0.03915814f, -0.07070313f, -0.11639006f, -0.15671782f, 
    0.06613199f, 0.08406803f, 0.21756417f, 0.14673544f, 0.31333432f, 0.15030144f, 0.31770128f, 0.19312996f, 
    0.01251623f, 0.19229986f, -0.06930039f, -0.36684877f, 0.12156714f, 0.11278193f, 0.15438884f, 0.21336524f, 
    0.07212951f, 0.01085852f, 0.13039464f, 0.11023654f, -0.14131021f, 0.07525021f, -0.06089386f, 0.06679168f, 
    0.06526374f, -0.04474990f, 0.03987991f, 0.14707610f, 0.04251727f, 0.23364520f, -0.00088305f, -0.06583100f, 
    0.10026608f, -0.07702191f, -0.01947541f, -0.11496557f, -0.00434441f, -0.01796892f, -0.07809470f, 0.10703120f, 
    0.32262966f, -0.27254695f, -0.15408981f, 0.13099097f, 0.08321209f, -0.02080970f, -0.13324697f, -0.00045562f, 
    0.16606092f, -0.09420615f, -0.07929944f, -0.01302869f, -0.16827424f, 0.05244589f, -0.01157032f, 0.05800486f, 
    0.15682030f, 0.10559802f, 0.02411973f, -0.06160724f, 0.23069823f, -0.28108999f, -0.28548583f, -0.17823486f, 
    0.12310393f, -0.02056492f, 0.01608141f, -0.09691267f, -0.03108226f, 0.02013344f, -0.02605407f, 0.10769854f, 
    -0.01286435f, 0.09815528f, 0.04577808f, 0.08510385f, -0.15405075f, 0.33973235f, 0.11804459f, 0.13186069f, 
    0.08926006f, 0.18612584f, 0.19180138f, -0.06744461f, -0.05813885f, 0.03036334f, 0.04536085f, 0.03523822f, 
    0.09674804f, -0.14081240f, -0.15669270f, -0.07799549f, 0.13274188f, 0.16728546f, 0.11606051f, -0.02465176f, 
    0.33312234f, 0.04930859f, -0.25334585f, -0.04637167f, 0.42138731f, 0.03919058f, -0.00957098f, -0.02157349f, 
    -0.45511690f, -0.66311932f, -0.16283698f, -0.07565636f, 0.08874442f, 0.04246851f, -0.02070563f, -0.04284278f, 
    0.13975902f, 0.09310167f, -0.05774420f, -0.16291022f, -0.12878339f, -0.18174380f, -0.05975101f, -0.01446068f, 
    0.03915628f, 0.14077553f, -0.24816395f, -0.41007537f, -0.11179031f, 0.16441235f, -0.00418140f, -0.09913784f, 
    -0.15620632f, 0.11070334f, -0.01833398f, 0.30994633f, -0.09934702f, -0.12626304f, -0.17466874f, 0.06349570f, 
    -0.08291402f, -0.00034699f, 0.05908460f, 0.19595106f, 0.28377897f, 0.32633018f, 0.14717686f, -0.22952875f, 
    -0.04572834f, -0.02189848f, 0.04430460f, 0.03853156f, 0.19009247f, -0.88181186f, -0.71287805f, 0.28523695f, 
    -0.08894347f, 0.11140067f, 0.08901875f, 0.01994348f, -0.12513259f, 0.09096396f, -0.24483182f, -0.29159087f, 
    -0.21442373f, 0.32753032f, -0.03919838f, 0.23995067f, -0.10137469f, -0.14823435f, -0.08802378f, 0.34125847f, 
    0.15266652f, 0.09000679f, -0.01179498f, 0.13525602f, 0.15457113f, -0.00696624f, 0.08707465f, -0.04041082f, 
    0.16790056f, 0.07332714f, 0.00259686f, 0.11971092f, 0.03557374f, 0.16049656f, -0.04399898f, -0.08943129f, 
    0.06175040f, -0.09641542f, -0.56574470f, 0.04193201f, 0.00101573f, 0.06914991f, 0.12861775f, -0.04475958f, 
    -0.17217724f, -0.10766482f, -0.33873633f, -0.15293641f, 0.21183428f, 0.10101411f, 0.04177229f, -0.06121284f, 
    0.12747231f, -0.08528683f, -0.08212907f, -0.03903882f, 0.07772451f, -0.49852884f, 0.13546829f, -0.05500587f, 
    0.03763667f, 0.13981254f, 0.08275055f, 0.21151571f, -0.18491468f, -0.39523870f, 0.14833838f, -0.03420855f, 
    -0.04555395f, -0.05309831f, -0.01303144f, -0.06216306f, -0.04981231f, 0.06136135f, 0.30005541f, -0.00591980f, 
    0.10126521f, -0.10716413f, 0.09415792f, 0.06906852f, -0.01202414f, 0.02220206f, 0.24942787f, -0.20375460f, 
    0.14326373f, -0.12750216f, -0.01972022f, 0.13137758f, 0.01651528f, -0.04401055f, 0.07352415f, 0.10151546f, 
    -0.42490974f, -0.55224675f, 0.03064813f, -0.03716014f, -0.02048731f, 0.00819948f, 0.17056902f, 0.24915580f, 
    -0.05612164f, 0.11877393f, -0.08768607f, -0.03230352f, 0.13635822f, -0.05547607f, 0.05522479f, 0.32661468f, 
    -0.00465968f, 0.04068546f, -0.20001082f, -0.01187180f, 0.15201883f, 0.09141677f, 0.04749929f, 0.07908748f, 
    -0.13804875f, -0.04281130f, 0.22551529f, 0.21324714f, -0.15955593f, 0.01849985f, 0.18689515f, 0.03562517f, 
    0.07479591f, 0.07450119f, -0.06240091f, -0.36779931f, -0.29794866f, 0.43693265f, -0.23339713f, -0.15896799f, 
    0.06944452f, 0.05230716f, -0.03872399f, -0.08020417f, 0.30988836f, 0.14015460f, 0.11658882f, -0.06022120f, 
    0.07678369f, -0.04485196f, -0.25422174f, 0.00346262f, -0.06825496f, 0.40372336f, -0.73950565f, -0.55994421f, 
    -0.17643963f, -0.16510165f, -0.04939600f, -0.14458320f, -0.11902489f, -0.01306452f, 0.01925411f, 0.04770283f, 
    -0.52814758f, -0.00455955f, 0.05124998f, -0.08684459f, 0.22329547f, -0.02756016f, 0.18099247f, 0.01295158f, 
    0.14378378f, 0.21501791f, 0.27380797f, -0.18164897f, -0.03598464f, 0.03739741f, 0.08853272f, -0.04243081f, 
    0.29323304f, -0.22308204f, -0.04048942f, -0.06761856f, 0.05323463f, 0.00184464f, -0.04038266f, 0.10138147f, 
    0.01091736f, 0.08765324f, 0.27484617f, 0.04459064f, 0.04068872f, -0.05437788f, -0.14090918f, 0.17951722f, 
    0.00155062f, -0.01492482f, 0.27995294f, -0.81709832f, -0.48464158f, 0.05425145f, -0.13112924f, -0.09820335f, 
    0.08965645f, -0.08264120f, 0.07317641f, 0.08859520f, -0.15304555f, -0.53809857f, 0.17345411f, -0.06711691f, 
    0.18858053f, -0.01640346f, -0.06204402f, -0.09282268f, 0.25110257f, 0.26330569f, -0.09219599f, -0.20222637f, 
    -0.18676600f, 0.11797137f, -0.05658014f, 0.02249400f, -0.04329050f, -0.35842761f, -0.39384487f, -0.10552274f, 
    -0.05461247f, -0.01300793f, 0.21270171f, 0.09620309f, 0.14997220f, 0.02543424f, -0.11981327f, -0.03506896f, 
    -0.10749467f, 0.10737839f, -0.16938016f, 0.02727864f, 0.10066561f, 0.00268823f, -0.11789832f, -0.10990398f, 
    -0.51764256f, -0.66421002f, -0.12363440f, 0.25130191f, 0.16770971f, 0.08630634f, -0.08927698f, -0.20200375f, 
    -0.10022419f, -0.03732678f, -0.01507227f, 0.03266399f, -0.07507424f, 0.09494130f, -0.15926306f, -0.16945331f, 
    0.21224694f, 0.23910776f, 0.16630578f, 0.38176966f, -0.20822023f, -0.10730889f, -0.12684271f, 0.06281776f, 
    0.14359048f, 0.26712012f, 0.24567497f, 0.09063990f, 0.35027486f, -0.03180825f, 0.08954542f, 0.11017693f, 
    0.03385201f, 0.03886367f, 0.02027014f, -0.42407164f, 0.29276523f, -0.41152054f, -0.09183383f, -0.21441898f, 
    0.09893309f, -0.09032606f, 0.01651937f, -0.20298702f, -0.07571588f, -0.09228545f, -0.01226415f, 0.12930137f, 
    0.08833722f, 0.10710533f, 0.02060523f, 0.16867758f, 0.19903761f, -0.21873966f, -0.55578202f, -0.00241277f, 
    -0.08587255f, -0.08349251f, -0.02661727f, 0.19778955f, -0.01481768f, -0.25481197f, -0.10396916f, 0.37036082f, 
    0.01906143f, -0.04441974f, -0.36660516f, 0.06539580f, 0.08817817f, 0.21245632f, 0.16771325f, 0.22727725f, 
    -0.14953667f, -0.35616258f, -0.08132118f, -0.05627431f, -0.08376789f, 0.02782002f, -0.09334464f, 0.10666449f, 
    0.24232271f, 0.10323244f, -0.04569150f, -0.02501330f, -0.03166824f, -0.14484532f, 0.14686765f, 0.02383162f, 
    -0.18239017f, 0.59232265f, -0.00572535f, 0.28849378f, -0.01381063f, -0.02208143f, -0.18949866f, 0.14614694f, 
    0.15981352f, 0.05794169f, -0.02666673f, -0.17372936f, -0.06220571f, -0.30033642f, 0.17107409f, -0.10796172f, 
    -0.07767183f, 0.16906124f, 0.33945206f, -0.38330755f, 0.20931436f, -0.34360984f, -0.08231729f, -0.03684340f, 
    0.36637506f, -0.01244683f, -0.09293070f, 0.01855115f, 0.47185576f, 0.14431280f, -0.32863274f, -0.08101832f, 
    -0.06113381f, 0.08880558f, 0.10534406f, -0.05489867f, -0.05969689f, -0.18886490f, -0.44350904f, 0.10696105f, 
    0.08527771f, 0.02832838f, 0.23961379f, 0.06353729f, 0.12411707f, 0.07168993f, -0.14800291f, 0.01801996f, 
    0.13271071f, -0.00124738f, -0.00321222f, -0.18597414f, 0.05919649f, 0.06082594f, -0.14577164f, -0.50579226f, 
    0.54604340f, 0.19180629f, -0.12999272f, 0.05691813f, -0.08758619f, -0.24184869f, -0.02517138f, -0.08299552f, 
    0.18302083f, -0.11705659f, -0.22096266f, 0.08286463f, -0.09731337f, -0.04088540f, -0.07183910f, 0.05066068f, 
    0.24526520f, 0.05858876f, 0.13413230f, 0.02385236f, -0.13242811f, -0.21790437f, -0.07951213f, 0.03377588f, 
    0.05320710f, 0.26359949f, -0.03840034f, 0.17223191f, -0.25521788f, 0.15179326f, 0.09121118f, 0.02842638f, 
    0.05482119f, 0.02312801f, 0.07786421f, -0.27440795f, -0.41380176f, 0.47657588f, 0.01395819f, -0.02427397f, 
    -0.03353130f, -0.03782217f, -0.12163522f, -0.14239736f, -0.11363895f, 0.16669914f, -0.02301620f, 0.01102603f, 
    -0.02532444f, -0.20592819f, 0.16244003f, -0.00448943f, -0.17795107f, -0.09316394f, -0.10671120f, -0.35719800f, 
    -0.03166067f, 0.16586748f, -0.34222704f, 0.15874255f, -0.35924363f, -0.25607088f, 0.05801822f, -0.23908210f, 
    0.52166957f, -0.02758658f, -0.02456302f, -0.01006945f, 0.03192262f, 0.16634610f, 0.09172048f, -0.00932438f, 
    -0.08314100f, -0.17885536f, -0.14219698f, 0.09951822f, -0.02078972f, 0.19709854f, 0.01867011f, 0.01993123f, 
    -0.02797720f, -0.05840222f, 0.02677437f, 0.04228253f, -0.02921184f, -0.05096703f, 0.05844397f, -0.06611852f, 
    -0.06409464f, 0.03320503f, -0.03701432f, -0.02107720f, -0.07864564f, -0.08848251f, 0.03499724f, 0.00700062f, 
    -0.05816457f, -0.04721896f, 0.01410570f, 0.00131321f, -0.04959397f, -0.03522894f, -0.03601141f, -0.07011537f, 
    0.03377540f, -0.00851948f, -0.00257070f, -0.00038793f, 0.06214937f, -0.02018637f, 0.03957559f, -0.01951412f, 
    0.01518586f, 0.07855097f, -0.00484618f, -0.06168442f, 0.06043444f, -0.09133011f, 0.05274258f, 0.03038246f, 
    -0.05396329f, -0.03497810f, 0.03720896f, -0.08475637f, 0.07232884f, -0.00873453f, 0.05790858f, -0.06664553f, 
    0.02824793f, 0.06247452f, -0.06756758f, 0.05924365f, 0.02429534f, -0.07768536f, 0.06493911f, 0.00005370f, 
    -0.05964199f, 0.02331306f, -0.06525472f, -0.02929156f, -0.07263090f, 0.04732592f, 0.01433105f, -0.09250922f, 
    -0.07012833f, -0.05945928f, -0.07421846f, -0.06381588f, 0.01302141f, -0.01598318f, -0.08668765f, 0.05388773f, 
    -0.02736443f, -0.02977661f, -0.05174618f, 0.04926640f, -0.08163619f, 0.02785591f, -0.05137505f, 0.04254483f, 
    -0.01848037f, 0.05551193f, 0.04559740f, -0.03915074f, 0.03701189f, -0.02167891f, 0.04176658f, -0.08613675f, 
    0.04398441f, 0.05074036f, 0.07045116f, 0.02378542f, -0.00116730f, 0.02764652f, -0.04103877f, 0.00599658f, 
    -0.02163975f, -0.07648470f, -0.02725557f, 0.06512814f, -0.02063636f, 0.03329202f, 0.02856497f, -0.05781941f, 
    0.02872252f, -0.08242659f, 0.05330456f, -0.05258113f, -0.08891943f, -0.08101347f, -0.07386620f, 0.06829026f, 
    -0.09063260f, -0.04002815f, -0.08128553f, -0.04282940f, -0.03636159f, -0.07325875f, 0.02804303f, -0.01782207f, 
    0.04223065f, 0.02708020f, -0.08245888f, -0.03079818f, -0.03863889f, 0.06164391f, -0.08106630f, 0.02009463f, 
    -0.01690326f, 0.03331837f, 0.01268330f, -0.06144516f, -0.04053031f, -0.09015566f, -0.02156746f, -0.01511526f, 
    0.03286065f, -0.06089683f, -0.07664160f, 0.00196313f, -0.05718454f, 0.03272348f, 0.05528453f, 0.01093803f, 
    -0.03566040f, 0.15915333f, -0.04499550f, 0.05300707f, 0.08034386f, -0.12606604f, 0.01740037f, -0.15758269f, 
    -0.11750785f, 0.07363955f, 0.22950970f, 0.10840906f, -0.01561633f, 0.09830791f, 0.17861836f, -0.10486861f, 
    -0.14925337f, -0.16061041f, 0.29666674f, -0.23407462f, -0.11956898f, -0.06234381f, 0.12950243f, 0.04452217f, 
    -0.00780145f, -0.06676617f, 0.04754666f, -0.22846413f, 0.16911876f, -0.18804015f, 0.14335009f, -0.04759002f, 
    0.07160342f, 0.06271157f, -0.01093914f, -0.21178553f, 0.14295791f, -0.10712136f, -0.19814987f, 0.08299391f, 
    -0.02359666f, 0.09375638f, -0.09625351f, -0.16397567f, -0.16045263f, -0.19913243f, 0.08031231f, 0.21806887f, 
    0.01213827f, 0.08612758f, 0.03174970f, 0.06745587f, 0.19544964f, -0.09275136f, 0.02655297f, -0.18519792f, 
    -0.01503752f, 0.24346641f, -0.04346405f, 0.10253850f, -0.01472116f, 0.03237028f, -0.18409471f, 0.73253381f, 
    0.03918276f, 0.09959909f, 0.15363146f, 0.17012693f, 0.05923596f, 0.19694147f, -0.03418367f, 0.12365960f, 
    0.17080529f, -0.10326935f, -0.02568108f, 0.01854034f, -0.04899946f, 0.06490085f, 0.01120345f, 0.34693459f, 
    -0.08055989f, 0.15603054f, -0.15644215f, 0.01051569f, 0.12063438f, 0.28268635f, -0.13893723f, 0.15992369f, 
    -0.08513366f, 0.08444313f, 0.01911006f, 0.11485152f, -0.12175384f, 0.04107467f, 0.03072863f, 0.06458855f, 
    0.01831349f, 0.04345464f, -0.10196914f, 0.14855494f, -0.22572850f, -0.13563006f, 0.26192194f, 0.16441639f, 
    0.07549862f, 0.08274562f, 0.23679258f, 0.16145873f, 0.07464452f, -0.00237533f, 0.11623784f, 0.06777831f, 
    0.07591350f, -0.15816759f, -0.19372787f, -0.32519960f, -0.33175179f, 0.20577857f, 0.13715562f, -0.15008393f, 
    0.13285682f, -0.09274027f, 0.15331551f, 0.06739543f, 0.20688410f, 0.13449211f, -0.10094763f, 0.09397680f, 
    0.00650243f, 0.29346517f, -0.05895813f, 0.06339530f, 0.21670532f, 0.11918864f, 0.06177500f, 0.08897931f, 
    0.05783369f, 0.06634279f, 0.18255143f, -0.15150613f, -0.02479274f, -0.02964604f, 0.08112922f, 0.03636358f, 
    -0.20236187f, 0.12562722f, 0.13858244f, -0.19260871f, 0.15828395f, 0.06046025f, -0.01145728f, 0.00658319f, 
    0.00034366f, 0.15747054f, 0.13189746f, -0.26319638f, -0.01037283f, -0.10418989f, 0.01277466f, 0.15277073f, 
    0.00239714f, 0.02929431f, -0.13404226f, 0.14422078f, 0.03539444f, -0.08884587f, -0.13554475f, -0.28896832f, 
    0.02719534f, -0.00571219f, 0.06073432f, -0.34763661f, 0.43427527f, -0.13705841f, 0.15523086f, 0.26817304f, 
    0.08954231f, -0.15593086f, 0.04589330f, -0.05319129f, -0.11217211f, -0.07648648f, 0.02427022f, -0.02249903f, 
    -0.02783596f, 0.04787739f, 0.02671502f, 0.07397535f, 0.21053065f, 0.04734268f, -0.03378171f, 0.08484091f, 
    0.10370653f, -0.07075157f, 0.22862276f, -0.08420142f, -0.11170548f, -0.05758607f, 0.17843287f, 0.07268997f, 
    0.06210068f, -0.01772392f, -0.10276456f, -0.22965859f, 0.12329935f, -0.03762919f, 0.02691365f, -0.34576461f, 
    0.51550895f, 0.25249210f, -0.00036331f, 0.12556469f, -0.05217772f, -0.05101806f, 0.00540173f, -0.15482393f, 
    -0.05753578f, 0.22125556f, -0.01793783f, -0.08181679f, -0.13255854f, -0.09920108f, -0.02401412f, -0.12800023f, 
    0.21800332f, -0.09193745f, 0.13587937f, -0.22023860f, 0.06636886f, -0.22727697f, -0.10009673f, 0.02092287f, 
    -0.09015317f, -0.04076771f, -0.11658709f, -0.10984849f, -0.03755891f, 0.03617796f, -0.02727043f, -0.06255363f, 
    -0.04851197f, -0.01084864f, 0.11231069f, -0.05947007f, -0.27143210f, 0.22712693f, -0.20015575f, -0.39773434f, 
    -0.27221945f, -0.10252554f, 0.16225135f, 0.12897940f, 0.09809648f, 0.35237375f, 0.07229470f, 0.16441193f, 
    -0.08181938f, 0.00180903f, 0.08773080f, 0.05840160f, -0.16149129f, -0.80774522f, 0.29000333f, -0.21188259f, 
    -0.28255105f, 0.15417950f, -0.05789341f, 0.03616918f, 0.02408687f, -0.14759092f, -0.02514099f, -0.18990871f, 
    -0.06695969f, 0.20256819f, 0.09910765f, -0.05094108f, -0.00079620f, 0.09888621f, 0.00391571f, 0.00005484f, 
    0.17628753f, 0.13983361f, 0.12990451f, 0.06894441f, 0.20641884f, 0.02614997f, -0.13412228f, 0.01352982f, 
    -0.12502123f, -0.23383062f, -0.14175321f, -0.02471977f, 0.04971003f, -0.00324705f, 0.03905885f, 0.15460511f, 
    0.13444334f, 0.04054613f, -0.04864810f, 0.21159369f, 0.01096734f, 0.01286830f, -0.06654898f, 0.06822806f, 
    0.12051132f, 0.22602780f, -0.01421949f, 0.07834604f, 0.20093268f, 0.04445758f, -0.22474952f, -0.00588040f, 
    0.02821069f, -0.20498441f, 0.01140064f, -0.05681374f, -0.12914918f, -0.04867102f, 0.00980787f, -0.04247687f, 
    0.02821749f, 0.03003392f, -0.03234807f, 0.02828938f, 0.26601866f, 0.37172163f, 0.04940839f, -0.06197961f, 
    -0.16191752f, 0.18149538f, -0.12832765f, -0.10147811f, 0.08732568f, -0.23472066f, -0.12187567f, -0.18125340f, 
    0.00966842f, 0.17869346f, 0.11652385f, -0.04185102f, -0.16749528f, 0.04326519f, -0.07415672f, 0.21437183f, 
    -0.05891721f, 0.11248513f, 0.04193703f, 0.01527554f, 0.21032731f, 0.09843705f, 0.18286592f, -0.14463903f, 
    0.16775192f, -0.22483759f, 0.18840031f, 0.10668578f, -0.13291967f, -0.04624637f, 0.02070378f, 0.06293238f, 
    -0.35017395f, 0.03332890f, -0.09025071f, -0.07027598f, -0.09557980f, -0.07409249f, -0.08336519f, -0.37508932f, 
    -0.11914181f, 0.34212071f, 0.14187665f, 0.18789028f, -0.00085511f, -0.10445301f, -0.14759800f, -0.10985573f, 
    -0.28325006f, -0.20893294f, 0.04264249f, 0.07218347f, 0.43791613f, 0.13963392f, -0.07557899f, -0.15621188f, 
    0.10377117f, 0.25945261f, 0.02469411f, -0.05386035f, 0.26617882f, 0.17091471f, -0.01784553f, 0.14685924f, 
    0.06317728f, -0.01030067f, -0.10439298f, -0.01472409f, -0.23262683f, -0.15255757f, -0.32133132f, 0.14827994f, 
    0.16788651f, -0.02258366f, 0.08795207f, 0.00136017f, 0.13650702f, -0.02910164f, -0.24073538f, 0.28341267f, 
    -0.00922441f, 0.19294578f, -0.25160706f, 0.21139102f, -0.16158672f, 0.18561657f, 0.25414357f, -0.10707254f, 
    0.06970810f, 0.10250258f, -0.11787989f, 0.11975297f, -0.09020816f, -0.15980674f, 0.05718452f, -0.22055331f, 
    0.06081315f, -0.22454378f, -0.04112488f, 0.04417912f, 0.01282123f, 0.13106467f, 0.12124984f, -0.02347235f, 
    -0.03687875f, 0.09772158f, -0.49767467f, 0.06881311f, 0.06937058f, -0.10653619f, 0.29860225f, 0.02438769f, 
    -0.12735116f, 0.02079641f, 0.02620398f, 0.15255117f, 0.06054934f, -0.02338029f, 0.28348336f, 0.11511492f, 
    0.14005959f, 0.11632454f, -0.11982395f, -0.19451739f, 0.07585593f, -0.01661496f, -0.08769305f, 0.15670277f, 
    -0.29413685f, -0.15995477f, 0.01862443f, 0.24200545f, -0.07342114f, -0.19155569f, 0.16959660f, -0.11725664f, 
    -0.05113460f, -0.11771023f, -0.10258618f, 0.16095623f, 0.19518323f, 0.10802896f, -0.19442397f, 0.03275096f, 
    -0.08250447f, 0.10649309f, 0.14139007f, -0.14802782f, 0.05409510f, -0.29762205f, -0.07453723f, -0.13979702f, 
    0.00452223f, 0.17900467f, -0.11569820f, 0.02572337f, 0.09930255f, 0.04345754f, 0.07938210f, 0.01042905f, 
    -0.07946354f, -0.01032606f, -0.09523136f, -0.02132762f, 0.00307524f, 0.00538977f, -0.18094450f, 0.34792438f, 
    -0.15503290f, -0.23425268f, 0.13435794f, -0.02682503f, 0.16956818f, -0.07151768f, 0.13190895f, -0.18302526f, 
    -0.03913857f, 0.18223733f, 0.16480467f, 0.03674807f, 0.06027030f, 0.32191929f, 0.01277907f, -0.08226509f, 
    -0.00041030f, -0.09443569f, 0.17744346f, 0.14340153f, -0.08351683f, 0.04040120f, -0.09570505f, 0.17754829f, 
    0.14459945f, 0.26615709f, 0.06569343f, 0.04511328f, 0.11088035f, -0.06847429f, 0.03507721f, 0.07006385f, 
    0.00777798f, 0.19522333f, 0.17449760f, -0.04518147f, 0.02107630f, 0.06732100f, 0.04318589f, 0.31004587f, 
    0.26999804f, -0.24087541f, 0.06896607f, -0.11112706f, -0.12312850f, -0.04302361f, -0.22039659f, 0.06962483f, 
    0.03598178f, 0.15326446f, 0.04376834f, -0.16951814f, 0.00587458f, -0.14718810f, -0.20812744f, -0.51650453f, 
    -0.24178767f, -0.10882086f, -0.04084289f, 0.05903772f, 0.10393747f, -0.06738274f, -0.01996896f, 0.01733071f, 
    -0.14400379f, -0.08251888f, -0.13016067f, -0.10178057f, 0.06971411f, -0.07195219f, 0.05359912f, 0.19495757f, 
    -0.14038502f, -0.21501006f, 0.02800828f, -0.00455864f, -0.01112811f, 0.02598810f, 0.02139457f, 0.02858221f, 
    -0.27632570f, 0.21706854f, 0.21955928f, 0.02762049f, -0.19310795f, -0.08300842f, 0.07268642f, -0.05768888f, 
    0.03196394f, -0.28118768f, -0.23179813f, -0.41962907f, -0.05423620f, -0.19114037f, 0.21244305f, 0.08534558f, 
    0.09442122f, 0.12053908f, 0.19322450f, 0.07099931f, -0.01489122f, -0.03108539f, -0.08426134f, 0.07412487f, 
    -0.09354454f, 0.09530383f, 0.11548889f, 0.19130859f, -0.14396696f, -0.70664150f, -0.02658630f, -0.17397501f, 
    0.10984378f, 0.25304759f, 0.20954619f, -0.04247189f, 0.06275634f, 0.08005437f, -0.32541236f, 0.08732079f, 
    0.14177632f, 0.07202187f, 0.33013180f, 0.11211068f, 0.02097068f, 0.11997234f, 0.12884110f, 0.44509181f, 
    -0.09750480f, -0.08994006f, -0.05627628f, 0.05892759f, 0.00563562f, -0.22817312f, -0.11037411f, 0.05648381f, 
    0.01426425f, 0.08504756f, -0.05543282f, 0.04799463f, 0.24279247f, 0.11319923f, 0.25344539f, -0.06341501f, 
    0.07795306f, 0.09672319f, -0.18607841f, -0.08282244f, 0.01053873f, 0.18741973f, 0.14467737f, -0.10064287f, 
    0.39787492f, -0.31558120f, -0.14274687f, -0.07331099f, 0.01379061f, 0.13082470f, -0.00403457f, 0.10546547f, 
    0.15473226f, 0.18946376f, -0.07092518f, -0.30686393f, 0.24846838f, -0.09149249f, -0.03297513f, -0.08176973f, 
    -0.00532842f, 0.19040152f, -0.01128369f, -0.32589075f, -0.38025689f, -0.09530400f, 0.17491738f, 0.03850210f, 
    0.19923334f, 0.12962861f, 0.03083131f, 0.36650413f, 0.17665425f, 0.15860182f, -0.06524131f, 0.01076827f, 
    0.44400877f, 0.00699178f, 0.10233040f, -0.13158152f, 0.42137370f, 0.25213155f, 0.06050090f, -0.02554353f, 
    -0.00846868f, 0.01884760f, 0.21919468f, -0.15648715f, 0.17913987f, -0.47718513f, -0.62254059f, 0.13246793f, 
    0.04654904f, -0.43180364f, -0.33840978f, 0.10069638f, 0.07330028f, 0.00274206f, -0.06072867f, -0.03680951f, 
    -0.56576347f, 0.03276059f, -0.13436575f, -0.17448366f, -0.00283270f, 0.01671218f, -0.15841073f, 0.22994591f, 
    0.38234389f, 0.45194483f, -0.08584408f, -0.02251264f, -0.18338351f, 0.24686669f, -0.12870875f, -0.13210556f, 
    0.09320999f, -0.07719676f, -0.33422327f, 0.23384458f, 0.18090262f, 0.14576727f, 0.10703878f, 0.01922736f, 
    -0.14847653f, 0.24609697f, -0.11696186f, 0.25822669f, 0.18813135f, 0.23219113f, 0.12640870f, 0.03247125f, 
    -0.02349435f, -0.34286222f, -0.16034272f, 0.32726848f, 0.07521819f, -0.00063909f, 0.10476084f, -0.40369323f, 
    0.23196143f, 0.03907353f, -0.09449109f, -0.63025749f, 0.16828603f, -0.13739839f, -0.00275308f, 0.00006698f, 
    -0.14278565f, 0.08446049f, -0.08793232f, -0.12477518f, 0.23435202f, 0.12898311f, 0.28483599f, 0.13616540f, 
    -0.00260334f, 0.10774688f, 0.05251087f, 0.02764810f, 0.01761110f, -0.22281118f, -0.22981380f, -1.02736568f, 
    -0.03012059f, -0.26241267f, -0.16623048f, 0.31367007f, -0.02707677f, 0.03843468f, 0.23462631f, 0.08020218f, 
    0.23469009f, -0.04649241f, 0.04131966f, 0.02071438f, 0.10528855f, 0.06936143f, 0.14931916f, -0.02196098f, 
    0.16440547f, 0.18312995f, -0.17336951f, -0.29281110f, -0.12070698f, -0.16755378f, -0.18348876f, -0.30427423f, 
    0.49791920f, 0.24046272f, 0.34207785f, 0.03991634f, 0.02704394f, -0.30673555f, -0.07716220f, -0.22768870f, 
    -0.04338324f, -0.00777246f, 0.04692419f, 0.19836766f, -0.08779774f, -0.00796231f, 0.01636932f, 0.06905054f, 
    0.23342071f, 0.12059719f, -0.31724888f, -0.22918466f, -0.17913371f, -0.04287392f, 0.16492836f, 0.34379536f, 
    0.12504728f, 0.02960737f, -0.07887501f, -0.66217768f, -0.44812122f, 0.08658739f, -0.04158125f, -0.15303938f, 
    -0.18781808f, 0.04088365f, 0.14542404f, 0.09790520f, -0.09648004f, 0.18539532f, 0.02810824f, -0.05640977f, 
    0.16763659f, 0.07203473f, -0.03034105f, 0.25154772f, 0.26097131f, -0.50573564f, -0.53254408f, -0.47966880f, 
    -0.08911429f, -0.21568665f, -0.11183681f, -0.08999529f, 0.07695477f, -0.24863882f, 0.29753882f, 0.22064024f, 
    -0.18191245f, 0.20586678f, -0.02338254f, -0.06044429f, -0.08280357f, 0.00249500f, 0.00432215f, -0.43252963f, 
    -0.57049525f, -0.28971538f, -0.16414239f, -0.28631556f, -0.12531275f, 0.04908132f, 0.07392649f, 0.32945776f, 
    0.16376214f, 0.03237025f, -0.21054384f, 0.14818150f, 0.09262976f, 0.04791941f, 0.13842767f, 0.14771728f, 
    0.00574302f, -0.31163204f, -0.08569425f, 0.23484859f, 0.20948340f, -0.03071536f, 0.12255201f, 0.00172337f, 
    0.23388496f, -0.01597191f, -0.66202307f, 0.33448094f, 0.70335811f, -0.03463795f, -0.06191325f, 0.09767421f, 
    0.11136185f, 0.19685784f, 0.04115500f, 0.42243218f, -0.47686800f, -0.16648383f, 0.06787040f, 0.06373511f, 
    0.08677854f, 0.03989749f, 0.22951411f, -0.01276327f, 0.01470920f, 0.13471699f, -0.13519174f, -0.04186109f, 
    0.04991729f, 0.07354531f, 0.08717331f, 0.22207153f, 0.12611938f, 0.21147880f, -0.01149281f, -0.14664747f, 
    0.10539147f, 0.07428383f, -0.11241842f, -0.05034019f, 0.11641596f, 0.14729127f, 0.20678319f, 0.14000469f, 
    -0.02034268f, -0.01393198f, 0.18868400f, -0.06265603f, 0.48677221f, 0.07593104f, 0.03820457f, 0.27387998f, 
    -0.42313847f, -0.54879320f, -0.05174239f, -0.29843456f, 0.10167590f, -0.09569822f, 0.03269948f, 0.14988798f, 
    -0.04677099f, -0.15335536f, -0.14838856f, -0.04669662f, -0.01675462f, -0.05244299f, -0.18496154f, -0.09961414f, 
    0.09838986f, -0.06977955f, -0.11005156f, -0.33189732f, -0.17755195f, -0.32898417f, -0.19297098f, 0.21844311f, 
    0.01996576f, 0.13049141f, 0.19676670f, 0.02750175f, 0.10088197f, 0.00768382f, 0.14662020f, 0.07768987f, 
    0.11443458f, 0.10974567f, 0.03855932f, -0.70229286f, 0.13327959f, 0.42624578f, -0.14282566f, -0.08611453f, 
    -0.10017960f, -0.06999915f, 0.00768334f, 0.09188233f, 0.11724134f, -0.16545793f, -0.10534880f, -0.08157443f, 
    0.03271893f, 0.03101436f, 0.23281844f, 0.10266361f, 0.04070337f, -0.09897457f, -0.68882483f, -0.02116141f, 
    0.09038365f, -0.22648269f, -0.05796001f, 0.02232964f, -0.09155677f, -0.13880143f, 0.45814702f, -0.12375183f, 
    -0.39884809f, -0.12843162f, -0.03963240f, -0.01164861f, 0.08210966f, -0.22429177f, 0.14587270f, -0.19209450f, 
    -0.16927321f, -0.06876501f, -0.09681451f, 0.02183926f, 0.02106026f, 0.07051048f, 0.15526651f, 0.05790841f, 
    0.11875975f, 0.16671026f, 0.14259486f, -0.04370775f, 0.29542249f, 0.05740782f, 0.01336780f, 0.21337204f, 
    0.32044935f, -0.21790783f, -0.31564033f, 0.03557866f, 0.09186053f, -0.12539634f, 0.12334320f, 0.09538719f, 
    0.12588952f, 0.16695866f, 0.15924400f, 0.21719776f, 0.08259512f, -0.01257734f, 0.12878364f, -0.00201613f, 
    0.04174614f, 0.11745474f, -0.00487886f, -0.14647345f, 0.11896653f, -0.00715874f, 0.23261254f, -0.13057403f, 
    0.10293803f, 0.15639384f, 0.22562687f, -0.09322439f, -0.26976287f, -0.15686946f, -0.44461212f, 0.01760937f, 
    -0.23031083f, -0.14809181f, 0.05163575f, 0.10939432f, 0.00700578f, 0.29765245f, 0.32200196f, 0.17128408f, 
    -0.00720455f, 0.17756929f, -0.04351809f, 0.14564250f, 0.12668204f, -0.03451007f, 0.10150638f, 0.12715033f, 
    0.10189504f, 0.10775404f, -0.16431519f, -0.08120567f, -0.04366657f, 0.21692330f, 0.08788925f, -0.29209515f, 
    -0.22873959f, -0.02702804f, 0.11254103f, -0.20090175f, -0.04388244f, 0.12238932f, -0.18576199f, -0.18796168f, 
    0.15386051f, 0.10464977f, 0.14900872f, 0.05409741f, 0.08539286f, -0.06831599f, 0.21997608f, -0.19599670f, 
    -0.21206178f, -0.39517483f, -0.36603040f, 0.00689253f, -0.14806075f, -0.07916977f, -0.29115629f, 0.06263658f, 
    -0.02174152f, -0.20979255f, -0.24409178f, 0.02719806f, 0.12838066f, 0.11811615f, 0.29886213f, 0.09061755f, 
    0.26508936f, 0.20176698f, 0.04311218f, 0.23318836f, 0.16210660f, 0.01999077f, -0.09025420f, 0.07730114f, 
    0.09533792f, 0.23263671f, 0.04741542f, -0.01502519f, 0.17673051f, 0.16449484f, 0.13858180f, 0.13345437f, 
    0.09781578f, 0.09050403f, 0.28868708f, 0.07742477f, 0.23631692f, -0.27017078f, -0.24182482f, -0.05775157f, 
    0.21062198f, 0.00986526f, 0.14085539f, -0.11882240f, 0.37963918f, -0.10601945f, 0.00816187f, -0.17627728f, 
    0.20548934f, -0.11059391f, -0.02285825f, 0.12052459f, 0.08490442f, 0.19230488f, 0.06592996f, 0.19521621f, 
    0.26728392f, 0.04078609f, 0.24873915f, 0.26944682f, -0.07562756f, 0.08206712f, 0.15954241f, 0.00074867f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.15702499f, 0.08377973f, -0.02569935f, -0.07022680f, 0.27246645f, 0.18180165f, 0.20980823f, -0.07302888f, 
    0.02476136f, -0.03459457f, 0.10429593f, 0.27715597f, 0.01041603f, -0.03958778f, 0.40732247f, 0.23692971f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.42051491f, 0.29997978f, -0.01473856f, 0.17175601f, -0.10446952f, -0.62804145f, 0.26348150f, 0.18117112f, 
    0.14336470f, 0.59625918f, -0.21795452f, 0.18115678f, -0.06128075f, -0.18614331f, 0.37848857f, 0.00023117f, 
    0.01915040f, 0.01269735f, 0.05101869f, -0.14648782f, 0.42999825f, 0.78013593f, -0.20978859f, -0.01123428f, 
    -0.12952824f, -0.49911270f, 0.02647735f, 0.42459837f, 0.02469834f, -0.54041219f, 0.35329852f, 0.20578282f, 
    -0.01051219f, 0.33399540f, -0.04705214f, 0.02828399f, 0.43031722f, -0.95888883f, 0.18189128f, -0.13942568f, 
    0.19431584f, 0.37724283f, -0.46098700f, 0.32766053f, 0.04369768f, -0.07681185f, 0.34518102f, -0.15526906f, 
    0.26044640f, -0.40837428f, 0.28570774f, 0.36469570f, 0.18284172f, 0.08504315f, -0.38911515f, -0.17968753f, 
    -0.04002875f, 0.31708667f, 0.17479385f, 0.09192967f, 0.32498547f, 0.05595076f, -0.10558313f, -0.11576156f, 
    -0.32462019f, -0.30774891f, 0.17851029f, 0.04731193f, -0.19395091f, 0.11714225f, 0.55768633f, -0.14764887f, 
    0.30901706f, -0.36952838f, 0.21943964f, 0.32417446f, 0.28122234f, 0.29829219f, 0.23062424f, -0.19883481f, 
    -0.27935138f, -0.21369484f, 0.04345712f, 0.26875404f, -0.27180508f, -0.18489797f, -0.20150577f, -0.12535955f, 
    0.48034176f, -0.08846357f, -0.32882160f, 0.08484977f, 0.34224343f, 0.07529213f, -0.35022557f, 0.12955603f, 
    0.33164564f, 0.31738552f, -0.28116542f, -0.40154061f, 0.25492382f, 0.18322891f, 0.25828162f, -0.03608522f, 
    0.18693532f, -0.36022249f, 0.31940416f, 0.46544746f, 0.01687159f, -0.16937907f, 0.42809063f, -0.07436492f, 
    -0.42996952f, 0.34589478f, 0.18867299f, 0.33879995f, 0.34748361f, -0.22925261f, 0.25322211f, -0.18894254f, 
    0.01312176f, 0.30429211f, 0.16118059f, -0.37700799f, -0.10023686f, 0.08942946f, 0.20822886f, -0.09367643f, 
    -0.33248630f, -0.08655104f, -0.15542914f, 0.46024758f, 0.01113172f, -0.08050527f, 0.43660617f, -0.09168161f, 
    -0.15791893f, 0.21634862f, 0.31579384f, -0.38005179f, -0.08758094f, 0.09237368f, 0.44011497f, 0.07033157f, 
    -0.16012539f, 0.17212665f, 0.00207415f, -0.09747322f, -0.35911748f, -0.16528507f, 0.61170018f, -0.12123644f, 
    0.25020573f, -0.26396123f, -0.25085750f, 0.44392231f, -0.14747147f, 0.17926368f, 0.34139445f, -0.00696548f, 
    0.31239390f, 0.37003121f, -0.07849191f, -0.21771178f, 0.17062256f, 0.70268196f, -0.05550474f, 0.08315205f, 
    -0.20391974f, -0.40852594f, 0.07148130f, 0.34244183f, 0.27338567f, -0.00445695f, -0.06290524f, 0.27809209f, 
    0.12836672f, 0.17014909f, -0.08611289f, 0.01744224f, 0.29429987f, -0.70346975f, 0.01609055f, 0.18900445f, 
    0.33507916f, 0.19023083f, -0.41420901f, 0.15059070f, 0.31192225f, 0.36449426f, -0.19452257f, -0.00097679f, 
    0.05325952f, 0.09380341f, 0.07056434f, 0.04429758f, 0.08660389f, 0.53338885f, -0.02704009f, 0.09409569f, 
    -0.09369452f, 0.52384585f, 0.16065170f, 0.41002145f, -0.12078787f, 0.64343148f, -0.27563226f, -0.04393182f, 
    0.20087783f, -0.32891718f, 0.33533341f, -0.01565861f, -0.18186080f, 0.59957767f, 0.02358123f, 0.22814554f, 
    -0.48835424f, -0.40065634f, 0.19043463f, -0.15081781f, 0.09487553f, -0.37976542f, 0.07063889f, 0.21456924f, 
    -0.44604376f, -0.02863837f, -0.09672088f, 0.13808838f, 0.52569300f, -0.57838690f, -0.07714590f, 0.16563176f, 
    0.21804680f, -0.13763911f, -0.25909981f, 0.20226000f, 0.24753878f, 0.01321028f, 0.20090935f, 0.24528053f, 
    -0.34000453f, 0.03646527f, 0.37408271f, 0.03013968f, 0.52046967f, 0.07890651f, -0.69224411f, -0.09540410f, 
    -0.45575109f, -0.02965084f, 0.21168336f, -0.05785704f, 0.12904026f, -0.16035707f, 0.10342923f, 0.23116480f, 
    -0.16773206f, 0.39962253f, -0.35292724f, 0.32528433f, 0.51817304f, -0.33033121f, -0.19325152f, -0.14040628f, 
    0.33245447f, -0.36475214f, 0.13413350f, 0.21341638f, 0.20979412f, -0.09132574f, 0.23963742f, -0.08426528f, 
    0.05891657f, -0.33255902f, 0.49740255f, 0.14031956f, 0.20107634f, -0.14407533f, -0.51438385f, -0.13707896f, 
    -0.24881068f, 0.30183145f, -0.26209664f, -0.27962944f, -0.22370039f, -0.32974941f, 0.33574632f, 0.32710814f, 
    0.12202290f, -0.06496841f, 0.31522796f, 0.03122882f, -0.57167822f, 0.21817645f, 0.48298329f, 0.21201411f, 
    -0.30826998f, 0.57720894f, 0.08306926f, -0.28962976f, -0.01945257f, -0.29822874f, -0.18529190f, 0.16064563f, 
    -0.14068916f, -0.10267054f, -0.04164269f, 0.08405211f, 0.13967766f, 0.51440537f, 0.41978419f, 0.20564227f, 
    0.14779697f, -0.21004888f, 0.30825067f, 0.25696784f, -0.43981308f, -0.47967485f, 0.46183953f, 0.22919603f, 
    -0.00279553f, -0.08862276f, -0.28283876f, 0.30557099f, -0.17363781f, -0.09299925f, 0.08274398f, 0.24518324f, 
    0.46678254f, -0.08412237f, -0.46144834f, -0.05599905f, 0.22857668f, 0.04489679f, -0.50589836f, 0.32490006f, 
    0.30536604f, 0.08703400f, -0.11495086f, 0.01576671f, 0.16077307f, 0.07813062f, 0.29381695f, 0.23667565f, 
    0.21557526f, 0.48428938f, -0.34567147f, -0.50484818f, 0.44293943f, -0.00331933f, -0.34553185f, 0.11723895f, 
    0.28541139f, 0.27449867f, 0.13548355f, -0.41028205f, -0.17540058f, -0.20605139f, 0.04215129f, -0.06006190f, 
    0.20813774f, 0.27456760f, -0.12438162f, 0.05625201f, -0.25173816f, 0.19687006f, -0.46518221f, -0.23578851f, 
    0.21350922f, -0.29488158f, 0.31025603f, 0.15324157f, -0.61071926f, 0.40028241f, 0.45331186f, 0.21463393f, 
    0.16401878f, 0.11571905f, -0.06421378f, -0.18409957f, 0.30729577f, -0.46408620f, -0.41369390f, 0.37948540f, 
    -0.01445247f, 0.40363768f, -0.25780943f, -0.03451465f, -0.32247013f, -0.35922328f, 0.45609069f, 0.25681755f, 
    0.36553511f, -0.36009806f, 0.01445097f, 0.16149119f, 0.00259816f, 0.00702061f, 0.36020166f, -0.08786017f, 
    -0.04833059f, -0.01977706f, 0.09224650f, -0.08450481f, 0.13722637f, -0.85967517f, 0.46369103f, -0.26197129f, 
    0.07523403f, 0.65073776f, -0.44861418f, -0.00211506f, 0.16708741f, 0.02544897f, 0.31564084f, 0.06531560f, 
    -0.22403933f, -0.09988905f, 0.41892478f, -0.12255305f, -0.10012397f, 0.00520271f, -0.53299940f, 0.11970636f, 
    -0.11712714f, -0.24472976f, 0.16995355f, -0.19719914f, 0.13080809f, -0.63066763f, 0.28187609f, 0.16337068f, 
    0.09511642f, -0.24239852f, -0.22841685f, -0.24297272f, -0.00505757f, -0.07899220f, -0.25515893f, 0.06224680f, 
    -0.25402737f, -0.02525635f, -0.24559085f, 0.13065013f, 0.06553954f, 0.11812401f, 0.04234777f, -0.16392413f, 
    -0.43313125f, -0.18081713f, 0.18779060f, 0.41438830f, 0.25747845f, 0.00386758f, -0.41400889f, -0.23199530f, 
    0.00242290f, 0.20553051f, 0.26590645f, -0.63215202f, 0.21068133f, 0.05705888f, 0.12703720f, 0.16663998f, 
    0.34800392f, 0.43220255f, -0.39007846f, -0.36262050f, 0.06162853f, -0.03266018f, 0.55277199f, -0.01079167f, 
    0.11239254f, 0.07846595f, -0.40577778f, 0.45865276f, -0.37112927f, -0.60737699f, -0.00853924f, 0.29337603f, 
    -0.20522507f, -0.20020139f, -0.12239489f, -0.05858724f, -0.06629014f, 0.48444039f, 0.28882730f, -0.10187599f, 
    -0.15592964f, -0.36562514f, 0.41126692f, 0.21739243f, -0.03650700f, -0.39397728f, 0.33573747f, 0.20202538f, 
    0.43201709f, -0.01092238f, -0.08949617f, 0.27486578f, -0.13354696f, 0.17896350f, 0.32408860f, 0.22596402f, 
    -0.25110453f, 0.26556045f, -0.10383870f, -0.44257739f, 0.60466570f, -0.14715630f, -0.04840899f, 0.04546760f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.32528543f, 0.31955981f, 0.19021541f, 0.16070597f, -0.11752315f, -0.17562132f, 0.40416822f, 0.27569216f, 
    0.15170375f, 0.60429960f, 0.13943659f, 0.08060846f, -0.32163498f, 0.37147909f, 0.20788239f, -0.10043847f, 
    0.04253347f, 0.44283742f, 0.17987564f, 0.45633081f, -0.21066427f, -0.15798570f, -0.02688957f, 0.02332161f, 
    -0.08788753f, 0.35641584f, 0.13070513f, 0.19441874f, -0.05331774f, 0.34130940f, 0.22762802f, 0.11777930f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.20405917f, 0.31281188f, -0.23663294f, -0.02850704f, -0.25408307f, -0.46694061f, 0.01408929f, 0.01036236f, 
    0.15251489f, -0.14512025f, 0.37426212f, -0.17097096f, 0.06426087f, 0.44109148f, -0.17601834f, 0.48343155f, 
    -0.24736829f, 0.37922326f, 0.22583494f, 0.21574809f, -0.47989959f, 0.18923369f, 0.07479182f, -0.06807016f, 
    -0.37644318f, 0.07959720f, 0.35609320f, 0.10829365f, -0.12564544f, -0.14794533f, 0.13154763f, 0.25997907f, 
    0.12138926f, 0.00813419f, 0.90898669f, 0.08455279f, -0.25324383f, -0.40060598f, -0.09236655f, 0.02656551f, 
    -0.16106121f, -0.07114859f, -0.35831597f, 0.42532256f, -0.65717101f, -0.17827371f, 0.42770988f, 0.07794669f, 
    0.10057779f, 0.38618010f, 0.02809932f, -0.01390942f, -0.02045164f, 0.32336473f, 0.89244711f, -0.23672502f, 
    -0.16217692f, 0.48247719f, 0.17955790f, 0.00279333f, 0.01239201f, 0.15186888f, -0.11266124f, 0.15225020f, 
    0.29337749f, -0.00072153f, 0.64861792f, -0.20184062f, 0.31289470f, -0.05568983f, 0.39065963f, 0.00347137f, 
    0.01378469f, 0.34181789f, 0.00926771f, 0.49693078f, -0.07129541f, -0.36892110f, 0.41315079f, -0.09135927f, 
    0.45249742f, -0.33996671f, -0.74939382f, 0.11773523f, 0.44533724f, 0.01515258f, 0.03133808f, -0.24784090f, 
    0.47039515f, 0.15857206f, -0.43791786f, 0.01101075f, -0.03964948f, 0.14449753f, -0.00014271f, -0.28677970f, 
    -0.01021519f, 0.24758466f, 0.28653401f, 0.01961399f, 0.22754957f, -0.26349646f, 0.28265071f, -0.13017219f, 
    0.13793154f, 0.29089364f, 0.21542306f, -0.25008890f, -0.27595526f, 0.51382369f, -0.12294926f, 0.06578340f, 
    -0.07212650f, 0.05278089f, 0.37852487f, 0.34624723f, -0.47337922f, -0.17684773f, -0.04240777f, 0.19462375f, 
    0.03980197f, 0.25360155f, -0.20291312f, 0.06877600f, -0.07540538f, 0.52963114f, 0.41408750f, 0.29754189f, 
    -0.08577452f, -0.00577443f, -0.12035058f, -0.03395411f, 0.11534525f, -0.14817907f, -0.01195924f, 0.06850574f, 
    -0.16008990f, -0.09214431f, -0.08545473f, -0.13180557f, -0.07953081f, -0.00458870f, -0.13340151f, -0.15895724f, 
    -0.04741802f, 0.02910414f, 0.15996280f, 0.09604847f, 0.09407564f, -0.10968279f, -0.05366860f, -0.12908477f, 
    0.02692164f, -0.05292742f, 0.16480164f, -0.11118180f, -0.10778829f, 0.11829872f, -0.05210242f, -0.08407453f, 
    0.17548878f, -0.03917375f, -0.14004858f, 0.21882209f, -0.38491091f, 0.58911484f, -0.42020974f, 0.27352953f, 
    0.10338984f, -0.85084903f, -0.09525383f, 0.24630505f, -0.79284281f, -0.20950960f, 0.26831913f, 0.35630357f, 
    0.27271250f, 0.34449124f, -0.20145150f, -0.15122204f, 0.48046866f, 0.26135549f, -0.29565820f, -0.02755604f, 
    -0.39321756f, 0.06541615f, 0.27804476f, -0.15306197f, 0.36446089f, -0.40271240f, -0.14357102f, 0.45219854f, 
    0.00132183f, 0.17372866f, 0.00941360f, 0.00796605f, -0.00588020f, 0.18072964f, 0.06471306f, 0.42552081f, 
    0.02940211f, 0.02000413f, 0.24788015f, 0.03809328f, 0.07334457f, -0.05630819f, 0.32142982f, 0.53915632f, 
    0.42988709f, -0.11477442f, -0.50731289f, -0.03765223f, 0.00889353f, -0.08856577f, 0.26420918f, -0.25554347f, 
    -0.11942795f, -0.22064747f, 0.10561678f, -0.07085802f, 0.36671954f, -0.09939373f, 0.21860982f, -0.35212550f, 
    0.29197282f, 0.32708466f, 0.49457264f, -0.36376682f, -0.03401366f, -0.51049411f, 0.04117636f, 0.71241617f, 
    0.50931698f, 0.19026966f, 0.04678906f, 0.01395946f, -0.05981248f, -0.24899976f, 0.46832302f, 0.50240278f, 
    0.24637771f, 0.48510072f, -0.54849988f, 0.44629973f, -0.50198692f, -0.38026851f, -0.32540885f, -0.17467305f, 
    0.07038943f, 0.22395280f, 0.21249478f, 0.06089489f, 0.41371650f, -0.00243142f, 0.01169222f, -0.24933456f, 
    -0.30275881f, 0.18858741f, -0.38106230f, 0.43109849f, -0.05703547f, 0.44770089f, -0.08013081f, -0.09162666f, 
    -0.08938479f, -0.30388662f, 0.19762631f, 0.10810015f, 0.34069186f, 0.20380165f, 0.02658242f, 0.19016029f, 
    -0.07812615f, 0.12473183f, 0.09238343f, 0.02163948f, 0.42685819f, 0.32563946f, 0.26629364f, 0.18217574f, 
    -0.40878907f, -0.01683001f, 0.29857650f, -0.00602777f, 0.26159516f, -0.00970681f, -0.01853396f, 0.05227419f, 
    -0.20777871f, -0.22707246f, -0.31046179f, 0.12677746f, -0.38747999f, 0.53328788f, -0.28017315f, 0.04938197f, 
    0.04064807f, -0.48165545f, 0.15523162f, 0.25836402f, 0.05621397f, 0.13626854f, 0.22000454f, 0.35563758f, 
    -0.24786280f, 0.28320429f, 0.34502900f, -0.14443651f, 0.21563929f, 0.52262080f, 0.00309722f, 0.39256704f, 
    -0.30974093f, 0.16469380f, 0.23800586f, -0.05837132f, 0.31099576f, -0.10600002f, -0.13625230f, 0.40187541f, 
    0.13165633f, 0.36980569f, -0.00319133f, 0.06451654f, 0.00104220f, -0.27870432f, -0.15599111f, 0.23329055f, 
    0.06686838f, -0.09568521f, 0.01943569f, -0.38587835f, -0.01679727f, 0.36730185f, 0.14927022f, 0.65375960f, 
    -0.14004782f, 0.66867816f, 0.30364752f, 0.14923337f, -0.71018100f, -0.39020836f, 0.29030621f, -0.23374188f, 
    -0.23846458f, -0.04260226f, 0.82747751f, 0.11115731f, 0.23725772f, -0.33079308f, 0.31375763f, -0.14009744f, 
    0.12183943f, -0.15140948f, -0.10453839f, -0.14844257f, -0.06955136f, -0.12661037f, -0.06913689f, -0.16822052f, 
    -0.08973993f, -0.16677290f, -0.12886970f, -0.05114263f, 0.15870358f, -0.02369753f, -0.02919951f, -0.07577725f, 
    0.03437303f, 0.04840643f, -0.16760944f, -0.15964596f, -0.09863228f, 0.05218819f, -0.06939759f, -0.12441084f, 
    -0.09949056f, -0.03298933f, 0.10711967f, 0.16189492f, -0.07690211f, 0.10201754f, 0.02189824f, -0.01427560f, 
    0.29898673f, 0.36991963f, -0.24428618f, -0.56721401f, -0.13886182f, -0.19840446f, 0.00593412f, 0.03566863f, 
    0.22953877f, 0.43575865f, -0.08302562f, -0.32537845f, -0.36118719f, 0.46097687f, 0.15791245f, -0.15288129f, 
    -0.06791253f, 0.04830343f, 0.51312971f, 0.36582258f, -0.38623634f, -0.31263053f, 0.35258946f, 0.20472261f, 
    0.48296005f, 0.24992593f, 0.24944077f, 0.01750884f, 0.03602492f, 0.46849126f, 0.59608364f, -0.22953886f, 
    -0.20460857f, 0.32960185f, -0.54509777f, -0.00300369f, -0.10079397f, -0.04047598f, 0.35549131f, -0.15956292f, 
    0.22835810f, 0.09396885f, 0.33418396f, -0.06519341f, 0.05330055f, 0.06002883f, -0.66257823f, -0.48702228f, 
    0.23397508f, -0.94279110f, 0.09303860f, 0.10737222f, -0.05696840f, 0.53275627f, -0.14927417f, -0.01605661f, 
    0.30440900f, -0.09171925f, -1.03149152f, -0.02869918f, -0.04510007f, 0.29385027f, 0.29409149f, 0.76309025f, 
    0.12993659f, -0.15049994f, 0.33549073f, 0.06813441f, 0.11037921f, 0.37645671f, -0.23707187f, -0.32466039f, 
    -0.36478087f, -0.00321345f, 0.05175833f, 0.41824454f, -0.00497747f, -0.22495450f, 0.15144315f, -0.11782710f, 
    -0.13611858f, -0.23350340f, -0.75460637f, -0.24318653f, 0.65742087f, 0.47752389f, -0.39759299f, 0.23752759f, 
    0.08025359f, 0.21976666f, -0.24474841f, -0.00108222f, -0.11308913f, 0.29643145f, -0.24093339f, 0.33434212f, 
    -0.10151555f, 0.35357666f, -0.30401585f, 0.08363815f, -0.06507520f, -0.39787215f, 0.21637841f, -0.07105413f, 
    0.25899297f, 0.33066255f, 0.16267215f, 0.15160783f, -0.13007981f, 0.27137411f, 0.09571139f, -0.19421242f, 
    0.08252552f, -0.03584746f, -0.16072598f, 0.36261788f, -0.33105913f, -0.47745571f, 0.12797228f, 0.26452154f, 
    0.24831943f, 0.00583014f, 0.22667877f, -0.02128555f, -0.08634560f, 0.19434293f, 0.49588022f, -0.15106776f, 
    0.45521683f, 0.16191851f, 0.62595886f, -0.42902100f, -0.48408303f, -0.47329694f, 0.23559959f, 0.03190891f, 
    -0.07326318f, 0.02760227f, 0.07272135f, 0.16356896f, -0.68857777f, -0.09511501f, 0.17161374f, -0.01574475f, 
    0.35391381f, 0.01814112f, -0.19719020f, 0.18578596f, -0.47918120f, -0.20694648f, 0.09957603f, -0.10424765f, 
    0.33868071f, 0.24696112f, 0.08655741f, 0.15605336f, -0.17793375f, 0.72929597f, 0.12096727f, -0.19645302f, 
    -0.11690114f, -0.05092968f, -0.14290848f, 0.09892081f, 0.26819205f, -0.15113112f, 0.01259862f, -0.16729614f, 
    -0.05657331f, 0.09811918f, -0.05403855f, -0.23277728f, -0.00817480f, 0.42421928f, -0.21017958f, 0.00220561f, 
    -0.78962034f, 0.54288965f, 0.72279549f, 0.13847548f, 0.03033679f, 0.05355650f, -0.25998992f, 0.22725114f, 
    -0.40868244f, 0.12113342f, 0.15322688f, 0.05310337f, 0.04045694f, 0.05069960f, 0.04096900f, 0.39080188f, 
    -0.06629212f, -0.00311029f, 0.01573974f, -0.07618755f, -0.05354628f, 0.01348725f, -0.15448231f, -0.09529819f, 
    0.02835322f, 0.14696088f, -0.12029874f, 0.00859104f, -0.07979628f, 0.12377478f, 0.03446717f, -0.07644869f, 
    0.08769276f, 0.08262474f, -0.05200381f, -0.00089227f, -0.13753702f, 0.11334311f, 0.06061541f, 0.16291322f, 
    -0.11771324f, -0.19351669f, -0.16262066f, 0.03279407f, 0.02850724f, -0.10862469f, -0.15117969f, 0.03119436f, 
    0.14465077f, -0.36204183f, 0.25878549f, 0.16381203f, -0.16120443f, 0.58843136f, -0.29862928f, 0.25423151f, 
    0.03288642f, -0.06999230f, -0.16325147f, 0.50756556f, -0.30958489f, -0.13455568f, 0.22775526f, 0.13042791f, 
    0.34919435f, 0.05380228f, 0.08957522f, -0.28362283f, 0.43762901f, 0.47301644f, 0.22006775f, 0.10397479f, 
    -0.05613057f, 0.14937662f, 0.05469966f, -0.03896848f, 0.05948693f, 0.18875009f, -0.16319942f, 0.58839232f, 
    0.04262000f, 0.12068475f, -0.19757825f, -0.00202620f, -0.06024542f, -0.19561857f, -0.20268418f, 0.05325105f, 
    -0.06027463f, -0.00383414f, -0.09143507f, 0.03046186f, -0.12463637f, -0.00521856f, -0.15328385f, 0.13070203f, 
    0.00028946f, -0.09967650f, -0.15119889f, 0.07983486f, -0.09727215f, 0.05324883f, 0.17593314f, -0.10901925f, 
    0.12809023f, 0.12309346f, 0.06138187f, -0.07112508f, -0.11326989f, -0.08684535f, -0.03280571f, 0.11366294f, 
    -0.01361363f, 0.01585025f, -0.02877043f, -0.20944692f, -0.11131541f, 0.11942952f, -0.20471148f, -0.17796125f, 
    0.10253171f, 0.12058054f, -0.12152400f, 0.00836086f, 0.10971516f, 0.03028247f, -0.11329165f, -0.17062899f, 
    0.07868277f, -0.01453340f, 0.11437813f, -0.03323719f, 0.14955996f, -0.03599409f, 0.07519158f, -0.11938508f, 
    -0.14391087f, 0.08416688f, 0.13313961f, -0.03951446f, -0.04258488f, -0.06523708f, -0.12198558f, 0.10859209f, 
    -0.13252151f, 0.45278513f, 0.04794268f, 0.04534154f, -0.40063450f, 0.05160351f, 0.29459411f, -0.32926244f, 
    -0.85745394f, -0.02544640f, 0.24865675f, 0.11852979f, -0.00346472f, 0.22645290f, -0.21201250f, 0.10767083f, 
    -0.03119351f, 0.25523138f, -0.35873890f, -0.02209437f, 0.02884658f, 0.12816212f, -0.17192008f, -0.03757791f, 
    0.02343940f, 0.02527140f, 0.10460865f, -0.05937203f, -0.30778965f, 0.45712191f, -0.04186081f, -0.14161462f, 
    0.33619535f, -0.42926082f, 0.60982162f, -0.26220432f, 0.22214913f, 0.07488830f, -0.20594634f, 0.23635145f, 
    0.24551573f, 0.30311719f, -0.01909947f, 0.29671371f, -0.18808852f, -0.01817133f, -0.18698545f, -0.24298871f, 
    -0.14733854f, -0.21818158f, 0.60890883f, -0.10717566f, 0.30950829f, 0.56849867f, -0.37103662f, 0.35455376f, 
    0.34432518f, 0.41837519f, -0.14699951f, -0.04996582f, -0.09975689f, -0.03659103f, -0.21131770f, 0.50852317f, 
    -0.26508695f, 0.58351105f, -0.52101153f, 0.41105062f, 0.26306161f, 0.39331165f, -0.08444977f, -0.15421259f, 
    -0.07468408f, -0.11783782f, 0.04614166f, -0.33630165f, -0.21566197f, 0.49265945f, 0.03250195f, 0.49650100f, 
    0.12376559f, 0.12956119f, -0.13638325f, 0.04166453f, 0.47670069f, 0.00936555f, -0.16327283f, 0.38115743f, 
    -0.32121930f, -0.33503968f, 0.40619284f, -0.12405473f, 0.29795977f, -0.30914211f, 0.29267535f, 0.39517048f, 
    0.03067720f, 0.08853563f, -0.05633692f, -0.13766305f, 0.08308595f, 0.12737723f, -0.13141559f, -0.14629075f, 
    0.13462871f, -0.02795580f, -0.16890122f, 0.14786229f, -0.12412276f, -0.15058498f, 0.12935807f, -0.18136828f, 
    -0.12767807f, 0.07607495f, -0.13540733f, -0.13927515f, 0.09074119f, 0.11860809f, -0.03615936f, -0.14656700f, 
    -0.03588977f, -0.00025917f, -0.05518506f, -0.05650752f, -0.13920744f, 0.07504521f, 0.12594566f, -0.11979733f, 
    -0.15391800f, -0.05724802f, -0.05643990f, -0.04144917f, -0.04143931f, -0.08214975f, 0.08507027f, -0.13194446f, 
    -0.05403683f, -0.04546732f, -0.03827208f, 0.15447062f, -0.13548785f, -0.07742439f, -0.11971639f, -0.09083252f, 
    -0.16717714f, -0.00143101f, -0.09348036f, -0.03205023f, -0.00294046f, -0.14459766f, 0.07744054f, 0.08145222f, 
    -0.12087088f, -0.16745442f, 0.07061426f, 0.03553856f, -0.11635417f, -0.10823633f, -0.11159689f, -0.03331304f, 
    -0.00225597f, 0.32181180f, -0.28943354f, -0.22037007f, -0.49384409f, 0.28245795f, 0.14794852f, -0.37343532f, 
    -1.02830756f, 0.03037133f, 0.40136698f, -0.16304189f, -0.41828516f, 0.49159276f, -0.00278716f, 0.00607062f, 
    0.11377824f, -0.23667675f, 0.21453308f, 0.24171653f, 0.25364110f, 0.03694534f, 0.64752692f, 0.38851666f, 
    0.13688827f, -0.14332931f, 0.24665169f, -0.11306672f, -0.11374614f, 0.18852100f, 0.23694032f, 0.03527090f, 
    0.19568762f, -0.25132659f, 0.18151145f, -0.05021782f, -0.20521079f, -0.05333354f, -0.20583799f, -0.03184273f, 
    -0.18763304f, 0.29862449f, 0.08401550f, 0.34619436f, 0.12731761f, -0.04590975f, 0.04504396f, 0.17106684f, 
    -0.36014909f, 0.05776250f, -0.03357812f, -0.25954515f, 0.20254543f, 0.38145146f, -0.24547984f, 0.16630051f, 
    -0.19001357f, 0.23444872f, -0.19045627f, -0.14138368f, -0.09251696f, 0.30549341f, -0.37972006f, 0.11205769f, 
    0.37997127f, 0.06052815f, 0.15272160f, 0.30174357f, 0.14233695f, -0.31397480f, -0.07416435f, 0.29258370f, 
    0.36858329f, -0.13057163f, -0.24053237f, -0.34323606f, -0.25886360f, 0.20833980f, -0.18631765f, 0.16214156f, 
    -0.23550931f, 0.42503044f, 0.92141676f, 0.28789592f, -0.20505275f, -0.14978793f, -0.05147432f, 0.17957906f, 
    -0.11303958f, 0.16060022f, 0.26804471f, -0.01904004f, 0.25438520f, -0.10675801f, 0.24903858f, 0.14573878f, 
    0.13283877f, 0.29807574f, 0.15468727f, 0.17630370f, -0.17064278f, 0.34324947f, -0.20670146f, 0.09709056f, 
    -0.27452162f, -0.05792163f, -0.07958289f, 0.22575909f, -0.06207504f, 0.14543460f, 0.01500516f, 0.47571561f, 
    0.01692357f, 0.61383152f, 0.48252192f, -0.00705277f, 0.32340193f, 0.46154705f, 0.31919929f, 0.46956834f, 
    -0.38302368f, 0.08264734f, 0.52917969f, 0.06318720f, 0.06405275f, 0.24869353f, 0.02377159f, 0.31623805f, 
    -0.14795324f, 0.09150591f, 0.27636942f, -0.07511010f, 0.07321046f, -0.23864973f, 0.32903638f, 0.17217207f, 
    -0.15941544f, -0.23674001f, 0.26349059f, -0.02061161f, -0.03590371f, 0.08082134f, -0.07226525f, 0.07892265f, 
    0.49336484f, -0.25696039f, -0.26400065f, -0.17838891f, -0.63304746f, 0.36161703f, 0.04920942f, -0.18320422f, 
    -0.04948385f, 0.19029067f, 0.01461557f, 0.04599635f, -0.06079821f, -0.02966302f, -0.03393241f, 0.40295637f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.29638478f, 0.36282653f, 0.23017035f, 0.08796711f, -0.00535226f, -0.30142736f, 0.09148602f, 0.66201556f, 
    -0.26734978f, -0.00477934f, 0.29809210f, -0.01658967f, 0.49859232f, -0.02261656f, -0.10047550f, 0.37689263f, 
    0.12164214f, 0.02128145f, -0.09031507f, -0.00473538f, -0.09359133f, -0.03108372f, 0.24103709f, -0.00862196f, 
    0.02532127f, 0.05370414f, -0.09458692f, -0.03935752f, 0.37696230f, -0.19065529f, 0.12720691f, 0.03308772f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.60376269f, -0.06933235f, -0.06121921f, -0.66829014f, -0.02086063f, 0.27674824f, 0.08841829f, -0.36623806f, 
    0.16613808f, 0.24936979f, -0.52310514f, -0.03845228f, 0.81410193f, -0.16670012f, 0.11752081f, 0.17332792f, 
    -0.88135880f, -0.41428074f, -0.15084954f, 0.29513070f, 0.10511295f, 0.10011982f, -0.45248759f, 0.12308212f, 
    0.26375553f, 0.00380728f, 0.07959371f, 0.35115913f, -0.07946979f, -0.19418570f, 0.17170894f, -0.38167447f, 
    0.36017570f, -0.02411223f, -0.49990958f, -0.03278456f, 0.11090961f, 0.20280860f, 0.12453879f, -0.02064203f, 
    0.15936726f, 0.45281351f, 0.27885291f, -0.02516327f, -0.12126791f, 0.39322945f, -0.34509718f, -0.01390989f, 
    -0.39907467f, -0.03849624f, -0.07955956f, -0.06656592f, 0.03815150f, -0.14988680f, 0.15357080f, -0.49673536f, 
    0.28397429f, 0.01570633f, -0.08151643f, -0.16472071f, 0.01732637f, 0.02844205f, -0.00369300f, 0.02110616f, 
    -0.19808136f, 0.38658789f, 0.21649881f, -0.27827677f, -0.00921333f, -0.89084083f, 0.32689917f, 0.44998640f, 
    -0.16003242f, -1.14291847f, 0.33007723f, -0.12096263f, 0.13084018f, -0.97286355f, -0.66973853f, 0.12430068f, 
    0.30682924f, -0.30471721f, 0.13738075f, -0.35274893f, 0.07262077f, -0.02194530f, 0.24985068f, -0.51414192f, 
    -0.51369864f, -0.09506081f, 0.16073883f, -0.12591276f, -0.80256718f, -0.00272919f, -0.08695532f, 0.04235915f, 
    -0.21016893f, 0.11819554f, 0.11893410f, -0.12743995f, 0.13298193f, -0.18846634f, 0.14742532f, 0.00094897f, 
    -0.02963196f, 0.07571288f, -0.52457911f, 0.09689067f, -0.21829335f, -0.93370658f, 0.24553847f, -0.25919706f, 
    0.03374108f, 0.26346892f, -0.07601925f, 0.09873998f, -0.02548840f, 0.05294905f, 0.83946240f, -0.00030138f, 
    -0.16867408f, -0.09275356f, -0.14454375f, 0.50964147f, 0.40759724f, -0.55111760f, 0.13610052f, 0.00642651f, 
    -0.48588687f, 0.28145385f, 0.08177710f, -0.14100888f, 0.07103009f, 0.17129414f, 0.06931703f, 0.13884737f, 
    0.00205307f, -0.03042009f, -0.26803875f, -0.10204772f, -1.08303738f, 0.15402684f, -0.00271749f, -0.44451565f, 
    -0.04424993f, -0.15959810f, -0.02373974f, 0.23652284f, -0.13568828f, 0.11294413f, -0.35662892f, 0.22136597f, 
    -0.18378600f, -0.10327128f, -0.04971562f, -0.94267392f, -0.13689138f, 0.20437618f, 0.06539556f, 0.02832021f, 
    0.09202852f, 0.00715454f, -0.09017850f, -0.13035959f, -0.07701220f, 0.11373062f, 0.21880284f, 0.29867333f, 
    -0.14438719f, 0.09790593f, 0.25017339f, 0.10999075f, -0.24716432f, 0.16227823f, -0.42135447f, -0.11929111f, 
    -0.08909275f, -0.54363465f, -0.14671580f, 0.04306075f, -0.02480587f, 0.09573605f, -0.37711209f, 0.08531283f, 
    0.07516855f, -0.18981552f, -0.06559002f, -0.15782923f, -0.19902906f, 0.12520091f, 0.03859094f, 0.27721536f, 
    -0.57066971f, -0.85096925f, 0.26055831f, 0.15828061f, 0.06893389f, -0.32507440f, -0.02147862f, 0.32847184f, 
    -0.45689222f, -0.62097055f, -0.18495309f, 0.08195852f, 0.48404741f, -0.22975180f, -0.57826650f, 0.22906965f, 
    0.43138748f, -0.56585127f, -0.14771993f, -1.21701550f, -0.03669163f, 0.13577659f, -0.62675530f, -0.01687924f, 
    -0.79422343f, -0.08050229f, 0.00402696f, -0.56433028f, -0.81104469f, -0.06075354f, -1.49564493f, -0.17605790f, 
    -0.02409250f, -0.78630322f, -0.24673384f, 0.08706944f, -0.06056119f, -0.27203369f, -0.27804291f, -1.37735796f, 
    0.13385762f, -0.73106337f, -0.59726870f, 0.13186276f, -0.07819755f, 0.39195028f, -0.65147126f, 0.13849811f, 
    0.49533018f, -0.16227110f, -0.02537940f, -0.66229737f, 0.09144660f, -0.12177939f, 0.77691031f, -0.36175457f, 
    0.11021616f, 0.03928108f, -0.01338129f, 0.77411085f, -0.24241419f, 0.04897660f, -0.16016538f, 0.27177674f, 
    -0.01542925f, -0.82049704f, -0.42111880f, 0.10670000f, -0.05257902f, -0.78720677f, -0.01671150f, 0.15022840f, 
    0.16273324f, -0.08675557f, 0.28436339f, -0.07918356f, 0.17798127f, -0.40424892f, -0.34469935f, 0.17127755f, 
    -0.50109726f, 0.33676040f, -0.14311282f, -0.82576209f, -0.00390117f, -0.03769214f, 0.27567703f, -0.54260075f, 
    0.47676003f, -0.12492465f, -0.00966330f, 0.30012217f, -0.03166598f, 0.36821693f, 0.24089839f, -0.59925085f, 
    -0.07281496f, 0.31622088f, 0.31369948f, -0.04695666f, -0.12060656f, -0.90677285f, -0.13499123f, 0.27676660f, 
    -0.85665470f, -0.61423850f, -0.33722046f, 0.13576819f, 0.02548587f, 0.08615198f, 0.46314323f, 0.22674049f, 
    -0.08402040f, -0.70020777f, -0.20431767f, 0.12286594f, -0.19218358f, -0.18527363f, -0.21661042f, 0.14631759f, 
    -1.03390455f, 0.13969792f, -0.05674352f, -0.71725136f, 0.33484784f, -0.47438684f, -0.41507369f, 0.04725976f, 
    0.26142657f, 0.14350685f, -0.80315089f, -0.14008799f, 0.14095496f, -0.41846091f, -0.43670058f, -0.04852726f, 
    -0.14240296f, 0.18855566f, 0.35383406f, -0.17461248f, -0.07668226f, -0.48863679f, -0.94769627f, -0.51621288f, 
    0.00449308f, 0.33947673f, -0.01583176f, -0.11195970f, 0.11148336f, -0.13312313f, -0.31793952f, 0.37761012f, 
    -0.29180163f, -0.11463709f, 0.15335020f, -0.32701340f, 0.51186067f, 0.45727119f, 0.29842022f, -0.52624339f, 
    -0.13070829f, 0.25845239f, -0.09021529f, 0.41959584f, 0.05868950f, -0.55419683f, -0.65889746f, -0.47128710f, 
    -0.39289498f, -1.19386446f, -0.20166232f, 0.06883103f, 0.25879338f, 0.03510704f, -0.11332850f, 0.13424596f, 
    0.06447809f, 0.23646136f, 0.07732633f, -0.13985799f, 0.12298475f, -0.01720920f, -0.18518388f, 0.35826519f, 
    -0.16011734f, -0.05154612f, 0.09583304f, 0.17184317f, -0.43172565f, 0.16272421f, -0.21106748f, 0.08809868f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.34979612f, 0.26832145f, 0.27784270f, 0.30770084f, -0.32054663f, -0.30234960f, 0.10201027f, -0.57392728f, 
    -0.26678625f, 0.22963917f, 0.15220013f, -0.17451091f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
