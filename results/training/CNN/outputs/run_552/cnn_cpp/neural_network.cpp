#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.42620602f, 0.07888060f, 0.39271641f, -0.89924765f, -0.47152415f, -0.72007358f, 0.00071132f, 0.28621754f, 
    0.18800053f, 0.75311351f, 0.73612320f, 0.57139707f, 0.31476325f, -0.64314890f, 0.14847928f, 0.27513400f, 
    0.45678860f, -0.11716007f, -0.31476691f, -0.45797071f, -0.43761203f, -0.15784770f, 0.75565761f, -0.38067618f, 
    -0.06931484f, -0.17715751f, 0.14355040f, -0.60618210f, -0.52792227f, -0.60776955f, 0.50478214f, 0.79389083f, 
    0.46387959f, 0.23585960f, -0.41231924f, -0.19112447f, -0.54052734f, -0.63682610f, -0.83485240f, -0.07056449f, 
    -0.07916266f, 0.15254897f, -0.37810582f, 0.00192254f, -0.13630109f, -1.02330899f, 0.76739109f, 0.07677592f, 
    0.03465885f, 0.14593914f, -0.56458318f, -0.04696737f, -0.02608454f, 0.12307977f, 0.82156432f, 0.57631904f, 
    0.81149065f, 0.02384636f, 0.48687503f, -0.15039283f, -0.25250444f, -0.04044041f, 0.11977237f, -0.30438405f, 
    -0.53675234f, -0.45630679f, -0.05138299f, -0.33206612f, -0.46608958f, 0.37442890f, 0.14340010f, -0.40348536f, 
    -0.28178594f, -0.01896465f, 0.33306187f, 0.73561406f, 0.24403584f, -0.85772014f, -0.14870869f, -0.26508465f, 
    -0.16631515f, -0.49851125f, 0.51899695f, 0.81753021f, 0.21617955f, -0.00841878f, 0.47680774f, -0.00364675f, 
    0.21306109f, -0.41914323f, -0.03913854f, 0.84423071f, -0.50958318f, -0.31599945f, -0.44452637f, -0.21750295f, 
    -0.05737586f, -0.30939424f, -0.34042042f, -0.39280277f, -0.82728112f, -0.42833170f, -0.26323658f, -0.35506445f, 
    0.04249043f, 0.31670099f, 0.16556400f, 0.32285041f, -0.23750550f, 0.15045491f, 0.20065798f, 0.36261618f, 
    0.34794953f, 0.57836038f, 0.56333417f, -0.34802696f, 0.35446236f, 0.05019216f, -0.42825791f, -0.23440561f, 
    -0.67334735f, 0.33466354f, 0.75572425f, 0.10015895f, -0.01603925f, 0.46847498f, 0.31371585f, 0.14801314f, 
    -0.31474423f, -0.32839003f, -0.60941553f, -0.36736417f, -0.09014381f, -0.52183777f, -0.03444300f, -0.34574050f, 
    -0.09050989f, -0.45111567f, 0.86256534f, 0.79555100f, -0.14396802f, 0.27656183f, 0.45663038f, 0.28654805f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.22964598f, 0.06758249f, 0.00267262f, 0.08191253f, -0.14702159f, -0.03741128f, 0.42803660f, 0.64866483f, 
    -0.24523196f, -0.05653460f, -0.08782195f, 0.00357066f, -0.11256933f, -0.12753378f, 0.01815819f, -0.06926446f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.13751568f, -0.27797776f, 0.08045974f, -0.21747440f, -0.03767817f, 0.06863914f, -0.00597379f, -0.14352521f, 
    0.06428130f, -0.12286340f, -0.38127947f, -0.15987211f, -0.30170837f, -0.27691919f, 0.11378424f, 0.10587945f, 
    -0.07676910f, 0.07868035f, 0.03954455f, 0.21564014f, -0.00763577f, 0.15023194f, 0.05058242f, 0.25765786f, 
    -0.14897780f, -0.17740643f, -0.36042711f, 0.26334015f, 0.25214323f, 0.11472601f, -0.02090378f, 0.04981736f, 
    -0.13851123f, 0.10865689f, 0.16149250f, -0.08134579f, 0.19977406f, 0.48547247f, 0.05109071f, 0.30502650f, 
    0.05146552f, -0.13330078f, -0.00090601f, 0.11655068f, 0.12583661f, 0.18659247f, -0.19471674f, 0.19561522f, 
    -0.04078897f, -0.20914412f, -0.08513592f, -0.03530330f, 0.02358426f, 0.04825494f, -0.20587158f, -0.05742551f, 
    0.13614327f, 0.10407455f, 0.01973533f, 0.10117528f, -0.13438305f, -0.10042781f, 0.12577964f, 0.06339141f, 
    -0.01910919f, -0.03348072f, 0.10200401f, 0.05798050f, 0.01165460f, -0.09845383f, 0.09723471f, -0.12968546f, 
    0.16393283f, 0.16355759f, 0.10576617f, -0.08960591f, -0.04954818f, -0.03768806f, -0.01341646f, -0.02924125f, 
    0.19861706f, -0.27839184f, -0.08897886f, -0.00630882f, 0.12451274f, -0.07557049f, -0.07280869f, -0.10607447f, 
    0.07379666f, -0.04763601f, 0.11129690f, -0.16990669f, 0.02039620f, 0.02589670f, -0.06999177f, 0.03539107f, 
    0.00523421f, 0.04031049f, -0.11046054f, 0.04681377f, 0.21869549f, -0.02773422f, -0.08605444f, -0.09328385f, 
    -0.15350629f, -0.04303572f, 0.01561578f, -0.05113328f, -0.03920091f, 0.15212651f, 0.01530590f, 0.05569376f, 
    0.01025429f, 0.00819880f, -0.00818484f, -0.13142955f, -0.05792095f, -0.18793407f, 0.11961263f, -0.22983314f, 
    0.03137609f, -0.10757610f, -0.21248002f, -0.05369037f, 0.20071033f, 0.19870050f, 0.16058460f, -0.02480821f, 
    -0.11736609f, -0.07807770f, -0.10387175f, 0.13589077f, 0.18304081f, 0.04559282f, -0.05643307f, 0.13236804f, 
    0.24554765f, -0.06727131f, -0.08851340f, 0.20698322f, -0.03570574f, 0.09890267f, 0.22034347f, -0.03637573f, 
    0.23855926f, 0.15772478f, -0.00490833f, -0.04041919f, 0.09429646f, 0.14379832f, -0.04972094f, -0.04665639f, 
    0.06935076f, 0.29988000f, 0.39485827f, 0.26066795f, -0.11297026f, 0.00980677f, -0.01203159f, 0.00226344f, 
    0.10490501f, 0.12182096f, -0.15347458f, -0.18242833f, -0.36093292f, -0.03294607f, 0.01182726f, 0.08466399f, 
    -0.10139548f, -0.25802755f, 0.10459420f, -0.18303038f, -0.26243970f, -0.26724708f, 0.09659359f, 0.18743089f, 
    0.11775295f, 0.07482342f, -0.01251167f, -0.07595748f, -0.07819710f, -0.01847403f, -0.15450870f, 0.01199743f, 
    0.05188478f, -0.04679738f, -0.00445718f, 0.02378624f, 0.02207285f, 0.04455076f, -0.00163141f, -0.05492815f, 
    -0.15418792f, -0.06233401f, -0.03985658f, -0.00615833f, 0.25987634f, 0.06087926f, 0.14949760f, 0.35010174f, 
    0.36257473f, 0.07729740f, 0.10200803f, 0.11544403f, -0.10400680f, -0.02840479f, 0.07311053f, -0.06029870f, 
    0.12181649f, -0.21837330f, 0.16973370f, 0.07886054f, -0.15071112f, 0.27873617f, -0.00477861f, 0.11213027f, 
    -0.26986849f, -0.05022803f, -0.37277398f, 0.29167205f, -0.07535866f, -0.16300385f, 0.29612219f, -0.16312417f, 
    -0.01187081f, -0.05413096f, -0.27484217f, 0.06667905f, -0.01086430f, 0.04766326f, 0.00347016f, 0.05431846f, 
    -0.05682078f, -0.08642433f, 0.03280393f, 0.05884422f, 0.37953824f, -0.15278094f, -0.00816487f, -0.14810084f, 
    -0.09545234f, -0.07814077f, 0.16134363f, -0.38382274f, 0.09068116f, -0.45283267f, 0.31777248f, 0.15226430f, 
    -0.05445584f, -0.05613191f, -0.15770714f, 0.05024251f, -0.41081026f, -0.31230089f, -0.01842040f, 0.09469044f, 
    0.18116899f, 0.01874813f, -0.11204668f, 0.03074376f, -0.14938657f, -0.08010903f, -0.18214162f, -0.30817163f, 
    0.04098256f, 0.02720998f, 0.01849983f, -0.05276620f, -0.16177496f, 0.04357680f, -0.13467458f, -0.05703420f, 
    0.09518835f, -0.22165467f, 0.06622484f, 0.05216907f, 0.11722086f, 0.14533372f, 0.20244250f, -0.20404685f, 
    -0.02946472f, 0.12736848f, 0.22312441f, 0.04893652f, -0.07602234f, 0.03901580f, -0.05335105f, -0.23131925f, 
    0.01849327f, 0.03578475f, -0.05927906f, -0.06376326f, -0.05903515f, -0.06640280f, 0.00530672f, -0.03484860f, 
    -0.00384554f, -0.07038623f, 0.00290965f, 0.03761550f, -0.08586740f, 0.03928104f, 0.02194240f, -0.00453454f, 
    0.05154491f, 0.06995696f, 0.07046098f, -0.01631299f, -0.06152083f, -0.00525239f, -0.03058025f, -0.07484301f, 
    0.02032792f, 0.00479108f, 0.03877274f, 0.02083415f, -0.03038465f, -0.02287359f, 0.00387740f, -0.02967690f, 
    0.04715595f, 0.05030869f, -0.00666548f, 0.03331643f, -0.03870846f, 0.02028430f, 0.00217968f, 0.00878876f, 
    -0.10179842f, -0.09186498f, -0.03615978f, 0.00262389f, -0.01713142f, -0.02588453f, -0.05537960f, -0.04297551f, 
    -0.01013305f, -0.06531207f, -0.04407177f, -0.02039923f, 0.05701752f, -0.07435583f, 0.01588833f, 0.00246030f, 
    -0.09084208f, -0.08203256f, 0.04063729f, -0.01633776f, -0.06986704f, -0.03075553f, -0.04092076f, 0.00175144f, 
    -0.07306934f, -0.02938187f, 0.01574382f, -0.05390787f, 0.05252934f, -0.04096176f, -0.07058549f, 0.03980783f, 
    -0.04695543f, 0.02251663f, 0.00181461f, -0.09782963f, -0.05836819f, -0.01298417f, 0.05356221f, -0.04758295f, 
    0.01381136f, -0.08357451f, 0.01053286f, -0.09024055f, 0.00406452f, -0.00270133f, -0.05737151f, -0.06758451f, 
    -0.02970578f, -0.07425106f, 0.05207888f, -0.06386430f, -0.02134406f, -0.07668335f, 0.04661107f, 0.01730705f, 
    0.01517670f, -0.06844269f, -0.03514649f, -0.05896384f, 0.01479247f, 0.03466915f, -0.01398703f, 0.00132046f, 
    0.03817821f, 0.02430100f, -0.05553885f, 0.03638162f, -0.03275525f, -0.03773158f, 0.01840495f, 0.04661174f, 
    0.01795173f, -0.04051042f, -0.01112405f, 0.06785804f, -0.03983728f, 0.03586827f, 0.02026254f, 0.02887417f, 
    0.05911298f, -0.04024173f, -0.05804664f, -0.04276022f, -0.02920048f, -0.05651782f, 0.03724710f, -0.05398168f, 
    -0.05501230f, -0.05256561f, -0.01688807f, 0.05422277f, 0.01992534f, 0.06634638f, -0.00006451f, 0.06490079f, 
    0.02706326f, 0.01780303f, 0.05164849f, 0.04032080f, 0.01099243f, 0.04054270f, -0.00852115f, 0.02452645f, 
    -0.37962627f, -0.28286400f, -0.12157375f, 0.11889639f, -0.05031013f, -0.04157042f, -0.09344380f, -0.07871370f, 
    0.02715658f, 0.26042807f, -0.04970375f, 0.18163785f, 0.04434340f, 0.08109849f, -0.07295904f, -0.01785707f, 
    -0.06110526f, -0.06438684f, 0.21718119f, -0.00488525f, -0.26599884f, -0.05983551f, 0.10717143f, 0.07075768f, 
    -0.03468026f, 0.18533984f, -0.14119625f, 0.23895703f, 0.20813420f, 0.28175664f, 0.05273882f, 0.08405925f, 
    0.00580213f, 0.00360872f, -0.06055908f, -0.12442871f, 0.26844007f, 0.27574113f, 0.17760599f, -0.03226086f, 
    0.12453489f, -0.18446897f, -0.05584701f, 0.01578006f, -0.06866995f, -0.38492492f, -0.09344348f, -0.04010824f, 
    -0.09744938f, -0.07089189f, 0.02485881f, 0.02923757f, -0.05460224f, -0.00129190f, -0.12570332f, -0.24056669f, 
    0.19073607f, 0.21800159f, 0.00060173f, -0.13709354f, 0.01326756f, -0.04880217f, -0.07397174f, 0.33501294f, 
    0.24853586f, -0.10942674f, -0.01470133f, -0.14736228f, 0.10017682f, 0.06941832f, -0.12928195f, 0.09865928f, 
    -0.30496666f, 0.01543538f, -0.06446460f, -0.16041422f, 0.02519744f, -0.06012898f, -0.05825139f, -0.06370609f, 
    0.01278926f, -0.11828417f, 0.10631942f, -0.13022794f, 0.04709174f, 0.00132497f, -0.10545729f, 0.12431636f, 
    -0.11233406f, -0.01318841f, -0.07165631f, 0.08451725f, -0.13778697f, -0.13442680f, -0.19525501f, -0.06620923f, 
    0.19798642f, 0.03488402f, -0.15352188f, 0.09283850f, 0.33779570f, -0.07756607f, -0.01409877f, -0.14718872f, 
    0.12843770f, 0.06551669f, 0.00765442f, 0.11003499f, 0.15483205f, 0.00344741f, 0.21837725f, -0.06831295f, 
    0.08206617f, -0.07054330f, -0.05216805f, 0.10940114f, -0.14202183f, -0.20425540f, 0.18629079f, 0.10530516f, 
    0.07624716f, -0.17877063f, -0.04764510f, 0.02933683f, -0.11529011f, 0.21221560f, -0.23390609f, -0.65314198f, 
    0.06102785f, 0.10090385f, 0.04028480f, 0.01567456f, -0.05687159f, -0.04331525f, -0.20978862f, 0.12127484f, 
    -0.05074503f, -0.01425562f, 0.08559888f, -0.31723791f, 0.10704822f, 0.05273141f, 0.07776994f, 0.08783341f, 
    -0.35817778f, 0.09271869f, -0.01101303f, -0.02898087f, 0.07589522f, 0.05496653f, 0.02000890f, -0.01133313f, 
    0.07687331f, -0.06450257f, 0.18912400f, 0.06988513f, -0.46077374f, -0.21655691f, -0.11684088f, 0.17117396f, 
    0.09526370f, 0.01071500f, 0.20894390f, -0.13710353f, -0.28757232f, 0.01570311f, 0.18859117f, 0.15349101f, 
    -0.09988419f, -0.11147733f, -0.24950047f, 0.45553678f, 0.29691899f, 0.07085956f, 0.12254984f, -0.00901413f, 
    0.01469159f, 0.05410492f, -0.21764697f, -0.01003209f, 0.04676411f, 0.03003017f, -0.05893608f, 0.10830010f, 
    0.01093627f, -0.11767945f, 0.08766805f, 0.04404939f, 0.18875282f, 0.24110964f, 0.00700538f, -0.23265946f, 
    -0.07268999f, 0.04364261f, 0.04442893f, -0.04780288f, -0.06504372f, 0.06766447f, 0.27823606f, 0.27706170f, 
    0.03101768f, -0.15257618f, -0.23338015f, 0.00790069f, 0.03054551f, 0.06448004f, -0.05935988f, -0.33716005f, 
    0.00431314f, 0.08094438f, 0.12652156f, 0.23443517f, 0.23283154f, 0.08041660f, 0.02917872f, 0.03700122f, 
    -0.35365266f, -0.13381262f, 0.18896486f, -0.21433413f, -0.08159817f, -0.08950742f, -0.08402174f, 0.00336450f, 
    0.14396703f, -0.06195830f, 0.01255084f, 0.11249693f, -0.16506192f, 0.10091148f, 0.04308567f, 0.00716579f, 
    0.14507037f, -0.23142651f, 0.00227567f, -0.13174392f, -0.14531957f, -0.18217947f, 0.09234220f, 0.04720427f, 
    -0.05354503f, 0.10345379f, 0.03777870f, -0.19761500f, -0.01026189f, 0.21819593f, 0.06424690f, 0.10921304f, 
    0.02132874f, -0.13792488f, 0.09783562f, -0.15804347f, 0.07076877f, 0.34523806f, -0.10349613f, -0.13188146f, 
    -0.12897260f, -0.03869024f, -0.23598309f, 0.17450060f, 0.15333818f, -0.09635483f, -0.23054281f, -0.35606965f, 
    -0.15739532f, -0.04832505f, 0.08522145f, -0.08597766f, -0.22490591f, 0.24691366f, -0.06666056f, 0.05699410f, 
    0.13823630f, -0.11292892f, -0.07851811f, -0.18534836f, 0.05960596f, 0.09979554f, 0.23888914f, 0.39788461f, 
    0.14921708f, 0.13278219f, 0.06668992f, 0.08323967f, 0.03649074f, -0.10433088f, 0.04365127f, 0.14935645f, 
    0.09642594f, -0.19238445f, 0.19064163f, -0.00493932f, -0.07463582f, 0.06211089f, -0.18934394f, -0.13215372f, 
    0.09999043f, -0.52749979f, -0.25966769f, -0.15147750f, -0.08013754f, -0.07380326f, 0.07126249f, -0.03012569f, 
    -0.04044625f, -0.09431682f, 0.13903107f, -0.03871883f, 0.16338038f, 0.16467108f, -0.16543274f, 0.09588268f, 
    0.14365643f, -0.01677163f, -0.01850876f, 0.30997613f, 0.10977160f, -0.10644770f, 0.15339988f, 0.12802821f, 
    -0.01846221f, 0.03600392f, 0.26748002f, 0.00021557f, 0.04759638f, 0.13247202f, 0.29055524f, 0.05928113f, 
    -0.11151450f, 0.09901993f, -0.02118595f, 0.26222345f, -0.00102045f, -0.17033742f, -0.07777574f, -0.18295898f, 
    0.20030707f, -0.06020842f, 0.17804173f, -0.19004413f, 0.13978797f, -0.11124825f, -0.45614448f, -0.22940096f, 
    0.11277094f, -0.09472375f, 0.09744667f, 0.11969008f, -0.14992969f, -0.09634319f, 0.20810655f, 0.19310802f, 
    0.01951159f, 0.12011916f, -0.21575771f, 0.16698839f, 0.22884020f, -0.01567009f, 0.06175464f, 0.02598344f, 
    -0.05889501f, 0.00047200f, -0.09594043f, -0.01119508f, 0.02592259f, -0.04174266f, -0.02725785f, 0.06976178f, 
    -0.07235168f, -0.10391663f, 0.11219400f, -0.19089530f, 0.02076703f, 0.17526262f, -0.24633832f, 0.06137999f, 
    0.01356958f, 0.02465640f, 0.32526919f, 0.03632876f, -0.04671776f, -0.07505067f, 0.00185634f, 0.17398737f, 
    -0.11550823f, -0.15066274f, -0.09269357f, 0.13893092f, 0.09586725f, 0.04614590f, -0.01773094f, -0.18610346f, 
    -0.04533112f, -0.09811886f, 0.04918155f, -0.07169823f, 0.26361459f, 0.20003287f, -0.28996623f, -0.11572015f, 
    0.03324392f, 0.29956836f, -0.16686890f, -0.01475491f, 0.06405024f, -0.13099875f, -0.17599161f, -0.08589572f, 
    0.09222917f, -0.08866820f, -0.20584740f, 0.11572480f, -0.03053424f, 0.09190721f, -0.09110776f, 0.28821620f, 
    0.19421396f, -0.02820185f, 0.15970118f, 0.07128294f, -0.13249084f, 0.10908812f, -0.13280079f, 0.13724194f, 
    0.10282009f, -0.04819787f, -0.04432140f, 0.07488290f, -0.01732836f, 0.21796384f, -0.11153633f, 0.17267720f, 
    0.28747180f, 0.41649225f, -0.01196052f, 0.11950234f, 0.11756509f, 0.03061699f, -0.04119447f, 0.03126292f, 
    -0.15393491f, -0.50647730f, -0.16352624f, 0.09685388f, 0.02984844f, 0.08556312f, 0.08484263f, -0.04925456f, 
    0.01057953f, -0.05439181f, 0.02227699f, 0.06329878f, -0.02998329f, 0.18488762f, -0.05657017f, -0.02478094f, 
    0.02129558f, -0.21622446f, -0.26280898f, 0.36326122f, 0.10171781f, -0.05979088f, -0.04830446f, 0.01728947f, 
    -0.09927365f, 0.05701544f, -0.01515955f, 0.21199673f, -0.12109698f, -0.19682662f, -0.02128881f, -0.12819293f, 
    0.12874736f, -0.00337408f, 0.01211942f, 0.06244125f, 0.03570459f, -0.13492881f, -0.05607376f, -0.39806888f, 
    0.10585461f, -0.02493370f, -0.00008442f, 0.09999535f, 0.14090472f, 0.00117115f, -0.41952145f, 0.02427338f, 
    -0.03768683f, 0.03984166f, 0.02031044f, 0.02640898f, 0.01316345f, 0.07137381f, -0.07465646f, -0.23185076f, 
    -0.21578954f, -0.06532465f, 0.04540538f, 0.08533588f, 0.09698477f, 0.04807382f, -0.01371734f, 0.00252957f, 
    0.09595104f, -0.39249864f, 0.10514172f, -0.14480324f, 0.11162099f, -0.12206407f, 0.01470484f, -0.05570262f, 
    -0.11646295f, -0.01284827f, 0.02369432f, -0.23446098f, -0.22208282f, -0.05408185f, 0.00227767f, 0.12532748f, 
    0.15683660f, -0.02603166f, -0.11055251f, -0.24566662f, -0.18257326f, -0.11500560f, 0.21285303f, 0.07950616f, 
    -0.26363853f, -0.02618240f, -0.17876558f, 0.17562154f, -0.04049115f, -0.19763403f, -0.17493364f, -0.02684183f, 
    -0.03326734f, -0.01309407f, 0.00479160f, -0.08797205f, 0.22946002f, -0.00903702f, 0.03244222f, -0.03394127f, 
    0.05883897f, 0.10738462f, -0.13322070f, -0.00576288f, 0.08303337f, 0.42877501f, 0.08734094f, -0.10310281f, 
    0.15747871f, -0.03479475f, 0.11023465f, -0.06003577f, 0.04138460f, -0.03530796f, -0.24777500f, -0.13262314f, 
    0.05230735f, -0.03325186f, 0.04610052f, 0.14796093f, -0.04829202f, 0.07302160f, 0.08981667f, 0.42272997f, 
    0.08941595f, 0.13783734f, -0.14433429f, -0.23555920f, 0.09081160f, 0.09464559f, 0.00215623f, -0.07617881f, 
    0.26844847f, 0.01365021f, -0.28503641f, 0.03054005f, -0.05276898f, 0.00617557f, 0.03578826f, -0.00213396f, 
    -0.04503020f, 0.13617890f, 0.14762469f, 0.18578400f, -0.08800113f, -0.09472770f, 0.09167519f, -0.04889465f, 
    -0.11559111f, 0.02585612f, 0.10192592f, -0.23823896f, -0.30578038f, 0.00802288f, 0.16845797f, 0.27295581f, 
    -0.15981340f, -0.01904298f, -0.21364667f, 0.07050206f, -0.05405142f, -0.19093235f, -0.17329030f, -0.09063809f, 
    -0.03391819f, 0.06514861f, 0.14345235f, -0.06533182f, 0.17520402f, 0.05062926f, 0.00372597f, -0.13850057f, 
    -0.02976716f, -0.05381839f, -0.02898234f, -0.00260899f, 0.15483515f, -0.29187503f, -0.14295191f, -0.12688628f, 
    -0.00797634f, 0.17052299f, 0.05569623f, -0.04471552f, -0.14813392f, 0.01115806f, 0.33802670f, 0.10323448f, 
    0.04857564f, -0.07725455f, -0.09545314f, 0.12294990f, -0.16587548f, 0.07209492f, -0.01283154f, 0.15033607f, 
    0.18963370f, -0.15027259f, -0.13717978f, 0.11539057f, 0.12412795f, -0.08031110f, 0.09855229f, -0.08173034f, 
    -0.25760841f, -0.65595549f, 0.08660868f, 0.07080708f, -0.03997097f, -0.21713032f, 0.06891570f, 0.05457805f, 
    0.01962709f, 0.12052120f, -0.14240682f, -0.21275946f, 0.11015502f, 0.00450344f, -0.12449436f, 0.22463241f, 
    0.24135217f, 0.04465195f, 0.17334038f, -0.15761615f, -0.08107166f, 0.24777919f, 0.11175352f, 0.02212388f, 
    0.13910563f, 0.10139584f, -0.01886428f, 0.09131507f, 0.24263504f, 0.00257083f, -0.05304957f, 0.08225331f, 
    0.12597221f, 0.13448906f, -0.00527423f, -0.15214886f, -0.06142734f, 0.21018775f, -0.10567879f, -0.21448992f, 
    0.09498286f, -0.03622484f, -0.15441447f, -0.02399302f, -0.09804189f, 0.25615370f, 0.01689327f, 0.16698222f, 
    0.04319615f, -0.06161216f, -0.13608028f, -0.00825233f, -0.19861083f, -0.02568589f, 0.05286080f, -0.02012500f, 
    -0.32792670f, 0.20064530f, 0.04288352f, 0.18931104f, -0.07629535f, 0.01243069f, 0.15208068f, -0.33557650f, 
    -0.37801072f, 0.12320371f, 0.05094848f, -0.14756650f, -0.07393283f, -0.10357629f, -0.04196050f, 0.08380356f, 
    -0.16113660f, -0.08046232f, -0.09888470f, -0.00802247f, 0.08587383f, 0.35337389f, -0.00289468f, 0.03643560f, 
    0.01168965f, 0.09429654f, 0.11302570f, 0.11286920f, 0.05136418f, -0.08683605f, 0.00169057f, 0.08962625f, 
    0.12001010f, 0.38953015f, -0.11630844f, -0.14180046f, -0.15674996f, 0.17729172f, -0.01999192f, 0.05670433f, 
    0.19571601f, -0.21748768f, -0.03670072f, 0.18640301f, -0.09666511f, -0.02642151f, -0.01033540f, -0.03053577f, 
    -0.32273224f, 0.22349258f, -0.15771963f, -0.19051099f, -0.02467215f, -0.02741532f, 0.00930067f, 0.00617013f, 
    -0.02098772f, 0.00685229f, 0.01828826f, -0.09715790f, -0.13353181f, -0.41958874f, -0.02192908f, 0.06073784f, 
    0.03517801f, 0.12083668f, -0.00353167f, -0.14192833f, 0.07710542f, 0.10589850f, -0.06502077f, -0.03674334f, 
    0.02907301f, 0.11948638f, 0.02738900f, 0.05200706f, -0.16383103f, 0.26201358f, 0.07837944f, -0.15950203f, 
    0.01242036f, -0.00011336f, 0.11553147f, 0.15696396f, 0.21458408f, 0.03893789f, 0.06910761f, -0.10100422f, 
    -0.12614192f, 0.23322541f, 0.02320971f, 0.06428795f, -0.00832919f, -0.00660795f, 0.13205746f, 0.01841909f, 
    -0.04209537f, 0.14574488f, 0.04445463f, 0.19617014f, -0.01354242f, -0.04016154f, -0.32969391f, 0.00980602f, 
    -0.00973758f, 0.03250008f, 0.08572714f, 0.13550887f, -0.15734844f, 0.18828413f, -0.22578436f, 0.06773871f, 
    -0.03129983f, -0.14162958f, -0.21898930f, -0.36888498f, 0.42905626f, 0.02282771f, -0.01394863f, -0.06000481f, 
    0.22620858f, -0.10338293f, 0.02330732f, -0.04358314f, 0.22785506f, 0.15292412f, 0.06720423f, -0.02048183f, 
    -0.11603281f, -0.13207930f, 0.02299609f, 0.11828332f, 0.07760127f, -0.07087267f, 0.14100997f, 0.07811455f, 
    0.17471816f, -0.24753413f, -0.02575725f, -0.01361952f, 0.17116030f, -0.00305911f, 0.15848149f, -0.12218778f, 
    -0.12612978f, 0.16817862f, 0.10645783f, 0.17484497f, -0.24648748f, -0.15084191f, -0.27331793f, -0.06521847f, 
    -0.11526033f, -0.14742017f, 0.08391115f, -0.01425541f, 0.04386849f, 0.14171860f, -0.02191081f, 0.03246731f, 
    -0.07651986f, -0.03191992f, -0.04799139f, 0.03745326f, 0.01040710f, 0.04359597f, 0.06691337f, -0.04875368f, 
    0.06705794f, -0.04578604f, -0.01057359f, -0.09754156f, 0.00181698f, 0.06999491f, 0.06098126f, -0.08947379f, 
    0.02658625f, -0.00888186f, -0.03677449f, 0.05760726f, -0.06528822f, -0.10255699f, -0.04657216f, 0.00859351f, 
    -0.11765884f, 0.06824902f, 0.02951089f, -0.01602555f, -0.00441552f, -0.02175658f, -0.04831804f, 0.04079213f, 
    -0.01860134f, -0.02741913f, 0.05969781f, -0.03419519f, -0.05603021f, 0.04862273f, 0.02213862f, -0.08320675f, 
    -0.01356117f, 0.06745236f, -0.02542585f, 0.00360871f, -0.11273099f, -0.03575232f, -0.05678039f, -0.05857469f, 
    -0.09764020f, -0.11779562f, 0.01420085f, -0.03509973f, 0.03481700f, 0.07123334f, -0.01769679f, -0.09720929f, 
    -0.05764288f, -0.09559720f, -0.08908094f, -0.06014324f, 0.02392190f, 0.05926192f, 0.04978626f, -0.07998121f, 
    0.03176401f, 0.06538178f, 0.00112757f, -0.01829685f, 0.00384977f, -0.10414074f, -0.04817538f, -0.08732652f, 
    0.01082054f, 0.04689436f, 0.06993407f, -0.02586046f, 0.07142743f, 0.05077577f, 0.04054223f, 0.06385023f, 
    -0.07432464f, 0.03610624f, -0.07411228f, 0.03459750f, 0.00146365f, -0.00805909f, 0.04378815f, -0.04790980f, 
    -0.05496396f, 0.02816924f, -0.08496091f, -0.01834157f, -0.08042903f, -0.06335848f, -0.08333151f, -0.09026656f, 
    -0.04882567f, 0.05030579f, 0.04945539f, -0.03995587f, -0.05233475f, 0.02103010f, 0.03618778f, 0.07238054f, 
    0.09185390f, 0.05153026f, 0.02036448f, -0.08151864f, -0.01961516f, -0.04913457f, -0.03994163f, 0.04555219f, 
    0.01249183f, -0.07973841f, 0.03023337f, -0.10404035f, -0.06460502f, -0.03881582f, 0.01988468f, -0.00601130f, 
    0.01812229f, 0.01978973f, 0.02110029f, -0.04705645f, -0.08569059f, 0.01225999f, -0.07525910f, -0.04887460f, 
    -0.10855935f, -0.02140043f, 0.01353271f, 0.06443391f, -0.11168013f, -0.04555402f, 0.05594192f, -0.08169078f, 
    -0.01383394f, -0.07755397f, 0.01961282f, -0.07198809f, -0.00117407f, 0.02547482f, -0.09312462f, -0.10707107f, 
    -0.16414736f, 0.20481083f, -0.18301594f, -0.21258222f, 0.09120125f, -0.19566667f, -0.04099583f, -0.02743880f, 
    -0.04092146f, 0.00031455f, 0.04707471f, -0.11197411f, -0.00059691f, -0.05204613f, 0.03935144f, 0.00800176f, 
    0.12069950f, -0.11554379f, 0.00932795f, 0.04563642f, 0.10032431f, 0.11905810f, -0.05729872f, -0.07328513f, 
    0.00828345f, -0.18113209f, 0.05731369f, 0.33663777f, 0.26821271f, 0.21404132f, -0.05413250f, 0.05561834f, 
    0.04207040f, 0.15147752f, 0.11025595f, -0.06833990f, 0.13218530f, -0.13355160f, 0.20129862f, -0.09410734f, 
    0.07181239f, 0.13909385f, 0.22284193f, -0.04045326f, 0.12660046f, 0.07024536f, -0.02868599f, -0.08006193f, 
    -0.20512329f, -0.02533406f, -0.07364955f, -0.02286842f, 0.08424805f, -0.02606165f, -0.25263900f, 0.06890279f, 
    -0.06357783f, -0.00760143f, 0.10267101f, 0.20412643f, -0.10644215f, -0.12040336f, 0.17554873f, -0.07787846f, 
    -0.48231801f, 0.05028050f, 0.02717660f, 0.11829406f, -0.03462680f, 0.02258070f, 0.04449572f, -0.07688536f, 
    0.20526759f, -0.27711013f, -0.00718991f, -0.08989306f, 0.11753560f, -0.03807059f, 0.10708261f, 0.02579681f, 
    -0.20471127f, 0.00594774f, -0.07992058f, -0.15205638f, -0.15795049f, 0.20804700f, 0.27380416f, 0.11022797f, 
    -0.03085038f, -0.18189201f, -0.27204451f, -0.07757770f, 0.00638577f, -0.11606471f, 0.35822782f, 0.01767694f, 
    -0.11922674f, -0.14145328f, -0.05743531f, 0.40199572f, -0.36845148f, 0.11718810f, -0.14100587f, 0.05966135f, 
    -0.16906191f, -0.21002741f, -0.17586040f, 0.06390986f, 0.16731377f, 0.15953457f, 0.12347119f, 0.19577833f, 
    -0.13855259f, 0.11093017f, 0.01012225f, -0.04501988f, -0.14117733f, 0.32521385f, -0.03752357f, 0.12094907f, 
    -0.20162523f, -0.07504313f, -0.07404794f, -0.03814444f, 0.10839548f, -0.00713029f, -0.22381286f, -0.16211063f, 
    0.16166364f, 0.10784759f, 0.08686966f, -0.16849504f, 0.07334911f, 0.13552088f, 0.10844018f, 0.26017821f, 
    -0.14543031f, 0.24170454f, 0.11781502f, -0.35921603f, -0.18325429f, -0.03275640f, 0.06069250f, 0.00048690f, 
    0.04575780f, -0.05736569f, 0.18040074f, 0.09337475f, -0.03717567f, -0.38558900f, 0.02065547f, 0.15939678f, 
    0.08649119f, -0.31730250f, -0.07425169f, 0.34491348f, 0.07510343f, 0.16873303f, 0.04164779f, -0.07642706f, 
    0.01231375f, -0.26359281f, 0.08374435f, 0.06989554f, 0.18895139f, -0.09647841f, -0.13197215f, 0.02490795f, 
    0.01248265f, -0.01435121f, 0.18371898f, -0.10709079f, -0.10723440f, -0.05588848f, -0.06902485f, 0.06766449f, 
    0.11438990f, -0.08041172f, -0.13923931f, 0.15022318f, -0.03772610f, -0.13657367f, 0.15905394f, -0.16553539f, 
    -0.13678400f, 0.07526036f, -0.05143442f, 0.05156126f, 0.18053871f, 0.38926315f, 0.06242463f, -0.08027965f, 
    -0.10993870f, -0.21239994f, 0.17233817f, 0.11315554f, -0.14195974f, -0.17630580f, -0.32500806f, 0.02735019f, 
    0.00360385f, -0.07596720f, -0.17850389f, 0.16883601f, 0.07280889f, 0.16737935f, 0.10637549f, -0.06640200f, 
    -0.00901951f, 0.11891533f, 0.03665020f, -0.05104915f, 0.06367395f, 0.01607359f, 0.08607711f, 0.13434820f, 
    0.14001738f, -0.20670849f, 0.04924252f, 0.08670422f, -0.07562569f, 0.09673869f, 0.08337481f, 0.01631905f, 
    0.05463251f, -0.14505300f, -0.09347227f, 0.07324017f, 0.00292545f, 0.01686412f, 0.19296685f, -0.03792918f, 
    -0.17067298f, -0.02712361f, 0.14129463f, -0.12852664f, -0.01207958f, 0.08636089f, -0.00375750f, -0.05011527f, 
    0.05220300f, -0.06885404f, -0.02591153f, -0.07405239f, -0.22548136f, 0.30154058f, -0.05063403f, 0.17125005f, 
    -0.15962036f, 0.09461813f, 0.01144686f, -0.02163262f, -0.07995789f, 0.09383786f, -0.15563472f, -0.15756270f, 
    0.19712207f, 0.12855603f, 0.08598317f, -0.03553280f, -0.07142792f, -0.19729719f, 0.01823302f, -0.01840870f, 
    -0.17215179f, 0.15382695f, -0.11584568f, 0.10287001f, -0.18029319f, -0.30690533f, 0.13209206f, 0.04215636f, 
    0.00521500f, -0.07541765f, 0.07125134f, -0.31470799f, 0.03468044f, -0.15291193f, 0.09066087f, 0.23957567f, 
    -0.06510901f, 0.04540056f, 0.06667366f, -0.12022971f, -0.05989777f, -0.09659554f, 0.12988913f, 0.01983772f, 
    -0.13643242f, -0.19184476f, 0.10671333f, -0.04673795f, 0.04157110f, -0.36812675f, 0.14945184f, 0.13552293f, 
    0.02212356f, -0.33263344f, 0.03532193f, -0.11225876f, -0.05575364f, 0.14798129f, -0.06622223f, -0.00301603f, 
    -0.03915678f, -0.10114855f, -0.15991715f, 0.19772585f, 0.12455482f, 0.28462711f, -0.15195239f, -0.15875547f, 
    -0.06815140f, -0.14934775f, 0.25999740f, 0.13178912f, 0.01784040f, -0.35159966f, 0.17070861f, 0.00736504f, 
    0.16038485f, -0.14045978f, 0.10241249f, 0.01143914f, 0.31967312f, -0.01406915f, 0.13027367f, 0.10871661f, 
    0.01250060f, -0.01418924f, 0.07995000f, -0.08002452f, 0.35886630f, 0.16498770f, 0.26818469f, 0.11718177f, 
    0.02711192f, 0.06031574f, -0.17427637f, 0.02606121f, 0.14176883f, 0.14763419f, 0.21551749f, 0.30384660f, 
    0.13659230f, 0.00231413f, -0.01548005f, 0.14672308f, 0.04671613f, 0.05935844f, -0.11472123f, 0.23863758f, 
    0.21386884f, 0.24894036f, -0.02052974f, -0.07381056f, 0.08217083f, -0.08134779f, 0.13766162f, 0.30672944f, 
    0.08292786f, -0.13838398f, 0.03183046f, 0.13968073f, 0.01581750f, 0.31695896f, -0.10350865f, 0.05859688f, 
    0.13809289f, -0.04804122f, 0.23209181f, 0.01045238f, 0.09751947f, -0.16926344f, 0.22684589f, 0.03822776f, 
    0.06122156f, -0.02542525f, 0.18620372f, 0.08935194f, -0.16753726f, 0.03482960f, 0.12397350f, 0.02385074f, 
    -0.01305893f, 0.10637824f, -0.21448661f, 0.30451220f, 0.03499347f, 0.22797894f, 0.01702243f, -0.06300899f, 
    0.02537569f, 0.23387228f, -0.01678749f, -0.24978882f, 0.02067491f, -0.05594661f, -0.27995837f, 0.28763172f, 
    0.03335885f, 0.17757881f, -0.20455448f, -0.16540591f, -0.16644681f, 0.03855786f, -0.14465433f, -0.26914236f, 
    0.12104487f, -0.13550228f, 0.03858831f, -0.15361699f, -0.19950545f, -0.13350874f, 0.05707028f, -0.09441313f, 
    0.03820242f, -0.28207180f, 0.09829061f, -0.30790269f, -0.00081339f, 0.12528124f, -0.25232896f, 0.02016016f, 
    0.14301345f, -0.37901750f, 0.09925073f, 0.14083929f, -0.12570983f, 0.09514640f, 0.19835670f, -0.03664414f, 
    0.19849163f, 0.23137453f, 0.02864220f, 0.21116495f, 0.13389617f, -0.10326101f, 0.18881793f, -0.10309511f, 
    0.11239462f, 0.32585242f, -0.58519012f, -0.06991248f, 0.24420123f, 0.14460315f, 0.06630836f, 0.22796349f, 
    -0.05465728f, -0.24631321f, -0.45149675f, 0.09219152f, 0.13429655f, -0.11570137f, 0.02290887f, 0.29074255f, 
    -0.16666475f, 0.03543133f, -0.15358551f, -0.13162342f, 0.09963423f, -0.00838953f, -0.11908542f, 0.04524882f, 
    0.04093293f, -0.04055607f, 0.00938952f, 0.25047576f, 0.14261726f, -0.08536253f, 0.15820329f, -0.46613079f, 
    -0.39239782f, -0.10941331f, -0.29420131f, 0.09024640f, 0.16145903f, 0.24864705f, -0.18402265f, 0.03850347f, 
    -0.07990861f, -0.02419112f, -0.15637723f, 0.02407475f, -0.08127951f, 0.07626227f, 0.35882711f, -0.08217731f, 
    -0.21046479f, 0.25904325f, 0.33809072f, 0.16643678f, 0.05915654f, 0.04934893f, -0.04247373f, -0.06793364f, 
    0.24029410f, 0.00857760f, -0.03546089f, 0.06538946f, 0.05926044f, -0.18337311f, 0.16610245f, -0.09706140f, 
    -0.21200207f, -0.43198478f, 0.01376913f, 0.08091833f, -0.11261551f, -0.00832698f, -0.09581494f, -0.04968578f, 
    -0.02635359f, -0.21478331f, 0.03651534f, -0.21956988f, 0.27534795f, -0.11945029f, -0.00861690f, -0.10061093f, 
    -0.06081956f, -0.16553974f, 0.55703419f, 0.27376515f, -0.18466316f, 0.11003955f, 0.09832472f, -0.12547888f, 
    0.09934310f, 0.04135930f, 0.13121785f, -0.02462992f, 0.03013815f, -0.39305329f, -0.27935809f, -0.13294521f, 
    -0.15200396f, 0.11999305f, 0.15498187f, -0.09884036f, -0.22559465f, 0.11655182f, -0.17889309f, -0.12371159f, 
    0.10277131f, 0.07499176f, -0.05101219f, 0.12441161f, 0.06395348f, -0.26271921f, 0.05735131f, -0.03769895f, 
    -0.23329236f, 0.07006281f, -0.03967223f, 0.10754534f, 0.03431562f, -0.00658013f, 0.63156664f, 0.30348039f, 
    -0.11831050f, 0.19232093f, -0.07938353f, -0.09699561f, 0.04171636f, 0.09818233f, -0.14080839f, -0.08849855f, 
    -0.07207307f, -0.04397873f, 0.24095429f, -0.06145815f, -0.14799577f, -0.08171208f, 0.03206905f, 0.11130080f, 
    0.17777595f, -0.07645149f, -0.13894370f, 0.01154046f, -0.07555591f, -0.09072561f, 0.01074032f, 0.05805802f, 
    -0.09462005f, -0.17413047f, 0.08286074f, 0.06823913f, -0.10796904f, 0.06695319f, -0.20776184f, -0.11086841f, 
    0.11429966f, -0.19915046f, -0.11871819f, 0.03071822f, 0.14840667f, 0.00822246f, -0.16664530f, 0.09916788f, 
    -0.00649163f, -0.14227934f, 0.14482023f, -0.30721080f, -0.01474995f, 0.13761817f, 0.10609452f, 0.11379232f, 
    0.04116422f, -0.15485342f, 0.08006943f, 0.12123102f, -0.07020494f, -0.16680138f, 0.65015328f, 0.15183629f, 
    0.02919210f, 0.26149440f, -0.09951912f, -0.01704883f, 0.06219448f, -0.04356617f, 0.29355827f, -0.01974597f, 
    0.15865299f, -0.19938433f, 0.07835300f, 0.01386067f, -0.23067521f, 0.02610840f, 0.22198065f, 0.02637592f, 
    -0.12132099f, -0.12564461f, -0.06936587f, -0.01433252f, -0.13579859f, -0.00449836f, -0.02793167f, 0.01219514f, 
    0.06170627f, -0.05681799f, 0.08056802f, -0.00440597f, 0.03043216f, -0.06630876f, -0.04501769f, -0.01603870f, 
    0.15439370f, -0.23318788f, -0.58372033f, 0.08249085f, 0.07563942f, 0.05399753f, 0.25866598f, 0.06386542f, 
    -0.00849015f, 0.29670602f, 0.14595245f, -0.21258427f, -0.26661831f, -0.07175633f, 0.08624023f, 0.05715339f, 
    0.00356685f, -0.10084679f, -0.20861183f, -0.08864190f, -0.12204671f, 0.23598355f, -0.04834205f, -0.19684640f, 
    0.01739316f, 0.10394748f, -0.12673663f, -0.03550776f, 0.08141009f, 0.15149036f, 0.13284549f, 0.12841922f, 
    0.05367501f, 0.04104034f, -0.13445139f, -0.18743289f, 0.07830039f, -0.34784409f, 0.15233535f, 0.02840561f, 
    0.08598649f, 0.02351824f, -0.14104870f, -0.13732342f, 0.09976913f, -0.19044794f, -0.12327918f, -0.14997263f, 
    -0.00305343f, 0.11527827f, -0.04247935f, 0.14653641f, -0.06197815f, -0.10266949f, 0.13000891f, -0.06424769f, 
    -0.07070652f, -0.05958423f, 0.11169511f, -0.00054847f, 0.14409320f, -0.02348043f, 0.18815345f, -0.24622528f, 
    -0.10419296f, 0.46811643f, 0.05982280f, -0.11667258f, 0.02018933f, 0.13509072f, 0.16349559f, -0.10431623f, 
    -0.19719796f, -0.03168910f, -0.45677131f, 0.15073150f, 0.05050642f, 0.11114588f, 0.10426687f, 0.03048063f, 
    0.03657741f, 0.36025119f, 0.24170391f, -0.10415801f, 0.15644099f, 0.16545276f, -0.02197487f, -0.02319084f, 
    -0.01436391f, -0.14595403f, -0.20785153f, -0.18466513f, 0.05078979f, -0.05737467f, -0.07781731f, 0.06792889f, 
    -0.08106252f, -0.22988795f, 0.03172190f, -0.10683195f, -0.08388262f, 0.10000866f, -0.02243322f, -0.18420446f, 
    -0.15502843f, 0.03403991f, 0.07384527f, 0.04043601f, -0.29499602f, -0.00378747f, 0.35087621f, 0.26894510f, 
    0.10623367f, -0.04393524f, -0.06339873f, -0.15979326f, -0.01242450f, -0.70815903f, 0.06456338f, 0.02166579f, 
    0.09596003f, 0.01290539f, -0.02858211f, 0.02175050f, -0.10400856f, -0.02313125f, -0.44503748f, 0.19485523f, 
    -0.02514156f, 0.40118936f, -0.04347667f, -0.13938731f, -0.01944196f, 0.00145904f, 0.12794746f, -0.09879126f, 
    0.05186576f, 0.09797548f, 0.31821775f, 0.11684638f, -0.00939618f, -0.00544852f, 0.21890000f, 0.00477493f, 
    0.05665329f, -0.38382202f, -0.21018967f, 0.02598872f, -0.10430678f, -0.06147087f, 0.03060238f, -0.04289458f, 
    0.14625905f, -0.36246186f, 0.23652054f, 0.04868640f, -0.01468090f, 0.03015292f, -0.19177285f, 0.17959650f, 
    0.05229122f, 0.23129927f, -0.26345450f, 0.10978737f, -0.18890530f, 0.15959595f, -0.07483849f, 0.01081933f, 
    0.01048681f, 0.11026687f, 0.04764957f, -0.53475475f, -0.01886981f, 0.37195620f, -0.00880772f, -0.08025510f, 
    -0.05645200f, -0.03871136f, 0.02818716f, 0.01515939f, 0.23019373f, -0.02281686f, -0.04261883f, 0.05984537f, 
    0.05693364f, 0.02079909f, -0.02797672f, 0.16113999f, -0.08922647f, -0.02168677f, -0.23078655f, -0.05736498f, 
    0.09741773f, -0.15283073f, 0.13663818f, -0.10454461f, -0.13578556f, 0.05132332f, 0.21844570f, 0.01265823f, 
    -0.00680343f, -0.02510419f, -0.04757359f, 0.10681336f, 0.15312564f, 0.04537827f, 0.22976236f, 0.00866697f, 
    -0.22258393f, 0.03506742f, -0.07231219f, -0.04497147f, 0.04822842f, -0.03836686f, -0.03977174f, -0.03890991f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.14017823f, 0.05007887f, 0.04951809f, -0.10531053f, 0.23418178f, 0.16437835f, 0.12015346f, 0.03532772f, 
    0.17197347f, 0.00734097f, 0.01358978f, -0.11400262f, -0.03122808f, 0.13036790f, -0.04910520f, 0.22453946f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.39989245f, -0.32413003f, -0.12525900f, -0.20744452f, 0.03955753f, 0.27005655f, -0.56480783f, -0.36540794f, 
    -0.27061504f, -0.01577701f, 0.09665850f, 0.10236043f, 0.28482723f, 0.19547194f, 0.12463222f, 0.40565696f, 
    -0.24266656f, -0.13567276f, -0.10316834f, -0.22174354f, 0.05726057f, -0.19222218f, -0.01976374f, -0.11568122f, 
    0.19003133f, 0.05060735f, -0.04544508f, 0.03251248f, -0.11102794f, -0.22840677f, 0.10518502f, 0.01608659f, 
    0.14611354f, -0.04366918f, -0.11893572f, 0.22204114f, -0.40385544f, 0.43794894f, 0.09402235f, -0.65551645f, 
    -0.21477765f, -0.06122951f, 0.17616846f, -0.00149779f, 0.39122373f, 0.08812048f, 0.31465131f, -0.27699819f, 
    -0.22554733f, 0.22785869f, 0.00676112f, 0.20897412f, -0.19754755f, -0.17518947f, -0.04653966f, 0.68087727f, 
    -0.34295410f, -0.23090285f, 0.16185810f, -0.32089949f, 0.31479722f, 0.21509822f, 0.14910203f, -0.56792140f, 
    -0.42678896f, 0.05372095f, 0.07644150f, -0.53823680f, 0.33382493f, -0.30773026f, 0.22349891f, 0.14448582f, 
    -0.08279393f, -0.14516754f, -0.05380611f, 0.10367321f, 0.39622590f, 0.26182145f, 0.20182744f, 0.27612597f, 
    0.31937373f, 0.23355517f, 0.19326620f, -0.35875759f, 0.20121384f, -0.06084467f, -0.38276568f, -0.71983910f, 
    -0.37066197f, 0.23226792f, 0.08453064f, 0.19433615f, 0.07499106f, 0.15688561f, 0.04257508f, 0.49169126f, 
    0.05544794f, 0.15543547f, 0.08956593f, -0.47214037f, -0.34335911f, -0.02984085f, 0.28972664f, 0.32929310f, 
    -0.41752604f, 0.13849579f, -0.03220294f, 0.54973340f, 0.18880665f, 0.42968819f, -0.31679025f, 0.04438497f, 
    -0.02417358f, -0.10621719f, -0.23449308f, 0.23114568f, 0.06435366f, 0.46461311f, 0.38962191f, 0.65423930f, 
    -0.35112232f, 0.15205617f, 0.17338355f, 0.30782107f, 0.36946490f, 0.02485533f, -0.33314967f, -0.66644204f, 
    -0.41950354f, 0.26116931f, 0.05427338f, -0.44053251f, -0.09749243f, 0.26176050f, 0.31977069f, 0.03950402f, 
    0.23767832f, 0.24264915f, -0.08233701f, 0.08354557f, -0.14841415f, -0.25496885f, 0.21932806f, -0.23898491f, 
    -0.21614082f, -0.18167487f, -0.08635682f, -0.00213526f, -0.04776639f, 0.07665713f, -0.14417136f, 0.15648673f, 
    -0.20575008f, -0.03244480f, -0.20328397f, 0.09962542f, -0.24469477f, 0.15047000f, 0.13535847f, 0.22302359f, 
    0.08677457f, 0.16368786f, -0.20933901f, -0.56734324f, 0.29795778f, 0.43567091f, 0.42671725f, 0.15205742f, 
    -0.07700799f, -0.25003108f, 0.35169879f, 0.09018087f, 0.14483184f, -0.44999954f, -0.28262037f, -0.35759136f, 
    0.53632897f, 0.41696063f, -0.08457320f, 0.17904900f, -0.07268545f, 0.24206375f, -0.23944332f, -0.06970546f, 
    0.18075310f, 0.18085334f, -0.35786036f, 0.28510782f, 0.20155641f, -0.01752761f, -0.54780853f, -0.32871425f, 
    -0.36715981f, 0.34509858f, 0.12359264f, 0.13924003f, -0.29909432f, -0.05429827f, -0.17772475f, -0.52206361f, 
    -0.25423852f, 0.12914354f, 0.37473956f, 0.38305375f, 0.07647692f, 0.07653224f, 0.70629436f, 0.26239815f, 
    -0.12261382f, -0.04374900f, 0.16456524f, -0.15029055f, 0.20025262f, -0.12201366f, -0.11995992f, 0.23493505f, 
    -0.20076832f, -0.20002553f, -0.13134986f, 0.01401338f, -0.21589789f, -0.15917227f, 0.13167956f, -0.20220858f, 
    -0.24351764f, 0.04878472f, -0.20340237f, -0.09799568f, 0.11235420f, -0.24740764f, -0.13625510f, 0.06768018f, 
    0.20390329f, 0.10895666f, -0.26992252f, 0.09563021f, -0.22006877f, -0.21222979f, 0.08648965f, -0.18517400f, 
    -0.04567032f, -0.10223801f, -0.07686695f, -0.18291688f, -0.01260040f, -0.21196049f, -0.24422120f, 0.23608997f, 
    0.17270610f, -0.05533653f, 0.00165852f, -0.08049675f, -0.23389679f, -0.07998360f, 0.08146583f, -0.09071179f, 
    -0.22478741f, -0.05077728f, -0.22605196f, 0.03147372f, 0.16386449f, 0.02535570f, 0.10913848f, 0.14453533f, 
    -0.23099442f, -0.15446737f, -0.13129152f, -0.23594244f, 0.03599070f, -0.22937456f, -0.23153509f, -0.06122081f, 
    0.22442311f, -0.16688417f, -0.01476067f, 0.55191845f, 0.25850695f, 0.08107106f, 0.33420494f, -0.18965498f, 
    0.48940814f, 0.05756426f, 0.09764070f, -0.44066843f, 0.06296466f, -0.05871673f, -0.40748557f, 0.05079430f, 
    0.07931075f, -0.02484938f, 0.21161649f, -0.26926377f, -0.08122490f, 0.05941529f, -0.17069328f, 0.07364138f, 
    -0.12583332f, -0.18416665f, -0.20465434f, -0.20025203f, -0.16134948f, -0.07089009f, 0.18737473f, 0.15788329f, 
    0.34735176f, -0.02823095f, -0.01447141f, -0.10478187f, 0.25290504f, -0.33734271f, -0.13803917f, -0.57635206f, 
    -0.25737444f, -0.14870411f, 0.42804974f, -0.09635134f, 0.42383310f, -0.23420411f, 0.26024035f, -0.43805823f, 
    -0.37829480f, -0.43390760f, -0.11558283f, 0.32064119f, 0.36252761f, 0.02918537f, 0.39223203f, 0.43163711f, 
    0.00122214f, 0.24514954f, 0.38924527f, -0.36980307f, 0.21025306f, -0.09529091f, 0.24675418f, 0.29544583f, 
    0.26816148f, -0.30407614f, 0.00022874f, -0.01066133f, -0.36507958f, 0.18249515f, 0.21160066f, -0.13543102f, 
    -0.00401245f, -0.03698121f, 0.36392426f, 0.11893346f, 0.02539693f, 0.50706583f, 0.17700754f, -0.08850473f, 
    -0.23332247f, -0.28490523f, 0.05566893f, 0.10541659f, -0.01138494f, 0.20080601f, -0.15544863f, 0.01194988f, 
    -0.05033154f, 0.09289548f, 0.03745367f, -0.15688406f, -0.18502221f, -0.09999811f, 0.24156573f, 0.00769377f, 
    -0.21399316f, -0.01045738f, 0.05525360f, -0.36701858f, 0.33168060f, -0.11421312f, 0.57771027f, -0.00620379f, 
    -0.29918736f, -0.16327959f, 0.24514464f, 0.46502209f, 0.16758698f, 0.31908286f, -0.15303628f, -0.17710859f, 
    -0.07074170f, 0.00360337f, -0.22300434f, -0.33864513f, 0.41120550f, -0.56184620f, -0.02166716f, -0.22971651f, 
    -0.01448961f, -0.13428637f, 0.32045802f, 0.31920427f, 0.13786076f, 0.36991617f, 0.30615747f, 0.15433465f, 
    0.12378047f, 0.15345310f, -0.18413854f, 0.29234987f, 0.20968167f, 0.22431375f, -0.34893212f, 0.01316814f, 
    0.36152127f, 0.28902853f, -0.16969781f, -0.35405329f, -0.17926033f, -0.10681523f, 0.03534408f, 0.55477262f, 
    -0.40420729f, 0.20702109f, 0.14881936f, -0.67627376f, 0.14246079f, 0.35762209f, 0.45440727f, 0.44000652f, 
    0.38273063f, 0.09724076f, -0.42680895f, -0.01873275f, 0.00007334f, 0.27259642f, 0.11821747f, 0.76265711f, 
    -0.15257664f, 0.35353115f, 0.05721357f, 0.19672807f, -0.26243338f, 0.25782016f, -0.18011685f, -0.06817108f, 
    -0.05875775f, -0.07863741f, 0.19693844f, -0.67257816f, 0.00266627f, 0.07179087f, -0.77996051f, -0.06022665f, 
    0.32710469f, -0.42344278f, -0.13670966f, 0.23538694f, 0.03801401f, 0.28719148f, -0.35971433f, -0.56532246f, 
    -0.17409740f, 0.04399006f, 0.14409375f, 0.56770229f, 0.34091666f, 0.22550149f, 0.24062073f, -0.24098520f, 
    0.11405260f, 0.17562130f, -0.04612903f, 0.55450892f, 0.26140746f, -0.35260618f, 0.18386853f, 0.80133384f, 
    0.45194319f, 0.06421072f, -0.15366109f, -0.10031440f, -0.10131575f, 0.35521361f, -0.16055517f, 0.39960518f, 
    -0.00254521f, 0.46118435f, -0.20097436f, 0.14844474f, 0.12618721f, -0.43380690f, -0.47221169f, -0.26979354f, 
    -0.15867124f, 0.21389492f, -0.17445113f, 0.19592416f, 0.35368091f, 0.13649884f, 0.43251494f, 0.12150998f, 
    -0.29595318f, 0.45247778f, 0.20097572f, -0.31514564f, 0.49653623f, -0.24581251f, 0.13100466f, -0.31277737f, 
    -0.15859443f, 0.15165432f, -0.12245022f, 0.05674871f, 0.25354895f, -0.23485413f, 0.25103951f, 0.06719986f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.17422679f, -0.24225499f, 0.06113760f, 0.46380115f, 0.52528286f, -0.10524524f, 0.28728166f, 0.15292655f, 
    0.27798864f, -0.04418736f, -0.03934574f, 0.09304854f, -0.15832934f, 0.14623222f, -0.21643145f, 0.01001157f, 
    -0.33616683f, 0.28355572f, -0.07154892f, -0.14179543f, 0.08812609f, -0.27798459f, -0.11207779f, 0.28562987f, 
    -0.28255826f, 0.19587398f, 0.91048878f, 0.00467530f, 0.23498252f, 0.42932090f, 0.14305542f, 0.08502589f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.00775736f, -0.05329076f, 0.13509911f, 0.43515310f, 0.09725252f, 0.03664633f, 0.27617320f, -0.00052018f, 
    -0.31528851f, 0.13160150f, -0.28968012f, -0.27982250f, 0.51985282f, -0.09910665f, 0.06379549f, 0.07907888f, 
    -0.20322183f, 0.02905102f, 0.07101418f, 0.07699278f, 0.44493541f, 0.68086016f, -0.14203811f, -0.00120142f, 
    0.33760422f, -0.11390111f, -0.03468667f, -0.18323430f, 0.24531828f, 0.05125786f, -0.04390937f, -0.32559809f, 
    0.34725356f, 0.03994587f, 0.45729336f, 0.29349670f, -0.26921844f, 0.38184506f, 0.33020672f, 0.20670381f, 
    -0.29876417f, -0.03018618f, 0.25171968f, 0.04738605f, 0.84281480f, -0.16334039f, 0.00927496f, 0.11099063f, 
    -0.11862434f, -0.10835198f, -0.12542334f, 0.17528734f, -0.19564876f, 0.51959783f, 0.08043100f, -0.14177917f, 
    -0.15742105f, -0.18808085f, -0.43927175f, 0.33732656f, 0.25569782f, -0.06691428f, -0.05813790f, -0.14440143f, 
    -0.00020562f, -0.01144934f, 0.10457741f, 0.57402503f, 0.20747371f, 0.01937619f, 0.20732181f, -0.08009567f, 
    -0.05317425f, 0.16411433f, -0.53362840f, 0.00347395f, 0.56516391f, -0.04434717f, -0.11497217f, -0.06296363f, 
    -0.04467427f, 0.02013185f, 0.08533873f, -0.28600311f, -0.03919096f, -0.06488427f, -0.14729354f, -0.33929932f, 
    0.10288837f, 0.21242245f, -0.08486099f, -0.47352621f, 0.04681430f, 0.29652265f, 0.68985724f, 0.01414490f, 
    0.49605531f, -0.02024000f, 0.24782622f, 0.17083305f, 0.07876883f, -0.10801029f, -0.22222000f, -0.06201024f, 
    -0.11774416f, 0.13165183f, -0.26449475f, 0.08119151f, -0.08219465f, 0.07415310f, 0.10767508f, -0.12642193f, 
    0.00455147f, 0.29464799f, -0.08731289f, -0.01617214f, -0.00936063f, 0.10446190f, -0.10924466f, -0.38304672f, 
    -0.16557583f, 0.19113520f, 0.18237741f, 0.55446851f, 0.40905300f, 0.22938879f, 0.09451320f, -0.21413390f, 
    0.05778553f, -0.00400749f, 0.22880241f, 0.11556413f, 0.13607901f, -0.56418520f, -0.04416886f, 0.19796616f, 
    0.17611541f, 0.05568024f, 0.24488947f, -0.16746308f, 0.06095245f, -0.03996600f, 0.15331821f, -0.02626269f, 
    0.05018825f, -0.01088691f, 0.16754574f, -0.15903904f, 0.33361730f, 0.24411604f, 0.15333118f, 0.17755406f, 
    0.01501634f, -0.13512963f, 0.29243663f, -0.27230668f, 0.19845933f, -0.13790040f, -0.33487812f, 0.02238553f, 
    0.02687735f, 0.04619393f, -0.09580943f, 0.05139195f, 0.03654598f, -0.02981226f, -0.07297100f, -0.07956456f, 
    -0.17000784f, 0.09952367f, -0.00112434f, -0.00789806f, 0.05442461f, 0.08763655f, -0.09057181f, 0.17239328f, 
    0.11257630f, -0.13945962f, -0.12552358f, -0.14759715f, 0.01230618f, -0.14730188f, 0.05001272f, -0.06530795f, 
    -0.01696568f, 0.10835524f, -0.08572026f, -0.13344131f, -0.04777737f, 0.07515087f, -0.07513388f, -0.10375248f, 
    -0.13305134f, -0.18065074f, -0.39610615f, -0.25860193f, 0.04231104f, -0.48324227f, -0.04001790f, -0.11003354f, 
    -0.07950172f, -0.10839533f, 0.18250805f, -0.14151123f, -0.41279250f, -0.06682766f, 0.07822164f, -0.09323315f, 
    -0.23085772f, 0.34387982f, 0.14171062f, -0.62194836f, 0.36863887f, -0.20432556f, -0.14236382f, -0.00236905f, 
    0.19901267f, 0.30141088f, 0.29793793f, 0.00407247f, -0.05532483f, 0.34671888f, -0.24341425f, 0.01972648f, 
    -0.09390261f, 0.08644559f, -0.25133047f, -0.01846753f, 0.33423609f, 0.12168246f, 0.17403467f, 0.02509787f, 
    -0.02982050f, -0.07619539f, 0.18500406f, -0.18072796f, 0.65079421f, 0.02723723f, 0.14505823f, 0.11522758f, 
    0.11026272f, -0.27751854f, 0.09983880f, 0.11207492f, 0.07416024f, -0.35521483f, -0.05307779f, 0.43952855f, 
    0.13478738f, -0.20711343f, 0.23404144f, -0.51762635f, -0.13855986f, -0.14864744f, 0.53643125f, 0.58461195f, 
    0.06944967f, 0.04835163f, 0.11630452f, 0.26298499f, 0.00996406f, 0.46966574f, 0.62725860f, 0.17945890f, 
    0.00296744f, -0.12557708f, -0.05080597f, 0.37808123f, -0.06891228f, 0.15330286f, -0.01538551f, 0.14017852f, 
    -0.05807993f, -0.06396762f, 0.08219111f, 0.53325987f, -0.43161884f, 0.05745363f, 0.19592124f, 0.19060825f, 
    0.32178062f, -0.37572119f, -0.25989768f, 0.20790531f, 0.36804259f, -0.14042692f, 0.35883319f, 0.08799226f, 
    0.01867901f, -0.17027810f, 0.30512309f, -0.00871884f, 0.00650733f, 0.29443201f, 0.03817296f, 0.03985969f, 
    -0.00311489f, 0.01421345f, -0.17558132f, 0.47797239f, -0.21543230f, 0.10119591f, 0.08157289f, -0.08670549f, 
    0.11525572f, 0.23427965f, 0.09106850f, -0.54147232f, -0.32965872f, 0.11263452f, 0.04235500f, -0.19213450f, 
    -0.31190374f, 0.28736791f, 0.38677323f, 0.48317167f, -0.05358134f, 0.24573092f, 0.07793682f, -0.01612282f, 
    -0.09367578f, -0.03271599f, 0.04193951f, 0.14297487f, 0.06971093f, -0.02318244f, 0.63941163f, 0.12554017f, 
    0.29473075f, -0.09543515f, -0.14571738f, 0.20435597f, -0.51188236f, -0.14068691f, -0.12497336f, -0.10212407f, 
    -0.04615594f, -0.00886816f, -0.00071246f, -0.11444285f, 0.07678689f, 0.30761364f, -0.20343745f, 0.29671946f, 
    -0.16516221f, -0.25291485f, 0.11044748f, 0.23758246f, -0.06135933f, 0.14765148f, -0.27255556f, -0.30141878f, 
    0.26230332f, -0.12858616f, -0.25684491f, -0.03100298f, -0.00580388f, 0.36083344f, 0.54401255f, 0.04720039f, 
    0.32472330f, 0.13491726f, -0.34706184f, -0.39458823f, -0.19021155f, -0.15871376f, -0.14161925f, -0.07461788f, 
    -0.10479644f, 0.16098557f, 0.06307109f, -0.20975395f, 0.35450953f, 0.46955884f, -0.15061583f, 0.34610745f, 
    0.19474469f, -0.19589373f, 0.08454475f, 0.38647336f, -0.12482068f, 0.28327733f, -0.21393286f, -0.36369318f, 
    -0.03516804f, 0.03288523f, 0.03756999f, -0.02422695f, 0.02345006f, 0.10861970f, -0.47019431f, 0.15044279f, 
    -0.01346326f, -0.09775433f, 0.25458547f, 0.24244799f, -0.78445357f, -0.16298966f, -0.15559803f, 0.17668241f, 
    -0.02732343f, 0.40901020f, -0.16389187f, 0.11334386f, 0.25414547f, -0.38494205f, 0.01165735f, -0.06945252f, 
    -0.06105123f, 0.56964236f, 0.06927232f, 0.64495850f, 0.04042248f, 0.31515592f, -0.28007138f, 0.07331174f, 
    -0.21538438f, 0.00714586f, -0.31715354f, 0.32729483f, 0.14141436f, 0.43408173f, 0.41703752f, 0.10166900f, 
    0.14117156f, -0.15035224f, 0.35577321f, 0.15427008f, 0.40041056f, 0.05100390f, -0.11095676f, -0.15687522f, 
    -0.01035748f, -0.25284371f, -0.03957127f, 0.14885582f, -0.39008248f, -0.26548600f, -0.10918412f, 0.22289196f, 
    0.31921330f, -0.22906914f, 0.15872073f, -0.00760615f, -0.24996676f, -0.02571267f, 0.20006107f, 0.40452033f, 
    0.43725264f, 0.01460591f, 0.14923246f, 0.04924048f, -0.06847751f, 0.12691164f, -0.46674198f, 0.21566062f, 
    0.04453605f, -0.06496568f, 0.12729831f, -0.03456254f, 0.11580473f, 0.10983656f, -0.08973627f, 0.12741470f, 
    0.00534822f, 0.04616542f, 0.01717983f, 0.43146005f, 0.37114736f, 0.17665164f, -0.00282669f, -0.26340386f, 
    -0.18486856f, 0.11673825f, -0.55390728f, 1.08573472f, 0.18173343f, -0.17660481f, -0.36504325f, -0.39438507f, 
    -0.01769359f, 0.04986299f, -0.17887509f, 0.07386030f, 0.43396702f, -0.02444138f, -0.30406484f, 0.08641396f, 
    -0.32269961f, -0.07894718f, 0.22457471f, -0.21656196f, 0.04069853f, -0.06384698f, 0.10210466f, -0.16167571f, 
    0.02019035f, -0.11757228f, -0.10686773f, 0.06864442f, 0.29110897f, -0.44026420f, -0.10057242f, 0.16591960f, 
    0.27229083f, 0.09969351f, 0.22189632f, -0.39699602f, -0.11140389f, 0.03039767f, 0.31588131f, 0.52907008f, 
    -0.21158165f, -0.03072000f, -0.40289330f, 0.42298269f, 0.17180395f, -0.90067220f, -0.03497833f, 0.32921559f, 
    0.23023047f, -0.15179646f, 0.18524061f, -0.07564922f, -0.27319717f, 0.00003899f, -0.11485630f, -0.06926166f, 
    -0.04028504f, 0.23916690f, -0.09371859f, -0.49120224f, 0.23654352f, -0.11814255f, -0.12174471f, -0.14525062f, 
    -0.25027171f, 0.03114525f, 0.11525521f, 0.05549125f, -0.15485884f, 0.25247523f, -0.29834253f, 0.12773764f, 
    -0.02736664f, -0.06144384f, -0.23210596f, -0.41275144f, 0.37782124f, 0.33622310f, 0.30800304f, -0.50201970f, 
    -0.40265810f, 0.02563506f, -0.29736084f, -0.34594402f, 0.29028657f, -0.01174652f, 0.10176765f, -0.06922633f, 
    -0.30124009f, -0.30017608f, -0.00310819f, -0.41877827f, -0.03901945f, 0.18510646f, -0.06059522f, -0.12657502f, 
    0.22691865f, 0.26255649f, 0.47021416f, -0.25454181f, -0.51687413f, 0.02427415f, 0.04797778f, 0.14307074f, 
    0.52409691f, -0.20042993f, 0.04662893f, -0.54701203f, -0.01820199f, 0.71161282f, 0.26416269f, 0.18674873f, 
    -0.34694308f, 0.03469403f, -0.09803985f, 0.39997450f, -0.23041633f, 0.09349851f, -0.03284406f, 0.01577005f, 
    -0.11564901f, -0.09546203f, 0.10402300f, 0.32146236f, -0.34577009f, -0.12140005f, 0.19245514f, 0.06698477f, 
    0.00613737f, 0.13323072f, 0.00253808f, -0.54409295f, 0.40735632f, -0.04819458f, 0.37461686f, 0.20805191f, 
    -0.14034234f, -0.02996148f, -0.22166395f, 0.34847778f, 0.31533647f, -0.36867756f, 0.66513783f, 0.26920801f, 
    0.27929369f, 0.08562278f, 0.22707777f, 0.03765427f, -0.24979141f, 0.07149839f, 0.07476083f, 0.06453563f, 
    0.18128708f, 0.04720225f, 0.03148053f, -0.17850113f, 0.00916370f, -0.04445757f, -0.21254717f, 0.64258868f, 
    0.09479365f, -0.39371067f, 0.02999586f, -0.19200306f, 0.01781482f, 0.20128284f, -0.24522021f, 0.18469083f, 
    0.27335134f, 0.18090276f, -0.50774503f, 0.49587590f, 0.24269082f, -0.39129034f, -0.40772155f, 0.04664496f, 
    -0.14150545f, 0.11928001f, -0.23718992f, -0.26166335f, 0.01686468f, -0.17247455f, 0.01819544f, -0.14834946f, 
    0.05041839f, 0.26636001f, -0.04723700f, 0.14030331f, 0.76747566f, 0.14259169f, -0.19221443f, -0.07800400f, 
    0.38397655f, 0.22853412f, -0.10141019f, 0.16355941f, 0.05144470f, 0.32451788f, 0.05268870f, 0.17552350f, 
    0.10280533f, 0.01145833f, 0.07563428f, -0.52524173f, 0.29369465f, 0.14704345f, -0.08825561f, 0.03274979f, 
    0.10671417f, -0.15975283f, 0.46619609f, -0.11739255f, -0.16260539f, 0.01111231f, -0.14611539f, 0.14035134f, 
    -0.14156945f, 0.08935135f, 0.08855984f, 0.22159599f, 0.25546801f, -0.34592485f, -0.01752933f, 0.37996265f, 
    -0.10021675f, 0.06510600f, 0.13664593f, -0.33287805f, 0.14266041f, -0.27663165f, -0.25187060f, 0.51087695f, 
    -0.27008060f, 0.07207168f, -0.03726343f, 0.77256638f, 0.39465401f, -0.37052122f, 0.01253129f, 0.14889002f, 
    0.38468155f, -0.04131608f, 0.10140035f, 0.04165556f, -0.17697214f, -0.00242945f, -0.02365633f, -0.00487070f, 
    0.18803206f, 0.05216824f, 0.08884753f, 0.44389907f, -0.28122723f, -0.55374491f, -0.09393699f, 0.15669547f, 
    0.02040041f, -0.14336941f, 0.10022553f, 0.02910392f, -0.22620749f, 0.25604746f, 0.30076116f, 0.49062482f, 
    0.58682108f, -0.19440322f, 0.31570131f, -0.14785513f, 0.08250611f, 0.45548049f, -0.29078799f, 0.11381337f, 
    -0.38961595f, 0.09257840f, 0.16205212f, 0.25150877f, -0.05390321f, 0.09615254f, -0.05163170f, -0.04181988f, 
    0.09359844f, 0.01919814f, 0.12210768f, 0.40686747f, -0.02391233f, -0.07210612f, 0.15444261f, -0.16265914f, 
    0.21383880f, -0.00396835f, -0.28612185f, -0.11801900f, 0.56320155f, -0.22334746f, 0.12449150f, 0.28551370f, 
    0.03541353f, -0.00995905f, 0.55906463f, 0.13296646f, -0.33309549f, -0.11286107f, -0.26861718f, 0.12666006f, 
    0.24679039f, 0.00429845f, 0.34071898f, 0.22985257f, 0.13765565f, -0.08304191f, -0.17177504f, -0.17095295f, 
    -0.07698112f, 0.08853981f, -0.12934846f, 0.07965881f, -0.08488671f, 0.23585835f, -0.09683187f, -0.50288486f, 
    -0.65673542f, -0.09853116f, 0.10866898f, 0.78491378f, 0.22377603f, -0.35547423f, -0.10537709f, -0.19254890f, 
    0.19259697f, -0.08452237f, 0.15484697f, 0.43319398f, 0.19538260f, -0.18512429f, 0.55634779f, 0.24853073f, 
    0.58965576f, 0.13319661f, 0.01036323f, 0.44802201f, -0.75729632f, 0.08090028f, -0.08891790f, 0.15907972f, 
    -0.02599025f, -0.03255576f, -0.02273229f, -0.33808723f, -0.17238429f, 0.34610230f, 0.02357289f, 0.34927341f, 
    -0.26927295f, -0.20250763f, 0.28061247f, 0.36041769f, 0.34494361f, -0.03517516f, -0.11486340f, -0.21995197f, 
    -0.37567756f, -0.03068640f, -0.19104443f, -0.18780927f, -0.09306557f, -0.17798162f, -0.12555337f, 0.12124506f, 
    0.12236089f, -0.07803421f, 0.02052956f, 0.47696996f, 0.03096376f, -0.15202956f, -0.10727526f, -0.02688281f, 
    -0.02539391f, -0.09808940f, 0.04225679f, -0.16407605f, -0.27396002f, -0.50617832f, 0.13258071f, -0.29765648f, 
    -0.22502330f, 0.54770619f, 0.34981290f, 0.35290086f, -0.40298438f, 0.24276033f, 0.33434740f, 0.27899650f, 
    0.48756206f, -0.07763486f, 0.14955820f, 0.07618025f, 0.14916325f, -0.06252274f, 0.03985088f, 0.20391016f, 
    -0.58559901f, -0.02657305f, -0.19726300f, -0.34798539f, 0.36151847f, 0.11827851f, -0.03012047f, 0.08137895f, 
    0.15128963f, -0.13156500f, 0.06580377f, -0.55122375f, 0.27618822f, 0.49181297f, 0.01200227f, 0.16632572f, 
    -0.01096213f, -0.06898145f, 0.33909133f, -0.19711739f, 0.48324254f, -0.03537271f, -0.14561214f, -0.27761132f, 
    0.08890115f, -0.11378231f, 0.04331836f, -0.15578964f, -0.04179028f, -0.02207687f, 0.06840272f, -0.08600425f, 
    -0.13682003f, -0.11463304f, 0.11458624f, 0.00756801f, -0.03426840f, 0.03153653f, -0.11525880f, 0.13235326f, 
    -0.00071738f, 0.08847400f, 0.07619500f, -0.20271263f, -0.04506155f, -0.10196646f, 0.07156084f, -0.04906335f, 
    0.07566962f, -0.04522742f, -0.19002894f, -0.14388441f, -0.02122106f, -0.15817560f, -0.17473766f, 0.17448859f, 
    -0.05852494f, -0.04324748f, 0.56227714f, 0.16544114f, 0.26262212f, 0.19447064f, 0.51571268f, 0.11478176f, 
    0.01322223f, -0.16260673f, 0.03306756f, -0.14139521f, 0.70485288f, 0.06369010f, -0.14906950f, -0.04048717f, 
    -0.00085191f, -0.01922881f, -0.00094865f, 0.34169343f, -0.02207601f, 0.38550153f, 0.03136750f, 0.61007243f, 
    0.25156242f, -0.49397120f, 0.11538708f, -0.69278139f, 0.01185623f, -0.24292454f, 0.31385395f, 0.11098841f, 
    -0.24323390f, 0.06459880f, 0.08274722f, 0.40946299f, -0.08079517f, -0.38063839f, -0.07335031f, 0.13297504f, 
    0.25767037f, -0.13924809f, -0.11725631f, 0.47396907f, -0.35374892f, -0.11892100f, 0.11088623f, 0.12655796f, 
    -0.04310914f, 0.21600059f, -0.14399543f, -0.36687264f, -0.04596351f, -0.40655777f, 0.04530149f, -0.23400807f, 
    -0.26396656f, 0.41357249f, 0.23148291f, 0.37335354f, 0.14119190f, 0.33686692f, 0.34981591f, -0.07712771f, 
    -0.08550585f, 0.04842822f, 0.12193164f, -0.17461582f, 0.27044159f, 0.21402910f, -0.36701545f, -0.24756680f, 
    -0.54029250f, -0.10997874f, -0.18475477f, 0.18862416f, 0.49905688f, -0.12144952f, -0.00232119f, 0.11414514f, 
    -0.00151848f, 0.00710815f, 0.02750282f, -0.01363301f, -0.06720582f, -0.46206674f, 0.07144655f, -0.07465921f, 
    0.07485653f, 0.56083322f, 0.25982141f, -0.47909454f, -0.12607674f, 0.05120305f, 0.34272975f, 0.48451856f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.04312533f, -0.40035769f, -0.13425080f, 0.28209347f, -0.04810172f, 0.05082583f, 0.39099848f, 0.16867422f, 
    0.18654561f, 0.47984424f, 0.23608318f, 0.27157253f, 0.29069886f, 0.17528509f, -0.35243872f, 0.28203824f, 
    0.32730231f, 0.10487141f, -0.15214306f, 0.09331483f, 0.13537943f, 0.33575174f, 0.52191979f, -0.16640373f, 
    0.25824606f, 0.20817789f, 0.13824724f, 0.22008304f, -0.19325981f, 0.04294422f, 0.18886086f, 0.02062949f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.26015648f, -0.84918618f, -0.27996740f, -0.13915105f, -0.24664101f, -0.02464303f, -0.00061325f, 0.12049198f, 
    0.18435887f, -0.22560638f, 0.03224708f, -0.26034537f, 0.26411861f, 0.11016041f, -1.65171039f, 0.08333127f, 
    -0.27870870f, -1.00904560f, 0.36812922f, 0.14893205f, 0.09455159f, 0.34906796f, -0.04904144f, 0.30917412f, 
    -0.14676157f, -0.05417211f, -0.16785251f, -0.22558177f, -0.08900063f, 0.05521470f, -0.13779159f, -0.17687893f, 
    -0.24714532f, 0.37394035f, -0.41623735f, 0.01558498f, 0.20912157f, -0.08310229f, 0.28843075f, 0.06316338f, 
    -0.48900655f, -0.12842080f, -0.18035115f, -0.39941424f, 0.25567189f, 0.09752104f, 0.66105741f, 0.15334529f, 
    0.50267416f, -0.51033944f, -0.21277195f, 0.14567123f, 0.21935402f, 0.05088494f, 0.08823786f, -0.10337291f, 
    0.22773123f, -0.03866633f, 0.24267736f, 0.11234249f, -0.16429277f, -0.43296352f, 0.29904902f, -0.11170156f, 
    0.30081913f, -0.50733185f, -0.36988577f, -1.09274566f, 0.37127990f, 0.17150828f, 0.10881049f, 0.26923823f, 
    -0.33164856f, -0.90705246f, 0.17540710f, 0.40635392f, -0.14896421f, 0.31803244f, -0.40426251f, 0.21776362f, 
    0.05547810f, 0.14285679f, -0.82625592f, 0.40410408f, 0.27789670f, 0.19343302f, 0.09284980f, -0.80426288f, 
    -0.89924103f, -0.30050978f, -1.09657454f, 0.11580767f, 0.10796084f, 0.32124984f, -0.80028260f, -0.45607471f, 
    0.01740960f, 0.25165826f, -0.28965363f, -0.14010817f, -0.04481016f, 0.10393741f, -0.48737130f, -0.00125186f, 
    0.32109404f, 0.11367339f, 0.30339700f, 0.32299355f, -0.33996788f, 0.12549470f, -0.73767012f, -0.64934123f, 
    -0.70336485f, 0.30212274f, 0.34728357f, 0.15263891f, -0.66885221f, -0.15654789f, -1.22262251f, 0.05975242f, 
    -0.31720918f, 0.31241506f, -0.02019853f, 0.16159649f, 0.08514547f, 0.13695291f, -0.07622137f, -0.47539833f, 
    0.14590992f, 0.00728505f, 0.32805499f, -0.02396794f, 0.11590125f, -0.14618187f, 0.29812232f, 0.28507805f, 
    0.00898962f, -0.21794248f, -0.34562314f, -0.23232578f, -0.46668229f, -0.13048770f, -0.30705816f, 0.02924004f, 
    -0.43275964f, -0.08952280f, -0.05721147f, -0.06239021f, 0.02256728f, 0.13122080f, -0.05635189f, 0.13239650f, 
    0.26406977f, -0.07923450f, -0.36852279f, 0.19418082f, -0.08046778f, 0.31633103f, -0.18735239f, 0.16305982f, 
    -0.39787871f, 0.16003880f, -0.29886991f, -0.00651376f, -0.33436149f, -0.00231425f, 0.31614843f, -0.22031343f, 
    0.12919904f, 0.23555094f, -0.04821444f, -0.11660135f, 0.36500081f, 0.08426081f, -0.04807020f, -0.09149299f, 
    -0.03721271f, 0.70799863f, -0.07608135f, -0.10200349f, -0.32229531f, 0.07557757f, 0.21729633f, 0.04961597f, 
    0.27474251f, -0.00919724f, 0.30067363f, -0.89170229f, 0.12139873f, -0.12770362f, 0.25858194f, 0.09519489f, 
    -0.22141829f, -0.32566544f, 0.34512407f, -0.38018051f, -0.22372937f, -0.05040510f, -0.44634315f, 0.18790992f, 
    0.13068083f, 0.10707594f, 0.18926680f, -0.66329384f, -0.21270403f, 0.37105575f, -0.42005128f, 0.04553564f, 
    -0.06692326f, -0.41195983f, 0.05378581f, 0.25079241f, -0.42401564f, -0.26040202f, 0.28748524f, -0.44190714f, 
    -0.23875126f, -0.01809155f, 0.42478934f, -0.41973120f, 0.11401109f, 0.19173862f, 0.22216298f, 0.03962355f, 
    0.07647062f, 0.48441294f, -0.08241323f, 0.14295977f, 0.04301108f, 0.02203626f, -0.05660436f, -0.72162765f, 
    0.15343121f, -0.19959009f, -0.44195214f, -0.46749789f, -0.15792245f, -1.16440642f, 0.25819728f, -0.39928657f, 
    -0.40252101f, -0.85462832f, 0.19027527f, -0.63519371f, -0.07570131f, -0.04550377f, -0.22921509f, 0.38666481f, 
    0.33952168f, -0.20259085f, 0.05684511f, -0.12123175f, -0.06634078f, 0.06181160f, -0.32095000f, -0.37728679f, 
    0.12498244f, -0.42108032f, 0.65115476f, 0.26639813f, -0.80696005f, -0.02032204f, 0.31207559f, -0.48033285f, 
    -0.90103567f, 0.37408215f, -0.41188729f, 0.44643897f, 0.27563828f, -0.35244593f, -0.01644297f, -0.17619580f, 
    -0.04581722f, 0.05404555f, -0.24651407f, -0.43035114f, 0.36116093f, -0.79322493f, -0.32404035f, -0.30070773f, 
    -0.38729933f, -0.80203080f, 0.20271049f, 0.02766226f, 0.01208071f, -0.69592023f, 0.39989749f, 0.23753630f, 
    0.00590740f, 0.34406772f, 0.30020016f, -0.09440008f, -0.21398985f, 0.13501619f, -0.38999507f, 0.25039625f, 
    -0.20539035f, 0.01465759f, -0.23250154f, -0.28757328f, -0.03423499f, -0.01359991f, 0.38348490f, 0.19375899f, 
    -0.66498667f, 0.66621703f, 0.20471840f, -0.04977176f, -0.04767310f, -0.00510134f, -0.26137227f, 0.00737391f, 
    -0.36763647f, -0.36204645f, 0.08805210f, 0.07164232f, -0.18738165f, 0.13964882f, -0.12161433f, 0.31975490f, 
    -0.05053851f, -0.22408785f, -0.73467261f, 0.17656080f, 0.29163665f, -0.07840316f, 0.32697818f, -0.74100631f, 
    -0.37662244f, 0.39799345f, 0.35499400f, 0.28075224f, 0.19955882f, -0.68070048f, -0.41570979f, -0.43881831f, 
    0.39552504f, -1.46419132f, -0.20122442f, 0.07147351f, -0.35812500f, 0.24537119f, -0.35370049f, -0.31667894f, 
    0.52301717f, 0.32104903f, -0.07211382f, 0.43383315f, -0.13181068f, 0.02950281f, 0.07844793f, -0.98141581f, 
    0.32062948f, -0.23155998f, 0.32237175f, 0.18279828f, -0.08905021f, 0.13761204f, -0.62496322f, -0.05857776f, 
    0.17092420f, -0.04794195f, 0.31767204f, 0.39024085f, 0.02164826f, 0.13722254f, 0.01290334f, -0.18373753f, 
    -0.14891794f, -0.95051813f, -0.09480748f, 0.10757066f, 0.33137405f, -0.63123441f, -0.07076297f, -0.27387345f, 
    -1.02232432f, 0.25077239f, -0.36262503f, 0.17977741f, -0.02312184f, -0.00019757f, 0.11508267f, -0.53057528f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.23699465f, -0.00496344f, -0.08459239f, -0.34510651f, 0.11486600f, 0.30814537f, 0.05541765f, -0.31772122f, 
    -0.34558061f, -0.14459197f, 0.32591295f, 0.24261732f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
