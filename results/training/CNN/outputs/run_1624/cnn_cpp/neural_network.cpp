#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.38877535f, 0.58762378f, -0.70214123f, -1.18674791f, -1.07329369f, -0.86543989f, -0.70380348f, -0.43608493f, 
    -0.73862970f, -0.48644990f, 0.36599919f, 0.39866930f, -1.46665204f, -1.08200538f, -1.25919390f, 0.71089017f, 
    -0.46466669f, 0.31179094f, -1.72878170f, 0.39792284f, 1.55597961f, -0.54765165f, 0.01868870f, 0.29944718f, 
    -0.17198360f, -0.31693548f, 0.07945347f, -1.10865808f, -0.08290686f, -0.67763478f, -0.31561211f, -0.62696254f, 
    -1.61088943f, -0.05183779f, 0.55025434f, 0.61584592f, 0.97205907f, -1.32104266f, -1.34417117f, 0.81459385f, 
    0.69672626f, 0.98161131f, -0.27864486f, -0.36448315f, -0.40867281f, 1.33378339f, -0.46413836f, -0.39938131f, 
    -0.43730801f, 0.10515181f, 0.56213200f, -0.05484492f, 0.48686352f, -0.08913777f, -0.45113590f, -1.31282544f, 
    -1.33996677f, 0.78831369f, 0.96138644f, -0.44775110f, 0.38425210f, 0.16534321f, 0.27784091f, -1.16765654f, 
    -0.87150282f, -1.35236216f, 0.94460911f, -0.33267203f, -0.92509335f, -0.63348502f, -0.67287326f, -0.77956027f, 
    -1.19870615f, -0.40034235f, -0.63831538f, 0.17469898f, -0.69852024f, 0.83517295f, 0.19505112f, 0.10674325f, 
    0.83580571f, 1.41581035f, -1.82146490f, 0.45056349f, -0.89508635f, 0.61061567f, -0.62874115f, -0.65549678f, 
    -0.33538389f, -0.27335292f, -1.32394540f, -0.48905542f, -0.43459666f, 0.28123313f, -0.28507653f, 1.08220136f, 
    0.77126032f, -0.08324164f, -0.64859223f, 1.00690460f, -0.39112073f, -0.83823270f, 0.20916189f, 0.94857186f, 
    0.33027256f, -0.39070040f, 0.75657827f, -0.06858144f, -0.16735883f, 0.01229062f, 0.40616879f, 0.78684926f, 
    -0.10232996f, -0.57415205f, 0.03253016f, 0.45314947f, 0.58873343f, 1.11551273f, -0.28562054f, 0.18781751f, 
    -0.35072574f, 0.25209013f, 0.44105726f, -0.30111054f, -0.25824535f, -0.51732063f, -0.05632924f, 0.67159635f, 
    -0.09650350f, 0.52686316f, -0.76865733f, -0.20958459f, -0.33115354f, 0.49444008f, 0.39280236f, 0.75486875f, 
    0.54442954f, 0.21499443f, 0.90387022f, -0.07911645f, -0.25198638f, 0.29125327f, 0.10883617f, -0.39628929f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.25020319f, 0.24706969f, 0.38879752f, 0.19321983f, 0.26024929f, 0.40824437f, 0.39385727f, -0.34803045f, 
    0.38609785f, 0.29792455f, 0.06954093f, 0.27760243f, -0.11639705f, 0.61678970f, 0.51491767f, 0.10043168f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.13239655f, 0.49447834f, 0.19378044f, -0.28949133f, -0.31821439f, 0.04579856f, 0.22453415f, 0.06851793f, 
    -0.09001260f, 0.13177848f, 0.01570670f, -0.12433488f, -0.04737991f, 0.00184192f, -0.02565949f, -0.10268538f, 
    -0.00423163f, -0.11435762f, -0.09181002f, 0.20442039f, 0.16959539f, 0.41313645f, 0.25877875f, -0.51971173f, 
    -0.21058275f, -0.03660600f, 0.16141108f, -0.08378665f, 0.04543624f, 0.12603199f, 0.04882306f, 0.02954968f, 
    0.06110865f, -0.04395171f, -0.07698178f, -0.05094924f, -0.04720253f, 0.06988859f, 0.03686127f, -0.18841395f, 
    -0.24150614f, -0.05893927f, 0.16325371f, -0.46797726f, 0.42711732f, -0.38218221f, -0.53985506f, 0.03623606f, 
    -0.01028873f, -0.18733136f, 0.04112947f, -0.02974451f, -0.27134636f, 0.05697240f, -0.07907724f, 0.06970977f, 
    -0.06179349f, -0.05336821f, -0.11594994f, -0.19663259f, 0.54134655f, 0.54808712f, -0.15514944f, -0.40531647f, 
    -0.28118810f, 0.03732766f, -0.01017897f, 0.15897873f, 0.09915379f, 0.07534996f, 0.09620631f, -0.11600587f, 
    0.04517272f, 0.00161710f, 0.04121038f, -0.01429944f, -0.10760050f, -0.11948098f, -0.00226234f, -0.02153575f, 
    0.39997569f, -0.55073661f, -0.75526780f, 0.08547190f, -0.12214867f, -0.02466558f, -0.00848632f, 0.09036472f, 
    -0.11650466f, 0.07619451f, -0.00442846f, 0.11296865f, -0.13989845f, 0.07378566f, -0.11796577f, 0.08218365f, 
    0.11183503f, -0.01205772f, 0.01685383f, -0.03723330f, -0.40532100f, -0.10548365f, -0.17367588f, -0.00201673f, 
    0.05842593f, -0.21172430f, -0.07674523f, -0.06353568f, 0.11394457f, -0.04567123f, -0.18391542f, -0.06565270f, 
    -0.28951895f, -0.13808148f, 0.07753191f, 0.09026275f, 0.00427290f, 0.17995848f, -0.05437443f, 0.06108637f, 
    0.42926404f, 0.28904712f, -0.71200001f, 0.03583519f, 0.04983587f, 0.13190836f, 0.13017237f, 0.11493165f, 
    -0.24017838f, -0.11920702f, -0.03462273f, -0.17281871f, -0.07574899f, 0.08128424f, 0.09523316f, 0.01333435f, 
    0.11967174f, -0.01820474f, 0.02767935f, 0.07653445f, 0.61164641f, 0.33175847f, 0.05020701f, -0.29822525f, 
    0.01632427f, 0.17575166f, 0.34892508f, 0.16451721f, -0.09166326f, 0.11478668f, -0.06844032f, -0.05555492f, 
    -0.04083657f, -0.06578503f, 0.07548043f, 0.00013967f, -0.14106616f, -0.12276154f, -0.21128675f, 0.07327630f, 
    0.35315308f, 0.29974169f, 0.22573717f, -0.22022261f, 0.21376482f, 0.11193371f, 0.23085274f, 0.19180372f, 
    -0.06732737f, -0.23108944f, -0.04721163f, -0.21494006f, 0.04033213f, 0.00094569f, 0.07923152f, -0.02672265f, 
    -0.06208160f, 0.04270222f, 0.03698155f, 0.02197951f, 0.12237417f, -0.16518269f, 0.29397225f, -0.52553600f, 
    -0.17471305f, -0.17532264f, -0.62958395f, 0.03011357f, -0.44605875f, -0.06287783f, -0.13124549f, -0.00215661f, 
    -0.14141680f, -0.04405832f, -0.07214636f, -0.03095176f, -0.02863518f, -0.03390685f, 0.01479756f, 0.18886675f, 
    0.53393668f, -0.26029342f, 0.20700742f, -0.30639544f, 0.01424047f, 0.07910361f, 0.16820805f, 0.08448016f, 
    0.03806901f, 0.00442929f, 0.00215108f, -0.06697322f, -0.08286114f, 0.12356241f, 0.18698606f, 0.04991409f, 
    -0.02759730f, 0.03219960f, 0.00639690f, -0.01311377f, -0.23124035f, -0.02653913f, -0.14413086f, 0.18180402f, 
    0.04444553f, 0.02128098f, -0.02356419f, -0.02593051f, 0.10383217f, 0.08234100f, -0.03208449f, -0.08233610f, 
    -0.36570495f, -0.44145906f, -0.16834192f, -0.03628800f, 0.07421792f, -0.01780309f, -0.10481261f, -0.03698770f, 
    0.10107714f, 0.03205971f, 0.05994419f, 0.11638248f, 0.07715233f, 0.00224237f, 0.11223352f, 0.08048287f, 
    0.10642913f, 0.09500229f, -0.19379191f, -0.14775468f, 0.02857940f, -0.11705374f, -0.07757115f, -0.16625339f, 
    -0.07683109f, -0.06106859f, -0.00209001f, 0.02241701f, -0.77521378f, -0.53395933f, -0.02492126f, 0.07772705f, 
    -0.11218828f, 0.00055118f, -0.04436935f, 0.00045746f, 0.03195825f, 0.13386634f, 0.04864760f, 0.03145918f, 
    -0.04541336f, 0.04956331f, 0.00817406f, -0.12265518f, 0.08842182f, 0.08769321f, -0.11076826f, -0.08621950f, 
    -0.08499609f, -0.27400231f, -0.32129762f, 0.01519670f, -0.28163293f, -0.14019012f, -0.04682327f, -0.00897650f, 
    0.02668525f, -0.02027671f, -0.07978299f, 0.04492552f, -0.09849641f, -0.11985864f, -0.09338836f, -0.21540612f, 
    -0.15441205f, -0.42998248f, -0.02874400f, -0.26392922f, -0.10001070f, -0.08792592f, -0.07833378f, 0.13144080f, 
    0.04372386f, 0.08528428f, 0.04727885f, 0.09031431f, 0.07605634f, 0.07896399f, -0.16630298f, -0.02366131f, 
    0.02941465f, 0.03101061f, 0.01408751f, -0.20395023f, -0.20105460f, -0.13932031f, -0.07522429f, 0.00793597f, 
    -0.25967059f, 0.20240369f, -0.24494396f, -0.03235222f, -0.37261260f, 0.10252804f, -0.10056885f, -0.47009566f, 
    -0.18944505f, 0.01330479f, -0.00697640f, 0.06780213f, 0.11092693f, 0.07631361f, 0.12609717f, -0.14070375f, 
    -0.07851005f, 0.07298757f, -0.44248024f, -0.39427799f, -0.20564429f, 0.09065959f, -0.13113998f, -0.49001119f, 
    -0.18166189f, -0.08393128f, -0.35095382f, -0.18116957f, 0.10098320f, 0.03105181f, -0.03405370f, 0.01559843f, 
    0.04957655f, 0.07408419f, 0.18298243f, -0.01969862f, -0.04861367f, 0.02215931f, -0.07486236f, 0.13286476f, 
    -0.74148071f, -0.39548305f, -0.16597459f, -0.31174093f, 0.42257887f, 0.12115687f, -0.12816073f, 0.01867679f, 
    0.09085623f, -0.12402499f, 0.12941515f, 0.20434837f, 0.23931323f, -0.10822759f, -0.00809903f, 0.13777126f, 
    0.08182579f, 0.16202608f, 0.18412904f, -0.12995252f, -0.18954657f, 0.15767726f, 0.04014363f, 0.42811781f, 
    0.16432080f, 0.04977354f, 0.05370029f, -0.35625899f, 0.00169361f, -0.04581784f, -0.09785639f, -0.03256289f, 
    0.00565294f, 0.02385639f, -0.02785258f, 0.00318725f, 0.07519286f, -0.00755597f, -0.05185796f, -0.08400466f, 
    0.94799995f, -0.03151412f, 0.15585804f, 0.24965368f, -0.56603998f, -0.01907624f, -0.02025463f, 0.08023034f, 
    -0.18368098f, -0.04878698f, 0.27969536f, -0.32065818f, -0.09924694f, -0.17603585f, -0.17608275f, 0.16911861f, 
    -0.08135660f, -0.14285527f, -0.08933549f, -0.02024530f, 0.50756973f, 0.10111455f, 0.08767689f, 0.01983062f, 
    -0.03091368f, -0.00141676f, 0.01879283f, -0.08205005f, -0.08645559f, 0.11515851f, 0.05320821f, -0.07732503f, 
    -0.10145322f, 0.39805549f, -0.04486683f, -0.31898999f, 0.00810978f, 0.11550441f, 0.03701270f, 0.04936950f, 
    0.36084658f, -0.33228034f, -0.34131861f, -0.02364247f, -0.10331765f, -0.04506809f, 0.00409399f, 0.18314183f, 
    -0.09329079f, -0.25052100f, -0.01324654f, -0.17635690f, 0.11421428f, -0.06461194f, 0.02396902f, -0.02133891f, 
    -0.08673248f, -0.07593725f, 0.03193108f, 0.02881173f, 0.47859156f, 0.49823880f, 0.49687877f, 0.20249349f, 
    -0.01857326f, 0.22107586f, -0.23729955f, 0.07343088f, 0.19307719f, -0.10504269f, 0.10957572f, -0.07140084f, 
    0.05850932f, -0.22972348f, 0.02600588f, -0.03715896f, -0.01365186f, -0.17518428f, -0.02440353f, 0.23062801f, 
    -0.79165560f, -0.14836460f, -0.16365327f, -0.11260949f, -0.15637130f, -0.05535185f, 0.22158766f, 0.27676812f, 
    0.03643469f, -0.08220086f, 0.02215312f, -0.04226266f, 0.03563938f, -0.01261880f, -0.09635343f, -0.02975241f, 
    0.12540284f, -0.06188346f, -0.12932631f, 0.07491795f, -0.03757459f, 0.38641596f, -0.36780491f, -0.06662809f, 
    0.00631911f, 0.01879646f, 0.12446221f, -0.10540771f, -0.02711803f, 0.00537689f, -0.10651611f, 0.00832579f, 
    0.02271344f, 0.00382895f, -0.12013274f, 0.01390404f, -0.41750655f, -0.15589245f, -0.16706291f, -0.18570244f, 
    -0.91156757f, -0.18936367f, -0.22871265f, -0.03427978f, -0.10693545f, 0.20186791f, -0.05725405f, 0.17453302f, 
    -0.18682899f, -0.04867370f, -0.09796143f, 0.11003208f, 0.10313366f, -0.00113415f, -0.19737294f, 0.06095145f, 
    -0.07494961f, 0.05042581f, -0.11260865f, -0.05189250f, 0.64959544f, -0.13837767f, -0.04971917f, 0.13334854f, 
    -0.16576897f, -0.11409209f, 0.04731892f, -0.04976346f, 0.01034710f, 0.00152851f, 0.04395965f, 0.24414264f, 
    -0.11095332f, -0.08948614f, 0.04128698f, -0.11182319f, -0.03463142f, -0.20753565f, 0.04543840f, 0.10370346f, 
    -0.02204723f, 0.03870254f, -0.03584223f, -0.00750655f, 0.12357280f, 0.13971919f, -0.15833838f, -0.02874290f, 
    -0.02344252f, -0.11315987f, 0.05007119f, 0.11567511f, -0.01753114f, 0.03673476f, -0.06807473f, -0.00201927f, 
    -0.07448373f, 0.16717075f, -0.05003511f, -0.04386937f, 0.92550766f, 0.27181730f, 0.24190897f, 0.27134132f, 
    0.13568565f, -0.05538060f, -0.05723745f, -0.09459133f, -0.08068617f, 0.04634685f, -0.07639710f, 0.01961713f, 
    0.03885911f, -0.00173016f, -0.03134005f, 0.19706409f, -0.02374414f, 0.05053748f, 0.08256152f, -0.02014766f, 
    -0.16042021f, 0.00396016f, 0.01951776f, -0.01919903f, 0.07203468f, 0.28415570f, -0.09779568f, -0.02525939f, 
    0.06024517f, -0.00934596f, -0.12824440f, -0.07301653f, 0.09940170f, 0.15123454f, 0.05176079f, -0.07735030f, 
    0.15697612f, -0.03784473f, 0.12288760f, 0.03639989f, 0.26252791f, 0.11561226f, -0.07772952f, 0.13124263f, 
    0.05357131f, -0.04115998f, -0.13616177f, -0.02022714f, -0.02164613f, -0.07734124f, -0.03793984f, 0.00898040f, 
    -0.05920599f, -0.04994633f, 0.22979525f, 0.08888649f, -0.04751485f, -0.05074577f, 0.07241746f, -0.03181651f, 
    -0.27002814f, -1.02013826f, -0.14305766f, -0.09055509f, -0.37676594f, -0.07771953f, 0.04957051f, 0.01177905f, 
    -0.04176362f, -0.18131970f, -0.11843751f, -0.05149045f, -0.00792279f, -0.05612595f, 0.00915450f, -0.08540024f, 
    -0.02981051f, -0.13500383f, 0.19022375f, 0.34214485f, -0.74727911f, -0.96768367f, -0.15868755f, -0.25637314f, 
    -0.31227985f, 0.25551713f, 0.05281012f, -0.24192168f, -0.04522717f, 0.04891745f, 0.00456980f, 0.00208695f, 
    -0.00105233f, 0.05152227f, -0.15209252f, 0.01839368f, -0.00256389f, -0.00339655f, -0.14826612f, 0.04400762f, 
    0.88198096f, 0.50906241f, -0.14236844f, 0.05645137f, 0.41777334f, -0.17628840f, 0.09301766f, -0.17389728f, 
    -0.13740490f, -0.08952493f, -0.15380839f, -0.05507960f, 0.02330063f, -0.11304583f, -0.11190373f, -0.02128603f, 
    -0.08853347f, 0.10099438f, -0.02215645f, 0.03453789f, 0.37239692f, -0.99480498f, -0.40789631f, 0.08129386f, 
    -0.30490160f, 0.04418200f, -0.03133839f, -0.25289345f, -0.03113139f, -0.14322244f, 0.06622314f, 0.14450501f, 
    0.05957307f, -0.01842578f, -0.00556682f, 0.01285044f, 0.00373318f, 0.00924189f, 0.11424361f, -0.08918817f, 
    -0.36206925f, 0.23128913f, 0.87973499f, 0.04914555f, 0.28172663f, -0.12464854f, -0.02361914f, 0.01890671f, 
    -0.11125551f, 0.16771749f, 0.11118750f, 0.06984244f, 0.13201107f, -0.13074364f, 0.03540535f, 0.00271270f, 
    0.07029172f, 0.10256351f, 0.01985992f, -0.05245682f, -0.49784675f, 0.24027629f, 0.01289102f, 0.08510593f, 
    0.10357090f, -0.12258795f, 0.09382942f, -0.12741347f, -0.14381281f, 0.02343630f, 0.06946659f, 0.06049794f, 
    -0.30157211f, 0.05304813f, -0.05534520f, 0.07778361f, -0.04835234f, -0.05306965f, 0.08709402f, -0.08102445f, 
    0.07996690f, -0.19763491f, 0.62174761f, 0.18063068f, 0.24064922f, -0.02449425f, -0.10194597f, 0.10087749f, 
    0.36209896f, -0.35405442f, 0.05064558f, -0.03291592f, 0.07153842f, -0.03871376f, 0.07325393f, 0.07528602f, 
    -0.08380426f, -0.05318923f, 0.02531853f, -0.11814069f, -0.51350516f, -0.33700031f, 0.90600640f, 0.64811522f, 
    -0.34718585f, -0.07620856f, 0.14060555f, -0.16748840f, 0.10987148f, -0.18626085f, 0.01617729f, -0.02846185f, 
    -0.01937803f, 0.04476077f, -0.15189864f, -0.16080472f, -0.04131717f, -0.01016324f, 0.07003841f, -0.22225545f, 
    -0.06041486f, 0.22278903f, -0.01789998f, 0.38751295f, 0.16098553f, -0.06750902f, -0.14780121f, 0.10818035f, 
    -0.18063623f, -0.15247801f, 0.14167950f, 0.03149527f, 0.02741972f, -0.00717258f, 0.06012220f, -0.01492607f, 
    -0.12110142f, 0.00214210f, -0.04632614f, 0.00571804f, -0.04946998f, 0.40411285f, -0.08534548f, 0.28995207f, 
    -0.66830581f, -0.07049961f, -0.03118213f, -0.23078395f, -0.06541508f, 0.23952769f, 0.06066251f, -0.04317570f, 
    0.01707351f, -0.10519268f, 0.09297431f, 0.23000075f, 0.11786748f, -0.13059084f, 0.15227550f, 0.08102851f, 
    -0.52918845f, 0.57976317f, -0.13153662f, 0.11116819f, 0.33279479f, -0.10784685f, 0.05793745f, -0.05922483f, 
    0.00680969f, 0.16295524f, -0.03824520f, 0.11348256f, -0.00288278f, 0.15327561f, -0.00550146f, 0.00042073f, 
    0.03382313f, 0.04303991f, -0.15131304f, 0.07382848f, -0.14230900f, 0.11918900f, 0.21558784f, -0.01615149f, 
    0.04385689f, -0.07459155f, -0.01461665f, 0.10641932f, -0.00118273f, 0.01961486f, -0.23180179f, -0.11384366f, 
    -0.15256482f, 0.12733214f, 0.22770968f, 0.08814628f, -0.05889207f, -0.11316607f, 0.14183353f, -0.16753970f, 
    0.01081123f, -0.04084700f, -0.07231434f, -0.05310656f, 0.13838810f, 0.09828535f, -0.18083222f, 0.01553257f, 
    0.14019683f, 0.10432193f, -0.52085692f, -0.19123504f, 0.01199479f, -0.07702249f, -0.16205080f, 0.00849768f, 
    -0.17662236f, -0.09621952f, 0.15456448f, -0.04619713f, -0.42791337f, -0.20097822f, -0.28866121f, -0.06690494f, 
    -0.37660471f, -0.03338950f, 0.01927258f, -0.00822425f, -0.00547345f, 0.08472857f, 0.06682552f, 0.01803819f, 
    -0.05299259f, 0.04651988f, 0.00476648f, 0.09521064f, -0.03083756f, 0.17528240f, 0.10587630f, -0.10137330f, 
    -0.03443083f, -0.02057669f, 0.04783067f, -0.02620835f, 0.15690601f, 0.07245812f, -0.22400138f, -0.16082858f, 
    -0.05013858f, 0.04402256f, 0.25854942f, -0.01309580f, -0.04554890f, 0.04325086f, 0.05894973f, 0.10974066f, 
    -0.13868484f, -0.14523384f, 0.04187034f, 0.02211894f, -0.26614255f, -0.23563620f, -0.03161428f, -0.46578461f, 
    0.04994034f, 0.01969534f, -0.14180569f, -0.11105590f, 0.08203607f, 0.13912171f, 0.01856386f, -0.04357642f, 
    -0.00524035f, 0.05813892f, -0.09875509f, 0.00696676f, -0.09027135f, -0.09361618f, 0.21448380f, -0.02229231f, 
    0.23593432f, -0.30811480f, -0.02612821f, -0.03101152f, 0.59035277f, -0.08786664f, 0.15140828f, -0.00648639f, 
    0.02557636f, 0.01088391f, -0.07893030f, 0.01849221f, -0.08601239f, -0.11820522f, 0.00706867f, 0.06048547f, 
    -0.09913760f, 0.00259240f, 0.01246044f, -0.13155872f, 0.24136294f, -0.25194591f, 0.14635517f, -0.04986757f, 
    0.39125881f, -0.07177157f, 0.21966119f, 0.03262752f, 0.06048915f, 0.05528611f, 0.05548857f, -0.10078862f, 
    -0.02781456f, 0.05104383f, 0.08214475f, -0.16685766f, -0.07710856f, -0.06831636f, -0.05219639f, -0.11147859f, 
    0.79505557f, 1.07792497f, 0.49087700f, -0.66099811f, 0.32351032f, -0.12730199f, 0.04441843f, -0.33262807f, 
    -0.38433790f, -0.04331714f, -0.09496614f, -0.08375466f, -0.01272578f, 0.02054154f, 0.00240076f, 0.06740823f, 
    -0.00126416f, -0.08573755f, -0.06300271f, 0.01041469f, -0.04924601f, -0.21199113f, -0.51553416f, -0.26151457f, 
    0.42580351f, 0.24127859f, 0.05730323f, 0.11775670f, 0.01935291f, 0.16043223f, -0.07410891f, 0.01564388f, 
    -0.19334312f, 0.16539000f, -0.13062933f, 0.02686272f, -0.10492232f, 0.14472124f, -0.15976095f, 0.06186241f, 
    0.27919462f, 0.95005482f, 0.19103417f, -0.15566136f, 0.26543370f, 0.43432057f, 0.09955550f, 0.07084314f, 
    0.09744885f, 0.12287765f, -0.21366090f, -0.06469493f, 0.01263384f, 0.08060799f, 0.21421747f, -0.02969718f, 
    0.01736703f, -0.00946893f, -0.07407800f, -0.07120365f, -0.87249124f, -0.09814021f, -0.04918342f, 0.67499840f, 
    0.07505518f, -0.08414312f, -0.16985564f, 0.13453989f, -0.16538574f, -0.29316986f, -0.14021890f, 0.19908279f, 
    -0.01922880f, -0.27613798f, -0.10483006f, -0.04764455f, 0.16348995f, 0.14993830f, -0.10083478f, -0.07998206f, 
    -0.46112695f, 0.37291914f, -0.31995785f, 0.08919678f, 0.53548324f, 0.36696449f, -0.00927013f, -0.03769913f, 
    -0.16514120f, 0.04988569f, -0.13462368f, 0.16047807f, 0.05215317f, 0.04062641f, 0.01014556f, 0.11542378f, 
    -0.02330320f, -0.10636538f, 0.20022631f, 0.04140805f, 0.02533734f, -0.04474066f, -0.56174499f, 0.14828630f, 
    0.62486345f, 0.06780426f, 0.12402014f, -0.08570921f, -0.06983848f, 0.08772896f, -0.11891130f, 0.15514252f, 
    0.00547113f, 0.09454288f, 0.12306470f, -0.11477143f, -0.00161357f, 0.26338884f, -0.03274789f, 0.04507610f, 
    -0.03504556f, -0.37288901f, -0.42051077f, -0.17763054f, 0.53018814f, 0.25948262f, 0.04528828f, -0.02358159f, 
    0.09942135f, -0.23792459f, -0.07244729f, 0.11019187f, -0.07998838f, 0.12095916f, 0.04499800f, 0.03565358f, 
    -0.12319160f, 0.24113514f, 0.07032555f, -0.17446454f, -1.06334770f, 0.31448409f, -0.39959309f, 0.46804270f, 
    -0.20256197f, -0.43609008f, -0.21966310f, 0.13539794f, -0.18893147f, -0.08618347f, -0.01478596f, -0.06614313f, 
    -0.02232818f, -0.16285804f, -0.19926590f, 0.09142236f, -0.00327841f, 0.13338618f, 0.02447005f, -0.27139980f, 
    0.05852262f, -0.17545986f, -0.31599444f, -0.44252613f, 0.16958915f, 0.42040774f, -0.08647006f, 0.10284527f, 
    0.03087810f, -0.54813969f, -0.23376708f, -0.07644941f, -0.01656897f, 0.03046381f, 0.10130262f, -0.04599142f, 
    0.09476525f, 0.10986244f, -0.02961651f, 0.03291788f, 0.26411298f, 0.15077017f, -0.40779272f, 0.02025342f, 
    -0.03104012f, 0.23970328f, -0.20985734f, 0.21383026f, -0.07506009f, -0.07969556f, -0.11989021f, -0.13665783f, 
    0.05495757f, -0.11114760f, -0.17007759f, 0.05157322f, -0.14739940f, 0.09452219f, -0.07168016f, -0.18684179f, 
    -0.12291944f, -0.07976745f, -0.23114635f, -0.34057328f, -0.05509182f, 0.09525059f, 0.27444711f, 0.00950281f, 
    0.31631452f, 0.13350712f, -0.03498896f, -0.08577983f, -0.42713270f, -0.04723027f, -0.11812901f, 0.05077379f, 
    -0.32875568f, 0.13202783f, -0.05215259f, -0.49878550f, -1.07236922f, 0.00040266f, 0.37530383f, -0.02429867f, 
    -0.60055405f, 0.05591025f, -0.10823430f, 0.07351334f, 0.03501008f, -0.16609082f, 0.00098262f, 0.10355464f, 
    0.06636864f, -0.14319958f, -0.07949610f, -0.13061345f, -0.04133087f, -0.14720117f, -0.06436004f, -0.07914124f, 
    -0.46970442f, 0.11196595f, 0.61227643f, -0.39367303f, 0.09170748f, -0.12181583f, 0.04845732f, -0.10930676f, 
    -0.01258304f, -0.03391165f, 0.16218048f, -0.02610507f, -0.22644730f, -0.01999804f, -0.00313711f, -0.10793713f, 
    -0.07964957f, 0.33947384f, -0.09465539f, -0.10842102f, -0.52460283f, -0.52320838f, -0.49814865f, 0.01160078f, 
    -0.43997252f, -0.00510796f, -0.01934328f, -0.16856660f, -0.18796314f, -0.00296862f, 0.08650862f, -0.01989400f, 
    -0.03594550f, 0.18989360f, 0.03882776f, -0.03207874f, 0.06958506f, 0.14506558f, -0.22652088f, -0.24971396f, 
    -0.00116364f, 0.05438904f, 0.16509482f, 0.31924236f, 0.10906617f, -0.03212060f, 0.16395752f, 0.12012068f, 
    0.24716969f, 0.15982828f, 0.02802397f, -0.05434071f, -0.09080428f, -0.03846976f, -0.05777760f, 0.14146554f, 
    0.17657897f, -0.10152133f, 0.19809633f, 0.27482137f, 0.02716041f, 0.34523645f, 0.29153743f, 0.60426587f, 
    0.17287752f, -0.03450572f, 0.16500206f, 0.02757668f, 0.11051771f, 0.15670052f, 0.07026367f, -0.10423432f, 
    -0.04320038f, 0.00006570f, -0.04927725f, -0.09211951f, 0.02413526f, -0.23135068f, -0.11275036f, -0.16380569f, 
    -0.08225437f, -0.80098170f, -0.40693244f, 0.50581777f, -0.41737083f, -0.23857477f, -0.04335769f, -0.00584279f, 
    -0.54205680f, 0.03047629f, 0.10722988f, -0.39440525f, -0.03844152f, 0.15488195f, 0.04911216f, -0.18509114f, 
    -0.18739446f, 0.02594070f, -0.31003472f, 0.05542555f, 0.10550173f, 0.37346560f, 0.35963055f, 0.26932579f, 
    0.25362146f, -0.27739856f, -0.06785656f, 0.02571329f, -0.26870182f, 0.39578816f, -0.07445736f, -0.01171486f, 
    0.02177675f, 0.07937088f, 0.05650490f, -0.03406629f, -0.17711811f, -0.08739474f, -0.19084638f, -0.22336854f, 
    -0.75565249f, -0.36235589f, -0.05714308f, -0.27993476f, -0.06020003f, -0.20882320f, 0.19863038f, -0.31105831f, 
    0.05386554f, 0.13820240f, -0.04301473f, -0.00736897f, -0.19386299f, 0.24012285f, -0.12004592f, -0.10915104f, 
    -0.03509530f, -0.06126217f, 0.01596881f, -0.02106000f, 0.10297602f, -0.23427270f, 0.06620581f, -0.32009873f, 
    0.04639989f, 0.13986613f, 0.04638333f, 0.21828406f, -0.10182022f, -0.18926793f, 0.00970557f, 0.04932390f, 
    0.09154454f, -0.36066204f, -0.08815572f, 0.16297820f, -0.04090961f, -0.18491630f, -0.09448517f, -0.18491389f, 
    0.26111603f, -0.35381177f, 0.11482973f, 0.12430293f, -0.01307405f, -0.15720008f, -0.10326809f, -0.15221201f, 
    -0.12916012f, 0.06534488f, 0.01445834f, 0.01568746f, 0.09605811f, -0.02099341f, 0.06587918f, 0.04853916f, 
    0.07004328f, 0.10131521f, -0.09931306f, -0.11888713f, -0.25308716f, -0.26009813f, 0.16601507f, 0.12219407f, 
    0.00781148f, -0.24413158f, 0.08581246f, -0.16022894f, -0.15400806f, -0.28140059f, -0.04030635f, -0.03304846f, 
    0.04596968f, 0.12211674f, -0.12768809f, -0.04813259f, 0.28222615f, 0.01756919f, 0.07199144f, 0.09003418f, 
    0.06197358f, 0.02738106f, 0.10723142f, 0.09507552f, 0.07863986f, -0.19438054f, -0.16866258f, -0.17558703f, 
    0.10467424f, -0.07367860f, 0.08249587f, 0.03348606f, 0.01993639f, 0.03443985f, 0.11704270f, 0.10027086f, 
    -0.02356158f, -0.00706399f, 0.01640344f, -0.07100672f, 0.01747136f, -0.05350214f, -0.00091378f, -0.58218545f, 
    0.18347354f, -0.15097845f, 0.07640892f, 0.00545678f, 0.11500461f, -0.37956074f, 0.05628385f, -0.01487118f, 
    -0.03763615f, 0.08095703f, 0.03128973f, -0.10642672f, 0.32629815f, -0.02906357f, -0.14811940f, -0.13834827f, 
    0.34532347f, 0.03251052f, 0.14041160f, -0.04284313f, 0.15037479f, -0.39237913f, -0.24731600f, -0.16847694f, 
    0.20297171f, -0.03646259f, 0.01768547f, 0.04094689f, -0.37620729f, -0.07688246f, 0.00077480f, 0.06583276f, 
    0.08279520f, -0.10238516f, 0.11148287f, 0.02200059f, 0.06657676f, -0.05167116f, 0.01696469f, -0.08601765f, 
    -0.00511593f, 0.05776992f, 0.01494479f, 0.13282163f, -0.10072088f, 0.00431736f, -0.00570444f, -0.28252667f, 
    -0.06917497f, 0.00044883f, 0.02236124f, 0.10468571f, 0.09790926f, -0.06449990f, -0.14677118f, -0.08158173f, 
    0.08848001f, 0.15478706f, 0.03236517f, -0.08889056f, 0.02950100f, 0.21810533f, 0.14225821f, 0.10965721f, 
    0.04431769f, 0.15257680f, -0.04227977f, 0.01771518f, 0.07772750f, -0.05141658f, 0.02588726f, 0.26128381f, 
    -0.22842133f, -0.10937454f, -0.01767575f, -0.09974442f, -0.11266451f, 0.09873050f, -0.19056185f, -0.44913337f, 
    -0.00015965f, 0.11885139f, 0.07672941f, 0.03730750f, 0.21964897f, 0.06263086f, 0.05822721f, 0.05540301f, 
    -0.05379722f, 0.05149497f, 0.05738007f, -0.03991095f, 0.15898781f, 0.08381192f, -0.10323375f, 0.25189421f, 
    0.09523172f, 0.03133470f, -0.21249503f, -0.06434981f, -0.00396887f, 0.06788099f, -0.03318557f, -0.03210596f, 
    -0.02010921f, -0.01999047f, -0.04725172f, 0.06721105f, 0.02918938f, -0.15449779f, 0.02321689f, -0.03131373f, 
    -0.34467682f, -0.06913453f, -0.01656355f, -0.16490254f, 0.09844027f, 0.14253919f, 0.06215462f, 0.01374544f, 
    -0.01079637f, 0.27020884f, 0.11333650f, 0.06466328f, -0.03996936f, 0.06872828f, 0.08792441f, 0.11034240f, 
    0.03196955f, -0.04584757f, -0.08717598f, 0.14166893f, 0.05054833f, -0.05800648f, -0.03592271f, 0.02463243f, 
    0.09809124f, 0.06248451f, 0.48543018f, 0.12674896f, -0.08046690f, 0.01084598f, -0.04712163f, 0.19527310f, 
    0.13508365f, -0.04797310f, 0.09185262f, 0.08638631f, 0.04303215f, -0.08174519f, -0.06177504f, 0.05925670f, 
    -0.06184503f, 0.01869912f, -0.37957990f, -0.29106471f, 0.07789269f, 0.09698009f, 0.21102248f, 0.15287210f, 
    -0.30012590f, 0.16194889f, 0.05842166f, 0.07992758f, -0.02986697f, -0.02757907f, 0.06294801f, 0.00785170f, 
    -0.04279675f, 0.03302207f, 0.04223779f, 0.06231720f, 0.10797036f, 0.09251970f, -0.10524207f, 0.01358192f, 
    -0.63918245f, -0.07191183f, 0.40690941f, 0.42475143f, -0.79900599f, 0.20079865f, -0.13580291f, 0.01950811f, 
    0.39495814f, 0.02983743f, 0.01762739f, -0.01828185f, -0.21151695f, 0.01383252f, 0.10249112f, -0.07890362f, 
    0.03995527f, -0.07095640f, -0.06935975f, 0.20091271f, -0.07374060f, -0.00095766f, 0.48244393f, -0.14229079f, 
    -0.15361629f, 0.06435290f, -0.00710686f, 0.11035102f, 0.15359935f, -0.41922370f, 0.08575768f, 0.00617423f, 
    0.07704510f, 0.01601188f, -0.06262734f, 0.04068357f, -0.00080648f, -0.06787379f, -0.01068781f, 0.37233377f, 
    -0.20555454f, 0.02471296f, -0.21895652f, -0.35682160f, 0.11433452f, -0.11391430f, -0.05672578f, -0.04712421f, 
    -0.02225806f, -0.22300532f, -0.08047507f, 0.16227427f, -0.05656141f, -0.13078448f, 0.20256506f, -0.16531383f, 
    -0.09416036f, 0.00768836f, 0.02559160f, -0.02677950f, -0.03180148f, -0.34096929f, -0.40204737f, -0.06149144f, 
    0.15047003f, 0.27707440f, -0.07237600f, -0.13375133f, 0.08512085f, 0.13696653f, 0.10217614f, 0.04019761f, 
    0.10276721f, -0.07956216f, -0.07087070f, 0.11232886f, 0.08789386f, -0.08641610f, 0.01869696f, -0.06112588f, 
    -0.43594462f, 0.08475333f, -0.02569369f, -0.52933019f, -0.22263162f, 0.04927827f, 0.06614225f, -0.08953720f, 
    -0.02749737f, 0.30502716f, 0.09134156f, 0.19786526f, -0.29831406f, -0.01082822f, -0.19044057f, -0.05286559f, 
    0.01884735f, 0.11494643f, -0.07095853f, 0.14981979f, -0.51442564f, 0.03567264f, 0.17058571f, -0.32532880f, 
    -0.26232392f, 0.03952073f, -0.06336766f, -0.00440198f, -0.00437009f, 0.11918362f, -0.00602027f, -0.08769258f, 
    -0.02587328f, 0.12714158f, 0.07816474f, -0.00758515f, -0.16174127f, -0.27145323f, -0.05607594f, -0.25674558f, 
    -0.06778577f, -0.02278911f, 0.05006655f, 0.05869346f, -0.28503561f, 0.13087197f, -0.11160091f, -0.16075893f, 
    0.01604995f, 0.20117086f, 0.04132721f, -0.00974588f, -0.05771208f, -0.04662998f, -0.05900764f, -0.03269846f, 
    0.14331643f, 0.09806308f, 0.09583453f, 0.15870644f, 0.75592661f, -0.18085097f, 0.27643219f, -0.04913700f, 
    -0.18679726f, 0.00079399f, 0.07995511f, -0.09319156f, -0.13330294f, 0.22315452f, 0.11953445f, 0.01771282f, 
    0.09152801f, -0.06984744f, 0.06249575f, -0.25665739f, 0.04143704f, -0.02321250f, 0.06593824f, 0.05466891f, 
    -0.31917733f, 0.22498801f, -0.38225988f, -0.01037541f, -0.18449408f, -0.18994015f, 0.16520591f, -0.01874706f, 
    -0.28657722f, 0.10042228f, 0.20844974f, -0.13153434f, 0.01879409f, -0.11704866f, 0.03064846f, -0.25806138f, 
    0.01509498f, 0.05796023f, 0.00861614f, -0.07640606f, -0.35511211f, -0.05657488f, -0.29719710f, -0.17403856f, 
    0.16780692f, 0.17318580f, -0.01970300f, 0.05599953f, -0.10992198f, -0.05354597f, 0.11348537f, -0.04613258f, 
    0.33516914f, 0.00205332f, -0.09558161f, 0.01825310f, -0.05705116f, 0.27154124f, -0.10123752f, 0.06033738f, 
    0.15002380f, -0.01813939f, 0.03113819f, 0.11725716f, -0.00309043f, -0.22950809f, -0.01903627f, -0.14033447f, 
    -0.10057254f, 0.07567032f, 0.31799147f, -0.12213136f, 0.16817051f, -0.04932217f, 0.13285483f, -0.05566639f, 
    0.22810651f, -0.11605601f, -0.01361280f, 0.18720384f, 0.01561525f, -0.28742293f, -0.19936682f, -0.20054452f, 
    0.26939043f, 0.13517939f, 0.00543622f, -0.03923485f, -0.06011844f, 0.01656605f, 0.09963378f, -0.04565717f, 
    0.00147021f, 0.01142741f, 0.11389631f, -0.27366298f, -0.33244371f, 0.16983855f, 0.22090787f, -0.10592017f, 
    0.20782441f, 0.08006006f, -0.13285774f, -0.04337803f, 0.10404430f, -0.38678068f, 0.11665811f, 0.11650616f, 
    -0.08016049f, 0.04136670f, 0.05980881f, 0.01147837f, 0.08596549f, -0.09856913f, -0.05066244f, 0.34605458f, 
    0.02338492f, -0.02839353f, -0.03107885f, 0.18976752f, -0.15227525f, -0.03676362f, -0.19462521f, -0.24211676f, 
    0.19916065f, 0.10694382f, 0.07987937f, -0.15450174f, -0.03944800f, -0.10280332f, 0.18633986f, -0.11971127f, 
    0.07924577f, 0.16045590f, 0.04350554f, -0.15228947f, -0.23838127f, 0.04883861f, 0.05793124f, -0.09068120f, 
    -0.93369454f, -0.57387489f, -1.20021713f, -0.52619171f, 0.11821748f, -0.42004675f, 0.31043220f, -0.31926098f, 
    0.07256889f, -0.51782846f, 0.07426763f, -0.09261859f, 0.05030549f, -0.03425562f, 0.11655271f, 0.01957157f, 
    -0.06530524f, 0.11759559f, 0.21332684f, 0.10440265f, -0.32616708f, -1.71781969f, -1.34471107f, -0.27882308f, 
    0.57845020f, -0.06284411f, 0.08091304f, 0.02069292f, -0.24154322f, -0.60497975f, 0.01448866f, -0.01354265f, 
    -0.04681210f, -0.10466713f, 0.08059929f, 0.00399875f, 0.03828334f, 0.10080051f, 0.25736874f, 0.08999304f, 
    -0.45940536f, -0.47392249f, -0.72611916f, -0.12649637f, 0.60125113f, -0.09954825f, 0.36946693f, 0.06215220f, 
    -0.27352080f, 0.22206376f, 0.11902309f, 0.06353107f, 0.08034220f, 0.27545711f, 0.00363523f, -0.14092153f, 
    0.01334565f, -0.18604578f, 0.35597274f, -0.00024042f, -1.61306071f, -0.85259533f, -0.23608282f, -0.21070968f, 
    -0.19409117f, -0.15032287f, -0.01956291f, -0.30939206f, -0.15861012f, -0.58179802f, -0.01157192f, 0.00377875f, 
    -0.05645049f, 0.02645932f, 0.02687644f, -0.01597714f, -0.03839268f, 0.15604363f, -0.03661545f, -0.10868897f, 
    -0.41643754f, 0.46665648f, 0.12982441f, 0.02575005f, 0.60009503f, -0.05400383f, 0.02404067f, -0.02594179f, 
    0.29006109f, -0.00088428f, 0.13172857f, 0.19604215f, 0.20040214f, -0.02965354f, -0.12621415f, 0.01995195f, 
    0.07554700f, 0.11878380f, 0.13587931f, -0.01230485f, 0.21176869f, 0.37287405f, -0.20906101f, -0.27724248f, 
    0.02537992f, -0.01446241f, -0.04979246f, 0.01043952f, -0.03574434f, 0.13236824f, -0.01582018f, 0.05642809f, 
    0.24564241f, -0.17490171f, -0.07477369f, 0.04370450f, -0.07870460f, -0.04149136f, -0.09885306f, 0.00283694f, 
    -0.79467177f, 0.64052433f, 0.68999785f, -0.07782746f, 0.21726473f, -0.11949234f, -0.11439332f, -0.08163609f, 
    -0.03283639f, 0.04136823f, -0.09341519f, 0.19940645f, 0.05556962f, 0.13407695f, 0.08810990f, 0.00339611f, 
    -0.00171885f, -0.02026868f, -0.07888130f, -0.07165604f, -0.16547075f, -1.02625489f, -1.22016478f, -0.27084127f, 
    0.10628147f, -0.03666221f, -0.30932701f, -0.34967512f, -0.01627068f, -0.15237144f, 0.02994892f, 0.04302970f, 
    0.00348375f, -0.04916783f, -0.22577317f, -0.13737617f, -0.01295290f, 0.33133069f, 0.01280655f, -0.06645750f, 
    -0.64138329f, 0.75848705f, 0.43545023f, -0.10823972f, -0.06815674f, -0.24544139f, -0.08875474f, -0.07062437f, 
    -0.14560412f, 0.22117688f, -0.18676031f, 0.13406274f, -0.05729069f, 0.14530654f, 0.05109185f, -0.01214861f, 
    -0.04783266f, -0.12577783f, 0.06516562f, -0.02529949f, -0.35323301f, -0.35475561f, -0.32035935f, 0.40978599f, 
    -0.24343733f, -0.03364221f, 0.29909337f, 0.09168969f, 0.04897298f, -0.12401142f, 0.14679913f, -0.04821011f, 
    -0.01314168f, 0.08104106f, 0.06335597f, 0.12961201f, 0.13321280f, 0.38364983f, 0.04471246f, 0.19249590f, 
    -0.29899207f, 0.46391970f, 0.21358700f, 0.30772641f, -0.13154522f, -0.28705817f, 0.03218648f, -0.03505530f, 
    -0.01286722f, 0.51261985f, -0.07140847f, -0.04348172f, 0.26649237f, -0.18729956f, 0.06722322f, 0.02994171f, 
    0.05544624f, -0.09685745f, 0.17284790f, -0.13442464f, 0.00254239f, 0.35508084f, 0.04418036f, -0.10768805f, 
    0.14035824f, 0.05882600f, 0.01100045f, -0.08967263f, -0.11129460f, 0.02680098f, 0.00995662f, 0.11634371f, 
    0.29677123f, 0.10651312f, 0.02141147f, 0.04103814f, -0.18113539f, -0.07021628f, -0.14375088f, -0.02618442f, 
    -0.17880012f, -0.26100910f, -0.00794573f, -0.00138348f, -0.06624410f, -0.01625083f, -0.05317484f, -0.04243734f, 
    -0.05505199f, -0.11741606f, 0.03451009f, -0.15336604f, -0.14714426f, 0.14072998f, -0.09886174f, 0.00571068f, 
    -0.15496367f, -0.03070822f, -0.15373273f, -0.10271310f, -0.20732060f, 0.14047731f, -0.08327269f, -0.34620619f, 
    -0.13212977f, 0.01202734f, 0.01681176f, 0.11835703f, -0.06730900f, -0.02405153f, -0.03663651f, -0.05914124f, 
    0.08706727f, 0.02327464f, -0.03711048f, 0.08182805f, 0.21679588f, -0.31722331f, -0.02522891f, 0.28199223f, 
    0.06508511f, -0.05600230f, -0.06519688f, 0.02849884f, 0.10339672f, -0.03257984f, 0.01228782f, 0.05020748f, 
    0.10935851f, -0.10577437f, 0.18888149f, -0.11670286f, -0.11191658f, 0.16132702f, -0.04303676f, -0.15745674f, 
    0.10286023f, -0.05681814f, -0.07605603f, -0.00526406f, 0.04714443f, -0.24880174f, -0.12473290f, -0.14197586f, 
    -0.15476722f, 0.10832187f, 0.03275268f, 0.02920650f, -0.12626857f, -0.01302830f, -0.06446938f, -0.20315076f, 
    -0.03544413f, -0.19519575f, -0.10992211f, -0.01313191f, -0.08237692f, -0.00941920f, -0.17533883f, -0.05376533f, 
    -0.47023818f, -0.47932193f, -0.08229694f, 0.81405669f, -0.10886589f, 0.08725270f, 0.07949495f, 0.07183787f, 
    -0.04766246f, 0.22136508f, 0.03581794f, -0.01487418f, -0.14760284f, -0.11861878f, -0.08753511f, 0.01185228f, 
    0.22999671f, -0.06581901f, 0.15271159f, 0.07257248f, -0.68530631f, -1.31436896f, -0.25678235f, 0.77938771f, 
    -0.43398049f, -0.06621200f, -0.01756245f, -0.14567515f, 0.05997325f, 0.16181345f, -0.05430359f, -0.00398206f, 
    -0.06300355f, 0.00255027f, -0.02735168f, -0.07580967f, 0.01131156f, -0.25733721f, 0.13631672f, -0.31390172f, 
    0.29510933f, 0.42779946f, -0.64722747f, 0.38561299f, -0.85040176f, -0.01737491f, 0.23960893f, -0.05891949f, 
    -0.05219434f, 0.08172842f, -0.31041333f, 0.24570785f, -0.12397388f, -0.01541521f, -0.15604645f, -0.21399760f, 
    -0.00151475f, 0.06588173f, -0.18893568f, -0.14350410f, 0.34615776f, -0.83229399f, 0.34444609f, 0.23804504f, 
    -0.08348381f, -0.01949724f, 0.11352062f, 0.13800924f, 0.06583383f, 0.06797604f, 0.06499570f, -0.00054351f, 
    0.02247001f, -0.05412608f, -0.02118095f, 0.05553047f, 0.04632243f, -0.17446846f, -0.05580793f, 0.11337444f, 
    -0.30999860f, -0.59317636f, -0.82134831f, -0.12910987f, 0.01662064f, 0.12524393f, -0.04225378f, 0.40499610f, 
    0.07558783f, 0.16672119f, -0.05482349f, 0.08340971f, -0.18403041f, -0.19302651f, 0.00294582f, -0.04926484f, 
    -0.11030887f, -0.07406240f, 0.17177148f, 0.19909456f, 0.07609730f, 0.10910138f, -0.02360117f, -0.04501791f, 
    -0.11130470f, 0.00039089f, -0.07034215f, 0.12601706f, -0.08355625f, -0.00798500f, -0.10332127f, -0.00367621f, 
    0.02479822f, -0.03689812f, -0.03550468f, 0.05816094f, -0.00757306f, -0.07643878f, 0.02626477f, 0.06059341f, 
    0.48137885f, -0.54015791f, 0.02775432f, -0.17023754f, -0.16807197f, -0.06847022f, -0.11390971f, 0.02480781f, 
    0.12793608f, -0.18215244f, 0.05808298f, 0.06385412f, 0.12128063f, 0.08419146f, 0.12971868f, -0.03924464f, 
    0.05349387f, -0.00314686f, 0.10766533f, -0.02236140f, 0.39557984f, -0.94055623f, 0.41447675f, -1.17747355f, 
    -0.04088011f, -0.24097039f, 0.09009423f, -0.13056847f, 0.46566528f, 0.02005168f, 0.05524825f, 0.02574634f, 
    -0.03989493f, -0.13078021f, -0.06246057f, -0.05229194f, 0.05975026f, -0.10341485f, -0.03156197f, -0.07135898f, 
    1.01161742f, -0.84359717f, -0.35573232f, -0.26016745f, -0.19335911f, 0.20743012f, -0.00653287f, -0.06015464f, 
    -0.08250745f, -0.04821141f, 0.10458932f, -0.03748298f, 0.09235629f, 0.03478459f, -0.02257921f, 0.01921138f, 
    -0.06004695f, 0.09061965f, -0.00608928f, -0.05666553f, -0.53240269f, -0.75773406f, 0.84224051f, -0.24792399f, 
    0.55179459f, 0.06933267f, -0.30629048f, 0.22863875f, -0.27789098f, 0.01020041f, -0.00125629f, -0.00980735f, 
    -0.09172093f, 0.07637803f, -0.07492705f, 0.15760548f, 0.15298750f, -0.14442287f, -0.00964295f, -0.10761288f, 
    1.21024692f, -0.42023644f, -0.34893864f, -0.20443706f, -0.40306237f, 0.14984551f, -0.15625730f, -0.16137053f, 
    -0.00820338f, -0.00318189f, 0.09539842f, 0.04763656f, -0.11084267f, 0.00933325f, 0.12459111f, 0.02635194f, 
    -0.03063299f, 0.05505180f, 0.10845056f, -0.02328905f, -0.10116774f, 0.09665270f, 0.01137908f, 0.06528087f, 
    -0.09025545f, 0.05797942f, -0.02751822f, 0.08367122f, -0.04330586f, -0.02039377f, -0.23677541f, -0.12004758f, 
    0.00363386f, -0.06794026f, -0.18185399f, -0.03228747f, -0.02623460f, 0.07082430f, 0.01471678f, 0.02473886f, 
    0.11369453f, 0.19669887f, 0.19857495f, -0.15724136f, -0.03543676f, -0.02914652f, 0.13801332f, 0.02188735f, 
    0.01633673f, -0.05289107f, -0.15237951f, -0.18113324f, 0.08395119f, -0.03470849f, 0.03454170f, -0.16796045f, 
    -0.03018341f, -0.01898891f, -0.02448162f, -0.02563641f, 0.03709120f, -0.04084516f, -0.08200409f, 0.25154868f, 
    -0.10128190f, -0.01082605f, 0.03657090f, 0.11470803f, -0.16679205f, -0.03924926f, 0.04052611f, 0.03968415f, 
    0.07022871f, 0.03168876f, -0.02377249f, 0.03721001f, -0.16102576f, -0.42194355f, 0.10214409f, 0.07247237f, 
    0.04195064f, 0.15275738f, 0.06239704f, -0.08509221f, -0.09676247f, -0.12929364f, 0.04487433f, 0.07928992f, 
    -0.07012658f, -0.06659961f, -0.04662490f, -0.02225376f, 0.03463132f, -0.08244947f, -0.15338659f, -0.10023160f, 
    -0.11901919f, 0.05316642f, -0.04499708f, -0.04851647f, 0.03722264f, 0.21797216f, 0.26581353f, -0.17278422f, 
    -0.02158234f, -0.05867909f, -0.01827213f, -0.03674287f, 0.00823566f, -0.00622402f, 0.04140370f, -0.04821383f, 
    0.11808936f, -0.11148413f, -0.09913553f, -0.00092814f, -0.08041759f, -0.00406857f, 0.05070795f, -0.05605013f, 
    0.15290888f, -0.51411372f, -0.24537082f, -0.33080670f, -0.22281376f, 0.12586071f, -0.23056401f, -0.04839158f, 
    -0.29031029f, -0.60737622f, 0.03749504f, 0.00181085f, 0.09497931f, 0.04667857f, 0.20435114f, 0.13974683f, 
    0.04303505f, 0.16006541f, -0.21039218f, -0.44993418f, 0.60919988f, 0.01224095f, 0.00149705f, -0.31201670f, 
    -0.10007475f, 0.15922180f, -0.12592554f, -0.02971617f, -0.12096027f, -0.37054259f, -0.03033791f, 0.15227447f, 
    0.08680449f, -0.06407186f, 0.01183029f, 0.07850730f, 0.14362873f, 0.24190772f, -0.01088091f, 0.04417803f, 
    0.97423208f, 0.48637474f, -0.04469465f, -0.25595677f, -0.22722420f, 0.19645232f, -0.08077280f, 0.05368712f, 
    0.25406754f, -0.17890494f, 0.12633267f, 0.00110687f, 0.09245536f, 0.07139489f, 0.05564833f, 0.02689337f, 
    0.08667179f, -0.13464716f, 0.15443251f, -0.17220163f, 0.16246891f, -0.56286472f, -0.60039848f, -0.20628195f, 
    -0.26857266f, -0.04251200f, -0.02920092f, -0.06178433f, 0.09950255f, -0.02368341f, -0.03011366f, 0.11475151f, 
    -0.07454898f, 0.05522389f, 0.02622998f, 0.02749567f, 0.16190630f, 0.09320963f, 0.16206539f, 0.10485081f, 
    -0.18363714f, -0.70113569f, 0.18911383f, 0.16930090f, 0.34259874f, -0.23633584f, -0.06085999f, 0.08456060f, 
    -0.12151828f, -0.05299050f, 0.09763678f, -0.07341623f, 0.08459990f, 0.02615049f, -0.11464754f, -0.06678747f, 
    -0.04921168f, -0.05175045f, -0.16823158f, -0.18566911f, -0.29672837f, -0.07599761f, 0.14312416f, -0.03358056f, 
    0.02808516f, -0.00653060f, 0.07893606f, -0.01727687f, -0.08669230f, 0.10816707f, 0.22308010f, 0.01443826f, 
    0.07776226f, 0.26156443f, 0.03606736f, -0.16818152f, 0.09371711f, 0.08002954f, 0.09649981f, 0.12845123f, 
    -0.14144227f, -0.59907734f, -0.62749082f, -0.04207158f, 0.10193488f, -0.22238185f, 0.06727510f, 0.13625978f, 
    0.23053063f, 0.20296757f, 0.07357906f, -0.28858230f, 0.01514287f, -0.13575214f, -0.09162942f, -0.07189116f, 
    0.02962334f, 0.05325644f, 0.07474320f, -0.05224329f, 0.00384742f, -0.45392576f, -1.37546396f, -0.60401034f, 
    0.04688274f, -0.03368273f, -0.17412277f, 0.31072494f, -0.07369175f, -0.21188533f, -0.04878313f, -0.13618362f, 
    -0.03371695f, -0.00766553f, 0.14422536f, 0.04115748f, -0.05609651f, 0.06763408f, -0.06016316f, -0.23142830f, 
    0.20154327f, -0.81889570f, -0.75564981f, -0.31657150f, -0.13155198f, -0.08004924f, 0.05438229f, 0.10744468f, 
    0.08364142f, 0.28864577f, 0.04868039f, -0.05182211f, -0.21715190f, -0.04455960f, -0.10423461f, 0.07015776f, 
    0.05731566f, 0.00219688f, 0.06344695f, -0.01205066f, 1.06198204f, -0.62949455f, 0.34807113f, 0.42609817f, 
    0.45941362f, 0.30331600f, 0.28940004f, -0.07532953f, 0.10665897f, 0.29125369f, 0.01086302f, 0.01996614f, 
    0.05018954f, 0.02952797f, 0.03019558f, -0.11570658f, -0.27947080f, -0.07151967f, -0.58009022f, -0.30228487f, 
    0.10123688f, -1.10005653f, -0.93103868f, -0.35074800f, 0.02939934f, 0.02494457f, 0.09315589f, 0.43343511f, 
    0.37688610f, 0.05914364f, 0.10319073f, -0.21612066f, -0.05627194f, 0.00935887f, -0.01044064f, -0.00512399f, 
    -0.08657540f, -0.07650467f, -0.10807912f, -0.03613923f, -0.53070188f, -0.20781128f, 0.17827241f, -0.01188802f, 
    -0.06934047f, -0.16849546f, 0.06205246f, 0.01458328f, -0.03542776f, 0.00472300f, 0.10987311f, 0.22766437f, 
    0.08836300f, 0.23822165f, 0.14719611f, 0.02396623f, 0.08875068f, 0.04068846f, 0.17778093f, 0.11316088f, 
    -0.07370658f, -0.10653394f, -0.12252882f, -0.15594400f, -0.25575274f, -0.22913760f, -0.13223410f, -0.08595049f, 
    -0.11144400f, -0.05521150f, 0.01827763f, 0.16439679f, -0.05133513f, 0.06604786f, 0.06129774f, 0.03958639f, 
    0.27133548f, 0.10919143f, 0.10114864f, 0.18326689f, -0.23546419f, 0.12677035f, 0.38666865f, 0.11811849f, 
    -0.02482588f, -0.04081430f, -0.05596409f, -0.10370331f, -0.09012888f, -0.01844164f, -0.02504622f, -0.09324042f, 
    -0.08151226f, -0.04966584f, -0.03142424f, -0.20041579f, -0.09864824f, -0.18316106f, -0.45410454f, -0.21910192f, 
    0.02377046f, -0.05782652f, 0.13668123f, -0.03477298f, -0.13265489f, 0.03337971f, -0.05024360f, -0.21322387f, 
    -0.04666514f, -0.05725453f, -0.10695215f, 0.17882301f, -0.05074369f, 0.08188193f, 0.13511230f, 0.04375118f, 
    0.33475715f, 0.10873286f, 0.06380794f, 0.15593441f, -0.58788639f, -0.00844307f, 0.21140158f, -0.06104534f, 
    -0.19906539f, -0.02109325f, -0.02525830f, 0.08719243f, 0.08778670f, -0.09067316f, -0.12028208f, -0.19511591f, 
    -0.08170607f, 0.01816639f, -0.00322773f, 0.08718028f, 0.18018724f, 0.00755074f, -0.08468858f, 0.17676808f, 
    -0.25216454f, 0.04833462f, -0.39569411f, 0.20933662f, -0.09854122f, 0.12097249f, -0.44614828f, 0.05765908f, 
    -0.15273872f, 0.39455321f, 0.03518592f, 0.13758591f, 0.01804431f, 0.09210964f, -0.05495058f, 0.04934685f, 
    0.11126861f, 0.33134049f, 0.20673352f, 0.37187165f, 0.29848194f, 0.39395410f, -0.99980587f, 0.16014619f, 
    -0.26132882f, 0.10292838f, 0.04363125f, 0.37118694f, -0.06864324f, 0.20905611f, 0.07033558f, -0.02044957f, 
    -0.01868663f, -0.06482153f, 0.00271702f, 0.13222995f, -0.07940967f, -0.05613811f, 0.23851623f, -0.17309551f, 
    -1.26581311f, -0.17625131f, -1.42297816f, 0.27414310f, -0.56237388f, -0.00788492f, -0.08047824f, -0.20454930f, 
    0.16613442f, 0.04034478f, -0.01013536f, -0.11730892f, 0.05358912f, -0.22843482f, -0.06477861f, 0.07465361f, 
    -0.14796479f, -0.16508926f, 0.06949256f, -0.17256120f, -0.64436686f, 0.04001519f, -0.14230599f, 0.04154719f, 
    -0.16001463f, -0.39118439f, -0.05134384f, 0.26297015f, 0.09853899f, 0.26966333f, -0.00489040f, -0.07529692f, 
    -0.01340551f, -0.12332393f, -0.05845879f, 0.03181931f, -0.08880535f, 0.10799894f, -0.02554605f, -0.25734344f, 
    0.18269889f, 0.01459580f, 0.28457212f, 0.37997666f, -0.45258510f, 0.04598780f, -0.33856988f, -0.32627660f, 
    0.15351470f, -0.39457548f, -0.16366285f, 0.02306435f, 0.03065952f, 0.01071825f, 0.08149067f, 0.18679938f, 
    0.00931065f, 0.01130630f, -0.00025923f, 0.21293996f, -0.31065091f, -0.04335548f, 0.55124176f, -0.40974596f, 
    -0.12766470f, 0.12521550f, -0.06206388f, 0.07606095f, -0.17031892f, -0.08893111f, 0.03405419f, -0.10803109f, 
    -0.08206375f, -0.16618271f, 0.21186227f, -0.03022973f, -0.02338438f, -0.12369493f, -0.06012471f, -0.13828191f, 
    0.29414827f, 0.06291718f, 0.41344219f, 0.11155763f, -0.52170533f, 0.03265394f, 0.08969553f, -0.54171628f, 
    0.04848943f, -0.09037410f, 0.05488320f, -0.09552879f, 0.05945808f, 0.16038103f, 0.03831773f, 0.05998960f, 
    0.02855921f, -0.05984253f, 0.00069838f, 0.05109802f, 0.06608862f, -0.51193142f, -0.05678673f, 0.22659637f, 
    -1.00152385f, -0.40235716f, 0.07597688f, -0.15722767f, 0.15497619f, 0.14361763f, 0.07181886f, -0.03691753f, 
    0.18030354f, 0.09123688f, -0.02911434f, -0.01900023f, 0.11984765f, 0.11275189f, 0.06393503f, 0.08285487f, 
    0.00729573f, 0.30543098f, 0.20200679f, 0.42774838f, -0.58135128f, -0.00204044f, -0.31736025f, -0.37521905f, 
    -0.04552031f, -0.21482883f, 0.21770079f, -0.09579226f, 0.16227432f, 0.00139539f, 0.03381393f, 0.00594779f, 
    -0.11234975f, -0.05849692f, -0.05570188f, -0.10080463f, -0.00897016f, -1.08302522f, -0.20681369f, -0.69583094f, 
    0.21672797f, 0.39426288f, -0.32195923f, 0.01398858f, 0.06826213f, 0.04996943f, 0.03201443f, -0.04360667f, 
    0.13826153f, -0.01192865f, -0.03414268f, -0.03158928f, -0.06749381f, -0.16299000f, 0.03540681f, 0.13844936f, 
    -0.20215474f, 0.33888486f, 0.81585401f, 0.59250683f, -0.74020696f, 0.28948316f, -0.18832201f, -0.39064410f, 
    -0.09524207f, -0.35437992f, 0.24133937f, -0.04025996f, 0.17873287f, 0.02833438f, 0.16674618f, 0.05330786f, 
    -0.04358481f, -0.28417885f, 0.11112542f, 0.17055458f, 0.01711965f, 0.06500211f, 0.55779648f, -0.49693230f, 
    -0.00859406f, 0.04693943f, -0.22385685f, -0.01604183f, -0.05828637f, -0.11008468f, -0.03370789f, 0.14085209f, 
    -0.14940108f, 0.21488409f, 0.04308494f, 0.06630516f, 0.00546596f, 0.08699880f, -0.16228440f, 0.05694519f, 
    0.07860545f, -0.28277925f, 0.02401759f, 0.07284634f, 0.15337181f, -0.14373764f, 0.15566702f, -0.10299657f, 
    -0.00601469f, -0.11961607f, 0.00951911f, 0.22785327f, 0.02276556f, -0.06583519f, 0.06965177f, 0.20077080f, 
    -0.01410756f, 0.05060000f, -0.26137379f, 0.01256659f, -0.07962677f, -0.32367918f, -0.52788812f, -0.28556910f, 
    0.34589103f, 0.10857306f, 0.03021150f, 0.17696202f, 0.01062094f, -0.11896108f, -0.06393231f, -0.02709509f, 
    -0.07322207f, -0.00957215f, -0.07566962f, 0.24106224f, 0.33253741f, -0.03663721f, -0.00438575f, -0.03916990f, 
    -0.05522162f, 0.05254542f, -0.26801193f, -0.11369673f, -0.04717309f, 0.08674885f, 0.32619411f, 0.10017252f, 
    -0.03601565f, 0.04953248f, 0.07147380f, -0.05449352f, -0.03539474f, -0.10461598f, -0.03091465f, 0.21688995f, 
    -0.09428003f, -0.04436892f, -0.11749944f, -0.10400450f, 0.01293795f, -0.57612354f, -0.19015633f, -0.07142577f, 
    0.30915442f, -0.11101753f, 0.32295799f, 0.33337015f, 0.18987630f, 0.18931581f, 0.00073672f, 0.04453427f, 
    -0.02012684f, -0.01286210f, -0.10322299f, 0.16251348f, 0.06936590f, 0.18859704f, -0.16772678f, 0.04235332f, 
    -0.25711381f, -0.25804436f, -0.23372583f, -0.13435169f, 0.06926011f, -0.09771501f, -0.06624019f, 0.37261581f, 
    0.08895210f, -0.20864923f, -0.10630168f, 0.13732970f, 0.06980209f, 0.03223134f, -0.08392116f, 0.25169146f, 
    -0.28119081f, -0.15223259f, -0.34023827f, -0.53117323f, -0.68680543f, -0.19992293f, -0.13645679f, 0.20805705f, 
    0.04383362f, -0.10065450f, -0.07495913f, 0.23982477f, -0.40993297f, 0.02685976f, -0.11071216f, 0.31551462f, 
    -0.01225180f, 0.32508609f, 0.04269367f, 0.17410493f, -0.09294934f, -0.03928985f, -0.00475259f, 0.03098580f, 
    0.53854722f, -0.27299914f, 0.52354491f, 0.03476569f, 0.25092891f, -0.29358429f, 0.00465098f, 0.18603846f, 
    0.02092818f, -0.11283486f, -0.20560777f, 0.05159175f, -0.21810281f, -0.06642798f, 0.17645569f, 0.05142715f, 
    -0.09343973f, 0.08364722f, 0.00334035f, -0.18044746f, -0.59763825f, 0.02778700f, -0.04298662f, -0.16838473f, 
    0.17267634f, 0.08428691f, 0.14419194f, 0.38162094f, 0.20872156f, -0.02504439f, -0.01081588f, -0.15458509f, 
    0.01501529f, -0.00234103f, -0.01879480f, 0.07782006f, 0.00784570f, -0.01242089f, 0.26590562f, 0.31341225f, 
    -0.25575256f, 0.34562916f, 0.00185107f, 0.19302988f, -0.03820862f, 0.16620813f, -0.18398669f, -0.05689558f, 
    0.08865943f, 0.02249805f, 0.01344503f, 0.00695136f, -0.09679575f, -0.26680067f, -0.06419047f, -0.09455299f, 
    -0.25151610f, -0.14404026f, -0.07423558f, -0.15200679f, -0.50402480f, -0.31658512f, 0.04636909f, -0.15210901f, 
    -0.29140711f, 0.03968713f, -0.01428810f, -0.36515096f, 0.34578541f, 0.07601125f, -0.13765323f, -0.07692260f, 
    0.20319445f, -0.03135903f, 0.17525007f, 0.14143074f, 0.03003629f, -0.00684872f, 0.17414679f, 0.22481401f, 
    0.05375133f, 0.50894892f, 0.01542133f, -0.03367344f, 0.21388796f, 0.03743708f, -0.08790071f, -0.19167614f, 
    -0.16019532f, 0.04142183f, -0.14638908f, 0.09308627f, -0.08396723f, -0.16968304f, -0.02111555f, 0.13025771f, 
    -0.02316834f, 0.02502531f, -0.08068565f, -0.03748928f, -0.46273890f, 0.04147841f, -1.44091034f, 0.12911230f, 
    0.13678530f, 0.07267863f, -0.12251379f, 0.16614826f, -0.20738843f, 0.20554027f, -0.01890424f, 0.07557818f, 
    -0.05579977f, -0.34829208f, -0.02712987f, -0.01280638f, -0.16572227f, -0.40616682f, 0.00903498f, -0.18312487f, 
    0.12802942f, -0.10795074f, 0.24456371f, 0.18325812f, 0.16020377f, 0.05526956f, 0.16813217f, -0.14183371f, 
    0.13481078f, 0.05471580f, -0.19210199f, 0.18170929f, 0.07693718f, -0.18851592f, -0.20128421f, 0.10297569f, 
    0.14077710f, -0.06289964f, 0.29623601f, 0.22506978f, -0.77222991f, 0.56262058f, 0.23838954f, 0.59144545f, 
    0.20026276f, 0.19538146f, 0.17899629f, 0.00594413f, 0.55263305f, -0.03479565f, -0.31080493f, 0.08796812f, 
    -0.03387834f, -0.08811674f, 0.08057628f, -0.10572437f, -0.11192513f, -0.22956240f, -0.24552836f, -0.06299348f, 
    -0.05287927f, -0.07239857f, 0.43369240f, 0.19213741f, 0.10829874f, -0.25580451f, 0.01648782f, -0.37075618f, 
    0.38499406f, 0.03823596f, -0.05582399f, -0.06871286f, -0.32933876f, -0.24221003f, -0.09269548f, -0.01779799f, 
    -0.23665346f, 0.13113865f, 0.05478359f, 0.16683072f, -0.20758738f, -0.12372629f, 0.22419441f, -0.23350564f, 
    -0.28569588f, 0.11954545f, -0.07610731f, -0.26073840f, 0.08791392f, 0.17743099f, -0.00399117f, -0.12555543f, 
    -0.02365246f, 0.05437354f, -0.09435017f, -0.35145116f, 0.06799883f, 0.00020725f, 0.30816698f, -0.02796929f, 
    -0.26385403f, -0.40076184f, -0.16245142f, 0.04817868f, -0.31769642f, 0.22114578f, -0.06441888f, 0.16669101f, 
    -0.33905697f, -0.03159681f, -0.05336312f, 0.12456212f, 0.02106173f, -0.00520641f, 0.01479896f, -0.16196086f, 
    0.41002414f, 0.18883793f, -0.00785750f, 0.26076803f, -0.26293331f, 0.00654726f, -0.00411731f, 0.04467792f, 
    0.02881048f, -0.13374381f, -0.04379565f, 0.01572390f, 0.14978586f, -0.13119052f, -0.23465054f, 0.18050829f, 
    -0.04169285f, -0.11854032f, 0.04368177f, 0.00406993f, -0.09505179f, -0.13824390f, -0.20757928f, -0.11638711f, 
    -0.27241504f, -0.17237310f, -0.02662570f, 0.39034000f, -0.12916315f, 0.21789673f, 0.01839198f, 0.25284243f, 
    -0.19828512f, 0.04170505f, -0.05449143f, 0.01421020f, 0.06040672f, -0.04911845f, -0.02493586f, -0.04776720f, 
    0.07912447f, 0.34511301f, 0.27930364f, -0.01526366f, 0.11953410f, -0.74290723f, -0.44613165f, 0.40606132f, 
    -0.54070193f, -0.37536949f, -0.40803742f, 0.01617642f, -0.17367724f, -0.15907010f, -0.20909555f, 0.16538365f, 
    -0.03256115f, -0.01160675f, 0.32940957f, -0.07467978f, 0.09742588f, 0.04363113f, 0.17353603f, 0.09652884f, 
    0.30524960f, -0.59043348f, -0.13229251f, -0.52526861f, 0.32734862f, -0.18859255f, -0.65874809f, -0.22935516f, 
    -0.02492643f, -0.21044624f, -0.04101721f, 0.10900342f, 0.08067763f, -0.03075038f, -0.03626691f, 0.00164932f, 
    -0.01709536f, -0.22363669f, 0.20296210f, -0.04223045f, 0.51112843f, -0.28967527f, 0.23877874f, 0.05738643f, 
    0.16666606f, -0.18867856f, -0.51984590f, -0.25727084f, -0.00926462f, -0.34018728f, 0.00225129f, -0.01838397f, 
    -0.07181957f, -0.05961660f, -0.09596920f, 0.09336487f, 0.00037411f, -0.08676014f, 0.09922831f, 0.11123596f, 
    -0.20946507f, -0.35190615f, 0.28766990f, -0.57228470f, 0.55798292f, 0.23557831f, 0.29104286f, 0.40074390f, 
    -0.14701121f, 0.11434160f, 0.01311226f, 0.04812490f, 0.01369240f, 0.11214340f, 0.03328507f, -0.00811718f, 
    0.16444129f, -0.00323564f, -0.11248512f, 0.22753602f, -0.29384753f, -0.38117713f, -0.26348212f, -0.00704746f, 
    0.01922483f, 0.11838445f, -0.17890412f, -0.24143291f, -0.37813547f, -0.05214423f, 0.13670018f, -0.04637599f, 
    -0.07680946f, -0.03705783f, 0.03313813f, 0.12911040f, -0.01034547f, -0.08996231f, -0.02854269f, -0.19305073f, 
    -0.95223081f, -0.25095779f, -0.29093176f, 0.26388797f, -0.56493407f, 0.23486023f, 0.24226190f, 0.06910398f, 
    0.07568745f, -0.03165835f, -0.16259308f, -0.14193678f, 0.26833189f, 0.32174939f, 0.01551051f, 0.19102184f, 
    0.11741166f, 0.13163444f, 0.02519258f, 0.25365257f, 0.16325225f, -0.19476826f, -0.16158068f, 0.76105255f, 
    0.09333198f, -0.25795507f, 0.39536628f, -0.09905773f, 0.50896490f, -0.20040742f, -0.24129227f, -0.09196606f, 
    0.11098691f, 0.11028197f, 0.08125700f, -0.03267990f, -0.06456992f, 0.15342256f, -0.13993315f, 0.06181991f, 
    -0.97574651f, 0.11332487f, -0.63259155f, 0.69482899f, -0.32752055f, -0.01466427f, -0.01893990f, -0.02831035f, 
    0.07360049f, 0.05864661f, -0.12238287f, -0.10782768f, -0.01721573f, -0.17739171f, -0.07916846f, 0.07998093f, 
    -0.02804010f, -0.17512880f, -0.12413292f, -0.02985572f, -0.33062407f, -0.21210136f, -0.14322260f, 0.09802189f, 
    -0.58187300f, -0.01038678f, 0.10308538f, 0.34806538f, -0.16707818f, 0.10500117f, -0.09596967f, 0.09553853f, 
    0.26182196f, 0.04222779f, 0.12859266f, 0.25536108f, 0.05987207f, 0.12091798f, 0.13932344f, 0.13535775f, 
    -0.00211610f, -0.44193435f, 0.22339052f, -0.02801678f, -0.10991846f, 0.04630217f, -0.13148390f, -0.07099310f, 
    -0.04863055f, 0.01018529f, 0.05977943f, 0.01214428f, -0.08691336f, -0.26719558f, -0.02672822f, -0.13287252f, 
    -0.08993018f, -0.14787473f, -0.07009178f, -0.26758382f, -0.55756801f, 0.04254359f, -0.96899742f, 0.35205817f, 
    -0.16767304f, 0.05260257f, -0.02463540f, 0.13833317f, 0.25692385f, -0.18158200f, -0.25196654f, 0.06135754f, 
    -0.07549564f, 0.06139832f, 0.06610046f, 0.39348745f, -0.13027811f, 0.30230924f, 0.43746090f, 0.10290711f, 
    0.34456494f, -0.45817125f, 0.35392359f, 0.11947601f, -0.14226530f, 0.30913803f, 0.10601307f, -0.08807896f, 
    -0.09838030f, -0.07986262f, -0.15669900f, 0.18067093f, 0.19669387f, 0.25856003f, -0.23993567f, -0.21217217f, 
    -0.00560482f, 0.29087514f, 0.11307359f, 0.04742923f, -0.31401226f, -0.18471280f, -0.58438259f, 0.56167418f, 
    0.17095517f, -0.18667273f, 0.21159910f, -0.12796791f, 0.29382485f, -0.07168240f, -0.15000032f, -0.06859859f, 
    0.05411222f, 0.02410211f, 0.14333591f, 0.04992440f, -0.03544902f, 0.01471838f, -0.35188863f, 0.00667437f, 
    -0.35448474f, 0.19475052f, -0.13305731f, 0.21666346f, -0.28699237f, -0.10433497f, 0.07799503f, 0.20034795f, 
    -0.16556421f, 0.03231759f, -0.09340394f, 0.02689323f, -0.18712355f, 0.15992142f, 0.15434514f, -0.02937841f, 
    -0.15232819f, -0.12556151f, 0.00341843f, -0.30587548f, 0.39317122f, -0.03205682f, 0.13719301f, 0.24562831f, 
    0.01543273f, -0.11759580f, -0.03203705f, -0.10414147f, 0.05828647f, -0.33527359f, -0.17618139f, -0.27544910f, 
    -0.03037537f, -0.15535539f, -0.10168048f, 0.27166295f, 0.10326041f, -0.02148933f, -0.02292563f, -0.01492180f, 
    0.36859187f, 0.06004879f, 0.31146201f, 0.02618910f, -0.00796643f, 0.04872838f, 0.21619433f, -0.21475048f, 
    0.13901924f, 0.06817988f, -0.20258558f, 0.16807655f, -0.15240161f, -0.01025626f, 0.02165938f, -0.23210298f, 
    0.00935271f, 0.09883034f, -0.11376392f, -0.09427240f, 0.21983814f, 0.31069008f, 0.12824807f, 0.06484444f, 
    -0.31377888f, -0.22147700f, 0.13532436f, -0.03305179f, -0.02642051f, 0.20949531f, -0.27084148f, 0.09755715f, 
    -0.02493240f, 0.08158095f, -0.18003063f, 0.03840981f, 0.22404060f, 0.19541301f, -0.09445713f, -0.11228590f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.32424420f, 0.20787847f, 0.05751459f, -0.15569779f, -0.12454633f, 0.10906372f, -0.00642734f, -0.11911068f, 
    0.02887707f, 0.03561657f, 0.07172588f, -0.00839305f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
