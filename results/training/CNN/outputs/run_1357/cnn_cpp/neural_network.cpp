#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.10526862f, -0.11669707f, -0.75881523f, -0.70467788f, -0.68153292f, -0.13121705f, 0.28511345f, 0.24779445f, 
    0.07802977f, -0.14812852f, -0.17750724f, 0.25583178f, -0.28909335f, -0.46674338f, -0.19378379f, -0.59453684f, 
    -0.07503453f, -0.11788070f, 0.12218983f, -0.43006703f, 0.28260502f, 0.27999076f, -0.06328300f, 0.28308907f, 
    0.32138976f, 0.76315063f, 0.58325464f, -0.85039169f, 0.31229627f, -1.04709768f, -0.11482672f, -0.35088065f, 
    0.00212251f, 0.41257089f, 0.64371407f, 0.26991481f, -0.09961466f, -0.28760028f, 0.06450301f, -0.35343692f, 
    0.07518426f, -0.13157283f, -0.03000645f, -0.07232104f, 0.20931353f, -0.19552630f, 0.03611290f, 0.06281448f, 
    -0.00607905f, 0.32930282f, 0.03358387f, -0.13949907f, 0.42823628f, 0.23655154f, 0.04886135f, -0.07729717f, 
    -0.23337561f, -0.48184061f, 0.19259393f, 0.33151135f, -0.29071018f, -0.23810238f, 0.48395583f, -0.09664834f, 
    -0.22185545f, 0.22853744f, -0.24279144f, 0.31568944f, -0.15203737f, -0.00739637f, 0.06007230f, -0.24911770f, 
    -0.11426547f, 0.24417402f, -0.17539784f, 0.77649939f, 0.47381604f, 0.37658674f, -0.16711155f, 0.15573560f, 
    -0.13920772f, 0.23432823f, -0.03240220f, 0.08354235f, 0.31985503f, -0.01824091f, 0.13604349f, 0.01653438f, 
    -0.01937822f, 0.10806436f, 0.00717209f, -0.21298455f, -0.15631375f, 0.33974448f, -0.32393169f, 0.00899187f, 
    0.21505177f, 0.04311221f, -0.06236640f, 0.08867797f, 0.68342054f, -0.04840768f, -0.45563549f, -0.43176857f, 
    -0.29820818f, 0.55953473f, 0.25183362f, 0.21023272f, -0.01762093f, 0.12125082f, -0.13887879f, 0.17507941f, 
    -0.12768540f, 0.04346059f, 0.30457672f, 0.00393990f, 0.11088321f, 0.19736946f, -0.18171111f, -0.12555926f, 
    0.19990373f, -0.22709531f, -0.01904505f, 0.06745350f, 0.03113490f, 0.46507913f, 1.00152671f, 0.20472030f, 
    -0.80775803f, -0.35948715f, 0.15159269f, -0.12966867f, 0.18674882f, -0.37158459f, -0.31339180f, 0.07802087f, 
    -0.12451698f, 0.09451140f, 0.10216459f, 0.01924318f, 0.23117127f, -0.14067718f, -0.34044012f, 0.35215670f, 
    -0.26802567f, -0.01640933f, 0.19451539f, -0.08238217f, -0.00789918f, 0.14943798f, -0.53151447f, -0.22625796f, 
    0.25093010f, 0.38198203f, 0.50365901f, 0.31345475f, 0.69436532f, 0.14398554f, -0.19631630f, -0.18063043f, 
    -0.12874240f, 0.22362716f, 0.00562856f, -0.32075965f, 0.05332618f, 0.08147677f, -0.18023115f, 0.06708702f, 
    0.14824164f, 0.30764601f, -0.13130054f, -0.15039402f, 0.01379245f, 0.04031378f, -0.11199749f, -0.72817284f, 
    -0.30428389f, -0.00297705f, -0.02801760f, -0.10783108f, -0.40905216f, -0.55377936f, -0.54359907f, 0.01334486f, 
    -0.42186785f, -0.21359242f, 0.05619519f, 0.01966264f, 0.01145991f, -0.71531117f, 0.08313616f, -0.41176504f, 
    -0.13451999f, -0.25772288f, -0.39532101f, -0.24335292f, -0.16446704f, -0.28089869f, -0.11880860f, 0.34528133f, 
    -0.97318649f, -0.46369591f, -0.17974287f, -0.22932445f, 0.05136727f, 0.07297130f, 0.49167708f, 0.73129666f, 
    -0.15413947f, 0.13068676f, 0.17885226f, 0.21648411f, -0.00778724f, 0.49609512f, -0.43688509f, -0.01053929f, 
    -0.15499388f, -0.21738698f, -0.09893405f, -0.01939864f, 0.38020530f, -0.10722338f, 0.29201117f, 0.12595241f, 
    0.19184494f, -0.27418524f, 0.00241751f, 0.29350024f, -0.21800587f, 0.29159954f, -0.08268845f, 0.18040387f, 
    -0.05978114f, -0.26117331f, 0.14705522f, -0.21494628f, -0.26172036f, -0.27324966f, 0.57722038f, 0.24116987f, 
    -0.18787238f, -0.17550111f, -0.42525691f, 0.12561750f, 0.01291835f, 0.23954383f, 0.16208641f, -0.15500985f, 
    0.26285493f, 0.05344960f, -0.41677773f, -0.48880264f, -0.07139529f, 0.56291986f, 0.52200848f, 0.47384104f, 
    0.19764155f, 0.29792288f, 0.03353757f, 0.05830815f, -0.19027176f, 0.39282972f, -0.29544336f, -0.11085787f, 
    -0.25236911f, -0.17797619f, 0.01131369f, 0.34966680f, -0.40771216f, -0.26055890f, 0.09109344f, -0.15667239f, 
    -0.33359224f, 0.24224496f, 0.24615462f, -0.25417328f, 0.24693398f, 0.27430910f, 0.25903991f, 0.14362937f, 
    0.12024264f, -0.35104221f, -0.27764148f, 0.24474052f, -0.39699462f, -0.19387569f, 0.36340636f, 0.15003440f, 
    -0.36198407f, 0.43623251f, -0.21644528f, 0.05383208f, -0.25007612f, 0.29846379f, 0.04416599f, 0.33773586f, 
    0.13776995f, -0.25960729f, 0.33524433f, 0.44299456f, -1.03662717f, -0.98436606f, -0.39007837f, 0.64582157f, 
    0.68752706f, 0.34122580f, 0.02783773f, -0.60502172f, -0.38386449f, -0.18251620f, 0.09530515f, 0.01806756f, 
    -0.28047889f, 0.24530795f, -0.64802599f, 0.07371168f, 0.31245300f, 0.02813776f, -0.05580411f, -0.22979045f, 
    -0.23526460f, -0.08089884f, -0.20002723f, -0.13164777f, -0.42686206f, 0.42225504f, -0.15865245f, 0.25139320f, 
    0.23295847f, 0.11530510f, -0.05565951f, 0.41268912f, -0.02864359f, 0.45166922f, -0.10113911f, -0.10351385f, 
    0.16485648f, 0.00030146f, 0.17092231f, 0.32338288f, -0.21636827f, -0.10702212f, -0.18717040f, -0.20285915f, 
    -0.04667704f, 0.09188791f, -0.01582344f, 0.13978131f, -0.07478653f, 0.16339393f, 0.07874043f, 0.00153277f, 
    -0.33985695f, -0.14558221f, 0.36721048f, 0.25436819f, 0.00709016f, -0.08949041f, -0.11293162f, 0.09134366f, 
    -0.08333500f, -0.17122266f, 0.43015829f, -0.26450229f, -0.25538960f, -0.27911910f, 0.14654683f, 0.29566175f, 
    0.05757698f, -0.60746223f, -0.10955552f, 0.12993905f, -0.10150403f, 0.53773600f, 0.48851818f, 0.58633506f, 
    0.40849921f, -0.17177987f, 0.15754473f, 0.05033393f, 0.29493970f, 0.20600125f, -0.28818503f, -0.23079349f, 
    -0.03936937f, -0.07855140f, -0.22235169f, -0.21122769f, -0.07670369f, -0.26063973f, 0.05909097f, 0.02421343f, 
    0.14200152f, 0.21781817f, 0.17921683f, -0.10984855f, 0.14849877f, -0.38338071f, -0.52023089f, -0.29167396f, 
    -1.03866696f, -0.98906499f, -0.23755541f, 0.62109822f, 0.49963799f, -0.05450387f, -0.09342793f, -0.22799410f, 
    0.60529274f, 0.61022699f, -0.07372888f, -0.06393114f, 0.17773585f, -0.05537533f, -0.12518182f, -0.41025391f, 
    0.13329241f, 0.23830225f, -0.38483277f, 0.50023675f, -0.22535181f, 0.02185735f, -0.07246656f, 0.22130741f, 
    -0.01153366f, 0.53554010f, 0.01486989f, -0.15767740f, 0.53609276f, 0.07947063f, -0.88468713f, -0.48583522f, 
    -0.53858113f, 0.15255311f, 0.08900660f, 0.11020246f, -0.04065021f, 0.13134058f, 0.52748775f, -0.16030967f, 
    0.10465533f, 0.43957621f, -0.25450251f, -0.39893973f, -0.46380109f, 0.04728908f, -0.08906556f, -0.09356700f, 
    0.03317703f, -0.02145896f, -1.18015766f, 0.41820464f, -0.41922063f, -0.07068443f, 0.26127058f, -0.03724226f, 
    0.15199204f, 0.15420356f, 0.50217026f, 0.61017931f, -0.18090416f, -0.22544701f, -0.11553126f, 0.01733809f, 
    0.24069151f, 0.05291954f, 0.13962591f, -0.22738272f, 0.13670184f, -0.27663332f, 0.16394357f, -0.16484545f, 
    0.10746662f, -0.14865775f, -0.05671300f, -0.67319536f, -0.87109172f, -0.26737097f, 0.38017318f, 0.43734571f, 
    0.47386608f, 0.15344360f, -0.03592005f, 0.25675216f, 0.31279409f, -0.14447673f, -0.31457761f, -0.07549253f, 
    -0.02426450f, 0.34765959f, -0.13976346f, -0.33420748f, -0.15073679f, 0.17452878f, -0.13948001f, -0.15088187f, 
    -0.23548222f, -0.32913586f, -0.14420162f, -0.30657807f, -0.76475477f, -0.50238830f, -0.54595751f, -0.90420592f, 
    -0.85569096f, 0.28566435f, 0.33473226f, 0.24453080f, 0.33291778f, 0.20386967f, 0.03841852f, -0.21410057f, 
    -0.40170336f, -0.26789612f, 0.39949203f, 0.00637608f, 0.10009187f, -0.29724452f, -0.03491522f, -0.13973910f, 
    -0.28544497f, -0.33046201f, 0.04696429f, -0.09957996f, -0.44894052f, 0.71646458f, 0.05677447f, -0.24606845f, 
    -0.44582766f, -0.89322186f, -0.31814045f, -0.27656308f, 0.33222431f, 0.53060806f, 0.12352091f, 0.32527173f, 
    0.23177934f, 0.07512972f, 0.21530665f, -0.21067530f, 0.05612651f, 0.10406838f, -0.21811424f, -0.38931593f, 
    -0.31642127f, 0.15588294f, -0.09406261f, -0.15553653f, 0.07400957f, -0.21948345f, 0.15135491f, -0.26741496f, 
    -0.30276108f, -0.43749925f, -0.48615634f, -0.68383396f, -0.73074734f, -0.67363358f, -0.61021459f, -0.93141544f, 
    0.19777706f, 0.12932268f, 0.19099168f, 0.54833883f, 0.22086440f, 0.06800751f, -0.27636614f, 0.05615524f, 
    0.07891189f, 0.03514664f, -0.03844370f, 0.19875500f, 0.10324964f, 0.04947393f, 0.02382959f, 0.52606016f, 
    0.68274856f, 0.29837283f, 0.29586890f, -0.42750055f, -0.60687149f, -0.75656217f, 0.11568975f, 0.73061466f, 
    -0.23438805f, 0.12599070f, -0.44309497f, -0.27886134f, -0.10222387f, -0.36257106f, 0.01342971f, 0.13821572f, 
    -0.00459017f, -0.15691924f, 0.21854344f, 0.09542631f, -0.02004103f, -0.13252932f, 0.31408283f, 0.04507967f, 
    0.06091190f, -1.40922880f, -0.12984318f, 1.02201545f, 0.79180855f, 0.27333865f, -0.71185887f, -0.98142970f, 
    -0.78234535f, -0.22058326f, -0.18256873f, 0.53802788f, 0.27720833f, -0.22444715f, -0.01671884f, -0.02810215f, 
    0.32368827f, -0.28023145f, 0.35562691f, 0.12065908f, 0.37750256f, -0.11271941f, -0.20271622f, 0.02157286f, 
    -0.28727457f, 0.05624643f, 0.48900926f, 0.44066289f, -0.19484526f, -0.48323220f, 0.25003487f, 0.37848476f, 
    -0.18470031f, 0.45748192f, -0.33313724f, -0.32211190f, 0.35509458f, 0.06072293f, 0.24951753f, -0.24691670f, 
    -0.09424447f, -0.03986058f, -0.12715970f, -0.29661384f, 0.18081412f, 0.31723797f, 0.23275831f, 0.28256422f, 
    -0.23961961f, -0.28140476f, -0.58369392f, -0.32559422f, -0.32757586f, -0.38169879f, -0.20737334f, 0.31332031f, 
    -0.04278954f, -0.31640837f, -0.29130393f, 0.31616378f, 0.25045604f, -0.00174337f, 0.05454332f, 0.28128654f, 
    0.51681638f, -0.23381540f, -0.13283128f, -0.43611419f, 0.03431597f, 0.05379670f, 0.21661848f, 0.18248034f, 
    0.49490336f, 0.34534404f, -0.15682055f, -0.26340905f, 0.51118892f, -0.47923961f, 0.42704484f, 0.10245381f, 
    0.27591297f, -0.15473098f, -0.54889542f, -0.20111707f, 0.60855824f, -0.13490975f, 0.21857384f, -0.03747209f, 
    -0.16534854f, -0.42259812f, -0.18189754f, 0.15839584f, 0.22812045f, -0.26547366f, -0.19636305f, -0.37131622f, 
    -0.13261870f, 0.11358295f, -0.28630230f, -0.03418147f, 0.44767281f, -0.65051872f, -0.17446552f, -0.43916428f, 
    -0.62405622f, 0.70085371f, -0.01310506f, -0.71549135f, -0.71577406f, -0.10091987f, 0.35446885f, -0.28183207f, 
    -0.21245195f, 0.32293448f, -0.13359594f, 0.27097356f, -0.20330465f, 0.06842466f, -0.13362175f, -0.48043481f, 
    -0.58756769f, -0.21212149f, 0.10078569f, -0.36680937f, -0.17674476f, 0.52998531f, 0.91195023f, -0.15308116f, 
    -0.42024046f, -0.10163496f, -0.38620162f, -0.02916512f, 0.14449504f, -0.14562857f, -0.16439351f, -0.30426702f, 
    -0.22975954f, 0.85878456f, -0.69840711f, -0.04449941f, 0.23797667f, 0.05460417f, -0.06841334f, -0.20502716f, 
    -0.07634298f, -0.38037685f, -0.14626147f, -0.27532151f, 0.16428335f, -0.30037996f, -0.01927711f, -0.28816739f, 
    -0.04954455f, 0.29082924f, 0.14480816f, 0.33779338f, -0.03482220f, -0.34783792f, -0.43741286f, -0.27043524f, 
    0.77067560f, -0.63042700f, 0.17586669f, -0.17130834f, -0.06662946f, -0.27990019f, 0.14122666f, 0.36421281f, 
    0.06393649f, 0.03960775f, -0.24655017f, 0.00500878f, 0.18208809f, 0.28090096f, -0.02875482f, -0.56896645f, 
    -0.29635078f, -0.52933872f, -0.45115945f, -0.19642074f, -0.17371736f, -0.31938267f, -0.06073901f, -0.56737369f, 
    0.24289726f, 0.08144530f, 0.32755479f, -0.03015514f, 0.23458453f, -0.15275835f, 0.20901340f, -0.40513778f, 
    -0.00191219f, 0.15672366f, -0.11278956f, -0.01748391f, 0.44649172f, 0.10854621f, 0.01222363f, 0.19932032f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.14980020f, 0.34383547f, 0.20787168f, -0.16509394f, 0.22624734f, 0.34671718f, -0.08932865f, 0.02723534f, 
    -0.08280981f, 0.34818056f, 0.38590205f, -0.05798458f, 0.22784890f, -0.26357907f, -0.00336780f, -0.19558220f, 
    0.26295501f, 0.12156428f, 0.22314368f, 0.03087560f, -0.04723368f, 0.17914142f, -0.05402195f, 0.14345177f, 
    0.25263789f, 0.11446143f, -0.07678913f, 0.12159915f, 0.21484208f, 0.01863166f, 0.17372023f, 0.17378311f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.04838772f, 0.13283086f, 0.26994717f, 0.03079000f, 0.01235343f, 0.01689951f, -0.03276441f, -0.01817586f, 
    0.00336036f, 0.07090344f, -0.10844282f, -0.22665250f, 0.26418480f, -0.04032553f, -0.01790767f, 0.01397304f, 
    0.09765036f, -0.01175895f, 0.16178146f, 0.11863538f, 0.32309222f, 0.02296965f, 0.13043629f, 0.03357317f, 
    0.16049720f, 0.21327743f, 0.27629364f, -0.12189621f, -0.14132915f, 0.01709849f, 0.00312141f, -0.12561622f, 
    0.11328457f, 0.04755755f, 0.07595186f, -0.05508191f, 0.43930316f, 0.20303455f, 0.09771720f, 0.23470724f, 
    -0.12128305f, -0.01298151f, -0.02371928f, 0.04987603f, 0.01476335f, 0.05361833f, 0.04437609f, -0.08798529f, 
    0.22699583f, 0.09124791f, -0.05836286f, 0.00259652f, -0.00938253f, -0.06041797f, 0.01678149f, 0.03216738f, 
    -0.18047182f, 0.00202350f, -0.02004958f, 0.00106543f, 0.56898868f, -0.05764638f, 0.11802316f, -0.01938624f, 
    -0.02705383f, -0.13791320f, 0.12711005f, -0.02940733f, -0.07799538f, 0.05780532f, 0.01720344f, 0.14881462f, 
    0.10790671f, 0.02132010f, 0.05030441f, 0.03439679f, 0.02648148f, 0.07892978f, -0.00362539f, 0.00539596f, 
    -0.05495783f, 0.11755257f, 0.04156883f, -0.06772163f, -0.04812420f, -0.09126977f, 0.33302811f, 0.30784559f, 
    0.05153268f, 0.01642799f, -0.09135468f, -0.15416245f, -0.02852351f, 0.02222454f, 0.04478536f, 0.23424073f, 
    0.02172092f, 0.05524993f, 0.08934114f, -0.22269532f, -0.16431841f, -0.13661921f, 0.06845287f, 0.05928087f, 
    0.05104190f, 0.01761929f, -0.13914095f, -0.04143059f, 0.03186896f, 0.11764888f, -0.01431971f, 0.06916580f, 
    -0.08958411f, 0.10348152f, 0.18809777f, 0.04664876f, 0.01513727f, 0.03579291f, -0.04011260f, -0.13495575f, 
    -0.06732018f, -0.15496820f, 0.06069287f, 0.17775233f, -0.01024951f, 0.10328496f, -0.08728205f, 0.04550309f, 
    0.31701726f, -0.05169404f, -0.10612515f, -0.00949176f, 0.04642051f, 0.21324702f, 0.02404352f, -0.01989735f, 
    0.12833264f, 0.03289805f, 0.00729116f, -0.02767963f, -0.07882503f, -0.03455765f, -0.11390265f, -0.01687187f, 
    -0.19369271f, -0.08355741f, 0.17238341f, 0.14784193f, -0.05292362f, 0.07709634f, 0.06679372f, -0.00240616f, 
    -0.15311286f, 0.02356233f, 0.17251304f, 0.02496844f, 0.36243853f, 0.28975824f, 0.27692184f, 0.12201919f, 
    -0.02727773f, -0.00337497f, -0.03235670f, -0.05584593f, 0.07300163f, 0.01287898f, -0.00915103f, -0.03644413f, 
    0.00128091f, 0.06636158f, 0.12949468f, -0.06548481f, -0.00672977f, 0.13049002f, 0.01385786f, 0.03383360f, 
    -0.12998109f, -0.05606687f, 0.05656870f, -0.08628642f, 0.22484317f, 0.20285316f, -0.06362225f, 0.23091836f, 
    0.00213682f, -0.04323393f, -0.11018873f, 0.08429194f, 0.05016671f, 0.04826682f, 0.14354999f, 0.13879897f, 
    -0.28320733f, -0.22560261f, -0.18936060f, -0.16164882f, -0.32051465f, -0.01059811f, -0.06861829f, -0.07941081f, 
    -0.03736502f, 0.12530918f, -0.10465116f, -0.14429331f, -0.10681569f, -0.01084043f, 0.03341250f, 0.13840212f, 
    -0.07459206f, 0.04672456f, -0.10631208f, 0.05684000f, -0.06090245f, -0.03755997f, 0.07672114f, 0.03996082f, 
    -0.28906313f, 0.15475015f, -0.04144138f, -0.23682114f, -0.04874013f, -0.03379449f, 0.07515698f, 0.11035913f, 
    0.08511726f, 0.05577641f, -0.13669622f, 0.16548169f, -0.20517990f, -0.11101597f, -0.38395891f, -0.22353213f, 
    -0.03789117f, -0.07244486f, 0.01479462f, -0.01007740f, 0.09466942f, 0.11440093f, -0.12898412f, 0.02821306f, 
    -0.07176310f, 0.14667124f, -0.10666087f, -0.16490383f, -0.31810495f, -0.29838172f, -0.05380692f, 0.02569822f, 
    0.08766329f, -0.03327366f, -0.17368171f, 0.01522000f, 0.09406782f, -0.40763605f, 0.00377731f, -0.05968581f, 
    -0.03788194f, 0.08027032f, -0.04299805f, 0.11845826f, 0.11665823f, -0.06317557f, 0.15736583f, 0.06848983f, 
    -0.17362788f, 0.12016223f, 0.35889211f, 0.19858620f, -0.09499525f, -0.03671110f, -0.20449176f, -0.00853493f, 
    -0.05464863f, -0.03884207f, -0.02607577f, 0.02260991f, 0.41975266f, -0.08464286f, 0.28728926f, -0.00547176f, 
    -0.07285751f, -0.05179264f, -0.03338506f, -0.04313475f, -0.01452456f, 0.03853081f, 0.04201805f, -0.05685476f, 
    -0.49561152f, 0.00892849f, 0.40119222f, 0.03456485f, -0.09038489f, 0.08857511f, -0.07989346f, 0.29843158f, 
    -0.10482614f, -0.04835055f, 0.07181440f, 0.09363160f, 0.40703049f, 0.09039061f, 0.23576991f, 0.13899142f, 
    -0.03177430f, -0.03316054f, 0.08120149f, -0.06260219f, -0.00969294f, 0.05469651f, -0.06714859f, -0.11450483f, 
    -0.21881565f, 0.13506094f, -0.09819567f, -0.01819782f, -0.07776283f, -0.07945885f, 0.05845529f, 0.11554383f, 
    -0.06334694f, 0.11440742f, 0.01658731f, 0.00786444f, 0.13896023f, 0.18930440f, -0.17075992f, 0.17729865f, 
    0.01690568f, -0.01562648f, 0.00748150f, 0.04213129f, 0.00877748f, 0.00858228f, 0.12706695f, 0.09750245f, 
    0.00532820f, 0.22015280f, 0.22613390f, 0.21257858f, 0.13742945f, -0.17491540f, 0.05325940f, 0.10399599f, 
    0.11533681f, 0.21827959f, -0.01139921f, 0.17957643f, 0.60249865f, 0.07467373f, 0.48268074f, -0.26424214f, 
    0.00524108f, -0.09973651f, -0.01883175f, 0.15348843f, 0.05670053f, 0.03498699f, -0.10060276f, 0.05076425f, 
    -0.19170861f, 0.11433628f, -0.01310699f, 0.17091811f, -0.15679893f, 0.00717191f, 0.23544864f, 0.12567106f, 
    -0.09038433f, 0.01057009f, 0.05157755f, -0.03005050f, -0.08985320f, 0.04775316f, 0.18467210f, 0.12319870f, 
    -0.12315072f, -0.10022020f, -0.05793904f, 0.02402880f, 0.06966003f, -0.00646034f, 0.01375747f, -0.01478501f, 
    0.00064699f, 0.27642804f, 0.13349427f, 0.22048670f, 0.06974895f, -0.08060539f, 0.18430138f, 0.00588980f, 
    -0.06654833f, -0.01765728f, -0.02708616f, 0.02162152f, 0.17579465f, 0.32115108f, 0.06431936f, 0.02683610f, 
    0.08848903f, -0.03866194f, -0.14560911f, 0.09223063f, 0.29092652f, 0.09125158f, 0.01784654f, 0.00704460f, 
    0.21330895f, 0.09720576f, 0.08259892f, -0.03389016f, -0.13111758f, -0.00615670f, -0.00982818f, -0.10157695f, 
    0.10779978f, 0.10831184f, 0.08985253f, -0.09543855f, 0.13571650f, -0.02806210f, 0.11167622f, 0.18414691f, 
    -0.00872875f, -0.06304432f, -0.13158220f, -0.03330046f, 0.00559148f, -0.08681784f, -0.02300705f, -0.03456041f, 
    0.14897220f, -0.03360242f, 0.04049107f, -0.02767721f, 0.03017867f, -0.01434322f, 0.06149746f, -0.01671208f, 
    0.12208385f, -0.05566568f, -0.01679834f, 0.15252084f, 0.13773769f, 0.08385136f, 0.17306867f, -0.16847257f, 
    0.16249573f, 0.16127756f, -0.06569761f, -0.02118293f, 0.00166101f, -0.10046176f, 0.14031811f, -0.02351485f, 
    0.16181475f, 0.07413529f, -0.10282717f, 0.00924036f, 0.00755678f, -0.06520824f, 0.04715899f, -0.00011586f, 
    0.17941219f, 0.09663916f, -0.05219110f, -0.07767559f, -0.08388154f, -0.24417236f, -0.09749932f, 0.13311447f, 
    0.00900229f, -0.05050390f, -0.09249723f, -0.11070110f, -0.01640953f, -0.01766434f, 0.04339827f, 0.02309807f, 
    -0.11183503f, -0.11916084f, 0.00685535f, 0.04587994f, -0.03562024f, -0.04389727f, 0.06437094f, -0.01719364f, 
    0.02405744f, 0.05306391f, -0.00819638f, 0.10107256f, 0.01877168f, 0.01455281f, 0.03991461f, 0.11631186f, 
    0.09778470f, -0.10631473f, 0.02213835f, 0.02619218f, -0.06441884f, -0.02859284f, 0.12033966f, -0.07466950f, 
    0.07726597f, 0.08846968f, -0.00795941f, -0.13329136f, -0.04971902f, -0.03826045f, 0.02745916f, 0.06974372f, 
    0.01921233f, 0.18742715f, -0.16488394f, 0.18921031f, -0.02023859f, -0.04327240f, -0.05558848f, 0.05893704f, 
    0.12011559f, -0.07598846f, -0.08598988f, -0.00874837f, -0.04600750f, -0.11113093f, -0.05229708f, 0.08350768f, 
    -0.15532632f, -0.02236427f, 0.14156657f, 0.04159711f, -0.10089688f, -0.05497734f, 0.04344160f, -0.00065172f, 
    0.00425595f, 0.05886796f, -0.01076611f, -0.01326409f, 0.21399829f, 0.01717926f, 0.08345704f, 0.17122079f, 
    -0.04399633f, 0.01500834f, -0.05250381f, -0.09630688f, -0.01960706f, -0.10392246f, -0.15594906f, 0.07676212f, 
    -0.06599077f, 0.03161796f, -0.02233855f, -0.10203935f, 0.12369886f, -0.07629922f, 0.00130213f, -0.07242026f, 
    -0.03932184f, 0.02784423f, -0.01234837f, 0.00296533f, 0.06699575f, 0.11323197f, 0.11701977f, 0.05525964f, 
    -0.03551206f, -0.10887817f, -0.15114665f, -0.00741054f, 0.20570891f, 0.04615197f, 0.12461670f, -0.01554305f, 
    0.03058160f, -0.18392459f, -0.16320348f, -0.04933714f, -0.10227033f, -0.02830771f, -0.08307255f, 0.19592245f, 
    -0.01276879f, 0.18953528f, 0.03882238f, 0.01397517f, 0.01789672f, -0.22072758f, -0.06454121f, 0.00089462f, 
    -0.03897188f, 0.02034352f, 0.17018104f, -0.03119729f, 0.10641019f, -0.01176750f, -0.01771101f, 0.08535498f, 
    0.12809631f, -0.19672893f, -0.03173897f, 0.00912735f, 0.15141132f, 0.01261189f, -0.01241989f, -0.06337190f, 
    -0.01328063f, -0.06144949f, 0.06528261f, 0.27880052f, 0.00598670f, 0.02220722f, -0.09671748f, -0.01678783f, 
    0.00681135f, -0.04238627f, -0.04205887f, 0.08632388f, -0.07604631f, 0.01531352f, 0.02030016f, -0.25611788f, 
    0.07602667f, 0.11498822f, 0.27904707f, 0.23748158f, -0.03759781f, -0.08047093f, 0.05611449f, -0.06675398f, 
    0.08072006f, 0.04800431f, 0.03184155f, 0.02314419f, 0.24437033f, 0.12366392f, -0.07615246f, -0.07270943f, 
    -0.09060271f, 0.04998267f, 0.06664179f, 0.04897717f, 0.28116608f, 0.06144077f, 0.00988302f, 0.03174858f, 
    -0.32376629f, -0.30021435f, 0.03940221f, 0.10664296f, 0.08053064f, 0.13822557f, -0.04968481f, -0.17446125f, 
    -0.02674283f, -0.06174226f, -0.02460785f, -0.08584131f, -0.08506128f, -0.03573432f, 0.32352731f, -0.17403725f, 
    -0.03291234f, -0.08079958f, -0.01912452f, -0.09289700f, -0.01938703f, 0.02225678f, -0.06993653f, -0.02781984f, 
    -0.15685102f, 0.25707564f, 0.01775776f, 0.11119575f, 0.04497783f, 0.02719149f, -0.05914971f, 0.01518339f, 
    0.14083566f, 0.00659066f, -0.05793199f, 0.09827632f, 0.14946692f, 0.04385769f, 0.05123264f, 0.00511304f, 
    0.03955879f, -0.09169317f, -0.05833872f, -0.02009634f, 0.01132154f, -0.12401200f, -0.03543218f, 0.03282100f, 
    -0.04238751f, -0.33323452f, 0.14192048f, 0.11059342f, 0.06916349f, -0.13403308f, 0.25465158f, 0.04035556f, 
    0.00941713f, 0.00167474f, 0.06180703f, -0.02349591f, 0.02053993f, -0.13476811f, -0.03430540f, -0.22369938f, 
    -0.10804400f, 0.01834134f, -0.18408421f, 0.01166702f, 0.11941905f, 0.07780743f, -0.03187935f, 0.09116670f, 
    -0.18075761f, 0.00430287f, 0.29679033f, 0.02939623f, 0.11508414f, 0.16382070f, 0.02707822f, -0.14366454f, 
    0.00488832f, 0.06692676f, 0.14256884f, -0.00073941f, 0.43372795f, -0.22249062f, -0.33797103f, 0.03969558f, 
    -0.12823315f, -0.01998819f, -0.08216778f, -0.10476651f, -0.01527285f, 0.16132024f, -0.06947123f, -0.00011985f, 
    -0.17114200f, 0.13481285f, 0.08981043f, -0.25506189f, -0.06591208f, -0.08217708f, 0.20930313f, 0.11653617f, 
    0.09144987f, 0.07061943f, 0.05132329f, -0.04780162f, 0.01252053f, -0.17650254f, -0.05650858f, 0.26605138f, 
    0.07668489f, 0.05539832f, 0.06455773f, -0.11867455f, -0.05497216f, 0.03266834f, -0.07784067f, -0.00596254f, 
    0.32398432f, 0.28460491f, 0.02466379f, -0.21199918f, 0.02522156f, -0.03888241f, -0.03190026f, 0.10183740f, 
    -0.11748328f, 0.08096869f, -0.04734999f, 0.03172119f, -0.01477118f, 0.06205160f, 0.41165456f, -0.34983456f, 
    0.04818616f, 0.05385959f, -0.18983749f, -0.13917540f, -0.02714048f, 0.05190567f, -0.05575629f, 0.04962797f, 
    -0.19750376f, -0.01182536f, 0.29799220f, 0.17404509f, 0.05447813f, -0.18962774f, 0.06586355f, -0.28220856f, 
    0.01995461f, 0.00210954f, 0.18929194f, -0.18110132f, 0.07367799f, -0.04905289f, 0.06718847f, 0.11653610f, 
    -0.03169789f, 0.05173583f, -0.15625177f, 0.02606796f, 0.09903760f, 0.09509876f, 0.05628963f, -0.00648801f, 
    0.11287219f, -0.18378386f, -0.04719840f, -0.15339690f, 0.04906654f, 0.03554342f, 0.07613061f, -0.10858107f, 
    0.11417517f, 0.06805734f, 0.00268694f, 0.06396322f, 0.15175989f, 0.10036393f, 0.19317020f, -0.25214234f, 
    -0.08105017f, -0.11222878f, -0.04248777f, 0.11510769f, 0.09262375f, 0.05596828f, 0.15862563f, 0.17493373f, 
    -0.30430901f, -0.06956377f, -0.12753791f, 0.09588185f, 0.08635526f, 0.10172260f, -0.01663751f, 0.00676942f, 
    0.05979339f, 0.13546711f, 0.00249745f, 0.07993788f, -0.15012938f, -0.05629196f, -0.04269788f, 0.20707861f, 
    0.18346256f, 0.16627298f, -0.02304660f, 0.02855753f, 0.03149292f, 0.00769216f, -0.01131273f, 0.02206538f, 
    -0.21933806f, -0.21208559f, -0.30805761f, 0.27830234f, 0.32640457f, 0.03036382f, 0.04462802f, -0.04555382f, 
    0.07019483f, 0.04592980f, 0.06870196f, 0.01704698f, 0.12056294f, 0.02514525f, 0.12735470f, 0.04971628f, 
    0.09828845f, -0.04213566f, 0.06219747f, 0.05291646f, 0.10087532f, -0.07727575f, -0.00987719f, -0.06392641f, 
    -0.13106443f, 0.01104657f, -0.04594913f, 0.15025878f, 0.00301246f, -0.03260205f, 0.00445895f, 0.05459971f, 
    -0.03255934f, 0.02717254f, -0.02424953f, 0.10013121f, -0.01879379f, -0.10747855f, -0.20895672f, 0.09072830f, 
    0.07651987f, 0.16122349f, 0.02143336f, 0.09290660f, -0.05770044f, 0.03590516f, -0.13370942f, 0.02455386f, 
    -0.22089000f, 0.06595936f, 0.00699525f, 0.14582214f, 0.10978206f, 0.06981845f, 0.07732518f, 0.19427654f, 
    0.06222679f, -0.11493661f, -0.03210694f, 0.07889719f, 0.00550294f, -0.19872841f, -0.09084328f, 0.22214773f, 
    -0.13731216f, -0.09670333f, -0.10497717f, -0.06409299f, 0.09436905f, 0.08142783f, 0.00999697f, -0.06381325f, 
    0.07676388f, 0.01842529f, 0.16189264f, -0.08315495f, 0.06837555f, 0.00682628f, 0.04136293f, -0.21230598f, 
    -0.04677693f, -0.04923512f, 0.06760880f, -0.12140638f, 0.02370390f, 0.01767882f, -0.18898304f, -0.28563663f, 
    -0.18927959f, -0.05375749f, -0.15518914f, 0.30979648f, 0.13310535f, 0.10144622f, 0.14197457f, -0.04514842f, 
    -0.15229794f, -0.10889591f, 0.11711256f, 0.25268185f, 0.18699868f, -0.01362024f, -0.13951805f, -0.20458846f, 
    0.15777411f, -0.10629736f, 0.00885417f, 0.08887403f, 0.17262785f, 0.21619762f, 0.13648090f, 0.11176215f, 
    0.05592376f, -0.18872137f, 0.08316171f, -0.02812798f, 0.03827085f, -0.07312515f, 0.07548779f, 0.19822986f, 
    -0.17296734f, 0.12514983f, 0.10174749f, 0.24619874f, 0.24177423f, 0.00774092f, -0.12378132f, -0.30640668f, 
    -0.07972887f, -0.09174596f, -0.07570525f, 0.12100042f, 0.03464327f, -0.00811140f, 0.18749137f, 0.21217036f, 
    0.17165169f, -0.06173295f, -0.08304892f, -0.29195490f, -0.20405629f, -0.01418151f, -0.09078830f, -0.04558780f, 
    0.24654867f, 0.01249635f, 0.16607738f, -0.12711498f, 0.01120298f, -0.05776712f, -0.00308680f, -0.14944965f, 
    0.00599240f, 0.02784325f, -0.05478337f, -0.05504726f, -0.21590313f, -0.17742512f, 0.16063958f, -0.11296209f, 
    0.00828688f, -0.05274202f, 0.07531804f, -0.12162074f, 0.14056641f, 0.03838675f, -0.07740799f, 0.08910356f, 
    0.00799041f, -0.08397958f, 0.06901542f, -0.07691996f, -0.01598589f, 0.02862225f, 0.07480676f, 0.08002843f, 
    -0.12523821f, -0.04580399f, 0.08954524f, -0.00982341f, 0.29064155f, -0.33606327f, -0.10476577f, 0.22184600f, 
    -0.09382489f, -0.22179511f, 0.01186392f, -0.02389856f, -0.11413698f, 0.05105173f, -0.24941434f, -0.05577477f, 
    0.07703076f, 0.38899428f, -0.11711422f, -0.00567925f, -0.00531945f, 0.00703649f, 0.02003416f, 0.27728060f, 
    -0.06549178f, -0.01343993f, -0.13259487f, 0.02727952f, 0.06100809f, -0.18142548f, -0.27978751f, 0.09432019f, 
    0.07925466f, -0.04326216f, 0.09917752f, 0.09890565f, 0.11091296f, 0.00562123f, 0.01452043f, 0.06524982f, 
    0.01850314f, -0.11070320f, 0.17142475f, -0.06918394f, 0.18584912f, -0.02542015f, 0.11264864f, 0.03432875f, 
    0.05396694f, -0.03480675f, -0.06191748f, -0.04045899f, -0.21688145f, -0.10951728f, 0.05857650f, -0.00357239f, 
    -0.07223296f, 0.06570783f, -0.12787472f, -0.02758276f, 0.13336369f, -0.21459927f, -0.02127922f, -0.07770009f, 
    -0.02404000f, -0.03295568f, 0.09508654f, -0.01099655f, -0.10392429f, 0.11738372f, -0.00616844f, 0.04061186f, 
    0.15777864f, 0.01831425f, 0.03340557f, 0.04267078f, 0.29475808f, -0.10219549f, 0.15808024f, -0.02328443f, 
    0.07166946f, 0.00043850f, -0.08805889f, 0.03598608f, 0.10822728f, 0.08341834f, 0.11359785f, 0.06114777f, 
    0.04151997f, 0.28644514f, -0.08704339f, -0.26934910f, -0.00295157f, 0.09604023f, 0.16496594f, 0.01816140f, 
    0.08799502f, -0.08902624f, 0.18443376f, -0.11081684f, -0.02968036f, -0.01249051f, -0.01642868f, 0.07694650f, 
    0.08206534f, 0.16303264f, 0.18928571f, -0.10500573f, 0.08017765f, -0.01947483f, 0.01741363f, -0.02319636f, 
    -0.02698714f, 0.02483078f, 0.03346578f, 0.02307514f, 0.02685431f, -0.22957748f, 0.05991962f, 0.07749899f, 
    -0.00020406f, 0.10644823f, -0.13205640f, -0.04627124f, -0.20181476f, 0.17850891f, 0.26845282f, -0.00556064f, 
    -0.03345904f, -0.04238064f, 0.07070478f, -0.03689899f, -0.05732127f, 0.14134267f, 0.08065372f, -0.18476558f, 
    0.23432308f, 0.11039014f, 0.05895377f, 0.18366106f, 0.05252115f, 0.04047457f, 0.07301120f, 0.00904965f, 
    0.08382362f, 0.13594195f, -0.01842288f, -0.02402090f, 0.33104041f, 0.20882846f, 0.12327831f, 0.02504014f, 
    -0.01341324f, 0.00167295f, -0.02374039f, 0.00994873f, -0.13723314f, -0.02352087f, 0.00717186f, -0.05583072f, 
    0.31959110f, 0.14334324f, 0.06972929f, 0.10007995f, 0.02687215f, -0.05969167f, 0.00043461f, -0.09421059f, 
    -0.10286956f, 0.03556478f, 0.05059688f, 0.03610677f, 0.32830885f, 0.24430314f, 0.43497819f, -0.26332229f, 
    -0.02973128f, 0.04958563f, -0.11201156f, 0.01236324f, -0.00141602f, -0.02089576f, 0.01333734f, 0.03541405f, 
    -0.08180398f, 0.05949195f, -0.01959179f, -0.03649244f, 0.13761859f, 0.14834842f, -0.03626643f, 0.02879973f, 
    -0.00782650f, 0.10696597f, 0.15164277f, -0.01351849f, -0.23965600f, -0.29501680f, -0.09657285f, 0.07222741f, 
    0.08754762f, 0.01508240f, -0.09407199f, -0.10422200f, 0.10442133f, 0.26707399f, 0.16637000f, -0.01601202f, 
    -0.09605728f, 0.08962733f, 0.12924795f, -0.06119428f, -0.08451399f, -0.04445825f, -0.14035189f, -0.05670088f, 
    -0.07486577f, -0.04683594f, -0.15193143f, -0.13059649f, 0.02275700f, 0.06807275f, -0.07399806f, 0.14544721f, 
    -0.03026876f, 0.06901211f, 0.13251984f, -0.04372265f, 0.01192759f, -0.28063446f, 0.15248393f, 0.05233684f, 
    0.03335002f, 0.33738405f, 0.10990357f, 0.19768143f, 0.16657667f, 0.02705051f, -0.11639456f, 0.05566444f, 
    -0.05575935f, 0.21887970f, -0.04727390f, 0.09508749f, 0.06961814f, -0.00174105f, -0.07093072f, -0.15355250f, 
    0.03412512f, -0.06938780f, -0.12574802f, -0.09125125f, -0.14091758f, -0.21259315f, -0.21526341f, -0.16110903f, 
    -0.25490907f, -0.16004156f, -0.21764317f, 0.26914346f, 0.08947046f, 0.14557141f, -0.04846717f, 0.17495327f, 
    0.03231606f, 0.17061394f, 0.08469126f, -0.06842821f, 0.27133304f, 0.17346513f, 0.07224618f, -0.06537379f, 
    -0.03374590f, 0.09158224f, -0.04885409f, -0.00320952f, -0.03935947f, -0.10731047f, -0.02534316f, -0.04782481f, 
    0.03384283f, 0.15476151f, 0.11469535f, -0.04338955f, 0.04944663f, -0.14594708f, 0.07057256f, 0.01290186f, 
    -0.14930494f, -0.03975449f, -0.25231332f, -0.18834323f, 0.03283710f, 0.23193292f, 0.02305255f, 0.00999602f, 
    -0.01408959f, 0.09551219f, -0.07067730f, 0.06776860f, 0.07831377f, 0.10085138f, 0.13158330f, 0.18644103f, 
    -0.40168706f, 0.10604018f, -0.22780305f, -0.09939727f, 0.20711662f, -0.00613771f, -0.20248879f, 0.08343964f, 
    0.00761131f, 0.23649360f, 0.00804704f, 0.03523306f, 0.36965612f, 0.06459824f, -0.26939794f, 0.21285607f, 
    0.05518766f, -0.03402196f, 0.18117428f, 0.23566115f, 0.00865720f, -0.02854162f, -0.01331507f, -0.09396013f, 
    0.55434227f, 0.11252864f, -0.19836403f, 0.10284567f, 0.19640408f, -0.05445541f, -0.07540993f, -0.08377610f, 
    -0.08276033f, 0.12885636f, 0.14051500f, 0.10012084f, 0.03795188f, 0.25949863f, -0.03029333f, 0.13913950f, 
    0.08136382f, -0.01253671f, -0.05292663f, -0.07675481f, -0.11241320f, 0.03642803f, 0.24873754f, 0.00128707f, 
    0.13111062f, -0.05170188f, 0.21731478f, 0.18427619f, 0.00585637f, -0.18060516f, 0.09122459f, -0.18620016f, 
    0.00453398f, 0.22135223f, 0.20155710f, 0.12580104f, 0.07973310f, 0.22163939f, 0.23944186f, -0.02720568f, 
    0.03319257f, -0.02404512f, 0.08279443f, 0.05077602f, 0.10435114f, 0.20454724f, 0.12385749f, 0.15155897f, 
    -0.16955535f, -0.28531525f, -0.01148767f, 0.03969899f, -0.13139234f, -0.00327734f, 0.01031084f, 0.11073036f, 
    0.03645788f, -0.06247945f, 0.03170987f, -0.09042367f, 0.17368439f, -0.26523155f, 0.10703372f, 0.07012154f, 
    -0.17060883f, -0.15481031f, 0.07117217f, 0.00178992f, -0.09321139f, 0.06532365f, -0.06042599f, -0.08889173f, 
    -0.34581754f, 0.14257038f, -0.31191832f, 0.32777321f, -0.02527963f, 0.09038923f, -0.05732873f, 0.15132143f, 
    -0.01247828f, -0.10647005f, -0.07256581f, 0.11408848f, 0.26380023f, 0.15443994f, 0.15882501f, -0.06008542f, 
    -0.00342817f, 0.00266177f, 0.05153833f, -0.06390293f, -0.01261127f, -0.09360421f, -0.12883234f, 0.11067554f, 
    -0.12269340f, -0.14195494f, -0.00740375f, 0.02994845f, -0.04184328f, -0.09831587f, 0.03941619f, -0.10504320f, 
    -0.18206012f, -0.18431178f, -0.10614721f, 0.04471835f, 0.00379687f, -0.00270456f, -0.01748925f, 0.06576587f, 
    0.02835688f, 0.09745800f, -0.10618339f, 0.02256034f, 0.17963147f, 0.39351979f, 0.13475819f, 0.00843032f, 
    -0.24877766f, -0.12156674f, 0.15069038f, 0.25673079f, 0.05134645f, 0.07305468f, -0.02252339f, 0.04958050f, 
    0.06930198f, 0.24285015f, 0.15356478f, 0.10655043f, 0.11529210f, 0.18608382f, 0.29411501f, -0.24614941f, 
    0.00552914f, -0.04906357f, -0.02367823f, 0.16231203f, 0.07161182f, 0.36865962f, 0.11027247f, 0.07789238f, 
    -0.20183703f, 0.05396073f, 0.02015237f, 0.13653551f, 0.00297939f, 0.05501112f, 0.03675877f, 0.00773324f, 
    -0.09971986f, -0.16148596f, -0.18004201f, -0.01636776f, -0.15181018f, -0.14498441f, -0.08034372f, 0.03892027f, 
    -0.18590662f, -0.07082842f, 0.01904475f, -0.04239937f, -0.01319768f, -0.03401973f, 0.00670958f, -0.08522943f, 
    -0.11326097f, -0.11330471f, 0.03453172f, 0.36981809f, -0.06782339f, 0.12196929f, 0.07293089f, -0.20262724f, 
    0.03161480f, -0.01822210f, 0.16505335f, 0.12230923f, -0.13758980f, -0.26354262f, -0.05138836f, 0.03665292f, 
    0.09709087f, 0.10917449f, -0.11360665f, -0.09259377f, -0.02744555f, -0.10343818f, 0.05530204f, 0.12836704f, 
    0.28059110f, -0.13321918f, 0.12098791f, 0.00393082f, -0.01852785f, -0.05809597f, -0.09113607f, -0.05871492f, 
    0.03516639f, 0.03741439f, -0.03740220f, 0.03501088f, -0.19304797f, 0.01890069f, 0.14389910f, 0.15175916f, 
    0.00198718f, -0.02323020f, -0.09424396f, -0.06948181f, 0.14368843f, 0.10766052f, 0.05068772f, 0.10034048f, 
    -0.34698984f, -0.10747011f, -0.05995744f, 0.02129173f, 0.06663448f, 0.04754557f, -0.03214283f, -0.06478726f, 
    -0.01224681f, -0.09127003f, 0.02998438f, 0.14864069f, -0.51129925f, 0.34732848f, 0.08324158f, 0.29417905f, 
    0.13480814f, 0.14915420f, -0.28735894f, 0.09013091f, 0.13232228f, 0.08844782f, 0.05145277f, -0.07000023f, 
    0.21975254f, 0.17075382f, -0.00375081f, -0.05529685f, 0.07656237f, -0.02657475f, -0.06863363f, -0.05827020f, 
    -0.35973769f, -0.18053694f, -0.15652363f, 0.10789477f, 0.06541590f, -0.03258964f, 0.26224113f, 0.15275808f, 
    0.01831256f, 0.06578586f, 0.01536682f, 0.08165081f, -0.02573186f, -0.08965790f, 0.08350942f, 0.18630728f, 
    0.27850273f, 0.04436642f, -0.38577527f, -0.18346500f, 0.12757915f, 0.02460269f, -0.03990301f, 0.05369429f, 
    0.03638709f, 0.21272637f, 0.01268359f, 0.06901672f, 0.05475694f, 0.34862116f, 0.04960382f, -0.14062937f, 
    0.08881165f, 0.07478544f, -0.08103449f, -0.04629625f, 0.01311837f, 0.08382291f, -0.17135033f, 0.03120031f, 
    0.07226954f, 0.21501987f, -0.12527342f, -0.34203368f, 0.00318615f, -0.01199465f, 0.05829702f, 0.02855201f, 
    0.00385759f, -0.13302557f, 0.01391710f, -0.17797816f, 0.16089860f, 0.11009138f, 0.20301038f, -0.11785677f, 
    -0.09203355f, -0.31178361f, 0.07846828f, -0.10815602f, -0.14051254f, 0.04789255f, 0.00943298f, 0.01865001f, 
    -0.07383168f, 0.33470988f, 0.04619688f, -0.22333671f, 0.01188327f, 0.11269411f, 0.06836558f, -0.03068468f, 
    -0.12380839f, 0.02392069f, 0.06632715f, 0.23202559f, 0.05038167f, 0.00919813f, 0.11625445f, -0.00247331f, 
    0.02984313f, -0.02551307f, 0.02450909f, 0.05908258f, -0.01099158f, 0.01920014f, -0.00953552f, -0.12631580f, 
    0.24315101f, 0.03193291f, -0.06483415f, -0.02435316f, -0.05763561f, 0.13226850f, -0.17182693f, -0.08278888f, 
    0.03810472f, -0.07764431f, -0.02498434f, 0.03718652f, 0.04044874f, 0.07515578f, 0.03723960f, 0.03559849f, 
    0.00592485f, -0.09351090f, 0.10556186f, -0.09948108f, 0.13412729f, 0.14594923f, 0.07438123f, -0.06017407f, 
    0.42811516f, -0.35540977f, -0.22146118f, -0.45580715f, 0.03424476f, -0.00004778f, -0.00324604f, 0.10749656f, 
    -0.10456057f, -0.01559411f, -0.05692033f, 0.09153762f, 0.22016451f, -0.36540207f, 0.57593203f, 0.41690841f, 
    0.00998983f, -0.04987269f, -0.11675069f, -0.15955029f, 0.08676713f, -0.01572437f, 0.04236856f, -0.05145775f, 
    0.52247036f, -0.13170110f, 0.10734849f, -0.24708723f, -0.02692489f, -0.00841169f, 0.04420499f, 0.01280761f, 
    0.03502401f, -0.01868331f, 0.08506179f, 0.01184314f, -0.00004340f, -0.21157347f, -0.12495604f, -0.32120714f, 
    -0.02612352f, 0.04502897f, -0.02698829f, -0.05165228f, -0.02538688f, 0.14207499f, -0.10735076f, -0.07927992f, 
    -0.09925916f, -0.27488682f, -0.26990336f, 0.09046096f, 0.14505498f, -0.05352385f, 0.13253866f, 0.12237129f, 
    0.02864390f, -0.07480387f, -0.20066458f, 0.04805968f, -0.25835922f, -0.18300493f, -0.11072296f, 0.17679448f, 
    0.03993661f, -0.05902654f, -0.00205290f, 0.00690575f, -0.09674758f, -0.08900878f, -0.03162928f, -0.11286765f, 
    0.11594355f, 0.12126958f, 0.38483107f, 0.42478979f, 0.29140997f, 0.24197230f, 0.11878449f, 0.25117689f, 
    0.06134900f, 0.03743744f, -0.04390356f, -0.03921767f, 0.39196643f, -0.12214118f, 0.41628233f, 0.22205803f, 
    0.20772712f, -0.02662282f, -0.24444047f, 0.00243047f, 0.04899812f, 0.06455080f, -0.01414587f, -0.02154707f, 
    0.31068271f, 0.10312540f, 0.50803792f, -0.04942242f, 0.08597236f, 0.11230146f, 0.18978758f, -0.00695678f, 
    -0.02309491f, 0.00055827f, -0.04006954f, 0.05782603f, -0.09330478f, 0.04234350f, 0.01715211f, 0.13657366f, 
    0.07413533f, 0.00478764f, -0.11343151f, -0.05673119f, 0.00327248f, 0.20699564f, 0.05226929f, -0.21577087f, 
    -0.01581169f, -0.01438181f, -0.07786105f, -0.00808307f, -0.07215279f, 0.17475399f, 0.14453670f, 0.07168089f, 
    0.16443381f, 0.15225090f, -0.01911206f, 0.07235331f, 0.18313648f, 0.00689136f, -0.10446183f, 0.00191247f, 
    0.00096962f, -0.15932445f, 0.10797155f, 0.02775900f, 0.15653929f, -0.11507132f, 0.11703628f, -0.00984752f, 
    -0.18383110f, 0.14288278f, 0.02412729f, -0.01817513f, -0.03609020f, 0.18082793f, 0.05678421f, -0.01756701f, 
    0.00399194f, -0.03471231f, -0.05550285f, 0.08348447f, 0.10877332f, 0.15197317f, -0.07808916f, 0.22673096f, 
    -0.10447849f, 0.14369856f, -0.18414590f, -0.15222999f, 0.19000717f, -0.10476010f, 0.32618955f, 0.02149618f, 
    0.19717418f, 0.14532606f, -0.07175116f, 0.00733150f, 0.00402825f, 0.15180787f, -0.00412309f, -0.00268044f, 
    0.05713294f, -0.10675503f, -0.00790581f, -0.07368883f, 0.06959179f, -0.01364968f, 0.00495328f, 0.22820219f, 
    0.12788720f, 0.10537378f, 0.07046805f, 0.08149543f, 0.10691606f, 0.00896019f, -0.02380330f, -0.01964200f, 
    -0.19022736f, 0.02613000f, 0.13432819f, 0.17573783f, -0.02580965f, -0.07498433f, 0.10297339f, -0.08265516f, 
    -0.10902895f, 0.02216268f, -0.05992606f, -0.14924565f, -0.38435176f, 0.11224021f, -0.01557580f, -0.19577688f, 
    -0.07176574f, 0.09386835f, -0.12846988f, 0.07332812f, -0.16773517f, 0.10127813f, 0.10480302f, -0.09410721f, 
    0.00980882f, 0.03464349f, -0.14205153f, -0.18561295f, -0.00790803f, 0.05415074f, 0.19339466f, 0.02493471f, 
    0.04929486f, 0.03777345f, 0.04859831f, -0.04245260f, -0.29394674f, -0.25355381f, -0.04939779f, -0.27467296f, 
    0.13176095f, -0.10729776f, 0.07124434f, 0.03804748f, -0.05829049f, -0.14686094f, 0.01462425f, 0.11510031f, 
    -0.14908123f, 0.19404685f, 0.10257489f, -0.25292307f, -0.07536038f, -0.03922663f, -0.04090568f, -0.10095070f, 
    -0.02355246f, 0.04199450f, 0.04220952f, 0.20537943f, -0.18083385f, 0.35197863f, -0.04983985f, 0.01392848f, 
    0.17695458f, -0.01787985f, -0.00890444f, -0.01549136f, -0.03267113f, -0.12321416f, -0.08201724f, -0.19515090f, 
    -0.08972183f, 0.16952074f, 0.06717978f, -0.16509132f, -0.06693432f, 0.04814982f, -0.05293910f, 0.33768997f, 
    -0.07590777f, 0.12260204f, 0.00907217f, -0.06030843f, -0.04615974f, -0.01022773f, -0.02843088f, 0.07247023f, 
    0.02653446f, 0.04860970f, -0.01443423f, 0.08758320f, -0.03859500f, 0.10181046f, 0.04557839f, -0.01245875f, 
    0.45036638f, 0.59125775f, 0.20399781f, 0.11676415f, 0.04040941f, -0.05834712f, 0.01272870f, 0.05782661f, 
    -0.15972726f, -0.13721700f, -0.16914852f, -0.21234180f, -0.06599680f, 0.04923359f, -0.14347301f, -0.02479873f, 
    -0.10183851f, 0.17494301f, -0.13033612f, -0.16722465f, -0.15818332f, -0.26835224f, -0.15514611f, -0.29398391f, 
    0.09267805f, 0.25722197f, 0.10385363f, -0.03170319f, 0.06943863f, 0.03440557f, -0.06130466f, 0.02317688f, 
    -0.18620045f, 0.19113092f, -0.08054310f, -0.17046477f, -0.11245379f, 0.09089050f, -0.03676572f, -0.12424518f, 
    0.14403722f, 0.00232655f, 0.00028937f, -0.01981803f, -0.36534226f, -0.19002017f, -0.38829827f, -0.45656461f, 
    -0.02580736f, -0.11021584f, 0.06620786f, 0.22415064f, 0.09995987f, 0.10136294f, -0.24735683f, 0.11552377f, 
    0.09001260f, 0.21607113f, 0.08307458f, 0.12223498f, -0.06649771f, -0.21151237f, -0.27024382f, -0.31594452f, 
    0.04912874f, -0.07870293f, 0.06930509f, 0.09225383f, -0.12606953f, -0.10280457f, -0.19687520f, -0.08765797f, 
    -0.00031127f, 0.04883716f, 0.07141162f, -0.04369805f, 0.06782073f, 0.00699333f, -0.14521126f, -0.09006181f, 
    -0.38306150f, -0.24205950f, -0.18673900f, -0.55399013f, -0.08555467f, -0.21165816f, 0.14351353f, -0.00113278f, 
    0.06782361f, -0.11290952f, 0.08215531f, 0.14883770f, 0.34340864f, 0.22013074f, 0.22574532f, 0.27211389f, 
    0.19870235f, 0.12169806f, 0.14047126f, 0.10373791f, -0.11084375f, 0.01047771f, -0.08932643f, -0.05800991f, 
    0.04372187f, 0.21923548f, -0.07273525f, -0.04946028f, -0.34006327f, -0.27958220f, 0.09077986f, 0.33386263f, 
    0.03075752f, 0.14835809f, -0.07163855f, 0.00328197f, -0.10045090f, -0.06897246f, -0.11722407f, -0.05056097f, 
    0.61889213f, 0.01577247f, -0.11700492f, 0.16500446f, -0.02446479f, 0.01812714f, 0.00111240f, -0.02419748f, 
    0.04758293f, -0.04018862f, -0.07767515f, 0.01450975f, 0.21181057f, 0.11236832f, 0.15383826f, 0.07313044f, 
    -0.16883352f, 0.01511271f, -0.02686940f, 0.05703064f, 0.13600147f, 0.09191979f, 0.12937008f, 0.11532393f, 
    0.11717854f, 0.12475190f, 0.23688298f, 0.47255781f, -0.08844922f, -0.04923888f, 0.04132221f, 0.03040880f, 
    0.02395364f, 0.12500039f, 0.11342426f, 0.39374343f, -0.10392553f, 0.29926839f, 0.05008817f, 0.10736288f, 
    -0.15154441f, -0.11592087f, 0.09555123f, -0.15218481f, 0.10044838f, 0.25996101f, 0.01097923f, 0.15269195f, 
    -0.10021066f, -0.02536576f, -0.00209013f, 0.16834423f, -0.04522542f, -0.10414545f, 0.16301925f, 0.24153596f, 
    0.13712183f, 0.01880693f, -0.00615974f, -0.10703350f, -0.31981876f, -0.13868578f, 0.01510186f, 0.03335568f, 
    -0.03314240f, 0.23434788f, 0.23447698f, 0.12390459f, 0.01607194f, -0.15450628f, -0.07748055f, -0.14660604f, 
    -0.05106707f, -0.20822708f, 0.28996864f, 0.10701255f, 0.23187025f, 0.12831363f, 0.02351822f, 0.10684960f, 
    0.08975198f, -0.01462761f, -0.01368212f, -0.00197490f, -0.00272003f, 0.13107032f, -0.16071732f, -0.16639535f, 
    0.03956001f, 0.09873052f, -0.03171601f, 0.05715723f, 0.15480992f, -0.22322924f, -0.11331203f, -0.04006730f, 
    0.26979941f, 0.08122429f, -0.01586617f, 0.07809409f, -0.17317407f, 0.01284724f, -0.05964051f, 0.12434544f, 
    -0.04150173f, -0.25498119f, -0.09656446f, -0.04340420f, 0.27667361f, -0.20197691f, 0.12390195f, -0.00081705f, 
    0.01091637f, 0.01009464f, -0.02176509f, -0.07837194f, 0.07784142f, 0.12573004f, 0.24595915f, 0.11486820f, 
    -0.12827496f, -0.06751666f, 0.17589502f, 0.07194685f, -0.11448769f, 0.01480209f, 0.06496992f, 0.15820175f, 
    0.01419226f, 0.13475914f, 0.16819195f, 0.04694864f, -0.25169617f, 0.46844146f, -0.06303355f, 0.10257930f, 
    0.00366931f, -0.06619703f, 0.12668049f, 0.07142587f, 0.13861893f, 0.13818257f, 0.29128802f, 0.11319960f, 
    -0.04343769f, -0.28572977f, 0.16410777f, 0.00848665f, -0.00432552f, 0.12744144f, -0.19727619f, 0.09890359f, 
    -0.25168955f, -0.07982587f, 0.02667840f, -0.33033273f, 0.04388885f, 0.12841713f, 0.04635875f, 0.01497414f, 
    -0.12192067f, -0.25170261f, -0.00774056f, 0.04949382f, -0.03916629f, -0.13948561f, -0.00985668f, 0.00962470f, 
    0.30655587f, 0.19377446f, -0.07485072f, 0.15631615f, 0.16344839f, -0.05052622f, -0.00367162f, 0.14315078f, 
    -0.05039261f, 0.11844582f, 0.06920695f, 0.15353848f, -0.60499811f, -0.42821836f, 0.18564202f, -0.14430399f, 
    -0.05989394f, 0.01817599f, -0.16243812f, -0.26148555f, -0.00461278f, 0.05473654f, 0.21543962f, -0.03320979f, 
    -0.06799304f, 0.08839006f, -0.14031374f, -0.07751511f, 0.05088220f, -0.09240736f, -0.11140753f, -0.11169497f, 
    0.04954430f, 0.01759923f, -0.06234310f, 0.02906542f, -0.02865931f, 0.00380353f, -0.27430472f, 0.09920430f, 
    0.10159932f, -0.00336342f, -0.05855759f, -0.11175388f, -0.14147310f, -0.06371856f, 0.01728576f, -0.06815295f, 
    0.20994498f, -0.41151500f, -0.27304462f, 0.11743076f, 0.05611337f, 0.00150078f, 0.08319392f, -0.09483518f, 
    -0.13494156f, -0.03759285f, 0.06073882f, -0.04497914f, -0.12468188f, -0.17068768f, -0.04670062f, 0.09100059f, 
    -0.04775568f, 0.04649153f, -0.13782193f, -0.01918936f, -0.00188430f, 0.03903957f, 0.01976036f, -0.01455274f, 
    -0.19180378f, 0.08668277f, -0.12713504f, -0.01172526f, 0.12908547f, 0.12608086f, 0.29870117f, -0.09414873f, 
    -0.05326106f, 0.14808239f, 0.00513881f, 0.08112180f, 0.15931819f, 0.09968957f, -0.02934220f, 0.06289226f, 
    0.02430343f, 0.00107498f, 0.07671322f, 0.13658515f, -0.11625688f, -0.07923593f, 0.06334601f, -0.01379854f, 
    -0.19299643f, 0.01537750f, -0.24226411f, -0.05335952f, 0.20102182f, 0.14524163f, 0.03590871f, -0.08943535f, 
    -0.06901588f, -0.00757451f, -0.02058686f, -0.02280867f, -0.16774637f, 0.06267459f, -0.07478870f, -0.03314803f, 
    0.03051706f, 0.01321107f, -0.10856212f, -0.07154983f, -0.02187341f, -0.26335710f, 0.08774182f, 0.04134650f, 
    -0.03247775f, 0.08498251f, -0.05846477f, -0.15618297f, 0.02015472f, -0.06172144f, 0.16309105f, -0.00186414f, 
    -0.09388360f, 0.05811660f, -0.11223911f, -0.00636298f, 0.15748279f, -0.08919470f, 0.06163375f, -0.15361054f, 
    -0.05048658f, 0.01235677f, -0.22149867f, -0.08085452f, -0.06323270f, -0.03999753f, -0.20264031f, -0.11677648f, 
    0.28494564f, 0.07779492f, -0.07683911f, 0.02948608f, 0.12157409f, 0.05853743f, 0.09329013f, 0.11476321f, 
    0.09266233f, -0.04560030f, -0.01242983f, -0.02634289f, -0.03398712f, -0.21948798f, -0.20719221f, -0.23720330f, 
    -0.04925711f, 0.09385957f, 0.01585453f, -0.06675445f, -0.06244260f, -0.12399843f, 0.01859199f, 0.01462745f, 
    -0.07935958f, 0.25104803f, 0.02036473f, -0.02190012f, 0.12723389f, -0.12721166f, -0.03750374f, -0.00621633f, 
    -0.02749500f, -0.03596300f, -0.09929254f, -0.05855586f, -0.22211988f, 0.03515862f, -0.17206638f, 0.08080781f, 
    -0.00320637f, 0.01236068f, -0.11281545f, -0.00537379f, 0.11374955f, 0.09501625f, 0.08935232f, 0.17491953f, 
    0.25998336f, 0.43585640f, 0.05797793f, -0.51007509f, 0.23535995f, 0.04022359f, 0.17840306f, -0.03518315f, 
    0.12118105f, -0.01569358f, -0.02557760f, -0.05682701f, 0.26820001f, 0.19752581f, 0.04551478f, -0.22455138f, 
    -0.09495186f, 0.05250970f, 0.25907061f, 0.09353041f, -0.09133412f, 0.00600757f, -0.01423661f, 0.01073604f, 
    0.56771511f, -0.15540512f, -0.16160622f, -0.08133588f, 0.12966971f, 0.19249979f, 0.11938316f, -0.09319005f, 
    -0.03725921f, 0.06839704f, -0.04483274f, 0.03147798f, 0.11429475f, 0.15570444f, -0.08701260f, -0.18129799f, 
    0.06038192f, -0.01432384f, 0.16774960f, -0.09768936f, -0.05293026f, -0.13181347f, 0.13408215f, 0.01299768f, 
    0.37739220f, -0.03907151f, 0.08023798f, 0.13557442f, 0.22861461f, 0.15869460f, 0.04091538f, -0.02344513f, 
    -0.14383079f, 0.03321920f, 0.19424638f, 0.17484131f, -0.19829188f, -0.54292083f, 0.16143687f, 0.04974585f, 
    -0.08476504f, -0.00899516f, 0.05667820f, 0.05620228f, -0.00048421f, 0.03739990f, -0.05426731f, 0.20297036f, 
    0.44549921f, 0.09022233f, 0.00285539f, 0.05486241f, -0.05608685f, 0.11527596f, 0.14831452f, 0.17934147f, 
    0.05068909f, -0.00251643f, -0.01344764f, -0.04986941f, -0.24024005f, -0.45340526f, 0.34208846f, -0.05625428f, 
    -0.14085762f, -0.14420103f, -0.09247580f, -0.06439354f, -0.00910536f, -0.07660180f, -0.13155179f, 0.02093530f, 
    0.00063175f, 0.42976427f, -0.25547448f, 0.37386161f, -0.01247963f, -0.14793696f, 0.07487267f, -0.11136620f, 
    -0.03439824f, -0.06500112f, 0.03801384f, 0.04931531f, -0.05047914f, -0.27371788f, -0.25485665f, -0.18206182f, 
    -0.10884903f, 0.06242901f, -0.04837311f, 0.07904568f, -0.07700072f, -0.12951288f, -0.06567735f, -0.01860869f, 
    0.33376974f, 0.08243006f, 0.04092586f, -0.02142609f, 0.16273455f, 0.08505171f, 0.15122859f, -0.01312249f, 
    -0.04692831f, -0.21141304f, 0.03354157f, 0.10077535f, -0.28815523f, 0.21163802f, -0.16234332f, -0.10934808f, 
    -0.06073658f, 0.05372390f, -0.07839809f, -0.11396841f, -0.03592864f, 0.03349433f, -0.05435564f, 0.04991382f, 
    0.04798066f, -0.00635495f, -0.07941574f, 0.15423056f, 0.09111970f, 0.01001047f, -0.01039946f, 0.04150186f, 
    -0.06725110f, 0.17080329f, 0.14763542f, 0.13848108f, -0.17422993f, 0.03138745f, -0.24617019f, 0.21147946f, 
    -0.03248480f, -0.11417909f, -0.10323803f, -0.06763317f, 0.00955562f, 0.26514813f, -0.02096081f, 0.21233290f, 
    0.04905163f, 0.22782882f, 0.04696671f, -0.26293904f, -0.17669936f, -0.06958367f, -0.00282298f, 0.00579950f, 
    0.09865972f, -0.00174972f, -0.05152815f, -0.01634278f, 0.26918003f, 0.15599625f, -0.13517980f, 0.02444178f, 
    0.09971398f, 0.11360807f, 0.02785873f, -0.18642716f, -0.04675934f, 0.01959359f, 0.00681673f, -0.05826025f, 
    -0.10901049f, -0.10214385f, -0.06811878f, -0.22382692f, 0.02270319f, 0.13501544f, -0.16314584f, -0.07774015f, 
    0.00652194f, -0.12017865f, 0.05012169f, -0.08000623f, 0.37537137f, 0.13393778f, -0.12270831f, 0.41394517f, 
    0.04675224f, -0.11112122f, 0.20197365f, 0.24858564f, 0.01733639f, 0.12383570f, 0.03095749f, 0.12806763f, 
    0.16163413f, -0.17099673f, 0.00851246f, 0.06659117f, -0.03426290f, -0.01272256f, -0.01111992f, 0.25508860f, 
    -0.03635662f, -0.00779033f, -0.05511178f, 0.02923031f, 0.00270041f, 0.03824769f, -0.04081216f, -0.07954120f, 
    -0.04904792f, 0.08898565f, 0.09272441f, 0.00380566f, 0.00713016f, -0.04522382f, -0.06390336f, -0.00676024f, 
    -0.19188261f, 0.17934136f, 0.03983523f, 0.02338479f, -0.02193927f, 0.01753952f, -0.08339099f, 0.16208218f, 
    0.09954909f, 0.17191057f, -0.03837787f, 0.11174033f, 0.20040306f, -0.28468663f, 0.00882938f, -0.04644114f, 
    0.15077174f, 0.15174912f, 0.01392492f, -0.01231154f, -0.00661614f, 0.01732750f, -0.02681995f, -0.02753175f, 
    -0.15619375f, -0.10453615f, -0.12343921f, -0.03781014f, -0.05460370f, -0.04797165f, -0.07410600f, -0.04299454f, 
    0.10879707f, 0.01484227f, -0.02213559f, 0.12982044f, 0.13255906f, 0.01397956f, -0.12980643f, -0.25189206f, 
    -0.00739785f, 0.06915680f, 0.09182221f, -0.02516268f, 0.08756024f, -0.03031102f, 0.06878907f, 0.12573491f, 
    -0.16886291f, -0.12737861f, 0.31609830f, 0.07198699f, -0.11744133f, -0.04656078f, -0.10006613f, 0.07738144f, 
    -0.06709561f, -0.05601883f, -0.12803164f, -0.07926913f, 0.01026195f, -0.09677250f, -0.08296807f, -0.01420763f, 
    0.26863459f, -0.05348895f, 0.11306946f, 0.01484687f, 0.05234500f, 0.08668086f, -0.00155129f, 0.12798403f, 
    -0.07395552f, -0.12471423f, -0.04210117f, 0.31125507f, 0.03877202f, -0.03416447f, 0.04626309f, -0.03077508f, 
    0.13909349f, 0.10859162f, 0.36364141f, 0.21980612f, -0.09645253f, -0.08268861f, -0.14258993f, 0.09581981f, 
    0.05004017f, 0.09477989f, 0.04080013f, 0.00397150f, 0.01595496f, -0.05278101f, -0.01061953f, -0.01307162f, 
    0.22762594f, -0.01520451f, 0.00529750f, -0.02559327f, 0.00592019f, -0.09183661f, 0.07947014f, -0.10793547f, 
    -0.00312817f, 0.11031549f, 0.20482090f, 0.06134802f, -0.16166112f, 0.14068091f, -0.03744816f, 0.06020067f, 
    0.03548746f, 0.03011772f, 0.05237341f, -0.00544459f, -0.07642994f, -0.00329973f, -0.00156942f, 0.09859804f, 
    -0.15741369f, -0.22128814f, -0.07721397f, -0.06790154f, -0.11543023f, -0.03246786f, -0.08898841f, 0.06097037f, 
    -0.00373871f, 0.03345978f, -0.04413165f, -0.02258873f, -0.17255451f, -0.26199886f, -0.01961090f, -0.03413527f, 
    -0.14614429f, -0.01210521f, 0.03512667f, -0.03249327f, -0.05293272f, -0.07934051f, -0.23206207f, -0.03091739f, 
    -0.01501908f, -0.02626732f, 0.16956277f, 0.46674854f, 0.12784636f, -0.05439048f, 0.09337694f, 0.10791779f, 
    -0.03403304f, -0.14724877f, 0.18757482f, 0.04835886f, 0.23343460f, 0.16466400f, 0.02996663f, -0.18228748f, 
    0.28949860f, 0.13159515f, 0.08298169f, 0.14472128f, -0.06350247f, 0.02646991f, 0.02549114f, -0.01642564f, 
    -0.34019911f, 0.00274988f, -0.04929379f, 0.14143558f, -0.04862474f, -0.00918608f, 0.03337595f, 0.27669901f, 
    0.06091253f, 0.15000331f, 0.09702276f, -0.00446919f, -0.07439759f, 0.01725077f, 0.18246174f, 0.15436995f, 
    -0.04326778f, -0.11432266f, -0.01610654f, 0.02323382f, 0.18007039f, 0.10422347f, 0.08891098f, 0.20867369f, 
    -0.08046504f, 0.18970400f, 0.04558213f, 0.02056069f, -0.00630285f, 0.09305638f, 0.15496063f, 0.16407287f, 
    -0.06638111f, 0.00438712f, 0.05982621f, -0.02355325f, 0.29899478f, 0.32761493f, 0.03486696f, 0.04037797f, 
    0.01337212f, -0.01938666f, 0.06313490f, -0.00823103f, 0.05233873f, 0.13749813f, 0.08721172f, 0.01797776f, 
    0.07463744f, 0.10480811f, -0.08125191f, -0.29014501f, -0.11992814f, -0.18736002f, -0.20417377f, -0.23772757f, 
    -0.08223966f, -0.01942741f, -0.10489167f, 0.03532526f, -0.00599914f, 0.10297359f, -0.12432668f, -0.05683357f, 
    -0.03395974f, -0.01211951f, -0.00215612f, 0.02833164f, -0.07104301f, -0.01442086f, -0.00403998f, -0.07355461f, 
    0.23230898f, -0.16767080f, -0.17867494f, 0.13344324f, -0.02261757f, 0.04411790f, 0.09543243f, -0.13843964f, 
    0.04927156f, 0.01630806f, 0.02014427f, -0.08141938f, -0.15794612f, 0.02281486f, 0.20429645f, -0.01796720f, 
    -0.00896132f, -0.00041471f, -0.06018919f, -0.11158014f, -0.01405545f, 0.06181111f, 0.07111122f, 0.04897100f, 
    0.04957182f, 0.10047200f, -0.05328598f, -0.02631747f, -0.05846999f, -0.02161494f, -0.06174650f, 0.04138576f, 
    -0.09742612f, -0.08582912f, -0.12959588f, -0.11141872f, -0.01679539f, 0.02715470f, -0.07023577f, 0.07437109f, 
    0.06845827f, -0.10277822f, 0.07136413f, 0.08161546f, -0.04772137f, 0.30568841f, 0.13736713f, 0.05353580f, 
    0.13710748f, 0.13360743f, -0.08016402f, -0.11541405f, 0.10811171f, 0.10307960f, 0.11719503f, -0.08935862f, 
    -0.02667315f, 0.03095590f, 0.08642977f, 0.04184181f, -0.03145009f, -0.10056292f, 0.36244842f, -0.18160896f, 
    -0.06107379f, 0.05213990f, 0.00929309f, 0.08245460f, -0.06807870f, 0.06217886f, 0.07971340f, 0.05697264f, 
    -0.05456443f, -0.16701478f, -0.04165226f, 0.11782539f, 0.28157830f, -0.01857484f, 0.03362100f, -0.05519938f, 
    0.01578424f, 0.04011088f, -0.08005407f, -0.02722204f, 0.04789823f, 0.15678833f, 0.10081550f, -0.11586378f, 
    0.05207263f, -0.01556129f, -0.15803091f, 0.09724110f, -0.02501351f, -0.02903199f, -0.10451725f, -0.02848801f, 
    -0.08521990f, -0.23975043f, -0.13908121f, -0.18567398f, -0.02799690f, -0.01747890f, 0.12839986f, -0.05885966f, 
    0.14779590f, 0.01286245f, 0.10672452f, 0.06422653f, 0.62906092f, -0.10079322f, 0.04438341f, 0.13996565f, 
    -0.00781875f, -0.12783219f, 0.11136191f, 0.01484844f, 0.18045141f, 0.07983976f, -0.05999117f, -0.05637078f, 
    0.14385858f, -0.05493889f, -0.09078724f, 0.33689162f, 0.04528998f, 0.05729960f, -0.09889441f, 0.13543731f, 
    0.01583336f, 0.01393600f, -0.07182056f, 0.08829433f, 0.13379830f, -0.03158169f, -0.04304036f, 0.04877593f, 
    0.08852899f, -0.01161490f, 0.00296115f, -0.00885486f, 0.04386064f, -0.10825688f, -0.13145848f, 0.09842382f, 
    0.05465219f, -0.06977720f, -0.08836187f, -0.10720648f, -0.06512946f, -0.01420701f, 0.02764123f, -0.02815735f, 
    0.23799451f, -0.07005470f, -0.08702650f, -0.05789516f, 0.05772876f, 0.20172147f, -0.23612343f, -0.11544170f, 
    0.14122738f, 0.01069721f, 0.17107622f, -0.07922052f, 0.04876849f, -0.08370794f, 0.05025018f, 0.00518033f, 
    0.02426861f, -0.02504555f, 0.07801768f, 0.10652839f, -0.01607638f, -0.11432948f, -0.15895313f, -0.00290998f, 
    0.18636611f, -0.10498605f, -0.12711012f, -0.02573327f, -0.13652794f, 0.07811865f, 0.07941061f, -0.07605990f, 
    -0.00527474f, -0.04296416f, 0.01080509f, 0.14946006f, 0.14065810f, 0.11662951f, -0.08976758f, 0.00606667f, 
    -0.16227755f, 0.03645658f, 0.01942661f, 0.13101679f, -0.00578101f, -0.13748093f, -0.16028143f, -0.03788096f, 
    -0.06305623f, 0.18458723f, 0.02539994f, 0.04785515f, -0.11302739f, -0.20530844f, 0.12980258f, 0.07709212f, 
    0.07609152f, 0.00579070f, 0.03786297f, -0.02293873f, -0.05589484f, 0.06854156f, 0.05800383f, 0.11862726f, 
    0.05347860f, -0.06749835f, -0.02974894f, 0.03717431f, -0.00180154f, -0.13670537f, -0.09111758f, 0.03389731f, 
    -0.04179461f, 0.08632731f, 0.23589462f, 0.07711302f, -0.02029113f, -0.13658437f, -0.06323416f, 0.06302391f, 
    0.01752709f, -0.00297724f, 0.24915530f, -0.16008301f, 0.01637559f, -0.07897744f, 0.04844772f, 0.05457001f, 
    -0.05551979f, -0.08798417f, 0.27686447f, -0.11413087f, -0.09433173f, -0.10553127f, 0.21031049f, -0.02067780f, 
    0.09369397f, 0.23843460f, -0.04629053f, -0.02665640f, 0.08740719f, -0.03918577f, 0.13413696f, 0.12121584f, 
    0.06660343f, 0.02955958f, -0.01234005f, -0.08556048f, -0.04917020f, -0.12166741f, -0.03462047f, -0.02749627f, 
    -0.08813240f, -0.08936924f, -0.14721006f, -0.04815910f, -0.17460433f, -0.10431688f, 0.00500999f, 0.08835875f, 
    -0.00454904f, 0.09297448f, -0.25505266f, 0.14447294f, 0.13778825f, -0.06175899f, 0.09890450f, 0.00981673f, 
    0.05947256f, -0.01110661f, 0.19503710f, -0.05367353f, 0.01558557f, -0.02556521f, -0.03132767f, 0.01459408f, 
    -0.10633221f, -0.30191764f, 0.32976010f, 0.17819846f, -0.21232671f, -0.12908840f, -0.00527973f, 0.13719724f, 
    0.11480775f, -0.07128777f, 0.16048811f, 0.21719234f, 0.13814712f, 0.04400309f, -0.06700070f, -0.08417246f, 
    0.11014436f, 0.05408629f, 0.26656020f, 0.05583598f, -0.01761509f, 0.05677186f, -0.02260976f, -0.11633079f, 
    -0.45608890f, -0.05638288f, 0.07780631f, 0.09947734f, -0.11331285f, -0.09862030f, -0.01848401f, -0.06913541f, 
    0.13934563f, -0.08723269f, 0.14534153f, -0.09722826f, 0.03736438f, -0.06769878f, 0.27342457f, 0.02938211f, 
    0.01182868f, -0.06685852f, -0.05553241f, 0.03402051f, 0.12803994f, 0.09488798f, -0.04474419f, 0.09218460f, 
    -0.27118248f, -0.09272929f, -0.21682478f, -0.12300237f, -0.03093210f, 0.07227993f, -0.09341174f, 0.05926454f, 
    0.26472428f, 0.00901454f, 0.19990197f, -0.11961192f, 0.49733961f, 0.18233977f, -0.07415571f, -0.06276765f, 
    -0.00027533f, 0.01722746f, -0.10128360f, -0.07740248f, 0.09465452f, 0.09586888f, -0.02687811f, -0.14232109f, 
    0.15716524f, 0.36791646f, 0.14819452f, -0.14092781f, 0.15879199f, 0.06144529f, 0.03843916f, -0.08161893f, 
    -0.07541144f, 0.04334251f, 0.00807930f, 0.04168873f, -0.00837396f, 0.14721486f, -0.40931061f, 0.00135775f, 
    0.15217997f, 0.03290146f, 0.04416417f, -0.09300841f, -0.03614552f, 0.05530564f, 0.07292375f, 0.11782432f, 
    0.16597016f, -0.60249156f, 0.47237003f, -0.17988916f, 0.22554432f, 0.28894198f, 0.10118690f, -0.08746119f, 
    0.02717394f, 0.12361513f, 0.01113322f, -0.01164674f, -0.07533889f, 0.01348410f, -0.08988570f, 0.22025128f, 
    -0.00560543f, 0.01046608f, -0.07333514f, -0.17430818f, 0.04632720f, -0.13483816f, -0.00584827f, 0.20196052f, 
    -0.23519346f, -0.06856393f, 0.06204920f, -0.13017486f, -0.01290617f, -0.02341815f, -0.09785110f, -0.01876506f, 
    0.18279065f, 0.01652722f, 0.08961774f, -0.08805539f, 0.33928844f, -0.04678499f, 0.41028970f, -0.01591639f, 
    0.08335642f, 0.00949885f, -0.01236678f, 0.27097395f, 0.10161227f, -0.01532949f, -0.01593831f, 0.12576726f, 
    0.22939500f, -0.01877435f, -0.02915562f, -0.33943087f, -0.10898382f, 0.19913873f, 0.05916153f, 0.03062549f, 
    0.01882087f, -0.04922441f, -0.06360281f, -0.11759528f, 0.07112714f, 0.11131483f, -0.43289375f, 0.09079408f, 
    0.09668188f, 0.12918568f, 0.22244319f, 0.12096571f, -0.04770183f, 0.00173081f, 0.05845236f, -0.00658975f, 
    0.19152218f, -0.17110762f, 0.02401717f, -0.27524167f, 0.24238621f, 0.06445315f, 0.03351150f, -0.04632356f, 
    0.02776503f, -0.02186430f, -0.07344356f, 0.04467462f, -0.19014472f, -0.05111221f, 0.15016124f, -0.21461101f, 
    0.09585093f, 0.03603678f, 0.05098970f, 0.06061439f, -0.03705906f, 0.08528321f, -0.02485394f, 0.05283425f, 
    -0.02474785f, 0.01921092f, -0.13703170f, -0.06777849f, -0.07627767f, 0.03612884f, 0.11223818f, -0.00319883f, 
    -0.08301889f, -0.04480946f, -0.12462769f, 0.06414183f, 0.42913735f, 0.08511378f, -0.13464922f, -0.17827515f, 
    -0.16581573f, 0.07265520f, 0.00878592f, -0.06976243f, 0.06240600f, 0.12080867f, 0.10616148f, 0.02721548f, 
    -0.25783545f, 0.09310792f, -0.11721463f, 0.00969696f, -0.12463775f, 0.01440999f, -0.01021339f, 0.24365385f, 
    0.13926043f, -0.06516134f, 0.18726477f, 0.07372969f, -0.12190396f, -0.27562243f, 0.01997436f, -0.08254430f, 
    -0.12498911f, -0.12267662f, -0.18909325f, -0.17277531f, 0.02843130f, -0.06278212f, 0.02609690f, -0.02626950f, 
    0.22916025f, 0.14694038f, 0.06422120f, -0.27598795f, 0.03198519f, -0.16516468f, 0.05969787f, 0.03419401f, 
    0.13517404f, 0.10836016f, 0.06897188f, -0.08118784f, -0.10347019f, -0.05790566f, -0.26448572f, 0.01222353f, 
    -0.20253801f, -0.23330772f, 0.31293693f, -0.07949510f, 0.05777355f, 0.02237261f, -0.03191356f, -0.05703463f, 
    0.12403299f, 0.08612990f, 0.16523303f, -0.06416934f, -0.11147771f, -0.13155669f, -0.23929162f, -0.15868346f, 
    0.14576449f, -0.09646828f, 0.23824881f, 0.10179294f, -0.01992064f, 0.17413132f, -0.05308942f, -0.06649610f, 
    0.05384507f, 0.14110011f, 0.05821764f, 0.18223207f, -0.01556431f, 0.02473381f, -0.05868037f, -0.08930930f, 
    -0.00839470f, 0.24095835f, 0.02612772f, 0.22932732f, 0.21086024f, 0.04117292f, -0.04684585f, -0.00873306f, 
    0.00503492f, -0.03067031f, 0.04568860f, -0.04439213f, 0.15447280f, -0.01022548f, -0.04334217f, 0.21323480f, 
    0.17963791f, 0.08062539f, -0.15788317f, -0.08725919f, -0.08335700f, 0.01777678f, -0.04576333f, -0.01680886f, 
    0.33765811f, 0.22902283f, 0.25369921f, -0.08266571f, -0.10236350f, -0.00611399f, -0.10475913f, 0.04393835f, 
    0.14295007f, 0.06894456f, 0.02211833f, 0.08116145f, -0.27461714f, -0.10828584f, -0.17912485f, 0.04340639f, 
    -0.06831663f, 0.20449281f, 0.02251981f, -0.06580533f, 0.22958323f, -0.04271324f, 0.10628077f, -0.03851709f, 
    0.10311675f, -0.03913649f, 0.13881263f, -0.05441194f, 0.21015970f, 0.02580586f, 0.08243828f, 0.24336493f, 
    0.19899842f, 0.00649155f, -0.02803233f, -0.06532536f, -0.06648729f, -0.03716995f, -0.00240528f, -0.03280023f, 
    -0.08516540f, -0.23869483f, -0.15929443f, -0.28795639f, 0.00757573f, 0.10614237f, 0.14376675f, -0.01251935f, 
    0.07315143f, -0.13183901f, 0.00587387f, -0.12023748f, -0.06892104f, -0.13901454f, 0.15670441f, -0.12938093f, 
    0.27238646f, -0.22843960f, -0.13640696f, 0.22547455f, 0.09314438f, -0.17718624f, 0.10929890f, -0.17690703f, 
    0.02362858f, -0.04476986f, 0.21726418f, 0.24858689f, 0.07331844f, 0.12391134f, 0.02798367f, -0.00788892f, 
    0.24151607f, 0.33884659f, 0.55797964f, 0.21339716f, -0.10724152f, 0.03767385f, -0.12615795f, 0.19955796f, 
    0.07330865f, 0.05206620f, 0.09273878f, 0.01456959f, -0.42729381f, -0.21896775f, -0.26597452f, -0.10260347f, 
    -0.04083360f, 0.06182565f, 0.04936538f, 0.03038982f, 0.01728046f, -0.00121463f, -0.08291011f, 0.01525019f, 
    0.17154959f, -0.01964125f, 0.23360834f, 0.16637357f, -0.06693071f, 0.07273877f, -0.14803600f, -0.24719051f, 
    0.01567743f, -0.09212333f, 0.08985648f, -0.06615751f, 0.22121000f, 0.12505908f, 0.35176253f, 0.12414446f, 
    0.04383494f, -0.08654167f, -0.16303703f, -0.06945597f, 0.09660196f, 0.06153727f, 0.17967574f, 0.01146182f, 
    0.12233080f, 0.13915156f, 0.10873733f, 0.01837252f, 0.04829966f, 0.09458990f, -0.05613556f, 0.07743402f, 
    0.02047037f, 0.01043092f, 0.10867900f, 0.09338975f, 0.09484623f, 0.17252496f, -0.15407890f, 0.03253751f, 
    -0.22421744f, -0.05039682f, 0.05490027f, -0.12240243f, 0.01948896f, 0.08030958f, 0.01244617f, 0.14211953f, 
    -0.03488239f, -0.03655198f, -0.28309059f, -0.26992288f, 0.23229343f, 0.03662629f, 0.18817288f, -0.08447962f, 
    -0.07424427f, -0.01130636f, -0.01095171f, -0.05560295f, -0.34924835f, 0.20060776f, -0.24688405f, -0.12006202f, 
    -0.06506135f, 0.04668847f, 0.18326581f, -0.19674243f, 0.07165716f, 0.02648623f, -0.01102056f, 0.15167011f, 
    -0.14308318f, -0.09009515f, -0.14752720f, -0.00836741f, 0.08885758f, 0.05614929f, 0.09698949f, 0.13417239f, 
    0.07691215f, 0.03874616f, 0.07817401f, -0.27514252f, 0.10321125f, 0.05809503f, -0.18814170f, 0.10176405f, 
    -0.10835236f, -0.03511822f, -0.03158346f, 0.11615896f, 0.05000283f, 0.01680510f, 0.09082732f, 0.07249905f, 
    0.12413175f, -0.17505465f, 0.06199629f, -0.11308134f, 0.15211886f, -0.00037786f, -0.18690841f, -0.01492126f, 
    -0.00515987f, -0.19428995f, 0.03043364f, -0.30640256f, 0.07433511f, -0.02204322f, 0.16520815f, -0.03436809f, 
    -0.07763899f, 0.19640878f, -0.21921524f, 0.21125191f, -0.01299706f, -0.08141789f, 0.06248183f, 0.02021057f, 
    0.04863772f, -0.10264928f, 0.08443013f, -0.17329648f, 0.01660328f, 0.09899526f, 0.04272839f, 0.06385644f, 
    0.12958260f, 0.09044820f, 0.06118945f, 0.06266166f, -0.21832120f, 0.01247898f, -0.43055594f, 0.32694021f, 
    0.04774972f, -0.03784654f, 0.19672793f, 0.13162638f, 0.06654342f, -0.00469826f, 0.03399279f, 0.20364513f, 
    -0.00526404f, -0.38640991f, 0.12522422f, -0.27425271f, 0.03355872f, 0.10541511f, 0.13266204f, 0.02373020f, 
    0.05995157f, -0.08032618f, -0.10673166f, -0.02772719f, -0.07286630f, 0.07586436f, 0.03662282f, -0.15916727f, 
    0.16051543f, 0.21289372f, 0.09702814f, -0.03761297f, -0.25202036f, -0.12008594f, -0.10925832f, 0.04181404f, 
    0.32101661f, 0.31063384f, 0.37463078f, 0.34499976f, 0.01750250f, 0.11123496f, 0.01281708f, 0.13066462f, 
    -0.04158800f, -0.01041756f, 0.02940627f, -0.02234734f, -0.53669626f, 0.04527247f, -0.05027525f, -0.17545475f, 
    0.04298112f, 0.07444502f, -0.04033141f, -0.12609977f, 0.12932007f, 0.11219554f, 0.12942305f, 0.19126061f, 
    -0.20680697f, -0.02834900f, -0.05496252f, -0.05948066f, -0.13327751f, 0.01704915f, -0.11107679f, -0.08772406f, 
    0.09172885f, 0.01787671f, 0.05380141f, 0.01201760f, -0.66288501f, -0.28145424f, -0.26246265f, -0.28907508f, 
    -0.08487419f, -0.09455448f, -0.03353169f, -0.07960416f, 0.03437369f, 0.14710698f, 0.01883223f, -0.03580973f, 
    -0.08220506f, -0.12756006f, 0.00995845f, 0.01045980f, 0.05964939f, -0.03243352f, -0.02853981f, -0.02959186f, 
    0.00252756f, 0.08841743f, 0.20859906f, 0.00477800f, -0.24413757f, -0.26209372f, 0.03612645f, 0.21903744f, 
    0.09421304f, 0.02636555f, -0.01555682f, -0.10605004f, 0.02943654f, 0.07348128f, 0.05800407f, 0.01804355f, 
    -0.01204784f, -0.29676661f, 0.08383947f, -0.28198045f, 0.01826995f, -0.01710830f, -0.03809121f, -0.13188855f, 
    -0.08728723f, 0.03889649f, -0.01151625f, 0.02670275f, 0.06114625f, 0.28338560f, 0.18775597f, 0.28158435f, 
    -0.08946095f, 0.09865975f, -0.00179754f, 0.05438913f, -0.06262264f, 0.11738829f, -0.01565859f, -0.06710584f, 
    0.17695178f, 0.13896871f, -0.05561021f, -0.21430789f, 0.00394223f, 0.06680831f, 0.10401934f, 0.18509740f, 
    0.09344009f, 0.07328629f, 0.05824344f, -0.04039725f, -0.01341411f, -0.00062063f, -0.16549361f, 0.07213633f, 
    -0.06625029f, 0.07399680f, -0.01330681f, 0.12242880f, 0.14542888f, 0.10231471f, 0.12483654f, 0.11082417f, 
    -0.01463654f, -0.02562218f, 0.22604412f, 0.04818066f, 0.03509642f, 0.03450055f, -0.05244567f, 0.07829040f, 
    0.01047473f, -0.13554212f, -0.04406465f, -0.08360492f, -0.11641493f, -0.18163438f, -0.09946981f, -0.17971669f, 
    -0.02891246f, -0.10291351f, 0.04684085f, 0.02713457f, 0.03236837f, 0.14019796f, 0.12107273f, 0.01605683f, 
    0.10663120f, 0.27382368f, 0.11180235f, 0.13126053f, 0.02620707f, 0.17829901f, 0.03085447f, 0.04407408f, 
    -0.09910429f, 0.06325293f, -0.02640888f, 0.03258888f, -0.44186983f, -0.15038966f, -0.14058818f, -0.38081777f, 
    -0.09388313f, -0.04768748f, -0.00234172f, -0.08215872f, 0.06894650f, 0.08832487f, 0.11215699f, 0.01492450f, 
    -0.01734315f, -0.04946214f, -0.09773915f, 0.03165533f, 0.08864211f, -0.01645707f, 0.03818953f, -0.07995506f, 
    0.07023380f, 0.13384411f, 0.21882260f, 0.11377754f, -0.15981260f, -0.03722401f, -0.26580992f, -0.14118969f, 
    -0.11352769f, -0.19713238f, -0.01552284f, -0.11112616f, 0.01018696f, -0.12111118f, -0.04836323f, -0.01695896f, 
    -0.22129503f, 0.24150179f, -0.07250404f, -0.07812104f, 0.03480108f, 0.08686965f, -0.01811001f, -0.04757962f, 
    -0.05190730f, 0.15161595f, -0.13420513f, 0.01935775f, -0.23511483f, 0.12127414f, -0.04760603f, 0.36025241f, 
    -0.10239574f, 0.05899433f, 0.00587052f, 0.03033262f, -0.15053345f, 0.06456771f, 0.00311031f, -0.00771985f, 
    0.06896657f, -0.00895000f, 0.13376023f, -0.15857854f, -0.04804564f, 0.02747691f, 0.08435546f, -0.01316272f, 
    0.03690125f, -0.00546518f, -0.03419806f, 0.14140327f, -0.28409824f, 0.02106146f, -0.22961308f, -0.11286402f, 
    0.02552582f, 0.09979181f, -0.06816244f, -0.08842360f, -0.07689241f, -0.04616054f, -0.17059915f, -0.16391122f, 
    0.28999203f, 0.23337305f, 0.19763957f, 0.27776498f, 0.17807630f, 0.02706953f, 0.08088401f, 0.12003785f, 
    0.03537759f, 0.12454563f, -0.13862337f, -0.18781100f, -0.23443186f, -0.05913800f, 0.00386625f, -0.07804629f, 
    0.01232045f, -0.03465537f, -0.07036592f, 0.01189309f, -0.05302970f, -0.03319744f, -0.02779191f, 0.04745368f, 
    0.09810627f, 0.17801324f, 0.32999286f, 0.46279931f, -0.00667449f, 0.12532000f, -0.01635215f, 0.16096933f, 
    -0.01608719f, 0.04182539f, 0.00861267f, -0.02844465f, -0.42520744f, -0.19592236f, -0.25654933f, -0.12076206f, 
    -0.12358556f, -0.00704029f, -0.18904309f, 0.05325481f, 0.01710357f, -0.00786927f, 0.05907049f, 0.00070242f, 
    0.06042549f, 0.25475496f, 0.24656832f, 0.08430622f, -0.03468482f, 0.02161455f, -0.04559639f, 0.25622571f, 
    0.05907175f, -0.04190340f, 0.11680680f, -0.03514951f, 0.08242020f, -0.09879748f, -0.09650990f, -0.30249080f, 
    -0.13661698f, -0.12613982f, -0.06739312f, 0.01260148f, 0.01796744f, -0.05188203f, -0.02160268f, -0.00165429f, 
    0.29404578f, 0.26792145f, 0.11329053f, 0.21629432f, -0.01897899f, 0.13656674f, 0.12173942f, 0.19294991f, 
    0.00681445f, 0.10701561f, 0.11490955f, 0.08519206f, -0.06728281f, 0.09191611f, -0.13332988f, -0.09318107f, 
    -0.02154540f, -0.00554674f, 0.09112342f, -0.02928948f, -0.00849808f, -0.12102452f, 0.04229833f, 0.07060649f, 
    0.13262084f, 0.40639108f, 0.11868666f, 0.26019698f, 0.24803296f, -0.02456740f, 0.05050641f, 0.13338462f, 
    0.02985037f, -0.09847534f, -0.14784370f, 0.01534380f, 0.11338079f, -0.02621893f, 0.04525840f, 0.02666749f, 
    -0.00324007f, 0.00075172f, -0.09862947f, -0.08987050f, 0.09700844f, -0.19801754f, 0.04286836f, -0.08433742f, 
    -0.00443378f, 0.09820779f, -0.17994635f, 0.39038131f, -0.11470760f, 0.06521475f, 0.01994612f, 0.21141009f, 
    -0.05433445f, 0.07890067f, -0.11287171f, 0.14054869f, 0.24257004f, 0.25197077f, 0.25076270f, 0.32959226f, 
    -0.17892458f, 0.08164760f, 0.02139368f, 0.11771446f, 0.07896174f, 0.00360813f, 0.04718341f, 0.06525182f, 
    -0.08386856f, -0.12988849f, 0.01981748f, 0.11278009f, -0.05915233f, 0.11163576f, 0.11316701f, -0.04493909f, 
    -0.09998416f, -0.04621338f, 0.03860898f, 0.08252069f, 0.18884930f, 0.26574093f, 0.13659568f, 0.25674185f, 
    -0.00036263f, 0.12541215f, 0.20126145f, -0.12361352f, 0.01714077f, 0.16777544f, 0.19853982f, 0.19758195f, 
    0.21551046f, 0.10378988f, 0.11400340f, 0.05966403f, 0.06166274f, -0.09274256f, -0.01015861f, 0.05084870f, 
    -0.03196540f, 0.09538497f, 0.06329435f, 0.08416811f, -0.04801648f, 0.07174955f, -0.06993152f, -0.35471275f, 
    -0.21548866f, -0.22637522f, -0.17412360f, 0.00850394f, -0.13608594f, 0.05915640f, -0.05367338f, -0.08948170f, 
    -0.39456257f, 0.13549025f, 0.12988560f, 0.13917397f, -0.03315790f, -0.02464609f, 0.05281585f, 0.14704038f, 
    -0.04147237f, -0.00270534f, -0.04968596f, 0.12162121f, -0.10277613f, -0.01759965f, 0.55669051f, -0.07624017f, 
    -0.04770888f, -0.03689410f, -0.13931772f, 0.00796824f, 0.07344358f, 0.02558423f, 0.07704006f, 0.16975212f, 
    -0.28072724f, -0.05003779f, -0.37247911f, -0.48354232f, 0.01391486f, -0.11920553f, 0.02549138f, -0.23061422f, 
    -0.07311207f, 0.04318109f, 0.05230067f, -0.07874599f, -0.00147754f, -0.08839697f, -0.04863860f, -0.00910759f, 
    -0.02295254f, -0.15593316f, -0.11020611f, -0.02813115f, 0.05220117f, 0.08482649f, -0.02113692f, 0.01920225f, 
    -0.11742389f, -0.01122864f, 0.14375277f, -0.08834504f, -0.08448952f, -0.01377438f, 0.03821916f, 0.15209854f, 
    -0.07327186f, 0.01061741f, 0.02936388f, -0.12114867f, 0.12321126f, 0.18264803f, 0.05096515f, -0.05467126f, 
    0.06007770f, 0.00475548f, 0.24654248f, -0.00417641f, 0.12792483f, 0.10116387f, 0.11882253f, 0.29831520f, 
    -0.05959234f, 0.22417088f, -0.16373713f, 0.01288782f, 0.10831829f, -0.10306716f, 0.05654043f, 0.08600973f, 
    0.27851620f, 0.34722513f, 0.33281720f, 0.30421570f, -0.03074923f, 0.11630524f, 0.04005288f, -0.21959269f, 
    -0.13513930f, -0.03067155f, -0.14683075f, -0.09648071f, -0.02864881f, -0.00587771f, 0.02719602f, -0.07049451f, 
    -0.04662210f, 0.21452624f, -0.17125048f, 0.21332762f, 0.10086987f, 0.03043373f, 0.08323283f, 0.00995804f, 
    -0.05344104f, 0.00126116f, 0.19739917f, -0.06606016f, -0.17460284f, 0.09422005f, -0.23607020f, -0.25946307f, 
    -0.02358570f, -0.16345192f, -0.10147648f, -0.04422546f, -0.05377014f, -0.04474655f, -0.09447240f, 0.00412544f, 
    -0.02023775f, -0.14314651f, 0.02881167f, -0.21651970f, 0.04394617f, -0.20008583f, 0.04836134f, 0.09565767f, 
    -0.02937752f, 0.10009579f, 0.14648564f, 0.12987660f, -0.31631169f, -0.03293725f, -0.02864231f, -0.20302571f, 
    -0.02954100f, -0.06311066f, -0.08686791f, -0.06183402f, -0.00669576f, 0.05228499f, -0.15392517f, -0.14800651f, 
    -0.12259077f, 0.00515015f, -0.22097726f, -0.02724835f, 0.31336376f, 0.17953636f, 0.07415441f, 0.26984775f, 
    0.08464717f, 0.16108161f, 0.22080891f, 0.16002958f, 0.14055324f, -0.11337482f, 0.08297756f, 0.11469070f, 
    0.20896725f, 0.04545299f, 0.14882849f, 0.10288396f, 0.03454717f, 0.00228706f, 0.07631036f, -0.07273667f, 
    0.45991129f, -0.10652857f, -0.09863400f, -0.08829028f, 0.02432759f, 0.12470522f, 0.04291281f, 0.18158454f, 
    0.01922945f, 0.17129591f, 0.15585549f, 0.06982341f, -0.06170089f, 0.09339987f, -0.16151732f, -0.16095524f, 
    0.05483336f, -0.10252663f, -0.06444369f, -0.05516506f, 0.06953835f, 0.16266397f, 0.23999235f, -0.08297223f, 
    0.08508545f, 0.08492345f, 0.16219710f, 0.14013511f, -0.00486104f, 0.03914674f, 0.13961343f, 0.25904986f, 
    0.00544593f, -0.00182524f, -0.05295102f, -0.20904335f, -0.02666492f, 0.38830280f, 0.01895783f, 0.16449507f, 
    -0.01331358f, 0.03637518f, 0.12412706f, 0.04269848f, 0.12312275f, 0.12447931f, 0.10423835f, 0.06620490f, 
    -0.42811444f, -0.48325503f, -0.21055591f, -0.02725509f, 0.11535130f, -0.08778788f, -0.18786539f, -0.25696939f, 
    -0.07110421f, -0.05910314f, -0.07243048f, 0.00093106f, -0.05335511f, 0.01296818f, 0.21598041f, -0.06866301f, 
    -0.04054407f, -0.17064610f, -0.12795861f, -0.17490789f, -0.16786332f, 0.03047229f, -0.04506653f, 0.01033786f, 
    -0.20174666f, 0.37369502f, -0.37031621f, 0.37048525f, 0.05473698f, 0.07929070f, 0.14468351f, 0.00242586f, 
    0.03993439f, -0.04778646f, 0.02934570f, 0.13267851f, -0.12334509f, 0.04921760f, 0.30936736f, -0.19067797f, 
    -0.04123387f, -0.09253870f, -0.04923976f, -0.07298792f, 0.02641835f, 0.20854911f, 0.07415026f, 0.10404333f, 
    -0.12237741f, -0.19908528f, -0.00627677f, 0.06032965f, 0.04466630f, -0.00528361f, -0.05896645f, -0.06500904f, 
    -0.06604579f, 0.02314325f, -0.04278229f, -0.11888813f, -0.02153054f, 0.27936050f, -0.03720218f, 0.06210985f, 
    -0.08848225f, -0.00443498f, 0.05325240f, 0.06698745f, 0.13396259f, 0.36935610f, 0.12417212f, 0.12635386f, 
    -0.42367175f, 0.04527021f, 0.19132373f, 0.22928984f, -0.09057307f, 0.06756087f, 0.18713172f, 0.03921711f, 
    -0.07436141f, 0.07895984f, 0.03379213f, 0.02341168f, -0.08045743f, -0.07109816f, 0.40343016f, 0.08556101f, 
    -0.06042849f, -0.02327992f, -0.02032096f, 0.26741394f, 0.03458162f, 0.24885635f, -0.04344810f, -0.05779435f, 
    -0.20488748f, 0.19214702f, 0.20289537f, 0.35536277f, 0.04026870f, 0.02671053f, 0.17435551f, -0.08872508f, 
    0.03212998f, 0.01271386f, 0.11438494f, 0.09266029f, -0.01502975f, -0.26106235f, -0.08822223f, 0.11327495f, 
    0.06959119f, -0.00911027f, 0.05110833f, 0.14246003f, -0.11011890f, 0.02537908f, -0.04152790f, -0.13074641f, 
    -0.16052650f, -0.03825246f, -0.02583742f, 0.00257550f, 0.02132607f, -0.06407650f, 0.25215104f, -0.02674626f, 
    -0.11205126f, -0.08765450f, -0.09069602f, 0.06045573f, 0.11646525f, 0.20603926f, -0.24005485f, 0.08768664f, 
    -0.06203543f, 0.07157937f, -0.10569648f, -0.07179395f, 0.24448720f, 0.06179422f, 0.02137378f, -0.10992267f, 
    0.07212409f, 0.16503552f, -0.16552037f, -0.03661905f, -0.26019979f, 0.13613504f, -0.02624829f, -0.01056102f, 
    0.07033225f, 0.19730300f, -0.10938191f, -0.08111598f, 0.04666371f, -0.05535673f, -0.02648987f, 0.04220229f, 
    -0.02122150f, -0.13049798f, -0.02887350f, -0.01792786f, -0.02926689f, -0.09610169f, 0.01311451f, -0.00279778f, 
    0.39756262f, 0.17476179f, -0.07886320f, -0.08517260f, 0.15419333f, -0.04449655f, 0.09065293f, 0.02247176f, 
    0.07279523f, 0.01165357f, -0.02509714f, 0.11566694f, 0.25301355f, 0.03651368f, 0.09057701f, -0.02616366f, 
    0.00142803f, -0.04281747f, 0.05585445f, -0.02657508f, 0.03137722f, -0.04561497f, 0.04131564f, -0.05043032f, 
    0.27891630f, 0.07850258f, 0.12389772f, 0.06222701f, 0.08057930f, 0.00072540f, 0.04940513f, 0.02652130f, 
    0.12353081f, -0.06783991f, 0.15813570f, -0.01989100f, -0.17987037f, -0.13743196f, -0.03481022f, -0.03338359f, 
    -0.10007276f, 0.08948171f, -0.03236882f, -0.00379936f, -0.05232431f, 0.01724052f, -0.03480384f, 0.10527489f, 
    0.01819614f, 0.07762690f, 0.07177887f, -0.19495018f, -0.00208747f, -0.08922744f, 0.04905032f, -0.05822008f, 
    -0.02604136f, 0.08436812f, -0.08511954f, 0.04031738f, 0.00892488f, 0.02903952f, -0.08263395f, 0.20761500f, 
    -0.05491928f, 0.03060502f, -0.02737646f, 0.02929763f, -0.12351459f, -0.14162645f, 0.13790749f, 0.02305902f, 
    0.28356427f, 0.19617729f, 0.26582202f, -0.12626435f, -0.02247059f, -0.08866751f, 0.00999954f, 0.07463700f, 
    0.10191295f, 0.28397256f, 0.05018174f, 0.16028692f, -0.07416208f, -0.03254746f, 0.00257951f, 0.03843503f, 
    -0.04413730f, -0.10963474f, -0.08442383f, -0.10652105f, -0.09823302f, -0.17088610f, -0.15400772f, -0.07122048f, 
    -0.02036993f, -0.12234438f, 0.06164465f, -0.00404619f, 0.06164214f, 0.07902222f, 0.06394234f, 0.19560666f, 
    0.00331812f, 0.12955292f, 0.01314709f, -0.00636882f, 0.06537476f, 0.06441302f, 0.16392539f, 0.04165752f, 
    -0.04409629f, -0.05539994f, -0.00685676f, -0.03226513f, -0.02709002f, -0.05759344f, -0.00689061f, 0.00695518f, 
    -0.06556869f, -0.06599974f, 0.04409822f, -0.02968328f, 0.09121381f, -0.14558822f, 0.12579115f, -0.14960518f, 
    0.07923420f, -0.01155050f, -0.05634951f, -0.08663385f, 0.06918769f, -0.02427370f, 0.01304613f, -0.05633036f, 
    0.08652687f, -0.10766932f, 0.14645606f, -0.03578088f, 0.12810776f, 0.07651705f, 0.13902654f, -0.06386355f, 
    0.15220252f, 0.27933997f, -0.02196830f, -0.33129358f, -0.25447103f, 0.01897821f, -0.12229979f, 0.32762292f, 
    0.02616734f, 0.06660430f, -0.06425331f, 0.02727253f, -0.21787323f, -0.04875244f, -0.32653502f, -0.07321120f, 
    -0.34095648f, 0.01907407f, 0.11118674f, -0.00446792f, 0.01219906f, -0.20287926f, -0.20044181f, 0.03764695f, 
    0.36071780f, 0.06789449f, 0.02726858f, -0.03593982f, -0.07986482f, 0.03013186f, -0.08142992f, -0.06697492f, 
    0.12712415f, 0.03890029f, 0.13039015f, 0.10208967f, 0.18165624f, 0.20319486f, 0.00044770f, -0.10212876f, 
    -0.02310613f, -0.00072022f, -0.00549131f, 0.09061829f, 0.00171662f, 0.00100014f, 0.17928658f, 0.01611269f, 
    0.16622740f, 0.03487980f, 0.10149802f, 0.12175482f, -0.15837367f, -0.04545731f, 0.06835752f, 0.05446278f, 
    -0.01290067f, -0.02580089f, 0.18592766f, 0.09084258f, 0.25157675f, 0.14452541f, -0.24264839f, 0.05595570f, 
    -0.14063811f, 0.01283021f, -0.01155942f, -0.01597797f, 0.14648814f, 0.14891016f, 0.18101545f, 0.00946452f, 
    -0.25646472f, -0.31996611f, -0.24936379f, 0.03402345f, 0.01756124f, 0.11173739f, -0.06155041f, -0.03978896f, 
    0.06967404f, -0.17854464f, -0.06067187f, -0.09655098f, -0.00156086f, 0.19028398f, 0.10332666f, -0.12145106f, 
    -0.17020337f, 0.03227545f, -0.00372944f, -0.08918438f, -0.06714772f, 0.03275232f, -0.05750572f, -0.02697266f, 
    -0.38619983f, 0.11347217f, -0.24628800f, 0.00601355f, 0.17613506f, 0.27696726f, -0.11294119f, 0.08202939f, 
    -0.08528257f, -0.03193012f, 0.00219400f, 0.05117405f, 0.24070519f, 0.03637128f, 0.11564170f, 0.00004131f, 
    0.04114358f, -0.06640946f, -0.02399525f, -0.04588829f, 0.07669862f, 0.00527108f, -0.04904640f, 0.06474214f, 
    -0.15965585f, -0.30051371f, -0.06255087f, 0.02757307f, -0.05744974f, -0.22975667f, -0.19154939f, 0.02101742f, 
    -0.16400938f, -0.10508696f, 0.03555961f, -0.22170135f, 0.19972859f, -0.02311202f, -0.02315279f, -0.09289011f, 
    -0.03509599f, 0.12243033f, -0.08975947f, 0.11981307f, 0.08053192f, 0.12785412f, 0.11387115f, 0.16542555f, 
    -0.01914283f, -0.16377150f, 0.17929932f, 0.10508355f, 0.26324239f, 0.07750899f, 0.00195323f, 0.11772956f, 
    -0.00641094f, 0.16910931f, 0.18035462f, 0.14992455f, 0.18886802f, -0.03512869f, -0.34946692f, 0.08432247f, 
    -0.19602551f, -0.15140094f, 0.06319192f, 0.07352442f, 0.14976104f, 0.04846407f, -0.08169763f, 0.07556055f, 
    -0.19303000f, -0.05620415f, 0.09742957f, -0.20433302f, 0.07679167f, -0.01888218f, 0.15245505f, 0.08196180f, 
    -0.09278070f, 0.00168691f, -0.10948692f, 0.02022405f, -0.14072414f, -0.20076127f, -0.09425234f, 0.08212025f, 
    -0.01472463f, 0.03908864f, 0.00566939f, -0.06365533f, -0.11257524f, -0.11239198f, -0.05974780f, -0.12479604f, 
    0.34612131f, 0.32164040f, -0.03204869f, -0.04440676f, 0.08761338f, 0.03919077f, 0.03697999f, 0.10250881f, 
    0.04081831f, 0.00634124f, -0.09262325f, 0.09820897f, 0.37465349f, -0.45552090f, 0.10894937f, -0.20739356f, 
    -0.00658625f, -0.02433773f, -0.12355597f, -0.04720952f, 0.08808164f, -0.02968962f, 0.09366273f, 0.07397883f, 
    -0.19635980f, -0.18131252f, -0.20480670f, 0.09263765f, 0.21731506f, -0.13776450f, -0.06334059f, 0.08052089f, 
    0.05084924f, -0.01099214f, -0.09925107f, -0.09748704f, -0.24749349f, -0.40295583f, -0.41856214f, 0.12132911f, 
    -0.03520099f, 0.08540066f, -0.02740788f, -0.16100194f, 0.01266531f, -0.04987840f, -0.00197754f, -0.13730012f, 
    0.28043771f, -0.67028964f, -0.28319204f, -0.32219306f, 0.04919558f, -0.05612894f, -0.00605594f, -0.09269933f, 
    0.09729656f, 0.00751691f, 0.05251342f, -0.07100303f, -0.14667881f, 0.06283977f, -0.49759275f, -0.22238281f, 
    -0.07723796f, 0.06311183f, 0.14936139f, -0.03500941f, 0.03492099f, 0.07212292f, 0.06884516f, 0.07758306f, 
    -0.34542611f, -0.17959484f, -0.23961265f, 0.11036658f, -0.06611539f, -0.05556689f, -0.02028383f, 0.05522761f, 
    0.09647752f, 0.00357276f, 0.10143345f, 0.04570073f, 0.05942795f, 0.11767968f, 0.13809237f, 0.20929337f, 
    0.25735927f, 0.10280158f, 0.09917335f, 0.22166374f, 0.02050899f, -0.05413980f, -0.04307036f, 0.15781274f, 
    -0.38762528f, -0.22133805f, -0.41899389f, 0.21564178f, 0.22202112f, -0.00072871f, 0.07718468f, -0.13522896f, 
    0.03584752f, -0.02838619f, 0.16453390f, 0.07037044f, -0.20401025f, -0.17293845f, -0.01106591f, 0.11378605f, 
    0.12215165f, -0.15574116f, -0.06895208f, -0.05890327f, -0.02562379f, -0.02364522f, 0.09185503f, -0.01132565f, 
    -0.04730393f, -0.30505049f, -0.07113513f, 0.06755017f, -0.03718016f, -0.03895424f, 0.06163699f, 0.04108911f, 
    0.02706232f, 0.19160296f, -0.01028655f, 0.00300952f, -0.16773258f, -0.34464687f, -0.29670408f, -0.04678032f, 
    0.02195024f, 0.05917223f, -0.07025722f, 0.05638907f, 0.16487859f, 0.11063154f, -0.12893783f, 0.16423637f, 
    0.19991039f, 0.01840906f, 0.32312974f, 0.10453381f, 0.03129141f, -0.00092782f, 0.19688825f, 0.23141237f, 
    0.09089141f, -0.15597986f, 0.02686639f, -0.01019616f, -0.17783265f, -0.44842258f, -0.18110417f, -0.04024345f, 
    0.00518068f, 0.08200119f, -0.09655750f, -0.09789246f, 0.06383756f, 0.00526924f, 0.01103322f, -0.10439742f, 
    -0.01499445f, -0.08495422f, -0.07636425f, -0.19346160f, -0.06749429f, -0.07606867f, 0.03215417f, -0.00402260f, 
    0.06740916f, -0.04825716f, -0.21268660f, 0.00572728f, -0.00670787f, -0.12198871f, -0.28736046f, -0.25994393f, 
    -0.01266632f, -0.00337088f, 0.01550290f, 0.09471425f, -0.13565911f, 0.18066347f, 0.10309952f, 0.06007024f, 
    0.13715237f, -0.05670813f, 0.25991362f, 0.06329700f, 0.05752234f, 0.01985750f, 0.01485780f, 0.00435965f, 
    0.15429388f, -0.05057815f, 0.07870909f, 0.10181553f, 0.33229750f, -0.03037890f, -0.03630023f, -0.32322317f, 
    -0.02105324f, -0.07438470f, 0.26861826f, 0.00347553f, 0.07830395f, -0.00547285f, -0.03278117f, -0.01396049f, 
    -0.49046966f, -0.13403761f, 0.04555290f, 0.12802368f, 0.10068250f, -0.01039913f, -0.14868759f, -0.19079418f, 
    0.03573795f, 0.04891396f, 0.05597679f, -0.00689508f, -0.17534158f, -0.17871845f, 0.10843251f, 0.15454288f, 
    0.06541962f, -0.05118894f, 0.00889191f, -0.04538253f, -0.13456921f, -0.09673902f, 0.09963825f, 0.00538561f, 
    0.24826281f, 0.05460622f, 0.01668397f, -0.10228113f, 0.07625344f, 0.05036826f, -0.06005545f, -0.03873428f, 
    -0.00777840f, -0.06893867f, 0.16642581f, -0.04060366f, 0.33358523f, -0.47573799f, 0.15713236f, -0.01607051f, 
    -0.02552315f, -0.01730584f, -0.02091594f, -0.03784380f, 0.04444045f, -0.04728904f, -0.07888301f, 0.10255086f, 
    0.49696556f, 0.48193702f, 0.17670396f, -0.02384030f, -0.12932277f, 0.09194980f, -0.00718763f, 0.01594735f, 
    -0.18072514f, -0.08545658f, -0.02902059f, 0.03690653f, -0.09263226f, -0.41649544f, -0.48475626f, -0.06805159f, 
    0.02680991f, -0.10376982f, -0.09285046f, -0.19942275f, 0.05639200f, -0.05137942f, -0.02386224f, 0.04282803f, 
    0.31565383f, 0.02535143f, 0.21707180f, -0.17649695f, 0.00389177f, -0.09669427f, 0.29459190f, 0.08477892f, 
    0.01247552f, -0.02962870f, 0.00195507f, 0.03289422f, -0.31460479f, -0.40954897f, -0.52411157f, 0.06891335f, 
    -0.05701164f, 0.09087426f, -0.00715676f, 0.06306434f, 0.12253160f, 0.09136928f, 0.02800859f, 0.04583903f, 
    0.15874545f, 0.07260499f, 0.32300484f, -0.03138994f, 0.06282033f, 0.02127152f, -0.06064126f, -0.08009920f, 
    0.06540655f, -0.10459674f, 0.02627543f, -0.00451776f, -0.14281636f, -0.09427434f, 0.07797870f, -0.23722915f, 
    -0.04200913f, 0.04871434f, -0.14906001f, 0.05211759f, -0.08470211f, -0.06525693f, -0.07136609f, -0.10373425f, 
    0.38510582f, 0.08121029f, 0.19000550f, -0.10669043f, 0.07503183f, 0.02941564f, -0.05913801f, 0.14724106f, 
    -0.01792602f, 0.00430733f, 0.05655632f, -0.03449880f, 0.09522209f, -0.04372319f, -0.36339417f, 0.07906140f, 
    0.14871898f, 0.04839646f, 0.06009306f, -0.12834130f, -0.15203398f, 0.04427382f, -0.08113676f, 0.18486787f, 
    0.21570030f, 0.05407923f, 0.17919378f, -0.31050718f, -0.14341716f, 0.05157885f, 0.23577356f, 0.19649346f, 
    0.22262734f, -0.13833037f, 0.02963460f, -0.06368328f, 0.15709713f, 0.24124457f, 0.16385835f, 0.06486596f, 
    0.18299325f, 0.16586496f, 0.00421682f, -0.07655962f, -0.15831874f, 0.01831853f, -0.11012651f, 0.07219013f, 
    -0.02453308f, -0.00981783f, -0.00444473f, -0.03012134f, 0.04047555f, -0.00149394f, -0.00251870f, 0.01207998f, 
    0.01212539f, -0.02174528f, 0.04411919f, -0.03068575f, -0.02606263f, -0.00200120f, 0.00452994f, -0.01139108f, 
    -0.00175451f, 0.02890068f, -0.03855250f, 0.01834395f, 0.02782551f, -0.01924270f, -0.03493542f, -0.04888929f, 
    0.03204136f, 0.03337816f, -0.03180116f, -0.01035450f, 0.02253826f, -0.03800511f, -0.00188662f, -0.01193285f, 
    0.02636112f, -0.02629677f, -0.04855600f, 0.02818172f, -0.03703377f, -0.05136982f, -0.00798639f, -0.02548054f, 
    0.00511466f, 0.04131797f, 0.01688065f, -0.03317663f, -0.00772400f, 0.00417855f, -0.02201911f, -0.05859261f, 
    -0.02854797f, 0.03636621f, 0.03996942f, -0.04917059f, -0.02405453f, -0.02053046f, 0.02486883f, -0.01782965f, 
    -0.00614453f, 0.02660406f, -0.05188868f, 0.00207849f, 0.00975628f, -0.03947945f, -0.03142260f, -0.04350038f, 
    -0.05446066f, 0.03224093f, -0.00613118f, -0.05671137f, 0.01309596f, 0.01194687f, -0.04287468f, 0.03486683f, 
    0.02117868f, -0.03851699f, 0.02507966f, 0.00239777f, 0.04460413f, 0.02238845f, -0.03567019f, -0.03404211f, 
    0.02444316f, 0.01230055f, 0.00893147f, 0.02464090f, 0.00565816f, 0.00869391f, 0.02161219f, 0.01227287f, 
    -0.05207222f, -0.04852286f, 0.02002792f, -0.05368543f, 0.00545767f, -0.02132321f, 0.04198074f, -0.02422788f, 
    -0.03629420f, -0.04324214f, -0.00637217f, 0.02080630f, -0.04319499f, -0.00415697f, -0.00963109f, 0.01195160f, 
    -0.01284979f, 0.02468207f, -0.00596421f, 0.02780814f, 0.00341300f, -0.05497776f, 0.03654474f, -0.04107168f, 
    -0.06267001f, 0.00498552f, -0.03214641f, -0.05140116f, -0.01091149f, 0.00313180f, 0.02364370f, -0.03450142f, 
    0.02351578f, 0.02845244f, -0.04388965f, 0.02918656f, 0.00943867f, -0.05050614f, 0.01256142f, 0.03006751f, 
    -0.02290712f, -0.04815434f, -0.05053573f, -0.01240214f, 0.03879733f, 0.00984214f, -0.01003202f, -0.01711278f, 
    -0.05186838f, 0.03694076f, -0.00898926f, -0.01854695f, -0.01371773f, -0.03883608f, 0.03468731f, -0.02983271f, 
    0.02056660f, 0.03487102f, -0.02419592f, 0.00489323f, 0.02021407f, 0.03432071f, 0.02723181f, -0.03355439f, 
    -0.05036445f, -0.02791105f, -0.04899462f, -0.05166192f, -0.05581281f, -0.04182105f, 0.02215114f, -0.00294870f, 
    0.01024607f, 0.03845221f, 0.00647073f, 0.01433349f, 0.01732215f, -0.04213858f, -0.04424009f, -0.00327447f, 
    0.00246597f, -0.00083491f, 0.00172408f, -0.05119224f, -0.02251117f, 0.00807100f, 0.00746729f, 0.00156590f, 
    -0.02057655f, -0.02409129f, 0.03440248f, 0.04089411f, -0.05236570f, 0.03085223f, 0.02256684f, -0.01847599f, 
    -0.02146007f, 0.02771125f, -0.03803019f, -0.01703855f, -0.00396759f, 0.00913022f, 0.03028104f, -0.01020828f, 
    -0.00231050f, -0.02055492f, -0.00151811f, 0.04154442f, -0.02024189f, 0.01173188f, 0.02378398f, 0.03381537f, 
    -0.01050890f, -0.01691297f, -0.05119886f, 0.02228943f, -0.02251399f, -0.02013231f, -0.04006261f, -0.05146737f, 
    -0.03241368f, -0.00294974f, -0.04991329f, -0.04350619f, 0.00122599f, 0.01449768f, -0.03311611f, 0.02921999f, 
    -0.00850189f, 0.02004919f, 0.00229272f, -0.00206162f, -0.01547278f, 0.01392845f, 0.00680744f, 0.03298656f, 
    -0.02965850f, -0.00550073f, -0.05004488f, -0.04440620f, -0.02677931f, 0.04951258f, -0.00115619f, 0.00171102f, 
    -0.04960895f, -0.05185189f, -0.04949027f, -0.00036722f, -0.05262303f, -0.05558418f, -0.03354399f, -0.01851034f, 
    0.00233677f, -0.05261766f, -0.03720950f, 0.03114541f, -0.02681702f, -0.01242619f, -0.00747464f, 0.03284737f, 
    -0.03999107f, 0.03624543f, 0.02196721f, 0.02275162f, -0.01496181f, -0.03209756f, 0.03726614f, -0.01422747f, 
    0.01459015f, -0.00877200f, 0.02661556f, 0.01066383f, -0.00592831f, -0.00896156f, -0.02638673f, -0.02338773f, 
    0.04172559f, 0.00877235f, -0.00906653f, 0.02012496f, 0.02489983f, -0.04900865f, -0.00367144f, -0.01797869f, 
    0.03104637f, 0.00337331f, -0.02245195f, -0.04100733f, -0.03908474f, 0.00608390f, -0.02095150f, -0.04335977f, 
    0.03103388f, -0.01297349f, 0.01013546f, 0.02542827f, 0.00851028f, -0.02747668f, -0.04696150f, 0.01808918f, 
    -0.00869606f, 0.02656253f, 0.03240885f, -0.02895130f, 0.02709767f, -0.04251995f, 0.02206755f, 0.03232009f, 
    0.03587390f, 0.00967583f, -0.02981303f, 0.00872138f, -0.00152036f, -0.02588601f, -0.05300383f, -0.00616893f, 
    -0.05768127f, 0.03154557f, 0.02492711f, 0.00814745f, -0.02602273f, -0.01420390f, -0.05412628f, 0.03599443f, 
    0.02430414f, -0.05677200f, 0.03689384f, 0.03291262f, -0.01690656f, -0.02104579f, 0.01124779f, -0.01686656f, 
    0.01898443f, 0.01862810f, 0.04389588f, 0.02641360f, -0.03555414f, -0.06166356f, -0.02468645f, 0.00152914f, 
    -0.05193817f, -0.00557150f, 0.02322786f, 0.01233783f, -0.02311388f, 0.00318769f, -0.06140317f, 0.00426914f, 
    -0.05176016f, 0.02834576f, -0.02914877f, -0.01991966f, 0.01607485f, 0.00757393f, 0.03549163f, 0.03185026f, 
    -0.03621075f, 0.00940197f, -0.04950316f, -0.04760186f, -0.01118949f, 0.03534950f, -0.02490331f, -0.01851397f, 
    -0.01878120f, -0.00183177f, 0.00057282f, -0.05142654f, -0.03809793f, -0.03219335f, -0.03786144f, -0.01967537f, 
    -0.03047819f, -0.04819915f, -0.03025373f, -0.05966873f, -0.01852291f, -0.00266515f, 0.02183405f, -0.03656206f, 
    -0.03154343f, -0.01980761f, -0.02233740f, 0.00539729f, 0.03556493f, -0.02178867f, 0.00394468f, -0.00976249f, 
    -0.04166550f, -0.02146952f, -0.03762328f, -0.05442749f, 0.02091873f, 0.04353911f, 0.02963987f, -0.04930127f, 
    -0.24136835f, -0.01315075f, 0.03392810f, -0.08879121f, -0.17921557f, -0.03802013f, 0.04374196f, -0.10071765f, 
    -0.02708000f, 0.03634272f, 0.11264003f, -0.10940522f, 0.52279985f, -0.10601951f, -0.13915184f, 0.11493210f, 
    -0.04546580f, -0.11853017f, -0.00082224f, 0.31711581f, 0.01834283f, 0.06720706f, -0.04090837f, 0.01717537f, 
    0.01920659f, -0.34707454f, 0.02853253f, 0.01536663f, 0.03120484f, -0.02242487f, 0.10179128f, 0.09420054f, 
    -0.02083704f, -0.04287357f, -0.01293555f, 0.01405858f, -0.07937393f, -0.36034030f, -0.05262800f, -0.07066482f, 
    0.03620445f, 0.00555239f, 0.09043068f, 0.01357819f, 0.09434298f, -0.02887278f, -0.06214386f, 0.02741423f, 
    -0.24125145f, 0.02006619f, -0.10937582f, -0.23225509f, -0.04995938f, -0.02044928f, -0.07768005f, 0.03290477f, 
    0.06746193f, 0.02868896f, 0.02141351f, 0.19425955f, 0.01978719f, 0.41001773f, -0.19630700f, -0.23560174f, 
    0.06482513f, 0.13490438f, 0.05689713f, 0.01154141f, 0.06643226f, -0.05982343f, 0.04074961f, -0.07241227f, 
    -0.24039638f, 0.01357521f, -0.13203114f, -0.05844353f, 0.09168249f, -0.03779461f, -0.16201885f, 0.13706745f, 
    0.01521087f, 0.05529692f, -0.06456379f, 0.06851906f, -0.17862116f, -0.16102062f, 0.12120920f, 0.03319596f, 
    0.00795512f, 0.09478637f, -0.04439711f, 0.08396973f, 0.15139608f, 0.01411861f, 0.09505116f, 0.04200641f, 
    0.15311338f, 0.18978915f, 0.00934998f, 0.23360196f, -0.01899928f, -0.06036960f, -0.11114022f, -0.01287936f, 
    -0.03922471f, -0.01786662f, -0.06769872f, -0.00368181f, 0.10449594f, -0.01928885f, 0.00311716f, -0.00304630f, 
    0.08386743f, 0.03202937f, -0.01468701f, -0.16871424f, -0.01626752f, 0.03084344f, -0.17610995f, -0.07811840f, 
    -0.04743934f, 0.11660019f, -0.01078197f, 0.09449431f, 0.13320856f, -0.00609277f, -0.06734953f, 0.00444283f, 
    -0.11499902f, 0.06255781f, 0.10368710f, -0.10431409f, -0.13905859f, -0.04544807f, -0.07640757f, 0.07813884f, 
    0.19860040f, 0.25832736f, 0.29431644f, 0.03980397f, -0.10644022f, -0.12107208f, -0.06450389f, 0.02946556f, 
    -0.28573814f, -0.10741384f, 0.31205681f, 0.06305656f, -0.01069140f, -0.07112219f, -0.10879375f, -0.01160362f, 
    -0.05438941f, 0.11147086f, 0.10698196f, 0.15580007f, -0.00976655f, -0.18440095f, -0.10618596f, 0.14484419f, 
    0.07738812f, -0.06548239f, 0.04137997f, 0.03717148f, -0.02831119f, -0.08561532f, -0.08342459f, 0.05243374f, 
    0.09799287f, -0.07731632f, 0.02575766f, -0.13425985f, -0.07643163f, 0.03867650f, -0.08677778f, 0.06450301f, 
    -0.19893287f, -0.03827161f, -0.18660937f, -0.26409864f, 0.01210915f, -0.25659934f, 0.05525550f, -0.01349899f, 
    0.00887650f, 0.02875842f, 0.16628832f, 0.07602297f, 0.12454981f, 0.06029429f, 0.04031929f, 0.12665918f, 
    0.08205045f, -0.52842450f, 0.18674746f, 0.47556612f, -0.18648416f, 0.01900357f, -0.13785917f, 0.08982369f, 
    -0.00610522f, 0.00713005f, 0.09982277f, 0.03183860f, 0.13438042f, -0.25956517f, 0.23808636f, 0.41296592f, 
    0.05921811f, 0.07255758f, -0.07890976f, 0.02575062f, -0.03365872f, -0.14979291f, -0.05628720f, -0.10059811f, 
    -0.10668645f, -0.03592949f, -0.10186895f, 0.20985807f, -0.04711454f, -0.18312046f, 0.00182405f, 0.15008202f, 
    0.13902780f, -0.05713019f, 0.06745008f, -0.04330348f, -0.14745404f, -0.16103911f, 0.31484923f, 0.09414902f, 
    -0.00091307f, 0.02527656f, -0.08353217f, 0.03501629f, 0.13047762f, 0.09583749f, -0.02956948f, 0.16536921f, 
    -0.23308615f, 0.07475039f, 0.17587240f, 0.15433381f, -0.12249421f, -0.19946732f, 0.06485495f, 0.07442894f, 
    0.03856769f, -0.07348257f, 0.02225374f, 0.30335400f, 0.27501237f, 0.50152647f, -0.01201899f, 0.12476872f, 
    -0.01608395f, -0.07335033f, 0.02153806f, -0.08963973f, -0.00966884f, 0.12804805f, 0.09481504f, -0.02874547f, 
    0.00342744f, 0.20380926f, 0.28969070f, 0.07057264f, 0.03643798f, -0.04662614f, 0.07109078f, 0.06271449f, 
    0.00781098f, -0.03751687f, -0.08179266f, -0.05826034f, 0.37307674f, -0.19484024f, -0.35811746f, 0.11008372f, 
    0.01305567f, 0.14481361f, 0.11719586f, 0.12002937f, 0.03599122f, -0.00311450f, -0.07916579f, -0.10734047f, 
    0.15108655f, -0.48692647f, 0.63065726f, 0.00000296f, 0.23397347f, 0.10232315f, -0.01394116f, 0.12277060f, 
    0.06502814f, 0.01691375f, -0.04534107f, 0.04054555f, -0.04784354f, -0.08838077f, -0.14697000f, 0.01715351f, 
    0.18799163f, 0.08795362f, -0.01678514f, -0.16622458f, 0.16322865f, -0.02135398f, -0.01225043f, -0.00133199f, 
    -0.02175993f, 0.03029743f, 0.12709178f, 0.14541829f, -0.03323255f, 0.03952044f, 0.04587245f, -0.03903445f, 
    0.11880329f, -0.07563591f, -0.12692441f, -0.06898639f, 0.34654352f, -0.42454582f, 0.15936232f, 0.18263426f, 
    0.08076366f, -0.08974975f, 0.03816537f, 0.08076543f, 0.02640741f, 0.02354627f, 0.11334106f, -0.01118555f, 
    -0.05690330f, 0.12360791f, 0.23258002f, -0.07629074f, -0.10888338f, 0.11061000f, 0.11858641f, 0.04721036f, 
    0.06105386f, -0.13381572f, 0.00943923f, 0.11931565f, 0.10770591f, 0.31311405f, 0.06018732f, -0.30768591f, 
    -0.04413016f, 0.09209615f, 0.02286818f, 0.01228764f, 0.15402517f, -0.10998400f, 0.20618753f, -0.05328792f, 
    0.02438620f, -0.14066550f, 0.16349335f, 0.03899707f, 0.05389325f, 0.19148654f, -0.05942367f, -0.06722368f, 
    -0.07308562f, -0.11794236f, 0.00500145f, -0.16083933f, -0.07714908f, 0.07214638f, 0.18138281f, 0.03002561f, 
    -0.08016708f, -0.20182376f, 0.03937404f, 0.09356084f, 0.08076604f, -0.18530916f, -0.11232217f, 0.01073805f, 
    0.06808861f, 0.00282967f, -0.03547990f, 0.30126384f, 0.17312223f, -0.00562892f, 0.04472247f, 0.02253851f, 
    -0.08000273f, 0.03215774f, 0.00299711f, -0.13756588f, -0.33903632f, -0.37812030f, -0.13446276f, 0.40304068f, 
    -0.16309533f, -0.00583930f, -0.09304739f, 0.04169073f, -0.28477633f, 0.00401673f, 0.09470567f, -0.32316566f, 
    0.06877821f, 0.02648986f, -0.06477838f, -0.04778074f, -0.06347849f, -0.02523155f, 0.08985435f, 0.05516854f, 
    -0.07336520f, 0.01816647f, -0.13310260f, -0.01849482f, 0.19833072f, -0.00885260f, -0.24346334f, 0.05374922f, 
    0.20571293f, 0.00003937f, 0.08892995f, -0.23158358f, -0.06386349f, -0.23949580f, -0.07932615f, -0.09093902f, 
    -0.29064944f, -0.02315814f, -0.46202883f, 0.04685608f, 0.07400870f, -0.22521228f, -0.20090936f, -0.18900065f, 
    -0.06949519f, 0.04939476f, 0.07059195f, 0.07971219f, 0.17065604f, 0.24872750f, -0.13239242f, 0.20073104f, 
    0.19892336f, 0.11896446f, -0.17107497f, -0.02279825f, 0.04494606f, -0.08841079f, 0.02780019f, -0.26481202f, 
    -0.35362297f, 0.27218312f, -0.08965211f, -0.12276439f, 0.19779007f, 0.04135663f, 0.09573111f, -0.07105836f, 
    -0.10555632f, 0.04273618f, -0.03302861f, 0.11439966f, 0.23885986f, 0.07321377f, 0.07947499f, 0.02404459f, 
    0.03928519f, 0.06200095f, 0.06512903f, 0.15358564f, -0.16293925f, 0.08310144f, 0.18120566f, 0.04464804f, 
    0.10988662f, 0.45084974f, 0.23658001f, -0.00696019f, 0.14107767f, 0.00816250f, -0.01496147f, -0.07207930f, 
    -0.17089044f, -0.15833555f, -0.26317602f, -0.25406268f, -0.25521904f, 0.02899310f, -0.13144666f, -0.14667192f, 
    -0.12137837f, 0.08239329f, -0.04969902f, -0.15492952f, -0.16034454f, -0.28437671f, -0.25590488f, -0.36282563f, 
    -0.21462601f, 0.34277248f, -0.01342292f, -0.08987426f, 0.15318033f, -0.04212968f, 0.05560787f, -0.15423644f, 
    -0.30379772f, 0.03621783f, -0.02346787f, -0.01702446f, 0.02636112f, -0.08578567f, 0.08595131f, -0.13134903f, 
    0.09517018f, 0.10256176f, -0.10581359f, -0.08955273f, -0.20333780f, -0.11850753f, -0.35935012f, -0.50380319f, 
    0.16852932f, 0.13735737f, -0.10544289f, 0.15257154f, 0.05767751f, 0.11768865f, -0.04817306f, -0.00499786f, 
    -0.03401054f, 0.16006850f, 0.15205291f, 0.20370807f, 0.06562006f, -0.14479418f, -0.15166607f, -0.18231994f, 
    0.10901126f, -0.12088412f, 0.12893273f, -0.01795996f, -0.01833872f, -0.30383009f, -0.24212050f, -0.07002293f, 
    -0.05406892f, 0.27977413f, -0.13020457f, 0.05274301f, -0.01185010f, -0.12231255f, -0.23540269f, -0.01332588f, 
    -0.48682824f, -0.23741148f, -0.36528268f, -0.57858300f, -0.36560091f, -0.17707016f, -0.02727498f, 0.23965900f, 
    0.06848902f, 0.05842977f, 0.27167141f, 0.00699752f, 0.36729410f, 0.07927552f, 0.16177215f, 0.27369341f, 
    -0.07750845f, 0.31123793f, 0.19416349f, -0.48145980f, 0.08694777f, 0.12605923f, 0.10390534f, -0.20204030f, 
    -0.08792417f, 0.19544978f, -0.03318628f, 0.01646217f, 0.30826795f, 0.11607455f, 0.17333736f, -0.01605053f, 
    -0.11885408f, 0.00659030f, -0.08653517f, 0.07053871f, -0.15230063f, 0.05287714f, -0.03922218f, -0.14277683f, 
    0.50399834f, 0.12019017f, -0.21031415f, -0.07205199f, -0.10495888f, -0.08333005f, 0.09822531f, 0.00803377f, 
    -0.00400507f, 0.02690976f, -0.00453893f, 0.01580872f, -0.09105491f, 0.26387611f, -0.15221651f, -0.25490245f, 
    -0.11010960f, 0.05063840f, 0.05720861f, 0.01601802f, 0.12264826f, 0.02130163f, 0.21475503f, 0.35754395f, 
    0.16959353f, -0.03619472f, -0.05710637f, 0.22526447f, 0.12005538f, 0.16417897f, 0.07128438f, -0.04443767f, 
    -0.03548801f, 0.01126519f, 0.19083065f, 0.32135904f, 0.11044963f, -0.15889975f, 0.24638112f, 0.19110212f, 
    -0.05824310f, -0.11724238f, -0.03679460f, -0.09554589f, -0.01960230f, 0.23527548f, 0.07845442f, 0.15639046f, 
    0.38085344f, 0.17205320f, 0.09508497f, 0.10220797f, 0.01879015f, 0.12126469f, 0.05803455f, 0.27444124f, 
    0.17526549f, 0.02225016f, -0.01080897f, -0.18460110f, 0.20412359f, -0.21437442f, 0.15712954f, 0.12728834f, 
    -0.08320954f, 0.08189123f, 0.20377967f, 0.11556580f, -0.07647161f, -0.19266264f, -0.16585845f, -0.13844004f, 
    0.13355987f, 0.12323281f, 0.13734058f, 0.37339696f, 0.19886941f, -0.03952833f, 0.08278894f, -0.09208814f, 
    -0.00999872f, 0.04840605f, -0.05542762f, 0.06583224f, 0.01008112f, -0.12749240f, 0.12061960f, -0.01916148f, 
    0.10538932f, 0.15427986f, -0.23621030f, -0.19328478f, 0.16594341f, -0.10942024f, -0.17921737f, -0.08838377f, 
    0.16313468f, 0.23371905f, -0.24337246f, -0.03234096f, 0.13429303f, 0.08627678f, 0.06936744f, 0.01072956f, 
    -0.17027019f, -0.26830345f, -0.19739711f, -0.06474466f, 0.11983008f, 0.07644901f, -0.21983400f, -0.00595613f, 
    -0.02272664f, -0.05164737f, 0.04300949f, -0.11026192f, 0.00150803f, 0.15226562f, 0.22867946f, -0.01728431f, 
    -0.02019390f, 0.01813728f, -0.16228244f, 0.21367642f, 0.06381809f, 0.11676997f, -0.05168681f, 0.01248369f, 
    0.01766417f, 0.16853654f, 0.16197175f, 0.20999068f, -0.15335675f, 0.30214322f, 0.19565864f, 0.04258563f, 
    -0.12876882f, -0.12521000f, -0.02766035f, 0.14812666f, 0.10633438f, 0.17459767f, 0.25851059f, 0.16282654f, 
    0.03038451f, -0.19575484f, -0.09281334f, 0.17155723f, 0.07672887f, 0.15127443f, -0.28937352f, -0.18966444f, 
    -0.04582238f, -0.01779783f, -0.00990390f, -0.25034434f, 0.15714616f, 0.22918218f, -0.02643432f, -0.11171170f, 
    0.19454087f, 0.01106739f, -0.04890908f, -0.05302846f, -0.08389960f, -0.06563170f, -0.04187173f, -0.13654588f, 
    -0.05816940f, 0.13088666f, 0.12435992f, -0.03937593f, -0.00464861f, 0.13117744f, -0.04082649f, 0.00479653f, 
    0.02472821f, 0.03055735f, 0.04659834f, -0.10714915f, 0.02005916f, 0.02722659f, -0.18412620f, -0.27058852f, 
    0.04977979f, 0.00776167f, -0.19811718f, 0.18420184f, -0.09003969f, -0.01444689f, -0.08393132f, 0.13037094f, 
    -0.13818519f, -0.17584673f, 0.16715401f, -0.09795888f, 0.06298178f, -0.16065127f, -0.02347124f, 0.08305468f, 
    0.02387674f, -0.13235466f, 0.17754658f, -0.04051585f, -0.38144991f, -0.28636774f, 0.07462242f, 0.02361511f, 
    0.04528192f, -0.02273227f, 0.02001615f, 0.01699184f, 0.13458045f, -0.08160894f, 0.00933298f, 0.06113879f, 
    -0.41998494f, -0.10060212f, 0.05480653f, -0.31118751f, -0.08565708f, -0.03626335f, -0.15697534f, -0.09447306f, 
    0.16830446f, 0.03450960f, 0.01350224f, 0.08092766f, -0.24560384f, 0.08298679f, -0.32777873f, 0.03568837f, 
    0.14324169f, -0.18666409f, 0.00258842f, 0.05036166f, 0.13319768f, -0.01452831f, -0.08138587f, -0.11300407f, 
    -0.06366199f, -0.04712713f, -0.13639818f, 0.06396424f, -0.11236726f, -0.15139718f, -0.16172940f, 0.19287014f, 
    0.00054699f, 0.08155276f, -0.04462952f, -0.02677888f, 0.08056093f, 0.08482664f, 0.02537467f, 0.02895219f, 
    0.06178797f, 0.14665374f, 0.07241340f, 0.15070646f, 0.11805354f, 0.01578852f, 0.08338147f, 0.10692399f, 
    0.30407119f, -0.02503956f, -0.19503826f, 0.08965781f, 0.02601833f, -0.04851033f, -0.09951048f, -0.02706975f, 
    -0.04225868f, -0.13916688f, -0.07169817f, -0.18406452f, 0.09821603f, -0.10575808f, -0.06732579f, -0.01760393f, 
    0.08019076f, -0.12927046f, -0.06354520f, 0.02685151f, 0.02867085f, 0.09573893f, -0.28790808f, -0.23835599f, 
    0.05796473f, -0.10465919f, 0.11821739f, 0.06883901f, -0.09752631f, -0.06234929f, -0.02188957f, -0.04386682f, 
    -0.08419154f, -0.01283177f, 0.07180853f, -0.09734470f, -0.15185840f, 0.06170607f, -0.08181287f, 0.19996595f, 
    0.03889327f, 0.02388804f, 0.08432737f, 0.16002303f, -0.14572839f, -0.03061383f, -0.15418690f, -0.08374239f, 
    0.06856534f, -0.02858919f, 0.31047183f, 0.03791463f, 0.08271737f, 0.00333774f, -0.01406727f, 0.05808224f, 
    0.05130114f, -0.05381195f, 0.11462960f, 0.13794801f, -0.13305703f, -0.31006780f, -0.27066967f, 0.09353424f, 
    -0.11371353f, -0.15807377f, -0.00551471f, 0.02566427f, 0.02285555f, 0.12026781f, -0.11543670f, -0.08785486f, 
    -0.01104158f, -0.14107531f, 0.01760850f, 0.05426676f, -0.04019711f, 0.11598612f, -0.14184694f, 0.04516339f, 
    -0.14415190f, -0.33047670f, -0.14237812f, -0.50351131f, -0.10103107f, -0.25134641f, -0.02034662f, -0.10477269f, 
    -0.06371781f, -0.08129185f, -0.10173524f, 0.05837008f, 0.10863931f, 0.14388917f, 0.05649199f, 0.05211253f, 
    0.13182014f, -0.28973383f, 0.17566732f, 0.46054429f, -0.14336474f, -0.11716682f, 0.02038005f, -0.13358566f, 
    -0.06543506f, -0.19354065f, 0.03583677f, -0.06387100f, -0.19025612f, -0.17971382f, 0.51339477f, 0.13458079f, 
    -0.00048646f, 0.00150475f, -0.23000188f, -0.04517286f, -0.03845185f, 0.00070910f, 0.04285868f, 0.09751983f, 
    -0.28694317f, -0.00713851f, 0.04364501f, 0.24898021f, -0.18531063f, -0.16743675f, -0.22597927f, 0.03172537f, 
    0.10867085f, -0.16318972f, -0.17551079f, 0.00085041f, -0.04673901f, -0.15774284f, 0.26932070f, 0.30809253f, 
    -0.04822777f, -0.03901534f, 0.01281171f, 0.01375353f, 0.06244002f, 0.13085777f, -0.05487041f, 0.08393458f, 
    -0.03201335f, 0.12722275f, 0.18191379f, 0.13705149f, 0.02788181f, -0.04412607f, 0.09706119f, -0.03486810f, 
    -0.02765610f, 0.00028297f, 0.01724249f, 0.32568261f, -0.08773198f, 0.11892535f, -0.19505869f, -0.06999071f, 
    -0.07579809f, 0.02405729f, -0.00059974f, -0.15477188f, 0.03733097f, 0.19269185f, 0.04668849f, 0.16107994f, 
    0.09880954f, 0.33948475f, 0.25228938f, 0.05082133f, 0.11944102f, -0.01766424f, 0.13431258f, 0.18919843f, 
    0.06846895f, 0.09731465f, 0.10536081f, 0.04428769f, 0.08281793f, -0.09466334f, -0.30010211f, 0.15334241f, 
    -0.02548333f, 0.12338365f, -0.04167345f, 0.22917831f, 0.14147486f, -0.17247581f, 0.00754196f, -0.02920657f, 
    0.49949792f, -0.18809143f, 0.44599015f, -0.28939819f, 0.01732242f, -0.00542126f, 0.02924657f, 0.13063227f, 
    0.05521754f, 0.09157646f, -0.06981973f, -0.07115073f, -0.01035508f, -0.00625094f, -0.39451382f, 0.06029465f, 
    0.01392737f, -0.13816155f, -0.01513625f, -0.04014878f, 0.22398379f, -0.16053629f, 0.00258941f, -0.12269166f, 
    0.06500655f, 0.10167500f, -0.01481227f, 0.07328794f, 0.03615565f, 0.11482676f, 0.02895346f, 0.07795321f, 
    0.11193735f, -0.02748531f, -0.20512652f, -0.09697793f, 0.12599476f, -0.39073807f, 0.20614973f, 0.13553508f, 
    0.17530495f, 0.00181424f, -0.01434595f, 0.03084737f, 0.08084959f, -0.04053723f, 0.21283251f, -0.01496515f, 
    0.14515594f, 0.14432983f, 0.18530537f, -0.11164419f, 0.01707131f, 0.11510029f, 0.10405260f, 0.09300783f, 
    0.19400181f, -0.08678763f, 0.07170695f, 0.10183543f, 0.03107665f, 0.06439266f, 0.00126145f, -0.06423493f, 
    0.07580727f, 0.10463756f, -0.05837454f, -0.13536601f, 0.20468378f, -0.11078683f, 0.18314750f, 0.01804864f, 
    0.12541418f, -0.13875043f, -0.11420492f, -0.28662997f, 0.17861013f, 0.11593788f, 0.00929045f, 0.09094065f, 
    -0.09887204f, -0.06616002f, 0.02168667f, -0.31285450f, 0.07842364f, 0.18096183f, 0.16263039f, -0.03429878f, 
    0.07192060f, 0.05115691f, 0.04247508f, 0.12972237f, 0.08715485f, -0.11941717f, 0.01911803f, 0.02213113f, 
    -0.05260192f, 0.05222530f, -0.05536865f, 0.11538679f, 0.06589092f, 0.16314687f, 0.14769022f, 0.10939183f, 
    -0.00330125f, 0.04581328f, 0.26712117f, 0.22663572f, 0.15043193f, 0.09906118f, 0.18769027f, -0.01801415f, 
    0.02375600f, 0.09902580f, -0.13688564f, -0.10842636f, 0.01709603f, 0.08607981f, 0.00048295f, 0.19497998f, 
    0.19334152f, 0.18252063f, 0.21728155f, 0.21431167f, 0.09124224f, -0.10447612f, -0.04653239f, -0.08351712f, 
    -0.16231479f, -0.00411250f, 0.10012086f, -0.09964927f, -0.11448767f, 0.14359318f, 0.20284288f, 0.02950083f, 
    -0.16021004f, -0.14426407f, -0.25387287f, -0.02023151f, -0.03085351f, -0.05933734f, -0.12582335f, -0.04486515f, 
    -0.51983714f, -0.17292960f, -0.02271208f, 0.00473037f, -0.12170984f, -0.05482930f, -0.02640074f, -0.04726252f, 
    0.06068099f, -0.09775934f, -0.01755063f, 0.05085531f, -0.47468063f, 0.15743499f, 0.35690555f, 0.05013942f, 
    0.00042871f, 0.03147068f, -0.17948191f, 0.07755392f, 0.09767947f, 0.04970865f, 0.18905361f, 0.07344461f, 
    -0.05591753f, 0.09367110f, -0.30799213f, -0.24938375f, -0.17724815f, -0.14640462f, -0.04894114f, -0.18543623f, 
    0.01217250f, -0.07233307f, -0.04126501f, -0.03733887f, 0.01157794f, -0.03661570f, -0.02359013f, 0.00282169f, 
    0.11591627f, 0.05392203f, 0.06860080f, 0.06662921f, 0.09168996f, -0.03014001f, -0.04668909f, 0.05834901f, 
    -0.23378110f, -0.45290399f, -0.34236348f, 0.03442624f, -0.02966426f, 0.02755388f, 0.00070891f, -0.05592836f, 
    0.13445717f, 0.02104083f, 0.07511996f, 0.14781407f, 0.13108903f, 0.11525515f, 0.15361360f, -0.08211870f, 
    0.11781069f, -0.10712045f, 0.01329467f, 0.02245128f, 0.05784870f, 0.08857073f, 0.09353101f, 0.09019839f, 
    0.01256321f, 0.17216687f, -0.30283791f, -0.22883564f, 0.01518865f, 0.01593647f, 0.06767258f, -0.02559497f, 
    0.20561841f, 0.14284571f, 0.11932074f, 0.21535346f, -0.05079478f, -0.01324228f, -0.02389484f, -0.17460914f, 
    -0.10337505f, 0.01772702f, -0.09469128f, -0.09373531f, -0.01099326f, 0.05075930f, 0.07021820f, 0.14867298f, 
    -0.05539776f, 0.32795170f, -0.06962749f, -0.07731440f, 0.10292586f, 0.01231422f, 0.17385806f, 0.09899434f, 
    0.11159173f, -0.10187501f, 0.00015748f, 0.10734512f, -0.06455771f, -0.09798674f, -0.14643303f, -0.07947246f, 
    -0.13602430f, -0.10511567f, -0.08964719f, -0.13116105f, -0.01173883f, -0.06245307f, -0.14061444f, 0.03901102f, 
    -0.13712871f, -0.03890513f, 0.08745437f, -0.12146603f, -0.00357698f, -0.09925617f, 0.05105045f, -0.17791669f, 
    0.04210359f, 0.10238927f, 0.17193398f, 0.10179938f, -0.22471720f, 0.11387569f, 0.06461380f, -0.08966902f, 
    -0.08877727f, 0.02050621f, -0.22728139f, 0.01309750f, -0.06295241f, -0.01600312f, -0.02017489f, -0.26797703f, 
    0.25398317f, -0.24555132f, -0.27485624f, -0.27245677f, 0.29626796f, 0.06521823f, -0.03956258f, 0.01612827f, 
    0.21776631f, 0.01094109f, 0.11505748f, 0.15993625f, 0.35663882f, -0.06158215f, 0.37290218f, 0.13976377f, 
    0.16457583f, 0.00625806f, 0.15651321f, -0.05542174f, 0.03966890f, -0.11833219f, 0.10640164f, 0.09326497f, 
    0.27780265f, -0.06335172f, -0.02730544f, -0.09760108f, 0.01918316f, 0.08166266f, -0.07033750f, -0.17992993f, 
    -0.03189530f, 0.03604089f, 0.06386937f, 0.14525269f, 0.21450764f, 0.01121918f, 0.00873839f, -0.12452343f, 
    0.15008506f, -0.06593738f, -0.04975849f, -0.07720815f, -0.09880403f, 0.03693538f, 0.04774453f, -0.21206327f, 
    0.09256904f, -0.13843389f, 0.00952824f, 0.05063592f, -0.01069538f, 0.01052648f, 0.09406495f, 0.08729983f, 
    0.06729113f, -0.02767021f, -0.14556055f, -0.12974228f, -0.17170548f, 0.13281795f, -0.12714539f, 0.04166962f, 
    0.02142059f, -0.06317285f, 0.06521971f, -0.00073220f, 0.05448102f, 0.05398414f, -0.03012112f, -0.00703290f, 
    -0.21449013f, -0.26211703f, -0.03912216f, 0.03068852f, 0.17490789f, 0.16079178f, 0.06422788f, -0.00360658f, 
    -0.10725425f, -0.03504165f, 0.02211841f, 0.04921622f, 0.12587617f, -0.01171851f, 0.43300450f, 0.18352941f, 
    0.00944815f, -0.17535253f, -0.05151766f, -0.02251974f, -0.10116066f, 0.01394682f, -0.06370033f, 0.10644327f, 
    0.15687460f, 0.59241694f, 0.00482742f, 0.01088191f, 0.01695070f, 0.00687059f, 0.17995453f, 0.02836706f, 
    -0.05148033f, 0.10189740f, -0.08043101f, 0.14273377f, -0.22302940f, -0.10711005f, 0.03600034f, 0.13926095f, 
    -0.09264134f, -0.08880832f, -0.11247388f, -0.05708594f, 0.00884985f, 0.10603309f, 0.02432692f, 0.12982638f, 
    -0.18294603f, -0.33335507f, -0.03711536f, 0.03610659f, 0.09150104f, 0.03803972f, 0.13419230f, 0.00158240f, 
    0.04798879f, 0.06910243f, -0.01600175f, -0.01513428f, -0.02623379f, 0.18162706f, 0.16240154f, 0.01445209f, 
    -0.06847545f, 0.01928698f, -0.05205025f, 0.04700043f, 0.06186917f, -0.04696915f, -0.04108386f, 0.00429791f, 
    -0.25030276f, -0.03708165f, 0.16712768f, 0.00286173f, -0.03920504f, 0.19421968f, 0.12574750f, -0.08080985f, 
    -0.00649052f, -0.08245095f, 0.03723959f, -0.02492838f, 0.17589374f, -0.12979737f, 0.12332705f, 0.36178532f, 
    0.01609686f, 0.08936002f, 0.01193192f, 0.03640434f, 0.01225885f, 0.06687929f, -0.03203164f, -0.15874301f, 
    0.02336007f, 0.23170239f, 0.10424090f, -0.17849401f, 0.03075362f, 0.10557286f, 0.27814421f, -0.09012906f, 
    0.14749488f, 0.02163892f, 0.16652320f, 0.14363456f, 0.03550475f, -0.19074583f, -0.17512833f, 0.12248752f, 
    0.23652744f, 0.21488348f, 0.15207464f, 0.07428397f, 0.00567860f, 0.04106023f, 0.06154934f, -0.01969420f, 
    0.09860159f, 0.09343471f, -0.02494882f, -0.42712304f, 0.07190916f, -0.05624925f, -0.03141174f, 0.11848753f, 
    -0.07682218f, -0.00809102f, -0.10747935f, -0.11485556f, -0.03954208f, 0.13649888f, 0.16549718f, -0.10484068f, 
    0.10344340f, -0.09293613f, 0.08521663f, 0.07438411f, 0.10652384f, 0.14994876f, 0.08477385f, 0.06547733f, 
    0.16702244f, 0.05203113f, 0.09543985f, 0.15830305f, -0.02921912f, -0.02788078f, 0.00350990f, 0.01201503f, 
    0.11457728f, 0.04195496f, -0.02987967f, 0.03717924f, 0.24242042f, 0.18504208f, -0.01638231f, 0.05376980f, 
    -0.03224549f, -0.02702685f, -0.01929964f, -0.05292808f, -0.05934351f, -0.02998297f, 0.00321053f, 0.02911602f, 
    0.31688610f, -0.05111833f, 0.03888171f, -0.04060138f, -0.06631847f, -0.05673910f, 0.02410928f, 0.05371427f, 
    0.14001493f, 0.09660847f, 0.04742672f, -0.06558672f, 0.38441557f, -0.04565768f, -0.02765354f, -0.14459114f, 
    0.03858745f, 0.00351735f, 0.13290544f, -0.03784798f, -0.09160498f, -0.02001110f, -0.05583785f, 0.06880268f, 
    -0.02131008f, -0.12117714f, 0.08261649f, 0.11576011f, -0.13265713f, -0.04557664f, -0.05213312f, 0.01018840f, 
    0.40138215f, 0.18536042f, 0.17929879f, 0.13863085f, -0.13879316f, -0.05383758f, -0.12616505f, -0.02607393f, 
    0.01535232f, 0.03421484f, 0.04995979f, -0.08010536f, 0.22315405f, 0.21592383f, 0.04984310f, -0.00556904f, 
    -0.20343226f, -0.00910875f, 0.05158857f, 0.06443013f, -0.01190037f, -0.04994062f, 0.03559593f, -0.01385409f, 
    -0.02748354f, -0.14175460f, -0.07991438f, -0.01830290f, -0.03124647f, -0.19925006f, 0.04162747f, 0.09396344f, 
    0.11503094f, -0.00918058f, 0.04522239f, 0.03275977f, -0.00202277f, -0.08247484f, 0.13017851f, 0.03429211f, 
    0.16974688f, -0.21104306f, 0.31584799f, 0.30592698f, -0.10812823f, 0.03598288f, -0.02514179f, 0.01659410f, 
    0.05883261f, 0.09526214f, 0.00155438f, 0.10077722f, -0.00027587f, -0.05655048f, -0.14208457f, 0.03202582f, 
    0.27365944f, -0.07765943f, -0.00591029f, -0.01934787f, 0.03274336f, -0.15353917f, -0.10296099f, -0.04125719f, 
    -0.01794678f, -0.39913365f, 0.08653490f, 0.11853065f, 0.00477693f, -0.00556545f, 0.12583812f, 0.08881844f, 
    0.31213677f, 0.13931395f, 0.05513062f, -0.04129232f, 0.20346163f, 0.08789129f, 0.06903329f, 0.06630678f, 
    -0.02576429f, 0.03929471f, -0.07432840f, -0.05714263f, 0.02884903f, -0.02294208f, 0.10390590f, 0.15558705f, 
    -0.02684885f, -0.03648186f, -0.04798792f, 0.09698910f, 0.05047175f, -0.15377870f, -0.01826507f, -0.03871455f, 
    -0.12154729f, -0.04532453f, -0.07947395f, -0.05502642f, 0.07697044f, 0.04722265f, -0.00806540f, -0.01325091f, 
    -0.02467653f, -0.04854932f, -0.08651450f, 0.00471722f, 0.12488704f, 0.01853994f, 0.05915826f, 0.07006529f, 
    -0.16925345f, 0.16914251f, 0.07389013f, 0.28919598f, -0.17906775f, -0.21027996f, -0.01388872f, -0.09746098f, 
    0.23484014f, -0.11379152f, 0.10427472f, 0.17352104f, 0.06840190f, 0.42659420f, -0.42793894f, -0.24497433f, 
    0.14274222f, -0.02016440f, 0.21286455f, 0.04203660f, 0.01246763f, -0.04169206f, 0.05816367f, 0.03151818f, 
    -0.49497366f, 0.22836316f, -0.00136523f, 0.09049661f, 0.05706357f, -0.04054401f, -0.10032034f, -0.06704395f, 
    0.06128370f, 0.00264246f, 0.02243816f, 0.16141710f, 0.14805950f, 0.05027041f, 0.12676266f, 0.25732037f, 
    -0.02930885f, -0.12346835f, -0.02811759f, -0.04442371f, 0.06120389f, -0.10168389f, 0.05125624f, 0.13918668f, 
    0.03004504f, 0.10611109f, 0.16697417f, -0.14245413f, 0.04981739f, 0.00381884f, -0.02202852f, -0.08872199f, 
    0.11378913f, 0.00457714f, 0.22113314f, -0.10369157f, 0.25578880f, -0.09375660f, 0.18703324f, -0.22818366f, 
    0.00753765f, 0.05881684f, -0.00510852f, 0.01272487f, 0.19955091f, 0.03376678f, 0.12223712f, 0.07278389f, 
    0.10458154f, 0.21827377f, 0.03252294f, -0.10134701f, -0.35063252f, -0.19386606f, -0.03379665f, -0.02673614f, 
    -0.06064123f, -0.10769285f, -0.07054472f, -0.03370088f, 0.01624541f, 0.09646516f, -0.09131230f, 0.23339164f, 
    0.05256070f, -0.12987086f, 0.02123278f, -0.10818701f, -0.04815216f, -0.12857036f, -0.03900941f, 0.00745057f, 
    0.00632354f, -0.25845173f, -0.10397758f, 0.05771970f, -0.08000512f, -0.11110268f, -0.03193391f, 0.11479823f, 
    0.05859755f, -0.01372273f, 0.01109484f, -0.03564988f, 0.09825730f, 0.07547779f, 0.04794596f, 0.03782557f, 
    -0.07680702f, 0.00624565f, 0.06240216f, -0.03095867f, 0.03105043f, -0.11257644f, -0.04783994f, 0.09829619f, 
    -0.04827321f, 0.00953052f, 0.04795941f, -0.04370186f, 0.03032964f, 0.05890726f, 0.08574658f, 0.14186087f, 
    -0.09886312f, -0.21522759f, -0.03637657f, -0.04264568f, 0.02759379f, -0.03548553f, 0.16755104f, 0.08391706f, 
    -0.02229408f, 0.07159014f, -0.08345728f, -0.05288366f, 0.12294314f, 0.15790081f, 0.01215961f, 0.19137576f, 
    0.40453321f, 0.00159913f, -0.04198016f, -0.04528172f, 0.08100937f, 0.00751933f, 0.01632067f, 0.15836972f, 
    0.19683516f, 0.24440935f, 0.13865842f, -0.08392444f, 0.08019494f, -0.14986509f, 0.09356382f, -0.18425122f, 
    0.13963942f, -0.07816547f, 0.04400801f, 0.02857108f, -0.08856151f, 0.15219036f, -0.10460239f, 0.16959500f, 
    -0.00114905f, -0.05677160f, 0.02963108f, -0.06236467f, 0.02342915f, -0.07855822f, 0.05478327f, 0.21852285f, 
    -0.03011266f, -0.03710245f, -0.09301997f, -0.04291745f, -0.02064551f, 0.10746555f, 0.11899550f, 0.03697288f, 
    -0.15590908f, -0.04450687f, -0.09553429f, 0.09338266f, -0.04187332f, 0.02285285f, -0.12749450f, -0.06604192f, 
    -0.17173290f, -0.10946516f, -0.09795812f, -0.00492159f, -0.05756779f, 0.07223421f, -0.08336016f, -0.19609858f, 
    -0.01225984f, 0.01920211f, 0.13402966f, -0.01731039f, 0.45551109f, -0.35128126f, -0.09691607f, 0.29317302f, 
    -0.18793206f, -0.01923224f, 0.02351066f, 0.19504064f, -0.10341083f, 0.01338072f, 0.09422187f, -0.04081444f, 
    0.14653447f, -0.12656648f, 0.10397706f, -0.12367786f, -0.00276856f, -0.26769221f, 0.04739702f, 0.05429630f, 
    -0.10071108f, -0.07091307f, 0.02330451f, -0.01861656f, 0.04105851f, -0.12562202f, 0.03087830f, 0.03635705f, 
    0.01616422f, -0.04426356f, 0.04812132f, 0.04918002f, -0.06695830f, -0.15423810f, -0.01142940f, -0.07206742f, 
    -0.53816050f, 0.01766698f, -0.22522445f, -0.08996618f, -0.15430401f, -0.00049022f, -0.04891983f, 0.11544682f, 
    -0.01920529f, -0.02512480f, -0.07821617f, 0.14195976f, 0.05910988f, 0.07965835f, -0.05886183f, -0.11601969f, 
    0.07672591f, 0.14946599f, -0.07704633f, 0.02339848f, 0.03575506f, -0.04344297f, 0.10163874f, -0.05579802f, 
    -0.17936614f, 0.18154986f, -0.32228199f, -0.12362041f, 0.11813366f, -0.13378668f, 0.12407430f, 0.02516124f, 
    -0.01651894f, 0.11691508f, -0.05276208f, 0.02635714f, 0.13388641f, -0.00850173f, 0.18111630f, 0.02745273f, 
    0.02428439f, -0.01918837f, -0.07475907f, -0.04070783f, 0.13377936f, 0.06153963f, -0.01284525f, 0.11261002f, 
    0.06876043f, 0.15514746f, 0.02045357f, 0.11961924f, -0.04567268f, -0.13480893f, -0.11497920f, 0.10680251f, 
    -0.05670537f, 0.02604651f, -0.19237311f, -0.11019998f, 0.02395430f, 0.13645801f, -0.09705047f, -0.14183845f, 
    0.14407757f, -0.02498989f, 0.02848118f, -0.27390313f, -0.10988509f, 0.12319198f, -0.19809866f, -0.02827391f, 
    -0.16533056f, 0.04509944f, -0.22625822f, -0.05560066f, 0.11774261f, -0.02764638f, 0.04310312f, -0.07360583f, 
    0.00104609f, 0.09948013f, 0.12771890f, -0.06616747f, -0.02193509f, 0.23449568f, -0.00776417f, -0.01578805f, 
    0.04360916f, 0.22392796f, 0.15608004f, 0.03428527f, -0.18050821f, -0.09178589f, -0.12532231f, -0.04920270f, 
    -0.01312568f, 0.00284709f, 0.14306539f, -0.08259732f, 0.02094186f, -0.05417487f, -0.03242831f, -0.05217971f, 
    0.04894843f, 0.15695722f, 0.19484180f, 0.08614755f, 0.10709192f, 0.00305778f, -0.12676679f, 0.06247368f, 
    0.07791314f, 0.00241777f, 0.17334348f, 0.19714107f, -0.05038395f, -0.12249232f, -0.14692529f, 0.04144584f, 
    -0.07029692f, 0.02443567f, 0.19097762f, -0.15980777f, -0.07218183f, 0.07314540f, -0.18590876f, 0.22633839f, 
    -0.29401132f, -0.07210332f, -0.17919366f, -0.20380372f, -0.10296985f, -0.08119743f, -0.02747158f, 0.10004524f, 
    -0.12528913f, 0.03958138f, 0.12266154f, 0.08001325f, 0.11978692f, 0.13140436f, -0.00035217f, 0.04741632f, 
    0.26479030f, -0.41698593f, 0.03700538f, 0.04830610f, 0.02865767f, 0.22357661f, 0.14752199f, 0.17769103f, 
    0.03744939f, 0.10033074f, 0.17895468f, -0.13184984f, 0.18547167f, -0.28670579f, 0.59278297f, 0.09805688f, 
    0.18880747f, 0.07781157f, -0.14313856f, 0.05676491f, -0.00272921f, -0.07676352f, 0.01712550f, 0.01848501f, 
    -0.15225226f, -0.19647390f, -0.11153175f, -0.10451256f, -0.06626831f, -0.06634434f, 0.13190843f, 0.37395686f, 
    0.08639864f, 0.05105049f, 0.07303054f, 0.03800642f, -0.00018821f, -0.08442594f, -0.05866441f, -0.23330131f, 
    -0.01398413f, 0.00352156f, 0.04208798f, 0.08652052f, 0.19624697f, 0.18842176f, 0.13915886f, 0.30355251f, 
    -0.08864716f, 0.04293729f, -0.10743188f, -0.09825698f, -0.10421664f, -0.02248228f, 0.12651995f, 0.20409518f, 
    0.13457589f, -0.04593548f, 0.03332529f, 0.27314365f, 0.18891373f, -0.11748034f, -0.18006784f, 0.24239478f, 
    -0.15948154f, 0.02063789f, 0.00557886f, -0.06935113f, -0.10977371f, 0.08227179f, 0.16698699f, 0.00378695f, 
    0.11108344f, 0.11352093f, 0.19361621f, 0.05683104f, 0.20360769f, -0.07659503f, -0.11432106f, -0.07883017f, 
    0.07440333f, -0.05128511f, -0.10745475f, -0.05117628f, 0.33333182f, -0.15362783f, 0.26345989f, 0.11325145f, 
    0.03075539f, 0.08714580f, -0.05697962f, 0.04382571f, 0.00932278f, -0.11540058f, -0.02753038f, -0.15157123f, 
    0.04055328f, -0.08275738f, 0.53094846f, -0.07058246f, 0.06185301f, 0.03798069f, 0.06686826f, 0.03483680f, 
    -0.02937697f, 0.04317374f, -0.10523173f, 0.02060190f, -0.02784504f, -0.12989575f, 0.16751310f, 0.00843852f, 
    0.09607033f, 0.16776043f, -0.08259487f, -0.19710371f, -0.02487680f, 0.02470974f, 0.03433587f, -0.13322543f, 
    -0.02050444f, 0.25103948f, 0.00426475f, 0.07401337f, 0.06894155f, 0.05746077f, 0.00377404f, 0.00306412f, 
    0.08274697f, 0.03132235f, -0.23028412f, -0.17506440f, 0.18164563f, 0.03765269f, 0.00213231f, 0.09564971f, 
    -0.01705680f, -0.11008776f, 0.00033701f, 0.19165094f, -0.02510234f, 0.11531581f, 0.18142535f, -0.11767905f, 
    -0.16384019f, 0.11501340f, 0.09486375f, -0.16101098f, -0.11638979f, 0.04516083f, 0.02188838f, 0.00976412f, 
    0.06065324f, -0.07230649f, 0.03776846f, 0.22509676f, 0.16125549f, 0.14865322f, 0.29107171f, -0.15937284f, 
    -0.02740018f, 0.14493927f, 0.03248815f, 0.05315809f, 0.12578392f, -0.01211415f, 0.19889040f, 0.06137279f, 
    -0.07092455f, -0.02264647f, 0.09642285f, 0.21028310f, 0.07308474f, 0.08352330f, 0.07229704f, 0.00778243f, 
    -0.02118256f, -0.02622208f, 0.00816164f, -0.23318405f, 0.02942379f, 0.11788398f, 0.12776023f, -0.16500106f, 
    0.18971016f, -0.04851732f, 0.00127896f, 0.05233781f, 0.04100207f, -0.16970505f, -0.13562033f, -0.08667179f, 
    -0.04230666f, -0.02221184f, -0.01738089f, -0.00804983f, -0.02228668f, -0.03890993f, -0.01899215f, -0.03604659f, 
    -0.04335622f, -0.01618993f, 0.02660750f, -0.02554799f, -0.00514247f, -0.04157219f, -0.03339557f, -0.00102458f, 
    -0.00968248f, -0.02694346f, -0.02077213f, 0.00584685f, -0.00635098f, -0.01507075f, 0.02055938f, 0.04240466f, 
    0.01709702f, 0.03534413f, -0.02097758f, 0.02439486f, 0.00206602f, -0.04383684f, 0.04028367f, 0.01592223f, 
    -0.03275961f, -0.03547703f, 0.00682929f, -0.01608224f, -0.02168759f, 0.03241572f, -0.03823761f, 0.04376579f, 
    -0.03817382f, 0.00953993f, -0.00988290f, 0.01927585f, -0.03536140f, -0.03445342f, -0.05472711f, 0.02928338f, 
    -0.03984775f, -0.02428631f, -0.00232614f, 0.01629661f, -0.03578719f, -0.00221012f, -0.00488518f, -0.05499803f, 
    0.02595657f, 0.01461970f, -0.02116730f, -0.03245573f, 0.02004629f, -0.04315103f, -0.00635927f, 0.04521432f, 
    -0.05180637f, -0.00105013f, -0.00818366f, 0.01710320f, -0.01222003f, -0.02652325f, -0.01008070f, 0.03373336f, 
    0.00037061f, -0.01107263f, 0.00543146f, 0.00496012f, -0.01269642f, 0.04538930f, 0.00120634f, 0.00430600f, 
    0.02794132f, -0.00771568f, -0.02366956f, 0.00499820f, 0.02082120f, 0.03476627f, -0.01630636f, 0.03780408f, 
    0.03534462f, -0.04129416f, -0.00282031f, 0.04421128f, 0.00004223f, -0.00681396f, 0.04226743f, -0.00205999f, 
    0.03584654f, -0.02891354f, -0.02846220f, 0.03553013f, -0.03356303f, 0.00817536f, -0.03665562f, -0.05458813f, 
    -0.00383404f, -0.04678549f, 0.00902643f, -0.02576042f, -0.01550415f, 0.03472475f, -0.04171280f, 0.04522948f, 
    -0.03484817f, 0.03624214f, 0.02142682f, 0.00576846f, 0.03188956f, 0.02008552f, 0.03316272f, -0.05315929f, 
    -0.03602540f, 0.00038132f, -0.01686565f, 0.04366287f, -0.01319862f, 0.03964847f, -0.05427609f, 0.01603435f, 
    -0.04904635f, 0.03555938f, -0.03209686f, 0.02178369f, -0.04255055f, 0.00390828f, -0.05098155f, -0.01008410f, 
    0.00385305f, -0.04594727f, -0.01681243f, -0.04779650f, -0.02239749f, -0.00059360f, -0.02016189f, 0.02253038f, 
    0.01785658f, -0.04517909f, -0.03274447f, -0.00382761f, -0.02500956f, 0.02642850f, 0.02821970f, -0.02547069f, 
    -0.00724848f, 0.02180136f, -0.05573965f, -0.00463128f, 0.02073158f, -0.02245514f, -0.02602317f, -0.03058313f, 
    -0.03912508f, -0.02079380f, 0.04070038f, 0.01638554f, -0.01703788f, 0.02362431f, -0.04587093f, 0.04435958f, 
    -0.04651135f, -0.00779641f, -0.01684792f, -0.04097119f, -0.03750484f, 0.04359566f, -0.04597077f, -0.04394569f, 
    -0.03046673f, -0.03270036f, 0.05063752f, 0.03794209f, 0.05025551f, 0.00383261f, -0.04686759f, 0.03045360f, 
    -0.04632058f, -0.03151171f, 0.04486537f, 0.01620723f, 0.02230074f, -0.03022495f, -0.04591817f, -0.05021122f, 
    0.03104321f, -0.00252088f, 0.00197550f, -0.01918936f, 0.03073766f, -0.03000504f, 0.01844407f, 0.00570080f, 
    0.03005131f, 0.01395367f, -0.05416315f, -0.03378882f, -0.00781912f, -0.03227549f, 0.00074810f, -0.01839750f, 
    -0.04249338f, -0.03200243f, -0.00434136f, 0.02137093f, 0.00198494f, -0.04324889f, -0.03939183f, 0.00480882f, 
    -0.05023742f, -0.05243639f, -0.02260162f, -0.02849553f, 0.01443415f, -0.04305400f, 0.00979939f, 0.03640995f, 
    0.01079732f, 0.01068926f, -0.00176400f, -0.03688505f, 0.01286937f, -0.03959525f, -0.05578196f, 0.00355558f, 
    0.04400094f, -0.01141572f, -0.01843759f, -0.04407061f, 0.00678756f, -0.04437969f, 0.00976903f, -0.02127058f, 
    0.01205233f, -0.01317615f, -0.01931653f, -0.04493855f, 0.03208728f, 0.03588487f, -0.03365664f, -0.03061423f, 
    0.01456791f, -0.04189469f, 0.00881949f, -0.02102094f, -0.04998058f, -0.02561375f, -0.02361763f, -0.00149177f, 
    -0.01480742f, -0.03396719f, -0.04629119f, 0.04186996f, -0.02992093f, -0.01447853f, 0.00224851f, 0.00048829f, 
    -0.00473831f, 0.01061461f, 0.04237191f, -0.01097584f, -0.04335856f, -0.00609789f, 0.03788232f, -0.03920529f, 
    -0.01597447f, -0.03562903f, -0.00360618f, -0.04715913f, -0.00865013f, 0.03332063f, 0.04203386f, -0.00584518f, 
    -0.04671557f, -0.04331099f, 0.04129278f, -0.03342124f, 0.01382257f, 0.04020839f, -0.02808491f, 0.00396205f, 
    0.04520520f, 0.00726986f, -0.03619168f, 0.04416180f, -0.03042086f, 0.01320602f, -0.04899710f, 0.00329530f, 
    0.04100779f, -0.04317005f, -0.01557521f, -0.02439714f, -0.02115889f, -0.02387881f, 0.01263565f, -0.02143901f, 
    0.03271485f, -0.03494205f, -0.04441384f, -0.02360134f, -0.01459289f, 0.00207801f, 0.02962338f, -0.00261590f, 
    0.03754389f, -0.01927471f, 0.02640632f, 0.00362848f, -0.00489678f, -0.04084944f, 0.05066813f, 0.00106288f, 
    -0.00500747f, 0.01516902f, 0.00556903f, -0.02186190f, -0.00314720f, -0.05324696f, 0.03101290f, -0.00206509f, 
    0.01545295f, -0.02187951f, -0.01661403f, -0.01919861f, -0.00419544f, -0.01825964f, -0.01200437f, -0.05077036f, 
    -0.02073620f, -0.03362745f, -0.03161603f, -0.02399281f, -0.00433841f, -0.03405629f, -0.05440091f, 0.01183239f, 
    0.01505123f, 0.00888650f, -0.01269555f, 0.03408715f, -0.01866187f, 0.01989033f, -0.03662681f, -0.01822438f, 
    -0.05577084f, 0.04838585f, 0.00838297f, -0.02847422f, -0.01919067f, -0.02866589f, 0.04297278f, -0.02293498f, 
    -0.02882043f, 0.01083160f, -0.00549614f, -0.02625326f, -0.03734937f, -0.03722280f, 0.02473184f, 0.00431873f, 
    0.04806407f, -0.01207716f, -0.00554513f, 0.02063741f, 0.00927663f, -0.00914144f, 0.01778995f, -0.04103152f, 
    -0.01099622f, 0.01359627f, 0.00169087f, -0.02258662f, 0.01145265f, 0.01608722f, -0.00055228f, -0.01415664f, 
    0.03076432f, 0.17097978f, -0.20040953f, -0.12399334f, 0.23097949f, 0.26701692f, -0.27065161f, 0.07193271f, 
    -0.14121723f, -0.11119975f, -0.15810084f, -0.03736204f, -0.26643065f, 0.40140143f, -0.07508107f, 0.00441457f, 
    0.10665875f, 0.03474802f, -0.27014095f, 0.08309028f, 0.08737929f, -0.14724699f, -0.13239031f, 0.16258815f, 
    -0.17467655f, 0.28975570f, 0.01546737f, -0.16250417f, 0.01617722f, -0.06538256f, -0.04004015f, 0.15895489f, 
    -0.02828529f, -0.02813917f, 0.13069189f, -0.05769050f, 0.03154646f, -0.02309545f, 0.17036486f, 0.24661328f, 
    -0.03634683f, 0.05050483f, -0.07434642f, 0.01855399f, -0.12517741f, -0.01168361f, 0.07287655f, 0.00585983f, 
    0.04547940f, 0.04063534f, 0.16256201f, 0.06892004f, 0.03860560f, 0.13646126f, 0.04076466f, -0.08809927f, 
    0.06234254f, -0.05330143f, -0.11935481f, -0.13093574f, -0.00767408f, -0.45830092f, 0.09437497f, 0.00945121f, 
    0.10863363f, 0.06617801f, -0.14504106f, -0.09921585f, -0.01566021f, -0.02954260f, 0.13177039f, 0.06610413f, 
    0.27942592f, 0.04068358f, -0.28993371f, 0.04449972f, -0.12848215f, -0.10619333f, 0.21022427f, 0.10503946f, 
    0.19252717f, 0.22353227f, 0.24032986f, -0.12678534f, 0.32031858f, 0.14509149f, -0.11068283f, -0.01884113f, 
    0.11513740f, -0.04324985f, 0.04671665f, 0.05165914f, -0.11787298f, -0.15359397f, 0.04025306f, 0.05576852f, 
    -0.09215056f, -0.28444794f, -0.11844361f, 0.06271728f, -0.16948605f, 0.10011176f, 0.27051488f, -0.04966859f, 
    -0.05076895f, -0.22932123f, -0.05949444f, -0.08029684f, -0.05429717f, -0.09766297f, -0.10401458f, 0.13680351f, 
    0.20717186f, -0.27612445f, -0.03314452f, 0.04458646f, -0.04188266f, 0.00840273f, 0.11999653f, -0.05084258f, 
    0.11797075f, -0.14898300f, 0.01145703f, -0.07139002f, -0.08514466f, -0.04058368f, 0.24810259f, 0.08341882f, 
    0.26485008f, 0.15516077f, -0.07379311f, 0.13314371f, -0.01400618f, 0.16535644f, 0.03135924f, 0.11785173f, 
    -0.17583603f, 0.10529233f, -0.28171626f, 0.14299022f, -0.07058402f, -0.00483360f, 0.00658278f, 0.01411423f, 
    0.47781271f, -0.05589212f, 0.17005262f, -0.10692701f, 0.09380193f, -0.03366672f, 0.16843246f, 0.02315076f, 
    0.17389317f, -0.17379293f, 0.01870190f, -0.07251081f, -0.05498566f, -0.02972149f, -0.15660022f, 0.22877765f, 
    -0.14522733f, 0.14460480f, 0.04448672f, 0.01552952f, -0.03309426f, 0.09549144f, -0.01542595f, 0.20915237f, 
    -0.28478730f, 0.07663484f, 0.08349648f, -0.12710305f, -0.04302606f, -0.02726738f, -0.03038360f, 0.00063879f, 
    0.07170925f, -0.06136753f, 0.23095527f, -0.11483012f, -0.19022222f, 0.01933446f, -0.09375308f, -0.07514144f, 
    -0.03935201f, -0.01459193f, -0.33794844f, -0.01496324f, -0.05578081f, -0.18344839f, 0.06559821f, 0.01060813f, 
    0.40346059f, 0.19899069f, -0.01592370f, 0.12033985f, 0.00760393f, 0.17717901f, 0.28933996f, -0.00166129f, 
    0.11715709f, 0.11201725f, 0.02596635f, -0.28893462f, -0.27484071f, 0.06150968f, 0.31124306f, -0.28082159f, 
    0.01410195f, 0.08793464f, 0.00484018f, -0.12663712f, 0.03065365f, -0.06929772f, 0.03451844f, 0.18830906f, 
    -0.47981066f, -0.24971426f, -0.00251643f, 0.12083486f, 0.07319809f, 0.22359449f, -0.04689381f, 0.15087345f, 
    -0.03040609f, 0.00553733f, -0.04706433f, 0.19074470f, 0.22446036f, -0.06949433f, -0.11506414f, 0.01571041f, 
    -0.05028926f, -0.05313388f, 0.17793407f, 0.12785688f, 0.10564101f, 0.06220611f, 0.18973982f, 0.11728998f, 
    0.12881137f, 0.19372503f, 0.16822699f, 0.03941509f, 0.14011532f, 0.21935152f, 0.12262395f, -0.00954762f, 
    -0.14474383f, 0.06371450f, 0.03060783f, 0.17282589f, -0.06498262f, -0.16846676f, -0.07759944f, 0.09798504f, 
    -0.10585725f, 0.09412120f, 0.11436980f, 0.03001470f, 0.10282283f, 0.08794001f, -0.01690524f, 0.14262754f, 
    -0.00977015f, -0.22041994f, -0.27441853f, -0.30858523f, -0.09485217f, 0.02992570f, -0.10730815f, -0.14696009f, 
    -0.00664421f, -0.09931580f, 0.05558645f, 0.01675568f, -0.39150241f, 0.30391237f, 0.54628676f, -0.10334524f, 
    -0.03283468f, -0.01498194f, -0.10081812f, 0.04132990f, 0.01942740f, -0.02808273f, -0.08617773f, 0.01329643f, 
    0.24272703f, 0.74555302f, -0.31527475f, -0.05944046f, -0.02997278f, -0.19615027f, 0.07324012f, -0.04931318f, 
    0.17472687f, 0.07053333f, -0.03568283f, -0.02314998f, 0.08351433f, -0.02021030f, -0.08349570f, -0.19928245f, 
    0.04180379f, -0.16979097f, -0.06341602f, 0.15355456f, -0.06735592f, -0.17821926f, 0.04148557f, 0.01284353f, 
    0.03867250f, -0.17322049f, 0.11255570f, 0.09797025f, 0.20736551f, 0.07530971f, -0.04916931f, -0.04831332f, 
    -0.08859962f, 0.02650945f, -0.13818462f, -0.00318226f, -0.25843647f, 0.11193085f, -0.09508442f, -0.10231624f, 
    -0.00080632f, -0.02546016f, -0.07834093f, -0.04711182f, 0.07410068f, 0.05163712f, 0.01129191f, 0.15308133f, 
    0.15453213f, -0.05693303f, 0.16074529f, -0.16141015f, 0.17505836f, 0.04516970f, 0.13710359f, -0.10641642f, 
    0.00899217f, -0.11791638f, 0.20156837f, 0.12726572f, 0.01688433f, -0.22716460f, -0.06668483f, 0.31462416f, 
    0.04693975f, -0.02203956f, -0.11049607f, -0.18379235f, -0.08621441f, 0.03508003f, -0.06813272f, 0.08393954f, 
    -0.18288817f, 0.35637337f, 0.07872275f, -0.29907593f, -0.05266234f, -0.21979482f, 0.02424379f, 0.09856618f, 
    0.01459941f, 0.14418992f, 0.13702567f, -0.06618237f, 0.20285986f, -0.02198074f, -0.16584992f, -0.00236635f, 
    0.15219396f, 0.23633718f, 0.00184817f, -0.07982053f, -0.08697236f, -0.05735058f, -0.11782452f, 0.04534398f, 
    0.04838523f, -0.24258514f, -0.01146821f, 0.17199233f, 0.13472356f, -0.11092540f, 0.19611359f, 0.27879629f, 
    -0.04254571f, -0.01912396f, 0.14268830f, 0.24165173f, -0.51232237f, 0.05304020f, 0.10404383f, 0.09400989f, 
    -0.01407769f, -0.07963998f, 0.03448583f, -0.02199902f, -0.13466442f, 0.12796353f, 0.15779196f, 0.02501982f, 
    0.21052124f, 0.01583497f, -0.06470517f, 0.20140323f, 0.07193841f, 0.11622028f, -0.03185639f, -0.00527896f, 
    0.02396391f, 0.01318687f, -0.18551791f, -0.01986250f, -0.12620062f, 0.16492993f, -0.02663202f, -0.14329623f, 
    0.00613850f, 0.04516261f, -0.02171531f, -0.05200182f, 0.05546859f, 0.01725987f, 0.05199354f, 0.18990308f, 
    -0.11331606f, -0.16769099f, 0.04078990f, 0.04703708f, 0.00563547f, 0.01716719f, -0.00612203f, 0.03790949f, 
    0.15659311f, 0.14054389f, 0.11362181f, 0.09051181f, -0.44510710f, 0.24365067f, 0.06001139f, 0.17129600f, 
    0.06009234f, 0.03399254f, 0.03803142f, 0.11399087f, 0.00196981f, 0.01233825f, 0.11748705f, 0.02493245f, 
    -0.05363776f, -0.06380173f, -0.04998058f, -0.11874302f, -0.13454306f, 0.02166345f, 0.03952317f, -0.05908384f, 
    0.20491882f, 0.09946518f, 0.07795794f, 0.14744633f, -0.00461310f, -0.08839002f, -0.04662312f, -0.21640617f, 
    0.12303882f, 0.13295755f, 0.21644698f, 0.11319716f, 0.08760703f, 0.13378614f, 0.00285779f, 0.13891999f, 
    -0.01883870f, -0.12157045f, -0.13074002f, -0.12162240f, -0.06778978f, 0.14650384f, 0.02646537f, 0.06101845f, 
    0.15861008f, 0.00904001f, 0.05014549f, 0.03024924f, 0.00255638f, -0.00336412f, -0.02846675f, -0.10156199f, 
    0.06980301f, 0.04484924f, -0.05297360f, -0.04067741f, 0.00255344f, -0.06851994f, 0.16049200f, 0.11747316f, 
    0.06911080f, 0.15836671f, -0.09887004f, -0.09620716f, -0.10809664f, -0.06801273f, -0.05348508f, -0.01447765f, 
    0.16324669f, 0.25484148f, 0.15895303f, 0.12908301f, 0.05833825f, -0.04164817f, 0.01527182f, -0.07306402f, 
    0.16386133f, -0.04597389f, -0.02087535f, -0.08471315f, 0.02738706f, 0.04833557f, 0.05936626f, 0.05306774f, 
    0.10555637f, 0.22985689f, -0.46259385f, -0.00051462f, 0.09102055f, 0.14118569f, 0.09366728f, 0.03675373f, 
    0.12428344f, 0.06317877f, -0.05406032f, 0.11615665f, -0.06909776f, 0.04253863f, 0.00565122f, -0.31580496f, 
    -0.00577325f, 0.06422748f, -0.07685176f, 0.02428614f, 0.10477871f, 0.03282510f, 0.06964388f, 0.18708111f, 
    -0.01901560f, -0.01265946f, -0.08954716f, 0.06924833f, 0.16340177f, -0.16895051f, -0.05926358f, -0.08992792f, 
    0.14255938f, 0.12328461f, 0.04290602f, 0.13681927f, -0.26447925f, -0.09516991f, -0.07711361f, -0.10764898f, 
    -0.04402757f, -0.00012883f, 0.07833001f, 0.00557395f, -0.10238807f, -0.13046303f, -0.09497289f, -0.08256362f, 
    0.12765069f, 0.16667959f, -0.34752434f, -0.26511368f, 0.27963576f, 0.00572435f, 0.06052739f, -0.04123283f, 
    0.28606683f, -0.06453372f, -0.15785331f, 0.22075886f, 0.38434023f, 0.31246534f, -0.16431957f, 0.08071584f, 
    0.12562506f, -0.07558951f, 0.08664907f, -0.07345030f, -0.00083866f, 0.07215732f, 0.08502895f, -0.14645253f, 
    0.34113774f, -0.05363585f, -0.14546420f, -0.13223666f, 0.04305481f, -0.00467625f, -0.01738302f, -0.11189848f, 
    0.12729470f, 0.09847215f, 0.09864203f, 0.09339151f, 0.16767736f, 0.05136934f, -0.07535005f, -0.07512134f, 
    0.00259902f, -0.08317393f, -0.03206750f, -0.06903999f, 0.02437503f, -0.07494673f, -0.04194347f, -0.12565547f, 
    -0.06218663f, -0.50162828f, -0.22432968f, 0.09371351f, 0.15408251f, 0.14953956f, 0.11035732f, 0.06608070f, 
    0.00930840f, -0.07726751f, 0.14605461f, -0.11125217f, -0.16943149f, 0.16779183f, 0.13195367f, -0.01419675f, 
    -0.02600700f, -0.02422677f, 0.02492908f, 0.01627101f, 0.03888040f, 0.00301737f, -0.06497622f, 0.00111870f, 
    0.06233327f, -0.17100953f, -0.04319875f, 0.01757564f, -0.00391390f, 0.12488993f, 0.12479465f, 0.23052448f, 
    -0.15167789f, -0.07242141f, 0.03608285f, 0.03063351f, -0.21680671f, 0.23246229f, 0.08183464f, 0.28525743f, 
    -0.05324551f, -0.16286030f, -0.00098900f, -0.08425913f, -0.02354877f, -0.04616317f, 0.00980685f, -0.06535619f, 
    0.26193193f, -0.00260119f, -0.04735968f, 0.14414935f, 0.06386053f, 0.09371398f, 0.08920875f, -0.14711504f, 
    -0.05236527f, 0.00335348f, -0.06245591f, 0.02734687f, -0.24686441f, 0.17969096f, -0.00462210f, -0.03625793f, 
    -0.11372530f, 0.02965841f, -0.01452968f, 0.03431148f, -0.00778381f, 0.16956124f, 0.09231011f, 0.25170183f, 
    -0.00809803f, -0.34615847f, -0.27404517f, -0.14130865f, 0.07246949f, 0.18519016f, 0.11577037f, 0.16023803f, 
    -0.05278288f, -0.22913611f, 0.01670465f, 0.00710893f, -0.04442764f, 0.09891008f, 0.03491920f, 0.03970922f, 
    -0.05832673f, -0.00786434f, -0.00647742f, -0.09679028f, 0.14247276f, 0.16420321f, -0.09955864f, 0.15064146f, 
    -0.03829982f, -0.19363193f, -0.23587668f, 0.17910406f, 0.05096498f, 0.01966724f, 0.10682328f, 0.19789992f, 
    -0.05921305f, 0.05966374f, 0.05258678f, -0.03812549f, -0.34682134f, 0.04610623f, -0.15157153f, 0.28866619f, 
    -0.07308646f, -0.03629388f, 0.01399800f, 0.20421159f, -0.10749970f, 0.09530421f, -0.14363331f, -0.07540344f, 
    0.15630186f, 0.03658387f, 0.02035503f, -0.03530143f, 0.19099145f, -0.07314774f, -0.08850572f, -0.02696971f, 
    0.00544129f, 0.01560371f, 0.00157064f, 0.05590909f, 0.02223771f, -0.43655339f, -0.29226872f, 0.12990701f, 
    -0.11335129f, 0.06357008f, 0.03310525f, 0.11589152f, -0.06716879f, 0.04263112f, 0.03239293f, -0.02318066f, 
    -0.02503717f, -0.16036126f, -0.03662267f, -0.09487009f, 0.05191218f, 0.10480288f, -0.00397653f, -0.03273360f, 
    0.10739477f, -0.02861431f, 0.07191413f, 0.09256735f, 0.27236816f, -0.25488958f, -0.12423684f, 0.06017357f, 
    -0.01760171f, -0.05657016f, -0.01717350f, 0.08717414f, -0.00339838f, 0.07446836f, 0.06491024f, 0.00076995f, 
    0.01832154f, -0.18347129f, 0.01652126f, 0.15079698f, 0.06794313f, 0.00323052f, -0.12175263f, 0.08044545f, 
    0.03967217f, -0.05062791f, -0.07202983f, 0.05074284f, -0.04602342f, 0.01796640f, -0.02487315f, -0.03922945f, 
    0.03669195f, -0.02334056f, 0.10119749f, 0.01730288f, 0.12124842f, 0.03796915f, 0.04601815f, 0.07405344f, 
    -0.18566968f, -0.14822076f, -0.05978291f, -0.14530738f, -0.03188515f, -0.10456179f, -0.04313448f, 0.04689301f, 
    0.12970982f, 0.06474296f, 0.02150756f, -0.11267764f, -0.13450770f, 0.10169318f, -0.39551720f, 0.16625738f, 
    0.06001396f, -0.01351511f, 0.18536469f, -0.01674523f, -0.00759395f, 0.09415805f, -0.04771188f, -0.04740119f, 
    0.05755414f, -0.01138500f, 0.19908233f, 0.00229168f, -0.03369506f, -0.08216226f, -0.06365167f, -0.06544980f, 
    0.10802188f, -0.05931063f, 0.07129189f, 0.05793064f, 0.06900167f, 0.25641215f, 0.13201085f, -0.05169979f, 
    0.03374749f, 0.11721899f, 0.08264283f, 0.21608736f, 0.10142475f, -0.00058318f, -0.03926127f, 0.09854630f, 
    0.07614978f, 0.15807541f, -0.00570421f, 0.05354613f, -0.09585339f, -0.12857266f, -0.07359591f, 0.01860829f, 
    0.05331134f, 0.02522397f, 0.08375349f, -0.05120409f, -0.06656803f, -0.09797409f, 0.07196432f, -0.11454979f, 
    -0.03355118f, -0.04195557f, -0.11808421f, -0.04434986f, -0.03950977f, 0.13815166f, -0.09391375f, 0.05773504f, 
    0.14589787f, -0.07454602f, 0.10379016f, 0.05745573f, -0.13744898f, -0.05310300f, -0.03991181f, -0.04967390f, 
    0.15140307f, -0.01570171f, 0.22295095f, -0.03786824f, 0.03523644f, -0.04544835f, 0.04323881f, -0.00984763f, 
    0.03450267f, -0.02916505f, 0.11877224f, -0.07850394f, 0.05069745f, 0.03213415f, 0.16220450f, -0.01746314f, 
    0.16537456f, 0.11580496f, 0.18401682f, -0.12964001f, 0.05078307f, 0.07747890f, 0.09810526f, 0.02650039f, 
    -0.03635631f, 0.03212363f, 0.03514259f, 0.03771033f, 0.02350586f, 0.07792723f, 0.08541650f, 0.03471252f, 
    0.04545263f, -0.01408916f, 0.04919474f, -0.00088371f, 0.06827796f, 0.02552294f, 0.07397864f, 0.04697215f, 
    0.03266896f, -0.09381384f, -0.02926047f, 0.08861890f, -0.10715764f, 0.00895789f, -0.12145717f, -0.01776902f, 
    0.07600348f, 0.04166993f, -0.02821654f, 0.04985860f, -0.01766431f, -0.15990403f, 0.01272347f, -0.01878914f, 
    0.01106606f, -0.02107230f, 0.23220666f, -0.06428707f, -0.05247118f, 0.05173071f, -0.16452695f, -0.07623377f, 
    0.20519225f, -0.06388601f, 0.16892932f, 0.03371075f, -0.20290177f, -0.07798528f, -0.05337443f, -0.00283410f, 
    0.10105048f, -0.24799684f, 0.05273723f, 0.02736773f, -0.06132871f, 0.06196215f, 0.06580561f, -0.07531698f, 
    0.06262996f, 0.10793845f, -0.05883538f, 0.02718878f, -0.09326578f, 0.02827568f, -0.01808550f, -0.12308251f, 
    -0.26877907f, 0.08610781f, -0.01766142f, -0.06659849f, -0.16630569f, -0.13664757f, -0.09476843f, -0.02238555f, 
    0.10322087f, -0.02176188f, 0.06295997f, -0.19230969f, 0.05160451f, -0.23911572f, 0.17802277f, 0.01258222f, 
    -0.12548882f, -0.03928414f, -0.08112027f, -0.01905482f, 0.17055942f, 0.08433077f, -0.00843134f, 0.16303004f, 
    -0.18808594f, -0.03944452f, -0.21142721f, -0.14771415f, -0.06501418f, -0.00890741f, 0.00151533f, 0.21726020f, 
    0.12408548f, -0.11400045f, 0.04641679f, -0.01646782f, 0.05444179f, 0.03436594f, -0.07714627f, -0.06723500f, 
    0.00159971f, -0.04424661f, 0.01825458f, 0.07984533f, -0.06749013f, -0.03375373f, 0.01518613f, -0.12068943f, 
    0.20961834f, 0.45829377f, 0.14064464f, -0.03339091f, 0.08802193f, -0.00007987f, 0.12236618f, 0.10156263f, 
    -0.11601733f, 0.02184638f, -0.05399856f, 0.04643774f, 0.04398571f, 0.19430065f, -0.36432207f, 0.22890127f, 
    0.10254923f, 0.09567874f, 0.02349894f, 0.03173793f, 0.09401968f, 0.01384036f, 0.05178992f, -0.00291427f, 
    0.22432889f, -0.42216650f, 0.51399493f, -0.34713155f, 0.19728431f, 0.19023409f, 0.07950149f, -0.00456237f, 
    0.01715820f, 0.06989834f, 0.10565351f, -0.08170145f, -0.10343197f, 0.13121296f, -0.07500012f, 0.23817812f, 
    0.00960920f, -0.02211144f, 0.01201383f, -0.05531054f, 0.05613348f, 0.05066925f, 0.02633955f, 0.06075949f, 
    0.02575110f, 0.19471101f, -0.20745902f, -0.22273022f, -0.05508353f, 0.07373729f, -0.18343754f, 0.06765681f, 
    0.07372721f, -0.02771078f, -0.05815932f, -0.08699986f, 0.16663867f, -0.02394473f, 0.22254051f, 0.14718175f, 
    0.01855663f, -0.05332303f, 0.01736387f, 0.09994390f, -0.01496689f, -0.01222511f, 0.11066382f, -0.01774475f, 
    0.27376086f, 0.01361287f, -0.11674847f, -0.23329142f, -0.05361645f, 0.02470649f, -0.02129233f, 0.12907594f, 
    0.05028574f, -0.14603515f, -0.04752107f, 0.01470617f, -0.19904338f, 0.21428269f, -0.15775202f, 0.14622657f, 
    0.05823419f, -0.01668029f, 0.09591273f, 0.07764457f, 0.01499363f, -0.20236807f, 0.06524149f, 0.06576875f, 
    0.23633993f, -0.21468350f, -0.02891827f, -0.02899496f, 0.13577460f, 0.15145890f, -0.11263058f, 0.03141910f, 
    -0.00458426f, -0.03201386f, -0.06147643f, 0.01317184f, 0.00214102f, 0.11187349f, 0.19104041f, -0.25403702f, 
    0.05198813f, -0.01184419f, -0.02160373f, 0.16651991f, -0.03608256f, -0.02813658f, -0.00080222f, 0.07486089f, 
    0.35722688f, 0.03760859f, -0.02429562f, -0.11856414f, 0.08409841f, 0.13574293f, -0.13428748f, 0.06386682f, 
    -0.04798486f, -0.05726409f, -0.09395202f, 0.02821529f, 0.37895945f, -0.18311371f, -0.07952371f, 0.02674953f, 
    -0.02212555f, 0.05329296f, 0.05438665f, -0.11599093f, 0.21652628f, 0.01639734f, 0.13377258f, 0.09516669f, 
    -0.08151187f, 0.11568222f, 0.21464522f, 0.21993861f, -0.09922776f, -0.06565513f, -0.16302210f, -0.09529242f, 
    -0.01534783f, -0.01116420f, 0.04964451f, 0.00459707f, 0.15008919f, 0.05048016f, 0.05516858f, 0.11864134f, 
    -0.09253650f, -0.04031915f, -0.01525512f, -0.04980447f, -0.07814140f, 0.03824000f, -0.08412633f, -0.09725092f, 
    0.19803283f, -0.01509870f, -0.18792149f, 0.03825609f, 0.00197091f, -0.04564503f, -0.06456165f, -0.00156750f, 
    0.06007466f, 0.02686069f, -0.00499837f, -0.07384723f, 0.32217768f, -0.35788283f, 0.00921478f, 0.05949591f, 
    -0.01498758f, 0.07962032f, 0.08635294f, -0.11008101f, -0.09581432f, 0.05153583f, 0.00342686f, 0.13477074f, 
    0.05153067f, -0.08465762f, 0.08258539f, 0.05227382f, -0.01358610f, -0.07664935f, -0.03687220f, -0.13755879f, 
    0.11093888f, 0.02224786f, -0.01481885f, 0.04888117f, 0.20951031f, 0.31965464f, 0.10554702f, 0.13783866f, 
    0.11043101f, 0.07466410f, 0.14337727f, -0.03505807f, -0.05478315f, -0.04580270f, -0.07458188f, 0.01535227f, 
    -0.11925261f, -0.09705327f, -0.00744116f, -0.06179964f, 0.00298651f, -0.10302451f, 0.02896993f, -0.07973174f, 
    -0.05929212f, -0.02308643f, 0.02822149f, 0.04136505f, -0.02415698f, -0.06244887f, -0.01297549f, 0.07740741f, 
    0.21796197f, -0.04630586f, 0.01989864f, 0.05552109f, -0.02765458f, 0.13778317f, 0.02234359f, -0.00338692f, 
    -0.04766408f, -0.08319575f, 0.24537112f, 0.27304134f, -0.04578859f, -0.02227604f, -0.02455693f, -0.03366472f, 
    0.18323851f, -0.24259457f, 0.03440466f, 0.23650287f, -0.10878721f, -0.10415120f, -0.11953702f, 0.10012206f, 
    -0.06457032f, 0.13016173f, 0.00790625f, 0.00058264f, -0.01646414f, 0.02013742f, 0.02135726f, 0.01260251f, 
    0.10459821f, 0.26261285f, 0.00115982f, 0.00323259f, 0.14974298f, 0.07491481f, 0.29259440f, -0.08394679f, 
    0.02037989f, -0.05816850f, -0.05536464f, -0.04507806f, 0.16152459f, 0.06697705f, 0.14865179f, 0.22476587f, 
    -0.11488894f, -0.01526249f, -0.09061695f, -0.10609143f, 0.00626235f, -0.05743244f, 0.08452780f, -0.05046663f, 
    -0.03050606f, 0.00099932f, 0.02093085f, 0.06080762f, -0.16472466f, -0.04662253f, -0.00443261f, -0.13017070f, 
    0.06244387f, -0.03796391f, 0.10580376f, 0.05778711f, 0.05906990f, 0.03549908f, -0.10959864f, 0.11349379f, 
    -0.05379846f, -0.05862382f, -0.06476498f, 0.00914993f, 0.09473068f, -0.04276803f, -0.17975311f, -0.25821394f, 
    -0.44900498f, 0.10488978f, 0.06248660f, -0.13877626f, -0.06744365f, 0.18834020f, 0.01843882f, -0.09926724f, 
    -0.08679512f, 0.02598413f, 0.09869216f, -0.00991601f, 0.03114520f, 0.38953137f, -0.06999369f, -0.07889501f, 
    0.02911670f, 0.19403042f, 0.16955969f, -0.00263936f, -0.08250644f, 0.00511672f, -0.04026894f, 0.09255575f, 
    -0.40797305f, 0.17066248f, 0.13695800f, -0.13408044f, -0.06144755f, -0.04978873f, 0.04894808f, -0.01246329f, 
    -0.01999190f, 0.00882660f, 0.07492848f, 0.13608851f, -0.14292736f, 0.25101778f, -0.03391732f, -0.07448220f, 
    0.00541525f, 0.01590460f, -0.09439725f, -0.07292601f, -0.00566473f, 0.01351983f, -0.05333059f, -0.04799010f, 
    0.14017136f, 0.17336448f, -0.12318964f, -0.35960025f, 0.01530135f, 0.08613307f, -0.06354222f, -0.01290336f, 
    0.09361648f, -0.04437315f, -0.16280064f, -0.20475480f, 0.20125616f, -0.39209595f, 0.01108317f, -0.08776724f, 
    -0.06363899f, 0.01442845f, -0.02330651f, 0.05534688f, -0.12282393f, -0.18992986f, 0.02303433f, -0.01010524f, 
    0.17710774f, 0.17925498f, 0.00366638f, -0.13459252f, 0.06695636f, 0.00449629f, -0.08210169f, -0.06484059f, 
    -0.07298025f, -0.00491703f, 0.00540748f, 0.00576781f, 0.29356301f, -0.14097685f, -0.03982585f, 0.12090849f, 
    -0.04599763f, -0.14798199f, 0.00937784f, -0.05935198f, -0.06945810f, 0.00802287f, -0.02472411f, -0.06589553f, 
    -0.25812376f, 0.43207091f, -0.22567701f, 0.05489111f, -0.10308235f, 0.06925149f, -0.02254956f, 0.13329071f, 
    0.02797379f, -0.03467149f, 0.10101651f, -0.07204325f, 0.13165328f, -0.17716929f, 0.13524806f, 0.14826289f, 
    -0.01945396f, -0.13202475f, -0.01692103f, -0.08771321f, -0.07764927f, -0.03289577f, 0.06709527f, 0.02897176f, 
    -0.05078161f, 0.29053119f, -0.00951885f, -0.13437085f, 0.21427855f, 0.04194641f, -0.01561582f, -0.03576218f, 
    -0.09168290f, 0.02347430f, -0.03307370f, -0.08772767f, -0.20923629f, 0.45190874f, -0.12916729f, 0.15988706f, 
    -0.10865057f, 0.05043269f, 0.01766133f, 0.02910978f, -0.10413531f, -0.40283304f, -0.04024878f, 0.04116159f, 
    0.26304021f, 0.23036635f, -0.27709320f, 0.10295298f, 0.09770200f, 0.06145738f, -0.08049481f, 0.04718938f, 
    0.08673409f, 0.07729554f, -0.15727210f, -0.00730997f, 0.65099430f, -0.26254806f, 0.39037678f, 0.05467033f, 
    0.03972447f, 0.02103594f, -0.03793377f, 0.04220868f, -0.09306198f, -0.10321840f, -0.19515252f, 0.06605425f, 
    -0.11047640f, 0.05383480f, -0.16405652f, 0.18496196f, -0.04017638f, 0.15739068f, 0.26603898f, -0.07818314f, 
    0.03746551f, 0.04580119f, -0.01485450f, 0.08552177f, 0.11924805f, 0.30329874f, 0.14092599f, -0.03292163f, 
    0.18076304f, 0.25319895f, -0.00129838f, -0.03938994f, -0.00936860f, -0.04633420f, -0.00406559f, -0.08316033f, 
    0.03162994f, 0.01147321f, 0.00199253f, 0.03713215f, -0.05051776f, 0.02676003f, -0.04603554f, -0.05244253f, 
    -0.00747934f, 0.03132153f, 0.03319303f, 0.01348040f, -0.04192794f, -0.04140068f, 0.03561141f, -0.03782157f, 
    0.02445986f, 0.02552236f, -0.00159523f, -0.04972348f, 0.00828972f, -0.01236697f, -0.04399779f, 0.04465960f, 
    -0.03435826f, 0.00423936f, -0.02574242f, 0.02512917f, -0.03035207f, -0.04385778f, 0.00958141f, -0.03182126f, 
    -0.03684501f, 0.01192158f, 0.00407089f, -0.02477522f, -0.05576520f, 0.01721120f, -0.04957189f, 0.02092314f, 
    0.04623076f, -0.02864848f, -0.03785100f, 0.05083272f, -0.00040201f, 0.04275029f, 0.02446588f, 0.01958230f, 
    0.03357320f, 0.03668694f, 0.01653611f, -0.02338887f, -0.00201098f, -0.03950582f, -0.02078857f, 0.03812103f, 
    0.02544858f, -0.03132775f, 0.01056333f, -0.04245063f, -0.04333874f, -0.03030277f, -0.05567870f, 0.00550642f, 
    0.00359068f, -0.02934999f, -0.02797977f, 0.01041050f, -0.02928062f, 0.02064797f, -0.02591173f, -0.00520271f, 
    0.02727978f, -0.02337268f, -0.04481765f, 0.03023712f, 0.03123360f, -0.02685978f, -0.05034820f, -0.04159857f, 
    0.00853874f, 0.03607109f, -0.04137090f, -0.03937455f, 0.04188843f, -0.04030252f, -0.02847980f, 0.04080116f, 
    -0.04434646f, 0.02474161f, -0.03983233f, 0.02707772f, -0.00606290f, -0.03110457f, 0.01166961f, 0.01357489f, 
    -0.03087622f, 0.02096267f, 0.03137619f, 0.03850441f, 0.01250833f, -0.00548657f, 0.03436838f, -0.02571695f, 
    -0.01961972f, -0.04172301f, 0.01121085f, -0.04049706f, 0.01892336f, 0.01020674f, -0.04873266f, -0.00451790f, 
    -0.01244826f, -0.00738728f, -0.05122313f, -0.01839026f, -0.02720745f, 0.02823715f, 0.01667832f, -0.01279957f, 
    -0.02313554f, -0.04679088f, 0.03144655f, 0.03584431f, 0.01215675f, -0.04837344f, -0.04419269f, 0.00568421f, 
    0.03882030f, 0.03182834f, 0.02478210f, 0.01223426f, -0.02946013f, 0.03168919f, 0.02760788f, -0.00847948f, 
    0.03978187f, -0.00840450f, -0.05345698f, -0.03405776f, -0.02339732f, -0.04105736f, 0.01817567f, -0.04448893f, 
    -0.02177984f, 0.03627785f, 0.01104445f, 0.00446263f, -0.00791199f, -0.02212044f, -0.00491968f, -0.02697007f, 
    0.02051571f, -0.02092855f, -0.01260728f, 0.03571213f, 0.03913043f, -0.00423590f, -0.02687928f, -0.00189447f, 
    0.01104654f, -0.01130021f, 0.02031714f, -0.04404244f, -0.03246201f, 0.02143509f, 0.02787667f, 0.01261572f, 
    -0.02974786f, 0.00454392f, -0.03078608f, -0.03394914f, -0.02382338f, 0.00437154f, 0.02373375f, 0.00276766f, 
    0.01321220f, -0.04642767f, 0.01625658f, -0.03234617f, 0.01807306f, -0.02675789f, 0.00007574f, 0.00103440f, 
    -0.04441794f, -0.04394496f, 0.00595869f, -0.04164637f, 0.02958632f, -0.04303074f, 0.04492958f, 0.01704816f, 
    0.04071572f, 0.01318706f, -0.04009951f, -0.04866457f, -0.05541620f, -0.03775809f, 0.00471085f, -0.01235899f, 
    0.02568149f, -0.02171529f, -0.01577188f, -0.00300933f, -0.02240781f, 0.03635297f, -0.03947528f, 0.01035322f, 
    0.00737630f, 0.04350029f, 0.03111173f, 0.04159419f, -0.01037683f, 0.04074724f, -0.04507886f, -0.00524974f, 
    -0.05299681f, 0.03906128f, 0.02440013f, 0.03126552f, 0.04465769f, -0.03738258f, 0.00160552f, -0.03211632f, 
    -0.02669496f, 0.00703830f, -0.04333637f, -0.02957898f, -0.03089268f, 0.02626208f, -0.03226809f, -0.02347340f, 
    -0.01526583f, -0.00240903f, -0.04066684f, 0.01658835f, 0.01782952f, -0.05154813f, -0.04990735f, 0.00691835f, 
    -0.03085120f, 0.03832974f, -0.02933432f, -0.02163050f, 0.00976604f, 0.04874521f, -0.04230110f, -0.05435130f, 
    -0.01578555f, -0.02079573f, 0.03792273f, -0.05084839f, -0.03860698f, 0.03216361f, -0.05540394f, -0.03440272f, 
    -0.04620524f, -0.03531696f, -0.01600667f, -0.03280817f, 0.04572180f, -0.03020139f, -0.02704650f, -0.00649332f, 
    0.02375710f, 0.01061291f, 0.00809060f, 0.04503953f, -0.04679137f, -0.04895787f, -0.05462296f, -0.02719119f, 
    0.00419101f, 0.01093197f, 0.00415750f, 0.00406278f, -0.02324571f, -0.02142476f, 0.04072019f, 0.02329545f, 
    0.04232281f, -0.01090352f, 0.01429379f, -0.00310498f, -0.00335439f, 0.00422121f, -0.03032827f, -0.02151430f, 
    0.01038328f, -0.04073778f, -0.03710688f, 0.00852077f, -0.02895384f, 0.04324175f, -0.02255753f, -0.01726325f, 
    -0.04047627f, -0.02073547f, -0.03767419f, -0.01084972f, -0.04070414f, -0.03673474f, -0.02467218f, 0.02970328f, 
    0.01603157f, -0.03851011f, -0.04411813f, 0.01893517f, 0.03484996f, -0.03067368f, -0.05093054f, -0.05348120f, 
    0.00657526f, 0.01396049f, -0.03480383f, -0.03002263f, 0.03673682f, -0.01704013f, -0.04760492f, -0.04410901f, 
    0.03971288f, -0.04364748f, 0.03674230f, 0.00003025f, -0.03418763f, 0.00290000f, 0.02557446f, 0.03557855f, 
    0.03827140f, -0.02827772f, -0.02154834f, -0.03952669f, 0.01225440f, -0.02463383f, -0.01925953f, 0.00617990f, 
    0.00971914f, -0.01176558f, -0.00044897f, -0.04480540f, -0.03083395f, -0.03012364f, -0.01363525f, -0.05489852f, 
    -0.02855844f, 0.02918612f, -0.01782567f, -0.02362582f, -0.02828391f, -0.05209851f, -0.03052776f, -0.01290530f, 
    -0.03733426f, 0.04493687f, -0.03466753f, -0.00412189f, -0.00641027f, 0.03743202f, 0.00701149f, -0.00689041f, 
    0.01909187f, -0.00988449f, 0.00687360f, 0.03220869f, 0.02764350f, 0.03691478f, 0.02005284f, -0.02646972f, 
    0.03066976f, 0.02138657f, -0.00468581f, -0.03070438f, -0.01476971f, 0.01892037f, 0.01672898f, -0.03369554f, 
    -0.02603854f, -0.05273850f, -0.05325500f, -0.00933767f, -0.03665477f, 0.01730929f, 0.03935211f, -0.01880897f, 
    -0.02685241f, 0.00724226f, 0.02268535f, -0.04547360f, -0.05458782f, -0.03216980f, 0.02525456f, 0.01772865f, 
    -0.04573903f, 0.02055676f, 0.00045108f, -0.01370743f, 0.03439299f, -0.05116778f, 0.00533204f, 0.01942739f, 
    -0.00639737f, 0.04581450f, -0.04845451f, -0.04881338f, -0.01136332f, -0.02876621f, -0.02605798f, -0.01180612f, 
    -0.01626652f, -0.00635274f, 0.00760991f, 0.01432117f, 0.03429985f, -0.00389497f, 0.04153760f, -0.02393836f, 
    -0.03423343f, 0.02748520f, -0.02678406f, -0.05485946f, -0.04556336f, -0.02797629f, -0.02978206f, 0.01377459f, 
    0.02540016f, 0.01253465f, -0.00900536f, 0.02235349f, 0.02948371f, 0.01239365f, 0.04274961f, -0.03247464f, 
    -0.04665755f, 0.02030990f, -0.02464341f, 0.01476617f, -0.04766845f, -0.02708374f, 0.02923289f, -0.03607466f, 
    0.03772327f, -0.03975743f, -0.04061008f, -0.05381905f, -0.03490053f, 0.02103963f, 0.02989495f, -0.03451509f, 
    0.03249008f, -0.02845210f, -0.03142329f, 0.01623347f, 0.00814508f, 0.02497087f, -0.01411441f, -0.02641530f, 
    -0.02194824f, -0.01683016f, -0.00713891f, 0.00169200f, 0.00594615f, 0.04268205f, 0.03927771f, -0.01115587f, 
    -0.03760530f, -0.01471816f, 0.03724188f, 0.01874938f, -0.02712298f, -0.01357600f, 0.00889781f, -0.04605521f, 
    -0.00615833f, 0.00812067f, 0.03139420f, -0.03403128f, -0.05881910f, -0.04141350f, 0.04271466f, 0.03923102f, 
    -0.03423097f, -0.02760943f, 0.00013318f, -0.00049233f, -0.00018155f, -0.01052852f, 0.01424974f, 0.01800522f, 
    0.00542347f, -0.04339320f, -0.04784158f, 0.04185630f, -0.02662909f, -0.01063115f, 0.00682616f, -0.02896331f, 
    -0.01318232f, 0.02331225f, -0.00576288f, 0.04136923f, 0.02052278f, -0.05142982f, 0.04344256f, -0.04764706f, 
    -0.03753030f, -0.03324733f, -0.01634557f, -0.02358548f, 0.03115372f, 0.03490369f, 0.03313207f, 0.00081371f, 
    -0.05577838f, -0.05190257f, 0.01423122f, 0.02722408f, 0.02685663f, 0.01385282f, 0.01581673f, -0.03446868f, 
    -0.03178924f, 0.04284446f, -0.05595623f, -0.01733308f, -0.04824729f, -0.05459614f, 0.03728237f, 0.00986658f, 
    0.01234514f, -0.05213708f, 0.03755696f, -0.03851198f, 0.04002094f, -0.03478765f, -0.01789562f, -0.05170276f, 
    -0.03475043f, 0.01862830f, -0.03155391f, 0.04218414f, -0.01569824f, 0.03717296f, 0.02690736f, -0.01127131f, 
    0.00721648f, -0.03781696f, -0.04184673f, -0.05330338f, -0.00991310f, -0.04184243f, 0.01740395f, 0.04282554f, 
    -0.03886938f, 0.05066946f, 0.01967634f, -0.04128469f, -0.01493745f, 0.02947524f, 0.03615138f, -0.03189311f, 
    0.00479788f, -0.00909522f, 0.00395222f, -0.02602343f, 0.03876672f, 0.04414434f, -0.00793278f, -0.00592797f, 
    0.03135897f, -0.05672580f, -0.02831242f, -0.05304325f, 0.01626215f, -0.03903086f, -0.05737916f, -0.02147796f, 
    0.01619332f, 0.03469218f, -0.00317961f, 0.01428385f, 0.03280678f, 0.02206305f, -0.02801992f, 0.01760447f, 
    -0.05662496f, -0.00150953f, -0.05172281f, 0.04530345f, 0.00023591f, -0.00552148f, 0.02271503f, 0.03292549f, 
    0.03383116f, 0.01126998f, -0.00306216f, 0.02310675f, 0.03899587f, -0.02055757f, -0.04093238f, -0.04164459f, 
    0.01857371f, -0.03234138f, 0.02267153f, -0.00105489f, 0.04436625f, 0.04131340f, 0.02324943f, 0.00160849f, 
    -0.02610678f, 0.02378832f, -0.04280103f, 0.04133171f, -0.01504461f, -0.02006144f, 0.02385585f, -0.03571471f, 
    -0.04216058f, -0.00611376f, -0.05268639f, -0.04418664f, 0.03037787f, -0.01511569f, 0.03500587f, 0.02850537f, 
    -0.03440932f, -0.00933558f, 0.02637541f, 0.02964038f, 0.01107546f, -0.01237679f, -0.01958886f, 0.03112882f, 
    -0.00198379f, -0.00492222f, 0.04009007f, -0.05307575f, -0.03779510f, -0.02961984f, -0.05423071f, 0.02149886f, 
    0.00315810f, -0.04572721f, 0.01514034f, -0.01932135f, 0.01683947f, 0.00517497f, 0.01932592f, 0.04083366f, 
    0.00629316f, -0.03509810f, -0.04432089f, 0.03275298f, -0.05497590f, 0.04514247f, 0.03587569f, 0.02801566f, 
    -0.05258071f, -0.01752085f, -0.02387710f, -0.04071381f, -0.00941446f, -0.03740070f, 0.04667488f, -0.03710946f, 
    -0.03825032f, -0.04167557f, 0.01648120f, 0.01977939f, -0.00787324f, -0.04067533f, 0.02820445f, -0.04760169f, 
    0.01613864f, 0.00682524f, -0.04013149f, -0.02385451f, -0.01711002f, -0.02757481f, -0.00634225f, -0.02456930f, 
    -0.02636912f, -0.02532419f, -0.00611649f, 0.03262500f, 0.03963798f, -0.04176162f, -0.04121549f, 0.00382355f, 
    -0.04675772f, -0.01749482f, 0.04251882f, -0.00605829f, 0.02658291f, -0.03172106f, -0.01189586f, 0.03313344f, 
    0.03140847f, -0.01604490f, -0.04745395f, -0.03430267f, -0.00504416f, -0.01172702f, 0.03998942f, 0.02838121f, 
    0.01111920f, 0.02344284f, 0.01876942f, -0.04886527f, -0.04855255f, -0.00333676f, -0.00047818f, -0.00562075f, 
    0.00895616f, -0.04330624f, 0.01897271f, -0.01811566f, -0.05612854f, 0.03435170f, -0.04502971f, 0.01216969f, 
    0.02852467f, -0.05470684f, 0.02286919f, 0.03762026f, 0.03593228f, -0.00003054f, 0.01626784f, 0.03104975f, 
    0.00026188f, -0.04798709f, 0.02445612f, 0.00904779f, -0.04228350f, -0.01332395f, -0.05283906f, 0.03425398f, 
    -0.03600138f, -0.03453786f, -0.00170321f, -0.01120620f, -0.00324962f, -0.03022411f, -0.05348746f, -0.02750561f, 
    0.03562686f, 0.04539828f, -0.03839533f, 0.03046899f, -0.00946137f, -0.01142246f, 0.00325460f, -0.01779241f, 
    0.00748021f, -0.00876446f, 0.02643987f, -0.02286736f, 0.00838965f, 0.02651574f, 0.00145172f, -0.01998150f, 
    -0.01574897f, -0.03470232f, -0.03464378f, -0.01180900f, 0.02168004f, 0.03113827f, -0.01017719f, 0.00170892f, 
    0.31258020f, 0.08577073f, 0.21391159f, 0.28031608f, 0.02325741f, 0.16661625f, 0.08363269f, 0.07532417f, 
    0.00661069f, -0.01180771f, 0.07116887f, 0.22024766f, 0.29093370f, 0.17099233f, -0.26965913f, 0.14964476f, 
    -0.09678721f, 0.14048941f, 0.07418928f, -0.11501943f, 0.21194659f, 0.08172750f, 0.07549284f, 0.08649258f, 
    -0.24517399f, 0.14583127f, 0.01486014f, 0.26258335f, -0.31520072f, -0.00785866f, -0.06054078f, 0.01157439f, 
    -0.07874379f, -0.04654722f, 0.04671801f, 0.13804658f, -0.39457044f, -0.24539119f, -0.13839982f, -0.25402638f, 
    -0.21679148f, -0.19581236f, 0.00444300f, -0.13540642f, -0.08294842f, 0.16797680f, -0.00376728f, -0.08881558f, 
    -0.12407985f, 0.27018696f, -0.06585462f, 0.05548404f, 0.05935881f, -0.06158161f, -0.01238107f, 0.01079289f, 
    0.12555461f, -0.04010535f, 0.06953866f, 0.00900488f, -0.02233509f, -0.36601868f, 0.14053451f, 0.11925673f, 
    -0.12155008f, 0.04634494f, -0.00699616f, -0.02127084f, 0.12515543f, 0.01507375f, 0.12924016f, 0.01158403f, 
    0.07270974f, -0.10875893f, 0.05064870f, -0.33813056f, 0.07058173f, -0.16370675f, -0.11292213f, -0.39186922f, 
    0.01510265f, -0.01228902f, -0.04605762f, -0.08918269f, 0.18418671f, 0.27999425f, -0.02325242f, 0.02863554f, 
    0.06079183f, 0.14775088f, 0.09196755f, 0.04986682f, -0.10622788f, -0.02147747f, -0.08403299f, 0.02810275f, 
    0.01441469f, 0.13994460f, 0.28345585f, 0.07421499f, 0.08584750f, -0.03041512f, 0.09718812f, 0.13129294f, 
    0.07538201f, 0.18749696f, 0.16903426f, -0.01361657f, 0.19941796f, 0.03980133f, -0.02387651f, 0.01128141f, 
    0.10010145f, 0.00065969f, -0.05044061f, 0.09785406f, 0.02091947f, 0.14706670f, 0.05503734f, -0.00867907f, 
    0.00947327f, 0.33380508f, 0.11353039f, 0.11700328f, 0.16383298f, 0.01525190f, 0.01835361f, 0.04780033f, 
    0.06404254f, -0.18779692f, 0.14002866f, 0.17571460f, -0.34073889f, -0.17200755f, -0.02742313f, -0.09351329f, 
    -0.08105640f, 0.12435313f, 0.09301697f, -0.01490535f, 0.07328848f, 0.16415758f, 0.19703411f, 0.03555666f, 
    -0.09587440f, 0.53516978f, -0.01641211f, 0.03558411f, 0.13351759f, 0.07020122f, 0.10973494f, 0.07235979f, 
    -0.12559633f, -0.06188138f, -0.00837491f, 0.08421875f, -0.28007635f, 0.08399855f, 0.06069116f, 0.04573875f, 
    -0.11686326f, -0.13170870f, -0.11526334f, -0.08441722f, 0.00088241f, 0.05886317f, 0.12070592f, 0.06748065f, 
    -0.17199488f, -0.05672640f, -0.08230519f, 0.05219851f, -0.04784024f, 0.07853897f, -0.04117099f, -0.23083900f, 
    0.18881695f, 0.20010684f, 0.22642232f, 0.37935200f, -0.03523623f, -0.04844501f, -0.12430870f, -0.12503783f, 
    -0.18675230f, -0.19118503f, 0.06663173f, -0.07020076f, 0.12958705f, 0.02700624f, -0.16746975f, -0.27561373f, 
    -0.51517689f, 0.25615835f, 0.10195602f, -0.24649641f, 0.15282843f, 0.24609563f, -0.08517470f, 0.03598272f, 
    -0.22915217f, 0.11409389f, 0.11605039f, -0.00375411f, -0.21288234f, -0.01521376f, -0.20680121f, 0.13824186f, 
    -0.02288741f, 0.21429890f, 0.16427223f, 0.07548899f, -0.19045292f, 0.19375336f, -0.02126121f, 0.06322278f, 
    0.18506548f, 0.07013781f, 0.15528427f, -0.05006400f, -0.02049762f, 0.05248918f, 0.05488973f, -0.00677034f, 
    -0.04160337f, 0.06990495f, 0.09269809f, 0.07088062f, -0.18628721f, 0.42680040f, -0.00884274f, -0.30068979f, 
    0.12082764f, 0.09066246f, -0.13349433f, -0.08825314f, -0.12643754f, 0.02199028f, -0.08172520f, -0.25558358f, 
    0.18396802f, 0.16719614f, 0.09230097f, 0.14703980f, 0.06860194f, 0.06507956f, -0.02296373f, 0.14976616f, 
    0.14840461f, 0.05467961f, -0.19111624f, -0.19747624f, 0.00901280f, 0.21440075f, -0.20332988f, 0.09149700f, 
    -0.03608476f, -0.12624748f, -0.04422873f, 0.11040731f, -0.15611362f, -0.10071743f, -0.13414903f, -0.01035186f, 
    -0.12701336f, -0.15286668f, -0.16456698f, 0.00181060f, 0.33244506f, 0.15595360f, -0.00663222f, -0.04405376f, 
    -0.05383795f, 0.02032484f, 0.05230053f, -0.02164429f, -0.15795960f, -0.12174728f, -0.31928444f, -0.21392153f, 
    -0.21274306f, -0.04243341f, -0.09341568f, -0.07367119f, -0.18902358f, 0.13352169f, -0.07408586f, 0.03841535f, 
    -0.24174017f, 0.47764236f, -0.30129501f, 0.18677902f, 0.24437039f, 0.19408211f, -0.05073856f, 0.03721521f, 
    0.08830468f, 0.05441511f, 0.08561309f, -0.00480147f, 0.02606576f, -0.10790674f, 0.08114227f, 0.10902791f, 
    -0.13560764f, -0.19906344f, -0.06539358f, -0.10362357f, -0.04802936f, 0.09378637f, 0.08868990f, 0.12752107f, 
    0.08993794f, 0.11719123f, 0.07766766f, 0.16007924f, 0.13185662f, 0.10546429f, 0.02426283f, 0.01726412f, 
    -0.08312064f, 0.16551508f, 0.01261290f, -0.08059813f, -0.12284425f, 0.29050756f, -0.08853570f, 0.03360234f, 
    -0.08487862f, -0.01132876f, 0.08655851f, 0.17738684f, -0.08767650f, -0.09127454f, 0.02765507f, 0.13828266f, 
    -0.17510678f, 0.14673690f, -0.09395315f, 0.21820685f, 0.16076674f, 0.14073718f, 0.03883429f, 0.04539465f, 
    0.02812198f, -0.08255226f, -0.14156802f, 0.14016677f, 0.38753927f, -0.16801220f, 0.15388289f, 0.19627438f, 
    -0.10417458f, -0.07421131f, -0.02187932f, 0.06155856f, -0.05679969f, -0.09900655f, -0.07770616f, -0.08593646f, 
    -0.04088259f, 0.03650485f, -0.23933002f, 0.29197755f, 0.07658653f, 0.15017284f, 0.09374116f, -0.22002593f, 
    0.05447502f, 0.08814778f, -0.05841498f, 0.17811549f, 0.11531574f, 0.13855556f, 0.10760743f, 0.10965087f, 
    0.19373086f, 0.24063103f, 0.11403609f, 0.01637925f, -0.00214390f, -0.02423118f, 0.09701668f, -0.07411339f, 
    0.08957960f, 0.00231496f, -0.10577369f, -0.26092446f, 0.16678682f, 0.25618491f, 0.16522622f, 0.12234709f, 
    -0.03733851f, -0.08648874f, -0.10527541f, 0.01108192f, -0.33011478f, -0.02805962f, 0.25973067f, -0.43731615f, 
    0.04992191f, 0.28680700f, -0.07872115f, -0.09368397f, -0.06622497f, 0.06954269f, 0.04972665f, 0.26686585f, 
    0.13932374f, 0.15872061f, 0.21606635f, 0.13816358f, 0.19484764f, -0.06311398f, -0.12181086f, 0.00276293f, 
    -0.04422617f, -0.09619686f, 0.14303033f, 0.02510075f, 0.02597645f, 0.17310572f, 0.21304840f, 0.05804281f, 
    -0.12053481f, 0.00262213f, -0.06056333f, 0.01839178f, 0.08043772f, 0.09306452f, 0.02166514f, 0.06808962f, 
    0.01759977f, -0.07949325f, 0.20768894f, -0.07424279f, -0.08801529f, -0.00876792f, -0.05517961f, -0.01630776f, 
    0.03830881f, 0.07494619f, -0.13118017f, -0.13550296f, -0.11755814f, -0.03688614f, -0.19284683f, 0.19629011f, 
    -0.12682585f, -0.10932867f, 0.32900140f, 0.02522110f, -0.02279291f, 0.04485579f, -0.09265246f, 0.10449716f, 
    0.23177989f, 0.04159789f, 0.21965626f, 0.06731277f, -0.14514236f, 0.01716555f, -0.02447803f, -0.05617913f, 
    0.19003291f, 0.12380712f, 0.07175732f, -0.00983294f, 0.15948376f, 0.22123125f, 0.09431905f, 0.19463442f, 
    0.13604432f, 0.17974861f, 0.14238474f, 0.17469233f, -0.03289554f, -0.05300973f, -0.08594148f, -0.10111659f, 
    0.25887069f, 0.08114463f, -0.29387021f, -0.00427839f, -0.15929890f, 0.07872100f, 0.07893559f, -0.02748153f, 
    -0.02219348f, -0.17822775f, 0.07528476f, 0.11453533f, 0.10846468f, 0.06949793f, 0.08576055f, 0.02399275f, 
    -0.14262173f, 0.04807342f, 0.08261766f, 0.13709727f, 0.00112982f, 0.18302706f, 0.04782866f, -0.21229714f, 
    0.33134508f, -0.10408814f, 0.22691192f, 0.12753884f, -0.09862134f, -0.02039867f, -0.08042601f, -0.01885553f, 
    0.32151252f, -0.04901183f, -0.01826241f, -0.11939259f, 0.13020636f, 0.10353329f, -0.05818845f, -0.05935594f, 
    -0.15519778f, -0.13599609f, 0.01010339f, 0.08613548f, -0.05014148f, 0.14595944f, 0.03684153f, -0.10541234f, 
    0.39463532f, -0.14367868f, 0.05565054f, -0.07640087f, 0.16706981f, 0.08478794f, 0.10196761f, 0.10694794f, 
    0.10530838f, -0.19312407f, -0.07132706f, 0.03588610f, 0.27145818f, 0.07607294f, 0.11561403f, -0.00593023f, 
    -0.17072499f, 0.00736893f, -0.03722515f, -0.12687908f, 0.04995093f, 0.10302625f, 0.13993691f, -0.17702505f, 
    0.05716658f, 0.04674235f, -0.02665930f, 0.10158457f, 0.12192866f, -0.00285669f, 0.12652285f, -0.00920651f, 
    0.12176827f, -0.11272269f, 0.10794747f, 0.13357699f, 0.14095700f, 0.13349846f, 0.08023193f, 0.05086803f, 
    -0.00472604f, -0.13198619f, -0.02759787f, -0.03117323f, 0.03198128f, 0.13002795f, -0.00932972f, 0.06174263f, 
    0.68161547f, 0.11673057f, -0.08761329f, -0.09843717f, 0.07003675f, -0.12294476f, 0.01293005f, -0.37740159f, 
    -0.09575847f, -0.11384265f, 0.10544570f, -0.08625031f, -0.32530060f, 0.25820938f, 0.22141962f, 0.01184327f, 
    0.17049180f, -0.00012740f, -0.01070662f, -0.00543232f, -0.06635757f, -0.15402855f, 0.10739306f, 0.05092834f, 
    0.09146055f, 0.19930218f, 0.27543291f, -0.01495923f, -0.11845873f, 0.03058189f, -0.16836558f, -0.16592826f, 
    -0.08953141f, -0.04749412f, -0.03665715f, -0.14642073f, 0.34501138f, -0.21043688f, 0.01093640f, 0.08929937f, 
    0.01779263f, -0.09820089f, -0.07784678f, -0.21024066f, 0.13743028f, -0.00572657f, 0.01780958f, 0.02725193f, 
    0.09034668f, -0.02205859f, -0.08824330f, -0.24539141f, -0.01317552f, -0.10772308f, -0.10887776f, -0.01538760f, 
    0.07527065f, 0.01700909f, -0.07591187f, -0.09118734f, -0.34940556f, -0.29123405f, 0.02588436f, -0.28069162f, 
    0.08230938f, 0.03205800f, -0.06203463f, 0.10150841f, 0.06610212f, -0.12250315f, 0.04225496f, 0.11108238f, 
    0.15404618f, 0.29018965f, 0.09465540f, -0.06058305f, -0.05613329f, -0.06688476f, 0.15457101f, 0.23746367f, 
    -0.14091656f, 0.10035174f, -0.02186284f, 0.02671549f, -0.22747779f, 0.19288579f, -0.02480134f, 0.40429372f, 
    -0.01452140f, 0.15697511f, -0.14317793f, -0.17512830f, 0.06265388f, -0.11410199f, 0.06278842f, 0.04800672f, 
    0.04321379f, -0.19459412f, 0.21505246f, -0.42617065f, -0.16050953f, 0.00543940f, 0.10579975f, 0.22027758f, 
    -0.03239044f, 0.01999993f, 0.02173242f, -0.07902206f, 0.08691581f, 0.20157479f, -0.09096073f, 0.17963618f, 
    -0.10156187f, -0.15023240f, 0.03547328f, 0.14612575f, -0.08164820f, 0.02721062f, 0.08461006f, 0.08822797f, 
    0.29581389f, 0.02449159f, -0.05489472f, -0.22398715f, 0.02533564f, -0.02995947f, -0.07555179f, 0.05485213f, 
    -0.19020328f, 0.09817123f, 0.02963866f, -0.05307030f, 0.02946530f, 0.20346576f, 0.21096961f, 0.13204652f, 
    0.09263953f, 0.06447947f, -0.12644722f, -0.09006603f, 0.05253815f, -0.28354889f, 0.04512735f, 0.16007008f, 
    0.51270467f, -0.02012585f, 0.01503477f, -0.15835053f, 0.13145958f, -0.09301128f, -0.04803775f, 0.22037929f, 
    0.21115112f, 0.02835996f, -0.08206570f, -0.20448197f, -0.19853750f, 0.21239755f, -0.01752216f, 0.34433123f, 
    0.07198312f, 0.02088059f, 0.01943900f, -0.10001574f, 0.07114530f, -0.30438429f, -0.09261341f, 0.06860027f, 
    0.10473390f, 0.11339800f, -0.06545126f, -0.06729387f, -0.03820349f, 0.00258629f, 0.05188707f, 0.24791311f, 
    -0.05256905f, 0.06780314f, 0.06963164f, 0.04522675f, 0.00326013f, 0.03952912f, -0.02776344f, -0.06495919f, 
    0.01960122f, 0.13141753f, 0.10779352f, 0.03314117f, -0.06297699f, 0.07583898f, -0.06108860f, 0.03201926f, 
    -0.02983524f, -0.01715674f, 0.02424073f, -0.00170435f, -0.04492912f, -0.05660299f, 0.04098532f, -0.04954048f, 
    -0.05617191f, 0.04017263f, -0.04990741f, 0.03276385f, 0.00356693f, 0.01872583f, -0.04614151f, -0.03134516f, 
    -0.03679877f, -0.02381895f, 0.01711042f, 0.00497506f, 0.03732899f, -0.05386762f, 0.03854851f, -0.03052975f, 
    -0.02784245f, -0.01599819f, 0.01129250f, -0.02871866f, 0.02274171f, -0.04633527f, 0.02546128f, -0.01408735f, 
    -0.01017719f, -0.04545661f, -0.05213192f, -0.04489696f, 0.00796785f, -0.00238909f, -0.04878584f, 0.00042018f, 
    0.04033435f, 0.02239805f, -0.01586677f, 0.00084346f, -0.02287694f, -0.00063414f, 0.02080021f, 0.03701989f, 
    -0.03469478f, -0.03712040f, -0.01864032f, -0.02765828f, -0.03577514f, 0.00228727f, 0.03792496f, 0.03315128f, 
    -0.05642164f, -0.01630128f, 0.03093941f, -0.03615066f, 0.02022337f, 0.04793423f, -0.03981603f, 0.02983945f, 
    0.03197380f, -0.03803647f, 0.04851907f, -0.04597018f, -0.03637549f, -0.04559265f, -0.00785979f, -0.04497243f, 
    0.04689808f, -0.01067886f, 0.01987615f, -0.01343989f, -0.03306108f, 0.02333489f, 0.01038526f, -0.03038069f, 
    0.01810719f, 0.02124430f, -0.03974077f, -0.05378144f, -0.02637756f, 0.02708423f, 0.00260485f, -0.04531519f, 
    -0.02111945f, -0.03097505f, 0.04285149f, -0.02949430f, -0.04563118f, 0.00438725f, 0.00937358f, 0.00387051f, 
    -0.01897317f, -0.02915503f, -0.05400060f, 0.04287961f, 0.01687479f, -0.00489026f, -0.01920560f, 0.01772904f, 
    -0.02966810f, -0.01274463f, -0.03097464f, 0.02170733f, -0.03914770f, 0.02977759f, -0.02115318f, -0.02275984f, 
    -0.01093649f, 0.02334655f, 0.02924740f, -0.05675123f, -0.04963153f, -0.02647530f, 0.02030252f, -0.03839029f, 
    -0.03604223f, -0.03278320f, -0.02529535f, -0.00805240f, 0.03040525f, -0.04030965f, -0.03922680f, 0.02108556f, 
    0.03879960f, -0.01882934f, -0.03382236f, 0.01927232f, -0.04020743f, -0.00503724f, 0.03468835f, 0.01167679f, 
    0.00151090f, -0.03743830f, 0.04007844f, 0.02883729f, -0.01871493f, -0.00259733f, -0.03386671f, -0.04577145f, 
    0.04044738f, -0.03362526f, -0.04878311f, 0.01217846f, 0.03164019f, 0.03146769f, 0.04149836f, 0.00707119f, 
    0.02227896f, -0.02426578f, 0.03305326f, 0.03488734f, 0.02195707f, -0.00780488f, 0.02028773f, 0.03914664f, 
    0.00213575f, -0.02547477f, 0.02452013f, -0.02240177f, 0.00663154f, 0.00065775f, 0.04590162f, -0.03858460f, 
    0.02544928f, 0.02194967f, 0.04633142f, -0.04321109f, -0.04434474f, 0.01991245f, -0.03465062f, -0.00274872f, 
    -0.00899825f, -0.02081116f, -0.02601639f, 0.02320533f, 0.05027496f, 0.01568590f, -0.04866936f, 0.00092165f, 
    -0.00331516f, -0.04342909f, -0.00263481f, -0.01720810f, 0.02286781f, -0.02156771f, -0.01028138f, 0.01489039f, 
    -0.03634582f, 0.04469156f, -0.03861859f, 0.00094941f, -0.03728154f, -0.01833167f, 0.02141854f, 0.04970741f, 
    -0.01750212f, -0.03764959f, -0.04690054f, -0.05526038f, 0.04469078f, 0.00547634f, -0.00082763f, 0.02904815f, 
    -0.01873622f, 0.00366775f, -0.04562490f, 0.02588604f, -0.00536783f, 0.02798169f, -0.02565255f, 0.04047132f, 
    -0.03702748f, -0.03538223f, -0.04681586f, 0.00013512f, -0.00919781f, 0.01957439f, -0.03037251f, 0.02058797f, 
    -0.05028798f, 0.02099252f, 0.03885522f, -0.03345935f, -0.03907659f, 0.02630911f, -0.00578121f, -0.03811346f, 
    0.01411764f, -0.03710530f, 0.00002446f, -0.04785482f, 0.01318692f, 0.00274532f, 0.02038702f, -0.03978429f, 
    0.00241950f, -0.01061140f, 0.00560451f, 0.02285401f, 0.04251964f, -0.04562984f, 0.00740939f, 0.02047861f, 
    0.03207734f, -0.01692543f, 0.00478919f, -0.03478126f, 0.01020885f, -0.04603747f, -0.01368232f, -0.01457492f, 
    0.00464699f, -0.03568816f, -0.03225854f, -0.02661911f, -0.05149285f, -0.00764634f, -0.04547885f, -0.03822799f, 
    -0.02272174f, 0.03168387f, 0.00920445f, 0.00742873f, 0.00308769f, -0.03912853f, -0.02660422f, 0.02281580f, 
    0.02265162f, -0.01323046f, 0.02114936f, 0.00693193f, 0.02488996f, 0.01773889f, -0.04239303f, 0.02615151f, 
    -0.02443398f, -0.04248351f, -0.04342271f, -0.01787645f, -0.04225654f, -0.04906156f, -0.04151739f, 0.03146252f, 
    0.03793992f, -0.01633351f, 0.03380089f, 0.02374056f, 0.03010526f, -0.00193063f, -0.04742745f, 0.00390285f, 
    -0.05465555f, -0.05699780f, -0.04265778f, -0.03348917f, -0.01293189f, 0.04510655f, 0.01400451f, -0.02828264f, 
    0.03002369f, 0.01632114f, -0.01451638f, 0.05087779f, -0.02463725f, -0.00255789f, -0.05332474f, 0.04270726f, 
    0.04957138f, 0.00882872f, -0.03154987f, -0.02645820f, -0.00917245f, 0.02713457f, 0.00174154f, 0.02810820f, 
    0.00293539f, -0.04943503f, 0.04497406f, -0.03296334f, -0.01552482f, -0.02930631f, -0.05578292f, -0.03149407f, 
    0.00946577f, 0.04209838f, 0.02810286f, -0.01038927f, -0.04614026f, 0.01325262f, -0.03416551f, -0.02507317f, 
    0.00560383f, -0.02116725f, 0.00556740f, -0.01017637f, -0.02774991f, -0.01958656f, 0.03730977f, 0.02946981f, 
    -0.00470857f, -0.00277845f, -0.01626058f, -0.02881452f, 0.00416408f, -0.04718556f, 0.02959603f, -0.03691965f, 
    0.03047982f, 0.00047524f, 0.04334705f, -0.00014359f, -0.03383666f, 0.02834092f, -0.05351296f, 0.04112760f, 
    0.02938032f, -0.03289840f, 0.02750456f, -0.02206388f, -0.04597846f, 0.04661620f, -0.05456656f, 0.03029329f, 
    0.01556701f, 0.03035849f, -0.03689248f, -0.03983160f, 0.02821534f, -0.01075874f, 0.03006884f, 0.01754849f, 
    0.00424465f, -0.04056551f, 0.00355224f, -0.05422400f, 0.03150470f, -0.01066178f, -0.01127939f, 0.00244002f, 
    0.34112972f, 0.38263196f, 0.26454037f, 0.08571897f, 0.07137346f, 0.00772885f, -0.01226599f, 0.04039418f, 
    -0.13348402f, 0.00428577f, -0.13303299f, -0.09625255f, -0.68363339f, -0.04020247f, 0.11625811f, -0.51883584f, 
    -0.01529839f, 0.06606134f, -0.00313990f, -0.15535459f, -0.14404412f, -0.00443251f, 0.06701408f, -0.02507262f, 
    -0.34623110f, -0.13569525f, -0.07548686f, -0.23692125f, 0.04763533f, -0.04940560f, -0.01161465f, -0.03520106f, 
    0.09139086f, -0.04888406f, 0.04543324f, 0.03085705f, -0.38104439f, -0.31150714f, -0.21163791f, -0.10101345f, 
    0.03981036f, 0.05044119f, 0.04752151f, -0.06704924f, -0.07538021f, 0.03903696f, 0.01631382f, 0.01236808f, 
    0.18191487f, -0.08668055f, 0.08995963f, 0.09363697f, -0.03947353f, 0.04544093f, -0.07269173f, 0.05073024f, 
    -0.13178006f, 0.08057450f, 0.07818248f, -0.08481912f, -0.20313478f, -0.35383633f, -0.14470999f, 0.00180094f, 
    0.07903276f, -0.01270434f, -0.08603548f, -0.07004548f, -0.02024527f, 0.00990719f, -0.02227393f, -0.02438523f, 
    -0.02490972f, -0.03870567f, 0.20749106f, 0.02302978f, -0.01714003f, -0.01412226f, -0.01143261f, -0.02798143f, 
    0.03621698f, 0.15813485f, 0.07810137f, -0.02796697f, 0.02132644f, 0.05289846f, 0.03742124f, 0.18147197f, 
    -0.15606266f, 0.01197316f, -0.03227498f, 0.08431941f, -0.05987198f, 0.00882373f, 0.07169283f, -0.21296847f, 
    0.22924764f, 0.32365134f, 0.07699783f, -0.04728448f, 0.06874346f, 0.05084623f, 0.06038417f, 0.00564162f, 
    0.02032665f, -0.08931822f, 0.06139331f, -0.03621886f, -0.09507733f, 0.10171811f, -0.01816702f, 0.02688082f, 
    -0.11242015f, 0.15381862f, -0.00563562f, 0.09073459f, 0.03521190f, -0.10385709f, -0.00653913f, -0.07450900f, 
    0.17914107f, 0.06489238f, 0.38470289f, 0.05748376f, -0.04160963f, 0.11290707f, 0.03183394f, 0.08748071f, 
    -0.17388231f, -0.00930753f, -0.12808624f, -0.09777206f, -0.04476548f, 0.00852160f, -0.02147360f, 0.07915092f, 
    0.01676911f, -0.02900455f, -0.04594043f, 0.14221302f, 0.01248569f, -0.06012099f, -0.09949326f, -0.05111858f, 
    0.09060843f, -0.15935548f, 0.16817375f, 0.25056753f, -0.08067355f, 0.10052383f, -0.09556507f, 0.15001272f, 
    0.14176460f, -0.09795830f, -0.08835584f, 0.04296818f, -0.28847346f, -0.26000246f, -0.12021316f, -0.22326788f, 
    -0.00134421f, 0.00478716f, 0.03558942f, 0.01765249f, -0.15204175f, 0.01326083f, -0.00485909f, 0.01109478f, 
    0.12965019f, 0.02986507f, 0.05493012f, 0.06699346f, 0.07230394f, 0.05772369f, 0.04501297f, -0.03262721f, 
    -0.02321710f, -0.05801165f, 0.13812211f, -0.04618665f, -0.10905376f, 0.04431688f, -0.08078289f, -0.01740949f, 
    0.07516150f, 0.00431057f, -0.06855138f, 0.01215124f, -0.01864123f, 0.19002883f, 0.08960813f, 0.10733701f, 
    0.02249976f, 0.55379510f, 0.08785126f, 0.03673433f, -0.07132903f, 0.02814095f, 0.09081007f, -0.06020157f, 
    0.02022579f, -0.00571866f, -0.06783016f, -0.08864325f, -0.42793211f, -0.01110357f, -0.23229712f, 0.12110091f, 
    -0.03084962f, -0.03076865f, 0.10840593f, 0.05329074f, -0.05257992f, -0.05994983f, 0.03651953f, 0.03690985f, 
    0.16607557f, 0.19567381f, 0.08221860f, 0.03114020f, 0.03294743f, 0.03942115f, -0.00940934f, 0.05317518f, 
    0.00765016f, 0.00688753f, -0.03129821f, 0.01944744f, -0.00705176f, 0.09076653f, -0.01623904f, 0.20650142f, 
    -0.05755145f, 0.06169089f, 0.01019782f, -0.01328254f, -0.01464417f, 0.03330353f, 0.05153986f, 0.12372809f, 
    0.32539850f, 0.22626306f, 0.33781710f, 0.13805711f, 0.13887003f, -0.00144997f, -0.02178588f, -0.06599223f, 
    0.01855284f, 0.18001021f, 0.07959889f, 0.14982046f, -0.22138533f, -0.15115146f, 0.18366043f, -0.09186587f, 
    -0.04560091f, -0.00228997f, -0.04000117f, 0.07447033f, 0.02668643f, 0.09409387f, 0.03648917f, 0.13830189f, 
    0.16264096f, 0.10946053f, 0.13424975f, 0.28174731f, -0.15549187f, 0.05624475f, 0.21040189f, 0.25585860f, 
    0.03198685f, 0.03791916f, -0.01688435f, 0.00497699f, -0.63413095f, -0.32444003f, -0.24517268f, 0.04666040f, 
    0.04133385f, 0.05177626f, 0.02595837f, 0.03165841f, 0.08344159f, -0.04933188f, -0.06498788f, -0.04107837f, 
    -0.00585606f, -0.00666507f, -0.03486669f, 0.29540312f, -0.05250501f, -0.16026978f, -0.00803553f, 0.12244420f, 
    0.07723732f, 0.02722816f, 0.01815359f, -0.03420629f, 0.07055177f, -0.15136634f, -0.20456180f, -0.22755383f, 
    -0.00823285f, 0.01536632f, -0.01385106f, 0.04893405f, -0.02942314f, -0.17855208f, -0.16818334f, -0.10050681f, 
    0.45183977f, 0.42008218f, 0.19691695f, 0.18422188f, 0.02964652f, 0.06828251f, 0.07024161f, 0.12099007f, 
    -0.11439501f, -0.06590937f, 0.01164692f, 0.04930668f, -0.16509113f, -0.09836216f, -0.12225187f, -0.08998403f, 
    0.00656370f, -0.00942420f, 0.00441319f, -0.14429171f, -0.13264325f, 0.06924169f, 0.11152232f, 0.01105763f, 
    0.13420267f, 0.06594532f, 0.12801281f, 0.12024873f, 0.06645115f, -0.10433710f, -0.08127236f, 0.08043413f, 
    0.11805046f, 0.10466909f, -0.03369607f, 0.10285233f, -0.18400784f, 0.05715919f, -0.13734160f, -0.06974638f, 
    0.05442503f, -0.15010990f, -0.08599005f, -0.16144034f, 0.09029168f, 0.05574363f, 0.04206935f, 0.11929369f, 
    -0.04110878f, -0.04078382f, 0.12777324f, 0.14294799f, -0.18036214f, -0.05749438f, -0.04295889f, 0.15532202f, 
    -0.04229556f, 0.00361527f, -0.01959290f, 0.00052798f, 0.32660249f, 0.25792837f, 0.11847419f, 0.25227818f, 
    -0.12223008f, 0.04284612f, 0.08282255f, 0.04483841f, 0.01832427f, -0.01737561f, 0.07806196f, -0.01329323f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.02923704f, 0.16237259f, 0.15253043f, 0.02375347f, -0.00458254f, -0.03231315f, -0.16909146f, 0.11386205f, 
    0.05823797f, 0.09242138f, 0.08809420f, 0.21926722f, 0.07043152f, 0.06120066f, 0.03061100f, 0.02540690f, 
    -0.15223365f, 0.11330432f, 0.15294035f, 0.17754371f, -0.04332644f, -0.00974880f, 0.06311685f, 0.07262304f, 
    0.01803614f, 0.05182062f, 0.01998566f, -0.04807817f, 0.15404576f, 0.08959625f, -0.04259827f, -0.06307542f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.49122584f, -0.42972025f, -0.24634849f, -0.56776369f, -0.05001085f, 0.03334362f, 0.38843226f, 0.16888942f, 
    -0.33799165f, 0.27231124f, -0.01528525f, -0.34887388f, -0.41530791f, 0.19113319f, -0.02546443f, -0.43529046f, 
    0.33212486f, 0.06157350f, -0.34218362f, -0.11740901f, 0.00820732f, -0.08897614f, 0.40929440f, -0.17100346f, 
    0.20502707f, 0.11197363f, 0.02072958f, 0.00634915f, -0.00503691f, 0.19768812f, -0.01309758f, 0.23183957f, 
    0.22258657f, 0.26911467f, 0.38051179f, 0.18675201f, -0.16350164f, -0.67748368f, 0.11623033f, -0.12341104f, 
    0.00465780f, -0.00117438f, 0.07444219f, -0.25057298f, 0.38514525f, 0.40852201f, 0.03109846f, -0.49694580f, 
    -0.89896142f, -0.20717841f, 0.02028390f, 0.27805689f, -0.72104311f, 0.09978609f, 0.23481767f, -0.11377595f, 
    -0.12223709f, 0.20420238f, 0.14817120f, 0.05602575f, -0.01565912f, 0.27319869f, -0.06235986f, 0.26790887f, 
    -0.14207764f, 0.31387624f, 0.22351389f, -0.04943338f, -0.40459427f, 0.30869627f, -0.85761738f, 0.13415599f, 
    -0.06860502f, 0.26312551f, 0.03807641f, 0.18656768f, 0.12657596f, -0.58900970f, 0.05266893f, 0.09465001f, 
    -0.49852663f, 0.31489661f, 0.19448961f, -0.17235786f, -0.06026933f, 0.09741752f, 0.42782223f, -0.40923819f, 
    -0.41715705f, -0.17855936f, -0.12955259f, 0.09481982f, 0.10854715f, -0.19703262f, 0.06853903f, 0.13158993f, 
    -0.14216825f, 0.23786114f, 0.14335249f, 0.33466384f, 0.26030022f, 0.12659927f, 0.28568211f, -0.26706028f, 
    -0.44282848f, -0.04205366f, 0.09565162f, -0.06450802f, 0.41994956f, 0.01124125f, 0.11141223f, -0.12989354f, 
    0.24616815f, -0.17765543f, 0.20549375f, -0.56675583f, -0.18311805f, 0.04360226f, -0.13935293f, 0.07780346f, 
    -0.42015553f, -0.06610427f, 0.01391472f, 0.06710760f, 0.19265142f, -0.57403272f, -0.04649232f, 0.12628698f, 
    0.29784411f, -0.17346859f, -0.22064427f, -0.24957158f, 0.17228590f, 0.29396215f, -0.17377900f, 0.05936097f, 
    -0.04343479f, -0.34594387f, 0.14930642f, -0.42245233f, -0.46925077f, -0.00802978f, -0.04353045f, 0.41671062f, 
    0.23234972f, 0.30618364f, -0.46473554f, -0.09950614f, 0.20177837f, 0.05582725f, -0.07693112f, -0.19601564f, 
    0.15316153f, -0.11730458f, 0.00793151f, -0.13424636f, -0.18244407f, -0.02218407f, -0.13720560f, 0.19946639f, 
    0.00674163f, -0.04476327f, 0.15134454f, -0.59800702f, 0.20447764f, -0.48603314f, -0.46478915f, 0.12172134f, 
    0.29413316f, 0.15966359f, -0.04662624f, -0.16662931f, -0.42936754f, 0.30092469f, -0.08321077f, 0.27422833f, 
    -0.35897768f, 0.18123546f, 0.22748542f, -0.17430881f, 0.23381805f, 0.10884723f, -0.17365678f, -0.19799857f, 
    0.39321208f, 0.18699417f, -0.06073620f, -0.10200167f, 0.13133647f, -0.03274583f, 0.14601621f, -0.36725783f, 
    0.02287347f, 0.25593406f, -0.75180453f, 0.21633555f, -0.72348571f, -0.01426409f, -0.60700631f, 0.39230216f, 
    0.39348254f, 0.19450904f, -0.64278603f, 0.12162879f, 0.42112848f, -0.37780115f, 0.15853700f, 0.24645592f, 
    0.05544638f, -0.52825642f, -0.37771469f, 0.20461641f, 0.07129898f, 0.01127996f, -0.15581334f, -0.13391528f, 
    -0.01073930f, -0.10865183f, -0.14866559f, -0.07696046f, -0.03623691f, -0.89270246f, -0.17718343f, -0.52564770f, 
    0.13533993f, 0.03640287f, -0.67817467f, -0.29251328f, 0.27228829f, 0.32561991f, 0.11402671f, -0.50920874f, 
    -0.05321528f, 0.39433375f, -0.29614615f, 0.09933005f, 0.21902332f, -0.32166392f, -0.10889643f, 0.00587381f, 
    -0.02198575f, -0.30991828f, 0.14604801f, -0.31494215f, 0.39984253f, 0.01345188f, -0.17916813f, -0.19648023f, 
    0.09415574f, -0.26334512f, 0.12330729f, 0.06485832f, -0.49468035f, 0.38414744f, 0.14853324f, -0.06007032f, 
    -0.25770050f, 0.03892238f, -0.43695965f, -0.18292765f, 0.09639344f, -0.37329149f, -0.15453188f, 0.13076855f, 
    0.02015943f, -0.27811518f, -0.05901485f, 0.28751302f, -0.16503473f, -0.40313274f, -0.06359003f, -0.59500390f, 
    -0.42898297f, -0.37458631f, 0.41766167f, -0.08837397f, -0.38013163f, -0.15340704f, 0.08854994f, 0.57156485f, 
    0.13180593f, -0.32532600f, 0.08094909f, -0.03181711f, -0.15791140f, 0.24774157f, -0.16879700f, -0.57338893f, 
    -0.30464780f, -0.32667419f, 0.35587642f, 0.13863859f, -0.52436066f, 0.29064518f, -0.38256729f, 0.02316913f, 
    0.26824346f, 0.29552662f, -0.22816136f, -0.18952037f, -0.11910779f, 0.24134895f, 0.07783126f, 0.28787559f, 
    -0.01331593f, 0.18579954f, -0.32984197f, 0.31117925f, -0.30898389f, 0.12444532f, -0.73433739f, 0.11244853f, 
    0.25143534f, -0.36840099f, 0.03717463f, 0.03833427f, -0.30136344f, 0.21767023f, 0.17034614f, 0.19031619f, 
    0.27561125f, -0.32691717f, -0.28455892f, 0.02439137f, -0.10894141f, -0.34116110f, -0.52112615f, 0.09870512f, 
    -0.16051711f, 0.06846579f, 0.39943177f, 0.25181836f, -0.01607703f, -0.68609512f, 0.02441880f, -0.28739420f, 
    -0.39983454f, -0.48744020f, -0.14933905f, -0.12664112f, -0.33625028f, -0.12467344f, -0.64551747f, -0.00862262f, 
    0.06039441f, 0.31494004f, -0.07056269f, 0.11316914f, 0.52566367f, 0.00393775f, 0.13172263f, 0.15511294f, 
    0.24285148f, -0.14435938f, 0.45823994f, 0.39283746f, -0.14775886f, -0.42182970f, 0.18990698f, 0.27144104f, 
    -0.23842061f, -0.69531059f, -0.37462473f, 0.30695462f, -0.43621728f, -0.18971474f, 0.09554229f, 0.08723897f, 
    0.24733156f, -0.41246942f, 0.14471591f, 0.11677418f, 0.64159364f, 0.12432425f, -0.16343944f, -0.11991145f, 
    -0.34827259f, 0.19379808f, -0.00351323f, -0.18088178f, -0.30318412f, -0.25908059f, 0.11932313f, -0.17924736f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.40944150f, 0.07156568f, 0.27576229f, 0.01417141f, -0.14758113f, -0.11696056f, 0.00246061f, -0.03218098f, 
    0.15138859f, 0.21086776f, 0.00672399f, -0.05850311f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
