#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.05985640f, 0.27504933f, 0.04320313f, 0.08791710f, 0.35609490f, 0.57722694f, -0.49736485f, -0.97936791f, 
    -0.51900327f, -0.28396672f, -0.88506752f, 1.24590135f, -0.42824215f, -0.66183621f, -0.07274451f, 0.26363653f, 
    -0.18715890f, 0.24491450f, -0.07412565f, 0.64814472f, -1.07664442f, -0.21805227f, 0.43300152f, -1.00390983f, 
    -0.10660101f, -0.60372782f, -0.38263044f, -0.02284996f, 0.54120618f, -0.63450474f, -0.69429612f, 0.24076886f, 
    -0.07482518f, 0.73456842f, 0.50056058f, 0.61348778f, 0.07661448f, 0.67965811f, 0.56505305f, -0.84875304f, 
    -0.19112474f, 0.06588964f, 0.45770180f, 0.57963520f, -0.59632427f, -1.27972662f, 0.26571164f, 0.12924016f, 
    0.67077607f, 1.01146448f, 0.80462748f, 0.13122243f, 0.16470672f, 0.01663302f, -0.29090098f, -0.30704612f, 
    -0.20409001f, -0.59155202f, -0.30029580f, 0.74859554f, 0.70066273f, -0.57870406f, -0.40660989f, 1.21432018f, 
    -0.17423597f, -0.48682329f, -0.12547135f, 0.43399441f, 0.07274829f, 0.30756333f, 0.39452541f, 0.09246958f, 
    0.20857880f, 0.25591370f, 0.64394087f, 0.57127684f, 0.09013424f, -0.09945778f, 0.11037084f, -0.12433807f, 
    -0.47080308f, -0.14442417f, -0.27719104f, -1.04697061f, -0.48402828f, -0.46864831f, -0.10419669f, -0.66416800f, 
    -0.67121243f, -0.12932871f, -1.33680439f, -1.14719737f, 0.10866155f, 0.74426252f, -0.05128888f, -0.36947435f, 
    -0.19401151f, -0.18219790f, 0.03813732f, -0.06073180f, -0.50986290f, -0.71819574f, -0.89503860f, -0.44341597f, 
    -0.83265883f, 0.34069318f, 0.54463065f, 0.55207610f, 0.27863503f, -0.64224309f, 0.92633736f, -0.40837392f, 
    -0.05334411f, 0.90268642f, 0.13802756f, 0.22202873f, 0.13517576f, -0.04934916f, 0.00551218f, 0.03738198f, 
    -0.22405137f, 0.28311050f, -0.72128540f, 0.87735933f, -0.42583659f, 0.34373581f, 0.17092626f, 0.16314434f, 
    0.54309249f, 0.87951428f, -1.38004899f, -0.58273095f, -0.21413694f, 0.12688407f, 0.05782910f, -0.07463835f, 
    1.36312521f, -0.91326427f, -0.50056481f, 0.64722043f, -0.24197282f, -0.25245363f, 0.03216103f, 0.42379874f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.01147375f, 0.14889926f, 0.58000869f, 0.25706232f, -0.11331255f, -0.33405802f, 0.58798999f, 0.74512869f, 
    0.60237539f, 0.24074706f, 0.54381454f, 0.07919671f, 0.42205617f, -0.26964825f, -0.25499624f, 0.45334560f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.04658807f, -0.09181567f, 0.04708941f, -0.04153615f, 0.05818726f, 0.02144085f, 0.04115494f, -0.09840066f, 
    -0.01024359f, -0.09281275f, -0.03349792f, -0.10024789f, -0.03216162f, 0.05676445f, -0.07015488f, -0.03753760f, 
    -0.04993701f, -0.10296144f, 0.04205937f, -0.01422786f, -0.00841549f, -0.01843353f, 0.07167458f, -0.03406813f, 
    -0.06840206f, -0.07592699f, -0.09044021f, -0.10566747f, 0.00727699f, -0.05963236f, 0.00875241f, 0.00003061f, 
    -0.04940077f, -0.09972570f, 0.05384662f, -0.06538343f, 0.01766442f, -0.01408107f, -0.10079987f, -0.08206744f, 
    -0.01586154f, 0.02757738f, -0.05919311f, 0.05882909f, 0.03157850f, 0.02752064f, -0.03577003f, -0.01610048f, 
    -0.06848983f, -0.00494364f, 0.03647644f, 0.02714678f, 0.05788478f, -0.05242036f, -0.05352773f, -0.08728839f, 
    -0.05319782f, -0.00530822f, -0.03364435f, -0.00711441f, -0.05342585f, -0.04010972f, -0.09105184f, -0.03604963f, 
    -0.04400310f, 0.00036515f, -0.00462057f, -0.07568456f, -0.09690139f, -0.05797578f, -0.05647161f, -0.07278438f, 
    0.00238762f, -0.06825943f, -0.00492995f, 0.01451516f, 0.04431874f, -0.08776771f, -0.09118956f, -0.03725454f, 
    -0.05144051f, 0.01868013f, 0.04590040f, 0.07432489f, -0.01218549f, -0.00298726f, 0.06355892f, -0.05630113f, 
    -0.07282700f, -0.02534860f, -0.06828044f, -0.09680676f, -0.09372701f, -0.00329595f, -0.01447720f, -0.01842174f, 
    -0.04531274f, -0.01827652f, -0.09349934f, -0.03212705f, -0.01428587f, 0.06325361f, 0.05509111f, -0.01162735f, 
    -0.03045743f, -0.03076620f, -0.03669429f, 0.05400328f, 0.05741821f, -0.03003220f, 0.04811078f, -0.03640335f, 
    -0.00680244f, -0.08875022f, -0.08876301f, 0.04454731f, 0.05454025f, -0.02039277f, 0.06344443f, 0.05475579f, 
    0.05567314f, -0.04052741f, 0.05414345f, -0.03445177f, 0.00003941f, -0.05811358f, -0.03003291f, 0.05762916f, 
    -0.02147445f, -0.05738357f, 0.01766752f, 0.02419775f, -0.06901987f, 0.03549020f, 0.00046560f, -0.01788807f, 
    -0.03702196f, 0.02216098f, 0.02751680f, -0.09653940f, -0.00037329f, -0.02301501f, 0.03986609f, -0.08017077f, 
    -0.28005368f, -0.19114079f, -0.27244201f, 0.05254812f, -0.05379752f, -0.10209525f, 0.06178897f, -0.14139470f, 
    -0.24751754f, -0.57794976f, -0.33455056f, -0.08069237f, 0.16192700f, -0.20829900f, 0.18198411f, -0.34200120f, 
    -0.04360971f, -0.05950264f, 0.09741919f, 0.27941540f, 0.35333887f, 0.12633277f, 0.13481091f, 0.14132547f, 
    0.16248782f, -0.07899097f, -0.01569417f, -0.11566809f, 0.02800620f, 0.00449041f, 0.02683501f, 0.16031238f, 
    0.18137802f, 0.10933207f, -0.10480572f, 0.11400949f, -0.09881092f, -0.00045024f, 0.19997661f, 0.06336021f, 
    0.06010701f, 0.30914876f, 0.16862516f, 0.03182351f, 0.14504324f, 0.33170083f, 0.22370309f, 0.30762219f, 
    -0.28021523f, 0.09427346f, -0.26716045f, -0.01454437f, -0.02835534f, 0.11765036f, -0.22637515f, 0.01834242f, 
    0.14568740f, -0.04324372f, -0.18081962f, -0.23769322f, 0.17202470f, -0.12194033f, 0.10666507f, -0.26171300f, 
    -0.24207787f, -0.00968738f, -0.05917731f, 0.29485700f, -0.28163648f, -0.20733167f, 0.12772468f, 0.33354846f, 
    0.01516542f, -0.69617343f, 0.07334387f, 0.02893098f, -0.01201662f, -0.15699162f, -0.06436750f, 0.02240113f, 
    -0.05728387f, -0.37134942f, 0.17941000f, -0.03430546f, -0.02079545f, 0.17328691f, -0.04759904f, 0.08132222f, 
    0.11140174f, 0.09741223f, -0.16530377f, -0.10977796f, 0.25993213f, -0.07898802f, 0.12975800f, 0.08634550f, 
    0.16535190f, -0.00270946f, 0.03936305f, -0.04469954f, 0.11769691f, 0.18769662f, -0.05143733f, -0.09623837f, 
    -0.09459726f, 0.03978905f, 0.02406923f, 0.06736737f, -0.61096048f, -0.40165064f, 0.28265223f, -0.14253235f, 
    -0.22680716f, 0.05711773f, -0.03132496f, 0.07738604f, 0.09128594f, -0.19460064f, 0.22681251f, 0.02889391f, 
    0.18781745f, 0.01816782f, -0.17455302f, -0.06236691f, -0.13662262f, -0.07014299f, 0.16298597f, -1.19679368f, 
    -0.40960613f, 0.05087781f, -0.11733153f, -0.17842460f, -0.10975327f, 0.05201359f, 0.04848468f, 0.20656270f, 
    -0.42931738f, 0.15456118f, 0.03294273f, -0.04086489f, 0.44930208f, -0.15761864f, -0.01737279f, 0.14751300f, 
    -0.01598528f, 0.16852504f, -0.01535951f, -0.05192136f, -0.10215993f, 0.04111059f, -0.04305305f, -0.05980755f, 
    -0.00529593f, -1.08112991f, 0.11137690f, 0.34417844f, -0.06009525f, 0.29216176f, 0.28481567f, -0.07445145f, 
    0.12365658f, 0.09788409f, -0.16314062f, -0.20601715f, -0.08474042f, 0.16980276f, 0.10949387f, 0.02722431f, 
    -0.07486476f, -0.20557049f, -0.01907166f, -0.09001295f, 0.06525818f, 0.02484261f, 0.33983639f, 0.01762713f, 
    0.28764865f, -0.02045424f, -0.05291437f, 0.00331768f, 0.31063274f, 0.21217784f, 0.29361439f, 0.01611387f, 
    -0.08532633f, -0.00429210f, -0.01901372f, 0.18902013f, 0.08471306f, -0.01742441f, 0.01852274f, -0.13237312f, 
    0.10034704f, -0.18094936f, -0.16224569f, 0.21656996f, -0.21945694f, -0.14997047f, -0.33591142f, 0.18504260f, 
    -0.10510208f, -0.04627680f, -0.10327578f, -0.01497255f, -0.14341743f, 0.20699286f, -0.16788834f, 0.42740771f, 
    0.08155212f, 0.21938625f, 0.09725074f, -0.09854747f, 0.24611953f, -0.17049943f, 0.06515235f, 0.10975549f, 
    0.04448066f, 0.16910087f, 0.06975227f, -0.05031503f, 0.06950875f, 0.09148232f, -0.21497795f, 0.22005419f, 
    0.14266618f, 0.10418040f, -0.21543062f, -0.53550225f, -0.00153446f, 0.00020796f, -0.32953876f, 0.08841848f, 
    0.09246251f, 0.10854764f, -0.46672854f, -0.12028529f, 0.16459675f, 0.03013116f, 0.08674601f, -0.03086624f, 
    0.10721040f, -0.06112118f, -0.08258317f, -0.18726589f, 0.00424761f, -0.38050088f, 0.07713462f, 0.02099711f, 
    0.15351580f, 0.11744180f, 0.01760696f, -0.00858346f, 0.52917582f, 0.39427355f, 0.16594610f, -0.11173025f, 
    0.11692187f, 0.04740863f, -0.14478613f, 0.03925779f, 0.04382575f, -0.41230503f, -0.25172338f, 0.61642361f, 
    0.13774130f, 0.07521532f, 0.07510110f, -0.15354548f, 0.05176101f, -0.08581023f, -0.01880373f, -0.05863399f, 
    0.29027599f, -0.03919078f, 0.09735572f, 0.11796754f, 0.13840048f, -0.02115878f, 0.19837384f, -0.21511181f, 
    0.18051364f, 0.13439789f, 0.36547080f, -0.14130311f, 0.21534002f, 0.14679153f, -0.12547354f, -0.18521422f, 
    0.28888172f, 0.21914157f, 0.32876208f, 0.29511881f, -0.15950857f, 0.09393150f, -0.54027724f, 0.33447206f, 
    -0.01584373f, 0.02196097f, -0.13725650f, 0.06537203f, 0.01154120f, -0.15000914f, -0.15209891f, -0.00745785f, 
    0.20047258f, 0.19514534f, -0.52758789f, -0.26350427f, -0.33893621f, 0.06735740f, 0.14101699f, -0.07941958f, 
    0.07840622f, 0.01441673f, -0.27448934f, 0.11052942f, 0.06931154f, -0.06145453f, -0.00272138f, -0.16081962f, 
    -0.15442963f, 0.13626184f, 0.23015498f, 0.22991088f, 0.45532009f, -0.11568343f, 0.14961365f, 0.07660582f, 
    -0.00599405f, 0.36045671f, -0.09428532f, 0.22068998f, 0.56686819f, 0.44384354f, 0.33463120f, 0.27861345f, 
    -0.30062136f, -0.22638293f, -0.08331990f, -0.03606945f, 0.02177421f, 0.06826634f, -0.00261098f, -0.27422777f, 
    -0.50306630f, -0.18750930f, 0.06759115f, -0.29241821f, -0.16136821f, -0.48146006f, -0.16461390f, 0.12338639f, 
    -0.06692500f, 0.10343096f, 0.19164269f, -0.32024115f, -0.12164796f, 0.02807289f, 0.29076248f, 0.32301092f, 
    0.16317926f, 0.06876092f, 0.12000111f, 0.17529394f, -0.09510836f, -0.14809780f, -0.22787724f, -0.27631533f, 
    -0.07467309f, -0.49224108f, -0.40230167f, -0.62916225f, -0.07677042f, 0.02073053f, 0.03462378f, 0.29151317f, 
    0.16902332f, -0.07706891f, 0.23989059f, -0.44332987f, -0.60494500f, -0.15135929f, -0.11243542f, 0.03457418f, 
    -0.00556943f, 0.02379472f, -0.15262216f, 0.11394927f, -0.01787839f, 0.18020400f, 0.21277145f, -0.04759465f, 
    0.00505742f, 0.00934891f, 0.23831438f, 0.05167936f, 0.37824574f, 0.02875101f, 0.04263008f, -0.07093365f, 
    -0.25404891f, 0.08479798f, 0.03640923f, -0.24160464f, 0.06924533f, 0.23381199f, -0.17555295f, 0.34423423f, 
    -0.04596991f, 0.20307833f, -0.29116106f, 0.03852597f, 0.03203911f, -0.00402992f, -0.25244629f, 0.28017902f, 
    0.12709947f, 0.07065386f, 0.22252616f, -0.01412454f, -0.11958361f, -0.39216748f, -0.07824172f, 0.06731428f, 
    -0.07988128f, -0.14703566f, 0.26575357f, 0.20299293f, 0.20479634f, 0.21507102f, -0.13953969f, -0.05352658f, 
    -0.11580797f, 0.16712902f, -0.01551159f, -0.04001202f, 0.01268699f, -0.00316312f, -0.27697781f, 0.12842634f, 
    0.23677097f, -0.38586614f, -0.97379142f, 0.06791046f, 0.02614243f, 0.23454386f, -0.03095602f, -0.09692010f, 
    -0.13475563f, -0.22890633f, -0.24267162f, 0.04499365f, -0.12686343f, -0.11007302f, 0.25523064f, 0.13981779f, 
    -0.05799750f, 0.09452593f, 0.32121265f, 0.23491630f, 0.05266432f, -0.15804188f, 0.14051113f, 0.00724003f, 
    0.02850847f, 0.11514170f, 0.08514813f, -0.10672309f, -0.06713783f, -0.06366186f, -0.14570329f, -0.11814369f, 
    -0.29252961f, -0.12187955f, -0.15141366f, 0.11193869f, -0.28333363f, 0.28349668f, 0.28331342f, -0.23474854f, 
    -0.17920868f, -0.12644504f, -0.22405626f, -0.21368343f, -0.11581352f, -0.03356061f, 0.00126046f, 0.21711479f, 
    0.17486688f, -0.03530903f, 0.13474612f, 0.02899303f, 0.14799108f, 0.06770556f, 0.10217962f, 0.21569404f, 
    0.11391374f, -0.06470147f, 0.18902613f, 0.01810990f, 0.17836221f, 0.05447722f, 0.09884061f, -0.20334661f, 
    -0.11097665f, -0.07276767f, -0.01383705f, 0.02244180f, 0.08040178f, 0.02639300f, 0.21330889f, -0.01059600f, 
    0.25773826f, 0.25230104f, -0.85740888f, -0.19494948f, -0.02025402f, -0.02530879f, 0.18229592f, 0.27916178f, 
    -0.05887478f, 0.09881230f, 0.02314108f, -0.49969009f, -0.53407454f, 0.06846856f, -0.08060717f, -0.09236173f, 
    -0.02978230f, 0.15628925f, 0.08529054f, 0.17011714f, 0.27707702f, -0.49649575f, -0.07163714f, -0.17143999f, 
    -0.04508518f, 0.01588225f, -0.15959607f, -0.24880962f, 0.26322126f, 0.06995174f, 0.18327628f, -0.06421714f, 
    0.18481737f, 0.07156599f, 0.09638967f, -0.03796465f, -0.21247545f, -0.25138497f, -0.37046427f, -0.03117784f, 
    0.26866895f, 0.03484824f, 0.10941675f, 0.16171299f, 0.04149337f, -0.22991697f, 0.35982510f, -0.04762445f, 
    0.30307868f, -0.25871959f, -0.02769249f, -0.11633494f, -0.25066698f, -0.01769419f, 0.15297677f, 0.19047494f, 
    0.40728122f, -0.13054411f, 0.02859647f, 0.19153917f, 0.03225575f, 0.16304173f, -0.05159101f, -0.23333903f, 
    -0.05003956f, 0.03949899f, 0.00519890f, 0.03356614f, -0.05220965f, -0.05099665f, 0.04149806f, 0.08452818f, 
    0.03664944f, -0.02778643f, 0.05655275f, -0.08770634f, 0.04684523f, -0.01992156f, 0.02642144f, -0.00246027f, 
    0.06834403f, 0.07592745f, 0.06077996f, -0.09922791f, -0.02616500f, 0.00901663f, -0.10675553f, -0.12682097f, 
    -0.00518216f, 0.05091079f, 0.05833253f, 0.04068492f, -0.07617181f, 0.02541187f, -0.00257757f, -0.07728598f, 
    0.03232683f, 0.01711186f, -0.01475461f, -0.05854871f, 0.02575381f, -0.11609993f, -0.02893424f, -0.05414969f, 
    -0.10680920f, 0.02808121f, -0.10623743f, -0.01524929f, -0.07318330f, -0.03049808f, -0.03350482f, 0.00262316f, 
    0.03395499f, 0.04199512f, 0.04324709f, -0.00895960f, -0.04653035f, -0.10498524f, 0.03103287f, 0.04338071f, 
    -0.09918706f, 0.02985651f, 0.01528270f, 0.04075532f, 0.02831539f, -0.04938824f, 0.02580036f, -0.08377516f, 
    0.02647878f, -0.10150326f, -0.06104990f, -0.08661039f, 0.00268111f, -0.05233085f, -0.08749168f, -0.03476761f, 
    -0.08303154f, -0.12479834f, -0.09729291f, -0.02103265f, 0.02520105f, -0.09362425f, -0.03424858f, -0.04882043f, 
    0.00927675f, 0.04607809f, -0.06406012f, -0.06123931f, -0.05315083f, -0.08314779f, -0.11630698f, -0.00698867f, 
    0.01515227f, 0.04841470f, 0.01847237f, -0.03802326f, 0.01425490f, 0.02218410f, -0.03938751f, 0.02373117f, 
    -0.07843496f, -0.06623264f, -0.09909756f, 0.07459470f, -0.03675098f, -0.02271497f, -0.08646244f, -0.04064477f, 
    -0.04453615f, 0.01175111f, 0.02787297f, 0.03020174f, -0.08170476f, 0.00913861f, 0.01340599f, -0.03187735f, 
    0.02666079f, -0.07565068f, -0.09680638f, -0.05818842f, -0.03570709f, -0.03459550f, -0.01409259f, 0.02726010f, 
    -0.05805526f, -0.05806379f, -0.08984815f, 0.01484909f, -0.11771353f, -0.03990312f, 0.00869240f, 0.00832183f, 
    -0.13371572f, -0.00282155f, -0.04429015f, 0.00296968f, -0.04527931f, 0.00155866f, -0.04354513f, 0.01729941f, 
    0.02731818f, -0.01028937f, -0.09185225f, -0.00081684f, 0.04163527f, -0.02539112f, -0.04868685f, 0.00664416f, 
    -0.05126651f, -0.03721336f, -0.23422337f, 0.02946416f, -0.03853019f, 0.14686696f, -0.35779738f, -0.46517953f, 
    -0.31603420f, -0.24331491f, 0.22164996f, 0.34512594f, 0.10675599f, 0.13464433f, 0.16669483f, 0.07709286f, 
    0.05894752f, 0.21218023f, -0.26852721f, 0.57207465f, 0.11651354f, -0.00086699f, 0.14603631f, 0.06407721f, 
    0.02563723f, 0.07737403f, -0.53701830f, -0.10225487f, -0.04831393f, -0.23806362f, -0.01951243f, 0.15432930f, 
    -0.05895971f, 0.25141305f, 0.32032925f, 0.21752091f, 0.03886412f, 0.14546616f, 0.01270123f, -0.15732169f, 
    0.47995919f, -0.31951872f, 0.12295433f, 0.24517393f, 0.10428640f, 0.04038645f, -0.17795512f, -0.06660615f, 
    0.16282657f, 0.11099792f, -0.01993321f, -0.14745134f, 0.07370173f, -0.15935734f, 0.30357927f, -0.06305248f, 
    0.37674835f, -0.09821299f, 0.15810288f, 0.07649842f, -0.32323429f, -0.01296619f, -0.18729450f, 0.00375589f, 
    0.11376137f, -0.01497435f, 0.11402614f, 0.31631303f, 0.09785727f, -0.07264705f, 0.23869014f, 0.04198956f, 
    0.03216360f, 0.11371651f, 0.11254372f, 0.00365787f, -0.11095316f, 0.02691913f, -0.05740802f, 0.26241204f, 
    -0.17871045f, -0.46226236f, -0.17582013f, -0.21051344f, -0.09132200f, -0.03518141f, 0.01176013f, 0.11102428f, 
    -0.04963968f, -0.14927979f, -0.19205704f, -0.22277595f, 0.10183906f, 0.03477995f, -0.06838536f, -0.12261716f, 
    -0.03764033f, -0.18284124f, 0.10818686f, -0.01514614f, -0.34747159f, 0.02827960f, -0.16875842f, -0.01955950f, 
    -0.15988585f, 0.25762248f, -0.01724557f, 0.14199752f, 0.35128310f, 0.30539832f, 0.17744909f, -0.07259663f, 
    -0.16578095f, -0.03935691f, 0.13530616f, 0.16588393f, -0.03882786f, -0.45879781f, -0.34723729f, 0.13112739f, 
    0.12773862f, -0.20165831f, -0.12348708f, -0.04489192f, 0.09074672f, -0.05871476f, -0.42503676f, 0.21322571f, 
    -0.19223852f, 0.07877939f, 0.00785218f, -0.10835858f, 0.12731077f, 0.02926863f, 0.10296401f, 0.37424946f, 
    0.41583115f, 0.21510389f, 0.11629664f, -0.11929287f, 0.07668293f, 0.23627146f, 0.46091664f, -0.00449672f, 
    -0.01041964f, 0.14848147f, 0.26710898f, -0.30502972f, 0.08079759f, 0.04938886f, 0.08808653f, 0.15162031f, 
    0.25864667f, -0.36364973f, -0.62006861f, -0.36846718f, 0.08802073f, 0.26660386f, 0.06562935f, 0.01693425f, 
    0.08164702f, 0.10039870f, -0.60599321f, -0.13857512f, -0.68815237f, -0.03000083f, 0.01649310f, 0.01722044f, 
    -0.07730258f, 0.02821917f, -0.03601989f, 0.31095293f, 0.12631385f, -0.49058920f, -0.04707894f, 0.14103961f, 
    0.14274924f, 0.12939569f, 0.11816981f, 0.20752564f, -0.09767359f, -0.77891380f, 0.23401807f, 0.39183784f, 
    0.02066213f, -0.22461282f, -0.00347050f, 0.02137708f, -0.10255519f, 0.09465343f, -0.09664575f, 0.22250362f, 
    -0.22349101f, -0.44885090f, -0.22946432f, 0.22962365f, -0.01018065f, -0.06145630f, -0.05443801f, 0.46904492f, 
    -0.01341253f, -0.12121470f, 0.02666062f, -0.02453593f, 0.20300798f, 0.19304198f, -0.09980565f, 0.02025654f, 
    0.14669594f, -0.50089949f, 0.04341988f, -0.02543314f, 0.03018336f, 0.16966937f, 0.14401454f, 0.21925803f, 
    -0.26919040f, 0.04918396f, -0.10698508f, 0.01119780f, -0.02101857f, -0.12343974f, -0.02680486f, 0.06229643f, 
    0.01487513f, -0.35258931f, 0.18235272f, -0.11861377f, -0.24639995f, 0.03262992f, 0.03223542f, -0.00038359f, 
    0.21493521f, 0.10179012f, 0.10928665f, 0.37601766f, 0.06286450f, 0.00207852f, -0.08380962f, -0.04904198f, 
    0.13239051f, 0.01137218f, 0.16406946f, 0.24194752f, 0.56372005f, -0.19448043f, -0.29819679f, 0.01198816f, 
    -0.07419286f, -0.13576712f, 0.05947142f, -0.19204924f, -0.04466065f, -0.35223237f, 0.01354991f, 0.06674980f, 
    0.42086303f, -0.01286149f, -0.04586092f, 0.02548640f, -0.13639860f, -0.74098289f, 0.14537254f, -0.19913805f, 
    -0.06611189f, 0.13371141f, 0.04074691f, -0.01223506f, 0.04639792f, 0.00849283f, -1.01408732f, 0.22431685f, 
    0.19657134f, 0.11406831f, 0.00228410f, -0.00724307f, 0.01581520f, -0.15763950f, -0.12466224f, 0.39955470f, 
    0.01575615f, -0.42011157f, -0.22697589f, 0.14358190f, 0.15731509f, 0.02562956f, -0.10383404f, 0.15205131f, 
    0.28090322f, 0.15405761f, 0.03677598f, -0.10972855f, -0.05866887f, -0.07411060f, 0.00191188f, -0.11889121f, 
    -0.00946283f, 0.12124281f, 0.30242416f, -0.30781621f, -0.34821284f, 0.06945869f, 0.11492954f, -0.24424250f, 
    -0.17445685f, -0.25331631f, 0.29765606f, -0.61112046f, -0.56294709f, 0.09357885f, -0.21098267f, -0.19766939f, 
    0.07380049f, -0.03452110f, 0.10994435f, 0.14784074f, 0.15127319f, -0.00396798f, 0.15950090f, 0.09225165f, 
    0.03979542f, 0.10347050f, -0.04371983f, -0.15124999f, -0.12271301f, 0.07895967f, 0.15384182f, -0.18409874f, 
    -0.13093638f, -0.25311682f, 0.18365084f, -0.47071066f, 0.04804771f, 0.04906403f, -0.07763217f, 0.20042546f, 
    -0.26712543f, -0.29114512f, -0.27087149f, -0.10374798f, -0.13356104f, -0.06889827f, -0.21376546f, 0.10117843f, 
    -0.24882545f, -0.04945958f, 0.18051130f, 0.07061511f, 0.06701436f, -0.02814764f, 0.22685650f, 0.27228171f, 
    0.10953186f, 0.07471150f, 0.30205923f, 0.10331286f, 0.10280932f, 0.12290166f, 0.17977895f, -0.04461776f, 
    0.39213413f, 0.13639373f, 0.13290049f, 0.07853064f, 0.05749546f, 0.14007574f, 0.10027533f, -0.03476684f, 
    0.03605946f, 0.01847965f, -0.33688638f, -0.18818265f, -0.19188252f, -0.06562802f, -0.32916272f, 0.09438302f, 
    0.00081447f, 0.23110485f, -0.30127880f, 0.02886455f, 0.07075615f, -0.53422612f, 0.01531997f, 0.24455065f, 
    -0.11612783f, 0.05254018f, -0.05039245f, 0.23396440f, 0.07153925f, 0.30761710f, -0.09591346f, -0.29877844f, 
    -0.22836249f, 0.11960042f, -0.02088503f, -0.07052980f, -0.00164363f, -0.05429209f, 0.26467544f, 0.07270814f, 
    -0.07739652f, 0.34633026f, 0.15870620f, 0.11902411f, -0.00236668f, 0.30478278f, 0.12549506f, 0.14338654f, 
    0.05372198f, 0.20258784f, -0.05029466f, 0.21121030f, -0.30863604f, 0.07064201f, -0.19639909f, -0.41933468f, 
    -0.02022627f, 0.11072701f, -0.05864108f, -0.09339628f, -0.04688450f, -0.10049444f, 0.02294256f, -0.20670490f, 
    0.15569521f, -0.14324248f, 0.05433188f, 0.12600012f, -0.09063110f, 0.00588024f, 0.14778437f, 0.03786210f, 
    -0.36134955f, -0.57766831f, -0.56605470f, -0.01643941f, -0.02161718f, -0.13469350f, 0.15988599f, -0.14606963f, 
    0.12801249f, -0.58804679f, -0.21288826f, 0.26741257f, -0.08179815f, 0.01290878f, 0.07905699f, -0.05211258f, 
    0.03922538f, -0.06728138f, 0.18013181f, 0.08008061f, 0.52297455f, 0.05657528f, 0.13396366f, -0.00194198f, 
    0.06334475f, 0.12485828f, -0.07827418f, 0.00449008f, -0.00801029f, 0.10924634f, -0.01454516f, 0.11072598f, 
    -0.14798823f, 0.05121904f, -0.09791712f, 0.01891349f, 0.29374388f, 0.09756681f, -0.04773257f, -0.36072734f, 
    -0.06946019f, -0.02483599f, -0.06897263f, 0.01724494f, 0.04522516f, 0.07219797f, 0.03191735f, 0.01576207f, 
    -0.07164925f, -0.08435567f, -0.20308599f, 0.11867882f, -0.19078857f, 0.12760152f, -0.16536388f, 0.41451854f, 
    0.42216054f, 0.03859628f, 0.00200406f, 0.10323995f, 0.02568669f, 0.26753068f, -0.02290286f, 0.06001868f, 
    -0.00210275f, 0.07468750f, 0.08797541f, 0.06500261f, -0.03987247f, -0.06765544f, 0.07382691f, 0.02783410f, 
    -0.23578928f, 0.19308263f, -0.20756960f, -0.02350561f, 0.18675068f, -0.12902157f, 0.25776020f, 0.14137742f, 
    0.08499645f, 0.09233647f, -0.09876476f, -0.09449533f, -0.10143572f, 0.08871524f, -0.09407507f, 0.17814212f, 
    0.02545507f, 0.06238592f, -0.38152751f, -0.16340050f, 0.18097724f, 0.11194346f, 0.27933136f, -0.22531189f, 
    -0.02195278f, 0.01422441f, 0.21525057f, -0.27509159f, 0.14654349f, 0.54691797f, 0.01140561f, 0.12060361f, 
    -0.13848746f, -0.06470388f, -0.17646264f, 0.17332612f, -0.15034658f, -0.11843322f, -0.19149531f, 0.12952119f, 
    -0.07384136f, -0.23483148f, 0.13315697f, -0.17205606f, -0.15889381f, -0.23130332f, -0.51983905f, 0.33712500f, 
    -0.07640395f, -0.24728811f, -0.15026294f, -0.12486651f, -0.05863054f, -0.10360283f, -0.50608456f, -0.14487351f, 
    0.54814661f, -0.29785597f, -0.21357825f, -0.15631598f, -0.02156304f, -0.05083369f, -0.17870358f, 0.27133548f, 
    0.24882410f, -0.07476323f, -0.15029639f, -0.03390914f, 0.26626822f, 0.11611322f, -0.06901393f, -0.04580792f, 
    -0.01779526f, 0.08986454f, 0.30543125f, 0.07660477f, -0.18745106f, -0.05588206f, 0.15089193f, -0.07443482f, 
    0.22785510f, -0.79574674f, 0.07483178f, -0.02273398f, -0.11052076f, 0.18865652f, -0.02266493f, 0.22552490f, 
    0.13630709f, -0.17065249f, -0.15947010f, -0.33596736f, 0.27411485f, -0.09669900f, -0.04456398f, -0.17391416f, 
    0.02105141f, 0.11961900f, -0.12158155f, 0.07168883f, 0.02222420f, -0.22294021f, -0.00367427f, 0.12230061f, 
    -0.07483898f, -0.07427078f, -0.03408848f, -0.04197109f, -0.05351580f, 0.41292575f, 0.03681753f, -0.19385569f, 
    0.08405194f, 0.08009715f, 0.16605344f, 0.15259063f, 0.02712894f, 0.30973804f, 0.45066956f, -0.50511801f, 
    -0.20176195f, -0.06515982f, -0.33621106f, -0.05466311f, -0.16863497f, -0.00647115f, 0.06433042f, -0.10686947f, 
    0.26295200f, 0.03002190f, -0.30386850f, 0.12189081f, 0.11010866f, 0.14099793f, 0.03695944f, -0.24949099f, 
    -0.29895440f, 0.19643898f, 0.03263652f, -0.09224934f, 0.28871569f, 0.07201331f, 0.14286911f, -0.00653784f, 
    0.09553659f, 0.19297083f, 0.12668163f, -0.09434140f, 0.00399511f, -0.22675775f, 0.04610072f, 0.12738158f, 
    -0.08623769f, 0.12381848f, 0.05784893f, -0.53028113f, 0.05551021f, -0.07228007f, -0.01846154f, -0.16019772f, 
    -0.09678923f, -0.17010666f, 0.80366778f, -0.15932927f, -0.14289211f, 0.08005715f, 0.15985446f, -0.28342408f, 
    0.00439633f, 0.20355332f, -0.03394383f, 0.29449481f, -0.20672387f, 0.05085291f, -0.04241148f, -0.01986102f, 
    -0.10688439f, -0.04024527f, -0.04806214f, 0.11691696f, -0.17177090f, 0.52855200f, -0.16069952f, -0.13231169f, 
    0.02069432f, -0.14621733f, -0.04834296f, 0.20325930f, -0.18647458f, -0.10281742f, 0.13027683f, 0.65769941f, 
    0.10641798f, -0.07230829f, -0.09960534f, -0.01674456f, 0.18085492f, 0.18741971f, -0.11689965f, 0.09793997f, 
    0.36826611f, -0.19534314f, 0.06858242f, -0.23822385f, 0.03323736f, 0.30974981f, 0.09527251f, 0.04559167f, 
    0.44291127f, -0.09326759f, -0.29208836f, 0.01624231f, 0.14358416f, 0.28925511f, 0.22333847f, -0.00615439f, 
    -0.11495072f, 0.07545082f, 0.07945452f, -0.06440431f, -0.11595772f, 0.05391870f, 0.01197442f, 0.18444487f, 
    0.29031247f, 0.30326679f, -0.11354969f, -0.30661604f, -0.17111751f, 0.07286681f, -0.07755645f, -0.17647417f, 
    0.20471331f, -0.01420430f, -0.13236061f, -0.60560393f, -0.07637166f, -0.02031986f, 0.21389864f, 0.09267940f, 
    -0.16087113f, 0.12778968f, 0.17955895f, 0.27754220f, 0.00586356f, -0.14828418f, -0.25521749f, 0.10022605f, 
    -0.11412226f, 0.02707935f, 0.00678174f, -0.28044930f, -0.06186425f, -0.63623786f, -0.38438264f, 0.09742903f, 
    0.05087558f, -0.11287437f, -0.00769957f, -0.13138582f, -0.12021016f, -0.27159923f, -0.20360945f, 0.05221104f, 
    -0.31980881f, 0.12702093f, -0.14700127f, -0.07650915f, 0.07038155f, 0.23385118f, -0.01314716f, 0.12888011f, 
    0.01886403f, 0.09451581f, 0.19565076f, 0.24079734f, 0.04039000f, 0.18314596f, 0.14226423f, -0.06577247f, 
    0.18545754f, -0.22829469f, -0.18947196f, 0.04064506f, -0.12587826f, -0.03099662f, 0.01341941f, -0.11197524f, 
    -0.05690675f, 0.24260001f, 0.22591636f, 0.11258574f, -0.08709421f, -0.03765982f, -0.21543816f, 0.12435438f, 
    0.01732408f, -0.17871471f, -0.19012760f, -0.17637634f, -0.09986971f, -0.24082902f, -0.06759844f, 0.02770555f, 
    0.02623806f, 0.08175571f, 0.21327841f, -0.01163992f, 0.82930493f, 0.04171194f, 0.19879045f, -0.02990180f, 
    -0.08587910f, 0.10727908f, 0.07704601f, -0.50685805f, -0.06383653f, -0.43520850f, 0.17265214f, -0.07552511f, 
    -0.28585166f, -0.18733189f, -0.02129890f, -0.18893486f, 0.39631063f, 0.12616600f, -0.34880722f, 0.02962651f, 
    -0.04645325f, 0.28716007f, -0.03690981f, 0.06903006f, 0.12023722f, -0.61946553f, -0.51555616f, 0.04026945f, 
    0.16404794f, 0.03044158f, 0.10632030f, 0.06208745f, 0.03247681f, 0.02422256f, -0.30627567f, -0.45592734f, 
    0.16333102f, -0.01741469f, -0.25335556f, -0.20364280f, 0.02921271f, -0.17279267f, -0.07744569f, 0.26158893f, 
    -0.48010585f, 0.24106652f, 0.24450909f, -0.04302726f, 0.09968141f, 0.07654179f, -0.01456269f, -0.01870926f, 
    -0.06345333f, -0.30836004f, 0.04004033f, 0.09458560f, -0.12612104f, -0.08125616f, 0.23950392f, -0.01167941f, 
    0.13969184f, 0.01709964f, 0.25108600f, -0.17326637f, 0.01905166f, 0.00631516f, 0.06473122f, 0.02474665f, 
    0.00731250f, -0.42990759f, 0.07920597f, 0.25416687f, 0.18977635f, -0.09749609f, -0.12495986f, 0.08195683f, 
    0.18627249f, 0.14423087f, 0.03963303f, 0.12513000f, -0.08024331f, -0.39145795f, -0.18807170f, 0.04435053f, 
    0.13059731f, 0.13733467f, -0.03130110f, -0.13350342f, -0.47624108f, -0.48852840f, 0.30984256f, -0.11747694f, 
    0.20867455f, -0.46115783f, 0.04483770f, -0.00017046f, 0.19442977f, -0.10244926f, -0.53349090f, -0.49414739f, 
    -0.25407037f, -0.10673122f, 0.05769054f, 0.05984262f, 0.19735314f, 0.13067234f, -0.14267606f, 0.02798490f, 
    -0.01506598f, 0.16945058f, 0.07342169f, 0.08220616f, 0.06933831f, 0.29862455f, 0.29520231f, 0.27290124f, 
    -0.04803244f, -0.43669131f, 0.10612501f, -0.06587680f, 0.12425713f, 0.08695537f, 0.18314371f, 0.06486854f, 
    0.15238550f, -0.27822602f, 0.04422181f, 0.10995297f, 0.05424999f, 0.08766174f, -0.08830146f, -0.09459632f, 
    -0.21290468f, 0.09304469f, 0.27906203f, 0.48367193f, -0.03140562f, 0.03972486f, 0.14438337f, -0.01436728f, 
    -0.02454605f, -0.16021042f, 0.75761104f, 0.15936179f, 0.01573700f, 0.04092366f, 0.03168360f, 0.14235514f, 
    0.09868242f, 0.04602729f, 0.04459221f, 0.18846603f, 0.48736048f, 0.46449423f, -0.05646051f, -0.02588311f, 
    -0.28219232f, 0.01809829f, 0.03865764f, 0.09938834f, -0.21059166f, -0.47016463f, -0.18836868f, -0.04961298f, 
    0.09162986f, 0.18135557f, 0.09513492f, 0.08096240f, 0.00067542f, -0.21766810f, 0.23992914f, 0.24023056f, 
    0.00580669f, -0.22598018f, -0.15678710f, -0.11206559f, -0.14509274f, 0.03942715f, -0.38170344f, -0.38384056f, 
    -0.39927861f, -0.22792950f, 0.03106411f, -0.17607006f, -0.03218372f, -0.13328099f, 0.23611821f, -0.38184795f, 
    -0.73250586f, -0.52693051f, -0.03753115f, 0.08587550f, 0.20127262f, 0.30262682f, 0.14082906f, 0.08018353f, 
    -0.01575857f, -0.08066773f, -0.34369072f, 0.05190756f, -0.00426859f, 0.04779021f, 0.15664916f, 0.37535915f, 
    -0.01591038f, 0.33309418f, 0.12535146f, -0.10547873f, -0.10313727f, 0.30616862f, -0.07358617f, 0.10053041f, 
    -0.00486944f, 0.02206264f, 0.20903648f, 0.05782335f, 0.11113074f, -0.04017510f, 0.13145357f, 0.10641495f, 
    -0.11585753f, 0.10205575f, 0.48085672f, 0.05121465f, 0.10982603f, 0.16113076f, 0.11504517f, 0.13101716f, 
    -0.01298658f, -0.00603156f, -0.03577004f, -0.69870794f, 0.18333420f, 0.21856301f, -0.37469465f, 0.29307646f, 
    0.12195256f, 0.05231523f, -0.18854296f, -0.19256637f, 0.05792695f, 0.02013161f, 0.12588735f, 0.52579534f, 
    0.10439613f, 0.21677990f, 0.19167060f, 0.15533696f, -0.20210665f, 0.00951804f, -0.00266596f, -0.07440005f, 
    0.08185182f, 0.05274320f, 0.16790392f, 0.16771239f, 0.12737142f, 0.15115489f, 0.18682967f, 0.00592410f, 
    -0.08994544f, 0.17942433f, 0.02110834f, 0.01134621f, 0.09436073f, 0.06953210f, 0.09957225f, -0.22496422f, 
    0.24071449f, 0.39187673f, 0.06374023f, -0.18097979f, 0.01206060f, 0.16526671f, 0.27491739f, 0.06098139f, 
    0.06878012f, -0.11358438f, -0.07352166f, 0.32287467f, 0.09850132f, 0.06128202f, 0.17945619f, -0.05525548f, 
    0.05274570f, 0.12116119f, -0.01738158f, -0.01725209f, -0.18650058f, 0.05815355f, 0.07809734f, 0.16717134f, 
    0.21601003f, 0.09476102f, 0.12568516f, -0.12202839f, -0.20035242f, 0.23263510f, 0.10968638f, 0.32567468f, 
    -0.08129509f, 0.10641940f, -0.03275525f, -0.38132191f, 0.10013159f, -0.03611631f, 0.11731242f, 0.20259552f, 
    0.27105600f, 0.04128711f, 0.21458347f, 0.12865931f, 0.05593383f, 0.49784431f, -0.09842505f, -0.00722288f, 
    0.06962565f, 0.13544089f, 0.23854324f, -0.12944111f, -0.28562003f, -0.16242073f, 0.43407407f, 0.28372699f, 
    0.29536155f, 0.05212793f, -0.26758924f, 0.14366233f, -0.05585942f, -0.00216857f, 0.14347555f, 0.06831583f, 
    0.34031811f, 0.12953013f, 0.16685934f, 0.06147194f, 0.04867674f, -0.04815586f, 0.10438777f, 0.10057862f, 
    -0.19322622f, -0.35941964f, -0.03734134f, -0.02366168f, 0.06390543f, -0.01794087f, -0.13701023f, -0.25392631f, 
    -0.61173326f, 0.10773069f, 0.34849009f, 0.00014623f, 0.45070621f, 0.14904243f, 0.13905582f, 0.23310769f, 
    0.34740683f, 0.14669254f, 0.06828836f, 0.27914831f, -0.22711416f, 0.03414135f, 0.00315079f, 0.18275064f, 
    0.09628103f, 0.22130366f, -0.32472384f, -0.05378811f, 0.10500413f, 0.29425386f, 0.07314094f, 0.09659611f, 
    0.12618525f, 0.29312822f, 0.28141162f, 0.32788613f, 0.01035622f, -0.67366129f, 0.19204602f, 0.07214295f, 
    -0.05670118f, 0.10824052f, -0.13001448f, 0.19790950f, 0.21734120f, -0.12907301f, -0.11542848f, -0.09219721f, 
    0.21907054f, -0.05104339f, -0.15566537f, -0.10809250f, -0.15825921f, -0.03487290f, 0.49380121f, 0.08395022f, 
    0.02627878f, -0.11431239f, 0.07282332f, -0.01708296f, -0.12810431f, 0.10580246f, -0.06541641f, 0.19092993f, 
    -0.07084642f, 0.23721135f, 0.28454545f, 0.27957362f, 0.15856549f, 0.22005504f, -0.00982248f, 0.24311025f, 
    -0.22830218f, -0.10516129f, 0.32055056f, 0.12718345f, 0.10520532f, 0.13391028f, -0.08112826f, 0.13398789f, 
    -0.10458411f, 0.32296976f, 0.03351906f, -0.03637902f, 0.04606654f, -0.07173980f, -0.08387545f, 0.12065063f, 
    0.14177121f, 0.03727668f, 0.15657713f, 0.55836529f, 0.13877216f, 0.05215039f, -0.14777280f, -0.09504677f, 
    0.12752916f, -0.21833353f, -0.24515830f, 0.11098292f, 0.05191589f, -0.02949292f, -0.15821005f, 0.30778143f, 
    0.20952393f, 0.29418570f, 0.12219175f, 0.11606648f, 0.26709983f, -0.22951353f, -0.15726915f, 0.30059063f, 
    0.05701166f, -0.03724402f, 0.03817102f, 0.07932413f, 0.26416764f, 0.18415765f, 0.38393295f, -0.28191274f, 
    -0.15924744f, 0.31558576f, -0.19333901f, 0.01289349f, 0.50442469f, 0.39005840f, -0.32507893f, -0.79616094f, 
    0.01289546f, 0.02895601f, 0.24689806f, 0.08338344f, 0.07572062f, -0.12860617f, -0.22919896f, -0.15776424f, 
    0.15297751f, 0.23982877f, 0.24180782f, -0.00357994f, 0.08993804f, 0.18367609f, 0.11570115f, 0.08423857f, 
    -0.27593282f, 0.27987334f, 0.06131412f, -0.23835610f, -0.10892563f, -0.05503031f, 0.03378137f, -0.19813544f, 
    -0.00792155f, -0.05791011f, -0.61010051f, -0.57722062f, 0.24603651f, -0.11507412f, -0.05220985f, 0.10011827f, 
    0.26374945f, -0.13203579f, -0.01291922f, -0.24663997f, 0.09979385f, -0.07658818f, 0.05272447f, 0.14817992f, 
    0.05076520f, 0.10388356f, 0.19373135f, -0.10691823f, 0.05775816f, 0.04976748f, -0.26712257f, 0.07039691f, 
    -0.16105896f, 0.05959839f, -0.05910976f, 0.17179170f, 0.38912988f, -0.14279467f, -0.20537582f, -0.20078801f, 
    0.02907763f, 0.07288355f, 0.06543462f, -0.22663897f, 0.12573673f, -0.25501406f, -0.57596248f, -0.00809776f, 
    0.04921715f, 0.06252435f, 0.07645284f, 0.01687058f, -0.20622841f, 0.26860315f, 0.13010874f, 0.29076073f, 
    0.07010961f, 0.05335825f, 0.07442161f, 0.00375681f, 0.15528767f, 0.06048299f, 0.30314815f, 0.01718388f, 
    0.31442863f, -0.15995207f, 0.13160186f, 0.15563004f, -0.13033755f, 0.19438355f, 0.12906945f, 0.18545222f, 
    0.06033049f, 0.37159416f, 0.11730815f, 0.06478363f, 0.19798005f, 0.06140611f, 0.08480738f, 0.18145737f, 
    0.15069886f, 0.16379291f, -0.29947236f, 0.10722967f, 0.09315617f, -0.22733602f, -0.14759828f, 0.11918116f, 
    -0.01698782f, 0.08190284f, 0.13763478f, -0.21420741f, 0.11027575f, 0.02933614f, 0.05861875f, 0.09784745f, 
    -0.00269734f, 0.01270386f, -0.08975203f, -0.34441996f, -0.15667106f, -0.10059974f, -0.04053693f, 0.33942866f, 
    -0.28933617f, -0.21879333f, -0.02386347f, 0.04560897f, 0.32420397f, 0.01686635f, -0.18128137f, -0.03973337f, 
    -0.03591765f, -0.06267841f, -0.00899520f, 0.22189680f, 0.03272486f, -0.25894055f, -0.43089065f, -0.04416456f, 
    -0.08926828f, -0.31625110f, 0.03355556f, 0.36902380f, 0.25829700f, 0.14485575f, -0.89364189f, -0.38012403f, 
    -0.30765989f, 0.00873732f, 0.10111108f, -0.49013957f, 0.41281670f, -0.11172812f, 0.04067042f, -0.00862427f, 
    -0.25129002f, -0.20167269f, -0.12577228f, -0.00164907f, 0.13104600f, 0.18212700f, -0.04805745f, 0.20829014f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.02150585f, 0.06324416f, 0.08057902f, -0.17193452f, 0.18550441f, -0.11493808f, 0.27604339f, 0.17316532f, 
    0.21056405f, 0.21436884f, -0.28627294f, 0.22298807f, -0.01165647f, -0.08063859f, 0.34875986f, 0.46366504f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.06150743f, -0.47539416f, -0.23683470f, -0.12288442f, 0.57413179f, -0.03194791f, 0.35299024f, 0.30761477f, 
    -0.74307793f, 0.11027435f, -0.53419417f, -0.25231540f, -0.02375363f, -0.31866702f, 0.46493322f, 0.58010787f, 
    -0.03905014f, -0.38563281f, -0.38226870f, -0.16546614f, -0.06944793f, -0.09079826f, -0.09541926f, -0.17497453f, 
    0.68149191f, 0.39994004f, 0.12396608f, -0.53826576f, -0.37944624f, 0.07780598f, 0.35256019f, 0.53214049f, 
    0.09536871f, -0.77927715f, 0.19334565f, 0.02183973f, 0.31586677f, -0.13455963f, 0.18711185f, 0.09359393f, 
    -0.11563134f, -0.02594182f, 0.46067184f, 1.29126501f, -0.15289395f, 0.04761276f, -0.16200817f, 0.21768093f, 
    -0.16553310f, 0.53265345f, 0.10344549f, -0.20315650f, 0.36679631f, -0.06128782f, -0.01351915f, 0.32941750f, 
    0.35425264f, 0.15370318f, -0.00629073f, -1.16852295f, 0.51292050f, -0.01203083f, 0.14869568f, -0.47032678f, 
    0.11759856f, 0.23206396f, 0.15911736f, -1.01815641f, -0.58646572f, -0.24065953f, 0.60824329f, -0.59155005f, 
    0.35569888f, 0.82304156f, -0.37597549f, 0.58013856f, -0.24511445f, 0.23961169f, -0.17137848f, 0.22483084f, 
    0.15040497f, 0.05111561f, -0.42791033f, 0.13312174f, 0.17972261f, 0.12174260f, 0.21689352f, 0.50847751f, 
    -0.26841787f, -0.09805002f, 0.28855425f, -0.09346614f, -0.19530486f, 0.19642310f, 0.12392799f, -0.37563795f, 
    -0.05311378f, 1.22164154f, 0.21388860f, -0.41743970f, -0.50165927f, 0.01417670f, 0.21074899f, 0.02913153f, 
    -0.40044978f, -0.49003679f, -0.61368012f, 0.48596707f, 0.27450126f, -0.31971639f, 0.45214528f, 0.16232722f, 
    -0.18508157f, 0.00952794f, -0.07969288f, -0.07202026f, -0.09916312f, -0.00850288f, -0.00345905f, -0.07135987f, 
    0.19099797f, -0.14723833f, -0.00910444f, 0.19826870f, -0.08093847f, 0.19175117f, -0.28130832f, -0.12688376f, 
    0.11231101f, -0.10322725f, -0.06804804f, -0.05664095f, -0.05357014f, 0.05800907f, -0.22543134f, -0.09020662f, 
    0.23042603f, -0.11733940f, -0.07467370f, -0.23573416f, -0.13036859f, -0.20919517f, 0.10417981f, 0.16535810f, 
    -0.21188357f, 0.23108630f, -0.07080314f, 0.09630455f, 0.31318599f, -0.20584078f, 0.36738205f, 0.52553624f, 
    -0.51273185f, -0.24186586f, 0.36565769f, 0.04336723f, 0.49182934f, -0.10109460f, -0.17275861f, -0.01542174f, 
    -0.23405309f, -0.26336533f, -0.27072519f, -0.98935294f, -0.97256005f, 0.14970937f, -0.36559710f, -0.49311575f, 
    0.31662062f, 0.32958788f, 0.31796339f, -0.27471367f, 0.44231603f, 0.51863360f, 0.04187374f, -0.26251677f, 
    0.18431836f, -0.11216844f, 0.06857993f, -0.20438646f, -0.36008620f, -0.11424306f, 0.20779403f, -0.21489462f, 
    -0.01028091f, 0.60346884f, -0.38850710f, 0.86692148f, -0.54801083f, 0.39148983f, 0.08842881f, 0.59253114f, 
    -0.13322766f, 0.34239352f, 0.39371431f, -0.19308592f, 0.76677620f, -0.03941054f, 0.18867818f, 0.12327792f, 
    -0.00469390f, 0.57898825f, -0.09725489f, -0.51692754f, 0.04995814f, -0.06391854f, -0.03424236f, -0.38665083f, 
    -0.07769307f, -0.46804449f, -0.50151271f, -0.03340811f, 0.14136666f, -0.22392596f, 0.09723559f, -0.36112633f, 
    -0.28930861f, -0.11268534f, 0.20871009f, -0.40005723f, 0.45114669f, -0.04876592f, 0.36054718f, 0.02831483f, 
    0.19611099f, 0.02509728f, -0.24246114f, -0.22502181f, -0.01799387f, -0.20608276f, -0.23340341f, 0.16282043f, 
    0.13688010f, -0.19723707f, -0.06173319f, 0.11226049f, -0.09621865f, 0.21765205f, -0.18677685f, -0.15181318f, 
    -0.16314055f, -0.71958607f, 0.28168476f, -0.16441089f, 0.37549731f, 0.08934624f, 0.12092902f, -0.52386415f, 
    -0.64720368f, -0.08330110f, 0.31141618f, -0.04419017f, 0.09856187f, -0.22862314f, 0.29593450f, 0.20139581f, 
    -0.06575486f, -0.74591619f, 0.36015043f, -0.09749508f, 0.29662809f, -0.13707885f, -0.08964921f, -0.13044244f, 
    -0.08425011f, 0.29360017f, 0.18916269f, 0.66169870f, -0.18158348f, -0.04366158f, 0.17552814f, 0.66972452f, 
    0.20881771f, 0.43034419f, 0.26367557f, -0.30848271f, 0.72848970f, 0.04604828f, 0.25614542f, 0.44582486f, 
    -0.71020579f, 0.07661806f, 0.30688900f, 0.20955606f, 0.27236462f, -0.35728583f, 0.12105059f, -0.26400846f, 
    -0.17693044f, -0.41330472f, -0.36912313f, -0.27678707f, -0.43103391f, 0.13539217f, -0.40716821f, 0.85480529f, 
    0.36986560f, -0.27648678f, -0.36948958f, 0.71524066f, 0.44647190f, 0.46600166f, -0.00820185f, -0.03500706f, 
    0.12960713f, 0.65978169f, 0.32441103f, -0.25613070f, 0.44967142f, 0.01032060f, 0.26734784f, 0.13337195f, 
    -0.05006379f, 0.09421474f, -0.55913270f, 0.03667795f, -0.18483697f, 0.02538041f, 0.17484653f, -0.07291344f, 
    -0.02872479f, -0.02360832f, 0.17723604f, 0.06822433f, -0.42255527f, -0.00695475f, -0.35278091f, -0.36118579f, 
    0.05649137f, 0.11196883f, -0.34174815f, -0.21657184f, -0.50411230f, 0.07165132f, -0.06144559f, -0.16234756f, 
    -0.14162202f, -0.15878750f, 0.38579234f, 0.15228033f, -0.03073300f, 0.18392296f, -0.35219389f, 0.04847159f, 
    0.26755592f, -0.62669361f, 0.24082440f, -0.52322817f, 0.54118937f, -0.28475523f, 0.27956849f, -0.11404875f, 
    0.19127932f, 0.04992732f, -0.01031362f, 0.05879436f, -0.02692327f, -0.10042856f, 0.10275265f, 0.42399013f, 
    0.31255022f, 0.24204919f, 0.54440957f, -0.43103725f, 0.26019284f, -0.15213796f, -0.01788978f, -0.24903683f, 
    0.20689970f, -0.09813246f, -0.18200374f, -0.19015861f, 0.07348690f, -0.13012742f, -0.28659299f, 0.05444130f, 
    -0.24910463f, 0.01769305f, -0.03810139f, -0.09215708f, -0.13771193f, -0.09904033f, -0.05980958f, 0.21138902f, 
    -0.16650203f, 0.76929259f, 0.02932917f, -0.18049279f, -0.43811792f, 0.22002982f, 0.52398485f, -0.20706455f, 
    -0.07478664f, -0.08738706f, -0.62129676f, 0.08807673f, -0.11049020f, -0.35368082f, 0.43954179f, 0.11660594f, 
    -0.01560996f, 0.08991631f, 0.33042917f, 0.14515641f, 0.09079131f, 0.06613677f, 0.06649416f, 0.05544189f, 
    0.36826903f, -0.30582303f, 0.22786468f, -0.43768579f, 0.38692158f, 0.13901128f, -0.37183663f, -0.02924671f, 
    -0.19866800f, 0.61296356f, -0.15300713f, -0.00938528f, -0.12899299f, 0.02271983f, 0.05739459f, -0.59748280f, 
    0.09146088f, -0.48381054f, -0.22624721f, -0.67955291f, 0.46723041f, -0.33660281f, 0.51161408f, 0.19979319f, 
    0.01064181f, -0.27323154f, 0.16545592f, -0.14011414f, 0.13235657f, -0.19505490f, -0.23100442f, 0.53326225f, 
    0.48093000f, -0.08261283f, -0.65133792f, -1.08918965f, 0.77847761f, 0.10758417f, -0.03385366f, 0.05309551f, 
    -0.08032971f, -0.20803143f, -0.44938594f, -0.33205852f, 0.13624279f, 0.15774199f, -0.16082165f, 0.46041533f, 
    0.30346802f, 0.85581261f, 0.50894082f, 0.43988669f, 0.00837061f, 0.41696844f, -0.38132429f, 0.14984432f, 
    0.18448141f, 0.11674128f, 0.13413437f, -0.14700596f, -0.44327462f, -0.06234082f, 0.35853964f, -0.50050932f, 
    -0.03601981f, 0.56941605f, 0.87317717f, -0.68927634f, 0.29023439f, -0.28039911f, 0.21704823f, -0.13384928f, 
    0.08450657f, -0.31884089f, 0.02761775f, -0.34936664f, 0.44525775f, -0.03220254f, -0.05331492f, 0.26616657f, 
    0.48040631f, 0.09592834f, 0.09194966f, -0.46754131f, -0.41157112f, 0.23246615f, -0.12340636f, 0.01839768f, 
    -0.08606149f, -0.18332814f, -0.39713132f, 0.19281253f, -0.12802023f, 0.06442418f, 0.27201599f, -0.27434275f, 
    0.04233843f, -0.09312907f, -0.04109369f, -0.50346899f, 0.20128837f, 0.24526986f, 0.12676927f, -0.18397376f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.03489995f, 0.49753496f, 0.27576053f, 0.13801062f, 0.47344458f, -0.39526868f, 0.57699275f, -0.08754407f, 
    -0.10515250f, -0.07882916f, 0.32886159f, 0.20588484f, -0.11012442f, 0.04671574f, -0.10708162f, -0.21821149f, 
    0.41691026f, -0.31747606f, 0.45934945f, 0.05830865f, -0.32012877f, -0.22384736f, -0.20677735f, 0.05956249f, 
    0.24398257f, -0.19917087f, 0.36679071f, 0.56910104f, 0.10030955f, -0.05779812f, 0.37972751f, -0.03840461f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.61301154f, -1.18174362f, -0.26455933f, 0.03522474f, -1.38783753f, 0.10327800f, 0.11239756f, -0.10982400f, 
    0.10332728f, 0.58344966f, 0.37954208f, -0.82402724f, -0.35210818f, 0.39165708f, 0.13315411f, 0.08803072f, 
    -0.55701125f, 0.00355843f, 0.27869987f, -0.37705821f, 0.05449350f, 0.53184199f, 0.09932968f, 0.15421003f, 
    -0.59754497f, 0.30208528f, 0.32845211f, 0.22436696f, -0.43851259f, -0.05784654f, -0.56717235f, 0.24864554f, 
    0.17333591f, -0.03088171f, -0.11118051f, 0.18119338f, -0.58155251f, -0.61590648f, 0.43722051f, -0.08665884f, 
    0.02815653f, -0.07496378f, -0.14840221f, -0.22288419f, 0.13921970f, -0.07162178f, -0.14667641f, 0.25831664f, 
    0.10848428f, 0.08950540f, -0.13418806f, 0.16377647f, 0.16150410f, 0.36667764f, -0.00887810f, 0.12612993f, 
    0.21726982f, 0.08969513f, 0.34942609f, 0.43226284f, -0.72746438f, -0.04272458f, 0.45975333f, -0.25790736f, 
    -0.36056045f, -0.00424773f, 0.21208674f, -0.78362751f, 0.75048810f, -0.00204345f, 0.57658935f, -0.11544909f, 
    0.06549301f, -0.31149921f, 0.33200273f, 0.35654804f, -0.57595354f, -0.41552958f, -0.01045703f, -0.39107758f, 
    0.02905937f, -0.35494885f, 0.54090744f, -0.10644647f, -0.23762709f, -0.05951736f, 0.12522365f, -0.12710489f, 
    0.16746786f, -0.16509439f, -0.80361158f, -0.33554044f, 0.05053393f, -0.59063536f, -0.59755903f, 0.02042251f, 
    -0.18205747f, 0.77735007f, -0.57199013f, -0.02588475f, -0.33326098f, 0.19919540f, -0.51139450f, 0.12083891f, 
    -0.08741583f, -0.29008809f, 0.35027146f, -0.06843580f, -0.54671705f, 0.22527865f, -0.14422958f, -0.06739406f, 
    0.12072241f, -0.79905915f, 0.16780372f, -0.75243431f, -0.26162091f, 0.00592829f, 0.20806706f, -0.03534339f, 
    -0.84335464f, -0.45182961f, 0.01908522f, 0.01830054f, 0.31228036f, 0.17464608f, -1.54976523f, 0.26096213f, 
    -1.25564742f, -0.18843670f, -0.29854858f, 0.22932310f, 0.00558934f, -0.08949294f, -0.01232308f, -0.14038436f, 
    -0.05928712f, 0.06993110f, 0.27409324f, -0.28864679f, 0.30890664f, -0.03599242f, 0.12833025f, -0.82552058f, 
    -0.29065222f, -0.20639355f, 0.21151945f, -0.08579517f, -0.29863054f, -0.01671774f, 0.26322487f, 0.03329108f, 
    -0.43469796f, 0.31786758f, -0.01886141f, 0.46086562f, 0.11159524f, 0.20825496f, -0.33914605f, -0.01120902f, 
    0.33769822f, -0.00353403f, -0.08505294f, 0.00756172f, -0.00835879f, 0.22492154f, 0.18038778f, -0.11153490f, 
    -0.14780161f, 0.17744721f, -0.10864420f, -0.09947868f, 0.10491122f, 0.09901631f, 0.17495218f, -0.12144091f, 
    -0.21952792f, -0.21654686f, -0.00741478f, 0.12692273f, -0.16247639f, -0.48594677f, -0.08481579f, 0.06096443f, 
    0.25855634f, 0.14979811f, 0.25792226f, 0.19239338f, -0.29313385f, 0.05851616f, -0.18982589f, 0.27855775f, 
    0.19923697f, -0.09010276f, 0.29324701f, -0.77908230f, 0.25102353f, -0.37294361f, -0.41767812f, -0.18979879f, 
    -0.01983666f, 0.04880553f, -1.45100772f, 0.50061852f, 0.07291664f, -1.47632468f, -0.16727626f, -0.20263176f, 
    0.38904485f, -0.34162670f, 0.36208463f, 0.17201205f, -0.20315874f, -0.34274575f, -0.52699435f, -0.04963110f, 
    -0.50648147f, 0.04973046f, -1.03583336f, -0.81790495f, 0.34113848f, -1.44371700f, -0.21676470f, -0.48026782f, 
    0.10161708f, -0.60494018f, 0.37843028f, -0.14991118f, -0.88563955f, 0.15563935f, -1.56535029f, 0.08031505f, 
    0.13237338f, 0.58845383f, -0.26776806f, -0.41125613f, 0.33359697f, 0.08944756f, -0.11728033f, 0.42736238f, 
    0.14376915f, 0.65737051f, -1.03996503f, -0.01401284f, -0.08013799f, -0.10108504f, 0.09908497f, -0.06089990f, 
    0.00355478f, 0.01781829f, -0.59436238f, -0.56380022f, 0.07006502f, 0.09055338f, -0.29870793f, -0.25512353f, 
    0.58753842f, 0.41019687f, -0.06522992f, -0.48858386f, -0.35770461f, -0.10682595f, 0.39995137f, 0.09717265f, 
    -0.14384030f, -0.38997215f, -0.68324184f, 0.28188244f, -0.33724555f, 0.25287977f, -0.16130567f, 0.35925502f, 
    0.30423522f, 0.06073218f, -0.56321591f, 0.19767405f, -0.01094585f, -0.27633074f, -0.44366944f, -0.10688017f, 
    0.57629657f, -0.35466248f, 0.20508987f, -0.74565285f, -0.63736725f, -0.16114329f, 0.01526596f, -0.04320800f, 
    0.17613190f, -0.06321990f, -0.15484133f, 0.40839809f, -0.22075276f, 0.31278402f, -0.35238102f, 0.02912259f, 
    0.09706394f, 0.13976113f, 0.08486731f, -0.02595385f, 0.26727018f, -0.09713322f, 0.06548391f, -0.87785763f, 
    -0.09964508f, 0.21110478f, 0.48918086f, 0.27550828f, 0.00008869f, -0.31322423f, -0.04571148f, -0.13461213f, 
    -0.13826407f, -0.25810537f, -0.85358840f, 0.42613640f, 0.37286669f, -1.01231623f, 0.46003997f, -0.19359304f, 
    -0.19529131f, 0.10455006f, -0.68441278f, 0.28461415f, 0.59944576f, 0.22261161f, 0.23348770f, 0.10170696f, 
    0.11040525f, -0.11459570f, -0.24019691f, 0.02939487f, 0.25863203f, -0.15546067f, -0.03040400f, -0.24910851f, 
    -0.31628951f, 0.13039230f, -1.15296113f, 0.26796365f, 0.02623704f, -0.31273666f, 0.03191293f, -0.06830234f, 
    0.52080613f, -0.18463895f, 0.16756363f, -1.40581608f, -0.09379587f, 0.61181265f, -0.19715737f, 0.11845728f, 
    -0.15422988f, 0.11276749f, -0.03630435f, -0.15853618f, 0.74201161f, -0.42610094f, -1.01011741f, -0.16162694f, 
    0.11292456f, -0.74772990f, 0.43391010f, 0.30693713f, 0.33789673f, -0.37203434f, 0.10057574f, 0.51223540f, 
    0.18977383f, -0.24540170f, -0.78856605f, 0.08856533f, -0.20082042f, -0.50305426f, -0.23874217f, -0.04704043f, 
    -0.38709152f, -0.23111199f, -1.03700376f, -0.02263821f, -0.09742780f, 0.38514459f, -0.10287993f, -0.01539163f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.58660704f, 0.04775000f, 0.19199222f, -0.10419733f, 0.06440449f, 0.13904674f, -0.04864287f, -0.04628094f, 
    -0.15349209f, 0.02662078f, -0.12126386f, -0.14639716f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
