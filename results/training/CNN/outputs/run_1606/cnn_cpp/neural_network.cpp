#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.38433373f, -0.30704364f, 0.75025046f, 0.00058888f, -0.10844702f, -0.55245399f, -0.40060562f, 0.06034457f, 
    0.06323820f, 0.13645147f, -0.02720796f, -0.16628137f, -0.03268745f, 0.39360076f, -0.20532785f, -0.21306494f, 
    -0.21585697f, 0.07347789f, -0.30752346f, -0.47513098f, -0.15115315f, -0.45652258f, -0.36197391f, -0.15981796f, 
    -0.27382448f, -0.85953677f, 0.03826907f, -0.62177944f, -0.71539527f, -0.78031856f, 0.04997080f, 0.07183703f, 
    0.52866173f, -0.08297893f, -0.15524016f, -0.24513280f, -0.12737052f, -0.30462930f, -0.17523527f, 0.15691628f, 
    -0.13878447f, -0.01406506f, 0.06005345f, -0.20845142f, 0.04577260f, 0.12792103f, 0.19641736f, -0.01724190f, 
    0.17506096f, -0.14075686f, -0.72733593f, 0.51566344f, -0.05798960f, 0.39244381f, -0.30928177f, -0.04224959f, 
    -0.40166578f, 0.00995209f, 0.42594165f, 0.34542680f, -0.23817666f, -0.34320042f, -0.32370338f, -0.22894025f, 
    0.12203986f, 0.01901219f, 0.27246210f, -0.01449001f, 0.14741272f, 0.19380307f, -0.27984130f, -0.09172220f, 
    -0.23328860f, -0.28764355f, -0.11916132f, -0.69601190f, 0.17128262f, 0.03820293f, 0.30764002f, 0.25511432f, 
    0.14805569f, 0.09291580f, 0.07741607f, -0.04335678f, -0.22906537f, -0.01181506f, 0.27057633f, 0.19244559f, 
    -0.28880534f, 0.05236810f, -0.21570531f, -0.13019282f, -0.29273170f, -0.02432455f, 0.35572663f, -0.08842416f, 
    0.40830642f, -0.11121739f, -0.11991158f, 0.03580952f, 0.17528170f, 0.39301386f, 0.51967561f, 0.03211154f, 
    -0.43483809f, -0.30188939f, -0.56880385f, -0.36865613f, 0.23324277f, 0.08739804f, 0.09171530f, -0.39276963f, 
    -0.34627804f, -0.12437421f, 0.26848343f, 0.12974790f, 0.38446110f, 0.15130492f, 0.22346827f, -0.28867862f, 
    -0.18392639f, 0.05505635f, -0.10045684f, -0.13190253f, -0.24397033f, -0.31861666f, -0.42488173f, -0.18538137f, 
    0.21852633f, 0.09367098f, -0.36237130f, -0.04574993f, 0.14891842f, 0.08254045f, 0.35712516f, 0.09774127f, 
    -0.05523655f, -0.27185431f, 0.21313244f, 0.38849452f, 0.06675382f, 0.01130023f, -0.04354899f, 0.17574017f, 
    -0.32764697f, 0.05783977f, 0.37727147f, -0.08951005f, -0.05493012f, -0.09554896f, 0.21173993f, -1.03886533f, 
    -0.74896151f, -0.51657259f, 0.17661811f, 0.24679042f, -0.32115921f, 0.13906488f, 0.62135816f, 0.54374355f, 
    -0.08531726f, 0.03362343f, 0.09343042f, -0.09903306f, 0.32000619f, -0.24094902f, 0.00767941f, -0.21531704f, 
    -0.01578606f, -0.54235286f, 0.02608537f, 0.00939082f, 0.10434000f, 0.09330029f, 0.48584473f, -0.06992815f, 
    0.10034537f, 0.00387563f, -0.09561729f, -0.27605176f, 0.46303672f, -0.46628499f, -0.13054559f, 0.49812916f, 
    -0.76405066f, 0.30253267f, 0.14752422f, -0.07378469f, -0.22506568f, -0.27212852f, -0.06523276f, 0.24474609f, 
    -0.17077185f, -0.43626851f, -0.15715547f, 0.17547888f, -0.12284240f, -0.17684583f, 0.10563981f, 0.35897145f, 
    -0.39405528f, -0.56879157f, -0.37693569f, 0.08502266f, -0.62181699f, 0.15180664f, 0.42184660f, 0.07097644f, 
    -0.13416326f, -0.32300389f, -0.08647183f, 0.01456670f, 0.01117950f, 0.34458262f, -0.24092357f, -0.00392853f, 
    0.12805413f, 0.10121122f, -0.09616342f, 0.13662136f, -0.23308797f, -0.49561813f, -0.21179181f, 0.17348766f, 
    0.12117655f, 0.96645582f, -0.31899247f, -0.61554760f, -0.36362100f, 0.00471823f, -0.74742293f, -0.52306575f, 
    -0.13447343f, 0.70079476f, 0.30830881f, 0.32588571f, 0.02789519f, 0.29360422f, 0.00462553f, -0.11379404f, 
    0.10786515f, -0.17407669f, -0.01362646f, 0.16672382f, -0.10167820f, 0.06453073f, -0.15509970f, -0.08547486f, 
    -0.15273333f, 0.19991617f, 0.57507241f, -0.09830048f, -0.33594272f, -0.50737929f, -0.43053260f, 0.43393371f, 
    0.49261150f, 0.01652584f, -0.22690354f, 0.23047875f, -0.25589478f, 0.04538246f, -0.18789622f, -0.23034604f, 
    0.16718571f, -0.16428874f, -0.08160076f, 0.04376244f, -0.48795775f, -0.53006858f, -0.21842311f, -0.32756984f, 
    -0.33182794f, -0.39337760f, -0.39697823f, -0.26472557f, -0.47030801f, -0.55885339f, -0.34499809f, -0.16034655f, 
    -0.39284012f, -0.59873754f, -0.22591059f, 0.02004357f, -0.34408882f, 0.01072265f, -0.19097355f, -0.06704001f, 
    0.24048935f, 0.29234809f, -0.13235664f, 0.03682382f, 0.00074791f, -0.30768529f, -0.08421187f, -0.12334169f, 
    0.21203512f, -0.44020128f, -0.43600762f, -0.17483437f, -0.33752042f, -0.28586102f, -0.21996224f, -0.34894603f, 
    -0.58319461f, -0.61529768f, -0.40921679f, -0.53293282f, -0.63106441f, -0.73107177f, 0.28463528f, -0.16874407f, 
    0.13727792f, -0.19014487f, 0.02624566f, -0.07260600f, -0.07460277f, 0.08762582f, 0.11637654f, 0.03139161f, 
    -0.20665666f, -0.29102001f, 0.00970406f, -0.05926111f, 0.26703212f, -1.18148839f, -0.13100673f, -0.52619112f, 
    -0.87617141f, -0.55618340f, 0.32274777f, 0.18756658f, -0.36769903f, -0.22550486f, 0.17261700f, -0.28703254f, 
    -0.35163468f, -0.39448985f, -0.41016319f, -0.21352904f, 0.29818517f, 0.14713965f, -0.19625393f, 0.05105521f, 
    -0.08353557f, 0.00342904f, -0.08246398f, -0.12086640f, 0.03564458f, -0.12055012f, 0.08125251f, -0.52198517f, 
    -0.39406675f, -0.63970411f, -0.75702232f, 0.03632512f, 0.25993672f, 0.17594407f, 0.33175012f, 0.03395491f, 
    0.11885758f, 0.28140330f, -0.14084189f, -0.05223124f, -0.18523446f, -0.23706138f, -0.30256265f, -0.27118766f, 
    0.11061285f, -0.08345456f, 0.08649088f, -0.24149622f, -0.19998991f, -0.15864712f, -0.45460355f, -0.06947998f, 
    -0.52281576f, -0.07863746f, -0.03372732f, -0.23085612f, 0.53100610f, -0.01340265f, 0.10889570f, 0.06389181f, 
    0.33096018f, 0.12645616f, 0.08445582f, 0.15027966f, -0.41759872f, -0.27586222f, -0.45480639f, -0.12633507f, 
    0.37661552f, -0.15860906f, 0.30765718f, -0.28306347f, 0.10347851f, 0.21448691f, 0.09953023f, 0.12018032f, 
    -0.36285552f, -0.22784802f, -0.11825861f, 0.02193245f, 0.12931705f, -0.03051481f, 0.37388447f, -0.01066605f, 
    0.12174859f, 0.07610742f, 0.10786676f, 0.05837363f, 0.03075139f, -0.19456929f, -0.38749650f, -0.01167822f, 
    -0.32739672f, -0.10228398f, 0.21740784f, -0.10114638f, 0.26026109f, -0.28324500f, 0.25638106f, 0.02145687f, 
    0.25128573f, 0.43799171f, 0.11568165f, -0.30613223f, 0.03234219f, -0.47878721f, -0.37717313f, -0.26380983f, 
    -0.00260852f, 0.02508991f, -0.09871880f, 0.02840512f, 0.21573779f, 0.36415204f, 0.22289325f, 0.21678570f, 
    0.20296761f, 0.02049422f, 0.02549272f, -0.01771170f, -0.21122846f, -0.21408165f, -0.22660281f, -0.02152248f, 
    -0.05536849f, -0.15569021f, -0.53223926f, -0.19390471f, 0.12215799f, 0.24456480f, -0.01809865f, -0.22778764f, 
    -0.23090570f, -0.43342856f, 0.39720696f, 0.44297630f, 0.14851645f, 0.02833574f, -0.01182972f, 0.14263546f, 
    -0.11193718f, -0.22483139f, -0.16674018f, 0.21313271f, -0.34260923f, -0.28624529f, 0.12184748f, 0.33345404f, 
    0.08674787f, 0.21434188f, 0.25881582f, 0.22170867f, -0.05714792f, -0.55120414f, -0.35543031f, -0.24168438f, 
    -0.17737716f, -0.04704388f, 0.14127605f, -0.19617531f, 0.38894337f, 0.40560403f, 0.44068339f, 0.03563584f, 
    -0.41086116f, -0.35297737f, -0.37516457f, -0.14988714f, 0.38974336f, -0.39571860f, -0.21101885f, -0.45589474f, 
    -0.33710274f, 0.36952803f, -0.27314150f, -0.21874021f, 0.23992439f, 0.31613928f, 0.36181957f, -0.32294783f, 
    -0.42027876f, -0.18354945f, 0.01155446f, -0.08981874f, 0.22810099f, -0.36215308f, -0.15143099f, 0.02082121f, 
    0.18824747f, 0.52664649f, -0.24825756f, 0.17361000f, 0.02357822f, -0.18718871f, 0.06659820f, -0.30839819f, 
    0.22247475f, -0.10584860f, -0.38653436f, 0.09986058f, 0.16612200f, -0.66067815f, -0.19405954f, -0.71796739f, 
    -0.57950675f, -0.44036776f, 0.18975618f, -0.17245871f, 0.10696623f, -0.12656078f, 0.22339511f, 0.10461793f, 
    0.24087739f, 0.44081062f, -0.08287375f, 0.31080180f, -0.10834542f, -0.05376833f, -0.13948813f, -0.22501865f, 
    -0.28682068f, -0.24631555f, 0.01338302f, 0.02606907f, -0.19292328f, 0.26656619f, -0.89946371f, -0.80676788f, 
    -0.65842414f, -0.07614721f, -0.58703983f, 0.40836421f, -0.20018379f, -0.35802361f, -0.04198588f, 0.35515994f, 
    -0.03637128f, -0.31005520f, -0.33346441f, 0.04640643f, -0.15920854f, -0.19971141f, -0.23040421f, -0.10338788f, 
    0.06487387f, -0.22728203f, -0.19727154f, -0.16366066f, 0.03422933f, 0.06816735f, -0.09829309f, -0.67601216f, 
    -0.39495781f, -0.02121769f, 0.42787430f, 0.15144728f, -0.25012046f, -0.26768696f, 0.51206547f, 0.30685303f, 
    0.27775070f, -0.10888119f, 0.17284742f, 0.05344839f, 0.12346338f, -0.30128497f, 0.09582882f, 0.09673205f, 
    0.05776414f, -0.22692505f, 0.21611266f, 0.26890436f, -0.24088609f, -0.09230579f, -0.21611349f, -0.08033887f, 
    -0.41959965f, -0.60597938f, -0.10457037f, 0.54172194f, 0.43696147f, -0.27735361f, -0.53508252f, -0.49847841f, 
    -0.54359269f, -0.55851847f, 0.07537950f, 0.03723003f, -0.17870542f, 0.33810914f, -0.31162709f, 0.34133825f, 
    0.19736581f, -0.12598418f, 0.06650107f, -0.25248152f, -0.28182015f, 0.27468809f, 0.16554545f, 0.12992693f, 
    0.07231797f, 0.47104219f, 0.67336226f, -0.40062505f, 0.14259823f, -0.12996505f, -0.45794305f, -0.39660221f, 
    -0.50672829f, -0.18504360f, -0.36671925f, 0.00763973f, -0.26561788f, 0.00674859f, 0.49687079f, -0.16304383f, 
    0.02373099f, 0.02527538f, -0.10649944f, 0.12435517f, -0.03143998f, -0.00914892f, -0.06865084f, -0.25580072f, 
    -0.09598517f, 0.14972658f, -0.72592723f, -0.61344492f, 0.44177204f, 0.27976972f, 0.41573575f, 0.65154529f, 
    -0.27158898f, -0.34053898f, -0.03282491f, -0.01895576f, -0.16084421f, -0.10431289f, -0.22064011f, -0.13525091f, 
    -0.08692616f, -0.05522087f, -0.04886780f, -0.01786037f, 0.26541314f, 0.09753004f, 0.19552743f, -0.27833903f, 
    -0.07573144f, -0.04108474f, 0.29492033f, -0.35152912f, -0.29028541f, 0.26318109f, 0.19987810f, -0.31274265f, 
    0.23744448f, 0.17337400f, -0.56071222f, -0.13320205f, 0.61611181f, -0.02827465f, -0.22960405f, 0.03998134f, 
    0.25212207f, 0.04381606f, 0.15454161f, -0.05384196f, -0.27282667f, -0.03622352f, -0.23552331f, -0.01657268f, 
    0.05425713f, 0.21704206f, 0.25647566f, -0.10125104f, -0.13387707f, -0.52586222f, -0.33860710f, -0.34448144f, 
    -0.23019497f, 0.55075961f, 0.53973383f, 0.37371862f, 0.22698633f, 0.24455377f, 0.18051152f, 0.11074068f, 
    -0.04874117f, -0.01955428f, -0.28044450f, 0.12407655f, 0.06904852f, 0.21525259f, -0.21419939f, -0.20559968f, 
    0.14808999f, -0.00446825f, -0.19498895f, -0.06064178f, -0.21998298f, -0.44859096f, -0.51054031f, -0.57696152f, 
    0.24219052f, 0.35155785f, -0.22111444f, -0.36765775f, -0.33865222f, -0.26979741f, -0.11589479f, 0.35698450f, 
    -0.37326109f, -0.16345122f, -0.19951311f, -0.35262227f, 0.02776572f, -0.33395034f, -0.20577204f, -0.44873229f, 
    -0.44413102f, -0.28440413f, -0.17502165f, 0.01882168f, -0.40082955f, 0.26360053f, -0.13500498f, 0.40343723f, 
    -0.27154237f, -0.40740865f, -0.15294120f, -0.10372358f, 0.11206991f, 0.09422877f, 0.19618987f, 0.22216344f, 
    -0.00196787f, -0.20840006f, 0.04007789f, 0.01764802f, -0.29482508f, 0.02018368f, -0.03667819f, -0.08958949f, 
    0.05125578f, 0.00788888f, -0.00953659f, 0.23408809f, 0.14453901f, 0.09847581f, 0.23171552f, 0.63558400f, 
    -0.48543647f, -0.49403203f, -0.33808297f, -0.17988791f, 0.27531964f, -0.18692552f, -0.10595903f, -0.21465288f, 
    0.51177078f, -0.12867740f, 0.37738502f, 0.00715348f, -0.26752591f, 0.01157473f, 0.17602380f, -0.05020697f, 
    0.13128243f, 0.11915163f, 0.03302937f, 0.27643895f, -0.43846488f, -0.10651377f, -0.11100565f, -0.17996430f, 
    0.42917392f, -1.21171737f, -0.12495580f, 0.87533283f, 0.82524544f, -0.61999458f, -0.68789697f, -0.93087775f, 
    -0.27720210f, 0.14841162f, 0.11008794f, 0.56742877f, 0.21493094f, 0.07197800f, -0.11794689f, -0.12342986f, 
    0.20131606f, -0.28987938f, -0.08602326f, -0.29886836f, 0.16000564f, 0.03210302f, -0.09843457f, 0.03929376f, 
    -0.00218731f, 0.81553388f, -0.38289693f, -0.02879479f, 0.44703647f, 0.11405830f, 0.03943369f, 0.42674264f, 
    -0.13767621f, -0.58282495f, -0.43084881f, 0.09763948f, 0.09959169f, -0.14513887f, -0.37466744f, -0.08371586f, 
    -0.32188252f, 0.01723126f, 0.26990315f, 0.32336268f, -0.19444691f, 0.23794200f, -0.18724991f, -0.15254356f, 
    0.13231100f, 0.03368079f, 0.27919975f, 0.16269082f, -0.20481554f, -0.22463976f, 0.07310805f, 0.21865506f, 
    -0.18672153f, -0.25357634f, 0.01235190f, 0.25957224f, -0.40809265f, 0.66325021f, -0.28781134f, -0.13287377f, 
    0.22759545f, 0.16715662f, 0.15074880f, -0.13181455f, -0.20999666f, -0.13945529f, -0.31504488f, 0.17869182f, 
    0.27381465f, -0.01223086f, 0.00868762f, 0.56028271f, 0.52713579f, -0.28165376f, -0.36313987f, 0.28290099f, 
    -0.04909270f, 0.30718461f, 0.12021451f, 0.10342655f, -0.44736347f, -0.19846830f, -0.11518720f, -0.12572794f, 
    0.09766778f, -0.17807662f, -0.07936163f, 0.01251188f, -0.01546899f, 0.06892823f, 0.06283282f, 0.14323539f, 
    -0.18364292f, -0.30435571f, -0.15186882f, -0.32234383f, -0.08679438f, -0.19602273f, -0.19817053f, 0.10920760f, 
    0.44043407f, 0.24006273f, 0.17915423f, -0.29421148f, -0.38761327f, 0.56401807f, 0.24406026f, 0.08308832f, 
    -0.48175147f, -0.13641387f, 0.24922974f, 0.36620763f, -0.13897286f, -0.14274445f, -0.21042424f, -0.12406215f, 
    -0.26972598f, 0.00771892f, 0.23807241f, 0.10134109f, 0.19284490f, -1.00140786f, -0.32220861f, -0.00374383f, 
    0.12166596f, -0.05669759f, 0.75625980f, -0.10499142f, -0.04570411f, 0.42557952f, 0.57122135f, 0.28376824f, 
    -0.29570064f, 0.15533698f, -0.26315662f, -0.36576310f, -0.13660365f, 0.08337123f, -0.23918438f, 0.08228328f, 
    0.05253205f, -0.10286094f, 0.15573168f, 0.08556348f, 0.02753549f, -0.10340519f, 0.22879349f, 0.07762851f, 
    0.14220564f, 0.04046624f, -0.14682719f, 0.19868502f, -0.03216240f, 0.23166648f, 0.05758051f, -0.03711128f, 
    0.13918534f, 0.14483669f, -0.09149931f, 0.00561647f, 0.15778738f, -0.07783218f, 0.05601652f, 0.16695246f, 
    -0.24379596f, 0.21660748f, -0.10420109f, -0.22069278f, 0.18721965f, 0.13413446f, 0.09144819f, 0.01290196f, 
    0.03755654f, -0.22457759f, -0.43612546f, 0.06681369f, -0.25547183f, -0.08638237f, 0.10746761f, -0.15527977f, 
    -0.32965025f, -0.28946480f, 0.23981465f, -0.15785357f, 0.00001116f, -0.30541915f, 0.15783852f, -0.09445228f, 
    -0.30260307f, 0.15325570f, -0.00507560f, 0.18254915f, 0.13255930f, -0.12530874f, 0.29180562f, 0.27548727f, 
    -0.98779774f, -0.48767108f, -0.25061446f, 0.20607477f, 0.69315392f, -0.00682275f, -0.46305493f, -0.48090097f, 
    0.55910528f, 0.48441270f, 0.15305662f, -0.08684026f, 0.31742170f, -0.22213495f, 0.00229711f, -0.25326976f, 
    0.19003499f, 0.01344612f, 0.02676391f, 0.27579251f, 0.28423417f, -0.06826874f, -0.03387916f, -0.12487405f, 
    -0.16495742f, -0.04796484f, 0.19427870f, 0.20611744f, 0.09212340f, -0.23617314f, 0.24655265f, 0.05219916f, 
    -0.25792778f, -0.36348510f, 0.25856450f, -0.27277473f, -0.01838137f, -0.10791871f, -0.02179593f, 0.24567133f, 
    0.07611413f, -0.51259702f, 0.11008440f, 0.24382369f, 0.14301449f, -0.03571026f, 0.24957421f, 0.23042254f, 
    -0.37066138f, -0.16430950f, -0.65875363f, -0.49083778f, -0.12970516f, -0.30337852f, 0.11583463f, -0.27457267f, 
    -0.45101112f, -0.33116171f, -0.28733778f, -0.52932507f, 0.22509885f, -0.26379597f, 0.07174979f, -0.32211092f, 
    -0.11709411f, 0.06423497f, -0.08136154f, 0.07276557f, 0.10541864f, 0.24581556f, 0.13651747f, 0.07536083f, 
    0.18975550f, -0.14870606f, 0.48811761f, -0.16134755f, -0.65628523f, -0.10215437f, -0.20724900f, 0.64162922f, 
    0.25588959f, 0.34175509f, 0.25211468f, 0.01850047f, 0.01583571f, -0.29291409f, -0.25315979f, 0.00458672f, 
    0.08918601f, 0.30793598f, 0.18883272f, 0.18744615f, -0.23582317f, -0.20563439f, 0.09466474f, 0.16432413f, 
    -0.42660791f, -0.15551153f, 0.31180587f, -0.00187366f, -1.02077281f, 0.06118954f, 0.51749998f, -0.64988053f, 
    -0.25396532f, -0.10587408f, -0.05609449f, -0.07118073f, 0.12269250f, 0.55333734f, -0.25410080f, 0.18537319f, 
    0.19116606f, -0.04530381f, 0.11251996f, 0.15345007f, 0.07227682f, 0.17501147f, -0.09627983f, -0.31904072f, 
    0.07743637f, 0.11208075f, 0.10964627f, -0.24971132f, 0.04268351f, -0.75348622f, -0.50578994f, -0.30924910f, 
    0.16529885f, 0.81968755f, -0.59835845f, -0.71391243f, 0.21091665f, -0.33765203f, 0.21298456f, 0.26582485f, 
    -0.20862286f, 0.16293015f, 0.33138722f, -0.32751325f, 0.17467852f, 0.09378583f, -0.15520540f, -0.08125957f, 
    0.16247585f, -0.06752526f, -0.07118046f, 0.18453047f, -0.14668296f, -0.02273439f, -0.97119761f, -0.30232090f, 
    -0.23488949f, -0.08922412f, 0.21308070f, 0.49740240f, 0.49594212f, 0.30990165f, -0.13123764f, -0.23356262f, 
    0.18110521f, 0.00543868f, 0.21739399f, -0.01177916f, 0.30602327f, -0.02811402f, -0.06850285f, -0.26468948f, 
    -0.21322037f, 0.12291585f, 0.13474841f, 0.22034681f, -0.05008531f, 0.02806080f, 0.07307775f, 0.31853309f, 
    -0.05467967f, 0.09466709f, -0.19246298f, -0.21261135f, 0.28275859f, -0.23476796f, 0.01785735f, 0.42772970f, 
    -0.22180268f, 0.40320012f, -0.49736261f, -0.42152661f, 0.42941225f, -0.27146691f, -0.06492597f, 0.22219440f, 
    0.24440953f, -0.20521973f, -0.05974732f, 0.18013631f, -0.18430789f, -0.12173579f, -0.10144056f, 0.21099147f, 
    0.06042815f, 0.56248879f, 0.05226671f, -0.65986681f, -0.78438234f, 0.57824129f, 0.36103907f, -0.01679739f, 
    0.11168381f, -0.22750941f, 0.01250958f, 0.23086895f, 0.05561431f, -0.02084976f, -0.37738240f, 0.22188866f, 
    -0.55283278f, -0.07309169f, 0.03776760f, -0.13586783f, -0.17703304f, 0.38978016f, 0.23835446f, 0.06429739f, 
    0.11305712f, 0.14970721f, 0.13155143f, -0.06823530f, -0.38070238f, -0.21679047f, -0.34087598f, -0.37513047f, 
    -0.27538514f, -0.44904628f, -0.39896360f, -0.04227879f, 0.07849139f, 0.10088588f, 0.43514261f, 0.22909743f, 
    -0.18718575f, -0.32446158f, -0.37630790f, -0.43064186f, -0.15672532f, -0.23942056f, -0.15991423f, -0.17726740f, 
    -0.02326075f, -0.32158953f, -0.99292338f, -0.45608398f, 0.02314692f, 0.31424046f, 0.62777364f, 0.20177375f, 
    -0.03208591f, 0.36019737f, 0.29350317f, -0.01049434f, -0.62178844f, -0.66945642f, -0.16647562f, 0.44349924f, 
    0.10000060f, 0.19974327f, 0.01259065f, -0.28983304f, -0.07091822f, -0.32468316f, 0.20150250f, -0.30786532f, 
    0.08565561f, 0.07644066f, -0.04415530f, -0.78810829f, -0.22465762f, -0.30009606f, -0.47183797f, -0.63754481f, 
    0.73849988f, 0.25251889f, -0.66600192f, -0.45631793f, 0.70605147f, -0.02433264f, -0.26181665f, -0.13221897f, 
    -0.05320837f, -0.08683521f, 0.14060046f, -0.10411106f, -0.07883471f, 0.24192540f, -0.11854629f, 0.10410182f, 
    -0.25644878f, 0.01324489f, -0.15048128f, -0.18529975f, 0.65607828f, 0.60198641f, 0.42285183f, 0.09172428f, 
    -0.24213073f, -0.25009546f, -0.35211328f, -0.24879092f, -0.06417812f, -0.30226853f, 0.12879616f, 0.18925108f, 
    -0.23364377f, -0.28728601f, 0.17522228f, -0.18922140f, 0.11403412f, -0.03074712f, 0.09673778f, 0.10996585f, 
    0.05091117f, 0.20015346f, -0.19194867f, -0.12325825f, -0.16536969f, 0.95184016f, -0.55759311f, -0.69769031f, 
    0.13253494f, -0.48974839f, 0.66764867f, 0.39744064f, -0.13531047f, -0.22529215f, 0.08344339f, -0.37500644f, 
    -0.22549909f, -0.20281821f, 0.07916236f, 0.21808347f, -0.14662711f, 0.11514362f, -0.01961785f, -0.02692877f, 
    -0.03121235f, 0.13624342f, -0.09280034f, -0.34571263f, 0.10116912f, -0.15554088f, 0.25918892f, 0.21789704f, 
    0.38568112f, 0.44281462f, 0.36414662f, 0.10916840f, 0.01215090f, 0.00298902f, 0.44096699f, -0.11437494f, 
    0.16931227f, 0.17516141f, -0.07052230f, -0.15190814f, 0.06805521f, -0.06986291f, 0.01822448f, 0.05376152f, 
    -0.23838824f, -0.04624119f, 0.02725527f, -0.03897975f, 0.07190830f, 0.01562620f, -0.01641177f, 0.23968758f, 
    -0.68099207f, -0.72890645f, 0.11089388f, 0.32769153f, 0.24609643f, -0.14089173f, -0.06985194f, 0.50163996f, 
    -0.23289531f, -0.07191448f, 0.25215399f, -0.02588714f, -0.00435939f, -0.25656751f, -0.20168790f, -0.23920611f, 
    -0.27052942f, 0.41705146f, 0.06216478f, 0.35499892f, -0.37878537f, -0.38331693f, 0.16449763f, 0.01019246f, 
    -0.62900674f, -0.53779620f, 0.41167414f, 0.35695216f, 0.27791876f, 0.15030874f, -0.49177966f, -0.50121379f, 
    0.36678180f, -0.25155827f, 0.03476352f, 0.09883385f, -0.23555928f, 0.01992625f, 0.40435511f, 0.13216519f, 
    -0.26817384f, 0.00539538f, -0.05684033f, 0.16044706f, 0.11820107f, -0.19500059f, -0.03811682f, 0.07088975f, 
    0.20575911f, -0.26128316f, -0.01294188f, 0.18664531f, 0.27585533f, -0.04171135f, -0.25060138f, -0.29523125f, 
    0.16613868f, -0.10084553f, -0.01193210f, 0.24689382f, -0.01074775f, 0.32900909f, -0.40222958f, 0.17940986f, 
    -0.41796613f, -0.02590706f, 0.04567865f, -0.13202578f, 0.25980651f, 0.24524218f, -0.01545639f, -0.07952297f, 
    0.16055071f, 0.07188739f, 0.84456319f, -0.17688839f, 0.02818139f, 0.01965842f, -0.65890288f, -0.02256280f, 
    0.22065246f, 0.20862888f, -0.21979670f, -0.17736818f, 0.15594640f, 0.19797614f, -0.14320740f, -0.18565418f, 
    0.18716757f, -0.26054704f, 0.12280275f, -0.21671598f, 0.05795996f, 0.11943464f, 0.45651326f, -0.19970885f, 
    -0.08609118f, 0.13398302f, -0.21030745f, 0.00855495f, -0.72349030f, -0.25416294f, -0.23946139f, 0.29333910f, 
    -0.26001406f, -0.00651316f, -0.25328675f, 0.03636861f, 0.17286836f, 0.30332100f, 0.10353919f, 0.08559412f, 
    -0.13158481f, 0.08414426f, -0.17765442f, 0.14861628f, 0.10928706f, 0.06129161f, -0.12698184f, 0.11085737f, 
    -0.16214386f, -0.25518560f, -0.37007254f, -0.23971547f, -0.44075346f, 0.20323204f, -0.34189254f, -0.42036951f, 
    -0.14473684f, -0.12049254f, -0.58368576f, 0.05549369f, -0.31588623f, 0.17084287f, -0.01723035f, 0.20740305f, 
    -0.11431053f, 0.08404680f, -0.05477740f, -0.02929324f, -0.05321044f, -0.17199236f, 0.13981189f, 0.15768006f, 
    0.19813687f, 0.24435546f, -0.04236777f, 0.09842992f, -0.13037768f, -0.31466296f, -0.60523719f, -0.59684938f, 
    -0.54035842f, -0.41928971f, 0.70944232f, 0.33596408f, -0.26306224f, 0.30626059f, 0.31912360f, -0.02191368f, 
    0.00079531f, -0.31457525f, -0.29343572f, -0.13287242f, -0.11392798f, 0.31053829f, 0.21671480f, -0.23735674f, 
    0.06744730f, 0.15873207f, 0.02215701f, 0.11602961f, -0.05004755f, 0.21890697f, -0.62149632f, -0.07241005f, 
    0.18669921f, 0.36546162f, 0.43999395f, 0.15499353f, 0.60835499f, 0.12115737f, -0.21694110f, -0.38026223f, 
    -0.08861109f, 0.08596218f, -0.30891889f, 0.14018622f, -0.09540672f, -0.01606091f, -0.24239017f, -0.13138485f, 
    0.10019121f, 0.04223652f, 0.10107854f, -0.12476614f, 0.18211977f, -0.09778138f, -0.33149546f, 0.45731974f, 
    -0.20036221f, 0.28654781f, 0.66091877f, 0.06905059f, -0.15448686f, 0.11573241f, -0.35303965f, -0.52354050f, 
    -0.09074703f, -0.04282624f, 0.10769221f, 0.05628220f, 0.26875013f, -0.31637362f, -0.09337007f, 0.12951019f, 
    -0.10748508f, 0.09060604f, 0.08330949f, -0.22629882f, 0.15004510f, 0.25007039f, -0.14907104f, -0.11283757f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.06411381f, -0.03045104f, -0.14704701f, 0.24522504f, 0.10618686f, 0.05472688f, 0.43440983f, 0.19117863f, 
    -0.23056072f, 0.32762498f, -0.01079655f, -0.31225470f, -0.25505561f, -0.53293449f, 0.20325521f, 0.05963305f, 
    0.08564818f, 0.11394017f, 0.21368343f, -0.16027448f, 0.18311514f, 0.42040816f, -0.44175640f, 0.03289645f, 
    0.14381486f, -0.06427867f, 0.00733043f, 0.21721476f, -0.16055712f, 0.12407110f, -0.07369442f, 0.31268021f, 
    0.15447722f, 0.08752788f, 0.32103556f, 0.11024249f, 0.39676011f, 0.16999854f, 0.06620600f, 0.07672621f, 
    0.10963279f, 0.26357538f, 0.02790561f, 0.00572071f, 0.13908270f, 0.05130835f, 0.11261097f, 0.15391701f, 
    0.36822924f, -0.22979476f, 0.04212537f, 0.00496063f, 0.17343098f, 0.22030996f, -0.03677156f, 0.34332687f, 
    0.31111112f, 0.09079301f, 0.12551810f, 0.05539973f, 0.01150070f, 0.14905784f, 0.42760679f, 0.07538527f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.03991173f, 0.16154499f, 0.14863867f, -0.10990809f, -0.10779405f, -0.02735889f, -0.04701668f, 0.10200557f, 
    -0.12862916f, -0.11870907f, -0.12578297f, 0.11277907f, 0.12166128f, 0.06646790f, 0.00576067f, -0.00057953f, 
    0.02200974f, 0.18132886f, 0.01169393f, -0.04568690f, 0.00544003f, -0.02224938f, 0.01891170f, 0.02707742f, 
    -0.21773528f, 0.24287862f, 0.26990899f, -0.14678149f, 0.03602831f, 0.07202701f, -0.00392652f, 0.06721705f, 
    0.09050787f, 0.05478004f, 0.00401791f, -0.09529816f, -0.21758473f, 0.15382914f, 0.02750005f, 0.05627097f, 
    -0.06728098f, -0.00142002f, 0.04348939f, -0.01954884f, -0.10810873f, -0.03359042f, 0.05397677f, -0.27799100f, 
    -0.18079254f, 0.19420391f, 0.11135288f, -0.32725108f, -0.02824862f, -0.02612616f, -0.05747009f, -0.07921553f, 
    0.02918575f, -0.05924372f, 0.00956564f, 0.06277169f, -0.03518641f, 0.16394071f, 0.11066405f, -0.04830504f, 
    -0.03174083f, -0.06803790f, 0.09796389f, -0.28229007f, -0.15918885f, 0.05406329f, -0.06029791f, 0.01856822f, 
    -0.12990506f, 0.05076680f, -0.03670656f, -0.05248041f, 0.06467842f, 0.04495847f, 0.06228784f, -0.26685485f, 
    -0.02500693f, -0.11720815f, -0.04476141f, -0.02884128f, 0.11085018f, -0.04714521f, 0.02751037f, -0.31343523f, 
    -0.14446211f, 0.09840085f, -0.07321162f, -0.14428857f, -0.09121822f, -0.00045727f, 0.20668611f, -0.21947031f, 
    0.28044111f, -0.07380124f, -0.08654851f, 0.00311682f, 0.18174294f, 0.03198843f, 0.18434402f, 0.04047635f, 
    -0.02371071f, -0.00473328f, 0.09494285f, 0.04531512f, 0.13322414f, 0.10620366f, 0.00524966f, -0.31276941f, 
    -0.11240479f, -0.14620206f, 0.02885143f, -0.10945718f, -0.03678465f, -0.14910309f, -0.00594226f, 0.09574850f, 
    0.03240192f, -0.03861233f, -0.09674951f, -0.01459467f, 0.00211876f, 0.00612338f, 0.05346596f, -0.02098524f, 
    -0.06888348f, 0.00554101f, -0.00600534f, 0.14070471f, 0.25830036f, 0.11955305f, 0.04157876f, -0.14048015f, 
    0.05801099f, 0.15874779f, 0.00902527f, -0.02268560f, -0.11595520f, -0.06797101f, -0.01092660f, 0.00663697f, 
    0.32231471f, 0.22933102f, -0.06085973f, -0.18312836f, 0.07264342f, 0.03300891f, 0.02765302f, 0.09767605f, 
    -0.04305936f, -0.02711383f, 0.05332453f, 0.01373081f, 0.20623651f, 0.28789365f, -0.05812343f, -0.06696671f, 
    0.11106545f, 0.29570439f, 0.11471666f, 0.20449808f, -0.03344275f, 0.01737515f, 0.04113051f, -0.04174035f, 
    0.05856559f, -0.08800048f, -0.12168405f, -0.04574811f, 0.09345817f, 0.02628438f, -0.08658710f, -0.05242527f, 
    -0.01574427f, 0.01445621f, 0.07079467f, 0.11787981f, 0.04082164f, -0.07017206f, -0.06685146f, -0.01636948f, 
    -0.01603824f, 0.00095074f, 0.03659705f, -0.05133311f, 0.10039409f, 0.07281329f, -0.12478737f, -0.26942545f, 
    0.02267896f, 0.07259002f, 0.02931929f, -0.00789434f, -0.00493057f, -0.03727799f, 0.05393394f, -0.01841334f, 
    -0.05761471f, -0.01928220f, -0.07615674f, -0.02122435f, 0.09959074f, -0.04503470f, 0.05370239f, 0.02704670f, 
    -0.06630459f, 0.00912520f, -0.02655349f, 0.02982610f, 0.09591992f, -0.00127121f, 0.00974933f, 0.09182044f, 
    -0.00206725f, 0.24436413f, 0.21905670f, -0.20252241f, -0.00231259f, 0.13024029f, -0.05816669f, -0.19498166f, 
    -0.04352506f, -0.14073227f, -0.16316773f, -0.05433062f, 0.10958835f, 0.07753965f, -0.17552559f, 0.01913137f, 
    0.01322879f, -0.04320440f, -0.03562316f, 0.09554709f, -0.08256682f, -0.04566603f, -0.15064353f, 0.12169882f, 
    0.02573523f, -0.23747769f, -0.02820750f, -0.15517057f, -0.17795971f, -0.07428312f, -0.15181357f, 0.03030014f, 
    -0.01738751f, -0.11705924f, -0.03766371f, -0.14051513f, 0.15711404f, -0.00209006f, -0.07816380f, -0.10454994f, 
    0.01582713f, 0.04913035f, -0.01291822f, -0.22856542f, -0.05543704f, -0.10932606f, -0.04893516f, -0.03405284f, 
    0.38736093f, 0.16592181f, 0.08748185f, -0.17444286f, 0.21268582f, 0.11891942f, 0.16367638f, -0.08441026f, 
    -0.05361660f, -0.08264520f, -0.03150767f, 0.09051063f, 0.00404880f, 0.03678767f, 0.15223698f, -0.03516177f, 
    0.01258963f, -0.00463371f, 0.04591980f, 0.07188500f, -0.22457050f, -0.11511788f, 0.07117706f, -0.02345139f, 
    0.27886456f, 0.12660606f, -0.07865585f, -0.28102773f, 0.04244941f, -0.17869414f, 0.03004637f, -0.14880028f, 
    -0.04816629f, -0.00572445f, -0.07855685f, -0.06923314f, -0.04100214f, 0.07193986f, -0.02932488f, -0.11170979f, 
    0.05696305f, -0.07858635f, 0.02302397f, 0.00922770f, -0.00363561f, 0.02634550f, -0.01984728f, 0.06835072f, 
    0.49267364f, 0.27289221f, -0.17829633f, -0.36935890f, -0.27632281f, -0.16202705f, 0.08866873f, 0.05814426f, 
    0.01555634f, -0.02754128f, -0.06246540f, -0.03710100f, 0.06218641f, -0.12591231f, -0.00066374f, -0.11264473f, 
    -0.09056161f, -0.08328637f, -0.04821103f, -0.00530285f, -0.07716329f, -0.00538890f, 0.00657952f, 0.00966669f, 
    0.03809854f, -0.08675978f, -0.11266767f, 0.09126924f, 0.09222770f, 0.07241817f, 0.06392499f, 0.03938745f, 
    -0.05316254f, 0.14055263f, -0.00300869f, 0.06446771f, 0.30222547f, 0.10990211f, 0.06733106f, -0.06954186f, 
    -0.06802515f, -0.00111053f, 0.07635804f, -0.07801145f, -0.19103509f, -0.09862715f, -0.07757680f, -0.05930332f, 
    -0.03318345f, -0.01348464f, 0.03057927f, 0.02465022f, -0.07639764f, -0.04651680f, -0.03766735f, -0.00793328f, 
    0.01146933f, -0.02064684f, 0.00514161f, -0.03005726f, 0.00540151f, 0.10271782f, -0.05051449f, 0.05536031f, 
    0.06145156f, -0.03548024f, -0.06752677f, -0.23526081f, -0.11479008f, 0.05368975f, 0.03610992f, 0.03624236f, 
    -0.01228013f, 0.39907759f, -0.04995941f, -0.35636812f, 0.01357589f, 0.05980989f, -0.07177965f, -0.13297497f, 
    0.04792471f, -0.02002543f, -0.03735777f, -0.00189280f, 0.01962090f, -0.47323662f, -0.24736117f, -0.05974276f, 
    -0.07382591f, -0.05558995f, -0.00360820f, -0.04218633f, 0.03754219f, 0.04659255f, 0.02710719f, 0.07456324f, 
    -0.00797466f, -0.07710734f, -0.13629226f, -0.00030486f, -0.09674164f, -0.03177287f, -0.03854201f, -0.04643391f, 
    -0.17353101f, -0.02322129f, -0.14688152f, -0.16367598f, -0.37851655f, -0.47196266f, -0.44152993f, 0.15642753f, 
    0.01139241f, 0.05214705f, -0.03421280f, -0.04094149f, 0.09201451f, -0.05850687f, -0.09006099f, -0.08779359f, 
    -0.24981546f, 0.14486136f, -0.03760952f, -0.02206562f, -0.09106443f, -0.10524948f, 0.03636613f, -0.06402835f, 
    -0.05950094f, -0.01473270f, -0.14766899f, -0.13846557f, 0.17282602f, 0.05477780f, 0.19486000f, -0.16074094f, 
    -0.04941655f, 0.05952219f, 0.02876463f, 0.01702546f, 0.05334231f, 0.10992080f, -0.08789917f, -0.22661066f, 
    -0.01644880f, 0.01883642f, 0.02526570f, 0.06255667f, 0.02781564f, 0.03520257f, 0.00858687f, 0.03540269f, 
    -0.27119419f, -0.11642540f, -0.10962008f, -0.08834339f, 0.08036613f, 0.14404695f, -0.17923093f, -0.07619429f, 
    0.02166216f, -0.00246449f, 0.00849384f, -0.09663872f, -0.04857600f, -0.04402231f, 0.01331765f, 0.00279404f, 
    0.32219890f, 0.43576095f, 0.18890356f, -0.26471624f, -0.20364937f, 0.08766371f, 0.08471211f, -0.01381390f, 
    0.03144290f, -0.03558142f, -0.03468554f, -0.10813414f, -0.12170426f, -0.11926528f, -0.05933780f, -0.09217792f, 
    0.01976706f, -0.13331929f, 0.12724520f, -0.02528340f, -0.10444078f, -0.09711070f, -0.02735408f, -0.12677203f, 
    0.31925339f, 0.21744232f, -0.04410060f, -0.25022104f, 0.06571781f, 0.05359644f, 0.10512137f, 0.00272729f, 
    -0.01797281f, -0.00057972f, 0.00224380f, -0.04555671f, -0.09078630f, -0.08849791f, -0.08837678f, -0.00629137f, 
    0.04845409f, 0.04482511f, -0.00982660f, 0.03254650f, -0.14325880f, 0.04770695f, -0.03092520f, -0.02033597f, 
    0.02406743f, 0.06549682f, 0.18028936f, -0.09399049f, -0.12983695f, 0.07859125f, 0.00114333f, -0.05256355f, 
    -0.01611322f, -0.06635196f, -0.05063707f, -0.02066788f, 0.42158374f, 0.38516128f, 0.29623801f, -0.25892997f, 
    0.20569846f, 0.00109255f, -0.04766532f, 0.05969474f, -0.01939306f, -0.05198288f, -0.07504616f, -0.01911485f, 
    0.02718078f, -0.02539360f, -0.10474660f, 0.00572495f, 0.07660772f, 0.06790266f, 0.05873984f, -0.02169455f, 
    -0.20237601f, -0.30424568f, -0.09997095f, -0.07664747f, -0.13590734f, -0.25773588f, -0.07916205f, -0.02835842f, 
    -0.03532252f, 0.13335001f, -0.07468227f, 0.01918474f, -0.09693402f, 0.11041244f, -0.19562708f, -0.05093001f, 
    -0.18520552f, -0.65724230f, -0.43882495f, -0.10772214f, 0.08654577f, -0.04606342f, -0.01685686f, -0.05237712f, 
    -0.08245995f, -0.30080944f, -0.36520514f, -0.00531967f, 0.26336020f, 0.12355521f, -0.14227894f, -0.10346062f, 
    -0.18811241f, -0.20647220f, -0.18983068f, -0.14575550f, -0.01953567f, -0.06197270f, 0.01688389f, -0.05770868f, 
    0.33020082f, -0.04284324f, 0.22404765f, -0.20018107f, -0.05049756f, 0.02177122f, 0.03874204f, 0.07549195f, 
    -0.02734799f, 0.06499224f, -0.07962242f, -0.06937587f, 0.24607195f, 0.19082177f, -0.13798767f, -0.11052349f, 
    -0.01923803f, 0.15194319f, 0.09505151f, 0.01661744f, -0.01689446f, -0.05244678f, 0.06184442f, -0.04357896f, 
    -0.24824563f, -0.10239375f, -0.19961971f, -0.07653784f, 0.04326729f, 0.06694484f, -0.06743335f, -0.03941207f, 
    -0.01439169f, 0.04146914f, 0.06418987f, 0.04644978f, 0.12352673f, -0.08009394f, -0.09984437f, -0.06360814f, 
    0.01304583f, -0.06563903f, -0.15101303f, -0.11697134f, -0.11440321f, -0.06410029f, -0.05707106f, 0.00408633f, 
    -0.15613683f, -0.13025165f, 0.01012155f, 0.04639626f, 0.04496823f, 0.02515119f, 0.01282927f, 0.04855819f, 
    0.02819311f, -0.00068924f, 0.01866126f, 0.05027052f, -0.01475859f, 0.07579415f, -0.24670745f, -0.10772261f, 
    0.06037692f, -0.06130412f, -0.01487730f, -0.16725183f, -0.07950594f, -0.08072660f, 0.00626653f, 0.00940750f, 
    0.14371143f, 0.15779784f, 0.08379150f, -0.22189067f, -0.13168027f, -0.11311219f, 0.01175155f, 0.04088506f, 
    0.01924835f, -0.07484935f, -0.09841691f, -0.14403562f, -0.08650944f, -0.02916387f, 0.24514984f, -0.03802392f, 
    -0.24313515f, 0.13391413f, 0.05786884f, -0.09041069f, 0.01192785f, -0.03384106f, 0.01778213f, -0.13665418f, 
    -0.37729955f, -0.16021709f, -0.12959947f, -0.04617487f, -0.10620760f, -0.01536127f, -0.00005092f, -0.03002955f, 
    -0.12179611f, -0.01310123f, 0.01000552f, -0.17205305f, 0.13108870f, 0.09740520f, 0.01142180f, -0.03838864f, 
    0.00918982f, -0.03103641f, 0.06154779f, -0.01941347f, -0.00434861f, 0.07927129f, 0.07682443f, -0.00981735f, 
    0.09233862f, 0.11721504f, -0.05641364f, -0.18218821f, 0.01530355f, 0.13478652f, -0.08975144f, -0.02413130f, 
    0.02690788f, -0.01087887f, -0.01073875f, 0.00469821f, 0.20005059f, 0.05338289f, -0.11968673f, -0.04612364f, 
    0.02450378f, 0.11389669f, -0.01658754f, -0.05856669f, 0.03117491f, 0.06308741f, 0.00599117f, -0.03703492f, 
    0.27796212f, -0.32796639f, -0.09782343f, -0.11923933f, 0.00856624f, -0.00254612f, 0.01179189f, -0.03709092f, 
    -0.09464618f, 0.01105812f, 0.07965105f, 0.04043620f, -0.13655384f, -0.16894537f, -0.00857687f, -0.04528575f, 
    0.00902657f, -0.07625008f, 0.00768188f, -0.11086638f, 0.00813040f, 0.05224768f, 0.07057869f, 0.00727139f, 
    -0.14391355f, -0.07973095f, -0.15847561f, -0.21094947f, 0.03196288f, 0.05352475f, -0.01117774f, 0.01261021f, 
    0.05395582f, -0.22645314f, -0.23114248f, -0.47001058f, -0.09128200f, 0.18878378f, 0.18563302f, -0.06469843f, 
    0.11292759f, 0.11977303f, -0.01104684f, -0.11738958f, -0.06869051f, 0.01350368f, -0.03052190f, -0.02958226f, 
    -0.50461513f, 0.25863579f, 0.00009136f, -0.17484568f, -0.01365143f, -0.01745871f, -0.14559467f, -0.16599418f, 
    0.14904989f, -0.08905223f, -0.18763407f, -0.00976446f, 0.00171694f, -0.05495332f, -0.02977295f, 0.17559546f, 
    0.08859610f, -0.09741916f, 0.02471239f, 0.01195149f, -0.06387470f, 0.11013761f, -0.06236971f, 0.09130139f, 
    -0.10263440f, -0.07675400f, 0.16396987f, -0.27217665f, 0.03675069f, -0.09380293f, 0.08691861f, 0.00741200f, 
    -0.05554180f, 0.06890991f, -0.06830370f, 0.01879085f, -0.18575385f, 0.06508395f, -0.02013146f, -0.04979691f, 
    -0.18101919f, 0.08728695f, -0.01247634f, 0.06322412f, -0.17998305f, 0.03223325f, -0.01092099f, 0.02336113f, 
    -0.04370537f, -0.01800499f, -0.30275199f, -0.27548096f, -0.06938417f, 0.09983049f, 0.04404773f, 0.03934775f, 
    -0.01953178f, 0.08276078f, 0.14330028f, -0.20389304f, -0.16739686f, -0.30480477f, -0.32177311f, -0.01113950f, 
    0.03786632f, -0.00001294f, 0.06137088f, 0.21371718f, 0.07821746f, -0.02863496f, 0.03381190f, 0.05324502f, 
    0.06416322f, -0.06676350f, 0.20736949f, -0.04751500f, 0.05893615f, 0.05993612f, 0.00599649f, -0.15364236f, 
    0.18080977f, -0.09327021f, -0.04619532f, -0.04047079f, -0.26957184f, -0.09203876f, 0.11980622f, 0.02452724f, 
    0.10103033f, 0.07880834f, -0.05277811f, -0.20197253f, 0.09182708f, 0.10528872f, 0.02934019f, -0.00072711f, 
    0.36989474f, -0.19513409f, 0.21299729f, -0.13410474f, 0.00307557f, -0.00381536f, -0.05514657f, -0.06134033f, 
    -0.22715373f, -0.24649076f, -0.27750897f, -0.15066585f, -0.12962447f, 0.18345073f, 0.05606108f, 0.12588035f, 
    0.01844094f, 0.02034959f, 0.02934821f, -0.05228321f, -0.07904281f, 0.05284329f, 0.00426591f, -0.00335075f, 
    0.05511956f, 0.06335047f, 0.15954654f, -0.10023277f, -0.26928943f, -0.05718888f, 0.01233142f, -0.11256576f, 
    0.03190336f, 0.01250469f, -0.03911478f, -0.01257414f, 0.42964512f, 0.27247664f, 0.25059995f, 0.18119560f, 
    0.06970647f, 0.02897223f, -0.11340658f, -0.17763153f, 0.03659326f, -0.03262936f, -0.03120307f, -0.05143256f, 
    -0.02613368f, -0.20201643f, -0.15248622f, -0.17801760f, -0.01909283f, 0.02065893f, -0.10389262f, -0.00848189f, 
    0.01452127f, -0.11889955f, -0.14178047f, -0.02567220f, 0.11046032f, 0.17719391f, -0.23370050f, -0.07365875f, 
    -0.03145175f, 0.03606526f, -0.06187474f, 0.06110746f, 0.02524594f, 0.07774271f, -0.08854457f, 0.15667483f, 
    -0.05388686f, 0.00636275f, -0.00593804f, 0.04291464f, -0.05115966f, 0.08821718f, -0.01388116f, -0.03643187f, 
    0.03258034f, 0.04460639f, -0.07273912f, 0.03928587f, -0.12370670f, -0.11485022f, -0.00521571f, -0.10727324f, 
    0.00716461f, 0.06910385f, 0.09421936f, 0.08849807f, 0.13249421f, 0.03751466f, 0.00222693f, 0.09160915f, 
    -0.22066346f, 0.07754306f, -0.07273862f, -0.00433283f, 0.03144791f, 0.08702648f, -0.04175125f, 0.17204860f, 
    -0.04739920f, -0.02313480f, 0.08180853f, -0.01742524f, -0.21835421f, -0.11700203f, 0.07839002f, -0.04368624f, 
    -0.01644610f, 0.03891154f, -0.08580783f, -0.01222364f, 0.20886835f, -0.40083694f, -0.23000127f, 0.03611064f, 
    0.15039051f, -0.25861496f, -0.01066384f, -0.08162311f, 0.05070538f, 0.14047483f, 0.15686007f, -0.07023118f, 
    0.17676906f, -0.18538806f, 0.05452768f, 0.12771256f, -0.36332062f, -0.16627039f, -0.16004805f, -0.09924638f, 
    0.17706318f, 0.13736613f, 0.00414212f, -0.09892973f, 0.06607069f, 0.07622296f, 0.04295116f, -0.10303339f, 
    0.36343682f, 0.31298476f, 0.08937020f, 0.04770457f, 0.04881344f, -0.00535305f, 0.04666163f, -0.01869623f, 
    0.08899147f, -0.03610870f, 0.02168982f, -0.13863292f, -0.15646875f, 0.07029039f, 0.02945114f, -0.02453688f, 
    -0.00676516f, -0.01922723f, -0.01723253f, -0.00308028f, -0.11157596f, -0.16685314f, -0.13156220f, 0.16533276f, 
    -0.11375113f, -0.08493292f, -0.03835869f, 0.04934697f, -0.17351985f, 0.07643633f, 0.29074895f, 0.13187867f, 
    -0.03619874f, 0.02919331f, 0.02981243f, 0.04666493f, -0.03107217f, -0.03367687f, -0.31511125f, -0.28408998f, 
    0.05174043f, -0.23206320f, -0.00830908f, 0.13004953f, -0.04972291f, -0.05885629f, 0.01829258f, 0.03453225f, 
    -0.10854555f, 0.02742601f, -0.25473270f, -0.23867601f, -0.16166367f, 0.12271611f, -0.05513615f, 0.03424853f, 
    0.13436303f, -0.05016253f, 0.00684481f, -0.04315449f, 0.16311942f, 0.02654008f, -0.05437379f, -0.12540285f, 
    0.06819966f, -0.01195095f, 0.14168365f, 0.05910349f, 0.03101790f, -0.05643356f, 0.18030468f, -0.16523413f, 
    0.28927052f, -0.26702338f, -0.15288177f, -0.01268335f, -0.09002550f, 0.00251296f, -0.06552307f, -0.04627720f, 
    -0.10725704f, -0.08156256f, -0.03943516f, 0.18572909f, -0.25442049f, -0.09078545f, -0.24042551f, 0.00949735f, 
    0.13215229f, -0.02337017f, 0.05183123f, 0.05171938f, 0.07283713f, 0.01578384f, -0.12097844f, 0.00493888f, 
    -0.05198438f, -0.01591485f, 0.09629197f, -0.01386256f, 0.05695634f, -0.00625510f, 0.00339097f, -0.06823549f, 
    -0.04753523f, -0.02966683f, -0.02582276f, -0.05278199f, 0.19243416f, 0.00015840f, -0.02774439f, -0.11185783f, 
    0.08782422f, -0.04746618f, -0.10704726f, -0.09866373f, 0.12809011f, -0.09009301f, 0.00757016f, -0.02313095f, 
    -0.70210242f, 0.21843173f, -0.69152433f, 0.08595408f, -0.06319813f, -0.02917604f, -0.04784009f, 0.08127164f, 
    -0.05548155f, -0.01512787f, -0.06763597f, 0.10865473f, 0.44723848f, 0.14070638f, 0.07090820f, -0.11500748f, 
    -0.00522907f, -0.11533792f, -0.12371453f, -0.11337270f, 0.02216519f, -0.14065287f, 0.07077514f, 0.04658966f, 
    0.19370452f, -0.05245021f, 0.06323755f, 0.00300039f, 0.05026033f, -0.03295466f, 0.03746869f, 0.03356545f, 
    -0.04468985f, 0.19928110f, -0.15018865f, -0.03474980f, 0.20421174f, 0.12768881f, 0.06835122f, 0.09309590f, 
    -0.00518159f, -0.08032084f, -0.06501158f, 0.10672192f, -0.00260501f, -0.02562293f, 0.11849753f, 0.05396212f, 
    0.18771991f, -0.05287145f, -0.00572083f, 0.16907610f, 0.02623824f, -0.03557415f, 0.02004997f, -0.01891177f, 
    -0.01113399f, 0.10324942f, -0.02176828f, 0.20071883f, 0.19509973f, 0.33593273f, -0.22382310f, -0.01784011f, 
    -0.04491451f, 0.01940034f, 0.00822199f, -0.04714042f, -0.12812683f, 0.05375461f, -0.08677706f, 0.13837467f, 
    0.08897755f, 0.02628901f, 0.07261360f, 0.09204983f, -0.03882409f, -0.03394215f, -0.00393439f, -0.01534936f, 
    0.10478817f, 0.06464427f, -0.01408171f, -0.00595768f, 0.10508116f, 0.01749547f, 0.01662984f, -0.02862935f, 
    -0.12452986f, 0.05361784f, 0.10100616f, -0.01253394f, -0.05705087f, 0.02391568f, -0.00642133f, -0.00656857f, 
    -0.41295639f, 0.21195613f, -0.17735501f, 0.13318139f, -0.12042707f, -0.01644978f, 0.03660841f, 0.05324120f, 
    -0.10689774f, -0.05572332f, -0.08998176f, 0.06393268f, 0.05737255f, 0.16447613f, 0.00102132f, -0.02754564f, 
    -0.02781378f, 0.09583928f, 0.04266085f, 0.01712448f, -0.04735794f, 0.04423810f, 0.20264252f, -0.25557429f, 
    0.01443322f, 0.18189545f, -0.03106836f, 0.09352846f, -0.08838695f, -0.06827284f, 0.09721431f, -0.00379617f, 
    -0.05399671f, 0.00731095f, -0.05521691f, -0.01540064f, 0.04241224f, -0.03840737f, 0.07057187f, 0.07307198f, 
    -0.02925455f, -0.00045269f, 0.00648588f, -0.14955585f, 0.13192302f, -0.11642731f, 0.00673754f, -0.24353716f, 
    -0.48437747f, -0.08992227f, 0.04992210f, -0.05699308f, 0.19815058f, 0.07681331f, -0.23782548f, 0.11051048f, 
    -0.07492581f, 0.02686154f, -0.01588113f, 0.04149164f, -0.57169646f, -0.08995064f, -0.36125544f, 0.16502732f, 
    -0.12501432f, -0.05580067f, 0.34149003f, -0.12515014f, -0.06198086f, 0.02211414f, 0.01347833f, -0.02212154f, 
    -0.02908627f, -0.18430628f, -0.02254194f, 0.07647289f, 0.00054970f, -0.02487100f, 0.01205688f, -0.02661626f, 
    -0.08563622f, 0.03706728f, 0.08035229f, 0.03486962f, 0.08486212f, 0.07014374f, 0.07603407f, -0.02822107f, 
    0.00736952f, -0.10641885f, 0.08450278f, 0.10009491f, 0.06906569f, 0.03473026f, -0.03940270f, -0.19929591f, 
    0.17667639f, 0.04366358f, 0.10386804f, 0.01948491f, -0.10962674f, -0.13397677f, 0.05368569f, 0.06470399f, 
    -0.05039061f, 0.23450337f, -0.07598885f, 0.02703268f, 0.11003146f, -0.21832071f, -0.10082662f, -0.11865785f, 
    0.01955613f, 0.05333266f, 0.11664865f, 0.23063274f, -0.05168264f, 0.00917077f, 0.03493717f, 0.10801252f, 
    -0.64231527f, -0.11310964f, 0.20359221f, 0.12771165f, 0.04228618f, -0.02157558f, 0.03642257f, 0.01762365f, 
    0.03262984f, 0.01107523f, 0.06758597f, -0.16709791f, 0.26792473f, 0.16457739f, 0.03590692f, -0.02548537f, 
    0.03687136f, 0.03058619f, -0.09426859f, -0.11715636f, -0.01371725f, 0.00807140f, -0.00846803f, -0.05067406f, 
    0.20529014f, 0.05139375f, 0.05567100f, -0.02410063f, 0.07286455f, -0.11652449f, -0.03003736f, 0.01488631f, 
    -0.03538877f, -0.05433173f, -0.00543486f, 0.03589218f, 0.60850734f, -0.20166372f, 0.03028496f, 0.01606981f, 
    0.11233461f, -0.07147707f, -0.03644878f, -0.04333959f, -0.00153469f, -0.07634482f, 0.14328517f, -0.08435374f, 
    0.17162639f, 0.14155430f, 0.17587388f, 0.20694023f, -0.02187743f, -0.02043018f, -0.00215389f, -0.02616876f, 
    -0.00003258f, 0.01701809f, -0.04907880f, 0.02865011f, 0.14169706f, -0.05814701f, -0.35935149f, 0.23975757f, 
    0.07153153f, 0.05282520f, 0.03945353f, -0.14430046f, 0.10492465f, 0.14716810f, 0.04972688f, 0.09156404f, 
    -0.23372790f, 0.05094190f, -0.08760647f, 0.00278918f, 0.01691468f, -0.00921295f, 0.17575890f, 0.20175180f, 
    0.13521563f, 0.00438456f, 0.13021134f, -0.02084557f, -0.11692682f, 0.07116967f, -0.05496459f, 0.03330233f, 
    0.15938103f, 0.06977284f, 0.03766269f, -0.09249095f, -0.00229063f, 0.03980416f, -0.01098162f, 0.11804876f, 
    0.34649393f, 0.02383293f, 0.05096424f, -0.19066326f, 0.03557373f, -0.04481426f, 0.05053299f, -0.06500635f, 
    -0.03435786f, 0.01417666f, 0.01044375f, 0.04448709f, -0.10096386f, 0.00644238f, -0.05171664f, -0.01538920f, 
    -0.10624176f, 0.02213091f, -0.02846327f, 0.02322364f, 0.00677928f, -0.05900846f, -0.10184360f, 0.05227730f, 
    -0.01518214f, 0.02928540f, 0.00609824f, 0.08232252f, 0.06703008f, 0.01642496f, -0.15920666f, -0.03543897f, 
    -0.13838905f, -0.01896898f, -0.07776201f, 0.02392334f, 0.23927070f, 0.12507975f, -0.07777559f, -0.21245022f, 
    -0.07161137f, -0.11088981f, -0.11494813f, 0.12764783f, 0.03444976f, -0.01507899f, -0.01890702f, -0.12069417f, 
    0.26112407f, -0.19098188f, 0.23559994f, 0.15108132f, -0.03926879f, -0.00811729f, 0.01798271f, 0.02574313f, 
    0.00637537f, 0.06333999f, 0.07301656f, 0.00601056f, 0.05942096f, 0.20817263f, -0.04395863f, -0.05714292f, 
    -0.02833899f, 0.06170222f, 0.00911410f, -0.07668980f, -0.06769484f, 0.02421367f, 0.01901595f, 0.02940586f, 
    0.14522731f, -0.02313983f, -0.07915185f, -0.05152508f, -0.05552015f, 0.01891305f, -0.11454566f, 0.00758736f, 
    -0.08784398f, -0.03396473f, 0.19226475f, 0.05724907f, -0.19977468f, 0.30512822f, 0.34153178f, 0.24496192f, 
    -0.18857272f, -0.07417750f, 0.06760453f, -0.10624082f, 0.00112665f, -0.01120732f, 0.02358954f, -0.06861146f, 
    0.11683153f, -0.14677572f, -0.13857174f, -0.00715669f, -0.00086090f, 0.01671164f, -0.08642811f, -0.00282380f, 
    -0.05204163f, 0.12029837f, -0.17006406f, -0.04631426f, 0.04761111f, 0.06044102f, -0.30255666f, -0.07647917f, 
    0.06258001f, 0.00724620f, 0.02474767f, 0.06511699f, 0.01655458f, 0.04916101f, -0.01203023f, -0.03772918f, 
    -0.42909902f, -0.10956819f, 0.18161428f, -0.12123806f, 0.04861484f, -0.04203387f, -0.11409275f, 0.08060428f, 
    0.01470468f, -0.00342802f, -0.03832044f, 0.03716111f, -0.10900281f, -0.08661778f, 0.05574988f, 0.21827230f, 
    0.10492037f, 0.12110492f, -0.06229400f, 0.00344867f, 0.00688214f, -0.07354348f, 0.06168355f, 0.05551368f, 
    -0.01088511f, 0.21517649f, 0.05019185f, 0.02539810f, -0.02550946f, 0.09009154f, -0.00266830f, -0.08008040f, 
    -0.08898816f, 0.04987158f, -0.06053383f, 0.00267260f, -0.12354659f, 0.09872768f, -0.24507363f, -0.40717289f, 
    0.05456023f, 0.06228451f, -0.01284915f, 0.03834193f, -0.03432712f, 0.02157739f, -0.26891226f, 0.08859834f, 
    -0.05642938f, 0.01761829f, 0.23398055f, -0.06647581f, -0.14512061f, -0.06259778f, 0.09771203f, -0.10370117f, 
    -0.01211675f, 0.00617449f, 0.07212760f, -0.02019046f, -0.48035008f, 0.36157331f, 0.01682550f, 0.10328793f, 
    0.01039254f, 0.18079032f, -0.05099343f, 0.04342531f, 0.03437107f, 0.07355214f, 0.10942709f, 0.07205437f, 
    -0.03964489f, 0.00651987f, 0.33492982f, -0.06517257f, 0.01026265f, -0.00760467f, 0.00837805f, -0.03072321f, 
    0.11254901f, 0.16515493f, -0.00421892f, 0.08706404f, -0.55197930f, -0.26578331f, -0.17748305f, -0.19525293f, 
    -0.09822873f, -0.02087270f, -0.08997354f, 0.05353646f, 0.04085281f, 0.08066443f, -0.02248844f, -0.05063322f, 
    -0.91836292f, -0.54996055f, -0.42867300f, -0.51463914f, -0.01941472f, 0.08647840f, -0.01302150f, -0.19049838f, 
    -0.04298907f, 0.04122484f, 0.02609394f, -0.05859805f, -0.24517234f, -0.03895243f, 0.29481047f, 0.19543886f, 
    -0.10330490f, -0.13827848f, 0.00733114f, -0.08287913f, -0.03427880f, -0.04609215f, -0.05260285f, 0.04481839f, 
    0.06671073f, 0.36085382f, 0.06626445f, 0.13913965f, -0.03792639f, -0.04766987f, 0.07121977f, -0.00490802f, 
    0.04094888f, 0.06694593f, -0.01213341f, 0.14803535f, -0.16367586f, 0.27537990f, -0.06911806f, 0.07464883f, 
    0.02597726f, -0.01437565f, -0.11240489f, 0.00624552f, 0.00849663f, 0.01051895f, 0.09147735f, -0.29295453f, 
    -0.01606277f, -0.09394433f, 0.02170310f, -0.09332212f, -0.01655865f, -0.00408550f, -0.03899370f, 0.02370283f, 
    0.02175429f, -0.08108665f, 0.12541151f, -0.12606029f, -0.05580967f, 0.01347529f, 0.00299397f, 0.03343391f, 
    -0.09099350f, 0.04081726f, -0.10078160f, -0.27358332f, 0.02952995f, 0.00645594f, 0.03115168f, -0.01272406f, 
    -0.04572530f, -0.19702753f, -0.14352936f, 0.14847960f, 0.14989473f, 0.07442347f, -0.23260725f, 0.06685349f, 
    -0.01333121f, -0.08240925f, 0.03277238f, -0.04988408f, -0.16232340f, 0.06754587f, -0.07033918f, -0.12929450f, 
    0.00513947f, 0.00859100f, 0.01399817f, -0.12651654f, 0.07304968f, 0.11943185f, 0.10225593f, 0.04161359f, 
    -0.13029486f, -0.11751944f, -0.01614182f, -0.11256625f, -0.09737304f, -0.00742344f, -0.08921280f, -0.07770817f, 
    -0.04022265f, -0.11734837f, 0.02673459f, -0.02966089f, 0.22186905f, 0.05819249f, 0.08515313f, 0.22011998f, 
    -0.02987040f, 0.06578685f, 0.07714638f, -0.08943212f, -0.03921750f, 0.01661212f, -0.00129214f, 0.03248918f, 
    -0.25200275f, 0.15910408f, 0.57521152f, 0.27174827f, -0.13392702f, -0.11290503f, 0.01898644f, 0.14093144f, 
    -0.06705472f, 0.00262385f, 0.01155597f, -0.08048537f, 0.05361738f, -0.01614374f, -0.10403518f, 0.13414800f, 
    -0.03584398f, 0.04621333f, 0.02920878f, 0.08115858f, 0.01321634f, 0.03245968f, -0.07645810f, 0.05727938f, 
    -0.29548928f, -0.25840881f, -0.43390316f, -0.02852804f, -0.15533976f, -0.10243988f, -0.00919650f, -0.01134204f, 
    0.00361118f, -0.02658338f, -0.01764163f, -0.01180135f, -0.30735561f, -0.17886828f, 0.21539621f, -0.15906720f, 
    -0.00470497f, -0.04463505f, -0.14387184f, -0.11480530f, 0.02507543f, -0.01853396f, 0.03289552f, -0.03216722f, 
    -0.00376248f, 0.21332841f, -0.23412603f, 0.06314386f, -0.04792865f, 0.03046138f, -0.12992895f, 0.10024948f, 
    -0.04432733f, 0.06114510f, 0.02960705f, -0.12086503f, 0.11278639f, -0.19524142f, 0.23245478f, 0.20975131f, 
    0.06946603f, 0.02530964f, 0.01957283f, 0.04452033f, -0.00536341f, -0.29721788f, 0.02731891f, 0.13354230f, 
    -0.10924625f, 0.14933278f, 0.26616475f, 0.05384385f, -0.01771333f, -0.02027397f, 0.01481011f, -0.01866674f, 
    -0.01368352f, -0.14151455f, 0.10202816f, 0.04724662f, -0.10175393f, 0.02431384f, 0.01991551f, -0.12525731f, 
    0.07766664f, 0.03194854f, -0.04717685f, -0.08092947f, 0.03994344f, 0.04710158f, -0.00951605f, 0.00413798f, 
    -0.00690389f, -0.06273542f, 0.05254875f, -0.00665997f, -0.09450832f, 0.00655735f, -0.04506126f, 0.03388444f, 
    -0.01012697f, -0.08486631f, 0.03844726f, -0.08541657f, -0.02191356f, 0.03841753f, 0.00841327f, 0.04239102f, 
    0.02821441f, 0.14725235f, -0.08339573f, 0.00284802f, 0.06347102f, 0.14387612f, 0.05809732f, 0.06439690f, 
    -0.13083291f, 0.06344938f, -0.24334836f, 0.03276593f, -0.09402578f, -0.03088188f, -0.25507143f, 0.03521642f, 
    0.03205218f, -0.03742800f, -0.01425330f, 0.00878989f, -0.38146931f, 0.18045175f, -0.16781022f, -0.17238128f, 
    0.02985121f, 0.08439713f, 0.05309538f, 0.02490189f, 0.03867521f, -0.10050362f, 0.00777428f, -0.03048102f, 
    0.03317720f, -0.20188753f, 0.03979190f, 0.02570804f, 0.00461225f, -0.00651319f, 0.02290556f, -0.02210028f, 
    0.02769624f, -0.01006277f, -0.24532852f, 0.12600186f, -0.00726412f, -0.10115594f, -0.07046966f, -0.10539374f, 
    -0.00299812f, -0.06611346f, 0.01003506f, 0.04752507f, -0.08979697f, -0.04263841f, -0.07599898f, 0.02423310f, 
    0.05671175f, -0.26125351f, 0.05093655f, 0.03214107f, 0.02146716f, -0.04203354f, 0.03280352f, 0.03291374f, 
    -0.00759672f, 0.01215927f, -0.21879728f, 0.00826453f, -0.11284862f, 0.00054607f, -0.01052092f, 0.19495173f, 
    0.06697355f, -0.00277653f, 0.00265381f, 0.03149081f, 0.01978978f, -0.14823709f, 0.08123665f, 0.06511999f, 
    -0.10902909f, -0.01187727f, 0.00111584f, -0.02097023f, -0.04757906f, -0.01531658f, 0.05265078f, 0.00060351f, 
    -0.12236087f, 0.07008647f, -0.08076193f, 0.03486568f, -0.01489033f, -0.07402358f, -0.12124193f, -0.02996564f, 
    0.10950085f, 0.05598619f, 0.13975793f, 0.01929480f, 0.00963769f, -0.05163048f, -0.04716749f, 0.00417197f, 
    0.00904435f, -0.13665693f, -0.15078633f, 0.27801704f, 0.15206110f, -0.01693314f, -0.00664915f, 0.13747035f, 
    0.14152469f, 0.00536266f, -0.07613931f, 0.02717443f, 0.05218133f, 0.00902156f, 0.04350036f, -0.02910308f, 
    0.01603499f, 0.00959079f, -0.00723733f, 0.15665644f, -0.00089127f, -0.00219940f, 0.04753960f, -0.02055798f, 
    -0.33640456f, -0.09202468f, -0.34275377f, -0.22846346f, 0.11490681f, 0.05369499f, -0.06164033f, 0.04729831f, 
    -0.01561383f, 0.02393870f, -0.01331235f, -0.05294625f, 0.09501963f, -0.14414085f, 0.16195151f, 0.08015629f, 
    -0.06184322f, 0.02800658f, 0.07064716f, 0.05023000f, 0.16876455f, 0.04940544f, 0.05805625f, -0.11056671f, 
    0.47829488f, -0.02240222f, 0.05638231f, 0.25225765f, -0.00256961f, 0.14867616f, -0.16695030f, -0.05848856f, 
    0.00726798f, -0.04576353f, 0.00320489f, 0.06446201f, 0.01729920f, -0.38327482f, -0.54201746f, 0.11904287f, 
    -0.06397128f, 0.05038767f, 0.12180944f, -0.00860631f, 0.04241346f, 0.03213953f, -0.00825506f, 0.02637777f, 
    0.01837390f, -0.13547884f, 0.15742166f, 0.10666633f, 0.01835815f, -0.04216536f, 0.08686691f, 0.12839818f, 
    -0.03251523f, 0.00990595f, -0.05774599f, -0.03667427f, -0.15453020f, 0.16177644f, -0.06704264f, -0.16758814f, 
    0.04430837f, 0.01890768f, 0.05628492f, 0.03892899f, -0.05690422f, 0.00684089f, 0.10092790f, -0.01328430f, 
    0.11195652f, 0.05266080f, -0.11013016f, -0.18171780f, 0.15619694f, -0.17240512f, -0.11823474f, 0.04971527f, 
    0.04367284f, -0.33378637f, -0.09154075f, -0.03722633f, -0.48527670f, -0.36900461f, -0.07684681f, -0.26891756f, 
    -0.00974340f, -0.02657786f, 0.03839785f, -0.10501304f, -0.01263977f, 0.01304751f, -0.13687292f, -0.11217973f, 
    -0.07418714f, -0.11274849f, -0.02636859f, 0.28406018f, 0.02371355f, 0.02264955f, 0.00718992f, -0.05034555f, 
    0.01094826f, -0.11550917f, 0.02252996f, -0.06596603f, 0.28076470f, -0.07805715f, 0.49298197f, 0.34474671f, 
    -0.02822210f, 0.03338913f, -0.12048370f, 0.12235653f, 0.03256134f, 0.03600370f, 0.04816623f, 0.05362848f, 
    -0.31965286f, -0.08818679f, 0.21533796f, -0.40177852f, 0.02407238f, -0.07458901f, -0.14787677f, 0.05462332f, 
    0.04441524f, 0.01244930f, -0.05855550f, 0.07172444f, -0.20119834f, 0.22493838f, 0.34586623f, 0.00991279f, 
    0.03485140f, -0.03523089f, 0.06271452f, -0.12450051f, 0.10349443f, 0.08418144f, 0.02598819f, 0.04267944f, 
    -0.22039548f, -0.02429161f, -0.10266870f, 0.02805416f, -0.06843215f, -0.03530918f, 0.04827090f, 0.06738499f, 
    -0.05180971f, -0.02120784f, 0.01022594f, 0.05163631f, -0.02054684f, 0.20558454f, -0.01433498f, 0.22600371f, 
    -0.06904840f, 0.00870334f, -0.04551125f, 0.28959340f, 0.06403004f, -0.01280208f, 0.18261674f, -0.09815910f, 
    0.10318688f, 0.11389206f, -0.10644417f, 0.04092447f, 0.02968701f, -0.06115603f, -0.13872570f, 0.13417040f, 
    -0.08791976f, 0.07091852f, -0.06485542f, 0.05887466f, -0.02114180f, -0.02682361f, -0.14746422f, -0.05881389f, 
    0.07583985f, -0.03104907f, -0.14193583f, -0.02540652f, -0.02518627f, -0.00257061f, -0.00632246f, -0.04794680f, 
    -0.21853815f, 0.05713976f, -0.11862137f, -0.13101818f, -0.02505054f, -0.04792440f, -0.07303885f, 0.02973689f, 
    -0.00970122f, -0.03888375f, -0.26354000f, 0.20379408f, 0.04900991f, -0.02778834f, -0.02101202f, 0.08799318f, 
    0.05821964f, -0.01787657f, -0.12327547f, 0.10062125f, 0.02784056f, 0.05668824f, 0.07895918f, 0.06067976f, 
    0.05651454f, -0.23389137f, -0.25083536f, 0.04400442f, 0.14356181f, -0.07352788f, 0.03120331f, 0.08254533f, 
    0.00704979f, -0.01677996f, -0.00002065f, -0.01475954f, -0.05265261f, 0.18908218f, 0.43117681f, 0.20341615f, 
    -0.06977525f, -0.06142174f, -0.04294809f, -0.05488919f, 0.03416739f, 0.01153229f, -0.05354437f, -0.00312747f, 
    0.16882071f, 0.14763848f, -0.34483114f, -0.08298454f, 0.03812820f, -0.10882659f, 0.11497830f, 0.08541997f, 
    -0.13835646f, 0.04662947f, -0.01096960f, -0.00351968f, -0.18768145f, 0.14705031f, -0.18398577f, -0.10867003f, 
    -0.02743609f, -0.04882057f, 0.02869991f, 0.06879991f, -0.02422617f, -0.04274423f, 0.02970514f, 0.00282240f, 
    0.02219731f, 0.06603329f, 0.02977853f, 0.02011439f, -0.06763711f, -0.04615174f, -0.11383376f, -0.03556492f, 
    0.00952531f, 0.07146282f, -0.00774215f, -0.08335429f, 0.30594736f, -0.11450266f, 0.01713949f, 0.20066036f, 
    0.01684162f, -0.13880126f, 0.01239252f, 0.02838122f, 0.01454582f, 0.03673792f, -0.01806748f, 0.08970355f, 
    0.52160043f, 0.08194466f, 0.06042729f, -0.11370930f, 0.01323760f, 0.05686062f, -0.05775672f, 0.02884490f, 
    -0.10759197f, 0.06374332f, 0.08611658f, -0.08660825f, -0.05039807f, 0.01226801f, -0.18056974f, -0.49991149f, 
    0.01579581f, 0.03189673f, -0.13014325f, 0.20727737f, -0.12196823f, -0.06754760f, 0.04275692f, -0.05237297f, 
    0.09263545f, -0.25392401f, 0.28665259f, 0.09928800f, -0.25656563f, 0.00754009f, 0.01364984f, 0.04721433f, 
    0.02436460f, 0.09611290f, -0.01339504f, 0.00649325f, 0.19300058f, 0.06381521f, -0.09360763f, -0.07107344f, 
    0.01143583f, 0.00035194f, -0.00439561f, 0.11863025f, 0.08699813f, -0.01523501f, 0.17240757f, -0.08190974f, 
    -0.14751616f, 0.04494115f, -0.02187133f, 0.10312372f, 0.02399805f, 0.01092815f, -0.01174595f, -0.10457675f, 
    -0.05109458f, 0.08239776f, -0.10378779f, 0.02652141f, 0.01048236f, -0.27636918f, 0.17293678f, 0.02636204f, 
    -0.02638576f, -0.00250837f, -0.10098387f, 0.10285331f, -0.17429987f, 0.15131998f, -0.15994993f, 0.12009638f, 
    -0.17504042f, 0.07364377f, 0.02612775f, 0.19379821f, 0.06040735f, -0.01354979f, 0.03179404f, -0.10304400f, 
    -0.14854963f, 0.05015252f, -0.10521289f, 0.01142224f, -0.31853214f, 0.09061176f, -0.21875715f, 0.14017342f, 
    -0.07160102f, -0.05592537f, -0.02537119f, -0.08048952f, -0.12918149f, -0.05606808f, 0.03341177f, -0.11839804f, 
    -0.04575057f, -0.02529693f, 0.00068584f, 0.25409263f, -0.00270152f, 0.04136143f, -0.06203908f, -0.02756329f, 
    0.01698751f, 0.02372052f, -0.03487927f, 0.02661175f, 0.03265512f, -0.17002304f, -0.04622518f, 0.13609535f, 
    0.09565914f, 0.05084057f, -0.03581747f, 0.13876426f, 0.05839100f, 0.01564022f, 0.00172664f, -0.01442585f, 
    -0.02207004f, -0.22324626f, -0.00644328f, 0.13383693f, -0.02094623f, 0.09688397f, 0.09439569f, 0.03764187f, 
    0.02413493f, -0.01024522f, -0.14793760f, -0.13715756f, 0.23750514f, -0.22393622f, 0.02952935f, 0.19532441f, 
    0.06675274f, -0.05737875f, -0.02593471f, -0.06621294f, 0.00569173f, 0.02976874f, -0.00570407f, 0.13759023f, 
    -0.00597984f, -0.04393430f, 0.07351649f, 0.26014131f, 0.04173900f, 0.02286001f, 0.00454641f, -0.10115263f, 
    -0.00050328f, 0.01224041f, -0.00887207f, 0.01896377f, -0.38891634f, -0.14164299f, -0.01938913f, -0.24071336f, 
    0.21294025f, 0.03319354f, -0.01847826f, 0.06824808f, 0.04650272f, 0.06971600f, -0.02183929f, -0.05319028f, 
    -0.01709446f, 0.23325498f, -0.15593918f, -0.23109081f, 0.18110910f, 0.07697222f, 0.00856254f, -0.04651707f, 
    -0.00524123f, 0.03165692f, 0.09774241f, -0.04369367f, -0.12131976f, -0.04559695f, 0.00247306f, 0.10407500f, 
    -0.02852947f, 0.06625835f, 0.03867789f, 0.04702468f, 0.07784204f, 0.06267021f, 0.07579595f, -0.10684696f, 
    0.26192644f, -0.02543403f, -0.02653982f, -0.04263731f, -0.16100626f, -0.08318625f, -0.09275734f, 0.02730056f, 
    0.01517513f, 0.25003728f, -0.07413284f, 0.03014455f, -0.20388460f, -0.06391302f, -0.09164707f, 0.09059641f, 
    0.00557437f, 0.00718314f, 0.07112312f, -0.14285558f, 0.00995388f, 0.08889058f, -0.01523340f, 0.05701239f, 
    -0.04311396f, -0.07833286f, 0.13439146f, 0.04546527f, -0.02474698f, -0.06171167f, 0.09966869f, 0.05817538f, 
    0.11218066f, 0.07256829f, 0.06159595f, -0.07969851f, -0.01087166f, -0.12408844f, -0.11826856f, 0.16739461f, 
    0.06729435f, -0.00450182f, 0.00037886f, 0.01043588f, 0.00185135f, 0.10853156f, -0.03301771f, 0.03825851f, 
    -0.18482070f, -0.07787413f, -0.00982912f, 0.10246019f, 0.08762147f, -0.00638827f, -0.08701059f, -0.14538577f, 
    -0.00136935f, 0.01834754f, 0.11644456f, -0.01357221f, 0.04390036f, -0.01124311f, -0.11759574f, -0.41207865f, 
    0.06901070f, 0.07295855f, 0.04691230f, 0.04797364f, 0.03955739f, 0.05307931f, -0.25983274f, -0.05084119f, 
    0.04276606f, 0.15762821f, -0.19399619f, 0.24674809f, -0.06322881f, 0.02642652f, -0.00490102f, 0.19639647f, 
    -0.07067604f, -0.04224693f, 0.04345419f, 0.01427768f, 0.01687288f, -0.25436705f, 0.04714370f, 0.21826878f, 
    0.03059578f, 0.17068350f, 0.05419299f, 0.00017812f, 0.07728938f, -0.01711829f, 0.05272371f, -0.11703074f, 
    -0.51377910f, 0.55331206f, 0.04433395f, -0.28028917f, 0.02517513f, 0.01258073f, -0.05314581f, -0.07166619f, 
    -0.24248214f, -0.09210169f, 0.06656533f, 0.08643736f, -0.10359410f, -0.02798021f, 0.23774582f, 0.00371754f, 
    0.00725781f, 0.06682967f, -0.05928595f, -0.15591680f, -0.06840557f, -0.22412996f, -0.06809457f, 0.12534176f, 
    0.17263968f, 0.04863268f, -0.02032914f, 0.13290873f, 0.33679169f, 0.22481658f, 0.16463172f, 0.16560468f, 
    -0.12051533f, -0.01698521f, 0.00639893f, 0.04445439f, -0.05628387f, 0.07599210f, -0.15169527f, 0.08380315f, 
    0.02142674f, 0.04806183f, -0.04574649f, 0.00883552f, -0.09783248f, 0.06680349f, 0.02690106f, 0.01240533f, 
    0.41769624f, 0.02672851f, -0.08297031f, 0.28241536f, 0.01921331f, 0.06992964f, -0.09188190f, -0.03124421f, 
    0.01633965f, -0.05396111f, 0.15558873f, -0.02693403f, -0.33080864f, -0.05597628f, -0.09972697f, 0.08330828f, 
    -0.00588529f, -0.05933213f, 0.23354651f, -0.12292480f, 0.04211713f, -0.08844763f, 0.10373966f, 0.00764129f, 
    0.00232119f, 0.10328086f, -0.22581689f, 0.21738447f, -0.02945809f, -0.14464343f, 0.10275836f, 0.12761381f, 
    -0.08126387f, 0.00863346f, -0.15819888f, 0.13000083f, -0.41616842f, 0.69556993f, -0.09452360f, 0.70996302f, 
    -0.18489003f, -0.15031096f, 0.16461137f, -0.08919994f, 0.12194441f, 0.04845050f, 0.06755469f, -0.03557335f, 
    -0.31728783f, 0.01026624f, -0.16725242f, -0.33218861f, -0.16368371f, -0.07383472f, -0.00172395f, -0.04583231f, 
    0.02222318f, 0.06225738f, 0.00729720f, -0.10256595f, 0.35753682f, -0.11101970f, 0.57807600f, 0.17957005f, 
    -0.09084298f, -0.04913935f, 0.00923213f, 0.07120120f, 0.10372641f, 0.09030953f, -0.05229737f, 0.05048624f, 
    0.13276397f, 0.00064218f, -0.31755856f, -0.36911091f, 0.06111958f, -0.09797436f, 0.01853732f, -0.26358199f, 
    -0.12932594f, 0.09689012f, 0.00381090f, -0.04973548f, 0.32313231f, -0.16433591f, 0.14717163f, -0.35186034f, 
    0.26984701f, 0.24466737f, -0.00183245f, 0.10682809f, -0.07912714f, -0.07910279f, 0.12307459f, -0.01227827f, 
    -0.25537875f, -0.31731603f, -0.11056118f, -0.12523068f, 0.04022051f, -0.29650182f, -0.03427029f, -0.05070771f, 
    -0.10445358f, 0.02821062f, -0.13778935f, -0.15036654f, 0.05118730f, -0.02992500f, 0.03930728f, 0.05831244f, 
    -0.14985974f, 0.03621465f, 0.10008164f, 0.03614508f, 0.05653106f, -0.00096823f, -0.05720291f, -0.12922791f, 
    0.11566475f, -0.12143852f, -0.20213671f, -0.60735637f, 0.18936099f, -0.03883971f, -0.09738217f, -0.04381397f, 
    -0.09538382f, 0.09727217f, -0.17670229f, 0.00918762f, -0.24443662f, 0.05728654f, 0.04246484f, 0.11343379f, 
    0.04318889f, 0.00978990f, -0.21429305f, -0.11765338f, -0.07707748f, -0.40523022f, 0.12290426f, 0.00756378f, 
    -0.04084568f, -0.08720885f, -0.05209138f, 0.00803938f, 0.03694957f, 0.07171360f, -0.03876497f, 0.05601414f, 
    0.00762134f, 0.02029032f, -0.02422728f, -0.19414595f, -0.08320025f, 0.58304113f, -0.18452843f, -0.44657707f, 
    0.13673437f, 0.02529526f, -0.00717286f, 0.00399608f, -0.17758138f, -0.08482742f, -0.11931624f, 0.00673869f, 
    0.54558140f, 0.07934709f, -0.06878675f, 0.13947417f, 0.02918097f, -0.01730214f, 0.00156998f, -0.14234096f, 
    -0.14740425f, 0.01414638f, -0.16039889f, 0.13572074f, -0.01129812f, 0.00000283f, -0.37218943f, -0.18577190f, 
    -0.07716826f, 0.07267231f, -0.06911253f, 0.06854407f, 0.01400303f, -0.06238580f, 0.10323346f, -0.06508118f, 
    0.00610089f, 0.26018324f, -0.09830514f, 0.00414685f, 0.15626124f, 0.07448950f, -0.01802733f, 0.13424793f, 
    -0.13735698f, 0.01904081f, -0.00883252f, -0.11352914f, -0.24360125f, -0.47452688f, 0.01329553f, 0.02526927f, 
    -0.01635070f, 0.05255532f, 0.01715958f, -0.13602790f, -0.19013529f, 0.05150248f, -0.02672346f, 0.01632183f, 
    0.07617249f, 0.05319164f, 0.05705522f, 0.37878346f, -0.00726731f, 0.04685884f, -0.31823727f, -0.07107597f, 
    -0.04948879f, 0.08416680f, 0.17704765f, -0.05833848f, 0.01028281f, -0.07602956f, 0.09545372f, 0.10760485f, 
    -0.00664181f, 0.06076739f, 0.13213912f, 0.15620694f, -0.03970783f, -0.07415503f, 0.04601651f, 0.04703224f, 
    0.09369405f, 0.60072976f, -0.37271848f, -0.58452100f, -0.00736955f, 0.06719457f, -0.03463186f, -0.03210811f, 
    -0.22063956f, -0.07712066f, 0.05254104f, 0.02567226f, -0.00135792f, -0.11509632f, 0.03848269f, 0.21568389f, 
    0.06450359f, -0.04435274f, 0.06069651f, -0.19985782f, -0.06148169f, 0.00552339f, 0.08282797f, 0.04053547f, 
    -0.53676784f, -0.44873121f, 0.37454426f, 0.07141431f, -0.35445043f, -0.01279045f, -0.16160305f, 0.01715829f, 
    0.16185953f, 0.04437876f, -0.11245011f, 0.11494127f, -0.26241836f, 0.13067228f, -0.01471549f, 0.20274463f, 
    -0.03465749f, 0.08596158f, 0.00767747f, -0.10470608f, -0.01876961f, -0.04967939f, -0.03783972f, 0.06657906f, 
    -0.40259358f, -0.51268488f, -0.11937501f, -0.20782067f, -0.29299933f, 0.00449583f, -0.12696998f, 0.08982415f, 
    -0.08290765f, 0.11436616f, -0.05024833f, 0.05315192f, 0.02025038f, 0.09599334f, -0.02791007f, -0.09586567f, 
    0.06810993f, -0.08824372f, -0.02840614f, -0.12595665f, -0.12555790f, -0.09088002f, -0.02733565f, 0.03473527f, 
    -0.09343250f, 0.26908624f, -0.18272625f, -0.12117693f, -0.07491388f, 0.05317598f, -0.05120897f, 0.02532893f, 
    0.01315838f, -0.05971380f, -0.12489706f, -0.00911083f, 0.32766670f, -0.09767710f, -0.19012393f, -0.06340667f, 
    -0.02289958f, -0.06553942f, -0.04852157f, 0.02394360f, -0.14450598f, 0.06522998f, -0.04701445f, -0.01711835f, 
    -0.71514684f, 0.14700481f, -0.00330872f, 0.45690188f, -0.10496849f, -0.17178443f, 0.01595487f, -0.00276973f, 
    -0.19011077f, 0.13666353f, -0.07077620f, 0.07206940f, -0.12427434f, 0.07695076f, -0.10330899f, 0.03091766f, 
    0.02128030f, 0.00479782f, 0.00189788f, -0.03082651f, -0.07440396f, -0.03997900f, -0.06320026f, 0.05717750f, 
    0.03902649f, -0.02327043f, -0.15565361f, 0.14914969f, 0.00630852f, 0.06222132f, 0.10224887f, -0.08088041f, 
    0.04947396f, -0.00663891f, 0.03225403f, -0.01531181f, 0.01017563f, 0.06995920f, -0.06201500f, 0.09469543f, 
    0.06926987f, -0.00788390f, 0.00250212f, 0.00079659f, 0.03799434f, 0.07512501f, -0.03822342f, 0.03998073f, 
    -0.16800842f, 0.52081162f, -0.55338734f, -0.38387427f, 0.03312972f, 0.09473656f, -0.07180229f, 0.04779623f, 
    -0.13500836f, -0.21673496f, 0.10101087f, 0.01159251f, -0.23777936f, 0.10842922f, -0.24883458f, 0.45400536f, 
    -0.02409700f, -0.32674256f, 0.04219768f, 0.08911648f, 0.06142220f, 0.01943872f, -0.02488271f, 0.19841893f, 
    -0.05651916f, 0.09992092f, 0.04764606f, 0.05582456f, -0.01169846f, -0.04192730f, -0.01165169f, -0.12291884f, 
    0.01167220f, 0.16892199f, 0.21249706f, 0.29207146f, 0.00454999f, -0.07544356f, 0.07637521f, 0.04256117f, 
    -0.09580594f, -0.10833537f, -0.02870443f, -0.10606889f, 0.03599442f, 0.00766178f, -0.00525509f, 0.06508759f, 
    0.16838728f, -0.17698644f, -0.23123211f, 0.09430324f, -0.07171430f, -0.01328870f, 0.11779035f, -0.00358286f, 
    -0.08379291f, -0.08435757f, 0.12325120f, 0.24319628f, 0.18391927f, -0.31495380f, 0.05606580f, 0.11433478f, 
    -0.04077256f, -0.11092038f, -0.07838910f, -0.08913725f, -0.02607197f, -0.00517087f, -0.14390543f, 0.00137342f, 
    0.17478862f, 0.18271032f, -0.43034390f, 0.16670391f, 0.03071393f, -0.01747569f, -0.09484942f, -0.13563944f, 
    0.04464072f, -0.02870683f, -0.01093009f, 0.05463821f, -0.10408901f, -0.09236534f, 0.06361356f, -0.09744492f, 
    -0.15448122f, -0.01808420f, 0.08384608f, 0.07277075f, 0.14835407f, -0.01086889f, -0.09202622f, 0.07689769f, 
    0.23645233f, 0.08804312f, 0.01586678f, 0.15300472f, -0.06305537f, -0.01371424f, -0.07440383f, 0.07624853f, 
    -0.08698188f, -0.19848986f, -0.04800455f, 0.05547257f, 0.07387850f, 0.19020467f, 0.06646492f, 0.16393897f, 
    0.00960601f, -0.14921018f, -0.03778771f, -0.10155285f, -0.15347286f, -0.15488562f, -0.13131155f, -0.28971234f, 
    0.08337089f, -0.03409633f, 0.11131018f, -0.00792035f, -0.05959574f, -0.06847747f, 0.08269525f, 0.01400473f, 
    -0.10293733f, 0.10040531f, 0.01346560f, 0.03023656f, 0.09395351f, -0.17089412f, 0.12862635f, -0.05166936f, 
    -0.15464592f, 0.15185231f, -0.26059943f, -0.02432447f, 0.03750877f, -0.00557112f, -0.05069741f, -0.05581925f, 
    -0.08374963f, -0.04567675f, -0.14535140f, -0.01204398f, -0.04144182f, -0.08416112f, 0.04567969f, 0.01121667f, 
    0.08178928f, -0.00670051f, 0.15917459f, 0.25790542f, 0.00448162f, 0.11157089f, 0.19118281f, 0.03049923f, 
    -0.12656023f, 0.05909760f, -0.05163533f, -0.02269632f, 0.04969718f, -0.01080741f, 0.07198773f, 0.09335332f, 
    0.00985636f, 0.22140184f, 0.15887654f, 0.18818331f, -0.11201959f, -0.02895137f, 0.01840361f, 0.19645591f, 
    -0.02358682f, 0.00964499f, -0.00349859f, 0.02200186f, -0.14890936f, -0.11676953f, -0.03158091f, 0.09378964f, 
    0.00298798f, -0.05983436f, 0.04103824f, -0.04063787f, 0.01832604f, 0.00249414f, 0.03186525f, 0.03651585f, 
    -0.06140317f, 0.17769626f, 0.03434761f, 0.06711113f, -0.03592805f, -0.11365577f, -0.02774642f, -0.02329099f, 
    0.06070434f, 0.02768359f, -0.17020375f, 0.06926640f, 0.08496276f, 0.02803808f, -0.13276441f, -0.04731376f, 
    -0.02795112f, -0.10520227f, 0.17218322f, -0.00387440f, -0.12511235f, -0.14510672f, -0.12054738f, -0.01046381f, 
    0.07738766f, 0.00241601f, -0.11074930f, 0.03051153f, -0.01925872f, 0.05712670f, 0.02629698f, 0.06131860f, 
    -0.01906789f, -0.10935926f, -0.18268576f, -0.32941791f, 0.09796063f, 0.08788900f, 0.10671835f, 0.10787619f, 
    0.05411437f, -0.03365511f, 0.00567793f, -0.05924083f, -0.09528240f, 0.10754374f, 0.10084827f, -0.01911323f, 
    -0.01459665f, 0.04485652f, -0.03971844f, 0.06475725f, 0.07567241f, -0.02118278f, 0.06356990f, -0.20580827f, 
    -0.11388082f, -0.10823220f, -0.09889071f, -0.04819895f, 0.03112944f, -0.01552627f, 0.11028062f, 0.00246644f, 
    0.02870783f, -0.09184457f, 0.05791765f, -0.08914333f, 0.07101544f, 0.10285079f, 0.21381855f, -0.02181686f, 
    0.02517511f, 0.06425498f, -0.14470330f, 0.11870653f, 0.08127076f, 0.03811428f, -0.45988315f, -0.18513615f, 
    -0.11434362f, 0.02260799f, -0.07003134f, -0.12274342f, 0.25465077f, 0.13879903f, 0.10142568f, 0.16482727f, 
    -0.10243126f, -0.07473790f, -0.07426867f, -0.07260410f, 0.04177117f, -0.09884290f, 0.04838939f, 0.01811795f, 
    -0.02139599f, 0.06392270f, 0.01471318f, 0.13939299f, -0.10864020f, 0.03350057f, 0.10478672f, -0.03888591f, 
    -0.08676818f, 0.05876909f, -0.02552900f, 0.17379093f, -0.02032958f, -0.00249972f, 0.04103164f, -0.00507478f, 
    -0.05944037f, -0.01869194f, 0.06431764f, 0.01042036f, 0.00857873f, 0.19158505f, 0.06928589f, 0.08486362f, 
    0.14805780f, 0.00222658f, 0.44083685f, 0.09053119f, 0.01513883f, 0.12627751f, -0.14328158f, 0.10549346f, 
    -0.00566484f, 0.04995504f, -0.00015487f, -0.08808481f, -0.02240117f, 0.24657820f, 0.19183043f, 0.17930388f, 
    0.12623060f, 0.15169241f, -0.21546404f, 0.18033063f, 0.00331855f, -0.00982066f, -0.06393767f, 0.03643838f, 
    0.00443458f, -0.61247891f, 0.08169023f, 0.18100634f, -0.02293753f, -0.01798409f, 0.08220939f, -0.10526807f, 
    -0.23610146f, 0.01376562f, 0.01986208f, 0.02047913f, 0.23045257f, 0.15885943f, -0.39627641f, 0.10364886f, 
    -0.02434521f, 0.04086629f, 0.07261618f, -0.09455001f, -0.06254248f, -0.03732214f, -0.04036605f, -0.09721590f, 
    -0.16621438f, 0.07140768f, 0.00946028f, 0.05455120f, -0.01465944f, 0.01398522f, 0.10334205f, 0.10739186f, 
    0.08782851f, -0.10346688f, -0.03210738f, -0.00829907f, 0.03244859f, 0.02761354f, 0.21490243f, 0.02209516f, 
    0.01144746f, -0.13019893f, -0.14468572f, -0.10114543f, -0.06607717f, -0.03563610f, 0.04790692f, -0.03936182f, 
    0.03467143f, -0.00043187f, -0.02109314f, 0.00138854f, 0.08150416f, 0.01752656f, -0.03085667f, 0.09945075f, 
    0.03951203f, -0.00876004f, 0.03782069f, -0.01509868f, 0.05381694f, -0.04615925f, 0.00296543f, -0.02891063f, 
    -0.02305616f, -0.02855173f, -0.17067234f, -0.16652393f, -0.05620627f, -0.08135562f, -0.03174542f, 0.00186740f, 
    0.20345107f, -0.08719299f, 0.50714630f, -0.01812045f, 0.01920043f, 0.00929258f, -0.12201624f, -0.00556624f, 
    -0.05539383f, 0.04092994f, 0.03812659f, -0.07112455f, 0.07916367f, -0.10215572f, 0.15755019f, -0.11004891f, 
    0.16118068f, -0.01846741f, -0.05092584f, 0.12748000f, -0.02441481f, 0.01932467f, -0.06371852f, -0.08233374f, 
    0.01063262f, -0.03221798f, -0.15388158f, -0.01296343f, -0.03004166f, 0.09396730f, 0.01604330f, -0.11674163f, 
    0.01286964f, -0.14517505f, 0.02051867f, -0.12534820f, -0.08666106f, 0.19677858f, -0.40572694f, -0.11567663f, 
    0.10530778f, 0.11851098f, -0.10686610f, -0.02344865f, 0.06854856f, 0.09848435f, 0.14317715f, 0.12797476f, 
    0.04397653f, -0.00443626f, -0.11485348f, -0.02331484f, -0.02838462f, 0.06338378f, -0.00844506f, 0.04923591f, 
    -0.20404541f, -0.22620985f, -0.17959742f, -0.05024287f, 0.22473067f, 0.11111648f, -0.22833620f, -0.01186540f, 
    -0.04308442f, -0.10881199f, 0.11189596f, 0.01535176f, 0.14472376f, -0.08259059f, -0.09057626f, -0.08321635f, 
    0.03943941f, 0.04875880f, -0.01886390f, -0.01869719f, 0.12614374f, 0.04546307f, 0.01250751f, 0.01509333f, 
    -0.04077157f, -0.04363040f, -0.01230716f, 0.02222717f, -0.00636046f, 0.00906264f, -0.00330618f, 0.04645789f, 
    0.12535946f, -0.09734903f, -0.28975427f, -0.09778637f, 0.08090146f, -0.04093723f, -0.00196325f, -0.04688573f, 
    -0.10175502f, -0.07871054f, -0.00546991f, 0.13253564f, -0.18187433f, -0.08961646f, -0.16818066f, -0.19887996f, 
    0.02340775f, -0.03126139f, -0.04639259f, -0.00612587f, 0.12042198f, -0.08615185f, -0.07208487f, 0.14480516f, 
    0.01560357f, 0.01154660f, -0.04308446f, -0.19938415f, -0.01332565f, -0.00800619f, -0.12608694f, 0.10117547f, 
    -0.00553116f, 0.05415750f, 0.20053743f, 0.16054711f, -0.06254674f, -0.09116128f, -0.10461343f, -0.13059542f, 
    0.01469703f, -0.01137677f, -0.01331592f, 0.02967689f, -0.02978220f, -0.16179402f, -0.01123803f, -0.04617579f, 
    -0.06354263f, 0.06305007f, 0.03418756f, 0.09598751f, -0.04038090f, 0.07188534f, 0.04361640f, -0.02312163f, 
    -0.14652424f, 0.08008417f, -0.01835141f, -0.00220343f, -0.13701536f, -0.11533743f, 0.03702208f, -0.19481072f, 
    -0.02706684f, -0.03531568f, 0.10754732f, -0.11492964f, 0.00972242f, -0.11578032f, 0.28104138f, 0.13505432f, 
    -0.22454596f, -0.00622926f, -0.19453703f, -0.03748653f, -0.01756147f, -0.03725047f, -0.01051497f, 0.00366264f, 
    0.25676167f, -0.28352571f, -0.00265097f, -0.00033074f, -0.03991415f, 0.03892290f, -0.02224912f, -0.01696607f, 
    0.17679401f, -0.06014336f, -0.01828033f, 0.01304807f, -0.00133752f, 0.00508420f, -0.05311849f, -0.07143985f, 
    0.07792386f, -0.05713573f, -0.10875883f, 0.14768620f, 0.03422517f, 0.05500688f, -0.12429945f, -0.12356995f, 
    0.17913491f, 0.05140689f, -0.11458670f, 0.17904085f, 0.08858968f, -0.07005992f, -0.05172739f, -0.08359679f, 
    -0.12975726f, -0.54110879f, 0.04448087f, -0.11000656f, 0.05573478f, 0.30402747f, 0.16577251f, 0.27419740f, 
    -0.00205103f, 0.08430803f, -0.03227511f, -0.02849794f, 0.10702240f, 0.03762634f, 0.08501819f, 0.07884137f, 
    -0.27925199f, -0.52931523f, -0.15085264f, -0.16927269f, 0.01108609f, 0.09441327f, 0.01596121f, 0.08620849f, 
    -0.06892428f, -0.02199674f, -0.02017137f, -0.01485662f, -0.09429218f, -0.03450100f, -0.03648801f, 0.07302584f, 
    -0.05463069f, -0.12160159f, -0.00500632f, -0.06563777f, -0.00916472f, -0.00209794f, -0.03683786f, 0.07724522f, 
    0.16968223f, 0.14940493f, 0.00199910f, 0.20499946f, 0.10772783f, 0.01459472f, 0.12939341f, -0.09230850f, 
    0.08748169f, 0.02321121f, 0.08988175f, 0.02739309f, -0.09943897f, -0.06202540f, -0.11096834f, -0.22129831f, 
    -0.10075960f, -0.02108295f, -0.10386906f, -0.08392342f, 0.03071693f, 0.03902033f, -0.10979751f, 0.17827399f, 
    -0.05636767f, 0.05165732f, -0.05495845f, -0.01061449f, 0.09535332f, 0.03147394f, 0.05951589f, 0.04539008f, 
    0.06546862f, 0.04915685f, 0.03648455f, 0.05915917f, -0.00905844f, -0.17701790f, 0.08897379f, -0.05946030f, 
    -0.31215140f, 0.07126630f, -0.21315211f, 0.05650039f, -0.10736711f, 0.03404751f, -0.47402385f, -0.19373696f, 
    0.08300962f, -0.19361994f, 0.05283747f, 0.09445943f, -0.06291050f, -0.12717944f, -0.15969563f, -0.14542654f, 
    -0.28816471f, -0.07782304f, -0.13207176f, 0.07953195f, -0.09068521f, 0.10262243f, 0.07044668f, -0.05783814f, 
    0.12746137f, -0.14531069f, -0.06101697f, -0.01500898f, -0.13861477f, -0.00418353f, -0.05957180f, -0.02106526f, 
    0.01908851f, 0.04813296f, 0.08697864f, -0.10081363f, 0.10441490f, 0.09760311f, -0.05745473f, -0.05077236f, 
    0.01504040f, 0.13590109f, -0.14188753f, -0.13728821f, -0.01441996f, -0.09390941f, -0.00183632f, 0.04139975f, 
    0.02083136f, -0.00347008f, -0.08372175f, -0.14234909f, 0.19899102f, 0.09075320f, -0.01091672f, 0.06445557f, 
    0.05446186f, 0.08665623f, 0.16142596f, 0.08349881f, -0.08996844f, -0.09466594f, -0.06406941f, 0.06439936f, 
    0.11725641f, -0.00204186f, -0.01703805f, 0.01723021f, -0.04655853f, -0.04110723f, 0.08563826f, 0.06578798f, 
    -0.08648109f, 0.06584468f, 0.02128275f, -0.11303727f, -0.00704277f, -0.00938116f, 0.03639304f, 0.04190568f, 
    -0.39002898f, -0.64055264f, 0.10969424f, 0.18886328f, 0.07367063f, -0.05554854f, 0.01443817f, -0.07351603f, 
    -0.05607197f, -0.00678805f, -0.09887588f, 0.12353899f, 0.02236421f, -0.12593959f, 0.16062130f, 0.17724188f, 
    -0.00317536f, 0.08993189f, 0.03280465f, -0.04513577f, -0.02086555f, -0.00964659f, -0.02816620f, 0.02914344f, 
    0.07052398f, -0.04270187f, 0.14573768f, 0.27631673f, 0.06293091f, 0.02492250f, 0.03295373f, -0.01019786f, 
    -0.00108294f, -0.10055164f, -0.33211946f, -0.23827316f, -0.07906782f, 0.15631497f, -0.20529872f, -0.12593393f, 
    0.06880333f, 0.06694523f, 0.02708085f, 0.17196903f, 0.03391450f, 0.01795807f, 0.02717485f, -0.04248367f, 
    -0.28825191f, -0.29069540f, 0.12844123f, 0.10228968f, -0.05859112f, -0.06566992f, 0.05847361f, 0.06863158f, 
    -0.23324418f, -0.14313525f, -0.22241218f, -0.29322037f, -0.11738031f, 0.07568641f, 0.04699317f, 0.20267682f, 
    -0.00796108f, -0.03361948f, 0.01254117f, -0.01164375f, 0.15153807f, -0.16521682f, 0.05655775f, 0.07626585f, 
    -0.09552900f, -0.01454284f, -0.00730187f, 0.04304688f, 0.12846003f, -0.00505076f, -0.04467216f, 0.11227200f, 
    -0.05736273f, 0.03628199f, 0.13925099f, -0.09703378f, 0.15043294f, -0.19426878f, 0.12484810f, -0.04878123f, 
    0.11803325f, -0.05713418f, -0.08215581f, -0.00071659f, -0.01537720f, -0.04378035f, -0.00634350f, -0.03594526f, 
    -0.06934958f, -0.35183102f, 0.25064704f, -0.03270084f, 0.02456346f, -0.06860192f, -0.04155862f, 0.05026926f, 
    0.24055752f, -0.00572858f, -0.01948827f, 0.04401613f, 0.14996365f, 0.03678245f, -0.12644736f, 0.09733128f, 
    0.02148623f, 0.04347048f, -0.07236619f, -0.15659939f, 0.09412191f, -0.09107026f, 0.08889644f, 0.22058511f, 
    0.00674309f, 0.05840298f, -0.24664412f, -0.11628430f, -0.05231033f, 0.18319045f, -0.21737872f, -0.05640305f, 
    -0.12790696f, 0.02962409f, -0.07280050f, 0.01922050f, 0.34766322f, -0.04352895f, 0.00763796f, -0.01864343f, 
    -0.07592361f, -0.01519597f, -0.01692620f, 0.11306680f, 0.07438549f, -0.05128587f, -0.07111577f, 0.02060151f, 
    -0.12727854f, -0.08653150f, -0.27977645f, -0.22896063f, 0.06032896f, 0.03462521f, 0.04799841f, 0.03817689f, 
    0.13431971f, -0.11253154f, -0.07656421f, -0.44593266f, 0.15863484f, 0.04680631f, 0.06718469f, 0.11169766f, 
    0.11398514f, -0.12351274f, 0.02316365f, -0.17362466f, 0.00257302f, -0.06175967f, -0.04376043f, 0.04629979f, 
    0.07736174f, 0.14886096f, 0.09614241f, 0.07209416f, 0.28616631f, 0.15219699f, 0.04031593f, -0.12805098f, 
    0.04545652f, 0.01876092f, 0.07214594f, 0.09276092f, -0.32265401f, 0.15248536f, 0.04727299f, -0.24958791f, 
    0.05450681f, -0.05137655f, 0.01045243f, 0.04912576f, 0.00233820f, -0.03693663f, -0.06146370f, 0.06692197f, 
    0.11269455f, -0.06577262f, -0.16319852f, -0.15684457f, 0.05817035f, 0.06850288f, 0.00711711f, 0.02451194f, 
    -0.08527459f, -0.00882300f, 0.18238078f, -0.09394316f, 0.03491989f, -0.47823232f, -0.07690320f, 0.05316456f, 
    -0.03337069f, 0.07639031f, -0.09602020f, -0.08543588f, 0.02751738f, -0.07785899f, 0.13909109f, -0.01743000f, 
    -0.06794710f, -0.05264699f, 0.10949671f, 0.13775328f, -0.04619521f, -0.13900396f, 0.09082189f, 0.00150056f, 
    0.07017481f, 0.05757808f, 0.01012029f, 0.20578678f, 0.10386200f, -0.03697068f, -0.09705191f, 0.02428699f, 
    -0.00333488f, -0.11646087f, -0.03614397f, 0.00488342f, -0.14243409f, 0.00152286f, -0.10964619f, -0.18747497f, 
    0.00560835f, -0.07180046f, 0.24431567f, -0.09233002f, -0.22644550f, -0.08830839f, 0.04887123f, 0.03231210f, 
    0.05648511f, 0.01654983f, 0.08570535f, -0.03214448f, 0.35815477f, -0.02276541f, -0.25775552f, -0.08840629f, 
    -0.00476921f, 0.05846297f, 0.05833732f, 0.01520938f, -0.11061529f, -0.20952463f, 0.12443346f, -0.06814538f, 
    0.00582708f, 0.14143823f, -0.19040191f, 0.10650168f, -0.01512984f, 0.01183351f, -0.07271413f, 0.12463529f, 
    -0.10885371f, 0.11433040f, -0.00945517f, 0.03838397f, -0.04607223f, 0.09605699f, 0.01646968f, -0.18016616f, 
    -0.05568288f, -0.00110681f, 0.08320111f, 0.15578727f, -0.02722147f, -0.10631805f, -0.15864074f, 0.00191055f, 
    -0.27160922f, -0.12975802f, 0.04240575f, -0.24333686f, 0.00914924f, 0.03187174f, -0.12191352f, 0.02489831f, 
    0.01521225f, -0.02720906f, -0.03133534f, -0.07327331f, 0.09488866f, -0.24374193f, -0.05416619f, 0.08387121f, 
    0.08841918f, -0.07391807f, -0.02361408f, 0.00942734f, -0.03377562f, -0.09528253f, 0.14539538f, -0.22262420f, 
    0.00409651f, 0.14918596f, 0.14726675f, -0.22189215f, 0.13116911f, 0.02230330f, 0.13345450f, -0.16141097f, 
    0.06677739f, -0.01790090f, 0.01760106f, 0.05167172f, 0.29334018f, 0.04380970f, -0.05529604f, -0.02028538f, 
    -0.25690246f, 0.07432496f, 0.10577974f, -0.21584681f, 0.02456366f, -0.00533301f, -0.06907918f, -0.00057844f, 
    -0.11193220f, -0.08363138f, 0.38579869f, 0.14811949f, 0.12679854f, -0.04829810f, -0.02091468f, 0.05262679f, 
    0.04189951f, 0.08157481f, -0.06634676f, 0.05500868f, -0.42567202f, -0.08243629f, 0.16651772f, -0.07799107f, 
    -0.11754844f, -0.08306332f, -0.22532329f, 0.05428169f, 0.12624550f, 0.10006066f, -0.13643520f, 0.02676868f, 
    -0.07894853f, -0.21019164f, -0.31727698f, -0.14400731f, 0.02671451f, 0.00989867f, 0.01240453f, -0.08995844f, 
    0.13024420f, -0.05811703f, 0.08609842f, -0.10378695f, 0.11686030f, 0.16047558f, 0.14140536f, 0.01859839f, 
    -0.22502217f, 0.05120076f, 0.03303481f, 0.11477162f, 0.14549914f, -0.16607840f, -0.11952610f, 0.19688359f, 
    -0.04314912f, -0.00815047f, -0.09759335f, 0.03070151f, -0.05503828f, -0.09067598f, -0.01099939f, -0.09716350f, 
    0.04100204f, 0.06476255f, 0.00577888f, 0.11765482f, -0.02522371f, -0.06783998f, 0.04378762f, -0.01487283f, 
    -0.02718770f, 0.06909402f, 0.03568925f, 0.33762500f, -0.15231228f, 0.15332595f, 0.04744142f, -0.03335880f, 
    0.41827288f, -0.11172268f, 0.43240517f, -0.25839126f, 0.11130353f, 0.08830123f, 0.10483814f, -0.05318447f, 
    0.01906002f, -0.00134173f, 0.05702165f, -0.02673912f, 0.01218604f, -0.19757600f, -0.25543118f, -0.27698499f, 
    0.07277040f, -0.00623698f, -0.07406494f, 0.14585397f, -0.01924809f, 0.15702391f, -0.06016551f, -0.00462251f, 
    -0.05561453f, 0.14036122f, -0.00461617f, -0.01744110f, 0.05053994f, 0.01470004f, -0.09951785f, -0.03480176f, 
    0.22888435f, -0.18430880f, 0.12579401f, 0.19580409f, -0.03638151f, 0.02781103f, -0.25029421f, -0.15786111f, 
    0.01064860f, 0.05862681f, 0.07885314f, -0.10093101f, -0.02709487f, -0.14381200f, -0.18379499f, -0.19613096f, 
    -0.19147520f, 0.05750515f, 0.18465056f, -0.07871766f, -0.07735569f, 0.06749760f, -0.03710673f, 0.03021913f, 
    0.16220966f, -0.18432337f, -0.02663596f, 0.07729558f, -0.80812931f, -0.50535107f, 0.03613256f, -0.03664773f, 
    -0.01825809f, -0.01951716f, -0.07683402f, 0.01845836f, -0.02444739f, 0.00370550f, 0.07249832f, 0.09480133f, 
    -0.03901294f, -0.04036919f, -0.11763557f, -0.00734328f, 0.03515848f, 0.01041751f, -0.07669285f, 0.01978090f, 
    0.07067130f, -0.07764123f, 0.10953145f, 0.11828921f, -0.08413173f, 0.10008222f, 0.05920251f, -0.07407495f, 
    0.14540266f, 0.17515707f, 0.10105841f, 0.00928337f, 0.08706331f, 0.05241513f, -0.02852245f, 0.16683666f, 
    -0.15273453f, -0.29860863f, 0.30742341f, -0.07084122f, 0.08701229f, -0.06521019f, 0.01026691f, 0.17781180f, 
    0.03154719f, -0.02315374f, 0.17973940f, 0.02196178f, -0.10009021f, -0.17876355f, -0.10658880f, 0.03014999f, 
    0.04753853f, -0.11540613f, 0.06688142f, 0.17120028f, 0.10222778f, 0.05562298f, -0.19731615f, 0.18697129f, 
    0.04770699f, 0.12999955f, 0.12557544f, 0.00857259f, 0.15282473f, 0.27518368f, 0.17852142f, 0.09352242f, 
    0.03438141f, 0.03601198f, 0.05522916f, 0.09456539f, -0.03876662f, -0.02996220f, 0.03385741f, -0.05138954f, 
    -0.00793349f, -0.08641213f, -0.13505918f, 0.11491093f, -0.05847545f, -0.00284557f, -0.24174055f, 0.17806458f, 
    -0.32871503f, -0.04707972f, 0.02255380f, -0.07679289f, 0.04780110f, -0.14775322f, 0.07082305f, 0.19287832f, 
    0.08023384f, 0.03426452f, 0.04940817f, 0.02413501f, -0.03919291f, 0.01890140f, 0.36093956f, -0.04883474f, 
    0.27988902f, -0.03074876f, -0.03068129f, -0.01560953f, 0.08616130f, -0.03206517f, -0.07799484f, 0.08974733f, 
    -0.11895310f, 0.27952862f, -0.12558754f, -0.01385729f, -0.02190849f, -0.03894907f, -0.05564502f, -0.02237582f, 
    0.23130363f, 0.08915620f, -0.07347421f, 0.05630802f, 0.10276990f, -0.01769973f, -0.19630855f, -0.03960549f, 
    -0.10885543f, 0.16585903f, -0.07224248f, -0.10398598f, -0.03498928f, -0.23396963f, 0.22378029f, 0.27607477f, 
    -0.14556773f, -0.10756342f, -0.53320014f, -0.51056284f, 0.07959562f, 0.15103096f, 0.06187977f, -0.03520886f, 
    0.26332718f, 0.10963195f, 0.08339746f, 0.05919199f, -0.08083850f, 0.04001893f, 0.00945039f, -0.00966539f, 
    0.09189615f, 0.01344751f, -0.00549212f, -0.19619124f, -0.13586201f, -0.01963616f, -0.07312624f, -0.16187614f, 
    -0.16266195f, -0.10387877f, 0.28995824f, 0.07055455f, -0.03659640f, -0.08038861f, -0.04226247f, -0.02158617f, 
    0.02810131f, -0.01130247f, -0.17761490f, -0.04037095f, -0.32893801f, 0.05131002f, 0.06244813f, -0.26957458f, 
    0.05702083f, 0.02393432f, -0.07273520f, 0.20554622f, -0.02845006f, -0.01241839f, -0.10198191f, -0.02857916f, 
    -0.04595201f, -0.15809079f, -0.27880323f, 0.11911105f, 0.07369728f, 0.05302039f, -0.10297625f, 0.05137862f, 
    -0.04620039f, -0.00626521f, 0.01042328f, -0.10561174f, -0.06316924f, 0.07723926f, -0.00320847f, -0.27436608f, 
    -0.06943209f, -0.03107326f, -0.01570622f, 0.16916193f, 0.06213780f, 0.02013720f, -0.18003999f, -0.30404127f, 
    -0.15365857f, -0.12604775f, -0.04915347f, 0.06444109f, 0.02894573f, 0.00522544f, -0.05739074f, -0.05160497f, 
    0.00371680f, -0.08472592f, 0.07505620f, -0.01827263f, -0.05546489f, -0.03108523f, 0.13512948f, -0.31831932f, 
    -0.06035747f, 0.08218884f, 0.15513718f, -0.09599227f, 0.09189443f, -0.12977642f, 0.08978292f, 0.08794030f, 
    0.10539479f, -0.11640863f, 0.13455753f, 0.08003622f, -0.02486735f, 0.11689963f, -0.02750065f, -0.07545804f, 
    0.15289240f, -0.06583089f, -0.05301132f, 0.02895205f, 0.17473048f, -0.11372072f, 0.00625855f, 0.07873543f, 
    -0.15359141f, 0.11125777f, -0.04296039f, 0.21264236f, 0.03953293f, -0.06578617f, 0.05355171f, -0.06355862f, 
    0.06501152f, -0.24593012f, -0.18309776f, 0.12966086f, 0.01615004f, 0.10220928f, -0.09143346f, 0.15100308f, 
    0.12133764f, -0.08267633f, 0.06379893f, -0.19092280f, 0.08941776f, -0.08253663f, 0.06194044f, -0.10459512f, 
    0.01470021f, -0.05061808f, 0.07800133f, 0.07965660f, -0.21104296f, -0.10674223f, 0.12059554f, -0.11822574f, 
    -0.09042031f, 0.08396693f, 0.12287612f, -0.04032931f, 0.03576285f, 0.09028819f, 0.16050813f, -0.02205561f, 
    0.00043145f, 0.08941445f, 0.01839168f, -0.03538315f, -0.14167847f, -0.13817608f, -0.14339729f, -0.18069173f, 
    0.13511166f, 0.00559003f, 0.01229862f, 0.00399158f, -0.05180273f, -0.06533869f, 0.09436090f, 0.05255088f, 
    -0.11809807f, 0.24435371f, -0.01326683f, 0.08126550f, 0.02768814f, -0.07146782f, -0.04482052f, -0.01613608f, 
    0.07012813f, -0.00798420f, -0.02366772f, -0.21416338f, 0.04188494f, -0.27630651f, -0.01686694f, 0.01243478f, 
    0.03682097f, -0.12023861f, -0.00937963f, 0.10922138f, 0.10757364f, 0.06917430f, -0.07228537f, -0.03787652f, 
    0.10662938f, -0.13381578f, -0.29748845f, -0.25699174f, -0.00851986f, 0.00930405f, 0.05378094f, 0.03381709f, 
    0.04153712f, 0.10992989f, 0.04886875f, 0.13544700f, -0.72364789f, -0.22709420f, -0.31803751f, -0.12716955f, 
    -0.03315021f, -0.01825653f, -0.17483057f, -0.20507434f, 0.01484006f, -0.03978048f, -0.02076864f, 0.00028221f, 
    -0.08545350f, 0.17219698f, -0.11204568f, 0.17587414f, -0.01539684f, -0.00099830f, -0.00310196f, 0.18285725f, 
    -0.01610723f, 0.00096960f, 0.24782269f, 0.02187711f, -0.25698283f, -0.07183211f, 0.18113467f, 0.07466096f, 
    0.04359462f, 0.07354988f, 0.03363305f, -0.05713668f, 0.08081590f, -0.04418341f, 0.14624409f, 0.06116210f, 
    0.11686379f, -0.25307715f, -0.33366671f, -0.04541663f, -0.13503851f, 0.18640381f, 0.06473042f, -0.09933206f, 
    0.07029682f, -0.01678560f, 0.01287714f, -0.02602518f, -0.10010988f, 0.04154551f, -0.03544627f, -0.03185292f, 
    -0.12322593f, -0.01443899f, -0.04218038f, -0.01342434f, 0.13150321f, 0.01912263f, 0.02642108f, -0.02015123f, 
    -0.16380717f, 0.43922615f, -0.00594517f, 0.19889270f, 0.00732142f, -0.07501049f, 0.03484731f, 0.31348655f, 
    0.07443412f, 0.02812412f, 0.10861386f, 0.06865250f, 0.02644520f, -0.14869958f, 0.25171447f, -0.58129460f, 
    0.02775304f, -0.17281960f, 0.07883827f, -0.05457439f, 0.14717142f, 0.12751018f, 0.14841850f, -0.14253443f, 
    -0.38281482f, -0.06207896f, 0.38441998f, -0.19101980f, -0.19141002f, -0.16446841f, 0.15423098f, -0.20399378f, 
    -0.09303178f, 0.02296501f, -0.04463104f, -0.00798170f, 0.45630774f, 0.11698224f, -0.52748847f, 0.13364020f, 
    0.00535308f, 0.03718437f, 0.03427008f, 0.18296942f, 0.04160941f, 0.07691922f, -0.14901024f, -0.05338858f, 
    0.15491095f, 0.12717274f, 0.00922286f, 0.02221598f, -0.02534488f, -0.01288210f, 0.07778750f, 0.04632809f, 
    0.11166402f, 0.13871735f, 0.22259788f, 0.26373804f, -0.56047857f, -0.39947334f, -0.58266592f, -0.35797614f, 
    -0.19597757f, 0.03400894f, 0.02298930f, -0.21182105f, 0.04002593f, -0.05238631f, 0.04599984f, 0.04811097f, 
    -0.34479481f, -0.50335044f, -0.42911619f, -0.31882331f, -0.08132990f, -0.21323863f, -0.20292166f, -0.34943396f, 
    -0.03842426f, -0.02318126f, 0.01222589f, 0.00246881f, -0.48680684f, -0.62069964f, -0.37130770f, -0.01085133f, 
    -0.07372418f, -0.11213203f, -0.11801204f, -0.07696556f, -0.01125650f, 0.01225646f, 0.03334623f, -0.04575859f, 
    0.07746202f, 0.28478843f, 0.20714989f, 0.21653326f, -0.03011475f, 0.02514980f, -0.03083110f, -0.20205738f, 
    0.06184658f, 0.04886002f, 0.07359107f, 0.05953670f, -0.14123610f, 0.08397216f, 0.35479787f, 0.27062830f, 
    -0.07342610f, -0.05911956f, -0.05526889f, 0.07842897f, -0.11247936f, 0.00338033f, -0.14475755f, 0.17681718f, 
    0.02369166f, -0.10693485f, 0.11075043f, 0.09263843f, 0.03112227f, -0.13788326f, 0.00114579f, 0.06433874f, 
    -0.23554090f, 0.05908149f, -0.04125403f, -0.15638588f, 0.21780577f, 0.15298657f, -0.17746845f, -0.14750855f, 
    -0.08417577f, -0.00962320f, -0.02127368f, -0.04177083f, 0.09631184f, -0.14621906f, 0.04220898f, 0.03057299f, 
    -0.16678603f, -0.20982708f, -0.11102460f, 0.08161948f, -0.23188625f, -0.11649366f, 0.10070539f, 0.06385488f, 
    0.03054479f, 0.02726311f, -0.19067922f, -0.02133241f, 0.04068345f, 0.12842579f, -0.04921215f, 0.05286919f, 
    -0.02862228f, 0.03620626f, -0.06574225f, 0.12566921f, 0.03902990f, 0.22141913f, 0.00845964f, -0.01996684f, 
    0.29020032f, 0.16494064f, 0.01607769f, -0.18381338f, 0.01870033f, 0.00717329f, 0.16476755f, -0.04734505f, 
    0.00148382f, 0.12344186f, -0.08431890f, -0.00254932f, -0.18415524f, 0.44240037f, 0.42107254f, 0.02419048f, 
    -0.06664731f, -0.13570109f, -0.05587455f, 0.03257167f, -0.06588957f, 0.03949890f, 0.03771319f, 0.04233012f, 
    -0.55231941f, -0.60968786f, -0.27406919f, -0.00783995f, -0.12479118f, -0.03079431f, -0.11083991f, -0.07903785f, 
    -0.07661397f, 0.05338841f, -0.04890222f, -0.03209478f, -0.06943306f, 0.03738663f, 0.04043017f, 0.05437008f, 
    -0.09570121f, 0.05484602f, 0.02249259f, -0.05755140f, -0.00999932f, -0.00055446f, 0.01800994f, -0.02620073f, 
    -0.44062364f, -0.75775844f, -0.48392686f, -0.01444727f, -0.07540555f, -0.21401548f, -0.32835722f, -0.39560932f, 
    -0.07775158f, -0.01026337f, -0.02543525f, -0.01804111f, -0.02400823f, -0.28030488f, -0.53478491f, -0.08406791f, 
    0.05045472f, 0.07145111f, 0.19965959f, 0.02862245f, 0.05890902f, 0.06150140f, 0.03031197f, 0.03552004f, 
    0.06657670f, -0.16567439f, -0.08625381f, 0.36658198f, 0.14612187f, 0.07369474f, 0.06856400f, 0.06273253f, 
    -0.02879255f, 0.02425075f, 0.02740596f, 0.06130125f, 0.10555064f, -0.21222661f, -0.00921344f, 0.10828065f, 
    -0.04871468f, 0.00685691f, 0.02688549f, 0.08725095f, -0.04182710f, 0.09496690f, -0.01640708f, 0.03337694f, 
    -0.12333709f, 0.15496816f, 0.26258573f, 0.02302729f, 0.05144675f, 0.01244021f, -0.00520616f, -0.10930748f, 
    -0.01657255f, 0.08029138f, -0.05285563f, -0.02216057f, -0.29189840f, -0.44821918f, -0.00133504f, -0.14852740f, 
    -0.14235413f, -0.13281444f, 0.05361750f, -0.01182392f, -0.02955487f, 0.01406914f, 0.12607785f, -0.06288166f, 
    0.00083761f, -0.03315599f, -0.10748044f, 0.04326816f, -0.09417300f, -0.11078482f, 0.04914566f, 0.17252874f, 
    0.03433648f, -0.07044115f, -0.00920768f, -0.10155838f, 0.11674790f, 0.04559994f, -0.06789161f, 0.13876933f, 
    0.03402362f, 0.02465466f, 0.20829664f, 0.17100675f, 0.03250641f, 0.10662264f, -0.03248364f, 0.00632727f, 
    -0.49194911f, -0.78448761f, -0.49094048f, 0.14920710f, 0.01969763f, 0.19415540f, -0.02228685f, -0.03475544f, 
    0.02751547f, -0.02302244f, -0.02714480f, -0.09671339f, -0.31657946f, -0.19324329f, -0.04746077f, 0.08242030f, 
    0.22111958f, 0.08317295f, 0.07765428f, -0.19762628f, 0.02032388f, -0.02509132f, -0.04173597f, 0.11508178f, 
    0.13459609f, 0.05642482f, -0.02439206f, 0.01177440f, 0.07379162f, 0.00757195f, -0.03846889f, 0.09137255f, 
    -0.04882339f, -0.11916982f, 0.12133622f, -0.08394234f, -0.07029317f, 0.07432652f, 0.13575532f, -0.06656112f, 
    0.06419668f, -0.06471843f, -0.00511636f, -0.03994566f, -0.02639711f, 0.00103521f, 0.04258512f, -0.09049150f, 
    0.14711268f, -0.20089152f, 0.03690619f, -0.00680145f, 0.05179393f, 0.00050834f, -0.04185201f, 0.19185790f, 
    -0.03881341f, -0.03035087f, 0.21238109f, -0.16782442f, -0.17306429f, -0.06016777f, 0.47016352f, 0.07327799f, 
    -0.04379258f, -0.00905562f, -0.03763992f, 0.01555691f, 0.05117873f, 0.11654693f, 0.00357147f, -0.01044053f, 
    0.06367834f, -0.00764290f, -0.06567373f, 0.00229801f, 0.00090067f, -0.03360938f, 0.01061927f, 0.03642996f, 
    -0.04075700f, -0.16946435f, -0.21288016f, -0.10469101f, -0.23824939f, -0.37724957f, -0.11627183f, -0.08661955f, 
    -0.00665459f, -0.18072328f, -0.16401353f, -0.13532102f, -0.00864436f, 0.01508194f, -0.04882117f, -0.03989669f, 
    -0.05544484f, -0.14149794f, 0.15031840f, 0.12777598f, -0.08644009f, -0.12751076f, -0.06406657f, 0.13013384f, 
    0.01698845f, 0.10069256f, 0.16147290f, 0.06306282f, 0.01801210f, -0.12306006f, -0.12198526f, 0.14071937f, 
    0.07465500f, 0.01622778f, 0.09485735f, -0.01701355f, 0.05114181f, -0.00521414f, -0.02070885f, 0.07860658f, 
    -0.42539018f, -0.52670574f, -0.15439554f, 0.06232664f, -0.16199352f, -0.34780586f, -0.06898300f, -0.38713187f, 
    -0.01462312f, -0.04778710f, 0.01945909f, -0.05959331f, 0.09000434f, 0.02664053f, 0.00034777f, -0.06955967f, 
    -0.05389884f, 0.00337673f, 0.02034668f, 0.14579006f, 0.04781051f, 0.03347281f, 0.13458078f, 0.09422415f, 
    -0.05104909f, -0.25586167f, 0.02621360f, 0.04443783f, 0.03347026f, -0.09722335f, 0.15944606f, 0.01502066f, 
    0.05139706f, 0.11847879f, -0.04694783f, 0.00931050f, -0.16625196f, -0.57110947f, 0.00918077f, 0.06011777f, 
    -0.07829751f, -0.06941795f, -0.03171557f, 0.16590980f, -0.00320356f, -0.05078792f, 0.00452931f, -0.03967086f, 
    -0.43103760f, 0.23610270f, 0.33368695f, -0.14718300f, -0.07021992f, -0.12181854f, 0.00926177f, -0.12902921f, 
    -0.06421006f, 0.04112944f, 0.06413845f, 0.06345665f, 0.00742351f, 0.19492148f, -0.03402478f, 0.08066163f, 
    0.17390947f, -0.03591090f, 0.09927518f, -0.10686714f, 0.15457231f, 0.06919403f, 0.01623345f, 0.10173058f, 
    0.03868823f, 0.01001779f, 0.35523266f, -0.12562776f, 0.12003203f, -0.31187245f, 0.00657474f, -0.00357118f, 
    0.05615381f, -0.04235995f, -0.05052630f, 0.00806698f, -0.01241597f, -0.20279945f, -0.25737712f, -0.07919714f, 
    -0.03354624f, -0.15280330f, -0.05761989f, 0.00700366f, -0.01407640f, -0.09177498f, 0.00010758f, 0.07314131f, 
    0.02439923f, -0.22274920f, -0.21114407f, -0.39034316f, -0.09485824f, -0.02796670f, -0.05204912f, 0.09858511f, 
    -0.17867333f, 0.12870276f, 0.03209236f, 0.24973683f, -0.39172402f, -0.40432662f, 0.19400540f, 0.00110659f, 
    0.04976064f, -0.02929294f, 0.19313847f, 0.07294521f, -0.06032450f, 0.10004313f, 0.03458802f, 0.01873474f, 
    0.23936491f, -0.32923681f, -0.17739436f, -0.22377159f, 0.02597558f, 0.07385790f, 0.18781650f, -0.12278804f, 
    -0.00282443f, -0.10959729f, 0.05909767f, -0.07792169f, -0.06431523f, 0.26846734f, 0.02381043f, 0.09619050f, 
    0.05676579f, 0.09798856f, 0.06072725f, -0.11566118f, 0.14024182f, -0.00099675f, 0.17720154f, 0.10249075f, 
    -0.15762065f, -0.04654435f, -0.03764371f, -0.09909408f, 0.00905160f, 0.08175340f, 0.03129402f, 0.02345789f, 
    -0.04185054f, -0.06525685f, -0.09999306f, -0.13995846f, -0.12865373f, 0.32146645f, 0.05997353f, 0.05519995f, 
    0.06171412f, 0.04990046f, 0.06827451f, -0.03899033f, -0.05799487f, 0.07864849f, -0.01468163f, 0.07155516f, 
    -0.33568314f, -0.30646896f, -0.09352335f, 0.25570402f, -0.09617566f, 0.16001058f, -0.03028115f, 0.06925258f, 
    0.05829413f, -0.06605238f, 0.02520987f, -0.02721237f, -0.09957460f, -0.10008233f, 0.05402510f, 0.14556608f, 
    -0.04365876f, 0.09572082f, 0.02356269f, -0.11063636f, -0.02429783f, -0.04092545f, -0.03918939f, 0.05021703f, 
    0.36488765f, 0.04145834f, -0.08176608f, -0.09015906f, -0.01123980f, -0.05547223f, 0.08766824f, -0.18168761f, 
    0.05650190f, -0.06062479f, 0.12197834f, -0.05162107f, -0.02648930f, 0.05743402f, 0.08128763f, -0.00577381f, 
    -0.05823418f, 0.04072908f, -0.01195261f, -0.02890204f, 0.01071078f, 0.08085249f, -0.10524303f, 0.01247784f, 
    -0.42352575f, -0.61571062f, -0.14198150f, -0.01099823f, -0.07993389f, 0.08018593f, -0.19402091f, -0.08472700f, 
    0.03776034f, -0.00697128f, -0.03017952f, -0.03687815f, -0.43207490f, -0.07530458f, 0.15724728f, 0.33986333f, 
    -0.10302256f, 0.04824349f, -0.03512260f, -0.11608618f, 0.00045554f, -0.00825047f, 0.06574538f, -0.04117071f, 
    -0.27177304f, -0.11560708f, 0.03813244f, 0.10671617f, 0.05014486f, 0.04889754f, 0.00113952f, -0.01431194f, 
    0.05787113f, -0.03152753f, 0.08802380f, -0.15187356f, -0.08927377f, -0.23281784f, -0.17147183f, -0.01508749f, 
    0.07424526f, 0.12116083f, -0.05656923f, -0.05322301f, 0.00747509f, -0.01744490f, -0.09062284f, 0.05058816f, 
    -0.03845187f, 0.04108186f, -0.08340601f, 0.22485597f, -0.07862454f, -0.05374242f, -0.06703871f, -0.00221620f, 
    0.06851950f, 0.02450014f, -0.00650554f, 0.05207247f, -0.17694640f, -0.23320410f, -0.23459752f, -0.22612964f, 
    0.14186080f, -0.02934896f, 0.09497571f, -0.01688516f, 0.02861065f, 0.03200652f, -0.00862580f, -0.01123573f, 
    0.31047538f, -0.14469227f, 0.12477944f, 0.03792639f, 0.05036117f, 0.06501058f, -0.14610258f, -0.01466345f, 
    -0.13691683f, 0.04558344f, 0.05526627f, 0.18429323f, 0.21215865f, 0.07343046f, -0.04910967f, -0.11310318f, 
    -0.00243530f, 0.00214164f, 0.01721217f, -0.01789225f, -0.08927298f, 0.06391921f, -0.06570560f, -0.21933025f, 
    -0.02395028f, 0.17526628f, 0.11209774f, 0.10193944f, -0.06822164f, 0.11695846f, -0.04500115f, 0.00793851f, 
    -0.00544340f, -0.04327060f, 0.02427089f, 0.02854077f, 0.25526258f, -0.06510793f, 0.01760516f, -0.06392381f, 
    0.09857124f, -0.15499710f, -0.08441468f, -0.14714578f, -0.05674017f, 0.06100097f, 0.00770755f, -0.05038995f, 
    0.13449715f, -0.61685461f, -0.15478081f, -0.44319975f, -0.02919113f, -0.10170554f, 0.03645062f, 0.02674709f, 
    0.05565552f, 0.07834738f, -0.04213240f, -0.08026176f, 0.10351425f, 0.39410383f, 0.24719532f, -0.08183385f, 
    -0.20430146f, -0.02899399f, -0.06565988f, -0.10300007f, -0.12592979f, -0.11031827f, -0.02476523f, -0.00324013f, 
    -0.15813969f, -0.34170917f, -0.11610991f, -0.12655166f, 0.01830709f, -0.16729033f, 0.11276780f, 0.27433789f, 
    0.01872981f, 0.04971512f, -0.02660451f, -0.00179123f, -0.25639385f, -0.32082975f, -0.00355869f, -0.09336137f, 
    0.11247846f, -0.07871754f, 0.05387402f, -0.13035086f, -0.03327379f, 0.07734110f, -0.08065157f, -0.02324630f, 
    0.06042414f, -0.14308526f, 0.08184734f, 0.23228629f, -0.02989934f, 0.02204838f, 0.01481901f, -0.01063473f, 
    0.11633100f, 0.00654909f, 0.04824699f, 0.00499834f, -0.29083529f, -0.21107039f, -0.10831920f, 0.17727506f, 
    0.08780894f, 0.15110770f, 0.16928457f, 0.08717666f, -0.04130157f, -0.03463275f, -0.06275840f, -0.07496735f, 
    -0.15597261f, -0.17699665f, -0.09902252f, 0.23214759f, 0.15180050f, -0.02170927f, 0.06135213f, 0.17187944f, 
    0.00693005f, -0.02589915f, -0.04031584f, -0.04710630f, -0.11152842f, -0.22775659f, -0.24771079f, -0.21449859f, 
    -0.00938083f, -0.04189591f, 0.03344302f, 0.28597289f, 0.00985614f, -0.04457412f, -0.03702643f, 0.00807587f, 
    -0.27080670f, -0.49990657f, -0.30408642f, -0.17818120f, -0.12779501f, -0.06317140f, 0.06473806f, 0.06927604f, 
    0.05335943f, 0.05336261f, -0.02238725f, -0.03197392f, 0.04885951f, 0.04646854f, -0.01388147f, -0.13576660f, 
    -0.00791315f, 0.04983333f, 0.04248581f, 0.02326145f, -0.01280763f, -0.01250746f, 0.04004067f, -0.24891309f, 
    0.17012918f, 0.03229294f, -0.09866780f, -0.09354977f, 0.01000044f, 0.00500385f, 0.07607249f, 0.01408425f, 
    0.03334074f, -0.14463168f, -0.04844736f, -0.08566618f, 0.01099058f, -0.04123573f, -0.06603667f, 0.02267119f, 
    0.04468350f, 0.01693510f, 0.01545215f, 0.03296180f, -0.04393703f, 0.05723587f, 0.05670878f, -0.06887555f, 
    0.23381373f, -0.23980030f, 0.17191057f, 0.09201638f, -0.09498908f, 0.02744708f, 0.02284717f, 0.01445987f, 
    -0.02739780f, -0.02659651f, -0.00414210f, -0.04438080f, 0.07510141f, 0.00445771f, 0.05079283f, 0.17225200f, 
    0.01421603f, -0.03225023f, 0.06540745f, -0.00894807f, 0.00184943f, 0.13995773f, 0.14025110f, -0.12386469f, 
    -0.37571743f, 0.19224221f, 0.00292256f, 0.18232509f, -0.02488921f, 0.05461366f, 0.01701426f, -0.04910839f, 
    -0.03668141f, 0.05553365f, -0.07071134f, 0.05517016f, 0.16970359f, -0.37891436f, -0.29646155f, -0.26327959f, 
    -0.05194177f, -0.02945365f, 0.01857424f, 0.00034796f, 0.16993451f, -0.01702499f, 0.06213735f, 0.01473235f, 
    0.51609832f, -0.35251880f, -0.12534997f, -0.34049171f, -0.10628969f, -0.04413734f, -0.20058204f, 0.29549444f, 
    0.05690480f, -0.01505344f, -0.12147579f, 0.05559111f, 0.18447958f, 0.13735588f, -0.14615598f, -0.01135655f, 
    -0.01547480f, 0.00970245f, -0.01844933f, 0.00376552f, -0.02192225f, 0.00116760f, -0.17948397f, -0.13715741f, 
    -0.24719062f, -0.57730669f, 0.48436221f, 0.13134418f, 0.07745463f, 0.04681750f, -0.03914198f, 0.03382902f, 
    -0.01557603f, -0.01778916f, -0.01201089f, -0.03758486f, -0.38785973f, 0.14760585f, 0.00863742f, -0.09117089f, 
    0.04584192f, -0.14064375f, -0.00872940f, 0.01827510f, 0.03273653f, 0.04431216f, 0.02397414f, -0.02766789f, 
    0.34678590f, -0.26675704f, 0.28708729f, -0.24560221f, 0.00499778f, -0.00368603f, -0.09068967f, 0.11760194f, 
    -0.04106736f, 0.00894859f, -0.09995378f, -0.01426883f, 0.24784370f, -0.09955292f, 0.08164828f, -0.15030822f, 
    -0.09766526f, 0.03676738f, -0.03735681f, -0.03844609f, -0.09706500f, 0.10595329f, -0.00462740f, -0.15202329f, 
    -0.06018095f, 0.11275971f, 0.04261953f, -0.07739257f, 0.00888543f, -0.01742423f, -0.03088468f, -0.00340575f, 
    0.17002745f, -0.03166344f, -0.08905777f, -0.07272413f, 0.16207191f, -0.12245863f, 0.23924038f, 0.11208030f, 
    -0.10077345f, -0.03526992f, -0.02910844f, 0.01074972f, -0.05971923f, -0.07278214f, 0.07838862f, -0.12511231f, 
    0.00486492f, -0.01928675f, -0.00602618f, -0.03445704f, -0.14513454f, 0.14373195f, 0.16182502f, 0.01219421f, 
    0.00528632f, 0.00484353f, 0.06229192f, 0.03440095f, -0.14463507f, -0.04678456f, 0.09396264f, -0.05260862f, 
    -0.10716128f, -0.08044863f, 0.07552543f, -0.08741261f, 0.00248037f, -0.06454474f, -0.05272637f, 0.01459029f, 
    -0.71727639f, -0.72473955f, 0.45229128f, -0.12463634f, 0.01991738f, -0.02401322f, 0.14194793f, -0.08538503f, 
    0.10158268f, -0.02086933f, 0.00391582f, -0.00229254f, 0.17409624f, 0.11140927f, 0.14516082f, -0.26330665f, 
    -0.05943451f, 0.00300699f, 0.05604582f, -0.04455507f, -0.00881476f, 0.04994653f, 0.04226504f, 0.05430189f, 
    -0.04989392f, -0.05042429f, 0.12373427f, -0.08318473f, -0.08507783f, -0.05577573f, 0.00964957f, -0.01559569f, 
    -0.01297436f, -0.19923447f, 0.03868438f, -0.14444119f, -0.08718938f, 0.05513640f, -0.00897699f, 0.11903293f, 
    -0.00866549f, -0.08263392f, 0.08599375f, -0.10494200f, 0.11703221f, 0.03923666f, 0.11782335f, -0.00194059f, 
    0.09016496f, -0.01826519f, 0.10975087f, -0.18751575f, -0.00699283f, -0.01936681f, 0.00876005f, -0.04510038f, 
    0.07355176f, -0.06994840f, -0.06340099f, -0.15582621f, 0.29858777f, -0.00395209f, 0.01294773f, -0.50259590f, 
    0.02866516f, -0.00042002f, -0.05659178f, 0.02157574f, -0.03663075f, -0.04329083f, -0.04026479f, -0.14429238f, 
    0.04824683f, 0.02613621f, 0.01972871f, -0.05117464f, 0.00620228f, 0.03723883f, -0.00377536f, 0.00361250f, 
    -0.07163575f, -0.13000937f, -0.05405148f, -0.09429286f, -0.32626680f, 0.01950021f, -0.18643498f, 0.20767552f, 
    0.05875271f, -0.08691756f, 0.05278569f, 0.00931923f, 0.02756889f, 0.00052137f, -0.06758557f, 0.00708771f, 
    0.71133488f, -0.24146804f, 0.04127299f, -0.36206755f, -0.20030421f, 0.21319509f, -0.25851113f, -0.02784891f, 
    -0.12985173f, 0.02972081f, -0.00870287f, -0.15036292f, 0.01827350f, -0.03832187f, 0.01478675f, -0.01629239f, 
    -0.02350048f, -0.06749023f, -0.05177407f, -0.00698828f, -0.08706136f, 0.05699988f, 0.05147844f, 0.01224505f, 
    -0.17290370f, -0.27777597f, -0.09047426f, -0.01467620f, 0.04217963f, -0.01636555f, -0.11729275f, 0.11874603f, 
    0.03379031f, 0.02508056f, -0.00453247f, -0.03169064f, 0.04453309f, -0.05934346f, -0.10762700f, -0.01015133f, 
    0.00445674f, 0.02620026f, -0.08161931f, -0.05579663f, 0.00880849f, 0.14478786f, -0.03847171f, 0.03266683f, 
    0.35794854f, -0.28071019f, -0.13753471f, -0.11366693f, -0.07051682f, 0.10682937f, -0.03378365f, -0.06824211f, 
    0.10024130f, 0.00910168f, 0.02973682f, -0.02904698f, 0.64823288f, -0.22483350f, -0.24225035f, 0.08957434f, 
    0.06421716f, 0.11970983f, -0.08882614f, -0.02464821f, -0.01722619f, 0.07827815f, -0.03917105f, -0.00703852f, 
    0.20138742f, 0.11620514f, -0.15690246f, -0.07274947f, 0.05294457f, -0.00398071f, 0.01920012f, -0.01849617f, 
    -0.02038002f, 0.08710445f, 0.06789743f, 0.08598749f, 0.03892173f, -0.04841163f, 0.19394341f, -0.10505537f, 
    -0.03469962f, 0.03800856f, 0.02339010f, -0.02707712f, -0.03307753f, 0.09111386f, -0.20482530f, -0.00963090f, 
    -0.15488537f, 0.21030521f, -0.05025513f, 0.08148788f, -0.10042694f, 0.08048648f, 0.11872878f, 0.05798173f, 
    -0.04517898f, -0.13034210f, 0.08831874f, 0.05372000f, -0.30042389f, 0.27192175f, 0.09473591f, 0.39457294f, 
    0.08604231f, -0.04254638f, -0.09195615f, 0.00536579f, 0.00667646f, -0.02213851f, 0.02894804f, 0.00298439f, 
    0.39489779f, -0.26233408f, -0.02209750f, -0.14630362f, 0.02406981f, -0.00601805f, -0.04889327f, 0.07401069f, 
    -0.01604025f, 0.14076412f, -0.00535358f, -0.02580606f, 0.02645823f, -0.30941439f, 0.05018128f, -0.20032717f, 
    -0.07722791f, 0.04310640f, -0.05532028f, 0.23725142f, 0.07102691f, -0.00725740f, -0.00602662f, -0.02600760f, 
    -0.00446573f, 0.13796015f, 0.00362154f, -0.08171587f, -0.00044972f, -0.03490230f, -0.05695691f, 0.01848648f, 
    0.06899527f, 0.04321886f, 0.08921549f, -0.01321073f, -0.13428143f, -0.19731444f, 0.21887577f, -0.02558162f, 
    -0.12490103f, 0.02316147f, 0.13909850f, 0.03249909f, -0.13591252f, -0.05058291f, -0.00365028f, 0.00564568f, 
    0.09165629f, -0.04470978f, 0.00306823f, -0.17510879f, -0.03055587f, -0.05155874f, -0.01965386f, -0.01030166f, 
    0.02489740f, -0.00984109f, 0.00190175f, -0.01129704f, -0.33094421f, -0.16720438f, 0.17571604f, -0.42709586f, 
    -0.02928984f, -0.03680512f, 0.02887680f, 0.05429064f, -0.06885257f, -0.03804772f, -0.13594098f, -0.01325129f, 
    0.14278938f, -0.15983097f, 0.14629249f, -0.07454687f, -0.02792951f, 0.06124891f, -0.05110848f, -0.06751835f, 
    -0.11023834f, 0.09375717f, -0.01980522f, -0.01451221f, 0.01293195f, -0.02741982f, -0.03111307f, 0.04391928f, 
    -0.03802089f, -0.05170529f, 0.00000826f, 0.00690359f, -0.03606937f, 0.05972715f, 0.03960076f, 0.02228686f, 
    -0.02572348f, 0.05926298f, -0.02954540f, 0.06309737f, 0.01682058f, 0.00238662f, 0.05065345f, -0.01508459f, 
    0.02374767f, 0.08719976f, 0.02047293f, -0.03079603f, -0.03135690f, -0.14866796f, -0.02352346f, -0.11891636f, 
    0.01221670f, -0.00294237f, 0.03790521f, 0.01741453f, -0.01152259f, -0.03486487f, -0.01235930f, -0.00417293f, 
    -0.23419634f, -0.07970156f, -0.22612935f, 0.06531055f, 0.11766617f, -0.05709844f, 0.12033024f, -0.00826064f, 
    0.00349090f, 0.01847134f, 0.00919589f, 0.07398351f, 0.07808429f, -0.37010330f, -0.31076774f, -0.24279533f, 
    -0.19944979f, -0.08154611f, -0.07000659f, 0.07160237f, 0.09388524f, 0.00630282f, -0.05022160f, -0.04687050f, 
    0.05172569f, 0.03143983f, -0.15409768f, -0.12380526f, -0.02419799f, -0.11025596f, -0.00372186f, -0.00146384f, 
    0.00141367f, 0.07238154f, -0.08012053f, -0.14140508f, 0.04115541f, -0.01169933f, -0.00873321f, -0.06576674f, 
    -0.03418482f, -0.07119948f, 0.03114402f, -0.05855788f, 0.03256756f, -0.01194295f, 0.04139700f, 0.04025010f, 
    0.25691670f, -0.06225887f, -0.03593957f, -0.07338249f, 0.09690209f, 0.02125113f, 0.04385662f, 0.08812054f, 
    0.08855838f, 0.04337239f, 0.03868914f, -0.30673543f, -0.30646244f, -0.52433735f, -0.36417118f, 0.05300678f, 
    -0.00496427f, 0.19752586f, 0.10207406f, 0.02314128f, -0.02365964f, -0.03377008f, -0.00097551f, 0.00715602f, 
    0.01626710f, 0.09280775f, 0.01159467f, -0.18106079f, 0.04948838f, -0.04702837f, 0.01595462f, 0.02124715f, 
    0.08353122f, 0.03917535f, -0.04533680f, -0.22777753f, 0.17169218f, -0.01321380f, -0.03965777f, -0.15663165f, 
    -0.22185105f, -0.02832026f, 0.08216804f, -0.02113910f, -0.08218288f, 0.06793957f, 0.04921440f, 0.08402380f, 
    -0.27619272f, 0.08491717f, 0.21044934f, 0.03968995f, 0.12841284f, -0.13236767f, -0.08444972f, 0.01284621f, 
    -0.11949918f, 0.01808951f, -0.02168688f, -0.02874726f, -0.02424745f, -0.08133782f, -0.10062477f, -0.12220673f, 
    0.07235473f, 0.20639825f, 0.08581666f, 0.17664193f, -0.03871666f, 0.02447413f, 0.03707791f, 0.04324089f, 
    0.02144443f, -0.32529283f, -0.30158237f, -0.01689139f, 0.14937270f, 0.12359077f, 0.11608980f, 0.04894965f, 
    0.07156105f, 0.03675202f, -0.03370271f, 0.00983055f, -0.17994671f, 0.23792809f, 0.03917728f, -0.16591211f, 
    0.16617794f, 0.08837701f, 0.02700701f, 0.10739639f, 0.07159135f, 0.01056585f, 0.14938831f, 0.19357182f, 
    0.02460402f, -0.10872600f, -0.19712557f, 0.15784690f, -0.18554096f, 0.12157031f, 0.15832530f, -0.02463945f, 
    0.02424396f, -0.23282699f, -0.06321237f, -0.04060011f, 0.46409366f, -0.15071064f, -0.15964311f, -0.08485731f, 
    0.22270343f, -0.08704046f, 0.12156878f, -0.04834849f, -0.06184642f, -0.05803221f, 0.08512603f, 0.04645590f, 
    -0.36989298f, -0.13617907f, 0.11271295f, 0.15109353f, -0.01624973f, 0.07664159f, -0.01739168f, 0.00488905f, 
    -0.07817265f, -0.12325526f, -0.08554933f, -0.44803956f, 0.03560672f, -0.16801228f, -0.18674320f, -0.24513842f, 
    -0.04643913f, 0.04050023f, 0.00687008f, 0.07261000f, -0.07830943f, -0.06611872f, -0.02586419f, -0.07186355f, 
    -0.16732021f, -0.18417375f, -0.04708567f, -0.26148754f, -0.06336508f, -0.23965128f, -0.05626845f, -0.17448923f, 
    -0.00799277f, -0.05538904f, 0.02207986f, 0.00283658f, -0.04470886f, -0.35408249f, -0.47441077f, -0.19338028f, 
    -0.25362155f, 0.03547931f, 0.03757396f, -0.16127634f, -0.02680394f, -0.04810908f, 0.02835828f, -0.00000202f, 
    -0.11315817f, -0.08528158f, 0.05935718f, 0.22237118f, 0.03470526f, 0.10897272f, 0.07901276f, 0.13244049f, 
    -0.08899512f, 0.02018156f, -0.03553127f, -0.28975669f, -0.04382576f, -0.02111126f, 0.07671831f, 0.26916575f, 
    -0.00413253f, -0.04121608f, 0.08111207f, -0.03288062f, 0.15491624f, -0.02587679f, 0.09637054f, 0.16115505f, 
    0.09316576f, -0.03531089f, -0.03632038f, 0.01158927f, -0.07986819f, 0.02031564f, -0.05763255f, -0.03168623f, 
    0.01849922f, 0.04057861f, 0.19428651f, -0.01513106f, -0.13729502f, -0.06969595f, -0.03192134f, 0.01819495f, 
    0.02851705f, -0.01250705f, -0.14330682f, -0.03002704f, -0.05621612f, -0.24794109f, -0.04095753f, -0.06009740f, 
    0.17448755f, -0.04603682f, -0.27660832f, -0.09311471f, 0.34111550f, -0.04272712f, 0.01435468f, 0.05042298f, 
    -0.05884200f, 0.14014257f, 0.13809223f, 0.23314765f, -0.22227097f, -0.07114436f, 0.11333305f, 0.19539601f, 
    0.05530697f, 0.03011236f, 0.04552800f, 0.08207192f, -0.10325348f, -0.08698919f, -0.16938955f, -0.17628926f, 
    -0.12526649f, 0.07179449f, 0.13884182f, 0.19438058f, 0.08653948f, 0.00883177f, 0.00065913f, 0.12906797f, 
    -0.02089621f, -0.09065899f, 0.08840223f, 0.07017778f, -0.30721840f, -0.49336898f, -0.39294294f, -0.00878355f, 
    0.17994231f, 0.12000389f, 0.06962039f, 0.08353079f, -0.13909958f, 0.03618220f, -0.07759304f, -0.12967521f, 
    -0.25057375f, -0.28744653f, -0.50833863f, -0.35791314f, 0.07984282f, -0.11374243f, 0.17846566f, -0.04983393f, 
    -0.03212580f, 0.00778958f, 0.01478275f, 0.07457856f, 0.02117877f, -0.16716954f, -0.19326159f, -0.05918315f, 
    -0.02249609f, -0.04986956f, 0.05560388f, -0.03667063f, 0.14278269f, -0.02676051f, 0.03271788f, -0.11864847f, 
    0.32433748f, 0.00656919f, -0.15377057f, -0.05638836f, -0.00064059f, -0.23544858f, -0.05965101f, 0.03069106f, 
    0.04384364f, 0.06114465f, -0.02588813f, 0.11762043f, -0.35058406f, 0.18827029f, 0.23714024f, 0.10163359f, 
    0.02943463f, 0.00753352f, -0.01510550f, -0.19432259f, -0.07911436f, -0.04500937f, 0.03423939f, -0.06370837f, 
    0.36789444f, 0.33286372f, -0.03419095f, -0.27734196f, -0.03730191f, -0.27965617f, -0.00488528f, -0.10096158f, 
    0.00190873f, -0.02758124f, 0.12056942f, 0.01999552f, 0.01394892f, -0.11436433f, 0.02765252f, -0.03813550f, 
    0.00467637f, 0.02204623f, -0.02463119f, 0.09339148f, 0.14167674f, 0.10559753f, 0.05064734f, -0.00039856f, 
    -0.30105275f, -0.14194088f, 0.05276778f, -0.01317834f, -0.15782744f, 0.00503726f, 0.03008076f, 0.01172565f, 
    0.10772306f, 0.12357759f, -0.07321531f, -0.18718147f, 0.00397318f, -0.16481403f, -0.23505668f, -0.48297477f, 
    0.08077613f, 0.00783153f, 0.12638032f, 0.03526355f, 0.11665857f, -0.00007674f, 0.04776311f, -0.05926025f, 
    -0.10560388f, -0.00694723f, -0.02968877f, 0.00736175f, 0.05798296f, 0.03838588f, 0.00388465f, 0.01063549f, 
    -0.01797458f, 0.05715090f, 0.07350925f, 0.10190982f, -0.02118526f, -0.13855565f, -0.06298339f, 0.08532372f, 
    0.03715336f, 0.08035472f, 0.05723317f, -0.02064263f, -0.08661354f, -0.18816955f, -0.00891056f, -0.02583318f, 
    0.86686522f, -0.24401605f, -0.20310523f, -0.12399821f, -0.03745569f, -0.00923277f, -0.01594116f, -0.27576894f, 
    0.00606044f, 0.10743862f, 0.03062505f, -0.02704348f, -0.07714298f, 0.12092394f, 0.15512857f, 0.07878680f, 
    -0.25014225f, 0.07728259f, -0.08135014f, -0.13252306f, -0.10872499f, -0.02629489f, -0.02856058f, -0.01826856f, 
    -0.27066049f, -0.09106316f, 0.10842171f, 0.05990643f, -0.00225978f, -0.01561555f, -0.01836261f, 0.00167351f, 
    -0.00639542f, 0.13064446f, 0.03809513f, 0.14402531f, -0.40378070f, -0.12899874f, 0.17568426f, -0.05186068f, 
    -0.04541370f, -0.04958629f, -0.12503746f, -0.07744922f, -0.22403997f, -0.05540578f, -0.12427870f, -0.14319029f, 
    0.01155151f, -0.06436652f, 0.07072550f, -0.07558947f, -0.08224469f, 0.00030591f, 0.02642142f, 0.02845688f, 
    0.03310250f, 0.07687330f, 0.11539359f, -0.02964376f, -0.04039808f, -0.08813065f, -0.32366949f, -0.08792067f, 
    0.03215120f, -0.02996450f, 0.03100125f, 0.02590224f, 0.09481255f, 0.19425873f, 0.05636581f, -0.03900579f, 
    -0.10040025f, -0.02376752f, 0.01658644f, -0.05156542f, -0.03151957f, -0.04111753f, -0.05980536f, 0.02409826f, 
    0.09479488f, -0.01220933f, 0.07857146f, 0.11791871f, 0.03457031f, -0.18837330f, -0.03479268f, 0.16426891f, 
    -0.02201325f, -0.09435813f, -0.03749518f, 0.05604408f, -0.05297706f, 0.01916918f, 0.08973684f, 0.08538222f, 
    0.12035825f, 0.16297287f, -0.28349054f, -0.27467147f, 0.16855913f, -0.13731554f, 0.21667804f, -0.14233841f, 
    0.03787214f, 0.00293915f, 0.09644305f, 0.03076238f, 0.00876961f, -0.06241036f, 0.11295401f, -0.03851424f, 
    -0.03362918f, -0.03594296f, -0.05301368f, 0.10759262f, -0.13906978f, 0.06673942f, 0.02266910f, 0.05395455f, 
    0.18720247f, -0.27488124f, -0.36776114f, -0.22802004f, 0.03100400f, -0.13592298f, 0.04298994f, -0.11485010f, 
    -0.02831499f, 0.01301953f, 0.02196809f, 0.03687409f, 0.04660197f, -0.10961473f, -0.06116145f, -0.07434604f, 
    -0.07293878f, -0.02195684f, -0.04093860f, 0.05198809f, 0.04651220f, 0.00608229f, 0.12581427f, -0.05380362f, 
    -0.00784258f, -0.14949791f, -0.10872342f, 0.05551546f, 0.13697384f, 0.00316729f, 0.06053263f, 0.16543745f, 
    -0.00829807f, 0.00808176f, -0.04087847f, -0.04970475f, 0.30453664f, 0.08390430f, -0.53699857f, 0.05157484f, 
    -0.06321100f, -0.00035908f, 0.10609800f, -0.09033524f, 0.01345520f, 0.01160299f, 0.06063062f, 0.02239244f, 
    -0.10591132f, -0.27644303f, -0.19280244f, -0.19821049f, -0.14238770f, 0.04465138f, 0.10233811f, 0.09153326f, 
    0.07441385f, 0.11873941f, 0.02598235f, 0.07737257f, -0.26443079f, 0.01752624f, -0.02705711f, 0.03502781f, 
    0.12961602f, -0.07537053f, -0.06859221f, 0.03644605f, 0.06259274f, 0.02255632f, 0.04286210f, 0.03232713f, 
    -0.38845834f, 0.06310890f, 0.01484283f, 0.34970194f, -0.22964491f, 0.17479491f, 0.01348034f, 0.06194948f, 
    -0.01314002f, 0.26939493f, 0.03486657f, 0.03359605f, -0.17288849f, -0.25716802f, -0.23464288f, -0.25039303f, 
    0.11546542f, 0.02111632f, -0.02252446f, 0.10453832f, 0.08929132f, 0.01840069f, 0.02197432f, -0.09922872f, 
    0.31582448f, -0.02076733f, -0.31220514f, -0.44735393f, 0.02897584f, -0.09982438f, -0.08211654f, -0.02519515f, 
    0.09996329f, -0.01198829f, 0.04256473f, -0.04497042f, 0.09348625f, -0.37951183f, -0.26993823f, 0.08572775f, 
    0.10041671f, 0.06500562f, 0.13586414f, -0.09108935f, -0.07707658f, -0.04206665f, -0.04086417f, -0.14678216f, 
    -0.36776516f, 0.07728460f, 0.17786460f, 0.04292976f, -0.03583411f, -0.06645204f, -0.10013074f, 0.05411723f, 
    -0.13739750f, -0.02485728f, -0.01836000f, -0.09717058f, -0.19850284f, -0.24847323f, 0.01636658f, 0.26817796f, 
    -0.02323287f, -0.02510555f, 0.17094533f, -0.05583500f, 0.04052713f, -0.01594110f, 0.04043724f, -0.05446561f, 
    0.00151709f, 0.03958146f, -0.00413872f, -0.21380420f, -0.06970125f, -0.08679765f, -0.01340498f, -0.05854374f, 
    -0.03580690f, 0.00273018f, -0.01647079f, 0.04160472f, 0.33408326f, 0.01677510f, -0.03754439f, -0.04284940f, 
    0.03325170f, -0.02569351f, 0.16319537f, -0.12993714f, 0.08665154f, 0.01069028f, 0.30426779f, -0.00912838f, 
    0.34216669f, 0.12303285f, 0.00667494f, -0.27853021f, -0.03510200f, -0.05534506f, -0.03228383f, -0.01697684f, 
    0.03583329f, 0.10853046f, 0.09389932f, -0.01256341f, 0.17389078f, -0.01095973f, -0.04873984f, -0.01693003f, 
    0.04099773f, -0.08722201f, 0.03363659f, -0.04450920f, 0.01966355f, -0.05557401f, 0.06902211f, 0.06638016f, 
    -0.25735754f, -0.01127464f, 0.13501471f, 0.06672055f, -0.08308278f, 0.07081717f, -0.08739563f, -0.05874191f, 
    -0.03753651f, -0.07951584f, 0.05759920f, 0.06834272f, 0.08204827f, 0.01209052f, -0.08623523f, 0.01122362f, 
    0.02979966f, 0.04433151f, 0.04637567f, 0.02694444f, -0.17602366f, -0.17105098f, -0.14595814f, -0.28253388f, 
    0.07199632f, -0.47679639f, -0.29936922f, 0.19413835f, 0.00102657f, 0.06688367f, 0.03598569f, 0.06335524f, 
    -0.07245762f, 0.00194555f, 0.07990517f, -0.02204680f, -0.08629584f, -0.18913068f, -0.19619572f, 0.37365788f, 
    0.05950121f, 0.05291831f, 0.16461600f, 0.01852299f, -0.05221006f, -0.04702831f, 0.03804505f, 0.12533683f, 
    0.11979326f, 0.00965283f, -0.09998456f, -0.31093588f, -0.15338613f, -0.04682546f, 0.00800187f, -0.01893498f, 
    -0.06738151f, -0.03786984f, 0.01766668f, 0.11131774f, -0.03571508f, 0.08195461f, 0.12269332f, -0.04786203f, 
    -0.04469224f, 0.04766734f, -0.02263169f, -0.11276798f, 0.00429768f, 0.02791481f, -0.07551935f, -0.03089646f, 
    -0.23381162f, 0.04413716f, -0.18654078f, 0.19746280f, -0.02103682f, 0.03580267f, 0.02915938f, -0.01880609f, 
    -0.06037191f, 0.10622624f, 0.05685487f, 0.16632874f, -0.01383742f, -0.13269414f, -0.09049320f, -0.22366247f, 
    0.00626782f, -0.19095434f, 0.08776535f, 0.11520593f, 0.00477647f, -0.03012880f, 0.02857160f, 0.05646972f, 
    -0.06818756f, -0.12561312f, -0.08188382f, 0.06594544f, 0.03020339f, -0.07924878f, 0.02943995f, -0.22406089f, 
    0.10473850f, 0.04147740f, 0.06342759f, 0.21690539f, -0.26092225f, -0.00345165f, 0.17892829f, 0.10567118f, 
    0.04291403f, 0.04355269f, -0.24296632f, -0.04972175f, 0.04131189f, -0.07833989f, -0.02898714f, 0.02228292f, 
    0.20771657f, -0.12358747f, -0.54699618f, 0.10284153f, -0.02695929f, 0.04275331f, 0.06915696f, 0.07335095f, 
    0.00983870f, 0.00370630f, -0.03534755f, 0.07186002f, 0.24424787f, -0.13987722f, 0.14074039f, 0.33476958f, 
    0.14524068f, -0.14297266f, -0.04511929f, -0.03795839f, 0.06187527f, -0.04164652f, -0.04170849f, -0.05574967f, 
    0.36707866f, -0.13181262f, 0.50020462f, 0.01287869f, -0.06223454f, -0.24504772f, -0.03554294f, -0.19109860f, 
    -0.14102881f, 0.02681235f, -0.03816321f, 0.09703922f, -0.27653879f, 0.03614713f, -0.23888458f, 0.22708474f, 
    -0.04242871f, 0.01949986f, -0.00731918f, 0.03418081f, -0.05665777f, 0.04299022f, -0.04526867f, -0.12945940f, 
    -0.05268227f, 0.08374190f, -0.30979130f, 0.08735556f, -0.11009728f, -0.17279291f, -0.07632432f, 0.16305673f, 
    0.08580169f, 0.01223865f, 0.05225239f, 0.06298839f, -0.16831028f, 0.06643634f, 0.58212715f, -0.23833944f, 
    0.03600975f, -0.28065369f, 0.15332654f, -0.10197092f, -0.14481801f, 0.04481025f, 0.06126507f, -0.05088987f, 
    0.09253787f, 0.01247059f, 0.14521050f, -0.14197062f, -0.04850225f, 0.00016041f, -0.03526653f, -0.03431112f, 
    -0.00561914f, 0.12795404f, 0.12373048f, 0.13180134f, -0.12880066f, 0.19121082f, 0.16998161f, 0.16927871f, 
    0.01953319f, -0.26621211f, 0.11046074f, 0.06533496f, 0.02170565f, 0.04900219f, 0.10582161f, 0.10431959f, 
    -0.15368985f, 0.08327404f, 0.15276542f, -0.14078331f, -0.04382544f, -0.21999216f, 0.10978770f, 0.31117484f, 
    0.00756239f, 0.04204890f, 0.04290476f, -0.01227969f, -0.31214693f, -0.04826489f, 0.03684610f, -0.25620684f, 
    -0.16606638f, 0.00716055f, 0.03764506f, -0.01741688f, 0.03124675f, 0.08312493f, 0.02323186f, -0.08066571f, 
    -0.04124101f, 0.15708467f, 0.28210014f, -0.19084604f, 0.01509281f, -0.09654326f, -0.11022409f, -0.00621293f, 
    -0.02468885f, 0.02996771f, 0.05172865f, 0.03001391f, 0.16358498f, -0.07014471f, 0.22350474f, -0.21993844f, 
    0.12971281f, -0.07014998f, -0.05322378f, -0.01383735f, -0.06277994f, -0.16170566f, 0.00836296f, 0.08113673f, 
    0.00662766f, -0.02746874f, 0.19066577f, 0.12589130f, 0.10674288f, 0.06411062f, -0.11922292f, -0.01881843f, 
    -0.08147666f, -0.02233928f, 0.01122423f, 0.05628381f, 0.04961364f, 0.13776056f, 0.18848781f, -0.03695232f, 
    0.05460923f, -0.15684377f, 0.03197351f, 0.12413663f, 0.03356772f, 0.09697357f, 0.09619246f, 0.05585448f, 
    0.19092669f, 0.05687594f, 0.07686078f, 0.06400324f, -0.02717454f, -0.08465853f, -0.06189606f, -0.10018618f, 
    0.09823854f, 0.03806482f, -0.12599877f, 0.06554955f, 0.06066800f, -0.11624884f, 0.37372383f, -0.25525621f, 
    0.07438483f, -0.01034507f, 0.10076192f, 0.01211599f, -0.03165166f, 0.12337111f, 0.02725995f, 0.01035654f, 
    -0.40496984f, 0.23345572f, -0.32164177f, 0.01598539f, 0.06706646f, -0.11683286f, 0.16579433f, 0.05736505f, 
    0.09878919f, -0.02565195f, 0.02433465f, -0.04523607f, 0.15355274f, 0.02908376f, 0.14091429f, -0.21113563f, 
    -0.16659434f, -0.23929754f, -0.02225993f, 0.00629175f, -0.02426069f, 0.02750961f, 0.02589725f, 0.06629270f, 
    -0.05648992f, -0.30751723f, 0.13906306f, 0.05411613f, -0.07489812f, 0.06928486f, -0.11658801f, -0.06942660f, 
    0.06183888f, -0.03592714f, 0.03731687f, -0.00920887f, -0.07568798f, 0.09299400f, 0.12523381f, 0.29854074f, 
    -0.00098789f, -0.08408105f, -0.13777190f, -0.07277916f, 0.24942721f, -0.01002679f, -0.05133149f, 0.05093168f, 
    -0.18515565f, -0.30259061f, -0.14880563f, -0.07478529f, 0.18602289f, 0.08825940f, -0.00650740f, 0.26281029f, 
    0.03528864f, 0.01122381f, -0.02759455f, -0.14514704f, -0.16506338f, 0.15890929f, -0.25391591f, -0.03641109f, 
    0.08724220f, -0.09959520f, 0.11627430f, 0.02650587f, -0.10170824f, 0.03592455f, -0.05935879f, -0.00830684f, 
    -0.50013584f, -0.35988644f, 0.04882399f, -0.09127580f, -0.03298365f, 0.08148682f, -0.14883851f, -0.00369706f, 
    0.04608341f, -0.01095838f, 0.00841109f, -0.00771950f, 0.05291413f, -0.12034690f, -0.11009054f, -0.00201740f, 
    -0.15915045f, -0.01632162f, -0.14540894f, -0.10046443f, 0.05198576f, -0.10114586f, -0.10489174f, -0.12438666f, 
    0.31784558f, 0.16152705f, 0.24877696f, 0.16562554f, -0.08225401f, -0.04333046f, -0.15945064f, -0.09571017f, 
    0.10805222f, 0.14830895f, -0.00471037f, 0.14419580f, -0.09769569f, -0.05822477f, 0.08131064f, 0.09720889f, 
    0.07247362f, 0.01430702f, -0.01955754f, -0.01726658f, -0.03236023f, 0.13207360f, 0.01170498f, -0.06963397f, 
    -0.02341753f, 0.02143901f, 0.00186297f, -0.17068495f, 0.07658260f, -0.02481843f, 0.17605908f, -0.04238508f, 
    -0.00565370f, 0.07808252f, -0.13599619f, 0.07270045f, 0.06947078f, -0.00162528f, 0.47022471f, -0.50043845f, 
    0.04014977f, -0.02752329f, -0.13024826f, -0.18047942f, -0.01929659f, 0.08261335f, -0.05805850f, 0.04481040f, 
    0.04956232f, -0.78656965f, 0.13253255f, -0.12137703f, 0.00844576f, -0.09713415f, 0.08217020f, -0.03278527f, 
    0.01593924f, 0.01408541f, 0.00042838f, -0.08906630f, 0.16246541f, -0.75804156f, 0.21014163f, -0.31717661f, 
    -0.08618025f, 0.09754171f, 0.01292860f, 0.08685255f, -0.02697877f, 0.01834773f, -0.03548712f, 0.02576567f, 
    0.01005742f, -0.08773047f, 0.01469072f, -0.22497943f, -0.01923916f, -0.08330890f, 0.08385503f, -0.03096831f, 
    0.09457668f, 0.02331656f, -0.10005208f, -0.15549833f, -0.10186245f, -0.11828419f, -0.15344088f, -0.14839633f, 
    0.03741423f, -0.00397627f, 0.19894382f, 0.05253549f, 0.10420856f, 0.11500145f, 0.00476661f, 0.25090769f, 
    -0.02584851f, -0.19839828f, 0.13109381f, 0.07537410f, 0.00659181f, 0.09123632f, -0.08996440f, -0.10095466f, 
    -0.19458066f, 0.03359044f, 0.01431633f, -0.31914026f, 0.03800409f, 0.15322374f, 0.00995794f, 0.21880510f, 
    -0.00872594f, 0.13230634f, -0.14363174f, -0.15769257f, 0.14876962f, -0.13467848f, -0.10331265f, 0.02826471f, 
    0.02600956f, -0.07906832f, -0.02867011f, -0.01755859f, 0.04072190f, 0.08005235f, 0.04187452f, 0.02513643f, 
    -0.02072978f, -0.01538080f, 0.16595554f, 0.00881884f, -0.20860022f, 0.04883214f, 0.04773916f, -0.15931229f, 
    -0.18140116f, -0.17568339f, 0.04946788f, 0.07272825f, -0.04707771f, -0.01240816f, -0.00643657f, -0.12319864f, 
    -0.26377746f, -0.17349809f, 0.35655233f, 0.25359163f, 0.02736898f, -0.02667601f, -0.06109456f, -0.22269359f, 
    0.11910190f, -0.08943951f, -0.16644366f, 0.03802175f, 0.10760670f, -0.03113077f, 0.14957450f, -0.24517919f, 
    -0.03502873f, 0.01991648f, -0.15323140f, -0.11820584f, 0.09569498f, -0.10806565f, -0.05566731f, 0.08637214f, 
    -0.17693695f, -0.11236479f, 0.10748731f, -0.19092506f, -0.08438068f, -0.21377049f, -0.00894417f, 0.12570447f, 
    0.04576473f, -0.05227567f, 0.03078158f, 0.02734404f, 0.10674722f, 0.12794708f, -0.02969154f, 0.24102339f, 
    -0.00292472f, -0.08044817f, -0.13425475f, -0.16253954f, 0.04112821f, 0.02449231f, 0.02030400f, 0.07004040f, 
    -0.23318468f, 0.22226050f, -0.07857892f, -0.05214597f, -0.20456341f, -0.14648776f, -0.11771618f, -0.17090011f, 
    0.18547191f, -0.04492053f, -0.12501900f, -0.03639299f, -0.41665769f, -0.18893322f, 0.00343646f, 0.17125167f, 
    -0.01800750f, -0.21788676f, -0.23221299f, -0.05719013f, 0.02879334f, 0.03834877f, -0.03071922f, -0.02114828f, 
    0.04164851f, 0.20854060f, 0.09383920f, 0.36409798f, 0.08739660f, 0.03075353f, -0.27715611f, -0.11497094f, 
    -0.10595507f, -0.16347991f, 0.07691397f, 0.00903592f, 0.14275680f, -0.03229266f, -0.29993007f, 0.03283154f, 
    -0.10314330f, -0.13216284f, -0.08003572f, -0.10473187f, -0.01051402f, 0.01420040f, -0.08836747f, -0.08086483f, 
    -0.17641029f, 0.14671232f, 0.10675865f, -0.41662320f, -0.06279554f, 0.11403577f, 0.04184807f, 0.01109303f, 
    0.07817425f, 0.11457161f, -0.10032089f, -0.01174832f, 0.18190564f, 0.25886065f, 0.09804766f, -0.14389282f, 
    -0.07553575f, 0.00658908f, 0.13059674f, 0.00599169f, 0.16729829f, 0.07017872f, 0.07721058f, 0.03053544f, 
    0.04481427f, 0.37968203f, -0.00975844f, 0.64573616f, -0.01611847f, -0.04612022f, -0.07306895f, 0.00314230f, 
    0.01399935f, -0.08159228f, 0.13487257f, -0.07566865f, -0.15072325f, -0.22555394f, -0.16682971f, -0.39141101f, 
    -0.21467352f, 0.06759053f, -0.07944576f, -0.13837628f, 0.17130242f, 0.01696500f, -0.00711142f, 0.02992640f, 
    -0.06489152f, -0.06580091f, -0.44274515f, 0.06853455f, -0.02460322f, 0.25967485f, 0.16018999f, 0.10555986f, 
    0.04381547f, -0.03334329f, -0.02506030f, 0.03684037f, 0.14954740f, -0.47110018f, -0.03594879f, -0.23017278f, 
    -0.06488387f, -0.02068639f, -0.13900538f, 0.08521619f, -0.07628539f, 0.02026264f, -0.01000959f, 0.10596906f, 
    -0.04588711f, -0.24972121f, -0.24485137f, 0.07965070f, 0.07866720f, 0.20084268f, 0.07312263f, 0.05538296f, 
    0.10651191f, -0.01798598f, 0.10768235f, 0.02913195f, 0.05216824f, -0.34195185f, 0.32218739f, -0.06898123f, 
    0.06111508f, -0.23496765f, -0.18248333f, 0.06744786f, -0.13797478f, 0.12155808f, -0.10172545f, 0.06101288f, 
    0.00227639f, -0.13089432f, -0.08963700f, 0.00376881f, 0.10530253f, -0.12889819f, -0.06321860f, -0.11625973f, 
    -0.08024964f, -0.03667719f, 0.00460357f, -0.01682754f, -0.00029170f, -0.21087998f, -0.22402857f, -0.05569705f, 
    -0.00660716f, 0.01773005f, 0.00101089f, 0.08895437f, 0.08139808f, -0.07501271f, -0.12016816f, -0.11118195f, 
    -0.18379521f, 0.00661328f, 0.00900407f, -0.26830727f, 0.09617009f, 0.15271604f, -0.04206549f, -0.05467178f, 
    0.15718424f, 0.02767079f, -0.11573217f, -0.07182240f, -0.04752314f, -0.02421055f, 0.33066890f, 0.14279068f, 
    -0.00150188f, -0.07687744f, -0.00628394f, -0.12067377f, 0.23849608f, -0.02572669f, 0.03838497f, 0.05166850f, 
    -0.15893002f, 0.25299761f, -0.02887759f, -0.20042306f, -0.19368191f, -0.05961857f, 0.04519382f, -0.08036963f, 
    0.06311349f, -0.01053103f, 0.00043664f, 0.01168803f, 0.33587325f, -0.06972335f, 0.08878502f, -0.28455168f, 
    0.06010019f, 0.03127442f, -0.02481331f, 0.07230631f, -0.00243753f, -0.04704680f, -0.03466749f, 0.04993469f, 
    -0.31372541f, 0.02419259f, 0.19438282f, 0.12451520f, 0.05225275f, 0.18231006f, -0.18511246f, 0.00747805f, 
    0.02604828f, -0.01970561f, -0.01122752f, 0.06428794f, 0.13509347f, -0.46631244f, -0.03733248f, -0.05987877f, 
    0.23941252f, 0.17076975f, 0.03000608f, 0.10568384f, 0.04847772f, -0.09568244f, -0.03601955f, -0.08430570f, 
    -0.07238921f, 0.13945235f, -0.00093296f, -0.15840578f, -0.10581325f, -0.01369480f, 0.03834640f, 0.04252343f, 
    -0.05427087f, -0.06558752f, -0.23827833f, -0.19903132f, 0.14488566f, -0.15088747f, 0.07226452f, 0.08228697f, 
    -0.18801689f, 0.05298235f, -0.03987980f, 0.11695981f, 0.07639831f, 0.10416061f, -0.05119758f, -0.06409948f, 
    -0.04388618f, -0.12937215f, -0.05566053f, -0.06609730f, -0.04649650f, 0.17497839f, 0.12888399f, 0.03183640f, 
    -0.06615780f, -0.00156308f, -0.00086106f, -0.20927581f, 0.10840769f, -0.21904941f, 0.26603487f, -0.23789999f, 
    -0.10174634f, 0.22029807f, 0.12092291f, 0.19435413f, 0.06422166f, 0.00775864f, -0.01942326f, -0.02704649f, 
    -0.00358012f, -0.11415100f, -0.12114454f, -0.08047386f, 0.14179900f, -0.07787814f, 0.12349650f, -0.12066393f, 
    0.05554208f, 0.02099145f, -0.14646241f, 0.01742326f, -0.36054969f, 0.12647328f, -0.07371609f, -0.05819796f, 
    0.00299095f, -0.17122245f, 0.07743990f, 0.05727979f, 0.00633873f, 0.00475937f, -0.03401987f, 0.01630213f, 
    -0.18768702f, 0.28691110f, -0.24491554f, -0.01514758f, -0.03094227f, -0.03497989f, 0.10543083f, 0.02711955f, 
    0.12338997f, 0.02100567f, 0.06954396f, -0.06088696f, 0.10462883f, 0.32219163f, 0.02142575f, 0.00870811f, 
    0.01063174f, -0.04117814f, 0.08725055f, -0.16922808f, 0.05303161f, 0.01406601f, 0.06581978f, 0.04658705f, 
    0.00583409f, 0.20165175f, 0.05040199f, 0.06061171f, 0.09475745f, 0.08308318f, -0.29262558f, -0.07775699f, 
    -0.03849642f, 0.14519385f, 0.14557034f, -0.18354750f, -0.23088863f, 0.13573709f, -0.37377647f, 0.18561232f, 
    -0.05985685f, 0.01725543f, -0.00316054f, 0.20955510f, -0.01841356f, -0.04254499f, 0.05660926f, -0.05513202f, 
    -0.08642409f, 0.17252944f, 0.01612313f, 0.03187628f, 0.00932368f, -0.08467597f, -0.12736295f, 0.08860449f, 
    -0.21754086f, -0.13614617f, -0.37364957f, -0.36603644f, -0.06047587f, 0.00097434f, -0.38026303f, -0.02396002f, 
    -0.03842894f, 0.04416532f, -0.01369582f, 0.05169919f, -0.05735987f, -0.01210069f, -0.06524948f, -0.06128886f, 
    -0.10694626f, -0.22571352f, -0.06985415f, 0.07457872f, -0.05191887f, 0.02605741f, -0.19978969f, -0.13634729f, 
    0.01426591f, 0.03722308f, 0.04036866f, 0.03335888f, 0.06813101f, -0.35148057f, -0.14150077f, -0.06047934f, 
    -0.02499390f, -0.00598432f, -0.01421466f, 0.10918322f, -0.03369628f, -0.00678297f, 0.03492931f, -0.14092034f, 
    0.08894295f, -0.08429948f, 0.11279619f, -0.03071921f, 0.04563583f, 0.01008809f, -0.06214167f, 0.09682500f, 
    -0.05160923f, -0.09684782f, -0.22312705f, -0.39192337f, -0.12795098f, 0.12051034f, 0.03623088f, 0.25175601f, 
    -0.03381039f, -0.03671261f, 0.12656561f, 0.03674630f, -0.09009032f, -0.06832863f, 0.01988268f, 0.10723441f, 
    -0.06441588f, -0.06253153f, 0.18696225f, -0.13731799f, -0.13001460f, -0.03355862f, 0.00490946f, 0.00772407f, 
    0.03232154f, -0.01302877f, 0.00710226f, 0.20784518f, -0.27613458f, -0.12294943f, -0.06341329f, 0.01600321f, 
    0.09695485f, -0.02277029f, -0.01295530f, -0.04261502f, -0.12392163f, -0.13671030f, -0.13421869f, -0.08928699f, 
    -0.17154410f, 0.18264575f, -0.09892289f, -0.20900898f, -0.03024231f, 0.15259010f, 0.11379756f, -0.19987592f, 
    0.00177214f, 0.08663573f, 0.20682780f, 0.25069591f, -0.12477454f, 0.15808955f, 0.07826839f, 0.00988521f, 
    -0.03268400f, -0.04513187f, -0.01013768f, 0.13226758f, -0.05093215f, -0.32084307f, -0.18704955f, -0.04463895f, 
    0.09224463f, 0.10047927f, 0.13693638f, 0.09285449f, -0.11189329f, -0.06327954f, -0.00697283f, 0.01261076f, 
    -0.00659269f, 0.15223479f, 0.00226204f, 0.03062300f, 0.11439259f, 0.08686960f, 0.11451568f, 0.06969008f, 
    0.03514611f, -0.02382425f, -0.06170455f, 0.08732393f, -0.05101029f, 0.00570121f, 0.03939943f, -0.00456013f, 
    -0.23919022f, -0.00387005f, -0.57748616f, -0.00799258f, 0.04910107f, 0.02961313f, -0.02036140f, -0.05241839f, 
    0.00621697f, 0.07978471f, -0.18655972f, -0.10261904f, -0.19112396f, 0.11177351f, 0.24473181f, -0.25063518f, 
    -0.09512444f, 0.01577943f, -0.23620541f, 0.15099660f, -0.07366149f, -0.00888819f, -0.03705334f, -0.01639722f, 
    -0.32457563f, 0.23357539f, -0.39165148f, 0.11412593f, 0.04960257f, 0.12285877f, -0.10748038f, 0.05285102f, 
    -0.01770308f, 0.11571328f, 0.06216316f, 0.10291369f, 0.04983740f, -0.06831402f, -0.17963038f, -0.01790551f, 
    -0.13094756f, -0.05086983f, 0.27996534f, -0.19607602f, 0.00520763f, 0.12325359f, -0.10431468f, -0.12704007f, 
    -0.21087942f, -0.12558487f, -0.28325772f, 0.05361392f, 0.01970726f, 0.04821442f, 0.13298956f, -0.14355017f, 
    -0.01852723f, -0.00679775f, -0.01137619f, -0.03652195f, -0.28201768f, 0.21036710f, 0.11427817f, -0.20129853f, 
    0.13023473f, 0.11276063f, 0.03228913f, -0.06235600f, -0.12658374f, 0.17211728f, -0.06817443f, 0.11708103f, 
    -0.07371689f, -0.13377064f, -0.03940538f, 0.02682519f, 0.00401650f, -0.26174906f, -0.20058013f, 0.05182993f, 
    -0.18108198f, 0.05787970f, -0.13893175f, -0.28300470f, -0.06633832f, 0.09897131f, -0.34358373f, 0.19246250f, 
    0.08536518f, 0.04813061f, 0.06769087f, 0.09845284f, 0.03123663f, -0.01904135f, -0.09309261f, -0.16078739f, 
    0.10823675f, 0.05524911f, 0.02383632f, 0.00530083f, -0.15092041f, 0.00876349f, 0.08419991f, -0.04710770f, 
    -0.00895324f, 0.14385442f, -0.00915259f, 0.12209022f, -0.18822326f, 0.16685204f, -0.08828403f, 0.18760425f, 
    0.07752141f, -0.05671965f, -0.09878612f, 0.06696613f, -0.08304538f, -0.13993415f, -0.08680341f, -0.10167176f, 
    -0.64762992f, 0.04050387f, -0.06440005f, 0.13547221f, -0.00869905f, 0.09578700f, -0.11550507f, 0.03084591f, 
    -0.02802388f, 0.02043870f, 0.13312525f, -0.01272722f, -0.30381328f, -0.07704815f, 0.13391133f, 0.16932502f, 
    0.04091255f, 0.02617354f, -0.34439746f, 0.11657287f, 0.00077736f, -0.02214629f, 0.05745088f, -0.09793968f, 
    -0.13671558f, 0.21353847f, 0.13168250f, 0.26182145f, 0.01819507f, -0.01677587f, 0.12351713f, -0.07480070f, 
    -0.13664284f, -0.02022818f, 0.22167222f, 0.19501272f, 0.12767829f, 0.13366930f, 0.08044332f, -0.02766737f, 
    -0.17071696f, -0.02152989f, -0.02391259f, -0.12340438f, -0.02358454f, 0.04608892f, -0.19076030f, -0.20419407f, 
    0.01682962f, 0.29825732f, 0.08126675f, 0.10986496f, 0.07081374f, -0.01408093f, 0.10978802f, -0.07943393f, 
    -0.04225424f, 0.14073499f, 0.13154800f, 0.12035786f, 0.12842317f, 0.03020866f, 0.17099027f, 0.10461253f, 
    0.04994965f, -0.01149912f, 0.05832766f, -0.14607149f, -0.22013520f, 0.08025697f, -0.09141696f, 0.03702353f, 
    -0.08037005f, -0.12282207f, -0.00587623f, -0.16293064f, -0.20700665f, -0.08044444f, -0.09188654f, 0.05782061f, 
    -0.01980163f, 0.10037412f, 0.10024374f, 0.07204332f, 0.00752081f, -0.11526330f, 0.24133359f, 0.12966433f, 
    -0.02255240f, 0.07367834f, 0.12376963f, 0.07706232f, 0.03674186f, 0.06648336f, 0.15598145f, 0.07894330f, 
    -0.42940530f, 0.12515986f, -0.13543187f, -0.35895681f, 0.02981307f, 0.11852097f, 0.00329369f, 0.00665785f, 
    -0.21199995f, 0.00793365f, -0.05343705f, -0.02439486f, -0.01828444f, 0.06622671f, -0.04123043f, 0.15499856f, 
    -0.08237299f, -0.17712006f, -0.07022461f, -0.04074094f, 0.03437381f, 0.12886143f, -0.09209083f, 0.12786868f, 
    -0.16194101f, -0.18676771f, -0.07816491f, 0.07704219f, -0.01918024f, 0.05504608f, 0.05887553f, 0.11966225f, 
    -0.02862184f, 0.01578529f, 0.11595755f, 0.15441535f, -0.20605075f, 0.23311032f, -0.02503112f, -0.14931151f, 
    0.03041467f, 0.10957234f, -0.03725598f, 0.02387852f, -0.00764486f, 0.00594415f, 0.07603381f, -0.15585358f, 
    0.30804113f, -0.00948471f, 0.19045895f, -0.08905864f, -0.09701718f, -0.04525348f, 0.07893763f, 0.01801139f, 
    -0.14978909f, 0.00035084f, 0.01407278f, 0.03501853f, -0.44718799f, 0.37752548f, 0.12312542f, 0.01883260f, 
    0.01106915f, 0.15300629f, 0.05704459f, 0.10445761f, -0.14915657f, 0.08677400f, -0.17600235f, 0.08754186f, 
    0.44846109f, 0.09508146f, 0.20923130f, 0.03722481f, -0.04623892f, 0.06180935f, 0.01572634f, 0.16124703f, 
    -0.08149106f, 0.15759088f, 0.09658629f, 0.05114429f, 0.08874781f, 0.20738068f, -0.18470520f, 0.09465507f, 
    0.08267606f, -0.16916940f, -0.00323468f, 0.11351291f, -0.08471977f, -0.04299939f, -0.04909136f, -0.06306893f, 
    0.31900546f, -0.13390984f, 0.38573480f, 0.10342422f, -0.06840152f, 0.02431009f, 0.06319302f, 0.03572901f, 
    -0.09440590f, 0.06836927f, -0.05924811f, 0.09213448f, -0.17891692f, -0.12266172f, -0.13483769f, -0.08574845f, 
    0.05856338f, 0.07291024f, 0.00013374f, -0.01934380f, -0.03424575f, -0.00673077f, -0.03395795f, -0.10610358f, 
    -0.01727345f, 0.26200774f, -0.14283502f, -0.07837154f, -0.14227177f, 0.02882334f, 0.06296132f, 0.06829999f, 
    0.09682191f, 0.01789950f, -0.21025003f, -0.05963054f, -0.00389183f, -0.08208524f, -0.09979601f, 0.17482343f, 
    0.13437010f, -0.19559360f, 0.01050733f, 0.03396709f, -0.04572935f, 0.00817553f, -0.21529129f, -0.06770998f, 
    -0.04794168f, -0.24575473f, -0.07546835f, -0.19283356f, -0.15119897f, -0.27090305f, 0.07364380f, -0.07602736f, 
    -0.12799603f, 0.05947468f, -0.00282835f, -0.13381533f, -0.03837254f, 0.24273923f, -0.10225743f, 0.15796971f, 
    0.13631955f, 0.05418753f, 0.01431554f, 0.04260223f, -0.04366259f, -0.07094131f, -0.05890539f, -0.16632985f, 
    -0.34556669f, 0.06242914f, -0.48477733f, -0.47325641f, -0.16275451f, -0.08350140f, 0.05870187f, -0.07477901f, 
    -0.00410822f, 0.01706519f, 0.04485256f, -0.06160359f, -0.11944206f, 0.27560893f, 0.04845112f, 0.01851103f, 
    0.02860173f, -0.10169946f, -0.19275594f, -0.00150973f, 0.04476595f, -0.07210491f, -0.00103832f, -0.15589085f, 
    -0.24875747f, 0.14354709f, -0.17978883f, -0.06347672f, -0.08765128f, 0.04282834f, 0.12027613f, -0.15711690f, 
    0.01817825f, 0.11460142f, 0.05879939f, -0.02159110f, -0.26644856f, -0.23904666f, 0.35782456f, 0.01710599f, 
    -0.22737527f, 0.13112128f, -0.02361215f, -0.04076315f, 0.04042914f, 0.04938920f, 0.13252321f, 0.22103670f, 
    -0.29291853f, -0.03157283f, 0.21926878f, 0.11580584f, -0.12911507f, 0.09696923f, -0.09109240f, 0.12606166f, 
    -0.08968727f, -0.08021743f, 0.22427298f, -0.07193042f, -0.14503807f, 0.11440481f, -0.07029863f, 0.08495487f, 
    -0.00260488f, 0.05700408f, -0.03297373f, 0.05635206f, -0.03961722f, -0.14177835f, -0.15608214f, -0.19544327f, 
    -0.05872322f, -0.07235716f, 0.24467567f, 0.04513085f, 0.02055019f, -0.05475900f, 0.05591915f, 0.11996019f, 
    -0.03745469f, 0.02295167f, 0.11718980f, 0.06838698f, -0.02226189f, 0.09182460f, 0.00545196f, 0.12331653f, 
    0.03978654f, -0.11114206f, 0.01834122f, 0.00422654f, -0.11879531f, 0.02391802f, 0.07937426f, -0.09045345f, 
    -0.00505340f, -0.02864290f, 0.23481524f, -0.11550331f, -0.13988198f, 0.04108073f, -0.15951474f, -0.00911130f, 
    0.06836119f, -0.00130023f, -0.16647175f, 0.11476673f, -0.26383683f, -0.01919969f, -0.01081320f, -0.06872114f, 
    -0.15102182f, -0.00511458f, -0.11279594f, 0.09849083f, -0.03429521f, 0.09727085f, 0.05080329f, -0.05710730f, 
    -0.05621058f, -0.38689104f, 0.08264095f, -0.13964944f, 0.15990117f, -0.07295418f, 0.12358358f, -0.00410023f, 
    0.10861389f, 0.13973220f, 0.18128037f, 0.17110673f, 0.06424826f, 0.00830263f, 0.23238234f, -0.38669229f, 
    -0.08712962f, -0.12227256f, -0.03986929f, 0.00121616f, -0.02971417f, -0.01687392f, -0.04520754f, -0.12459694f, 
    0.26463285f, -0.12897532f, 0.06703480f, -0.05965523f, 0.05071081f, -0.05919814f, 0.15884988f, 0.22955568f, 
    0.22764091f, 0.08497698f, -0.06696443f, 0.11379355f, -0.06803194f, 0.17774300f, -0.17819962f, -0.24011323f, 
    0.02449770f, 0.14939976f, -0.08400530f, 0.02962164f, -0.00870652f, -0.06913143f, -0.00289528f, -0.01800289f, 
    0.42707071f, 0.18131101f, 0.09669672f, 0.12641262f, -0.08264248f, -0.11157349f, 0.08190988f, -0.09718879f, 
    0.00920760f, -0.00949800f, 0.01205831f, -0.07033578f, 0.08236745f, 0.22866867f, -0.14393757f, 0.14843415f, 
    0.15119891f, 0.04246538f, 0.06614683f, 0.03538521f, 0.09697788f, 0.04099311f, -0.04161991f, -0.14100592f, 
    -0.48500514f, -0.12073192f, -0.11280086f, 0.10477269f, 0.11769900f, -0.06631767f, -0.04639554f, 0.03135283f, 
    -0.10386515f, -0.07777689f, -0.11595216f, -0.11305062f, -0.06832030f, -0.23987119f, 0.34934935f, 0.39575827f, 
    0.02542109f, 0.06977334f, 0.04801740f, 0.00325146f, 0.00668619f, 0.13112986f, -0.17331037f, -0.07012673f, 
    -0.11243325f, 0.18024674f, 0.10492562f, 0.08634260f, 0.02446821f, -0.17925030f, -0.14810288f, 0.11309332f, 
    -0.05593525f, 0.03452076f, -0.07243663f, 0.07180121f, 0.24863259f, -0.32292530f, 0.27453852f, 0.03430149f, 
    0.05722759f, 0.08432395f, 0.03987015f, 0.05247979f, -0.11695403f, -0.00427108f, 0.07746744f, -0.02090565f, 
    -0.49451566f, 0.24761626f, -0.31080422f, -0.07391450f, -0.01300163f, -0.06187410f, 0.00661221f, 0.05120154f, 
    -0.07646529f, 0.02886960f, 0.07343472f, 0.07633217f, -0.05798368f, -0.29679689f, 0.04134840f, -0.18229495f, 
    -0.00311606f, -0.17861298f, -0.30290455f, 0.00501227f, 0.08624663f, 0.06677485f, 0.00998945f, -0.08473687f, 
    0.04926886f, -0.33604491f, -0.22046988f, 0.05139632f, -0.12093279f, -0.04928365f, -0.08270586f, -0.08361328f, 
    -0.06406825f, -0.01235295f, -0.14247629f, -0.08905188f, -0.22864312f, -0.03639996f, -0.13943030f, -0.22384982f, 
    -0.15962589f, 0.05313808f, 0.12603721f, 0.01329608f, 0.02733269f, 0.07748660f, 0.00655376f, -0.05100325f, 
    -0.12109984f, -0.20698072f, -0.24240978f, -0.32843941f, -0.01119206f, -0.04792563f, 0.09769315f, 0.10209879f, 
    0.01276127f, 0.10525285f, 0.09035085f, -0.00489282f, -0.21829922f, 0.07550214f, -0.16888726f, 0.03954215f, 
    -0.03267716f, 0.03894760f, 0.04514971f, -0.00327338f, -0.04732584f, 0.07479842f, -0.00726037f, -0.11556596f, 
    -0.21104547f, 0.04923089f, -0.27312714f, -0.02069680f, 0.12166397f, 0.01939013f, -0.13726363f, 0.07709474f, 
    -0.08704821f, -0.02044631f, -0.07595927f, 0.08493664f, 0.10300970f, -0.10342918f, 0.11006824f, -0.00740326f, 
    -0.01783681f, 0.01181498f, 0.02898166f, 0.06340339f, -0.03526856f, 0.03634650f, -0.00231873f, 0.09980450f, 
    -0.13405217f, -0.00751954f, -0.10330445f, 0.04597129f, 0.06911187f, -0.08400533f, 0.10787164f, 0.01861764f, 
    -0.01181943f, -0.01455442f, -0.11180434f, -0.35012525f, -0.05618017f, -0.06904010f, -0.19635552f, 0.07680166f, 
    0.00754239f, 0.02326467f, -0.03014176f, 0.03019153f, -0.12628140f, 0.21196319f, 0.02670271f, 0.06291243f, 
    0.20798837f, -0.28286690f, 0.33579445f, -0.04008214f, 0.20990284f, -0.03543617f, 0.14857504f, 0.03125137f, 
    -0.04634935f, 0.13803668f, 0.09461919f, 0.13471423f, -0.35875878f, -0.03513971f, -0.14187741f, -0.30233249f, 
    -0.15267846f, -0.10507854f, -0.16551742f, 0.06100709f, 0.00855344f, 0.11040547f, 0.00590332f, -0.06348700f, 
    0.05032851f, -0.09003082f, -0.45873058f, -0.03884418f, 0.00562041f, 0.04971633f, 0.06352280f, -0.04549966f, 
    -0.00012356f, 0.07730747f, 0.12411606f, 0.11983595f, -0.09153812f, -0.13550305f, -0.07839207f, -0.19901466f, 
    0.17059922f, 0.02405390f, 0.04367637f, -0.07774960f, 0.09883007f, 0.11983211f, 0.19404383f, 0.09632615f, 
    -0.03989077f, 0.01219124f, 0.12763271f, 0.18445894f, -0.06670920f, 0.00922701f, -0.16747227f, -0.16476949f, 
    -0.01987987f, -0.13478583f, 0.05689108f, -0.08324720f, 0.37774652f, -0.22886312f, 0.45066825f, -0.02046836f, 
    0.05833325f, -0.03142182f, -0.33693668f, 0.01470027f, 0.01677283f, -0.00871911f, 0.12214641f, 0.03249112f, 
    -0.40261286f, -0.09262498f, -0.12850632f, 0.21616521f, 0.15119934f, 0.06763200f, 0.13272353f, -0.26028669f, 
    -0.02504997f, -0.01571538f, 0.05740136f, 0.11060784f, -0.52964348f, 0.35331067f, -0.22680019f, 0.16844946f, 
    0.20339620f, -0.16760063f, 0.13784558f, -0.12005644f, -0.00276616f, 0.00824621f, -0.09500540f, 0.20194368f, 
    -0.37721175f, 0.03386266f, -0.24335925f, -0.02530540f, -0.13070716f, -0.07672544f, 0.08534581f, 0.08308790f, 
    -0.19940381f, 0.03278748f, 0.20185350f, -0.02679909f, -0.39756975f, -0.44382653f, -0.02896979f, 0.17093906f, 
    -0.08501869f, 0.10687237f, -0.09884711f, -0.13631234f, -0.00133788f, 0.04658319f, 0.17806084f, 0.02531959f, 
    0.07121407f, -0.08804406f, 0.03194635f, -0.12240154f, 0.00985338f, 0.00160673f, -0.09408665f, 0.10831080f, 
    -0.14440602f, -0.14884414f, -0.14889735f, -0.20743985f, -0.27349973f, 0.12243433f, -0.18624674f, 0.32101676f, 
    -0.01740971f, -0.11417130f, 0.11488576f, -0.03153403f, -0.02746352f, 0.01179515f, -0.04753611f, 0.04862898f, 
    0.02685813f, 0.29414061f, -0.41389942f, 0.25905141f, -0.12627083f, -0.07609314f, 0.10699064f, 0.23246464f, 
    -0.06558459f, 0.05864633f, -0.03568601f, 0.02052210f, -0.12728001f, 0.41075793f, -0.22784579f, 0.15337867f, 
    -0.15495449f, -0.04162190f, 0.11493446f, 0.05614522f, -0.03610604f, 0.03365747f, 0.02589915f, -0.09333990f, 
    0.02617605f, 0.05573588f, -0.04046936f, 0.21037617f, 0.03858913f, 0.17950813f, -0.09344795f, 0.10980529f, 
    -0.08644339f, -0.00086832f, -0.03296237f, -0.00554328f, 0.18234296f, -0.06311153f, -0.02222827f, -0.01542671f, 
    -0.05369962f, 0.18620683f, -0.11937875f, 0.15980531f, -0.19147757f, 0.07670113f, 0.02296094f, 0.10629719f, 
    -0.31272221f, 0.28184879f, -0.41184938f, 0.13976675f, 0.02720094f, -0.02765339f, -0.07476630f, -0.01536909f, 
    0.01372969f, -0.01783598f, 0.12308387f, 0.02269590f, -0.16061012f, -0.18321016f, -0.23112176f, 0.20191313f, 
    0.11755033f, -0.08989663f, 0.02943757f, -0.07326514f, -0.03494567f, -0.13575585f, 0.15946428f, 0.02150321f, 
    0.03220850f, 0.08643102f, 0.00500941f, 0.07865988f, -0.00099104f, 0.02810350f, 0.01395913f, -0.00144012f, 
    0.01528363f, 0.05104819f, 0.01129133f, 0.02696469f, 0.01504260f, 0.03451388f, 0.08417235f, -0.24795166f, 
    0.01344395f, 0.04410489f, -0.20741947f, 0.13757983f, -0.07203609f, -0.04860370f, -0.08901704f, -0.06734022f, 
    -0.09289089f, -0.08420531f, -0.24922615f, 0.18461150f, 0.09173939f, 0.07367291f, 0.18446398f, -0.08388551f, 
    0.04069233f, 0.08436757f, 0.09205534f, -0.11055856f, -0.14943953f, 0.16829774f, 0.03586336f, -0.06718733f, 
    -0.01732066f, 0.10655893f, 0.06726211f, -0.12040588f, 0.14196004f, -0.05916873f, 0.01638361f, -0.06354166f, 
    0.07073575f, -0.19243705f, 0.00967940f, -0.12306117f, -0.06492204f, -0.09010003f, -0.29947203f, -0.19700697f, 
    -0.01147068f, -0.06475386f, -0.04421436f, -0.13223845f, -0.26201159f, -0.01629903f, -0.13764584f, -0.04376051f, 
    0.07429799f, 0.01331765f, 0.08182536f, 0.00622499f, -0.03430133f, 0.00718925f, 0.00711447f, 0.21598403f, 
    -0.09890971f, 0.24986990f, -0.14873210f, -0.15495726f, -0.03738106f, 0.22399935f, 0.19197020f, -0.12072027f, 
    -0.04825590f, 0.04150404f, 0.01559794f, -0.13166693f, 0.05801764f, -0.15404212f, 0.17193814f, 0.01471244f, 
    -0.03461031f, 0.10375483f, -0.11545135f, -0.14485383f, 0.06952366f, -0.04826900f, 0.12598607f, -0.08032741f, 
    -0.38735041f, -0.11219276f, -0.15184689f, 0.07374185f, 0.04465007f, 0.07010690f, -0.05081465f, -0.02118792f, 
    -0.12110718f, -0.20061368f, -0.06449343f, -0.25804138f, 0.00469914f, -0.22900110f, 0.33679265f, 0.31620717f, 
    -0.13000619f, -0.00655820f, 0.09101927f, -0.05478329f, -0.07603031f, -0.03422495f, -0.00589677f, 0.14711441f, 
    -0.29251528f, -0.17404051f, 0.11940516f, -0.15304677f, -0.04887346f, 0.23373602f, -0.11843269f, -0.00223631f, 
    -0.06408925f, -0.00784366f, 0.06124127f, 0.00702992f, -0.28732955f, -0.48185608f, 0.20107782f, -0.11346231f, 
    -0.00690435f, 0.00569813f, -0.03921492f, -0.11361070f, 0.01569584f, 0.06222782f, 0.07217423f, 0.15795697f, 
    -0.07596806f, -0.21723688f, -0.17176120f, 0.19558609f, 0.06884855f, -0.02026817f, 0.03204758f, -0.13650256f, 
    -0.00711039f, 0.04975495f, 0.05913616f, 0.17968389f, -0.14395878f, 0.53788286f, -0.44307315f, 0.08680615f, 
    -0.10092440f, 0.02808033f, 0.12155542f, -0.03982772f, 0.00537730f, 0.03612833f, 0.04722928f, 0.09790061f, 
    0.29610655f, 0.30709806f, 0.17773454f, 0.05451860f, -0.10117871f, -0.02165414f, -0.00892668f, -0.03758182f, 
    -0.03087565f, 0.04101326f, -0.05134931f, 0.00607967f, -0.49754137f, 0.17599891f, -0.06496207f, 0.27080110f, 
    0.02361043f, 0.11535225f, 0.15967964f, 0.16448066f, -0.12140726f, 0.01508971f, -0.00834387f, 0.08071054f, 
    0.27375907f, 0.17368715f, -0.10651230f, -0.02933229f, -0.05824362f, 0.02283737f, -0.01545615f, 0.03331118f, 
    -0.04540476f, -0.01882146f, -0.09413082f, -0.09878898f, -0.21625686f, -0.32852936f, -0.05030617f, 0.47178206f, 
    0.10833796f, 0.07015592f, -0.02659968f, 0.15682206f, 0.07564604f, 0.12813886f, -0.06613081f, 0.02216305f, 
    -0.02955946f, -0.03536203f, 0.24111173f, 0.17773199f, 0.32330701f, -0.10259570f, 0.10788350f, -0.09118909f, 
    -0.03674208f, -0.02773950f, 0.12975913f, -0.07202665f, 0.05797749f, 0.21827759f, 0.02577308f, -0.11591088f, 
    -0.07780574f, -0.12756424f, 0.03020498f, -0.02185090f, 0.07413544f, -0.07596571f, -0.14589858f, -0.14724578f, 
    -0.06282358f, 0.10915045f, 0.04848177f, 0.28063273f, -0.08565838f, -0.12140421f, 0.20685522f, 0.13106795f, 
    -0.11466845f, -0.04498319f, -0.01254850f, 0.13171922f, 0.02758397f, 0.00678877f, -0.25982314f, 0.11677333f, 
    0.07354251f, -0.04653609f, 0.01927506f, 0.02541207f, 0.04435262f, 0.14875212f, 0.11233148f, -0.04399927f, 
    0.07376304f, 0.02638457f, 0.28874561f, -0.40335658f, 0.00572936f, -0.25231105f, -0.03020732f, 0.00635657f, 
    0.07081665f, 0.02513031f, -0.15952045f, -0.07013629f, -0.17287922f, 0.18714395f, 0.10298817f, 0.03491978f, 
    0.01064549f, 0.04893946f, 0.01705823f, -0.13337649f, -0.11832259f, -0.06731055f, -0.05882755f, -0.11211275f, 
    -0.16309226f, 0.11671169f, -0.27237830f, 0.04415834f, -0.01430529f, 0.11165114f, -0.02291662f, -0.07714448f, 
    0.09770440f, -0.02360207f, -0.02023670f, 0.13856669f, 0.11198584f, 0.39091852f, 0.11095077f, -0.07853990f, 
    -0.11141207f, -0.04769623f, 0.03916504f, 0.11524933f, -0.13061059f, -0.06647868f, 0.07834187f, -0.06875905f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.18962285f, 0.11717661f, 0.02012345f, -0.11054967f, -0.10159948f, 0.01673399f, -0.00582767f, -0.09013432f, 
    0.02342160f, 0.00749468f, 0.02504787f, 0.01471484f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
