#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.00068947f, 0.40104994f, 0.15424973f, 0.02811683f, -0.55761021f, 0.16338174f, 0.40423429f, -0.26547095f, 
    0.31906113f, 0.73203248f, 0.30394334f, -0.23167343f, 0.03640288f, -0.10490765f, -0.46936041f, -0.07169487f, 
    -0.10809200f, 0.02129668f, 0.57248032f, -0.36837798f, -0.46491930f, -0.43489677f, 0.06837570f, 0.00167753f, 
    -0.28884292f, -0.17573422f, -0.65931773f, -0.18324827f, -0.36117488f, -0.01290712f, 0.46228334f, 0.56733876f, 
    0.01063844f, -0.51582390f, 0.30539054f, -0.05849508f, 0.29964399f, 0.29570705f, 0.05680752f, -0.43535280f, 
    -0.46138337f, 0.22479975f, 0.31889307f, -0.24024117f, -0.26540533f, 0.00838884f, -0.18615305f, -0.13139017f, 
    0.32993922f, -0.27175593f, -0.68548965f, -0.72332299f, -0.92093706f, -0.46576267f, 0.04899336f, -0.68195039f, 
    -0.06647086f, 0.19410606f, -0.40522766f, 0.40143558f, 0.24495699f, 0.21538220f, 0.38609496f, -0.01123405f, 
    0.14463058f, -0.16699509f, 0.15061308f, 0.28157052f, 0.06903844f, -0.13043399f, -0.12458955f, -0.15681081f, 
    -0.19416147f, -0.15903838f, -0.01302475f, 0.33429483f, -0.63671792f, 0.06971823f, -0.61998856f, -0.12171514f, 
    -0.25072184f, -0.46091461f, -0.02910427f, 0.41990748f, -0.60023355f, 0.10296454f, -0.24612981f, -0.38975599f, 
    -0.15309151f, 0.30912277f, 0.60631257f, 0.12759833f, 0.23542742f, 0.15486772f, -0.16661546f, -0.25477749f, 
    0.00811668f, -0.09916741f, 0.04578405f, 0.20004840f, 0.66128743f, 0.83288354f, 0.45803991f, -0.06270136f, 
    0.64337569f, -0.15397564f, -0.33325794f, 0.44043800f, 0.31712681f, 0.27978170f, -0.10055002f, -0.11109816f, 
    0.02570109f, 0.27282235f, 0.26655865f, -0.16370574f, 0.19412144f, 0.00695081f, 0.11264738f, 0.02705921f, 
    0.01241298f, 0.44043380f, -0.20778476f, 0.36040470f, 0.17235148f, 0.98324925f, -0.00495525f, 0.42032292f, 
    -0.27245057f, -0.15900816f, -0.34352618f, 0.21764658f, -0.36198986f, 0.17087379f, 0.34529725f, 0.24801789f, 
    0.05450501f, 0.26912659f, -0.34865093f, -0.28907627f, -0.11302820f, -0.05658354f, 0.41061696f, -0.02620514f, 
    0.01093127f, -0.27840111f, -0.02887537f, 0.09564577f, -0.02230792f, 0.23107024f, 0.36384884f, 0.62415844f, 
    0.76272970f, 0.49982604f, 0.29413125f, -0.54928863f, -0.42274508f, -0.68717605f, -0.62282991f, 0.40615949f, 
    -0.00850631f, 0.11662333f, 0.04613465f, 0.11407335f, -0.43491164f, -0.16575007f, 0.09038852f, -0.16321379f, 
    -0.07375532f, -0.04676060f, 0.12405379f, 0.33353311f, -0.13756561f, -0.16965726f, 0.30166316f, -0.53173041f, 
    -1.32930219f, -0.00400976f, 0.77298188f, -0.05706235f, 0.41890210f, 0.50453836f, 0.62721360f, -0.09109026f, 
    -0.62545431f, 0.25763389f, -0.04701246f, -0.12785017f, 0.25609413f, 0.22622052f, -0.03214563f, 0.17187177f, 
    -0.17165039f, -0.28062794f, 0.07805280f, 0.04730275f, 0.39811331f, 0.20189096f, -0.06707612f, 0.31970561f, 
    -0.74086416f, -0.20163371f, -0.62182987f, 0.15978910f, -0.69631183f, 0.71365243f, 0.62558359f, -0.51657873f, 
    0.05851571f, 0.34585932f, -0.21253729f, -0.37006646f, 0.33548349f, 0.01940879f, 0.27880698f, -0.06416301f, 
    -0.26023486f, 0.31601632f, -0.04598470f, -0.08863117f, 0.22101918f, -0.09566486f, -0.06833212f, -0.02145210f, 
    0.13171221f, -0.91752189f, 0.13685122f, -0.54471874f, 0.82126892f, 0.56114924f, 0.25379968f, 0.79992175f, 
    0.39741620f, 0.33398867f, 0.39523101f, -0.26319772f, -0.08379323f, -0.15805963f, -0.26858330f, 0.07168367f, 
    -0.01708938f, -0.09535465f, -0.11140839f, -0.17656881f, -0.06471586f, 0.03932332f, -0.19267495f, -0.03663233f, 
    -0.01129604f, -0.30813307f, 0.73844981f, 0.92698377f, 0.23061936f, -0.52327776f, -0.35797766f, 0.15829842f, 
    -0.20916578f, -0.43137920f, 0.40610316f, 0.37677768f, -0.04455536f, -0.26987016f, -0.13453873f, 0.05994023f, 
    0.32880703f, 0.03832632f, 0.00051920f, 0.12034401f, 0.26307121f, -0.26400480f, -0.06125615f, -0.09173322f, 
    -0.38837841f, -0.04564882f, -0.05887108f, 0.23689021f, 0.31807855f, 0.34487891f, 0.87103766f, -0.26655608f, 
    0.09713223f, -0.08795143f, 0.00050187f, 0.08317682f, 0.55826068f, 0.44343442f, -0.05148610f, 0.02805455f, 
    0.07121893f, -0.22851202f, 0.25937352f, -0.01599629f, 0.27906147f, 0.13264772f, 0.44574514f, -0.30380857f, 
    0.08256593f, 0.26020572f, -0.19393709f, -0.38955584f, -0.29761446f, 0.77979970f, -0.24459012f, -0.72797018f, 
    -0.61430573f, 0.31793183f, -0.21188064f, -0.35854483f, -0.21162899f, -0.67548716f, -0.35054192f, 0.41537216f, 
    0.03149600f, 0.05221942f, 0.37194887f, 0.12402057f, 0.27609196f, -0.07147949f, 0.16580051f, 0.31067508f, 
    0.08535437f, -0.25982612f, -0.09546012f, 0.23104577f, 0.22042258f, 0.99155462f, 0.70496702f, 0.35424197f, 
    -0.78772926f, -0.86638731f, -0.20637716f, -0.26339269f, 0.12150053f, -0.39797604f, 0.37101069f, 0.35155389f, 
    0.28576869f, -0.11438344f, -0.00141548f, -0.14675869f, -0.21439798f, -0.13340603f, 0.08162732f, 0.10095990f, 
    0.15306740f, 0.14389932f, 0.22729668f, -0.01516386f, -0.00930391f, 0.04030131f, 0.54868168f, -0.02234296f, 
    0.32721847f, 0.84053600f, -0.34018978f, 0.26633599f, -0.02146927f, 0.31244910f, 0.01188090f, 0.59777153f, 
    -0.37406790f, -0.09913525f, 0.15593582f, -0.47861126f, -0.20841897f, -0.40715829f, -0.14692125f, -0.04917328f, 
    -0.26842842f, -0.18666372f, 0.11929715f, -0.19898725f, -0.30852702f, -0.23269512f, -0.07919855f, 0.42592698f, 
    0.11302094f, 0.33319682f, 0.88440388f, 0.86943728f, 0.65933383f, 0.26470992f, -0.48224437f, 0.10818296f, 
    0.04952472f, -0.06503422f, -0.14091514f, -0.32964379f, 0.15729639f, -0.27913967f, -0.04820711f, -0.22718412f, 
    0.11454060f, -0.04305153f, -0.21727465f, 0.00333921f, 0.34718034f, -0.08366216f, -0.15981473f, -0.03245733f, 
    -1.39294279f, 0.65847641f, 0.37416109f, -0.61155206f, -0.69884491f, 0.34714982f, 0.49114504f, -0.12569731f, 
    0.45919025f, 0.48748010f, -0.16812202f, -0.08482388f, -0.32040918f, -0.13572042f, -0.09649049f, -0.04820698f, 
    0.27361888f, -0.20161510f, -0.10031008f, -0.23520862f, 0.06776600f, 0.12909482f, 0.16801226f, 0.00355317f, 
    0.03049980f, -0.29283816f, -0.53163266f, -0.74721563f, -0.54452658f, -0.35619906f, 0.18518744f, 0.32256657f, 
    0.33003220f, 0.21003996f, 0.47122338f, -0.23394540f, 0.07776640f, 0.19129755f, -0.14832501f, -0.27088052f, 
    -0.00067801f, -0.01268078f, 0.16221525f, 0.11437760f, 0.16858594f, -0.01535165f, 0.18954545f, -0.12917659f, 
    0.00042155f, 0.27334735f, -0.51655442f, 0.11968799f, 0.59707165f, -0.83810467f, -0.68159604f, 0.33184263f, 
    -0.00726215f, -0.13122934f, -0.41907418f, 0.02573601f, 0.26957700f, 0.34641773f, -0.17532748f, 0.38049760f, 
    0.14416339f, -0.10094840f, -0.22811174f, -0.03209484f, -0.23007783f, -0.18302019f, -0.06349628f, 0.26808098f, 
    0.19159742f, -0.11176235f, 0.12109781f, -0.26154083f, 0.41775000f, 0.46477827f, 0.23228990f, 0.50144094f, 
    0.03963472f, 0.27836916f, 0.72613496f, 0.41229284f, -0.01296669f, -0.30504450f, 0.26992440f, 0.07006378f, 
    0.32755637f, -0.39559975f, -0.10475744f, 0.16282700f, -0.32374230f, -0.22404425f, -0.17022486f, 0.37869605f, 
    -0.26082310f, -0.04944723f, 0.07452677f, -0.11928075f, -0.01250493f, 0.66986710f, -0.49451852f, -0.90289748f, 
    -0.45495844f, 0.13436031f, 0.21849121f, 0.05460593f, 0.15916009f, 0.52011609f, -0.06357887f, -0.12773888f, 
    -0.42988554f, -0.11921573f, -0.41221207f, 0.12372335f, -0.18882765f, -0.02266175f, -0.07703087f, 0.26483005f, 
    -0.22644621f, -0.12023307f, -0.06714977f, -0.35787883f, 0.06420283f, -0.59604037f, -0.46924120f, -0.48918927f, 
    -0.27726090f, -0.10676467f, 0.39118165f, 0.02450531f, 0.11630853f, 0.63421738f, 0.49170765f, -0.15903956f, 
    -0.00925067f, 0.29783908f, -0.33954203f, -0.19954552f, -0.16236070f, 0.01289323f, -0.14986779f, 0.05326544f, 
    -0.09117298f, -0.37653294f, -0.34722832f, -0.53928256f, 0.08024734f, 0.14174508f, -0.92451119f, -0.07176334f, 
    0.88453686f, 0.03971104f, 0.12518407f, 0.19746526f, 0.38921499f, -0.27015325f, 0.32986817f, -0.75483274f, 
    -0.25084814f, 0.12880048f, -0.47155535f, 0.05175291f, 0.13055603f, 0.19513419f, 0.17452458f, 0.13073167f, 
    -0.45883512f, 0.05670998f, -0.32772979f, -0.30991659f, 0.13447122f, 0.43918139f, 0.11228966f, 0.64409596f, 
    0.43082738f, 0.39460894f, 0.47307995f, 0.92935342f, 0.16941030f, -0.04908790f, -0.26136905f, 0.09524687f, 
    0.11761671f, -0.45568967f, -0.35530102f, 0.23441161f, 0.31903344f, 0.27344015f, 0.18281148f, 0.09346046f, 
    0.27825746f, 0.16889875f, 0.13723332f, 0.24526332f, 0.05491702f, -0.08103549f, -0.27422473f, -0.20923147f, 
    -0.76986253f, 0.91276944f, 0.51476407f, -0.91451734f, 0.60690421f, 0.70501721f, -0.70171237f, -0.18635605f, 
    0.17889309f, -0.58288282f, 0.00964927f, 0.13570546f, -0.13919196f, 0.21409447f, -0.49787173f, 0.04822549f, 
    0.29518199f, -0.15888505f, -0.14513040f, -0.03067023f, -0.13616899f, 0.20930901f, 0.01400009f, -0.11438063f, 
    0.25967011f, 0.64512241f, -0.19337328f, -0.29014578f, -0.24429892f, -0.51537043f, -0.28797475f, -0.43037051f, 
    0.30188757f, 0.26993001f, 0.44588742f, 0.32991153f, 0.01625145f, -0.23821069f, -0.09124489f, 0.36906570f, 
    0.30633286f, 0.36327770f, -0.52236313f, 0.04759392f, 0.42073554f, 0.31954804f, 0.20103432f, 0.46970287f, 
    -0.07928269f, 0.27826771f, -0.69895971f, -0.54238063f, -0.61779290f, -0.43454561f, 0.15802771f, -0.43015736f, 
    -0.23972008f, -0.28878158f, -0.19090737f, -0.07224618f, 0.39276996f, 0.02349415f, 0.07191230f, -0.16537601f, 
    -0.16168894f, 0.11228052f, -0.24834353f, -0.31618837f, -0.17573239f, 0.15921423f, -0.18150428f, 0.24291302f, 
    0.03268066f, -0.24937601f, -0.21996295f, 0.80864346f, 0.00978618f, 0.72193593f, 0.45620286f, 0.10504443f, 
    0.72572029f, 0.13975920f, -0.43562520f, 0.05911193f, -0.43276545f, 0.18515618f, 0.38883537f, -0.12121265f, 
    0.31023818f, -0.23623988f, -0.16954699f, 0.13403554f, -0.21040437f, -0.26808673f, -0.10254036f, -0.08963654f, 
    0.11954948f, -0.06816666f, 0.31779295f, 0.17011422f, 0.56250811f, -0.52205634f, 1.10015440f, 0.64936417f, 
    -0.70483077f, 0.18411542f, -0.84813994f, 0.20952028f, 0.38562894f, -0.11799391f, -0.30985293f, -0.08730130f, 
    0.01369349f, 0.06786590f, -0.06458727f, -0.08925211f, -0.07254750f, 0.01016460f, 0.00342115f, 0.11095561f, 
    0.19883816f, 0.01789627f, 0.04632822f, 0.29408655f, -0.25928819f, -0.00022800f, -0.51134139f, -0.52708256f, 
    -0.39095551f, 0.23890293f, -0.60992426f, 0.24499817f, 0.58771682f, -0.10060802f, -0.38730714f, 0.30331862f, 
    -0.24749865f, 0.18355906f, 0.33211604f, 0.13295847f, 0.21691741f, -0.34790152f, -0.19777384f, -0.23481771f, 
    -0.35308278f, 0.13589497f, -0.38268679f, 0.31279159f, 0.18539144f, 0.46960407f, 0.97264069f, 0.09273530f, 
    0.50599778f, 0.03107143f, 0.55879748f, -0.54235572f, 0.35757673f, 0.10238566f, 0.05477850f, 0.35266551f, 
    -0.30043924f, 0.03456608f, -0.17103271f, -0.15235086f, -0.35303545f, 0.11548240f, -0.18649827f, -0.19361608f, 
    0.05210271f, -0.02302047f, -0.03445626f, -0.05028251f, 0.00713519f, -0.08808579f, 0.12063641f, -0.44066799f, 
    -0.98937386f, -0.37407860f, -0.32013640f, -0.49027440f, -0.12936087f, 0.83422816f, 0.64347303f, -0.42713183f, 
    0.39635876f, -0.04127534f, -0.30961597f, -0.46541414f, -0.26955435f, 0.19792433f, 0.07716817f, 0.04321876f, 
    -0.22712313f, 0.07020871f, -0.19596811f, -0.09415056f, -0.05373793f, 0.25594699f, 0.32463980f, 0.17660943f, 
    0.47135812f, 0.44352415f, 0.55739737f, 0.27459869f, 0.11033004f, 0.33299458f, -0.11590810f, -0.07978028f, 
    -0.56203032f, -0.47981846f, 0.02676431f, -0.12650026f, -0.45269549f, -0.06219101f, 0.27323356f, 0.15246814f, 
    0.40257913f, 0.29929057f, 0.07219578f, 0.06378616f, 0.38071683f, 0.25157166f, 0.14157933f, 0.29552072f, 
    -0.14454405f, 0.21460648f, -0.40366447f, -0.58234441f, -0.44878051f, -0.52209055f, 0.07952662f, 0.81315804f, 
    -0.07789190f, 0.43597737f, 0.33226219f, -0.02291640f, -0.02774082f, -0.22648381f, -0.06453872f, -0.12803560f, 
    0.17826800f, -0.16229299f, -0.21593152f, -0.15410087f, -0.28473970f, 0.21877225f, 0.32609212f, -0.28581756f, 
    0.07706445f, -0.14921394f, 1.14044201f, 0.31819674f, -0.37679833f, 0.97508299f, 0.56996453f, -0.25960115f, 
    0.12542470f, -0.13430104f, 0.25617546f, 0.05327549f, -0.13988657f, -0.09380183f, -0.07684113f, -0.00943134f, 
    -0.13306107f, 0.11090487f, -0.06329309f, -0.18447703f, -0.04513840f, 0.29894519f, 0.14768881f, -0.04879452f, 
    0.11641104f, 0.14426124f, 0.11471792f, 0.61964899f, -0.58410585f, -0.63154435f, -0.64777762f, -0.03091993f, 
    0.82019371f, -0.72977549f, 0.20083666f, 0.05773118f, -0.13494049f, -0.25572079f, 0.27406195f, 0.11650737f, 
    0.25560728f, -0.14449500f, -0.11228406f, -0.10108731f, 0.08818123f, -0.06100244f, -0.05920466f, -0.04927786f, 
    0.31471086f, -0.17705020f, 0.05310423f, -0.13907303f, -0.58506638f, 0.20745780f, 0.57283324f, -0.35810047f, 
    0.24439600f, -0.21758230f, -0.43561593f, -0.25634870f, -0.62877047f, -0.08861578f, -0.34592402f, 0.24833547f, 
    0.34150356f, -0.22230752f, -0.01091517f, 0.18606494f, -0.26283810f, 0.24751036f, -0.41900855f, -0.33461815f, 
    0.07119250f, -0.07498378f, -0.12301084f, 0.05015008f, 0.12036050f, -0.79434490f, 0.09658020f, 0.15033960f, 
    -0.51082170f, 0.80285269f, -0.53623033f, 0.60669988f, 0.30801672f, -0.44516864f, 0.11212146f, -0.24121633f, 
    0.05290015f, 0.64713007f, 0.01801265f, 0.17129500f, 0.18228321f, -0.29764688f, -0.29417199f, 0.27561843f, 
    0.27099794f, 0.24568728f, -0.10302737f, -0.16382080f, -0.10064130f, 0.04341277f, 0.39910817f, 0.74342215f, 
    0.38326499f, 0.33582249f, 0.23691899f, -0.59279561f, 0.34833825f, -0.36139706f, -0.62853068f, 0.02281746f, 
    0.08133690f, 0.19258842f, 0.05089954f, 0.23326269f, 0.28087130f, -0.34114543f, 0.14808743f, 0.05117296f, 
    -0.13080461f, 0.18162507f, 0.34970012f, 0.21457553f, 0.45006827f, 0.35134640f, 0.12863915f, -0.46081612f, 
    0.36445379f, -0.95179790f, -0.40255353f, 0.33889306f, -0.64036345f, 0.28327030f, 0.68518603f, 0.20150301f, 
    -0.28721333f, 0.35260379f, -0.33456323f, 0.27846131f, -0.20164159f, -0.09868342f, -0.25343251f, 0.19105861f, 
    -0.11385269f, -0.16440882f, -0.07347447f, -0.02783433f, 0.45318893f, -0.15179300f, 0.29015312f, 0.25772911f, 
    -1.14976835f, 0.70765716f, 0.16292599f, -0.54183072f, -0.34588826f, -0.34893808f, 0.79751652f, -0.13481271f, 
    0.38099140f, -0.22885774f, -0.34056839f, 0.28962088f, 0.04157544f, 0.22594017f, 0.19174904f, 0.22321185f, 
    -0.06610367f, 0.06287020f, 0.17875165f, 0.04394380f, 0.29008973f, 0.07843252f, 0.05251300f, 0.00994228f, 
    0.35690722f, -0.43914902f, -0.60227370f, 0.35812163f, 0.81156939f, 0.07789936f, -0.72372109f, 0.29145208f, 
    -0.06556615f, -0.54805398f, 0.00472563f, 0.53606874f, 0.24479115f, 0.23594783f, 0.04115412f, 0.10479672f, 
    0.37812573f, 0.29322338f, 0.47431412f, -0.11961588f, -0.11425710f, 0.04227335f, -0.04784331f, 0.19875434f, 
    0.27935454f, -0.16146672f, 0.87979156f, 0.17758372f, -0.64512777f, 0.44626093f, 0.09064841f, 0.40198249f, 
    0.26771569f, 0.27702036f, 0.52888674f, 0.50669146f, -0.32779434f, -0.04728507f, -0.34805828f, -0.37002668f, 
    0.18196172f, 0.02530023f, -0.08951945f, 0.06607493f, -0.05016441f, 0.03456563f, -0.00873360f, -0.18007903f, 
    -0.20555055f, -0.15253542f, -0.37770233f, -0.57157606f, 0.98812222f, 0.22946343f, -0.26696128f, 0.41107446f, 
    -0.89093351f, 0.08970814f, -0.48181802f, -0.63994706f, -0.08452746f, 0.20294264f, 0.23557970f, -0.24940579f, 
    0.23414676f, -0.12103243f, 0.03264909f, -0.35011417f, -0.33787200f, -0.29882172f, -0.03710839f, 0.13635582f, 
    -0.02105959f, 0.25083357f, 0.25420964f, -0.32884419f, 0.96835893f, 0.89417565f, -0.74016881f, 0.28503469f, 
    -0.86926782f, 0.01535992f, 0.29999948f, -0.63126218f, -0.01623346f, -0.36647865f, 0.27723974f, 0.04700233f, 
    0.20170401f, -0.01384220f, -0.34550703f, 0.06489792f, -0.23120731f, 0.02658828f, -0.02467486f, -0.22534762f, 
    -0.24470317f, 0.12652676f, 0.15259922f, -0.14058439f, 0.02474698f, -0.49745244f, -0.69110471f, -0.77894396f, 
    -0.29884011f, 0.13705693f, 0.00219904f, 0.33146313f, 0.20374888f, 0.26521808f, 0.49167827f, 0.28967735f, 
    0.17742710f, 0.24851945f, -0.15422726f, 0.34331840f, -0.23169449f, 0.29140836f, 0.29626575f, 0.07677714f, 
    0.27387369f, -0.02474278f, 0.32268956f, -0.24419993f, 0.35486278f, -0.23930104f, 0.48510113f, 0.51502544f, 
    -1.12802577f, -0.22202824f, 0.08429516f, -0.32604745f, 0.19807899f, 0.31586608f, 0.45540825f, -0.45096898f, 
    -0.08379570f, 0.10239051f, -0.21694633f, 0.12059458f, -0.13387330f, 0.33147475f, -0.04289843f, -0.34954694f, 
    -0.31569102f, 0.00912264f, 0.25313127f, -0.19388309f, 0.29508784f, 0.30170178f, 0.26326072f, -0.58673239f, 
    0.41599083f, 0.62629336f, 0.16303922f, 0.30075970f, -0.95229059f, 0.20775449f, -0.26879036f, -0.47670352f, 
    -0.84699249f, 0.27181304f, 0.12211442f, 0.40084445f, -0.07600093f, 0.15435819f, 0.02630936f, 0.25135624f, 
    0.09257808f, 0.21528596f, 0.07855704f, -0.02993920f, 0.01452435f, -0.02355720f, 0.03958702f, 0.14784963f, 
    0.29078257f, 0.67384267f, 0.71928114f, -0.01943792f, 0.68503928f, 0.28018147f, 0.38554743f, -0.10442296f, 
    0.26306763f, 0.30772796f, -0.30032670f, -0.09624962f, 0.31243476f, 0.15513246f, 0.03817704f, -0.04435323f, 
    0.29956850f, -0.09555922f, -0.13486485f, 0.07258625f, -0.18530008f, -0.33779559f, -0.19562018f, -0.39298767f, 
    -0.10474689f, 0.47755146f, -0.34568700f, -0.08798524f, 0.68231088f, 0.91546285f, -0.65510345f, -0.74563867f, 
    -0.35219786f, -0.22282718f, 0.13474827f, 0.18022460f, 0.38919875f, -0.16990755f, 0.02306363f, 0.05094972f, 
    -0.14266548f, 0.21415855f, 0.24090436f, 0.20480904f, 0.03813019f, 0.03268088f, 0.07085419f, 0.05710575f, 
    -0.04405634f, 0.02649018f, -0.25479889f, 0.41802081f, -0.33799982f, -0.57063055f, 0.75766307f, -0.23043981f, 
    -0.81114870f, -0.67993426f, -0.11685217f, 0.08094064f, 0.05776615f, 0.34847060f, -0.01202381f, 0.14784099f, 
    0.04710422f, -0.21630043f, -0.03741219f, -0.23416662f, -0.08260464f, -0.26455978f, 0.08480351f, -0.24166003f, 
    0.00811389f, -0.06124225f, -0.21458752f, -0.20289485f, 0.06906636f, -0.44697168f, -0.49625412f, -0.52802479f, 
    0.77750325f, -0.15995394f, 0.06775914f, 0.49821228f, -0.10827801f, -0.35654166f, -0.59144521f, 0.12634255f, 
    -0.38648573f, -0.20005429f, 0.43562958f, 0.17137106f, -0.12232348f, 0.15228723f, 0.33600315f, 0.02531948f, 
    -0.38773459f, -0.19551137f, -0.15832010f, -0.17160302f, 0.70398241f, 0.40432137f, 0.43323457f, 0.26542184f, 
    0.52959222f, -0.72124523f, -0.31126997f, -0.11323869f, 0.41535985f, -0.55106568f, -0.28775716f, -0.21615288f, 
    0.36861920f, 0.00092925f, 0.01684064f, -0.34675273f, -0.08156687f, -0.01942894f, -0.13377482f, -0.16068020f, 
    -0.13359423f, -0.03552204f, -0.00905311f, 0.00675308f, -0.10367166f, 0.39538109f, 0.67349750f, 0.43486464f, 
    0.42088753f, 0.78393847f, 0.43338829f, -0.02776973f, 0.43738860f, -0.63370156f, -0.18650281f, -0.09856454f, 
    -0.03877172f, 0.01522756f, -0.08562322f, -0.02024337f, -0.11524899f, -0.07408578f, 0.04314525f, 0.00452220f, 
    0.13309360f, 0.30951074f, -0.28764296f, 0.03173978f, -0.10898933f, 0.22033036f, 0.21032196f, 0.03240542f, 
    0.00513085f, -0.47012046f, -0.30483976f, -0.10150059f, -0.68395036f, 0.33694464f, -0.30240431f, 0.00012370f, 
    -0.19371997f, -0.03479004f, 0.33973226f, 0.23736647f, -0.32747421f, 0.12786731f, 0.18768598f, 0.02313645f, 
    0.25813338f, -0.35286972f, 0.04307139f, -0.00637351f, 0.07655430f, -0.07340664f, 0.44476569f, 0.15037827f, 
    0.52348483f, 0.38684845f, 0.63943517f, 0.32353911f, 0.04137574f, 0.43600664f, 0.45600462f, 0.06609150f, 
    0.20587116f, -0.42354983f, -0.36331090f, -0.25698605f, 0.13590185f, -0.26176885f, 0.18493152f, 0.00746003f, 
    0.23301160f, 0.00450009f, -0.33479261f, -0.13892286f, -0.25011107f, -0.05861729f, 0.32401916f, 0.18866721f, 
    0.72907370f, 0.29383293f, 0.15721354f, -0.40646824f, 0.10243525f, 0.54133588f, -0.65136504f, 0.41804191f, 
    0.35540384f, 0.64077014f, 0.52572006f, -0.21955393f, -0.43371367f, -0.31158215f, -0.07530688f, 0.26237872f, 
    0.16225110f, -0.07370239f, 0.05090112f, 0.04942618f, 0.44038668f, -0.09447277f, 0.01014721f, 0.09869141f, 
    -0.05239585f, -0.63459337f, -0.54245204f, 0.04690330f, -0.32161224f, -0.29324800f, -0.32688233f, -0.37473896f, 
    -0.22124328f, 0.20364013f, 0.48757556f, -0.21609925f, 0.44432136f, -0.34569719f, 0.41968194f, -0.40275279f, 
    0.33379924f, 0.03563851f, 0.24981654f, -0.17738622f, -0.33616742f, -0.11857978f, 0.24631228f, -0.08613386f, 
    -0.01925067f, 0.21100180f, -0.60700160f, -0.55936474f, 0.17844495f, -0.42563879f, 0.43215054f, -0.48229289f, 
    0.10972793f, 0.34132150f, -0.46465167f, 0.33899215f, 0.00851193f, 0.01364205f, 0.22061487f, 0.42230016f, 
    -0.10951162f, -0.07278971f, -0.48492593f, -0.33012831f, -0.38665950f, 0.03393552f, 0.07355566f, 0.12271485f, 
    0.23609135f, 0.40803048f, 0.17141140f, 0.85427272f, -0.81737840f, 0.07106527f, 0.70287848f, 0.34217194f, 
    0.42001441f, 0.54088515f, 0.32242203f, 0.25145206f, -0.06593610f, -0.34104604f, -0.02047265f, -0.50309175f, 
    0.18369678f, -0.06443659f, 0.02123511f, 0.17656335f, 0.06648430f, 0.51632285f, 0.22870804f, -0.14401509f, 
    0.03816041f, 0.08938880f, 0.14798102f, -0.24023950f, 0.83250302f, 0.84590834f, 0.81145394f, 0.09031723f, 
    -0.10067287f, -0.34630671f, 0.00909547f, -0.21053714f, -0.01665874f, 0.13128607f, 0.33068138f, 0.36164436f, 
    -0.28761360f, 0.31577730f, 0.18041903f, 0.19200954f, -0.09261172f, 0.18079826f, 0.20542799f, 0.17098637f, 
    -0.15939985f, 0.35223445f, -0.11019430f, -0.06930068f, 0.36668333f, -0.41336450f, 0.13168904f, -0.36981490f, 
    -0.03790622f, 0.50182241f, -0.34077719f, 0.60611624f, 0.86074358f, -0.07648745f, 0.70441192f, -0.40655273f, 
    0.09306177f, -0.31939763f, -0.04164425f, -0.32051447f, -0.20115605f, 0.11033317f, -0.00373605f, 0.25397161f, 
    -0.14803648f, 0.01640612f, 0.19211984f, -0.03302453f, -0.24075083f, 0.04196172f, 0.61719781f, -0.06285524f, 
    -0.68327910f, -0.36485383f, 0.06447419f, 0.28887299f, -0.65797228f, -0.18312947f, -0.33564314f, -0.40026167f, 
    -0.39245585f, -0.17133746f, 0.46087143f, 0.12913902f, -0.17464487f, -0.13666676f, -0.01029435f, 0.09825341f, 
    0.06098837f, -0.06429533f, 0.20307478f, 0.00828064f, 0.22739373f, 0.17337067f, -0.14932919f, -0.07374848f, 
    -0.10979773f, -0.43351626f, 0.35481679f, -0.40516204f, -0.38689715f, 0.40048712f, 0.09047242f, 0.53961593f, 
    0.45317152f, -0.35242289f, -0.03193356f, -0.03402317f, -0.46357653f, -0.22004953f, -0.13828525f, -0.24057642f, 
    0.04006619f, 0.37210500f, 0.11147086f, 0.44121432f, 0.35718408f, -0.13888928f, 0.17151314f, 0.25164431f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.02959180f, 0.05293078f, 0.21604301f, 0.08808817f, 0.16915293f, 0.13949782f, 0.24675561f, 0.10036249f, 
    0.06877028f, 0.21566972f, 0.16424163f, 0.05198428f, 0.22162887f, 0.26913279f, 0.21929570f, 0.19089830f, 
    0.00818604f, 0.01876818f, 0.00467147f, 0.26438010f, 0.04286287f, 0.06356405f, 0.09267134f, 0.10604700f, 
    -0.02560560f, 0.11714220f, 0.11093469f, 0.05080544f, 0.01981337f, 0.04125309f, 0.00602196f, 0.04481345f, 
    -0.02836397f, 0.08623531f, 0.20151469f, 0.21422538f, 0.16893113f, 0.15729840f, -0.04297296f, 0.13763739f, 
    0.28773183f, 0.14798538f, 0.25501031f, 0.13795391f, 0.15035658f, 0.20136485f, 0.14721651f, 0.11446356f, 
    0.09227113f, 0.25901055f, 0.25485194f, -0.03980259f, -0.05170826f, 0.04656497f, 0.17631160f, 0.13145386f, 
    0.09313576f, 0.18755470f, 0.03834620f, -0.04952411f, 0.14718226f, 0.18042083f, 0.37444457f, -0.08461525f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.24174206f, 0.08247264f, -0.08461782f, -0.06110593f, 0.14241271f, 0.02562575f, 0.02608915f, -0.00182387f, 
    0.08785754f, 0.11418270f, -0.03186915f, -0.11667804f, -0.15067683f, 0.07623491f, -0.00624668f, -0.29617414f, 
    -0.00709662f, -0.05314395f, -0.02927720f, -0.01886656f, -0.07699532f, 0.07749125f, 0.00466857f, -0.05690602f, 
    -0.30827683f, -0.19047332f, -0.05362791f, -0.02157523f, 0.04261725f, -0.07502565f, -0.00426152f, 0.04729283f, 
    0.01551520f, -0.01051263f, -0.12159503f, 0.04769360f, -0.07694655f, -0.06772742f, 0.11801048f, -0.04320042f, 
    0.03103213f, -0.03289268f, 0.00223825f, -0.05933609f, 0.06217770f, -0.04613917f, -0.02306462f, -0.11140292f, 
    0.14281566f, 0.04110796f, 0.12961622f, -0.16628815f, -0.12999925f, -0.09165882f, -0.00488623f, -0.01788485f, 
    -0.03178521f, 0.04646010f, -0.01193652f, -0.02694927f, 0.09231074f, 0.08508449f, 0.05764253f, 0.01702027f, 
    -0.09089174f, -0.08118412f, -0.08218439f, 0.09355096f, -0.01900760f, 0.06080865f, -0.04400951f, -0.14929883f, 
    0.04118016f, 0.08017659f, 0.01726952f, 0.03434122f, -0.09558886f, 0.01386762f, -0.02943622f, -0.06265768f, 
    -0.07497050f, 0.01022641f, -0.05732768f, 0.00354076f, -0.16355196f, 0.14746138f, 0.02011521f, 0.13129212f, 
    -0.04408023f, 0.19169223f, -0.07927691f, 0.05077058f, 0.02648966f, -0.19199954f, 0.00526778f, -0.00891365f, 
    0.45404166f, 0.07942498f, -0.09521125f, -0.12929462f, -0.01090053f, -0.02115046f, -0.04425998f, 0.08847518f, 
    0.09436680f, -0.07997002f, -0.00650054f, 0.09095211f, 0.15225902f, 0.20052554f, 0.14697011f, 0.10552865f, 
    0.01504762f, 0.07744209f, -0.05954755f, -0.08216200f, -0.02875837f, -0.05819548f, -0.06662519f, -0.02163095f, 
    0.04279890f, 0.07187366f, -0.00305032f, -0.16812170f, -0.07054203f, -0.05044751f, 0.03460595f, -0.05620785f, 
    0.02746407f, 0.10238371f, -0.03749567f, -0.02570193f, 0.09002894f, 0.03225765f, -0.30738828f, 0.20277143f, 
    -0.10934019f, 0.06848163f, -0.05127332f, -0.01926108f, 0.10649357f, 0.11348409f, -0.02840250f, -0.05039139f, 
    -0.13841850f, 0.22138110f, 0.17200638f, -0.23947355f, 0.02712754f, 0.02860990f, 0.05205109f, 0.03233076f, 
    -0.07240250f, -0.16722153f, -0.10148373f, 0.06537049f, -0.31110263f, 0.14251682f, 0.06173961f, -0.18572345f, 
    0.08888459f, -0.10438000f, 0.00968669f, -0.04835659f, -0.11103831f, -0.06597319f, -0.05230669f, -0.00671314f, 
    -0.00077860f, 0.02910746f, -0.15067185f, 0.27976459f, -0.05289535f, -0.02022840f, 0.04084667f, -0.06046499f, 
    -0.07719098f, -0.03892008f, -0.04946949f, 0.00421206f, 0.09308855f, -0.06302937f, 0.08307246f, 0.30002347f, 
    -0.06519251f, -0.03870710f, -0.01865014f, -0.02751854f, -0.04513498f, -0.01283556f, -0.06726930f, -0.04998489f, 
    0.54371744f, 0.02646460f, 0.03954050f, 0.05442097f, -0.04362183f, 0.07771228f, -0.05419643f, -0.00182318f, 
    0.09567481f, -0.00293350f, -0.01714045f, -0.09951787f, 0.09264688f, 0.11588523f, -0.19323868f, -0.32605514f, 
    0.07580592f, 0.00821083f, 0.12429808f, 0.03892951f, -0.03885439f, -0.02965359f, -0.00566762f, 0.05661769f, 
    -0.28016004f, 0.08834369f, 0.13038361f, -0.11779197f, 0.01779289f, 0.12043123f, 0.04209521f, -0.00112087f, 
    0.06268016f, 0.03973189f, 0.03676923f, 0.04297184f, -0.21072562f, 0.10201456f, -0.01934389f, 0.06099303f, 
    -0.00636847f, 0.05784962f, 0.07281008f, -0.09857472f, 0.01932788f, -0.04192353f, 0.06467155f, -0.09962214f, 
    0.10931163f, -0.07661659f, -0.02701215f, -0.35925931f, -0.00392680f, -0.01566852f, 0.08145383f, -0.05938352f, 
    -0.00987209f, 0.09209598f, 0.08649316f, -0.07859623f, 0.24652359f, 0.11818136f, -0.14742228f, -0.08286101f, 
    0.03702518f, 0.02582690f, 0.00266608f, 0.02503185f, -0.00538757f, -0.02895566f, -0.02118255f, 0.02628424f, 
    -0.25387806f, -0.09803342f, 0.06077887f, 0.05254206f, 0.07853809f, -0.03050690f, 0.15008560f, 0.05916811f, 
    0.08612336f, 0.01504120f, -0.04304232f, -0.08963440f, 0.08427978f, -0.05599096f, -0.02974060f, 0.09871436f, 
    -0.10067561f, 0.01402138f, 0.05226900f, -0.02573170f, 0.03680682f, 0.13185562f, -0.01849657f, -0.01973315f, 
    -0.37483722f, 0.05949371f, 0.17354956f, -0.15887278f, 0.03720110f, 0.02461802f, 0.01851472f, -0.09707403f, 
    0.04505612f, 0.02248710f, 0.06857344f, 0.02969891f, 0.03379009f, -0.32320225f, -0.03474309f, 0.00633215f, 
    0.04657893f, -0.07937413f, 0.11824685f, -0.01863708f, 0.02178515f, -0.11711743f, 0.12664753f, 0.03503231f, 
    -0.14822604f, -0.32219538f, -0.06718773f, 0.13879152f, -0.07708804f, -0.07258229f, -0.03131652f, 0.14109291f, 
    -0.08207044f, 0.05100374f, 0.08000487f, -0.11875398f, 0.17185825f, 0.01469887f, -0.08638239f, 0.06374122f, 
    -0.11201652f, -0.22207703f, -0.00062453f, 0.00239461f, -0.05879762f, 0.11206736f, -0.02133822f, 0.02795618f, 
    0.11955840f, -0.07164207f, -0.19719116f, 0.47424516f, 0.08243047f, -0.13593182f, 0.05927066f, -0.07568321f, 
    -0.07174761f, 0.00676591f, -0.00086848f, -0.00934918f, -0.22820470f, 0.16459350f, -0.09550794f, 0.01225475f, 
    -0.07398546f, -0.10735682f, -0.05437720f, -0.01135761f, 0.08303823f, 0.17658766f, 0.02903775f, 0.01311745f, 
    0.20056129f, -0.11534701f, 0.00679691f, 0.00138622f, -0.06361620f, -0.10380674f, -0.03672680f, 0.16723065f, 
    -0.04370228f, 0.02201973f, 0.10535194f, -0.13612323f, -0.11183305f, 0.14472093f, 0.15179439f, -0.40117344f, 
    0.11909881f, 0.03427179f, -0.06589635f, 0.03770715f, 0.11381362f, 0.07367449f, -0.04021356f, 0.11917269f, 
    0.04703363f, 0.13993441f, -0.06728329f, -0.12202892f, -0.16741055f, -0.04538793f, 0.00814841f, -0.01655399f, 
    0.00003037f, -0.04493564f, 0.02758586f, -0.06994800f, 0.04669788f, 0.10471976f, 0.02833283f, -0.27090079f, 
    0.06829190f, 0.08522017f, 0.00058243f, -0.02165820f, -0.01408045f, 0.02459619f, 0.05147990f, -0.01920283f, 
    0.17431137f, -0.03873129f, 0.00257876f, 0.23942439f, -0.18330485f, 0.03239523f, -0.04492226f, 0.06487793f, 
    -0.10126031f, -0.00879757f, 0.08874992f, -0.08985303f, 0.22991920f, -0.25117740f, 0.09544776f, -0.26176736f, 
    0.06769627f, -0.00481453f, 0.10076245f, -0.16642879f, -0.05728722f, -0.09111656f, -0.05386913f, 0.10179376f, 
    -0.43843180f, -0.01082091f, 0.09984826f, 0.08093011f, -0.03694816f, -0.08710313f, 0.05874629f, -0.00475813f, 
    -0.00999714f, 0.02246527f, -0.01669810f, -0.10909667f, -0.30710039f, 0.00326049f, -0.12643908f, -0.02532800f, 
    -0.03860227f, 0.04746483f, -0.09393314f, 0.13789439f, 0.08569790f, -0.12246051f, 0.09027360f, 0.10016646f, 
    0.10065432f, 0.08723363f, -0.00342246f, 0.02400565f, -0.12984878f, -0.06633622f, -0.00180238f, -0.08339895f, 
    -0.07205263f, -0.13092397f, -0.10041337f, -0.00889333f, -0.23199548f, 0.28772575f, -0.02965442f, -0.05187963f, 
    -0.04255568f, -0.06911245f, 0.00167589f, -0.04676212f, 0.04087302f, 0.02892734f, -0.11020579f, 0.02930548f, 
    0.28140745f, -0.02189981f, 0.05100717f, -0.05499669f, 0.01843031f, 0.07387037f, -0.03813816f, 0.07813361f, 
    -0.00071749f, -0.12122831f, -0.06892885f, -0.01049974f, -0.05792839f, -0.19826464f, -0.21460439f, 0.20684777f, 
    0.05578719f, -0.02247377f, -0.01802710f, 0.01554412f, 0.11592226f, -0.00086971f, 0.00087831f, 0.01853884f, 
    0.05083204f, -0.07731759f, 0.02247984f, 0.18339276f, -0.14962138f, 0.01700563f, -0.06508499f, -0.00789933f, 
    -0.09105189f, -0.04878866f, 0.00911674f, 0.09302095f, -0.13998201f, -0.11711621f, 0.10798658f, -0.05713527f, 
    0.08716878f, -0.02441468f, 0.04554644f, -0.06074528f, 0.05482322f, -0.10034252f, 0.00028025f, -0.04777441f, 
    -0.14122537f, 0.13371183f, 0.04312729f, -0.02548735f, -0.18452543f, -0.00538787f, -0.12497590f, 0.12832271f, 
    -0.09574252f, -0.01707044f, 0.00039024f, -0.12982629f, 0.02200771f, 0.03234123f, -0.11290273f, -0.13371028f, 
    0.02997451f, -0.00182146f, 0.10988715f, -0.00615683f, -0.09687065f, -0.01535581f, -0.01224303f, 0.03717879f, 
    -0.14637342f, 0.16070701f, 0.04364639f, -0.18417075f, -0.07979397f, -0.01778948f, -0.03574004f, -0.01099724f, 
    -0.05007920f, 0.10508953f, 0.10600013f, -0.14448145f, -0.20297471f, 0.10845888f, -0.02163179f, 0.10465163f, 
    0.00307968f, -0.01033692f, 0.01886553f, -0.02660448f, -0.03084075f, 0.01378035f, 0.01907961f, -0.08764832f, 
    -0.15953368f, -0.12861221f, 0.03479135f, -0.02496922f, -0.10781846f, 0.04454376f, 0.06363748f, 0.01880703f, 
    0.08287701f, -0.01532414f, -0.06944526f, 0.08395495f, 0.22143234f, -0.18738152f, 0.13872540f, 0.19954218f, 
    -0.19887772f, 0.09006679f, 0.01119894f, 0.00658561f, -0.01666246f, -0.00095005f, -0.04243538f, -0.07066834f, 
    -0.07534604f, -0.27029681f, 0.27059668f, -0.14530498f, -0.02999639f, 0.07848827f, 0.01875829f, -0.06304719f, 
    -0.03643870f, -0.03806283f, -0.00066130f, -0.06842844f, 0.31314763f, -0.01734836f, -0.05268330f, -0.11450484f, 
    -0.10821316f, 0.02393143f, 0.00294038f, 0.00895896f, -0.11399300f, 0.03626858f, 0.05009216f, 0.03576994f, 
    0.12413900f, 0.19923073f, 0.00388563f, -0.02369479f, -0.12688246f, -0.05968406f, 0.06262566f, 0.02118527f, 
    0.01274958f, -0.05590210f, 0.04203493f, -0.08476352f, 0.05701134f, -0.03403588f, 0.11785538f, -0.06677593f, 
    -0.06661850f, -0.09272190f, 0.07547449f, 0.08227512f, -0.00852358f, -0.02040263f, -0.08881824f, 0.01018654f, 
    -0.27171880f, -0.04069541f, 0.11857726f, -0.13286690f, 0.02758194f, 0.00972079f, 0.04890823f, -0.06070150f, 
    -0.04156251f, 0.16565809f, -0.07976288f, -0.05654709f, -0.01314925f, 0.05761606f, -0.06737057f, 0.11859296f, 
    -0.01279734f, -0.01211477f, 0.03377187f, -0.04068802f, 0.00652537f, 0.02641683f, 0.06402458f, 0.01372481f, 
    0.17711583f, -0.17434132f, 0.09476317f, -0.21465747f, 0.01313253f, -0.01169882f, -0.05249171f, -0.03259593f, 
    -0.00581048f, 0.04492710f, 0.09149109f, -0.07388239f, -0.29515976f, -0.24378061f, -0.04957120f, -0.04661437f, 
    -0.07007646f, -0.01594658f, -0.06178105f, 0.08280648f, -0.01916747f, 0.08860487f, -0.15776566f, -0.08522251f, 
    -0.11757553f, 0.08953432f, -0.08650942f, 0.01107785f, -0.05816399f, -0.04191647f, -0.16281229f, 0.10751403f, 
    0.01186399f, -0.00319671f, 0.07770260f, 0.03961494f, 0.11838488f, -0.00954874f, -0.03532224f, 0.20104843f, 
    -0.08523393f, 0.03362463f, -0.06765448f, 0.04353302f, -0.08090165f, -0.04249875f, 0.14123508f, -0.04537871f, 
    0.09124450f, 0.03858136f, 0.01239319f, -0.08018242f, -0.08108213f, -0.04459828f, -0.09140836f, 0.11232407f, 
    0.00116716f, 0.03317289f, -0.08616211f, 0.05123619f, -0.00677059f, 0.14745305f, 0.01692857f, -0.20631450f, 
    -0.03638193f, 0.06415437f, -0.03047243f, -0.03851764f, -0.09038584f, 0.00431759f, -0.08508119f, -0.00986322f, 
    -0.01044258f, -0.15481994f, 0.15322012f, -0.08962782f, -0.04882620f, 0.05855965f, 0.04051620f, -0.02255131f, 
    -0.09228557f, -0.06269503f, -0.08884751f, 0.04714401f, 0.03657188f, 0.20017786f, -0.09878834f, 0.01641984f, 
    -0.00978799f, -0.01427652f, 0.02902494f, -0.01071962f, 0.03413878f, -0.08072767f, -0.01234883f, 0.07208028f, 
    -0.18254976f, -0.04583800f, -0.00100275f, 0.06739297f, -0.12276654f, -0.09076142f, 0.00213135f, -0.02166081f, 
    -0.01951067f, -0.16671459f, 0.00911618f, 0.18728045f, 0.15088499f, -0.08762340f, -0.00837214f, 0.05702710f, 
    0.10123174f, -0.04995410f, -0.01323331f, 0.07117713f, 0.05480642f, -0.18010025f, 0.08542125f, -0.02373806f, 
    0.29745871f, 0.04049939f, 0.05771352f, -0.02623143f, -0.10808893f, -0.05077847f, 0.06381200f, 0.07605655f, 
    0.00133010f, -0.13437112f, 0.09577715f, -0.01544951f, -0.02278376f, -0.07538750f, 0.00145300f, -0.08065734f, 
    0.10591353f, 0.10462249f, -0.02616447f, -0.07149524f, -0.00587645f, 0.16875219f, -0.02533699f, 0.08150724f, 
    0.08144940f, 0.03211812f, 0.03173601f, 0.14029010f, -0.04217054f, -0.14206001f, 0.11503480f, 0.04694583f, 
    -0.10866961f, 0.00858231f, -0.03483361f, 0.09807679f, 0.32184714f, -0.09572610f, -0.04517031f, -0.02961734f, 
    -0.01809573f, -0.12425680f, 0.07300541f, -0.05877171f, 0.08246354f, -0.15010622f, 0.04801815f, -0.04261591f, 
    0.13132058f, -0.03167509f, 0.15435144f, 0.02725702f, -0.04068056f, 0.09256262f, 0.09675060f, 0.05232682f, 
    0.06053990f, -0.02335180f, 0.08713800f, -0.12958410f, -0.01506334f, 0.16473283f, -0.16783805f, 0.26362735f, 
    -0.16411361f, 0.10840245f, -0.00071378f, 0.02334904f, -0.00371274f, 0.01637618f, -0.03223353f, 0.07476938f, 
    -0.19773047f, -0.00277869f, -0.04205133f, -0.05234898f, -0.00174614f, -0.13460098f, 0.10655949f, 0.05569640f, 
    -0.06717204f, 0.02972963f, -0.04078134f, 0.08532055f, -0.03811386f, 0.01259357f, -0.09894233f, -0.00747241f, 
    0.22497565f, 0.05610191f, -0.13760555f, -0.01038166f, -0.01790672f, 0.15610500f, 0.09597938f, -0.00687525f, 
    0.05121714f, -0.04188289f, -0.00338705f, -0.04838175f, -0.00572089f, -0.12897243f, -0.04008197f, 0.06761297f, 
    -0.00983489f, -0.09780196f, -0.08218759f, 0.00888563f, -0.03494379f, 0.01570436f, 0.13176522f, 0.17159589f, 
    -0.07857466f, -0.20157757f, 0.02951411f, -0.08868137f, -0.08801578f, -0.08379557f, -0.04509892f, 0.10693887f, 
    -0.35915166f, -0.08646327f, -0.06479577f, -0.21884948f, -0.04862938f, 0.09669454f, 0.08693726f, 0.07610019f, 
    0.05970836f, 0.21157454f, 0.01766848f, -0.01633757f, 0.21909916f, 0.00050756f, -0.10212121f, -0.24173747f, 
    0.01756995f, -0.03598910f, 0.08098406f, 0.07158612f, -0.05212374f, -0.00750930f, 0.08921864f, 0.03937574f, 
    0.09027424f, 0.13523348f, 0.06083862f, 0.18223970f, -0.09149952f, 0.03252793f, 0.02354937f, -0.03952433f, 
    0.07599952f, -0.03557650f, 0.07004585f, -0.07592017f, 0.23814428f, -0.14215982f, 0.05940481f, 0.05561246f, 
    -0.06046582f, 0.06874041f, 0.02450774f, 0.01271234f, -0.06024984f, 0.02187615f, 0.08687107f, 0.00104066f, 
    -0.72393548f, 0.00578483f, -0.18082304f, -0.09255509f, 0.01708842f, -0.08482282f, -0.02496862f, 0.01634314f, 
    0.11804239f, 0.03826395f, -0.06997402f, -0.10827570f, 0.05467890f, -0.12779059f, 0.01288984f, -0.15968508f, 
    0.03266829f, -0.03472095f, -0.06568897f, 0.03248029f, 0.03939320f, -0.06519393f, 0.04922958f, 0.01072888f, 
    -0.32686061f, 0.05064487f, -0.23793752f, -0.05602132f, -0.00227753f, 0.01060275f, 0.01974189f, -0.00048496f, 
    -0.05190526f, -0.10201997f, -0.14447366f, -0.09039471f, 0.01427273f, 0.13153175f, -0.04987537f, 0.14160018f, 
    0.01691959f, 0.02296030f, -0.02724778f, 0.02345224f, 0.00993396f, -0.07116621f, -0.10132891f, -0.09673625f, 
    -0.14783666f, -0.03181826f, -0.00492412f, -0.29257721f, -0.03601532f, -0.12450039f, 0.06936718f, -0.06443907f, 
    0.08736514f, -0.03916447f, -0.09335317f, 0.04415404f, 0.01877151f, 0.01865966f, -0.00004463f, -0.04472170f, 
    0.03551332f, 0.02073182f, -0.08850836f, -0.08116090f, -0.05077122f, -0.07726654f, -0.05791830f, -0.01108795f, 
    -0.21032512f, 0.12017181f, -0.23217505f, -0.12936030f, -0.03324594f, 0.16868901f, 0.00606367f, -0.08289065f, 
    0.02311968f, -0.04544154f, 0.04260209f, 0.06625195f, 0.19113135f, -0.07728477f, -0.01289105f, 0.07681426f, 
    -0.11491643f, -0.06091035f, -0.04137162f, 0.01562982f, 0.07872503f, 0.00401826f, -0.09996174f, 0.02399468f, 
    0.06424890f, -0.09800071f, -0.14662017f, -0.20580089f, -0.06989536f, 0.01592921f, 0.02861251f, -0.04148528f, 
    0.03089320f, 0.12233616f, 0.05324069f, -0.02507170f, 0.14822252f, -0.05822309f, -0.02832090f, -0.21387103f, 
    -0.03716939f, -0.00920819f, -0.15003309f, -0.00424788f, -0.15847751f, 0.12093482f, 0.01486547f, 0.05279797f, 
    0.20290387f, 0.08391091f, 0.02038484f, -0.15303598f, -0.00387699f, -0.11145617f, 0.05700211f, -0.09346034f, 
    -0.04734259f, -0.02830432f, -0.09120853f, -0.05693571f, 0.06237886f, -0.01975607f, 0.23078650f, 0.05752151f, 
    -0.05805110f, 0.03887812f, -0.05947432f, 0.02577063f, -0.09586904f, -0.05305791f, 0.00339456f, -0.05185223f, 
    -0.24976403f, 0.14382638f, -0.16109230f, -0.00511215f, -0.15887083f, -0.06888045f, 0.00018393f, -0.03768022f, 
    0.10754934f, -0.05999843f, 0.02391401f, -0.05322742f, 0.06295419f, -0.13886388f, 0.01815672f, 0.01142319f, 
    0.07197141f, 0.07996652f, 0.01018876f, 0.01805191f, -0.04407246f, -0.11533501f, -0.07042583f, 0.01781800f, 
    0.29768676f, 0.01668043f, 0.06604370f, 0.20856574f, 0.07154080f, -0.00412395f, 0.01678533f, 0.00752476f, 
    -0.02508978f, -0.11207216f, -0.22872959f, -0.03952926f, 0.16098866f, -0.06461725f, -0.07771688f, 0.04778865f, 
    -0.11008409f, -0.00595089f, -0.08669773f, -0.10458863f, 0.02372407f, -0.05998411f, -0.13102223f, 0.03895232f, 
    0.01356874f, 0.05034873f, 0.11628692f, 0.24325046f, -0.08072620f, -0.00969807f, 0.10972488f, -0.05526312f, 
    -0.05458599f, 0.05384775f, -0.06364024f, 0.10322422f, 0.18314536f, -0.20542186f, -0.09710491f, -0.10834748f, 
    0.06929544f, -0.02164771f, -0.05656372f, -0.04324344f, 0.03071908f, -0.04727879f, -0.16177765f, 0.00195086f, 
    0.24030647f, -0.09538760f, 0.06404822f, 0.14719023f, -0.05133725f, -0.10925664f, 0.00630526f, -0.03412541f, 
    -0.02284979f, 0.10354304f, -0.07336564f, 0.09607573f, 0.10280500f, -0.27366206f, 0.05023604f, -0.17348568f, 
    0.03583654f, 0.01302935f, -0.07317676f, 0.07829508f, -0.01419418f, -0.04456457f, 0.05115103f, 0.01187216f, 
    0.08021090f, -0.01714541f, -0.09539884f, -0.26649293f, -0.03947204f, 0.06264257f, -0.04284288f, -0.05967829f, 
    0.05529219f, -0.09071798f, -0.04527165f, 0.02453531f, 0.14661157f, 0.09317201f, -0.01805108f, -0.18011038f, 
    -0.03534243f, -0.12374357f, 0.03342797f, -0.05341505f, -0.07675445f, 0.05591806f, -0.10989787f, -0.03875912f, 
    -0.00755758f, 0.05591172f, 0.09069841f, 0.11810836f, -0.01187069f, 0.07484006f, 0.08828762f, 0.01621250f, 
    0.10224514f, 0.03368922f, 0.12740609f, 0.11115722f, 0.27967557f, -0.02044674f, -0.15101467f, -0.18241782f, 
    0.06560956f, 0.09165055f, -0.13313624f, -0.01166284f, 0.10956090f, -0.06263153f, 0.07796804f, -0.01073427f, 
    -0.51439953f, 0.02548027f, -0.12978929f, -0.18683071f, -0.08504152f, -0.01828026f, 0.07682972f, 0.13428921f, 
    0.07204425f, 0.06293979f, 0.03708772f, 0.03914050f, -0.26940745f, -0.02556440f, -0.06595387f, 0.09939042f, 
    -0.10651322f, 0.01775891f, -0.06306715f, -0.04221267f, 0.00176329f, -0.09429681f, 0.10788842f, 0.09839613f, 
    0.27291006f, -0.04443789f, 0.09699208f, -0.00456462f, 0.12858966f, -0.04020445f, -0.06593981f, -0.02057714f, 
    0.03153988f, 0.08453457f, -0.10145732f, 0.02508531f, -0.13289128f, 0.10802110f, -0.18429993f, -0.34291151f, 
    -0.01769903f, 0.03374458f, 0.00639554f, -0.11801074f, -0.02825908f, 0.07868395f, -0.00834872f, 0.00414717f, 
    0.41736463f, -0.37296435f, -0.04464334f, -0.16438939f, 0.00661295f, -0.09761254f, 0.06175006f, 0.10034708f, 
    -0.07813923f, -0.00035378f, -0.06649384f, 0.05476470f, 0.27486673f, 0.04311285f, -0.01222030f, -0.07853288f, 
    0.06111148f, -0.06527960f, -0.03335667f, 0.05138529f, 0.13182636f, -0.06712655f, 0.08391766f, 0.12880236f, 
    0.18720783f, -0.23144431f, 0.05271273f, -0.03331106f, -0.03676980f, 0.00685482f, 0.04969030f, 0.03126520f, 
    -0.06419593f, -0.06969611f, -0.02681847f, 0.06594440f, -0.26966912f, 0.01362921f, -0.13590945f, -0.09144513f, 
    0.04394178f, 0.09694190f, -0.04229953f, -0.10699943f, 0.01379081f, 0.07144771f, 0.05530573f, -0.04913891f, 
    0.26600060f, 0.06945869f, 0.01394240f, 0.06102353f, -0.07409696f, 0.04938726f, 0.01693202f, -0.05957979f, 
    0.01140429f, -0.03936144f, 0.03248262f, -0.09582090f, -0.14556673f, -0.10763215f, 0.03777866f, 0.07141580f, 
    0.00104797f, 0.01132187f, -0.05996243f, 0.12433438f, -0.04448688f, -0.02852848f, 0.09282764f, 0.07356209f, 
    -0.07779886f, -0.04057264f, 0.05543337f, -0.17199482f, -0.10457078f, -0.10835107f, 0.03050830f, 0.01107565f, 
    0.04792125f, -0.11853088f, -0.11564850f, -0.04325959f, -0.39263874f, -0.08247586f, 0.20928670f, -0.06311133f, 
    0.07255775f, 0.09866206f, -0.03155673f, 0.02717063f, 0.10272008f, 0.06420703f, -0.06007203f, 0.05940948f, 
    0.10508206f, -0.14520401f, -0.20313255f, 0.20627274f, -0.00735285f, -0.00969785f, 0.03142809f, 0.02876853f, 
    -0.10137513f, -0.02689229f, -0.13209237f, 0.03366677f, 0.25262299f, 0.03311715f, -0.00202935f, 0.21587512f, 
    0.00786015f, -0.00584691f, 0.02831253f, 0.02693726f, -0.04355202f, 0.04699727f, 0.03014342f, 0.03132544f, 
    0.01031954f, -0.01161420f, 0.01140581f, -0.15906739f, -0.03457860f, -0.10485313f, -0.00744863f, 0.08438678f, 
    -0.04929211f, -0.09828249f, 0.07187857f, -0.05169348f, 0.18979295f, 0.09868895f, 0.01856488f, 0.25001895f, 
    -0.01243975f, 0.07910675f, 0.00149047f, 0.02375997f, -0.04342071f, 0.04121462f, 0.03255415f, -0.05190281f, 
    0.04094495f, 0.03754341f, 0.19148667f, -0.11563278f, -0.09409663f, -0.13505299f, -0.03616467f, 0.04344588f, 
    0.09937820f, 0.04804271f, 0.03630737f, -0.01193607f, -0.04528606f, 0.00073947f, -0.07551548f, -0.00324406f, 
    -0.03969740f, 0.03980493f, 0.09149396f, 0.08223947f, 0.01769990f, -0.11180925f, -0.03416960f, -0.11535033f, 
    0.02973265f, -0.08334729f, 0.02554096f, -0.09435010f, 0.08808692f, -0.01844830f, -0.00284051f, 0.05661125f, 
    0.01615810f, -0.09134346f, -0.15426949f, -0.13399461f, 0.39713198f, -0.08404920f, -0.00233733f, 0.15440194f, 
    -0.02650149f, -0.00514189f, -0.07695942f, 0.02654663f, 0.11843499f, 0.11405016f, -0.07471387f, 0.11036198f, 
    0.07578813f, 0.09177826f, 0.00918075f, 0.06124281f, -0.05402489f, -0.10488147f, 0.03889581f, -0.00558948f, 
    0.01630075f, 0.02279067f, -0.04426065f, 0.02391301f, 0.02767322f, 0.04673851f, 0.01225849f, -0.00934692f, 
    0.00510279f, -0.02739614f, -0.01815010f, 0.10481334f, 0.14737527f, -0.01162153f, 0.05224182f, -0.00199944f, 
    -0.02859728f, -0.26415464f, 0.01710354f, -0.35461026f, -0.03578226f, 0.00953695f, 0.10011972f, 0.01222217f, 
    -0.01587360f, 0.02880289f, -0.06368734f, 0.01847507f, 0.00082442f, -0.12813535f, -0.12864673f, -0.05939725f, 
    0.15859649f, -0.00569652f, 0.02278996f, -0.03982086f, 0.02599658f, 0.01990817f, -0.15302800f, 0.17849642f, 
    0.17367338f, -0.02910244f, 0.12915225f, -0.04675542f, -0.06126877f, 0.00889689f, 0.09164856f, -0.01119843f, 
    -0.22349812f, 0.06398496f, 0.07985912f, -0.13359560f, 0.24660064f, 0.05075994f, 0.24172691f, -0.04306211f, 
    -0.10906599f, 0.00392064f, 0.03562398f, 0.04062017f, -0.01885150f, 0.05901629f, -0.03241888f, 0.04129183f, 
    0.41058388f, -0.23005943f, -0.09742413f, 0.13566105f, -0.10322265f, -0.02109106f, -0.00734638f, -0.07100400f, 
    -0.04513441f, 0.03943425f, -0.10135838f, -0.02498170f, -0.45048061f, -0.08674457f, -0.25628963f, -0.05586176f, 
    -0.00256260f, -0.03946535f, -0.08850411f, 0.06079056f, 0.01283011f, 0.01030065f, 0.01071056f, -0.07292609f, 
    -0.06258455f, 0.12212837f, -0.00678484f, -0.03291875f, 0.03990015f, -0.04578719f, 0.05133296f, -0.02641663f, 
    0.03890108f, -0.05225542f, 0.00618643f, 0.08118319f, -0.11524812f, 0.06818172f, 0.05136772f, -0.10296556f, 
    -0.01266112f, -0.00405253f, 0.05133902f, 0.11702462f, -0.06973942f, 0.04420151f, -0.05098874f, -0.02066972f, 
    -0.06530555f, 0.07318829f, -0.05520736f, 0.07844196f, -0.01767052f, 0.07964206f, -0.01011300f, -0.07242361f, 
    -0.05866585f, 0.07527424f, -0.06175958f, 0.01559050f, 0.23915198f, -0.10357812f, 0.03416555f, -0.03827702f, 
    -0.13274390f, -0.02058507f, -0.09602523f, -0.05258407f, 0.08344367f, -0.03693029f, 0.04986981f, -0.13937372f, 
    0.20213695f, -0.00106316f, 0.07857783f, 0.10877077f, -0.01729490f, -0.13076794f, -0.03062795f, 0.04141774f, 
    0.01443951f, -0.05743938f, -0.04907234f, -0.02403506f, 0.11607514f, -0.06513353f, 0.00031871f, 0.03276073f, 
    -0.03517118f, 0.03646148f, 0.02822796f, 0.00453827f, 0.03975489f, 0.05901027f, 0.05886161f, 0.01172908f, 
    0.02605342f, -0.05022942f, -0.04836139f, -0.00689776f, 0.02220173f, 0.00514824f, 0.07097597f, -0.01229656f, 
    -0.01682337f, 0.06584569f, -0.02443235f, -0.07225423f, 0.02747093f, 0.09718920f, -0.04334746f, 0.06220749f, 
    -0.09605344f, 0.07343217f, -0.03979530f, 0.04439522f, -0.10889770f, -0.04607435f, -0.02516511f, -0.06123463f, 
    -0.33785793f, 0.09179902f, -0.15999156f, -0.34037337f, -0.03826358f, -0.05113622f, 0.00937425f, 0.00583357f, 
    -0.10019432f, -0.06566111f, -0.08753123f, 0.01416102f, -0.29894820f, 0.02341977f, 0.13353589f, -0.20860964f, 
    -0.02608720f, 0.02374384f, 0.05603107f, -0.06535177f, -0.05145645f, -0.06031910f, 0.00752511f, -0.01740237f, 
    -0.01525266f, 0.00181999f, -0.04202415f, -0.04836976f, 0.01011560f, 0.08393148f, 0.02042461f, 0.00166103f, 
    0.00488227f, 0.08484864f, 0.00282437f, 0.00617573f, -0.01943156f, -0.19541727f, 0.06487042f, 0.02146355f, 
    0.03258795f, 0.00666273f, -0.03980732f, -0.09414722f, 0.05569064f, 0.04008394f, -0.01129875f, 0.02950448f, 
    0.42871943f, -0.05842669f, -0.02172618f, -0.07963978f, -0.08262677f, 0.08781684f, 0.02855741f, 0.07118938f, 
    -0.08050254f, 0.04403137f, 0.03892297f, -0.06876155f, 0.12217485f, 0.08785781f, 0.10561937f, 0.24210203f, 
    -0.08396839f, -0.11526684f, -0.03942090f, 0.00953254f, -0.04126486f, 0.02662223f, -0.05151161f, 0.02706074f, 
    0.01232370f, -0.00793311f, -0.02344851f, -0.38674462f, -0.02994100f, 0.00195081f, -0.11229718f, -0.00526033f, 
    -0.05146763f, -0.03231269f, -0.05886122f, -0.02006434f, 0.11423180f, 0.02786025f, -0.06694721f, 0.04180698f, 
    -0.01335059f, -0.01340410f, 0.03318823f, -0.05749743f, 0.04330657f, 0.05737984f, 0.00620058f, -0.00201229f, 
    0.07670833f, -0.05618532f, 0.04182912f, 0.09211643f, -0.03868657f, 0.01860156f, -0.00219229f, -0.02711846f, 
    -0.08584063f, 0.05419841f, 0.09726950f, 0.00616940f, 0.17338480f, 0.17309043f, 0.09839471f, 0.09494674f, 
    -0.04715097f, -0.09286033f, 0.03795944f, 0.08965366f, -0.01962886f, 0.03927694f, -0.00696110f, -0.10179993f, 
    0.33796814f, -0.24000630f, -0.24034983f, 0.02743690f, 0.01281743f, -0.04339383f, 0.04412662f, -0.03599297f, 
    0.02139078f, -0.06004963f, -0.08060134f, -0.05903648f, -0.08018227f, -0.05219930f, 0.07248655f, -0.01717869f, 
    0.15883876f, 0.00993095f, 0.06144816f, -0.14078996f, 0.08691315f, -0.03328656f, 0.01158161f, 0.02059562f, 
    0.10268280f, -0.03961337f, -0.07963075f, 0.13231379f, 0.00861837f, -0.05301638f, 0.06984903f, -0.07516266f, 
    -0.08759257f, 0.10581926f, -0.16661893f, -0.04799727f, -0.08385143f, 0.04861129f, 0.13722320f, 0.04743296f, 
    -0.03402757f, -0.02400814f, 0.07113513f, -0.01584865f, -0.10975911f, -0.18724643f, 0.08207688f, -0.06062356f, 
    0.03745165f, -0.30266547f, -0.05404044f, -0.11166898f, -0.02080109f, 0.01249271f, -0.07230886f, -0.09327068f, 
    0.01720847f, 0.00810844f, -0.03213384f, -0.05696376f, -0.07616277f, 0.02949787f, -0.02531499f, -0.03058768f, 
    0.03644248f, 0.07292788f, -0.00330862f, 0.00849599f, 0.06492362f, 0.07181510f, -0.04139549f, 0.01145233f, 
    -0.53872794f, 0.03287042f, -0.06091313f, -0.03880208f, -0.14532974f, 0.12639004f, -0.12700754f, -0.01380412f, 
    0.00078566f, 0.01221034f, 0.00190678f, -0.07496902f, 0.20383970f, 0.03224576f, -0.13066420f, 0.02492382f, 
    -0.05256412f, -0.07366764f, -0.01481300f, -0.03449788f, -0.03276768f, 0.06326560f, 0.01958468f, -0.06191060f, 
    -0.13751981f, 0.15250283f, -0.11462750f, -0.17553890f, 0.04422243f, -0.04584351f, 0.04382983f, 0.05020489f, 
    -0.15329847f, 0.01223997f, -0.00124560f, 0.02605679f, 0.25970611f, 0.03600891f, 0.15978231f, 0.27274343f, 
    -0.09542908f, -0.13233519f, -0.04304364f, 0.06592249f, 0.03291817f, 0.04705634f, 0.08202620f, -0.05950976f, 
    -0.18997665f, 0.04883941f, -0.05448325f, -0.09001398f, 0.03000365f, -0.00732522f, 0.03129795f, 0.00173670f, 
    0.04314308f, -0.10974580f, -0.01361719f, -0.03529764f, 0.15232976f, 0.07632243f, 0.18011157f, 0.14186309f, 
    -0.07538962f, -0.08030418f, 0.10370014f, 0.06895514f, -0.01112464f, -0.01894695f, -0.00522527f, -0.09361134f, 
    0.16162595f, -0.01095812f, -0.05601757f, -0.06726392f, 0.07772099f, -0.01380565f, 0.02436542f, 0.04543589f, 
    -0.01627278f, 0.00579927f, 0.09881860f, -0.09899681f, -0.42930505f, 0.06981910f, 0.01529668f, -0.01297209f, 
    -0.00489511f, -0.12111990f, -0.01351247f, -0.09765257f, 0.02330261f, 0.01085662f, -0.12061307f, -0.04201796f, 
    0.17750001f, -0.08140936f, -0.23333746f, -0.05682241f, -0.04421301f, -0.00991119f, -0.00974966f, 0.00304480f, 
    -0.04927027f, 0.11889225f, -0.06343383f, -0.02803097f, 0.19142522f, -0.05972353f, -0.09658159f, 0.04690555f, 
    0.05048041f, -0.01074044f, -0.01882368f, -0.00722383f, 0.02128871f, -0.03386267f, 0.00730359f, -0.02561789f, 
    0.13739991f, 0.11173792f, -0.06749955f, -0.17093892f, 0.11195764f, 0.02862812f, -0.00693564f, -0.12552945f, 
    -0.03548886f, -0.04819643f, -0.06362484f, 0.00613618f, -0.08991239f, -0.05050486f, -0.11979204f, 0.03787440f, 
    -0.03508695f, -0.03338848f, -0.00911340f, 0.00605141f, 0.00853533f, -0.02297075f, 0.07570391f, 0.03302793f, 
    0.23273532f, 0.02575497f, -0.20885484f, -0.11876007f, -0.07509692f, 0.00211644f, -0.04323785f, 0.00962575f, 
    -0.06914118f, -0.05718841f, -0.04184062f, -0.09951834f, 0.40234494f, -0.09411367f, -0.11529422f, 0.07188895f, 
    -0.05797612f, 0.10640199f, -0.02334370f, 0.01089528f, -0.02407444f, -0.08510390f, 0.02086794f, -0.05721070f, 
    0.11472040f, -0.06675494f, 0.02173217f, -0.02457216f, 0.04264124f, -0.04259669f, 0.01931132f, 0.11886591f, 
    0.05371629f, -0.01248680f, -0.02603524f, -0.03069969f, 0.19721015f, -0.00941409f, -0.26615915f, -0.15236783f, 
    0.11124294f, 0.10896895f, -0.01707663f, -0.12826000f, 0.03346037f, -0.07776912f, 0.07186322f, -0.06339370f, 
    0.20547307f, 0.01464939f, -0.12210370f, -0.24133776f, 0.00349909f, -0.11643184f, 0.03911458f, -0.03886343f, 
    -0.02176197f, 0.01668724f, 0.04662981f, -0.03971214f, 0.12150198f, 0.07012217f, 0.10403341f, 0.12841241f, 
    -0.15021521f, -0.02500475f, -0.01135675f, 0.04677774f, -0.04338951f, -0.04052189f, -0.00032820f, -0.02002488f, 
    0.00862522f, -0.00975375f, -0.17466167f, 0.05985264f, -0.05939697f, -0.09124847f, 0.01468094f, -0.00594376f, 
    -0.01413878f, 0.03460696f, 0.08973724f, 0.01192680f, 0.22046547f, 0.06108013f, -0.24774669f, 0.07187761f, 
    0.05799799f, 0.05577032f, -0.08286730f, -0.02134720f, -0.13425083f, -0.02216291f, -0.02876314f, -0.05636629f, 
    0.09136609f, -0.10550044f, 0.10461382f, 0.04650022f, 0.08537319f, 0.04333141f, 0.08313671f, -0.04561791f, 
    -0.01737935f, 0.00763428f, -0.04370781f, 0.06054274f, -0.02708525f, -0.05859968f, -0.03931473f, -0.02259536f, 
    0.09278429f, 0.08797266f, -0.07582855f, -0.06029732f, -0.05428752f, -0.05598325f, 0.06232612f, -0.06048628f, 
    -0.11995380f, -0.22557437f, -0.05384337f, -0.21548177f, 0.05606894f, -0.03549246f, 0.05498907f, 0.02080283f, 
    -0.03578337f, 0.06829621f, 0.04539746f, -0.10782077f, -0.13580751f, 0.13045050f, 0.06226024f, 0.11094274f, 
    0.05123400f, 0.12488355f, 0.01289407f, 0.00351358f, -0.04453053f, -0.06648590f, 0.12792949f, 0.02622513f, 
    -0.14064878f, 0.15367399f, -0.15204139f, 0.01730109f, 0.09357464f, 0.00444748f, 0.01794592f, -0.03974630f, 
    0.02009299f, 0.05502926f, -0.02111902f, -0.06686496f, -0.14250748f, -0.05909260f, 0.05278289f, -0.01008621f, 
    0.04544532f, -0.07749186f, 0.07197639f, -0.15796554f, 0.03971185f, -0.03072519f, -0.01570380f, 0.06331320f, 
    -0.34998351f, -0.00437077f, -0.04973964f, 0.00842509f, 0.01239905f, 0.00119473f, -0.03404990f, 0.00942521f, 
    -0.01667799f, 0.01440284f, -0.15511177f, 0.00541595f, 0.02484307f, -0.05454645f, -0.09510179f, 0.01289846f, 
    0.04813834f, 0.03015957f, 0.01753628f, -0.03031357f, -0.03946287f, 0.02321418f, -0.04060136f, -0.05594884f, 
    -0.02932527f, 0.09441405f, 0.09004307f, 0.07683434f, -0.02642621f, -0.03604594f, 0.16603479f, -0.04165172f, 
    -0.10303386f, -0.06828199f, -0.04464224f, 0.01972452f, 0.09637492f, -0.07000435f, -0.01558938f, -0.05322661f, 
    -0.13209477f, -0.09689093f, -0.11346647f, 0.01859663f, -0.01016771f, 0.02891397f, -0.04668983f, -0.03949469f, 
    0.20299679f, 0.02145547f, -0.19132805f, 0.09067224f, 0.01346676f, 0.00408661f, -0.12619345f, -0.08011675f, 
    0.03500761f, 0.03625098f, 0.10125356f, 0.05459538f, -0.11728688f, 0.02864218f, 0.06238565f, -0.00487063f, 
    0.04611106f, -0.02389229f, -0.04392834f, 0.04041481f, -0.02599635f, -0.06795725f, -0.03208280f, -0.06767301f, 
    -0.02048959f, 0.12572949f, 0.02700211f, -0.08087049f, 0.04116756f, 0.12621956f, 0.07899758f, -0.01484682f, 
    -0.02029167f, -0.05067893f, 0.01548454f, -0.04276932f, 0.14245854f, 0.00977506f, -0.06352845f, 0.14890647f, 
    -0.02685990f, -0.00907106f, 0.02668326f, 0.01344345f, -0.06107128f, 0.02856330f, -0.05779899f, 0.10917656f, 
    -0.42288390f, -0.09149909f, -0.05740193f, -0.20170815f, 0.04504757f, -0.09826539f, -0.05431383f, -0.09371167f, 
    -0.07015277f, 0.01143722f, -0.01288950f, -0.02505807f, 0.14141873f, -0.05730147f, 0.02268160f, 0.16981450f, 
    -0.03617969f, 0.07264834f, 0.07628275f, -0.01735380f, -0.03150805f, -0.02537766f, 0.02530324f, 0.06333324f, 
    -0.22107053f, 0.10684613f, -0.04521403f, -0.08564728f, -0.04252769f, 0.08735210f, 0.01497238f, -0.09770197f, 
    0.06010204f, -0.06399668f, 0.07995429f, -0.01752209f, 0.09253569f, -0.07435514f, 0.10179707f, -0.09895159f, 
    0.07531311f, 0.10116485f, 0.06414973f, 0.12344394f, -0.12288620f, 0.06225711f, -0.08430942f, 0.13596268f, 
    -0.00676177f, 0.05552329f, -0.07954087f, -0.06634630f, -0.09613702f, -0.08739185f, -0.00885015f, -0.02437044f, 
    -0.03641471f, 0.05398316f, -0.08155490f, 0.03691325f, 0.10066388f, 0.02851424f, 0.14055181f, 0.01515296f, 
    -0.00617471f, 0.04253886f, 0.07521529f, -0.06053258f, 0.14431854f, 0.03284198f, -0.01466272f, 0.02733063f, 
    -0.46493813f, -0.34245330f, -0.33390775f, -0.13752002f, -0.15772860f, -0.00880264f, 0.03128831f, -0.10100759f, 
    -0.06528112f, -0.08763128f, -0.03293083f, 0.02583993f, -0.20127539f, 0.08511175f, -0.27363732f, 0.02390389f, 
    -0.12291003f, 0.06784008f, -0.01551932f, 0.01158764f, 0.09804387f, -0.04508514f, -0.02055062f, 0.04405027f, 
    -0.17571336f, -0.10452383f, -0.15614924f, 0.25181094f, 0.02091556f, 0.05416194f, -0.04454907f, -0.05121462f, 
    0.04276159f, -0.01577699f, -0.02144723f, -0.01127361f, 0.23158753f, 0.06079834f, -0.00927009f, 0.01884088f, 
    -0.08148271f, -0.06252885f, 0.09508204f, -0.05392242f, -0.08605532f, -0.04319661f, -0.00904148f, -0.05768886f, 
    0.00518391f, 0.08812326f, -0.09678284f, -0.13343507f, 0.01873277f, -0.05942730f, 0.09706265f, 0.03184547f, 
    -0.07683660f, -0.08783063f, -0.04460741f, 0.00467553f, -0.18953915f, 0.20582737f, -0.06715486f, 0.01607106f, 
    -0.00530430f, -0.03553015f, 0.04268277f, 0.04137312f, 0.00925647f, 0.04655687f, 0.05685616f, -0.08613726f, 
    -0.06305224f, -0.13979615f, -0.04003368f, -0.04672451f, -0.11791874f, 0.05776602f, 0.00193885f, 0.02314381f, 
    -0.03257835f, 0.04290741f, 0.07733391f, 0.08759072f, -0.14114472f, 0.00659709f, -0.12313662f, 0.16729660f, 
    0.00711198f, 0.08176929f, 0.03856479f, 0.01862481f, 0.05266472f, 0.05911474f, 0.02103803f, -0.08560879f, 
    0.17969978f, 0.02522162f, 0.03285914f, -0.11634021f, -0.02160488f, -0.02087171f, 0.07760981f, 0.11945053f, 
    -0.02424316f, -0.01662198f, -0.03580103f, 0.06603778f, -0.06774315f, -0.19386272f, -0.05326404f, 0.13019119f, 
    -0.06976197f, 0.00045387f, -0.12834188f, 0.03667407f, 0.03043793f, 0.05998209f, -0.05612736f, 0.01728673f, 
    0.16430321f, -0.23202212f, -0.21958709f, 0.04667594f, 0.03652528f, 0.02978911f, 0.10560701f, 0.01206228f, 
    0.05577946f, 0.08359974f, -0.02444099f, 0.02041432f, 0.04455195f, -0.37358776f, -0.02691803f, 0.16056190f, 
    -0.02466861f, 0.04670361f, -0.06985664f, -0.11352936f, 0.07599302f, -0.04001185f, 0.05771223f, 0.01258953f, 
    -0.32101461f, 0.21506335f, 0.12064397f, -0.19907358f, -0.02737222f, 0.12783751f, -0.08869928f, 0.11044960f, 
    0.04513595f, -0.03837683f, -0.06473274f, -0.02861718f, 0.00169536f, 0.00164424f, -0.06689289f, -0.09429176f, 
    -0.03609431f, -0.01537958f, 0.01092379f, -0.03204555f, -0.09161076f, -0.06317846f, 0.00882559f, -0.01803387f, 
    0.23189265f, 0.05640596f, 0.12572284f, -0.11078372f, 0.02856378f, -0.07393825f, -0.11682003f, 0.04042094f, 
    -0.03434189f, -0.01471950f, -0.00962015f, 0.07777243f, -0.18313053f, -0.05292007f, -0.03130969f, -0.10603645f, 
    -0.07137457f, -0.02931220f, 0.06915226f, -0.05722439f, -0.04255046f, 0.09610005f, -0.13519448f, 0.05401680f, 
    -0.19869702f, 0.08719647f, 0.08129085f, -0.11206317f, -0.06091365f, 0.08491579f, -0.02001099f, 0.01767372f, 
    -0.00630105f, -0.01523121f, -0.03796740f, 0.02678284f, -0.08977166f, 0.01548878f, -0.06838301f, -0.09147708f, 
    -0.08404325f, -0.06197876f, 0.00156527f, -0.01889810f, -0.05066110f, -0.05026100f, 0.04517675f, 0.00974750f, 
    0.00564194f, 0.16081898f, 0.03492169f, -0.00357932f, 0.04488749f, -0.14725603f, 0.01465394f, 0.08937700f, 
    -0.07328650f, -0.01358599f, 0.04662318f, -0.09965377f, -0.02778260f, -0.22684571f, -0.01714287f, 0.12508087f, 
    -0.03175042f, 0.09599347f, 0.01974660f, -0.19487263f, -0.02702919f, -0.09885800f, 0.05547526f, 0.02636262f, 
    0.59847105f, 0.02310476f, -0.02100037f, 0.07486154f, 0.03393947f, -0.03381763f, -0.02409216f, 0.14402115f, 
    0.05298677f, -0.02471075f, -0.13250251f, -0.11940412f, 0.07472204f, -0.07966155f, -0.14985488f, -0.07923077f, 
    -0.07283182f, 0.12569205f, -0.08263936f, 0.06912357f, 0.09709962f, -0.02563348f, -0.07805202f, -0.02709246f, 
    0.02180779f, 0.14378124f, 0.01798091f, 0.12530643f, -0.09478840f, -0.07478853f, 0.00373737f, 0.12259124f, 
    0.01120689f, -0.01809441f, 0.10929271f, 0.06108324f, -0.12755033f, -0.41474378f, -0.13914005f, 0.17979309f, 
    -0.05458245f, -0.01444620f, 0.01866688f, 0.09993891f, 0.05833183f, 0.03163876f, -0.05040668f, 0.02941647f, 
    0.14639781f, -0.20803276f, 0.00051892f, -0.06568764f, -0.08514642f, 0.03781133f, 0.07830045f, 0.09548023f, 
    0.03892876f, 0.11491957f, -0.13020082f, 0.04275331f, 0.06953717f, -0.01003363f, 0.15067075f, 0.10360024f, 
    -0.03659637f, -0.08181125f, 0.05127886f, 0.03144975f, -0.00718727f, 0.05596096f, -0.02532359f, -0.01720827f, 
    -0.49388933f, -0.01656633f, -0.22800775f, 0.01341001f, 0.01549204f, 0.05759996f, -0.01227505f, -0.03483455f, 
    -0.03320633f, 0.03947010f, 0.17864017f, 0.06762821f, 0.14552261f, -0.19209589f, 0.06447151f, -0.07671228f, 
    -0.00899821f, -0.00414279f, -0.01751030f, -0.01341878f, 0.02067183f, -0.07058173f, 0.01373573f, -0.00902695f, 
    -0.02978706f, -0.34570831f, -0.11592670f, 0.18398637f, -0.14936571f, -0.02338236f, 0.00828958f, -0.07255866f, 
    0.02977411f, -0.13438217f, 0.13068804f, -0.05767113f, 0.04206345f, -0.08316436f, -0.00441802f, 0.09403479f, 
    -0.08293786f, 0.04861567f, 0.05149905f, -0.07882715f, -0.06243820f, 0.03479314f, 0.04755211f, 0.03742641f, 
    0.09918527f, -0.25619689f, -0.06011513f, -0.17279314f, -0.00729967f, -0.00620483f, 0.02021016f, -0.03462056f, 
    0.04499101f, -0.07239091f, 0.01138520f, -0.06394476f, 0.05617414f, 0.07583179f, -0.13361919f, 0.15379587f, 
    -0.03900840f, 0.07633183f, 0.03447493f, 0.07800061f, -0.04763044f, -0.02924543f, -0.05928093f, -0.00204302f, 
    -0.00137065f, 0.01975460f, 0.11397744f, 0.10667293f, 0.09772742f, 0.02095263f, 0.09008811f, 0.02163879f, 
    0.08984175f, 0.06346590f, -0.03179570f, 0.07408345f, -0.16775058f, 0.15998062f, 0.14279695f, 0.01552108f, 
    0.13237600f, 0.00753307f, 0.01924036f, 0.04485841f, 0.03236597f, 0.01090726f, -0.06851500f, 0.06976144f, 
    -0.44268343f, -0.21257885f, 0.03998667f, -0.00810574f, 0.00057018f, -0.02940674f, -0.14530364f, -0.02183966f, 
    -0.03869849f, -0.04544850f, -0.00772615f, -0.10520671f, -0.07862591f, 0.11494331f, 0.01349439f, 0.14278826f, 
    -0.09091322f, -0.12130522f, 0.06665242f, 0.06571094f, -0.20130911f, 0.20121628f, -0.09027091f, -0.00210413f, 
    -0.13283622f, 0.30444694f, 0.07499839f, -0.04918182f, -0.04545879f, 0.00265520f, 0.06387643f, 0.01266179f, 
    -0.04616958f, -0.07272090f, 0.01586471f, 0.11691523f, -0.35402781f, 0.03065372f, 0.22492434f, 0.10137895f, 
    0.12471234f, -0.02613707f, -0.00956657f, -0.03482572f, -0.02360098f, 0.11696614f, -0.16391815f, -0.07346912f, 
    -0.06048033f, -0.14586635f, 0.04301585f, -0.05552576f, -0.06607812f, -0.01859878f, 0.02172469f, -0.05306939f, 
    0.02009501f, -0.02248348f, 0.02996871f, 0.02315273f, 0.09310765f, 0.28641257f, 0.16442078f, 0.06097819f, 
    0.07836387f, 0.03649581f, -0.02889863f, 0.00638836f, -0.04580412f, 0.00027715f, 0.03432898f, -0.04929985f, 
    0.23269679f, -0.21199346f, -0.25286171f, 0.02071525f, -0.10558821f, 0.06310573f, -0.05180179f, 0.02488538f, 
    -0.04732335f, 0.04344609f, -0.06212325f, 0.03406948f, 0.01241329f, -0.01929358f, -0.08314443f, -0.11278027f, 
    -0.15918916f, -0.06503810f, -0.01614637f, 0.02874519f, -0.05510450f, -0.07675453f, -0.02013613f, 0.00412501f, 
    0.19875683f, -0.06904183f, 0.04622551f, 0.01603369f, -0.07287988f, -0.04298369f, 0.05410786f, 0.07405213f, 
    -0.06763580f, 0.04620805f, 0.05637380f, -0.08986658f, -0.34282598f, 0.24086955f, 0.13313465f, 0.07581223f, 
    0.05744195f, 0.02438038f, -0.00234224f, 0.10974665f, -0.06676210f, -0.02117974f, -0.14383665f, -0.10604194f, 
    0.13876684f, -0.27065343f, -0.07936405f, -0.03542612f, -0.07869014f, -0.06136971f, 0.08468089f, 0.00026183f, 
    0.06035402f, 0.01524299f, -0.12520477f, 0.05969483f, 0.13607213f, 0.08203317f, 0.11239830f, 0.29415229f, 
    0.04042837f, 0.16053219f, -0.01452938f, -0.17552018f, 0.01452234f, -0.00116131f, -0.07287472f, -0.11566754f, 
    0.36283469f, 0.26275492f, 0.07320894f, 0.21037988f, -0.07330256f, 0.07740872f, 0.02096968f, -0.06773418f, 
    -0.01045112f, 0.04884471f, 0.05790317f, -0.04920378f, -0.10882986f, -0.08106652f, -0.03816422f, -0.06822081f, 
    0.07621671f, -0.02654735f, 0.07232065f, 0.02192990f, -0.06765386f, 0.01252976f, 0.03926366f, 0.01322925f, 
    0.04503716f, -0.03292662f, 0.03717789f, 0.00745933f, -0.02681842f, -0.00271589f, -0.00336809f, 0.03081539f, 
    0.00817027f, -0.04209661f, -0.01015960f, 0.01922357f, -0.11866456f, -0.50133151f, -0.01671941f, 0.16211994f, 
    -0.06483166f, -0.02352500f, -0.00219021f, -0.04807178f, 0.12738813f, -0.09827220f, 0.01134848f, 0.03843849f, 
    0.15694501f, -0.14569275f, -0.04627840f, 0.04797282f, -0.04241069f, 0.01160384f, 0.03497798f, -0.02570438f, 
    0.01276569f, 0.05748808f, -0.07099654f, 0.09667519f, -0.43712637f, -0.15726838f, -0.08044426f, 0.02062358f, 
    -0.08170883f, -0.10664247f, 0.02950825f, 0.01671464f, -0.01718068f, -0.04141223f, 0.01855524f, -0.01048028f, 
    -0.31945780f, 0.16070965f, -0.22836302f, 0.10466640f, -0.13652115f, 0.05805521f, 0.02355536f, -0.07810363f, 
    -0.01994630f, -0.02308792f, -0.14116570f, -0.01257442f, 0.05366277f, 0.12698562f, 0.11187229f, -0.02959932f, 
    -0.10520867f, -0.04026920f, -0.06747176f, 0.02685601f, 0.01396749f, -0.03927505f, 0.07455563f, 0.09736852f, 
    0.15249535f, 0.09147208f, 0.15933792f, 0.16479960f, 0.08046461f, 0.01919308f, -0.04979007f, -0.04248673f, 
    0.05443742f, 0.02843246f, -0.03075965f, 0.06918094f, -0.20187575f, -0.09366500f, -0.05062895f, -0.21415846f, 
    -0.08778612f, 0.01603363f, 0.00387617f, -0.06855208f, 0.01452313f, -0.06814504f, 0.19935060f, 0.10869411f, 
    -0.45014784f, -0.20220675f, -0.25597966f, 0.10693734f, -0.10729555f, -0.03199508f, 0.01587132f, 0.03714894f, 
    0.02240948f, -0.10687812f, 0.02398196f, -0.17181046f, -0.35455033f, 0.06556365f, 0.01797664f, -0.11596658f, 
    -0.07651811f, -0.01244512f, 0.01112317f, 0.00201301f, -0.05487613f, 0.10015512f, 0.00849800f, 0.04550534f, 
    0.13509311f, 0.07089399f, 0.06771574f, 0.02138845f, 0.01976604f, -0.00181734f, -0.01074884f, 0.04055820f, 
    0.00619503f, -0.03891649f, -0.03484421f, 0.03554703f, 0.01484087f, 0.09347519f, 0.03973924f, -0.15534970f, 
    0.01350013f, 0.01277341f, -0.02873952f, -0.01214322f, -0.03794447f, -0.00687189f, -0.06212687f, -0.02781721f, 
    -0.22348951f, -0.02787083f, 0.04134273f, -0.13316242f, 0.01280700f, -0.03673785f, 0.03244971f, 0.08229771f, 
    -0.03552755f, 0.18848865f, 0.08338095f, -0.00650330f, -0.28438449f, 0.14704493f, 0.09050505f, 0.04811442f, 
    -0.02057926f, -0.11695828f, -0.05110463f, 0.03333198f, 0.15171586f, 0.02991606f, -0.20319952f, -0.03292684f, 
    0.00823164f, 0.08159765f, 0.09816578f, 0.19285107f, 0.11824584f, 0.03999047f, -0.04625754f, 0.10918786f, 
    0.12354431f, 0.05200322f, 0.07932004f, 0.00760400f, 0.10440380f, -0.00032942f, 0.14604613f, 0.09852675f, 
    -0.07478955f, -0.01362351f, 0.09709997f, -0.00113056f, -0.05407090f, -0.04069688f, 0.08235350f, -0.01516178f, 
    0.08208938f, -0.29337284f, -0.02770972f, 0.03001404f, -0.21523406f, -0.01337310f, -0.05249900f, -0.05038437f, 
    0.08167925f, 0.11459941f, -0.06397169f, -0.10458341f, -0.16566651f, -0.12950546f, 0.08057910f, -0.09697769f, 
    -0.13053586f, 0.19155721f, 0.06728133f, 0.07463714f, 0.00571585f, 0.01691409f, -0.09116395f, -0.05342741f, 
    -0.32725978f, -0.05091335f, 0.14510310f, 0.14703348f, -0.10661333f, -0.00700387f, -0.05931521f, -0.05923115f, 
    0.04674322f, 0.01352633f, 0.04082280f, 0.04496265f, -0.55793381f, 0.00256041f, -0.15520415f, -0.36374265f, 
    0.03027589f, 0.00416605f, -0.04411341f, 0.11528932f, -0.07810581f, -0.08439774f, -0.01686214f, 0.02352410f, 
    -0.45437390f, -0.13412192f, 0.06516490f, -0.00834111f, 0.03609014f, -0.05436132f, 0.03835556f, -0.09446779f, 
    0.01432170f, 0.06222834f, 0.01850514f, 0.01905721f, -0.08814409f, -0.01585410f, -0.05123927f, 0.03796895f, 
    0.00406959f, 0.07907926f, 0.06568930f, 0.01777794f, -0.00612209f, -0.08211394f, 0.02364608f, 0.09010478f, 
    -0.10310347f, -0.19137222f, -0.03305309f, -0.04935950f, -0.03239622f, 0.01822215f, 0.08256239f, 0.01829308f, 
    0.02950012f, -0.03229650f, 0.07583149f, 0.06664540f, -0.09454923f, -0.16657484f, -0.08564351f, -0.14779347f, 
    0.01652765f, 0.10671635f, -0.02735851f, 0.08513699f, 0.07827208f, -0.08519668f, -0.07895149f, -0.08980749f, 
    0.01619771f, -0.02533550f, 0.05012523f, -0.07526551f, 0.14628689f, 0.01429540f, 0.10663433f, 0.05113690f, 
    -0.09835594f, 0.00971742f, 0.05207012f, -0.05404537f, -0.13412343f, -0.33103037f, 0.14746498f, -0.00688896f, 
    -0.10635816f, 0.12244439f, -0.04153244f, -0.09184681f, 0.04930925f, -0.07652517f, 0.00682937f, -0.10210519f, 
    -0.10237122f, 0.02041375f, 0.19874676f, 0.02523362f, 0.04404387f, 0.06123596f, -0.03601246f, -0.02130278f, 
    0.02974846f, 0.02804015f, 0.09210870f, 0.13170125f, 0.04269184f, 0.17942528f, -0.08295941f, -0.03627535f, 
    0.00101037f, 0.03485774f, 0.09173122f, 0.09340900f, 0.00319771f, 0.01478718f, 0.00383713f, 0.14372741f, 
    0.27825198f, 0.08152187f, 0.04756153f, -0.04463931f, -0.01933489f, -0.01445465f, 0.11410978f, 0.06801021f, 
    0.04508239f, 0.02607195f, 0.04252930f, 0.08703873f, -0.20619246f, -0.06331136f, 0.08070758f, 0.20084436f, 
    0.05607449f, -0.01842647f, 0.00380527f, 0.06425167f, -0.06221820f, 0.05002276f, 0.01716096f, -0.01955764f, 
    0.36401087f, -0.05060247f, 0.05799756f, -0.22997482f, 0.07118427f, -0.00752238f, -0.05243569f, 0.02140430f, 
    0.00349361f, -0.03554440f, -0.09053438f, 0.03678953f, 0.26805323f, -0.05032882f, -0.06958561f, 0.06678523f, 
    0.01195639f, 0.01212506f, 0.12034529f, -0.00731827f, -0.10252825f, 0.00241088f, 0.03596410f, -0.03353943f, 
    0.01048111f, -0.04807807f, 0.06213264f, 0.14308633f, -0.09629550f, -0.03607206f, 0.00385350f, 0.09470621f, 
    -0.04771530f, 0.02544023f, 0.04643156f, 0.04040656f, -0.13887730f, -0.06701718f, -0.01029309f, 0.20475683f, 
    0.06028660f, -0.03742625f, 0.01458952f, 0.00088594f, 0.03981616f, 0.03364464f, 0.10547884f, 0.06906290f, 
    0.15757915f, 0.20815144f, -0.00434894f, -0.45028546f, -0.10853576f, -0.09197736f, -0.08279657f, -0.03769859f, 
    -0.06700978f, -0.08798240f, -0.00630262f, 0.05197841f, 0.10306498f, -0.03824966f, -0.14736228f, 0.15309949f, 
    0.04070315f, -0.00005094f, 0.03792510f, 0.03511249f, 0.02577519f, 0.07347216f, -0.05965718f, 0.05837239f, 
    0.38844407f, 0.17117466f, -0.14313738f, -0.29489151f, -0.12002340f, -0.09492385f, -0.08869929f, 0.01698719f, 
    0.07785501f, -0.06127394f, 0.04690325f, -0.04269810f, -0.00688517f, -0.09206571f, -0.02076398f, 0.04504985f, 
    -0.09150080f, 0.00915993f, 0.12529644f, -0.00108790f, 0.09398272f, 0.05601754f, -0.07592169f, -0.05694808f, 
    -0.05219500f, 0.07295851f, 0.00607562f, 0.04982412f, 0.04274858f, 0.03090162f, 0.07405896f, 0.11862016f, 
    0.03298749f, 0.08349232f, 0.01619580f, 0.00002104f, -0.10259059f, 0.18976183f, 0.03575206f, -0.13316908f, 
    -0.01728140f, -0.03397426f, 0.00977610f, 0.03000587f, 0.01547330f, -0.07419165f, 0.01531510f, 0.02254276f, 
    -0.21124506f, 0.04804841f, 0.13812631f, -0.16947676f, 0.03262972f, 0.15457089f, -0.03834216f, -0.05576187f, 
    0.02094365f, -0.10919125f, -0.00389830f, 0.14209811f, 0.06943475f, -0.03736543f, -0.22537304f, 0.00472926f, 
    0.05945186f, -0.08839674f, 0.12509005f, 0.05265296f, -0.08684783f, -0.20415504f, 0.13546000f, -0.04652943f, 
    -0.00385997f, 0.09973793f, 0.10905823f, -0.03420254f, -0.06098051f, -0.01284610f, 0.02235631f, -0.00115227f, 
    0.13216621f, -0.03054354f, 0.12510818f, -0.07395419f, -0.75607210f, -0.14405710f, -0.00627415f, 0.10477238f, 
    0.08660960f, 0.03149544f, 0.00303838f, 0.17222062f, -0.04820516f, -0.07765780f, 0.08087933f, 0.07273392f, 
    0.03466512f, 0.03551171f, 0.16942868f, -0.15255383f, 0.16847260f, 0.07250424f, -0.02947287f, 0.01796683f, 
    0.01973657f, 0.01941001f, 0.04820695f, 0.08187700f, -0.38731214f, 0.09233466f, 0.19220600f, 0.08316637f, 
    -0.01451220f, 0.08530127f, -0.01695443f, 0.10015244f, -0.02851768f, 0.01088796f, 0.01831537f, -0.01192742f, 
    0.33105907f, 0.07527477f, -0.01519868f, 0.05384807f, -0.01937670f, 0.01215710f, 0.02529838f, -0.02902736f, 
    -0.01483139f, 0.02046223f, -0.00709969f, -0.03505047f, -0.22562969f, 0.04873417f, -0.10954072f, 0.10635003f, 
    0.01969237f, 0.01285337f, 0.06004537f, -0.02235471f, -0.03867566f, 0.00049232f, 0.00198266f, 0.01349497f, 
    -0.00709802f, 0.02586752f, 0.12039195f, -0.02059812f, -0.06679867f, 0.03254949f, -0.02334697f, -0.01314929f, 
    0.05487540f, -0.04259617f, -0.03617147f, 0.09443019f, -0.21581019f, 0.11904312f, -0.10816718f, 0.02842398f, 
    -0.11448711f, -0.10877905f, -0.01514090f, -0.06288649f, -0.03394230f, -0.12925638f, 0.02103302f, -0.02126299f, 
    -0.30401981f, -0.07254181f, 0.28273267f, 0.11512581f, -0.06638218f, -0.03666480f, -0.06490134f, -0.05772307f, 
    0.06028465f, -0.09888012f, -0.08884179f, -0.04619095f, 0.21900293f, -0.09022032f, -0.23410495f, -0.20350192f, 
    0.03428173f, 0.08063878f, 0.14917840f, -0.13323840f, -0.03528311f, -0.09649140f, -0.07396250f, -0.00655560f, 
    0.05363945f, 0.08474714f, 0.08014598f, -0.02378295f, 0.02829173f, -0.05688095f, 0.01298126f, -0.09321301f, 
    0.11845998f, 0.01900714f, -0.15602878f, -0.05087139f, -0.33066154f, -0.10239231f, 0.05057478f, -0.08318624f, 
    0.09044421f, -0.05094016f, -0.06032031f, 0.01753006f, -0.00941905f, 0.07796954f, -0.21886510f, -0.06103792f, 
    -0.00163846f, -0.07861685f, -0.03455101f, 0.05489006f, -0.02047078f, 0.05990247f, 0.12036358f, -0.03115154f, 
    0.01586821f, -0.05266945f, 0.07705332f, -0.00978811f, -0.29399973f, 0.07505183f, 0.12919110f, 0.15032320f, 
    -0.13424154f, -0.07938501f, 0.04615300f, -0.14170641f, 0.00263383f, 0.10603237f, -0.01375951f, -0.01794043f, 
    -0.11952884f, -0.02763596f, -0.02471764f, -0.07608347f, -0.13784383f, 0.01646694f, 0.09934835f, -0.06219855f, 
    0.06330035f, -0.05775244f, -0.04819745f, -0.03576193f, -0.16001488f, 0.12825528f, -0.05828226f, 0.10354549f, 
    0.02786343f, 0.10020448f, -0.05601583f, 0.03737225f, 0.03209673f, -0.05552555f, 0.05641698f, -0.12282994f, 
    0.20867364f, -0.02581044f, -0.28433356f, -0.13546970f, -0.10993496f, -0.10996944f, 0.05062911f, -0.06328745f, 
    -0.02457786f, -0.04039334f, -0.03467400f, -0.02854406f, -0.35568625f, -0.04685409f, 0.20095065f, 0.02901538f, 
    0.03554099f, 0.01896343f, -0.02429915f, -0.11156076f, 0.07227217f, -0.05141437f, -0.06481411f, 0.04050219f, 
    -0.17970358f, 0.03557763f, -0.24576893f, -0.00712587f, 0.05529832f, 0.01110204f, 0.07691580f, 0.17436746f, 
    -0.07871059f, -0.00628821f, 0.04434502f, 0.08422780f, -0.12084344f, -0.13044031f, 0.06037831f, 0.11034035f, 
    0.02043489f, 0.00722455f, -0.03018298f, -0.02603468f, 0.09481008f, -0.03744582f, -0.01001864f, -0.09977905f, 
    -0.03495143f, -0.08814739f, -0.14246075f, 0.14317045f, -0.03561177f, -0.03144054f, -0.04424837f, 0.02267939f, 
    0.01571827f, 0.12167078f, 0.00967833f, 0.06642216f, -0.06741573f, 0.01165350f, -0.01481611f, 0.19831738f, 
    0.04060261f, -0.04314465f, 0.05459604f, -0.05525366f, -0.07338321f, -0.03663451f, 0.05571813f, -0.00546486f, 
    0.11176607f, -0.06536828f, 0.13309595f, 0.08366582f, -0.11355849f, 0.03116399f, -0.06588625f, -0.05754340f, 
    0.06542747f, 0.03603588f, -0.09183123f, -0.00580480f, 0.23144023f, 0.12130029f, -0.04645716f, 0.07358464f, 
    -0.04289771f, -0.01995206f, 0.08302025f, 0.08484557f, -0.04085512f, -0.00507027f, 0.10962291f, -0.14668569f, 
    0.17061584f, -0.11121058f, 0.09032194f, -0.04127252f, -0.01730975f, 0.06733034f, -0.01523099f, -0.02390150f, 
    -0.02920562f, 0.08779834f, 0.05608873f, -0.04452860f, 0.09995139f, 0.04593821f, 0.02868220f, 0.06035211f, 
    -0.10610633f, -0.07838762f, 0.06356740f, 0.11650511f, 0.01310481f, 0.04200039f, -0.02173288f, 0.10239723f, 
    -0.16969104f, -0.08337077f, 0.00896929f, 0.03262054f, 0.03620389f, 0.02759668f, -0.03039661f, -0.14676178f, 
    0.01999022f, -0.09551428f, -0.06915438f, -0.04615801f, 0.30265927f, 0.07222168f, 0.09611263f, 0.08966108f, 
    0.08760917f, -0.00637586f, -0.11677446f, 0.02165659f, 0.11288459f, 0.06938469f, 0.02352933f, 0.07089572f, 
    -0.12436024f, 0.06182240f, -0.02924697f, -0.16048518f, 0.06373746f, -0.10040632f, -0.04655230f, 0.08353534f, 
    -0.07652778f, -0.06165975f, 0.02126841f, 0.01337674f, -0.15854532f, 0.27835208f, -0.11456494f, -0.02931185f, 
    0.14985500f, 0.00946145f, -0.00964636f, -0.00387668f, 0.06040492f, -0.02492921f, 0.02070613f, -0.04266867f, 
    -0.29934755f, -0.18488047f, 0.10971520f, 0.07962875f, -0.11486039f, -0.04536805f, -0.00299627f, -0.00709595f, 
    0.14339079f, 0.04214947f, 0.00774153f, -0.08717070f, -0.06842653f, 0.02056782f, -0.05642850f, 0.09411654f, 
    0.00613894f, 0.05127478f, 0.03943573f, -0.18561743f, -0.06986631f, -0.06799809f, 0.00645441f, -0.01511631f, 
    0.08389330f, 0.06209036f, -0.10368884f, 0.10472428f, -0.07397518f, -0.04327018f, -0.02928933f, 0.00004521f, 
    -0.14806350f, 0.00207764f, 0.00431055f, -0.00169637f, -0.23711053f, 0.05658528f, 0.01149843f, 0.08840635f, 
    -0.07246291f, 0.10802282f, 0.02268687f, 0.02215635f, -0.12673399f, 0.00180592f, 0.08950169f, -0.18764660f, 
    0.19028290f, 0.06286675f, -0.05764827f, -0.13800843f, -0.00219280f, -0.06032996f, 0.01474976f, -0.09915644f, 
    -0.07779316f, -0.15807229f, 0.02584543f, -0.04974303f, -0.11941414f, -0.00064484f, 0.00930504f, 0.07701320f, 
    0.05793127f, 0.03078679f, 0.03767864f, 0.00325349f, -0.05504115f, -0.00190908f, 0.10813231f, -0.11703629f, 
    -0.57517618f, -0.19168474f, -0.17341006f, -0.04295247f, 0.13369030f, 0.15772100f, -0.06159068f, -0.05249741f, 
    0.01869129f, 0.05794766f, 0.04125031f, 0.12816358f, -0.00656991f, -0.01403639f, -0.14138949f, 0.05575187f, 
    0.12383538f, 0.03667392f, 0.02070314f, 0.10277093f, 0.03824482f, 0.01373065f, -0.01081301f, 0.13084304f, 
    0.12646082f, 0.00988196f, 0.12807594f, -0.03479082f, 0.12100882f, 0.03153669f, -0.06874325f, -0.02137481f, 
    0.02959972f, -0.06439143f, 0.19114189f, -0.03535073f, -0.07255848f, -0.04548808f, 0.05163708f, 0.01552540f, 
    -0.06476901f, 0.01671137f, 0.04968835f, -0.09980955f, 0.08648316f, -0.15915428f, 0.06609506f, 0.05368958f, 
    0.07575316f, -0.07872350f, 0.08042438f, 0.14319405f, -0.02547786f, -0.17217624f, 0.08846918f, 0.00202013f, 
    -0.06751491f, -0.05278564f, -0.02374121f, 0.14856634f, -0.57141256f, 0.06026452f, -0.01803342f, -0.17245492f, 
    0.14965720f, -0.00107807f, 0.17775351f, 0.00230912f, 0.02428104f, 0.03662771f, -0.08336440f, -0.01621208f, 
    -0.45330802f, -0.04684654f, -0.11870952f, -0.06308932f, 0.07753342f, 0.06047369f, -0.05834562f, 0.05759098f, 
    -0.01013109f, -0.03753673f, 0.16660282f, -0.17284565f, -0.25235233f, 0.20733279f, 0.24139418f, -0.27430877f, 
    -0.11414307f, -0.05427370f, 0.15071161f, -0.03856427f, 0.06000099f, -0.12885225f, -0.15154138f, -0.20476452f, 
    0.17282660f, -0.12084870f, -0.00899052f, -0.05698967f, 0.02791544f, 0.00370599f, 0.01704276f, -0.05413156f, 
    -0.07391556f, 0.02505866f, 0.01373896f, -0.04990013f, 0.06190129f, -0.01857650f, -0.04456749f, -0.12931266f, 
    0.19996162f, -0.07662578f, 0.01926469f, 0.06780970f, 0.07343075f, -0.03845051f, 0.12460370f, 0.01973981f, 
    -0.21496937f, -0.06651780f, 0.12647372f, 0.15303297f, 0.03818279f, -0.08048332f, -0.14294806f, -0.14648166f, 
    -0.03984442f, 0.05143566f, 0.21361636f, 0.09202819f, 0.00412796f, 0.08412374f, -0.06654466f, -0.02616885f, 
    -0.06614745f, -0.07293032f, 0.02076932f, 0.07206874f, 0.05918286f, -0.00900342f, 0.03037960f, -0.02949921f, 
    0.29043600f, -0.01902413f, 0.03354787f, -0.12142731f, -0.05254930f, -0.05676933f, -0.12341448f, 0.08827288f, 
    -0.19209345f, -0.09020408f, -0.06227195f, -0.19507249f, -0.14355482f, 0.07949380f, 0.02697383f, -0.04385869f, 
    0.02068334f, -0.04515636f, 0.03760204f, -0.00753722f, 0.10268774f, 0.02236304f, -0.08755524f, 0.02494431f, 
    -0.21032396f, -0.21806508f, -0.08739547f, 0.06627695f, 0.10439181f, -0.00813028f, -0.10007284f, -0.07528190f, 
    0.04980787f, -0.05423110f, -0.08685482f, 0.06723672f, -0.08852724f, -0.08479068f, -0.16256411f, -0.06210637f, 
    0.08602307f, 0.07632493f, -0.07711420f, -0.03037581f, 0.03825591f, -0.04454907f, 0.01235664f, 0.02796807f, 
    -0.42400262f, -0.05538520f, 0.07278498f, 0.11206342f, -0.14990559f, -0.06191711f, 0.07733195f, 0.04853734f, 
    0.01639166f, 0.03983900f, -0.00112262f, -0.02056568f, 0.02295219f, -0.03794255f, 0.17784189f, -0.07810612f, 
    0.03951053f, -0.01143628f, -0.09005526f, 0.15390120f, 0.02836772f, -0.03398402f, -0.09131642f, -0.00191212f, 
    0.36841181f, -0.07152757f, -0.11515113f, 0.01571752f, 0.04888142f, 0.02522010f, -0.09765872f, -0.09292743f, 
    -0.07061504f, -0.08914778f, -0.13087995f, -0.08188652f, -0.08212631f, 0.00317615f, -0.18998644f, -0.07195506f, 
    0.00174258f, 0.16110358f, -0.07223867f, -0.24530269f, 0.01424297f, -0.05770081f, 0.04935042f, -0.06411283f, 
    -0.16678326f, 0.04444082f, 0.23194417f, 0.26214656f, 0.08009262f, -0.04711145f, 0.07040355f, -0.05449846f, 
    0.07399350f, 0.04421715f, -0.16572332f, 0.02061076f, 0.06996807f, 0.08562750f, 0.14140360f, -0.15948686f, 
    0.06346294f, 0.04809611f, -0.01740770f, -0.00541554f, 0.07592904f, 0.09960593f, 0.15382813f, 0.12874657f, 
    -0.29292461f, -0.10183448f, 0.23229840f, 0.27286518f, 0.05603401f, 0.00767687f, 0.03733186f, -0.10708658f, 
    -0.03329799f, -0.16254434f, -0.12647270f, 0.09769607f, 0.08111689f, -0.01891165f, -0.07910485f, 0.07773395f, 
    0.10101454f, -0.10421377f, 0.00456298f, -0.02381383f, 0.08544137f, 0.14611170f, -0.23511139f, 0.08609987f, 
    -0.08321527f, -0.16246393f, -0.00834826f, 0.04112352f, 0.05773799f, 0.07749851f, -0.01561934f, -0.06469147f, 
    -0.05440661f, 0.04444913f, -0.08168948f, 0.09932037f, -0.15418306f, -0.02669482f, 0.12790167f, 0.28038710f, 
    -0.06426833f, 0.04943302f, 0.13891074f, -0.00539250f, -0.06839189f, -0.16803297f, -0.06571739f, 0.02958860f, 
    0.15459551f, -0.15327425f, 0.00679075f, 0.15072784f, 0.00754028f, -0.13070531f, -0.05626865f, 0.06417337f, 
    -0.06220101f, 0.06027766f, 0.03932085f, -0.12007409f, -0.39459547f, -0.04489565f, 0.01811979f, -0.05975480f, 
    0.06531422f, 0.10321615f, 0.00679790f, 0.06899230f, 0.10926522f, 0.00424726f, -0.00560475f, 0.03164943f, 
    -0.08530544f, -0.02073562f, 0.09936140f, -0.11846135f, -0.07656897f, 0.08367942f, -0.03072330f, -0.06446935f, 
    0.15096480f, 0.00519515f, -0.04503909f, 0.07840110f, -0.18806216f, 0.18980797f, -0.22770110f, -0.13109593f, 
    0.04440132f, 0.07125080f, 0.08610434f, 0.02239640f, -0.05185167f, 0.00605163f, -0.18150908f, -0.04168899f, 
    -0.00433738f, -0.01991956f, 0.04256773f, 0.14510241f, -0.13498698f, 0.06433268f, -0.01119751f, 0.07647425f, 
    0.05791282f, 0.15369631f, 0.05756873f, -0.02155551f, 0.00441873f, -0.26363862f, -0.22159742f, -0.07837426f, 
    -0.03908754f, -0.07738446f, -0.00564020f, 0.04224762f, 0.12518263f, -0.02483063f, -0.08110438f, -0.01032913f, 
    -0.19020957f, -0.02282001f, 0.05007640f, -0.32551190f, 0.02404986f, -0.07424226f, -0.04046353f, -0.12636180f, 
    0.05315556f, 0.03960999f, -0.06105830f, 0.07643846f, -0.23404267f, -0.12213594f, -0.02490281f, -0.00228038f, 
    -0.07790423f, -0.07771958f, -0.12857080f, 0.04925169f, 0.17314476f, 0.03100878f, 0.07936578f, -0.13227840f, 
    0.04924258f, -0.02290678f, 0.11128605f, 0.20031902f, 0.01304683f, 0.05842468f, -0.04216972f, -0.02830254f, 
    -0.24549282f, -0.05896259f, 0.13602433f, -0.07779353f, -0.13908094f, -0.01012938f, -0.14929163f, -0.18197675f, 
    0.11276101f, 0.07196918f, -0.00050240f, 0.07022309f, -0.04040387f, 0.23331431f, 0.11205328f, 0.00240752f, 
    0.07631701f, -0.06941809f, 0.11268174f, 0.04427909f, -0.02130691f, 0.04546588f, 0.08362223f, 0.05219364f, 
    -0.07861535f, 0.02654825f, 0.11504217f, 0.01187667f, -0.30240947f, -0.08878575f, 0.06764032f, 0.05742633f, 
    -0.01864879f, -0.09125008f, -0.04563037f, 0.06044269f, 0.07305776f, -0.03400764f, -0.11764773f, 0.06036392f, 
    -0.11314357f, -0.14513274f, 0.03266609f, 0.13421685f, 0.04086009f, 0.02923315f, -0.09734009f, -0.08022799f, 
    0.09430457f, 0.08843064f, 0.19210771f, 0.08263923f, 0.14032403f, 0.09862067f, -0.00251482f, -0.06592957f, 
    0.03303140f, -0.03707886f, 0.02596276f, 0.01848816f, 0.09890182f, -0.01402142f, 0.05466012f, 0.10112033f, 
    0.17453657f, 0.10667171f, 0.11938670f, -0.25070894f, 0.01093981f, -0.12078915f, -0.26824623f, -0.03511601f, 
    -0.20522711f, 0.06163624f, -0.00279568f, -0.07369315f, 0.04901506f, -0.04161887f, 0.13454434f, 0.25986758f, 
    -0.16388136f, -0.09575349f, 0.03956889f, 0.10705905f, -0.03330890f, -0.01568643f, -0.14966470f, 0.08680951f, 
    -0.10856134f, 0.21743229f, -0.03287687f, 0.13128188f, -0.08563033f, -0.06760149f, 0.05582092f, -0.12052760f, 
    -0.01468268f, -0.14544959f, -0.05085435f, -0.03647023f, -0.38525671f, -0.06581724f, -0.10456044f, -0.07135252f, 
    0.10376015f, -0.03978880f, -0.03823582f, -0.08118904f, -0.08873537f, 0.06549514f, -0.02491237f, -0.00455017f, 
    0.04710470f, -0.04834665f, 0.03969954f, -0.02556090f, -0.02975142f, 0.18820016f, 0.06148840f, -0.10702413f, 
    0.06935849f, -0.05859609f, -0.26597914f, 0.00849486f, 0.19966328f, 0.03251640f, 0.03881220f, 0.07247204f, 
    0.04313161f, -0.03808761f, 0.08606035f, 0.06138160f, -0.00606967f, -0.07262885f, 0.15554859f, 0.21073325f, 
    0.13702875f, 0.12261645f, 0.18296883f, 0.03893353f, 0.15841126f, 0.01829449f, -0.10401990f, -0.06881382f, 
    -0.08410149f, 0.05229811f, -0.02510218f, -0.00719464f, -0.04341664f, -0.06856840f, -0.08506804f, -0.30749282f, 
    0.01217906f, -0.11963116f, 0.04039423f, 0.03534965f, 0.04758456f, 0.04037083f, 0.04814137f, 0.13507704f, 
    -0.11782122f, 0.07674766f, -0.00103881f, 0.08031406f, -0.10275370f, 0.00283845f, 0.03932396f, 0.02526422f, 
    -0.14993598f, -0.04280749f, -0.03153545f, 0.11466800f, 0.25788781f, 0.06431248f, -0.05672816f, -0.11321657f, 
    0.13121940f, -0.03424574f, -0.15529001f, -0.07085505f, -0.04183011f, 0.14176178f, -0.01085050f, -0.12147886f, 
    0.09573124f, -0.02007011f, 0.08666121f, 0.03723788f, -0.02890793f, 0.00391517f, 0.08120710f, -0.00342220f, 
    -0.10586055f, -0.12303223f, 0.08591309f, -0.01841992f, -0.12144523f, -0.01542039f, 0.22442746f, 0.01050095f, 
    -0.06461622f, 0.09149779f, -0.06659716f, -0.01901248f, 0.00855255f, 0.02786781f, -0.02743736f, 0.06184649f, 
    -0.14172445f, 0.04660244f, 0.10833789f, 0.08633794f, 0.03248324f, 0.01481933f, -0.12172975f, -0.05818471f, 
    0.08124089f, -0.12728916f, 0.03943113f, 0.08824547f, 0.08508974f, 0.02731838f, 0.13112885f, -0.06694065f, 
    -0.03432776f, 0.00211206f, -0.01754477f, -0.05968842f, 0.09298078f, -0.09315000f, -0.00864588f, 0.00189486f, 
    0.22274400f, -0.09958598f, -0.15681851f, 0.08399707f, 0.01823887f, -0.06118555f, -0.07032837f, 0.06265747f, 
    0.06587978f, 0.02679207f, -0.05013867f, 0.05446381f, -0.05414656f, 0.19471195f, -0.20769894f, 0.10223351f, 
    0.13239379f, 0.07641073f, -0.00660803f, -0.02385742f, 0.04024754f, -0.05961755f, 0.03515228f, 0.06166784f, 
    -0.09404257f, -0.06835567f, -0.05941492f, 0.00432419f, -0.07248072f, 0.04069079f, 0.21522301f, 0.14042908f, 
    -0.13819315f, 0.12903374f, 0.04540697f, 0.01187544f, -0.26858783f, 0.20654379f, 0.11129566f, -0.07781892f, 
    -0.00251891f, 0.00031143f, -0.05599484f, -0.11144231f, -0.02940467f, 0.04951133f, -0.05720076f, 0.00426728f, 
    0.06413613f, 0.07691392f, -0.03443499f, -0.02361969f, -0.07334594f, 0.09793482f, 0.02921228f, -0.01663885f, 
    -0.13287023f, -0.03049512f, 0.20662147f, 0.07314673f, 0.05677078f, 0.10469986f, 0.06556143f, -0.22960244f, 
    -0.05085982f, 0.03717486f, 0.00383333f, -0.14649983f, -0.02859176f, -0.10085945f, 0.05325986f, -0.13116744f, 
    0.00705078f, -0.13002847f, 0.07775825f, 0.09873914f, 0.03712892f, -0.07969590f, 0.02881922f, 0.03352470f, 
    0.13626145f, -0.01858712f, 0.09484638f, -0.08141746f, 0.08276226f, -0.09973586f, 0.03462946f, -0.02327549f, 
    0.03318397f, -0.03844892f, -0.10866127f, 0.14823106f, 0.09519063f, -0.00828852f, 0.13004994f, -0.16620542f, 
    -0.06634447f, 0.06147085f, 0.14472261f, 0.18418638f, 0.09193219f, 0.05446738f, 0.04882982f, -0.04817689f, 
    0.06138501f, 0.10321724f, -0.05149593f, 0.14534871f, 0.12516144f, -0.16592368f, -0.16806033f, -0.08475661f, 
    -0.16959238f, 0.08757892f, -0.05695571f, 0.00993202f, -0.01122973f, 0.04381876f, -0.02159934f, 0.24098374f, 
    -0.39530957f, 0.05747319f, -0.12244306f, -0.14652659f, -0.06210350f, -0.05899282f, 0.04510964f, 0.08811789f, 
    -0.01122749f, -0.08360167f, -0.07902246f, 0.05975672f, -0.14067176f, 0.02830833f, -0.05965642f, -0.02526368f, 
    -0.02492989f, 0.00176699f, -0.06722409f, -0.11069578f, 0.04837021f, 0.03472163f, -0.03929802f, -0.07247469f, 
    -0.30930758f, 0.29206398f, 0.07022300f, -0.01916259f, -0.01884699f, -0.05649757f, 0.00631588f, 0.02423490f, 
    -0.03859247f, 0.05881839f, -0.13011721f, -0.04057724f, -0.07959966f, 0.14698519f, 0.08867772f, 0.18518224f, 
    0.07034462f, -0.02842224f, -0.01283370f, -0.06930845f, -0.02076858f, 0.09218126f, 0.02711874f, -0.00463220f, 
    0.05336642f, 0.17598052f, -0.01765407f, -0.25908047f, 0.03798147f, 0.11490154f, -0.00387902f, 0.04471126f, 
    -0.04996985f, -0.03127685f, 0.01039183f, -0.01949932f, 0.37688339f, -0.28775719f, 0.14301887f, -0.08733703f, 
    0.10206242f, -0.08733848f, 0.01760990f, -0.16827770f, 0.01216664f, -0.01243036f, 0.05119232f, -0.07205730f, 
    0.30175942f, 0.09760252f, 0.09198273f, -0.07358737f, -0.17812338f, 0.08112930f, -0.14589666f, -0.06252527f, 
    -0.03085552f, 0.07291685f, 0.05961338f, 0.06168686f, -0.02103998f, -0.38910389f, -0.02974434f, 0.10778630f, 
    -0.05628929f, 0.01175997f, -0.02769439f, 0.02466742f, -0.00907726f, -0.02259019f, 0.06889281f, 0.16143736f, 
    -0.15950660f, 0.20227742f, -0.04156502f, 0.26181006f, 0.06559031f, 0.13670816f, 0.10334642f, 0.01413898f, 
    0.01937363f, 0.03521163f, -0.01409182f, -0.09132216f, 0.17162517f, 0.05374589f, 0.07701559f, -0.10789846f, 
    -0.13660234f, 0.16113868f, 0.16766202f, -0.01450362f, -0.04478831f, 0.05948594f, -0.06017501f, -0.17247434f, 
    0.23906124f, -0.27887622f, -0.13872647f, 0.28734699f, -0.10914643f, 0.01869618f, -0.07677108f, -0.02259251f, 
    0.08340577f, -0.19881974f, -0.04534412f, 0.08970759f, -0.25432473f, 0.08685265f, -0.22851703f, 0.30494168f, 
    0.07101446f, 0.12696080f, -0.10133770f, 0.04957678f, -0.07475832f, 0.00272521f, -0.15647100f, -0.06112541f, 
    -0.01501497f, 0.03528330f, 0.08739509f, -0.11203861f, -0.03525565f, -0.03569497f, -0.03813967f, -0.04085096f, 
    -0.00930961f, 0.06985204f, 0.02807222f, 0.15448947f, 0.11908322f, -0.05064370f, 0.09590043f, -0.29467133f, 
    0.07945952f, -0.00332331f, -0.00243466f, 0.07175258f, -0.04560429f, 0.01658060f, 0.07809913f, -0.03492306f, 
    0.24121368f, -0.12485126f, -0.09261619f, 0.12800500f, -0.10770310f, -0.05306512f, 0.00215105f, 0.01758305f, 
    -0.13600086f, -0.00046974f, 0.12393353f, 0.03675902f, -0.10259756f, -0.11271780f, -0.11893945f, -0.13188152f, 
    -0.13409299f, -0.02239501f, 0.03240117f, -0.16949649f, 0.04623606f, 0.01751932f, -0.00384540f, 0.02452409f, 
    0.05228376f, 0.03666061f, -0.21936491f, 0.24388717f, -0.03853187f, 0.02901791f, -0.00326262f, -0.14476897f, 
    -0.20881321f, 0.00602106f, 0.02942754f, -0.02932648f, -0.02700323f, -0.04388995f, 0.12409411f, 0.07257205f, 
    0.01674796f, -0.08181763f, 0.13081990f, 0.01420656f, -0.03609497f, 0.06101165f, 0.06524029f, 0.12694998f, 
    -0.26923850f, -0.05203982f, -0.26467866f, 0.22082934f, -0.06031459f, 0.05293653f, 0.11411566f, -0.03519933f, 
    0.09068788f, 0.01770089f, 0.05183583f, 0.08105925f, -0.16291255f, -0.21845835f, -0.01905619f, -0.18544032f, 
    -0.05661838f, 0.01533845f, -0.02434455f, -0.01654403f, -0.03770364f, 0.16297787f, -0.02735406f, 0.18857600f, 
    0.20878918f, -0.32578465f, -0.13657230f, -0.03171567f, -0.02624041f, 0.11367007f, -0.05204563f, 0.00564070f, 
    0.00164984f, 0.08599380f, 0.01565058f, -0.12961000f, -0.22006615f, 0.14162074f, 0.16080801f, -0.30406225f, 
    -0.01960635f, 0.02322997f, 0.00995382f, 0.06003549f, -0.11366747f, -0.05969288f, 0.00401724f, -0.25320634f, 
    0.08883137f, -0.00493679f, -0.07048281f, 0.09833653f, -0.02748758f, -0.08391762f, 0.06445900f, -0.05136980f, 
    0.03671566f, 0.02100507f, 0.01973001f, -0.04136999f, -0.22963199f, -0.02610498f, 0.03825601f, 0.10259549f, 
    0.04399527f, 0.00839210f, -0.04122990f, -0.01668936f, 0.04695451f, -0.20596799f, 0.19713664f, -0.20572045f, 
    -0.20227151f, 0.17462572f, -0.15977865f, -0.27820370f, 0.02469791f, -0.03206294f, 0.05236456f, 0.01424353f, 
    0.00003093f, -0.04013291f, 0.04129085f, 0.02533993f, 0.07446535f, 0.01856003f, 0.01878599f, -0.20500685f, 
    -0.10146943f, -0.08947720f, -0.04226793f, 0.05561492f, 0.01730686f, 0.03133261f, 0.21104419f, -0.05601577f, 
    -0.22272582f, -0.12582776f, 0.10472813f, -0.08535603f, 0.05213863f, 0.08067818f, 0.08993958f, -0.00242983f, 
    -0.08168279f, -0.07221121f, -0.06857074f, 0.00574228f, 0.01360138f, -0.02130380f, -0.01221979f, -0.10639027f, 
    -0.02537836f, -0.07370394f, 0.03842739f, -0.11836387f, 0.09255139f, -0.03149313f, 0.06482326f, -0.05681708f, 
    0.04882866f, 0.12516534f, 0.24611147f, 0.06935561f, 0.01958272f, 0.06972140f, -0.06910041f, 0.09886073f, 
    -0.18757994f, 0.00222465f, 0.10622639f, 0.12234678f, 0.13901970f, -0.22666796f, -0.06172629f, -0.19085295f, 
    0.02355580f, 0.05089343f, -0.01368359f, -0.14342064f, -0.01359160f, 0.00516270f, 0.04788646f, 0.03999877f, 
    -0.03958731f, 0.02324618f, -0.02308872f, 0.04484634f, 0.17324726f, 0.03826842f, -0.01586004f, 0.09685777f, 
    -0.01851028f, -0.05060296f, -0.08002257f, 0.03757184f, -0.05326778f, 0.00620997f, -0.06881909f, -0.02276614f, 
    0.01994535f, 0.06163811f, -0.02880513f, -0.11658174f, -0.18137453f, 0.00914860f, 0.13053387f, 0.01542882f, 
    -0.13572493f, 0.22464119f, 0.02634354f, -0.06451512f, -0.10944973f, 0.13755278f, -0.04452522f, 0.09980413f, 
    -0.00594601f, -0.02225139f, 0.08847774f, -0.08155831f, 0.08574598f, -0.11622497f, -0.15836303f, 0.03640182f, 
    0.04455040f, -0.01216810f, 0.10355037f, -0.03514911f, 0.00512737f, -0.06813855f, -0.02645072f, 0.08445561f, 
    -0.02478703f, 0.09026948f, -0.16746189f, -0.03943174f, 0.06510688f, -0.07677125f, 0.05415021f, -0.05428582f, 
    0.09756649f, 0.05880637f, 0.00871527f, 0.03848994f, -0.13457771f, -0.21730776f, 0.06992132f, 0.16386521f, 
    -0.02114164f, 0.09668359f, 0.03246202f, -0.05609551f, 0.01120917f, -0.21178643f, -0.11322939f, 0.02368387f, 
    -0.14006688f, 0.06697851f, -0.01049657f, -0.06579396f, 0.14817648f, -0.02793838f, -0.22127010f, 0.11115514f, 
    -0.06906147f, 0.08506405f, -0.11478138f, -0.02571389f, -0.37364408f, 0.12099349f, 0.01603598f, 0.10341518f, 
    0.06975676f, -0.02070043f, 0.09293185f, -0.03629282f, 0.08760010f, -0.05816277f, 0.03302215f, -0.08019773f, 
    0.04243483f, -0.27711302f, -0.11703702f, 0.06083754f, 0.05529953f, 0.05609445f, 0.05271033f, -0.08423790f, 
    -0.14656870f, -0.01007089f, -0.11389857f, -0.17012522f, 0.15735412f, -0.06405414f, 0.01254422f, -0.11860805f, 
    -0.01066282f, 0.00913591f, 0.15251790f, 0.04839024f, -0.02721123f, 0.10656182f, -0.03938629f, -0.11223761f, 
    -0.24096993f, -0.02024985f, 0.01579764f, 0.04217539f, -0.13619250f, 0.05341471f, 0.09507980f, 0.08197428f, 
    0.07553708f, -0.10896341f, 0.01295751f, 0.06182737f, -0.04631256f, 0.04233963f, -0.13930865f, -0.14808920f, 
    0.19232337f, 0.07134146f, -0.03172929f, 0.06519898f, -0.11032508f, 0.06225810f, 0.08347616f, -0.01590267f, 
    -0.09239218f, -0.02035498f, 0.13418220f, 0.27319768f, 0.17106153f, 0.08774727f, -0.13686752f, 0.15163232f, 
    0.08938317f, 0.12182180f, 0.02461624f, 0.08584671f, -0.21942134f, -0.19701174f, -0.07990933f, -0.15408202f, 
    -0.00786365f, 0.06510424f, 0.06845811f, 0.05367967f, -0.06911639f, 0.06881654f, -0.02492195f, 0.00136799f, 
    -0.31426525f, 0.02603506f, 0.03665668f, 0.14644356f, 0.14836438f, -0.07396699f, -0.08291365f, -0.11478594f, 
    0.02198816f, 0.00622978f, 0.07578370f, -0.10195943f, 0.23460704f, 0.00911092f, 0.08582852f, -0.11533137f, 
    -0.01359923f, -0.02430184f, 0.05090253f, 0.05910413f, 0.03290444f, -0.06545607f, -0.09519753f, -0.06001768f, 
    -0.21898505f, 0.15959902f, 0.05245354f, 0.03354375f, -0.20385075f, -0.10139223f, 0.15368107f, 0.09107684f, 
    0.10648123f, 0.08036942f, 0.01079608f, 0.01020760f, 0.34740451f, 0.18090071f, 0.00228685f, -0.30899030f, 
    -0.10010846f, 0.12152994f, 0.04501470f, -0.06882244f, -0.10809721f, -0.03873533f, -0.20539188f, -0.04056536f, 
    -0.07926251f, -0.01237528f, 0.05372855f, -0.14142703f, 0.13164720f, -0.04527145f, -0.07510125f, -0.04834736f, 
    -0.02773274f, -0.02244342f, 0.07953025f, 0.02279756f, -0.11002246f, -0.08917310f, -0.14518315f, 0.14474729f, 
    -0.21079352f, 0.06559253f, 0.05866563f, -0.00283606f, 0.07256610f, -0.06996888f, -0.00333178f, 0.12754199f, 
    -0.07150716f, 0.32121697f, 0.05117207f, -0.28059354f, 0.11135014f, 0.05763168f, 0.03735195f, -0.01898646f, 
    -0.07558790f, 0.13826247f, 0.03015189f, 0.06963921f, -0.09303857f, 0.14489508f, 0.10282707f, -0.17198454f, 
    -0.10203038f, -0.01013927f, 0.04113374f, 0.01953117f, 0.12149790f, -0.11437560f, 0.10484915f, 0.01968248f, 
    0.02783651f, -0.11192703f, -0.03261703f, 0.07144951f, -0.01345732f, 0.09435093f, 0.04012047f, -0.01619042f, 
    -0.09368557f, -0.14265822f, -0.03956590f, -0.11147717f, -0.04673047f, 0.07734489f, 0.09341515f, -0.21540244f, 
    0.06514845f, 0.00712749f, 0.07664277f, 0.07847541f, 0.10345849f, 0.09511511f, 0.03064042f, 0.01558985f, 
    -0.51090801f, 0.15269962f, -0.00510187f, 0.09199778f, 0.00794473f, 0.02689625f, 0.13852224f, -0.01138306f, 
    -0.01989261f, 0.05055361f, 0.18253115f, -0.06339876f, -0.24320112f, -0.04145972f, -0.07504889f, -0.03434402f, 
    -0.01950507f, -0.12554441f, 0.05184092f, -0.20841837f, 0.00056200f, 0.11799514f, 0.11959828f, 0.04856273f, 
    0.16497135f, -0.01795199f, 0.01474342f, -0.02460241f, 0.00054374f, 0.01460936f, -0.00513440f, -0.29191375f, 
    0.06968807f, -0.12877022f, -0.02113261f, -0.02555474f, 0.13241018f, -0.16504107f, 0.14412795f, -0.28742588f, 
    -0.00419305f, 0.02327923f, -0.00397652f, 0.04668942f, -0.04017801f, 0.03220298f, -0.09328650f, -0.00129545f, 
    -0.22135541f, 0.24345531f, 0.08848647f, 0.07883003f, -0.02079086f, -0.04131461f, -0.02607470f, 0.08566827f, 
    0.05520880f, 0.05302093f, -0.13295110f, -0.04544501f, -0.19108289f, -0.13063551f, 0.04679298f, 0.05329249f, 
    0.04631253f, 0.00821916f, -0.05446758f, 0.07346903f, -0.00786912f, -0.07848445f, 0.02560811f, 0.18895131f, 
    0.15881635f, -0.18918888f, -0.18660206f, -0.06489687f, 0.03150532f, 0.04562850f, 0.00555037f, -0.11219712f, 
    0.01821273f, -0.00245091f, -0.00751496f, -0.01534331f, -0.08168473f, 0.08195246f, 0.16536273f, -0.10986408f, 
    -0.10347462f, 0.02240877f, 0.12884092f, -0.24912147f, -0.11146515f, -0.05028519f, 0.01182381f, -0.10065691f, 
    -0.07970297f, 0.09636717f, 0.02770176f, -0.17337127f, 0.02482574f, -0.02270673f, -0.03982222f, 0.04226802f, 
    0.06110798f, 0.10919382f, -0.01350747f, -0.01331958f, -0.10065463f, 0.04688964f, 0.02374180f, 0.03935190f, 
    -0.02820489f, -0.00035977f, -0.04885788f, -0.02491437f, 0.10144609f, 0.12058248f, -0.05588793f, -0.03026139f, 
    0.13477278f, 0.02942904f, 0.20641400f, 0.07793818f, 0.05767603f, 0.02555286f, 0.00062433f, -0.05579915f, 
    -0.02131965f, -0.00537094f, -0.05570568f, -0.07840957f, 0.09027088f, 0.09295852f, -0.04427679f, 0.15675554f, 
    0.00061323f, -0.03566256f, -0.02281304f, -0.10502718f, -0.05322993f, -0.08266512f, -0.05115369f, -0.06636433f, 
    -0.10815078f, 0.04709826f, -0.10632360f, -0.10210251f, 0.03700446f, 0.01341470f, 0.02940816f, -0.01588381f, 
    -0.11905801f, -0.01432569f, 0.03708379f, -0.03674713f, -0.09178084f, -0.06555768f, -0.18454525f, -0.12749070f, 
    -0.06617794f, -0.04609522f, -0.06144901f, -0.01617920f, -0.06886057f, -0.00300993f, -0.09342504f, -0.09549122f, 
    -0.12348699f, -0.15321063f, -0.09916484f, -0.04742955f, 0.03518366f, -0.03632854f, -0.02826806f, -0.05310580f, 
    -0.05383917f, -0.00675097f, 0.00233576f, -0.00252249f, 0.13671868f, -0.15336667f, 0.20101643f, -0.00605539f, 
    -0.00095239f, 0.02596556f, -0.09631110f, 0.03030657f, 0.01356619f, 0.00331043f, 0.03487775f, -0.03233024f, 
    -0.04630082f, 0.08320826f, 0.04442632f, 0.12491395f, 0.06724087f, 0.04928747f, 0.03846645f, -0.01677556f, 
    -0.10776836f, 0.00552579f, 0.02072192f, -0.02027499f, -0.15733416f, -0.09760385f, 0.02564995f, -0.14577809f, 
    0.01043789f, -0.02187533f, -0.00660284f, -0.01181700f, 0.01277808f, -0.02430641f, 0.04158483f, 0.01868230f, 
    -0.04249630f, 0.03258443f, -0.30310169f, -0.03726535f, 0.00447705f, -0.00605544f, 0.00507653f, 0.05240934f, 
    -0.03239921f, -0.00400775f, 0.02215267f, -0.00759484f, -0.03366150f, -0.01277654f, -0.06032651f, -0.14350682f, 
    -0.05314022f, 0.05193774f, -0.04116632f, -0.06508853f, -0.00952549f, -0.05146288f, 0.06245078f, -0.10670569f, 
    0.18375392f, 0.18453372f, -0.01626323f, 0.27852076f, 0.04886492f, -0.07170575f, -0.07851234f, -0.03613516f, 
    0.01088087f, -0.02475111f, -0.06320141f, -0.10898398f, -0.18750614f, -0.03367848f, -0.11076967f, -0.01721649f, 
    -0.00347617f, -0.04141163f, -0.03498251f, -0.06534906f, -0.03685974f, -0.09880919f, -0.02933047f, -0.07567634f, 
    -0.06025158f, 0.09166854f, -0.12998076f, -0.21197145f, -0.11870342f, -0.03217472f, -0.02651712f, -0.09927705f, 
    -0.02856703f, -0.06014331f, -0.06417202f, -0.09339758f, -0.19741929f, 0.14646199f, -0.09634047f, -0.09942753f, 
    -0.09561155f, 0.02666347f, -0.03975814f, -0.11558107f, -0.07320676f, 0.02023303f, -0.01242083f, -0.11613207f, 
    0.12377139f, 0.16127466f, 0.03827302f, 0.15118548f, 0.19400924f, 0.04596946f, 0.02903779f, -0.01857577f, 
    0.00319404f, -0.06700648f, -0.00888027f, -0.01023528f, 0.10071206f, 0.11549035f, 0.14242227f, 0.17328872f, 
    0.07204650f, 0.06141556f, 0.05353600f, -0.08399812f, 0.02685805f, 0.08324439f, -0.02682885f, -0.05139155f, 
    0.26392847f, 0.13694827f, 0.05680876f, 0.22782107f, 0.12112905f, 0.08274710f, 0.09993996f, -0.03516478f, 
    -0.00118766f, -0.03084110f, -0.02412220f, -0.02666841f, -0.17688634f, -0.05823030f, -0.05490742f, -0.12792458f, 
    -0.02694435f, 0.02476673f, 0.05336417f, -0.04545995f, -0.03948396f, -0.10596652f, -0.01944261f, -0.03983327f, 
    -0.05747985f, 0.14555106f, 0.01996618f, 0.07731114f, 0.07533208f, -0.01797288f, -0.04926681f, -0.07677458f, 
    0.04954589f, -0.01371326f, -0.01203480f, -0.09260616f, 0.05919890f, 0.11698943f, 0.01348078f, 0.07641860f, 
    0.04827556f, 0.01463111f, 0.13924091f, 0.07587085f, -0.01526613f, 0.01197780f, -0.02548002f, -0.10631578f, 
    0.00493774f, -0.06584837f, 0.17734312f, -0.05684933f, 0.02891115f, 0.01034326f, -0.03104102f, -0.06093408f, 
    -0.08353944f, 0.05375539f, 0.06244498f, 0.03174166f, -0.17078421f, 0.13351770f, -0.07172296f, -0.03685107f, 
    0.00465246f, 0.04930986f, 0.01458873f, -0.04026568f, -0.07999134f, -0.03872631f, 0.03213910f, -0.02398228f, 
    -0.07152132f, 0.16817096f, -0.04499906f, 0.13163899f, 0.03772637f, -0.07244380f, 0.00931450f, 0.02764673f, 
    -0.07239855f, 0.01191430f, 0.03005486f, 0.02389552f, -0.09745222f, 0.16898775f, -0.05916607f, 0.00589430f, 
    -0.09243599f, 0.01242805f, -0.06502506f, -0.03984004f, -0.02474027f, -0.02412561f, -0.00297477f, -0.13435601f, 
    0.03375212f, 0.04033634f, 0.13102596f, 0.09005072f, 0.09778565f, 0.02433043f, -0.03217720f, -0.04360840f, 
    -0.03827338f, 0.00886848f, -0.05222952f, -0.07834451f, -0.23743829f, 0.04597108f, -0.02484320f, -0.10843126f, 
    -0.04530898f, 0.02724479f, -0.00023268f, -0.05234584f, -0.06596405f, -0.02913205f, 0.02510008f, -0.01573947f, 
    0.20041844f, 0.13734944f, -0.01378213f, -0.05728551f, -0.00598679f, -0.03175727f, -0.00424422f, -0.02403082f, 
    -0.03542531f, -0.07640772f, 0.04196517f, -0.13469605f, 0.15830480f, -0.07501180f, 0.06426770f, 0.02596902f, 
    -0.11785326f, 0.08747464f, -0.03157783f, 0.00869711f, 0.02265611f, -0.08459173f, -0.00346465f, 0.00983118f, 
    0.06944597f, -0.17316705f, -0.11552525f, -0.01107158f, -0.11726089f, 0.01078000f, -0.04931850f, -0.03677027f, 
    -0.07313997f, -0.05193820f, -0.00387042f, -0.02691941f, 0.15134548f, 0.21798271f, 0.16887203f, 0.11828846f, 
    0.10786784f, 0.06694933f, 0.06314540f, 0.03399596f, -0.01052750f, 0.10976261f, 0.01741494f, -0.05602940f, 
    -0.16159327f, -0.12228860f, -0.01496263f, 0.00328647f, -0.01792104f, 0.01711002f, -0.00631847f, -0.07118015f, 
    -0.01274551f, 0.02609845f, 0.10525832f, 0.01926796f, -0.02450962f, 0.20770201f, 0.10043107f, 0.09637734f, 
    0.01248674f, 0.04413379f, 0.04254074f, -0.01290071f, 0.01467379f, -0.05267527f, -0.04517207f, 0.00132884f, 
    -0.25018761f, 0.18241400f, -0.07974800f, -0.12156547f, 0.00447754f, 0.00816780f, -0.06418699f, -0.05379642f, 
    -0.09631907f, -0.06396216f, -0.00910711f, -0.09068301f, 0.13484012f, 0.13959157f, -0.03273668f, 0.04702942f, 
    -0.02298606f, 0.00464777f, 0.00051634f, -0.04149983f, -0.09154267f, 0.01874989f, -0.04508767f, -0.07795898f, 
    0.15433095f, -0.14912678f, 0.03033540f, 0.12572612f, -0.01687432f, -0.05273313f, -0.06595475f, -0.08784032f, 
    -0.04714935f, -0.00205552f, 0.00971363f, -0.09989421f, 0.13019378f, -0.24686375f, 0.05997140f, 0.11086272f, 
    -0.10357675f, 0.04783317f, -0.02743492f, 0.00373034f, -0.03241348f, -0.00443634f, -0.02570143f, -0.01843952f, 
    -0.02044825f, -0.13884801f, -0.08525157f, -0.16582990f, -0.03716733f, -0.02577100f, -0.07054291f, -0.04408556f, 
    -0.00578363f, -0.02367778f, -0.03678242f, 0.03036017f, 0.06280844f, 0.00212453f, 0.11264811f, 0.10264201f, 
    0.12861969f, 0.02946981f, -0.01487140f, 0.02763792f, -0.05871129f, 0.06961178f, 0.01594650f, 0.02696439f, 
    0.20497683f, -0.01271195f, 0.10861393f, 0.07147089f, 0.09269979f, -0.02452768f, -0.01171761f, -0.04881896f, 
    -0.00964719f, -0.08356078f, -0.01491604f, -0.07907224f, 0.21832249f, -0.14331304f, 0.13975556f, -0.13462465f, 
    -0.12207301f, -0.00851720f, 0.02068182f, -0.00137223f, -0.02751270f, 0.01844533f, -0.03169154f, -0.10340779f, 
    -0.17012325f, 0.09858301f, -0.15466167f, -0.05408511f, -0.10029695f, 0.03221761f, -0.07202257f, -0.04795887f, 
    -0.03860255f, 0.00727384f, -0.06761198f, -0.07060324f, 0.09888183f, -0.19859327f, 0.13308874f, 0.14354002f, 
    -0.04387420f, -0.13513276f, -0.00539837f, -0.04246823f, -0.03575273f, -0.03983420f, 0.00016049f, -0.02992159f, 
    -0.28237036f, 0.04561701f, -0.02193636f, 0.18858652f, -0.14869279f, -0.00188562f, -0.01374605f, 0.03298519f, 
    -0.04033916f, 0.07170476f, 0.02871677f, 0.00504311f, -0.11049101f, 0.06382286f, 0.09697508f, 0.00585906f, 
    0.03717473f, -0.00306210f, 0.02966171f, -0.06137271f, 0.00085159f, 0.04652558f, -0.02215116f, -0.04349567f, 
    0.02683258f, 0.01974639f, -0.13072057f, -0.00565302f, -0.01145559f, 0.04507353f, 0.02928116f, 0.05570196f, 
    -0.00513069f, -0.04602464f, -0.01495825f, -0.05870445f, 0.16856338f, -0.46103984f, 0.17007613f, 0.05634219f, 
    -0.02460521f, -0.11018924f, -0.09622686f, -0.02462918f, 0.01198234f, 0.06648145f, 0.01727790f, -0.03744752f, 
    -0.11492187f, 0.13543841f, 0.00624683f, 0.03980299f, -0.01764256f, 0.07606207f, -0.02985123f, -0.01943225f, 
    -0.05960355f, -0.02350065f, 0.04341401f, -0.04373854f, 0.00515368f, 0.09593866f, -0.20411187f, -0.06674518f, 
    -0.03179394f, -0.08753433f, -0.02459283f, -0.10762445f, -0.07729166f, 0.00171909f, -0.03385283f, -0.02399336f, 
    -0.13887833f, -0.00941305f, -0.09004814f, 0.15758654f, 0.02188763f, -0.11604869f, -0.04800794f, -0.02244289f, 
    0.00353706f, -0.02717295f, 0.05362159f, -0.00593746f, 0.24267101f, 0.22089185f, -0.09673022f, 0.21606587f, 
    0.10364937f, 0.01458533f, -0.00210537f, 0.13459466f, 0.00985184f, -0.03826559f, 0.00530360f, -0.01143881f, 
    -0.01671774f, -0.13466245f, -0.00873089f, 0.05325516f, 0.01353050f, -0.03321324f, -0.06016622f, -0.05935480f, 
    -0.10888425f, 0.01248815f, 0.10158101f, 0.04066616f, -0.20920679f, 0.12094022f, -0.07409911f, 0.00338736f, 
    -0.01505564f, -0.00015782f, 0.03705303f, -0.08132587f, -0.03728621f, -0.07892746f, -0.03624382f, -0.06002243f, 
    0.06428320f, 0.06586611f, 0.03519475f, 0.14366110f, 0.06358594f, -0.07129800f, -0.01976277f, 0.02515303f, 
    -0.00595659f, -0.01899824f, 0.00399021f, 0.03048522f, -0.02345061f, -0.13762628f, -0.03230254f, -0.12037798f, 
    -0.03081962f, -0.03415665f, -0.03752160f, -0.05675127f, 0.02664785f, -0.04508831f, -0.04155894f, 0.03869555f, 
    -0.27786124f, 0.01527036f, -0.13820788f, -0.12717560f, 0.05087568f, 0.00962199f, -0.11026783f, 0.01226156f, 
    -0.11923737f, -0.04092919f, -0.01752508f, -0.07124273f, -0.03726587f, 0.12081404f, 0.14017498f, 0.14852354f, 
    0.12011892f, 0.06228034f, 0.08966225f, -0.07980525f, -0.04802143f, 0.01352722f, -0.01787804f, -0.03809899f, 
    0.04068105f, -0.12859865f, -0.00223379f, 0.07689728f, -0.05423891f, -0.00153018f, 0.02106607f, 0.01596882f, 
    -0.03097769f, -0.01646133f, -0.02479319f, 0.05161707f, 0.02261587f, -0.10318132f, 0.01122054f, -0.09672963f, 
    -0.07236704f, 0.03179693f, 0.00905603f, -0.01918969f, -0.02519709f, -0.00085348f, -0.00441434f, -0.18152770f, 
    -0.14145347f, -0.19761331f, -0.12136419f, -0.11340854f, -0.02162737f, 0.03218394f, 0.00478834f, -0.06729105f, 
    -0.10826913f, -0.04038170f, -0.02219854f, -0.01605645f, 0.08036201f, -0.09635133f, 0.07381556f, -0.02801805f, 
    0.01861131f, 0.01737855f, -0.07801586f, -0.06596354f, -0.04489793f, 0.02873491f, -0.04922003f, -0.03361274f, 
    0.15755355f, 0.15495361f, 0.03557851f, 0.15926544f, -0.04536714f, 0.02949627f, -0.04920094f, 0.03182174f, 
    -0.17275544f, 0.02552014f, -0.08143371f, 0.06618636f, 0.01334290f, 0.08896380f, 0.02402595f, -0.18160677f, 
    0.02524933f, -0.06894562f, -0.00209841f, -0.03419184f, 0.03975266f, 0.01051740f, 0.01981070f, -0.09913839f, 
    0.19107427f, 0.01212146f, -0.06462919f, 0.13637342f, -0.00369609f, 0.05601037f, -0.05390510f, -0.03137103f, 
    0.00774671f, -0.10203744f, 0.04969333f, 0.02009889f, -0.08961993f, -0.09023461f, 0.06748295f, -0.01024879f, 
    -0.15956594f, -0.09738784f, 0.04767564f, -0.07959843f, -0.05824846f, -0.17144178f, -0.06031064f, 0.03014334f, 
    -0.23569535f, 0.04493994f, 0.10438672f, -0.09928912f, -0.07602111f, 0.00301507f, -0.09243038f, -0.18317050f, 
    0.01488537f, -0.07834385f, 0.09874168f, 0.09679474f, -0.27950653f, -0.02226492f, -0.10393761f, -0.40522841f, 
    -0.14724626f, 0.05083674f, -0.14646883f, -0.02740672f, -0.03868333f, -0.01182283f, 0.01962908f, 0.01249631f, 
    0.04959037f, -0.13744645f, 0.00755216f, 0.09350665f, 0.12395088f, 0.03783542f, -0.07838607f, 0.03453525f, 
    0.00266996f, 0.01789833f, -0.01068415f, -0.00832096f, 0.10107679f, -0.00081221f, -0.13331561f, 0.04215111f, 
    0.05842108f, 0.02111314f, -0.02860049f, -0.08314083f, 0.03295805f, -0.08105999f, 0.10372614f, 0.10322028f, 
    -0.13365556f, -0.09106176f, -0.15964423f, 0.03229454f, 0.04058941f, 0.00014679f, 0.00167445f, 0.00558230f, 
    0.08211536f, -0.06667524f, 0.02735018f, -0.06912411f, -0.07438085f, -0.11232135f, 0.10742482f, -0.09744404f, 
    -0.15043946f, -0.13694654f, 0.07974636f, -0.02288518f, -0.02137972f, 0.08896820f, -0.15584490f, 0.07678370f, 
    0.03769222f, -0.06944998f, 0.15494348f, -0.08592962f, -0.04282877f, 0.01920692f, -0.05650976f, -0.04248017f, 
    -0.03461165f, 0.10596245f, 0.05008082f, -0.07102492f, 0.17193313f, 0.02671098f, -0.00314610f, 0.15107116f, 
    -0.09787744f, -0.09052211f, -0.01004462f, -0.14516954f, 0.01223876f, -0.02336708f, -0.21587268f, -0.06017229f, 
    0.04008863f, 0.09002838f, -0.25877732f, 0.01984958f, 0.00211723f, 0.03046209f, -0.09701986f, -0.00110662f, 
    -0.09731977f, -0.03318379f, 0.04773398f, -0.00380075f, 0.12507185f, -0.16718929f, 0.01321022f, 0.08791818f, 
    0.08494758f, -0.03583555f, -0.04112241f, -0.01732443f, -0.05272392f, 0.17538962f, -0.01151173f, 0.09538736f, 
    0.24434640f, 0.03375020f, -0.26788318f, -0.24552590f, 0.01155102f, -0.05994998f, -0.14421797f, -0.04846500f, 
    -0.03150930f, 0.01781972f, 0.01607184f, 0.01358081f, 0.22232799f, 0.10159520f, -0.33466670f, -0.07412861f, 
    0.00435139f, 0.05327911f, -0.14214784f, -0.03692684f, 0.09435625f, 0.01059067f, -0.00913761f, 0.10869586f, 
    0.10504758f, -0.05126924f, 0.02340380f, 0.03823572f, 0.07450787f, -0.08828291f, -0.03365641f, -0.05808979f, 
    0.01558681f, -0.00459066f, 0.05346808f, -0.11331934f, -0.04312135f, 0.01067229f, 0.17050527f, 0.17114504f, 
    0.00917943f, -0.02208168f, -0.01387959f, 0.01943468f, 0.11292581f, -0.08080336f, 0.05092527f, -0.01149400f, 
    0.11146167f, 0.01935063f, -0.06726755f, -0.00531459f, -0.04321477f, -0.12716065f, 0.09464430f, 0.02001441f, 
    0.11469329f, -0.18790311f, -0.18159613f, 0.01321418f, -0.17477724f, 0.07268378f, 0.17101134f, 0.15685739f, 
    -0.07397985f, 0.05158183f, -0.08317981f, -0.00423980f, 0.06537205f, -0.02001480f, -0.00976003f, -0.01922764f, 
    0.12698250f, -0.02979652f, -0.03638199f, -0.16612652f, 0.00452324f, -0.03306602f, 0.09260011f, 0.00255552f, 
    0.03571975f, 0.06647126f, 0.11569812f, 0.04047946f, 0.12870139f, -0.03125357f, 0.08496049f, 0.05956241f, 
    -0.01426061f, -0.01349955f, -0.10795035f, -0.01224656f, 0.02512736f, -0.06280079f, -0.03194486f, 0.05223960f, 
    0.00653130f, 0.18752638f, -0.15852401f, 0.09225896f, 0.07656828f, -0.02303872f, -0.06743513f, 0.07486526f, 
    -0.08807591f, -0.04722048f, -0.16409738f, 0.01740791f, -0.17499581f, -0.05334168f, 0.16792607f, 0.10820942f, 
    -0.08740324f, 0.02130391f, -0.05582035f, -0.05496624f, 0.04041871f, -0.01758482f, 0.01204605f, -0.02350750f, 
    -0.03213818f, -0.20175712f, -0.08092748f, -0.09440679f, -0.06933030f, 0.01492260f, -0.11420657f, -0.17627509f, 
    -0.02528295f, 0.03091316f, -0.16281947f, 0.09217452f, 0.02589200f, -0.12522966f, 0.01536207f, 0.21308190f, 
    0.08009551f, -0.04869830f, -0.04800284f, -0.01288699f, -0.00526181f, 0.02985106f, 0.11009334f, -0.06992219f, 
    -0.10058530f, 0.05828430f, -0.21578418f, -0.18412969f, 0.01004705f, 0.03705600f, -0.19393019f, 0.02939729f, 
    0.07511647f, -0.06731109f, 0.07416032f, -0.02627661f, -0.08539855f, 0.05093497f, 0.08531818f, 0.02243751f, 
    -0.06991336f, 0.09656617f, 0.08032066f, 0.06855441f, 0.12423629f, -0.00406279f, -0.11561493f, 0.08806539f, 
    -0.18507889f, -0.03095379f, 0.13035172f, -0.22203170f, -0.01791297f, -0.05171400f, -0.07764188f, -0.03548509f, 
    0.01653217f, -0.01463782f, -0.03496919f, 0.14734592f, 0.12937853f, -0.00632703f, 0.09988446f, 0.07211771f, 
    -0.01663294f, 0.06037894f, 0.02575054f, -0.07267282f, -0.03712212f, -0.05961756f, 0.02449625f, -0.05178380f, 
    0.09850149f, -0.00537856f, 0.11318987f, -0.08522882f, 0.01485624f, -0.03155083f, 0.03978708f, 0.02219933f, 
    -0.01197506f, 0.07757442f, -0.00192211f, -0.00355280f, -0.18597600f, 0.03766874f, -0.06443407f, -0.18385379f, 
    0.11039252f, 0.10681940f, 0.00894975f, -0.03736631f, -0.02443409f, 0.02991640f, 0.04761982f, 0.11373724f, 
    0.11286118f, -0.06135609f, -0.06609163f, 0.00461885f, 0.05510417f, -0.01069607f, -0.02326388f, -0.12147460f, 
    0.00354741f, 0.04549581f, -0.02953897f, 0.04633160f, -0.08923459f, -0.00746226f, 0.03822887f, 0.06551926f, 
    -0.13753885f, 0.02337009f, 0.10560812f, -0.20085405f, -0.02160356f, -0.06549281f, -0.05948973f, 0.00289068f, 
    -0.02605909f, -0.01573169f, -0.04709948f, -0.00335545f, -0.03534561f, 0.03555980f, 0.02932817f, -0.00183858f, 
    0.09400534f, 0.02689474f, 0.04638580f, 0.13495071f, 0.06999820f, 0.13364992f, -0.00153741f, 0.04221727f, 
    -0.06249848f, 0.00866473f, -0.12504253f, 0.06435402f, -0.00394144f, -0.08384860f, -0.05976892f, -0.09436423f, 
    -0.00708350f, -0.14343724f, 0.04517163f, 0.14808418f, 0.09834117f, -0.05286513f, 0.02054419f, -0.00335008f, 
    0.00106020f, 0.01814456f, -0.00723673f, 0.02725849f, -0.15247752f, 0.20557983f, 0.05208479f, -0.14568450f, 
    -0.07988166f, 0.03628033f, -0.09338569f, 0.05921837f, 0.09282405f, 0.07801077f, 0.03886522f, 0.02178361f, 
    -0.08986621f, -0.16927283f, -0.09727547f, -0.25187996f, 0.05759662f, -0.05069500f, -0.03682037f, -0.03151545f, 
    0.06708664f, 0.01672246f, 0.02808582f, -0.13030553f, 0.08633126f, 0.05281685f, 0.14518315f, 0.02869008f, 
    -0.11900432f, 0.03908446f, -0.09481341f, -0.06019064f, -0.01006239f, 0.04092601f, 0.06484118f, -0.08843729f, 
    0.04403954f, -0.02466954f, -0.22601426f, 0.10078386f, 0.04069201f, 0.05169529f, 0.11407606f, 0.02655185f, 
    0.07723442f, 0.08884118f, 0.02830710f, 0.02568001f, -0.20818156f, 0.22733603f, 0.05885557f, -0.09607257f, 
    -0.02406390f, 0.00948450f, -0.05482114f, 0.04425775f, 0.01895174f, -0.05541095f, 0.02055741f, 0.07663148f, 
    0.13185972f, -0.00220354f, -0.02695118f, -0.03809952f, -0.01670044f, -0.03301823f, -0.07589130f, -0.04451488f, 
    0.07330101f, 0.00341095f, 0.01495057f, 0.05177674f, 0.02544869f, -0.17803741f, -0.03204267f, -0.05984752f, 
    -0.01325745f, -0.03827794f, 0.10516893f, -0.06143457f, -0.05318346f, 0.03849963f, 0.05604606f, 0.15733761f, 
    0.07238662f, 0.09834129f, 0.01557581f, 0.06145859f, -0.01354490f, -0.07436266f, -0.02970608f, -0.01076477f, 
    0.04166418f, 0.03853903f, -0.02833123f, -0.08927360f, -0.20464209f, 0.05328112f, -0.29499835f, -0.04002211f, 
    0.01091651f, -0.05048551f, -0.04083397f, -0.01038862f, 0.09391008f, -0.05188878f, 0.03052958f, -0.00972182f, 
    0.06983151f, 0.02627285f, -0.31438357f, 0.09488922f, 0.08590388f, -0.06394889f, -0.07475504f, -0.13438629f, 
    -0.00509271f, -0.10129841f, 0.04168454f, -0.05180160f, -0.17780943f, 0.06408328f, 0.15848008f, 0.12096079f, 
    -0.16610922f, -0.06577457f, -0.01017378f, 0.05080739f, 0.05345090f, -0.00298434f, -0.01891494f, -0.01997961f, 
    -0.12498863f, -0.04961642f, -0.11430845f, -0.04544120f, 0.08941589f, 0.00411574f, -0.06929104f, 0.05418921f, 
    0.03765875f, -0.04965419f, -0.09666736f, 0.17346598f, -0.02331148f, -0.20034070f, -0.02050657f, -0.12138152f, 
    -0.01580049f, 0.01127084f, -0.02147869f, -0.05676862f, 0.05931473f, 0.04666036f, 0.07028364f, 0.12663366f, 
    0.19027950f, -0.07069819f, 0.06559951f, 0.08128062f, 0.06769705f, -0.05154963f, -0.12896463f, -0.06984678f, 
    0.01634588f, 0.01010712f, -0.04251708f, -0.06824822f, -0.31235954f, -0.02844243f, -0.02261571f, -0.02757141f, 
    -0.01295631f, -0.01930122f, 0.03860449f, -0.03168991f, 0.00753117f, 0.06822599f, 0.03811052f, 0.03937946f, 
    -0.15607366f, 0.11354046f, -0.14288574f, -0.16755477f, 0.01840847f, 0.01759114f, -0.10832323f, -0.00881233f, 
    0.05164513f, -0.01154196f, -0.02216078f, 0.00774300f, -0.12911682f, 0.04532633f, -0.09698686f, -0.20738770f, 
    -0.04610380f, -0.13697636f, -0.07819498f, -0.05709163f, 0.04236950f, 0.03448805f, -0.09718138f, -0.01077780f, 
    -0.19540851f, -0.41677210f, 0.04254802f, 0.06277361f, 0.11282234f, 0.01769025f, -0.08538610f, -0.07069480f, 
    0.04326959f, 0.02921773f, 0.05647485f, -0.08719192f, 0.12604003f, 0.04620352f, 0.01593976f, 0.16370387f, 
    0.05102864f, 0.00841009f, -0.16399372f, -0.04183968f, 0.07319503f, 0.03481332f, 0.04724559f, -0.10927203f, 
    -0.06400392f, 0.00385232f, -0.12404009f, -0.11899958f, -0.05081737f, 0.00958609f, -0.14472879f, 0.02205105f, 
    0.09305292f, -0.06449894f, 0.13838510f, 0.02204198f, 0.22737043f, -0.00354520f, 0.03471611f, 0.07006790f, 
    0.05622038f, -0.01992284f, -0.07347343f, -0.09474633f, -0.03355289f, -0.03674299f, 0.08039674f, -0.02229909f, 
    0.01104596f, 0.20431620f, -0.10487762f, 0.01367173f, 0.05984027f, 0.09913442f, 0.00087667f, -0.02728818f, 
    -0.01765533f, 0.01213238f, -0.01291468f, 0.10076243f, -0.21473765f, -0.15681756f, 0.15565003f, -0.01200069f, 
    -0.01146909f, 0.02722451f, -0.05203089f, -0.08081338f, 0.03709638f, -0.09555267f, 0.09123173f, 0.10684899f, 
    -0.02765381f, -0.05273370f, 0.17639935f, -0.01994003f, -0.03360784f, -0.00515079f, 0.06068946f, -0.07262063f, 
    0.05341241f, 0.02512326f, 0.13545504f, -0.10382325f, 0.17245202f, 0.07755602f, 0.09723293f, 0.04750478f, 
    -0.04822047f, -0.12253667f, 0.04818003f, -0.08915024f, 0.01034113f, -0.02155364f, 0.11974177f, -0.01864766f, 
    0.11068855f, -0.08977517f, -0.14662130f, 0.07099781f, 0.10760125f, 0.07896765f, -0.01873034f, -0.01064995f, 
    -0.01510727f, 0.06551314f, 0.02957099f, 0.08450188f, 0.17470603f, 0.03678368f, -0.01511243f, 0.11570250f, 
    -0.01530365f, 0.03806732f, -0.03876072f, -0.10632771f, -0.01597844f, -0.01999180f, -0.03360334f, -0.04463436f, 
    -0.26355267f, 0.10062735f, -0.04711725f, -0.18264388f, -0.13831827f, 0.05158978f, -0.02040518f, 0.08584889f, 
    0.10225716f, -0.05016490f, 0.00774323f, -0.14218877f, 0.16391997f, 0.02943200f, 0.01063020f, 0.13317472f, 
    -0.00608260f, -0.02371543f, -0.01834339f, 0.09461794f, 0.03549747f, -0.02633270f, 0.01887316f, -0.00803616f, 
    0.03961016f, -0.11556175f, 0.07376260f, 0.03220956f, -0.04702841f, 0.02936045f, -0.11449777f, 0.20444746f, 
    0.07033381f, 0.06410740f, -0.07906677f, -0.05686338f, -0.07430850f, -0.11465252f, -0.13879687f, 0.08909742f, 
    0.16394645f, 0.07973079f, -0.06717566f, 0.02321324f, 0.01189596f, 0.12420516f, -0.05181791f, 0.02578064f, 
    -0.03689523f, -0.41372851f, -0.11158819f, -0.00722265f, -0.01466115f, 0.04790583f, 0.07545653f, -0.01539287f, 
    -0.09881808f, 0.01507937f, -0.08944912f, -0.16049853f, 0.29493245f, -0.11015425f, -0.16024576f, 0.09089035f, 
    -0.07153226f, -0.12268419f, 0.05032706f, 0.12021702f, -0.00771162f, -0.09579897f, -0.01893045f, -0.05414805f, 
    0.00477773f, -0.05602517f, 0.05456794f, -0.05490572f, 0.07045402f, 0.20380685f, -0.00276496f, -0.06761845f, 
    -0.06773643f, -0.10948747f, 0.05844103f, -0.00033691f, 0.11477521f, 0.12897341f, -0.01276237f, -0.04707431f, 
    0.01409936f, -0.05553167f, -0.12186353f, 0.13538243f, -0.04893288f, 0.05916031f, -0.02699309f, 0.03049435f, 
    -0.15784946f, 0.00831090f, 0.08003864f, -0.37700143f, -0.00732681f, -0.03580326f, -0.07609592f, 0.02051845f, 
    0.05699615f, 0.02414471f, -0.06871403f, -0.06637478f, 0.41629386f, 0.13429417f, -0.18047746f, 0.24989121f, 
    0.06811567f, -0.00423495f, -0.08412191f, 0.06901173f, -0.10181985f, -0.02693380f, -0.01243232f, -0.03173987f, 
    -0.25624824f, -0.09639741f, 0.20293249f, -0.02058451f, 0.10442343f, 0.07133600f, 0.11258317f, -0.06314780f, 
    0.03876046f, 0.02086612f, -0.17236051f, 0.14343749f, 0.26416937f, -0.11127038f, 0.00787390f, 0.06190585f, 
    0.00896014f, -0.00053497f, -0.02593003f, -0.04197210f, -0.03590416f, 0.04735894f, 0.02432432f, -0.00501061f, 
    -0.03500735f, 0.04072360f, 0.33109289f, 0.01848225f, -0.04777364f, 0.07284868f, -0.00069292f, 0.12011991f, 
    -0.01101603f, -0.05443276f, 0.02777041f, -0.00536148f, -0.16342287f, 0.22414050f, 0.07029536f, -0.06711083f, 
    0.02676281f, -0.02254392f, -0.04179786f, 0.03657183f, -0.00608645f, -0.09599999f, -0.11821487f, -0.03126232f, 
    -0.17146733f, -0.02087288f, 0.22416474f, -0.00987281f, -0.04990265f, -0.00423207f, -0.05247395f, 0.03208760f, 
    0.05899712f, -0.04719969f, -0.04581807f, 0.02330966f, 0.31870496f, -0.05468839f, 0.24027592f, 0.11411826f, 
    -0.02587670f, 0.01624349f, 0.07599566f, -0.17065661f, -0.14385840f, 0.02164261f, -0.05718589f, 0.09760614f, 
    -0.08434095f, 0.11609372f, -0.06944127f, -0.00116865f, 0.00172249f, -0.00440087f, 0.15785229f, -0.07046753f, 
    0.05249693f, 0.11232632f, 0.00845018f, 0.11650977f, -0.28764415f, 0.32811213f, -0.18562895f, -0.14982110f, 
    0.10750598f, -0.07801976f, -0.02146241f, -0.09230710f, -0.10447738f, -0.05223811f, -0.08844202f, -0.10583061f, 
    -0.05699371f, -0.30538797f, 0.12373948f, -0.03332960f, 0.02408061f, -0.00726208f, -0.03884403f, -0.01976655f, 
    -0.02241536f, -0.03177216f, 0.20052159f, 0.09479957f, -0.15941936f, -0.17546508f, 0.10422952f, -0.09746975f, 
    0.03016511f, -0.00997650f, 0.02927076f, 0.12189419f, 0.04444318f, 0.05841467f, -0.06524407f, -0.00182454f, 
    -0.14719385f, -0.07892682f, 0.14212584f, 0.00933052f, 0.11284792f, -0.06850518f, -0.06346235f, -0.06862526f, 
    0.10174291f, 0.09589134f, 0.03785317f, 0.08902831f, 0.04708938f, -0.05659841f, -0.02778221f, -0.00594503f, 
    -0.00748126f, 0.00684485f, -0.00502487f, -0.14265834f, 0.04715505f, 0.02696436f, 0.11705502f, 0.04943310f, 
    0.02294278f, -0.03363036f, 0.22689350f, -0.05986013f, -0.05865128f, 0.01215816f, -0.08690324f, 0.02832409f, 
    -0.02498144f, 0.02393096f, 0.06748609f, 0.06653643f, -0.12892973f, -0.15630786f, 0.07872537f, -0.03142389f, 
    0.04790283f, -0.06660022f, 0.08366040f, 0.10608892f, 0.00769581f, 0.05145662f, 0.09663510f, 0.00937056f, 
    0.15796827f, -0.04731433f, -0.03748319f, 0.17536631f, 0.06522691f, 0.03314106f, 0.01364549f, 0.10129304f, 
    -0.03417572f, 0.00599925f, 0.14136417f, -0.01781062f, -0.05467062f, 0.18146217f, -0.09719334f, -0.09307436f, 
    -0.00022091f, 0.11368939f, 0.01051167f, -0.03205379f, -0.11621901f, -0.07914490f, -0.05388301f, 0.01162753f, 
    -0.29946685f, -0.07566484f, -0.08850348f, -0.30356455f, -0.08341809f, 0.06350374f, -0.01646003f, 0.15431800f, 
    -0.05829548f, -0.07133878f, 0.14036320f, -0.00845636f, 0.10079902f, 0.09176540f, -0.02925454f, -0.01666060f, 
    -0.05559831f, 0.09643710f, 0.09394319f, -0.04000789f, -0.11921468f, -0.14155936f, 0.02293223f, -0.03431059f, 
    -0.00254453f, -0.29192090f, -0.04176143f, 0.20598783f, -0.11674930f, 0.17549850f, -0.02344782f, 0.00199266f, 
    -0.05523502f, 0.04950853f, -0.02840976f, 0.02782405f, 0.10698760f, 0.23041388f, -0.15001471f, -0.19957592f, 
    0.12369790f, 0.02384166f, -0.03662287f, -0.01673304f, -0.02049528f, 0.03978176f, 0.05426225f, 0.03388347f, 
    0.49861974f, 0.06831286f, 0.02863340f, -0.25583887f, 0.03826847f, -0.01470451f, -0.02474487f, 0.01475027f, 
    -0.06505930f, -0.04795187f, -0.03542629f, -0.01910337f, 0.15384804f, -0.04699457f, 0.01110369f, 0.25875306f, 
    -0.20836806f, -0.06366747f, -0.08804207f, 0.03086856f, -0.00497319f, 0.16405790f, 0.04944682f, -0.00949998f, 
    -0.13050227f, -0.06921178f, 0.00863450f, 0.03047092f, 0.02258781f, -0.04543640f, 0.01058774f, -0.12936834f, 
    -0.04392917f, 0.01699865f, -0.00519102f, 0.03828103f, 0.15588018f, -0.04333594f, -0.07296076f, -0.01907217f, 
    0.03552302f, -0.11512378f, -0.07784247f, 0.02010055f, -0.01326617f, 0.11148296f, 0.06732940f, -0.04165693f, 
    0.07932825f, 0.09475226f, -0.06914034f, -0.11038905f, 0.04045123f, -0.02285608f, -0.09943925f, -0.02152151f, 
    -0.21810262f, -0.06100241f, -0.05428618f, -0.23341523f, -0.22006440f, 0.00709131f, -0.00136218f, 0.01559035f, 
    0.10652924f, 0.02086228f, -0.05180386f, 0.05701165f, 0.10052313f, 0.08847538f, 0.01775575f, 0.11912687f, 
    -0.55000222f, 0.13962007f, -0.01590298f, -0.00892980f, 0.02012924f, 0.01106422f, -0.01320191f, -0.11382196f, 
    -0.01887311f, -0.11280829f, 0.04754057f, 0.05807188f, 0.05093534f, 0.25047901f, 0.15305452f, 0.16910101f, 
    -0.00721641f, 0.01488520f, 0.02097902f, 0.04938670f, -0.01343724f, 0.01555834f, -0.02311010f, 0.04655137f, 
    0.00837012f, -0.13690589f, 0.02614293f, -0.13149215f, 0.03416380f, 0.05407166f, -0.01977935f, 0.00057109f, 
    -0.01134190f, -0.03889044f, 0.01541738f, 0.05833394f, 0.42792246f, -0.48143393f, -0.06809453f, -0.00914036f, 
    0.05393137f, -0.00817073f, 0.02774940f, -0.10096438f, 0.07060158f, -0.06571331f, 0.07450100f, -0.11161039f, 
    0.06550419f, -0.11089437f, -0.10341567f, -0.19155414f, 0.02664150f, 0.07977137f, 0.03947808f, -0.02614213f, 
    -0.11752615f, -0.10397037f, -0.09269994f, -0.01283675f, 0.22546172f, -0.53041065f, 0.04353855f, 0.13574976f, 
    -0.11146419f, -0.04592505f, -0.03321561f, 0.21670018f, -0.18536644f, 0.14520237f, 0.04783707f, 0.02412719f, 
    0.12270465f, -0.34667853f, 0.16085698f, 0.05578585f, -0.03201532f, -0.06345846f, 0.05550288f, 0.01938631f, 
    -0.10912568f, -0.15842161f, 0.02195132f, 0.01667609f, 0.02994801f, 0.18973607f, 0.01839911f, -0.07171584f, 
    -0.02113455f, 0.02909729f, -0.11303195f, -0.05312115f, 0.02476397f, 0.05730625f, -0.01311751f, -0.21119323f, 
    -0.22338209f, 0.24877542f, -0.09038798f, 0.06544448f, 0.09551780f, 0.05148580f, 0.07293649f, 0.04266020f, 
    0.10463841f, 0.04621407f, 0.07536282f, 0.02468271f, 0.15354478f, -0.41224876f, 0.10865951f, -0.25485244f, 
    -0.08408795f, 0.04571674f, -0.08315582f, 0.01898435f, 0.04599112f, -0.12446604f, 0.04196922f, -0.01687681f, 
    -0.42571044f, 0.19427133f, 0.19485438f, -0.09933567f, -0.02749452f, 0.08869607f, -0.02457348f, -0.06733692f, 
    -0.04482708f, 0.00385086f, 0.01807976f, -0.00999699f, -0.02973810f, -0.30840230f, 0.03945407f, -0.05633170f, 
    0.02675282f, -0.03644251f, -0.03762024f, -0.00699841f, 0.04778790f, 0.00378875f, -0.00916193f, -0.01599311f, 
    -0.22060412f, 0.17911460f, 0.21426776f, 0.09190663f, -0.01407927f, -0.00147497f, -0.12377958f, 0.05917820f, 
    -0.06958612f, 0.01928729f, 0.12037945f, 0.02432285f, 0.19610564f, -0.03504531f, -0.14233354f, -0.22117430f, 
    -0.12753649f, -0.03753647f, -0.05074559f, 0.08944210f, -0.03531472f, -0.02460762f, 0.01416003f, -0.06330056f, 
    0.04816539f, -0.09571562f, 0.05145493f, -0.14596078f, 0.02546944f, 0.12666745f, -0.13190135f, 0.04861965f, 
    0.00700532f, 0.02860685f, -0.00709547f, -0.03425942f, -0.24326186f, 0.22250058f, -0.08113357f, -0.18929048f, 
    -0.00232422f, -0.11011854f, 0.01704251f, -0.10183308f, 0.06044903f, 0.06237734f, 0.01989549f, -0.05284805f, 
    -0.07993273f, 0.00836610f, 0.02001420f, -0.17973767f, -0.06106698f, 0.09373152f, 0.00074828f, -0.03728054f, 
    0.02331379f, -0.06544223f, 0.06761737f, -0.00505522f, -0.09458268f, -0.10707273f, 0.08045340f, -0.12792681f, 
    0.02213041f, 0.05305683f, 0.09820360f, 0.16222337f, 0.09026025f, -0.04244132f, 0.01665613f, 0.00896928f, 
    -0.06489895f, -0.23692507f, -0.09024467f, -0.20221010f, -0.17176971f, 0.00678491f, 0.04487303f, -0.00077078f, 
    0.08285592f, 0.02223627f, 0.09482992f, 0.00155911f, -0.17054321f, 0.10762184f, -0.33679208f, -0.05868870f, 
    0.06086506f, -0.05195070f, -0.06251819f, 0.06882831f, -0.07553322f, 0.01822511f, -0.13375992f, -0.02180491f, 
    0.09029528f, 0.05031903f, 0.02390730f, -0.02872870f, -0.03973586f, 0.02386660f, 0.04564705f, -0.03519267f, 
    -0.05420544f, 0.13860400f, -0.07041889f, 0.08575787f, 0.02869653f, -0.06165207f, 0.00140314f, 0.01738271f, 
    0.06864911f, -0.00852289f, -0.03319395f, -0.08918138f, -0.03998725f, -0.05499396f, -0.06974593f, 0.05394708f, 
    0.30894998f, 0.09635991f, -0.03460135f, 0.03837805f, -0.13586296f, 0.09520590f, 0.02519675f, 0.00099695f, 
    -0.06244008f, -0.04002889f, 0.05226349f, -0.15212159f, -0.02375376f, -0.27338520f, -0.03405918f, -0.04058669f, 
    -0.01689537f, 0.08736791f, 0.02315314f, 0.00435877f, -0.10813592f, -0.05271874f, -0.08283993f, 0.01928703f, 
    -0.03384599f, -0.23645546f, -0.12953651f, -0.01485795f, -0.07074466f, 0.02591998f, -0.01684000f, -0.08148753f, 
    0.02086671f, 0.02410019f, -0.09444815f, 0.02295389f, 0.08924016f, 0.12617552f, -0.16142188f, 0.06942929f, 
    0.08116722f, 0.01152286f, 0.06206458f, 0.03925259f, 0.00901957f, -0.07443754f, 0.02490597f, 0.06409892f, 
    0.16626199f, -0.04993993f, 0.25289962f, -0.10826469f, 0.08471993f, 0.10286928f, -0.09824216f, -0.05480033f, 
    -0.10547301f, -0.03960601f, -0.04125781f, -0.07091306f, 0.20504853f, -0.37094632f, -0.00369566f, 0.06097325f, 
    -0.00819435f, -0.11981475f, -0.01591343f, 0.03344972f, -0.02761734f, 0.17556727f, 0.01472074f, -0.06558554f, 
    -0.22133751f, 0.14831568f, 0.03933295f, 0.07317286f, 0.04229280f, 0.07820857f, -0.08352163f, -0.06723651f, 
    -0.04762065f, -0.00759500f, -0.05032630f, 0.08583347f, -0.05658864f, -0.13888487f, 0.07892394f, 0.02596642f, 
    0.01711200f, -0.00492000f, 0.05677207f, -0.11588790f, -0.01686118f, 0.01824269f, -0.14530803f, 0.12785438f, 
    -0.05308042f, 0.01171617f, -0.06367003f, 0.12948163f, 0.02619348f, -0.04160556f, -0.00653688f, 0.00197944f, 
    -0.03191580f, -0.12995587f, 0.00110487f, -0.00722038f, 0.09461769f, 0.17098889f, -0.14817855f, 0.11385550f, 
    -0.24141584f, -0.13698113f, 0.04780049f, -0.02566521f, 0.04290133f, -0.18838547f, 0.12180986f, -0.08512214f, 
    0.18364689f, 0.13047378f, -0.04753730f, -0.13552088f, 0.00726937f, 0.08666703f, 0.02904373f, 0.00339041f, 
    -0.03306020f, -0.04362737f, 0.08736326f, 0.00778881f, -0.12976158f, -0.04817200f, 0.18737057f, -0.04253098f, 
    0.08692501f, 0.04923418f, 0.03455197f, 0.05826875f, -0.09972277f, -0.00942309f, 0.02350111f, 0.02576473f, 
    -0.39438733f, -0.16274717f, -0.12712298f, 0.06849819f, 0.08367908f, 0.06886769f, -0.02967557f, -0.00819351f, 
    0.14249252f, 0.18941748f, 0.05007630f, -0.03939778f, -0.38214421f, -0.33594227f, 0.08074212f, 0.10495725f, 
    0.08514229f, -0.00140345f, 0.06785987f, -0.07875406f, 0.10848008f, 0.01493601f, 0.06329108f, 0.00864449f, 
    0.13093020f, 0.09057648f, 0.09279022f, -0.15892343f, 0.08043740f, -0.01807852f, 0.02090018f, 0.04172089f, 
    -0.00382675f, -0.02655683f, 0.02100113f, 0.04033281f, 0.13293694f, -0.05595515f, -0.00289031f, 0.07745264f, 
    0.00071296f, -0.06920286f, 0.06958050f, 0.07550418f, 0.03867621f, 0.07123613f, 0.01352091f, 0.01992073f, 
    0.19617601f, 0.17290264f, -0.10442062f, 0.17520803f, -0.05080379f, -0.01368295f, 0.05612082f, -0.03684406f, 
    0.08824252f, 0.00308394f, 0.06397258f, -0.06449636f, 0.22162108f, 0.01765309f, -0.10015384f, 0.06861269f, 
    0.01960985f, -0.08389958f, -0.08059605f, 0.06825099f, -0.02689529f, -0.01012771f, -0.13155416f, 0.00561884f, 
    -0.37270948f, -0.18683995f, 0.02011842f, 0.19539069f, 0.11459482f, -0.02871499f, -0.06288645f, -0.12365511f, 
    -0.00988454f, -0.07631716f, -0.08851033f, -0.00655776f, -0.37264276f, -0.13141656f, -0.00565173f, -0.08673626f, 
    0.04661821f, -0.25911966f, -0.09810991f, -0.08122833f, -0.10687328f, 0.04354795f, 0.09179457f, 0.18781455f, 
    0.04592630f, -0.16145268f, -0.09856246f, 0.02052466f, -0.01851111f, 0.06295008f, -0.09432647f, -0.08792470f, 
    0.07072865f, 0.13890779f, -0.02355075f, -0.04531692f, -0.33292684f, -0.03021873f, 0.04850699f, 0.10151526f, 
    0.13002218f, -0.05380202f, 0.04488244f, 0.10774480f, 0.10864776f, 0.01580170f, -0.01485716f, 0.06666143f, 
    -0.24551935f, -0.18944702f, -0.10788190f, -0.01343123f, 0.06749522f, -0.01275441f, -0.06625696f, -0.04941119f, 
    0.07165600f, -0.22446589f, -0.07644416f, -0.01298071f, -0.21002692f, -0.10914426f, -0.02112013f, -0.14901085f, 
    0.03135629f, -0.13713716f, -0.03042292f, 0.03440803f, 0.01206114f, -0.07090839f, 0.01799695f, 0.01749521f, 
    -0.13938847f, 0.01184181f, -0.09633957f, 0.04809704f, -0.07779838f, -0.08610968f, -0.03897683f, -0.03553370f, 
    -0.10863665f, -0.03514251f, -0.03392013f, -0.11650878f, 0.14828524f, 0.12085018f, -0.01363690f, -0.07501993f, 
    -0.13168643f, -0.01089585f, -0.02692903f, 0.03702052f, 0.06791145f, -0.03632636f, 0.03392463f, -0.00635432f, 
    -0.18911032f, 0.03877362f, -0.11142378f, -0.02839851f, 0.00212032f, 0.05280359f, 0.00671175f, 0.15673292f, 
    -0.01233718f, 0.04034122f, 0.03538459f, -0.05914403f, -0.04806310f, 0.06019061f, -0.23709121f, -0.16775033f, 
    0.11874695f, 0.03362417f, -0.13678879f, 0.08363979f, -0.06447015f, -0.07286731f, 0.11044504f, -0.01281601f, 
    -0.13428186f, -0.06335258f, -0.08725625f, -0.04901644f, 0.01847909f, -0.05800562f, 0.01658995f, -0.04485695f, 
    0.00146478f, -0.05422312f, -0.14105099f, -0.07230455f, 0.12541251f, 0.06609675f, 0.05038619f, -0.01990431f, 
    -0.13867439f, -0.04233506f, -0.02567321f, -0.02032204f, 0.04459844f, -0.17821884f, -0.12014502f, -0.09392320f, 
    -0.20176379f, 0.15935478f, -0.03369600f, 0.06927936f, 0.07347188f, 0.19727281f, -0.00428045f, -0.00029930f, 
    0.12731041f, -0.01096068f, -0.06309932f, -0.00820976f, -0.52843863f, -0.27338138f, -0.18092440f, -0.14828482f, 
    0.04058064f, -0.16585098f, 0.00046394f, 0.05100569f, 0.01459724f, 0.11159199f, 0.03442439f, -0.02069495f, 
    -0.34829238f, 0.05506395f, 0.04617902f, -0.14654867f, 0.24282111f, -0.02250404f, 0.03295009f, -0.07053488f, 
    0.00334694f, 0.07686479f, 0.00090586f, 0.05533256f, -0.13412996f, -0.04577534f, 0.15739796f, 0.09179556f, 
    0.11378632f, -0.01119803f, 0.01457005f, -0.12396168f, 0.09976964f, 0.10641444f, 0.02672664f, 0.24494492f, 
    0.22658424f, 0.13169791f, 0.04423539f, -0.02479081f, 0.08251624f, -0.07967752f, 0.00009255f, -0.09393476f, 
    -0.03863165f, 0.00338257f, -0.19132067f, -0.04560229f, -0.48455805f, -0.18049645f, -0.08137768f, -0.22328199f, 
    0.09406486f, 0.07913153f, 0.03397232f, -0.07418147f, 0.10780483f, 0.06272223f, 0.00079930f, 0.08438526f, 
    -0.31103510f, -0.07520345f, 0.00993432f, 0.20771918f, 0.04021741f, -0.09260435f, 0.06326362f, -0.09718270f, 
    0.02665168f, 0.06488183f, -0.00683187f, 0.03240997f, 0.13874257f, -0.09573755f, 0.11719354f, -0.09411055f, 
    -0.04933797f, 0.14127105f, -0.05836212f, -0.00981531f, 0.00617499f, 0.01620216f, -0.01655835f, 0.01388827f, 
    -0.30578265f, -0.35064161f, -0.07237095f, -0.07613694f, -0.00548111f, 0.05198322f, 0.00668590f, -0.06530670f, 
    0.05945325f, 0.00517652f, -0.12869908f, -0.04278526f, 0.25391576f, 0.02913818f, -0.02577939f, -0.08754255f, 
    -0.12865642f, 0.00220264f, 0.01616980f, 0.01703206f, 0.04057321f, 0.07064553f, -0.16974035f, 0.01276921f, 
    -0.26998559f, -0.08574796f, -0.14873332f, -0.17241871f, 0.07448700f, -0.05215241f, -0.03483786f, 0.08264064f, 
    -0.05650981f, 0.08186122f, 0.02245794f, 0.08544064f, 0.18139859f, -0.03762230f, 0.00987391f, -0.04780572f, 
    -0.10510461f, -0.08533939f, 0.07765546f, 0.01577321f, 0.09586277f, -0.13225411f, -0.00438476f, -0.06272418f, 
    -0.31212923f, -0.40293935f, -0.14000252f, -0.01483504f, 0.00961070f, -0.01723947f, 0.00710125f, 0.03600334f, 
    0.08069369f, 0.14642309f, -0.03826402f, 0.12665246f, -0.04792070f, -0.03191131f, 0.03546545f, -0.06634163f, 
    -0.00770832f, 0.06728741f, 0.04781462f, 0.03707120f, 0.02293609f, -0.00058897f, 0.04687720f, 0.03237645f, 
    0.27129644f, 0.18289131f, 0.03918495f, -0.02914385f, -0.01154344f, -0.04022327f, 0.02231592f, 0.04910417f, 
    0.00984449f, -0.03554309f, 0.10285305f, -0.04710926f, 0.14689918f, 0.13453917f, -0.04068230f, -0.01514043f, 
    0.00033703f, -0.01286142f, 0.02580581f, 0.02118793f, 0.02656754f, 0.14358230f, 0.01194433f, 0.10747583f, 
    -0.24159828f, 0.09512998f, -0.04486548f, -0.01852662f, 0.00479199f, 0.03917383f, 0.07908712f, 0.02998217f, 
    0.07376887f, 0.08876022f, 0.07248034f, 0.13172497f, 0.14838877f, -0.03290915f, 0.10530644f, -0.00606533f, 
    0.08982772f, 0.12746947f, -0.03834783f, -0.00412579f, 0.12758535f, -0.02744934f, 0.04885954f, 0.00841438f, 
    -0.07527062f, -0.00755954f, -0.08505647f, -0.06355821f, -0.01836495f, 0.05302776f, 0.00534676f, 0.01364122f, 
    0.01828104f, 0.11639923f, 0.04627499f, 0.00944490f, -0.01153823f, 0.07914711f, -0.12036197f, -0.00546328f, 
    -0.04182005f, 0.09579238f, 0.04596857f, 0.04582613f, -0.08917321f, -0.09580690f, 0.17397080f, 0.11164244f, 
    -0.23072754f, -0.16519631f, -0.17527926f, -0.03867411f, 0.11747178f, 0.07156987f, 0.00411745f, -0.04401924f, 
    0.00835575f, 0.00047871f, -0.07954176f, 0.02095414f, 0.04597213f, 0.12665144f, -0.14643216f, -0.03245527f, 
    0.06594281f, -0.00000357f, 0.04635916f, 0.03425943f, 0.11060094f, 0.01206446f, -0.08162832f, 0.05157540f, 
    -0.51449555f, -0.24398036f, 0.22471480f, -0.05729816f, 0.12826449f, -0.03252245f, 0.03225707f, 0.01703364f, 
    0.20419934f, -0.02644820f, 0.02197090f, 0.05553368f, 0.14988710f, 0.08429712f, -0.04213989f, -0.03020249f, 
    -0.01922429f, 0.00574717f, 0.09169229f, -0.02829247f, 0.06381191f, 0.05856280f, 0.09459576f, 0.08610769f, 
    -0.09118771f, -0.14678657f, 0.10880583f, 0.07382757f, -0.05503665f, 0.08975329f, 0.01580842f, 0.00560010f, 
    0.01486158f, 0.02794428f, -0.03720202f, 0.15527289f, -0.07988868f, 0.20921002f, -0.05386005f, -0.13220036f, 
    -0.02457775f, 0.03258975f, 0.05437308f, 0.00243589f, 0.03290564f, 0.03653526f, 0.14557514f, 0.09143694f, 
    -0.41908240f, -0.09143653f, -0.26233277f, -0.11898273f, 0.06840272f, -0.01134092f, -0.19698074f, -0.04177836f, 
    -0.05570531f, -0.00697030f, -0.02256086f, -0.09664516f, 0.12111705f, -0.02585752f, 0.05708881f, -0.06165028f, 
    -0.01538681f, -0.06554206f, 0.05510630f, 0.11280607f, -0.00673012f, 0.03391573f, 0.11100510f, 0.10868480f, 
    0.24391936f, 0.02687364f, -0.05028502f, -0.08883133f, 0.16309798f, -0.00308721f, -0.05167001f, 0.01562561f, 
    0.02096652f, -0.07242130f, -0.05668229f, -0.05670747f, 0.00596077f, -0.14762029f, -0.00743902f, -0.10207943f, 
    -0.08166989f, -0.01026203f, -0.03930977f, -0.14434527f, 0.04378531f, -0.07832195f, -0.09472859f, 0.00627750f, 
    -0.28797638f, -0.24353598f, 0.17041947f, -0.14286987f, 0.00109973f, 0.03955849f, -0.05209455f, 0.07420853f, 
    0.00773879f, 0.03456973f, -0.02719212f, 0.00118101f, -0.29633871f, -0.06251561f, -0.09796126f, -0.35608968f, 
    -0.01339216f, 0.04611715f, -0.12114561f, 0.09381336f, -0.05884998f, 0.01533401f, -0.02487990f, -0.00527265f, 
    -0.01157251f, 0.11127023f, 0.06901663f, 0.04817505f, 0.10006668f, 0.02656155f, -0.02198028f, 0.03276912f, 
    0.07023632f, -0.05469411f, 0.11757635f, 0.01631616f, -0.23122595f, -0.00507555f, -0.22234614f, -0.18561193f, 
    0.07835698f, 0.08928829f, -0.13584830f, -0.08529022f, 0.04038326f, -0.06645940f, -0.00306503f, -0.02964958f, 
    -0.19522308f, -0.24338040f, -0.01629852f, 0.02189416f, 0.12211654f, 0.02088057f, 0.06489345f, 0.00225979f, 
    0.03706287f, 0.05201666f, -0.04437988f, 0.14063019f, 0.15803599f, 0.07843429f, -0.05619521f, -0.00889282f, 
    0.05694200f, 0.03911944f, 0.01296548f, -0.05591658f, 0.00580831f, -0.06452778f, 0.08567277f, -0.07423183f, 
    0.08657829f, 0.09399485f, 0.01518304f, -0.07207967f, -0.02727222f, 0.05785383f, 0.04230868f, -0.03989654f, 
    0.09103619f, 0.09546353f, -0.00397735f, 0.02399180f, -0.16383043f, -0.25118282f, -0.06894078f, 0.02028163f, 
    -0.10384212f, -0.01200359f, 0.03260548f, -0.01554997f, -0.02823013f, 0.08306274f, -0.06254739f, -0.13844727f, 
    -0.40839243f, -0.12322961f, -0.07925746f, -0.08807857f, 0.07475074f, -0.03833500f, -0.01062730f, -0.07234920f, 
    0.02615011f, 0.16178030f, 0.02827766f, 0.14457726f, 0.23182714f, 0.01157181f, -0.04317236f, -0.01693865f, 
    -0.03452620f, 0.03970154f, 0.00795074f, 0.12743448f, 0.04498890f, -0.02027186f, -0.00610827f, -0.04727590f, 
    0.01541484f, -0.04887608f, 0.05966650f, 0.04056377f, 0.02956994f, 0.10604170f, 0.03250658f, 0.02350099f, 
    0.08035039f, 0.04953014f, 0.00280697f, -0.09874965f, 0.04672327f, -0.10248404f, -0.02794841f, 0.04404375f, 
    -0.02140186f, -0.02562041f, -0.07386770f, 0.04199467f, 0.08073562f, 0.12265817f, 0.03724819f, 0.07852889f, 
    0.03664306f, -0.09978665f, 0.01297818f, 0.02927667f, -0.06025475f, -0.04314963f, -0.05481963f, -0.03807345f, 
    -0.04187004f, 0.06294174f, -0.08660339f, 0.06238256f, -0.03678119f, -0.20311438f, -0.12118158f, -0.01798060f, 
    0.02596224f, 0.02455904f, 0.06410914f, -0.13329636f, -0.06348653f, -0.11879908f, -0.14986673f, 0.03050494f, 
    0.07866915f, 0.20894331f, -0.13787144f, -0.03233888f, -0.04101352f, -0.01846641f, 0.03825865f, -0.13023914f, 
    -0.03386201f, -0.02401231f, -0.03028811f, -0.09285424f, -0.00757400f, 0.10465547f, -0.01870332f, -0.08004120f, 
    -0.03286181f, -0.06891824f, -0.05786837f, -0.01772747f, -0.08936719f, -0.10284457f, -0.02803129f, -0.02405398f, 
    0.14737123f, 0.05217826f, -0.11377568f, 0.02946755f, 0.03707387f, 0.06250913f, -0.01034985f, 0.15776409f, 
    0.05907974f, -0.07783953f, -0.07986130f, 0.02467601f, 0.10920440f, 0.09993722f, -0.03305291f, -0.03922016f, 
    0.09830218f, -0.10409752f, -0.00784186f, -0.01804681f, -0.02433861f, 0.02986745f, -0.01502796f, 0.04024626f, 
    0.34453130f, 0.05556674f, -0.29502147f, -0.15131244f, 0.02009238f, -0.09928320f, 0.03185944f, 0.08940157f, 
    0.01317704f, 0.06688593f, 0.04539004f, 0.00846475f, -0.19308276f, -0.12210369f, 0.27477285f, -0.08341567f, 
    -0.00790199f, -0.04864651f, -0.09817665f, -0.07045386f, -0.01833986f, -0.02578370f, 0.14270413f, -0.02198495f, 
    0.21550879f, -0.26318967f, -0.09661151f, 0.07950503f, -0.07921044f, 0.16605264f, -0.09906414f, 0.03221020f, 
    0.03424551f, -0.09061944f, -0.07817414f, -0.03582646f, -0.22060318f, -0.02641340f, -0.06648435f, -0.15343069f, 
    -0.00095740f, -0.07739574f, 0.07967955f, 0.09862425f, -0.08365847f, 0.10745692f, 0.03459486f, 0.08394778f, 
    0.27944562f, 0.12927809f, -0.01146918f, 0.04200956f, -0.08804950f, 0.01389691f, -0.09461925f, 0.03994820f, 
    0.09041881f, 0.06346336f, -0.02206630f, 0.09603617f, 0.19959970f, -0.15427747f, 0.04802743f, -0.08791415f, 
    0.04068502f, -0.04473232f, 0.03834735f, 0.01370308f, -0.05552308f, -0.03730170f, 0.07748791f, 0.01786183f, 
    0.04350512f, -0.05698466f, -0.08144645f, 0.13914420f, -0.10450373f, 0.08158796f, -0.00191430f, -0.03308490f, 
    -0.09925290f, -0.00835128f, -0.03171010f, -0.08848472f, 0.31179166f, 0.09247237f, 0.02917927f, -0.01469258f, 
    0.07328467f, -0.06691603f, -0.09379436f, -0.02228887f, 0.10208176f, 0.04921425f, 0.05638215f, 0.00905773f, 
    -0.21104012f, -0.04856852f, -0.02930730f, -0.29274186f, 0.07749390f, -0.02787781f, 0.06535257f, 0.12119243f, 
    0.11535098f, -0.00288064f, 0.00925182f, 0.04785863f, 0.11710363f, -0.21817222f, 0.02363149f, -0.11225020f, 
    -0.06683607f, 0.02350819f, 0.08408523f, -0.09308662f, 0.06429783f, -0.00982490f, 0.01412834f, 0.01932688f, 
    -0.36643457f, -0.04178993f, 0.04095454f, -0.03999953f, -0.13198166f, 0.02974584f, -0.01139013f, 0.08544239f, 
    -0.03617449f, 0.07170092f, -0.05117967f, -0.00654354f, 0.02197911f, 0.01411741f, -0.13290305f, 0.02389199f, 
    0.02747917f, 0.01091815f, -0.10984329f, -0.11807441f, 0.01275690f, 0.03775410f, -0.09605347f, -0.11480759f, 
    0.12415151f, -0.20137601f, -0.07780056f, 0.21878003f, -0.07860413f, 0.12752074f, -0.01689580f, -0.08250990f, 
    0.14270107f, 0.03400995f, 0.11492786f, -0.03229044f, -0.41495794f, -0.07025167f, -0.01740289f, -0.24999751f, 
    -0.00862485f, 0.02029565f, 0.00000008f, 0.08942333f, 0.04404277f, 0.01518218f, 0.03014724f, 0.00968996f, 
    -0.06504726f, -0.06110156f, 0.08962550f, 0.08691016f, 0.07387448f, 0.02077744f, -0.05493271f, -0.03877702f, 
    0.06616180f, 0.14379461f, 0.05393956f, 0.01813505f, 0.01467487f, -0.11336395f, 0.01555796f, -0.07101084f, 
    0.02749961f, 0.03530620f, 0.06838942f, 0.17452945f, 0.09174946f, 0.09735546f, -0.12986568f, -0.04680084f, 
    -0.15517488f, 0.03487739f, 0.12084563f, 0.06439945f, -0.10299863f, -0.11845746f, -0.02425961f, 0.09100718f, 
    -0.15643993f, 0.11414889f, 0.06046800f, 0.02272385f, 0.05980335f, -0.02660779f, -0.15938626f, 0.08546755f, 
    0.02474955f, -0.04843873f, -0.00558748f, -0.02197451f, 0.03290716f, -0.10846718f, 0.02552711f, 0.00282602f, 
    -0.14348449f, -0.25998273f, 0.17747878f, 0.42873329f, 0.01383068f, 0.20398054f, -0.04338611f, -0.01444875f, 
    -0.08444058f, -0.01079322f, 0.00232458f, -0.03372098f, 0.03055248f, 0.23132220f, 0.04325900f, -0.09492160f, 
    0.05809996f, -0.07220170f, -0.08893181f, 0.01561115f, -0.05341867f, 0.02645449f, 0.07669196f, -0.07435084f, 
    0.04993625f, 0.05059334f, -0.08219843f, -0.21216330f, -0.04884110f, -0.04032492f, 0.01013512f, -0.06875437f, 
    0.09805852f, -0.04616905f, 0.04384858f, -0.06139671f, 0.18440886f, -0.30753884f, -0.13074353f, -0.07141285f, 
    0.03273581f, -0.07853174f, -0.05210475f, -0.05407930f, 0.00647698f, 0.07554244f, -0.11165091f, -0.01252625f, 
    -0.09366731f, 0.05961933f, 0.06271200f, -0.19166072f, 0.18191569f, 0.06739769f, -0.13338879f, 0.05233594f, 
    0.05030992f, -0.05581768f, 0.08017623f, 0.01012371f, -0.28408372f, 0.21102892f, 0.16564897f, -0.03204942f, 
    0.20552221f, -0.01807397f, -0.00789064f, -0.01571833f, -0.10010277f, -0.02745990f, -0.10346274f, 0.06395490f, 
    -0.06666249f, 0.18680079f, -0.47330204f, -0.14904854f, -0.02454223f, -0.08953163f, 0.04071331f, 0.00044689f, 
    0.02831313f, 0.04053504f, -0.03053715f, -0.00110009f, -0.27258676f, 0.02648297f, -0.04085583f, 0.14804889f, 
    0.01997511f, -0.04241443f, 0.07134209f, 0.03328456f, -0.11759103f, -0.00929063f, 0.08687220f, -0.11111699f, 
    0.15486488f, -0.07554397f, 0.07782627f, -0.10299271f, 0.06272221f, -0.05420408f, 0.02326080f, -0.13930233f, 
    0.03610419f, -0.04963024f, -0.06306929f, -0.11393271f, -0.07577422f, -0.03387357f, -0.04580468f, 0.02610761f, 
    0.09511631f, -0.02171648f, 0.04568257f, -0.09151983f, -0.11374189f, 0.05061962f, 0.05376566f, -0.05519683f, 
    -0.01558025f, 0.09594433f, -0.02514134f, 0.00118465f, 0.03496787f, 0.02176898f, 0.00469396f, 0.07449395f, 
    0.07575608f, -0.07809608f, 0.02781934f, -0.03723544f, 0.16909260f, -0.03916210f, -0.08242811f, 0.06067688f, 
    0.12216117f, -0.13596347f, -0.05085788f, -0.06030990f, -0.11414742f, 0.02023797f, -0.00219766f, 0.00438235f, 
    -0.10934076f, 0.05293451f, 0.00789521f, 0.13203238f, -0.17731296f, 0.11385793f, 0.14373456f, 0.08124059f, 
    0.06872902f, 0.04336967f, -0.02814629f, 0.07067804f, -0.24956794f, 0.16577706f, 0.04437773f, 0.07898089f, 
    -0.08470272f, -0.02078021f, 0.05084164f, 0.08680169f, -0.02024823f, -0.05907557f, 0.03784691f, 0.05499944f, 
    0.38363373f, 0.14331907f, -0.21679392f, 0.05453411f, 0.01090841f, -0.06074004f, -0.02839899f, -0.00731032f, 
    -0.02675812f, -0.00915374f, -0.08057982f, 0.01209740f, -0.11466886f, 0.01714812f, 0.16349627f, -0.04575820f, 
    -0.08484519f, 0.03624280f, -0.03612365f, -0.13614981f, -0.08692811f, -0.07449611f, 0.07612713f, -0.02777190f, 
    -0.08010855f, 0.16903397f, -0.03341059f, 0.13846852f, -0.11312153f, 0.00605436f, -0.11150402f, 0.04609738f, 
    -0.10489788f, 0.04666785f, -0.00510885f, -0.00213971f, -0.14452258f, 0.22136265f, -0.05530376f, 0.03945497f, 
    0.00551764f, 0.04681556f, -0.02263460f, -0.09872226f, -0.06578977f, -0.03267489f, 0.03563216f, -0.06853779f, 
    -0.17031050f, -0.02105843f, -0.09514254f, -0.04010787f, 0.04518743f, 0.03967940f, 0.15034381f, 0.05467804f, 
    0.09484578f, -0.01508181f, 0.00776477f, 0.00857944f, 0.21879794f, -0.02560007f, -0.19880790f, 0.14982806f, 
    -0.04841566f, -0.00262650f, -0.03743734f, 0.13018791f, 0.01037662f, -0.04177160f, 0.03440703f, 0.01891518f, 
    0.22427151f, -0.09895869f, -0.10600945f, -0.05416297f, 0.05383372f, 0.03833731f, -0.10867570f, -0.13172999f, 
    -0.08625041f, 0.08971469f, 0.06775931f, 0.05558099f, 0.07740432f, 0.00827032f, 0.04119430f, 0.05278478f, 
    -0.02065712f, -0.00974478f, 0.05470022f, -0.05276993f, -0.00092814f, -0.01180621f, -0.04512982f, -0.07108470f, 
    -0.08255686f, 0.12796655f, -0.01680712f, 0.01073358f, 0.13137923f, 0.07461338f, 0.08247278f, 0.01914898f, 
    0.06220480f, 0.06715485f, -0.03492311f, 0.03578452f, 0.02009801f, -0.07128440f, -0.01283537f, 0.11550079f, 
    -0.11150303f, -0.03003494f, 0.00715843f, 0.05790477f, -0.01345967f, 0.05914282f, -0.08282271f, -0.04223425f, 
    -0.17821325f, -0.08599757f, -0.16164465f, 0.05172590f, -0.10368853f, -0.03416684f, 0.00818370f, -0.06067500f, 
    -0.01926426f, -0.00514260f, -0.02418175f, 0.00570053f, -0.08886421f, 0.10669872f, -0.17207317f, 0.07087845f, 
    0.21693407f, -0.05153941f, 0.00653020f, 0.05713653f, -0.01403534f, -0.00175302f, 0.00820601f, -0.02416885f, 
    0.11366154f, -0.01678027f, -0.15389083f, 0.23860355f, 0.04160271f, 0.07427315f, 0.07490537f, 0.11753873f, 
    0.14391871f, 0.14887470f, -0.00895425f, 0.02129857f, 0.14020252f, -0.17188115f, -0.04654276f, 0.03432583f, 
    -0.13436390f, -0.01420110f, -0.04935881f, -0.01102713f, -0.01971435f, -0.16258183f, -0.04256899f, -0.12830600f, 
    0.05145063f, 0.27558872f, -0.10676185f, -0.01859076f, 0.08918498f, 0.01390994f, -0.09781422f, 0.04389282f, 
    0.12875296f, 0.06218353f, 0.00927436f, -0.04458607f, 0.05776501f, -0.04435147f, -0.11092112f, -0.02811663f, 
    0.07629439f, 0.04895801f, -0.02440438f, -0.05740862f, -0.01989209f, 0.02592838f, 0.08622525f, 0.08776377f, 
    0.03165150f, 0.06232611f, -0.17190519f, 0.03873361f, -0.09356261f, -0.00155983f, 0.14837763f, -0.02017837f, 
    0.00140513f, 0.05499060f, -0.01366180f, -0.13144356f, -0.22920008f, -0.10993885f, -0.11266939f, -0.26363897f, 
    -0.01195634f, -0.05067311f, 0.06145678f, 0.09770202f, -0.05834158f, -0.02331487f, -0.05871615f, -0.10404944f, 
    0.19643676f, -0.11940442f, -0.05890239f, -0.00274959f, 0.10455342f, 0.03610342f, -0.03138551f, 0.09298580f, 
    -0.13191362f, 0.01835309f, -0.04700186f, -0.05545854f, 0.04576058f, 0.03652880f, -0.00173497f, -0.21964009f, 
    -0.17224872f, 0.01071996f, 0.09062059f, -0.00478290f, -0.00301401f, 0.08564446f, -0.05007420f, -0.09821086f, 
    -0.26501635f, 0.19347176f, -0.11760982f, -0.03256601f, 0.00858138f, -0.05598722f, 0.04379424f, 0.11339574f, 
    -0.02160582f, 0.02713306f, 0.06635834f, 0.06160488f, -0.37247378f, -0.32506123f, 0.00724027f, -0.12878191f, 
    0.07222591f, -0.00741244f, 0.05240789f, 0.03742084f, -0.07900276f, -0.07740705f, -0.19159901f, -0.05077437f, 
    0.48830009f, 0.00594780f, -0.13014014f, -0.01054620f, -0.00140436f, -0.04664083f, -0.01460219f, 0.00990096f, 
    0.05080324f, -0.02970185f, 0.03110218f, -0.00512525f, -0.32218927f, 0.12016529f, -0.17574346f, 0.01601051f, 
    0.06732510f, -0.08845796f, 0.06051434f, 0.10767965f, 0.06209935f, -0.00063490f, -0.00423834f, -0.11834752f, 
    0.05601789f, 0.11459625f, -0.11552292f, 0.09084741f, 0.03900116f, -0.03623739f, 0.01349807f, 0.09067979f, 
    -0.05701750f, 0.07769886f, -0.01841914f, 0.06304833f, -0.20201229f, 0.14469568f, -0.09578563f, -0.07263506f, 
    -0.07902149f, -0.03895953f, -0.09613433f, 0.09237949f, 0.04506515f, -0.08811532f, -0.06304531f, -0.11994564f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.09747888f, 0.01799167f, -0.02880369f, 0.02525900f, -0.00532034f, 0.03323418f, -0.00016019f, -0.02594930f, 
    -0.03581079f, -0.01002300f, 0.06299751f, 0.02794429f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
