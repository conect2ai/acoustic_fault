#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.12483379f, 0.87778199f, -0.58283806f, -0.52611458f, 0.63276505f, 0.48867664f, 0.10909403f, 0.73419899f, 
    0.05126425f, 1.21106362f, -0.24638578f, 0.21709709f, -0.60593718f, -1.09390545f, -1.36470735f, -0.18009910f, 
    0.18740763f, 0.35362017f, -1.35673904f, -0.31505042f, -0.00106335f, 0.85319304f, 0.04100418f, 0.29679263f, 
    0.06813259f, 0.75071597f, -0.44569409f, 0.66897094f, -0.25320303f, -0.28014043f, 0.90494460f, -0.78425372f, 
    -0.07884420f, -0.81223565f, -0.12929428f, -1.13897121f, -2.16644859f, 1.52858329f, 0.11294966f, -0.64997059f, 
    -0.72747678f, 1.03335702f, -0.47942153f, -0.64034390f, -0.61024040f, -0.37782428f, 0.35205215f, -1.02526402f, 
    -0.95591766f, -0.82314277f, -0.81711245f, -0.65968603f, -0.57338315f, -0.72049767f, 0.00050444f, 1.15823257f, 
    -0.23138219f, 0.35381424f, -0.45327246f, -0.18316957f, -0.26887226f, 0.06926765f, 0.40344131f, -1.87779784f, 
    -1.13185322f, 0.00418346f, 1.48368096f, 0.97412550f, -0.53609633f, -0.12405016f, -0.35423046f, -0.28185526f, 
    0.79363489f, 0.86863017f, 0.63341916f, -0.95110196f, 0.48801985f, 0.31047636f, -0.28485861f, 0.21087997f, 
    0.26509956f, -0.97702461f, -1.58876503f, -0.68954080f, -0.35812789f, -0.44806284f, 0.36370882f, 0.87719375f, 
    0.13203129f, 0.60432625f, 0.98242199f, -1.59800911f, 0.14675923f, -0.82864010f, -0.85823596f, -0.95711946f, 
    0.30704287f, -0.88407409f, -0.37091541f, 1.17021203f, 0.10181262f, -1.28383923f, -0.19884406f, 0.16507824f, 
    -0.26217267f, -0.00749111f, 0.24387766f, 0.45797575f, -0.03825249f, 0.30985749f, 0.34989464f, 0.37396470f, 
    0.55885553f, 0.71736521f, 0.28367785f, 0.09660248f, 0.05180208f, 0.53955460f, -0.30673984f, -0.98374605f, 
    0.00530165f, 0.10697518f, -0.74158275f, 0.69181663f, 0.28248000f, 0.52866572f, -1.42869520f, -1.25771630f, 
    -1.17933178f, -0.06663991f, -0.64618760f, -0.08692504f, -0.68118382f, -0.60432094f, -0.58240098f, -0.57802087f, 
    -0.49767232f, 1.18438721f, -0.87233776f, 0.01980115f, -0.80366993f, 0.67044032f, 0.51040351f, 0.18833879f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.10801735f, 0.40170303f, -0.02288732f, 0.00042582f, 0.27947962f, -0.25997820f, 0.82946694f, 0.34672987f, 
    0.03006381f, 0.97416973f, 0.20601451f, 0.28207266f, -0.18828259f, 0.47130248f, 0.11848770f, 0.42220029f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.02242051f, 0.01977614f, 0.06088535f, 0.06387628f, 0.02763388f, 0.01584814f, -0.01626279f, 0.03062008f, 
    0.09081648f, 0.11142688f, 0.09122654f, -0.30543151f, -0.39587682f, -0.24127619f, -0.18096475f, 0.00319381f, 
    -0.01861045f, 0.04068867f, -0.10741246f, -0.00952761f, 0.00709976f, 0.09139948f, -0.23925708f, -0.53650546f, 
    -0.33541590f, -0.04824432f, -0.11748371f, -0.26846808f, -0.08816846f, -0.07123237f, -0.06310377f, -0.03644304f, 
    0.03213504f, 0.06962583f, -0.03150032f, 0.05002742f, -0.05487295f, 0.01345560f, -0.18440615f, 0.00842940f, 
    0.03659676f, -0.11026859f, 0.05104279f, -0.09789636f, 0.24013019f, 0.03238580f, 0.14233691f, 0.10442137f, 
    0.04888076f, 0.15828581f, -0.09535237f, -0.02320928f, -0.00499063f, 0.08254760f, -0.01413035f, -0.01358531f, 
    0.01147391f, 0.14230290f, -0.07743645f, 0.05660103f, 0.23602797f, 0.12234980f, -0.09364074f, -0.15271299f, 
    0.05708372f, -0.04175708f, -0.03061073f, -0.04308360f, -0.02484080f, 0.21326089f, -0.06735247f, 0.03049657f, 
    0.00024382f, 0.04351524f, 0.07619175f, -0.22797523f, 0.00068353f, 0.14795093f, 0.07993601f, 0.17170222f, 
    -0.30503321f, 0.32796028f, 0.69231856f, -0.14913447f, 0.10975326f, -0.43680114f, -0.16815358f, -0.03899378f, 
    0.00218498f, -0.40025470f, 0.13473094f, -0.01503122f, -0.00715963f, -0.16139926f, 0.05236620f, -0.06942599f, 
    -0.02392162f, -0.07571953f, -0.29707786f, 0.03701149f, 0.32127264f, 0.40292206f, 0.29445416f, -0.31132868f, 
    -0.25953075f, 0.03641952f, 0.24359372f, 0.21895033f, -0.06028973f, 0.10856961f, -0.00222953f, -0.09205025f, 
    -0.04481857f, 0.01030649f, -0.05998612f, -0.00943779f, -0.06775291f, 0.06132096f, 0.03084257f, 0.18568808f, 
    -0.53621012f, -0.47643346f, -0.38110271f, 0.01035953f, -0.37281832f, -0.04201053f, -0.21670297f, -0.11991411f, 
    0.04703405f, -0.08075035f, -0.11994930f, 0.04148880f, -0.15285067f, 0.06939217f, -0.14235450f, -0.31556487f, 
    -0.06124137f, -0.14564118f, -0.05634571f, -0.19116023f, 0.68171388f, 0.11592665f, -0.50256306f, -0.36100996f, 
    -0.14318374f, -0.06702933f, 0.09792183f, -0.04073378f, 0.01374499f, 0.05098206f, -0.05354011f, 0.00613015f, 
    -0.21262613f, 0.05491147f, 0.10177421f, -0.03367153f, 0.12637594f, 0.12013630f, -0.05235736f, 0.01564933f, 
    -0.19700958f, -0.21946058f, -0.09539507f, 0.13523604f, 0.04190592f, 0.03752913f, 0.08872856f, -0.07192741f, 
    -0.00282522f, -0.04651800f, 0.03416069f, 0.08234553f, 0.02929472f, 0.04292721f, 0.09608681f, 0.06931401f, 
    0.07286093f, -0.08565889f, -0.06929944f, 0.01942122f, 0.43486941f, 0.48491910f, 0.15609308f, -0.36917031f, 
    -0.01189952f, 0.18416896f, 0.06289621f, 0.21258332f, 0.06519251f, -0.21873571f, -0.03228445f, -0.09568046f, 
    -0.09951863f, 0.05620446f, 0.08238678f, -0.03802624f, -0.05285780f, -0.09688609f, -0.02811418f, -0.05755694f, 
    0.38866204f, 0.15354638f, 0.22623974f, -0.91992843f, -0.00986282f, 0.01420769f, 0.09401445f, -0.05497708f, 
    -0.14574322f, -0.01504326f, 0.00348625f, 0.09475385f, 0.07314071f, -0.03808464f, -0.06528144f, -0.06815975f, 
    -0.06522771f, -0.08356702f, 0.03124162f, 0.16443445f, -0.12146819f, 0.01423830f, -0.36138266f, 0.13548091f, 
    -0.15355776f, 0.03433080f, -0.04698376f, 0.10743596f, 0.11544145f, -0.04233884f, -0.28191876f, -0.17093112f, 
    -0.15980186f, 0.01975780f, 0.01431429f, -0.05428858f, -0.02988369f, -0.10738526f, -0.01116073f, -0.13789791f, 
    -0.04288682f, -0.06296229f, 0.02519609f, 0.10002507f, 0.04167100f, -0.00366346f, 0.10676677f, 0.08039142f, 
    0.06750810f, 0.12676750f, -0.20569749f, -0.27330416f, -0.24998294f, -0.17645605f, -0.38092595f, 0.00520548f, 
    -0.03105816f, 0.05728539f, 0.01990156f, 0.10657546f, 0.23986419f, 0.35457903f, -0.24417301f, -0.00823910f, 
    -0.00961910f, 0.07829391f, -0.00699240f, 0.15569904f, -0.15816806f, -0.10034645f, -0.07432806f, 0.03778382f, 
    -0.12987444f, 0.03764116f, 0.00632616f, -0.12820935f, -0.06523325f, -0.14804645f, -0.03241186f, -0.03259864f, 
    0.55858624f, 0.22519408f, 0.07671561f, -0.32507259f, -0.05677952f, 0.23964159f, 0.22285171f, 0.20000470f, 
    -0.00104941f, 0.02517684f, 0.04832347f, -0.04356049f, 0.01920999f, -0.10919428f, -0.01726004f, 0.04924408f, 
    -0.23033047f, -0.08782044f, -0.03671118f, -0.11193012f, 0.20323558f, 0.31593040f, 0.21780859f, -0.24487814f, 
    -0.00956646f, -0.09279516f, -0.15261295f, 0.03521355f, -0.10969237f, 0.12501267f, 0.03594885f, 0.06804264f, 
    -0.24190912f, -0.05070400f, -0.05999647f, 0.01860919f, -0.03737253f, -0.22096702f, -0.29377744f, -0.24814829f, 
    -0.02697811f, -0.07239110f, 0.18013330f, 0.00630935f, -0.01717304f, -0.11148452f, -0.06168048f, -0.08563533f, 
    -0.09166565f, 0.00357384f, 0.29327527f, 0.09669752f, -0.13301423f, 0.10870431f, 0.05149995f, -0.24650836f, 
    -0.01875794f, -0.11956172f, -0.02543169f, 0.05960818f, -0.15158989f, 0.23595697f, -0.40875626f, -0.13204637f, 
    -0.47819489f, -0.07336008f, -0.24071673f, -0.25747567f, -0.09048809f, 0.25932556f, -0.08974053f, -0.04521237f, 
    0.03011518f, 0.05292106f, 0.05134625f, -0.00601605f, 0.07519482f, -0.14468786f, 0.16464239f, -0.00230853f, 
    -0.02877686f, -0.16704449f, -0.26245743f, 0.00167236f, -0.09996331f, -0.08852069f, -0.02733775f, 0.09845832f, 
    0.16708376f, -0.13994497f, -0.30337670f, -0.09409235f, -0.27541944f, 0.06342598f, -0.00283926f, -0.09990395f, 
    -0.00855723f, -0.04473833f, 0.01561153f, -0.09322829f, 0.88591349f, 0.09890885f, -0.50473124f, 0.00538707f, 
    -0.24406818f, 0.02378389f, -0.10707910f, -0.13322185f, 0.00637082f, -0.22477689f, 0.15805022f, 0.07122301f, 
    -0.10663521f, -0.03457132f, 0.07443157f, 0.03400231f, -0.50319374f, -0.39606783f, -0.01448443f, -0.08671803f, 
    -1.69306064f, -0.32304797f, -0.04580821f, -0.31212732f, -0.05681055f, 0.25067595f, -0.06283562f, -0.11271001f, 
    -0.11709429f, -0.04767520f, 0.00028667f, 0.08232341f, -0.14054169f, -0.10490817f, 0.16918437f, 0.05884296f, 
    -0.19697683f, 0.03540462f, -0.10254941f, -0.21304905f, -0.23618352f, 0.20947753f, -0.03065051f, 0.06440184f, 
    -0.20692976f, 0.32098210f, -0.08894403f, -0.22148226f, -0.20214912f, 0.10313262f, 0.00426168f, 0.01468720f, 
    0.04049844f, 0.05059557f, 0.06861270f, -0.22154626f, -0.06198102f, -0.00063329f, -0.26352209f, -0.10607156f, 
    0.13320443f, 0.12867422f, -0.07417688f, 0.08304586f, 0.16273262f, 0.21168925f, -0.08308130f, -0.12307096f, 
    -0.01042553f, -0.01414222f, -0.11266226f, -0.02578617f, 0.10652667f, 0.06313061f, -0.04691532f, -0.01260405f, 
    0.23248217f, -0.14553414f, 0.03480299f, 0.08288845f, 0.61655164f, -0.00275425f, 0.05881832f, -0.01576900f, 
    0.07781397f, 0.25908169f, 0.02362401f, 0.08612367f, 0.17178670f, -0.14143462f, 0.26041302f, -0.06252074f, 
    0.00091257f, -0.14558144f, -0.14626469f, 0.18124808f, -0.08520400f, -0.14567073f, 0.04724238f, -0.09530897f, 
    0.31750932f, 0.13783228f, 0.13295150f, 0.05485360f, 0.14271250f, -0.01669591f, -0.04126612f, -0.00846323f, 
    -0.03363878f, -0.03302707f, 0.02090346f, -0.02932039f, 0.04123334f, 0.05615908f, -0.03820008f, -0.07455775f, 
    0.17060398f, -0.18014450f, 0.09363285f, -0.01513156f, -0.55887455f, 0.00646051f, -0.38251531f, 0.14690404f, 
    0.02982963f, 0.01356964f, 0.30134416f, 0.33521348f, -0.10348160f, 0.23194644f, -0.15167221f, 0.00146767f, 
    0.11133056f, 0.03558328f, -0.03849987f, -0.00052062f, 0.05026613f, 0.01706493f, -0.10673551f, 0.01194820f, 
    -0.48453742f, 0.19181961f, -0.28584445f, -0.29041308f, 0.06985892f, 0.05024800f, -0.30897924f, -0.02892874f, 
    -0.02478573f, 0.02355512f, -0.00805163f, -0.02135063f, 0.18169430f, -0.00920895f, 0.13232037f, 0.00843264f, 
    -0.07896452f, 0.19576827f, -0.27959105f, -0.26431841f, 0.22370589f, -0.19039664f, -0.24458718f, -0.06968141f, 
    -0.34313297f, -0.01572794f, -0.04500440f, 0.03435147f, -0.07144973f, 0.09878165f, 0.18698889f, 0.04727107f, 
    0.01564336f, 0.05198005f, 0.04216037f, -0.01764364f, 0.00084310f, -0.00006686f, 0.12089288f, 0.11324563f, 
    0.13911393f, -0.01354102f, 0.18491748f, 0.12463368f, 0.09996659f, -0.06724525f, -0.14789103f, -0.00071491f, 
    -0.03791175f, -0.06088800f, 0.26331314f, 0.01981081f, -0.13092208f, -0.03320910f, 0.07197309f, -0.11893634f, 
    -0.15150307f, -0.06427762f, -0.02958474f, -0.11353166f, -0.12284908f, -0.22519389f, -0.27920452f, 0.05936705f, 
    -0.22627729f, 0.03655813f, 0.06267699f, 0.13242868f, 0.01758893f, -0.06123256f, 0.33067331f, -0.03404244f, 
    0.02650471f, 0.06012080f, -0.00076655f, 0.07334439f, 0.03403706f, 0.05883468f, 0.08882049f, 0.12321690f, 
    0.23772439f, 0.46857062f, 0.41321045f, 0.31864822f, -0.03720821f, 0.09897085f, 0.02967937f, 0.20582765f, 
    0.24761732f, -0.03192301f, -0.02082777f, -0.01166388f, 0.01270770f, -0.21390203f, 0.05834775f, -0.02901554f, 
    0.03660858f, -0.07712602f, -0.14237311f, 0.09114569f, -0.33153591f, 0.14566408f, -0.00896220f, -0.03470339f, 
    0.30574730f, -0.15859495f, 0.18747741f, -0.01028332f, 0.42241964f, 0.15909404f, -0.05757067f, 0.01356247f, 
    0.13019298f, 0.06868689f, 0.08434027f, -0.04987550f, -0.05178739f, 0.03975520f, 0.08789119f, -0.01421258f, 
    -0.05536245f, -0.03768888f, 0.05694557f, -0.02723159f, 0.05245813f, 0.02450871f, 0.01592253f, 0.01305646f, 
    0.05471786f, 0.01905539f, 0.02584667f, -0.15451474f, -0.03576556f, -0.02454820f, 0.11083379f, 0.04848883f, 
    -0.11700649f, 0.01244431f, 0.07373782f, -0.17573214f, -1.75383008f, -0.32240248f, 0.32358715f, -0.57785660f, 
    -0.34619388f, 0.05385897f, 0.12398053f, -0.14925602f, -0.20906195f, -0.22589424f, 0.01371321f, 0.00980840f, 
    0.05124307f, -0.05008039f, -0.04691607f, -0.00072434f, -0.00360084f, 0.13365227f, -0.07631911f, 0.09365140f, 
    0.15195736f, -0.16413775f, 0.14555722f, 0.11199772f, 0.28281444f, 0.05033499f, -0.06693397f, 0.04727579f, 
    0.17740133f, -0.21073399f, -0.09256317f, 0.11222254f, -0.14966050f, 0.08276744f, -0.03826126f, 0.10364835f, 
    -0.10462724f, 0.00783660f, 0.10246871f, -0.02908703f, -0.44707865f, -0.15484419f, -0.03042918f, -0.08007870f, 
    -0.33199182f, 0.14618017f, -0.01866329f, -0.10696310f, -0.02555997f, 0.07773389f, -0.05176175f, 0.01775888f, 
    -0.04573378f, -0.00235839f, -0.00894092f, 0.33398128f, 0.13296998f, 0.38225952f, 0.35838091f, 0.00415011f, 
    0.28785893f, 0.04485520f, -0.59185821f, 0.12928420f, -0.02624599f, 0.10732260f, 0.14899708f, -0.09168220f, 
    -0.13861036f, 0.26037475f, -0.16615599f, -0.07112121f, 0.01505374f, -0.02213820f, -0.12973821f, 0.11137321f, 
    0.07923788f, 0.18220089f, 0.18035205f, 0.18857193f, -0.61991078f, -1.37817001f, -0.30726132f, -0.21099272f, 
    -0.33533987f, 0.08082702f, -0.05647159f, 0.06910060f, -0.05399216f, -0.23849502f, -0.09849988f, -0.03165621f, 
    -0.05367697f, -0.09296821f, 0.08166989f, -0.09554099f, -0.01401887f, -0.23302104f, -0.03713167f, 0.24025108f, 
    -0.00879643f, 0.01683886f, 0.23047344f, -0.26659921f, 0.23617691f, 0.04220327f, -0.08308128f, -0.08342318f, 
    -0.05553273f, 0.09283505f, 0.18141356f, 0.03357451f, 0.19335920f, -0.06013226f, 0.08139632f, 0.04806704f, 
    0.13401712f, -0.25166371f, 0.00381723f, 0.07788111f, -0.22231670f, -0.63769430f, 1.12540412f, 0.54496622f, 
    0.55504805f, -0.00971938f, -0.09713367f, 0.00774917f, 0.39686468f, -0.23724157f, 0.01672351f, 0.03006344f, 
    0.01720532f, -0.13684003f, -0.05092734f, 0.08444378f, 0.02905844f, -0.03395648f, 0.02738173f, 0.00095554f, 
    -0.35683233f, -0.15847526f, -0.02850510f, -0.19908820f, 0.11832666f, -0.12376502f, -0.06277970f, -0.02974843f, 
    -0.00055151f, 0.11913583f, -0.00459137f, -0.10224676f, -0.04001234f, -0.00521292f, -0.05079339f, -0.10868154f, 
    -0.20793873f, -0.19225095f, 0.00193638f, -0.06891207f, 0.02770112f, 0.11452330f, -0.07937887f, 0.16304286f, 
    0.36594263f, -0.00369520f, -0.04014112f, -0.05205594f, 0.28058776f, -0.08915613f, 0.02291459f, 0.08833463f, 
    0.11193516f, 0.02486191f, 0.04902939f, -0.06283136f, 0.07036284f, 0.02414169f, -0.11914656f, 0.05181810f, 
    -0.92612517f, 0.39333546f, -0.40148497f, 0.14781179f, -0.88865608f, 0.01832230f, 0.03331145f, -0.05995295f, 
    -0.04649838f, 0.00570478f, -0.06924853f, -0.02992584f, -0.09895869f, 0.01749867f, -0.17623079f, -0.06204051f, 
    0.00709934f, -0.04705456f, -0.07561763f, 0.17154536f, -0.32737878f, 0.10744667f, 0.02355780f, -0.00728570f, 
    0.02933800f, -0.06576997f, 0.05895992f, -0.31113577f, -0.38695794f, -0.08262135f, 0.22770807f, -0.05081194f, 
    0.04504697f, -0.01032164f, 0.04164743f, 0.04481933f, 0.05703074f, -0.02647548f, 0.10598265f, -0.25837353f, 
    -0.13486360f, -0.17602836f, -0.11405417f, -0.02825908f, 0.06547852f, 0.00656361f, 0.01774838f, 0.11997638f, 
    0.10510678f, 0.08355503f, -0.19458151f, -0.02493589f, 0.26010621f, 0.26028317f, 0.03914031f, 0.06729456f, 
    -0.01377057f, 0.04318043f, -0.07431383f, -0.13644198f, -0.12584095f, -0.03849795f, -0.06152898f, -0.09507598f, 
    0.06414174f, 0.00024864f, -0.16569676f, -0.23159863f, 0.20903255f, -0.43639299f, 0.19268307f, 0.09772217f, 
    0.14126474f, 0.00042065f, -0.02809133f, 0.05568805f, 0.04899266f, -0.08747165f, 0.03969982f, -0.16106157f, 
    -0.11606087f, -0.14840680f, 0.31786400f, 0.65503198f, 0.26454112f, 0.07613739f, -0.09263511f, 0.22969857f, 
    0.05121043f, 0.13078789f, -0.04744567f, -0.03456044f, 0.05026132f, 0.02703022f, 0.02655961f, 0.00211599f, 
    0.03433920f, -0.02161694f, -0.19573756f, 0.06625861f, 0.21905091f, -0.14903906f, -0.16566055f, -0.12480099f, 
    -0.02052323f, 0.11524487f, 0.19173203f, -0.59958434f, -0.05646357f, 0.13569707f, 0.03577655f, -0.24620049f, 
    0.02194339f, 0.07913201f, -0.16727234f, 0.08439878f, 0.01202971f, -0.06754769f, -0.04862969f, -0.08341721f, 
    -0.35628843f, -0.01098410f, -0.47044146f, 0.07059649f, -0.23639287f, 0.04146603f, -0.25707859f, -0.00133370f, 
    -0.38461891f, 0.08851111f, -0.41239074f, 0.11056090f, -0.01718661f, -0.00315931f, 0.22469680f, 0.32429719f, 
    -0.06019121f, 0.14624369f, -0.17647937f, 0.09370030f, -0.30596584f, -0.21813235f, 0.17156880f, 0.37230790f, 
    0.37159944f, -0.00527490f, -0.14168286f, 0.32962391f, -0.11590961f, 0.02386889f, 0.04704848f, 0.04932517f, 
    -0.14320758f, -0.09445745f, 0.08888396f, -0.09726721f, -0.18843381f, -0.11135022f, -0.07300970f, -0.10372558f, 
    -0.02760654f, 0.78446591f, -0.66213948f, -0.31866062f, 0.21593821f, 0.52423376f, -0.05619977f, 0.18713076f, 
    0.38663468f, -0.37071770f, -0.28748718f, 0.01120073f, -0.09753962f, 0.08378933f, 0.03212247f, 0.02525907f, 
    0.08121586f, -0.10778461f, 0.13272487f, 0.03767564f, -0.19265512f, -0.06239656f, 0.14381365f, 0.01233342f, 
    -0.17487684f, 0.08953966f, 0.20546058f, 0.24208213f, 0.31094778f, 0.20082629f, -0.10538018f, 0.18698175f, 
    0.05505829f, -0.07080254f, 0.08837479f, 0.19526592f, -0.02370124f, 0.33521786f, -0.05678168f, 0.14129707f, 
    1.10821486f, 0.08907054f, -0.05544341f, -0.52722657f, 0.05898875f, -0.00523060f, 0.10526867f, 0.01850276f, 
    -0.06062035f, -0.09992375f, 0.04002920f, -0.14163014f, 0.02720869f, 0.02885529f, -0.11986957f, 0.06951478f, 
    -0.10002834f, 0.03246843f, 0.04179396f, -0.02600172f, 0.23346613f, -0.32210341f, -0.20868972f, -0.11611556f, 
    0.42875716f, -0.05855256f, 0.09465849f, -0.07573457f, 0.03839628f, 0.09625676f, -0.09912290f, -0.05693118f, 
    -0.11042474f, -0.22693746f, -0.03844724f, 0.06262724f, -0.04593723f, -0.00973358f, -0.05609534f, 0.02994786f, 
    -0.90957332f, -0.06857962f, 1.01133585f, -0.71565366f, 0.36097515f, -0.25652093f, 0.04581457f, -0.53956914f, 
    -0.41263679f, 0.05930716f, 0.13814074f, -0.20224385f, -0.13001877f, -0.17893453f, -0.02353009f, -0.03918874f, 
    -0.08204289f, -0.02234977f, -0.27358234f, -0.12155917f, -0.24467082f, 0.69215286f, -0.18554576f, -0.17840883f, 
    0.34885460f, 0.32033083f, 0.13221310f, -0.02563250f, -0.02916653f, 0.01002528f, -0.41488555f, -0.04015915f, 
    -0.00581201f, -0.03387691f, 0.19414832f, -0.21297289f, 0.07700982f, -0.06328578f, 0.08620516f, -0.06072314f, 
    -0.52158654f, -0.35105225f, 0.33975315f, -0.15675212f, -0.37180045f, -0.14014958f, -0.44096673f, 0.20131767f, 
    -0.13692512f, -0.24949794f, 0.05350026f, 0.15376960f, 0.22369961f, 0.03565190f, 0.04522488f, -0.00744868f, 
    0.09721164f, -0.14429940f, -0.05094096f, -0.19317977f, -0.08130243f, -0.11810830f, -0.13039464f, -0.39906153f, 
    0.28655633f, 0.01023033f, 0.06305731f, -0.11867876f, 0.09309699f, -0.07706619f, -0.13965963f, 0.02278425f, 
    -0.00543740f, 0.02344016f, 0.03712026f, -0.05117053f, -0.10580742f, 0.20751010f, -0.06858248f, 0.04195889f, 
    -0.68517554f, -0.01299010f, -0.30706444f, 0.27102304f, 0.26100349f, -0.01300183f, 0.06380472f, -0.06703504f, 
    -0.14844894f, 0.02944045f, -0.15106635f, -0.06850104f, -0.09576623f, -0.10567480f, -0.04859482f, 0.00862489f, 
    0.02963091f, 0.02876313f, -0.22034787f, 0.04021405f, -0.38173810f, 0.48215580f, -0.03696267f, 1.04552507f, 
    0.55905473f, 0.13029365f, -0.22127664f, 0.01338949f, -0.11033381f, -0.09787186f, 0.01807685f, 0.02566948f, 
    -0.05569524f, -0.27193424f, -0.29900035f, -0.07239925f, -0.04368884f, 0.19846712f, -0.03757780f, -0.39868632f, 
    -0.33527249f, -0.35358381f, -0.46786228f, 0.02059743f, -0.52564156f, 0.28297806f, 0.15462238f, 0.27387860f, 
    0.13872370f, -0.00045358f, -0.34941098f, -0.13957970f, 0.06856345f, -0.23068725f, -0.04051638f, 0.01922134f, 
    0.14923628f, -0.13052286f, -0.28201270f, 0.02075726f, -0.31164771f, 0.22765088f, -0.49635616f, 0.07104857f, 
    0.23507139f, 0.18675581f, 0.06977756f, 0.15861952f, -0.08087820f, 0.03085731f, 0.00943710f, -0.04514291f, 
    0.20535819f, 0.02289534f, -0.28325468f, 0.33899420f, -0.20038670f, 0.07836811f, 0.11911013f, -0.15991203f, 
    -0.06948157f, -0.04014425f, -0.33900961f, -0.14205253f, 0.46630457f, 0.09877164f, -0.01090270f, -0.07399237f, 
    0.00512742f, -0.06917413f, 0.03530204f, 0.09812301f, -0.07912394f, 0.21741457f, 0.14268345f, -0.01808786f, 
    0.11258076f, 0.32372701f, -0.11527486f, 0.09024177f, 0.12699555f, 0.01530973f, -0.31161830f, -0.27506512f, 
    0.22334282f, 0.12070305f, 0.18567647f, -0.06794669f, 0.06773321f, 0.12155920f, 0.17949778f, -0.12988110f, 
    -0.12321731f, -0.10919549f, 0.07122815f, 0.08017508f, 0.02019262f, 0.06876820f, -0.13301523f, 0.06201188f, 
    0.01999615f, -0.00517532f, -0.04397881f, -0.08937547f, -0.04205713f, 0.15317050f, 0.02445028f, 0.11127573f, 
    0.09898141f, 0.01334642f, 0.02444078f, -0.16144538f, -0.06444567f, -0.33515316f, 0.04287903f, 0.16397934f, 
    0.05622076f, -0.11017004f, -0.14773506f, -0.01633078f, 0.38051450f, 0.25353962f, 0.29546753f, -0.02810748f, 
    0.46118227f, 0.05131041f, 0.14432997f, 0.02901378f, 0.20789413f, 0.24021854f, -0.02188142f, 0.04133884f, 
    -0.07740626f, -0.03677810f, -0.04587664f, -0.01244675f, -0.01998481f, -0.21801661f, -0.05244882f, -0.15041322f, 
    0.41123161f, -0.46517032f, -0.20899047f, 0.04830718f, -0.09663160f, -0.17222996f, -0.17470713f, 0.01120936f, 
    -0.09986316f, 0.30329168f, 0.16740780f, -0.00089600f, -0.13349529f, -0.18712796f, 0.08432212f, 0.13366130f, 
    0.01189138f, 0.10288452f, -0.02625304f, -0.08454313f, -0.15222526f, 0.05349365f, 0.12281111f, -0.10036597f, 
    -0.20338303f, -0.05703506f, 0.09779465f, -0.03382320f, 0.04937469f, 0.08610676f, 0.02675048f, 0.01160348f, 
    -0.03929804f, -0.02644359f, -0.08694207f, -0.10160093f, 0.18703511f, 0.09718513f, -0.04060573f, 0.25888342f, 
    0.37347451f, -0.39674386f, -0.34222317f, 0.30776712f, -0.09345862f, 0.09669980f, -0.22770041f, 0.08242313f, 
    0.12346304f, 0.00302816f, 0.08666442f, 0.00574901f, 0.09527047f, 0.09408583f, -0.11158182f, -0.13295253f, 
    0.09158517f, 0.03170788f, -0.18464398f, 0.08169611f, -0.04991690f, 0.16538034f, 0.22045888f, 0.24272013f, 
    0.08353510f, -0.16915509f, 0.15525728f, -0.07412685f, 0.05301500f, 0.12919797f, 0.05012311f, -0.02449810f, 
    -0.03229347f, 0.03289348f, 0.00326078f, 0.07632772f, 0.18181308f, -0.06824259f, 0.03788783f, 0.28796273f, 
    0.27334619f, -0.06656814f, -0.35124367f, -0.07064278f, -0.13189821f, -0.17508641f, -0.01928739f, -0.01097624f, 
    0.03958322f, -0.16665722f, 0.00942245f, -0.01253028f, -0.12363040f, -0.18361348f, 0.02110891f, 0.01291809f, 
    -0.21036007f, 0.16914420f, -0.07094093f, -0.12226655f, -0.09297591f, -0.56166655f, 0.18347244f, 0.24030964f, 
    -0.00116642f, -0.43308887f, -0.12827912f, 0.05557620f, -0.32068360f, 0.16650371f, -0.13449168f, 0.05890523f, 
    -0.00015189f, -0.13885967f, -0.06628407f, -0.07931990f, -0.00111803f, 0.12363894f, -0.17349139f, 0.00867142f, 
    -0.00911077f, -0.03755037f, -0.13970783f, -0.04371123f, 0.11803632f, 0.12870827f, 0.05206910f, 0.01761967f, 
    0.07230630f, -0.05325038f, 0.23110476f, 0.07759970f, 0.04608192f, 0.00001013f, 0.14526585f, 0.06876562f, 
    -0.12044817f, 0.13096453f, -0.11217807f, 0.03290255f, 0.29492560f, 0.05458406f, 0.14183602f, 0.24331985f, 
    0.06038422f, -0.11989529f, -0.16758345f, -0.13239160f, -0.20971026f, -0.17857747f, 0.12845926f, -0.01058239f, 
    -0.07173911f, 0.08251261f, 0.07602715f, 0.03610995f, -0.10476649f, -0.10366248f, 0.05942024f, -0.11402630f, 
    0.38088608f, 0.17745267f, 0.44714659f, 0.01906377f, 0.06554283f, -0.10475911f, 0.13536827f, -0.06922037f, 
    0.09677440f, -0.10522013f, -0.04327559f, -0.07717286f, -0.03994691f, -0.07807627f, -0.06566274f, 0.00777143f, 
    0.00270631f, -0.43362454f, -0.01681624f, -0.03735233f, 0.01927797f, -0.27433765f, 0.16180903f, -0.45335522f, 
    0.05246404f, 0.18195693f, 0.08403470f, 0.21514833f, -0.31752604f, -0.00765074f, -0.23463438f, -0.14158683f, 
    0.27935895f, -0.08614332f, -0.08461070f, -0.01748448f, -0.04924904f, -0.22510067f, -0.07610672f, -0.28518355f, 
    0.03470315f, 0.05999980f, -0.03880119f, -0.05192964f, -0.07270473f, 0.07469570f, 0.05747572f, 0.01570570f, 
    0.11565338f, 0.10179084f, 0.05937212f, -0.13562903f, 0.05677280f, -0.08642177f, -0.15633121f, 0.20246953f, 
    0.12409778f, -0.01231250f, 0.02604437f, 0.07797773f, 0.21015270f, -0.09850173f, 0.28540015f, -0.09560642f, 
    -0.07399584f, 0.05715416f, -0.01255431f, -0.03420628f, 0.08898262f, 0.17303427f, -0.02627655f, -0.04423726f, 
    0.03341874f, -0.02128587f, 0.07023825f, -0.05377145f, -0.04166294f, -0.12437356f, -0.13000487f, -0.24213678f, 
    -0.15406619f, -0.09987469f, 0.10734610f, 0.10566143f, 0.07918096f, -0.35265306f, 0.14650869f, -0.12964848f, 
    -0.21551955f, -0.08034460f, -0.08422797f, 0.02429003f, 0.05872023f, 0.05694805f, 0.05847762f, 0.06555559f, 
    0.14218885f, -0.03851289f, 0.18463801f, 0.04925488f, -0.11849814f, 0.03177435f, 0.05829225f, 0.27874684f, 
    -0.08011054f, 0.00111664f, -0.32027182f, -0.33870047f, -0.22556204f, 0.22940370f, -0.18098350f, 0.10239346f, 
    0.04376642f, -0.04827205f, 0.14354461f, -0.00919527f, -0.14961311f, -0.25351644f, -0.39310777f, -0.38076016f, 
    0.24498986f, -0.02405574f, -0.36824739f, 0.09590094f, 0.04822630f, 0.13445674f, -0.14677076f, -0.06234654f, 
    -0.12035080f, 0.06735162f, -0.11715868f, -0.02153075f, 0.18166880f, 0.04906798f, -0.35513151f, 0.08712917f, 
    0.09845728f, 0.24378347f, 0.01961782f, -0.01903675f, 0.13436730f, 0.03018683f, 0.10251889f, 0.06970557f, 
    -0.00939311f, -0.11877391f, 0.10583484f, -0.04898154f, 0.20920375f, 0.00166435f, 0.09584986f, 0.01805285f, 
    -0.03640631f, -0.07823636f, 0.00033930f, -0.02560510f, 0.06898710f, 0.17504106f, -0.05940948f, 0.25851727f, 
    -0.65126950f, 0.01886939f, -0.32923028f, -0.30975014f, -0.14981052f, 0.11756907f, 0.14764242f, -0.16959278f, 
    -0.20120823f, -0.18240951f, 0.26401907f, -0.04670539f, 0.22024155f, -0.10322867f, -0.05479262f, -0.06002207f, 
    -0.07021812f, 0.05476833f, -0.07195571f, 0.05548875f, -0.31801799f, 0.19462845f, 0.29879370f, -0.53185815f, 
    0.52107179f, 0.00959911f, 0.08095621f, -0.15453073f, -0.01632969f, -0.09043055f, 0.05715223f, -0.04137151f, 
    0.10592323f, -0.05099032f, -0.13120782f, -0.27869254f, -0.24412292f, -0.53270549f, 0.06019311f, -0.60094905f, 
    -0.62293911f, 0.54059213f, 0.17969784f, 0.25452915f, -0.28980875f, -0.08174094f, -0.09868339f, -0.09541730f, 
    0.03893097f, 0.12957402f, -0.00756356f, 0.01942908f, -0.07820646f, 0.05095970f, -0.10698362f, -0.10517327f, 
    -0.07994975f, -0.07247388f, -0.00873814f, -0.04276724f, 0.18295583f, 0.12169532f, 0.29175213f, 0.19727518f, 
    -0.13306980f, -0.05348067f, -0.13299476f, 0.17867403f, 0.11955692f, -0.03131406f, 0.06809822f, 0.00851183f, 
    0.08284198f, 0.06436901f, -0.02920925f, 0.23199129f, -0.01336700f, -0.19580831f, -0.23761050f, -0.42443070f, 
    0.03682579f, -0.07446341f, -0.44341004f, 0.16511430f, 0.15246640f, -0.07181568f, 0.20025547f, 0.05323474f, 
    -0.05958561f, 0.11984405f, 0.14430666f, -0.04572156f, 0.04163568f, 0.03176642f, -0.06867495f, 0.14128497f, 
    -0.15695171f, 0.07508885f, -0.00887552f, 0.09034713f, -0.76099366f, 0.16884424f, -0.14058436f, -0.32958812f, 
    -0.55553126f, -0.05818968f, -0.00244913f, 0.04908795f, -0.10993586f, -0.16844864f, -0.07013948f, 0.03644580f, 
    -0.21105534f, 0.01634333f, 0.04697048f, -0.14797005f, -0.17779084f, -0.10856320f, 0.01383315f, -0.06594370f, 
    -0.10135972f, -0.37160707f, -0.23666182f, 0.23772033f, 0.10716742f, 0.04765404f, 0.03344986f, -0.05872923f, 
    -0.03255511f, 0.00791130f, -0.00755082f, -0.08574381f, -0.12190204f, -0.06953894f, 0.01558878f, 0.04006542f, 
    -0.21046947f, 0.27024686f, -0.05461643f, -0.09691029f, 0.08621725f, -0.22194684f, 0.05130705f, 0.00805258f, 
    -0.44074002f, 0.15446398f, 0.04618212f, -0.00148220f, -0.07701818f, 0.19737324f, 0.02632307f, 0.02307428f, 
    -0.01276493f, -0.05979740f, -0.06193572f, -0.10167971f, 0.14878418f, -0.03794606f, 0.04859640f, 0.06538931f, 
    0.58169484f, 0.00358782f, 0.35297471f, 0.14645219f, -0.24854192f, 0.12166259f, 0.16914172f, 0.16142306f, 
    0.04176871f, 0.12326574f, 0.01803032f, 0.07890595f, 0.02100962f, 0.12244936f, 0.03997030f, -0.06657860f, 
    -0.04756643f, -0.01715823f, -0.02330795f, 0.02970017f, 0.45061719f, -0.05404573f, -0.04406503f, -0.25624132f, 
    0.20890024f, -0.05705351f, 0.10437685f, 0.06940261f, 0.00323183f, 0.23161870f, 0.16908151f, -0.01479848f, 
    -0.15799180f, -0.15082097f, 0.02883675f, 0.11829884f, 0.01740990f, 0.03936220f, -0.10765182f, 0.26542851f, 
    -0.10668278f, -0.09779651f, -0.25389141f, 0.05733605f, 0.11879174f, 0.02270840f, -0.04888498f, -0.16517626f, 
    -0.02952008f, 0.01295577f, -0.05468088f, 0.07084829f, -0.05991979f, 0.16661087f, 0.11528790f, -0.07569255f, 
    0.09379568f, 0.08041407f, 0.01328379f, -0.03863782f, 0.09419831f, 0.05746861f, 0.28223813f, -0.44483772f, 
    0.15253463f, -0.04095890f, 0.06204129f, -0.08352721f, -0.20102692f, 0.15602154f, -0.23472065f, -0.01926459f, 
    -0.04738430f, -0.04175365f, -0.03983975f, 0.00852316f, 0.15418591f, -0.01389529f, 0.06561568f, 0.18612215f, 
    -0.14957759f, 0.01597274f, 0.10485654f, -0.10488550f, -0.22078188f, 0.12858309f, -0.09811393f, -0.11359270f, 
    -0.08682592f, 0.03702935f, 0.09032527f, -0.04944438f, -0.07520235f, 0.13245413f, 0.00817828f, -0.02517839f, 
    0.03893899f, -0.02124898f, -0.00517171f, -0.10695048f, 0.26664346f, -0.19936971f, 0.38184470f, -0.08964392f, 
    -0.29719278f, 0.12531191f, 0.04939768f, 0.24384153f, 0.10585407f, -0.30081460f, -0.05432903f, -0.13793327f, 
    -0.05296941f, 0.03793813f, 0.11520649f, -0.05813791f, 0.08167284f, 0.12553571f, 0.11724127f, 0.37706849f, 
    0.16289493f, 0.14677574f, -0.02256235f, -0.21955831f, -0.00733772f, -0.06260018f, -0.06288102f, -0.03263857f, 
    -0.02601263f, 0.10262100f, 0.13616772f, 0.31744638f, -0.03751769f, -0.02955448f, 0.06044373f, 0.00600254f, 
    -0.16056710f, -0.09200454f, -0.09608608f, -0.05193572f, 0.59900749f, -0.80745554f, -1.08627665f, -0.07453295f, 
    0.06620200f, -0.07092508f, 0.15619248f, 0.24084938f, 0.08979686f, -0.51609421f, 0.08849320f, -0.00170792f, 
    -0.08639982f, -0.01424329f, 0.11981578f, -0.06044045f, -0.01269826f, 0.21799976f, 0.15238631f, -0.01744163f, 
    -0.64776611f, -0.19234891f, 0.71879560f, 0.32312831f, 0.06192391f, -0.07737078f, -0.16003443f, -0.03773822f, 
    -0.20798150f, 0.42308235f, 0.01116146f, 0.16149108f, 0.28598678f, 0.16649975f, 0.14028931f, 0.01846509f, 
    0.02302659f, -0.10602956f, -0.12662695f, -0.04502213f, -0.14092119f, -0.35087860f, 0.07315789f, -0.07469480f, 
    -0.38535574f, 0.12527108f, 0.04548631f, 0.08463766f, -0.01777084f, -0.03499817f, -0.02356905f, -0.09778333f, 
    0.09417575f, 0.03088778f, 0.08640202f, 0.28405789f, 0.32056603f, 0.36987370f, -0.05292125f, 0.20205335f, 
    -0.18438011f, 0.08921318f, -0.83389974f, -0.14608324f, 0.47826096f, -0.36546698f, 0.15673196f, -0.01932810f, 
    0.07484772f, 0.30757892f, 0.07247555f, -0.03520507f, 0.21807671f, 0.01659693f, 0.01890767f, 0.15270737f, 
    -0.00581529f, -0.08375557f, 0.20935050f, -0.00782440f, -0.64219850f, -0.34331512f, -1.04577351f, -0.45000461f, 
    0.00785808f, -0.25037467f, -0.01723039f, -0.18190873f, 0.09544475f, -0.48922583f, 0.01047236f, -0.10427058f, 
    -0.03047291f, 0.05355687f, 0.09922351f, -0.01925586f, -0.03282992f, -0.01697497f, 0.18442787f, 0.03052208f, 
    0.11930419f, -0.00931050f, -0.01534386f, -0.04917793f, 0.26673636f, -0.12568015f, 0.02453913f, 0.15851016f, 
    0.17901967f, -0.01024089f, 0.13832514f, 0.08270700f, -0.02378920f, 0.07008676f, 0.02036597f, 0.04795009f, 
    0.00343915f, 0.01765123f, 0.00300195f, 0.03277565f, -0.26809937f, -0.12466832f, 0.66083640f, 0.05852931f, 
    0.26130626f, -0.12294937f, -0.14391208f, -0.03631791f, -0.09021443f, 0.15673120f, -0.00280043f, 0.17285541f, 
    0.21496694f, 0.07539701f, -0.21599236f, 0.00910612f, 0.07255605f, 0.03746305f, 0.14001817f, 0.05978629f, 
    0.14746530f, -0.13014407f, -0.09107236f, -0.21185857f, 0.07866301f, -0.06786531f, 0.01043718f, 0.16678761f, 
    -0.05295687f, 0.08917695f, -0.07288587f, -0.00188277f, -0.22039127f, -0.13845558f, -0.05681702f, -0.22782680f, 
    -0.25316954f, -0.17692479f, 0.00654022f, 0.12363471f, -0.89721143f, 0.57934809f, 0.36530620f, -0.14044863f, 
    0.08304045f, -0.50286084f, -0.10721716f, -0.33772227f, -0.06777944f, 0.07224628f, -0.06898108f, 0.00106560f, 
    0.04302983f, -0.05040880f, 0.02068222f, -0.01199048f, -0.05832990f, 0.04134722f, 0.16281849f, -0.09903475f, 
    -1.04820943f, -1.68426752f, -0.93224621f, -0.16809312f, -0.05617825f, 0.20628856f, 0.13059020f, -0.10176681f, 
    -0.04675862f, -0.38259283f, 0.01627704f, -0.05848496f, -0.09635449f, -0.01140396f, 0.14765780f, -0.04806022f, 
    0.06404037f, 0.24609737f, 0.22041543f, 0.23230322f, 0.33129627f, 0.49589789f, -0.26056692f, -0.01667505f, 
    -0.01161886f, 0.08130845f, -0.04434884f, -0.09314782f, 0.10344733f, -0.24072093f, -0.03103543f, 0.08526569f, 
    -0.18728039f, 0.05008011f, 0.01570321f, 0.05829525f, -0.06268257f, 0.06505957f, -0.38182116f, -0.13447365f, 
    -0.03755213f, -0.06607225f, -0.02225444f, -0.12613134f, 0.00446029f, -0.02786807f, -0.02902721f, -0.12204926f, 
    -0.04239996f, 0.08566907f, 0.12761435f, 0.19586770f, 0.18754305f, 0.06709139f, -0.01230551f, 0.00211029f, 
    -0.11660085f, -0.12529497f, -0.10972432f, -0.03704883f, 0.02414062f, 0.32464167f, 0.13496514f, 0.03142435f, 
    -0.05237118f, -0.00274666f, -0.12805636f, -0.31120518f, -0.11733235f, -0.32308194f, -0.07195789f, -0.08816417f, 
    -0.26477402f, -0.06384645f, 0.02257646f, -0.00735796f, -0.08258964f, 0.09952619f, -0.24565987f, -0.11615542f, 
    -0.62585384f, -1.08841646f, -0.94693905f, -0.15887742f, 0.55805987f, 0.02321421f, -0.14860705f, -0.06000522f, 
    -0.19951385f, -0.01813211f, -0.07589652f, -0.05875300f, -0.02169666f, 0.01462057f, -0.20681445f, -0.11038459f, 
    -0.08508253f, 0.02519183f, 0.12522875f, -0.07756550f, -0.21064039f, -0.65150434f, 0.16674095f, -0.00949543f, 
    0.27548277f, -0.05259062f, 0.14558898f, -0.12144370f, -0.15635233f, -0.18499376f, -0.04167676f, 0.10600582f, 
    -0.07062144f, -0.01247729f, 0.07936974f, 0.03180943f, 0.08990437f, 0.04085645f, 0.32784769f, -0.28823283f, 
    0.01010545f, 0.14110862f, -0.12893440f, 0.01978340f, -0.20452099f, -0.00847914f, 0.00531806f, 0.07569813f, 
    -0.09898105f, 0.02858459f, -0.23954763f, -0.29324642f, 0.12518996f, 0.03473697f, -0.11347687f, 0.08762792f, 
    -0.04535390f, 0.08629178f, -0.07278766f, 0.01149544f, -1.60879350f, -1.05533326f, 0.48807594f, -0.09700605f, 
    -0.06846271f, -0.05092658f, -0.19408016f, -0.16962557f, 0.00340984f, 0.09031734f, 0.06859475f, -0.00939925f, 
    0.02691536f, -0.01180337f, -0.09491482f, 0.10292991f, -0.01312961f, -0.34206706f, -0.17137571f, -0.04446375f, 
    0.59301353f, 0.32772487f, 0.17891029f, -0.31871489f, -0.16506080f, 0.02390987f, 0.10719927f, -0.01032507f, 
    0.02997663f, -0.00276768f, 0.01905791f, -0.12450603f, 0.23995030f, -0.08487528f, 0.08289935f, -0.02588282f, 
    0.05008486f, 0.00612469f, 0.13315821f, -0.00080825f, 0.36820343f, -0.24819417f, 0.54644215f, -0.42929384f, 
    0.30246356f, 0.10687509f, 0.00587331f, 0.14105977f, 0.08570276f, 0.06210109f, 0.00450478f, -0.09587200f, 
    0.10282385f, 0.03011248f, -0.00789621f, -0.07110106f, 0.06762893f, 0.06699512f, -0.20114940f, -0.14193489f, 
    0.40357107f, 0.38746640f, -0.09632578f, 0.95035642f, -0.54930151f, -0.05390485f, 0.03450124f, -0.10937005f, 
    -0.26651755f, -0.08402973f, -0.05517261f, -0.10579272f, -0.18479250f, -0.08132342f, 0.03910887f, -0.13590072f, 
    -0.01777815f, 0.06043617f, 0.02149635f, 0.02507392f, -0.22100776f, -0.29153031f, -0.00920686f, 0.63782459f, 
    0.01819503f, 0.08886425f, -0.01246913f, -0.00794048f, -0.10258397f, 0.12702198f, 0.05641120f, -0.05468185f, 
    -0.12504910f, -0.12268665f, -0.12059695f, 0.10578234f, 0.16289596f, -0.15597932f, 0.11427671f, 0.04254889f, 
    0.01252427f, 0.21464542f, -0.02863675f, -0.05567824f, -0.18907282f, -0.02783129f, -0.01159439f, -0.03010785f, 
    -0.01255021f, -0.06808429f, -0.07533734f, 0.03409530f, 0.18344982f, -0.04038091f, -0.13552625f, -0.19937319f, 
    -0.26349241f, 0.17640096f, -0.05033194f, -0.05106958f, 0.69209957f, -1.07095003f, -0.20854765f, -0.72561330f, 
    -0.31315887f, -0.09566610f, 0.35213837f, -0.20506604f, 0.45166308f, -0.00993358f, -0.04497522f, 0.10627066f, 
    -0.05812049f, -0.00936314f, -0.00150522f, -0.13682200f, 0.07432044f, -0.14705043f, 0.08111907f, 0.01565577f, 
    0.02849177f, 0.16535169f, -0.09575425f, -0.00322893f, -0.29441813f, 0.01853022f, 0.06227975f, 0.00620022f, 
    -0.01211954f, -0.05721119f, 0.06905470f, 0.10541263f, 0.05334681f, 0.06343681f, -0.05391093f, -0.15297548f, 
    -0.36994821f, 0.28614393f, 0.05874840f, 0.03032909f, 0.65434867f, -0.84201849f, -0.55644667f, -0.27213031f, 
    -0.22291106f, -0.05885590f, 0.00766818f, 0.05288998f, 0.23202288f, -0.30719844f, -0.07432020f, -0.02237241f, 
    0.00002839f, -0.01194978f, 0.01348446f, -0.04514540f, 0.00344523f, 0.07324811f, -0.04704487f, -0.08348827f, 
    -1.04851305f, -1.35078871f, 0.81553054f, 0.61645180f, 0.50683069f, -0.09678007f, 0.02503574f, 0.32270977f, 
    -0.21536066f, 0.02197966f, 0.00542654f, 0.01576670f, -0.16144580f, -0.06890006f, -0.09882465f, 0.07337622f, 
    0.09278046f, -0.18952736f, 0.23660740f, -0.24467753f, -0.26972619f, -0.03444777f, 0.27459431f, 0.02952724f, 
    0.24709503f, 0.00965377f, -0.01919264f, 0.01308823f, 0.12083022f, 0.02990891f, 0.04656121f, -0.06312940f, 
    0.02577623f, 0.10368895f, -0.00254256f, 0.07265800f, -0.05654154f, -0.10510164f, -0.18747196f, 0.03576136f, 
    0.06489915f, 0.16985838f, -0.04766223f, -0.09850714f, -0.19938281f, 0.04582773f, 0.07006730f, 0.05865107f, 
    0.05394963f, -0.05109987f, -0.28202400f, -0.45791656f, -0.26779556f, -0.28247914f, -0.28733438f, 0.08849854f, 
    0.04608190f, 0.04699565f, 0.03701499f, -0.02674575f, -0.37824225f, -0.27370036f, 0.26874363f, -0.03808098f, 
    0.19242416f, 0.02869916f, 0.02758860f, 0.08541874f, 0.17199038f, 0.12393889f, 0.02116553f, 0.21916731f, 
    -0.06497981f, 0.09898473f, 0.03390378f, -0.04773883f, 0.02463756f, -0.08663766f, -0.13735628f, -0.08140256f, 
    0.66125244f, -0.65769792f, -0.49364018f, -0.66358072f, -0.10082227f, 0.12124508f, -0.00080810f, -0.28504789f, 
    0.31671584f, -0.03050354f, 0.05984984f, 0.01999683f, -0.03930833f, -0.03409160f, 0.02457304f, -0.03843075f, 
    -0.09655771f, -0.02619357f, 0.10857471f, -0.01882014f, -0.26703435f, -0.33916721f, -0.20864895f, 0.39821807f, 
    -0.13592795f, 0.13832335f, -0.01315051f, 0.46384463f, -0.00592404f, -0.02439942f, 0.12323909f, 0.05856782f, 
    0.07700955f, -0.04466772f, -0.01326041f, -0.01530546f, 0.03643257f, 0.06211770f, -0.04542477f, 0.10546600f, 
    -0.21787399f, -0.02126733f, 0.06586367f, -0.07913104f, -0.13967247f, -0.13542201f, 0.16402408f, -0.02439755f, 
    0.02914076f, -0.07339898f, 0.13220760f, 0.02287386f, 0.06260075f, 0.14587860f, 0.04652483f, -0.02904154f, 
    0.01167985f, 0.09771209f, 0.29947838f, -0.04462387f, 0.73702437f, -0.16920784f, 0.05847148f, 0.10297540f, 
    -0.18133114f, 0.24370450f, 0.14099057f, -0.13429938f, -0.19318269f, -0.23292644f, 0.00212261f, 0.06885491f, 
    0.01712182f, -0.01984684f, 0.02640682f, 0.00456773f, 0.11430264f, 0.02551639f, -0.11907350f, -0.09560256f, 
    -0.19847073f, -0.23675838f, -0.42411810f, -0.00674722f, -0.09920665f, -0.10899504f, -0.04829386f, 0.25665057f, 
    0.10069448f, 0.09290434f, 0.27574915f, 0.01787262f, 0.03538553f, -0.18910630f, -0.12587598f, -0.18068418f, 
    0.04819358f, 0.03046206f, 0.01355413f, 0.06542194f, -0.41931164f, 0.09479447f, 0.13074669f, 0.23691922f, 
    0.35097229f, 0.02256009f, -0.32288104f, 0.10288063f, -0.08569232f, -0.00031447f, 0.04544464f, -0.00180848f, 
    -0.02032441f, 0.03626489f, -0.06520450f, -0.27477503f, -0.21449599f, -0.24865748f, -0.34705874f, -0.33547649f, 
    0.90772200f, 0.28851241f, -0.36755189f, 0.19959401f, 0.29616198f, 0.19968201f, 0.10425445f, 0.04065812f, 
    0.19957753f, -0.00367508f, 0.13047671f, 0.02871636f, 0.14741281f, 0.00496347f, 0.03931304f, -0.01158121f, 
    -0.10168058f, -0.24401423f, -0.15689430f, -0.30097413f, -0.05054164f, -0.34335917f, -0.37137744f, -0.21189788f, 
    -0.14511897f, 0.03725928f, -0.14470750f, 0.01911437f, -0.22981206f, -0.45613039f, 0.03378951f, -0.01495362f, 
    0.00242342f, 0.01241235f, 0.07762593f, 0.09658967f, 0.01562902f, 0.25531721f, 0.14698033f, -0.20804338f, 
    -0.14347415f, 0.10636970f, 0.17260236f, 0.13895790f, -0.19504978f, 0.02270647f, 0.02047417f, 0.02167643f, 
    0.08580717f, -0.14051861f, 0.02755860f, 0.10335459f, -0.12134860f, 0.06835798f, 0.07152712f, 0.14873013f, 
    0.05488523f, -0.09287722f, 0.00225048f, 0.15231419f, -0.07800183f, 0.14631991f, -1.41767597f, -0.24752280f, 
    0.35040951f, -0.04113213f, 0.03642057f, 0.31152931f, 0.32258227f, -0.11415309f, 0.12600827f, -0.05729036f, 
    -0.04430915f, 0.15377980f, 0.14110067f, -0.02140052f, -0.05814208f, 0.07520285f, -0.11439021f, -0.10341892f, 
    -0.40637064f, 0.32800055f, 0.28026170f, 0.04341362f, -0.29202029f, -0.03307450f, 0.11200499f, -0.11636946f, 
    0.04905834f, -0.09097307f, -0.15993473f, -0.12611897f, -0.01561863f, 0.07624698f, -0.03028895f, 0.05583055f, 
    0.07581341f, -0.03473250f, 0.06871243f, 0.01410342f, 0.27815682f, -0.52731252f, -0.96070617f, -0.34434620f, 
    0.14033523f, 0.06749427f, -0.06100769f, 0.03086937f, 0.21210849f, 0.15275113f, -0.08873314f, -0.20058079f, 
    -0.17109160f, -0.07115023f, -0.08970467f, -0.00443084f, -0.00882304f, 0.00053422f, 0.04740080f, 0.03540935f, 
    1.29707491f, -0.33816758f, -0.35040492f, 0.00245792f, 0.01659978f, 0.08098551f, -0.24742088f, 0.14504835f, 
    -0.01540428f, -0.05245202f, -0.02151323f, -0.00637375f, 0.08151252f, -0.04266614f, 0.03167268f, 0.09295691f, 
    0.04321001f, 0.25082099f, -0.49493054f, -0.05271440f, -0.59134889f, -0.22782691f, -0.04283134f, 0.07488412f, 
    0.10737208f, -0.14882982f, -0.05605580f, -0.08042958f, -0.09999889f, -0.06505758f, 0.01617566f, 0.17857717f, 
    0.12323920f, 0.28647357f, -0.15581779f, 0.01920088f, 0.10597007f, 0.02403930f, 0.08796414f, 0.18019244f, 
    -0.17169678f, -0.06575014f, -0.06956243f, -0.15088807f, -0.20314503f, -0.16654056f, -0.00963696f, 0.03043749f, 
    0.03948301f, -0.13462125f, 0.08843197f, 0.10055204f, 0.08113115f, 0.03110185f, 0.05791356f, 0.02490144f, 
    0.02298506f, -0.01140533f, 0.12326024f, 0.02498225f, -0.19910882f, -0.35603702f, -0.25365543f, 0.02808335f, 
    0.18787287f, -0.15072680f, -0.16259834f, -0.01356481f, -0.01309506f, 0.16940019f, -0.11682869f, 0.06473162f, 
    -0.10337127f, -0.15267031f, -0.09195869f, -0.07732522f, 0.14294095f, 0.09235632f, 0.04212239f, 0.17999591f, 
    -0.30474696f, -0.59793657f, -1.26716423f, -0.78006262f, -0.01079081f, -0.07250791f, 0.03846711f, 0.25795931f, 
    -0.08765549f, -0.21610133f, -0.07853911f, -0.03448039f, -0.06403307f, 0.09172245f, 0.05794279f, 0.08744463f, 
    -0.01650001f, 0.00551591f, 0.09898917f, 0.00813682f, 0.74278307f, 0.02832651f, -0.16472775f, 0.02126222f, 
    -0.33110592f, -0.21874669f, -0.16678320f, -0.15739568f, -0.16990265f, -0.25899500f, 0.07016205f, 0.06036089f, 
    0.17592287f, -0.18177883f, 0.09212705f, -0.14770043f, 0.13815306f, 0.10278042f, 0.24553427f, 0.10017276f, 
    -0.43348497f, 0.35200351f, 0.31545860f, -0.16457088f, 0.03025392f, 0.08857776f, -0.13948701f, -0.06859560f, 
    -0.13216867f, -0.19885129f, 0.06467412f, 0.16455182f, -0.09962765f, 0.01259794f, 0.19175632f, 0.11433474f, 
    0.11894387f, -0.23495442f, 0.15327147f, 0.08135832f, 0.59206283f, 0.12301156f, -0.50873339f, 0.09142201f, 
    -0.26623887f, 0.31636533f, 0.14910010f, 0.26708490f, -0.14909056f, 0.17192090f, 0.00389403f, -0.00104687f, 
    -0.01819949f, -0.06871402f, -0.12092817f, -0.01068524f, -0.02900656f, -0.00073282f, -0.08173721f, -0.13717371f, 
    -0.17371294f, 0.58000076f, 0.17346439f, 0.20281936f, 0.18866156f, 0.04088176f, -0.17020826f, -0.50234956f, 
    -0.32128042f, -0.33645535f, 0.16231376f, 0.18231359f, 0.04774677f, 0.10175721f, 0.08952956f, 0.03590400f, 
    -0.08364850f, -0.04095734f, -0.02082266f, 0.02363152f, 0.38441435f, -0.55742735f, -0.47996053f, -0.08862879f, 
    0.03910862f, -0.23000823f, -0.04450428f, 0.07400803f, 0.04461452f, 0.11904345f, -0.07883298f, -0.13120361f, 
    0.08829369f, -0.06202697f, -0.14358939f, 0.08308139f, 0.13256501f, 0.05981252f, -0.12235511f, 0.14037994f, 
    -1.23543918f, -0.34858513f, -0.97158360f, 0.48931456f, -0.79845113f, 0.13320477f, -0.34908310f, 0.23107804f, 
    -0.33080876f, -0.03221833f, 0.09975033f, -0.01799842f, 0.01050977f, 0.14232574f, -0.02218340f, -0.09892812f, 
    0.18027890f, 0.06208073f, 0.13263406f, 0.32228994f, -0.23960872f, 0.09920651f, -0.09391249f, 0.31719604f, 
    -0.08631136f, -0.03018524f, -0.20655861f, -0.03523740f, -0.12711461f, 0.28753883f, -0.00005000f, 0.11126917f, 
    0.06141526f, 0.07050607f, 0.03364201f, -0.00110686f, 0.18579754f, 0.33478811f, 0.05905010f, 0.22195268f, 
    -0.32564250f, 0.09807196f, -0.31754145f, 0.03458530f, -0.20355825f, 0.17694449f, -0.06948324f, 0.09988059f, 
    -0.25761637f, 0.05822745f, -0.07734192f, -0.04055594f, -0.23335528f, -0.01814809f, 0.01371312f, -0.01537199f, 
    -0.03904145f, -0.11035718f, -0.13695523f, -0.03567440f, -0.43882647f, 0.18645997f, -0.15886423f, 0.63673431f, 
    -0.52102661f, -0.31783104f, 0.23331128f, -0.69335341f, 0.06546230f, -0.02535229f, 0.04723043f, -0.10362903f, 
    0.15964448f, 0.28004569f, 0.00641164f, 0.13594984f, 0.13498758f, -0.03631965f, 0.08844547f, 0.02840591f, 
    -0.63029683f, -0.01536812f, -0.55174571f, -0.28874841f, 0.06450883f, 0.21278472f, 0.06487608f, 0.25899273f, 
    0.13196522f, 0.00323625f, 0.15296455f, -0.02294474f, 0.02471612f, 0.10329320f, -0.11911226f, 0.15186314f, 
    0.08442891f, 0.06745899f, 0.01995449f, -0.01413394f, -0.16578920f, -0.02588071f, 0.51522374f, 0.28619400f, 
    -0.76975101f, 0.13835342f, -0.25087169f, -0.19086714f, 0.08316007f, -0.07380242f, 0.05640928f, 0.03217112f, 
    0.12210774f, 0.01924906f, 0.05742905f, -0.02837533f, -0.11541706f, -0.06636113f, 0.01873031f, -0.09684930f, 
    0.27040592f, -1.13255203f, -0.29041827f, -0.02991922f, -0.21448995f, -0.17841351f, -0.37642488f, -0.05047743f, 
    -0.09650940f, 0.34780228f, -0.05753172f, 0.05668886f, -0.06506902f, -0.03570216f, -0.02957324f, -0.00402704f, 
    0.08344763f, -0.11915793f, 0.14713991f, -0.00292359f, -0.25962919f, 0.45385405f, 0.92677838f, -0.65120417f, 
    -0.44943404f, -0.02966538f, -0.30362678f, -0.11633807f, 0.04672094f, 0.04445198f, -0.07920036f, 0.07461415f, 
    0.00840913f, 0.01315156f, 0.06050865f, -0.15457906f, 0.01183089f, -0.01173251f, -0.30951133f, -0.10932356f, 
    -0.23204249f, 0.14183187f, 0.18790366f, 0.16359501f, 0.24073334f, -0.02851701f, -0.02373270f, -0.00568262f, 
    -0.05513381f, -0.26567006f, 0.17235927f, 0.35894081f, 0.11793000f, -0.08017525f, -0.17626926f, 0.08821357f, 
    0.00753107f, -0.02306277f, 0.05447122f, 0.08488959f, 0.22327770f, 0.40109122f, 0.69617075f, -0.51500797f, 
    -0.27244651f, -0.08268002f, -0.06710003f, -0.00711418f, -0.01814929f, 0.17258771f, -0.06937012f, 0.14584278f, 
    0.17300867f, -0.07761728f, -0.04259361f, -0.02811771f, -0.06956884f, -0.04117661f, -0.16922699f, -0.20468786f, 
    -0.10632513f, 0.03701662f, 0.30970564f, 0.52814382f, -1.14010298f, 0.01422418f, 0.05131840f, -0.09580456f, 
    0.41960052f, 0.09930267f, 0.11863935f, -0.01972566f, 0.05867110f, 0.09567115f, 0.04556134f, -0.12737764f, 
    0.07987563f, 0.12806284f, 0.06661686f, -0.05853394f, -0.04180538f, 0.08558021f, -0.27356753f, 0.07446651f, 
    -0.11041299f, -0.13727243f, 0.03102353f, -0.13942121f, 0.05208468f, -0.04263068f, 0.03087197f, -0.09305332f, 
    -0.21146056f, -0.11901414f, -0.16268069f, 0.08255744f, -0.10121601f, -0.16854163f, -0.16330023f, -0.22150384f, 
    -0.08624896f, -0.95243895f, 0.15725040f, -0.23388506f, -0.12716965f, -0.15172137f, 0.16764273f, 0.15010594f, 
    0.24565208f, -0.03044756f, -0.02718706f, -0.38224790f, 0.02643851f, -0.06862643f, -0.05230061f, -0.21769637f, 
    0.10353256f, 0.21576321f, 0.09897780f, 0.10084835f, -0.62243557f, -0.11376300f, -0.22466603f, 0.21600834f, 
    -0.08847964f, 0.19750077f, -0.10620011f, 0.08187152f, 0.18940876f, -0.14248234f, -0.06963868f, 0.10996313f, 
    -0.00756351f, 0.04063196f, -0.10507666f, 0.18206726f, -0.17776643f, -0.09473590f, 0.11944077f, 0.04224574f, 
    0.64327383f, 0.29193011f, 0.26562721f, 0.25444993f, -0.22942133f, -0.00481742f, -0.03886081f, -0.22605804f, 
    0.15192671f, 0.00827388f, -0.26407975f, 0.26804855f, 0.10926994f, -0.45393756f, 0.01359288f, -0.11559532f, 
    -0.12222684f, -0.10874133f, 0.23402375f, 0.09042524f, -0.45799330f, 0.09146895f, -0.46604922f, 0.57273704f, 
    0.21897502f, 0.07453477f, -0.07002456f, -0.17463258f, -0.48829317f, -0.12007268f, -0.23559369f, -0.00201841f, 
    -0.15235722f, 0.00808910f, 0.01777478f, -0.22511847f, -0.12560248f, -0.72577339f, -0.14200577f, 0.05804155f, 
    0.47689840f, -0.18880527f, 0.32618138f, 0.11004662f, 0.15847622f, -0.29178220f, 0.24687256f, 0.47776845f, 
    0.15767585f, -0.00396468f, -0.06198001f, 0.05454912f, -0.17627196f, 0.15600999f, 0.10656192f, 0.12600790f, 
    -0.35330728f, -0.08172284f, -0.23473439f, -0.58306181f, -0.13353875f, -0.14344254f, -0.71969199f, 0.01436805f, 
    0.11920845f, -0.12583953f, -0.02464303f, 0.41770583f, -0.14994945f, -0.21215968f, 0.00195661f, 0.24895282f, 
    -0.01614346f, 0.08275066f, -0.12150673f, 0.04871110f, -0.12554102f, -0.02501850f, -0.17791621f, -0.44800320f, 
    -0.13663445f, -0.30189845f, -0.01114547f, 0.43582827f, -0.37039945f, 0.06812209f, -0.03599617f, 0.34649032f, 
    -0.28855079f, 0.08775167f, -0.05797578f, -0.02081714f, 0.09973770f, 0.12623407f, 0.03045430f, -0.05422283f, 
    0.10363088f, 0.31069064f, 0.16089760f, 0.06945371f, 0.20796241f, 0.19920585f, -0.00016443f, -0.02322957f, 
    0.21208560f, 0.43970206f, -0.17080544f, 0.01029163f, -0.09601469f, -0.19281226f, -0.18552125f, 0.09348752f, 
    -0.11516565f, -0.26493353f, -0.30304319f, -0.06989911f, -0.07944826f, -0.16033752f, -0.09360785f, -0.13818221f, 
    -0.30376855f, -0.72328806f, -0.09580075f, -0.32386726f, -0.35873416f, -0.14797893f, -0.46381724f, -0.02790647f, 
    0.07622356f, -0.19216077f, -0.21958131f, 0.04732591f, 0.00720573f, -0.11081035f, 0.05459550f, 0.13242497f, 
    0.04948005f, 0.06118924f, 0.11141658f, -0.21431416f, -0.55739105f, 0.04376512f, 0.17726676f, 0.15249154f, 
    0.21194844f, -0.01876962f, 0.10154153f, -0.23410173f, 0.03105403f, -0.11762556f, 0.04615691f, -0.06917411f, 
    -0.00751010f, 0.09261329f, 0.14353828f, 0.20510045f, 0.01170558f, -0.16777097f, 0.09424372f, 0.26692525f, 
    -0.64808935f, 0.36578465f, -0.98667288f, 0.39213914f, 0.00745429f, 0.18758400f, -0.13855284f, -0.27030665f, 
    0.35993963f, 0.07798351f, -0.13482894f, 0.15736301f, -0.00263730f, 0.05701800f, 0.05272981f, 0.11067510f, 
    -0.28029388f, -0.38487810f, -0.06039054f, -0.16245574f, -0.14734517f, -0.21532902f, -0.31299540f, 0.57342058f, 
    -0.21262951f, 0.18566073f, 0.14923307f, 0.15247197f, 0.20093095f, -0.00099729f, 0.06347290f, -0.28890723f, 
    0.00212506f, 0.12923495f, 0.10723423f, 0.02420170f, -0.06490903f, 0.03809632f, 0.25606218f, 0.20054772f, 
    0.26421270f, -0.59984356f, 0.00584460f, -0.39789009f, -0.29783484f, 0.08261138f, -0.16035369f, -0.14865360f, 
    -0.06801612f, -0.05804012f, 0.14238027f, -0.00362955f, -0.24880129f, 0.08044231f, 0.02984215f, 0.02415348f, 
    -0.08620725f, -0.10344815f, 0.08787387f, -0.13772900f, -0.11175407f, 0.11468516f, -0.19329284f, 0.41926193f, 
    0.07519875f, 0.05692315f, 0.10210322f, 0.05316466f, 0.13574037f, 0.07564504f, -0.22781774f, -0.35654253f, 
    0.09223782f, 0.01145843f, 0.11992082f, 0.09731057f, 0.09734233f, 0.14843793f, 0.14460087f, 0.45698273f, 
    -0.60572702f, 0.14007847f, -0.73058695f, 0.10226320f, 0.04861310f, -0.15834309f, -0.15264848f, 0.03348349f, 
    0.05348948f, 0.06446636f, -0.16487949f, 0.20007709f, 0.03252542f, -0.08368065f, -0.15359476f, 0.14018808f, 
    0.02261497f, -0.00599725f, 0.05711660f, -0.15225896f, -0.58960903f, -0.24830322f, 0.21305545f, -0.12836833f, 
    0.10482078f, -0.05660252f, -0.12193150f, 0.33862579f, -0.10706787f, 0.21052854f, -0.13362376f, 0.08545279f, 
    0.00148917f, 0.12780525f, -0.08690239f, 0.09246827f, 0.22130533f, 0.14692590f, 0.23635107f, 0.16221403f, 
    0.04563362f, -0.09800111f, -0.13235627f, 0.26545787f, 0.23940830f, -0.02416955f, 0.23788191f, -0.06505181f, 
    0.20771918f, -0.04254428f, -0.14909858f, 0.16567172f, 0.22225738f, 0.14783914f, 0.21388042f, -0.02817521f, 
    -0.07339161f, -0.00325945f, -0.23063011f, -0.01092494f, 0.57036608f, 0.18119191f, 0.44025844f, 0.35167691f, 
    -0.16714276f, -0.02605964f, -0.23254266f, -0.14883806f, 0.03826487f, -0.27874568f, -0.20823169f, 0.13721818f, 
    0.07925827f, 0.12000032f, 0.07030138f, 0.00506016f, -0.14361806f, 0.15960267f, 0.15928563f, 0.14285061f, 
    -0.60151690f, -0.01486306f, -0.43692774f, 0.22207007f, -0.15669514f, 0.09489197f, 0.11202611f, 0.10758855f, 
    -0.30280483f, 0.22591232f, -0.06423251f, -0.23869853f, -0.02174684f, 0.05892466f, -0.02595668f, -0.03540620f, 
    -0.20157976f, 0.04387223f, -0.00789043f, 0.07230360f, -0.39056054f, -0.21397701f, -0.11087751f, 0.51498699f, 
    -0.39770693f, 0.04337943f, -0.04604293f, 0.14686972f, -0.20362552f, -0.10693481f, -0.22351623f, -0.03374280f, 
    -0.17608641f, 0.03506692f, -0.06118022f, 0.29996049f, 0.23626067f, 0.25269598f, 0.21360309f, -0.08992618f, 
    -0.02127692f, -1.03557837f, 0.75485945f, -0.72429252f, 0.78930557f, 0.15006860f, 0.10492150f, -0.01664027f, 
    0.28205925f, -0.05942087f, -0.16624308f, 0.04320483f, 0.15310770f, 0.08978839f, 0.06567899f, 0.03946728f, 
    0.29504722f, 0.11278578f, 0.02750725f, -0.05903882f, 0.29848245f, -0.45580086f, -0.33520395f, -0.64735234f, 
    0.32196745f, -0.17030022f, -0.47339451f, -0.06789221f, 0.05549146f, -0.18345155f, 0.01043302f, 0.01186113f, 
    0.11940135f, -0.11069491f, -0.03898091f, 0.07481724f, 0.00210992f, -0.12530448f, 0.20053163f, 0.01090202f, 
    0.37932646f, -0.06732415f, 0.47549048f, -0.22640543f, -0.18697454f, 0.03528421f, 0.26340184f, -0.24070685f, 
    0.35217381f, 0.17829925f, -0.13082589f, 0.10121016f, -0.17068769f, 0.04578301f, -0.09511729f, -0.02963411f, 
    0.16242753f, 0.01911950f, 0.06489912f, -0.09559668f, -0.97632623f, -0.07049060f, -0.44284359f, 0.16134246f, 
    -0.48508888f, 0.21650501f, 0.19120577f, 0.23867862f, -0.52289528f, 0.19607523f, -0.00616391f, -0.11484845f, 
    0.04968352f, 0.12323502f, -0.00057880f, 0.02369017f, 0.08426811f, 0.10065821f, 0.08268595f, 0.09329136f, 
    0.61359614f, 0.19859189f, 0.29309702f, -0.06626051f, -0.12218367f, -0.07935381f, 0.13353381f, -0.12185860f, 
    0.16061312f, -0.03858429f, -0.24734841f, 0.01056681f, -0.00868736f, -0.08279834f, -0.16764288f, 0.09946764f, 
    -0.00283808f, 0.01617425f, -0.06069075f, 0.18426117f, 0.18472309f, -0.35375902f, 0.08438734f, 0.21164672f, 
    -0.07551437f, -0.00008107f, -0.28041533f, -0.09390890f, -0.18869777f, 0.00447518f, 0.11591022f, 0.01269842f, 
    -0.10744461f, -0.20702770f, -0.15356770f, -0.04577235f, -0.03821700f, 0.05686727f, -0.02291763f, -0.14924197f, 
    -0.28556550f, -0.34693113f, -0.15377066f, 0.50298208f, 0.04335685f, -0.14594541f, -0.37450823f, -0.00812723f, 
    -0.07430134f, -0.32616463f, -0.06583655f, -0.02914398f, 0.06445444f, -0.02582539f, 0.11564587f, 0.09109680f, 
    -0.09668106f, 0.14000183f, 0.22721598f, -0.06711262f, -0.05265969f, -0.29254827f, 0.15004484f, 0.39995056f, 
    0.13912851f, -0.34793809f, 0.20828092f, -0.05554544f, 0.36539891f, -0.10032000f, -0.20230633f, 0.17530514f, 
    -0.16054375f, 0.08510046f, 0.24551572f, -0.12817675f, -0.01771871f, 0.22982422f, -0.06323688f, -0.07446296f, 
    -0.32700780f, -0.19960105f, -0.09827862f, -0.18794625f, -0.15738772f, -0.10699496f, 0.12194935f, 0.10740656f, 
    0.02312165f, 0.03738850f, -0.07930721f, 0.12998605f, 0.00365809f, 0.07938551f, 0.03384357f, 0.10929836f, 
    0.02538277f, 0.00217027f, -0.18090506f, -0.21709792f, -0.34246749f, -0.30967590f, -0.21355821f, 0.48564699f, 
    -0.01554436f, -0.29742911f, 0.03269443f, -0.00751131f, 0.08076532f, -0.15894283f, -0.05863549f, -0.10078937f, 
    -0.18840384f, -0.06824598f, 0.02659329f, -0.04964118f, 0.00875101f, 0.00797249f, -0.17691195f, -0.26800245f, 
    0.16597615f, -0.33869153f, 0.09367011f, -0.52269876f, -0.23498210f, 0.00547848f, -0.09878512f, 0.02336864f, 
    -0.01360891f, 0.04716701f, 0.05499369f, 0.07603747f, 0.28803384f, 0.00021203f, -0.14664046f, 0.08651521f, 
    0.01166802f, 0.01607525f, 0.10577442f, 0.03080562f, -0.31093505f, 0.15102066f, -0.44165748f, 0.24424680f, 
    0.01889159f, -0.12127264f, -0.12104584f, 0.09565565f, -0.39078918f, -0.25616464f, -0.00099238f, 0.06092154f, 
    0.00687410f, -0.19762044f, -0.14243031f, 0.18765938f, -0.13116269f, -0.18155706f, -0.07924314f, 0.04803353f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.39289039f, 0.30556014f, 0.08244703f, -0.19561310f, -0.13794439f, 0.07136205f, 0.15500315f, -0.16790807f, 
    -0.00018202f, 0.01029784f, 0.01388735f, 0.00133616f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
