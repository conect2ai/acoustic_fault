#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.95656449f, -0.69511265f, -1.07635283f, 0.87007844f, 0.61960196f, 0.31602797f, -0.08031198f, 0.09424526f, 
    0.16226435f, 0.08448926f, -0.28629056f, -0.35766143f, -0.00283139f, 0.49751037f, 0.52556652f, 0.58998889f, 
    -0.72070414f, -0.19413841f, 0.27534899f, 0.09917188f, 0.54221284f, -0.55892777f, 0.15176226f, 0.43469778f, 
    0.46123701f, 0.30063310f, -0.30662125f, -0.88530236f, 0.12495146f, 0.89825928f, -0.63656992f, -0.63472605f, 
    1.23455644f, 0.16117361f, -0.38848478f, -0.19972973f, -0.26069111f, -0.21224411f, -0.59464985f, 0.38855612f, 
    0.29552007f, -0.50721341f, -0.23078175f, -0.44231206f, -0.50757134f, -0.09528001f, 0.33603790f, -0.13255866f, 
    -0.12144461f, 0.79166764f, -0.62322640f, 0.04085196f, 0.72131419f, -0.36015192f, 0.12692069f, -0.02745562f, 
    -0.75709015f, -0.38277230f, -0.36728343f, 0.54329693f, -0.51152921f, -0.31130928f, 0.31861877f, 0.60317957f, 
    -0.88305986f, -0.13381045f, -0.35321292f, -0.19699112f, -0.12631860f, -0.52988398f, -0.42081600f, -0.14146020f, 
    -0.75951844f, -0.77483457f, -0.02453274f, -0.11637112f, -0.26778001f, -0.12883455f, 0.50346756f, -0.64588296f, 
    0.52343506f, 0.20521557f, 0.39844513f, -0.37468851f, 0.41460171f, -0.42610869f, -0.06799721f, -0.01886352f, 
    -0.42382222f, -0.27307463f, -0.92649436f, -0.31425488f, 0.03541448f, -0.35928327f, 1.06345427f, -0.82736093f, 
    -0.04853761f, -0.18932532f, -0.11031689f, -0.01317195f, -0.25522053f, -0.55739731f, -0.36784354f, -0.27357385f, 
    -0.46057874f, -0.06999583f, -0.43389887f, -0.20263790f, -0.88040900f, -0.43051541f, 0.13453797f, 0.02487539f, 
    -0.79370642f, -0.58949661f, 0.36723143f, 0.61709946f, -0.05936339f, 0.24404658f, 0.67674124f, -0.11657726f, 
    0.73005027f, -0.71180236f, -0.31640902f, 0.10610786f, -0.27498823f, 0.11971363f, 0.02730977f, -0.36839420f, 
    0.68582499f, 0.14360110f, 0.13692129f, -0.18908815f, 0.19064574f, 0.35293263f, -0.55379456f, 0.60409784f, 
    0.89586592f, 0.41444334f, -0.97425807f, -0.48452908f, -0.06591354f, 0.29651549f, 0.07272951f, 0.31430551f, 
    -0.02345449f, 0.12844881f, 0.11484918f, -0.99735051f, -0.36635873f, -0.65491205f, 0.08308903f, 0.56772172f, 
    -0.30872825f, 0.13007787f, 0.62711269f, 0.37882656f, -0.40210304f, -0.66095775f, -0.53163671f, -0.38263306f, 
    -0.62698519f, -0.56102049f, 0.32498434f, 0.68480849f, -1.02419901f, -0.54237574f, -0.06524392f, -0.40615332f, 
    0.18876302f, 0.45434982f, 0.75287849f, 0.30832902f, -0.67473704f, -0.67282385f, -0.22480048f, 0.31501365f, 
    -0.07480630f, -0.02555427f, 0.04471536f, -0.65469718f, -0.93766576f, -0.87990469f, 0.37051132f, 0.24760672f, 
    0.32869837f, -0.20397595f, -0.05456609f, -0.21514006f, -0.56425112f, -0.38079908f, -0.46922088f, 0.04656530f, 
    0.19603705f, 0.11206669f, -0.86576259f, -0.14296758f, 0.66904277f, -0.04721605f, -1.30552912f, 0.76016986f, 
    -0.50849086f, -0.06436872f, -0.18552455f, 1.28422868f, 0.07587070f, -0.03006041f, -0.06114498f, 0.25344837f, 
    0.09015052f, -0.00030577f, 0.56919968f, 0.34705594f, 0.62299299f, -0.33340552f, 0.64758182f, -0.16916382f, 
    -0.05097429f, 1.23316777f, -0.77292401f, -0.62711841f, -0.28111890f, 0.62292826f, -0.09458561f, -0.10177559f, 
    -0.17184846f, -0.38053066f, -0.22715224f, -0.45441547f, -0.63599253f, 0.60768723f, -0.05572614f, 0.68299192f, 
    0.50474244f, 0.70865726f, 0.14331479f, -0.09620296f, 0.74936378f, 0.31995165f, -0.29728150f, -0.08098309f, 
    0.60566801f, -0.49674332f, 0.51362753f, 0.68746167f, 0.39916670f, 0.20890783f, 0.05421651f, 0.51430464f, 
    0.10079018f, 0.36669385f, -0.14106421f, -0.17809227f, 0.26597106f, -0.67351854f, -0.46055269f, 0.76094866f, 
    0.48645347f, 0.05420960f, -0.39716789f, -0.43023553f, -0.02333405f, -0.50391442f, -0.23402898f, 0.63662320f, 
    -0.41002437f, -0.62650198f, -0.79334468f, 0.53083986f, 0.00522026f, 0.42071056f, 0.80403614f, -0.11270949f, 
    0.57977664f, -0.06044240f, -0.22789375f, 0.59267175f, -0.68285304f, -0.23184247f, -0.44786492f, 1.09804177f, 
    -0.31083953f, -0.55124038f, -0.10057083f, 0.25743592f, 0.09663855f, -0.03313814f, 0.10527694f, 0.08224913f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.51826280f, 0.36861038f, -0.06430446f, 0.00926862f, -0.15382440f, 0.20795788f, 0.25350800f, -0.24337180f, 
    0.38552552f, 0.25086764f, -0.28852117f, -0.32616299f, 0.07700322f, 0.15086775f, 0.28158134f, 0.19499029f, 
    0.02926569f, -0.36722821f, -0.00451197f, 0.32131544f, 0.27303109f, 0.29193750f, -0.00208691f, 0.37122771f, 
    0.05854259f, -0.03986000f, 0.03260005f, -0.14872895f, -0.27176645f, 0.11799441f, -0.05018358f, 0.46225411f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.01648055f, -0.17536926f, -0.38736340f, 0.03255625f, 0.17174563f, 0.21060370f, 0.00422165f, -0.16639245f, 
    0.06142990f, -0.21481045f, -0.41877127f, -0.25226256f, 0.03873087f, 0.04172167f, -0.05166982f, 0.28993511f, 
    -0.03663448f, 0.01842555f, -0.23140626f, -0.61225790f, -0.23877746f, -0.06268896f, 0.29903120f, -0.06703852f, 
    0.03648425f, 0.11760169f, 0.18816258f, -0.90909356f, -0.38696489f, 0.22079036f, 0.12503259f, -0.12769352f, 
    0.01385033f, 0.09558982f, 0.21905050f, 0.02209043f, 0.11283002f, 0.03217662f, 0.23272514f, 0.04679476f, 
    -0.02265741f, -0.07830662f, 0.16760489f, 0.05010097f, 0.03506076f, -0.21012986f, -0.71811080f, 0.10123868f, 
    0.13538879f, 0.15693700f, -0.18964019f, 0.02200936f, 0.29375526f, -0.09360708f, 0.19016425f, 0.23513182f, 
    0.22644064f, 0.07074518f, 0.17945831f, 0.06319306f, 0.13006110f, -0.16346972f, 0.05909650f, 0.16760720f, 
    0.09128742f, 0.11915690f, 0.05907439f, 0.01680234f, 0.01050368f, 0.16021547f, -0.10001951f, 0.02808572f, 
    0.18385693f, 0.14330500f, 0.03091239f, -0.13422401f, 0.02824850f, 0.17158851f, -0.00227489f, 0.03030865f, 
    0.08053631f, -0.00947519f, 0.26722255f, -0.08798420f, 0.04851472f, -0.14920528f, 0.02693211f, 0.16811065f, 
    0.07187813f, 0.02614764f, 0.30894265f, -0.38259676f, -0.02841308f, -0.11163670f, -0.04293994f, 0.14155233f, 
    0.23387876f, 0.14443289f, -0.14608285f, 0.13200304f, 0.13866296f, 0.10598785f, 0.05236083f, -0.03625627f, 
    0.01567815f, 0.00115786f, 0.02233647f, 0.14028972f, -0.00088646f, 0.17387982f, 0.14558738f, -0.09099437f, 
    0.06277298f, 0.08772411f, -0.04184861f, 0.06966481f, -0.05410865f, -0.07271183f, -0.39076021f, -0.27807954f, 
    0.11873103f, -0.37776428f, -0.17967822f, -0.04142451f, 0.18428466f, -0.00542344f, 0.04754367f, -0.21872179f, 
    -0.14761367f, 0.01364048f, -0.02529958f, 0.07450417f, -0.07661285f, 0.07382051f, 0.04935300f, 0.04468459f, 
    -0.43476799f, -0.10826781f, -0.00936019f, -0.01098821f, -0.13802445f, 0.00372542f, 0.10902437f, 0.14010453f, 
    0.04629182f, 0.01778763f, -0.16054681f, -0.09780641f, 0.02601556f, -0.36030322f, 0.03252738f, -0.01062123f, 
    0.00981711f, -0.23313807f, 0.07802312f, -0.30938202f, 0.16710465f, 0.02275246f, 0.01213935f, 0.00540102f, 
    0.04283438f, 0.06589636f, 0.20969671f, -0.10972025f, -0.57809252f, -0.13358699f, -0.11292643f, 0.01337819f, 
    0.17621040f, -0.00438557f, -0.01600524f, 0.16357277f, -0.04359207f, 0.12659310f, 0.16416715f, 0.06159184f, 
    0.05388184f, 0.06914406f, 0.06835926f, -0.13266276f, 0.31345677f, -0.06090448f, 0.02624289f, -0.00888370f, 
    -0.08543373f, 0.16782317f, 0.17395847f, 0.07269940f, 0.03998258f, 0.06633023f, -0.02185366f, 0.20789760f, 
    0.07191715f, 0.12003167f, -0.01845309f, 0.05600996f, 0.09219000f, 0.05912713f, -1.28234267f, -0.44376531f, 
    -0.17100187f, -0.10743585f, -0.10433907f, -0.04830184f, 0.11935797f, 0.05459407f, -0.00099238f, 0.22175522f, 
    -0.23257604f, -0.31926432f, -0.18573599f, -0.23151268f, -0.08631133f, 0.11713551f, 0.18883707f, 0.10061844f, 
    -0.50757420f, -0.20848005f, 0.05080109f, 0.01671140f, -0.16935660f, -0.09483884f, 0.04685188f, 0.07940469f, 
    -0.12032317f, 0.01173425f, -0.21942465f, -0.26620016f, -0.02640169f, -0.08156957f, 0.04173176f, -0.08436215f, 
    0.11779370f, 0.07650884f, -0.32604885f, -0.17817208f, -0.24620143f, 0.02299891f, -0.03372557f, 0.06388342f, 
    0.01970466f, 0.08122768f, -0.09168871f, -0.17841728f, -0.33098772f, -0.56264281f, -0.07849523f, -0.01217799f, 
    0.16465253f, 0.01420095f, -0.14652692f, 0.17969610f, 0.26750213f, -0.28063175f, 0.22080751f, -0.23530965f, 
    -0.07295523f, -0.05729769f, 0.17101115f, 0.07765053f, 0.11395556f, 0.05881495f, 0.36105374f, 0.03087284f, 
    -0.03948467f, 0.03809851f, -0.09053917f, -0.07917769f, -0.02529967f, 0.08249424f, 0.66808194f, 0.05409238f, 
    -0.49759716f, -0.10049643f, -0.06379987f, 0.14127395f, 0.13471279f, -0.06187524f, -0.17744525f, 0.61170650f, 
    -0.05502519f, -0.46992299f, -0.02168223f, 0.05081335f, -0.10731244f, 0.08461042f, 0.10096879f, -0.06905846f, 
    0.02667947f, 0.02469958f, 0.03196984f, -0.02454594f, -0.00902774f, 0.04204450f, -0.06368347f, 0.01065439f, 
    -0.05019626f, -0.06376704f, 0.03409479f, 0.03842661f, -0.02329696f, 0.04738086f, 0.04598986f, -0.01570280f, 
    0.00767985f, 0.01746335f, -0.05398675f, 0.00867215f, 0.04490759f, 0.03466889f, 0.03157922f, -0.06031867f, 
    -0.04936737f, 0.01596710f, -0.01326662f, -0.03824081f, -0.02293367f, -0.05745215f, -0.04261029f, 0.04076570f, 
    0.00911213f, 0.01302735f, 0.01487365f, 0.02902065f, 0.02409877f, -0.01852283f, -0.04909398f, -0.01201380f, 
    -0.04507441f, 0.04975282f, 0.00544362f, -0.01434537f, -0.05530908f, 0.04088401f, -0.05971977f, 0.03844074f, 
    -0.06069049f, -0.02888745f, 0.01682536f, -0.05407632f, 0.01628722f, 0.01173465f, -0.00266094f, -0.00964051f, 
    -0.03404191f, -0.05800887f, 0.00458440f, -0.05817868f, -0.03713195f, -0.05846782f, -0.05932780f, 0.02439576f, 
    -0.02891536f, 0.00837845f, 0.01946973f, 0.00409130f, 0.02404328f, 0.01391002f, 0.02492106f, 0.00236176f, 
    -0.03038267f, 0.03238760f, -0.03382573f, 0.00934254f, -0.04398130f, -0.04296893f, 0.00955560f, 0.02196847f, 
    0.02348272f, -0.02364908f, 0.02561920f, 0.02120279f, 0.00651969f, 0.02354106f, -0.06279984f, -0.02715364f, 
    -0.00289135f, -0.04561556f, 0.04326655f, -0.01040591f, 0.01409796f, 0.01741530f, -0.04417476f, -0.00646765f, 
    -0.00446052f, -0.06073412f, 0.00210212f, -0.02436769f, -0.00928479f, 0.02370426f, -0.04322061f, 0.03073306f, 
    0.00518801f, 0.00340868f, -0.00214608f, -0.00186312f, -0.03579651f, 0.03022565f, 0.00724507f, 0.01835011f, 
    0.03438877f, -0.01115768f, -0.01851699f, 0.04439525f, -0.01007835f, 0.04091650f, -0.03739727f, 0.00285464f, 
    -0.05718081f, -0.02438582f, 0.00651487f, 0.03337345f, 0.03539287f, -0.03947045f, 0.01222606f, -0.05502039f, 
    0.01888690f, -0.00279938f, -0.02081961f, 0.00640270f, -0.02881330f, 0.02191455f, 0.04453814f, -0.01549003f, 
    -0.02512517f, 0.01472738f, 0.04305989f, -0.03102259f, 0.00435964f, -0.02561793f, 0.01500403f, -0.03194676f, 
    0.00868786f, 0.00153338f, 0.00859778f, -0.01987404f, 0.04242354f, -0.04561144f, -0.01857846f, -0.02421951f, 
    0.00927266f, -0.00340796f, -0.03262780f, -0.02581300f, -0.06625719f, -0.02042933f, -0.05093592f, -0.02154531f, 
    -0.00808724f, -0.01267982f, -0.06961603f, -0.00184005f, -0.00630116f, 0.00880496f, 0.00060490f, 0.00463879f, 
    -0.06142910f, -0.04970654f, -0.05779922f, -0.00786602f, -0.04792241f, 0.04636763f, -0.05249624f, -0.03599096f, 
    -0.05723754f, -0.04958538f, -0.02598183f, -0.05351411f, -0.04131693f, 0.00218041f, -0.03576705f, -0.02147739f, 
    0.02084844f, 0.02814785f, 0.02029973f, -0.02470771f, -0.00374246f, 0.05021238f, 0.01702142f, -0.06428074f, 
    0.02647303f, 0.02821016f, 0.03243919f, -0.00110358f, -0.05618103f, -0.01557144f, -0.01708827f, 0.01455968f, 
    -0.02983058f, -0.05128554f, -0.04197355f, -0.02275422f, -0.05505523f, -0.04255866f, 0.03518036f, -0.00650373f, 
    0.02440253f, -0.03903515f, -0.04913441f, 0.01752654f, 0.02540946f, -0.01630369f, -0.04971015f, 0.01386714f, 
    -0.04942400f, -0.03907498f, -0.03982100f, 0.01399936f, 0.00528754f, 0.03825538f, -0.04180389f, -0.05081137f, 
    -0.03437886f, 0.02611218f, -0.02457892f, 0.03155924f, -0.00594088f, -0.05794780f, -0.04720198f, -0.05919794f, 
    0.04528236f, -0.04566327f, 0.01379662f, -0.04178212f, -0.00713210f, 0.00515565f, -0.05423145f, 0.01311298f, 
    0.04116571f, -0.02048691f, 0.04412068f, 0.03673044f, 0.05688747f, 0.03881126f, -0.00489933f, 0.01140867f, 
    -0.06790169f, -0.06565451f, 0.03777748f, -0.05122026f, 0.01345365f, -0.05258198f, 0.02171294f, 0.02029891f, 
    0.03016579f, 0.01638989f, 0.03258007f, 0.03384773f, -0.04905814f, 0.04247468f, -0.05678925f, -0.00443659f, 
    -0.06539251f, 0.02339240f, 0.01775563f, -0.05185121f, -0.03753943f, -0.03552210f, -0.05578991f, -0.01382399f, 
    -0.04063246f, -0.04533125f, -0.04784422f, -0.01821084f, -0.02947712f, -0.02166556f, 0.02765730f, 0.02583026f, 
    -0.00823657f, 0.02115103f, 0.00573234f, -0.03222341f, -0.06523445f, -0.04969059f, -0.00384941f, -0.05111272f, 
    -0.06946675f, 0.29311430f, 0.28448352f, -0.14011128f, -0.24568044f, -0.13293016f, 0.08914124f, 0.04457333f, 
    0.09106462f, -0.24050596f, 0.38463897f, 0.05269395f, -0.03724029f, -0.39490509f, 0.08234985f, 0.03369107f, 
    0.07958239f, 0.06242927f, -0.28821322f, -0.21045761f, -0.11055779f, -0.02122178f, 0.15923344f, -0.10580953f, 
    0.18000017f, 0.03218042f, -0.11278258f, -0.65175855f, -0.10798198f, -0.13417239f, -0.12853067f, -0.18812351f, 
    -0.30024981f, -0.05597479f, 0.05482072f, 0.14902543f, -0.10895652f, -0.07509251f, -0.12429260f, 0.06661192f, 
    -0.13882583f, 0.04390184f, 0.13538826f, -0.15459067f, 0.00264799f, -0.11102247f, -0.13128895f, -0.11582959f, 
    -0.11751042f, 0.22120161f, -0.00367048f, 0.13890956f, 0.27069741f, -0.30738369f, -0.07737549f, -0.03572681f, 
    -0.09514593f, 0.21669099f, -0.14764670f, -0.00756124f, 0.11829408f, -0.11277748f, 0.08201138f, 0.01039915f, 
    -0.01077976f, -0.10832608f, 0.20635720f, -0.08651491f, 0.29556417f, 0.07935363f, -0.02658689f, 0.17488392f, 
    -0.00915836f, 0.04138538f, 0.42458361f, 0.11410182f, -0.11479866f, -0.20712827f, 0.15167554f, 0.03909622f, 
    0.11245541f, 0.03394419f, -0.26729196f, -0.00643321f, 0.23519607f, 0.09622506f, 0.10118381f, 0.06131110f, 
    -0.21032830f, 0.08272438f, -0.48305961f, 0.17759971f, 0.17643660f, -0.16624735f, -0.21554995f, -0.34052870f, 
    0.09928655f, -0.07683383f, 0.04120537f, 0.01169371f, -0.00047877f, 0.14915623f, 0.12844309f, -0.12576716f, 
    -0.00132607f, 0.18173446f, -0.09256909f, 0.16632676f, 0.21519481f, 0.31766704f, 0.33082333f, 0.11618324f, 
    -0.10304909f, 0.04401519f, 0.21651602f, 0.03244385f, 0.06135775f, -0.61575752f, -0.34631434f, -0.10289547f, 
    0.04469318f, 0.09187131f, -0.14813180f, -0.01579873f, -0.14820161f, 0.01556490f, -0.56676900f, -0.18136232f, 
    0.05611653f, -0.00285123f, 0.18127054f, -0.14479318f, 0.14894359f, 0.17922431f, -0.38188425f, -0.08511756f, 
    -0.15546072f, -0.16573103f, 0.13189614f, 0.06123387f, -0.06651395f, -0.14027293f, 0.01847317f, -0.03486410f, 
    0.11656756f, 0.50044268f, 0.59780258f, -0.05557644f, 0.17513624f, 0.17121039f, -0.06494550f, 0.23581401f, 
    -0.24873012f, 0.21194622f, -0.27548456f, 0.29221979f, 0.15780619f, -0.07911554f, 0.00875453f, 0.15156053f, 
    0.06808195f, 0.09191617f, -0.11628358f, 0.37784609f, -0.01121286f, -0.11594826f, -0.07615787f, 0.03769846f, 
    0.00501351f, 0.33689845f, -0.12065519f, -0.11908232f, -0.10856260f, -0.07671010f, 0.07630154f, -0.16833755f, 
    0.05163623f, 0.01235138f, -0.11321684f, 0.01825520f, -0.17893307f, 0.11717185f, 0.04158087f, -0.02707113f, 
    -0.11844137f, -0.12846491f, 0.08233158f, -0.00057939f, -0.03140061f, -0.00659613f, 0.15704051f, 0.22636332f, 
    0.00083056f, 0.00390085f, 0.06659408f, 0.16595058f, 0.09136649f, 0.02893198f, -0.33314326f, 0.38191566f, 
    0.05712250f, -0.12550284f, -0.28907412f, 0.03680748f, -0.02518788f, 0.07003149f, -0.15114379f, 0.13722530f, 
    0.42719755f, 0.06719301f, -0.18260625f, -0.00335436f, -0.22308344f, 0.23326433f, 0.18245009f, 0.03200495f, 
    0.14923944f, -0.67134643f, -0.23211552f, 0.16892138f, -0.00097442f, 0.14989634f, 0.00431490f, -0.00629564f, 
    0.09061105f, -0.07333846f, 0.16093969f, 0.28371000f, -0.17226768f, -0.30081725f, -0.16424058f, 0.23034409f, 
    -0.00295110f, 0.27198941f, -0.13400577f, -0.19158728f, 0.01972221f, 0.08564471f, 0.12290452f, -0.14913164f, 
    0.03846527f, -0.12887768f, -0.06449701f, -0.38222101f, -0.22823426f, 0.00613369f, -0.06626558f, -0.16283047f, 
    -0.00929416f, 0.35743576f, -0.05027292f, -0.00866391f, -0.27853167f, -0.29953289f, -0.26200116f, -0.08172739f, 
    -0.49509442f, -0.14002608f, -0.07149547f, 0.03058765f, -0.00296956f, 0.20778136f, 0.32906023f, 0.20635507f, 
    -0.01260064f, 0.05959610f, 0.02393935f, 0.16417246f, -0.00031896f, 0.07797495f, -0.70210505f, -0.50288731f, 
    -0.26437381f, -0.03499144f, -0.22187826f, 0.10214785f, -0.04496884f, 0.00862562f, 0.14645472f, -0.39623550f, 
    0.02378185f, -0.29274073f, -0.12651725f, -0.12583834f, 0.19057785f, 0.17512894f, 0.02391022f, 0.15553696f, 
    -0.03179026f, 0.05071915f, -0.01424006f, -0.00917782f, -0.04851419f, -0.02212261f, -0.04432977f, 0.05080505f, 
    -0.01193198f, -0.03964696f, 0.02692065f, -0.02428445f, -0.00175347f, 0.04247782f, 0.00346556f, 0.00888052f, 
    -0.05913620f, 0.02393204f, -0.04958406f, 0.02281983f, -0.05926342f, 0.00711796f, 0.01330081f, -0.04684277f, 
    -0.00618659f, 0.05091272f, -0.00172936f, -0.00671969f, -0.03029264f, -0.01070815f, -0.05839638f, -0.02246582f, 
    0.00960258f, -0.05291795f, 0.03908764f, -0.02695677f, -0.04941474f, -0.03468982f, 0.00985075f, 0.02473319f, 
    -0.02387349f, -0.05930672f, 0.04550619f, 0.04629542f, 0.03304374f, -0.04212062f, -0.01737112f, -0.03172669f, 
    -0.04544978f, -0.04326030f, 0.02247456f, -0.00855972f, -0.04040807f, -0.05464123f, -0.00827599f, -0.00964964f, 
    -0.02939940f, -0.02211415f, 0.04262999f, -0.02325531f, -0.01228532f, -0.01090664f, -0.03018654f, -0.04107629f, 
    -0.00797652f, -0.03124527f, -0.02382486f, -0.05332811f, 0.00609107f, 0.00868569f, -0.00131408f, 0.02835582f, 
    0.02964783f, 0.02932981f, -0.05273918f, -0.00191028f, 0.04368789f, 0.02003312f, -0.05523023f, 0.01648762f, 
    0.00052186f, -0.00149545f, -0.06210303f, 0.01078541f, -0.02110315f, -0.02552315f, -0.06252272f, 0.04770605f, 
    0.02512492f, -0.02424661f, 0.00844261f, 0.01447561f, 0.05014459f, -0.02753357f, -0.05754615f, -0.00641554f, 
    0.00614176f, 0.02508904f, -0.06261815f, -0.00603025f, -0.01730893f, 0.01485392f, 0.05713783f, 0.03357362f, 
    -0.02103177f, -0.05417554f, -0.03685072f, 0.03976765f, 0.05124641f, 0.05154535f, -0.00758525f, 0.05288971f, 
    -0.03945806f, -0.05455908f, -0.01606531f, 0.05113085f, -0.03349696f, 0.00629088f, -0.03774989f, -0.02247430f, 
    0.01388111f, -0.05425481f, 0.04283035f, -0.04583967f, 0.01924320f, -0.06052573f, -0.00120528f, 0.00161062f, 
    0.00778983f, 0.03081786f, -0.01016795f, -0.06184548f, 0.05257361f, -0.02226611f, 0.03208803f, -0.05714472f, 
    0.04461176f, 0.01554304f, 0.01481431f, -0.04739197f, 0.04308762f, 0.05046370f, 0.01596743f, -0.05841561f, 
    0.01135015f, 0.01892091f, -0.02104068f, -0.04030371f, -0.05263043f, 0.05003340f, 0.05548339f, 0.00874125f, 
    0.05136983f, -0.05733609f, -0.02675785f, 0.05067749f, -0.05204617f, 0.04819237f, -0.04904827f, 0.00821746f, 
    -0.04841824f, -0.05311115f, -0.01252165f, 0.02046175f, -0.05818507f, -0.03915463f, 0.01016416f, 0.05206788f, 
    -0.02744039f, 0.04707026f, -0.03213774f, -0.02695921f, -0.00513701f, 0.04769441f, -0.03844499f, 0.03521072f, 
    -0.02699484f, 0.02181515f, 0.00013569f, -0.02436643f, -0.06160123f, -0.03600880f, -0.03097408f, 0.03042429f, 
    -0.05868584f, -0.00263076f, -0.00800392f, 0.01206330f, 0.01294794f, -0.02754417f, -0.02413371f, 0.02005623f, 
    0.04031035f, 0.02940348f, -0.01808519f, 0.04006327f, -0.05592283f, 0.01584422f, 0.05825067f, 0.01028818f, 
    0.03477590f, 0.05295058f, 0.00243909f, 0.04709749f, 0.00777881f, 0.05076714f, 0.04336145f, -0.02628229f, 
    -0.04280467f, -0.03415122f, -0.00863621f, -0.00108338f, -0.06171348f, -0.02998026f, -0.03390564f, -0.00975645f, 
    0.00224818f, -0.05688139f, -0.05786477f, -0.00660840f, 0.04127045f, -0.05227108f, -0.02502533f, -0.04068024f, 
    -0.01211122f, -0.00797798f, -0.05359616f, -0.02013771f, 0.02878047f, -0.03404152f, -0.00542578f, -0.05663776f, 
    0.04523933f, -0.04913162f, 0.00372141f, -0.04035805f, -0.05569512f, 0.04217357f, 0.02392162f, 0.02030970f, 
    0.02397760f, -0.04959765f, 0.00188796f, 0.02909174f, 0.00882429f, -0.03175689f, -0.01513608f, 0.02378049f, 
    -0.02516131f, -0.06018444f, 0.03319403f, 0.01389926f, 0.04034220f, -0.01411032f, 0.00919832f, -0.01798536f, 
    -0.00425306f, -0.01117707f, -0.00323408f, 0.01599951f, 0.03326161f, 0.01509219f, 0.04512078f, 0.02209219f, 
    -0.01351360f, -0.00606161f, 0.02860727f, -0.05443739f, -0.02067781f, -0.01160831f, 0.04111852f, -0.04450518f, 
    -0.02479033f, -0.03983160f, -0.00655469f, 0.01326980f, -0.03353820f, -0.01429429f, -0.00688880f, -0.01930404f, 
    -0.06414030f, 0.04909279f, 0.01400221f, -0.00772496f, -0.06260025f, -0.06367855f, 0.04568240f, -0.00804909f, 
    -0.02522391f, 0.04929784f, -0.03091853f, 0.04196317f, -0.03959059f, -0.00004020f, -0.02156383f, -0.02763196f, 
    -0.04797556f, -0.01934478f, 0.04400559f, -0.04882058f, 0.02356687f, 0.00959146f, 0.01515710f, 0.02336952f, 
    -0.04136604f, -0.03213038f, -0.03304978f, -0.01863891f, -0.02234080f, -0.01520024f, -0.00869150f, 0.01091653f, 
    -0.02087719f, -0.02957297f, 0.01997693f, -0.05024477f, -0.03573760f, -0.01404888f, -0.00681814f, -0.01713924f, 
    0.04786231f, 0.00539924f, -0.04230694f, -0.05251084f, 0.01934808f, -0.06270687f, -0.01406263f, -0.01290724f, 
    0.03135633f, 0.00952739f, -0.04941157f, -0.03903260f, 0.03095067f, 0.00640580f, -0.01891023f, -0.02959787f, 
    0.00281574f, -0.03786058f, 0.01422878f, 0.01179088f, -0.01409169f, -0.01525623f, -0.01291628f, -0.06132362f, 
    0.04730965f, 0.04642113f, 0.01229580f, 0.04566754f, 0.04066405f, -0.05975262f, -0.05625254f, 0.00329302f, 
    0.04750419f, -0.04925919f, -0.05809837f, 0.03413749f, -0.00114930f, 0.04186777f, 0.01751275f, 0.02184119f, 
    -0.04695470f, 0.00245327f, 0.00758792f, -0.04507812f, 0.04180647f, -0.04266179f, 0.02153737f, -0.00641800f, 
    0.00342862f, -0.01417771f, 0.00618331f, 0.04255999f, 0.02022284f, -0.04350066f, -0.02103147f, -0.02422919f, 
    -0.05406228f, -0.06077512f, 0.01560529f, -0.02306467f, 0.04954893f, -0.05733038f, -0.02872579f, 0.04112055f, 
    0.04159676f, 0.02808633f, 0.00473102f, 0.04319101f, -0.06126352f, 0.02379250f, 0.05287160f, 0.00922858f, 
    -0.03401912f, -0.01176140f, 0.00230787f, -0.00412187f, -0.04532839f, 0.03867343f, -0.00105226f, -0.05997976f, 
    0.01346661f, -0.04319029f, 0.01022761f, -0.00366350f, -0.03236790f, -0.04221889f, 0.00493057f, -0.00521394f, 
    -0.02667380f, -0.04696038f, -0.00365745f, 0.01143159f, -0.06328551f, -0.05518360f, -0.02687749f, -0.05159552f, 
    -0.03186306f, -0.06845035f, 0.03642366f, -0.02068754f, 0.00333791f, 0.00817005f, -0.05480405f, -0.06461447f, 
    -0.06023227f, -0.02763012f, 0.00961772f, -0.05793908f, 0.00474663f, -0.06126137f, 0.00337717f, -0.04499718f, 
    -0.00357722f, 0.00841176f, -0.01373249f, -0.05622990f, 0.01520854f, 0.02754431f, 0.00495241f, 0.00395430f, 
    0.02390336f, -0.05842459f, -0.00197568f, 0.04687683f, 0.02018364f, 0.04426746f, -0.05311315f, 0.00628197f, 
    -0.04678225f, 0.02558105f, 0.02697808f, -0.00368543f, 0.02459262f, -0.03313404f, 0.01725258f, -0.02437315f, 
    0.01306933f, 0.01878771f, 0.03171692f, -0.00677768f, 0.04005529f, 0.03789170f, -0.02254662f, -0.02964625f, 
    0.03352199f, 0.04648894f, -0.01418548f, -0.03179044f, -0.04485929f, -0.00740265f, 0.04128965f, 0.02375929f, 
    0.00177500f, 0.03281719f, 0.00655660f, 0.04015617f, 0.04578308f, -0.05213289f, -0.01484148f, -0.00222910f, 
    0.00345241f, 0.00494564f, -0.00352607f, -0.05011674f, -0.04136711f, -0.00341123f, -0.00323864f, 0.02360610f, 
    0.00349504f, 0.01156609f, 0.01800273f, -0.02515919f, 0.03187863f, -0.04762046f, -0.02880139f, -0.00644875f, 
    -0.02029085f, -0.03863513f, 0.03220356f, 0.02515118f, 0.03501773f, 0.00163334f, -0.02655471f, -0.04741004f, 
    0.05047529f, -0.05144487f, -0.03147385f, -0.02284972f, -0.03986998f, -0.04958552f, -0.01403451f, -0.01899550f, 
    0.04668143f, 0.01540735f, 0.02473121f, 0.01618997f, -0.06195328f, -0.03020518f, -0.05423258f, 0.01875308f, 
    -0.00107312f, 0.02637500f, -0.01632016f, -0.04771568f, 0.00767884f, -0.02827733f, 0.00675083f, 0.02537456f, 
    0.03575110f, -0.04484184f, -0.06269390f, 0.02315467f, 0.02024491f, 0.02743030f, -0.04089987f, -0.01916816f, 
    0.02748640f, -0.02087588f, -0.04586672f, -0.03679533f, -0.02134077f, -0.03194730f, -0.06869303f, 0.01033988f, 
    -0.02946978f, -0.04946842f, -0.04642215f, -0.03680017f, -0.04492379f, -0.04672054f, 0.00479517f, 0.03205112f, 
    -0.03711925f, 0.01454480f, 0.01859797f, 0.04117108f, -0.03858745f, 0.03352759f, 0.00527435f, -0.05631009f, 
    -0.04410205f, -0.02803257f, -0.04588307f, -0.01720150f, -0.05995712f, 0.02959035f, -0.03895190f, -0.01734283f, 
    0.02178017f, 0.03344927f, -0.04157416f, -0.06155983f, -0.01492079f, -0.01575679f, -0.03791992f, -0.06113216f, 
    0.02544127f, -0.06904829f, -0.03943523f, -0.16535716f, 0.03836150f, -0.00015572f, -0.01578363f, 0.09780376f, 
    0.09037396f, -0.01521718f, -0.08599354f, 0.39056447f, -0.05805288f, -0.11255907f, 0.02364636f, -0.11557225f, 
    -0.05071390f, 0.14989293f, -0.02553008f, 0.10583436f, 0.00131032f, 0.07188995f, -0.05020934f, -0.02595846f, 
    0.01413376f, 0.11389223f, -0.07409438f, -1.00142193f, 0.61143523f, -0.09196185f, 0.05515558f, -0.15659468f, 
    0.11131802f, -0.04212829f, -0.13053881f, -0.12541065f, -0.02923455f, 0.01909937f, 0.00783230f, 0.05835437f, 
    0.10591343f, -0.01342862f, 0.12687810f, -0.02666561f, 0.04832051f, -0.00425065f, 0.16887386f, 0.01762610f, 
    -0.00162836f, -0.05480438f, 0.12894167f, 0.10881975f, 0.04389089f, -0.08100531f, 0.01384557f, 0.07083354f, 
    0.06107500f, -0.07498048f, -0.02541348f, 0.00640141f, 0.03208359f, 0.06741513f, 0.00426593f, 0.14227158f, 
    -0.22421455f, -0.19582121f, -0.01205560f, -0.05044861f, 0.19292890f, -0.04219172f, -0.06766147f, 0.32528946f, 
    0.00260122f, 0.12834387f, 0.34169215f, -0.07019930f, -0.04439872f, -0.01504158f, -0.05336205f, 0.20193258f, 
    0.07927524f, 0.11893728f, -0.18055180f, 0.22975665f, 0.06255016f, 0.17001428f, -0.07932141f, 0.07716852f, 
    -0.10123601f, 0.02679006f, -0.40850157f, 0.29473796f, 0.28285617f, -0.10151819f, -0.03356668f, -0.22288591f, 
    0.14052394f, 0.02014801f, 0.00287125f, -0.01412419f, -0.16297503f, -0.16308492f, -0.01969180f, 0.16586652f, 
    -0.08191528f, 0.05910791f, 0.07369305f, 0.12500411f, 0.10386053f, 0.02751677f, 0.00152677f, -0.04305338f, 
    -0.08349266f, 0.19005755f, 0.03423503f, -0.04707895f, -0.04893725f, -0.00094067f, -0.27473381f, 0.44191217f, 
    0.00071327f, 0.06723980f, -0.25865644f, 0.04534120f, -0.01511781f, 0.04841670f, -0.01112892f, 0.18792348f, 
    0.02357578f, -0.08515294f, 0.22329274f, -0.00974910f, 0.07300333f, 0.07260507f, -0.00202048f, -0.21534079f, 
    0.16484900f, -0.04619354f, 0.00152429f, 0.00270557f, -0.23532064f, 0.01648436f, -0.06489036f, -0.08153252f, 
    -0.20272954f, 0.28823692f, 0.13670413f, -0.16474564f, -0.04138444f, -0.12147246f, 0.06998879f, 0.11188526f, 
    -0.06191018f, 0.08329667f, -0.20108934f, -0.45805845f, 0.08557045f, 0.00159243f, -0.03193322f, 0.11478660f, 
    0.09195445f, 0.00198593f, -0.49860302f, -0.08922827f, -0.12684685f, 0.29489705f, 0.24327089f, -0.02445018f, 
    -0.14742877f, -0.16011278f, -0.16945781f, 0.11985099f, -0.08407511f, 0.15666565f, 0.07552202f, -0.08533374f, 
    0.05693998f, -0.00924525f, 0.05112578f, 0.04678356f, -0.22812274f, -0.05470247f, 0.06560324f, 0.02159541f, 
    0.05632191f, -0.04764272f, 0.06972239f, 0.03031386f, 0.09798501f, 0.13436362f, 0.21283241f, 0.30707207f, 
    -0.06499596f, -0.05154382f, 0.08845443f, -0.01427954f, 0.06379572f, 0.05508282f, -1.18623614f, 0.57626438f, 
    -0.16053927f, 0.18836766f, 0.04063847f, -0.02860858f, 0.06163067f, -0.13932638f, -0.08468069f, 0.12179469f, 
    0.12181987f, 0.22588509f, 0.01854133f, -0.16248752f, -0.18445285f, 0.11273085f, 0.00572787f, -0.04057951f, 
    -0.35753998f, -0.32327327f, -0.13183358f, 0.17925707f, 0.15760493f, 0.01881130f, 0.13787274f, -0.04651789f, 
    0.07059206f, -0.34209293f, -0.02515839f, 0.03808353f, 0.11147072f, 0.10318507f, -0.06340842f, -0.11885171f, 
    -0.07879455f, 0.00494344f, -0.01037494f, 0.05711434f, 0.26600766f, -0.01256337f, 0.08273908f, -0.20727471f, 
    -0.00600250f, -0.17333584f, -0.09271532f, 0.16283011f, 0.20568013f, 0.18962021f, -0.07839637f, -0.22303355f, 
    -0.01754531f, -0.09305859f, -0.13936840f, 0.09519896f, -0.04344675f, -0.30759236f, -0.08811930f, -0.14913118f, 
    -0.13919102f, -0.14842187f, 0.06840188f, -0.08272623f, 0.18192482f, -0.10738268f, 0.04415210f, -0.01337445f, 
    0.04735900f, 0.03992567f, -0.05845637f, -0.03920663f, -0.07169242f, 0.11199560f, 0.11717522f, 0.26518297f, 
    0.21463178f, -0.08137611f, -0.08345079f, -0.00467600f, -0.08829337f, -0.03638271f, -0.07445883f, 0.19024700f, 
    0.04325699f, 0.17555948f, 0.05566426f, -0.01977750f, 0.29796597f, -0.09228964f, 0.06244355f, 0.01254794f, 
    -0.05559476f, -0.21476455f, 0.22859335f, 0.02006668f, -0.00805255f, 0.03432870f, -0.06010693f, 0.08748510f, 
    0.16921921f, -0.07940167f, -0.05712107f, 0.06070729f, 0.05599573f, 0.24052425f, 0.09723324f, -0.06298627f, 
    -0.16652535f, -0.06536733f, 0.05647098f, 0.04195522f, 0.03657299f, 0.07958660f, 0.04973496f, -0.16254969f, 
    -0.22152881f, -0.08374292f, -0.03304712f, 0.59839272f, 0.22197124f, 0.10123594f, -0.03529092f, 0.22774178f, 
    -0.09458188f, 0.03451478f, 0.11932920f, 0.03490588f, 0.08279656f, 0.01839836f, 0.19240710f, 0.11406928f, 
    0.21352620f, 0.13182007f, -0.02999840f, 0.24164708f, 0.25359631f, -0.12993813f, 0.06960062f, -0.12168237f, 
    -0.10132012f, 0.11777205f, 0.08919760f, -0.18090253f, -0.03009482f, -0.03665680f, 0.09229314f, 0.09027117f, 
    0.09803919f, -0.02268812f, 0.02427602f, -0.14106204f, -0.03100056f, 0.14014998f, 0.02161877f, -0.00227162f, 
    0.43025467f, 0.15720177f, -0.06995676f, 0.06152333f, 0.11847900f, -0.13231367f, 0.05988238f, 0.06970348f, 
    0.24435994f, 0.00339213f, 0.15350164f, 0.15668663f, 0.11699036f, 0.04132618f, 0.11266130f, 0.10079650f, 
    0.00365837f, -0.05455021f, 0.07175900f, 0.04315068f, -0.08538185f, 0.30951381f, 0.00917191f, 0.05712666f, 
    0.08392909f, 0.11860133f, 0.15040961f, 0.03782355f, 0.15431216f, -0.12265255f, 0.11272896f, 0.12395191f, 
    0.03693686f, 0.18495795f, 0.21861103f, 0.17767778f, 0.24534692f, 0.21348846f, 0.03075876f, 0.05501183f, 
    -0.07556666f, -0.17392273f, 0.04904742f, 0.11015224f, 0.02264951f, -0.17059159f, -0.10289220f, 0.22655611f, 
    0.07811338f, 0.22120009f, -0.04725583f, 0.03653658f, -0.01644865f, -0.12667322f, 0.04483821f, 0.17771854f, 
    -0.16222143f, 0.09010381f, -0.00352062f, -0.02374147f, 0.21596211f, -0.20628141f, 0.03169696f, 0.03905954f, 
    -0.33705536f, -0.02823667f, 0.06416854f, -0.15360187f, 0.18610111f, 0.10370371f, -0.00438522f, -0.05911030f, 
    0.12066463f, -0.06246059f, -0.06576017f, -0.04880636f, -0.13632041f, -0.04044981f, -0.01964807f, -0.06343743f, 
    0.30691302f, 0.12571634f, 0.21151146f, -0.02297036f, 0.07869020f, 0.09527963f, 0.09241265f, -0.01207781f, 
    0.12151649f, 0.47884938f, 0.31761798f, 0.39920413f, -0.01097160f, -0.10511608f, 0.05474468f, 0.06870836f, 
    0.03093337f, 0.08069975f, -0.16126339f, 0.25208077f, 0.04338613f, 0.06217149f, 0.05645894f, -0.14007188f, 
    -0.09703317f, -0.20384568f, -0.27156302f, -0.03332238f, 0.17811036f, 0.21040852f, 0.00049213f, 0.07066473f, 
    0.07203691f, 0.00133429f, 0.21341963f, 0.19195417f, 0.04502110f, -0.00034125f, 0.17334725f, -0.12021775f, 
    0.11344344f, 0.27866051f, 0.18443665f, 0.05343591f, 0.07896294f, -0.00076392f, -0.17710726f, 0.07540449f, 
    0.00830534f, 0.12875596f, 0.05079791f, -0.14073752f, 0.07354481f, 0.05202963f, 0.38657930f, 0.02865047f, 
    -0.18266146f, -0.02283323f, 0.24428385f, 0.07479329f, -0.02606845f, -0.00128965f, -0.02771886f, 0.10470526f, 
    0.00326663f, 0.02944402f, 0.02502281f, 0.00608215f, 0.19537427f, -0.17910916f, -0.25255182f, -0.17674550f, 
    -0.01189590f, 0.31470603f, 0.06842908f, -0.25178093f, 0.09312884f, -0.05890019f, 0.07494970f, 0.12236378f, 
    0.08571316f, -0.23684564f, -0.13721697f, 0.02185846f, 0.09062589f, 0.16797513f, 0.05937089f, -0.18779306f, 
    -0.50184429f, -0.07911398f, 0.14038964f, -0.08736122f, -0.14448495f, 0.08836482f, 0.09807446f, -0.02428783f, 
    0.17848493f, 0.20171028f, -0.20878635f, 0.08187042f, 0.24323972f, -0.09266716f, -0.05806645f, 0.02570881f, 
    -0.03423623f, 0.02974466f, -0.07165346f, 0.00330879f, -0.13944723f, 0.06036980f, 0.14268765f, 0.12560125f, 
    0.14140736f, 0.33482814f, 0.00091097f, 0.29391685f, 0.07288830f, 0.19542085f, -0.13623093f, -0.12656188f, 
    0.16019501f, -0.08684727f, 0.09099252f, -0.15710104f, 0.01165032f, -0.17211987f, -0.13408798f, -0.21407501f, 
    -0.47010779f, -0.00117477f, 0.11690410f, 0.10945430f, 0.10662100f, 0.07278535f, 0.00389270f, -0.53944933f, 
    0.19195364f, -0.00501623f, -0.06461778f, 0.18822533f, 0.06049273f, 0.09548385f, 0.00942946f, -0.16939756f, 
    -0.05115459f, 0.02164202f, 0.03295532f, -0.00191964f, 0.03380694f, -0.06793676f, -0.05771738f, -0.01593009f, 
    -0.01506847f, -0.00179148f, -0.02167151f, -0.00423896f, -0.03380236f, 0.01033612f, 0.00193302f, 0.02059674f, 
    -0.04835233f, -0.06644465f, 0.02458973f, -0.05563416f, -0.04210281f, -0.00648906f, -0.05669966f, 0.05488091f, 
    0.01951690f, -0.03440211f, -0.03021084f, -0.01387324f, 0.00777293f, -0.05550080f, 0.01580856f, 0.04253604f, 
    -0.05538984f, -0.01341031f, -0.01281149f, -0.03668188f, 0.02603563f, -0.05587626f, -0.01812730f, -0.06412186f, 
    0.03161566f, -0.03774134f, 0.02568209f, -0.00603716f, -0.00108032f, -0.04123590f, -0.01065782f, -0.01775587f, 
    -0.02492205f, 0.01850832f, -0.05022487f, -0.02659439f, -0.00802930f, -0.02160591f, -0.01765079f, -0.03763751f, 
    -0.04021467f, 0.02411426f, -0.01760558f, 0.00220297f, -0.03472856f, 0.04586492f, 0.00906713f, 0.02633832f, 
    -0.03786844f, 0.03480219f, -0.02180319f, 0.01569986f, 0.02875077f, 0.01144301f, -0.05503986f, -0.03005225f, 
    -0.06849443f, 0.03547719f, -0.00952111f, 0.04443929f, -0.01587872f, -0.02861333f, 0.00093672f, -0.04014303f, 
    -0.01243523f, 0.04095636f, 0.02755217f, -0.00782541f, 0.01665196f, 0.02470952f, 0.04017394f, -0.05484679f, 
    0.00810032f, -0.05870088f, -0.04066796f, 0.04224325f, -0.03936356f, -0.00198129f, 0.03650033f, -0.01833585f, 
    0.01567975f, -0.00052942f, 0.00815585f, -0.01595069f, 0.05141021f, -0.00326120f, -0.04787729f, -0.06793000f, 
    -0.06673709f, -0.04659882f, -0.02352443f, 0.04744568f, -0.01770521f, -0.03347437f, -0.03089578f, 0.02158805f, 
    -0.01834115f, 0.00879489f, 0.02008121f, 0.01046414f, -0.03068478f, -0.02321275f, -0.00062079f, -0.01221005f, 
    0.04546339f, -0.06578343f, -0.06752867f, -0.04622376f, 0.04920363f, -0.01663394f, -0.04940826f, 0.00309393f, 
    0.02126347f, -0.02368153f, -0.04020587f, 0.02898626f, -0.01567039f, -0.04005472f, -0.03937061f, 0.04234082f, 
    0.03218072f, -0.01941055f, -0.05614320f, -0.02479479f, -0.01340632f, -0.02913891f, -0.03406581f, -0.01259272f, 
    -0.06176965f, -0.05141152f, 0.02928789f, 0.00955992f, 0.02394644f, 0.02505539f, 0.01396265f, -0.02628040f, 
    -0.00586933f, 0.01574568f, -0.02606467f, 0.01655981f, -0.03186731f, 0.01513344f, 0.04403561f, -0.05314402f, 
    -0.01594859f, -0.04167561f, -0.01519818f, -0.00030775f, -0.00776560f, -0.01329660f, 0.02343737f, 0.00441024f, 
    -0.06823276f, 0.03216339f, -0.05441902f, -0.02004456f, -0.05007307f, -0.00733424f, -0.04893503f, -0.04632707f, 
    0.00870986f, -0.04829393f, -0.04965980f, -0.06103314f, -0.05810020f, -0.02651780f, -0.06505565f, -0.00294912f, 
    0.02707339f, 0.02799807f, -0.06080605f, -0.06627221f, -0.02457686f, -0.04873626f, 0.04283946f, -0.05441928f, 
    0.02326457f, 0.00024610f, 0.00641757f, 0.01368108f, 0.00500511f, 0.00600219f, -0.00695557f, 0.02069182f, 
    -0.00925368f, 0.04211249f, -0.06474002f, 0.03197983f, -0.03686760f, -0.00318359f, -0.01951868f, -0.06548885f, 
    -0.02742514f, 0.00880493f, 0.01447419f, 0.02158403f, 0.01986711f, -0.00379169f, -0.06821490f, 0.00746454f, 
    -0.00873870f, -0.04257802f, -0.00950077f, -0.03077769f, -0.02296413f, -0.00285502f, -0.04042672f, -0.03116848f, 
    -0.01858920f, 0.00657400f, -0.00538637f, 0.01117836f, -0.01989009f, -0.02840708f, 0.03973104f, -0.02280684f, 
    0.03332106f, -0.00532846f, -0.03217340f, 0.01495656f, 0.00666782f, 0.01511394f, -0.02888394f, 0.04633914f, 
    0.00906504f, 0.01945382f, -0.03537934f, -0.01720991f, -0.06541186f, 0.01257157f, -0.05025304f, -0.01704786f, 
    -0.04227711f, 0.01271776f, 0.02380073f, -0.04356543f, -0.00178587f, -0.05646991f, -0.01253017f, -0.00896734f, 
    -0.03728281f, -0.04602076f, -0.00728289f, -0.03801284f, -0.06325427f, -0.00112459f, 0.04644245f, 0.04290941f, 
    -0.06495494f, 0.00125188f, 0.03092721f, -0.00746591f, -0.06840827f, 0.04006178f, -0.01545671f, -0.05196494f, 
    -0.00399138f, -0.03795597f, -0.04373067f, -0.03595188f, -0.04008564f, -0.04638089f, -0.00050134f, -0.03834154f, 
    0.02667629f, -0.02417504f, 0.02563859f, -0.05059091f, 0.04835283f, 0.03917520f, 0.00321627f, -0.01851344f, 
    0.02138432f, -0.08379823f, -0.05246190f, 0.06648634f, 0.07193086f, 0.03485572f, -0.03004717f, -0.06717446f, 
    0.09939894f, 0.08841030f, -0.06597084f, -0.00878553f, 0.02081447f, 0.02445855f, 0.06825311f, 0.12984991f, 
    -0.18607529f, 0.17114136f, 0.09742676f, -0.03273612f, -0.12833995f, 0.00635319f, 0.15409599f, -0.11689699f, 
    -0.02052144f, 0.09015942f, -0.00138708f, 0.36779037f, 0.26130769f, -0.50795668f, -0.24828964f, 0.01306706f, 
    -0.10689390f, 0.18321314f, 0.11042234f, 0.03086083f, 0.03221057f, 0.01226250f, 0.03728899f, -0.01850748f, 
    -0.12466646f, -0.00740669f, -0.02241799f, 0.09417111f, 0.32834944f, 0.03612805f, 0.06893843f, 0.08967989f, 
    0.03374509f, 0.02513444f, 0.13829584f, -0.11213693f, -0.03557248f, 0.02226970f, 0.01273783f, -0.13463570f, 
    0.04529887f, 0.15788826f, 0.15507352f, -0.15696630f, -0.08844817f, 0.00652878f, 0.23132618f, -0.05146322f, 
    0.04562640f, 0.17750379f, 0.11363857f, -0.11525430f, 0.07599803f, -0.00967800f, 0.08548862f, -0.01746743f, 
    0.27139741f, 0.04320067f, 0.03692530f, 0.00936194f, 0.04491280f, 0.13037841f, 0.02142577f, -0.02415866f, 
    -0.19064881f, 0.02234945f, -0.02053997f, 0.17568351f, 0.00363677f, 0.06818610f, 0.00553759f, 0.12281355f, 
    0.10095863f, 0.16136691f, 0.02587857f, 0.15381353f, -0.23196949f, -0.09474500f, -0.03782377f, 0.01772693f, 
    -0.05428269f, 0.09278303f, 0.14207742f, 0.09467907f, -0.04090058f, 0.10332462f, -0.14112607f, -0.24111889f, 
    -0.10866029f, -0.03728585f, 0.07549968f, 0.15346952f, 0.04617129f, -0.09727639f, 0.01432403f, 0.13339964f, 
    0.05220834f, 0.08404959f, 0.30864829f, -0.12889752f, -0.04374505f, -0.05074551f, 0.06440809f, 0.09447365f, 
    0.18294056f, 0.04640586f, 0.19860280f, 0.01988078f, -0.05785795f, -0.01304671f, 0.10846629f, 0.13480781f, 
    -0.25445676f, -0.03612457f, 0.17654377f, 0.07255619f, 0.11885816f, 0.07921565f, 0.12641659f, 0.12978852f, 
    0.24559300f, -0.12827393f, 0.12116588f, -0.06388257f, 0.07527526f, -0.01514015f, 0.14487003f, -0.10244092f, 
    -0.11029004f, 0.10702282f, 0.11061440f, 0.11490518f, 0.09665225f, 0.11310109f, 0.20444249f, 0.01437182f, 
    0.01655581f, 0.31505927f, -0.08744274f, 0.29286838f, -0.03601683f, -0.04762921f, -0.05141857f, 0.25201207f, 
    0.10463389f, 0.05280693f, -0.01005948f, 0.26892570f, 0.23958908f, 0.20834641f, 0.08082237f, -0.49243894f, 
    -0.00887950f, 0.04024858f, -0.29315194f, -0.07830055f, 0.03415993f, -0.07783792f, 0.00603132f, -0.19959320f, 
    0.22040243f, 0.00827333f, 0.16966693f, 0.20586644f, 0.12576742f, 0.21017817f, -0.17530261f, -0.06877771f, 
    -0.04973995f, 0.20124398f, 0.08997826f, 0.03595333f, 0.08502530f, -0.13283850f, -0.08487000f, -0.00073244f, 
    -0.16615781f, 0.10209182f, -0.01946419f, 0.04934490f, -0.06343282f, 0.09455243f, 0.11789835f, -0.04534787f, 
    -0.37466818f, 0.02770042f, 0.07056370f, 0.11513864f, 0.14502592f, -0.11529641f, 0.09772097f, 0.00198660f, 
    0.04875216f, -0.10887403f, -0.02906117f, 0.17687520f, 0.20712890f, 0.13913150f, 0.00988986f, -0.08774089f, 
    0.16247068f, -0.00868297f, -0.00990531f, 0.10212812f, -0.07728323f, -0.11975468f, -0.01977246f, 0.05339264f, 
    0.24579452f, 0.03422260f, 0.06194089f, 0.19476180f, 0.01671160f, 0.15359472f, -0.14295256f, 0.15655920f, 
    -0.17496429f, -0.57065797f, 0.17255414f, -0.06488477f, 0.20168315f, -0.07947749f, 0.12685376f, 0.06896822f, 
    -0.01245755f, 0.14988978f, -0.13058802f, -0.00120843f, 0.19160011f, -0.15787794f, -0.02398298f, -0.02099521f, 
    0.08663626f, -0.01714694f, 0.03240115f, 0.03157390f, -0.19673894f, -0.18948916f, -0.18733235f, -0.00717735f, 
    -0.07195508f, 0.03053200f, -0.17601730f, 0.09919821f, 0.16675207f, 0.00583447f, -0.11065093f, 0.11467386f, 
    0.09164003f, 0.04129308f, -0.14626086f, 0.13959090f, -0.22987401f, -0.21105346f, -0.22294936f, 0.01248092f, 
    -0.14988165f, 0.01486824f, -0.03818632f, 0.07645849f, 0.02594885f, 0.27130783f, -0.04277270f, -0.25895765f, 
    -0.02215527f, 0.00516771f, -0.01738887f, -0.05218663f, 0.14887790f, -0.00626757f, 0.13307051f, -0.02573930f, 
    0.38733828f, 0.07891622f, 0.41252959f, -0.14148781f, -0.15052833f, -0.39671701f, 0.19656150f, 0.11079382f, 
    0.00662690f, 0.14414319f, 0.26462561f, 0.16836451f, 0.03702534f, -0.14793575f, -0.07683992f, 0.04293432f, 
    0.05121282f, 0.05519620f, -0.00643588f, -0.02075738f, -0.08964136f, 0.02154864f, 0.07956686f, -0.02373006f, 
    0.14427975f, -0.05386248f, -0.05305328f, -0.43557706f, -0.00559751f, -0.63511842f, 0.02625883f, 0.05760556f, 
    0.05641782f, -0.05673445f, 0.17511533f, 0.25427160f, 0.30714816f, -0.40616018f, 0.05409585f, -0.00843694f, 
    0.15548529f, -0.16054535f, 0.14630547f, 0.05627951f, 0.06894764f, 0.13530257f, -0.13648973f, 0.09768013f, 
    -0.17758548f, 0.17072895f, -0.14569575f, -0.03503744f, -0.10932063f, -0.03549358f, -0.26099223f, -0.00942159f, 
    -0.04539625f, 0.05044273f, -0.02579194f, -0.00964889f, -0.07613451f, -0.08705151f, -0.01628206f, -0.04422998f, 
    0.11128933f, -0.19646870f, 0.11651453f, 0.02865119f, 0.04092964f, -0.15319999f, 0.02701480f, -0.07266019f, 
    0.19434044f, 0.06392465f, 0.12508139f, 0.12909380f, 0.15105173f, 0.06090941f, -0.00721387f, -0.09780843f, 
    -0.03519318f, 0.07785279f, -0.24153163f, -0.01312144f, 0.01024085f, -0.05503351f, 0.00278778f, 0.05566837f, 
    0.07021097f, -0.00807131f, 0.29652444f, -0.30593002f, -0.44364274f, -0.01400069f, 0.12813634f, -0.39617786f, 
    0.11704082f, -0.12950544f, -0.01771051f, 0.13113815f, -0.09849329f, -0.11663200f, 0.23148686f, -0.12780644f, 
    -0.24463664f, -0.11779767f, -0.07857598f, 0.12375295f, 0.09144424f, -0.15923211f, 0.17387456f, 0.15985203f, 
    -0.23938172f, -0.01471335f, 0.05471656f, -0.13243289f, -0.10230502f, -0.15661894f, 0.02111020f, -0.11003715f, 
    0.12023375f, 0.05206978f, 0.03105283f, 0.17063199f, 0.05577708f, -0.04549031f, -0.14683950f, -0.15328531f, 
    -0.08600526f, -0.08846493f, -0.05993412f, 0.09230576f, 0.13264577f, 0.05791639f, 0.06230040f, -0.16563548f, 
    0.31193453f, -0.42617634f, 0.25587371f, 0.06541301f, 0.12422015f, 0.10089526f, 0.12204474f, -0.10964273f, 
    0.01483282f, -0.14250034f, -0.19691481f, 0.14557536f, -0.16385342f, -0.01146997f, 0.07217169f, -0.06763104f, 
    0.04313270f, 0.09115773f, 0.28532505f, -0.17457955f, 0.03708519f, -0.09777179f, -0.10897257f, -0.03254119f, 
    0.02906435f, 0.10538231f, 0.02315860f, 0.33468494f, 0.15509798f, 0.17619368f, 0.02870826f, 0.24818477f, 
    -0.10403626f, -0.32426092f, -0.20481317f, 0.13504440f, -0.12221387f, 0.04938558f, 0.12163270f, -0.00347923f, 
    0.12564464f, 0.10997410f, 0.02308366f, 0.16243581f, 0.17469142f, 0.18250950f, -0.09216005f, -0.07755972f, 
    0.21985190f, -0.08665863f, 0.16124472f, 0.01264760f, 0.07757638f, 0.12134973f, -0.52286953f, 0.08051710f, 
    -0.21432506f, 0.02608258f, -0.16365537f, -0.00866934f, -0.06412428f, 0.01025432f, -0.11201782f, 0.28671661f, 
    0.18040927f, -0.17027320f, 0.00576562f, -0.21509036f, 0.12115530f, 0.03445960f, 0.01453868f, 0.30278108f, 
    0.31784299f, 0.28427580f, -0.16330488f, -0.13068542f, -0.04064359f, 0.16860552f, -0.10134181f, 0.06296422f, 
    -0.69834453f, -0.04320135f, -0.42816117f, 0.07825230f, -0.09433705f, 0.26486573f, -0.00843331f, 0.09825185f, 
    -0.01345997f, 0.00332555f, 0.24200699f, 0.18240349f, 0.09089172f, 0.00526621f, -0.10507594f, 0.00984086f, 
    -0.27456737f, -0.00363538f, 0.19606352f, -0.15180188f, -0.06457570f, 0.15455420f, 0.07950274f, 0.04736688f, 
    0.24551983f, 0.29382253f, -0.04768122f, 0.01098858f, -0.12955666f, -0.00555056f, -0.07953891f, 0.00097773f, 
    0.05585455f, 0.13610874f, 0.17499813f, 0.08615619f, 0.36375746f, -0.37826338f, -0.06205579f, -0.08967512f, 
    -0.10215560f, -0.23800126f, 0.01367481f, -0.07959422f, -0.10091311f, 0.16680314f, 0.04822000f, -0.08126082f, 
    -0.08560178f, -0.07519218f, 0.10125240f, -0.07939946f, -0.18646345f, -0.28685430f, -0.17661026f, -0.42897302f, 
    -0.32798430f, 0.07039215f, -0.16877630f, 0.03996821f, 0.08090734f, -0.01338481f, 0.13211410f, -0.11468159f, 
    0.11704040f, 0.28470683f, 0.04226837f, -0.08221816f, 0.07065605f, 0.05250122f, 0.06547007f, 0.03291981f, 
    0.31441954f, -0.06246108f, -0.00889232f, -0.00668581f, 0.10058019f, 0.13732310f, -0.17285265f, 0.00475659f, 
    0.09297724f, 0.16351438f, -0.13785258f, -0.05847474f, -0.03912259f, -0.02132636f, -0.04360414f, -0.06060147f, 
    -0.02402523f, -0.05271336f, 0.02655757f, 0.09681448f, -0.09458462f, -0.04733244f, 0.16057767f, 0.01390724f, 
    -0.03369771f, -0.05634950f, 0.11643991f, -0.52533484f, -0.25442702f, 0.32892838f, -0.01262497f, -0.21553248f, 
    -0.05051031f, -0.05480434f, -0.08875129f, 0.17155440f, 0.14735834f, 0.03160170f, 0.09664203f, -0.03224878f, 
    0.05828663f, 0.00131705f, 0.08184341f, 0.06677382f, -0.04333439f, -0.06146722f, -0.23143588f, -0.01628874f, 
    0.13812067f, -0.02431519f, 0.11513367f, -0.09959115f, -0.01623227f, 0.17600937f, -0.08354138f, 0.11653551f, 
    0.18653807f, 0.00973931f, 0.06622507f, -0.05611263f, 0.02544654f, -0.02804239f, 0.04193901f, 0.14338243f, 
    0.09039579f, 0.13895233f, -0.01871042f, 0.03582898f, 0.12439183f, -0.11726739f, 0.03334393f, -0.03224664f, 
    0.24453594f, 0.23337756f, 0.15366028f, -0.07500699f, 0.02268881f, -0.02210835f, -0.02136852f, -0.12297624f, 
    0.05702288f, -0.04454450f, 0.27685556f, 0.06409533f, -0.12871462f, -0.04600134f, 0.00229630f, 0.00154163f, 
    0.04732005f, -0.05973374f, 0.28233048f, -0.15888710f, 0.19502290f, -0.07887784f, -0.18262677f, -0.18690839f, 
    -0.03746345f, -0.05462810f, 0.10720730f, 0.12811427f, 0.06411046f, 0.11111504f, 0.00608750f, 0.12138987f, 
    -0.02686165f, 0.05249013f, -0.07937741f, -0.03954404f, 0.09685565f, 0.22482266f, 0.32736048f, -0.12654735f, 
    -0.00478117f, -0.13764024f, -0.12331134f, 0.02281286f, 0.03560362f, 0.07888538f, -0.12256581f, -0.17146562f, 
    0.06705687f, -0.03112402f, -0.05079247f, -0.07099637f, 0.01288167f, -0.14443894f, -0.09331527f, -0.43012318f, 
    -0.09620532f, 0.10128786f, 0.01150011f, -0.06265245f, 0.02378481f, -0.08468270f, -0.08626876f, 0.13552353f, 
    -0.01161617f, -0.13061997f, -0.13955832f, -0.01349271f, -0.05178007f, 0.01340752f, 0.03992435f, 0.05153252f, 
    0.07718618f, 0.09650644f, 0.19909669f, 0.00409611f, 0.05760516f, -0.07804786f, -0.03482129f, -0.06717111f, 
    -0.01119812f, -0.13592407f, 0.17197335f, -0.01993998f, -0.15454917f, -0.03558356f, -0.07106517f, 0.24791500f, 
    0.02522397f, 0.02007674f, -0.02962233f, 0.27896079f, -0.12392208f, 0.01371576f, 0.00112362f, -0.09776537f, 
    0.13011146f, 0.06444867f, -0.20429052f, 0.09406719f, -0.07308035f, -0.02239058f, 0.21261168f, 0.07049321f, 
    0.04625515f, -0.07082980f, -0.01431973f, -0.08451094f, 0.27560785f, -0.05893737f, 0.13172315f, -0.12975104f, 
    -0.07410819f, 0.18558237f, 0.02172682f, 0.05206708f, 0.04696531f, 0.14991120f, 0.03592362f, 0.26157913f, 
    0.06057221f, 0.08156724f, -0.05814910f, 0.03630555f, 0.00330413f, 0.05970084f, -0.32093328f, -0.20762376f, 
    0.01357333f, -0.09291209f, -0.07664574f, 0.21950780f, -0.07705612f, 0.01697149f, 0.09413816f, -0.01471850f, 
    0.20009041f, -0.15084706f, 0.05717639f, -0.17500468f, -0.08386920f, -0.01029513f, 0.00584657f, 0.07569766f, 
    -0.68481940f, 0.10520871f, -0.50030500f, -0.07956055f, -0.19236837f, -0.02310865f, 0.13666642f, 0.09188074f, 
    -0.06888951f, -0.06740258f, 0.01151855f, 0.06418632f, 0.06637940f, -0.03477953f, -0.01027059f, 0.10978070f, 
    0.02871133f, 0.03879622f, 0.13872926f, -0.06572203f, -0.13397263f, -0.05582397f, 0.04078188f, -0.00383028f, 
    -0.18028873f, 0.07880192f, -0.09376937f, 0.13969567f, 0.13438095f, -0.23476258f, -0.02786726f, 0.06060120f, 
    0.06276398f, 0.08976689f, 0.17142649f, 0.22489744f, 0.44485241f, -0.10809106f, 0.18374558f, -0.06988846f, 
    0.12475529f, 0.09093354f, -0.09910740f, -0.07592595f, 0.02695965f, 0.14145541f, 0.43783358f, 0.11955030f, 
    -0.25887522f, 0.00762258f, -0.22836480f, -0.02467640f, -0.02168949f, -0.12801598f, -0.03732434f, -0.02346448f, 
    -0.20194091f, -0.03006639f, -0.02829980f, -0.08911785f, 0.14458112f, -0.04271239f, -0.06372210f, -0.19695491f, 
    0.31733444f, -0.34415221f, 0.01187598f, -0.11334921f, 0.03643747f, 0.12423118f, 0.10000585f, -0.12829043f, 
    0.00524709f, -0.03420980f, 0.01865790f, -0.06609332f, 0.04252972f, -0.00901927f, 0.00499261f, -0.02179440f, 
    0.00793737f, -0.01623570f, -0.02765724f, -0.01811876f, -0.04931874f, 0.00193617f, -0.04819851f, -0.00862109f, 
    0.01900334f, -0.02990023f, 0.01499560f, -0.06167263f, 0.02506378f, -0.04085162f, -0.00555272f, 0.01631298f, 
    -0.02562523f, 0.04726735f, -0.04046908f, 0.04548277f, -0.00747274f, 0.03856611f, -0.05435019f, -0.03266294f, 
    -0.03495270f, 0.05141951f, -0.03702113f, -0.06373277f, 0.00367180f, 0.04032021f, -0.03535685f, 0.04107377f, 
    -0.04585819f, 0.00214331f, 0.04530444f, -0.01492792f, -0.02260391f, 0.01614822f, 0.01029369f, 0.02825610f, 
    0.00790613f, -0.04018147f, -0.02894116f, 0.03786020f, -0.02339501f, -0.06489031f, 0.03994954f, -0.04600894f, 
    0.03605787f, -0.04963964f, 0.01575004f, -0.06259172f, -0.02389619f, -0.05919424f, 0.00107845f, 0.00007495f, 
    0.03024753f, 0.02802355f, -0.02997704f, -0.01050244f, 0.01042138f, 0.02563485f, -0.04427259f, -0.06558853f, 
    0.04819075f, -0.05149185f, -0.05374941f, -0.04944209f, 0.00702333f, -0.00416603f, 0.00506927f, 0.00274003f, 
    -0.01621984f, -0.04784551f, -0.04922234f, 0.02731328f, 0.03732942f, 0.01259346f, -0.01341227f, -0.05019276f, 
    -0.03605410f, 0.03885367f, -0.01309304f, -0.01422186f, -0.04650501f, 0.01659768f, -0.05506242f, 0.03953736f, 
    -0.00215978f, 0.00680948f, -0.04155742f, -0.05201494f, 0.02945280f, -0.01339985f, -0.02284810f, -0.02216145f, 
    -0.04313823f, -0.00818307f, -0.04130819f, -0.04849454f, -0.04947533f, 0.02438784f, -0.06434837f, 0.03800944f, 
    0.01797507f, -0.01463562f, -0.03028938f, -0.04559455f, -0.06507058f, 0.02483578f, 0.02579575f, 0.00847913f, 
    0.03308113f, 0.03362151f, 0.03055028f, -0.02756805f, -0.04165648f, -0.04078316f, -0.00070698f, -0.02287037f, 
    -0.03791890f, 0.04941342f, 0.03025252f, 0.03361056f, -0.01258330f, 0.01269096f, -0.05723235f, 0.01065468f, 
    0.02713079f, -0.00376192f, 0.02003910f, -0.05777299f, 0.01427401f, 0.03761014f, -0.03446693f, -0.06103410f, 
    -0.05303872f, -0.01352058f, 0.01906010f, -0.06256600f, -0.03785110f, -0.02278621f, 0.02723131f, 0.04468462f, 
    -0.01194631f, -0.02100848f, -0.00982039f, 0.02282361f, 0.00861828f, -0.03723964f, -0.06176991f, 0.01569611f, 
    -0.05663729f, 0.00647123f, 0.02783697f, -0.02750710f, 0.00845747f, -0.03828540f, -0.02356413f, 0.02776736f, 
    0.03508929f, -0.06124509f, 0.03865549f, 0.03577774f, -0.00121413f, -0.00066170f, -0.00116492f, -0.00913251f, 
    -0.03320344f, -0.02510118f, 0.00182934f, -0.02315982f, -0.03179266f, 0.00881328f, -0.05314897f, 0.04994207f, 
    -0.01824233f, -0.05808342f, -0.00847403f, -0.02380446f, 0.04210491f, -0.03586143f, 0.01096716f, 0.00847694f, 
    0.04389843f, -0.00336663f, 0.00528707f, -0.06226770f, -0.05179324f, 0.01967352f, -0.02160632f, -0.03207397f, 
    -0.06175690f, -0.05329233f, -0.05925272f, -0.02910647f, 0.05893406f, -0.00424889f, -0.02866523f, -0.02967484f, 
    -0.05925458f, 0.01799795f, -0.04477730f, -0.00223935f, 0.03851433f, -0.02197278f, 0.05013249f, 0.02181009f, 
    -0.03695001f, 0.04056421f, -0.00300078f, 0.00351778f, 0.01817326f, -0.00262447f, -0.01701812f, 0.02295780f, 
    0.02777064f, -0.01851700f, -0.02370903f, -0.03947927f, -0.00985222f, -0.00688558f, 0.00895444f, 0.01438186f, 
    -0.05163036f, -0.04168459f, -0.01958981f, -0.06271453f, -0.02895688f, -0.01625808f, 0.03150086f, -0.03943790f, 
    0.03235945f, -0.02100591f, 0.04431057f, 0.02669124f, -0.05565961f, 0.04625010f, 0.01137215f, -0.00134738f, 
    0.01023475f, 0.04538905f, 0.01488799f, 0.01526397f, 0.04294978f, -0.03467063f, -0.04308429f, -0.06276764f, 
    -0.06199573f, -0.00197824f, -0.02750245f, -0.00382209f, 0.03606108f, -0.01096073f, -0.00870146f, -0.00445337f, 
    0.01048645f, 0.02521849f, 0.00875394f, 0.03549872f, -0.04138316f, 0.04644831f, -0.01120343f, 0.03948406f, 
    0.02549521f, -0.00254324f, -0.03529776f, 0.00259740f, -0.03207389f, -0.01617833f, 0.03144297f, 0.01075472f, 
    -0.02608233f, 0.02108734f, -0.03876344f, -0.00824674f, 0.03586439f, -0.04700696f, -0.00071094f, -0.03572682f, 
    -0.00836820f, -0.08407757f, -0.27502888f, -0.00848290f, -0.21681531f, 0.15816088f, 0.06544989f, -0.12219314f, 
    0.06127618f, 0.15369281f, 0.04518206f, -0.07368661f, -0.08178340f, 0.07187605f, 0.11116228f, 0.16440512f, 
    -0.03835583f, -0.07048474f, 0.02282602f, 0.09002002f, 0.03685126f, 0.16260155f, 0.02028403f, 0.05130890f, 
    -0.17438808f, -0.05997313f, -0.18992530f, -0.00770285f, 0.28412321f, 0.41661492f, 0.06382714f, 0.24664572f, 
    0.23752952f, 0.08446609f, 0.06475124f, -0.09235390f, -0.28385571f, 0.04513540f, -0.22315496f, 0.16200787f, 
    -0.13576873f, 0.21963529f, 0.04942109f, 0.06095428f, -0.09885123f, 0.10372422f, 0.21981622f, -0.12501600f, 
    -0.06142981f, 0.03471630f, 0.00856905f, -0.05044273f, -0.08075766f, -0.01166799f, 0.13504919f, -0.37802687f, 
    -0.28178567f, -0.08563373f, 0.05181054f, 0.05623162f, 0.02461506f, -0.11177918f, -0.01101309f, 0.09729225f, 
    0.06517714f, 0.01314141f, 0.00123784f, 0.19976944f, 0.02071567f, 0.00229483f, -0.16157709f, 0.12386310f, 
    -0.24028330f, -0.11948859f, 0.00946077f, 0.05652115f, -0.01700645f, -0.06645532f, 0.08932035f, -0.13895980f, 
    -0.07083597f, 0.09746542f, 0.05440702f, 0.12543577f, -0.01808773f, 0.11298185f, -0.09977940f, 0.04991620f, 
    0.00649370f, 0.01981318f, -0.17376684f, 0.02487661f, -0.45951816f, 0.13270046f, -0.18501197f, 0.23998430f, 
    0.16587828f, 0.12629695f, -0.20536743f, -0.11503680f, -0.12528218f, -0.06143335f, -0.07422035f, 0.17084128f, 
    0.12359031f, -0.05452850f, -0.10899078f, -0.01603432f, -0.22123265f, 0.18919718f, -0.05947409f, -0.10843200f, 
    -0.05262268f, -0.05711202f, 0.09889224f, -0.10959101f, -0.06079914f, 0.38160831f, 0.29978517f, 0.04480822f, 
    0.04436852f, 0.12241600f, -0.10347803f, 0.00333860f, -0.02873513f, 0.10609264f, -0.06851581f, 0.29900613f, 
    -0.11690205f, -0.00608934f, 0.05912524f, -0.02729115f, 0.08807301f, 0.05367379f, -0.04142590f, 0.15511014f, 
    -0.08563062f, 0.22199272f, 0.03784272f, 0.02301680f, 0.07315757f, 0.00405712f, -0.10944764f, -0.00731774f, 
    0.10028057f, -0.35918209f, 0.12442113f, -0.06104323f, -0.01975473f, -0.08111021f, -0.04935798f, -0.09789249f, 
    0.15911180f, 0.26629335f, 0.06400008f, 0.23480415f, -0.00177329f, 0.05833048f, -0.04098752f, -0.21677558f, 
    -0.11036911f, 0.11470588f, 0.02612120f, -0.01680169f, -0.05367418f, -0.02009616f, -0.00085392f, 0.09277479f, 
    -0.15103303f, -0.05729898f, 0.03786840f, -0.29897198f, -0.06224151f, -0.02835273f, -0.15166150f, 0.08577908f, 
    0.08775106f, 0.03788969f, -0.00495497f, 0.00600187f, -0.22284342f, -0.19829127f, -0.15223986f, 0.02623454f, 
    -0.11774611f, 0.17370734f, 0.22844617f, 0.10913604f, -0.08761255f, -0.62594008f, 0.04017862f, -0.39686987f, 
    -0.04813041f, -0.09945615f, 0.00462066f, 0.11724064f, 0.03888955f, 0.11599575f, 0.68360615f, -0.01737604f, 
    -0.36662856f, -0.12937205f, 0.15333833f, 0.08689509f, -0.00400309f, -0.28436476f, -0.19594641f, 0.17225973f, 
    0.10909654f, 0.00737066f, 0.08337180f, 0.04284466f, -0.09122841f, -0.07227062f, -0.12057126f, -0.12775369f, 
    0.19455001f, -0.09154078f, 0.18600793f, -0.18200128f, 0.29068631f, -0.16999143f, 0.24052951f, 0.09046041f, 
    0.21603106f, 0.21154833f, -0.14636886f, -0.07535427f, -0.20070796f, -0.08204475f, 0.10069467f, -0.09235918f, 
    -0.18956617f, -0.13103387f, 0.09528939f, 0.19115953f, -0.22293226f, 0.05596621f, -0.03266809f, -0.13523588f, 
    -0.04579009f, -0.09071403f, 0.00938825f, -0.05641442f, 0.09435700f, 0.03102949f, 0.29153958f, -0.07282244f, 
    0.09435329f, 0.13718237f, 0.06977601f, 0.09083863f, -0.16445990f, 0.05873524f, -0.32194284f, -0.08652021f, 
    0.16739857f, 0.24256954f, 0.04623573f, 0.13822784f, -0.03955973f, -0.18680964f, 0.04176738f, 0.46661994f, 
    -0.07632695f, -0.10561194f, 0.05356679f, -0.06279974f, 0.02749799f, -0.03050654f, 0.20863782f, -0.18269084f, 
    0.17353575f, -0.14156969f, -0.09001894f, -0.04814571f, 0.09546310f, -0.00485350f, -0.03839764f, -0.02407473f, 
    0.18414554f, 0.25774556f, 0.18179876f, 0.18760301f, -0.11365649f, 0.10410634f, 0.13882920f, 0.02461640f, 
    0.24486646f, -0.11825893f, -0.40447879f, -0.14263524f, -0.13881870f, 0.00855323f, 0.05664490f, -0.09823751f, 
    0.10073131f, 0.11258482f, -0.02547459f, 0.12897512f, -0.09498921f, 0.06130932f, -0.08161169f, -0.00161745f, 
    -0.23706593f, -0.01562410f, -0.02259406f, 0.09465190f, 0.15511070f, 0.14066190f, -0.13356805f, -0.12981890f, 
    0.04003512f, 0.13889834f, 0.06442003f, -0.13176347f, -0.05256834f, 0.33731827f, 0.12798862f, -0.25135386f, 
    -0.11838742f, -0.10758721f, 0.10372605f, -0.10846217f, 0.19295014f, 0.06493600f, -0.03171215f, -0.06114019f, 
    -0.02115332f, -0.12717530f, -0.03453764f, -0.17061947f, -0.05132355f, 0.06256630f, 0.09182169f, 0.05824354f, 
    -0.09828165f, -0.19982161f, -0.15407428f, 0.20563531f, -0.01752206f, 0.11016741f, 0.06358469f, 0.06569295f, 
    0.13586940f, 0.07833297f, 0.00118506f, -0.13886255f, 0.04791888f, 0.08750314f, -0.12700592f, 0.08012854f, 
    0.04788692f, 0.23197190f, -0.02626861f, 0.13464843f, 0.02940046f, -0.04550990f, 0.07930377f, -0.25855914f, 
    0.20752400f, -0.01248946f, -0.07563750f, 0.08294198f, 0.08676260f, 0.01964368f, 0.03291202f, 0.15162309f, 
    -0.01020169f, -0.15322393f, -0.06215339f, 0.08589614f, -0.02612078f, 0.02902463f, 0.06361025f, -0.06347135f, 
    -0.05887723f, -0.24356632f, 0.41227582f, 0.20907539f, 0.02261682f, 0.11959500f, -0.03335902f, -0.06061042f, 
    0.03432656f, -0.10472047f, 0.08485088f, 0.20168188f, 0.09061771f, 0.11226051f, -0.06170282f, 0.08445361f, 
    0.15844455f, -0.07430257f, 0.14698684f, -0.08540020f, 0.16432014f, 0.17833105f, 0.16458657f, 0.07390501f, 
    -0.02267778f, 0.03544829f, 0.08761350f, -0.00458593f, 0.19856746f, -0.40483832f, -0.06726853f, 0.10641221f, 
    -0.08308265f, 0.07615575f, 0.05547163f, 0.13796146f, -0.09386864f, -0.07107742f, -0.09523056f, -0.00245500f, 
    -0.14456952f, -0.02590024f, 0.04159882f, 0.12100978f, -0.00049687f, 0.03795367f, -0.18613550f, -0.17799364f, 
    0.02718706f, 0.15437470f, 0.05631679f, -0.00526551f, 0.08110643f, 0.04408613f, -0.03326500f, 0.09356503f, 
    0.17755629f, -0.01956021f, -0.27250341f, -0.03872040f, -0.06278089f, 0.06218022f, 0.06962356f, -0.03291952f, 
    -0.04306994f, -0.41707906f, -0.05778388f, 0.28087705f, 0.05841637f, 0.04442028f, 0.20255768f, -0.20672670f, 
    -0.10202691f, 0.02744631f, -0.16001733f, 0.21444485f, -0.17425601f, 0.00132970f, 0.02942003f, 0.00849346f, 
    0.12966548f, 0.07885814f, -0.00431619f, 0.11710007f, -0.23354830f, -0.08565380f, -0.09715715f, -0.05144470f, 
    0.20577054f, -0.05910055f, -0.01800936f, -0.04183892f, 0.29798493f, 0.10128763f, -0.26234490f, 0.04440035f, 
    -0.12748522f, 0.00939545f, -0.04188606f, -0.13396768f, -0.13620649f, 0.23010245f, -0.03042932f, 0.07214569f, 
    -0.01418356f, -0.12152122f, -0.06505402f, 0.09286358f, -0.03325839f, 0.23799703f, 0.40486717f, -0.14354043f, 
    -0.16870630f, 0.04756794f, -0.10184211f, -0.26669157f, -0.07633572f, -0.00469972f, -0.18813148f, 0.05549076f, 
    0.12440240f, 0.10423847f, 0.10622962f, -0.05877090f, -0.23228535f, -0.03695779f, -0.12585624f, -0.14087532f, 
    -0.36396542f, -0.22162449f, 0.12782717f, -0.07586070f, -0.08618280f, -0.08240643f, -0.23253167f, -0.00658424f, 
    -0.02842131f, 0.14656201f, -0.18607680f, 0.19039750f, 0.15453163f, -0.26302308f, 0.02906012f, 0.21990295f, 
    0.06846309f, 0.09509595f, 0.07235157f, 0.19359766f, -0.06139591f, 0.20490038f, -0.00377569f, -0.19014680f, 
    0.16011189f, 0.10434330f, -0.11357327f, 0.11844488f, 0.14463614f, 0.15382515f, -0.06657279f, 0.02819780f, 
    0.00292357f, 0.07193149f, -0.05574338f, 0.12285317f, 0.27104759f, 0.04330911f, -0.15588087f, -0.11764540f, 
    -0.06850750f, -0.06897494f, -0.01323265f, -0.25955525f, -0.07751762f, 0.16238903f, 0.17051263f, 0.23445067f, 
    0.22275880f, 0.07443248f, -0.01893018f, 0.07870983f, 0.06324099f, 0.04809999f, -0.00845573f, -0.13649508f, 
    0.06855696f, 0.19122134f, 0.16046466f, 0.00646867f, -0.15009676f, 0.02372348f, -0.05900698f, -0.19417031f, 
    -0.10475029f, 0.03305563f, -0.03696828f, 0.04805324f, 0.04802401f, 0.04086984f, 0.13422887f, -0.19338144f, 
    -0.35355943f, 0.01774743f, 0.27881807f, 0.02703183f, 0.15655474f, -0.03670157f, 0.01649118f, 0.05162423f, 
    0.05266039f, -0.05098984f, 0.16798808f, 0.12745610f, 0.21318942f, 0.08613102f, -0.16204263f, 0.09985600f, 
    0.05734986f, 0.14260006f, 0.28159383f, 0.10504567f, -0.08889845f, 0.02584585f, -0.11527007f, -0.02525349f, 
    -0.09492540f, 0.03591689f, 0.16152513f, 0.19787540f, 0.18102020f, -0.07561079f, -0.03758219f, -0.06602103f, 
    0.16519438f, -0.08534843f, 0.08024785f, 0.00525142f, -0.01637659f, 0.00877001f, -0.09581588f, -0.06854223f, 
    0.03931895f, -0.11749806f, 0.02668201f, -0.12433709f, -0.06099721f, -0.00398945f, -0.04942035f, 0.24644978f, 
    0.09372456f, 0.21724188f, 0.05730045f, 0.14560084f, 0.18836504f, 0.18512274f, -0.08239123f, -0.09719790f, 
    0.18652551f, -0.02659927f, -0.01183192f, -0.01098247f, 0.06446645f, 0.05415717f, 0.10919471f, -0.23983084f, 
    -0.06168903f, -0.23860957f, 0.20671172f, -0.01041531f, -0.17604074f, 0.24241383f, -0.13863789f, 0.04505697f, 
    -0.11471733f, 0.04748463f, 0.36453584f, 0.08953402f, -0.07267144f, -0.03276997f, 0.05008346f, -0.04445288f, 
    0.12323133f, -0.11955670f, 0.13623551f, 0.09714883f, -0.00585189f, 0.03828904f, -0.16769078f, 0.14432135f, 
    -0.07659972f, 0.12971029f, -0.17963271f, -0.13725086f, 0.04644147f, -0.03216739f, -0.07225569f, 0.05865186f, 
    -0.09208050f, 0.02783312f, -0.10428110f, -0.27370369f, -0.08508746f, -0.16178107f, 0.15243050f, -0.06602193f, 
    -0.06463889f, 0.16917738f, -0.07821999f, 0.12975456f, -0.25465780f, -0.26658514f, -0.29614156f, -0.16654116f, 
    0.07088351f, -0.24447910f, 0.08951972f, 0.01049542f, 0.06663135f, -0.10136812f, 0.08372257f, 0.11348898f, 
    -0.02400554f, -0.00295950f, -0.06473235f, 0.17048107f, 0.00531500f, -0.01571792f, 0.13831820f, 0.03242176f, 
    -0.05086409f, 0.09094831f, -0.04127957f, 0.25438285f, -0.00220149f, 0.02021017f, 0.21054772f, 0.36269462f, 
    -0.28480744f, -0.07123347f, 0.06624032f, 0.21439974f, 0.03847715f, -0.08300386f, 0.11267477f, 0.08573458f, 
    -0.12716955f, -0.57445866f, -0.31019112f, 0.07892390f, 0.14336666f, -0.21665870f, 0.01325381f, -0.04223112f, 
    0.24840806f, -0.49770734f, 0.10843149f, -0.22065638f, 0.07135841f, 0.02902859f, -0.17275436f, 0.13045079f, 
    -0.00288660f, 0.08048440f, 0.19855049f, -0.12306479f, -0.26349121f, -0.09388278f, -0.05868252f, 0.15107566f, 
    0.01964205f, -0.03966268f, 0.05780780f, -0.06745788f, -0.01196219f, 0.21563049f, -0.07120802f, 0.18478489f, 
    -0.05367811f, 0.11082136f, -0.04329276f, -0.08085532f, 0.16732702f, -0.00649885f, -0.05966962f, -0.11175827f, 
    0.06089219f, 0.14585935f, -0.07624481f, -0.02469941f, -0.03039657f, -0.02814653f, -0.14025845f, 0.12682745f, 
    0.11378895f, 0.13851394f, -0.18697719f, 0.09701870f, -0.08483523f, 0.11928992f, -0.62928051f, -0.31968629f, 
    0.20164289f, 0.17369165f, -0.17041282f, 0.04845867f, -0.03125475f, -0.08077788f, 0.06988180f, -0.06064779f, 
    0.06040410f, 0.14904012f, 0.16147518f, 0.02400128f, 0.15783446f, 0.02842850f, 0.08244082f, 0.10226437f, 
    0.14215058f, 0.04527349f, -0.17990692f, 0.02673775f, -0.04274416f, -0.03388304f, 0.08812875f, 0.12053017f, 
    0.17265964f, -0.16754848f, 0.05170720f, 0.02670516f, -0.22268237f, -0.05094806f, -0.04534318f, 0.08993478f, 
    0.20245229f, 0.12845314f, -0.00269225f, -0.00828061f, 0.16617602f, -0.06535777f, -0.01668282f, 0.14917585f, 
    0.00830756f, 0.04544007f, 0.02517101f, -0.15714274f, 0.09468674f, 0.02397090f, -0.11266125f, -0.11708418f, 
    -0.15691580f, -0.10882436f, 0.04821265f, -0.07074157f, -0.23070014f, -0.10115789f, -0.09927078f, -0.16758221f, 
    -0.08308384f, -0.26958537f, 0.12501338f, -0.37659615f, -0.16369955f, -0.15085028f, -0.21515924f, -0.39166588f, 
    -0.03559972f, 0.13961442f, -0.20844252f, 0.16527261f, 0.04572444f, 0.11628291f, -0.34139153f, -0.04604063f, 
    -0.18722478f, -0.08619486f, 0.01876670f, -0.08650585f, -0.12765467f, -0.15568851f, 0.13958345f, 0.32120776f, 
    0.27957425f, 0.06354219f, 0.04509751f, 0.21328022f, 0.13812481f, 0.17067449f, 0.12534213f, 0.04532500f, 
    -0.14441469f, 0.42376563f, 0.24964416f, -0.04745358f, -0.02692083f, 0.02534256f, -0.01788505f, 0.02852518f, 
    0.12333676f, 0.06106650f, 0.18179275f, 0.18956748f, -0.04326148f, -0.08026879f, 0.08514778f, 0.20782863f, 
    0.15947275f, 0.24716979f, 0.10973907f, -0.14600158f, -0.11467078f, 0.04919378f, 0.06912709f, -0.06542565f, 
    -0.09278347f, 0.24222338f, -0.10605599f, -0.04020280f, -0.34080312f, -0.01990056f, -0.22298776f, 0.17944211f, 
    -0.04853106f, -0.08617741f, 0.03210755f, 0.15518615f, 0.02946762f, 0.11589426f, -0.02471791f, -0.00901717f, 
    -0.04970517f, -0.00230546f, 0.02254353f, -0.04833666f, 0.13105778f, 0.00834742f, -0.03439455f, 0.20160300f, 
    0.13621874f, 0.13442524f, -0.00067498f, -0.11965787f, 0.19922638f, 0.10001785f, 0.04436804f, 0.22921798f, 
    -0.04503530f, 0.02387462f, -0.11219374f, 0.07365442f, -0.01418971f, 0.06173315f, 0.01069635f, 0.03869626f, 
    -0.13936180f, -0.12182478f, 0.12738492f, -0.17116453f, 0.09816507f, 0.00398781f, -0.04374361f, -0.08623611f, 
    -0.04514956f, 0.42326552f, 0.44017184f, 0.27903464f, -0.03729596f, 0.03522560f, -0.00852272f, -0.06882194f, 
    -0.01288051f, -0.05191620f, -0.08477803f, 0.14924085f, 0.07629889f, -0.02247621f, 0.05678982f, 0.12121702f, 
    -0.05373310f, 0.20754622f, -0.56684560f, -0.17364165f, -0.21189508f, 0.10358951f, -0.08905944f, -0.11261257f, 
    -0.03138523f, -0.11192983f, 0.15839598f, -0.18978664f, -0.24517120f, -0.14657937f, 0.12735456f, -0.14888366f, 
    0.01845394f, 0.07687525f, -0.05875211f, -0.01417194f, -0.51958752f, -0.09451137f, -0.04085382f, -0.07596294f, 
    -0.02948515f, -0.10204948f, 0.02549102f, 0.01415350f, 0.02518482f, 0.14753330f, -0.32750410f, 0.23938049f, 
    -0.03020926f, -0.00459034f, -0.16031618f, 0.18765198f, -0.00382713f, 0.20823710f, 0.02354425f, -0.11719865f, 
    -0.00212591f, 0.15616274f, -0.02817189f, -0.05817266f, -0.03959583f, 0.14585969f, 0.18576705f, 0.14306051f, 
    -0.38254660f, -0.23109739f, -0.05330557f, 0.11587648f, -0.03493889f, 0.10344153f, 0.08311512f, -0.04807477f, 
    -0.55832714f, -0.79599220f, -0.39577773f, 0.04132444f, 0.11407147f, -0.18375789f, -0.17024550f, -0.05469153f, 
    -0.03656483f, -0.49594849f, -0.38444823f, -0.11521850f, -0.00571604f, 0.17034924f, -0.01687362f, 0.00452095f, 
    0.02527097f, 0.02307666f, 0.40298808f, -0.01007506f, -0.42764759f, 0.05233198f, 0.11515272f, -0.00419233f, 
    0.13796842f, -0.10677341f, -0.18395461f, -0.18433523f, 0.14378540f, 0.04430928f, 0.14417851f, 0.02507479f, 
    0.14079584f, 0.16068895f, 0.04385181f, 0.08540643f, 0.02985081f, 0.09307647f, 0.10618691f, -0.05310987f, 
    -0.07479453f, 0.03628923f, -0.02472757f, 0.02856063f, 0.22747667f, -0.44546327f, -0.14620422f, 0.12277141f, 
    0.02791796f, 0.07849200f, -0.12489896f, -0.03213070f, 0.07590631f, 0.12767492f, -0.39954779f, -0.32826468f, 
    0.02352839f, -0.34694609f, -0.07967346f, -0.01808648f, 0.01477213f, -0.17074682f, -0.14340793f, 0.06520976f, 
    0.08945391f, -0.17636597f, 0.04459123f, 0.01052912f, 0.02926469f, 0.01713228f, 0.25285035f, 0.11143348f, 
    -0.07113180f, -0.42892757f, -0.60003614f, -0.15136684f, 0.05041891f, 0.03517102f, 0.03715492f, 0.10955100f, 
    0.10290407f, -0.08302392f, 0.24015006f, -0.01747973f, -0.09149694f, -0.05165118f, -0.05728659f, 0.06097756f, 
    0.13009238f, -0.12467221f, 0.15878606f, 0.00100900f, 0.13017614f, 0.04222429f, 0.01538927f, -0.06768355f, 
    0.01222091f, 0.08817196f, -0.10913075f, 0.08593079f, -0.13811363f, -0.13638182f, -0.01030581f, 0.03053734f, 
    -0.01441374f, -0.00147216f, 0.06987192f, 0.01976211f, -0.09030468f, 0.14149895f, -0.06232714f, -0.10941781f, 
    -0.16797841f, 0.12382680f, 0.09767032f, 0.01362789f, 0.23348927f, -0.25118637f, -0.22107914f, -0.21985194f, 
    -0.14279111f, -0.04277867f, -0.11450138f, 0.06091465f, -0.17228189f, -0.05825037f, -0.24932843f, -0.16864535f, 
    -0.33055007f, -0.02327687f, 0.07830898f, -0.01961369f, 0.01942864f, -0.11007485f, 0.15580946f, 0.28582233f, 
    0.24334937f, -0.28672609f, 0.16681603f, 0.02484392f, 0.05240970f, 0.02980686f, 0.09011381f, 0.11390916f, 
    0.16380772f, -0.03698608f, -0.11973962f, 0.16308436f, -0.04035038f, -0.05393634f, -0.04054939f, 0.00593979f, 
    0.00783482f, 0.06572483f, -0.00740079f, 0.01224064f, 0.03682751f, -0.00388218f, 0.09339362f, -0.14745669f, 
    0.13423792f, -0.14663692f, -0.01559352f, 0.07714359f, 0.10749307f, 0.00117492f, 0.10713460f, -0.04218367f, 
    0.01841573f, 0.26978406f, 0.03083395f, -0.62074947f, -0.00475022f, 0.02710110f, -0.17810310f, -0.01589843f, 
    -0.00801507f, -0.17035051f, 0.14768901f, -0.12395287f, 0.00619760f, 0.20760041f, -0.34925196f, -0.01252405f, 
    -0.13166510f, -0.01095884f, -0.05407182f, -0.03204576f, -0.06370673f, -0.10625841f, 0.18775059f, 0.33852750f, 
    0.18022329f, 0.12192522f, 0.03124898f, 0.15977190f, 0.30708390f, 0.15744121f, -0.04591025f, -0.28488234f, 
    -0.32619065f, 0.03417937f, -0.02023267f, -0.01993837f, 0.00811114f, 0.06312422f, 0.10304967f, 0.17329198f, 
    -0.15243530f, -0.07552335f, 0.13059779f, 0.02919198f, -0.10209014f, 0.16079938f, -0.06410392f, -0.03111521f, 
    -0.13424066f, -0.11680759f, 0.09954759f, -0.00293409f, 0.10591064f, 0.04408139f, 0.09140919f, -0.18293881f, 
    -0.02465411f, 0.16329151f, -0.02077931f, -0.20614138f, 0.00698211f, -0.14368489f, 0.05189897f, -0.02411960f, 
    -0.23329434f, -0.20145531f, -0.38333094f, -0.00969436f, 0.02615673f, -0.04445421f, -0.02215276f, 0.09398878f, 
    0.04865464f, -0.01035134f, -0.15131295f, 0.02820997f, -0.07642802f, -0.01265605f, 0.01232385f, 0.06033490f, 
    -0.11983389f, 0.18090315f, 0.12109849f, -0.03545670f, -0.33224344f, 0.15722296f, 0.01442122f, 0.06799292f, 
    0.10038961f, -0.09304889f, -0.09117296f, -0.09296970f, 0.14327496f, 0.15190646f, -0.02352958f, -0.09349182f, 
    -0.00889885f, -0.06923857f, 0.04871989f, 0.08418830f, -0.06864668f, 0.09114519f, -0.16341497f, 0.25363556f, 
    0.32184675f, 0.12635769f, 0.04180672f, -0.09378714f, -0.02881028f, 0.02874188f, 0.00388441f, 0.03105136f, 
    -0.10671078f, 0.00840342f, 0.01518533f, 0.12864830f, -0.00934215f, 0.13590969f, 0.14656399f, 0.00006106f, 
    -0.15995802f, 0.02453082f, 0.11395564f, 0.02870650f, 0.12151034f, -0.01493314f, 0.13695899f, -0.00437870f, 
    -0.08883203f, 0.05725974f, -0.18825093f, -0.12451452f, 0.18683988f, 0.04681129f, 0.08039383f, -0.06618929f, 
    -0.21594478f, -0.21950139f, 0.20020908f, 0.26017797f, -0.33503637f, -0.06357551f, 0.11567477f, 0.14931875f, 
    0.13857162f, 0.10958920f, 0.18758433f, -0.06736980f, -0.09528661f, -0.15499310f, -0.00710379f, -0.07952346f, 
    -0.24400443f, -0.18747142f, 0.10941591f, -0.05246777f, -0.09223337f, 0.00783051f, -0.05156464f, -0.05973659f, 
    -0.08071232f, -0.11836682f, -0.04947183f, -0.10484678f, -0.08227035f, -0.40881154f, -0.07901017f, -0.00689120f, 
    0.26341596f, 0.12545899f, -0.01220936f, -0.02095270f, 0.12842549f, 0.11553968f, 0.04080952f, 0.07088695f, 
    0.15059413f, 0.01402686f, -0.00133817f, 0.08178376f, -0.11048451f, -0.02479140f, -0.08059390f, 0.24417251f, 
    0.06573421f, 0.27985573f, 0.01382875f, -0.06576899f, -0.03649092f, -0.03823021f, 0.13353160f, 0.04373543f, 
    -0.11478842f, 0.09574334f, -0.27411154f, 0.12300346f, 0.01032149f, 0.30608308f, -0.02003310f, -0.04397834f, 
    -0.24990045f, 0.14017355f, 0.10515719f, 0.03985992f, -0.06221718f, -0.07853550f, -0.00075537f, 0.16508746f, 
    0.15826610f, 0.07295226f, 0.07816143f, 0.18607941f, 0.08188137f, 0.12757057f, -0.14763233f, 0.15805054f, 
    -0.03888356f, 0.01121504f, 0.11551895f, 0.48215663f, -0.01646354f, 0.15081315f, 0.19176793f, -0.15721320f, 
    -0.16116095f, 0.12072143f, 0.04324799f, 0.00641245f, -0.08094657f, -0.00671973f, -0.29947406f, 0.13992824f, 
    0.05160836f, -0.10672729f, -0.16832976f, 0.00268242f, -0.03615286f, -0.28690621f, 0.26583344f, -0.09860746f, 
    0.13589533f, 0.01860801f, 0.13672647f, 0.08716957f, -0.00478979f, 0.04265561f, 0.22285253f, 0.11327108f, 
    0.11044335f, 0.11520119f, 0.04299418f, 0.04930012f, 0.10801239f, -0.09129152f, -0.31722522f, 0.38829896f, 
    -0.04572800f, 0.10465084f, -0.02006312f, -0.02364644f, -0.17538008f, 0.14828925f, -0.01000626f, 0.14868836f, 
    -0.35411993f, -0.24915367f, -0.20368265f, 0.09959399f, -0.05194477f, -0.00416135f, 0.11662555f, 0.04384415f, 
    0.02098140f, -0.18396725f, -0.31737271f, -0.34364402f, -0.05142041f, 0.05650707f, -0.13026252f, 0.02869123f, 
    0.13859603f, 0.03226127f, 0.15799217f, 0.08506495f, -0.15611282f, 0.12506342f, -0.11884711f, -0.15643622f, 
    -0.07686145f, 0.06202865f, 0.08121491f, -0.09102179f, -0.35929993f, -0.19721025f, 0.04343544f, -0.03597213f, 
    -0.22937588f, 0.01857261f, 0.00638708f, 0.09588304f, -0.24135692f, -0.04084709f, 0.05204894f, -0.01296880f, 
    0.16273844f, -0.02176699f, 0.16038032f, -0.02075555f, 0.14105444f, -0.06911206f, -0.03698455f, 0.04924672f, 
    -0.05604292f, 0.12285605f, 0.23421560f, 0.11717779f, -0.05536333f, 0.11438683f, 0.17824991f, 0.12398359f, 
    0.16753975f, 0.29040280f, 0.11295692f, 0.11542841f, 0.09435708f, -0.02578064f, -0.20868009f, 0.31996369f, 
    0.13768774f, 0.34175488f, 0.10329694f, 0.00545822f, 0.16993852f, 0.05527258f, -0.02744241f, -0.14152130f, 
    0.27772182f, 0.02917910f, 0.22456536f, 0.16772304f, -0.19306591f, 0.07349012f, -0.06400338f, -0.07864688f, 
    -0.04723142f, 0.33733970f, 0.26621237f, -0.04260012f, 0.10995892f, 0.01948468f, 0.04416245f, 0.10969280f, 
    -0.06593447f, 0.00813017f, -0.61951214f, -0.05210210f, 0.24676731f, 0.02059783f, -0.00998753f, 0.00582181f, 
    0.08446611f, -0.00709702f, 0.21796812f, 0.08030655f, 0.03571987f, 0.28375986f, 0.03234331f, 0.11281305f, 
    0.12000312f, 0.12838288f, -0.16781558f, -0.08409785f, 0.24527867f, 0.10133504f, 0.44998690f, 0.05347460f, 
    0.10899742f, 0.08703699f, -0.08542689f, 0.00196617f, -0.08421194f, 0.28571644f, -0.00436588f, -0.29098284f, 
    -0.02502449f, 0.00491864f, -0.01022507f, 0.21457957f, 0.10847821f, -0.01308656f, 0.12934481f, -0.23907171f, 
    -0.07167767f, 0.02659375f, 0.17748174f, -0.01082548f, -0.01779565f, -0.10628267f, 0.07295094f, -0.30041465f, 
    -0.33953890f, -0.58548665f, 0.03390215f, -0.10392200f, 0.01188834f, -0.00883134f, 0.14816804f, 0.09595056f, 
    0.04388183f, 0.06092517f, 0.26710463f, -0.11097573f, -0.00764296f, 0.10058701f, 0.02474392f, 0.02916368f, 
    -0.20624605f, 0.23057286f, 0.07836115f, 0.28471625f, 0.13635789f, -0.09581680f, 0.07967860f, -0.04624858f, 
    0.04114025f, -0.07528672f, 0.47406662f, 0.34062299f, -0.07555325f, -0.06825906f, 0.15413967f, -0.00158643f, 
    -0.07515369f, -0.04956365f, -0.26766694f, 0.04696646f, -0.00248458f, 0.06221477f, 0.04062562f, 0.02664605f, 
    0.02234248f, 0.10759327f, 0.04818464f, 0.07989716f, -0.24774449f, -0.12772049f, 0.00696955f, 0.10269502f, 
    0.00422079f, 0.04132989f, 0.07702515f, -0.01304324f, -0.11330092f, -0.06984399f, -0.00898609f, 0.39032102f, 
    -0.04832076f, 0.22482729f, 0.01998667f, -0.04164257f, -0.07240137f, 0.02928964f, -0.16490208f, 0.17235975f, 
    -0.13483021f, -0.26430464f, 0.05524373f, -0.05317878f, 0.01043015f, 0.01522501f, 0.21578091f, -0.17377499f, 
    -0.15185946f, -0.49202892f, -0.04572997f, -0.17125204f, 0.03041768f, -0.06251148f, -0.02800190f, 0.14233592f, 
    0.45542389f, 0.36431122f, -0.41119051f, -0.08709868f, 0.15417299f, 0.23511127f, 0.15671270f, -0.02180227f, 
    0.09438739f, 0.00599700f, -0.07238410f, 0.05554774f, -0.15212017f, -0.23723178f, 0.13904464f, -0.16760033f, 
    -0.06742247f, -0.21138491f, 0.07947913f, -0.08387211f, -0.18309440f, 0.13802744f, -0.13138504f, -0.02085835f, 
    0.05626063f, -0.02982044f, -0.02045857f, -0.05918396f, -0.08768303f, 0.08391259f, 0.34724927f, 0.02112469f, 
    0.06651520f, 0.12174994f, -0.13086244f, 0.18401784f, 0.04604434f, -0.05374167f, -0.55736834f, -0.17135023f, 
    0.00337314f, -0.21875830f, 0.14096913f, 0.00468634f, 0.01791014f, 0.36333388f, -0.04261417f, 0.08621665f, 
    0.05602969f, -0.07402171f, 0.15686277f, -0.08211379f, 0.04363848f, -0.01073499f, -0.02926569f, -0.27425322f, 
    -0.40221107f, 0.17766050f, -0.21475524f, -0.00043960f, -0.02526165f, -0.04451365f, 0.19082490f, -0.19955482f, 
    0.17309934f, -0.45069942f, 0.04525826f, 0.01524032f, -0.16333006f, 0.13209844f, 0.00198256f, 0.01191979f, 
    0.11460900f, 0.14129828f, -0.42822629f, -0.14112522f, 0.06466486f, -0.00334706f, 0.05008305f, -0.08030440f, 
    -0.02427451f, 0.11628556f, 0.08650322f, 0.15851100f, -0.08447324f, -0.09105699f, -0.18973583f, -0.07845464f, 
    0.02792034f, 0.05082531f, 0.20046590f, 0.13373066f, 0.09740363f, -0.19192475f, -0.08761778f, 0.00798946f, 
    -0.12855583f, -0.03178110f, 0.07957438f, -0.01423900f, 0.35430038f, 0.27708751f, 0.04778327f, -0.10564549f, 
    0.14371088f, -0.13770200f, 0.27133384f, 0.18582524f, -0.07774552f, 0.04409439f, -0.12015908f, -0.11992465f, 
    -0.14970669f, 0.02143707f, -0.27085677f, 0.01123688f, 0.10524344f, -0.02877404f, -0.01532093f, 0.21374635f, 
    0.08023611f, 0.08299539f, -0.02869031f, -0.03078163f, 0.15209052f, 0.14398836f, -0.03257622f, -0.23126279f, 
    -0.40289950f, -0.04065486f, 0.03406685f, 0.00201172f, -0.13336647f, 0.02596195f, 0.16892785f, -0.29075792f, 
    -0.19816773f, -0.19276549f, 0.02411514f, -0.00354196f, 0.02848585f, -0.09638163f, -0.00969503f, -0.01662299f, 
    -0.24233146f, 0.18963510f, -0.03456124f, -0.03841347f, 0.11901250f, -0.03916062f, 0.04759425f, 0.17289777f, 
    -0.25221294f, -0.10950290f, 0.08260807f, 0.10306697f, -0.12867366f, 0.13239942f, 0.03353479f, 0.00287508f, 
    0.00138495f, -0.06050427f, 0.23509754f, -0.02505546f, 0.03340972f, -0.06054237f, 0.02327421f, -0.15977213f, 
    0.11680683f, -0.06550024f, -0.04313603f, -0.20638083f, -0.19112368f, -0.39037257f, -0.01954572f, 0.02375514f, 
    -0.05733819f, -0.02620322f, -0.05813305f, -0.15361322f, -0.13293491f, -0.04492019f, 0.23321137f, -0.03521929f, 
    0.02193077f, -0.05660192f, 0.04617155f, -0.07011216f, -0.19740607f, -0.12155560f, 0.06142409f, 0.23866095f, 
    -0.03662298f, 0.17481513f, 0.13066062f, 0.15284802f, 0.16028470f, 0.19333085f, 0.03928477f, 0.07461078f, 
    0.07379491f, -0.07057499f, 0.22838777f, 0.00864794f, 0.01587021f, -0.05981446f, 0.08666711f, 0.24388631f, 
    -0.23776981f, 0.14704026f, -0.02961163f, 0.09896382f, 0.14782794f, -0.03583128f, -0.03041376f, 0.09537314f, 
    -0.10569512f, -0.40825814f, 0.05333792f, 0.01820938f, 0.06400923f, 0.00058904f, 0.13912730f, 0.07997919f, 
    0.29136941f, -0.29168057f, -0.11509163f, -0.45405006f, -0.00967544f, 0.08615933f, 0.19788018f, -0.03337711f, 
    -0.17776954f, -0.06183889f, 0.07033117f, -0.08870534f, -0.28284556f, 0.06497110f, 0.13005145f, 0.20434467f, 
    0.02900476f, -0.19473147f, 0.11678523f, -0.14278005f, -0.07187025f, -0.13331774f, 0.08251081f, -0.08164953f, 
    -0.19664413f, 0.05215807f, -0.01439373f, -0.15312704f, 0.11162943f, -0.06853238f, -0.29078808f, -0.09675188f, 
    0.02576299f, -0.08990590f, 0.02109197f, -0.11092296f, 0.05626199f, -0.06672225f, 0.01015924f, 0.19194199f, 
    0.09872071f, -0.10135334f, -0.04398737f, 0.05221615f, 0.03636498f, -0.04586737f, 0.11691344f, 0.12823668f, 
    -0.36832613f, -0.00187685f, -0.05019051f, 0.10094053f, -0.04017752f, 0.03037229f, -0.02407033f, 0.12835996f, 
    0.20373695f, 0.12001903f, -0.03572844f, -0.23641241f, -0.09197803f, -0.07856092f, -0.10565618f, -0.07577277f, 
    0.03742458f, 0.13484500f, -0.44823840f, 0.01845288f, 0.04822179f, 0.17162128f, 0.24503449f, 0.18964222f, 
    -0.09113768f, -0.09559675f, 0.19267932f, -0.08854326f, -0.07622147f, 0.12898780f, 0.21087314f, -0.13635138f, 
    -0.01011316f, -0.08212499f, -0.00101310f, 0.14049134f, 0.21706702f, 0.03333012f, -0.04417214f, 0.05398525f, 
    -0.20904949f, 0.05212503f, 0.17944798f, 0.10322818f, 0.02739431f, 0.16769040f, -0.12252753f, -0.20143844f, 
    -0.10978501f, -0.11279525f, -0.10672038f, 0.12116576f, -0.16591339f, 0.18535772f, 0.04302341f, -0.16010335f, 
    0.08588374f, -0.08334481f, -0.04554284f, -0.08261631f, 0.06361031f, -0.52105725f, -0.03283712f, 0.01566161f, 
    0.15217321f, 0.08013811f, 0.09558545f, 0.05983406f, 0.17669304f, 0.06103250f, 0.06367674f, 0.05624752f, 
    -0.13809915f, -0.13146767f, 0.03874594f, 0.08987236f, 0.17069331f, -0.08471449f, 0.10104415f, 0.39196208f, 
    0.11081246f, 0.16192068f, -0.04754299f, -0.13511270f, 0.15332654f, -0.05491358f, -0.00330281f, 0.08487193f, 
    0.01732512f, -0.01082288f, 0.03994532f, 0.01360649f, 0.00083946f, -0.01600935f, -0.02667869f, 0.04013062f, 
    -0.04355169f, -0.01122054f, 0.00090381f, 0.03568116f, -0.04077118f, -0.01382518f, 0.01167928f, -0.06098087f, 
    0.02573544f, 0.04600861f, -0.06101726f, -0.01087968f, -0.01849750f, -0.04478531f, -0.01364002f, 0.03928564f, 
    -0.04036250f, 0.04084579f, -0.01393751f, -0.00718761f, -0.00907471f, -0.01629442f, 0.04605186f, -0.02841176f, 
    -0.04876831f, 0.02651180f, -0.03289854f, -0.04898480f, -0.01312902f, 0.02360429f, 0.01828127f, -0.03031822f, 
    -0.04821489f, 0.00639799f, 0.01877081f, 0.00092492f, -0.00403801f, 0.01601791f, -0.03453097f, 0.01722182f, 
    0.05030077f, -0.03537862f, 0.00187199f, 0.01694371f, -0.02329413f, -0.04401610f, -0.00293464f, -0.00179105f, 
    0.03726863f, 0.00601973f, -0.02050519f, 0.04409377f, 0.03868285f, 0.05074205f, -0.00078111f, 0.00963529f, 
    -0.03265387f, -0.00957138f, 0.01217990f, -0.02908568f, 0.02493770f, -0.04618385f, 0.04250293f, 0.02280200f, 
    -0.04841340f, 0.01455093f, 0.00597748f, -0.05026004f, 0.01293726f, 0.03297763f, 0.04201668f, 0.01064659f, 
    0.01733223f, 0.02458855f, 0.02382841f, -0.04372661f, -0.01652722f, -0.06002098f, -0.04099594f, 0.01194170f, 
    -0.03850593f, -0.01892501f, 0.00927756f, -0.06513478f, -0.00319692f, -0.00734496f, 0.03779992f, -0.06535418f, 
    -0.05944714f, 0.03192308f, 0.01878513f, 0.04446429f, 0.00352859f, 0.00068894f, 0.03991853f, -0.05884162f, 
    -0.00455779f, 0.03647336f, -0.04381044f, 0.03883172f, -0.01687194f, -0.04828050f, -0.06340656f, -0.02650627f, 
    -0.04939121f, 0.02264803f, 0.02583772f, 0.04439866f, 0.01237383f, -0.00757798f, -0.04421967f, 0.01420474f, 
    -0.01906928f, -0.04437823f, -0.04657692f, 0.03568467f, -0.00902455f, -0.05037168f, -0.04313619f, -0.05944303f, 
    -0.06167525f, 0.03397977f, 0.00177329f, -0.02676605f, 0.00528543f, -0.06278663f, -0.06062587f, 0.03028295f, 
    0.04489946f, -0.03718124f, 0.02558219f, 0.00264229f, 0.00795810f, 0.04023765f, 0.01830736f, -0.00864578f, 
    0.03426432f, -0.01027134f, 0.02918482f, -0.00299477f, -0.01332852f, -0.00565695f, -0.04441635f, -0.01609430f, 
    -0.03511575f, 0.04155590f, 0.04181429f, 0.02186439f, -0.01632028f, -0.05878538f, -0.04535137f, -0.00676399f, 
    -0.01974670f, -0.00121848f, -0.03676733f, -0.01289554f, 0.03537654f, -0.06127425f, -0.01491746f, -0.05392805f, 
    0.03803948f, 0.04226592f, -0.05433426f, -0.00092895f, -0.04494825f, 0.01317261f, 0.03412618f, 0.00423363f, 
    -0.05684754f, -0.01130032f, 0.03301407f, -0.02947635f, -0.04840652f, 0.02880982f, -0.03730860f, -0.03085984f, 
    0.03046615f, -0.03453539f, -0.04949740f, -0.01711032f, -0.00975889f, -0.01501893f, 0.02526009f, -0.04189419f, 
    -0.00792065f, 0.00330119f, -0.04369137f, -0.05734452f, 0.00074491f, 0.04743420f, -0.01399688f, 0.04901264f, 
    -0.03065846f, 0.04508324f, -0.05429626f, -0.02539556f, 0.04921325f, 0.04289391f, -0.06462157f, 0.05478032f, 
    0.00554911f, 0.00793861f, -0.03542551f, 0.04600350f, -0.05453942f, -0.00584315f, -0.02932784f, -0.06219943f, 
    -0.03206734f, 0.02072223f, 0.00121301f, -0.05987721f, 0.01961974f, -0.02289278f, -0.04663333f, 0.00023380f, 
    -0.02947391f, 0.03679024f, -0.00043491f, -0.02613551f, 0.02891113f, -0.05385551f, 0.00943106f, -0.04425461f, 
    -0.00900682f, -0.01670560f, 0.00025839f, -0.04743044f, 0.02449374f, 0.01714408f, -0.01228020f, -0.02656988f, 
    -0.04465843f, 0.02421177f, -0.04845392f, 0.00615220f, 0.03079550f, -0.01457723f, 0.03817564f, 0.02328161f, 
    -0.02872275f, -0.06309579f, -0.05840316f, -0.01960302f, 0.02740398f, -0.04503183f, -0.01373119f, -0.02457627f, 
    -0.03871684f, -0.06315885f, 0.02365749f, -0.01723723f, -0.05759393f, -0.05704177f, -0.01205288f, 0.01630377f, 
    -0.01099422f, -0.05429201f, -0.03050810f, 0.00250886f, -0.02368543f, -0.06315002f, 0.04688317f, 0.01907959f, 
    -0.01440699f, -0.03663875f, -0.05656374f, 0.05584554f, 0.03816454f, -0.04427697f, 0.01842338f, -0.01452828f, 
    -0.04610532f, -0.06123033f, -0.01300209f, -0.06469359f, 0.00427037f, 0.00017296f, -0.02499071f, 0.04811600f, 
    -0.14821431f, -0.06446624f, -0.14032736f, -0.06849875f, 0.11039194f, -0.04106214f, -0.06605823f, -0.00374247f, 
    -0.02871893f, 0.01845636f, -0.04480818f, 0.16619051f, -0.03395196f, -0.00976285f, -0.01454591f, -0.21814227f, 
    0.12320741f, 0.27953395f, 0.12000564f, 0.11039480f, 0.16828313f, -0.06808443f, -0.00128461f, -0.00007057f, 
    -0.00771458f, 0.11410017f, -0.06097816f, -0.39507946f, 0.37895006f, 0.48029870f, -0.10207666f, 0.07296353f, 
    -0.16853838f, 0.00921946f, -0.07015943f, 0.02022523f, -0.09999662f, 0.33390564f, -0.09432071f, 0.22166716f, 
    0.07921588f, -0.02110850f, -0.10542126f, -0.06711209f, 0.04527498f, 0.10229597f, -0.34026048f, 0.38423508f, 
    0.18576297f, -0.11371296f, 0.01413160f, -0.01438664f, 0.12033239f, 0.23084955f, 0.07100306f, 0.46917027f, 
    -0.31890294f, -0.11184309f, -0.10040582f, -0.16242640f, 0.30216163f, -0.00293534f, 0.05090000f, 0.16777062f, 
    0.02259209f, -0.22477286f, -0.17799523f, -0.18225686f, 0.26257867f, 0.02987565f, 0.00935694f, -0.00506131f, 
    -0.16635992f, 0.11864271f, 0.33304927f, -0.20604596f, -0.18667491f, -0.03351752f, 0.00499989f, 0.13911633f, 
    -0.00679714f, 0.07268501f, 0.02984339f, 0.02554885f, 0.04307558f, -0.07393805f, 0.05239483f, -0.04917271f, 
    0.17685392f, 0.29148778f, -0.54082048f, -0.39976951f, 0.80651814f, 0.02121668f, 0.10923195f, -0.27054551f, 
    -0.13416012f, 0.02216368f, 0.05741653f, -0.12636778f, 0.24883896f, -0.21222210f, -0.27917573f, -0.14081188f, 
    0.16988254f, 0.19274502f, 0.15690079f, -0.00081285f, -0.19972220f, -0.00930163f, 0.29482952f, -0.25102448f, 
    -0.08188305f, -0.17454492f, 0.00197806f, 0.16391774f, -0.15224312f, 0.30516142f, 0.28399688f, 0.04143680f, 
    0.09138383f, -0.19366100f, 0.06653719f, 0.02696707f, 0.08575477f, 0.13037555f, 0.13979153f, 0.07762110f, 
    0.01589461f, 0.01901816f, 0.38138732f, -0.14349657f, -0.01262403f, 0.05115395f, 0.01176778f, 0.50174290f, 
    0.41226134f, -0.16029175f, 0.08772399f, -0.10185304f, -0.03751889f, 0.09049459f, 0.03498596f, 0.05620208f, 
    -0.14617117f, -0.18886833f, 0.32439354f, -0.23467867f, -0.11451183f, -0.07438564f, 0.03784938f, 0.04564924f, 
    -0.11597538f, 0.10110705f, -0.02348881f, -0.18450640f, 0.02150038f, 0.14520274f, 0.03550854f, 0.10564906f, 
    0.04108850f, -0.10185029f, -0.15089491f, 0.11746408f, -0.34201944f, 0.31120205f, 0.25276718f, 0.15775459f, 
    0.18895315f, -0.00517616f, -0.31485173f, 0.13531956f, -0.02253061f, 0.07954809f, 0.06525851f, 0.01756967f, 
    -0.01815630f, -0.05827674f, -0.09871773f, 0.15520552f, -0.15537776f, -0.08646819f, 0.13854854f, 0.20482938f, 
    0.02409194f, -0.16675854f, -0.16566648f, 0.10042298f, 0.15897684f, -0.07597656f, -0.05102262f, 0.37698859f, 
    -0.14051712f, -0.10853012f, -0.05824562f, -0.08451083f, 0.00765263f, 0.05307787f, -0.68116820f, 0.32866216f, 
    -0.77081269f, 0.16182937f, -0.19935746f, 0.19201893f, -0.05236076f, 0.02569366f, -0.04297326f, -0.03757793f, 
    -0.11701472f, -0.07013082f, 0.04552286f, -0.10361290f, -0.03553992f, 0.14120288f, 0.12495714f, 0.12726177f, 
    0.01192925f, -0.29585737f, -0.54645461f, -0.15894417f, -0.30291814f, 0.21385819f, -0.02691135f, -0.01419048f, 
    0.27363542f, -0.07730061f, -0.27587137f, 0.01016526f, 0.08696280f, 0.20475857f, 0.01657489f, 0.17231660f, 
    0.24240381f, -0.15216985f, -0.00487956f, 0.26608193f, -0.04675104f, -0.09574962f, 0.13221090f, -0.10979985f, 
    -0.04893608f, -0.01397110f, 0.10045436f, 0.00962834f, 0.13335271f, -0.03042991f, -0.10019913f, -0.28969663f, 
    -0.03278888f, -0.08649365f, 0.24037932f, 0.12746811f, -0.28970832f, -0.12657547f, -0.22427081f, 0.05082698f, 
    0.11067258f, -0.10953219f, -0.28780246f, -0.00678240f, 0.04180765f, -0.22848766f, -0.18514118f, 0.16259202f, 
    0.17228511f, 0.06030148f, -0.33714148f, -0.03434141f, 0.09677108f, -0.08197802f, -0.02126221f, -0.10125721f, 
    -0.04221330f, -0.26718748f, -0.07742593f, -0.18992560f, 0.12468352f, 0.03427149f, 0.06148780f, 0.19308951f, 
    -0.33597609f, 0.15073574f, 0.16722891f, 0.29241425f, 0.40595528f, -0.22806023f, 0.04801828f, 0.04668896f, 
    -0.04882561f, 0.01060249f, -0.03250968f, 0.00560385f, -0.01469872f, -0.03054633f, 0.03645288f, -0.04481018f, 
    -0.03899002f, 0.00787284f, 0.02630382f, -0.04758894f, 0.04106304f, -0.01638983f, 0.03202605f, -0.00750240f, 
    0.00066199f, -0.06133400f, 0.01779484f, -0.05175662f, -0.04324008f, 0.03717965f, -0.03397150f, 0.03303265f, 
    0.01699534f, -0.01205889f, 0.01917246f, -0.00610857f, 0.03626684f, 0.02374701f, 0.02624064f, -0.04729799f, 
    -0.04857111f, -0.03454762f, 0.03834644f, -0.04671851f, -0.05328706f, -0.00072013f, 0.00832568f, 0.03127870f, 
    -0.05013736f, -0.04143953f, 0.04516694f, 0.00719435f, 0.00452109f, -0.00466349f, 0.00563658f, -0.06102518f, 
    0.02307955f, -0.06871217f, -0.04753007f, -0.06403841f, 0.04828355f, 0.02066087f, 0.00953129f, 0.02692318f, 
    -0.04327939f, 0.02931344f, -0.02112327f, 0.02950221f, -0.03813373f, 0.02089350f, -0.06724564f, 0.00813056f, 
    -0.01597466f, -0.04073651f, -0.04148500f, -0.06554126f, 0.02052622f, -0.04297044f, 0.03911551f, -0.06797708f, 
    0.00785615f, 0.01767604f, -0.02217056f, 0.00363514f, 0.00778176f, 0.00426825f, 0.03200690f, -0.04523256f, 
    -0.05210372f, -0.00388239f, -0.02783920f, -0.00722650f, -0.06497472f, 0.04463789f, -0.02655858f, 0.04532671f, 
    0.04431324f, -0.03866927f, -0.02977659f, -0.05329500f, -0.04156554f, -0.03398154f, 0.04873223f, 0.01559641f, 
    0.02581440f, 0.00590781f, -0.07215179f, 0.03849440f, 0.02894586f, -0.05339615f, 0.04725023f, -0.02309183f, 
    -0.02622837f, 0.00733186f, 0.01004328f, -0.03217814f, -0.03679904f, -0.04670441f, 0.05648160f, 0.04922824f, 
    0.01240557f, 0.02546273f, 0.04416483f, -0.05982726f, -0.02492727f, 0.04226250f, -0.01171125f, -0.03985097f, 
    -0.00652910f, -0.05682256f, 0.05200397f, -0.04581978f, 0.03337437f, 0.04053881f, 0.03816612f, 0.01447089f, 
    0.03198887f, 0.00204438f, 0.03773015f, 0.01854766f, -0.01703553f, 0.02391998f, -0.04381837f, 0.01676124f, 
    0.04735994f, -0.04061700f, 0.00627956f, -0.06380365f, -0.02903329f, -0.02020785f, 0.00093914f, 0.01284402f, 
    -0.02246214f, 0.04292230f, 0.00331640f, 0.03238830f, -0.06289673f, 0.04041043f, -0.00206095f, 0.01885655f, 
    0.03725336f, 0.03147120f, -0.07089356f, -0.03726378f, -0.02485098f, -0.01248092f, 0.03875101f, 0.04664382f, 
    -0.05988918f, 0.01443590f, 0.00054160f, -0.00959020f, -0.05447954f, 0.02370524f, -0.00811972f, 0.03272031f, 
    -0.01616729f, -0.02107176f, 0.02182831f, -0.03556210f, 0.02061382f, -0.05269701f, -0.04940486f, -0.01883256f, 
    0.03650956f, -0.03315093f, 0.02501566f, 0.01803355f, -0.02697156f, 0.02470599f, 0.03012008f, -0.04647732f, 
    -0.05602777f, -0.07233068f, 0.03269431f, 0.00940904f, 0.00179152f, -0.04078301f, -0.00566325f, -0.01214660f, 
    -0.02480085f, 0.00470098f, -0.06607797f, 0.02617361f, -0.03226221f, 0.02017871f, 0.03384208f, 0.05101070f, 
    -0.01035138f, -0.00245126f, -0.03595917f, -0.05532853f, -0.01438098f, -0.04116308f, -0.02313367f, -0.03317708f, 
    -0.06413563f, -0.01958635f, -0.05938623f, -0.06143203f, 0.03636430f, 0.00444621f, 0.00042046f, -0.01600758f, 
    0.00466640f, -0.03392781f, -0.04502961f, -0.02497892f, -0.05753998f, 0.02175589f, -0.06642659f, 0.00390047f, 
    0.03998744f, -0.03458970f, -0.02685715f, 0.03343740f, -0.04145445f, -0.06334214f, -0.02134210f, 0.02279000f, 
    -0.00960524f, 0.05102435f, 0.00389828f, 0.04158936f, -0.01028763f, 0.05496380f, 0.05452072f, -0.01458606f, 
    -0.03785841f, -0.01922846f, -0.00585613f, -0.00831317f, -0.00128488f, -0.02749325f, -0.04384435f, 0.04345073f, 
    0.03147974f, -0.02048190f, -0.03162911f, 0.01864964f, -0.01368637f, 0.02853950f, 0.02539480f, 0.02876050f, 
    0.02563501f, -0.00422998f, 0.00217512f, -0.05230849f, -0.04088614f, -0.02650858f, 0.04523065f, 0.02924757f, 
    0.04678131f, 0.03377287f, 0.00497501f, -0.02640766f, -0.05758939f, -0.00701200f, -0.02795803f, -0.02655384f, 
    0.04698867f, 0.02282696f, 0.03949808f, 0.01500683f, 0.01090203f, 0.01031304f, -0.03118473f, -0.05159907f, 
    -0.02339170f, -0.02055266f, 0.01199111f, 0.02517157f, -0.00580326f, -0.05565390f, -0.06029798f, -0.00454987f, 
    0.17797880f, 0.13587648f, -0.10282516f, -0.15456179f, -0.17215420f, -0.07994241f, -0.03078141f, -0.06822377f, 
    0.07517498f, 0.10882583f, -0.19380304f, 0.06527945f, 0.00865299f, 0.02465115f, -0.03316791f, -0.17510797f, 
    -0.17613696f, -0.22660968f, 0.08843511f, -0.07172418f, 0.07603962f, 0.03840005f, 0.14824025f, 0.03378511f, 
    -0.08474821f, 0.18887460f, 0.15286945f, -0.21847703f, 0.07996609f, 0.39026174f, 0.01203246f, -0.04978959f, 
    -0.02018678f, -0.08520890f, -0.21711728f, -0.15716197f, -0.06884519f, 0.29052100f, -0.08429269f, 0.06456488f, 
    -0.03452983f, 0.02536620f, -0.21147305f, -0.20359010f, -0.23585293f, 0.02479757f, 0.03526774f, 0.22862396f, 
    -0.00980633f, 0.20412254f, -0.03828761f, 0.01277766f, 0.32624307f, 0.00601737f, 0.25752005f, 0.22974120f, 
    0.16575925f, -0.00523799f, 0.10606036f, -0.18791515f, 0.10232495f, 0.04257539f, 0.07365260f, 0.22035836f, 
    0.17347088f, -0.10913135f, 0.12805016f, -0.00679122f, 0.02563153f, 0.20844083f, 0.07647201f, -0.19192843f, 
    -0.00925792f, 0.09298098f, 0.00908369f, -0.13223541f, 0.02193375f, 0.03751016f, 0.08607820f, -0.00499889f, 
    0.04276913f, -0.05494593f, -0.06962490f, -0.04337445f, -0.06554145f, 0.00177074f, -0.04632826f, 0.04395992f, 
    -0.23561172f, -0.24314171f, 0.29114139f, 0.24013421f, 0.32512379f, 0.08939455f, -0.05869327f, -0.00223641f, 
    0.02365651f, 0.01736998f, -0.03994505f, 0.18825389f, 0.25540921f, -0.29325706f, 0.10635459f, 0.11329241f, 
    0.04323720f, 0.16320688f, 0.10337721f, -0.08133185f, 0.14634472f, 0.27177641f, -0.06738636f, -0.10525598f, 
    0.05112838f, -0.00802504f, 0.15977094f, 0.03152310f, -0.05804030f, -0.04787462f, -0.14289124f, -0.03051855f, 
    0.10422298f, 0.07651932f, 0.04688738f, -0.08058549f, 0.16075058f, -0.01447270f, -0.03596335f, -0.15320504f, 
    0.01745400f, 0.02323672f, 0.10069691f, 0.01513716f, -0.21973628f, 0.07615181f, -0.30684316f, -0.13629472f, 
    -0.22890909f, -0.00904297f, -0.00102537f, -0.00315405f, 0.05271074f, -0.05093484f, 0.07581305f, 0.17265797f, 
    -0.01370279f, -0.00920785f, -0.27725089f, -0.05853053f, 0.21021925f, 0.20408687f, 0.07016350f, 0.16749893f, 
    -0.14783446f, 0.00737768f, -0.10226841f, -0.14712200f, 0.07137912f, 0.07088434f, 0.20283353f, -0.10304739f, 
    -0.15235485f, -0.34201074f, -0.20441276f, -0.03336933f, 0.05255904f, 0.12989740f, 0.25938851f, 0.03376121f, 
    0.08327674f, 0.13975281f, 0.21947375f, 0.00158081f, 0.17349498f, -0.20591414f, -0.00239539f, -0.11786488f, 
    -0.06347565f, -0.13209850f, 0.08166961f, -0.10870794f, -0.01484814f, -0.09086420f, 0.03769856f, 0.06509130f, 
    -0.10296309f, 0.02438057f, -0.17189246f, -0.11264263f, -0.24561501f, 0.14860669f, 0.20609728f, -0.07633772f, 
    -0.14424793f, 0.09816261f, -0.07681890f, 0.05006820f, 0.01697632f, -0.05466524f, -0.03418232f, 0.04231887f, 
    0.42283827f, 0.16426948f, 0.02219294f, 0.01900860f, -0.11507981f, -0.13963720f, -0.04956335f, 0.02309557f, 
    -0.03441190f, 0.05003857f, 0.26090780f, 0.17475156f, 0.02645162f, -0.19162934f, -0.19339079f, -0.23374222f, 
    0.14000829f, -0.10357061f, 0.14848843f, -0.00947307f, 0.02328257f, -0.07229295f, 0.04175737f, -0.10048687f, 
    -0.18577366f, -0.00509284f, -0.05886445f, 0.18691976f, -0.20541532f, -0.10748720f, -0.03877129f, 0.05030090f, 
    0.26133460f, 0.15840341f, 0.10198917f, 0.00873796f, 0.06323448f, 0.19536728f, 0.07145432f, -0.08395643f, 
    -0.06319973f, -0.01722922f, 0.00719265f, 0.13758712f, -0.11298538f, 0.00463190f, 0.17007223f, 0.05944777f, 
    0.15964170f, -0.05110443f, 0.06435636f, -0.09453478f, 0.07977258f, 0.09471572f, -0.14588405f, 0.01610305f, 
    -0.08995406f, -0.00532271f, -0.09102154f, -0.18226929f, -0.04737835f, -0.01918725f, 0.14981613f, 0.01381824f, 
    0.16312590f, 0.06296910f, 0.02377954f, 0.09838070f, 0.20405923f, -0.00757879f, -0.04091716f, -0.14146210f, 
    -0.05915217f, 0.18099114f, 0.13023923f, 0.07912088f, -0.13961288f, -0.00290933f, -0.26278013f, 0.14516971f, 
    -0.05322929f, -0.09573731f, 0.14188969f, 0.01174812f, -0.04728360f, -0.03145152f, -0.09468298f, 0.03112661f, 
    0.01507291f, 0.00705617f, 0.00087096f, 0.00491067f, 0.03585081f, -0.03317397f, -0.06090943f, -0.05343799f, 
    0.02329600f, -0.04149591f, 0.04326461f, 0.00590532f, -0.06709705f, 0.04010106f, 0.03689812f, 0.03454493f, 
    -0.05743132f, -0.05238445f, 0.03356829f, -0.02015764f, -0.05860900f, -0.02960355f, 0.01292324f, 0.00780507f, 
    -0.02627172f, -0.03718387f, -0.01106614f, -0.01140405f, -0.00039660f, -0.01044550f, -0.03424685f, -0.04890883f, 
    -0.00435233f, -0.05259301f, -0.03075201f, 0.03500174f, 0.00867717f, -0.06273712f, 0.04641853f, 0.03528494f, 
    0.01973932f, -0.04683408f, 0.03457547f, -0.02868185f, 0.02434563f, -0.05322127f, -0.06195720f, -0.04320487f, 
    0.01018455f, 0.02819980f, -0.05626082f, -0.00995820f, 0.04989946f, 0.00014902f, 0.03940947f, 0.02700481f, 
    -0.01696684f, 0.02955764f, 0.01313562f, 0.03204588f, -0.05099485f, -0.01722477f, -0.06392287f, -0.05691658f, 
    0.01086283f, -0.01776526f, -0.02075169f, 0.03602864f, -0.03313306f, -0.02306733f, -0.01681092f, 0.04708451f, 
    -0.04183954f, -0.04516976f, 0.03639437f, 0.02508630f, -0.03805996f, 0.02665943f, -0.04796353f, -0.02851562f, 
    0.00581781f, -0.02835848f, -0.06321368f, -0.06466438f, 0.02608495f, -0.02017224f, 0.03423795f, 0.04167418f, 
    0.03966563f, 0.02313560f, -0.02322554f, 0.02874262f, -0.01179524f, -0.05546480f, 0.02636097f, 0.02244290f, 
    0.03182776f, -0.06522449f, 0.04250902f, 0.02353935f, 0.03071826f, 0.03609910f, -0.02033329f, -0.00048402f, 
    -0.00078293f, -0.01738223f, -0.06452139f, -0.00548383f, 0.01643282f, 0.01880128f, 0.00279116f, 0.00779804f, 
    0.03837636f, 0.03967249f, -0.04408078f, 0.01843657f, -0.04502558f, -0.06744234f, -0.03671344f, 0.00815742f, 
    0.01423449f, -0.03662106f, -0.00276282f, 0.04424419f, -0.04282848f, 0.01475232f, -0.00620269f, -0.02016900f, 
    0.04612418f, 0.03589553f, 0.03974853f, -0.02748141f, -0.03185534f, 0.04162129f, -0.01743517f, 0.04017557f, 
    -0.03169021f, 0.01342908f, 0.00626480f, 0.02882992f, 0.04930997f, -0.02672311f, 0.04430786f, 0.03262196f, 
    0.01718394f, -0.05599632f, -0.04986017f, 0.01538378f, -0.02651173f, 0.04626997f, 0.00364261f, -0.02745550f, 
    -0.05673242f, 0.01481181f, 0.01909640f, 0.04412118f, -0.00504676f, 0.01058096f, 0.02239779f, -0.05159949f, 
    0.02562277f, -0.03561569f, 0.00183208f, -0.05876432f, -0.04567500f, -0.04439911f, -0.04747863f, -0.03808916f, 
    -0.03397211f, -0.05162213f, -0.01298281f, 0.02807081f, -0.04390914f, -0.00862824f, -0.01113074f, -0.05399334f, 
    0.04617599f, 0.02584935f, -0.04965388f, -0.03721284f, -0.03242167f, -0.04827843f, -0.05973683f, 0.04456782f, 
    -0.06604213f, -0.04832367f, -0.01835385f, -0.00988922f, -0.03374816f, 0.00357143f, -0.04380846f, -0.02000178f, 
    0.04094274f, 0.01206255f, -0.00578188f, 0.01391096f, 0.01603389f, 0.02678337f, -0.05464530f, -0.01686590f, 
    0.00750848f, -0.03834677f, -0.03068222f, 0.03880079f, -0.05135104f, -0.02624722f, -0.01752026f, -0.01065458f, 
    -0.05962597f, 0.01012135f, -0.00749618f, -0.03238674f, -0.01202307f, -0.06211875f, -0.03371431f, 0.02471104f, 
    -0.04502887f, -0.02567282f, -0.03473194f, 0.03542910f, 0.01900229f, 0.04011858f, 0.04263707f, 0.01421852f, 
    0.01047621f, -0.03071690f, 0.03324131f, -0.05696861f, 0.05393763f, -0.04168982f, -0.05929924f, -0.06613060f, 
    -0.00369959f, 0.02037754f, -0.03395089f, -0.00334492f, -0.05353235f, 0.01794380f, 0.00819243f, -0.00952390f, 
    0.03856723f, 0.02039752f, -0.05940242f, 0.00343628f, 0.01314238f, -0.05613815f, 0.03234795f, -0.00764988f, 
    -0.01359218f, -0.05178838f, -0.05505359f, -0.05688535f, 0.00403715f, -0.00268299f, 0.03321760f, -0.02182033f, 
    0.03569584f, -0.06589644f, -0.03483598f, 0.00605790f, -0.05632863f, -0.03152924f, -0.05617099f, -0.01763710f, 
    0.03032863f, -0.06201724f, -0.03878494f, 0.02333727f, -0.01272324f, 0.04836812f, -0.01221986f, 0.04537870f, 
    -0.02628634f, 0.01524663f, -0.03851537f, -0.02010909f, -0.00123807f, -0.01001951f, 0.00378793f, 0.00449536f, 
    0.03197389f, -0.01766231f, -0.05109899f, 0.03907666f, -0.06438787f, -0.06320859f, -0.01381867f, 0.00008975f, 
    0.03368438f, 0.29668424f, 0.15591751f, 0.20116943f, 0.11286400f, 0.15200622f, 0.01165346f, 0.08711269f, 
    0.06193182f, -0.18783785f, 0.05953339f, 0.32803896f, 0.10067490f, 0.03348540f, 0.00026755f, 0.04133585f, 
    0.14392416f, 0.11448818f, -0.22908755f, -0.56976503f, 0.01988445f, 0.05110752f, 0.08243950f, -0.12773511f, 
    -0.11440974f, 0.25853670f, 0.07841008f, -0.41151115f, -0.02774267f, -0.07577453f, -0.21046565f, -0.04988993f, 
    -0.36516419f, 0.23467074f, 0.14270131f, -0.30199161f, 0.19533494f, 0.11144973f, 0.24215728f, -0.01592186f, 
    0.12428016f, -0.20230794f, 0.16765988f, 0.00007778f, -0.09666457f, -0.08538488f, -0.16063285f, -0.12359110f, 
    -0.20365739f, -0.14776014f, 0.03620608f, -0.28329954f, -0.06891717f, 0.28644699f, 0.22482201f, 0.11858253f, 
    0.11990682f, -0.06367284f, 0.08913604f, -0.13379396f, 0.29355565f, 0.07431102f, -0.21928570f, 0.08737057f, 
    0.01622309f, 0.00146645f, -0.26634905f, -0.00573286f, -0.07227778f, 0.21220590f, 0.03412129f, -0.15661959f, 
    0.06505632f, 0.05566147f, 0.08137611f, 0.03910622f, 0.21784805f, 0.02794688f, 0.12703367f, 0.05696164f, 
    -0.09263934f, 0.05512052f, 0.12392759f, 0.09343474f, 0.11503394f, 0.00805955f, 0.04610928f, 0.02286632f, 
    0.24811287f, 0.20790721f, 0.42624933f, 0.05954481f, -0.17455429f, 0.11576516f, -0.01032327f, 0.13358714f, 
    0.05377523f, 0.03259511f, -0.09508907f, 0.04965784f, -0.06646879f, 0.18399927f, -0.02199154f, 0.05477912f, 
    -0.05598088f, 0.06136308f, 0.06362551f, -0.02385423f, 0.05670863f, -0.05462293f, -0.12861212f, -0.13186543f, 
    0.13025169f, 0.06707405f, -0.01591073f, -0.10736210f, -0.00720100f, -0.71671724f, -0.05941485f, -0.12389805f, 
    -0.16053146f, -0.02688333f, 0.01339081f, 0.01985335f, 0.32875818f, 0.15821773f, 0.00820471f, 0.02346856f, 
    -0.25134775f, -0.08301474f, 0.14731482f, 0.06394764f, -0.13858341f, 0.34854937f, 0.09631722f, -0.42971799f, 
    -0.22697528f, 0.17498234f, -0.26094967f, -0.32366222f, 0.00389218f, -0.07407105f, 0.20275977f, 0.01515132f, 
    -0.20813650f, -0.20251004f, -0.33117884f, -0.32168224f, -0.31592646f, -0.06480291f, -0.02165497f, 0.02206705f, 
    0.14761770f, -0.28082806f, 0.07033781f, -0.18435214f, -0.04516752f, -0.09080417f, -0.12247287f, -0.03509443f, 
    0.08014134f, 0.15486120f, -0.06220284f, -0.42334983f, -0.07572959f, -0.03092649f, -0.04957401f, -0.10393743f, 
    -0.03802289f, -0.06244480f, 0.24312024f, 0.34396166f, 0.28553331f, 0.22927724f, 0.05974951f, 0.09050100f, 
    0.16591857f, 0.12809055f, 0.09949876f, -0.03012377f, 0.31383452f, 0.31518182f, 0.04778723f, 0.11800158f, 
    0.08582356f, 0.02393897f, -0.00668508f, 0.04646849f, -0.07607247f, 0.21464811f, 0.02642037f, -0.14902261f, 
    -0.05857898f, -0.00397335f, 0.19731773f, -0.00445836f, -0.04881167f, 0.04728806f, -0.42766094f, -0.06088173f, 
    -0.03902006f, -0.07839865f, 0.13321112f, 0.00138090f, -0.12919794f, -0.07311244f, 0.05485784f, -0.10892311f, 
    -0.27061185f, -0.07250574f, 0.01925573f, -0.03299262f, 0.01250159f, 0.07395230f, 0.03062098f, 0.14364669f, 
    -0.21006344f, -0.30514014f, 0.25583085f, 0.15953080f, -0.06300794f, -0.25515833f, 0.06718425f, -0.04246246f, 
    0.03428000f, -0.08736216f, -0.29236907f, 0.11232505f, -0.01013098f, 0.21179213f, 0.19787838f, -0.18477115f, 
    -0.04300255f, 0.07481313f, -0.20174654f, 0.00068920f, -0.18955754f, -0.20470534f, 0.20959719f, -0.02315171f, 
    0.22168894f, 0.31634295f, 0.12745909f, -0.06626154f, -0.46348077f, 0.10338641f, -0.07485954f, -0.17514101f, 
    -0.09021559f, -0.03335927f, 0.05894065f, 0.17338584f, 0.24200866f, 0.16018976f, 0.36247271f, -0.05132349f, 
    0.15761532f, -0.03942630f, 0.10419738f, 0.01035267f, -0.02449874f, -0.05277138f, 0.11850362f, -0.01829875f, 
    -0.24042600f, 0.03699715f, -0.12392141f, -0.03351706f, 0.04110648f, 0.06966086f, 0.27259642f, -0.05667900f, 
    -0.21221340f, 0.06856509f, 0.11931079f, 0.00448758f, 0.02517559f, -0.11051840f, -0.04220621f, 0.71198583f, 
    -0.02522892f, -0.08670300f, -0.10457625f, 0.18561287f, -0.03040378f, -0.03619549f, 0.18800305f, 0.11051827f, 
    -0.23756453f, -0.49244592f, -0.40092555f, -0.15461953f, 0.00408651f, 0.00116560f, 0.03646583f, -0.15875562f, 
    0.04891871f, 0.01202437f, 0.14731176f, -0.09233939f, -0.01898994f, 0.05394597f, -0.04642639f, 0.05395171f, 
    0.07293911f, 0.23680556f, 0.29801926f, 0.17311727f, -0.05222065f, -0.31189382f, 0.03528487f, -0.12164582f, 
    -0.05243239f, -0.09816367f, -0.07594956f, -0.05537718f, -0.12927140f, 0.35881138f, -0.09735815f, 0.05821710f, 
    0.04644087f, 0.29556921f, 0.03787128f, 0.11641462f, -0.21460448f, 0.04880099f, -0.43637553f, -0.18723486f, 
    0.08195122f, -0.09410859f, 0.11271835f, -0.14917074f, 0.19285364f, -0.12806751f, 0.11520760f, 0.24267195f, 
    -0.03407874f, 0.21279648f, -0.09768552f, 0.31013998f, 0.07589489f, 0.06018936f, -0.14966518f, -0.50953394f, 
    -0.09066699f, 0.22194515f, 0.00235315f, 0.17687497f, -0.04547559f, 0.03959669f, 0.06997387f, -0.02668983f, 
    -0.16603999f, -0.29507038f, 0.12232101f, -0.01283226f, 0.08794522f, 0.13524133f, -0.04880277f, 0.05398170f, 
    0.33129925f, -0.36520907f, -0.25423524f, 0.09534734f, 0.00616690f, 0.03696381f, 0.18872084f, 0.04705361f, 
    0.07681746f, -0.02930052f, -0.04843644f, -0.03377599f, 0.00539343f, 0.02015757f, 0.18395713f, 0.10740522f, 
    0.09935457f, 0.09703639f, -0.03093040f, -0.67843968f, -0.43441769f, -0.19615854f, 0.09523153f, -0.12707062f, 
    0.12370761f, -0.16495748f, -0.00108477f, 0.10241030f, -0.11208931f, -0.48913339f, -0.16296373f, -0.03191129f, 
    -0.00626542f, 0.09545565f, -0.04422183f, 0.06843086f, -0.07706561f, -0.39263168f, -0.02705977f, -0.02883069f, 
    0.09819002f, -0.08299322f, -0.11692099f, -0.08100794f, 0.02135466f, 0.31778455f, 0.17425154f, 0.05954114f, 
    -0.04353978f, -0.09810453f, 0.14670862f, 0.14429389f, 0.18981257f, -0.05546267f, 0.06147128f, 0.07271065f, 
    0.12366655f, 0.06676282f, 0.03699521f, 0.00485901f, 0.20229158f, 0.05969965f, 0.13593237f, 0.63857359f, 
    0.29542536f, 0.10327344f, -0.17886347f, 0.02315427f, -0.19254503f, 0.03672988f, 0.09306409f, 0.06224924f, 
    -0.13667428f, -0.02995902f, 0.17749877f, -0.16952959f, -0.11125321f, -0.17654260f, -0.01273862f, 0.08056705f, 
    0.03458429f, 0.16473301f, 0.37097722f, 0.02126713f, -0.22393219f, -0.13556272f, -0.17418519f, -0.05450011f, 
    -0.03048327f, 0.04587751f, -0.22234936f, -0.24941310f, -0.19402646f, -0.00893993f, 0.03956875f, 0.06920105f, 
    -0.06886894f, 0.11695690f, -0.03066571f, 0.16096161f, -0.17749058f, -0.31307489f, 0.03319292f, 0.21559472f, 
    0.10131408f, 0.07276656f, -0.10655734f, 0.03167890f, 0.08924917f, -0.41943833f, -0.54969639f, -0.06050170f, 
    0.03902053f, -0.04626533f, 0.12527288f, 0.00632262f, 0.20697789f, -0.08298192f, -0.08739813f, 0.08187532f, 
    0.08605497f, 0.06213440f, 0.00926348f, 0.13585913f, -0.06157247f, -0.00114774f, -0.59043318f, -0.47224516f, 
    -0.63679469f, 0.04352873f, 0.11993947f, 0.09068257f, -0.08694260f, 0.04723930f, -0.02803205f, -0.03124215f, 
    0.31360778f, 0.23995569f, -0.04523363f, 0.00461063f, -0.00495075f, 0.07220802f, -0.04436314f, -0.04929795f, 
    -0.04789160f, -0.14040501f, -0.02008064f, -0.06183563f, 0.18360335f, 0.11596691f, -0.05024635f, -0.04650468f, 
    0.02411035f, -0.37329528f, -0.27541524f, -0.33428541f, 0.00703366f, 0.15443274f, 0.11069990f, 0.22032762f, 
    -0.00340477f, -0.29504675f, 0.25831452f, 0.06883832f, 0.01189293f, -0.08190616f, -0.08724643f, -0.00422937f, 
    0.22459234f, 0.00683571f, -0.05930321f, 0.42486534f, 0.38951787f, -0.02123561f, -0.23265474f, -0.11218853f, 
    -0.17632620f, 0.01788208f, 0.23457453f, 0.15108261f, -0.47757262f, -0.74780744f, -0.38215029f, -0.30028331f, 
    -0.11728869f, -0.12088623f, -0.12681475f, -0.30840230f, -0.00621003f, -0.62660855f, -0.34084123f, 0.01783829f, 
    -0.01489662f, -0.06577060f, -0.14459069f, 0.07551141f, 0.07334146f, 0.05472684f, 0.26309201f, -0.00772605f, 
    0.07138474f, -0.16888900f, -0.09846680f, -0.12007543f, 0.05252533f, -0.11458141f, 0.23428549f, 0.29760632f, 
    0.20270175f, 0.03039624f, 0.22584461f, 0.17734034f, 0.14209971f, 0.18595260f, 0.11219534f, 0.08206377f, 
    0.30888215f, -0.39142212f, -0.76838923f, -0.22836010f, -0.01203126f, 0.03408835f, 0.03261997f, 0.05573750f, 
    -0.06044054f, -0.10577513f, -0.13469735f, 0.08241893f, -0.08129798f, 0.16093828f, -0.15506527f, -0.06712578f, 
    -0.06239755f, 0.02343318f, -0.13155776f, 0.06195493f, 0.14820307f, -0.27143157f, 0.06169539f, -0.04747622f, 
    -0.02502024f, 0.09545232f, 0.12116125f, 0.20704697f, 0.16690819f, 0.44472358f, -0.09471513f, -0.01667909f, 
    -0.11793244f, 0.27300715f, -0.11839218f, -0.16273412f, 0.07310567f, 0.09097273f, -0.26769957f, -0.13405785f, 
    -0.08378497f, 0.22506791f, 0.07358640f, -0.01977394f, -0.12939878f, -0.04241144f, -0.10196605f, 0.25925040f, 
    0.15377904f, -0.01339827f, 0.08376118f, 0.08877511f, 0.18123288f, 0.02810970f, 0.08648743f, -0.06294961f, 
    -0.24171771f, 0.12665103f, 0.11191554f, -0.08877888f, 0.02284468f, -0.04996036f, 0.00860873f, 0.17228843f, 
    0.14145772f, -0.24130654f, -0.09794229f, 0.00834129f, -0.02057985f, 0.06875992f, 0.01145811f, 0.05875167f, 
    0.46831080f, -0.09068616f, -0.19891186f, -0.03728348f, -0.00949481f, 0.07384738f, -0.01816705f, 0.01914809f, 
    0.04720760f, -0.15958388f, -0.06927843f, -0.14668867f, -0.05202531f, -0.11563084f, 0.16439919f, 0.17374896f, 
    -0.04784953f, 0.03311567f, 0.43749213f, 0.24254431f, -0.12437385f, -0.14208573f, -0.02220459f, 0.12008369f, 
    -0.00411551f, -0.04276302f, -0.08238604f, 0.18563753f, 0.19386469f, -0.15169595f, -0.09256440f, -0.01033775f, 
    -0.00485858f, -0.02627894f, -0.09031328f, 0.26969415f, 0.44373217f, 0.08691069f, -0.09363916f, -0.03855864f, 
    0.01874656f, -0.02461802f, -0.14078298f, 0.04605388f, 0.21415754f, -0.27146053f, -0.20512573f, 0.00511468f, 
    -0.13685292f, -0.11228158f, 0.11951073f, 0.17697185f, 0.09303395f, 0.05926640f, -0.00441610f, 0.01376956f, 
    0.02390502f, 0.01730957f, 0.06107641f, 0.05583938f, 0.00639103f, -0.08706032f, 0.01387316f, -0.50678790f, 
    -0.04641709f, 0.32122242f, 0.07843169f, 0.06451277f, -0.06873431f, 0.07496134f, 0.20489818f, 0.20725320f, 
    -0.12171461f, -0.16117507f, 0.19309370f, -0.04390117f, -0.00248962f, -0.01491881f, 0.05403983f, 0.16123137f, 
    0.10873283f, -0.31830913f, 0.03071614f, 0.12520511f, -0.06399635f, -0.23176382f, 0.03049384f, 0.02192432f, 
    0.07279120f, 0.16786034f, -0.58668804f, -0.13256471f, -0.08755919f, 0.06500869f, -0.11399987f, 0.27449802f, 
    -0.06893292f, 0.20442353f, 0.00088095f, 0.02648767f, -0.13558571f, -0.13178474f, -0.11330365f, 0.18655352f, 
    0.14228553f, -0.09849237f, -0.20634036f, 0.03837673f, 0.24427745f, -0.10476710f, -0.43765867f, 0.03627051f, 
    0.05379375f, 0.00152800f, -0.03091435f, -0.00575588f, -0.27357119f, 0.20118725f, 0.12720479f, -0.06686608f, 
    -0.02702752f, 0.09919816f, 0.06344619f, 0.04181735f, -0.03296498f, -0.01502448f, 0.77570963f, -0.35406554f, 
    0.00077056f, -0.03103481f, 0.11616357f, -0.10202151f, -0.04072196f, -0.06649126f, -0.05559819f, -0.02520722f, 
    -0.07621343f, 0.23817113f, -0.18661624f, -0.10281500f, -0.21795557f, -0.13475332f, -0.06016623f, 0.09007550f, 
    -0.04756461f, -0.10676312f, -0.07756326f, -0.02564530f, 0.04231061f, -0.05850770f, 0.10747849f, -0.10190605f, 
    -0.00177039f, 0.07188158f, -0.27949882f, -0.05864660f, -0.00585284f, -0.15750052f, 0.04868151f, 0.07224467f, 
    0.10981103f, 0.13424729f, -0.04746397f, 0.07015260f, 0.16772489f, -0.07604998f, -0.00982964f, -0.04238061f, 
    0.28989458f, 0.04622246f, 0.03554131f, 0.10803872f, 0.12203958f, 0.24474528f, -0.18275271f, -0.23615907f, 
    -0.15846074f, -0.03289675f, -0.06842776f, 0.01965775f, 0.06838761f, 0.14734833f, -0.52590793f, -0.10212024f, 
    0.15692692f, 0.01436984f, 0.16115606f, 0.02238215f, -0.27952266f, 0.13677874f, 0.09987856f, 0.45425013f, 
    0.01703327f, -0.10745302f, 0.00333988f, 0.09298854f, 0.14344732f, 0.20122576f, -0.05653299f, 0.02022703f, 
    0.19760969f, 0.06633574f, -0.04949577f, 0.02167527f, 0.01168120f, -0.00906419f, -0.00559608f, -0.24006672f, 
    -0.30630219f, -0.00620182f, 0.02416565f, -0.03518746f, -0.07550782f, 0.07374211f, 0.05244343f, 0.03241947f, 
    -0.08562678f, 0.52422357f, 0.17658056f, 0.02710976f, 0.07681803f, 0.00467170f, 0.21510527f, 0.13987091f, 
    0.03116199f, 0.01629552f, 0.09282068f, 0.16188017f, -0.18616202f, -0.10586010f, -0.00915637f, 0.07386588f, 
    0.02574717f, 0.22075586f, -0.14411019f, -0.18956837f, -0.03604177f, -0.09232617f, -0.12442224f, -0.02306409f, 
    0.12366291f, -0.01426842f, 0.16206183f, -0.07674322f, -0.55074340f, -0.14975518f, -0.05531353f, -0.10581783f, 
    0.01432709f, -0.11998669f, -0.05348954f, -0.07862890f, -0.35239539f, 0.33964136f, 0.14672792f, -0.11792561f, 
    -0.01136817f, -0.09338750f, 0.06986455f, -0.14042816f, -0.08348455f, -0.30937359f, -0.03944575f, 0.12795103f, 
    -0.11811160f, 0.06988358f, 0.09911561f, -0.09606139f, 0.08411114f, 0.16412395f, 0.01955687f, 0.01897588f, 
    0.24798855f, 0.01754589f, 0.12056234f, 0.00730744f, 0.08528111f, 0.08771753f, 0.07197813f, 0.08753005f, 
    -0.06757540f, -0.08184041f, 0.03682888f, 0.02741011f, -0.13678434f, 0.11590257f, -0.00263964f, -0.13132600f, 
    -0.17421475f, 0.12446335f, 0.10895058f, 0.02126882f, 0.08075896f, 0.13268146f, 0.05518270f, 0.01532595f, 
    0.04609168f, 0.18360357f, 0.26824316f, -0.13675031f, 0.25722030f, 0.01600188f, 0.03462132f, 0.25240785f, 
    -0.02972553f, 0.03184894f, -0.58378279f, 0.13597475f, 0.13673793f, -0.05881859f, -0.10406985f, -0.09466870f, 
    0.17621741f, -0.19480193f, -0.03136722f, -0.10649266f, -0.03519909f, -0.07230091f, -0.04361561f, -0.01328279f, 
    -0.09657644f, 0.08589557f, 0.05458302f, -0.11870735f, -0.15384296f, -0.25612089f, 0.27889732f, -0.05772992f, 
    -0.06381500f, 0.00522010f, 0.03293949f, -0.00575947f, -0.15609789f, 0.05784989f, -0.02291366f, -0.52768475f, 
    -0.10641095f, -0.15735979f, -0.01463597f, 0.24739859f, 0.14227533f, 0.16215621f, 0.13126953f, -0.00422412f, 
    0.02655014f, -0.06815176f, 0.02164740f, 0.11528645f, -0.05993802f, 0.10531060f, 0.32151741f, -0.43090588f, 
    -0.19561605f, -0.06981204f, 0.03440997f, -0.15102200f, -0.04824205f, -0.07165366f, 0.05823827f, 0.24371590f, 
    -0.30740502f, -0.19231565f, 0.23228943f, 0.12036385f, -0.10717589f, 0.03100653f, 0.01749030f, -0.08363767f, 
    0.17540452f, 0.02671410f, -0.04080294f, -0.33784336f, 0.05178917f, -0.03175695f, -0.05985622f, 0.04924351f, 
    -0.03662151f, -0.23012708f, -0.45828733f, -0.81129080f, -0.33396840f, 0.26745677f, 0.13777919f, 0.04377935f, 
    -0.16115721f, 0.07704234f, 0.01701022f, -0.02170031f, 0.38454983f, 0.18206465f, -0.03994930f, 0.06965233f, 
    -0.07211750f, 0.06437952f, 0.04135206f, 0.09355377f, -0.19282854f, 0.37364668f, 0.17240629f, -0.04919514f, 
    0.03665912f, -0.04230659f, 0.17314634f, 0.08304428f, -0.05911691f, -0.18501079f, 0.15966929f, 0.30028969f, 
    0.03682216f, 0.04568688f, 0.03440132f, 0.10995004f, -0.06736001f, -0.01866082f, -0.09924331f, -0.05907607f, 
    -0.07589997f, -0.60721534f, -0.17468157f, -0.27161753f, 0.00528784f, 0.00364366f, 0.11672807f, 0.04594129f, 
    0.10676696f, 0.15150611f, -0.02726358f, -0.04156396f, -0.16297716f, 0.10685126f, 0.07674979f, 0.12070710f, 
    0.04316018f, 0.15275000f, -0.24151734f, 0.09386484f, -0.08366666f, 0.04429201f, -0.12779793f, 0.14438589f, 
    0.12585722f, -0.22605605f, -0.22459228f, 0.02382491f, 0.01944028f, 0.08914966f, 0.01841446f, -0.00848519f, 
    0.02064322f, -0.04148924f, -0.09967931f, -0.02732162f, -0.07030495f, -0.26145625f, 0.01902214f, -0.02615923f, 
    0.14412647f, 0.14354599f, 0.13887668f, -0.27030236f, -0.02549626f, -0.05358101f, -0.29789403f, -0.31321809f, 
    -0.29967341f, 0.03493648f, -0.08525890f, 0.19584826f, -0.26869678f, 0.17061692f, 0.14061040f, 0.00374884f, 
    -0.08475257f, -0.33002335f, 0.12413633f, -0.06284916f, -0.15544300f, -0.20279904f, -0.39160004f, -0.00154491f, 
    0.13634443f, -0.03666033f, 0.15671445f, 0.03781895f, 0.02034115f, 0.11847938f, -0.17361049f, -0.07312584f, 
    0.06369591f, -0.14164376f, -0.19426937f, -0.07555697f, -0.11072539f, -0.26980680f, -0.20755455f, 0.57796240f, 
    -0.09293418f, 0.10088090f, 0.11947781f, 0.05313440f, 0.04327007f, -0.01797483f, 0.08668506f, 0.35757393f, 
    0.15564196f, 0.11901233f, -0.11199814f, 0.02798973f, 0.05974537f, 0.03025559f, 0.08598279f, -0.03504764f, 
    0.11119374f, -0.00844976f, -0.06513676f, -0.26810789f, 0.00426679f, -0.03365159f, 0.16051033f, 0.06094922f, 
    0.00047953f, 0.14735167f, -0.12607774f, -0.04811845f, -0.17765693f, 0.10549643f, 0.05186302f, -0.01669232f, 
    0.00411867f, 0.16690455f, 0.11338808f, 0.01951555f, -0.24126366f, 0.07723780f, 0.45496708f, -0.19348778f, 
    -0.23707920f, -0.11162930f, 0.05763833f, 0.18105617f, 0.18318498f, 0.18861334f, 0.15520884f, 0.01702915f, 
    -0.14718439f, 0.00946273f, 0.00918388f, -0.09068201f, 0.06291116f, -0.19795641f, -0.13147536f, -0.10719746f, 
    -0.04357558f, 0.37004256f, 0.07867092f, 0.10531574f, 0.22121151f, 0.07151939f, 0.15230031f, 0.16280901f, 
    0.09292923f, 0.04456809f, 0.10869543f, 0.06214666f, 0.04187024f, -0.01163773f, -0.02253878f, 0.14211392f, 
    0.07439221f, 0.18102394f, 0.03322775f, -0.00413219f, 0.12412973f, 0.08234886f, -0.09093519f, -0.06741296f, 
    0.28197584f, 0.17998482f, 0.13867064f, -0.01360652f, 0.01527955f, -0.14567579f, -0.00488701f, -0.00127558f, 
    -0.08531275f, 0.03813586f, 0.23445594f, -0.02994209f, -0.03116849f, -0.12508918f, 0.03680547f, -0.05440095f, 
    -0.08334958f, 0.02508339f, 0.36710903f, 0.21909563f, 0.21656582f, -0.09897154f, -0.13373239f, 0.02579371f, 
    0.01864814f, 0.19924121f, 0.12794068f, 0.02060936f, 0.11615228f, 0.20461182f, -0.02193172f, 0.04840339f, 
    0.07360527f, 0.11704393f, -0.10179113f, 0.02143883f, 0.18881297f, 0.33856934f, 0.46953493f, -0.05869589f, 
    -0.03688767f, 0.01396355f, 0.13827954f, 0.07446972f, 0.02689984f, -0.12335900f, -0.15053070f, -0.21080934f, 
    -0.10339223f, 0.08214539f, -0.02909339f, 0.02641704f, 0.11664087f, 0.13472222f, -0.14726187f, -0.14245771f, 
    0.21497288f, 0.05292123f, 0.11332481f, 0.04011642f, -0.06437978f, 0.11240442f, 0.04809542f, -0.07924505f, 
    -0.27136502f, -0.15447038f, -0.01290965f, 0.04000172f, -0.11729100f, 0.08394983f, 0.07857033f, 0.17093360f, 
    -0.14265899f, 0.05620866f, 0.16970091f, 0.01060755f, 0.11289915f, -0.10102474f, -0.09022821f, -0.04243379f, 
    -0.07626733f, -0.04373910f, -0.11757407f, -0.13728170f, 0.07044072f, -0.00598036f, 0.06771564f, -0.03159279f, 
    -0.21484298f, -0.10320536f, 0.03253326f, 0.04560412f, -0.09524915f, 0.04623361f, 0.25870430f, 0.15133044f, 
    0.02731424f, 0.10676337f, 0.04641141f, 0.13374987f, 0.11377975f, 0.04237929f, 0.04147485f, -0.04838137f, 
    0.03019970f, -0.05999765f, -0.10337962f, -0.00816025f, 0.32207164f, -0.02408792f, -0.03954819f, 0.08504893f, 
    -0.09195582f, 0.03775766f, 0.00623231f, -0.08214978f, 0.10525349f, 0.26895157f, 0.16286080f, 0.36856392f, 
    -0.12544793f, -0.00538255f, 0.05893802f, -0.00924823f, 0.04473928f, 0.04605661f, 0.22395846f, -0.16565755f, 
    -0.08040466f, 0.15542863f, -0.15818459f, 0.02914006f, -0.03254345f, 0.11114021f, 0.10820845f, -0.21134904f, 
    -0.10708594f, -0.47511157f, 0.01484749f, -0.02419814f, -0.06277864f, -0.03057658f, 0.06647860f, 0.05193390f, 
    -0.00979270f, 0.08472995f, -0.24438311f, 0.03701938f, -0.02954440f, -0.06127458f, -0.09912293f, -0.01007813f, 
    -0.00499466f, 0.08753832f, 0.09243360f, 0.02474330f, 0.16333002f, -0.07780061f, 0.07909650f, 0.15161173f, 
    0.06190836f, -0.15155599f, -0.15507513f, -0.04447538f, -0.28710145f, 0.14446388f, 0.03829147f, 0.01211205f, 
    -0.00182013f, 0.31761622f, 0.14602675f, -0.34311470f, -0.23753217f, -0.38334960f, -0.01459600f, 0.11146124f, 
    0.05106667f, 0.11726384f, 0.18041831f, 0.25069398f, 0.21487230f, 0.21943755f, 0.16279243f, -0.11139835f, 
    -0.06533726f, -0.16618043f, -0.00679488f, -0.14400111f, 0.17548512f, 0.13210577f, 0.36055410f, 0.42149568f, 
    0.14873616f, 0.07521310f, -0.17681636f, -0.07723463f, 0.06233662f, -0.04745958f, -0.15217900f, -0.30727026f, 
    -0.30382678f, 0.06679907f, -0.01937667f, -0.10391384f, 0.04179458f, -0.07630259f, -0.03365237f, -0.18491678f, 
    0.08353321f, -0.24388514f, -0.02618240f, 0.02781445f, 0.11064143f, -0.02562455f, 0.03404701f, 0.19583531f, 
    -0.14659010f, 0.09946514f, -0.00687946f, 0.05287063f, 0.02267294f, 0.00571409f, 0.11715391f, -0.06982002f, 
    0.10586062f, -0.08491916f, 0.06283452f, -0.00615180f, 0.06070622f, 0.23157033f, 0.03057909f, 0.19159098f, 
    -0.07979286f, -0.08371570f, -0.06006836f, -0.16079175f, -0.37943819f, -0.24439913f, 0.08618155f, -0.29660678f, 
    0.08371939f, -0.01738553f, -0.07468485f, 0.36201602f, -0.33383688f, -0.00327708f, -0.07274177f, -0.01939118f, 
    0.23210135f, -0.03676008f, 0.06300934f, -0.06216697f, -0.37061474f, -0.02987399f, 0.08713447f, -0.01328326f, 
    0.09009770f, 0.18970920f, -0.15749480f, 0.14768623f, -0.03633829f, 0.06428318f, 0.08686169f, 0.08331280f, 
    0.06401106f, 0.23959738f, -0.16169070f, 0.34962106f, 0.12075761f, 0.15798919f, 0.05269244f, -0.08802021f, 
    0.10027824f, 0.10391387f, -0.11510257f, 0.15616913f, 0.06472784f, 0.12943736f, 0.05475575f, -0.10508292f, 
    -0.10837216f, 0.03200756f, 0.03141535f, -0.01488414f, -0.04460252f, 0.04446756f, 0.23470277f, 0.19866501f, 
    -0.00244272f, -0.08539122f, 0.00923140f, -0.01368933f, -0.03428550f, -0.02506820f, -0.03878146f, -0.06496784f, 
    0.00578845f, 0.14402972f, 0.09963802f, -0.03113024f, -0.02562732f, 0.09038960f, 0.09238040f, 0.01427734f, 
    0.12240618f, -0.11018318f, -0.25737277f, 0.00512797f, 0.02694049f, -0.09838672f, -0.07172935f, 0.00233926f, 
    -0.05800283f, -0.02836655f, 0.16950375f, -0.38186598f, -0.20154782f, -0.04294936f, -0.00737733f, 0.00760927f, 
    0.04605933f, 0.11367024f, 0.32944742f, 0.21558344f, -0.04786205f, -0.11236539f, -0.04840946f, 0.09215241f, 
    -0.05909840f, 0.01115249f, 0.02705854f, -0.06478874f, 0.19445294f, -0.12497118f, 0.06881362f, -0.05313884f, 
    0.03060578f, 0.19433783f, 0.00906317f, 0.31905934f, 0.22214781f, -0.26032344f, 0.22245893f, -0.11749967f, 
    0.13593175f, 0.08233055f, 0.13334200f, 0.10265668f, 0.27356607f, -0.09834392f, 0.08872773f, 0.06991500f, 
    -0.25195575f, -0.50140703f, 0.10398627f, -0.04068524f, -0.12489626f, -0.02628444f, 0.19112290f, 0.06987924f, 
    -0.08392561f, -0.21876363f, 0.28227222f, 0.03409342f, -0.06178622f, -0.00954683f, 0.16017970f, -0.00930619f, 
    0.34598228f, 0.01846207f, -0.20256469f, -0.02511207f, 0.04222334f, 0.04108549f, 0.06546590f, -0.13632189f, 
    0.03466960f, -0.05358396f, 0.09952286f, -0.28639236f, -0.10492937f, -0.17775601f, -0.07228605f, -0.03586414f, 
    0.04482447f, 0.14486296f, 0.17573607f, 0.00493128f, 0.08575519f, 0.15980740f, 0.04343425f, 0.05134530f, 
    0.08603971f, -0.18443400f, 0.17050129f, 0.14033045f, -0.01223232f, 0.08611576f, 0.12919867f, 0.00806701f, 
    0.08408431f, -0.00864779f, -0.02151969f, -0.06159151f, -0.02650613f, 0.07950537f, 0.05759047f, 0.05137518f, 
    -0.01897875f, 0.04951277f, 0.05006433f, 0.12787081f, 0.00934832f, 0.17914774f, -0.13713010f, 0.02123909f, 
    -0.03042228f, 0.07890718f, -0.08512130f, -0.18823518f, 0.13012446f, 0.05842087f, -0.01132470f, -0.11811824f, 
    -0.07869661f, -0.12214877f, 0.08912086f, 0.26960507f, 0.00239412f, 0.14336990f, 0.02974521f, -0.00281018f, 
    0.48969570f, -0.07238255f, 0.10275847f, -0.02363145f, -0.13192096f, -0.10188896f, -0.16528054f, 0.00700661f, 
    -0.06650885f, -0.02821331f, -0.07831706f, -0.29795140f, -0.01300256f, 0.06474029f, -0.18658786f, 0.14946197f, 
    0.11935288f, 0.08824618f, -0.25252190f, -0.15596344f, 0.00094409f, -0.09692992f, -0.16383845f, 0.08228670f, 
    0.05363373f, 0.12448420f, 0.07950043f, -0.20577370f, -0.05106581f, -0.32218471f, -0.29108682f, -0.26847625f, 
    -0.52531457f, 0.01953011f, 0.05268434f, -0.22507332f, -0.29193619f, -0.03214345f, 0.01342157f, -0.07527272f, 
    -0.10746919f, 0.05017578f, 0.03800060f, -0.01444486f, 0.01323577f, -0.04010584f, -0.18729232f, 0.19242932f, 
    0.17734420f, -0.13270748f, 0.04250019f, 0.15257648f, 0.11381720f, 0.12186788f, -0.07308023f, 0.02904345f, 
    -0.12435403f, -0.17197745f, -0.14004309f, 0.00139088f, -0.11239646f, -0.08246298f, -0.03775352f, 0.23205154f, 
    0.13047059f, 0.11702402f, 0.12680355f, 0.16577969f, 0.12601040f, 0.03009180f, 0.07516862f, -0.04634368f, 
    0.24342877f, -0.08693348f, 0.13236825f, -0.18252571f, -0.00569475f, 0.12208735f, 0.06130628f, 0.15748669f, 
    0.05366446f, 0.02969582f, -0.13720571f, 0.11030921f, -0.03165865f, -0.13091354f, 0.24196416f, -0.00205873f, 
    -0.14949006f, -0.01463623f, -0.10984070f, -0.03182365f, 0.01536074f, 0.03485296f, 0.16056298f, -0.01318169f, 
    0.02528585f, 0.06981248f, 0.15137656f, -0.80818033f, -0.18032740f, 0.19178733f, -0.23066834f, -0.25817341f, 
    -0.17713018f, 0.18198887f, 0.01536517f, 0.12859264f, 0.04078021f, 0.03604262f, 0.04129138f, -0.04799896f, 
    0.18754533f, -0.09831356f, 0.12679036f, -0.10125568f, -0.17699365f, -0.13672151f, -0.31421787f, 0.10046386f, 
    -0.08771554f, -0.10541406f, 0.05703155f, 0.03463870f, 0.11001085f, 0.12406568f, -0.11601114f, 0.11853947f, 
    0.15352231f, -0.05784130f, 0.06753722f, 0.10601041f, 0.06438126f, 0.06033408f, -0.07328767f, 0.10573971f, 
    0.21848032f, 0.02759232f, -0.12029345f, 0.05778170f, 0.04204314f, 0.03005829f, 0.02807874f, -0.15677597f, 
    0.19367422f, 0.07701362f, 0.15905651f, -0.10631476f, 0.01282887f, 0.03008923f, -0.03503415f, 0.12579164f, 
    0.03321138f, -0.05091229f, 0.19814160f, -0.03111233f, -0.03502304f, 0.04273212f, 0.10674931f, -0.01995487f, 
    -0.05477032f, -0.00708755f, 0.26316565f, -0.13385405f, 0.25968349f, -0.26842913f, -0.11793835f, -0.04869286f, 
    -0.14301236f, 0.12053550f, -0.05356251f, 0.14275070f, 0.13507022f, 0.01966449f, -0.08026448f, 0.04197535f, 
    -0.06209803f, 0.03171046f, 0.01203507f, -0.11600666f, 0.27805895f, 0.27244127f, 0.14188160f, -0.02880674f, 
    -0.08410887f, 0.12119438f, -0.05867476f, 0.08977789f, 0.06195104f, 0.02811829f, -0.40748709f, -0.36452785f, 
    0.03458021f, -0.14919780f, -0.07679737f, -0.12306993f, 0.01058356f, 0.27300352f, -0.14192766f, -0.18077430f, 
    -0.06855167f, -0.11157532f, -0.06644810f, 0.06485121f, 0.07143312f, -0.05679911f, 0.15966341f, -0.40871459f, 
    -0.28478071f, -0.09125924f, 0.22267880f, -0.03744603f, -0.04001290f, -0.04631205f, 0.02825716f, 0.05501191f, 
    -0.14939973f, -0.03303264f, 0.01340186f, 0.00019944f, -0.09445938f, -0.05161849f, -0.08376223f, -0.00864879f, 
    0.10194907f, -0.02405611f, -0.09181076f, -0.28316349f, -0.19661607f, -0.09901044f, -0.06666254f, 0.13892817f, 
    0.03969458f, 0.04562446f, -0.24025671f, -0.33316824f, -0.18004493f, 0.09448341f, 0.01590141f, 0.09859450f, 
    0.08882464f, 0.22199318f, 0.23825064f, 0.05266372f, 0.04072039f, 0.01408208f, 0.03589116f, 0.16664800f, 
    0.08995857f, 0.07984903f, -0.14203656f, -0.11495426f, 0.19748124f, -0.08281123f, 0.13247630f, -0.15467614f, 
    -0.08987800f, 0.12670092f, 0.05813118f, -0.04479527f, 0.04788461f, 0.15809596f, 0.01417805f, 0.21502399f, 
    0.02112531f, -0.14241974f, 0.04631796f, -0.04185014f, 0.11014095f, 0.01931366f, -0.31520599f, -0.16842151f, 
    0.15982415f, -0.02297208f, -0.03083150f, 0.04800704f, -0.07517411f, 0.23196650f, -0.04168310f, 0.29866275f, 
    0.04468952f, 0.10187973f, -0.05573012f, -0.07575777f, -0.12724069f, 0.12415173f, 0.02387253f, -0.00652549f, 
    -0.46865380f, 0.03847245f, -0.06852946f, 0.08614422f, 0.04213061f, 0.17479250f, -0.03215664f, 0.03897131f, 
    0.07464832f, 0.04216339f, -0.20318970f, 0.03490942f, -0.06108675f, 0.00593009f, -0.07612841f, 0.03635801f, 
    0.13357316f, 0.28062949f, -0.11961667f, -0.04589743f, -0.09537573f, -0.06470954f, 0.09219262f, -0.02941068f, 
    0.09467114f, 0.06363520f, 0.11336412f, -0.37258154f, -0.15111864f, 0.06077142f, -0.02593786f, -0.04813320f, 
    -0.04315082f, -0.03694728f, 0.08503515f, 0.07737105f, 0.10238429f, -0.04165745f, 0.22271985f, -0.21876968f, 
    0.12063853f, 0.11444706f, 0.09515605f, -0.08308086f, 0.05580609f, -0.00563760f, 0.23301516f, 0.03506469f, 
    0.09496645f, 0.14580821f, -0.07327731f, -0.05892442f, 0.13054465f, 0.07987060f, 0.03570637f, -0.21183568f, 
    -0.12804541f, 0.05684842f, -0.08411027f, 0.00109895f, 0.01568806f, 0.06899250f, -0.28108397f, 0.07304755f, 
    0.10082574f, -0.21331955f, 0.05420456f, -0.01259251f, -0.07616145f, -0.00573707f, -0.14573836f, 0.14753997f, 
    0.11997468f, 0.13086450f, 0.04513117f, -0.08025575f, 0.10419737f, 0.19856970f, -0.14464144f, -0.21771745f, 
    -0.12651245f, 0.01704153f, 0.02685387f, -0.09527550f, 0.16656017f, 0.12640502f, 0.15135694f, -0.28386861f, 
    0.01930953f, -0.28715098f, -0.27987415f, -0.09879884f, -0.19016939f, 0.01701691f, 0.11436252f, 0.10914483f, 
    0.12294629f, 0.11797505f, 0.14844024f, 0.10875569f, 0.33642453f, 0.15404150f, 0.40484381f, 0.02196613f, 
    0.18782485f, 0.22348581f, -0.00657850f, 0.14386766f, -0.24318209f, -0.09740956f, 0.16135557f, -0.06730941f, 
    -0.25610059f, -0.03111839f, 0.02260160f, -0.04425925f, -0.22696251f, 0.15414393f, 0.08150640f, 0.17812894f, 
    0.18727060f, 0.17271760f, -0.06256966f, 0.19409873f, 0.14916822f, 0.38788924f, 0.18162495f, 0.05111255f, 
    0.23808043f, -0.06597872f, -0.02897838f, 0.12573184f, 0.07325098f, 0.00443183f, 0.21006049f, 0.01020057f, 
    -0.18011165f, 0.15376809f, 0.07216498f, -0.00084526f, 0.16687724f, 0.03780630f, -0.16481131f, -0.17215921f, 
    0.09992965f, 0.04431511f, 0.00894507f, -0.06934883f, -0.17037463f, 0.07847124f, -0.03722328f, -0.06233037f, 
    0.03779680f, -0.06572087f, 0.09410723f, 0.07627708f, -0.09555545f, 0.05379919f, 0.08453109f, -0.08226228f, 
    0.03408094f, -0.03718929f, -0.04608922f, 0.10320047f, -0.02626161f, 0.11263280f, -0.21060677f, -0.05607644f, 
    -0.13700110f, 0.18126960f, -0.03901771f, -0.09143168f, -0.09331836f, -0.04385111f, -0.02600859f, -0.09648689f, 
    0.11144873f, 0.04753532f, -0.00989066f, -0.15127932f, 0.24147855f, -0.04038419f, 0.00020427f, -0.00816542f, 
    -0.14314495f, 0.01839872f, -0.01657742f, -0.01000852f, 0.02071728f, -0.13059820f, 0.37531009f, -0.05190971f, 
    0.10682973f, 0.06870208f, 0.05885375f, -0.13568142f, 0.20184653f, 0.04454618f, -0.01207908f, 0.36858228f, 
    0.18296190f, 0.00228033f, 0.35854679f, -0.00354018f, -0.06799328f, 0.17118309f, 0.26883146f, -0.16252391f, 
    0.21286060f, -0.22052324f, 0.07660865f, 0.08527842f, 0.06678672f, 0.08525552f, 0.08264532f, 0.05371561f, 
    -0.00808832f, -0.17581189f, -0.07574816f, 0.00331536f, 0.31620139f, -0.10979205f, 0.16895860f, 0.26453459f, 
    -0.10544813f, -0.17448592f, -0.22453648f, -0.16455162f, 0.00397901f, -0.08447900f, 0.01070563f, -0.08868861f, 
    -0.30776170f, -0.40806559f, -0.12848790f, 0.29214340f, 0.28388059f, 0.00913328f, -0.05671421f, 0.12387388f, 
    0.29692200f, 0.20307823f, 0.11483172f, -0.03653527f, 0.20810780f, 0.11937509f, -0.10101428f, -0.08304683f, 
    0.15675440f, -0.05254550f, -0.00086590f, 0.05098758f, 0.06607958f, 0.12808980f, 0.20455573f, 0.04727401f, 
    -0.22198172f, 0.03660407f, 0.05488873f, -0.07357711f, -0.04264618f, 0.31612828f, 0.02492101f, 0.03464731f, 
    -0.01580118f, 0.05518001f, -0.09855130f, 0.06960773f, -0.04776059f, 0.24257998f, 0.15295579f, 0.24318044f, 
    0.31292030f, 0.16641876f, 0.07797307f, 0.14298886f, -0.19070895f, 0.28820485f, -0.07023957f, -0.21833037f, 
    -0.07770737f, -0.24002321f, 0.04184338f, 0.21966730f, 0.23686935f, -0.03857531f, 0.14401297f, 0.10525329f, 
    0.24627976f, 0.32021603f, 0.14451294f, -0.13580920f, 0.12342504f, -0.01849123f, -0.04041671f, 0.08837078f, 
    -0.10021237f, -0.06856331f, 0.04594694f, 0.00920402f, -0.13253872f, 0.04592297f, -0.15194486f, 0.14238158f, 
    0.19652180f, 0.05514544f, -0.25054792f, 0.15641798f, -0.03379481f, 0.01214590f, 0.06709781f, 0.03623668f, 
    -0.07555008f, 0.19947478f, 0.01072333f, -0.31100020f, -0.35360077f, -0.30013949f, -0.15726952f, -0.09044860f, 
    0.16797510f, -0.06140948f, 0.10490169f, -0.26233101f, -0.19603911f, -0.31355765f, -0.00733973f, -0.09578087f, 
    -0.17196840f, -0.15199505f, 0.14539362f, -0.34069994f, -0.12399911f, -0.03760358f, 0.27688634f, -0.02595926f, 
    0.22429954f, 0.10369174f, -0.04844933f, 0.13425073f, 0.11343471f, -0.06583052f, -0.17679815f, -0.16037665f, 
    -0.09770785f, -0.27693596f, -0.06968881f, -0.02483568f, -0.14933343f, -0.17506891f, -0.14568818f, 0.13762860f, 
    0.22716641f, 0.65610498f, 0.22644052f, 0.09659133f, 0.52535957f, 0.13571401f, 0.16224016f, 0.31850600f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.07513683f, -0.01763800f, 0.19800681f, 0.00508121f, -0.01550999f, 0.26517871f, -0.04246760f, 0.00246978f, 
    0.02302749f, 0.15334764f, -0.01986599f, 0.01696646f, -0.00999994f, -0.00795286f, 0.25892061f, 0.22914131f, 
    0.04380903f, 0.00746726f, 0.08538711f, -0.03957019f, 0.13873994f, -0.02460465f, -0.02775427f, -0.00484290f, 
    0.16451393f, 0.30939072f, -0.00158816f, 0.32548293f, 0.06202998f, 0.11862908f, 0.01065425f, 0.12554644f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.62230468f, -0.07241318f, -0.23690696f, -0.07374910f, -0.15244491f, 0.36209887f, -0.01377305f, -0.06919522f, 
    -0.10890125f, -0.13212742f, 0.38296905f, 0.11128701f, 0.21780820f, -0.01605630f, -0.24241686f, 0.07682929f, 
    0.21485707f, 0.37314761f, 0.14428416f, -0.17440806f, 0.16750929f, -0.07571494f, -0.00687327f, -0.06774078f, 
    0.23070003f, -0.11781486f, 0.03819873f, -0.13546577f, 0.04027929f, -0.11210086f, 0.17303631f, 0.02463372f, 
    0.19546640f, -0.17309740f, 0.23257712f, -0.11311606f, 0.15363456f, 0.09668545f, 0.26764861f, -0.12470226f, 
    0.32486826f, 0.40794268f, 0.37686014f, 0.02469632f, 0.12800150f, 0.12380201f, -0.45503205f, -0.35429281f, 
    -0.32042143f, -0.22021236f, -0.20270464f, 0.03242250f, -0.07432309f, -0.10344670f, -0.02583159f, 0.00355279f, 
    0.15659660f, 0.38843328f, -0.05956917f, -0.42155904f, 0.15839171f, -0.14627005f, 0.10960345f, -0.10834354f, 
    -0.18748644f, -0.03406547f, 0.12932007f, 0.09300717f, 0.05108668f, 0.28518215f, 0.41172066f, 0.09117748f, 
    0.45484108f, 0.28006944f, -0.22437884f, 0.06841059f, -0.27379060f, -0.73895764f, -0.11358481f, 0.21041362f, 
    -0.45797604f, -0.23473440f, -0.03774678f, -0.12876603f, 0.33373529f, -0.15080303f, -0.54827344f, -0.09589578f, 
    0.08500895f, -0.25285411f, -0.78066283f, -0.01031718f, 0.06614262f, 0.15595239f, -0.26625618f, 0.13302754f, 
    0.23714969f, -0.16960572f, 0.26655635f, -0.06499250f, 0.14149742f, 0.62438631f, -0.06383939f, 0.00851859f, 
    -0.22292098f, -0.01880143f, 0.23318723f, 0.14791377f, 0.44387791f, -0.26141289f, -0.07411514f, -0.13824256f, 
    0.07271213f, 0.16310559f, 0.00244425f, -0.06148776f, -0.16301677f, 0.17225704f, -0.11822647f, 0.17085734f, 
    -0.21223731f, 0.08837302f, -0.28846258f, 0.29313555f, 0.29503527f, -0.33749893f, 0.41397038f, -0.06501383f, 
    0.01974922f, 0.00206715f, -0.44302920f, -0.04540113f, -0.08210199f, -0.13390857f, 0.10739833f, -0.09774023f, 
    -0.16623652f, 0.36990720f, 0.21841982f, 0.09712798f, -0.08017617f, 0.17971838f, -0.09150117f, -0.22660832f, 
    0.02955567f, 0.06780153f, 0.09272108f, 0.05159891f, -0.34588063f, 0.06975359f, 0.21889880f, -0.16783722f, 
    0.04656043f, -0.30091956f, 0.45610282f, -0.19514556f, 0.15164809f, -0.35014081f, 0.17147338f, -0.00969544f, 
    -0.01551586f, -0.04530078f, -0.10186304f, 0.04334822f, -0.12911236f, -0.04642629f, 0.08009003f, -0.10018814f, 
    -0.13276397f, -0.06472963f, -0.12219838f, 0.16866516f, -0.13141398f, -0.19639389f, 0.10734881f, -0.04054366f, 
    0.09020605f, 0.07933268f, 0.02951763f, 0.04183443f, -0.18654576f, 0.05516106f, -0.02381989f, -0.11893132f, 
    -0.10621002f, -0.11707354f, 0.06946294f, -0.12992960f, -0.15391859f, 0.03280141f, -0.05264219f, -0.14244448f, 
    -0.23419136f, -0.01503860f, 0.17575961f, -0.03833837f, 0.06790576f, -0.24521261f, 0.24880357f, 0.04733325f, 
    0.14911830f, 0.28710413f, -0.09217674f, -0.16734582f, -0.07056545f, 0.31447405f, -0.31834599f, 0.08482476f, 
    -0.57210624f, 0.44355258f, -0.62490332f, -0.08560286f, 0.29844546f, -0.15771155f, -0.19134030f, 0.05817288f, 
    0.21783854f, -0.47340512f, -0.34516245f, 0.22850572f, 0.11761946f, 0.02205011f, 0.08915295f, -0.06868186f, 
    -0.15881570f, 0.06488954f, 0.34206232f, 0.10186889f, -0.09338422f, 0.46187890f, -0.20831923f, 0.08693343f, 
    -0.16181041f, -0.07643827f, 0.34003031f, 0.06692743f, -0.08452730f, 0.04206349f, 0.10698143f, -0.49849975f, 
    -0.01601537f, -0.36980388f, 0.07168692f, -0.11545404f, 0.09238634f, 0.03775989f, 0.30282128f, -0.10542665f, 
    -0.06033103f, 0.40543160f, 0.24435219f, -0.10340503f, 0.40984330f, -0.03717259f, 0.33965403f, 0.11361464f, 
    -0.10337316f, -0.01716578f, -0.03800185f, -0.07532877f, -0.06344404f, -0.61459237f, 0.14416055f, 0.13886073f, 
    0.09323294f, 0.10212468f, -0.06270713f, -0.04347021f, 0.24651641f, 0.39013284f, -0.10306615f, 0.02948936f, 
    0.00930092f, 0.32193914f, 0.05390074f, -0.16935940f, -0.18001510f, 0.00524719f, 0.17085280f, 0.18132240f, 
    -0.12059482f, 0.54485464f, 0.50473273f, -0.15446122f, 0.05530669f, -0.00556100f, -0.21600679f, 0.18920563f, 
    0.39949355f, 0.10127964f, 0.06242513f, 0.03714025f, 0.12948889f, -0.38198161f, 0.18730071f, 0.07814515f, 
    0.20582694f, 0.36402696f, -0.11897618f, -0.08984748f, 0.06022962f, 0.25550401f, -0.16733207f, -0.08373360f, 
    -0.37110251f, -0.05844134f, -0.13325879f, 0.11248305f, -0.25877643f, 0.09418631f, -0.09629214f, 0.08610668f, 
    0.50569361f, -0.61659437f, -0.54655319f, 0.27115017f, 0.22925240f, -0.08941773f, 0.06989519f, -0.25440460f, 
    -0.25759411f, 0.09127560f, 0.40795285f, -0.05326340f, 0.02587175f, 0.28193253f, 0.23529451f, 0.17597963f, 
    0.31059369f, 0.01235752f, 0.02608247f, -0.01701729f, -0.10186129f, -0.29582578f, 0.04356921f, 0.11941788f, 
    -0.03162118f, 0.39265728f, -0.39449975f, 0.04589128f, 0.41906774f, 0.17281640f, -0.16902916f, 0.10789736f, 
    -0.26991820f, -0.36387715f, -0.32510939f, -0.15072723f, 0.02784269f, 0.08367129f, 0.04139202f, -0.10238191f, 
    -0.21981555f, 0.15836361f, 0.45387205f, 0.08033967f, -0.15242630f, -0.02288217f, 0.05537255f, -0.00222037f, 
    -0.24923089f, 0.12802051f, -0.10450969f, -0.14739266f, 0.29696983f, -0.32830426f, 0.34648177f, 0.46072367f, 
    0.13209733f, 0.16912854f, 0.19276395f, -0.03901975f, -0.00420535f, -0.12399619f, -0.07303898f, 0.11740957f, 
    -0.32384980f, 0.15176815f, -0.08267538f, 0.24110572f, 0.14230858f, 0.12608026f, 0.11701491f, 0.19471300f, 
    0.24050939f, 0.10389403f, -0.06178585f, -0.11889689f, 0.13592415f, 0.49837968f, -0.26126519f, -0.10043912f, 
    0.01164675f, -0.05985291f, -0.20338276f, 0.11424562f, 0.04677984f, 0.04942739f, 0.00000651f, -0.53787488f, 
    -0.24564710f, -0.41462478f, -0.02276178f, -0.03332553f, 0.55984026f, -0.12915283f, 0.05282786f, -0.01345816f, 
    0.41885772f, 0.46902567f, -0.02142526f, 0.10576927f, -0.03914943f, 0.29351696f, -0.29126668f, 0.36434859f, 
    -0.40172109f, -0.02540415f, 0.12889431f, 0.14410132f, 0.11934955f, 0.11365169f, 0.03138989f, 0.08850464f, 
    0.30185691f, 0.07931954f, -0.10660707f, 0.08163231f, -0.09911585f, -0.14571176f, 0.33582214f, -0.18472435f, 
    -0.07755103f, -0.15017608f, -0.25339359f, -0.02079279f, 0.04538343f, 0.12270357f, -0.03530689f, 0.16633829f, 
    0.13532791f, -0.22088979f, 0.09163870f, 0.13027269f, -0.13903823f, 0.38114643f, -0.41322184f, 0.36788586f, 
    0.85400039f, -0.05596271f, 0.08278798f, 0.06395741f, -0.06789341f, 0.45781907f, -0.05784287f, -0.02188222f, 
    -0.21827504f, -0.02506633f, 0.39333758f, 0.13592173f, 0.29123253f, 0.01609236f, -0.12546323f, 0.18965328f, 
    -0.08210815f, -0.02401103f, 0.07675342f, 0.16903286f, 0.51987588f, -0.11348322f, -0.16359913f, -0.14163876f, 
    -0.03550903f, 0.29971257f, -0.30810818f, -0.19772424f, 0.23702011f, -0.04211511f, 0.07740659f, -0.10469873f, 
    -0.03876440f, -0.00803358f, -0.02195270f, -0.01397195f, 0.09488597f, -0.14144130f, -0.04477029f, 0.04857976f, 
    -0.09053016f, -0.14074346f, 0.13928315f, 0.09631078f, 0.09515785f, -0.02836039f, 0.03676715f, 0.05969673f, 
    -0.00678150f, -0.16386500f, -0.03303528f, 0.16869992f, -0.12524347f, 0.01409780f, 0.13482596f, 0.14893302f, 
    -0.17659162f, 0.07687167f, -0.05678888f, 0.07500916f, -0.13484240f, -0.14414068f, -0.07636083f, -0.14900132f, 
    0.21279638f, -0.07680658f, -0.22685710f, -0.04825095f, -0.13344090f, 0.43826893f, -0.07806093f, -0.15610206f, 
    -0.20751925f, -0.04312162f, 0.04506154f, -0.15949529f, -0.07490972f, -0.30152619f, 0.29884499f, 0.19139338f, 
    0.07003433f, -0.15693659f, 0.27368370f, 0.12790361f, 0.01235126f, 0.03347513f, -0.04331036f, 0.12938643f, 
    0.34991580f, 0.09471804f, -0.52975100f, 0.40081123f, -0.07725032f, 0.20104793f, 0.22149420f, 0.05789372f, 
    -0.23008563f, -0.17357889f, 0.11027309f, 0.11499910f, 0.09692203f, -0.68398148f, 0.11828954f, 0.03888536f, 
    0.16914476f, -0.06343373f, -0.19362220f, 0.01495637f, 0.43875265f, 0.11916102f, -0.36359239f, -0.00435924f, 
    -0.03797647f, 0.56214201f, -0.41208181f, -0.05718862f, 0.00977481f, -0.11974282f, -0.16957459f, -0.06782100f, 
    -0.13190661f, -0.11256714f, 0.56183231f, 0.04236880f, 0.13807034f, 0.13790730f, -0.14054853f, 0.17119421f, 
    -0.38697371f, -0.07325495f, 0.26236841f, 0.00653163f, 0.09002887f, 0.43584508f, 0.33291531f, 0.16845702f, 
    0.15937534f, 0.46496868f, -0.02849044f, -0.02081592f, 0.05506712f, -0.21794881f, 0.02169709f, 0.12015556f, 
    0.08355083f, 0.12846637f, -0.26102045f, -0.00283879f, -0.49688518f, 0.09782486f, -0.30848297f, 0.17097358f, 
    -0.08635058f, -0.53656453f, -0.19476704f, 0.10699634f, -0.13276592f, -0.19540013f, 0.10422150f, 0.12445427f, 
    -0.07511484f, -0.11008663f, 0.30622211f, -0.14813626f, 0.06861899f, -0.13351905f, 0.00338345f, 0.08517731f, 
    0.22044958f, -0.29661503f, -0.13591310f, 0.17192829f, -0.31283638f, -0.23767251f, 0.48317027f, 0.38646382f, 
    -0.03083347f, 0.03341480f, -0.18961549f, -0.11800694f, 0.37721878f, -0.14589407f, -0.04326104f, 0.13463399f, 
    -0.09195129f, -0.05995189f, -0.44311208f, 0.24636106f, -0.05749865f, 0.52929956f, -0.20672843f, 0.31421271f, 
    0.26848346f, -0.14544623f, -0.48326740f, -0.03418883f, -0.07458998f, 0.10250218f, -0.03588133f, -0.15226306f, 
    0.22294126f, -0.25623316f, 0.05792631f, -0.10897927f, 0.18980579f, 0.25146651f, -0.07612084f, -0.00324007f, 
    0.19529229f, 0.19483870f, -0.00148661f, 0.02337831f, 0.19444576f, -0.09548067f, 0.18742937f, -0.08159379f, 
    0.13009961f, 0.26575506f, 0.11966970f, -0.03694351f, -0.05162047f, -0.04256439f, -0.59809512f, -0.13070014f, 
    0.38192600f, 0.16419923f, -0.37391785f, -0.15912552f, 0.06883690f, 0.00622454f, -0.16150813f, 0.09108779f, 
    -0.00610900f, 0.16951080f, 0.14871199f, -0.07079408f, 0.05510053f, -0.00378071f, -0.00864715f, -0.13179721f, 
    0.20661563f, 0.31204376f, -0.02621760f, -0.02615935f, -0.00928775f, -0.16529828f, 0.00800433f, 0.07460689f, 
    -0.05048431f, -0.58932203f, -0.22916348f, -0.32851243f, 0.04978007f, 0.09116615f, -0.08995383f, 0.18565269f, 
    -0.02176697f, 0.05136011f, -0.04225996f, 0.16655031f, 0.14054917f, -0.02738999f, -0.22934528f, -0.01872395f, 
    -0.26175916f, 0.30158213f, 0.13460007f, -0.01707706f, -0.08240539f, -0.15028848f, 0.00342721f, -0.00604832f, 
    0.19140261f, -0.37276387f, 0.07338756f, 0.08313718f, -0.13454291f, -0.04530655f, -0.06664639f, -0.07295862f, 
    -0.04858765f, -0.37412503f, 0.10697935f, -0.30505812f, 0.27568582f, 0.07787136f, 0.05940856f, 0.19691785f, 
    0.71794480f, -0.15836748f, -0.03461004f, 0.03783857f, -0.04734083f, -0.12346644f, -0.19390751f, -0.08445738f, 
    -0.14374429f, 0.14481233f, 0.07201821f, -0.14415845f, -0.23347722f, 0.10675159f, -0.13961354f, -0.17286947f, 
    -0.02706769f, 0.43890658f, -0.23780490f, -0.12285992f, 0.23149396f, 0.01283278f, 0.14484452f, 0.04508187f, 
    0.26202306f, 0.03938425f, -0.05282273f, 0.42124662f, 0.26113239f, -0.05913453f, 0.35226810f, 0.02460225f, 
    0.15652284f, 0.02780164f, 0.29774386f, -0.12689415f, -0.14933729f, 0.21696661f, -0.08142585f, 0.17196050f, 
    -0.02160857f, -0.08435447f, 0.30624402f, 0.15990362f, -0.37088868f, -0.02418244f, -0.36324632f, -0.36647817f, 
    0.23497093f, 0.59087551f, -0.20034996f, 0.15452482f, -0.04177706f, 0.13707601f, 0.09581076f, -0.16250613f, 
    0.08557389f, -0.31174922f, 0.05104740f, -0.15681821f, 0.46264219f, -0.27005869f, 0.00030390f, 0.14903022f, 
    -0.10568502f, 0.10731321f, 0.07928314f, -0.16856033f, -0.14035130f, -0.10465965f, -0.08095666f, 0.13482901f, 
    -0.01299540f, -0.13219452f, 0.05315334f, 0.13719131f, 0.11781740f, -0.17901567f, 0.10564532f, -0.00643088f, 
    -0.05616787f, -0.15635018f, -0.14301485f, 0.16289726f, 0.05155218f, -0.02525813f, -0.12960637f, -0.00314368f, 
    -0.11220326f, -0.18380001f, 0.00374833f, -0.20172277f, -0.12052737f, -0.00045613f, -0.07146944f, 0.05820794f, 
    -0.05192950f, 0.08762311f, 0.43407914f, 0.09770140f, -0.06311096f, 0.39203599f, -0.00111168f, -0.02446563f, 
    0.16876791f, 0.30921406f, 0.21520391f, 0.09756029f, 0.20251039f, 0.13956766f, -0.11796803f, -0.07995278f, 
    0.22268657f, -0.02254489f, -0.17209588f, 0.04101707f, -0.30669740f, 0.07735179f, 0.11432238f, 0.10437460f, 
    -0.31375337f, -0.13996904f, -0.30161753f, 0.11750273f, -0.12233193f, -0.26201147f, 0.47577417f, -0.01806190f, 
    -0.06606599f, 0.14505409f, 0.00689695f, 0.11210602f, 0.06357823f, -0.35437807f, 0.45790333f, -0.04462757f, 
    0.11171548f, 0.42116296f, 0.11110522f, -0.14108998f, 0.25775242f, -0.11533685f, 0.11120383f, 0.43949273f, 
    -0.15130560f, 0.10026699f, 0.19431724f, -0.11722197f, 0.09528349f, -0.08963353f, -0.34940091f, -0.12999281f, 
    0.03735311f, -0.00312153f, -0.03188109f, 0.14520536f, -0.09142490f, -0.12992440f, -0.08273300f, -0.18380173f, 
    -0.00504217f, 0.14467575f, -0.11812467f, 0.00444095f, 0.02875733f, -0.06155826f, -0.09131109f, -0.07375470f, 
    -0.22513993f, -0.21794567f, -0.19760497f, -0.00166270f, -0.54581720f, 0.25556454f, 0.09013182f, -0.37827867f, 
    -0.37828055f, 0.36682329f, -0.28408498f, 0.15376517f, -0.32464999f, 0.13340479f, 0.43720725f, 0.13309234f, 
    0.45176205f, 0.02227632f, 0.47181752f, 0.54777944f, 0.32137176f, 0.25025052f, 0.24700721f, 0.45304829f, 
    0.08783478f, 0.04837078f, 0.31329632f, -0.13884480f, -0.12368583f, -0.17790964f, -0.17922758f, -0.03052316f, 
    0.26066676f, 0.04973095f, 0.08961088f, -0.15909909f, 0.04440722f, -0.10849541f, 0.20313455f, 0.33736044f, 
    -0.03488710f, 0.43215111f, -0.32396144f, 0.04989802f, -0.09355492f, 0.12049926f, -0.03999131f, 0.17166324f, 
    -0.47923565f, -0.05084064f, -0.20226510f, -0.09759820f, 0.12128911f, 0.26194236f, -0.25148997f, 0.11133198f, 
    0.08159590f, 0.02294512f, -0.09604718f, 0.10498826f, -0.13653122f, -0.08837394f, 0.02928871f, -0.09097770f, 
    -0.03120148f, -0.09286766f, 0.01595473f, -0.09826005f, -0.13007371f, 0.04481598f, -0.02105721f, -0.14260440f, 
    -0.05633207f, -0.02726602f, -0.04475498f, 0.16794994f, -0.10685767f, 0.05704147f, -0.16691579f, 0.08852155f, 
    -0.00442008f, -0.13158648f, -0.20477417f, 0.01981973f, 0.05548044f, -0.02345593f, -0.14122202f, 0.00122180f, 
    0.19681446f, 0.03240475f, 0.35709655f, -0.02598701f, -0.15599325f, -0.07253779f, 0.14194246f, 0.18576851f, 
    -0.09646145f, 0.02727356f, 0.37952808f, -0.06356432f, 0.53497583f, 0.19260022f, -0.27047959f, -0.33221984f, 
    -0.24429613f, -0.17049153f, -0.20169747f, 0.12080339f, 0.17012741f, 0.04304726f, -0.26972780f, -0.10067233f, 
    -0.24039960f, 0.11735220f, 0.53999895f, -0.48496220f, 0.32577774f, 0.16871977f, 0.00832273f, 0.14231656f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.13437714f, -0.10603803f, 0.29534379f, 0.00664953f, -0.17341739f, -0.12832689f, 0.30893865f, -0.04533553f, 
    0.15120703f, 0.18094890f, 0.00128546f, 0.05296614f, 0.05010776f, 0.02823656f, -0.03970337f, 0.16138145f, 
    0.39326757f, -0.07589928f, 0.30462003f, 0.15761015f, -0.09841579f, -0.14182213f, -0.11933087f, 0.05599213f, 
    -0.18308520f, 0.14578819f, 0.14952709f, 0.19215001f, 0.24491027f, 0.21187009f, -0.11470396f, -0.04763182f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.21536310f, 0.37628320f, -0.46256438f, 0.07546166f, 0.43947420f, -0.08067539f, -0.03619957f, 0.09197207f, 
    0.00109058f, 0.11289475f, -0.36396515f, -0.48717707f, -0.17184855f, -0.32319903f, 0.35626644f, 0.13481441f, 
    -0.17120752f, -0.22764164f, 0.00407424f, -0.69397926f, -0.08658701f, -0.00498550f, -0.30520865f, 0.08471718f, 
    0.09543762f, 0.03058307f, 0.06597569f, -0.07826328f, -0.06628143f, -0.40052855f, -0.06621997f, 0.24014798f, 
    0.23309509f, -0.14245172f, -0.62203276f, 0.34574062f, -0.19646503f, -0.09676275f, -0.33948016f, 0.10102782f, 
    0.07527036f, 0.36384213f, -1.23889697f, -0.08944236f, 0.29534352f, -0.23309985f, 0.50931960f, -0.12098552f, 
    0.37043065f, -0.46685049f, -0.56872040f, -0.03042554f, -0.00609875f, 0.04107062f, -0.21876581f, 0.32357547f, 
    -0.08967236f, -0.02414206f, -0.12019815f, -0.04838534f, 0.14053899f, -0.46328819f, -0.09572139f, -0.20931485f, 
    -0.26792282f, -0.93557328f, 0.28688484f, -0.17697807f, 0.04243586f, -0.13396221f, 0.55041909f, -0.26258403f, 
    -0.23704253f, 0.33424401f, -0.05227054f, -0.09673686f, -0.07353055f, 0.21013093f, -0.62796283f, -0.16724239f, 
    0.18790397f, 0.14308394f, 0.37566060f, 0.22000158f, 0.07797099f, 0.24322395f, 0.03933423f, 0.08542415f, 
    -0.84838057f, -0.01883204f, 0.15119283f, 0.10837235f, 0.24705943f, -0.18160383f, 0.13909183f, -0.91241050f, 
    -0.32546613f, 0.29517633f, 0.23918405f, -0.45479763f, 0.41750005f, 0.01113489f, 0.15411721f, -0.21168742f, 
    0.28540227f, 0.28581601f, -0.08735105f, -0.43209377f, -0.07860304f, 0.25511274f, -0.64547879f, 0.02449562f, 
    -0.84717292f, 0.29006028f, 0.31640545f, -0.26870102f, -0.26701024f, -0.28749302f, 0.20119438f, -0.08671413f, 
    0.12039037f, -0.11368237f, -0.20747882f, 0.13019185f, 0.21838966f, -0.13087991f, 0.00132776f, 0.04186919f, 
    -0.12343322f, 0.12253509f, -0.00468583f, 0.45232341f, -0.64455080f, 0.15480880f, -0.01751011f, 0.17640740f, 
    -0.02246275f, 0.06457584f, 0.40653929f, -0.10887849f, -0.57650441f, -0.36978030f, 0.08377368f, -0.05356395f, 
    -0.33892375f, -0.01397910f, 0.13377064f, -0.11430001f, 0.25456092f, -0.18625501f, 0.36748648f, 0.10246893f, 
    0.24773143f, 0.08015218f, 0.27830389f, -0.09993640f, -0.36574200f, 0.25818983f, 0.10678340f, 0.02536176f, 
    0.16783786f, -0.60827923f, -0.61625051f, -0.13922884f, -0.32470500f, 0.00971901f, -0.10120129f, -0.18375032f, 
    0.17035171f, -0.17255473f, 0.00868726f, -0.12050043f, -0.00434290f, 0.11114883f, 0.04334176f, -0.02406840f, 
    -0.12571186f, 0.34823555f, -0.27696756f, 0.19577211f, 0.18184365f, 0.14342377f, -0.45598435f, 0.17720945f, 
    0.27121103f, -0.09555806f, -0.22324575f, -0.21542588f, 0.22541445f, 0.57360101f, -0.17841025f, -0.03256616f, 
    -0.19108674f, -1.10639465f, 0.46855846f, -0.79069638f, 0.17164429f, 0.00139502f, -0.82963419f, -0.74832380f, 
    -0.03538813f, -0.52810538f, 0.28337765f, 0.25218359f, -0.39525220f, 0.24459527f, -0.04106884f, 0.07784022f, 
    0.37614009f, -0.17224155f, 0.09825354f, 0.36661458f, -0.15931934f, -0.36450556f, -0.39471370f, -1.03146863f, 
    -0.45881400f, -0.10278643f, -0.46765560f, 0.42122871f, -0.67954975f, 0.27143636f, 0.18071581f, -0.60337675f, 
    0.12745157f, 0.05628517f, -0.34705785f, 0.19047931f, -0.07159685f, 0.09326559f, -0.27084771f, 0.08984878f, 
    0.22659169f, -0.38997936f, -0.61531252f, 0.24446851f, -0.18648538f, -0.29863709f, -0.00533289f, -0.10331282f, 
    -0.22956201f, 0.90052718f, -0.42006034f, -0.32606459f, -0.16380198f, -0.36546239f, 0.13289078f, -0.66279715f, 
    -0.47357473f, 0.09625018f, -0.27471054f, 0.27643818f, -0.28173566f, -0.53226471f, 0.01998045f, 0.69923860f, 
    -0.63646275f, 0.05615539f, -1.18686354f, -0.72590256f, -0.72752047f, 0.02037102f, -0.67674297f, 0.38012284f, 
    0.23276554f, -0.45765662f, -0.92567950f, 0.09503671f, 0.22496496f, 0.32479048f, -0.40817299f, 0.14551328f, 
    -0.10844794f, -0.00955850f, -0.56041330f, 0.33721140f, -0.15267906f, -0.06090609f, -0.00306511f, -0.14079848f, 
    -0.58956063f, -0.13012287f, -0.20197655f, -0.24535999f, 0.54791349f, 0.41402280f, -0.04504612f, 0.15394486f, 
    -0.08764935f, 0.23908201f, 0.03399757f, 0.14480051f, -0.65997100f, 0.03526232f, 0.16485769f, -0.46352929f, 
    0.05248518f, 0.17925783f, 0.26936400f, 0.12403419f, -0.35262442f, 0.04741956f, 0.31689098f, 0.14437000f, 
    -0.10869703f, 0.04643271f, 0.45839173f, -0.00987110f, -0.48990452f, -0.43220171f, -0.14041726f, -0.35318589f, 
    -0.58691251f, 0.18301563f, 0.52016544f, 0.25472406f, -0.68769783f, 0.34520829f, -0.04621673f, 0.14642489f, 
    0.12208293f, -0.26262262f, -0.02953215f, 0.31267440f, -0.23104605f, 0.05493107f, -0.95907760f, 0.30737209f, 
    -0.38580936f, -0.69973350f, -0.12672266f, 0.07738152f, 0.02593031f, 0.19859959f, -0.51518810f, -0.18404810f, 
    0.13473871f, -0.56801182f, 0.54647112f, 0.09401989f, -0.64687157f, -0.29525703f, 0.04109195f, -0.05763863f, 
    0.31394586f, -0.01821647f, 0.34541205f, -0.53249872f, 0.22063464f, -0.42821991f, 0.08380948f, -0.21755171f, 
    -0.15695198f, 0.16108513f, 0.28607270f, -0.40676260f, -0.34607655f, 0.05806500f, -0.00829332f, 0.05786205f, 
    -0.18233779f, -0.42784494f, 0.20312467f, -0.12627323f, 0.62952733f, 0.33490577f, 0.36522251f, -0.01427486f, 
    0.16652001f, -0.42673165f, -0.54008013f, 0.24202186f, -0.08808639f, 0.34434560f, 0.43442687f, -0.42552277f, 
    -0.25649825f, -0.07590278f, -0.51036048f, -0.10594273f, -0.53894365f, -0.29958969f, -0.00991115f, 0.19692948f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.33588102f, 0.36002246f, 0.00676777f, 0.06101337f, -0.36802202f, -0.04404765f, 0.09507804f, -0.12926814f, 
    0.22327848f, 0.05550465f, -0.14482951f, -0.16411749f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
