#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.49276257f, 0.81598955f, -0.22488622f, -0.34211498f, -0.22171737f, 0.29800567f, -0.46406347f, 0.32569450f, 
    0.32217216f, 0.33282563f, -0.85735804f, 0.69684815f, -0.53008175f, -0.44021496f, 0.77622420f, 0.06954700f, 
    -0.07191416f, 0.09636524f, 0.17889747f, 0.63719714f, -0.78234446f, -0.50050503f, -0.16364974f, 0.07742366f, 
    0.46192157f, 0.29083866f, 0.38253945f, 0.88039047f, -0.40707698f, -0.33651081f, 0.37035426f, 0.57225943f, 
    -0.59700370f, -0.24248435f, 0.16886514f, -0.25189328f, 0.23740703f, 0.45337117f, 0.35637787f, 0.34211159f, 
    0.44724986f, 0.00011112f, 0.45734665f, 0.21213745f, -0.17725267f, -0.62181711f, 0.65855986f, 0.30507427f, 
    0.22092326f, 0.12180486f, -0.02774748f, -0.50745875f, -0.01994809f, 0.15779980f, -0.76046509f, -0.54257298f, 
    -0.37185884f, 0.13141042f, -0.42631075f, -0.21027921f, -0.14719248f, -0.33377549f, -0.18252289f, -0.31430051f, 
    -0.17428075f, -0.45898187f, -0.06276741f, -0.09340167f, 0.44877663f, 0.56939131f, -0.44179463f, 0.09658175f, 
    -0.69095886f, -0.35906053f, -0.82144433f, 0.64218354f, 0.14436343f, -0.12612681f, 0.31143239f, 0.24595761f, 
    0.55199981f, -0.20756502f, -0.06401683f, -0.69556010f, -0.43225664f, 0.76599365f, -0.17542277f, 0.11881760f, 
    -0.03300909f, -0.05204038f, 0.75870061f, 0.43236122f, -0.51847070f, -0.15354784f, -0.54629713f, -0.33792862f, 
    -0.34746751f, -0.21434201f, -0.20216359f, -0.25454539f, -0.54042888f, -0.27646461f, -0.60234612f, -0.89956236f, 
    -0.29726976f, 0.10671333f, 0.50260526f, 0.17242023f, 0.42324549f, -0.62082946f, -0.98951042f, 0.33839694f, 
    0.80521220f, 0.36390701f, -0.36575496f, -0.29523322f, -0.34978867f, -0.30900517f, 0.42376921f, 0.14571564f, 
    -0.49382591f, 0.44667390f, 0.55063164f, 0.15479451f, 0.03583881f, 0.35028782f, -0.82637370f, 0.46001598f, 
    0.68792337f, 0.21605475f, -0.63605332f, -0.71313256f, 0.33459842f, 0.06374958f, 0.15757944f, 0.29503947f, 
    0.09953484f, 0.28218824f, 0.20878281f, 0.62738889f, 0.48643187f, -0.49949834f, 0.26676109f, -0.49505693f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.02036394f, 0.05979787f, -0.14964402f, 0.24184076f, -0.27290526f, 0.22083411f, -0.22303140f, 0.30324313f, 
    0.15294358f, -0.11846802f, 0.07621209f, -0.10350320f, -0.08068641f, 0.29680490f, -0.05133756f, -0.21950914f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.08527349f, 0.19870810f, 0.02537455f, -0.13903683f, 0.01002108f, 0.06093540f, 0.01641934f, -0.02213403f, 
    0.14405090f, 0.04255117f, -0.03484021f, -0.00341322f, 0.00590839f, -0.05367968f, -0.00481846f, -0.13183251f, 
    -0.02789641f, 0.00570582f, 0.02888202f, 0.05250669f, -0.21282774f, 0.00929140f, 0.00497853f, 0.00487446f, 
    -0.00601546f, -0.09697311f, 0.03005488f, 0.03958563f, 0.18470542f, -0.21341884f, -0.04693098f, -0.13535838f, 
    0.21107402f, -0.05044989f, -0.09081599f, 0.00054155f, 0.12641583f, -0.09645571f, 0.07209198f, 0.05157615f, 
    0.04490044f, 0.13294855f, 0.16628687f, -0.08249276f, 0.13914432f, 0.01980462f, -0.03101821f, -0.01398799f, 
    -0.01161821f, -0.16447771f, 0.01758646f, -0.06390905f, 0.10971270f, -0.01895279f, 0.09331922f, -0.07223092f, 
    -0.07266218f, -0.11520380f, -0.03903421f, -0.15995724f, -0.19691043f, -0.09133092f, 0.11747968f, -0.10217321f, 
    0.03762649f, 0.16872145f, 0.00890621f, 0.00721543f, 0.13266635f, 0.10866290f, -0.01207772f, 0.06765226f, 
    -0.02035765f, -0.01352069f, 0.07937578f, -0.00543650f, 0.02489015f, 0.06625470f, 0.12038759f, 0.05538345f, 
    0.03021360f, -0.11027510f, 0.06947846f, -0.08510353f, 0.05286181f, -0.05157384f, 0.05828035f, 0.09344849f, 
    0.03143114f, 0.05217684f, -0.02799883f, -0.06569369f, -0.06521813f, 0.03623023f, -0.09687984f, 0.11758641f, 
    0.03843627f, -0.00350261f, -0.04274324f, 0.07226095f, 0.06705358f, -0.15202026f, 0.10558528f, -0.13869105f, 
    0.13375597f, 0.04814310f, -0.00123948f, 0.06518641f, 0.01899521f, 0.05258910f, 0.13292699f, -0.06173595f, 
    -0.05343508f, -0.03994250f, -0.06457569f, -0.07502259f, 0.04864214f, 0.17516077f, 0.07241135f, 0.04829974f, 
    -0.27261877f, -0.22444905f, -0.12488523f, 0.20419823f, -0.21280469f, -0.14655125f, -0.11172759f, -0.01300458f, 
    -0.14919494f, 0.13352919f, 0.01350304f, 0.07859077f, 0.13274729f, 0.13252135f, -0.07056545f, 0.08687687f, 
    0.10164893f, 0.03440880f, 0.14728971f, 0.01116334f, 0.12081129f, 0.11041324f, 0.38212848f, 0.25983554f, 
    -0.17595190f, -0.06205036f, -0.04744016f, -0.12977567f, 0.02799489f, 0.08679778f, 0.11393430f, -0.02047175f, 
    0.13794862f, 0.07407925f, 0.05392150f, 0.04685516f, 0.01047064f, 0.04444108f, 0.06069153f, 0.03969684f, 
    0.00794307f, 0.06561916f, 0.29715073f, 0.14624444f, -0.09523471f, -0.03984537f, -0.19218045f, -0.32451758f, 
    -0.16572912f, -0.02230354f, 0.01063526f, -0.01208038f, 0.09044374f, 0.01839806f, 0.10259680f, 0.07048327f, 
    -0.17270619f, -0.06497730f, -0.09432619f, -0.10201943f, -0.24976851f, -0.16244793f, 0.11368449f, 0.19200975f, 
    -0.02629212f, -0.06898400f, -0.07818116f, -0.25167921f, -0.09535989f, -0.00838228f, 0.12874013f, -0.01879894f, 
    0.11174946f, 0.01348370f, -0.04685174f, 0.06119497f, -0.07295129f, 0.03403343f, 0.02746972f, -0.01405270f, 
    0.08058418f, -0.09684112f, -0.15617797f, 0.02089257f, 0.01659148f, 0.18201704f, 0.06901517f, 0.30761859f, 
    0.22616836f, 0.14146994f, -0.01046825f, 0.03929559f, 0.04694398f, -0.04003216f, 0.00250423f, 0.12925793f, 
    0.11244424f, 0.09403422f, 0.14630878f, 0.17091875f, -0.26279327f, -0.21095568f, 0.21695168f, -0.02456003f, 
    -0.20788974f, -0.00941085f, -0.14297839f, -0.02051201f, 0.10856458f, -0.00063634f, -0.06836853f, 0.10214822f, 
    0.06978464f, -0.04378171f, 0.04044389f, 0.07337946f, 0.00337733f, -0.04052906f, 0.08358079f, -0.08381125f, 
    -0.40403858f, -0.02694084f, 0.10193611f, 0.16736746f, -0.16356082f, -0.03315960f, -0.11316843f, -0.21977605f, 
    0.11911619f, 0.06856944f, -0.01162396f, 0.15427598f, 0.13287359f, 0.03460657f, 0.00779455f, -0.00183832f, 
    0.15578151f, 0.13083802f, 0.14655513f, 0.19153911f, -0.02071502f, 0.09862700f, 0.12298267f, -0.02485559f, 
    0.11097188f, -0.03323870f, 0.01716329f, -0.02758612f, 0.06163786f, -0.10775108f, 0.04824970f, 0.05157668f, 
    0.04910439f, 0.02287936f, 0.14496541f, 0.04626112f, -0.00077998f, -0.05629980f, -0.04405844f, -0.00760572f, 
    -0.03981735f, -0.19082437f, -0.28231239f, 0.29605356f, -0.22209091f, -0.06497267f, 0.06686287f, 0.04152333f, 
    -0.20837077f, 0.13849995f, 0.01061268f, 0.01677524f, 0.06353837f, 0.03443971f, -0.07558500f, 0.11626936f, 
    -0.10765709f, -0.06332240f, -0.04234173f, -0.06733749f, -0.07857587f, -0.02245851f, -0.06959449f, -0.08321582f, 
    0.16639493f, 0.04489334f, -0.06421287f, -0.01808303f, -0.03332758f, -0.03656920f, 0.00437387f, -0.08364545f, 
    -0.15116058f, -0.02628338f, -0.18584901f, 0.04577281f, 0.01991922f, 0.17045663f, 0.05021552f, 0.12710126f, 
    0.02178731f, 0.06317075f, -0.00301420f, -0.09827349f, 0.08245426f, -0.06335419f, -0.06248952f, 0.05920951f, 
    -0.01352190f, -0.06435954f, 0.12206906f, -0.00449502f, 0.02413248f, -0.00156605f, -0.03212238f, -0.07927219f, 
    -0.20063910f, -0.00227894f, -0.09214034f, -0.09897274f, 0.39768705f, 0.31735101f, -0.32263607f, 0.21764810f, 
    -0.03553807f, -0.03387652f, -0.02300270f, 0.03886496f, -0.27314630f, -0.01025524f, 0.08195107f, 0.10701131f, 
    0.07275250f, 0.04349523f, -0.08479489f, -0.05218485f, 0.03714428f, 0.04081050f, -0.14483291f, 0.00083878f, 
    -0.04094508f, 0.10392182f, -0.17599289f, -0.12872519f, 0.03160812f, 0.06648722f, -0.05001577f, -0.09499107f, 
    0.02439451f, -0.08133068f, 0.02418926f, 0.02402720f, 0.00275610f, -0.04378643f, -0.12429818f, 0.04565019f, 
    -0.18759423f, -0.21080546f, -0.02872292f, -0.21525723f, 0.22529323f, 0.07873048f, 0.18177429f, -0.16791044f, 
    -0.04399576f, 0.05983730f, 0.00419858f, -0.02028653f, -0.05581984f, -0.03865355f, 0.18782006f, 0.11407528f, 
    0.14373377f, -0.04939324f, 0.10389476f, 0.12528087f, 0.13806529f, 0.04725304f, 0.24452706f, 0.16950695f, 
    0.09386822f, 0.02050391f, 0.01197353f, -0.02350335f, 0.09884289f, -0.06870263f, -0.09698116f, 0.00581279f, 
    0.07150089f, 0.02167221f, 0.15520577f, -0.00752629f, -0.02411643f, -0.03054277f, -0.05342211f, -0.05962215f, 
    -0.08859660f, -0.07566489f, 0.00788029f, -0.14974402f, -0.10617112f, 0.22893772f, 0.08194482f, 0.02330596f, 
    0.12896428f, -0.01694839f, -0.06679260f, -0.00453216f, -0.01302392f, 0.03073859f, 0.00358586f, 0.04672839f, 
    0.24578352f, -0.06240204f, -0.08843519f, 0.11418773f, 0.02288510f, 0.02354968f, -0.00810395f, 0.09096397f, 
    -0.17357425f, -0.20017669f, 0.34761095f, 0.16053087f, -0.32656193f, -0.09091143f, -0.01903948f, -0.10599016f, 
    0.00607505f, 0.09636333f, -0.02216802f, -0.12898988f, -0.09870367f, -0.02234527f, -0.10739060f, -0.09999310f, 
    -0.01659238f, 0.16762400f, 0.00393495f, 0.04626800f, -0.13184339f, 0.23341660f, 0.19566223f, 0.08863778f, 
    -0.05059396f, 0.06631234f, -0.01687978f, -0.03373228f, 0.05872006f, 0.14038350f, 0.00685457f, 0.11195906f, 
    0.13115968f, -0.02843197f, 0.02277084f, -0.02509372f, 0.03782320f, 0.00495288f, 0.03749033f, 0.01830029f, 
    0.05341155f, 0.11035891f, 0.43803838f, 0.17095789f, -0.04786993f, -0.03188081f, -0.14137059f, -0.19084756f, 
    0.09081424f, -0.21679653f, 0.04510074f, 0.07851559f, 0.09209980f, 0.02776239f, 0.00817152f, -0.09905616f, 
    -0.15170938f, -0.09458749f, -0.14312948f, -0.16717476f, -0.11365724f, -0.07357171f, 0.17993982f, -0.39149752f, 
    -0.17982687f, 0.06758000f, -0.10729695f, -0.07417330f, 0.05437876f, 0.00516301f, -0.07510003f, -0.00395450f, 
    0.06845751f, -0.02513817f, -0.06179680f, -0.00102609f, -0.12297206f, -0.04692893f, 0.08275461f, -0.15508804f, 
    0.11601233f, 0.19931805f, 0.11441620f, -0.13565007f, -0.09301818f, -0.09106926f, 0.03304064f, -0.00459108f, 
    0.01699085f, 0.00288811f, 0.14159246f, -0.01418282f, -0.08827089f, -0.01958807f, 0.02290306f, 0.13592871f, 
    0.07533211f, 0.02935704f, 0.08248863f, 0.05249689f, -0.36996254f, -0.25539875f, -0.13722864f, 0.01879584f, 
    -0.39920244f, 0.07589437f, 0.09211724f, 0.02480651f, -0.13635282f, -0.03454417f, -0.04688440f, -0.00400199f, 
    -0.01006337f, -0.05028183f, -0.17747226f, -0.11827612f, -0.04485520f, 0.09932086f, -0.06702231f, -0.09287424f, 
    -0.08358197f, -0.16480383f, 0.44212708f, -0.07274324f, 0.05831650f, -0.05409170f, -0.19053656f, 0.00341228f, 
    0.03087333f, -0.06029252f, 0.00700913f, -0.01043706f, 0.09544472f, -0.09916129f, -0.01766698f, 0.13654347f, 
    0.11372349f, -0.01711362f, 0.13335185f, 0.12566455f, 0.06098384f, 0.14460963f, 0.00315064f, 0.08186972f, 
    0.15219294f, 0.01537254f, -0.08576555f, -0.02391439f, -0.03304425f, 0.08200791f, -0.04561282f, 0.09610818f, 
    0.02354086f, -0.05606383f, -0.02852490f, -0.05774683f, -0.10311712f, -0.04504769f, 0.04649070f, -0.09163276f, 
    -0.06084557f, -0.38610587f, -0.04192220f, 0.06321301f, -0.09440979f, 0.08356895f, 0.05782369f, -0.14494009f, 
    0.11178444f, 0.00584357f, 0.04978817f, -0.12518221f, 0.15109125f, -0.18011649f, -0.10841627f, -0.11995455f, 
    -0.15855776f, 0.03072315f, 0.09901308f, -0.10711107f, 0.12698542f, 0.06221446f, 0.01586528f, 0.07682198f, 
    0.16163599f, -0.04482867f, -0.08213028f, -0.03300484f, -0.03311663f, 0.01029674f, 0.04432341f, 0.05090180f, 
    0.00227887f, 0.03149571f, -0.12964997f, 0.03165627f, -0.16626811f, 0.02286342f, 0.12726972f, 0.04487319f, 
    -0.01888722f, -0.01382710f, -0.00887525f, -0.12739013f, 0.04432794f, 0.04420342f, 0.14881136f, -0.05460387f, 
    -0.13200337f, 0.05403237f, -0.13665664f, -0.04392008f, 0.07293638f, -0.16596580f, -0.07547252f, -0.00349970f, 
    -0.02252757f, 0.09445541f, 0.01069902f, -0.02523190f, -0.37980887f, -0.06346640f, -0.00922012f, -0.05668053f, 
    -0.03907065f, -0.00463325f, -0.04102210f, 0.02295201f, 0.13886425f, 0.02161413f, 0.00447605f, 0.00114085f, 
    -0.00940810f, -0.02329103f, 0.06450374f, -0.02320298f, 0.00451036f, 0.14524528f, 0.09843930f, 0.13763301f, 
    -0.11915104f, -0.15658717f, 0.12570457f, 0.04560343f, -0.07917995f, 0.05451694f, 0.03069934f, 0.06360083f, 
    -0.07006638f, 0.03245241f, -0.03891729f, -0.12095125f, 0.10826292f, 0.14839211f, -0.05104782f, -0.08051930f, 
    -0.03163758f, 0.00725906f, -0.09687009f, 0.02078307f, 0.25104314f, 0.23689446f, 0.08067907f, -0.05970256f, 
    0.03223543f, 0.09360603f, 0.07814243f, -0.21326081f, 0.03693727f, 0.00542360f, 0.00432162f, 0.05051916f, 
    0.03146229f, -0.02922505f, 0.06287764f, 0.08515216f, 0.09951123f, -0.00727067f, 0.14352643f, 0.04113492f, 
    0.04150863f, -0.14615992f, 0.01071864f, -0.08626439f, 0.01862844f, -0.00409382f, -0.07507779f, -0.11109087f, 
    -0.12943704f, -0.04229674f, 0.18906856f, 0.08560768f, -0.02838390f, 0.01181211f, 0.25509736f, 0.06279168f, 
    0.01638235f, -0.05697001f, 0.05687707f, -0.02937562f, 0.22485937f, -0.27852356f, 0.14133424f, -0.03244530f, 
    0.06745233f, 0.06920756f, -0.07641713f, -0.02295719f, -0.05859318f, 0.05116926f, 0.09677449f, -0.20408870f, 
    0.04174998f, 0.01724861f, -0.05562372f, 0.07665157f, -0.02242603f, 0.03214630f, -0.01386568f, -0.08116841f, 
    -0.42189872f, -0.02594208f, -0.11643233f, 0.44386458f, -0.00077362f, -0.11254338f, -0.08201447f, -0.03960431f, 
    -0.00113043f, 0.01888787f, -0.07714011f, 0.10583074f, -0.05001548f, -0.02023522f, -0.03373564f, 0.09966380f, 
    0.15819727f, -0.03744404f, 0.03230783f, 0.00185370f, -0.13398750f, 0.11267872f, 0.06164599f, 0.30543062f, 
    0.18932346f, -0.15185378f, 0.00990667f, 0.04825752f, 0.02991762f, 0.17481804f, 0.12949540f, 0.02111877f, 
    -0.11206237f, 0.11102702f, -0.02574500f, 0.13108292f, 0.02279519f, 0.03476351f, -0.07377832f, 0.09653372f, 
    0.09548016f, -0.04532417f, 0.25875962f, 0.10956218f, -0.09078674f, -0.10626106f, -0.00847750f, -0.08735824f, 
    0.11621949f, 0.18227106f, 0.14822847f, 0.06130885f, -0.01352260f, 0.04986390f, -0.07280507f, 0.02643092f, 
    0.05126566f, -0.08271897f, 0.00746534f, -0.01996574f, -0.20105033f, -0.30626145f, 0.30552042f, 0.36643088f, 
    0.17764609f, -0.19035728f, -0.01579027f, -0.14961609f, -0.00069759f, 0.13143173f, 0.04124496f, -0.06832203f, 
    -0.06110262f, -0.10466133f, -0.09180369f, 0.02878164f, 0.02445256f, 0.02119527f, -0.01086455f, -0.00589051f, 
    0.15478785f, 0.01090926f, -0.25449866f, 0.07481987f, 0.02806305f, 0.17012244f, 0.15751655f, -0.00881360f, 
    -0.05090300f, 0.05311535f, 0.01761667f, 0.07841954f, 0.01735547f, 0.00561532f, -0.08705000f, 0.07511007f, 
    0.02452700f, -0.16103122f, -0.15318096f, 0.06549237f, -0.33665353f, -0.07738081f, 0.12313174f, 0.27302080f, 
    0.06922875f, -0.14230858f, -0.05312141f, -0.07516447f, 0.13567117f, 0.06499819f, -0.07590971f, 0.17354125f, 
    -0.03332585f, 0.00990611f, -0.06623150f, 0.01172786f, 0.09003871f, -0.09474207f, -0.10803302f, 0.02674913f, 
    -0.05556562f, 0.28460953f, 0.41690040f, 0.16164909f, -0.02584379f, -0.05012267f, -0.03917576f, -0.16826384f, 
    -0.01724603f, 0.02721161f, 0.07016762f, -0.06212139f, -0.09719978f, -0.06820078f, -0.06600244f, 0.01246868f, 
    -0.02276111f, -0.16176626f, -0.14836155f, -0.09896140f, 0.06933356f, -0.23902702f, -0.00512891f, -0.01306450f, 
    0.00877087f, -0.09564611f, -0.06461692f, 0.02720211f, 0.04675268f, -0.03497274f, 0.14967920f, 0.01359015f, 
    -0.01829575f, 0.14030300f, 0.17725347f, 0.04305137f, 0.05500723f, 0.09187083f, 0.04024989f, -0.00902576f, 
    -0.04423860f, -0.18503508f, -0.21969829f, 0.17347690f, -0.10000671f, 0.11291160f, -0.14016390f, 0.02745583f, 
    -0.03077440f, 0.22361815f, -0.12282626f, 0.07732101f, 0.03808831f, 0.18968801f, 0.12993801f, 0.01242106f, 
    -0.04205268f, -0.14530918f, -0.05520360f, -0.04799319f, 0.21233447f, -0.06648564f, 0.17234853f, -0.14209482f, 
    0.02200246f, -0.15134206f, -0.21992686f, -0.16830370f, -0.17634688f, -0.06355509f, -0.01393219f, -0.00484866f, 
    -0.09158111f, -0.10284095f, 0.06679146f, 0.05913383f, -0.05877947f, -0.07092701f, -0.03865378f, -0.11913836f, 
    0.32623088f, 0.30489343f, -0.27731815f, 0.21365324f, -0.02096049f, -0.01140161f, -0.04006549f, 0.00897325f, 
    -0.02103964f, -0.03141709f, 0.05305859f, 0.03267389f, 0.04953826f, -0.00508331f, -0.04913792f, 0.05402455f, 
    -0.08023516f, 0.06917267f, -0.12467210f, 0.08818767f, 0.33714032f, -0.13624336f, -0.04662397f, 0.19229721f, 
    -0.03811661f, 0.21213320f, -0.11906846f, 0.07972420f, 0.10371206f, 0.05265268f, -0.19934820f, 0.08957687f, 
    0.10450939f, -0.09701045f, 0.23050676f, -0.01896678f, -0.04172949f, -0.08680110f, -0.00608292f, 0.21904834f, 
    0.06672110f, 0.14085852f, -0.05563682f, -0.06057528f, -0.08439293f, 0.09752119f, -0.06662431f, 0.15370812f, 
    0.03224564f, 0.07474086f, 0.00759430f, -0.02045277f, 0.09453417f, -0.00783250f, -0.03624484f, -0.06675525f, 
    -0.02807051f, -0.12283664f, -0.03247150f, 0.00033088f, 0.18288127f, -0.11547118f, 0.33583915f, -0.01134901f, 
    0.29916272f, -0.03106077f, 0.08828609f, 0.11967435f, 0.02688801f, 0.00816614f, 0.24565373f, -0.05826273f, 
    0.06198265f, 0.06839967f, 0.02413752f, -0.03321597f, 0.07597486f, 0.09818387f, -0.11594588f, -0.06888375f, 
    0.20008209f, 0.31601155f, 0.00731265f, 0.08846337f, 0.10736190f, 0.08764007f, 0.06801745f, -0.05659687f, 
    -0.06159603f, -0.00869668f, 0.10915443f, -0.09572423f, 0.04226627f, 0.00219782f, -0.03027056f, 0.04293128f, 
    -0.04215507f, 0.01537526f, -0.00390287f, -0.07500882f, -0.15514985f, 0.19768740f, -0.04768799f, 0.22227773f, 
    0.00508272f, -0.02511239f, -0.01269836f, 0.02669424f, -0.04344202f, 0.04753947f, -0.00250008f, 0.02033439f, 
    -0.05575522f, 0.10520997f, -0.10454310f, 0.00698337f, -0.01500307f, 0.03215347f, -0.02799336f, 0.05291790f, 
    0.27577513f, -0.05267513f, 0.15470015f, -0.22708982f, -0.30922857f, 0.10671118f, 0.12074538f, -0.03420775f, 
    0.00823107f, 0.20917358f, 0.14152423f, 0.05575295f, 0.09445289f, 0.04615193f, 0.02741017f, 0.10947734f, 
    0.05132432f, -0.11025909f, 0.29000631f, 0.03362315f, 0.18494764f, -0.12755427f, 0.03959412f, -0.18003339f, 
    -0.40278137f, 0.01842492f, -0.03204685f, 0.04436148f, 0.04307178f, 0.08483241f, 0.06283574f, 0.10701974f, 
    0.06286773f, 0.01842481f, 0.06470288f, -0.01886503f, -0.00433095f, -0.04244861f, 0.08769175f, -0.06547253f, 
    0.10960484f, -0.11386763f, -0.04563667f, -0.33398893f, -0.18979122f, -0.14819802f, 0.08589794f, -0.17238277f, 
    -0.05242106f, 0.13456108f, 0.09142284f, 0.02856610f, -0.08786571f, -0.03864381f, 0.02674145f, 0.03599989f, 
    0.04176780f, -0.06159405f, -0.16695900f, 0.01189853f, -0.10333573f, -0.06978558f, -0.18294236f, 0.17193598f, 
    -0.29450423f, 0.06071306f, 0.03312406f, -0.06663391f, -0.00265088f, 0.07841690f, 0.03154145f, 0.09261639f, 
    -0.11254154f, 0.10096887f, -0.00978280f, 0.06199545f, -0.03248491f, 0.16764881f, -0.05974787f, 0.05242617f, 
    0.60875344f, 0.23507537f, -0.23762640f, -0.15018652f, 0.01808122f, 0.02041753f, 0.06640355f, 0.16287047f, 
    0.05956901f, 0.02014663f, 0.10118860f, -0.03876305f, 0.02058663f, 0.03791688f, -0.03462333f, -0.02099446f, 
    0.09952497f, 0.03516543f, 0.02555970f, -0.00968477f, 0.19040886f, 0.13033281f, 0.60377556f, 0.05552393f, 
    -0.07379286f, 0.12533720f, -0.00511273f, 0.06972361f, 0.04344699f, 0.08890474f, 0.08084456f, 0.01304336f, 
    0.01212332f, 0.03368911f, -0.02025294f, 0.00001206f, -0.03970078f, -0.05448958f, 0.33035931f, -0.05048431f, 
    -0.10427511f, -0.42475271f, -0.55871528f, -0.07666803f, -0.13641503f, -0.08976247f, 0.02707203f, 0.08455472f, 
    0.04753783f, -0.03625367f, -0.04207885f, 0.14001516f, -0.13474071f, 0.06382288f, -0.05046150f, 0.04224015f, 
    -0.10180268f, 0.20055434f, 0.04376379f, 0.29794225f, 0.00027994f, 0.15547623f, -0.11321487f, 0.08681395f, 
    -0.05810761f, 0.09524243f, -0.02770610f, -0.07280798f, -0.06524383f, -0.12450235f, -0.04586995f, 0.03099420f, 
    0.09087465f, 0.04896083f, 0.00125589f, 0.12316573f, 0.02970813f, 0.02498598f, -0.05599469f, -0.01387709f, 
    -0.22853020f, -0.01053707f, -0.00507793f, 0.12295694f, -0.25180176f, -0.23130533f, 0.15507837f, 0.18470812f, 
    0.02082271f, 0.08808827f, -0.02551055f, 0.05557630f, -0.10663213f, -0.09550140f, 0.02464295f, 0.08888375f, 
    -0.02875773f, -0.07772825f, 0.04531375f, 0.02557570f, 0.24042246f, 0.37469241f, 0.20736860f, 0.20312104f, 
    0.12835172f, -0.01983543f, -0.01861820f, -0.01977901f, 0.00490447f, -0.04382909f, 0.10076255f, -0.03117784f, 
    0.03183975f, 0.05954703f, -0.07215758f, 0.02591000f, 0.01657051f, 0.03090462f, -0.13199961f, -0.03996639f, 
    0.02863804f, 0.03881332f, -0.05289059f, -0.00787551f, -0.04015585f, 0.00367872f, -0.00477403f, 0.02577412f, 
    0.00258544f, 0.02077370f, 0.02438083f, 0.04362931f, -0.02201358f, 0.01573058f, -0.00063835f, -0.01304260f, 
    -0.03310217f, -0.04760052f, 0.02119119f, -0.01612907f, -0.04507880f, 0.04400017f, -0.05824012f, -0.02373119f, 
    -0.01512717f, -0.05259040f, 0.01601663f, -0.05272568f, -0.05959815f, 0.01042695f, -0.05207569f, -0.04347521f, 
    0.03602403f, -0.00575263f, -0.03935196f, -0.03272671f, 0.03620896f, 0.01127891f, 0.03879620f, -0.01320841f, 
    -0.02211131f, -0.04125094f, -0.03653801f, -0.01993808f, -0.04954081f, 0.02662518f, -0.00414690f, -0.04053320f, 
    0.04374287f, 0.02674100f, 0.02650500f, -0.03295972f, -0.00029680f, -0.02868613f, -0.03205175f, 0.04021977f, 
    -0.02779571f, 0.00758998f, -0.02016790f, -0.06143717f, -0.01455717f, -0.00666054f, 0.01245353f, 0.03105717f, 
    -0.06130321f, 0.02987303f, -0.02026679f, -0.03276818f, -0.03542734f, 0.03566154f, -0.02954861f, -0.03703677f, 
    -0.02047036f, -0.05472767f, -0.03354316f, 0.00424901f, -0.01577697f, -0.03516125f, 0.01862724f, 0.00042458f, 
    -0.01513678f, -0.06315066f, 0.01792082f, -0.02514613f, -0.00745161f, -0.00326028f, 0.01619999f, -0.04945655f, 
    -0.01406305f, -0.02757050f, 0.00406981f, -0.01190568f, -0.00532784f, 0.03238678f, 0.03945130f, -0.03912959f, 
    0.01246245f, 0.03134978f, -0.06078873f, -0.03210291f, -0.03228112f, -0.05366774f, -0.02576713f, -0.02020309f, 
    -0.00856776f, 0.00884851f, -0.01983688f, -0.03726615f, 0.00676951f, -0.00522793f, 0.01407361f, -0.00142691f, 
    0.03564103f, -0.01263710f, 0.03632922f, 0.03928389f, -0.00186910f, 0.01118433f, -0.00900280f, -0.05103843f, 
    -0.04147043f, 0.02825102f, -0.02634869f, -0.02873518f, -0.04070741f, -0.04867474f, 0.04323323f, 0.02771698f, 
    0.02861955f, -0.06019102f, 0.03234850f, -0.02216968f, -0.01796980f, -0.02974765f, -0.05542050f, 0.01018873f, 
    0.02230361f, -0.04326442f, -0.05780449f, 0.03798097f, -0.04975696f, 0.01587626f, 0.03640244f, -0.05685663f, 
    -0.01202784f, -0.04155238f, -0.05998144f, 0.04178621f, -0.05090201f, 0.02566315f, 0.04038756f, -0.01784364f, 
    -0.01330017f, -0.06852189f, -0.02926458f, -0.03959685f, 0.03784339f, 0.03150079f, -0.00009591f, -0.04700035f, 
    0.02931145f, -0.05650937f, -0.00729023f, 0.03219971f, -0.01317548f, 0.00551585f, -0.03512818f, -0.03619735f, 
    0.03972542f, -0.00767786f, -0.00234618f, 0.01734173f, 0.01584681f, 0.03768865f, 0.03826715f, -0.02578715f, 
    -0.02172419f, -0.05210079f, 0.03870870f, -0.02217639f, 0.00731904f, 0.00849924f, -0.04451818f, 0.03206325f, 
    0.01446317f, -0.01385891f, -0.05872438f, 0.03779645f, -0.01841680f, 0.03707659f, 0.01759028f, 0.02398839f, 
    -0.03892512f, 0.00854142f, -0.00440334f, -0.00093103f, -0.02500144f, -0.02287489f, -0.03148203f, -0.02629766f, 
    0.00536743f, -0.02803079f, 0.03610992f, -0.01496527f, -0.03921647f, -0.01611546f, 0.03619316f, 0.00938842f, 
    0.03667244f, 0.00817876f, -0.06588227f, 0.01235505f, -0.00778954f, 0.02987515f, 0.03173072f, -0.06350817f, 
    0.03920982f, 0.00824250f, 0.00834952f, -0.02165715f, 0.03339141f, -0.00324236f, 0.04020196f, 0.00112185f, 
    -0.06135093f, -0.06460529f, -0.04829100f, 0.03325579f, -0.03366524f, -0.05376544f, -0.03617186f, -0.02237829f, 
    -0.05634534f, 0.02825339f, 0.02087609f, -0.02989692f, 0.01727949f, -0.05256584f, 0.02362759f, 0.01699985f, 
    -0.04879906f, 0.01408447f, -0.03199755f, 0.04094247f, -0.01534193f, -0.00461611f, 0.03899980f, -0.03666830f, 
    0.00571499f, -0.02808314f, -0.05301573f, -0.04640216f, 0.01522994f, -0.05681866f, -0.00105194f, -0.00255744f, 
    0.02365950f, -0.05480734f, 0.03473576f, -0.05525232f, -0.02860913f, -0.03993919f, -0.00615937f, -0.06194474f, 
    -0.02274070f, 0.00218112f, -0.04368494f, -0.03581585f, -0.02483523f, -0.03978393f, -0.03623663f, -0.05771456f, 
    0.01356901f, -0.03975485f, 0.02483881f, -0.06057501f, -0.01579162f, -0.00423632f, 0.02701273f, 0.02191175f, 
    -0.01432291f, -0.06020785f, 0.03175345f, 0.03971659f, 0.03524132f, -0.02485029f, -0.01619361f, -0.05558743f, 
    0.02611909f, -0.02504251f, -0.05923158f, -0.03541784f, 0.01587125f, 0.03592438f, -0.04566112f, -0.01551262f, 
    -0.02041469f, 0.00373398f, -0.04230915f, 0.03986060f, -0.02106046f, -0.00677786f, -0.05338112f, 0.02704121f, 
    -0.03065999f, 0.04362420f, -0.00834267f, -0.03476285f, 0.00553462f, -0.00439999f, 0.01100328f, -0.06740547f, 
    -0.00146350f, -0.04338043f, 0.02243591f, -0.01029345f, 0.03797088f, -0.00155661f, 0.03275480f, 0.00976893f, 
    -0.12416107f, 0.13478658f, -0.46116513f, -0.12324165f, 0.09633622f, 0.03773841f, -0.15082055f, -0.05365447f, 
    -0.15638590f, -0.01255948f, 0.06891047f, -0.06003480f, 0.04554364f, -0.02128938f, 0.05280773f, 0.08902743f, 
    -0.12450398f, -0.04352402f, -0.16600147f, -0.02706691f, 0.05296152f, -0.18808985f, -0.42689145f, 0.08328474f, 
    0.04394129f, -0.07995728f, -0.04791519f, -0.05509897f, -0.20192713f, 0.08476438f, 0.01773636f, 0.02956327f, 
    0.12772845f, 0.02908012f, 0.10339697f, -0.02985737f, -0.00120763f, -0.13595122f, -0.03977227f, 0.00107516f, 
    0.08683584f, 0.46743956f, -0.09123523f, -0.20709482f, -0.03345700f, 0.03564365f, -0.09927879f, -0.01278111f, 
    -0.08721337f, 0.09296743f, 0.02940555f, 0.03788140f, 0.10903496f, -0.16585065f, -0.02522339f, 0.07367641f, 
    -0.11725538f, -0.27677077f, 0.03271176f, -0.21027128f, -0.19266938f, -0.07301130f, 0.14706533f, -0.29989487f, 
    -0.00433069f, 0.08159007f, -0.13029471f, 0.05274301f, -0.12594038f, -0.02389849f, 0.12775360f, 0.03954321f, 
    0.11467911f, 0.02325324f, -0.02959802f, -0.07307796f, 0.12505825f, 0.07804009f, 0.03088171f, 0.03613780f, 
    -0.10552175f, -0.06542797f, -0.20070811f, -0.19085670f, 0.19936718f, 0.12902729f, -0.07992990f, 0.08350864f, 
    -0.02354583f, 0.07458115f, 0.11424430f, 0.05681590f, 0.08454774f, 0.14642625f, 0.04106075f, 0.00400607f, 
    0.00049956f, -0.08854248f, -0.15937267f, -0.01756340f, -0.07028862f, 0.11405613f, -0.02783501f, 0.10193210f, 
    0.02899380f, 0.02028813f, -0.13742830f, -0.14283702f, 0.01970188f, 0.14680405f, 0.10917522f, 0.07728899f, 
    0.13116683f, 0.08674477f, -0.03213222f, 0.03316445f, -0.02483505f, -0.02945961f, 0.01318600f, 0.08465856f, 
    0.14641215f, -0.16973294f, 0.21759719f, 0.09160051f, -0.04616150f, 0.05753070f, 0.15002559f, 0.01592954f, 
    -0.09669457f, -0.01983299f, -0.07521094f, -0.16917156f, -0.11241394f, 0.03043043f, 0.00611895f, -0.07478604f, 
    0.06450427f, -0.06097711f, -0.00857663f, 0.05068626f, 0.13049117f, 0.13072494f, 0.33996636f, -0.12463949f, 
    -0.06162937f, 0.06132674f, 0.05628207f, -0.02691163f, 0.06585123f, 0.03720434f, -0.12471696f, -0.13504606f, 
    0.09738169f, -0.10721542f, 0.08996364f, -0.03043776f, 0.00136891f, -0.01770603f, 0.09738591f, 0.02066284f, 
    0.14263485f, 0.26655519f, 0.26091760f, -0.01946432f, 0.11536199f, -0.01275451f, -0.08913418f, -0.09136641f, 
    -0.03993643f, -0.06024165f, -0.03132742f, -0.00844765f, 0.06172161f, 0.03376551f, 0.10717290f, 0.01628276f, 
    -0.13503133f, 0.06458639f, -0.04111186f, -0.11628063f, 0.07772615f, 0.17543823f, 0.08076446f, -0.07499469f, 
    -0.03780618f, 0.15873565f, -0.06748692f, 0.06532016f, 0.00631436f, 0.06230829f, -0.11621182f, -0.01134566f, 
    -0.01274410f, 0.00415907f, -0.00238876f, -0.08558272f, 0.04289023f, 0.01211086f, 0.02033298f, 0.05051051f, 
    -0.05316049f, 0.05233930f, 0.14605895f, -0.11416940f, 0.18823978f, -0.03447769f, 0.03264413f, 0.08232597f, 
    0.06674390f, 0.09947111f, 0.03466218f, -0.01847283f, -0.00217756f, -0.14539346f, -0.01260000f, 0.06491059f, 
    0.15777811f, 0.13798240f, 0.12268029f, 0.14565730f, 0.25904942f, 0.12769908f, 0.24011764f, 0.00159108f, 
    -0.03523303f, 0.14867893f, 0.08956152f, 0.26617911f, -0.03715145f, 0.04198228f, -0.01668804f, -0.10557076f, 
    -0.09869681f, -0.09357302f, -0.10119261f, -0.13301352f, -0.08664115f, 0.00137117f, 0.02164185f, 0.10281318f, 
    -0.09667643f, -0.07629251f, 0.01713309f, -0.06393433f, -0.00143435f, -0.07574717f, -0.10058930f, -0.03350826f, 
    0.02325200f, 0.09011830f, -0.06742405f, 0.12266769f, 0.09304996f, 0.02495163f, 0.08412959f, -0.00638739f, 
    0.11399918f, 0.19024958f, 0.22214428f, 0.17950937f, -0.16193330f, 0.15060401f, -0.18668292f, -0.03399036f, 
    0.12180007f, 0.05372390f, -0.15882069f, 0.03308500f, -0.13725476f, 0.04795812f, 0.09111969f, 0.09894568f, 
    -0.00879081f, -0.00355061f, -0.02360207f, -0.03384203f, -0.06270561f, -0.05988324f, -0.00323170f, -0.10575967f, 
    0.10691303f, 0.06055574f, -0.02060976f, 0.09191041f, -0.14173108f, 0.08629784f, 0.13960314f, -0.06842924f, 
    0.00765620f, 0.03367481f, 0.19345161f, -0.00227344f, -0.05762023f, -0.20014063f, -0.12080882f, -0.03491665f, 
    -0.04878226f, 0.00717808f, 0.02075626f, -0.11348136f, 0.02314064f, 0.21147853f, -0.12169905f, -0.05080106f, 
    0.28279766f, 0.01007725f, -0.15895616f, -0.08482215f, -0.01745018f, 0.17777888f, 0.03215706f, 0.00950169f, 
    0.02331726f, 0.05249771f, -0.04041506f, 0.02704990f, 0.03289817f, 0.21424486f, 0.11234138f, 0.12422479f, 
    -0.00528308f, -0.03661347f, 0.30829892f, -0.06665511f, -0.04999254f, 0.05632586f, 0.19634980f, -0.06894597f, 
    0.10208993f, -0.00438391f, -0.06154099f, 0.01331559f, 0.00745558f, 0.02283423f, -0.02937372f, 0.09094129f, 
    0.09731991f, 0.04966779f, -0.06843456f, -0.06366875f, 0.37163588f, 0.08065683f, -0.13699612f, 0.04587471f, 
    -0.20103551f, 0.10877180f, -0.13007335f, -0.04140829f, 0.12821724f, -0.11723626f, 0.07625712f, -0.02996467f, 
    0.06400193f, -0.00735642f, 0.16550086f, 0.01498451f, -0.01293673f, 0.06338099f, 0.11002760f, 0.05953428f, 
    0.05547109f, -0.04573029f, 0.03864323f, -0.02344634f, 0.08893081f, -0.09277546f, -0.05677877f, 0.02897655f, 
    0.01340198f, -0.07319761f, 0.02389760f, 0.11914663f, 0.00607828f, -0.13007779f, -0.06776841f, 0.03881300f, 
    0.02195520f, 0.04929315f, -0.01524486f, 0.02958289f, -0.23790732f, 0.21179920f, -0.00390882f, 0.07309771f, 
    0.13187492f, 0.02731327f, 0.19456038f, -0.04727320f, 0.03923042f, 0.05731897f, 0.03620490f, 0.01744504f, 
    0.05606698f, -0.01494351f, -0.00824629f, 0.20097294f, 0.01255657f, 0.01559143f, 0.08537602f, -0.08007696f, 
    -0.08270794f, 0.00517394f, 0.05859170f, -0.03057200f, -0.11249117f, -0.01335950f, -0.01130043f, -0.04535938f, 
    0.02571529f, -0.05412974f, 0.00551809f, 0.13864702f, -0.03289085f, 0.08125966f, 0.22064523f, 0.07919817f, 
    0.06799337f, -0.00149586f, -0.08597511f, -0.04699886f, 0.20665288f, 0.01866336f, 0.11177749f, -0.12097876f, 
    -0.00835500f, 0.00374724f, 0.08626237f, 0.05262691f, -0.05411210f, 0.04215631f, 0.02382135f, -0.10603112f, 
    -0.03217485f, 0.10844223f, 0.04665609f, 0.19279875f, -0.00120200f, 0.02637155f, 0.05569451f, -0.05737076f, 
    -0.42651170f, -0.11104782f, -0.17406647f, 0.17996503f, 0.04429607f, -0.12090923f, -0.17315395f, -0.03535010f, 
    -0.02344704f, -0.04049952f, 0.04335865f, 0.03455823f, 0.10671657f, 0.03415558f, -0.03406115f, 0.08073510f, 
    0.13711204f, 0.03055032f, 0.07294171f, 0.12623411f, 0.03506460f, 0.07314008f, 0.00337464f, 0.12945621f, 
    0.15607521f, -0.01609156f, -0.06297874f, 0.00160920f, 0.12407177f, 0.08592490f, 0.13627917f, -0.01569004f, 
    -0.04148565f, 0.13599426f, -0.13416938f, -0.02285276f, -0.04399020f, -0.03575426f, -0.06875104f, 0.10785636f, 
    -0.19337209f, -0.16619976f, 0.07453770f, 0.02755706f, -0.02412153f, -0.16718055f, -0.05844849f, -0.05294266f, 
    0.09999900f, 0.30788031f, 0.11624477f, 0.04207928f, -0.10982135f, -0.04100371f, -0.09922629f, -0.10978515f, 
    -0.01137385f, -0.01234487f, -0.06070722f, 0.01776828f, -0.21933138f, -0.16679630f, 0.07528277f, 0.17707056f, 
    0.06720561f, -0.07138730f, 0.08703262f, -0.05799519f, -0.01138227f, 0.01662244f, 0.08731789f, -0.12284418f, 
    0.12691870f, -0.01681413f, 0.00139935f, 0.07484451f, 0.04004438f, -0.05062119f, 0.13217333f, 0.01126207f, 
    0.13346842f, -0.16770655f, 0.15099452f, 0.18772465f, 0.26974747f, 0.11866847f, 0.07269559f, -0.02156679f, 
    0.07073233f, -0.12072680f, -0.00001714f, -0.03307299f, -0.01568981f, -0.08432324f, -0.01282970f, 0.07589590f, 
    0.00313736f, -0.05421114f, 0.05705872f, -0.03080301f, -0.14734785f, -0.30414110f, -0.06484142f, 0.12964053f, 
    -0.07844038f, -0.12139641f, -0.07537999f, -0.01399799f, 0.02304945f, 0.03274135f, -0.05104285f, 0.03644954f, 
    -0.05215979f, 0.01719776f, 0.03274119f, 0.00067048f, 0.12003003f, 0.05472679f, -0.01801568f, 0.05562511f, 
    -0.14743234f, 0.12417115f, 0.02439618f, -0.06270800f, 0.21273257f, 0.00051758f, 0.04366034f, -0.19442703f, 
    0.11682066f, -0.09449258f, -0.06402745f, -0.12334355f, 0.13455239f, -0.04502211f, 0.00928041f, -0.02238327f, 
    -0.11615039f, -0.03566586f, -0.10989657f, -0.10244487f, 0.03502455f, -0.00660571f, -0.05723686f, -0.06503271f, 
    0.04065653f, 0.04478936f, 0.06012878f, -0.07539518f, 0.04845492f, 0.01885755f, 0.09450251f, 0.05877753f, 
    0.11252107f, 0.07258024f, 0.11893194f, 0.00351779f, 0.00330623f, 0.04970724f, 0.16024449f, 0.06818551f, 
    0.08510421f, -0.18589245f, 0.04172645f, -0.02612456f, 0.04631380f, 0.05690585f, -0.05973338f, -0.00563388f, 
    -0.14067072f, 0.07778504f, 0.00175938f, -0.02850804f, -0.06418782f, -0.03565867f, 0.08228363f, -0.01551817f, 
    -0.01577139f, -0.03867176f, 0.01361768f, 0.06960161f, -0.32926479f, -0.05576170f, 0.03765827f, -0.19909000f, 
    -0.05567709f, -0.07123376f, -0.01779976f, -0.06996489f, -0.01364992f, -0.02587000f, -0.09467664f, -0.00025309f, 
    0.02241932f, 0.10655290f, 0.12812199f, 0.03968681f, 0.04722522f, -0.07995845f, 0.01496500f, -0.18664077f, 
    0.29604411f, -0.25035930f, -0.42774585f, 0.22044706f, 0.13447489f, 0.18751660f, 0.05409876f, -0.11321788f, 
    -0.09125964f, 0.09095835f, 0.02467599f, -0.00060991f, 0.02340742f, -0.06029273f, -0.01769539f, 0.06243279f, 
    0.00317086f, 0.03739889f, -0.01794626f, 0.14720763f, 0.09022167f, -0.53165406f, -0.23589513f, 0.32919207f, 
    0.18871967f, 0.01296562f, -0.14906232f, -0.06530618f, -0.14877638f, 0.11233302f, 0.18018728f, -0.01362912f, 
    0.11433887f, 0.02827675f, 0.13795853f, -0.07868258f, 0.00779383f, -0.00565743f, 0.04340521f, 0.15417391f, 
    0.11248569f, 0.00765527f, 0.06412115f, -0.17123976f, -0.12675413f, 0.06420016f, -0.10490469f, -0.01548063f, 
    -0.04727625f, 0.01947869f, 0.00860516f, 0.09475717f, 0.06393998f, 0.04708286f, 0.02858500f, -0.03898622f, 
    -0.05046165f, -0.32632479f, -0.14353004f, -0.13897246f, 0.18726039f, -0.13871092f, -0.04535991f, -0.38756377f, 
    0.16598615f, -0.00860663f, 0.15108758f, 0.00772374f, -0.03538068f, 0.00352250f, -0.02741544f, -0.03149226f, 
    0.06062163f, -0.09307937f, 0.15059958f, 0.03742236f, 0.02053866f, -0.02623893f, 0.17581461f, 0.01175187f, 
    -0.22002611f, -0.17034060f, -0.31840661f, -0.04937903f, 0.14775132f, 0.16863880f, 0.02915632f, -0.02676021f, 
    0.04266369f, 0.11394894f, 0.08964759f, -0.06614878f, 0.08373800f, 0.17128263f, 0.06795854f, 0.16034536f, 
    0.06810416f, -0.02122706f, -0.02350571f, 0.00296569f, -0.44537622f, -0.32816762f, -0.29059198f, 0.25187555f, 
    0.11249111f, 0.15058301f, -0.16460456f, -0.07942867f, 0.14505859f, 0.02102301f, 0.07777288f, 0.07585053f, 
    0.10772195f, -0.18479086f, -0.06204790f, -0.00225163f, 0.04704059f, 0.07340996f, 0.12097920f, 0.07445977f, 
    0.00105512f, -0.03942836f, 0.48190695f, 0.24549040f, -0.23675478f, -0.06229014f, 0.08004567f, 0.18163957f, 
    0.12844840f, 0.01527052f, 0.19582886f, -0.05371220f, 0.05058092f, -0.00642838f, 0.00970638f, 0.14457801f, 
    0.20699185f, 0.02559965f, -0.09348610f, 0.06945291f, 0.11511856f, 0.19084586f, 0.15685391f, 0.01720808f, 
    -0.06266563f, -0.03772644f, 0.03188284f, 0.14227554f, 0.14357951f, 0.12897526f, 0.13151175f, -0.02319741f, 
    0.04874050f, 0.05378869f, 0.04026701f, 0.00620804f, 0.01672709f, -0.13643852f, -0.02444622f, 0.03785278f, 
    0.33098871f, -0.05092079f, 0.13886632f, 0.07163373f, -0.23212983f, -0.06859552f, 0.07156164f, 0.09915791f, 
    0.13093455f, 0.05606593f, 0.14121844f, -0.07049624f, 0.10149067f, 0.04357407f, 0.00727226f, 0.06116042f, 
    -0.04827243f, -0.07346962f, -0.05738955f, -0.00577455f, -0.06886707f, 0.05627227f, 0.10918631f, 0.28101987f, 
    -0.12424304f, -0.03667440f, -0.06920934f, 0.09359667f, 0.11766832f, 0.04509648f, 0.08092447f, -0.09068096f, 
    0.07679243f, 0.05848103f, -0.00921624f, -0.09080141f, 0.06079486f, -0.02697625f, 0.02874784f, -0.02403687f, 
    0.25419605f, 0.16133352f, -0.01548738f, -0.19051409f, 0.03865100f, 0.18045349f, 0.12529306f, -0.06994683f, 
    -0.05513516f, 0.10514406f, 0.00256761f, 0.09377249f, 0.02785503f, -0.00857863f, -0.15006290f, 0.03086797f, 
    0.09065110f, -0.09294293f, 0.14397183f, 0.04828252f, 0.15104428f, 0.18883900f, 0.42036727f, 0.27832812f, 
    -0.08155788f, -0.10407179f, 0.02307333f, 0.17976256f, -0.06690647f, 0.08038190f, 0.09233828f, 0.02840958f, 
    -0.00761750f, 0.03342788f, 0.02118522f, -0.01333143f, 0.04549498f, -0.09591163f, -0.05259354f, 0.05783606f, 
    -0.12765613f, -0.13488932f, 0.33847290f, -0.01203665f, -0.30689973f, -0.03321721f, -0.00930326f, 0.07068016f, 
    -0.05064852f, -0.03400581f, 0.11282308f, -0.01713174f, 0.00135944f, -0.04726462f, 0.09968888f, 0.02722758f, 
    -0.14387362f, -0.01507815f, 0.11476983f, -0.00882420f, -0.19768460f, -0.09650323f, -0.34925941f, 0.06569327f, 
    0.15251060f, 0.17311558f, -0.05185105f, -0.03404061f, -0.00239019f, 0.10534456f, 0.03945565f, 0.08218694f, 
    0.12305582f, 0.05909695f, 0.11638258f, 0.00006981f, -0.05006545f, 0.08695952f, -0.05479586f, 0.05165657f, 
    -0.06425600f, 0.11863446f, 0.05725770f, 0.25756735f, -0.43521735f, -0.10467518f, -0.15219308f, -0.08312159f, 
    0.20615359f, 0.09744339f, 0.11373655f, -0.02755942f, -0.00186369f, -0.01840199f, 0.09066687f, 0.03937078f, 
    0.01366456f, -0.11554851f, -0.06135907f, -0.06418107f, -0.05410022f, -0.26500341f, -0.53923064f, 0.04976385f, 
    0.22311006f, 0.05313969f, 0.01075439f, -0.09248902f, -0.01979408f, -0.02303373f, -0.08767829f, -0.02503197f, 
    -0.10809671f, 0.09108899f, 0.14787912f, 0.04125114f, 0.00067729f, 0.16511375f, -0.02976025f, 0.06242128f, 
    -0.04115045f, 0.04274064f, 0.35869482f, 0.02499207f, -0.24154589f, -0.01592083f, -0.10142306f, -0.04286648f, 
    -0.06400415f, -0.13024269f, 0.03627831f, 0.01526374f, -0.00353775f, 0.14862646f, -0.01044790f, 0.03656005f, 
    0.05703400f, -0.16420619f, -0.01601396f, -0.14371236f, 0.14084649f, -0.05558167f, -0.09187507f, 0.20378603f, 
    -0.08892057f, 0.21528326f, 0.00464457f, -0.13762893f, -0.39534473f, -0.26100111f, 0.07872932f, 0.05563613f, 
    -0.09767310f, -0.10186013f, 0.00569857f, 0.03648134f, -0.01006461f, 0.06683856f, -0.26492840f, -0.13870969f, 
    -0.23843406f, -0.02116249f, 0.07174300f, -0.07952649f, -0.09182193f, 0.19038539f, 0.06759629f, -0.10161459f, 
    -0.09035575f, 0.08080871f, -0.03617023f, 0.07975678f, -0.11184718f, 0.22036800f, -0.15767455f, 0.22865710f, 
    0.09879062f, 0.00627585f, -0.00241645f, 0.03002523f, 0.24518239f, 0.04142667f, -0.23648353f, -0.01872477f, 
    0.09507350f, -0.22669736f, 0.10933303f, 0.15444025f, 0.00829111f, 0.10852173f, 0.02627424f, -0.01693151f, 
    0.02940067f, 0.02422711f, -0.16271169f, 0.13406447f, 0.00626301f, -0.04125249f, 0.03589556f, -0.05690984f, 
    -0.03798216f, 0.13571970f, -0.00879374f, 0.10467748f, -0.00472491f, -0.23423254f, 0.07736553f, -0.12247138f, 
    -0.04477488f, -0.25453413f, -0.01278822f, -0.03667158f, -0.11929998f, -0.04831351f, -0.13350117f, -0.06236747f, 
    0.04706224f, -0.03730352f, -0.02240042f, -0.19729590f, -0.14008473f, 0.21640092f, -0.01759562f, 0.01837381f, 
    0.15823214f, 0.06490392f, 0.15980510f, -0.04668752f, -0.11717924f, -0.08399180f, -0.04621680f, -0.01557296f, 
    0.03633051f, -0.00048209f, -0.07142740f, 0.14867137f, 0.01767806f, 0.03482465f, -0.07642397f, -0.14104371f, 
    0.01515112f, -0.00012310f, 0.04053198f, -0.00531079f, 0.01006115f, 0.04704523f, -0.12363766f, -0.04530177f, 
    0.07080411f, 0.01356478f, 0.06311723f, 0.03270545f, 0.09168223f, -0.07973368f, 0.06589219f, -0.09595820f, 
    0.03050149f, 0.08318736f, -0.09556697f, 0.04063601f, 0.02717873f, -0.22848812f, -0.15580405f, -0.13851258f, 
    -0.21281089f, 0.09257204f, -0.05098816f, 0.03960111f, -0.11002976f, -0.02069514f, -0.02494962f, -0.01947637f, 
    0.07920650f, 0.08061527f, 0.01331356f, -0.04803097f, 0.00108943f, 0.15988284f, -0.13301399f, -0.04825790f, 
    -0.05937941f, -0.33877218f, -0.21927778f, -0.03737484f, -0.08698402f, 0.04652534f, 0.14024791f, -0.00656382f, 
    0.06930933f, -0.04524472f, -0.00761999f, -0.03997241f, 0.02583251f, 0.05329574f, -0.05394396f, -0.02520092f, 
    0.02225987f, 0.09488958f, 0.00363858f, 0.01438683f, 0.01230758f, 0.00209909f, -0.17016497f, -0.24522346f, 
    -0.09979351f, 0.11242794f, -0.08378894f, -0.00655798f, -0.01224516f, 0.05014015f, -0.09836612f, -0.05230246f, 
    -0.01324834f, 0.06544686f, -0.04006775f, 0.15898362f, 0.07416971f, -0.16694017f, 0.06209468f, 0.06159370f, 
    0.14057939f, -0.15500307f, 0.15046506f, 0.03399752f, 0.00360863f, -0.11294537f, -0.12970352f, -0.03141186f, 
    0.00870702f, 0.08787571f, -0.07642151f, 0.00128093f, -0.02327065f, 0.03179836f, 0.07459924f, -0.00286338f, 
    0.01003299f, 0.00557483f, 0.06561636f, -0.13415988f, 0.01184098f, -0.08889736f, -0.20835036f, 0.03097500f, 
    0.06649172f, 0.07730082f, -0.17415392f, 0.07513540f, 0.07069939f, 0.17446804f, -0.06573548f, -0.12116069f, 
    -0.06587044f, 0.08878419f, -0.04230163f, 0.06776224f, 0.06033081f, 0.22840174f, -0.13960500f, 0.07453191f, 
    0.36691105f, 0.07645183f, -0.04346987f, 0.09934717f, -0.19910227f, -0.02771387f, -0.07004062f, 0.14003488f, 
    0.13185085f, 0.01731081f, -0.12377957f, -0.13068809f, -0.01034911f, -0.04441275f, 0.11145277f, 0.21727486f, 
    -0.08494182f, 0.00302606f, -0.00637060f, 0.09739762f, -0.09027486f, 0.07924186f, -0.11958255f, -0.02001672f, 
    -0.05618389f, 0.05069809f, 0.05425268f, -0.03450541f, -0.11131650f, -0.25424212f, 0.01234475f, 0.03573215f, 
    0.13170290f, -0.00226792f, -0.10918607f, 0.09212538f, -0.06811316f, -0.07001889f, -0.00474270f, -0.01005794f, 
    0.07109887f, 0.21876562f, 0.39817232f, -0.02136904f, 0.14601669f, -0.15336217f, 0.08233882f, 0.07510214f, 
    0.01758735f, 0.02994253f, -0.08572236f, -0.06543899f, 0.03974732f, -0.12239743f, 0.01796929f, -0.03720535f, 
    0.02404560f, 0.05819468f, 0.04342161f, -0.05388464f, -0.05132727f, -0.07194849f, -0.00537929f, 0.03993849f, 
    0.03562558f, -0.00613545f, 0.03882892f, 0.03275558f, 0.00673548f, -0.24259868f, -0.01952886f, -0.08010964f, 
    -0.01021010f, -0.09517258f, -0.03311091f, -0.00201506f, -0.14153492f, -0.11170546f, -0.11186615f, -0.12266111f, 
    0.00733351f, 0.00102252f, -0.06001211f, -0.02402383f, -0.03199377f, -0.03574429f, -0.01963041f, -0.01151502f, 
    0.03441270f, -0.03272413f, 0.04762393f, -0.02990088f, -0.05998304f, 0.00823216f, -0.00737117f, 0.02760082f, 
    0.01643858f, -0.00593103f, -0.00061978f, -0.06045162f, -0.00293712f, -0.04422150f, -0.02234166f, -0.04569469f, 
    -0.02685591f, -0.05795048f, -0.03647163f, 0.04729369f, -0.01102832f, -0.03534726f, -0.03035469f, 0.01421119f, 
    0.03836435f, -0.02555047f, -0.05088647f, 0.03246628f, 0.03180100f, -0.02330558f, -0.03888597f, -0.05386579f, 
    -0.04757666f, 0.01204460f, -0.00027288f, 0.01459052f, -0.05173027f, -0.00481218f, 0.03651760f, -0.04674759f, 
    -0.02767658f, 0.00808082f, -0.03278092f, -0.00267322f, -0.02656287f, -0.01887519f, -0.01957921f, 0.00391078f, 
    -0.03595806f, 0.03457354f, -0.03955056f, -0.01033745f, -0.03591031f, -0.01374806f, 0.02704664f, -0.06112901f, 
    0.03033741f, -0.03563204f, 0.03445292f, -0.03510265f, -0.04426664f, -0.02380793f, -0.00776795f, -0.03840913f, 
    0.04589275f, 0.00527452f, 0.00038593f, -0.01481908f, -0.03883521f, -0.00044712f, -0.01713229f, 0.04933389f, 
    -0.00077275f, -0.00694833f, -0.00159176f, 0.00453793f, 0.02828261f, 0.03786927f, -0.03773908f, 0.04055476f, 
    -0.03681217f, -0.00876928f, 0.01081759f, 0.02192469f, -0.04517176f, -0.01044444f, -0.01662826f, 0.01396953f, 
    -0.01375553f, 0.04503623f, -0.06054353f, -0.01286885f, 0.01898925f, 0.03715200f, -0.05261721f, -0.00035776f, 
    0.01623178f, -0.02631250f, -0.05323375f, 0.01959563f, -0.03229091f, -0.05541679f, 0.01569340f, -0.05123014f, 
    -0.05067145f, -0.02619839f, -0.02920014f, 0.00540533f, -0.03080687f, -0.04793267f, -0.04613382f, -0.05777951f, 
    0.01396243f, 0.00304708f, 0.01550479f, -0.02993119f, 0.05381618f, -0.00520321f, -0.00361766f, -0.03283491f, 
    -0.03598099f, -0.02783404f, 0.03782582f, 0.02848190f, 0.01128033f, 0.02438682f, -0.04615581f, -0.05223003f, 
    0.00603125f, 0.00016533f, -0.03796008f, -0.00344497f, -0.00401240f, -0.02649412f, -0.01028484f, -0.04039131f, 
    -0.00125608f, 0.02905647f, -0.03295679f, 0.01571222f, -0.02208221f, 0.02446658f, 0.02663092f, 0.05257943f, 
    -0.01543538f, -0.00901177f, 0.05164838f, 0.03056208f, -0.02435251f, 0.04854278f, -0.02445601f, -0.04099406f, 
    -0.04438151f, 0.04851952f, -0.01549028f, -0.00970717f, -0.04789467f, 0.01222206f, -0.05745082f, 0.03826771f, 
    0.02345080f, 0.04607977f, -0.01573360f, 0.03221450f, 0.03352119f, -0.01506252f, 0.00322253f, -0.00395997f, 
    0.01477951f, -0.04267563f, 0.03301526f, -0.05289321f, -0.04135067f, -0.01064603f, -0.05149507f, -0.04658913f, 
    -0.00075084f, -0.01461919f, 0.00692096f, 0.00904909f, -0.00991130f, -0.02686358f, 0.01871570f, 0.02685320f, 
    0.04789658f, -0.03758229f, -0.05430116f, -0.05479694f, -0.05068899f, 0.03898602f, -0.05009801f, 0.03470098f, 
    -0.01231612f, -0.00581417f, -0.05011219f, -0.04850553f, 0.04062201f, -0.04129176f, -0.03728797f, -0.01297288f, 
    0.00121898f, 0.01357452f, 0.04897028f, 0.01591909f, -0.03890813f, 0.00505514f, 0.00777245f, -0.01934403f, 
    0.02436773f, 0.03020738f, -0.00293275f, -0.03030104f, 0.00650535f, 0.03127858f, 0.00726044f, 0.03572177f, 
    -0.04895709f, -0.02187875f, 0.04799362f, 0.01536002f, 0.00923832f, -0.03123150f, -0.02392020f, 0.00260493f, 
    -0.03527701f, -0.05081350f, -0.01557516f, -0.06133678f, 0.03867559f, 0.03742504f, -0.03812902f, -0.00624378f, 
    -0.04549025f, 0.02051512f, 0.05116938f, 0.01914736f, 0.01243907f, 0.01487590f, -0.00372209f, 0.02702045f, 
    -0.01932589f, 0.00002679f, -0.04291055f, 0.02075477f, 0.03456715f, -0.04018585f, 0.01513320f, -0.02401816f, 
    0.00274122f, 0.00103920f, 0.01147653f, -0.00229563f, -0.01959269f, 0.04037971f, 0.04556727f, 0.03070047f, 
    -0.06329239f, 0.02835173f, -0.01792188f, 0.01313267f, 0.00062270f, 0.01095098f, -0.05431417f, -0.03883207f, 
    0.02187363f, 0.01307303f, -0.03884505f, -0.02508276f, -0.04962674f, -0.05657149f, 0.01081803f, -0.06260046f, 
    0.03445229f, 0.04411659f, 0.02074736f, -0.01823369f, 0.01566440f, -0.05876723f, -0.04378200f, -0.02946718f, 
    -0.02334002f, -0.04019543f, 0.01916312f, 0.00281987f, -0.02770291f, 0.02270748f, -0.01390826f, -0.01053249f, 
    0.00654823f, 0.00575254f, 0.04697673f, -0.00414385f, 0.04636069f, 0.03507482f, 0.04165809f, -0.01081827f, 
    0.02891941f, -0.04183832f, 0.00993995f, 0.03911046f, -0.06190707f, 0.01581392f, -0.05864682f, 0.01900922f, 
    -0.05070747f, -0.01322801f, -0.03207413f, -0.02799731f, 0.00870947f, -0.01315312f, 0.01255146f, 0.01909310f, 
    0.00644848f, 0.04507260f, -0.04157578f, 0.01136913f, 0.01821834f, 0.02474990f, -0.03653691f, 0.03983434f, 
    -0.03862228f, 0.01509735f, 0.00199526f, -0.02400779f, 0.02688693f, 0.02253779f, 0.02077295f, -0.01578443f, 
    -0.04371971f, 0.01369382f, -0.01045153f, 0.03015389f, -0.00742415f, 0.02827017f, 0.03495341f, 0.04858159f, 
    0.03035553f, -0.03082177f, -0.03630327f, 0.03827971f, -0.04131922f, -0.05337644f, -0.05044707f, -0.01092096f, 
    -0.00564353f, -0.03943224f, -0.03473683f, 0.02336588f, -0.03297884f, -0.05050192f, -0.04368377f, -0.00297431f, 
    -0.01212678f, -0.05421753f, -0.01743936f, -0.05616365f, -0.03858170f, -0.00664203f, 0.04603723f, -0.02105900f, 
    -0.00767011f, 0.00168093f, 0.03681279f, 0.01696120f, -0.03678467f, -0.02351419f, 0.00584474f, -0.03871802f, 
    -0.02356204f, 0.01500739f, 0.01539304f, 0.03456801f, 0.00342290f, -0.04701448f, -0.05674031f, 0.04109790f, 
    0.03922137f, 0.00097357f, -0.04643927f, -0.03751302f, 0.01913401f, -0.03136478f, -0.05227208f, -0.04231066f, 
    -0.04462133f, -0.04981862f, 0.02551128f, -0.02565515f, 0.03181138f, -0.01628168f, 0.04954620f, -0.04511890f, 
    -0.02520173f, -0.03295951f, 0.00271434f, 0.01990168f, -0.06025441f, -0.04147360f, 0.00159981f, 0.03348343f, 
    -0.05945690f, 0.00765205f, 0.00511726f, -0.03808138f, 0.00513594f, 0.02925226f, -0.05823319f, 0.01152129f, 
    -0.04651906f, -0.02898906f, -0.00544743f, -0.04589380f, -0.00308466f, 0.03779082f, 0.01170570f, 0.01813846f, 
    -0.00277669f, 0.01520128f, -0.01584487f, -0.01213320f, 0.01073290f, -0.01652904f, 0.01283902f, 0.04335640f, 
    0.02563166f, -0.02384250f, 0.00311473f, -0.01648485f, 0.02378498f, -0.02498504f, 0.04971762f, -0.01179553f, 
    -0.03973889f, 0.04070714f, -0.01024899f, 0.00217342f, 0.02699724f, 0.00737348f, 0.00400274f, -0.02052815f, 
    -0.02039490f, -0.05124347f, 0.00221991f, -0.00222402f, -0.05815900f, 0.04715034f, -0.02438107f, -0.02813296f, 
    0.01094245f, -0.01461140f, -0.02208721f, 0.03859322f, 0.01841395f, -0.03776804f, -0.04580746f, 0.01913771f, 
    -0.04250808f, -0.06046624f, 0.01245462f, 0.02094928f, 0.03134792f, 0.00462061f, 0.01606396f, -0.02291799f, 
    -0.02714613f, -0.01037603f, -0.02340257f, 0.02517650f, 0.04696460f, -0.00122617f, 0.03428962f, -0.04778171f, 
    0.03903871f, 0.02276875f, -0.05325253f, 0.02595901f, -0.02364660f, 0.00637708f, 0.04840302f, -0.02615371f, 
    -0.02301209f, -0.02295140f, -0.00626956f, -0.00767522f, 0.00100835f, -0.00261274f, 0.05623507f, -0.04800703f, 
    0.04104649f, -0.04188554f, 0.02569668f, 0.02349787f, -0.05199375f, 0.00114827f, 0.03265793f, 0.01480570f, 
    0.02967698f, 0.02853277f, -0.00873928f, -0.03377464f, 0.02546887f, -0.04018063f, 0.05740128f, -0.01101318f, 
    -0.00036971f, 0.05137447f, 0.03598996f, 0.04966893f, 0.04801798f, 0.04030708f, -0.01791356f, -0.04016126f, 
    0.04984878f, 0.00714345f, 0.01696311f, -0.06069325f, -0.04954168f, 0.02554176f, -0.04060213f, -0.05569510f, 
    -0.06260309f, -0.01370520f, -0.00189183f, -0.05045290f, 0.02800329f, -0.05827000f, -0.04827031f, -0.01518407f, 
    0.00745165f, -0.00091784f, -0.04313147f, 0.01803220f, -0.03458912f, 0.04255686f, 0.00034972f, -0.00850460f, 
    0.04643114f, 0.00135903f, -0.02936552f, -0.04923171f, -0.05606464f, -0.00941134f, 0.01864542f, -0.04443400f, 
    0.02243667f, -0.03597054f, 0.00557669f, -0.00921771f, 0.04095612f, -0.03309854f, 0.03184229f, -0.02199703f, 
    -0.00067446f, 0.01147188f, -0.00370982f, -0.05200848f, 0.00253341f, 0.01696000f, -0.00838064f, 0.01849384f, 
    0.03410025f, 0.04590737f, -0.04718792f, 0.01401107f, -0.01296314f, 0.03070679f, -0.02916058f, -0.04135225f, 
    -0.05555488f, -0.02659975f, -0.05949121f, -0.05475226f, -0.02590055f, -0.06107398f, -0.03807633f, 0.02394736f, 
    -0.02930359f, -0.05366484f, -0.03286725f, -0.02287405f, -0.02765666f, 0.03246327f, -0.05254594f, -0.05681350f, 
    0.03893470f, -0.04611181f, -0.02215737f, -0.04948632f, -0.00277974f, 0.03506932f, -0.02188111f, -0.00381326f, 
    0.04225267f, -0.02747921f, -0.03014432f, 0.03174979f, -0.05243221f, -0.05175433f, 0.01903515f, -0.01951414f, 
    0.04236029f, -0.01239434f, 0.01715529f, -0.01117644f, -0.05376063f, -0.00360194f, -0.00246159f, 0.01375162f, 
    0.01708619f, -0.03256646f, 0.01111939f, -0.03046231f, -0.02763643f, 0.01583326f, 0.02149216f, -0.00899190f, 
    0.03922013f, -0.02238746f, -0.00127231f, 0.03392253f, 0.01069100f, -0.00936980f, -0.00132867f, 0.02888864f, 
    0.03742308f, -0.06147861f, 0.02259823f, 0.01213004f, -0.02377864f, 0.03057374f, -0.02251802f, -0.04707661f, 
    0.02514008f, 0.06806982f, 0.23536168f, -0.12178674f, -0.28729647f, -0.12626541f, -0.09258511f, -0.02589138f, 
    0.15009928f, -0.04275723f, -0.04850189f, 0.00981054f, -0.09385302f, 0.02971578f, -0.11688024f, -0.03602017f, 
    -0.11856544f, -0.12768841f, 0.05200653f, 0.06773200f, 0.66053408f, 0.28202105f, -0.13010143f, 0.13335952f, 
    -0.13497196f, 0.12670873f, -0.01393557f, 0.00988908f, -0.14321573f, -0.00336029f, 0.05098735f, -0.01249624f, 
    0.13180454f, -0.02978532f, -0.07023147f, -0.06169385f, 0.07524852f, -0.04892236f, -0.01982088f, -0.00360901f, 
    -0.09335539f, -0.06200518f, -0.07128940f, -0.07471836f, 0.03334394f, 0.04834709f, -0.10886225f, -0.20829767f, 
    0.01662743f, -0.13661791f, -0.00854456f, 0.16951175f, -0.02466790f, 0.08609600f, 0.02777402f, 0.11675783f, 
    0.02988075f, -0.01736733f, -0.05433027f, -0.03301186f, 0.23524548f, -0.05612908f, -0.01538256f, 0.10882007f, 
    0.09260627f, -0.05491885f, 0.10832463f, 0.03757553f, 0.04721617f, 0.04344755f, 0.10706718f, 0.08403578f, 
    0.09188531f, 0.04333367f, 0.09716660f, 0.11120047f, 0.02197761f, 0.08364822f, -0.01045778f, 0.12629253f, 
    -0.01715244f, 0.10431928f, 0.01530183f, -0.00587152f, -0.12141117f, -0.19290763f, -0.08553276f, -0.06635568f, 
    -0.10284791f, -0.07975039f, 0.00519079f, -0.05859169f, -0.16701056f, -0.11767500f, -0.02300067f, -0.17737576f, 
    -0.07848866f, -0.01801578f, 0.02342200f, -0.06675092f, -0.28106856f, 0.19359502f, 0.10671388f, -0.02722844f, 
    0.09849808f, -0.01889432f, 0.09551493f, -0.00191522f, -0.07152952f, -0.10271779f, 0.02045248f, 0.06275890f, 
    0.02090521f, 0.04652392f, -0.11997429f, 0.19575551f, -0.06516933f, 0.08459491f, -0.07857831f, -0.09896276f, 
    -0.08606548f, -0.03205779f, -0.00724267f, -0.00650238f, -0.12552689f, 0.04980044f, -0.21199429f, 0.01590563f, 
    0.03098039f, 0.07939395f, 0.00677306f, 0.00894406f, -0.01885354f, -0.00614542f, -0.01715700f, -0.01476087f, 
    -0.05159312f, 0.11897496f, 0.04446352f, -0.05254296f, 0.04043584f, 0.04325311f, -0.01361114f, 0.00081444f, 
    -0.08114689f, 0.02610196f, 0.03865910f, 0.01945088f, 0.07844713f, 0.24988641f, -0.00924733f, 0.10441643f, 
    0.06154127f, 0.08455812f, -0.03693493f, 0.09520666f, 0.02206714f, -0.01700280f, -0.00487704f, 0.06829890f, 
    -0.17298503f, -0.20109943f, -0.04340704f, 0.00234282f, -0.14070928f, -0.10043388f, -0.03707957f, -0.06495968f, 
    0.07787043f, -0.00779617f, 0.01514415f, 0.01719283f, -0.04222179f, -0.03414566f, -0.07254608f, -0.02218747f, 
    -0.01417465f, 0.02790967f, 0.00128536f, 0.02134687f, -0.11797802f, -0.23306403f, -0.08082245f, -0.16890140f, 
    -0.19336672f, -0.03139367f, 0.03896557f, -0.12637772f, 0.12008911f, 0.02597630f, 0.03835147f, -0.06886771f, 
    0.02250044f, 0.01296010f, -0.05284364f, 0.09341393f, -0.01388973f, -0.09178728f, 0.04546290f, -0.01888149f, 
    0.29662555f, -0.04136799f, -0.00732249f, -0.03621618f, -0.13587974f, 0.05337946f, -0.05175297f, 0.04674743f, 
    0.05375108f, 0.01481420f, -0.01035635f, -0.00095065f, -0.05611269f, 0.01911666f, 0.10823565f, -0.00033401f, 
    0.05270277f, 0.04474481f, 0.10789892f, -0.10868917f, -0.10394584f, -0.24208485f, -0.14185613f, 0.01190688f, 
    -0.11374126f, -0.03540229f, -0.02846609f, -0.03315598f, 0.12843069f, -0.13121393f, 0.03833559f, -0.00037176f, 
    -0.01123479f, -0.03212690f, -0.04389736f, 0.06907531f, 0.05062022f, 0.12490327f, -0.03394534f, 0.02433403f, 
    0.09115042f, -0.15175261f, -0.03530331f, 0.03890869f, 0.08308933f, 0.00668891f, -0.04402628f, 0.05552546f, 
    0.09804654f, 0.03555886f, -0.02438206f, -0.09598038f, 0.05448437f, 0.00688755f, -0.00084240f, 0.17313920f, 
    0.02158192f, 0.01965110f, 0.08378062f, 0.09649026f, 0.01493846f, 0.10440078f, -0.00274956f, -0.04191852f, 
    0.02356104f, -0.00669600f, 0.00436615f, -0.06385473f, 0.03735498f, -0.08984668f, 0.00611670f, 0.07897200f, 
    0.09078760f, -0.00555372f, -0.11856590f, 0.04424907f, -0.03768125f, 0.02422094f, 0.03158339f, 0.04706265f, 
    -0.03593647f, -0.35222867f, 0.16744001f, -0.05148260f, -0.08713507f, -0.07047629f, 0.03651723f, -0.04669864f, 
    0.10002360f, 0.06251433f, 0.05026326f, -0.03584978f, 0.06315032f, -0.06179168f, 0.02196893f, -0.01411957f, 
    0.18038069f, 0.06996454f, 0.08181635f, 0.07406665f, -0.17918912f, -0.00899177f, 0.01073289f, -0.03998225f, 
    -0.10539074f, -0.12868401f, -0.02268436f, -0.08177434f, -0.07742735f, -0.13024883f, -0.08943702f, -0.06222970f, 
    -0.10915523f, 0.04264108f, -0.11467173f, -0.10017361f, -0.13424912f, -0.09074422f, 0.02351230f, -0.03600649f, 
    -0.01011069f, 0.03803625f, -0.35114276f, -0.03719235f, -0.07191405f, 0.00322700f, -0.02157176f, -0.01817347f, 
    -0.09851438f, -0.03014275f, 0.02696780f, 0.13870515f, 0.03152632f, -0.14262637f, -0.13164367f, -0.18347512f, 
    -0.04975327f, -0.00301242f, 0.19186790f, 0.05368121f, -0.91643727f, -0.23650043f, 0.32401824f, -0.23876718f, 
    0.12919024f, -0.08713385f, 0.11228761f, 0.17716537f, 0.16312355f, 0.15614876f, -0.17596334f, -0.14179303f, 
    0.03369388f, 0.17168207f, -0.03248182f, -0.05382393f, -0.05905029f, 0.04402187f, 0.11086705f, -0.06812692f, 
    -0.07319219f, -0.03883624f, 0.03499705f, 0.09934434f, -0.19401376f, 0.10625651f, 0.06983456f, 0.20617512f, 
    0.05641233f, 0.11440174f, 0.01137386f, -0.21520279f, 0.09282885f, 0.18009378f, 0.12879547f, -0.16410321f, 
    -0.02719293f, 0.07922601f, 0.08913656f, 0.24541833f, 0.22202730f, -0.05588854f, 0.16526134f, 0.16814740f, 
    0.00253013f, 0.03972995f, -0.01646780f, -0.05004014f, 0.07917556f, -0.08334523f, -0.15475425f, -0.04543780f, 
    -0.04987102f, 0.11158887f, 0.01523593f, -0.22331986f, 0.04923384f, -0.06906220f, -0.18742439f, 0.00106413f, 
    0.08878573f, -0.12939727f, -0.06834135f, -0.11738304f, -0.19105263f, 0.01499869f, 0.06839605f, 0.08916746f, 
    -0.08628312f, -0.01870920f, 0.00486683f, -0.02517127f, 0.02928293f, -0.14520940f, -0.01936945f, 0.03406772f, 
    0.01799022f, 0.16709411f, 0.08795613f, 0.06921744f, 0.16483159f, -0.46585965f, -0.00025168f, 0.06078146f, 
    -0.05878237f, 0.04073432f, -0.09719380f, 0.01393511f, 0.00818893f, -0.01001133f, 0.01865008f, 0.04969411f, 
    -0.08055481f, -0.06784237f, -0.00859729f, -0.19006599f, 0.03934743f, 0.12985925f, -0.06128979f, 0.02968277f, 
    0.15478872f, 0.17926070f, -0.01172887f, 0.04731264f, 0.00836139f, -0.10140433f, 0.08219415f, -0.00382799f, 
    0.00406896f, 0.00733297f, -0.02029572f, 0.06508369f, 0.00523303f, -0.13311554f, 0.07830097f, 0.02175298f, 
    -0.04351851f, -0.11700969f, 0.13000292f, -0.04200223f, -0.03077040f, 0.13918427f, 0.05524167f, 0.18691628f, 
    -0.03287507f, -0.10311598f, -0.01565597f, 0.01005155f, 0.08209751f, -0.03891989f, 0.02399629f, -0.02330770f, 
    -0.16671091f, 0.03173869f, -0.00798546f, 0.07588860f, 0.10658948f, 0.02167488f, -0.06883260f, 0.03563302f, 
    0.28279680f, 0.19476765f, -0.01734813f, 0.01832415f, -0.09705582f, 0.01046294f, 0.08885906f, -0.02048296f, 
    0.02615070f, 0.05211142f, -0.08836948f, -0.00561071f, 0.10895988f, 0.00648975f, 0.09068309f, 0.14408197f, 
    0.21903342f, -0.06449661f, 0.02622912f, 0.14456786f, 0.05697438f, 0.00100023f, 0.14041716f, 0.25243121f, 
    0.03122337f, -0.04817143f, -0.02725481f, -0.05150784f, -0.03572847f, 0.12569796f, 0.04103036f, 0.02013864f, 
    -0.08403520f, -0.07422877f, -0.01277221f, -0.00022054f, 0.11040258f, 0.17470533f, -0.16981387f, 0.01556348f, 
    -0.15473059f, 0.10411888f, -0.35908538f, 0.01281259f, -0.18189044f, -0.03753860f, -0.13855946f, -0.05164067f, 
    -0.07176359f, 0.01093937f, 0.02998306f, -0.02412529f, 0.10003880f, 0.15476197f, -0.04053631f, -0.07814512f, 
    -0.06338768f, -0.07038616f, -0.19415453f, 0.06370924f, -0.11769967f, 0.25089642f, 0.20573878f, 0.05021017f, 
    0.21066898f, -0.13483284f, 0.01106224f, -0.08000915f, 0.11297362f, 0.08267538f, 0.03509790f, 0.04322834f, 
    0.14742681f, 0.04537871f, 0.06372812f, 0.08840358f, 0.02124235f, -0.10678108f, 0.08881068f, -0.00321075f, 
    0.08062690f, 0.04675969f, 0.19832265f, 0.14371912f, -0.08400706f, 0.03990062f, 0.17508551f, 0.09729002f, 
    0.08923648f, 0.07302922f, 0.07800138f, 0.11000102f, -0.08957767f, 0.00547751f, -0.16576701f, -0.02657142f, 
    0.06016084f, -0.11429720f, -0.04292504f, 0.00835601f, -0.00058194f, -0.24244829f, 0.18008347f, -0.01467276f, 
    -0.21021998f, -0.03536498f, 0.06188406f, 0.07825223f, -0.03322095f, -0.04044999f, -0.05218564f, -0.22521181f, 
    -0.15649414f, 0.00273843f, 0.05856636f, -0.00946013f, 0.05995370f, 0.02504320f, -0.11028723f, -0.02723764f, 
    -0.21970716f, 0.11801745f, -0.39825553f, 0.38077018f, -0.06617648f, -0.01550108f, -0.02152858f, 0.19742447f, 
    0.07672217f, 0.13990965f, -0.24823564f, 0.13611028f, 0.10949598f, 0.24706310f, 0.08070144f, 0.12718076f, 
    0.04087842f, 0.06594092f, -0.17010483f, 0.01169088f, 0.33922443f, 0.12086353f, 0.20302239f, -0.08818569f, 
    -0.26007652f, 0.07795853f, -0.01336999f, 0.03194612f, -0.04154116f, 0.06581043f, 0.04318494f, 0.13049695f, 
    0.01882102f, -0.15649024f, -0.01016131f, -0.00531674f, -0.05031750f, -0.01348760f, -0.06296059f, 0.11385609f, 
    0.01169357f, 0.02118516f, 0.03337361f, 0.00169096f, -0.04041091f, 0.04805069f, -0.04831784f, 0.04415521f, 
    0.04346036f, 0.02041706f, 0.04818902f, 0.01041941f, -0.01534825f, 0.04368169f, -0.02688098f, 0.02322609f, 
    -0.02679735f, 0.01991092f, 0.00790494f, 0.00908683f, 0.00429837f, -0.00693454f, -0.04417832f, -0.00059530f, 
    -0.03726155f, -0.05703789f, -0.04021694f, 0.02995632f, -0.02971658f, -0.04903388f, -0.01909087f, -0.02823459f, 
    -0.04633440f, -0.00050324f, -0.02755115f, 0.03919730f, -0.01698459f, 0.00133285f, -0.02528914f, -0.01950172f, 
    0.05061103f, 0.00807471f, 0.01104087f, -0.02782677f, 0.04000747f, 0.03857134f, 0.04113196f, 0.00909968f, 
    0.02966191f, 0.00736401f, -0.03127548f, 0.04572687f, -0.02899283f, 0.00546552f, 0.03755607f, -0.01765929f, 
    0.01616767f, -0.05200343f, 0.02641054f, -0.03820646f, -0.06015309f, -0.04016986f, 0.04119067f, -0.01866522f, 
    -0.00910763f, -0.03279936f, -0.01410464f, -0.05558022f, 0.01755268f, -0.01623802f, -0.00454232f, 0.01216799f, 
    -0.05854831f, -0.02024093f, -0.00460523f, -0.06305153f, -0.02312728f, 0.04243173f, -0.06315588f, -0.06043984f, 
    -0.03901386f, -0.01628767f, 0.01419518f, 0.01835700f, -0.04509985f, 0.02685166f, 0.00992380f, -0.00562677f, 
    -0.05798389f, 0.00834659f, -0.04445462f, -0.00522388f, -0.04448951f, 0.01605310f, -0.01252689f, -0.01031004f, 
    0.01326435f, -0.04637226f, -0.05567695f, -0.00742825f, -0.05264422f, 0.02175957f, 0.02531756f, 0.01887813f, 
    -0.03685759f, 0.04621896f, 0.03805751f, -0.00676571f, 0.04429498f, -0.05381805f, -0.01094614f, 0.00539739f, 
    -0.05309708f, 0.03203520f, 0.00738763f, 0.01325465f, -0.02151222f, -0.00006059f, 0.00995087f, 0.00071284f, 
    -0.01397895f, -0.03512519f, -0.03779658f, -0.00476560f, -0.01067564f, -0.05252457f, -0.00695687f, -0.00464662f, 
    0.02933441f, 0.00773626f, 0.03452163f, 0.02435129f, -0.02297913f, 0.02140874f, -0.00002983f, -0.03182442f, 
    -0.00994222f, -0.01548930f, 0.00455684f, 0.01023399f, 0.02613125f, -0.03123029f, -0.03660920f, -0.03040673f, 
    -0.00858927f, 0.03625146f, 0.03610888f, -0.04223861f, -0.03547524f, -0.00549082f, -0.00823537f, 0.03449574f, 
    -0.02643651f, -0.02977598f, -0.00769959f, 0.01874068f, 0.02499208f, -0.03950638f, -0.03929897f, -0.06162664f, 
    0.01213291f, -0.01993535f, 0.00306028f, 0.02120504f, -0.00996258f, -0.00781546f, -0.01443826f, 0.02233864f, 
    0.01565566f, 0.01317974f, -0.01963735f, 0.02786201f, -0.04581780f, 0.03248098f, -0.05851217f, -0.00458872f, 
    -0.00297243f, -0.02930339f, -0.05196402f, 0.02975716f, -0.00048804f, 0.00687325f, -0.02853854f, -0.03094022f, 
    -0.02999187f, 0.01120673f, 0.04423630f, -0.00160521f, -0.00277912f, -0.01000934f, -0.00500893f, 0.03743078f, 
    0.03562384f, 0.00530353f, -0.03326790f, 0.00496232f, -0.01068430f, -0.00785799f, -0.02437630f, -0.04733307f, 
    0.03967530f, 0.02826917f, -0.03683154f, -0.01553301f, -0.06028859f, -0.04612422f, 0.02098018f, 0.03649921f, 
    -0.05143848f, -0.03058766f, -0.02727497f, -0.04480162f, -0.02745000f, 0.01305560f, -0.00924959f, -0.01809071f, 
    -0.04928093f, -0.04358708f, -0.02309383f, -0.06416900f, -0.06101241f, -0.04520031f, -0.02553058f, -0.03314151f, 
    -0.04438316f, 0.00396385f, 0.01594340f, -0.02964217f, 0.02700501f, 0.00840140f, -0.04269055f, 0.00893724f, 
    -0.06275980f, -0.03866922f, -0.03105603f, 0.03992966f, 0.01368443f, 0.01635644f, -0.04798058f, -0.01569435f, 
    -0.03303382f, -0.02881978f, -0.01430712f, 0.01254476f, -0.01881470f, 0.03291500f, -0.00970918f, -0.05856881f, 
    0.01793467f, 0.01858650f, -0.00519298f, -0.01342590f, -0.03750325f, 0.00014539f, -0.01254611f, -0.04103800f, 
    0.04055757f, -0.00328728f, -0.00400153f, 0.03701850f, 0.03837083f, 0.01030324f, -0.05256318f, -0.00455668f, 
    0.03915984f, -0.05938152f, 0.01731960f, -0.05608324f, -0.00596678f, -0.03731131f, 0.03395090f, -0.04901208f, 
    0.00417364f, 0.00828265f, -0.03963659f, -0.01180018f, -0.06501273f, 0.04139424f, -0.02863065f, 0.04444202f, 
    -0.02630776f, -0.06486657f, 0.03558272f, 0.01968627f, -0.01327871f, 0.03980856f, -0.00527846f, -0.06092261f, 
    0.02606480f, 0.02655133f, -0.06563248f, -0.00333157f, 0.03859814f, 0.01408526f, -0.02822388f, 0.02721357f, 
    0.01771376f, -0.02261750f, -0.06574932f, -0.05424292f, -0.00321219f, -0.00042852f, -0.03978862f, 0.01153140f, 
    -0.03675436f, 0.01417646f, 0.03344237f, 0.01485990f, 0.04798293f, -0.03949655f, -0.05476188f, 0.04185589f, 
    -0.02722359f, -0.02337770f, -0.01330283f, -0.04196442f, 0.03732297f, 0.01865362f, 0.03857548f, -0.04059339f, 
    -0.03297476f, 0.03445680f, -0.02584777f, 0.04686790f, -0.02027144f, 0.02824936f, 0.01426470f, 0.03747555f, 
    -0.05097339f, 0.02448699f, -0.03772597f, 0.00325768f, 0.03933152f, -0.04145690f, -0.06150838f, -0.06006979f, 
    0.04655272f, 0.04787035f, 0.01203548f, 0.02728799f, 0.04026816f, -0.04160446f, 0.01042838f, 0.03231102f, 
    0.00946707f, -0.00519891f, -0.04137448f, 0.03349028f, -0.04784356f, 0.00307078f, -0.05194433f, -0.01969241f, 
    0.03317929f, -0.02204134f, -0.01422348f, -0.03765026f, 0.00997800f, 0.01165874f, -0.00288469f, -0.04878333f, 
    0.01303689f, -0.00730701f, -0.03838613f, 0.04545364f, 0.02466148f, 0.04121731f, -0.03452684f, 0.04076648f, 
    -0.03266688f, -0.01524474f, -0.05967433f, 0.00226747f, -0.02867885f, 0.00642622f, 0.00178772f, -0.05979206f, 
    0.02756708f, -0.02247463f, -0.02851968f, -0.05970049f, -0.02418613f, -0.04732705f, -0.04867063f, -0.03520837f, 
    0.03704448f, -0.03334491f, -0.00265584f, 0.04273932f, -0.03147104f, -0.01305480f, -0.03645511f, -0.02447562f, 
    -0.03986809f, -0.00146744f, -0.00230979f, -0.02233014f, 0.02142717f, 0.03910569f, -0.03452757f, 0.00671419f, 
    0.00942674f, 0.01902075f, 0.03719643f, 0.04056307f, 0.01738001f, 0.01766228f, -0.05305987f, -0.02694204f, 
    -0.04458064f, 0.01711017f, -0.03161528f, -0.04131311f, -0.05418219f, -0.03340120f, -0.02144324f, -0.02057585f, 
    -0.06062510f, -0.00127385f, 0.01822584f, -0.02656284f, 0.02795649f, 0.03404061f, 0.02640576f, -0.04635109f, 
    0.04466055f, 0.01390597f, -0.05346275f, -0.02938559f, 0.02759517f, 0.03686127f, 0.01691464f, -0.03639767f, 
    -0.05038306f, 0.00280454f, 0.02530780f, 0.03093181f, -0.00062732f, -0.04704264f, -0.01706551f, -0.06071791f, 
    -0.02739569f, 0.01022027f, -0.04003618f, 0.04473718f, -0.05207518f, 0.04671087f, -0.04657951f, -0.01307970f, 
    -0.05286891f, -0.04954106f, 0.04929161f, -0.05822115f, -0.04251715f, -0.00250767f, -0.02613864f, 0.01548778f, 
    -0.05486159f, 0.01097697f, -0.04167184f, -0.05782840f, 0.00189838f, 0.00091973f, -0.05132689f, 0.04872551f, 
    -0.04585700f, 0.04479967f, -0.04088640f, -0.00769304f, 0.04173603f, -0.02759939f, 0.00816945f, 0.04724447f, 
    -0.00615096f, 0.02882542f, -0.03050176f, -0.06063324f, -0.02295207f, 0.03373347f, 0.01952268f, -0.00867136f, 
    -0.00017665f, -0.04412189f, -0.04054318f, -0.03469129f, -0.01500292f, 0.04252170f, -0.04920033f, -0.00557701f, 
    -0.01669239f, 0.01839369f, 0.00038759f, -0.00074004f, -0.03796690f, -0.03916063f, -0.05594628f, -0.00674120f, 
    -0.05186649f, 0.01061015f, -0.03762027f, 0.02526828f, 0.02778612f, 0.05625904f, -0.06201357f, -0.03983406f, 
    -0.04404612f, 0.03769883f, 0.01231260f, -0.05644437f, -0.05534234f, 0.04980099f, 0.02129173f, 0.01597363f, 
    0.01190517f, -0.02318853f, 0.03772766f, -0.04106699f, -0.01971832f, 0.01714270f, -0.01761329f, 0.04492250f, 
    -0.04725075f, -0.05865224f, -0.03443839f, -0.01708175f, -0.02569189f, -0.03271145f, -0.04022489f, -0.04441789f, 
    -0.06239224f, -0.02540978f, -0.03511259f, -0.05756218f, 0.00792335f, -0.05484360f, 0.02396874f, -0.00062341f, 
    0.04870342f, 0.01357281f, -0.01252167f, -0.04192786f, -0.04989697f, -0.03269866f, -0.03499004f, -0.04972282f, 
    0.03534971f, 0.01782134f, 0.02999167f, 0.01069481f, -0.02888572f, -0.00658248f, 0.02346320f, -0.04321235f, 
    0.01412820f, 0.01935861f, -0.04832677f, -0.03246844f, -0.03633741f, -0.00424799f, -0.02038192f, -0.05384203f, 
    -0.01920047f, -0.05872719f, 0.01563606f, -0.02748629f, 0.03751292f, 0.02784943f, 0.04054309f, -0.05208212f, 
    0.03413863f, 0.00044284f, 0.02472867f, -0.03075247f, 0.03941624f, -0.02079221f, -0.05265791f, 0.03527382f, 
    0.01174752f, 0.01705498f, -0.02950992f, 0.01268282f, -0.02138672f, -0.01941934f, 0.00006601f, -0.01375474f, 
    0.00976756f, -0.03907897f, 0.04805246f, -0.05956497f, -0.05946795f, 0.00207483f, 0.02410131f, 0.02007644f, 
    0.04379846f, -0.01864569f, 0.00378625f, 0.04449885f, 0.04766218f, 0.01127219f, 0.00029061f, -0.02257587f, 
    0.02101552f, 0.00054286f, 0.02148907f, -0.05866374f, -0.02100875f, -0.04936714f, 0.01214042f, 0.04408576f, 
    -0.00975980f, -0.00947871f, 0.00862531f, -0.03392771f, -0.02002198f, 0.00791931f, -0.03333836f, 0.02262995f, 
    -0.05608039f, 0.03881466f, -0.00315721f, -0.01584690f, 0.01186847f, -0.03913636f, -0.05743950f, 0.01424417f, 
    0.04097613f, -0.01560374f, -0.01167867f, -0.02672886f, -0.05054257f, -0.01154606f, 0.04095029f, 0.03316499f, 
    -0.04352544f, -0.05605580f, -0.03252652f, 0.04968626f, 0.03004951f, -0.05875713f, -0.03554728f, 0.01441165f, 
    0.13825513f, -0.30421114f, 0.28005663f, 0.09319197f, 0.03302024f, -0.09485243f, 0.11431326f, -0.09592931f, 
    0.11050813f, 0.04519242f, -0.09838346f, -0.09056193f, 0.01405736f, -0.20744428f, 0.08127316f, 0.03654955f, 
    -0.08555913f, 0.20082536f, -0.03100444f, -0.05825268f, 0.58342475f, -0.14539818f, 0.28730047f, -0.03303064f, 
    -0.10825022f, 0.09351197f, -0.23241515f, -0.00731973f, 0.14199647f, 0.01479795f, 0.08359793f, 0.02718172f, 
    0.04572972f, 0.03827541f, 0.15021197f, 0.07791878f, 0.03496132f, 0.16925527f, 0.03072503f, 0.02905513f, 
    0.16643302f, -0.40989330f, -0.24407916f, -0.04989082f, 0.12564954f, -0.02673174f, -0.05926604f, -0.02814909f, 
    -0.01274945f, 0.00213189f, -0.04501275f, 0.00380776f, 0.11829478f, -0.08627589f, -0.12437253f, 0.07295790f, 
    0.02457199f, 0.09580394f, -0.00597146f, -0.00597537f, -0.32996359f, 0.44648573f, 0.17881078f, 0.15261763f, 
    0.18833831f, 0.06377642f, 0.14709808f, -0.01070261f, 0.05353568f, 0.08592848f, 0.02732786f, -0.05129717f, 
    -0.06248630f, -0.05873629f, 0.04334942f, 0.20480014f, -0.04494616f, -0.09361967f, 0.22026539f, -0.00321537f, 
    -0.08397611f, -0.03921846f, 0.10875296f, -0.03428966f, -0.08194286f, 0.19830628f, -0.15675990f, -0.29529607f, 
    -0.07552585f, -0.04614948f, -0.10695504f, 0.02651917f, -0.07387601f, 0.08349419f, -0.00772395f, -0.02820200f, 
    -0.05793292f, -0.05034115f, -0.10773917f, -0.05084229f, 0.30873603f, 0.08492094f, -0.00846058f, -0.07164153f, 
    -0.13916390f, -0.07043920f, -0.05434495f, -0.06022157f, -0.03108421f, 0.00969276f, -0.02975899f, 0.00038989f, 
    0.12377748f, 0.00754318f, 0.09565519f, 0.08614866f, -0.02579281f, 0.05342620f, 0.10385691f, 0.06644465f, 
    -0.25345123f, -0.14712563f, -0.03953470f, 0.07171301f, 0.13207814f, -0.02885520f, -0.01078300f, -0.03054091f, 
    0.09613357f, -0.02250951f, -0.05927178f, -0.00257800f, 0.00288595f, 0.10723768f, -0.10017330f, 0.03628808f, 
    0.06422619f, -0.06151175f, -0.05168262f, 0.02567282f, 0.10824452f, -0.05286987f, -0.13114746f, 0.08583149f, 
    0.21063097f, 0.01739723f, 0.12560542f, 0.06570028f, 0.09968150f, 0.16399476f, 0.05490685f, 0.05540274f, 
    -0.02315966f, 0.08979858f, -0.04752812f, -0.00544928f, 0.10315047f, 0.02727726f, -0.01169972f, 0.04634125f, 
    0.00777370f, -0.23772383f, -0.29582441f, -0.01612698f, 0.00013380f, 0.00829962f, -0.06841888f, 0.03314814f, 
    0.01517703f, 0.20544523f, 0.11854213f, 0.04973323f, -0.01972995f, -0.03747005f, 0.00072970f, 0.06192577f, 
    0.03049208f, -0.06341565f, -0.04860962f, 0.02043974f, 0.03246804f, -0.11413658f, 0.02491074f, 0.29280621f, 
    0.27831721f, -0.07625534f, 0.11173008f, 0.16692767f, 0.12196534f, 0.02237533f, -0.01400939f, -0.04455482f, 
    0.16947442f, -0.01565472f, -0.01585727f, -0.07826251f, -0.04177910f, 0.05653499f, 0.05955050f, 0.05315152f, 
    0.01324280f, 0.01523690f, 0.38972846f, 0.28011832f, 0.39913601f, 0.07348938f, 0.19322151f, -0.04766860f, 
    0.02492055f, -0.11421079f, 0.07514972f, 0.10203302f, -0.02429692f, -0.08902528f, -0.07859439f, -0.01126353f, 
    0.01021633f, -0.14780705f, 0.14821145f, 0.03269951f, 0.16737166f, -0.10038459f, 0.05919914f, 0.23749568f, 
    0.04983580f, -0.00215295f, 0.09839322f, -0.10452976f, -0.01080872f, -0.08804268f, -0.04351471f, 0.06664003f, 
    -0.08413281f, 0.00127446f, 0.08795138f, -0.05610402f, 0.04867781f, -0.10489263f, -0.03059052f, 0.02490369f, 
    -0.33710685f, 0.22008713f, 0.10002243f, -0.09364422f, 0.23182887f, -0.03000682f, 0.18881647f, 0.08658268f, 
    0.01844434f, 0.05366487f, -0.11353245f, -0.06618862f, 0.04857016f, 0.02449668f, 0.06959638f, -0.15059453f, 
    -0.06329211f, -0.04178013f, -0.02976707f, -0.19122379f, 0.13004427f, -0.04061775f, -0.09555659f, -0.08528766f, 
    -0.08938727f, 0.05064570f, -0.03237543f, -0.09648699f, 0.02289874f, 0.01290963f, -0.01090501f, -0.10305125f, 
    0.08426667f, 0.05318684f, -0.02549989f, 0.02717849f, -0.00121084f, 0.15191385f, -0.02988704f, 0.09637960f, 
    0.27032933f, -0.04796327f, 0.32909337f, -0.03926443f, 0.03663447f, 0.30394602f, -0.12318126f, 0.05193445f, 
    0.00601775f, 0.12476572f, -0.01568483f, 0.11680751f, -0.04062613f, 0.03108952f, 0.08880761f, 0.06746023f, 
    0.06713884f, -0.11165280f, 0.00005236f, 0.20353106f, -0.08305752f, -0.16115655f, -0.04719182f, -0.03221384f, 
    -0.22788617f, -0.10651932f, -0.05350649f, -0.15532874f, -0.07346112f, 0.02134725f, -0.02926945f, -0.08001928f, 
    -0.07717275f, 0.01038696f, 0.08909330f, -0.04719040f, 0.03673913f, 0.08530447f, 0.12123045f, -0.15994985f, 
    -0.01809327f, -0.31150064f, -0.22405836f, 0.22471687f, 0.17707011f, 0.02090083f, 0.14309204f, -0.00953665f, 
    -0.04233021f, 0.06533862f, -0.08861405f, -0.07040577f, -0.06203858f, -0.04191008f, -0.01705165f, 0.12593582f, 
    -0.08947320f, -0.09904051f, -0.02694130f, 0.02358835f, 0.35198888f, -0.06453137f, -0.07643363f, 0.22343516f, 
    0.16400965f, 0.06033657f, -0.18278286f, -0.09637407f, -0.17227818f, 0.32454935f, 0.02551088f, 0.05484513f, 
    -0.06588174f, -0.00277860f, -0.03879496f, 0.03320437f, 0.00449054f, -0.03001605f, 0.07404941f, -0.03446830f, 
    0.16957848f, -0.02931492f, -0.20936275f, 0.01357754f, 0.00506534f, -0.13436067f, -0.13985422f, -0.08373215f, 
    -0.01386855f, 0.09864671f, -0.14280681f, -0.02063894f, -0.09503023f, -0.02228377f, -0.04249435f, 0.03108455f, 
    0.07473609f, -0.01670918f, 0.02082147f, 0.13804731f, 0.18130219f, 0.07110827f, -0.09913924f, -0.19711147f, 
    0.00999354f, -0.08647233f, -0.11494074f, 0.03790569f, -0.12842114f, -0.00388730f, 0.10680326f, -0.10063514f, 
    0.01854382f, -0.03895324f, 0.11451373f, -0.02651236f, -0.07818578f, -0.10115751f, -0.00905358f, 0.02416403f, 
    -0.03914737f, -0.02234646f, -0.13451542f, 0.02794264f, 0.07027701f, 0.04377957f, -0.02960728f, -0.04688813f, 
    0.01504181f, 0.04062487f, -0.07536743f, -0.16593114f, -0.08059054f, -0.08658229f, -0.15058851f, -0.19437166f, 
    0.04533216f, 0.03415681f, 0.00850591f, 0.02100890f, -0.39077288f, 0.05086982f, -0.19836101f, 0.26260495f, 
    -0.04238428f, -0.02304059f, -0.07908431f, -0.13859865f, 0.11463118f, -0.00512634f, 0.01876286f, 0.02084805f, 
    0.05031531f, -0.10804307f, 0.04012029f, -0.01655883f, -0.02138173f, -0.10740024f, 0.02290297f, 0.15313680f, 
    0.26875961f, 0.13929549f, 0.32162297f, -0.00640543f, -0.06439944f, 0.19642906f, 0.18088093f, 0.22443599f, 
    -0.00049930f, -0.09398276f, 0.04377302f, -0.04207786f, -0.12177843f, 0.03214270f, 0.00692150f, 0.08771495f, 
    -0.01658205f, -0.00686990f, -0.15249017f, -0.10423721f, -0.13905250f, 0.07364008f, -0.09609300f, -0.18570852f, 
    0.15581559f, 0.08571539f, 0.21916661f, 0.12256015f, 0.06726192f, 0.01623941f, -0.02105297f, -0.09055611f, 
    -0.05444735f, 0.03028325f, 0.04267219f, -0.05841414f, -0.01158621f, 0.03948737f, -0.03682910f, 0.08009531f, 
    0.06362323f, 0.08303882f, -0.07623112f, -0.03212142f, 0.07582062f, 0.04517313f, 0.13160971f, 0.31113946f, 
    -0.01193413f, -0.04739943f, -0.04977474f, 0.07186036f, -0.07398185f, -0.09696237f, -0.01709361f, -0.05554897f, 
    0.08112084f, 0.13942939f, 0.08455329f, 0.08294864f, 0.12548465f, 0.23571528f, -0.05780639f, -0.21242930f, 
    -0.09626806f, 0.12333881f, 0.08540827f, 0.26685920f, 0.10086454f, -0.00183733f, -0.02406680f, 0.00739967f, 
    -0.05323800f, 0.09221599f, 0.04230095f, -0.04289490f, 0.03570105f, -0.02173977f, 0.05459267f, 0.03309746f, 
    -0.01469269f, 0.28405839f, 0.16837150f, -0.14530486f, -0.08105561f, -0.00351325f, 0.20069021f, -0.05299662f, 
    -0.21933988f, 0.05028822f, -0.01531591f, -0.01426835f, 0.00562215f, -0.00573461f, 0.06062547f, -0.02003929f, 
    0.01093650f, -0.06746502f, 0.10446154f, -0.00330569f, 0.23780455f, 0.25125068f, 0.04475917f, -0.00913305f, 
    -0.10377321f, 0.04555500f, 0.19222111f, 0.00848689f, -0.14938490f, -0.20445590f, 0.05008858f, 0.00628303f, 
    0.02709454f, 0.07159293f, 0.05574208f, -0.01004038f, -0.02021501f, -0.03741818f, 0.13324274f, 0.13243610f, 
    0.18118928f, -0.06114827f, 0.14509624f, -0.07167999f, 0.07407425f, -0.09440341f, 0.07306578f, 0.31980574f, 
    -0.23868528f, 0.04965146f, 0.17993349f, 0.13130447f, -0.09189463f, -0.02485899f, 0.06438124f, 0.00491457f, 
    -0.16389221f, -0.05159963f, 0.00600444f, -0.05751345f, -0.03571563f, -0.05495629f, -0.16005549f, 0.12731715f, 
    0.09287325f, 0.01628713f, -0.10752264f, -0.02040702f, 0.00692204f, 0.14621578f, 0.03453331f, -0.02346602f, 
    -0.06512345f, -0.02478809f, -0.03820669f, 0.02783421f, 0.06799000f, 0.12768766f, 0.04545211f, 0.00703081f, 
    0.15813063f, 0.19046573f, 0.24196115f, -0.16568813f, -0.02635219f, 0.10502701f, -0.08857522f, -0.17409571f, 
    0.29660845f, -0.09997059f, 0.15709470f, 0.00794305f, 0.02094836f, -0.08769395f, 0.02711673f, -0.08414157f, 
    0.12903480f, 0.03995894f, -0.00281625f, 0.07498983f, 0.15127318f, -0.02387858f, -0.23094591f, 0.17569315f, 
    0.00012469f, -0.06912235f, -0.06539666f, -0.02731323f, 0.00919012f, 0.09046238f, 0.10242081f, -0.04298731f, 
    0.03520756f, 0.08364687f, 0.00664888f, -0.08640951f, 0.05474420f, 0.19364215f, 0.01401046f, 0.04540936f, 
    0.07439410f, 0.15202442f, 0.08917959f, -0.03291972f, 0.00478445f, 0.15148205f, -0.07565099f, 0.00912077f, 
    0.08046719f, -0.01755755f, -0.01338675f, 0.05021121f, 0.00640279f, 0.13963893f, 0.00175025f, -0.08203308f, 
    0.19780436f, -0.13221772f, -0.00688137f, 0.02866580f, -0.22958389f, 0.19438925f, -0.05976367f, 0.08695707f, 
    0.09499621f, -0.04607102f, 0.19799252f, 0.02467104f, -0.04628178f, -0.07870305f, 0.00577005f, -0.07487567f, 
    -0.01129131f, -0.01136503f, -0.07832386f, -0.07635467f, 0.07220931f, -0.14150004f, -0.07345854f, -0.03581290f, 
    -0.06152644f, 0.22951739f, 0.19637476f, -0.10426974f, -0.04045115f, 0.00908023f, 0.03589356f, -0.21202202f, 
    0.14218467f, 0.04409130f, 0.08005552f, 0.19443482f, 0.06468929f, 0.04411685f, 0.11525956f, 0.01702336f, 
    -0.00783339f, -0.08058926f, 0.00988826f, -0.11764778f, 0.25411108f, -0.36305788f, -0.35520616f, -0.01679138f, 
    -0.08977289f, -0.06344053f, 0.03727275f, -0.01670866f, -0.02182493f, 0.06476384f, -0.14706968f, 0.07530690f, 
    0.03249246f, 0.05540775f, 0.06186019f, -0.01973940f, 0.01709483f, 0.11071683f, -0.12269996f, 0.09152731f, 
    -0.00618412f, -0.03663969f, -0.17090182f, 0.09841850f, 0.10206088f, -0.08347397f, 0.10433057f, 0.08390689f, 
    0.10524450f, 0.06664011f, -0.07505653f, -0.09678024f, 0.00568488f, 0.03170966f, -0.01671086f, -0.03594859f, 
    0.01544240f, 0.06577664f, 0.06907382f, -0.00219596f, -0.40817529f, -0.04925999f, 0.01139259f, -0.01857376f, 
    0.20872563f, 0.12066133f, 0.02349686f, 0.00239990f, 0.06283255f, 0.02196919f, -0.00234808f, 0.12808098f, 
    -0.06910593f, 0.03792939f, 0.01485803f, 0.08325928f, 0.01852245f, -0.01898081f, -0.00938495f, 0.04493859f, 
    0.39436334f, -0.03743906f, 0.15001792f, -0.08523004f, -0.19770966f, 0.07269815f, -0.04033786f, 0.06371814f, 
    -0.08492140f, 0.13230449f, 0.17509955f, 0.02416141f, 0.09779479f, 0.06185191f, -0.01391866f, -0.05409421f, 
    -0.05421026f, 0.09949749f, -0.05834205f, 0.01965513f, 0.12405425f, 0.06628640f, 0.12658583f, -0.17830601f, 
    -0.26969329f, 0.08379368f, -0.00675243f, -0.06265037f, -0.07784200f, -0.08201618f, 0.00168998f, -0.01080212f, 
    0.05053603f, -0.10797245f, 0.07610944f, -0.02174181f, 0.03009575f, -0.00982945f, 0.09064601f, -0.05720532f, 
    -0.06983691f, 0.12775671f, 0.02743938f, 0.14204895f, -0.03622971f, -0.01769634f, -0.03291097f, 0.03096197f, 
    -0.13454764f, -0.11882666f, -0.00222756f, -0.04641652f, 0.05559253f, -0.01468434f, -0.01132633f, -0.05202811f, 
    0.00326683f, 0.04597737f, -0.01670888f, -0.02411827f, 0.10522737f, 0.01954480f, -0.24469426f, -0.10421756f, 
    -0.23815767f, 0.10690998f, -0.04952336f, -0.03089661f, -0.02185571f, 0.08233614f, 0.09207282f, 0.01562069f, 
    -0.09405103f, 0.04311637f, -0.00987665f, 0.09273201f, 0.01157680f, -0.11850800f, 0.05181003f, 0.07552254f, 
    0.18825215f, 0.00745879f, -0.09485773f, -0.06293543f, -0.20329468f, 0.05959409f, -0.07073725f, 0.08740059f, 
    0.02331173f, -0.02463808f, -0.03824459f, -0.05363014f, 0.03841230f, 0.05425202f, 0.08843749f, -0.04221972f, 
    0.06867608f, 0.19813149f, 0.05203198f, 0.05811089f, 0.15705381f, 0.13134634f, 0.01841831f, -0.13597868f, 
    0.05561126f, 0.08289854f, -0.13866331f, 0.07629723f, -0.00497639f, 0.06040822f, 0.09278255f, -0.03167220f, 
    0.02636952f, 0.06195736f, -0.04553948f, 0.07353709f, 0.02383172f, 0.13083196f, -0.02469564f, -0.04102152f, 
    0.16582052f, -0.24937925f, -0.08668190f, 0.13451917f, -0.22037989f, 0.11030049f, -0.07247800f, -0.12339802f, 
    0.08456638f, 0.00110427f, 0.08391618f, -0.02163462f, 0.04788976f, 0.08318090f, 0.06734063f, 0.26416361f, 
    0.16967598f, 0.00567429f, 0.13713028f, 0.16044264f, -0.12983486f, 0.04715930f, -0.01208598f, 0.01692585f, 
    0.08166572f, 0.02042652f, 0.05919658f, 0.08776139f, 0.06318714f, -0.02379229f, 0.08523712f, 0.08342353f, 
    -0.05010300f, -0.11067286f, 0.01713338f, -0.00441594f, 0.03798804f, -0.15066381f, -0.03912889f, 0.00324073f, 
    -0.15496206f, 0.25654855f, -0.11909360f, 0.08823391f, -0.15107076f, -0.12377708f, 0.06271341f, 0.08214539f, 
    -0.06686404f, -0.03402816f, 0.05157246f, -0.05673958f, 0.09200504f, -0.04556252f, -0.11908688f, 0.02507526f, 
    0.00159434f, 0.08532460f, 0.07141569f, -0.04108591f, -0.06765358f, -0.00872105f, -0.20066331f, 0.01677386f, 
    0.26270860f, 0.02888211f, 0.04004820f, 0.02738295f, 0.11178208f, -0.00735113f, -0.04098046f, 0.05066565f, 
    0.05610703f, -0.04083499f, 0.03966290f, 0.05740950f, -0.02219323f, 0.03940292f, -0.03666606f, 0.18043169f, 
    0.04592388f, -0.04383059f, 0.01830007f, -0.05716297f, -0.01684274f, 0.04571650f, 0.04610735f, 0.01594725f, 
    -0.00670414f, 0.00988026f, -0.06071224f, -0.05902136f, -0.04590828f, -0.01224163f, 0.01186228f, 0.02738975f, 
    -0.03008954f, 0.04592204f, -0.02869136f, -0.04936653f, -0.00356453f, -0.05438538f, 0.04274531f, -0.03577134f, 
    0.00682697f, -0.02269784f, -0.01452768f, 0.04199607f, -0.00359994f, -0.03354284f, -0.02134124f, -0.03361858f, 
    -0.03192516f, -0.05015568f, 0.04325311f, 0.03847975f, -0.00667193f, 0.01675720f, -0.00514658f, -0.04629894f, 
    -0.02377517f, 0.04280781f, -0.05278922f, 0.04216999f, -0.05007679f, 0.00734845f, 0.04482869f, 0.04552845f, 
    0.01396875f, 0.04281403f, 0.04462326f, -0.01563449f, -0.04071113f, -0.05425429f, -0.02360643f, -0.02947149f, 
    -0.00895701f, -0.05568388f, -0.00980545f, 0.03091646f, -0.03511447f, -0.01544204f, -0.02506839f, 0.00409018f, 
    -0.00216241f, 0.01934926f, 0.03693295f, -0.04365334f, -0.05809398f, 0.02192150f, 0.02275191f, -0.01873498f, 
    -0.01164981f, 0.00135918f, 0.01647676f, -0.03616541f, 0.01186785f, 0.05331208f, 0.01048358f, -0.01825758f, 
    -0.03623374f, -0.00931826f, 0.01231314f, 0.04015357f, -0.00708258f, 0.02957394f, -0.00583956f, 0.02597531f, 
    0.01829357f, -0.05722127f, 0.03540593f, 0.03267368f, 0.04418359f, -0.01899937f, -0.03389155f, -0.02571256f, 
    0.02042281f, 0.00235795f, 0.00377972f, -0.05756446f, -0.02739915f, -0.00963612f, 0.00957776f, -0.01210296f, 
    0.01775186f, 0.00905818f, 0.01635336f, 0.04021711f, -0.04062881f, -0.02203309f, -0.03890697f, -0.01546784f, 
    -0.05428098f, -0.05813886f, 0.03985275f, 0.02876003f, -0.03639533f, 0.03033473f, 0.02888380f, -0.05415386f, 
    0.02198379f, -0.04670427f, -0.02414872f, -0.00801008f, 0.02621447f, 0.00591792f, 0.00887714f, -0.02266443f, 
    -0.02170984f, -0.02791714f, 0.00872778f, -0.05064233f, -0.05249668f, 0.03107008f, 0.03460854f, 0.04295107f, 
    -0.04682028f, 0.04489046f, -0.02514596f, -0.06019596f, -0.03041285f, -0.04315348f, -0.00827507f, 0.01855166f, 
    -0.03103205f, -0.00169865f, -0.02356929f, -0.00306792f, -0.05229226f, 0.04811529f, 0.00669030f, 0.00932341f, 
    -0.01954719f, -0.05400291f, 0.04816323f, -0.02426872f, 0.03344940f, -0.00753452f, 0.00903288f, -0.02020061f, 
    -0.06023642f, 0.00494816f, -0.01355163f, -0.03451841f, 0.04551572f, -0.04024305f, -0.03552042f, -0.04386286f, 
    -0.00928642f, -0.02998262f, -0.03456362f, 0.01824180f, 0.03523020f, 0.01721776f, -0.00292128f, 0.03161530f, 
    0.04367651f, 0.03472954f, 0.04856921f, -0.01247541f, 0.04795629f, -0.04831157f, 0.03136151f, -0.03611594f, 
    -0.00965025f, 0.03786511f, -0.00203519f, -0.05025971f, -0.01436505f, -0.02611922f, -0.01389785f, 0.00013937f, 
    -0.02408085f, 0.02166920f, 0.04938338f, -0.03129492f, 0.03092461f, -0.04726091f, 0.03693396f, -0.05199893f, 
    -0.00592556f, -0.04907125f, -0.03145375f, -0.02076108f, 0.02883272f, 0.02062056f, -0.02006257f, -0.00473962f, 
    -0.01555320f, -0.04803878f, -0.05909120f, -0.03651424f, 0.04878015f, -0.04722431f, 0.01812592f, 0.00908750f, 
    -0.00400511f, -0.02724285f, -0.03472658f, 0.04239786f, 0.02099634f, 0.04555601f, -0.01833378f, 0.04026674f, 
    -0.02525998f, -0.00706070f, -0.05117590f, 0.00035938f, 0.02972207f, -0.03348950f, -0.01320547f, 0.02926420f, 
    -0.05782412f, -0.03501506f, 0.02171330f, -0.01466405f, 0.01338661f, -0.03406973f, -0.03801095f, 0.00349170f, 
    -0.04726873f, 0.02060560f, -0.02615101f, -0.00818269f, -0.02032621f, -0.04125237f, 0.00202475f, 0.04037594f, 
    -0.04782493f, -0.02826820f, -0.00336495f, 0.01466931f, -0.04587397f, -0.01278571f, -0.00965844f, 0.04146998f, 
    -0.04917128f, 0.02931736f, 0.00384057f, -0.02833538f, 0.01342922f, -0.05632900f, 0.03260209f, 0.04733513f, 
    -0.05493507f, 0.04152426f, -0.00860808f, -0.01279998f, -0.05926368f, 0.00083546f, -0.03013520f, -0.02088796f, 
    -0.00563675f, -0.05661907f, -0.00697878f, -0.01693812f, 0.00561221f, -0.04855210f, -0.05387354f, -0.01941178f, 
    -0.06095105f, -0.05175852f, 0.04588974f, -0.05675959f, 0.03525985f, -0.05119118f, 0.03639275f, -0.05494075f, 
    -0.04005223f, -0.04333038f, 0.04071038f, -0.01486733f, -0.01206918f, -0.01310579f, 0.03531467f, -0.05386081f, 
    -0.00121567f, 0.00816777f, -0.00378667f, 0.04402081f, 0.01506018f, -0.01880181f, -0.04452075f, -0.06002554f, 
    -0.03056604f, -0.03019881f, -0.03768935f, -0.04318884f, 0.03246342f, -0.00447098f, 0.00508470f, 0.02684261f, 
    -0.03509880f, -0.04938268f, 0.04834876f, -0.00679409f, -0.02095609f, 0.03055313f, -0.05000038f, 0.03971517f, 
    -0.07030698f, -0.05152200f, -0.41353044f, -0.09967384f, 0.04987843f, 0.12537441f, 0.03666541f, 0.10815700f, 
    -0.23009613f, -0.08412868f, 0.08286897f, -0.07166892f, 0.03616958f, -0.11111978f, 0.02358240f, 0.09582363f, 
    -0.11012199f, 0.00494244f, -0.11431045f, 0.04605443f, 0.06695001f, -0.18487491f, -0.44206828f, 0.10355854f, 
    -0.23489849f, -0.00945238f, -0.10874161f, -0.15262167f, -0.07107852f, 0.07012730f, 0.07240950f, 0.07067072f, 
    0.00730352f, -0.03439409f, 0.12079759f, 0.07169793f, 0.00285425f, -0.12127580f, 0.21398579f, 0.13149573f, 
    0.14939734f, 0.34127054f, 0.00569587f, -0.18378961f, -0.02696557f, -0.11048783f, -0.11924822f, 0.08787408f, 
    -0.06748961f, 0.09274166f, -0.04913944f, 0.04350233f, -0.05230555f, -0.32681069f, -0.12627169f, 0.10735837f, 
    -0.04223665f, -0.07268056f, -0.15482000f, -0.11373490f, -0.06253855f, -0.05228318f, 0.32432616f, -0.43507099f, 
    0.14339486f, 0.04938240f, -0.10058007f, 0.14501438f, -0.05090033f, 0.09168682f, 0.14636554f, 0.07294473f, 
    0.12673821f, 0.02211127f, 0.08557840f, 0.03589480f, 0.18242988f, 0.24610309f, 0.03661926f, 0.09823774f, 
    -0.06531337f, -0.20920189f, -0.19004253f, -0.10049248f, 0.06508979f, 0.07333459f, -0.11131508f, -0.04633784f, 
    -0.13959241f, 0.01720396f, 0.17866257f, 0.07424423f, 0.12551293f, 0.07436762f, 0.05356444f, -0.01450624f, 
    -0.02729483f, -0.08414375f, -0.10972971f, -0.08030133f, -0.16322622f, 0.02784040f, 0.01352489f, 0.09250775f, 
    -0.02337401f, -0.06685273f, -0.10195944f, -0.02465900f, -0.16187477f, 0.14146142f, 0.11449043f, 0.01138291f, 
    0.07185921f, 0.09563505f, -0.00025288f, 0.13533102f, -0.10166378f, -0.04181582f, 0.03082991f, 0.09634297f, 
    -0.36022133f, -0.16953392f, 0.10492226f, 0.19424491f, -0.16934372f, 0.11351603f, 0.18482816f, -0.00308311f, 
    0.06658621f, 0.16816573f, 0.01314718f, -0.18847962f, -0.05368353f, 0.03407118f, -0.01934307f, 0.01714256f, 
    0.02439438f, 0.00196928f, 0.14403188f, -0.01261534f, -0.01451692f, 0.19817744f, 0.39267421f, 0.04917593f, 
    -0.11286344f, 0.07483453f, 0.07421488f, -0.03093527f, 0.06335606f, 0.15350281f, 0.05206804f, -0.09743360f, 
    0.08922606f, 0.01552178f, 0.06995383f, -0.02811253f, -0.03796687f, 0.02881917f, 0.12318272f, 0.09954751f, 
    -0.05643983f, 0.32163161f, 0.49782616f, -0.17433295f, -0.03821192f, -0.04456615f, 0.00912133f, -0.16845626f, 
    -0.00301778f, 0.13673806f, 0.01148471f, 0.13781013f, 0.16393097f, 0.09807760f, 0.05071103f, 0.03100418f, 
    -0.08541033f, 0.02772357f, -0.14169306f, 0.06886590f, -0.22740933f, 0.17759965f, 0.28680649f, -0.07816919f, 
    -0.11995539f, 0.09835725f, -0.00544658f, -0.03477080f, 0.01489523f, 0.16692373f, -0.11452594f, -0.20029923f, 
    0.00295804f, 0.09214242f, -0.10079500f, -0.07305180f, -0.02156388f, 0.18556997f, 0.03580636f, 0.02841033f, 
    0.21979229f, -0.15737075f, -0.25756210f, -0.06978588f, 0.44625360f, 0.07671117f, 0.12529141f, 0.32665145f, 
    0.09176618f, -0.00144999f, 0.04869494f, 0.01503347f, -0.01484952f, -0.05886145f, -0.02715852f, 0.02285546f, 
    0.16669635f, 0.01715487f, -0.08880503f, 0.00530160f, 0.04639612f, -0.12491820f, 0.48263481f, 0.07688250f, 
    -0.17374840f, 0.10496713f, -0.02086404f, 0.22621509f, 0.14288449f, 0.06446977f, -0.00182529f, -0.10677337f, 
    -0.16943021f, -0.16942790f, -0.16150101f, -0.10349829f, 0.01206378f, -0.02363396f, 0.03890022f, 0.08622030f, 
    -0.04108087f, 0.20736650f, -0.15674122f, -0.20930660f, 0.02997189f, 0.07753047f, -0.17510709f, -0.00270128f, 
    0.17391758f, -0.03894097f, -0.06333943f, 0.15073210f, 0.23895711f, 0.07713294f, 0.10199812f, -0.10719463f, 
    -0.01912272f, 0.26638108f, 0.14517561f, -0.00085522f, -0.13008548f, 0.06347635f, -0.13764240f, 0.05447862f, 
    -0.00107960f, 0.11088416f, -0.22645071f, -0.10948296f, -0.13396852f, 0.02019037f, -0.00457581f, 0.09392919f, 
    0.06056797f, 0.04666463f, 0.08646786f, 0.00847407f, 0.06351446f, -0.01482570f, 0.04369628f, 0.05097723f, 
    -0.02651771f, -0.33056045f, 0.00727988f, 0.13604350f, -0.15524735f, -0.07690131f, 0.31227568f, 0.01003578f, 
    -0.07235265f, 0.11053273f, 0.26437449f, 0.00811660f, -0.14343335f, -0.17472140f, 0.12841994f, 0.03743513f, 
    -0.09088910f, 0.02439748f, 0.01544576f, -0.17085932f, -0.02773793f, 0.17530352f, -0.02522544f, -0.05804150f, 
    0.22514853f, -0.01191731f, -0.21220993f, -0.16281387f, -0.17461598f, -0.11286784f, 0.13020770f, 0.15055335f, 
    0.01542782f, 0.09374503f, -0.09830906f, -0.02578372f, 0.03474979f, 0.05359643f, 0.01619079f, -0.02557981f, 
    0.04024711f, 0.00674517f, 0.03031868f, -0.00483034f, 0.00433817f, 0.00500648f, 0.04496598f, 0.01993603f, 
    0.00162008f, -0.02057272f, -0.00361341f, 0.04548270f, -0.05613123f, 0.05310063f, 0.01800277f, 0.02879336f, 
    -0.04604272f, 0.02274233f, -0.00837733f, 0.00010924f, 0.01321673f, 0.03940683f, -0.05809941f, -0.00190762f, 
    -0.04686778f, -0.01359586f, -0.00725429f, 0.04462751f, 0.01304034f, 0.00201703f, -0.04988271f, 0.01841602f, 
    -0.03514276f, 0.00940441f, -0.00917962f, 0.04288905f, 0.02472718f, -0.05219812f, -0.01650610f, 0.04414297f, 
    0.03731198f, -0.03423646f, 0.00013912f, -0.03117210f, 0.03662756f, 0.00089995f, 0.01108933f, -0.04320260f, 
    -0.00700996f, -0.04227542f, -0.04281929f, -0.02765455f, -0.05172950f, -0.02923464f, -0.03883681f, -0.05359793f, 
    -0.02204167f, 0.04028472f, 0.04403825f, 0.04325968f, 0.01757676f, 0.00604564f, -0.00959526f, 0.04606083f, 
    -0.01721017f, -0.04929157f, 0.04670781f, -0.06234771f, 0.01845073f, -0.06319639f, -0.04112794f, -0.01986710f, 
    0.01366119f, -0.00172949f, -0.02736903f, 0.02985076f, -0.03955586f, -0.04095675f, -0.06424540f, -0.03686497f, 
    0.03227875f, -0.01274065f, 0.03032745f, -0.05928100f, -0.01676753f, -0.05424228f, -0.02628809f, 0.03170845f, 
    -0.00788173f, 0.01877336f, 0.00262176f, 0.03495089f, -0.02763308f, -0.04386960f, -0.01203939f, 0.02937469f, 
    0.01975850f, -0.03370659f, -0.03867215f, -0.04494949f, -0.04801356f, -0.03419620f, 0.00838165f, -0.04252768f, 
    -0.00596284f, -0.02881612f, -0.00985606f, 0.03761164f, 0.04077474f, -0.02673034f, 0.00834415f, -0.02615879f, 
    0.02658470f, 0.01015448f, 0.04320074f, 0.02559671f, -0.00435972f, -0.01429211f, 0.01941676f, -0.01252959f, 
    -0.03672044f, -0.01307226f, 0.01021014f, -0.01471271f, -0.04415551f, 0.02030205f, -0.02578708f, -0.06156693f, 
    -0.01218818f, -0.00008094f, 0.01266539f, -0.02426449f, 0.01567426f, -0.05175873f, 0.00061927f, -0.02482735f, 
    -0.01225674f, -0.01600164f, -0.05929104f, 0.00102903f, -0.00063576f, -0.00056293f, 0.01194726f, -0.06105972f, 
    -0.03143201f, -0.00792242f, 0.04044636f, -0.05873189f, -0.04170201f, 0.02701817f, -0.03763123f, -0.02324817f, 
    -0.00206792f, -0.01789865f, 0.02145202f, -0.01507313f, -0.01803030f, 0.04261651f, -0.00169778f, -0.01532666f, 
    -0.05275298f, -0.02513350f, -0.01821083f, -0.04910834f, 0.01181777f, 0.03888564f, 0.01985339f, -0.00390122f, 
    0.02411637f, -0.03611976f, 0.03440285f, 0.02748437f, 0.02222786f, -0.00850288f, -0.06132973f, -0.04037664f, 
    0.04000024f, 0.04015299f, -0.06053669f, -0.01541269f, 0.01888306f, 0.02579837f, -0.05511392f, 0.02140387f, 
    0.01286694f, 0.02040983f, 0.02900954f, 0.01223874f, 0.04700771f, -0.01088772f, 0.01459429f, -0.03182366f, 
    -0.00201663f, -0.00516964f, -0.04503625f, 0.02863076f, -0.05345980f, 0.00029917f, 0.03590828f, -0.03386785f, 
    0.00305456f, -0.04286482f, 0.03104304f, 0.02285146f, -0.05099228f, 0.02829785f, -0.04360955f, -0.03281231f, 
    -0.00158033f, -0.03151383f, -0.02508263f, -0.02424811f, -0.04917869f, 0.03056339f, 0.01000975f, 0.04691867f, 
    0.02757153f, -0.05588659f, 0.00751090f, -0.00610440f, -0.03406280f, 0.00722969f, 0.01321268f, 0.03144335f, 
    -0.06081518f, 0.01792281f, -0.03092114f, -0.02804671f, -0.03667448f, 0.04068128f, -0.06190328f, 0.01767778f, 
    0.01448010f, 0.02760281f, 0.02189770f, -0.01281669f, -0.01967576f, -0.06112836f, -0.02409664f, 0.00908644f, 
    0.01646660f, -0.05534631f, 0.00134063f, -0.00260482f, -0.02143599f, -0.00862044f, 0.00566915f, -0.06473407f, 
    -0.03564134f, -0.02794981f, -0.00397443f, 0.01364319f, 0.00959274f, -0.05626326f, -0.00544396f, -0.04661874f, 
    0.01761850f, -0.06008413f, 0.02706758f, -0.06745531f, -0.02882061f, -0.02335841f, 0.03463069f, -0.06136180f, 
    -0.02140991f, -0.05179091f, 0.01970775f, -0.01147354f, -0.00841518f, -0.02012439f, 0.00966406f, 0.01082834f, 
    0.04067669f, 0.04598644f, 0.03229957f, 0.04149951f, -0.02492495f, -0.01997142f, -0.01592000f, 0.00446782f, 
    0.01186130f, 0.03873047f, 0.03954482f, -0.00858827f, 0.01850439f, -0.05992629f, 0.03407893f, -0.01460557f, 
    0.04296379f, -0.01249648f, -0.02788989f, -0.05274851f, -0.00056180f, -0.03290331f, -0.03813736f, -0.02131110f, 
    -0.00508334f, 0.01268915f, -0.00953075f, 0.02171815f, 0.00197055f, 0.04223566f, -0.00408212f, -0.00036947f, 
    0.02793242f, 0.04773052f, -0.01281705f, 0.02007263f, -0.04500231f, 0.01459347f, -0.00577114f, 0.00368742f, 
    -0.00601633f, -0.00329047f, -0.04570567f, -0.05839852f, -0.00830856f, -0.04008567f, -0.05511105f, -0.01454824f, 
    0.27899995f, 0.18988554f, 0.07243604f, 0.04845645f, 0.24388514f, -0.02904820f, -0.05169297f, -0.01061092f, 
    -0.07186252f, 0.02312824f, 0.01979954f, 0.00819208f, -0.07279395f, -0.01556837f, 0.05097795f, -0.06453677f, 
    0.01627140f, -0.13977124f, -0.09304435f, -0.00164368f, -0.23487817f, 0.06287686f, 0.15502839f, -0.08425421f, 
    0.04985189f, -0.14532591f, -0.00807575f, 0.16024923f, -0.04985511f, 0.09069703f, -0.18322852f, 0.07868856f, 
    -0.06596421f, -0.03816111f, 0.10496603f, -0.05097640f, 0.13711104f, -0.01430650f, -0.10184544f, 0.23382059f, 
    -0.10379813f, 0.02959912f, 0.02013241f, -0.05536793f, -0.03541845f, -0.00610137f, 0.06645550f, 0.04749738f, 
    0.04689240f, 0.11698426f, 0.13884591f, -0.07258695f, -0.08368129f, 0.02481636f, -0.03987153f, 0.04475202f, 
    -0.01998401f, 0.09100804f, -0.12614904f, -0.13453421f, 0.54669958f, 0.25728443f, -0.04327585f, 0.17846698f, 
    -0.13475595f, 0.11367985f, 0.08140167f, -0.08410844f, 0.09716063f, -0.03645957f, 0.24694271f, 0.18156546f, 
    0.12132885f, 0.08499622f, -0.09198610f, 0.23447073f, 0.18062139f, 0.22516224f, 0.00600069f, -0.08767518f, 
    0.17677908f, 0.05583339f, 0.00887720f, 0.12469460f, 0.13305138f, 0.03220446f, -0.07936956f, -0.06861553f, 
    -0.02644794f, 0.05407912f, 0.09242034f, 0.05574687f, -0.04148410f, 0.02222798f, -0.03450634f, -0.05172889f, 
    -0.09332262f, -0.12154502f, -0.03031980f, -0.09817567f, 0.13297816f, 0.09387247f, 0.19964078f, 0.20892952f, 
    0.15039422f, 0.01777354f, 0.04978889f, 0.05929551f, 0.01723653f, 0.00108135f, 0.11351500f, -0.01923111f, 
    -0.00083064f, 0.04884384f, 0.15284081f, 0.04597401f, 0.08080209f, 0.02890117f, 0.02180644f, -0.05880303f, 
    -0.34691912f, -0.29445374f, -0.71017510f, -0.52311575f, 0.05212036f, -0.03445242f, 0.06699764f, -0.05929118f, 
    -0.22934850f, 0.07262357f, -0.04310846f, 0.03826439f, 0.06609351f, 0.05616069f, 0.03028306f, -0.09575298f, 
    -0.06073441f, -0.05677941f, 0.26600164f, 0.11963278f, -0.51754719f, 0.02667734f, -0.12438347f, -0.13288385f, 
    -0.14814886f, -0.17250220f, 0.19089359f, -0.02757383f, -0.06643791f, 0.02971562f, 0.03601431f, 0.09194725f, 
    0.12154243f, 0.04517499f, -0.02837306f, -0.06690712f, 0.07272551f, -0.03168533f, 0.12642026f, 0.09353110f, 
    -0.37355471f, -0.08441032f, -0.17908089f, -0.14544642f, -0.09428004f, 0.11770387f, -0.01528803f, 0.05413271f, 
    0.01230127f, 0.01484460f, 0.06254990f, 0.20184234f, -0.00444908f, 0.00567178f, 0.05516929f, 0.06083011f, 
    -0.03162076f, 0.00786696f, -0.03073697f, 0.03156162f, -0.58386660f, -0.26358923f, -0.33838913f, -0.42481795f, 
    0.01352874f, -0.16201727f, 0.18157819f, -0.12453330f, -0.14028856f, 0.06297492f, -0.04180298f, 0.11372907f, 
    -0.03513345f, 0.03771497f, 0.00210320f, -0.02999382f, -0.09801234f, 0.08000839f, 0.16813296f, -0.01308855f, 
    0.64176857f, 0.46454620f, -0.17988871f, 0.05186625f, -0.20451662f, -0.09087489f, 0.20991641f, 0.03361601f, 
    0.10420655f, 0.08768523f, 0.01416258f, 0.10968678f, -0.00463501f, 0.15311618f, 0.12775522f, -0.06651256f, 
    0.03907713f, -0.00608495f, 0.02379378f, 0.12071112f, -0.57675815f, 0.00555608f, -0.28036028f, -0.54703754f, 
    -0.16059253f, 0.00649907f, 0.17664213f, -0.00326137f, -0.01048212f, 0.13240880f, -0.04465371f, 0.05604292f, 
    0.00833112f, 0.03606522f, -0.00214315f, -0.10506770f, -0.03838208f, 0.02555443f, -0.01312032f, 0.13603011f, 
    0.00582648f, -0.22407390f, -0.67431521f, -0.25546429f, -0.04259427f, 0.08070629f, 0.08993176f, -0.17935829f, 
    -0.06098105f, 0.03778632f, -0.02762431f, -0.02120717f, -0.06893652f, -0.09035211f, -0.12085774f, 0.09668390f, 
    -0.03489895f, 0.10136443f, 0.11699352f, 0.07919031f, 0.04215446f, -0.00856115f, 0.07577359f, 0.06474792f, 
    0.12444180f, 0.01606395f, -0.09443771f, -0.08245426f, 0.01888863f, 0.09549344f, 0.04674932f, 0.02171371f, 
    -0.01491520f, -0.08651622f, 0.01588098f, -0.04876733f, -0.02079667f, -0.07301499f, -0.10531665f, 0.00189302f, 
    -0.31633231f, -0.05699775f, -0.22310066f, -0.38453734f, 0.13585573f, 0.00822291f, 0.14755967f, -0.08708986f, 
    -0.05305547f, 0.07520051f, 0.04955060f, 0.00131998f, -0.00679712f, 0.02101469f, 0.02309541f, 0.09679181f, 
    -0.13845806f, 0.03809957f, 0.11454380f, 0.04397278f, 0.28799149f, 0.08710281f, 0.11494133f, 0.04159646f, 
    0.18976516f, 0.03886123f, 0.00280822f, 0.02173770f, 0.04454132f, -0.01357718f, 0.16282763f, 0.05303771f, 
    -0.03178729f, -0.08863530f, -0.09826727f, -0.10792847f, -0.00344799f, -0.10655699f, -0.17523579f, -0.07770336f, 
    0.26775396f, -0.03288092f, -0.10032842f, -0.00888313f, 0.09852592f, 0.04263707f, 0.00709304f, 0.02500392f, 
    -0.00410599f, -0.06048138f, 0.10495709f, 0.05730992f, -0.02214741f, -0.02198819f, 0.03884551f, 0.05262178f, 
    -0.02999535f, 0.01570990f, -0.28423715f, 0.02358023f, 0.55680412f, -0.21398070f, -0.21873997f, 0.00273490f, 
    -0.07290593f, -0.01621473f, 0.10112424f, -0.11578185f, -0.18237036f, 0.03219026f, -0.00749439f, 0.15939787f, 
    0.09575035f, 0.02042425f, 0.07973222f, 0.03458261f, 0.04202701f, -0.13865501f, -0.05452581f, 0.10282101f, 
    0.21514602f, -0.00378995f, -0.19217615f, -0.15638369f, 0.10413513f, -0.00757060f, -0.04543878f, -0.11630599f, 
    0.03457514f, -0.01638940f, 0.01859708f, 0.15798329f, -0.03386474f, -0.27852017f, -0.07840463f, 0.02802703f, 
    -0.08859961f, -0.17429006f, -0.07903489f, -0.24240194f, -0.25188312f, 0.08347421f, -0.00982835f, 0.02255740f, 
    0.07739342f, -0.01818883f, 0.06693386f, 0.14456348f, -0.05008846f, -0.16523694f, 0.12073557f, -0.01201668f, 
    0.09055422f, -0.00661359f, 0.00266033f, 0.08570915f, 0.07332080f, 0.10334196f, -0.07927392f, -0.04599869f, 
    -0.00588018f, 0.01076812f, -0.06460338f, -0.06619042f, -0.06234570f, 0.12062546f, 0.00605841f, -0.03587391f, 
    -0.00888229f, 0.00008954f, 0.00090761f, 0.03133112f, 0.07775860f, 0.00919002f, 0.02561242f, 0.04171977f, 
    0.00556189f, -0.16547619f, -0.23783644f, -0.13976204f, -0.04718303f, -0.04750099f, -0.14419410f, -0.21252495f, 
    -0.06821565f, -0.11296053f, 0.07147110f, -0.10548799f, -0.00928895f, 0.06983788f, 0.00467420f, 0.11372627f, 
    0.05243872f, 0.08998641f, -0.01850436f, 0.09408292f, -0.02030957f, -0.02769751f, 0.01742685f, 0.12175723f, 
    0.05515830f, -0.14201565f, 0.27226520f, -0.09958397f, 0.07918216f, 0.03459076f, 0.02974369f, 0.00516361f, 
    -0.07524545f, 0.04690368f, 0.02929329f, -0.03925223f, 0.02536072f, 0.10718339f, 0.01705004f, -0.03739028f, 
    0.05542293f, 0.15481663f, 0.08646494f, -0.00385417f, 0.23803157f, 0.02019999f, 0.25304401f, -0.22842015f, 
    0.01887733f, 0.02500566f, 0.07439335f, -0.01192047f, 0.15134037f, 0.13811693f, -0.03337899f, 0.01942910f, 
    0.11657917f, -0.12794504f, -0.07757572f, -0.04636464f, 0.05420877f, -0.05768688f, 0.14451987f, -0.08626599f, 
    -0.13969280f, 0.12560737f, 0.02793731f, -0.01476202f, 0.05157756f, -0.05564153f, 0.05281217f, 0.00111395f, 
    -0.03477873f, 0.03837857f, 0.01104369f, -0.00099760f, -0.09668398f, 0.06435589f, 0.02158387f, -0.01704654f, 
    -0.13379385f, 0.06670374f, -0.09502287f, -0.13812700f, 0.13941221f, 0.06539147f, -0.18779798f, 0.17928775f, 
    0.10047332f, 0.04619869f, 0.14701627f, 0.20137158f, 0.04463789f, 0.03710918f, -0.12805294f, -0.04923424f, 
    0.05147098f, 0.03032354f, -0.03552400f, -0.04517365f, -0.02637820f, 0.11918350f, 0.09507936f, 0.01594079f, 
    0.32562035f, -0.00349103f, 0.25809908f, -0.04496466f, 0.42312065f, -0.08502122f, 0.06827106f, -0.01149511f, 
    0.12730974f, -0.13619572f, 0.00081761f, -0.00295345f, 0.03849551f, -0.09056339f, -0.02499258f, 0.03473578f, 
    0.08994374f, 0.20391649f, 0.11956339f, 0.00557212f, 0.44006971f, -0.08498871f, 0.29647151f, 0.19879410f, 
    0.04709987f, 0.06674100f, 0.09466629f, 0.09184223f, -0.16827706f, -0.03337326f, 0.09228946f, 0.01776600f, 
    -0.18821850f, -0.05537988f, -0.07933387f, -0.08381935f, 0.01446558f, 0.20987687f, 0.06089435f, 0.01328590f, 
    -0.37152714f, 0.07952441f, -0.29996386f, -0.12771793f, 0.16697088f, 0.00633731f, -0.00694948f, 0.05868336f, 
    0.01260185f, -0.03927315f, -0.09275981f, -0.00641685f, 0.27301353f, 0.18786457f, 0.16502555f, -0.00471658f, 
    0.10661935f, 0.15756263f, 0.10015581f, 0.06161467f, -0.01434402f, 0.13165961f, -0.33064625f, -0.06892318f, 
    0.02064210f, 0.15227914f, -0.03910575f, -0.08883443f, -0.03664303f, 0.03360698f, 0.01536404f, 0.09209393f, 
    0.11120789f, -0.04374450f, -0.01773306f, -0.08572038f, -0.13069421f, -0.14141528f, -0.11015601f, -0.03323877f, 
    -0.02575601f, -0.12781441f, 0.44179508f, 0.28571615f, 0.00777827f, -0.06669172f, 0.09321918f, -0.01076881f, 
    -0.00402117f, -0.03065937f, 0.26561895f, -0.03789894f, -0.08313395f, -0.21452005f, 0.01571753f, -0.06719650f, 
    0.06466912f, 0.09102488f, 0.11437754f, -0.01901150f, -0.19808739f, 0.08003452f, -0.20399629f, 0.05247559f, 
    0.00582872f, 0.04444731f, 0.03758015f, 0.01913304f, -0.05308905f, 0.04991467f, 0.03415768f, 0.03206760f, 
    0.03709259f, 0.07863814f, -0.03433076f, 0.00979809f, 0.14785635f, -0.07241128f, -0.02125203f, 0.04445169f, 
    -0.28383896f, -0.30833644f, 0.16306576f, -0.07709254f, -0.16187543f, -0.01320259f, 0.08081244f, 0.06227605f, 
    0.03051921f, -0.09659702f, -0.09538414f, 0.03625341f, -0.00471682f, 0.14893942f, 0.03258676f, 0.01844430f, 
    0.09189998f, 0.01226234f, -0.03099339f, 0.02261871f, -0.16511965f, -0.08529577f, 0.43729508f, -0.12508897f, 
    -0.10534840f, -0.06956980f, 0.10796325f, 0.01677549f, 0.08933806f, 0.01716908f, -0.05251775f, 0.04218099f, 
    -0.06041066f, 0.12218180f, 0.04922438f, 0.15279482f, -0.04851045f, 0.07871270f, 0.10477558f, -0.11588675f, 
    -0.09431110f, -0.27751791f, -0.18365119f, 0.06073624f, -0.09973637f, -0.06786390f, 0.08330099f, 0.14643706f, 
    0.05116241f, 0.08499685f, -0.04327168f, 0.00869080f, -0.11955559f, -0.06027593f, 0.02038503f, -0.00879784f, 
    0.14160073f, 0.19001000f, 0.06621096f, 0.16306485f, -0.26634407f, 0.23565613f, -0.00022901f, 0.28199309f, 
    -0.02573968f, -0.05521924f, -0.11691841f, -0.05254335f, 0.15173450f, 0.02184408f, 0.02540985f, 0.03166814f, 
    0.03827355f, -0.05710824f, 0.01560638f, 0.06324533f, -0.08758152f, 0.04659142f, -0.08096503f, 0.09012905f, 
    -0.27280298f, -0.30698282f, -0.08840713f, -0.05639994f, -0.28366274f, -0.18133073f, -0.12001848f, -0.03642164f, 
    -0.07308281f, -0.11934038f, -0.06191866f, 0.06605934f, 0.03777832f, -0.12093792f, 0.01812081f, -0.06441262f, 
    -0.10851553f, 0.05633448f, -0.00313749f, 0.08209950f, 0.01509636f, -0.03438617f, -0.05287297f, 0.00102200f, 
    -0.15094541f, -0.13973004f, 0.05853922f, -0.02215504f, -0.03514592f, -0.00594867f, 0.05984779f, 0.08046038f, 
    -0.03319369f, 0.12211802f, 0.06898188f, -0.08957894f, -0.07660110f, -0.12991208f, 0.08997240f, 0.05739027f, 
    0.14852604f, 0.26806882f, -0.08029652f, -0.24564081f, 0.23793770f, 0.09855571f, 0.02432887f, -0.03318452f, 
    -0.00217464f, -0.04858990f, -0.07894179f, 0.07208414f, -0.05656065f, -0.06579815f, 0.00860250f, 0.07009236f, 
    -0.09331448f, 0.04695682f, -0.02060894f, -0.17092529f, -0.03390395f, 0.05125429f, -0.14022408f, 0.04280784f, 
    0.24665961f, 0.12000981f, 0.18744045f, 0.00065538f, 0.03275764f, -0.03477621f, -0.03621467f, -0.07607512f, 
    -0.08716104f, -0.02213609f, 0.06230548f, 0.04785533f, 0.04302024f, 0.10578621f, -0.02426670f, -0.07422301f, 
    -0.17979632f, 0.06844859f, -0.21514477f, -0.07320252f, -0.00035724f, 0.13527632f, 0.13307811f, 0.14830597f, 
    -0.05524220f, 0.07048960f, -0.12922543f, 0.00699891f, -0.07829699f, -0.11744282f, -0.03674507f, 0.09397548f, 
    0.09487881f, 0.05441571f, 0.11986297f, 0.14750415f, 0.26819777f, 0.33078110f, -0.00161417f, 0.04944586f, 
    0.16883758f, 0.10166844f, 0.18303657f, 0.20176001f, 0.01354673f, 0.08844379f, 0.02424713f, -0.04329235f, 
    -0.02178268f, -0.06335806f, 0.02695165f, 0.00353761f, -0.03440226f, 0.06096104f, 0.01786553f, 0.00264554f, 
    -0.10541202f, -0.05089878f, 0.04250693f, 0.22911587f, 0.05229426f, -0.01056696f, -0.05816848f, -0.06062252f, 
    -0.01215178f, -0.13828188f, 0.12302869f, 0.01263075f, -0.05943402f, 0.00665672f, -0.07423098f, 0.01824794f, 
    -0.04366982f, 0.11956944f, -0.07329914f, -0.02527149f, 0.29287529f, 0.14836581f, -0.12537806f, -0.06004195f, 
    0.11021081f, 0.15692824f, 0.09363548f, -0.02779064f, 0.02386167f, 0.00440051f, -0.05969488f, -0.00892170f, 
    -0.03366136f, -0.01698709f, 0.05475221f, 0.06680536f, 0.04470718f, 0.07466999f, 0.06014540f, 0.11556048f, 
    0.28145841f, 0.38705328f, -0.11950080f, -0.04973046f, 0.12093382f, 0.18839429f, 0.13744007f, 0.08859012f, 
    -0.05740669f, 0.09261548f, -0.01629249f, 0.08405796f, -0.10272045f, 0.01545860f, -0.03914179f, -0.03613507f, 
    -0.19059806f, 0.02373970f, -0.08560330f, -0.14459236f, -0.02589220f, -0.14520130f, 0.09009269f, -0.00172063f, 
    -0.13445915f, -0.03732752f, 0.09499322f, 0.00668675f, 0.00720347f, -0.07159170f, 0.06517322f, 0.04976618f, 
    0.06342462f, 0.04962372f, 0.06650559f, -0.03472877f, 0.13589591f, 0.07830739f, 0.10796713f, 0.11658787f, 
    0.19068055f, 0.20306006f, 0.04899938f, -0.29871216f, 0.14837968f, 0.01639020f, 0.00039047f, 0.11927083f, 
    0.14633773f, -0.00432177f, 0.04638926f, 0.11426964f, -0.03791530f, 0.01472944f, 0.06369808f, 0.09645998f, 
    0.02506797f, 0.07449663f, 0.10826551f, 0.24988784f, -0.36052990f, -0.21161082f, -0.01572927f, -0.13694613f, 
    -0.30872947f, -0.02594320f, -0.04907300f, 0.00230747f, -0.01746915f, -0.13553877f, -0.03964404f, 0.07849697f, 
    0.10212961f, 0.01784636f, 0.11365751f, -0.08212956f, 0.03590440f, -0.07297631f, 0.05968780f, -0.09710015f, 
    -0.12260332f, -0.01303151f, 0.29061812f, 0.08009265f, -0.18079272f, -0.03648428f, 0.11920260f, 0.03581919f, 
    0.03996866f, 0.02839167f, -0.07327582f, -0.10693505f, -0.00497979f, 0.00120286f, -0.13759588f, 0.00323061f, 
    -0.11031876f, 0.07395731f, 0.14423423f, -0.02471439f, 0.36596179f, 0.05764194f, -0.02680491f, 0.26909807f, 
    -0.09347031f, 0.19445188f, -0.08468860f, 0.01178913f, -0.04349806f, -0.18414721f, 0.17117658f, -0.11870129f, 
    0.05142809f, -0.11085185f, 0.00394804f, -0.04542750f, 0.14398463f, 0.23380977f, -0.01244581f, -0.07997537f, 
    -0.22656745f, -0.11964857f, 0.02243505f, 0.02395499f, -0.05540704f, 0.12409264f, -0.06480066f, -0.07523762f, 
    0.07053203f, -0.07386723f, -0.07447121f, -0.09098922f, 0.08036546f, 0.20736149f, 0.02507291f, 0.17878546f, 
    0.13846780f, 0.12972346f, 0.09919510f, 0.04955426f, 0.19217840f, 0.07389779f, 0.10941615f, -0.09064081f, 
    0.25605023f, -0.01389780f, 0.07926897f, 0.02863622f, 0.14388277f, 0.16219872f, 0.03705080f, 0.11316890f, 
    0.02128861f, 0.01507270f, 0.05946998f, 0.05046377f, 0.02753659f, -0.09136219f, 0.32573941f, 0.11517416f, 
    -0.11153436f, 0.04833570f, 0.09207188f, 0.00432400f, -0.06154458f, -0.16677697f, -0.01260911f, -0.08858888f, 
    -0.05191094f, -0.10233941f, 0.04057181f, -0.03172027f, -0.07205117f, 0.00173965f, 0.02205644f, -0.03295403f, 
    -0.02342482f, 0.11102137f, 0.19316778f, -0.01917801f, 0.06127394f, 0.10286296f, 0.12689021f, -0.00286924f, 
    0.16583851f, -0.03449990f, 0.03561887f, 0.08941073f, -0.02596208f, -0.07248441f, 0.02042250f, 0.02550944f, 
    0.14339195f, -0.10179179f, -0.04508504f, 0.14636745f, 0.04168082f, 0.21836115f, 0.07986393f, -0.08106089f, 
    -0.22183478f, -0.05626335f, -0.00193349f, 0.24814087f, -0.11035253f, -0.13274556f, -0.19258361f, -0.07108964f, 
    0.11102492f, -0.02335272f, -0.01154086f, 0.02403127f, 0.02052716f, -0.11159515f, -0.07841225f, 0.02718972f, 
    0.05229438f, -0.02236433f, -0.29968810f, -0.10464543f, 0.01990556f, -0.04736984f, -0.13995825f, 0.32651326f, 
    0.00950774f, 0.04693433f, -0.05256537f, 0.05327096f, -0.03870376f, 0.13577145f, -0.00077845f, 0.06121124f, 
    -0.00108113f, 0.24794720f, -0.03505162f, 0.14559360f, 0.06379485f, 0.12642798f, -0.04033730f, 0.15134868f, 
    0.11017764f, -0.30059391f, 0.06044613f, 0.14347324f, -0.08866901f, -0.09788167f, -0.07077891f, 0.01534780f, 
    0.10235839f, 0.05425459f, 0.04510746f, 0.00731549f, 0.04831327f, 0.02190144f, -0.00961250f, 0.02429431f, 
    0.04466180f, 0.03387403f, 0.12324856f, 0.10984921f, -0.12857869f, -0.32894447f, 0.12143345f, -0.08721725f, 
    -0.01153175f, -0.06123675f, -0.01925430f, -0.08051176f, 0.08473755f, -0.05498123f, -0.07068127f, -0.10718114f, 
    0.13475142f, -0.03031515f, -0.05306282f, 0.18531683f, 0.10578356f, -0.04339337f, 0.01471342f, -0.04013998f, 
    0.07941170f, 0.00142453f, 0.11925124f, 0.10516311f, -0.15191515f, 0.18190654f, 0.04779011f, -0.05114320f, 
    -0.10301057f, 0.17043245f, 0.01415544f, 0.05073233f, 0.01764035f, -0.05125109f, 0.01428960f, 0.10067938f, 
    -0.05050986f, -0.20197293f, -0.03000692f, -0.22882667f, -0.26760641f, -0.23943356f, -0.20437790f, 0.12055599f, 
    -0.12022272f, -0.08430219f, -0.15091127f, -0.07056374f, 0.11619367f, -0.05161270f, -0.08992998f, 0.07418785f, 
    0.06180060f, -0.02740826f, 0.01348451f, 0.11643089f, 0.13313118f, 0.06595192f, -0.26805511f, -0.00983124f, 
    -0.05357989f, -0.05458576f, 0.34335226f, 0.08821981f, -0.01768418f, -0.02736573f, -0.10019118f, 0.02587567f, 
    0.04161051f, 0.00198878f, 0.13304526f, -0.19665980f, -0.05039311f, -0.13374388f, 0.06156585f, 0.10620678f, 
    -0.03911033f, -0.10419129f, -0.00397915f, -0.04552398f, 0.08856140f, 0.00542287f, -0.01641776f, -0.02758223f, 
    -0.04390633f, -0.02853264f, 0.11485052f, -0.03344756f, 0.01342188f, -0.02193069f, 0.05141060f, -0.01433798f, 
    0.04885565f, 0.14677365f, -0.03743142f, 0.10826298f, 0.03912016f, 0.18816517f, 0.18261647f, 0.06318315f, 
    0.14558737f, -0.14359707f, 0.06824621f, -0.02884336f, -0.00929071f, 0.17054498f, -0.21477245f, 0.04835659f, 
    0.26635492f, 0.09459312f, -0.25719097f, 0.04218390f, 0.12699026f, 0.11390124f, 0.06634536f, 0.14146985f, 
    0.12673381f, -0.01955009f, -0.01888424f, -0.05406963f, -0.13412371f, -0.20168075f, 0.01887474f, -0.01779801f, 
    -0.05478894f, -0.12306860f, -0.07654468f, -0.12058228f, -0.06290513f, -0.12071666f, -0.13105136f, -0.08201315f, 
    -0.09120931f, -0.02715732f, 0.13934958f, 0.11624847f, -0.13831255f, 0.06559965f, 0.10761615f, -0.07052742f, 
    -0.02012716f, 0.12565583f, -0.20663032f, -0.27794594f, 0.07777142f, -0.01186765f, 0.02248112f, -0.02008815f, 
    -0.15647377f, -0.04373813f, -0.03272516f, 0.11303162f, -0.09025160f, 0.09210370f, 0.01741570f, -0.08655295f, 
    -0.00020886f, -0.16670701f, 0.01425337f, -0.11716953f, -0.67375529f, 0.16877510f, -0.50329536f, -0.01423619f, 
    0.17190047f, -0.06385397f, 0.19804455f, -0.08095606f, -0.04199275f, 0.05906751f, 0.03961309f, 0.05158334f, 
    0.03706860f, 0.13283527f, -0.11116682f, -0.01226277f, 0.08198221f, -0.06496374f, -0.05098717f, -0.00620007f, 
    -0.21151449f, 0.26570854f, 0.23791599f, -0.03204758f, -0.17292029f, 0.02604182f, 0.07186421f, 0.00244715f, 
    -0.02325003f, 0.06662394f, 0.15808620f, -0.03504619f, -0.02672475f, 0.10907976f, 0.12375061f, -0.08771206f, 
    -0.11686680f, -0.23517165f, -0.08510566f, -0.03586936f, 0.34558603f, -0.19749108f, -0.06029858f, -0.08191249f, 
    -0.16896686f, 0.08454625f, 0.06733395f, -0.00666827f, 0.00923278f, -0.03908626f, 0.06632586f, 0.01826056f, 
    0.06299979f, 0.06885910f, 0.13941363f, 0.04518356f, 0.06821361f, 0.08497949f, 0.09870264f, 0.10224225f, 
    -0.03301476f, -0.21458326f, -0.23231292f, -0.13328747f, 0.02521398f, -0.21658434f, 0.10423715f, 0.05132164f, 
    -0.06115449f, -0.00377685f, 0.08878118f, 0.11621755f, 0.02996241f, 0.00995900f, -0.07437005f, 0.05461618f, 
    0.15445215f, -0.10270631f, -0.01016878f, -0.07388429f, -0.13075991f, -0.06424764f, 0.06834390f, 0.05202912f, 
    0.25896356f, 0.19208471f, 0.03202350f, -0.01072215f, -0.01091486f, 0.04816952f, 0.02887433f, 0.08495145f, 
    0.09362124f, 0.01504254f, 0.04696861f, -0.00397961f, 0.09508901f, 0.04530920f, 0.03661150f, -0.02886476f, 
    0.06880127f, 0.13214520f, 0.10719462f, 0.23028958f, -0.09571278f, -0.02994122f, 0.03735351f, 0.04409615f, 
    -0.04329893f, -0.05463133f, 0.00410772f, -0.07122021f, 0.01757088f, -0.12050304f, 0.00091421f, -0.01409747f, 
    0.00275136f, 0.18639596f, 0.02214162f, 0.12849514f, -0.12872402f, 0.29454929f, 0.21925132f, 0.19057018f, 
    0.07096963f, 0.05139760f, -0.02411691f, 0.13770996f, 0.01765267f, 0.01439874f, -0.00947282f, 0.08235063f, 
    -0.07201111f, -0.02168015f, 0.15407731f, 0.16083863f, 0.05678165f, 0.02044882f, -0.00069485f, 0.06608143f, 
    0.02702948f, 0.23846099f, 0.36275595f, 0.21119499f, 0.02766265f, 0.04034138f, 0.02279895f, -0.05400584f, 
    0.02817963f, -0.14730354f, -0.00924559f, -0.03913363f, 0.11050121f, 0.04270074f, 0.01366253f, 0.04062659f, 
    -0.01082368f, -0.01132460f, -0.01088644f, -0.11030246f, -0.09425541f, 0.08380795f, 0.26336947f, -0.01800354f, 
    -0.20675276f, 0.17448647f, -0.10820985f, -0.09017792f, -0.00580963f, 0.08591225f, 0.04865202f, 0.07795508f, 
    -0.09571755f, -0.18488146f, 0.00585542f, 0.01471993f, -0.03524284f, -0.21373160f, -0.00823321f, -0.01710090f, 
    -0.12793691f, 0.04480470f, -0.28016844f, -0.13904615f, -0.25158605f, -0.02124319f, -0.00462245f, 0.07314199f, 
    -0.16139731f, 0.14164861f, -0.06499260f, -0.09255291f, 0.03138117f, 0.14127642f, 0.08233583f, 0.04207758f, 
    0.06919933f, 0.05355345f, -0.06782839f, 0.14619179f, -0.32760537f, 0.20697314f, 0.08309778f, 0.04334817f, 
    0.12925340f, -0.12002225f, -0.02044738f, 0.04392489f, 0.07697252f, 0.07419268f, -0.04101969f, 0.04666938f, 
    0.03013347f, -0.02455231f, -0.03144166f, 0.08700104f, -0.08964257f, 0.01002276f, 0.06338299f, 0.11809038f, 
    0.42720219f, 0.11776484f, 0.57590067f, 0.28623453f, -0.12651730f, 0.09596442f, -0.08458386f, -0.01125952f, 
    0.09598079f, 0.07634400f, 0.25215277f, -0.01435723f, 0.06134401f, -0.06241166f, -0.01126442f, 0.11652499f, 
    0.12429883f, 0.01697009f, 0.15524220f, 0.07312655f, -0.07032059f, -0.15679882f, 0.10571777f, 0.08193551f, 
    0.07427666f, -0.08529287f, 0.01721808f, 0.10768924f, -0.04960495f, -0.10115148f, 0.13045785f, 0.07431694f, 
    0.00128816f, -0.01584963f, 0.04115748f, 0.11490272f, -0.00439976f, -0.21453427f, -0.11435869f, -0.17269215f, 
    -0.13726580f, 0.05858224f, -0.32195503f, 0.20877980f, 0.12937973f, 0.04489696f, 0.03575289f, 0.01144232f, 
    0.12151390f, -0.01572742f, -0.08209131f, -0.03301808f, 0.02197997f, 0.16118921f, 0.00647768f, -0.10579625f, 
    -0.02381007f, -0.00818204f, 0.07628673f, -0.03416084f, 0.29164827f, 0.00058172f, -0.02734819f, -0.17384633f, 
    0.08273824f, -0.02630618f, -0.00675189f, -0.00254453f, -0.05680083f, -0.05330842f, 0.00504398f, 0.10831294f, 
    0.07460809f, 0.03572236f, 0.01262706f, 0.08930779f, -0.01644966f, -0.05259584f, -0.07992448f, -0.01497086f, 
    -0.14460489f, -0.18370527f, 0.12020078f, -0.05922299f, 0.02749602f, -0.02052529f, -0.00288268f, 0.04098951f, 
    -0.15959719f, -0.10842954f, 0.07820689f, 0.01859956f, -0.07865708f, 0.05561589f, -0.00612532f, 0.08797900f, 
    0.19311567f, -0.13279940f, 0.09748264f, 0.01560505f, -0.48902917f, 0.19814442f, -0.08666061f, 0.02164173f, 
    0.23484607f, 0.00448053f, 0.11164614f, -0.14424647f, -0.29955539f, 0.01464236f, 0.13428724f, 0.04807359f, 
    0.02569060f, 0.01211040f, -0.02300634f, -0.05361724f, 0.13990974f, 0.09891300f, -0.00599691f, 0.01948685f, 
    -0.45577884f, -0.07534130f, 0.03958947f, 0.00295026f, -0.30636856f, -0.04325906f, 0.04058901f, -0.19492665f, 
    -0.08971699f, 0.00365825f, 0.06541750f, 0.09335521f, -0.07332347f, 0.24514514f, 0.05557356f, 0.11302624f, 
    0.11046815f, -0.00116004f, 0.02964970f, 0.17957348f, 0.49225479f, -0.11779630f, -0.27305660f, 0.00897479f, 
    -0.03435454f, -0.02592915f, 0.06515653f, 0.01173507f, -0.03601462f, 0.09669121f, 0.05243845f, 0.03447952f, 
    -0.00179010f, -0.03361017f, 0.05880961f, 0.10488015f, 0.10647634f, 0.00368467f, 0.17400497f, 0.12008689f, 
    -0.15359198f, -0.10459568f, -0.09507348f, 0.17825322f, 0.12481426f, -0.30923125f, -0.01426532f, -0.12759416f, 
    -0.16479136f, -0.25633860f, 0.05255022f, 0.01375250f, -0.02053408f, 0.06105820f, 0.04833983f, 0.13654621f, 
    0.19719423f, -0.02945716f, 0.11627101f, -0.01269717f, -0.28979462f, 0.12693395f, -0.00419964f, 0.18756981f, 
    0.22094604f, 0.11282568f, 0.06914920f, 0.05121377f, 0.04130189f, -0.08363718f, -0.01957168f, -0.05324943f, 
    -0.02252942f, 0.00337242f, -0.03456441f, 0.09472547f, 0.07341718f, 0.00297555f, 0.04896839f, -0.03938301f, 
    0.28946903f, 0.23377587f, 0.16904448f, 0.08893840f, -0.01973380f, -0.02701272f, 0.07326238f, 0.09545672f, 
    0.06183451f, -0.10984343f, 0.08014131f, 0.02353922f, -0.05954416f, -0.14881498f, -0.04215927f, -0.00222383f, 
    -0.13580187f, 0.03205390f, -0.20113365f, 0.01030133f, -0.16355354f, 0.07145041f, -0.26687235f, -0.01934804f, 
    0.03429799f, 0.06072026f, 0.04981848f, 0.01505179f, -0.05617975f, -0.10252707f, 0.04802642f, 0.13176863f, 
    0.05213445f, 0.11405523f, 0.08296226f, 0.15154371f, 0.01648905f, -0.00973043f, -0.19991750f, -0.07321700f, 
    -0.02826225f, -0.06654102f, -0.23663935f, -0.11249670f, -0.09346504f, 0.00523618f, 0.09844366f, 0.13393673f, 
    0.06570038f, -0.05913551f, 0.02372511f, 0.09685770f, 0.03601911f, 0.00942325f, -0.01331414f, -0.12317244f, 
    0.14080296f, 0.03034473f, 0.07719062f, 0.01214285f, 0.06181173f, 0.12647176f, 0.04520005f, -0.24056992f, 
    -0.16089536f, 0.10304319f, -0.00691436f, 0.01084328f, 0.08989330f, 0.07003582f, 0.03336147f, 0.05674328f, 
    0.01561191f, -0.07487863f, -0.00378075f, 0.09752198f, -0.05139068f, -0.23654124f, -0.11319899f, -0.11733221f, 
    -0.01701342f, -0.01130398f, -0.21486309f, -0.09875286f, -0.39906269f, 0.03127153f, 0.02648595f, 0.01384018f, 
    -0.11179738f, 0.23690395f, -0.06482649f, -0.08789566f, -0.00089959f, 0.07219303f, -0.01239267f, 0.05073235f, 
    -0.03172174f, -0.06621023f, -0.09291447f, -0.13942404f, -0.08636392f, 0.22927389f, -0.13306445f, -0.07150118f, 
    0.11104895f, -0.07577919f, 0.01167402f, -0.04661376f, 0.03538060f, 0.06297242f, 0.01005106f, 0.03410768f, 
    0.00301776f, 0.08686908f, -0.09548941f, 0.02871508f, -0.02622278f, -0.02124802f, -0.12508136f, 0.08906152f, 
    0.51652336f, 0.09087648f, 0.19745649f, 0.16066843f, -0.14849094f, 0.06101781f, 0.05184099f, 0.13081117f, 
    0.01598096f, -0.06567176f, 0.14489435f, -0.06038460f, -0.12493178f, -0.05308798f, -0.03292059f, 0.15077454f, 
    -0.11584064f, -0.02816894f, 0.02671133f, -0.08815527f, -0.10915269f, -0.24859633f, 0.11347666f, 0.02404727f, 
    -0.03809969f, -0.07961043f, -0.01834881f, -0.02619751f, -0.11096403f, -0.07879274f, 0.05442028f, 0.07852086f, 
    0.04399545f, 0.09290450f, 0.14987507f, 0.18833551f, 0.11471743f, 0.04184207f, 0.06161796f, 0.10060272f, 
    0.02690650f, 0.28615749f, -0.02647666f, -0.13771242f, 0.03795532f, 0.06588043f, -0.05333350f, -0.00720235f, 
    0.30109966f, -0.05282310f, -0.17052972f, -0.07212742f, 0.13072039f, 0.06962858f, -0.06964707f, -0.09128407f, 
    0.12762229f, 0.03576340f, 0.03171884f, 0.03006371f, 0.11377566f, -0.28314269f, -0.01029643f, 0.04589352f, 
    -0.01124729f, -0.08221077f, 0.00513515f, -0.02251560f, -0.06069795f, -0.27192882f, 0.06014229f, 0.04738518f, 
    -0.00352553f, -0.07384641f, -0.00387567f, 0.13737532f, 0.04647467f, -0.07186455f, 0.01470925f, 0.11748144f, 
    -0.03533069f, -0.16462667f, -0.12744795f, -0.18600050f, 0.04913403f, 0.03896140f, 0.03633557f, -0.01723847f, 
    -0.00092859f, 0.03108839f, 0.03628216f, -0.08348598f, -0.12336724f, -0.16041799f, 0.04731685f, -0.03143656f, 
    -0.03892449f, 0.01882638f, -0.01859616f, -0.05072394f, -0.26036945f, 0.01707182f, 0.04860129f, -0.17364343f, 
    -0.05152320f, -0.19373156f, -0.14260176f, 0.07996961f, 0.31684682f, -0.00564997f, -0.15452811f, -0.05391371f, 
    0.13203554f, -0.05754127f, -0.00638129f, 0.01080369f, -0.05488789f, -0.09729457f, 0.15267250f, 0.06658608f, 
    0.19790822f, 0.07541347f, -0.05147140f, 0.06754229f, 0.08642355f, -0.06773041f, -0.07114608f, 0.03108387f, 
    -0.08697410f, -0.09636873f, -0.01887152f, -0.11108982f, -0.04930552f, -0.27033451f, -0.02368655f, 0.03835049f, 
    -0.04529608f, 0.04101095f, 0.03914081f, -0.11146700f, -0.56130183f, 0.16574298f, 0.32244566f, -0.08289413f, 
    -0.04915911f, 0.14882040f, -0.03336244f, -0.05602121f, 0.01427480f, 0.06158606f, 0.00435838f, -0.08704352f, 
    -0.10855922f, -0.13341942f, 0.03739074f, -0.06877312f, 0.10770979f, 0.06797411f, -0.08132447f, 0.00226676f, 
    -0.10056077f, -0.19478677f, 0.02748295f, -0.17868753f, -0.00702801f, 0.09847767f, -0.05256136f, 0.00949532f, 
    -0.01794151f, 0.12334409f, -0.10721762f, -0.05950642f, -0.00160453f, -0.06392449f, -0.09300697f, 0.16735728f, 
    0.03468271f, -0.03214362f, -0.03505271f, 0.09676389f, 0.20025863f, -0.15647635f, 0.04830504f, -0.13834180f, 
    -0.08459495f, -0.00394640f, -0.04809611f, -0.03061393f, -0.03164168f, 0.05018206f, 0.13304038f, -0.12549917f, 
    -0.03842175f, 0.01631662f, -0.07218954f, -0.17132391f, -0.10994576f, -0.04436164f, 0.11445250f, 0.12850749f, 
    -0.27120331f, -0.09450562f, -0.15874630f, 0.02308136f, -0.02226759f, 0.03348719f, 0.18074320f, 0.02897419f, 
    -0.18489066f, -0.02905616f, -0.09905718f, -0.02270641f, -0.03561061f, 0.11227177f, -0.07428145f, 0.00465869f, 
    -0.03897469f, -0.06008848f, 0.13958032f, -0.11237131f, -0.02006844f, 0.21318531f, 0.35525176f, 0.19961800f, 
    0.10646013f, -0.03392715f, -0.01157197f, -0.04385298f, 0.11205583f, 0.07016319f, 0.16753553f, 0.00249608f, 
    0.02947998f, -0.00303966f, 0.01868580f, -0.02470269f, -0.00074653f, -0.11831863f, 0.12040334f, -0.04548899f, 
    0.02160807f, 0.33562979f, 0.23908380f, 0.06929676f, 0.14595029f, 0.03353809f, -0.17197719f, -0.16679172f, 
    -0.18032075f, -0.00252480f, 0.07942537f, 0.05696284f, 0.07879087f, -0.01279677f, 0.08195471f, -0.00543883f, 
    -0.02179872f, -0.14665040f, -0.10565890f, -0.03950097f, -0.08879868f, 0.05505046f, 0.31037256f, 0.20208131f, 
    0.09771626f, 0.00634910f, 0.12922345f, -0.02416952f, -0.09053555f, 0.01826622f, 0.08083361f, 0.00085129f, 
    0.03763671f, -0.00041071f, 0.04103041f, -0.13164520f, -0.06688647f, 0.11441161f, -0.06886458f, -0.09384029f, 
    -0.27208760f, -0.08678991f, 0.01922457f, 0.06041837f, 0.20315142f, 0.04034443f, 0.11300682f, 0.23095682f, 
    0.22511205f, 0.00983725f, 0.06776366f, 0.06807678f, -0.10188284f, -0.06370346f, -0.06921500f, -0.01304459f, 
    0.02573942f, 0.05906725f, 0.04876000f, 0.30243897f, 0.02012770f, 0.04304767f, 0.13769925f, -0.01929070f, 
    -0.11742175f, 0.09881856f, 0.09368748f, 0.10954142f, -0.07430200f, -0.06710074f, 0.04806441f, -0.01677067f, 
    0.01410129f, -0.04639166f, -0.03174083f, -0.04966303f, -0.04858063f, -0.07478675f, 0.20421061f, -0.02054596f, 
    -0.36872056f, 0.21999544f, 0.13749699f, -0.05800765f, 0.19093928f, -0.04084224f, 0.07783443f, -0.16762134f, 
    0.04751095f, 0.05132162f, -0.02151591f, 0.26601142f, 0.10173605f, 0.14149769f, -0.00909955f, -0.15819383f, 
    0.08223687f, 0.10581429f, -0.01532870f, -0.11587919f, -0.01304288f, -0.00710338f, 0.10303076f, -0.05615689f, 
    0.04779103f, 0.02632292f, -0.06795884f, 0.01011602f, 0.02707077f, 0.05912283f, -0.01567316f, 0.01546995f, 
    0.00800764f, 0.01569908f, 0.12260205f, 0.01639272f, -0.01383065f, 0.03561690f, 0.00963161f, -0.02983064f, 
    0.13972060f, -0.15930843f, -0.24366635f, 0.12672620f, 0.04896455f, 0.07807855f, 0.16272391f, 0.01077732f, 
    -0.15964775f, 0.05558025f, 0.04748895f, 0.05212327f, -0.07848291f, -0.01661414f, -0.10643116f, 0.12133885f, 
    -0.06657141f, -0.13644786f, 0.01431179f, 0.06624582f, 0.01112324f, 0.06591021f, -0.00478390f, -0.16775747f, 
    0.08146089f, 0.07438528f, 0.01800834f, -0.08487762f, 0.03869515f, 0.06183072f, -0.10561249f, -0.05605941f, 
    -0.03002400f, -0.03407434f, -0.18087734f, 0.12459718f, 0.14585204f, 0.05761153f, -0.04228605f, 0.02703525f, 
    0.27707970f, -0.19035646f, 0.53558779f, -0.09486604f, 0.14972788f, 0.03918850f, 0.22581978f, -0.16290021f, 
    0.01134000f, -0.04806870f, -0.02380999f, 0.12406097f, 0.01162267f, 0.08699156f, -0.00455866f, 0.01271111f, 
    0.12644701f, 0.10230144f, -0.06054457f, -0.10954606f, -0.25690216f, 0.03174908f, 0.17174721f, -0.03035139f, 
    0.08763637f, 0.11703515f, 0.10587366f, -0.08941222f, 0.17751502f, -0.09458424f, -0.01606317f, 0.07961500f, 
    0.01709223f, -0.07417177f, -0.00467624f, 0.19921170f, 0.06337446f, 0.15319842f, -0.12853886f, -0.06207786f, 
    0.07134864f, -0.16934650f, 0.09264988f, 0.07199417f, 0.14995879f, -0.03638732f, 0.09446821f, -0.01547754f, 
    0.03799928f, -0.15215912f, -0.00108393f, 0.09333539f, -0.03927802f, -0.01835011f, 0.02579996f, 0.03941517f, 
    -0.03737508f, 0.06853714f, -0.06198252f, 0.04939130f, -0.26245582f, 0.42216900f, -0.39070374f, 0.28707129f, 
    -0.07847676f, 0.01167437f, 0.12830466f, 0.03890932f, 0.20991935f, -0.07241081f, 0.00555389f, 0.08632173f, 
    -0.07992225f, 0.00023309f, 0.10054632f, 0.22123408f, 0.02703302f, 0.10549685f, 0.22721520f, -0.09642306f, 
    0.00313846f, -0.03271699f, -0.03839021f, -0.04271482f, -0.07725686f, 0.05878693f, 0.12533064f, -0.07251682f, 
    -0.06101665f, 0.07272393f, -0.09343230f, -0.01742354f, -0.00532142f, 0.07058602f, -0.05304104f, 0.07854398f, 
    0.05099098f, 0.01591997f, -0.07000027f, -0.09624667f, 0.21902376f, -0.09664827f, 0.17603821f, -0.26821741f, 
    0.25080496f, 0.09963454f, 0.14521968f, -0.04161209f, 0.08856407f, 0.01396459f, 0.00730601f, 0.06283871f, 
    0.01513972f, 0.09659397f, 0.14883155f, -0.00857279f, 0.04577978f, -0.06892801f, 0.11471008f, -0.04570376f, 
    -0.29712912f, -0.08089450f, -0.15623298f, 0.11261740f, 0.16028184f, -0.02175780f, -0.21872097f, 0.00464034f, 
    -0.14583719f, 0.03110058f, -0.10690219f, 0.06989583f, 0.05701115f, 0.00775236f, -0.00115807f, 0.03644792f, 
    0.01989371f, 0.12256837f, -0.03856199f, 0.07970916f, -0.12107757f, 0.08500780f, 0.08790115f, 0.21653941f, 
    0.14844148f, -0.01304496f, -0.00859051f, 0.02163549f, -0.04640286f, -0.00622479f, 0.07751042f, 0.04531833f, 
    0.14492898f, 0.05139033f, -0.03109735f, -0.01164236f, -0.01431612f, 0.11398239f, -0.06174143f, -0.00312800f, 
    -0.37402791f, -0.06759378f, -0.11009876f, 0.22438020f, 0.21392603f, 0.13589050f, -0.09414899f, 0.07432500f, 
    -0.04246484f, 0.00968938f, -0.10555999f, 0.00084757f, -0.05792379f, -0.02918376f, -0.08923266f, 0.04495930f, 
    -0.13825479f, 0.01532777f, -0.01231043f, -0.05435240f, -0.11700638f, 0.03640520f, -0.04747907f, 0.30363593f, 
    0.19577688f, 0.01008886f, 0.06124382f, -0.02954372f, -0.05413071f, -0.05242040f, 0.06460398f, 0.03563221f, 
    0.09168649f, -0.16154434f, 0.02522640f, -0.05228185f, -0.00282701f, -0.13965468f, 0.16893241f, 0.12345020f, 
    -0.00647618f, -0.31402418f, 0.11320008f, 0.37164703f, 0.19893414f, -0.02874793f, 0.06502849f, -0.06344548f, 
    0.10254936f, -0.15292537f, -0.02013973f, 0.13169329f, 0.06778963f, -0.02600590f, 0.10923470f, -0.00528892f, 
    0.00561182f, 0.12194767f, 0.19874208f, 0.02921838f, -0.08486686f, -0.19926366f, -0.16555528f, 0.06678001f, 
    0.20830721f, 0.09457760f, -0.08573661f, -0.03218261f, -0.02920530f, -0.07132339f, -0.01292457f, 0.12098341f, 
    0.04531289f, 0.06287345f, 0.00788485f, 0.01797360f, -0.16415092f, 0.00352399f, -0.00786289f, 0.06826677f, 
    0.03393335f, 0.51314932f, -0.04660492f, 0.22562003f, 0.13672785f, 0.12816654f, 0.10014748f, 0.02357986f, 
    0.12468094f, -0.05702238f, -0.06395970f, -0.08778643f, 0.20386006f, 0.07325305f, 0.12331057f, 0.03142142f, 
    -0.03023415f, -0.02333026f, -0.04526943f, 0.03161127f, 0.10544596f, -0.16313711f, 0.06257489f, -0.11053760f, 
    0.10445887f, -0.00631025f, 0.08203516f, -0.03618294f, 0.02482176f, -0.06615630f, 0.08117593f, 0.04851198f, 
    0.07352524f, -0.00502815f, -0.02819739f, -0.00038445f, 0.06138997f, -0.08910417f, -0.03001658f, 0.06917387f, 
    0.06742173f, 0.17490976f, 0.13275045f, -0.04755436f, 0.33913505f, 0.16832018f, 0.08316287f, 0.03613404f, 
    -0.07029138f, 0.06441817f, 0.02542745f, 0.00919866f, -0.06196413f, 0.17107457f, -0.01984683f, -0.02516107f, 
    -0.09821271f, 0.01425010f, -0.06862774f, 0.10982542f, -0.09437464f, -0.24956870f, -0.17992234f, -0.11775608f, 
    -0.00031833f, 0.10062794f, 0.03480809f, 0.07506192f, 0.03700366f, -0.04978960f, -0.10827996f, -0.08602858f, 
    0.03271206f, 0.04915992f, 0.00573908f, 0.05991862f, -0.00171239f, -0.12675999f, -0.05697817f, -0.21806428f, 
    0.47525311f, 0.15040316f, -0.08621792f, 0.11857380f, -0.03419670f, 0.08081774f, 0.01501733f, 0.03344507f, 
    0.08264665f, -0.00099275f, -0.01677394f, 0.02844878f, -0.01616713f, 0.04041687f, -0.03926695f, -0.10055804f, 
    -0.00433550f, -0.08384272f, 0.04237882f, -0.01680282f, 0.09395803f, -0.11505242f, 0.34032008f, 0.12941512f, 
    0.11571027f, 0.07493285f, 0.09381497f, 0.25095522f, -0.01503905f, -0.06090111f, -0.03176709f, -0.03300028f, 
    -0.01344299f, 0.05510464f, 0.11273034f, 0.00026841f, 0.02934638f, -0.19261184f, 0.01637985f, -0.07649713f, 
    -0.03017103f, 0.19119231f, 0.20913520f, -0.18504752f, -0.17513514f, -0.05172051f, -0.05723992f, 0.06884441f, 
    0.05136765f, 0.08265284f, 0.03358576f, 0.10507077f, -0.04051585f, 0.01023960f, 0.09909368f, -0.09204487f, 
    0.03831615f, -0.14203851f, -0.07410075f, -0.14623874f, 0.28278440f, -0.22809607f, -0.03007483f, 0.12967940f, 
    0.20302211f, -0.03515536f, 0.09106615f, -0.05369033f, 0.11686145f, 0.03043789f, -0.00610206f, 0.07396946f, 
    -0.01561771f, 0.01895187f, 0.02675979f, 0.08820460f, 0.07428259f, 0.18573129f, -0.12974212f, 0.05310418f, 
    0.11911050f, 0.11371963f, -0.02391235f, 0.13009259f, 0.16280694f, 0.00431772f, 0.04680707f, 0.00988084f, 
    0.00162378f, 0.04795298f, -0.00192676f, -0.02796626f, 0.08097800f, 0.07253599f, 0.01818502f, -0.00469292f, 
    -0.06198799f, 0.07968613f, -0.16689041f, -0.10183555f, -0.38373345f, -0.16918017f, 0.02300005f, 0.17939197f, 
    0.19614200f, -0.01275811f, 0.02380537f, 0.07455554f, -0.01832360f, -0.01041744f, 0.10673354f, 0.07118834f, 
    -0.11139893f, 0.06093903f, -0.05225712f, 0.09228486f, -0.06070370f, 0.06600406f, 0.03300159f, 0.02929175f, 
    0.36814538f, 0.03003563f, 0.12354495f, -0.23192117f, -0.34786820f, 0.00096368f, 0.11197777f, 0.05936325f, 
    -0.02425676f, 0.22138047f, 0.06389987f, -0.04847403f, 0.08129320f, 0.01471572f, 0.05042912f, 0.01468338f, 
    -0.02353597f, -0.09175519f, 0.14642939f, 0.04914861f, 0.17364737f, -0.01041221f, 0.17978780f, 0.01801796f, 
    -0.34433073f, -0.03218309f, 0.01458483f, 0.00695038f, 0.00473072f, 0.18018213f, 0.00138549f, 0.01805812f, 
    0.10086814f, -0.01118238f, -0.00298515f, -0.04405753f, -0.02945344f, -0.06615330f, 0.09926191f, 0.01386260f, 
    -0.18389821f, 0.01203465f, -0.09391515f, -0.07202420f, -0.42418289f, -0.20762342f, 0.02283408f, -0.05968378f, 
    -0.09423094f, 0.11805302f, -0.09221351f, 0.00003360f, -0.01407337f, -0.07196679f, -0.08757685f, -0.06558692f, 
    -0.07575422f, -0.00755750f, -0.16668588f, -0.11096357f, -0.10186899f, -0.02430157f, -0.20602787f, 0.16900763f, 
    -0.37329158f, -0.02498774f, 0.08051374f, -0.11115512f, 0.00847578f, 0.09162693f, 0.05311130f, -0.06107768f, 
    -0.07953610f, 0.03353260f, -0.12578653f, -0.08566778f, 0.01026583f, 0.00370890f, 0.03043403f, 0.08290526f, 
    0.67036092f, 0.17755978f, -0.35996845f, -0.14187388f, -0.08108717f, 0.10023335f, -0.02935949f, 0.10678593f, 
    0.10471587f, 0.00336619f, -0.06421078f, -0.00704346f, -0.01496320f, 0.03113979f, 0.04655593f, 0.07629681f, 
    0.17987713f, 0.17928329f, 0.07810839f, 0.11950060f, 0.22202700f, 0.13809389f, 0.46155652f, -0.03625651f, 
    -0.09111646f, 0.10560387f, -0.04838624f, -0.00239130f, -0.05867429f, 0.00496085f, -0.03933544f, -0.03397144f, 
    -0.08774355f, 0.00691426f, -0.07886422f, -0.08073090f, -0.04059698f, -0.00894579f, 0.07737543f, -0.04683514f, 
    -0.13365169f, -0.22739932f, -0.48167855f, 0.04027766f, -0.22389434f, 0.06390729f, -0.05137037f, -0.10564344f, 
    0.03360712f, -0.00748655f, -0.04006832f, -0.04857121f, 0.04781958f, 0.11753730f, -0.00124268f, 0.11810219f, 
    0.06085938f, 0.26915145f, 0.10121722f, 0.17242830f, -0.12387919f, 0.00068303f, 0.10738534f, 0.03757828f, 
    0.19044484f, 0.03350732f, -0.01126369f, -0.04783389f, 0.00051655f, 0.05256691f, -0.04574032f, 0.09656189f, 
    0.04785401f, 0.03561835f, 0.04025004f, -0.09219593f, -0.00459300f, -0.11735772f, -0.09484003f, -0.09228985f, 
    -0.41411096f, 0.08674913f, -0.13358994f, 0.26099801f, -0.31823400f, -0.17821401f, 0.03789315f, 0.18398322f, 
    -0.10518405f, -0.00124562f, 0.05416251f, -0.05725367f, 0.05026659f, -0.06550133f, 0.02767241f, 0.01603825f, 
    0.04971310f, 0.13734145f, 0.11687995f, 0.01340266f, 0.05796658f, 0.07230906f, -0.00445963f, 0.14118546f, 
    0.36972752f, 0.00451392f, -0.01117840f, -0.11416651f, -0.02184421f, -0.07642928f, -0.02443263f, 0.03324698f, 
    0.01854166f, 0.05597594f, 0.02841981f, -0.00686557f, 0.03866713f, -0.01432854f, -0.17881210f, -0.14547127f, 
    -0.03519242f, -0.02938264f, -0.04356931f, -0.03303251f, -0.01489786f, -0.05305669f, -0.02592255f, -0.04680311f, 
    0.01510598f, 0.00760131f, -0.05337344f, -0.04270726f, -0.02729325f, -0.02668042f, -0.02216781f, -0.00076890f, 
    0.00744431f, 0.02260446f, 0.03063083f, 0.04550501f, 0.01526852f, 0.02933330f, 0.01344160f, -0.00183643f, 
    -0.03361558f, 0.01356511f, -0.01474907f, -0.02159221f, 0.01804807f, 0.04168503f, 0.02354661f, -0.05508491f, 
    -0.06166397f, -0.04798281f, -0.01634967f, 0.00122475f, 0.02501512f, -0.03243996f, -0.02931475f, -0.00140676f, 
    -0.05411628f, -0.04782460f, 0.00080301f, -0.00555675f, 0.03450437f, -0.00783106f, 0.04349393f, -0.03030115f, 
    0.00970095f, -0.03498143f, -0.06134740f, 0.00283388f, -0.00570089f, -0.00641484f, 0.01869915f, -0.04975145f, 
    0.03645655f, -0.00397503f, -0.00188045f, -0.04235477f, -0.01495073f, -0.04052210f, -0.03578280f, 0.03661697f, 
    -0.05433711f, 0.01172101f, 0.04407614f, -0.04760572f, -0.02157402f, -0.02458491f, -0.02003033f, -0.01647695f, 
    0.02562824f, 0.03706562f, 0.02886683f, -0.01533747f, -0.02553074f, 0.04331124f, 0.03238088f, -0.02240682f, 
    -0.04195073f, 0.04726123f, 0.01214075f, -0.03665829f, -0.04162000f, 0.04268951f, 0.05068901f, 0.03078298f, 
    0.02231735f, -0.00345280f, -0.04482450f, -0.04373804f, 0.01900951f, -0.02226659f, -0.02149660f, 0.01265885f, 
    0.02620379f, -0.03167524f, 0.00631088f, -0.05207369f, 0.02562993f, -0.04389320f, -0.05028752f, 0.04404445f, 
    -0.05501490f, 0.02112881f, 0.00370487f, -0.02093273f, -0.03167594f, -0.00864349f, 0.04442365f, -0.04482974f, 
    -0.04055834f, -0.04433933f, -0.01755440f, -0.05790286f, -0.02393133f, -0.04203993f, 0.02681996f, -0.01287039f, 
    -0.06491574f, 0.00969965f, -0.03424288f, -0.02747768f, -0.01275802f, 0.02199996f, -0.01204159f, 0.04006794f, 
    0.00449593f, 0.03388402f, -0.04785520f, -0.03127280f, 0.00285938f, 0.02505654f, -0.04063566f, -0.02953308f, 
    0.00952667f, -0.02427688f, 0.01516886f, -0.05324502f, 0.03006898f, 0.02629309f, -0.02758214f, 0.02933899f, 
    -0.01220017f, -0.02840758f, -0.00103266f, -0.04603333f, -0.06099518f, -0.02384414f, -0.06165517f, -0.01418111f, 
    -0.03582287f, -0.04693303f, -0.04403081f, -0.01001683f, -0.05774921f, 0.04562802f, -0.05623823f, 0.03029452f, 
    0.03338069f, 0.00533008f, -0.01894505f, 0.03746575f, 0.00604017f, 0.04219238f, -0.02117715f, -0.02460851f, 
    0.03271365f, -0.02307647f, -0.02757481f, -0.01258570f, 0.03200811f, 0.03928651f, 0.04696582f, -0.04374646f, 
    -0.00580956f, -0.05030882f, 0.01042180f, -0.01807024f, -0.00099301f, 0.02433598f, 0.03847885f, -0.01548683f, 
    -0.03848704f, 0.03379482f, 0.02780062f, 0.02320000f, 0.01189658f, -0.02439177f, -0.02216276f, 0.04560829f, 
    -0.01132927f, -0.03049605f, 0.05480599f, -0.00856809f, -0.04562500f, 0.05175606f, -0.04360344f, 0.03395211f, 
    0.02123879f, -0.06263020f, 0.03339023f, -0.05833467f, 0.03790757f, 0.00828746f, -0.02287642f, 0.01181244f, 
    0.03036401f, -0.04794607f, -0.03275379f, 0.04707849f, 0.01786296f, 0.03429841f, 0.00967573f, 0.04017438f, 
    -0.06580177f, 0.00551068f, 0.01767377f, -0.03103682f, -0.00465459f, -0.01231011f, -0.00826211f, -0.03809142f, 
    -0.02486660f, -0.00764450f, -0.00147428f, 0.03656560f, -0.04560035f, 0.03998680f, 0.00449329f, -0.03600210f, 
    -0.01319806f, 0.01008857f, -0.04380953f, 0.00727001f, 0.01717073f, 0.04072961f, 0.03561910f, 0.02955651f, 
    -0.04839435f, -0.00866393f, 0.02651156f, -0.04781990f, -0.03455520f, -0.00090088f, -0.00792349f, -0.02995590f, 
    -0.00267935f, -0.04060390f, -0.03947155f, 0.05118499f, 0.00263235f, -0.02435726f, -0.05280286f, 0.03979024f, 
    0.00493852f, 0.00948443f, -0.03749052f, -0.01604639f, 0.04810480f, -0.02543628f, -0.04063058f, -0.02589668f, 
    0.04959329f, 0.04971591f, -0.04626056f, -0.03833305f, -0.04498490f, 0.00749890f, -0.00334952f, 0.02526438f, 
    0.03760158f, -0.06152363f, -0.04577631f, -0.03304171f, -0.01485486f, -0.01269736f, 0.04919995f, 0.02295495f, 
    -0.00669214f, 0.02684687f, -0.02209360f, -0.05027207f, -0.04460189f, -0.04537665f, -0.06341590f, 0.03854025f, 
    -0.05521026f, 0.00033271f, -0.06079412f, -0.05086023f, 0.00082803f, -0.01847464f, -0.01308532f, -0.02527920f, 
    -0.05334329f, 0.01636910f, -0.04688746f, -0.05644671f, -0.00929872f, -0.04733249f, 0.04876754f, -0.03671885f, 
    -0.04293974f, 0.05250072f, -0.02272046f, 0.04004940f, 0.04365660f, 0.04794749f, 0.05340648f, -0.03796676f, 
    0.02142068f, 0.03254757f, 0.02829157f, -0.01531143f, 0.03694568f, -0.02161172f, -0.02482008f, 0.04091009f, 
    -0.05396284f, 0.02396256f, -0.03156793f, 0.02523585f, 0.04837489f, -0.02972857f, 0.03275132f, -0.05839235f, 
    0.02208676f, 0.03302284f, -0.04831998f, 0.01068912f, -0.00349272f, -0.04688376f, -0.02518195f, -0.03491402f, 
    -0.05613500f, 0.01495901f, 0.02966951f, -0.02230531f, -0.02488148f, 0.03837727f, -0.03102868f, -0.00563414f, 
    0.02947968f, 0.02989683f, -0.06067118f, 0.05611255f, 0.02591793f, -0.03105729f, 0.03089766f, -0.04192091f, 
    0.01707396f, 0.04837392f, -0.03281289f, -0.03153061f, -0.02771717f, -0.04971164f, 0.04144993f, -0.02308314f, 
    -0.05290882f, -0.00227868f, 0.04254571f, -0.02295809f, -0.03776574f, -0.00832864f, 0.01547380f, -0.01998772f, 
    0.02857105f, -0.03457959f, -0.01322249f, 0.02521384f, -0.00545969f, 0.04732402f, -0.02226216f, -0.03610599f, 
    0.03007125f, -0.01467077f, 0.01390139f, 0.04701276f, 0.04208326f, 0.02020499f, 0.01240260f, -0.02791085f, 
    0.00594663f, -0.00760214f, 0.03549512f, 0.03332514f, 0.00916237f, 0.04764239f, -0.01771075f, -0.05615957f, 
    0.00619075f, 0.04228917f, -0.00707796f, 0.00933861f, -0.01314764f, -0.02380919f, 0.02678209f, 0.04374554f, 
    0.02510558f, -0.04479796f, -0.01644672f, 0.03854541f, -0.04828070f, 0.04226233f, 0.01419881f, 0.02978691f, 
    0.03226215f, -0.03888886f, 0.02400635f, -0.01910174f, 0.02360342f, 0.04397922f, -0.05521770f, 0.01935749f, 
    0.01437702f, -0.04223235f, -0.04586055f, -0.00256435f, 0.04259579f, -0.05633505f, -0.02365280f, -0.01035647f, 
    0.00176518f, -0.04661423f, -0.01298083f, 0.01855312f, 0.00007514f, -0.04173654f, 0.03999109f, 0.01087625f, 
    0.02156686f, 0.01715120f, -0.00731845f, 0.00594959f, 0.04549711f, -0.02462402f, -0.05530677f, 0.01991950f, 
    0.05670317f, 0.02911044f, 0.04968618f, -0.00099410f, -0.03841197f, -0.00421036f, 0.00249592f, 0.05567604f, 
    -0.04294892f, 0.03220075f, -0.03065883f, 0.02765265f, 0.02666087f, 0.02648109f, 0.03787812f, -0.05588537f, 
    -0.02338557f, -0.01722517f, -0.03506361f, -0.00242857f, -0.05587864f, -0.05907682f, -0.05974698f, -0.03496677f, 
    -0.01542104f, 0.00168513f, -0.00120522f, -0.01256784f, -0.02838953f, 0.03143902f, -0.03860334f, 0.00154576f, 
    -0.05871437f, 0.04806146f, -0.01202103f, -0.01409268f, 0.00712672f, 0.05433752f, 0.03092537f, -0.01941479f, 
    -0.00111033f, -0.03429717f, -0.03818687f, 0.01309727f, -0.01414805f, -0.04691719f, -0.01476711f, 0.03757266f, 
    -0.03321928f, -0.02820958f, 0.01816988f, 0.01562962f, 0.01354588f, 0.00523310f, -0.03829571f, -0.02987265f, 
    0.04211335f, -0.01399068f, -0.04860900f, 0.00988608f, 0.03187376f, -0.03096025f, -0.00776784f, -0.02979279f, 
    -0.01063971f, -0.01603851f, 0.01492496f, 0.03900542f, 0.02087221f, -0.01600941f, -0.04845697f, 0.04471215f, 
    -0.01459646f, -0.04878546f, -0.04154363f, 0.03578824f, 0.03105950f, -0.00000574f, -0.05030601f, -0.04080081f, 
    0.01852956f, -0.05399292f, -0.01521090f, 0.01440096f, 0.01055246f, -0.00286644f, -0.05593343f, -0.03042790f, 
    -0.01748397f, 0.00095873f, -0.02022805f, -0.01868183f, -0.01881883f, 0.02097980f, -0.05603562f, 0.05309048f, 
    -0.00773397f, -0.02149002f, 0.00813968f, -0.05093350f, 0.00111952f, 0.04805103f, -0.05780064f, 0.03443598f, 
    -0.04903467f, -0.02315525f, -0.04660701f, -0.05129708f, 0.01954352f, 0.02739916f, -0.06199265f, 0.00635966f, 
    0.04604893f, 0.04980029f, -0.03710236f, -0.01895329f, 0.01845983f, -0.04829381f, -0.03876072f, -0.03120063f, 
    0.02799402f, -0.05029050f, -0.03780829f, 0.00986342f, 0.04667982f, 0.01425439f, -0.06076622f, 0.03109653f, 
    -0.01335139f, 0.00879031f, 0.01123509f, -0.04514538f, 0.03399784f, -0.04747560f, -0.04513579f, -0.04397447f, 
    -0.03629689f, -0.01251384f, 0.01357354f, 0.01998607f, 0.03323105f, -0.03541474f, -0.00789690f, -0.00088423f, 
    -0.00634679f, -0.01474295f, -0.03650232f, -0.05439259f, -0.04096903f, -0.05646216f, 0.03923624f, -0.04239589f, 
    -0.00965205f, -0.04474282f, 0.02271342f, 0.00600493f, -0.04837834f, -0.06244903f, -0.04377884f, -0.03130891f, 
    0.03550726f, 0.01494643f, -0.00256526f, -0.05698990f, -0.03759287f, -0.05818794f, -0.01693891f, 0.03614097f, 
    -0.02024803f, -0.00828538f, -0.04144134f, 0.00152353f, 0.02262466f, -0.00023568f, -0.03502584f, 0.04270834f, 
    -0.02027886f, 0.03105508f, -0.03471063f, -0.04003151f, -0.03533071f, -0.03837229f, -0.02861870f, -0.02689457f, 
    -0.03507163f, -0.01146625f, -0.03807230f, -0.00511419f, -0.02378580f, -0.01092511f, 0.01098102f, 0.03948414f, 
    -0.01223873f, -0.00493854f, 0.03795180f, 0.01160558f, -0.03378937f, -0.05882008f, 0.02081351f, 0.00143170f, 
    0.04239005f, -0.02137705f, -0.04457669f, 0.00866282f, 0.04863498f, 0.01653618f, 0.03072162f, -0.04125194f, 
    -0.04768192f, 0.00254684f, -0.02070500f, 0.01689492f, -0.06165700f, 0.03720326f, -0.02029325f, 0.02194847f, 
    0.00955066f, -0.04813088f, 0.01844706f, -0.00047399f, -0.03278299f, 0.03356224f, 0.02093317f, -0.04078269f, 
    -0.00637110f, 0.02483695f, -0.02635990f, -0.04071118f, -0.00897590f, -0.03340884f, -0.03947779f, -0.01887422f, 
    0.03441611f, -0.05684722f, 0.03751587f, -0.05197929f, -0.01885186f, -0.00211495f, 0.04175103f, -0.03543418f, 
    -0.03868281f, 0.02093607f, 0.00225888f, -0.03020905f, -0.04104384f, 0.01696192f, 0.00942601f, 0.04885801f, 
    -0.00708480f, 0.01190625f, 0.02980023f, -0.05539716f, -0.05638396f, -0.05342211f, -0.04311676f, 0.01866956f, 
    0.03943222f, 0.00576248f, 0.03044505f, 0.00364115f, -0.04349697f, -0.04653991f, 0.00900958f, 0.04834861f, 
    -0.00663368f, -0.05441367f, -0.00132471f, 0.04227942f, 0.00929154f, 0.04538548f, 0.04609701f, 0.03132271f, 
    -0.01860410f, 0.01446547f, 0.01225726f, -0.04903533f, 0.03959461f, 0.01251486f, 0.02062004f, -0.02153919f, 
    0.00753154f, 0.04877295f, -0.01496362f, -0.01353256f, 0.02479123f, 0.00165480f, 0.04499476f, 0.02768266f, 
    0.02368093f, -0.00172799f, 0.02402289f, -0.03334977f, -0.03403842f, -0.04800279f, 0.02627355f, 0.03831574f, 
    -0.04534280f, 0.00529675f, -0.05519519f, 0.03227278f, 0.01465744f, 0.00204783f, -0.02221000f, -0.03489669f, 
    0.00060216f, -0.01720431f, -0.05399858f, 0.05025448f, 0.03749244f, 0.05111475f, 0.04484583f, -0.05850688f, 
    0.01271847f, 0.04238949f, -0.05211049f, -0.00266527f, -0.05679142f, 0.00708682f, -0.01381933f, -0.00419336f, 
    -0.05495158f, 0.01326018f, -0.04063557f, 0.01393971f, 0.05126078f, -0.01184809f, -0.05305159f, 0.03895786f, 
    -0.01780996f, 0.03614517f, 0.02786396f, -0.05525020f, -0.04129699f, -0.01183232f, -0.02019470f, -0.02170993f, 
    -0.02408092f, -0.02517490f, -0.02536953f, -0.03865669f, 0.01493172f, -0.05883984f, -0.03205623f, 0.01105468f, 
    0.03727715f, -0.01331734f, -0.00320001f, 0.00230707f, -0.05455256f, 0.00536192f, -0.05050767f, -0.00172753f, 
    -0.04880093f, -0.01575810f, -0.03229924f, 0.00507181f, 0.04685072f, -0.02881014f, 0.01401450f, -0.00538416f, 
    0.01171518f, 0.03758765f, 0.03684753f, 0.04528887f, 0.03991142f, -0.04905429f, -0.04035294f, 0.00114443f, 
    0.01754888f, -0.03937942f, 0.04281825f, 0.03468422f, -0.05230372f, -0.00452059f, 0.01295867f, -0.02506438f, 
    0.05080787f, -0.02825141f, 0.04690196f, -0.03194958f, -0.03609843f, 0.02381984f, -0.03376497f, -0.04856255f, 
    -0.02778033f, -0.04165777f, 0.01256519f, -0.00627405f, -0.00175624f, 0.01305995f, -0.00265509f, -0.03363381f, 
    -0.02030058f, 0.04713770f, -0.03972227f, -0.01772400f, 0.05433365f, -0.03835304f, -0.02008751f, 0.02170567f, 
    0.00557636f, -0.05450170f, -0.04572832f, -0.01832341f, 0.00043449f, 0.03644075f, -0.04411000f, -0.05906807f, 
    -0.03007575f, -0.01343567f, 0.02067184f, -0.01954685f, -0.01014568f, 0.04224476f, -0.03479304f, -0.01682900f, 
    0.04811011f, 0.04024369f, 0.00047443f, -0.03868452f, 0.03689749f, -0.05524603f, -0.01050930f, -0.05055749f, 
    0.03013918f, -0.05246500f, -0.01315970f, 0.02203007f, -0.03796861f, 0.01429593f, -0.02262403f, 0.01565987f, 
    -0.05142394f, 0.05167703f, -0.03290334f, 0.01737834f, 0.03873454f, -0.03438664f, -0.01159865f, -0.02816067f, 
    0.00180340f, -0.02672861f, 0.02646272f, 0.05089351f, 0.00667846f, 0.02607239f, -0.04547962f, -0.06151051f, 
    -0.04494657f, -0.03283518f, -0.04075273f, 0.00653172f, -0.03267122f, 0.01324446f, -0.00598693f, 0.02065774f, 
    0.05025240f, 0.02832098f, -0.03672554f, 0.03908474f, -0.01597134f, 0.04246841f, 0.00374664f, -0.03383967f, 
    -0.03015625f, -0.01577318f, 0.00636593f, -0.01899323f, 0.04082032f, -0.00978290f, 0.01833513f, 0.01351464f, 
    -0.03512254f, -0.05483452f, -0.04298091f, -0.03005834f, -0.00224805f, -0.05403282f, -0.01157602f, -0.01554452f, 
    -0.00884771f, -0.04385230f, 0.04499400f, -0.06020946f, -0.01531939f, 0.03274284f, 0.02065984f, 0.02684165f, 
    -0.05884147f, -0.05486485f, 0.00304233f, -0.03352419f, -0.03947033f, -0.04317555f, 0.02649724f, 0.03066061f, 
    0.02641646f, 0.00101655f, 0.04080686f, -0.05515273f, -0.01655735f, -0.03789658f, -0.00463054f, -0.02182123f, 
    0.01253516f, 0.04251458f, -0.01840551f, 0.03203187f, -0.01429416f, -0.02015594f, 0.00801070f, 0.04974462f, 
    -0.04333362f, -0.00940714f, -0.05926992f, -0.02292757f, 0.00276421f, -0.00160875f, -0.05644841f, -0.00038555f, 
    0.00039255f, -0.03436704f, 0.04901327f, 0.01422582f, -0.02673091f, -0.00254077f, -0.01498774f, -0.00569755f, 
    0.00939880f, -0.04214235f, -0.02477407f, -0.05554955f, -0.04628643f, 0.04669696f, 0.01501666f, -0.00859803f, 
    0.02996669f, -0.03536445f, -0.00034590f, 0.02364008f, -0.04703256f, -0.05326361f, -0.03043270f, -0.03443480f, 
    -0.01096176f, 0.00601174f, -0.03322703f, 0.00173378f, 0.02610880f, -0.00005396f, 0.04513098f, -0.06226558f, 
    -0.03178878f, -0.01741715f, 0.04610245f, -0.00833882f, -0.06105536f, -0.04986152f, -0.03157695f, -0.04297946f, 
    -0.04511733f, -0.04680161f, -0.00601251f, -0.03058527f, -0.01056134f, 0.01950236f, 0.01641391f, -0.04529409f, 
    0.04825590f, -0.00296598f, -0.02313811f, 0.02604148f, -0.03950876f, 0.03680539f, -0.00377535f, 0.00837511f, 
    0.02651786f, -0.01451075f, -0.01659982f, -0.01953056f, -0.04540540f, -0.04770339f, 0.04914050f, 0.00083663f, 
    0.00222599f, -0.00618908f, 0.00180597f, 0.02483555f, -0.05021891f, -0.04840054f, 0.02594930f, 0.02675556f, 
    0.02139801f, -0.02362494f, 0.01111295f, -0.05536199f, -0.02043652f, -0.02074146f, -0.01617340f, 0.04037058f, 
    -0.05632302f, 0.01291926f, -0.01106717f, -0.03350812f, -0.03083201f, -0.02878345f, 0.00528485f, 0.04410947f, 
    -0.04049416f, -0.04806104f, 0.02593954f, -0.03561044f, -0.00974282f, -0.05810256f, 0.04219653f, -0.05301540f, 
    -0.03273622f, -0.05160130f, -0.05432509f, 0.02173035f, 0.03673974f, -0.02125525f, -0.03115392f, -0.00382910f, 
    -0.02889156f, 0.01521513f, 0.03762447f, -0.00916342f, -0.04030963f, 0.03856954f, -0.02145496f, 0.00096746f, 
    -0.03666147f, -0.00078203f, -0.01316487f, 0.01272439f, 0.03340708f, -0.02376643f, -0.05821798f, 0.00909028f, 
    0.00242548f, -0.04787713f, -0.01565514f, -0.02052775f, 0.01757661f, -0.05953376f, 0.01482292f, -0.03503342f, 
    0.02130820f, -0.05706745f, -0.02761018f, 0.01597773f, 0.01111118f, 0.03633733f, -0.01948010f, -0.01169866f, 
    -0.02851393f, 0.04031229f, -0.03894025f, 0.03654574f, -0.04236821f, -0.00502436f, -0.04988157f, 0.00391252f, 
    -0.02342182f, -0.03221320f, 0.01555423f, -0.04362752f, 0.02120461f, 0.04270241f, -0.00426351f, 0.01103540f, 
    0.02081990f, 0.00315494f, -0.02483634f, -0.00992804f, 0.00989123f, -0.01575941f, 0.02800270f, 0.04522569f, 
    -0.01038893f, 0.01379753f, -0.04637829f, -0.02607485f, -0.02946462f, -0.03355784f, -0.02817097f, 0.04670320f, 
    0.02504139f, -0.03281166f, 0.01413346f, -0.00737526f, -0.04478231f, -0.04704403f, 0.00047176f, -0.06286392f, 
    0.01981648f, -0.01882243f, 0.00998614f, -0.02853760f, -0.04925786f, -0.01993350f, 0.04296211f, -0.03668490f, 
    -0.02868115f, -0.05783999f, -0.01380161f, 0.00299912f, 0.01344769f, -0.03867845f, -0.01521792f, 0.01281006f, 
    0.01288800f, 0.03066978f, -0.00697913f, -0.05286813f, -0.05398591f, -0.00510295f, -0.04592683f, -0.00262089f, 
    0.02617615f, -0.05219001f, -0.02695523f, 0.02822404f, -0.03943201f, 0.04153267f, -0.01354068f, -0.04322425f, 
    -0.02052385f, 0.01217281f, 0.01535439f, 0.00199270f, 0.00654644f, 0.03803292f, -0.00724493f, -0.01160431f, 
    -0.06029459f, 0.00411398f, -0.03108841f, 0.01045716f, 0.04501199f, -0.00182044f, 0.02555733f, -0.04126632f, 
    -0.03590056f, -0.04131875f, 0.01692478f, -0.02188795f, -0.02747885f, -0.00219476f, 0.00660396f, 0.02604233f, 
    -0.03017584f, 0.03147813f, -0.05224197f, 0.00725215f, -0.03187708f, -0.05348887f, -0.01607057f, -0.03613621f, 
    0.04625466f, 0.01835101f, -0.00525423f, -0.01071059f, -0.03555389f, -0.04020619f, -0.04953245f, 0.04341846f, 
    -0.04868346f, 0.00192773f, -0.03379847f, -0.04179369f, -0.06079753f, -0.02631840f, -0.00710821f, 0.02053959f, 
    -0.00193873f, 0.03555376f, -0.00926331f, -0.00266998f, -0.04120128f, 0.02389014f, -0.02018347f, 0.01906887f, 
    -0.03469979f, 0.02987070f, -0.04051900f, -0.01627321f, 0.04921889f, -0.02782645f, -0.02734443f, -0.00739886f, 
    -0.06143578f, 0.02822874f, 0.04018626f, 0.03104368f, 0.00127800f, -0.05162955f, -0.00834579f, -0.01167926f, 
    -0.00159416f, -0.06190990f, 0.01466521f, 0.04015025f, -0.03928474f, 0.04904740f, 0.00898713f, -0.04442053f, 
    0.03208463f, -0.05391920f, -0.04617665f, 0.02008677f, -0.00937378f, -0.00252891f, -0.01028714f, -0.02589848f, 
    0.00860523f, 0.02488314f, -0.00794825f, 0.02176161f, -0.05699285f, -0.03973721f, 0.03195218f, -0.04616239f, 
    -0.03627811f, -0.03120352f, -0.01547751f, 0.01620853f, -0.04492698f, 0.01456145f, 0.03497373f, -0.01738180f, 
    0.01390793f, 0.00408262f, 0.02497303f, -0.03806635f, 0.00310321f, 0.00562721f, 0.03332270f, -0.04329206f, 
    0.23000140f, 0.10855046f, -0.26915458f, 0.12829028f, 0.27057001f, -0.16268435f, -0.15145475f, 0.08692499f, 
    0.19616045f, -0.09005453f, -0.04014467f, 0.04864121f, -0.14321391f, -0.04650429f, 0.10229297f, 0.03648429f, 
    -0.09026305f, -0.13908583f, -0.02421127f, -0.01058498f, 0.12151221f, 0.22341660f, 0.06207870f, -0.03223034f, 
    0.29667315f, -0.16344093f, 0.09170631f, 0.19606951f, -0.06060068f, 0.06948711f, 0.01808221f, -0.01471717f, 
    0.20121999f, 0.12627685f, -0.02944100f, -0.00673257f, 0.00779353f, -0.21840318f, -0.06197043f, 0.00874295f, 
    0.09943864f, -0.17262968f, -0.35608357f, -0.14303285f, -0.14130528f, -0.07156562f, -0.08328558f, -0.12358408f, 
    0.10427514f, -0.11806482f, 0.15710083f, 0.12227365f, 0.07936082f, -0.02054095f, 0.16182445f, -0.32025650f, 
    -0.27819821f, -0.31534413f, 0.08783658f, -0.34668800f, 0.11416559f, -0.16518365f, 0.19561075f, 0.25882745f, 
    0.16594386f, 0.06076015f, 0.08505182f, -0.03980896f, -0.04777680f, -0.15352264f, -0.13760133f, 0.00099154f, 
    0.04283985f, 0.05808083f, 0.16194221f, 0.05867113f, 0.10757871f, -0.02296670f, 0.01171213f, 0.13815458f, 
    0.24894834f, -0.01153568f, 0.15376726f, -0.04615364f, -0.07875454f, 0.16111611f, -0.03624783f, 0.02705190f, 
    0.05663420f, 0.08965994f, -0.08395306f, -0.08070720f, 0.09049731f, 0.03799020f, 0.06044167f, 0.07324212f, 
    0.05313420f, -0.19522066f, -0.08383463f, -0.12980631f, 0.17090893f, -0.13344592f, -0.15066107f, 0.02189776f, 
    0.10421291f, -0.00299984f, -0.14899108f, 0.01279282f, 0.19786359f, -0.16247417f, -0.05717618f, 0.15209012f, 
    0.07459718f, -0.13710219f, 0.05633955f, -0.01942144f, 0.24930039f, 0.07901078f, -0.03551049f, 0.06514765f, 
    0.23120821f, -0.08190920f, 0.15390858f, -0.04054708f, -0.13706699f, -0.11616934f, 0.08599022f, 0.10183088f, 
    -0.03940142f, 0.07694329f, -0.04536752f, -0.05198204f, -0.03472763f, 0.03858181f, 0.06777156f, 0.10468274f, 
    0.04568519f, 0.07006613f, 0.07499218f, 0.07369630f, 0.24235754f, 0.13990039f, 0.09925067f, -0.13051079f, 
    0.04818018f, -0.09881040f, -0.05527987f, 0.05445749f, 0.13705893f, 0.04801877f, 0.09959792f, 0.07889254f, 
    0.01574571f, -0.15896372f, 0.00365592f, 0.06834423f, 0.18215653f, -0.19880827f, 0.20601945f, -0.10887013f, 
    0.53530991f, 0.17637166f, 0.07748012f, 0.20645268f, -0.13437501f, -0.15566863f, -0.13402197f, -0.04416252f, 
    0.10299769f, -0.08137469f, 0.10441580f, 0.00416502f, -0.12432843f, -0.15739757f, 0.16441968f, -0.04751334f, 
    -0.11985067f, -0.05406423f, -0.13710810f, -0.31622788f, 0.18179727f, -0.10351028f, -0.09224654f, 0.11238554f, 
    -0.05144388f, -0.08023041f, 0.00981665f, 0.06940550f, 0.01706587f, -0.02257917f, 0.12282482f, 0.09857334f, 
    -0.08506627f, -0.00642366f, 0.03894209f, -0.10742313f, -0.01523383f, -0.11775482f, 0.05299528f, -0.04424636f, 
    -0.18445683f, 0.27982554f, 0.21688788f, -0.12218063f, -0.18249179f, 0.07490813f, 0.05757912f, -0.11507411f, 
    -0.05944350f, -0.03079700f, -0.09752996f, -0.07264674f, 0.09920890f, 0.04746887f, -0.00544108f, 0.17498966f, 
    0.08111476f, 0.11885205f, 0.03933896f, 0.20856510f, 0.07830874f, 0.06838635f, 0.04229359f, -0.02334541f, 
    -0.03987436f, -0.07473975f, 0.15291263f, -0.05062732f, -0.09639490f, -0.00405993f, -0.00037141f, 0.05914590f, 
    -0.02271990f, -0.07026869f, 0.00126864f, -0.00990592f, -0.06629501f, -0.09304324f, 0.15793958f, -0.16435783f, 
    -0.27679917f, -0.36064616f, 0.29075065f, 0.11336478f, 0.13872962f, -0.08991190f, 0.05459896f, 0.20603529f, 
    -0.00347725f, 0.14429630f, 0.13084362f, -0.09638379f, -0.13994625f, 0.13894172f, -0.02704151f, 0.10849853f, 
    0.23153242f, -0.08218703f, 0.17653611f, 0.10933468f, 0.13095535f, 0.03901859f, -0.07171822f, -0.06951036f, 
    -0.04844810f, -0.05739043f, -0.04434481f, 0.21200863f, 0.16728994f, 0.11272810f, 0.09827146f, -0.07533797f, 
    -0.09200041f, -0.08566588f, 0.12262376f, 0.01206852f, -0.14773242f, -0.21220833f, -0.19830993f, -0.24398482f, 
    -0.10811059f, -0.08431370f, -0.10396507f, 0.17839929f, -0.30962351f, 0.12320453f, -0.08219606f, 0.01912114f, 
    0.06180939f, 0.02214507f, -0.02878515f, 0.07019586f, 0.15060043f, 0.08314884f, -0.12995043f, 0.08704811f, 
    0.04757529f, -0.08788125f, 0.03491770f, 0.16467288f, 0.28029078f, 0.16430664f, 0.08143525f, 0.12328007f, 
    -0.13690655f, -0.13345774f, -0.02668834f, 0.01246375f, -0.02781476f, 0.31779140f, 0.06203795f, -0.05039496f, 
    -0.01366804f, 0.04359588f, 0.09757799f, 0.04776202f, 0.20091441f, -0.04680409f, -0.14967877f, 0.12120089f, 
    0.00618386f, -0.02686267f, -0.03465248f, 0.04253164f, -0.00851512f, -0.02541978f, -0.03110227f, -0.01240179f, 
    -0.02137990f, 0.02724742f, 0.03180491f, -0.05269486f, -0.04635081f, -0.01806205f, -0.01851356f, 0.01599239f, 
    0.00231245f, -0.05429925f, -0.04571201f, 0.02742895f, -0.05080738f, -0.06291960f, -0.05467847f, -0.06675347f, 
    0.00151594f, -0.01795842f, -0.05601053f, -0.02783854f, 0.00817059f, 0.00099744f, 0.00287851f, -0.01282059f, 
    -0.01702056f, -0.04577050f, 0.01974596f, -0.03258837f, 0.01723032f, -0.00320160f, -0.00730486f, -0.05750892f, 
    0.01947081f, 0.03350668f, 0.03823024f, -0.04811138f, -0.02975388f, -0.05290711f, 0.03331362f, 0.00079247f, 
    0.01464935f, -0.02410301f, -0.02998796f, -0.02499685f, 0.04343063f, 0.04244407f, -0.04867861f, -0.02704930f, 
    -0.04038693f, -0.05994072f, -0.03305089f, -0.02115322f, -0.06355812f, -0.02350694f, 0.03598145f, -0.01251491f, 
    0.02888716f, -0.03862218f, -0.04883121f, 0.00153915f, 0.01564571f, 0.04412011f, -0.00506587f, -0.02904025f, 
    0.02582239f, 0.03746682f, 0.00160954f, 0.03334248f, -0.05314237f, -0.00951953f, -0.00533877f, 0.00793129f, 
    0.02227383f, 0.04084856f, -0.00137448f, 0.03242420f, 0.03727089f, 0.02614208f, 0.02741897f, 0.03035288f, 
    0.03298317f, -0.00655332f, -0.02671374f, -0.03546801f, -0.06229784f, -0.01880860f, -0.04674689f, -0.03759713f, 
    -0.06483799f, 0.03596217f, -0.02747153f, -0.01030061f, 0.01923767f, 0.03711932f, -0.04073516f, -0.03423624f, 
    -0.05437640f, 0.01116505f, 0.04255433f, 0.03273337f, 0.04046668f, -0.01235633f, -0.02247937f, -0.04562653f, 
    -0.03722719f, -0.02284233f, 0.04304620f, -0.01364952f, 0.02506437f, 0.03967906f, -0.03880128f, -0.06622631f, 
    -0.04635118f, 0.03360141f, -0.03463648f, -0.06284092f, 0.01864926f, 0.03819782f, -0.06364888f, -0.03884631f, 
    -0.03231480f, -0.03254276f, 0.03439609f, -0.05157579f, 0.03010704f, -0.01779976f, 0.00282827f, 0.04083578f, 
    0.04002127f, 0.00195251f, 0.01606734f, -0.01979062f, -0.00610492f, -0.00325820f, -0.05851253f, 0.02145375f, 
    -0.05586232f, -0.02973773f, 0.03982940f, 0.02349181f, 0.03917153f, -0.01540968f, -0.03150778f, -0.01342592f, 
    0.01498068f, 0.04148113f, 0.00866199f, -0.02998540f, -0.04324427f, -0.03627414f, 0.01816829f, 0.00553488f, 
    -0.00776336f, 0.01212847f, 0.04575116f, 0.04415226f, 0.03083003f, 0.01791754f, -0.02338668f, 0.04106706f, 
    0.00345976f, -0.02876113f, 0.01215628f, 0.02635967f, 0.01861770f, -0.04416825f, -0.02888738f, -0.05981731f, 
    0.00391710f, -0.02680046f, 0.00191997f, -0.01168243f, -0.00306615f, 0.03629395f, 0.00572122f, -0.01697718f, 
    0.02378683f, 0.04276393f, -0.00844390f, 0.02674960f, 0.01668740f, -0.02193997f, -0.05910475f, -0.04791405f, 
    0.02806538f, -0.03519901f, -0.02782513f, -0.01530000f, -0.03576397f, -0.03364733f, -0.00458121f, -0.03598592f, 
    -0.01852663f, 0.00740112f, -0.06436755f, -0.03750424f, -0.01814713f, 0.00600673f, -0.02605101f, 0.03815060f, 
    0.04531771f, 0.00064924f, 0.04408703f, -0.01909611f, -0.05295404f, -0.02971638f, 0.02484291f, -0.05334813f, 
    -0.03729807f, -0.00632066f, -0.03741536f, -0.04467297f, -0.05719884f, -0.02286744f, -0.06347669f, 0.02788309f, 
    0.03450309f, 0.04664271f, 0.00210656f, -0.05485889f, 0.04073066f, -0.05439235f, 0.04389698f, -0.03595089f, 
    0.01234871f, 0.04138348f, -0.04253974f, -0.02154903f, -0.04392935f, 0.04581408f, -0.02742599f, -0.03997927f, 
    -0.01835569f, 0.03518603f, -0.02265767f, 0.01987175f, 0.02107781f, -0.05629254f, 0.02123768f, 0.01308251f, 
    -0.03905030f, -0.05221382f, -0.01698516f, -0.00974952f, -0.01984886f, 0.02813412f, 0.00840700f, 0.03882469f, 
    -0.02354385f, -0.02338511f, -0.01176442f, 0.04746996f, 0.00974268f, -0.06469186f, -0.00875134f, 0.00487884f, 
    0.03446415f, -0.03272122f, 0.03114310f, -0.02331471f, -0.06285216f, -0.04126694f, -0.00533876f, -0.02882417f, 
    0.02340899f, 0.03644776f, 0.02291176f, 0.01110619f, -0.05915087f, 0.03114657f, -0.01453824f, 0.01052604f, 
    0.01480593f, -0.03509176f, -0.00064578f, 0.00869571f, 0.00790190f, 0.01798030f, 0.02746016f, 0.01529576f, 
    0.01935201f, 0.00225585f, -0.05541732f, -0.05378321f, -0.05404428f, 0.00791762f, 0.04442931f, -0.06122773f, 
    -0.03398231f, -0.03058582f, -0.00112151f, -0.02044019f, -0.06143267f, -0.03735978f, 0.02774790f, 0.04209603f, 
    0.01169870f, 0.00371948f, -0.02874770f, 0.01568250f, 0.00763973f, -0.00501327f, -0.04456764f, -0.04600549f, 
    0.03880488f, -0.05933158f, -0.03252283f, 0.02366044f, -0.02767623f, 0.03324979f, 0.04452640f, -0.00663477f, 
    0.33833677f, 0.30614179f, -0.05309376f, -0.14331040f, 0.09324532f, -0.02315228f, -0.00385780f, -0.12222570f, 
    -0.00721136f, -0.00144646f, 0.01717658f, 0.05110011f, 0.05475929f, -0.07307015f, -0.02941465f, -0.07556127f, 
    0.01830923f, 0.00685256f, -0.19899055f, -0.00243665f, 0.07461115f, 0.01569954f, -0.30747327f, 0.03135883f, 
    -0.06502811f, -0.07799895f, 0.03413043f, -0.09534997f, 0.04055369f, -0.02989359f, 0.00849461f, -0.02405956f, 
    0.21275499f, -0.08660855f, 0.05845025f, -0.07091369f, 0.08047058f, -0.04699975f, 0.05127299f, 0.14799146f, 
    0.02510850f, 0.15966591f, 0.04666888f, -0.15584138f, 0.09207030f, 0.10717691f, 0.05169826f, 0.06658643f, 
    -0.00073128f, -0.00800903f, 0.03221806f, -0.03541967f, 0.02273189f, -0.18746328f, -0.06159512f, -0.18327120f, 
    -0.16817334f, -0.27653119f, -0.07641488f, -0.33181462f, -0.05921131f, -0.07594743f, 0.04408267f, -0.03683581f, 
    0.11894283f, 0.08348209f, 0.23674405f, 0.01339745f, 0.02277598f, -0.10728323f, 0.01340637f, 0.00493279f, 
    0.09392127f, 0.10177515f, -0.03054624f, 0.07805786f, 0.08723400f, 0.05622255f, 0.05838553f, 0.08876859f, 
    0.04797661f, -0.01129097f, 0.04217326f, -0.25159290f, -0.04419696f, 0.14209923f, 0.05545344f, -0.03223805f, 
    0.03935657f, 0.09472398f, 0.11587389f, 0.09379411f, 0.10168975f, -0.07895491f, 0.10409252f, 0.09451098f, 
    0.03773875f, -0.14442591f, -0.09152992f, -0.18347949f, 0.16069441f, -0.27042609f, -0.01761616f, -0.15751615f, 
    0.18569557f, 0.12661251f, -0.10228700f, -0.05076938f, -0.02519401f, 0.06113970f, 0.07607308f, 0.03933660f, 
    -0.00224275f, -0.06717251f, 0.07694386f, 0.00329245f, 0.06442806f, 0.05504536f, -0.03415897f, 0.02556227f, 
    -0.19025984f, -0.19827554f, 0.13947198f, 0.35185742f, -0.12092150f, -0.16269039f, -0.09392810f, -0.02798282f, 
    -0.05415119f, 0.08506312f, -0.02885189f, 0.00233985f, 0.09536897f, 0.12840033f, -0.00577748f, 0.09984232f, 
    0.19056191f, 0.08689181f, 0.09780896f, 0.11096477f, 0.02083109f, 0.15813221f, 0.34413987f, 0.18235259f, 
    -0.01246521f, -0.08648305f, -0.08865567f, 0.01819687f, 0.15989280f, 0.09040106f, 0.12046777f, 0.04890119f, 
    0.03870119f, 0.05508613f, -0.06280389f, 0.03522831f, 0.04495820f, -0.03435883f, 0.05953177f, -0.02314331f, 
    0.06245726f, 0.04844858f, 0.40608275f, 0.26723394f, -0.00098784f, -0.10723341f, -0.15691173f, -0.18840539f, 
    -0.01446904f, -0.03003252f, 0.09221351f, 0.02187540f, -0.04147240f, 0.00776552f, -0.00413284f, 0.11730100f, 
    -0.25903854f, -0.09031288f, -0.28436056f, -0.29305708f, -0.21442963f, -0.20887870f, 0.13978367f, 0.26130730f, 
    0.02301100f, -0.03984234f, -0.01960805f, -0.19001533f, -0.09579455f, 0.01371122f, 0.01303880f, -0.07506914f, 
    -0.00778423f, 0.03361953f, -0.08429839f, -0.02304153f, -0.05835811f, -0.03532653f, 0.10345700f, -0.08336653f, 
    0.15687309f, 0.04076834f, 0.11933591f, 0.01208997f, 0.14432327f, 0.07189382f, 0.04225280f, -0.09444852f, 
    0.05910695f, -0.07053861f, 0.02854700f, 0.02834669f, 0.06752129f, 0.02735949f, -0.10293925f, 0.05779481f, 
    0.17302406f, 0.05488601f, 0.04913959f, 0.12989734f, -0.16449809f, -0.07417575f, 0.17058171f, 0.20284288f, 
    0.00865008f, -0.10248323f, -0.07763526f, -0.00697088f, -0.01561473f, 0.05266932f, 0.04351592f, 0.06626544f, 
    -0.05770382f, -0.12051358f, -0.00148371f, -0.02596619f, 0.02583021f, 0.00255897f, 0.05348201f, -0.12642661f, 
    -0.50177276f, -0.15761729f, 0.32035956f, 0.14412433f, 0.00218105f, -0.10210339f, -0.08325929f, -0.15632790f, 
    0.17606497f, 0.01420742f, 0.01080940f, -0.06680191f, 0.11440303f, 0.10145792f, 0.05310539f, -0.02362293f, 
    0.17455445f, 0.02390078f, 0.11097439f, 0.17085683f, -0.11424323f, 0.09661265f, -0.17212485f, -0.19348209f, 
    0.09856513f, 0.07325688f, 0.04346404f, -0.00616496f, 0.00267564f, 0.06352867f, 0.08926195f, 0.05709247f, 
    -0.02355660f, -0.07149096f, 0.07320549f, -0.04188673f, -0.06186399f, -0.17271839f, -0.11021589f, -0.02449774f, 
    -0.13829866f, -0.23542866f, -0.21725900f, 0.38565034f, -0.19087479f, 0.05384706f, 0.04557366f, -0.05971469f, 
    -0.22519891f, 0.09356505f, -0.03284203f, -0.02086129f, -0.03667229f, -0.04793891f, -0.05456815f, -0.01264644f, 
    -0.07207447f, -0.13520367f, 0.00894827f, -0.21527939f, -0.04802361f, 0.14730521f, -0.00089161f, -0.12954341f, 
    0.14464420f, -0.00911918f, 0.00955945f, -0.03643844f, -0.14597034f, 0.15849642f, 0.07902252f, 0.09596881f, 
    0.00024278f, -0.06501386f, -0.04060822f, 0.01508687f, 0.00633245f, -0.04738299f, -0.06243580f, 0.04753437f, 
    0.04473205f, -0.07535977f, 0.07966754f, -0.06103196f, 0.08787833f, -0.16652609f, -0.00241990f, -0.10027726f, 
    -0.01761765f, -0.03863498f, 0.12000146f, 0.12238754f, 0.06443195f, -0.12823878f, 0.12421419f, -0.06763680f, 
    0.01041243f, 0.19229226f, -0.23007804f, -0.11130697f, 0.08928771f, -0.15805313f, 0.08618012f, -0.32486096f, 
    -0.03398430f, -0.11597075f, -0.00669378f, -0.14505668f, 0.07886544f, 0.01912504f, -0.12055814f, 0.06419998f, 
    -0.03991688f, 0.04831919f, 0.00531716f, 0.12521060f, -0.08692371f, 0.11174460f, -0.11182934f, 0.05794716f, 
    0.06895956f, -0.21037571f, -0.18203627f, -0.05349547f, 0.22930273f, -0.03011926f, 0.17819659f, 0.13089824f, 
    -0.04695134f, 0.01044965f, -0.01131363f, -0.08093647f, 0.08540597f, -0.24669315f, -0.06552649f, 0.04031633f, 
    -0.07846090f, -0.03895249f, -0.12152022f, -0.15683126f, -0.49210179f, 0.43313026f, 0.02771801f, 0.16728850f, 
    0.02676025f, 0.07475848f, 0.00287694f, -0.04905578f, 0.03510807f, -0.17281666f, 0.07566098f, 0.00769680f, 
    -0.02216994f, 0.00971030f, -0.06894690f, 0.03401586f, -0.01475916f, -0.01820576f, 0.01408343f, -0.08601847f, 
    -0.03945740f, -0.01518106f, -0.00806255f, -0.18371618f, -0.23169252f, 0.10908541f, -0.00198544f, -0.03164492f, 
    -0.05311447f, 0.11636310f, 0.02795068f, 0.11496820f, 0.07866945f, -0.00963281f, 0.01350191f, 0.08547473f, 
    -0.13428119f, -0.11408351f, -0.23320840f, -0.06744906f, 0.63191772f, -0.01639475f, -0.02872893f, -0.40198702f, 
    -0.17592472f, -0.12049361f, 0.02766224f, -0.10149927f, -0.07556597f, 0.04484073f, -0.06350879f, 0.13236447f, 
    0.01291360f, 0.02079078f, 0.04280552f, -0.06125391f, 0.03999449f, -0.03998727f, -0.05987055f, -0.07496030f, 
    -0.06097836f, -0.12700608f, -0.13340202f, 0.02339202f, 0.27959076f, -0.07096129f, 0.00367754f, -0.12260585f, 
    0.00781697f, 0.01580997f, -0.14959235f, -0.02167797f, -0.04151912f, 0.04913091f, 0.08040623f, 0.00430614f, 
    0.08719763f, 0.01505347f, 0.04470480f, 0.08892553f, 0.10335539f, -0.11111428f, 0.06472035f, 0.04600699f, 
    0.22724029f, 0.05225941f, 0.03891297f, -0.04029470f, 0.08242534f, -0.05344693f, -0.01887069f, 0.01109495f, 
    -0.01364723f, 0.02263391f, 0.01001556f, -0.05108353f, 0.01502135f, 0.01666359f, -0.05909571f, -0.11209013f, 
    -0.01611832f, 0.02450959f, -0.14956844f, 0.08518461f, 0.32165870f, 0.19086511f, -0.00718695f, 0.06805555f, 
    -0.05810842f, -0.02615259f, -0.02261483f, 0.00807003f, -0.03120153f, 0.00308096f, 0.00376961f, 0.16469282f, 
    -0.15345336f, 0.01344640f, -0.07006805f, -0.11838336f, 0.19853710f, 0.07412631f, 0.07583541f, 0.27274618f, 
    0.45223394f, -0.01636682f, 0.04086901f, 0.14611970f, -0.01156410f, -0.07592400f, -0.12822713f, 0.05261383f, 
    0.05812896f, -0.07157576f, 0.12868239f, -0.06341919f, 0.05416481f, 0.05345935f, 0.03870161f, -0.09263222f, 
    -0.11395965f, -0.03703333f, 0.45661610f, 0.30199233f, 0.39517546f, -0.16730165f, -0.01181855f, -0.05924173f, 
    0.10854327f, -0.15281595f, -0.04080808f, 0.04582456f, -0.00884765f, -0.03801186f, -0.11698402f, -0.01300101f, 
    0.06277223f, 0.05724740f, -0.03708111f, 0.21862710f, 0.16278321f, -0.04960672f, -0.03827573f, 0.09661773f, 
    0.26413804f, 0.10304799f, 0.07594740f, -0.00214976f, -0.05206636f, 0.04200786f, -0.01553846f, -0.00175415f, 
    -0.00816505f, -0.05450482f, -0.00871050f, -0.00057022f, -0.02803514f, 0.00363600f, -0.03166321f, 0.00360838f, 
    -0.37277803f, 0.31062883f, -0.07816157f, 0.05139922f, 0.21488164f, -0.04375368f, 0.06972831f, -0.06697312f, 
    0.01706382f, 0.08291987f, -0.21728639f, 0.06013485f, 0.05341380f, 0.10809898f, 0.02822093f, -0.20413269f, 
    0.17533326f, 0.03365836f, 0.05779450f, -0.01027590f, 0.08686788f, -0.05544128f, -0.09160788f, -0.17822273f, 
    -0.24069457f, -0.07865290f, -0.02496529f, -0.02368354f, -0.02193294f, -0.09810900f, -0.11691034f, -0.05498040f, 
    0.01601412f, 0.01336237f, -0.00295833f, -0.08065694f, -0.08207285f, -0.15333571f, -0.11351729f, -0.08732072f, 
    0.13832189f, 0.10588027f, 0.25150922f, 0.14599702f, 0.14211836f, 0.17204964f, 0.14887764f, -0.06934439f, 
    -0.03248643f, 0.15104780f, -0.06528300f, 0.03786880f, -0.09180740f, 0.00050858f, -0.12620702f, -0.03284219f, 
    -0.10535341f, 0.02993578f, 0.03411868f, -0.05611299f, -0.00941000f, -0.07023419f, -0.10603859f, -0.10614604f, 
    -0.35672688f, 0.16431811f, -0.05042898f, 0.03784082f, 0.09904611f, 0.22419067f, 0.07338425f, 0.02349942f, 
    0.06337076f, -0.10203641f, -0.13988607f, -0.06516197f, 0.11129561f, -0.17602639f, 0.00847068f, -0.02035644f, 
    -0.02230859f, -0.02903138f, 0.04803995f, -0.00217972f, 0.01359422f, -0.04086481f, 0.02126742f, -0.01691933f, 
    -0.00498706f, -0.03375160f, -0.05967941f, -0.05175464f, 0.02125476f, -0.05456282f, 0.02089700f, -0.02552888f, 
    0.01644963f, -0.03318372f, -0.05750739f, -0.05484580f, 0.01392825f, -0.05038866f, 0.00435911f, 0.03729267f, 
    -0.02673463f, 0.01828353f, -0.01358740f, 0.04452728f, -0.05306254f, -0.05989541f, -0.03342458f, 0.00255431f, 
    0.00448287f, -0.00630410f, -0.00391155f, -0.04062055f, 0.04912486f, 0.01174356f, -0.00616338f, 0.02765181f, 
    -0.04725102f, -0.05478095f, 0.00862048f, -0.00239072f, 0.03972180f, 0.00489050f, 0.00141958f, -0.00959910f, 
    -0.05363773f, -0.01665737f, 0.04789592f, -0.00301466f, -0.03571100f, 0.03388338f, -0.00790216f, -0.02907367f, 
    -0.03103918f, 0.02469727f, 0.03552480f, -0.01932562f, 0.03239890f, -0.01880101f, -0.02156026f, 0.04209169f, 
    -0.02936209f, -0.00785290f, -0.03342691f, 0.02462824f, -0.02534178f, 0.04266124f, 0.00527083f, 0.00379284f, 
    0.04185250f, 0.04769207f, -0.00625174f, -0.03256215f, -0.02754536f, 0.00615224f, 0.02856827f, -0.01838963f, 
    0.00759004f, -0.00806150f, -0.05346060f, 0.03440860f, -0.01540056f, 0.00852143f, 0.04354606f, 0.03501248f, 
    0.03781578f, 0.01373042f, -0.05472859f, 0.04738556f, 0.00267671f, 0.01682121f, 0.04270659f, -0.00566210f, 
    0.00211565f, -0.01036893f, -0.00325038f, 0.02279230f, -0.05030009f, -0.03208615f, 0.01477157f, 0.04621224f, 
    -0.04506107f, 0.03595899f, -0.00895185f, -0.03003548f, -0.05497774f, -0.02694793f, -0.03179058f, 0.00624187f, 
    -0.03435312f, -0.05769704f, 0.00258852f, 0.00877097f, 0.03910792f, -0.00641457f, 0.02541426f, -0.02126028f, 
    -0.01853343f, 0.04875300f, 0.04871490f, 0.00520115f, 0.04809281f, 0.00217016f, -0.00759510f, -0.04029657f, 
    -0.02262802f, 0.04642301f, 0.01391627f, -0.04914593f, 0.03236590f, -0.02255858f, 0.02875486f, -0.04819449f, 
    0.02736322f, -0.04648254f, -0.01799104f, 0.02991267f, -0.04228166f, 0.00480143f, -0.02584333f, 0.00596981f, 
    -0.05039362f, 0.01727781f, -0.02373170f, 0.01768604f, -0.05695899f, 0.02140668f, -0.01039419f, -0.01721405f, 
    -0.00233011f, 0.04075688f, -0.00239198f, -0.02868346f, -0.03011287f, -0.05714381f, 0.00944814f, -0.01388436f, 
    -0.03320758f, 0.02309283f, -0.02302413f, -0.03495273f, -0.05676308f, 0.00370778f, 0.03401311f, -0.05526630f, 
    0.00462812f, 0.02121904f, 0.00799989f, 0.01131163f, -0.00303906f, 0.02359093f, -0.02184162f, 0.04927025f, 
    -0.04351597f, -0.02847159f, -0.04127556f, -0.01889727f, -0.01392585f, 0.05422492f, 0.01226110f, 0.01840679f, 
    0.00499007f, -0.00648714f, -0.03055072f, -0.05007068f, 0.02406004f, -0.02859333f, -0.03607259f, -0.03931244f, 
    0.04672000f, 0.04069084f, 0.02100548f, -0.00074380f, -0.05463837f, 0.03338592f, 0.05002078f, -0.03802198f, 
    0.05408642f, 0.02855816f, -0.02716107f, 0.03545721f, 0.01326444f, 0.04416928f, -0.04119927f, -0.05108446f, 
    -0.01456958f, -0.02975960f, -0.02287257f, -0.05452508f, -0.05557276f, 0.00031527f, 0.00800909f, -0.02393646f, 
    -0.02105781f, -0.03072024f, -0.04875475f, -0.02049245f, 0.00824376f, 0.01464205f, -0.00774395f, 0.00242053f, 
    -0.03587502f, -0.04935881f, -0.04395656f, -0.02860534f, 0.02809280f, -0.03301660f, -0.04343292f, -0.00083517f, 
    -0.03364550f, -0.02657853f, -0.04672569f, 0.01614239f, -0.01462385f, -0.05107322f, -0.04016565f, 0.03442057f, 
    0.01651522f, -0.02356492f, -0.05349324f, 0.05509428f, -0.00352406f, -0.01119743f, -0.03203103f, 0.01671484f, 
    -0.04645059f, -0.04707947f, 0.03962352f, -0.04446662f, 0.04874110f, -0.01114297f, -0.02482801f, -0.02909021f, 
    -0.04755335f, -0.05202825f, -0.02508937f, -0.01439005f, -0.00563120f, -0.05304493f, -0.04814102f, 0.03881599f, 
    0.00253149f, 0.00230845f, -0.00123037f, -0.01156853f, 0.05004613f, -0.02101227f, -0.04779949f, -0.00069188f, 
    -0.05613979f, -0.04251214f, -0.00927317f, -0.05426821f, -0.00201674f, -0.04616277f, 0.01282589f, 0.01843467f, 
    -0.00417939f, -0.03035293f, -0.04613455f, -0.03140303f, 0.03402980f, 0.04118779f, -0.06058405f, 0.04460692f, 
    0.03671381f, -0.01980985f, 0.00990020f, 0.01005263f, 0.03536301f, -0.01133185f, 0.04921628f, 0.04422167f, 
    -0.04792895f, -0.00155400f, -0.03395136f, 0.04748924f, 0.04109747f, 0.03342343f, -0.04247002f, 0.01704064f, 
    0.02934431f, -0.04474137f, -0.00130041f, -0.05199893f, -0.03835064f, 0.04623032f, 0.03178160f, -0.04116528f, 
    -0.00390241f, -0.03595501f, -0.04838929f, -0.00865828f, -0.04032320f, -0.02000025f, 0.03500407f, 0.03650151f, 
    0.01721870f, -0.06702174f, -0.05897380f, -0.00143843f, -0.00211390f, 0.00784665f, -0.03749880f, -0.07401151f, 
    -0.08199058f, 0.02579402f, -0.06313177f, 0.01306152f, -0.04675554f, -0.01811108f, -0.08449145f, -0.00298288f, 
    -0.07970483f, 0.00055256f, -0.04486274f, 0.02081041f, -0.08558274f, -0.06148944f, -0.06435358f, -0.08062971f, 
    -0.08082757f, -0.01122813f, 0.01931223f, -0.06456852f, -0.01692052f, -0.01796697f, -0.05389537f, -0.04813402f, 
    0.01643796f, -0.02139615f, 0.00089186f, -0.07914361f, -0.01550579f, -0.08355179f, -0.03352656f, -0.00517837f, 
    -0.00611476f, -0.01379285f, -0.05111384f, -0.01161116f, -0.05861191f, -0.02377782f, 0.00031192f, -0.02190781f, 
    -0.03342618f, -0.00676019f, -0.04964524f, -0.07447149f, 0.01242171f, -0.00642114f, 0.02197974f, -0.05468959f, 
    -0.02471544f, 0.01303779f, -0.05058328f, -0.00964286f, -0.03664195f, -0.07159673f, -0.06241529f, -0.02696241f, 
    -0.04654752f, -0.03382254f, -0.04227485f, -0.04707897f, -0.03644552f, -0.06366242f, -0.08406992f, -0.05960866f, 
    -0.02779756f, -0.04439856f, -0.03509338f, 0.02239389f, -0.08141419f, -0.05917201f, -0.07281174f, -0.01475633f, 
    0.01338357f, -0.04278506f, -0.05407358f, 0.02551517f, -0.04089171f, -0.00635672f, -0.07421326f, 0.04495254f, 
    -0.04151435f, -0.05010845f, -0.02920621f, 0.02225358f, -0.07048884f, 0.02376825f, -0.07740537f, -0.06154874f, 
    -0.07601605f, 0.02174990f, -0.03407804f, -0.03152945f, 0.01980334f, -0.03942901f, -0.01714303f, -0.00815099f, 
    -0.07292245f, 0.01604452f, -0.01585462f, -0.02184999f, 0.00324913f, -0.06871755f, -0.07695699f, -0.04576339f, 
    -0.01832253f, 0.02092946f, 0.00260434f, -0.08139067f, -0.04472687f, -0.01668544f, -0.07405145f, 0.00306253f, 
    -0.01399896f, -0.07282160f, 0.01119482f, -0.03640844f, -0.01174804f, 0.00998421f, -0.06201372f, -0.07609865f, 
    0.02489185f, 0.03982006f, -0.00323010f, 0.02225247f, -0.04926529f, 0.04999215f, -0.03603117f, -0.02562276f, 
    -0.02110371f, 0.04152893f, 0.02053189f, -0.03086014f, -0.00594786f, 0.02597460f, -0.02345328f, -0.07359448f, 
    -0.02823148f, -0.04841600f, 0.00254832f, -0.08285838f, 0.01419094f, -0.02430116f, -0.06870098f, -0.00886650f, 
    -0.08350231f, 0.02229240f, -0.08581054f, 0.04818273f, -0.01316457f, 0.01481805f, 0.02421162f, -0.07791439f, 
    -0.05594094f, -0.07567987f, -0.06581707f, -0.04149604f, -0.02704409f, -0.02013846f, -0.07768220f, -0.07524307f, 
    -0.00879824f, -0.04415538f, -0.02359959f, -0.02583913f, -0.06402618f, 0.00360078f, -0.02212841f, -0.00293497f, 
    -0.07886127f, -0.05222721f, -0.04978474f, 0.01019517f, 0.00127930f, 0.03520394f, -0.08454771f, -0.03553519f, 
    0.01445961f, -0.06065205f, 0.01992967f, -0.08557915f, 0.00021387f, -0.08105869f, -0.07255277f, -0.06705776f, 
    -0.00318766f, 0.02178321f, -0.04109138f, -0.02982688f, 0.02381296f, 0.00036419f, -0.02872097f, 0.04501867f, 
    -0.07263993f, -0.07103474f, -0.04673566f, -0.07919022f, -0.03422265f, -0.04960369f, 0.00185644f, -0.04970684f, 
    -0.00009581f, -0.05023346f, -0.03029652f, 0.01493388f, -0.05444246f, -0.02933860f, 0.02518968f, 0.02056744f, 
    -0.06729538f, -0.08135708f, 0.00899949f, -0.00751011f, -0.07510769f, -0.05860168f, 0.00185072f, -0.04078345f, 
    -0.05086504f, -0.06225187f, -0.04182553f, -0.02422954f, 0.01900844f, 0.02413162f, -0.03992579f, 0.00165941f, 
    -0.03576571f, -0.05252614f, -0.04133210f, -0.04088918f, -0.07874737f, -0.02032475f, -0.00228974f, -0.01078108f, 
    -0.00781813f, -0.03477668f, -0.05595324f, -0.06891341f, -0.07157735f, 0.00493992f, -0.03860205f, -0.01515973f, 
    -0.04490952f, -0.01367087f, 0.01754798f, 0.00510656f, -0.00603757f, -0.07125581f, 0.00619287f, -0.08092497f, 
    0.02084391f, -0.01251994f, -0.08130140f, -0.02537365f, 0.02442382f, -0.05919156f, -0.05668491f, -0.02191364f, 
    -0.04784281f, -0.07084948f, -0.00138387f, -0.05432385f, 0.00171686f, -0.05983302f, 0.00373496f, -0.04480841f, 
    -0.06759943f, -0.04367385f, -0.03526454f, -0.06034212f, -0.01999971f, -0.05324845f, -0.01734091f, -0.02438060f, 
    -0.04153962f, -0.06502301f, -0.05911248f, 0.01331749f, -0.00158264f, -0.02760853f, -0.06456821f, -0.02534962f, 
    -0.03537127f, 0.01607891f, -0.04801008f, -0.04641560f, -0.02426117f, -0.06465667f, 0.01378724f, -0.08569213f, 
    -0.05235900f, -0.08563346f, 0.02265746f, -0.06488758f, -0.02707022f, -0.04611927f, -0.03995587f, -0.07433461f, 
    -0.05228465f, -0.01024422f, 0.02022266f, 0.01092614f, -0.06396693f, -0.07301457f, 0.02133815f, -0.06556088f, 
    0.00467785f, -0.03711567f, -0.06031168f, 0.01446710f, -0.03194280f, 0.00737337f, -0.01028378f, 0.01101938f, 
    -0.17943977f, -0.03727139f, 0.14810379f, 0.02910883f, 0.07576659f, 0.05446837f, 0.06815964f, 0.07032853f, 
    0.04187442f, 0.11629455f, -0.05264917f, -0.06062209f, 0.03764622f, 0.20072526f, 0.02425436f, 0.02180134f, 
    0.02795641f, -0.16823490f, 0.10749150f, -0.00062289f, 0.25735047f, 0.34374881f, -0.08979953f, 0.14160562f, 
    0.17734902f, 0.02343631f, 0.03963929f, -0.10585321f, -0.29288900f, 0.12859948f, 0.18834077f, 0.07802951f, 
    0.00273326f, 0.13061169f, -0.07605828f, -0.06855287f, 0.06804204f, 0.11215075f, -0.11395618f, -0.14048310f, 
    0.04717477f, -0.08452053f, -0.09293625f, 0.06143050f, 0.07079590f, -0.00985164f, -0.00921046f, -0.29335865f, 
    0.11530495f, 0.00183861f, 0.08798703f, 0.07668058f, 0.06805250f, 0.23002088f, 0.04477138f, 0.05028388f, 
    0.09875337f, -0.01766296f, 0.10543299f, 0.12287951f, 0.29675871f, -0.21772297f, -0.32849744f, 0.03707987f, 
    -0.15929841f, -0.06689201f, 0.02212761f, 0.06538302f, -0.10499809f, 0.09649715f, 0.05051133f, 0.03005644f, 
    0.03194407f, -0.02792691f, 0.04302305f, -0.04333207f, -0.09455361f, -0.06475437f, 0.06126123f, 0.04209404f, 
    0.01948521f, 0.16823065f, 0.00809425f, 0.23704015f, 0.12385898f, 0.01737143f, -0.03156019f, 0.09497068f, 
    0.07269190f, 0.00911232f, -0.05509899f, -0.07457232f, -0.10112297f, 0.03408037f, -0.04109649f, -0.03186586f, 
    0.09591909f, 0.10674436f, 0.16658051f, 0.05427996f, -0.34021369f, 0.14799504f, -0.05857558f, 0.10758298f, 
    0.09251133f, 0.07125525f, 0.10193326f, 0.12059075f, 0.07356633f, -0.06282860f, -0.06930511f, -0.02842896f, 
    0.00789263f, -0.08902857f, 0.07022770f, -0.00101593f, 0.07159626f, 0.03674043f, -0.03416750f, 0.02434169f, 
    0.39146546f, 0.25371003f, 0.18726858f, 0.01548546f, 0.01821871f, 0.09923808f, 0.04031365f, 0.21153592f, 
    0.08912736f, -0.18157558f, 0.03704578f, -0.04667977f, -0.07647103f, -0.13599189f, -0.04797973f, -0.08665877f, 
    -0.09169544f, 0.05185351f, -0.31861216f, -0.10767151f, -0.08123095f, 0.02130440f, -0.27848476f, -0.16293530f, 
    0.16183096f, 0.07395867f, 0.09564828f, 0.17513333f, -0.02388770f, -0.09843644f, -0.02779387f, 0.10471804f, 
    0.04463390f, -0.02332260f, -0.06316333f, 0.04319313f, 0.00425286f, 0.00973975f, -0.07171313f, -0.01779050f, 
    -0.04793496f, -0.03483955f, -0.10595202f, 0.00310000f, 0.01383861f, 0.03590414f, 0.13444009f, 0.19553989f, 
    0.01573755f, -0.16351506f, 0.04060287f, 0.05543762f, 0.04750648f, -0.04700371f, -0.03070737f, -0.11310884f, 
    0.06740630f, 0.10019968f, 0.19694054f, 0.09879600f, 0.18572816f, 0.10213393f, -0.17276148f, -0.35976005f, 
    -0.06518576f, 0.01713377f, 0.09534170f, 0.09955766f, 0.11790401f, -0.05288880f, 0.07335147f, 0.08684734f, 
    0.03993231f, 0.01835985f, 0.04493218f, 0.10644767f, -0.04334990f, -0.22421600f, 0.00053622f, -0.08879352f, 
    -0.05515015f, 0.05037145f, 0.06060893f, -0.10429358f, -0.33035100f, -0.02842947f, -0.07689139f, -0.09473182f, 
    -0.18160832f, 0.04769919f, -0.00789606f, -0.10932653f, 0.09245919f, 0.08662449f, 0.03388489f, -0.05669264f, 
    -0.10786593f, 0.09039466f, -0.00424623f, -0.16418333f, 0.17264725f, 0.14226714f, -0.30252978f, -0.07281888f, 
    -0.02656774f, -0.03842763f, 0.10908566f, 0.00491452f, -0.01865009f, -0.10545333f, 0.01472912f, 0.01646401f, 
    0.03487422f, 0.05942531f, -0.03503117f, -0.00360056f, -0.05236674f, 0.02647199f, -0.19950679f, 0.04047280f, 
    0.46193004f, -0.21624506f, 0.10877847f, 0.07467028f, 0.15491675f, 0.09625702f, 0.13717887f, 0.16378702f, 
    -0.14785951f, 0.06992197f, 0.17327230f, -0.11092188f, -0.06139148f, 0.00294770f, 0.08869933f, 0.13636194f, 
    -0.02010092f, -0.13897249f, 0.00125979f, -0.08650109f, 0.12823519f, 0.01412872f, 0.04664479f, 0.10086481f, 
    0.10719173f, 0.01963248f, 0.00992681f, 0.04199423f, 0.10866621f, 0.13792641f, 0.00905446f, 0.01697923f, 
    -0.01707686f, -0.04789936f, -0.08376557f, 0.10851943f, 0.03501996f, 0.06144717f, 0.04933710f, 0.03562717f, 
    0.04665170f, 0.05729596f, 0.13866998f, -0.31485200f, 0.11367571f, 0.07356977f, -0.21095641f, -0.07718690f, 
    0.17590074f, -0.18347004f, 0.03206728f, 0.02086611f, 0.15613244f, 0.07865833f, -0.00387503f, 0.00114585f, 
    0.20432110f, 0.14013204f, 0.09834356f, 0.13834439f, -0.01401684f, -0.06627825f, -0.10989286f, 0.13189958f, 
    0.00813296f, -0.09245036f, 0.05774884f, 0.11854616f, 0.03091767f, -0.04044880f, -0.02589116f, -0.04583126f, 
    -0.05959982f, 0.06120282f, 0.09401240f, 0.03044886f, 0.02541077f, 0.09657504f, 0.14411448f, 0.02617541f, 
    -0.34945893f, -0.22822851f, -0.18624213f, 0.03617053f, 0.03813996f, -0.09854998f, -0.16688631f, -0.01834390f, 
    -0.24771403f, -0.08288258f, 0.03757474f, -0.09207945f, -0.16114023f, 0.00486497f, 0.14268868f, 0.01861864f, 
    0.04261056f, 0.01617917f, 0.00131814f, 0.02048490f, -0.30979243f, -0.04029303f, -0.14647262f, -0.03027567f, 
    0.09363858f, -0.14392120f, -0.05717851f, -0.17054097f, -0.28588808f, 0.24191728f, 0.07900085f, 0.13838266f, 
    -0.05975240f, 0.04622642f, -0.05098750f, -0.01148500f, 0.03774585f, 0.16486911f, 0.01323019f, 0.00263476f, 
    -0.14950222f, -0.10079022f, -0.16991377f, -0.03919025f, -0.28471547f, -0.03637626f, -0.22041073f, -0.12286776f, 
    -0.09787404f, 0.03853196f, 0.01596713f, -0.03751690f, 0.05808441f, 0.10107594f, 0.04580711f, 0.06162107f, 
    -0.05854905f, -0.12016291f, -0.09945527f, 0.06529924f, 0.33917809f, 0.05088481f, 0.04618429f, -0.08389470f, 
    -0.16692697f, 0.09728670f, -0.16294450f, -0.00641836f, -0.13249245f, 0.13259016f, 0.12498058f, 0.03196101f, 
    0.03714356f, 0.00397684f, 0.05936316f, -0.00256669f, 0.03147072f, -0.04260063f, 0.24111518f, 0.08040109f, 
    -0.18496859f, -0.21378765f, -0.14411867f, 0.06135870f, 0.13682389f, -0.15649761f, -0.35357970f, -0.14338337f, 
    -0.24275051f, -0.19841947f, 0.02861540f, 0.02969169f, 0.04925679f, 0.04657223f, 0.01604286f, 0.11067647f, 
    0.16179354f, -0.09033260f, 0.02835217f, -0.03308471f, -0.20428027f, 0.18530153f, 0.00086547f, 0.19108789f, 
    -0.00723114f, 0.07528653f, -0.10306533f, -0.08277669f, 0.01136137f, -0.03416905f, -0.04210529f, -0.01887642f, 
    0.06826102f, -0.05973322f, 0.03504472f, -0.00540894f, 0.10941248f, -0.07254647f, 0.06065283f, 0.11822809f, 
    0.10591821f, 0.24571311f, 0.22724050f, 0.03802937f, 0.02470337f, 0.07123506f, 0.18493614f, 0.13216530f, 
    0.09482834f, -0.21255326f, 0.14009517f, -0.00379568f, -0.12139981f, -0.08926617f, 0.05365481f, -0.00656218f, 
    -0.00151888f, 0.10730658f, -0.08878464f, 0.00922090f, -0.17290860f, 0.13317388f, -0.12750129f, 0.02082602f, 
    0.10077017f, 0.06963838f, 0.10271729f, 0.11680526f, -0.05119485f, -0.03466157f, -0.02660253f, 0.06855969f, 
    0.01660615f, 0.04936100f, 0.16431013f, 0.12648925f, -0.00963013f, 0.05245199f, -0.06139679f, -0.00679181f, 
    0.18195753f, 0.03818241f, -0.04861615f, -0.09620224f, -0.05225671f, 0.09380213f, 0.01604130f, 0.08690948f, 
    0.10140543f, -0.09850178f, 0.05866511f, 0.11418287f, 0.18246523f, 0.08159833f, 0.01423873f, -0.09543744f, 
    0.12562400f, 0.05241750f, 0.25507578f, 0.03318651f, 0.13780375f, 0.29289988f, 0.13000008f, -0.25820225f, 
    -0.06719543f, 0.15560180f, -0.04174153f, 0.16718321f, 0.11522964f, 0.03279367f, 0.08825671f, -0.00319511f, 
    0.01388188f, 0.01188779f, 0.02542247f, -0.01036389f, 0.02480316f, -0.10284209f, -0.04491972f, -0.04645849f, 
    -0.24056144f, 0.13041028f, 0.03794863f, -0.17813264f, -0.27445191f, 0.05794633f, 0.07780508f, 0.05711468f, 
    -0.07690670f, 0.18230690f, 0.05880706f, -0.08271421f, -0.09445696f, 0.04731405f, 0.10025566f, -0.01612400f, 
    0.00486720f, -0.05345581f, 0.04687794f, 0.04135000f, 0.04183367f, 0.21144989f, -0.06369829f, -0.03422862f, 
    0.01872772f, 0.09894352f, 0.15473843f, 0.07948104f, 0.03265724f, -0.04802134f, 0.00071189f, 0.05552467f, 
    0.02677580f, 0.09691454f, 0.02663374f, 0.08056414f, -0.02633783f, -0.08975422f, -0.13574445f, 0.08160579f, 
    0.48021561f, 0.08900296f, 0.35337594f, 0.02182169f, -0.01734451f, 0.03889451f, 0.01526384f, 0.16036068f, 
    -0.12146395f, 0.04962976f, 0.24452603f, 0.12101509f, -0.13835280f, -0.01878827f, 0.05195145f, 0.06993391f, 
    0.04801653f, 0.03925137f, 0.16739094f, -0.05602136f, -0.02191794f, -0.13060385f, -0.09219228f, 0.14010854f, 
    0.00793231f, -0.12186224f, -0.25462362f, -0.00714439f, -0.14497511f, 0.03031367f, 0.02745805f, 0.03016803f, 
    0.04737895f, 0.03246301f, 0.05440799f, 0.03538838f, 0.05933310f, 0.06974418f, -0.05858306f, -0.03578343f, 
    0.17318109f, 0.20333931f, -0.04404293f, -0.26110426f, 0.07051677f, 0.10146670f, -0.06542613f, -0.16463731f, 
    0.25674731f, 0.00243273f, 0.01965387f, -0.02567862f, 0.04536185f, 0.15613042f, 0.08294371f, -0.04831337f, 
    -0.02450314f, -0.02385965f, -0.00867684f, 0.06839228f, 0.21418449f, -0.10304168f, -0.12062936f, -0.04114971f, 
    -0.13490278f, -0.19426371f, -0.36917290f, -0.13515496f, -0.12603953f, -0.07912311f, 0.01795782f, 0.02972037f, 
    -0.05148415f, 0.05111585f, 0.11246304f, 0.10688568f, -0.05944682f, 0.08606862f, 0.08650791f, 0.01001170f, 
    -0.05868973f, 0.04980003f, 0.31685093f, -0.00413645f, -0.13029900f, -0.06562150f, -0.01934669f, 0.01874351f, 
    0.23267038f, -0.07586697f, -0.04010829f, 0.01556639f, 0.04889026f, 0.02649930f, -0.01729928f, -0.09172962f, 
    0.03533156f, 0.08412810f, 0.01075113f, -0.00713751f, 0.32684344f, 0.24948558f, 0.18894169f, -0.10817383f, 
    -0.07575538f, 0.01824570f, 0.02366894f, 0.06148233f, 0.11837272f, 0.02292697f, 0.07461683f, -0.07893085f, 
    0.06366584f, 0.00866525f, -0.01558454f, 0.10844129f, 0.04196500f, 0.13949287f, 0.11190029f, -0.10412768f, 
    -0.00220445f, -0.15414020f, -0.11200829f, 0.11946389f, 0.03739141f, -0.01473102f, 0.01305723f, 0.00428801f, 
    0.05111533f, -0.16844682f, 0.01290907f, 0.03990145f, -0.00785369f, 0.03816602f, 0.01075658f, -0.05143378f, 
    0.00204089f, 0.16573799f, 0.01383290f, 0.05379231f, -0.10912492f, 0.26620802f, 0.16641279f, 0.30669633f, 
    0.09602846f, 0.04178491f, 0.09437112f, 0.06509087f, 0.12241925f, -0.06099477f, -0.01226564f, 0.10479191f, 
    -0.00602295f, 0.09849530f, 0.09900802f, 0.01806970f, -0.01632330f, -0.00701113f, 0.03016184f, 0.02403105f, 
    0.08155672f, 0.05325466f, 0.21694303f, -0.10708633f, -0.24601366f, -0.03743255f, -0.05817140f, -0.01224617f, 
    -0.08040640f, -0.14324151f, -0.05043032f, 0.02782780f, -0.11235031f, -0.05500144f, -0.01748434f, -0.04089461f, 
    -0.03652955f, -0.02032005f, 0.02209393f, 0.00014390f, 0.26396647f, 0.10988893f, 0.18577911f, -0.10870108f, 
    -0.03346865f, -0.01979632f, 0.08035030f, 0.11023368f, -0.05893589f, -0.03013582f, 0.01532479f, -0.04054303f, 
    0.03089820f, 0.07130376f, 0.04768698f, -0.01920893f, 0.00179218f, 0.06666496f, -0.03555120f, -0.12863195f, 
    -0.21907017f, -0.01487388f, -0.32909054f, -0.06540670f, 0.05967383f, -0.02185417f, -0.14010736f, -0.03224267f, 
    0.00522918f, -0.00382652f, -0.14312036f, 0.02054678f, -0.07396938f, -0.10999144f, -0.05152221f, 0.10677903f, 
    0.02792068f, 0.09413512f, 0.03313986f, 0.02999462f, 0.00431234f, 0.03694076f, -0.11471063f, 0.21135132f, 
    0.23709510f, -0.03005030f, 0.03934018f, 0.12859990f, 0.11088282f, 0.01039965f, 0.06023117f, 0.10589711f, 
    -0.03617346f, 0.07961807f, -0.08864028f, -0.00779403f, -0.01315371f, 0.06224477f, -0.08274854f, 0.07613551f, 
    -0.27161989f, -0.05216984f, -0.06632415f, 0.05281506f, -0.03703110f, -0.08027739f, -0.06586884f, -0.02320120f, 
    0.07782561f, 0.16530208f, 0.02170841f, 0.08160917f, -0.10182260f, -0.02309062f, -0.04273133f, -0.02843047f, 
    0.05373158f, -0.04022697f, -0.01851894f, 0.01923514f, -0.12912722f, -0.23560157f, 0.06217156f, 0.08270270f, 
    0.17085335f, -0.14363645f, 0.04807747f, -0.00164942f, 0.07674360f, -0.12527183f, -0.02915104f, 0.04526853f, 
    -0.01815318f, -0.07207464f, -0.05912282f, -0.00678888f, 0.00587628f, 0.10468032f, -0.02681114f, -0.05556083f, 
    -0.03010524f, -0.13218902f, 0.08078221f, 0.12922028f, 0.00745256f, 0.08437876f, 0.01089256f, 0.01516208f, 
    0.08703849f, -0.19477607f, -0.05485704f, -0.08538000f, -0.02667358f, 0.00082478f, 0.03911464f, 0.07358095f, 
    -0.04134739f, 0.09137055f, -0.03153874f, 0.00833330f, -0.14497100f, -0.19542420f, -0.30731028f, -0.00178424f, 
    -0.02601602f, -0.04505765f, 0.01370081f, -0.11850693f, -0.04244518f, -0.14256862f, -0.03245522f, -0.00707933f, 
    0.00393786f, 0.02671075f, -0.01992130f, 0.02201445f, -0.00345179f, 0.04244396f, -0.01290286f, -0.03136618f, 
    -0.10870006f, 0.10690533f, -0.01267137f, -0.00425765f, 0.24502319f, -0.00763215f, 0.09235103f, -0.03635769f, 
    0.01086814f, -0.00806248f, -0.06496042f, 0.01692407f, 0.05411094f, -0.00014256f, 0.00878353f, -0.05141087f, 
    -0.07095126f, 0.04352522f, -0.02150504f, -0.11800083f, 0.20016283f, 0.00296329f, 0.11927608f, -0.11432761f, 
    -0.01945999f, -0.06435842f, 0.08528975f, -0.03891589f, 0.05363612f, -0.05263115f, 0.06659564f, 0.04389786f, 
    0.10886346f, 0.05798727f, 0.05141020f, -0.02190132f, -0.01041534f, 0.09070366f, 0.08910088f, -0.06332882f, 
    0.13603809f, -0.31349882f, 0.15091994f, -0.05473081f, 0.17724691f, 0.12495338f, -0.02106491f, 0.14699595f, 
    0.02346467f, 0.04580728f, -0.13465650f, 0.02513084f, -0.01492730f, 0.04629739f, 0.07766234f, 0.00261556f, 
    0.03082780f, 0.07116909f, 0.04500310f, 0.05390855f, -0.13318940f, 0.00354147f, 0.19707909f, -0.01257510f, 
    -0.24780896f, -0.15979379f, -0.01872878f, -0.05893012f, -0.05504032f, -0.10316678f, 0.00309965f, 0.06021373f, 
    -0.00072175f, 0.05530443f, 0.08379537f, 0.05564122f, 0.05017043f, -0.03620768f, 0.06779325f, -0.21458407f, 
    -0.31320623f, 0.01268930f, -0.15525085f, 0.16061786f, -0.02807978f, 0.04177752f, -0.18430716f, 0.18091577f, 
    -0.08125208f, -0.05594987f, 0.05143908f, -0.00601020f, 0.04142717f, -0.10293581f, 0.04309599f, 0.21191555f, 
    -0.11005037f, 0.20183480f, -0.16277535f, -0.20461749f, 0.09360595f, -0.31428480f, -0.02465714f, 0.01203324f, 
    -0.16505302f, 0.00022945f, -0.11260093f, -0.15388741f, -0.14154962f, -0.34167081f, 0.02671231f, -0.00752779f, 
    -0.21370099f, 0.03255532f, -0.02977631f, -0.01793392f, -0.13288333f, 0.11217948f, -0.11959095f, 0.01897100f, 
    0.12255394f, 0.13150570f, 0.02144617f, 0.09030508f, 0.12053329f, -0.01276895f, 0.02498352f, -0.01182238f, 
    -0.25866243f, 0.12084091f, 0.00354290f, 0.05020584f, 0.11379148f, -0.17834276f, -0.03935507f, -0.01143093f, 
    -0.35613465f, -0.12222566f, -0.05618904f, -0.14820112f, -0.19763218f, -0.02534292f, 0.28305849f, -0.20458184f, 
    0.08857398f, 0.04464148f, -0.09590432f, 0.03505336f, -0.03825810f, 0.07866273f, -0.05556321f, 0.02327734f, 
    -0.01875670f, -0.07770129f, -0.06667890f, -0.05800576f, 0.04658156f, -0.01226787f, 0.04654789f, 0.00190315f, 
    -0.04067682f, 0.05620308f, 0.10270884f, -0.08681120f, 0.09074748f, -0.01440986f, -0.11725198f, 0.06643739f, 
    0.00410948f, -0.05709105f, 0.10382020f, -0.02215108f, -0.01191715f, 0.08893151f, 0.16640191f, -0.02355903f, 
    -0.16826004f, -0.15288781f, -0.04238956f, -0.14669220f, 0.16052429f, 0.17801549f, -0.04119256f, 0.08631408f, 
    -0.20137814f, -0.09607744f, -0.11687642f, -0.07650885f, -0.02038063f, -0.07720798f, -0.01828424f, -0.01572174f, 
    0.16525565f, -0.02480929f, -0.04642614f, 0.00152887f, -0.08389287f, -0.03175226f, 0.02082093f, 0.07161197f, 
    0.09332918f, -0.01846117f, -0.10146746f, -0.08048221f, 0.24588422f, 0.06086570f, 0.18883203f, -0.08215323f, 
    0.09079751f, 0.04194250f, 0.06703480f, -0.07166908f, -0.09661833f, 0.07731728f, 0.12013935f, -0.04800539f, 
    0.11259781f, 0.07295920f, 0.07825720f, -0.00079802f, 0.19702686f, -0.17880452f, 0.01735742f, -0.09235897f, 
    -0.04988636f, 0.01744022f, 0.06894884f, -0.05520704f, -0.01435711f, -0.12907676f, 0.04008735f, -0.04966335f, 
    0.01574495f, -0.00899588f, 0.03733923f, -0.10646265f, 0.12081550f, -0.00894839f, 0.03541956f, 0.00176177f, 
    0.50286281f, -0.02524314f, -0.03615392f, -0.11417375f, 0.16410762f, 0.06526481f, -0.00718624f, -0.06749400f, 
    0.03556661f, -0.04659718f, 0.10546462f, -0.02086235f, 0.06725791f, 0.04331657f, 0.03758566f, -0.01006399f, 
    -0.11140161f, 0.03366704f, 0.13491297f, -0.10106080f, 0.22170317f, 0.14273030f, 0.05671244f, -0.04819475f, 
    0.29525051f, 0.14001267f, -0.16758904f, 0.16456042f, -0.12522292f, 0.12400561f, -0.06972792f, 0.01698396f, 
    0.19014619f, -0.05316061f, 0.11447253f, -0.05919406f, 0.03394928f, 0.15244865f, -0.03826467f, 0.11268475f, 
    -0.21894969f, 0.03654421f, 0.29256269f, 0.07512473f, 0.46149725f, 0.03372712f, 0.09699643f, 0.21002470f, 
    0.20940667f, 0.22401097f, -0.04263337f, 0.13249363f, 0.04381442f, -0.18133084f, -0.07771028f, 0.12335351f, 
    0.14189970f, -0.03457365f, 0.02541566f, 0.05595901f, 0.14515884f, -0.00206984f, 0.21542744f, 0.13815799f, 
    0.13730708f, 0.20140578f, 0.00469674f, 0.15030654f, 0.09412128f, 0.25476375f, 0.09649586f, -0.01802043f, 
    0.06946529f, -0.06678944f, 0.05163803f, -0.02254496f, 0.00903052f, -0.01418853f, -0.09415261f, 0.04262397f, 
    -0.16380359f, 0.07282051f, -0.13927467f, -0.12217498f, -0.00219020f, -0.02923978f, -0.12543428f, 0.06081124f, 
    0.01469563f, 0.09891556f, -0.04688894f, 0.12252111f, 0.01876621f, 0.08715222f, 0.07421328f, -0.05443128f, 
    0.09964357f, 0.07001916f, 0.15784210f, 0.17270507f, 0.03291748f, 0.20134230f, -0.19948420f, 0.01260268f, 
    -0.29675910f, -0.07460824f, -0.26400560f, -0.04899894f, -0.24363966f, -0.28543824f, 0.08833502f, -0.02996325f, 
    0.06771156f, -0.01557349f, -0.07165722f, -0.17851017f, -0.26436162f, 0.02824537f, -0.13958621f, -0.20531437f, 
    0.30364326f, 0.26284012f, 0.41288006f, 0.21512838f, 0.02175269f, -0.06775676f, 0.12592742f, 0.05849659f, 
    0.02501986f, 0.10914571f, 0.18721595f, 0.00419307f, 0.06946630f, -0.04252400f, -0.07825665f, 0.04595307f, 
    -0.17741767f, -0.14598998f, -0.09740006f, -0.04357314f, 0.15819553f, 0.13669096f, 0.05842312f, 0.15266472f, 
    -0.09427170f, -0.05279299f, -0.27577460f, 0.11480751f, 0.16089134f, 0.00222469f, 0.05329854f, -0.01233547f, 
    -0.06133232f, 0.01862236f, -0.01471696f, -0.01545086f, -0.02724121f, 0.17551139f, 0.13952760f, 0.13066182f, 
    0.11367380f, -0.17762715f, 0.31755278f, 0.21998428f, -0.08920603f, -0.02888981f, 0.11430646f, -0.20729822f, 
    0.14339666f, 0.06259240f, -0.01489480f, -0.06924903f, -0.01277339f, -0.09275009f, 0.08072972f, 0.08653370f, 
    0.05464165f, 0.06098409f, -0.07615334f, 0.09559504f, 0.87815279f, -0.06885750f, 0.25678867f, 0.16037765f, 
    -0.08090604f, 0.24587677f, -0.15503293f, -0.11584905f, -0.16288257f, -0.11978064f, 0.03308460f, -0.10157934f, 
    -0.05024896f, -0.02107152f, 0.11418611f, 0.06889693f, 0.03735387f, 0.10223819f, -0.09897619f, 0.02713220f, 
    0.07890677f, -0.28161511f, -0.24597457f, -0.17271303f, 0.10825455f, -0.00910981f, -0.05985235f, -0.17909199f, 
    -0.05471928f, -0.06524456f, -0.08403688f, 0.16759892f, 0.05337365f, -0.02872009f, -0.06619228f, 0.13877305f, 
    0.16798662f, 0.07286414f, -0.03519547f, 0.06464786f, -0.22864312f, 0.30093271f, 0.05161514f, -0.01518691f, 
    0.26726422f, -0.07199328f, 0.11748672f, 0.12163864f, 0.05843868f, 0.17840654f, 0.08791852f, 0.09822079f, 
    0.01203042f, -0.09283873f, -0.07169015f, 0.20352347f, 0.01708984f, -0.07067493f, 0.12527631f, -0.05201829f, 
    -0.10019842f, 0.28386113f, 0.07121292f, 0.10241699f, 0.01459948f, -0.02035817f, -0.10670640f, -0.32573131f, 
    -0.06058368f, -0.13139378f, -0.13224429f, -0.06060457f, -0.13289528f, 0.00507278f, -0.02190733f, -0.06100769f, 
    -0.04921543f, 0.00177340f, -0.17880462f, 0.03923765f, 0.01628889f, 0.29090002f, -0.01630198f, -0.02987015f, 
    -0.05561122f, -0.08664024f, 0.01621604f, -0.11470431f, -0.02711638f, -0.05983818f, -0.03612142f, -0.04816772f, 
    -0.00224633f, 0.11086997f, 0.00892243f, 0.19063985f, -0.05729886f, 0.05344152f, -0.06626044f, 0.12376161f, 
    -0.03841991f, -0.09345514f, 0.02004448f, -0.10197683f, -0.02226093f, 0.05413638f, -0.03935691f, -0.01680621f, 
    0.08291820f, -0.01220683f, 0.07491173f, -0.00568354f, 0.06995749f, 0.07720113f, -0.07166442f, 0.01876451f, 
    0.01849375f, -0.05564628f, -0.11183595f, -0.09308223f, 0.19211148f, -0.16383904f, -0.14206754f, -0.16095228f, 
    0.08974530f, 0.06049398f, 0.14156877f, -0.00440810f, 0.07204679f, 0.07983495f, 0.09531914f, -0.00758391f, 
    0.03276004f, 0.11390461f, -0.11147549f, -0.08386528f, 0.03600959f, 0.14099424f, -0.04423146f, 0.05139023f, 
    -0.07940186f, -0.45057857f, -0.42054653f, -0.10121899f, -0.08807120f, -0.01683676f, 0.06252096f, 0.01061255f, 
    -0.11990242f, 0.02684731f, 0.13316528f, 0.08732340f, -0.04327218f, -0.01834460f, -0.00304996f, -0.05828061f, 
    0.05336476f, 0.01540801f, 0.04062941f, 0.12605070f, 0.07836194f, -0.01664119f, -0.20584005f, -0.01311989f, 
    0.13099630f, 0.02819937f, 0.09992123f, 0.06538595f, 0.04947539f, -0.01412187f, -0.07612614f, -0.00742134f, 
    0.16245264f, 0.07829776f, 0.04377588f, 0.13326937f, 0.04055288f, 0.04000358f, 0.07757460f, 0.03692452f, 
    0.23451202f, 0.04477869f, 0.38011023f, 0.11699200f, 0.19915363f, -0.01204920f, 0.01504773f, -0.05554766f, 
    0.05413766f, -0.01507919f, 0.01445749f, 0.13511969f, 0.07621626f, -0.09853571f, -0.08061897f, 0.01958125f, 
    -0.03131518f, 0.01468767f, 0.15231626f, -0.09146309f, 0.28801590f, -0.12625028f, -0.07827558f, 0.05572563f, 
    -0.07772229f, 0.09297486f, 0.03061952f, -0.03048710f, -0.00217388f, 0.01618297f, -0.00477343f, -0.00773383f, 
    -0.02562816f, 0.08334561f, 0.05560217f, -0.04700561f, 0.05094001f, 0.02779448f, 0.00734921f, 0.02110921f, 
    -0.08214979f, 0.05258662f, -0.31099153f, -0.18031372f, -0.01281284f, -0.06251470f, 0.08683573f, 0.09644005f, 
    0.06756853f, -0.04314917f, -0.15775160f, 0.09809344f, 0.06472026f, 0.10702335f, 0.08493295f, 0.01947259f, 
    -0.10829801f, 0.07695234f, 0.04761234f, 0.00832272f, 0.11178807f, 0.16791511f, -0.14514060f, -0.02684497f, 
    0.07485148f, 0.02754279f, -0.03564458f, -0.29060274f, -0.04416382f, -0.04888228f, 0.01237534f, 0.06488910f, 
    0.15494823f, 0.08065400f, -0.07784566f, -0.01340069f, 0.06194530f, 0.20716962f, 0.08067602f, 0.21718276f, 
    0.29008901f, 0.12239639f, 0.45481393f, -0.20406891f, -0.01678733f, 0.05866470f, -0.00695664f, 0.02146746f, 
    0.10298798f, 0.10868606f, 0.02986162f, 0.08078390f, -0.03880309f, -0.07369126f, 0.02808745f, 0.11386842f, 
    0.11247821f, -0.06931964f, 0.01866391f, 0.11943056f, -0.29326034f, -0.15095085f, -0.08061304f, 0.15165494f, 
    -0.07574309f, -0.11942745f, -0.01614980f, -0.18530419f, 0.00904258f, -0.20147027f, -0.08268440f, -0.06286629f, 
    -0.07173941f, 0.00879699f, 0.10178743f, 0.03276510f, 0.03867051f, 0.07758905f, 0.07203808f, -0.05861244f, 
    -0.12816019f, 0.16417915f, 0.05028439f, 0.04384825f, -0.03864792f, -0.00066856f, -0.16979562f, -0.07156517f, 
    -0.16925268f, -0.13009055f, -0.07299508f, -0.10745962f, 0.07398126f, 0.01547731f, 0.06769639f, 0.05718639f, 
    -0.00178890f, 0.02248400f, -0.17260601f, -0.14931239f, -0.23326448f, -0.11392228f, -0.11712860f, -0.02156337f, 
    -0.02134260f, 0.03691823f, -0.02530564f, -0.17614307f, -0.12925893f, -0.43468139f, -0.05381687f, -0.00050177f, 
    -0.03672823f, -0.07118325f, 0.04025860f, -0.02614483f, 0.05817795f, -0.05558037f, -0.20228353f, -0.06556493f, 
    -0.01750041f, 0.27921897f, 0.01287849f, -0.04074207f, 0.04136018f, -0.10942090f, -0.01712603f, -0.05387255f, 
    -0.15600672f, 0.10446881f, 0.02730652f, 0.05673496f, -0.00944049f, -0.19108526f, 0.05336084f, -0.10608494f, 
    -0.22553602f, -0.26781386f, -0.17058061f, -0.45062041f, -0.16622059f, -0.14049414f, 0.02169978f, -0.08266006f, 
    -0.00298662f, -0.00456000f, 0.00202370f, 0.06682397f, -0.02095034f, 0.01434120f, -0.04211763f, 0.01194076f, 
    -0.01453793f, 0.07944015f, -0.01548989f, 0.05818592f, 0.07287135f, 0.01931661f, 0.01377467f, -0.01330605f, 
    -0.01859860f, 0.07299876f, -0.00415484f, -0.15888095f, 0.09028053f, -0.17357513f, -0.08168530f, 0.03218892f, 
    -0.18905947f, -0.16899461f, -0.07210180f, -0.04229718f, 0.00113215f, 0.10923430f, 0.00257012f, 0.00839599f, 
    -0.11795496f, -0.16646223f, -0.15272026f, -0.13033298f, 0.08820353f, 0.10333133f, 0.00162840f, -0.01554397f, 
    0.04026610f, 0.03568402f, -0.07228056f, -0.05686987f, -0.06441315f, -0.02852919f, -0.15760477f, 0.12467592f, 
    -0.01625467f, 0.02437245f, 0.11764476f, 0.09192122f, 0.00408187f, -0.08390708f, 0.00089407f, 0.04033363f, 
    0.17654407f, -0.04970933f, -0.04277847f, -0.10977240f, 0.08108693f, -0.08753873f, -0.01259133f, -0.02079239f, 
    0.06779678f, 0.02740600f, -0.11536667f, -0.09322080f, 0.08050582f, 0.11950412f, -0.06310891f, -0.02164846f, 
    0.06281372f, 0.09070294f, 0.10019072f, 0.14725357f, 0.26675203f, -0.03812180f, 0.14822142f, -0.06440419f, 
    -0.11800182f, 0.02927903f, -0.10143504f, -0.15515901f, -0.03138417f, -0.17752653f, -0.08376051f, 0.03825584f, 
    0.07298136f, -0.14537913f, 0.01345580f, -0.04072596f, 0.06488969f, 0.07378766f, 0.06920221f, -0.03396517f, 
    0.21835673f, -0.11708232f, -0.03006383f, 0.01129341f, 0.14471254f, -0.01119287f, -0.07936140f, -0.05751266f, 
    -0.12248946f, -0.09089139f, -0.10961323f, -0.02372828f, 0.02974609f, 0.12186334f, 0.08781482f, 0.03297127f, 
    -0.27216524f, -0.06817055f, -0.10199247f, -0.25976107f, 0.28937435f, 0.15511768f, -0.12000728f, -0.05593930f, 
    -0.03010532f, 0.08139430f, -0.16816075f, -0.04609492f, -0.08596757f, -0.01546797f, -0.09361331f, 0.04996734f, 
    0.04968872f, -0.05889945f, 0.12782978f, 0.03805032f, 0.07033708f, -0.04682422f, 0.08666021f, 0.08749858f, 
    -0.22377898f, -0.10674861f, 0.20635100f, 0.12410595f, 0.16751535f, -0.06776013f, 0.03303407f, 0.10341837f, 
    0.07949245f, 0.02987322f, -0.11504312f, -0.08777159f, 0.02826867f, -0.02163986f, 0.00326684f, 0.00638146f, 
    0.19570169f, 0.15479873f, 0.08648770f, 0.17880458f, 0.16180155f, 0.01570989f, 0.01365127f, -0.07457148f, 
    0.04171565f, 0.04694366f, -0.13971078f, 0.10831185f, 0.09007861f, 0.06427008f, -0.12736039f, -0.15264742f, 
    -0.07866888f, -0.09967983f, -0.05377242f, 0.05646116f, -0.04832641f, -0.01217303f, -0.05524740f, -0.00133764f, 
    0.02211851f, -0.08293405f, -0.15594067f, 0.22394229f, -0.15246883f, -0.09868705f, -0.17287306f, 0.05767292f, 
    0.09878708f, -0.13861884f, -0.17459862f, 0.01463111f, 0.09289518f, 0.03380037f, 0.05778380f, 0.09969985f, 
    0.19872415f, 0.13149184f, 0.14754143f, 0.13962583f, -0.06243556f, 0.14484194f, -0.10270121f, -0.04137327f, 
    -0.20899643f, -0.06207117f, -0.09724688f, 0.00365764f, -0.28680521f, -0.33549541f, 0.06777044f, 0.13408588f, 
    0.04840906f, -0.09164908f, 0.03033361f, -0.00072438f, -0.23708445f, -0.22148116f, -0.07386991f, -0.03770076f, 
    0.21326505f, 0.33915094f, 0.16056883f, 0.03271029f, 0.14282955f, -0.12021153f, 0.15006112f, 0.07159789f, 
    -0.15701392f, 0.10018909f, -0.10487116f, -0.03826209f, -0.04269499f, -0.05084410f, -0.21992451f, -0.06211591f, 
    -0.13190384f, -0.07655758f, -0.02867373f, -0.08249038f, -0.11168547f, -0.02684120f, -0.00630112f, -0.03052192f, 
    0.04729674f, 0.14579423f, -0.13219567f, -0.00787269f, 0.00660300f, -0.35149747f, -0.04206401f, -0.02563526f, 
    0.00840618f, -0.00505362f, -0.04648567f, 0.16143624f, -0.01714647f, -0.07837223f, -0.14758095f, 0.00934093f, 
    0.01525688f, 0.03137944f, -0.05141509f, -0.05380246f, -0.00701191f, -0.02425116f, 0.00449548f, -0.03359943f, 
    -0.03437136f, -0.03688210f, 0.00120986f, 0.00162232f, -0.05652680f, -0.03019084f, -0.02966212f, -0.04848165f, 
    0.03409724f, -0.01902214f, -0.03135791f, -0.03287862f, -0.00328206f, -0.05494811f, -0.02044380f, 0.03238001f, 
    -0.01963337f, 0.00126358f, 0.01064185f, -0.03397522f, -0.01611281f, -0.02978183f, 0.00716410f, -0.05025264f, 
    0.03060044f, 0.02079396f, 0.02012185f, -0.01899501f, 0.04030869f, -0.02709243f, -0.02792661f, 0.03323656f, 
    0.00400911f, 0.03780936f, 0.01026274f, -0.04742754f, -0.00053396f, -0.06480899f, -0.02574768f, 0.00202321f, 
    0.03205764f, 0.00495467f, 0.04636996f, 0.02322223f, 0.03660208f, 0.00533820f, 0.03727596f, 0.02241825f, 
    0.01721042f, 0.00812958f, -0.05810279f, 0.00125249f, 0.03384593f, -0.03583060f, -0.00655202f, -0.00767634f, 
    -0.05264376f, -0.02005504f, -0.06020797f, -0.05956394f, 0.04085757f, -0.02504127f, 0.00042058f, -0.02048708f, 
    -0.02244497f, -0.03892036f, 0.03235976f, 0.03265727f, 0.04255959f, 0.01202530f, -0.02270716f, -0.00788010f, 
    0.02028084f, -0.04463286f, 0.03878438f, -0.05683178f, -0.03880101f, -0.01889183f, -0.03336915f, -0.01635491f, 
    0.02241253f, -0.04148624f, 0.00050525f, -0.01546321f, -0.06468443f, 0.00501902f, 0.01259046f, 0.02452774f, 
    -0.05908518f, 0.00752505f, -0.04843919f, 0.04235411f, 0.01156037f, -0.05036863f, 0.04567481f, -0.04541339f, 
    -0.00009524f, 0.00930052f, -0.03310589f, 0.00923617f, 0.03133582f, 0.02476957f, -0.03158845f, 0.00623310f, 
    -0.01880657f, -0.04757116f, -0.04016143f, -0.02062920f, -0.01974247f, 0.03206681f, -0.05301232f, 0.02491396f, 
    0.02043355f, 0.03349346f, -0.00067124f, -0.01882808f, -0.01153696f, -0.02026004f, -0.04172774f, 0.04776271f, 
    -0.06155838f, 0.00586839f, 0.03180650f, 0.02419499f, -0.04902715f, 0.01295107f, 0.00689048f, -0.00651880f, 
    0.00525834f, 0.01916626f, -0.05090164f, 0.02053705f, -0.04138505f, -0.04184536f, 0.02502988f, -0.00849105f, 
    -0.05076264f, -0.01964624f, 0.00991014f, -0.04217543f, -0.02193251f, 0.00684581f, 0.00748452f, -0.01227606f, 
    0.02330696f, -0.01335104f, 0.04686186f, 0.00308867f, -0.03810474f, 0.00393426f, 0.02611296f, 0.02576460f, 
    -0.05705616f, 0.02845586f, -0.02459049f, -0.00517556f, 0.01073789f, 0.02108874f, 0.02674570f, -0.04399726f, 
    0.01369081f, 0.03871518f, -0.03738154f, -0.04378298f, -0.00291573f, 0.03125229f, -0.01350098f, -0.04060645f, 
    -0.01555163f, 0.03622941f, -0.04325480f, 0.04352758f, -0.00791369f, -0.04555422f, -0.00507199f, 0.01871367f, 
    0.03755302f, -0.05183879f, 0.03983766f, 0.03527691f, -0.04505885f, 0.03492378f, -0.01701457f, -0.01376974f, 
    0.03200275f, -0.02846012f, 0.02252408f, 0.03031543f, 0.02203085f, 0.04833408f, 0.02045682f, 0.03090572f, 
    0.03069940f, 0.01605302f, 0.02443162f, 0.02823888f, -0.04506222f, -0.00173713f, -0.04864061f, 0.00603197f, 
    0.01810235f, 0.01092235f, -0.01474545f, 0.02096398f, -0.04513434f, -0.01007135f, -0.04487295f, -0.00363157f, 
    0.04722368f, 0.03134905f, -0.04068822f, -0.00386196f, -0.04779704f, -0.05015911f, 0.04678655f, -0.06070239f, 
    0.01252742f, -0.02933308f, -0.01526290f, -0.03211514f, -0.05666952f, -0.00766795f, 0.02828243f, -0.06063458f, 
    0.01330195f, -0.02726875f, 0.03839258f, -0.01273027f, -0.00702789f, -0.04339922f, -0.04785290f, 0.00635057f, 
    -0.01612309f, 0.02687594f, -0.04099791f, 0.00583504f, 0.04717984f, 0.01744782f, -0.04375727f, 0.00954071f, 
    0.04429743f, 0.05008430f, -0.05174274f, 0.01330135f, 0.04880704f, 0.00708274f, 0.01792946f, 0.02687027f, 
    -0.02682553f, 0.01719624f, 0.03352769f, 0.01611472f, -0.02266962f, 0.02887763f, -0.00650349f, 0.01221150f, 
    -0.01836725f, -0.01065676f, -0.00041852f, -0.01000398f, 0.02383207f, 0.03693994f, -0.05586662f, 0.02115171f, 
    -0.04997171f, -0.04710428f, -0.03043314f, -0.00975714f, 0.01409967f, -0.04190525f, 0.00141095f, -0.03359208f, 
    -0.03016791f, -0.05282726f, -0.05278708f, 0.01979546f, 0.00510370f, -0.01977466f, -0.02269417f, 0.04479581f, 
    0.03281548f, 0.04212333f, -0.05696869f, -0.02715811f, 0.01373749f, -0.02210572f, 0.04715032f, -0.03355917f, 
    0.02824100f, -0.05551410f, 0.04249103f, -0.04487044f, 0.03658441f, 0.04267659f, 0.01355548f, 0.02622250f, 
    -0.01466146f, -0.01421139f, -0.03119396f, -0.04252188f, -0.02794773f, -0.00887351f, 0.04518939f, 0.00015498f, 
    0.02304557f, -0.03745124f, -0.00875738f, -0.02226654f, -0.06499615f, -0.04832572f, 0.04244247f, 0.03393388f, 
    0.01898791f, 0.02417791f, 0.40612537f, 0.01688901f, -0.13385890f, -0.02467916f, -0.03568579f, -0.10882767f, 
    0.04485794f, -0.12414598f, 0.06822303f, 0.12553057f, 0.12738797f, 0.20093316f, 0.03560581f, -0.00347542f, 
    0.08396242f, 0.23558101f, -0.13950449f, 0.00992046f, -0.05258613f, 0.10820420f, 0.16600935f, -0.11435181f, 
    -0.10243074f, 0.13085559f, 0.19783470f, -0.05512874f, 0.01311799f, -0.22944605f, 0.09601943f, 0.08921583f, 
    0.07061734f, -0.04959952f, 0.02122958f, 0.12362557f, -0.01536345f, 0.19043516f, -0.21312088f, -0.01646435f, 
    -0.21008167f, -0.35278273f, -0.08852597f, 0.00114664f, 0.06711340f, 0.12487774f, 0.12001797f, 0.07718278f, 
    -0.02498563f, -0.08508418f, 0.07731938f, 0.03539706f, 0.02447315f, 0.06742914f, -0.01229673f, -0.00664709f, 
    -0.13398644f, -0.00335293f, 0.02409955f, 0.01323382f, -0.21403706f, 0.29356894f, -0.12091359f, 0.29140335f, 
    0.11364469f, -0.02973530f, 0.02924723f, 0.06329189f, 0.09873139f, -0.03630609f, -0.01161748f, 0.06443839f, 
    -0.10106853f, 0.11606240f, -0.06195990f, 0.05559718f, 0.03617268f, -0.02433020f, 0.06939383f, -0.10978473f, 
    0.00400825f, 0.15659767f, 0.15873003f, -0.02760640f, -0.24251842f, -0.18981481f, -0.02210069f, -0.04850824f, 
    -0.01164745f, -0.11693452f, -0.00506572f, 0.08369257f, 0.03936145f, 0.01273829f, 0.09711783f, 0.10364844f, 
    0.05844249f, -0.13603753f, 0.01189578f, -0.10498801f, 0.43323013f, 0.08879491f, 0.09334821f, -0.35068923f, 
    0.03409836f, -0.01355953f, 0.13707227f, 0.03497472f, -0.06465308f, -0.07103846f, -0.12566225f, 0.09179327f, 
    0.06117235f, 0.05801920f, 0.05930253f, -0.06559813f, 0.06169217f, -0.07499810f, -0.06806163f, -0.11679206f, 
    -0.00378898f, -0.11237374f, -0.24979031f, 0.00007363f, 0.24782071f, 0.01061343f, -0.14700675f, -0.17698927f, 
    0.02744025f, 0.03959472f, -0.18622509f, 0.00465232f, 0.00234132f, -0.09548865f, -0.04981611f, -0.05803959f, 
    -0.01922541f, -0.00589630f, -0.02027127f, 0.09424130f, 0.22559422f, -0.21177191f, -0.06409328f, 0.09630046f, 
    0.09523348f, 0.03851290f, 0.00046368f, 0.01144453f, 0.02737497f, -0.07748852f, 0.02245461f, 0.03932380f, 
    0.02875827f, 0.00182151f, -0.02164457f, -0.08264009f, -0.00505256f, 0.05347036f, -0.08454722f, -0.19407985f, 
    0.04144190f, -0.37580186f, -0.29553682f, 0.12415931f, 0.18279797f, 0.13312705f, -0.06354821f, -0.01337252f, 
    0.01255162f, 0.07082291f, 0.03808206f, -0.04182630f, -0.11401474f, -0.00590032f, -0.01479816f, 0.02079638f, 
    -0.09272782f, -0.07080470f, -0.12163745f, -0.16371332f, 0.18569145f, -0.11359768f, -0.07962146f, 0.26951644f, 
    0.28461307f, 0.02431429f, -0.05835055f, -0.01219671f, -0.05953206f, -0.05262608f, -0.12423296f, 0.08019163f, 
    0.03707413f, -0.10057282f, 0.00658718f, 0.05183343f, -0.00675807f, -0.06755592f, 0.00473915f, -0.07857496f, 
    -0.06930462f, -0.18299407f, 0.26392689f, 0.36011714f, 0.22357212f, -0.11518673f, -0.08020075f, -0.10209382f, 
    0.04572242f, -0.14149477f, -0.04030123f, 0.04969128f, -0.00241465f, -0.06949228f, -0.08575616f, 0.02594159f, 
    -0.03236480f, 0.18338363f, 0.09822150f, 0.09909977f, -0.01533939f, -0.12239497f, -0.20174719f, 0.10556999f, 
    0.22244827f, 0.05955937f, -0.05243518f, -0.04442973f, 0.13168241f, 0.17271838f, -0.03245694f, -0.02021265f, 
    -0.06841756f, -0.06280072f, -0.02622503f, -0.01216989f, -0.16258171f, 0.03101754f, -0.10232794f, -0.06673373f, 
    -0.07057650f, 0.17203352f, -0.08978506f, 0.24924953f, 0.09254800f, 0.05539691f, 0.00324246f, 0.09588297f, 
    0.11556920f, -0.03862233f, -0.20033792f, -0.07603010f, 0.03596176f, 0.11102500f, 0.12329988f, -0.04672428f, 
    -0.05533674f, -0.04331419f, -0.07997186f, 0.07509512f, 0.12152698f, 0.08282679f, 0.01967799f, -0.14809261f, 
    -0.20789419f, 0.00282358f, 0.16758110f, -0.00396806f, -0.05030786f, -0.24267069f, 0.03281309f, -0.02564061f, 
    0.09424263f, 0.05044886f, 0.01932519f, 0.03781341f, -0.08919752f, -0.18658768f, -0.02184234f, -0.00461949f, 
    0.18326400f, 0.17224561f, 0.23268455f, 0.05785252f, 0.23316054f, 0.01569529f, 0.13551573f, 0.11786415f, 
    -0.07325955f, 0.08239598f, -0.09956273f, 0.02462417f, 0.10145824f, -0.00262738f, -0.02054319f, -0.13708140f, 
    -0.09468187f, 0.03732760f, 0.03405203f, -0.04351146f, -0.04344533f, -0.04505957f, 0.04088873f, 0.01995948f, 
    -0.27698153f, 0.05298710f, 0.01638659f, 0.14240517f, 0.04386120f, -0.10925721f, -0.03995894f, -0.06205090f, 
    0.05931040f, -0.00331990f, 0.04274991f, 0.02014416f, -0.02674427f, -0.27152956f, -0.00257136f, -0.08985218f, 
    -0.35801753f, 0.11659135f, -0.16761942f, -0.12287745f, -0.01154697f, -0.01124236f, -0.10107097f, 0.06709122f, 
    0.08087214f, -0.00843753f, 0.01596264f, -0.15834135f, -0.06631528f, 0.01604243f, 0.04453048f, 0.10227965f, 
    -0.05031229f, -0.13224415f, -0.03458887f, 0.00523189f, 0.46023035f, 0.50610423f, -0.47184101f, -0.07651903f, 
    0.01696932f, -0.09445649f, 0.00296433f, 0.01563398f, -0.06757964f, 0.11239824f, 0.15035379f, -0.02196452f, 
    0.13498607f, 0.06372091f, -0.02684000f, -0.11699363f, 0.05032239f, -0.05096455f, 0.13936201f, 0.06148273f, 
    0.07832804f, 0.10194157f, -0.31244776f, -0.08146419f, 0.01621849f, -0.03913767f, -0.03279194f, -0.14469622f, 
    -0.01838256f, -0.08134150f, 0.05436673f, -0.04669132f, 0.04452990f, -0.09908719f, -0.10546540f, 0.03498664f, 
    -0.03042263f, 0.00741901f, 0.07910568f, -0.07527625f, 0.08553900f, -0.13354485f, 0.34232637f, 0.07843693f, 
    0.01795265f, 0.10597986f, -0.00295588f, 0.12492757f, -0.17305340f, -0.01574250f, 0.03433558f, 0.09821038f, 
    0.13482699f, 0.17622951f, 0.11578539f, 0.09848545f, 0.09407429f, 0.02464349f, 0.00177361f, 0.10649014f, 
    -0.06351621f, -0.04034395f, 0.01060699f, -0.04877511f, -0.13748915f, -0.03728373f, -0.16822276f, -0.08799663f, 
    -0.02052451f, -0.13351600f, 0.10578508f, 0.08802490f, -0.07591046f, -0.13214712f, 0.06182983f, -0.16398443f, 
    -0.09607277f, -0.12846242f, 0.01145005f, -0.00017631f, 0.08325185f, 0.31325081f, 0.08265907f, 0.05586921f, 
    -0.17213531f, -0.08738878f, -0.09822822f, 0.09582011f, 0.05394079f, 0.03921912f, 0.01601515f, -0.01541060f, 
    0.06517909f, -0.00393792f, 0.05879996f, 0.09307950f, 0.03908921f, 0.03268930f, -0.03304928f, 0.09266687f, 
    -0.19794774f, -0.24857964f, -0.19340070f, 0.00730750f, -0.10455406f, 0.01693940f, -0.04233608f, -0.06565155f, 
    0.07127203f, -0.05353638f, 0.05603116f, -0.07019369f, -0.07720079f, 0.02442786f, -0.06718001f, 0.00812633f, 
    -0.00232460f, 0.09707745f, 0.02311594f, -0.01551909f, -0.05382960f, 0.14120035f, 0.04044238f, -0.08670804f, 
    0.35779852f, 0.19314972f, 0.05291884f, 0.20565605f, 0.11708319f, 0.06164115f, 0.02592665f, 0.03897291f, 
    -0.06629968f, -0.06726170f, 0.07219495f, 0.09212448f, 0.04181317f, 0.02886661f, 0.07248212f, 0.02485296f, 
    0.03954483f, 0.10200012f, 0.30070978f, -0.05875900f, 0.00511519f, -0.03483845f, -0.12520671f, -0.11967085f, 
    0.02188504f, 0.05301666f, 0.02369022f, 0.09914219f, 0.02345386f, 0.04341099f, 0.12306938f, -0.10005348f, 
    -0.00375032f, 0.00235220f, -0.02183894f, 0.06202324f, -0.00715609f, -0.29148164f, 0.23562382f, -0.66743958f, 
    0.00791574f, -0.04306176f, -0.04788315f, -0.01667571f, 0.07634920f, -0.09002581f, 0.01662641f, 0.00373666f, 
    -0.03833354f, -0.00754068f, 0.04554479f, 0.04493326f, -0.04129453f, 0.00114779f, -0.04412548f, -0.13756658f, 
    -0.41071677f, 0.09120572f, 0.08204474f, -0.14309539f, -0.01274031f, 0.03863842f, -0.05118586f, 0.12878484f, 
    -0.02197136f, 0.02395703f, 0.13749060f, -0.09194098f, 0.02551368f, -0.00234954f, 0.08624864f, 0.08896095f, 
    0.01150725f, 0.05500217f, -0.11487599f, 0.09427126f, -0.10609213f, -0.24663430f, -0.42169487f, -0.12123840f, 
    -0.40407607f, -0.17249119f, 0.13072409f, -0.00322743f, -0.05457019f, -0.02363801f, 0.02553411f, -0.17626414f, 
    -0.00707346f, -0.02938393f, 0.03949310f, 0.03391073f, 0.14012747f, 0.00037373f, 0.05311905f, -0.06654984f, 
    -0.08668412f, -0.51190245f, 0.26915339f, -0.18797407f, 0.55062383f, -0.11362444f, -0.07062282f, 0.08838942f, 
    0.04119318f, 0.03499744f, 0.01339947f, 0.10231791f, -0.01986001f, 0.03370084f, -0.08866861f, -0.05694331f, 
    0.15844852f, -0.06393582f, 0.09338012f, -0.16317822f, 0.12472191f, 0.17331539f, -0.02092033f, -0.02864883f, 
    -0.08399256f, -0.08391894f, -0.03309286f, 0.03473973f, 0.04747456f, 0.06979192f, 0.07544769f, 0.04247170f, 
    -0.02931337f, -0.02699238f, 0.08546992f, 0.01741260f, -0.08326010f, -0.10741787f, 0.15867762f, -0.09470697f, 
    0.30985346f, -0.51456028f, -0.16744883f, -0.15430525f, 0.13008031f, 0.04864869f, 0.08309445f, -0.17040561f, 
    0.11768047f, -0.04878386f, 0.00424390f, 0.03799066f, 0.09551164f, -0.11707017f, 0.10725380f, -0.05018584f, 
    0.11657292f, -0.01129468f, 0.09622366f, 0.11646564f, -0.03809717f, 0.18826346f, 0.23165746f, -0.06253453f, 
    -0.16761909f, -0.14315842f, -0.03589372f, -0.09280613f, -0.08283568f, 0.00701743f, 0.06525502f, 0.12255001f, 
    -0.01904991f, -0.04860133f, 0.05174384f, 0.06950814f, 0.06505075f, -0.05905244f, 0.08925708f, 0.00310319f, 
    -0.02657565f, -0.05521147f, -0.04132497f, -0.02481082f, -0.00448717f, 0.04514231f, 0.01922133f, 0.03925460f, 
    0.01707526f, -0.00320003f, 0.00779359f, 0.00922183f, 0.05115734f, 0.03953221f, 0.01609285f, -0.01940394f, 
    0.03545487f, -0.03350244f, -0.01177906f, 0.02863358f, -0.03077150f, -0.03719717f, 0.05108074f, 0.00560062f, 
    0.00490125f, 0.00844721f, 0.06363988f, -0.03970091f, 0.02607311f, 0.02153198f, 0.03592087f, -0.05742737f, 
    0.02952871f, 0.04904874f, 0.01794696f, -0.02318177f, -0.03553116f, -0.05808641f, 0.05390604f, 0.03784331f, 
    0.03053904f, -0.04749225f, -0.04774908f, -0.04473358f, 0.00237050f, -0.03251416f, 0.02960335f, 0.02229260f, 
    0.01801201f, 0.03978920f, 0.01234819f, 0.00779876f, -0.01561831f, -0.00267118f, 0.05370810f, 0.03131766f, 
    -0.01175286f, -0.02064274f, -0.01538170f, 0.00684785f, -0.02535832f, 0.03305101f, -0.02241926f, 0.03009260f, 
    -0.05827266f, -0.05558109f, 0.02819657f, -0.06309462f, -0.00098493f, -0.00987838f, -0.01090232f, -0.04265695f, 
    -0.05551311f, -0.04070863f, 0.01150425f, -0.01067709f, -0.01614163f, -0.06228688f, -0.02412518f, 0.03741951f, 
    0.00805211f, 0.03507164f, 0.04518043f, -0.05908302f, -0.02101082f, -0.02639277f, 0.03523985f, -0.03400787f, 
    0.00009049f, 0.00984295f, -0.01511015f, 0.01303258f, -0.01550105f, 0.01406132f, -0.01856518f, -0.01214761f, 
    0.00297496f, 0.02791126f, -0.02522152f, -0.00027258f, 0.01653093f, 0.03769476f, 0.04789593f, 0.00121050f, 
    0.05199276f, -0.06241283f, -0.05249610f, -0.00321486f, -0.04556210f, 0.00500831f, 0.00595737f, -0.04196623f, 
    0.00504142f, -0.01848343f, -0.03697730f, 0.03663125f, 0.01319510f, -0.00868513f, -0.01934301f, -0.04409971f, 
    -0.02820768f, 0.03776706f, 0.02157110f, -0.04812684f, -0.01882889f, 0.01914131f, 0.03390577f, 0.03772911f, 
    -0.03910730f, 0.00364827f, -0.03261555f, -0.01498404f, -0.02776162f, -0.01088298f, -0.05810747f, -0.03990863f, 
    -0.00117077f, -0.02766193f, -0.02788467f, -0.03937446f, 0.03283975f, 0.02774780f, -0.03027803f, 0.00807155f, 
    -0.04089316f, -0.02977969f, -0.03205461f, 0.01333307f, -0.05880257f, -0.02636743f, -0.01407348f, -0.03409839f, 
    -0.04333409f, 0.02069519f, -0.04292189f, -0.03902258f, 0.02713059f, 0.01434219f, 0.03271515f, -0.05710306f, 
    -0.03587528f, 0.03160074f, -0.01568501f, -0.02593718f, 0.00661894f, -0.02137745f, -0.05450638f, -0.00298796f, 
    -0.05584807f, -0.04168126f, 0.01109953f, -0.01752231f, -0.03711653f, -0.04810353f, 0.04308145f, 0.03038508f, 
    0.00585330f, -0.02263722f, 0.02976600f, 0.03371894f, 0.02633060f, -0.05257356f, -0.01503009f, -0.02106302f, 
    -0.04086432f, -0.00508048f, 0.00947310f, -0.01457066f, 0.00674230f, 0.01914846f, 0.01518226f, -0.02949095f, 
    -0.05930229f, -0.04395671f, -0.02558783f, 0.01991972f, -0.03702933f, 0.01920545f, -0.04832041f, -0.00857698f, 
    0.01718055f, 0.02129041f, 0.02740187f, -0.05000860f, 0.04627029f, 0.01275684f, -0.06026227f, -0.01732141f, 
    0.01148552f, -0.02722715f, 0.03828135f, -0.02281339f, 0.00730505f, -0.02008070f, 0.01022014f, -0.02792186f, 
    0.04071141f, 0.01071703f, -0.03738770f, 0.02814414f, 0.04400050f, 0.02023955f, 0.01517872f, 0.03672042f, 
    0.03255035f, 0.03533345f, -0.06241779f, 0.00523856f, 0.02531692f, 0.03771928f, -0.03198332f, -0.02003044f, 
    -0.03333182f, -0.05295781f, -0.01221162f, 0.00904013f, -0.03648160f, 0.03202671f, 0.01668836f, -0.04069407f, 
    -0.04778086f, -0.04401137f, -0.06151852f, 0.00833957f, 0.02674587f, -0.05438890f, -0.04233969f, 0.03895084f, 
    -0.05228769f, 0.04471266f, -0.01405878f, -0.04011029f, 0.00017114f, 0.00845710f, 0.01708544f, -0.05362853f, 
    -0.01391448f, 0.03153374f, 0.02988322f, -0.02049216f, -0.02213006f, -0.02609327f, -0.01456707f, 0.03138143f, 
    0.00838157f, -0.00100222f, -0.04969920f, -0.02350047f, 0.03387326f, -0.05777751f, -0.04537081f, -0.02829182f, 
    0.00857567f, 0.00857492f, -0.05225549f, -0.03264500f, 0.04791358f, -0.04170171f, -0.00508148f, 0.00543067f, 
    0.00341378f, -0.03078946f, 0.02753992f, 0.02277049f, -0.05963854f, -0.05798206f, 0.03805087f, -0.01161784f, 
    0.02461072f, -0.05530968f, 0.05300118f, -0.00416841f, -0.04188975f, -0.00959300f, 0.01063896f, 0.02671725f, 
    -0.03532784f, 0.05596138f, -0.02963329f, -0.03301057f, -0.00128550f, -0.03972614f, 0.01713315f, -0.02503181f, 
    -0.05830010f, 0.01147213f, -0.02145896f, 0.04911074f, 0.06083586f, -0.00777168f, 0.04595743f, 0.01208383f, 
    -0.00930390f, 0.03416930f, -0.04461525f, 0.01025881f, -0.01608538f, 0.00090286f, 0.05366196f, 0.02475017f, 
    0.03839592f, 0.03495627f, 0.05791540f, -0.01302695f, 0.02063586f, -0.02469001f, 0.00810271f, -0.06259353f, 
    -0.00793702f, -0.03914077f, 0.00186208f, 0.02097422f, -0.02718411f, -0.04144995f, 0.02658351f, -0.05474713f, 
    0.01697319f, -0.00675264f, -0.00820462f, 0.04211994f, -0.03670961f, -0.01552530f, 0.01110542f, -0.04524245f, 
    -0.04662939f, 0.02309535f, 0.05022995f, -0.03572855f, 0.02642117f, 0.02604996f, -0.02362188f, -0.01393690f, 
    -0.03929323f, -0.01581766f, -0.00127672f, 0.04825873f, 0.05535710f, -0.04181365f, -0.04753749f, 0.05745264f, 
    -0.02294419f, 0.00917510f, 0.01919734f, -0.00225674f, -0.00309167f, 0.01344287f, -0.02607913f, -0.03882544f, 
    -0.02086205f, 0.00975856f, -0.01076157f, 0.05427860f, -0.05014122f, -0.02305499f, 0.00472656f, 0.03294491f, 
    -0.01160913f, -0.01976808f, 0.01250626f, 0.02175693f, -0.04568573f, 0.00989124f, -0.05154869f, -0.04992499f, 
    -0.02571196f, 0.04571844f, 0.00247967f, 0.02118608f, 0.01911742f, -0.01604762f, -0.05756444f, -0.04393664f, 
    -0.01782712f, -0.01347391f, -0.02878106f, -0.00081973f, 0.02219383f, 0.01639500f, 0.03431603f, -0.03345910f, 
    0.02208964f, 0.01373065f, -0.02139883f, 0.04673237f, 0.04470113f, 0.00137743f, -0.02927604f, 0.03293494f, 
    -0.01776347f, -0.03955188f, -0.02757979f, 0.00493855f, 0.03963979f, -0.00947553f, -0.05911320f, -0.00601069f, 
    0.05243770f, -0.02741680f, -0.03889289f, 0.01600320f, 0.01909098f, 0.00800225f, 0.02817891f, -0.03692389f, 
    -0.00558673f, -0.00246762f, 0.01927429f, 0.02039275f, -0.02843933f, -0.05493075f, 0.01782712f, -0.05195788f, 
    -0.01106905f, -0.03810695f, 0.00768438f, 0.00085741f, -0.04091839f, -0.02846000f, 0.03488190f, 0.02884204f, 
    0.01063680f, 0.03182283f, 0.02931260f, 0.02119607f, -0.01284237f, -0.02922656f, -0.01826947f, -0.01389002f, 
    0.00488635f, -0.01491819f, -0.01957672f, 0.01545930f, 0.03800281f, 0.01944473f, 0.04704172f, -0.00655647f, 
    0.02740385f, 0.02339091f, 0.02439775f, 0.02316593f, -0.01630753f, -0.04040408f, 0.03459351f, -0.03867696f, 
    -0.06163451f, -0.05638590f, -0.04075037f, 0.02028727f, -0.02595311f, 0.03784674f, -0.04540131f, -0.00746580f, 
    0.04046194f, -0.06104357f, -0.00649158f, -0.03078306f, -0.06472293f, 0.02445294f, -0.05106246f, -0.04822997f, 
    -0.05999237f, -0.02206957f, -0.06090290f, -0.03533066f, -0.03991183f, 0.00023265f, -0.04001548f, -0.04036360f, 
    0.04206542f, 0.02922105f, 0.04695584f, -0.02584538f, -0.02229314f, -0.05812385f, 0.03365152f, -0.01779056f, 
    -0.00880877f, 0.03710755f, -0.01434206f, 0.00395768f, 0.00189675f, -0.02170985f, 0.00355834f, -0.04399048f, 
    0.03191768f, 0.00484577f, -0.00119429f, -0.06061306f, -0.05301532f, -0.04439247f, -0.04489629f, -0.05424429f, 
    0.04625554f, -0.00329259f, 0.00286003f, -0.06324892f, -0.06170286f, -0.00462577f, -0.02042075f, 0.04309459f, 
    0.00267952f, -0.00947210f, -0.00225565f, 0.00055387f, -0.00165699f, 0.02577727f, -0.03548200f, 0.01544744f, 
    0.01848436f, 0.00890864f, 0.00269900f, -0.06041238f, -0.05026986f, -0.01393740f, -0.02713435f, -0.00974470f, 
    0.03937281f, -0.01398139f, -0.00931511f, 0.04468374f, -0.03126489f, -0.03792699f, 0.04269693f, 0.03203796f, 
    -0.02301330f, -0.01540399f, -0.03372544f, 0.02990852f, -0.03001567f, 0.03362831f, 0.01651959f, 0.00821912f, 
    -0.01010583f, 0.00750635f, 0.01959548f, -0.02736741f, 0.02242449f, -0.06258005f, -0.04041928f, -0.04499127f, 
    0.01642334f, 0.01146654f, 0.02364401f, 0.02158665f, -0.03360121f, -0.05635060f, -0.00172194f, 0.03963567f, 
    -0.03332373f, 0.03305775f, 0.02294158f, -0.01820381f, -0.04174684f, 0.04021777f, -0.05909856f, -0.03809076f, 
    -0.00396242f, -0.05125998f, -0.01739321f, 0.01496487f, -0.00987014f, -0.01684760f, 0.03462150f, -0.01996165f, 
    0.01494286f, -0.05559476f, -0.00044252f, 0.04910587f, -0.01374750f, 0.00665307f, 0.03795041f, 0.00947162f, 
    -0.00126989f, 0.01468162f, -0.03743770f, 0.03338964f, 0.00758132f, 0.01473011f, 0.01413391f, 0.01378401f, 
    0.04380842f, 0.00229949f, -0.05180182f, -0.06226426f, 0.03519042f, -0.04812086f, 0.00870856f, 0.03751177f, 
    -0.05922223f, -0.03436132f, -0.01597877f, 0.01558668f, 0.01674766f, 0.01665141f, 0.02413234f, 0.03584472f, 
    -0.04118987f, -0.00453065f, -0.04807517f, 0.03802507f, 0.04684777f, -0.01971295f, -0.01530763f, -0.05347013f, 
    0.00405704f, -0.01971252f, -0.00233666f, 0.04549329f, 0.03136483f, -0.01337795f, -0.04736365f, 0.01890533f, 
    -0.02617186f, 0.02651903f, 0.02297387f, 0.04763551f, -0.04304500f, -0.04036579f, -0.04851754f, 0.02939757f, 
    0.01970403f, -0.02155061f, 0.03756626f, -0.02569739f, -0.03774753f, 0.03287172f, -0.03966481f, -0.02870077f, 
    -0.00590925f, -0.05517980f, 0.04730856f, 0.02177304f, 0.01764543f, 0.00633184f, 0.00486445f, 0.02834101f, 
    0.02781314f, -0.05458473f, -0.02681152f, -0.04892527f, -0.00564646f, 0.01891670f, -0.02202753f, -0.03909204f, 
    -0.04635197f, -0.01703086f, -0.01119851f, 0.01131361f, -0.04145862f, 0.00608580f, -0.03025741f, 0.02994564f, 
    -0.02811028f, 0.04646291f, 0.00326598f, 0.04490368f, 0.03160540f, 0.04138704f, -0.03925300f, -0.03151781f, 
    -0.04733025f, -0.02725237f, -0.06209784f, 0.00405741f, -0.05508145f, -0.04313281f, 0.03068743f, 0.01841445f, 
    -0.00643177f, 0.03689908f, 0.03922439f, -0.00655505f, -0.05277457f, -0.01204801f, 0.03453004f, 0.04205803f, 
    -0.04203456f, -0.05310608f, 0.04462766f, 0.03580124f, 0.01595976f, 0.04410223f, 0.03612424f, -0.01273634f, 
    -0.04403913f, 0.02223258f, -0.02584910f, 0.02215942f, -0.00728540f, 0.02322217f, -0.05820610f, 0.01942379f, 
    0.03856332f, -0.02416832f, 0.00297252f, -0.05430069f, -0.05908104f, 0.04838871f, -0.00794998f, -0.04596703f, 
    -0.05589867f, -0.05179432f, -0.00650235f, 0.03268880f, -0.00769651f, 0.04526296f, -0.01736074f, 0.03823219f, 
    0.05461298f, -0.02844230f, 0.01249879f, -0.04074555f, -0.01347646f, -0.03751738f, -0.04711270f, 0.01363704f, 
    -0.00902831f, -0.00499112f, -0.00317137f, 0.03867326f, -0.00094153f, 0.03596106f, 0.04393687f, -0.06149357f, 
    -0.02444303f, -0.02289722f, -0.03643057f, 0.04227508f, 0.03010430f, -0.03893550f, 0.01028288f, -0.05157586f, 
    0.03439898f, 0.04638517f, -0.04253568f, 0.01020391f, -0.00000712f, 0.03137980f, 0.03025561f, -0.04904309f, 
    -0.01090507f, 0.01744765f, 0.01682281f, -0.02694434f, -0.05712938f, 0.02376288f, 0.03676088f, 0.03707404f, 
    0.00928947f, 0.01694400f, -0.02044725f, 0.01699147f, 0.01415199f, -0.05931165f, -0.00130492f, -0.04181070f, 
    -0.00997687f, -0.04657891f, 0.00732933f, 0.00792509f, 0.03324366f, 0.02604759f, 0.04597694f, -0.02464311f, 
    -0.05587534f, -0.02177703f, 0.02177289f, 0.02100969f, 0.00983759f, -0.04072022f, 0.00087390f, 0.02422511f, 
    -0.04214428f, 0.00697740f, -0.05058262f, -0.00487726f, 0.01677686f, -0.05537472f, 0.02448854f, -0.05273224f, 
    0.03190675f, 0.01500712f, -0.04613567f, -0.02573578f, 0.01589758f, -0.01799301f, 0.01367456f, -0.04399199f, 
    0.04574620f, -0.04222996f, -0.04577585f, -0.03677659f, -0.03754454f, -0.05344298f, -0.05998398f, -0.05658664f, 
    0.00756179f, -0.04939022f, -0.00381654f, 0.00390831f, -0.03949622f, 0.04407072f, 0.05786094f, -0.00375577f, 
    0.04881136f, 0.03274146f, 0.02829261f, -0.03285079f, 0.04944642f, -0.00023919f, -0.03339075f, -0.03458526f, 
    0.00332119f, 0.03107488f, -0.04459549f, -0.02383537f, -0.04367914f, -0.04491273f, -0.02278961f, 0.01403801f, 
    0.01223191f, -0.01842523f, 0.00863492f, -0.00918471f, -0.02384361f, 0.04411923f, 0.04517973f, -0.05198016f, 
    0.01555066f, -0.03603181f, 0.03444400f, -0.01118601f, 0.00983185f, 0.02677949f, -0.01419808f, 0.01426930f, 
    0.00024818f, -0.03906138f, 0.03332766f, 0.02521239f, 0.02428418f, 0.05331490f, 0.00012701f, 0.00996441f, 
    -0.05021250f, -0.04123626f, 0.03453616f, -0.05547165f, -0.03600989f, -0.01415624f, 0.01777242f, -0.03205607f, 
    -0.02163799f, -0.00967725f, 0.00489444f, 0.03962559f, -0.06472104f, 0.02020313f, -0.04368221f, -0.04119355f, 
    0.00958563f, -0.01871603f, -0.02897344f, 0.00770807f, -0.00412182f, -0.02714414f, -0.02038353f, -0.00869796f, 
    -0.04639784f, -0.06253376f, -0.01122750f, 0.00073087f, -0.05085604f, 0.02950240f, 0.00580773f, -0.01114295f, 
    0.03994947f, -0.02036946f, -0.04510403f, -0.01407553f, -0.00718057f, -0.01811756f, 0.01846216f, -0.00632138f, 
    -0.00849416f, -0.06417833f, -0.05756935f, 0.05114074f, 0.00018937f, -0.05343676f, 0.04134332f, 0.03275807f, 
    -0.04517233f, -0.04127045f, -0.01130618f, 0.02292566f, 0.01801275f, -0.03488968f, -0.04555654f, -0.04626508f, 
    0.01560550f, -0.04073938f, -0.02302373f, 0.01504837f, 0.00289642f, 0.02873234f, 0.04285079f, 0.04141239f, 
    -0.04463674f, 0.03007863f, -0.02591883f, 0.03872508f, 0.05043741f, -0.02202686f, -0.02871907f, 0.00847037f, 
    0.01009461f, 0.00622773f, -0.02607244f, -0.00908710f, 0.03179791f, -0.00646028f, -0.00665908f, 0.04209613f, 
    -0.01926191f, -0.01806088f, 0.02448538f, -0.02358754f, 0.02418202f, 0.01756835f, 0.01793645f, 0.01712833f, 
    -0.02123672f, 0.04362855f, 0.04972880f, -0.04075645f, 0.04896382f, -0.01902721f, 0.04456282f, -0.04954448f, 
    0.26304471f, -0.02002880f, 0.19839177f, -0.14294343f, -0.05668375f, -0.03628613f, -0.02048148f, 0.04743173f, 
    0.09613960f, -0.04491263f, -0.06836802f, -0.08580928f, -0.00812852f, -0.14269847f, -0.12576155f, -0.02173593f, 
    -0.07004841f, 0.07634968f, -0.02759264f, -0.06088405f, 0.53711331f, 0.10624399f, 0.11842358f, 0.01236169f, 
    -0.19407746f, -0.03126593f, -0.05896655f, 0.03191055f, 0.06306206f, -0.01397505f, -0.04023092f, 0.09538386f, 
    -0.05970462f, -0.01579681f, 0.01139629f, 0.04931515f, -0.01504811f, 0.06271010f, 0.09466273f, 0.05778215f, 
    0.04799965f, -0.10283581f, -0.16947031f, 0.03802147f, 0.19248538f, -0.15856732f, -0.04203456f, 0.08369507f, 
    -0.05434376f, -0.11071812f, -0.04462998f, 0.05976122f, 0.01919085f, -0.05451274f, -0.07247463f, -0.03143598f, 
    -0.00522228f, 0.18973389f, -0.09240136f, 0.03474509f, -0.02735812f, 0.40622476f, 0.28555319f, 0.15670860f, 
    0.11181087f, 0.03505387f, -0.00344102f, 0.09690607f, 0.04968742f, -0.11008493f, 0.02660697f, 0.07887147f, 
    -0.01714846f, 0.04059699f, 0.00551139f, 0.18938865f, 0.08137073f, 0.19970147f, 0.06136720f, 0.03755422f, 
    0.13768272f, -0.02845791f, 0.16485831f, 0.00934149f, -0.13759749f, -0.01727136f, -0.20875578f, -0.13699642f, 
    -0.11808617f, -0.03749748f, -0.06344537f, -0.03182577f, -0.15063167f, -0.12523608f, -0.02717074f, -0.19721042f, 
    -0.16002095f, -0.00207623f, -0.06395350f, -0.04404814f, 0.32770851f, 0.11965980f, 0.18127181f, -0.10051655f, 
    0.01317340f, -0.12079677f, 0.11114240f, 0.00708494f, -0.13818997f, 0.02807063f, 0.01158803f, -0.11654270f, 
    0.06046840f, 0.05121798f, -0.06570639f, 0.13896598f, -0.00865974f, 0.09139265f, 0.10295273f, 0.06800108f, 
    -0.31843525f, -0.11982786f, -0.22792889f, 0.00249108f, 0.04259241f, 0.00584797f, -0.09419671f, -0.16915703f, 
    0.05317355f, 0.06970299f, -0.05786910f, 0.07204683f, -0.01336022f, 0.08482781f, 0.06194910f, 0.03708074f, 
    -0.01648388f, -0.05139230f, 0.21589227f, 0.05183402f, -0.04604797f, -0.12283953f, 0.08823512f, 0.11414014f, 
    0.06460061f, -0.00278787f, 0.12705947f, 0.10729355f, 0.06132823f, 0.12532185f, 0.06417259f, 0.03385939f, 
    0.08044074f, 0.11557107f, 0.01392996f, -0.04495403f, -0.01686758f, 0.07745631f, 0.04557697f, 0.06806420f, 
    -0.35749206f, -0.06089748f, 0.12273632f, -0.05982861f, -0.04154677f, -0.04453158f, -0.09590439f, -0.11602449f, 
    0.04044062f, 0.13746436f, 0.00627688f, 0.11673505f, -0.04213704f, 0.05934859f, -0.02344571f, -0.03584890f, 
    -0.10213817f, -0.02762185f, -0.04268588f, 0.04403389f, -0.24968368f, -0.23769590f, 0.08337111f, 0.08305129f, 
    0.07195211f, -0.09130769f, 0.07531442f, -0.02943958f, -0.01779795f, -0.01130654f, 0.00144163f, -0.03523231f, 
    0.10833061f, -0.05289109f, 0.01528661f, 0.07529516f, -0.04796132f, 0.19783802f, 0.09835389f, 0.00189020f, 
    0.20438343f, -0.04822521f, 0.03015506f, 0.17407508f, 0.19690137f, 0.10077729f, 0.09767143f, 0.07225505f, 
    0.21497071f, -0.07548076f, -0.00171987f, 0.02531590f, -0.08268928f, -0.04442199f, -0.01566676f, 0.07820525f, 
    0.02653401f, 0.05505033f, 0.12667224f, 0.01605546f, -0.23191123f, -0.19666326f, -0.12565675f, 0.00266201f, 
    -0.01766284f, 0.03881703f, 0.05229905f, -0.14781031f, -0.03467041f, -0.11094663f, -0.05516475f, 0.01810141f, 
    -0.03692421f, -0.04229825f, 0.04420650f, -0.07261795f, 0.04618868f, 0.06521371f, 0.10297578f, 0.02316701f, 
    -0.21787913f, 0.09776870f, -0.18443415f, -0.10561067f, 0.19927160f, -0.02353953f, -0.03668198f, -0.04161944f, 
    0.09200355f, 0.05256284f, -0.12781934f, 0.02165432f, 0.13458940f, 0.01135290f, -0.04351567f, -0.02101473f, 
    -0.03474621f, 0.12191007f, -0.03097733f, 0.04908155f, 0.13100059f, -0.02268440f, 0.03156497f, -0.06680351f, 
    0.05578082f, -0.05067058f, -0.09919400f, -0.09953478f, -0.07827247f, 0.01441538f, -0.04300039f, 0.00901741f, 
    0.15258852f, 0.03053740f, -0.02692681f, -0.20556004f, 0.03549029f, 0.10394963f, 0.02623685f, 0.07307333f, 
    -0.14978279f, -0.32477513f, 0.16292256f, 0.00384521f, 0.15425740f, 0.02997021f, 0.06399422f, 0.07076123f, 
    -0.01624187f, 0.08299731f, 0.02426037f, 0.03313781f, -0.04793359f, 0.00020979f, -0.03129255f, -0.06478434f, 
    0.00114280f, 0.11661156f, 0.06382700f, 0.06012059f, -0.00846858f, 0.04819566f, 0.19701749f, 0.03516681f, 
    -0.09399474f, -0.10588873f, -0.05774125f, -0.11485977f, -0.07297803f, -0.08050460f, -0.04326154f, -0.02706068f, 
    -0.01647270f, -0.00569818f, -0.13208534f, -0.11075065f, -0.03013580f, 0.00880242f, 0.01571265f, -0.09505548f, 
    0.10613830f, -0.20306012f, -0.05739369f, 0.02465494f, 0.02425900f, -0.02227603f, 0.05730153f, -0.11275122f, 
    -0.04651818f, 0.01114172f, -0.02291872f, 0.17418602f, 0.05810216f, 0.02941104f, 0.05214217f, -0.14208229f, 
    0.09551046f, 0.00737727f, -0.04183140f, -0.02594933f, -0.46938169f, -0.32639322f, 0.40870193f, -0.09054251f, 
    0.22166848f, -0.05403841f, -0.00575459f, 0.24343929f, -0.01329738f, 0.03038114f, -0.17169814f, -0.15453078f, 
    0.03598459f, 0.00140779f, -0.01869081f, -0.06501158f, -0.04213685f, 0.01374688f, -0.03293435f, -0.09289359f, 
    -0.00271988f, -0.03333707f, 0.19214819f, 0.08812149f, -0.14669061f, -0.06255624f, -0.00248210f, 0.13274552f, 
    0.06535424f, 0.01189914f, 0.00234892f, 0.03604368f, -0.00531487f, 0.05527778f, 0.07853716f, -0.13414551f, 
    -0.05228600f, -0.03104926f, -0.03981894f, 0.10396799f, 0.19763790f, -0.10321444f, -0.20140313f, -0.00637824f, 
    -0.04132828f, -0.03575379f, 0.04413477f, -0.12218299f, 0.18061431f, 0.06637648f, -0.17693534f, 0.01569743f, 
    -0.04432243f, -0.03341034f, 0.03910882f, -0.03638481f, 0.05496023f, -0.07814758f, 0.04035290f, 0.04756881f, 
    -0.01325935f, -0.07540718f, -0.13159864f, -0.03167063f, -0.00416742f, -0.00932514f, 0.05646036f, 0.05204701f, 
    0.01303737f, 0.01619643f, -0.02231017f, 0.00704906f, 0.01787484f, 0.08991071f, 0.07538986f, 0.02763022f, 
    0.00792036f, -0.03068526f, -0.04447160f, -0.07714693f, 0.00953536f, -0.28253248f, -0.11770543f, 0.08976450f, 
    -0.01663942f, 0.01429540f, -0.13622090f, -0.00108350f, 0.04006914f, -0.01571993f, -0.00792066f, 0.11833288f, 
    -0.02613498f, -0.03636121f, 0.00745510f, -0.15188465f, 0.01324469f, 0.01003506f, -0.04526893f, -0.05842740f, 
    0.26507723f, 0.05355854f, 0.12518798f, -0.01637813f, -0.00088002f, 0.00448736f, 0.17742519f, 0.08482698f, 
    -0.00669540f, 0.10677117f, -0.07419713f, -0.04704990f, 0.01783134f, -0.05889744f, 0.00799884f, 0.11125212f, 
    0.04095317f, -0.07976696f, -0.02164041f, 0.02131900f, 0.13280207f, -0.00883095f, 0.07463908f, 0.14064857f, 
    -0.03442927f, -0.01527151f, -0.00359668f, 0.04686672f, 0.02841082f, -0.02860806f, 0.00532515f, -0.00696773f, 
    0.01189007f, -0.01843380f, -0.08949818f, -0.07837749f, 0.08372744f, -0.02603667f, -0.01022650f, -0.06919328f, 
    0.16355805f, 0.03835436f, -0.15113778f, 0.15078036f, -0.01824934f, 0.02533907f, 0.13344571f, 0.12780724f, 
    0.04090859f, 0.00418135f, -0.02530910f, -0.13460669f, -0.13060673f, -0.13533463f, -0.07311834f, 0.01839293f, 
    -0.03972854f, -0.03290754f, -0.04503965f, -0.00584430f, 0.09057654f, 0.05759619f, 0.01212696f, 0.39624408f, 
    -0.03974512f, 0.01711100f, 0.00844424f, 0.03144495f, 0.02118542f, 0.03514351f, -0.09281811f, -0.09350415f, 
    -0.09169523f, -0.02559374f, -0.03596300f, -0.07144748f, 0.05698849f, -0.03488126f, -0.08747550f, 0.04776187f, 
    0.00109194f, 0.14550118f, -0.07430468f, 0.05324022f, -0.18290479f, -0.06408034f, -0.13911016f, -0.25182882f, 
    0.01600794f, 0.09613971f, -0.14973073f, 0.08485012f, 0.02314204f, 0.05057190f, -0.13466506f, 0.03262778f, 
    -0.01405824f, -0.04370199f, 0.06202612f, 0.08491192f, 0.16363297f, 0.32706299f, 0.31705025f, 0.04702319f, 
    0.16524482f, 0.04191429f, -0.04370285f, -0.09420624f, 0.05438057f, 0.08296519f, 0.00629439f, 0.05432589f, 
    -0.03503323f, 0.04257934f, -0.00654432f, -0.03100580f, -0.08313423f, -0.05616692f, 0.02871633f, -0.03143759f, 
    -0.00255342f, -0.04410969f, 0.08663105f, 0.11575000f, -0.27234191f, -0.00587868f, 0.07944632f, 0.02537144f, 
    0.01993021f, -0.06935473f, -0.02439112f, -0.09392539f, -0.07890648f, 0.15776753f, 0.09068122f, 0.04339005f, 
    -0.00332245f, -0.10971367f, -0.11790673f, 0.02436554f, -0.05294883f, -0.18064910f, 0.11905843f, 0.05367832f, 
    0.04191916f, -0.01840217f, -0.01440621f, 0.03946060f, 0.08195344f, -0.04960332f, -0.00873819f, -0.12145036f, 
    -0.08574422f, -0.07049159f, -0.00632182f, -0.09480543f, -0.00159636f, 0.03056397f, -0.17380956f, 0.02911186f, 
    -0.09377667f, 0.39891192f, -0.06384479f, 0.22497603f, -0.15032279f, 0.01950239f, -0.13528712f, 0.11023396f, 
    -0.05722516f, 0.13888343f, -0.00848915f, 0.00257854f, 0.07467867f, 0.14007033f, -0.02074446f, 0.01841240f, 
    -0.06963501f, -0.02264276f, -0.14353864f, 0.07837330f, 0.10675094f, -0.17133488f, -0.18224883f, -0.05910261f, 
    0.02682371f, 0.01482399f, 0.06333373f, 0.06381799f, 0.01611753f, 0.07374280f, 0.02879908f, 0.14462015f, 
    0.03720535f, -0.04234693f, 0.09309366f, -0.10113033f, -0.03101632f, 0.01715872f, -0.14799455f, 0.02262861f, 
    -0.16394612f, -0.01699081f, -0.30175737f, 0.20392551f, -0.11557432f, 0.08285520f, -0.03284685f, 0.01324116f, 
    -0.19154087f, -0.07572933f, 0.01546928f, 0.06075495f, 0.12111510f, 0.08036499f, -0.07655295f, 0.00136789f, 
    -0.00365108f, 0.06898987f, -0.10933781f, -0.19796169f, -0.46671516f, -0.38156047f, 0.06148132f, 0.10311437f, 
    0.01710259f, -0.02630050f, 0.01950497f, 0.04139418f, -0.02304987f, -0.32309917f, -0.01021939f, -0.02212344f, 
    -0.08931459f, 0.09776224f, -0.02877611f, 0.01997713f, -0.05009687f, -0.00443107f, -0.02849426f, -0.20199971f, 
    -0.17344652f, 0.18407927f, 0.30032820f, 0.04376939f, -0.25676900f, 0.07149618f, 0.00024449f, 0.07970633f, 
    -0.16226244f, 0.12811302f, -0.08233350f, -0.03152053f, 0.05355718f, 0.02255105f, 0.01616257f, -0.07682610f, 
    -0.06934556f, -0.14805061f, 0.05187777f, 0.00834567f, -0.01329114f, -0.02528674f, 0.05619353f, -0.23059569f, 
    0.13015610f, -0.10448812f, -0.15504208f, 0.00902411f, 0.13018747f, 0.19375300f, 0.01647323f, 0.06388411f, 
    0.01270738f, 0.04133270f, -0.01917277f, -0.07112777f, 0.04263109f, 0.01463478f, 0.13347615f, 0.17403163f, 
    -0.06500595f, 0.00528179f, -0.07588416f, -0.09650455f, 0.18911102f, -0.13259746f, 0.04820541f, 0.18341616f, 
    -0.06282190f, 0.03662870f, 0.03673658f, -0.05313155f, 0.14892058f, 0.17338379f, -0.02550749f, -0.01793643f, 
    0.01172725f, -0.05176650f, -0.07793675f, -0.13829477f, -0.02469874f, -0.05888520f, -0.03720616f, 0.11205776f, 
    0.02196901f, -0.07715205f, -0.06288880f, -0.09567677f, 0.02584288f, -0.02148345f, 0.06045575f, 0.10928709f, 
    0.07448011f, 0.10807072f, -0.06007999f, -0.00150815f, -0.02129821f, 0.01309997f, 0.06319784f, -0.03314870f, 
    0.23894705f, 0.05741286f, 0.07913651f, -0.03738564f, 0.03359896f, 0.08465265f, 0.08438130f, -0.00135951f, 
    0.06242515f, 0.08643696f, 0.05014944f, -0.01995460f, -0.02992479f, -0.07364539f, 0.10553743f, 0.05557707f, 
    0.10393146f, 0.00687223f, 0.01701075f, 0.05443293f, 0.16951145f, -0.11126322f, 0.14849579f, 0.09580206f, 
    -0.22778830f, 0.09085274f, 0.03202533f, -0.09880967f, -0.05494235f, -0.10708608f, -0.07153730f, -0.09964412f, 
    0.03239542f, 0.05911744f, 0.10403768f, 0.04250929f, -0.02674203f, 0.02593174f, 0.04943677f, 0.05394533f, 
    0.25422993f, 0.02689655f, 0.01232227f, 0.02911329f, 0.00132916f, 0.11228824f, 0.04512375f, -0.03305309f, 
    0.01607523f, -0.05217297f, -0.01175090f, -0.03843326f, 0.07696866f, -0.02400922f, 0.02048728f, 0.02382189f, 
    -0.14437073f, 0.11789715f, 0.03851191f, -0.04347517f, 0.14684710f, 0.24896348f, -0.01812246f, 0.16257565f, 
    -0.08717646f, 0.21977861f, -0.05538220f, 0.00738313f, -0.03503605f, 0.15338182f, -0.06734065f, -0.04602170f, 
    -0.04135694f, 0.03415240f, -0.05131004f, -0.04326566f, 0.02982925f, 0.10704979f, -0.04526617f, 0.14318691f, 
    -0.08227714f, 0.09877441f, -0.00551311f, 0.00907188f, 0.17458996f, -0.02990305f, 0.05747507f, 0.12677650f, 
    0.02687510f, 0.23384339f, 0.01043892f, 0.02115958f, 0.00438483f, -0.05426986f, -0.02966780f, 0.08070162f, 
    0.13237461f, 0.02606716f, 0.01385926f, 0.01215373f, 0.09866679f, 0.24386805f, 0.27448055f, 0.08405501f, 
    0.07090426f, 0.26505703f, -0.04547887f, 0.19205308f, 0.05408473f, 0.14184064f, -0.05836624f, 0.02512031f, 
    -0.01458607f, -0.09810707f, -0.02429568f, 0.03520415f, -0.03400318f, -0.12230298f, 0.05600694f, 0.14217995f, 
    0.07849959f, 0.16651188f, -0.01944872f, 0.10402650f, -0.26602259f, 0.09546726f, -0.12614733f, 0.03429922f, 
    0.12389837f, 0.03712839f, 0.07221006f, 0.17148529f, -0.05102968f, 0.03254027f, 0.13615170f, 0.04282067f, 
    0.09092023f, 0.14831370f, 0.12816261f, 0.18106499f, -0.22410592f, 0.00494660f, -0.01827234f, 0.07822873f, 
    -0.08482050f, -0.04516266f, -0.04396234f, 0.00912268f, -0.18451592f, -0.24797870f, -0.01078114f, 0.05141491f, 
    -0.01383038f, -0.00876059f, -0.02060676f, -0.02791189f, -0.02038492f, -0.01055397f, -0.01323410f, -0.11742879f, 
    0.01450809f, 0.45799753f, 0.07743201f, 0.22790036f, -0.06499831f, -0.03256935f, 0.20531526f, 0.13527586f, 
    0.04777201f, 0.01035938f, 0.12090733f, -0.01672629f, -0.01956452f, -0.10599954f, -0.05505421f, 0.04339359f, 
    -0.24389772f, -0.01660970f, 0.03838829f, -0.03492087f, 0.19633536f, 0.01918545f, -0.08738727f, 0.04027715f, 
    0.19816741f, 0.02309982f, -0.16616289f, 0.11266765f, 0.03399581f, -0.19845180f, 0.09848195f, 0.11451048f, 
    0.02938429f, 0.01395193f, -0.00701921f, -0.07390081f, -0.05199329f, 0.21156433f, -0.03645555f, 0.02841439f, 
    0.26504716f, 0.12205818f, 0.18356159f, -0.06459747f, 0.20669422f, -0.02956394f, -0.10068244f, 0.01232676f, 
    0.04297424f, 0.00982628f, -0.04035926f, -0.04650081f, 0.00576332f, 0.08236008f, 0.05252662f, -0.14348350f, 
    -0.05869276f, -0.12767690f, -0.04077124f, -0.08457837f, 0.06604245f, 0.33530352f, -0.05963821f, 0.08786125f, 
    0.14945346f, -0.19693261f, 0.15591453f, 0.15829679f, -0.07592279f, 0.16787973f, 0.00916402f, 0.06517360f, 
    0.03147414f, 0.08425253f, -0.09830131f, -0.06886400f, 0.20900331f, 0.07216213f, 0.06650806f, 0.04746281f, 
    0.01080137f, -0.07599310f, 0.06591224f, 0.04297441f, 0.03849019f, -0.02623495f, 0.00582834f, 0.01714146f, 
    0.11977097f, -0.12927286f, 0.14103220f, 0.03048193f, -0.07131866f, 0.07087094f, -0.03876324f, -0.11873258f, 
    -0.06431579f, -0.00737980f, -0.06408842f, -0.07236067f, 0.58173794f, 0.10594007f, -0.04844054f, 0.12466602f, 
    -0.13840179f, 0.04271624f, 0.13886546f, -0.00802086f, 0.06606118f, -0.10039620f, 0.07757621f, 0.13627574f, 
    0.16942836f, -0.00475114f, 0.13326284f, 0.33919182f, 0.10103589f, 0.15425926f, 0.15356916f, 0.13317089f, 
    0.19904935f, -0.04843621f, 0.05650580f, 0.06843962f, 0.06747043f, 0.02657555f, -0.06229459f, -0.07539286f, 
    0.00444847f, -0.00407340f, 0.04478853f, 0.08669360f, -0.00983437f, 0.04111448f, 0.09343442f, -0.06933156f, 
    -0.08893329f, -0.17025641f, -0.02690499f, -0.07812487f, -0.07274667f, -0.01509037f, 0.24885498f, 0.03536389f, 
    0.26960480f, 0.03734463f, 0.10066251f, 0.12801109f, 0.05929674f, 0.08049707f, 0.12520187f, -0.02105884f, 
    0.15266308f, -0.02456503f, 0.11465134f, 0.06649099f, 0.04479961f, -0.00925024f, 0.07415805f, 0.00565870f, 
    -0.18620598f, -0.00803404f, 0.09476347f, 0.33194610f, -0.20329201f, -0.05943950f, -0.18234962f, 0.03076058f, 
    -0.05795880f, 0.04479422f, -0.13919967f, -0.08492729f, 0.01905751f, -0.07146155f, -0.05666584f, -0.09065861f, 
    0.03492946f, 0.10491902f, 0.02583271f, -0.01674554f, -0.29207012f, 0.26010704f, 0.12782872f, 0.18568157f, 
    0.07351189f, -0.09360703f, 0.07801986f, 0.08889596f, 0.02125835f, 0.08695500f, 0.04967114f, 0.19001620f, 
    0.08752294f, -0.02630839f, 0.05387457f, 0.02063660f, -0.01754408f, -0.01610414f, 0.07941602f, -0.00432859f, 
    -0.39331385f, 0.04655761f, 0.38440391f, 0.24499662f, -0.05731548f, 0.03541237f, -0.08043513f, -0.07675627f, 
    0.12897979f, -0.00179862f, -0.09179509f, 0.03384608f, -0.00758917f, -0.01615161f, -0.04220974f, -0.09074688f, 
    -0.17770025f, -0.06759179f, -0.14002007f, -0.07369059f, -0.24242340f, -0.22732566f, 0.21697010f, 0.04734720f, 
    -0.11679435f, -0.15286797f, 0.04564780f, -0.15707952f, 0.05894255f, -0.06868673f, -0.00160674f, -0.02049744f, 
    -0.02426171f, -0.11631590f, -0.03903158f, 0.02435139f, -0.18398203f, -0.22273365f, 0.12684920f, -0.09742513f, 
    0.41549715f, 0.05302706f, -0.07135034f, -0.00653594f, -0.28573087f, 0.02986958f, 0.00726807f, -0.01390658f, 
    0.03193515f, -0.09132394f, -0.00252355f, 0.07084072f, -0.01883309f, 0.07260033f, 0.08835243f, 0.09156501f, 
    0.07166311f, 0.02961821f, 0.00711559f, 0.01238366f, -0.45609748f, -0.13791108f, -0.13778265f, 0.08199463f, 
    -0.09525973f, -0.24336867f, 0.05577321f, -0.21510343f, -0.11464954f, -0.21289119f, -0.05435463f, -0.03163353f, 
    -0.09558664f, -0.05787297f, -0.08656709f, -0.12396828f, -0.01137971f, 0.03954362f, -0.02987288f, -0.16390716f, 
    -0.00379132f, -0.05313204f, 0.40863913f, 0.03579137f, 0.08165796f, 0.02850821f, 0.00129256f, -0.11856967f, 
    0.11704660f, 0.04412705f, -0.01022468f, -0.18717259f, 0.05601617f, -0.04774941f, -0.05155932f, 0.01144973f, 
    -0.03282993f, -0.08658881f, 0.03146341f, -0.09227707f, 0.04024867f, -0.06071721f, 0.16389221f, 0.07990973f, 
    0.25230160f, -0.03262487f, 0.05925869f, 0.03048469f, 0.09448197f, 0.12956366f, 0.13093524f, 0.11431687f, 
    -0.06868483f, -0.03850447f, 0.02431199f, -0.14498404f, -0.06762461f, -0.02055631f, 0.05892259f, 0.01965063f, 
    -0.27008465f, -0.41252694f, 0.04456063f, 0.00643895f, 0.06605822f, 0.06304049f, -0.06899492f, -0.18726097f, 
    0.00659175f, 0.01137057f, 0.00345618f, -0.10178375f, 0.10580025f, 0.06283098f, 0.03592150f, -0.08957357f, 
    -0.00458802f, -0.03047895f, 0.18044393f, 0.02158669f, 0.09440268f, -0.12081174f, -0.00050661f, -0.01167204f, 
    0.08371232f, -0.12854040f, -0.08137099f, 0.03363713f, -0.04883058f, 0.05025994f, 0.13384333f, 0.17023404f, 
    0.04519533f, -0.01210146f, 0.11916324f, -0.08263475f, -0.11200935f, -0.13804996f, -0.04183985f, -0.10325526f, 
    -0.35290316f, 0.16860875f, 0.26337260f, -0.05247804f, 0.01635183f, 0.03176309f, -0.08769575f, 0.01758566f, 
    -0.18994847f, -0.08974651f, -0.05699614f, -0.01429156f, 0.09229527f, 0.01034905f, 0.16110083f, 0.00902519f, 
    0.05872513f, 0.04497448f, -0.21089222f, -0.12256011f, -0.24865441f, 0.19661887f, -0.36575806f, -0.01464162f, 
    -0.04570922f, 0.02583331f, 0.05454588f, -0.29456636f, -0.24074969f, -0.33601791f, 0.04070371f, 0.12179606f, 
    -0.01545067f, -0.01938718f, -0.01664688f, 0.03307842f, 0.09305418f, 0.00161983f, -0.14894058f, -0.02515277f, 
    -0.06742761f, 0.15587449f, -0.06542407f, 0.10042562f, 0.25091946f, 0.04336616f, -0.02266799f, -0.02465195f, 
    -0.06774823f, 0.03046900f, 0.12135249f, 0.01774073f, -0.02616083f, -0.14920045f, 0.08977431f, -0.18087552f, 
    -0.19054788f, -0.18050762f, -0.03021132f, -0.23707387f, -0.25661987f, -0.08837028f, -0.01363493f, 0.04005084f, 
    -0.04946550f, 0.00999981f, 0.01092914f, 0.17807566f, 0.01346707f, -0.07086588f, -0.00435022f, 0.00197337f, 
    -0.03854192f, 0.13072184f, 0.04028805f, 0.03552148f, -0.00244564f, 0.06287710f, 0.05346642f, -0.07165267f, 
    -0.04064969f, -0.00117282f, 0.03122239f, -0.16742501f, 0.03195519f, -0.26746622f, -0.17466243f, 0.06945443f, 
    -0.12398890f, -0.33600953f, -0.11271181f, -0.12771204f, 0.02825138f, 0.01743619f, -0.04496789f, 0.06364030f, 
    -0.00830764f, -0.19122727f, -0.15145700f, -0.17361189f, 0.45310390f, 0.28405827f, 0.09789263f, -0.17683117f, 
    0.03094507f, 0.04558752f, 0.08758437f, -0.01123171f, -0.08308077f, 0.03295373f, -0.16221032f, 0.02030312f, 
    0.03450097f, 0.01103314f, 0.14880270f, 0.04605833f, 0.10433093f, -0.05871622f, 0.00863742f, -0.03658407f, 
    -0.00034313f, -0.24236359f, -0.17744343f, 0.01311633f, 0.21664894f, -0.04321294f, -0.05771413f, -0.14146858f, 
    0.10345991f, 0.01833388f, 0.00178956f, 0.03918825f, 0.00999689f, 0.10226411f, 0.01976478f, -0.02959949f, 
    0.03827963f, 0.18804049f, -0.01487561f, 0.09891170f, 0.19052605f, -0.08764986f, 0.08139126f, -0.05210587f, 
    0.01064165f, 0.02031584f, -0.14393848f, -0.08836622f, 0.00983806f, -0.13134259f, 0.04476650f, 0.06251495f, 
    0.06533695f, -0.05083888f, 0.06319275f, -0.04315669f, 0.04973155f, 0.08041174f, 0.00052170f, -0.01009520f, 
    0.27403808f, -0.09392016f, 0.05855426f, 0.08179058f, 0.31960028f, 0.06334456f, -0.09844478f, -0.06043428f, 
    0.04265407f, -0.15489902f, 0.07293141f, 0.04032003f, 0.00589417f, 0.08310831f, 0.17054369f, 0.03176139f, 
    -0.18132290f, -0.05622500f, -0.07500426f, -0.15076104f, 0.19347867f, 0.05365191f, 0.00892494f, -0.12320905f, 
    0.18809952f, 0.10306400f, -0.21396674f, 0.02532394f, -0.11778568f, 0.07093251f, -0.06057753f, 0.09593189f, 
    0.05882208f, -0.07689413f, 0.18332073f, 0.11188692f, 0.04303000f, -0.07409289f, 0.03115331f, 0.02242549f, 
    -0.30784589f, -0.18645932f, 0.42460713f, 0.12631778f, 0.22304091f, -0.03917425f, 0.02743794f, 0.02291490f, 
    0.07360784f, 0.10911849f, -0.12192500f, -0.07760537f, 0.02593548f, -0.03694209f, -0.06487141f, 0.09868991f, 
    0.11750889f, 0.13050799f, 0.06747821f, 0.16545784f, -0.07652859f, -0.09419544f, -0.21688460f, 0.04275562f, 
    0.13856381f, 0.01303686f, -0.11918961f, 0.11128476f, 0.13551256f, 0.23272283f, 0.03701494f, 0.00795405f, 
    0.02008086f, -0.08487019f, 0.03901164f, -0.01428916f, -0.07069667f, 0.09186670f, -0.04953586f, -0.05386637f, 
    -0.05834131f, 0.05949318f, 0.16102260f, 0.09017166f, 0.13600005f, -0.06161320f, -0.01407878f, 0.11731075f, 
    0.08870331f, 0.02915527f, -0.03143558f, -0.04209449f, 0.03679812f, 0.05118451f, 0.18512769f, 0.03569282f, 
    0.11964951f, 0.00791437f, 0.23752528f, 0.17066798f, 0.03086618f, 0.25376970f, -0.04696440f, -0.20618683f, 
    -0.27416468f, -0.04326162f, -0.03751412f, 0.02944534f, -0.29501060f, -0.33994988f, 0.02369822f, 0.08471031f, 
    0.03776249f, -0.00558036f, 0.01308545f, -0.02155799f, -0.10995973f, -0.25886405f, -0.07883076f, -0.02920207f, 
    0.32511386f, 0.24157147f, 0.18124892f, -0.03076904f, 0.22907606f, 0.09473697f, 0.15665956f, 0.05163043f, 
    -0.01562355f, 0.05472305f, -0.05233110f, -0.01415105f, -0.00317504f, -0.08979719f, -0.11888022f, -0.02877452f, 
    -0.21784505f, -0.03680469f, 0.07161338f, -0.20560312f, -0.04509646f, 0.06102405f, 0.07548592f, -0.06896161f, 
    -0.12398660f, 0.01916002f, 0.02313310f, 0.25325269f, 0.15740882f, -0.08644278f, 0.01719614f, -0.00564770f, 
    0.09143674f, 0.03147181f, 0.00024937f, 0.10258968f, 0.00908631f, -0.12684590f, 0.04743345f, 0.06880365f, 
    0.04559183f, -0.02279873f, 0.04063253f, -0.00006830f, 0.04405995f, 0.00381625f, -0.00801384f, 0.01712161f, 
    0.02010485f, -0.00959563f, 0.04926659f, 0.03042989f, -0.03367088f, 0.01190451f, 0.01341805f, 0.00782824f, 
    0.04429558f, 0.00459238f, -0.04861775f, 0.04747923f, -0.01249748f, 0.04422502f, 0.00871002f, -0.06070871f, 
    -0.05594694f, -0.02641591f, -0.01366765f, 0.00363990f, 0.00544731f, -0.02265390f, -0.00784351f, -0.04829124f, 
    -0.05110467f, -0.03519792f, -0.00796228f, -0.00844159f, -0.01157969f, -0.04392710f, 0.01004520f, -0.02658363f, 
    0.03683119f, 0.03697101f, -0.01722774f, 0.04279773f, -0.01699564f, 0.02377960f, 0.01883721f, 0.01260974f, 
    -0.00259053f, 0.01446723f, -0.01277315f, -0.00533698f, 0.01557534f, -0.02906678f, -0.01230146f, 0.05536379f, 
    -0.03565570f, -0.00479259f, -0.05177186f, 0.03815856f, 0.03820181f, 0.01707027f, 0.03331515f, -0.05881865f, 
    0.03151853f, 0.01576810f, -0.01767605f, -0.03866263f, 0.04032069f, -0.02219041f, 0.02591260f, 0.01803006f, 
    -0.00353308f, -0.01470818f, -0.00727181f, 0.02247483f, 0.04732294f, -0.01701043f, 0.03436872f, -0.05610085f, 
    -0.01663539f, 0.02661075f, -0.03252592f, 0.04241295f, -0.00249108f, -0.03653356f, -0.04902022f, -0.02448750f, 
    -0.01732266f, 0.01163221f, 0.04186092f, -0.04325112f, -0.00405368f, -0.03450236f, -0.00848104f, -0.05487332f, 
    -0.04189273f, 0.02494096f, -0.03355880f, -0.04209556f, 0.02417684f, -0.02180162f, -0.01208161f, 0.04049685f, 
    0.02257679f, 0.00090208f, 0.01674166f, 0.04394675f, 0.03890824f, 0.00699946f, 0.01489800f, -0.02626309f, 
    0.04322492f, -0.03562623f, -0.04274566f, -0.01698159f, -0.00415131f, -0.01567056f, 0.03519448f, -0.02079836f, 
    0.02625841f, -0.04164569f, -0.03031502f, -0.01345192f, 0.05574071f, 0.04471447f, 0.02065857f, 0.04218512f, 
    -0.05307404f, 0.05513348f, -0.04244770f, -0.02252250f, -0.06127236f, -0.00924545f, -0.04488166f, -0.05672759f, 
    -0.03332450f, -0.05165798f, -0.05382853f, -0.03790849f, 0.02833813f, 0.01155700f, 0.04211016f, -0.00630202f, 
    -0.03376123f, -0.06064028f, -0.03563403f, -0.02667341f, -0.02963088f, 0.04348723f, -0.03960023f, -0.01225431f, 
    0.00616395f, 0.03331392f, 0.04169566f, -0.00834868f, -0.01168788f, -0.05139564f, 0.04484190f, -0.01114704f, 
    -0.03924422f, -0.02528697f, 0.03177334f, 0.02756714f, -0.00728952f, -0.03416667f, -0.03855480f, -0.00864817f, 
    0.02869247f, -0.03253823f, -0.04109640f, 0.04148696f, -0.03565252f, 0.02886116f, -0.01058579f, -0.03765879f, 
    -0.02894460f, -0.05480275f, -0.06082144f, 0.00971984f, -0.04709329f, -0.03103199f, -0.04461225f, 0.01758377f, 
    0.03550399f, 0.02578763f, 0.03035515f, -0.04783505f, -0.00585763f, -0.04773073f, -0.00201250f, 0.03903007f, 
    -0.00729468f, -0.03503910f, 0.05001911f, -0.01478120f, -0.03371926f, -0.04790476f, -0.00250815f, -0.05107912f, 
    -0.04893169f, -0.03288575f, 0.00137413f, 0.00115819f, -0.02734311f, 0.03726304f, -0.01861377f, 0.00990713f, 
    -0.05426147f, -0.00711532f, -0.05394641f, -0.00821727f, 0.00374901f, 0.00457128f, 0.02177553f, -0.00454008f, 
    0.04529055f, 0.01593701f, -0.03120306f, -0.04994162f, 0.00702628f, -0.00891098f, 0.00083147f, -0.03035811f, 
    0.04368767f, -0.05289838f, -0.00571320f, -0.04666755f, -0.04177661f, -0.03964923f, -0.00364018f, -0.04275670f, 
    -0.02566597f, -0.00793704f, -0.05479083f, 0.02690266f, -0.05665967f, -0.03184769f, 0.03036126f, -0.04361053f, 
    0.02660128f, -0.00029122f, 0.02423082f, -0.04429281f, -0.00939862f, -0.04060097f, -0.00557517f, 0.03111216f, 
    -0.03082642f, 0.02103823f, -0.04151247f, 0.02528589f, 0.00633506f, 0.00397178f, -0.05353401f, 0.01362453f, 
    0.00403923f, 0.00273605f, 0.03209914f, -0.00209574f, 0.04167166f, -0.04276919f, 0.00385004f, 0.03973520f, 
    0.03606774f, 0.03243695f, -0.01977241f, -0.04232064f, 0.04979822f, -0.06006432f, -0.04100845f, -0.03936086f, 
    -0.05371249f, -0.04861989f, -0.01255313f, -0.03250440f, -0.03221935f, 0.03976007f, 0.00794635f, -0.03492141f, 
    0.03310689f, -0.01750824f, 0.02499019f, -0.05599371f, 0.01506068f, -0.05318945f, -0.01863929f, -0.01097381f, 
    -0.03697933f, -0.03144812f, -0.02815867f, -0.03645419f, 0.00634788f, -0.05547446f, -0.04418723f, 0.02061558f, 
    -0.04746420f, -0.02376443f, -0.02907040f, -0.01789724f, -0.00868343f, 0.01821911f, -0.02855426f, -0.05424523f, 
    -0.03196763f, -0.06145798f, -0.01726974f, 0.02194423f, -0.02358793f, -0.00008900f, -0.02529718f, -0.03639725f, 
    -0.02116808f, -0.00311250f, -0.03457132f, -0.02048031f, -0.02268787f, -0.05127229f, -0.02031650f, -0.03995080f, 
    -0.39659983f, 0.22327410f, -0.08918533f, 0.14490305f, -0.28237247f, -0.01355934f, -0.22008611f, 0.11477342f, 
    0.03620371f, 0.02620423f, 0.10702398f, -0.05322943f, -0.01634660f, 0.12105789f, -0.04269481f, 0.10729796f, 
    0.09132273f, -0.07597428f, -0.01067621f, -0.05113825f, 0.11566621f, 0.10995942f, 0.09648969f, -0.02844073f, 
    0.01081052f, 0.06104967f, 0.01541221f, 0.07587147f, -0.18081316f, -0.09016779f, 0.26292899f, -0.02734461f, 
    0.00686691f, 0.08864413f, 0.03511534f, -0.07704670f, 0.00211922f, 0.02020428f, -0.01303248f, -0.06525568f, 
    -0.33171275f, 0.05593604f, -0.08194956f, 0.03412854f, -0.21530354f, 0.09936064f, 0.05105716f, -0.00260685f, 
    -0.07099463f, 0.14984046f, 0.00651542f, -0.03039449f, -0.01455947f, 0.06309727f, -0.19629738f, -0.01729511f, 
    0.00947689f, 0.00575507f, 0.07925582f, 0.07266952f, 0.28372657f, -0.23545614f, 0.25004813f, 0.04943933f, 
    0.13887559f, -0.08234609f, -0.04462334f, 0.06383535f, 0.01576155f, 0.09131431f, 0.01031617f, 0.05373802f, 
    0.11527055f, 0.17351942f, -0.09843570f, -0.08165856f, 0.10915612f, -0.01628863f, -0.09373178f, 0.17292303f, 
    0.03065022f, 0.18667601f, 0.15556197f, 0.07297285f, 0.00133194f, -0.16978802f, -0.01761686f, -0.01204727f, 
    0.04200551f, -0.21969454f, 0.11751288f, 0.05029878f, -0.00840506f, 0.04672655f, 0.11321884f, -0.06586207f, 
    0.02805055f, -0.12213887f, 0.02393778f, -0.02426999f, -0.00015059f, 0.27665690f, -0.00927759f, 0.26559457f, 
    -0.11262812f, -0.04517611f, -0.05119221f, 0.15504475f, -0.10528195f, -0.14989972f, -0.09920361f, -0.01480147f, 
    -0.00645333f, 0.03104692f, 0.03981979f, 0.02032788f, 0.02778788f, -0.02714569f, -0.14293392f, -0.12786812f, 
    0.43430808f, 0.16675511f, -0.12613371f, -0.22608133f, 0.15600732f, 0.09289609f, 0.03096830f, -0.07617665f, 
    0.14649303f, 0.02991905f, 0.03658578f, 0.03860865f, -0.08113861f, -0.09547977f, 0.08094457f, -0.02794021f, 
    -0.00211860f, 0.07140654f, 0.01251602f, 0.01279972f, 0.19332425f, -0.24863324f, -0.28793368f, -0.12367716f, 
    -0.06532227f, 0.11423832f, 0.01160073f, 0.12002431f, 0.00188766f, -0.12193163f, -0.10820479f, 0.02417543f, 
    -0.11884835f, -0.00001027f, -0.03499958f, -0.00669906f, -0.01144392f, 0.03249011f, -0.11331325f, -0.03734341f, 
    0.30726185f, -0.25134051f, -0.22943214f, -0.18805212f, -0.08282766f, -0.04948510f, 0.15272358f, 0.01529240f, 
    0.14228699f, 0.13448142f, 0.04938247f, 0.09696011f, -0.03300129f, -0.09106721f, -0.03122037f, -0.09945595f, 
    0.07189663f, 0.02591752f, 0.06411769f, 0.05033631f, 0.23150352f, -0.07658015f, -0.12324460f, -0.54917210f, 
    -0.11481380f, 0.09038169f, -0.09519477f, 0.01144848f, 0.00543988f, 0.05839466f, -0.13966432f, -0.02742582f, 
    -0.07663754f, 0.02501430f, -0.04993740f, 0.07559836f, 0.00640117f, -0.02622683f, -0.14981112f, -0.05443007f, 
    -0.26548946f, 0.07349700f, -0.07494900f, -0.10548779f, -0.11550878f, -0.05919896f, -0.13490635f, 0.07587980f, 
    -0.05245066f, 0.22323801f, 0.01797352f, -0.08852696f, -0.00653976f, -0.00237480f, 0.00114891f, 0.00668801f, 
    0.01781451f, -0.05262279f, -0.19678782f, -0.13296032f, 0.07461340f, 0.07776440f, -0.16885701f, -0.17593497f, 
    0.09577139f, 0.02190634f, -0.07882319f, 0.03175774f, 0.07716566f, 0.25252435f, 0.05321876f, -0.07399752f, 
    -0.00207406f, -0.00354237f, -0.02815711f, 0.00929001f, 0.04930388f, -0.08351497f, 0.06047753f, 0.04587726f, 
    0.44149649f, -0.41728842f, -0.14644431f, -0.06127870f, 0.00596851f, -0.02689523f, -0.04539696f, 0.05904506f, 
    -0.05595746f, 0.02617517f, -0.01059664f, -0.09281075f, -0.27829576f, -0.03775180f, -0.11305466f, 0.01944534f, 
    0.04841108f, 0.03020181f, 0.03250436f, 0.10460351f, 0.04601761f, 0.08659296f, 0.00822485f, 0.00444780f, 
    -0.14250958f, -0.07741660f, 0.01085927f, 0.11780515f, -0.09489282f, -0.15382971f, 0.03050686f, -0.01879967f, 
    -0.06594566f, 0.04994497f, 0.08380842f, 0.03229690f, -0.00313429f, -0.00601848f, 0.08138155f, -0.10173170f, 
    0.27107531f, 0.12316357f, -0.13682184f, -0.21102999f, -0.00355030f, -0.01606044f, 0.02245033f, 0.04289883f, 
    0.18422815f, 0.01507682f, -0.17357834f, 0.11765150f, 0.10252624f, -0.10601233f, -0.00038850f, -0.04145924f, 
    -0.04393579f, -0.00995236f, 0.10170987f, -0.06989952f, 0.02208969f, 0.20706850f, 0.29262751f, 0.17882115f, 
    -0.15966843f, -0.10355879f, -0.02533135f, -0.00406241f, -0.05401287f, -0.05248031f, 0.15492380f, 0.08675241f, 
    0.11945295f, -0.05191103f, 0.07045572f, 0.10970862f, -0.01952082f, -0.20529273f, 0.00650857f, -0.07410511f, 
    0.02653026f, -0.01435639f, -0.04707014f, -0.03636036f, -0.02099580f, 0.03937767f, -0.00565304f, 0.02265590f, 
    -0.01552814f, -0.00759069f, -0.01227505f, 0.01428325f, -0.03537435f, 0.01715816f, -0.06177636f, -0.00660326f, 
    -0.02448375f, -0.04745492f, 0.02160826f, -0.02300376f, 0.02430276f, 0.04434763f, -0.05018383f, 0.02455767f, 
    0.02204354f, -0.04309875f, -0.03537226f, -0.01766484f, -0.02092139f, 0.02914033f, -0.05341340f, -0.02363152f, 
    -0.00715016f, 0.02194713f, -0.03403637f, 0.04676276f, -0.02152908f, -0.02690682f, -0.03038960f, -0.02521084f, 
    0.03116105f, 0.03675225f, 0.01772336f, -0.03918305f, 0.00642724f, -0.06037718f, 0.01238995f, -0.01163862f, 
    -0.03148308f, -0.00682160f, 0.03610622f, 0.00549868f, 0.01442049f, -0.00030731f, 0.00199210f, 0.04354677f, 
    -0.00601929f, 0.04398660f, -0.05435190f, -0.01045382f, -0.02077057f, 0.04213566f, -0.06117104f, -0.04695220f, 
    -0.02701147f, -0.06023776f, -0.02123037f, -0.00469889f, -0.06185897f, 0.02937934f, -0.01885946f, -0.03596798f, 
    -0.03810916f, -0.03539228f, -0.03025381f, 0.02642915f, 0.00320379f, -0.01918615f, -0.00873647f, -0.03709532f, 
    0.01265231f, 0.03853355f, -0.05139244f, 0.00634208f, 0.02733847f, -0.00979723f, 0.00488316f, -0.02779806f, 
    -0.01241627f, 0.03369029f, -0.00876695f, 0.00406264f, 0.00447653f, 0.03762639f, -0.04065297f, 0.02419668f, 
    0.02971475f, -0.00534840f, 0.02127047f, -0.04203308f, -0.03740957f, 0.03205799f, 0.01934971f, 0.00900848f, 
    0.02017272f, 0.04327103f, -0.01265841f, -0.02729529f, -0.03284846f, 0.04875462f, -0.00324353f, -0.01923474f, 
    -0.06314498f, -0.05683210f, -0.02824881f, -0.01649151f, -0.03801852f, -0.04748923f, 0.04726597f, 0.02838048f, 
    -0.01062523f, -0.01829944f, -0.01099109f, 0.04531466f, -0.03700433f, 0.02413232f, 0.03883038f, -0.02552102f, 
    -0.03131557f, 0.00260425f, 0.01685377f, -0.00082884f, -0.01889409f, 0.01838653f, 0.03497790f, 0.04090856f, 
    -0.00066618f, -0.01853943f, 0.03230459f, 0.04521447f, -0.00238231f, -0.05433701f, 0.02258646f, -0.01266795f, 
    0.00367052f, -0.05125876f, 0.04332911f, -0.03968873f, -0.06381169f, 0.00961739f, 0.01680559f, 0.02025994f, 
    -0.05582543f, -0.03113137f, -0.06397995f, -0.02358852f, -0.04321416f, -0.02395215f, -0.00925973f, -0.05790281f, 
    0.01778941f, -0.05758346f, 0.03792260f, 0.03862313f, -0.00389002f, 0.02583738f, -0.02909785f, 0.00054971f, 
    -0.05626663f, -0.02581024f, 0.00851882f, -0.03199153f, 0.03940499f, -0.01918062f, 0.03188230f, -0.04337173f, 
    -0.05585640f, -0.03428936f, 0.04785572f, -0.00973403f, 0.01666419f, -0.03975399f, 0.00036176f, -0.02432344f, 
    -0.05076243f, -0.00880903f, -0.02557478f, 0.00444444f, -0.01817042f, -0.02335399f, -0.00069813f, 0.03991400f, 
    -0.04940188f, 0.00664088f, 0.01042310f, -0.00074291f, -0.01686938f, 0.02133708f, -0.03815124f, 0.01154317f, 
    -0.01246347f, 0.00481675f, 0.01744115f, -0.02186690f, -0.00919600f, -0.03399834f, -0.01728643f, -0.05328828f, 
    0.00845036f, -0.01873386f, -0.03878352f, -0.02495411f, 0.00430968f, -0.01120772f, -0.05196662f, -0.06229695f, 
    0.01012368f, -0.00032076f, -0.02492345f, -0.03709348f, -0.01741498f, -0.04213032f, 0.01021947f, -0.01156462f, 
    0.00636272f, 0.01637136f, 0.04478158f, -0.01536055f, -0.00386890f, -0.04285030f, -0.04762089f, -0.00744111f, 
    -0.00715916f, 0.04576203f, -0.04997846f, -0.02861474f, -0.03798791f, -0.04079694f, 0.01107414f, 0.04656751f, 
    -0.01428785f, -0.02316423f, -0.02363029f, 0.05469761f, -0.01753701f, 0.02383292f, -0.00617747f, 0.01282805f, 
    0.02071183f, -0.00609067f, -0.01346511f, 0.00630406f, -0.03614262f, 0.04769797f, -0.05837055f, -0.04291605f, 
    0.02134236f, 0.03104694f, 0.03827675f, -0.04740294f, -0.02044408f, 0.00967408f, 0.03539323f, 0.04648673f, 
    -0.06092240f, -0.04935579f, -0.04694089f, -0.03468081f, -0.05415677f, -0.00967892f, -0.00319812f, -0.04492439f, 
    0.01613257f, -0.05483946f, -0.01104450f, -0.06210606f, -0.02997108f, 0.01202221f, -0.00264116f, -0.00757100f, 
    -0.05144767f, 0.02037933f, -0.02939646f, 0.00688382f, -0.00512502f, 0.03822906f, -0.03145621f, 0.03089374f, 
    0.01412078f, 0.03774209f, 0.02596551f, -0.04273443f, 0.04663136f, -0.03768003f, 0.04597627f, -0.04323952f, 
    -0.03212425f, 0.04613215f, 0.03248249f, 0.01087071f, -0.00654694f, 0.00486398f, 0.04569967f, 0.02478152f, 
    0.00058688f, -0.03852035f, -0.03662487f, 0.00746462f, 0.03738932f, -0.02096795f, -0.00387552f, 0.02961202f, 
    0.03204900f, -0.01230856f, 0.02743409f, -0.06054847f, -0.02846528f, 0.04673925f, 0.02900275f, 0.01850983f, 
    -0.40070853f, 0.08912376f, -0.32193074f, -0.23110820f, -0.10727374f, 0.12628554f, -0.14818577f, -0.05345470f, 
    -0.17517203f, -0.04116283f, -0.01516314f, -0.06174000f, 0.12932256f, 0.04736513f, 0.00274562f, -0.07038666f, 
    0.03081888f, 0.00701222f, 0.02795626f, -0.16084862f, -0.86188102f, -0.06936184f, -0.24774353f, -0.04299429f, 
    0.08268792f, 0.00913699f, 0.11000820f, -0.01996681f, 0.08546514f, -0.23643073f, -0.00833523f, 0.04203644f, 
    0.02522847f, 0.11987156f, -0.07031246f, -0.01030634f, 0.08282493f, 0.07261869f, 0.00453820f, -0.05893944f, 
    -0.29467541f, 0.22412780f, 0.27963239f, 0.05455020f, -0.16255681f, 0.01117873f, -0.02583672f, 0.05094181f, 
    -0.15776485f, 0.04622752f, 0.08302007f, -0.05369303f, -0.03432259f, 0.07706621f, 0.15617275f, -0.18411086f, 
    -0.11982712f, -0.11644106f, 0.07106455f, 0.00730433f, 0.19102354f, -0.24674591f, 0.05855886f, -0.13335402f, 
    -0.03855529f, 0.06197774f, -0.03393381f, -0.05326571f, 0.07426169f, 0.01055955f, 0.02167463f, 0.03298138f, 
    0.01522013f, 0.11671763f, 0.06037469f, -0.13177451f, 0.03455598f, 0.04110688f, 0.08780505f, 0.07265694f, 
    -0.11816967f, -0.25782049f, -0.16518690f, -0.16695662f, 0.16313732f, -0.10901999f, 0.05143778f, 0.12699644f, 
    -0.02619505f, -0.07075764f, -0.07054810f, -0.01906056f, 0.08758178f, 0.03643619f, 0.01389965f, 0.04751280f, 
    -0.10635222f, -0.15981849f, -0.00765032f, -0.07247686f, 0.12957157f, -0.15803726f, 0.09247178f, -0.03614385f, 
    0.09495066f, 0.09607855f, -0.12585817f, -0.08936311f, 0.01823826f, 0.02383430f, -0.00646845f, -0.02175194f, 
    0.09027521f, -0.05154920f, 0.06198211f, 0.03541714f, 0.09070772f, -0.05671426f, 0.07104586f, -0.11360651f, 
    -0.02874800f, -0.05665765f, -0.06876595f, 0.21286115f, 0.11586326f, -0.06455810f, -0.02359939f, 0.03398674f, 
    0.02554417f, 0.03012861f, 0.00682404f, -0.04162646f, 0.08010410f, -0.01116593f, 0.01605622f, 0.08478978f, 
    0.04601057f, 0.05750224f, 0.03743730f, 0.05074662f, 0.04090557f, 0.09637690f, 0.20622344f, 0.23274343f, 
    -0.02912852f, 0.09403469f, -0.15052775f, 0.09912513f, -0.05738155f, -0.05466381f, -0.05324357f, 0.05891821f, 
    -0.07342950f, -0.01434087f, 0.02358279f, 0.13734986f, 0.07596745f, 0.06535070f, 0.03100380f, 0.05343182f, 
    0.30766499f, 0.06824929f, 0.18930069f, 0.12517603f, 0.15495780f, 0.01311491f, -0.00435177f, -0.02622054f, 
    0.12422725f, -0.02836750f, 0.02437278f, -0.02325231f, 0.06326841f, 0.00925865f, 0.01822409f, 0.04772151f, 
    -0.04728543f, 0.01882505f, 0.10538876f, -0.12951258f, 0.05647289f, 0.03293512f, 0.18951078f, 0.15834591f, 
    -0.00759262f, 0.10042907f, -0.22602436f, -0.02331967f, -0.04297077f, 0.03501321f, -0.02044626f, -0.02824343f, 
    0.03899721f, -0.14503013f, -0.05991212f, 0.00479417f, 0.06352745f, -0.00421626f, -0.06711783f, 0.05710121f, 
    -0.26779550f, -0.18090773f, -0.13550645f, 0.03244574f, 0.01989897f, 0.00996589f, 0.03369041f, 0.05383654f, 
    -0.01239751f, 0.18475176f, -0.06659215f, -0.00882677f, 0.07458127f, 0.05372317f, 0.02247076f, 0.06060737f, 
    0.12088383f, 0.00008043f, -0.10769922f, 0.19163263f, -0.21618710f, 0.10755268f, 0.10291941f, 0.09376194f, 
    0.13428426f, -0.01259712f, -0.09929625f, 0.16845509f, 0.15041795f, 0.20674229f, -0.04436963f, 0.04955508f, 
    0.10230402f, -0.05551388f, -0.05387376f, 0.09786019f, -0.07322187f, -0.00627957f, 0.12072945f, -0.01945849f, 
    0.22984204f, 0.06464425f, 0.32526904f, 0.32862702f, -0.12556358f, 0.09217735f, -0.05976985f, -0.01202891f, 
    0.03428527f, -0.04900421f, 0.10590422f, 0.04451134f, -0.03894207f, 0.06234645f, 0.06705797f, 0.05643485f, 
    0.20184763f, -0.04412385f, 0.06949221f, 0.10723447f, -0.22220050f, -0.07214917f, 0.13176787f, -0.01897441f, 
    -0.05082135f, -0.09411842f, 0.07405801f, 0.11734321f, -0.03020893f, -0.19902118f, 0.05932900f, -0.08214831f, 
    -0.07092699f, 0.06965408f, 0.09219895f, 0.01297077f, -0.06914466f, -0.14267820f, -0.03011763f, -0.16236697f, 
    0.19242327f, 0.32739908f, -0.22827667f, 0.11218216f, 0.07051428f, 0.07198769f, 0.06915706f, 0.10696626f, 
    -0.05809917f, 0.08162476f, -0.10289943f, 0.07593667f, 0.03760665f, 0.14064845f, -0.02786529f, -0.05593713f, 
    -0.13018629f, -0.10188076f, -0.03496763f, -0.04942532f, 0.16915125f, -0.06297098f, 0.07082721f, -0.14040083f, 
    0.11142927f, 0.12530515f, -0.13098481f, 0.07648910f, 0.09536780f, -0.12208630f, 0.05728989f, 0.07477278f, 
    -0.01230463f, -0.05713999f, 0.11668716f, 0.09004547f, -0.01311025f, 0.01160955f, 0.05393460f, 0.05429686f, 
    0.25697738f, -0.40812704f, 0.03723951f, 0.31283143f, -0.05567605f, 0.06047770f, 0.14798991f, 0.02173341f, 
    -0.03263705f, 0.02909665f, -0.02326139f, 0.01721316f, 0.03251066f, -0.02724538f, 0.03136387f, 0.11046601f, 
    0.00657565f, 0.15894124f, -0.04143411f, 0.07225798f, -0.07971100f, -0.60580099f, 0.57029808f, 0.13231434f, 
    -0.10435621f, 0.20056528f, -0.05661215f, 0.06678601f, 0.05464394f, -0.08752513f, -0.06056197f, -0.00394675f, 
    -0.11449271f, 0.07733558f, 0.16484913f, 0.15842232f, -0.02819700f, 0.13730034f, 0.00243405f, -0.07678165f, 
    0.06118368f, -0.21200934f, 0.16367897f, 0.01863638f, -0.15360482f, -0.06172680f, 0.05884504f, 0.16982354f, 
    -0.07822712f, 0.06501308f, -0.12275261f, 0.10516921f, -0.04710314f, -0.02824665f, -0.04557962f, 0.08841913f, 
    0.25117743f, 0.13422264f, -0.10692169f, 0.14069448f, -0.00837516f, 0.19091800f, 0.02039623f, -0.14158346f, 
    0.17715715f, -0.15011534f, -0.07801469f, -0.03096557f, 0.09355933f, 0.13985163f, 0.02576530f, -0.02239727f, 
    -0.04151835f, -0.11684558f, -0.08414195f, 0.05801267f, 0.02502282f, 0.11517099f, 0.02491120f, 0.04296213f, 
    -0.07164036f, -0.02230798f, -0.13985272f, 0.21266569f, 0.04512257f, 0.03189239f, 0.03413124f, -0.04256213f, 
    -0.13242504f, -0.09612259f, 0.04174738f, 0.04506785f, 0.03754860f, 0.08042055f, 0.09303337f, 0.01895515f, 
    0.01390276f, 0.19950046f, -0.11349792f, -0.07009585f, -0.20880331f, -0.09579631f, -0.12367988f, 0.08263552f, 
    -0.08262161f, -0.06032977f, 0.04467317f, -0.03437412f, -0.01548309f, -0.01454920f, 0.03379696f, 0.04050232f, 
    -0.07477231f, 0.13120469f, -0.02866587f, 0.05430035f, -0.12414400f, -0.06067532f, 0.03260143f, -0.00290412f, 
    0.06933957f, 0.25102419f, 0.15770555f, -0.12935612f, 0.06502227f, 0.19801570f, 0.14004153f, 0.09322537f, 
    0.18083340f, 0.08526373f, 0.00977674f, 0.02550275f, 0.01955306f, -0.01078586f, 0.00255771f, 0.03431012f, 
    -0.04933432f, -0.14693382f, -0.05210467f, -0.09804709f, 0.08211741f, -0.13625361f, -0.09880099f, 0.01255910f, 
    -0.14327824f, -0.00623699f, 0.09403278f, -0.00246458f, -0.01385233f, 0.06256546f, -0.04092871f, -0.10422804f, 
    0.12087921f, 0.15431188f, 0.02184909f, -0.03932794f, 0.02317187f, 0.02274616f, -0.03708075f, -0.03706802f, 
    -0.04291759f, -0.05605203f, -0.31006545f, -0.25323027f, -0.18221582f, -0.00829381f, 0.15146637f, 0.17443223f, 
    -0.06491702f, 0.20853889f, -0.00331019f, 0.01392011f, 0.08578220f, -0.05996373f, -0.09638256f, -0.05231600f, 
    0.06238244f, 0.08920293f, 0.08990851f, 0.14013396f, 0.03726986f, 0.28905991f, -0.10661684f, 0.26010612f, 
    0.06282181f, 0.03740685f, 0.05142028f, 0.21295111f, 0.04284965f, 0.18006922f, -0.00481645f, -0.06793787f, 
    0.07385100f, 0.10137209f, -0.04085735f, -0.06751051f, 0.02821274f, 0.19695087f, -0.06865727f, 0.09037439f, 
    0.35548854f, 0.11613055f, -0.13548356f, 0.16526715f, 0.24375720f, 0.05957669f, 0.07009994f, 0.15355107f, 
    0.16827121f, 0.09507462f, -0.02008291f, 0.00544873f, -0.05212809f, -0.01703771f, -0.07557081f, -0.02994440f, 
    0.03212258f, -0.02596865f, -0.02384504f, -0.08724140f, 0.35391131f, 0.21463612f, 0.29634282f, 0.04425938f, 
    0.10798287f, 0.15099891f, 0.00759309f, 0.07564888f, 0.09381411f, 0.06670479f, -0.05905428f, -0.01357324f, 
    -0.09271754f, 0.04998033f, -0.06459402f, -0.04658170f, -0.03010539f, -0.05323436f, 0.02638740f, 0.11751533f, 
    0.10573071f, 0.31519890f, -0.54608017f, -0.13771886f, -0.23386762f, 0.14976136f, 0.04786102f, 0.13613886f, 
    -0.01837677f, -0.00702882f, -0.09106954f, 0.10764117f, -0.01282641f, 0.04373439f, 0.08273531f, -0.03329714f, 
    -0.22038877f, 0.18108863f, -0.05075506f, -0.15331405f, -0.14728706f, -0.21102807f, 0.00857243f, 0.06135470f, 
    -0.00251992f, 0.06955818f, -0.11565621f, -0.14790882f, -0.04396461f, -0.07214969f, -0.07206633f, 0.08946741f, 
    0.09335157f, 0.11912782f, 0.02062899f, 0.02141320f, 0.14249417f, 0.27061397f, -0.06215047f, 0.13455039f, 
    -0.11138661f, 0.37863028f, 0.38966823f, 0.01248484f, -0.10276134f, -0.03080993f, 0.12883480f, 0.24555600f, 
    0.07921801f, 0.03482081f, 0.09868851f, -0.05484793f, -0.11496271f, -0.04720234f, 0.10829011f, 0.08566362f, 
    -0.11516705f, 0.00081730f, 0.09548105f, 0.09268530f, -0.07832785f, -0.31289130f, -0.19211584f, 0.20976651f, 
    0.06715024f, 0.08365127f, -0.01060620f, -0.06081378f, -0.02736156f, -0.23583610f, -0.00316691f, 0.02529994f, 
    0.01082827f, 0.11308902f, 0.02399819f, -0.00312034f, 0.07904237f, 0.21935359f, -0.03948474f, -0.17353511f, 
    0.01890606f, -0.13854319f, 0.17185956f, -0.07371626f, -0.07714542f, -0.11359570f, 0.04887012f, 0.09600259f, 
    -0.03633710f, -0.01674282f, -0.14687292f, -0.16218032f, -0.11738524f, -0.01080180f, 0.04191487f, 0.06249666f, 
    -0.10967837f, -0.02404237f, -0.06255879f, 0.02819918f, 0.67433560f, 0.12226523f, -0.22984199f, -0.04212524f, 
    -0.29878157f, 0.10718807f, -0.11239516f, -0.18105754f, 0.11334164f, 0.02814866f, 0.04606487f, 0.16578910f, 
    -0.01010349f, 0.00564478f, 0.09161646f, 0.02452575f, -0.08443680f, 0.02270085f, 0.18431218f, 0.04630766f, 
    0.22485574f, -0.01646795f, -0.23429121f, -0.02123920f, 0.16311345f, -0.14897755f, -0.02132012f, -0.06215193f, 
    -0.06846388f, -0.05484496f, -0.07133208f, 0.04547659f, -0.09183130f, -0.14505038f, -0.16039348f, 0.01574862f, 
    0.11862651f, 0.16697478f, -0.04831428f, 0.07994439f, -0.18705992f, 0.34089705f, 0.21168409f, 0.13094302f, 
    0.13235119f, -0.02857406f, 0.05619224f, 0.14307839f, 0.03585370f, -0.02238251f, 0.11073249f, -0.06501607f, 
    0.10531098f, -0.02562551f, 0.05934171f, 0.16525106f, 0.01355104f, 0.01514823f, -0.05177829f, 0.01976590f, 
    -0.06905320f, -0.11668801f, 0.04410746f, -0.02594728f, -0.15697576f, 0.05126422f, -0.06360115f, -0.16059290f, 
    -0.05463536f, -0.05258303f, -0.04615128f, -0.00959996f, -0.18667898f, -0.08891594f, 0.07961231f, -0.09208592f, 
    -0.03943286f, -0.08206558f, -0.04000286f, 0.01626206f, 0.14851461f, 0.24299814f, 0.11954734f, -0.14354342f, 
    -0.12768446f, 0.00406868f, 0.15133418f, -0.02947786f, -0.06645864f, -0.00751803f, 0.07661130f, -0.06886549f, 
    -0.07381333f, 0.15273343f, 0.04171297f, 0.12584534f, -0.07036645f, -0.05939403f, 0.10045451f, -0.01406446f, 
    -0.34663585f, -0.14914645f, -0.17818950f, -0.02845490f, 0.06389818f, 0.04484911f, -0.18054749f, -0.03933271f, 
    0.11052593f, 0.04785547f, 0.04833645f, 0.10120287f, 0.00460686f, 0.11936656f, 0.09473054f, 0.04567876f, 
    0.09869686f, 0.11691701f, 0.10744842f, 0.14790997f, -0.07845576f, -0.03563738f, -0.05862718f, 0.02064990f, 
    0.25389123f, 0.07463882f, 0.05954132f, 0.10984133f, 0.09575920f, 0.19466658f, 0.10024171f, 0.02149342f, 
    0.08059435f, 0.06135596f, 0.03545953f, -0.03171192f, 0.03560507f, 0.10355369f, 0.03280144f, 0.07237273f, 
    -0.32277888f, -0.00771397f, -0.05085316f, -0.19499438f, 0.02269972f, -0.14627974f, 0.00998933f, -0.06707906f, 
    0.06048843f, 0.21416391f, 0.02788138f, 0.11912165f, -0.06174548f, 0.01912279f, -0.07263149f, -0.08803003f, 
    0.03129619f, -0.05133249f, -0.02441257f, 0.13863313f, -0.24645211f, -0.19326003f, 0.04195651f, -0.07746986f, 
    0.17684479f, -0.12627958f, 0.17620270f, 0.12446967f, 0.02079809f, 0.00119615f, 0.03574107f, 0.00733743f, 
    0.04856971f, 0.08936007f, 0.01359782f, 0.09435401f, -0.00519100f, 0.15665089f, 0.16556937f, 0.02524524f, 
    0.04752398f, -0.08063359f, 0.14614794f, 0.12367254f, 0.42240611f, 0.10573946f, 0.19424514f, 0.15838170f, 
    0.03114594f, -0.05952588f, 0.10446105f, -0.00358815f, 0.04542944f, 0.01185343f, 0.01376328f, 0.10388534f, 
    -0.05292634f, 0.07666162f, 0.11518724f, -0.06832606f, -0.01168985f, -0.25586408f, -0.12397624f, 0.02060823f, 
    -0.05471135f, -0.08824630f, 0.02891601f, -0.09039151f, 0.04083247f, -0.03911829f, 0.07982583f, -0.04678354f, 
    -0.03382699f, 0.07000245f, 0.07564653f, -0.02855396f, 0.12613359f, 0.10437163f, 0.15636486f, 0.17255659f, 
    -0.22655228f, 0.20463105f, -0.22245987f, -0.09131464f, 0.30759624f, -0.04032930f, 0.05808239f, -0.08603814f, 
    0.04270171f, 0.08319587f, -0.02985341f, 0.04798909f, 0.12795392f, 0.08041084f, -0.00423090f, -0.09322904f, 
    -0.10078092f, 0.02445955f, -0.04744559f, -0.11446648f, 0.08865538f, 0.08323272f, -0.13414614f, -0.03362055f, 
    -0.09973309f, -0.04982666f, -0.03311259f, -0.18005542f, -0.06847860f, -0.03633345f, 0.00730480f, 0.08890433f, 
    0.12058094f, 0.07942277f, -0.04571152f, -0.02529619f, 0.05418791f, 0.00950070f, 0.09744114f, -0.03189131f, 
    0.15494001f, -0.30390492f, 0.21939655f, -0.17213856f, 0.19429815f, 0.03095428f, 0.05086994f, -0.04174416f, 
    -0.00559741f, -0.06909220f, 0.11367207f, 0.06454489f, -0.10071597f, 0.00793336f, 0.17847097f, -0.03869474f, 
    0.12415633f, 0.00340322f, 0.12187786f, 0.00959845f, -0.30622756f, -0.01743641f, 0.14803827f, 0.01073634f, 
    -0.19948681f, -0.02592144f, 0.05876157f, -0.12126116f, -0.03077321f, -0.00851316f, -0.18181360f, -0.15577443f, 
    0.04821898f, 0.06456171f, 0.06650982f, -0.10313662f, 0.04829268f, -0.12768809f, 0.03169454f, -0.16902857f, 
    0.05018834f, 0.00727914f, 0.36483499f, -0.08834812f, 0.05941040f, -0.01211370f, -0.11136364f, -0.05466693f, 
    -0.04868169f, -0.09161852f, -0.03083935f, 0.13410226f, 0.03737232f, 0.22508471f, 0.10209394f, -0.00639338f, 
    0.15080525f, -0.02056483f, -0.04046082f, -0.08824831f, -0.61676866f, 0.25856078f, 0.18300334f, -0.03033576f, 
    0.23293744f, -0.08313430f, 0.28088114f, -0.01093298f, -0.03645219f, -0.02719587f, 0.05996349f, -0.04055402f, 
    -0.06273372f, 0.03570646f, -0.11172340f, 0.04058832f, 0.01598180f, 0.07570636f, -0.20576306f, -0.05258316f, 
    -0.27307174f, -0.12033094f, 0.13842885f, 0.10526474f, -0.12667783f, 0.02664852f, 0.11394886f, -0.00375907f, 
    0.00169143f, 0.03299730f, 0.12592241f, 0.03944222f, -0.02602246f, 0.17130616f, 0.12009872f, -0.13567488f, 
    -0.04644033f, -0.07449560f, -0.01163541f, 0.03804226f, 0.37781677f, 0.07481115f, -0.42543373f, 0.30877945f, 
    -0.16319497f, -0.06955007f, 0.00687025f, -0.02712657f, 0.13844150f, 0.03459911f, 0.00104356f, 0.08433288f, 
    -0.04034264f, 0.03289307f, 0.00062875f, 0.10687242f, 0.02471183f, 0.02941280f, 0.11408375f, 0.03320803f, 
    0.08467617f, 0.02544878f, -0.01871395f, 0.08725247f, 0.02109731f, -0.16319528f, 0.07567538f, 0.02284350f, 
    -0.02718368f, 0.00834800f, -0.07222536f, 0.08880527f, 0.01971084f, -0.02370824f, 0.03811003f, 0.03820479f, 
    0.00667638f, -0.11217308f, -0.09476251f, -0.06716211f, 0.11098763f, 0.07000280f, 0.15322877f, -0.04330841f, 
    0.29519588f, 0.08637046f, 0.13382527f, 0.03694354f, 0.02866094f, -0.04429635f, -0.05988669f, 0.06015860f, 
    0.00594712f, -0.00825647f, 0.13259546f, -0.04192263f, 0.14624235f, -0.00077475f, -0.02962361f, -0.09267551f, 
    0.28971499f, 0.20483656f, -0.06075345f, -0.01921514f, 0.14822742f, -0.05384203f, -0.03543906f, -0.00775994f, 
    -0.04328242f, -0.13853927f, -0.06154915f, -0.02817241f, 0.10645019f, -0.03669523f, 0.05604315f, -0.07567982f, 
    -0.06403460f, 0.11587116f, -0.16319095f, 0.17978989f, -0.04475791f, -0.11758258f, -0.17116913f, 0.07199959f, 
    0.00098937f, -0.01588190f, 0.05444740f, 0.06246975f, -0.07593717f, -0.18594018f, -0.07851234f, 0.06759595f, 
    0.06379999f, -0.08258390f, 0.02906553f, -0.04382280f, 0.03781981f, 0.05453336f, -0.12526178f, -0.04908517f, 
    -0.12529710f, -0.14151947f, -0.30194518f, 0.21728733f, 0.10973019f, 0.07825322f, -0.04375314f, 0.12809485f, 
    0.11739565f, -0.08122060f, -0.08966615f, -0.01100100f, -0.08054548f, -0.11056229f, -0.08509318f, -0.00689429f, 
    -0.08522110f, -0.03300349f, 0.01170061f, -0.03556383f, 0.14199372f, 0.11839671f, -0.07753036f, 0.12030850f, 
    0.02181475f, 0.01242931f, -0.02799848f, -0.00857120f, -0.09941766f, -0.03452801f, -0.00008865f, 0.03419199f, 
    -0.06127963f, -0.11760644f, -0.00032527f, -0.06926066f, -0.03608889f, -0.22868234f, -0.02905303f, -0.02658636f, 
    -0.01252834f, 0.01855792f, 0.03419423f, 0.17068663f, -0.41111717f, -0.12172540f, -0.21338430f, -0.14083900f, 
    -0.05230761f, 0.07393341f, -0.22579721f, 0.00125930f, -0.04573153f, 0.09358589f, 0.01126251f, 0.02033578f, 
    0.08370300f, 0.09329724f, 0.00828147f, 0.06324359f, -0.16787538f, 0.10490483f, -0.34639105f, -0.12325671f, 
    0.20694116f, 0.05004266f, -0.09364454f, -0.04800367f, 0.03809941f, 0.11255703f, -0.05819786f, -0.01219271f, 
    0.06174631f, 0.00344404f, 0.01699970f, -0.02180438f, -0.15763283f, 0.09175114f, -0.13020504f, 0.04900975f, 
    0.50792605f, 0.21334407f, 0.03428444f, 0.39415106f, -0.17028238f, 0.22182050f, 0.09923311f, 0.01435918f, 
    -0.00765111f, -0.01819247f, -0.06195052f, -0.21939106f, -0.11433560f, 0.02988723f, 0.03926814f, 0.21388930f, 
    0.01170170f, -0.02904281f, 0.01339864f, 0.15123776f, -0.02643512f, -0.19425839f, 0.20926182f, -0.01532576f, 
    0.01991314f, -0.10897047f, 0.06295934f, 0.03621807f, -0.01310678f, -0.02597659f, 0.08442652f, 0.07128385f, 
    0.01591514f, -0.01684662f, 0.01474109f, -0.01491773f, -0.06880997f, -0.14843324f, -0.06096541f, 0.03231343f, 
    -0.06267671f, 0.50069553f, 0.02799073f, -0.11885239f, 0.25371739f, 0.03756988f, 0.03579493f, 0.12005339f, 
    0.06162026f, 0.00668132f, -0.13449304f, -0.02741553f, 0.04523423f, 0.13069753f, -0.03777001f, -0.08784255f, 
    -0.10096895f, 0.12456688f, 0.02635162f, 0.07457709f, 0.07525137f, -0.21052535f, -0.02124915f, -0.06045439f, 
    0.06806999f, 0.02037098f, -0.01609374f, 0.08444262f, 0.05998273f, 0.00618244f, 0.06127045f, 0.03789989f, 
    0.04852865f, -0.02807927f, 0.02763746f, 0.02794879f, 0.01530949f, -0.17597038f, -0.13306274f, -0.04569524f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.01326657f, 0.10941742f, 0.17368615f, 0.06836484f, -0.06351472f, 0.05517587f, 0.10540000f, 0.07356702f, 
    0.05849762f, -0.01847524f, 0.00520624f, 0.11962557f, -0.03715837f, -0.01333929f, -0.05306310f, 0.02580461f, 
    -0.04728366f, -0.01909642f, -0.05523305f, 0.17747791f, -0.03002114f, 0.10648707f, 0.05838544f, -0.06391949f, 
    0.20758416f, 0.10169516f, 0.07642940f, -0.04851558f, 0.03723459f, 0.07602028f, -0.05873012f, 0.02060712f, 
    0.02086308f, 0.02586756f, 0.03957621f, 0.04080493f, 0.06129016f, -0.05120392f, 0.02520092f, -0.06668922f, 
    -0.08694880f, 0.02718951f, 0.08149331f, -0.13522862f, -0.00669571f, -0.06156517f, -0.05040136f, -0.05311233f, 
    0.10877956f, -0.01573106f, 0.04029630f, 0.02498188f, 0.14380960f, -0.04250085f, -0.05119692f, 0.20026748f, 
    -0.02542647f, -0.02785156f, 0.05216469f, 0.03838199f, -0.03745142f, 0.05741381f, 0.06760810f, -0.02851127f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.18382272f, 0.40036783f, 0.12097202f, 0.05124186f, 0.05860920f, 0.30020571f, -0.06416889f, 0.11841123f, 
    0.06371525f, -0.09191954f, 0.06409859f, 0.13892254f, -0.20821401f, -0.03687467f, 0.02695147f, -0.10888286f, 
    0.09200029f, 0.09582673f, 0.10880537f, 0.23394366f, -0.11132047f, 0.00658486f, 0.04081702f, -0.17420778f, 
    0.11785284f, 0.28436026f, 0.20468080f, 0.10233779f, -0.07967086f, 0.22436215f, 0.03968024f, -0.09586769f, 
    0.09132656f, -0.12057370f, 0.02166727f, 0.06157647f, 0.20056225f, -0.31033078f, 0.06351720f, -0.03379546f, 
    0.13659257f, 0.06067149f, -0.16569854f, -0.31041083f, -0.10064040f, 0.02247756f, -0.02991988f, -0.28204218f, 
    0.01703903f, 0.02074414f, 0.03694152f, -0.10793931f, -0.03097542f, -0.04448515f, 0.05881823f, 0.24058644f, 
    -0.22914687f, 0.06855615f, -0.12947799f, 0.03566994f, 0.06883812f, -0.15707991f, -0.02955859f, -0.13030447f, 
    0.15991014f, 0.23248352f, -0.11235461f, 0.23508522f, -0.11787626f, -0.04221538f, -0.13214584f, 0.04043596f, 
    0.08968223f, -0.00751527f, 0.03529491f, 0.12006049f, 0.15944573f, 0.00976169f, 0.02763232f, 0.04681016f, 
    0.02566335f, -0.10324699f, -0.10927305f, -0.03439378f, -0.00108852f, 0.08658764f, 0.18111135f, -0.15069279f, 
    0.24673465f, -0.02335786f, -0.15152119f, -0.16211189f, -0.07961363f, 0.27827874f, -0.01438494f, -0.04236840f, 
    0.00470139f, -0.07550707f, 0.44749898f, -0.02228213f, 0.24367586f, 0.12900211f, -0.08432985f, -0.07793206f, 
    -0.02984919f, -0.13396665f, 0.10090336f, 0.01887837f, -0.02754570f, 0.15102993f, -0.06104386f, 0.02883044f, 
    0.09002595f, -0.10853015f, 0.10781258f, -0.08394883f, 0.10318726f, 0.07097921f, -0.07107711f, 0.08303498f, 
    -0.17214610f, -0.11840931f, -0.11982155f, 0.12649712f, -0.18271022f, -0.14037097f, -0.15478051f, -0.00405254f, 
    -0.22705227f, 0.03222118f, 0.12747721f, -0.25575176f, -0.02816333f, -0.12694937f, -0.04414036f, -0.24643947f, 
    0.02827165f, 0.11618917f, 0.04519850f, -0.11537271f, 0.04444233f, -0.04672743f, 0.08875078f, 0.13985690f, 
    0.18894218f, -0.28795850f, 0.09862782f, -0.05606865f, -0.02986128f, 0.14031729f, 0.02699137f, 0.29405504f, 
    0.01063466f, 0.09572426f, 0.12216738f, 0.16398223f, 0.07035439f, -0.28721550f, -0.00316670f, 0.06459416f, 
    -0.08376255f, 0.05828705f, 0.00658346f, 0.07409792f, -0.36381990f, 0.36148438f, -0.00672331f, 0.09678178f, 
    -0.11170097f, 0.22313733f, -0.01949319f, 0.21518704f, -0.12817620f, 0.04047780f, 0.04603654f, 0.12050801f, 
    -0.01063373f, -0.02298601f, -0.03919717f, -0.10983019f, 0.12590817f, 0.02128159f, 0.04291535f, -0.07430270f, 
    0.12225883f, 0.10458871f, 0.16434790f, 0.03602991f, 0.04820704f, 0.09960043f, -0.04261723f, 0.28948158f, 
    0.19997174f, 0.03483121f, 0.35909432f, 0.03244406f, -0.01769644f, 0.17325570f, 0.06613481f, 0.32254070f, 
    -0.14132836f, 0.07345071f, -0.03539640f, 0.05061898f, 0.09538475f, 0.08038326f, -0.10219107f, -0.01620317f, 
    0.27889282f, 0.02364809f, -0.10666460f, 0.18230166f, 0.02499348f, 0.12565479f, -0.06986853f, -0.20870082f, 
    0.03071214f, 0.20749751f, 0.15063643f, -0.04881741f, 0.14726728f, -0.08383396f, 0.00071399f, 0.04894180f, 
    0.07547341f, -0.08298162f, -0.06324855f, -0.08728061f, 0.36724800f, 0.01301657f, 0.05806562f, -0.03321633f, 
    0.04679298f, 0.23726751f, -0.08480722f, -0.21631111f, -0.19132984f, -0.37069762f, 0.07273816f, -0.35174149f, 
    0.12029538f, 0.02431716f, 0.11544707f, -0.04586747f, 0.08894451f, -0.01835011f, -0.12310296f, 0.08455907f, 
    -0.24355944f, 0.00649266f, -0.15259558f, 0.07876243f, 0.11135986f, -0.18453600f, 0.27296945f, 0.03418055f, 
    0.04324754f, 0.25109580f, 0.08387404f, -0.07104018f, 0.09853461f, 0.30161855f, -0.05339677f, -0.02983141f, 
    -0.00179302f, 0.10541002f, -0.09373873f, 0.05816557f, -0.30451697f, 0.10009179f, -0.12404253f, -0.11701418f, 
    0.14108083f, -0.16580090f, 0.01740735f, 0.14612888f, 0.10915136f, 0.01656464f, -0.02783710f, -0.19742718f, 
    -0.05546775f, 0.33457100f, 0.11905191f, -0.05209422f, -0.04109969f, -0.06763031f, 0.11731005f, -0.08365580f, 
    0.02982581f, -0.02120562f, 0.03183924f, -0.03010992f, -0.03596523f, -0.11872583f, 0.07815935f, -0.10623744f, 
    -0.06968585f, 0.34028089f, -0.09142645f, 0.25753978f, -0.11035232f, 0.12026165f, 0.10477244f, -0.12603272f, 
    0.29778334f, -0.11695272f, 0.07426079f, -0.11238036f, 0.02092830f, -0.20022076f, 0.15604773f, 0.14976257f, 
    0.30595618f, 0.02563819f, 0.00539581f, -0.10036720f, 0.24309644f, -0.17752358f, -0.01575237f, 0.02328701f, 
    -0.07933837f, 0.27142382f, -0.10028197f, -0.04458953f, 0.02381155f, 0.17171112f, 0.18985730f, -0.11601957f, 
    0.15353234f, -0.06055425f, 0.01203310f, 0.14594910f, -0.26718441f, -0.05269942f, -0.01110832f, -0.06347249f, 
    -0.00371143f, 0.00735128f, -0.11711776f, 0.16807243f, 0.03735178f, -0.25523603f, 0.09047958f, -0.04783731f, 
    0.17604825f, -0.02418052f, -0.00291662f, -0.01890844f, -0.11592390f, -0.38174182f, 0.09871912f, 0.00081648f, 
    0.11408109f, -0.05152792f, -0.23200101f, 0.04955124f, -0.07141094f, -0.10714151f, 0.04436672f, 0.02832975f, 
    0.10160860f, 0.11648498f, -0.01648084f, 0.01629662f, -0.02943482f, 0.21184745f, 0.00603432f, -0.03500937f, 
    0.34355807f, 0.11674267f, -0.07287450f, -0.11960900f, -0.04531526f, -0.32149029f, 0.02736765f, 0.08535762f, 
    0.35697281f, -0.05232474f, 0.14166644f, -0.01365702f, 0.01270840f, -0.21099548f, 0.21776280f, -0.15218797f, 
    0.07782825f, -0.14182080f, -0.04254832f, -0.19950303f, 0.00162076f, -0.31083801f, 0.19486538f, 0.00654708f, 
    0.23973402f, 0.05251112f, -0.06045657f, 0.11226669f, -0.08856950f, -0.02590114f, -0.03081259f, -0.01481049f, 
    -0.00550668f, -0.00300110f, -0.00561538f, -0.09170666f, -0.01558699f, -0.32004264f, 0.12345181f, 0.17928381f, 
    0.17423223f, -0.11034902f, 0.28896540f, -0.01338918f, 0.01454543f, 0.14199743f, 0.10638574f, -0.08324442f, 
    0.09315003f, 0.01283943f, 0.17775355f, -0.09412894f, -0.15861782f, 0.00169124f, 0.04645481f, -0.00957191f, 
    0.11932936f, 0.03824795f, 0.11072384f, -0.32770589f, 0.39688060f, -0.13379557f, -0.08156542f, 0.03933758f, 
    0.08964999f, 0.08115651f, 0.05976865f, -0.10416807f, 0.10546180f, 0.10714264f, -0.12340448f, 0.12679291f, 
    -0.10123231f, -0.08143475f, 0.00787565f, 0.06583690f, -0.15459456f, -0.02786245f, 0.14024730f, 0.01448522f, 
    -0.18567762f, -0.01447754f, 0.08513811f, 0.21916902f, -0.07876117f, -0.13453813f, 0.13003610f, -0.14076324f, 
    0.19339706f, 0.11783705f, 0.07331562f, 0.14367813f, -0.05815955f, -0.11385615f, 0.06200108f, 0.08105168f, 
    -0.07376690f, -0.02376564f, -0.03157129f, -0.07456990f, 0.12185463f, -0.03122367f, 0.01423944f, -0.08002388f, 
    0.09866383f, -0.30511636f, 0.01298103f, -0.21814539f, -0.27060148f, -0.12594678f, 0.12653130f, -0.10871307f, 
    -0.05169049f, -0.07573481f, -0.09037663f, -0.11169838f, -0.18984760f, 0.07046692f, -0.02295632f, -0.09281387f, 
    0.14624268f, 0.06746323f, 0.07402521f, 0.39832771f, 0.25768179f, 0.04183984f, -0.02947843f, 0.18559137f, 
    0.06070272f, 0.08043995f, 0.01674811f, 0.12625091f, 0.04359358f, -0.08431555f, -0.14519103f, -0.27757207f, 
    0.20013958f, 0.01125718f, 0.38801587f, -0.02505656f, -0.11995735f, -0.02616562f, 0.14929684f, -0.11826647f, 
    -0.10288516f, -0.02830757f, -0.12684689f, -0.09046441f, -0.06503946f, -0.05968617f, -0.14630339f, -0.03966090f, 
    -0.07287858f, -0.00464843f, 0.03410850f, 0.02513585f, -0.02502284f, 0.00190784f, 0.05280271f, 0.10023997f, 
    -0.11638241f, 0.00068350f, 0.06278196f, 0.08172079f, -0.04667346f, -0.10004546f, -0.13279477f, -0.12321748f, 
    -0.00827059f, -0.12239607f, 0.06427418f, -0.03067538f, 0.05784544f, -0.11320622f, -0.11759105f, -0.10764571f, 
    -0.01059583f, -0.06259521f, 0.06156359f, 0.11133955f, -0.01426078f, 0.04753622f, 0.03498526f, 0.06199411f, 
    -0.11126371f, 0.07131512f, 0.01489660f, -0.03918697f, 0.01794070f, 0.01656666f, -0.04391997f, -0.12399445f, 
    -0.02921521f, 0.10147230f, 0.10060689f, 0.07691656f, -0.05013611f, 0.07369705f, 0.08675692f, 0.02028082f, 
    -0.09924792f, 0.05924533f, 0.06632297f, 0.08401446f, -0.08492690f, 0.04909325f, 0.05212041f, -0.11972346f, 
    -0.03040699f, 0.25970241f, 0.05026291f, -0.01357174f, 0.10556123f, -0.16911432f, 0.04780195f, -0.17243685f, 
    0.10622328f, 0.07912449f, -0.01478697f, 0.08455319f, -0.11334526f, -0.09145086f, -0.10987881f, 0.15496013f, 
    -0.11534345f, 0.07215163f, -0.03798148f, -0.13898075f, -0.06889494f, 0.17587228f, -0.18790607f, -0.23671468f, 
    0.02511606f, -0.22876072f, 0.09920584f, 0.04235746f, -0.15216748f, -0.02815456f, 0.07354905f, -0.00132249f, 
    0.05493468f, -0.01903602f, 0.10990028f, 0.03860914f, -0.01352030f, -0.13853443f, -0.00939055f, 0.08244716f, 
    0.13793921f, 0.08368286f, 0.06505106f, 0.03491624f, 0.16385035f, 0.03391099f, 0.10863030f, 0.10788922f, 
    0.11015956f, 0.06147972f, 0.06393141f, -0.07305048f, -0.00614962f, 0.19263901f, -0.12999479f, 0.08334651f, 
    0.02451147f, -0.09198897f, -0.03799608f, 0.04505433f, -0.01927648f, 0.00258247f, -0.00405105f, 0.26253203f, 
    -0.23713480f, -0.02588870f, 0.10291550f, -0.24719065f, -0.05973512f, 0.13285507f, 0.04736520f, 0.16191310f, 
    -0.03388710f, -0.01212165f, -0.06951384f, -0.11229700f, -0.05532458f, -0.07955750f, 0.07114979f, 0.25558090f, 
    0.25886890f, -0.22702177f, 0.06117904f, 0.18593368f, 0.10839248f, -0.32397377f, -0.08957724f, 0.13305479f, 
    0.13923411f, -0.10902598f, 0.26663089f, 0.04733688f, 0.06259304f, -0.29946443f, -0.06843016f, -0.06047305f, 
    0.01178575f, 0.01595389f, -0.21620956f, -0.10755675f, 0.00276397f, 0.10801412f, 0.01667327f, -0.10129803f, 
    -0.00201357f, 0.33441839f, -0.02688032f, -0.06761114f, 0.28904316f, -0.22032814f, -0.09217428f, -0.15052627f, 
    0.17332977f, -0.08088797f, 0.00316047f, 0.07008571f, 0.02328817f, -0.05810073f, -0.10118610f, -0.10616107f, 
    0.00683560f, 0.10426185f, -0.02132095f, 0.03314552f, -0.00620603f, 0.08393913f, -0.02307223f, -0.16442701f, 
    -0.05990463f, -0.22385305f, -0.14504494f, -0.01727144f, -0.08325984f, -0.10870413f, -0.04015941f, -0.16963950f, 
    0.05884821f, -0.03088497f, -0.01988208f, -0.06460240f, -0.05513486f, -0.00939290f, 0.09084591f, -0.09798461f, 
    0.09991096f, 0.04377901f, 0.04062756f, 0.00906892f, -0.01665904f, -0.03596439f, 0.16309367f, 0.21497391f, 
    -0.16419934f, 0.02538696f, -0.04340463f, 0.13509998f, 0.19379781f, -0.11248405f, -0.03469086f, -0.01206090f, 
    -0.08283242f, 0.07446574f, -0.37300372f, -0.04662533f, -0.38273332f, 0.28656459f, -0.09457360f, -0.08893132f, 
    0.07600211f, 0.10879731f, -0.13201444f, 0.02382906f, 0.03545537f, 0.04218069f, -0.11875392f, 0.22251050f, 
    -0.00049241f, -0.06924720f, 0.07614620f, 0.11321317f, -0.11139918f, 0.04107629f, 0.06066690f, -0.31918573f, 
    0.23850749f, 0.06643675f, -0.07258596f, 0.07305299f, 0.00816364f, 0.12854855f, 0.00114510f, 0.14276482f, 
    -0.03260165f, 0.15021318f, 0.00130139f, -0.12018266f, 0.07381485f, 0.11261193f, 0.18962705f, 0.25286892f, 
    0.32225531f, 0.10597480f, 0.00317573f, 0.03720331f, -0.21920404f, 0.06956452f, 0.04611456f, 0.10832411f, 
    -0.12399627f, 0.08492678f, 0.01436133f, 0.06359114f, -0.08990167f, -0.16971251f, 0.18383206f, -0.17231481f, 
    0.02141975f, -0.05358591f, 0.06083752f, -0.24455258f, 0.03554852f, -0.09385697f, 0.06149267f, -0.01837627f, 
    0.09372004f, 0.10936469f, 0.12541355f, 0.09700681f, 0.34006730f, -0.09149146f, 0.07089344f, 0.04151030f, 
    -0.00743993f, -0.07888640f, -0.07726151f, -0.17255113f, 0.10681590f, 0.11709797f, -0.00121431f, 0.26117817f, 
    -0.16764018f, -0.06729911f, 0.03675046f, -0.10102656f, 0.05703504f, -0.10225496f, -0.01483042f, -0.02052529f, 
    0.25330147f, 0.09830569f, -0.18756711f, -0.00423619f, 0.09409137f, -0.19083895f, -0.01164741f, 0.05966086f, 
    0.10793184f, 0.21502812f, 0.21929279f, -0.04631178f, 0.00175519f, 0.07754430f, -0.03585385f, -0.04482972f, 
    -0.21947764f, 0.11180307f, -0.02140655f, -0.17120139f, 0.13343915f, -0.05319184f, 0.01103913f, -0.00109589f, 
    -0.12295397f, -0.17108937f, -0.04715632f, 0.16675091f, 0.04029400f, -0.28954348f, 0.08843809f, -0.07835969f, 
    -0.18164046f, -0.00000445f, -0.15526308f, 0.26257497f, -0.16767372f, -0.03633721f, 0.04801757f, 0.02143315f, 
    -0.08265107f, -0.02813472f, 0.28527841f, -0.10143846f, 0.31368816f, 0.18586607f, 0.01598859f, 0.05349902f, 
    -0.46284711f, 0.08123516f, 0.01630136f, 0.35375625f, -0.39043936f, 0.06464548f, 0.05843250f, 0.15533119f, 
    0.28951478f, -0.07645874f, -0.11917231f, 0.11589137f, 0.07367682f, 0.05221062f, 0.16995512f, 0.16111340f, 
    0.35490561f, 0.10688966f, -0.08747716f, 0.02273506f, 0.26193127f, -0.15620263f, 0.02205618f, -0.19557405f, 
    -0.08423377f, -0.08079740f, 0.10387982f, 0.01280315f, 0.08738693f, -0.23545858f, -0.00262641f, -0.13396415f, 
    0.24836947f, -0.00077675f, -0.09856617f, 0.16598746f, 0.10206202f, -0.09086090f, 0.05523315f, 0.20790417f, 
    -0.05574908f, -0.27641216f, 0.10658385f, 0.13825600f, 0.02786954f, -0.13762838f, -0.06140509f, 0.12734908f, 
    0.11584505f, -0.19005221f, 0.09930459f, -0.14273576f, 0.00285210f, -0.16129325f, -0.12330353f, -0.03479356f, 
    0.11597036f, -0.00632851f, -0.40038854f, -0.05639767f, -0.24617082f, 0.11367657f, -0.08990443f, 0.07918064f, 
    -0.02176675f, 0.00289109f, 0.22795723f, 0.16130204f, 0.32917866f, -0.10900379f, 0.09485754f, 0.27694216f, 
    -0.00490507f, -0.12432408f, -0.00612844f, -0.02963236f, 0.27718085f, -0.07543392f, 0.13649762f, -0.10093780f, 
    -0.09320754f, 0.09059532f, 0.09100116f, 0.12299319f, -0.12138568f, 0.28499460f, 0.19019595f, -0.14627501f, 
    0.12845224f, -0.07225995f, -0.10969577f, 0.07320123f, 0.00463638f, -0.06555323f, 0.06078461f, -0.48330075f, 
    -0.08083855f, 0.04291147f, 0.09250846f, 0.18297984f, -0.08460802f, 0.12762980f, -0.00394140f, 0.16893341f, 
    -0.02921663f, 0.06562856f, -0.10795274f, 0.05905046f, -0.02750572f, -0.01485209f, 0.09491783f, 0.15602653f, 
    -0.10576517f, -0.21430364f, -0.13022202f, -0.08506603f, 0.13880724f, 0.08420263f, 0.03860832f, -0.00389465f, 
    0.08020187f, 0.08603881f, 0.36893669f, 0.11713388f, -0.05328365f, 0.15200785f, 0.07488909f, -0.05009615f, 
    -0.19863895f, -0.22739789f, 0.17263003f, -0.17260197f, 0.09674274f, -0.08522587f, -0.09022940f, 0.04175900f, 
    0.31583956f, 0.03358636f, 0.01405769f, 0.07771194f, 0.22199260f, -0.13658376f, -0.37861013f, 0.04493947f, 
    -0.00740086f, -0.10215810f, 0.00865298f, 0.07814755f, -0.34234995f, -0.03937428f, 0.29117608f, -0.09423652f, 
    0.26511416f, -0.08821546f, 0.06905643f, -0.01518327f, -0.02031984f, -0.12546749f, 0.20224185f, -0.06219662f, 
    0.12654640f, 0.06812935f, 0.09386677f, 0.06831873f, 0.06201245f, -0.07693242f, 0.11048358f, 0.06574710f, 
    -0.16652535f, -0.03721675f, -0.08950622f, -0.01036923f, -0.05209352f, -0.30091059f, -0.00146146f, -0.13840646f, 
    0.27501720f, -0.05102468f, -0.10317056f, 0.02011406f, 0.07297423f, -0.10896090f, -0.01424428f, -0.03319773f, 
    -0.00953517f, 0.00993388f, 0.15286322f, -0.07414476f, 0.26925093f, 0.08374689f, 0.07207078f, 0.13196580f, 
    -0.07491325f, -0.28097576f, -0.07046548f, 0.14419653f, 0.14688705f, 0.22265075f, -0.04225625f, 0.35798946f, 
    0.10562767f, -0.03756675f, -0.01226938f, 0.01449745f, -0.06243923f, -0.02324835f, 0.02356600f, -0.19148681f, 
    0.38855612f, 0.05777949f, 0.16372442f, 0.01102580f, 0.08754419f, -0.13111921f, 0.22856343f, -0.08205243f, 
    0.00304108f, -0.23218079f, -0.14249106f, 0.19173661f, -0.12979516f, 0.15167636f, -0.00058116f, 0.14204058f, 
    0.20957820f, 0.05528137f, 0.04598397f, -0.01882263f, 0.10413321f, 0.01600753f, 0.06578704f, 0.07642959f, 
    -0.07007915f, 0.18987563f, 0.11286165f, 0.17764068f, -0.12791947f, -0.04234153f, 0.24057570f, 0.14427596f, 
    -0.15256695f, -0.03970632f, -0.00502455f, -0.01220253f, -0.08031075f, 0.53642178f, 0.04643143f, 0.10126431f, 
    -0.04308362f, 0.02899015f, 0.19052203f, -0.01654079f, 0.09910577f, 0.00341362f, -0.04635584f, 0.04634945f, 
    -0.16043945f, 0.04252004f, -0.28456515f, 0.22416051f, 0.19450046f, 0.27635762f, -0.07454943f, 0.07264223f, 
    -0.18939780f, -0.05855757f, -0.02261864f, -0.09191021f, -0.10257639f, 0.11806086f, 0.30796960f, -0.31870982f, 
    0.09898313f, -0.04032670f, 0.11984991f, 0.00783887f, 0.00688879f, 0.21813437f, -0.16027723f, 0.00283256f, 
    0.09598298f, -0.12971203f, 0.04790813f, 0.04076035f, 0.07628425f, -0.16665728f, 0.28373811f, 0.11077778f, 
    0.00865353f, -0.12765080f, -0.12025315f, 0.02106538f, -0.25825360f, 0.04547099f, 0.06298218f, 0.22503020f, 
    -0.12234502f, -0.00890441f, -0.05432242f, 0.01596471f, 0.05093696f, -0.17796679f, 0.03044893f, 0.08379482f, 
    0.01694728f, -0.18483680f, 0.06155615f, 0.13207732f, 0.34308952f, 0.17138115f, 0.10500009f, 0.10338083f, 
    0.02828903f, -0.04498102f, -0.36092520f, -0.06870962f, -0.01518504f, 0.07849781f, 0.09908962f, -0.01472902f, 
    -0.02816264f, -0.15821695f, 0.24421677f, -0.19305103f, 0.32410908f, -0.19731565f, -0.07334308f, 0.11160445f, 
    -0.29801056f, 0.01813818f, 0.10986000f, 0.10579062f, 0.22377822f, 0.09059340f, 0.06751904f, 0.08547194f, 
    -0.16757959f, 0.01530195f, -0.34750766f, 0.08697557f, -0.18240446f, 0.12203874f, 0.10401645f, 0.14584076f, 
    -0.11608731f, -0.18249771f, 0.04668059f, 0.26349354f, 0.07408400f, -0.08287374f, -0.14050825f, 0.06878057f, 
    -0.21964426f, 0.07125844f, 0.04089850f, -0.03754300f, 0.20120615f, 0.00352055f, -0.08750974f, 0.11594851f, 
    0.14907397f, -0.06137215f, 0.04371035f, 0.03756730f, -0.01051933f, 0.14108089f, -0.14673051f, 0.10134865f, 
    0.04125927f, -0.15181375f, 0.07918759f, -0.10843191f, -0.07999218f, 0.11042359f, -0.07239389f, 0.06520274f, 
    0.11832397f, -0.04295968f, 0.12955046f, -0.08215272f, -0.11292933f, 0.17770492f, -0.05800855f, 0.06960583f, 
    0.08700272f, 0.21736893f, -0.04318747f, 0.25157177f, -0.09180731f, -0.17945571f, 0.05961119f, -0.17407937f, 
    -0.07043613f, 0.08981773f, 0.00266998f, -0.00678707f, 0.10140088f, 0.14281316f, 0.16959107f, -0.08892280f, 
    -0.31295773f, -0.09095623f, 0.17914568f, 0.11464969f, -0.06196037f, 0.11561959f, -0.08766725f, -0.19512711f, 
    0.23032820f, 0.09157200f, -0.00746370f, -0.20901340f, 0.08030725f, 0.07382905f, 0.07056661f, -0.09405506f, 
    -0.11901967f, -0.06716098f, 0.00520424f, 0.02602306f, 0.22718664f, 0.05393035f, 0.04968468f, -0.13212194f, 
    -0.11661103f, 0.12583897f, 0.01221092f, 0.11648879f, -0.08471838f, -0.09038151f, -0.22429632f, -0.04001661f, 
    0.16657349f, 0.29616982f, 0.00024239f, 0.13045019f, -0.01350370f, 0.11935281f, 0.09058715f, 0.08639634f, 
    0.08679540f, -0.00329929f, 0.07791283f, 0.04955852f, -0.10705968f, -0.08981313f, 0.00863983f, -0.09440361f, 
    0.05957160f, 0.12215256f, -0.02320535f, -0.22793441f, -0.42433479f, 0.18123133f, -0.07632623f, -0.06970660f, 
    0.13671263f, 0.06405197f, -0.08047398f, 0.04208706f, 0.09562955f, -0.05483997f, 0.00397636f, 0.03237371f, 
    0.14473905f, -0.07961679f, 0.11943283f, -0.02751923f, 0.24960725f, -0.11268239f, -0.14947888f, 0.10601745f, 
    0.31506798f, 0.01629849f, 0.34396037f, -0.01226781f, -0.07693456f, -0.05296214f, 0.19176100f, 0.27793017f, 
    -0.16847932f, 0.09214103f, 0.05673630f, 0.03891790f, 0.15714994f, 0.02983209f, 0.08757075f, 0.13231482f, 
    -0.26748937f, -0.15321231f, 0.00384927f, -0.00363628f, 0.10776130f, -0.12939012f, -0.12377232f, -0.13835140f, 
    0.16408494f, 0.06139304f, -0.15100729f, 0.10064772f, 0.04097290f, -0.05984775f, -0.10883815f, -0.06107580f, 
    0.02039352f, -0.10174819f, 0.18100782f, 0.11242963f, 0.45505840f, -0.05073642f, -0.08095253f, 0.06601349f, 
    -0.33188695f, -0.05350427f, -0.05294004f, -0.14934325f, -0.07508903f, -0.07293228f, -0.03054410f, -0.05255133f, 
    -0.18914436f, 0.08741785f, -0.12412725f, 0.02013693f, 0.02557854f, 0.10728379f, 0.04610818f, 0.19759761f, 
    -0.21456264f, -0.03722687f, -0.05266838f, -0.08436530f, 0.26950380f, 0.00979057f, -0.10258247f, -0.14782503f, 
    -0.02860922f, 0.23989713f, -0.09338087f, -0.02574898f, 0.10643608f, -0.08433627f, 0.02909029f, -0.31443226f, 
    0.21411519f, -0.04624980f, -0.06883818f, 0.16972063f, 0.02739336f, 0.04500644f, 0.05325012f, -0.14361584f, 
    -0.07740089f, -0.18462966f, 0.11363755f, 0.03755079f, 0.12617578f, 0.00891691f, -0.06083659f, 0.02513476f, 
    0.15543289f, 0.21396729f, 0.15491956f, -0.02639671f, 0.12593271f, -0.06359980f, -0.10936834f, 0.06078590f, 
    0.00226683f, 0.09293941f, 0.06121115f, 0.05928671f, 0.01312074f, 0.04987063f, -0.03895118f, -0.08994280f, 
    -0.07564901f, 0.03700763f, 0.10687090f, -0.22140123f, -0.15157762f, 0.07262710f, 0.01484114f, 0.21158835f, 
    0.12716514f, 0.07674325f, 0.06695002f, 0.00709954f, 0.18338992f, -0.21871394f, 0.04772227f, 0.21690275f, 
    0.27676752f, -0.04453459f, 0.17292680f, 0.06399188f, 0.04081844f, -0.04753676f, 0.17391181f, 0.32881171f, 
    -0.05196372f, 0.11594335f, -0.28212154f, 0.08882850f, 0.08482174f, 0.35982746f, 0.07117745f, 0.06603599f, 
    0.03775331f, 0.07743198f, 0.11048220f, -0.03432545f, -0.30663106f, -0.08266433f, -0.09462667f, 0.20889781f, 
    0.14251326f, -0.12916151f, 0.06524175f, 0.09956637f, -0.12297531f, -0.41764283f, 0.12988579f, 0.11590643f, 
    -0.01753283f, -0.14756970f, -0.06333935f, 0.10272479f, -0.11289841f, -0.13324195f, 0.07697338f, 0.00990059f, 
    0.00289176f, 0.08347854f, 0.06695534f, 0.09913344f, -0.09978947f, 0.15823396f, 0.04318154f, 0.02242223f, 
    -0.08537338f, 0.04064514f, -0.09888040f, 0.65524089f, 0.25139531f, 0.51619393f, 0.08580442f, 0.08295165f, 
    0.22769344f, -0.03793247f, 0.02843595f, -0.01717968f, 0.08776443f, -0.08350983f, 0.14899874f, -0.25477189f, 
    0.50975931f, 0.11321033f, 0.27928832f, 0.10883033f, 0.00888745f, 0.09966864f, 0.01796171f, -0.18729988f, 
    -0.04489925f, 0.02384768f, -0.11850225f, -0.00700622f, -0.07137525f, 0.06945772f, 0.04929687f, -0.09573922f, 
    -0.08904956f, -0.12103856f, 0.11224730f, 0.05213087f, 0.00551416f, -0.03603500f, 0.05939767f, -0.11767918f, 
    -0.11981187f, 0.05451946f, -0.00396188f, 0.03000226f, -0.08354118f, -0.10512351f, -0.00497078f, -0.14183500f, 
    0.04535362f, -0.01602308f, 0.08008796f, -0.14041449f, 0.03544984f, -0.13503458f, 0.03911653f, 0.02511264f, 
    0.04257498f, 0.00492007f, -0.09063330f, -0.02923042f, 0.02601071f, -0.03439069f, -0.02379663f, 0.00760601f, 
    -0.05924539f, 0.09066083f, -0.03830577f, 0.06506694f, -0.08361747f, 0.07945360f, 0.11537924f, -0.05932304f, 
    -0.04777665f, -0.04363569f, 0.08198036f, -0.06463650f, -0.08426263f, 0.07079494f, -0.07127862f, -0.01258325f, 
    -0.00134460f, -0.02992259f, -0.01276787f, 0.00504972f, -0.01004076f, -0.12615952f, -0.10365517f, -0.01356358f, 
    0.07223371f, 0.08898903f, 0.04996848f, 0.02512994f, 0.03216549f, 0.16420412f, -0.07281374f, 0.27062514f, 
    0.22092868f, -0.12252434f, 0.10302655f, 0.13529058f, -0.32602441f, -0.06556505f, -0.00103502f, -0.01634530f, 
    -0.12084195f, 0.03759684f, 0.09991467f, 0.10963337f, 0.01773193f, -0.09432059f, 0.18465488f, -0.18901691f, 
    0.06061660f, -0.02282883f, -0.23358603f, -0.18727428f, -0.04324828f, 0.04313305f, 0.12472847f, -0.09325529f, 
    -0.10769088f, 0.07847857f, -0.11897978f, 0.10625020f, 0.18801981f, 0.27909204f, 0.03627427f, -0.05741286f, 
    -0.37978312f, 0.08194111f, -0.05738984f, 0.35692376f, 0.13969465f, 0.28299251f, 0.04507143f, 0.16073319f, 
    -0.07407267f, 0.01387480f, 0.01165071f, -0.11250417f, 0.02841434f, 0.01541025f, 0.17154606f, -0.11310685f, 
    0.17505838f, -0.04103559f, -0.13391921f, 0.05990984f, -0.02101231f, 0.18309060f, -0.08521730f, -0.19755162f, 
    -0.04539571f, 0.02934934f, -0.08851808f, -0.37473252f, 0.05487966f, 0.22319274f, -0.05298874f, -0.00954122f, 
    -0.01616490f, 0.02046959f, -0.06413298f, -0.18747832f, -0.02784932f, 0.01690199f, 0.06823658f, 0.15615176f, 
    0.04624356f, 0.16018927f, -0.05483143f, 0.02649913f, 0.11315044f, -0.06665717f, 0.24323200f, 0.04830513f, 
    -0.19663741f, 0.24954778f, 0.13982901f, 0.20647100f, 0.10735689f, -0.21390350f, -0.10417932f, 0.00850922f, 
    0.05713437f, -0.07348403f, 0.38244194f, -0.02901340f, 0.12592080f, 0.29124945f, -0.07381047f, -0.10870916f, 
    0.01547321f, 0.23719615f, -0.21071769f, 0.01086037f, -0.21107610f, 0.30264843f, -0.07626569f, -0.03492913f, 
    -0.11190448f, 0.06084609f, -0.03451184f, 0.09525129f, -0.16271603f, 0.10013108f, 0.17039958f, -0.14803129f, 
    0.39734960f, -0.09997687f, -0.34787166f, 0.06686122f, 0.20899750f, -0.12306538f, -0.00411822f, 0.17331976f, 
    0.00987683f, -0.04630424f, -0.04303359f, -0.34172425f, 0.00655427f, 0.16396408f, 0.00551053f, 0.42569354f, 
    0.24740645f, -0.03947292f, 0.11809499f, -0.10392759f, 0.00835067f, -0.11610308f, 0.08508871f, -0.05021138f, 
    0.06829813f, 0.03774993f, 0.02090265f, 0.11097493f, -0.03330443f, -0.24587129f, 0.24534883f, 0.19658816f, 
    0.03243022f, 0.24818605f, 0.39834416f, 0.03010621f, 0.27457383f, 0.05488431f, 0.10252623f, -0.03013908f, 
    0.07514077f, -0.05139243f, 0.00945588f, -0.06384300f, -0.01376230f, 0.16404092f, -0.03028779f, -0.01159049f, 
    -0.00006729f, 0.16307449f, -0.09969594f, 0.00386335f, 0.04025572f, 0.29526091f, 0.07934487f, 0.14418255f, 
    -0.27228367f, -0.02076155f, -0.03916151f, 0.02872772f, -0.20662892f, 0.21286994f, 0.19058956f, 0.04245546f, 
    0.10433882f, 0.07936296f, -0.24030131f, -0.04435813f, 0.04240652f, 0.30021524f, -0.03454405f, 0.21535288f, 
    0.32040685f, 0.38544744f, 0.10106186f, -0.12095430f, 0.11182528f, -0.00018846f, -0.05895438f, 0.19130099f, 
    -0.07349016f, 0.08991289f, -0.00180209f, 0.17786591f, -0.09154290f, 0.08326714f, 0.02987292f, -0.00516040f, 
    0.17150250f, 0.02150906f, 0.03816442f, 0.03914825f, -0.04073504f, -0.07928116f, 0.02673138f, -0.08710369f, 
    0.18817800f, 0.22058438f, -0.12375042f, 0.15882413f, 0.12800857f, 0.02025752f, 0.00727746f, -0.05107266f, 
    -0.01713325f, -0.05154540f, 0.55590683f, -0.08455068f, 0.33590740f, -0.16761518f, -0.09496181f, 0.07276239f, 
    0.13355447f, -0.06555595f, 0.06875556f, -0.25188100f, -0.12736382f, -0.17271350f, -0.03156384f, -0.01225307f, 
    0.09319028f, 0.10723744f, 0.10402301f, -0.07466566f, 0.08829420f, -0.05520362f, 0.08975314f, 0.32284138f, 
    -0.18285926f, -0.00443037f, -0.32167315f, -0.05461374f, -0.07954942f, -0.22812416f, -0.13311183f, -0.01812190f, 
    0.06420198f, 0.10648068f, 0.04858311f, -0.21786648f, -0.01806697f, 0.03410952f, 0.07951007f, -0.04156430f, 
    0.15015887f, -0.10528494f, -0.10921489f, -0.00080416f, -0.11389993f, -0.09179054f, 0.08479463f, 0.14407508f, 
    -0.03896398f, -0.22185698f, -0.10742390f, 0.11064278f, 0.00781292f, -0.23584180f, 0.06513748f, 0.08154480f, 
    0.23536403f, -0.05725301f, -0.16208899f, -0.02225038f, 0.17777634f, -0.23646629f, 0.04910075f, -0.03292698f, 
    0.09106418f, 0.03437003f, -0.22216570f, 0.05097513f, 0.32135761f, 0.30539468f, -0.11473787f, -0.04370314f, 
    -0.16764398f, -0.15652236f, 0.13354248f, 0.23219636f, 0.11158567f, 0.03356360f, -0.01851483f, 0.29626691f, 
    0.19909124f, 0.07698504f, 0.11475425f, 0.00277966f, 0.17199551f, -0.03635965f, -0.04959616f, -0.05843902f, 
    0.24412033f, 0.00566451f, -0.05257659f, -0.03397323f, 0.03138822f, -0.02507925f, 0.29652894f, -0.26447847f, 
    -0.03971767f, 0.05581478f, -0.01424301f, 0.00774566f, 0.04527799f, 0.04609415f, -0.02622599f, -0.05274775f, 
    -0.13448781f, 0.03044357f, 0.12495166f, 0.03528902f, -0.09372496f, -0.00578480f, -0.02440270f, -0.08585415f, 
    -0.11049891f, -0.06432898f, -0.02139431f, -0.12339181f, 0.05883908f, 0.04037687f, -0.03665744f, -0.00189279f, 
    -0.00095854f, 0.03702711f, 0.05225669f, 0.04646120f, -0.00805516f, 0.03193018f, -0.02423675f, 0.04838089f, 
    0.03789591f, 0.08753345f, -0.09183760f, 0.06475612f, -0.14602493f, -0.13361262f, -0.09381445f, 0.05172424f, 
    -0.08696567f, -0.05848145f, 0.00010552f, -0.12053108f, -0.14314985f, -0.11180757f, -0.10774123f, 0.04083258f, 
    0.01869602f, -0.09368289f, 0.00551647f, -0.01874000f, 0.02332873f, -0.12832160f, 0.00017393f, -0.18298346f, 
    -0.00700122f, 0.02363277f, -0.16580701f, -0.09848563f, -0.05937695f, -0.12229107f, -0.03344479f, -0.11375400f, 
    0.01539333f, -0.00823017f, 0.04947788f, 0.06817291f, -0.02161074f, -0.04805792f, 0.06871542f, -0.15254226f, 
    0.17528293f, -0.07147354f, -0.01889843f, -0.01756478f, -0.08691113f, 0.09621634f, 0.09053785f, -0.03390854f, 
    -0.14588472f, -0.10639684f, -0.12723206f, 0.08820828f, 0.10868104f, 0.06592056f, -0.12059927f, 0.06207113f, 
    0.09246988f, -0.13078173f, -0.04280940f, 0.04858080f, 0.19235051f, 0.10660033f, -0.13278310f, 0.10357577f, 
    0.11325165f, 0.11170155f, -0.56598794f, 0.04512520f, -0.09527777f, -0.05523352f, -0.01893726f, -0.02390298f, 
    -0.16842565f, -0.07016874f, 0.06847619f, 0.05778920f, 0.22545862f, 0.16196752f, -0.03660126f, 0.05451141f, 
    -0.27633771f, 0.04263635f, 0.01328862f, 0.08472499f, 0.06023125f, 0.12610310f, 0.16818605f, 0.05869850f, 
    -0.02370569f, 0.05789401f, -0.00378376f, 0.00280798f, 0.00514930f, 0.26665056f, -0.01200440f, 0.05520230f, 
    -0.22217658f, 0.20151998f, 0.05123291f, 0.00721550f, -0.11980543f, -0.03998764f, 0.04439399f, -0.18909994f, 
    0.05304723f, -0.07592353f, -0.03910168f, -0.15306664f, -0.24998681f, 0.04407443f, 0.06266048f, -0.06740642f, 
    -0.19578701f, 0.05440043f, -0.07310169f, -0.00102165f, -0.11677122f, 0.13175130f, 0.03258706f, -0.10338657f, 
    -0.07062852f, 0.15293120f, 0.35764429f, -0.18366031f, -0.18487966f, 0.21291955f, 0.04199110f, 0.05779433f, 
    0.04613376f, -0.06124306f, -0.23704012f, -0.02247278f, 0.13070585f, -0.04298495f, 0.11911708f, -0.07745469f, 
    0.05957257f, -0.05401461f, -0.01708051f, -0.09431046f, -0.01920637f, -0.19363597f, -0.00086607f, 0.11961535f, 
    0.14890717f, -0.03677542f, -0.12470575f, 0.02662336f, -0.02067102f, 0.01709279f, -0.13860649f, 0.37016860f, 
    -0.18362220f, 0.09251827f, 0.12838787f, -0.07481816f, 0.08610138f, 0.04933745f, -0.11255421f, 0.16487509f, 
    0.10425884f, -0.10213654f, 0.09458932f, -0.09297538f, -0.00890970f, 0.00475768f, 0.09884097f, -0.12595035f, 
    0.02041448f, 0.00017630f, -0.00976397f, 0.04665082f, 0.17156747f, 0.07232871f, 0.03222058f, 0.21758161f, 
    -0.01864282f, -0.10991050f, 0.00242856f, -0.17088370f, -0.01738674f, 0.03020224f, -0.11170566f, 0.08905506f, 
    0.18027407f, -0.14218281f, -0.05392461f, -0.01334502f, 0.27312303f, -0.26064345f, -0.02237908f, 0.00736009f, 
    -0.02170430f, 0.01228466f, 0.19717659f, 0.03419032f, 0.17599744f, 0.33384395f, 0.03206607f, -0.00708769f, 
    0.02276110f, -0.05413015f, 0.14974959f, -0.03115308f, 0.10541252f, 0.03386051f, -0.05836667f, 0.39994055f, 
    -0.18477039f, -0.04407665f, 0.03141999f, -0.08748316f, 0.05937391f, 0.16228634f, -0.09418213f, -0.04933029f, 
    0.38876057f, 0.03064174f, -0.09043378f, -0.02198202f, 0.02088129f, -0.05835420f, 0.13085751f, 0.35347566f, 
    0.00268445f, 0.06036776f, -0.12362027f, -0.01169639f, -0.00256853f, -0.12753679f, 0.07838228f, -0.02093505f, 
    -0.08874315f, 0.02703086f, 0.07897444f, -0.07369100f, -0.01538480f, 0.10785604f, -0.03913972f, -0.10045234f, 
    -0.05253403f, 0.00505765f, 0.08615170f, -0.10414389f, 0.08492208f, 0.07320127f, -0.04033303f, -0.03844948f, 
    0.05921952f, -0.04587257f, -0.01702213f, -0.15108426f, -0.10966916f, -0.10041925f, -0.10198221f, -0.03771803f, 
    -0.07270359f, -0.03810358f, 0.05842085f, -0.12729938f, 0.09307626f, 0.00057075f, 0.03877676f, -0.02871898f, 
    -0.12564789f, 0.07003900f, 0.02980535f, 0.01195566f, 0.05578168f, -0.11274278f, 0.00377267f, -0.10724285f, 
    -0.07718062f, -0.05851632f, 0.02536465f, 0.10692728f, -0.02327623f, -0.10470038f, -0.12761103f, 0.06023001f, 
    -0.00853507f, 0.03404838f, -0.10690647f, -0.00910297f, -0.02951567f, -0.08587191f, 0.06126329f, -0.05665721f, 
    0.07151119f, -0.19684665f, 0.10850056f, 0.02636722f, 0.01213979f, 0.11384118f, 0.02882835f, 0.18670419f, 
    0.15934099f, 0.10858863f, -0.04722245f, -0.11773026f, 0.16493919f, 0.09515241f, 0.00532332f, -0.09624414f, 
    -0.13179599f, 0.02578659f, 0.06839004f, 0.21244957f, -0.13163644f, -0.01945864f, -0.06513415f, 0.11185622f, 
    -0.06342435f, 0.34118670f, 0.14454655f, -0.11253663f, 0.19252071f, 0.15510066f, -0.11358151f, -0.02541648f, 
    -0.05377847f, 0.03179036f, -0.31804049f, 0.04775404f, 0.01789894f, -0.01856023f, -0.04851286f, 0.01340150f, 
    -0.33503026f, -0.00831000f, -0.10753548f, 0.04931269f, -0.21723209f, 0.15550442f, 0.05306615f, 0.15689217f, 
    -0.27989775f, 0.04222169f, 0.02922066f, -0.09185535f, -0.09716955f, 0.14589138f, 0.34474298f, -0.09936290f, 
    0.13144651f, -0.01461336f, 0.07349612f, 0.07792967f, 0.40782708f, 0.32183444f, -0.00890564f, 0.27548742f, 
    -0.11723705f, -0.00182256f, 0.27544600f, 0.03759720f, 0.11445680f, -0.09966232f, 0.09750312f, 0.03611553f, 
    0.11172943f, 0.06440833f, -0.04625650f, 0.10543430f, -0.02182768f, -0.06666648f, -0.06692307f, 0.04506821f, 
    -0.12087711f, -0.24221224f, 0.09401884f, 0.12692638f, 0.04265775f, 0.20016991f, -0.19392961f, -0.07622589f, 
    0.09529289f, 0.14338130f, 0.19908091f, 0.05712436f, -0.13587932f, 0.25215563f, 0.05410326f, 0.07901737f, 
    -0.05261858f, -0.08620998f, -0.35039037f, 0.00205489f, -0.08340383f, -0.28602657f, -0.02879657f, 0.09396482f, 
    -0.03090608f, 0.17019603f, -0.01421666f, -0.25892001f, -0.14009833f, -0.45809308f, 0.09679811f, -0.21360926f, 
    0.00424496f, 0.03138058f, 0.01791906f, -0.00541301f, 0.15803804f, 0.04940823f, 0.05511618f, 0.26820201f, 
    -0.53559589f, 0.03352107f, -0.00130617f, -0.09701106f, 0.01567329f, 0.19478025f, 0.17878880f, -0.10881723f, 
    -0.01116375f, -0.22758828f, 0.13084775f, -0.02791975f, 0.11621994f, 0.16313906f, 0.04017271f, 0.11391450f, 
    -0.17372404f, 0.12668642f, 0.11282183f, -0.09098360f, 0.11844428f, -0.06809308f, 0.08518132f, 0.07375856f, 
    0.07207333f, -0.06430010f, 0.05840518f, 0.17907113f, 0.11909631f, 0.02459328f, -0.02518891f, 0.12549226f, 
    -0.01791526f, 0.08132469f, 0.09756123f, 0.04169746f, 0.10157914f, 0.23492879f, -0.08453967f, 0.07122423f, 
    -0.08066362f, -0.03301287f, -0.10768666f, -0.05534731f, -0.42514244f, 0.07524274f, 0.00371622f, -0.07522938f, 
    -0.15809663f, 0.18158688f, -0.12361635f, 0.23907071f, -0.06786924f, -0.10624590f, -0.08374696f, -0.02167854f, 
    -0.17411377f, -0.07890892f, -0.04408143f, 0.12777631f, -0.05064223f, 0.24123865f, 0.12671864f, -0.24130760f, 
    -0.17409819f, 0.04264648f, -0.09133557f, 0.10747171f, 0.00972695f, 0.35911408f, -0.03079530f, 0.03101549f, 
    -0.07228699f, -0.05540464f, -0.21744525f, -0.01050123f, -0.12168376f, -0.09745419f, 0.08248994f, -0.08048559f, 
    0.04650806f, 0.01195318f, -0.08590731f, 0.02072517f, -0.18033740f, 0.07572290f, 0.10567416f, 0.12796983f, 
    0.00043749f, -0.06394471f, -0.05831334f, -0.15079686f, 0.03716880f, 0.11925033f, -0.06072717f, -0.10974649f, 
    0.05259990f, -0.04955324f, 0.06593246f, -0.10409749f, 0.07883493f, 0.01965553f, 0.05412852f, -0.02059990f, 
    0.11338618f, 0.09842010f, 0.12361835f, -0.11884886f, 0.07488385f, -0.10322417f, 0.07138468f, 0.12415542f, 
    -0.07158566f, -0.13240619f, -0.00865789f, 0.08690973f, 0.20540249f, 0.13055573f, 0.10898644f, 0.12385034f, 
    -0.08366214f, -0.10565005f, -0.03680697f, 0.10850981f, -0.00492787f, -0.03757190f, 0.00630011f, -0.05831586f, 
    -0.01843409f, 0.03069313f, 0.07274514f, -0.07939678f, -0.08629332f, -0.00403015f, -0.05473708f, 0.00331408f, 
    -0.17426422f, 0.05506780f, 0.00122504f, 0.11846208f, 0.10503417f, -0.09241232f, 0.14389056f, -0.45491600f, 
    0.07893480f, 0.00975733f, 0.08882446f, 0.07080467f, 0.00420806f, 0.06456369f, 0.06774360f, -0.15422384f, 
    -0.11078046f, 0.06034775f, -0.04202546f, 0.02044300f, -0.11641122f, 0.14022040f, 0.08575040f, -0.11141939f, 
    0.00410359f, -0.11041662f, -0.09436708f, -0.21338083f, -0.09832843f, 0.10076838f, -0.10941578f, -0.11759220f, 
    0.11221113f, -0.05229501f, 0.01918555f, 0.08653966f, 0.00702507f, -0.11528995f, 0.09797675f, 0.11005453f, 
    0.05560838f, -0.02142849f, 0.18623149f, -0.18642811f, -0.08343463f, -0.16245270f, -0.09727901f, 0.16179897f, 
    0.16365321f, -0.03878671f, 0.05319453f, -0.04816961f, 0.12825145f, -0.14657278f, -0.30788878f, 0.25005025f, 
    -0.07096386f, 0.06263474f, 0.25058997f, -0.02873105f, -0.24544877f, -0.31602675f, 0.14934465f, 0.01610311f, 
    0.05304264f, -0.13150416f, 0.16758819f, 0.02302978f, 0.10319740f, 0.09704322f, -0.04065415f, -0.03289846f, 
    -0.12277733f, 0.05369665f, -0.04627193f, -0.06185174f, 0.12031930f, 0.06225748f, 0.06397112f, -0.10602158f, 
    -0.09362222f, -0.10975297f, -0.03859821f, 0.05462556f, -0.04766709f, 0.04486350f, -0.08742014f, -0.00502263f, 
    0.14173955f, -0.11459669f, -0.09574915f, 0.07858446f, -0.07579342f, -0.02965324f, 0.08089053f, 0.11988691f, 
    0.06361651f, 0.00462555f, -0.15220955f, 0.01954195f, -0.09265223f, -0.14813371f, 0.03496854f, -0.12372611f, 
    -0.01753448f, 0.08153674f, 0.21620172f, 0.05557343f, -0.01854431f, -0.09723002f, -0.01226073f, 0.02327700f, 
    0.22241686f, 0.00266159f, -0.05925760f, -0.06911995f, 0.07936549f, -0.12595285f, 0.01044249f, -0.11977224f, 
    -0.08497482f, -0.06416585f, 0.24597524f, 0.01063711f, 0.05129053f, -0.03715845f, -0.06148891f, -0.04417492f, 
    -0.04215603f, 0.15384637f, 0.14242023f, -0.18607803f, -0.00341427f, 0.01699092f, 0.27777624f, 0.06321196f, 
    0.03973519f, 0.10007544f, -0.07427119f, 0.08666302f, 0.02511674f, -0.00402121f, -0.03812468f, 0.27981290f, 
    -0.03739101f, -0.31102222f, 0.12654759f, 0.11387150f, -0.02122693f, -0.20194627f, 0.09685938f, -0.05222035f, 
    0.11683543f, 0.04268839f, 0.04340130f, 0.18369342f, -0.07991233f, -0.18997510f, -0.05494197f, 0.09552477f, 
    -0.00986177f, -0.00992596f, -0.00456535f, -0.08941228f, 0.18671072f, -0.00419626f, 0.07698929f, -0.02461840f, 
    -0.19894114f, 0.13976417f, 0.13615417f, 0.04910090f, 0.13528533f, -0.16988604f, 0.01638811f, -0.17023711f, 
    0.15691295f, 0.05960478f, 0.11277854f, -0.07078561f, 0.11971564f, -0.14785050f, -0.08852957f, 0.10948669f, 
    -0.12744142f, 0.04104326f, -0.18482891f, -0.05199264f, -0.11121818f, 0.02097528f, 0.15432520f, -0.45270294f, 
    -0.02942362f, 0.21804829f, -0.07702706f, 0.08797921f, 0.10452991f, 0.28528786f, 0.01371884f, 0.14887355f, 
    -0.07682199f, -0.04008925f, -0.02172624f, 0.03538264f, -0.28236803f, 0.06798203f, 0.06372052f, 0.09355658f, 
    0.14694227f, -0.06774189f, 0.09132916f, 0.24361829f, -0.02455157f, -0.14413570f, 0.26777470f, 0.03804623f, 
    -0.13711393f, -0.00041757f, -0.22109894f, 0.06229959f, 0.01186867f, 0.17126575f, 0.02583416f, 0.04426404f, 
    -0.06412442f, 0.12257206f, 0.09459540f, 0.11213224f, 0.25767568f, 0.28204489f, -0.12329584f, -0.07985895f, 
    -0.05434667f, -0.00335706f, -0.06553160f, 0.30662873f, 0.14685385f, 0.12420871f, 0.10225704f, 0.01272351f, 
    -0.04761669f, -0.04035240f, -0.10600937f, 0.11229867f, 0.09449355f, -0.16000620f, 0.03834818f, 0.07779302f, 
    -0.09227544f, -0.08989762f, -0.21482727f, -0.09058562f, -0.29075390f, 0.17959373f, 0.21233585f, -0.34788612f, 
    0.30381733f, 0.00967952f, 0.28442484f, 0.06793858f, -0.08651723f, 0.00270428f, 0.17066343f, 0.24677573f, 
    -0.33227938f, 0.03116783f, -0.09740585f, -0.04600053f, 0.20445804f, 0.09988531f, -0.08943994f, -0.08001072f, 
    -0.15112758f, -0.15827547f, -0.11786114f, 0.20810847f, -0.10326345f, 0.00321219f, 0.05942974f, -0.00498823f, 
    0.14611742f, 0.15677488f, -0.08153587f, 0.22138330f, -0.16092613f, -0.01480448f, 0.04952284f, 0.08452347f, 
    0.06507766f, 0.09943160f, 0.11428200f, -0.00851006f, 0.49385545f, 0.06078092f, 0.09187615f, 0.01875214f, 
    -0.30829483f, -0.15797684f, 0.10689808f, -0.09342088f, -0.33944917f, -0.06823098f, -0.08583546f, -0.17195915f, 
    0.13159272f, 0.09853738f, -0.09916687f, 0.10373738f, -0.02162955f, -0.00350768f, -0.08289312f, 0.11798830f, 
    0.03644493f, -0.00461836f, -0.00293868f, 0.01355907f, 0.06742448f, -0.19148521f, 0.01099311f, -0.40450591f, 
    0.02117778f, -0.07134392f, 0.11223567f, -0.34431690f, -0.02447660f, -0.04987631f, 0.16478917f, -0.32191589f, 
    -0.13582854f, 0.03304794f, -0.07993956f, 0.02236300f, -0.07719057f, 0.00827124f, 0.09894154f, 0.09550938f, 
    -0.13854897f, -0.11045220f, 0.11216620f, 0.14232944f, 0.01053831f, -0.15461130f, 0.19217120f, 0.20788614f, 
    -0.14494933f, 0.11904324f, -0.13991423f, 0.32249400f, 0.35273924f, -0.17051478f, -0.09644679f, -0.00592627f, 
    0.10017630f, 0.05260253f, -0.10564778f, 0.09111471f, 0.21521290f, 0.35150740f, -0.10128871f, 0.05894997f, 
    -0.02099205f, 0.07677624f, 0.22233976f, -0.04223742f, -0.05305174f, -0.01952375f, 0.05950257f, 0.17539576f, 
    0.26518595f, -0.08688664f, 0.03661637f, 0.06463497f, 0.16956963f, -0.17140448f, -0.09792025f, 0.15758224f, 
    0.23487781f, -0.07292117f, -0.21887815f, 0.08129947f, 0.00269083f, -0.17965750f, 0.34877107f, 0.08766343f, 
    0.11113636f, -0.02658769f, 0.10788572f, 0.06286152f, 0.03196596f, -0.37606096f, 0.00331695f, 0.03224366f, 
    0.09997877f, 0.05701344f, -0.00829101f, 0.05265026f, -0.31315047f, -0.04021787f, -0.08510982f, 0.12501581f, 
    -0.20774791f, -0.07117225f, 0.01887049f, -0.18685918f, 0.06385718f, 0.13425732f, -0.11344711f, -0.21545219f, 
    0.08593015f, -0.35342917f, 0.02665896f, -0.14474182f, 0.09643818f, 0.14269097f, -0.12335050f, 0.05467232f, 
    -0.09330422f, 0.09018533f, -0.04162702f, 0.08813705f, -0.07363487f, 0.01947995f, 0.05355843f, 0.05455380f, 
    -0.04253116f, -0.10723615f, 0.05804433f, 0.10522130f, 0.35794139f, 0.15274349f, -0.05441680f, 0.12197702f, 
    -0.04782737f, 0.02412761f, -0.08943129f, -0.05041256f, 0.17028195f, 0.02707982f, 0.00424237f, 0.17721495f, 
    -0.14135949f, -0.01224877f, 0.09378068f, 0.08236158f, -0.10208962f, -0.08899061f, -0.04468376f, 0.17345802f, 
    -0.27956581f, 0.16521017f, 0.11495399f, -0.13719127f, -0.01487528f, -0.19566819f, -0.02160257f, 0.07080743f, 
    0.23976445f, -0.06818445f, -0.00246006f, 0.03084500f, 0.10826562f, -0.01160911f, 0.09956063f, 0.09060179f, 
    0.02368659f, 0.02314817f, -0.00794195f, -0.10849673f, 0.11629685f, 0.04328899f, 0.04151144f, -0.03590356f, 
    0.29462004f, 0.17516851f, 0.31655726f, -0.33993584f, -0.10765543f, -0.13623531f, -0.06383827f, 0.03579102f, 
    0.10832454f, 0.02465613f, 0.18744728f, 0.07234232f, -0.06502465f, -0.20194650f, 0.12516835f, -0.05231493f, 
    0.06783105f, 0.22605370f, 0.07270552f, -0.29342955f, -0.07623336f, -0.36127397f, 0.04120805f, 0.08203772f, 
    0.02157630f, 0.10297017f, 0.02332746f, 0.06135100f, 0.04019532f, 0.00752196f, -0.08980960f, 0.21600093f, 
    0.00423048f, 0.02653907f, 0.19396767f, -0.01160181f, -0.05396323f, -0.08655765f, 0.03414557f, 0.16515701f, 
    -0.11642566f, 0.03957719f, -0.03352041f, 0.03702593f, -0.12130238f, -0.06269778f, -0.03359037f, -0.05954828f, 
    0.04663369f, 0.10776706f, -0.06223816f, -0.05581060f, -0.11275188f, -0.08266285f, -0.00476238f, -0.01720128f, 
    0.03584470f, -0.14518593f, -0.00465022f, -0.08250995f, 0.00455374f, -0.08294314f, 0.06362874f, -0.04655235f, 
    0.03519787f, -0.07743690f, -0.11802939f, 0.03376073f, 0.08345404f, -0.10526793f, 0.02979152f, 0.03414389f, 
    -0.00779554f, 0.01008172f, -0.07654684f, 0.00163274f, -0.12524872f, 0.09624465f, 0.01723914f, 0.02002575f, 
    -0.04892816f, -0.00784631f, -0.11293872f, 0.11667444f, -0.06214162f, -0.04526301f, 0.09329267f, -0.13010353f, 
    -0.01370440f, -0.02895404f, -0.04836909f, 0.04144861f, -0.07213275f, -0.07412310f, 0.04433259f, -0.12923832f, 
    -0.10793002f, -0.04012875f, -0.09848623f, -0.05672485f, -0.12342238f, 0.08957770f, -0.06761596f, 0.05165980f, 
    -0.27726361f, -0.03190095f, -0.02188097f, -0.09307045f, 0.03833720f, -0.11115253f, 0.17437918f, 0.03743962f, 
    0.17832330f, -0.05388195f, -0.05100052f, 0.08259814f, -0.26317179f, 0.04837074f, -0.11272943f, 0.11355074f, 
    0.07963120f, -0.08131928f, -0.02657412f, -0.17224970f, 0.11887056f, 0.06157860f, 0.01434032f, 0.16008808f, 
    -0.01166199f, -0.00280949f, 0.25585449f, -0.24915504f, 0.10779232f, 0.17654218f, -0.03605044f, 0.00923331f, 
    -0.10909244f, -0.01318077f, 0.14690457f, 0.05215764f, -0.25717357f, -0.10402306f, 0.10152385f, -0.02407478f, 
    -0.03786404f, 0.19636479f, 0.03471098f, -0.26457420f, 0.27993149f, -0.21625534f, 0.04097653f, 0.17638363f, 
    0.10010725f, -0.08331479f, 0.04340547f, 0.09905235f, -0.15881214f, -0.03682234f, -0.06497511f, 0.13899212f, 
    -0.09819017f, 0.00781977f, 0.22971882f, -0.04754012f, -0.08239602f, 0.16168515f, 0.09904712f, 0.24688338f, 
    -0.14491917f, -0.45062777f, 0.11568864f, -0.30244151f, 0.05104371f, -0.12679482f, -0.00442040f, -0.16489810f, 
    -0.08188701f, 0.04863450f, -0.03052880f, -0.07694292f, 0.21948847f, 0.06470892f, -0.10950002f, -0.00355878f, 
    0.07467716f, -0.11640038f, -0.11854140f, 0.10130303f, 0.10675804f, -0.14064749f, 0.06349938f, 0.27944043f, 
    0.04755750f, 0.26634488f, 0.32281658f, 0.01302457f, 0.14038086f, -0.10285690f, -0.01246207f, 0.12572323f, 
    -0.00591592f, -0.01212783f, -0.11910851f, -0.07199884f, -0.38727933f, -0.04687634f, 0.06325072f, -0.06527065f, 
    -0.01007735f, 0.17247857f, 0.14362784f, -0.03704982f, -0.38052681f, 0.04493149f, -0.05895935f, 0.15580931f, 
    -0.16968228f, -0.11030620f, 0.03137612f, 0.11511762f, -0.18783580f, 0.16298193f, 0.27615660f, -0.11669227f, 
    -0.03228927f, -0.07606170f, 0.03510468f, 0.01466670f, 0.38435987f, 0.12640169f, -0.19468138f, 0.34137630f, 
    -0.12204827f, -0.34053212f, -0.02973591f, -0.09985889f, -0.08918279f, -0.05598583f, -0.00103436f, 0.30941245f, 
    -0.03644886f, 0.04122228f, 0.02596918f, 0.04833365f, 0.08613548f, 0.03183403f, 0.05311546f, -0.06262200f, 
    0.25940368f, 0.15361233f, 0.03998717f, 0.02740142f, -0.00232041f, -0.14749706f, 0.10702498f, 0.08507424f, 
    0.01263012f, 0.20793658f, 0.27646577f, -0.07337093f, 0.03858840f, -0.12437981f, -0.00476527f, -0.11248977f, 
    0.02724636f, -0.03776213f, 0.13969631f, 0.00183146f, -0.08589762f, -0.04855312f, -0.08008733f, 0.07892010f, 
    0.11946731f, 0.19617759f, -0.08815042f, -0.22554322f, -0.15506108f, -0.22131759f, -0.05748207f, -0.17681271f, 
    -0.32277429f, -0.08890576f, -0.03760369f, 0.06229252f, -0.41099358f, 0.04373379f, 0.15846641f, -0.06153792f, 
    -0.14847717f, -0.01369549f, -0.24170321f, 0.10930803f, 0.00286081f, 0.18856049f, -0.06524977f, -0.05319000f, 
    -0.15251309f, 0.12852363f, -0.02384011f, -0.18830378f, -0.04482973f, 0.00876651f, 0.09814741f, -0.12940055f, 
    -0.20638090f, 0.10304082f, -0.07047328f, -0.04459791f, -0.07263885f, -0.04986084f, 0.10659000f, 0.19706717f, 
    0.13179240f, -0.27352917f, 0.07320615f, 0.05684912f, 0.10533024f, -0.31619093f, 0.12538208f, 0.14064404f, 
    0.03827108f, -0.23836537f, -0.17336510f, 0.17049098f, -0.05870870f, -0.06714313f, -0.00407163f, 0.12618446f, 
    -0.07259078f, 0.01185470f, 0.37035853f, 0.06245929f, -0.07708032f, 0.21704894f, -0.06757870f, 0.03959624f, 
    -0.13235731f, 0.13212849f, 0.14327551f, 0.19390289f, 0.29563102f, 0.02350104f, 0.11574038f, 0.03713522f, 
    0.27695951f, 0.11444182f, 0.06068343f, -0.09023537f, 0.00702643f, 0.11649456f, 0.10043932f, -0.00511890f, 
    -0.03595694f, -0.08314577f, -0.06274813f, 0.00520785f, -0.18210606f, 0.15212630f, 0.18803264f, -0.33349276f, 
    -0.22545686f, 0.06750620f, -0.11034171f, 0.28827995f, 0.13516770f, 0.05147455f, -0.09205373f, 0.40990978f, 
    0.09323078f, -0.04786707f, 0.09522881f, 0.10449580f, 0.01733682f, 0.07145239f, 0.01092182f, -0.06787364f, 
    0.19568262f, -0.10908622f, -0.04569829f, 0.01829955f, -0.09073429f, 0.19004650f, 0.20189804f, 0.03886665f, 
    -0.08200570f, -0.05901679f, 0.04953264f, -0.23279859f, -0.05481214f, 0.32657596f, 0.09359822f, 0.12533444f, 
    0.00343429f, -0.01434287f, 0.30903748f, -0.02505836f, 0.10405253f, 0.11854748f, -0.06023858f, 0.05726770f, 
    -0.00899616f, 0.11052573f, -0.22301692f, 0.10942214f, 0.12225656f, 0.07485209f, -0.05513513f, 0.02677820f, 
    -0.11015610f, -0.03926706f, -0.08880489f, -0.01290671f, -0.01054190f, 0.15637909f, 0.06418505f, 0.05139310f, 
    -0.14328508f, 0.00572283f, -0.06065858f, 0.04927874f, 0.09634971f, 0.15083282f, -0.08354241f, 0.11646339f, 
    -0.24780940f, -0.04365721f, 0.27394652f, 0.10124260f, 0.11641985f, -0.19683024f, 0.14917201f, 0.23712747f, 
    0.10974120f, -0.05094633f, 0.05624816f, 0.00396588f, -0.00216848f, -0.10768358f, -0.01472883f, 0.02887361f, 
    0.09885224f, -0.15163517f, 0.02319972f, 0.08069122f, 0.06458035f, 0.16943707f, -0.00043075f, -0.06638756f, 
    0.08206869f, 0.07441565f, 0.32157376f, -0.15113492f, -0.10443511f, -0.19033842f, -0.06261101f, -0.10323747f, 
    0.03620206f, -0.08344139f, -0.24138062f, 0.12562108f, -0.19592451f, -0.14528042f, 0.10981369f, 0.10037706f, 
    -0.04784752f, 0.26447496f, 0.03506765f, -0.06028416f, 0.20008412f, -0.28092033f, 0.01756850f, -0.10576684f, 
    0.04476941f, 0.11955233f, 0.03065574f, -0.07096919f, -0.07286651f, -0.11915570f, -0.08178496f, -0.02288534f, 
    -0.36204642f, 0.07549644f, 0.20406793f, 0.07367509f, -0.11378982f, 0.17578277f, 0.12414443f, -0.10435820f, 
    -0.08682045f, -0.07380124f, -0.05178138f, 0.13774028f, -0.05003073f, -0.07590409f, -0.05899288f, -0.14064677f, 
    -0.06751384f, -0.13027024f, 0.08426418f, 0.00616474f, -0.00664740f, -0.12613879f, 0.02185815f, -0.02334960f, 
    -0.01883121f, -0.14232442f, -0.10637492f, 0.08573262f, -0.06922648f, 0.20719084f, -0.06745306f, -0.24833179f, 
    -0.16724338f, -0.06684867f, 0.08510813f, 0.07435672f, -0.08811950f, -0.01557522f, 0.00693772f, 0.08774818f, 
    -0.12040848f, -0.10911313f, 0.03727822f, 0.08158488f, -0.02767551f, -0.01893527f, -0.08129288f, 0.06088907f, 
    -0.21198349f, 0.02003501f, 0.06336702f, -0.06191830f, -0.03294484f, -0.22661261f, 0.01607514f, -0.00993168f, 
    0.04402993f, -0.02191964f, -0.06539629f, 0.06181702f, 0.20271759f, -0.22209270f, -0.20968984f, 0.08665290f, 
    -0.05646727f, 0.09220418f, -0.11617224f, 0.02901153f, -0.05551658f, 0.06450409f, 0.12483185f, -0.05017987f, 
    0.07199243f, -0.10960551f, 0.25597462f, 0.03184789f, -0.08311605f, -0.03728846f, 0.21548304f, -0.04627327f, 
    -0.10325111f, 0.00107929f, -0.09429825f, -0.03107074f, 0.03446800f, -0.04029977f, 0.03271610f, 0.06889678f, 
    -0.23742017f, -0.06297965f, -0.00395010f, 0.03188680f, -0.04727072f, 0.09772120f, 0.12502937f, -0.06227415f, 
    -0.11401286f, 0.04208321f, -0.20418455f, 0.21506178f, 0.39826614f, 0.10586920f, -0.01713784f, 0.03223025f, 
    0.00710694f, 0.09737846f, -0.12877467f, -0.05503302f, 0.13298322f, 0.19354425f, 0.03480369f, 0.09928080f, 
    -0.20790042f, -0.23450412f, 0.03207673f, -0.11577258f, -0.14864649f, -0.14514448f, -0.03910846f, 0.23551701f, 
    -0.36503455f, -0.06515604f, 0.08441242f, -0.09391001f, 0.23594382f, -0.10638085f, 0.05037812f, 0.20531969f, 
    -0.03155388f, -0.10542305f, -0.42810050f, 0.08679161f, 0.11086582f, 0.10589317f, 0.19254120f, 0.14712736f, 
    0.10031821f, 0.15655524f, 0.09088862f, 0.13421993f, -0.11930566f, -0.15290576f, 0.04254867f, -0.08683265f, 
    0.27371785f, 0.07508805f, 0.04212748f, -0.00064772f, -0.31736213f, 0.01737841f, 0.05490316f, -0.07881144f, 
    -0.31150192f, 0.07258242f, 0.07234052f, -0.05362203f, -0.12816365f, 0.01114204f, -0.16495630f, -0.36984959f, 
    0.14042138f, -0.33164394f, 0.16049418f, -0.08636765f, -0.19266351f, 0.06401496f, -0.04194209f, -0.07612136f, 
    0.11934370f, -0.04361373f, -0.17203669f, -0.06365316f, 0.03680420f, -0.23820277f, 0.02241909f, -0.05491082f, 
    -0.14723152f, -0.06314094f, 0.06393772f, 0.23108961f, 0.16969118f, 0.04664325f, 0.08257446f, 0.05493847f, 
    0.08340587f, -0.12088516f, -0.06941915f, -0.09049987f, 0.02814185f, -0.03834115f, 0.15776208f, -0.05557208f, 
    -0.00886348f, -0.05959682f, 0.28074801f, -0.00739157f, 0.08162417f, -0.01552603f, -0.15418890f, 0.15962198f, 
    0.05413683f, 0.13295871f, -0.22987501f, 0.29344484f, 0.09393633f, 0.09604866f, -0.03659158f, -0.31146026f, 
    0.17787074f, -0.04616858f, 0.10648059f, 0.18728834f, -0.07064620f, -0.03142525f, -0.08472087f, -0.14622988f, 
    -0.22530769f, 0.01041978f, -0.09471932f, 0.08599862f, -0.10353032f, 0.16492674f, 0.21910785f, -0.17705828f, 
    -0.12411981f, -0.03260097f, -0.04425045f, -0.12934738f, -0.13651164f, 0.47153765f, -0.08268423f, 0.04483668f, 
    -0.07340495f, -0.03621208f, 0.04854866f, -0.04858330f, 0.16324867f, 0.12384634f, 0.08501871f, 0.06680956f, 
    -0.21862698f, -0.30806503f, 0.13414578f, -0.20416515f, -0.07435465f, 0.25560200f, 0.08605192f, 0.04377123f, 
    0.03509420f, -0.04958072f, 0.03537297f, -0.06888824f, 0.17783023f, -0.07556107f, -0.00498991f, 0.13627638f, 
    0.02541761f, 0.04718746f, 0.00363411f, -0.00219698f, -0.01365345f, -0.04227893f, 0.03735981f, 0.21823412f, 
    -0.21654123f, -0.08549242f, -0.09894980f, -0.07595848f, 0.12820055f, 0.09500138f, 0.08787103f, 0.03765056f, 
    0.06968424f, -0.12441300f, 0.12263162f, -0.18332756f, -0.03420253f, -0.03895185f, 0.06684771f, -0.08751304f, 
    0.04545646f, -0.01517483f, -0.00067401f, -0.04192751f, 0.10481413f, 0.11112951f, 0.03174746f, -0.11243612f, 
    -0.03400045f, -0.08387700f, -0.11688699f, -0.02839655f, -0.06964217f, -0.07543517f, 0.04887784f, 0.04573894f, 
    -0.12225375f, -0.05494110f, -0.09804704f, -0.02301059f, 0.04315371f, -0.00359493f, -0.11595811f, -0.04263851f, 
    -0.01237535f, -0.06693978f, 0.04525188f, -0.18281044f, -0.14256184f, -0.09456541f, 0.07137705f, -0.15164003f, 
    0.10767464f, 0.05675642f, 0.00673483f, 0.04254667f, 0.04495814f, -0.08801463f, -0.07966892f, -0.08208492f, 
    -0.07912518f, -0.09824342f, -0.15439324f, -0.01810855f, -0.07007801f, 0.05739636f, 0.03662572f, -0.12846807f, 
    -0.11844540f, 0.18798825f, 0.28473356f, -0.37251860f, 0.11040495f, -0.26195675f, 0.23973745f, -0.13707028f, 
    0.05025441f, 0.11650625f, -0.02886473f, -0.01305007f, -0.14454004f, -0.03872934f, -0.07595729f, 0.18155403f, 
    -0.03769049f, -0.18725380f, 0.07579853f, -0.06450461f, 0.06185828f, 0.07674438f, -0.12206502f, -0.01156784f, 
    0.06878342f, 0.17979163f, 0.16701669f, -0.13835841f, 0.28934252f, -0.42332360f, 0.00858410f, 0.03332651f, 
    -0.07148020f, -0.02354811f, -0.08733317f, 0.08707501f, 0.12140795f, 0.13237798f, -0.11066141f, -0.01505411f, 
    0.05558497f, 0.17635754f, 0.15376228f, -0.01274821f, -0.00285633f, -0.02044027f, 0.11557005f, 0.26005164f, 
    -0.01635626f, -0.11929385f, -0.07004829f, 0.09269342f, -0.01984739f, 0.02525388f, 0.00294628f, 0.24494945f, 
    0.22365136f, -0.05798282f, -0.22223929f, -0.07184251f, 0.17615981f, -0.06717335f, -0.04347050f, 0.30979356f, 
    0.01114830f, -0.03877338f, -0.00822879f, -0.05524796f, 0.02688178f, 0.02356768f, -0.09747048f, 0.01295667f, 
    -0.08139962f, 0.05524098f, -0.04242777f, -0.11464676f, 0.09351329f, -0.10820440f, 0.06547146f, -0.00230907f, 
    -0.13979125f, -0.04780713f, -0.09451574f, -0.03354483f, -0.02789980f, -0.08941051f, 0.04865326f, 0.07383566f, 
    -0.08140016f, -0.05468513f, 0.14414224f, -0.16010323f, -0.12640896f, 0.10243961f, -0.08673000f, -0.00592033f, 
    -0.03308252f, -0.01680469f, -0.13872620f, -0.00279743f, -0.06617154f, -0.02278816f, -0.01553261f, 0.04657353f, 
    -0.06946342f, 0.02371703f, 0.05148963f, 0.11301225f, -0.07071602f, 0.04156703f, 0.03188363f, -0.12589440f, 
    -0.02218551f, -0.08156662f, -0.06661859f, 0.02515086f, 0.10805665f, -0.05955264f, -0.02657404f, 0.04549799f, 
    -0.12379213f, 0.06198400f, 0.04846108f, -0.02840729f, -0.07264805f, -0.12834150f, -0.06836133f, -0.02546971f, 
    0.20484309f, 0.24285096f, 0.14444117f, -0.11568239f, 0.00973138f, -0.07102755f, 0.24815346f, -0.03795653f, 
    0.13352992f, -0.10926488f, 0.10182304f, 0.18926638f, -0.30627933f, -0.00790108f, -0.12160724f, 0.12678522f, 
    0.03219504f, -0.01735854f, 0.00872056f, 0.06860831f, -0.00389688f, -0.04183694f, 0.06170063f, 0.13016310f, 
    0.12339555f, 0.02858403f, 0.01432811f, -0.07800543f, 0.12379975f, 0.05991532f, 0.04027076f, 0.04240617f, 
    -0.05152332f, -0.09856489f, -0.27519092f, 0.01983307f, 0.16539875f, -0.21381426f, 0.02657530f, 0.07787146f, 
    -0.15550317f, -0.01031031f, 0.16135557f, -0.29960620f, 0.07647077f, -0.03150366f, 0.04638186f, -0.06194637f, 
    0.06335239f, -0.03724753f, 0.07250313f, 0.02738970f, 0.01394663f, -0.18051852f, -0.16307816f, 0.15318991f, 
    -0.18101916f, -0.11661619f, -0.29763433f, 0.05200173f, -0.23944019f, 0.17104420f, 0.26426589f, -0.28614822f, 
    -0.12346578f, 0.02685145f, 0.10379305f, -0.15545592f, -0.09336102f, 0.05184327f, 0.04041998f, -0.04149643f, 
    0.05486947f, -0.01361544f, 0.11449862f, 0.04638875f, -0.12881464f, -0.11570700f, -0.03576390f, -0.11355477f, 
    -0.10490295f, -0.05254740f, -0.09191011f, -0.04455867f, -0.02948515f, -0.02440431f, -0.08701578f, -0.01917873f, 
    -0.07199471f, -0.00215641f, -0.03552446f, 0.01178811f, -0.09459314f, -0.03603414f, -0.05406909f, -0.05777568f, 
    0.11699429f, 0.03539461f, -0.15317817f, -0.09995206f, 0.00801743f, -0.17085338f, 0.09925885f, 0.03298892f, 
    -0.08888553f, -0.11135948f, 0.00991220f, 0.02813244f, -0.09340882f, 0.01453041f, -0.06010580f, -0.04357637f, 
    -0.00279445f, 0.00691403f, -0.05238661f, 0.00585546f, 0.04027369f, -0.07540382f, 0.06108429f, -0.00948568f, 
    -0.12189320f, -0.09033683f, 0.05293627f, 0.07125688f, 0.05091691f, -0.00255438f, -0.04180431f, -0.16355687f, 
    0.17303245f, 0.08201028f, -0.02292440f, 0.23727438f, 0.07933803f, 0.02449252f, 0.21591829f, 0.29275003f, 
    -0.03725496f, 0.08700617f, 0.07518531f, 0.02601006f, -0.12546378f, 0.08331545f, -0.10559350f, 0.06568737f, 
    0.07215784f, 0.02765106f, -0.04775590f, 0.24356300f, 0.03863335f, 0.09209181f, 0.17824258f, -0.02403712f, 
    0.02834797f, -0.14104661f, -0.03459775f, 0.17219083f, 0.07081284f, 0.34419122f, 0.03044585f, -0.04371156f, 
    -0.05117559f, -0.04492904f, -0.32757503f, -0.02784094f, 0.09195868f, -0.19650196f, 0.00574425f, -0.04230803f, 
    -0.09797569f, -0.11842818f, -0.01275502f, -0.18029812f, 0.05880754f, -0.32786819f, 0.10324150f, -0.31594792f, 
    0.07290460f, -0.09352551f, -0.09982050f, 0.08003171f, 0.22356056f, 0.02972115f, -0.11849847f, 0.00299603f, 
    -0.50690705f, -0.02708065f, -0.14246170f, 0.06415060f, -0.19094485f, 0.09481860f, 0.20045447f, -0.17111042f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.01162549f, 0.12530729f, 0.11307160f, 0.15776892f, 0.11799379f, 0.18102731f, 0.07643493f, 0.01290443f, 
    -0.10836497f, -0.04180107f, 0.19750942f, -0.21821207f, 0.08815932f, 0.12264322f, -0.07323664f, 0.07361467f, 
    -0.00264397f, -0.12037580f, 0.10064889f, -0.07665069f, 0.00332278f, 0.15018125f, 0.06523523f, -0.01174442f, 
    0.07488839f, -0.00942198f, -0.14506726f, 0.06109228f, 0.08883714f, 0.03753563f, -0.04254161f, -0.02061864f, 
    0.05203777f, 0.02905251f, -0.05183855f, 0.16010745f, 0.00036823f, 0.02636091f, -0.01271386f, 0.07261103f, 
    -0.02452837f, 0.21547936f, 0.02272502f, 0.11565705f, 0.20028575f, -0.01174574f, 0.06057042f, -0.09527139f, 
    0.04884409f, -0.03489418f, -0.17839566f, 0.16760203f, 0.11374454f, 0.00046069f, 0.05324524f, 0.09385045f, 
    0.07544224f, -0.08699749f, -0.02605342f, -0.02986468f, -0.01914963f, 0.21823357f, -0.15649496f, 0.02600943f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.01639650f, -0.08402339f, 0.17269062f, -0.15001173f, 0.14633764f, -0.13749972f, -0.04002623f, -0.16544539f, 
    -0.01735171f, -0.02671318f, 0.07828815f, 0.17111389f, -0.20542711f, -0.02949422f, -0.23144181f, -0.07237916f, 
    -0.29774213f, 0.25449148f, -0.34603712f, 0.09860051f, 0.05487566f, -0.20402355f, -0.14023761f, 0.15747279f, 
    0.10159352f, -0.03887933f, 0.20026401f, 0.16611892f, 0.00365221f, -0.54985970f, -0.00234257f, -0.06127882f, 
    -0.52418137f, -0.13415997f, -0.03805397f, 0.08229084f, -0.19552229f, 0.18131958f, 0.04882042f, -0.21143429f, 
    -0.13803309f, -0.48386252f, -0.04851442f, -0.36123747f, -0.44382203f, -0.02643167f, -0.28228411f, 0.00352160f, 
    0.06437562f, 0.22746789f, 0.08537333f, 0.10201556f, 0.10254329f, -0.13934898f, -0.06914137f, -0.37955832f, 
    -0.25043181f, 0.08074117f, 0.04128131f, -0.24894702f, 0.06103359f, -0.35548654f, 0.00024879f, -0.29980171f, 
    0.11523480f, 0.02506307f, 0.09587438f, 0.18686250f, 0.06361797f, -0.02602418f, 0.07472049f, -0.02360024f, 
    0.06339940f, -0.06392138f, 0.07477539f, -0.13762702f, 0.03148883f, -0.53570145f, -0.00143809f, -0.03486586f, 
    -0.19551904f, -0.19787665f, -0.11513525f, 0.03334508f, -0.05691810f, -0.03290717f, 0.11379255f, -0.51481384f, 
    0.00528529f, -0.25522938f, 0.01796097f, 0.14275846f, 0.04453352f, -0.24329789f, -0.02343099f, -0.02643182f, 
    0.25243020f, -0.09137356f, -0.04403117f, 0.07536823f, 0.14479613f, 0.02361843f, 0.04936864f, 0.08397435f, 
    -0.06355362f, -0.07277744f, -0.49700984f, -0.21935353f, -0.31035104f, 0.16945927f, 0.28951177f, 0.03833769f, 
    0.23964174f, 0.26689404f, 0.20979330f, -0.36145559f, 0.05641257f, 0.28320777f, 0.18763933f, -0.07692678f, 
    0.20389941f, 0.14422680f, -0.04042632f, 0.25140882f, 0.09847172f, -0.03467265f, -0.03573591f, -0.07649893f, 
    0.20988648f, -0.02143796f, 0.02823624f, 0.15269913f, 0.30824554f, 0.21652085f, 0.04009660f, -0.21577990f, 
    0.02179696f, 0.15758006f, 0.18858035f, -0.00986260f, 0.11778350f, 0.09009551f, -0.23468107f, -0.25920460f, 
    -0.06037695f, -0.78795230f, -0.09083664f, -0.13981280f, 0.07310221f, 0.11502625f, 0.08661579f, 0.06132585f, 
    -0.01027169f, 0.02804824f, 0.11670662f, -0.01870522f, 0.24259765f, 0.10203402f, -0.02699656f, -0.16480958f, 
    -0.22488211f, 0.08076160f, 0.01168332f, -0.27262074f, -0.10260382f, -0.60639888f, -0.00876551f, -0.45438191f, 
    -0.24284770f, 0.21371539f, -0.04859265f, -0.02670147f, 0.14309855f, -0.03312887f, 0.08114003f, -0.04111143f, 
    -0.09574354f, -0.31549764f, -0.08486155f, 0.21775866f, -0.29933733f, -0.12706827f, -0.16379581f, -0.25480497f, 
    -0.16795681f, -0.33465135f, 0.01407428f, 0.38285190f, 0.03696151f, 0.08541023f, -0.04522384f, -0.15498088f, 
    -0.18637444f, -0.41348994f, 0.18771577f, -0.05183844f, 0.11552794f, 0.14198652f, -0.07369264f, 0.15562795f, 
    0.01152500f, -0.22434552f, 0.09821183f, 0.34432748f, -0.00127287f, -0.04539793f, 0.09099502f, -0.23453756f, 
    0.04257923f, -0.06057607f, 0.00237476f, -0.16015571f, -0.08152040f, -0.24114133f, 0.14737354f, 0.09924071f, 
    -0.05434325f, 0.10365136f, 0.13892944f, 0.07597739f, -0.65676641f, 0.22840779f, -0.01877634f, 0.12685226f, 
    -0.19415179f, 0.22685902f, -0.09952208f, 0.11291862f, -0.41244385f, -0.01424823f, -0.11650033f, -0.31121254f, 
    -0.35935077f, -0.14214717f, 0.00703726f, -0.39840221f, 0.27408606f, -0.64351314f, -0.14824450f, -0.10524826f, 
    -0.06363755f, 0.08754029f, -0.05394810f, -0.01314648f, -0.12683789f, -0.12805197f, -0.06465709f, 0.16218345f, 
    -0.54065692f, -0.00735528f, 0.05339365f, 0.22351179f, 0.03634092f, -0.14173420f, 0.02587373f, -0.41509980f, 
    -0.06796513f, 0.06973170f, -0.01149349f, 0.15036151f, 0.06466781f, -0.34438807f, -0.29938951f, 0.02985674f, 
    -0.00919179f, 0.15828058f, 0.03800092f, -0.07634701f, 0.04234917f, 0.21633494f, -0.37036088f, -0.26158398f, 
    0.02442741f, 0.01951054f, -0.21036358f, 0.12636200f, -0.06036105f, 0.30586135f, -0.31458700f, -0.00570204f, 
    -0.09986167f, 0.11180976f, 0.15452993f, 0.00505999f, -0.05006469f, -0.05209323f, 0.02212385f, -0.25046679f, 
    0.21827102f, 0.17173582f, -0.03410321f, 0.04871994f, -0.19114286f, 0.00908135f, -0.02765089f, 0.17889264f, 
    0.04619801f, -0.04093459f, 0.03965650f, 0.31270063f, -0.02888902f, 0.06625043f, -0.14791133f, -0.14377648f, 
    -0.34164339f, 0.00310518f, -0.00247893f, 0.07288462f, 0.09348365f, -0.12792146f, -0.43414462f, 0.16311143f, 
    -0.10033151f, -0.30250096f, -0.01776882f, -0.03257107f, 0.01832508f, -0.25325695f, 0.02347682f, -0.19234543f, 
    0.09839667f, -0.08852638f, -0.04325676f, 0.12593193f, 0.03012121f, -0.08421940f, -0.05402652f, 0.07594459f, 
    0.00950956f, -0.12475189f, 0.14870766f, -0.10907362f, -0.01852228f, -0.23292144f, 0.15005848f, -0.38544974f, 
    -0.33986136f, -0.08825631f, 0.14473748f, 0.12309871f, -0.30187282f, -0.01573293f, -0.18802540f, -0.02134306f, 
    0.01387180f, 0.12406037f, -0.16411231f, 0.05315496f, -0.09902821f, 0.00220483f, -0.02477737f, 0.18292779f, 
    -0.28283304f, -0.33500019f, 0.02125704f, -0.05445912f, 0.16141498f, 0.10549734f, 0.05516882f, -0.14263140f, 
    -0.01398145f, 0.19233626f, 0.27332136f, -0.03691520f, -0.14931615f, 0.01491908f, -0.17758977f, -0.07574940f, 
    -0.05262477f, -0.15298758f, 0.02589175f, 0.09704375f, 0.09643933f, 0.13407324f, -0.27231595f, -0.04804923f, 
    0.04584449f, -0.25207749f, 0.04673254f, -0.15068319f, 0.03789376f, 0.13216549f, 0.07838501f, 0.24609259f, 
    0.21207263f, 0.15092348f, -0.18205887f, 0.18086462f, 0.12772611f, 0.00126415f, -0.14015128f, -0.33841377f, 
    0.02873224f, -0.16378224f, -0.28585494f, 0.00094843f, -0.01360876f, 0.19751807f, -0.31498960f, 0.32454354f, 
    -0.22233751f, -0.60790777f, -0.10877849f, -0.01277390f, 0.10707657f, -0.11927460f, 0.15614356f, -0.37712806f, 
    0.07331349f, -0.27972490f, -0.19604264f, -0.76781631f, 0.23843622f, 0.02458126f, -0.04939695f, -0.25608066f, 
    0.05970334f, -0.24850917f, -0.01596676f, -0.45622888f, 0.07158732f, -0.23770846f, -0.03328625f, 0.12993622f, 
    -0.04543438f, 0.17190202f, 0.22517881f, 0.22602542f, 0.39628515f, -0.27369103f, -0.07351143f, 0.02263951f, 
    -0.18032217f, -0.32293102f, -0.06487945f, 0.02690373f, -0.18510768f, -0.34546146f, 0.13143668f, 0.27765226f, 
    -0.36356962f, 0.19729564f, -0.13503781f, -0.20541863f, 0.00424348f, 0.11030926f, -0.15106827f, 0.14627574f, 
    -0.07896231f, 0.20609818f, -0.01887526f, -0.52444327f, 0.02432777f, 0.05161876f, -0.00480849f, 0.25786597f, 
    -0.06761830f, -0.04132628f, -0.21068755f, -0.06807654f, 0.14036851f, 0.14176235f, 0.18013656f, 0.12214176f, 
    0.25259149f, 0.13204703f, -0.34417170f, 0.15788823f, -0.11382186f, -0.21268520f, 0.12132521f, 0.28958353f, 
    -0.09886300f, 0.21599193f, -0.49351823f, -0.47052947f, 0.04650766f, 0.19576040f, -0.10712826f, -0.16613357f, 
    -0.26179987f, 0.10229830f, -0.03980774f, -0.42570826f, -0.22313669f, -0.22729126f, 0.11330099f, -0.03183758f, 
    0.16264369f, -0.01954457f, 0.15378414f, -0.14937529f, -0.42121586f, -0.05441225f, 0.06954361f, -0.07037523f, 
    -0.20433329f, -0.11318956f, -0.22592463f, 0.24521501f, 0.12801780f, -0.03701388f, -0.05930690f, -0.31337857f, 
    -0.02925195f, 0.00491598f, -0.04938310f, -0.22037992f, -0.02506067f, -0.17934150f, -0.00482234f, -0.27399632f, 
    -0.11886909f, -0.25859743f, -0.07933447f, -0.08626486f, -0.31958649f, 0.17937304f, 0.23073056f, 0.23562042f, 
    -0.09811749f, -0.06218832f, 0.25082672f, -0.04583171f, 0.00690239f, -0.26065478f, 0.12467539f, 0.27560794f, 
    0.21046145f, -0.30657643f, -0.02438522f, -0.12033906f, -0.29674906f, -0.24653655f, -0.12659663f, 0.14842018f, 
    0.11159374f, -0.45967415f, -0.32786113f, -0.28905150f, -0.14658462f, 0.15646327f, 0.07272251f, -0.16743323f, 
    0.04094648f, 0.06513096f, 0.10035490f, -0.69491166f, -0.13031223f, -0.23155478f, -0.02038504f, 0.08158351f, 
    0.02832057f, 0.12611137f, -0.26619068f, -0.12642458f, 0.17047562f, -0.11816914f, -0.11800174f, -0.10571320f, 
    0.29097462f, -0.13477837f, -0.07944221f, 0.35751098f, -0.31490740f, 0.12339370f, -0.15536781f, -0.43311560f, 
    0.06773249f, -0.25353682f, -0.05552507f, -0.05151439f, -0.02561271f, 0.16709559f, -0.04427494f, 0.07407666f, 
    0.23370019f, -0.00367566f, -0.54036373f, 0.07206067f, 0.25115389f, 0.19736332f, -0.15360206f, -0.16283394f, 
    0.09353025f, -0.22440514f, -0.17698103f, -0.40354624f, 0.12885505f, 0.10900056f, -0.33317623f, -0.24310327f, 
    0.10866401f, 0.06145177f, -0.29764640f, -0.33783680f, 0.29202271f, 0.14952211f, 0.07515490f, -0.00682364f, 
    -0.09341048f, 0.17185491f, -0.15446937f, -0.09266493f, 0.00978670f, 0.02359037f, 0.03823192f, 0.10108497f, 
    0.09841865f, -0.36734581f, -0.03215417f, 0.24730569f, -0.05359055f, -0.20984736f, 0.02100369f, -0.03709250f, 
    0.14351331f, -0.10419787f, -0.06756204f, 0.26019326f, -0.24248292f, -0.16072939f, -0.18801308f, -0.07763609f, 
    -0.44150028f, -0.14505686f, -0.14856160f, -0.49110407f, -0.07162338f, -0.25611749f, -0.11276966f, -0.16839518f, 
    0.17581007f, 0.15539508f, -0.03191715f, -0.49629036f, 0.09065179f, 0.00830983f, 0.03640731f, 0.03131747f, 
    -0.30215788f, -0.23536475f, 0.20149437f, -0.02288020f, -0.19958760f, -0.37987182f, -0.06262769f, -0.18921484f, 
    0.02605968f, -0.46935427f, -0.00643167f, -0.22156003f, -0.49856412f, 0.14107567f, 0.29731542f, -0.11152994f, 
    0.00842466f, -0.35352889f, 0.12727979f, 0.18280751f, 0.19566761f, 0.27983645f, 0.15399143f, -0.32040271f, 
    0.06428419f, -0.30867293f, -0.32157719f, -0.13541318f, -0.30008948f, 0.09149598f, -0.07993761f, 0.25260860f, 
    -0.10515792f, 0.15465701f, 0.07678268f, 0.11421408f, 0.20312145f, 0.09555926f, -0.19321302f, -0.27023941f, 
    0.15835978f, 0.11111439f, -0.54140544f, 0.18598779f, 0.15966722f, -0.31051672f, -0.14263740f, -0.07669627f, 
    -0.29948679f, 0.18068762f, -0.31685537f, 0.11913975f, -0.54664028f, -0.05526013f, -0.13964705f, 0.28761330f, 
    -0.63639021f, -0.19390023f, -0.12365991f, 0.15248063f, 0.09721673f, 0.02919661f, 0.00084245f, -0.02413970f, 
    -0.02671803f, 0.17438194f, -0.33919397f, -0.14337231f, -0.47229943f, -0.29929280f, 0.23402479f, -0.19322293f, 
    -0.06995717f, -0.01101403f, -0.41694331f, -0.51728654f, 0.17745724f, -0.34008256f, -0.07534565f, 0.12494598f, 
    0.11451662f, 0.16941659f, 0.34868696f, -0.45581019f, -0.20005329f, 0.14318964f, 0.00584556f, -0.18307376f, 
    -0.07290787f, 0.04679576f, -0.09187905f, 0.13487360f, 0.12428401f, 0.01215255f, -0.10734332f, 0.21044910f, 
    -0.19916746f, 0.26106617f, -0.01492656f, 0.00581350f, -0.13219723f, -0.30601782f, 0.15019411f, -0.09980579f, 
    -0.07859276f, -0.08597115f, 0.04212802f, -0.16605748f, 0.05663437f, 0.21460944f, -0.08622970f, 0.04598939f, 
    0.06369194f, -0.23950064f, -0.19149354f, -0.06308045f, 0.00533580f, -0.39781606f, -0.09556796f, 0.36130548f, 
    0.05014416f, 0.18482153f, -0.02098989f, 0.11661045f, 0.03189144f, 0.13622956f, 0.01546687f, 0.09840915f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.19179125f, 0.11098297f, -0.00412541f, -0.13595495f, -0.00469787f, 0.14035363f, 0.05281223f, 0.04027901f, 
    -0.12490056f, 0.10094711f, 0.11334392f, -0.07345278f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
