#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.49066836f, -0.92751777f, 0.85629976f, 0.62082404f, -0.54950386f, -1.13276982f, 0.16644371f, -0.23845392f, 
    0.40975013f, 1.37220156f, 1.08509099f, 0.46885258f, -0.71646619f, 0.23371807f, -0.14299822f, 0.55163962f, 
    -0.18214281f, 0.00105182f, 0.23594625f, 0.90512830f, 1.14352119f, -0.64263046f, 0.78846699f, -0.57470292f, 
    0.72273898f, 0.53121716f, -0.47491723f, -0.20968857f, -1.41805303f, -0.33866251f, 0.90239811f, 0.83280158f, 
    1.01895690f, -0.42324796f, -0.57781237f, 0.27366021f, -0.23976339f, 0.02016554f, 0.05643746f, -1.28273976f, 
    1.57881367f, -1.00908160f, 0.15800031f, -0.21268336f, 0.18318520f, 0.30034715f, 0.56155783f, 0.38082212f, 
    1.03321242f, 1.14955616f, 0.45488295f, 0.12684964f, 0.00417616f, -0.56458008f, 0.84486598f, -0.82960165f, 
    -0.46797851f, -0.50985301f, -1.04960465f, -0.69100314f, -0.41798753f, -0.05167957f, 0.54593927f, 0.94398558f, 
    -0.24615073f, 0.16858748f, -1.31243420f, 0.21836738f, -0.33541942f, -0.23400928f, 0.52248001f, 0.79689282f, 
    0.88166839f, 1.18000269f, 0.86092424f, -0.19831538f, -0.88556838f, 0.08905949f, -0.64696497f, 0.05909681f, 
    -0.34515384f, -1.35296476f, 0.85572326f, -0.15518600f, -0.78111714f, 0.22668475f, 0.53443056f, 0.60797209f, 
    -0.04343166f, 0.56265402f, 1.04150939f, 0.68570143f, 0.97458297f, 0.29638466f, 0.81196791f, -0.27084506f, 
    -0.36340794f, 0.28106117f, 0.51233768f, -0.31585339f, 0.05222284f, 0.19165951f, -0.03660327f, 1.05711830f, 
    1.06688511f, -0.05287065f, -0.42463392f, -0.49252254f, -0.31686395f, 0.94834906f, 0.23734367f, -1.25258482f, 
    -0.01393030f, -0.95783174f, -0.40941915f, 0.57532126f, 0.07408082f, -1.45333874f, -0.62914658f, -0.47435689f, 
    0.47946870f, 1.38299990f, -0.64247543f, -0.15392713f, -0.19419564f, 0.54164946f, -0.29718056f, -0.82667053f, 
    0.55447203f, 0.89011151f, -1.37366557f, 0.83960164f, 0.24601166f, -0.02870916f, -0.67986482f, 0.91648984f, 
    0.90251374f, -0.29638809f, -0.37199855f, 0.43988469f, -0.09214115f, 0.21998960f, 0.73131680f, 0.81429458f, 
    -1.09360623f, -0.99268198f, -1.18025744f, 0.71456885f, -0.25019848f, 0.41709197f, -0.79930848f, -0.35982651f, 
    -0.49150705f, -0.94685620f, -1.35250592f, -1.33842206f, -0.40310600f, -0.33047962f, 0.62977117f, 0.33640921f, 
    0.12367486f, 0.46971247f, -0.54944909f, -1.23723793f, -1.10494137f, -0.75668663f, 1.02721894f, -0.35478377f, 
    0.08748748f, 0.43921614f, -0.28846553f, -0.73062158f, -0.10626838f, 1.08421028f, -1.32009482f, -0.60846186f, 
    0.39341149f, 0.39253032f, -0.04448076f, -0.42878807f, 0.88550687f, -0.02715867f, -0.93547404f, -0.81749767f, 
    0.92594814f, -0.22324313f, -0.02895430f, 1.08095920f, 0.03161501f, 0.69933861f, 0.79753274f, 0.85514039f, 
    -1.18876028f, -0.94638926f, -0.53342927f, -0.30622172f, -0.82147700f, -0.40513873f, -0.62443876f, 1.36021125f, 
    -0.08432100f, 0.69309449f, -0.58017153f, -0.67514366f, -0.38126177f, -0.42168286f, -0.69294900f, 1.10977554f, 
    0.98252690f, -0.28802854f, 0.72231972f, -0.55324101f, 0.07975692f, 0.55880308f, 0.70418698f, 0.60011178f, 
    -0.91517353f, -0.82720941f, -0.47647220f, 0.76205516f, 1.06102872f, 0.09386735f, 0.11220869f, 0.36035287f, 
    -0.52002805f, -1.05544412f, -0.99706244f, -0.47563541f, -0.47336727f, -0.92388475f, -0.22513789f, -0.60920715f, 
    -0.03507771f, 0.16392280f, 0.46735975f, 0.74719012f, -1.42160428f, -0.36656466f, 0.13944018f, -0.44574708f, 
    0.19706471f, -0.57957232f, 0.56351560f, -0.34341103f, -0.24124399f, 1.01942325f, 1.43709052f, 0.24558666f, 
    0.47805330f, 0.64361936f, -0.40386474f, 0.60470897f, 0.65413433f, -0.35977054f, -0.39158830f, -1.04132581f, 
    -1.19130301f, -1.00840402f, 0.70573944f, 0.16629615f, -0.04134246f, 1.15090489f, -0.63185608f, -0.84445149f, 
    -0.97517490f, -0.62199718f, 1.01151836f, -0.12339155f, -0.35862315f, 0.17582715f, 0.51830107f, 0.91744399f, 
    -1.07734883f, 0.13445212f, -0.16034894f, 0.48341319f, 0.72626781f, 0.22301999f, 0.01228568f, 0.03879629f, 
    -0.36179361f, 1.11179113f, 1.02680862f, 0.73768407f, 0.84275860f, -0.64115411f, 0.42756805f, 0.05085165f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.16753189f, 0.29208809f, -0.20536362f, 0.00456846f, -0.18977585f, 0.06582350f, 0.14690299f, -0.39906606f, 
    -0.02380966f, 0.16436556f, 0.65017092f, 0.33635902f, 0.48095694f, -0.03603104f, 0.25606027f, 0.01701463f, 
    -0.33178192f, 0.01368981f, 0.29221892f, 0.13231733f, -0.15901330f, 0.02807538f, 0.25079975f, -0.29139817f, 
    0.17736788f, 0.39745671f, 0.07049942f, -0.04637076f, -0.01055846f, -0.14266936f, 0.14941913f, 0.39615676f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.03512263f, -0.02537911f, -0.02283184f, -0.03177690f, -0.05575106f, -0.06627443f, 0.01263454f, 0.01753751f, 
    0.00299781f, 0.01752492f, 0.03580327f, 0.02892119f, -0.01522008f, -0.03094340f, -0.03446262f, -0.04151410f, 
    0.04743996f, 0.02315166f, 0.00405361f, 0.03696939f, -0.00647186f, -0.05405327f, 0.01539061f, 0.05272835f, 
    0.03660441f, -0.04461258f, -0.07195876f, -0.03186068f, -0.02571138f, -0.00673235f, 0.02512418f, -0.04858785f, 
    0.00444383f, -0.01949977f, -0.02941362f, -0.00498589f, 0.01504310f, -0.05616974f, 0.02964023f, 0.03838822f, 
    0.00358248f, -0.05801061f, -0.06515953f, 0.04694153f, -0.06765148f, 0.02731008f, -0.06408741f, -0.02412218f, 
    -0.03680257f, 0.04180536f, 0.00585127f, -0.00257791f, -0.00597791f, -0.05197258f, 0.04998360f, -0.03965424f, 
    0.02282497f, -0.06391504f, 0.02400871f, 0.00867993f, -0.02386329f, 0.06152966f, 0.00223671f, -0.06007909f, 
    -0.04687049f, 0.03010077f, -0.05938859f, -0.04396789f, -0.06588729f, 0.03836774f, -0.00211042f, -0.06378025f, 
    -0.00039982f, 0.04793648f, 0.03872768f, -0.04942937f, -0.04521739f, 0.01602141f, 0.00054315f, 0.00034235f, 
    -0.00255071f, -0.05684826f, -0.06615711f, 0.01638236f, -0.00254609f, 0.02370333f, -0.02597186f, -0.00236191f, 
    -0.02998228f, -0.02206052f, -0.04165005f, -0.03211916f, 0.02073112f, -0.04556874f, -0.05874608f, -0.01312336f, 
    -0.03955532f, 0.00633371f, 0.00237672f, -0.02285426f, -0.06369092f, -0.03283196f, 0.03810617f, -0.06877277f, 
    -0.04505715f, -0.06513239f, 0.01817090f, -0.02805787f, -0.03334035f, 0.00801106f, 0.00068153f, 0.00467386f, 
    0.01183156f, -0.00462308f, -0.03133100f, -0.05187379f, -0.01456589f, -0.04445136f, -0.02126347f, -0.02621764f, 
    -0.03657630f, -0.02853364f, -0.04550987f, 0.00264164f, 0.02266707f, -0.02941463f, 0.02213142f, -0.04410975f, 
    -0.00698051f, -0.03391999f, 0.02362668f, -0.04178198f, -0.01607501f, 0.02748391f, -0.05124678f, 0.04833492f, 
    -0.02842796f, -0.02940629f, -0.02527367f, -0.04393422f, 0.04805093f, -0.05125992f, 0.04184679f, 0.00208520f, 
    0.00188857f, -0.04183307f, -0.00408415f, -0.01375438f, -0.02143254f, 0.01093017f, -0.06006666f, -0.04565176f, 
    -0.00329673f, 0.04416179f, 0.06476242f, 0.05631687f, -0.03403106f, -0.00206405f, 0.03822010f, 0.02123591f, 
    -0.06261516f, -0.02288468f, -0.03918318f, -0.02936184f, -0.05545333f, 0.00717868f, -0.04220285f, -0.03344537f, 
    -0.02961523f, 0.05641293f, 0.01509852f, 0.05082594f, 0.01590820f, -0.06214064f, -0.04267336f, 0.00343716f, 
    -0.04550052f, -0.00462509f, -0.00170462f, -0.01673615f, -0.04489056f, 0.00866586f, 0.02414718f, -0.02202046f, 
    -0.04988711f, 0.00797484f, 0.04056942f, 0.00740101f, -0.01358986f, -0.04642669f, -0.04680568f, -0.02962274f, 
    -0.01831512f, -0.02110421f, -0.00293041f, -0.00796014f, -0.01220347f, 0.05808666f, 0.00910455f, 0.01570534f, 
    -0.01931914f, -0.02816781f, 0.01001009f, -0.00090264f, 0.04569988f, 0.04724284f, -0.00722405f, -0.00834967f, 
    -0.05487307f, 0.03606327f, 0.01559176f, -0.05673034f, 0.04946209f, -0.00187794f, 0.00847200f, -0.03077107f, 
    -0.02076953f, -0.02813301f, -0.01729824f, -0.00679940f, 0.03127093f, -0.07360119f, -0.02288432f, -0.00064895f, 
    -0.01575181f, -0.02336792f, 0.02205804f, -0.05277699f, -0.02014936f, -0.05184013f, -0.05804722f, 0.02329605f, 
    -0.03704664f, -0.02704627f, -0.01258038f, 0.01615012f, -0.03581136f, -0.05937486f, -0.00123662f, -0.03782202f, 
    -0.04190382f, -0.01297987f, -0.02914888f, -0.01636111f, -0.05958870f, 0.02043492f, -0.03267604f, -0.04344751f, 
    0.01614966f, -0.03396378f, -0.00999513f, -0.04100036f, -0.01413447f, -0.00571551f, -0.04008213f, 0.02850546f, 
    -0.04182789f, -0.00348553f, 0.03735889f, -0.04838901f, -0.02835428f, 0.02282282f, 0.03160357f, -0.03677386f, 
    0.02312649f, -0.00912348f, -0.00321339f, -0.03173888f, -0.03398386f, 0.00031067f, -0.05789015f, -0.04086359f, 
    0.02183685f, 0.01018946f, -0.04647410f, -0.06435714f, -0.00428791f, -0.02562292f, -0.04765420f, -0.02684042f, 
    -0.06414077f, 0.04891453f, -0.01721037f, 0.04373131f, 0.05049580f, 0.02675825f, 0.01089326f, 0.00162592f, 
    0.05731475f, -0.00792522f, 0.12185631f, 0.14790648f, 0.03332619f, -0.16884392f, 0.06653428f, -0.18524662f, 
    -0.14885293f, -0.22124878f, -0.18177868f, 0.18408331f, 0.01965849f, 0.14263827f, -0.07808436f, 0.18826598f, 
    0.04463700f, -0.01719881f, -0.46199030f, 0.23410633f, 0.34855646f, 0.16032773f, 0.12846915f, 0.06480687f, 
    0.12972628f, -0.06517766f, 0.01915684f, 0.26577446f, -0.10269204f, -0.24759689f, 0.17100079f, 0.11903567f, 
    0.02493961f, 0.05019539f, 0.08050472f, -0.01093385f, -0.54285127f, 0.36343467f, 0.01723122f, 0.01718601f, 
    0.00241675f, -0.06684820f, -0.22391383f, -0.40258414f, 0.05690679f, -0.28459987f, -0.21522559f, 0.35015011f, 
    -0.02151860f, -0.00418281f, 0.27943999f, 0.14070871f, 0.10444345f, -0.11528543f, 0.16195177f, 0.13537781f, 
    0.29815802f, -0.00844714f, -0.01198710f, -0.06329748f, 0.31894737f, -0.02318492f, 0.22122969f, -0.05666277f, 
    -0.07439157f, -0.08681385f, 0.00032975f, 0.07736152f, -0.04220904f, 0.21459962f, 0.08449169f, -0.07439201f, 
    -0.54166728f, -0.31882024f, 0.39450270f, -0.08619007f, 0.14690977f, -0.11512330f, 0.14711723f, -0.07044476f, 
    -0.08083852f, -0.18782201f, 0.22710253f, -0.05507553f, 0.02164548f, 0.21508324f, 0.05653832f, -0.02063244f, 
    0.03983488f, 0.12759672f, -0.60612696f, -0.10022551f, 0.19468063f, 0.11921238f, -0.03811979f, 0.14962280f, 
    0.11103740f, 0.08303469f, 0.03168867f, 0.16249989f, 0.03097504f, 0.17008117f, -0.00155146f, -0.02492627f, 
    0.19749942f, -0.02084091f, 0.02176028f, 0.15402389f, 0.12200721f, 0.19654980f, 0.11640460f, 0.17379832f, 
    0.10966022f, 0.05258397f, -0.05403806f, -0.02561094f, 0.16700433f, 0.01532892f, 0.12931061f, 0.15477940f, 
    0.06430100f, -0.12107698f, -0.08882710f, 0.03920093f, 0.05204362f, 0.07022922f, -0.09329744f, 0.05785125f, 
    -0.02628682f, -0.10703874f, 0.05142950f, -0.07057381f, -0.17241998f, -0.03064037f, 0.30079055f, -0.20602417f, 
    -0.57070309f, -0.04891023f, -0.16406061f, -0.03735753f, 0.01745955f, 0.10484894f, 0.32016557f, -0.08756743f, 
    0.00910172f, -0.28703901f, -0.23963575f, -0.13442409f, 0.02147235f, 0.01985033f, -0.06614203f, -0.30911303f, 
    0.10802190f, 0.12275134f, -0.29803836f, 0.01123923f, -0.09649508f, -0.07349084f, 0.02813330f, 0.03441091f, 
    0.10412975f, 0.01130658f, -0.03509157f, 0.20871964f, 0.17779759f, -0.06569439f, -0.01433528f, 0.04161820f, 
    -0.00010833f, -0.14726910f, 0.05053091f, 0.10123753f, -0.02052385f, -0.00087487f, 0.00072570f, -0.19015434f, 
    -0.22319590f, -0.09308522f, -0.00991947f, 0.09854289f, -0.03294882f, 0.25336966f, -0.03666978f, -0.22170171f, 
    -0.02428966f, 0.17907508f, 0.07496344f, 0.08983423f, -0.01496686f, -0.18537682f, -0.12910092f, 0.20091490f, 
    0.11182833f, -0.01772728f, -0.32042861f, 0.11902672f, -0.20971030f, 0.19483897f, 0.50466144f, 0.25051814f, 
    -0.10611709f, 0.14909506f, -0.00491541f, 0.12951547f, 0.03560410f, -0.10375001f, 0.17796133f, -0.31303370f, 
    -0.57911497f, -0.21351832f, -0.06026099f, 0.00857269f, -0.05400601f, 0.07835528f, 0.07445466f, -0.16516173f, 
    0.01583089f, 0.00123067f, -0.00780498f, 0.03353311f, 0.07985125f, -0.02605804f, -0.00313786f, 0.04096541f, 
    0.04079613f, 0.01301011f, -0.40217403f, 0.17257461f, -0.02343459f, -0.12432043f, -0.00870925f, 0.13310215f, 
    -0.22628559f, 0.10050485f, 0.19604692f, -0.20027611f, -0.19053206f, 0.11714132f, 0.04448573f, 0.09065551f, 
    -0.03905948f, 0.06823873f, 0.11586987f, 0.13591047f, -0.15487963f, -0.25098273f, -0.11304411f, 0.05031108f, 
    0.15164764f, -0.04142560f, 0.17241392f, 0.11546241f, 0.04029447f, 0.00751042f, 0.10662419f, -0.03042440f, 
    -0.03139847f, -0.05984309f, -0.11526933f, 0.14009106f, 0.05777603f, 0.24528234f, -0.27470854f, -0.00982618f, 
    -0.03749542f, 0.12872554f, -0.30897060f, 0.11224885f, -0.03735081f, -0.19725215f, 0.11446454f, -0.13027680f, 
    -0.26229277f, -0.00231891f, 0.06225364f, 0.06938007f, -0.04665584f, 0.04479558f, -0.01736916f, 0.13534386f, 
    -0.00762652f, 0.06348013f, 0.22555436f, -0.05733338f, 0.14545883f, 0.12168272f, 0.19410113f, -0.23682463f, 
    -0.15235786f, -0.15166287f, -0.20701949f, -0.00771603f, -0.03887076f, 0.10787650f, -0.13798529f, -0.06596235f, 
    0.00758967f, 0.19515026f, -0.28681850f, -0.05602796f, 0.16532196f, -0.09948794f, -0.07753138f, -0.10639400f, 
    -0.04767795f, 0.02451341f, 0.24747077f, -0.26883087f, 0.14621937f, -0.03761644f, -0.14562239f, 0.13572796f, 
    0.03942748f, 0.22877508f, -0.01335054f, 0.10478619f, -0.14064652f, 0.12972027f, 0.27244365f, 0.02417866f, 
    0.01316428f, 0.17073870f, -0.00046615f, -0.00453487f, -0.02531273f, 0.32957533f, -0.17145671f, -0.02514584f, 
    0.11698969f, 0.15539025f, -0.02327242f, 0.02829191f, -0.18498775f, -0.20966817f, -0.20870875f, -0.00657228f, 
    0.01403081f, 0.00488706f, -0.07288111f, -0.00365963f, 0.07026824f, 0.22515166f, 0.21359105f, -0.10057661f, 
    -0.14001054f, -0.03723415f, -0.08167364f, -0.05377984f, -0.01810206f, 0.01445289f, -0.06112088f, -0.09338158f, 
    -0.15461308f, -0.07330515f, -0.13705222f, -0.03845357f, 0.18486334f, -0.14235128f, -0.02300869f, -0.16493742f, 
    0.02023013f, 0.00228884f, -0.17169622f, -0.03568619f, -0.06634246f, 0.02603084f, 0.01686081f, 0.01569841f, 
    0.23328970f, -0.17791504f, -0.01606753f, 0.14014624f, 0.04998953f, -0.14751661f, -0.15614998f, -0.07857317f, 
    -0.13088548f, -0.19221494f, 0.27894676f, -0.12038940f, -0.01940152f, -0.15637620f, 0.05801432f, -0.06685713f, 
    0.07333195f, 0.00579756f, 0.04972648f, -0.10013969f, -0.08348649f, 0.12373967f, -0.09547108f, 0.04991151f, 
    -0.04592537f, 0.00941941f, 0.20277300f, 0.10734644f, -0.22571866f, -0.16683234f, -0.03388591f, -0.05495017f, 
    -0.08362287f, 0.05300033f, -0.07725794f, -0.00032457f, -0.14910583f, -0.16298084f, 0.33361897f, 0.14676720f, 
    0.18529198f, 0.25831237f, 0.01275215f, -0.05703208f, -0.09561412f, 0.03162337f, 0.23539416f, -0.41422758f, 
    -0.35839006f, -0.07582388f, 0.05264639f, -0.04852998f, 0.03589631f, -0.03284267f, -0.00181871f, 0.36630195f, 
    -0.18353310f, 0.18023418f, 0.21329677f, 0.07164110f, -0.14910235f, -0.00231168f, -0.15793490f, -0.12098108f, 
    0.32190531f, 0.31421506f, 0.39516231f, 0.16309819f, -0.08256660f, -0.15383391f, 0.11027312f, 0.24924062f, 
    0.28782135f, 0.22539823f, 0.20810816f, 0.36544681f, 0.09887274f, 0.13915475f, -0.09718113f, 0.07468934f, 
    0.17455387f, 0.04415834f, 0.16937478f, 0.23083727f, 0.15814690f, 0.15405636f, 0.01998336f, -0.16697131f, 
    -0.13834411f, 0.00647981f, -0.15180494f, -0.25575465f, -0.40078995f, -0.30964783f, 0.03580043f, -0.14151506f, 
    -0.02983630f, 0.08839231f, 0.07120261f, -0.02473020f, 0.25837824f, 0.04206987f, 0.19051068f, 0.06610123f, 
    -0.04487012f, -0.05479369f, -0.01728128f, -0.00589812f, -0.20221207f, 0.02218564f, -0.27463806f, -0.24548526f, 
    -0.07299333f, -0.11556043f, -0.04464678f, 0.04071444f, -0.11655901f, -0.02067863f, -0.01326182f, 0.08859485f, 
    0.11644578f, -0.07500095f, 0.07012171f, 0.05574137f, -0.05584849f, 0.15867390f, 0.00409069f, 0.06535798f, 
    0.09573352f, 0.31582758f, 0.34830460f, -0.01089376f, -0.14222355f, 0.20794994f, -0.11577830f, -0.13012786f, 
    0.07034174f, 0.23294026f, 0.09707052f, 0.05462126f, 0.07619674f, -0.02781419f, -0.17004438f, 0.22006813f, 
    0.08298604f, 0.08990519f, 0.14640395f, 0.11641281f, -0.03130332f, -0.00553422f, -0.00579851f, 0.01494375f, 
    -0.05152690f, 0.15019228f, 0.26711076f, -0.13008134f, 0.20714280f, -0.07662092f, -0.10732943f, -0.03133271f, 
    -0.10047057f, -0.04666965f, -0.06121346f, -0.43011808f, -0.06535137f, -0.26113120f, 0.11749748f, -0.05538414f, 
    0.18450621f, 0.02207947f, -0.21802635f, 0.07040924f, -0.01501296f, -0.17442216f, -0.08752981f, -0.12947504f, 
    -0.15205008f, -0.24657348f, -0.09245447f, 0.00833001f, -0.09491395f, 0.21363561f, 0.11254331f, -0.20284688f, 
    -0.22614528f, -0.08013283f, 0.02121449f, 0.08598513f, 0.29959100f, 0.19488944f, 0.22713438f, 0.18912558f, 
    0.09147504f, 0.27946994f, -0.07049181f, 0.04748416f, -0.12226289f, 0.04758824f, -0.27658299f, -0.32104188f, 
    -0.02739086f, -0.20448187f, 0.06523301f, -0.08381204f, 0.15378630f, -0.17331977f, -0.05510643f, 0.09821560f, 
    -0.03357958f, -0.08942221f, -0.06756972f, -0.07411026f, 0.00585833f, -0.07642095f, -0.04521459f, -0.18341933f, 
    0.25171724f, 0.28840566f, 0.00177978f, -0.10593421f, 0.12871894f, 0.02623475f, 0.16931936f, 0.24852581f, 
    -0.16353016f, 0.03522824f, 0.09741293f, -0.07234940f, -0.13572177f, -0.05872838f, -0.07407791f, -0.00476336f, 
    0.05494045f, 0.24525309f, -0.19487093f, 0.45136276f, 0.25667116f, 0.20929910f, -0.28564960f, -0.13561870f, 
    -0.07598647f, 0.06843361f, 0.23191923f, 0.25008610f, -0.26778817f, -0.24325208f, -0.50055885f, -0.01399027f, 
    -0.00483913f, 0.14866337f, 0.14641725f, -0.04939510f, 0.16183937f, -0.04042971f, -0.06297045f, -0.01007875f, 
    -0.40809631f, -0.18677379f, -0.03433898f, 0.11047082f, 0.16175467f, -0.05977577f, 0.18461074f, 0.02445012f, 
    -0.07403537f, 0.18849818f, 0.13702095f, -0.05553224f, -0.04419672f, 0.02193638f, 0.04656556f, 0.44804564f, 
    -0.06162778f, -0.19414775f, -0.04720344f, -0.02941784f, 0.17649534f, 0.35389698f, 0.04320091f, -0.08858207f, 
    -0.12292869f, -0.42018154f, -0.14856969f, 0.23711948f, 0.07442492f, 0.09525824f, -0.12715450f, -0.13582814f, 
    -0.16654663f, 0.39021739f, -0.04654655f, -0.30989227f, -0.00457754f, -0.10765646f, -0.02079139f, -0.01219294f, 
    -0.14021412f, 0.03327214f, -0.19701543f, -0.10381714f, -0.07712187f, -0.03429146f, 0.09794985f, 0.20385225f, 
    -0.01958467f, -0.16934630f, -0.07370059f, 0.14783059f, -0.05108247f, 0.33323324f, -0.09850810f, -0.07284353f, 
    -0.03103948f, -0.16875774f, 0.28074986f, 0.09714017f, 0.15883268f, -0.26109615f, -0.54503214f, 0.22588664f, 
    0.03631986f, 0.09750121f, 0.00246557f, 0.16728435f, -0.18810798f, -0.04540489f, -0.15682647f, 0.02464424f, 
    -0.12485334f, -0.03318695f, 0.05797946f, 0.28366125f, -0.16197012f, 0.22001435f, 0.09836311f, 0.26794291f, 
    0.11187132f, 0.12347936f, 0.08492608f, 0.08722039f, -0.16033360f, 0.10016023f, 0.24256989f, 0.33365756f, 
    0.00528282f, 0.02047012f, -0.08817974f, 0.01304384f, 0.21299067f, -0.02097919f, -0.17969900f, -0.21140002f, 
    -0.27961844f, 0.13132668f, 0.11593919f, -0.14466622f, -0.12771159f, 0.14312094f, 0.26727578f, 0.11093613f, 
    0.00026030f, 0.17711289f, 0.06510117f, 0.41967115f, -0.20201573f, -0.09355897f, -0.15793413f, -0.21123160f, 
    0.19643541f, 0.13253158f, -0.03394443f, -0.04059934f, 0.02555132f, 0.07631732f, 0.11109902f, -0.08944058f, 
    0.11793682f, 0.01835627f, 0.10943371f, 0.15539132f, -0.14010772f, -0.00908931f, 0.27177298f, -0.13296202f, 
    -0.22655001f, -0.11273625f, -0.06230251f, 0.11249318f, 0.40050980f, 0.11308056f, 0.01682930f, -0.10869675f, 
    0.03199917f, -0.11782218f, 0.09803267f, -0.04522752f, -0.38681957f, 0.02098561f, -0.14670780f, 0.08095617f, 
    0.26828146f, 0.06153319f, 0.06776893f, -0.00645234f, -0.31108409f, 0.00196437f, -0.37469596f, -0.50259840f, 
    -0.40797058f, -0.00263586f, -0.01240016f, -0.16826268f, 0.04903976f, -0.05654901f, 0.04249014f, 0.01685603f, 
    0.06400987f, -0.05409502f, 0.05812458f, -0.03884946f, 0.00271981f, -0.17325890f, -0.04926182f, 0.08801664f, 
    0.04947528f, -0.05815971f, 0.00467513f, -0.17529331f, 0.03416972f, 0.05248116f, 0.20208630f, 0.10743871f, 
    0.11825875f, -0.35182703f, -0.27536073f, -0.00174841f, 0.02740389f, -0.09395127f, 0.03913403f, 0.21380354f, 
    -0.11116818f, 0.00618912f, 0.20867674f, -0.17129937f, -0.71558946f, -0.16305241f, 0.19886906f, 0.14569370f, 
    -0.01430373f, -0.03071409f, 0.01402338f, 0.33961007f, -0.02101924f, 0.05044731f, -0.13733807f, 0.05323817f, 
    -0.08226210f, -0.17534167f, -0.11921619f, 0.15305834f, 0.43979937f, -0.03453547f, -0.32545674f, 0.18759231f, 
    0.09299649f, -0.08340661f, -0.25538620f, 0.13155134f, -0.04505124f, 0.08072137f, -0.16424043f, 0.05423792f, 
    -0.10069837f, -0.14799730f, -0.09566498f, -0.02804238f, 0.01354844f, 0.09373499f, 0.07536989f, 0.06656530f, 
    -0.04272626f, -0.10676076f, -0.25542879f, -0.08355009f, 0.00432808f, -0.18010177f, 0.03339826f, 0.18996735f, 
    -0.02590051f, 0.28166324f, 0.03450032f, 0.05968246f, -0.11627185f, -0.01814740f, 0.03151362f, 0.12587322f, 
    -0.07266629f, -0.14740059f, 0.05582849f, -0.08387613f, -0.03005587f, 0.01707278f, -0.12755004f, 0.01959055f, 
    0.17342000f, 0.06168278f, -0.14632367f, 0.04523710f, 0.19078936f, 0.12726265f, -0.10970648f, 0.10315564f, 
    0.05584959f, 0.06649890f, 0.38297078f, -0.41090634f, 0.10727818f, 0.05927107f, 0.21755715f, -0.05668462f, 
    0.13359207f, 0.05491088f, -0.10641593f, 0.24683270f, 0.01573861f, -0.09561127f, -0.23910910f, -0.01690428f, 
    0.16110076f, -0.21592636f, 0.15214023f, -0.01396521f, -0.30101037f, -0.11559278f, 0.22930130f, -0.01033460f, 
    -0.07768594f, 0.07111493f, -0.12846975f, -0.13790411f, -0.03341511f, -0.39154840f, 0.29494709f, -0.09807866f, 
    -0.04310520f, 0.15860900f, 0.03872918f, -0.04848010f, -0.01881997f, 0.00751838f, 0.46167704f, 0.21336807f, 
    -0.18673554f, -0.19161341f, -0.13424046f, 0.15950984f, 0.32009509f, 0.03779929f, -0.03833548f, -0.09114359f, 
    0.11114240f, -0.13043515f, -0.04793165f, -0.00995119f, 0.15643096f, 0.24224912f, 0.09550149f, 0.00908400f, 
    -0.06758896f, -0.80287468f, -0.02331812f, 0.33275834f, -0.03341598f, -0.03973862f, 0.10384505f, 0.04257204f, 
    0.28108636f, -0.11371581f, -0.03707905f, 0.02346519f, -0.15132898f, 0.02506967f, 0.15437204f, 0.10862484f, 
    0.08566971f, -0.02980944f, -0.15068574f, -0.29399937f, 0.05376771f, -0.04517437f, 0.21810229f, 0.11371910f, 
    0.06040373f, 0.15446673f, 0.06418307f, 0.03437690f, -0.01594013f, 0.17305402f, -0.06858507f, 0.01720075f, 
    0.21283062f, 0.02452829f, 0.07014737f, -0.01038565f, 0.08165675f, 0.09555802f, 0.28949460f, 0.03732467f, 
    0.01109227f, 0.05274436f, 0.10492509f, -0.12992488f, 0.10481861f, -0.35632828f, 0.07103536f, 0.19877471f, 
    -0.29315737f, 0.07919622f, 0.06725432f, 0.03211449f, 0.14243536f, 0.05274080f, -0.34076813f, -0.00297307f, 
    -0.21640944f, 0.04870502f, 0.10410898f, 0.20558700f, -0.18854520f, 0.03484900f, 0.08530796f, 0.01234974f, 
    -0.13578016f, 0.01283138f, -0.02053252f, 0.01538673f, -0.01211274f, 0.09896700f, -0.06645065f, -0.11760459f, 
    0.20782912f, 0.25841373f, -0.31368276f, -0.32060403f, 0.01487463f, -0.10923143f, -0.15213925f, 0.27455482f, 
    0.13574800f, -0.11571135f, 0.12529056f, -0.46849734f, -0.07083867f, -0.09913096f, -0.15264063f, -0.09947223f, 
    0.31941932f, 0.19792059f, -0.35208726f, 0.17038241f, -0.06925923f, -0.11593317f, -0.23522392f, -0.14298794f, 
    0.06937663f, 0.10511056f, -0.18490623f, 0.19444352f, 0.14211442f, 0.00132952f, -0.03481876f, -0.28037366f, 
    0.12725785f, -0.12642699f, 0.18481840f, 0.04993077f, 0.06573530f, 0.22128546f, -0.30617243f, -0.00974636f, 
    -0.35413450f, -0.25344202f, 0.03248975f, -0.02711347f, -0.13224223f, 0.44234517f, -0.05239527f, -0.10424618f, 
    0.21742335f, -0.04303184f, 0.02538715f, 0.02394194f, 0.11948603f, 0.30800289f, 0.70632410f, -0.41795346f, 
    0.11569196f, 0.14552280f, -0.06823123f, -0.09766422f, -0.23708440f, 0.03936811f, 0.13706870f, 0.06021672f, 
    -0.28008536f, -0.07943848f, 0.22890228f, -0.00788974f, -0.05466188f, 0.06048600f, 0.13606812f, 0.16895835f, 
    -0.20263913f, 0.26002860f, 0.10699650f, -0.41437322f, -0.12893268f, -0.13788520f, -0.10925201f, 0.10911353f, 
    0.02893113f, -0.11455370f, 0.14921691f, -0.08871517f, -0.06229124f, -0.05250318f, 0.06529997f, 0.03027960f, 
    0.08633171f, 0.07046215f, 0.08482774f, -0.05223198f, -0.34530413f, 0.17752638f, -0.13815813f, 0.02207153f, 
    -0.12132335f, 0.17333330f, -0.03968465f, -0.45109689f, -0.06365398f, 0.02212875f, 0.24688241f, 0.04451805f, 
    0.02045110f, 0.12820268f, -0.04759344f, -0.09507806f, 0.29361516f, 0.60232794f, -0.25254545f, -0.04381908f, 
    -0.39271331f, 0.05096800f, -0.06500329f, 0.07181606f, -0.01302062f, 0.01936766f, 0.01157512f, -0.27719989f, 
    -0.04486518f, -0.12706263f, -0.04538375f, 0.27712160f, 0.14380305f, -0.02889842f, 0.06568430f, 0.00048628f, 
    -0.14517213f, 0.19636385f, 0.02168935f, -0.16632885f, -0.08181169f, 0.07553637f, 0.16465978f, -0.42720500f, 
    0.19045644f, 0.29099625f, 0.03989698f, 0.03590776f, 0.10215343f, -0.08655578f, 0.09848625f, 0.06391017f, 
    0.11062916f, -0.40013531f, -0.10653538f, -0.18559681f, 0.00976668f, -0.04342049f, 0.01447145f, 0.09381423f, 
    0.00125500f, -0.06249627f, 0.17642955f, 0.01743510f, 0.15623084f, 0.01495290f, -0.06918446f, -0.21065934f, 
    -0.08645225f, 0.01250197f, -0.27238277f, -0.15903853f, -0.43714228f, 0.18702681f, 0.23719148f, 0.15312415f, 
    -0.10409123f, -0.03570554f, 0.27759612f, 0.18131274f, 0.15623479f, 0.18479609f, -0.01130013f, -0.00015703f, 
    -0.05607511f, -0.07313345f, 0.07622615f, 0.06639168f, 0.05297422f, 0.07457298f, -0.74271196f, -0.06507243f, 
    0.18154676f, 0.14422911f, -0.11924238f, 0.06513369f, 0.14869431f, 0.19320178f, 0.13169274f, -0.19662288f, 
    -0.02416761f, -0.08361209f, 0.01759890f, 0.18620215f, 0.12299832f, 0.27483711f, -0.54369479f, 0.05382163f, 
    -0.30212495f, -0.09524963f, -0.21430586f, 0.18618381f, 0.13730460f, 0.11070707f, 0.13956714f, 0.10725795f, 
    0.19975252f, -0.28588733f, 0.17927951f, -0.01692276f, 0.08957056f, -0.02772408f, -0.06098493f, -0.02641400f, 
    -0.31938156f, -0.23586445f, 0.03737905f, 0.16066794f, -0.02956361f, -0.06309201f, 0.14306146f, 0.19599716f, 
    -0.02681831f, -0.13467181f, 0.05180314f, 0.31072426f, -0.07833691f, 0.01707772f, -0.03635128f, -0.07045948f, 
    0.08091848f, 0.14001812f, -0.05612341f, 0.10641100f, -0.15846342f, 0.20722434f, 0.13334371f, -0.04774236f, 
    -0.11972732f, 0.11165954f, 0.15570010f, 0.09763511f, -0.04306952f, 0.01572991f, 0.02091875f, 0.06209148f, 
    -0.04593819f, 0.09067214f, 0.30114701f, 0.01539658f, -0.37997270f, 0.07655944f, -0.53819907f, 0.07910143f, 
    -0.09169841f, 0.29173049f, -0.15365832f, -0.12172556f, -0.06283831f, -0.03554733f, -0.10057515f, 0.27389988f, 
    0.03806681f, -0.17589158f, 0.12990527f, -0.03401201f, 0.07611363f, 0.04353992f, -0.05237154f, -0.01658055f, 
    -0.18154030f, -0.03399737f, -0.04170693f, 0.03198007f, 0.12923567f, -0.05722163f, -0.09180672f, -0.01693072f, 
    0.13076232f, -0.11895896f, 0.09728354f, 0.05313687f, -0.04489939f, -0.07550990f, 0.09866092f, 0.05525581f, 
    0.06537540f, -0.05839577f, 0.60220098f, 0.05486926f, -0.02949062f, -0.20708078f, 0.18536323f, 0.01882582f, 
    0.00773726f, -0.39043406f, 0.27082357f, 0.80593944f, 0.05447041f, 0.24484771f, -0.22527149f, 0.00820790f, 
    -0.00445302f, 0.15855074f, 0.11242515f, 0.23150153f, 0.19421031f, 0.04740632f, 0.00468646f, -0.09519149f, 
    0.03777864f, -0.01001315f, -0.02122046f, 0.07434481f, -0.26777261f, 0.06972393f, -0.07439437f, 0.13047267f, 
    -0.05536783f, 0.16936411f, -0.07564098f, 0.13540959f, 0.10195228f, 0.08810443f, -0.30341616f, 0.30466071f, 
    -0.05832318f, -0.04713096f, -0.10351671f, 0.03729119f, -0.21963331f, -0.73587203f, -0.01674045f, -0.46860927f, 
    0.03303898f, -0.04633817f, 0.11989524f, 0.06997376f, 0.27454993f, 0.05917257f, -0.21219756f, -0.08701922f, 
    -0.31314999f, 0.05259604f, -0.21662568f, 0.05073837f, -0.04088039f, -0.01706240f, 0.03922765f, 0.19116156f, 
    0.38817140f, -0.13263823f, -0.31694528f, 0.12212706f, -0.12396418f, 0.01108507f, 0.07495204f, 0.10546911f, 
    0.10615616f, -0.04570351f, 0.15159129f, -0.00668800f, -0.12297820f, 0.07628630f, 0.06376291f, -0.11373759f, 
    -0.15764073f, -0.18824510f, -0.16046204f, 0.35173023f, -0.04843556f, 0.03468461f, -0.10245884f, -0.04329440f, 
    0.11593549f, 0.17346618f, -0.08695581f, 0.15525764f, -0.24850279f, 0.15065028f, -0.13356288f, 0.04363099f, 
    0.01604680f, 0.13956079f, -0.17309946f, 0.50205141f, 0.15571932f, 0.06843410f, 0.07625504f, 0.18108141f, 
    -0.11644201f, 0.06129109f, 0.17145480f, 0.06223826f, -0.13474406f, 0.13308907f, -0.37455913f, -0.15906632f, 
    0.07043282f, 0.01998216f, -0.01445804f, -0.00790480f, -0.04216466f, -0.36867127f, -0.01540359f, -0.01595455f, 
    -0.00094363f, -0.05149861f, -0.18362999f, 0.02708231f, -0.02041372f, 0.05539615f, -0.11275359f, 0.30301544f, 
    -0.23113249f, -0.13422154f, 0.03024552f, -0.06067182f, 0.05360606f, 0.13913198f, -0.01825934f, 0.19915599f, 
    0.18701184f, 0.00117702f, 0.24422355f, -0.02178681f, 0.00634443f, 0.01044721f, 0.18894747f, 0.14446564f, 
    -0.01186076f, 0.01747869f, -0.03094699f, -0.01693425f, 0.02186982f, 0.04940724f, -0.03850183f, -0.00424926f, 
    -0.06104241f, -0.02578699f, -0.02531812f, -0.03472918f, 0.02862898f, -0.02478354f, 0.04154438f, -0.01091858f, 
    0.03613434f, -0.00495332f, -0.06170058f, 0.02573937f, -0.06227628f, 0.01233448f, 0.02877254f, -0.03998252f, 
    -0.02254452f, -0.03481092f, -0.03513473f, 0.01515183f, -0.05216736f, -0.04831382f, -0.02987415f, -0.04896479f, 
    -0.05851795f, 0.00601190f, -0.03310411f, -0.04631432f, -0.01773460f, 0.00439153f, 0.04583878f, 0.01189312f, 
    -0.05327242f, -0.04582492f, 0.03687420f, -0.00317026f, -0.03857052f, 0.04018646f, -0.03468268f, -0.05061479f, 
    -0.01203318f, 0.02725245f, -0.00530692f, -0.05953931f, -0.01163330f, -0.03500899f, -0.00006658f, 0.03964075f, 
    -0.02312080f, 0.04298610f, -0.01789127f, -0.03537427f, -0.04273301f, 0.04355345f, 0.01620744f, 0.03497013f, 
    0.03737422f, 0.01882792f, -0.04562882f, -0.01447946f, 0.05223243f, -0.05973198f, 0.02639950f, -0.02284134f, 
    -0.01713915f, 0.02285303f, -0.02963227f, 0.02550222f, -0.03670591f, 0.00298949f, 0.02813706f, 0.00747659f, 
    0.01813676f, -0.00709420f, -0.00977253f, -0.04178283f, -0.05312681f, 0.04533812f, -0.03935059f, 0.02801005f, 
    0.02299047f, 0.03714650f, 0.01033314f, 0.01090903f, -0.04984053f, -0.02319127f, 0.02984746f, 0.03738461f, 
    0.01113023f, 0.01801406f, -0.04940149f, -0.06288428f, -0.02787400f, 0.02459042f, -0.05186934f, -0.01681845f, 
    0.01070336f, -0.02149061f, -0.01977506f, -0.06241059f, 0.05048285f, -0.02253847f, -0.04353051f, -0.02594693f, 
    -0.05364588f, -0.02130750f, 0.04756605f, 0.00498805f, -0.05919118f, 0.02368593f, -0.00073963f, -0.05903416f, 
    -0.00286882f, -0.06405057f, -0.03673001f, -0.04541013f, 0.03752264f, 0.02783800f, 0.02861600f, -0.04874770f, 
    -0.00792860f, 0.02677214f, -0.05755022f, -0.01980219f, -0.02786253f, 0.02833837f, 0.05041363f, 0.02753332f, 
    -0.04005425f, -0.05915287f, -0.03757225f, -0.01228947f, -0.04357119f, -0.02706521f, 0.04733531f, -0.01408922f, 
    -0.02985009f, -0.06342959f, 0.02375997f, 0.01414081f, 0.01076789f, 0.00375406f, -0.05697516f, -0.04043814f, 
    -0.06204215f, -0.03443359f, -0.03453965f, -0.02361988f, -0.05524613f, -0.04949924f, -0.00148051f, -0.03234646f, 
    -0.00425099f, 0.00389632f, -0.03269565f, 0.04781345f, 0.00757316f, 0.01478478f, -0.02241182f, 0.01297190f, 
    -0.05043903f, 0.02755960f, 0.04171644f, 0.04522905f, -0.03020312f, -0.06179656f, -0.00953571f, -0.01290818f, 
    -0.05223785f, -0.02142465f, 0.05074521f, 0.03060873f, 0.05174644f, 0.04645162f, 0.03202943f, 0.04009265f, 
    -0.01765480f, -0.02087883f, -0.03064501f, 0.04126757f, 0.01240171f, 0.01561780f, 0.04440738f, 0.03694316f, 
    0.03574158f, 0.05183814f, -0.01535524f, -0.02230808f, 0.04853241f, 0.04462949f, -0.06419289f, -0.04831242f, 
    -0.00712348f, -0.04778941f, -0.02725278f, -0.04670243f, 0.04362530f, -0.02403275f, 0.03088151f, -0.00212474f, 
    -0.05898595f, -0.00697391f, 0.03742738f, 0.02376497f, -0.04807635f, -0.02709702f, 0.04627895f, -0.02075686f, 
    0.05156765f, -0.03420065f, 0.04366894f, -0.06318525f, 0.01054399f, -0.02674928f, 0.00860505f, 0.04462714f, 
    0.03465070f, -0.01252021f, 0.03828980f, -0.02035118f, 0.00370191f, 0.01742849f, -0.02973179f, -0.05246848f, 
    -0.00572629f, 0.01563517f, 0.03236613f, -0.06230768f, -0.00797350f, 0.02984254f, -0.00527798f, 0.02382015f, 
    -0.03205310f, -0.04229612f, -0.02113331f, -0.03289479f, -0.01164681f, 0.00931588f, 0.02086975f, 0.03289269f, 
    -0.00061313f, 0.04709417f, 0.00649359f, -0.05093026f, -0.02186533f, 0.02076759f, -0.04782448f, -0.02449918f, 
    0.00534270f, -0.03892753f, -0.01326815f, -0.02185354f, -0.00192411f, -0.02939116f, 0.00564176f, 0.00522052f, 
    -0.03928356f, -0.03248250f, -0.05468690f, 0.03365346f, -0.05741182f, -0.03311172f, -0.05931363f, -0.01779081f, 
    -0.01111490f, 0.00642987f, 0.04189298f, 0.00289025f, -0.03192442f, 0.05112334f, -0.00712317f, 0.01668790f, 
    -0.02551221f, 0.01149454f, -0.05731069f, -0.03957175f, 0.02862339f, 0.02010038f, 0.00269016f, -0.03883637f, 
    -0.55828792f, -0.03822058f, 0.28917843f, 0.18177725f, 0.02832856f, -0.01402893f, 0.12279840f, 0.07616073f, 
    0.11788591f, 0.06334385f, 0.01544700f, 0.08950919f, -0.11299866f, -0.29728597f, -0.01384460f, -0.03089824f, 
    0.02068529f, 0.07972445f, -0.04653220f, -0.10108953f, -0.03515126f, 0.03739987f, 0.01056490f, 0.29806274f, 
    0.07846274f, 0.07188749f, -0.07586215f, -0.04454847f, 0.15158555f, -0.50732481f, -0.03388032f, 0.07636505f, 
    -0.06550453f, 0.23649362f, 0.08470756f, -0.00239857f, -0.27925014f, -0.38694909f, -0.23208968f, 0.12623377f, 
    0.02342589f, 0.18390122f, 0.40425113f, -0.28516740f, -0.17443594f, 0.32547536f, 0.25933233f, -0.11915710f, 
    0.02130347f, -0.19245984f, -0.04888436f, 0.06317183f, 0.07162301f, 0.03878037f, -0.32846630f, -0.00211459f, 
    0.10781182f, -0.14606300f, 0.11260508f, 0.03572960f, -0.09103813f, -0.00241272f, -0.08703482f, -0.06614542f, 
    -0.52225524f, 0.02124687f, -0.21540549f, 0.09693911f, -0.01048344f, -0.20418413f, -0.01074533f, -0.14096083f, 
    0.17055842f, 0.38316959f, 0.42952698f, -0.03636331f, -0.22097312f, -0.21866068f, 0.04708894f, 0.19859575f, 
    0.09134081f, 0.05512813f, 0.11157463f, -0.34100333f, 0.03872263f, -0.01108824f, 0.15299779f, -0.00840973f, 
    -0.08056526f, 0.02674031f, 0.17588909f, 0.07076278f, 0.26597846f, -0.10463294f, -0.03286563f, 0.04480998f, 
    0.10841289f, 0.12366299f, 0.08111314f, 0.09546629f, 0.25153482f, -0.26303348f, -0.05404919f, 0.08037776f, 
    -0.03648980f, 0.11948930f, -0.00295981f, -0.03657158f, -0.09207334f, -0.06918697f, -0.04237382f, 0.23752894f, 
    -0.19530426f, 0.16730268f, 0.01389471f, -0.01791545f, 0.16613626f, -0.11741084f, 0.17716563f, -0.03928272f, 
    -0.00322244f, 0.17054194f, 0.12803030f, 0.11979561f, -0.23723152f, 0.00402440f, -0.39545074f, 0.06938369f, 
    0.04791664f, 0.17586844f, -0.09438304f, 0.12924728f, 0.15149431f, -0.15016931f, -0.06081153f, 0.17173463f, 
    0.18956415f, -0.38138717f, -0.03242525f, 0.02533321f, 0.04863989f, -0.00697846f, 0.01542711f, -0.02645597f, 
    0.04599806f, 0.10864796f, -0.34682721f, 0.21376207f, 0.08683912f, 0.06415199f, 0.19819558f, -0.15252343f, 
    0.09243526f, 0.37789631f, 0.34059632f, -0.04071087f, 0.25706619f, 0.04827012f, -0.05209615f, -0.05825062f, 
    0.06646962f, 0.07622734f, -0.16502723f, 0.00324246f, 0.05180907f, 0.14968446f, 0.23653439f, 0.15001692f, 
    -0.04068008f, -0.19564296f, 0.16530980f, -0.38195217f, -0.55931973f, -0.05335983f, -0.20576556f, 0.02355751f, 
    -0.02418952f, -0.03844398f, 0.03028021f, 0.16858055f, -0.20949249f, 0.14933336f, -0.63507438f, -0.03732424f, 
    -0.12839016f, -0.14843692f, -0.16016451f, -0.11134958f, -0.05178521f, 0.04227991f, 0.08840474f, 0.31676996f, 
    -0.01097679f, -0.32457292f, 0.03515121f, 0.22101083f, 0.11721505f, 0.23123285f, 0.06488349f, 0.22525117f, 
    0.13483071f, 0.13686049f, -0.01692301f, -0.01649770f, 0.10450153f, 0.07445873f, 0.09952949f, -0.24427857f, 
    0.08322919f, -0.36857954f, 0.01557533f, 0.11234547f, 0.07277030f, 0.01201357f, 0.03553707f, 0.09665219f, 
    0.12755762f, 0.20183860f, -0.38348597f, 0.07172091f, 0.10857689f, 0.03569208f, -0.07719170f, -0.06631953f, 
    -0.01952143f, -0.14160030f, -0.12782250f, 0.00041290f, 0.10706753f, 0.06832097f, 0.07490872f, 0.08734202f, 
    -0.00034460f, -0.17508827f, -0.01834955f, 0.12807800f, -0.47488257f, 0.12490908f, -0.04758697f, 0.08481143f, 
    0.06432299f, -0.14308679f, -0.00305706f, -0.39100906f, 0.47127697f, 0.26465958f, 0.29250857f, -0.07741906f, 
    -0.07299335f, 0.01771555f, 0.03200236f, -0.33828348f, -0.42554283f, 0.10126826f, 0.27881017f, -0.01204290f, 
    -0.03478825f, 0.10828182f, -0.00676464f, 0.15040918f, 0.21614136f, -0.24429721f, -0.33973342f, -0.33258915f, 
    0.04321171f, -0.07748840f, 0.08457565f, -0.22447455f, 0.05747872f, -0.09824238f, 0.05770307f, -0.12048647f, 
    -0.50109577f, -0.08703300f, -0.22604540f, -0.03446290f, -0.10254909f, -0.08607598f, 0.09543834f, 0.00789627f, 
    0.28283978f, 0.14258149f, 0.03414818f, 0.01576216f, -0.17996895f, -0.00100413f, 0.08616408f, -0.15478709f, 
    0.00926752f, -0.00742383f, 0.03084574f, 0.04346631f, -0.03967056f, -0.01331632f, -0.05853397f, -0.01306728f, 
    0.04044495f, 0.01478181f, 0.04460893f, -0.02460760f, 0.02393886f, 0.01902179f, 0.01523896f, -0.03583863f, 
    -0.03981533f, -0.00713262f, 0.04745476f, -0.01674487f, -0.03405745f, -0.02403175f, -0.04000400f, 0.05254725f, 
    -0.01417300f, 0.04356859f, 0.02353963f, -0.02128551f, -0.04042932f, -0.03331968f, -0.03356635f, -0.00167038f, 
    -0.02488711f, 0.05226948f, 0.02328659f, 0.00049248f, -0.01360565f, -0.04675328f, -0.04829615f, 0.03791118f, 
    -0.04701234f, 0.01515812f, -0.02805123f, -0.05540819f, 0.00087881f, -0.00358893f, -0.00916012f, 0.02414991f, 
    -0.00581109f, -0.00901596f, -0.01654865f, -0.01483321f, -0.00818146f, -0.00818273f, 0.02301419f, 0.01551411f, 
    -0.05942394f, 0.02480021f, 0.03426579f, -0.04708066f, 0.03965905f, 0.04834384f, 0.02676570f, 0.01782003f, 
    -0.02488682f, 0.02064015f, -0.00025698f, 0.02195186f, -0.03013797f, 0.04490411f, -0.04613497f, -0.00364886f, 
    -0.03193255f, -0.01171768f, -0.03248943f, -0.01452420f, 0.04415891f, 0.00813564f, -0.03206559f, 0.01525711f, 
    0.02408663f, 0.02919484f, 0.01695252f, -0.00623713f, 0.03142498f, -0.00438345f, -0.02289272f, -0.04689922f, 
    0.00936766f, 0.00551179f, -0.03872733f, 0.00383401f, -0.03405253f, -0.04431568f, -0.06224022f, -0.00597269f, 
    -0.02206909f, 0.03760535f, -0.00035076f, -0.02239225f, -0.02547727f, -0.06115048f, -0.03999356f, -0.04927611f, 
    -0.05994950f, 0.00822908f, -0.03041940f, -0.01278131f, -0.06434981f, -0.00618753f, 0.00454874f, -0.00102825f, 
    -0.05602328f, 0.01495668f, -0.02866229f, 0.02604529f, 0.04703432f, -0.00566997f, -0.00319898f, -0.04739177f, 
    0.04613701f, 0.00903041f, 0.01747016f, 0.00553708f, -0.02970752f, -0.02782663f, -0.04778865f, -0.01313665f, 
    -0.05304606f, 0.00335211f, -0.01930440f, 0.03245476f, 0.02942566f, -0.01506343f, -0.06207773f, -0.04179142f, 
    0.05285085f, -0.05067055f, 0.02034641f, 0.04266175f, -0.00162305f, -0.04701583f, 0.00151815f, 0.01941689f, 
    -0.02133207f, 0.03539653f, -0.02258473f, 0.01754364f, -0.02552076f, -0.05030462f, -0.01609130f, -0.04396914f, 
    -0.00225509f, -0.01458045f, 0.01080003f, -0.04611242f, 0.03964534f, 0.04470513f, -0.06404752f, 0.00581272f, 
    0.02423595f, -0.06190495f, 0.01451670f, -0.06349596f, 0.02867299f, -0.05013742f, -0.00829901f, -0.03392424f, 
    0.00267721f, -0.04169374f, 0.03961959f, 0.01392966f, 0.02040104f, -0.01776248f, 0.04516205f, -0.05342542f, 
    -0.04952321f, 0.02022649f, -0.06448926f, -0.00701174f, 0.01461254f, 0.01194877f, 0.04455954f, 0.03847338f, 
    -0.06148802f, -0.02237947f, -0.05097263f, 0.02377342f, -0.04338706f, 0.02267127f, 0.04001842f, -0.03741509f, 
    0.00330874f, -0.05598885f, -0.01516981f, -0.00956726f, 0.03300679f, -0.01331102f, 0.03884312f, -0.00422471f, 
    -0.06026337f, 0.02322904f, 0.01754441f, -0.05156681f, 0.01619922f, -0.02280863f, -0.05057348f, -0.04206082f, 
    -0.06252894f, 0.00865654f, -0.02728190f, 0.02263071f, -0.03511992f, 0.04180614f, -0.04285077f, -0.00805317f, 
    -0.03654572f, 0.01532010f, -0.03871796f, -0.06111586f, -0.03215855f, -0.05612895f, -0.04111497f, -0.02300107f, 
    0.04529616f, 0.03468344f, -0.02697640f, 0.02203659f, 0.00784445f, -0.04735620f, -0.04664556f, -0.03390201f, 
    0.01144786f, -0.00469317f, -0.00553046f, -0.04048638f, -0.00274445f, -0.04707032f, -0.03176204f, -0.02384748f, 
    -0.02801604f, -0.00530468f, -0.05163604f, -0.06421070f, 0.05030982f, 0.00496881f, 0.02427747f, -0.03635227f, 
    -0.01608462f, -0.00547497f, 0.00920608f, -0.02943883f, 0.00431577f, 0.04721036f, 0.01895138f, -0.02020131f, 
    -0.05506768f, 0.00184017f, -0.03606856f, 0.03906455f, -0.00667909f, -0.00133081f, 0.02128181f, -0.02102740f, 
    0.02778066f, -0.05834644f, 0.03384460f, 0.02266396f, -0.03535516f, 0.00041775f, -0.04001531f, 0.00605308f, 
    0.00677705f, 0.03407781f, -0.05795992f, 0.02206169f, 0.03832938f, -0.02031108f, -0.03937834f, 0.04987136f, 
    0.00142117f, -0.00878238f, 0.02869571f, -0.02126019f, -0.04308796f, -0.01753681f, -0.06071564f, -0.04785227f, 
    0.00438972f, -0.00042505f, -0.01820591f, 0.04582415f, -0.03155410f, 0.03838383f, 0.04854661f, -0.04362398f, 
    0.04181449f, 0.04703122f, -0.03777808f, -0.01705764f, -0.04553910f, -0.03113184f, 0.01014051f, -0.01150371f, 
    -0.05935821f, 0.01144205f, -0.03600596f, 0.04544071f, -0.06260582f, -0.04534972f, -0.02824866f, -0.00121270f, 
    0.04128493f, 0.02517496f, -0.04478115f, 0.04166526f, 0.02644704f, -0.03200661f, -0.05166737f, 0.02612508f, 
    0.00164420f, 0.03117188f, -0.04193551f, -0.03885436f, 0.01834338f, 0.03373294f, -0.06537542f, -0.03114353f, 
    -0.02236135f, 0.03060089f, -0.04365005f, -0.03645602f, -0.02415970f, 0.00782596f, -0.02835138f, -0.00502598f, 
    -0.04670827f, -0.06558685f, 0.04426473f, -0.06155968f, -0.00018327f, -0.01785368f, 0.01788450f, -0.01803254f, 
    -0.01559809f, -0.01164355f, -0.01814530f, -0.03037111f, -0.01713412f, -0.04606627f, 0.03293903f, 0.01608518f, 
    -0.04977627f, 0.00801990f, -0.00992162f, 0.00105520f, -0.04511668f, -0.02865751f, -0.03870725f, -0.00094715f, 
    0.01942225f, 0.05691504f, -0.01137201f, 0.01650565f, -0.05723353f, 0.04527742f, -0.04404822f, -0.03298706f, 
    -0.00972213f, -0.01034314f, 0.00328935f, -0.02325580f, -0.04005603f, -0.03210543f, 0.01631924f, -0.05959797f, 
    0.05429150f, 0.01167085f, -0.03762557f, 0.03398115f, 0.01459546f, -0.00856709f, 0.02970494f, 0.04961475f, 
    0.02054437f, -0.01349117f, -0.00387639f, -0.00564546f, -0.05666493f, -0.00290562f, -0.05492764f, -0.02356718f, 
    0.01984529f, 0.03504733f, -0.02718373f, -0.00857882f, 0.01918065f, -0.03738980f, -0.05042310f, -0.03622322f, 
    0.04582381f, 0.02332483f, -0.05523726f, 0.05484607f, 0.01532046f, -0.05522332f, -0.05168459f, -0.02067308f, 
    -0.04776787f, 0.01542993f, -0.04746580f, 0.03449577f, -0.00109650f, -0.01476828f, -0.01650795f, -0.01261003f, 
    0.05245118f, 0.00171155f, 0.00178121f, 0.04344954f, 0.03064621f, -0.00956413f, 0.00280829f, 0.00458554f, 
    0.03350138f, -0.00196217f, 0.02740812f, -0.00507194f, 0.04188405f, 0.01945236f, -0.04731854f, -0.03907815f, 
    0.00915558f, -0.03811054f, -0.02315076f, 0.04223707f, -0.05791685f, -0.00155901f, 0.00307403f, -0.00945558f, 
    -0.03008854f, -0.01767956f, -0.01708170f, -0.03636900f, -0.02589254f, 0.00424368f, -0.00562200f, -0.03222695f, 
    0.00239123f, -0.04899642f, -0.00047179f, -0.01200163f, -0.01294615f, -0.05900586f, -0.01250411f, -0.03916259f, 
    -0.05036543f, 0.03458618f, 0.04308313f, 0.00168292f, -0.05318210f, -0.01494646f, -0.03836529f, -0.02916555f, 
    -0.02872066f, 0.04288711f, 0.04255104f, 0.04640477f, 0.03672245f, -0.04655653f, -0.06533384f, 0.02216882f, 
    -0.03870840f, 0.01383905f, -0.03240382f, 0.04206704f, -0.00271340f, 0.00884769f, 0.03074655f, 0.02504265f, 
    0.04260800f, -0.05299423f, 0.04968699f, -0.04825043f, 0.01513535f, 0.05041993f, -0.03659777f, 0.03411625f, 
    -0.02738296f, 0.03073029f, 0.02608387f, 0.02921326f, 0.00162347f, -0.01252128f, -0.01496033f, -0.03341412f, 
    0.03554397f, 0.03346798f, -0.06155339f, -0.01472663f, 0.02136878f, -0.02614696f, -0.04623615f, 0.00269029f, 
    -0.03967675f, -0.06090647f, 0.02316540f, -0.05206397f, -0.02271207f, -0.00433498f, 0.05077343f, -0.00057768f, 
    0.02860942f, -0.04705927f, -0.06282973f, -0.00691069f, -0.05465991f, 0.00447527f, -0.01806166f, -0.05014200f, 
    -0.04958305f, -0.06213566f, 0.00455393f, -0.06670170f, 0.03352147f, -0.02902574f, -0.03423345f, 0.00373349f, 
    -0.00288848f, 0.01871229f, 0.03607121f, -0.05184189f, -0.04877363f, 0.00463390f, 0.02461568f, 0.04125350f, 
    -0.01013896f, -0.01955253f, 0.04691879f, 0.00130096f, 0.05339598f, 0.04075959f, -0.03516973f, 0.02677205f, 
    0.01726165f, -0.06293049f, -0.04392720f, 0.03544164f, -0.00890906f, 0.03765986f, -0.05106650f, -0.01827877f, 
    0.05085654f, 0.03402693f, -0.00703061f, -0.00321371f, -0.03585006f, -0.02974609f, -0.01753271f, 0.04343750f, 
    0.01398132f, 0.04697844f, -0.00198581f, -0.03670245f, -0.02364279f, 0.03884466f, -0.00188917f, -0.03393673f, 
    0.03062568f, 0.01650121f, 0.02942088f, 0.00162632f, 0.03240895f, -0.00878992f, -0.04156420f, -0.03518561f, 
    0.22561480f, -0.04873605f, -0.26148909f, -0.02423679f, -0.07979745f, -0.02193433f, 0.05664347f, 0.00901871f, 
    0.02013233f, -0.01807689f, 0.32360417f, -0.08683687f, 0.15532821f, 0.09021424f, -0.26287657f, -0.23620260f, 
    0.08338728f, -0.05971117f, -0.21802413f, 0.24949683f, -0.08986263f, 0.19111398f, 0.05484074f, -0.15671957f, 
    0.00313177f, 0.10027380f, -0.05667331f, 0.11103666f, -0.41416311f, 0.11222561f, 0.05275211f, 0.05584563f, 
    -0.00381781f, 0.02471324f, -0.04974850f, 0.18846405f, -0.41372392f, -0.07014851f, -0.07342760f, 0.20698090f, 
    0.13406007f, 0.03008889f, -0.05915515f, -0.11449071f, -0.09434039f, 0.28341934f, -0.20556277f, -0.03987218f, 
    -0.00784788f, 0.00531767f, -0.04261069f, 0.11237147f, 0.28672618f, -0.02479760f, -0.30062890f, -0.02425070f, 
    0.17575097f, -0.31408045f, 0.00567603f, -0.07797797f, 0.19531575f, 0.05700072f, 0.06159169f, -0.09695351f, 
    -0.24083643f, 0.03064279f, -0.16180393f, 0.00823429f, -0.14120129f, 0.08981599f, 0.07700235f, 0.01366776f, 
    -0.04042282f, 0.32033229f, -0.09624732f, 0.19751281f, 0.02590153f, -0.03215441f, -0.10937958f, 0.06339399f, 
    -0.00889203f, -0.27233213f, 0.12374530f, 0.19089468f, -0.09871776f, -0.04795882f, 0.18889597f, 0.02479308f, 
    -0.02133692f, -0.17494377f, 0.23431236f, 0.13189983f, -0.09041330f, 0.23692665f, -0.11277872f, -0.08550572f, 
    0.07710104f, 0.06932782f, 0.09836309f, 0.02751401f, -0.12496527f, -0.07400410f, 0.05774737f, 0.10328375f, 
    -0.02685600f, -0.04176852f, 0.14774343f, 0.15761147f, -0.47141257f, 0.23923148f, 0.19940452f, 0.16943702f, 
    0.03531487f, 0.03572382f, 0.23027182f, -0.03441773f, 0.05079645f, -0.24177450f, -0.08704776f, 0.23332566f, 
    -0.19909637f, 0.15933567f, 0.03325567f, 0.11274225f, 0.03864528f, 0.14102077f, 0.10055494f, -0.19341792f, 
    0.02799084f, 0.02095370f, 0.21258421f, 0.05480734f, -0.18470450f, 0.02263469f, -0.10747828f, -0.08479585f, 
    -0.07756837f, 0.01484713f, 0.02840838f, -0.03953556f, -0.07194932f, 0.25759313f, -0.13705164f, 0.07488111f, 
    -0.06040100f, -0.15994084f, 0.26407397f, 0.02616062f, 0.00333803f, -0.01472271f, -0.11541429f, -0.06589536f, 
    0.19035262f, -0.00381726f, 0.06867047f, 0.25264135f, 0.03520378f, -0.17979859f, -0.08278336f, -0.20037594f, 
    -0.08352342f, 0.01912090f, 0.10145209f, -0.03287498f, 0.28474861f, 0.18069848f, -0.04366218f, 0.06604976f, 
    -0.17811865f, 0.00828342f, 0.15430364f, -0.39320496f, 0.23228790f, -0.24824826f, -0.16513558f, -0.14949618f, 
    -0.15384057f, 0.05395539f, 0.11696018f, -0.10614839f, 0.01466204f, -0.18226828f, 0.27627915f, 0.16085356f, 
    -0.06413698f, -0.09660588f, 0.04085587f, 0.01295012f, -0.08924068f, -0.62378109f, 0.22133668f, -0.03796076f, 
    0.23572837f, 0.02655763f, -0.04625543f, 0.07461761f, 0.12135375f, -0.05945169f, -0.03064837f, 0.14914867f, 
    0.06050598f, 0.00531205f, -0.13869263f, -0.01041741f, -0.16173172f, 0.04158770f, -0.01415968f, 0.28489098f, 
    -0.06240021f, -0.24066041f, -0.14496596f, 0.00443557f, 0.03279146f, 0.02567517f, 0.25349799f, -0.13970934f, 
    -0.02954930f, -0.16889787f, 0.13338460f, 0.06432284f, 0.13681933f, -0.04683451f, 0.05296854f, 0.04609860f, 
    0.12783009f, 0.27753195f, 0.05750513f, 0.37513471f, 0.09010590f, -0.10771070f, -0.11583971f, 0.13245748f, 
    -0.10469247f, -0.04820817f, 0.35311839f, 0.01647130f, 0.27938426f, -0.05306476f, -0.03446933f, -0.04668919f, 
    -0.15760449f, -0.06308709f, -0.12225179f, 0.25510868f, -0.32184348f, -0.26613817f, 0.07705902f, -0.05105513f, 
    0.13123828f, -0.08339168f, -0.01154468f, 0.10188337f, -0.28464371f, 0.19224922f, -0.02543461f, -0.19415814f, 
    -0.06999780f, -0.05056874f, -0.17973682f, 0.16699547f, 0.06285107f, -0.28553182f, -0.25602949f, -0.20648034f, 
    -0.19250232f, 0.14207204f, -0.21138903f, 0.02589538f, 0.18676637f, 0.06753583f, -0.01612028f, 0.10115687f, 
    -0.05686634f, 0.01911244f, -0.06347912f, -0.04179129f, 0.10397780f, 0.23683037f, -0.10084426f, 0.30161247f, 
    -0.12788996f, -0.21090053f, 0.14113599f, 0.18473245f, 0.08107955f, 0.15588340f, 0.07791819f, 0.00580399f, 
    0.14344327f, -0.04998541f, -0.29023051f, 0.02125401f, 0.01361303f, -0.28283161f, -0.02674097f, 0.14437738f, 
    0.15064128f, -0.16015331f, 0.13848549f, -0.01804495f, -0.14078021f, -0.20254797f, 0.20372614f, -0.03658565f, 
    0.16823217f, 0.06655547f, -0.23638459f, 0.03428002f, -0.24905908f, -0.12200058f, 0.13108647f, 0.01362972f, 
    0.16875044f, 0.07738189f, -0.04104211f, 0.01320051f, 0.11462253f, -0.08605690f, 0.06335668f, 0.03822111f, 
    0.02352245f, -0.03450485f, -0.08632329f, 0.05198506f, 0.10340318f, -0.13856246f, -0.10281119f, 0.21953610f, 
    0.16753617f, 0.15241286f, -0.12775575f, -0.17478512f, -0.11825681f, 0.09939325f, 0.05128329f, -0.05173989f, 
    -0.05005027f, 0.19061470f, 0.00901307f, 0.05528156f, -0.02462425f, 0.26456863f, -0.08622140f, 0.06913646f, 
    -0.14779012f, -0.08856103f, 0.12537356f, 0.02483806f, -0.36854231f, 0.15470344f, -0.29365018f, 0.46255714f, 
    0.01698656f, -0.16572826f, 0.14513181f, 0.35717356f, 0.13728032f, -0.47440314f, 0.00390856f, -0.00075069f, 
    0.06073043f, -0.14020886f, -0.27455926f, -0.13028844f, -0.10975609f, 0.25350314f, 0.05161887f, 0.12324561f, 
    0.06613461f, 0.26174170f, -0.25303620f, -0.20116144f, -0.10448152f, -0.19294143f, 0.18820164f, 0.07215342f, 
    -0.13173214f, 0.00178518f, -0.31827530f, -0.17770566f, -0.23513804f, 0.07097347f, 0.08762168f, -0.01642714f, 
    -0.05676426f, -0.01798253f, 0.19016190f, 0.12582602f, 0.03837813f, -0.02283316f, 0.14538318f, 0.06380195f, 
    -0.12787448f, -0.11619110f, -0.03197684f, 0.17395270f, -0.10825691f, -0.15769275f, -0.18780279f, -0.08096246f, 
    -0.08578201f, -0.07353190f, -0.12160591f, 0.06620264f, -0.16508287f, 0.34181711f, 0.21254565f, -0.05117664f, 
    0.09231080f, -0.20050228f, 0.21696103f, 0.08898475f, -0.16156517f, 0.01883868f, -0.19219798f, 0.18613978f, 
    0.25089660f, -0.17201632f, -0.02912286f, -0.07802460f, 0.03974407f, -0.14983524f, -0.02910760f, 0.12389252f, 
    0.26052403f, -0.15273006f, 0.01243994f, 0.02875308f, 0.15740512f, -0.13015004f, 0.14298221f, 0.07555588f, 
    0.53405315f, 0.10658635f, 0.40753859f, 0.00169811f, -0.03624284f, 0.05565808f, 0.15028211f, 0.16789161f, 
    -0.03643309f, 0.37993884f, 0.12147187f, 0.13169838f, -0.15642697f, 0.07779806f, -0.10817303f, 0.22071473f, 
    0.08187227f, -0.00718249f, 0.31062293f, -0.04454302f, 0.14803588f, 0.00544302f, -0.09931500f, 0.01156418f, 
    0.06577759f, -0.11145982f, -0.03097714f, 0.05257286f, -0.24760745f, -0.04451329f, 0.06510579f, -0.25772288f, 
    -0.01667686f, -0.06693878f, -0.01616435f, 0.15091236f, -0.01100763f, -0.06889740f, -0.11510807f, 0.01653600f, 
    0.14664832f, 0.12735377f, -0.02782137f, 0.11044473f, -0.07716925f, -0.14206578f, -0.02843401f, -0.13656443f, 
    -0.21632801f, -0.12005420f, 0.21081463f, -0.18988091f, -0.11059027f, 0.07842647f, 0.11214752f, -0.08635533f, 
    -0.14277813f, -0.15111740f, 0.18824229f, 0.01892313f, -0.03498793f, -0.05315534f, -0.11793677f, -0.20892757f, 
    0.11321769f, -0.02114477f, -0.00167853f, 0.06667148f, 0.21271800f, 0.26386669f, 0.06318593f, 0.11470084f, 
    0.30912629f, 0.24099062f, -0.04596506f, -0.18879531f, -0.07129268f, 0.10443801f, 0.10697248f, 0.14721909f, 
    -0.06425829f, 0.13912308f, -0.18324049f, 0.07652435f, 0.09120076f, 0.05435774f, 0.03283747f, -0.00094889f, 
    -0.08419035f, 0.08309134f, -0.17224695f, 0.01110950f, -0.15418845f, -0.27088264f, -0.00579443f, 0.19123872f, 
    -0.08227102f, 0.12355538f, -0.17739251f, 0.06027756f, 0.34837732f, -0.07230799f, 0.06611685f, 0.06677212f, 
    -0.19915847f, 0.10969484f, 0.01594527f, 0.24539058f, 0.21005668f, 0.01553903f, -0.11559653f, -0.07573201f, 
    0.19172445f, 0.03714952f, 0.01896331f, 0.07667764f, -0.09275440f, -0.15411191f, 0.12426715f, 0.02962858f, 
    0.00338353f, -0.08042651f, 0.04488653f, 0.12355246f, 0.16910015f, -0.05094655f, -0.32620296f, -0.21000266f, 
    0.01262587f, -0.05546426f, -0.04066603f, -0.00067521f, 0.07559277f, -0.01820028f, 0.08125956f, -0.05896522f, 
    -0.07770921f, -0.12486201f, 0.09387966f, 0.09764161f, -0.10571496f, -0.03170388f, -0.15125126f, 0.27498797f, 
    -0.35169518f, -0.23213150f, 0.16104954f, -0.07304270f, 0.15650627f, -0.01117310f, -0.07081656f, 0.12606440f, 
    0.21379459f, 0.32760334f, 0.15484346f, 0.05680503f, -0.27896145f, -0.00454986f, -0.00031953f, 0.07873454f, 
    0.08466307f, 0.03420733f, 0.04752809f, 0.20497870f, -0.01764127f, -0.04916328f, -0.14280087f, 0.02739345f, 
    -0.02347730f, -0.05296896f, -0.13791595f, -0.13468350f, 0.06550596f, -0.35789403f, -0.23353729f, 0.18786441f, 
    0.17270951f, 0.25915909f, 0.02405359f, 0.12106036f, 0.15030777f, -0.36399555f, -0.05560509f, -0.03879105f, 
    0.33540425f, -0.00465631f, 0.00698300f, -0.32084078f, 0.11845729f, -0.06498341f, 0.05461638f, 0.28192535f, 
    -0.34817147f, -0.00354202f, -0.07495792f, -0.07397417f, 0.11196673f, 0.02446238f, -0.09040665f, -0.14154685f, 
    -0.00982890f, -0.01240409f, -0.03251499f, 0.09730533f, -0.13514355f, -0.13340573f, -0.05155221f, 0.53005564f, 
    -0.03861208f, 0.02422623f, 0.22481282f, 0.05337651f, 0.00887983f, 0.07173328f, -0.03949401f, 0.07252157f, 
    0.23342474f, 0.12146537f, 0.20977885f, -0.09515051f, -0.13122113f, 0.07184944f, 0.10043067f, -0.09337351f, 
    0.07103967f, -0.04773891f, -0.09977447f, -0.03951391f, -0.17789766f, 0.20737042f, -0.21040505f, 0.00203407f, 
    0.06159312f, 0.03904866f, 0.16144063f, 0.23330133f, 0.25165164f, -0.16195135f, 0.21325961f, -0.01346014f, 
    -0.02935262f, 0.07302429f, 0.01551520f, -0.13816200f, -0.00194314f, -0.05059502f, 0.03926475f, -0.07429111f, 
    0.05895530f, -0.03190987f, 0.20447533f, 0.02662132f, 0.09308434f, 0.08704127f, -0.18528746f, -0.00248605f, 
    -0.09426904f, -0.15494920f, 0.02410348f, 0.12860687f, 0.28473020f, 0.26486143f, -0.11941281f, -0.16267245f, 
    -0.07110263f, 0.19395645f, 0.11420065f, 0.08422734f, -0.01928868f, -0.08140503f, -0.29822376f, 0.19957198f, 
    0.19204366f, 0.13746235f, 0.04074837f, -0.15202883f, 0.05686641f, -0.00838069f, -0.05224220f, 0.40276322f, 
    0.09136202f, 0.08433671f, -0.11111349f, 0.12417108f, -0.34678027f, 0.00785147f, -0.04124271f, 0.17004350f, 
    0.21048462f, 0.18599378f, -0.47556484f, 0.02157025f, -0.07246648f, -0.03559864f, 0.18143976f, 0.07623477f, 
    -0.08659675f, -0.08294128f, 0.23473580f, -0.23742853f, -0.09769830f, 0.13964134f, 0.05944854f, 0.13002110f, 
    -0.14048423f, 0.12642454f, 0.04475985f, -0.09682801f, -0.11490000f, 0.04496640f, 0.09250382f, 0.01717856f, 
    -0.08044561f, 0.11180916f, -0.07994430f, -0.71055585f, 0.14794022f, -0.46070677f, 0.05372983f, -0.08647642f, 
    0.04941889f, -0.05717811f, -0.12664968f, 0.02765234f, 0.00739319f, -0.31459346f, 0.01928347f, -0.06570429f, 
    0.10850629f, -0.22956318f, 0.03816690f, -0.13934176f, 0.05115663f, -0.03517748f, 0.06062271f, 0.05539740f, 
    -0.17751522f, 0.24899900f, 0.16626778f, 0.08259784f, 0.01336773f, 0.06443954f, 0.03792956f, -0.05286244f, 
    0.19994402f, 0.03144131f, -0.12726147f, 0.02233504f, 0.36202660f, 0.13920105f, -0.00631375f, 0.15038939f, 
    -0.00745742f, 0.26893246f, -0.13195895f, 0.14889158f, -0.06185683f, 0.11070545f, -0.11878292f, -0.02092137f, 
    0.12691535f, -0.28276145f, -0.42049977f, 0.14115061f, 0.01056216f, 0.10507339f, 0.12608780f, -0.01027037f, 
    0.00370089f, -0.44163248f, -0.00453697f, -0.13104028f, -0.00481202f, 0.04323026f, 0.11184232f, -0.23107415f, 
    0.19423427f, 0.10795261f, -0.09595511f, -0.32337937f, 0.30777180f, -0.10340269f, 0.02183377f, -0.17817561f, 
    0.18524870f, -0.15880033f, -0.14386696f, -0.41468489f, -0.08328619f, 0.50431937f, 0.16180331f, 0.28821474f, 
    -0.13396280f, -0.05290162f, 0.06092446f, 0.01380424f, -0.07784974f, -0.02106556f, -0.06429373f, 0.23981459f, 
    0.04625685f, -0.03731516f, 0.21331431f, -0.01668356f, 0.06017996f, -0.21103752f, -0.02181252f, -0.29184490f, 
    0.07652993f, -0.24651273f, 0.09003726f, -0.04393332f, 0.01610386f, 0.16777882f, -0.00868124f, -0.07006162f, 
    0.05744959f, -0.23077087f, -0.25294271f, 0.00795792f, -0.11060110f, -0.09582201f, -0.15800744f, -0.04679080f, 
    0.21017706f, 0.23573275f, -0.00964359f, -0.04592364f, -0.01109374f, 0.05576281f, -0.00774626f, -0.01059933f, 
    0.10554787f, -0.15776667f, 0.00723599f, -0.11615495f, -0.01057755f, 0.02489002f, 0.07806679f, -0.01079722f, 
    -0.06599952f, 0.18023580f, 0.20194638f, -0.15250516f, 0.33578932f, 0.15662128f, 0.13160071f, 0.01257984f, 
    -0.15201931f, -0.11726897f, 0.61287212f, 0.21033564f, 0.10845080f, -0.06814252f, 0.07775833f, 0.00289214f, 
    -0.05005822f, -0.28402734f, 0.19703005f, 0.20982662f, 0.05769473f, 0.23366828f, -0.02506977f, -0.13080302f, 
    -0.09554515f, 0.03504087f, 0.02021760f, -0.03425263f, -0.03386356f, 0.29363412f, 0.10557704f, -0.18999000f, 
    -0.18864135f, 0.13931587f, -0.33934000f, 0.09210808f, 0.02617789f, -0.23572078f, -0.11252353f, -0.09848174f, 
    -0.00438618f, 0.03628479f, 0.26435372f, -0.08468649f, 0.07488406f, -0.08639342f, 0.19190863f, 0.37551862f, 
    -0.15218894f, 0.02763041f, -0.14529462f, -0.17089735f, -0.00935935f, 0.19330689f, -0.11931910f, 0.04749027f, 
    0.23156981f, 0.12001717f, 0.08981698f, -0.06820530f, -0.19475800f, -0.25510064f, 0.22083931f, -0.20538315f, 
    0.14670047f, 0.15607059f, -0.14965045f, 0.31425300f, 0.26694605f, -0.00456372f, -0.02812355f, -0.05394736f, 
    -0.20300078f, 0.17868368f, 0.13993308f, -0.06677879f, -0.47414503f, 0.11959795f, -0.05839658f, 0.03602684f, 
    0.07163929f, 0.09493916f, -0.25521028f, -0.18484750f, -0.20188324f, 0.12407075f, 0.17774840f, 0.07923662f, 
    0.19202274f, -0.17288938f, -0.29455841f, -0.26480526f, -0.00270709f, 0.08161631f, 0.00886945f, 0.14966308f, 
    0.14329417f, -0.04580016f, -0.00883212f, -0.16725254f, 0.30410436f, 0.28135172f, 0.13171543f, 0.07192482f, 
    -0.00750732f, -0.18447366f, -0.09200819f, -0.13446449f, 0.02440285f, 0.32617912f, -0.03528211f, 0.14496303f, 
    -0.03993299f, -0.22772804f, -0.21598350f, -0.11430990f, 0.13896574f, -0.02727650f, -0.15255652f, 0.06563672f, 
    -0.16843773f, 0.00414768f, 0.00340419f, 0.01763723f, -0.04320627f, -0.07349482f, 0.09700636f, -0.06490800f, 
    0.00142380f, -0.05243309f, -0.02616493f, 0.04157978f, -0.07361553f, -0.01925401f, -0.07448044f, -0.19210382f, 
    -0.23788801f, -0.06918437f, 0.18310635f, -0.34147984f, -0.04892629f, 0.25432611f, -0.10249986f, 0.11859792f, 
    0.25147775f, 0.31489354f, -0.10776696f, -0.12433846f, -0.40048152f, -0.13781337f, -0.45230481f, -0.00717285f, 
    -0.06763957f, -0.03983868f, 0.24568930f, 0.01341861f, 0.09677014f, -0.33583334f, 0.08661216f, 0.05763023f, 
    0.06384014f, -0.00824593f, 0.03399137f, 0.30132172f, 0.13667671f, 0.13956751f, 0.02306274f, 0.15462621f, 
    -0.08767439f, 0.10163066f, -0.08228499f, -0.04843697f, 0.09062658f, 0.11278836f, -0.05302064f, -0.09216117f, 
    -0.08668981f, 0.02659630f, -0.16569147f, 0.01010827f, -0.24258128f, 0.06494313f, 0.42558298f, -0.01547224f, 
    0.23780468f, 0.18224372f, -0.04554632f, -0.09885324f, 0.08407298f, -0.02444292f, 0.32402289f, 0.03522748f, 
    0.04942889f, -0.21166393f, -0.01856609f, 0.14025481f, 0.03005981f, -0.08106840f, -0.21343890f, -0.24673529f, 
    0.03890467f, 0.02871820f, 0.20953742f, 0.01740405f, 0.22182128f, -0.07860848f, 0.00968275f, -0.24291289f, 
    0.18028288f, 0.05162916f, 0.16084193f, -0.21371832f, -0.22562724f, -0.01592302f, -0.21776854f, 0.09992573f, 
    0.15952039f, -0.14260635f, -0.10454425f, -0.06650230f, -0.02145997f, 0.13349804f, -0.04572545f, 0.14950983f, 
    -0.07207954f, 0.12423714f, 0.12110004f, -0.05756496f, -0.32878235f, 0.03489487f, 0.19842868f, -0.27150378f, 
    -0.15472600f, 0.21067299f, 0.11276158f, 0.14222367f, -0.31057566f, 0.03480187f, 0.01898608f, 0.13343255f, 
    0.21343097f, 0.05927790f, 0.10950124f, -0.27959704f, 0.33865538f, 0.26414657f, -0.03809348f, 0.26036647f, 
    0.01322519f, -0.28843078f, -0.14930427f, 0.15926737f, 0.18476847f, 0.04816796f, 0.39264062f, -0.04077810f, 
    0.05439765f, 0.12321986f, 0.19993494f, 0.02643813f, 0.06344304f, -0.25728014f, 0.01096109f, -0.06039672f, 
    0.06591748f, 0.00282896f, 0.31113812f, -0.10324799f, -0.01025988f, 0.05990544f, -0.13773902f, -0.10754459f, 
    -0.34358421f, -0.07218504f, 0.19080202f, 0.20835923f, 0.11066236f, -0.05082568f, -0.05597283f, -0.13961938f, 
    -0.03049308f, -0.13357164f, 0.02950298f, -0.06007478f, -0.24430302f, 0.04058754f, 0.02219013f, 0.13638517f, 
    0.10110088f, -0.02474103f, -0.11719948f, -0.00563688f, -0.00869214f, -0.19024445f, -0.04759309f, 0.07098354f, 
    0.10158835f, 0.04545534f, -0.01272166f, 0.18265796f, -0.16258675f, -0.04174970f, -0.34583423f, 0.12301106f, 
    -0.09709547f, 0.08080775f, -0.24773453f, 0.05987661f, 0.00649720f, -0.22639978f, -0.10216135f, 0.00234756f, 
    -0.00635815f, 0.07164961f, 0.12532185f, 0.02681954f, -0.18937995f, 0.25843775f, -0.17315528f, -0.02226186f, 
    -0.12675777f, 0.00318435f, -0.26737946f, 0.02885493f, -0.26309931f, -0.34421560f, -0.05739960f, -0.19615062f, 
    0.38005555f, 0.14715868f, -0.18438035f, 0.21669194f, 0.13135833f, 0.15306075f, 0.24761423f, -0.27022538f, 
    0.28575927f, 0.06747928f, -0.13954507f, -0.13904537f, 0.04242066f, 0.03543675f, -0.05743793f, -0.32772237f, 
    -0.13116203f, 0.28431523f, 0.10770502f, -0.20700660f, 0.15342772f, 0.05411691f, -0.27809829f, 0.03223669f, 
    -0.01652649f, -0.14117721f, -0.22355813f, -0.02170525f, 0.07231948f, 0.06694049f, 0.09676197f, 0.01514505f, 
    0.04101851f, -0.18434379f, 0.03508139f, -0.08093745f, 0.11257529f, 0.00180834f, 0.02370070f, -0.10236160f, 
    0.05264681f, 0.00160871f, -0.15846664f, -0.10545995f, -0.04332485f, 0.13156115f, 0.20262328f, 0.22242236f, 
    -0.13346025f, -0.04152892f, 0.05216722f, -0.21216711f, 0.05116123f, 0.06910320f, 0.12051393f, 0.20693253f, 
    -0.18362670f, 0.10079449f, 0.08215109f, 0.14540367f, 0.00457273f, 0.21936585f, -0.04747517f, -0.01188288f, 
    0.18014835f, -0.02542701f, -0.15141171f, 0.04349159f, -0.02837736f, -0.22993936f, 0.04192631f, 0.16896266f, 
    -0.07201076f, -0.09979934f, 0.24376136f, -0.21075171f, 0.14923762f, -0.09595333f, -0.00162592f, -0.04636730f, 
    -0.29312766f, 0.26714030f, 0.06259477f, 0.28012419f, 0.03020122f, -0.02588462f, 0.18419413f, -0.02265157f, 
    -0.17364402f, 0.21209395f, -0.06577037f, 0.07225293f, -0.09678482f, 0.12996328f, 0.04778072f, -0.20554224f, 
    0.19970584f, -0.07778189f, 0.22046851f, 0.06443913f, -0.38596937f, 0.13637935f, -0.13558491f, -0.06832324f, 
    0.05806460f, 0.11080157f, -0.41144076f, 0.25165215f, -0.00304791f, -0.01376250f, -0.26652852f, 0.15130334f, 
    0.22900844f, 0.13395417f, -0.06412588f, -0.17717305f, 0.33786249f, 0.01073221f, -0.02918222f, -0.05692911f, 
    -0.03826390f, -0.08917072f, -0.19516383f, 0.00036703f, -0.00125646f, -0.05368738f, 0.05270502f, -0.09141678f, 
    -0.01253777f, 0.10603693f, -0.01439375f, 0.28327835f, 0.01090485f, -0.25879642f, 0.30747467f, 0.08687159f, 
    0.01145009f, 0.03259271f, 0.11726547f, 0.15171748f, -0.18666516f, 0.13012204f, -0.18068492f, -0.02427508f, 
    0.12567526f, 0.02729701f, 0.20798761f, 0.08053362f, 0.06078082f, 0.02641602f, -0.10921685f, 0.02480638f, 
    0.06091516f, 0.37586901f, -0.04108586f, -0.06432561f, -0.27884623f, 0.03591453f, -0.07608391f, 0.00218773f, 
    0.15019080f, -0.10276029f, 0.10260130f, -0.06873932f, -0.12655492f, 0.00214092f, -0.14260668f, 0.04398960f, 
    0.10540041f, 0.02069032f, 0.07940210f, 0.03051309f, -0.02607198f, -0.12638722f, -0.05068039f, 0.16671233f, 
    0.07795761f, 0.18790205f, -0.14717770f, 0.13767295f, 0.12904291f, -0.13306685f, 0.11444782f, 0.04974876f, 
    -0.02151581f, 0.10333074f, -0.02209227f, 0.14990880f, 0.21306635f, -0.14226793f, -0.03069079f, 0.07172223f, 
    -0.07128266f, 0.34384549f, -0.19309883f, -0.00794649f, 0.15301844f, -0.27328598f, 0.28299871f, -0.04182575f, 
    0.15212519f, -0.07672802f, -0.03825885f, 0.10022939f, 0.13360283f, -0.19396992f, 0.09313952f, -0.07180518f, 
    0.00657318f, -0.10763622f, 0.24547452f, -0.21498165f, 0.02059975f, 0.13610934f, -0.17995657f, 0.04717644f, 
    -0.02223434f, -0.07124590f, -0.15611717f, -0.07045928f, -0.03185187f, 0.01585740f, -0.29563090f, 0.16618839f, 
    -0.16868149f, 0.05643961f, 0.04597893f, -0.05518102f, 0.05621941f, -0.02147863f, 0.10703090f, 0.02044973f, 
    -0.19775808f, -0.45670125f, 0.07301038f, 0.05713801f, 0.15161850f, -0.05350120f, -0.07574277f, 0.15624803f, 
    -0.16092408f, 0.03058805f, -0.32071370f, -0.15577431f, -0.10465907f, -0.21835253f, -0.04404388f, 0.05947068f, 
    -0.10652488f, -0.28615183f, 0.02006515f, 0.05839424f, 0.00983481f, -0.12954888f, 0.03941628f, -0.10331026f, 
    -0.10058329f, -0.15372357f, 0.06785385f, 0.06288952f, 0.26005414f, 0.11442555f, 0.23947966f, 0.02197115f, 
    -0.17786980f, -0.04231010f, -0.13292432f, -0.09215916f, -0.09377732f, -0.00383541f, -0.28745449f, 0.14609934f, 
    -0.02580612f, -0.12453677f, 0.00669969f, -0.11837941f, -0.09575736f, 0.21819484f, 0.08902559f, -0.02513572f, 
    0.13854308f, -0.00304110f, 0.07685332f, -0.08076556f, -0.11449820f, -0.09791221f, -0.01284553f, 0.14006206f, 
    -0.01025107f, -0.34437013f, 0.04966680f, -0.01539089f, -0.13409129f, 0.04824834f, 0.48458901f, 0.24551755f, 
    0.10160317f, 0.03308886f, -0.13937068f, -0.18586209f, -0.04251681f, 0.02725106f, 0.00411605f, 0.27279133f, 
    0.00890295f, 0.11108927f, -0.09321614f, 0.09416363f, 0.16915140f, 0.04515367f, 0.02723890f, -0.03255589f, 
    -0.17236820f, -0.22440103f, 0.01889035f, 0.12510270f, 0.16511247f, 0.13787472f, -0.21276824f, 0.12846771f, 
    -0.03593162f, 0.07524600f, -0.27117398f, -0.09245180f, -0.04663210f, -0.01944098f, -0.07293380f, 0.00080072f, 
    -0.16764283f, 0.06061570f, -0.10958261f, 0.20693700f, -0.06551927f, 0.10539620f, -0.03056957f, 0.14984362f, 
    0.10459626f, 0.18526211f, -0.13170338f, 0.10180748f, -0.10588574f, 0.12585896f, -0.22694191f, 0.00201318f, 
    0.04797621f, -0.01112573f, -0.21587010f, 0.03839990f, 0.16530938f, -0.07033444f, 0.11152358f, 0.07587337f, 
    -0.03104145f, -0.07591090f, -0.21115878f, -0.14738612f, -0.07052734f, -0.40267187f, 0.14132297f, 0.11092125f, 
    0.09290168f, -0.04790851f, 0.19096696f, -0.08815952f, 0.02129841f, 0.06322306f, -0.01075345f, -0.01229761f, 
    -0.26870519f, -0.12706432f, -0.04287643f, -0.05108071f, 0.14123338f, -0.19995646f, -0.16307677f, -0.21669124f, 
    0.16447030f, 0.15332432f, 0.02282977f, -0.05221601f, -0.19102243f, -0.06934644f, 0.08122260f, 0.14293453f, 
    -0.16134514f, 0.15946577f, 0.27232322f, 0.15617768f, -0.00338214f, 0.21739255f, -0.15817526f, 0.01917938f, 
    -0.09864563f, 0.11162886f, -0.12636520f, 0.09963807f, -0.00432667f, 0.01967226f, 0.00443312f, -0.07125924f, 
    0.31535524f, -0.08989986f, 0.07658256f, 0.02420438f, 0.45984757f, -0.02872538f, -0.09266522f, 0.15489782f, 
    0.01396886f, 0.05625382f, -0.15569735f, 0.03858871f, 0.06166678f, 0.06733935f, -0.08732462f, 0.03233905f, 
    -0.18524124f, -0.01410921f, -0.04351496f, -0.25762087f, 0.14427283f, -0.10212176f, 0.17255279f, -0.29217789f, 
    0.11511065f, 0.13622236f, 0.07000916f, 0.15007314f, 0.29464698f, -0.31177324f, -0.26628220f, 0.09919013f, 
    -0.07510614f, 0.02030676f, -0.01100945f, -0.03666913f, 0.01332585f, -0.06134761f, 0.71135253f, -0.04444859f, 
    0.09231162f, 0.00279189f, 0.11142489f, 0.00910067f, 0.01677870f, 0.12801005f, 0.08501827f, -0.08240465f, 
    0.29736930f, 0.44077551f, -0.05731292f, -0.23925513f, -0.12702990f, -0.09702156f, 0.07577096f, 0.14938603f, 
    -0.12994005f, 0.16767043f, 0.32662097f, 0.08031789f, -0.10614863f, 0.04607540f, -0.08020616f, 0.01591869f, 
    -0.00134049f, -0.07291916f, 0.07505640f, 0.19874199f, 0.25858665f, -0.05532547f, -0.12158743f, -0.08704041f, 
    0.11693131f, -0.08284273f, 0.02119017f, -0.02691000f, -0.00717418f, -0.05910262f, -0.09013159f, -0.09236564f, 
    -0.07920243f, -0.32667151f, -0.03607138f, 0.18476965f, -0.24804935f, -0.07530266f, -0.18082729f, -0.14299837f, 
    0.00955008f, 0.12336821f, -0.04053477f, 0.09283769f, 0.28705573f, -0.04010743f, 0.07025030f, 0.03204605f, 
    0.01321189f, -0.14302850f, 0.13158344f, 0.09678996f, -0.03776495f, 0.26482227f, 0.22289388f, 0.09798097f, 
    -0.17158565f, 0.36487928f, -0.19401902f, 0.21458401f, -0.09554435f, 0.26417583f, 0.04789744f, -0.00416416f, 
    -0.14793791f, 0.02900727f, -0.11469263f, -0.16397986f, 0.12954748f, -0.04712295f, 0.11058263f, 0.11434521f, 
    -0.23872408f, -0.27234018f, 0.01930062f, -0.20811063f, 0.08589922f, 0.16670224f, -0.15051003f, 0.07453456f, 
    -0.11994142f, -0.21703562f, -0.21821128f, 0.05122652f, 0.16734685f, -0.16273947f, 0.26559997f, 0.09438678f, 
    0.10107199f, 0.09033803f, 0.10648640f, 0.11388485f, -0.34821510f, -0.15236562f, 0.08882765f, 0.00803147f, 
    0.18505000f, -0.15970744f, -0.33823088f, 0.35101798f, 0.17799567f, -0.02480612f, 0.14959897f, 0.00170396f, 
    0.03242859f, 0.09170131f, -0.19093400f, 0.25848153f, 0.34906819f, -0.01168374f, -0.19872320f, -0.06639126f, 
    -0.08547319f, 0.25347754f, -0.09410681f, 0.19908425f, -0.18236838f, 0.24421592f, -0.50061619f, -0.04172168f, 
    -0.03001439f, 0.13536017f, -0.19058345f, -0.30893317f, 0.11743449f, 0.23108892f, 0.08687980f, 0.17378603f, 
    -0.12205248f, -0.06873038f, 0.01327675f, -0.03300034f, 0.00225764f, 0.05749340f, -0.60806876f, -0.15137909f, 
    0.07560306f, 0.13470130f, 0.08729875f, -0.25742275f, -0.14592721f, 0.07751324f, -0.07215680f, -0.08714444f, 
    -0.11702776f, -0.09905838f, -0.03785797f, 0.05163992f, -0.22383410f, -0.07701771f, 0.04856058f, -0.16391285f, 
    -0.21217503f, 0.19773631f, -0.17863515f, -0.33722779f, -0.00322232f, 0.10640607f, 0.07857863f, 0.05276155f, 
    -0.09614092f, 0.37334922f, 0.07161244f, -0.34386340f, -0.09537615f, 0.21726961f, 0.04368749f, -0.08659674f, 
    -0.07890672f, 0.09615995f, 0.06185199f, 0.22978514f, -0.03338310f, -0.27486321f, 0.06916799f, 0.06005775f, 
    0.10513476f, 0.11879145f, 0.11796046f, 0.10951567f, 0.32704449f, -0.05091156f, 0.06130423f, -0.16107918f, 
    0.34191200f, -0.11617231f, -0.09618227f, 0.11566617f, 0.04591661f, 0.30098867f, -0.22459239f, 0.04271648f, 
    0.19357842f, -0.15960850f, 0.03190705f, -0.00497155f, 0.00548749f, 0.34248364f, -0.18727092f, -0.01152046f, 
    -0.01146745f, 0.12973052f, -0.02573669f, 0.15407260f, 0.14217924f, 0.07522560f, 0.10180904f, 0.22816272f, 
    -0.13554727f, 0.01069575f, 0.12576447f, 0.13390425f, 0.13374749f, -0.03267754f, -0.17321339f, 0.01280287f, 
    0.11410926f, 0.08870776f, -0.00578354f, -0.26778898f, 0.01419898f, 0.09257347f, -0.06013500f, -0.22502606f, 
    0.06913479f, -0.16839448f, 0.33381847f, -0.00568245f, 0.17251076f, -0.00333728f, 0.00735431f, 0.03738317f, 
    0.29195210f, 0.94673645f, -0.38810563f, 0.29294607f, 0.07501122f, -0.00308588f, -0.16348989f, -0.05350536f, 
    -0.11582537f, -0.02204158f, 0.27742553f, -0.42094371f, 0.18946075f, -0.01395074f, 0.22658251f, 0.02315993f, 
    0.05334800f, -0.06915694f, 0.24192725f, -0.26070514f, 0.10820663f, -0.53667712f, 0.01415418f, 0.02098475f, 
    -0.13950771f, -0.05251042f, 0.25140774f, -0.01028685f, -0.00653985f, -0.05010585f, 0.02349154f, 0.10590621f, 
    -0.02047029f, 0.03300174f, 0.05501587f, 0.06803268f, -0.09007938f, -0.25663981f, 0.06679378f, -0.22298469f, 
    -0.09015805f, 0.02422285f, -0.11935531f, -0.07377303f, 0.14299545f, -0.03723834f, -0.02636045f, -0.37282354f, 
    -0.20573488f, -0.24139018f, 0.13105769f, -0.00900965f, 0.08543350f, 0.01232956f, 0.21506742f, -0.58936065f, 
    -0.04806956f, 0.08671036f, -0.14554642f, -0.15207332f, -0.03963319f, -0.21955185f, -0.05732621f, -0.04635280f, 
    0.42116725f, -0.29054403f, 0.04976206f, 0.08898112f, 0.07355859f, -0.01881315f, 0.03100420f, 0.21651822f, 
    0.06468585f, -0.00899282f, -0.22736365f, 0.33084723f, -0.04677919f, 0.14520672f, 0.10307004f, -0.04495572f, 
    -0.00157794f, 0.24106212f, 0.30749789f, -0.32983246f, 0.01424803f, 0.19977356f, 0.06636570f, -0.08573605f, 
    -0.00041518f, -0.05891364f, -0.00987691f, -0.05691889f, 0.35703242f, 0.00087010f, 0.02546548f, 0.20209107f, 
    0.04924474f, -0.10752716f, 0.00156721f, -0.12167945f, -0.20082469f, -0.14657079f, 0.09084042f, -0.02308868f, 
    0.20456615f, -0.15574549f, -0.10765690f, 0.04811491f, 0.00172531f, -0.31260386f, -0.36131692f, -0.11698782f, 
    -0.12933941f, -0.18446203f, 0.08048803f, 0.21363778f, 0.01266122f, 0.20908384f, -0.25277579f, -0.32666957f, 
    0.03805678f, -0.09755483f, -0.06059976f, -0.10829125f, 0.00766210f, 0.06785776f, -0.02864075f, 0.16276897f, 
    0.33606195f, 0.07549278f, -0.12409332f, 0.07879940f, 0.12394219f, -0.00441797f, 0.09183557f, -0.00615532f, 
    0.02102050f, -0.00040496f, 0.01203804f, 0.03961216f, 0.01559417f, -0.01008700f, 0.01280170f, -0.00220774f, 
    -0.02139110f, -0.05733761f, 0.05055336f, -0.05235408f, 0.04878066f, 0.02401680f, 0.00833296f, -0.03323627f, 
    -0.02101526f, -0.04929636f, -0.00607813f, -0.04253595f, 0.01478734f, 0.04426390f, 0.01862458f, 0.03333061f, 
    -0.05559288f, -0.03846018f, -0.04671146f, 0.00883438f, 0.03305613f, 0.04839507f, -0.02501675f, -0.02245458f, 
    -0.02051320f, -0.03853259f, 0.01618892f, -0.05430439f, -0.06506556f, -0.02583210f, -0.00013364f, -0.05325927f, 
    -0.03476689f, 0.03040591f, 0.00339247f, -0.05341436f, -0.02216890f, 0.00374226f, 0.01750552f, 0.02304392f, 
    -0.02273876f, 0.04841682f, -0.03385246f, 0.02052736f, 0.03057706f, -0.04472909f, -0.04063774f, 0.02426449f, 
    -0.02560434f, -0.05845226f, 0.04787023f, -0.02610730f, -0.04024092f, 0.02580200f, -0.03552865f, -0.05744754f, 
    0.00000268f, -0.04054866f, 0.04436963f, 0.02591081f, -0.04925276f, -0.02387594f, -0.04212884f, -0.03934243f, 
    0.04198566f, -0.00202503f, 0.03648531f, 0.01236031f, 0.00628681f, 0.02939619f, -0.02420677f, 0.03337692f, 
    -0.00977930f, -0.04509873f, -0.05125353f, -0.03958942f, 0.01107523f, 0.01105474f, 0.01948772f, -0.06497052f, 
    0.03984404f, 0.02277120f, -0.02138483f, -0.00642427f, 0.04003205f, 0.01315993f, 0.01342884f, -0.05459967f, 
    -0.01725826f, -0.02136134f, -0.05988019f, 0.02517173f, -0.04140912f, -0.02634158f, -0.00905952f, 0.04562948f, 
    -0.03413990f, -0.04784678f, 0.01548922f, 0.02015855f, -0.06248170f, -0.01894050f, -0.04514023f, -0.04934714f, 
    0.04025864f, 0.01500158f, 0.02852002f, 0.04309356f, 0.00938155f, -0.05416464f, -0.05659760f, 0.01388070f, 
    -0.05827411f, -0.01618024f, 0.03709099f, -0.02325080f, -0.05549586f, -0.02741445f, -0.01484517f, -0.04496501f, 
    0.02814756f, -0.04027388f, -0.01544759f, 0.03156397f, -0.00338529f, 0.02689799f, -0.05850153f, -0.03774213f, 
    -0.01069300f, -0.03736919f, 0.02642186f, -0.02225645f, -0.04713329f, 0.03702275f, -0.02628393f, -0.01569670f, 
    0.04023780f, 0.00227855f, -0.04555043f, -0.00790579f, 0.04823327f, 0.03132772f, -0.00753215f, -0.00358660f, 
    -0.02804887f, 0.03490380f, 0.02734307f, -0.01236872f, -0.05773912f, 0.01390333f, 0.03921413f, -0.00640437f, 
    -0.04824585f, -0.01737962f, -0.04154600f, 0.02785222f, 0.03982385f, -0.03430785f, 0.04020205f, -0.05506060f, 
    0.03445044f, -0.00327323f, -0.02561363f, -0.01874779f, 0.04257626f, 0.04332040f, -0.03547636f, 0.01000150f, 
    0.01829018f, -0.04245609f, 0.02620598f, 0.02845552f, -0.06207083f, -0.03847270f, 0.03317742f, -0.06258279f, 
    -0.06436574f, 0.01368288f, 0.04921534f, -0.06157515f, 0.03793990f, -0.04474853f, 0.04569348f, 0.02307999f, 
    0.04748713f, -0.06302128f, 0.03461408f, 0.01406313f, -0.01917040f, -0.04948251f, -0.01244189f, 0.03686588f, 
    -0.04251647f, -0.00713386f, -0.04887386f, -0.04862602f, -0.01513544f, -0.05094996f, 0.02974002f, 0.02521092f, 
    -0.06150873f, 0.03051003f, -0.03341317f, 0.02480045f, 0.00828850f, 0.01641525f, -0.03284312f, 0.01194177f, 
    0.02925586f, -0.06538826f, 0.02569701f, 0.03229767f, 0.02108199f, 0.02207378f, -0.05602147f, -0.01326785f, 
    -0.01492321f, -0.02642834f, -0.05455070f, -0.01655837f, -0.06053450f, 0.03701735f, -0.00539855f, -0.03616618f, 
    -0.03101589f, 0.00066291f, 0.04876627f, 0.01487483f, -0.01581203f, -0.05042312f, -0.03281689f, -0.00524125f, 
    -0.00368172f, 0.03849668f, 0.03766490f, 0.03362586f, -0.02361878f, 0.00352693f, -0.02486376f, -0.05732450f, 
    0.01522922f, 0.01772536f, -0.02400004f, -0.03887219f, -0.01307804f, 0.01455312f, -0.05535503f, -0.02497039f, 
    -0.03097467f, -0.01776507f, 0.03334247f, 0.03870273f, 0.03392086f, -0.04520402f, -0.05475431f, -0.04769050f, 
    0.01445797f, -0.02736928f, -0.03645105f, 0.02011941f, 0.02812726f, -0.05765915f, -0.01620072f, 0.00304296f, 
    -0.06600185f, 0.00639336f, 0.04536102f, -0.00767001f, -0.01381932f, -0.05670537f, -0.01423947f, 0.00834980f, 
    -0.04809161f, 0.02062679f, 0.01413923f, -0.04858905f, 0.03406269f, 0.03255256f, 0.03781071f, -0.02568769f, 
    -0.21635723f, -0.18461666f, 0.18992080f, -0.07431735f, 0.10892807f, 0.08730932f, 0.10013419f, 0.22722568f, 
    -0.11002748f, 0.33352736f, 0.18647477f, -0.02262633f, 0.11366876f, 0.00118792f, 0.28898886f, -0.00159022f, 
    0.09690023f, 0.13539612f, 0.28799155f, -0.00931783f, -0.05198938f, -0.13234644f, -0.17362085f, 0.04918458f, 
    -0.16588891f, -0.02596444f, 0.19000939f, -0.23983794f, -0.02859200f, 0.02857233f, -0.13681404f, 0.00200539f, 
    -0.17869638f, -0.10598475f, -0.06558298f, -0.03518622f, 0.30859140f, 0.12877189f, -0.17128097f, 0.30969641f, 
    0.07115199f, 0.03535839f, -0.02778300f, -0.05504042f, 0.19362056f, 0.30897507f, 0.03462355f, -0.06088439f, 
    -0.25723228f, -0.19110495f, -0.16746671f, 0.11401815f, 0.08292112f, -0.05293494f, -0.15435638f, -0.12744017f, 
    -0.14262353f, 0.02065594f, -0.01281490f, 0.23238732f, -0.01994557f, -0.20507741f, -0.17995778f, 0.37648374f, 
    -0.04210558f, -0.15687527f, 0.30628693f, 0.04831389f, 0.06541136f, -0.00243645f, 0.11026647f, 0.29989988f, 
    0.12178130f, 0.11899406f, -0.18103182f, 0.04642626f, -0.08530425f, 0.26292115f, -0.02922823f, 0.03610012f, 
    -0.04758230f, -0.19263364f, -0.12862307f, -0.27413067f, 0.09845396f, 0.17050841f, 0.08722639f, -0.00362381f, 
    -0.06731993f, -0.17192875f, 0.18740116f, 0.15054683f, 0.01918911f, 0.06490763f, -0.01231387f, 0.01043210f, 
    0.05899455f, 0.21397604f, -0.00887877f, 0.13712166f, 0.04758322f, -0.17919771f, 0.03607271f, 0.02085402f, 
    -0.12618996f, 0.12334973f, 0.08592840f, 0.00823659f, 0.13551362f, -0.11326274f, -0.31194919f, 0.08376466f, 
    0.05795511f, 0.11822694f, 0.04938858f, 0.23691988f, -0.08987236f, -0.17548993f, -0.24217905f, -0.37206379f, 
    -0.00139641f, 0.19773373f, 0.01650222f, -0.07304876f, 0.10906962f, -0.31104299f, -0.36344153f, 0.15400393f, 
    0.32097057f, -0.13197951f, -0.01142091f, -0.14085153f, 0.07302484f, 0.01419777f, 0.40468276f, 0.56690294f, 
    0.20786290f, 0.07011830f, 0.05757306f, -0.00702242f, -0.00233183f, -0.02786464f, -0.00648743f, 0.24760392f, 
    0.21336886f, 0.22122511f, -0.30859458f, -0.15443690f, -0.02845980f, -0.19910040f, -0.25294259f, 0.05585464f, 
    -0.12951137f, -0.01157215f, 0.33412459f, -0.09619975f, -0.08041111f, -0.08853803f, 0.14267132f, 0.00669159f, 
    0.05236322f, -0.26957375f, 0.11412971f, -0.25548536f, -0.22018114f, 0.04486246f, 0.04428126f, 0.22667812f, 
    0.11290956f, -0.08269358f, -0.19109516f, -0.05253766f, -0.15222715f, -0.34626135f, 0.07337469f, 0.04043162f, 
    0.30248514f, -0.02742691f, 0.08398587f, -0.12363303f, 0.37961519f, -0.00642841f, 0.08725030f, -0.17683239f, 
    -0.16159822f, -0.12785213f, 0.04928472f, 0.02243355f, 0.09626450f, 0.16638799f, 0.14226945f, -0.13277830f, 
    -0.08483433f, -0.05445173f, 0.14395243f, -0.25144729f, -0.02078240f, -0.28656644f, -0.33446580f, -0.17587560f, 
    -0.13281918f, 0.11644837f, 0.16181283f, -0.09560488f, -0.10859962f, 0.02343660f, -0.17133515f, 0.23062642f, 
    0.14716694f, 0.07404349f, 0.12790158f, 0.02324564f, -0.03560456f, -0.09574789f, 0.09667490f, 0.22225685f, 
    0.01299813f, -0.31066015f, -0.26159093f, -0.09733614f, -0.02088343f, -0.04790168f, 0.02835530f, -0.02027373f, 
    -0.20905001f, -0.06831982f, -0.03270614f, -0.09767312f, -0.03870059f, 0.02880476f, 0.06845560f, 0.03984941f, 
    0.08920606f, -0.07312758f, 0.10061747f, -0.21467231f, -0.09925210f, 0.26504728f, 0.25476444f, 0.02188793f, 
    -0.02731187f, -0.02361632f, 0.00306185f, -0.28466293f, 0.29216653f, 0.27023390f, -0.27824622f, 0.17494878f, 
    0.00372793f, -0.12256510f, -0.03728852f, 0.16874351f, 0.17602016f, 0.02237369f, -0.05829796f, 0.02834363f, 
    -0.05384377f, 0.20478472f, 0.03182640f, -0.02495214f, -0.28422263f, -0.18809368f, 0.04784587f, 0.16240479f, 
    0.25643861f, -0.08489075f, 0.19001043f, 0.13824368f, 0.21922946f, -0.11026162f, 0.16354495f, 0.11400991f, 
    0.10366298f, 0.13599862f, -0.09220175f, -0.12150276f, 0.08417002f, 0.19529906f, 0.15445732f, -0.10903289f, 
    0.01481962f, 0.15784267f, -0.05051669f, -0.12354793f, -0.06023290f, -0.13076371f, -0.07536279f, 0.01105512f, 
    0.01007685f, -0.00581662f, -0.01385241f, 0.00711913f, -0.00481184f, -0.00878187f, 0.00678191f, -0.02124866f, 
    0.01161736f, -0.01631533f, 0.05138515f, -0.03723207f, -0.03490391f, -0.03003548f, -0.01851060f, 0.03243057f, 
    0.00438987f, 0.02697489f, -0.05000864f, -0.01922549f, -0.04891340f, 0.03087346f, -0.06292310f, -0.05012648f, 
    -0.04181799f, 0.05029738f, 0.04488281f, 0.00927873f, -0.00270642f, -0.05288781f, 0.03600230f, -0.00026348f, 
    -0.05211483f, -0.06112805f, 0.00254821f, -0.02633679f, 0.00981147f, -0.05616979f, 0.03499271f, 0.01694280f, 
    0.00113159f, -0.05159103f, 0.03912470f, -0.06172886f, 0.00442532f, 0.04921263f, -0.02906089f, -0.02530309f, 
    -0.01954946f, -0.02252236f, 0.04731258f, -0.05624982f, -0.05852450f, -0.04890161f, -0.05526401f, -0.01695983f, 
    0.04798483f, -0.01790311f, 0.01389170f, 0.01280899f, 0.03735381f, 0.01382783f, 0.02160191f, 0.02769268f, 
    -0.04110456f, -0.01488933f, 0.01715934f, 0.02627977f, -0.04925384f, -0.00044486f, 0.04432543f, -0.00748377f, 
    0.04299453f, 0.05356207f, 0.00157450f, -0.02183940f, -0.04714240f, -0.00460803f, 0.02801737f, -0.00492797f, 
    0.00903853f, -0.02315735f, -0.04093862f, 0.03926684f, -0.03075486f, -0.00161185f, -0.00741009f, -0.05394209f, 
    0.04311634f, -0.00634490f, 0.00010442f, 0.03699718f, 0.02992787f, 0.01121830f, 0.01528943f, 0.05280121f, 
    0.02844699f, -0.02768339f, -0.01083305f, -0.05040328f, 0.04718358f, -0.03928494f, -0.04414395f, 0.01276957f, 
    -0.05425333f, 0.05026251f, -0.05252855f, -0.03404071f, 0.00398703f, -0.03194282f, 0.03140124f, -0.01881731f, 
    -0.03931205f, 0.00765282f, -0.01311268f, 0.04207890f, 0.01248619f, -0.05831384f, 0.00628368f, -0.03142193f, 
    0.01236693f, -0.00976131f, -0.02945512f, 0.00481635f, 0.04575485f, 0.00956959f, -0.06138621f, 0.03904844f, 
    0.01359643f, 0.00374191f, -0.02640691f, 0.02193478f, 0.00215915f, -0.01804619f, -0.00701693f, 0.01132230f, 
    -0.06121278f, -0.04172881f, -0.05426243f, 0.02720455f, -0.04219704f, -0.05139093f, -0.02879395f, 0.02792036f, 
    0.03123788f, -0.04236560f, 0.02886657f, 0.01072841f, 0.03503807f, -0.00922385f, -0.03709280f, -0.03691950f, 
    0.04663184f, 0.05357075f, -0.00678895f, 0.05835485f, 0.03892951f, -0.03429512f, 0.00377486f, -0.01299883f, 
    -0.00980034f, -0.04238395f, -0.03597290f, 0.02287315f, -0.06220982f, 0.00951588f, 0.00759859f, 0.00436872f, 
    0.04508474f, -0.02721267f, -0.00018318f, 0.03469012f, 0.00145704f, -0.02547593f, 0.00137914f, -0.04090383f, 
    -0.01324775f, -0.01461270f, -0.04870754f, -0.06264035f, -0.01073646f, 0.00802286f, 0.03384644f, 0.02179334f, 
    -0.04262295f, 0.03285405f, -0.02724705f, -0.05450904f, 0.05161447f, -0.00440555f, -0.04648702f, 0.03423017f, 
    0.01116848f, -0.02240740f, -0.03181621f, 0.03638294f, -0.04535935f, -0.02634215f, -0.00184525f, -0.06287386f, 
    0.03213916f, 0.03318838f, 0.03126067f, -0.04687438f, 0.01724190f, -0.02914414f, 0.01374472f, -0.00454568f, 
    0.02759405f, -0.05488989f, 0.00871470f, 0.04781277f, 0.01970265f, -0.00776954f, -0.04459757f, -0.02210895f, 
    0.02015015f, -0.05657825f, 0.04879081f, -0.04546903f, -0.04519027f, -0.01660133f, -0.06095930f, 0.00802693f, 
    -0.03995082f, -0.00773723f, 0.03849216f, 0.02489711f, -0.06387212f, -0.01166259f, -0.01045103f, -0.03216290f, 
    -0.01868561f, 0.01605497f, -0.06223760f, -0.04150537f, -0.05312099f, -0.00119781f, 0.04705643f, -0.05905294f, 
    -0.04929810f, -0.06186013f, -0.02892326f, 0.01728583f, -0.02254854f, 0.02993110f, -0.04927592f, 0.01220939f, 
    0.01460295f, -0.02435588f, -0.04561809f, 0.05248462f, 0.00467588f, -0.04964725f, 0.04679625f, -0.04979461f, 
    -0.02629857f, -0.00885840f, -0.03726770f, 0.00729460f, 0.00820305f, 0.04194154f, 0.01063509f, -0.03360297f, 
    0.04336780f, 0.02390894f, -0.01780593f, -0.04596133f, 0.02342561f, -0.01862556f, 0.03965497f, -0.05645500f, 
    -0.02932423f, -0.03231808f, 0.03244155f, 0.02235414f, -0.04049829f, -0.04770975f, -0.00359643f, -0.00177187f, 
    -0.00826959f, -0.05812449f, -0.00299249f, -0.00625408f, -0.05453108f, 0.00325336f, -0.04094761f, -0.03693394f, 
    -0.28517985f, 0.09521724f, -0.02954396f, -0.08679977f, -0.01727646f, -0.03708969f, 0.15363336f, 0.12565801f, 
    -0.19613285f, -0.36666533f, -0.40505546f, -0.04565467f, 0.25312790f, 0.17884482f, -0.08000197f, 0.04197619f, 
    0.03735949f, 0.21335277f, -0.15653676f, -0.20102403f, -0.25058535f, 0.18100357f, 0.07370334f, -0.02930522f, 
    -0.11880647f, 0.12912844f, 0.19888036f, 0.37416062f, 0.09030401f, 0.01290974f, 0.01112672f, 0.16152160f, 
    -0.15288267f, 0.14527574f, 0.17803186f, 0.15135834f, -0.57922733f, -0.14787607f, -0.24180643f, 0.39773843f, 
    0.01939694f, 0.08435018f, -0.04458123f, -0.10703772f, -0.33588251f, -0.18321861f, -0.10916673f, -0.20529771f, 
    0.06637789f, -0.08078405f, -0.13985355f, 0.15402327f, -0.00971750f, 0.23656009f, 0.33336666f, 0.17645502f, 
    -0.03438688f, 0.02666789f, -0.00660009f, 0.19149530f, -0.02588630f, -0.15375058f, -0.23608148f, -0.33679414f, 
    -0.28591645f, 0.11724278f, 0.04148122f, 0.09790888f, 0.22261094f, -0.06317067f, -0.09380630f, 0.07960930f, 
    -0.29688570f, -0.44259009f, 0.15952925f, 0.13832144f, 0.03763871f, 0.08296278f, -0.03016882f, -0.23147601f, 
    0.09461137f, 0.01666817f, 0.26540899f, -0.11736315f, 0.17352140f, 0.04336904f, -0.14408332f, -0.05090280f, 
    -0.17578605f, -0.14882796f, -0.33662900f, -0.33146870f, -0.16003403f, 0.07711118f, 0.11527990f, -0.04700288f, 
    0.08245216f, 0.04962096f, 0.26547378f, 0.22649194f, -0.38224003f, -0.01825442f, 0.08071326f, 0.05310952f, 
    -0.24779265f, 0.14614426f, 0.04597815f, 0.06238011f, 0.02465251f, 0.01759237f, 0.13888662f, 0.04416017f, 
    0.01592562f, 0.20228022f, -0.10126372f, -0.17033285f, -0.10314230f, 0.02002601f, 0.18734211f, 0.23807895f, 
    -0.06250820f, 0.06907457f, 0.17014159f, 0.01229791f, 0.05824101f, -0.07991861f, -0.20762624f, 0.07621782f, 
    -0.00357464f, 0.10454383f, -0.11793699f, 0.05575082f, 0.09698722f, 0.09765717f, -0.01398378f, -0.15223196f, 
    -0.44249699f, -0.00227051f, -0.25536066f, -0.09221832f, -0.09402290f, 0.08075368f, -0.15549064f, 0.02439029f, 
    0.27824917f, 0.42307609f, 0.12525414f, -0.10357231f, 0.13257293f, 0.02745548f, -0.02142816f, 0.27095872f, 
    0.01517489f, 0.23142000f, 0.53471076f, 0.12041847f, 0.14101319f, -0.04055651f, 0.04160031f, -0.01226462f, 
    0.30257192f, 0.21401206f, 0.10036770f, 0.07839540f, 0.12634499f, 0.12245615f, -0.11629432f, -0.21883988f, 
    0.06465046f, -0.13276286f, -0.10654717f, 0.10714202f, 0.27444658f, -0.02118100f, -0.07130294f, -0.24017903f, 
    -0.28112626f, -0.28334075f, 0.08634292f, 0.17636320f, 0.04861916f, -0.28718641f, -0.10618697f, 0.09620629f, 
    -0.29939127f, -0.14888211f, 0.00456008f, -0.13013755f, -0.10055689f, -0.09427653f, -0.05847987f, 0.29727268f, 
    0.21833597f, 0.09068216f, 0.37446144f, -0.13912159f, -0.15494682f, -0.17647588f, 0.06251532f, 0.13277537f, 
    -0.17669880f, 0.23604110f, -0.00242059f, 0.10280447f, -0.29827926f, -0.02886989f, -0.22513968f, 0.28096890f, 
    -0.29630807f, -0.03089283f, 0.05963613f, -0.09071548f, 0.00341195f, 0.02268807f, -0.03313351f, -0.21858859f, 
    0.16732223f, 0.16291642f, 0.10122129f, -0.08023974f, -0.04043122f, -0.10557339f, 0.11281812f, -0.00403295f, 
    0.12343162f, -0.05335752f, 0.35046113f, -0.09719782f, -0.13435055f, 0.09971721f, 0.07374307f, -0.15636130f, 
    0.04707022f, -0.04314957f, 0.19540015f, -0.16535251f, -0.00808466f, -0.16914482f, 0.17062144f, -0.07107271f, 
    -0.02202962f, 0.04654499f, -0.24062471f, 0.05013615f, 0.02996694f, 0.21113712f, 0.06597419f, -0.09820816f, 
    0.02727772f, 0.18105318f, 0.08402307f, -0.16376705f, 0.39119345f, 0.11547713f, 0.00163239f, -0.01313477f, 
    -0.02262654f, 0.37248564f, -0.08757560f, 0.01254502f, -0.20236969f, -0.10499795f, -0.04083617f, -0.08619184f, 
    -0.00658950f, -0.27436942f, -0.22659345f, -0.01195797f, -0.16724758f, 0.01006699f, 0.17682989f, -0.19650243f, 
    -0.09695894f, -0.01462694f, 0.10108894f, -0.09996475f, 0.00525840f, -0.02760091f, -0.18527812f, 0.05026213f, 
    0.00200999f, -0.04322132f, 0.00280747f, 0.09514689f, 0.00208625f, 0.12042458f, 0.06007382f, 0.25890997f, 
    0.01226188f, 0.01420276f, -0.01315762f, -0.05230914f, 0.02395685f, -0.01759243f, -0.05645693f, -0.00004009f, 
    -0.02425397f, -0.02551972f, 0.03559501f, -0.02958540f, 0.02567008f, 0.01101074f, 0.01599221f, -0.04061998f, 
    -0.05910208f, -0.03105993f, 0.00374337f, 0.04206060f, -0.00410801f, -0.06149742f, -0.02516851f, 0.01657974f, 
    0.03675925f, -0.02327382f, -0.06086208f, 0.04980592f, -0.06959113f, -0.05640115f, -0.03912169f, 0.02054083f, 
    -0.04113069f, -0.04778613f, -0.01390685f, 0.01965437f, -0.04548244f, -0.00872988f, -0.03880369f, 0.01563348f, 
    0.00533297f, 0.00398505f, 0.02054035f, 0.01615921f, -0.03177920f, -0.03165532f, -0.06201619f, 0.02895669f, 
    -0.03586466f, 0.03320964f, -0.04146979f, -0.02542428f, 0.04178705f, -0.02213833f, -0.01654217f, 0.01072395f, 
    0.00637302f, -0.01311064f, 0.00891171f, -0.02441800f, 0.05105456f, 0.02391080f, -0.01817898f, -0.00786045f, 
    -0.00785180f, -0.05747408f, 0.02291456f, 0.01534242f, 0.04169030f, -0.00728624f, 0.03990045f, -0.04380296f, 
    -0.03660284f, 0.02801665f, -0.04053875f, 0.01089825f, -0.04505895f, 0.00729731f, 0.00569812f, -0.03966875f, 
    0.01879932f, 0.02169793f, -0.03271715f, -0.01646408f, 0.01181226f, -0.01860949f, 0.00760602f, 0.01516694f, 
    0.03328988f, 0.02478658f, -0.03619200f, -0.03821264f, 0.02816797f, 0.00048361f, 0.01499331f, -0.02751330f, 
    0.01278578f, -0.06890654f, -0.04065388f, -0.03668675f, -0.01758675f, 0.04996826f, 0.01949497f, 0.03167584f, 
    0.02242564f, -0.02410646f, 0.02728837f, 0.04966732f, 0.00385482f, 0.02925622f, -0.03366362f, 0.04345529f, 
    0.03278625f, -0.01632566f, 0.04034457f, -0.05830013f, 0.02192810f, -0.05799476f, -0.04783143f, 0.02063689f, 
    0.04435986f, 0.01057793f, 0.04506332f, 0.00714303f, 0.02883920f, -0.02860788f, -0.02005220f, -0.00672676f, 
    0.01301085f, -0.01242451f, 0.03474324f, 0.03902623f, -0.03287242f, 0.02052474f, -0.02643014f, 0.04792714f, 
    -0.00850129f, -0.01546331f, -0.04041383f, 0.01326745f, 0.00450567f, 0.00665108f, 0.02174434f, -0.06572644f, 
    -0.01357544f, -0.03927580f, 0.03790869f, -0.02618665f, -0.00296666f, -0.01854091f, -0.05204570f, -0.04868041f, 
    -0.00109352f, -0.00310978f, 0.00320450f, 0.02650374f, -0.01581013f, -0.02081828f, -0.04904433f, -0.01660592f, 
    -0.02924659f, -0.01553531f, -0.01864772f, -0.01513976f, -0.02297040f, -0.02215339f, 0.05315553f, -0.00554230f, 
    0.03666592f, 0.00594699f, 0.00257597f, -0.01994651f, 0.01316586f, -0.03111810f, -0.04655491f, 0.00955679f, 
    0.02383200f, -0.01147793f, 0.05104865f, -0.00561374f, -0.04533496f, 0.02059288f, -0.02625774f, -0.00294223f, 
    0.03398536f, -0.04126027f, 0.05029496f, 0.00426188f, -0.05246217f, -0.05852604f, -0.04926718f, 0.04575053f, 
    -0.06524190f, 0.02456191f, 0.01392822f, -0.00239870f, -0.06172286f, -0.02629711f, -0.01255715f, 0.02107724f, 
    0.03098797f, 0.03636987f, -0.05163512f, -0.00358441f, -0.01756840f, -0.02396370f, -0.01336390f, -0.03357085f, 
    -0.03382086f, -0.02485413f, 0.03709951f, -0.02980203f, -0.03659659f, -0.02701655f, 0.03955537f, -0.03762668f, 
    -0.03761303f, -0.03011299f, 0.01523276f, 0.01712984f, -0.02732626f, -0.00936203f, -0.01064904f, 0.03817006f, 
    -0.00098552f, -0.01549438f, -0.03313589f, -0.02329294f, -0.05004757f, -0.05942126f, 0.00691273f, 0.00495681f, 
    -0.00641474f, -0.00993444f, -0.02593147f, -0.04475129f, -0.03550337f, -0.04528635f, -0.03381377f, 0.01872626f, 
    -0.03181440f, -0.01600444f, -0.06432377f, -0.01696961f, 0.02761293f, 0.02260933f, 0.05302685f, -0.01381603f, 
    0.01171767f, 0.02653303f, -0.00330814f, -0.06257077f, -0.00088730f, -0.05462441f, 0.03331284f, -0.00778892f, 
    -0.04031336f, -0.04013602f, 0.00523547f, -0.00447927f, -0.05613809f, -0.02872812f, 0.04288718f, -0.01756857f, 
    -0.06731011f, -0.05218543f, -0.03480282f, 0.01272818f, -0.04322122f, 0.02798094f, 0.00030926f, -0.04964688f, 
    0.00463089f, -0.01278205f, 0.04451569f, -0.02428150f, 0.03372483f, -0.02065058f, -0.01237603f, -0.01029711f, 
    0.01459449f, 0.05063873f, 0.03819638f, 0.04241763f, 0.04193170f, 0.05322487f, 0.03453947f, -0.02290078f, 
    -0.10121208f, 0.04128123f, -0.17163205f, -0.19128010f, -0.08020680f, -0.01750218f, 0.07835028f, 0.18006572f, 
    -0.07466487f, 0.09685140f, 0.22535881f, 0.06337830f, 0.07432481f, -0.06472315f, -0.16799164f, -0.24513166f, 
    -0.16508029f, 0.17021580f, -0.07542936f, -0.13631165f, -0.20637833f, -0.30743223f, 0.04881085f, -0.10965015f, 
    0.06102262f, 0.04136680f, -0.00140191f, 0.41865608f, 0.28795734f, -0.35446885f, -0.09093636f, 0.08453996f, 
    -0.16280855f, 0.05713785f, -0.01942272f, -0.04204965f, -0.11445038f, -0.27149925f, -0.00287775f, 0.20238377f, 
    0.08669926f, -0.09065323f, -0.02959981f, -0.03465031f, 0.00736164f, -0.07040992f, 0.13142674f, -0.06849813f, 
    0.25067341f, 0.05825534f, 0.07234333f, 0.01190249f, 0.01430234f, 0.17333600f, 0.14288501f, 0.01583670f, 
    0.20638405f, -0.02114184f, 0.06818044f, 0.07796642f, -0.07434069f, 0.07203593f, -0.07251029f, -0.43100423f, 
    -0.12355657f, -0.03543012f, -0.01603845f, 0.05357898f, 0.00498403f, -0.25195080f, 0.10022868f, -0.17720313f, 
    0.22478433f, 0.05355231f, -0.02962223f, -0.27465272f, -0.15598831f, -0.18090515f, -0.25861755f, -0.12958436f, 
    -0.02248228f, 0.17634246f, 0.02615741f, -0.10067976f, -0.08092817f, -0.03668551f, 0.04088491f, 0.02374629f, 
    -0.14608313f, 0.18850008f, -0.08802434f, -0.04344827f, -0.06342401f, -0.00757210f, -0.11286787f, -0.09188863f, 
    0.05640812f, 0.06308099f, 0.02934392f, -0.09068869f, 0.20705423f, -0.16251904f, 0.15444204f, -0.10695777f, 
    -0.33774793f, 0.09283404f, 0.05330484f, 0.12232599f, -0.16236676f, -0.17073205f, 0.03944109f, -0.14426421f, 
    -0.14751615f, 0.00697696f, -0.09113775f, 0.10943782f, 0.03409976f, 0.50371999f, -0.01089785f, 0.11238385f, 
    -0.06107007f, 0.02916608f, -0.02034933f, -0.07265691f, 0.10437488f, -0.19492157f, 0.45839769f, -0.08323203f, 
    -0.02654219f, 0.12055666f, 0.13317290f, 0.11987453f, -0.14148311f, -0.14444923f, 0.09681801f, -0.10233959f, 
    -0.04729450f, 0.11832044f, 0.19660154f, -0.07144745f, -0.03357015f, 0.09050335f, 0.07273996f, 0.05702960f, 
    0.57460874f, 0.13159046f, -0.15011664f, 0.16547753f, 0.09778712f, -0.30631652f, 0.17712256f, -0.13939808f, 
    0.03329090f, -0.31592003f, 0.62981158f, -0.41880077f, -0.14916760f, 0.16630781f, 0.08606252f, 0.10991787f, 
    0.09517441f, -0.13711755f, -0.47203955f, -0.06372535f, -0.20826663f, 0.15629664f, 0.14049824f, 0.11639603f, 
    -0.00831250f, -0.00220800f, -0.31058273f, -0.16164674f, -0.02783669f, -0.16423455f, 0.19292554f, 0.05237499f, 
    0.02346506f, -0.04369143f, 0.13962291f, 0.02902010f, -0.64426094f, -0.06856658f, -0.00570339f, 0.00814696f, 
    -0.18248150f, -0.08645568f, 0.27498195f, 0.05567846f, 0.05629271f, 0.20618679f, 0.03695069f, 0.00810584f, 
    -0.00720476f, -0.07835690f, 0.18412335f, -0.11059911f, 0.14938754f, 0.06378412f, -0.21354654f, -0.12702195f, 
    -0.28316024f, 0.00044924f, 0.12509498f, 0.03026235f, -0.09997503f, 0.10124093f, -0.06903718f, 0.30719954f, 
    -0.06593009f, 0.14548105f, 0.24539755f, 0.19163555f, 0.16767921f, -0.03166757f, 0.02152861f, 0.07063391f, 
    0.08879674f, 0.11344422f, 0.07312466f, 0.13812026f, 0.01638632f, 0.03886814f, 0.13443558f, -0.20436105f, 
    0.04715181f, 0.13809162f, 0.18790554f, 0.16722043f, -0.01813591f, -0.13008390f, 0.02114202f, -0.00474223f, 
    0.14688256f, 0.01351649f, -0.20071487f, 0.45664486f, 0.26558429f, -0.00934532f, 0.29531986f, 0.02267482f, 
    -0.34391057f, -0.07948840f, -0.14230651f, -0.15855213f, -0.07083498f, 0.11729550f, 0.04919935f, 0.08639033f, 
    0.06520163f, 0.05217779f, 0.00887704f, 0.25457868f, 0.00981628f, -0.01255285f, 0.14122972f, 0.02629482f, 
    -0.12422118f, 0.15448268f, -0.02178063f, 0.16931957f, -0.12229880f, -0.48142987f, 0.13957016f, -0.16852404f, 
    -0.10996751f, -0.05638507f, 0.06343433f, 0.06107874f, -0.02316558f, 0.02146293f, -0.17882802f, 0.02830685f, 
    0.32182488f, -0.04913874f, 0.03318788f, 0.13960747f, -0.11237169f, 0.04661268f, 0.17361262f, 0.13585712f, 
    0.21209447f, 0.14915371f, 0.00907335f, -0.06489410f, 0.09012729f, 0.01193970f, 0.12503736f, -0.00697450f, 
    0.15511176f, 0.06157235f, -0.18583597f, 0.15112059f, -0.04600426f, -0.06131439f, 0.11967101f, 0.09281573f, 
    0.35342506f, -0.03873435f, 0.00537870f, 0.10349628f, -0.22158590f, 0.09607147f, 0.04667657f, 0.06981123f, 
    -0.07286733f, 0.08713013f, -0.26432526f, 0.24508931f, 0.16724478f, -0.04969942f, 0.20778582f, -0.19785789f, 
    -0.01304340f, 0.03285490f, 0.05339802f, 0.12053426f, -0.03495502f, -0.01504264f, 0.11084382f, 0.00674549f, 
    -0.04597177f, 0.15172672f, -0.06645318f, 0.01352613f, -0.39269182f, 0.31462479f, -0.17598289f, 0.32111660f, 
    0.22447379f, 0.11628045f, 0.02809171f, -0.18843016f, -0.03426633f, -0.12125296f, 0.08714531f, 0.33096269f, 
    0.03926202f, -0.12684725f, -0.30135942f, 0.24580853f, 0.08914015f, 0.00937462f, -0.28044003f, -0.01632858f, 
    -0.24904706f, -0.07351914f, 0.18508089f, 0.12990303f, 0.08299337f, -0.06402629f, -0.07944855f, -0.32650861f, 
    -0.22026241f, -0.23351474f, -0.26839334f, 0.17253728f, 0.08104626f, -0.00107745f, -0.21408203f, 0.16877507f, 
    -0.09219444f, -0.06265972f, 0.21920250f, -0.03112302f, 0.09311655f, 0.02220942f, 0.13522337f, -0.16159268f, 
    0.06295849f, 0.10164466f, 0.11087812f, -0.14449066f, 0.07207261f, 0.04469527f, 0.07682081f, -0.04264866f, 
    0.12464943f, 0.04752526f, 0.06459628f, 0.01814019f, 0.44774905f, -0.00590656f, 0.21197113f, 0.01746794f, 
    0.11596678f, 0.21457946f, 0.39666975f, -0.05344256f, 0.19538149f, 0.11134235f, 0.06718083f, 0.10281610f, 
    -0.22282450f, 0.46009216f, -0.01863750f, 0.23790117f, 0.22760722f, 0.20730405f, -0.05682475f, -0.06356454f, 
    0.20219904f, 0.35973677f, -0.09435094f, 0.03605939f, 0.09605345f, -0.76600873f, -0.50591624f, -0.47499892f, 
    0.02784690f, -0.01700595f, 0.06542130f, -0.05209458f, -0.07836013f, 0.05447502f, 0.06274592f, 0.19882473f, 
    0.01609971f, 0.00850207f, 0.04011424f, 0.15140849f, 0.04225765f, 0.19680816f, 0.10646354f, -0.19204731f, 
    0.00903942f, 0.03062948f, -0.13031477f, -0.06045735f, -0.02588582f, 0.02984299f, -0.05312167f, 0.02419804f, 
    0.11395033f, 0.08351979f, -0.04926099f, -0.00792944f, -0.13123484f, -0.27520776f, 0.12404137f, 0.11160783f, 
    -0.19674052f, -0.02012966f, -0.00803602f, 0.08719327f, 0.18907678f, 0.04458017f, 0.14344256f, -0.00830765f, 
    0.01408577f, 0.21179797f, -0.28724247f, -0.51782364f, -0.02329173f, 0.22338241f, -0.03104965f, 0.20396520f, 
    0.09355015f, -0.10599781f, -0.15838717f, 0.15304261f, -0.06075674f, -0.20034720f, 0.28481349f, -0.09547112f, 
    -0.14291139f, -0.02403667f, 0.06414726f, 0.04733109f, -0.39858744f, -0.13532507f, -0.01855323f, -0.01129572f, 
    0.00459564f, -0.15634288f, 0.17986675f, 0.02507519f, 0.02000495f, -0.09536815f, -0.07836448f, 0.05680887f, 
    -0.09972186f, 0.06179381f, 0.04122137f, -0.15633704f, 0.02103454f, 0.22498503f, -0.11969093f, -0.16604157f, 
    -0.08841557f, 0.03018683f, 0.17053531f, -0.07195621f, 0.15980308f, 0.01051614f, -0.09005909f, -0.38575774f, 
    -0.02379698f, -0.11771633f, -0.13716003f, -0.07760705f, -0.31139129f, -0.02477362f, -0.12557590f, -0.02810985f, 
    -0.22273013f, -0.53475606f, -0.24610506f, 0.07359531f, -0.08884529f, -0.20092238f, -0.02089535f, -0.08651292f, 
    -0.08950126f, 0.23369846f, -0.03808360f, 0.04829945f, 0.12053969f, 0.14865692f, 0.08846864f, 0.08889466f, 
    0.23344602f, 0.02109280f, -0.03003053f, -0.29668963f, 0.16578595f, 0.12658803f, -0.00902945f, -0.02320313f, 
    -0.18304741f, 0.15014732f, -0.18918754f, 0.09657966f, 0.27879930f, 0.16989875f, 0.14147854f, -0.22587603f, 
    0.00056539f, 0.07275596f, -0.16999805f, -0.02341159f, -0.01944150f, -0.07910191f, 0.02985723f, -0.19753000f, 
    -0.00905706f, 0.24142590f, 0.05017291f, -0.08322190f, 0.00713727f, -0.44473949f, -0.32431418f, -0.31317794f, 
    0.03305418f, 0.05478806f, -0.15661734f, -0.06955054f, -0.26254624f, -0.12000950f, -0.12197409f, -0.12997942f, 
    -0.09212415f, 0.02533992f, -0.11347779f, -0.16026130f, -0.00625255f, 0.07226109f, 0.03672534f, 0.07404137f, 
    0.06647906f, 0.00615200f, 0.04047723f, 0.12953666f, 0.02619403f, 0.11895379f, 0.17214644f, 0.30817902f, 
    0.13656408f, -0.03009977f, 0.06747272f, 0.02186572f, 0.11226889f, -0.09859578f, -0.09444811f, -0.15043692f, 
    -0.01436749f, -0.20894891f, -0.54155916f, -0.17430085f, 0.12011148f, 0.05425398f, -0.00186505f, -0.12712803f, 
    0.00409485f, -0.06478240f, 0.02091678f, -0.26330692f, -0.24042840f, 0.04896574f, -0.02807585f, 0.20978324f, 
    -0.26770544f, -0.17815383f, -0.19399136f, 0.22148229f, 0.07032462f, 0.14817928f, -0.14239576f, -0.06556770f, 
    0.17901722f, 0.13295272f, 0.22748053f, -0.07919785f, 0.07029779f, -0.02736479f, 0.04026892f, 0.20563707f, 
    -0.14186446f, -0.18455647f, 0.04548486f, 0.14541247f, -0.03700753f, -0.06467278f, -0.00435942f, 0.07431456f, 
    0.04893534f, 0.04971275f, 0.17174962f, 0.06854681f, 0.31237236f, -0.18020830f, 0.33418182f, 0.25217071f, 
    0.07119742f, -0.15499260f, 0.04326907f, -0.02235749f, 0.14118393f, 0.08078858f, 0.12294922f, -0.06334363f, 
    -0.33827683f, 0.03425776f, -0.14885916f, 0.10279594f, -0.00532737f, 0.10233949f, 0.15125248f, 0.04467479f, 
    -0.26802188f, -0.50091618f, -0.37109259f, 0.08359826f, -0.06748674f, -0.02318732f, 0.20117454f, -0.01242094f, 
    -0.21451838f, -0.05463883f, 0.12998487f, -0.15478677f, 0.04121014f, -0.10446168f, 0.07600981f, 0.04047336f, 
    0.11489563f, 0.01405905f, -0.35306966f, -0.50997883f, -0.12684622f, 0.01676669f, -0.00304437f, 0.00518673f, 
    -0.15251370f, 0.00654696f, -0.09507784f, -0.07262589f, -0.03756883f, 0.00053896f, -0.07476531f, 0.05729313f, 
    0.09610213f, 0.09300684f, 0.17116027f, -0.03029171f, 0.03210069f, -0.04347579f, 0.08585291f, -0.14774103f, 
    -0.08554969f, 0.01194270f, 0.28425238f, -0.01297184f, 0.08354007f, 0.03676550f, 0.07209893f, 0.09837947f, 
    -0.01298332f, 0.03798834f, -0.11556140f, -0.18269745f, 0.10997625f, 0.12958561f, 0.13547398f, 0.17333075f, 
    0.06502532f, 0.15089957f, -0.14522675f, 0.03901267f, -0.11262577f, 0.07050563f, -0.01698015f, -0.12845105f, 
    -0.48622537f, 0.07415666f, 0.14394429f, -0.00043244f, -0.09713505f, 0.01104115f, 0.06241683f, 0.14402965f, 
    -0.06749735f, -0.03566254f, 0.04307266f, -0.14150031f, 0.03218136f, 0.19848673f, -0.06378278f, -0.01978627f, 
    0.21677516f, -0.07226371f, 0.04235625f, 0.11282498f, 0.19448504f, -0.06248436f, 0.10666627f, -0.09700173f, 
    0.12318447f, 0.09116369f, -0.02009739f, 0.06822552f, 0.07588527f, -0.00112589f, 0.05571853f, 0.00572272f, 
    0.01118812f, -0.02494394f, 0.14607190f, -0.06586260f, 0.04348414f, -0.11476080f, 0.24454111f, 0.06091205f, 
    0.00966003f, 0.06683785f, 0.05152129f, 0.06996516f, 0.07010340f, -0.15047686f, 0.07887410f, 0.01672293f, 
    -0.09640496f, -0.14027578f, 0.28587008f, -0.02867185f, -0.06405339f, 0.03767225f, -0.05577185f, -0.08163905f, 
    0.09337620f, 0.08339006f, 0.09495778f, 0.15420043f, -0.03728280f, 0.15167178f, -0.11240835f, -0.03639368f, 
    -0.04749440f, 0.20337179f, -0.18008521f, -0.03375236f, 0.09716440f, 0.03155538f, 0.03330897f, -0.09375285f, 
    -0.41931510f, 0.04848102f, 0.05848135f, 0.03126126f, -0.12037376f, -0.10574435f, -0.01775219f, 0.06073571f, 
    -0.15141383f, 0.01754465f, 0.28736061f, 0.04165268f, 0.07413518f, 0.09674950f, -0.16419969f, 0.04689530f, 
    0.25053808f, 0.04761957f, 0.06451465f, 0.16712992f, 0.05574789f, 0.05055140f, -0.08544721f, 0.17918792f, 
    -0.11725085f, 0.01912289f, 0.05057492f, 0.01874002f, 0.22505486f, -0.03060973f, -0.08752012f, -0.05297091f, 
    0.04500014f, 0.25402108f, 0.12406912f, 0.12641178f, 0.04619199f, -0.19307846f, -0.01467395f, 0.03409289f, 
    0.08443654f, 0.24180518f, -0.11913928f, -0.15948685f, 0.07273185f, 0.21567453f, 0.17239818f, -0.01691534f, 
    -0.06412321f, -0.17126139f, 0.02919601f, -0.26638865f, 0.20505549f, -0.10680829f, 0.07192382f, -0.26376474f, 
    -0.00376470f, 0.19057675f, -0.00435350f, 0.06975841f, -0.23853247f, -0.31584871f, 0.11047905f, -0.24684638f, 
    0.11750026f, 0.17337348f, -0.02686938f, 0.03328647f, -0.15324794f, -0.05158884f, -0.08938947f, 0.01783272f, 
    -0.06342945f, -0.04217368f, 0.04836798f, 0.01689904f, 0.30614352f, 0.27165899f, -0.03970696f, -0.15784362f, 
    -0.08316199f, -0.13348958f, -0.23003988f, -0.34981793f, -0.00855928f, 0.09249740f, 0.05684828f, 0.08912476f, 
    0.22792783f, -0.67135531f, -0.01897211f, 0.02412812f, -0.07004452f, 0.07246556f, -0.08015452f, -0.07005696f, 
    0.05652912f, -0.05187162f, -0.16811295f, 0.05947539f, -0.08806494f, 0.07731052f, -0.12338020f, 0.02714061f, 
    -0.17881142f, 0.03392005f, 0.18843913f, 0.13853396f, 0.29181287f, 0.07669910f, -0.11399362f, 0.07369939f, 
    0.22708720f, 0.09922863f, 0.15711829f, 0.00777570f, 0.29842621f, -0.03010605f, 0.18219317f, -0.01399764f, 
    -0.14112875f, -0.08907866f, 0.14420570f, -0.11251016f, -0.02363847f, 0.28473464f, 0.11907411f, -0.04350666f, 
    0.15358928f, 0.08686019f, 0.19943947f, 0.06175660f, 0.00479669f, -0.32302225f, 0.13782921f, -0.04771033f, 
    0.02204897f, 0.01025182f, -0.14625861f, 0.23345561f, -0.01749272f, -0.06260489f, 0.08789922f, -0.13209397f, 
    -0.25760987f, 0.09997819f, -0.06647991f, 0.14737205f, 0.01739825f, -0.10849163f, -0.31864658f, 0.15144056f, 
    -0.26667243f, 0.17051077f, -0.58446944f, 0.11250473f, 0.04837474f, -0.02347171f, 0.23674187f, -0.09495100f, 
    0.06128264f, -0.09455352f, 0.02063474f, 0.22675595f, 0.08277591f, -0.14500043f, -0.15022552f, -0.01134847f, 
    0.21303934f, -0.05317440f, -0.31468964f, -0.10968520f, -0.22141479f, 0.12212522f, 0.04572712f, 0.07387944f, 
    0.09432061f, -0.11776461f, -0.12225011f, 0.35039231f, -0.16100666f, -0.08399541f, -0.08263016f, -0.04440760f, 
    0.17881441f, -0.04527248f, -0.02185469f, -0.28214177f, -0.06180525f, -0.05292075f, -0.03791315f, 0.06503189f, 
    -0.23684114f, 0.08576545f, -0.17952141f, -0.10386620f, 0.17269102f, 0.20499930f, 0.24883564f, -0.25547415f, 
    -0.12072200f, -0.16003363f, -0.08025388f, 0.16537058f, 0.20385036f, 0.08089645f, 0.26672336f, -0.13503754f, 
    0.41322565f, 0.06432742f, -0.03303111f, -0.00120157f, -0.03061897f, -0.13742243f, -0.01531946f, -0.52554959f, 
    0.10258348f, 0.01616330f, 0.21879210f, -0.18075302f, -0.03135840f, -0.04328318f, 0.05028185f, 0.00752924f, 
    0.45606413f, 0.40325317f, 0.30755401f, -0.08285426f, 0.19466619f, 0.02891127f, 0.09924919f, 0.12977253f, 
    0.19402215f, -0.02229907f, 0.39342698f, -0.16489571f, 0.26009667f, -0.02468364f, -0.11056875f, 0.13626797f, 
    0.11479209f, -0.06486117f, 0.11622068f, 0.21232857f, -0.30828390f, 0.04732330f, 0.18176979f, -0.23090148f, 
    -0.05694830f, -0.04659347f, -0.11111178f, 0.20697320f, 0.03650152f, -0.12762032f, -0.17496085f, -0.14313811f, 
    -0.00860159f, 0.09028902f, 0.16700500f, -0.15667599f, -0.35432062f, 0.02351133f, -0.05315500f, -0.15354553f, 
    0.00194676f, 0.08741323f, 0.00040860f, -0.15258138f, -0.12350313f, -0.26439482f, 0.01461396f, -0.03827380f, 
    -0.03077887f, 0.16018896f, -0.10162807f, 0.14253145f, -0.09519713f, 0.03959064f, -0.10012900f, 0.22373328f, 
    -0.03002078f, 0.12466984f, -0.09264059f, 0.04237982f, -0.00872166f, -0.04806015f, -0.20172700f, -0.41821712f, 
    0.20021114f, -0.16451395f, 0.04169940f, -0.12093674f, -0.07450259f, 0.01345869f, -0.10747897f, 0.07296102f, 
    0.25769061f, 0.29044801f, 0.08512643f, 0.03241661f, 0.07141596f, 0.09030573f, 0.18579258f, 0.05770021f, 
    0.00478020f, 0.18015932f, 0.09071681f, 0.03887558f, 0.08953542f, -0.16304770f, -0.12257101f, 0.22671360f, 
    0.06279609f, 0.08308505f, -0.20382658f, -0.00445849f, -0.07172711f, -0.02904455f, -0.22478107f, 0.09779548f, 
    0.16835268f, 0.10595988f, 0.05827397f, -0.25539938f, -0.03801552f, -0.27754515f, 0.23580891f, -0.00067877f, 
    0.04220229f, 0.03708608f, 0.14712051f, -0.02073436f, 0.18148690f, 0.02701723f, -0.12707080f, -0.18300955f, 
    -0.13906763f, 0.03697184f, -0.06180279f, 0.05577694f, 0.11299055f, 0.04951596f, 0.03692720f, -0.28520837f, 
    -0.05278616f, 0.10974964f, -0.08959356f, 0.29767993f, -0.05840589f, -0.04371821f, -0.34929445f, 0.05273304f, 
    -0.03269246f, 0.10525736f, 0.05693905f, -0.09369370f, -0.04054970f, 0.04746644f, 0.01526089f, -0.01855019f, 
    0.06165393f, 0.09156503f, 0.05412576f, 0.00541374f, 0.09046414f, 0.09927558f, -0.00499455f, 0.01444248f, 
    0.13612980f, 0.11831695f, -0.11790854f, -0.15668467f, 0.12499831f, -0.11195509f, 0.01935246f, 0.04181520f, 
    -0.11324646f, 0.49978161f, 0.29064569f, 0.22940880f, 0.01836599f, 0.04264568f, -0.02955451f, 0.25620481f, 
    0.02893408f, 0.10293908f, 0.72309339f, 0.09559898f, 0.04268813f, -0.12512714f, 0.09984688f, 0.03140911f, 
    -0.12991384f, 0.16737367f, 0.27088624f, -0.59603596f, -0.21203652f, -0.18741941f, 0.11022348f, 0.05822738f, 
    0.11478664f, -0.03548428f, -0.12437654f, 0.05590312f, -0.11937555f, 0.24069625f, -0.19834502f, 0.02523614f, 
    0.31027859f, -0.14749540f, -0.21759549f, -0.11518919f, 0.00093256f, -0.08911376f, -0.18867759f, -0.12248521f, 
    0.01729760f, 0.19116288f, -0.06283263f, -0.24285835f, 0.06565999f, 0.09562338f, -0.06400487f, 0.10576821f, 
    -0.39519063f, 0.01217359f, -0.13989483f, 0.01412878f, 0.04297406f, 0.18978049f, 0.00421420f, -0.34464222f, 
    0.04966966f, -0.02510048f, -0.13664621f, 0.03075255f, -0.02289241f, 0.14713877f, 0.14330302f, -0.22753741f, 
    0.48968193f, 0.29811716f, 0.02636957f, -0.08995384f, -0.09204809f, 0.04380825f, 0.23760900f, -0.05518351f, 
    0.33561894f, -0.59882319f, -0.10281150f, 0.09267677f, 0.00927906f, 0.10868771f, 0.07304162f, 0.17110021f, 
    0.04916403f, -0.19838932f, 0.40130579f, 0.22030132f, 0.10582513f, 0.19273722f, 0.06163777f, -0.00866452f, 
    0.01896487f, -0.10838003f, 0.08700725f, -0.24304493f, -0.03651562f, -0.17335740f, 0.01269907f, -0.06662866f, 
    -0.01888010f, -0.14396936f, 0.10967636f, 0.18781786f, 0.01703744f, 0.06724378f, 0.08607757f, -0.01863216f, 
    0.00093965f, 0.04411569f, 0.08314653f, -0.09109438f, 0.00056372f, -0.44705626f, -0.04867807f, -0.14710946f, 
    -0.02024162f, -0.00411075f, -0.01690640f, 0.01131615f, -0.06996933f, -0.01494219f, -0.49130288f, -0.20924960f, 
    -0.11902568f, 0.20182437f, 0.04289447f, 0.04160536f, 0.01772225f, 0.04292145f, -0.25072074f, 0.13362101f, 
    0.09250294f, 0.18742256f, 0.18371454f, 0.24956340f, 0.02191556f, 0.00059429f, -0.06653848f, -0.13645643f, 
    0.27564240f, 0.05270908f, -0.23116797f, -0.17904988f, -0.02484418f, -0.10283095f, 0.17291774f, -0.00767257f, 
    -0.11456180f, -0.16609980f, 0.15851925f, -0.10969296f, 0.18250492f, 0.08199857f, 0.16476937f, 0.09388322f, 
    0.15779939f, 0.18847866f, 0.14258252f, 0.15542334f, -0.15078622f, -0.05327521f, -0.03684355f, -0.13016930f, 
    0.07210387f, -0.07810125f, -0.01260471f, 0.07538106f, -0.30089909f, -0.03797840f, 0.05228809f, 0.18378361f, 
    -0.16600698f, -0.25048494f, -0.07811772f, 0.11854894f, -0.10741560f, 0.11520521f, -0.01742788f, 0.00378138f, 
    0.09799022f, -0.05054219f, -0.31113499f, 0.07724381f, -0.00423318f, 0.47726074f, 0.25831002f, -0.09660177f, 
    -0.07458945f, 0.12280437f, -0.23037967f, -0.07305218f, -0.26046199f, -0.02678575f, 0.16459270f, -0.08701019f, 
    0.20649053f, 0.03906192f, 0.21255618f, -0.25115249f, -0.05983867f, -0.07807965f, 0.07822620f, 0.12565300f, 
    -0.17153437f, -0.05810053f, 0.31953830f, -0.05935034f, 0.00515964f, 0.21647926f, 0.07100873f, 0.04038392f, 
    -0.28942820f, -0.05377587f, -0.22480798f, -0.10842073f, -0.01260741f, 0.02087175f, -0.02762774f, -0.10537347f, 
    -0.10585058f, 0.18983579f, -0.08137131f, -0.27498689f, -0.04390745f, -0.13111041f, 0.02316057f, -0.08998707f, 
    0.18277414f, -0.02082031f, 0.04307939f, -0.11318334f, 0.05927683f, -0.01902712f, -0.15973835f, -0.22438551f, 
    -0.05313223f, 0.00478260f, 0.10346364f, -0.35307050f, -0.27742237f, -0.00166061f, 0.02311863f, 0.13731658f, 
    -0.04243598f, -0.07468250f, -0.00498866f, -0.07020600f, -0.01379218f, 0.08182601f, -0.38386706f, -0.00569887f, 
    -0.15927579f, 0.09182676f, 0.08655841f, 0.05310643f, 0.15749377f, -0.00311998f, 0.08496320f, -0.36848429f, 
    -0.05118370f, -0.22606564f, -0.03069794f, -0.01865848f, 0.10804795f, 0.18837550f, 0.09352945f, 0.03475671f, 
    0.20478907f, 0.09658992f, 0.09962847f, -0.13472992f, 0.09166166f, 0.09540872f, 0.19612916f, -0.61938906f, 
    -0.09798545f, -0.04145768f, 0.18688856f, 0.22182824f, 0.00152925f, -0.08236181f, 0.07467522f, -0.04300440f, 
    0.02571725f, 0.03588582f, -0.01279575f, 0.03129989f, -0.03034021f, 0.02816669f, -0.06425245f, -0.00309708f, 
    0.02871238f, -0.01024560f, -0.03720213f, 0.03599006f, -0.05792236f, 0.02886129f, -0.06356362f, -0.04003631f, 
    0.02219020f, -0.00427478f, 0.04163551f, -0.05854300f, 0.05827054f, -0.01510229f, -0.00216916f, 0.04904605f, 
    -0.04291567f, 0.03697664f, -0.05521338f, -0.05546845f, -0.02733635f, 0.01693278f, -0.01462215f, 0.03585767f, 
    -0.05147011f, 0.01083450f, 0.00648880f, 0.03497226f, -0.03004572f, 0.05253911f, -0.02312491f, 0.02366421f, 
    0.02742683f, -0.05026883f, 0.00094552f, -0.06368908f, -0.04522343f, 0.02279530f, 0.00588493f, -0.03040546f, 
    0.03907698f, -0.02360521f, 0.00910772f, 0.02213015f, -0.05222821f, 0.01924050f, 0.04579306f, 0.03123154f, 
    0.04388822f, 0.01801694f, -0.03010872f, 0.04919080f, -0.00224184f, -0.05813255f, 0.00367982f, 0.04943709f, 
    -0.06048933f, -0.01669490f, -0.00256652f, 0.01405645f, -0.02727474f, 0.00566705f, -0.02091863f, 0.03408512f, 
    -0.01161635f, -0.04076352f, 0.04604469f, -0.02883062f, -0.03871382f, -0.04669632f, -0.05584168f, -0.04649472f, 
    0.04873133f, 0.01051957f, 0.02108071f, -0.00708934f, 0.03923912f, -0.05350874f, 0.02525311f, 0.02890700f, 
    0.01072365f, -0.06076019f, -0.06314858f, 0.05034311f, -0.03014011f, -0.02553737f, 0.02764260f, -0.02133431f, 
    -0.05511141f, 0.02880234f, -0.04283813f, 0.01379323f, 0.02609847f, -0.01218552f, -0.04729344f, 0.02693984f, 
    -0.03633482f, -0.05262173f, 0.01707467f, -0.04084117f, 0.00734470f, -0.01861587f, -0.04849360f, 0.03026957f, 
    0.02147220f, 0.00649287f, -0.05741773f, 0.00636854f, -0.03164251f, -0.04488549f, -0.02088579f, -0.06400740f, 
    -0.01900292f, -0.03733433f, 0.00354060f, -0.04232270f, -0.00780113f, 0.04069540f, -0.04507608f, -0.04899083f, 
    -0.05305602f, -0.04788756f, -0.04828715f, 0.02933195f, -0.05195177f, -0.02332009f, -0.00857125f, -0.04078638f, 
    0.01842630f, 0.05278552f, -0.01919045f, -0.01327314f, -0.00981616f, -0.03474174f, -0.01970809f, 0.00510688f, 
    -0.03193165f, -0.01709316f, -0.03742569f, 0.00437067f, 0.02479324f, 0.00675989f, -0.00994614f, -0.05601745f, 
    -0.04227096f, 0.00249837f, -0.00715836f, 0.03658614f, 0.03512254f, 0.04902937f, -0.00699952f, 0.01388364f, 
    -0.05011487f, 0.00514676f, 0.04511326f, -0.00592244f, -0.05464586f, -0.05852411f, 0.02331958f, 0.04373668f, 
    0.00217901f, -0.05622561f, -0.02079151f, -0.05076217f, 0.04291662f, -0.01310656f, -0.04651580f, 0.01175411f, 
    -0.02474152f, -0.02722572f, -0.03396681f, -0.02463539f, 0.01634230f, -0.02063376f, -0.04396683f, 0.00440513f, 
    -0.05812316f, -0.03473179f, -0.04216527f, 0.04022531f, -0.01301695f, -0.03590073f, -0.06137710f, -0.01628212f, 
    -0.04164997f, -0.01687317f, -0.00886409f, 0.03209052f, -0.06263673f, 0.02962518f, -0.02484695f, -0.03567338f, 
    -0.02663743f, 0.03992617f, -0.03250163f, 0.03475143f, 0.01777322f, -0.03771687f, 0.00811441f, -0.03569913f, 
    -0.01826801f, -0.06042533f, -0.02269482f, -0.00299076f, -0.03051872f, -0.00075025f, -0.06221383f, -0.05900165f, 
    0.04503528f, 0.02809389f, 0.01688500f, 0.01741410f, -0.03749429f, -0.00070115f, 0.00678595f, -0.01771743f, 
    -0.05210267f, -0.00747575f, -0.01003885f, 0.02988190f, -0.01711067f, 0.04085040f, 0.02762494f, -0.05328471f, 
    -0.04801369f, 0.02976248f, 0.01837661f, -0.01545358f, -0.02639427f, 0.00201508f, -0.02270594f, -0.00594762f, 
    0.02766902f, -0.04847272f, -0.02440378f, 0.02752084f, -0.00164024f, 0.01177569f, -0.05056167f, -0.04520582f, 
    0.02175220f, -0.01602965f, -0.05289313f, -0.02001695f, 0.02254296f, 0.02220916f, -0.04805036f, 0.04852677f, 
    -0.00611488f, 0.03278006f, 0.02787953f, 0.00389425f, 0.01454654f, -0.04512818f, 0.01908364f, 0.05104086f, 
    -0.04785695f, -0.02218331f, -0.01006580f, -0.03630655f, -0.04502310f, -0.01960826f, 0.03536816f, -0.02394827f, 
    0.05233155f, 0.04282616f, -0.00429550f, 0.03152183f, -0.03894342f, -0.04767300f, 0.01740983f, -0.03999957f, 
    -0.00087445f, 0.02193728f, -0.03960695f, 0.00346600f, -0.04804142f, -0.02285132f, -0.03119574f, 0.03501223f, 
    -0.05824571f, 0.05326949f, 0.03860490f, -0.00792806f, -0.05205480f, -0.03520656f, 0.04971693f, 0.00079326f, 
    -0.05899153f, -0.05828122f, -0.00952953f, 0.00339452f, 0.00011304f, -0.03421317f, 0.03443691f, 0.01079119f, 
    0.04051599f, -0.05686372f, 0.00015658f, 0.04496906f, -0.01751537f, 0.02470608f, -0.03964000f, -0.00437422f, 
    -0.02719615f, 0.05398555f, -0.01548364f, -0.04763284f, 0.01280676f, 0.01201665f, 0.04208162f, -0.04012706f, 
    0.02713868f, -0.04164550f, -0.03663525f, 0.02254981f, -0.03939157f, -0.01917797f, 0.05428893f, -0.01743670f, 
    0.05042714f, -0.02804761f, 0.04693627f, -0.01368846f, -0.03080890f, -0.02765995f, 0.01753333f, -0.03374519f, 
    -0.03459236f, 0.00776896f, 0.02455846f, -0.04234410f, -0.06149000f, 0.04431383f, 0.02689545f, -0.02747433f, 
    -0.05812194f, 0.04766181f, -0.03799969f, 0.02218197f, 0.04396282f, -0.02577930f, 0.01143046f, -0.02308139f, 
    0.02988925f, 0.04312863f, -0.02224798f, -0.02611866f, -0.04574902f, -0.05789391f, 0.01772964f, -0.02570503f, 
    0.03804547f, -0.04817478f, 0.02504972f, -0.06134836f, -0.03986364f, -0.03496265f, -0.01601134f, 0.02268983f, 
    0.00717892f, 0.04541079f, -0.02703853f, 0.02176459f, -0.02679807f, -0.03447469f, -0.05680397f, 0.01928320f, 
    0.03413520f, -0.01479681f, -0.04022586f, -0.00802337f, -0.05821206f, -0.00993046f, 0.05027251f, 0.05020173f, 
    0.02702109f, -0.06195515f, 0.04131725f, 0.02974801f, -0.00961908f, 0.00724906f, -0.01747950f, -0.04419702f, 
    0.04289517f, 0.00568468f, -0.02463109f, -0.01143476f, -0.03817421f, -0.01903531f, 0.04224473f, -0.03329280f, 
    -0.06246500f, -0.02094956f, -0.00754972f, 0.01123589f, -0.02030095f, 0.02466247f, 0.02395658f, -0.00380490f, 
    -0.05327608f, 0.02427369f, -0.03292685f, 0.03453619f, 0.00814739f, -0.04433645f, 0.01744683f, -0.06269299f, 
    0.01043464f, 0.04188888f, 0.01606356f, 0.01386091f, -0.00102809f, 0.03682316f, -0.00688177f, -0.04317803f, 
    -0.02880512f, -0.00989936f, -0.06053054f, -0.05827867f, 0.02521604f, 0.01101577f, -0.04069376f, -0.04486407f, 
    -0.06000626f, -0.04406396f, -0.02918441f, -0.00163958f, -0.03343324f, -0.03861357f, -0.01083024f, 0.02152945f, 
    -0.03038401f, -0.03517965f, -0.02396211f, 0.02852637f, -0.01102793f, 0.04093482f, -0.02622262f, -0.03943866f, 
    -0.06051089f, 0.05802726f, 0.04883332f, -0.05642683f, -0.04132567f, 0.02740555f, -0.05222201f, -0.05723035f, 
    0.03107388f, -0.05371188f, 0.00016957f, -0.00542098f, 0.02404646f, -0.00029670f, -0.03275320f, 0.03475845f, 
    0.03053147f, 0.00289204f, -0.04373165f, -0.03355049f, -0.02495303f, -0.04404548f, -0.00007888f, -0.01256884f, 
    -0.00969922f, -0.01790464f, -0.03228817f, 0.00537386f, -0.02377803f, 0.01517699f, -0.01874925f, 0.00388931f, 
    -0.04536615f, 0.02655057f, -0.01789257f, -0.02142835f, -0.00399668f, -0.01324681f, -0.03139373f, 0.02607210f, 
    0.02857717f, -0.00467549f, -0.04761498f, -0.04008910f, -0.02352811f, -0.02847629f, 0.05367501f, 0.02417598f, 
    -0.00873515f, -0.04388361f, -0.01347872f, -0.05313913f, -0.03077605f, 0.05397651f, 0.00973231f, -0.03717812f, 
    0.00313799f, -0.00402973f, -0.04965647f, 0.00183216f, -0.01991872f, -0.02788308f, 0.03158792f, 0.03942423f, 
    -0.00628166f, 0.01551007f, 0.02411262f, 0.04975398f, -0.04338855f, 0.04927663f, 0.00571602f, -0.02087141f, 
    0.03106234f, 0.01402755f, -0.02602828f, -0.05618181f, 0.04284525f, -0.03263575f, -0.00013156f, 0.01001028f, 
    -0.04224783f, -0.04335186f, -0.02621111f, 0.04022577f, 0.00023838f, 0.04603752f, -0.05882172f, -0.04416673f, 
    0.00300014f, -0.05220939f, -0.06224535f, -0.05074985f, -0.00400309f, 0.00550672f, 0.04207174f, -0.00391529f, 
    0.04031774f, -0.05189362f, -0.00559779f, -0.04841579f, 0.02031001f, -0.04552150f, -0.05673474f, -0.04068560f, 
    0.04728792f, 0.04597770f, -0.03110782f, 0.01515516f, -0.03205420f, -0.02113277f, -0.02953543f, -0.02663067f, 
    -0.03383665f, -0.03111336f, -0.01108066f, -0.06144882f, 0.01350014f, -0.04984571f, -0.04076146f, 0.01402607f, 
    -0.06069636f, -0.03206418f, -0.02891859f, 0.03533961f, 0.02456088f, -0.02516904f, -0.04564356f, -0.04575234f, 
    -0.02802531f, 0.00359679f, -0.05563296f, 0.01654745f, 0.02673807f, -0.07605447f, 0.00450608f, -0.03918754f, 
    -0.00609975f, -0.11501443f, -0.02781117f, -0.04342100f, -0.04824911f, -0.05594842f, -0.03175896f, 0.02246275f, 
    -0.01574935f, 0.04910038f, -0.10686074f, -0.04969808f, -0.03270884f, 0.02560866f, 0.01721020f, 0.02902247f, 
    0.03877024f, -0.01895806f, 0.04313915f, -0.02150368f, -0.08855114f, -0.01204852f, 0.02570420f, 0.01682692f, 
    -0.06050083f, -0.00596810f, -0.09944528f, 0.05893718f, 0.02383367f, -0.00083485f, -0.04621623f, -0.09545285f, 
    -0.03198151f, -0.05368634f, -0.00956317f, -0.05663801f, -0.00813510f, -0.02880986f, -0.03402486f, -0.06998444f, 
    -0.04122293f, -0.04952573f, -0.03859690f, -0.01621681f, -0.00286938f, -0.00141659f, -0.07831651f, -0.02393281f, 
    -0.03633566f, 0.04071797f, 0.02273681f, -0.01100149f, -0.08761925f, -0.09706711f, -0.09299085f, -0.05210587f, 
    -0.09344476f, 0.02506449f, -0.06315352f, 0.00497693f, -0.06934675f, -0.02648690f, 0.04714380f, -0.03860353f, 
    -0.07688648f, 0.02032284f, 0.02161272f, 0.00521984f, -0.09340769f, -0.07368607f, 0.04524232f, 0.06443280f, 
    0.01683008f, 0.03144823f, 0.02139851f, -0.00814942f, -0.01572792f, -0.06819277f, 0.02799512f, -0.03286080f, 
    -0.01391355f, -0.01572935f, -0.10277127f, 0.04391017f, 0.05111130f, -0.03739514f, -0.06332321f, -0.04745780f, 
    -0.05843163f, -0.00192542f, 0.03591544f, -0.01353023f, -0.04701952f, -0.07221407f, 0.00290780f, -0.04859855f, 
    0.00131248f, -0.02545745f, -0.06491952f, 0.03302633f, -0.01455634f, -0.07589199f, -0.04100785f, 0.04093835f, 
    0.03647421f, 0.00362139f, 0.00214559f, -0.05485537f, -0.06812254f, -0.05650336f, -0.03069128f, -0.00019718f, 
    -0.05265561f, -0.04091736f, -0.01330594f, -0.00987822f, -0.09524509f, -0.01339230f, -0.00634175f, 0.02039103f, 
    -0.02562553f, -0.00427280f, -0.04654118f, -0.04686897f, 0.01560610f, -0.02637932f, -0.04168792f, -0.10608138f, 
    -0.06677707f, 0.01701067f, -0.05426393f, -0.02723744f, -0.00461064f, 0.01260496f, -0.03279839f, 0.01004006f, 
    0.00152902f, -0.05923099f, -0.03228170f, -0.01916609f, -0.00977470f, -0.07401825f, 0.09311298f, -0.05370182f, 
    0.02244569f, -0.05272284f, -0.01227039f, 0.02282966f, -0.01329833f, 0.01978477f, 0.00609306f, -0.02681339f, 
    -0.06216652f, -0.02490219f, -0.05046378f, -0.07004014f, -0.06050251f, 0.01128005f, 0.02063325f, -0.08117247f, 
    -0.06259950f, -0.03687213f, -0.05584039f, -0.03324071f, -0.06759340f, -0.03168632f, -0.04214088f, -0.01387898f, 
    -0.04704599f, 0.01904496f, -0.00539995f, -0.00445814f, -0.05511897f, -0.05135528f, -0.05973992f, -0.04603440f, 
    0.03157146f, -0.09055759f, 0.01771106f, -0.05746249f, 0.01220562f, -0.10425092f, -0.04843814f, 0.03138386f, 
    -0.03129200f, 0.00891725f, -0.06768373f, -0.01231420f, -0.02752009f, -0.04266187f, -0.03519121f, 0.02969661f, 
    -0.04159721f, -0.03734291f, -0.06592502f, -0.08881278f, -0.07340539f, -0.01371939f, -0.09418055f, -0.07877506f, 
    -0.00742513f, 0.00900670f, -0.03290795f, -0.07161867f, -0.02292625f, -0.03561027f, -0.01357735f, -0.02735561f, 
    -0.02157813f, -0.05349059f, -0.03427655f, 0.05403135f, -0.04922127f, -0.09681615f, 0.01713557f, -0.04307018f, 
    -0.01496251f, 0.00447012f, -0.05377140f, 0.04285058f, -0.01116959f, -0.04662336f, -0.04340008f, 0.00873906f, 
    -0.06533051f, 0.02333711f, -0.08460414f, -0.05114098f, -0.03284813f, -0.02479940f, -0.06440217f, -0.03493471f, 
    -0.02309794f, 0.00200531f, 0.02790101f, -0.06055285f, -0.04917077f, -0.01625258f, 0.00055642f, 0.05059323f, 
    -0.01638477f, -0.04789072f, 0.03101557f, 0.00870987f, 0.00434375f, -0.09569663f, -0.04602675f, -0.01771882f, 
    -0.04935485f, 0.00386116f, 0.05706526f, -0.02807609f, -0.02612277f, -0.03132537f, -0.07207017f, 0.02818571f, 
    0.00495388f, -0.07381667f, -0.11064777f, -0.00137734f, -0.01811321f, 0.00459336f, -0.11849590f, -0.04417044f, 
    0.04124765f, -0.01631572f, -0.05783103f, 0.02594468f, -0.01583840f, -0.05578508f, 0.03934475f, -0.07598849f, 
    -0.01377782f, -0.04556360f, -0.05360541f, -0.00490418f, -0.02867879f, -0.01543524f, 0.02194316f, 0.02714854f, 
    -0.01103963f, 0.00370619f, -0.04572279f, -0.05321731f, -0.03349233f, 0.03688964f, -0.02741852f, -0.00717798f, 
    -0.04293157f, -0.04140868f, -0.01592977f, 0.01874745f, 0.01863683f, -0.05333291f, 0.01152197f, -0.02125591f, 
    -0.00719299f, -0.05997126f, -0.02466844f, -0.02937414f, 0.02339839f, 0.04257857f, -0.01723395f, -0.00280084f, 
    0.00969818f, 0.05362022f, -0.05727123f, -0.02569387f, 0.02490527f, 0.01137529f, -0.04001205f, -0.04132074f, 
    -0.05012225f, 0.00454976f, -0.04918642f, 0.01090886f, 0.03014764f, -0.04776945f, -0.06064976f, 0.03028138f, 
    0.01772236f, 0.01746792f, 0.00855328f, 0.03293993f, -0.05402621f, 0.01375262f, 0.03169930f, -0.02225422f, 
    -0.06456099f, -0.00765098f, -0.00978267f, 0.00785652f, -0.03357312f, 0.01905756f, -0.03310570f, -0.05926102f, 
    -0.03541878f, 0.03123631f, 0.03567168f, -0.05739449f, 0.01108259f, -0.02632158f, -0.00359344f, 0.01746407f, 
    0.04667399f, -0.04321867f, 0.02805761f, 0.01437563f, -0.00419385f, 0.01500153f, -0.01429188f, 0.03017900f, 
    0.04979940f, -0.03169971f, 0.04386761f, -0.06218088f, -0.04240137f, -0.05546993f, -0.06325058f, -0.00438645f, 
    0.02120367f, 0.01534848f, 0.02079985f, -0.03879916f, 0.03472147f, -0.05178411f, 0.03681914f, 0.05706934f, 
    -0.05513074f, 0.02619661f, 0.03370707f, 0.03756952f, -0.02860872f, -0.04283520f, -0.03061706f, -0.04460488f, 
    -0.02354274f, 0.04528535f, 0.02995079f, 0.00898277f, -0.03483177f, -0.00981023f, -0.05225080f, -0.02163611f, 
    -0.03123571f, 0.01248686f, 0.04983585f, -0.00704366f, -0.00593709f, -0.05367652f, -0.03278099f, -0.01720873f, 
    0.04279226f, 0.01663382f, -0.00989189f, -0.03348836f, -0.00917512f, -0.01596689f, -0.00191438f, 0.04579213f, 
    0.03990481f, -0.01359425f, -0.00947599f, -0.00902652f, -0.05703313f, -0.04091224f, -0.04071658f, -0.00431132f, 
    -0.06441794f, -0.02682541f, 0.02781662f, 0.01522771f, -0.00343205f, -0.03809127f, 0.04914293f, -0.05007361f, 
    0.02937046f, 0.02614528f, 0.03216157f, 0.02014091f, -0.06881922f, -0.00758388f, 0.02507207f, -0.05291005f, 
    -0.00805055f, -0.01577798f, 0.06470293f, -0.02937104f, -0.04139908f, 0.05102153f, 0.03248791f, -0.01781193f, 
    -0.05173296f, 0.02317050f, -0.00406051f, -0.03739000f, -0.04479588f, -0.05012955f, 0.01795042f, -0.01247910f, 
    -0.03552734f, 0.01159798f, 0.02732804f, -0.04408618f, 0.01781739f, 0.05034681f, 0.01751508f, -0.05385941f, 
    0.01582406f, -0.05140969f, -0.03734727f, -0.05411566f, 0.01271049f, -0.01981862f, 0.00050398f, -0.00243408f, 
    -0.00606405f, -0.01872608f, -0.00887119f, 0.04230651f, 0.03195846f, 0.05388262f, 0.04355784f, 0.01173083f, 
    0.02907629f, -0.04574320f, 0.03278610f, -0.00139750f, -0.04771789f, -0.06841742f, -0.04428308f, 0.02977030f, 
    -0.04505592f, -0.01996862f, -0.02626616f, 0.04766706f, -0.05299905f, -0.01135812f, -0.04319564f, 0.04362228f, 
    -0.01789935f, 0.04614029f, -0.02250130f, -0.03589751f, 0.04887505f, -0.00367095f, -0.01267225f, 0.04115766f, 
    0.04741856f, 0.03087770f, 0.04075587f, -0.00579957f, -0.03590639f, 0.03323517f, 0.03115244f, -0.05605577f, 
    -0.04669725f, -0.00104122f, -0.04613179f, -0.02822443f, 0.03662424f, -0.04875220f, -0.00954053f, -0.01227553f, 
    0.04438780f, -0.03193563f, -0.02910078f, -0.04233219f, 0.01395680f, -0.01146948f, 0.04043519f, -0.02764901f, 
    -0.04501554f, 0.05876838f, 0.04087411f, 0.04445897f, -0.03285799f, -0.05073906f, -0.01891733f, 0.02370197f, 
    -0.01089212f, -0.04558095f, -0.03546754f, 0.03347887f, -0.03290122f, -0.06396839f, 0.01858262f, -0.01587222f, 
    0.04057043f, -0.04204194f, 0.04667361f, -0.03542304f, -0.04164008f, 0.01146406f, 0.04747152f, -0.04901224f, 
    -0.03109282f, -0.05709327f, -0.01228515f, 0.01686444f, -0.03336167f, 0.02880238f, -0.01480599f, -0.04853670f, 
    0.05805645f, 0.04233649f, -0.04876648f, 0.02411289f, 0.04292644f, 0.01211131f, 0.04758581f, -0.02164026f, 
    0.03655054f, 0.04744251f, 0.02112221f, 0.01381598f, 0.01850537f, -0.04174636f, -0.01695402f, -0.05289343f, 
    0.00250000f, 0.03081769f, -0.02370770f, 0.00871520f, -0.06652106f, 0.04980425f, 0.02233247f, -0.06144103f, 
    0.10995531f, -0.13881581f, -0.31497434f, 0.02762531f, 0.11414122f, -0.03526111f, 0.24381329f, 0.14064406f, 
    0.17270383f, 0.05441975f, 0.46434841f, 0.18286797f, -0.00988812f, -0.17883904f, 0.06730378f, -0.12725888f, 
    0.09891866f, -0.07061820f, -0.16261414f, -0.07585949f, 0.19261535f, 0.13941364f, 0.05772789f, 0.25590762f, 
    0.02972101f, 0.09779084f, -0.05257807f, 0.50992703f, 0.08397146f, -0.28074211f, 0.49360561f, 0.06295255f, 
    0.29323107f, -0.01578305f, -0.26330006f, 0.00939883f, -0.02576759f, -0.30276129f, 0.05780854f, 0.09117372f, 
    -0.06348716f, -0.02936843f, -0.08642990f, -0.10171677f, -0.06467371f, 0.02751763f, -0.04488306f, -0.04440032f, 
    0.50616372f, 0.30168530f, 0.44152790f, 0.15559292f, 0.10231759f, -0.17699231f, -0.04695204f, -0.08032736f, 
    -0.11563289f, 0.06304996f, 0.00531222f, -0.12249086f, -0.00654784f, 0.06449255f, 0.20730187f, 0.16948041f, 
    0.05434731f, 0.01147145f, -0.40308064f, -0.25938877f, -0.14453273f, 0.00455409f, -0.06668329f, -0.29161683f, 
    0.11240634f, 0.45211056f, 0.36091948f, 0.29437184f, -0.13851026f, -0.07227784f, -0.06364173f, 0.00213028f, 
    0.18431713f, -0.23736636f, -0.29978701f, -0.08784515f, -0.35096917f, -0.01394420f, 0.07295610f, 0.27062127f, 
    -0.19434489f, -0.10698445f, -0.01933730f, 0.25433013f, 0.37816444f, 0.22985452f, 0.15949179f, -0.08336948f, 
    0.05434529f, 0.12964115f, 0.09395585f, 0.10114311f, 0.21928231f, 0.26395723f, 0.03151992f, 0.10720970f, 
    0.08768269f, 0.05068239f, -0.00433897f, 0.06920604f, 0.36560529f, 0.21192083f, 0.23316075f, -0.17202798f, 
    0.16487546f, 0.06758231f, -0.22659136f, 0.02899100f, 0.27507025f, -0.17661044f, -0.48789310f, 0.00916749f, 
    0.19313656f, 0.09823986f, 0.12258906f, 0.09987257f, -0.29192343f, -0.13774444f, 0.08457091f, -0.40265635f, 
    -0.31276825f, -0.15962389f, 0.18855186f, 0.33420068f, 0.15029499f, 0.11331633f, -0.05093346f, 0.02123220f, 
    0.20523503f, 0.00561486f, -0.08764095f, -0.06020476f, -0.01671499f, -0.10805694f, 0.08323502f, -0.34343854f, 
    -0.31554842f, 0.28072226f, -0.49348649f, 0.43062010f, 0.16845234f, 0.17816231f, 0.05682657f, -0.10805859f, 
    0.12209074f, -0.99822348f, -0.35119084f, -0.48431286f, 0.29375744f, 0.38339964f, -0.09525262f, -0.01959012f, 
    0.00846073f, -0.13212697f, -0.42841089f, 0.18019040f, -0.48840958f, 0.20905353f, 0.29171032f, -0.13274778f, 
    -0.07604034f, -0.04847453f, -0.12286533f, -0.02928883f, -0.17371151f, 0.28729981f, -0.25775486f, 0.02829686f, 
    0.23141029f, 0.32230654f, 0.22472325f, 0.13464609f, -0.41866973f, -0.20383653f, -0.00506941f, -0.07764696f, 
    -0.27403060f, -0.16229707f, -0.25188988f, 0.11782862f, -0.29075018f, 0.15357614f, 0.38609403f, 0.31015429f, 
    -0.13995208f, -0.14101945f, 0.13266386f, 0.17885168f, 0.06563634f, 0.19364348f, 0.01106398f, 0.19281073f, 
    0.40373325f, -0.14149743f, -0.10547179f, -0.09993920f, 0.14064074f, 0.27146918f, 0.20892678f, -0.20489126f, 
    0.21028109f, -0.08025649f, 0.05212280f, -0.04425644f, -0.05174796f, -0.08520418f, -0.06345104f, -0.25809443f, 
    -0.09850053f, -0.29756907f, -0.38359645f, 0.31121817f, 0.32785171f, 0.23443101f, -0.00551354f, -0.20781392f, 
    -0.11375013f, -0.12777072f, -0.04616365f, -0.18264407f, 0.39907578f, 0.26803860f, 0.09763593f, 0.10227745f, 
    0.23129584f, 0.23029412f, -0.07985988f, -0.02232618f, 0.68709928f, -0.24133281f, -0.06767367f, -0.15306726f, 
    -0.03338672f, 0.02596786f, 0.01657263f, -0.13845766f, -0.59079289f, -0.24818553f, 0.25328416f, 0.27639320f, 
    0.30363387f, -0.03692991f, 0.01201191f, -0.46536022f, 0.12396380f, 0.18773526f, -0.03016472f, 0.03047452f, 
    0.06384581f, 0.08319904f, 0.17996065f, 0.14871696f, 0.27163047f, 0.14277647f, -0.25011581f, 0.03052810f, 
    -0.21311788f, -0.00388732f, 0.16056989f, -0.12315747f, 0.14839068f, 0.18392336f, -0.42039245f, -0.04310665f, 
    0.42219815f, 0.00767977f, 0.01826226f, -0.02786579f, -0.11583823f, -0.10431588f, -0.17198794f, 0.20521693f, 
    0.18505137f, 0.16690552f, 0.23806834f, -0.03528510f, 0.15959191f, 0.04596997f, -0.00035034f, -0.24232203f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.06722618f, 0.06748332f, -0.04947126f, 0.01689048f, 0.05765228f, 0.06739577f, -0.02807252f, 0.09963188f, 
    0.02364609f, -0.05142764f, 0.15681601f, -0.12229062f, -0.03451572f, 0.01839718f, 0.05839723f, -0.14500113f, 
    0.16454361f, -0.03809661f, -0.00607612f, -0.00568270f, 0.06706762f, -0.00153543f, 0.05184174f, 0.31582931f, 
    -0.02907727f, -0.04330305f, 0.02022275f, -0.01230678f, -0.00586692f, -0.08181373f, -0.00060673f, 0.22145042f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.08841480f, 0.23950313f, -0.28061745f, 0.04714351f, -0.30034348f, -0.23203422f, 0.01709328f, 0.60912097f, 
    -0.14662358f, 0.13674693f, -0.13628878f, 0.28259125f, 0.27630311f, -0.17262302f, 0.04668746f, -0.33477193f, 
    -0.00006624f, -0.05032255f, -0.21661735f, -0.11286965f, -0.66055709f, -0.03876770f, 0.59712017f, -0.65731651f, 
    0.28467372f, 0.26741996f, -0.69187409f, 0.07837158f, 0.05543087f, -0.15486704f, 0.05316648f, -0.03490642f, 
    -0.05685598f, 0.04764894f, 0.18858936f, 0.35546112f, -0.63393515f, -0.22036353f, 0.11521940f, 0.47714794f, 
    -0.03348056f, 0.14241676f, -0.44062531f, 0.43264538f, 0.26940754f, -0.40378439f, 0.02781294f, -0.41624659f, 
    0.36315450f, 0.10274811f, 0.25406289f, -0.02236498f, 0.34000394f, 0.16730982f, -0.02592785f, 0.34317338f, 
    -0.32887432f, -0.61434168f, -0.17396127f, -0.01240660f, -0.01544099f, 0.03364282f, -0.00885515f, -0.25909486f, 
    0.00698682f, -0.28116634f, -0.56007409f, 0.46378314f, -0.40269175f, 0.22417030f, -0.01700053f, -0.11470093f, 
    0.15126367f, -0.09484648f, -0.35413587f, 0.56696111f, -0.06126349f, 0.57786214f, -0.17053686f, -0.07367541f, 
    0.54289091f, -0.03457301f, 0.18166113f, -0.13204905f, -0.54488289f, -0.00821290f, -0.75372416f, -0.57100528f, 
    -0.33055803f, -0.17186207f, -0.13741626f, 0.08224405f, -0.06720635f, -0.11936674f, 0.00002875f, -0.11773050f, 
    -0.08517775f, 0.53349036f, -0.26049748f, 0.17285134f, 0.79373044f, -0.35432479f, -0.12254179f, -0.63881159f, 
    0.09987977f, 0.04324431f, -0.22067218f, -0.39070436f, 0.10253442f, 0.29523998f, 0.35867304f, 0.30880970f, 
    -0.12192731f, 0.01187832f, -0.56106687f, 0.01994915f, 0.46467012f, -0.04982594f, -0.40906149f, -0.31409994f, 
    0.25340247f, -0.35829738f, -0.30008337f, 0.02577271f, 0.10504019f, -0.05073927f, 0.10476627f, -0.41214696f, 
    0.16414560f, 0.50237554f, 0.12181088f, 0.04900965f, -0.04793213f, -0.09656776f, 0.10528244f, 0.21275516f, 
    -0.05620547f, -0.16504632f, 0.44171059f, -0.38572845f, -0.49927270f, 0.00593005f, -0.09945939f, 0.43823037f, 
    0.18356347f, -0.06286016f, -0.76513588f, -0.08369906f, -0.46711278f, -0.04475738f, -0.65899742f, 0.33779776f, 
    -0.12846828f, 0.19249442f, 0.11010537f, -0.07140229f, 0.12871750f, 0.00169410f, 0.16383465f, -0.03349473f, 
    0.06723804f, -0.29294717f, 0.00765275f, -0.77243304f, 0.00158356f, -0.08716821f, 0.01675840f, 0.24209088f, 
    0.08594269f, -0.03410254f, -0.22347994f, 0.18907103f, 0.20156275f, -0.67159301f, 0.23485628f, 0.07296783f, 
    -0.37263644f, 0.14374241f, 0.21455106f, -0.10695454f, 0.30167016f, -0.09173419f, 0.03231387f, 0.38485613f, 
    -0.72662914f, -0.00188887f, 0.03764250f, 0.11508942f, 0.12587327f, -0.12572375f, -0.06964897f, 0.21915790f, 
    -0.13806801f, 0.39727610f, -0.20293148f, -0.32400832f, -0.09402116f, -0.53407776f, -0.09022398f, -0.18105109f, 
    0.15418059f, 0.08190237f, 0.18912971f, -0.59924221f, 0.44055519f, -0.00230042f, -0.73959649f, -0.24581324f, 
    -0.38853917f, 0.07243732f, 0.08024679f, 0.00037551f, -0.49150193f, 0.05024728f, -0.45786557f, -0.20366129f, 
    0.22786444f, 0.17972545f, 0.64435345f, -0.08603816f, 0.15830599f, -0.21842462f, -0.12892179f, 0.33438453f, 
    0.15342376f, -0.25204384f, 0.49572784f, -0.12725273f, -0.28280097f, 0.03697054f, 0.02346786f, -0.44309163f, 
    0.08566435f, -0.04727318f, -0.15119274f, 0.41385895f, -0.13062137f, 0.05639009f, 0.05826977f, 0.73881000f, 
    -0.22793873f, 0.11572004f, -0.19324693f, -0.05800404f, -0.06032282f, -0.14982137f, -0.09231585f, -0.50066340f, 
    0.08509503f, 0.51659584f, -0.26680961f, 0.10992035f, -0.13102676f, -0.04806689f, 0.11872517f, -0.42495692f, 
    0.01076293f, -0.31464353f, -0.05289895f, 0.33397225f, 0.13065289f, 0.84294790f, 0.12100841f, 0.20066217f, 
    0.13957652f, -0.01077052f, -0.34484988f, -0.17614144f, 0.18274322f, -0.54436183f, -0.80770713f, -0.00027474f, 
    -0.49348038f, 0.05368432f, 0.09937713f, -0.15131201f, 0.45700189f, -0.03991768f, 0.17857604f, 0.04029959f, 
    -0.04199870f, -0.33982334f, 0.08404529f, -0.09029737f, -0.12681764f, 0.12448628f, 0.04597456f, -0.37497783f, 
    -0.07425854f, -0.39289835f, -0.03823339f, -0.15775391f, -0.34693012f, 0.17178068f, 0.10868356f, -0.56852561f, 
    0.04225694f, -0.05550709f, 0.52234721f, -0.38012558f, -0.52399284f, 0.09840628f, 0.41390392f, -0.60110325f, 
    -0.02567226f, 0.11156220f, -0.21763685f, -0.05494926f, -0.32022423f, 0.15392260f, 0.58009833f, 0.21553563f, 
    0.22394404f, -0.30918512f, -0.83328766f, -0.03809227f, -0.12916653f, 0.07491837f, 0.14081791f, 0.42020655f, 
    0.14370829f, 0.06525738f, -1.11300290f, 0.33801109f, 0.13644731f, -0.18589073f, -0.10529187f, -0.38086841f, 
    -0.02211651f, 0.02648442f, 0.13065107f, 0.19120000f, -0.57811826f, -0.01606593f, 0.14798048f, -0.43322909f, 
    -0.27435064f, 0.13002761f, 0.44296202f, 0.08471292f, 0.59903115f, 0.10208195f, 0.33097771f, -0.00884628f, 
    0.18795997f, 0.54610336f, -0.11269699f, 0.00280141f, -0.08158972f, -0.03766068f, -0.08454292f, -0.55043495f, 
    -0.07957603f, -0.08618198f, 0.72568649f, 0.11100942f, 0.38763484f, -0.37495530f, -0.05980304f, -0.20951343f, 
    0.01825933f, 0.04079464f, -0.39155462f, -0.27614230f, -0.38664168f, 0.38933259f, 0.31568775f, -0.61416477f, 
    -0.21060847f, 0.06973358f, 0.16380510f, 0.06686101f, -0.16857804f, 0.13294783f, 0.22733466f, -0.53509265f, 
    0.28284147f, -0.28031924f, 0.79037148f, 0.02024541f, 0.02200042f, -0.12983082f, -0.17364803f, -0.24584152f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.21883331f, -0.02613638f, 0.02056740f, -0.01174007f, 0.17501411f, 0.17568037f, 0.05960033f, -0.33330747f, 
    0.01535398f, -0.03131144f, -0.18090929f, 0.11422876f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
