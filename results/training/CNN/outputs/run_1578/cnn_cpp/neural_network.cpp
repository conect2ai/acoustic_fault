#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.43589601f, 0.05707211f, 0.08536842f, -0.41194376f, 0.28404203f, -0.11575769f, -0.14762408f, 0.37738344f, 
    0.45666885f, 0.32688668f, -0.54554760f, -0.05603589f, 0.09875587f, 0.13376102f, -0.17756471f, 0.18007936f, 
    -0.47268039f, 0.12247211f, -0.41540790f, -0.01567120f, -0.17346190f, 0.21055704f, 0.36942726f, -0.12538597f, 
    0.24909969f, 0.21376279f, -0.48884282f, -0.26891387f, 0.34548119f, -0.02943642f, -0.50479650f, -0.00051460f, 
    0.34921730f, -0.90663451f, -0.40041643f, 0.47671017f, -0.22138162f, 0.18494099f, 0.02261551f, 0.07028909f, 
    0.10765681f, 0.00273086f, -0.19766079f, -0.31097025f, 0.25593355f, 0.13154952f, -0.10194327f, 0.18642160f, 
    0.07721177f, -0.20640858f, -0.16410428f, -0.22379501f, 0.36893010f, 0.00071193f, -0.29519483f, 0.67544514f, 
    -0.63620108f, -0.25748679f, 0.49636534f, -0.35839865f, -0.22536390f, -0.29993060f, -0.12688047f, 0.22104026f, 
    -0.22351064f, 0.10159825f, -0.11010014f, -0.18478239f, -0.28607306f, 0.26099667f, -0.12670162f, -0.03455945f, 
    0.18199165f, -0.25725502f, -0.05409719f, -0.39832968f, -0.41460258f, -0.01307765f, 0.41322896f, -0.54982561f, 
    0.59712189f, -0.58325565f, -0.41597992f, 0.18180339f, 0.73985440f, 0.10819383f, 0.14313737f, -0.05033396f, 
    0.37071478f, 0.32868570f, -0.19817199f, 0.14484508f, -0.16491352f, -0.30987361f, -0.34790856f, 0.16791973f, 
    0.03390273f, 0.25613904f, 0.20099916f, -0.20759235f, 0.19309948f, -1.04655981f, 0.16341491f, 0.64759833f, 
    0.73887998f, 0.57661909f, -0.00082170f, -0.66981643f, -0.55416662f, -0.01871970f, 0.36332390f, -0.25674847f, 
    0.17523050f, -0.02862248f, -0.03445790f, -0.25113520f, -0.17808047f, 0.20537725f, 0.06268054f, 0.08522952f, 
    -0.07740764f, 0.19775224f, -0.04022260f, -0.10155624f, -0.11884826f, -0.50243622f, 0.33140409f, 0.20761940f, 
    0.21051528f, 0.48382348f, 0.03577375f, 0.26157770f, 0.40436259f, 0.27128756f, 0.19908826f, 0.11112411f, 
    0.19505470f, -0.12324443f, -0.10324373f, 0.05119899f, -0.14940913f, 0.16212754f, -0.16759372f, -0.16511500f, 
    -0.34141532f, -0.28304186f, 0.04643916f, 0.02871550f, 0.01027170f, -0.32981399f, 0.47743532f, 0.39838955f, 
    0.32225221f, 0.10200509f, 0.36583048f, 0.20568831f, 0.15538134f, 0.01015537f, 0.38365838f, -0.19002144f, 
    0.19753799f, -0.03211551f, 0.08850121f, 0.20606416f, -0.16333365f, 0.04367393f, -0.03817117f, -0.23415452f, 
    -0.17923549f, 0.12950379f, 0.17387974f, 0.11041502f, 0.06496486f, -0.17296501f, -0.11324381f, 0.13089117f, 
    0.23856741f, 0.42536932f, -0.43758553f, -0.31312501f, 0.21768619f, 0.02072197f, 0.14513707f, 0.31761727f, 
    -0.01919680f, 0.25337738f, -0.35053620f, 0.16940482f, -0.25173447f, -0.02123582f, -0.06819480f, 0.14310560f, 
    -0.06303111f, -0.45437291f, 0.39831766f, 0.07958931f, 0.58114409f, 0.36692688f, -0.46493796f, -0.46996158f, 
    -1.34611082f, -0.18728273f, 0.21084508f, 0.22203106f, 0.59623504f, -0.70271546f, -0.75950623f, -0.08954299f, 
    0.76770377f, 0.23252299f, 0.43564928f, -0.20349908f, -0.30490336f, 0.03833870f, 0.28766629f, 0.15903012f, 
    -0.00357330f, -0.07696340f, -0.11441465f, -0.50155705f, -0.04781054f, -0.23295911f, 0.13709795f, 0.14009723f, 
    -0.19825456f, -0.51965815f, -0.37581980f, -0.23791753f, 0.20467332f, 0.17666486f, -0.17819040f, -0.47242039f, 
    -0.53674549f, -0.39126083f, 0.09188424f, -0.04464585f, -0.30345529f, -0.32719240f, -0.27906242f, 0.14876346f, 
    -0.24839169f, -0.22474904f, -0.05611508f, -0.09547598f, -0.29235375f, -0.00586796f, -0.43004784f, -0.06320381f, 
    -0.04759670f, 0.40716705f, -0.61998719f, -0.50489241f, -0.62464428f, -0.40812886f, -0.08774847f, 0.57352495f, 
    0.50361246f, -0.02977160f, -0.48857445f, 0.91335028f, 0.01199611f, 0.00803711f, -0.13250618f, -0.05553444f, 
    0.01057364f, -0.20042519f, -0.09326517f, -0.17321874f, 0.42090195f, -0.19937982f, 0.18559153f, 0.15016167f, 
    0.20945355f, 0.27123773f, -0.06044371f, -0.31563264f, -0.34973940f, -0.30150512f, -0.46222597f, -0.65370464f, 
    0.70593882f, 0.36436412f, -0.16534770f, -0.18347798f, 0.78304034f, -0.32518724f, -0.32003734f, -0.20257851f, 
    0.01775325f, 0.02638200f, -0.05674701f, -0.29348913f, -0.10138212f, 0.27976602f, 0.21440966f, -0.17970802f, 
    -0.08432051f, 0.15625364f, -0.15065989f, -0.00243930f, -0.46477750f, -0.44738930f, -0.47054464f, 0.10986320f, 
    0.44693527f, -0.08384833f, 0.00984196f, -0.34184656f, -0.18897934f, -0.23816760f, -0.12499152f, -0.45212540f, 
    -0.18657370f, 0.16756335f, 0.43272579f, -0.31544393f, -0.15270406f, 0.28106508f, -0.25702471f, 0.22698654f, 
    0.06671131f, 0.08396411f, -0.24329826f, -0.00067660f, -0.07087963f, 0.60126168f, 0.29348981f, -0.23903437f, 
    0.56410301f, -0.33246031f, -0.21064083f, 0.28005952f, 0.17082824f, 0.05007504f, 0.16083305f, -0.20476721f, 
    0.08651508f, 0.36654815f, -0.01092030f, -0.03938209f, -0.18715335f, -0.02407745f, 0.19838718f, 0.15966511f, 
    -0.19148818f, -0.11546648f, -0.05623503f, 0.19524093f, 0.15764107f, 0.12342030f, -0.38089052f, -0.54899955f, 
    -0.46286604f, -0.40338513f, -0.42493683f, 0.05892835f, -0.12755226f, 0.06063850f, 0.41271424f, 0.25458917f, 
    -0.29411113f, -0.35847709f, -0.43146795f, -0.23563819f, 0.06401543f, 0.25468230f, 0.32064125f, -0.13947244f, 
    0.14584418f, 0.10852932f, -0.29563636f, 0.02754030f, -0.18933487f, -0.36367613f, -0.44087285f, -0.01343351f, 
    -0.22990197f, -0.15741234f, -0.20294833f, -0.60269850f, -0.40758750f, -0.39639571f, -0.55761886f, -0.17227978f, 
    -0.94058400f, 0.04428699f, 0.36363158f, 0.41378987f, 0.00582932f, 0.09184030f, 0.17740598f, -0.06390086f, 
    0.05807457f, 0.02471962f, -0.02818673f, 0.01525094f, -0.23284136f, -0.06852020f, 0.00968164f, 0.25219643f, 
    -0.36775589f, -0.11516432f, -0.14576080f, 0.40128022f, 0.29668906f, 0.46139207f, 0.27693865f, -0.48983687f, 
    -0.45886582f, 0.44148296f, 0.30574086f, -0.37914938f, -0.00659301f, -0.13407871f, -0.09561931f, -0.11129449f, 
    0.32854041f, 0.17173484f, 0.07148949f, -0.24804114f, 0.44255808f, 0.19811161f, -0.30061752f, -0.03369176f, 
    0.02122101f, -0.39048561f, 0.29904276f, 0.46202832f, 0.28483728f, -0.39875695f, -0.13722032f, -0.55917639f, 
    -0.00365834f, 0.38785279f, -0.10705911f, 0.20760532f, 0.35932648f, 0.04952383f, 0.15217461f, -0.13517155f, 
    -0.33376095f, -0.19065151f, 0.07722981f, -0.18884899f, -0.23778436f, 0.04958278f, 0.39724076f, 0.10990358f, 
    0.45834866f, 0.23684290f, 0.13750248f, 0.15408398f, 0.16154686f, -0.29980159f, 0.05548914f, -0.29749465f, 
    -0.18829218f, -0.03405056f, -0.22160389f, 0.03929168f, 0.12755083f, -0.10859214f, -0.13795605f, 0.58507377f, 
    -0.02537620f, -0.04154065f, -0.05169338f, 0.16129263f, 0.29966357f, 0.22272055f, 0.24508016f, 0.23107475f, 
    0.21431866f, 0.12200762f, 0.31157088f, -0.10386948f, 0.71416730f, 0.02686437f, -0.78311938f, 0.48372415f, 
    -0.30180359f, -0.02602902f, 0.23409471f, 0.27755651f, -0.18883629f, -0.04802195f, -0.29794112f, -0.00212259f, 
    -0.31973344f, -0.21518220f, 0.26110899f, 0.15639986f, -0.05556140f, 0.05098007f, -0.15942205f, 0.17441738f, 
    -0.18117169f, -0.58446109f, -0.15440777f, -0.17949082f, -0.26147929f, -0.38981557f, -0.65920651f, -0.52376682f, 
    0.11353786f, 0.79687154f, 0.02092620f, 0.04871144f, -0.07870504f, 0.11122250f, 0.50107533f, 0.13535282f, 
    0.25046882f, 0.04305395f, 0.04877650f, -0.21491814f, -0.07885141f, 0.07829233f, -0.27597937f, -0.24671644f, 
    -0.15656440f, 0.25677446f, -0.17504962f, 0.48517460f, 0.03398716f, -0.32423857f, -0.16629201f, 0.10826058f, 
    0.59045345f, 0.25272229f, 0.21167772f, 0.27800962f, 0.19166929f, -0.00843483f, -0.03661571f, -0.29979762f, 
    0.27595615f, 0.40953347f, -0.19658895f, -0.19990279f, -0.47153842f, 0.25430089f, -0.23070672f, -0.39606360f, 
    0.22138719f, 0.27435797f, -0.03829185f, 0.02139619f, 0.08771903f, 0.34196228f, 0.25214127f, 0.21939708f, 
    0.16479516f, 0.30142379f, 0.26706135f, -0.41282004f, -0.06690064f, 0.23675001f, 0.49221569f, -0.08310254f, 
    -0.22144601f, -0.45056853f, -0.03087117f, 0.16102667f, -0.08892925f, -0.16151221f, 0.37746888f, 0.17792983f, 
    0.30003306f, 0.13843364f, -0.13799033f, -0.17119542f, -0.34028944f, -0.16362162f, 0.28979543f, 0.22204831f, 
    -0.60698527f, -0.65780640f, -0.34045753f, 0.02768063f, 0.40132183f, 0.53399861f, -0.04117585f, 0.53046429f, 
    -0.26566017f, -0.23125906f, 0.11721845f, 0.13252144f, 0.16435094f, 0.28318387f, 0.10746723f, 0.24588548f, 
    -0.20997250f, -0.23649801f, -0.10350325f, -0.06847121f, -0.42731318f, 0.09597944f, 0.22105348f, 0.19053209f, 
    -0.41296354f, -0.30622089f, -0.18849394f, -0.05635143f, 0.32016590f, 0.29772928f, -0.08921444f, 0.18374896f, 
    -0.45610517f, -0.26825199f, 0.47449455f, 0.13435774f, -0.08974119f, 0.18391019f, 0.03910636f, -0.24626195f, 
    -0.09364036f, -0.11264652f, 0.10138680f, 0.21776739f, -0.22849654f, -0.12837857f, -0.07570413f, -0.33101967f, 
    -0.51277500f, 0.55646867f, 0.47871053f, -0.25378543f, -0.14181168f, 0.18320598f, 0.05398836f, -0.17316699f, 
    -0.32222348f, -0.09614352f, -0.28807148f, -0.04516029f, -0.20062059f, 0.46314797f, -0.41578430f, -0.26469994f, 
    -0.12148764f, -0.18203989f, 0.32016477f, -0.07027848f, 0.09984490f, -0.01373470f, -0.15138830f, 0.32130775f, 
    0.48646048f, 0.01464163f, -1.04675531f, -0.26334178f, 0.28232151f, 0.53643364f, 0.33031416f, 0.17071006f, 
    0.59981430f, 0.34683976f, -0.11391757f, -0.44712946f, -0.54949707f, -0.04407732f, -0.29614922f, 0.20637208f, 
    -0.02990628f, 0.09535901f, -0.29566988f, -0.19356468f, 0.31804636f, 0.17508665f, 0.04209401f, 0.00053941f, 
    0.30247182f, 0.13374689f, -0.23671235f, -0.26276287f, -0.50110251f, -0.46708706f, -0.52777678f, -0.72161180f, 
    0.25204298f, 0.20718694f, -0.08149654f, 0.01040371f, -0.28929466f, 0.12269888f, -0.41369697f, -0.20906465f, 
    -0.16501467f, 0.05256739f, -0.19596766f, 0.14055601f, -0.27167761f, -0.53083128f, -0.67864633f, -0.25090870f, 
    -0.21624425f, 0.50151920f, -0.13892469f, -0.39580557f, -0.60346991f, -0.40411085f, -0.80306232f, -0.38939193f, 
    0.45860738f, 0.25383827f, 0.73954576f, 0.07297266f, -0.31548807f, 0.05174926f, 0.05121478f, 0.56719822f, 
    -0.30909282f, -0.09005418f, -0.29484051f, -0.23445015f, 0.25706622f, -0.01741342f, -0.12113766f, 0.48617256f, 
    0.12523572f, -0.26166856f, -0.23362322f, 0.18792407f, -0.32147673f, 0.51589996f, 0.80750620f, 0.38107413f, 
    0.01065391f, -0.03852455f, -0.65463263f, -0.51278132f, -0.17740865f, 0.18156476f, 0.28516409f, 0.08186188f, 
    -0.33949885f, 0.11856218f, 0.09594430f, 0.11131225f, 0.26008746f, 0.21653867f, -0.24283764f, -0.15538776f, 
    -0.03632517f, -0.20360303f, 0.13991188f, -0.32157958f, 0.15369295f, 0.19148491f, 0.00770673f, 0.38754061f, 
    0.08290713f, 0.13993846f, 0.34090480f, 0.39486796f, 0.22141266f, 0.16065970f, 0.05559511f, -0.09423629f, 
    0.32842875f, -0.13759920f, -0.04687755f, -0.16440004f, -0.23196448f, 0.03804306f, 0.00741797f, -0.15877038f, 
    0.27411297f, -0.28828105f, 0.19821396f, -0.11029299f, -0.24138564f, -0.15441845f, -0.62552118f, 0.47419679f, 
    1.26476908f, 0.67928010f, -0.47681546f, -0.62881678f, -0.37767583f, -0.36619157f, -0.04609549f, 0.17187953f, 
    -0.20835829f, 0.13736695f, -0.12956542f, 0.03609781f, 0.26157179f, -0.42728409f, -0.04635616f, 0.01438216f, 
    0.23190773f, 0.09872480f, -0.16608934f, 0.08120881f, 0.10007033f, -0.21507400f, 0.09439503f, -0.25369215f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.22915417f, 0.00635165f, 0.32863969f, 0.16863918f, 0.11157374f, 0.07971384f, -0.08402666f, 0.14739406f, 
    -0.05423444f, -0.01589226f, -0.08108876f, 0.14717330f, -0.16828436f, -0.01781299f, -0.27239144f, -0.06462970f, 
    0.18083583f, -0.04312242f, 0.00650921f, -0.02829139f, 0.14178628f, 0.27521065f, -0.24112563f, 0.27508399f, 
    -0.12686957f, 0.18230304f, -0.11020873f, -0.29408857f, 0.30480278f, 0.03875250f, -0.14163595f, 0.34101307f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.02250842f, -0.01661950f, 0.01013628f, -0.01741303f, -0.00732657f, -0.03712112f, -0.03219049f, 0.03175259f, 
    0.02407875f, 0.02312466f, 0.00037635f, 0.00730754f, 0.02782678f, 0.03854121f, -0.05153676f, -0.01533561f, 
    -0.05160820f, -0.03406651f, 0.00577157f, 0.02406421f, 0.01160717f, 0.00598242f, -0.01758971f, -0.01480565f, 
    -0.04593865f, 0.00262322f, -0.03047347f, -0.00236462f, 0.02630613f, 0.00254557f, 0.02822115f, 0.02766425f, 
    -0.05476673f, -0.02327940f, 0.03491734f, -0.04814806f, 0.02155560f, -0.04708753f, 0.00585234f, 0.03705820f, 
    -0.04029300f, -0.01320048f, -0.04397541f, 0.03670041f, 0.00740291f, -0.05479173f, 0.00937814f, -0.00905762f, 
    0.00071512f, 0.02352638f, -0.04005431f, -0.04343275f, 0.01620043f, -0.00752301f, -0.00135930f, 0.01466528f, 
    -0.05576027f, -0.01894898f, 0.04125186f, 0.01294741f, 0.02199856f, -0.05446399f, -0.01501132f, -0.00262208f, 
    -0.02574559f, 0.04090267f, -0.05577113f, -0.01479410f, 0.01362308f, -0.02880814f, 0.04352088f, -0.00988442f, 
    -0.01615906f, -0.04442306f, -0.02924823f, 0.03859491f, -0.05271150f, -0.02331293f, -0.03617287f, -0.01955110f, 
    -0.01441676f, -0.04773328f, 0.02503435f, -0.01096198f, -0.00910501f, -0.01579443f, 0.03648990f, -0.05621454f, 
    0.03730798f, -0.04372157f, 0.00245328f, 0.04395542f, -0.04823600f, 0.00485594f, 0.00957225f, 0.01359146f, 
    0.00880796f, -0.03192240f, -0.04470894f, 0.00292857f, -0.03407701f, 0.04105603f, 0.01064017f, -0.04629743f, 
    0.04488507f, -0.02373324f, 0.00881893f, 0.01770636f, -0.04071011f, -0.03395453f, -0.01833390f, 0.01849647f, 
    -0.03911147f, -0.04589311f, 0.01740542f, -0.01834482f, -0.01306319f, -0.02048673f, 0.01113436f, 0.03025172f, 
    -0.04053279f, 0.00445162f, 0.03001596f, -0.04205935f, 0.01624390f, -0.04300923f, 0.03269684f, 0.00423436f, 
    0.02723608f, -0.01836715f, 0.01811018f, 0.02070747f, 0.02296905f, -0.02372036f, 0.03957082f, -0.04593119f, 
    0.03872523f, 0.00928884f, -0.03638744f, -0.04866106f, -0.00639796f, -0.03590591f, -0.02239827f, 0.02115723f, 
    0.04548159f, 0.00581236f, -0.02556805f, -0.01010785f, -0.02729314f, -0.01609671f, -0.02934230f, -0.01213805f, 
    -0.04532674f, -0.04505463f, -0.03363893f, 0.00508871f, -0.00898386f, -0.02794377f, -0.05245734f, -0.03185411f, 
    -0.01296869f, -0.00100523f, -0.05113546f, -0.01796832f, -0.01002223f, 0.03451531f, -0.03115325f, -0.04824104f, 
    -0.01445793f, 0.03134926f, -0.02906222f, -0.05416613f, 0.01424057f, 0.03575547f, -0.03385909f, -0.03177829f, 
    0.03961038f, -0.04393598f, -0.00870247f, -0.04660231f, -0.05229599f, -0.02593863f, 0.04991234f, 0.01331108f, 
    -0.01771803f, 0.02299151f, 0.02052859f, -0.00922698f, 0.03747370f, -0.01446117f, -0.00507012f, -0.02250696f, 
    -0.03009905f, 0.01416774f, -0.01471376f, -0.00180911f, -0.04544967f, 0.00304341f, -0.04841149f, -0.01609150f, 
    -0.01731601f, -0.04518876f, -0.04488243f, -0.03518580f, -0.05318232f, -0.04144214f, 0.03853191f, 0.01931451f, 
    -0.00338793f, 0.02093678f, -0.02799049f, 0.03572040f, 0.02482768f, -0.01275909f, -0.01607860f, -0.02989951f, 
    -0.05078313f, 0.01309008f, -0.01478801f, -0.03586641f, 0.04143630f, 0.02568575f, 0.01357100f, 0.00142365f, 
    -0.03513228f, -0.03777367f, -0.00967220f, 0.04421703f, -0.04311333f, 0.04544986f, -0.05127960f, -0.04301614f, 
    -0.04312664f, 0.03081684f, -0.00178014f, -0.02626523f, 0.00504390f, 0.01917073f, -0.02382098f, -0.04031598f, 
    -0.04059611f, 0.01599937f, 0.01603101f, -0.05306606f, -0.05285381f, -0.01819009f, 0.01456531f, -0.03999854f, 
    0.01349975f, -0.02867046f, -0.03745028f, 0.04419720f, 0.03214782f, -0.05118053f, 0.02849926f, -0.03034128f, 
    0.02564346f, -0.05231649f, 0.02848215f, -0.02817881f, 0.03064003f, -0.04253744f, -0.02461334f, -0.02265217f, 
    -0.04192485f, -0.04694753f, 0.01790808f, -0.02432045f, -0.02931614f, 0.03686095f, 0.02862773f, -0.02396762f, 
    -0.00895636f, 0.01756473f, 0.00209799f, 0.03430537f, -0.02186627f, -0.02343369f, -0.03802675f, -0.04266138f, 
    -0.00172987f, -0.01377116f, -0.04388337f, -0.03050220f, -0.00265780f, -0.02344943f, 0.01122935f, -0.01280652f, 
    -0.02196641f, 0.01565951f, -0.00197915f, 0.03856450f, 0.02485624f, -0.00644408f, 0.00881254f, -0.01668150f, 
    -0.05269067f, 0.02055290f, -0.00851598f, 0.03100078f, 0.01016642f, -0.05029416f, -0.01986944f, -0.00049505f, 
    0.00737415f, -0.02816320f, -0.00128123f, -0.05009692f, -0.00370348f, 0.00434462f, 0.03950082f, -0.00282551f, 
    0.00255600f, -0.03223112f, 0.02301210f, 0.00031763f, 0.04239133f, -0.05045193f, -0.03215893f, 0.02730437f, 
    0.03335463f, -0.03235778f, -0.03136207f, 0.02510858f, -0.05605779f, 0.03127387f, -0.03098543f, 0.01804974f, 
    -0.01067839f, -0.01851502f, -0.01099846f, -0.01021909f, 0.03412529f, 0.00406572f, -0.01098800f, -0.00648132f, 
    -0.02418873f, -0.02150466f, -0.04559606f, -0.03054991f, -0.03074384f, -0.03154521f, -0.00352534f, 0.03801692f, 
    0.00020395f, -0.01865410f, -0.03771185f, -0.04216877f, -0.01667476f, -0.01905719f, 0.03236379f, 0.00475889f, 
    0.01312738f, 0.03056082f, -0.00829649f, -0.00306275f, -0.00733185f, -0.03276237f, -0.01246734f, 0.03056533f, 
    0.03553612f, 0.03836508f, -0.03497571f, -0.05430711f, 0.03921334f, 0.02353329f, -0.03423722f, 0.01852426f, 
    -0.05470543f, 0.04495855f, 0.02455421f, -0.03140938f, 0.04307505f, 0.03500938f, -0.04739810f, 0.00665247f, 
    -0.00478995f, -0.03471383f, -0.04117513f, 0.01558093f, -0.01913430f, -0.03129105f, 0.02996050f, 0.00547018f, 
    0.02380409f, 0.04764350f, 0.04773749f, 0.02088517f, -0.01743519f, -0.03848296f, 0.00769506f, -0.03647491f, 
    -0.00082917f, 0.03842083f, -0.03013539f, -0.04788763f, 0.04464772f, 0.01216230f, 0.01234273f, 0.03809884f, 
    0.02690888f, 0.05185253f, -0.01771284f, -0.03080418f, -0.00673619f, -0.03613579f, 0.04249890f, -0.03441971f, 
    -0.02372742f, 0.01061289f, 0.03988243f, 0.03635015f, 0.03574248f, -0.03076057f, 0.00900816f, -0.04066294f, 
    -0.02615955f, -0.04737264f, 0.00158311f, 0.02704928f, 0.04312808f, 0.05067935f, 0.02135846f, -0.00736967f, 
    0.03606620f, -0.05103311f, 0.01558756f, -0.03613677f, 0.03889992f, 0.02403932f, 0.01249059f, 0.03124384f, 
    -0.02465140f, -0.02374554f, -0.03718217f, 0.05096946f, 0.04109829f, 0.02846997f, 0.02689262f, 0.01024035f, 
    -0.02181606f, 0.03765235f, 0.03345776f, 0.01859288f, 0.03391297f, -0.04874680f, 0.01953898f, -0.02961257f, 
    0.04321517f, -0.00387051f, -0.00248883f, 0.00270741f, -0.02607898f, -0.01857997f, -0.04674319f, 0.04006240f, 
    0.02112575f, -0.00031846f, -0.04157716f, -0.04285025f, 0.03762256f, 0.04463460f, -0.02493194f, -0.03690897f, 
    0.02938084f, 0.01706141f, -0.00121900f, -0.03616078f, -0.05138390f, 0.03314357f, -0.04899573f, 0.03804510f, 
    -0.00490370f, 0.00412415f, -0.05195148f, 0.01412017f, -0.04670017f, -0.02677089f, 0.04729431f, 0.00608019f, 
    -0.03966132f, 0.03363871f, -0.03733280f, -0.04372754f, -0.01850002f, -0.03509893f, -0.04922795f, -0.05570882f, 
    -0.01895225f, -0.05436830f, 0.04463438f, -0.05713769f, -0.02643458f, -0.02251477f, -0.05687070f, 0.01898119f, 
    0.04142906f, -0.02993269f, 0.00865412f, 0.02147815f, -0.05970262f, -0.00367691f, -0.04538642f, -0.04311638f, 
    -0.05403329f, -0.01927467f, -0.01499475f, 0.00428086f, 0.02080356f, -0.00987672f, -0.03624953f, -0.00479816f, 
    0.00188744f, -0.00726630f, -0.05092789f, 0.02331171f, 0.02526786f, -0.01761493f, -0.04300354f, -0.05136803f, 
    -0.01975240f, 0.02303088f, -0.02337354f, -0.03934013f, 0.01672866f, -0.01278985f, -0.05213912f, -0.00034930f, 
    -0.02313555f, 0.02314002f, -0.02734118f, -0.02161189f, -0.00374443f, -0.00357798f, -0.02459831f, -0.01112867f, 
    -0.01713921f, -0.02379255f, 0.04544934f, -0.05268794f, 0.01200066f, -0.05416928f, -0.03379989f, 0.04218265f, 
    0.02120683f, -0.02381268f, 0.04990477f, 0.04613389f, -0.02211138f, -0.03929208f, -0.04782954f, 0.00068133f, 
    -0.00624594f, 0.02457623f, -0.00586743f, 0.03056173f, 0.02736397f, -0.01817084f, -0.00580399f, -0.05855212f, 
    -0.01631665f, -0.03375487f, 0.04112316f, 0.00624057f, -0.03500578f, 0.03496315f, -0.04870179f, -0.04984184f, 
    -0.03440996f, 0.02393372f, -0.02362529f, -0.04632406f, 0.01570572f, -0.05243103f, 0.03912782f, -0.00231448f, 
    0.03401389f, -0.03119330f, 0.02985488f, 0.01140723f, -0.00382568f, 0.04217398f, -0.00155119f, -0.01213093f, 
    0.00995631f, -0.00517004f, 0.03607885f, 0.01346876f, 0.00658454f, 0.02808029f, 0.00190416f, -0.04156380f, 
    0.04198844f, -0.03466162f, 0.01860119f, -0.03967380f, -0.00039052f, -0.00549556f, -0.00381656f, -0.02659220f, 
    -0.04332418f, 0.03671122f, -0.03519074f, 0.00414520f, 0.04687191f, 0.00487482f, -0.01036563f, -0.04216503f, 
    -0.03443667f, 0.04348065f, 0.02631211f, 0.01333118f, 0.01533004f, 0.02819563f, -0.03903005f, -0.02924743f, 
    -0.00442811f, 0.00864670f, -0.03636549f, -0.03767334f, -0.01654095f, 0.00803797f, -0.05583927f, 0.04875018f, 
    0.01513153f, 0.00103435f, 0.02026276f, 0.02624181f, -0.05172493f, 0.04120954f, -0.00713194f, -0.04186910f, 
    -0.03324015f, -0.02441470f, 0.04692445f, -0.01899098f, -0.02490106f, 0.00418821f, -0.05299664f, 0.02857991f, 
    -0.03715814f, -0.02856145f, 0.01874520f, 0.02820495f, 0.02006838f, -0.03080963f, -0.04949069f, -0.04822145f, 
    -0.04841702f, 0.01696787f, -0.02220466f, -0.01408428f, 0.01964851f, 0.00234207f, 0.00154805f, 0.03733065f, 
    -0.04443000f, -0.00246560f, 0.03694108f, -0.03397676f, 0.03641238f, 0.03767231f, 0.00310781f, -0.00342806f, 
    -0.03524060f, -0.01872669f, -0.02219940f, 0.04682377f, 0.01256073f, -0.00209015f, 0.01903265f, 0.04575090f, 
    0.03812738f, -0.05265637f, -0.05170250f, 0.00342860f, 0.01920666f, -0.04817091f, -0.00235976f, -0.02302407f, 
    0.01535374f, 0.01867859f, 0.02646304f, -0.04572390f, -0.03012786f, -0.04308800f, 0.03958467f, -0.00931661f, 
    -0.04957887f, -0.02357547f, 0.00796214f, 0.01811873f, -0.01916544f, -0.02426376f, 0.00268482f, -0.00088669f, 
    -0.00081436f, -0.04519161f, 0.00718902f, -0.03163186f, -0.03885268f, -0.00998367f, 0.01251782f, -0.01090788f, 
    0.04401690f, 0.02658476f, -0.04177360f, 0.00404497f, 0.02685622f, 0.00685728f, -0.00139546f, -0.01311651f, 
    -0.04168127f, 0.04159803f, 0.00201366f, 0.02992475f, -0.04863808f, -0.01393855f, 0.04694730f, 0.00876795f, 
    -0.03484808f, -0.03572771f, 0.01114104f, -0.04887595f, 0.02361687f, 0.03706654f, 0.02712142f, -0.02287510f, 
    0.03153055f, -0.01234844f, -0.00776082f, 0.02346181f, -0.04760053f, -0.00274660f, -0.00170598f, 0.01106734f, 
    -0.00420794f, -0.01891545f, -0.00276951f, -0.01023211f, -0.03739118f, -0.02180694f, -0.02550974f, 0.02873745f, 
    -0.01127727f, 0.03818509f, -0.02865420f, 0.01076765f, -0.03882714f, -0.00103393f, -0.04024900f, 0.01951199f, 
    0.05166461f, 0.02947219f, -0.02709904f, 0.03295726f, -0.01283390f, -0.05656589f, 0.03409281f, 0.00614805f, 
    -0.01255614f, -0.00213184f, -0.02419302f, 0.02024329f, 0.02091674f, -0.05085406f, 0.04155111f, -0.01078739f, 
    0.07887065f, 0.18354738f, 0.17583436f, 0.24633816f, 0.01249638f, -0.10393958f, -0.11082519f, -0.05981437f, 
    0.24560781f, -0.01519935f, 0.05959375f, 0.03713180f, 0.02806778f, -0.13319203f, 0.08628804f, 0.04006586f, 
    0.13675223f, -0.02254933f, -0.24135858f, 0.01723176f, 0.07693676f, -0.05705645f, -0.02133203f, -0.03362618f, 
    -0.16668537f, -0.40119311f, -0.29520088f, -0.07145809f, -0.02343525f, 0.00594235f, 0.08897019f, -0.00713995f, 
    0.10498118f, -0.06555233f, 0.06286585f, 0.17823040f, 0.23096634f, 0.08436976f, 0.07202883f, 0.02289031f, 
    -0.08448876f, -0.01352445f, -0.02345478f, 0.00880316f, 0.07564865f, 0.14107095f, 0.07854254f, 0.06704505f, 
    0.07614587f, -0.62049448f, 0.07809831f, 0.06151645f, 0.24602987f, 0.13885197f, -0.07685786f, -0.12780236f, 
    0.00509819f, 0.07403740f, -0.21533778f, -0.07482594f, -0.07762893f, 0.13067363f, -0.03847043f, 0.14258669f, 
    0.07995410f, 0.04536755f, -0.10456252f, -0.04696729f, 0.18617544f, 0.14597973f, 0.12388485f, -0.00348154f, 
    -0.07377660f, -0.01309495f, -0.06632318f, 0.03869623f, 0.14569633f, 0.09797101f, 0.01411967f, -0.08995005f, 
    0.04788070f, 0.02993914f, 0.06010854f, -0.02458820f, 0.00412254f, 0.34000424f, -0.14967032f, -0.17090212f, 
    0.06854041f, 0.12087689f, 0.00036367f, -0.07090770f, 0.08122611f, -0.02762185f, 0.26018316f, 0.11040549f, 
    -0.58696097f, -0.20970319f, 0.04216735f, 0.30696294f, 0.17835477f, -0.07250897f, -0.00520080f, -0.05293647f, 
    0.18610428f, 0.01158654f, 0.06411567f, -0.00750933f, -0.08415905f, -0.26060793f, 0.03340294f, 0.14507529f, 
    -0.00137001f, -0.05121486f, 0.20536609f, 0.06269468f, 0.12199756f, 0.07029183f, 0.17056812f, 0.16284008f, 
    -0.14347488f, -0.08427139f, 0.24371873f, 0.07042283f, -0.03090051f, 0.15789050f, -0.12094057f, -0.05091126f, 
    -0.02489989f, -0.05487163f, 0.08235358f, 0.00718872f, -0.08323058f, -0.16676590f, 0.10660649f, -0.07418414f, 
    -0.05663569f, -0.00880920f, -0.09579060f, 0.13681263f, 0.08334442f, -0.10959559f, 0.06989060f, 0.14719579f, 
    -0.08064639f, -0.04731497f, 0.01355451f, 0.22294258f, 0.00802493f, -0.08977541f, 0.08544779f, -0.12022577f, 
    -0.02260903f, -0.07246517f, 0.03251502f, 0.09040873f, -0.02926710f, -0.13218760f, -0.07585497f, -0.07635259f, 
    0.07159422f, -0.05057620f, -0.01597678f, -0.01205166f, 0.19664052f, -0.10333595f, -0.08000046f, 0.02803127f, 
    -0.03194662f, -0.15454349f, 0.02759928f, -0.02807250f, -0.15409026f, -0.20770824f, 0.08827216f, 0.12116240f, 
    0.06004668f, -0.03663449f, 0.14386952f, -0.04294762f, -0.09269615f, 0.32336503f, 0.11860104f, 0.07762554f, 
    -0.07841343f, -0.13156213f, -0.00115461f, -0.08530243f, -0.10105637f, -0.05255176f, 0.02005333f, 0.00829134f, 
    0.05339487f, -0.30951804f, 0.13300970f, 0.01402494f, 0.00619359f, 0.13677043f, -0.03574513f, -0.11777972f, 
    0.07958727f, -0.02056185f, 0.04831005f, -0.08909348f, -0.07435239f, -0.05999979f, -0.24470988f, 0.05459525f, 
    0.02430271f, 0.09532445f, 0.12064248f, -0.05707193f, 0.16781828f, -0.00373479f, -0.17195179f, -0.14053041f, 
    -0.01861424f, -0.05047165f, -0.16397780f, -0.09034153f, 0.13870825f, 0.09450099f, 0.15265024f, 0.09703533f, 
    -0.07240446f, 0.02984720f, -0.08795226f, -0.01596860f, -0.12001602f, 0.11598504f, -0.15407039f, -0.27336654f, 
    -0.01438798f, -0.18465175f, 0.03351336f, 0.02188946f, -0.01648865f, 0.05225682f, 0.14846919f, 0.06137830f, 
    0.01228024f, 0.33270085f, 0.57564026f, 0.10014179f, 0.06977636f, -0.09359191f, -0.14817001f, -0.00293744f, 
    -0.03289491f, -0.01945426f, 0.10776120f, 0.14215139f, -0.16295397f, -0.25591335f, 0.05898218f, 0.21096604f, 
    -0.01674603f, 0.06593111f, -0.18834621f, -0.09186867f, 0.00943108f, -0.04084541f, 0.01969033f, 0.01340200f, 
    -0.11459712f, -0.11119146f, -0.20271055f, -0.07746994f, 0.06661966f, -0.09039482f, 0.05875488f, 0.08441810f, 
    0.16293916f, 0.08123051f, 0.03874570f, 0.13049312f, 0.07245543f, 0.30061641f, 0.16970432f, 0.18517359f, 
    0.10195308f, -0.10858528f, -0.14007318f, 0.01855937f, 0.04527395f, 0.23077957f, 0.16068564f, 0.07895393f, 
    -0.19854017f, -0.11230505f, 0.16514356f, 0.07642270f, 0.04548277f, -0.02737686f, -0.06694081f, -0.10909438f, 
    0.05903754f, -0.03247973f, 0.08885505f, -0.00762296f, 0.02532344f, -0.18634941f, -0.28440028f, -0.03152628f, 
    -0.01581170f, 0.22074965f, 0.18159515f, 0.11693572f, 0.07572504f, -0.02209301f, 0.02009493f, 0.02869857f, 
    -0.40596706f, 0.09764876f, 0.02127422f, 0.22146800f, 0.16844782f, 0.01016464f, -0.19828977f, 0.09218285f, 
    0.16602415f, -0.03471167f, 0.01420590f, -0.05025066f, -0.11214131f, 0.09415813f, -0.09772193f, 0.10532529f, 
    0.02538458f, -0.00020047f, 0.13312842f, 0.21881770f, 0.20426558f, 0.20392555f, 0.19705145f, 0.03127553f, 
    -0.18398251f, 0.08419619f, 0.29271749f, 0.14864086f, 0.12643468f, 0.06731666f, -0.17342615f, 0.03192247f, 
    0.11818042f, -0.02755448f, 0.08303153f, 0.17939928f, 0.02059356f, 0.03878471f, -0.47359425f, -0.04711524f, 
    0.10781246f, 0.04260683f, 0.19284694f, 0.01465848f, 0.04348144f, -0.07727795f, 0.07544906f, 0.02732723f, 
    -0.11492787f, -0.04609456f, 0.07798197f, -0.07912173f, 0.01756228f, 0.16302799f, -0.03051573f, -0.03866499f, 
    0.19940840f, 0.18163086f, 0.14509419f, -0.02796571f, 0.09661701f, 0.29092315f, -0.44040948f, 0.12570538f, 
    0.02119096f, 0.03015332f, 0.13933982f, -0.03691157f, 0.08815151f, 0.08642437f, -0.04349253f, 0.05234728f, 
    0.32778674f, -0.12163954f, -0.12814195f, -0.00770789f, 0.09590334f, 0.04054281f, -0.17114228f, -0.17085646f, 
    0.06968912f, -0.10662537f, 0.09723193f, -0.16041376f, 0.33908826f, 0.23394820f, -0.08935369f, 0.17522545f, 
    0.21407741f, -0.10972641f, 0.03305793f, 0.34444657f, -0.09856479f, 0.09658534f, -0.13308628f, -0.15181570f, 
    0.07768951f, -0.10363217f, -0.04993141f, -0.00052747f, -0.23435004f, -0.02372873f, -0.02182728f, 0.10241261f, 
    -0.07315880f, 0.13801818f, -0.02301717f, -0.02818261f, 0.35275283f, -0.20176540f, 0.24419545f, -0.02425482f, 
    0.04863096f, -0.01780247f, -0.19418068f, -0.02182070f, 0.07264719f, 0.12910026f, -0.18862985f, 0.33142686f, 
    -0.02823157f, 0.02372226f, 0.24387378f, -0.18150894f, -0.03692916f, -0.07576397f, 0.04926693f, -0.22075106f, 
    -0.04045849f, 0.03440148f, 0.01269273f, -0.11773832f, 0.07550448f, 0.03787712f, -0.08136320f, 0.08252177f, 
    0.07639747f, 0.16154647f, -0.09106029f, -0.25720599f, 0.08013998f, -0.02199592f, -0.05893324f, 0.01762179f, 
    0.06929957f, -0.06350014f, -0.08797319f, 0.01837778f, 0.24299715f, 0.03462133f, -0.07266203f, -0.20436932f, 
    0.15334284f, -0.06425517f, -0.00717761f, 0.03353307f, 0.01727636f, 0.04115638f, -0.01438211f, -0.11503673f, 
    0.21364908f, 0.14378972f, -0.04512260f, -0.13089699f, 0.12950532f, -0.06196043f, -0.14923516f, 0.04867836f, 
    0.52698803f, 0.20535876f, 0.43545082f, -0.05314014f, -0.00747766f, 0.06239615f, -0.09286385f, -0.08222464f, 
    0.01176034f, -0.06999443f, 0.00062322f, 0.03417275f, 0.21960588f, 0.22512758f, 0.28371000f, 0.17327116f, 
    0.04487578f, 0.09857006f, 0.02957187f, 0.01829713f, -0.12369353f, 0.09625255f, -0.01475235f, 0.05193739f, 
    0.15341291f, -0.01769452f, -0.13166822f, 0.14506397f, 0.07210952f, 0.09320231f, 0.05486045f, -0.05651343f, 
    0.06904049f, 0.02076291f, -0.01708170f, 0.01957895f, -0.01895485f, -0.27990294f, -0.17862043f, -0.15674600f, 
    0.03639306f, -0.04400436f, 0.03065620f, -0.04903284f, 0.07796706f, 0.02027049f, -0.07493136f, 0.12369502f, 
    0.36047661f, 0.09958991f, -0.09426172f, -0.03401733f, 0.01373601f, 0.11768496f, -0.00883619f, 0.03402442f, 
    -0.05951018f, -0.00612420f, -0.07514294f, 0.05144895f, 0.07420313f, 0.09109629f, -0.31993243f, -0.07009338f, 
    0.34852412f, -0.06657147f, -0.25362948f, -0.12548120f, -0.06901808f, -0.11547840f, -0.21403383f, -0.01687543f, 
    0.25887316f, -0.20326558f, 0.10939738f, 0.04949490f, 0.12937903f, 0.05419177f, 0.21147336f, 0.12884565f, 
    0.14057048f, 0.08994257f, 0.24673122f, 0.47520784f, 0.28905228f, 0.07245592f, 0.15440583f, 0.28813949f, 
    0.10433745f, -0.00412363f, 0.17124830f, 0.25729981f, -0.02366678f, 0.14688724f, -0.05866465f, -0.19742480f, 
    0.07670444f, -0.07827966f, 0.10243938f, -0.28773668f, -0.26028019f, 0.14497969f, -0.18404557f, -0.10937496f, 
    -0.10470305f, -0.00345669f, -0.06732179f, -0.09644547f, 0.11566698f, 0.06614534f, 0.18233311f, 0.22998345f, 
    -0.07320091f, 0.01919414f, -0.03977663f, -0.23956385f, -0.07287584f, -0.18952343f, -0.26894823f, -0.29204470f, 
    -0.26365951f, 0.03778099f, -0.21157791f, 0.00139006f, 0.04368088f, 0.07081006f, 0.10001925f, -0.11530013f, 
    0.03752520f, 0.06024102f, -0.20433180f, -0.18390000f, 0.00341627f, -0.09359539f, 0.12373257f, 0.20131336f, 
    -0.06660680f, 0.02641124f, 0.02865579f, 0.00409545f, 0.03442413f, 0.09242143f, 0.00970043f, 0.02346624f, 
    0.19057034f, -0.02241399f, 0.06556092f, 0.10264716f, 0.08669806f, 0.01020456f, -0.10722446f, -0.17444435f, 
    0.02232983f, -0.04428243f, -0.10926403f, -0.08261913f, -0.00304270f, 0.09960750f, 0.09315339f, -0.17486513f, 
    -0.03315344f, -0.06025368f, -0.32477632f, -0.12916653f, -0.18115991f, -0.18850459f, -0.07982374f, -0.23545146f, 
    0.34908330f, -0.40690446f, -0.08191182f, -0.00619841f, 0.12709148f, -0.10905420f, 0.22693628f, 0.00187454f, 
    0.15501449f, 0.28164351f, 0.17764416f, -0.03178258f, -0.04341066f, 0.05891044f, -0.30709776f, -0.15358338f, 
    -0.09221599f, -0.13003697f, -0.15751757f, -0.09698189f, -0.08766700f, 0.01233387f, -0.27321061f, 0.04820392f, 
    0.18756787f, 0.10154158f, -0.04193040f, 0.27221125f, 0.10688158f, 0.02990395f, 0.07064495f, 0.16059373f, 
    0.25652704f, -0.04841473f, 0.11076679f, 0.17496710f, -0.07554355f, 0.26120058f, -0.04395485f, 0.24028912f, 
    0.06967386f, 0.03180149f, -0.09717461f, -0.00106068f, 0.04877982f, -0.11670700f, -0.09273993f, -0.33217996f, 
    0.20722570f, 0.47094014f, -0.29751372f, 0.09331833f, 0.20532276f, 0.04181152f, -0.07244392f, -0.08821957f, 
    -0.16175127f, -0.38025248f, -0.07898682f, 0.01703518f, 0.11564352f, -0.05957590f, -0.08691192f, 0.29713881f, 
    0.08264765f, 0.19112977f, 0.16886580f, 0.17702065f, 0.08562857f, -0.08027146f, 0.15438482f, 0.17293893f, 
    0.09930041f, 0.17622851f, -0.38266951f, 0.00790697f, 0.21949258f, 0.02082495f, -0.16201718f, -0.02816934f, 
    -0.08925076f, 0.05216162f, -0.02049932f, 0.03312278f, -0.26511836f, 0.02371699f, 0.13201691f, 0.21802147f, 
    -0.03888156f, 0.07096107f, -0.06017168f, -0.13631669f, 0.04999230f, -0.06544618f, 0.04795400f, -0.27237633f, 
    -0.00746164f, 0.03913656f, 0.04276975f, 0.13718596f, 0.03784853f, 0.30728504f, 0.23251836f, 0.03918367f, 
    0.14751320f, 0.08432289f, -0.06363298f, 0.17712016f, -0.30739561f, 0.38467464f, -0.06872732f, 0.39520410f, 
    -0.26382989f, 0.04031158f, 0.01051186f, -0.20966268f, -0.03403953f, -0.03509002f, 0.08697467f, 0.03355936f, 
    -0.18590176f, -0.05721306f, -0.01938873f, -0.04496045f, 0.06389928f, 0.13849545f, 0.08385053f, 0.02234757f, 
    -0.09139533f, -0.12301021f, 0.20059054f, -0.04144178f, 0.09365100f, 0.13230801f, 0.33443752f, 0.16883741f, 
    -0.16416372f, 0.05482721f, 0.23445149f, 0.03195301f, -0.00837590f, -0.05005864f, 0.02842962f, 0.12753586f, 
    0.14554384f, 0.19487847f, 0.17565857f, 0.20853834f, 0.15287480f, 0.07676686f, 0.08741590f, 0.16632980f, 
    -0.03254800f, 0.03572991f, 0.01555088f, -0.02177112f, -0.16459064f, 0.31680354f, -0.04773698f, -0.03975094f, 
    0.08950473f, -0.11581986f, 0.02958591f, 0.03601705f, -0.03926271f, -0.01525798f, 0.11626040f, -0.07164788f, 
    -0.05131594f, 0.26503301f, -0.31969747f, -0.03673824f, -0.11109649f, 0.05358667f, 0.10061932f, -0.03827410f, 
    0.07195269f, -0.04085718f, -0.03441987f, 0.10409008f, -0.29944161f, -0.26060599f, -0.11555958f, -0.11777417f, 
    -0.05981587f, -0.03138182f, -0.10821527f, -0.12228400f, -0.11489424f, 0.02534614f, -0.02055118f, -0.01421231f, 
    0.18842061f, -0.08449273f, -0.13569598f, 0.05276436f, -0.13841556f, -0.04449503f, -0.09247062f, -0.06780617f, 
    -0.00919148f, 0.02061162f, 0.09458370f, 0.03529463f, 0.02515045f, -0.31373835f, -0.06828989f, -0.12637696f, 
    0.00002034f, -0.10086981f, -0.04049379f, 0.14542899f, -0.09276919f, -0.06326091f, -0.04473168f, -0.10461780f, 
    -0.25827572f, 0.15519661f, 0.17080297f, 0.10968138f, 0.01899565f, -0.03932916f, 0.03680270f, -0.12317443f, 
    -0.14614132f, -0.04846421f, -0.06870424f, 0.08646779f, 0.05689217f, 0.10903899f, 0.13827312f, 0.11141436f, 
    0.15402150f, 0.14944670f, 0.09246060f, 0.00840311f, -0.01353699f, -0.00596329f, -0.01001672f, 0.02356617f, 
    0.31169885f, 0.50991029f, -0.11575031f, -0.19457474f, 0.22023620f, 0.04459967f, 0.09943498f, 0.01848613f, 
    0.00135630f, 0.04638774f, 0.04297944f, -0.03494546f, 0.19536383f, 0.41855985f, -0.15851021f, -0.13450679f, 
    0.12201937f, 0.10092517f, 0.07558693f, -0.02677766f, 0.04806237f, 0.10790674f, -0.00049114f, -0.07158903f, 
    0.06611519f, 0.15692903f, 0.17846450f, -0.02297372f, 0.03222653f, 0.04039380f, -0.00129650f, 0.17788500f, 
    0.00258424f, 0.08941834f, 0.06582300f, -0.05207768f, 0.24761975f, -0.12118819f, -0.05480269f, 0.00113212f, 
    0.04707868f, 0.03689269f, -0.04791677f, -0.00300230f, -0.02233900f, 0.11387940f, 0.16069861f, -0.10922834f, 
    0.19423068f, 0.27806950f, 0.14027542f, -0.04728604f, 0.12038831f, 0.05676362f, -0.01257755f, -0.09931453f, 
    -0.07740592f, 0.11943883f, -0.09843142f, 0.10720812f, 0.39613935f, 0.34619218f, 0.31946221f, 0.07335629f, 
    -0.05693137f, 0.09394865f, 0.10697992f, 0.23199309f, -0.04369658f, 0.01251884f, -0.04476058f, -0.01101558f, 
    -0.26318666f, 0.21223991f, -0.27895778f, -0.00939501f, -0.04554771f, 0.07650311f, 0.05517121f, 0.08159386f, 
    0.08501643f, -0.00097181f, -0.04074251f, 0.06165687f, -0.17375267f, 0.00694285f, 0.23248813f, 0.02286501f, 
    -0.03446120f, 0.06518319f, -0.03282148f, 0.09952575f, -0.15677166f, 0.01022250f, -0.02594066f, 0.03640302f, 
    0.09370773f, 0.01617008f, 0.12077385f, -0.13038108f, -0.02706334f, 0.06298564f, 0.03562049f, 0.09644890f, 
    0.02512055f, 0.07244603f, -0.07470384f, -0.18266392f, 0.07994068f, 0.12540953f, 0.17649335f, 0.14884633f, 
    -0.02259649f, 0.13904206f, -0.22918041f, 0.17128487f, 0.06807379f, -0.12784468f, -0.04409149f, 0.20361240f, 
    0.11182339f, -0.19869173f, -0.47151074f, 0.06395528f, -0.05840878f, 0.14695616f, 0.02329673f, -0.01208491f, 
    -0.03604990f, 0.09811309f, 0.17868428f, -0.02938264f, -0.05443126f, 0.02528268f, -0.09979892f, 0.03541457f, 
    -0.00896156f, 0.02201242f, -0.00895583f, -0.02830806f, 0.05982311f, -0.05103787f, -0.08431011f, -0.11765187f, 
    0.11294850f, -0.13540150f, -0.00027207f, 0.04706001f, -0.13101855f, 0.06763519f, -0.14568923f, -0.10903934f, 
    0.09796184f, 0.11389354f, -0.09657944f, -0.13565826f, 0.16557384f, -0.22721553f, -0.18887611f, 0.11622317f, 
    0.00101438f, 0.01641927f, 0.15397200f, -0.06398239f, -0.04195631f, -0.09922071f, 0.12126157f, -0.08182786f, 
    0.12188573f, -0.00233612f, -0.21950577f, -0.10720178f, -0.01387262f, -0.02785207f, 0.07116661f, 0.05241100f, 
    -0.14967594f, 0.19830197f, -0.02021741f, -0.01219725f, 0.27171201f, 0.20430073f, 0.07789449f, 0.17214231f, 
    -0.01565832f, -0.05675213f, -0.02198772f, 0.01292276f, -0.08393672f, -0.09592670f, -0.00207015f, 0.05856876f, 
    0.06850027f, -0.32794222f, 0.15503187f, -0.02578487f, 0.11668469f, 0.09637250f, 0.13079433f, 0.00833595f, 
    -0.03037806f, 0.15807915f, -0.13424653f, -0.01340366f, 0.22505429f, 0.01361285f, 0.26125309f, 0.02974245f, 
    0.10676299f, 0.12964113f, 0.14947273f, 0.14194861f, 0.01905202f, 0.01822876f, -0.13031571f, 0.04989235f, 
    0.12578326f, -0.04144763f, -0.30132747f, -0.02014828f, 0.14991012f, 0.15320231f, 0.06213231f, 0.16124801f, 
    0.08509146f, 0.12056258f, 0.00925812f, -0.01170796f, 0.24289873f, -0.05516407f, 0.21802348f, -0.01764229f, 
    -0.03217766f, -0.04468551f, -0.06387150f, -0.10248531f, -0.12123328f, 0.07317840f, -0.04939581f, 0.04011755f, 
    -0.17872475f, -0.15067180f, -0.24830672f, 0.24552502f, 0.01083875f, 0.01960649f, -0.11574399f, -0.08393820f, 
    -0.10034873f, -0.01414396f, -0.08482843f, 0.12764859f, 0.10336776f, -0.43274552f, 0.37638584f, 0.24036227f, 
    -0.03927286f, -0.09022219f, 0.06041091f, -0.17982022f, 0.01500303f, -0.01790375f, -0.01906200f, 0.01861439f, 
    -0.15146814f, 0.39446068f, -0.07955164f, 0.28760952f, -0.15935065f, 0.06239407f, 0.09851398f, -0.14671068f, 
    0.31390637f, 0.03813489f, -0.06034540f, 0.12963527f, 0.16717279f, 0.16509464f, -0.09822472f, 0.15408239f, 
    0.30372235f, 0.06880701f, 0.07537704f, -0.12767427f, -0.04365350f, 0.14061005f, 0.07397537f, 0.03479368f, 
    -0.09914730f, 0.21249685f, -0.21453206f, -0.03150219f, 0.08732293f, 0.04336300f, 0.09492487f, 0.16989122f, 
    0.06850681f, 0.06814913f, -0.04232549f, 0.00361073f, 0.36564931f, 0.03261954f, 0.39931017f, -0.10397554f, 
    -0.08072473f, 0.09880164f, 0.06441730f, 0.11490347f, -0.03087341f, -0.02832605f, 0.02944718f, -0.03054479f, 
    0.40785205f, -0.06475203f, 0.12172490f, -0.37954238f, 0.01238847f, -0.01642570f, -0.06309506f, 0.06909843f, 
    0.00847595f, 0.06029603f, -0.08314516f, -0.07917620f, 0.08452695f, -0.01505865f, 0.15321341f, 0.14103934f, 
    -0.15883252f, -0.18993071f, -0.04582645f, -0.18713307f, 0.03383810f, 0.01984280f, 0.02512319f, -0.04915190f, 
    -0.29016453f, -0.00712248f, 0.00608669f, 0.02156100f, -0.13822903f, -0.20604703f, 0.00879111f, -0.05765826f, 
    0.06115876f, 0.00604275f, 0.10892647f, 0.07048831f, -0.04926428f, 0.20999712f, -0.16027702f, -0.10352226f, 
    0.10479065f, -0.11881448f, 0.02177982f, 0.12984774f, 0.03897001f, 0.16506039f, 0.24829431f, 0.19779076f, 
    -0.13434063f, 0.01002494f, 0.07594790f, 0.34763980f, 0.04929651f, 0.03243218f, 0.10411657f, 0.04866752f, 
    0.11435465f, 0.10999648f, -0.17468661f, 0.02345258f, 0.01631608f, 0.03398549f, 0.29201511f, 0.01463210f, 
    0.05313232f, 0.10337774f, -0.04351576f, 0.14101626f, 0.07282223f, 0.11766753f, -0.04680375f, 0.09064925f, 
    0.31095728f, -0.45781109f, 0.45010126f, 0.11357028f, -0.18935564f, 0.14732884f, 0.19815880f, 0.07896163f, 
    0.09743705f, -0.07221372f, 0.12219107f, 0.04530510f, 0.09971072f, 0.07472816f, 0.44016218f, 0.02575426f, 
    -0.08911259f, 0.16442771f, -0.07515587f, 0.08104666f, 0.09491397f, 0.07209714f, 0.16323704f, 0.05329151f, 
    0.02593404f, 0.04188286f, 0.48255455f, 0.09655583f, 0.10698608f, -0.08337630f, 0.09828362f, 0.13027005f, 
    0.10168712f, 0.02411677f, -0.01579064f, -0.03850427f, -0.48411080f, -0.13040227f, 0.03297024f, -0.07715367f, 
    -0.16789342f, 0.00355620f, -0.30628514f, -0.22585422f, 0.10039001f, -0.07006048f, 0.29204980f, 0.03515163f, 
    -0.24965543f, 0.17087840f, 0.25794667f, 0.16979448f, -0.05699473f, -0.09420957f, -0.00115409f, 0.02402293f, 
    -0.03033944f, 0.00035484f, -0.11413643f, -0.01687517f, -0.18650272f, 0.23407833f, -0.02995936f, -0.16682322f, 
    -0.11412522f, 0.23075959f, 0.02919226f, 0.05882889f, -0.02240604f, 0.03057917f, 0.13738443f, 0.03278408f, 
    0.22571366f, -0.34312156f, 0.19678809f, -0.14088005f, -0.00456395f, 0.12776883f, -0.06958581f, 0.30269572f, 
    0.33076990f, 0.00088255f, 0.08009767f, 0.05538495f, -0.26387841f, 0.04570191f, -0.22610787f, -0.19537960f, 
    0.00555011f, 0.09015486f, -0.18402508f, 0.02782477f, 0.19033402f, -0.12445507f, 0.14201918f, 0.21660480f, 
    -0.24077629f, -0.03592606f, -0.23125201f, -0.15266165f, 0.07473376f, 0.05517111f, 0.09832724f, 0.11403929f, 
    0.00319911f, 0.12501460f, 0.14664049f, 0.11256464f, -0.25447747f, 0.01282648f, 0.03072510f, 0.31330889f, 
    0.17067885f, -0.11592011f, 0.06845423f, -0.08251058f, 0.09932947f, -0.02309172f, -0.12908828f, 0.05093216f, 
    0.40520704f, -0.21295911f, 0.18591265f, -0.14591876f, -0.01670592f, 0.06546552f, 0.13300961f, 0.04714840f, 
    0.11214298f, 0.08352409f, 0.12361579f, 0.09310634f, 0.00204606f, -0.13009842f, -0.03083916f, 0.00988116f, 
    -0.20388553f, 0.01157349f, -0.00749089f, -0.01756808f, 0.17256078f, -0.14039610f, 0.15680259f, -0.04107014f, 
    -0.31431380f, -0.08472862f, -0.10724421f, -0.10024313f, -0.03457569f, 0.01563299f, 0.01415031f, -0.22761856f, 
    -0.12709452f, -0.23309773f, -0.03893585f, 0.01183993f, 0.49164152f, -0.12088885f, 0.10746352f, -0.00556244f, 
    0.00830906f, -0.01061213f, 0.07579774f, -0.14966249f, 0.27307999f, 0.15014900f, 0.17305918f, 0.17808463f, 
    0.15621842f, -0.04500458f, 0.01479401f, 0.01130372f, 0.15442814f, -0.02647855f, -0.10568284f, 0.06667200f, 
    -0.03904309f, 0.07078281f, -0.05104909f, -0.14304765f, -0.14381108f, 0.00096527f, -0.06272721f, -0.01675635f, 
    0.17329465f, 0.12267289f, 0.33272511f, 0.04165304f, 0.14149132f, -0.04998110f, 0.21531969f, 0.00683266f, 
    0.04907887f, -0.00162211f, -0.05643684f, 0.16904402f, -0.16341710f, -0.23757662f, 0.10996584f, 0.19658267f, 
    0.12929790f, 0.09325846f, 0.05247528f, -0.23450528f, 0.10130313f, 0.22716041f, 0.24594563f, -0.21031274f, 
    0.11805990f, -0.06968208f, 0.04762128f, 0.13878097f, 0.03706600f, -0.07255908f, -0.18826693f, -0.21731137f, 
    0.49496007f, -0.18042582f, 0.42130327f, -0.02953384f, 0.13957652f, 0.00214431f, 0.11437445f, 0.19851413f, 
    0.28310716f, 0.00372693f, 0.01600792f, 0.13459253f, -0.78737354f, 0.03838367f, -0.10739349f, 0.11254635f, 
    0.10898393f, -0.06189217f, -0.06789244f, -0.04189253f, -0.05933790f, -0.14991182f, -0.02646382f, 0.16414261f, 
    -0.06381064f, -0.08276623f, 0.12794250f, 0.08783408f, -0.11675479f, -0.22047734f, -0.01154723f, -0.08386412f, 
    -0.00598985f, -0.14771391f, 0.01027362f, -0.08881520f, -0.42202196f, 0.41609353f, -0.23900640f, 0.12280469f, 
    0.11606241f, -0.05362581f, 0.00323558f, 0.02781763f, 0.09946601f, -0.09477054f, -0.03156364f, 0.01218200f, 
    0.16074502f, 0.37371156f, -0.08064056f, 0.01736949f, -0.13236611f, 0.02333875f, 0.07776815f, -0.01631859f, 
    0.07141992f, 0.29154298f, 0.02506095f, 0.18084663f, -0.13714711f, -0.05561709f, -0.02659258f, 0.06286938f, 
    -0.10817686f, 0.08466256f, 0.08397108f, 0.02626168f, -0.14277446f, -0.04965357f, 0.18393940f, 0.18782464f, 
    0.06305012f, 0.36523074f, -0.00506239f, -0.04347192f, 0.01198600f, 0.02137766f, 0.04542036f, 0.23029290f, 
    -0.10610155f, 0.20269842f, -0.01719647f, 0.02864476f, -0.18923518f, 0.10006966f, -0.13847436f, -0.19284940f, 
    -0.00273131f, 0.03609215f, 0.05202318f, -0.01160666f, -0.29981852f, -0.11607456f, 0.12849870f, -0.09134798f, 
    -0.06672575f, 0.24183683f, -0.25506517f, -0.06162817f, -0.09032145f, -0.02360792f, -0.01631844f, -0.02714637f, 
    -0.02563313f, -0.05719350f, 0.06456378f, -0.00391068f, 0.08296251f, 0.07247963f, 0.11434552f, -0.32378861f, 
    -0.08098341f, -0.06173808f, -0.07231114f, -0.10133893f, -0.12714018f, 0.04535463f, -0.06654502f, 0.02229004f, 
    -0.13286135f, 0.23472753f, 0.05174129f, -0.11270318f, -0.17675103f, -0.12065336f, -0.02685157f, -0.03654947f, 
    -0.00955959f, 0.12486937f, -0.05967350f, 0.17134054f, 0.01664526f, -0.01598772f, 0.12358879f, 0.18144627f, 
    -0.20844026f, -0.19183183f, -0.13405357f, 0.16614018f, -0.17928068f, 0.26448700f, -0.13492507f, 0.10521461f, 
    0.36492902f, 0.29102710f, -0.44667789f, -0.48373529f, 0.24044394f, 0.06462347f, -0.01549172f, -0.02784451f, 
    0.03555535f, 0.08990007f, -0.07009180f, 0.00383035f, 0.00078630f, 0.09222263f, -0.37208486f, -0.13618113f, 
    0.08308728f, 0.07558922f, 0.06586480f, 0.01173858f, 0.02849673f, -0.01799163f, 0.13415328f, 0.06914211f, 
    0.48964190f, -0.07688814f, -0.02930530f, 0.09759246f, -0.07995792f, -0.04077917f, 0.04351475f, 0.13286136f, 
    -0.05137864f, -0.00698992f, 0.06833138f, 0.10960247f, 0.30583951f, 0.05811530f, 0.13476205f, 0.25327113f, 
    0.11717988f, 0.00640793f, 0.04436282f, -0.05164295f, -0.00256280f, -0.08453312f, -0.10822655f, -0.16386385f, 
    -0.00225654f, 0.10707980f, -0.17836930f, -0.04075416f, 0.06295365f, 0.00772911f, 0.09358496f, 0.07652636f, 
    0.10812458f, -0.09241795f, -0.06388632f, -0.16861853f, -0.27963239f, 0.06255542f, 0.04407862f, -0.05557303f, 
    -0.09834570f, 0.18306740f, -0.08420961f, -0.07868287f, 0.09232862f, 0.13957466f, 0.27427298f, 0.09232960f, 
    0.11864059f, 0.15866402f, -0.10062801f, 0.17829980f, 0.12150459f, -0.00184112f, -0.11842734f, -0.20836496f, 
    -0.04433088f, 0.01654630f, -0.31203079f, -0.38043055f, -0.07443462f, -0.23643754f, -0.04670227f, 0.03052259f, 
    -0.29576254f, 0.22502285f, -0.10148933f, 0.17954887f, -0.05800357f, -0.09576276f, 0.03945056f, 0.01641942f, 
    -0.02859354f, 0.00435052f, -0.02959774f, -0.17545985f, 0.20364390f, 0.03682027f, 0.23577897f, 0.01179670f, 
    -0.06561758f, 0.08253721f, 0.04513943f, 0.19812287f, 0.11008059f, 0.10228831f, -0.00853053f, -0.21227857f, 
    0.24606153f, 0.01826657f, -0.17769781f, 0.02564967f, 0.11842715f, 0.18570904f, 0.24425654f, 0.35270885f, 
    -0.04558645f, 0.01762142f, -0.15307702f, -0.13200735f, 0.07385992f, 0.03163756f, 0.03833046f, 0.07315265f, 
    -0.02389389f, 0.08701002f, 0.09814432f, 0.09367129f, 0.12015913f, -0.04980096f, 0.16996427f, 0.33401245f, 
    -0.04991717f, 0.02822791f, -0.07843583f, -0.02732848f, -0.22581619f, 0.07827692f, -0.11424764f, -0.04560920f, 
    0.17596653f, -0.18119232f, -0.36917740f, 0.15147929f, 0.01607256f, 0.05001095f, 0.23345163f, -0.02744495f, 
    0.03938340f, 0.18400806f, 0.08483917f, 0.04918058f, -0.01916683f, 0.09939954f, 0.26103228f, -0.17822087f, 
    -0.11556718f, 0.06391569f, 0.05202705f, -0.06040828f, 0.22392701f, -0.03450931f, -0.01518101f, 0.18702579f, 
    -0.06614794f, 0.24912576f, -0.02557741f, -0.11954597f, -0.19510947f, -0.00394098f, -0.10360056f, -0.26326045f, 
    -0.16257513f, -0.10913087f, 0.06864801f, -0.09503815f, 0.11184800f, 0.15340586f, -0.14377880f, -0.06420768f, 
    0.07298786f, 0.10297762f, 0.17343697f, -0.05551491f, 0.07427694f, -0.01161780f, 0.06784903f, -0.13303643f, 
    -0.06722204f, -0.03878995f, -0.11555170f, -0.00553802f, -0.05018780f, 0.05537083f, 0.04912030f, 0.04415060f, 
    -0.44354874f, -0.16477747f, -0.20364629f, -0.29467502f, -0.15441410f, -0.18808204f, -0.04041008f, 0.29797640f, 
    0.07037278f, -0.08348905f, 0.21373169f, -0.01604293f, 0.11112887f, 0.10107890f, 0.14112777f, 0.18001933f, 
    0.43995547f, -0.06631187f, 0.07925625f, -0.25391933f, -0.21705133f, 0.01151265f, -0.07493516f, 0.05086241f, 
    0.08153749f, 0.06583433f, 0.22269070f, 0.12426089f, 0.10783188f, -0.12290249f, 0.20202331f, 0.20649859f, 
    0.15348972f, 0.04196721f, 0.05045572f, 0.08508443f, -0.13285956f, 0.07814588f, -0.04192749f, -0.08663433f, 
    0.28640035f, -0.21625562f, 0.06743340f, -0.11977695f, 0.01100274f, 0.10432512f, 0.13045537f, -0.03586042f, 
    -0.06464426f, -0.03429472f, -0.07075583f, -0.06673364f, -0.34727478f, 0.10786864f, 0.00918952f, -0.10084606f, 
    -0.14136340f, -0.13332365f, 0.13228875f, -0.05712661f, -0.20076232f, 0.05574906f, 0.06851154f, 0.01795326f, 
    -0.05446694f, -0.07117885f, 0.08459216f, -0.04965303f, -0.03624727f, -0.13879852f, -0.06779566f, -0.14815918f, 
    -0.27173394f, 0.00368642f, -0.11122047f, -0.11579899f, -0.30366328f, 0.07380043f, 0.19175965f, -0.07717481f, 
    -0.13825470f, -0.12247179f, -0.06810977f, 0.13222438f, 0.03656263f, 0.10317548f, 0.04177177f, 0.02977921f, 
    0.03719789f, -0.01099504f, 0.00903517f, -0.02238570f, -0.04643323f, -0.04857291f, 0.00051036f, -0.04485995f, 
    0.01063580f, -0.02883480f, -0.04748389f, 0.03641245f, -0.04769363f, -0.02018624f, 0.00844470f, -0.04970571f, 
    0.04202323f, 0.02938434f, -0.02677915f, -0.00536855f, -0.04095558f, -0.03028198f, -0.01829292f, -0.03108792f, 
    -0.04722971f, 0.01154352f, -0.02751931f, -0.04338184f, 0.03771934f, 0.00224934f, -0.01700770f, -0.04512610f, 
    0.00612858f, -0.00084945f, -0.00029805f, 0.02308258f, -0.00942400f, 0.04376693f, -0.04590186f, 0.01440503f, 
    -0.04412518f, -0.06176386f, -0.01667445f, 0.02372898f, 0.01628769f, -0.02614233f, -0.03662527f, -0.00858729f, 
    0.01853002f, 0.01467424f, -0.01768885f, 0.03033313f, 0.05478579f, -0.03102231f, -0.00707268f, -0.03649576f, 
    -0.02564954f, 0.03738892f, -0.02280694f, -0.01364999f, 0.02403098f, -0.02512401f, 0.00381216f, -0.00333949f, 
    0.02289371f, 0.03111620f, -0.03702602f, -0.00185087f, 0.03561569f, 0.00627427f, -0.02178716f, -0.05375131f, 
    -0.01935586f, 0.01054064f, -0.02042290f, 0.00835693f, -0.00197924f, -0.05415181f, -0.01113402f, -0.04877044f, 
    -0.01760140f, 0.03649128f, -0.03763499f, -0.05120680f, -0.04329686f, -0.01346762f, -0.03972686f, -0.05170131f, 
    -0.04522000f, -0.03488900f, 0.00929267f, -0.05091174f, 0.00722172f, 0.03269665f, 0.03852311f, 0.02502644f, 
    -0.05302111f, 0.01515211f, -0.03012443f, -0.01661720f, -0.01958474f, 0.01984827f, -0.01961924f, -0.00409829f, 
    0.00221631f, 0.01387026f, 0.01796099f, -0.02187089f, 0.01087582f, 0.01860294f, 0.03212130f, -0.03398804f, 
    0.02071820f, -0.01300481f, -0.00674696f, 0.01236969f, -0.02707786f, -0.03849943f, 0.02650944f, -0.04703567f, 
    -0.02733426f, 0.02583810f, -0.00252454f, -0.01566446f, 0.00837812f, 0.01978496f, 0.01409838f, 0.01590918f, 
    0.02882669f, -0.04730879f, -0.03784695f, -0.03242198f, 0.03381749f, 0.00513685f, 0.01434212f, 0.01319990f, 
    -0.00374198f, -0.04058561f, 0.01626687f, -0.04196674f, 0.00648152f, -0.05481425f, 0.00617554f, -0.01107328f, 
    0.01323588f, 0.02878211f, 0.02956627f, 0.01230703f, 0.03095848f, 0.02879916f, -0.00568887f, -0.03127962f, 
    0.03640052f, 0.02385537f, -0.02597870f, 0.01941822f, 0.03171196f, 0.02039204f, 0.03434306f, 0.00717526f, 
    0.00812992f, 0.01397200f, 0.02575143f, 0.04357649f, 0.02012880f, -0.02610179f, -0.02746551f, -0.00921504f, 
    -0.03086974f, -0.05492214f, -0.03865317f, 0.00288150f, 0.00749697f, 0.00198874f, 0.01602193f, -0.01582373f, 
    -0.02987755f, 0.02377977f, -0.02757294f, -0.01863163f, 0.01771953f, -0.00842099f, -0.05985432f, -0.02760515f, 
    -0.05341934f, 0.02617754f, 0.03180315f, 0.00065533f, -0.01600530f, -0.03242568f, -0.02132084f, 0.02648078f, 
    -0.05985459f, -0.02546099f, -0.03436213f, 0.02510813f, 0.03189367f, 0.01049573f, 0.03251354f, 0.01310526f, 
    0.03556475f, 0.02314262f, -0.06049464f, 0.00552632f, 0.01545937f, -0.02461831f, -0.00187538f, 0.02606484f, 
    -0.01621458f, -0.06131224f, 0.02204478f, 0.04012635f, -0.05059920f, -0.03692386f, -0.01042495f, 0.04309415f, 
    -0.03214130f, -0.02374309f, -0.02528541f, 0.00809372f, -0.03217708f, 0.00123832f, 0.03661150f, 0.01969887f, 
    -0.02517117f, -0.02822144f, 0.04199075f, -0.00335532f, -0.00787185f, -0.03779138f, -0.00907133f, -0.04858820f, 
    -0.04890012f, -0.04921274f, -0.04162705f, -0.02316712f, -0.00236705f, -0.04611704f, 0.04277854f, -0.00648649f, 
    -0.05148750f, 0.02242053f, -0.00973598f, -0.06055411f, -0.04812836f, -0.03987515f, -0.00938405f, 0.03774127f, 
    -0.04388427f, -0.05724595f, 0.02237105f, -0.03258412f, -0.01800802f, 0.00842194f, -0.00030129f, -0.00030523f, 
    -0.01178818f, -0.00114333f, -0.01604649f, -0.01795973f, 0.02850627f, 0.04370024f, 0.02232017f, -0.03922777f, 
    -0.02369173f, 0.04350286f, 0.04339868f, -0.05122976f, 0.00038699f, -0.03920306f, -0.03009938f, 0.02867519f, 
    0.02478269f, 0.00369381f, 0.02315831f, 0.01678165f, -0.04869699f, -0.03636699f, 0.00376833f, -0.02518646f, 
    0.00923954f, -0.00963548f, 0.01523217f, 0.00270544f, 0.03377322f, -0.01428408f, -0.02713197f, -0.04169720f, 
    -0.04136984f, -0.00338591f, 0.03897047f, -0.01891294f, -0.04008747f, -0.02032341f, -0.04066197f, -0.05191619f, 
    -0.02253370f, -0.02381354f, 0.03305780f, 0.02908556f, 0.01255306f, -0.00826519f, -0.02220091f, 0.00031115f, 
    -0.01000842f, -0.05431710f, 0.02922085f, -0.05008076f, -0.01640221f, -0.04577361f, 0.03098573f, -0.04043249f, 
    0.00809296f, 0.03594382f, 0.00548440f, 0.01438269f, -0.02067309f, -0.01900658f, -0.00712066f, -0.04078195f, 
    0.02487662f, -0.03279559f, -0.01197607f, -0.01133183f, -0.06682587f, -0.04615327f, -0.05157015f, 0.02137867f, 
    0.01311966f, -0.00730504f, -0.03400846f, -0.00830105f, 0.03587343f, -0.01576998f, 0.01916876f, -0.03156329f, 
    0.01357951f, 0.01346226f, 0.03569689f, 0.01237594f, 0.00745063f, 0.04112696f, -0.03279969f, 0.03158445f, 
    -0.04403827f, -0.01347089f, 0.02380485f, -0.04860952f, 0.01876138f, 0.03202118f, 0.00107331f, 0.00390087f, 
    -0.01567152f, -0.00195857f, -0.02606498f, 0.02237208f, 0.03328133f, -0.04555859f, -0.02004923f, -0.02584262f, 
    0.02605055f, -0.01367058f, -0.00331555f, -0.05092657f, 0.03875165f, -0.00758229f, -0.02551092f, 0.02418794f, 
    -0.03717200f, 0.00329819f, -0.02769677f, -0.01252203f, 0.01046526f, -0.03577351f, -0.03081322f, 0.01612348f, 
    -0.03581489f, -0.04800053f, -0.02071518f, 0.00891230f, -0.01432658f, 0.00576884f, -0.02118571f, 0.01747917f, 
    -0.29981285f, -0.16129190f, 0.01684013f, -0.10552054f, -0.02807909f, -0.07048572f, 0.06071356f, -0.12597729f, 
    0.33619899f, 0.11932278f, 0.12870401f, 0.15195026f, 0.21949250f, 0.19303645f, 0.08055376f, -0.06082972f, 
    0.04372259f, 0.12623857f, 0.02212891f, 0.05547804f, 0.00889130f, 0.11779781f, -0.08051556f, -0.07277121f, 
    0.30973536f, 0.16179936f, 0.03916261f, 0.05532241f, 0.07205168f, 0.04690577f, -0.03086405f, 0.01372553f, 
    0.04503897f, -0.01252688f, 0.04779071f, 0.01117003f, 0.03521692f, 0.01945169f, 0.02759699f, -0.07497255f, 
    0.04624237f, 0.00305618f, -0.10885752f, 0.03881174f, 0.05953819f, 0.09080956f, 0.01508638f, -0.08113657f, 
    0.16735850f, -0.04561322f, 0.03378463f, -0.04624997f, -0.08492634f, -0.03629091f, 0.06020270f, -0.10685360f, 
    0.19654290f, 0.01714317f, -0.07306065f, 0.06157564f, -0.11844095f, -0.01545153f, -0.12578529f, -0.09695680f, 
    -0.07591997f, -0.02179919f, -0.11460382f, -0.08292125f, 0.01457564f, 0.00500136f, 0.02669048f, -0.11725278f, 
    -0.15118240f, 0.01932691f, -0.02497241f, -0.08013690f, -0.08673668f, -0.05584606f, -0.04256129f, -0.17798719f, 
    0.01945062f, 0.11464497f, 0.05826477f, -0.00576533f, -0.17985737f, -0.20876822f, -0.10874896f, 0.10480191f, 
    0.02732063f, -0.11865140f, 0.10807145f, 0.02040941f, -0.03436549f, 0.09881112f, 0.14391129f, 0.11107252f, 
    0.02319137f, 0.13696189f, 0.52332425f, -0.06100320f, 0.02611326f, 0.14924969f, 0.15653270f, 0.18883099f, 
    0.23651133f, -0.09782638f, -0.12134262f, -0.10985775f, 0.31048822f, 0.23170519f, 0.26884621f, -0.08373927f, 
    0.06212815f, 0.03614361f, 0.11955505f, 0.14316666f, 0.05618130f, -0.19254978f, -0.00207137f, 0.09518761f, 
    -0.09806544f, 0.17784329f, -0.05786120f, -0.18366040f, 0.09665202f, 0.07194150f, 0.04401333f, 0.13516848f, 
    0.13688055f, 0.03851352f, -0.11488879f, -0.07022936f, 0.13238329f, 0.03863277f, -0.19049925f, -0.20927334f, 
    0.13109641f, 0.01850712f, 0.02274419f, 0.04098664f, -0.04317996f, 0.00010205f, -0.06389800f, 0.00649774f, 
    0.44708863f, 0.29861048f, 0.07917050f, 0.08905147f, 0.04844193f, -0.00496416f, 0.09410752f, 0.04254320f, 
    -0.22149801f, -0.07996757f, -0.11482298f, 0.10394959f, 0.10372872f, -0.20535269f, -0.23067474f, 0.02495275f, 
    -0.09435230f, -0.04157180f, -0.01294624f, 0.06121071f, 0.23237950f, 0.05545667f, 0.10025005f, 0.12481515f, 
    0.26010951f, 0.12661321f, 0.04506679f, -0.20351774f, 0.11007377f, 0.00195816f, 0.15015928f, 0.09545863f, 
    -0.19657779f, -0.05466422f, -0.08748624f, -0.22763211f, 0.34712777f, 0.27284902f, 0.06015245f, -0.07070047f, 
    0.15875603f, 0.17362416f, -0.18185344f, -0.06806099f, -0.12846032f, -0.12893251f, 0.00172130f, 0.16972743f, 
    -0.10951130f, 0.21763948f, 0.09114919f, -0.02646685f, -0.18386838f, -0.18889067f, 0.11955534f, 0.12823415f, 
    0.08337906f, 0.09325734f, 0.04863203f, 0.08677814f, 0.05343050f, -0.11470401f, 0.22890937f, 0.04614106f, 
    -0.12429948f, 0.22010331f, 0.01786247f, -0.04116065f, 0.25406206f, 0.10231863f, 0.23072153f, 0.10925085f, 
    -0.00293803f, -0.03686691f, -0.15017003f, 0.02213400f, 0.20474985f, 0.01347191f, 0.07549180f, 0.10902748f, 
    -0.08264356f, 0.30495432f, 0.08776454f, 0.31439111f, -0.54986733f, 0.07000180f, -0.07708924f, 0.03972356f, 
    -0.04556426f, 0.07457135f, -0.12165017f, 0.04267162f, 0.02185413f, -0.21253407f, -0.01484376f, -0.03975043f, 
    -0.20277345f, -0.18672168f, -0.16996655f, -0.19368109f, -0.11392817f, 0.14496937f, -0.09901382f, 0.03913811f, 
    0.06236688f, -0.10546600f, -0.14532900f, 0.06417851f, -0.26642787f, -0.28710100f, 0.06698955f, 0.23710333f, 
    -0.34520164f, -0.04027219f, -0.05060782f, -0.00978357f, 0.23363125f, 0.05864866f, 0.35551235f, 0.07311248f, 
    -0.12049893f, -0.33874187f, -0.01835593f, -0.14437895f, 0.01369341f, -0.21992415f, -0.15043350f, 0.01847874f, 
    -0.02301564f, -0.06002327f, 0.04353590f, 0.01144054f, -0.14135110f, -0.25517100f, -0.22160614f, -0.21261276f, 
    -0.04895933f, 0.03603102f, -0.09872795f, 0.15879515f, 0.05442123f, 0.07699914f, -0.03015190f, 0.03700376f, 
    0.02327847f, -0.02940121f, -0.25927386f, -0.06024504f, 0.00328901f, -0.14090633f, -0.01255740f, -0.10048338f, 
    -0.08225923f, -0.09992425f, -0.10352910f, -0.17094138f, 0.11482725f, 0.05106396f, -0.21663299f, -0.05529651f, 
    0.05490408f, 0.09810665f, -0.04676813f, 0.01866545f, 0.05410484f, 0.07420301f, 0.01990785f, 0.19964859f, 
    0.15411331f, -0.16492659f, -0.05458088f, -0.19741429f, -0.04168299f, -0.24002661f, 0.07895973f, 0.00693011f, 
    0.08187615f, 0.22088891f, -0.14801197f, 0.13202406f, 0.29429862f, 0.04092449f, -0.16186278f, -0.16271901f, 
    0.01736216f, 0.09894831f, -0.00319802f, 0.14513516f, -0.19342999f, -0.14616755f, -0.18843202f, -0.32699978f, 
    0.07389305f, 0.19818237f, -0.25632045f, -0.07469504f, 0.10609259f, 0.09948327f, 0.06385095f, 0.09043730f, 
    0.09088130f, 0.01192605f, 0.08917110f, 0.05772087f, -0.10134979f, 0.00527531f, -0.14778949f, -0.02369296f, 
    0.00159169f, -0.03306530f, 0.08961225f, -0.00411487f, 0.02013834f, -0.02995188f, 0.14844893f, 0.23351704f, 
    -0.34909371f, -0.02210470f, -0.03064475f, -0.09154029f, -0.09158907f, -0.02395857f, -0.06148832f, -0.18436363f, 
    0.04724690f, 0.07064682f, -0.10810555f, -0.15207799f, -0.17580283f, -0.01436245f, -0.28961736f, 0.23989478f, 
    -0.01192383f, 0.01563555f, 0.14743051f, -0.01097273f, -0.10526787f, 0.00513790f, -0.02227437f, -0.03444530f, 
    -0.03258901f, -0.34941646f, 0.00974038f, 0.11446930f, -0.01127986f, -0.00231918f, 0.02746950f, -0.10094661f, 
    0.06944382f, 0.01801654f, 0.03955065f, 0.03690033f, 0.14186728f, 0.09991486f, -0.09980051f, 0.01399013f, 
    0.12698886f, 0.13742733f, -0.03410557f, 0.06175474f, 0.06142829f, 0.07882350f, -0.17058286f, 0.11392364f, 
    0.32334375f, 0.02174657f, 0.21951146f, 0.09315886f, 0.04498524f, 0.19308998f, 0.08888277f, 0.03077847f, 
    0.01416949f, 0.01921161f, -0.17082973f, 0.03901985f, -0.11780375f, -0.06149420f, 0.01299728f, 0.05033075f, 
    0.05740489f, 0.02841035f, 0.04259219f, 0.02472003f, 0.13612662f, 0.19899923f, -0.02851524f, 0.09245147f, 
    0.28984997f, 0.40757006f, 0.10023665f, 0.10532729f, -0.17019804f, -0.16055575f, 0.09345707f, -0.07503653f, 
    0.10907427f, -0.20829007f, -0.13640955f, 0.11498169f, -0.07657042f, -0.00608623f, -0.04306583f, 0.06786646f, 
    0.06273247f, -0.05887571f, -0.05390097f, 0.05188586f, -0.11955454f, 0.01086144f, 0.00326899f, 0.05195012f, 
    -0.07632842f, 0.02174877f, 0.11316656f, 0.01517776f, 0.03136422f, 0.01031833f, -0.02795112f, -0.05940603f, 
    -0.11383157f, -0.03335057f, 0.01442026f, 0.02381101f, -0.22107330f, -0.16065575f, 0.02677052f, 0.21474400f, 
    0.14621471f, -0.04702478f, 0.13460895f, -0.13861245f, 0.02856823f, 0.15290955f, 0.12814373f, 0.10780599f, 
    0.36642087f, -0.07274440f, 0.34811217f, -0.12755097f, -0.05903634f, -0.10358643f, 0.26721781f, 0.10195316f, 
    -0.00264986f, -0.00854299f, 0.06093346f, 0.17210643f, 0.08763061f, 0.19615006f, 0.12144670f, -0.08302728f, 
    0.00328616f, 0.10438022f, 0.04299473f, 0.00786212f, 0.08863365f, -0.05162053f, -0.02986117f, 0.12134606f, 
    -0.51675951f, -0.00227094f, -0.18775094f, -0.12111721f, 0.07492556f, 0.22987789f, 0.17362906f, 0.06044930f, 
    0.20631450f, 0.11514621f, -0.07623045f, -0.08145311f, -0.32961088f, -0.14577407f, -0.08294781f, 0.00369048f, 
    0.06314038f, 0.21533397f, 0.03603420f, 0.06174168f, -0.13632482f, 0.16402689f, -0.17339258f, 0.04025368f, 
    0.20571424f, 0.13073616f, -0.06171991f, 0.06001486f, -0.11973322f, -0.01462336f, 0.09604946f, 0.05801271f, 
    -0.07495313f, -0.00990788f, -0.08212492f, 0.10964753f, 0.01098798f, -0.04871669f, 0.04778692f, 0.17446166f, 
    0.02021797f, 0.05801488f, -0.05738940f, -0.05164835f, 0.06007125f, -0.04166232f, -0.11328492f, 0.07222552f, 
    -0.07605403f, -0.14179051f, -0.10081711f, -0.29552522f, -0.01352124f, -0.10793450f, 0.13665757f, 0.12999554f, 
    -0.23323989f, 0.03376509f, -0.04951094f, -0.05312149f, 0.24701759f, -0.00577142f, -0.03347974f, -0.05069059f, 
    0.35765347f, 0.21777551f, -0.08201356f, -0.17448494f, 0.03157478f, 0.05543968f, -0.07089601f, 0.00501274f, 
    0.11423898f, 0.31473112f, 0.05953037f, 0.00763282f, -0.16665070f, -0.32247996f, -0.02878070f, 0.28006348f, 
    -0.01539651f, -0.03482403f, -0.02935955f, 0.06935759f, 0.08708069f, -0.11482013f, 0.25548613f, -0.07605953f, 
    0.01893199f, 0.08379322f, -0.09014680f, -0.14338394f, -0.01468301f, 0.03952152f, 0.12350128f, 0.03420323f, 
    -0.02512495f, -0.15421580f, -0.06201952f, 0.05735175f, -0.00839198f, 0.12456603f, 0.14280191f, 0.15717539f, 
    0.03133974f, 0.18141848f, 0.01479943f, 0.06297842f, -0.19536594f, 0.28095233f, -0.08055820f, 0.10320839f, 
    0.01593748f, 0.19329749f, -0.09698684f, 0.24161234f, 0.05440871f, -0.25392276f, -0.02651345f, 0.03142857f, 
    -0.35227913f, 0.03500315f, -0.26183641f, -0.10741441f, 0.01029722f, 0.23392265f, 0.12117724f, 0.02609114f, 
    0.21290976f, -0.14992011f, -0.12953019f, -0.06012863f, 0.02487484f, 0.07228128f, -0.00615118f, 0.18111810f, 
    -0.08191203f, -0.11844993f, 0.05977368f, 0.01093675f, -0.03915574f, -0.07816325f, 0.24264081f, 0.04531045f, 
    -0.02939698f, -0.05303596f, 0.16253471f, 0.13594268f, 0.04343480f, -0.06220528f, -0.20089482f, 0.07776383f, 
    -0.06561434f, 0.01705955f, -0.02071706f, -0.09206905f, -0.28473401f, -0.04803637f, -0.07584326f, -0.06780925f, 
    0.13310918f, 0.11867896f, 0.07314154f, 0.05514699f, 0.17369813f, -0.07780354f, -0.15537409f, 0.15806541f, 
    0.06294230f, 0.06523338f, -0.03292235f, -0.02434981f, 0.01020358f, -0.10999196f, -0.04484184f, -0.11490748f, 
    0.09019774f, 0.00017426f, -0.03653568f, -0.18315949f, -0.00639869f, 0.02934750f, 0.03179421f, -0.11891551f, 
    0.02552256f, 0.23351589f, -0.18486899f, -0.09272604f, 0.08569602f, -0.00638106f, 0.03809717f, 0.08271418f, 
    0.26162890f, 0.17850412f, -0.20048332f, -0.06961464f, 0.01064211f, -0.20943382f, 0.14525004f, -0.00084362f, 
    -0.11055862f, 0.10881553f, -0.41582885f, -0.08395442f, 0.00705953f, 0.01464260f, -0.31716564f, -0.28935909f, 
    -0.03416513f, 0.10033429f, 0.10635777f, 0.02703583f, -0.10055137f, -0.17580873f, -0.12383225f, -0.16354175f, 
    -0.14148177f, 0.29301107f, -0.33124015f, -0.03237317f, 0.11626291f, 0.18982692f, 0.15955074f, 0.08294669f, 
    -0.06008097f, 0.07370076f, 0.16793843f, 0.03082152f, -0.31646457f, -0.11615554f, 0.33048397f, 0.36161655f, 
    0.22060211f, 0.03003060f, -0.10214145f, 0.04867285f, 0.01960576f, 0.07250445f, -0.04862710f, 0.16792038f, 
    -0.09288450f, 0.07263220f, -0.10889310f, 0.00624085f, 0.03947904f, -0.07741181f, -0.03081682f, 0.02378088f, 
    -0.05277316f, -0.10109866f, -0.15429163f, -0.07647816f, -0.13271068f, 0.08887088f, 0.08939268f, 0.34313613f, 
    0.20451820f, 0.13181567f, -0.08115783f, 0.09902075f, -0.15137807f, 0.00346453f, -0.05731274f, -0.11707471f, 
    -0.24844947f, 0.21911007f, 0.31799644f, 0.20869406f, 0.06452705f, 0.14399670f, 0.03160527f, 0.03870664f, 
    0.03618497f, -0.20551811f, 0.09259970f, -0.04222019f, 0.16156076f, -0.41952828f, 0.20053633f, 0.08611273f, 
    0.19573383f, -0.09150387f, 0.04043105f, -0.03932795f, -0.06280775f, 0.06373467f, 0.04202735f, 0.13907708f, 
    -0.15846916f, -0.25841719f, -0.32639924f, 0.14893831f, 0.06459858f, -0.06727183f, 0.23295833f, 0.14792539f, 
    0.10671259f, -0.15420720f, 0.13432017f, 0.05086865f, -0.22001240f, 0.26035169f, -0.49946570f, -0.16880180f, 
    0.02977663f, -0.06043491f, 0.10757283f, 0.10133658f, 0.09387316f, 0.02743642f, 0.19786917f, -0.16885242f, 
    0.26794383f, 0.13525234f, -0.07731052f, 0.24777217f, -0.00906006f, 0.04242924f, 0.05840846f, 0.00676302f, 
    0.06579275f, 0.12605482f, -0.01904780f, -0.00211383f, -0.09102789f, 0.02181357f, 0.19433169f, 0.24281880f, 
    -0.02854996f, -0.00524887f, -0.03391197f, -0.08816715f, 0.10463896f, -0.01856893f, 0.00004380f, 0.06789290f, 
    0.29035440f, 0.05916750f, 0.15109524f, 0.33083358f, -0.04546325f, 0.01434217f, -0.11410244f, -0.02760466f, 
    0.11706967f, -0.01324718f, 0.06065319f, -0.02460527f, 0.06481490f, 0.14402646f, -0.07351199f, -0.03042936f, 
    0.15456790f, 0.07045548f, -0.05082922f, 0.30675045f, 0.09271473f, 0.08121011f, 0.00847322f, -0.22386137f, 
    -0.94656694f, 0.30897954f, -0.22766681f, -0.08845983f, 0.19119090f, -0.23729452f, -0.13251866f, -0.20122550f, 
    -0.12192416f, -0.18685529f, -0.03537323f, 0.00640732f, -0.42161188f, 0.21361937f, -0.35178220f, -0.13699341f, 
    0.29534253f, 0.19141215f, 0.05958888f, 0.06878786f, -0.14301339f, -0.12984316f, -0.13790441f, -0.03506106f, 
    -0.13542169f, 0.08462331f, -0.12838392f, -0.27285743f, 0.07795414f, -0.09263712f, -0.17477195f, -0.03609909f, 
    -0.29649526f, -0.07562121f, -0.03067830f, -0.04142584f, -0.23732170f, -0.11451817f, -0.39754981f, -0.24755391f, 
    -0.15568686f, -0.24091108f, 0.07458828f, -0.12431814f, -0.05183821f, -0.09178527f, 0.05072550f, 0.06006716f, 
    -0.13648148f, 0.26957497f, -0.32740003f, -0.10054074f, 0.03127303f, 0.06526109f, -0.04041407f, 0.13518459f, 
    -0.08470380f, -0.01712676f, 0.03171884f, -0.19375192f, 0.14842485f, 0.10181705f, 0.17912512f, 0.03749520f, 
    -0.01775036f, -0.04929367f, -0.04219575f, -0.09110853f, 0.03638405f, -0.03498998f, 0.00123201f, -0.02269544f, 
    -0.33697307f, -0.28161442f, 0.01537578f, -0.16970564f, 0.27012023f, 0.09033737f, -0.18645117f, -0.24706465f, 
    -0.16365398f, -0.05837343f, -0.13832583f, 0.04639062f, 0.11589203f, 0.34917930f, 0.30412361f, -0.16872339f, 
    0.17325108f, 0.13348174f, 0.23520957f, 0.15435633f, -0.12909706f, 0.02807549f, 0.06709752f, -0.04993655f, 
    0.06464718f, 0.03792992f, -0.16933292f, 0.10912929f, 0.05259847f, 0.09468896f, 0.00698968f, 0.01786574f, 
    0.04172486f, -0.04851959f, -0.04470164f, -0.00732393f, 0.01886225f, 0.15273438f, 0.06868751f, 0.03301994f, 
    -0.04820843f, 0.02178843f, 0.02225127f, 0.00450100f, -0.04202880f, -0.08675779f, -0.16345470f, -0.15152486f, 
    0.08065972f, -0.03269833f, -0.08632411f, -0.02959925f, -0.00396048f, -0.04062936f, -0.09051564f, -0.16571382f, 
    -0.06223772f, -0.03984945f, -0.05323951f, -0.07484674f, 0.17260602f, -0.05465069f, 0.10420500f, 0.04221542f, 
    -0.08211862f, -0.02760780f, -0.10145396f, 0.02182689f, 0.00081616f, -0.04714041f, 0.14791468f, 0.20172831f, 
    0.09262746f, -0.10046580f, -0.36214930f, 0.10055918f, -0.03911972f, 0.06389841f, -0.07201006f, 0.00789052f, 
    -0.05596959f, 0.02876230f, 0.23972823f, 0.08580710f, 0.19297847f, 0.09471979f, 0.25595349f, 0.34609908f, 
    0.05136094f, 0.10539287f, -0.08202750f, 0.00579894f, 0.12217025f, -0.06586404f, -0.09382372f, 0.01676447f, 
    0.16336465f, 0.09557892f, 0.06688083f, 0.13165596f, -0.20070909f, -0.09562059f, -0.10595375f, -0.02340071f, 
    0.19320577f, 0.17767285f, -0.05764480f, -0.04606384f, 0.19285604f, -0.14610080f, -0.07340828f, 0.17411201f, 
    0.03979223f, 0.01531444f, -0.06622576f, -0.20742539f, -0.06766825f, -0.07494997f, 0.27345908f, -0.11940525f, 
    -0.13357250f, -0.16402370f, -0.15847173f, -0.12106898f, -0.21629150f, -0.03051816f, 0.08101512f, 0.09943031f, 
    0.10076819f, 0.09884586f, -0.08721387f, -0.14104331f, 0.35475758f, 0.01867998f, -0.07647363f, 0.10611510f, 
    -0.12167419f, 0.04623287f, 0.13703696f, -0.15207188f, 0.01788673f, -0.06116226f, 0.00778676f, 0.01760403f, 
    -0.15004358f, -0.02690918f, 0.30652890f, 0.30445251f, 0.11198020f, 0.19241172f, 0.10824839f, -0.15273461f, 
    0.04796998f, -0.14380193f, -0.14455749f, -0.13643906f, -0.06542090f, -0.36574131f, -0.04228124f, 0.09880430f, 
    0.16116966f, 0.16085315f, 0.22129264f, 0.01071260f, -0.01832338f, 0.02141480f, 0.01508349f, -0.12414025f, 
    -0.15353052f, -0.44968954f, -0.54193914f, -0.27303264f, 0.03430570f, 0.26751378f, -0.22514954f, 0.05187894f, 
    0.05786922f, -0.10054216f, -0.07587837f, 0.19293271f, 0.26995248f, 0.21260916f, 0.10375492f, 0.14219582f, 
    0.03425557f, -0.14526299f, -0.09387149f, 0.06648196f, -0.02822379f, 0.03393853f, 0.01598468f, 0.07830604f, 
    0.09070899f, 0.00780564f, 0.11106582f, 0.35303706f, 0.00671346f, 0.09904165f, -0.01041042f, -0.06612933f, 
    0.46996436f, 0.09611198f, 0.03505252f, 0.17813763f, 0.40139511f, 0.13750790f, 0.25778615f, 0.26182097f, 
    -0.07473553f, -0.11728584f, 0.15502362f, -0.05289922f, 0.02560830f, 0.06339370f, 0.09535967f, -0.05256345f, 
    -0.42754316f, 0.06487337f, 0.00236597f, -0.03558609f, 0.02256063f, 0.06871455f, 0.05502071f, 0.08380753f, 
    -0.16025516f, -0.14822780f, -0.00058872f, -0.13712074f, -0.12279826f, -0.05648003f, 0.21351932f, -0.03481132f, 
    -0.20229925f, -0.07654809f, 0.28488430f, -0.25532347f, -0.05499823f, -0.09153172f, 0.09172899f, -0.04541324f, 
    -0.17663361f, 0.14268488f, 0.13180280f, 0.06648654f, 0.08108114f, -0.07076785f, 0.04511844f, 0.13479808f, 
    -0.06414249f, 0.05739348f, 0.07930857f, -0.10267413f, -0.18729691f, 0.25879773f, 0.02261963f, 0.15059699f, 
    0.12132692f, -0.06788194f, 0.10104742f, -0.07233228f, -0.06899197f, -0.19859719f, 0.03041902f, -0.02300335f, 
    0.01322484f, 0.29413939f, -0.22896004f, -0.06298162f, -0.03703363f, -0.08212067f, 0.15007718f, 0.20954260f, 
    -0.14118759f, 0.06005527f, 0.13099083f, -0.02646425f, -0.05673394f, -0.18728285f, 0.00402975f, 0.06620499f, 
    -0.01336118f, -0.03780122f, 0.11308663f, 0.09013077f, -0.00066215f, -0.01971608f, -0.03919252f, 0.00091494f, 
    0.11773284f, -0.01537833f, 0.04536558f, 0.20408612f, -0.12172873f, -0.02127643f, 0.02942938f, 0.11538146f, 
    -0.00474844f, 0.06628597f, -0.00126280f, 0.03079521f, 0.08974987f, -0.05691770f, -0.05303189f, -0.12312574f, 
    -0.01947410f, -0.11471613f, -0.04923939f, 0.15708087f, -0.04734383f, 0.05819365f, -0.08151428f, -0.05995307f, 
    -0.28837147f, 0.04301608f, -0.33343923f, 0.08675157f, 0.02476864f, 0.05076428f, -0.13861449f, -0.03040465f, 
    -0.11515243f, 0.09643001f, 0.03309199f, 0.19461584f, -0.01533984f, -0.08079012f, -0.05400826f, -0.03212132f, 
    0.13677891f, 0.05019435f, -0.01171559f, -0.10102335f, -0.16984230f, -0.11826500f, -0.06852683f, -0.11774903f, 
    0.44095948f, 0.25613469f, 0.13244411f, 0.05078476f, 0.04574280f, -0.07817008f, 0.15927769f, -0.17512693f, 
    -0.03211522f, -0.05325428f, 0.00107371f, 0.10765621f, 0.19130014f, 0.36779287f, 0.25623780f, 0.13642985f, 
    -0.03464372f, 0.03540714f, 0.09888373f, -0.05570348f, 0.06135016f, 0.09536326f, 0.01752268f, -0.00048178f, 
    -0.24852602f, -0.20749286f, 0.25292745f, -0.11127705f, 0.08916599f, -0.01044318f, 0.03120214f, 0.15590249f, 
    0.03153250f, -0.00443249f, 0.01441663f, -0.26256654f, -0.07804914f, 0.01290037f, 0.01343358f, 0.00277806f, 
    -0.02631235f, 0.02192864f, -0.03854910f, -0.00078514f, -0.16491789f, 0.02169052f, 0.16071661f, -0.16197243f, 
    -0.14138965f, 0.20467445f, 0.10028264f, 0.17208603f, -0.00345062f, 0.18817127f, -0.18859445f, -0.14118437f, 
    0.00736844f, 0.01823494f, -0.01211153f, 0.08245762f, -0.02487242f, -0.05130160f, -0.12552239f, -0.24335299f, 
    -0.09387995f, 0.05342217f, 0.12171191f, 0.00432048f, 0.03736389f, -0.02272109f, -0.04387600f, -0.14743565f, 
    -0.22497642f, 0.04627813f, -0.10582808f, 0.13206933f, 0.15957324f, 0.18528208f, 0.13611434f, 0.05594650f, 
    0.09177011f, -0.00235248f, -0.01832355f, -0.10094246f, -0.19938931f, 0.00962988f, -0.06153127f, -0.05090088f, 
    0.12347088f, -0.00911231f, -0.02503325f, 0.18818425f, -0.08724318f, -0.02390827f, -0.03391712f, 0.04495341f, 
    0.09018693f, 0.10135039f, 0.15064028f, -0.02757083f, -0.10721993f, -0.07074283f, -0.12204033f, -0.05755800f, 
    0.01797961f, -0.17474645f, -0.11264775f, -0.10676038f, 0.10569604f, -0.11656164f, 0.23593143f, -0.01380774f, 
    0.05362710f, -0.00557961f, -0.02235478f, -0.03475550f, 0.06196363f, 0.15294765f, -0.11134339f, 0.06902535f, 
    0.05079640f, -0.14088948f, -0.20442323f, 0.01986466f, 0.08052316f, 0.03376657f, 0.16383743f, 0.06915233f, 
    -0.10131048f, 0.06732987f, 0.13342017f, -0.01480778f, -0.00383921f, -0.07010116f, -0.31325260f, -0.16276444f, 
    0.11141524f, 0.06369798f, 0.11517970f, 0.08075023f, 0.06836160f, -0.00996436f, -0.12847845f, -0.10212655f, 
    -0.01874150f, -0.04155251f, 0.01093229f, 0.08583572f, -0.02894715f, 0.13905200f, 0.05005063f, -0.05224121f, 
    0.09389445f, -0.08109389f, -0.13116583f, -0.06645160f, 0.25406861f, -0.20003575f, 0.16777091f, 0.24363263f, 
    0.01765264f, 0.10949913f, 0.24502231f, -0.11587445f, -0.01161095f, -0.03077562f, 0.30654958f, 0.02163894f, 
    0.14632228f, -0.07437667f, -0.14688945f, -0.06118375f, -0.03914449f, -0.11458333f, 0.02867495f, -0.07032824f, 
    -0.05986837f, 0.19924763f, 0.06186133f, 0.06563620f, 0.17116886f, 0.09436435f, 0.22842361f, -0.17634897f, 
    0.01961126f, -0.17173214f, 0.06340560f, 0.02155720f, -0.08066159f, -0.02877151f, 0.04980250f, -0.06325991f, 
    0.03629253f, -0.49649343f, 0.34823230f, 0.08083975f, 0.06653266f, 0.15451403f, 0.14047417f, -0.15306047f, 
    0.12082880f, -0.02035409f, 0.10339819f, 0.00194197f, -0.04266352f, 0.04556819f, 0.52876896f, -0.10599689f, 
    0.04118744f, -0.03187301f, 0.10606369f, -0.11700765f, -0.07921408f, 0.05690773f, -0.00288177f, 0.06798469f, 
    0.18623735f, -0.26758140f, -0.05750514f, 0.00996683f, -0.08122253f, -0.12124596f, 0.16839780f, -0.00982343f, 
    0.11394350f, 0.10267836f, 0.00828285f, -0.02531672f, 0.03204729f, 0.00163736f, 0.21673569f, -0.09700611f, 
    -0.20006481f, -0.03236458f, -0.09539303f, 0.06836501f, -0.01913716f, 0.01509643f, -0.16905494f, 0.03105976f, 
    0.04137881f, -0.10541425f, -0.08094312f, 0.16505533f, 0.02585202f, -0.03831989f, -0.08898596f, -0.03054049f, 
    -0.20387429f, -0.10590386f, -0.00067985f, 0.19053827f, -0.00230658f, -0.42888823f, 0.54353619f, -0.16076668f, 
    0.02215880f, -0.11579727f, 0.03388839f, 0.00333421f, 0.08125904f, -0.04152070f, 0.10268387f, 0.00379955f, 
    -0.31210706f, -0.01530045f, 0.02728254f, 0.00189117f, 0.19498809f, -0.00278403f, -0.06834503f, 0.04737226f, 
    0.07875501f, -0.12083277f, 0.05954838f, -0.15684603f, 0.32666677f, 0.21495269f, 0.09830536f, -0.12133872f, 
    -0.03499685f, -0.12495878f, 0.12105947f, -0.07050118f, -0.07624266f, 0.02145461f, 0.00341392f, -0.01687252f, 
    -0.01199673f, -0.10879856f, -0.01076152f, -0.12738591f, -0.09825974f, 0.01221697f, 0.04938090f, 0.01468965f, 
    0.04633232f, -0.10577343f, 0.10626306f, 0.10349821f, 0.34905338f, -0.13541162f, 0.29413235f, -0.14024161f, 
    -0.10988224f, -0.05613232f, -0.15365154f, -0.01726709f, 0.11969935f, 0.00788434f, 0.08097126f, 0.09191491f, 
    0.30264691f, -0.63868546f, 0.14247677f, -0.40378723f, -0.06658144f, -0.08742503f, 0.15953360f, 0.12727703f, 
    0.01288596f, 0.00178755f, -0.03961274f, -0.03632891f, -0.38703626f, -0.38202325f, -0.24170707f, 0.22878672f, 
    0.19634259f, -0.00557242f, -0.10515389f, -0.11729362f, 0.05927181f, 0.07860213f, 0.08185901f, 0.02468564f, 
    -0.32672864f, -0.46323869f, -0.28225595f, 0.13599741f, 0.09523456f, 0.05409404f, -0.01609066f, 0.00538739f, 
    0.11643846f, 0.00380366f, 0.22154601f, -0.00304750f, -0.13932627f, -0.07965856f, -0.34384972f, -0.25889122f, 
    0.01001757f, 0.14704520f, -0.13319187f, 0.01440168f, 0.13991816f, -0.20451827f, 0.01927763f, 0.03741584f, 
    -0.07431956f, 0.04448044f, 0.51641071f, 0.27041987f, 0.06440163f, -0.06602076f, -0.03579131f, -0.00204577f, 
    0.05080596f, -0.09680060f, 0.19048588f, 0.02341174f, 0.33617818f, 0.01102241f, 0.43775204f, -0.04140832f, 
    0.00447102f, -0.06046329f, 0.06836389f, 0.04985793f, 0.00601689f, 0.05580803f, 0.02634596f, 0.03533985f, 
    0.28485692f, 0.11228289f, -0.03388871f, -0.06315685f, 0.05043950f, 0.05385808f, 0.13527192f, -0.00827858f, 
    0.03566940f, -0.05751003f, 0.03842770f, -0.23549581f, 0.03501250f, 0.10565111f, -0.09695987f, -0.13865097f, 
    0.00214000f, 0.09498116f, 0.02956034f, 0.09591129f, 0.01767858f, -0.04334497f, 0.11378819f, 0.08908232f, 
    0.27485177f, -0.06789687f, 0.33808401f, -0.01990529f, 0.03211007f, 0.01664975f, 0.10313408f, 0.09336664f, 
    0.04009074f, -0.10022815f, -0.00868431f, 0.04593487f, -0.15461765f, -0.44392735f, -0.34077728f, 0.01625175f, 
    0.21616271f, -0.05345928f, -0.16293576f, 0.05106117f, 0.00364460f, 0.04285869f, -0.02961206f, 0.11399897f, 
    0.06753263f, 0.04748808f, 0.28556827f, 0.10798784f, 0.03260197f, 0.20049216f, 0.13735893f, 0.01233882f, 
    0.04742689f, -0.06716721f, 0.00995075f, 0.26106745f, 0.45397189f, 0.59445971f, 0.10424750f, -0.06024230f, 
    -0.02361308f, -0.08799560f, 0.11049394f, 0.13341612f, -0.01040246f, 0.11556416f, -0.01293299f, -0.00387502f, 
    0.08365792f, -0.19028220f, -0.05374967f, 0.01565700f, -0.10593984f, 0.08480621f, -0.13587871f, 0.10457601f, 
    0.11324213f, -0.05046560f, -0.04566813f, -0.10621163f, -0.19472840f, -0.14897273f, 0.16485213f, 0.11767344f, 
    -0.10754107f, 0.13922556f, -0.05534695f, 0.10479211f, -0.01104970f, -0.20631924f, -0.27515164f, -0.05565885f, 
    0.07179598f, 0.19897594f, 0.02063571f, -0.02089935f, 0.06179527f, 0.00647584f, 0.05447889f, -0.05485176f, 
    0.22373521f, 0.00749586f, -0.15420945f, -0.21402852f, -0.30421257f, 0.00720985f, -0.03113835f, 0.06001849f, 
    0.01859261f, -0.02750907f, -0.06425896f, 0.17678554f, 0.20631227f, -0.05369217f, 0.08683214f, 0.08101013f, 
    0.19638526f, -0.19042794f, 0.13797879f, -0.17144231f, -0.08797352f, 0.08001867f, -0.10891516f, -0.01526874f, 
    -0.16034620f, 0.02547192f, 0.03685906f, -0.02883378f, -0.14410405f, -0.30514938f, -0.12682433f, 0.20680279f, 
    0.02843015f, 0.06864142f, -0.03059559f, -0.02440077f, -0.02487245f, 0.07497344f, -0.12422881f, -0.03917037f, 
    -0.07653472f, -0.59395224f, -0.20712404f, -0.08784080f, 0.09523157f, -0.11949827f, 0.07006639f, 0.08419798f, 
    0.19301523f, -0.01490675f, -0.05652056f, 0.07878172f, 0.20814887f, -0.37432766f, -0.20660374f, 0.16028778f, 
    -0.07339016f, -0.02294954f, 0.05065899f, -0.11778263f, -0.07194409f, 0.01279570f, 0.03770721f, 0.12545720f, 
    0.08447446f, 0.03986752f, -0.09795039f, 0.08367787f, 0.07733838f, 0.01431101f, 0.11139751f, 0.12649132f, 
    -0.04802782f, 0.00466813f, 0.21623220f, 0.25397640f, 0.07044821f, 0.26178411f, -0.11227999f, 0.11715502f, 
    0.20013303f, -0.04511096f, 0.01600537f, 0.12556155f, -0.12117199f, -0.07947148f, -0.17895997f, -0.14125997f, 
    -0.11539474f, -0.11806656f, 0.16265956f, 0.19107203f, 0.20515504f, -0.10667678f, 0.03853391f, 0.10987999f, 
    0.09734415f, -0.08841452f, -0.03964775f, -0.02375358f, 0.17110631f, 0.08831377f, 0.07399656f, -0.07088365f, 
    0.03351995f, 0.17070279f, 0.06498646f, 0.14759322f, 0.03563177f, 0.13955075f, 0.06660524f, 0.20537770f, 
    0.15725906f, -0.03662614f, -0.20629524f, 0.08216688f, 0.22287378f, 0.09308142f, 0.05005111f, 0.05372705f, 
    -0.04072809f, 0.02337290f, 0.01773426f, 0.07704093f, -0.32566994f, -0.15165056f, -0.25915870f, 0.13946992f, 
    0.11499074f, -0.06371664f, -0.08489893f, 0.03606584f, 0.13552848f, -0.12802723f, 0.13132857f, -0.01528225f, 
    -0.35652909f, -0.25329363f, -0.22623640f, 0.12428661f, 0.10955779f, 0.00930906f, 0.04152774f, 0.12299756f, 
    0.01016798f, -0.03363215f, 0.05047264f, 0.10100961f, -0.33057010f, 0.08567118f, -0.40464824f, 0.32423043f, 
    0.09480435f, -0.01698352f, -0.09936965f, -0.02460902f, 0.11307886f, -0.14093338f, 0.01507674f, 0.06846920f, 
    -0.27679750f, -0.07508077f, 0.29124457f, 0.13762040f, -0.07404070f, -0.03430206f, 0.11283707f, 0.07821570f, 
    -0.06205649f, -0.12620951f, 0.00056111f, 0.03852045f, -0.04640577f, -0.21244624f, 0.21225031f, 0.00154836f, 
    -0.18157358f, 0.12308112f, -0.15184507f, 0.03757141f, 0.03130678f, -0.07164255f, 0.02418001f, 0.07105358f, 
    0.00884996f, -0.17910063f, -0.09876057f, 0.24196997f, 0.03517111f, 0.03813918f, 0.03901532f, -0.13075089f, 
    0.13402461f, -0.12781727f, 0.00838812f, 0.10609637f, -0.29026884f, 0.33579272f, -0.42082343f, 0.27201495f, 
    0.11628965f, 0.14101607f, 0.07877014f, 0.06165060f, 0.01152108f, -0.00887225f, -0.01217597f, -0.09195635f, 
    -0.00329999f, -0.29331273f, -0.15196547f, 0.25454593f, 0.07913999f, 0.10528368f, 0.06906435f, 0.05397765f, 
    -0.07517885f, 0.08048796f, -0.02817488f, 0.03446072f, -0.17340916f, -0.00440509f, 0.01040860f, 0.15920526f, 
    0.02234493f, 0.05760209f, -0.00673591f, 0.00145553f, 0.08589781f, -0.01779702f, 0.01463028f, -0.08604632f, 
    0.04452760f, 0.03110994f, -0.06265157f, 0.10150446f, 0.04915059f, 0.15716612f, 0.02345099f, 0.00096039f, 
    -0.03657850f, 0.04983271f, -0.03152642f, -0.04974899f, 0.06921942f, -0.12954694f, 0.03621753f, -0.02794496f, 
    -0.08206557f, 0.02355991f, -0.04075799f, -0.04083923f, -0.02361211f, -0.33118498f, 0.23713887f, 0.13938434f, 
    -0.56942993f, -0.08100046f, -0.10905953f, 0.23330414f, -0.03365938f, 0.01369061f, -0.14936003f, 0.04627386f, 
    -0.00901417f, 0.03683846f, 0.08629260f, -0.03091557f, -0.08740187f, -0.07550629f, -0.11496790f, 0.05369079f, 
    -0.02790523f, -0.05579172f, 0.06774333f, 0.05961669f, 0.05571613f, 0.13096638f, 0.01855945f, 0.04067058f, 
    -0.46478537f, 0.49684536f, 0.00336875f, -0.09494882f, 0.04659809f, -0.01304806f, -0.17581983f, 0.02819190f, 
    -0.14952606f, 0.16894822f, -0.05716063f, -0.02696664f, -0.27057496f, 0.23258582f, -0.15406840f, -0.13577335f, 
    -0.07806030f, -0.05922408f, 0.05902299f, -0.09109718f, 0.11602077f, 0.07208403f, -0.19443719f, 0.07473880f, 
    -0.15178443f, -0.01431177f, -0.17241620f, 0.09820510f, -0.07006735f, 0.04882319f, 0.00062963f, 0.02051035f, 
    0.06153586f, 0.02666812f, 0.17367002f, 0.00615563f, 0.15658152f, 0.02254563f, 0.12040772f, 0.07318497f, 
    0.10394546f, 0.04524084f, 0.20631084f, 0.08955015f, -0.08034160f, -0.01775629f, 0.00791693f, -0.01635969f, 
    -0.11911792f, -0.07109058f, -0.09543400f, -0.17378443f, -0.06774632f, -0.11334175f, -0.09020195f, -0.07988020f, 
    0.06018459f, 0.00147840f, 0.03326158f, -0.19264957f, -0.03184792f, 0.23153457f, 0.22317044f, -0.05450935f, 
    0.02326393f, -0.13917679f, -0.03609306f, 0.01359204f, 0.04696016f, -0.02858562f, 0.04605458f, 0.03302502f, 
    -0.10754285f, 0.09579646f, -0.09391849f, 0.29290023f, -0.00144423f, 0.00460242f, 0.11540411f, -0.12590809f, 
    -0.04079458f, -0.00692927f, -0.02277898f, -0.02837677f, -0.21580276f, 0.08913797f, -0.11938041f, 0.06761118f, 
    -0.09673131f, 0.25324497f, 0.16637409f, 0.03314352f, 0.14943920f, 0.08636457f, 0.06577611f, -0.03779570f, 
    0.14781867f, 0.10161323f, 0.08649220f, -0.00560068f, -0.02325061f, -0.11077729f, 0.06232373f, -0.03225111f, 
    -0.01895328f, 0.04300294f, 0.03485649f, 0.01365260f, -0.04728935f, 0.23369704f, -0.20242999f, -0.28217110f, 
    0.06934977f, -0.00196040f, -0.03369652f, 0.01905020f, -0.08311518f, -0.28347448f, 0.08633919f, -0.07712003f, 
    -0.01603591f, 0.12760584f, -0.09665435f, 0.27976099f, -0.02617491f, 0.00462383f, -0.19124033f, 0.00195453f, 
    -0.12763335f, -0.06643232f, 0.17389800f, 0.02387473f, -0.19343308f, -0.27387217f, 0.09570840f, 0.19749962f, 
    -0.06833293f, 0.13149098f, -0.05829849f, 0.07676353f, 0.03158583f, -0.01828473f, 0.08955967f, 0.04820519f, 
    -0.08248708f, 0.06937544f, -0.01576152f, 0.04651783f, 0.05945497f, -0.00717648f, -0.01012285f, 0.17372203f, 
    -0.04650440f, -0.10614137f, -0.01165950f, 0.04687375f, 0.05105545f, 0.18258888f, 0.24914452f, 0.11230895f, 
    -0.01522214f, 0.01751963f, 0.00563643f, -0.02364010f, -0.10364642f, 0.00180295f, 0.28819269f, -0.02780233f, 
    0.02801771f, -0.08991349f, 0.10133887f, 0.05842268f, -0.10903804f, -0.04832092f, -0.02644755f, -0.02588814f, 
    0.03020735f, 0.01319401f, -0.00171413f, -0.10559013f, 0.22883315f, -0.20030452f, -0.10760565f, -0.11803932f, 
    -0.06095004f, -0.05050883f, 0.04511856f, 0.14884022f, -0.04180724f, 0.06471753f, 0.02631106f, 0.13301688f, 
    -0.30969745f, -0.35538056f, 0.36971194f, 0.10416982f, -0.00990516f, 0.17506936f, -0.18548629f, -0.00864450f, 
    0.08256387f, 0.10840191f, 0.02134879f, 0.11122668f, -0.03144734f, 0.08991027f, -0.14648454f, 0.00566545f, 
    0.06266717f, -0.06902094f, 0.03809664f, 0.08348022f, 0.05493211f, 0.02598097f, 0.07133616f, -0.04235993f, 
    -0.18157053f, -0.07104354f, 0.14254057f, 0.02931088f, -0.03313895f, 0.04398750f, -0.13528092f, -0.00569774f, 
    -0.00916326f, 0.08288807f, 0.04829920f, 0.03947415f, 0.39118037f, 0.05847708f, -0.11538406f, -0.03312946f, 
    0.00629573f, 0.13606599f, 0.29546240f, 0.08070806f, -0.03887792f, 0.05829925f, -0.07770249f, 0.13216667f, 
    -0.06404219f, -0.05587065f, -0.05155895f, 0.16094638f, 0.08415922f, 0.06395233f, -0.04880602f, 0.04287750f, 
    0.07418218f, 0.09210102f, -0.06426942f, 0.06180400f, 0.43882629f, -0.11065457f, -0.05215978f, 0.11541062f, 
    0.02163813f, 0.11326580f, 0.27809358f, -0.09335390f, -0.05798691f, -0.01810493f, -0.08705178f, -0.07219967f, 
    -0.00660731f, -0.10106602f, -0.01302531f, -0.05020117f, -0.04501275f, -0.09571795f, -0.08426321f, -0.11772602f, 
    0.28741229f, 0.13893244f, -0.02604252f, 0.18798293f, -0.07009833f, 0.09968428f, -0.11709218f, -0.03303647f, 
    0.11646569f, 0.13340211f, 0.08208969f, 0.11742894f, 0.12039911f, 0.10227073f, -0.00338780f, 0.07500213f, 
    0.11524345f, 0.12088493f, 0.23973018f, 0.15153524f, 0.29969889f, 0.09401093f, 0.06476315f, 0.02522600f, 
    0.21227114f, -0.00758914f, 0.13014288f, 0.18211247f, -0.05294690f, -0.20429575f, -0.02060847f, -0.00658715f, 
    -0.18294853f, -0.01596333f, -0.01129127f, 0.26007274f, 0.18835774f, 0.12298226f, 0.07919786f, -0.14355901f, 
    0.05573523f, 0.26673001f, 0.12462745f, 0.05287939f, 0.03716617f, 0.11481548f, -0.16243471f, 0.02726146f, 
    0.01821556f, 0.00635981f, -0.10448352f, -0.08181192f, 0.05918209f, 0.17667940f, 0.11506040f, -0.11047574f, 
    -0.02312036f, 0.01426614f, -0.09317779f, -0.03307914f, 0.10196774f, 0.07990299f, 0.12202734f, 0.05321364f, 
    0.12824537f, 0.19845004f, 0.23005588f, 0.05596209f, -0.04683667f, -0.06247175f, -0.03577255f, -0.04752680f, 
    -0.04353971f, -0.01878304f, -0.01204369f, 0.03241356f, 0.07960428f, 0.02211140f, 0.00807978f, 0.10517287f, 
    -0.02255393f, 0.02587302f, 0.03828766f, -0.03567269f, 0.09170817f, 0.17274232f, 0.23002967f, -0.01278276f, 
    0.05059847f, -0.20666437f, 0.07581849f, 0.14784148f, -0.00345493f, -0.07450359f, 0.03454249f, 0.12331332f, 
    0.15250207f, 0.19606224f, 0.06174016f, -0.04799011f, -0.18125305f, -0.12889278f, 0.03841687f, 0.03696418f, 
    0.04799827f, 0.01959400f, -0.03279470f, 0.06634668f, 0.30773577f, -0.03300396f, 0.17702901f, 0.16828251f, 
    -0.34507495f, -0.35431617f, -0.01777437f, -0.12681566f, -0.07296199f, 0.01214955f, 0.04939672f, 0.08387313f, 
    -0.01726512f, -0.13139324f, -0.00824650f, -0.07081847f, 0.07530709f, -0.24703306f, -0.01292824f, -0.06830895f, 
    0.02671663f, 0.11433083f, -0.00043962f, 0.14088811f, -0.11429206f, -0.02803116f, 0.03228883f, 0.03746057f, 
    -0.04437129f, 0.13764270f, 0.10724349f, 0.06929099f, 0.09650115f, -0.07832236f, 0.09481938f, 0.05487397f, 
    0.06713693f, 0.08027765f, 0.07758543f, 0.12515262f, 0.12341543f, 0.09921379f, 0.17889842f, 0.00684527f, 
    -0.15420471f, -0.07715222f, 0.05813438f, 0.06040250f, 0.18492152f, -0.00154749f, -0.02543163f, 0.08535399f, 
    0.05650019f, -0.07094562f, 0.02540895f, -0.09922481f, -0.02527146f, -0.08336303f, 0.01436750f, 0.20159134f, 
    -0.11828404f, -0.10664362f, 0.01856061f, -0.13840686f, -0.16017188f, -0.00427980f, -0.07862964f, 0.02154472f, 
    0.21078645f, 0.00258958f, -0.14830610f, -0.22081006f, -0.02984107f, -0.10095614f, -0.03299972f, 0.12698588f, 
    0.09022024f, 0.01153116f, 0.07080947f, -0.07523699f, 0.09442989f, 0.05772245f, 0.09932220f, 0.12088079f, 
    0.03810692f, 0.01089217f, 0.01505538f, 0.04625057f, 0.05010617f, -0.06058056f, -0.17049716f, -0.04079523f, 
    0.02936949f, -0.08733095f, -0.18494655f, -0.01753285f, -0.06355973f, -0.07610980f, -0.04841152f, -0.00625194f, 
    0.05422635f, -0.09521360f, -0.00500693f, -0.07098266f, 0.27715841f, 0.14643468f, 0.07497662f, 0.06046315f, 
    -0.15809354f, -0.04244150f, 0.06607477f, 0.09094077f, 0.03964815f, -0.00328161f, 0.13714059f, -0.05250093f, 
    -0.01734502f, -0.00257737f, 0.10062788f, 0.13102031f, -0.00472185f, 0.05078714f, 0.02618509f, 0.02527756f, 
    -0.30236495f, -0.19405551f, 0.09656318f, -0.22178553f, -0.15095484f, 0.00284046f, 0.02892196f, 0.25258717f, 
    0.15139788f, 0.14816369f, -0.04138030f, 0.01611362f, 0.05461852f, 0.10563519f, 0.02651484f, 0.12708494f, 
    -0.04336328f, -0.11596876f, 0.02260113f, -0.03021854f, 0.06195103f, 0.13259506f, 0.08802569f, 0.06180341f, 
    0.05506098f, 0.12147114f, 0.05875259f, -0.20463136f, -0.14365302f, -0.13082233f, -0.00699128f, -0.02954346f, 
    0.03218924f, 0.01698223f, -0.03032315f, 0.03790018f, -0.11263981f, -0.22058174f, 0.04548873f, -0.18703882f, 
    -0.07045431f, 0.03594379f, 0.05548944f, 0.08328624f, 0.13729751f, 0.01321702f, -0.16892034f, -0.04119788f, 
    -0.24026579f, 0.08822880f, 0.05338646f, -0.22269514f, 0.04777981f, 0.07317021f, 0.00136001f, 0.10287068f, 
    0.02726664f, -0.16254486f, -0.12902285f, -0.19351164f, 0.06321505f, 0.04170518f, 0.15556000f, -0.09069596f, 
    0.15291916f, -0.05700459f, -0.06166793f, -0.14962813f, -0.00850853f, 0.05719310f, -0.05081151f, 0.02052473f, 
    -0.26428542f, 0.05261547f, -0.15667430f, -0.07342958f, 0.02811775f, -0.04721778f, 0.19258830f, -0.08005644f, 
    0.05396369f, 0.00350872f, 0.12320138f, -0.12539278f, -0.08096156f, -0.02618847f, -0.09487623f, -0.16705668f, 
    -0.09880260f, 0.14657097f, -0.03072215f, -0.07783137f, 0.03631169f, -0.02046384f, 0.03727169f, -0.13829188f, 
    -0.10077051f, 0.08979227f, -0.00791301f, -0.05583801f, 0.02012983f, 0.14928418f, 0.12955856f, 0.10492887f, 
    0.14291005f, -0.01339210f, 0.08100727f, 0.09916531f, 0.28197891f, 0.15166000f, 0.07641936f, -0.05254168f, 
    0.07253303f, -0.13141173f, -0.07201847f, 0.04672879f, 0.00284249f, -0.05361190f, 0.07665154f, 0.00215476f, 
    0.02096209f, 0.03272042f, 0.10385562f, -0.19892466f, -0.06684104f, 0.00561194f, -0.10921493f, 0.00630295f, 
    0.10068541f, -0.02553307f, 0.04386324f, -0.22036766f, 0.23487274f, -0.07551441f, 0.30208331f, -0.16572642f, 
    0.08027415f, -0.03364422f, -0.04076230f, 0.04685147f, -0.07439197f, -0.08654054f, 0.04807581f, -0.07982293f, 
    0.25857684f, -0.13325147f, -0.18433097f, -0.27722913f, 0.07487223f, 0.03884720f, 0.12849969f, 0.08363555f, 
    -0.31815931f, -0.03014325f, 0.33909911f, -0.10790800f, -0.00331794f, 0.01748840f, -0.11601350f, 0.10998877f, 
    -0.01512434f, -0.12915532f, -0.26111591f, -0.11089173f, 0.21715286f, 0.06317017f, -0.13348265f, 0.12039532f, 
    -0.09241807f, -0.07396422f, -0.17855524f, -0.17264827f, -0.00310515f, -0.45604110f, 0.04800839f, -0.21246898f, 
    -0.09688944f, 0.11577601f, -0.01204807f, 0.03467062f, 0.27038389f, 0.00415255f, 0.27458963f, -0.11627850f, 
    0.10014078f, -0.08792999f, -0.02646022f, -0.04960276f, -0.34288925f, 0.22542734f, 0.07620841f, -0.13921160f, 
    -0.02308532f, -0.22660427f, -0.06438781f, -0.03715085f, 0.02970721f, 0.00590976f, -0.07331981f, -0.03390324f, 
    0.16738047f, 0.07201363f, -0.04060475f, 0.03266777f, -0.06272390f, 0.01673813f, -0.10626712f, -0.13334844f, 
    0.10791918f, 0.08154151f, 0.00674716f, 0.07632163f, -0.15375701f, -0.46800014f, -0.29958451f, -0.54313505f, 
    -0.04956393f, -0.09405977f, -0.12655911f, -0.12814178f, 0.03763632f, 0.04774210f, 0.03502547f, 0.05765691f, 
    0.08976308f, 0.12987138f, -0.06905327f, 0.00932873f, -0.28628749f, 0.16084635f, -0.01318020f, -0.11263866f, 
    0.10959002f, 0.00328518f, 0.19662139f, -0.02037660f, -0.51816154f, 0.44077408f, -0.07656806f, -0.28657261f, 
    0.16403526f, -0.14401056f, 0.15330589f, 0.04272019f, -0.08352951f, 0.08397277f, 0.23570582f, -0.16900343f, 
    -0.32957992f, -0.21575461f, -0.37598172f, 0.04744952f, -0.05476533f, -0.13460521f, 0.09957951f, -0.18621679f, 
    -0.28074616f, -0.07543174f, -0.02287179f, -0.13777483f, -0.06051297f, 0.04719816f, -0.13086256f, -0.10562325f, 
    0.31129172f, -0.27165058f, -0.29704309f, -0.18191728f, 0.14510189f, 0.14322285f, 0.14900060f, 0.18788332f, 
    0.21182992f, 0.08596129f, 0.12201653f, 0.14915127f, -0.17892049f, -0.14516580f, -0.02913636f, 0.14566024f, 
    0.27969873f, 0.11756291f, 0.16950122f, 0.37442034f, -0.20500593f, 0.01135942f, -0.01827834f, -0.21763889f, 
    0.00128480f, -0.21889961f, 0.21606980f, -0.00890866f, -0.03821409f, -0.25332174f, -0.46643716f, 0.00137611f, 
    -0.05171918f, 0.11689208f, -0.01746946f, 0.06411001f, -0.00273055f, -0.01831042f, -0.02777899f, -0.03715086f, 
    -0.06513713f, 0.05841066f, -0.01138708f, -0.05372208f, 0.11591803f, -0.00402647f, 0.11552783f, 0.07862191f, 
    -0.04900444f, 0.03223742f, 0.05496856f, -0.07801342f, 0.20764919f, 0.13229413f, 0.45360398f, 0.37300962f, 
    -0.13962267f, -0.09864961f, -0.19037528f, -0.00157576f, 0.22035164f, 0.18780744f, -0.01133076f, 0.18051162f, 
    0.01748211f, -0.02751084f, 0.24165121f, -0.03067267f, 0.21577138f, 0.06829558f, 0.13079628f, 0.00191006f, 
    0.15782955f, 0.03202691f, -0.04877846f, 0.02607467f, -0.19706860f, -0.42103156f, -0.28045052f, 0.09873082f, 
    0.15696806f, -0.03652783f, -0.05406897f, 0.00432354f, 0.17358154f, 0.05069854f, 0.13311435f, 0.07969762f, 
    0.01487684f, -0.27547315f, 0.16896963f, -0.03458928f, 0.08692652f, 0.03798666f, 0.01659693f, 0.09715744f, 
    0.09514283f, 0.08053334f, 0.05431325f, 0.10638098f, -0.40920404f, -0.18232539f, -0.13138388f, 0.16957198f, 
    0.16918339f, 0.22210462f, 0.10976297f, 0.12289125f, -0.17494655f, 0.10938962f, -0.23020609f, -0.09152394f, 
    0.08916544f, 0.17115939f, -0.21213399f, 0.00438390f, 0.22496751f, -0.03110454f, 0.04748212f, 0.17272659f, 
    0.03729738f, 0.40721881f, 0.26181963f, -0.09257045f, 0.11239539f, 0.08239979f, 0.15325001f, -0.00121387f, 
    -0.12263736f, -0.23520005f, 0.10527003f, 0.07954410f, 0.11459915f, 0.11207990f, 0.06798522f, -0.05074580f, 
    0.04808483f, -0.00325434f, 0.13001832f, -0.00757063f, -0.02280908f, 0.10099372f, 0.05200169f, -0.03645999f, 
    0.04199258f, 0.03551460f, 0.04273129f, -0.00351484f, 0.09115081f, 0.08224666f, -0.07289926f, -0.02424691f, 
    -0.07426405f, 0.16961247f, 0.18835062f, 0.03202523f, -0.28053531f, -0.17056482f, -0.06174085f, 0.03795329f, 
    0.09181812f, 0.04794896f, -0.04465198f, 0.07258148f, -0.23536959f, 0.20094565f, -0.16464286f, -0.22345346f, 
    0.00450706f, -0.03449243f, 0.15265621f, -0.01357895f, 0.19107230f, 0.11546648f, 0.05703774f, 0.01275978f, 
    -0.13696422f, -0.16228940f, -0.03052453f, -0.04687659f, -0.02168494f, 0.07647943f, 0.09410251f, 0.08514073f, 
    -0.17619953f, 0.41973558f, -0.01987192f, -0.09904949f, 0.17707601f, 0.10960827f, 0.08168186f, 0.12011047f, 
    0.38115296f, 0.23417197f, -0.06305570f, -0.16599847f, 0.00517302f, -0.26986021f, 0.18873617f, 0.15402192f, 
    -0.20880386f, 0.17594516f, -0.20541212f, -0.11657554f, -0.15558991f, -0.30112177f, -0.27410644f, -0.28442025f, 
    0.00207348f, -0.20899370f, -0.27221033f, -0.05561909f, -0.24984771f, -0.21524347f, -0.39996248f, -0.23239054f, 
    -0.03703816f, 0.16257372f, 0.03839789f, -0.00393265f, 0.03683667f, 0.14728986f, -0.24226610f, 0.20482583f, 
    -0.41106120f, -0.35330820f, 0.25402093f, 0.12513998f, -0.02237156f, -0.09606270f, -0.10076842f, -0.08429343f, 
    0.07413156f, 0.02708478f, -0.17870232f, 0.04573304f, 0.12752816f, 0.09262670f, 0.04760001f, 0.12274642f, 
    0.00208357f, 0.06686776f, 0.02846632f, -0.10710312f, 0.14362405f, 0.02952740f, -0.01628464f, -0.00577058f, 
    0.07336234f, -0.09978337f, -0.11180021f, -0.40544826f, -0.01499276f, 0.30962744f, -0.47854570f, -0.08380728f, 
    0.08352134f, 0.01474568f, -0.11982184f, -0.07853244f, 0.10969290f, 0.10317083f, -0.01180772f, -0.12413117f, 
    -0.17001173f, -0.11235988f, 0.02367628f, -0.04270154f, 0.12693389f, 0.02297295f, -0.07605113f, 0.03636754f, 
    -0.08985603f, -0.05433145f, 0.04920420f, -0.17377703f, -0.00347843f, 0.06758031f, 0.14289844f, -0.01142491f, 
    -0.25702119f, -0.10418738f, 0.29094535f, -0.13109119f, -0.12792505f, -0.06280863f, 0.14860828f, -0.03179139f, 
    -0.00541505f, 0.15784591f, 0.17949313f, 0.08414664f, 0.03968263f, -0.07070012f, -0.05216026f, 0.10876186f, 
    -0.02113529f, 0.04105498f, 0.17475431f, -0.09355429f, -0.08529039f, 0.18908806f, 0.09040789f, 0.11700179f, 
    0.03666332f, -0.13196436f, 0.10580903f, -0.04144769f, -0.00167253f, -0.11089396f, -0.04566280f, -0.04092519f, 
    -0.19001837f, 0.34833524f, -0.13304441f, -0.07459522f, -0.07464111f, 0.00679085f, 0.10794529f, -0.00422838f, 
    -0.07119089f, -0.01345697f, 0.09785967f, 0.03251015f, -0.00700586f, -0.15265547f, -0.05358070f, -0.17637333f, 
    -0.03691979f, 0.04843276f, 0.13004507f, 0.08951730f, -0.05580544f, 0.08073507f, -0.00103450f, 0.04016312f, 
    0.08806073f, 0.01647338f, 0.01498820f, 0.00138220f, -0.09677930f, 0.06068231f, 0.05439570f, 0.06864776f, 
    -0.09070548f, 0.06108461f, 0.02638667f, 0.05112064f, 0.03668113f, -0.19229683f, 0.14696522f, -0.08122025f, 
    -0.04535193f, -0.04822970f, 0.00551758f, 0.08197841f, 0.02787324f, 0.00020010f, -0.16581570f, -0.05264364f, 
    0.25525299f, 0.10502768f, -0.05058937f, -0.06214617f, 0.03057029f, 0.10882393f, -0.12509754f, -0.03559523f, 
    0.02589530f, 0.09725364f, 0.02806678f, -0.01620928f, 0.14154066f, 0.05529263f, 0.01772353f, -0.07549305f, 
    -0.05456701f, 0.08041065f, -0.02222620f, -0.20421144f, -0.06478307f, -0.01336561f, -0.06175542f, -0.12336735f, 
    0.45752391f, 0.37450463f, 0.06424724f, -0.00330448f, 0.08589567f, -0.09619696f, 0.06200502f, -0.10591085f, 
    -0.11503462f, -0.10078674f, -0.08884054f, 0.00038670f, 0.28522223f, 0.40771437f, 0.10054982f, 0.10175201f, 
    -0.00626070f, 0.07414249f, 0.05733041f, -0.13099927f, 0.01145226f, 0.01808034f, 0.09772956f, 0.05755410f, 
    -0.01382199f, -0.07418465f, 0.20782381f, -0.15992850f, -0.04115494f, -0.07838175f, -0.02562882f, 0.05349043f, 
    0.02436983f, -0.02441230f, 0.02469117f, -0.16875274f, 0.10839629f, 0.05674322f, 0.03163321f, -0.01421608f, 
    -0.01921291f, 0.01181126f, 0.03859116f, 0.14753579f, -0.20304658f, 0.07549977f, 0.05207108f, -0.19196355f, 
    0.05542521f, 0.19340980f, 0.11651780f, -0.00740319f, 0.11042787f, 0.21859911f, -0.15368724f, -0.12911217f, 
    0.04674885f, 0.05309994f, -0.03542699f, 0.21775056f, 0.14327133f, -0.04941805f, -0.07843997f, -0.12571959f, 
    -0.19349296f, -0.06646156f, -0.00858290f, 0.05061134f, -0.01462057f, -0.10098274f, -0.02663016f, -0.06884634f, 
    -0.33675280f, 0.17157218f, -0.17306900f, 0.09306796f, 0.14883506f, 0.05407736f, 0.19219944f, 0.08755627f, 
    -0.00122872f, -0.05937274f, -0.02909083f, -0.02771456f, -0.07938475f, -0.05713655f, 0.07465442f, -0.01858908f, 
    0.02240706f, -0.00091472f, 0.00252995f, 0.25439331f, -0.18462694f, -0.01899363f, -0.14702569f, -0.00417450f, 
    0.06708277f, 0.02548829f, 0.20261812f, 0.02673683f, -0.16395789f, 0.01997708f, -0.04863832f, -0.10133096f, 
    -0.05970877f, -0.23700725f, -0.08536489f, -0.13627848f, 0.04599508f, -0.11528770f, 0.23215847f, 0.02362814f, 
    -0.03721346f, 0.03961977f, -0.06015882f, 0.07358277f, 0.13779874f, 0.16287819f, 0.01160158f, 0.08038101f, 
    0.01818187f, -0.02096776f, -0.16713390f, 0.12478834f, -0.15250029f, -0.03393146f, 0.03590679f, 0.01747234f, 
    -0.08120258f, 0.07366019f, -0.02299090f, -0.09530602f, -0.07069075f, 0.09886762f, -0.30296940f, -0.25772905f, 
    0.04807032f, 0.00484215f, 0.13564736f, 0.10164375f, -0.06593446f, 0.00915103f, -0.08699198f, -0.14678864f, 
    0.08467623f, -0.03686467f, 0.07072306f, 0.06166824f, 0.03551140f, 0.13200659f, 0.07489709f, -0.00807117f, 
    0.08153217f, 0.08325114f, -0.09456070f, -0.08057459f, 0.25052106f, -0.11985547f, 0.11960575f, 0.17665146f, 
    -0.04044789f, 0.08935725f, 0.11756342f, -0.08253288f, -0.07868782f, -0.13933340f, 0.10004462f, -0.03422625f, 
    0.06820799f, -0.02654081f, -0.18540996f, -0.08784974f, -0.10080630f, -0.08995338f, 0.02925046f, -0.03874663f, 
    -0.04186361f, 0.15778650f, 0.11658831f, 0.32838252f, 0.01809473f, 0.13310197f, 0.21298011f, -0.11024708f, 
    0.03743178f, -0.11741287f, -0.03401008f, 0.07739248f, -0.18656929f, 0.02949083f, -0.05491511f, -0.12947004f, 
    0.03709173f, -0.33649588f, 0.03501977f, -0.07616306f, 0.15779819f, 0.06660985f, 0.08466742f, -0.14621226f, 
    -0.02451067f, 0.03693244f, 0.09029905f, 0.00665628f, 0.14327703f, -0.05998349f, 0.35435334f, -0.08698267f, 
    -0.04215720f, -0.01854884f, -0.05428164f, -0.15403141f, -0.11345004f, -0.02308661f, 0.00445700f, 0.09416293f, 
    0.19392876f, -0.05157643f, -0.11547124f, 0.10693105f, -0.00514093f, -0.10131431f, 0.12455528f, 0.02554736f, 
    0.10064488f, 0.11871602f, -0.01197133f, -0.05255537f, 0.19573812f, -0.11824552f, 0.33137175f, -0.08635572f, 
    -0.07103507f, 0.04875603f, -0.05771065f, 0.11330341f, -0.10431905f, 0.00199512f, -0.10194574f, -0.03200228f, 
    -0.11436894f, -0.05892171f, -0.15712693f, 0.02151241f, 0.04039211f, -0.02313392f, -0.04450410f, 0.06745762f, 
    -0.16759352f, 0.02942904f, 0.04727300f, 0.25115517f, -0.03463624f, -0.50488919f, 0.58555186f, -0.09752902f, 
    -0.03434728f, -0.07223467f, 0.00391077f, 0.06094676f, 0.05066519f, -0.05253161f, 0.07235429f, 0.13214776f, 
    -0.01007865f, 0.01187497f, -0.00897275f, -0.01742481f, -0.04966551f, 0.01844031f, -0.00830812f, -0.04890025f, 
    0.01190851f, -0.04805360f, 0.00198210f, -0.04217992f, -0.00953254f, 0.00873382f, 0.02176837f, 0.00671599f, 
    -0.05290943f, 0.03595404f, 0.04007063f, 0.05234128f, -0.05268740f, -0.02324153f, -0.02715862f, 0.01025399f, 
    -0.04862687f, -0.00272770f, 0.03504552f, 0.04175291f, 0.00947077f, -0.04294764f, 0.02993679f, -0.00995928f, 
    0.03844582f, -0.02217910f, -0.02987037f, 0.00143088f, -0.00304657f, 0.04220701f, 0.00693878f, -0.04462584f, 
    -0.03661124f, -0.01957066f, -0.02472697f, 0.00951177f, -0.03887938f, 0.01528771f, 0.03194661f, -0.02567475f, 
    -0.00855103f, 0.02632396f, -0.01950887f, 0.04506790f, -0.01003299f, 0.03454233f, 0.03390389f, 0.03883312f, 
    0.02144126f, 0.03128815f, -0.00788516f, 0.01412596f, -0.01574275f, -0.01958573f, -0.00853682f, 0.04697712f, 
    -0.00528814f, -0.00988637f, -0.03913961f, -0.04407461f, 0.03556548f, -0.03691457f, 0.03320567f, -0.02283818f, 
    0.00238077f, -0.04856608f, -0.01651841f, -0.04633936f, -0.05142647f, -0.01484102f, -0.00652410f, -0.04903380f, 
    -0.03729691f, 0.03148339f, 0.03357986f, 0.00300513f, -0.02436658f, -0.04023657f, -0.04248415f, -0.05249051f, 
    -0.02147413f, 0.00322218f, 0.01390672f, -0.02891741f, 0.01773602f, -0.03091280f, 0.01186805f, -0.01299962f, 
    0.04393988f, -0.02972064f, 0.01752254f, -0.04306338f, -0.01673870f, -0.00160696f, -0.05088518f, -0.03407191f, 
    -0.00159421f, 0.04019586f, 0.00746926f, -0.00236120f, 0.00418592f, -0.01702739f, -0.00470004f, -0.02632712f, 
    -0.01134476f, 0.01453046f, 0.00508983f, -0.04046291f, 0.00667938f, -0.05239068f, -0.00442548f, -0.05177580f, 
    0.03737362f, 0.02928224f, 0.00077007f, -0.00878169f, 0.01600233f, 0.01682165f, 0.03379320f, -0.05681864f, 
    0.02346367f, 0.02016185f, -0.04638107f, 0.02422667f, -0.05147645f, -0.03630373f, -0.00039175f, -0.01971481f, 
    -0.03994263f, 0.03177651f, -0.03498412f, 0.00120488f, -0.04809609f, -0.00005695f, -0.04946663f, -0.04017367f, 
    -0.04089841f, -0.01586715f, 0.04125827f, 0.01961912f, -0.00244009f, -0.04657452f, -0.03356465f, 0.01365463f, 
    0.00526598f, -0.01920945f, 0.03001887f, 0.04304376f, -0.04136311f, 0.04696155f, -0.00265466f, -0.02051217f, 
    0.02513637f, -0.01355307f, -0.00531085f, -0.01793713f, -0.00330316f, -0.05620280f, -0.03747603f, -0.05435567f, 
    0.02902861f, -0.04241536f, -0.04710537f, -0.01707364f, -0.02064852f, 0.01509625f, -0.04297150f, 0.03777168f, 
    0.00138076f, 0.00045906f, 0.03483220f, -0.02050252f, -0.03779215f, 0.02318342f, 0.03593959f, -0.00363669f, 
    -0.01550101f, -0.02618534f, -0.03461957f, -0.05214100f, -0.03988126f, -0.00125025f, 0.04151835f, 0.01709210f, 
    -0.03288829f, -0.02773779f, -0.04943489f, -0.01457227f, 0.03737745f, 0.00371351f, 0.00925675f, -0.03834086f, 
    -0.04700810f, -0.01834627f, -0.04011191f, -0.04553692f, 0.04347489f, -0.04003028f, -0.05592941f, 0.00758087f, 
    0.01535050f, 0.00167194f, -0.03024418f, 0.02320063f, -0.04740745f, -0.03634467f, 0.03920065f, -0.01228011f, 
    -0.02727531f, 0.02857815f, 0.01507124f, 0.02088270f, -0.00662217f, 0.03425806f, 0.02716731f, -0.00023583f, 
    0.03965959f, -0.01550878f, -0.03008775f, -0.00431155f, 0.02364069f, -0.02198339f, 0.01390125f, -0.03586470f, 
    -0.02663513f, -0.02443614f, 0.00056706f, 0.02662035f, -0.00396556f, -0.05252513f, -0.03866507f, 0.01241482f, 
    0.00069162f, 0.00282630f, -0.02197639f, -0.03933197f, -0.04897852f, 0.02725202f, -0.01393156f, 0.00838377f, 
    0.03823664f, -0.02385793f, -0.03526056f, 0.00271472f, 0.02313874f, -0.04864690f, 0.03377254f, -0.01804097f, 
    -0.01097598f, 0.00454329f, 0.03199700f, -0.00902412f, -0.00173550f, 0.03032829f, -0.01985641f, -0.03627763f, 
    -0.01863053f, 0.04915081f, 0.00874840f, 0.03561091f, 0.00154156f, -0.04038418f, 0.02767229f, -0.02486851f, 
    -0.03366560f, 0.03287921f, 0.01473910f, -0.01896677f, -0.00772302f, -0.05222340f, 0.02077613f, -0.00604886f, 
    -0.04334795f, -0.05104478f, -0.05250324f, 0.02463888f, -0.05496421f, -0.01611419f, -0.01647412f, -0.01840088f, 
    -0.00694988f, -0.01633534f, -0.00179069f, -0.02696812f, 0.03702387f, 0.04344921f, -0.02874380f, -0.04526030f, 
    -0.05256449f, -0.04755776f, -0.01308184f, -0.05274837f, -0.02040317f, -0.05844589f, -0.04476613f, 0.03376463f, 
    0.03219035f, -0.01082958f, -0.03426696f, 0.01069872f, -0.00429027f, -0.02518097f, 0.02004912f, 0.01860708f, 
    0.02684142f, -0.04226640f, 0.03900357f, 0.03574170f, 0.02462279f, 0.03629901f, -0.00401228f, -0.03908532f, 
    -0.01992631f, -0.05075955f, 0.03854715f, 0.00730107f, 0.00905265f, -0.01712442f, -0.00711876f, -0.01220609f, 
    0.01422144f, 0.02585829f, -0.00651918f, -0.03333325f, 0.01428791f, -0.02821156f, -0.02499589f, -0.01535794f, 
    -0.03155211f, 0.01148173f, 0.03369217f, 0.01933600f, -0.04645858f, -0.04177404f, -0.00389646f, 0.02377414f, 
    -0.01318873f, -0.04859677f, -0.02199686f, 0.00100666f, 0.00889634f, 0.02486630f, -0.04100227f, 0.03776912f, 
    -0.02717698f, -0.00834257f, 0.00691616f, 0.01790963f, -0.01529793f, -0.05797009f, -0.01586304f, -0.02503311f, 
    -0.01076316f, -0.00827648f, 0.02614458f, -0.05178916f, 0.02684237f, -0.02536660f, -0.05044036f, 0.01762857f, 
    0.00820642f, 0.00073338f, 0.04115469f, 0.01313980f, -0.03601038f, -0.03764426f, -0.02147599f, 0.02586452f, 
    -0.04264634f, -0.02603670f, -0.04310129f, -0.00277847f, 0.00948252f, 0.00938341f, -0.00969090f, -0.04539999f, 
    0.00415351f, -0.01562790f, -0.03787548f, -0.03545085f, 0.02198146f, 0.00112103f, -0.03393422f, -0.03532978f, 
    -0.02276720f, -0.01925261f, -0.01192129f, -0.04885126f, -0.03314552f, -0.05631487f, -0.00417800f, 0.02783625f, 
    -0.05286527f, -0.00307905f, -0.00516648f, -0.04971960f, 0.00639975f, 0.00979473f, 0.02865744f, 0.03956879f, 
    -0.03210087f, -0.04035162f, -0.04317698f, 0.03885206f, -0.00268262f, -0.02328323f, 0.04292928f, 0.02923891f, 
    0.02829839f, -0.04949179f, 0.02612196f, -0.04952152f, -0.04121146f, -0.02881937f, -0.03615588f, -0.02363454f, 
    0.00672087f, -0.04200152f, 0.03938231f, -0.00638388f, 0.02841702f, -0.00427052f, -0.00865611f, -0.03208331f, 
    -0.03671892f, 0.03374336f, 0.00350900f, 0.00312445f, -0.00310716f, 0.02970578f, -0.03467726f, 0.00968014f, 
    0.04551486f, -0.00153791f, 0.00421131f, 0.03093224f, 0.01085853f, -0.04961330f, 0.02935541f, 0.00250039f, 
    0.02433570f, 0.04623829f, 0.03278998f, 0.01538355f, 0.02133142f, -0.01318493f, -0.05038227f, -0.01569605f, 
    0.00300650f, 0.01685590f, -0.02863192f, -0.02938568f, 0.01023577f, -0.04319616f, -0.02493576f, 0.01766592f, 
    -0.00185490f, 0.03638023f, 0.04733784f, 0.03256773f, -0.00015824f, -0.01522404f, -0.00448281f, -0.02450192f, 
    0.03871219f, 0.01085490f, -0.02994793f, 0.04029253f, 0.00062181f, -0.02697421f, 0.00538516f, 0.00819206f, 
    0.00460900f, 0.05008063f, -0.00409377f, 0.02800718f, 0.01308031f, -0.05061992f, 0.03430537f, 0.03070863f, 
    0.03884203f, 0.00922665f, 0.00475787f, 0.01826470f, -0.01476689f, -0.00190450f, -0.00377512f, 0.01284621f, 
    0.04250751f, -0.01946887f, -0.03991404f, 0.00156623f, 0.03784595f, 0.01625460f, 0.00800678f, -0.02736900f, 
    -0.00270029f, -0.00507344f, 0.01555404f, 0.03043108f, -0.00256863f, -0.03804349f, -0.05075276f, -0.02864034f, 
    -0.05045845f, -0.04964544f, 0.00604251f, 0.02178549f, -0.02213197f, 0.01314665f, 0.04067766f, -0.01484731f, 
    0.01614843f, -0.00619745f, -0.05285161f, -0.00494510f, -0.01785718f, 0.01291968f, 0.03459439f, 0.01487123f, 
    -0.02026748f, -0.00110824f, -0.00103130f, 0.03095134f, -0.03559470f, -0.04685228f, 0.01898118f, -0.01891414f, 
    -0.02059361f, -0.05806303f, -0.01059084f, -0.00443903f, -0.01737396f, -0.04226040f, -0.04575520f, 0.02679478f, 
    0.04370981f, -0.04532785f, -0.04092465f, -0.00037727f, -0.03488059f, -0.02733095f, 0.03996360f, -0.05230836f, 
    0.02264632f, -0.04418323f, -0.02903390f, 0.02275182f, -0.00635531f, -0.02253572f, 0.02993076f, 0.00833413f, 
    0.03929630f, -0.05299098f, -0.00707594f, -0.04037874f, -0.05129571f, 0.03070197f, 0.00061393f, 0.00583885f, 
    0.03231556f, -0.00190819f, -0.02651109f, -0.03195973f, -0.04858667f, -0.02512569f, 0.03294017f, -0.00409726f, 
    0.03665772f, 0.03357645f, -0.05495345f, -0.00527910f, 0.03684083f, -0.05317606f, 0.04667507f, -0.05329126f, 
    -0.02902859f, -0.00714037f, -0.03571324f, 0.01643029f, -0.02046441f, 0.04443325f, -0.03205859f, -0.05452878f, 
    -0.03654299f, 0.00472418f, 0.01719854f, 0.00854350f, 0.04021542f, -0.01418266f, 0.02807720f, 0.00981811f, 
    0.01972204f, -0.01575472f, 0.01645012f, 0.02026741f, -0.00152424f, -0.06134444f, 0.02629903f, -0.02485864f, 
    -0.02673924f, 0.01877583f, -0.04448641f, 0.02664899f, 0.03975412f, -0.01080320f, -0.04656187f, 0.03643383f, 
    0.02006248f, 0.02025568f, -0.02980828f, 0.03243068f, -0.01005919f, 0.02943171f, -0.00641047f, -0.02334390f, 
    -0.00339683f, -0.00814942f, 0.03323954f, -0.00762344f, 0.02409401f, -0.03703035f, -0.01645214f, -0.00876919f, 
    0.04429639f, -0.05203800f, 0.01129418f, -0.00406976f, -0.03539934f, 0.00172348f, 0.04156711f, -0.00074413f, 
    -0.03678218f, 0.03806581f, -0.03786811f, 0.02746323f, -0.02170326f, 0.03284775f, -0.05055180f, -0.03783525f, 
    -0.00355200f, -0.02912801f, 0.01484336f, 0.01938258f, -0.04948106f, 0.02155523f, -0.01777515f, 0.03768344f, 
    0.01553814f, -0.04854089f, 0.02030892f, 0.01413927f, 0.02929497f, 0.01591491f, -0.02785591f, 0.00949680f, 
    -0.03691077f, -0.00374649f, -0.04556594f, -0.04742385f, -0.04131539f, -0.02737297f, -0.04933637f, 0.00104267f, 
    0.03482411f, -0.03962258f, 0.00024499f, -0.04335096f, -0.03934751f, -0.04541912f, 0.01586935f, 0.01549566f, 
    -0.00046198f, -0.04805899f, -0.05542520f, 0.02920562f, 0.00724901f, 0.03815341f, 0.02721681f, -0.04066743f, 
    0.00882731f, 0.02185429f, 0.01212668f, 0.03952663f, -0.03722901f, -0.00713106f, -0.04675838f, -0.02125051f, 
    -0.05474064f, 0.04002042f, -0.04687345f, 0.02597090f, 0.01540451f, 0.03668227f, -0.01454715f, -0.04173741f, 
    0.01196861f, -0.02141388f, -0.03981391f, 0.00312981f, -0.00685299f, -0.02557408f, 0.00867111f, 0.02367740f, 
    -0.04519125f, 0.01718487f, -0.01188195f, -0.02292390f, -0.05144710f, -0.05363975f, 0.01400259f, 0.02551880f, 
    0.01364797f, -0.03483319f, -0.05294112f, -0.00291131f, -0.01196339f, -0.01035284f, 0.01421734f, -0.03429389f, 
    -0.03341986f, 0.00518288f, -0.02818195f, -0.01474222f, 0.02823163f, -0.01983115f, 0.01548787f, 0.03519133f, 
    -0.00171385f, -0.05261219f, -0.00599093f, 0.03650269f, 0.04218801f, -0.03451176f, -0.02499310f, 0.00193500f, 
    0.00099472f, 0.01202495f, -0.03908513f, 0.01884125f, -0.01814862f, 0.02320031f, -0.04396012f, 0.00682566f, 
    0.00919545f, 0.01252455f, -0.03348124f, 0.01234291f, -0.00030965f, -0.02164050f, -0.05110563f, 0.01701915f, 
    -0.02675821f, -0.00173076f, -0.04845755f, 0.03342461f, -0.00057721f, -0.02711512f, 0.05278713f, 0.00818895f, 
    0.20061566f, -0.05118807f, 0.00640673f, 0.10813969f, 0.12463315f, 0.04434566f, -0.08116160f, 0.20425253f, 
    -0.12606274f, -0.12212972f, 0.03446964f, -0.17756511f, -0.04174858f, -0.11237145f, 0.30575874f, 0.14410408f, 
    -0.18059631f, -0.01223157f, -0.01270808f, 0.08922257f, -0.02788484f, -0.16800606f, 0.08325934f, 0.13417038f, 
    -0.12721530f, -0.13570994f, 0.15106097f, 0.20240404f, -0.02363219f, -0.18861160f, 0.04998061f, -0.00330427f, 
    0.00317853f, 0.08198248f, 0.01652669f, -0.01771429f, -0.14875692f, 0.32790548f, -0.10740174f, 0.29932454f, 
    -0.01897371f, -0.13851921f, 0.10991748f, -0.11219557f, 0.04773533f, -0.12757298f, -0.17047156f, 0.20251484f, 
    -0.38981289f, 0.11559693f, -0.02357269f, 0.09426778f, 0.10152453f, 0.00287402f, 0.04630825f, 0.00685878f, 
    -0.06114989f, 0.00669729f, 0.03441020f, 0.01483607f, -0.16151997f, -0.12515911f, -0.24661091f, -0.24830641f, 
    0.16006538f, -0.00565263f, 0.05938852f, 0.01638799f, 0.10607673f, 0.04071780f, 0.06893902f, 0.13276792f, 
    0.18212147f, 0.03458103f, -0.01755000f, -0.06868098f, 0.03591701f, 0.16925484f, 0.01719254f, 0.17129695f, 
    -0.02313584f, -0.04727841f, -0.04864294f, 0.04948323f, 0.03639521f, 0.12790540f, 0.14377154f, -0.05994893f, 
    0.07031643f, 0.16470277f, 0.01199847f, -0.15496899f, 0.11587211f, -0.03073909f, 0.00478216f, 0.12304087f, 
    -0.04241343f, -0.03358046f, -0.46202588f, 0.19874237f, -0.15193246f, -0.12211976f, -0.05379176f, -0.20127836f, 
    -0.11639183f, 0.00056212f, 0.20519893f, 0.32276440f, -0.10698131f, -0.05296471f, -0.16136797f, 0.22039913f, 
    -0.10536983f, 0.05892383f, 0.02236634f, -0.06598046f, -0.05643192f, 0.14869413f, -0.08044048f, -0.02522537f, 
    -0.02576774f, 0.36462647f, 0.19471191f, 0.16835825f, 0.05952062f, -0.11132005f, 0.05356000f, 0.03140591f, 
    -0.09505899f, -0.05535925f, -0.01823940f, 0.00376119f, -0.08237571f, 0.30346164f, 0.21327044f, 0.19807467f, 
    0.01292695f, 0.03973800f, 0.21124658f, 0.10986121f, 0.07680423f, -0.03444452f, -0.01077808f, 0.02304062f, 
    -0.27538958f, -0.07626791f, -0.08357073f, -0.02414427f, -0.07837242f, 0.06855341f, -0.10623374f, 0.08253371f, 
    0.07925317f, 0.11877491f, 0.12792167f, -0.08009901f, 0.21127981f, 0.04017529f, -0.01302204f, -0.04390393f, 
    0.13473326f, 0.05441914f, 0.09856477f, -0.02552923f, -0.28089431f, 0.00078008f, -0.02238327f, -0.28841922f, 
    -0.16366352f, -0.00222107f, -0.06095843f, 0.09593003f, -0.06591470f, 0.07957491f, 0.02172251f, 0.03614288f, 
    0.09573861f, 0.07868402f, 0.08068574f, 0.25229192f, -0.06672645f, -0.12644945f, 0.14802872f, 0.17169443f, 
    -0.08121279f, -0.12953457f, 0.06830960f, 0.07376076f, 0.02509259f, 0.10611466f, -0.07170685f, -0.29216340f, 
    -0.26175529f, 0.06615743f, -0.25890654f, 0.29753739f, 0.22856416f, 0.07208788f, 0.03886417f, -0.10758443f, 
    -0.04047550f, 0.08495221f, -0.01321287f, -0.01865849f, 0.01540309f, 0.23616196f, -0.00080509f, -0.00665036f, 
    0.17292680f, 0.00722192f, 0.17480330f, -0.03722030f, -0.33941925f, -0.09347106f, -0.31911397f, -0.30218828f, 
    -0.01842874f, -0.00056602f, 0.31515828f, -0.10643989f, -0.10425284f, -0.02633337f, -0.01076474f, 0.01181540f, 
    0.08713750f, -0.35633954f, -0.23708673f, -0.41237500f, 0.37684187f, 0.01659545f, 0.05600259f, -0.31322342f, 
    -0.13054310f, -0.03267632f, -0.13141145f, 0.01800135f, 0.12904014f, 0.25241092f, 0.14107049f, 0.08015992f, 
    0.20929907f, 0.37429523f, 0.15120921f, 0.34251335f, -0.08503817f, -0.22200657f, -0.07012742f, 0.01530978f, 
    -0.05411041f, 0.07713959f, 0.13174056f, 0.00196207f, 0.16451010f, 0.03007744f, -0.12925975f, -0.30384174f, 
    0.15654556f, -0.06268582f, -0.06426769f, 0.06973976f, -0.26797915f, -0.00860968f, -0.32849392f, -0.17689371f, 
    0.08530251f, 0.09088060f, -0.15000395f, 0.17065804f, 0.11061084f, 0.23131330f, -0.05598952f, 0.15810558f, 
    0.05185200f, 0.15709683f, 0.01154372f, -0.13359715f, 0.02029836f, 0.21711811f, 0.22202115f, 0.21832027f, 
    0.01907533f, 0.06652372f, 0.05994235f, 0.07122000f, -0.09361309f, -0.07546908f, -0.01297638f, 0.07257641f, 
    -0.10864633f, -0.13736540f, 0.07770378f, 0.05030303f, -0.09573445f, -0.12356725f, -0.11716540f, 0.04591791f, 
    0.17581110f, 0.16959900f, 0.11374786f, 0.18361251f, 0.10425021f, -0.03279620f, 0.26403511f, -0.08957898f, 
    -0.05447749f, -0.04157921f, -0.11522301f, 0.12567161f, -0.19990960f, -0.20617086f, -0.07418095f, -0.35034519f, 
    -0.06168520f, -0.02372582f, 0.19391982f, 0.06611516f, 0.03267281f, 0.14237615f, -0.06064007f, -0.00766230f, 
    0.01813013f, 0.09718063f, 0.05209056f, 0.02672484f, -0.20758691f, 0.04637994f, 0.24709095f, 0.25667930f, 
    -0.05434079f, -0.22814469f, 0.04752465f, -0.06512787f, 0.11809593f, 0.11266194f, 0.18878040f, 0.25970685f, 
    -0.12537757f, -0.00752940f, 0.19062677f, 0.24669796f, 0.02889002f, -0.13976358f, 0.01273220f, 0.04003206f, 
    -0.14754328f, 0.09259622f, 0.09584689f, -0.10523749f, 0.43886977f, -0.11702609f, 0.24013497f, 0.07531913f, 
    -0.09965774f, 0.17006841f, -0.13376418f, 0.02407853f, -0.07469420f, 0.06227641f, -0.15781477f, -0.28011033f, 
    -0.12437067f, -0.05157642f, -0.30461153f, -0.09200021f, 0.05204120f, 0.00751880f, -0.06952287f, -0.02751637f, 
    0.11252452f, 0.13926077f, 0.08493908f, 0.22448868f, 0.18520845f, -0.16715653f, 0.36790583f, 0.04494504f, 
    0.08919176f, 0.04452055f, -0.08677160f, -0.13751931f, -0.05827446f, 0.04077875f, 0.12993181f, -0.03964066f, 
    -0.13256295f, -0.04577843f, 0.04572026f, 0.19173673f, -0.24053980f, 0.01864784f, -0.01549497f, -0.01930706f, 
    0.12887950f, 0.01546370f, 0.07739422f, 0.12257468f, -0.14754166f, -0.06358916f, 0.22946133f, 0.19090316f, 
    0.00230302f, 0.08472848f, -0.13373004f, -0.04477010f, 0.14250407f, -0.02378711f, 0.04978421f, 0.19162342f, 
    -0.02562608f, -0.00827018f, -0.01711980f, 0.31307718f, 0.21135037f, 0.04553497f, 0.18834464f, -0.04757767f, 
    0.06622965f, -0.04913124f, 0.00239901f, 0.13366571f, -0.27451506f, 0.22696918f, -0.16507246f, 0.16469371f, 
    0.01418193f, 0.08700193f, 0.18122257f, 0.13923661f, 0.00713792f, 0.01359917f, -0.07100623f, -0.13802403f, 
    -0.01699195f, -0.24545723f, -0.12409450f, 0.00336998f, 0.07661153f, 0.15232819f, -0.04463344f, 0.05943121f, 
    -0.00725149f, -0.01919227f, -0.12962191f, -0.06961875f, -0.23669386f, -0.20399004f, -0.21071155f, -0.11567608f, 
    0.01589005f, -0.24520269f, -0.11367455f, -0.03884598f, 0.18159814f, -0.08714344f, -0.04400055f, 0.03071389f, 
    -0.03002374f, -0.07086723f, -0.21122593f, -0.11929815f, -0.01512920f, -0.02985603f, -0.06539813f, 0.00280167f, 
    -0.09308115f, 0.02906169f, 0.04032634f, -0.02775204f, 0.05106405f, 0.10685631f, -0.13161853f, -0.06486937f, 
    0.06972282f, -0.04558627f, -0.00835843f, -0.09647396f, 0.00115393f, 0.12710069f, 0.34815544f, 0.18967865f, 
    -0.53462934f, -0.24919239f, -0.31532267f, 0.53162199f, -0.00037751f, -0.06097060f, 0.09814791f, 0.01722631f, 
    0.06162418f, 0.06583913f, -0.03114301f, 0.09619378f, -0.21411292f, -0.10967945f, 0.08223107f, 0.22831331f, 
    -0.04215299f, 0.03509453f, 0.09535599f, 0.18064371f, 0.13305067f, 0.20999463f, -0.05274889f, 0.12712495f, 
    -0.31408116f, 0.20079847f, 0.34464329f, -0.02094775f, -0.12378968f, -0.02978809f, 0.06198091f, 0.19952016f, 
    -0.02329556f, 0.03732818f, 0.01094216f, -0.12116300f, -0.18358171f, 0.16511860f, 0.14601912f, 0.05137013f, 
    0.06651197f, 0.03563790f, 0.10990518f, 0.22156310f, 0.05292967f, 0.03277941f, -0.04090662f, -0.02853208f, 
    -0.24901141f, 0.06091489f, 0.10504436f, 0.22133233f, -0.04697050f, -0.05933486f, 0.01983388f, -0.00758674f, 
    0.10925592f, 0.09682445f, 0.12618026f, 0.02857854f, 0.12373961f, -0.14031872f, -0.00583504f, -0.25596416f, 
    -0.14818059f, -0.02206669f, 0.13778140f, -0.20621961f, 0.13916455f, -0.05962232f, 0.14983279f, -0.15190314f, 
    -0.31541726f, 0.04658789f, -0.04359370f, -0.02924607f, -0.03939259f, -0.10026472f, 0.04630418f, 0.08409219f, 
    -0.08636451f, -0.14460163f, -0.22194964f, -0.22500065f, -0.19175890f, 0.13104354f, 0.20253165f, 0.09427232f, 
    0.05012507f, -0.02201608f, -0.01154432f, -0.06773491f, -0.06646190f, -0.11070336f, -0.05941490f, 0.06692387f, 
    -0.06290243f, -0.10494598f, 0.03542996f, 0.13204876f, 0.08959392f, -0.03588240f, 0.05508855f, 0.03889121f, 
    0.07921566f, 0.09633984f, 0.06223293f, 0.03498759f, -0.23299523f, 0.06263344f, -0.18823875f, -0.15832710f, 
    -0.04445540f, -0.05172775f, 0.07824993f, -0.01322728f, 0.05208461f, 0.05406934f, -0.02393426f, -0.15052325f, 
    0.12341777f, -0.10034415f, 0.06352431f, -0.03678497f, 0.02873267f, -0.08333667f, 0.01561883f, 0.16348292f, 
    0.03851144f, 0.10684323f, 0.10805521f, 0.04066407f, 0.13891844f, 0.33473295f, -0.26909363f, -0.37332690f, 
    -0.00252552f, -0.04368515f, -0.00349654f, -0.06421853f, 0.05662845f, -0.11665016f, 0.04283017f, 0.12611127f, 
    -0.01552993f, 0.20441392f, 0.21961874f, 0.16825999f, -0.13064495f, -0.05058800f, -0.03073405f, 0.14563178f, 
    0.02005794f, -0.05496584f, 0.07171663f, 0.14649568f, 0.08562089f, -0.28577423f, -0.08819739f, 0.09545763f, 
    -0.08779661f, -0.04146209f, -0.06523342f, 0.03745162f, 0.07985076f, 0.07814085f, 0.06779915f, 0.05694360f, 
    -0.12057992f, 0.04104314f, -0.15114722f, -0.21126272f, -0.05312759f, 0.06816182f, -0.16342041f, 0.02218154f, 
    -0.14916451f, -0.06091820f, 0.01357465f, -0.02269712f, -0.03336758f, 0.16100661f, 0.44410223f, 0.17368676f, 
    0.13792624f, 0.14781649f, -0.05831542f, 0.07049248f, 0.16679434f, 0.10602937f, 0.10687888f, 0.02890198f, 
    -0.20961370f, -0.11422658f, 0.03782408f, -0.01010741f, -0.04975551f, -0.05639223f, -0.18622945f, -0.12614861f, 
    -0.02203864f, 0.08285975f, -0.18545879f, -0.27276951f, 0.23496300f, -0.13152692f, 0.10092881f, -0.15690987f, 
    -0.21326049f, 0.00275825f, -0.02575142f, 0.09701507f, 0.09325546f, -0.04718198f, 0.12302073f, -0.04290235f, 
    -0.35254619f, -0.20144546f, 0.10603381f, 0.15107824f, -0.10993284f, 0.03722690f, 0.00558411f, 0.02973891f, 
    0.12391169f, 0.28350842f, -0.08581365f, -0.13022783f, -0.10510300f, 0.23439918f, 0.08028362f, 0.04423075f, 
    -0.02184252f, -0.18181258f, 0.18845408f, 0.17146291f, 0.17372574f, -0.01325724f, 0.02283173f, -0.11803798f, 
    -0.16323683f, 0.00930621f, 0.47883669f, 0.18132456f, -0.03321556f, 0.01589115f, -0.06799339f, 0.21177945f, 
    0.11478312f, 0.02753513f, 0.17184207f, 0.03414954f, 0.11308956f, -0.10103591f, -0.19087096f, 0.10967568f, 
    -0.06331811f, -0.00214240f, -0.00578849f, 0.01236131f, -0.08148975f, 0.08926451f, 0.00758769f, 0.14446466f, 
    -0.16478753f, -0.12670052f, -0.27447444f, -0.22293437f, 0.02805305f, -0.06117111f, -0.12160969f, -0.10273608f, 
    0.18194292f, 0.02624335f, -0.00302863f, -0.09672121f, 0.48790422f, 0.15848278f, -0.24174719f, 0.14787450f, 
    -0.00531950f, 0.05175414f, 0.02315433f, 0.04031043f, -0.07551745f, 0.05044492f, 0.02840934f, -0.12188255f, 
    0.30422619f, 0.16765970f, 0.01839101f, 0.09967853f, 0.16480413f, 0.18874061f, 0.01381614f, 0.18001284f, 
    -0.06024246f, 0.07755785f, -0.02808618f, -0.06410567f, 0.02355175f, 0.07444225f, -0.01249067f, 0.02670092f, 
    -0.10310612f, -0.07721051f, 0.21981455f, -0.04200019f, -0.17170274f, -0.02266547f, 0.09934403f, 0.00595214f, 
    -0.02927322f, 0.17300045f, 0.02291488f, -0.16568619f, -0.13750768f, -0.00665806f, -0.09974863f, 0.12908688f, 
    -0.18171571f, 0.02708074f, 0.02155469f, -0.16914347f, 0.17256765f, 0.04027408f, 0.22640346f, -0.00420940f, 
    0.06782140f, 0.04092003f, 0.01106949f, 0.06682178f, -0.09191158f, -0.14932673f, -0.11815518f, 0.01916554f, 
    -0.29247785f, 0.28311411f, -0.12433081f, 0.00241425f, -0.00772915f, -0.19015771f, 0.06377019f, -0.03121017f, 
    0.02783279f, 0.13686219f, 0.14847097f, 0.07360986f, -0.09442286f, -0.43760192f, -0.13441627f, -0.33104938f, 
    -0.00640491f, 0.06625294f, 0.14828797f, 0.03765377f, -0.07705495f, 0.07852661f, 0.01160803f, 0.05211472f, 
    -0.28315344f, -0.30537611f, -0.21008933f, -0.02897697f, -0.00039433f, 0.00923423f, 0.01788528f, 0.15363345f, 
    0.06901111f, 0.03449301f, 0.03577917f, 0.08591329f, 0.12833609f, -0.24508151f, 0.14783360f, -0.14741686f, 
    -0.07779746f, 0.05813023f, -0.06553516f, 0.21665901f, -0.00616526f, -0.08166276f, -0.19599269f, -0.20784613f, 
    0.36273360f, 0.29947615f, -0.11336910f, -0.48330307f, 0.11641067f, 0.19430065f, -0.07842326f, 0.00431676f, 
    -0.15304534f, -0.02830712f, -0.03128401f, -0.11791358f, 0.13679415f, 0.14262287f, -0.11074770f, -0.11704791f, 
    0.02322556f, -0.01103720f, -0.01224026f, -0.24166362f, -0.21766913f, -0.07759552f, -0.08872189f, -0.13006747f, 
    0.61170864f, 0.27329463f, 0.08955882f, 0.16357397f, 0.16356668f, 0.08280732f, 0.06552590f, -0.11493826f, 
    -0.11280558f, -0.13660872f, -0.03820726f, 0.14587666f, 0.24148005f, 0.21408616f, 0.18553725f, 0.25154525f, 
    0.09501980f, 0.08902200f, -0.01779403f, 0.01825847f, -0.04839231f, -0.09659554f, 0.09118867f, 0.01069670f, 
    0.10188124f, 0.01509419f, 0.02705996f, -0.01097317f, 0.02862831f, 0.09191260f, -0.09189085f, -0.06120628f, 
    0.02436332f, -0.08249729f, -0.05317407f, -0.08529372f, -0.33564895f, -0.09899665f, -0.17942891f, -0.03502227f, 
    0.18569447f, -0.00717137f, -0.02916873f, -0.01560655f, -0.18600081f, 0.22388472f, 0.08010399f, 0.05591628f, 
    0.19360286f, 0.13921629f, 0.14048274f, 0.30219504f, 0.14589393f, 0.24786027f, -0.02809640f, -0.08385614f, 
    0.04026293f, 0.06212866f, -0.00551458f, 0.30708712f, 0.22651003f, -0.03253265f, 0.04614104f, 0.09833013f, 
    -0.10455077f, 0.05980658f, 0.14113376f, 0.17121446f, 0.05246497f, 0.06251635f, 0.03730800f, -0.11986656f, 
    -0.10595743f, 0.07875875f, -0.10787088f, -0.09488742f, 0.09909207f, 0.09305179f, 0.02519345f, -0.05028861f, 
    -0.07536007f, -0.03136012f, -0.12882298f, 0.01298555f, -0.07786734f, 0.02321138f, 0.26501930f, -0.10935798f, 
    0.11747191f, 0.03592852f, -0.07278027f, 0.05769084f, -0.08726034f, 0.03702912f, 0.02839564f, 0.05230526f, 
    -0.09346268f, 0.08381801f, 0.05787362f, -0.00612502f, -0.06949592f, 0.07814442f, -0.07333050f, -0.05915093f, 
    0.08069286f, -0.11415338f, 0.03512948f, -0.11756737f, 0.16755535f, -0.24553643f, 0.13387860f, 0.27773497f, 
    -0.13992518f, 0.00569558f, 0.01704483f, -0.02369812f, 0.13974006f, 0.12398282f, 0.03467914f, -0.01359132f, 
    0.25914916f, 0.18547170f, -0.11785511f, 0.11400259f, 0.07361760f, 0.11289090f, 0.10785206f, 0.07149187f, 
    -0.05974222f, 0.07048816f, 0.04382290f, -0.13092084f, -0.05566035f, 0.16104345f, -0.13278484f, -0.20202190f, 
    0.14857736f, 0.04758803f, 0.13561592f, 0.04799142f, -0.01685245f, 0.05442003f, -0.22809778f, 0.03305835f, 
    -0.01171438f, -0.11097724f, -0.04333656f, 0.17130882f, 0.03593710f, 0.12521824f, 0.01393755f, -0.00711794f, 
    0.13552125f, 0.12562104f, 0.03904599f, -0.00451778f, 0.27733743f, 0.07161763f, -0.23213069f, 0.05963286f, 
    0.00482708f, 0.06813462f, 0.14009349f, -0.03254886f, -0.04107949f, -0.01415302f, -0.09049649f, -0.10607168f, 
    0.08107866f, 0.11364611f, -0.11189947f, 0.10866946f, 0.03603347f, 0.00545757f, 0.08170749f, 0.13745964f, 
    -0.13897386f, 0.09298001f, 0.15514401f, 0.30980355f, -0.25641352f, 0.13994421f, -0.01651770f, 0.17514600f, 
    -0.00329090f, -0.06469286f, -0.04805094f, -0.00385002f, -0.06672980f, -0.04539488f, -0.09269873f, 0.10377849f, 
    0.37382433f, 0.09141830f, 0.16776703f, -0.15948839f, 0.15962383f, 0.08730348f, -0.01643717f, -0.04923554f, 
    -0.09570429f, -0.09307071f, 0.11563382f, -0.04317230f, 0.09541331f, -0.04048132f, 0.27653217f, 0.14673179f, 
    0.20367417f, 0.13358782f, -0.11032259f, -0.01633612f, 0.01356516f, 0.01639769f, -0.00895056f, 0.21799035f, 
    0.19639546f, -0.09237275f, -0.10668889f, 0.06714126f, 0.11830332f, -0.09614839f, 0.15664113f, -0.09859567f, 
    -0.07494995f, 0.00831525f, -0.12131134f, -0.07571220f, -0.47889501f, -0.26582909f, 0.15762815f, -0.16991550f, 
    -0.18490092f, 0.09913810f, -0.10657939f, -0.03091636f, -0.04533401f, 0.03262419f, 0.11179783f, -0.10721455f, 
    -0.13441125f, -0.15297855f, -0.20263878f, -0.01125823f, 0.06607988f, -0.07921818f, 0.07280773f, 0.07524817f, 
    -0.12038046f, 0.06337617f, 0.10585428f, 0.25244480f, -0.52235287f, -0.45922646f, 0.15758541f, -0.33851922f, 
    -0.14245322f, -0.02713776f, -0.21014759f, -0.16486830f, 0.12595573f, -0.06439494f, 0.05266025f, 0.10414360f, 
    0.40541023f, 0.05889219f, 0.01446890f, -0.03384552f, 0.11647452f, -0.07174473f, -0.14811406f, -0.00913646f, 
    0.00386024f, 0.15532935f, -0.03767934f, 0.02483666f, -0.06993724f, -0.04643392f, -0.16213110f, 0.16294417f, 
    0.03249761f, 0.02331343f, -0.08983708f, 0.12310435f, -0.06010145f, 0.03564905f, 0.01252018f, -0.09414723f, 
    -0.12631691f, -0.14644787f, -0.06405780f, -0.11896824f, -0.00078432f, -0.05729239f, 0.06609406f, -0.07155287f, 
    0.08017955f, 0.04322150f, 0.15198380f, 0.08411315f, 0.13843834f, -0.23020212f, 0.14761347f, 0.11639142f, 
    -0.10405175f, -0.00365545f, -0.09165186f, 0.05088636f, 0.05478901f, 0.05015331f, 0.07040229f, 0.07427914f, 
    -0.19149026f, -0.04118560f, 0.14254496f, 0.03276190f, 0.17532618f, 0.14968260f, -0.08469760f, 0.03035036f, 
    -0.02386060f, 0.12316621f, 0.02175195f, -0.12651387f, 0.19075720f, 0.11827894f, 0.02770798f, -0.08169530f, 
    -0.03280484f, 0.04836798f, 0.01438581f, 0.02489917f, 0.16030869f, 0.04643600f, 0.09221418f, 0.07339695f, 
    0.07333101f, 0.15386468f, 0.08406541f, -0.01728075f, 0.00489820f, -0.03028630f, 0.00792792f, 0.08102583f, 
    0.05592956f, -0.00026111f, -0.10297425f, -0.04038125f, 0.16516623f, 0.35408661f, 0.01951372f, 0.09124977f, 
    -0.03448422f, 0.14840835f, 0.02088446f, -0.06757768f, 0.20482641f, 0.13096389f, 0.03465567f, 0.01504965f, 
    0.20057812f, -0.04860558f, -0.26876870f, 0.00739618f, 0.04451130f, -0.00135389f, -0.03362946f, -0.08279344f, 
    0.10998189f, 0.11227924f, 0.06137292f, -0.02918684f, -0.18759677f, -0.15716772f, -0.18469648f, 0.04795046f, 
    -0.07994848f, -0.02564839f, 0.02107415f, -0.00682092f, 0.01255712f, -0.02582001f, 0.10081153f, -0.06061832f, 
    0.07107470f, -0.39687026f, 0.07335944f, 0.11608606f, -0.02973339f, -0.08640196f, -0.07875072f, 0.05595273f, 
    -0.09345758f, 0.00805031f, 0.16575053f, 0.10345042f, 0.06492993f, -0.32474917f, 0.11803268f, 0.16271907f, 
    -0.02399625f, -0.04305508f, -0.02550639f, 0.15164146f, 0.03014530f, -0.16028088f, 0.16379258f, 0.02290393f, 
    -0.13266209f, -0.13343126f, -0.10138093f, 0.06179129f, 0.02846030f, 0.00787381f, -0.02523650f, -0.10294344f, 
    -0.01647868f, -0.02134164f, -0.01555438f, 0.02405410f, -0.05797765f, 0.11995426f, -0.00383764f, -0.08817151f, 
    -0.04897283f, -0.07452268f, 0.05565519f, 0.00513787f, -0.02592872f, -0.04871144f, -0.16727735f, 0.07173631f, 
    -0.00694977f, -0.05220644f, -0.03217395f, 0.25563151f, -0.03552241f, -0.03752116f, 0.03080796f, 0.08728687f, 
    0.02869277f, -0.09868589f, 0.20935625f, 0.10369774f, -0.28493109f, -0.24211724f, -0.04549259f, 0.07758340f, 
    -0.04337870f, -0.09903497f, 0.04079480f, -0.02034971f, -0.00947821f, 0.04630976f, -0.07228938f, 0.01181940f, 
    0.06451672f, -0.16707808f, 0.13555168f, -0.10702740f, 0.32533753f, 0.25915959f, -0.04723231f, -0.14417540f, 
    -0.12083720f, 0.03919782f, -0.01374774f, -0.00458323f, 0.20969698f, 0.10353647f, -0.22685479f, 0.04655034f, 
    0.08011117f, -0.10128529f, 0.04943195f, -0.05577963f, -0.06189912f, -0.08111665f, -0.11797933f, -0.12335104f, 
    -0.01303542f, -0.05780256f, -0.05201676f, 0.02208180f, 0.14770362f, 0.09857848f, -0.09859524f, -0.02736881f, 
    -0.03282196f, -0.15616407f, 0.00779310f, 0.01504332f, 0.33478275f, -0.10973976f, 0.16576695f, -0.13161354f, 
    -0.05873548f, -0.13067408f, 0.16524601f, -0.09628971f, 0.04496726f, 0.34371462f, 0.14025719f, -0.05318463f, 
    -0.03294885f, 0.15776153f, 0.47867945f, 0.00296109f, 0.02449309f, -0.15221795f, -0.01619372f, 0.05268197f, 
    0.09952790f, 0.16974455f, 0.05110746f, 0.13796392f, 0.13290222f, 0.14118192f, 0.02773230f, -0.00376658f, 
    0.20721750f, -0.06320413f, -0.04327780f, 0.00035767f, -0.15269712f, 0.03417706f, -0.24670264f, 0.12886056f, 
    -0.01270125f, 0.22247820f, -0.01592951f, -0.15245770f, -0.04494558f, -0.02949181f, 0.08236963f, 0.02429534f, 
    0.11078991f, 0.08711233f, 0.02658862f, 0.12826751f, -0.04080982f, 0.24585068f, 0.16303638f, -0.02669377f, 
    0.01893197f, -0.01262881f, -0.10150836f, -0.01837831f, -0.02835828f, 0.11130503f, -0.11827457f, 0.00473413f, 
    -0.27165666f, -0.01223888f, 0.11274783f, -0.01119600f, -0.05478373f, 0.05348101f, -0.05484685f, 0.02137368f, 
    0.15078664f, -0.09569150f, 0.04551520f, 0.10692587f, -0.09137437f, -0.10478265f, 0.12070319f, 0.06470846f, 
    0.05407283f, 0.04347668f, 0.10442171f, 0.02524125f, -0.05813149f, -0.00859667f, -0.02451678f, -0.15929908f, 
    -0.21389495f, 0.38169792f, -0.18130885f, 0.05162562f, 0.01944532f, 0.03533924f, -0.02323912f, -0.03206722f, 
    0.05262370f, -0.22897294f, 0.29969177f, 0.05643607f, -0.21712199f, -0.04470578f, 0.02929328f, 0.14216442f, 
    -0.08225429f, 0.03516988f, -0.05725823f, -0.05237278f, 0.18254286f, 0.14330572f, 0.20428613f, 0.20858522f, 
    -0.11363594f, -0.05799327f, 0.27766886f, 0.01969934f, -0.05728849f, -0.03048861f, -0.08618613f, -0.01945525f, 
    -0.02144753f, -0.02405363f, -0.00710067f, 0.07629398f, 0.29323235f, 0.17438379f, -0.13748939f, -0.11365056f, 
    -0.14863151f, -0.01695090f, 0.02012938f, 0.08894042f, 0.06757927f, -0.08423025f, 0.13381150f, -0.19455817f, 
    0.16108662f, 0.06832326f, 0.16428702f, -0.22632439f, -0.09569681f, 0.10992041f, -0.00375255f, -0.00573972f, 
    0.12833998f, 0.14324756f, 0.25085869f, -0.04760838f, 0.15022513f, 0.32574710f, -0.04802469f, -0.34981483f, 
    -0.10701443f, -0.00791523f, -0.02364685f, 0.07888115f, 0.05576643f, 0.08041310f, 0.03203743f, -0.04619704f, 
    0.44708240f, -0.27101025f, -0.02067636f, -0.17437023f, 0.13154334f, -0.10604693f, -0.04818384f, -0.07789904f, 
    0.14255619f, 0.18703067f, 0.07059963f, 0.11071116f, -0.01463507f, 0.07816286f, -0.03197540f, 0.15342359f, 
    0.12946981f, 0.10237209f, 0.06014552f, 0.31157890f, 0.03014048f, 0.04041067f, -0.12110095f, -0.09326876f, 
    0.22724701f, -0.03064145f, 0.20915648f, 0.19345847f, 0.05780286f, 0.06000891f, -0.06901664f, 0.00339402f, 
    0.05459779f, 0.09776706f, 0.14006826f, 0.18073560f, 0.11804441f, -0.32312632f, 0.15232259f, 0.16677104f, 
    0.02951040f, -0.13731137f, -0.04604662f, 0.02349152f, 0.22114284f, 0.25345293f, 0.06960131f, 0.15236796f, 
    -0.19515520f, 0.27379099f, 0.16228966f, 0.14293166f, -0.03341817f, 0.11211111f, -0.01420388f, -0.07752402f, 
    -0.03110249f, 0.00676536f, 0.01654752f, -0.00701244f, 0.27634940f, 0.22508389f, 0.02272263f, -0.05912352f, 
    -0.13371778f, 0.08306761f, -0.01668562f, 0.00450560f, -0.00086696f, -0.00923812f, 0.00926924f, -0.07705251f, 
    0.14457417f, 0.12486213f, 0.13949694f, -0.02729843f, -0.11350657f, 0.03100148f, -0.10625256f, -0.03133658f, 
    -0.15244940f, -0.09524777f, -0.14680567f, -0.23476477f, 0.02882662f, -0.01962542f, 0.24909043f, 0.18236427f, 
    -0.06807675f, 0.11047931f, 0.08977181f, -0.17661192f, 0.14050291f, 0.08937069f, -0.00487905f, -0.04390326f, 
    0.67898107f, -0.09357660f, 0.29701671f, 0.01281278f, -0.05584105f, 0.15398870f, 0.04841499f, 0.08002476f, 
    0.12028758f, 0.17258525f, 0.10679368f, -0.04382091f, 0.06035623f, -0.03714760f, 0.09307984f, 0.07129977f, 
    0.05545342f, 0.04189296f, -0.01884858f, -0.03547139f, 0.11851687f, -0.02001584f, 0.06574082f, 0.04521430f, 
    -0.25691938f, -0.21280906f, -0.27993348f, -0.05935305f, 0.09569377f, -0.00625494f, -0.06955370f, 0.13932247f, 
    0.05309219f, 0.09540076f, 0.01652727f, 0.12558019f, 0.04558489f, -0.30172318f, -0.26351649f, -0.13557173f, 
    0.06238534f, 0.01997643f, 0.10536148f, 0.14602953f, 0.08333186f, 0.01568019f, 0.05912137f, 0.12935376f, 
    0.13210511f, 0.04172111f, -0.12159845f, -0.04131369f, 0.07748963f, 0.10496887f, 0.02696692f, 0.00910003f, 
    -0.04204151f, 0.06420365f, 0.07992981f, 0.16133639f, 0.14195532f, 0.12429268f, -0.00981052f, 0.04577724f, 
    -0.07851219f, -0.15513742f, -0.00009353f, 0.15512155f, -0.08089502f, -0.07972687f, -0.34156960f, -0.03789810f, 
    0.12274180f, -0.17704399f, -0.15894629f, -0.21782936f, 0.08316348f, 0.03178877f, 0.27937534f, 0.24267513f, 
    0.02665883f, -0.02758592f, 0.22839899f, 0.22281465f, -0.04607774f, -0.25575721f, -0.13638708f, 0.14587608f, 
    0.19080183f, -0.00801603f, 0.03720639f, 0.02442017f, -0.02785159f, 0.02994091f, -0.07759114f, 0.07109196f, 
    -0.15108518f, 0.23218459f, -0.00136977f, -0.16780931f, -0.10079525f, 0.01730468f, 0.04231563f, 0.02017487f, 
    -0.16792159f, -0.04296102f, 0.07206185f, 0.02619251f, 0.17685130f, -0.08602276f, 0.09117743f, 0.13563158f, 
    -0.10490289f, 0.02936081f, 0.19208550f, -0.00763641f, -0.09963087f, -0.00202331f, -0.10455091f, -0.15625896f, 
    -0.13145761f, -0.14015511f, 0.00348790f, 0.00903210f, 0.05023024f, 0.10791402f, 0.07093275f, -0.04933027f, 
    -0.02289388f, -0.03628043f, -0.09946781f, -0.02397995f, 0.04932692f, -0.05778381f, 0.23730366f, 0.00114478f, 
    0.04871907f, 0.09649487f, 0.22840276f, 0.13292857f, 0.03269259f, 0.17990813f, 0.10918027f, 0.01133909f, 
    -0.25341150f, -0.10873947f, 0.07779264f, 0.07822036f, -0.03780974f, -0.08876174f, -0.18823966f, -0.01012412f, 
    0.11485494f, 0.02124228f, -0.04180434f, 0.09371297f, 0.07499500f, 0.26840580f, -0.05375905f, -0.17343280f, 
    0.03089726f, -0.09688043f, -0.07926256f, -0.09640565f, -0.14557287f, 0.02993647f, 0.06766824f, -0.09397534f, 
    0.17632715f, 0.02994108f, 0.15994461f, -0.07594106f, 0.04384064f, -0.05428096f, 0.01352266f, 0.08085278f, 
    0.03182393f, 0.15339315f, 0.04493793f, 0.05030500f, -0.35175583f, -0.00162832f, -0.00232403f, -0.15004803f, 
    -0.04780335f, -0.09315930f, -0.11141602f, 0.20863494f, -0.00814042f, 0.06231738f, -0.12405411f, 0.04244807f, 
    -0.00548396f, 0.16251354f, 0.02251156f, -0.04807119f, 0.02667066f, -0.03480302f, 0.05013692f, 0.03624856f, 
    0.22310023f, -0.00469638f, 0.07789527f, 0.15453582f, -0.07737317f, 0.08954782f, 0.20620456f, 0.14004712f, 
    0.11002316f, 0.08326872f, -0.00874044f, 0.09274026f, -0.04704171f, 0.12815621f, -0.05415211f, -0.02627762f, 
    0.01476336f, 0.42936206f, -0.46810895f, -0.19786112f, 0.11522331f, 0.07217439f, 0.04697700f, -0.03775372f, 
    -0.13978104f, -0.08882568f, 0.03011250f, 0.16754943f, -0.08594861f, -0.14738727f, -0.23259203f, 0.00085945f, 
    -0.18100010f, 0.06438035f, -0.05595060f, 0.04796147f, 0.02103983f, 0.01795103f, 0.09162700f, 0.13715772f, 
    -0.13645524f, 0.24588893f, -0.21049869f, -0.04488240f, 0.03603938f, 0.06992176f, -0.01179275f, 0.06552330f, 
    0.02592759f, 0.13775691f, 0.04376473f, 0.06909629f, 0.34298155f, 0.06612957f, 0.12158031f, -0.04490718f, 
    -0.04112438f, 0.01107652f, 0.02861945f, 0.16571303f, 0.01969110f, -0.01326974f, -0.13265805f, -0.08530933f, 
    0.14542152f, 0.21252264f, 0.10677660f, -0.06333099f, -0.09692085f, 0.15894246f, 0.03680054f, 0.12006313f, 
    0.01172816f, 0.07322504f, 0.09203479f, 0.01885504f, -0.06642257f, 0.02335989f, 0.22903626f, 0.02523702f, 
    -0.04385334f, 0.04499882f, 0.03118052f, 0.05735087f, -0.10284743f, 0.08273956f, -0.05067026f, -0.00586106f, 
    0.28219855f, -0.31863505f, -0.09130508f, 0.02961900f, 0.02534935f, -0.10718350f, -0.13758446f, 0.03262232f, 
    0.17343037f, 0.34313282f, 0.00352738f, 0.03709249f, -0.04626409f, -0.00792187f, -0.05629759f, 0.00175620f, 
    -0.03207927f, 0.02444814f, 0.11645053f, 0.06679004f, 0.04425063f, 0.00612996f, 0.06012576f, 0.05674599f, 
    0.01123901f, -0.03077940f, 0.43681750f, 0.05714212f, 0.14836599f, 0.11254963f, 0.04123856f, -0.04392608f, 
    0.15951097f, 0.05173431f, 0.16110961f, 0.07514133f, -0.20101191f, -0.24738954f, 0.13711631f, 0.18949701f, 
    -0.05958581f, -0.15780978f, 0.06518898f, 0.16044857f, 0.13158001f, 0.06036981f, -0.09669949f, 0.05536751f, 
    -0.31656426f, 0.49947545f, -0.07539877f, 0.02669433f, -0.05821922f, 0.02777532f, -0.03912067f, 0.02273061f, 
    -0.02514172f, -0.03930429f, 0.06075307f, 0.12596262f, -0.03127382f, 0.01404238f, -0.13598415f, -0.17240448f, 
    0.03689452f, -0.06199636f, 0.01418346f, 0.10964736f, -0.08451701f, 0.16651380f, 0.04420733f, 0.14010166f, 
    -0.08246885f, 0.04651584f, 0.10938803f, -0.15406986f, -0.07933259f, -0.04755595f, -0.06869531f, 0.01173787f, 
    -0.13161515f, -0.01160858f, -0.03633802f, -0.04285323f, -0.04418106f, -0.05308659f, -0.03324447f, 0.19302265f, 
    -0.07235864f, -0.00674394f, -0.07294175f, -0.10378909f, 0.17659414f, 0.23385927f, -0.04778694f, -0.05593422f, 
    0.36483252f, -0.22119370f, -0.15890740f, -0.17775655f, 0.04544624f, -0.17319295f, 0.09628788f, 0.11767158f, 
    0.09602659f, 0.13839342f, 0.07988796f, 0.10087974f, -0.25455543f, -0.12807399f, -0.07576916f, 0.03739311f, 
    -0.06796801f, -0.04050152f, -0.01115061f, -0.19410767f, 0.15346426f, -0.02572111f, 0.14667423f, 0.02664318f, 
    -0.39809558f, -0.28751650f, 0.16223261f, 0.17909327f, -0.01817401f, 0.11464927f, 0.06094714f, -0.03848913f, 
    0.02917920f, -0.05989861f, 0.06360091f, -0.00336200f, -0.00939824f, -0.31655398f, 0.24610750f, 0.31179824f, 
    0.01401173f, 0.13268867f, 0.02611702f, 0.03661546f, -0.01454924f, 0.01697682f, 0.10565555f, 0.10441902f, 
    -0.08974712f, -0.03263163f, 0.09147146f, 0.09121016f, -0.06754558f, -0.09431317f, 0.05133171f, 0.03826750f, 
    0.07673371f, 0.10032215f, -0.02242618f, 0.09653804f, -0.03067947f, -0.00343337f, 0.03354636f, -0.02947192f, 
    -0.07024459f, -0.11279101f, 0.09541805f, 0.08230128f, -0.06623565f, 0.02219109f, -0.16011967f, 0.01116265f, 
    0.11045246f, -0.10223071f, 0.02754082f, 0.15972811f, -0.00331182f, -0.12411069f, 0.12361524f, 0.13052544f, 
    -0.06215923f, -0.01627147f, 0.19535089f, 0.03210985f, -0.11748344f, -0.24991705f, -0.19734915f, 0.07018648f, 
    0.17200671f, 0.09629670f, -0.02671671f, -0.21742713f, -0.02897755f, 0.00871406f, -0.00032925f, 0.14068148f, 
    -0.31261122f, 0.22047773f, -0.13390705f, -0.07030543f, 0.21702094f, 0.03654826f, 0.05788602f, 0.13407148f, 
    -0.00416600f, 0.02953722f, 0.11656496f, 0.10135685f, 0.23599418f, -0.13436146f, -0.12895177f, -0.00903141f, 
    0.17556949f, -0.07973836f, -0.02709423f, 0.06342411f, -0.14381370f, 0.07282490f, -0.01305482f, 0.05046806f, 
    0.03627153f, -0.09696396f, 0.16076458f, 0.03701560f, 0.16972505f, 0.23161364f, -0.00553327f, 0.07427468f, 
    0.10516763f, -0.07565494f, 0.09050868f, 0.10158392f, 0.35619792f, -0.20143338f, 0.26869684f, -0.18762636f, 
    0.06194378f, 0.06994142f, 0.03605882f, 0.20987009f, -0.12719512f, 0.29446569f, 0.05005879f, 0.00342325f, 
    -0.67047089f, -0.10896783f, 0.23101240f, -0.07480089f, 0.00101897f, -0.12049581f, 0.16371873f, 0.21625853f, 
    0.08705492f, 0.05384885f, -0.11521327f, -0.01330543f, -0.07999419f, 0.16412599f, -0.28251731f, -0.17070730f, 
    0.01342437f, -0.09243397f, -0.00341278f, 0.08561546f, -0.05550567f, 0.17403491f, 0.03792839f, 0.16222186f, 
    -0.06497937f, -0.11047878f, 0.06210202f, -0.09755088f, -0.00550793f, -0.01186818f, 0.02942115f, 0.03445582f, 
    -0.00232049f, -0.04173854f, 0.00708336f, 0.05276882f, -0.37839800f, -0.09763820f, 0.06097694f, 0.07093275f, 
    0.06849495f, 0.04375850f, 0.14494897f, 0.09372643f, 0.05249494f, -0.00526625f, -0.14842477f, -0.02396577f, 
    -0.32224891f, 0.15326959f, 0.00991768f, -0.02270437f, 0.08290067f, 0.00566641f, 0.07893354f, 0.09100635f, 
    0.06195878f, -0.01287856f, 0.05389024f, -0.01011114f, -0.03682992f, 0.07438880f, 0.30869970f, -0.12281971f, 
    0.07844166f, 0.01503259f, -0.08527815f, 0.01368964f, 0.02783074f, 0.09399910f, -0.03948486f, -0.02267994f, 
    -0.23091742f, 0.25577244f, -0.36004549f, -0.08579540f, 0.15453374f, -0.02098959f, 0.18378511f, -0.08747739f, 
    0.04452730f, -0.07210930f, 0.15929869f, 0.00344067f, -0.17176321f, -0.01102969f, 0.11672560f, -0.02477484f, 
    -0.14562991f, 0.15932283f, -0.01631099f, -0.28611845f, 0.03098795f, 0.02721995f, 0.07263609f, 0.06617367f, 
    -0.34279680f, 0.16437893f, -0.08209472f, 0.05239049f, 0.01519821f, -0.01269974f, 0.21901238f, -0.05612483f, 
    -0.02538596f, 0.10967186f, -0.00992949f, 0.04183394f, 0.08699601f, -0.13964134f, 0.26915336f, -0.08239146f, 
    -0.02323218f, -0.01549807f, -0.01967485f, 0.09978665f, 0.02443989f, -0.02720801f, -0.02554959f, -0.05392568f, 
    -0.14904913f, 0.00923383f, -0.18831037f, -0.28962654f, 0.08413600f, 0.01906666f, -0.04339570f, 0.09050462f, 
    -0.10396242f, 0.03108865f, 0.17522863f, -0.03537295f, -0.16720147f, -0.36919644f, 0.48143816f, -0.28490901f, 
    0.09674516f, -0.04501068f, -0.12397660f, 0.06164343f, -0.09034944f, 0.01365689f, 0.12802996f, -0.13787660f, 
    -0.02708264f, 0.22853826f, 0.12696800f, 0.21978213f, -0.01470075f, 0.07599992f, 0.01842877f, 0.03263019f, 
    0.03676295f, -0.13164878f, 0.00141209f, 0.00227963f, 0.18417788f, -0.03867068f, 0.04940026f, 0.13500182f, 
    0.13242809f, -0.03036525f, -0.12362944f, -0.03151709f, 0.13736145f, 0.02726520f, 0.07347143f, 0.07173081f, 
    -0.10017217f, -0.12963606f, -0.18191688f, 0.02701527f, 0.05368521f, 0.00951696f, 0.07646264f, 0.04891608f, 
    0.05449952f, 0.06884671f, -0.06261401f, -0.05763605f, 0.21724817f, 0.21734421f, 0.03952483f, 0.07385652f, 
    -0.05875190f, 0.15544967f, 0.06385620f, 0.15336040f, 0.02413205f, -0.05122808f, -0.20957734f, 0.11247970f, 
    0.11331262f, -0.50106835f, -0.04602519f, -0.24939273f, 0.11883246f, -0.03670812f, 0.00946250f, -0.01515449f, 
    -0.02722971f, 0.09055660f, -0.04188799f, 0.05038017f, -0.11414053f, -0.10912412f, -0.16093019f, 0.00907104f, 
    -0.02203496f, -0.10668970f, -0.07186054f, -0.08117400f, 0.14888479f, -0.01871693f, 0.04475508f, 0.09039485f, 
    -0.21173348f, -0.20942257f, -0.19846627f, -0.15172820f, -0.03119210f, -0.13063639f, -0.00839617f, -0.02123487f, 
    0.12176441f, 0.03263459f, 0.06025210f, 0.03005513f, -0.09464087f, 0.17763315f, -0.21851175f, -0.19457707f, 
    0.12000693f, 0.01461663f, 0.00023621f, -0.05968565f, 0.08543192f, 0.04760372f, 0.18609524f, 0.08424082f, 
    -0.36488196f, 0.01737376f, -0.17775926f, 0.26556066f, 0.05345625f, 0.06340900f, 0.03391777f, -0.09620763f, 
    0.06545652f, -0.00460358f, 0.02836314f, 0.15208185f, 0.00152834f, 0.03082610f, 0.11862790f, 0.16512631f, 
    0.00592617f, 0.11461607f, 0.15725696f, 0.03075668f, 0.00316133f, 0.16637599f, -0.12776101f, 0.13844676f, 
    0.12585104f, 0.11606281f, 0.39390063f, 0.11779377f, -0.04928387f, -0.00520326f, 0.04885280f, 0.01014491f, 
    0.04313609f, -0.07853273f, -0.07267293f, -0.04118381f, -0.10156714f, 0.20743224f, 0.26805440f, 0.04934841f, 
    -0.03269082f, -0.09214248f, 0.03126240f, 0.08372656f, 0.04551259f, 0.03054838f, -0.07195526f, 0.09653207f, 
    -0.04360830f, -0.03274785f, 0.23453839f, 0.06047945f, 0.01732895f, 0.10908127f, 0.03732076f, 0.08878432f, 
    0.06657273f, 0.06196062f, 0.07346198f, -0.02006578f, -0.33545858f, -0.26087752f, -0.22627865f, -0.13119471f, 
    0.01937771f, -0.01902463f, -0.06253265f, -0.14417577f, 0.10985018f, -0.08725520f, 0.12922372f, 0.00812073f, 
    -0.17439267f, 0.03104377f, 0.05417634f, 0.15237178f, 0.00158119f, 0.03777763f, -0.01195305f, 0.03139436f, 
    0.08026163f, 0.01965066f, 0.00035904f, 0.06930221f, 0.01612131f, 0.30465588f, 0.19090150f, 0.02824084f, 
    0.02077425f, 0.05643055f, 0.12088211f, 0.00038754f, -0.01597350f, 0.08129098f, 0.10911270f, -0.01096100f, 
    0.04099013f, -0.27933812f, 0.06297919f, -0.01079386f, 0.02448248f, -0.00297153f, -0.16093215f, 0.04859843f, 
    0.29213160f, 0.10525380f, 0.12214059f, 0.04026173f, -0.27466679f, -0.01477460f, -0.26692590f, -0.14926812f, 
    -0.00968497f, 0.08679197f, -0.01306941f, -0.02973531f, 0.19189571f, -0.07262344f, 0.11932835f, 0.09236325f, 
    -0.06184429f, -0.06057695f, -0.11621214f, 0.07155588f, 0.03646785f, 0.05065156f, 0.09804233f, 0.10667509f, 
    0.22983533f, 0.15725686f, 0.04418924f, 0.13835067f, 0.08393396f, 0.12004146f, -0.32853761f, -0.13224520f, 
    -0.00318007f, -0.13198045f, -0.08599923f, -0.09308866f, 0.09330910f, -0.17302583f, 0.00698747f, -0.00944134f, 
    0.29480365f, 0.16888887f, 0.25800508f, 0.15057339f, -0.00159923f, 0.05289216f, -0.06735307f, 0.11790624f, 
    -0.09468606f, -0.09896918f, 0.02054945f, 0.08878674f, 0.03722037f, -0.33038256f, -0.05279162f, 0.05921620f, 
    -0.09894709f, 0.05968340f, -0.02712548f, 0.02842123f, 0.09539521f, -0.03553409f, -0.01013790f, 0.01637272f, 
    -0.22785240f, -0.32728827f, -0.36376065f, -0.04855479f, -0.03809357f, -0.00742152f, 0.02554430f, 0.04296503f, 
    -0.07325163f, -0.15262766f, 0.00818745f, 0.05853556f, 0.26042765f, 0.15389118f, 0.15148774f, 0.12335301f, 
    0.00584170f, 0.07771535f, -0.13094112f, -0.03090950f, 0.05850314f, 0.10058690f, 0.19711883f, 0.12686619f, 
    0.03120217f, -0.05446430f, 0.10098557f, 0.19003733f, 0.05544368f, -0.05458081f, -0.13698260f, -0.04220946f, 
    0.11423476f, 0.06760468f, 0.03913253f, -0.03643529f, -0.02665719f, -0.05746061f, -0.09791064f, -0.14313252f, 
    -0.06394594f, 0.15980625f, 0.09966549f, 0.04458439f, 0.13906138f, -0.10458767f, 0.08148869f, 0.07756586f, 
    -0.16129115f, 0.02419528f, 0.08990462f, 0.33352277f, 0.13950138f, -0.01470430f, -0.12812299f, 0.06414172f, 
    0.03811152f, 0.12053295f, -0.08057094f, -0.03930243f, 0.02736204f, 0.21147364f, 0.12265125f, 0.00766822f, 
    0.19068532f, -0.02187049f, 0.14789465f, 0.14388786f, 0.05971742f, -0.04366750f, -0.06749173f, -0.07112384f, 
    0.15008162f, 0.06221385f, 0.34445825f, 0.09221530f, 0.08093515f, -0.03654910f, -0.08598817f, 0.08088124f, 
    0.11979559f, 0.01854246f, 0.13358577f, 0.02106582f, -0.42458564f, -0.13102481f, -0.34655273f, 0.12312815f, 
    0.00692974f, 0.03039782f, -0.04545420f, -0.09486093f, 0.07823723f, -0.07084043f, -0.05841375f, 0.09101463f, 
    -0.11321204f, -0.08567430f, -0.09532913f, 0.00018750f, 0.04462537f, -0.09071197f, -0.05807481f, 0.01214595f, 
    0.01864372f, -0.02761053f, 0.10027293f, -0.00288995f, -0.07141320f, 0.32243922f, -0.47007126f, 0.14421351f, 
    -0.02492256f, 0.06061843f, -0.06187190f, -0.05762011f, 0.13012397f, -0.06117351f, -0.00060099f, -0.07433306f, 
    -0.08932973f, 0.10391889f, -0.08345240f, -0.11077242f, 0.05125101f, 0.10931744f, 0.00329891f, -0.05005708f, 
    0.19470416f, 0.10765114f, -0.03061013f, 0.16001633f, -0.04615741f, 0.05239642f, -0.26089850f, 0.01462446f, 
    0.17945661f, 0.08761534f, 0.18466602f, -0.07481890f, 0.07809217f, 0.09434718f, 0.02090677f, 0.10717357f, 
    -0.10706611f, 0.09607489f, 0.07260650f, -0.02618621f, 0.24404490f, 0.04286127f, 0.04423134f, -0.04650686f, 
    0.07094430f, 0.07041331f, 0.18521176f, 0.04089460f, 0.17910539f, -0.42589578f, 0.17155157f, -0.20185159f, 
    -0.16558628f, 0.03924550f, 0.00464258f, 0.17243217f, 0.03553685f, -0.00299777f, 0.24559277f, -0.13624753f, 
    0.27467090f, 0.24706595f, 0.28604332f, -0.12157846f, 0.08827341f, -0.01689922f, 0.00726710f, 0.23978204f, 
    -0.01661546f, 0.08181221f, -0.04162896f, -0.03365265f, 0.29730260f, 0.13169022f, 0.23144282f, 0.04258532f, 
    -0.16159615f, -0.01822477f, -0.05255593f, -0.02202421f, 0.09894288f, 0.00606688f, 0.07842344f, 0.18237880f, 
    0.20339440f, 0.26843691f, 0.17899399f, 0.15422070f, -0.09037460f, -0.14011791f, -0.07002801f, -0.00728721f, 
    -0.00111322f, -0.02811642f, 0.04411269f, 0.08652543f, -0.01855660f, 0.21221547f, -0.03501197f, 0.04297885f, 
    -0.07723369f, 0.14956576f, -0.15676221f, 0.08936791f, 0.06650627f, 0.15950122f, 0.08621173f, -0.09313117f, 
    0.13090438f, -0.16716155f, 0.01029323f, 0.30397785f, 0.09528551f, -0.03522607f, 0.03292394f, 0.07268238f, 
    0.14893632f, 0.14819369f, 0.06735170f, -0.08233499f, -0.09211548f, -0.10084217f, 0.04095662f, -0.07529952f, 
    0.12017532f, -0.11842356f, -0.13885736f, 0.10259975f, 0.14762127f, 0.08667726f, -0.00437732f, -0.04298684f, 
    0.17952837f, -0.67794102f, 0.06304355f, -0.06962489f, -0.25344256f, -0.17705700f, 0.06806554f, 0.11525255f, 
    -0.04201734f, -0.11945197f, 0.03634130f, -0.09365997f, 0.13060568f, -0.19963518f, 0.10512208f, 0.07903420f, 
    -0.13317080f, 0.09406120f, -0.00839910f, 0.10121199f, -0.12013092f, -0.04866421f, 0.08230835f, -0.14415467f, 
    -0.15237254f, -0.07092451f, 0.33333319f, -0.09263304f, 0.11201254f, -0.03821767f, 0.09231552f, 0.09401754f, 
    0.06763203f, 0.04690256f, 0.01400460f, 0.01412373f, 0.02480942f, 0.21883717f, 0.13913153f, 0.07020628f, 
    -0.15659736f, -0.14376064f, -0.08764019f, -0.04146966f, 0.07785346f, -0.01005711f, 0.12493563f, 0.11014185f, 
    -0.17920078f, 0.02100170f, 0.09061412f, 0.13988747f, 0.02339799f, -0.01560854f, -0.06429789f, 0.00117796f, 
    -0.02979589f, -0.18080541f, -0.06123937f, -0.01587031f, -0.32307398f, -0.15459989f, -0.18610080f, 0.07882197f, 
    0.02047139f, 0.15380505f, 0.02131101f, -0.03467435f, -0.00990979f, 0.03193978f, -0.03754962f, 0.00598220f, 
    0.20227598f, -0.05879485f, 0.10236451f, -0.04852099f, 0.26159495f, 0.05158607f, -0.03302033f, 0.19699833f, 
    0.01981732f, -0.04838566f, -0.08119190f, 0.00077513f, -0.00636165f, 0.09564769f, -0.09822895f, 0.00591311f, 
    -0.00071125f, -0.18311076f, -0.08791354f, 0.11158711f, -0.07230628f, -0.14469038f, -0.03409363f, -0.02000578f, 
    -0.11711784f, -0.00558081f, -0.01373315f, -0.08081118f, 0.15459739f, -0.03508510f, -0.03118631f, -0.09966842f, 
    -0.17182118f, -0.09965988f, 0.08626730f, 0.03558437f, 0.10739047f, -0.11185490f, 0.18231820f, 0.14832582f, 
    0.00003415f, -0.04098474f, 0.11374000f, -0.10895353f, 0.12575480f, 0.31390077f, -0.03502310f, 0.05907013f, 
    0.08001056f, -0.27792895f, 0.10166107f, -0.38206521f, -0.08419134f, -0.12877113f, 0.11809446f, 0.09891565f, 
    0.20008808f, 0.13424225f, 0.00695602f, -0.02703878f, 0.29710609f, 0.28692898f, 0.02444549f, 0.19629742f, 
    -0.01914456f, -0.00591662f, 0.11271451f, -0.02287440f, 0.03916035f, 0.04951716f, -0.03008944f, 0.10221021f, 
    0.01604991f, 0.13561398f, 0.17534252f, -0.10488977f, -0.09085058f, -0.05987279f, 0.05000517f, -0.18980427f, 
    0.07136197f, -0.01565643f, 0.03772385f, 0.03646354f, 0.14503442f, -0.25288111f, 0.23077901f, -0.09459858f, 
    -0.12643766f, 0.03609685f, 0.07314115f, -0.06687471f, 0.14004353f, 0.08555529f, -0.06315020f, 0.09059270f, 
    -0.02022871f, 0.04818048f, -0.01426586f, -0.24795727f, 0.03016243f, 0.18695705f, 0.03494048f, 0.18477909f, 
    0.04518697f, -0.01830052f, -0.14043291f, -0.01070341f, 0.08568124f, 0.20337738f, 0.13813040f, -0.01244728f, 
    0.12715288f, -0.10322837f, 0.15873735f, -0.01180456f, -0.01046140f, -0.05516270f, 0.10364267f, -0.05924288f, 
    -0.08606297f, -0.06958684f, -0.06763946f, 0.04424781f, -0.19139613f, -0.19311659f, 0.27045655f, -0.06413709f, 
    0.15823804f, -0.04562227f, 0.20577364f, -0.18841065f, -0.10805291f, 0.08871851f, 0.19776425f, -0.23901238f, 
    0.07258087f, 0.10850623f, -0.07886063f, -0.11480165f, 0.23216070f, 0.13903025f, 0.02187520f, -0.06759309f, 
    0.21638660f, -0.12248852f, 0.24159515f, -0.10498539f, -0.09754109f, -0.04327578f, 0.20236234f, 0.10927813f, 
    0.16271558f, -0.11896093f, -0.17679623f, 0.07346665f, 0.03336521f, 0.23068702f, 0.19516340f, 0.03540469f, 
    0.10971948f, -0.14894895f, -0.12383462f, 0.02950901f, 0.03209227f, -0.02856636f, 0.09691329f, -0.03818820f, 
    0.27219671f, 0.11957350f, 0.18153869f, 0.03116719f, -0.08245306f, -0.01031843f, -0.08085176f, -0.00579069f, 
    0.05456677f, -0.11031490f, 0.04543616f, -0.04148822f, 0.16688657f, 0.30976802f, 0.24056326f, -0.18897131f, 
    0.02708204f, -0.19303767f, -0.12266161f, 0.10181864f, -0.00336443f, -0.07326318f, 0.17939079f, 0.03773908f, 
    0.45769641f, 0.11538546f, 0.09267315f, 0.24576832f, -0.14628150f, 0.06535757f, 0.00742816f, 0.14145532f, 
    -0.04515899f, -0.02386392f, -0.08641288f, 0.07128542f, -0.10088611f, -0.18744038f, -0.05633590f, 0.23909956f, 
    0.05476740f, 0.10705382f, -0.16358666f, 0.09599430f, 0.01224701f, -0.05828364f, -0.04654203f, 0.13462494f, 
    -0.07137054f, -0.04369610f, -0.11932751f, 0.09583283f, -0.04472997f, 0.10214899f, 0.10626981f, -0.05002759f, 
    0.00641438f, 0.06980513f, -0.15660416f, 0.03177903f, -0.12075974f, 0.28192213f, -0.02007971f, 0.23301665f, 
    0.01147744f, 0.21484125f, -0.01806598f, -0.01374730f, 0.01528745f, -0.00679481f, -0.12110481f, 0.11090132f, 
    -0.38842306f, 0.06175685f, 0.00303056f, 0.20491558f, 0.10498685f, -0.07721243f, -0.06231711f, 0.05389865f, 
    -0.09881951f, 0.00026660f, -0.09985528f, 0.05539593f, -0.08491806f, -0.14037228f, -0.07724000f, -0.05658618f, 
    -0.01120606f, -0.10285478f, 0.02345838f, 0.12525359f, 0.11198971f, -0.05218331f, -0.00964367f, 0.05198760f, 
    -0.18841989f, -0.22390740f, -0.24745952f, -0.17439328f, 0.08072793f, -0.11078607f, 0.05077414f, 0.05465019f, 
    -0.01012649f, -0.02553542f, -0.09973720f, -0.00382367f, 0.13675478f, 0.07287887f, 0.04921303f, 0.26511288f, 
    0.01982814f, 0.14352655f, -0.00765685f, -0.01713516f, 0.15875530f, 0.03513828f, 0.18363979f, 0.23894218f, 
    -0.05528850f, 0.05717071f, -0.41116813f, 0.07405826f, -0.09855270f, -0.04705574f, 0.08078529f, 0.02158788f, 
    -0.12803164f, 0.08227095f, -0.02026760f, 0.14882122f, -0.21922387f, 0.01308912f, -0.28783253f, 0.19690950f, 
    -0.04472242f, 0.08946858f, -0.00436626f, 0.07904979f, -0.06324752f, 0.15284307f, -0.07997649f, -0.00187419f, 
    -0.34826085f, 0.14527801f, 0.20858635f, 0.24380080f, -0.00544629f, 0.00569931f, -0.13149957f, -0.03500422f, 
    -0.05993253f, 0.12807554f, 0.04056995f, -0.06542533f, -0.35132438f, 0.15720214f, 0.34819749f, 0.29745883f, 
    0.06933406f, -0.05179662f, 0.12526354f, 0.08030182f, -0.01671627f, 0.03842903f, -0.07654295f, 0.02231070f, 
    -0.28655732f, 0.02082142f, -0.28984955f, 0.07295958f, -0.07298543f, 0.17799765f, -0.15141697f, -0.03101935f, 
    -0.06470662f, 0.09919880f, 0.06014708f, -0.04554751f, -0.25955880f, -0.26155519f, -0.08303899f, -0.12689382f, 
    0.03630364f, -0.01727048f, 0.20134202f, -0.22624928f, 0.03574441f, -0.09720509f, -0.01506867f, -0.04397262f, 
    -0.22224218f, -0.05395751f, -0.06434782f, 0.15509605f, -0.03300244f, 0.05824979f, 0.20005925f, 0.07106358f, 
    0.03415965f, 0.00136629f, 0.05810667f, 0.02499224f, -0.28561008f, -0.16733743f, 0.08214469f, 0.11057456f, 
    0.12510854f, 0.08640157f, 0.09426001f, 0.00135505f, -0.00737009f, 0.09847831f, -0.01152060f, -0.02326532f, 
    0.09669100f, -0.05416649f, 0.19440821f, 0.06838958f, 0.10798482f, -0.05118977f, -0.06675874f, -0.15527999f, 
    -0.14663008f, 0.04341220f, 0.00452381f, 0.08896015f, 0.06524319f, 0.15197009f, -0.01040443f, -0.21691936f, 
    0.09128088f, 0.02219493f, 0.12205601f, -0.12382416f, -0.04356719f, 0.03719735f, 0.06396285f, -0.17018564f, 
    -0.13330193f, -0.08165639f, -0.02278477f, 0.08562402f, -0.16325289f, -0.08109356f, -0.04077999f, 0.01538067f, 
    0.17407717f, 0.00044202f, 0.03160042f, 0.02481372f, 0.42151240f, 0.18009411f, -0.35234374f, -0.29705346f, 
    -0.23765285f, 0.02320946f, 0.02813638f, -0.04391864f, 0.10843291f, 0.01990078f, 0.03004542f, -0.00035734f, 
    0.22818127f, 0.62592584f, 0.24176019f, 0.24589764f, 0.00185309f, -0.16588090f, -0.01760857f, -0.04859264f, 
    -0.07808454f, -0.10801452f, 0.01224481f, -0.01542424f, 0.10073798f, -0.07381548f, 0.20812011f, -0.06621964f, 
    0.05948209f, -0.16516550f, -0.01373238f, 0.14275397f, -0.16752718f, -0.07083908f, -0.00253673f, 0.06615244f, 
    -0.27665243f, 0.12282114f, -0.14266296f, -0.08829204f, -0.20563743f, 0.03267620f, 0.03380469f, -0.05000152f, 
    0.03050556f, 0.06914592f, 0.07860620f, -0.07466882f, -0.18639034f, 0.55079556f, 0.37149733f, 0.13165744f, 
    0.07149763f, 0.01913439f, 0.01750561f, 0.14264810f, 0.00993800f, 0.04875829f, -0.10929609f, 0.07710341f, 
    -0.16407377f, -0.04584904f, 0.20033883f, 0.14731319f, 0.04900368f, 0.04662964f, -0.10572194f, -0.08116640f, 
    0.18045086f, 0.03470278f, -0.09195255f, -0.07256076f, -0.04577544f, -0.19983910f, 0.06848563f, -0.05634988f, 
    -0.10243081f, 0.02023489f, -0.01300382f, 0.18711556f, 0.05069445f, -0.01866299f, 0.13435663f, -0.05383748f, 
    -0.06906117f, 0.35611093f, -0.01341646f, 0.14975061f, -0.17699087f, 0.02065766f, -0.11525450f, 0.05184719f, 
    -0.05971559f, -0.08384408f, -0.12251328f, 0.08179840f, -0.18749958f, 0.04645094f, -0.09144570f, 0.23669863f, 
    -0.01062113f, -0.09958029f, 0.14988479f, 0.14653693f, 0.17983596f, 0.06938387f, 0.12561369f, 0.15355381f, 
    -0.05185498f, 0.10624444f, 0.55988550f, 0.13632137f, 0.08669318f, -0.02258419f, -0.06308658f, 0.15472484f, 
    -0.17841513f, 0.11093897f, 0.03071918f, -0.06360208f, -0.20583700f, -0.25605324f, -0.13518792f, 0.12057142f, 
    -0.24659865f, 0.15858813f, 0.03992481f, -0.09486830f, 0.03809813f, 0.04457784f, -0.05522640f, -0.05402325f, 
    0.04073755f, -0.07595538f, -0.18732278f, -0.22498320f, -0.00601631f, -0.10303453f, -0.01632718f, -0.01707527f, 
    0.24252455f, 0.13405861f, 0.00736909f, -0.01781790f, 0.24120100f, 0.16147788f, -0.19771899f, -0.09925579f, 
    -0.18886347f, 0.02726183f, -0.10492507f, -0.04701933f, 0.03119688f, 0.02061878f, -0.00056878f, -0.04603737f, 
    0.02899481f, 0.25422442f, 0.15922178f, 0.07833760f, -0.01960139f, 0.03103055f, -0.05554444f, 0.05177660f, 
    0.06106596f, 0.00734807f, 0.08328155f, -0.06883137f, 0.09623100f, -0.07276525f, -0.00166991f, -0.05278113f, 
    0.11582784f, -0.00359364f, -0.21347350f, 0.11508583f, 0.07428060f, 0.04304660f, -0.08417212f, -0.07663935f, 
    -0.07148870f, -0.22367965f, -0.30884656f, -0.05889159f, -0.08456548f, 0.05755920f, -0.07289108f, -0.09241882f, 
    0.00276409f, -0.04960223f, -0.05705297f, 0.05222406f, 0.20328118f, 0.25678411f, -0.10342012f, -0.05627114f, 
    0.06810268f, 0.08208021f, -0.18755175f, -0.05739777f, 0.02033843f, 0.03680049f, 0.05828042f, 0.07373662f, 
    0.06328276f, -0.62983805f, 0.21596117f, 0.12093246f, 0.16251144f, 0.09667548f, 0.00850529f, -0.06453913f, 
    -0.00901250f, 0.03906139f, -0.19285266f, -0.05532654f, -0.07559646f, 0.03948039f, 0.03458318f, 0.13224769f, 
    0.01516646f, -0.01398437f, -0.01956328f, -0.06291955f, 0.19627357f, 0.10691468f, 0.12304995f, -0.04872504f, 
    -0.08041768f, -0.10619116f, -0.16874132f, 0.02175256f, 0.07271371f, 0.05444592f, 0.05029029f, -0.09577002f, 
    0.05931101f, -0.07081132f, -0.03770445f, -0.07757337f, 0.03126074f, 0.20796978f, 0.08640632f, -0.05682267f, 
    -0.04632686f, 0.01136288f, 0.02278144f, -0.09031153f, -0.06712497f, -0.25844806f, 0.09837101f, 0.19311598f, 
    -0.41204536f, 0.15313338f, 0.23239784f, 0.09562942f, -0.00763738f, 0.16317609f, 0.02036947f, 0.07787687f, 
    -0.00222454f, -0.00219962f, 0.04600333f, 0.02668124f, 0.19139269f, 0.10725156f, -0.00755939f, 0.05574065f, 
    0.01799021f, 0.05015330f, 0.16466688f, 0.19093615f, -0.05879818f, 0.05992118f, 0.01796904f, 0.12877603f, 
    -0.09956238f, 0.36827517f, -0.05442629f, 0.01172700f, 0.05497803f, 0.00939557f, -0.15193082f, 0.05550580f, 
    -0.01911187f, 0.05615825f, -0.06095108f, -0.10865557f, -0.31048658f, 0.12433957f, -0.12503155f, -0.18963934f, 
    0.00287115f, -0.04593942f, 0.06241527f, 0.10652274f, 0.08029369f, -0.08861204f, -0.09105391f, 0.04978048f, 
    0.10152051f, -0.05069315f, -0.22762266f, 0.08072090f, 0.01275064f, 0.12380340f, 0.01590051f, -0.06743994f, 
    -0.02915520f, -0.09099913f, 0.03012711f, 0.04679545f, 0.00751922f, -0.04040221f, -0.14255746f, -0.13561742f, 
    0.09916675f, 0.00412409f, 0.02671196f, -0.07340240f, 0.00629051f, -0.10861833f, -0.10423256f, 0.02581276f, 
    -0.10245897f, -0.07928268f, -0.06536228f, -0.12958215f, -0.04821261f, 0.16467464f, 0.07219555f, 0.05227922f, 
    0.12127423f, 0.01117454f, 0.05784460f, 0.07597760f, 0.09123828f, 0.25293392f, 0.15902340f, 0.00147891f, 
    0.08384405f, -0.06919727f, 0.10191527f, 0.09950196f, -0.03141616f, 0.07696693f, -0.06043528f, -0.02059029f, 
    0.17514692f, -0.23335102f, 0.17285152f, 0.05543107f, -0.05777593f, -0.05353649f, -0.04485942f, -0.16871369f, 
    0.00987492f, 0.00487991f, -0.01239687f, -0.02617692f, -0.14724022f, 0.04562523f, 0.09704872f, 0.04631488f, 
    -0.14860559f, 0.15637085f, 0.15603119f, -0.15168856f, 0.07933195f, -0.08364523f, -0.06893755f, -0.15183014f, 
    -0.10655267f, -0.05702261f, -0.23340721f, 0.00441263f, -0.06288099f, -0.08694682f, 0.06850624f, -0.03721865f, 
    0.04204019f, 0.00000931f, -0.05829765f, 0.00022559f, -0.19766250f, 0.25757778f, -0.41613585f, -0.12544076f, 
    -0.11906826f, -0.05531189f, -0.01027888f, 0.01303093f, 0.15287399f, -0.03387075f, 0.21099780f, 0.04413213f, 
    0.36612827f, 0.48572576f, 0.20557547f, 0.20201975f, -0.04501669f, -0.05520003f, -0.26804268f, -0.12332758f, 
    -0.01768603f, -0.11854945f, 0.06883712f, -0.01860712f, -0.01905444f, -0.19280370f, 0.39030996f, 0.17056593f, 
    -0.03417543f, 0.06684134f, -0.10929950f, -0.02353117f, -0.06357171f, -0.06554311f, 0.02434500f, -0.02724435f, 
    -0.01428113f, -0.05297612f, -0.14707112f, -0.06625301f, 0.05266612f, -0.06306289f, 0.11722117f, 0.05434231f, 
    0.04869278f, 0.00075110f, 0.05025444f, 0.03615601f, 0.10264578f, 0.39207211f, 0.07639332f, 0.03044961f, 
    -0.11758503f, -0.10471997f, -0.17032444f, 0.09294233f, 0.06405283f, 0.10354378f, -0.02147865f, 0.05772379f, 
    0.02683231f, -0.11045313f, 0.13756154f, 0.15545110f, -0.00065582f, -0.01548460f, -0.11216669f, -0.05819913f, 
    0.20022653f, 0.05954061f, 0.18454093f, 0.12639859f, 0.01449062f, -0.06428045f, -0.31238490f, -0.04126780f, 
    -0.02615924f, 0.14630674f, 0.01627629f, 0.08281025f, -0.05454289f, -0.08852608f, -0.12626272f, 0.05258090f, 
    -0.01184130f, 0.03093083f, 0.27908847f, 0.15269203f, 0.06057392f, 0.07544778f, -0.24767165f, 0.08684742f, 
    0.07907878f, 0.04212986f, -0.04605718f, 0.13075937f, 0.08503895f, -0.00959393f, -0.29632759f, 0.07691728f, 
    0.15021192f, 0.08380849f, 0.10360292f, 0.18672238f, 0.17992109f, 0.04180311f, 0.15752807f, 0.08999870f, 
    -0.01413976f, 0.18893781f, 0.15304722f, 0.00280665f, 0.07540188f, 0.05425402f, -0.13825648f, 0.08411270f, 
    -0.08939125f, 0.09400102f, 0.11929316f, 0.03440690f, 0.02643236f, -0.06545638f, -0.43927482f, 0.04424723f, 
    0.01657684f, 0.10503466f, 0.23872815f, 0.02176508f, -0.02269650f, -0.02398091f, 0.06615382f, -0.10119545f, 
    -0.03619302f, -0.00492900f, 0.00947093f, 0.11410741f, -0.04987595f, 0.08862191f, 0.08674286f, -0.02735752f, 
    0.17646779f, 0.17915583f, 0.04080157f, 0.08233619f, 0.23975946f, 0.37799111f, -0.55694079f, 0.35543257f, 
    -0.16418113f, 0.09710345f, 0.14645684f, -0.14078102f, -0.06291319f, 0.03924840f, -0.12892178f, 0.06051800f, 
    0.01597879f, 0.14881647f, 0.15898332f, 0.12472598f, -0.15591204f, -0.11494796f, 0.09920913f, 0.11160625f, 
    0.08533608f, 0.24029832f, -0.02518332f, 0.24365608f, -0.24442190f, -0.16082872f, -0.03180078f, -0.05262271f, 
    -0.05508295f, 0.11755607f, -0.11773051f, -0.05142990f, 0.00259401f, -0.02103461f, 0.12845016f, 0.19819961f, 
    0.25608793f, 0.23670553f, 0.05963072f, -0.05118481f, 0.00537137f, 0.23322792f, 0.08825789f, 0.10527258f, 
    0.11829723f, 0.04741107f, -0.01296432f, 0.19111057f, -0.37690932f, 0.09341532f, -0.25748181f, -0.06268141f, 
    0.18946154f, 0.15075345f, 0.09937694f, 0.06673384f, 0.04698955f, 0.07598539f, 0.23851955f, -0.10865960f, 
    -0.00754591f, 0.01047807f, -0.13010824f, 0.32364234f, 0.08881938f, -0.05920929f, 0.02656536f, -0.01584742f, 
    0.15159258f, -0.15571019f, -0.00199477f, 0.01701533f, 0.03248003f, 0.06739173f, 0.15737836f, -0.02222225f, 
    -0.07414555f, -0.07110691f, -0.08722926f, -0.06201699f, -0.03929010f, 0.07563645f, 0.07860893f, 0.02651552f, 
    -0.14397667f, 0.05550180f, 0.00644537f, -0.02365372f, -0.00951172f, -0.09513423f, -0.06611009f, -0.18592042f, 
    -0.15209940f, -0.03338239f, -0.10738412f, -0.16620091f, 0.14036064f, -0.08284051f, 0.08540004f, 0.29779497f, 
    -0.14502656f, -0.12854731f, -0.03195067f, 0.13395284f, -0.10346290f, 0.02000275f, 0.07518010f, -0.03056777f, 
    -0.11195272f, 0.05144738f, -0.11911190f, -0.45630956f, 0.04070012f, 0.05942528f, 0.17866480f, 0.13156813f, 
    0.11694295f, 0.08997005f, 0.03271862f, -0.02830369f, -0.14976667f, 0.05068967f, -0.38495126f, -0.12722230f, 
    -0.03763808f, -0.05401107f, 0.10508766f, 0.04875921f, 0.17695887f, -0.11893748f, 0.20311834f, 0.22669636f, 
    -0.15971631f, 0.01735346f, -0.04625448f, 0.03590794f, 0.06861196f, 0.10641213f, -0.11469739f, 0.13655490f, 
    0.02125766f, 0.06148127f, 0.13522378f, 0.06960332f, 0.17139284f, 0.02356050f, -0.00850578f, 0.14949940f, 
    0.15972610f, 0.09301765f, -0.04737050f, 0.00941361f, 0.03213656f, 0.04070817f, 0.01269533f, -0.03360690f, 
    0.05533310f, 0.19332637f, -0.26687196f, 0.18138413f, 0.00564416f, 0.01130053f, 0.01975604f, -0.07462910f, 
    0.07765130f, 0.04552836f, -0.03381718f, 0.09142485f, -0.05422779f, 0.01476947f, -0.03008468f, 0.05569660f, 
    -0.08876744f, -0.01147493f, 0.05932002f, -0.09929584f, 0.03764283f, -0.03530928f, -0.07196558f, 0.02640433f, 
    0.14665055f, 0.07424150f, -0.19026226f, 0.01735588f, 0.00539483f, -0.15076157f, -0.03830334f, -0.03188425f, 
    -0.03750547f, 0.00014159f, -0.06107183f, -0.48887435f, -0.14423662f, -0.07092196f, 0.07003712f, -0.03628274f, 
    0.06181531f, 0.13172312f, -0.18544470f, -0.09784164f, 0.03505894f, -0.15593602f, 0.12263159f, 0.15980820f, 
    -0.05708784f, 0.03381772f, -0.00293103f, -0.22583628f, 0.04073222f, -0.14395523f, 0.20170145f, -0.14350092f, 
    -0.07935891f, 0.02564051f, 0.03082826f, 0.12568109f, 0.05893459f, -0.06017713f, -0.06892128f, -0.19348750f, 
    0.07236050f, 0.06563370f, -0.03847717f, -0.05673982f, 0.07656001f, 0.15378658f, 0.10090682f, 0.18541671f, 
    -0.03945097f, -0.19583264f, -0.16427802f, -0.16541849f, 0.11128368f, 0.06266736f, -0.04050088f, 0.02527877f, 
    -0.12633632f, -0.02317200f, 0.03611462f, -0.02713162f, 0.13325512f, 0.10038856f, 0.03553414f, 0.12677643f, 
    0.02310852f, -0.02977908f, 0.10561285f, 0.16037123f, -0.25106531f, -0.06115855f, 0.04956408f, -0.05488067f, 
    -0.34107205f, 0.08715446f, -0.17919533f, -0.02991177f, 0.09296793f, 0.03986785f, 0.13124976f, -0.09758513f, 
    0.03660370f, 0.03409918f, 0.15284081f, 0.16424797f, -0.23830004f, -0.11891843f, 0.23106584f, 0.13420224f, 
    -0.13996039f, -0.09494755f, -0.06202212f, -0.09571065f, 0.17426932f, -0.13171726f, 0.01221638f, 0.14270276f, 
    -0.16909254f, 0.09895109f, 0.03305075f, -0.08034264f, -0.05970536f, -0.11823101f, -0.09205492f, -0.08353442f, 
    -0.26199588f, -0.31607762f, -0.06885847f, 0.01078013f, -0.11478403f, 0.25508961f, -0.12179271f, 0.01941351f, 
    0.20109780f, 0.02104262f, -0.00208023f, 0.05011262f, 0.04452409f, 0.06690904f, 0.14183311f, -0.00551865f, 
    -0.06229205f, -0.03187296f, 0.10814980f, 0.00112348f, -0.11764444f, -0.01481486f, 0.07997020f, -0.07280986f, 
    -0.28908443f, -0.18124326f, -0.12245551f, -0.27427492f, 0.01474073f, -0.33254251f, -0.26349398f, 0.02534739f, 
    0.00949766f, 0.07586042f, 0.18136109f, -0.07338205f, 0.11293922f, 0.13182046f, 0.04273191f, 0.23591815f, 
    -0.09430382f, -0.01251516f, 0.10589469f, -0.20389919f, -0.22833177f, 0.06619778f, -0.20440793f, 0.09742856f, 
    0.11000215f, 0.07360315f, 0.00394272f, 0.05373687f, 0.05393175f, -0.05604747f, -0.14616199f, 0.01187221f, 
    0.02907515f, 0.17550154f, -0.01469772f, 0.10815646f, -0.01910702f, 0.12370123f, 0.02819464f, -0.10803436f, 
    -0.11703682f, 0.09038409f, 0.13451208f, -0.06288870f, -0.01404260f, 0.24271208f, 0.19952077f, -0.15932414f, 
    0.08648809f, 0.06911984f, 0.00968308f, 0.06658202f, 0.12605035f, 0.09616204f, -0.16827092f, -0.16667099f, 
    -0.02564407f, 0.06903170f, 0.18817089f, 0.01409029f, -0.17111650f, 0.08416344f, -0.03153488f, 0.06514307f, 
    0.04441505f, -0.03251860f, 0.14547339f, -0.07288048f, 0.05194923f, -0.10817277f, 0.02173334f, -0.07429039f, 
    -0.13279316f, 0.18466759f, 0.01574505f, -0.22250070f, 0.15088807f, -0.06253017f, -0.02140875f, -0.12961958f, 
    -0.00985999f, 0.07242932f, 0.05344458f, 0.16334464f, -0.03033081f, 0.13507563f, -0.04956842f, -0.00026643f, 
    0.42449629f, -0.19287902f, -0.11135160f, -0.11817148f, 0.00505825f, 0.01652508f, -0.08720662f, 0.01316991f, 
    0.02973921f, 0.33758822f, 0.07923406f, 0.11648147f, -0.09520464f, 0.04576052f, 0.14722811f, 0.24577411f, 
    0.02339269f, 0.12088634f, 0.13662840f, 0.11253242f, -0.05156976f, -0.10976887f, 0.08087818f, 0.14681509f, 
    0.20564736f, 0.24351193f, 0.36529240f, 0.20894824f, 0.01063282f, 0.04833654f, 0.03199021f, 0.06757249f, 
    0.02107549f, 0.15271664f, 0.06305488f, 0.02408849f, -0.39242962f, 0.14915776f, -0.11716664f, 0.20478994f, 
    0.01441968f, -0.00698122f, 0.14034915f, 0.12672311f, 0.08066529f, 0.08364293f, -0.10381380f, 0.10163694f, 
    -0.49641514f, 0.70453203f, -0.17832989f, 0.19527988f, -0.00726385f, 0.08417450f, -0.13336560f, -0.07613306f, 
    -0.10324579f, -0.09321401f, 0.13653991f, 0.18017894f, 0.00683748f, -0.02296313f, -0.02626413f, -0.32664567f, 
    -0.05317160f, -0.03544644f, 0.01795039f, 0.06237465f, -0.09951194f, 0.14087027f, 0.02827937f, 0.19043648f, 
    0.00654590f, 0.05763662f, 0.12317545f, -0.16183189f, -0.06094500f, 0.01974857f, 0.01158722f, 0.00689107f, 
    -0.09099913f, 0.05749354f, -0.09609900f, 0.05674399f, 0.11069974f, -0.14176236f, 0.18281960f, 0.27040750f, 
    -0.03104788f, -0.07837348f, -0.00643993f, -0.00054805f, 0.20872363f, 0.31567958f, -0.07603265f, 0.07545803f, 
    0.44098353f, 0.06749362f, -0.44988397f, -0.49645439f, -0.06044992f, -0.03846743f, 0.13009785f, -0.07736971f, 
    -0.02366522f, 0.07508574f, 0.01970072f, 0.11767688f, -0.14055918f, 0.11432549f, -0.34830043f, 0.09412171f, 
    -0.09678203f, 0.15149997f, 0.06753872f, -0.10727059f, -0.05399668f, -0.08411448f, 0.10424215f, 0.05141060f, 
    -0.25631827f, 0.07715188f, -0.05989106f, 0.29040915f, 0.10081660f, 0.04210896f, 0.05770602f, -0.03568218f, 
    -0.11259429f, -0.03964321f, 0.06072781f, -0.00554166f, 0.03002914f, -0.00237927f, 0.13177864f, 0.31203485f, 
    0.13466144f, 0.14003734f, 0.16261367f, 0.08660987f, -0.03091344f, 0.01559224f, 0.07014434f, -0.06609152f, 
    0.01405630f, 0.17644657f, -0.27517298f, 0.07131913f, -0.02429871f, 0.07901680f, -0.05216184f, 0.08094931f, 
    -0.07725377f, 0.04038210f, 0.02279479f, -0.00757453f, 0.03519681f, -0.02737352f, 0.04366138f, -0.02927927f, 
    0.00989616f, 0.02453469f, 0.06702845f, 0.02687907f, 0.04359871f, 0.15518884f, -0.02161181f, 0.00967924f, 
    0.15911607f, 0.02183609f, -0.13737622f, 0.09844315f, 0.21579450f, 0.01731700f, 0.07202962f, 0.10687242f, 
    -0.13706875f, -0.05784880f, 0.02956121f, -0.00908031f, -0.10766069f, -0.50039124f, 0.04077831f, 0.30763394f, 
    0.14835858f, 0.12095248f, -0.00134293f, -0.05317473f, -0.11973400f, -0.10596451f, -0.06137127f, -0.00945691f, 
    -0.30283728f, 0.26068711f, -0.12960753f, -0.07727344f, 0.22987841f, 0.09217770f, 0.18361010f, 0.02790104f, 
    -0.07262579f, 0.12907709f, 0.24170996f, 0.19576769f, 0.30914044f, -0.00852134f, 0.03899575f, -0.17505281f, 
    0.15123607f, -0.01823824f, 0.04784099f, -0.04510178f, -0.18681408f, 0.08744542f, -0.04121675f, 0.09705383f, 
    0.02133021f, -0.11107275f, 0.06126428f, -0.02262982f, 0.09555410f, 0.12638679f, 0.01159083f, 0.14529668f, 
    0.02380805f, -0.05986239f, 0.03506139f, -0.08670342f, 0.48359194f, -0.15651886f, 0.21909240f, -0.07348203f, 
    -0.11471875f, 0.04670958f, 0.00486448f, 0.25826946f, -0.05807895f, 0.14643529f, 0.03203659f, -0.10119148f, 
    -0.38073763f, 0.10473026f, -0.16146109f, 0.19896984f, 0.03173929f, -0.06471205f, 0.16395912f, 0.11971479f, 
    0.08055872f, 0.10345422f, 0.04195441f, -0.01271691f, 0.00735754f, 0.15094776f, -0.03937393f, -0.12717658f, 
    0.08003473f, -0.02493780f, 0.04436959f, -0.02832141f, -0.05393014f, 0.01427051f, -0.00339054f, 0.19313270f, 
    -0.00755881f, 0.12050495f, 0.09034877f, -0.15499507f, -0.19435558f, -0.00068699f, -0.06167947f, 0.11339258f, 
    0.09021239f, 0.06700160f, -0.02985311f, -0.07131994f, -0.34744865f, 0.26483956f, -0.02729641f, 0.10976198f, 
    0.10677498f, 0.07723898f, 0.17071193f, 0.17001691f, 0.08152895f, -0.03378793f, -0.14392816f, -0.02971605f, 
    -0.34263915f, 0.00277067f, -0.11194395f, -0.01728067f, -0.01173537f, -0.03841166f, 0.02526362f, -0.00831433f, 
    -0.05295370f, -0.10753406f, -0.06770281f, -0.06602558f, -0.01164185f, 0.02021323f, 0.32488310f, 0.14747007f, 
    0.02251043f, 0.07291811f, -0.11704230f, -0.00976275f, 0.03598594f, 0.07275442f, -0.01816126f, 0.01135560f, 
    0.02757060f, 0.30507183f, -0.13475657f, -0.25775963f, 0.05371981f, 0.12577067f, -0.02899771f, -0.09941953f, 
    -0.04073063f, -0.12112308f, 0.11916032f, 0.01971810f, -0.04578261f, -0.07186043f, 0.07661005f, 0.32980958f, 
    -0.06713682f, 0.01162195f, 0.06571633f, -0.03467670f, -0.06231989f, 0.00306813f, -0.02895621f, 0.13720436f, 
    -0.18483281f, 0.15067956f, -0.02530715f, 0.21462739f, 0.09066087f, 0.07378055f, 0.22821222f, 0.04085212f, 
    -0.08019983f, 0.10590176f, -0.00067201f, -0.01059728f, 0.16230863f, -0.08525240f, 0.31070542f, -0.08546026f, 
    -0.26523158f, 0.03243691f, 0.02532758f, -0.04186634f, -0.06802355f, 0.06728734f, -0.02697143f, -0.01885965f, 
    -0.09553137f, -0.04891221f, -0.11886747f, -0.26626906f, -0.00281915f, -0.02888668f, 0.00134588f, -0.08673014f, 
    0.00953792f, 0.07924809f, 0.01784514f, -0.04704965f, 0.05467214f, -0.32557374f, 0.61354285f, -0.18240200f, 
    -0.11366291f, -0.06701675f, -0.02959169f, 0.06394593f, -0.04762307f, 0.06028438f, 0.09151527f, -0.02562008f, 
    0.00785989f, 0.04422934f, 0.00799861f, 0.03374832f, 0.01427840f, -0.01681070f, 0.03001598f, -0.04787226f, 
    -0.01240095f, -0.03562468f, -0.05415585f, -0.02196686f, -0.01048368f, 0.03474478f, 0.04267284f, -0.05041186f, 
    0.00603789f, 0.01789741f, -0.02453197f, -0.00540928f, -0.02875372f, 0.00212651f, -0.01024675f, -0.05048007f, 
    -0.01770038f, -0.01741056f, -0.05049456f, 0.02107317f, -0.02008894f, -0.00744292f, -0.02093711f, -0.05669572f, 
    -0.03981066f, 0.01153172f, -0.01516625f, -0.04370015f, 0.03391049f, -0.02380959f, -0.03216696f, -0.02024676f, 
    -0.03968499f, 0.00137495f, -0.01822156f, -0.03595526f, 0.01645367f, -0.00565045f, 0.02316259f, 0.01174195f, 
    0.04701411f, 0.04265051f, 0.02803704f, -0.04800079f, -0.01201598f, 0.01042844f, -0.01368165f, 0.03481893f, 
    -0.03091613f, 0.02595891f, 0.01480675f, -0.03993009f, 0.00939828f, -0.00851149f, 0.04643235f, 0.01103844f, 
    -0.04013330f, -0.01913816f, 0.02394590f, 0.00467210f, 0.03714148f, -0.04341018f, -0.01925867f, 0.03438598f, 
    -0.04373746f, -0.00469803f, 0.01833261f, -0.02774982f, 0.00085728f, 0.03031106f, 0.00468107f, 0.00568976f, 
    0.01587661f, 0.01003330f, -0.03250277f, -0.02108965f, -0.01318419f, -0.01523108f, -0.04267826f, -0.04162969f, 
    -0.04827812f, -0.00981316f, -0.01536485f, -0.04864402f, -0.00424501f, 0.01681403f, -0.02343414f, -0.00438314f, 
    -0.00320623f, 0.00693250f, 0.00103716f, 0.01028540f, -0.03646987f, -0.02112127f, 0.00812979f, -0.01935602f, 
    -0.04744832f, 0.03341601f, -0.02620889f, -0.03477610f, -0.00857196f, 0.03787604f, -0.02587513f, -0.01376926f, 
    -0.02930208f, -0.03505823f, -0.05088906f, 0.02435296f, -0.03111003f, -0.05689562f, 0.01467542f, 0.02457031f, 
    -0.03704034f, 0.00636193f, 0.01156008f, -0.02980659f, -0.05357350f, -0.00357930f, -0.03010338f, -0.05688144f, 
    -0.04588260f, -0.00582457f, -0.02681920f, 0.01593422f, 0.03794365f, -0.04436839f, -0.00801982f, -0.00313126f, 
    -0.05560530f, -0.05075635f, 0.03274150f, -0.01111734f, -0.01001618f, 0.00571399f, 0.00215995f, 0.01161254f, 
    0.00594327f, -0.01122910f, -0.01784558f, 0.01378799f, -0.04054620f, -0.05143230f, 0.01094154f, 0.01037457f, 
    0.00644758f, -0.02909036f, 0.00417934f, -0.03182326f, -0.04327401f, 0.01868618f, -0.00192106f, -0.03552509f, 
    -0.00004454f, 0.04535151f, -0.02931558f, 0.01699568f, 0.03872305f, 0.02067848f, 0.02008016f, 0.02000033f, 
    -0.01673398f, 0.03032831f, 0.00049108f, -0.00215098f, -0.03232001f, -0.01773962f, 0.01523694f, 0.01555655f, 
    0.03525794f, -0.02159388f, 0.03895884f, 0.00700665f, 0.02803021f, -0.03737219f, -0.01712184f, -0.00619165f, 
    0.00917070f, -0.01363616f, 0.01141961f, -0.05111415f, -0.03757330f, 0.03200544f, 0.03662673f, -0.00489577f, 
    -0.00381422f, -0.04305786f, 0.02015598f, 0.01417390f, -0.00612885f, 0.01688334f, -0.02516275f, -0.00867130f, 
    -0.03189422f, 0.02048922f, 0.00901469f, -0.00530150f, -0.04809652f, 0.04113654f, 0.00252198f, 0.00163045f, 
    0.01390415f, 0.01180090f, 0.02051843f, 0.00120041f, -0.00632514f, -0.04367362f, 0.00898516f, 0.03742598f, 
    -0.01698978f, -0.02362775f, 0.04997836f, 0.00319353f, -0.03870470f, 0.02048986f, 0.04045136f, -0.02702175f, 
    -0.00793457f, 0.01166242f, -0.02118149f, -0.00971214f, -0.04613826f, -0.05182405f, -0.03608910f, 0.03942565f, 
    0.02550180f, -0.04155251f, -0.05597915f, 0.03325146f, 0.00775500f, 0.01228967f, -0.03213216f, 0.01481792f, 
    -0.02732129f, -0.03320440f, 0.00022349f, -0.04410391f, 0.01917144f, -0.01650568f, 0.02194629f, -0.05304612f, 
    0.03486362f, -0.05103277f, -0.04156940f, -0.03528082f, -0.05537506f, -0.05513274f, -0.01264788f, -0.04140713f, 
    -0.04009002f, 0.00650910f, -0.00646560f, -0.05133109f, -0.04463146f, -0.00636288f, -0.00452542f, -0.01241826f, 
    -0.02166202f, -0.04453089f, -0.02054770f, -0.00889228f, 0.02515561f, 0.00049277f, -0.01333738f, -0.04006584f, 
    -0.00795269f, -0.04900565f, 0.00301524f, -0.02015089f, -0.00072255f, 0.02325893f, 0.03922081f, -0.03408559f, 
    -0.00486865f, 0.01579628f, 0.03653004f, -0.04594612f, -0.02728606f, 0.01156976f, -0.01313837f, -0.04589663f, 
    0.04194575f, 0.01762399f, 0.00811333f, 0.00272771f, -0.01277323f, -0.03758311f, 0.01248802f, -0.00892850f, 
    0.00218366f, -0.03132442f, 0.02342584f, -0.02607178f, -0.03360662f, 0.00740283f, 0.01765945f, 0.02114585f, 
    0.00103784f, 0.02171158f, -0.03278238f, 0.02399050f, 0.02791583f, -0.00307093f, 0.00356537f, -0.02100465f, 
    -0.04587755f, -0.01979402f, 0.02833260f, -0.01709217f, -0.01780304f, 0.02159302f, 0.01055202f, -0.03960850f, 
    -0.01339894f, -0.03146942f, 0.00824455f, -0.00454247f, 0.00483251f, 0.00631971f, -0.01232250f, 0.02227524f, 
    -0.00115289f, -0.04650655f, 0.01729854f, 0.02275820f, -0.04618477f, 0.02229983f, 0.04433782f, -0.03748801f, 
    0.01578396f, -0.01970212f, -0.04346330f, 0.03034538f, -0.03907282f, 0.01024507f, 0.03257890f, -0.04125024f, 
    0.00117646f, 0.03508285f, -0.04263849f, 0.02725725f, -0.03022761f, -0.04976908f, 0.01069739f, -0.03586073f, 
    -0.01205389f, -0.03697747f, -0.04775732f, -0.02496214f, 0.04078292f, -0.00169801f, -0.00482694f, 0.02624751f, 
    0.04993359f, 0.01731190f, -0.04168408f, 0.02840092f, 0.00223344f, -0.04908502f, -0.02387786f, 0.01063577f, 
    -0.05545497f, 0.02018369f, 0.01948703f, -0.00829390f, -0.02032169f, -0.03453156f, -0.04201938f, -0.00558949f, 
    -0.02819074f, -0.00877279f, -0.03145625f, -0.04886321f, -0.03320608f, -0.03526982f, 0.01761132f, -0.02318133f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.01487948f, 0.01675876f, 0.18707991f, -0.17844684f, 0.01152929f, 0.13002470f, 0.04936025f, 0.02357612f, 
    -0.03118918f, -0.02585207f, 0.22278719f, -0.03183473f, -0.05121900f, 0.04731844f, 0.12431919f, -0.23465286f, 
    -0.00894545f, -0.03053499f, -0.04637792f, 0.03361920f, 0.23148727f, -0.17692554f, 0.02430210f, -0.01527359f, 
    0.09740073f, 0.13208507f, 0.14263278f, 0.17148325f, -0.00577514f, 0.12973982f, 0.14635773f, 0.00181952f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.09859473f, 0.13492736f, 0.07026145f, 0.02112623f, 0.19952929f, 0.31344199f, 0.02979370f, -0.12677848f, 
    0.50439584f, 0.07965320f, 0.03144782f, -0.31577653f, 0.15911914f, -0.21388337f, -0.16547744f, -0.10741564f, 
    0.15058313f, -0.01561242f, 0.01219921f, -0.21965486f, 0.21149585f, 0.20991771f, -0.39172751f, -0.24041393f, 
    -0.14262795f, 0.27699143f, -0.27466792f, -0.12398511f, 0.00096731f, 0.02967938f, -0.08894204f, -0.14747661f, 
    -0.07934865f, 0.00391080f, 0.22216572f, -0.13654424f, 0.00582244f, 0.21718922f, -0.25957954f, -0.00700020f, 
    -0.15869148f, -0.09166675f, 0.30046636f, -0.07635170f, 0.35955831f, -0.03957608f, -0.05387867f, 0.17082100f, 
    -0.22029243f, 0.08272733f, -0.11250897f, -0.02094228f, 0.11770667f, 0.00276281f, 0.07966232f, -0.02690256f, 
    -0.08641516f, 0.33592865f, 0.24675424f, -0.01601651f, 0.31223348f, 0.01541658f, -0.32331076f, 0.13860899f, 
    0.17348932f, -0.13365003f, -0.05203109f, 0.05726090f, -0.17383890f, -0.01331985f, -0.06814129f, 0.13471200f, 
    0.00111826f, -0.06058282f, 0.04927182f, 0.02810286f, -0.10729924f, -0.10783336f, 0.05281691f, -0.04502387f, 
    0.14668562f, 0.00661819f, -0.15203039f, -0.07024906f, 0.02285506f, 0.09890730f, -0.08608199f, -0.15981276f, 
    -0.10139851f, 0.10508040f, -0.11318756f, -0.18312983f, -0.02524564f, -0.14151773f, -0.09592996f, -0.11900138f, 
    0.17465048f, 0.12095388f, -0.29727551f, -0.01964786f, -0.18104836f, -0.19065398f, 0.14229442f, 0.03956793f, 
    -0.06265621f, -0.14862239f, -0.33955839f, -0.03427615f, -0.16002314f, 0.19271751f, -0.06341047f, 0.12618330f, 
    0.12574594f, -0.07315087f, 0.15403746f, -0.14105327f, -0.21178502f, 0.28094640f, 0.00348479f, -0.24108340f, 
    0.19586815f, -0.22314136f, -0.18735541f, -0.23543535f, -0.16253197f, -0.17553674f, 0.13274604f, 0.00972737f, 
    -0.00221844f, -0.09981964f, -0.00711224f, 0.03163516f, 0.00203373f, -0.22049771f, 0.10204171f, 0.15994598f, 
    -0.16882937f, -0.05757049f, 0.08223007f, -0.09293605f, 0.16162142f, 0.01669770f, -0.03062410f, -0.17268209f, 
    -0.22587256f, -0.02114052f, -0.12871569f, 0.01042075f, -0.10239045f, 0.10976160f, 0.03978361f, -0.14369729f, 
    -0.08709154f, -0.02230272f, -0.10781456f, -0.23467463f, -0.08557843f, 0.04841835f, 0.09829471f, -0.04678294f, 
    -0.01963634f, 0.08954294f, 0.18437426f, 0.35217524f, -0.15661786f, -0.21555302f, -0.28813648f, 0.11780072f, 
    0.08128631f, -0.36672646f, 0.03213831f, -0.43958038f, 0.26767644f, -0.00900340f, 0.02606451f, -0.08127024f, 
    0.10461578f, 0.16001727f, 0.14287986f, 0.36197981f, 0.05744733f, 0.11339793f, 0.30581892f, 0.18509312f, 
    0.08067175f, 0.09292507f, -0.14077999f, 0.02299942f, 0.11627195f, -0.15530908f, 0.18628411f, 0.14553393f, 
    -0.13436915f, -0.12279278f, 0.05597645f, 0.34178403f, 0.23221348f, 0.18603724f, -0.19216339f, -0.10323338f, 
    0.06773059f, 0.02812503f, 0.12417157f, -0.03654693f, 0.25180092f, -0.32288244f, -0.25787187f, 0.06926738f, 
    0.10303779f, -0.16527283f, 0.01606596f, 0.34479088f, 0.13330550f, 0.33586669f, -0.09458931f, -0.18658164f, 
    0.07060143f, 0.32809079f, -0.24962766f, 0.51620847f, 0.00542523f, -0.27420065f, 0.19162817f, -0.11197781f, 
    0.17964466f, 0.10908438f, 0.31683290f, 0.29737750f, -0.03695328f, -0.04431313f, -0.07786766f, 0.04499214f, 
    -0.20742717f, -0.24305426f, 0.09008857f, -0.43516177f, 0.01084103f, 0.08740424f, -0.20730789f, -0.08334050f, 
    -0.32472605f, -0.15582268f, 0.12225337f, 0.25251421f, 0.17327023f, 0.11532668f, 0.18090007f, -0.02206523f, 
    -0.13095711f, 0.27209407f, -0.27675515f, 0.41874275f, 0.60320848f, 0.20765641f, 0.24356216f, 0.09930547f, 
    -0.08887400f, -0.09386324f, -0.06774989f, -0.24121681f, -0.05453625f, 0.20888481f, -0.06975246f, -0.08397651f, 
    -0.24701375f, -0.24964659f, 0.27406099f, 0.37797987f, 0.14923842f, -0.02328693f, 0.09862947f, -0.24827325f, 
    0.10389976f, -0.04012719f, 0.12874322f, 0.21323037f, 0.26679233f, -0.00295779f, 0.00333681f, -0.15992956f, 
    -0.16536489f, 0.24162664f, 0.27916631f, 0.08009008f, 0.10769664f, -0.13810430f, -0.19361557f, -0.09726055f, 
    0.12050188f, -0.09722163f, 0.17222264f, 0.12017497f, -0.19454372f, 0.14738165f, -0.13994403f, -0.09742700f, 
    -0.43860692f, -0.32957023f, -0.26265597f, -0.14065218f, -0.02480035f, -0.34010491f, 0.17803386f, 0.00700673f, 
    0.10428894f, -0.15913633f, -0.06205462f, -0.13632889f, -0.19498348f, -0.07396402f, 0.33622229f, 0.16965742f, 
    -0.09235892f, -0.13163058f, 0.21926674f, 0.23983124f, 0.30750287f, -0.06169141f, 0.00376323f, -0.01438887f, 
    0.11499462f, 0.13249344f, -0.01086990f, -0.44660231f, 0.19393930f, -0.21862315f, -0.13878210f, -0.02387028f, 
    -0.23657335f, 0.09688567f, 0.07799806f, 0.21182369f, -0.36605960f, 0.25801000f, -0.05259721f, -0.24753501f, 
    0.19628985f, -0.16928186f, -0.06032389f, 0.28092307f, 0.16261111f, 0.02126892f, -0.08079719f, 0.18187684f, 
    0.09478018f, -0.04134674f, -0.11358966f, 0.24223715f, 0.11093972f, 0.21786818f, 0.28850222f, -0.16220297f, 
    -0.03059847f, -0.14339861f, 0.15820771f, -0.34661946f, 0.17872591f, 0.28350607f, 0.27637237f, -0.01525481f, 
    0.40339962f, -0.22207692f, 0.34338000f, -0.05013185f, 0.19694224f, 0.02771869f, 0.19683307f, -0.35177040f, 
    -0.17029837f, -0.08041169f, -0.13344154f, -0.55320317f, 0.18797266f, -0.22695413f, -0.06018691f, -0.09386954f, 
    -0.19845103f, 0.16664343f, 0.21195768f, -0.20131360f, -0.06289042f, 0.21444458f, -0.05845401f, 0.08153400f, 
    -0.07927291f, -0.04995603f, -0.02207893f, 0.15434699f, 0.18606290f, -0.20343548f, -0.38606024f, -0.15483969f, 
    -0.22866410f, -0.39717281f, -0.32423103f, 0.13842972f, -0.11321277f, -0.09129626f, 0.18936059f, -0.25217056f, 
    0.20713726f, 0.06694009f, 0.08911341f, 0.55631387f, 0.09077427f, -0.10379492f, 0.20240536f, 0.38832840f, 
    0.36965969f, -0.15095687f, 0.16519332f, 0.05740211f, -0.19300847f, -0.33434772f, 0.28330302f, -0.00386775f, 
    -0.13141343f, 0.08037752f, -0.16210192f, 0.03682907f, -0.08739273f, -0.19718204f, -0.17273892f, -0.11510217f, 
    -0.13930704f, -0.02318112f, -0.10231246f, 0.02843921f, 0.09309632f, -0.12736157f, -0.11359739f, -0.01358447f, 
    0.00423664f, 0.11325104f, 0.16528842f, -0.08851729f, -0.19966270f, -0.02200952f, -0.25891760f, 0.14937539f, 
    -0.03295664f, -0.01686888f, -0.08187176f, -0.15461852f, 0.00667897f, 0.00319594f, 0.04700710f, 0.15881923f, 
    -0.16227777f, -0.09584939f, 0.28601193f, -0.06814785f, -0.12490802f, 0.26836964f, 0.14109758f, 0.14176717f, 
    -0.21680401f, -0.19012073f, -0.24438953f, 0.12704700f, -0.03597807f, -0.10251336f, -0.06670951f, -0.03678461f, 
    -0.13653827f, -0.15271150f, -0.07652950f, -0.00028639f, 0.03857098f, -0.14572465f, 0.25259113f, -0.24653789f, 
    0.35505316f, 0.25358003f, 0.05462277f, 0.07418213f, -0.37830046f, 0.26249388f, 0.11786532f, 0.12847371f, 
    0.17417735f, -0.10275634f, 0.27755752f, -0.29115766f, -0.08754552f, 0.17679127f, 0.20921263f, -0.10442878f, 
    0.14399263f, -0.28625083f, -0.24026047f, -0.18101472f, -0.07276177f, 0.26033312f, -0.06948636f, 0.00878064f, 
    -0.10404592f, -0.10077456f, 0.03872863f, 0.09260984f, 0.29524949f, -0.24686502f, 0.03285823f, 0.12714761f, 
    -0.21755224f, 0.09106238f, 0.16724786f, 0.22636807f, 0.35514030f, 0.13780318f, -0.20675927f, 0.07734762f, 
    -0.00448619f, 0.02014672f, 0.22643295f, -0.48844919f, -0.02503062f, 0.03840834f, -0.27204072f, -0.05042617f, 
    -0.10674378f, 0.17254283f, 0.13901249f, 0.06013883f, -0.11591212f, -0.13406375f, 0.28624910f, -0.40637922f, 
    0.21125205f, 0.00389991f, 0.10815111f, 0.12900737f, 0.39692581f, -0.17428657f, 0.15554278f, 0.05303483f, 
    0.41524157f, 0.11353087f, 0.30820724f, -0.04903461f, -0.25640321f, 0.11255621f, 0.40800434f, -0.17789759f, 
    -0.16177098f, 0.07843575f, 0.02937620f, -0.33053243f, 0.12799269f, -0.12905109f, 0.00982239f, -0.11292569f, 
    -0.02626117f, -0.00964163f, 0.38256645f, 0.16072553f, -0.06003203f, 0.06610288f, -0.04091991f, 0.14433496f, 
    -0.09414387f, -0.07673337f, -0.01097845f, -0.12441504f, -0.00331188f, -0.13728108f, 0.15129495f, -0.17819308f, 
    -0.16936393f, -0.35009921f, -0.00051088f, 0.04421055f, 0.09910351f, 0.02823910f, -0.15098222f, 0.12889364f, 
    0.11928673f, -0.15549938f, 0.09981715f, 0.51507843f, 0.35145965f, 0.00975091f, -0.28052136f, -0.13546392f, 
    0.44832382f, 0.23359291f, 0.04104041f, -0.12639232f, 0.40146285f, -0.10203734f, -0.00441278f, 0.16670430f, 
    0.08339377f, -0.12395032f, 0.05559186f, -0.14789933f, -0.08157024f, -0.00406796f, -0.25278923f, 0.25205401f, 
    -0.04059075f, 0.12513955f, -0.06979641f, -0.07868315f, 0.31409222f, -0.14747253f, 0.07195295f, 0.15049493f, 
    0.05074883f, -0.09298107f, 0.16921571f, 0.03550936f, 0.29406878f, 0.13776451f, 0.28253987f, 0.17665057f, 
    0.17573106f, -0.52565044f, -0.14726235f, 0.39925444f, 0.28684220f, -0.40711066f, -0.31674251f, -0.07240780f, 
    0.18918668f, 0.01556128f, 0.04123085f, 0.02814005f, -0.13975434f, 0.43294176f, -0.13196953f, -0.12110682f, 
    0.01882175f, -0.04974477f, -0.31096545f, -0.22731462f, 0.10051437f, 0.01141437f, -0.11335151f, 0.10482281f, 
    -0.12218687f, 0.03629247f, -0.05873562f, -0.01800393f, 0.09462950f, 0.39764157f, 0.47479656f, -0.18952614f, 
    -0.01122985f, -0.13189785f, 0.16038683f, 0.17143764f, -0.04926138f, 0.12154701f, -0.21620888f, -0.16939734f, 
    0.24515384f, -0.15114182f, -0.17230904f, 0.28782395f, -0.04425279f, 0.16380884f, -0.20891890f, -0.25516739f, 
    -0.12885293f, 0.29676288f, -0.16813892f, 0.24179587f, -0.09369377f, -0.02667103f, 0.12319656f, 0.03207242f, 
    0.00091545f, 0.01278843f, -0.09194571f, 0.31259105f, -0.05982047f, 0.15052129f, 0.61861950f, 0.03384772f, 
    -0.29093149f, -0.01039591f, -0.30103400f, 0.00638666f, -0.13199693f, -0.42154223f, -0.19053774f, 0.05646794f, 
    0.08499496f, -0.09992508f, -0.08020152f, -0.08860561f, -0.16249712f, 0.30317599f, 0.17780840f, 0.12725469f, 
    -0.07685684f, -0.00761353f, 0.26382059f, 0.08823444f, -0.12922759f, 0.07514390f, 0.28871921f, 0.15511771f, 
    0.07220598f, 0.07558334f, -0.04162006f, 0.10782541f, 0.04489314f, -0.19441220f, 0.17634307f, -0.00115379f, 
    0.03574616f, -0.07728254f, 0.22453895f, -0.00597191f, -0.24226809f, -0.11379896f, -0.11642032f, 0.15970258f, 
    -0.03907840f, -0.01075419f, -0.11058336f, -0.09908517f, -0.12416357f, -0.08843097f, -0.08922037f, -0.03591641f, 
    -0.22048800f, -0.20889138f, 0.07535186f, -0.07126988f, -0.15017974f, -0.00983423f, -0.23791908f, -0.11278151f, 
    0.03292428f, 0.05552618f, 0.25219187f, 0.18598285f, -0.21490386f, 0.15117049f, -0.21959542f, 0.13505769f, 
    0.28667298f, 0.21363623f, -0.36255944f, -0.34291491f, -0.13856883f, 0.07294677f, 0.08435489f, -0.12971312f, 
    -0.35530394f, 0.00076840f, 0.06773151f, -0.09623976f, 0.29542947f, -0.42007437f, 0.06841191f, 0.07434103f, 
    0.06806818f, 0.08420490f, -0.06984957f, 0.35033190f, 0.31063238f, 0.08017041f, -0.14661321f, 0.06450134f, 
    -0.05070511f, -0.00287814f, 0.06933542f, 0.25132355f, -0.17727555f, 0.26353303f, -0.33961913f, -0.08174786f, 
    -0.43400541f, -0.11401898f, -0.26442993f, 0.04699836f, 0.18703248f, -0.27676615f, -0.00353109f, -0.30172166f, 
    -0.01627867f, -0.10744014f, -0.05463273f, 0.10207257f, 0.09756055f, 0.17203113f, 0.14158265f, 0.04939237f, 
    -0.05570133f, 0.22365476f, 0.27545187f, 0.24253380f, 0.03046283f, -0.65278083f, -0.11989595f, -0.16961534f, 
    -0.03705315f, 0.07762925f, -0.10900415f, 0.12080774f, 0.10997563f, 0.30075294f, -0.03595319f, 0.01036044f, 
    0.20868808f, 0.19365269f, -0.30447179f, -0.07385005f, 0.10345203f, -0.35813621f, 0.15125212f, 0.11957119f, 
    0.03959800f, 0.10610568f, 0.09381644f, -0.20944458f, -0.02946601f, 0.12199745f, -0.10797156f, 0.33365464f, 
    0.22206956f, -0.16548821f, 0.25032827f, -0.25855556f, -0.36235732f, -0.12409421f, 0.15386328f, -0.03259481f, 
    -0.08320087f, 0.13257760f, -0.06991772f, 0.11900494f, -0.00028785f, 0.02704703f, -0.00820465f, -0.14945921f, 
    -0.11277629f, 0.10039432f, -0.06808107f, 0.02062869f, -0.07576749f, 0.07528928f, 0.09579723f, -0.16378789f, 
    -0.14489964f, 0.08367636f, -0.12307393f, 0.08149114f, -0.12519659f, 0.00783010f, -0.08083491f, -0.10780904f, 
    -0.14179634f, -0.01409542f, -0.17108966f, -0.09668368f, 0.00128172f, -0.03836180f, -0.00131990f, 0.02741724f, 
    -0.10680249f, 0.06232538f, -0.25434396f, -0.33965805f, 0.13874978f, -0.09854525f, 0.02754859f, -0.06396449f, 
    0.11983782f, 0.13608171f, 0.02095791f, -0.20639353f, -0.19624843f, 0.02720775f, 0.05931382f, -0.14630067f, 
    -0.13614735f, -0.07879438f, -0.06744475f, -0.33045983f, -0.07334646f, 0.10488338f, 0.06075340f, -0.02433048f, 
    -0.15787335f, -0.03353469f, -0.02343480f, 0.02861247f, -0.00435180f, -0.00580011f, -0.02840922f, -0.05595673f, 
    -0.15654789f, -0.05197763f, -0.09159816f, -0.24111107f, -0.03170393f, 0.05492073f, 0.60301572f, -0.03282603f, 
    0.10105502f, 0.06837413f, -0.18352471f, -0.30714521f, -0.47051787f, -0.16715242f, 0.23596713f, -0.19553995f, 
    -0.19242680f, 0.00363983f, 0.10347765f, -0.17785156f, 0.04489543f, 0.10966397f, 0.05070140f, 0.15095863f, 
    0.13895072f, 0.03865784f, 0.11484896f, 0.31013310f, -0.04348094f, 0.35109505f, 0.48275909f, -0.13735561f, 
    -0.05838584f, -0.16864769f, -0.02149853f, 0.08228385f, 0.20652819f, -0.03280153f, 0.12188584f, 0.17177087f, 
    -0.05441801f, -0.09762102f, 0.37408146f, -0.10717128f, 0.19083501f, 0.03688917f, 0.21652314f, -0.05575856f, 
    0.07879305f, -0.17452437f, -0.16866678f, -0.28512967f, -0.06566434f, 0.17670029f, 0.11770216f, 0.07718701f, 
    0.13297701f, -0.22016357f, 0.36778614f, -0.39778322f, -0.24996693f, -0.00313532f, 0.00009393f, -0.13624120f, 
    0.11041691f, -0.01778627f, 0.05521148f, -0.24273972f, 0.29064468f, 0.06848650f, 0.13845441f, 0.01073674f, 
    -0.22261319f, -0.17980301f, 0.31681240f, 0.27614719f, -0.16675836f, 0.09339759f, -0.05368054f, -0.22429895f, 
    0.01267239f, 0.14765981f, 0.06488346f, 0.35366455f, 0.38764724f, -0.07840557f, -0.08236931f, -0.22482786f, 
    -0.10601310f, 0.00157185f, -0.21312219f, 0.27344784f, -0.15347844f, 0.02275408f, 0.17038149f, 0.00976231f, 
    -0.13592143f, -0.02665588f, 0.15008430f, -0.13700321f, -0.13273776f, -0.17225599f, -0.07262420f, -0.03648516f, 
    -0.04650511f, -0.10081890f, -0.15753838f, -0.16771057f, 0.06312847f, -0.02895066f, -0.17350972f, 0.02468946f, 
    -0.06193453f, -0.17496553f, -0.05988055f, -0.11208694f, 0.04121456f, -0.06296366f, -0.16710085f, 0.12815873f, 
    -0.09651020f, -0.10045438f, -0.17440476f, -0.06759317f, 0.04601400f, -0.24096535f, 0.05404538f, -0.17359726f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.11038863f, 0.03221335f, 0.10271245f, -0.15554360f, 0.01789020f, 0.04489913f, -0.01325510f, 0.13386123f, 
    -0.02608216f, 0.09164195f, 0.19081067f, 0.18756953f, 0.07714079f, 0.07548101f, 0.20037809f, 0.06440199f, 
    0.30642340f, -0.19745252f, 0.16288681f, -0.17962657f, 0.16370480f, -0.11552584f, -0.09928972f, 0.17480700f, 
    0.03503609f, -0.10247697f, -0.02052884f, -0.04641452f, 0.07414988f, 0.18736984f, 0.16600931f, -0.07402033f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.19851160f, -0.10692485f, -0.14364234f, 0.12517028f, -0.10299623f, 0.00314480f, 0.16617420f, 0.04338106f, 
    -0.23881330f, 0.12921630f, -0.06928404f, -0.06316607f, -0.67230558f, 0.10356120f, -0.55369568f, -0.32290047f, 
    -0.54749393f, 0.05497742f, 0.31348071f, 0.28055537f, 0.10834756f, 0.09975739f, -0.07862812f, -0.37229514f, 
    -0.06847846f, 0.10711452f, -0.09692646f, 0.09672166f, -0.33979735f, -0.17040661f, -0.45589849f, 0.06631996f, 
    0.17857291f, 0.06126100f, -0.05315887f, 0.01425571f, 0.03518771f, -0.56333184f, -0.11501004f, -0.31343040f, 
    0.41336107f, 0.05600137f, -0.01632424f, 0.36673623f, -0.11221947f, -0.00143408f, -0.00466071f, -0.04562501f, 
    0.22727832f, -0.03459147f, -0.11777759f, 0.39432383f, 0.13233826f, -0.15242259f, 0.01998463f, -0.45883071f, 
    -0.39440039f, 0.06680301f, -0.13460751f, -0.07555081f, 0.02867622f, 0.18949501f, 0.23816797f, 0.08392633f, 
    -0.47411221f, 0.05747802f, 0.13849185f, 0.02613689f, -0.18187580f, -0.28540310f, 0.18473029f, -0.27765602f, 
    0.40543705f, 0.04619328f, 0.07261753f, -0.17975411f, 0.04811649f, 0.00510139f, 0.32687208f, -0.02908171f, 
    0.10666341f, 0.04386213f, -0.44327003f, -0.59982473f, 0.28389513f, 0.21784787f, -0.27694950f, -0.01204946f, 
    0.50993431f, 0.15510438f, 0.11227766f, -0.29543358f, -0.06639998f, -0.30169004f, -0.03106699f, -0.01952416f, 
    -0.15282924f, -0.20151852f, -0.09203901f, -0.23082793f, -0.08571414f, 0.14763962f, 0.21316375f, 0.21926975f, 
    -0.52238983f, -0.07068369f, -0.08182864f, -0.40680307f, 0.11174495f, -0.04757115f, 0.01715790f, -0.61097336f, 
    -0.15507504f, -0.34028092f, -0.04834215f, 0.12723345f, 0.06465515f, 0.42143601f, -0.20919915f, -0.19869149f, 
    0.05649167f, 0.09707141f, -0.06662297f, -0.44134161f, 0.31194732f, -0.03949588f, -0.12820356f, -0.10095298f, 
    -0.02502483f, 0.27555802f, 0.18217532f, -0.20031747f, 0.01282164f, 0.01410963f, 0.22681566f, 0.23940116f, 
    0.26555040f, -0.73936278f, -0.06658286f, -0.41072243f, -0.08218128f, 0.01818160f, -0.17646743f, -0.04755249f, 
    -0.14605242f, 0.05328418f, 0.07642017f, -0.07432661f, 0.10151865f, -0.13658459f, 0.03595179f, -0.04404762f, 
    0.21444777f, -0.26709214f, -0.19462194f, -0.19606659f, -0.48695982f, 0.00538708f, 0.17469946f, -0.12279230f, 
    0.23447426f, 0.06845408f, 0.06460468f, -0.05505718f, -0.11970609f, -0.20640682f, 0.04950658f, -0.00917689f, 
    -0.18027267f, -0.43791446f, -0.21093783f, 0.26924759f, -0.46682757f, 0.09675986f, -0.05188910f, 0.04493952f, 
    0.08949302f, -0.02180919f, 0.27463067f, -0.27632511f, -0.07022880f, -0.41250169f, -0.09591908f, 0.48605546f, 
    -0.07538962f, 0.30549839f, -0.00789964f, -0.32482365f, -0.03036837f, 0.04418989f, -0.29741320f, 0.08756573f, 
    -0.32053524f, -0.07642707f, 0.09231131f, -0.13299175f, 0.03536778f, 0.27692795f, -0.62049425f, 0.24316624f, 
    0.04306600f, 0.26236826f, 0.19869675f, -0.28769839f, 0.04166277f, 0.13261034f, 0.18521008f, 0.30585569f, 
    0.12068313f, -0.00128815f, -0.82135201f, -0.38896650f, -0.69579405f, -0.42735994f, -0.26948553f, 0.20415634f, 
    -0.06529822f, -0.39542329f, 0.07177419f, 0.00336373f, 0.23496859f, -0.10236556f, -0.35277250f, -0.03054322f, 
    -0.25909954f, 0.02669184f, 0.09964895f, -0.64590013f, 0.03937820f, 0.00712546f, -0.72965777f, -0.54078251f, 
    0.01072963f, 0.36353421f, -0.53088045f, -0.26810858f, 0.24406746f, 0.11308274f, -0.32880092f, -0.00058132f, 
    -0.20965287f, 0.18495779f, 0.05029139f, -0.37680736f, -0.21483915f, 0.52257514f, 0.17664693f, -0.14775622f, 
    0.42674321f, 0.26837042f, 0.11871076f, -0.08477845f, -0.07809351f, 0.20744021f, -0.15263252f, -0.01226684f, 
    -0.01959053f, -0.52587509f, -0.10107475f, -0.08321014f, -0.14003728f, -0.16226672f, -0.55974120f, -0.66237837f, 
    -0.64229441f, -0.08347980f, -0.09352506f, 0.06353796f, -0.19564046f, -0.09773801f, 0.28507638f, 0.06367137f, 
    0.12969014f, -0.11989271f, -0.42897567f, -0.21669258f, 0.15387951f, 0.29995728f, -0.15329927f, 0.13951324f, 
    -0.47508875f, 0.22375765f, 0.14886494f, 0.08978422f, 0.46435153f, 0.14108430f, -0.64724505f, -0.06375085f, 
    -0.48743522f, 0.36412483f, -0.06675358f, -0.28133842f, 0.08249930f, 0.34035188f, -0.14706606f, 0.22859582f, 
    0.28535375f, 0.16615385f, -0.41575295f, 0.16444251f, -0.20126079f, -0.13953118f, 0.12860298f, 0.32361335f, 
    -0.22966911f, -0.23213917f, -0.18966337f, -0.06951285f, -0.03097932f, -0.28580999f, -0.29800758f, 0.22345476f, 
    0.27277473f, -0.34289816f, -0.06160393f, -0.04771231f, -0.52046466f, -0.02735434f, -0.29738027f, 0.05735100f, 
    -0.04695249f, -0.37025562f, 0.10226154f, -0.33652437f, -0.22693200f, -0.50716889f, -0.03256112f, 0.18511924f, 
    -0.11794687f, -0.18626519f, 0.25767061f, 0.05401959f, -0.25153241f, 0.04923048f, -0.21096863f, 0.33858094f, 
    -0.15940320f, -0.63701153f, -0.26369813f, -0.19967446f, 0.22610292f, 0.18363200f, -0.01299996f, 0.19530876f, 
    -0.51874310f, -0.33650431f, 0.18400930f, -0.09870145f, 0.40718493f, -0.34191445f, 0.58425462f, 0.08996603f, 
    -0.30393952f, -0.51786715f, -0.08199623f, -0.34535345f, 0.00199477f, 0.31474489f, -0.08767194f, -0.16539694f, 
    -0.36995918f, -0.27888292f, 0.35360578f, -0.20842375f, 0.49579561f, 0.09737173f, -0.12557785f, -0.07424727f, 
    0.28267753f, -0.53336018f, 0.10050380f, -0.09655938f, -0.14176784f, -0.53994250f, 0.07068394f, -0.21378846f, 
    -0.49010733f, 0.14225650f, -0.00118736f, -0.31860727f, -0.11000440f, 0.09315337f, 0.40700498f, 0.09506276f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.38441792f, 0.03181229f, 0.17333882f, -0.13642389f, -0.04472034f, 0.17968193f, 0.19083039f, -0.05321919f, 
    0.15853393f, 0.04140651f, -0.02844620f, 0.04997961f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
