#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.52576852f, -0.69797707f, 0.46927655f, -0.26644170f, 0.25709322f, 0.20741485f, -0.14419663f, -0.61286134f, 
    -0.19383660f, 0.69062483f, -0.20110959f, 0.05012950f, -0.00114762f, 0.16025518f, -0.07119530f, 0.12420975f, 
    -0.01374567f, 0.04738641f, 0.05690541f, -0.39157459f, -0.18241183f, 0.30484292f, -0.17656358f, 0.01169654f, 
    0.20973383f, -0.86105990f, -0.54622602f, -0.05854193f, 0.91109741f, 0.56425005f, -0.49715060f, -0.99572867f, 
    -0.22161119f, 0.81538332f, 0.65769452f, 0.25881872f, -0.18369713f, -0.20455156f, 0.26162601f, -0.00364344f, 
    -0.16718988f, 0.36614129f, 0.20749503f, -0.00507523f, -0.46646771f, -0.06422000f, -0.05183308f, 0.16918017f, 
    -0.01185958f, -0.04926930f, -0.75034285f, 0.11302773f, 0.19206080f, 0.17800711f, 0.06540240f, -0.84071964f, 
    -0.44061375f, 0.04660921f, -0.17044416f, -0.71176177f, 0.43039614f, -0.17266209f, -0.43632498f, 0.38572890f, 
    -0.34873042f, 0.44184420f, -0.53232652f, -0.62217069f, -0.54981631f, -0.59033936f, 0.03622125f, 0.20296960f, 
    -0.23526782f, 0.31528559f, 0.19669871f, 0.47260168f, 0.04363361f, -0.00509635f, 0.32369938f, 0.23131409f, 
    0.57398146f, 0.37978980f, 0.06151129f, -0.48875311f, -0.30024508f, -0.25541988f, -0.01407928f, 0.06925967f, 
    -0.34368971f, 0.28466317f, 0.18286729f, 0.02628499f, 0.09284553f, -0.13063537f, -0.22224426f, -0.16695486f, 
    -0.42049217f, -0.37468076f, -0.07796820f, 0.23923533f, 0.97347754f, 0.61622953f, -0.01120771f, -0.41039854f, 
    -0.24196069f, 0.41282827f, 0.27969846f, -0.03249798f, -0.28923669f, -0.10875132f, 0.24117385f, 0.01163333f, 
    -0.00433135f, -0.33813438f, 0.06026737f, -0.01624987f, -0.08981640f, 0.28772619f, -0.17496416f, -0.60582036f, 
    -0.17774123f, -0.11329741f, -0.32763579f, -0.14306830f, -0.17871611f, 0.58703637f, 0.33472154f, 0.31120941f, 
    0.25117964f, 0.34165072f, -0.63602656f, -0.09505329f, 0.14631735f, 0.17473543f, 0.34392393f, -0.01732609f, 
    0.03087787f, 0.18135549f, -0.40738171f, -0.42578265f, 0.17641290f, -0.14341378f, 0.22830768f, -0.21038726f, 
    -0.17967483f, -0.13246432f, 0.04453630f, 0.11352146f, 0.08159755f, -0.11325417f, 0.47286543f, 0.49088693f, 
    -0.11541093f, -0.08039147f, -0.35318473f, 0.08573544f, 0.11171202f, 0.12737197f, -0.06049314f, -0.09765049f, 
    -0.56719798f, -0.14185545f, 0.49242043f, 0.04737977f, -0.13515000f, -0.02736292f, 0.16563451f, -0.03053633f, 
    -0.38594347f, 0.26231545f, -0.01147167f, -0.16214651f, -0.09776814f, -0.32177958f, 0.26252511f, 0.13177508f, 
    -0.03797579f, 0.34120446f, 0.40181583f, 0.26261261f, -0.08910598f, -0.03507961f, -0.16223760f, 0.18027663f, 
    -0.31169590f, 0.24534807f, 0.31630087f, 0.36078793f, 0.11752529f, 0.20591708f, 0.03315010f, 0.15479773f, 
    -0.08386411f, -0.07522276f, 0.17352715f, -0.26746631f, 0.36637136f, 0.29937902f, -0.02491797f, -0.14616922f, 
    0.10069688f, 0.66835397f, -0.15121435f, -0.45795116f, -0.03329505f, 0.14832549f, -0.37856534f, 0.16510312f, 
    0.53650111f, -0.45503506f, -0.49948516f, -0.41341031f, 0.08552312f, 0.16612296f, 0.06652576f, 0.21074802f, 
    -0.00993563f, -0.31814909f, -0.12364142f, -0.10766251f, -0.14668193f, 0.17251915f, -0.04080184f, 0.32082209f, 
    0.27785283f, 0.73893768f, -0.56346649f, -0.09399340f, -0.14903240f, -0.28808892f, 0.35658938f, -0.02287911f, 
    0.20345168f, -0.14802447f, 0.37115473f, 0.00146621f, 0.14486325f, 0.00163973f, -0.15253244f, -0.30196881f, 
    -0.20119864f, -0.42772326f, 0.54892826f, 0.30648297f, 0.14380427f, 0.40408722f, -0.29027739f, -0.42247272f, 
    -0.01165012f, 0.22582071f, -0.73942691f, 0.92662889f, 0.17062837f, -0.24853113f, -0.34715733f, -0.42019650f, 
    -0.49042121f, 0.45682919f, 0.14982368f, 0.48387018f, 0.39055192f, -0.54974604f, -0.34553018f, -0.29238254f, 
    0.12111880f, -0.08521168f, -0.11103539f, -0.19187611f, 0.52106988f, 0.04161246f, -0.08222848f, -0.04140203f, 
    0.33646718f, 0.10876263f, -0.05170570f, -0.94255203f, -0.51328582f, -0.68904752f, 0.14174159f, 0.72378588f, 
    0.77712655f, 0.36036614f, 0.19115524f, 0.07341226f, 0.11406139f, 0.54926908f, -0.01572271f, 0.14254388f, 
    0.06102903f, 0.42803875f, -0.37686193f, 0.19902523f, -0.40457568f, -0.36921898f, 0.16991718f, 0.12620707f, 
    -0.11473067f, -0.02090749f, 0.32629761f, 0.09610591f, 0.58277059f, 0.59262162f, 0.15263139f, 0.00240165f, 
    0.39374679f, -0.05633414f, -0.28780696f, -0.13437110f, 0.07739522f, -0.02343798f, -0.19050625f, -0.29770628f, 
    0.33307746f, 0.07988241f, -0.40083614f, -0.30759472f, -0.27121499f, 0.25122723f, 0.34152666f, -0.35750005f, 
    0.10153986f, -0.22083724f, 0.04491845f, 0.31835240f, 0.22808276f, -0.66201448f, -0.12051353f, -0.23130383f, 
    -0.51393652f, 0.11176822f, -0.49660659f, -0.24592660f, -0.19888188f, -0.27768156f, -0.54779321f, 0.10286436f, 
    0.04690376f, 0.48726174f, 0.33316487f, 0.34737235f, 0.04600331f, -0.24143775f, 0.33430022f, -0.20509654f, 
    0.13552168f, 0.14371912f, 0.38619286f, 0.35291088f, 0.03500155f, 0.05793442f, 0.44174552f, -0.37823877f, 
    -0.88731360f, -0.35718995f, -0.61288673f, 0.09524482f, 0.52408379f, 0.56990439f, 0.17793982f, -0.46796668f, 
    -0.05356594f, 0.82780302f, -0.17530617f, -0.30911511f, -0.52256155f, -0.72091961f, -0.39008868f, 0.40630567f, 
    -0.38017324f, -0.26234245f, 0.22065827f, 0.33493292f, -0.01006204f, 0.32162336f, 0.18635416f, -0.56797409f, 
    -0.12210874f, -0.90888375f, -0.48199362f, -0.35766539f, 0.22498344f, 0.03969834f, 0.35622367f, -0.47354174f, 
    0.06443909f, -0.47787115f, 0.21836238f, -0.31968382f, -0.44297487f, 0.06046235f, -0.09038500f, -0.34095854f, 
    0.00719104f, 0.18937263f, -0.31404564f, 0.30551243f, -0.22175576f, -0.27020660f, -0.13147986f, 0.32689112f, 
    0.19658738f, -0.04850939f, -0.43261173f, -0.26880822f, 0.07802617f, 0.37437049f, 0.60116804f, -0.31806359f, 
    -0.67297006f, 0.28226551f, -0.35247537f, -0.30758557f, -0.27436867f, -0.35586146f, 0.30395719f, 0.14638168f, 
    -0.00818874f, 0.08682719f, -0.10045056f, -0.16638409f, 0.09290523f, -0.17893241f, -0.31993270f, -0.56286049f, 
    -0.67473483f, -0.43851811f, -1.00226712f, -0.78090763f, -0.48978540f, 0.15893100f, 0.93035066f, 0.62433779f, 
    -0.38220626f, -0.38314950f, 0.91480070f, -0.35889816f, -0.55533457f, -0.07204898f, 0.25022709f, 0.21640743f, 
    -0.11391614f, -0.03742016f, -0.33555010f, 0.03470625f, -0.30181241f, -0.14059649f, -0.02131303f, 0.23255789f, 
    0.29169524f, -0.15390094f, 0.84408307f, 0.34574053f, 0.32857597f, -0.12097035f, -0.17682460f, 0.10128404f, 
    0.10134309f, 0.00097617f, -0.38853410f, -0.90115434f, -0.45322385f, 0.28434545f, -0.01447420f, -0.29487014f, 
    -0.25604841f, -0.15144335f, 0.12523304f, -0.16801925f, -0.11638343f, 0.25698003f, -0.09937140f, 0.23777884f, 
    -0.06877560f, -0.01410749f, 0.25755122f, -0.61734390f, -0.45348915f, 0.20921664f, -0.28906977f, -0.21037982f, 
    -0.40395594f, -0.67536712f, -0.30991685f, -0.71379447f, -0.11165309f, 0.23549417f, -0.14574949f, 0.19797383f, 
    -0.07157768f, 0.06729692f, 0.17969385f, -0.03730576f, 0.09308137f, -0.03989086f, -0.06046739f, 0.25775146f, 
    0.34732002f, 0.05786039f, 0.10311270f, 0.51429141f, -0.03217468f, 0.00231133f, 0.25938782f, 0.51914644f, 
    0.02544711f, 0.09569176f, 0.60800755f, 0.33843026f, 0.23341307f, 0.37138331f, -0.08746380f, -0.17596443f, 
    0.22000515f, -0.01142786f, -0.09228335f, 0.03871141f, 0.04818198f, -0.12750359f, -0.00974442f, -0.12413196f, 
    0.05978282f, 0.28219706f, -0.06950133f, -0.20143375f, 0.29001519f, -1.12874329f, -0.06373497f, 0.89815146f, 
    1.00856686f, 0.20653766f, 0.12120803f, -0.03280171f, 0.16257453f, -0.67129999f, -0.42915565f, -0.00952758f, 
    0.19250692f, -0.35458589f, 0.40923706f, -0.18947050f, -0.18584035f, 0.03667381f, -0.07216208f, -0.19369024f, 
    0.32656366f, 0.14905925f, -0.14574993f, 0.31495744f, -0.13227122f, -0.07668412f, 1.06314838f, -0.49401069f, 
    -0.26783380f, 0.24021122f, 0.06646768f, -0.05896569f, -0.18003614f, 0.44258621f, 0.17025964f, -0.18761943f, 
    0.10785758f, 0.28995281f, -0.31754822f, -0.30399132f, 0.24413520f, -0.23953795f, 0.57142729f, -0.09026466f, 
    -0.01972006f, 0.03612665f, 0.07872496f, -0.32050961f, -0.19876097f, -0.14695817f, -0.17856598f, -0.52897185f, 
    -0.57611519f, -0.33622733f, -0.51129830f, 0.06499483f, 0.45803866f, -0.31101364f, 0.49824977f, -0.38522208f, 
    -0.59901798f, -0.46965995f, -0.34505481f, -0.31677800f, 0.31508011f, -0.06329628f, -0.18856324f, -0.43899503f, 
    -0.21770293f, 0.42631668f, 0.49089992f, -0.01495654f, -0.02583939f, 0.01672619f, -0.28745401f, -0.44805831f, 
    -0.20738129f, -0.61316079f, -0.63645834f, -0.73153728f, -0.40489334f, -0.21159092f, -0.22623958f, -0.13602240f, 
    -0.11010502f, -0.42154014f, 0.46165085f, 0.67451566f, 0.32761019f, -0.07675298f, -0.20759033f, -0.26687214f, 
    -0.48909110f, -0.02407445f, -0.11478988f, -0.11840778f, 0.01314554f, -0.24620694f, -0.31094936f, -0.14504319f, 
    -0.53174847f, -1.23683190f, 0.04942915f, 0.07655194f, -0.84831631f, -0.85111868f, 0.25829968f, 0.16499449f, 
    0.48002091f, 0.55594385f, 0.87366986f, -0.05437456f, -0.01465741f, 0.32565266f, 0.09530867f, -0.01952445f, 
    -0.28075626f, -0.28457162f, 0.00636328f, -0.07940111f, 0.11546122f, -0.01881582f, 0.14422339f, 0.22417165f, 
    0.01943397f, -0.04988687f, 0.59854096f, 0.32914665f, -0.51745433f, 0.46375686f, -0.44727939f, 0.46479067f, 
    0.24637142f, -0.33058280f, 0.36143768f, -0.27869597f, -0.42534629f, -0.02329951f, -0.13637026f, 0.10835656f, 
    -0.26897970f, 0.34812954f, -0.16058449f, -0.19702721f, -0.09336421f, 0.01621955f, -0.36283556f, -0.02818447f, 
    -0.10825520f, -0.46041003f, -0.30679911f, 0.51387805f, 0.29502568f, 0.33154061f, 0.02273610f, 0.12223911f, 
    -0.66046298f, -0.77731264f, -0.19238070f, -0.12415212f, -0.48608106f, -0.26915842f, -0.19722392f, 0.08640254f, 
    0.32169306f, -0.10440997f, 0.27594510f, 0.22375862f, -0.04254955f, 0.02836027f, 0.03760033f, -0.26861268f, 
    -0.05649254f, -0.29736480f, -0.32125708f, -0.44104418f, -0.27996507f, 0.90986782f, 0.69638449f, -0.63874894f, 
    0.00112352f, -0.17117798f, -0.38771334f, 0.19011380f, 0.40653303f, -0.02682738f, -0.02475977f, -0.34314775f, 
    -0.06808701f, -0.29480091f, -0.45418245f, 0.31163850f, 0.17884266f, 0.11551906f, -0.08197375f, -0.02831906f, 
    -0.28448418f, 0.05118565f, 0.11930855f, -0.14602561f, -0.71629769f, -1.29285073f, 0.46232778f, 0.69519627f, 
    0.04130346f, 0.25987509f, 0.04494258f, 0.45552981f, 0.36972305f, 0.05296443f, -0.16161679f, 0.04165898f, 
    0.35453466f, -0.07302732f, -0.57824278f, 0.23528592f, -0.11062678f, -0.24497218f, -0.50580776f, 0.16643181f, 
    0.34455508f, -0.14130703f, 0.07744598f, 0.07987505f, -0.36980808f, 0.08609625f, -0.64513010f, -0.55524421f, 
    -0.10568341f, -0.84408700f, -0.52999169f, 0.31110567f, 0.25411242f, -0.14303522f, 0.15398265f, 0.72180670f, 
    -0.07333848f, 0.23150949f, 0.13951616f, -0.03650640f, -0.01277962f, -0.02157485f, 0.03067265f, 0.03131026f, 
    -0.29639301f, 0.28260863f, -0.00630545f, -0.22688857f, -0.07554340f, -0.33868280f, -0.37384108f, -1.26839864f, 
    -0.03298001f, -0.08332244f, -1.03512192f, -0.20762354f, -0.23323415f, 0.08343579f, -0.26461473f, 0.19075954f, 
    0.33657011f, -0.23804387f, -0.59500593f, -0.55037594f, -0.57969207f, -0.06140209f, 0.33015144f, 0.28929707f, 
    -0.05117292f, -0.02365745f, -0.21327701f, -0.04523731f, -0.24938598f, -0.25777146f, -0.13415629f, -0.37264988f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.30024907f, 0.23369674f, 0.23346914f, 0.10534181f, 0.41810477f, 0.40098947f, 0.22934774f, -0.04985775f, 
    0.01064410f, 0.38166744f, 0.16329531f, 0.47027269f, 0.05669553f, 0.10410470f, 0.12339812f, 0.14462614f, 
    0.04119284f, 0.00059483f, -0.04327075f, 0.12206428f, -0.31897452f, 0.34057763f, 0.25850466f, 0.00184236f, 
    0.20187156f, 0.18604407f, 0.03944810f, -0.07782370f, 0.17799211f, 0.32886153f, -0.08938512f, -0.23695785f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.12682579f, -0.26302665f, 0.02155097f, -0.16014664f, -0.03467372f, -0.01607956f, -0.20108426f, -0.01331103f, 
    0.09598892f, -0.05768373f, -0.14761661f, 0.01594275f, 0.04873720f, -0.27005446f, -0.17270625f, -0.00243260f, 
    -0.24579741f, 0.12271415f, -0.02639229f, 0.03484909f, -0.03831103f, 0.08878506f, -0.06133946f, 0.07836381f, 
    -0.01201240f, -0.02341676f, -0.12909743f, 0.24782409f, 0.03239420f, -0.00979272f, 0.11404992f, 0.12206844f, 
    -0.12277662f, -0.02158262f, -0.00574711f, -0.02458916f, 0.33841532f, -0.00249849f, 0.03349889f, -0.06774818f, 
    0.00669607f, -0.02259873f, -0.12997526f, 0.03487856f, -0.01248327f, 0.03976992f, -0.07600933f, -0.01023580f, 
    0.19112520f, 0.17684831f, 0.05384866f, -0.10675132f, 0.07435221f, -0.22615063f, 0.00743171f, -0.04187493f, 
    0.11180114f, 0.03257764f, 0.08537695f, 0.02113326f, -0.10152825f, -0.23770581f, -0.07686760f, -0.15812181f, 
    -0.15693451f, -0.16240768f, -0.02262754f, -0.02643649f, 0.17976832f, 0.07874811f, 0.01696926f, -0.17789871f, 
    0.10585123f, 0.19046248f, -0.07223102f, -0.07232524f, -0.12630382f, -0.05605201f, 0.04093682f, -0.06581413f, 
    0.05874101f, -0.01817807f, -0.08311478f, -0.06786717f, -0.26566553f, -0.30645898f, -0.09019645f, -0.07274072f, 
    0.08324113f, -0.02578753f, -0.06667958f, 0.02302375f, -0.03903713f, -0.13295007f, -0.08949546f, 0.05682754f, 
    -0.19313538f, 0.35240540f, -0.23499893f, 0.00653384f, -0.01050404f, 0.05635887f, 0.08248027f, -0.03630517f, 
    -0.13165218f, 0.08702355f, 0.01492317f, -0.09593888f, 0.03425154f, 0.13885003f, -0.04953300f, 0.02744205f, 
    0.10890133f, 0.00813166f, 0.10239311f, -0.08249411f, -0.07184672f, 0.14874527f, -0.01367121f, 0.09105115f, 
    0.20722137f, 0.03766033f, -0.17049602f, 0.16503137f, 0.08898654f, 0.11153764f, -0.12009586f, -0.02446371f, 
    0.05464183f, 0.12860808f, 0.04949283f, -0.01654592f, 0.30425146f, -0.03848831f, 0.09976745f, -0.35582662f, 
    0.04267774f, -0.08299339f, 0.00026234f, 0.06182817f, 0.23756430f, 0.18927167f, 0.03639844f, 0.02242245f, 
    -0.41648614f, 0.03063922f, -0.19555357f, -0.32953742f, -0.19652146f, -0.12341280f, -0.07597300f, 0.04991235f, 
    0.02597762f, 0.02161374f, 0.02502764f, -0.14657918f, -0.18199973f, -0.12458906f, 0.12004820f, 0.30022460f, 
    0.04060245f, -0.06146868f, 0.00395238f, -0.02599980f, 0.12014908f, 0.05644167f, 0.04920829f, 0.05452924f, 
    -0.06166540f, 0.22799826f, 0.26401609f, 0.03422663f, 0.04672642f, -0.16811198f, 0.18228419f, -0.11955608f, 
    0.12195777f, -0.02399776f, -0.00242500f, -0.17667839f, -0.17618614f, -0.10882778f, 0.11460905f, 0.22207205f, 
    0.00519214f, -0.07301871f, -0.01115816f, -0.02731703f, 0.04184977f, -0.05080085f, -0.03185242f, 0.00305492f, 
    0.05700922f, -0.20599730f, 0.22075917f, 0.18524341f, 0.04579329f, 0.00398624f, 0.05731571f, 0.10779209f, 
    -0.00706029f, -0.01145826f, -0.09455574f, 0.04798637f, 0.01746904f, -0.26481795f, 0.45794612f, -0.12623234f, 
    0.12495992f, 0.09925754f, 0.02209784f, 0.36099193f, 0.16624305f, 0.01627852f, 0.05314472f, -0.01223332f, 
    0.26555711f, 0.24997959f, 0.05829692f, -0.14951663f, 0.08221708f, -0.18561997f, 0.11160740f, -0.05251141f, 
    -0.03376854f, -0.08255114f, -0.13222158f, -0.05359028f, -0.19290479f, -0.10697962f, 0.05359521f, 0.35387293f, 
    -0.00228741f, -0.04605690f, -0.14847994f, 0.03274522f, 0.00714573f, 0.06811520f, -0.04907033f, 0.12358655f, 
    0.13385190f, 0.03254547f, -0.05690506f, -0.31215557f, -0.05198096f, 0.12275867f, -0.03360606f, -0.02805830f, 
    -0.00588505f, -0.13833715f, -0.07189251f, -0.00854088f, -0.17456341f, 0.10361765f, -0.14612098f, 0.33382356f, 
    -0.08443345f, -0.02700017f, 0.11153787f, -0.18258850f, -0.10365299f, 0.06244732f, 0.04364163f, -0.10360216f, 
    0.12870677f, -0.06016476f, -0.10007992f, -0.22007613f, -0.05723679f, -0.06600972f, 0.09736238f, -0.21801724f, 
    -0.04891543f, 0.06841237f, 0.11796854f, 0.08828229f, -0.35328931f, 0.03722912f, 0.03441324f, 0.10291948f, 
    0.00609023f, -0.00908273f, -0.11579340f, -0.00675319f, 0.00636432f, -0.00048052f, -0.08304770f, 0.09718695f, 
    -0.03678091f, 0.12448629f, 0.14225011f, 0.25281417f, 0.08286845f, 0.20487280f, 0.14082135f, 0.08035002f, 
    0.13005222f, -0.01085377f, -0.04833855f, 0.15773878f, 0.63681799f, 0.36858895f, -0.11578532f, 0.34755561f, 
    0.03106315f, -0.11607031f, -0.10536039f, -0.02519749f, -0.01408784f, -0.09649122f, 0.03116313f, 0.20037985f, 
    0.09190878f, 0.34204915f, -0.13273621f, 0.04364463f, 0.05907590f, -0.05193080f, 0.01253026f, -0.01315023f, 
    0.11594149f, 0.05527528f, 0.25914225f, 0.04947448f, -0.07183468f, 0.12341120f, -0.14215674f, 0.13919045f, 
    -0.07924514f, 0.16482809f, 0.09636375f, -0.20266080f, 0.01021134f, 0.10019623f, 0.05088533f, 0.04604010f, 
    0.48607159f, 0.12421434f, 0.04207473f, 0.09722381f, -0.00614794f, -0.01218958f, -0.10196277f, -0.06419271f, 
    0.23730713f, -0.03106740f, 0.15428720f, -0.04298532f, 0.48909843f, 0.06325926f, -0.17161718f, 0.14986320f, 
    0.01884969f, -0.12425655f, 0.13123731f, -0.12335116f, 0.05910832f, -0.03023697f, -0.09986097f, 0.01176144f, 
    0.34447697f, -0.00503086f, 0.08466271f, 0.16815169f, 0.05628474f, 0.01043238f, 0.01888087f, 0.24765754f, 
    0.03504215f, -0.01149065f, -0.05882820f, 0.08275796f, -0.02128188f, -0.35084605f, -0.16097750f, 0.17663883f, 
    -0.03713172f, -0.07794961f, -0.02637150f, 0.03574042f, -0.01954508f, -0.00392261f, -0.13837732f, 0.08368449f, 
    -0.25901449f, -0.05123565f, -0.15865299f, 0.12800014f, -0.00770851f, 0.02292055f, 0.01188215f, 0.07255156f, 
    -0.12842287f, 0.01812789f, 0.17783681f, -0.03126585f, -0.49669337f, 0.61570710f, -0.11867747f, -0.09090392f, 
    0.10204589f, 0.22460853f, -0.09259252f, 0.07796700f, -0.14015232f, -0.16121706f, -0.05554687f, -0.00860086f, 
    -0.02652128f, 0.20898333f, -0.01017101f, 0.19369952f, 0.06433680f, 0.14296661f, 0.10485079f, 0.13278683f, 
    -0.08435445f, 0.00384902f, -0.14169729f, -0.08374758f, -0.11308247f, -0.14153393f, -0.12629290f, -0.12293426f, 
    -0.00223141f, -0.01153999f, 0.01083509f, 0.04724290f, 0.06789912f, 0.19442831f, 0.11183721f, 0.17111515f, 
    -0.18822844f, -0.37883028f, -0.08637166f, -0.10431143f, 0.05021320f, -0.05555280f, -0.03165036f, -0.03844606f, 
    -0.19868641f, 0.11646985f, -0.11810543f, 0.20905046f, -0.66077065f, -0.37399212f, -0.09383707f, -0.17487396f, 
    0.03001056f, 0.00042225f, 0.02461034f, 0.04274539f, -0.02016566f, -0.01686946f, 0.12669183f, 0.09239865f, 
    -0.54307175f, -0.18361677f, -0.27805883f, -0.30561379f, 0.14747156f, -0.07273044f, -0.02028888f, 0.03977191f, 
    -0.11172100f, -0.07748643f, -0.18968309f, -0.17097457f, -0.01567670f, 0.02406498f, 0.06448338f, -0.01651670f, 
    0.03331966f, 0.10314598f, 0.09559665f, -0.03348868f, -0.04661913f, 0.10721425f, 0.00461063f, -0.03654499f, 
    -0.14197785f, -0.02670500f, -0.14868991f, 0.14454736f, -0.04414516f, -0.08379900f, 0.10207291f, -0.05879432f, 
    0.03706890f, 0.00086233f, -0.00700507f, -0.02099115f, 0.00471690f, 0.13396879f, 0.07967138f, -0.08288535f, 
    0.10619773f, 0.02063578f, -0.11227205f, 0.10561202f, 0.09969387f, 0.06341968f, -0.02078154f, -0.27489248f, 
    0.01568204f, 0.21200322f, 0.12948889f, -0.23220561f, 0.01909800f, 0.06476606f, 0.07138129f, -0.13025746f, 
    -0.02639159f, -0.01522413f, -0.18214840f, 0.12713405f, 0.09118406f, -0.03332088f, -0.05883186f, 0.01930516f, 
    0.00679096f, 0.03366114f, -0.01356230f, 0.04630466f, -0.23098792f, -0.05365216f, -0.04822351f, -0.16161779f, 
    -0.59776795f, -0.22962387f, -0.19961235f, 0.03003846f, -0.01126178f, 0.03961682f, 0.03139225f, 0.01447869f, 
    0.07198427f, 0.09469865f, 0.19750242f, -0.01101856f, 0.04739952f, 0.27285293f, 0.17109826f, 0.14866903f, 
    -0.12069789f, 0.10899293f, 0.07682416f, 0.25311723f, 0.00800640f, 0.07144129f, 0.06911118f, -0.01450774f, 
    0.40954235f, 0.34906629f, 0.18687280f, -0.00572367f, 0.06979012f, -0.04564319f, -0.21479593f, -0.08734487f, 
    -0.14951716f, -0.06735020f, -0.13517144f, -0.18028922f, 0.24517326f, 0.17727417f, 0.22803831f, 0.13159499f, 
    -0.01926186f, 0.20314254f, 0.13274983f, 0.04683334f, -0.06189163f, -0.04862448f, -0.12937406f, -0.04801227f, 
    0.13535073f, 0.00485431f, 0.14821202f, -0.12253891f, -0.00523453f, -0.01395317f, -0.15099606f, -0.05381007f, 
    0.03508784f, 0.17979142f, -0.04879706f, 0.31226787f, 0.56530237f, 0.07860580f, 0.49892977f, 0.39643788f, 
    -0.01335261f, 0.06606575f, 0.00485152f, -0.09677979f, -0.04622485f, -0.16274677f, 0.08081079f, -0.04134708f, 
    -0.16036107f, -0.18175627f, -0.08364718f, 0.04787741f, 0.02217342f, -0.05918650f, 0.04650092f, 0.13925697f, 
    -0.07708348f, -0.01772668f, 0.00026337f, 0.01108082f, 0.11259469f, 0.23177361f, 0.20835474f, 0.26297939f, 
    -0.16553961f, 0.11349542f, 0.00786238f, 0.15130369f, -0.02960492f, 0.03542373f, 0.05136629f, 0.10654327f, 
    -0.09395674f, -0.18798433f, 0.01739274f, 0.00535708f, -0.01066786f, 0.09776060f, 0.03818180f, 0.01939593f, 
    0.18248716f, 0.10059132f, 0.04095524f, -0.10059166f, -0.32154176f, -0.11798450f, -0.01364784f, -0.11581562f, 
    -0.16474620f, 0.19700804f, 0.09133692f, -0.04356488f, -0.13794415f, 0.07168664f, 0.13170750f, 0.15117687f, 
    -0.06832462f, -0.05877635f, 0.17064326f, -0.07004908f, -0.06584681f, 0.01247690f, -0.11994684f, 0.08779042f, 
    -0.16161691f, 0.17322934f, -0.08314365f, 0.01167051f, -0.05368871f, -0.02166153f, 0.07690354f, 0.18807553f, 
    -0.01715904f, 0.21294661f, 0.02898804f, 0.04387183f, -0.08832979f, -0.11368041f, -0.00959278f, 0.01864198f, 
    0.10629757f, 0.00584989f, 0.07474803f, 0.18225431f, -0.02563618f, -0.13508143f, 0.04171843f, 0.21876144f, 
    0.14535311f, 0.14991060f, 0.10691818f, -0.05117771f, 0.49488559f, 0.51429319f, 0.30050683f, 0.25207791f, 
    -0.06150600f, 0.02152950f, 0.05546578f, -0.01619510f, -0.06069576f, -0.16678569f, -0.08519649f, 0.05301709f, 
    -0.53739208f, -0.08010853f, -0.07378129f, -0.13484482f, -0.03355247f, 0.03255020f, -0.13063926f, -0.02012487f, 
    -0.37118974f, 0.34251356f, 0.16928379f, 0.24739042f, -0.28740257f, 0.11022790f, -0.19710696f, 0.04627679f, 
    0.15075533f, 0.04218959f, 0.01550829f, -0.09116820f, -0.02335520f, -0.05730779f, 0.01344903f, -0.00817830f, 
    -0.19769078f, -0.17734046f, -0.25179398f, -0.07929331f, -0.03327364f, -0.08680202f, 0.24693972f, 0.09064040f, 
    0.15781337f, -0.23527975f, 0.06586700f, 0.03338976f, 0.05232877f, -0.44242066f, -0.01665661f, -0.04419884f, 
    -0.10912392f, 0.05268959f, 0.09980924f, 0.02889545f, -0.18256970f, 0.01795185f, 0.14756604f, -0.07238527f, 
    0.22670723f, 0.22432579f, 0.20216265f, 0.20307964f, 0.07086391f, -0.03502022f, 0.07598826f, -0.05223335f, 
    0.07686867f, 0.29427856f, 0.06089856f, 0.03630340f, 0.41007403f, 0.19315416f, 0.05329850f, 0.28985244f, 
    0.07999624f, 0.05838063f, -0.07476393f, -0.09426737f, 0.01397839f, -0.04419638f, -0.10279078f, 0.12145387f, 
    0.20857294f, -0.17490016f, 0.18401504f, -0.19113970f, 0.00459019f, -0.01338695f, -0.23606347f, -0.01125908f, 
    0.11639066f, 0.07981139f, 0.20064804f, 0.15172943f, 0.44277540f, 0.09952953f, 0.59138489f, -0.18675061f, 
    0.18922894f, -0.09661806f, -0.07289406f, 0.09668985f, 0.25371751f, 0.00741502f, 0.03528507f, -0.03677604f, 
    0.16916864f, 0.08584358f, 0.15523778f, -0.07389086f, 0.12971786f, 0.13180687f, 0.20451733f, 0.13279301f, 
    0.13848570f, -0.01171240f, -0.02398363f, 0.11603252f, -0.30267650f, -0.28315327f, -0.08854031f, 0.08230601f, 
    -0.04133879f, -0.05344873f, 0.01525000f, -0.01060912f, 0.09746059f, -0.21303898f, -0.09952962f, 0.00387489f, 
    -0.33273387f, -0.24694891f, -0.14167032f, 0.01730332f, -0.00905903f, 0.14121468f, 0.03509288f, 0.03192272f, 
    0.12568277f, -0.16349247f, -0.12889118f, -0.08269440f, -0.21231835f, 0.04690992f, 0.05412130f, 0.22891082f, 
    0.05589540f, -0.00860467f, -0.06591669f, -0.16369154f, 0.01048964f, -0.11710145f, -0.03584639f, 0.02791781f, 
    -0.09568404f, -0.26097769f, -0.32040325f, 0.36653680f, 0.03034915f, -0.02954214f, -0.11342872f, -0.10676585f, 
    0.06214457f, -0.10551193f, 0.13437593f, 0.06142825f, 0.01881137f, -0.06102878f, -0.00707627f, -0.01595821f, 
    -0.05920759f, -0.11378299f, -0.13528822f, -0.15251622f, 0.12001705f, 0.03806918f, -0.10912771f, -0.04339772f, 
    -0.23926747f, -0.23661633f, -0.14876734f, -0.10523899f, 0.03877672f, -0.15601650f, -0.15718377f, -0.14185938f, 
    0.12536949f, -0.09812354f, 0.14074793f, 0.10189655f, -0.05247735f, -0.36812750f, -0.20599504f, -0.22697398f, 
    0.01378093f, 0.06475101f, -0.16299960f, -0.05201953f, 0.02535654f, 0.02562341f, 0.20869936f, 0.11411532f, 
    -0.30626765f, 0.14674038f, 0.10591675f, -0.02578111f, 0.05966959f, 0.02147205f, 0.03295227f, 0.04782982f, 
    0.08994285f, 0.02106968f, 0.12349065f, -0.04747622f, 0.00057473f, -0.05952926f, -0.09780202f, -0.00267945f, 
    -0.08572641f, -0.04098579f, -0.07079314f, 0.04686501f, 0.12914017f, -0.11598375f, 0.00839242f, 0.04453649f, 
    -0.19287193f, -0.07440025f, -0.02814801f, 0.07473674f, 0.10538005f, 0.04270752f, -0.05318796f, -0.09823930f, 
    0.01045442f, -0.12005890f, 0.02955150f, 0.02625777f, 0.12925655f, 0.15569948f, -0.09208989f, -0.17589654f, 
    0.00580065f, 0.07632066f, 0.11588708f, 0.01682687f, -0.03034132f, 0.05831042f, 0.02143814f, 0.07451541f, 
    0.22463240f, -0.00939960f, -0.20930885f, -0.08606652f, 0.07111209f, 0.19177805f, 0.12773202f, 0.04501492f, 
    0.03170267f, 0.19778879f, 0.16471535f, 0.20402999f, 0.23083897f, 0.26133749f, -0.08553288f, -0.02477918f, 
    0.23263229f, 0.18019193f, 0.12604956f, 0.07941768f, -0.05546657f, -0.10069197f, 0.10520549f, 0.08577938f, 
    0.13404135f, 0.11354046f, 0.00045131f, -0.17684981f, -0.00250989f, -0.03376733f, 0.03217679f, 0.10025433f, 
    0.19830744f, -0.05736900f, -0.04555485f, -0.16284443f, 0.25044933f, -0.19155011f, -0.08076462f, -0.04133815f, 
    0.07873433f, 0.00938925f, -0.05210939f, -0.18226574f, 0.10644590f, -0.04099908f, -0.03144377f, -0.06724381f, 
    -0.22236568f, -0.15774441f, -0.17618564f, 0.19085112f, -0.01420261f, -0.03932591f, -0.02077980f, 0.07938417f, 
    0.00390086f, -0.01930997f, 0.09872463f, -0.01145294f, 0.12627117f, 0.06319638f, -0.00896974f, -0.26330364f, 
    0.16185531f, 0.09708185f, 0.12734731f, 0.27592152f, 0.04193754f, 0.08745313f, 0.03729190f, 0.04338718f, 
    -0.26258144f, -0.06652219f, -0.01004152f, 0.20294905f, -0.00791453f, -0.23199342f, -0.16317190f, -0.10876254f, 
    -0.02628086f, 0.15616253f, 0.05220739f, 0.19280848f, 0.47979900f, -0.03443775f, -0.12564017f, -0.16609418f, 
    0.04162258f, -0.10246381f, -0.06196126f, 0.12049656f, 0.15874775f, -0.02636984f, -0.18766704f, 0.05726185f, 
    -0.26042682f, -0.31177989f, -0.03978012f, -0.01682584f, 0.08088154f, -0.00542949f, -0.00056762f, -0.23848613f, 
    0.09456207f, -0.15074308f, -0.06795729f, -0.02488133f, 0.34028706f, 0.24944395f, -0.17640074f, -0.02848112f, 
    0.12949477f, 0.06945164f, 0.22717752f, 0.16225652f, 0.02214303f, 0.03306120f, 0.04322153f, -0.09884319f, 
    0.21022527f, 0.13857913f, -0.08867946f, -0.01130847f, 0.03625792f, 0.06414899f, 0.08677435f, 0.17860980f, 
    -0.06998526f, -0.09661095f, 0.13883130f, -0.03572568f, -0.26285800f, -0.49260786f, -0.17189004f, -0.00678477f, 
    -0.01403745f, 0.16326632f, -0.03447922f, -0.04771867f, 0.12075389f, 0.22818270f, 0.02767116f, -0.11187451f, 
    0.16464174f, -0.49773762f, -0.23438565f, -0.17464130f, -0.02133220f, 0.02165930f, 0.00755585f, -0.03554360f, 
    -0.15489230f, -0.01325498f, -0.16470578f, -0.20361944f, -0.02908554f, -0.01002754f, 0.12291645f, 0.06614094f, 
    0.16927528f, 0.01442036f, 0.05180850f, 0.12233098f, -0.04168240f, -0.03029183f, -0.01904575f, -0.18265648f, 
    -0.68481725f, 0.07627158f, 0.02369373f, 0.07889970f, -0.09139444f, -0.07047941f, -0.05306646f, 0.06255852f, 
    -0.07684790f, 0.13022512f, 0.05637012f, -0.19125357f, -0.39747161f, 0.25460622f, -0.02025491f, 0.06085059f, 
    0.03843556f, -0.18246262f, -0.25147784f, 0.05767613f, -0.01333143f, 0.03328634f, 0.08309060f, 0.15038714f, 
    -0.10232110f, -0.20991990f, -0.10281029f, -0.01557620f, 0.04672873f, 0.17193797f, -0.08489024f, -0.08164845f, 
    0.12784767f, 0.04160172f, 0.16863352f, -0.01412897f, 0.14282797f, 0.32773748f, 0.25876576f, -0.07559027f, 
    0.18792856f, 0.12406406f, 0.01099272f, 0.19735433f, 0.06058575f, -0.05365296f, -0.03400131f, 0.06166766f, 
    0.18323366f, -0.36205480f, -0.04084510f, -0.04935037f, 0.14956450f, 0.08826897f, 0.01950300f, -0.16543622f, 
    0.02152725f, 0.04925454f, -0.09983812f, -0.00053267f, 0.12758841f, 0.13131705f, 0.29883444f, -0.01109939f, 
    -0.03865345f, 0.13881616f, -0.07622067f, -0.07246323f, 0.10854198f, 0.04446907f, -0.05182511f, 0.17289641f, 
    -0.32307485f, 0.05322342f, -0.20538823f, -0.25061837f, -0.01474400f, -0.07837228f, 0.16907735f, -0.04899756f, 
    -0.04250701f, 0.04109149f, 0.06979971f, -0.19173558f, 0.13311835f, -0.11084639f, 0.28961292f, 0.21655299f, 
    0.04225842f, -0.00059424f, -0.02755224f, -0.05643882f, -0.09419233f, -0.07773586f, -0.03362096f, 0.12890856f, 
    0.43005013f, 0.01903478f, 0.18040261f, 0.06827788f, 0.01809618f, -0.00797820f, 0.09265535f, 0.03152496f, 
    0.07751760f, 0.17287105f, -0.00137580f, 0.08505768f, -0.05664399f, -0.08914137f, -0.33988541f, -0.00975732f, 
    0.02808255f, -0.02994344f, 0.14497004f, -0.05543603f, 0.12286762f, 0.02851178f, -0.13067523f, -0.00964511f, 
    0.10824309f, 0.19185913f, 0.00115842f, 0.16752759f, 0.02983697f, -0.15670900f, 0.07432616f, 0.00651163f, 
    0.15352936f, -0.10666445f, -0.08717391f, 0.06195916f, 0.05951943f, -0.22192982f, 0.03500117f, -0.06045824f, 
    0.21203572f, 0.03328171f, -0.01148622f, -0.02472366f, 0.19305719f, 0.00910070f, -0.00952053f, 0.04591471f, 
    -0.19610111f, 0.21262713f, -0.12695101f, -0.16119872f, -0.13738325f, -0.06132714f, 0.15386236f, -0.16183040f, 
    0.02845490f, -0.04770289f, 0.03321642f, -0.01570603f, 0.25839016f, 0.03418412f, 0.02109626f, -0.07005973f, 
    0.04418576f, -0.01522608f, 0.07291275f, -0.16688165f, 0.10465768f, 0.00538287f, -0.03123123f, 0.03681407f, 
    -0.30728072f, -0.04591438f, -0.44148520f, 0.10772911f, -0.16717640f, 0.11567538f, 0.10103378f, -0.09565447f, 
    0.00344343f, -0.01508373f, 0.13249123f, -0.02304430f, 0.14163446f, 0.36758202f, 0.41419128f, 0.09937797f, 
    0.05308110f, 0.02741369f, -0.20183250f, -0.18244159f, 0.08951370f, -0.07032192f, 0.25662822f, -0.12645121f, 
    -0.02300980f, -0.13247153f, -0.38387722f, 0.11168311f, 0.05219270f, -0.04792114f, 0.06070690f, -0.11491634f, 
    0.08058986f, 0.02755661f, -0.27837420f, 0.13706516f, -0.12003588f, 0.19756232f, -0.05894292f, -0.00390816f, 
    0.12939407f, 0.13796332f, 0.05499942f, 0.08583082f, -0.09182831f, -0.07027212f, -0.01521214f, 0.04557282f, 
    -0.06232494f, -0.13590074f, 0.20723191f, 0.02589917f, 0.33323359f, -0.20305686f, 0.05455482f, 0.04128216f, 
    -0.00306984f, 0.11549730f, 0.02034240f, 0.17530927f, 0.01149008f, -0.23618798f, -0.24088764f, -0.14116114f, 
    -0.03990557f, -0.22497568f, 0.11320980f, -0.04898697f, -0.00387375f, 0.02023715f, 0.02511077f, 0.00670499f, 
    0.19267881f, -0.17648605f, 0.00757209f, 0.10003922f, -0.07345983f, 0.06360487f, 0.04910676f, 0.00338781f, 
    0.01346716f, 0.05989578f, 0.11076222f, 0.14819390f, 0.50677902f, -0.22112240f, -0.49801388f, -0.16393457f, 
    -0.11388098f, 0.01870062f, -0.22846799f, -0.01145923f, -0.03743564f, -0.08878941f, 0.03107863f, 0.04473402f, 
    0.07120637f, -0.35497648f, 0.38771948f, 0.19665289f, 0.16458060f, 0.03493099f, 0.13454174f, -0.12467828f, 
    -0.07488983f, -0.12360321f, -0.02814727f, 0.05763147f, -0.14798699f, -0.12501784f, -0.20348947f, -0.13529578f, 
    -0.14876080f, 0.00041782f, -0.00219786f, -0.00128126f, -0.02152265f, 0.02498816f, 0.00881929f, -0.06234807f, 
    0.08170963f, -0.05642191f, 0.17053752f, 0.16420761f, -0.11368700f, -0.02221164f, -0.06467655f, -0.01603974f, 
    0.03474859f, 0.10889991f, -0.01475875f, 0.11908753f, -0.13988495f, -0.13299741f, 0.04163392f, 0.12609300f, 
    0.02666656f, 0.43482605f, -0.20725393f, -0.03852689f, -0.11519260f, -0.10417570f, 0.10901459f, -0.09336310f, 
    0.05880011f, -0.07404793f, 0.17516109f, -0.31682637f, -0.03558221f, 0.02976262f, -0.02854283f, 0.03215338f, 
    0.17037115f, 0.03357347f, 0.12742034f, -0.15357272f, -0.04176445f, -0.04594295f, -0.25663206f, -0.00137678f, 
    -0.15307362f, 0.02664161f, -0.05444441f, 0.08631326f, 0.07959031f, 0.00279445f, 0.18417485f, 0.08781472f, 
    -0.38012901f, 0.12841381f, 0.17355947f, -0.27716655f, 0.01234803f, 0.16024390f, -0.01225562f, 0.14090326f, 
    -0.05096092f, 0.07134269f, 0.06065453f, 0.07156374f, -0.13506569f, -0.03110798f, 0.12610906f, -0.18422620f, 
    -0.20074664f, -0.25252229f, -0.23767531f, -0.09931691f, 0.13336878f, 0.07790759f, 0.03100145f, 0.21911152f, 
    0.26317343f, 0.17427324f, 0.22577080f, 0.07769310f, 0.03634459f, -0.00769037f, 0.01115569f, 0.14450231f, 
    -0.09320677f, 0.14780028f, 0.24641381f, 0.00129694f, 0.03712860f, -0.06241105f, -0.41876495f, -0.12875573f, 
    0.09292762f, -0.12031572f, 0.38976514f, 0.13912363f, -0.08516528f, 0.11114920f, 0.08043206f, 0.15367281f, 
    -0.04247038f, 0.18092671f, -0.15784150f, 0.10575544f, -0.07977568f, -0.02793617f, 0.03207693f, 0.00510006f, 
    0.00260574f, 0.17553899f, -0.03081825f, 0.01687189f, -0.30144736f, 0.12270185f, 0.41054434f, 0.36341548f, 
    -0.13604008f, 0.02670613f, -0.07725900f, -0.11365219f, 0.19396414f, -0.07969457f, 0.20732045f, -0.07726988f, 
    0.16190654f, 0.14100449f, 0.09372250f, -0.30356547f, -0.17183818f, 0.06933897f, -0.22265168f, -0.05526360f, 
    0.09140894f, -0.15603215f, -0.00193097f, 0.05217288f, 0.11360398f, -0.18630800f, -0.06377213f, 0.09271155f, 
    -0.06981000f, 0.04977558f, 0.00123253f, 0.16164237f, 0.08051854f, 0.11972422f, 0.09380743f, 0.01994907f, 
    -0.05206746f, 0.00992130f, -0.01978487f, -0.01515797f, -0.03142965f, -0.03664305f, 0.01859095f, 0.00650226f, 
    0.00208574f, 0.03919405f, -0.00936464f, -0.00841185f, 0.03907894f, -0.03261826f, 0.00570058f, 0.03332372f, 
    -0.04987310f, 0.03935718f, 0.04250526f, -0.02446859f, 0.00612589f, 0.00904676f, 0.02164880f, -0.01411223f, 
    -0.02266409f, -0.03236019f, -0.00649841f, 0.00276039f, 0.02254385f, 0.03967982f, -0.05039766f, 0.04357175f, 
    0.01184303f, 0.04444365f, 0.03899075f, 0.02503060f, -0.04885995f, 0.01168542f, -0.00081955f, 0.03701409f, 
    -0.04779909f, -0.01214097f, -0.04253846f, -0.00583059f, -0.00075920f, -0.02892878f, 0.00164542f, 0.03110417f, 
    -0.04059173f, -0.05258565f, -0.02874497f, -0.04977133f, -0.02456781f, -0.02962271f, 0.03516226f, -0.03100778f, 
    -0.04060847f, -0.04299084f, -0.04864765f, -0.01765954f, 0.01577083f, 0.00599565f, -0.05190953f, -0.02136718f, 
    0.00655628f, 0.03564391f, -0.00364737f, -0.00935145f, -0.03989033f, 0.04808370f, 0.01474011f, -0.00519942f, 
    0.00375508f, 0.04258519f, 0.02977466f, 0.01538458f, 0.04384457f, -0.03143077f, -0.02557535f, 0.03322557f, 
    0.02901009f, -0.04550552f, 0.01852935f, -0.03999474f, -0.01152965f, 0.01505686f, -0.03255071f, -0.00552442f, 
    -0.04032329f, -0.02268343f, -0.02393379f, 0.01689650f, -0.05108738f, -0.02721331f, 0.00277354f, 0.00342679f, 
    0.02266536f, 0.01147146f, -0.00011546f, 0.01231267f, -0.05546774f, 0.02582111f, -0.01185397f, 0.00681677f, 
    0.02599063f, -0.05083630f, 0.00018642f, -0.04073420f, 0.00579649f, -0.02935213f, -0.00386198f, -0.01431789f, 
    0.00424621f, 0.03482308f, -0.04409892f, -0.01324788f, 0.03979509f, -0.00672217f, 0.04938977f, -0.00159516f, 
    0.02097691f, 0.02011730f, 0.03462479f, 0.03404661f, -0.05254199f, 0.00288470f, -0.05514797f, -0.00873978f, 
    -0.05213112f, -0.05539068f, 0.00405539f, -0.05024534f, 0.01754012f, -0.00779172f, 0.01640284f, 0.00550630f, 
    -0.02971615f, -0.00029652f, 0.03320420f, 0.01921252f, -0.00289286f, -0.01439195f, -0.02348453f, -0.03582178f, 
    -0.05089716f, -0.00117358f, -0.04546686f, -0.00652396f, -0.01499924f, -0.03824955f, -0.01190017f, -0.04633629f, 
    -0.05445588f, 0.03678019f, -0.04186640f, -0.05099119f, 0.00893993f, 0.01893909f, 0.03767868f, 0.00751320f, 
    0.02375720f, -0.00123541f, 0.02505019f, -0.03781559f, 0.02042568f, 0.04386890f, -0.03525473f, -0.05265568f, 
    -0.00467517f, -0.00102301f, -0.00579896f, -0.02532021f, 0.02219650f, -0.02827300f, 0.04248354f, 0.01467249f, 
    0.02395752f, 0.00425898f, -0.02119327f, 0.04463175f, 0.01738834f, 0.02317492f, 0.02766356f, 0.00907016f, 
    0.00088614f, -0.00958087f, -0.00891342f, 0.03188082f, -0.05312643f, -0.01499471f, -0.04003841f, -0.05047876f, 
    -0.02409974f, -0.05152917f, -0.05230260f, 0.02264045f, -0.04256433f, -0.00070334f, 0.04015390f, -0.00232715f, 
    -0.02680251f, -0.01548414f, 0.01676686f, -0.03036762f, 0.04086574f, 0.02106018f, -0.03492948f, -0.02438803f, 
    0.00969147f, 0.02589743f, -0.03379232f, -0.04458727f, -0.00827608f, -0.03867788f, -0.05328478f, -0.03710159f, 
    0.00643759f, 0.04519847f, -0.02934861f, -0.00988379f, 0.02812041f, -0.04765108f, 0.04497503f, -0.01137278f, 
    0.04393432f, 0.00753338f, -0.02812928f, -0.00701711f, -0.03076669f, 0.01965372f, -0.02714012f, 0.00192227f, 
    0.02984241f, 0.00167506f, -0.01070010f, -0.04509178f, -0.02591291f, 0.00986028f, -0.04980441f, 0.03100781f, 
    -0.00297082f, -0.03891595f, -0.02013553f, -0.01547048f, -0.00063120f, 0.03778891f, 0.00671106f, -0.03513445f, 
    -0.00439184f, -0.01546102f, -0.01538070f, 0.01925012f, -0.03597772f, 0.02628840f, -0.04248867f, 0.02774757f, 
    -0.01003027f, -0.02353864f, -0.03132431f, 0.00370324f, -0.04958167f, 0.02529465f, -0.04561936f, 0.02540702f, 
    -0.03158371f, -0.00834720f, 0.00907057f, -0.02993522f, 0.02428997f, -0.02336877f, -0.04912367f, 0.02992696f, 
    -0.00286281f, 0.00400158f, 0.02732218f, -0.00330513f, -0.00117019f, -0.03297117f, 0.01930185f, 0.02840697f, 
    -0.03569845f, -0.02380364f, -0.00035732f, -0.01175215f, 0.02512448f, -0.04002658f, -0.03640508f, -0.01843623f, 
    0.01120943f, -0.01421550f, 0.04148747f, 0.04389461f, -0.05577687f, -0.05579085f, 0.04086114f, -0.02918144f, 
    0.01675153f, 0.01626236f, -0.00986571f, 0.01708897f, 0.03415999f, -0.03066097f, 0.01358514f, -0.05017587f, 
    -0.04345156f, -0.04445569f, -0.01557278f, -0.04114638f, -0.00138544f, 0.00465274f, -0.02206641f, 0.00990779f, 
    -0.01054791f, -0.03509896f, -0.01273492f, 0.03772714f, -0.00069688f, 0.02454141f, -0.04040469f, 0.04161656f, 
    -0.05568688f, -0.04419564f, -0.04823343f, 0.04171145f, -0.03992731f, -0.04497612f, 0.01092649f, 0.00001062f, 
    -0.03884235f, -0.00487410f, 0.02621090f, 0.02389645f, -0.03679073f, -0.05303631f, -0.03270486f, 0.01112078f, 
    -0.05084056f, -0.02793016f, -0.02332030f, -0.03186798f, 0.01611644f, -0.01989187f, -0.03626600f, -0.01658750f, 
    0.02640913f, 0.01893658f, -0.02616838f, -0.02560876f, -0.01128718f, -0.03841179f, -0.04319992f, -0.03466357f, 
    -0.03959757f, 0.04583731f, 0.03153273f, 0.02581370f, -0.03809329f, -0.04619114f, -0.03325257f, 0.03716736f, 
    -0.04857446f, -0.04317888f, 0.04123803f, -0.02361939f, 0.00954945f, -0.04965849f, 0.00470234f, 0.01831896f, 
    0.01918240f, 0.01175136f, -0.02140547f, -0.04472822f, -0.02930425f, 0.00363342f, -0.01687774f, -0.02199228f, 
    -0.00820983f, -0.03429121f, 0.01483287f, -0.00761615f, -0.03020916f, 0.02160846f, 0.01960918f, 0.01633511f, 
    -0.04253534f, 0.09678879f, 0.05040893f, 0.13901277f, 0.12357470f, 0.06038222f, 0.09283187f, -0.11041456f, 
    -0.18859418f, 0.22557639f, 0.13677335f, 0.05902724f, 0.45792621f, 0.50643611f, -0.12701289f, -0.20496771f, 
    0.30696559f, 0.19599511f, 0.03831913f, -0.17898121f, 0.01224129f, 0.01542823f, 0.13154334f, -0.02423730f, 
    0.17564304f, 0.17053026f, 0.18960038f, 0.16041853f, -0.02177449f, 0.02605896f, 0.21131527f, 0.34264097f, 
    -0.00441650f, 0.18735009f, 0.00654467f, 0.24517247f, 0.04875389f, 0.10445679f, -0.11470010f, 0.00028399f, 
    -0.06895409f, -0.09334784f, -0.00358200f, -0.10153034f, -0.15815309f, -0.23280619f, -0.08184201f, -0.05555325f, 
    -0.16265585f, -0.13155732f, 0.22858801f, 0.26978263f, -0.08184468f, -0.07351429f, -0.13154173f, 0.02932018f, 
    -0.24169284f, -0.21811843f, -0.07106145f, -0.04071674f, 0.13918392f, 0.28880548f, 0.23663120f, -0.14272173f, 
    -0.08916271f, -0.11283971f, -0.11323273f, -0.11440471f, -0.15135032f, -0.05707732f, -0.07065430f, -0.02440524f, 
    0.13188101f, -0.28393990f, 0.32946137f, 0.09202369f, 0.00760808f, -0.02993180f, -0.00713448f, -0.00960952f, 
    -0.17051405f, -0.09554022f, -0.06137522f, -0.05210862f, 0.02104895f, 0.04156100f, 0.02149997f, -0.18784024f, 
    -0.17214815f, 0.00910588f, -0.04702218f, -0.06035734f, 0.01103121f, 0.21323635f, 0.11354148f, 0.12605296f, 
    0.03248011f, 0.05386128f, 0.03839123f, 0.10871513f, -0.04517275f, -0.06457662f, 0.02749874f, -0.05108786f, 
    0.05194454f, 0.04874431f, 0.08988564f, -0.06952133f, -0.03628796f, -0.06155484f, 0.00004250f, 0.03097503f, 
    0.06764285f, -0.08340184f, 0.07083230f, 0.05086010f, 0.05627213f, 0.08825021f, 0.28447291f, -0.06072509f, 
    0.08484564f, 0.00391532f, 0.56316596f, 0.04283838f, 0.07200727f, 0.14845771f, -0.06012148f, 0.09556281f, 
    0.01695647f, -0.06187915f, -0.01117095f, 0.03615715f, 0.03571267f, 0.00252388f, -0.49447834f, -0.40679589f, 
    -0.09162427f, 0.11268729f, 0.11387707f, -0.03773281f, 0.21629630f, 0.08098222f, 0.16610844f, -0.00500224f, 
    0.11748159f, 0.11869808f, 0.10358304f, 0.01197892f, -0.05106052f, -0.10356531f, -0.02048547f, -0.02491747f, 
    0.03281169f, 0.07130833f, 0.09985225f, 0.04909748f, 0.18080565f, -0.08707143f, 0.08835973f, 0.03025397f, 
    -0.09902407f, 0.02951554f, 0.02104577f, 0.01789100f, -0.05692640f, 0.08309601f, 0.03776010f, -0.03420475f, 
    0.10880463f, -0.17705271f, -0.20873289f, 0.32620734f, 0.01627296f, 0.10842960f, 0.30351725f, 0.22315545f, 
    -0.07518351f, 0.12748075f, 0.09533480f, 0.25436121f, 0.30171400f, -0.02596726f, -0.13298388f, 0.19526428f, 
    0.05011389f, 0.09587519f, 0.03054851f, 0.10485184f, 0.07266120f, 0.02385384f, 0.00359264f, -0.05661687f, 
    0.12823261f, 0.24108374f, 0.04206390f, 0.27528772f, 0.02857161f, 0.06465133f, 0.08023882f, 0.11736137f, 
    0.06310851f, -0.11757544f, -0.03965423f, -0.13225886f, 0.23550552f, 0.33790657f, -0.23838119f, 0.11821526f, 
    0.09240260f, -0.02961146f, 0.02245507f, -0.05714423f, -0.06904305f, 0.10790399f, -0.07714235f, 0.16127020f, 
    0.28800476f, 0.26959074f, 0.16073929f, 0.20701544f, -0.14133783f, -0.15364404f, -0.05875957f, 0.01678938f, 
    -0.08804343f, 0.09790276f, 0.02298750f, -0.01684828f, 0.08832829f, -0.04296632f, 0.09185687f, 0.14476874f, 
    -0.06399599f, -0.05078584f, -0.01593691f, 0.03017174f, -0.02784941f, 0.02610954f, 0.06337864f, 0.07320897f, 
    -0.04089853f, -0.00837764f, -0.00322719f, -0.12602060f, -0.12855616f, 0.02455332f, 0.02249037f, -0.10601674f, 
    0.07464251f, 0.25432986f, 0.20690931f, 0.19105931f, 0.04171742f, 0.58187330f, -0.01918899f, -0.49511304f, 
    -0.12685122f, -0.03661069f, 0.15172727f, -0.03828757f, 0.00198527f, 0.06750177f, -0.08998079f, 0.01019427f, 
    -0.01049602f, 0.01877239f, -0.05783746f, 0.02228315f, -0.08940907f, -0.05359040f, 0.04020801f, -0.00956534f, 
    -0.09662563f, 0.05682986f, -0.06910998f, -0.03104035f, 0.45848539f, -0.05267076f, 0.06157932f, 0.01228255f, 
    -0.00749235f, 0.12381314f, 0.26095909f, 0.14837410f, -0.06756562f, -0.12315821f, -0.08620661f, -0.07749902f, 
    0.11071038f, -0.42213067f, -0.17266338f, 0.19637464f, 0.26438415f, 0.14409675f, 0.12729381f, 0.24149442f, 
    0.01162175f, -0.01033224f, 0.07058835f, -0.03834680f, 0.26135457f, -0.45408601f, 0.06467223f, -0.44315442f, 
    0.11136242f, 0.25723717f, 0.05994524f, 0.01004026f, 0.23842551f, 0.11568132f, 0.05461663f, -0.18547107f, 
    -0.19754878f, -0.05875687f, 0.29753652f, 0.34029806f, -0.08196856f, -0.03948902f, -0.22836645f, -0.04546423f, 
    -0.09103226f, -0.07023566f, -0.15694621f, 0.00535708f, 0.14256477f, -0.00879058f, 0.16585776f, -0.10722175f, 
    0.26400152f, 0.05381767f, -0.07757501f, 0.03531297f, -0.13871858f, -0.14463158f, -0.14743355f, -0.06893720f, 
    -0.05306995f, -0.10773137f, 0.29625809f, -0.01478194f, -0.07793641f, -0.11745114f, -0.09228341f, 0.00744898f, 
    -0.11016084f, -0.05541291f, -0.12807442f, 0.07947117f, 0.46706301f, -0.05880016f, 0.13429548f, -0.53816581f, 
    -0.13061856f, 0.02345619f, 0.18298282f, -0.01272782f, -0.02832851f, 0.13430788f, 0.06413058f, 0.11200383f, 
    -0.02285812f, -0.11305109f, -0.18572490f, -0.12303220f, 0.10939794f, -0.02782952f, -0.01699673f, 0.03872894f, 
    -0.05246934f, 0.00568732f, -0.11039685f, -0.17909361f, 0.50347733f, -0.02342145f, 0.00570671f, -0.16692600f, 
    0.19441046f, 0.23502198f, -0.03216979f, 0.09181882f, -0.02377196f, 0.06333233f, -0.00476594f, -0.13768427f, 
    -0.01200177f, 0.03149805f, 0.02171860f, 0.02217689f, 0.01659705f, -0.01245876f, 0.01099092f, -0.00916158f, 
    -0.03763124f, -0.02727056f, -0.02805175f, 0.00301255f, -0.02290918f, -0.00426883f, -0.02222893f, 0.03342287f, 
    0.01855943f, -0.01612629f, 0.04297830f, 0.00157577f, 0.01152621f, 0.00492326f, 0.02013265f, 0.01719962f, 
    -0.01758670f, -0.01173516f, 0.02352773f, -0.03120462f, 0.04577447f, -0.04142481f, -0.00169211f, 0.00098990f, 
    -0.04812923f, 0.00067032f, -0.04959207f, 0.00719776f, -0.01628209f, 0.01111687f, 0.00749040f, 0.02510163f, 
    -0.00608364f, -0.00677819f, 0.04120436f, 0.04379179f, -0.01586601f, -0.01457382f, -0.00854759f, -0.00399824f, 
    -0.04539455f, 0.04479746f, -0.04432930f, -0.00014377f, -0.04696707f, -0.05962397f, -0.04562107f, 0.01437420f, 
    -0.03249978f, -0.01325058f, 0.00114185f, -0.05512228f, -0.03144874f, -0.03969903f, 0.02091661f, 0.02711281f, 
    -0.03871668f, -0.04896501f, -0.01905264f, 0.02140139f, -0.01965643f, -0.03678586f, -0.04187848f, -0.02248280f, 
    0.02324227f, 0.04191521f, 0.01705306f, 0.02426868f, 0.00872966f, -0.03288206f, -0.04261709f, -0.04475792f, 
    0.03159279f, 0.01261367f, -0.05056269f, -0.04415759f, -0.00142493f, 0.03824901f, -0.05208365f, 0.02108923f, 
    0.02049392f, -0.04171750f, -0.06325652f, -0.05286004f, 0.01604227f, -0.00821454f, -0.06209270f, -0.05621250f, 
    0.03287735f, -0.02708374f, -0.03593070f, 0.02064540f, 0.01656186f, -0.06226649f, 0.02795406f, -0.05426565f, 
    -0.00103085f, -0.00981143f, -0.01020560f, 0.00088667f, -0.03340354f, 0.02990017f, -0.03504297f, -0.00821303f, 
    -0.02046595f, 0.03348498f, -0.00182715f, -0.04686569f, 0.02376718f, -0.04181707f, -0.04261294f, -0.02095607f, 
    0.02777929f, 0.02838824f, -0.02510194f, -0.01969051f, -0.03455935f, -0.03869218f, -0.00985502f, -0.04995854f, 
    -0.00421957f, -0.00803257f, 0.01890583f, 0.01061661f, 0.03397574f, -0.03979572f, -0.06266308f, -0.05024841f, 
    -0.02514689f, -0.04557512f, -0.05932910f, -0.01236192f, 0.01461723f, -0.02185609f, 0.03489476f, -0.04315977f, 
    0.01318297f, 0.02121517f, 0.00709792f, -0.04469895f, 0.03756176f, 0.03776010f, 0.02614307f, -0.04708148f, 
    0.02389931f, -0.05015780f, -0.01062738f, -0.00066457f, 0.01119272f, -0.02632901f, -0.00083659f, -0.00726286f, 
    0.01983834f, -0.02303763f, -0.00677425f, 0.00126696f, -0.05002761f, 0.02774792f, 0.02886551f, -0.01196593f, 
    -0.04874747f, 0.00807024f, -0.00439767f, -0.04543887f, 0.00728522f, 0.00915942f, 0.00687079f, 0.01118270f, 
    -0.00954106f, -0.01594662f, -0.04116756f, 0.00791916f, 0.02891562f, -0.00309328f, 0.00218354f, 0.01925574f, 
    -0.05145650f, 0.03894915f, 0.03648984f, 0.03102912f, 0.02240114f, 0.03643901f, -0.01073576f, 0.00456847f, 
    0.00823377f, -0.02703349f, -0.04916204f, 0.03802243f, -0.01534381f, 0.02277914f, -0.04193538f, 0.02853202f, 
    0.02939980f, -0.03401258f, -0.05026692f, 0.03877845f, 0.03851080f, 0.00902407f, 0.03091367f, 0.03999031f, 
    -0.04650664f, -0.04984065f, 0.01320028f, -0.04213781f, -0.05093291f, -0.04769140f, 0.04343951f, -0.01873832f, 
    -0.02172180f, 0.01667422f, -0.02520536f, -0.00455055f, -0.00020416f, 0.03756756f, -0.00460441f, 0.00809921f, 
    -0.05542659f, -0.00150446f, -0.04088788f, -0.04580943f, 0.02676808f, -0.00885487f, 0.01100027f, 0.02940155f, 
    -0.03897982f, -0.03117273f, 0.02768428f, -0.02631070f, 0.00469972f, -0.04197211f, -0.01162002f, 0.00826443f, 
    0.02997312f, 0.01444770f, -0.02581431f, 0.00866045f, 0.03168609f, 0.02767958f, -0.00596806f, 0.02350171f, 
    0.03112678f, 0.02832776f, 0.00362765f, -0.02512247f, -0.04747147f, -0.00961527f, -0.01604683f, 0.01879530f, 
    0.01393379f, -0.04479848f, 0.02993144f, -0.03135122f, 0.03346646f, -0.04689131f, -0.05119473f, -0.02719097f, 
    -0.02163425f, -0.05608987f, -0.04446289f, 0.03812297f, 0.00592368f, -0.01718028f, 0.04090211f, -0.01606345f, 
    0.01825361f, -0.06112103f, -0.04448867f, -0.03090342f, 0.01928464f, 0.01032105f, 0.00841417f, 0.03841291f, 
    0.01042736f, 0.01712342f, -0.02194125f, 0.02549974f, 0.00695443f, -0.02840307f, -0.01799524f, 0.03289960f, 
    -0.04102270f, -0.01148502f, -0.00999601f, 0.04458899f, 0.01892836f, -0.02200718f, -0.02216654f, -0.00084565f, 
    -0.02454809f, 0.03571200f, 0.02088829f, -0.03412631f, 0.03213217f, 0.00966089f, -0.02096742f, 0.01353605f, 
    0.04530129f, -0.03366313f, 0.02034815f, 0.03306938f, -0.04600278f, -0.01962789f, 0.02581141f, 0.03909742f, 
    0.02193682f, -0.00800318f, -0.02763906f, -0.01086526f, 0.02702294f, 0.01522041f, -0.03726160f, 0.00084579f, 
    0.02696477f, 0.04335556f, -0.04731876f, -0.02736229f, 0.03665542f, 0.00282878f, -0.03289229f, -0.02515579f, 
    -0.01709560f, 0.04292259f, -0.02719386f, -0.02446145f, 0.01480320f, -0.04109477f, -0.03800077f, 0.03106555f, 
    -0.01383623f, -0.01380610f, -0.03205627f, -0.00896637f, -0.00178635f, -0.05688032f, -0.04290206f, -0.05654236f, 
    0.00880721f, -0.00799608f, 0.02927368f, 0.03139326f, -0.00367163f, 0.03165226f, -0.02064729f, -0.04440676f, 
    0.01361778f, 0.00287526f, -0.05106841f, -0.01347278f, 0.02012849f, -0.03213635f, 0.03612480f, 0.02528175f, 
    0.05034595f, -0.03895053f, -0.01351057f, -0.03635157f, -0.04722329f, -0.00742208f, 0.03074073f, -0.01316293f, 
    -0.04080174f, -0.04344593f, -0.04127005f, 0.00413278f, 0.02001995f, -0.02668167f, 0.02521780f, 0.03683928f, 
    0.03228496f, 0.00774595f, 0.03471678f, -0.00355059f, -0.00169637f, 0.00125810f, 0.00423756f, 0.03052456f, 
    -0.41624418f, 0.21919639f, -0.00943100f, 0.16101570f, 0.19944516f, -0.05156460f, 0.07598486f, -0.07768804f, 
    -0.12762882f, 0.14222099f, 0.04139901f, -0.07912986f, 0.20084488f, 0.02173032f, -0.28511357f, 0.06545017f, 
    0.30601695f, 0.14554846f, -0.03717407f, 0.06338605f, -0.07803411f, 0.07582817f, 0.37919647f, -0.06093718f, 
    0.05831767f, -0.07737708f, -0.15089394f, -0.05323687f, 0.03131787f, -0.18535708f, 0.03095551f, 0.15677755f, 
    -0.09336232f, 0.13671486f, 0.14324604f, 0.09828749f, 0.03843106f, 0.48173803f, 0.04833500f, -0.11332226f, 
    -0.11087409f, -0.09666713f, 0.07510649f, -0.04551703f, 0.03694199f, 0.24676390f, 0.02946938f, 0.02919471f, 
    -0.18921433f, 0.13417339f, 0.50706881f, 0.01278356f, -0.07158333f, -0.03487343f, -0.11425480f, 0.00499127f, 
    0.15843770f, 0.12027887f, 0.16879249f, 0.04360220f, 0.04493755f, 0.29611906f, 0.32447359f, -0.09400401f, 
    -0.12541184f, -0.05872409f, -0.15986203f, -0.07221074f, -0.06391994f, 0.11818241f, 0.11539834f, 0.02496800f, 
    0.25000522f, 0.00409871f, 0.30959088f, -0.05519022f, -0.14680856f, -0.03274154f, -0.00716053f, 0.00734867f, 
    -0.04484064f, 0.07156198f, 0.07761934f, -0.01679094f, -0.04380294f, 0.10258681f, 0.04951738f, -0.07341977f, 
    -0.09250122f, 0.12656760f, 0.03980673f, -0.02800836f, 0.12064356f, 0.16933398f, 0.19602570f, 0.09382658f, 
    0.32002085f, -0.29591468f, 0.14161630f, -0.07157540f, -0.27813199f, -0.06173144f, 0.01775838f, -0.04644944f, 
    -0.13241708f, -0.06614859f, -0.02168463f, -0.08109306f, -0.11396095f, 0.18067266f, 0.16653493f, -0.08803289f, 
    0.05165910f, -0.02946495f, 0.09517642f, 0.01297428f, 0.04329382f, 0.13037989f, 0.34776539f, -0.11579224f, 
    0.29173476f, -0.11456371f, 0.16235732f, -0.21315144f, 0.03791218f, 0.06377073f, -0.07487521f, -0.15189318f, 
    -0.02386430f, -0.12975332f, -0.05426493f, -0.01353673f, -0.06077764f, 0.16321121f, -0.16548568f, -0.14760076f, 
    0.13556631f, -0.00226371f, 0.17009032f, 0.03139314f, -0.06616943f, 0.06266573f, 0.09223886f, 0.01677178f, 
    0.14875980f, 0.21211185f, 0.33440167f, -0.04212680f, -0.09017446f, -0.07169534f, -0.07321347f, -0.09466670f, 
    0.03301896f, 0.14039889f, 0.10603281f, -0.10176598f, 0.13164897f, -0.16787118f, -0.05608439f, -0.01205812f, 
    0.08823261f, 0.10262957f, -0.00541524f, 0.11107349f, -0.07973237f, 0.04138922f, 0.01018620f, -0.19238655f, 
    0.03416693f, -0.04615156f, 0.00510538f, 0.20299478f, -0.08302896f, -0.12581928f, 0.20848987f, 0.20085032f, 
    -0.20908006f, 0.32796082f, 0.25062686f, 0.01826445f, 0.12746811f, -0.15164442f, -0.02357557f, 0.13643607f, 
    0.06462091f, -0.14889003f, -0.05031152f, 0.08066080f, -0.01332906f, 0.02661487f, 0.15926115f, 0.04926054f, 
    0.00466957f, 0.07941167f, -0.05278777f, 0.19589791f, 0.01328907f, -0.05870500f, 0.05209738f, 0.03595899f, 
    0.12956378f, 0.16321725f, 0.06620065f, -0.05589822f, -0.18163192f, 0.12269782f, -0.02458898f, 0.25810382f, 
    0.14051017f, -0.13255967f, 0.04526367f, -0.11014522f, -0.04715066f, 0.01613221f, 0.09743518f, 0.00362518f, 
    0.12081493f, 0.09842692f, 0.50969452f, 0.20009200f, -0.33873981f, -0.14084661f, -0.23605466f, -0.05747486f, 
    -0.05184355f, 0.07449549f, -0.14305726f, 0.19006376f, -0.04133043f, -0.16326258f, -0.13218442f, 0.10039490f, 
    -0.04064195f, -0.08798771f, -0.21006796f, -0.01685530f, -0.03928976f, -0.04151260f, -0.10054927f, -0.12418635f, 
    -0.07937113f, -0.06775630f, -0.01990965f, -0.10934728f, -0.03477639f, 0.11244135f, 0.10211240f, 0.02743808f, 
    0.04091619f, 0.02544114f, 0.11835293f, -0.09121963f, -0.45351344f, 1.18287957f, -0.04556802f, -0.24346121f, 
    0.17469825f, 0.00051592f, -0.07907050f, -0.00146817f, -0.20124038f, 0.00615599f, 0.06545711f, 0.12633474f, 
    -0.15582059f, 0.16675019f, -0.13617544f, 0.22642301f, -0.25448853f, -0.03219010f, -0.00531147f, 0.11183439f, 
    -0.05205723f, 0.25471351f, -0.17198811f, 0.15742214f, 0.09680161f, -0.16447431f, -0.08673775f, 0.05483716f, 
    -0.07360677f, 0.00980239f, 0.14328712f, 0.00977968f, 0.03550137f, -0.07325776f, 0.13332465f, -0.07454450f, 
    -0.30350396f, -0.37714511f, -0.08033902f, 0.13175480f, -0.00907790f, -0.04554582f, 0.03521301f, 0.05765750f, 
    -0.17031571f, 0.10975999f, 0.15166774f, -0.05334356f, 0.80654866f, -0.08870228f, 0.18143559f, -0.04219884f, 
    0.02933356f, 0.07643452f, 0.10006233f, -0.05475283f, -0.13773581f, 0.13533109f, 0.02151419f, -0.01930066f, 
    -0.09372872f, 0.29144016f, 0.10699238f, 0.19436969f, -0.14934310f, -0.03579449f, -0.17363761f, 0.14658050f, 
    0.03523222f, 0.12263009f, -0.00394449f, 0.12825464f, -0.09400789f, -0.37539849f, 0.11086752f, 0.06630820f, 
    -0.05182349f, -0.09737941f, 0.01866836f, 0.09365372f, 0.05606972f, 0.15513803f, 0.13507695f, 0.05591666f, 
    0.54719770f, -0.09157442f, 0.43103847f, -0.23816282f, -0.09920878f, 0.00367262f, -0.05898139f, 0.09466146f, 
    -0.04668965f, 0.15159823f, 0.12550627f, 0.02519549f, 0.30138284f, 0.14031847f, 0.03383875f, -0.45519444f, 
    -0.03059440f, 0.25810957f, 0.00272681f, -0.10905796f, -0.04986434f, 0.12573455f, -0.09096675f, 0.11030087f, 
    0.10629676f, -0.01130428f, -0.07216498f, 0.01872692f, -0.02049692f, -0.08888698f, -0.02540759f, -0.10357478f, 
    -0.00685582f, 0.19339123f, -0.09839142f, 0.09300505f, 0.52387625f, -0.26651180f, 0.11294656f, -0.09308314f, 
    0.12765205f, -0.04033884f, -0.09223697f, -0.12896405f, -0.00963983f, 0.09670537f, 0.09570814f, 0.15441138f, 
    -0.15150505f, 0.12519738f, -0.09647831f, -0.10115331f, 0.07886684f, -0.05528780f, 0.08516525f, 0.24330845f, 
    0.22559783f, -0.10698601f, -0.04069944f, -0.04534706f, -0.29632914f, -0.10808355f, -0.24153344f, 0.42800865f, 
    -0.19393167f, 0.00469769f, -0.03992428f, -0.16093375f, -0.04650365f, 0.23492785f, 0.03944544f, 0.32360843f, 
    -0.01976053f, 0.04922830f, 0.00079004f, 0.29718238f, 0.09170995f, 0.17820928f, -0.04185462f, -0.03723216f, 
    -0.00915900f, -0.18749341f, -0.08992636f, -0.07050201f, -0.00005194f, -0.17216250f, 0.11525869f, -0.12769459f, 
    0.12505168f, 0.10172581f, -0.03681966f, 0.06454594f, 0.02651763f, 0.17228673f, 0.05577473f, -0.03383798f, 
    0.18803410f, 0.21559574f, 0.01384378f, -0.05047286f, 0.03467854f, -0.04343017f, 0.11238652f, -0.07933177f, 
    0.07951557f, 0.18693265f, 0.11553688f, 0.02466384f, 0.06444809f, -0.21651913f, -0.03580527f, 0.18327069f, 
    0.01171425f, 0.03953002f, 0.07019835f, 0.16115540f, 0.09897216f, -0.17117134f, 0.01872881f, -0.06010686f, 
    -0.01979450f, 0.27160981f, -0.10899130f, -0.11372498f, 0.05231510f, -0.04033988f, 0.04630041f, 0.04271413f, 
    0.20777865f, -0.11061613f, 0.01299826f, -0.15592702f, -0.03289901f, -0.11996512f, -0.09056489f, 0.13753767f, 
    0.25789189f, -0.07005357f, 0.01949466f, 0.03572161f, 0.13830462f, 0.02702358f, 0.00444017f, 0.04251312f, 
    0.09810857f, -0.10985429f, -0.33040550f, -0.11549543f, 0.01389431f, 0.07949369f, -0.03565370f, 0.00098720f, 
    -0.01897424f, -0.01078467f, -0.11543311f, -0.18735455f, -0.17252159f, 0.09031550f, -0.03961163f, 0.03383480f, 
    -0.02167573f, -0.05472109f, -0.13804477f, 0.17234795f, 0.04457470f, 0.15086801f, -0.12021860f, 0.10477091f, 
    0.18417653f, 0.05575943f, -0.38666019f, 0.04099380f, -0.04610026f, -0.10848263f, 0.25719786f, 0.14186846f, 
    0.00745027f, 0.10570141f, -0.10642480f, 0.06731593f, 0.18348701f, 0.16176546f, 0.35763574f, 0.39118826f, 
    0.08372670f, -0.06547579f, -0.25136366f, 0.05369794f, -0.08803657f, 0.11083294f, -0.06111153f, 0.21638906f, 
    0.00950323f, -0.23533325f, -0.18931544f, 0.03360970f, -0.09321797f, 0.17156292f, 0.07913419f, 0.10633416f, 
    -0.08104156f, -0.04839859f, -0.16776489f, -0.27487022f, -0.01211627f, 0.17011558f, 0.08684774f, 0.08039284f, 
    0.06341670f, -0.05145704f, -0.06590797f, 0.11014557f, 0.17124657f, -0.11006621f, -0.04504954f, -0.09768910f, 
    -0.03961897f, 0.06076312f, 0.37821478f, -0.15306915f, 0.06602150f, 0.08008846f, -0.22303203f, -0.05437542f, 
    -0.02250849f, -0.16548078f, -0.16235432f, -0.13303821f, -0.13466367f, -0.06533015f, 0.14305271f, -0.01676543f, 
    -0.09002009f, 0.02297076f, 0.07285805f, 0.11129984f, 0.00853982f, 0.02805530f, 0.02441879f, 0.07055314f, 
    -0.09186909f, 0.02763731f, 0.15947893f, -0.13218687f, -0.09069117f, 0.00728963f, -0.03494214f, 0.15770617f, 
    0.08864892f, 0.14591402f, 0.01706402f, 0.31679466f, -0.41648966f, 0.21192126f, 0.18183006f, 0.08726647f, 
    -0.10318874f, 0.02279125f, 0.01157198f, 0.06356485f, 0.03217435f, 0.00522557f, -0.12274621f, -0.00875148f, 
    -0.06367052f, 0.12403236f, -0.20721133f, -0.07321739f, 0.28932473f, 0.09321028f, 0.17239851f, 0.20311914f, 
    0.11376890f, -0.12683930f, -0.07707991f, -0.25896478f, 0.00438649f, 0.00497505f, 0.18550555f, 0.15721887f, 
    -0.05659024f, 0.04004610f, 0.04672335f, -0.01633527f, 0.06756927f, -0.17122056f, -0.05584864f, 0.03742195f, 
    -0.04115287f, -0.21592775f, -0.07412863f, 0.10892641f, 0.08290406f, -0.06893178f, -0.04555802f, 0.00623647f, 
    0.11158659f, -0.00570415f, 0.05849595f, 0.01242820f, 0.13605499f, -0.57681149f, 0.34600106f, 0.44891074f, 
    0.27438870f, 0.35980284f, -0.02348294f, 0.01284154f, -0.01125528f, -0.05162020f, -0.05539393f, -0.09330399f, 
    -0.12370133f, -0.04766148f, 0.01831901f, -0.13456142f, 0.14386472f, -0.04369571f, -0.19590418f, 0.14926672f, 
    0.07553676f, -0.00026913f, 0.14443733f, 0.03082091f, -0.35899141f, -0.01742758f, 0.21638186f, 0.11061532f, 
    -0.11445610f, -0.07443478f, -0.09626856f, -0.03637877f, 0.10830626f, 0.20395043f, -0.06379686f, 0.05048732f, 
    0.01195359f, 0.19876474f, 0.31845823f, 0.10365867f, -0.01316143f, -0.10086918f, 0.02005561f, 0.04496485f, 
    0.22315302f, 0.10676125f, 0.08440916f, 0.07214180f, 0.01081530f, 0.54103917f, 0.18135646f, 0.27324516f, 
    -0.09103843f, -0.24445182f, 0.06986443f, -0.15691003f, -0.12352331f, -0.10094852f, 0.10717313f, -0.01235267f, 
    0.15623412f, 0.08076037f, 0.08666468f, -0.30688044f, 0.04239578f, 0.01895939f, 0.14988467f, -0.00448770f, 
    0.27116457f, -0.01494613f, 0.05183798f, 0.17082198f, 0.21946432f, 0.18086794f, 0.02132058f, 0.20414044f, 
    -0.07003771f, 0.06387091f, 0.00992390f, 0.02448145f, 0.03028184f, 0.02114616f, -0.09148597f, 0.06145843f, 
    0.38482860f, 0.01679471f, -0.48726138f, 0.17876177f, 0.00674733f, -0.11111912f, 0.11316595f, -0.16696894f, 
    0.15012300f, -0.25115827f, 0.07796519f, 0.11910403f, -0.26411247f, -0.11826929f, 0.02562772f, 0.47082913f, 
    0.08625314f, -0.08125432f, -0.08374290f, -0.13437328f, 0.13505843f, -0.08307130f, -0.20848541f, -0.00965810f, 
    -0.12912795f, 0.16004413f, 0.21211521f, 0.13957816f, -0.03423661f, -0.22057019f, 0.01905249f, 0.13040014f, 
    0.12267882f, 0.06386428f, 0.14972474f, 0.24957469f, -0.40044802f, -0.06395250f, -0.18245767f, 0.15141402f, 
    -0.04714110f, -0.20342594f, 0.15496227f, -0.04808905f, 0.12386390f, -0.06144322f, 0.19543713f, 0.21083610f, 
    -0.43089288f, -0.07148758f, -0.50803339f, -0.07837249f, 0.07009237f, -0.20990191f, -0.16842915f, -0.32993159f, 
    -0.16989003f, -0.15342374f, 0.05933736f, -0.24564275f, 0.27436298f, 0.15770912f, 0.51865375f, -0.56646806f, 
    0.08754829f, 0.08132012f, -0.07664652f, 0.00486780f, -0.11863121f, 0.01843112f, -0.12221110f, -0.16741808f, 
    0.23171867f, 0.05045875f, 0.34051386f, -0.01312106f, -0.05114191f, -0.06102631f, 0.09767837f, 0.09268595f, 
    -0.15311193f, -0.06927404f, -0.11173331f, -0.21278678f, -0.17436346f, 0.42825857f, -0.28475082f, 0.23990199f, 
    0.09286496f, -0.10333735f, 0.09072374f, -0.01918571f, 0.07646155f, 0.16812332f, 0.02367287f, 0.04014359f, 
    -0.42131045f, -0.27970526f, -0.18780589f, 0.21057552f, 0.00951684f, 0.05329338f, -0.15896156f, -0.07886596f, 
    0.06277528f, 0.22279890f, 0.09582276f, 0.04825066f, -0.48462981f, -0.04663430f, 0.06907339f, -0.07953837f, 
    -0.08970179f, 0.03090509f, -0.17538749f, -0.07559963f, -0.07154847f, 0.10895960f, -0.01251633f, 0.02171399f, 
    -0.16147180f, -0.36096889f, -0.18214634f, -0.04632751f, -0.03060363f, -0.11208611f, -0.34303895f, -0.10397090f, 
    0.04036576f, 0.04944482f, -0.04235001f, -0.08759048f, 0.11827721f, -0.18845747f, 0.31919312f, 0.07422644f, 
    -0.13543482f, -0.11131451f, -0.08944436f, 0.00162387f, 0.00331041f, 0.00995483f, -0.20740356f, -0.26630756f, 
    0.04599576f, -0.43032366f, 0.02793948f, -0.04184146f, -0.18160896f, -0.16960077f, -0.39169326f, 0.09413287f, 
    0.00279505f, -0.10611653f, 0.05722006f, -0.14255981f, -0.23184402f, -0.23882663f, -0.20663765f, -0.20139560f, 
    -0.01579253f, -0.10224564f, -0.07917652f, -0.20550701f, 0.01381015f, -0.01710428f, -0.06552629f, -0.17740956f, 
    0.31205755f, 0.07431217f, 0.22688033f, -0.13467237f, 0.00616530f, 0.09904310f, -0.10429010f, -0.07693826f, 
    0.04886382f, -0.25364888f, -0.03475518f, -0.20280665f, -0.28005549f, -0.01270078f, -0.54266214f, -0.41992059f, 
    0.14456853f, 0.08431531f, 0.13537829f, -0.22261138f, -0.09018996f, -0.08866259f, -0.08523605f, -0.21758655f, 
    -0.20993468f, 0.13031755f, -0.18900885f, 0.13325481f, 0.24379814f, 0.04233507f, -0.11064848f, -0.16312630f, 
    0.04664372f, -0.05289836f, -0.08952545f, -0.09888841f, 0.26041037f, 0.02919119f, -0.03735031f, -0.03394379f, 
    0.06578629f, 0.11239024f, 0.02506455f, 0.13724698f, -0.02600865f, -0.13176973f, -0.12630866f, -0.17889477f, 
    0.18182284f, 0.04476560f, -0.23900102f, 0.38270426f, 0.15417945f, 0.07712953f, 0.01659457f, 0.04312263f, 
    -0.12486852f, 0.14386277f, -0.04719793f, -0.05323420f, 0.26515242f, 0.07607103f, -0.11812420f, 0.26459956f, 
    0.14085828f, 0.01745956f, -0.04356451f, -0.07093272f, -0.07598104f, 0.01574007f, 0.14757219f, 0.05061914f, 
    0.20444635f, 0.21290068f, -0.24175498f, 0.20689970f, 0.04470812f, 0.08613706f, 0.08745860f, -0.03352800f, 
    0.02450519f, 0.14343575f, 0.16045304f, 0.07410534f, 0.22340670f, 0.08009945f, -0.40927777f, 0.09501545f, 
    0.24117665f, 0.11263017f, -0.06206859f, -0.19263493f, 0.05472677f, -0.09273683f, 0.02157459f, 0.06004076f, 
    0.23585340f, 0.12094123f, 0.41156507f, 0.46944034f, 0.03702678f, 0.02491519f, -0.05262843f, 0.09590830f, 
    -0.12826705f, -0.01125660f, -0.12111839f, -0.00970765f, 0.24065809f, 0.19831553f, -0.01434110f, 0.02418908f, 
    0.10262331f, 0.04433114f, -0.01012773f, -0.01238977f, -0.00166249f, -0.04916894f, -0.15569508f, -0.24677451f, 
    -0.01950216f, -0.16373383f, -0.03610631f, -0.07615284f, 0.27663735f, 0.08717544f, 0.22106464f, 0.29162440f, 
    -0.01878776f, -0.01607395f, 0.05735591f, -0.32486022f, -0.05062459f, 0.44370723f, 0.05705741f, -0.02704281f, 
    0.13881023f, 0.05061246f, -0.16096272f, 0.12210969f, -0.23315164f, -0.28079441f, -0.01207870f, -0.01277443f, 
    -0.25799143f, -0.30038354f, -0.32076046f, 0.06655090f, -0.22870882f, -0.10127973f, 0.12596339f, -0.28020856f, 
    0.04325746f, 0.25771219f, -0.17146938f, 0.15676366f, 0.27800271f, 0.12257149f, -0.01720078f, 0.03511773f, 
    0.09005678f, 0.24937496f, 0.13233894f, 0.11148214f, 0.02438288f, -0.13439789f, 0.17094544f, 0.15480660f, 
    0.13948153f, 0.07910243f, -0.11057293f, 0.15257671f, 0.22276340f, 0.06561808f, 0.19346692f, 0.18556407f, 
    -0.02815718f, 0.09601705f, 0.20733839f, 0.09931429f, 0.45175529f, -0.26719597f, 0.10401932f, 0.10586024f, 
    0.15463281f, 0.21067050f, -0.07226273f, -0.11510894f, 0.05342809f, 0.10747800f, -0.21981494f, 0.03717843f, 
    -0.22672866f, -0.01770622f, -0.10520142f, 0.10581002f, -0.17865819f, 0.05144154f, -0.11990172f, 0.10218264f, 
    -0.01390125f, 0.14334485f, 0.20913698f, 0.06186011f, 0.10746384f, 0.14276852f, 0.47054017f, 0.17118917f, 
    -0.23276693f, 0.00717919f, 0.02862971f, 0.06957611f, 0.13122416f, 0.18464142f, 0.19369787f, 0.13596633f, 
    0.14236985f, -0.18960147f, 0.34376326f, -0.03776233f, -0.27945858f, 0.17661655f, -0.12785591f, 0.14422029f, 
    0.04566301f, 0.14195283f, 0.04213387f, 0.12553591f, 0.07546654f, -0.17949791f, -0.16030936f, -0.19237936f, 
    -0.11909836f, 0.04992926f, -0.03224350f, 0.00093687f, 0.00504704f, -0.09737323f, 0.21369277f, -0.10962172f, 
    0.16039075f, -0.13944030f, -0.01565144f, 0.14715418f, 0.32396376f, 0.34852737f, 0.13539416f, -0.12313844f, 
    0.05323301f, 0.16955960f, -0.05336969f, 0.16854696f, 0.55034655f, 0.03828014f, 0.16770639f, 0.02972643f, 
    0.16336440f, 0.29902458f, 0.06183673f, 0.03455327f, -0.03344359f, 0.16181076f, 0.14304167f, 0.26520979f, 
    -0.05384198f, 0.02500432f, -0.03991347f, -0.00762279f, 0.01153816f, 0.02022134f, 0.02918006f, -0.03628654f, 
    -0.01241167f, -0.05705959f, -0.01052247f, -0.04848212f, -0.00915715f, 0.00990014f, 0.04141469f, 0.01298103f, 
    0.01802849f, -0.05003189f, -0.04853351f, -0.04801945f, 0.02834424f, 0.04315296f, -0.03500759f, 0.00976780f, 
    0.01930682f, 0.02355660f, 0.01053526f, 0.03797535f, 0.01065596f, -0.01674975f, -0.05393170f, 0.01020940f, 
    0.04916324f, -0.02556196f, 0.01193628f, 0.03256858f, -0.03775821f, -0.06055181f, -0.00778240f, -0.02984970f, 
    0.02913971f, -0.05066487f, -0.05096588f, -0.03573592f, -0.03002086f, -0.03320477f, 0.01136119f, 0.01807459f, 
    0.01477793f, -0.05002151f, 0.00595396f, -0.02751546f, -0.04634561f, -0.02415827f, -0.01094126f, -0.02058059f, 
    -0.03191333f, -0.01778922f, -0.02799529f, -0.05689373f, -0.04320718f, -0.04863582f, -0.01937191f, -0.00994632f, 
    -0.04052863f, -0.04216443f, -0.05057595f, 0.00921249f, -0.00088158f, 0.00927694f, 0.00335565f, -0.00610513f, 
    -0.02277798f, -0.02382117f, -0.03073296f, -0.01507646f, -0.02306776f, -0.01540161f, -0.02283025f, -0.02839784f, 
    0.02212631f, 0.00315715f, -0.01719629f, -0.00445684f, 0.04118885f, -0.02141821f, -0.01931525f, 0.05113075f, 
    -0.00979860f, -0.00798624f, -0.04706158f, 0.02340578f, -0.02004664f, 0.00774117f, 0.04035917f, -0.06205017f, 
    0.02025468f, -0.00981751f, 0.03279324f, -0.02942540f, -0.03768039f, 0.01997315f, 0.01942117f, -0.03870713f, 
    -0.02446378f, -0.05694450f, 0.04291087f, 0.03806765f, -0.03715304f, -0.03576604f, -0.04430913f, 0.00253694f, 
    -0.00030811f, -0.01600357f, -0.00230556f, -0.01005684f, 0.03518357f, 0.01013174f, 0.03954592f, -0.04391807f, 
    0.01110806f, 0.03654297f, 0.00038200f, 0.00740474f, -0.04075059f, -0.01097654f, -0.00309750f, -0.05045999f, 
    0.01411249f, -0.03967372f, -0.02406468f, 0.02539279f, -0.02404256f, 0.01590881f, 0.01054784f, -0.04615062f, 
    -0.01751621f, 0.02438014f, 0.00788528f, 0.00801812f, 0.00794811f, 0.03935846f, -0.00509942f, -0.02655102f, 
    0.01176185f, 0.01699317f, 0.03989587f, -0.04537372f, 0.00268184f, -0.01025510f, 0.01494635f, -0.03109592f, 
    -0.03960723f, 0.02079372f, 0.03748784f, 0.00901362f, 0.04640443f, 0.03670406f, 0.00322696f, 0.00214647f, 
    -0.03592563f, -0.05034650f, -0.04086960f, -0.03795487f, 0.01094063f, 0.00870016f, 0.00879901f, -0.00923576f, 
    -0.01435728f, -0.00829944f, 0.01404846f, 0.03412205f, 0.01464077f, -0.00949274f, -0.02722411f, -0.03759988f, 
    0.02222269f, -0.01463411f, 0.03329831f, 0.03737910f, -0.04870126f, 0.02147130f, -0.04812823f, -0.04075586f, 
    0.03478917f, 0.01015578f, 0.02123287f, -0.02611472f, 0.02732297f, -0.03625163f, 0.02068085f, -0.00725672f, 
    0.02349870f, -0.05117314f, -0.04576165f, -0.04884930f, 0.01833365f, -0.01430518f, -0.00825645f, 0.02320933f, 
    0.02361244f, 0.00327880f, 0.01084815f, -0.04033611f, -0.04061583f, -0.01640367f, -0.05748058f, -0.03687753f, 
    -0.01437369f, -0.04610988f, -0.03362460f, 0.02360736f, -0.02357728f, 0.04026731f, 0.03421691f, 0.03183473f, 
    -0.01067962f, -0.00228418f, -0.04830786f, 0.02568436f, -0.01375168f, -0.02202170f, -0.03405624f, 0.04587393f, 
    -0.03282350f, 0.03876390f, 0.00860677f, 0.03743225f, -0.01223129f, 0.04612393f, 0.01137264f, 0.02067459f, 
    0.03941453f, -0.05885341f, -0.01438597f, 0.02974233f, 0.01251186f, 0.03813990f, 0.02724616f, 0.01566276f, 
    -0.01324503f, -0.01230890f, 0.02882201f, 0.03346460f, 0.03020498f, -0.01107663f, -0.00174699f, -0.00066464f, 
    0.04251970f, 0.03078813f, 0.03072918f, -0.02749952f, -0.03452428f, -0.05621123f, 0.01603943f, 0.01178094f, 
    0.00482091f, 0.01905973f, 0.01979356f, 0.02664417f, 0.03866990f, 0.00249035f, -0.04653294f, -0.01502271f, 
    0.01958335f, -0.04615154f, -0.02336081f, 0.00137473f, -0.00519634f, -0.01237464f, -0.02821485f, -0.05398439f, 
    -0.04618355f, 0.02930559f, -0.05009656f, -0.02613669f, -0.02887527f, 0.00153488f, -0.05381982f, 0.01029241f, 
    -0.04700881f, -0.02143645f, 0.00388022f, -0.03487922f, -0.03374810f, 0.02300652f, -0.00558144f, 0.03066863f, 
    -0.03181338f, -0.00323429f, -0.01789985f, 0.02525897f, 0.04744418f, -0.04954006f, -0.03380976f, -0.03568107f, 
    0.02262205f, 0.02202151f, -0.01877011f, -0.00991447f, -0.00492467f, 0.00265318f, 0.03242609f, 0.00707833f, 
    -0.01727147f, -0.03028524f, -0.00951726f, 0.02532600f, -0.03857648f, -0.04104642f, -0.01900457f, -0.02078725f, 
    -0.02090755f, 0.04783959f, -0.04998617f, -0.01654087f, -0.05473154f, 0.01085276f, 0.00375456f, -0.03134837f, 
    -0.01732722f, -0.00326342f, 0.02924107f, 0.01582801f, -0.04809051f, -0.04420289f, 0.02817287f, -0.03751783f, 
    0.00088888f, -0.01600924f, -0.04318434f, -0.02698729f, -0.01668244f, -0.01616164f, -0.01796588f, -0.03759661f, 
    0.00244858f, 0.02865563f, 0.00354877f, -0.01840348f, -0.03908078f, 0.04297587f, -0.02079308f, -0.03343323f, 
    -0.02789678f, -0.03868109f, -0.03852933f, -0.03620813f, -0.00414050f, -0.03386599f, -0.05086015f, -0.03973433f, 
    -0.03869150f, 0.00156970f, -0.03193865f, -0.03300545f, -0.05593912f, -0.00473952f, 0.01338636f, 0.00561919f, 
    0.01119594f, -0.00845714f, 0.01836965f, -0.03707472f, 0.00212811f, 0.03956512f, -0.05378741f, 0.00716859f, 
    -0.02704339f, -0.01392763f, 0.01752307f, 0.01722735f, -0.02609880f, 0.01616389f, 0.03410991f, -0.05655795f, 
    0.00961369f, -0.00351518f, 0.02915717f, 0.04794047f, 0.03391553f, -0.01158711f, -0.03875437f, 0.01993185f, 
    0.09680471f, -0.19748174f, 0.28187361f, -0.40161550f, -0.04169199f, -0.06281406f, -0.19346954f, -0.02962105f, 
    0.27789959f, -0.26973465f, 0.00442919f, -0.12852007f, 0.90463024f, -0.35773700f, 0.29231542f, -0.20600039f, 
    -0.11426834f, 0.16618118f, 0.03423527f, 0.08418038f, 0.17518312f, 0.16266456f, 0.08264866f, 0.00845502f, 
    0.33782679f, -0.02832241f, 0.00588520f, 0.15674724f, 0.12204029f, -0.04024690f, -0.00149405f, -0.03441258f, 
    0.09686248f, -0.09598354f, -0.08035305f, -0.09317515f, -0.33534691f, -0.05223180f, -0.28279594f, -0.18496209f, 
    -0.08385643f, -0.04801896f, -0.01414707f, 0.14217244f, -0.20764811f, 0.24186043f, 0.22288996f, -0.11649230f, 
    -0.43342447f, 0.08543652f, -0.15031114f, 0.02909579f, 0.07943650f, 0.00417923f, 0.03115507f, -0.03272791f, 
    0.16706929f, 0.21974920f, 0.27088305f, -0.08103185f, -0.06800749f, -0.03645936f, -0.04354810f, 0.07801267f, 
    0.01374552f, -0.12335744f, -0.07944183f, 0.02827391f, 0.06125414f, 0.06053592f, 0.09943943f, 0.11780459f, 
    -0.34250310f, 0.14443439f, -0.23819487f, 0.24019569f, 0.03087604f, -0.03024079f, -0.17727338f, -0.00379602f, 
    -0.07084312f, 0.08523890f, 0.19458985f, 0.04508329f, -0.15688139f, -0.14775072f, -0.26647305f, 0.09343997f, 
    -0.02499010f, -0.21197234f, -0.08527213f, -0.04996072f, -0.06385863f, -0.12610571f, -0.07167742f, 0.02000534f, 
    -0.38853365f, 0.26735994f, 0.13553496f, -0.08969676f, 0.14948198f, 0.00613609f, -0.13624834f, 0.06446309f, 
    -0.01113441f, -0.14414422f, 0.03339145f, 0.13986239f, -0.41579938f, -0.10194764f, -0.13963835f, -0.02281257f, 
    -0.16175035f, -0.05826156f, 0.05314191f, 0.10449199f, -0.07854520f, 0.07664455f, 0.04809359f, 0.05642916f, 
    0.35270631f, 0.16870500f, -0.03390469f, 0.25744629f, -0.01510045f, 0.11067419f, 0.08263009f, -0.19011641f, 
    -0.02376160f, -0.00221174f, 0.28931746f, -0.05827461f, 0.33703798f, -0.02972991f, 0.07384387f, -0.40801933f, 
    -0.05700890f, 0.00244282f, -0.12688699f, 0.24079929f, 0.03355809f, -0.00371250f, -0.03952516f, -0.01545193f, 
    -0.28442323f, -0.00588439f, 0.12470963f, -0.18100968f, 0.23106372f, 0.00743341f, -0.02856830f, 0.00997752f, 
    -0.13033174f, -0.15499392f, -0.04408000f, 0.02156697f, 0.21395387f, -0.11408298f, -0.23608173f, -0.18039678f, 
    0.16081075f, -0.09552297f, 0.10652856f, -0.06221643f, 0.02973429f, -0.12487162f, -0.26425055f, 0.05409154f, 
    -0.33238629f, -0.03074535f, -0.07213556f, 0.07676048f, 0.01719042f, -0.03394018f, 0.14714266f, -0.19096488f, 
    0.17758974f, -0.04663220f, 0.10354134f, 0.00038236f, -0.08400190f, -0.04841968f, -0.21207844f, 0.03717963f, 
    0.22206302f, -0.06200936f, 0.00323273f, -0.00920553f, 0.00334914f, -0.16278620f, 0.12559347f, 0.16989115f, 
    -0.06357734f, 0.07932511f, 0.07489759f, -0.01820019f, -0.08798198f, -0.07025421f, 0.13709185f, 0.10977135f, 
    0.13653469f, 0.02908434f, 0.10680247f, -0.10136672f, -0.15357265f, -0.41087246f, 0.06615332f, -0.10052525f, 
    -0.02290368f, 0.19454369f, 0.05027539f, 0.00152478f, 0.24233814f, -0.05782626f, -0.13103046f, 0.15884420f, 
    -0.58063781f, 0.31082019f, 0.23568949f, 0.09548810f, 0.16003774f, 0.04097443f, -0.06265315f, 0.01530101f, 
    -0.10401712f, -0.10378773f, 0.01148989f, -0.12531123f, 0.15956549f, -0.03732809f, -0.09643026f, -0.01778135f, 
    0.42742810f, 0.09294166f, 0.04658735f, 0.07734249f, 0.06251667f, -0.04759132f, -0.09499855f, -0.02482108f, 
    -0.23729752f, 0.14690755f, -0.13060199f, -0.11583469f, 0.24803372f, -0.19382274f, -0.00781172f, 0.04901481f, 
    -0.04421132f, -0.02035432f, 0.01340538f, 0.07877941f, 0.29556024f, 0.30485114f, -0.15109169f, 0.25519359f, 
    0.11361571f, -0.02054303f, -0.11225995f, -0.08334454f, 0.06108112f, -0.07341681f, -0.03401994f, -0.00753034f, 
    -0.41533211f, -0.31589085f, -0.25028068f, -0.12981482f, -0.00829285f, -0.10135746f, 0.09444412f, -0.13255414f, 
    -0.02696535f, -0.00352422f, -0.03298467f, 0.07127915f, 0.17822817f, 0.08754520f, -0.21395962f, -0.03239288f, 
    0.20175329f, 0.03465847f, 0.00741019f, 0.14405964f, 0.18298516f, -0.04309642f, -0.07668246f, -0.02424666f, 
    0.08651891f, 0.19349924f, -0.10008006f, -0.02524601f, -0.03546021f, -0.07209776f, 0.10617858f, -0.01585119f, 
    0.01641628f, -0.00871328f, 0.15319210f, -0.02331033f, 0.33617836f, -0.20795792f, -0.10967926f, 0.55820394f, 
    0.09535684f, 0.02311791f, -0.02468890f, 0.13533559f, 0.11148707f, 0.09087931f, 0.00866139f, -0.01339986f, 
    -0.07948489f, -0.06682204f, -0.33230522f, -0.04066298f, 0.03429624f, 0.05631330f, 0.16467786f, -0.09715845f, 
    0.18236171f, -0.13995092f, -0.02145966f, -0.01886560f, -0.08153865f, -0.08245361f, 0.30846560f, 0.38224918f, 
    0.07776694f, 0.16534941f, 0.16978090f, 0.00434603f, 0.20370342f, 0.02301080f, 0.07312430f, -0.20932083f, 
    -0.05706055f, 0.27382997f, -0.05693062f, -0.02263956f, -0.16288525f, 0.22896181f, -0.02071906f, -0.02031893f, 
    0.17741184f, 0.02263684f, 0.19714671f, -0.01207157f, 0.09598982f, 0.39242071f, -0.12826551f, -0.09997343f, 
    -0.01107338f, -0.02170033f, -0.07270320f, -0.07933392f, 0.06047594f, -0.11375427f, 0.17517145f, 0.10236467f, 
    -0.03785616f, -0.29424709f, 0.05921370f, 0.39823616f, -0.02632482f, 0.16684756f, 0.18810131f, 0.18340528f, 
    0.23512968f, 0.19847509f, 0.17021175f, 0.33283314f, -0.06330372f, -0.07963716f, 0.04741021f, 0.03930460f, 
    0.01427278f, 0.09407594f, 0.14099063f, 0.21117690f, -0.03039444f, 0.03918993f, 0.13155471f, 0.21943685f, 
    -0.13837390f, 0.19860442f, -0.18645549f, -0.11677904f, -0.00396234f, 0.01464247f, 0.38856319f, -0.01086614f, 
    -0.10915893f, -0.08410641f, -0.13118356f, -0.41524044f, 0.02399376f, 0.10511742f, 0.09731772f, 0.22471181f, 
    -0.08678684f, 0.19123477f, -0.08652841f, -0.10325530f, -0.00785078f, 0.26209840f, 0.01765976f, -0.01000261f, 
    0.12416558f, 0.24908376f, 0.15096864f, 0.23635902f, -0.02086582f, -0.00009546f, -0.15712574f, -0.18502106f, 
    -0.06250294f, 0.00002679f, -0.08695551f, -0.25597695f, -0.09753667f, 0.09973577f, 0.07693014f, -0.26532260f, 
    -0.02305522f, -0.09228166f, 0.14693503f, 0.03469750f, -0.11796403f, 0.41345495f, 0.26480433f, 0.11252975f, 
    0.00997963f, 0.04278148f, -0.07288469f, 0.10928439f, -0.08635598f, -0.13113938f, 0.00253218f, -0.08853753f, 
    -0.06295876f, 0.21484062f, 0.28741875f, 0.26067293f, 0.15138850f, 0.03911287f, -0.02085644f, -0.04853975f, 
    0.06998596f, 0.02346154f, -0.16343373f, 0.07666505f, -0.15179066f, -0.08979744f, -0.03743155f, -0.05714180f, 
    -0.13031703f, 0.10833972f, 0.35149032f, -0.25269473f, 0.04215901f, -0.13542880f, 0.10119691f, 0.08171678f, 
    -0.19759744f, 0.16672586f, 0.00727490f, 0.12559317f, 0.21208397f, 0.19600016f, -0.11123330f, -0.15985507f, 
    0.05308562f, 0.14553188f, -0.00735607f, 0.11110550f, -0.05942671f, -0.20231108f, -0.00600584f, -0.06427784f, 
    0.26449877f, 0.06995411f, 0.02048618f, 0.05810981f, 0.01727624f, 0.00637989f, -0.04436397f, 0.18107145f, 
    -0.17485754f, -0.03885014f, -0.19780840f, -0.34394652f, -0.32932216f, -0.06846169f, 0.08714161f, 0.05831471f, 
    0.00061245f, -0.05178141f, 0.17340444f, 0.05144272f, -0.01401362f, -0.02890739f, -0.38305259f, -0.14132351f, 
    0.14182760f, -0.02273580f, 0.11492914f, 0.32968718f, -0.00880489f, 0.04509030f, 0.17794108f, 0.14130194f, 
    0.01563257f, -0.04194642f, -0.02756294f, 0.02525366f, 0.07942426f, 0.14977802f, -0.15211487f, 0.08384722f, 
    -0.05781163f, -0.03229371f, -0.23259768f, -0.09432955f, -0.16882585f, 0.03979739f, 0.03413263f, -0.16448766f, 
    0.41193694f, -0.14079356f, -0.04440339f, 0.09019094f, 0.14546157f, -0.03200911f, -0.21080586f, 0.19869591f, 
    -0.22089721f, -0.01639023f, -0.34109250f, -0.13873908f, 0.06220212f, 0.30359346f, 0.05369443f, 0.04647519f, 
    -0.04693336f, 0.06207856f, -0.20114844f, 0.04196740f, 0.06365138f, -0.25381780f, -0.23700789f, -0.19833101f, 
    -0.09690911f, -0.06691939f, 0.09155305f, 0.15983050f, -0.07891336f, 0.05766197f, -0.10694881f, 0.10412584f, 
    -0.23382513f, -0.16419686f, -0.16506954f, -0.15573190f, -0.02376036f, -0.08287708f, 0.07457858f, -0.06474457f, 
    -0.15037762f, -0.14042403f, 0.09767170f, 0.00285403f, 0.07251058f, 0.13529557f, -0.03215549f, 0.04131059f, 
    -0.14535259f, 0.20509382f, -0.17104031f, 0.15991969f, -0.04094826f, 0.07049711f, 0.12151097f, -0.01657347f, 
    0.08216083f, 0.09880081f, 0.27656963f, 0.44489700f, 0.14355475f, 0.66154593f, -0.37488380f, 0.02415075f, 
    -0.03036078f, -0.08931099f, 0.02618741f, 0.14324528f, -0.00676792f, 0.07142730f, 0.04056751f, 0.18317530f, 
    0.01328859f, 0.09565341f, 0.21297437f, 0.08517636f, 0.10644646f, 0.13647240f, 0.03145537f, -0.04785956f, 
    -0.10002110f, -0.11135933f, -0.11496621f, -0.31579813f, 0.03897069f, 0.19773069f, 0.15986228f, 0.02639113f, 
    -0.13359199f, -0.02298199f, 0.09226854f, -0.23239973f, -0.13819428f, -0.28939456f, 0.02622138f, -0.14290214f, 
    0.07553030f, -0.07059883f, -0.05833238f, -0.18829113f, 0.09297627f, 0.00113676f, 0.12737848f, 0.20038621f, 
    0.03947791f, 0.17031848f, 0.02775171f, -0.19219878f, -0.16789941f, -0.41862950f, 0.46120736f, -0.00914956f, 
    0.14195903f, 0.23393779f, -0.13718002f, -0.06222549f, -0.04513526f, -0.03266409f, -0.19071956f, 0.05904985f, 
    0.10565041f, -0.05761414f, -0.20273587f, -0.21321535f, 0.03816925f, -0.02456544f, -0.08908367f, 0.24173346f, 
    0.10915413f, 0.01157809f, 0.09342720f, 0.09491050f, -0.10388601f, -0.12131186f, 0.27194425f, -0.00046924f, 
    -0.10797634f, 0.19642209f, -0.04942140f, -0.00357812f, 0.08504821f, 0.00308169f, -0.02682297f, 0.36242026f, 
    0.12485631f, 0.08243541f, 0.24920477f, -0.01804762f, -0.06461027f, -0.19875024f, 0.01188024f, 0.05395615f, 
    0.21121347f, 0.31294549f, 0.02780813f, 0.09211248f, 0.13084388f, 0.36927909f, 0.40204969f, -0.19518858f, 
    -0.14940248f, -0.27363175f, 0.14196147f, -0.04444160f, 0.03834271f, -0.10096698f, -0.15635958f, -0.09306011f, 
    -0.36317316f, -0.13041501f, 0.40217045f, 0.08394361f, 0.04400151f, 0.04052215f, 0.18031560f, -0.03294671f, 
    0.26188150f, 0.13134810f, 0.12955976f, 0.37017474f, 0.34068459f, 0.32993355f, 0.22148797f, 0.05863300f, 
    -0.01404864f, 0.08459698f, -0.15124297f, 0.02648286f, 0.05303846f, 0.12530836f, -0.04437295f, 0.17552677f, 
    0.10106411f, -0.10084166f, -0.25868079f, 0.17477423f, -0.02166555f, 0.14247830f, 0.04196526f, -0.14051354f, 
    0.06975361f, -0.12747134f, 0.17411610f, 0.36268142f, 0.05783197f, -0.05256661f, 0.05816469f, -0.16136619f, 
    -0.03966845f, 0.06881071f, 0.10249191f, -0.19524378f, 0.18170851f, 0.10553113f, 0.06775396f, 0.02014923f, 
    -0.04805040f, 0.24531351f, -0.02710846f, -0.22232442f, -0.04847180f, -0.26517677f, 0.09604876f, 0.01395728f, 
    0.13037534f, 0.04397500f, -0.03068662f, 0.28544837f, -0.32650930f, -0.02970028f, -0.14207141f, 0.02368186f, 
    0.01742118f, 0.18967295f, 0.27369437f, 0.00399215f, 0.05819904f, 0.19141947f, 0.40481246f, 0.12535512f, 
    -0.01529324f, -0.04811075f, -0.01530458f, -0.04478439f, -0.02693093f, -0.04214320f, -0.05473273f, -0.01062524f, 
    -0.01432392f, 0.00444619f, -0.01354993f, -0.04823571f, 0.02169871f, -0.00922657f, 0.02807246f, 0.00381539f, 
    -0.00018495f, 0.00489037f, 0.03847230f, -0.01530760f, 0.02458245f, 0.01479356f, -0.00023362f, -0.01560416f, 
    -0.03862684f, -0.00532863f, -0.03929360f, -0.02653916f, -0.00673087f, -0.04957473f, -0.03613567f, 0.01542618f, 
    0.03291618f, 0.00511272f, 0.03222558f, -0.00353130f, -0.04084414f, -0.00489500f, -0.01868242f, 0.01623170f, 
    -0.02415964f, -0.05018575f, 0.02496849f, 0.01802053f, 0.00307876f, -0.02660374f, 0.03111587f, 0.02139398f, 
    0.02360963f, 0.01639859f, -0.02665360f, -0.04916104f, 0.01923430f, 0.03115789f, -0.00510197f, -0.03312906f, 
    -0.03676963f, 0.02064799f, -0.04191699f, -0.05438605f, -0.00805729f, -0.02336201f, -0.02144696f, -0.05619016f, 
    -0.01488771f, -0.05613363f, -0.04719423f, -0.03000863f, 0.00795126f, 0.04481673f, -0.05440785f, 0.02105306f, 
    0.01795235f, -0.01281761f, 0.00300696f, 0.01589877f, -0.00744364f, 0.04559514f, 0.02863514f, -0.00395488f, 
    -0.01146497f, -0.02403660f, -0.01356823f, 0.00182792f, 0.01263905f, -0.02487272f, 0.03065529f, -0.03035475f, 
    -0.00824051f, -0.03590839f, 0.01239718f, -0.01491654f, -0.04380699f, -0.02069445f, -0.01628261f, 0.02474908f, 
    -0.04241924f, -0.00552085f, 0.03224728f, -0.02477757f, 0.04497143f, 0.00186906f, 0.01439678f, 0.03120278f, 
    0.02498299f, 0.04218240f, 0.02789936f, -0.00245262f, -0.04304684f, -0.04914039f, -0.02355642f, -0.03339632f, 
    -0.00887101f, -0.00144168f, -0.01402840f, 0.02550529f, -0.00713108f, -0.00237524f, 0.01974377f, -0.04808356f, 
    -0.01304915f, 0.00692787f, 0.01859845f, 0.00418761f, 0.00779184f, 0.00654984f, -0.03561214f, 0.00818699f, 
    0.02419833f, 0.01630217f, -0.03226587f, 0.01972720f, 0.00818583f, -0.01214286f, -0.01459353f, 0.00322630f, 
    -0.01795175f, 0.03469251f, -0.02929226f, 0.01094714f, 0.00291991f, 0.01018307f, 0.02263867f, 0.01792205f, 
    -0.04874697f, 0.02146233f, 0.00687275f, 0.00812626f, 0.00749752f, -0.03607965f, -0.04184653f, 0.02247857f, 
    -0.02223388f, -0.02526412f, 0.03278616f, -0.04150145f, -0.03289331f, 0.03322356f, 0.00601529f, 0.04058982f, 
    -0.00344491f, 0.03723092f, -0.03306170f, 0.01736493f, -0.00663059f, 0.02140957f, -0.03358830f, -0.02203620f, 
    0.02060369f, 0.03419972f, 0.04367975f, -0.03408954f, -0.03241998f, 0.02944826f, 0.03435388f, -0.03782080f, 
    -0.01476138f, -0.04890593f, -0.01422075f, 0.03953672f, 0.01689098f, 0.03861418f, -0.04203602f, -0.03298475f, 
    -0.04146013f, 0.03707854f, 0.03912751f, -0.05196577f, 0.00974549f, 0.00341400f, 0.02838302f, 0.03488441f, 
    0.01163146f, -0.02754855f, 0.00433786f, 0.04285288f, 0.00065562f, -0.02136902f, -0.05454152f, 0.03729441f, 
    0.04907896f, -0.02475509f, 0.03679300f, -0.02339131f, 0.01419961f, -0.04672892f, 0.02727849f, -0.04709172f, 
    0.03113002f, -0.00283946f, 0.04187300f, -0.03338276f, 0.01540281f, -0.00708500f, -0.01408161f, -0.02394129f, 
    0.02775615f, 0.02341649f, 0.01537460f, -0.05475466f, 0.00792782f, 0.02833601f, -0.05232894f, 0.02780273f, 
    -0.02250098f, 0.03619922f, 0.00486411f, -0.00790355f, 0.02345212f, 0.04861600f, -0.04734855f, -0.04047504f, 
    0.01761174f, 0.02504515f, -0.01343338f, 0.04067175f, 0.01125399f, -0.00133070f, 0.03786211f, -0.02187173f, 
    0.01721056f, 0.02730239f, -0.04128027f, -0.03673733f, -0.03102884f, -0.05031688f, -0.01875518f, 0.04228882f, 
    0.00196568f, -0.03467418f, 0.00549626f, -0.00893233f, 0.02070240f, -0.01601982f, 0.03467975f, -0.05477571f, 
    -0.05145431f, -0.01312012f, 0.04112982f, -0.04463742f, 0.04302656f, -0.02646977f, 0.02663898f, 0.02913760f, 
    -0.02045469f, 0.01304159f, -0.05287730f, -0.05061956f, 0.01286890f, 0.04004854f, 0.02486985f, 0.04313571f, 
    -0.01808474f, -0.03431164f, -0.03890633f, 0.02498355f, -0.03199578f, 0.04187185f, -0.03070166f, 0.01212986f, 
    -0.04475566f, -0.04445196f, 0.00007315f, 0.03811955f, -0.00838538f, 0.01245257f, 0.01329996f, 0.03399054f, 
    0.02804364f, 0.03041634f, 0.02963515f, 0.00546216f, 0.01526131f, -0.00655199f, -0.03005905f, -0.03819030f, 
    0.02184700f, -0.03394110f, -0.03717494f, -0.03495058f, -0.05187939f, -0.02946284f, 0.00818764f, 0.04477625f, 
    -0.02036650f, -0.00083754f, -0.01417712f, -0.02797882f, 0.01949335f, -0.04523277f, 0.04143340f, -0.00724122f, 
    0.00112330f, -0.02656310f, -0.02822596f, -0.00132088f, -0.02252754f, 0.02400100f, 0.02997973f, 0.03273184f, 
    0.01991671f, -0.00046314f, 0.00512452f, -0.04553156f, -0.01276385f, 0.03735393f, 0.03470767f, -0.02321633f, 
    0.02531689f, 0.02451299f, -0.03089170f, -0.02134025f, -0.04053005f, -0.02243846f, 0.00673091f, 0.00348674f, 
    -0.05196182f, 0.02760345f, -0.04446789f, -0.04907824f, -0.02218445f, -0.05525840f, -0.01287203f, -0.00890989f, 
    -0.01843282f, -0.04028739f, 0.03294828f, -0.04310720f, 0.04262183f, 0.00171375f, -0.05351303f, 0.01832817f, 
    0.03799915f, 0.02377325f, -0.02643848f, -0.00321457f, -0.03992436f, -0.03520241f, 0.03236121f, -0.02899900f, 
    0.03599230f, 0.00771358f, 0.01538802f, -0.05077350f, 0.00793050f, 0.04796477f, -0.01849184f, -0.00851464f, 
    -0.04427461f, 0.00412820f, -0.02387160f, -0.04527635f, 0.00845118f, -0.05065583f, -0.02841681f, -0.03433287f, 
    -0.00471979f, -0.01205157f, -0.04336223f, -0.00915790f, -0.00555846f, 0.04036769f, -0.00527406f, 0.00707658f, 
    0.01550520f, -0.01238071f, 0.00780781f, -0.05002711f, -0.04300764f, -0.00968330f, 0.01509505f, -0.05278534f, 
    -0.01774765f, -0.05423135f, -0.02718591f, 0.01755266f, -0.00374352f, -0.01840037f, -0.00784865f, -0.02167417f, 
    -0.04882146f, -0.04235338f, -0.05468864f, -0.02409665f, -0.03643197f, -0.04183511f, 0.02616452f, -0.01227657f, 
    0.01717459f, 0.04521037f, 0.03925525f, -0.04527881f, 0.01712575f, -0.01416451f, -0.03482078f, -0.02770803f, 
    -0.00751024f, 0.01252075f, -0.00106814f, -0.01544910f, -0.01519155f, -0.00869658f, -0.04956043f, -0.04022336f, 
    0.01563222f, 0.03967131f, -0.00481958f, 0.03975260f, -0.03035877f, -0.01446764f, 0.03418835f, -0.03949086f, 
    0.00367841f, -0.04930366f, -0.01890204f, 0.03177682f, 0.03867769f, -0.04267895f, 0.02157285f, 0.00447671f, 
    0.02399171f, 0.04437249f, 0.01909241f, -0.03669452f, 0.01860209f, 0.02127998f, 0.04402296f, 0.03145410f, 
    0.03433100f, 0.03157892f, 0.03219446f, 0.00816266f, -0.02299225f, -0.03295395f, -0.01387454f, -0.02335383f, 
    -0.04317883f, 0.02495024f, -0.02128525f, 0.04071037f, -0.00970821f, -0.01627680f, -0.00834459f, -0.01162269f, 
    -0.02522142f, 0.01965020f, -0.01441710f, 0.02223852f, 0.02680875f, 0.00511993f, -0.02130329f, -0.01773523f, 
    -0.03341242f, -0.00719362f, -0.02186055f, -0.03000986f, 0.02480664f, 0.01259223f, -0.01174833f, 0.01634777f, 
    0.01141005f, -0.05586768f, 0.00232620f, -0.01008433f, 0.01816266f, -0.03216631f, -0.00921787f, 0.04074818f, 
    -0.00587693f, -0.03523087f, -0.01822849f, -0.04317348f, -0.01356470f, 0.02259942f, 0.01517415f, 0.02324192f, 
    0.01317309f, -0.00377307f, 0.03898340f, 0.00693760f, -0.01662683f, 0.02557096f, 0.01163570f, -0.00334191f, 
    -0.04116887f, -0.05140987f, -0.04392053f, -0.01906992f, 0.04077851f, 0.03535640f, -0.05036130f, 0.02727711f, 
    -0.02980662f, 0.03007810f, 0.03881699f, -0.00181510f, -0.00049663f, -0.02518136f, 0.01735401f, 0.01687857f, 
    -0.00943924f, -0.03013721f, 0.02101862f, -0.01399045f, -0.02266278f, -0.00637701f, -0.00614922f, -0.04703796f, 
    0.01138092f, -0.01423595f, -0.05270399f, -0.01736688f, 0.01318081f, -0.01938503f, -0.03741035f, 0.01109279f, 
    -0.01683391f, 0.00487745f, -0.01631972f, -0.02036692f, -0.02232220f, -0.02871908f, -0.03711567f, -0.03761081f, 
    -0.01912730f, -0.01961399f, -0.02484045f, -0.02612239f, -0.05685066f, -0.04294869f, -0.03916496f, 0.02586317f, 
    0.00617885f, 0.00952778f, -0.02366595f, -0.03082941f, 0.01669086f, 0.01431181f, 0.00156953f, 0.03040341f, 
    0.02051416f, 0.01665459f, -0.01456735f, -0.01201229f, -0.02964732f, -0.00638911f, 0.04301881f, 0.00882791f, 
    0.01916560f, 0.00831405f, -0.04281028f, -0.05080299f, -0.03235639f, 0.01411153f, -0.05395369f, -0.02453480f, 
    0.01949146f, -0.00526333f, 0.04493615f, -0.00183507f, -0.01809614f, 0.01697865f, 0.00522003f, 0.01777462f, 
    0.04033570f, -0.02894807f, -0.03562640f, -0.02282021f, -0.02713654f, -0.03420366f, 0.02572370f, 0.03348308f, 
    -0.00650107f, 0.02329122f, 0.01794492f, 0.00141324f, -0.00181109f, -0.01072224f, -0.04903943f, 0.00018882f, 
    -0.05138928f, 0.00546099f, -0.03113121f, 0.02097554f, -0.01236216f, 0.00736566f, 0.01958181f, -0.03637023f, 
    -0.00570044f, 0.04014653f, -0.02633259f, 0.04411094f, 0.02577838f, 0.01897537f, 0.04167093f, -0.04610337f, 
    -0.03030451f, 0.01933019f, -0.02810499f, 0.02964087f, 0.03474692f, -0.00175843f, 0.02415469f, -0.02902630f, 
    -0.01819666f, 0.00651520f, -0.03815504f, -0.04442783f, -0.05623894f, 0.01898824f, -0.01679180f, 0.03185752f, 
    -0.03868090f, 0.02704356f, 0.02455436f, -0.01984770f, -0.00056965f, 0.04316310f, -0.01918630f, -0.01098385f, 
    0.01641288f, 0.04284963f, -0.02509757f, -0.00274132f, -0.04204458f, -0.00974342f, -0.04823431f, 0.00114053f, 
    0.00898193f, -0.03346369f, 0.00806328f, -0.04289675f, -0.04995422f, -0.00856426f, -0.04849773f, 0.02745099f, 
    -0.00133424f, -0.02025517f, -0.04949816f, -0.04064901f, 0.00473234f, -0.05412802f, -0.05674976f, 0.00964049f, 
    -0.02917602f, -0.01196400f, -0.01904380f, 0.03143582f, -0.00065981f, 0.00123006f, -0.00300716f, -0.02833299f, 
    -0.00880127f, -0.03098255f, -0.00873248f, 0.01986572f, -0.05049113f, 0.03238567f, 0.00119150f, 0.00840762f, 
    -0.05425585f, -0.03265001f, 0.00566333f, -0.02223306f, -0.03480665f, 0.04148449f, -0.04851977f, -0.02918885f, 
    0.04476194f, 0.04383576f, 0.03736854f, 0.02251556f, 0.03485229f, -0.04948872f, 0.00227608f, 0.00069880f, 
    0.02574928f, -0.05238942f, 0.00064022f, -0.05336029f, 0.01486583f, 0.03373238f, 0.03379101f, 0.03241869f, 
    0.03073814f, 0.00802805f, -0.02812547f, -0.04005222f, -0.03967456f, 0.03723823f, -0.02141397f, 0.03349411f, 
    0.04189235f, -0.02244776f, 0.01416766f, 0.02785611f, -0.04266908f, 0.02549093f, -0.04495697f, -0.05628685f, 
    -0.02321228f, 0.03843428f, -0.00962474f, -0.04353381f, -0.04486312f, -0.00497880f, -0.01760857f, 0.02286802f, 
    0.02141466f, -0.01155940f, -0.01593368f, 0.00572093f, -0.00630205f, -0.03640252f, 0.04189695f, -0.05481019f, 
    -0.02228478f, 0.04368599f, 0.02814888f, 0.00831893f, -0.02690755f, -0.02481348f, 0.03230536f, -0.00217911f, 
    -0.03045828f, -0.04527902f, -0.03893431f, -0.01990393f, -0.00975912f, 0.00287960f, -0.03083335f, -0.03700646f, 
    -0.04426341f, 0.02489681f, 0.03579201f, -0.05275287f, 0.01128604f, 0.01634429f, 0.01212265f, 0.04286353f, 
    0.02959804f, -0.01131945f, -0.02985805f, -0.02859836f, -0.03400702f, 0.01941100f, 0.01117511f, 0.02750159f, 
    0.13747953f, -0.04012012f, -0.05059420f, -0.25799188f, 0.05765648f, -0.03724730f, 0.03813895f, 0.02253810f, 
    0.05863610f, -0.02806248f, -0.10252763f, -0.11026938f, 0.61445892f, -0.34696946f, -0.14397208f, 0.02980967f, 
    -0.02658792f, 0.03868233f, 0.04310279f, -0.02072779f, -0.01292193f, 0.24342218f, 0.17677815f, 0.22181168f, 
    0.31588316f, -0.07073667f, 0.02075151f, 0.01544498f, 0.02404772f, -0.12886067f, -0.09964208f, -0.02310334f, 
    0.01877945f, 0.01827365f, 0.12440443f, -0.05081859f, -0.25307298f, -0.07133234f, -0.06482314f, -0.33373323f, 
    0.00735204f, -0.01134702f, 0.08907416f, 0.02982476f, -0.23306450f, 0.17548634f, 0.08401187f, 0.09877174f, 
    -0.16362481f, 0.23289809f, -0.27949306f, 0.01797829f, -0.02108246f, 0.06815698f, 0.08713085f, 0.03916632f, 
    0.22339347f, 0.14162533f, 0.26077965f, -0.08197195f, 0.08107143f, -0.10619746f, -0.24538189f, -0.11328135f, 
    -0.04674753f, -0.00151227f, 0.09103116f, 0.00875201f, 0.05188778f, 0.02058442f, -0.05410305f, -0.00927735f, 
    -0.03198734f, 0.04904258f, 0.07903305f, 0.07696197f, -0.11559729f, 0.00525974f, -0.00285169f, 0.03823914f, 
    0.02317457f, 0.14570871f, 0.10596330f, 0.09380510f, 0.02336556f, -0.02618647f, -0.04253913f, -0.08136404f, 
    0.01215521f, -0.00250682f, -0.09065038f, 0.01928083f, 0.01004680f, -0.08441448f, 0.01273273f, 0.09352606f, 
    -0.15705816f, 0.01030299f, -0.01304657f, -0.21316114f, 0.02350673f, -0.01776572f, -0.18462500f, 0.08469764f, 
    0.01085315f, 0.01643106f, 0.11180187f, 0.06621594f, -0.19489883f, -0.10083354f, -0.08088128f, 0.09054615f, 
    -0.10795703f, -0.06712970f, 0.12643425f, 0.12172099f, -0.04428859f, -0.01941490f, -0.23422992f, 0.04541674f, 
    0.67123222f, -0.00196748f, -0.24489993f, 0.35416251f, 0.05912221f, -0.06492972f, 0.02913403f, 0.04834417f, 
    0.03960235f, 0.12806450f, 0.30439603f, -0.00422358f, -0.30819541f, 0.17789699f, 0.16083653f, -0.10886887f, 
    -0.01568620f, -0.01941697f, -0.07344146f, 0.00099968f, -0.00169836f, -0.09650774f, 0.13482217f, 0.09560592f, 
    -0.05719138f, -0.21963218f, -0.06728394f, -0.11526401f, 0.05979916f, 0.06302027f, 0.02168029f, 0.06941906f, 
    0.03642911f, -0.02128134f, -0.13939837f, 0.04140670f, 0.15985371f, 0.01273429f, 0.15377660f, 0.08281199f, 
    0.03764543f, -0.07707852f, -0.18499357f, 0.00067629f, 0.04490997f, -0.14283158f, -0.19147429f, -0.02522772f, 
    -0.20315883f, -0.04564079f, 0.25469381f, 0.39593717f, -0.01818133f, 0.03609535f, 0.01406285f, -0.06381046f, 
    0.14004311f, -0.03304038f, 0.32394668f, 0.07622148f, -0.17713572f, -0.22914837f, -0.12726492f, 0.19245401f, 
    -0.03674210f, -0.15156806f, 0.01929789f, 0.00787644f, 0.00054598f, -0.05631559f, 0.12059908f, -0.02543349f, 
    -0.25176671f, 0.02847013f, -0.00969227f, 0.02015455f, -0.12772600f, 0.00328627f, 0.27707875f, 0.18129538f, 
    0.05706883f, 0.05747052f, 0.16824451f, -0.00685961f, -0.49016142f, 0.14432709f, -0.44974795f, -0.14390527f, 
    -0.04877225f, 0.11743705f, 0.09363592f, 0.16037726f, -0.01541771f, -0.13178612f, -0.03910457f, 0.25865671f, 
    -0.28145528f, 0.02985091f, 0.43222138f, 0.18216059f, 0.16276029f, 0.10613859f, 0.10117888f, -0.02783277f, 
    -0.00243969f, -0.05014306f, -0.06167232f, -0.02673567f, 0.17046537f, 0.06104582f, 0.15771773f, 0.37104544f, 
    0.05352969f, -0.10711970f, -0.07245441f, -0.14988375f, 0.02972552f, 0.00839604f, -0.09052969f, -0.09577913f, 
    -0.11544083f, -0.07631721f, -0.10969529f, -0.18298775f, 0.06354680f, -0.05819422f, 0.05790618f, 0.00768294f, 
    -0.11587834f, -0.01500132f, 0.02126904f, 0.12351174f, -0.15514755f, 0.13799384f, 0.28106776f, 0.43641734f, 
    0.39922369f, 0.14066254f, -0.04366130f, -0.17454223f, -0.00358763f, -0.10763849f, -0.05650931f, 0.05399792f, 
    -0.06100283f, -0.10191932f, -0.25227135f, -0.20142332f, 0.12205078f, 0.04976002f, 0.07192574f, -0.02716467f, 
    -0.02136470f, -0.14534241f, 0.12257910f, -0.10478417f, -0.05336637f, 0.01701504f, 0.15184677f, 0.11260595f, 
    -0.05133754f, -0.06732018f, -0.07347159f, 0.07635419f, 0.01141058f, -0.02489488f, -0.12177315f, -0.00846780f, 
    -0.07865653f, 0.13088848f, 0.29767823f, 0.14079772f, -0.03207470f, 0.03466666f, -0.00750959f, -0.04294918f, 
    0.05718977f, 0.04722706f, -0.02581659f, -0.15793398f, -0.18410817f, -0.12338890f, 0.03861592f, 0.37774557f, 
    0.12663022f, -0.11447191f, 0.16411147f, 0.13169940f, -0.00182545f, 0.08414861f, 0.03772530f, 0.12655510f, 
    -0.09144188f, 0.09959740f, 0.14758073f, -0.09166176f, -0.03082974f, 0.01789861f, 0.08416837f, 0.05262069f, 
    0.28639680f, -0.12128963f, -0.02208768f, 0.10326961f, 0.33508226f, -0.08866781f, 0.14899242f, 0.25115341f, 
    0.00420625f, 0.27520138f, 0.21088977f, 0.06697848f, 0.06770595f, -0.05029239f, 0.04692475f, -0.02535061f, 
    0.59564686f, 0.01840153f, -0.24056384f, -0.12581755f, -0.07732953f, 0.05570392f, -0.10302129f, 0.01321248f, 
    0.10577354f, -0.01202809f, 0.20954268f, 0.02097833f, -0.21479225f, 0.19411056f, -0.05913099f, -0.15215999f, 
    0.07155715f, -0.04154002f, 0.01316717f, -0.11411715f, 0.13182038f, -0.12622960f, -0.05738101f, 0.11966668f, 
    -0.29337794f, -0.05775231f, -0.01735097f, 0.08771066f, 0.08834084f, 0.02622131f, 0.29410708f, 0.22809173f, 
    0.06251924f, -0.06735761f, 0.00882507f, 0.17421772f, -0.21564490f, -0.29342636f, -0.18024571f, 0.01103199f, 
    -0.11977541f, -0.14200810f, 0.24140219f, 0.01679081f, -0.10523514f, -0.09021915f, 0.18070337f, 0.16328710f, 
    -0.00712367f, -0.04351689f, -0.03652258f, -0.04769462f, -0.05037380f, 0.00770732f, 0.02594321f, -0.03240554f, 
    0.04552181f, 0.04192496f, -0.04697547f, 0.02074065f, -0.01702482f, -0.04575427f, -0.03177138f, -0.05605358f, 
    0.01966275f, -0.02576560f, -0.04997430f, 0.03496952f, -0.01895043f, 0.02675035f, -0.00967563f, 0.03512986f, 
    0.04270475f, 0.02645437f, -0.04419538f, -0.00288805f, -0.01606762f, -0.00867135f, -0.03545436f, 0.01802016f, 
    0.00516446f, -0.03591092f, -0.00104909f, 0.01258721f, -0.01034879f, 0.00269519f, -0.03286926f, -0.00268017f, 
    0.02578446f, -0.01737848f, 0.01130776f, 0.00290993f, -0.02532158f, -0.03281794f, -0.00248681f, -0.02104535f, 
    -0.04557007f, -0.00339438f, -0.05772451f, -0.01507599f, 0.00189624f, -0.00413393f, -0.04012225f, -0.03222686f, 
    -0.03743667f, -0.01057550f, -0.02539371f, 0.01236867f, 0.00855546f, -0.02416197f, 0.01989298f, -0.04909532f, 
    0.01403461f, -0.04391565f, 0.02362727f, 0.01671136f, -0.00188348f, 0.03139065f, 0.01982925f, -0.04467441f, 
    0.03729850f, -0.03596138f, -0.02195641f, 0.00193804f, 0.03146129f, -0.00802281f, -0.04091788f, 0.03108932f, 
    -0.03870637f, 0.03494580f, -0.03740770f, -0.05216337f, 0.02553117f, 0.03194150f, -0.00492718f, -0.01968311f, 
    -0.02230473f, -0.01400415f, -0.03391089f, 0.00524019f, -0.02162178f, -0.02875010f, 0.01708855f, 0.00022090f, 
    -0.03873712f, -0.01445001f, 0.02000549f, -0.02519362f, -0.01819205f, -0.02987786f, -0.05458835f, 0.04313980f, 
    -0.00169832f, -0.00528930f, -0.02552165f, -0.05569668f, 0.03826794f, -0.00407231f, 0.01204145f, -0.02191644f, 
    -0.03607175f, 0.02267292f, -0.00836823f, 0.02385376f, 0.02142784f, 0.01917394f, -0.05602947f, 0.02158425f, 
    -0.05686524f, -0.04739147f, -0.05454562f, 0.02292214f, -0.03681377f, 0.03788448f, 0.00185190f, -0.05369422f, 
    -0.03174321f, 0.02954695f, -0.03114523f, -0.01200012f, -0.04042873f, -0.01228964f, -0.05493821f, 0.02628789f, 
    -0.00359945f, 0.01047186f, -0.05099412f, 0.02842550f, -0.04035623f, 0.03811767f, -0.03374586f, -0.02221068f, 
    -0.03484371f, 0.00164605f, 0.00524072f, -0.03593398f, 0.02749266f, -0.01922700f, -0.02796401f, -0.05581235f, 
    -0.02887059f, 0.00509422f, 0.01327363f, -0.05834176f, -0.02334677f, -0.02166217f, -0.04729606f, -0.02587804f, 
    -0.04220528f, 0.03876073f, -0.03726637f, -0.04859558f, -0.04461356f, -0.01384159f, -0.04487490f, 0.03224554f, 
    0.02373025f, -0.03164584f, 0.00244147f, -0.04982416f, -0.04800067f, 0.03390605f, -0.03326889f, -0.01357366f, 
    -0.01911798f, 0.03770951f, 0.01403392f, -0.02825576f, -0.02911373f, 0.02826009f, 0.03960498f, 0.00381573f, 
    -0.00494751f, -0.04920245f, -0.05273389f, 0.04249383f, -0.02066049f, 0.04175023f, 0.01438961f, -0.02238515f, 
    0.00668356f, -0.01836308f, 0.01261312f, -0.01256832f, 0.00567232f, 0.01544417f, -0.00433852f, -0.04354975f, 
    0.02658923f, 0.03691898f, 0.02548037f, 0.02104747f, -0.02225508f, -0.03985588f, -0.05319063f, 0.04311370f, 
    -0.01092434f, -0.04378510f, 0.00338450f, 0.01402061f, 0.03635287f, -0.04588518f, 0.02724464f, 0.04050507f, 
    -0.01714605f, -0.03905940f, -0.05502522f, 0.01762251f, 0.03359561f, 0.01529571f, 0.03140956f, -0.04424836f, 
    -0.01554651f, -0.01494301f, 0.03191347f, -0.02478729f, 0.00614730f, 0.01360044f, 0.02363667f, -0.02382144f, 
    -0.00495258f, 0.03635845f, -0.01213143f, -0.04756003f, -0.00258059f, 0.02333776f, -0.02056333f, -0.02587782f, 
    0.03847140f, -0.01654594f, 0.02840680f, 0.02505437f, 0.01624364f, 0.01780106f, 0.01914175f, -0.02771674f, 
    -0.01821584f, 0.02850713f, -0.02723427f, -0.03365970f, 0.02616981f, 0.03612476f, -0.04198468f, -0.04703464f, 
    -0.04939516f, -0.01808578f, -0.03116398f, -0.02541226f, -0.04692699f, -0.03179568f, -0.02200694f, -0.00864081f, 
    -0.02876084f, -0.05172329f, 0.03929053f, 0.03859306f, 0.02368543f, 0.01478182f, -0.01256969f, -0.00164666f, 
    -0.04754050f, 0.02274234f, -0.01681308f, -0.04353084f, -0.02383693f, 0.03810253f, -0.05457210f, -0.00528595f, 
    0.01696710f, -0.03258074f, 0.04535339f, 0.02953109f, -0.03965467f, 0.04418527f, -0.01315383f, -0.02341884f, 
    0.00610421f, 0.02757633f, -0.00354299f, -0.04991607f, 0.03094881f, 0.01891783f, 0.01427968f, 0.02040750f, 
    -0.05294205f, -0.01649895f, -0.01290766f, 0.01389959f, 0.03431237f, 0.02574681f, -0.04833891f, -0.03913006f, 
    -0.05767858f, -0.04213356f, -0.01100048f, -0.04942514f, 0.04406138f, 0.01594134f, 0.00335171f, 0.00179093f, 
    -0.03270262f, -0.03863423f, -0.05562457f, -0.02563897f, -0.03812003f, -0.03372540f, 0.00288905f, -0.01450178f, 
    0.03099236f, -0.03024944f, -0.03917087f, -0.02797474f, 0.04485805f, 0.04383751f, 0.01140176f, -0.01719224f, 
    0.00181915f, 0.03419209f, 0.00775467f, -0.03226536f, 0.01925684f, -0.02504932f, -0.00596877f, 0.01360665f, 
    -0.03558582f, -0.03574691f, 0.01377989f, -0.04739351f, 0.00879133f, 0.03441324f, -0.04050139f, -0.04407648f, 
    0.00331888f, -0.02188493f, 0.01452027f, -0.00828965f, -0.01143895f, 0.02752266f, -0.01903844f, -0.03831541f, 
    -0.05704310f, 0.02558109f, 0.02780282f, -0.02293071f, -0.02570300f, -0.00227408f, -0.03451705f, 0.02779559f, 
    0.02789137f, -0.04171248f, 0.03469570f, -0.05317025f, 0.03253075f, 0.00954680f, -0.00755782f, 0.03434680f, 
    0.00731777f, 0.03872132f, 0.01643639f, 0.02295413f, -0.03451626f, -0.02621765f, -0.01085691f, -0.02521895f, 
    0.02814108f, 0.00678098f, -0.03465593f, -0.03969491f, 0.01689435f, 0.03781168f, 0.03740912f, 0.00877816f, 
    -0.04886817f, -0.01485602f, 0.19294985f, -0.16168354f, -0.08635154f, -0.01519017f, -0.10681006f, -0.09008795f, 
    0.07320713f, -0.06623802f, 0.10416660f, 0.12435917f, -0.15492722f, -0.11741752f, 0.58469218f, 0.18834282f, 
    -0.19650425f, -0.20875181f, 0.02792279f, -0.12345573f, 0.19255951f, -0.05486397f, 0.00830912f, -0.09267872f, 
    -0.07591997f, 0.12588921f, 0.48000222f, 0.45291644f, -0.06068549f, 0.15300335f, 0.01358682f, -0.00804725f, 
    0.03587043f, -0.18562748f, -0.13249229f, -0.01209950f, -0.02653399f, -0.29967198f, -0.28540093f, 0.03573503f, 
    -0.01491206f, 0.04686395f, -0.02418328f, -0.12679563f, 0.03372608f, -0.02865080f, -0.12794641f, 0.09298846f, 
    -0.15068011f, -0.27079588f, -0.26155648f, -0.19915016f, -0.07797579f, 0.06459978f, -0.03983705f, -0.01976545f, 
    -0.09375899f, -0.10715336f, 0.02933375f, 0.16361228f, -0.14219455f, -0.38721460f, 0.03981721f, 0.17386612f, 
    0.03719069f, 0.03206928f, -0.05233103f, -0.11793090f, 0.04562740f, -0.01755661f, -0.00406579f, -0.01170489f, 
    0.19649032f, -0.18503897f, -0.30335641f, -0.23688088f, 0.15476143f, 0.01877439f, -0.03292974f, -0.00556597f, 
    0.02870123f, 0.09038035f, 0.11514468f, 0.02587503f, 0.08673865f, -0.04175201f, -0.11800509f, -0.00259114f, 
    0.06110692f, 0.01891023f, 0.13553195f, 0.00222228f, 0.08801094f, 0.06827739f, 0.05556858f, 0.01196643f, 
    -0.01241796f, -0.30188143f, -0.15692317f, -0.07143436f, 0.19755343f, -0.09575113f, -0.08057309f, -0.05084631f, 
    -0.04520682f, -0.09373761f, -0.08747387f, -0.04118715f, 0.07160081f, -0.20990323f, -0.05033828f, -0.30129758f, 
    -0.01259020f, 0.11199900f, 0.02289134f, -0.00978267f, -0.10849436f, -0.10927904f, -0.07587902f, 0.04343677f, 
    -0.36823320f, 0.23106962f, 0.29671770f, -0.05930304f, 0.15487789f, -0.14379483f, 0.00695390f, -0.01533634f, 
    0.09914086f, -0.06203968f, -0.06217065f, 0.00070348f, -0.13899665f, -0.25417084f, -0.11467649f, 0.21513996f, 
    0.03511163f, 0.09262042f, -0.01503822f, -0.10236289f, 0.05792005f, 0.03207757f, 0.00599472f, -0.01095734f, 
    0.00789697f, -0.20044115f, 0.16043772f, -0.01628240f, 0.14759001f, -0.06730405f, -0.07348163f, -0.01632483f, 
    -0.11849036f, -0.05943558f, -0.05891393f, -0.15071104f, 0.22486418f, 0.41602048f, 0.26853606f, -0.01086666f, 
    0.04192402f, -0.02120724f, 0.03425093f, 0.05885386f, 0.05136559f, 0.01835643f, 0.00750766f, -0.09848852f, 
    0.51811785f, 0.30690169f, -0.09123287f, -0.17378037f, 0.12338477f, 0.22084045f, 0.10147259f, 0.10672544f, 
    -0.18020342f, -0.00009269f, -0.07237275f, -0.10350522f, 0.23646361f, 0.48053935f, 0.25493202f, -0.19681481f, 
    0.10508685f, 0.09335794f, -0.00254020f, 0.19678387f, -0.05793597f, -0.00867403f, -0.08575812f, -0.01958261f, 
    -0.02171972f, 0.04254953f, -0.02072480f, -0.00825527f, -0.01156229f, 0.00656625f, -0.17989221f, 0.02753242f, 
    0.06866379f, 0.10027199f, 0.02476745f, 0.14516005f, 0.53730887f, 0.23643468f, 0.24724257f, 0.21267825f, 
    0.03148210f, 0.12703115f, -0.02685153f, 0.08052948f, 0.17209530f, 0.00156268f, 0.16063038f, -0.02094347f, 
    0.36917260f, -0.04541602f, -0.45519695f, 0.03539835f, -0.20665762f, 0.03157625f, -0.07721616f, 0.02848365f, 
    -0.09300302f, -0.04489511f, -0.05654646f, -0.09538711f, 0.33124888f, 0.49593341f, 0.37826136f, 0.17480910f, 
    -0.04865620f, -0.01514298f, -0.03461332f, 0.19099383f, 0.03327755f, 0.03901607f, 0.00605764f, -0.12654664f, 
    -0.27604252f, -0.35317290f, -0.29073209f, 0.19838203f, 0.07486463f, 0.07892957f, -0.07610264f, -0.00696420f, 
    -0.00998797f, 0.08353661f, -0.06764746f, 0.00087114f, -0.04609627f, -0.43054077f, 0.17780216f, -0.17527054f, 
    -0.18930204f, -0.17327654f, 0.18461306f, -0.01918427f, 0.00568967f, 0.10138737f, 0.03706744f, -0.02992353f, 
    -0.02430914f, -0.22791527f, -0.01732531f, 0.09611556f, 0.02983105f, 0.00908733f, -0.00425371f, -0.05071850f, 
    0.18146442f, -0.07430498f, -0.12778042f, 0.17319733f, -0.00713501f, 0.32712743f, 0.36413559f, 0.05797863f, 
    0.01128461f, 0.11696709f, 0.06422775f, 0.12127407f, -0.01599786f, 0.00181736f, 0.12676820f, 0.09216521f, 
    0.32739145f, 0.23242861f, 0.11153046f, 0.15152442f, 0.16498947f, 0.14616348f, -0.01184398f, 0.20413470f, 
    0.16291450f, 0.16165021f, 0.19738029f, 0.15715384f, -0.18930678f, 0.06397387f, -0.10849720f, -0.22246939f, 
    0.02469357f, 0.08331794f, 0.05592768f, 0.00719604f, 0.00642832f, 0.03324111f, 0.13391073f, 0.00594817f, 
    0.02294159f, -0.56030595f, -0.37681803f, -0.28947812f, -0.04553771f, 0.01302602f, 0.00701558f, 0.10222398f, 
    0.01252716f, 0.11248320f, -0.01390306f, 0.11271185f, 0.29885110f, 0.32578355f, 0.13290659f, -0.00601319f, 
    -0.10279583f, -0.10282752f, 0.00436801f, -0.02231416f, 0.03026525f, 0.04588641f, 0.10319925f, -0.03388436f, 
    -0.67660064f, -0.14922884f, 0.05796043f, 0.00144794f, 0.13483849f, 0.03100448f, 0.01488272f, -0.00413482f, 
    0.08080427f, 0.04566726f, 0.17841552f, 0.00930696f, -0.69553846f, -0.16114363f, -0.50201052f, 0.28052071f, 
    0.25470498f, -0.06541768f, -0.11096887f, 0.06119094f, -0.10470767f, 0.19495836f, -0.03286465f, 0.02306678f, 
    0.02739691f, 0.11991894f, 0.07171794f, -0.03684616f, -0.06734788f, 0.04704735f, 0.01172833f, -0.08305640f, 
    0.03239760f, -0.06152035f, 0.18293650f, 0.21567239f, -0.04710168f, 0.61857998f, 0.40929335f, 0.17154729f, 
    0.11274793f, -0.05465896f, 0.15846191f, 0.06767289f, 0.13202971f, 0.01929805f, -0.00435949f, 0.12998451f, 
    -0.05248731f, -0.04285999f, 0.01469368f, -0.01455364f, -0.01986512f, 0.03905936f, 0.01857147f, 0.02418592f, 
    -0.00115370f, -0.05877670f, -0.01911145f, 0.02644680f, 0.00775742f, -0.00126419f, -0.05701179f, 0.00976135f, 
    -0.00260512f, -0.02787109f, -0.02326048f, -0.01281121f, -0.04156692f, 0.03674731f, 0.01096792f, 0.02422444f, 
    0.02928558f, 0.02728962f, 0.01441004f, 0.00668420f, -0.05097808f, 0.01204675f, -0.02356226f, -0.01207002f, 
    0.02913234f, 0.00399041f, -0.03412225f, -0.03189589f, -0.05869257f, -0.01918913f, -0.04742176f, -0.04471895f, 
    0.03857984f, -0.01971491f, -0.04155365f, 0.00384662f, 0.01587512f, 0.02575648f, 0.00199478f, 0.00537854f, 
    0.02057046f, 0.03671407f, 0.03641497f, -0.03216785f, -0.05486528f, -0.01145574f, -0.04016200f, -0.00642077f, 
    0.00907094f, 0.00475173f, 0.00404843f, 0.00703817f, -0.02566937f, -0.03575963f, -0.04330701f, 0.03414402f, 
    0.02286609f, 0.01492335f, 0.00526673f, -0.01478201f, -0.02671028f, 0.03702879f, 0.01716008f, -0.02227608f, 
    0.00247543f, 0.00690843f, -0.05032343f, 0.01011175f, 0.00402968f, -0.05693416f, 0.02521149f, 0.01259846f, 
    0.00876839f, -0.04948316f, 0.04298779f, -0.01981083f, -0.05131493f, -0.04737245f, -0.00367913f, -0.04735737f, 
    -0.00580373f, -0.02941392f, 0.02895024f, -0.05032942f, 0.03887065f, -0.02196050f, 0.04031245f, -0.04358564f, 
    -0.03637223f, 0.00721463f, -0.04807027f, 0.02177240f, -0.04581323f, -0.03050118f, 0.02290096f, -0.03852654f, 
    -0.05246007f, -0.03294037f, 0.02556816f, 0.01240970f, 0.00881123f, -0.00323220f, -0.02075301f, -0.00639024f, 
    0.02587418f, -0.00264093f, -0.00622062f, 0.01334505f, -0.05495884f, 0.03017230f, -0.02449740f, -0.03491372f, 
    -0.02756940f, 0.03631077f, -0.00424391f, 0.02741588f, -0.03230548f, 0.01993235f, -0.04883011f, -0.04138412f, 
    0.03163597f, 0.02956807f, -0.04892017f, -0.01128613f, 0.03087965f, -0.00772514f, 0.03565503f, 0.00640912f, 
    0.02903903f, 0.01742203f, -0.04400478f, -0.03848504f, -0.05322874f, 0.02708047f, -0.02698949f, 0.04247127f, 
    -0.05021794f, -0.04331253f, -0.01256595f, 0.02225689f, -0.00654556f, -0.01393821f, -0.00851127f, 0.01568231f, 
    -0.03694763f, 0.00246104f, 0.01540795f, -0.01502805f, -0.01148773f, -0.04695361f, 0.00648884f, -0.01597445f, 
    -0.05019879f, -0.04352969f, -0.05831739f, -0.02126105f, 0.04143504f, -0.02348823f, -0.00133573f, 0.03354404f, 
    -0.03399821f, 0.02084300f, -0.04515307f, 0.05120299f, 0.02006830f, -0.05804092f, -0.05118533f, -0.00984452f, 
    0.04182316f, -0.00788729f, -0.04516111f, 0.01509164f, 0.03760513f, 0.02488474f, 0.01457002f, -0.05368337f, 
    -0.02605014f, 0.01177741f, 0.02292288f, 0.04279210f, 0.00579250f, 0.04260302f, -0.04521516f, -0.00786828f, 
    0.03097362f, 0.04123536f, 0.03710502f, 0.01444278f, -0.02383237f, 0.02331604f, -0.03893173f, -0.03010493f, 
    -0.00220864f, 0.01553176f, -0.01189788f, -0.05814559f, -0.04690064f, -0.00471412f, -0.04153464f, -0.01168940f, 
    0.03158638f, -0.00054508f, 0.01977439f, 0.02520558f, -0.02684759f, -0.02637407f, -0.02242303f, 0.02582382f, 
    -0.04245792f, -0.02258889f, -0.02585714f, -0.05160396f, -0.02907976f, 0.02211088f, 0.01100630f, -0.05439648f, 
    0.02816743f, -0.03829465f, 0.01272332f, -0.00900175f, -0.01401699f, 0.00422391f, 0.00621726f, 0.04273771f, 
    -0.04156782f, 0.03724871f, 0.00698505f, 0.00771928f, -0.01535937f, -0.04175129f, 0.03701383f, 0.03776308f, 
    -0.00930958f, 0.01677015f, -0.00796226f, -0.03099987f, -0.02167117f, 0.01035611f, -0.03972678f, -0.02819140f, 
    0.02418612f, -0.00198388f, -0.00939755f, 0.01944534f, -0.05240114f, -0.03238818f, -0.05511329f, 0.02997033f, 
    -0.04398805f, -0.04478875f, -0.04681146f, -0.03851566f, -0.01463786f, -0.03271702f, -0.01646653f, -0.00881081f, 
    -0.04951528f, -0.00035886f, -0.05452757f, 0.02142907f, -0.02909333f, -0.02269191f, -0.04414495f, 0.01424903f, 
    -0.05461974f, 0.00764551f, -0.00110726f, -0.03338421f, -0.01420282f, -0.02902544f, 0.03525138f, 0.00062507f, 
    -0.03104201f, 0.01228129f, 0.00078344f, -0.02256192f, 0.01501064f, -0.05393986f, 0.01871667f, -0.01217085f, 
    -0.01937129f, 0.00978287f, -0.02411172f, 0.00955590f, 0.00407091f, 0.02208976f, 0.01999142f, 0.04242458f, 
    0.01351684f, 0.00683641f, 0.03874285f, -0.00400520f, 0.01195590f, 0.00732929f, -0.04721713f, -0.01892402f, 
    0.01407715f, -0.01482684f, -0.00295134f, -0.03598954f, -0.02631826f, -0.05151085f, -0.04573265f, 0.00298339f, 
    -0.03895685f, -0.04418139f, 0.02746847f, 0.02330325f, -0.04390507f, 0.03268703f, -0.04346874f, 0.03178797f, 
    0.02272896f, -0.04991131f, 0.01920559f, 0.01369029f, 0.01568709f, 0.03390515f, 0.04078891f, 0.01573729f, 
    -0.02744927f, -0.04464050f, -0.01088151f, 0.01462500f, 0.02883233f, -0.05318326f, 0.00890242f, 0.03350149f, 
    -0.01146814f, 0.01567523f, 0.03005078f, -0.02776274f, -0.01743119f, -0.03110191f, 0.01129541f, -0.05003541f, 
    0.03935759f, -0.02291317f, 0.03792203f, 0.02553892f, -0.02792893f, 0.01750903f, 0.01952650f, 0.02410499f, 
    -0.05034457f, 0.00106820f, -0.05804024f, -0.02962013f, -0.03220793f, -0.00759995f, -0.00320666f, -0.04738541f, 
    0.02519662f, -0.03256727f, 0.00292167f, 0.01982633f, 0.01765694f, -0.03562650f, -0.05236163f, -0.02458546f, 
    -0.02124207f, -0.01882510f, -0.04928337f, -0.05705623f, -0.00985995f, 0.05600528f, 0.01515858f, -0.00541320f, 
    0.02848885f, -0.01054076f, -0.02764621f, -0.03295055f, 0.00196009f, -0.01299999f, 0.01014945f, 0.02149020f, 
    0.23505926f, -0.27748743f, 0.31849095f, -0.26168442f, -0.04223092f, -0.04671219f, 0.03621588f, -0.08400347f, 
    0.12810987f, 0.04100828f, -0.00873951f, -0.02895345f, 0.33629361f, -0.23546223f, 0.50237161f, 0.25921524f, 
    0.20174046f, 0.09818815f, -0.11988467f, 0.03961113f, 0.21555148f, 0.07833003f, 0.02797299f, -0.07636078f, 
    -0.08689077f, 0.26056951f, 0.11471749f, 0.13521300f, 0.13679221f, 0.17134367f, -0.04356205f, -0.07692485f, 
    0.13643183f, -0.05133324f, -0.02574467f, -0.09287411f, -0.24668667f, -0.21807829f, 0.15762773f, -0.13185094f, 
    -0.28864408f, -0.00173762f, 0.06131084f, 0.08525641f, 0.01541162f, -0.02772963f, 0.17143093f, 0.07832436f, 
    -0.10411453f, -0.00185675f, -0.05310601f, 0.05117424f, -0.05668126f, 0.04406364f, 0.12430683f, 0.00817885f, 
    0.13406403f, -0.05077363f, -0.03578655f, 0.02028132f, -0.07256852f, -0.18596898f, -0.29245621f, 0.17600903f, 
    0.12887479f, 0.09541325f, 0.05752939f, -0.04583495f, -0.00254450f, -0.09611677f, 0.04589215f, 0.05367142f, 
    -0.18566987f, 0.26574612f, -0.22115748f, 0.32322851f, 0.00785218f, -0.10956696f, 0.04488093f, -0.06558739f, 
    0.10964461f, 0.04735372f, 0.08603327f, 0.11261797f, 0.16174108f, -0.13822682f, -0.31762001f, -0.22219703f, 
    0.17286821f, -0.07338315f, 0.08644397f, 0.03807210f, 0.12141383f, -0.02142048f, 0.07179468f, -0.07040095f, 
    -0.13756695f, 0.15215020f, -0.13948822f, -0.01275455f, 0.05899126f, -0.09997329f, 0.13255310f, -0.06319474f, 
    0.13142687f, -0.04261710f, 0.00890909f, 0.08886791f, -0.13063020f, -0.25339708f, 0.10868622f, -0.20798518f, 
    -0.20897256f, -0.06654441f, -0.01110737f, 0.01355168f, 0.03093752f, 0.03587864f, -0.12208702f, 0.12803805f, 
    -0.52065128f, -0.00251830f, 0.08744290f, 0.23158780f, -0.18446063f, 0.04730952f, 0.28243881f, -0.09425772f, 
    -0.02932325f, -0.06418235f, 0.06406576f, 0.14631952f, 0.30906892f, 0.12540300f, 0.32949257f, 0.33936226f, 
    -0.07096284f, 0.03221845f, -0.39481595f, -0.08227070f, 0.00208038f, -0.06725407f, 0.01887057f, -0.14434752f, 
    0.06929135f, -0.20130752f, -0.25908887f, 0.10496977f, 0.15629785f, -0.08671492f, 0.03442651f, 0.07369078f, 
    -0.02413436f, -0.10789012f, -0.25470656f, 0.23971960f, 0.12291516f, 0.38174492f, -0.04554779f, -0.12704945f, 
    0.14609618f, 0.11348363f, 0.19148681f, 0.07310248f, -0.07985623f, -0.12478743f, -0.20926581f, 0.09890048f, 
    -0.00383500f, -0.08237116f, 0.05030634f, -0.31095251f, 0.07882503f, 0.11490516f, -0.10773654f, 0.11951632f, 
    0.00208182f, -0.00304426f, -0.07144595f, 0.11157861f, 0.11180410f, 0.18289910f, -0.00590341f, -0.35614035f, 
    0.19403245f, 0.12855986f, 0.13120109f, 0.10297648f, -0.07768427f, 0.02148619f, 0.05175406f, 0.15558921f, 
    0.02239279f, 0.03493486f, 0.13477036f, -0.14153402f, -0.01274004f, -0.04346721f, 0.01467339f, 0.06873222f, 
    0.04192143f, -0.04168069f, 0.05841107f, -0.01154004f, 0.40513536f, -0.06167191f, -0.18679722f, -0.14411099f, 
    -0.04999672f, -0.03584125f, -0.12651616f, -0.09598840f, -0.01003756f, -0.01481557f, -0.06707960f, -0.02666287f, 
    -0.31859690f, -0.09749082f, -0.18513201f, 0.28024301f, -0.00722648f, 0.08104505f, 0.07673203f, 0.18340206f, 
    0.18938875f, -0.09030273f, -0.00699348f, 0.01092923f, 0.11695410f, 0.12020992f, 0.07690594f, -0.20863791f, 
    0.11781862f, 0.12528004f, 0.16818996f, 0.13771255f, 0.04697934f, -0.06496772f, 0.07942071f, 0.02069116f, 
    -0.02018496f, -0.09866596f, -0.11936648f, 0.17084637f, -0.00469244f, -0.31690097f, -0.08003616f, -0.03708079f, 
    0.12356570f, 0.26384738f, -0.03635855f, 0.18426824f, 0.38539302f, -0.66427183f, 0.08740297f, -0.15837374f, 
    -0.03998138f, 0.19858120f, -0.10460018f, 0.15484019f, 0.19552352f, -0.00748758f, -0.06734352f, -0.06295864f, 
    -0.05210372f, -0.42030916f, 0.14178215f, -0.34660128f, 0.18307075f, 0.07546392f, -0.16914196f, 0.05927695f, 
    0.03220559f, -0.18738528f, 0.09330434f, -0.14259905f, 0.18691237f, 0.17069201f, -0.09303448f, -0.08972983f, 
    0.08927178f, 0.09703099f, -0.00097828f, 0.22086516f, 0.12229108f, 0.01373861f, 0.01041592f, 0.23243287f, 
    0.05558547f, 0.23150229f, 0.21933557f, -0.28210413f, 0.05553345f, 0.01592635f, 0.11711810f, 0.12998001f, 
    -0.05932317f, -0.04283163f, -0.06900460f, -0.08755121f, -0.39591128f, -0.14768367f, -0.02955590f, -0.27699053f, 
    -0.25292313f, 0.00461144f, 0.04519772f, 0.02030699f, 0.16962792f, -0.03418684f, -0.04525049f, 0.00159696f, 
    0.17448118f, -0.29196519f, -0.05777999f, -0.16698676f, -0.00154418f, -0.06452149f, 0.14406016f, 0.08751196f, 
    -0.01505354f, 0.08919135f, -0.03301902f, -0.03015147f, 0.01002515f, 0.16733702f, -0.16513458f, 0.08589017f, 
    0.31437662f, 0.01117302f, 0.14822440f, 0.11457647f, -0.06638799f, 0.08590492f, -0.07283565f, -0.10415699f, 
    -0.88140655f, 0.24872048f, -0.51336265f, 0.36432371f, -0.00432700f, 0.16091973f, 0.07672261f, -0.15497023f, 
    0.00640513f, 0.01945512f, 0.03264472f, 0.05863668f, -0.60095835f, 0.18179619f, 0.12156365f, 0.24556261f, 
    -0.03472112f, 0.11720740f, -0.24036177f, 0.02647786f, 0.23104858f, -0.08744363f, 0.17972054f, -0.01529367f, 
    -0.24671094f, -0.01516522f, 0.03040475f, -0.30863973f, -0.18248729f, 0.06622583f, -0.12446698f, -0.10256036f, 
    0.05641219f, -0.04654744f, 0.14820591f, 0.09665380f, -0.38493204f, 0.36852124f, 0.14152634f, 0.03416005f, 
    0.04201375f, 0.18611005f, 0.08710576f, 0.29320115f, 0.16589923f, -0.10358592f, 0.15126766f, -0.06048673f, 
    0.03919191f, 0.19432665f, -0.11947499f, 0.06964625f, 0.05459122f, 0.08844286f, 0.14817259f, 0.40035042f, 
    0.08327536f, 0.05256447f, 0.08235404f, 0.09711191f, -0.20794408f, 0.25478831f, -0.39806598f, -0.11709379f, 
    -0.06622645f, 0.06702200f, 0.12308248f, 0.10998727f, 0.12316345f, -0.09820093f, 0.16206490f, 0.13390309f, 
    0.23247120f, -0.01059993f, -0.19732094f, -0.40724662f, 0.09785681f, 0.26668978f, 0.24390146f, 0.02730591f, 
    0.07883275f, 0.00451985f, 0.07476220f, 0.27694815f, -0.34800813f, -0.17192885f, -0.04932282f, -0.08347825f, 
    -0.12456233f, 0.05775426f, -0.03873013f, -0.01100315f, 0.08926522f, -0.06163720f, 0.21267420f, 0.05273670f, 
    0.05265980f, 0.13826646f, -0.13494323f, 0.16403568f, 0.02529915f, 0.02397953f, 0.01901280f, 0.16464159f, 
    0.16702457f, 0.01447083f, -0.03828884f, -0.06381346f, 0.17981546f, 0.17161605f, 0.05751973f, 0.31608686f, 
    -0.14570749f, 0.01137629f, 0.08138716f, -0.00631212f, -0.13645673f, -0.06598779f, 0.03464987f, 0.15485142f, 
    0.03302857f, -0.06609955f, 0.12924868f, 0.32897583f, -0.18052070f, 0.02219967f, 0.05936232f, 0.01679029f, 
    -0.04304583f, 0.11996568f, 0.08989401f, 0.19721749f, -0.26420543f, -0.03975347f, -0.09833761f, 0.01302995f, 
    -0.23210770f, -0.12672392f, -0.15059111f, -0.21525761f, -0.14647117f, -0.01256026f, -0.08366383f, -0.12838379f, 
    -0.04582788f, -0.09767237f, 0.01544442f, -0.12333767f, -0.07144064f, 0.00298017f, -0.03546327f, -0.15757824f, 
    0.21146953f, 0.04232884f, -0.03006963f, 0.15108868f, -0.15258743f, 0.12998958f, -0.21735533f, 0.11924244f, 
    0.02973804f, 0.02333065f, -0.07747941f, 0.22045128f, 0.17413934f, 0.16146830f, 0.11257765f, -0.06177565f, 
    0.15188296f, -0.03236535f, -0.01227135f, 0.14564349f, 0.06294234f, 0.11620819f, 0.17507029f, 0.08422169f, 
    0.06936479f, 0.10161637f, 0.15790243f, 0.02359023f, -0.29748312f, 0.28876737f, 0.09530445f, -0.03187824f, 
    -0.14248502f, -0.07422870f, -0.07290740f, 0.15452461f, 0.09173048f, 0.08013495f, 0.06537940f, 0.05246736f, 
    -0.18537021f, -0.01062013f, -0.01807672f, -0.01831013f, -0.16664049f, 0.06463514f, -0.03445775f, -0.05079009f, 
    -0.04660106f, -0.00309600f, 0.07539590f, 0.13282377f, -0.11356428f, -0.12406299f, -0.12118341f, -0.18728434f, 
    0.06811328f, 0.05760014f, 0.07007885f, -0.13441226f, -0.10414063f, 0.03554656f, -0.09559520f, 0.06564333f, 
    -0.06864538f, -0.02759054f, -0.00557062f, -0.07363841f, -0.10955868f, 0.18764250f, -0.11856420f, 0.04076544f, 
    0.33820617f, 0.01420162f, 0.28081289f, 0.21366477f, -0.07903152f, 0.02459477f, 0.06148298f, 0.02687246f, 
    0.15219812f, 0.13514207f, 0.17018652f, 0.15030360f, 0.04453905f, -0.00278060f, 0.11362351f, 0.09282623f, 
    -0.07120281f, 0.17853919f, 0.09031750f, -0.14860000f, 0.00097188f, 0.00641981f, 0.26502123f, 0.10688884f, 
    0.11437909f, 0.02196072f, -0.05021579f, -0.11643481f, -0.69037795f, 0.31594369f, 0.19813217f, -0.19468293f, 
    0.04252452f, 0.04469897f, 0.10384350f, 0.03494414f, 0.05664405f, 0.16574301f, -0.16565208f, 0.06088119f, 
    -0.36232442f, -0.04593327f, 0.18243597f, 0.11743309f, 0.16971356f, 0.04709026f, 0.01463517f, -0.07555922f, 
    0.01421323f, -0.02553616f, 0.17024873f, 0.08145407f, -0.03159241f, -0.21298803f, -0.02768666f, -0.13348706f, 
    0.32695299f, 0.07683675f, 0.14217438f, 0.00130252f, -0.01456687f, 0.03648403f, 0.04112423f, 0.09892736f, 
    -0.24214220f, 0.00948005f, -0.01426044f, -0.18265247f, -0.17171301f, -0.29806647f, -0.11847287f, -0.28655043f, 
    0.00405055f, -0.15173098f, 0.01646543f, 0.17015415f, 0.33318639f, 0.13816458f, 0.19705723f, 0.31818047f, 
    0.06594560f, -0.02016337f, 0.12202989f, 0.03715924f, 0.14177027f, 0.07477603f, -0.09982984f, 0.02286817f, 
    -0.40483841f, 0.14861384f, -0.17613359f, 0.01966319f, 0.01211438f, 0.08387624f, -0.13373834f, 0.15083814f, 
    0.02384700f, 0.01212882f, 0.25239271f, -0.18543543f, 0.19991906f, -0.04291685f, -0.06379653f, 0.04786991f, 
    0.14224038f, -0.03986898f, 0.05356120f, 0.13980444f, 0.03480287f, 0.21021987f, -0.13854852f, -0.30855337f, 
    0.15885447f, 0.06128374f, -0.07375664f, -0.18012589f, -0.03022530f, 0.06112427f, 0.02094616f, -0.00517364f, 
    0.00984042f, -0.07690690f, -0.09088398f, -0.18076514f, -0.21118262f, -0.05043371f, 0.37316692f, 0.34829098f, 
    -0.07670130f, -0.03328998f, 0.17414634f, 0.09762693f, 0.13822843f, 0.17534363f, 0.07198676f, -0.07450959f, 
    -0.00363315f, 0.04023810f, 0.06953262f, 0.00301267f, -0.07045522f, 0.12369550f, 0.08581033f, -0.14662997f, 
    0.13141476f, 0.02466240f, -0.28429988f, -0.21158406f, -0.14231162f, -0.17985538f, 0.08813606f, 0.00380494f, 
    0.02576562f, 0.23429449f, 0.21578062f, 0.11562224f, 0.01452494f, -0.05292683f, -0.14129636f, -0.25859886f, 
    0.07266346f, 0.17903604f, -0.13443300f, 0.08555950f, -0.11229546f, -0.01947640f, -0.06856862f, 0.06333587f, 
    -0.10057280f, 0.07707898f, -0.15627308f, -0.02036009f, 0.11358380f, -0.01365652f, 0.17994671f, -0.13118152f, 
    -0.07776698f, -0.16832824f, 0.12521566f, 0.06342064f, 0.12559325f, 0.00444303f, 0.04911141f, 0.15663321f, 
    -0.20052212f, 0.00178194f, 0.14457430f, 0.12793046f, 0.09883109f, 0.01567613f, 0.27594134f, 0.18829568f, 
    -0.05735482f, 0.10027754f, 0.10422807f, -0.09916543f, -0.14820418f, 0.06827054f, -0.08248326f, -0.11667868f, 
    -0.14645171f, 0.04556169f, 0.04535159f, 0.18251944f, -0.18957479f, -0.10614003f, -0.07768382f, -0.16606916f, 
    0.19532773f, 0.02713962f, 0.09306508f, 0.07342071f, 0.08410166f, 0.21036771f, -0.04783490f, 0.14629607f, 
    0.08323625f, 0.08081972f, 0.14714542f, -0.10148168f, -0.26988453f, -0.33065727f, 0.22493184f, 0.46965232f, 
    -0.12362863f, 0.02949766f, 0.07577533f, 0.40969270f, 0.33385170f, 0.12240856f, 0.14827664f, 0.01102179f, 
    -0.13896178f, -0.31516102f, -0.03394087f, -0.31557977f, 0.00809742f, -0.04553235f, -0.04642040f, -0.13607059f, 
    -0.03778101f, -0.03273576f, 0.26682043f, 0.07218596f, 0.08664084f, 0.08040416f, 0.06264390f, -0.02564067f, 
    -0.06457214f, -0.10239536f, -0.02945679f, 0.01965642f, 0.13933639f, 0.15610018f, -0.16082893f, -0.02645605f, 
    0.48520362f, 0.08754256f, 0.04838404f, -0.27072406f, 0.07256169f, -0.00308376f, 0.01810067f, 0.14947051f, 
    0.11717561f, 0.08166710f, 0.18982144f, 0.09100688f, 0.34781688f, 0.07349856f, 0.12384367f, 0.24428344f, 
    -0.03915163f, 0.01763201f, -0.04083772f, -0.09773596f, -0.06423178f, 0.07996564f, -0.09353158f, 0.06012733f, 
    0.63868940f, 0.17317717f, 0.28363729f, 0.07408277f, -0.02435430f, 0.05671638f, 0.06747681f, 0.04615024f, 
    0.09888837f, 0.01139797f, -0.03412812f, 0.20531566f, -0.03912818f, 0.00869886f, -0.07722595f, 0.01560227f, 
    -0.13958809f, -0.09925218f, -0.04408980f, -0.00895797f, -0.19255017f, -0.14913742f, -0.07887068f, 0.01135853f, 
    0.00784854f, -0.10981470f, 0.17199519f, -0.08313037f, 0.12221599f, -0.01276444f, -0.09442450f, 0.07653228f, 
    -0.06389219f, -0.05095428f, -0.13232093f, 0.13628978f, 0.19421162f, 0.15802912f, -0.09642741f, -0.05632444f, 
    0.03996029f, -0.04845482f, 0.26094019f, -0.06765381f, 0.02812130f, 0.31853735f, -0.08572107f, 0.22699931f, 
    -0.28589126f, 0.11399714f, 0.29846174f, 0.32652223f, 0.35674345f, 0.28375888f, -0.16518490f, -0.03210899f, 
    -0.00759577f, 0.04033034f, 0.23006216f, -0.18672518f, -0.31467769f, -0.01375258f, 0.13445999f, 0.02999538f, 
    -0.08866350f, -0.06302617f, 0.08355346f, 0.09344613f, 0.32465786f, 0.12716635f, 0.12385219f, 0.06693356f, 
    0.14370984f, 0.16060103f, 0.03846259f, -0.18951392f, 0.06975114f, -0.03812655f, -0.11484576f, 0.00463238f, 
    -0.09231436f, -0.11518639f, -0.09114489f, 0.07701044f, -0.26598614f, -0.19144897f, 0.05239112f, -0.01193976f, 
    0.15171313f, -0.00073476f, 0.16505617f, -0.21917306f, -0.11344577f, 0.00772258f, 0.03482069f, -0.04603579f, 
    -0.08281156f, 0.12128457f, -0.25391027f, -0.19892786f, -0.07988763f, 0.04278147f, 0.21622327f, 0.14340299f, 
    0.14204849f, 0.22836040f, -0.03295166f, -0.08432707f, -0.23355593f, 0.25466523f, 0.09289733f, -0.09789487f, 
    0.15889084f, -0.05705325f, 0.02953017f, 0.01115685f, -0.00566113f, 0.01288520f, -0.07025069f, 0.05377032f, 
    -0.21398799f, -0.06090374f, -0.09324536f, 0.11846854f, -0.00237628f, 0.13692351f, 0.23080489f, 0.04668301f, 
    0.01490047f, 0.01029605f, 0.29199761f, -0.03700157f, -0.27685913f, -0.16328225f, 0.22652088f, -0.12037122f, 
    0.05923506f, 0.03481787f, 0.05758438f, 0.21807002f, 0.29951128f, -0.01598991f, 0.04864571f, 0.13953871f, 
    0.26372427f, -0.03447468f, -0.07222655f, -0.28674316f, 0.10140902f, 0.00487376f, -0.04635488f, -0.12516567f, 
    -0.00511770f, -0.01412370f, -0.00184713f, 0.19402134f, -0.17251600f, -0.10167205f, -0.11761508f, -0.08990962f, 
    0.24550220f, -0.04790743f, 0.08445058f, 0.04419323f, -0.11413628f, -0.02170946f, -0.11541256f, -0.02375018f, 
    -0.03041900f, 0.04791851f, 0.03423427f, 0.17408118f, -0.16989712f, -0.09439784f, -0.05910205f, -0.07294147f, 
    -0.17853300f, -0.13612694f, 0.01364775f, 0.03756481f, -0.24580726f, -0.11993460f, -0.08927604f, -0.06094137f, 
    0.21817309f, -0.02272786f, 0.18880379f, 0.04788533f, 0.06393845f, 0.11118168f, 0.11654350f, -0.01795520f, 
    0.11135674f, -0.01060782f, -0.03420411f, 0.10807233f, 0.12061210f, 0.00260474f, 0.15883127f, -0.05848974f, 
    0.48437741f, 0.05292288f, -0.05093532f, 0.44351453f, 0.02346630f, 0.14341632f, 0.08578140f, -0.12808917f, 
    0.26459172f, -0.11847362f, 0.06967068f, 0.02154788f, 0.10382596f, 0.05484068f, 0.13749738f, -0.04977637f, 
    -0.07609071f, 0.07587469f, -0.26805955f, -0.19519271f, -0.09116659f, 0.12946722f, -0.01062897f, -0.28441587f, 
    -0.03015924f, 0.01642220f, -0.20027065f, 0.07912359f, -0.92294514f, -0.37205136f, -0.19062810f, 0.12358557f, 
    0.01281806f, 0.10919734f, -0.11411737f, -0.08126256f, -0.05609869f, 0.28669226f, -0.17355432f, 0.10420940f, 
    0.48298767f, 0.05862708f, -0.15852968f, 0.15819919f, -0.01993274f, -0.08592223f, -0.01075155f, 0.07254277f, 
    0.10312873f, 0.06190559f, 0.10262774f, -0.08068299f, 0.00831731f, -0.05210208f, -0.03135877f, -0.16944677f, 
    -0.03207413f, 0.07417922f, 0.11396205f, 0.01043299f, -0.12807682f, -0.02684931f, -0.02187662f, 0.02375351f, 
    -0.11896267f, 0.03137789f, 0.28912908f, -0.00801962f, -0.01380464f, 0.16024818f, -0.14374591f, 0.03143037f, 
    -0.03488499f, 0.21944553f, 0.15433334f, -0.08520883f, -0.23803537f, 0.42175391f, -0.20993823f, 0.13690501f, 
    -0.03986948f, -0.16294841f, -0.00403343f, 0.05561200f, 0.31661040f, 0.14481702f, 0.31189898f, 0.23524563f, 
    0.03253220f, -0.16015606f, -0.11453125f, 0.03175649f, -0.07485718f, 0.15150534f, 0.04629142f, 0.01556612f, 
    0.00398029f, -0.03863931f, 0.14289092f, -0.07568405f, -0.29180986f, 0.21273020f, 0.20199643f, -0.03809894f, 
    -0.33743012f, -0.02940434f, 0.07657066f, 0.22788443f, -0.03873968f, -0.07256193f, 0.04097920f, -0.06804051f, 
    -0.03728800f, -0.03876867f, -0.05002273f, 0.01122744f, -0.05322828f, -0.04071584f, -0.02164552f, 0.00916457f, 
    -0.03006336f, -0.02421189f, -0.02732630f, -0.01145533f, 0.00844898f, -0.05197482f, 0.01158008f, 0.02709579f, 
    0.02708116f, -0.00383018f, 0.03182624f, 0.00925081f, 0.03348981f, -0.04940967f, 0.03694646f, 0.00946396f, 
    -0.04507079f, -0.03410260f, 0.00797560f, -0.01740852f, -0.04337151f, -0.05107132f, 0.00939981f, 0.02849639f, 
    -0.00024922f, -0.04127470f, 0.02036043f, 0.02440238f, 0.02202907f, 0.03061693f, 0.01417223f, -0.02325788f, 
    0.03621709f, -0.02541708f, -0.02246433f, -0.04607004f, 0.02899829f, -0.01632663f, -0.04603127f, -0.02657200f, 
    -0.01513382f, 0.01602587f, -0.00867940f, -0.01076886f, -0.03337362f, -0.04564904f, 0.03660886f, -0.01680963f, 
    0.00652784f, 0.02045920f, 0.03888848f, -0.04750141f, 0.00849489f, 0.00518894f, -0.00401414f, -0.02133639f, 
    0.04461042f, -0.05102760f, 0.03313757f, -0.02227450f, -0.01777415f, 0.00143412f, -0.02669284f, 0.02397979f, 
    -0.01341041f, 0.00759924f, -0.05653955f, 0.03021474f, -0.00319260f, -0.02519324f, -0.02939094f, 0.02304648f, 
    0.00030254f, 0.01206182f, -0.03541621f, -0.01802457f, -0.01080136f, -0.01827551f, -0.01818510f, 0.02971061f, 
    0.00603228f, -0.03285239f, 0.00454471f, 0.01346012f, 0.00351949f, -0.04840131f, 0.02932117f, -0.02401734f, 
    0.02863589f, -0.00028094f, -0.00029476f, -0.01185749f, -0.05469390f, -0.02837631f, -0.00609967f, -0.02671249f, 
    -0.01500892f, -0.00360943f, -0.03517545f, -0.01853459f, -0.04883223f, -0.03435833f, 0.04331063f, -0.01506047f, 
    -0.03591185f, -0.01981401f, 0.00459377f, -0.03851690f, -0.02875368f, -0.04068827f, -0.04466483f, -0.01414029f, 
    -0.00880031f, -0.02916095f, 0.02023578f, -0.04417515f, -0.05446336f, -0.02553797f, 0.01873845f, -0.01986776f, 
    0.02629098f, 0.01930722f, -0.00583063f, -0.03968804f, -0.00692393f, -0.00668877f, -0.04061202f, -0.04693398f, 
    -0.00235696f, 0.00432089f, -0.05208594f, -0.00760408f, -0.03985181f, 0.04007225f, 0.01249782f, -0.01054334f, 
    -0.02948487f, 0.03692391f, -0.05208177f, 0.00271997f, 0.01122320f, 0.04422127f, 0.01659439f, -0.05557603f, 
    -0.04074457f, -0.02514154f, 0.02767791f, 0.00475934f, 0.01154722f, 0.01410736f, -0.02856729f, 0.03153929f, 
    -0.01045758f, -0.03284013f, -0.01733432f, 0.02208441f, 0.00439362f, 0.00258982f, 0.02172003f, -0.00576318f, 
    0.00090310f, 0.00536763f, 0.00594570f, 0.00946143f, -0.01382918f, 0.02521795f, 0.01108841f, -0.04265928f, 
    -0.04736349f, 0.04265080f, -0.04008031f, -0.02415523f, -0.00470930f, 0.03715292f, 0.00722757f, -0.01748321f, 
    0.02116647f, -0.00910226f, 0.00232220f, -0.00882189f, -0.01116293f, -0.05293054f, -0.00386512f, -0.02837682f, 
    -0.01784128f, -0.01715874f, 0.00832794f, -0.04433758f, -0.05180643f, 0.00468412f, -0.05449082f, 0.02749456f, 
    -0.03570485f, 0.02130365f, 0.01322965f, -0.03646195f, -0.01704343f, -0.03583447f, -0.04110613f, -0.02457763f, 
    0.02116586f, -0.03268116f, -0.01043845f, 0.00534967f, 0.01385377f, 0.02807273f, 0.03227130f, 0.04149436f, 
    -0.01460385f, -0.03068866f, -0.01012362f, 0.04127068f, 0.04189353f, 0.02534602f, -0.05220596f, -0.03288905f, 
    0.03677076f, 0.03695030f, -0.04596759f, 0.02098347f, -0.04876997f, 0.00319642f, -0.00044603f, -0.02343247f, 
    0.03381782f, -0.05180167f, 0.01340758f, -0.05240012f, -0.00457685f, 0.00666132f, -0.00565299f, 0.01600874f, 
    0.04206794f, 0.00721593f, 0.02014564f, -0.01873764f, 0.02402490f, 0.02468773f, -0.03044154f, -0.04464206f, 
    0.00786167f, -0.00385160f, -0.04678578f, -0.01136718f, -0.02450983f, -0.00780261f, -0.02316783f, -0.01176782f, 
    -0.00345095f, 0.00522083f, 0.01111254f, 0.01679334f, 0.00976585f, -0.04910248f, 0.01511157f, -0.03455441f, 
    0.01534033f, 0.02451970f, 0.02144334f, -0.00849637f, 0.03104894f, -0.05520167f, -0.00988608f, 0.04239790f, 
    0.02991155f, 0.03196428f, -0.01332919f, 0.00573005f, -0.03862908f, 0.00845055f, -0.03269541f, -0.00223302f, 
    -0.02611164f, 0.03246528f, -0.00852745f, 0.00571724f, -0.03930192f, 0.02787845f, -0.00654412f, 0.03932450f, 
    -0.00978755f, 0.01498713f, 0.02709206f, 0.01337769f, 0.01692732f, -0.04871079f, -0.01168857f, -0.00948512f, 
    0.01751615f, -0.02681169f, -0.04695547f, -0.01880151f, 0.02690768f, -0.04852577f, -0.05224653f, 0.03374796f, 
    -0.00208182f, 0.02120826f, -0.00037383f, -0.02588494f, -0.02558121f, 0.01995923f, 0.04276944f, -0.03243785f, 
    -0.01614432f, -0.04947118f, 0.02504359f, -0.00010914f, -0.01512147f, 0.00939808f, -0.01163870f, -0.03095809f, 
    -0.01456161f, 0.01770135f, -0.05098311f, -0.05613541f, -0.00777629f, -0.00082684f, -0.02722339f, 0.02532023f, 
    -0.04191966f, 0.03275092f, -0.01256262f, -0.03485814f, 0.02450049f, -0.04231071f, 0.02632535f, -0.04388927f, 
    0.02892506f, -0.04950489f, 0.03147864f, 0.04049543f, 0.04138412f, 0.00564681f, -0.03188902f, -0.04816938f, 
    -0.03055427f, -0.05614202f, -0.00558648f, -0.04595762f, -0.03829999f, 0.00408725f, 0.00751627f, -0.04026578f, 
    0.03357043f, -0.05003344f, 0.03073096f, -0.04477737f, 0.02949439f, 0.02402276f, 0.02804940f, 0.00479947f, 
    -0.03292711f, -0.01426154f, -0.00161924f, -0.01192486f, 0.03616738f, -0.02478146f, -0.01444530f, -0.05466728f, 
    0.04255697f, -0.03751351f, -0.02368843f, -0.01338111f, -0.05017856f, 0.02729940f, 0.04085900f, 0.00165352f, 
    -0.05563723f, 0.04226834f, -0.03091189f, 0.03059403f, 0.02679234f, 0.02572785f, -0.02416807f, -0.04171157f, 
    0.35873473f, -0.07546213f, -0.11361650f, 0.14604700f, 0.17647094f, 0.16257955f, -0.04003562f, 0.02040815f, 
    -0.09673335f, 0.12648989f, 0.02396581f, -0.03949192f, -0.28014198f, 0.41386315f, -0.09144501f, -0.18531422f, 
    0.11164350f, -0.04589674f, 0.01700723f, 0.05728786f, 0.16278373f, -0.02176377f, -0.04859972f, 0.16441680f, 
    -0.05796157f, -0.23474444f, -0.09909048f, -0.41421205f, 0.09846011f, -0.08761007f, 0.00614292f, 0.14440475f, 
    -0.01759503f, 0.02753637f, 0.17746952f, -0.10311777f, 0.08671085f, -0.15557818f, 0.07863062f, 0.13247117f, 
    -0.06278155f, 0.03249708f, 0.01232756f, 0.02240947f, 0.08385544f, 0.23599046f, 0.03740292f, 0.16277848f, 
    0.18529607f, -0.22622719f, 0.13171922f, -0.03444491f, 0.02806447f, -0.11943840f, 0.02636816f, 0.01539849f, 
    -0.03000069f, 0.34641734f, -0.07748252f, 0.28873289f, 0.07463443f, 0.03800869f, 0.01356335f, 0.13516806f, 
    -0.01824856f, 0.00093329f, 0.06424069f, 0.00627825f, -0.07217313f, 0.11032540f, -0.03043442f, 0.08415298f, 
    -0.18483692f, 0.19857350f, 0.28494191f, -0.19803344f, 0.04482920f, -0.06129406f, -0.08333013f, -0.03237816f, 
    0.05956359f, 0.05070443f, -0.23656429f, 0.08129597f, 0.00206310f, -0.01335509f, 0.10448903f, 0.02872718f, 
    0.04054834f, -0.03902544f, -0.11450645f, 0.01204578f, 0.15542582f, 0.05242412f, -0.08404129f, 0.11841825f, 
    -0.14123040f, -0.03614823f, 0.10972836f, 0.11245655f, 0.01402389f, -0.25316009f, -0.00855251f, 0.10375299f, 
    -0.08730847f, 0.06678876f, 0.01187486f, 0.00208404f, 0.19045505f, -0.00372564f, 0.07683462f, -0.04878558f, 
    0.21334743f, 0.04140811f, -0.03088302f, -0.06696682f, 0.03716337f, 0.12967423f, -0.01869069f, 0.16946463f, 
    0.11690178f, 0.19531666f, -0.32337022f, -0.15878008f, 0.04363233f, -0.07294495f, 0.13584395f, 0.13492455f, 
    0.10385283f, -0.13694488f, 0.12933905f, -0.12756938f, -0.10261822f, -0.03631868f, 0.23970242f, 0.04894284f, 
    -0.03603141f, -0.11763591f, 0.07088105f, 0.04183673f, 0.09977151f, -0.04969888f, 0.18624091f, -0.10328521f, 
    -0.14353621f, 0.13540795f, -0.01486216f, 0.12115275f, -0.02252283f, -0.14409313f, 0.05458527f, -0.03728795f, 
    -0.00101319f, -0.03224215f, -0.01838862f, 0.07010744f, -0.15674810f, -0.02120829f, -0.07680741f, -0.06553724f, 
    -0.18561032f, -0.05051531f, -0.12889865f, 0.03380929f, -0.05338246f, -0.10534284f, -0.02244769f, 0.08357158f, 
    0.09798204f, 0.01999254f, 0.11230350f, 0.11584552f, 0.08349514f, -0.03157119f, 0.03972130f, 0.03528723f, 
    -0.00987382f, 0.11609307f, -0.38821086f, 0.03923488f, 0.15269575f, -0.05733766f, -0.05346906f, 0.08932482f, 
    -0.10904430f, 0.01654510f, -0.03334483f, -0.23252685f, -0.10920433f, 0.01114566f, -0.04984102f, -0.13911222f, 
    0.30729473f, -0.29472914f, -0.06630925f, 0.07781224f, -0.05279117f, 0.26192015f, 0.01104019f, 0.03666659f, 
    0.10885733f, 0.22072476f, -0.00893993f, 0.19228843f, 0.38762107f, -0.08415528f, -0.05301267f, 0.09672970f, 
    -0.06929251f, 0.02743013f, -0.13779026f, 0.10627022f, -0.04592147f, -0.18651220f, 0.15278879f, 0.08857452f, 
    0.24962641f, -0.16544147f, 0.19541562f, 0.07243656f, -0.00785382f, -0.08757801f, -0.06633121f, -0.03783355f, 
    -0.16875081f, -0.00414353f, -0.02655650f, 0.01817380f, 0.02627791f, 0.07115912f, -0.09444679f, -0.19401686f, 
    -0.17561737f, -0.11314370f, -0.06655895f, -0.05899110f, -0.11705873f, -0.07063039f, -0.03259883f, -0.03193679f, 
    0.07677829f, 0.19652617f, 0.09095959f, 0.02155375f, -0.07718036f, -0.01186214f, -0.04459606f, 0.05147469f, 
    0.20702311f, 0.06803469f, 0.03543394f, 0.05561575f, 0.20637599f, -0.22853877f, -0.05358534f, 0.09643224f, 
    -0.16500552f, 0.15037642f, -0.02702650f, 0.01799388f, -0.04296213f, -0.10952988f, 0.15305497f, 0.22489391f, 
    0.08486306f, -0.00441643f, 0.07837196f, -0.04292008f, 0.03919365f, 0.08762461f, 0.13812922f, -0.12983443f, 
    0.35904977f, 0.18161424f, -0.12851579f, 0.36761221f, -0.00496061f, -0.10588194f, 0.00109056f, 0.03388105f, 
    -0.03544692f, 0.01504932f, 0.09980449f, -0.19981471f, 0.02840530f, 0.05149032f, 0.11563300f, -0.02177519f, 
    -0.00031798f, 0.23038225f, 0.09162444f, 0.04761726f, 0.00246771f, 0.16014245f, -0.11494142f, 0.18722209f, 
    0.12154338f, 0.08625791f, -0.03761709f, 0.27900603f, -0.44414803f, 0.46413213f, -0.02279764f, 0.03078103f, 
    -0.05656106f, -0.11638802f, -0.01935083f, 0.16133413f, 0.05519376f, 0.01931649f, -0.09583203f, 0.16744106f, 
    -0.21566533f, -0.01189754f, 0.29648098f, -0.02508730f, -0.04897516f, -0.05830389f, -0.17186882f, 0.13820751f, 
    -0.17934208f, 0.18778192f, 0.28333527f, 0.29686022f, -0.07958521f, 0.18568979f, 0.00610935f, -0.19010141f, 
    0.16552451f, -0.04407812f, -0.00656573f, -0.15487756f, -0.02895154f, -0.19548540f, 0.15404449f, 0.16225921f, 
    0.07270534f, -0.04087789f, -0.04543416f, -0.10155261f, -0.12073437f, -0.13258633f, 0.03345153f, 0.17976540f, 
    0.07158604f, 0.02535837f, 0.01163738f, 0.10876047f, -0.04183920f, -0.10308388f, 0.14281951f, 0.20428170f, 
    -0.11799517f, 0.03548903f, -0.00944160f, -0.00637283f, 0.13796969f, -0.07850996f, 0.36696523f, 0.26261285f, 
    0.15021631f, 0.36625129f, 0.19853118f, 0.00906732f, -0.03090959f, 0.05822414f, -0.09398541f, -0.02121261f, 
    -0.19868009f, -0.13937633f, -0.09737375f, 0.18576910f, 0.06057017f, 0.03598804f, -0.12234410f, 0.13212197f, 
    0.25214973f, 0.18238603f, -0.06652238f, -0.26884484f, 0.04318262f, 0.15490475f, 0.10398713f, -0.12350942f, 
    -0.05049374f, 0.03198047f, -0.00189095f, 0.03030528f, 0.00103598f, -0.02445122f, 0.04305108f, 0.03063920f, 
    -0.05531945f, 0.03779054f, 0.04358169f, -0.04898382f, 0.01819819f, -0.00149456f, 0.02213527f, -0.05335536f, 
    -0.04777147f, 0.02584139f, -0.03623996f, -0.00006955f, -0.03957628f, -0.03214459f, 0.01283923f, -0.01294189f, 
    0.03088612f, -0.03949285f, 0.00301562f, -0.01976663f, -0.05226919f, -0.03515926f, -0.00170765f, -0.00454032f, 
    -0.01279227f, -0.03949039f, -0.05198895f, 0.01943499f, -0.04080240f, -0.05371904f, 0.01066274f, -0.03934311f, 
    -0.04616579f, -0.02438012f, -0.02380097f, 0.00828529f, 0.03467705f, 0.02542086f, -0.00046849f, -0.04413502f, 
    -0.03785049f, 0.01581162f, -0.03801462f, -0.01900957f, 0.00603364f, 0.01424584f, -0.01485271f, -0.03174883f, 
    -0.00163662f, 0.03492261f, -0.04474657f, -0.00558498f, -0.01182574f, 0.00945852f, -0.01263925f, -0.02691183f, 
    -0.01627359f, 0.02478665f, -0.00147860f, -0.02323501f, 0.04408848f, -0.03039822f, -0.05269117f, -0.00323746f, 
    0.00578726f, -0.03644875f, -0.00527052f, 0.03413947f, 0.01367886f, 0.01695186f, 0.02966112f, -0.03734403f, 
    -0.05195183f, 0.03872845f, 0.03179320f, -0.04743281f, 0.01551294f, -0.03191729f, 0.02477855f, -0.00300915f, 
    -0.02242091f, -0.03230928f, 0.02355572f, -0.00452717f, 0.00870232f, 0.04408074f, 0.01176368f, 0.00701403f, 
    -0.01608325f, 0.01841147f, 0.02887643f, 0.00394823f, -0.04673423f, 0.01490554f, 0.00856190f, -0.04586618f, 
    0.01032551f, 0.02043427f, -0.04282741f, 0.00527000f, 0.04327111f, -0.05665768f, -0.03366350f, -0.04893333f, 
    0.00603771f, 0.00337246f, 0.00486958f, -0.02406606f, -0.01928785f, 0.03209484f, -0.02853155f, 0.00351398f, 
    -0.02596574f, -0.04190394f, -0.01975781f, 0.02730154f, 0.03936868f, -0.01307565f, 0.03502212f, -0.00707757f, 
    0.00019190f, 0.00480499f, 0.03673102f, 0.01213362f, -0.01688435f, -0.04960683f, -0.04376050f, -0.02984789f, 
    0.03078489f, 0.02940551f, -0.00224562f, -0.04004342f, -0.05024732f, 0.02089650f, -0.02749094f, -0.03673810f, 
    0.00550470f, 0.00804522f, -0.03636119f, -0.03259725f, 0.03803613f, -0.01262596f, 0.03945338f, 0.01421998f, 
    -0.01365645f, -0.01397488f, -0.05021124f, 0.00751566f, -0.04739900f, -0.04781178f, -0.00143203f, -0.03461011f, 
    -0.03931100f, 0.01076998f, 0.01466368f, 0.02789088f, 0.02395797f, -0.03401873f, -0.00838347f, -0.05287790f, 
    -0.04090539f, -0.02873871f, -0.05345320f, -0.00435270f, -0.04155518f, -0.00868984f, -0.03274492f, -0.04741925f, 
    -0.04090383f, -0.00171063f, 0.03014961f, -0.03341123f, -0.05305536f, -0.03302257f, -0.04795354f, -0.00698846f, 
    -0.01159362f, 0.02916671f, -0.02432609f, -0.04995881f, 0.03185406f, -0.03527627f, 0.02851506f, 0.02284935f, 
    0.03673048f, -0.03716160f, -0.04400429f, -0.04903415f, 0.00397563f, -0.02666376f, 0.01345677f, 0.03235370f, 
    -0.05253534f, 0.00979254f, 0.02454693f, -0.03926901f, 0.02460425f, -0.01250984f, -0.00131183f, -0.00191991f, 
    -0.02808504f, -0.05096992f, -0.03843781f, 0.04304729f, -0.02652578f, -0.04177119f, -0.03703176f, 0.01763700f, 
    -0.03511893f, -0.03795329f, 0.00736400f, 0.02350833f, 0.01866544f, 0.03870256f, -0.00913270f, -0.03206007f, 
    -0.00054238f, 0.03853812f, -0.00320289f, 0.03614348f, -0.04611771f, 0.02393429f, 0.02683612f, -0.04691575f, 
    -0.04175648f, -0.03963230f, -0.02826409f, -0.03037264f, -0.01149394f, 0.04034211f, -0.01366408f, -0.00429104f, 
    0.02062031f, 0.01063115f, 0.02158752f, -0.01590545f, 0.01147910f, -0.02549399f, 0.03821139f, -0.02828202f, 
    -0.00592717f, -0.05269345f, -0.01136106f, 0.00082209f, -0.05041645f, 0.00481330f, 0.04070214f, -0.00772043f, 
    -0.00813887f, -0.05351608f, -0.04027132f, 0.04180489f, -0.00570415f, 0.00375197f, -0.03258635f, -0.00901436f, 
    0.01805377f, 0.00463837f, 0.03324123f, -0.05317859f, -0.04311826f, 0.03444724f, -0.02615791f, 0.03026230f, 
    0.03700075f, -0.00766648f, -0.01024791f, 0.03917269f, 0.02533027f, -0.01171973f, 0.01370520f, -0.02930787f, 
    -0.03026943f, -0.02542387f, 0.00322691f, -0.00790031f, 0.04110051f, 0.04123695f, -0.03016098f, -0.00944633f, 
    -0.01127199f, -0.01870651f, -0.04901792f, 0.01357420f, -0.03146551f, 0.01987380f, -0.04389619f, 0.00887167f, 
    -0.00332515f, -0.04100716f, -0.00203830f, 0.01662519f, -0.05009070f, 0.02756832f, 0.00786635f, 0.04102595f, 
    0.02162968f, 0.04499212f, -0.02202377f, -0.03850916f, -0.02640593f, -0.03484846f, -0.01226761f, 0.04202893f, 
    -0.02981620f, -0.01167161f, 0.00671340f, -0.04139668f, 0.00251569f, 0.03577564f, -0.03123464f, 0.01215748f, 
    0.04439251f, -0.05018639f, -0.03214394f, -0.02195366f, -0.02791994f, 0.02902635f, 0.03254811f, -0.02592504f, 
    0.04329546f, 0.03194994f, -0.01871176f, -0.05468472f, 0.01243555f, 0.00192395f, 0.00909747f, -0.03239268f, 
    -0.02573331f, 0.04470936f, -0.05272190f, -0.03780765f, 0.03853972f, 0.03259518f, 0.03496965f, -0.01462016f, 
    0.04396738f, 0.01929162f, 0.00104390f, 0.01725944f, -0.04978534f, -0.00758431f, 0.03818962f, 0.00450699f, 
    -0.02439345f, 0.03199164f, 0.01744839f, 0.02831967f, 0.02940167f, -0.00063197f, -0.01438062f, 0.00866840f, 
    -0.02920458f, 0.04494153f, 0.01168515f, 0.04303853f, -0.02912807f, 0.00088424f, -0.05528599f, -0.03552429f, 
    0.03983121f, -0.02138754f, 0.00751157f, 0.03305019f, -0.02671451f, -0.02911937f, -0.05006643f, 0.02463629f, 
    -0.02845862f, -0.01738263f, -0.01152843f, 0.00938581f, 0.00136199f, 0.01775718f, 0.00910354f, -0.05029647f, 
    0.02288652f, -0.04037944f, 0.02847258f, -0.07550067f, 0.02324505f, -0.06727590f, -0.00017239f, -0.05478675f, 
    -0.03679318f, -0.03101522f, -0.04970623f, -0.01134912f, -0.00274511f, -0.03513378f, -0.01116366f, -0.04471884f, 
    -0.01285400f, -0.06228620f, 0.02425400f, -0.06918915f, -0.06006474f, -0.03819069f, -0.01383859f, 0.04302893f, 
    0.06011853f, -0.03347924f, 0.03800928f, 0.00212015f, -0.02565785f, -0.02120477f, -0.01557753f, -0.01717029f, 
    -0.06415621f, -0.04140581f, -0.03031324f, -0.01695759f, -0.01097886f, -0.03514256f, -0.02830229f, -0.05586561f, 
    0.02357041f, -0.05180470f, -0.03734598f, -0.01900491f, 0.05127715f, -0.04349482f, -0.04347952f, 0.02525454f, 
    -0.05048739f, -0.06755041f, -0.03815174f, -0.00137006f, -0.02961140f, -0.06344142f, 0.00073856f, -0.01777306f, 
    -0.02272255f, 0.00003677f, -0.00617677f, -0.05830798f, -0.02414508f, 0.01511791f, -0.05017783f, 0.00606220f, 
    0.00041421f, -0.05980887f, -0.05871516f, -0.02112149f, -0.01014845f, -0.01726348f, 0.01340221f, -0.02577565f, 
    -0.03374214f, 0.01444790f, 0.02672590f, 0.02667533f, -0.03987840f, -0.00033911f, -0.03960219f, -0.02405260f, 
    0.03598984f, -0.04156498f, -0.02854678f, 0.01826731f, 0.02172105f, -0.00830629f, 0.01711435f, 0.02456198f, 
    -0.01871902f, -0.02371644f, 0.03779387f, -0.04193325f, 0.01251082f, -0.01097203f, -0.05436706f, -0.03455230f, 
    -0.01106326f, -0.00218311f, -0.04247191f, 0.01880187f, 0.01697609f, 0.01685265f, -0.00380524f, -0.00226328f, 
    -0.03049804f, -0.05663526f, -0.01776957f, 0.01553014f, -0.01433347f, -0.05162469f, -0.00966150f, 0.02676058f, 
    -0.04923136f, -0.00588489f, -0.00475952f, -0.07383221f, 0.02439293f, -0.02795434f, -0.05204148f, -0.00655263f, 
    -0.00548430f, -0.03658526f, 0.01793820f, -0.01368778f, 0.00694679f, -0.05777052f, 0.00896020f, 0.04239340f, 
    0.01741069f, -0.00850681f, -0.00288889f, 0.02561094f, 0.02859924f, -0.01579519f, -0.02420026f, 0.01976702f, 
    0.00754992f, -0.02123954f, -0.04259363f, 0.00068060f, -0.02082956f, 0.03856416f, 0.03055620f, -0.04342298f, 
    -0.03012163f, -0.05466203f, -0.03340500f, 0.00012422f, -0.03228300f, -0.01785576f, 0.01773524f, 0.01635186f, 
    0.00890459f, -0.04183594f, -0.04838193f, -0.00712700f, -0.04351240f, 0.04547275f, 0.03858583f, -0.00562048f, 
    -0.04073704f, -0.04534083f, -0.04482835f, -0.03226594f, 0.01912037f, -0.00321160f, 0.01143805f, -0.02697600f, 
    0.05544630f, -0.02154320f, 0.02071796f, 0.04927346f, 0.03544247f, -0.04409563f, -0.05344914f, -0.03899720f, 
    -0.05524126f, 0.02983392f, -0.03558657f, -0.05025776f, 0.03913961f, 0.02894296f, 0.02270691f, -0.05047085f, 
    -0.04153736f, 0.00538776f, -0.03441401f, -0.07150399f, 0.03699150f, -0.04374231f, -0.02736483f, -0.05678965f, 
    0.04502048f, 0.04200161f, -0.01997415f, -0.00077094f, 0.02201063f, 0.02692288f, -0.03169117f, -0.04314068f, 
    0.02925017f, 0.02663377f, 0.01665852f, -0.04788691f, -0.00391886f, 0.02014668f, 0.03994275f, -0.03717752f, 
    -0.01193438f, 0.04289207f, -0.05663694f, 0.01341740f, -0.01613009f, 0.01146827f, -0.00578445f, -0.05205444f, 
    -0.00353053f, 0.02746897f, -0.05461563f, -0.03570778f, 0.01050280f, -0.00328466f, -0.00019854f, 0.03012366f, 
    -0.05699450f, -0.01408921f, -0.00213647f, -0.05681027f, 0.06341913f, -0.01981892f, -0.01156486f, -0.00584361f, 
    0.05224178f, 0.01524562f, -0.03423065f, 0.03547095f, -0.04430574f, -0.05448196f, -0.06908812f, -0.05801957f, 
    -0.03979256f, 0.00271874f, -0.01264378f, 0.04762033f, -0.03679566f, -0.03430541f, -0.02704872f, 0.01027099f, 
    0.00844791f, -0.05969458f, 0.02897481f, -0.05953152f, 0.00353168f, -0.04720197f, -0.03478437f, -0.01865033f, 
    -0.02902125f, 0.02989192f, 0.01166502f, -0.04232508f, -0.04172159f, 0.03193252f, 0.03087630f, -0.06108604f, 
    -0.03974406f, -0.04285943f, -0.01825761f, -0.05430301f, -0.02692919f, -0.03025738f, 0.03616696f, -0.07377286f, 
    0.02452575f, -0.05258946f, -0.01866434f, 0.04576149f, 0.07149776f, -0.05058110f, -0.04260752f, -0.01176120f, 
    0.00568235f, -0.02578130f, 0.01473431f, -0.01885202f, -0.03374548f, -0.01642086f, -0.01273695f, 0.00226676f, 
    0.01053722f, 0.00327438f, 0.00129050f, 0.03916206f, 0.03879952f, 0.04788651f, 0.00372532f, 0.00220082f, 
    -0.00724560f, 0.00822819f, -0.03692075f, 0.00159580f, -0.03728013f, 0.00194581f, -0.02912717f, -0.00484065f, 
    0.02939838f, -0.01532497f, 0.02893220f, -0.02945424f, 0.02156607f, -0.03194498f, 0.03435683f, -0.07095535f, 
    0.00205176f, 0.00329312f, -0.00905641f, -0.04022070f, -0.03311081f, 0.01691705f, -0.01767915f, -0.03526698f, 
    0.01965685f, -0.01620775f, 0.02668670f, 0.01729743f, 0.03613924f, 0.02952162f, 0.03182589f, -0.00437208f, 
    -0.01215735f, -0.05549432f, -0.03739266f, 0.01141657f, 0.03253454f, 0.01072192f, 0.02057952f, -0.01926647f, 
    -0.03176943f, -0.00349326f, -0.03318716f, -0.00622914f, -0.06391154f, 0.02571761f, -0.02831426f, 0.04001477f, 
    -0.03025492f, -0.05584561f, -0.01775198f, 0.00308702f, 0.02271221f, 0.03666974f, -0.04129365f, 0.02215371f, 
    -0.02064748f, -0.01490672f, -0.02526391f, 0.00370259f, -0.01418982f, 0.01822105f, -0.00507511f, -0.03591919f, 
    0.03987221f, 0.00844488f, 0.03660421f, 0.01559002f, 0.04679903f, 0.00058525f, 0.02120843f, 0.02748301f, 
    -0.06437951f, 0.00403599f, -0.07135560f, 0.03212029f, -0.02654618f, 0.03901983f, 0.03821990f, -0.04272603f, 
    0.03918006f, 0.04020603f, -0.05390448f, -0.01362506f, -0.05411480f, 0.00988675f, 0.01826754f, 0.02790654f, 
    -0.02085120f, -0.18769906f, 0.14663321f, 0.11549058f, 0.13450314f, -0.03865619f, -0.16922051f, -0.14414600f, 
    -0.01780537f, -0.17262705f, -0.10554251f, -0.13278349f, 0.21423905f, -0.05220569f, 0.00112187f, 0.22586142f, 
    0.15071641f, 0.03138893f, 0.07460091f, -0.03984411f, -0.02831336f, 0.18534228f, 0.02652452f, 0.09125984f, 
    -0.28564766f, -0.11948230f, -0.35727289f, 0.22154015f, 0.17542483f, -0.11604287f, 0.06903720f, -0.14649135f, 
    -0.09106873f, -0.05036940f, -0.07577658f, -0.10001854f, 0.29317784f, 0.07047742f, 0.08376177f, 0.07948232f, 
    -0.03233521f, -0.14710844f, -0.09463853f, 0.07775444f, 0.08602802f, 0.24918379f, 0.17394032f, 0.02655287f, 
    0.05946675f, 0.03045075f, 0.41892347f, -0.14830606f, 0.02550003f, -0.13182038f, -0.08283056f, -0.10486816f, 
    -0.10933392f, 0.26961598f, 0.24146898f, 0.26290235f, -0.20152652f, -0.11269621f, 0.07336318f, -0.00973855f, 
    0.01620007f, 0.04050703f, -0.05425421f, -0.09400690f, -0.02564938f, -0.03696203f, 0.01641523f, -0.04548009f, 
    -0.07782285f, 0.20406392f, 0.10074694f, -0.23737425f, 0.04973061f, -0.04990961f, -0.07965162f, 0.06809961f, 
    0.02008419f, -0.03079036f, -0.08313791f, -0.02038215f, -0.02194838f, 0.07915395f, -0.05232075f, -0.19372360f, 
    0.00264800f, 0.03359706f, 0.03347631f, -0.01479717f, 0.03273863f, -0.07164022f, -0.16096878f, -0.03008078f, 
    -0.17071189f, 0.05121334f, -0.10635485f, 0.10326362f, -0.04525321f, -0.19012719f, -0.02444915f, 0.04889617f, 
    -0.39837429f, -0.06516248f, 0.00840579f, -0.12674747f, 0.06883336f, 0.18061301f, 0.24716105f, -0.23344095f, 
    0.02712391f, 0.25150588f, 0.10041264f, -0.11323879f, -0.10500236f, -0.04849858f, -0.05919176f, -0.05591038f, 
    0.17329778f, -0.11761586f, -0.17436792f, -0.00125307f, -0.00821027f, 0.26303250f, -0.07943361f, -0.07291842f, 
    -0.00116951f, -0.00793231f, -0.05654140f, -0.13332412f, 0.28637236f, -0.16411176f, 0.23226742f, -0.14218615f, 
    0.05647302f, -0.17827888f, 0.10240012f, 0.04556128f, 0.03623019f, 0.07351375f, 0.02369143f, -0.09939214f, 
    -0.17741747f, -0.06503759f, 0.20118430f, -0.18210101f, 0.10659474f, -0.23368894f, -0.04610299f, -0.02639011f, 
    -0.30999905f, -0.20910749f, -0.00849430f, -0.50420415f, -0.15268569f, -0.06859069f, -0.14119042f, 0.06899149f, 
    -0.06877242f, -0.12057937f, -0.06608825f, 0.05141013f, -0.14270259f, -0.13370094f, -0.09357546f, -0.15484604f, 
    -0.19478564f, 0.12284108f, 0.22268881f, -0.02658908f, 0.01528346f, -0.12777726f, 0.13388550f, -0.00077380f, 
    -0.15808387f, 0.01858473f, -0.26641893f, -0.11565660f, 0.03390175f, -0.13587050f, 0.13012011f, 0.12674905f, 
    -0.16313885f, -0.05166721f, 0.01809785f, -0.11397872f, 0.00810903f, 0.03186155f, -0.01061953f, -0.07088570f, 
    0.06391324f, -0.33362743f, 0.11031796f, 0.23172826f, 0.01603116f, 0.16778091f, 0.05398964f, 0.00258734f, 
    0.20712586f, 0.33542413f, 0.15520085f, 0.24559939f, 0.38404766f, -0.44836029f, 0.54573011f, 0.39827579f, 
    -0.08273263f, 0.07759425f, 0.05420745f, 0.25272122f, 0.12173363f, -0.11865351f, 0.29466146f, 0.06900081f, 
    0.16838327f, 0.12780787f, 0.26119882f, -0.33574626f, 0.02880293f, -0.01440930f, -0.20377028f, -0.05888317f, 
    -0.36768541f, -0.22979522f, -0.17869256f, -0.05710276f, -0.21448526f, -0.16196147f, -0.31932208f, -0.01482562f, 
    -0.15696999f, -0.07484044f, -0.17302902f, 0.09001923f, -0.18205297f, -0.06733299f, -0.06466851f, -0.15886903f, 
    -0.15350565f, 0.05003427f, -0.30328354f, -0.23959495f, -0.13853590f, 0.19036742f, 0.01600064f, 0.15509295f, 
    -0.02430132f, 0.00711142f, 0.01628755f, -0.14002661f, -0.22748777f, 0.39834735f, -0.37626830f, 0.05228380f, 
    0.19606160f, -0.08879207f, -0.06971505f, -0.02508516f, -0.30458862f, 0.01583210f, 0.10063617f, 0.09976701f, 
    0.00637090f, 0.18958014f, -0.01958193f, 0.08587097f, -0.17038693f, 0.09073652f, 0.02080745f, -0.25851959f, 
    0.07836508f, 0.15397067f, -0.10886074f, 0.32881802f, -0.34518474f, -0.16541478f, -0.04528902f, 0.00036612f, 
    -0.00392738f, 0.11764957f, 0.05201751f, 0.01782838f, 0.10728422f, -0.13671079f, 0.13115728f, 0.25545198f, 
    -0.14384668f, 0.23267527f, 0.08869162f, 0.11519095f, -0.15804850f, -0.09661638f, 0.08730380f, 0.15003169f, 
    0.14910860f, 0.25536481f, 0.06705540f, 0.22494438f, 0.65817791f, 0.71974462f, 0.05740510f, 0.41141254f, 
    -0.19323285f, 0.03772706f, -0.18360448f, -0.06447640f, -0.04467297f, -0.11960627f, 0.06580460f, 0.28989381f, 
    -0.42978761f, 0.07943799f, 0.02291560f, -0.01478573f, -0.07070902f, -0.21935472f, -0.10581051f, -0.05321453f, 
    0.11917935f, 0.28670001f, 0.44013992f, 0.47534987f, -0.32849205f, -0.03773405f, -0.16445474f, 0.11815654f, 
    0.00065791f, 0.05286352f, 0.15528014f, -0.13216707f, 0.08324843f, 0.05997577f, 0.18969087f, 0.35096031f, 
    0.07440998f, 0.06829701f, 0.10955238f, 0.01640384f, 0.05039496f, 0.01703407f, -0.10855039f, 0.11967289f, 
    0.05028057f, 0.10742389f, 0.14690664f, 0.28264859f, 0.19802240f, 0.03822964f, -0.20614225f, -0.10392598f, 
    -0.05349688f, 0.23954009f, -0.10742010f, -0.18884525f, -0.04302906f, 0.06999857f, 0.14894417f, 0.09701054f, 
    0.40942693f, 0.20394346f, 0.25771046f, 0.28446636f, -0.15844180f, 0.12508897f, -0.03472947f, -0.07082712f, 
    0.21411254f, 0.09980287f, 0.04064531f, 0.32275939f, 0.26149195f, -0.13680068f, 0.08839010f, 0.37398440f, 
    0.08961946f, 0.10967947f, -0.00201298f, -0.12634970f, 0.08853302f, 0.17327845f, 0.02697940f, 0.21862364f, 
    -0.03864641f, 0.09709520f, -0.07936459f, 0.11475447f, -0.04966458f, -0.03912159f, 0.03970050f, 0.22007586f, 
    -0.00473056f, 0.06947538f, 0.01061416f, 0.35720918f, -0.61749095f, 0.13002126f, -0.49028307f, 0.00778085f, 
    -0.21821675f, -0.11383627f, -0.01547123f, 0.10202739f, -0.09947734f, -0.08736794f, -0.08478366f, 0.09866489f, 
    0.17242444f, 0.21398816f, 0.05338420f, 0.23859186f, 0.00305663f, -0.00537091f, 0.12681869f, 0.26080230f, 
    0.00486390f, 0.04043039f, 0.07808669f, 0.20556949f, 0.00612222f, -0.16346061f, 0.03900431f, -0.18736765f, 
    -0.05983000f, -0.01895300f, -0.17510708f, -0.16953428f, 0.15991433f, -0.11453174f, -0.01212518f, -0.03858102f, 
    0.04218284f, 0.03680937f, -0.10710778f, 0.02799524f, -0.07035822f, -0.12956460f, -0.02844087f, 0.03546812f, 
    0.10493654f, -0.11166963f, -0.07424327f, -0.11334568f, -0.15417142f, 0.00262299f, -0.01128799f, -0.00563172f, 
    -0.28869084f, -0.12335479f, -0.05598979f, -0.03223005f, 0.05280495f, -0.00451885f, 0.10517836f, 0.02732713f, 
    -0.06722075f, -0.27475640f, -0.06066378f, 0.08392319f, -0.13084902f, 0.03602716f, 0.04071005f, -0.16176197f, 
    0.07736602f, -0.16249317f, -0.02370094f, 0.03346147f, -0.30955073f, -0.09914118f, -0.12183895f, -0.13219252f, 
    0.13411376f, 0.00342282f, -0.06793455f, -0.01572532f, 0.04486106f, 0.16687000f, 0.17792451f, 0.13577089f, 
    -0.06415842f, 0.04748415f, -0.25561735f, 0.21020520f, -0.00092978f, 0.01775505f, -0.01824485f, -0.18266647f, 
    0.08429790f, 0.12093619f, -0.02859455f, 0.07503775f, -0.02480429f, 0.08971555f, -0.24961774f, 0.04513169f, 
    0.19395085f, -0.08801865f, -0.19784415f, 0.11185393f, 0.13297044f, 0.06155181f, 0.18429525f, -0.00207623f, 
    0.08462811f, 0.17499000f, 0.07811494f, 0.00532750f, 0.20164108f, -0.03968593f, 0.08421636f, 0.11046447f, 
    0.07537641f, 0.12617566f, -0.07651155f, 0.13685510f, 0.01768886f, 0.13899684f, -0.13952580f, -0.15346502f, 
    0.03152104f, 0.03101908f, -0.00153297f, 0.06220796f, 0.22885595f, 0.28547263f, 0.15189312f, 0.05875629f, 
    -0.26157376f, 0.17042902f, -0.17604776f, 0.06873347f, -0.39170042f, -0.06539561f, -0.11976022f, -0.10811752f, 
    0.16928864f, 0.11691852f, 0.17365712f, 0.17012043f, -0.07713049f, -0.07991038f, 0.08771833f, 0.12761596f, 
    0.10528477f, 0.17096481f, 0.13246398f, 0.13938309f, 0.06225879f, 0.11543784f, 0.03582416f, 0.06910278f, 
    0.27869183f, 0.17772578f, 0.35764420f, 0.06534266f, -0.03143129f, 0.06244109f, -0.00434532f, -0.11168666f, 
    0.15618247f, -0.09686091f, 0.14449118f, -0.02621537f, 0.01752668f, 0.11867555f, 0.22598198f, 0.20487359f, 
    0.06360133f, 0.12586594f, 0.12296498f, 0.23509470f, 0.17569363f, -0.00811187f, 0.00709234f, 0.02125823f, 
    0.04879933f, 0.02847316f, 0.20755534f, -0.12955849f, -0.01672538f, -0.10011559f, -0.09160532f, -0.00702161f, 
    -0.03888062f, -0.13933575f, -0.22542153f, -0.12746836f, -0.16351369f, 0.24118003f, 0.41021010f, -0.01475610f, 
    0.03098457f, -0.02363672f, -0.01988867f, -0.02846535f, 0.13361247f, 0.02281910f, -0.11743958f, -0.10098661f, 
    0.06810557f, -0.11941174f, -0.12792438f, -0.05362614f, -0.03510933f, -0.19212723f, -0.00505031f, -0.01975283f, 
    0.06690261f, -0.03355599f, 0.06007273f, 0.04232366f, 0.01093179f, 0.10362431f, 0.26798990f, 0.29410964f, 
    0.06314237f, 0.13961819f, 0.08512827f, 0.20898356f, -0.00392877f, 0.13244584f, 0.07810432f, 0.17311564f, 
    -0.04106119f, -0.07505973f, 0.10909496f, -0.20050751f, -0.21323654f, -0.00924855f, -0.18836582f, -0.19509421f, 
    0.12547600f, 0.04422355f, 0.10416462f, 0.12261496f, 0.01585401f, 0.07906572f, 0.25560966f, 0.13832958f, 
    -0.08058915f, -0.03190734f, 0.07598454f, 0.02914772f, 0.03723548f, 0.11529994f, 0.04206335f, -0.02292154f, 
    -0.03489495f, 0.12858501f, 0.00023087f, -0.12781189f, 0.01364362f, -0.05068466f, -0.12507047f, 0.11787546f, 
    -0.04061399f, 0.12646040f, 0.15327054f, -0.11159977f, -0.12910023f, 0.07446022f, 0.09407398f, 0.25698027f, 
    -0.01160963f, 0.00954816f, -0.12138651f, -0.16322601f, -0.06358267f, 0.11668675f, -0.22080697f, -0.12314291f, 
    0.14004008f, -0.01769327f, 0.12819779f, 0.21276973f, 0.02378105f, 0.10071599f, 0.09003660f, 0.05466287f, 
    0.12637399f, -0.07872650f, -0.03909535f, -0.06006217f, 0.37898877f, 0.39547822f, 0.07109765f, 0.18007375f, 
    0.00938901f, -0.23474161f, -0.11654010f, -0.11628345f, 0.03855579f, 0.03377129f, 0.07956620f, 0.00011985f, 
    0.10103767f, 0.15196043f, 0.03835481f, -0.07806354f, -0.05053807f, 0.07740828f, -0.00398688f, -0.10692196f, 
    -0.01038170f, -0.17752528f, -0.16617025f, -0.17606087f, -0.03574370f, 0.06693400f, -0.17905064f, 0.06088190f, 
    -0.11584564f, 0.16176300f, -0.01430600f, -0.02327467f, -0.00199514f, -0.13091463f, -0.19819003f, -0.16209835f, 
    0.41969588f, -0.05469065f, -0.21607609f, 0.06373817f, -0.11862560f, -0.23826924f, 0.07245801f, -0.02209264f, 
    0.15428995f, -0.16103800f, -0.01651381f, -0.16401403f, 0.25699261f, -0.28556001f, 0.02847288f, 0.01167309f, 
    -0.01985876f, -0.32976407f, 0.02418712f, -0.04001677f, -0.04292325f, 0.16038744f, -0.21927379f, 0.02498854f, 
    0.05076982f, 0.02892943f, 0.05428628f, 0.10826911f, 0.04706721f, -0.29937646f, -0.01825733f, 0.12060840f, 
    -0.11823790f, 0.08982001f, -0.04806407f, -0.19743557f, 0.15413456f, -0.08316071f, -0.13763742f, 0.06054823f, 
    0.11165681f, -0.14922324f, -0.04878197f, -0.11838263f, 0.05338065f, -0.12935117f, -0.10508001f, -0.10793661f, 
    -0.09987344f, 0.12729864f, 0.16521731f, 0.13039586f, 0.14635549f, 0.03737095f, 0.01372956f, 0.03596924f, 
    -0.07757829f, 0.13723466f, -0.00910576f, 0.09828801f, -0.25712249f, -0.22814319f, -0.39638838f, 0.63883752f, 
    0.01720244f, -0.16641985f, 0.04334974f, -0.04540555f, 0.23674312f, 0.09900909f, 0.21876602f, 0.16155495f, 
    -0.19784296f, -0.09009197f, -0.11130811f, 0.45170254f, 0.15449613f, 0.05144703f, -0.05303211f, 0.16237605f, 
    0.00799290f, -0.06461965f, 0.21786977f, 0.29167077f, 0.12804657f, 0.07333715f, 0.12732445f, -0.07640102f, 
    -0.01495765f, -0.05024969f, -0.01067722f, -0.01044024f, 0.31288499f, 0.13162504f, 0.02414442f, 0.04678166f, 
    0.28517967f, 0.19955371f, 0.59805954f, -0.22162642f, -0.10370326f, 0.03690130f, 0.00876635f, 0.07608934f, 
    0.06196496f, 0.00355415f, 0.08364810f, -0.00047623f, 0.40188965f, 0.32168207f, 0.36298108f, 0.09635330f, 
    0.01170193f, -0.10327949f, -0.12878323f, -0.08037715f, -0.02697798f, 0.01161954f, -0.01154787f, -0.11580873f, 
    0.56121379f, 0.29154500f, 0.30629665f, -0.11105032f, 0.12518233f, -0.10236225f, 0.03779209f, 0.09881698f, 
    0.07328153f, 0.12578514f, -0.09530208f, -0.08597622f, 0.01445866f, 0.01213906f, -0.14863181f, -0.16891411f, 
    0.06230611f, -0.02106279f, -0.00195854f, -0.07379493f, 0.14428668f, 0.10597611f, 0.08082353f, -0.06258883f, 
    0.27392578f, -0.11543769f, 0.01813132f, 0.02747032f, 0.00973303f, -0.08252505f, -0.09416054f, -0.09203079f, 
    -0.13477661f, -0.04382366f, -0.17406416f, -0.03954717f, 0.03461675f, -0.03779477f, 0.10966508f, -0.15165523f, 
    0.03983633f, -0.00871293f, -0.05136775f, 0.03934905f, 0.00994635f, 0.04458082f, 0.15577783f, 0.20768508f, 
    -0.07905693f, 0.07516034f, 0.11920319f, -0.16250363f, 0.23658638f, -0.17466722f, 0.07474122f, -0.01832955f, 
    -0.08464428f, 0.00635006f, -0.22480506f, 0.18841432f, -0.09002593f, -0.33770770f, -0.13409132f, 0.24124886f, 
    0.07539156f, -0.03912823f, 0.02592102f, -0.06616033f, 0.03508950f, 0.11092829f, -0.00756861f, 0.17337669f, 
    0.42384753f, 0.32213432f, 0.34653267f, 0.01795134f, -0.14816555f, -0.22899774f, -0.02093755f, -0.12404230f, 
    -0.09220694f, 0.03798815f, -0.01269150f, -0.10985483f, -0.17736378f, -0.14164113f, 0.08730971f, 0.01577680f, 
    0.17925780f, 0.00033677f, 0.11758802f, 0.11255009f, 0.00685557f, -0.11395826f, -0.04526382f, -0.17372923f, 
    0.05224199f, 0.05571866f, 0.36097261f, -0.21300572f, -0.03117274f, 0.08603664f, 0.12370940f, 0.11167338f, 
    -0.14995989f, 0.32482001f, 0.15071583f, 0.01489746f, -0.04956573f, 0.06751608f, 0.33361986f, -0.02616668f, 
    0.01482566f, -0.06730953f, 0.03952416f, 0.33574170f, 0.01259254f, -0.02452377f, 0.05713611f, 0.09520598f, 
    -0.08301289f, 0.00346532f, 0.31310049f, 0.05101048f, -0.03287294f, 0.03105565f, 0.01172150f, 0.20093977f, 
    0.13875431f, 0.01005677f, 0.09343384f, 0.08512855f, -0.08715146f, -0.05875202f, 0.45550057f, 0.38137752f, 
    0.07175871f, -0.13268127f, -0.05541739f, 0.07201823f, -0.13565391f, -0.09335572f, -0.01531078f, -0.15165319f, 
    0.48858798f, 0.36216989f, -0.18504460f, -0.14063361f, -0.31400016f, -0.24469084f, -0.07554878f, -0.04939982f, 
    -0.04108059f, 0.04633777f, -0.08610760f, 0.09264757f, -0.15590209f, -0.07524628f, 0.04148226f, 0.29093856f, 
    -0.12322186f, -0.05135246f, -0.07424489f, 0.17869830f, -0.02440884f, -0.00731985f, -0.07143688f, -0.03426687f, 
    -0.02067046f, -0.07682556f, -0.09472430f, 0.10318760f, -0.17505930f, 0.00977813f, -0.11990584f, -0.12773423f, 
    0.12495259f, 0.02870325f, 0.05531695f, -0.07660628f, -0.09038658f, 0.15376405f, 0.00672868f, -0.20014836f, 
    0.00925698f, -0.03966544f, 0.03754644f, 0.02417555f, 0.11698797f, 0.04169385f, 0.17871796f, 0.00178945f, 
    0.10880904f, -0.06170342f, 0.08108048f, 0.20123379f, 0.06496935f, -0.03372186f, 0.00947509f, 0.05650489f, 
    0.20367520f, 0.12962332f, -0.09895207f, 0.14747176f, -0.14479917f, 0.05548631f, 0.26455113f, 0.14137064f, 
    0.03617953f, -0.19161955f, 0.05866653f, 0.05379007f, 0.01530001f, 0.03799377f, 0.05500776f, 0.07558094f, 
    -0.21954951f, -0.27126580f, 0.20877969f, 0.22355047f, -0.06184423f, 0.04038063f, 0.15375721f, 0.25672868f, 
    0.05196880f, 0.12029354f, 0.15060322f, 0.06859273f, -0.19561276f, 0.30520573f, -0.27550316f, -0.26102972f, 
    0.01068049f, -0.02515471f, -0.03133357f, -0.14958496f, -0.09889425f, 0.14472198f, 0.13633962f, 0.04362850f, 
    0.23777406f, 0.09351831f, 0.03248002f, 0.05933920f, 0.01194118f, -0.05983285f, -0.08969923f, 0.18819275f, 
    -0.04024600f, 0.03291574f, -0.04289502f, 0.09677033f, 0.01868470f, -0.04585816f, -0.13843971f, 0.02518107f, 
    0.03914947f, -0.23434465f, -0.08236942f, 0.06955447f, -0.05027957f, 0.05499618f, -0.09434748f, -0.02108330f, 
    0.29832846f, -0.04495842f, 0.24945076f, -0.09233029f, 0.15405878f, -0.16088888f, 0.15936555f, 0.03208049f, 
    0.07814347f, 0.04979243f, 0.13908988f, -0.07427985f, -0.02403993f, 0.02691218f, -0.09783909f, -0.09289131f, 
    0.05513725f, 0.02637300f, -0.14804243f, -0.00264089f, 0.14520545f, 0.15537636f, -0.19325687f, 0.04137593f, 
    -0.09493162f, 0.06906156f, -0.04631260f, -0.05820712f, -0.02061142f, -0.20172711f, -0.09301527f, -0.02575894f, 
    -0.04876621f, -0.11103362f, 0.08710895f, -0.06008421f, 0.01717744f, 0.05390209f, 0.12419839f, 0.18740052f, 
    0.01790790f, -0.27592596f, -0.05337634f, -0.13239025f, 0.13188386f, -0.08700442f, 0.01747580f, 0.30109993f, 
    0.03926587f, -0.03327652f, 0.02737504f, 0.00234429f, -0.05294879f, -0.05190850f, 0.03362584f, 0.01804298f, 
    0.03187238f, -0.04428843f, -0.05620638f, -0.00918549f, 0.03201763f, 0.02062527f, -0.05617565f, -0.02082376f, 
    -0.01576158f, 0.04715500f, 0.02804917f, -0.02418006f, 0.02567845f, 0.02415188f, 0.02450122f, 0.00604754f, 
    -0.03056574f, 0.02035791f, -0.03227684f, -0.04567190f, 0.02845267f, 0.00265153f, -0.00853297f, -0.01005500f, 
    -0.02239572f, 0.04974971f, -0.04381170f, 0.03743630f, -0.02925635f, 0.04161883f, 0.03659910f, 0.01590900f, 
    -0.01152184f, 0.04190609f, -0.00713183f, -0.05303277f, 0.01945830f, -0.02846639f, -0.01519526f, 0.04222385f, 
    -0.01783313f, 0.03899644f, -0.05011883f, -0.03485215f, 0.03142002f, 0.03449930f, 0.02320687f, 0.00298059f, 
    -0.01660646f, 0.00651836f, -0.01570338f, -0.02371177f, 0.01035954f, -0.04191656f, -0.04347704f, -0.03662681f, 
    -0.05623932f, 0.00398878f, -0.04918742f, 0.00289014f, 0.01626414f, -0.04713600f, -0.00051411f, -0.03117731f, 
    -0.04154038f, -0.03248898f, -0.03798113f, -0.05121505f, -0.05217597f, -0.05681601f, 0.00733927f, -0.01701375f, 
    -0.03490092f, -0.00818915f, -0.04905386f, -0.05172459f, -0.05183353f, -0.04483508f, 0.04200579f, 0.02846655f, 
    0.01700284f, -0.04402808f, 0.00130889f, -0.01602067f, -0.04326605f, 0.04111928f, -0.05299589f, 0.04419824f, 
    0.02726513f, -0.03404194f, 0.03358113f, 0.02777465f, -0.03790451f, -0.02231508f, 0.00856073f, -0.03984521f, 
    -0.04527996f, -0.04842674f, -0.00111035f, -0.03791417f, 0.03396207f, -0.05559326f, -0.05155018f, 0.02987161f, 
    -0.04171021f, -0.00058168f, 0.01366893f, 0.02308227f, -0.02956784f, -0.00102960f, -0.04437867f, 0.04059766f, 
    -0.01576326f, 0.02652036f, -0.03556807f, 0.03246491f, -0.02850888f, -0.02718663f, -0.00284016f, 0.01353488f, 
    0.01980270f, 0.02901075f, -0.01345925f, 0.00429695f, 0.03279048f, 0.01094861f, -0.05152283f, -0.03241264f, 
    -0.01249035f, -0.01871884f, 0.01042995f, 0.03153834f, 0.00625265f, -0.04962886f, 0.02129129f, 0.01836519f, 
    0.01035349f, -0.04481279f, 0.03392149f, 0.02494622f, -0.02939585f, -0.00368555f, -0.05322381f, 0.00474483f, 
    0.00606912f, -0.00580700f, -0.01550894f, 0.03382960f, -0.03863729f, 0.01746282f, -0.05219019f, -0.03464388f, 
    0.02576051f, -0.00095205f, -0.00794257f, 0.00873202f, -0.00591793f, -0.01824586f, -0.01967882f, -0.00887341f, 
    -0.01875716f, -0.04138821f, -0.01245596f, -0.03890505f, -0.00658514f, 0.00914656f, -0.04129729f, -0.03227947f, 
    -0.00584538f, -0.00482398f, 0.03028535f, 0.03868586f, 0.04482026f, -0.03187178f, -0.04667278f, -0.03845754f, 
    0.00967693f, 0.04057406f, -0.00110312f, 0.03286581f, -0.00058043f, -0.04966854f, -0.00727004f, 0.03582941f, 
    -0.00652731f, -0.00959488f, 0.00921909f, -0.04219067f, -0.05030459f, -0.00306034f, -0.01378149f, -0.02132050f, 
    0.00158016f, 0.02491315f, -0.04981815f, -0.04933554f, -0.01901590f, 0.01309653f, 0.03241939f, -0.00347905f, 
    0.01631164f, 0.03250838f, -0.03481019f, 0.01909477f, -0.04615913f, -0.04623982f, -0.01701406f, 0.02722517f, 
    -0.03190224f, -0.04914417f, -0.03029047f, -0.03311298f, 0.01175649f, -0.01707439f, -0.03791461f, 0.02811393f, 
    -0.00610353f, 0.03783164f, 0.02155657f, -0.02119260f, -0.00593177f, -0.00583876f, 0.00385920f, -0.03165787f, 
    0.01491062f, 0.00253771f, -0.04169117f, 0.00289685f, 0.03054446f, -0.02297283f, 0.01776715f, 0.02053366f, 
    0.01150177f, -0.01260401f, -0.00838397f, 0.04968991f, -0.00711274f, -0.01998837f, -0.04006587f, 0.02416228f, 
    -0.02339057f, -0.03990433f, -0.01935156f, 0.04288728f, 0.00568392f, 0.00956523f, -0.04871849f, -0.04692388f, 
    -0.03866649f, 0.04058303f, -0.02667876f, -0.03624604f, -0.05241664f, -0.02738741f, 0.03331147f, -0.01439451f, 
    -0.03807157f, -0.01463666f, -0.00155497f, -0.02434092f, -0.03136847f, -0.05302610f, 0.01330515f, 0.01060673f, 
    0.04067683f, -0.02961780f, 0.01810573f, 0.02894929f, -0.01913042f, -0.03216924f, -0.03614854f, -0.05702584f, 
    0.03823801f, -0.03403951f, -0.02282051f, 0.04503260f, 0.01366426f, -0.00142152f, -0.01108940f, -0.04992921f, 
    0.03299787f, -0.02541214f, -0.05606296f, -0.05069098f, -0.05428712f, 0.02705390f, 0.04474673f, 0.01931765f, 
    -0.00751544f, 0.00700898f, -0.04403032f, 0.02206574f, 0.04525805f, -0.02048203f, 0.03198569f, 0.00589132f, 
    0.03335401f, -0.03117381f, -0.04000086f, -0.01985105f, -0.01665070f, 0.03837495f, 0.03423977f, 0.02498543f, 
    0.01756265f, 0.03827314f, 0.03889603f, -0.00166046f, 0.01631415f, -0.00699716f, 0.01177144f, -0.00641578f, 
    0.01984870f, -0.02530208f, -0.04021274f, -0.02686433f, 0.00393428f, -0.04124003f, -0.04549879f, -0.00941200f, 
    0.03468911f, 0.03508418f, -0.01210175f, -0.04502256f, 0.01338963f, 0.02945505f, -0.03473828f, 0.00501088f, 
    -0.03674392f, -0.04928183f, -0.01859979f, 0.04132594f, -0.05398886f, 0.03321592f, -0.04450736f, -0.00709599f, 
    -0.04706001f, 0.01100522f, -0.03872702f, -0.03769086f, -0.03613127f, -0.04373460f, 0.02681429f, 0.01752221f, 
    -0.05476489f, -0.00922278f, -0.00614175f, 0.04431170f, 0.00286401f, 0.04481148f, 0.01162020f, -0.03122208f, 
    -0.03315436f, -0.04773079f, -0.00025820f, 0.03396359f, 0.04107415f, -0.03422904f, 0.03810209f, 0.04217891f, 
    -0.05331993f, 0.01947716f, 0.00980271f, -0.03332208f, -0.05645483f, -0.02583522f, 0.03965608f, -0.00786001f, 
    0.01374669f, -0.01629380f, -0.01410678f, -0.01151229f, -0.04375705f, -0.03484539f, 0.02890054f, 0.04535185f, 
    0.08380756f, -0.05369648f, 0.21762168f, -0.04217256f, 0.03068289f, 0.00887849f, -0.06571204f, -0.10674041f, 
    -0.01348943f, -0.00855668f, 0.01493233f, 0.13233259f, 0.37461367f, -0.00886721f, 0.31132948f, -0.11614959f, 
    0.15089779f, -0.10692525f, -0.06818213f, -0.08058321f, -0.23829253f, -0.32227966f, -0.02321321f, 0.32779959f, 
    -0.26522630f, 0.48152611f, 0.08720226f, 0.76017892f, 0.02365386f, 0.26577142f, 0.17071089f, 0.17464446f, 
    -0.07812565f, -0.07042781f, -0.27899680f, 0.05720615f, 0.22916658f, 0.04208787f, 0.27811593f, 0.20201004f, 
    0.00273407f, 0.02010732f, -0.07010773f, -0.02766171f, 0.51244235f, 0.24606538f, -0.09289333f, 0.28679338f, 
    0.01031390f, 0.08528033f, 0.17036329f, 0.07440802f, 0.00744341f, 0.00422977f, 0.01369210f, -0.02156579f, 
    0.20639992f, 0.08687894f, -0.15627563f, -0.11801820f, 0.15848370f, 0.20348066f, 0.23719764f, 0.26360288f, 
    0.01845429f, -0.03005740f, -0.05003151f, 0.00596901f, 0.13627431f, 0.06097003f, 0.12939709f, 0.15534757f, 
    0.02691402f, 0.21736780f, -0.10458445f, 0.37673542f, 0.03572844f, 0.00437398f, -0.06973147f, -0.01112628f, 
    0.16441303f, 0.05907547f, 0.22081913f, 0.05738299f, 0.04283877f, 0.02289926f, 0.01686131f, 0.02250710f, 
    0.12384281f, 0.05781560f, 0.00857519f, -0.03568070f, -0.06404814f, 0.00477452f, -0.01483017f, -0.00437847f, 
    0.00206209f, 0.25312790f, 0.03397749f, 0.16291413f, -0.10661483f, 0.02781158f, 0.07171616f, -0.07767958f, 
    -0.08410635f, -0.03878365f, 0.06471017f, -0.04879144f, 0.17398870f, -0.00052241f, 0.04528965f, 0.01992063f, 
    -0.03549149f, 0.07495283f, -0.17055915f, 0.05493525f, 0.06469955f, -0.16392636f, 0.16021794f, -0.11635669f, 
    -0.62615305f, 0.13899778f, 0.31297144f, -0.08740333f, -0.03740595f, -0.00135352f, 0.09657617f, -0.26168379f, 
    -0.07338725f, 0.00966894f, -0.01499099f, 0.01045772f, 0.39354214f, -0.11786255f, -0.02739658f, -0.01749295f, 
    -0.06907041f, 0.01306150f, -0.03951945f, -0.08696876f, -0.06394560f, 0.10927323f, -0.09815206f, -0.21544428f, 
    0.17850310f, 0.23153685f, 0.10077439f, 0.18588433f, -0.05107825f, -0.01349298f, 0.07114973f, -0.10603268f, 
    0.04825214f, -0.01662443f, 0.11440693f, 0.00451046f, 0.02927359f, -0.05013468f, -0.14649566f, -0.06042046f, 
    0.18995363f, 0.04542003f, 0.34245881f, 0.23015428f, -0.08329828f, 0.01413783f, 0.07160825f, 0.02046548f, 
    -0.03608405f, -0.37669224f, -0.10676820f, -0.43381217f, 0.16850068f, -0.07783114f, 0.10221209f, -0.06803682f, 
    0.11032570f, 0.18566075f, 0.02020649f, 0.07790460f, -0.37290841f, -0.32934782f, -0.60821211f, -0.53090280f, 
    0.04948506f, 0.25028503f, 0.04587473f, 0.09007417f, -0.03023205f, -0.05749277f, -0.12690966f, -0.04399075f, 
    0.06662673f, -0.06196212f, 0.14388816f, -0.29084885f, -0.03356284f, -0.12983425f, -0.18244846f, 0.04644440f, 
    -0.07945915f, -0.24123596f, -0.23375951f, -0.08218195f, 0.58928537f, -0.84306532f, -0.07372499f, -0.27407780f, 
    -0.24438991f, -0.03617924f, -0.06623910f, -0.07238936f, 0.00881694f, 0.08987668f, -0.08366664f, -0.30613765f, 
    0.33200428f, 0.40452981f, -0.17866392f, 0.22720502f, -0.09732115f, -0.14207332f, -0.07063658f, -0.03297566f, 
    -0.01969371f, 0.00290040f, 0.03046129f, 0.03082488f, -0.17632587f, -0.06584293f, -0.26371872f, -0.18539250f, 
    0.05472390f, 0.37086314f, 0.09355545f, 0.31257015f, -0.07585974f, -0.01190633f, 0.11207364f, 0.08043481f, 
    0.13672154f, 0.11635228f, 0.18664262f, 0.13741471f, -0.06045549f, 0.07206444f, -0.04262882f, 0.02303872f, 
    0.14864390f, 0.02989788f, -0.02966810f, 0.08011218f, 0.34856337f, -0.06332181f, -0.09016276f, 0.14993495f, 
    -0.20148255f, -0.11813963f, 0.12178957f, 0.03500460f, -0.04582486f, 0.06101931f, 0.03435244f, -0.12261155f, 
    0.07121023f, -0.01558262f, 0.17510010f, 0.02198568f, 0.06515875f, -0.01085160f, -0.02261968f, -0.05170107f, 
    0.07151934f, 0.11392789f, 0.20421290f, -0.03981997f, -0.32480007f, 0.18510494f, -0.91961604f, -0.51662058f, 
    0.03023195f, -0.07808992f, -0.06281574f, 0.23403406f, -0.14062855f, 0.01779353f, 0.02718622f, -0.14915261f, 
    -0.03063743f, -0.34792525f, 0.07444260f, -0.08768661f, 0.04105207f, 0.08229198f, 0.16232453f, 0.25002408f, 
    0.14622353f, -0.06067868f, 0.12394939f, -0.03796447f, 0.23076446f, -0.37672335f, -0.63682491f, -0.56070071f, 
    -0.07610498f, 0.00547024f, -0.21546985f, 0.03390676f, 0.17567085f, -0.06983257f, 0.22310196f, -0.00428367f, 
    0.17139302f, -0.02168330f, -0.20513985f, 0.04638832f, 0.01762518f, -0.06608925f, -0.00032349f, 0.10894141f, 
    -0.08568191f, -0.09416059f, 0.06654344f, -0.19946119f, -0.11542569f, 0.23002681f, -0.17264369f, 0.26852360f, 
    0.10469986f, 0.01688727f, 0.20940647f, 0.18352135f, -0.04774348f, -0.00846370f, -0.00566100f, -0.09180931f, 
    -0.07613979f, 0.25251138f, 0.11874119f, 0.32461509f, 0.02526941f, -0.04703226f, -0.02256559f, -0.00414307f, 
    0.08420867f, 0.08513623f, 0.17316814f, 0.04381380f, 0.29030135f, 0.17034677f, 0.04885340f, 0.17379995f, 
    -0.06122007f, 0.02214543f, -0.06695496f, 0.01058835f, 0.16553590f, 0.12211747f, -0.08420098f, -0.14768158f, 
    0.00310364f, -0.36132213f, -0.19450776f, -0.32282379f, -0.13970889f, 0.03522792f, -0.04483133f, 0.09221919f, 
    0.14019625f, 0.08482956f, -0.03469460f, -0.12448297f, -0.19288088f, -0.44949138f, -0.15172802f, -0.18745215f, 
    0.00976145f, 0.02991094f, -0.11141556f, 0.09074142f, -0.03109263f, -0.26052168f, -0.31627759f, 0.18222539f, 
    -0.05235084f, 0.00206164f, -0.00664602f, -0.04133188f, -0.04224535f, 0.02886272f, 0.04082093f, 0.03640239f, 
    -0.01223406f, 0.02380314f, 0.02651689f, -0.00920313f, -0.06057734f, 0.00454627f, -0.01257514f, 0.03882812f, 
    -0.02443977f, -0.00610436f, 0.02435669f, -0.05034944f, 0.02760882f, -0.05984538f, -0.02785011f, 0.02153400f, 
    0.00999847f, -0.04920590f, 0.00548021f, 0.04116496f, 0.00351111f, 0.02044727f, -0.05090947f, 0.01772489f, 
    -0.05165907f, 0.01185425f, -0.00120171f, 0.00778580f, -0.04385293f, -0.03443090f, -0.04230122f, -0.03046876f, 
    -0.00234249f, 0.01221712f, 0.04150962f, -0.03028342f, -0.04387365f, 0.02349243f, -0.05773699f, 0.01458803f, 
    0.02638179f, -0.02100707f, -0.02185657f, -0.05623352f, 0.01506008f, -0.05090694f, -0.01296927f, -0.05781933f, 
    -0.04500490f, -0.04938510f, 0.01091882f, 0.01158096f, 0.01651087f, 0.01708460f, -0.02520940f, -0.01671001f, 
    0.00205851f, -0.04909128f, -0.02501420f, 0.02193014f, -0.05367025f, -0.04869144f, 0.00567195f, -0.05596434f, 
    0.03434166f, 0.02220899f, 0.01364317f, -0.00507250f, -0.01440885f, -0.00653096f, -0.04592140f, -0.03546519f, 
    -0.01715447f, 0.00039079f, 0.00105440f, 0.04180766f, 0.00188153f, -0.01574659f, -0.02897126f, -0.01987194f, 
    0.04118440f, -0.04856487f, 0.00495642f, 0.01179569f, -0.05038784f, 0.01522456f, -0.01432886f, 0.00815406f, 
    0.00757047f, -0.04227349f, -0.00112056f, 0.01149030f, -0.00636360f, -0.04315187f, -0.04238611f, 0.02114683f, 
    -0.00515111f, 0.00269297f, -0.04353681f, 0.02620106f, -0.05617262f, -0.01987707f, -0.05278146f, 0.00197032f, 
    -0.04049818f, 0.00206938f, -0.03422012f, 0.01573049f, -0.03567962f, -0.03000773f, 0.01600596f, 0.03392218f, 
    0.02884757f, -0.03173316f, 0.00972023f, -0.01559288f, -0.05654063f, -0.01067246f, -0.03012719f, 0.02275896f, 
    -0.05094162f, 0.02128040f, 0.00277105f, 0.02866160f, -0.02487347f, -0.00407949f, -0.03930137f, -0.00789782f, 
    0.02140871f, 0.00187178f, 0.02175817f, 0.04418761f, 0.00835182f, -0.02857901f, -0.00513411f, -0.04055302f, 
    -0.00418009f, -0.02490104f, -0.02404631f, -0.00802545f, 0.03877335f, 0.00578445f, -0.00205508f, 0.00881279f, 
    -0.05417204f, -0.02965281f, -0.04463536f, -0.04906594f, -0.03479430f, 0.00748737f, -0.04714312f, -0.04218357f, 
    -0.03908726f, -0.00619068f, 0.01581620f, -0.04654027f, -0.04579474f, 0.00508535f, -0.05865607f, -0.00499681f, 
    0.02143526f, 0.01128512f, -0.03777959f, 0.03628583f, 0.01315785f, -0.02306948f, 0.01546462f, -0.05273550f, 
    -0.02025021f, -0.04819020f, 0.04228985f, -0.00510419f, -0.05738824f, -0.04351119f, -0.03118534f, -0.01684122f, 
    0.01875808f, -0.05187835f, 0.00954506f, -0.05708320f, -0.02298434f, 0.03855002f, -0.03683682f, 0.03782983f, 
    0.02507793f, -0.04073073f, -0.00375250f, 0.01047593f, 0.00174621f, -0.05736510f, -0.05032215f, -0.01121927f, 
    -0.00155733f, 0.01507694f, -0.04639043f, 0.01886667f, 0.00064668f, 0.01426330f, -0.04941422f, -0.02048470f, 
    -0.05327182f, -0.00529524f, -0.00228864f, -0.03942666f, 0.03648402f, -0.02068346f, -0.00623519f, 0.02716956f, 
    0.03513681f, -0.03445595f, -0.02982818f, -0.02936229f, 0.01474856f, -0.03286374f, 0.00271038f, -0.05363661f, 
    0.04805326f, -0.02529129f, -0.02859867f, 0.03747305f, 0.03218886f, -0.04498850f, -0.01203783f, 0.01840019f, 
    -0.03916761f, 0.00088960f, -0.02885065f, -0.01647061f, -0.05027442f, -0.00119919f, 0.02404379f, -0.02082457f, 
    -0.01156845f, -0.02008242f, 0.02250011f, 0.01013843f, 0.03092098f, 0.00925574f, 0.01563343f, -0.05592321f, 
    0.00693870f, -0.04999100f, -0.04482781f, 0.02498377f, -0.05828398f, -0.01815843f, 0.00650024f, 0.02151911f, 
    -0.02236659f, 0.01482483f, 0.03432517f, -0.02559259f, 0.02351667f, 0.02707286f, 0.00137244f, -0.01555778f, 
    0.00341969f, 0.01636895f, -0.05476569f, -0.00168441f, -0.01941459f, -0.03840794f, 0.01960558f, 0.01006860f, 
    -0.00781256f, -0.02471906f, -0.04787442f, 0.00065195f, -0.02321703f, 0.03934674f, -0.01614918f, 0.03581943f, 
    0.02408699f, 0.00185617f, 0.03595385f, -0.02023305f, 0.01448006f, 0.00607405f, 0.03530995f, 0.02411142f, 
    0.04556736f, 0.03532632f, -0.05031753f, 0.00377435f, 0.01952812f, -0.04498872f, 0.03169715f, -0.03615370f, 
    0.01544784f, -0.01612935f, -0.05068076f, -0.05546904f, -0.03151019f, -0.01788775f, 0.00799845f, 0.04209936f, 
    0.00036804f, 0.04069630f, -0.01267105f, -0.05464533f, 0.04439802f, -0.04578913f, -0.01143534f, -0.03213336f, 
    -0.03406030f, 0.02812798f, -0.00585373f, -0.04428393f, 0.01602692f, -0.01888828f, 0.04424021f, 0.02396370f, 
    0.00781090f, 0.02376708f, -0.03464578f, 0.00875262f, 0.03001349f, 0.02956060f, -0.04392974f, -0.01329015f, 
    0.01262284f, -0.01391221f, -0.04710000f, 0.02786352f, -0.03711163f, 0.00242781f, 0.02547187f, 0.03312565f, 
    -0.03011290f, -0.01433810f, -0.00092189f, -0.05588908f, -0.00530219f, 0.00638155f, -0.02139774f, -0.03461570f, 
    -0.01559570f, -0.03541454f, -0.02522556f, 0.02774575f, 0.00430046f, -0.02457380f, -0.03854276f, -0.02791235f, 
    -0.02844635f, -0.03626038f, -0.03725487f, -0.05241503f, -0.02321769f, -0.02751589f, -0.04396811f, -0.02312574f, 
    0.02728196f, 0.00755765f, -0.03578307f, -0.05366490f, -0.03804891f, 0.00101108f, 0.00121826f, -0.00272974f, 
    -0.02422877f, -0.03181109f, -0.04092078f, -0.01564294f, 0.00642403f, -0.02875793f, -0.05004257f, -0.02694025f, 
    0.04068680f, 0.02438138f, -0.05572519f, -0.05337028f, -0.00929723f, 0.02470297f, 0.03274470f, 0.00014465f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.06034965f, -0.04168360f, 0.02670520f, 0.07573934f, -0.03934518f, 0.00562890f, -0.04766537f, -0.02945751f, 
    0.09895858f, -0.11475567f, -0.04121402f, -0.02209044f, -0.05532505f, -0.03820276f, 0.00549031f, -0.00353937f, 
    -0.01553545f, 0.09252673f, 0.01158165f, 0.01660824f, 0.16432543f, 0.23348862f, 0.00722486f, 0.20228960f, 
    -0.05084841f, -0.06478049f, 0.07189200f, 0.15153791f, 0.22646566f, 0.03676278f, 0.02504876f, 0.02950551f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.63576269f, 0.29416251f, 0.29613325f, 0.01843653f, 0.06864849f, 0.05438070f, -0.05663489f, -0.36813349f, 
    -0.20609507f, 0.31300777f, -0.09363518f, 0.12585755f, 0.19876243f, 0.00212841f, -0.00336357f, -0.49599516f, 
    -0.02052573f, 0.19599564f, -0.01238468f, 0.38231751f, -0.03181123f, -0.17799577f, -0.11725058f, 0.10377413f, 
    -0.03169595f, 0.17948344f, -0.24905811f, -0.20420517f, -0.43763158f, 0.11225099f, -0.39673847f, -0.00176048f, 
    0.01686166f, 0.20012109f, 0.11378286f, 0.28721675f, -0.14719194f, 0.09679405f, -0.05693060f, -0.04185872f, 
    -0.15060297f, -0.16851299f, -0.09071131f, -0.84066194f, -0.57336015f, -0.09715907f, -0.00297174f, -0.59814614f, 
    -0.13449012f, 0.25541469f, -0.11383335f, -0.27956551f, -0.17921367f, 0.17574899f, -0.04851263f, 0.15026577f, 
    -0.12962513f, 0.05863019f, -0.19212705f, 0.27078837f, 0.35945681f, -0.08276836f, 0.24441297f, 0.15916528f, 
    0.25985792f, 0.24561954f, -0.22757679f, -0.64680856f, 0.12026285f, -0.52468228f, -0.00907153f, 0.11505467f, 
    0.09702764f, -0.69091290f, -0.03169479f, 0.31862175f, -0.27097705f, -0.15158834f, 0.11212584f, -0.42199531f, 
    0.08639791f, -0.07518489f, -0.12564288f, -0.56448668f, 0.13576016f, 0.03915865f, -0.02135621f, 0.12387866f, 
    -0.02039856f, 0.03827910f, 0.46463877f, 0.04411383f, 0.22606008f, -0.10367701f, -0.20284086f, 0.02218610f, 
    0.09820691f, 0.05002903f, -0.00726121f, 0.15077214f, 0.08924755f, 0.05373305f, 0.06267042f, 0.50438184f, 
    -0.13765231f, 0.42302656f, 0.16795345f, 0.25696960f, -0.18573868f, 0.06521387f, -0.11314482f, 0.21266463f, 
    0.10788822f, -0.15257531f, 0.16029055f, -0.78511810f, -0.16866621f, -0.35110757f, 0.16639280f, -0.13167833f, 
    -0.16936550f, 0.01136952f, -0.00419061f, 0.05092284f, -0.10430669f, -0.05118523f, -0.18454252f, 0.14892563f, 
    0.25997376f, 0.01051932f, -0.18989551f, -0.74101311f, -0.02888683f, -0.26232260f, -0.01649616f, -0.52497858f, 
    0.32948032f, -0.01667473f, 0.00568710f, -0.00363254f, 0.41389740f, 0.02930103f, 0.10684846f, 0.29678500f, 
    0.15065376f, 0.11629342f, 0.10537516f, -0.16609575f, -0.26096329f, -0.18227065f, -0.04168780f, 0.10311639f, 
    -0.09318586f, -0.11115621f, -0.07600994f, 0.19001012f, -0.07884504f, -0.07952329f, 0.33719981f, -0.00469841f, 
    -0.19790159f, -0.18209645f, 0.27199787f, -0.30712011f, -0.07555404f, -0.24172954f, -0.06928664f, -0.42357275f, 
    0.13095900f, -0.25406286f, -0.08233525f, 0.29208335f, -0.32616329f, -0.04523913f, 0.01803106f, 0.16283868f, 
    0.00087649f, 0.19816434f, 0.05864087f, 0.45379961f, 0.24567020f, 0.33430806f, -0.06309583f, -0.34975612f, 
    0.04836107f, -0.11022881f, -0.80594051f, 0.17800233f, 0.06969148f, 0.15597077f, 0.12447018f, -0.06572220f, 
    0.22564536f, -0.42440185f, -0.85496253f, 0.40286094f, 0.15817705f, -0.63577640f, -0.03724613f, -0.12620817f, 
    -0.00105832f, -0.46483508f, -0.00055713f, 0.00395512f, 0.17922521f, -0.03150699f, 0.11939890f, 0.31747940f, 
    -0.16319881f, -0.99916953f, -0.11911490f, -0.26984546f, 0.12822863f, 0.35639420f, -0.10731032f, 0.38221848f, 
    -0.02674766f, -0.17293108f, 0.16437753f, -0.22848833f, -0.12124041f, 0.04180976f, -0.58363611f, 0.15499860f, 
    0.55978537f, -0.33231685f, -0.26483849f, 0.09723826f, -0.13349336f, 0.27487135f, 0.00247310f, 0.06071531f, 
    -0.38080657f, -0.04766338f, 0.11866368f, 0.32747403f, 0.00756051f, -0.13737667f, 0.01786464f, -0.14470336f, 
    0.08973031f, -0.68057430f, -0.08694736f, 0.16379188f, -0.50281936f, -0.08222508f, -0.00080250f, -0.54204279f, 
    0.13621670f, 0.14616917f, 0.19893241f, -0.39568114f, 0.03165653f, -0.06339146f, 0.34283280f, -0.03292556f, 
    -0.32964820f, -0.29248318f, 0.30591455f, -0.13519536f, -0.01135590f, 0.51972103f, -0.03477131f, 0.03045688f, 
    -0.61690241f, -0.53075433f, -0.02288722f, 0.37356225f, -0.81478631f, -0.09631003f, -0.04336945f, 0.28988695f, 
    -0.18039216f, -0.80347431f, 0.05204111f, -0.12611528f, 0.22660553f, -0.02362839f, -0.10785884f, 0.23633786f, 
    -0.14914741f, -0.02894598f, -0.19114934f, -0.05468588f, -0.03860822f, -0.03422004f, -0.05438883f, 0.00190904f, 
    -0.14660819f, 0.00672686f, -0.00757230f, 0.47020444f, 0.06102746f, -0.62008440f, -0.08334444f, -0.14195746f, 
    0.27078351f, -0.39748812f, 0.07029802f, -0.14083274f, 0.19802158f, -0.10423582f, 0.04669933f, -0.19633268f, 
    0.04120990f, 0.08124438f, -0.04485030f, 0.76076519f, -0.45020005f, -0.23154406f, 0.04447311f, 0.25847572f, 
    0.12755743f, -0.04752766f, 0.21883987f, -0.48461679f, 0.19024657f, 0.16858618f, -0.02411253f, -0.02621126f, 
    0.06977480f, 0.08654442f, -0.30209911f, -0.03149516f, 0.05379551f, 0.36867478f, -0.04509175f, 0.21637774f, 
    0.03930115f, -0.49303871f, -0.14993402f, -0.71113598f, 0.15453207f, -0.03523361f, 0.15827292f, -0.18353184f, 
    0.15920170f, -0.38214234f, -0.12224421f, -0.28506044f, 0.44506815f, -0.38481483f, 0.14776257f, -0.32797706f, 
    -0.00396214f, -0.04493060f, -0.57589096f, 0.57450497f, 0.10933029f, 0.04869644f, -0.50197238f, 0.12003032f, 
    -0.74788707f, -0.41701075f, -0.47784641f, -0.39435822f, 0.16423181f, 0.25808713f, -0.02739585f, 0.53567630f, 
    -0.06390247f, -0.26569864f, 0.15597034f, -0.22488472f, 0.45296252f, -0.00100198f, -0.16263197f, 0.13064365f, 
    -0.16079786f, 0.02914646f, -0.05235899f, -0.51116270f, -0.10980541f, 0.18341434f, -0.05427701f, -0.20068023f, 
    0.03334829f, 0.10203802f, -0.18356612f, -0.59886956f, 0.38188526f, 0.13167585f, -0.42377830f, -0.08378547f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.07541180f, -0.02877931f, 0.30771828f, -0.20337389f, -0.08626475f, 0.28912625f, 0.06644182f, -0.18396893f, 
    0.18222487f, 0.12806463f, -0.14538561f, -0.11013623f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
