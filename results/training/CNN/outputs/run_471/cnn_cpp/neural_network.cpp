#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.80899912f, -0.66515893f, -0.86054170f, 0.78354728f, 0.86766851f, 0.70568645f, -0.24833888f, -0.71131915f, 
    -0.43906039f, -0.09885724f, 0.91911447f, 1.01610327f, 0.23740843f, -0.12940447f, -1.11198246f, -0.30346382f, 
    -0.58651364f, -0.47578514f, -1.16675425f, 0.63016158f, 0.70774519f, 0.58388394f, 0.94127405f, 0.71304035f, 
    -0.40579835f, -0.78706783f, 0.19424076f, 0.17317945f, -0.73907119f, 0.54412246f, -1.12799048f, -0.50064862f, 
    -0.91596800f, -0.74355340f, -0.20016980f, -0.65996897f, -1.12228167f, -1.23799920f, -1.02260721f, -0.28873470f, 
    -0.32461324f, 0.24220638f, -0.29335165f, 0.07451169f, -0.09499241f, 1.01753628f, 0.69555485f, 0.39959008f, 
    -0.31228077f, -0.82105690f, 0.93712676f, 0.23743737f, 0.90853190f, -0.42136428f, 0.15462667f, -0.11677961f, 
    0.04641433f, -1.42620671f, 1.13352299f, -0.46304303f, -0.50164306f, 0.29037696f, 0.20845108f, -0.95431584f, 
    -0.85814410f, -0.00891680f, 0.99973541f, 1.14171433f, 0.99933523f, 0.17753583f, -0.17825489f, 0.06690665f, 
    0.83580077f, -1.15636146f, 0.65128338f, 0.90084225f, 0.45675787f, -1.04886949f, 0.81380814f, 0.23249251f, 
    -0.26162761f, -1.01929283f, -1.01583087f, -1.21310270f, -0.03703914f, 0.32530916f, 0.55172682f, -0.32933146f, 
    0.20402981f, 0.67444569f, -0.22967646f, -1.07546771f, 0.54492521f, 0.43948936f, 0.10014103f, 0.67760473f, 
    -0.82155782f, 0.75907904f, -0.40307888f, 0.28164074f, 0.95422894f, -0.71174139f, -1.04592896f, -1.12834120f, 
    -0.73979759f, 0.77969366f, 0.18440437f, 0.47017211f, -0.88619739f, -0.99770957f, -0.00516636f, 0.90335876f, 
    -0.54342538f, -1.00206184f, -0.62635440f, 0.21295515f, -0.76990664f, 0.84462786f, 0.68523258f, 0.61632210f, 
    0.54804379f, -0.75668097f, 0.10137928f, -0.67579854f, 0.30795929f, -0.82856399f, 0.48357657f, 0.60922956f, 
    -0.46726450f, 0.16545020f, 0.72353381f, 0.66624480f, 0.53408051f, 0.40993616f, 1.03665316f, -0.48193166f, 
    0.22103830f, 1.18359876f, 0.92725122f, 0.80353862f, -0.77232307f, 0.54242772f, 0.67327654f, -0.24016410f, 
    -0.09337196f, -1.07825673f, 0.29825830f, 0.79831004f, -1.29463267f, 0.77562684f, 0.76219636f, -0.55725980f, 
    -0.09641632f, -0.36030474f, -1.23306990f, -0.56656063f, -0.23233718f, 0.21415865f, -0.69397521f, 0.81476039f, 
    0.53616023f, -0.09635763f, 0.98608804f, 0.88885558f, -0.18918692f, -1.10888350f, 0.26377282f, -0.75794381f, 
    -0.12229875f, -0.11096470f, 0.35026577f, -0.13826592f, 1.27898836f, -1.09627724f, 1.29160392f, -0.45345604f, 
    -0.43909815f, 0.33056119f, 0.22800055f, 0.16893186f, -0.43244624f, -0.85193801f, -0.99037367f, 0.36525732f, 
    1.13741231f, -0.27001628f, -0.29754990f, 0.16636567f, -0.77039832f, 1.25276792f, 0.84560889f, 1.03214526f, 
    0.39679065f, -0.75086546f, 0.07310575f, -0.19871974f, -0.34801546f, 0.31226701f, -1.30194235f, -0.93895388f, 
    0.53537029f, -0.91747832f, -0.69370860f, 0.08457808f, 0.31498203f, 0.70669436f, -0.17445619f, -1.17342389f, 
    -0.02340878f, 0.87343383f, -0.83730811f, -0.30627343f, -0.11113166f, 0.85874683f, -0.25727880f, 0.64314741f, 
    -0.65890694f, -0.94454646f, -0.99012631f, -0.91147327f, 0.57112080f, 1.25732446f, 0.16264452f, -0.37345681f, 
    0.53964299f, 0.54081118f, 0.63246030f, 0.38978243f, -1.10199130f, -1.23797476f, -0.04012916f, 0.47346112f, 
    0.23016553f, -0.31886190f, 0.87685770f, 0.85307860f, 0.59889591f, 0.81077814f, 0.59359854f, 0.11618660f, 
    0.36885908f, 0.55063283f, -0.35050648f, -1.11540747f, -0.57562554f, -0.34831089f, 0.36199367f, 1.01442313f, 
    -0.90479416f, -0.07444701f, 0.09943066f, -0.33404502f, 0.81597269f, 1.32504761f, 0.91713607f, -0.75755525f, 
    0.87869948f, -0.07885221f, -0.14651991f, 0.34814832f, 0.42781469f, -0.29262665f, 1.03572714f, -0.98933339f, 
    1.00286782f, 0.78621161f, 0.40993530f, 0.91414785f, -0.66327083f, -0.44156459f, 0.64571577f, 0.76219255f, 
    1.24535692f, -0.08754150f, -0.28170988f, -0.47861913f, 0.39709833f, 0.67653233f, 0.38616621f, 1.20599234f, 
    -0.52937633f, 1.47201979f, 0.16646835f, 0.08070708f, 1.10488927f, -0.01332295f, -0.12378510f, -0.23983900f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.14547688f, 0.15757169f, 0.07142092f, 0.17670178f, -0.18049860f, 0.07308260f, 0.11264314f, -0.15429313f, 
    -0.31392366f, 0.20706359f, -0.18477789f, -0.20620723f, -0.04619900f, 0.20491731f, 0.01878165f, -0.29496330f, 
    0.30012515f, 0.21710953f, -0.04671369f, -0.19915567f, -0.08838529f, 0.48008886f, 0.26511252f, -0.05207148f, 
    -0.02448230f, -0.08774427f, 0.21699154f, 0.06759317f, 0.33104399f, 0.25950408f, -0.07200859f, -0.06459468f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.05821572f, -0.05204765f, -0.02491143f, 0.01557139f, -0.06311164f, 0.03625824f, -0.01913189f, -0.02052610f, 
    -0.04065418f, 0.03496616f, 0.02787332f, -0.00834832f, 0.03400393f, 0.02324446f, 0.00884074f, -0.04805904f, 
    0.04826066f, 0.04094787f, -0.00811171f, -0.04620152f, 0.03782452f, -0.00664016f, 0.05054349f, 0.01893560f, 
    -0.02530044f, -0.03856683f, -0.06406114f, -0.01465944f, -0.02063426f, 0.04940425f, -0.03653682f, -0.00975191f, 
    -0.04595174f, 0.01216475f, 0.00093001f, -0.00921212f, -0.05420525f, 0.04930905f, 0.04021514f, -0.05548784f, 
    0.03122139f, 0.04452771f, -0.01511886f, 0.00715165f, -0.04009802f, -0.00573216f, 0.03299590f, -0.00568849f, 
    -0.04494788f, -0.04980564f, 0.04571198f, -0.03304880f, 0.03140626f, -0.05639916f, -0.05017591f, -0.00924468f, 
    0.02487402f, -0.02843530f, -0.04198070f, 0.02737279f, 0.03618935f, 0.00534474f, 0.00247061f, -0.05132955f, 
    -0.01515157f, 0.01615599f, -0.02490820f, 0.04888389f, -0.01450339f, 0.02491295f, 0.02073294f, -0.06360913f, 
    0.03702386f, -0.05183370f, -0.06273249f, 0.05053538f, 0.00817526f, -0.01024234f, -0.04880903f, 0.03781551f, 
    -0.03806022f, -0.04249731f, -0.05979557f, 0.02290234f, -0.05214740f, 0.02511611f, -0.06779163f, 0.04254531f, 
    0.01197123f, -0.05745436f, 0.03411950f, -0.00467721f, 0.01315207f, 0.04273433f, 0.02673548f, -0.03644235f, 
    0.02632494f, 0.01921067f, 0.01472423f, 0.03549363f, -0.04789030f, 0.00789134f, -0.00820887f, 0.00742755f, 
    -0.02454510f, 0.00974407f, -0.03756497f, -0.02107985f, -0.03345960f, 0.01305100f, -0.06175748f, -0.02460087f, 
    -0.02194408f, 0.00343203f, 0.05055598f, 0.04269583f, 0.04924181f, -0.03672745f, -0.04944139f, -0.04372418f, 
    -0.04182848f, -0.00116651f, 0.01357357f, 0.03769285f, 0.02484842f, 0.00179394f, 0.00933777f, 0.04366091f, 
    0.02738424f, -0.02346877f, 0.05554125f, -0.00115052f, -0.04197093f, 0.00219072f, -0.01770504f, 0.00002397f, 
    0.04466932f, -0.04746671f, 0.01657993f, 0.04022007f, -0.06172649f, 0.04110286f, 0.02377645f, 0.02066985f, 
    -0.02555512f, 0.01480713f, -0.04115156f, -0.02300478f, -0.01635031f, 0.01388655f, -0.02873849f, 0.00281850f, 
    0.01929397f, -0.01391736f, -0.02799117f, 0.00560505f, -0.02651883f, -0.02825279f, 0.04127788f, 0.03948820f, 
    -0.00716245f, 0.03789102f, 0.03328415f, -0.05070836f, -0.01481936f, 0.04374791f, -0.06251287f, -0.02626767f, 
    0.05558360f, 0.01919747f, -0.02629094f, -0.02389413f, 0.04064461f, -0.02000572f, -0.06310101f, 0.00887852f, 
    -0.06065032f, 0.01123622f, -0.03967175f, -0.06706928f, -0.06038534f, -0.02508803f, -0.06109006f, -0.02925854f, 
    0.03551432f, -0.03904472f, -0.03360301f, -0.03946308f, 0.02442418f, -0.06519121f, 0.03647503f, 0.02683320f, 
    0.03689280f, -0.01400940f, -0.06877759f, -0.03044385f, 0.02131559f, -0.05954219f, -0.01184838f, 0.03601116f, 
    -0.02337579f, 0.04369796f, -0.02140617f, 0.04344160f, 0.00588499f, -0.02268011f, -0.04690247f, -0.05501871f, 
    -0.04087304f, -0.06198880f, -0.05436837f, -0.05789832f, -0.03689073f, 0.04320293f, -0.04732127f, -0.04342807f, 
    -0.05901789f, 0.02010004f, 0.02470798f, 0.03246578f, 0.04677724f, 0.00782173f, -0.02345276f, -0.00608932f, 
    0.01705831f, 0.04569328f, -0.05575372f, 0.03582374f, -0.03465778f, -0.06674438f, -0.01373237f, -0.04743217f, 
    0.03055557f, -0.02418012f, -0.01897179f, -0.04558668f, 0.03758941f, 0.01426462f, 0.02097991f, 0.03117423f, 
    -0.00195176f, -0.05157859f, -0.00753677f, -0.02452765f, -0.00339891f, -0.02611873f, 0.00201222f, -0.01102756f, 
    -0.02512906f, -0.01931194f, -0.04215282f, 0.00231872f, -0.05454907f, -0.05486084f, -0.00627722f, 0.00622428f, 
    -0.02712084f, 0.02423324f, 0.02150843f, -0.01129470f, 0.04183596f, -0.02142741f, 0.01400288f, -0.05672774f, 
    -0.04130522f, 0.02303024f, -0.06050773f, -0.05448709f, -0.05455570f, -0.01475318f, 0.02473825f, 0.03036281f, 
    -0.00475034f, 0.02293582f, 0.00198488f, -0.05643923f, -0.06655485f, -0.03242497f, -0.02081116f, -0.03978460f, 
    0.01828440f, 0.04221743f, 0.02738516f, 0.00641609f, -0.02991676f, 0.02740236f, -0.02377023f, -0.02875283f, 
    0.21993764f, 0.06403384f, -0.15902543f, 0.00169520f, -0.09444503f, -0.22662106f, 0.24053371f, 0.00955370f, 
    -0.10286474f, 0.02001471f, -0.10017987f, 0.13572533f, 0.02751040f, 0.04720486f, -0.01462425f, 0.19279203f, 
    0.17730352f, 0.03225776f, 0.35337847f, 0.41184339f, 0.17681630f, -0.20600639f, -0.30911806f, -0.37255710f, 
    0.13213637f, 0.06901299f, 0.07019259f, -0.16634759f, -0.18688753f, 0.05761515f, -0.02392084f, 0.25802270f, 
    0.11748511f, 0.08372123f, -0.06403732f, -0.05555739f, -0.21875723f, -0.03243197f, 0.00662741f, 0.13581420f, 
    -0.04542553f, 0.12793612f, 0.10487610f, 0.10808258f, 0.04233390f, 0.31613439f, 0.07075825f, -0.06243303f, 
    -0.04117600f, -0.14592002f, -0.11504986f, 0.00609356f, 0.06125792f, 0.22567984f, -0.25687289f, -0.12246609f, 
    -0.19446462f, 0.18696584f, -0.17634319f, 0.16195948f, 0.04844429f, 0.04370237f, -0.17103694f, 0.08356370f, 
    0.29210621f, -0.06634557f, -0.12101330f, -0.14949572f, -0.20055631f, 0.04548436f, -0.15237018f, 0.00604655f, 
    0.11446182f, -0.19100296f, 0.04814030f, -0.03908530f, 0.21926677f, 0.18465176f, -0.06780424f, -0.10157809f, 
    0.05010479f, 0.09421591f, 0.02673567f, -0.20801526f, 0.29485616f, 0.00824129f, -0.03960055f, -0.17996728f, 
    -0.01293606f, -0.00797791f, 0.28444824f, 0.09431108f, 0.26527366f, 0.03480636f, 0.02676271f, -0.06322543f, 
    0.02662044f, 0.05539433f, -0.18559419f, -0.25566584f, 0.12243822f, 0.28953895f, -0.03597429f, -0.04549123f, 
    0.30258849f, 0.03483986f, 0.07265290f, 0.06140763f, -0.32455304f, 0.02149503f, 0.18031523f, 0.08549246f, 
    -0.03331151f, -0.00273455f, -0.17952152f, 0.14477845f, -0.25151879f, 0.18268925f, 0.10132125f, 0.17404157f, 
    -0.09111029f, -0.32694787f, -0.19516963f, 0.14953946f, 0.16316529f, -0.02078719f, 0.24583305f, 0.14458053f, 
    -0.24290243f, -0.11729109f, -0.05362163f, -0.03162711f, -0.13662557f, 0.07791333f, 0.27570367f, -0.44775212f, 
    0.14687784f, 0.18829030f, -0.06732596f, 0.04323424f, -0.09001808f, -0.17140727f, 0.12108779f, 0.16573060f, 
    -0.21111694f, 0.05920468f, 0.23492034f, 0.05983828f, 0.14436164f, -0.02505675f, 0.27213880f, 0.05221862f, 
    -0.06095848f, -0.18514711f, -0.24512680f, 0.28589076f, -0.16145246f, 0.15058374f, 0.16833748f, 0.07554676f, 
    0.08423010f, -0.04172283f, -0.07830843f, 0.09429964f, -0.06883029f, 0.09555236f, -0.15901130f, 0.00625856f, 
    -0.23087427f, -0.00706167f, 0.07480498f, -0.36353800f, -0.11044778f, -0.40871504f, -0.02200749f, -0.04556826f, 
    0.00195234f, -0.11867695f, -0.02454910f, -0.09137560f, 0.19918746f, -0.17831355f, -0.22426800f, 0.06290986f, 
    -0.04348381f, -0.17615175f, -0.07847364f, -0.12947035f, -0.23382689f, -0.09408370f, 0.12036411f, -0.01888335f, 
    -0.04462493f, 0.00158292f, -0.02828144f, 0.16952625f, 0.07656539f, 0.05059675f, -0.53453004f, -0.28602901f, 
    0.02765690f, 0.01968699f, 0.09311315f, 0.01794054f, 0.05002621f, -0.15076506f, -0.09825728f, -0.18460436f, 
    -0.30056268f, -0.25778461f, 0.03461687f, -0.14176999f, -0.02656336f, -0.10449008f, 0.00373211f, 0.16421647f, 
    -0.18983126f, 0.03293039f, 0.05132329f, 0.13509722f, -0.16106871f, -0.13001597f, 0.03427062f, -0.00184886f, 
    -0.02009449f, 0.02818083f, -0.17535777f, 0.11132397f, -0.00540891f, -0.08726301f, 0.07271456f, 0.18099587f, 
    0.19141777f, 0.11874831f, 0.25049567f, 0.18709137f, -0.12311186f, 0.04139532f, -0.22245732f, -0.09612804f, 
    -0.08738370f, 0.13345730f, 0.10910528f, -0.09512650f, -0.08079204f, 0.06394458f, 0.01887794f, 0.06930409f, 
    -0.05220145f, -0.06790365f, -0.10129477f, -0.09198537f, 0.34655988f, -0.04177311f, -0.10558621f, 0.09467673f, 
    -0.08733679f, 0.05926510f, -0.02375111f, 0.15632327f, 0.19200487f, 0.26815268f, 0.09259196f, -0.22415417f, 
    -0.11143745f, -0.04336468f, -0.14783116f, 0.22607909f, -0.14809620f, 0.11623500f, 0.10325561f, -0.00359659f, 
    -0.06742406f, 0.04777862f, -0.02995226f, 0.06058544f, -0.08523674f, 0.13383634f, 0.07783272f, 0.12139149f, 
    -0.10835677f, -0.12361114f, -0.23783670f, 0.05728051f, -0.11451361f, 0.27305353f, 0.14762156f, 0.01792997f, 
    -0.03308602f, 0.04551524f, -0.01528473f, -0.04530763f, 0.00334973f, 0.01929980f, -0.00649822f, 0.04415743f, 
    0.00294618f, -0.03178523f, -0.02580541f, 0.03534755f, 0.00358301f, -0.03080750f, -0.01316721f, -0.00486961f, 
    0.00767757f, 0.04551550f, 0.01009061f, -0.04225330f, 0.02626114f, 0.01664199f, -0.01279782f, -0.06379049f, 
    0.00373560f, 0.04478396f, 0.01202743f, -0.04399176f, 0.03422336f, -0.03365381f, -0.00152394f, -0.02830417f, 
    0.00260008f, -0.01438378f, -0.06091295f, 0.02617075f, 0.05229678f, -0.04878367f, -0.02085230f, -0.02931134f, 
    -0.01246246f, 0.02412752f, -0.04272489f, -0.02639002f, -0.02931538f, -0.00969725f, 0.04764372f, -0.05137970f, 
    0.02057471f, -0.05536311f, 0.05124036f, 0.00187377f, 0.01681264f, 0.01646437f, 0.03865133f, -0.02893947f, 
    -0.03950310f, -0.02432686f, -0.03453150f, -0.02315765f, 0.02135899f, 0.05271684f, 0.01586268f, -0.05279464f, 
    0.01431019f, 0.00964886f, 0.01641958f, -0.04452191f, -0.03470752f, 0.01121421f, 0.02659810f, 0.02122806f, 
    0.00411800f, 0.01321726f, 0.03662358f, -0.01763544f, -0.02649572f, -0.00141252f, -0.01046902f, -0.05677604f, 
    0.01988250f, 0.02278225f, 0.02889219f, -0.01068457f, -0.04741592f, -0.05184199f, -0.04013641f, -0.03805946f, 
    -0.01300181f, -0.00469881f, 0.02533830f, -0.01851133f, 0.03528273f, -0.02873667f, -0.05538981f, -0.02435710f, 
    -0.02842111f, 0.03717934f, 0.04524117f, -0.02831070f, -0.01576570f, 0.04623262f, -0.02815744f, 0.02065415f, 
    -0.01482190f, -0.03227444f, 0.03597499f, 0.01242308f, 0.04643029f, -0.01057117f, -0.05701258f, 0.00007531f, 
    0.05846655f, -0.02498212f, 0.01150811f, -0.06759241f, 0.01590007f, 0.01205588f, -0.04814916f, 0.03863451f, 
    0.02846519f, -0.01081532f, 0.02578429f, 0.02216689f, -0.03498772f, -0.03369817f, 0.02244850f, 0.04297194f, 
    -0.04152685f, -0.03918347f, 0.03449015f, 0.02635431f, -0.05389236f, -0.06097834f, 0.04574352f, 0.03177264f, 
    -0.04873306f, -0.01091252f, 0.00165088f, -0.02669411f, -0.05222409f, 0.03048296f, -0.02852012f, -0.03308850f, 
    0.05072754f, -0.01598864f, -0.01813260f, -0.00726256f, -0.05636944f, 0.03676522f, -0.02388239f, -0.02329961f, 
    0.05739789f, -0.04145379f, -0.01639462f, -0.03710526f, -0.04818524f, 0.05282406f, 0.00576870f, 0.02963090f, 
    -0.02769419f, 0.01838540f, 0.04995360f, 0.01168005f, -0.04189324f, -0.03608104f, -0.01445515f, 0.04868582f, 
    0.01928322f, -0.04403813f, -0.00672463f, -0.02494071f, -0.06429293f, -0.00935964f, -0.02149468f, -0.01635205f, 
    -0.06290691f, -0.06237606f, 0.04116257f, 0.03013035f, -0.01740317f, -0.04818447f, 0.05173995f, 0.01499186f, 
    0.02311854f, -0.02790617f, 0.05099363f, -0.05884824f, -0.01866374f, -0.02946182f, 0.02565406f, 0.02127063f, 
    0.00834268f, 0.03089596f, 0.02037818f, 0.00906137f, 0.00798425f, 0.01265958f, -0.02718926f, -0.05102698f, 
    -0.03517278f, 0.05330871f, -0.02630401f, -0.01528439f, -0.05879199f, -0.03819810f, -0.00354348f, 0.05065169f, 
    -0.02653453f, -0.01933280f, -0.04118764f, -0.04643383f, -0.03215493f, -0.03232742f, -0.02340243f, 0.01528994f, 
    -0.04779093f, 0.05133596f, 0.05340394f, -0.01764145f, -0.05381127f, -0.00883097f, -0.00673671f, 0.05004508f, 
    -0.00288351f, 0.02506736f, 0.01860710f, 0.04952384f, 0.03428219f, -0.03223147f, -0.03122814f, 0.01879753f, 
    0.04491793f, -0.04242641f, 0.03971960f, -0.03317103f, -0.05490013f, -0.05435494f, -0.04361827f, 0.01396462f, 
    0.00053417f, -0.01446040f, -0.01307445f, 0.03648526f, -0.02425439f, 0.02791519f, 0.05409524f, 0.03523771f, 
    0.01843363f, -0.01539853f, -0.00934153f, -0.04525773f, 0.00781542f, -0.04507246f, -0.05518441f, 0.02270246f, 
    -0.06214403f, 0.05347516f, -0.05187324f, -0.02151960f, -0.02201645f, 0.03124497f, 0.01775973f, -0.04030024f, 
    -0.02635309f, -0.04773945f, 0.00302074f, 0.03289554f, 0.03473532f, -0.03197579f, -0.00017877f, -0.02005868f, 
    -0.01685440f, 0.03002995f, 0.01333739f, -0.04043358f, 0.02083372f, -0.03914696f, -0.02523506f, 0.02025871f, 
    -0.00350269f, 0.04494033f, 0.01660759f, 0.00536655f, 0.03744812f, -0.05787577f, 0.01646905f, -0.02493396f, 
    0.21294491f, 0.16863754f, 0.19280560f, -0.05605063f, 0.18348871f, -0.10927443f, 0.14078251f, -0.03232131f, 
    -0.06727200f, -0.40516952f, 0.18809073f, 0.18637401f, -0.13912565f, -0.04651293f, 0.16067256f, 0.04079759f, 
    0.12755938f, 0.15010776f, 0.32281515f, 0.25270462f, 0.16419777f, -0.11650987f, 0.09066273f, -0.35009277f, 
    0.12184796f, -0.08541966f, -0.00034513f, 0.26705503f, -0.10877099f, 0.05625984f, -0.12616865f, 0.01814580f, 
    -0.19266121f, 0.01102718f, 0.21556090f, -0.07463637f, -0.17814122f, 0.35054663f, -0.08817814f, 0.12996976f, 
    -0.10934861f, -0.24427690f, 0.07331385f, 0.03178469f, -0.00894833f, 0.12642288f, -0.22331269f, -0.34550154f, 
    0.09917516f, -0.05932801f, 0.05184065f, -0.06042929f, -0.10633188f, 0.14860451f, -0.14897402f, -0.27350774f, 
    -0.19560048f, 0.11454917f, 0.02414384f, 0.06949717f, 0.02840282f, -0.05228982f, 0.03092670f, -0.01504490f, 
    0.40720904f, 0.27855685f, -0.17469735f, 0.01327395f, 0.02659121f, -0.06901503f, -0.01048285f, -0.03991657f, 
    -0.42386448f, 0.01848393f, 0.13146350f, 0.08046886f, -0.04986708f, -0.07184368f, 0.03839790f, 0.01584642f, 
    0.05448826f, -0.23372470f, 0.27219319f, -0.24676216f, 0.15930587f, -0.12260979f, 0.02522925f, 0.10199745f, 
    -0.02182652f, -0.04896848f, -0.10799452f, 0.18290931f, -0.20251279f, 0.02087886f, 0.23693159f, 0.05096254f, 
    -0.09677601f, 0.00825522f, -0.08671094f, 0.37006259f, -0.32646576f, 0.03673596f, -0.03631842f, -0.07100794f, 
    -0.11480185f, -0.06504431f, 0.06626734f, 0.20792851f, -0.02221534f, 0.35410196f, -0.23185506f, -0.05027774f, 
    -0.01875383f, 0.05931479f, 0.03172423f, -0.08876359f, -0.10239863f, -0.17237312f, -0.03327063f, 0.21429779f, 
    -0.03929528f, -0.02266559f, 0.01158213f, 0.01541199f, 0.01548716f, -0.07384014f, -0.12168631f, 0.14573663f, 
    -0.05928238f, 0.11198533f, -0.20684767f, -0.00679559f, -0.09555963f, 0.15767796f, 0.15391964f, -0.23838882f, 
    -0.06816725f, 0.03309429f, -0.01334236f, 0.04277210f, -0.08476811f, 0.06033566f, 0.09297927f, 0.11733356f, 
    0.10177885f, 0.05154533f, -0.01830108f, 0.00519028f, 0.06914484f, 0.07098728f, -0.14757128f, -0.03163555f, 
    0.09728503f, -0.07656214f, 0.35928935f, -0.10898244f, -0.20310560f, -0.10444504f, 0.04273137f, 0.03787784f, 
    0.17544818f, 0.05743591f, -0.22337648f, -0.29347166f, 0.16115275f, -0.14906295f, -0.02025310f, 0.03636736f, 
    -0.09670935f, 0.01135145f, 0.04563518f, 0.19489546f, -0.38128725f, 0.01175708f, -0.08610504f, -0.09535326f, 
    -0.00186891f, 0.06601076f, 0.18138628f, 0.07833280f, 0.20449957f, 0.36061972f, 0.10180768f, -0.08240676f, 
    0.09677323f, 0.05828387f, -0.13521264f, 0.12709884f, -0.08382890f, -0.10902862f, -0.16488560f, 0.21463773f, 
    0.09932601f, -0.00793969f, -0.00647614f, 0.04076690f, 0.12192493f, -0.06409710f, -0.20989849f, 0.08358140f, 
    -0.10503545f, 0.14640677f, -0.06771927f, -0.03461447f, 0.10683122f, -0.01918232f, 0.19160908f, -0.31415957f, 
    0.17193800f, -0.15021375f, -0.32316452f, -0.16204585f, -0.06200615f, -0.03710670f, 0.00636029f, 0.11684984f, 
    -0.51368785f, 0.31028873f, -0.28717801f, 0.01974135f, -0.06294147f, 0.10768406f, 0.11786684f, 0.02741510f, 
    0.07827260f, 0.12515521f, -0.27094573f, -0.26742026f, -0.08935062f, -0.22083305f, 0.05281580f, 0.05994940f, 
    -0.15308118f, 0.10058422f, -0.09592846f, 0.05491804f, 0.20865735f, -0.01682917f, -0.08452204f, -0.01087875f, 
    -0.09659348f, -0.08934963f, -0.13454120f, 0.04819227f, 0.25082681f, -0.02595091f, -0.23352988f, -0.02388443f, 
    0.05470318f, 0.10544153f, 0.07851148f, -0.11951955f, -0.44567534f, -0.13126013f, 0.06312983f, -0.05121883f, 
    0.01961032f, -0.01237483f, -0.07824442f, 0.04027496f, -0.02344528f, 0.48206127f, -0.16450395f, 0.22675480f, 
    0.14106411f, -0.08788808f, -0.10853862f, -0.03800650f, 0.11389079f, 0.21903965f, -0.12417769f, -0.05439188f, 
    0.10077513f, -0.03554729f, -0.10195716f, -0.00928422f, 0.06388719f, 0.08849383f, 0.02276618f, 0.09512555f, 
    -0.04325610f, -0.09271614f, 0.04588306f, 0.04189411f, -0.06670217f, -0.02674914f, 0.37434933f, 0.04156545f, 
    0.02760776f, 0.10173021f, 0.13583750f, -0.02421549f, 0.00263575f, -0.00192856f, 0.03480585f, -0.00965129f, 
    -0.13889892f, -0.25058773f, -0.23438397f, -0.02062327f, 0.11685382f, 0.09974048f, 0.05582489f, 0.12932064f, 
    0.03114827f, 0.15622559f, 0.47051150f, -0.02187158f, 0.47604206f, -0.03302224f, 0.06386025f, 0.08936665f, 
    0.02511508f, 0.22155164f, -0.09290453f, -0.25126100f, -0.36067122f, 0.02936317f, 0.04000356f, 0.24800365f, 
    0.03860405f, 0.09645960f, -0.00145589f, 0.29548180f, 0.05919677f, 0.22577243f, 0.37987706f, 0.15595801f, 
    -0.02227368f, -0.02436531f, 0.10400177f, 0.01117426f, 0.07526882f, -0.07772408f, 0.03205157f, 0.07797239f, 
    0.02831756f, -0.00221455f, 0.04506871f, 0.12081287f, -0.17629477f, -0.01445355f, -0.21465786f, -0.22137037f, 
    -0.28435549f, -0.01183185f, 0.06918164f, -0.09819425f, 0.28256294f, -0.12420347f, -0.07696958f, 0.34421539f, 
    -0.00371669f, 0.41385728f, -0.09316386f, 0.16177805f, -0.00697530f, 0.02033604f, -0.09114337f, 0.08688709f, 
    0.12793845f, 0.19591156f, -0.09794272f, -0.06910340f, -0.05261488f, -0.21961041f, -0.06376423f, -0.44647619f, 
    0.25201553f, -0.09007162f, 0.20780027f, 0.14763807f, 0.05855620f, 0.07131711f, -0.13869441f, 0.08182343f, 
    0.17893174f, 0.09811317f, -0.00130070f, 0.06579007f, 0.18140289f, 0.18016113f, 0.05245020f, -0.15664385f, 
    0.03341348f, 0.10432136f, -0.11001809f, -0.21577427f, -0.13423319f, -0.47789416f, 0.02390745f, 0.16828570f, 
    0.07548183f, -0.08914091f, 0.01688257f, -0.04675906f, 0.02995931f, -0.41162458f, -0.00924962f, -0.12555720f, 
    -0.14200939f, 0.09313162f, -0.00107733f, 0.01790733f, 0.03238553f, -0.02804583f, 0.07728728f, 0.11833052f, 
    -0.05437472f, -0.01680013f, 0.12364826f, -0.03060832f, -0.03390657f, 0.19821709f, 0.42581332f, 0.16133159f, 
    0.05784268f, -0.06683696f, 0.00425113f, 0.11696287f, -0.14561544f, 0.01185238f, -0.03987194f, 0.18236832f, 
    0.16848414f, -0.10632325f, -0.07570460f, -0.04823280f, -0.05620082f, -0.04326143f, -0.16190019f, -0.02395810f, 
    0.38831741f, -0.06036500f, -0.09636261f, 0.06001293f, 0.17834479f, -0.04983301f, 0.03788497f, -0.10779656f, 
    0.11009724f, -0.06722778f, -0.04193313f, 0.25607017f, 0.03789399f, 0.00832853f, 0.02361795f, 0.01976684f, 
    -0.02491973f, 0.07320208f, -0.35721800f, -0.38203150f, -0.44148123f, 0.21441419f, 0.08384626f, 0.00085374f, 
    -0.00939044f, 0.08351144f, -0.13227221f, -0.37739834f, 0.09255459f, -0.45117864f, -0.19209011f, -0.02316319f, 
    -0.08278900f, 0.26380956f, -0.06115327f, 0.13503057f, -0.26899672f, 0.00597052f, 0.01102720f, -0.04022791f, 
    0.14431217f, -0.08751957f, 0.05767218f, -0.15366028f, -0.10989086f, 0.10131195f, 0.12897195f, -0.07524796f, 
    0.06143812f, 0.10624697f, 0.01524401f, -0.09803490f, 0.04004090f, 0.07122236f, -0.04368348f, -0.11264328f, 
    -0.03540746f, -0.05163353f, -0.04794557f, -0.13973109f, 0.13532640f, 0.05477081f, 0.04259681f, -0.11113892f, 
    -0.38084334f, 0.10583936f, 0.08959488f, -0.15944776f, -0.12985209f, 0.04523840f, -0.06674937f, 0.12562042f, 
    -0.13846421f, 0.16523993f, 0.01532374f, -0.20582582f, 0.01434853f, -0.07170881f, -0.12902068f, 0.04594889f, 
    0.07597058f, -0.31260937f, -0.45245767f, -0.23632096f, -0.02399459f, -0.05357829f, -0.15314646f, 0.09817012f, 
    -0.11625176f, -0.12213997f, 0.26893958f, 0.39870551f, 0.21007556f, 0.16975009f, -0.17394193f, -0.02577874f, 
    0.08304340f, 0.01483598f, -0.03027835f, -0.31237978f, -0.23459814f, -0.04665202f, -0.11984279f, 0.11861946f, 
    0.11549532f, 0.17903116f, 0.01271941f, -0.12780680f, 0.16981100f, -0.04864028f, 0.14357816f, 0.06515386f, 
    0.02408155f, 0.06452978f, 0.13159281f, 0.08005977f, -0.02725013f, -0.08552893f, 0.03763979f, -0.01107352f, 
    -0.03806764f, -0.12403204f, -0.14461125f, 0.24054168f, -0.08768389f, -0.05112650f, 0.09254684f, -0.13908938f, 
    0.19513918f, 0.18944235f, -0.12755091f, -0.04037049f, -0.11077942f, 0.05032293f, 0.08116568f, 0.09341553f, 
    0.03217563f, 0.05552172f, 0.25048268f, -0.01890534f, -0.14126374f, 0.10547701f, -0.04880346f, -0.08483518f, 
    0.01524393f, 0.05057103f, 0.00584189f, 0.00835655f, 0.04801359f, -0.01107019f, -0.03529540f, -0.00383729f, 
    -0.03173929f, 0.03552755f, -0.05625069f, 0.03450246f, -0.05760135f, -0.03566059f, -0.05228715f, -0.05319650f, 
    0.04250282f, -0.00502341f, -0.01471803f, 0.02246419f, 0.04615801f, 0.01968563f, -0.03396788f, 0.03530471f, 
    0.00694361f, 0.00927170f, -0.01333566f, 0.02045591f, -0.02917268f, 0.06109322f, -0.05215617f, 0.00749804f, 
    0.04361467f, -0.05936327f, -0.02417934f, 0.03895901f, -0.04856219f, 0.04473263f, -0.01947573f, -0.05423676f, 
    0.02710785f, -0.04527248f, 0.04671009f, 0.03074439f, 0.01610360f, 0.02795821f, -0.05895129f, -0.00401124f, 
    -0.00412585f, -0.01504526f, 0.00554190f, -0.01466388f, -0.03901038f, 0.02762487f, -0.00370358f, 0.02593642f, 
    0.03509533f, 0.03859613f, -0.01291010f, 0.04831468f, -0.05784380f, -0.06617950f, 0.02124721f, 0.03684765f, 
    -0.01351102f, 0.02426749f, 0.01852748f, 0.02820121f, 0.01486191f, -0.04570716f, 0.00233257f, -0.04060014f, 
    -0.06768612f, 0.04559695f, -0.05203967f, -0.00292568f, 0.00537360f, -0.01606976f, 0.03636970f, -0.02201354f, 
    -0.02967643f, -0.03312568f, 0.01728536f, -0.01646415f, -0.00605473f, -0.06315590f, -0.03049560f, 0.02283339f, 
    -0.04768233f, 0.01349825f, 0.01333656f, -0.05901891f, -0.05079385f, -0.02691215f, -0.04205004f, -0.06214910f, 
    0.00205056f, 0.00697046f, 0.04041601f, -0.03964080f, -0.06652633f, -0.02128623f, -0.04524936f, -0.04692992f, 
    -0.01290659f, -0.06308027f, 0.03704754f, -0.06383132f, -0.00159711f, 0.01259729f, -0.02371843f, -0.01360251f, 
    -0.01713255f, -0.01377853f, -0.05573992f, -0.01246111f, 0.01055496f, 0.05132859f, -0.00652468f, 0.04757554f, 
    -0.03545672f, -0.04545241f, -0.00776257f, 0.00054780f, 0.00477588f, 0.02983817f, -0.05791033f, 0.01878178f, 
    0.00613086f, -0.00310036f, -0.00716340f, -0.04810656f, 0.01421355f, -0.05028239f, 0.04835438f, -0.01221027f, 
    -0.05304233f, -0.06451730f, -0.00400938f, 0.01187183f, -0.00982673f, -0.02345875f, -0.04018391f, -0.03978651f, 
    0.04610933f, -0.05058440f, 0.03321131f, 0.03445740f, -0.02196071f, 0.01384863f, -0.03826826f, -0.04715410f, 
    -0.00401280f, -0.05279034f, 0.04231277f, -0.03774267f, -0.05670700f, 0.02242690f, 0.03518877f, 0.01396454f, 
    0.00496868f, 0.01257010f, -0.03591299f, -0.01703379f, -0.00748041f, 0.03458985f, 0.03277005f, 0.01751954f, 
    -0.02248889f, -0.02570910f, 0.04543783f, 0.03284100f, 0.03396562f, 0.01849187f, 0.00601735f, 0.01590225f, 
    0.01583856f, -0.03120208f, -0.03619310f, -0.02670998f, -0.01466625f, 0.03016435f, -0.04021113f, -0.04433110f, 
    0.02608037f, -0.04978539f, 0.01151479f, 0.00203833f, 0.04384429f, -0.02832874f, 0.00527798f, -0.00903583f, 
    -0.06250111f, -0.02747168f, 0.01541807f, -0.06404125f, -0.02182012f, 0.03250353f, 0.02774449f, -0.05288297f, 
    0.02539592f, 0.01023069f, 0.04675667f, -0.00073784f, -0.05436330f, 0.04862771f, 0.04880022f, -0.01851490f, 
    -0.04429600f, -0.05135139f, 0.02148436f, -0.00348451f, -0.04142780f, -0.01417453f, 0.02693417f, 0.00473215f, 
    0.04945195f, 0.00133994f, -0.03980021f, 0.01829443f, -0.04392152f, -0.02446549f, -0.03504375f, -0.00684459f, 
    -0.05378249f, 0.00369475f, -0.01613073f, -0.01690875f, -0.00457589f, -0.04912109f, -0.02628975f, -0.02544750f, 
    -0.05026679f, -0.04957226f, 0.01776818f, -0.03134617f, -0.01449158f, 0.00672582f, -0.02988634f, -0.03210292f, 
    0.03597499f, -0.02544896f, 0.04487621f, -0.00859732f, 0.03624608f, 0.00373178f, -0.00349406f, -0.06013861f, 
    -0.03030287f, -0.00044307f, 0.04609198f, -0.04175732f, -0.02675614f, 0.03317853f, 0.00651166f, -0.04562266f, 
    -0.00004388f, -0.00657584f, 0.04379760f, 0.02002749f, 0.02399872f, -0.02010104f, 0.04072566f, -0.05632548f, 
    -0.03279612f, 0.03493315f, -0.00495548f, -0.01236446f, 0.01541949f, -0.01428657f, -0.03084847f, 0.04918424f, 
    -0.05374600f, -0.04777732f, 0.04047419f, -0.01081285f, -0.01659532f, -0.01267657f, 0.01819952f, -0.00361966f, 
    0.01086703f, 0.04933354f, -0.06728527f, -0.06298236f, -0.04389882f, -0.03829076f, 0.03419770f, -0.04293809f, 
    -0.04901912f, -0.05497299f, -0.04916751f, -0.01365235f, 0.03632176f, 0.01934548f, 0.01065286f, 0.00234201f, 
    -0.04868500f, 0.00648770f, -0.07123902f, -0.01781575f, 0.01817807f, 0.03177692f, 0.04691408f, 0.00781737f, 
    -0.00440376f, 0.02350512f, -0.00946890f, -0.00829138f, 0.00937565f, 0.01484414f, 0.00556602f, -0.03686799f, 
    -0.02768411f, 0.00698350f, 0.00215930f, 0.03600338f, -0.02510087f, -0.02096250f, 0.00202997f, -0.04266808f, 
    -0.01470381f, -0.04062889f, -0.04010472f, -0.01479157f, -0.02474413f, 0.05156359f, 0.03530474f, 0.04383091f, 
    -0.05236373f, -0.05824978f, -0.05251526f, -0.01982209f, 0.00352656f, 0.01373471f, -0.02234573f, 0.01238961f, 
    -0.01536387f, -0.03235315f, 0.05159950f, 0.02132693f, 0.03286725f, 0.04743824f, 0.04092670f, -0.04339588f, 
    0.04742397f, 0.01747972f, -0.04121764f, -0.00969504f, 0.02500322f, -0.05633654f, 0.03785929f, 0.03920594f, 
    -0.01692423f, -0.03558989f, 0.01534042f, 0.02192022f, -0.02104441f, 0.02216364f, -0.04639078f, 0.02016263f, 
    0.02584399f, -0.04821918f, 0.00738107f, 0.03129977f, -0.02091548f, -0.06245351f, 0.00597830f, 0.00059393f, 
    0.03265117f, -0.06621668f, 0.04224465f, -0.04592873f, -0.03893607f, -0.00780637f, 0.01689516f, -0.04918006f, 
    -0.00919844f, -0.04001546f, -0.05599694f, -0.04004107f, -0.04641345f, -0.06174886f, -0.02844074f, -0.06580088f, 
    -0.02966432f, 0.00943419f, 0.01762466f, -0.02964645f, -0.05855607f, -0.04091972f, -0.04880866f, 0.02591480f, 
    -0.01509751f, -0.06143008f, 0.02185148f, -0.03387967f, -0.01944891f, -0.04466059f, -0.00991359f, -0.05746814f, 
    -0.04708349f, 0.02336097f, 0.00917118f, -0.04225248f, -0.04305565f, -0.05041665f, 0.00134050f, 0.01377152f, 
    -0.01079015f, -0.01670692f, -0.01189225f, 0.03886430f, -0.04286134f, -0.02769006f, -0.05762868f, -0.00786189f, 
    0.00383714f, 0.02726156f, -0.00370563f, -0.03203775f, -0.04666066f, -0.01325785f, -0.01221518f, -0.06436693f, 
    -0.03402329f, 0.05337416f, -0.01457345f, -0.01426786f, -0.03632658f, -0.01540492f, -0.02741175f, 0.00392271f, 
    -0.03213296f, -0.02242805f, -0.02128318f, 0.00735445f, -0.03362909f, 0.02981540f, -0.04095985f, -0.05513136f, 
    -0.04297720f, -0.01733357f, -0.03304896f, 0.02570925f, -0.05804282f, -0.00346099f, 0.03267080f, 0.01805509f, 
    -0.04004722f, -0.03692837f, 0.05241260f, -0.05744007f, -0.04598292f, -0.02386574f, 0.04029005f, -0.06781461f, 
    -0.00588748f, 0.04691813f, -0.03824041f, -0.00240254f, 0.04663989f, -0.05377537f, 0.03178826f, -0.03100734f, 
    -0.04390778f, -0.05954750f, -0.01407694f, -0.05759336f, -0.00742840f, -0.02342427f, -0.05156062f, -0.06103250f, 
    -0.05314267f, -0.04560138f, 0.04568686f, -0.04991787f, 0.02348718f, -0.02419921f, -0.02289944f, 0.01254458f, 
    -0.02887660f, -0.03551313f, -0.05951272f, 0.02097489f, 0.00728591f, -0.05586066f, 0.01052546f, -0.04566561f, 
    0.03839541f, -0.01606200f, 0.05432833f, -0.00436927f, 0.02568002f, 0.01111711f, -0.01906403f, -0.00636625f, 
    -0.03018798f, -0.04646074f, 0.03047542f, -0.05262670f, -0.05545890f, 0.03606166f, -0.05213340f, -0.04027276f, 
    -0.01415250f, -0.00490381f, -0.00786679f, -0.00619359f, 0.03213481f, 0.02240963f, -0.02671405f, -0.00417463f, 
    -0.06035202f, -0.02522326f, 0.00662102f, 0.01043209f, -0.03106388f, -0.00246630f, 0.01472550f, -0.00192414f, 
    -0.00584565f, 0.04395959f, 0.03176743f, -0.02126899f, -0.01532678f, -0.02304294f, -0.03826793f, -0.01834335f, 
    -0.01841895f, 0.03015248f, -0.03889571f, -0.06021506f, -0.04672503f, -0.06046417f, -0.06106596f, 0.00074039f, 
    0.04666246f, 0.01797850f, -0.04306432f, -0.02923352f, 0.03136168f, 0.00780329f, 0.02605010f, 0.02676571f, 
    -0.03577071f, -0.04222388f, -0.04783024f, -0.04001484f, 0.03762415f, -0.01893772f, -0.07032483f, -0.02682549f, 
    0.04060699f, -0.03250571f, 0.01573333f, -0.02434072f, -0.02002695f, 0.03843514f, -0.03898217f, 0.03765371f, 
    -0.04789082f, 0.03943774f, 0.01553364f, 0.03087079f, 0.04132165f, 0.02262540f, 0.03067972f, -0.06377447f, 
    -0.03498698f, -0.03322527f, -0.04060146f, -0.02404134f, -0.04382219f, -0.01475385f, -0.04299026f, -0.02406005f, 
    0.36859947f, 0.39574701f, -0.20115650f, 0.13128044f, 0.02975555f, 0.03994952f, -0.01466186f, -0.29435617f, 
    -0.14684737f, -0.09923646f, 0.00702842f, 0.17799091f, 0.07342553f, 0.01652115f, -0.22613655f, 0.17056510f, 
    0.16669436f, -0.03308773f, -0.06140523f, 0.14155912f, 0.22907548f, 0.06566193f, -0.01423392f, 0.00220508f, 
    -0.10320877f, -0.08335061f, -0.16235462f, 0.19693002f, -0.00508474f, -0.00574939f, -0.06266161f, -0.02277569f, 
    0.03342065f, -0.06180967f, 0.07312872f, 0.04164976f, -0.26243222f, 0.20442538f, -0.00273563f, 0.16389039f, 
    0.14059682f, 0.04907229f, -0.01475280f, 0.18359855f, 0.07694770f, 0.22847235f, 0.16518882f, -0.00701017f, 
    -0.05230514f, 0.00337123f, -0.13496470f, -0.10221967f, -0.02279225f, -0.02111596f, 0.22347099f, -0.30238265f, 
    -0.20298882f, -0.00976742f, 0.00772426f, 0.07485395f, 0.05356516f, 0.11577941f, -0.05539883f, 0.03057040f, 
    0.19736676f, -0.11490341f, 0.07932691f, 0.15352157f, 0.21869618f, -0.23967129f, -0.22753227f, -0.02245614f, 
    -0.15696192f, -0.43503103f, 0.27713931f, -0.09026093f, 0.15905240f, 0.01884585f, 0.16103777f, 0.03456868f, 
    0.20939602f, -0.35325104f, 0.09058422f, -0.25220513f, 0.11675015f, 0.11504659f, 0.01323568f, -0.06130148f, 
    0.28986752f, 0.06067792f, -0.15070656f, 0.30104023f, 0.03473700f, -0.01093746f, -0.17958146f, -0.00155194f, 
    0.16845693f, 0.02929601f, -0.16118431f, 0.09105530f, 0.15520373f, 0.39060730f, -0.08723951f, -0.07428949f, 
    -0.14036736f, -0.11173079f, 0.09363119f, 0.05349572f, -0.57146156f, -0.04602063f, 0.05631384f, 0.09063836f, 
    0.09929577f, -0.35770532f, 0.19916360f, -0.01189792f, 0.02746614f, -0.04331559f, 0.07328498f, 0.16381575f, 
    0.23202211f, -0.02897183f, -0.08393355f, -0.01257510f, 0.11864434f, -0.13443308f, -0.18305123f, 0.04131300f, 
    -0.01984090f, 0.00544569f, 0.10623542f, 0.01515465f, -0.12736115f, -0.29436979f, -0.01350540f, -0.23034903f, 
    -0.18224645f, 0.34332040f, 0.01273530f, -0.05940719f, 0.10459841f, 0.12690274f, 0.10048588f, -0.07664113f, 
    -0.29790863f, -0.46419722f, -0.13655676f, -0.09426955f, 0.06246751f, 0.12137110f, 0.17122731f, -0.17402709f, 
    0.00696601f, -0.30945718f, -0.16590263f, 0.09855157f, 0.06126518f, 0.15553080f, 0.03095643f, -0.03362063f, 
    -0.02135623f, 0.02348485f, 0.10623724f, 0.13075632f, 0.03504596f, -0.13256139f, -0.09260739f, -0.08424467f, 
    -0.00136447f, 0.01449524f, 0.22807997f, 0.24153049f, 0.31462029f, 0.01194849f, -0.03021869f, -0.08850310f, 
    -0.09874591f, -0.13360550f, 0.18095313f, 0.00638328f, 0.04089060f, 0.13200782f, -0.40330523f, 0.18387797f, 
    0.13104352f, 0.02995058f, -0.19315028f, -0.12950498f, -0.14954665f, 0.06898443f, -0.04339254f, 0.02431688f, 
    0.00437985f, -0.02526094f, 0.10659446f, 0.02707129f, 0.04467977f, -0.07861495f, -0.25797904f, -0.10007545f, 
    -0.04798948f, 0.10343386f, -0.01856594f, -0.15177904f, 0.00001228f, -0.10671431f, 0.08209842f, -0.06843323f, 
    0.00376279f, -0.28738257f, 0.05576351f, -0.12414221f, 0.01096888f, 0.00493176f, 0.10580453f, 0.15957852f, 
    -0.55199152f, 0.08591536f, -0.17268781f, 0.06005852f, 0.14735845f, -0.12724923f, 0.03393471f, 0.11973217f, 
    -0.06642256f, 0.20784104f, 0.15040457f, 0.00580461f, -0.25582618f, -0.05417307f, -0.05926860f, -0.04304235f, 
    0.21965010f, 0.30100721f, -0.15027162f, 0.07109661f, -0.05516891f, 0.15892774f, 0.20020515f, 0.14460507f, 
    0.11968680f, 0.19109814f, -0.04547682f, 0.18555938f, -0.04904075f, 0.25629839f, -0.21286634f, 0.18230805f, 
    -0.00953995f, -0.07783277f, -0.03076024f, -0.26419154f, 0.17120081f, 0.17176774f, -0.07504795f, -0.00645152f, 
    -0.00751430f, -0.01836634f, 0.11612401f, -0.04702822f, 0.05068184f, 0.28834698f, 0.20141557f, -0.17128162f, 
    0.18592642f, -0.01161163f, -0.01236640f, 0.00341101f, -0.04942274f, -0.02716785f, 0.20473881f, 0.25781634f, 
    0.18499790f, 0.05949261f, 0.02891463f, -0.09657016f, 0.09524406f, -0.09035192f, -0.09834091f, 0.03069907f, 
    -0.06219494f, 0.20217778f, -0.19834502f, 0.25813410f, -0.01004878f, -0.04841463f, 0.07080290f, -0.21037674f, 
    0.05429041f, -0.14440009f, 0.24322070f, 0.06360780f, -0.04129465f, 0.10254367f, -0.06198369f, 0.10270686f, 
    0.10452879f, -0.32125220f, -0.08642370f, -0.58262241f, -0.01875514f, -0.04094001f, 0.06609868f, -0.01750420f, 
    0.10454681f, 0.14236780f, 0.00158814f, 0.40935120f, -0.16649082f, -0.08162054f, -0.25381780f, 0.13253587f, 
    0.14036930f, 0.17814869f, 0.12464324f, -0.24116272f, 0.05062398f, -0.18244638f, 0.00300488f, 0.08878568f, 
    0.13774748f, 0.06797072f, 0.02695332f, 0.24808529f, -0.25921667f, -0.47879976f, 0.52183735f, 0.05568164f, 
    0.19500285f, -0.29745170f, 0.03379976f, 0.05133594f, 0.00356741f, -0.23096783f, -0.17399107f, 0.06643218f, 
    -0.07098434f, 0.18597239f, -0.02747171f, 0.14472698f, 0.04537120f, -0.14233731f, -0.05135059f, 0.19317389f, 
    -0.11471562f, 0.06956980f, 0.05174322f, 0.10397611f, -0.01129287f, -0.08936624f, -0.02002079f, 0.06988532f, 
    -0.13183188f, 0.24917260f, -0.23729163f, -0.25628138f, -0.12734444f, -0.11067793f, -0.08235145f, -0.00737404f, 
    0.16808452f, -0.50483918f, -0.13731802f, -0.10466076f, 0.01589575f, 0.11324313f, -0.11890852f, 0.32161289f, 
    0.21338588f, -0.36331135f, -0.15852296f, 0.57911819f, -0.24195099f, -0.00671444f, -0.13325365f, -0.03639078f, 
    0.02556568f, 0.05373977f, -0.35923228f, 0.04433873f, -0.03776560f, -0.06401496f, -0.20607889f, -0.18852748f, 
    0.08101396f, 0.19451007f, 0.02116669f, 0.18587533f, 0.24823822f, -0.40974331f, 0.15495495f, 0.23650207f, 
    0.06619530f, 0.01084580f, 0.08695982f, -0.25313357f, -0.13486250f, -0.49887469f, 0.31157565f, -0.20171340f, 
    -0.30615908f, -0.03849759f, 0.12306536f, 0.11389422f, 0.19303237f, 0.16616207f, -0.06705930f, 0.03805618f, 
    0.10474527f, 0.14609127f, 0.09593537f, 0.06092741f, 0.20042354f, 0.31037754f, 0.09529483f, 0.42187843f, 
    -0.01424339f, -0.17987323f, -0.04246162f, 0.02411598f, -0.11275384f, 0.00908621f, 0.17158794f, 0.19821382f, 
    -0.35846061f, -0.28650209f, -0.04779307f, -0.19513023f, -0.05439834f, -0.03536917f, -0.05598506f, 0.19729558f, 
    -0.17712149f, -0.09149660f, 0.02259543f, -0.04688979f, 0.20071518f, 0.05895871f, 0.17196205f, -0.02937090f, 
    0.15348884f, -0.23207593f, -0.05901991f, 0.00235682f, -0.01599718f, -0.00748891f, -0.07162440f, 0.02879894f, 
    0.08533804f, 0.04109360f, 0.05583940f, 0.01631825f, -0.30047986f, 0.10182749f, 0.08358501f, -0.14180577f, 
    -0.25375098f, -0.10433347f, -0.01562689f, 0.27652302f, 0.37985459f, -0.48482254f, -0.09400439f, -0.05948410f, 
    0.03073885f, 0.00354371f, -0.10038798f, -0.06585980f, -0.20897080f, -0.03958530f, 0.08359199f, -0.00456580f, 
    -0.06305766f, 0.14411810f, -0.22369023f, -0.02814009f, -0.14070410f, -0.05161276f, 0.09181565f, -0.11605564f, 
    0.13132228f, 0.10214227f, -0.08670403f, 0.06438387f, 0.00826679f, 0.15633018f, -0.19985567f, -0.15264390f, 
    -0.04746252f, -0.01938956f, 0.13142118f, -0.13919182f, -0.09719691f, -0.06044801f, 0.10573277f, 0.15176140f, 
    0.12297729f, -0.00510664f, 0.01425556f, 0.07682095f, -0.01123954f, 0.06896017f, -0.14245619f, 0.25375873f, 
    0.02285250f, -0.12930575f, 0.38990170f, -0.05971247f, 0.03614784f, 0.02609969f, -0.03108038f, 0.02775150f, 
    0.17827623f, -0.07330080f, 0.13089497f, -0.30085886f, -0.04855969f, 0.09320543f, -0.03116490f, 0.20616293f, 
    0.27491587f, -0.20753254f, 0.41074470f, 0.06034742f, 0.03165464f, 0.04704561f, 0.05747607f, -0.05207864f, 
    0.08192134f, 0.15428051f, 0.15260068f, -0.27604383f, -0.53295356f, 0.00472207f, 0.07881560f, -0.31626594f, 
    -0.04318676f, 0.04642170f, -0.03255114f, 0.01084726f, -0.27872887f, 0.37015119f, -0.18298179f, 0.22103833f, 
    -0.02252480f, -0.05928181f, -0.06287818f, -0.10820071f, -0.08450639f, 0.08147975f, 0.21562123f, -0.19449836f, 
    0.04311763f, -0.05505702f, -0.09833059f, -0.05939881f, -0.11488340f, -0.05812311f, 0.10350894f, 0.26523861f, 
    -0.11735882f, 0.14548443f, 0.00088406f, 0.15637130f, 0.00189529f, -0.04739726f, 0.00402911f, -0.18724856f, 
    0.06230918f, -0.07789627f, 0.12408093f, -0.02248779f, 0.09402076f, 0.12181413f, -0.10421940f, 0.04358799f, 
    0.21597336f, -0.23965503f, -0.13660376f, 0.12909083f, 0.09312472f, 0.14483650f, -0.00779070f, 0.04073787f, 
    -0.04025603f, 0.22120947f, -0.14942500f, 0.38065270f, -0.07802384f, -0.07263797f, 0.15901442f, 0.03909863f, 
    -0.05254371f, 0.10091899f, 0.06122228f, -0.07062145f, -0.26717401f, 0.18861550f, -0.00062891f, 0.02448832f, 
    -0.06756905f, -0.13555989f, -0.06765291f, 0.44828033f, 0.22695559f, 0.31031528f, 0.04130148f, -0.01281049f, 
    0.10857614f, 0.22590001f, -0.23493381f, 0.06715621f, 0.16226113f, -0.28647652f, 0.07686759f, -0.38515481f, 
    -0.06616730f, 0.10290562f, 0.22578740f, 0.12437674f, 0.03357814f, -0.48086834f, -0.22454341f, 0.19348146f, 
    -0.03183808f, 0.11831468f, 0.07029598f, -0.07885677f, 0.24502285f, -0.12578443f, 0.22016232f, 0.13419195f, 
    -0.27731103f, -0.02618835f, 0.18817678f, 0.11316223f, 0.17313975f, 0.07907069f, 0.20951362f, 0.27868402f, 
    -0.21355948f, -0.24542560f, 0.03300869f, -0.07472233f, 0.15766934f, -0.05975611f, 0.02176037f, -0.07628036f, 
    -0.21181443f, -0.03913484f, -0.18980645f, -0.14514500f, -0.09677734f, 0.17638215f, -0.07984691f, 0.07351082f, 
    -0.09772356f, 0.31948745f, -0.09209329f, 0.06086125f, -0.22994527f, 0.05916064f, 0.03823131f, 0.16314162f, 
    0.04611656f, 0.08791842f, 0.18466970f, -0.09816058f, -0.00724323f, 0.18441981f, -0.10985044f, 0.14883634f, 
    0.18397249f, 0.11732236f, -0.14298467f, -0.00732474f, -0.12677464f, 0.15740289f, 0.14931637f, 0.08075640f, 
    -0.20648837f, -0.11086988f, 0.09525499f, 0.04325963f, 0.19956237f, -0.20171879f, 0.05581291f, -0.08991005f, 
    0.08882394f, -0.03215910f, 0.01705031f, -0.02439970f, -0.00845229f, -0.37420014f, -0.08942185f, 0.22541223f, 
    0.06702400f, -0.02076535f, 0.15643924f, -0.11370312f, -0.17231220f, -0.06883515f, -0.20007887f, -0.07142142f, 
    -0.01255160f, -0.11399312f, 0.04698244f, -0.14500220f, 0.06820373f, -0.12497026f, -0.07693654f, -0.30970022f, 
    -0.15534951f, -0.00414122f, 0.07229875f, -0.24189581f, -0.02607473f, -0.06916377f, 0.08276194f, -0.11098554f, 
    0.24069403f, -0.15356779f, 0.11946774f, 0.06598184f, 0.17667754f, 0.08600445f, 0.04227276f, 0.06468049f, 
    0.16639610f, 0.14060986f, 0.14332500f, -0.12410963f, -0.19753948f, -0.09979961f, 0.02993103f, 0.03593412f, 
    0.09162586f, 0.06076197f, -0.07344573f, -0.05655714f, 0.28307590f, 0.21728984f, 0.11691169f, -0.04248416f, 
    0.14366393f, 0.02756540f, 0.01326517f, 0.25831443f, -0.18036106f, -0.13606755f, -0.18134615f, 0.26054701f, 
    -0.06529958f, 0.08756582f, -0.15154901f, -0.04038743f, 0.04992915f, -0.30386087f, -0.22932187f, -0.06179712f, 
    0.03397394f, 0.09987941f, -0.18266295f, 0.01135570f, -0.22645214f, -0.51724374f, -0.22153091f, 0.41897511f, 
    -0.02272679f, 0.23312479f, 0.10433949f, 0.03821828f, -0.09226354f, 0.05172871f, 0.19990772f, 0.23941080f, 
    -0.03260493f, -0.21756946f, -0.08157986f, 0.03459404f, 0.02497204f, 0.34085158f, 0.16475374f, 0.18953109f, 
    0.12575576f, 0.28238264f, 0.12385901f, -0.14598852f, 0.09776676f, 0.04090432f, -0.05906970f, -0.01047207f, 
    0.16367637f, -0.32968271f, 0.08333563f, -0.08604155f, 0.13469420f, -0.10022835f, 0.12385374f, 0.07867569f, 
    -0.05426312f, 0.03629179f, -0.00800162f, 0.24198459f, 0.09060636f, 0.04542505f, -0.01151364f, -0.00705742f, 
    0.10209550f, 0.07491907f, -0.59045100f, -0.18476866f, 0.05184070f, -0.06513643f, 0.08398814f, -0.00456301f, 
    -0.05151525f, 0.04666046f, -0.07695609f, 0.17532986f, -0.04322682f, 0.02026894f, 0.04753748f, 0.02976317f, 
    0.21626595f, -0.08722144f, 0.03665226f, -0.05777854f, -0.17768781f, -0.11096206f, 0.23691060f, -0.01202647f, 
    0.18691131f, 0.00229818f, 0.10559671f, -0.03368683f, -0.06931283f, -0.01424645f, -0.01959118f, -0.04837155f, 
    0.05939046f, 0.19378409f, -0.11343282f, 0.11747349f, 0.10263124f, -0.04701050f, -0.35603720f, -0.24181178f, 
    0.22100703f, -0.01416280f, -0.11719716f, 0.12163077f, 0.26647845f, -0.10412639f, -0.01514954f, -0.13960113f, 
    -0.19298692f, 0.21595462f, -0.07702976f, 0.03685346f, -0.00573230f, 0.14577776f, 0.01689566f, 0.06100954f, 
    -0.06623180f, -0.02834762f, -0.00356267f, -0.02077396f, 0.01436690f, 0.03640726f, -0.00341337f, 0.01435421f, 
    -0.05609893f, 0.02474570f, -0.05272793f, 0.04052450f, -0.00047648f, 0.04930051f, -0.01215183f, -0.04418974f, 
    0.00667142f, -0.00617999f, 0.01411711f, -0.04217913f, 0.03193287f, 0.05269338f, -0.04372835f, 0.01092721f, 
    -0.00203235f, -0.05399965f, -0.01310539f, 0.01592503f, -0.02503501f, 0.01490882f, -0.01519259f, -0.02982955f, 
    0.04784969f, -0.02508336f, -0.00404825f, -0.03587023f, 0.02948738f, 0.03412623f, -0.00319585f, -0.03066591f, 
    0.00943223f, 0.04150545f, 0.01753958f, 0.03548626f, -0.01030116f, 0.04719672f, 0.01564145f, 0.03527785f, 
    -0.01480864f, 0.00556802f, -0.03427345f, -0.01273378f, 0.04416366f, -0.01693173f, 0.01403267f, 0.04275189f, 
    0.04337962f, -0.05738474f, 0.01802935f, 0.00235990f, -0.02381638f, 0.01580798f, -0.03087546f, -0.01098968f, 
    -0.00489409f, -0.04013453f, 0.01730578f, -0.00096776f, 0.04656746f, -0.04791325f, 0.04230923f, -0.06235027f, 
    -0.06019135f, 0.03834962f, 0.03169785f, -0.01329056f, 0.00414387f, -0.05790362f, 0.05294575f, 0.03303216f, 
    0.05065295f, -0.03562691f, -0.03753108f, -0.02871628f, 0.04050686f, -0.03730740f, -0.05528133f, 0.04837598f, 
    0.03750093f, -0.05113392f, -0.04105530f, -0.04189898f, -0.01344335f, -0.00638047f, -0.01324963f, 0.03341991f, 
    -0.05511435f, -0.03554891f, 0.03096497f, -0.02363320f, -0.03096760f, 0.03028740f, -0.01575565f, -0.04247041f, 
    -0.02384232f, 0.04824534f, 0.02322601f, 0.04596327f, 0.00716698f, 0.03387886f, -0.06789783f, -0.00827852f, 
    -0.02826086f, -0.05303493f, -0.00097987f, -0.02352227f, 0.04363982f, 0.02897615f, -0.02699758f, -0.01757612f, 
    -0.01510744f, 0.05282518f, -0.03611796f, -0.01252272f, -0.05388685f, -0.05595924f, 0.00819176f, -0.01692660f, 
    -0.00342738f, -0.03233629f, -0.03300859f, -0.01689416f, 0.04416358f, -0.00271392f, 0.00342260f, 0.00476809f, 
    -0.06110511f, -0.05059374f, -0.03636058f, -0.00321563f, 0.01759457f, 0.00086215f, -0.00954772f, -0.01184725f, 
    -0.06404899f, 0.04007924f, 0.03646893f, 0.02051217f, -0.05023829f, -0.00392811f, -0.05809899f, -0.03331014f, 
    -0.06531044f, -0.00113005f, 0.04190261f, -0.02190136f, -0.06124288f, -0.04460349f, -0.01698882f, 0.01708492f, 
    -0.03689038f, -0.03743386f, -0.02387039f, -0.05780623f, 0.00723868f, -0.04111004f, -0.04178731f, -0.00191679f, 
    0.02417635f, -0.03622524f, -0.02524827f, -0.06850817f, -0.06396874f, -0.01808616f, -0.05457791f, -0.02991799f, 
    0.00417199f, -0.00319446f, -0.02671348f, 0.02500494f, -0.01349387f, -0.03273770f, -0.06068087f, -0.06215084f, 
    -0.05490802f, -0.04260127f, -0.00559512f, -0.04202119f, -0.01773878f, -0.00249873f, -0.01463375f, 0.03977100f, 
    -0.01759746f, -0.01650214f, 0.02265354f, 0.03266060f, 0.04435435f, 0.04190302f, 0.02539462f, 0.01492191f, 
    -0.05887306f, -0.04919449f, 0.03063462f, -0.00500177f, -0.04797807f, -0.05073866f, 0.01153130f, 0.03910063f, 
    -0.01046479f, 0.05142384f, -0.06021982f, -0.01074960f, -0.03389339f, -0.05533946f, -0.05453535f, 0.02337898f, 
    0.01513797f, -0.00440448f, 0.02869776f, -0.01456604f, -0.04127196f, 0.01320385f, -0.03141072f, -0.03833541f, 
    0.01743174f, 0.03734552f, 0.00789853f, 0.03438818f, 0.00717350f, -0.02332832f, 0.04283068f, -0.03304977f, 
    -0.05964426f, 0.00177483f, -0.02219861f, -0.04505463f, -0.04044620f, 0.01454017f, -0.05184929f, -0.05316834f, 
    -0.03988123f, -0.03232877f, -0.05388936f, 0.05373278f, 0.04118754f, -0.02034453f, 0.03055632f, -0.01310760f, 
    -0.01989453f, 0.01764168f, -0.01493174f, -0.00915096f, -0.01364510f, 0.03959969f, -0.03744194f, 0.01662739f, 
    0.04118922f, -0.04083363f, -0.03064047f, 0.02817897f, 0.00100872f, -0.05453941f, -0.02818969f, 0.04133125f, 
    -0.01180820f, -0.00915468f, -0.05739890f, -0.04726942f, -0.04122280f, -0.05614409f, -0.06572735f, -0.03914859f, 
    0.04949135f, 0.03101226f, -0.00303890f, -0.02726816f, -0.04859781f, -0.04547559f, -0.00349223f, 0.04968663f, 
    -0.06462651f, -0.04029809f, -0.01249815f, 0.00711927f, 0.03739157f, 0.01797472f, 0.03200174f, 0.02786425f, 
    -0.08569418f, 0.11042523f, 0.13692865f, 0.06126356f, 0.04549351f, 0.16304027f, 0.07214524f, 0.03456602f, 
    0.15221015f, 0.12385717f, 0.14668246f, 0.25217310f, 0.03298612f, 0.24743074f, -0.30381280f, 0.06638750f, 
    0.03153423f, 0.27513912f, 0.20867297f, -0.02138518f, -0.02574435f, -0.06392633f, 0.05890452f, 0.13393167f, 
    0.09030083f, 0.02463150f, -0.09031525f, 0.35017207f, 0.15335019f, -0.10418150f, -0.09102642f, 0.03845978f, 
    -0.13111259f, 0.05870793f, 0.22301917f, 0.03478516f, -0.51812083f, 0.02236874f, 0.08871222f, 0.35929766f, 
    0.18219304f, -0.05117352f, 0.00305432f, 0.04574262f, 0.14144562f, -0.35273194f, 0.25360104f, 0.26906389f, 
    0.00227042f, 0.07995622f, 0.06870341f, 0.05775525f, 0.00533084f, -0.07093369f, -0.05574114f, 0.21074483f, 
    0.15608786f, -0.14959835f, 0.01306245f, 0.33246335f, -0.14685142f, 0.01973259f, -0.05673084f, -0.31532636f, 
    -0.23676197f, -0.06157208f, 0.19970344f, 0.10456944f, 0.03606921f, 0.01349411f, -0.13977638f, -0.01371148f, 
    0.25688142f, -0.07711588f, -0.28414682f, -0.14530735f, -0.03733948f, -0.03866489f, -0.08289162f, -0.01577675f, 
    0.07507975f, -0.38717291f, -0.17673282f, 0.13791142f, 0.22145142f, 0.10694296f, -0.11838607f, -0.10215499f, 
    0.03741222f, 0.11587917f, -0.06729049f, 0.02971446f, -0.33715749f, -0.12226695f, -0.12360039f, -0.08652883f, 
    -0.10621504f, -0.03661006f, -0.15593375f, -0.06810284f, -0.15061489f, 0.03662623f, -0.21719901f, 0.16104394f, 
    -0.09553844f, 0.04281988f, 0.02602300f, 0.06380660f, -0.20188487f, -0.04915853f, -0.40217435f, 0.05402435f, 
    0.09281050f, 0.13942423f, 0.35412806f, -0.03730752f, -0.10748575f, 0.01899584f, 0.29364321f, 0.22655815f, 
    0.16339384f, 0.12038650f, 0.13781501f, 0.16337205f, 0.19165048f, 0.00345375f, 0.19659902f, 0.09980100f, 
    -0.15350905f, -0.00025307f, 0.07212861f, -0.22673385f, -0.01213362f, -0.19374198f, -0.27902079f, -0.05036137f, 
    -0.33104017f, -0.16587600f, 0.05043625f, 0.03289203f, 0.12240132f, 0.00539641f, -0.10619392f, 0.02254076f, 
    -0.33481932f, -0.22977014f, -0.41161537f, 0.03715923f, 0.13313991f, 0.14946790f, 0.03816336f, -0.13174620f, 
    -0.05273856f, -0.16518834f, -0.07015640f, 0.05100073f, 0.10069235f, 0.16092478f, -0.12346669f, 0.01480718f, 
    -0.13152747f, 0.10043436f, -0.16704939f, 0.12862395f, 0.18322422f, -0.15980385f, -0.06251042f, -0.03044457f, 
    -0.09538929f, -0.00634863f, -0.14927551f, -0.39571691f, -0.03120097f, 0.14174590f, -0.11772230f, 0.04603094f, 
    -0.15539718f, 0.01775604f, 0.03535319f, 0.04008649f, -0.34497887f, 0.18321829f, 0.17063807f, 0.20588514f, 
    0.11594132f, 0.18310998f, -0.09782081f, 0.10435248f, -0.02094946f, -0.06300012f, 0.13762522f, 0.22624293f, 
    0.10119348f, 0.25147161f, -0.15927216f, 0.10432232f, 0.07694545f, 0.04737586f, -0.00577239f, -0.07150712f, 
    -0.13744812f, 0.34795889f, 0.08244068f, 0.16181654f, -0.04888178f, -0.01102232f, 0.10851456f, -0.02250974f, 
    -0.06396025f, 0.06372302f, 0.03318996f, -0.05412008f, 0.13702729f, 0.01500360f, -0.05645733f, -0.22259369f, 
    -0.21958411f, -0.38143182f, -0.16138978f, 0.12118527f, 0.20694856f, -0.01035318f, 0.03711738f, -0.18472369f, 
    0.07238091f, -0.13483559f, -0.02007873f, 0.16630755f, -0.17834160f, 0.13385697f, 0.05273866f, 0.03569728f, 
    0.02066390f, 0.18491296f, -0.34026721f, 0.22324696f, 0.18691151f, 0.15049475f, -0.05869455f, 0.13334469f, 
    -0.04464947f, 0.03278692f, 0.01646358f, -0.68134904f, -0.09855375f, -0.04155765f, 0.16271585f, 0.05997063f, 
    0.07562842f, 0.11684221f, -0.10643156f, -0.04931961f, -0.28792772f, 0.09772483f, 0.35620213f, 0.21430729f, 
    -0.08425147f, 0.04750514f, -0.11855473f, 0.02656504f, -0.16928011f, -0.14620703f, -0.14079842f, 0.03726325f, 
    0.06453728f, -0.00207514f, 0.09305880f, -0.00504088f, 0.03839426f, 0.14871588f, -0.13464776f, 0.24863514f, 
    0.20302579f, -0.24227302f, 0.09844439f, -0.04309691f, -0.07643670f, 0.07769312f, 0.03550180f, 0.15595099f, 
    0.20286016f, 0.13160169f, 0.09602064f, 0.10185964f, -0.02931704f, -0.02729812f, -0.13491869f, -0.16268253f, 
    0.04640432f, -0.12955549f, 0.21766886f, 0.08234975f, 0.08501689f, 0.00441927f, -0.04529467f, 0.21018526f, 
    0.16766742f, -0.08009446f, 0.39063430f, -0.22942486f, -0.03247168f, -0.28361663f, 0.06423432f, -0.05787857f, 
    0.12054093f, 0.00031462f, 0.24944672f, -0.04160538f, -0.07949207f, 0.14283374f, 0.06250554f, 0.17069137f, 
    -0.15009880f, -0.01620939f, 0.12243304f, 0.37324029f, -0.19692422f, -0.10400721f, 0.24224713f, -0.02957688f, 
    0.08413155f, 0.03503475f, 0.21366076f, 0.24745852f, -0.11792874f, 0.04866903f, 0.50441384f, 0.09529854f, 
    -0.15769750f, 0.00198623f, 0.04473673f, 0.05930304f, 0.05082755f, -0.05380787f, 0.20762675f, -0.17187546f, 
    -0.02436470f, -0.08897370f, -0.06739813f, -0.09437747f, 0.01934801f, -0.26705897f, 0.09259544f, -0.02322571f, 
    -0.16367424f, 0.03689504f, -0.21882100f, 0.24863189f, -0.03019101f, -0.06806199f, -0.02441519f, 0.35683644f, 
    0.07257006f, 0.01489445f, 0.14901881f, -0.00703181f, 0.21164054f, -0.15029915f, 0.03945106f, 0.10493149f, 
    0.12832969f, -0.21324573f, -0.32067406f, -0.12543565f, -0.10314459f, -0.01404971f, 0.06992917f, -0.13372083f, 
    0.16864298f, 0.10785852f, -0.14841713f, 0.35834077f, 0.13277631f, -0.04503530f, 0.11218298f, 0.09217857f, 
    -0.12295325f, 0.13605060f, 0.44010183f, -0.23895031f, -0.05945932f, -0.01295981f, 0.11028650f, 0.06646254f, 
    -0.09137060f, -0.17501551f, 0.05562231f, -0.36806932f, -0.00698954f, -0.37429413f, -0.12477362f, 0.03136542f, 
    -0.43048877f, -0.11734126f, 0.12536927f, -0.21865661f, 0.05518698f, 0.03632833f, 0.05725507f, -0.10371576f, 
    -0.06872416f, 0.20563507f, 0.04932468f, -0.09622987f, 0.08177962f, 0.39486933f, 0.21125434f, -0.04285480f, 
    -0.15301090f, 0.02546363f, 0.10342389f, -0.04903466f, -0.17357783f, -0.12523820f, -0.06627510f, 0.00079055f, 
    0.06904621f, 0.03318991f, 0.21314999f, 0.04927469f, 0.01193579f, -0.19719046f, -0.11133748f, 0.08120681f, 
    0.07629056f, -0.23347516f, 0.05590747f, 0.14910808f, 0.12656610f, 0.11796924f, -0.18526231f, 0.05956827f, 
    0.09686147f, -0.00369669f, -0.23976436f, -0.00709917f, 0.09346852f, 0.05650369f, -0.03160802f, 0.03707734f, 
    -0.20698549f, -0.38360488f, 0.03233702f, 0.24218887f, 0.17872651f, -0.03422831f, 0.07048737f, 0.05806638f, 
    -0.08355244f, -0.30344060f, -0.14958687f, 0.07215577f, -0.08772429f, -0.10489272f, -0.26783493f, -0.23677550f, 
    -0.17203146f, -0.00644613f, -0.04080429f, 0.21656519f, 0.30725265f, -0.13720182f, -0.32917449f, 0.07442186f, 
    0.06365269f, -0.13205698f, 0.01786256f, 0.12511155f, -0.01026549f, 0.20577843f, 0.38623857f, 0.05627868f, 
    -0.03719294f, 0.23829953f, -0.08852419f, 0.15731487f, 0.12007845f, 0.29774144f, 0.07386288f, -0.07596242f, 
    -0.14141028f, -0.05086559f, -0.20765114f, -0.07400928f, -0.15312800f, -0.09855188f, 0.00002389f, -0.20042239f, 
    0.07705147f, 0.14980736f, 0.04267415f, -0.12224434f, -0.05424845f, 0.10935565f, -0.14538723f, -0.14894611f, 
    -0.11476679f, -0.01849737f, -0.04270205f, -0.11377598f, 0.00998220f, -0.05137330f, 0.02535180f, -0.18254599f, 
    0.15740204f, -0.23647329f, 0.06844659f, 0.10443476f, 0.14460082f, -0.02257607f, -0.01660755f, -0.05649776f, 
    0.08464780f, -0.22494106f, 0.16538306f, -0.34930128f, -0.03271416f, 0.15050867f, -0.20310950f, 0.10089727f, 
    0.26990223f, -0.20040011f, 0.11430937f, 0.18353017f, -0.27934363f, -0.30194503f, -0.05866787f, 0.14700967f, 
    0.12294462f, -0.14171979f, 0.12505421f, -0.14682755f, 0.10507525f, 0.29746023f, 0.25335461f, -0.02745616f, 
    0.12614869f, 0.04293314f, -0.08897775f, 0.08418589f, -0.06478494f, 0.22386488f, -0.26865566f, -0.12738459f, 
    -0.15179117f, -0.17527208f, -0.09558286f, 0.21080786f, -0.16697821f, -0.02818299f, 0.23285981f, 0.16857398f, 
    0.01089938f, -0.01761465f, 0.20267172f, -0.10244560f, 0.20959927f, -0.15673433f, 0.12413397f, 0.11200683f, 
    -0.27777261f, -0.12691218f, -0.05846971f, -0.42996290f, -0.17457096f, 0.12122838f, -0.21272635f, 0.30612519f, 
    -0.03355874f, -0.24585176f, 0.08245322f, -0.00970740f, 0.14511490f, -0.14268830f, 0.06672072f, -0.07272390f, 
    0.02082985f, -0.07033688f, -0.03259781f, -0.05950385f, -0.05755973f, -0.07409975f, -0.07343051f, 0.04743714f, 
    -0.00487836f, -0.04734730f, 0.03350569f, 0.00378626f, -0.06112770f, -0.07446849f, -0.02754605f, 0.00509819f, 
    0.03071096f, 0.05292150f, -0.05745893f, -0.02683143f, 0.02769461f, -0.03596878f, -0.04577132f, -0.03200022f, 
    0.03289057f, -0.07099874f, -0.00261413f, -0.02665242f, -0.02776765f, -0.02247161f, -0.08247958f, -0.07733822f, 
    -0.02372214f, -0.06969292f, 0.00251218f, 0.03658427f, -0.03537775f, -0.02724766f, -0.05599495f, -0.02849724f, 
    -0.01213649f, 0.00078147f, -0.03385698f, 0.02623529f, -0.05133148f, -0.03089586f, 0.01202361f, -0.07239573f, 
    -0.05450895f, -0.02444418f, -0.06421687f, -0.03434756f, 0.02357410f, -0.03166850f, -0.05023469f, -0.01714275f, 
    -0.00773318f, -0.06140989f, -0.01635566f, -0.01462981f, 0.01404530f, -0.01154713f, -0.03514671f, -0.03694889f, 
    0.00387174f, -0.03719418f, -0.05127827f, 0.01793022f, 0.01370851f, -0.07378495f, -0.06875449f, 0.00845266f, 
    -0.03310459f, -0.00834407f, -0.00088179f, -0.02215057f, -0.00679508f, -0.00278362f, -0.02391977f, -0.00986661f, 
    -0.01064129f, 0.02450076f, -0.05396188f, -0.05608915f, -0.03873099f, 0.00178437f, -0.00762444f, -0.10384434f, 
    -0.07320870f, -0.02588474f, -0.07444143f, -0.08053138f, 0.05260106f, -0.01261070f, 0.01738328f, 0.00904023f, 
    -0.05049229f, 0.02694792f, -0.07607527f, 0.03391422f, 0.04531776f, -0.02116417f, -0.05348263f, -0.01843841f, 
    -0.03421557f, 0.02716329f, 0.00577859f, -0.00177034f, -0.00354967f, -0.05866083f, 0.02234899f, -0.09153817f, 
    -0.05539223f, 0.02326593f, -0.01665321f, -0.01013489f, -0.05655349f, -0.00864699f, -0.06884966f, 0.00896049f, 
    0.04393009f, -0.06930406f, 0.02743577f, -0.02084019f, 0.01549429f, -0.03960025f, -0.03473173f, 0.04126803f, 
    0.00026916f, 0.00630010f, -0.02487793f, 0.01468764f, -0.05394110f, -0.00701674f, 0.01013689f, 0.06622401f, 
    0.03669287f, -0.01089151f, -0.05366410f, 0.02767846f, 0.01777952f, -0.01330825f, -0.04139531f, -0.01302303f, 
    -0.07274713f, -0.03004597f, -0.03339757f, -0.00147335f, 0.02943309f, -0.02986795f, -0.07865716f, -0.05562288f, 
    -0.02542288f, -0.03304838f, -0.00698409f, -0.01516301f, -0.01309084f, -0.02848434f, -0.03622413f, -0.06172858f, 
    -0.04825920f, -0.03444505f, 0.00806616f, 0.02317346f, 0.02376199f, -0.02598000f, -0.03369959f, 0.01913728f, 
    -0.03758897f, 0.03046922f, -0.01655678f, 0.06087141f, 0.02158597f, -0.00846317f, -0.03694334f, -0.03072459f, 
    0.01942243f, -0.02141847f, 0.01361253f, -0.01739069f, 0.01839076f, 0.01466950f, 0.06294313f, -0.01913014f, 
    0.02528797f, -0.00445049f, -0.00585217f, -0.04574238f, 0.01461734f, -0.07152493f, 0.02469339f, -0.06156958f, 
    0.00254040f, -0.00360334f, 0.01515492f, -0.01465083f, -0.03759689f, -0.01159600f, -0.06893997f, 0.00487185f, 
    0.04816305f, -0.03628095f, 0.00112899f, 0.00330179f, -0.00883327f, 0.02834722f, -0.04810587f, -0.08375141f, 
    0.03530449f, 0.04806549f, -0.01079588f, 0.02943661f, 0.01864501f, -0.04744903f, 0.00245055f, 0.00214327f, 
    0.03623741f, -0.02079395f, 0.00194516f, -0.03601021f, -0.00225302f, 0.00423484f, -0.06281114f, -0.00561270f, 
    0.00049282f, -0.00171749f, -0.05968617f, -0.02948905f, -0.04913791f, -0.01081308f, 0.00559690f, -0.07280305f, 
    -0.04241888f, -0.06421075f, -0.01317981f, -0.04330231f, 0.03516068f, -0.03153174f, -0.01608283f, -0.04345885f, 
    0.00913176f, -0.01035485f, -0.03899049f, 0.03072223f, 0.01854598f, -0.01069219f, -0.04674147f, -0.01311692f, 
    0.01579128f, -0.07305552f, -0.07515480f, 0.00427602f, 0.00857321f, -0.04967077f, -0.06810784f, -0.02273856f, 
    -0.04144839f, 0.01830906f, 0.01891314f, 0.01769504f, -0.08088432f, -0.06078669f, -0.05544804f, 0.02548283f, 
    -0.00095961f, -0.06101377f, 0.02459932f, -0.06393818f, -0.01093283f, -0.07528280f, -0.01276517f, 0.01905936f, 
    -0.06703898f, 0.04264220f, -0.07088798f, 0.01709421f, 0.03703348f, 0.02249342f, -0.01465152f, -0.05793905f, 
    -0.03291742f, -0.03340270f, 0.01138018f, -0.01099902f, -0.04145081f, -0.07152033f, 0.00478270f, -0.06134166f, 
    0.03616461f, 0.18660596f, 0.04489817f, 0.00271166f, 0.08024628f, -0.19803515f, -0.00627783f, 0.01923637f, 
    -0.01071642f, -0.15611409f, 0.01732473f, 0.01020698f, -0.01730259f, 0.15068001f, -0.14819275f, 0.04572489f, 
    0.03938027f, -0.03603607f, -0.19814730f, -0.17415981f, -0.08076582f, -0.07403892f, 0.08067653f, -0.15201066f, 
    0.02477647f, 0.23248994f, 0.15423363f, 0.13447453f, -0.16193964f, 0.04276095f, 0.03559135f, -0.02304929f, 
    0.14297687f, -0.24115057f, 0.19386806f, -0.17148474f, 0.30717099f, 0.19845045f, 0.19244726f, 0.23946372f, 
    0.03555269f, -0.10978111f, 0.11136136f, 0.05556328f, 0.05049891f, 0.05296424f, 0.11790798f, -0.22842340f, 
    0.20669538f, -0.13270539f, -0.01279927f, -0.14631109f, 0.04777879f, -0.07947484f, 0.30028486f, -0.10168349f, 
    -0.10764601f, 0.00476135f, -0.12106282f, 0.02253838f, -0.33791763f, -0.10646004f, -0.16030613f, -0.33376804f, 
    0.10816871f, -0.03162666f, 0.23793717f, 0.10630015f, -0.17463267f, 0.11460497f, 0.00359718f, 0.20521438f, 
    0.06039937f, -0.08509676f, 0.15747428f, -0.10291355f, 0.06425765f, 0.21026391f, -0.08451248f, -0.01815795f, 
    -0.08567138f, 0.20405024f, -0.00736965f, 0.10338361f, 0.01044122f, 0.25575951f, -0.14634387f, -0.02276772f, 
    0.07911744f, -0.13214485f, -0.35792530f, 0.04785219f, -0.01096723f, -0.01298153f, 0.08823275f, 0.14782113f, 
    -0.07978626f, -0.13222744f, -0.16816095f, -0.12709273f, 0.09339754f, 0.04786767f, 0.20228444f, -0.04327393f, 
    -0.06039971f, 0.12384526f, -0.28598037f, -0.07583787f, 0.03514059f, 0.35657889f, -0.26442230f, 0.27693743f, 
    0.04540437f, 0.04082973f, -0.09587730f, -0.00164126f, 0.01344419f, 0.44829711f, 0.23956946f, -0.06220875f, 
    0.20322137f, -0.00189101f, -0.01165289f, -0.10161006f, -0.07790467f, -0.08836774f, -0.25711223f, -0.03619760f, 
    0.26272520f, 0.24203628f, 0.02674735f, -0.21140379f, -0.13717073f, 0.08347149f, -0.08096682f, 0.45992845f, 
    -0.12488356f, -0.10626955f, -0.12847848f, -0.18945138f, -0.02328911f, 0.15894641f, 0.02276937f, 0.23620875f, 
    -0.20820360f, -0.24489623f, 0.13674922f, 0.05378053f, -0.12196156f, 0.00721722f, 0.10692790f, -0.20926079f, 
    -0.00146214f, 0.08601558f, 0.22307479f, 0.20102870f, -0.25308445f, 0.09202223f, 0.10007671f, 0.04041862f, 
    0.12058126f, -0.21562545f, 0.27277562f, 0.05609953f, -0.24218318f, -0.01104138f, 0.08592965f, 0.07332937f, 
    -0.13121580f, -0.27030802f, 0.03011244f, 0.04218096f, -0.05897661f, 0.28744605f, -0.00834110f, -0.10435786f, 
    -0.07837324f, -0.05750444f, -0.04302766f, 0.00994205f, -0.16292518f, 0.48428509f, 0.05764032f, -0.02356601f, 
    0.11798961f, 0.05786064f, -0.06369821f, 0.05454040f, -0.03883801f, 0.45979297f, 0.26528132f, -0.08457360f, 
    -0.03546820f, -0.21753822f, 0.07046722f, -0.01483005f, -0.00098888f, 0.22651650f, 0.16541924f, -0.35771620f, 
    -0.00760966f, 0.17714304f, -0.03453092f, 0.10130123f, -0.14738385f, -0.03559033f, 0.03442898f, 0.28015819f, 
    -0.44204074f, 0.07069307f, 0.15406244f, -0.06767488f, -0.11056995f, -0.02526096f, -0.18586533f, -0.06667992f, 
    0.30759400f, 0.05197510f, -0.03074585f, 0.17116758f, 0.12284222f, -0.13401163f, -0.25950733f, 0.02370279f, 
    -0.03923492f, 0.22052883f, -0.18319376f, -0.03739269f, -0.00897709f, -0.07466907f, 0.09778760f, -0.09639072f, 
    0.03437780f, 0.05329050f, 0.32440758f, -0.35792065f, -0.10846341f, -0.06592494f, -0.07537922f, -0.01351161f, 
    0.17499688f, -0.16706525f, -0.22150061f, -0.13988318f, 0.43179423f, -0.15173890f, 0.24395539f, -0.01537528f, 
    0.00559674f, -0.10781891f, 0.11765242f, -0.16914028f, 0.26793423f, -0.07925028f, 0.01726828f, -0.07984781f, 
    -0.05801455f, 0.06466364f, -0.15480910f, -0.09094113f, 0.07781044f, -0.40130314f, -0.23355448f, -0.00256381f, 
    0.03020723f, 0.01619432f, 0.06860959f, 0.03907933f, -0.01672171f, 0.04588446f, 0.28100088f, -0.12150909f, 
    0.05256101f, -0.12061805f, -0.10425352f, 0.01411540f, 0.13189366f, 0.07086588f, 0.01362940f, -0.27966529f, 
    -0.09570085f, -0.06100030f, 0.09783219f, 0.03734850f, 0.05288757f, 0.10274652f, 0.16778575f, -0.15192734f, 
    0.23826066f, 0.09724765f, -0.35579684f, 0.24004818f, 0.00308928f, 0.09744144f, 0.26411581f, 0.12226591f, 
    0.01755441f, 0.13586918f, 0.13722038f, 0.32130295f, -0.06159790f, -0.02996209f, -0.17505214f, 0.25878552f, 
    0.18499514f, 0.16614673f, 0.48576358f, 0.18801533f, 0.12018016f, -0.07516987f, 0.08075245f, -0.09862956f, 
    0.08297349f, 0.06569766f, 0.11627000f, 0.08794694f, 0.00533631f, 0.34331384f, 0.08718519f, 0.15038250f, 
    0.08897392f, 0.02182409f, 0.02684632f, 0.21291409f, -0.21046905f, 0.10063934f, -0.04292985f, 0.19658110f, 
    0.02043874f, -0.06988209f, 0.31847396f, -0.19076237f, 0.06568193f, 0.12798940f, -0.44062546f, 0.15830748f, 
    -0.16805518f, -0.10645373f, -0.04469846f, -0.12313244f, 0.03244279f, 0.06156675f, -0.60966253f, 0.29192549f, 
    0.06310513f, 0.14736854f, 0.05824624f, 0.22905575f, -0.21049075f, -0.09203541f, 0.03316807f, 0.16047670f, 
    0.35836214f, -0.06186506f, 0.25384027f, 0.18454041f, -0.13878150f, 0.23034939f, -0.08868584f, -0.04891438f, 
    -0.51336205f, -0.04742148f, -0.27144837f, 0.08558728f, -0.08833517f, -0.04310555f, -0.11762214f, 0.15865962f, 
    0.01894823f, 0.09050372f, 0.20168307f, -0.34928700f, 0.14386393f, -0.00990153f, 0.05947551f, 0.07906964f, 
    -0.13931347f, 0.11868209f, 0.17038417f, 0.45279425f, -0.14470346f, -0.02633206f, -0.15673451f, 0.10373422f, 
    -0.11087245f, -0.14538345f, 0.32714278f, -0.26691693f, -0.30734527f, 0.42835319f, -0.30680937f, -0.02535203f, 
    -0.03867533f, 0.01341866f, -0.04073712f, -0.06156415f, -0.06298265f, -0.04533885f, -0.18689342f, 0.28160334f, 
    0.07555540f, -0.14372867f, -0.10479032f, -0.00665959f, 0.36227754f, 0.10995389f, 0.10458225f, 0.36881232f, 
    -0.11527139f, 0.04627495f, -0.21240771f, 0.12183049f, 0.12390342f, 0.09551812f, 0.17842014f, -0.02215958f, 
    -0.41819194f, 0.01394344f, -0.02255025f, -0.02897982f, 0.25964180f, -0.05887420f, 0.02737297f, -0.54835689f, 
    0.07526926f, 0.19125447f, -0.06052778f, 0.04224822f, -0.10682458f, 0.04025844f, -0.02099174f, -0.00486522f, 
    0.15142314f, -0.07265494f, -0.10005586f, 0.27345073f, 0.23361054f, 0.15260573f, 0.02353475f, 0.02184259f, 
    0.00409834f, -0.22981694f, -0.28648317f, -0.08492704f, 0.13362129f, -0.01499537f, -0.04521232f, 0.24810068f, 
    0.09105411f, 0.12611827f, -0.28606448f, -0.05175377f, 0.07307736f, -0.04564538f, -0.10588603f, -0.08696440f, 
    -0.05713724f, -0.13002150f, 0.03657503f, -0.73246843f, -0.24067329f, -0.25378811f, 0.04321841f, 0.19678418f, 
    0.12421291f, -0.28084949f, -0.19989325f, -0.18393821f, -0.11253134f, 0.00167691f, -0.17545554f, 0.20609753f, 
    -0.10074325f, -0.02586335f, -0.01412405f, -0.05230477f, -0.16116503f, -0.09633122f, 0.06609799f, 0.31802326f, 
    -0.00322183f, 0.15945646f, -0.16437870f, 0.20627743f, -0.02769005f, -0.10605916f, -0.16857997f, -0.25521564f, 
    -0.04452160f, 0.15146665f, 0.03341851f, 0.08720765f, 0.03147590f, 0.14956595f, -0.02779349f, -0.08824021f, 
    -0.11249458f, -0.06607917f, 0.03342640f, 0.01247900f, 0.05373399f, -0.02211397f, 0.12458949f, -0.01740189f, 
    -0.05169822f, 0.07371575f, -0.56482303f, 0.12124021f, -0.00343643f, 0.02566177f, -0.01539795f, -0.22010660f, 
    0.00888641f, -0.11227793f, -0.24810146f, 0.22225249f, -0.48338473f, -0.09079646f, 0.00877439f, -0.14393784f, 
    0.18390596f, 0.17233884f, -0.06479758f, 0.03727752f, 0.20697649f, 0.13725312f, 0.05682192f, 0.05626638f, 
    0.20359747f, 0.08822776f, 0.15372686f, -0.02258204f, -0.02955590f, -0.06128452f, 0.20654145f, 0.11957427f, 
    -0.01025100f, 0.14092535f, -0.08555271f, -0.08801597f, -0.11596787f, 0.01308014f, 0.13050842f, 0.10248998f, 
    -0.09289966f, 0.07316040f, -0.01147460f, 0.18590440f, -0.06322040f, 0.07899642f, -0.10196836f, -0.24536736f, 
    0.04874264f, 0.06451985f, 0.10114922f, 0.20024209f, 0.17341653f, 0.10352913f, -0.19895141f, -0.03012052f, 
    0.16449313f, -0.12103029f, -0.06762569f, 0.06854798f, -0.18736359f, 0.08333296f, 0.02661486f, -0.10934190f, 
    -0.13138486f, -0.13333969f, 0.25421304f, 0.01393574f, -0.00581656f, 0.07288020f, 0.13092999f, -0.10476712f, 
    0.00713678f, -0.02694579f, -0.06040409f, -0.03725293f, 0.02535036f, -0.03069143f, 0.04693922f, -0.04530819f, 
    0.02009116f, -0.05273838f, -0.04937750f, -0.05272536f, -0.03241795f, -0.05816546f, 0.04623314f, 0.00534698f, 
    -0.02837719f, 0.02587426f, 0.01225507f, 0.03001452f, 0.02328847f, -0.00375679f, -0.00952121f, -0.02150153f, 
    0.03947691f, -0.01317884f, -0.00458268f, -0.00095460f, -0.03439565f, -0.02010375f, 0.03913613f, -0.04925669f, 
    0.04549314f, 0.02851911f, -0.05376831f, 0.01974438f, -0.02017334f, 0.05209457f, -0.05622856f, -0.04630334f, 
    -0.05453249f, -0.06437593f, 0.04719737f, 0.00844623f, -0.07043943f, -0.04533751f, -0.03855949f, 0.00703040f, 
    0.00603061f, 0.03083320f, -0.01240017f, -0.00956218f, -0.04541867f, 0.04107662f, 0.03326513f, -0.04951103f, 
    -0.01617850f, -0.06117494f, -0.04498043f, 0.04141544f, -0.01693757f, 0.02009793f, -0.03132907f, -0.00034156f, 
    -0.06127397f, -0.02584240f, 0.04954489f, 0.01912727f, -0.00691016f, -0.02888871f, -0.06731340f, 0.04866927f, 
    0.01287938f, -0.00536697f, 0.00359075f, -0.02774923f, 0.04618514f, 0.01009338f, -0.05967190f, 0.03618002f, 
    -0.03175916f, -0.04636962f, 0.04007347f, -0.02166104f, 0.04425828f, -0.02153625f, 0.00386186f, -0.04347152f, 
    -0.02403155f, 0.02100732f, -0.02927817f, -0.03745958f, 0.02985127f, 0.03985796f, -0.04951793f, -0.04010725f, 
    0.02800690f, -0.04593282f, 0.03379879f, 0.02828635f, 0.02938093f, -0.02382134f, -0.04447157f, -0.01921555f, 
    0.02385037f, 0.04275902f, -0.04413374f, 0.03893201f, -0.03591131f, -0.02155461f, -0.03911709f, -0.00162618f, 
    -0.05544463f, -0.04295391f, -0.02846118f, -0.06938702f, 0.01609504f, -0.03349132f, -0.04673169f, -0.00863062f, 
    -0.01808802f, 0.01075667f, 0.00862072f, 0.02982166f, 0.02150648f, 0.01396220f, 0.03985075f, 0.03973660f, 
    0.04129005f, -0.05549582f, -0.03962347f, 0.03552943f, 0.01564959f, -0.00625621f, -0.06340569f, -0.00391152f, 
    0.04792822f, -0.03025327f, -0.06760405f, -0.04621782f, -0.04711019f, -0.03158354f, 0.00418232f, -0.03712218f, 
    -0.05428868f, -0.06450816f, 0.02992400f, 0.00806305f, -0.02065086f, 0.04627557f, 0.01238377f, 0.00925557f, 
    -0.06585523f, 0.01089434f, 0.01816006f, -0.05318910f, -0.04184398f, 0.04096280f, -0.05582776f, -0.04673140f, 
    0.01327805f, 0.00357293f, 0.02084042f, -0.01841315f, 0.00378244f, 0.00756013f, 0.01733848f, 0.01251573f, 
    -0.03855289f, -0.00645151f, 0.00058924f, 0.00542979f, -0.00813920f, 0.02834446f, -0.00088475f, -0.06131245f, 
    0.00604392f, -0.01051181f, -0.03858841f, 0.03844920f, 0.04102984f, 0.03909233f, 0.04342099f, -0.00441744f, 
    0.02439115f, 0.05385946f, -0.02238318f, -0.00732741f, -0.05628998f, -0.05726809f, 0.03863945f, 0.01720146f, 
    -0.02460516f, -0.05180518f, -0.04245308f, 0.00872911f, -0.06550644f, -0.06389711f, -0.00250178f, 0.05500582f, 
    0.02719034f, -0.02108236f, 0.03996476f, -0.03138129f, 0.02058673f, 0.00679964f, -0.03305822f, -0.02677879f, 
    0.00873229f, 0.02763836f, 0.03587930f, -0.03003005f, 0.03670486f, -0.00907583f, -0.01641992f, 0.04331903f, 
    -0.02698727f, 0.01169377f, -0.04610656f, -0.00174191f, -0.00922810f, 0.00020795f, -0.00416121f, -0.02450358f, 
    -0.06551611f, 0.05017341f, -0.04432471f, 0.03676031f, 0.02704429f, 0.00342961f, -0.05891375f, -0.01192532f, 
    -0.03387669f, 0.04593309f, 0.00196119f, 0.02899840f, -0.04586304f, -0.01430434f, 0.02446147f, -0.01765329f, 
    -0.00241600f, 0.01091762f, -0.01473454f, -0.02974873f, -0.02305165f, 0.00928892f, -0.03321148f, -0.03835770f, 
    -0.05840696f, -0.02564998f, -0.05687695f, 0.01062144f, -0.05467908f, 0.02312094f, -0.03284018f, -0.01023326f, 
    -0.02974057f, 0.04179145f, 0.02369277f, -0.05965909f, 0.00368842f, -0.03294189f, 0.01945929f, -0.04401559f, 
    0.03550124f, 0.01135351f, -0.04409012f, -0.02443299f, 0.04232359f, 0.00760273f, -0.06408592f, -0.06414981f, 
    -0.06301625f, 0.04019110f, -0.02922682f, 0.00954316f, -0.02533153f, -0.05614152f, 0.03754066f, -0.05982680f, 
    -0.04556808f, -0.04867151f, -0.05535707f, -0.01813176f, -0.00351086f, -0.02984334f, 0.03920102f, 0.04722991f, 
    0.17140886f, 0.11055176f, -0.02553660f, 0.05633801f, -0.04694549f, -0.13941017f, 0.18100716f, 0.08674946f, 
    0.06786252f, 0.26792514f, -0.07182393f, -0.02249203f, -0.01597835f, 0.19019668f, 0.16978745f, -0.00954724f, 
    -0.00221296f, 0.04561720f, 0.37792969f, 0.36279911f, 0.03123993f, -0.07532861f, 0.07694235f, 0.11638643f, 
    0.01987826f, 0.07414886f, -0.20035583f, -0.08561890f, 0.11975834f, -0.04787736f, 0.11108561f, 0.15701221f, 
    -0.14847015f, -0.12076546f, -0.08045261f, -0.02745337f, -0.05604716f, -0.31456062f, 0.14421637f, -0.20631064f, 
    0.01263205f, 0.17891535f, 0.18433346f, 0.09767682f, 0.22884026f, -0.50384015f, 0.02760746f, 0.04974807f, 
    0.01809132f, 0.06497657f, 0.16486445f, 0.07557144f, 0.09511813f, 0.16891976f, 0.39159945f, 0.07350794f, 
    -0.23877028f, 0.02450387f, 0.18583252f, 0.13841376f, -0.07682218f, 0.00635235f, -0.10373557f, 0.44672909f, 
    0.25913289f, 0.06723949f, -0.19953790f, -0.17046534f, -0.20088719f, 0.10121553f, 0.06092353f, -0.00143471f, 
    -0.19574244f, -0.62619847f, -0.13991037f, -0.03138233f, -0.03692351f, -0.02248457f, -0.17227395f, -0.03513946f, 
    -0.01981718f, 0.39589536f, 0.19789286f, -0.02079747f, -0.23863472f, -0.09655812f, -0.13229914f, 0.09843649f, 
    -0.02722573f, 0.07081173f, 0.02721751f, 0.20923932f, 0.30030638f, 0.06086915f, -0.00637530f, -0.21422704f, 
    -0.03806618f, 0.05158554f, -0.09962499f, -0.05271732f, -0.32095879f, -0.18976688f, 0.04745870f, 0.15941347f, 
    0.00159968f, -0.04896437f, 0.01027147f, -0.04966520f, 0.05929939f, -0.34069490f, -0.10174099f, -0.24124263f, 
    -0.00790568f, -0.13694961f, -0.06577089f, -0.07105878f, -0.12236027f, -0.17779703f, 0.11410110f, 0.08167391f, 
    0.06625459f, -0.02302343f, 0.10553300f, 0.05229669f, 0.10312521f, -0.01377464f, 0.22114198f, 0.14901592f, 
    0.08182848f, 0.01065363f, -0.18506236f, -0.13997646f, -0.08768886f, 0.11721125f, -0.15109468f, -0.06680717f, 
    -0.41170809f, -0.24481319f, -0.12738104f, 0.03466248f, 0.06349577f, 0.00230624f, -0.00064610f, 0.01628333f, 
    -0.35871550f, 0.15690824f, 0.26148701f, 0.10943638f, 0.15116026f, -0.07744272f, 0.07650132f, -0.08260518f, 
    0.03360986f, 0.09543805f, -0.06940069f, 0.25136384f, -0.16009825f, 0.21866424f, -0.01405236f, -0.14873733f, 
    0.04221322f, -0.04317963f, 0.30261356f, 0.05701325f, -0.11644008f, -0.03675131f, 0.12082022f, 0.13090003f, 
    0.05710271f, 0.14247678f, -0.17006031f, 0.09200985f, -0.21402672f, -0.22543429f, -0.04492385f, 0.00984247f, 
    -0.02770571f, -0.08491840f, -0.00427716f, -0.04598644f, 0.03628948f, -0.28344843f, -0.13646631f, 0.11424831f, 
    0.13726485f, 0.02936993f, 0.16057217f, 0.00008701f, -0.03902983f, -0.38518685f, 0.13491262f, 0.13476737f, 
    0.00785152f, 0.12998915f, 0.08238342f, -0.01426996f, 0.08268443f, 0.06934936f, -0.06251059f, -0.28594550f, 
    -0.08593648f, -0.08944743f, -0.26029390f, 0.04066189f, -0.15299736f, 0.03808278f, 0.01865223f, -0.05922788f, 
    0.18044533f, -0.36166957f, 0.09787767f, -0.12038210f, -0.05701194f, -0.22941500f, -0.09306269f, -0.17573896f, 
    0.49303108f, -0.03889542f, 0.05527214f, -0.05188929f, -0.09297787f, -0.01994237f, -0.00037737f, 0.00191010f, 
    0.20348419f, -0.47413701f, 0.06520113f, -0.13390391f, 0.09384581f, -0.03823907f, -0.05597898f, -0.26941630f, 
    -0.11317521f, 0.05033689f, -0.13874449f, -0.05776410f, 0.14167044f, 0.04322715f, -0.11060859f, -0.00184747f, 
    -0.08947800f, 0.12947609f, 0.13562156f, 0.13877074f, -0.19599421f, -0.39839086f, 0.08953062f, 0.11803458f, 
    0.06316434f, 0.16839737f, -0.05658187f, 0.07380904f, -0.09667905f, 0.24405286f, 0.03362951f, -0.09202042f, 
    0.10829783f, 0.03477337f, 0.03819726f, 0.03818030f, 0.08132186f, 0.41110593f, 0.01157359f, -0.16442706f, 
    -0.10153524f, 0.11996092f, -0.22586301f, 0.19140396f, 0.03361187f, 0.20063296f, -0.43998849f, 0.08445998f, 
    -0.24151668f, 0.09832451f, 0.18201070f, -0.05597412f, 0.06152925f, 0.02420370f, -0.10372210f, -0.68354189f, 
    0.15417020f, -0.17931472f, 0.14232486f, 0.08407550f, -0.22480428f, -0.04517335f, 0.03384083f, 0.20440879f, 
    -0.17312692f, -0.00723298f, -0.32728118f, 0.08037578f, 0.02302775f, 0.05811309f, 0.06040806f, -0.01240246f, 
    -0.06960025f, 0.28559312f, -0.10395819f, 0.11766109f, -0.19640209f, 0.24515295f, 0.06041295f, -0.03829314f, 
    0.28001672f, 0.16654253f, -0.25673655f, 0.06153940f, -0.01847785f, 0.15163128f, -0.06740358f, -0.01792734f, 
    0.15237969f, -0.14355105f, 0.15758803f, 0.04980440f, 0.05082864f, 0.04103123f, 0.13713568f, 0.10812274f, 
    0.09923372f, 0.14774273f, -0.11055366f, 0.08092488f, -0.54694462f, -0.20409349f, -0.25922433f, 0.05784648f, 
    0.12831356f, 0.10846913f, 0.03771154f, -0.06017034f, 0.11443744f, -0.04782607f, 0.32158491f, 0.09549499f, 
    -0.22898421f, -0.06816520f, 0.03184379f, 0.17209655f, 0.09103125f, 0.02325127f, 0.00953770f, 0.28881407f, 
    -0.14786446f, 0.28247693f, 0.21146560f, 0.18903860f, 0.24864210f, -0.11097935f, 0.06968089f, -0.43376780f, 
    -0.00983264f, -0.47256503f, -0.00667209f, 0.04870632f, 0.15969792f, -0.08517625f, -0.15813106f, 0.01273066f, 
    -0.50112504f, -0.22727312f, 0.21737739f, -0.07967454f, 0.08251163f, -0.10794874f, -0.06163915f, -0.12802412f, 
    0.14045906f, -0.33720919f, -0.56269503f, -0.43969846f, -0.01072226f, 0.02796857f, 0.03699341f, -0.01720131f, 
    -0.06360687f, 0.24571052f, -0.46524692f, -0.09916668f, 0.19465783f, -0.20932004f, 0.05183239f, -0.16905913f, 
    -0.26680806f, 0.15143320f, 0.01248183f, -0.16003878f, -0.05446857f, 0.12330757f, -0.07879858f, -0.14102273f, 
    -0.04432346f, 0.01287687f, 0.04733579f, -0.05825546f, -0.18756650f, -0.14633068f, -0.47834074f, 0.02887494f, 
    0.12393098f, -0.16748537f, 0.10171223f, 0.21344377f, -0.00767110f, -0.10697986f, 0.13262016f, 0.12996787f, 
    -0.09751190f, 0.10877977f, 0.08820017f, 0.21303955f, 0.00324906f, -0.08243106f, 0.13491572f, 0.25522292f, 
    0.12888084f, 0.09861206f, -0.17848839f, -0.03518720f, 0.19200690f, 0.00899227f, -0.06611047f, -0.11764054f, 
    -0.49865797f, 0.35563684f, -0.08722742f, -0.05111061f, -0.11600285f, -0.16556594f, 0.06445675f, -0.04088980f, 
    -0.59722084f, -0.05573187f, 0.02214331f, 0.02336081f, 0.13045426f, 0.00204092f, 0.17412925f, 0.02839840f, 
    -0.10183061f, -0.00033196f, 0.09050253f, -0.63563031f, -0.07209408f, -0.10397840f, 0.05904682f, 0.24517851f, 
    0.13124983f, -0.20282462f, 0.13288386f, 0.12418684f, 0.06669455f, 0.12323237f, 0.03876761f, -0.02385096f, 
    -0.00001228f, -0.07325849f, 0.10368431f, -0.36309731f, -0.35000879f, -0.08488070f, -0.00027688f, 0.10186402f, 
    -0.10496186f, 0.08664128f, -0.01243516f, -0.19714659f, 0.06061250f, -0.56736618f, -0.84418148f, -0.15823899f, 
    0.02974531f, 0.15361527f, -0.07327121f, -0.10008247f, -0.29358035f, 0.09110340f, 0.13380480f, 0.19203499f, 
    0.07734011f, 0.14458317f, 0.17015645f, 0.26736343f, -0.10404024f, 0.17185830f, -0.07946536f, -0.32431400f, 
    -0.12278959f, -0.07402395f, -0.00121158f, 0.16560034f, 0.01006412f, 0.13907291f, 0.16098651f, 0.26882377f, 
    -0.11938677f, -0.14316818f, -0.08212204f, -0.13410538f, -0.01407706f, 0.22231120f, -0.10901174f, 0.23287947f, 
    -0.31431383f, -0.24556670f, -0.36274180f, 0.20895706f, -0.10524238f, 0.02218425f, 0.09278990f, -0.14154308f, 
    0.21366526f, 0.19767880f, 0.06940109f, -0.10943180f, -0.08612990f, -0.02234289f, 0.01718972f, -0.10212892f, 
    0.03307371f, 0.00606993f, 0.13292234f, 0.11888958f, 0.23739244f, 0.13296461f, 0.07583866f, -0.01355451f, 
    -0.23511803f, -0.04512424f, -0.14518018f, -0.01442718f, -0.20708504f, -0.51507169f, -0.17251709f, -0.06972773f, 
    0.06526673f, 0.01652366f, -0.10030911f, -0.16083021f, 0.21108150f, 0.36065775f, 0.12066375f, 0.14365359f, 
    0.16653144f, 0.25714222f, 0.10379791f, 0.01203630f, 0.03850863f, -0.29789177f, 0.21597916f, 0.03614279f, 
    0.15267824f, 0.07213768f, 0.00934357f, 0.13941832f, -0.04029470f, -0.14184342f, 0.30466455f, 0.11735865f, 
    0.19246647f, 0.11999020f, -0.10227064f, 0.11468536f, 0.03412146f, -0.09678065f, 0.12368693f, -0.41577217f, 
    0.14611268f, 0.09677956f, 0.18911037f, 0.03803611f, 0.20735788f, -0.08535079f, -0.04069702f, -0.15191509f, 
    0.08416560f, -0.27313429f, -0.10757847f, 0.12739076f, 0.13590260f, 0.18322492f, 0.02650942f, -0.01621352f, 
    -0.00647513f, 0.05219216f, 0.25831577f, -0.04171319f, -0.12937263f, 0.13236855f, -0.03585012f, 0.09678023f, 
    -0.12217166f, 0.08579615f, 0.35194805f, -0.30745932f, -0.23027468f, 0.06875224f, 0.06984175f, 0.29594746f, 
    -0.01468392f, -0.05250327f, -0.05831567f, -0.30368990f, 0.10230368f, 0.11481523f, -0.03165017f, 0.14253394f, 
    0.06352539f, 0.13290305f, -0.22456498f, -0.01014965f, -0.01056327f, 0.09614012f, -0.16488707f, -0.13802239f, 
    -0.01511996f, 0.14736556f, 0.01685993f, 0.06745669f, -0.00556427f, 0.02084733f, 0.25432324f, -0.03289099f, 
    -0.16657420f, -0.02440876f, -0.18890058f, 0.05265793f, 0.16356917f, 0.15189643f, -0.46463424f, -0.09499814f, 
    -0.02376338f, -0.01309849f, 0.29723302f, 0.19181746f, -0.26991665f, -0.00709244f, -0.18660097f, 0.06953400f, 
    -0.17052969f, -0.12108494f, 0.27188936f, 0.17833036f, 0.32302618f, -0.13505755f, -0.06167440f, -0.17884679f, 
    0.20929094f, -0.44511411f, -0.32166940f, -0.09332543f, -0.09432245f, -0.04972611f, 0.01165496f, -0.16501173f, 
    0.17948969f, 0.12038203f, 0.11283676f, 0.01758724f, -0.05544092f, 0.12313003f, 0.21265860f, 0.05411688f, 
    0.01081386f, -0.26715159f, -0.08684076f, -0.27531424f, -0.12182208f, 0.00983481f, -0.07178798f, 0.11890429f, 
    0.01710209f, -0.01404333f, 0.03910422f, 0.03737305f, -0.00315306f, -0.19149917f, 0.31154448f, -0.10835612f, 
    0.02734605f, -0.22980684f, 0.12057823f, 0.02298670f, 0.08011608f, -0.07598794f, 0.12667727f, -0.13616052f, 
    0.04504178f, -0.06229051f, 0.28524932f, -0.38551864f, 0.05349018f, 0.02475038f, 0.37718987f, 0.02851650f, 
    -0.24791048f, 0.05381376f, -0.20978926f, 0.11298385f, 0.05091410f, 0.11155002f, -0.24520509f, -0.31212601f, 
    -0.08241070f, 0.02177085f, -0.10980672f, 0.01802224f, -0.07855920f, -0.14076333f, 0.08908150f, 0.11851721f, 
    -0.14807904f, -0.18807095f, -0.18897803f, 0.11003549f, -0.04042190f, 0.00105481f, 0.08259722f, 0.01047473f, 
    0.04459356f, 0.29639044f, 0.04185855f, 0.10889469f, 0.10463800f, 0.20566516f, -0.08402272f, -0.10272332f, 
    -0.11595618f, 0.11180473f, -0.07381628f, -0.24609469f, -0.01644190f, 0.07455470f, 0.07077496f, -0.04527601f, 
    -0.07808492f, -0.06517965f, 0.03060813f, 0.46843186f, 0.10188118f, 0.32043585f, -0.02520431f, 0.04195148f, 
    0.12493049f, -0.01424930f, -0.09403600f, -0.05747166f, -0.53422701f, -0.04532281f, -0.15400757f, 0.01372525f, 
    -0.06357911f, 0.07707989f, -0.00148574f, -0.10671071f, 0.05342125f, -0.36647215f, -0.32727590f, 0.11101928f, 
    0.21009944f, 0.24442445f, -0.25779420f, 0.22244073f, -0.14413105f, 0.01276567f, 0.18128754f, 0.21508324f, 
    0.00460956f, -0.00215383f, -0.00677369f, 0.09581724f, 0.22903505f, -0.01314424f, -0.36522844f, 0.01694565f, 
    -0.13415156f, -0.03343200f, 0.02558879f, -0.03796038f, -0.05552861f, 0.04128643f, -0.02339313f, -0.05416799f, 
    -0.18901309f, 0.09116953f, -0.12674423f, 0.02011598f, -0.32223606f, 0.05211784f, -0.05529699f, 0.28111222f, 
    0.10468829f, 0.11850401f, -0.03877785f, -0.00490315f, 0.17133579f, 0.16982031f, -0.04481678f, -0.02634883f, 
    -0.10739829f, 0.37869960f, 0.22777827f, 0.08758315f, 0.17965271f, -0.15746948f, -0.12293021f, 0.07289218f, 
    0.24095415f, 0.15720677f, -0.02496129f, 0.20927745f, 0.09484893f, -0.07856873f, 0.24001248f, -0.00402492f, 
    0.06725147f, -0.04337601f, -0.00430384f, 0.06731673f, -0.12951441f, -0.07386132f, 0.01187557f, 0.10855883f, 
    0.04424501f, -0.06978767f, 0.01299698f, -0.15972771f, 0.10069277f, 0.11013992f, 0.13483486f, 0.01855421f, 
    -0.22358060f, -0.07498360f, -0.00757793f, -0.00894485f, 0.01172995f, -0.07147338f, -0.48610994f, 0.23343611f, 
    0.08681350f, 0.32907099f, 0.10041373f, -0.08472220f, 0.08509494f, 0.01015218f, 0.23453651f, 0.04982623f, 
    -0.07396831f, -0.14886357f, -0.18422253f, 0.00879063f, 0.05395368f, 0.05469850f, -0.01782947f, 0.23433697f, 
    -0.29486808f, -0.11362161f, 0.00253798f, 0.12656890f, -0.14930789f, 0.05028200f, 0.13542914f, 0.00748624f, 
    0.11074501f, 0.13829233f, -0.14914156f, 0.08817232f, -0.07686928f, -0.01591190f, 0.05288297f, 0.02618990f, 
    -0.13177451f, -0.06204544f, -0.24977097f, -0.00219347f, 0.01644308f, 0.11098043f, 0.03603964f, -0.16845103f, 
    -0.08211306f, -0.23817432f, 0.05857117f, 0.31141159f, -0.20866659f, -0.11183699f, 0.04006945f, 0.02159738f, 
    0.01666765f, 0.02964523f, 0.17882174f, -0.28996995f, -0.06418283f, -0.19760358f, 0.21421465f, 0.04831260f, 
    0.17413791f, -0.03540608f, 0.10179337f, -0.08819517f, 0.09464742f, -0.00163136f, -0.01290192f, -0.06106651f, 
    -0.01778981f, -0.13282092f, -0.12370579f, 0.08115283f, 0.06016959f, -0.20143706f, 0.05008112f, 0.04125053f, 
    0.02612397f, -0.03426947f, 0.17895329f, -0.12331459f, 0.05335662f, -0.01070450f, 0.41452527f, -0.13493884f, 
    -0.38781932f, 0.10762901f, 0.08236852f, 0.12676744f, 0.06875706f, -0.15160687f, -0.03144446f, 0.21443591f, 
    0.28803578f, -0.18110873f, 0.03735152f, 0.09304763f, -0.00374997f, 0.02197226f, 0.01524162f, -0.13638572f, 
    -0.33514827f, -0.37349734f, 0.09028644f, -0.21581145f, -0.00506201f, 0.07016890f, -0.01410684f, -0.01511845f, 
    0.12877618f, 0.24826941f, 0.17647742f, -0.20959920f, 0.05901042f, -0.03498526f, -0.03657250f, -0.14144212f, 
    0.02655624f, 0.08939734f, 0.16540419f, -0.20637234f, 0.22443986f, 0.05464504f, 0.18944615f, -0.07719049f, 
    -0.11640015f, 0.11593146f, -0.06493025f, -0.02360624f, -0.07329775f, 0.21242045f, 0.11888552f, -0.00282057f, 
    0.15258335f, -0.05891006f, -0.08349722f, -0.13412467f, 0.08705228f, -0.34884581f, -0.14877339f, -0.03307681f, 
    0.13305165f, -0.10349976f, -0.02549186f, 0.05693813f, 0.15117157f, -0.03299224f, 0.00707681f, -0.04720548f, 
    0.11259534f, -0.00906448f, 0.07054682f, -0.07222889f, 0.02127612f, -0.02595529f, 0.22755589f, 0.26012284f, 
    0.14753848f, -0.00791154f, -0.24580945f, -0.02818341f, 0.03605077f, -0.16307530f, 0.01178382f, -0.13490371f, 
    -0.17920312f, 0.24077328f, -0.14778049f, -0.08392528f, -0.06151699f, -0.04697381f, -0.11047214f, 0.03525591f, 
    -0.34248883f, 0.45206156f, 0.22019543f, 0.00660271f, 0.01288656f, 0.13692224f, 0.11312707f, 0.02005777f, 
    0.04521779f, 0.08706129f, -0.36672604f, -0.10273867f, -0.14954668f, -0.07090759f, 0.24003345f, 0.06665398f, 
    0.01800299f, -0.18940853f, 0.44017887f, 0.05587200f, -0.18451573f, -0.18494509f, 0.00241387f, 0.04519655f, 
    -0.21606657f, -0.05966021f, 0.17618258f, -0.37340638f, -0.23422264f, -0.11587573f, 0.09099284f, 0.05825850f, 
    -0.03830396f, -0.08295149f, -0.03931858f, -0.05958012f, 0.14338671f, -0.55639660f, -0.25664499f, -0.07675334f, 
    -0.02288566f, 0.14297429f, -0.01500653f, 0.09775616f, -0.25158140f, -0.23061164f, 0.09566897f, 0.07781077f, 
    0.10455853f, -0.03772235f, 0.06129508f, -0.05127489f, -0.13170035f, 0.09966271f, -0.07802883f, -0.39388835f, 
    -0.06128164f, -0.21250241f, 0.01319490f, 0.10639795f, 0.00184627f, -0.06452178f, 0.17094147f, 0.02243475f, 
    0.12853727f, -0.34178904f, 0.07890262f, 0.16690627f, 0.05777886f, 0.18090484f, -0.17638466f, 0.12082221f, 
    0.56894577f, 0.06467273f, -0.11706812f, 0.13918076f, 0.08813886f, 0.00899908f, 0.00792904f, 0.00772203f, 
    0.12203125f, -0.17093329f, 0.20897269f, 0.04687422f, 0.06406185f, -0.07391994f, 0.20929304f, -0.02765625f, 
    0.12554343f, 0.14296375f, 0.12613504f, -0.08933987f, 0.02384815f, -0.02691588f, 0.11699908f, 0.00750959f, 
    0.03956769f, 0.11953878f, 0.12766089f, -0.05920236f, -0.41403869f, -0.15710308f, -0.09086347f, 0.01218773f, 
    0.25660706f, 0.18086429f, 0.08859597f, 0.02372139f, 0.16306232f, 0.19439515f, -0.02540554f, 0.02921101f, 
    -0.01747729f, 0.07854789f, -0.08825453f, 0.11034553f, 0.14588673f, 0.13422982f, 0.12490509f, -0.22767885f, 
    0.14223246f, -0.11677292f, -0.01054199f, 0.18912667f, 0.09288960f, 0.06403469f, -0.08269370f, 0.12770186f, 
    0.11307278f, 0.08791525f, -0.07607995f, -0.01354989f, 0.11586408f, -0.14690189f, 0.07028132f, -0.65974945f, 
    0.07512836f, -0.41210857f, -0.11176427f, -0.00626100f, 0.01583790f, -0.15589660f, 0.03841973f, -0.07869831f, 
    0.07289597f, 0.09982359f, 0.11207335f, 0.02509503f, 0.18739717f, -0.09219425f, -0.12621042f, 0.14186257f, 
    0.09013448f, 0.17198929f, -0.39825162f, 0.09761215f, -0.12257608f, -0.00680944f, 0.03885524f, 0.06771045f, 
    0.12924337f, 0.18252024f, -0.54266685f, 0.01764289f, 0.07664654f, 0.12824844f, 0.09528050f, -0.01388387f, 
    -0.41525793f, 0.07828715f, -0.02086925f, -0.23503236f, 0.08811088f, 0.05206908f, 0.12184832f, 0.03126653f, 
    0.08736751f, 0.08183308f, -0.06751463f, -0.06481583f, 0.32981935f, 0.35209465f, 0.08142589f, -0.01126449f, 
    -0.01651380f, -0.31190157f, 0.07363118f, 0.22204991f, 0.22468945f, -0.04722108f, -0.38437411f, 0.06807626f, 
    0.04249822f, -0.04019788f, -0.03788268f, 0.07563933f, -0.07910419f, -0.03673260f, -0.31321707f, 0.26463678f, 
    -0.33349958f, 0.02767546f, -0.21028897f, -0.01499920f, -0.11388586f, -0.02443350f, -0.24331838f, -0.28175667f, 
    -0.02201521f, 0.13960722f, 0.33073130f, 0.22368349f, 0.07892916f, -0.19204378f, 0.18649529f, 0.26703462f, 
    -0.14637503f, -0.10565917f, -0.00793237f, 0.09577689f, 0.21588111f, 0.05466587f, -0.09667239f, 0.00527284f, 
    0.01389922f, 0.15512887f, 0.16927239f, 0.06324615f, 0.20109265f, 0.02332834f, -0.10863905f, 0.17104769f, 
    0.05886416f, 0.13335903f, -0.09770453f, 0.01968288f, -0.26234505f, -0.26374209f, -0.03164349f, 0.14180446f, 
    -0.07599357f, -0.01786265f, -0.03004223f, 0.26535302f, 0.23821585f, -0.20143206f, -0.06012556f, -0.00455779f, 
    0.06254534f, 0.06785965f, 0.13982256f, -0.37574258f, 0.16263258f, -0.12877232f, 0.18871599f, -0.29953840f, 
    -0.00970662f, 0.05581948f, -0.05540576f, 0.05181099f, 0.00803370f, 0.22593857f, -0.20412223f, -0.05486782f, 
    0.04526549f, 0.15519759f, -0.06179475f, 0.00723534f, -0.04716089f, 0.01353945f, -0.39510551f, -0.19440788f, 
    0.19071957f, 0.17617646f, 0.20445098f, 0.16239786f, -0.07265885f, -0.04508720f, -0.26172134f, 0.65990192f, 
    0.03058625f, -0.34831384f, 0.01851718f, -0.11465510f, 0.08235681f, 0.02788661f, -0.02243602f, 0.07269553f, 
    0.14840165f, -0.17234312f, -0.17753407f, 0.07198355f, 0.07468824f, -0.01281854f, 0.03709784f, 0.10258789f, 
    -0.21656986f, 0.00145857f, 0.23126197f, -0.15665795f, 0.13804053f, -0.00264139f, -0.07214926f, -0.09787483f, 
    0.23834135f, -0.13238700f, 0.33382928f, 0.01090421f, -0.20802478f, -0.20272270f, 0.18676430f, -0.09491825f, 
    -0.07348413f, -0.24703334f, -0.04707290f, 0.40102142f, 0.40927917f, 0.15448730f, 0.14291541f, -0.03946662f, 
    0.00654863f, -0.01392872f, 0.03215949f, -0.08060723f, 0.03591769f, 0.31674016f, 0.16083883f, 0.06143390f, 
    -0.00528318f, -0.14582038f, -0.37535420f, 0.22481674f, 0.10510799f, 0.16306597f, -0.15813984f, -0.23218454f, 
    -0.06390478f, -0.14614217f, 0.14281707f, 0.02142964f, -0.01796900f, -0.04131245f, -0.40449876f, 0.14801683f, 
    -0.02375338f, -0.17405240f, -0.00876688f, -0.03600127f, 0.09746110f, -0.03548370f, 0.01204201f, -0.36738363f, 
    0.20951901f, 0.13929416f, 0.02981286f, 0.12817511f, 0.06376622f, 0.01662532f, 0.08983413f, -0.23706952f, 
    -0.15620388f, 0.23191613f, 0.02199777f, 0.06023080f, -0.02227413f, -0.11731096f, 0.00589803f, 0.02433777f, 
    0.06984305f, 0.30196664f, -0.19619277f, -0.23571721f, 0.04930863f, -0.23335876f, 0.12322881f, 0.13292050f, 
    0.21042599f, -0.18986079f, 0.27421021f, -0.45656744f, -0.04774078f, -0.04560205f, 0.01303541f, 0.03587745f, 
    0.09995314f, 0.15577015f, 0.10766941f, 0.05864620f, 0.28309137f, 0.06452845f, -0.25773576f, 0.16718633f, 
    0.12430483f, -0.16887002f, 0.07505117f, 0.16815658f, 0.46287283f, -0.12632400f, -0.05318089f, -0.11289555f, 
    0.05264694f, 0.09426226f, 0.06719220f, 0.05718637f, 0.00508300f, 0.05714208f, -0.22967537f, -0.05705101f, 
    0.00063424f, 0.18153760f, -0.03944752f, -0.20697393f, 0.11811043f, -0.09367213f, 0.49835476f, -0.30079794f, 
    0.05615222f, -0.09305111f, 0.01293689f, 0.12251329f, 0.09407924f, 0.13285357f, -0.00019065f, -0.68377346f, 
    -0.05040644f, -0.16579843f, 0.05725373f, 0.18372545f, 0.15117991f, 0.17680334f, 0.11428530f, -0.03764516f, 
    0.08548457f, 0.03466242f, 0.07790212f, 0.05726364f, 0.09717150f, 0.12619603f, 0.07189043f, 0.15257567f, 
    -0.11634791f, 0.00302671f, -0.07858459f, 0.00808536f, 0.07232507f, 0.12895122f, 0.03418365f, -0.03215057f, 
    0.03041736f, -0.08174942f, -0.23229308f, -0.06057161f, -0.30646375f, 0.12008657f, 0.11878035f, -0.14289103f, 
    0.08246061f, 0.08716220f, -0.15719822f, 0.24764547f, 0.31086436f, 0.40235698f, 0.14350377f, -0.00311630f, 
    0.09474126f, 0.00594442f, -0.00749044f, -0.03244821f, 0.07045060f, 0.04132947f, 0.03567394f, -0.27749363f, 
    -0.32778332f, -0.10403673f, -0.15039732f, 0.08011785f, 0.14985287f, -0.48737645f, -0.34018868f, -0.11826704f, 
    -0.06454140f, 0.06605071f, -0.07820703f, 0.15125138f, -0.03447215f, -0.19540556f, -0.10785139f, 0.13945231f, 
    0.04910523f, 0.18010861f, -0.01037536f, -0.01611524f, 0.20461287f, -0.07020475f, 0.01401763f, 0.19931455f, 
    0.21953313f, -0.07110100f, 0.01194276f, 0.09868150f, 0.00691261f, 0.13186568f, 0.24820685f, -0.09392793f, 
    -0.22531368f, -0.20556548f, 0.03122398f, 0.11836608f, -0.02636939f, -0.03784921f, -0.04395218f, -0.15903117f, 
    0.11024273f, 0.04751872f, 0.07000489f, 0.00210005f, 0.04573885f, 0.03549708f, -0.09507538f, 0.07049562f, 
    0.09324116f, 0.00215585f, -0.01373080f, 0.11515220f, 0.09700567f, 0.00998792f, -0.01954968f, 0.06353404f, 
    -0.16703492f, 0.12906313f, -0.22070241f, 0.41922244f, 0.18064225f, -0.07200186f, -0.05975336f, -0.11068682f, 
    0.00528503f, -0.12206881f, 0.24164687f, -0.04028881f, 0.05774289f, -0.12592314f, 0.35913396f, -0.22853407f, 
    -0.00730971f, 0.14482304f, 0.06626954f, 0.10383707f, 0.09678870f, -0.60848689f, -0.29647651f, 0.02742128f, 
    0.24575503f, 0.03018482f, -0.02236811f, 0.06913196f, -0.13054605f, 0.04211102f, -0.16689502f, -0.03790646f, 
    0.00162176f, 0.08579022f, -0.17708211f, 0.05823079f, 0.01363716f, 0.04655107f, 0.15127094f, -0.17251931f, 
    -0.02743245f, -0.34772962f, -0.01688302f, 0.20507124f, 0.04873028f, 0.14250058f, 0.06858342f, 0.00362810f, 
    0.12416964f, -0.01468828f, -0.01553013f, 0.12764548f, -0.10183702f, 0.04462108f, -0.13169338f, 0.27230269f, 
    -0.07825650f, 0.01895092f, 0.14816950f, 0.10038760f, -0.10053790f, 0.04694720f, 0.06451698f, -0.09263684f, 
    0.07372581f, 0.10929609f, -0.15295506f, 0.23710236f, 0.21599832f, 0.12107529f, -0.13816556f, 0.12521362f, 
    -0.09062641f, 0.14583674f, 0.10649606f, 0.09075292f, -0.13719344f, 0.01877071f, -0.10997558f, -0.07348674f, 
    0.22734694f, 0.19158223f, -0.01507066f, -0.01091170f, -0.04026910f, 0.12831795f, 0.19633758f, -0.23430485f, 
    -0.01580926f, 0.11123139f, 0.04899815f, 0.26594239f, 0.03824382f, -0.64733690f, -0.22114582f, -0.22005615f, 
    0.17240034f, 0.12029421f, 0.08594503f, -0.08209962f, -0.03894042f, -0.02182685f, 0.22165160f, 0.22097935f, 
    0.18294427f, -0.19571689f, -0.08780149f, 0.01214078f, 0.06064243f, 0.27890995f, 0.03837400f, -0.08369312f, 
    0.19836421f, 0.31513309f, -0.32679197f, -0.13264987f, 0.04809219f, 0.00594451f, 0.01247326f, -0.06514718f, 
    0.05828320f, -0.03136909f, -0.06047960f, 0.05908709f, -0.18386301f, -0.16062012f, 0.13376284f, 0.18985035f, 
    0.01014159f, 0.07949994f, 0.12691639f, 0.11602626f, 0.02813486f, -0.10420472f, 0.10416294f, 0.13416685f, 
    0.02514921f, -0.25405157f, -0.72879684f, -0.35732657f, -0.32268003f, 0.11686807f, 0.15740892f, 0.02946996f, 
    0.12649781f, -0.03219687f, -0.01408622f, -0.02528754f, 0.19098251f, 0.01950358f, -0.45545816f, -0.04022520f, 
    0.11150730f, 0.15784921f, 0.21667169f, 0.03960434f, -0.44745806f, -0.17569391f, -0.02623491f, 0.01122476f, 
    0.11628844f, 0.03410633f, 0.02662420f, -0.11408826f, 0.04070495f, -0.15825339f, 0.00875111f, -0.04020649f, 
    0.26444823f, 0.02035128f, 0.19667569f, -0.14555886f, 0.21214755f, -0.06835413f, -0.19731787f, -0.19985747f, 
    0.40228608f, 0.14648919f, 0.05518334f, -0.00682422f, 0.02230415f, -0.05540848f, -0.01151998f, -0.42138258f, 
    -0.30224267f, -0.11417635f, -0.00738942f, 0.09183684f, 0.18216449f, 0.08415808f, 0.01151799f, -0.28147051f, 
    -0.13472596f, -0.07943582f, 0.29364616f, -0.01956295f, -0.06185730f, 0.02479718f, -0.10008430f, -0.02162980f, 
    0.14461209f, 0.19551383f, 0.13426605f, 0.04008010f, 0.08545550f, 0.12584531f, 0.01166630f, 0.33060536f, 
    0.02959267f, -0.09088917f, 0.13465647f, -0.10151370f, 0.01456624f, -0.19313903f, -0.05477993f, 0.19627398f, 
    0.23919855f, 0.03677445f, -0.07262509f, 0.05568459f, 0.27433115f, -0.06192595f, 0.05152610f, -0.07840546f, 
    -0.17709854f, -0.07458737f, -0.21281321f, 0.05082334f, -0.00984654f, -0.18167654f, 0.39879546f, -0.09737145f, 
    0.06100596f, -0.01718447f, 0.09575902f, -0.05524420f, 0.07468185f, -0.35344678f, -0.02487113f, -0.00278732f, 
    0.20615892f, 0.18149650f, 0.13216242f, -0.03815728f, -0.01428509f, -0.21465635f, 0.08479214f, 0.16802913f, 
    0.12429074f, -0.20556623f, -0.04125294f, 0.19453560f, 0.11774738f, 0.08894448f, -0.01327549f, 0.06689160f, 
    0.04744568f, 0.18883522f, -0.08832186f, -0.19625258f, 0.00316283f, 0.05787372f, -0.04952188f, -0.18869124f, 
    0.07778599f, 0.07231117f, -0.09948449f, 0.00583748f, -0.08737651f, 0.07692403f, 0.04072962f, 0.09289467f, 
    -0.17959169f, 0.13022628f, -0.03624674f, 0.19513772f, 0.05038729f, 0.04060001f, 0.03020172f, -0.00724248f, 
    -0.08031086f, 0.09095466f, 0.04809378f, -0.02916801f, 0.03813870f, -0.23539886f, 0.10344351f, -0.05322985f, 
    0.00341625f, -0.10371692f, -0.09265314f, -0.15676551f, -0.12576343f, 0.16989738f, 0.16746238f, -0.09643564f, 
    -0.31530768f, 0.17198604f, 0.02143569f, 0.06914575f, -0.23378906f, -0.18622595f, 0.10078884f, -0.08184544f, 
    -0.04944396f, 0.11724514f, -0.04728500f, 0.05926796f, -0.25463292f, 0.21896371f, -0.09502488f, 0.10322683f, 
    0.26530048f, 0.14127210f, 0.06495489f, 0.03672738f, -0.10742939f, -0.14973851f, -0.17113936f, -0.03166942f, 
    -0.00631921f, 0.15169719f, -0.07731929f, -0.13650668f, -0.09661013f, -0.20644139f, 0.06152760f, 0.26337945f, 
    -0.36611855f, -0.27004415f, -0.15269358f, 0.01836602f, 0.10670421f, 0.03560433f, -0.10538380f, -0.14135033f, 
    0.05596677f, 0.03159417f, -0.10973127f, -0.16615623f, -0.07305296f, -0.08425561f, -0.31868139f, -0.02764730f, 
    -0.11552335f, 0.14880948f, 0.00872568f, 0.19926669f, -0.04184574f, 0.05091749f, -0.00256898f, -0.13434520f, 
    -0.10677402f, 0.01460971f, 0.12517348f, 0.16812487f, 0.06495959f, 0.14906333f, 0.03194893f, 0.01996880f, 
    0.16237018f, 0.11360137f, -0.18437539f, 0.19878209f, -0.29527441f, 0.14950255f, -0.07325099f, -0.18295830f, 
    -0.05735919f, 0.01966298f, 0.09277485f, 0.08525533f, -0.00640012f, -0.07862811f, 0.37272680f, 0.04902918f, 
    -0.33462709f, 0.23148361f, 0.08995561f, 0.20806210f, 0.11435182f, 0.18354079f, 0.01421953f, 0.14354567f, 
    -0.06924233f, 0.15474375f, -0.03422693f, 0.03116953f, 0.13579625f, 0.05241202f, -0.02383836f, 0.13911176f, 
    -0.00660761f, 0.01522872f, -0.19494723f, -0.16188444f, -0.08762406f, -0.01420120f, 0.06233263f, 0.00504461f, 
    0.13732375f, 0.16767433f, -0.08751488f, -0.03138299f, -0.11917748f, -0.14411843f, -0.09223503f, -0.18525441f, 
    -0.25830507f, -0.06880413f, 0.14956939f, -0.03625536f, 0.27501905f, 0.01524512f, -0.09929569f, -0.17940375f, 
    0.01103376f, -0.53508979f, -0.06120396f, 0.25579304f, 0.24851526f, 0.03853588f, -0.30271035f, -0.08602230f, 
    -0.04081027f, -0.28502044f, -0.12495650f, -0.08127316f, 0.05009576f, -0.05352279f, -0.01824515f, 0.26439473f, 
    -0.05063337f, -0.14416999f, -0.10231313f, 0.14367773f, -0.21734463f, -0.09419002f, 0.09354075f, -0.23733114f, 
    0.11899055f, 0.02777037f, 0.11169629f, 0.08612067f, -0.03369914f, 0.02020983f, 0.24066578f, 0.10485005f, 
    -0.01106025f, 0.11475350f, 0.03139718f, -0.20493270f, -0.19818866f, 0.18811034f, -0.19421282f, 0.17412685f, 
    -0.09105441f, 0.18207914f, 0.16349451f, -0.30675125f, -0.17136778f, 0.25191402f, 0.03440766f, 0.08475295f, 
    0.24804924f, 0.23063685f, 0.15233427f, -0.02460346f, -0.09143432f, -0.03576382f, -0.10959307f, -0.06202927f, 
    0.19252688f, -0.21472290f, -0.07104633f, 0.04704946f, -0.00776242f, 0.18056628f, 0.03779034f, 0.06259940f, 
    0.01306837f, -0.00889373f, -0.03424411f, -0.01355522f, -0.06368399f, -0.05004210f, -0.02688670f, -0.06533402f, 
    0.00895809f, -0.04297242f, 0.03421210f, -0.04774567f, -0.04311251f, -0.06366882f, 0.02596502f, -0.00822397f, 
    -0.00991378f, -0.02235454f, 0.03592162f, -0.00100754f, 0.00973454f, -0.05070847f, -0.03731681f, -0.05599269f, 
    -0.04988657f, 0.00496079f, 0.02873340f, 0.01778700f, -0.04674384f, -0.03525354f, -0.01741554f, 0.02313146f, 
    0.00768074f, -0.05763995f, 0.01498480f, -0.01575993f, 0.01432831f, 0.05503113f, 0.00968568f, -0.00022558f, 
    0.01934606f, -0.05924707f, 0.00206086f, 0.00462368f, -0.04194613f, -0.06626723f, -0.06853472f, -0.05796853f, 
    0.01457881f, 0.00517147f, -0.00268211f, 0.04223956f, 0.00391027f, -0.01828781f, -0.06021192f, 0.00587344f, 
    -0.03141434f, -0.05983227f, -0.00181950f, -0.00554270f, -0.02902361f, -0.05866837f, 0.04876580f, 0.02879689f, 
    0.01298644f, -0.04707795f, 0.03017878f, -0.04207998f, -0.05506249f, 0.00311352f, 0.01961658f, 0.03888996f, 
    0.03827125f, -0.01614048f, 0.01436809f, 0.02654036f, -0.03281129f, -0.04109310f, 0.03856149f, 0.04624265f, 
    0.01498566f, 0.03519668f, 0.01555146f, 0.02421096f, 0.01562954f, 0.04550442f, 0.02089959f, 0.00229011f, 
    -0.02622708f, 0.00588267f, -0.00594002f, -0.05907102f, -0.02597955f, 0.00753016f, -0.03246099f, 0.04782614f, 
    -0.01706520f, 0.04570631f, 0.03827883f, -0.04106580f, -0.03209956f, -0.03942648f, -0.04500864f, 0.00022956f, 
    0.02261027f, -0.06574681f, -0.04218170f, -0.04953690f, 0.02902114f, -0.06369542f, 0.02917563f, 0.02031142f, 
    0.00927106f, -0.05350344f, 0.04267040f, -0.01531065f, 0.02049042f, 0.04685572f, 0.03193390f, -0.05989548f, 
    -0.01619515f, -0.02005384f, -0.00750726f, 0.02912264f, -0.06108890f, -0.05452614f, -0.05896123f, -0.00825078f, 
    0.02591650f, -0.02972868f, -0.05921493f, -0.01735654f, 0.00170756f, -0.02623717f, -0.06145312f, -0.05325359f, 
    0.05026357f, -0.05840063f, 0.04140721f, -0.06082964f, 0.00725480f, 0.03541084f, -0.00891318f, 0.01435179f, 
    -0.05888339f, -0.05273595f, 0.02325761f, -0.05703933f, 0.01946096f, 0.02037560f, 0.02706779f, -0.06203888f, 
    0.01314749f, 0.01454565f, -0.05755190f, -0.00834447f, 0.03992267f, 0.01046551f, -0.02056734f, -0.03075664f, 
    -0.03581887f, 0.03590752f, -0.03983808f, -0.03687244f, 0.01877384f, -0.02966324f, -0.06428488f, -0.00597937f, 
    -0.05242426f, -0.01347706f, -0.06125347f, -0.00549560f, -0.05364559f, -0.05383430f, -0.00943379f, -0.00776584f, 
    0.00465342f, -0.01040674f, -0.01997593f, 0.01377609f, 0.04813819f, 0.00837327f, 0.00838093f, -0.02219648f, 
    0.01113554f, -0.04092389f, -0.03974168f, 0.03505238f, -0.02867726f, 0.01314915f, -0.02905261f, 0.00275527f, 
    -0.00285919f, -0.02787263f, -0.06170857f, -0.05838437f, -0.06154897f, 0.01343318f, -0.00968193f, -0.05121917f, 
    0.02602684f, -0.06438088f, 0.01537293f, 0.03307828f, 0.00850320f, -0.06587409f, 0.03017972f, 0.02387357f, 
    -0.02161646f, 0.02187734f, -0.02067739f, -0.05619320f, -0.02219592f, 0.02608599f, -0.02446360f, 0.03375635f, 
    0.01705502f, 0.03983073f, 0.01059886f, -0.05644129f, -0.04668632f, -0.04277002f, 0.01718722f, 0.03890032f, 
    -0.03082339f, -0.04719057f, 0.01200854f, -0.05179958f, 0.04401480f, 0.04062868f, 0.04284133f, 0.03203147f, 
    -0.06229976f, -0.02314848f, 0.01462147f, 0.04383814f, -0.04155020f, 0.01833977f, -0.03791343f, 0.01091142f, 
    0.04057078f, 0.01113545f, -0.00317457f, -0.03740286f, -0.00254687f, 0.03470181f, -0.02938645f, 0.03473224f, 
    0.00638438f, -0.03488513f, 0.00016214f, 0.02626365f, -0.04385378f, 0.03631341f, 0.00493654f, -0.03437104f, 
    -0.02283205f, -0.05106949f, -0.05546553f, 0.03445859f, -0.01548220f, -0.04422791f, -0.04643248f, -0.01531707f, 
    -0.04652096f, 0.04155119f, 0.03011011f, 0.05005014f, 0.04356993f, 0.02759373f, -0.01428022f, -0.04013763f, 
    -0.01498593f, 0.00429099f, -0.01242901f, 0.00117636f, -0.01665488f, 0.02806716f, -0.05324862f, 0.00821706f, 
    0.01189794f, -0.03759539f, 0.04384838f, 0.00629969f, -0.05185196f, 0.02317996f, -0.00452259f, 0.03632869f, 
    0.31221592f, 0.10695414f, 0.16850939f, -0.02667233f, 0.09390719f, -0.01770444f, 0.13293308f, 0.15360457f, 
    -0.16763721f, -0.40274259f, 0.03567402f, -0.31238729f, 0.13625677f, 0.04221668f, 0.09244282f, -0.11935456f, 
    -0.02743588f, -0.20171511f, 0.21226402f, -0.10809444f, -0.25543877f, 0.06782873f, 0.19111753f, -0.17301339f, 
    0.13990234f, 0.11596040f, 0.03694693f, -0.13996908f, 0.11546646f, 0.02534555f, -0.15155329f, 0.05810805f, 
    0.13662533f, -0.19470358f, 0.10796025f, -0.16922724f, 0.17373647f, 0.14598696f, 0.57254767f, 0.15750588f, 
    -0.18765508f, -0.18485960f, -0.06294928f, 0.06296308f, 0.04975637f, -0.13024357f, 0.15124698f, -0.03632474f, 
    -0.06594319f, -0.01064787f, -0.12544119f, -0.00083671f, -0.04837257f, 0.29437774f, -0.50556368f, -0.24598347f, 
    -0.18557794f, 0.20005345f, 0.22008356f, 0.21942833f, -0.09188191f, -0.13345639f, 0.03697822f, 0.24379809f, 
    0.08743668f, 0.13102700f, 0.03071607f, 0.10218135f, -0.04136098f, 0.01946698f, -0.05735906f, 0.15178035f, 
    -0.05456457f, -0.22946347f, -0.18539110f, -0.38143554f, 0.16479906f, -0.16200508f, 0.04426859f, 0.07381819f, 
    0.20746602f, 0.03717667f, 0.13368635f, 0.42904559f, 0.09553687f, 0.02639546f, 0.07569680f, -0.08727767f, 
    0.21302812f, -0.00831923f, 0.26345304f, 0.39909849f, 0.17362265f, 0.02322430f, 0.02735358f, -0.00042620f, 
    0.11605148f, 0.07001294f, 0.04037989f, -0.05584140f, 0.13222362f, -0.15475386f, -0.07793680f, 0.06509249f, 
    0.24928893f, -0.18625908f, 0.11445487f, 0.05734801f, 0.16562708f, 0.05230059f, 0.05629164f, 0.12295009f, 
    -0.14386609f, 0.09998356f, -0.04062759f, -0.00334781f, -0.07519256f, -0.17859539f, 0.00649243f, -0.02425307f, 
    -0.08686020f, 0.00648489f, 0.08554646f, -0.16354376f, -0.03223829f, -0.03721911f, 0.19153284f, 0.16251081f, 
    -0.03763103f, -0.10502882f, 0.00357541f, -0.08515398f, 0.00066023f, -0.07630151f, 0.40231812f, -0.06793794f, 
    -0.09294625f, -0.35097179f, -0.06603379f, -0.01567423f, -0.18289068f, 0.14892676f, 0.08833952f, 0.20333615f, 
    -0.21869633f, 0.03604688f, 0.04959010f, -0.15541486f, -0.21876322f, 0.00873836f, 0.03120594f, 0.21415155f, 
    -0.08725529f, -0.00281050f, 0.12504408f, 0.17495672f, -0.19589430f, -0.09393805f, 0.05900273f, 0.08604863f, 
    -0.09086975f, -0.07612581f, -0.52267367f, -0.13642074f, 0.28127035f, 0.06835417f, -0.00598188f, 0.09847415f, 
    -0.19042139f, -0.03201232f, -0.11686599f, -0.14836770f, 0.05821383f, -0.29889524f, 0.01744898f, -0.07026307f, 
    0.20020381f, 0.26461667f, -0.04005707f, -0.05569540f, 0.29263636f, 0.22192946f, 0.19402857f, 0.01424300f, 
    -0.16665474f, 0.14300615f, -0.02906901f, -0.15611334f, -0.07872166f, -0.65472436f, 0.02621892f, -0.03067633f, 
    0.17223170f, 0.03410107f, 0.03952887f, 0.05821884f, 0.06688685f, 0.05118992f, 0.02827778f, 0.12177917f, 
    0.02310350f, -0.13401714f, -0.05708534f, -0.03495411f, 0.04665563f, -0.05102567f, 0.16529597f, 0.21786074f, 
    -0.05809474f, -0.08537194f, 0.00657082f, -0.20200403f, 0.03606396f, -0.35166290f, -0.04403896f, -0.02219605f, 
    -0.08001629f, 0.14146663f, 0.06255929f, 0.01907557f, 0.27453977f, -0.03122122f, -0.06213530f, 0.15430677f, 
    0.05454320f, -0.10379564f, 0.12916180f, -0.32296959f, 0.11212406f, -0.16982323f, -0.03541796f, -0.15841790f, 
    0.03374450f, 0.06960216f, -0.26053810f, -0.09577271f, -0.14757511f, -0.01109068f, -0.04928223f, -0.14983028f, 
    0.03140641f, -0.05499969f, 0.09965615f, 0.02989544f, 0.02615902f, -0.01335268f, -0.07533181f, -0.17540477f, 
    0.15762362f, -0.10530126f, 0.05280235f, 0.02485698f, -0.41460180f, -0.19940200f, -0.12735493f, 0.05332454f, 
    0.02239971f, 0.05663594f, -0.01666955f, -0.04079786f, 0.26309577f, 0.08947423f, -0.09633338f, -0.11826892f, 
    0.04220841f, 0.04089018f, -0.01466124f, 0.00232791f, -0.11465169f, 0.04422680f, -0.18067864f, 0.07839228f, 
    -0.31348589f, 0.03969049f, 0.09915204f, 0.02620286f, -0.09758271f, 0.13706706f, 0.06359868f, -0.29873314f, 
    -0.10341778f, -0.03847758f, 0.19928528f, -0.13799872f, -0.07246680f, -0.04847215f, 0.12298164f, 0.20698844f, 
    -0.00755887f, -0.02566866f, -0.00339039f, -0.01335092f, 0.02005744f, -0.00302300f, -0.03915904f, -0.01806583f, 
    -0.02015899f, 0.01651424f, -0.00780442f, 0.03933393f, -0.01956512f, 0.01887911f, -0.03723789f, -0.03329956f, 
    -0.01500435f, 0.00927039f, -0.05998071f, -0.05399622f, -0.01354849f, 0.00878235f, -0.02916125f, -0.02905580f, 
    -0.05797648f, -0.05863653f, -0.03951893f, -0.05463751f, 0.05140217f, -0.05707375f, 0.01747676f, 0.01121965f, 
    0.01006300f, -0.04766280f, 0.02049537f, -0.06313491f, -0.05686482f, 0.03793146f, 0.02353295f, 0.01572284f, 
    -0.05118793f, -0.01475015f, 0.04904482f, -0.04730090f, 0.02410049f, -0.03905453f, 0.04125373f, -0.03826061f, 
    -0.05077444f, 0.04686373f, -0.05123328f, -0.05449664f, -0.03485300f, -0.01725323f, -0.05046479f, -0.03304176f, 
    0.00913831f, 0.00518771f, 0.02360782f, 0.00561656f, -0.00943327f, -0.02402419f, -0.05905510f, -0.06275199f, 
    -0.04202705f, -0.06111665f, 0.04443198f, 0.04560905f, -0.05337824f, -0.03696117f, -0.05053677f, -0.06547682f, 
    -0.04536656f, 0.01555207f, -0.03479366f, 0.01414309f, -0.04856599f, -0.02536604f, 0.02893263f, -0.02785122f, 
    -0.04946300f, -0.04026277f, -0.06668754f, -0.05225356f, -0.05371018f, 0.02855913f, 0.01418591f, 0.02754366f, 
    0.03466443f, -0.00285508f, 0.00257450f, 0.01041394f, -0.00936862f, -0.02856022f, -0.06614045f, 0.04677105f, 
    0.03696347f, -0.01495060f, -0.00340834f, -0.00297775f, 0.04609484f, -0.03354543f, -0.05339324f, -0.04237995f, 
    0.04341885f, -0.00385007f, 0.00180654f, 0.04152794f, 0.00174510f, 0.00087040f, 0.00310657f, 0.01422987f, 
    0.03669732f, -0.00631926f, -0.03070762f, 0.03228787f, 0.01234774f, 0.01122465f, 0.04307513f, -0.01520059f, 
    -0.03447034f, -0.00259319f, 0.02310977f, -0.04522319f, -0.03346063f, 0.01548623f, -0.05242602f, 0.02641698f, 
    0.00187621f, 0.03648856f, -0.03494946f, 0.00437115f, 0.03647013f, 0.01530175f, 0.03446633f, -0.06048827f, 
    -0.02558748f, -0.04306729f, 0.04948162f, 0.04437729f, -0.06023188f, -0.03013378f, 0.03526710f, -0.04057672f, 
    -0.00774596f, 0.00234478f, -0.02849772f, 0.04013328f, 0.02220383f, 0.03160600f, 0.00737495f, -0.02487867f, 
    -0.00608100f, 0.01405573f, -0.03266970f, -0.03122294f, -0.03553428f, -0.00802364f, 0.00643713f, -0.06342060f, 
    -0.05570634f, -0.04774121f, 0.05052514f, -0.01004911f, -0.00465790f, -0.00115607f, -0.04243415f, 0.00154494f, 
    -0.05872089f, 0.00643308f, -0.00026848f, -0.00188161f, 0.02770797f, 0.00160274f, 0.04505693f, -0.01714436f, 
    0.03397325f, -0.02827236f, 0.04375041f, 0.03884356f, 0.05284342f, -0.04179836f, 0.01523114f, -0.02748770f, 
    -0.02541784f, -0.04375910f, -0.03621381f, -0.03411882f, -0.01876338f, -0.03602890f, 0.04002162f, -0.06621139f, 
    0.03289863f, -0.00318236f, -0.00295732f, 0.02146527f, -0.05290733f, -0.01527326f, 0.02162379f, -0.00348537f, 
    -0.05641822f, -0.04522172f, -0.03355021f, 0.01792619f, -0.05067070f, 0.00848124f, -0.03598059f, -0.00614046f, 
    -0.00821187f, -0.04486464f, 0.02091780f, -0.01021701f, -0.06722189f, 0.04360711f, 0.00037531f, -0.03242856f, 
    0.02778766f, -0.01695318f, -0.06498303f, 0.03342200f, -0.02531925f, 0.01835861f, 0.00510629f, -0.06374913f, 
    0.03667671f, 0.04446029f, 0.02646612f, 0.02994129f, 0.02601205f, 0.02900497f, -0.01653118f, 0.04123122f, 
    -0.01391915f, -0.02244361f, 0.05056487f, 0.01398090f, 0.01116655f, 0.02675385f, -0.03824189f, -0.05542626f, 
    -0.00369172f, -0.05419705f, -0.01152239f, -0.01978529f, -0.04804210f, 0.03453270f, 0.01319004f, -0.05442652f, 
    0.01167828f, 0.01684463f, -0.02067691f, 0.02642560f, 0.04038715f, 0.04236018f, 0.04239432f, -0.05910335f, 
    -0.05059131f, -0.04511167f, -0.05509409f, 0.03447985f, -0.01680358f, 0.03217516f, 0.01563986f, 0.02403739f, 
    -0.05777032f, 0.02155048f, -0.05029928f, 0.02243362f, 0.00665402f, 0.01626636f, -0.00140250f, -0.04423459f, 
    0.00304551f, -0.01359048f, -0.03062139f, -0.00841270f, -0.00964177f, -0.00806488f, -0.02484283f, -0.04166091f, 
    -0.04717830f, -0.03338609f, 0.04655502f, -0.00051851f, -0.00726806f, 0.03025228f, -0.06483702f, 0.03000883f, 
    0.20043699f, -0.07196982f, 0.01778156f, -0.19691709f, -0.11551388f, -0.02505104f, -0.08995636f, -0.18265711f, 
    -0.05628986f, 0.09659760f, 0.27171019f, -0.03054836f, 0.26176968f, 0.11169966f, -0.06924053f, -0.06329747f, 
    -0.18164580f, 0.00109344f, 0.32230166f, -0.06949607f, -0.11628616f, -0.12916891f, -0.13692388f, 0.11362062f, 
    0.18323714f, -0.07081775f, -0.00331666f, -0.00398995f, 0.04994277f, -0.11337167f, -0.06025880f, 0.12214918f, 
    0.14043064f, -0.04074485f, 0.00952879f, -0.01540483f, -0.02097428f, 0.10187037f, -0.28854659f, -0.08029091f, 
    0.09595767f, -0.22874352f, -0.09620699f, 0.01479777f, -0.05655769f, -0.16230299f, 0.10022162f, -0.09580778f, 
    0.16779603f, 0.22431329f, -0.00660040f, 0.05078234f, -0.07960174f, -0.02553349f, -0.14054756f, -0.01556102f, 
    -0.09034839f, -0.04185633f, 0.22064313f, 0.16794144f, -0.11551917f, 0.08185863f, 0.00430411f, 0.48369196f, 
    0.07891361f, 0.01757810f, -0.37955388f, -0.29254818f, -0.03038534f, -0.05799216f, -0.12235201f, -0.01262337f, 
    0.03703836f, -0.13145104f, -0.23679586f, -0.02911736f, -0.11095434f, 0.12597826f, 0.16739772f, -0.12180253f, 
    0.03232962f, 0.06622238f, 0.12452865f, 0.03787626f, -0.01101459f, 0.00981307f, -0.09008685f, -0.07853304f, 
    0.18228246f, -0.04819109f, -0.07376542f, 0.29905269f, -0.17105235f, 0.20447953f, -0.27865312f, 0.03208317f, 
    -0.03468279f, 0.21467592f, 0.02288943f, 0.57763422f, 0.17260478f, -0.14277036f, 0.23043378f, 0.02432518f, 
    -0.15795825f, 0.07126199f, 0.02927015f, 0.11291203f, -0.35726154f, -0.02677018f, -0.03438097f, -0.14237449f, 
    -0.09950887f, 0.00104752f, 0.20761628f, 0.02037617f, 0.15140314f, -0.12779549f, 0.19969410f, -0.01725499f, 
    0.17709933f, 0.20951539f, -0.01722209f, 0.01483631f, 0.18442312f, -0.02325023f, -0.13026127f, -0.03018262f, 
    0.16062354f, -0.07481933f, -0.08432309f, 0.16077930f, -0.13887540f, 0.02337270f, -0.08964864f, 0.20760520f, 
    -0.25615323f, -0.14540006f, 0.05866218f, -0.02805555f, 0.18773066f, -0.19947782f, 0.03536098f, 0.15071666f, 
    -0.21195255f, 0.06964903f, 0.11408166f, -0.01830573f, -0.08621693f, 0.01230801f, 0.13217743f, -0.05567297f, 
    0.10437746f, 0.33140600f, 0.06431343f, -0.03547523f, -0.07993167f, -0.09481268f, -0.32246628f, -0.28062391f, 
    0.03937644f, 0.01643237f, -0.08908135f, 0.36991677f, 0.04499004f, 0.23483853f, 0.22726324f, -0.08049197f, 
    0.00408785f, -0.04100113f, 0.06307310f, 0.30911052f, -0.13379583f, -0.06393573f, 0.10317200f, -0.05296801f, 
    -0.02759073f, -0.01938385f, 0.05784018f, 0.02317065f, 0.21840166f, -0.09418707f, -0.07221673f, -0.12783949f, 
    -0.16243252f, -0.05652080f, -0.25167757f, 0.03378451f, -0.16184825f, -0.18188176f, 0.01028838f, 0.13955186f, 
    0.16306029f, 0.21939488f, 0.12508135f, -0.14978628f, 0.06600714f, -0.05880249f, 0.39887774f, 0.37769023f, 
    -0.25226879f, 0.06135424f, -0.01682357f, 0.11656830f, 0.00642261f, 0.04146859f, 0.01243179f, 0.44970965f, 
    0.32072100f, 0.27077952f, -0.03836582f, -0.07807037f, -0.00273821f, 0.12477709f, 0.13530731f, 0.10519028f, 
    0.19227120f, 0.07440598f, 0.07291739f, -0.08771507f, 0.08176281f, -0.10840251f, 0.06356239f, 0.16470703f, 
    -0.24870542f, 0.48767897f, 0.27278912f, -0.21352954f, 0.25960556f, 0.05482655f, -0.11527046f, 0.02194794f, 
    0.00709406f, 0.11193983f, -0.20418847f, -0.22733778f, -0.21496789f, 0.18472946f, 0.13489996f, 0.05038539f, 
    0.09535289f, 0.01389912f, -0.05619066f, 0.22381258f, -0.19775575f, -0.29110375f, -0.30400169f, -0.17677568f, 
    -0.08269360f, -0.08483841f, 0.08929684f, 0.05615395f, -0.25478628f, 0.00347840f, 0.02089081f, 0.20767449f, 
    0.16572863f, 0.16327500f, -0.03575088f, -0.18536206f, 0.07589479f, 0.19399141f, -0.19410409f, -0.03532989f, 
    0.19688495f, 0.07258704f, -0.00711364f, 0.12890345f, -0.07607408f, 0.03933102f, 0.15648182f, -0.14636239f, 
    -0.04955554f, 0.19108318f, 0.12350971f, 0.13419995f, -0.20171411f, 0.21331391f, 0.09365937f, -0.29232663f, 
    0.01624098f, 0.03053414f, 0.10027186f, 0.10722072f, 0.17534140f, 0.11880586f, -0.19526528f, -0.24732251f, 
    0.02716427f, 0.01036590f, 0.00545211f, 0.04348175f, 0.01391791f, 0.03654543f, 0.02334770f, -0.02083638f, 
    -0.06508857f, 0.00776882f, -0.03167616f, -0.05487872f, 0.04313740f, -0.05327162f, 0.01621090f, -0.06310742f, 
    -0.03642510f, -0.02183766f, -0.05551055f, 0.02212748f, -0.04418851f, 0.05356205f, -0.02259598f, 0.00036595f, 
    -0.03280581f, 0.00276992f, -0.05269942f, 0.01130508f, -0.01249261f, -0.00751449f, 0.03485139f, 0.02761709f, 
    -0.05285945f, 0.02487765f, 0.01793191f, -0.05673054f, -0.01748119f, -0.02449349f, -0.05570024f, -0.01763457f, 
    0.04984481f, -0.00031950f, -0.01969451f, 0.01355928f, -0.07015318f, -0.05707613f, 0.02520689f, 0.03889447f, 
    0.05982853f, -0.01583793f, -0.00901423f, -0.02597189f, 0.01970868f, -0.03652367f, -0.05483289f, -0.04220597f, 
    -0.03291447f, -0.06138195f, 0.00059826f, 0.04953495f, -0.02827576f, -0.06433319f, -0.00582987f, 0.02641156f, 
    0.02487414f, -0.01107915f, -0.03974290f, 0.02364009f, -0.04261232f, 0.04004107f, -0.02040091f, 0.01927734f, 
    -0.02355874f, 0.00610439f, -0.05226611f, 0.02256029f, 0.05367121f, -0.01873423f, -0.05422482f, 0.02027592f, 
    0.05216208f, -0.02455203f, 0.02708224f, 0.04262332f, 0.01855450f, 0.00256142f, 0.03751117f, -0.02729275f, 
    -0.01601263f, 0.05169184f, 0.03072953f, 0.02367594f, -0.04868231f, 0.00787654f, -0.06507897f, 0.05031678f, 
    -0.03123387f, -0.02077798f, 0.00354981f, -0.03872056f, -0.06220613f, -0.00456764f, 0.03338098f, -0.03222932f, 
    -0.00266480f, -0.04812238f, 0.03783094f, -0.04150257f, -0.06484376f, 0.00962100f, 0.00098307f, 0.02871462f, 
    -0.04083792f, 0.00091518f, -0.01606745f, 0.00106917f, 0.03497178f, -0.02402076f, -0.00511427f, -0.05345212f, 
    -0.05777656f, -0.06242939f, 0.02278247f, -0.03667702f, -0.03737011f, -0.03752954f, -0.03621277f, -0.03925185f, 
    -0.05489497f, 0.01772814f, -0.01404250f, -0.02736904f, 0.04651835f, -0.01396038f, -0.04678081f, -0.03554304f, 
    0.03633926f, -0.03060247f, 0.00971913f, -0.02086407f, 0.01215440f, -0.05054905f, 0.03472576f, 0.01226639f, 
    0.02691091f, 0.01655130f, 0.01189544f, -0.01803970f, -0.04507671f, -0.04306696f, 0.03320367f, 0.01751660f, 
    -0.01994172f, -0.00319285f, 0.01809090f, 0.00312378f, -0.06592610f, -0.05481234f, -0.02677544f, -0.04075951f, 
    -0.05833317f, -0.02527746f, -0.03398346f, 0.03424466f, 0.02569705f, -0.03941881f, 0.03801274f, 0.01182452f, 
    -0.01054780f, 0.05438634f, 0.00819936f, 0.02944124f, -0.05437428f, -0.03732786f, 0.02029347f, -0.05636430f, 
    0.04803862f, -0.05441458f, 0.02728257f, -0.03296107f, -0.05146698f, 0.01119161f, -0.05283422f, -0.06085835f, 
    0.03810021f, 0.00948540f, 0.04963163f, -0.07779694f, -0.01782089f, -0.00317471f, 0.03192149f, 0.01147666f, 
    0.01529696f, -0.00612760f, -0.02961600f, 0.03447429f, 0.03711333f, -0.05956370f, -0.01395049f, -0.00485710f, 
    0.02432889f, 0.04778529f, 0.00849165f, 0.01216146f, -0.02302011f, 0.00812436f, 0.04391909f, -0.07562286f, 
    0.04066661f, -0.06455444f, -0.07201548f, -0.02370596f, 0.04226661f, -0.03212053f, -0.04873243f, -0.03505460f, 
    -0.02873766f, -0.00161965f, -0.04446102f, -0.04833350f, 0.04116859f, 0.04094442f, -0.04155587f, 0.02650368f, 
    -0.01994249f, -0.03156624f, 0.02124836f, -0.02271033f, 0.05960170f, 0.03318661f, -0.04750560f, -0.04103377f, 
    -0.01287806f, 0.04372984f, -0.03627481f, 0.00543625f, -0.05739185f, 0.05464116f, -0.05224912f, 0.03382701f, 
    -0.02340222f, 0.00440842f, 0.01740768f, 0.02562516f, -0.07403408f, 0.00011854f, -0.00472688f, 0.02805349f, 
    0.04082449f, 0.02222153f, 0.04182495f, -0.03848887f, 0.02667154f, -0.02627500f, -0.00925970f, 0.02454661f, 
    -0.00996519f, -0.02210441f, -0.04572814f, 0.01229135f, 0.02175673f, -0.06495187f, 0.03456561f, -0.01429686f, 
    0.00477186f, 0.02929280f, 0.01307154f, -0.02955585f, 0.01159343f, 0.00792339f, -0.00506295f, -0.05732119f, 
    -0.00198561f, 0.02247132f, 0.00011671f, -0.02229281f, 0.01287992f, 0.03295961f, 0.04888225f, -0.02217733f, 
    0.02847034f, 0.03841839f, -0.01808862f, -0.00374229f, 0.04622169f, -0.04649542f, -0.01414682f, -0.00802946f, 
    0.14820448f, -0.17544228f, -0.23474674f, -0.01557827f, 0.05177794f, 0.21309933f, -0.11460942f, 0.15680173f, 
    0.18883720f, 0.42592478f, 0.01342194f, 0.25826007f, 0.17250702f, -0.14747280f, -0.01850167f, 0.15125729f, 
    -0.03176753f, 0.04396214f, 0.03283965f, 0.20621777f, 0.25855750f, 0.03446797f, -0.23673242f, 0.01434380f, 
    0.00648606f, 0.06061782f, 0.13145801f, 0.13034078f, 0.08925389f, 0.36884084f, 0.14978763f, 0.02522910f, 
    -0.23155220f, 0.19622196f, 0.01614635f, -0.05380897f, 0.16827491f, -0.22982369f, -0.01891700f, -0.15559313f, 
    -0.16606060f, -0.02205163f, -0.09079943f, 0.08718167f, -0.04770383f, -0.11378368f, -0.14638370f, -0.21572094f, 
    -0.18003480f, 0.09019711f, 0.15832935f, 0.04045022f, -0.09620076f, -0.09340619f, 0.06488913f, -0.12783372f, 
    -0.34552434f, -0.00233733f, 0.19613075f, -0.03360669f, -0.08496519f, -0.07031738f, 0.00202643f, 0.45205337f, 
    0.07886917f, 0.16905561f, 0.02526398f, 0.08708650f, 0.14128669f, -0.15523995f, 0.03338851f, 0.11326075f, 
    -0.41160506f, -0.18144552f, 0.19366769f, 0.03706744f, -0.04311544f, -0.21934064f, 0.04008398f, 0.01922038f, 
    0.01748872f, 0.30543867f, -0.22342861f, -0.21476644f, -0.06966399f, -0.21280967f, -0.03893565f, 0.06112339f, 
    -0.22861025f, 0.02969332f, -0.16950174f, -0.01462878f, 0.32393092f, 0.02120772f, 0.19478139f, 0.17632137f, 
    -0.16683260f, 0.03580900f, -0.40427557f, 0.19409946f, -0.26691231f, -0.19209997f, 0.10366133f, 0.03713517f, 
    -0.09860549f, -0.10571516f, 0.21656685f, 0.05251858f, -0.25340873f, -0.21719143f, 0.14329861f, -0.20272367f, 
    -0.01094597f, 0.09461202f, 0.05780618f, -0.14141269f, 0.10375113f, -0.06875359f, -0.08147797f, 0.09464157f, 
    0.02752902f, -0.16821730f, 0.08984148f, -0.05228214f, 0.06398800f, -0.13124396f, -0.17065881f, 0.00443440f, 
    -0.19529904f, 0.01851559f, -0.08329022f, 0.15953726f, -0.08743822f, -0.33475506f, -0.13184178f, 0.09675370f, 
    0.16880146f, 0.33757985f, 0.05963651f, 0.03437189f, -0.06284314f, 0.04362968f, 0.06523757f, 0.04630868f, 
    0.21602570f, -0.09551620f, -0.11043322f, 0.07312951f, 0.05870286f, -0.11519389f, -0.09548704f, 0.15758042f, 
    -0.15562223f, -0.05531551f, -0.12287161f, 0.22407021f, -0.01894809f, -0.00165013f, 0.03648359f, 0.07381504f, 
    0.09003137f, -0.13767372f, 0.44263655f, -0.13913859f, -0.19756493f, 0.18496920f, 0.08835457f, 0.21404472f, 
    0.02886322f, 0.01802284f, 0.15617053f, 0.26666179f, 0.04885761f, -0.32671860f, -0.13538206f, 0.02288598f, 
    -0.09112395f, -0.05344529f, -0.10012171f, 0.07442879f, 0.04491259f, -0.06690205f, -0.07310498f, -0.16089295f, 
    0.07936352f, 0.00144198f, -0.06418803f, 0.19593543f, 0.11774731f, 0.02276904f, -0.12647262f, 0.11768062f, 
    0.01320710f, -0.07718847f, -0.09534186f, -0.02555226f, -0.01287910f, 0.03435270f, 0.01823693f, -0.07267760f, 
    0.02119746f, -0.06341208f, -0.04073260f, -0.10887659f, 0.06621945f, -0.13804503f, -0.01383473f, 0.06775762f, 
    -0.14232716f, 0.22263233f, -0.05198138f, 0.08087353f, -0.03272013f, -0.00019861f, -0.00443319f, 0.04276981f, 
    0.43607214f, -0.28594097f, -0.05463706f, -0.03557825f, -0.03379781f, 0.01314383f, -0.11224273f, -0.01688751f, 
    0.13969971f, 0.27831084f, -0.02627008f, 0.00989919f, 0.06634051f, -0.07444314f, -0.12616201f, 0.09513456f, 
    0.01185242f, 0.08325727f, -0.17925966f, -0.08073949f, -0.01681743f, -0.01904147f, 0.00860175f, 0.16198741f, 
    -0.02844320f, -0.14980926f, 0.05282715f, 0.10730401f, 0.16848256f, -0.05982449f, -0.13433553f, 0.08280906f, 
    0.14994386f, -0.07721416f, -0.02917839f, 0.08649566f, 0.20758055f, -0.08830341f, -0.01526724f, -0.09680673f, 
    -0.08450361f, 0.24225092f, 0.00744547f, 0.00880376f, -0.15648912f, -0.02380625f, 0.08108659f, -0.50553155f, 
    -0.00963276f, -0.02013273f, 0.17682631f, -0.07249986f, 0.07755579f, 0.05213806f, 0.14356445f, 0.03732215f, 
    0.32273877f, 0.08011868f, -0.00838084f, 0.15635733f, -0.01573917f, -0.12230342f, -0.13115294f, -0.32588238f, 
    -0.27558020f, 0.28076556f, -0.13443942f, -0.07458639f, -0.27715245f, 0.00282266f, -0.01927968f, 0.12898433f, 
    -0.10042354f, 0.06060040f, -0.26283059f, 0.05779726f, -0.05396980f, -0.10925075f, -0.06767518f, -0.04250412f, 
    0.05335816f, -0.11510485f, 0.05142512f, -0.15803026f, 0.10991284f, 0.07009740f, 0.05284061f, 0.02847337f, 
    -0.00236290f, -0.00320754f, 0.05941261f, -0.40484723f, 0.02688193f, -0.09517419f, 0.03189808f, 0.07149199f, 
    0.07697412f, -0.08203737f, -0.09301913f, -0.18098463f, -0.00634052f, -0.10610752f, 0.00730222f, 0.19826189f, 
    0.05567521f, -0.04683061f, 0.02798942f, 0.03137237f, -0.24086714f, 0.24803835f, -0.47156832f, -0.24860843f, 
    0.10852908f, 0.01106937f, -0.20949261f, 0.15844072f, -0.06710764f, 0.40349355f, 0.27704924f, 0.33493176f, 
    -0.04048951f, 0.02436340f, -0.01044084f, 0.10099345f, -0.04654275f, 0.11319606f, -0.23089664f, -0.29011902f, 
    -0.06443457f, -0.11913914f, 0.30193773f, -0.22350900f, -0.06754494f, -0.05817407f, -0.01205830f, 0.18514214f, 
    -0.18069306f, -0.19224010f, 0.01196492f, -0.06654111f, 0.00912515f, -0.15959491f, -0.07732356f, -0.02135565f, 
    0.31419775f, -0.18468429f, -0.42211783f, 0.03109881f, -0.05663512f, 0.06596208f, -0.01793011f, 0.16736539f, 
    -0.04309362f, -0.19044936f, 0.04236444f, -0.20172025f, -0.10689107f, 0.03430357f, 0.06093145f, -0.00207149f, 
    -0.11364497f, -0.06159079f, 0.03747674f, -0.17273811f, -0.26031110f, -0.09216761f, -0.20396219f, -0.12718497f, 
    0.05974527f, 0.09832519f, 0.10475239f, 0.12710322f, -0.07554986f, -0.33892763f, -0.07235406f, 0.04510848f, 
    -0.02859415f, -0.03014115f, -0.17907205f, -0.12229629f, -0.22277966f, -0.12002007f, -0.18146193f, -0.04657849f, 
    -0.00599524f, -0.00227588f, 0.14835443f, 0.11829709f, 0.03087582f, 0.20722343f, 0.15423790f, 0.19702263f, 
    0.13021053f, 0.04195802f, -0.02994819f, 0.14476173f, 0.02527207f, 0.01016266f, -0.24068664f, 0.01806798f, 
    0.31510869f, -0.08349386f, -0.00168791f, -0.08563290f, -0.00965751f, -0.07139686f, -0.32707348f, -0.35960171f, 
    -0.30073047f, -0.11213426f, -0.11941726f, 0.10761555f, 0.10626108f, 0.07541506f, -0.01803538f, -0.21022178f, 
    0.42919967f, 0.37164193f, -0.13057099f, -0.07482780f, 0.21427570f, 0.11960118f, 0.03056091f, 0.05118201f, 
    0.11355025f, -0.03973915f, -0.17841153f, -0.25881547f, 0.05965686f, 0.21205305f, 0.04313249f, 0.01610645f, 
    -0.14133817f, -0.10830010f, 0.21781197f, 0.16269971f, 0.18850562f, 0.04148338f, -0.05381222f, 0.02124543f, 
    -0.26531309f, 0.03468999f, 0.03356007f, -0.13469853f, 0.14211540f, 0.44547167f, -0.02439022f, -0.10593395f, 
    0.04482881f, 0.17701581f, -0.01167789f, 0.15470496f, -0.28256279f, -0.27552792f, -0.49455360f, 0.12601487f, 
    0.00950676f, 0.13604957f, 0.19935262f, 0.08307640f, 0.04031284f, 0.18095323f, 0.02082852f, 0.15540545f, 
    0.00807865f, 0.04249800f, 0.01388771f, 0.18271366f, 0.00664240f, 0.01967849f, -0.19627026f, -0.11697195f, 
    -0.24877656f, -0.14051151f, 0.15321459f, 0.05389168f, -0.06919276f, -0.00748679f, -0.11333554f, 0.09827043f, 
    -0.14045869f, 0.11577471f, 0.04153636f, 0.06700648f, -0.07516183f, 0.12713285f, -0.22991003f, -0.10849817f, 
    0.22121216f, 0.11322055f, -0.39833522f, 0.06189166f, 0.06125397f, 0.05167731f, -0.08708702f, 0.04385695f, 
    -0.23003682f, 0.38137388f, 0.21442515f, 0.03243661f, 0.19906345f, -0.01970755f, 0.18534555f, 0.09970549f, 
    0.13609655f, 0.21841104f, 0.01964713f, 0.13708217f, 0.20520823f, -0.07225647f, 0.30106583f, 0.03337154f, 
    -0.01310225f, 0.09191664f, -0.11253258f, -0.09643140f, -0.59528613f, 0.05292743f, 0.14688240f, -0.08707410f, 
    -0.03349702f, 0.10236798f, 0.05748409f, -0.05993893f, 0.41459176f, 0.05555468f, 0.23789729f, -0.14117491f, 
    -0.02220056f, -0.09865664f, -0.07322113f, 0.10089565f, -0.04631615f, -0.15231615f, -0.32890010f, 0.24556738f, 
    -0.00238258f, -0.11353781f, 0.16865198f, -0.00296250f, 0.22611059f, -0.01885368f, 0.38249448f, 0.29928955f, 
    -0.00042500f, 0.07141028f, -0.15209422f, -0.11311699f, 0.10919607f, -0.04690186f, -0.17514840f, 0.69925708f, 
    -0.20678246f, 0.36702719f, -0.20752566f, 0.05653856f, 0.03266757f, 0.05195122f, -0.02577573f, 0.12899837f, 
    0.18262896f, 0.25024202f, -0.10631488f, 0.11768496f, 0.01328485f, -0.12286481f, 0.23570700f, 0.09041824f, 
    -0.07263044f, 0.35264775f, -0.39609149f, 0.03488566f, -0.09908948f, -0.01950595f, -0.01367595f, -0.13211602f, 
    -0.02504520f, -0.10698551f, -0.13130634f, 0.03200154f, -0.04053498f, 0.12781727f, -0.10801750f, 0.04665205f, 
    0.04042148f, 0.13649110f, -0.05664083f, 0.28482437f, 0.34939277f, 0.20601915f, -0.04559816f, -0.05825167f, 
    0.09238516f, -0.24191399f, -0.17253299f, -0.33668387f, 0.21559490f, 0.54732853f, 0.31487161f, 0.15950592f, 
    -0.19222218f, 0.04997387f, 0.03955399f, 0.00990070f, 0.04070831f, -0.06964038f, -0.30874377f, 0.34810707f, 
    0.03001329f, -0.08006830f, -0.10330173f, 0.06588168f, -0.15384994f, 0.07121456f, -0.05550104f, 0.03985844f, 
    -0.04078175f, 0.06171488f, 0.04806230f, 0.13306986f, 0.07578105f, -0.38164860f, -0.23707789f, 0.19612378f, 
    0.08014427f, 0.12801667f, 0.07946951f, 0.18588184f, -0.38410348f, 0.28929073f, 0.10738717f, 0.01867426f, 
    0.21384816f, -0.19870150f, -0.12190662f, -0.08831778f, -0.05383707f, -0.18946928f, 0.04963087f, 0.13500965f, 
    0.07097140f, 0.08013319f, 0.41108149f, 0.25002742f, 0.01670706f, -0.16559817f, -0.02117952f, 0.00015617f, 
    0.02823762f, 0.02314293f, 0.21159633f, 0.04008880f, 0.13924663f, -0.02169169f, 0.04106338f, 0.08101682f, 
    -0.00337290f, -0.01330128f, 0.18113661f, 0.25395757f, -0.31743124f, -0.28021723f, -0.02656321f, 0.00361618f, 
    0.13474691f, -0.15371954f, -0.09751679f, -0.15146495f, 0.01100983f, 0.11082427f, -0.14083755f, 0.03523513f, 
    0.15436375f, 0.00338570f, 0.00693984f, -0.03369728f, 0.01988298f, 0.02620182f, -0.21582551f, 0.12103345f, 
    -0.11634111f, -0.00674079f, 0.07374443f, -0.02790140f, -0.18812340f, -0.11339595f, 0.41598150f, 0.10408870f, 
    -0.02031954f, -0.31322083f, -0.03287723f, -0.11220012f, -0.00581832f, -0.01275429f, 0.11639702f, -0.17723684f, 
    -0.25170252f, -0.16952385f, 0.14049487f, -0.14218093f, -0.11702359f, -0.04863624f, -0.03233028f, 0.12055348f, 
    0.01820236f, 0.19201279f, -0.28005195f, 0.17151670f, 0.14902422f, 0.03436847f, -0.03189591f, -0.07105714f, 
    -0.18819664f, 0.16649587f, 0.28687850f, -0.05857339f, -0.04440949f, -0.00301996f, -0.00678581f, 0.11022225f, 
    0.09289027f, -0.16412146f, -0.01965179f, -0.29525885f, -0.08320741f, -0.15099691f, 0.02912147f, -0.08567503f, 
    -0.25525776f, -0.10365959f, -0.26888087f, 0.37658125f, -0.07321137f, -0.07019094f, -0.01204813f, -0.18018708f, 
    0.12229487f, 0.10229728f, 0.16546337f, -0.01843483f, 0.40016201f, 0.22965774f, -0.07781415f, 0.07377093f, 
    -0.09553422f, -0.13936481f, 0.33062524f, -0.11678699f, 0.08554688f, -0.12085725f, -0.30344713f, 0.00951499f, 
    0.00632577f, 0.04252051f, 0.14837249f, 0.05617135f, 0.04802603f, -0.06167813f, -0.14142759f, 0.13495319f, 
    0.04069532f, -0.05006711f, -0.27196190f, -0.10775957f, -0.16998143f, -0.00582013f, 0.14415932f, -0.35946327f, 
    0.16689271f, -0.01246196f, -0.00755576f, -0.18415590f, 0.09029389f, -0.40306652f, -0.04398568f, -0.10399318f, 
    -0.03765664f, 0.20903264f, 0.03816714f, 0.05245064f, 0.04089889f, 0.04317103f, 0.16251042f, 0.01574499f, 
    0.00696634f, -0.10027799f, -0.29153499f, -0.10472659f, 0.06144211f, 0.05295967f, 0.03913358f, -0.03606590f, 
    -0.23749092f, -0.03486713f, 0.03321845f, -0.05520644f, -0.07866237f, -0.14131993f, -0.16704275f, -0.13115193f, 
    -0.02107379f, -0.07242711f, 0.08957393f, 0.12539086f, 0.14744942f, 0.17733960f, -0.02941562f, 0.12348128f, 
    0.00071455f, -0.10378695f, -0.04998082f, 0.01220401f, -0.27700412f, -0.07258214f, -0.10821375f, -0.06873246f, 
    -0.03032699f, -0.18029726f, -0.03332261f, 0.09892927f, -0.00338499f, 0.13145952f, 0.10819387f, -0.07240717f, 
    -0.00101724f, -0.06248495f, 0.08500847f, 0.07613360f, 0.09969416f, -0.12306421f, -0.25964558f, -0.15524036f, 
    0.07241759f, 0.06394599f, -0.02415119f, 0.06300971f, -0.11842650f, 0.07446782f, -0.13532890f, 0.02905640f, 
    0.02257271f, -0.01601198f, 0.16386089f, -0.04878955f, 0.03228818f, 0.01697967f, 0.05114929f, 0.32635984f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.05316062f, 0.20854260f, 0.00450310f, 0.01411758f, 0.00933123f, -0.03120415f, -0.02205631f, 0.01522014f, 
    0.08162309f, 0.20301211f, 0.00491564f, 0.10033888f, 0.04839263f, -0.02477339f, -0.20135345f, 0.30788407f, 
    0.01417671f, 0.03569688f, 0.23172484f, 0.16542362f, 0.01388678f, -0.18329570f, 0.04109651f, 0.03842545f, 
    -0.01459431f, 0.03331489f, -0.01642251f, -0.01428637f, -0.05484827f, 0.04861349f, 0.03707118f, -0.12995292f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.01452962f, 0.41598791f, 0.04983973f, 0.53507465f, -0.22832847f, 0.07766189f, -0.17876679f, 0.39225829f, 
    -0.62565196f, -0.12111273f, 0.15992612f, -0.35542545f, 0.35067970f, 0.15297739f, -0.35067034f, 0.35056949f, 
    0.04692622f, 0.10442601f, -0.26029843f, 0.23563010f, -0.31566668f, -0.37622625f, 0.24638194f, -0.00877717f, 
    0.09628975f, -0.45382810f, 0.16589338f, -0.28942487f, -0.15724078f, 0.73478144f, -0.15284337f, -0.38521853f, 
    -0.13658515f, 0.38595691f, -0.04772019f, -0.38228405f, 0.38690647f, -0.01321302f, 0.15556718f, -0.19359560f, 
    -0.52936733f, 0.21576223f, -0.16035517f, -0.24797638f, -0.32455748f, -0.02009076f, -0.21631362f, 0.16721845f, 
    -0.08887492f, 0.46112943f, 0.21486697f, 0.19417959f, 0.60636157f, -0.26802742f, -0.35944036f, -0.17129110f, 
    -0.12632877f, 0.20648982f, -0.13046901f, -0.39522308f, -0.13388155f, 0.09875330f, 0.07710561f, 0.57801223f, 
    0.09749697f, -0.07812046f, -0.09221303f, -0.71168751f, -0.13047479f, 0.09719849f, -0.04950751f, 0.04096215f, 
    0.28225532f, -0.41938218f, -0.06130991f, 0.15341459f, 0.17796278f, 0.11487816f, 0.09334904f, -0.42810830f, 
    0.01883023f, 0.94043112f, -0.56024367f, -0.31738877f, 0.42321357f, -0.29822800f, -0.03826283f, 0.22706403f, 
    -0.01437052f, -0.14756916f, 0.03797623f, 0.36810312f, -0.15017353f, 0.43511188f, 0.12888795f, -0.65550369f, 
    -0.16828544f, -0.65929323f, -0.15967943f, -0.07167633f, -0.42928827f, 0.07948687f, 0.09485584f, -0.10990869f, 
    0.14882040f, 0.53305250f, 0.02177547f, -0.27383947f, 0.04998281f, 0.17702220f, -0.75822437f, -0.37427860f, 
    0.15024309f, -0.13773580f, -0.02301891f, -0.49889958f, -0.45286021f, 0.25504282f, 0.40113518f, 0.51872170f, 
    -0.01869640f, -0.24585600f, 0.02131339f, 0.00228454f, -0.08599249f, 0.71899527f, -0.19731562f, 0.56873977f, 
    0.15118688f, -0.35423285f, -0.01301898f, -0.10352346f, 0.29802915f, -0.10310180f, 0.10083883f, -0.57276911f, 
    -0.07213229f, 0.08721512f, -0.03903439f, 0.51105005f, 0.28385654f, -0.08254881f, 0.00677202f, 0.56776083f, 
    0.09496253f, -0.01096602f, 0.02797905f, -0.13331954f, -0.64892119f, -0.15036637f, 0.01219592f, 0.66554868f, 
    0.15807442f, -0.11226389f, 0.03992533f, 0.11327498f, 0.08015165f, -0.31214377f, -0.77185303f, -0.49005389f, 
    -0.01219845f, 0.35845378f, -0.02914235f, -0.07909028f, -0.25922713f, -0.15871429f, 0.14611481f, 0.65429628f, 
    -0.20887636f, -0.02020986f, -0.08683912f, 0.36656463f, -0.64677471f, -0.09774587f, 0.30035177f, 0.30147058f, 
    -0.00870102f, -0.51440310f, 0.72612816f, -0.50160122f, 0.13510242f, 0.10617141f, -0.16618669f, -0.58672774f, 
    0.00636235f, 0.09681147f, 0.16341013f, -0.23413476f, 0.15705423f, -0.59666342f, -0.14406168f, 0.17450830f, 
    -0.12724672f, -0.30647218f, 0.03546665f, -0.08164430f, -0.64420575f, -0.05665313f, -0.03657321f, 0.06308442f, 
    -0.53071821f, 0.35711035f, -0.09985925f, 0.30230522f, -0.17770886f, 0.04420867f, 0.05535613f, -0.31803352f, 
    0.10825878f, -0.01627988f, 0.36466473f, 0.65630412f, -0.74777657f, -0.23326783f, -0.13065344f, 0.16052766f, 
    -0.00221852f, -0.63527983f, 0.13342032f, 0.18956645f, 0.03561922f, -0.21938604f, 0.69656587f, -0.60418499f, 
    -0.10437898f, -0.45867270f, 0.05599920f, 0.50780398f, 0.38936424f, -0.02759895f, 0.12918192f, -0.56330198f, 
    -0.61231786f, -0.33148241f, -0.14230782f, 0.14426067f, 0.46666783f, 0.11827903f, 0.70184547f, -0.30622095f, 
    0.06985530f, -0.21270603f, 0.17170857f, -0.59604889f, -0.17795965f, 0.17453885f, 0.19834058f, -0.01070013f, 
    0.09310313f, 0.31454402f, -0.13781351f, -0.19979717f, -0.03071644f, -0.07980204f, -0.24210197f, 0.30582273f, 
    0.14174585f, 0.35785031f, -0.08977678f, 0.66398221f, 0.41890851f, -0.12675072f, 0.12845716f, -0.40787107f, 
    0.66902739f, -0.45334950f, 0.06550998f, -0.03015743f, -0.35482997f, 0.03224957f, 0.26942274f, 0.05873962f, 
    -0.10292000f, -0.10156316f, -0.06787318f, -0.15307102f, -0.16000704f, -0.14066467f, -0.50478721f, -0.33630395f, 
    -0.15904403f, 0.34776673f, -0.07459487f, 0.05483465f, 0.13494439f, -0.62152123f, -0.01616931f, 0.40139061f, 
    0.05421221f, -0.19293159f, 0.05607093f, -0.76967138f, -0.12831852f, 0.04135011f, -0.08184510f, -0.04155875f, 
    0.64109731f, -0.00847239f, -0.12225448f, 0.36128560f, 0.62359124f, -0.12607396f, -0.41271436f, 0.26758218f, 
    0.05601837f, -0.95646298f, -0.56864226f, 0.27269971f, -0.06466394f, -0.01015972f, -0.36623520f, -0.24304856f, 
    0.00332239f, 0.05721414f, -0.05135074f, 0.07551989f, -0.04763808f, -0.55949444f, 0.56955868f, -0.10413413f, 
    0.10585252f, -0.05147662f, -0.16307864f, 0.01828071f, 0.13385393f, -0.01566461f, 0.14403862f, -0.46071187f, 
    0.04664777f, 0.27191940f, -0.03862542f, -0.56972551f, -0.55163395f, -0.03782417f, -0.10352340f, -0.40909633f, 
    0.09365593f, 0.24413937f, -0.03232596f, 0.05030360f, 0.18934347f, -0.42821917f, 0.52942145f, -0.51940197f, 
    0.09831044f, 0.69349593f, -0.13354115f, 0.49195281f, 0.07218786f, -0.17596179f, -0.22433607f, -0.03654894f, 
    -0.16256119f, -0.46947160f, 0.08692405f, -0.15613770f, 0.12721711f, -0.14613980f, 0.06073022f, -0.06217000f, 
    -0.13587904f, 0.09596583f, -0.05849363f, -0.40733907f, -0.57556129f, 0.04343659f, 0.58196330f, -0.38885546f, 
    -0.09868494f, -0.55142093f, -0.02976565f, 0.41668537f, 0.17129058f, 0.78034258f, 0.17534018f, -0.13202988f, 
    -0.18376192f, -0.79773515f, 0.03294421f, 0.31298813f, 0.04178118f, 0.11077165f, -0.08038592f, -0.58641309f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.04795904f, -0.02902151f, -0.02591743f, -0.00999003f, 0.12947088f, 0.17139618f, 0.06299493f, -0.43079668f, 
    -0.11122725f, 0.15753084f, 0.14136170f, 0.15130688f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
