#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.02390420f, -0.03277657f, 0.34716934f, 0.24029928f, 0.41594940f, -0.36263153f, -0.06027305f, 0.50867110f, 
    0.31130108f, -0.15300441f, -0.35597086f, -0.25966507f, 0.76958555f, -0.64231265f, -0.09720196f, 0.28185034f, 
    -0.19147290f, -0.23779443f, -0.34006694f, -0.45988703f, -0.59682775f, -0.29764187f, 0.23625639f, -0.20990433f, 
    -0.00106105f, 0.90396523f, -1.00020719f, -0.10975067f, 0.63526732f, 0.15118429f, 0.63357008f, 0.59199262f, 
    0.06802867f, -0.70525014f, -0.16330035f, 0.14190850f, -0.19409852f, 0.01098973f, -0.35223788f, 0.06498183f, 
    0.18568537f, -0.18984222f, 0.03707104f, -0.06640518f, -0.56799138f, -0.20044844f, 0.21901385f, -0.01600127f, 
    0.14871579f, 0.02444626f, -1.31120598f, -0.62045437f, -0.03184372f, 0.58469898f, 0.06462596f, 0.48820800f, 
    -0.32846451f, 0.39382038f, 0.38729775f, 0.57184213f, -0.05364070f, 0.18549581f, -0.17863616f, 0.74716198f, 
    -0.24341868f, -0.19820467f, -0.06311561f, -0.29490504f, 0.08113448f, 0.08548346f, -0.17363234f, 0.25011027f, 
    0.37808207f, 0.08682334f, -0.25192925f, -0.10871591f, -0.28429550f, 0.43271464f, 0.26536152f, -0.12959316f, 
    -0.16667333f, -0.20917428f, -0.29290816f, -0.00793158f, 0.37515569f, 0.14922838f, -0.28531250f, 0.42044756f, 
    0.11211876f, 0.01900313f, -0.26757362f, -0.14721794f, 0.09094006f, -0.22039947f, -0.58871931f, 0.32105520f, 
    0.47012725f, 0.32270914f, 0.54426271f, 0.52190226f, -0.61217165f, -0.60169321f, -0.46829998f, -0.32987016f, 
    -0.49520960f, -0.85205370f, -0.81884176f, -0.78681707f, -0.42756739f, -0.82431614f, 0.28799567f, 0.58853424f, 
    -0.13630430f, -0.24701504f, -0.03945354f, -0.46967217f, -0.14764349f, -0.45656762f, -0.46734467f, -0.42057183f, 
    -0.23051547f, -0.03622829f, -0.27729088f, 0.19388810f, -0.05705478f, 0.32402959f, 0.64500773f, 0.59033781f, 
    -0.60541803f, -0.31618908f, -0.43731639f, 0.31639510f, 0.07991184f, -0.03879925f, 0.12624784f, -0.22141518f, 
    0.25768539f, 0.52572441f, -0.57003742f, -0.26983216f, 0.27254900f, -0.37573224f, -0.42100471f, 0.15460271f, 
    0.31846210f, -0.15203044f, 0.46452564f, -0.25913066f, -0.41454834f, 0.29123524f, 0.73615223f, 0.87776673f, 
    0.68701762f, -0.49353907f, -0.06418794f, -0.45675936f, 0.18954174f, 0.39588022f, -0.18376289f, -0.05825201f, 
    -0.08808693f, 0.06829966f, 0.12384903f, 0.10935947f, -0.13250849f, 0.21917035f, -0.01123939f, -0.13257734f, 
    -0.14125347f, 0.07429501f, -0.14679097f, 0.28486204f, -0.10664491f, -0.06921011f, 0.01327054f, -0.96633035f, 
    -0.79580355f, -0.12906571f, -0.74986959f, 0.40884954f, 0.69662803f, -0.05219450f, 0.11643658f, 0.21341939f, 
    0.80408996f, -0.57690406f, -0.31686071f, -0.21472672f, 0.06835586f, 0.31432393f, 0.00307844f, -0.14402550f, 
    0.17200948f, 0.13650911f, -0.12857525f, 0.22810362f, -0.09364382f, 0.35690558f, 0.13097478f, -0.20204377f, 
    0.52115256f, 0.62877810f, 0.08250334f, -0.09034106f, 0.16894431f, 0.17382410f, 0.31685102f, 0.43494949f, 
    -0.06610661f, -0.11569735f, -0.19283424f, -0.25263503f, 0.26890701f, -0.03315445f, -0.40568802f, 0.06757079f, 
    0.13703819f, 0.11344716f, 0.07605477f, -0.18004410f, -0.01943601f, -0.25414795f, -0.39643139f, -0.31245777f, 
    -0.65818137f, -1.35928988f, -0.43810913f, -0.61582810f, -1.04348505f, -0.84305471f, 0.01517999f, -0.12939440f, 
    0.10662217f, 0.71264237f, 0.69896638f, -0.10126161f, -0.46635908f, -0.38936839f, -0.37949508f, -0.21865620f, 
    0.04038782f, 0.26454195f, -0.28142884f, 0.09625572f, 0.10215988f, -0.46210653f, -0.24940744f, -0.06678259f, 
    -0.38515636f, -0.28446117f, 0.93186110f, -0.56348252f, -0.14732611f, -0.35448569f, 0.00885078f, 0.41232774f, 
    -0.37580708f, 0.08203622f, 0.90193975f, -0.42272863f, 0.43422616f, -0.36002472f, -0.07435003f, -0.19146715f, 
    -0.08053412f, -0.08576836f, -0.02970368f, 0.05183404f, -0.16872455f, 0.38722631f, -0.10412934f, 0.02250926f, 
    0.14858101f, -0.16080093f, 0.08318572f, -0.14835992f, 0.24539368f, 0.47261226f, 0.42003977f, 0.29242167f, 
    -0.28214481f, -0.58530843f, 0.10675541f, 0.57771748f, 0.01541604f, -0.04539678f, -0.03848141f, -0.00955005f, 
    0.30199721f, -0.21920833f, 0.10015568f, 0.33136159f, 0.04367576f, 0.27615899f, -0.06728722f, 0.01492117f, 
    -0.51337397f, -0.35470957f, 0.14736064f, 0.34747788f, 0.86800987f, 0.93550485f, 0.38039467f, -0.18612483f, 
    0.75532025f, -0.53104264f, -0.35641617f, -0.50577748f, -0.62370527f, -0.55677402f, -0.04233751f, 0.14650042f, 
    -0.18927903f, 0.12768243f, -0.02265463f, -0.01525718f, 0.27586854f, -0.24852043f, -0.13575229f, 0.32583860f, 
    -0.11758628f, 0.18141006f, 0.14714061f, 0.18606499f, 0.05182916f, -1.39170742f, 0.00107415f, -1.36997509f, 
    -0.52232063f, 1.04284298f, 0.17512915f, 0.36595941f, -0.42343462f, -0.57290471f, -0.08337850f, 0.39297912f, 
    0.59212697f, 0.06591363f, -0.07933822f, -0.09866031f, 0.23183380f, -0.02886619f, -0.39502293f, 0.15688851f, 
    -0.08619235f, 0.25658751f, -0.41102314f, -0.08005515f, -0.11938864f, -0.39811435f, -0.50712466f, -0.81118214f, 
    0.03390004f, 0.50455552f, -0.22529857f, 1.05250621f, -0.09112328f, -0.06813257f, -0.06694394f, 0.24818771f, 
    0.35031012f, 0.31557518f, -0.27018583f, -0.29796717f, -0.42746598f, -0.59947419f, 0.09378763f, 0.18068373f, 
    -0.24140148f, 0.16528684f, -0.00217504f, 0.07405041f, -0.11802709f, 0.27745247f, -0.00227185f, -0.88608980f, 
    -0.82295132f, -0.34577653f, -0.58953571f, -0.50399917f, -0.20273781f, -0.18713313f, -0.46922630f, -0.75308907f, 
    -0.77886218f, 0.02294523f, -0.25003535f, -0.10568732f, -0.10262296f, -0.23984326f, 0.24222295f, 0.11472207f, 
    -0.05524341f, 0.25500250f, -0.08636416f, -0.04498188f, 0.44241476f, 0.36001411f, 0.25533360f, 0.31696257f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.34955862f, 0.62774348f, 0.26859674f, 0.27453083f, 0.02301895f, 0.47252095f, 0.10835288f, 0.44466668f, 
    -0.01790662f, -0.02765015f, 0.29032302f, 0.10966900f, 0.31773213f, 0.68729943f, 0.61855745f, 0.12925380f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.04370553f, 0.00487946f, -0.13691044f, 0.10718413f, -0.00845855f, 0.14346172f, -0.13123462f, -0.14137784f, 
    -0.07313384f, 0.13811404f, 0.03161906f, 0.01122308f, -0.14782999f, 0.16407149f, -0.09227320f, -0.30435410f, 
    0.19488920f, -0.17148708f, 0.01207853f, -0.09992287f, 0.14820406f, 0.01472655f, -0.14664178f, -0.20482635f, 
    0.01333496f, -0.54891068f, 0.13291755f, 0.25641850f, 0.02033869f, -0.10792841f, -0.13815053f, 0.07854541f, 
    0.22175899f, 0.05503422f, 0.05058144f, -0.04666582f, 0.20940824f, -0.16391605f, 0.05412102f, 0.11150449f, 
    0.04221397f, -0.01286067f, -0.15319033f, 0.11518567f, 0.09969892f, -0.12480836f, -0.16357239f, -0.14727090f, 
    0.59423423f, 0.24404444f, 0.22632341f, 0.17932075f, 0.27392390f, 0.16679174f, 0.17384471f, -0.07337478f, 
    0.07013452f, -0.04393207f, -0.19107831f, 0.02351459f, -0.10909627f, -0.31295416f, -0.46077001f, 0.29022682f, 
    -0.12776206f, -0.20368060f, -0.21475947f, 0.01773327f, 0.06756373f, -0.01659866f, -0.05178631f, 0.28851146f, 
    -0.64162523f, -0.51844335f, -0.08423047f, 0.17262468f, 0.06357627f, -0.06310110f, -0.28759155f, 0.00001111f, 
    0.26921937f, 0.05498410f, 0.06321489f, -0.07239086f, -0.21699987f, 0.03329268f, 0.41358957f, 0.02482181f, 
    0.16761284f, 0.19613436f, 0.04102847f, 0.08883062f, 0.11361953f, 0.07137120f, 0.04884360f, 0.10576911f, 
    -0.18244675f, -0.36459574f, -0.30971777f, -0.10123582f, -0.00608472f, 0.09248780f, -0.00656728f, -0.25053522f, 
    0.23613803f, 0.03092724f, 0.18446492f, -0.24864858f, 0.32412314f, 0.18811278f, 0.22279847f, 0.24324071f, 
    0.08035807f, 0.10612430f, 0.07346431f, -0.01313650f, 0.00568630f, -0.10121531f, 0.07307655f, 0.38809907f, 
    -0.17635946f, -0.44492668f, -0.38405430f, -0.34127671f, 0.03386668f, 0.23428552f, -0.28594390f, 0.02374338f, 
    0.10979225f, -0.27923268f, 0.08344351f, 0.17887868f, -0.25510913f, -0.41821745f, 0.21466613f, 0.02272258f, 
    -0.02793713f, -0.07794754f, -0.17227499f, 0.24935077f, 0.17433505f, 0.06806426f, -0.08915843f, 0.21007639f, 
    -0.48290065f, -0.03697557f, 0.46524456f, 0.09425316f, -0.05447694f, -0.06443071f, -0.12283811f, 0.37880895f, 
    0.22493874f, -0.16074523f, 0.00593856f, -0.16489193f, 0.28271058f, 0.47670048f, -0.08060587f, 0.01137048f, 
    0.32261774f, -0.24160117f, 0.10855630f, 0.06980282f, 0.01699003f, -0.01436364f, -0.09903489f, 0.14658561f, 
    -0.24611270f, 0.04124450f, 0.13089906f, -0.19636740f, 0.13998461f, 0.06656066f, 0.21032363f, 0.12096848f, 
    -0.10942177f, 0.03383496f, 0.09962502f, -0.00158305f, 0.35116711f, 0.36069041f, 0.12844716f, 0.11892548f, 
    0.20690027f, 0.10479669f, 0.21608727f, -0.00783440f, 0.13835657f, -0.04105751f, 0.00006727f, -0.00398546f, 
    0.06143723f, -0.05110151f, 0.05343948f, -0.06524330f, 0.03067231f, -0.05035971f, -0.05920603f, 0.00291430f, 
    0.02360936f, -0.02647343f, 0.01595485f, -0.00537652f, 0.03297729f, 0.01049920f, 0.03403997f, -0.04755890f, 
    0.05178119f, -0.02482108f, 0.06183268f, 0.05847090f, 0.06842636f, -0.06976518f, 0.03266824f, -0.05580248f, 
    -0.02351005f, 0.00865150f, -0.04705746f, -0.02726196f, -0.05216680f, -0.04517967f, -0.02711564f, 0.04309573f, 
    -0.05837154f, -0.02371234f, 0.04698229f, -0.00753580f, 0.04729329f, 0.04546643f, 0.06485373f, -0.02177761f, 
    -0.02900964f, -0.07036562f, -0.00166134f, 0.00086800f, 0.00191372f, -0.02196857f, -0.02723606f, -0.01151619f, 
    -0.04715236f, -0.00405436f, 0.02513924f, -0.03640096f, 0.00660976f, -0.05872974f, -0.06459389f, -0.01773233f, 
    -0.04406907f, -0.02167032f, 0.03564095f, -0.04647674f, 0.02930734f, -0.04972299f, -0.02718628f, -0.04750741f, 
    -0.05860673f, -0.06257416f, 0.04950071f, -0.03089508f, -0.01203965f, 0.06737316f, -0.05339865f, -0.04402005f, 
    0.01122665f, 0.02843837f, -0.05113871f, 0.03747259f, -0.05656406f, 0.00275670f, 0.04223921f, 0.05098965f, 
    -0.00567649f, -0.02038384f, -0.06912358f, -0.06258468f, -0.04498839f, 0.00472849f, -0.03540093f, 0.05176957f, 
    -0.06509826f, 0.01270931f, 0.04467012f, -0.01612021f, 0.06980733f, -0.04502140f, -0.05119712f, -0.01945846f, 
    -0.03862521f, -0.00963761f, -0.04680569f, -0.05558774f, -0.02737939f, -0.03213523f, 0.03021411f, -0.01557978f, 
    -0.02483812f, 0.00313818f, 0.04310284f, 0.03061410f, 0.05392119f, 0.04108338f, -0.02339290f, 0.04167703f, 
    -0.06516942f, 0.04356104f, -0.03514206f, -0.01130991f, -0.04378444f, 0.00524370f, 0.03502449f, 0.04851015f, 
    -0.03374919f, -0.00450406f, -0.05761093f, -0.00543467f, 0.06533401f, -0.01198495f, -0.05208007f, -0.00009537f, 
    -0.06567505f, -0.05851804f, 0.01758187f, -0.01516264f, 0.01653022f, -0.04169126f, 0.04454227f, -0.01677275f, 
    -0.01228306f, -0.06973911f, -0.06696499f, -0.00108516f, 0.01269919f, 0.03745610f, -0.05195002f, -0.02248720f, 
    -0.05991661f, 0.04688158f, 0.06808899f, -0.05838062f, 0.06129053f, -0.01542859f, 0.03298472f, -0.06891116f, 
    -0.04045514f, 0.03213450f, -0.01264496f, -0.00617965f, 0.04318710f, 0.06886638f, 0.05942178f, 0.06979460f, 
    -0.01166160f, 0.00381082f, -0.06634077f, -0.06020874f, -0.02668165f, -0.03486935f, 0.00745026f, -0.05125081f, 
    0.07179886f, -0.02485190f, -0.02456715f, 0.02386779f, 0.07030810f, 0.00088433f, -0.04844965f, -0.02445371f, 
    0.00067960f, -0.05038668f, -0.07071909f, -0.00711901f, -0.01591368f, -0.04132426f, -0.01786680f, -0.03946604f, 
    -0.02325376f, 0.04509747f, -0.06712421f, -0.02670993f, 0.02921197f, 0.06190523f, 0.01532059f, 0.03335421f, 
    -0.32849288f, -0.12316612f, 0.56015086f, 0.40430695f, -0.05125324f, -0.00941930f, -0.10441040f, -0.12303991f, 
    0.15453181f, -0.25447699f, 0.04237862f, 0.10695543f, 0.15437178f, -0.05366227f, 0.15895191f, -0.01438319f, 
    0.09282716f, -0.10013971f, -0.11172740f, 0.03992046f, 0.15810974f, -0.12895650f, -0.27007762f, -0.01178141f, 
    -0.09228189f, 0.34530762f, 0.07222128f, 0.65730667f, -0.01196342f, -0.22351612f, -0.09045084f, -0.15279049f, 
    0.06542349f, 0.09954029f, -0.06350773f, -0.03419930f, 0.12061454f, 0.00646515f, 0.17197116f, 0.02987142f, 
    -0.30979395f, 0.09975895f, -0.17208552f, -0.18437505f, 0.10476331f, -0.07673193f, -0.10324840f, -0.02361537f, 
    0.01459739f, 0.13652092f, 0.48613799f, 0.24973890f, 0.07564487f, 0.18375486f, 0.09589478f, -0.13530654f, 
    0.17207435f, 0.21097600f, 0.02758966f, 0.05556780f, -0.19899340f, 0.01164764f, -0.12528330f, 0.08326752f, 
    0.13175730f, -0.13773702f, 0.19920407f, 0.33228493f, 0.23644096f, -0.17664385f, 0.09872045f, 0.20165218f, 
    0.11419295f, -0.40724954f, -0.15844066f, 0.18908590f, -0.03349433f, -0.12515497f, 0.17521007f, 0.03023603f, 
    0.00457414f, 0.05733501f, -0.03764720f, -0.12375559f, -0.55849510f, 0.02033287f, 0.26864150f, 0.23298919f, 
    0.00760307f, -0.10694608f, -0.06879782f, -0.12380616f, 0.05149103f, -0.11670616f, 0.03326448f, 0.07397436f, 
    0.16232996f, -0.16070603f, -0.13693123f, 0.05038341f, -0.14612567f, 0.02170757f, -0.02224044f, -0.08074272f, 
    0.28035671f, -0.19230711f, 0.25893000f, -0.03410712f, -0.54023981f, -0.02495837f, 0.01115929f, -0.21923506f, 
    -0.04634693f, -0.28972107f, 0.09965426f, 0.22371908f, 0.10668208f, -0.14266627f, -0.11203883f, 0.24349086f, 
    0.13511485f, 0.13031946f, -0.16465791f, 0.11637643f, -0.22678867f, -0.08370541f, -0.12367240f, 0.03659783f, 
    -0.01040465f, -0.17856981f, 0.16208203f, 0.33058077f, -0.29218271f, -0.32601950f, -0.08776630f, 0.37518892f, 
    0.06047780f, 0.13259038f, -0.12551744f, -0.00385017f, 0.02290937f, 0.28623891f, 0.10741743f, 0.06951855f, 
    0.13547201f, -0.03642995f, -0.08092531f, 0.11174286f, 0.17245182f, 0.13740388f, 0.15152897f, 0.08007158f, 
    -0.10110570f, -0.12833224f, 0.05511552f, -0.24188218f, -0.26644889f, 0.28133336f, 0.40904158f, -0.23059584f, 
    0.33389357f, 0.01007608f, -0.26596394f, 0.29432011f, 0.15152246f, -0.06342155f, 0.10546921f, 0.07758971f, 
    -0.12586306f, -0.12391987f, 0.11567031f, 0.39770943f, -0.12010004f, 0.28852057f, -0.22197966f, -0.06694563f, 
    -0.09941071f, -0.13272049f, 0.09301002f, 0.00592319f, -0.20985892f, 0.17757623f, 0.17178114f, 0.08597153f, 
    -0.00307611f, 0.03692012f, 0.05986333f, 0.32100040f, -0.02083913f, 0.03420987f, -0.00845273f, 0.12519938f, 
    0.24655224f, -0.20294672f, 0.23250882f, 0.20697245f, -0.00899639f, 0.01494220f, -0.09162168f, 0.08687326f, 
    0.13405739f, 0.15713538f, 0.04519390f, 0.18670256f, -0.06240305f, 0.20428340f, 0.07495087f, -0.14490633f, 
    0.15532956f, -0.15004955f, -0.10723443f, 0.15126263f, 0.12964956f, -0.05178652f, 0.08732562f, -0.14361091f, 
    -0.34706432f, -0.00573851f, 0.28755280f, 0.51441228f, -0.04652186f, -0.07306735f, -0.05878084f, 0.09229255f, 
    0.00356861f, 0.19756968f, 0.13492654f, -0.05207842f, -0.07598568f, -0.16516656f, -0.01224395f, 0.06335013f, 
    -0.10358223f, -0.09864113f, -0.00564081f, 0.05946137f, -0.01755694f, -0.02531029f, -0.05759775f, -0.06366798f, 
    -0.36821225f, -0.10806673f, 0.17439580f, 0.05907204f, -0.08717554f, 0.11401021f, 0.02888846f, -0.26758176f, 
    0.02416778f, 0.08796949f, 0.10881489f, 0.04994022f, 0.57703018f, -0.13954660f, -0.32378241f, 0.04829399f, 
    -0.04162364f, -0.06572080f, 0.19680500f, 0.08737812f, 0.20311686f, -0.05772367f, 0.06321459f, 0.00737189f, 
    0.16239066f, -0.22188832f, 0.02231594f, -0.19031003f, -0.06631835f, 0.04854469f, 0.02268983f, -0.06775499f, 
    -0.07723612f, 0.03686308f, -0.01589942f, 0.01991627f, -0.62992918f, -0.06304103f, 0.30668268f, 0.40398249f, 
    0.03855386f, -0.08521735f, 0.04332124f, 0.23508178f, 0.14607063f, 0.01609679f, 0.08858986f, 0.28886670f, 
    0.17322311f, -0.04031363f, -0.11139248f, -0.22529298f, -0.05638777f, -0.06608369f, -0.01041454f, 0.03206096f, 
    0.04282982f, 0.06093331f, -0.00611957f, -0.17360540f, -0.30117348f, 0.28565785f, 0.00187530f, 0.33223477f, 
    -0.25441614f, -0.20978242f, -0.06277869f, 0.10158252f, 0.00883282f, 0.02058612f, 0.03660342f, -0.10197570f, 
    0.17392726f, 0.10054512f, -0.19461623f, 0.24168202f, 0.09823842f, 0.09805001f, -0.12070730f, -0.04724818f, 
    0.21739586f, -0.29608643f, 0.08853412f, 0.31886780f, -0.09723961f, -0.09397885f, -0.11843289f, 0.06364804f, 
    0.07287348f, 0.03286398f, -0.01190935f, 0.05733066f, 0.04080444f, 0.12275449f, 0.05180420f, 0.03249254f, 
    -0.09510098f, -0.53409386f, -0.02039253f, -0.28313211f, 0.27743968f, 0.36136606f, 0.17648135f, -0.22264355f, 
    0.03824635f, -0.09361105f, 0.00565335f, -0.00017359f, -0.55799645f, 0.06495539f, 0.84382474f, -0.18332800f, 
    0.09810451f, -0.25480652f, -0.03446971f, 0.09165552f, 0.13032672f, 0.28070569f, 0.09069964f, 0.00434624f, 
    -0.27706963f, -0.02435209f, 0.20519593f, 0.50135869f, 0.02747812f, -0.04867378f, 0.08264051f, -0.00947072f, 
    0.19419487f, -0.06194596f, 0.14790009f, 0.11453192f, -0.46429056f, -0.16945100f, 0.18591799f, 0.03578329f, 
    0.02397467f, 0.03837699f, 0.09880733f, -0.21448264f, 0.09789066f, 0.03858137f, 0.01200930f, 0.03859265f, 
    0.01815226f, 0.00401993f, 0.04431114f, 0.03453922f, 0.00462146f, 0.02050759f, -0.03938405f, 0.04901155f, 
    -0.07760594f, -0.01950714f, -0.06118312f, 0.02532517f, -0.00364766f, 0.01700981f, -0.02443683f, -0.01546739f, 
    0.01779855f, -0.03621105f, -0.01784976f, -0.02287313f, -0.01876633f, 0.00659701f, -0.00260186f, 0.05380637f, 
    -0.08112178f, 0.02520694f, -0.02966459f, -0.05143389f, 0.05090783f, 0.02920495f, -0.05139831f, -0.03066359f, 
    -0.05897014f, -0.03081751f, 0.00773231f, -0.04757654f, 0.00288877f, -0.01243407f, -0.07245357f, -0.04993017f, 
    -0.00542069f, 0.01226993f, 0.00572696f, -0.05164343f, -0.01488214f, -0.07226426f, 0.03448283f, 0.02341358f, 
    -0.00969558f, 0.02369801f, -0.04805804f, -0.05510554f, -0.01857632f, -0.05811190f, -0.01246988f, 0.05488670f, 
    -0.08064126f, 0.03145888f, -0.06671089f, -0.05936345f, 0.02004417f, 0.04905871f, 0.04141301f, -0.02289436f, 
    0.01240360f, -0.05808362f, 0.02244271f, 0.01001553f, -0.03914160f, -0.00083635f, 0.02429974f, 0.03512977f, 
    0.04282796f, -0.02203709f, -0.04886515f, -0.05364631f, -0.06832278f, 0.02095742f, 0.03247153f, -0.02308813f, 
    0.01676506f, 0.03903972f, -0.04914712f, -0.03103425f, -0.01562192f, 0.04000150f, -0.06299501f, -0.00031493f, 
    0.01416049f, -0.01249158f, -0.07722177f, -0.06305291f, 0.00146668f, 0.01810521f, -0.04865287f, -0.07017022f, 
    0.05645714f, 0.02070688f, -0.06730948f, -0.06606946f, -0.06934168f, -0.07233701f, -0.00931721f, -0.06423380f, 
    -0.05932429f, 0.00502316f, 0.00422524f, 0.02621668f, -0.02271012f, 0.00819371f, 0.03789731f, -0.03065002f, 
    0.01533636f, 0.05382554f, -0.06071617f, -0.06473453f, -0.07805602f, 0.05612910f, -0.00122578f, 0.03657625f, 
    -0.03601061f, 0.01736222f, 0.05263000f, -0.00959507f, 0.02165662f, 0.05688702f, -0.05455941f, 0.04940401f, 
    0.05206993f, 0.03014758f, -0.04189608f, 0.00688998f, 0.04094918f, 0.05080097f, -0.03176011f, 0.03489292f, 
    -0.02889901f, 0.00517272f, 0.02661560f, -0.03273267f, -0.03249454f, -0.02311300f, -0.01244497f, 0.00270556f, 
    0.02947529f, -0.04914679f, -0.02886260f, -0.02183110f, 0.04308533f, -0.04547228f, 0.01813112f, -0.07924040f, 
    -0.04588160f, -0.05652137f, 0.02836297f, 0.01497804f, -0.05939387f, -0.03601128f, -0.03722542f, 0.02211834f, 
    0.03449581f, -0.05311562f, 0.05243076f, -0.03785247f, 0.04237743f, -0.00215858f, 0.00704312f, 0.00162560f, 
    -0.04872639f, 0.05835079f, 0.02039423f, 0.05439682f, -0.05109974f, 0.02621249f, -0.01513024f, 0.01266061f, 
    -0.00095170f, 0.00273615f, -0.07646731f, -0.05681152f, 0.02072505f, -0.00520565f, -0.06503728f, 0.01727685f, 
    -0.06994200f, -0.05431440f, -0.02472467f, -0.06670393f, -0.02367364f, 0.00073568f, -0.00381883f, 0.04312098f, 
    -0.05475660f, -0.06132002f, 0.04080486f, -0.06590433f, 0.00462508f, 0.03509803f, 0.02589170f, 0.01823148f, 
    -0.02665451f, -0.06027510f, 0.02016217f, -0.05456700f, 0.01009965f, -0.06011227f, -0.01670099f, 0.01555231f, 
    0.02443834f, -0.05614464f, -0.02449422f, 0.00326663f, -0.05236919f, -0.02678628f, -0.03591952f, -0.02670119f, 
    0.02273926f, -0.02057917f, 0.02475063f, -0.00032924f, -0.03774121f, 0.05971321f, -0.03827983f, 0.05603880f, 
    -0.00908445f, 0.06353620f, 0.04121552f, 0.03089587f, -0.02389481f, 0.00076063f, -0.03420144f, -0.06156356f, 
    0.00891235f, 0.00789241f, 0.01463963f, -0.00984828f, -0.04769090f, -0.05098692f, -0.02473019f, 0.03393781f, 
    0.00128209f, -0.06761432f, 0.06209006f, 0.04109984f, 0.01199410f, -0.03008875f, -0.07375785f, 0.03490953f, 
    0.05230900f, -0.00865229f, 0.01368392f, 0.04040663f, -0.00617296f, -0.01928435f, 0.02601345f, -0.06427277f, 
    -0.00897258f, -0.08185565f, 0.02469046f, 0.04744652f, -0.02775774f, 0.03383062f, -0.06968807f, 0.04141340f, 
    0.05652813f, 0.03920845f, 0.00305984f, -0.04803626f, -0.05722100f, 0.00875215f, -0.00075444f, -0.06453108f, 
    -0.05120022f, -0.07959417f, -0.01766434f, -0.07970282f, -0.04824981f, -0.03945477f, 0.03672044f, 0.04444639f, 
    0.03342224f, -0.03462614f, 0.06179809f, -0.07406431f, -0.06275280f, -0.01401484f, -0.06417456f, 0.02775163f, 
    -0.00410460f, 0.02699616f, 0.00518830f, 0.03631526f, 0.02075165f, -0.05315120f, 0.02515398f, -0.05548321f, 
    -0.07889021f, -0.01292904f, -0.02025197f, -0.00758689f, -0.05281400f, -0.01545699f, 0.04032942f, -0.05477649f, 
    -0.05705104f, 0.00545197f, -0.02149135f, -0.07649630f, -0.04488310f, 0.05705091f, -0.01457629f, 0.03558777f, 
    -0.04338837f, 0.00459961f, -0.04811601f, -0.06229787f, -0.02239608f, -0.01581535f, 0.06242290f, 0.00967066f, 
    -0.00205981f, 0.02228261f, 0.06063717f, 0.04183451f, 0.03238764f, -0.03808989f, 0.06406084f, -0.05341689f, 
    0.06066962f, -0.00206051f, 0.06247059f, 0.04036033f, 0.04895090f, -0.04972954f, 0.00273158f, -0.01041580f, 
    -0.01366855f, 0.04197783f, 0.01722161f, -0.00050310f, 0.00030209f, -0.07086673f, 0.06210891f, -0.00401046f, 
    0.00721502f, -0.03630427f, -0.02738151f, -0.06782834f, -0.03503708f, -0.07074986f, -0.07355148f, 0.01243599f, 
    -0.00576947f, 0.04019848f, -0.07531255f, 0.01625570f, 0.00369426f, -0.02256425f, -0.01881608f, -0.00900371f, 
    -0.06049173f, 0.00165423f, -0.00429681f, -0.00641025f, 0.03090478f, -0.01703255f, 0.01869541f, -0.00926848f, 
    -0.06979608f, 0.05244439f, -0.01889665f, -0.03453174f, 0.03035184f, -0.01068048f, 0.05861070f, -0.05877242f, 
    0.00060036f, -0.02585888f, 0.00920593f, 0.00302443f, -0.01573817f, -0.01203783f, -0.04285848f, -0.00427645f, 
    0.37798357f, 0.35381025f, 0.20766048f, 0.20782344f, -0.03334133f, -0.09341849f, 0.05365559f, 0.22997910f, 
    0.28803435f, 0.02653025f, -0.10163160f, 0.25333127f, 0.02692801f, 0.11334635f, 0.32531458f, -0.08490283f, 
    0.01640690f, -0.04941131f, -0.11156361f, -0.06160703f, 0.19823320f, 0.00080563f, 0.09357703f, 0.29119956f, 
    0.08176361f, 0.42178798f, 0.30084628f, -0.20303935f, -0.25873017f, 0.03571323f, 0.00825418f, -0.09448471f, 
    0.04654250f, 0.26590383f, 0.21257058f, 0.05106760f, 0.09242422f, -0.16947098f, 0.05131782f, -0.09145423f, 
    -0.05306252f, 0.03823930f, -0.04093640f, -0.01710885f, 0.12861237f, 0.06308336f, 0.13258344f, 0.33668709f, 
    -0.09171979f, -0.19802248f, -0.14195605f, -0.24566768f, 0.07281189f, -0.01086447f, 0.11665621f, 0.11376833f, 
    0.10947063f, 0.00355687f, 0.23389015f, 0.05502372f, -0.38413548f, 0.22921959f, -0.17847790f, 0.02233630f, 
    -0.06222567f, -0.18646637f, 0.29888830f, -0.00807031f, 0.09965590f, 0.02984675f, 0.06779120f, -0.03491369f, 
    -0.49846020f, 0.10739684f, -0.04161679f, -0.11710371f, -0.00859084f, -0.17857936f, 0.01765758f, -0.09120591f, 
    -0.07964518f, -0.07253928f, -0.08361264f, 0.04348324f, 0.16267946f, 0.10553872f, -0.17190202f, 0.21267693f, 
    -0.02778243f, -0.12508112f, -0.11916842f, 0.26925319f, 0.09162149f, 0.14605153f, -0.03892047f, 0.17060085f, 
    -0.36996007f, -0.09476823f, -0.06043236f, 0.00652677f, -0.03027209f, -0.10012350f, 0.10683280f, -0.07052328f, 
    0.03125282f, 0.02276137f, -0.26832506f, -0.01928329f, -0.29536808f, -0.35172674f, -0.21552233f, -0.05680689f, 
    -0.10694312f, -0.05364283f, -0.07557230f, 0.21588348f, -0.06374960f, -0.01487167f, -0.10673410f, -0.21066436f, 
    -0.17717680f, 0.27731735f, -0.05381138f, -0.21759483f, 0.10554516f, -0.26707906f, 0.05757890f, -0.02177878f, 
    -0.04194606f, 0.10327137f, 0.17419744f, 0.23299977f, -0.05199735f, -0.00083942f, -0.13803037f, -0.31964839f, 
    -0.12793879f, -0.00929519f, 0.05958409f, -0.12975290f, -0.05489044f, -0.02460384f, 0.13518015f, -0.14298268f, 
    -0.56807470f, -0.39509749f, -0.04269669f, -0.19292741f, 0.13615018f, -0.05650384f, 0.16481517f, -0.09022084f, 
    0.01819411f, -0.11508135f, 0.03089074f, 0.01410484f, 0.18174793f, 0.35538435f, 0.60546958f, -0.39714772f, 
    -0.10603215f, 0.25880042f, 0.15439484f, 0.03700771f, 0.19605806f, 0.05590897f, -0.12878466f, -0.16072583f, 
    -0.02528218f, -0.17304857f, 0.41176370f, 0.19591077f, -0.00401847f, 0.16613528f, -0.02227121f, -0.01327288f, 
    0.11167005f, 0.10615098f, 0.11944046f, 0.17550948f, -0.25749189f, -0.31185997f, -0.36199355f, 0.12931523f, 
    0.04184601f, 0.01407720f, -0.16844501f, 0.06955805f, 0.02280740f, 0.06145231f, 0.06573545f, 0.13021046f, 
    0.44991341f, -0.22944011f, 0.09910943f, -0.39195341f, -0.07980994f, 0.12130270f, 0.13469139f, -0.11438099f, 
    -0.00159790f, 0.18274565f, 0.20639361f, 0.07241055f, -0.43417785f, 0.73318213f, -0.27784693f, 0.53185135f, 
    0.01096382f, 0.07707411f, -0.07563745f, 0.05891316f, 0.04337139f, -0.03306906f, 0.21853021f, 0.27107933f, 
    -0.24204504f, 0.64274794f, 0.23864295f, -0.11535236f, -0.08464592f, 0.02096984f, 0.21111727f, 0.09584436f, 
    -0.26081696f, -0.06271628f, 0.00568209f, 0.19699661f, -0.15806028f, 0.09433417f, -0.29747534f, -0.11017180f, 
    0.21442743f, -0.17235015f, 0.05433174f, -0.05389608f, -0.30066723f, -0.04862107f, 0.03407057f, -0.18802358f, 
    -0.33576551f, -0.18794742f, -0.08774162f, 0.20384592f, -0.07674691f, 0.07404894f, -0.00048793f, 0.11777826f, 
    -0.04391199f, 0.14751609f, 0.02165796f, 0.12550263f, 0.81837207f, 0.02726940f, 0.72912127f, -0.29945299f, 
    -0.13865402f, -0.02267081f, -0.15401927f, 0.18518478f, -0.01103349f, 0.10424352f, -0.02602307f, -0.17640878f, 
    0.48697734f, 0.04343394f, 0.42553589f, -0.45491394f, -0.23802534f, -0.10238946f, -0.25721622f, 0.02688252f, 
    -0.12510113f, 0.01219589f, -0.01742383f, -0.10077101f, -0.44727558f, 0.36207423f, 0.04715168f, 0.47448081f, 
    0.10589251f, -0.18613754f, 0.11454089f, -0.08527708f, -0.17475790f, -0.03843910f, 0.02955633f, -0.02350719f, 
    0.20714554f, -0.03784978f, 0.10478794f, -0.35899663f, -0.18975799f, -0.11535279f, -0.12195338f, 0.01467703f, 
    0.21503101f, 0.16647224f, 0.26206869f, 0.27842155f, 0.17840938f, 0.11312197f, -0.00041921f, 0.43442860f, 
    -0.04839027f, -0.13017944f, 0.03174079f, -0.16785754f, -0.06227089f, 0.21530052f, 0.00485523f, 0.05077111f, 
    -0.31925204f, 0.25426370f, 0.23177721f, 0.48999757f, -0.06663112f, 0.15044208f, 0.00153269f, 0.07716918f, 
    0.18208718f, 0.12063340f, -0.17470968f, 0.01459465f, 0.14428279f, 0.17984642f, 0.02625819f, -0.11030306f, 
    -0.17203237f, 0.12914456f, -0.10364073f, -0.05455000f, 0.09184315f, 0.17783891f, -0.03439074f, -0.02507578f, 
    0.21370225f, -0.11214470f, 0.60262686f, 0.22214191f, -0.13990815f, 0.12005260f, -0.14606003f, -0.07066211f, 
    -0.15838230f, 0.03266165f, -0.01035872f, 0.08346261f, -0.22163908f, -0.52721822f, 0.04382736f, 0.37053260f, 
    -0.07175230f, -0.09706430f, 0.11473524f, 0.01055597f, -0.10668960f, 0.21923174f, 0.13108847f, 0.20813116f, 
    -0.17481658f, 0.45290855f, -0.27443030f, 0.29896706f, 0.31699336f, -0.22589622f, 0.23105018f, -0.00359196f, 
    -0.14052066f, 0.08398502f, -0.06166599f, -0.10866363f, -0.28054532f, -0.32545894f, 0.22102137f, 0.41310549f, 
    -0.11426342f, -0.10714839f, -0.03276769f, -0.25576773f, -0.09185023f, -0.01825608f, -0.12572721f, -0.22537409f, 
    -0.22144581f, -0.00336140f, 0.01551085f, 0.17806736f, 0.04796222f, 0.14105348f, 0.02413459f, -0.17956875f, 
    -0.06291060f, -0.16363755f, -0.03471520f, -0.04636646f, 0.56601620f, -0.39375141f, 0.14044288f, 0.40011787f, 
    -0.13035502f, 0.03143643f, 0.11892587f, -0.06128779f, -0.10302853f, 0.15056677f, -0.01381677f, 0.09334528f, 
    0.00944662f, 0.51023674f, -0.16199037f, 0.24520403f, 0.05643166f, -0.04505094f, 0.35496137f, -0.07031257f, 
    -0.02786544f, -0.12849742f, -0.15036610f, 0.04741610f, -0.28833532f, 0.07827616f, 0.08227475f, 0.01205190f, 
    0.05392506f, 0.30504790f, 0.09401801f, 0.18422955f, -0.17612273f, -0.05645002f, 0.23829859f, -0.05527202f, 
    -0.15101227f, 0.12295962f, -0.00041991f, -0.00625331f, -0.19808924f, 0.10145374f, -0.12163354f, 0.32890463f, 
    0.03486861f, -0.01258451f, -0.13233447f, 0.05567310f, 0.15179309f, 0.00123200f, 0.51878411f, -0.20907208f, 
    -0.02666680f, 0.13103391f, -0.13981101f, 0.12053802f, -0.01575329f, -0.01201155f, 0.10159352f, -0.22595163f, 
    0.26347816f, 0.14936852f, 0.08377778f, 0.01482120f, 0.02281881f, -0.06466752f, -0.03546387f, 0.03784676f, 
    0.06419991f, -0.02201256f, -0.01603284f, 0.11160265f, 0.02824623f, 0.30526286f, 0.27907372f, 0.19398835f, 
    -0.05894280f, 0.10859910f, 0.03512405f, -0.13001117f, -0.02680591f, -0.02813764f, 0.04910561f, -0.32874569f, 
    0.02470949f, -0.06083877f, 0.11524884f, 0.05982239f, -0.08690496f, -0.00443696f, -0.11603121f, -0.03507597f, 
    -0.06411278f, -0.16255459f, 0.08216513f, 0.17639136f, 0.21525297f, 0.35243890f, 0.06649334f, -0.12976393f, 
    0.00895397f, -0.08013080f, -0.26484910f, -0.15775250f, 0.15619209f, 0.18220332f, 0.00522546f, -0.12513117f, 
    0.16893230f, 0.25766826f, 0.15489903f, 0.39590502f, -0.04581625f, -0.09440245f, 0.05955292f, 0.12823002f, 
    0.08448387f, 0.21807548f, -0.28806791f, -0.06009636f, -0.01592350f, 0.00906088f, 0.06990948f, 0.01314231f, 
    0.09768043f, 0.20172124f, 0.01770062f, 0.05819541f, 0.24875747f, -0.11844686f, -0.00375441f, -0.02854663f, 
    0.19478106f, 0.28935063f, -0.30631164f, -0.11546793f, -0.09203249f, -0.25832048f, 0.05605887f, -0.14558524f, 
    -0.18299820f, 0.03422155f, -0.11186423f, -0.00665188f, 0.22648986f, -0.50654489f, -0.28328025f, 0.27308118f, 
    -0.20810606f, 0.17640026f, -0.04439800f, 0.06686953f, 0.25820586f, 0.01672471f, 0.08414779f, 0.10804602f, 
    0.54561222f, 0.08735258f, -0.35030213f, -0.05990189f, -0.17667703f, -0.06770431f, 0.03622381f, 0.06789819f, 
    0.05706842f, -0.13649184f, -0.07743136f, -0.02645594f, 0.04670159f, 0.03093845f, 0.07354048f, -0.12654571f, 
    -0.09265026f, 0.00048811f, 0.14094663f, 0.36810189f, -0.05239355f, -0.00853558f, -0.08223522f, -0.13321318f, 
    -0.02450827f, 0.04957915f, 0.06332368f, -0.01662477f, 0.03992654f, 0.00416843f, -0.03755027f, -0.06230404f, 
    0.02955736f, -0.02186726f, -0.01692964f, 0.03757808f, -0.01667808f, 0.03233513f, 0.05344569f, -0.07336216f, 
    0.00026632f, 0.03240350f, -0.00197549f, -0.02678820f, 0.04612011f, 0.02126358f, 0.01180878f, 0.04759076f, 
    -0.04418850f, -0.02115022f, -0.03652119f, 0.05507188f, 0.00361610f, -0.02825367f, -0.00374995f, 0.06167129f, 
    -0.01983710f, -0.06648100f, -0.07028517f, -0.00875365f, -0.03359206f, -0.00977707f, 0.03063389f, 0.02814726f, 
    0.03315081f, 0.03633570f, 0.02791006f, -0.07656233f, 0.02123381f, 0.01894685f, -0.07200543f, -0.05327600f, 
    -0.04928943f, 0.00224692f, 0.01948487f, 0.04669157f, 0.01834283f, 0.06471357f, -0.00472578f, 0.00826617f, 
    0.04328814f, -0.00961917f, 0.01985188f, 0.03452999f, 0.04105669f, 0.00732997f, -0.07416189f, 0.06482874f, 
    0.06318119f, -0.06179085f, -0.05473171f, -0.03999551f, 0.05867873f, -0.04807029f, 0.06118244f, -0.07747684f, 
    -0.03844813f, -0.01278981f, -0.05860467f, -0.01525336f, 0.05954562f, -0.01925709f, -0.05656715f, 0.03065200f, 
    -0.06387986f, 0.02983906f, 0.00489400f, -0.07595722f, -0.05501020f, -0.05231961f, 0.04134654f, -0.05521523f, 
    -0.04548525f, -0.03267334f, -0.00360554f, -0.04131223f, -0.03603987f, 0.04706026f, -0.02867687f, -0.04566224f, 
    0.03676660f, -0.03626528f, -0.00378728f, 0.03836052f, 0.06197620f, -0.07049426f, 0.04830467f, -0.04707696f, 
    -0.07240219f, 0.02239235f, -0.02246530f, 0.04798355f, -0.03945862f, -0.04415772f, -0.01852019f, -0.01350233f, 
    0.03756502f, -0.06927531f, 0.05002639f, -0.05615405f, 0.01212788f, -0.00781471f, -0.02109002f, -0.07798954f, 
    -0.05002192f, -0.01493887f, -0.06586517f, -0.07102838f, 0.02158559f, -0.04374240f, -0.01177355f, -0.01959174f, 
    -0.06045624f, -0.00127802f, 0.00690052f, -0.06096768f, 0.06273854f, 0.02108785f, -0.05341412f, 0.04300040f, 
    -0.03211487f, 0.00778542f, 0.01242334f, 0.05716953f, 0.02618342f, 0.06611305f, -0.05706193f, -0.00718013f, 
    -0.03129686f, -0.05909018f, -0.00119962f, -0.06927186f, 0.06475215f, 0.03803523f, -0.01583311f, -0.07559199f, 
    -0.07806144f, -0.04672284f, 0.04826687f, -0.05785476f, 0.04744603f, -0.02268763f, -0.05816399f, 0.01709040f, 
    0.01204696f, 0.01543147f, -0.07283984f, -0.02441574f, -0.07525762f, -0.05952558f, -0.06715037f, -0.01934304f, 
    0.04750329f, 0.05743359f, -0.01022330f, 0.02407383f, -0.06328755f, -0.02804792f, -0.07719350f, 0.05108197f, 
    -0.06433360f, -0.02324025f, -0.02078386f, -0.06435456f, 0.00471986f, 0.03867654f, -0.04771828f, -0.06768359f, 
    -0.05121304f, -0.05897485f, -0.01351905f, -0.06341424f, -0.01486463f, -0.02660526f, -0.06203677f, 0.06497559f, 
    0.38459361f, -0.07081579f, -0.50192130f, 0.01307386f, 0.03526622f, 0.00035256f, -0.09405025f, -0.10070959f, 
    0.18744536f, 0.24132755f, 0.10706406f, 0.05428668f, 0.16791272f, -0.05675883f, 0.08532090f, -0.04727604f, 
    0.03991332f, -0.06717759f, 0.04767137f, 0.02676400f, 0.11114158f, 0.00963930f, -0.03755847f, 0.05120889f, 
    0.36244860f, -0.59845746f, -0.46837845f, -0.16027397f, -0.00932715f, 0.02072198f, -0.02069088f, 0.07266897f, 
    -0.02750494f, 0.10231029f, 0.08306419f, 0.06849654f, 0.05444981f, -0.12211572f, -0.17762432f, -0.01132313f, 
    0.02025485f, -0.15297553f, 0.02508984f, 0.16850954f, -0.10870060f, 0.05733368f, 0.05470274f, -0.05698019f, 
    -0.17958742f, -0.19307178f, 0.15839501f, 0.26538852f, -0.22582798f, 0.11189540f, 0.12041982f, 0.07216885f, 
    0.07389838f, 0.00461380f, 0.06838286f, 0.16310120f, 0.76001513f, 0.20184703f, -0.24981809f, 0.06703001f, 
    0.01970843f, 0.10691195f, 0.00818439f, -0.08696822f, -0.05976681f, 0.22338064f, 0.09043244f, 0.02645262f, 
    0.13891840f, 0.40348375f, 0.02158771f, 0.15014905f, 0.02459554f, 0.04498062f, -0.10894839f, -0.06338191f, 
    0.00181976f, 0.04182633f, -0.01350438f, -0.03265123f, 0.22884010f, -0.26095679f, -0.20193763f, -0.20781487f, 
    -0.09696526f, -0.03787831f, -0.21004312f, 0.41934118f, 0.05028070f, -0.08109628f, 0.06907090f, -0.01963087f, 
    -0.07769517f, 0.13696972f, 0.02011477f, 0.02564623f, -0.02004541f, -0.00942331f, -0.06982027f, -0.07182818f, 
    -0.04853195f, -0.06492468f, 0.16575313f, 0.07215659f, -0.10608770f, -0.00081783f, -0.16084275f, 0.28167906f, 
    -0.14456138f, 0.04427972f, 0.00321228f, 0.14201976f, 0.01249876f, -0.02814744f, -0.12127270f, 0.23207629f, 
    0.16198555f, -0.07622028f, 0.45830852f, -0.00170512f, 0.22403722f, 0.09270176f, -0.01006673f, -0.16629767f, 
    0.18253593f, 0.09939335f, -0.07332208f, 0.21946113f, 0.16836469f, 0.12519389f, 0.13112615f, -0.17914279f, 
    -0.01143240f, -0.08134907f, 0.06141683f, -0.01975490f, 0.07789038f, -0.00153930f, -0.02198931f, 0.04747713f, 
    -0.09193664f, 0.33384195f, 0.09082693f, 0.08673366f, 0.04228544f, 0.11981481f, 0.00157524f, -0.00363253f, 
    0.06669851f, -0.03502755f, -0.00380322f, 0.05881871f, 0.19179749f, -0.36119187f, 0.07487256f, 0.20179945f, 
    0.00200979f, -0.10767470f, 0.15615799f, 0.13423832f, 0.12638927f, 0.18008034f, -0.04822885f, 0.15132479f, 
    0.46934310f, 0.12381478f, -0.37921807f, 0.00357808f, -0.02760853f, -0.05754889f, 0.18812667f, 0.11733346f, 
    0.43921527f, 0.02333001f, 0.02863177f, 0.06199338f, -0.18179759f, -0.13450627f, 0.33503178f, 0.09846553f, 
    0.07123563f, 0.04078953f, -0.00781065f, -0.07934132f, 0.04095546f, -0.07470604f, -0.10027012f, 0.01456172f, 
    -0.30355868f, 0.39244273f, 0.17668304f, 0.19339350f, -0.06933067f, 0.10537586f, -0.13456482f, 0.21031125f, 
    -0.13468985f, 0.33645201f, 0.00720429f, -0.03465254f, 0.59678191f, -0.15890275f, 0.34069198f, 0.01245343f, 
    0.15091226f, 0.03351590f, -0.13245991f, 0.00932024f, -0.12601329f, 0.18548054f, 0.11095200f, -0.00403374f, 
    0.08098056f, -0.03317545f, 0.13127241f, 0.10774212f, -0.19114901f, 0.04383715f, -0.25354248f, -0.21129209f, 
    0.12489676f, -0.10260773f, 0.06318612f, -0.17911097f, 0.09792342f, 0.11617449f, -0.00873849f, -0.01931614f, 
    -0.19535623f, -0.10781881f, 0.06261379f, -0.11132084f, -0.01396995f, -0.03105900f, -0.34608787f, -0.18492582f, 
    -0.31756124f, -0.08978008f, 0.25121865f, -0.13558917f, 0.19867671f, -0.08507812f, -0.07034402f, 0.18196143f, 
    0.12878995f, -0.04719221f, 0.07606289f, -0.02097819f, 0.17592652f, 0.21173021f, -0.12260799f, 0.01851879f, 
    0.08558955f, 0.09522551f, 0.26393414f, -0.12336309f, -0.00818293f, -0.04035104f, 0.30669364f, 0.08186273f, 
    0.44304538f, 0.10009448f, -0.15561245f, 0.12008341f, 0.00812351f, -0.00428856f, 0.18261410f, -0.03261627f, 
    0.01906465f, -0.02273832f, 0.13970134f, 0.05870077f, 0.05278137f, -0.10692454f, -0.29922828f, -0.30057526f, 
    -0.05636145f, 0.10077149f, -0.19220373f, -0.03353635f, -0.05355782f, -0.16344067f, -0.12908114f, 0.20799948f, 
    0.17503548f, -0.02350159f, 0.03797719f, 0.03747158f, -0.05768288f, -0.07482263f, 0.10958707f, 0.11326620f, 
    0.13612850f, 0.24846449f, 0.14622745f, 0.36115149f, -0.45628533f, -0.58442944f, 0.22901672f, -0.25144726f, 
    0.04724003f, 0.17175092f, -0.11126871f, 0.05828062f, 0.04215007f, -0.01709695f, 0.27898893f, 0.16115774f, 
    0.39776808f, -0.25131610f, 0.07269940f, 0.30212441f, 0.18055363f, -0.05218890f, -0.07902773f, -0.13241298f, 
    0.00217806f, -0.13981874f, 0.15840948f, -0.18392445f, 0.03111678f, 0.11534584f, 0.01401590f, 0.15215698f, 
    -0.02981202f, 0.07078674f, 0.12249363f, -0.01142981f, 0.01172780f, 0.14124538f, -0.01104381f, 0.11566342f, 
    0.87987500f, -0.20204581f, -0.38479176f, 0.14448747f, 0.17103568f, -0.00113180f, 0.08871097f, 0.04965504f, 
    -0.14478683f, -0.20240147f, -0.01795924f, -0.07772740f, -0.55977160f, 0.25145406f, 0.28843838f, -0.06713765f, 
    -0.03220013f, 0.22800069f, -0.42943564f, 0.01480490f, 0.19929792f, 0.17808791f, 0.13415647f, 0.16348745f, 
    -0.00432625f, -0.00333872f, 0.42434615f, 0.26970688f, 0.00781626f, 0.01909613f, -0.36802390f, -0.17352186f, 
    0.04226656f, 0.22781308f, 0.25017303f, 0.13479865f, -0.34899840f, -0.36950749f, -0.31150967f, -0.34014514f, 
    0.18396409f, -0.20253053f, -0.18325663f, -0.11986599f, -0.07319905f, -0.09640875f, -0.15044303f, -0.16260971f, 
    -0.34473249f, -0.04760083f, 0.17554228f, 0.30364946f, 0.00214232f, 0.14286844f, 0.03107713f, -0.05864081f, 
    -0.00936821f, -0.09111230f, 0.02949853f, -0.08749968f, 0.93015862f, -0.46180037f, 0.39084259f, 0.10538536f, 
    -0.05348187f, 0.03153935f, -0.01503733f, 0.04930748f, 0.01373940f, 0.06027580f, -0.10703848f, 0.06767395f, 
    -0.12970434f, -0.55293989f, -0.22060959f, 0.15062208f, -0.10109795f, -0.05823434f, 0.04671131f, -0.04880022f, 
    0.03386478f, 0.14003925f, -0.05545156f, -0.10615233f, 0.01339119f, 0.12848383f, 0.18928252f, 0.09553668f, 
    -0.16168658f, 0.07018321f, -0.05637005f, -0.03135533f, -0.03068133f, -0.15428913f, 0.09376298f, -0.02475209f, 
    0.08655553f, 0.24388450f, 0.16730238f, 0.02020037f, -0.07201920f, 0.29641446f, 0.09656174f, -0.02074484f, 
    0.16054755f, 0.03021760f, -0.01590606f, 0.08901320f, 0.21164325f, 0.04818493f, -0.40583074f, 0.19211535f, 
    0.05492170f, -0.01459624f, 0.09046502f, -0.01653130f, 0.09242859f, -0.02418034f, 0.15485682f, 0.10937779f, 
    0.20713331f, 0.02669103f, 0.02713962f, 0.22965738f, 0.01259752f, -0.05582350f, -0.04376279f, -0.05483988f, 
    0.02659705f, -0.05549132f, -0.00023579f, 0.06023641f, -0.67061216f, -0.05422197f, 0.19128892f, -0.31573424f, 
    -0.13833125f, 0.07985107f, -0.09452841f, 0.06322263f, 0.07892596f, -0.17555673f, -0.02306064f, -0.14362605f, 
    0.14844456f, 0.04327069f, 0.02903100f, 0.14921550f, 0.02982344f, 0.03852770f, -0.03901443f, -0.01730790f, 
    0.08945940f, -0.14865454f, -0.00404984f, -0.23084454f, -0.29982507f, 0.24705836f, -0.07343192f, -0.19530648f, 
    -0.06331537f, -0.08430679f, -0.20264660f, 0.00944743f, 0.05747471f, -0.14744899f, -0.18077618f, 0.14041604f, 
    0.47903123f, -0.06188546f, -0.03039378f, 0.14478035f, 0.13897283f, 0.13664998f, -0.13098799f, -0.07641551f, 
    0.22186927f, 0.02609891f, -0.02088538f, 0.21188068f, -0.00364963f, 0.04159558f, 0.14545865f, 0.17708386f, 
    0.00495343f, 0.04199076f, -0.07553617f, -0.00331245f, 0.10588229f, 0.08909887f, 0.01342523f, 0.13382691f, 
    0.15419987f, 0.21843101f, -0.20660786f, 0.04630527f, 0.10584329f, -0.32279852f, -0.20662114f, -0.18316233f, 
    -0.17490245f, -0.05019087f, -0.03858124f, 0.09347176f, -0.03147051f, 0.01913011f, 0.00169905f, -0.19070698f, 
    0.04187772f, -0.00025456f, 0.10425766f, 0.26771244f, 0.23531908f, -0.11488781f, -0.10412024f, 0.06422316f, 
    0.37901029f, -0.01739080f, -0.17541483f, 0.13700508f, -0.16920818f, 0.10882722f, 0.02513002f, 0.05685898f, 
    0.36140823f, 0.04875510f, 0.06763418f, 0.20463270f, -0.19223490f, 0.22232802f, 0.19684881f, -0.27596056f, 
    0.26553729f, 0.16407555f, 0.24655862f, 0.18055788f, 0.01189834f, 0.01661194f, -0.00466892f, 0.00754086f, 
    0.37757045f, -0.11154827f, 0.62395370f, -0.07704692f, 0.03850450f, -0.14115746f, -0.11543357f, 0.12743539f, 
    0.36111149f, -0.14042129f, 0.02190382f, 0.30622172f, -0.43956262f, 0.33034310f, -0.19912952f, 0.03692735f, 
    -0.07497945f, -0.20840086f, 0.02202809f, -0.00046223f, 0.17988549f, -0.07354475f, -0.05236254f, 0.21239239f, 
    -0.31391498f, -0.18144493f, -0.06337323f, 0.13301735f, 0.15930972f, -0.08958504f, -0.10060795f, -0.14596182f, 
    0.12234889f, 0.24646385f, 0.18134323f, 0.12130745f, 0.04678124f, -0.02481059f, -0.11274491f, -0.08931181f, 
    0.06516667f, 0.00955169f, -0.02124912f, -0.13652761f, 0.15974067f, 0.21588081f, 0.07309470f, 0.18109328f, 
    0.24212678f, -0.01117299f, 0.12409201f, -0.09618787f, 0.04402072f, 0.01330296f, 0.15083472f, -0.18139742f, 
    0.09726343f, 0.01705205f, 0.08934736f, -0.13585216f, -0.27525637f, 0.19441418f, 0.07599359f, 0.36316666f, 
    0.02051728f, 0.06218207f, 0.26017016f, 0.10163958f, 0.15637940f, 0.10816360f, 0.06229723f, 0.20672049f, 
    -0.22717535f, 0.14867187f, 0.19687036f, -0.04363169f, -0.06280766f, 0.04619382f, -0.11877057f, 0.04680135f, 
    -0.19178303f, 0.02019010f, -0.03285823f, -0.02995131f, -0.31241545f, 0.08528756f, -0.23737377f, 0.02693452f, 
    0.15783842f, -0.07779417f, 0.15805285f, 0.15835984f, 0.00816191f, 0.12787594f, -0.02055246f, 0.24357267f, 
    -0.39607999f, -0.06469257f, -0.08350793f, -0.37315702f, -0.07448351f, 0.03111637f, -0.07031245f, 0.04420681f, 
    -0.11571013f, -0.18983036f, -0.21422493f, -0.41262484f, -0.29696572f, -0.35022298f, -0.23591271f, -0.28322971f, 
    0.03702446f, -0.06006819f, 0.27430904f, 0.24005024f, -0.22337085f, -0.11095887f, -0.02571652f, -0.35591048f, 
    0.27081406f, 0.00904220f, 0.05135088f, 0.27357274f, 0.01461320f, 0.15580776f, -0.14417601f, 0.05079829f, 
    0.24079917f, -0.00844157f, 0.22218138f, 0.30743402f, 0.04416043f, -0.17727958f, -0.02069581f, -0.24561824f, 
    0.02134346f, -0.03619431f, 0.02547751f, -0.00133868f, 0.01035164f, 0.07063207f, 0.02073351f, -0.03141942f, 
    0.16075778f, 0.25620985f, 0.22069360f, -0.13716719f, 0.27780178f, 0.38081366f, -0.06736774f, -0.03534590f, 
    -0.05615551f, -0.05911835f, 0.08828510f, -0.04939204f, -0.45376632f, 0.51363820f, 0.15984389f, -0.13640893f, 
    0.06124959f, 0.23924652f, 0.00505354f, 0.29206234f, -0.00598164f, -0.10871474f, 0.03574277f, -0.15754598f, 
    -0.17092390f, -0.14020661f, -0.19922459f, 0.76750833f, -0.13319682f, 0.02943465f, 0.29003310f, -0.16011116f, 
    0.27163827f, 0.04240398f, 0.32719812f, 0.09732712f, 0.17323142f, 0.04377239f, -0.01272048f, 0.08487673f, 
    0.05075466f, -0.01283653f, 0.08716749f, -0.05688310f, -0.14732331f, -0.07389189f, -0.14061010f, 0.11472236f, 
    -0.15458630f, 0.04056906f, 0.24473028f, -0.28100738f, -0.00032496f, -0.05495412f, 0.04079217f, 0.11382534f, 
    -0.03565075f, -0.07971513f, -0.13274813f, -0.13610572f, 0.11808937f, -0.35680261f, -0.29911101f, 0.10712089f, 
    -0.16804150f, -0.05880534f, 0.09661473f, -0.04778507f, -0.21490999f, -0.08374511f, 0.09093084f, 0.18052083f, 
    -0.03881780f, 0.61215717f, 0.05055473f, -0.27098832f, 0.09768807f, 0.08615329f, 0.12914373f, -0.03272390f, 
    -0.06288791f, 0.16716513f, -0.08436523f, 0.07040172f, -0.40852684f, 0.23017187f, 0.13407041f, -0.18293206f, 
    -0.06029029f, 0.07438021f, 0.19297732f, -0.00643437f, -0.15529402f, 0.00852773f, 0.07898508f, 0.13624795f, 
    0.23064916f, 0.35463908f, 0.19059946f, 0.15392983f, -0.02435228f, 0.02173957f, -0.21544263f, 0.35557446f, 
    -0.02470870f, -0.00856231f, 0.10851620f, 0.03974120f, -0.16168867f, -0.13111484f, 0.41876987f, -0.32982326f, 
    0.00252439f, -0.02635169f, -0.01932146f, -0.24250932f, -0.19094115f, -0.13944177f, 0.03868865f, -0.36683357f, 
    -0.18073949f, -0.46999568f, -0.45313531f, -0.20737429f, -0.05674609f, 0.06419814f, 0.03978447f, -0.02895154f, 
    -0.13304761f, 0.02390049f, -0.03574638f, -0.10478383f, 0.12120686f, 0.43973050f, -0.07651767f, 0.02418798f, 
    -0.07005431f, 0.11968005f, 0.27028751f, -0.07771245f, 0.01976502f, 0.07323585f, 0.07136222f, -0.18020520f, 
    -0.01379616f, 0.05625466f, -0.16712359f, 0.19933960f, -0.06721680f, 0.06837021f, -0.18386392f, 0.03248162f, 
    -0.27998307f, 0.02194826f, -0.19404058f, 0.33542919f, 0.48113731f, 0.23278940f, 0.19215716f, -0.03272004f, 
    0.17278199f, 0.18303300f, -0.02329826f, 0.07046875f, 0.10065453f, 0.14543004f, -0.13919373f, -0.23204626f, 
    0.19091536f, 0.30452076f, -0.14025970f, 0.09460687f, -0.13139881f, -0.33265880f, 0.24545199f, 0.17157377f, 
    -0.09269812f, 0.03090388f, -0.10876314f, -0.28673765f, -0.25005203f, 0.01835151f, -0.06545880f, -0.21755230f, 
    -0.00128592f, 0.09208413f, -0.15732871f, -0.10234746f, 0.03804347f, -0.20034885f, 0.01372550f, -0.27670163f, 
    -0.14403214f, -0.22725682f, -0.44791934f, -0.07172161f, -0.00482357f, 0.03406958f, -0.00983993f, -0.11283454f, 
    -0.16124493f, 0.15004662f, -0.03100676f, 0.00616853f, 0.30102855f, 0.05575903f, 0.03482924f, 0.23059410f, 
    -0.21850210f, 0.19639961f, 0.14205635f, -0.08623558f, -0.03319968f, 0.09243156f, 0.09828624f, -0.17274569f, 
    0.35653803f, 0.19078894f, -0.18396947f, -0.30024332f, -0.01860239f, 0.08445629f, -0.09160233f, -0.16317755f, 
    0.02329628f, -0.10410637f, -0.24883349f, 0.05629071f, 0.41639397f, 0.29825380f, 0.29221144f, 0.28183970f, 
    -0.00688294f, 0.04841721f, 0.01428130f, 0.10552500f, -0.01527277f, 0.13123657f, -0.03518263f, 0.08347718f, 
    -0.14888632f, -0.19211476f, 0.39889327f, -0.04023638f, -0.04529133f, -0.17961963f, 0.08293741f, 0.14818996f, 
    0.07428937f, 0.16337122f, 0.24141851f, 0.05012916f, -0.24160817f, -0.27853361f, 0.02806493f, -0.10334750f, 
    0.18021594f, 0.10546134f, -0.15942246f, 0.18755142f, 0.02700052f, -0.05508100f, 0.19230895f, -0.07268002f, 
    0.15284586f, 0.44368240f, 0.18544237f, 0.27933475f, -0.00715878f, 0.06390978f, -0.09644778f, -0.09098892f, 
    0.18968193f, 0.14772582f, -0.13338108f, 0.25359485f, 0.16773619f, 0.13912624f, 0.09815036f, 0.04710266f, 
    -0.02638543f, 0.04747921f, 0.01390634f, -0.01044584f, 0.02606951f, -0.04479517f, -0.18609937f, -0.08804609f, 
    -0.08522868f, -0.05260406f, 0.16127676f, 0.06073048f, -0.16843911f, -0.14044806f, -0.08752611f, -0.14576122f, 
    -0.02696127f, 0.04234673f, 0.09074069f, 0.01733582f, 0.02605876f, -0.04282006f, 0.12367590f, -0.30228272f, 
    0.01793603f, -0.06312449f, 0.30281079f, -0.02953175f, 0.15295385f, 0.03293849f, -0.11159936f, -0.16147144f, 
    0.18865010f, -0.22816157f, -0.11572949f, -0.33484271f, 0.00323208f, 0.06271434f, 0.07863423f, -0.06508063f, 
    0.16555290f, 0.06446666f, 0.02190699f, -0.10217461f, -0.27164248f, 0.05021802f, -0.03983031f, 0.39863962f, 
    -0.22448896f, -0.20869194f, 0.04090578f, 0.10229711f, -0.05326289f, 0.08523820f, -0.04952953f, 0.24112386f, 
    0.03331733f, 0.03877587f, 0.06541568f, -0.17099148f, 0.09614982f, 0.01150026f, 0.13503493f, -0.02616569f, 
    -0.00967559f, -0.02500376f, 0.05597273f, 0.06820546f, -0.46729752f, 0.06461065f, 0.11866209f, 0.23070420f, 
    -0.06614706f, -0.07166047f, 0.18404847f, 0.13557534f, -0.04539549f, 0.00400370f, 0.14503220f, 0.10795621f, 
    -0.00265877f, 0.25423196f, 0.00310816f, 0.15193260f, 0.07377835f, 0.01612425f, 0.16777182f, 0.15329263f, 
    0.10978322f, -0.21611995f, 0.24222438f, -0.08512823f, -0.07301739f, -0.01226879f, -0.24933995f, 0.09439619f, 
    -0.00453888f, 0.12437233f, -0.00259992f, -0.03079213f, 0.02488808f, 0.07095282f, 0.07710534f, -0.05457090f, 
    0.29737845f, -0.09440634f, -0.14044441f, 0.08501603f, -0.08628751f, 0.25913250f, 0.23675899f, 0.02748003f, 
    0.04583558f, -0.03585869f, 0.03580893f, -0.09010167f, -0.24510184f, -0.09562522f, 0.52344424f, 0.26169333f, 
    0.00137074f, -0.09969901f, -0.42784682f, -0.05582971f, -0.23634019f, 0.16505511f, 0.14268200f, -0.04963686f, 
    0.19687423f, -0.02952616f, 0.28181118f, 0.31739643f, 0.14124861f, 0.01747959f, -0.13354205f, -0.18020552f, 
    -0.07653300f, -0.03767791f, -0.14988001f, -0.03547420f, -0.03000061f, -0.01828353f, 0.04601831f, 0.17811993f, 
    -0.11519608f, -0.36143839f, -0.16945714f, -0.21807539f, 0.08971312f, -0.06566343f, 0.04083320f, -0.03591853f, 
    -0.58576661f, -0.10442246f, -0.01718573f, 0.17491426f, 0.11248854f, -0.07993471f, -0.04207087f, -0.03233314f, 
    -0.10605723f, -0.23058011f, -0.16319488f, -0.08361172f, 0.33727640f, -0.57552022f, -0.01313484f, -0.03366866f, 
    0.03484943f, 0.09046888f, -0.02263845f, 0.00197129f, -0.01355958f, -0.04526021f, -0.09419402f, 0.14284235f, 
    -0.10809814f, 0.28584880f, -0.15177634f, 0.08480410f, -0.10174274f, -0.03707471f, 0.15096560f, 0.05244596f, 
    0.04053957f, 0.12922525f, -0.05647638f, 0.34554490f, -0.01595927f, 0.06731487f, 0.13656300f, 0.04714905f, 
    -0.05283179f, 0.11728068f, 0.15748760f, 0.02781988f, 0.01178749f, 0.01353135f, 0.09489198f, 0.08063568f, 
    0.11754504f, 0.30375937f, 0.35467276f, 0.21793889f, -0.17398158f, 0.03078323f, -0.04384412f, 0.37824568f, 
    0.15303949f, 0.03394907f, 0.04492460f, -0.03069428f, -0.03015541f, -0.10619592f, -0.16008604f, -0.21190803f, 
    0.05889840f, 0.02564513f, 0.03334828f, -0.06539670f, -0.00160502f, -0.01592318f, -0.09527870f, -0.23861146f, 
    -0.10265226f, -0.20586197f, -0.42954734f, 0.13742477f, 0.14393963f, -0.04372696f, 0.01229256f, -0.01677753f, 
    0.06676101f, 0.10909916f, 0.06727150f, -0.03566972f, 0.19194786f, 0.35659683f, 0.29260790f, 0.14044692f, 
    -0.06575914f, 0.14060214f, 0.00085725f, 0.06874852f, 0.09278516f, -0.11532514f, 0.03405067f, -0.04459631f, 
    -0.10067608f, -0.22788765f, -0.20769571f, -0.03696809f, 0.02099673f, 0.00762371f, -0.06473759f, -0.09164898f, 
    0.01036723f, -0.12961277f, -0.09509017f, 0.21523401f, 0.22777092f, 0.29249173f, 0.26942569f, -0.09007132f, 
    0.08821987f, -0.05089042f, 0.01288218f, 0.00592232f, -0.00052836f, 0.04663713f, -0.03591167f, -0.03137458f, 
    0.10657776f, -0.18294016f, 0.07789425f, -0.11204119f, 0.01058274f, 0.01350538f, 0.00939916f, -0.01705213f, 
    -0.06100240f, -0.02231477f, 0.06333234f, -0.04739713f, -0.23456380f, -0.25530472f, 0.00061628f, 0.06265374f, 
    -0.07257409f, 0.02391995f, -0.00962624f, -0.09330393f, 0.22240435f, 0.02480397f, 0.11531804f, 0.08520637f, 
    0.04011813f, 0.03746571f, -0.45490617f, 0.00714424f, 0.15649673f, -0.16410951f, -0.02808463f, -0.00413900f, 
    -0.07259269f, -0.03354979f, -0.01085304f, -0.04645834f, 0.25059226f, 0.07021761f, -0.00169793f, 0.18038271f, 
    -0.14294098f, 0.03124456f, -0.22033066f, 0.00621121f, 0.15923932f, 0.08842870f, -0.00410927f, -0.01485895f, 
    0.39827725f, 0.08080596f, -0.08741984f, -0.29793152f, -0.01899216f, 0.21210426f, -0.03693303f, -0.08179362f, 
    -0.08823266f, -0.01585228f, 0.07253616f, 0.21824835f, 0.34592876f, 0.44106278f, 0.45554790f, 0.21629724f, 
    -0.14402810f, 0.08334812f, 0.08676970f, 0.23627147f, 0.06791297f, -0.00132515f, 0.05154338f, -0.04547213f, 
    -0.04181939f, 0.05308310f, 0.05365273f, -0.07221137f, 0.00613297f, 0.01710446f, 0.02777197f, 0.00975628f, 
    0.06206154f, -0.02733630f, 0.00896036f, -0.06753700f, 0.02416627f, -0.02484892f, 0.01296572f, -0.04090595f, 
    -0.02449628f, 0.02721681f, -0.06662302f, -0.05566176f, -0.01390185f, -0.07483549f, 0.00895740f, -0.06476167f, 
    -0.02043909f, 0.03301994f, -0.06082503f, -0.00141726f, -0.07560400f, 0.00080454f, -0.04914851f, 0.02095852f, 
    -0.01559018f, -0.04321683f, 0.02633806f, -0.00453828f, -0.00309861f, -0.02447257f, -0.03056361f, 0.02183802f, 
    -0.00438855f, 0.00818034f, -0.05166750f, -0.05827448f, 0.06134067f, -0.02803726f, 0.04923978f, -0.02095605f, 
    0.01688431f, -0.05187802f, -0.00933370f, -0.00218399f, -0.06877366f, -0.00437929f, 0.06197459f, -0.01806062f, 
    -0.03591238f, -0.02879293f, 0.01105210f, -0.05738921f, 0.01912392f, 0.01563299f, 0.05595433f, -0.05966563f, 
    -0.01810795f, -0.02764560f, -0.05204350f, 0.04046540f, -0.01666084f, -0.03462839f, -0.02982503f, 0.04625004f, 
    -0.03050990f, 0.00222386f, 0.03556598f, 0.03198940f, 0.01144713f, -0.03759052f, 0.03366176f, -0.05098324f, 
    0.04623831f, 0.04986795f, -0.02774493f, -0.00390129f, 0.02917992f, 0.03524802f, 0.01167499f, -0.07152804f, 
    0.03694163f, -0.07031033f, 0.00291540f, -0.06771863f, -0.05969370f, -0.00283177f, -0.00598429f, -0.01279709f, 
    -0.05307927f, -0.05875195f, -0.04097072f, -0.04150694f, 0.00966077f, 0.05287146f, -0.05960479f, -0.05002764f, 
    0.04092337f, -0.04729166f, -0.06916583f, 0.03748176f, 0.00802862f, 0.03997305f, -0.06912637f, -0.06686701f, 
    0.03234605f, 0.03150029f, 0.01313378f, -0.02267310f, 0.02117443f, -0.02708268f, 0.03968367f, 0.04844574f, 
    -0.04967877f, -0.03354799f, 0.00720487f, -0.06090017f, -0.04585443f, 0.00359984f, -0.03637962f, 0.01985155f, 
    0.05405463f, 0.04312182f, 0.00228860f, -0.06738842f, -0.06871205f, 0.04947402f, 0.04403397f, 0.00035509f, 
    0.05546908f, -0.01730652f, 0.02667745f, -0.03112565f, -0.04015751f, 0.05415669f, -0.02970689f, -0.04404714f, 
    0.00177657f, 0.00725317f, 0.05033500f, -0.07808354f, -0.05813912f, -0.05706742f, -0.02618177f, 0.04520842f, 
    0.04920166f, 0.00716680f, 0.02034507f, -0.05975238f, 0.00903350f, 0.03299985f, -0.05524855f, 0.05862520f, 
    0.03579069f, -0.07326079f, -0.02081839f, -0.06915067f, -0.00549576f, 0.04137107f, -0.00972191f, 0.00317398f, 
    0.04560187f, -0.02750930f, -0.07746866f, -0.04815418f, -0.07030351f, -0.04833727f, 0.02362210f, 0.04572282f, 
    -0.03377496f, -0.06345654f, -0.07724591f, 0.02001262f, -0.03366647f, 0.01435557f, 0.05340952f, -0.07045550f, 
    0.05601450f, -0.00614628f, 0.05992423f, 0.01335429f, 0.03656562f, 0.00278326f, 0.04596689f, 0.05026684f, 
    0.37562475f, -0.07994010f, 0.05517170f, -0.27406034f, 0.08671248f, 0.01952242f, -0.00811401f, 0.08944428f, 
    0.26178002f, 0.22740389f, 0.04797707f, 0.07270853f, -0.62320048f, 0.70684087f, -0.28813955f, 0.09573188f, 
    -0.05630152f, -0.11620354f, 0.01232542f, -0.02005355f, -0.01297616f, -0.07635828f, 0.16071007f, 0.11662541f, 
    -0.19576539f, -0.15320271f, -0.33186361f, -0.34164679f, 0.10072577f, 0.03486266f, -0.12438907f, 0.00505056f, 
    -0.09400213f, 0.20452893f, 0.12615272f, 0.18339549f, 0.05518474f, -0.08133909f, -0.20129772f, -0.06134571f, 
    0.19721320f, -0.08440143f, -0.10757986f, -0.19340308f, 0.09389402f, 0.13386366f, 0.03588330f, 0.05273941f, 
    -0.05487243f, -0.18182370f, -0.06079574f, 0.24407592f, -0.02009482f, -0.11182035f, 0.10761645f, 0.08379313f, 
    0.06244779f, 0.17417692f, 0.04369982f, 0.07716312f, 0.22706139f, 0.25959834f, 0.42582402f, 0.29348141f, 
    -0.05920054f, 0.02330578f, 0.06018675f, -0.09037407f, -0.05838646f, 0.11331659f, 0.08932894f, 0.08965217f, 
    -0.13459674f, 0.12812866f, 0.19303754f, -0.14519753f, -0.08343323f, -0.07736128f, -0.07752202f, -0.01332891f, 
    -0.15252095f, -0.10448935f, -0.04323522f, -0.02816328f, 0.11297807f, -0.02504030f, -0.36747715f, -0.21941136f, 
    0.26403284f, -0.03111849f, 0.21508630f, 0.05089599f, 0.10490125f, -0.02434015f, -0.06044370f, 0.45012176f, 
    -0.10216238f, 0.11332545f, 0.12817423f, -0.25922573f, -0.08344775f, 0.12371273f, -0.03644903f, 0.08129945f, 
    -0.11734086f, 0.15444228f, -0.14929494f, -0.11199316f, 0.18254374f, -0.40937203f, -0.09394856f, -0.13233706f, 
    0.06109362f, -0.01231953f, 0.15339153f, 0.07648524f, 0.03320314f, 0.16956662f, 0.19259058f, 0.08052360f, 
    -0.09307110f, -0.12903655f, 0.36307102f, 0.28428781f, -0.11731897f, 0.26117775f, -0.12828279f, -0.16204399f, 
    -0.07405649f, 0.01266687f, 0.10284463f, 0.06904003f, 0.29876444f, -0.00212898f, 0.01447403f, -0.29255784f, 
    -0.03179821f, -0.10970826f, 0.11286483f, -0.10417749f, -0.05046635f, 0.12606956f, -0.05298519f, 0.05491633f, 
    0.17724830f, -0.03308118f, 0.54492837f, 0.10819348f, 0.09648661f, 0.25047866f, -0.15265784f, -0.04698059f, 
    0.01375221f, -0.03158923f, 0.06959686f, 0.02631223f, -0.35155183f, 0.09716780f, -0.25562727f, 0.09956811f, 
    -0.03975172f, -0.00333576f, 0.15826230f, 0.13001180f, 0.10441642f, 0.11187533f, 0.12898259f, 0.03248519f, 
    -0.53931224f, 0.14035799f, -0.15908888f, 0.41848606f, 0.02377309f, -0.07162175f, 0.30081216f, 0.02746703f, 
    0.19284816f, 0.04949841f, 0.27188683f, 0.07007608f, -0.05833800f, -0.25706890f, 0.04438338f, 0.41890255f, 
    -0.11185447f, -0.11878531f, 0.02211364f, -0.02643826f, -0.03870644f, -0.05458550f, -0.13225514f, 0.01241952f, 
    -0.10422837f, 0.24183932f, -0.23340653f, 0.60668296f, 0.01436919f, 0.00754827f, -0.11068215f, -0.16491747f, 
    -0.05657549f, -0.11368072f, -0.26347601f, -0.30495384f, 0.22027847f, 0.24900949f, 0.60261357f, -0.14917201f, 
    0.05103099f, -0.07246221f, -0.23008321f, -0.00627605f, -0.05128771f, 0.07052834f, -0.05938910f, 0.10795901f, 
    0.12104659f, 0.59196657f, -0.12882178f, 0.07080120f, -0.21279928f, -0.04585218f, -0.09542719f, 0.01633043f, 
    -0.00055973f, -0.04251464f, 0.08748908f, 0.20602605f, 0.25372404f, 0.01225967f, -0.02290137f, -0.07862157f, 
    -0.05029698f, 0.08168279f, -0.06037998f, 0.01899408f, 0.20597342f, 0.11968802f, 0.15308364f, 0.39302719f, 
    -0.14205596f, -0.18011774f, 0.06563953f, 0.26613238f, -0.02149912f, 0.00423472f, 0.26624471f, 0.35361111f, 
    0.13996007f, 0.09731055f, -0.01433578f, -0.04257822f, -0.05618060f, 0.46396300f, -0.04564272f, -0.18523669f, 
    0.00522691f, -0.11410930f, -0.02609872f, 0.02400144f, 0.08374381f, 0.03646582f, -0.02428518f, -0.02650713f, 
    -0.58006895f, 0.16067879f, -0.24792528f, 0.05447295f, 0.03775024f, -0.20260905f, 0.01555699f, -0.14394824f, 
    0.03803546f, -0.05212521f, 0.08262086f, 0.09338507f, 0.22733837f, -0.04273117f, -0.02850811f, 0.17207018f, 
    0.25132746f, -0.18367828f, -0.08310641f, 0.01687828f, 0.13385992f, -0.02849012f, 0.04063280f, 0.03881480f, 
    -0.02679115f, 0.09020166f, -0.00023751f, 0.12737851f, -0.11258382f, -0.17439464f, -0.00932624f, -0.16123009f, 
    0.16225864f, 0.10244433f, 0.02687978f, 0.23842037f, 0.03899408f, -0.11703996f, 0.09707899f, 0.21102212f, 
    -0.06339190f, -0.14506194f, -0.12488263f, -0.25441357f, 0.00340083f, 0.05401526f, -0.00229107f, 0.11637712f, 
    -0.41064340f, -0.10026377f, 0.13174123f, -0.39558437f, -0.01965516f, -0.18067192f, 0.10290042f, -0.18807100f, 
    -0.12921625f, 0.28909868f, -0.09138361f, 0.06686481f, -0.13843049f, 0.06837468f, -0.33450878f, -0.04671530f, 
    -0.18923993f, -0.02098729f, 0.15925933f, -0.25599065f, 0.08015788f, 0.06934699f, 0.11620818f, 0.09638172f, 
    -0.32454202f, -0.41016978f, 0.14667565f, 0.13249457f, 0.10478142f, -0.22242050f, 0.32331890f, 0.26117101f, 
    0.09351106f, -0.05030436f, -0.01013755f, 0.01474781f, -0.01790792f, -0.27864069f, 0.22806232f, -0.07860354f, 
    0.10323877f, 0.01975204f, -0.07612181f, -0.18282671f, 0.26277298f, -0.20251985f, -0.01223934f, 0.08968121f, 
    -0.08111910f, 0.04742416f, 0.20774247f, -0.00915992f, 0.00559496f, 0.14994328f, -0.21622491f, 0.04028793f, 
    -0.02245284f, 0.14177914f, 0.03958051f, 0.25421712f, -0.27672401f, -0.14493915f, 0.06053464f, 0.29185918f, 
    -0.03376130f, 0.10839971f, -0.09302802f, 0.37692365f, 0.08417393f, -0.02897864f, 0.13677159f, 0.04024432f, 
    0.01828619f, 0.00695299f, 0.00959826f, -0.01229992f, -0.07500181f, -0.07558948f, 0.00210294f, 0.04595164f, 
    0.02135172f, 0.00883172f, 0.06333944f, 0.06265895f, -0.04498522f, -0.05194476f, 0.03182680f, 0.05743606f, 
    -0.04548021f, 0.04761630f, -0.01108823f, 0.03411832f, 0.00388091f, -0.05078900f, -0.01095234f, -0.07513663f, 
    -0.00691859f, -0.05216330f, 0.05106419f, -0.06920870f, 0.03323430f, 0.03248933f, 0.01992108f, -0.03123590f, 
    -0.06952736f, 0.00996102f, -0.06288417f, 0.02452207f, -0.01295249f, -0.04374151f, 0.04396953f, 0.04651055f, 
    0.02798562f, 0.00585608f, 0.05200807f, 0.02629273f, 0.03258180f, 0.00991664f, -0.03093212f, 0.01457469f, 
    0.00834986f, 0.02587595f, -0.06906414f, 0.00527341f, 0.00421102f, 0.05269260f, 0.06423847f, -0.00155578f, 
    -0.01216769f, 0.01295222f, -0.03825089f, -0.05953839f, -0.04648950f, -0.00457248f, -0.07116357f, 0.02809897f, 
    -0.07704865f, -0.02295705f, -0.05024933f, -0.06823362f, -0.05229759f, -0.00683823f, 0.04026255f, 0.03220473f, 
    -0.03539582f, -0.07072385f, -0.03843584f, -0.02682760f, 0.00371002f, -0.06055229f, 0.02458232f, -0.00695536f, 
    0.03063637f, 0.05805331f, -0.04551277f, 0.04874519f, -0.00776607f, -0.04844245f, -0.02553421f, 0.00372120f, 
    -0.03039421f, -0.03823853f, 0.01365147f, 0.01973153f, -0.01413887f, 0.05504367f, -0.05786143f, -0.06784321f, 
    0.03714480f, -0.00196443f, 0.00237308f, 0.02962952f, -0.02386165f, -0.02645099f, -0.05963391f, -0.06815954f, 
    -0.00077298f, -0.04094764f, -0.04576375f, 0.04697857f, 0.03632028f, 0.01044261f, 0.01581172f, -0.01621594f, 
    0.00758973f, -0.04963376f, 0.02460990f, -0.03686205f, 0.02664469f, -0.00016262f, -0.03460978f, -0.02839242f, 
    -0.06741195f, -0.04935611f, 0.01083518f, 0.05019240f, -0.01655231f, 0.04254320f, -0.04798863f, -0.07250271f, 
    -0.04110003f, -0.01579259f, -0.05256886f, -0.04442773f, 0.06002822f, -0.01993159f, 0.01599962f, -0.02042858f, 
    0.00274667f, 0.00549153f, 0.04135999f, 0.02857379f, -0.06193312f, -0.02905535f, -0.03494160f, -0.00530173f, 
    0.01190204f, -0.02900525f, -0.06710107f, 0.01362308f, 0.05272611f, -0.06836928f, -0.02445407f, -0.00314025f, 
    0.01140982f, -0.01355435f, -0.02286463f, -0.05454880f, 0.03291227f, -0.05245871f, -0.04113569f, 0.05163401f, 
    -0.04339758f, 0.04560933f, 0.04291648f, -0.05518453f, -0.05308590f, 0.04908561f, 0.03133275f, 0.02192986f, 
    0.02350224f, 0.05633705f, -0.08505511f, 0.00349159f, -0.05147712f, 0.01326530f, -0.02713340f, -0.01006164f, 
    -0.06301213f, -0.00107340f, -0.06672612f, -0.03776190f, -0.04136941f, -0.00743293f, -0.02645438f, -0.06358193f, 
    0.05957354f, 0.01681186f, -0.05324584f, -0.03298659f, 0.03611604f, 0.02904351f, 0.00258052f, -0.01517895f, 
    0.05815684f, 0.15766805f, -0.02646421f, 0.46136034f, 0.30222553f, 0.08235256f, -0.01115879f, 0.02446247f, 
    0.37297574f, 0.40519238f, 0.16953135f, 0.13268416f, 0.30257100f, -0.52147245f, 0.47489944f, -0.03130605f, 
    -0.07919974f, 0.11764321f, -0.19173634f, 0.13746047f, 0.16405851f, -0.00804308f, 0.27235103f, 0.08047252f, 
    -0.00925265f, -0.16766572f, -0.10721073f, 0.66949582f, -0.12752219f, -0.21175055f, -0.00863269f, -0.10415157f, 
    -0.05865315f, -0.07996344f, 0.30355194f, 0.35330573f, 0.07973455f, 0.02724083f, -0.15731843f, -0.02510778f, 
    -0.03723819f, -0.21993770f, 0.03887060f, 0.12607594f, 0.04233260f, 0.13044475f, -0.13651522f, -0.05526159f, 
    -0.37728608f, -0.11690470f, -0.02699527f, -0.12019302f, -0.37598208f, -0.09627032f, -0.11456002f, 0.04862462f, 
    0.08287044f, -0.06080787f, -0.01124627f, 0.05733551f, 0.50483888f, 0.16536126f, -0.02028337f, -0.29117426f, 
    0.13751067f, 0.00560855f, 0.29405743f, -0.02485460f, 0.08209271f, 0.37650692f, 0.06618977f, 0.00872246f, 
    0.26504034f, 0.03908577f, -0.02507833f, -0.43190187f, -0.04333210f, 0.03320705f, -0.11745752f, -0.12844202f, 
    -0.07833374f, -0.05990959f, -0.05693899f, 0.12367464f, 0.13474323f, -0.06117230f, 0.22573745f, 0.59092367f, 
    0.00455984f, 0.07717843f, 0.01107443f, 0.22785708f, 0.15660714f, 0.02841786f, 0.10546719f, 0.01005284f, 
    0.02661753f, 0.14317958f, 0.18205361f, -0.26765808f, -0.01896590f, -0.14215124f, -0.10069979f, -0.08426943f, 
    -0.08498736f, 0.08406886f, 0.06025047f, 0.18703906f, -0.29113927f, 0.54796088f, 0.31899247f, 0.17411654f, 
    -0.26096246f, -0.12622781f, -0.16738528f, 0.00862318f, -0.09805996f, -0.02635016f, 0.09203123f, -0.09015099f, 
    0.33100373f, -0.02455196f, 0.27531198f, 0.40584236f, 0.18908398f, -0.01663093f, -0.02127491f, -0.23583643f, 
    0.08293231f, 0.18305376f, 0.04068647f, -0.06442526f, 0.03340295f, 0.09937068f, -0.39485875f, -0.05020221f, 
    0.11130881f, -0.02240061f, 0.07358550f, -0.12636743f, 0.07143248f, -0.11068328f, 0.03185445f, 0.01335932f, 
    0.30975407f, -0.29122221f, -0.60174042f, -0.53777850f, 0.06835008f, 0.13505693f, -0.10698638f, -0.17144588f, 
    -0.03689430f, -0.11191018f, -0.01803205f, 0.19684340f, -0.64597362f, -0.34728685f, 0.74654847f, 0.12405807f, 
    -0.19098486f, 0.00688222f, -0.09209422f, 0.00904193f, 0.23362620f, 0.20798205f, 0.00682901f, 0.22586492f, 
    0.13159266f, -0.06893043f, 0.20965195f, 0.37588602f, -0.05530922f, -0.24077395f, -0.10555546f, 0.18271604f, 
    0.42427814f, 0.18309055f, 0.19586034f, 0.11905348f, -0.33237386f, -0.11901275f, 0.27943447f, -0.14156422f, 
    -0.03819676f, 0.10267796f, -0.00105400f, -0.08756652f, -0.03633424f, -0.15874350f, -0.00339615f, -0.03967276f, 
    -0.01557160f, 0.16193084f, 0.09031479f, -0.04166070f, -0.00269390f, -0.04099371f, -0.04270433f, 0.04882965f, 
    -0.09483472f, -0.00138155f, 0.33443844f, 0.18575422f, -0.24980935f, -0.65409362f, -0.03081320f, -0.30886537f, 
    0.28095269f, -0.11232203f, -0.21716915f, -0.06067342f, -0.03669734f, 0.04813221f, -0.13673013f, -0.03012392f, 
    0.33308768f, 0.30624369f, 0.14401953f, -0.01755036f, -0.19385742f, -0.03044855f, -0.14898512f, -0.25206348f, 
    0.29991606f, 0.02636101f, -0.15128718f, 0.08884834f, -0.15980826f, 0.08864252f, 0.01649723f, 0.21556321f, 
    0.03321013f, 0.14315090f, -0.06842507f, -0.21592571f, -0.54453123f, -0.43226394f, -0.54321438f, -0.48069197f, 
    0.29191881f, 0.20816061f, 0.23707436f, 0.26260948f, 0.04763477f, -0.04771060f, 0.07949079f, 0.13693832f, 
    0.07019427f, 0.18226059f, 0.18361339f, 0.06503131f, -0.69881678f, 0.00157756f, -0.06164929f, -0.27765661f, 
    -0.01345124f, 0.02521428f, 0.12464968f, -0.01657437f, 0.15887550f, -0.19739331f, 0.13227603f, -0.03623693f, 
    -0.30807334f, 0.15678413f, -0.25471067f, 0.28251910f, 0.44475579f, 0.27185622f, -0.15654792f, -0.15376800f, 
    0.07192888f, -0.23732245f, 0.15732223f, 0.04812895f, -0.00748168f, 0.19893360f, 0.05783970f, 0.11913697f, 
    -0.13285188f, 0.09932915f, -0.02086960f, -0.09735496f, 0.00628623f, -0.17269935f, -0.15406658f, 0.19257888f, 
    -0.25986016f, -0.18987654f, -0.30907312f, 0.11728580f, 0.19675955f, 0.00971183f, 0.27569252f, -0.02991470f, 
    0.25708112f, 0.19117163f, 0.00836272f, 0.36871040f, -0.17334379f, -0.26199439f, 0.05290045f, 0.02762541f, 
    0.07189901f, 0.07344313f, 0.07273066f, 0.25102299f, 0.20676467f, 0.10582800f, 0.19454119f, 0.38608560f, 
    -0.06265776f, -0.26525638f, 0.41896558f, -0.15937668f, 0.05174684f, -0.16872542f, -0.13103582f, -0.05621763f, 
    0.11546672f, -0.36657453f, -0.01938765f, -0.17858456f, 0.12978259f, -0.32159191f, -0.17254892f, 0.32348824f, 
    -0.01731040f, 0.38489044f, 0.04444509f, 0.20707102f, -0.16739264f, 0.12676436f, 0.27525690f, -0.02510781f, 
    0.16600639f, 0.79287589f, -0.01864552f, 0.49891469f, 0.27338967f, 0.32958984f, 0.06382535f, 0.04235339f, 
    -0.18259391f, 0.00557425f, -0.01812834f, -0.59176326f, 0.33089280f, 0.01286094f, -0.00636316f, 0.21487130f, 
    -0.14075020f, -0.05420207f, -0.27504304f, -0.02258277f, 0.17174293f, 0.04746044f, 0.01797439f, -0.07999052f, 
    0.12890828f, 0.07016504f, 0.22281136f, 0.10141890f, 0.04310732f, -0.09896052f, -0.11707127f, -0.23937935f, 
    -0.18951701f, 0.06767381f, -0.18419212f, -0.01523575f, 0.23338613f, 0.15004829f, -0.06073456f, -0.01732689f, 
    0.09516241f, -0.11985788f, -0.03756835f, 0.15494813f, -0.15836500f, -0.07076309f, 0.07105660f, -0.00210859f, 
    0.16738349f, 0.34600392f, -0.33742067f, 0.04765392f, -0.00606596f, 0.18823341f, 0.09290919f, 0.04808034f, 
    -0.01415842f, 0.32497647f, 0.37160328f, 0.08584457f, -0.24094950f, 0.02511653f, 0.03346090f, -0.10131880f, 
    0.17977074f, -0.04313942f, -0.14515334f, -0.00654229f, -0.04775180f, 0.08392740f, 0.27677193f, -0.16570096f, 
    0.43323457f, -0.00928241f, 0.22885069f, 0.40299955f, -0.03388836f, -0.05179958f, -0.28281438f, -0.00276480f, 
    0.21622272f, -0.24471699f, 0.15942584f, 0.09541509f, -0.03092747f, -0.26043248f, -0.08901023f, 0.15252715f, 
    0.17283027f, 0.10058931f, -0.06888350f, -0.16785142f, -0.32173276f, -0.33004233f, -0.69371802f, -0.66261578f, 
    -0.15938643f, -0.24155295f, -0.09323128f, 0.00366399f, 0.16850883f, -0.29913816f, 0.02924615f, 0.13327584f, 
    0.01856354f, 0.15822282f, -0.02077725f, 0.02678278f, -0.32718143f, 0.21479963f, 0.00584798f, -0.05322982f, 
    0.16365214f, 0.06475778f, -0.05075125f, 0.03270548f, 0.15436970f, 0.08724057f, -0.00951803f, 0.39229998f, 
    -0.25675383f, 0.02166960f, -0.05697428f, -0.12450562f, 0.15469024f, -0.02080299f, -0.15697415f, -0.05378562f, 
    -0.00047223f, -0.15895396f, 0.00516465f, 0.11556065f, 0.33785027f, -0.32602087f, 0.47064680f, 0.55916697f, 
    0.16750491f, 0.11653032f, -0.04664021f, 0.00404020f, -0.08408300f, -0.18596706f, -0.17467523f, 0.04370771f, 
    -0.11766288f, 0.02648594f, -0.22995964f, -0.09859353f, 0.07089837f, -0.08238274f, 0.25335529f, -0.08556423f, 
    0.26140746f, 0.52702785f, 0.31728753f, 0.26291934f, 0.18478772f, -0.06844147f, 0.25369787f, 0.52458394f, 
    0.10970811f, 0.03495155f, 0.18749903f, 0.21368971f, 0.18539959f, 0.22036026f, 0.30138797f, 0.47136274f, 
    -0.63421714f, -0.06355218f, 0.32849297f, -0.22407585f, -0.14257328f, 0.04575001f, -0.04176164f, -0.29593712f, 
    -0.16924106f, -0.05116838f, 0.01559632f, -0.01849461f, 0.07298516f, -0.18003541f, -0.23144636f, -0.05481444f, 
    0.10335252f, 0.05872396f, 0.20540152f, 0.20070399f, -0.07703532f, 0.29077587f, 0.04173698f, -0.25310448f, 
    -0.23332821f, 0.02675467f, 0.38431719f, 0.21999140f, 0.09257947f, 0.21484399f, -0.07191750f, -0.00407881f, 
    -0.10785850f, -0.25216293f, -0.28180826f, -0.40520909f, 0.35453448f, -0.07655939f, 0.20750052f, 0.22496830f, 
    0.15257491f, -0.21849135f, -0.12146265f, 0.20723033f, 0.19264641f, 0.06573637f, 0.06700169f, 0.21415985f, 
    -0.24774519f, 0.13196613f, 0.60753059f, -0.15965129f, -0.07421792f, 0.11275392f, -0.16144052f, 0.16788235f, 
    -0.08981919f, 0.12552935f, 0.00898161f, -0.15497029f, -0.30737248f, -0.17587872f, -0.15984002f, -0.11936270f, 
    -0.02651265f, -0.07792969f, -0.05612818f, 0.18482798f, -0.17257833f, -0.32153517f, -0.01910412f, -0.12361515f, 
    0.30902785f, 0.19151413f, -0.27036026f, -0.00228277f, -0.19030648f, 0.09437495f, 0.00675284f, -0.16111074f, 
    -0.05830635f, -0.14731704f, -0.18708305f, 0.03680343f, 0.25568646f, 0.56318259f, 0.05048653f, 0.17278750f, 
    -0.02380374f, 0.00190392f, 0.11437637f, -0.12317554f, 0.07614887f, 0.14404862f, -0.10235898f, 0.30056602f, 
    0.13862462f, 0.29350224f, 0.20811392f, -0.64395148f, -0.03249650f, 0.16336508f, -0.08241645f, 0.15608813f, 
    -0.25779665f, 0.09387757f, 0.36563188f, -0.09817336f, -0.01883043f, -0.07930905f, 0.09699363f, -0.08687291f, 
    -0.16015364f, -0.03918262f, 0.03967259f, 0.09277363f, -0.04270484f, -0.09058642f, 0.23177356f, 0.17819421f, 
    -0.00933172f, -0.04664638f, -0.21728839f, 0.22432008f, 0.13440756f, 0.28980306f, 0.06926552f, 0.12497602f, 
    -0.18349341f, -0.19059476f, -0.04831868f, 0.08847319f, 0.42352024f, 0.12950507f, -0.12778085f, 0.29146788f, 
    -0.05210638f, -0.06902264f, -0.22860202f, -0.00657234f, -0.07101879f, 0.14125586f, -0.01703086f, 0.11264025f, 
    -0.02211409f, 0.13798732f, -0.07922731f, 0.18536092f, -0.09444450f, -0.15636425f, -0.08955037f, 0.08485306f, 
    -0.04420492f, 0.00568483f, -0.03639965f, 0.05972784f, 0.52753270f, -0.05086960f, -0.01694206f, -0.26349729f, 
    0.27264446f, 0.02860384f, 0.07450045f, 0.28704846f, -0.02996888f, 0.13800001f, 0.08130302f, -0.13874225f, 
    -0.07560544f, 0.08762239f, -0.12688197f, 0.14714977f, -0.07274818f, -0.14611301f, 0.02550470f, -0.06950942f, 
    0.22640547f, 0.16220053f, 0.17238067f, 0.09813794f, 0.51239949f, -0.00109920f, -0.10551780f, 0.08714773f, 
    0.11261272f, 0.14803094f, 0.01694790f, 0.15331563f, -0.04327803f, -0.04252740f, -0.26664180f, -0.09086261f, 
    -0.28412637f, 0.33320573f, -0.30570462f, -0.20901835f, 0.07124799f, 0.00389126f, 0.10105591f, -0.01846410f, 
    0.07582369f, 0.31729662f, -0.13760476f, 0.03811609f, 0.05060291f, 0.19229443f, 0.15232135f, -0.21838725f, 
    -0.16670461f, -0.11307780f, -0.10516129f, -0.12858985f, 0.06674513f, 0.14904687f, -0.01161951f, -0.02821238f, 
    -0.55595732f, -0.40012255f, 0.34687591f, 0.13365164f, -0.05779523f, -0.29539174f, 0.08267643f, -0.08206534f, 
    -0.05321396f, 0.07532459f, -0.04723005f, 0.13159356f, 0.47685713f, 0.01842137f, -0.10697711f, -0.15090422f, 
    0.11855768f, 0.02463999f, 0.40238303f, 0.12687397f, 0.04603790f, -0.06369430f, 0.00737242f, 0.17960675f, 
    -0.01686413f, 0.35988414f, 0.13365149f, -0.44605559f, 0.03489101f, 0.09045934f, 0.05523730f, 0.10070796f, 
    0.02000396f, 0.16806571f, 0.01487891f, 0.06341890f, -0.02011973f, -0.20843518f, -0.18854804f, 0.18663132f, 
    0.12115618f, 0.23892906f, 0.19590963f, 0.12059636f, -0.05998065f, 0.05333735f, -0.06756290f, 0.06531043f, 
    -0.48802692f, 0.13824579f, -0.21664749f, 0.15599802f, 0.13375860f, 0.11573709f, -0.00399459f, 0.04759328f, 
    -0.17858098f, 0.06442808f, -0.01000804f, -0.12019692f, -0.28882062f, 0.14555354f, -0.05268186f, 0.03481735f, 
    -0.00955854f, 0.01824475f, -0.08438224f, -0.05866311f, -0.23308675f, 0.04224681f, 0.02150343f, 0.03920845f, 
    -0.07666995f, 0.05390976f, -0.04225179f, 0.06167882f, 0.21977527f, -0.01921874f, -0.08817442f, 0.00567876f, 
    0.20473407f, -0.18612316f, -0.00948395f, 0.09998597f, 0.09557757f, 0.16266620f, 0.04453105f, -0.03366513f, 
    0.16933060f, 0.08177081f, -0.03147809f, -0.20424245f, 0.12214813f, 0.00324370f, -0.12633650f, -0.08280468f, 
    0.17541437f, 0.09552215f, 0.04795300f, 0.18515606f, 0.14961229f, -0.23326667f, 0.14779249f, 0.18196666f, 
    0.05206920f, 0.08565067f, 0.00166986f, 0.05041281f, -0.27475882f, 0.14371489f, 0.27589929f, -0.16341016f, 
    0.08464721f, 0.03278492f, -0.20507182f, 0.08966343f, -0.08080643f, -0.07570706f, -0.06847427f, 0.27241874f, 
    -0.30807954f, -0.21533506f, -0.24271451f, 0.01700611f, 0.00759193f, -0.02130023f, -0.00912073f, 0.06013253f, 
    0.09980044f, -0.04923379f, 0.20149668f, 0.04874441f, 0.28091478f, 0.06651363f, 0.08896724f, 0.00294060f, 
    0.25065932f, -0.08092416f, 0.09951111f, -0.37109697f, 0.08072960f, -0.20499842f, 0.01627407f, 0.07535121f, 
    -0.09807795f, -0.17892948f, 0.09624619f, -0.04098190f, 0.05341440f, 0.06006928f, -0.00540600f, 0.09233654f, 
    0.12575281f, 0.15670322f, 0.26807162f, 0.28827679f, 0.29862285f, -0.15212810f, 0.30171928f, -0.14333448f, 
    0.17053470f, -0.09454873f, 0.01276067f, -0.07548903f, 0.08938897f, 0.08402616f, 0.32607755f, 0.24083608f, 
    -0.31124589f, -0.60223842f, 0.26450771f, -0.15153173f, -0.06289418f, 0.12659031f, 0.08893235f, -0.13302828f, 
    -0.18506631f, 0.00864211f, -0.01485619f, -0.11969138f, -0.08016369f, -0.40062916f, -0.14205641f, 0.08905289f, 
    0.04951739f, 0.03837302f, 0.08931956f, -0.19186215f, 0.00805910f, 0.23974144f, -0.01556643f, 0.12738267f, 
    0.50206345f, 0.03815251f, 0.17031041f, 0.32054409f, -0.02520167f, -0.04903997f, -0.01699340f, 0.21548514f, 
    -0.02229714f, 0.02166820f, -0.11440796f, -0.15163720f, -0.31691056f, 0.01366821f, -0.46981421f, 0.10231584f, 
    -0.00724363f, -0.02592076f, -0.16905284f, -0.05501509f, 0.02146175f, -0.07251487f, 0.05153659f, 0.16399963f, 
    -0.43523455f, 0.21110812f, 0.10636870f, 0.07553827f, 0.14354205f, 0.01586144f, -0.12529600f, 0.01364807f, 
    -0.17444758f, 0.06079563f, 0.04501354f, 0.02528918f, 0.13024977f, 0.14962675f, 0.00114199f, 0.14460585f, 
    -0.08775703f, 0.06930825f, -0.12274074f, 0.25227025f, 0.03835146f, 0.00244839f, 0.09015186f, -0.10359144f, 
    0.07936988f, 0.06157748f, 0.07971326f, 0.03828279f, 0.13809194f, 0.10951154f, 0.11448127f, -0.07795697f, 
    0.09358432f, 0.05296864f, 0.13270947f, 0.13575782f, 0.16259073f, -0.20282188f, -0.12749898f, 0.44420958f, 
    -0.13844301f, -0.02788449f, 0.16999538f, -0.16521487f, 0.06031315f, -0.06400289f, 0.11774164f, 0.13044672f, 
    -0.32535282f, -0.65479386f, -0.20109911f, 0.29323548f, 0.15133664f, -0.03297688f, 0.06149729f, -0.04149749f, 
    0.06952131f, 0.01593504f, 0.11949006f, -0.09338943f, -0.19006447f, -0.06441279f, -0.14796084f, -0.06468866f, 
    0.15341735f, 0.11778995f, -0.10482679f, -0.08512080f, -0.04917085f, 0.04372248f, 0.16014613f, 0.11179315f, 
    0.34523296f, 0.14879753f, -0.09378653f, -0.19385751f, 0.10190763f, 0.11184054f, 0.01663524f, -0.02295559f, 
    0.09544974f, 0.00919387f, -0.11380479f, 0.07360513f, -0.27705622f, 0.04387981f, 0.22345182f, 0.48249283f, 
    -0.01799720f, 0.22401963f, -0.17674971f, 0.16313379f, -0.13394755f, 0.04178192f, 0.09173113f, 0.38593444f, 
    -0.10362008f, 0.05104809f, 0.20895717f, 0.15911041f, -0.02501865f, 0.02437247f, -0.14542475f, -0.03546872f, 
    -0.20642631f, -0.08725288f, 0.00994752f, 0.04451144f, -0.07305229f, -0.04877486f, 0.22290206f, -0.04236427f, 
    0.13546383f, 0.31210020f, 0.26523662f, -0.20182149f, 0.21424007f, 0.09346404f, -0.02384820f, -0.08880930f, 
    -0.10310475f, -0.05826668f, 0.03659322f, -0.06720896f, -0.08820723f, 0.12308422f, -0.13705856f, 0.00432368f, 
    -0.08583588f, -0.08791708f, -0.07807518f, -0.28493062f, 0.14720120f, 0.18853053f, 0.00350720f, -0.37946469f, 
    -0.00327300f, -0.01936573f, -0.15040299f, -0.00525393f, 0.06153305f, -0.07930073f, 0.02926673f, 0.01171571f, 
    0.18610591f, -0.21683909f, -0.03515131f, 0.18795452f, -0.17096113f, 0.17525889f, -0.09142783f, -0.11477900f, 
    -0.04274188f, 0.03395944f, 0.07002480f, 0.16796052f, -0.02330211f, 0.00431158f, 0.25335336f, 0.00299829f, 
    0.08292872f, -0.16016831f, -0.10300220f, 0.17200419f, -0.09784739f, 0.06869585f, 0.03065549f, 0.00576729f, 
    0.07377404f, 0.24250428f, -0.12301912f, -0.26458859f, 0.08718842f, 0.13131984f, -0.28050068f, -0.10239609f, 
    -0.12492653f, 0.06858855f, -0.06662419f, 0.11180565f, 0.00027822f, 0.29986191f, -0.54571581f, -0.14606141f, 
    -0.06905176f, 0.09214641f, 0.21557464f, 0.28577262f, 0.22838353f, -0.09103700f, 0.03309222f, -0.02669633f, 
    -0.09061808f, -0.17920887f, -0.19777600f, 0.17191577f, -0.02854643f, -0.12020452f, 0.22959493f, 0.16691731f, 
    0.44595283f, -0.12371425f, 0.30201149f, 0.10350291f, 0.20505445f, 0.14906086f, -0.12450317f, -0.33940214f, 
    0.20757787f, 0.34117472f, 0.30663937f, 0.18711491f, -0.03057115f, -0.03987404f, 0.01505107f, 0.06565647f, 
    0.03958849f, -0.02107305f, -0.02288735f, -0.05076128f, -0.02524686f, 0.00418184f, -0.06978452f, -0.02421579f, 
    -0.03118495f, 0.00964059f, -0.05368832f, -0.06414130f, 0.06503579f, -0.00150920f, -0.03353591f, 0.00180221f, 
    0.03297087f, -0.06748801f, -0.01646764f, -0.04770644f, 0.00261282f, -0.02594472f, -0.04211342f, -0.00185880f, 
    0.00014966f, 0.01582523f, 0.00725815f, -0.03770344f, -0.03965132f, 0.01901767f, -0.07658722f, -0.05228740f, 
    0.04507090f, -0.05282137f, -0.05045839f, -0.00380353f, -0.00523210f, -0.05205559f, 0.01494821f, 0.03253969f, 
    -0.03067513f, 0.04615811f, -0.01115405f, -0.04445829f, 0.00584367f, 0.01119866f, -0.06155371f, -0.05224479f, 
    0.05348108f, -0.02948491f, 0.02180594f, 0.02534704f, 0.05608569f, 0.00023298f, 0.01058731f, -0.03557180f, 
    -0.02888788f, 0.05487349f, -0.01682059f, 0.00599805f, 0.00492831f, -0.01240481f, -0.02697525f, -0.03801475f, 
    0.01958178f, 0.02887251f, -0.06271330f, 0.00319692f, -0.07817148f, -0.06252345f, 0.04679392f, 0.03791661f, 
    -0.06538112f, -0.00265460f, -0.02834572f, -0.00675576f, -0.01302734f, 0.05154356f, -0.04092332f, -0.03398818f, 
    -0.05630219f, -0.06119196f, 0.03307263f, 0.01382748f, 0.01776194f, 0.05046060f, -0.03571762f, -0.01157114f, 
    -0.01298208f, -0.01767988f, 0.01793242f, -0.07086659f, -0.07953645f, 0.05995049f, 0.02939813f, 0.04897929f, 
    0.05932947f, -0.00473655f, -0.02554511f, 0.05444525f, 0.01490045f, 0.04731888f, -0.01367197f, -0.04737951f, 
    0.03633279f, -0.01475459f, 0.00782757f, -0.05158135f, 0.00068567f, -0.05350144f, 0.05616556f, -0.03384736f, 
    0.05627672f, -0.03499249f, 0.00456314f, -0.03571644f, -0.07686922f, 0.04695217f, -0.02345260f, -0.03895279f, 
    0.02164071f, 0.00320742f, 0.00650499f, 0.04830729f, -0.01005546f, -0.05777062f, -0.06777256f, -0.01846928f, 
    0.05744443f, -0.03047845f, -0.05153749f, -0.00997885f, -0.00909742f, 0.04246901f, -0.02137801f, 0.03544889f, 
    0.00324567f, -0.03037417f, 0.03510328f, -0.05780140f, -0.06389791f, 0.02303719f, -0.03519395f, -0.01190134f, 
    -0.04867067f, -0.00789995f, 0.06201190f, 0.04942143f, -0.01388989f, -0.04511167f, -0.00740581f, -0.03640940f, 
    0.02514915f, 0.03790406f, 0.01317483f, -0.04734372f, -0.02766365f, 0.01611086f, 0.02767668f, 0.00919491f, 
    -0.02519228f, -0.02809201f, -0.00277985f, -0.05509472f, 0.00415980f, 0.00872853f, -0.07782652f, 0.01705706f, 
    -0.04356182f, -0.06948964f, -0.08067128f, 0.02898689f, 0.03916785f, 0.04564680f, -0.08089935f, -0.03382177f, 
    -0.03176957f, -0.08237877f, -0.05966578f, -0.03463480f, -0.05266628f, -0.00360606f, 0.05832312f, -0.04756185f, 
    0.05593346f, 0.00531016f, -0.06589866f, 0.02107282f, 0.01578989f, -0.02739481f, -0.06033780f, 0.05203982f, 
    -0.06548722f, -0.02812128f, -0.01747107f, -0.01529422f, 0.00123525f, -0.07306349f, -0.07979587f, -0.00387673f, 
    -0.03190677f, 0.03082824f, -0.04669430f, 0.02249126f, 0.03162995f, -0.00639465f, 0.00278743f, -0.06065152f, 
    0.00827791f, -0.02645949f, 0.04278648f, -0.06536910f, 0.00722720f, 0.03253961f, -0.05662774f, -0.02560396f, 
    -0.01615950f, -0.00353843f, 0.00833943f, 0.05868109f, -0.00580436f, 0.00037603f, -0.00419867f, 0.03602559f, 
    0.02574262f, 0.02672218f, -0.05611210f, 0.01246230f, 0.05854379f, -0.04942251f, -0.04133136f, -0.02068992f, 
    -0.05247861f, -0.04254575f, 0.06502065f, 0.05076584f, 0.05714463f, 0.01303181f, 0.02331340f, -0.05495884f, 
    -0.05780610f, -0.00603155f, 0.00726859f, -0.06568756f, -0.04997489f, 0.04390520f, 0.04153631f, -0.06290736f, 
    0.01572740f, -0.03522598f, 0.04787898f, 0.00047353f, 0.04624245f, 0.01982377f, 0.03037238f, -0.05905784f, 
    -0.04671253f, -0.07441452f, -0.00565844f, -0.05838089f, 0.04142038f, -0.02499240f, -0.05840351f, -0.01512497f, 
    -0.01048206f, -0.04671628f, -0.01715960f, -0.02583626f, 0.00274948f, 0.05044324f, -0.04218730f, -0.02865907f, 
    0.01223628f, 0.02616410f, 0.02020451f, 0.03106538f, 0.06034147f, 0.00077485f, -0.06129961f, 0.05567668f, 
    -0.05345733f, 0.05889542f, -0.04706899f, 0.06011249f, 0.04791696f, -0.01747591f, 0.03023459f, 0.01136721f, 
    0.02735750f, -0.04453559f, 0.02277908f, -0.06206034f, -0.05611129f, -0.05922534f, -0.06689133f, -0.04554240f, 
    -0.07322742f, 0.04274343f, -0.00867916f, -0.01321966f, 0.00469201f, 0.05169167f, 0.00635485f, -0.02080006f, 
    0.01581401f, -0.04610635f, -0.08733802f, 0.04213046f, -0.08306344f, -0.05668817f, 0.05404232f, 0.01378465f, 
    -0.02982375f, 0.03821455f, 0.03055112f, -0.01373328f, 0.03375186f, -0.04564435f, 0.02356497f, -0.02376021f, 
    -0.05040928f, -0.04110615f, 0.05857693f, -0.02169136f, 0.03418708f, 0.01817632f, 0.05337104f, -0.05182258f, 
    0.05493108f, -0.02436924f, -0.02324462f, 0.02910117f, 0.05432710f, -0.02131246f, -0.06101083f, -0.03015877f, 
    -0.01153609f, -0.08510756f, -0.01980244f, 0.04228837f, -0.05106985f, 0.06017797f, -0.00391374f, 0.04150120f, 
    -0.07635607f, -0.03408327f, -0.08107778f, -0.06027753f, -0.05986918f, 0.06749021f, -0.04527003f, -0.04667648f, 
    0.01042165f, 0.00129568f, -0.00881048f, 0.02099215f, -0.01707662f, -0.02400964f, -0.03923914f, -0.05941721f, 
    0.02386703f, -0.01727122f, -0.03789433f, -0.01301085f, 0.02650545f, -0.05785653f, 0.04263880f, -0.01438086f, 
    0.04428040f, -0.06214577f, -0.07537443f, -0.02171017f, 0.00150345f, -0.03327538f, -0.05663182f, -0.01844239f, 
    -0.05175168f, 0.00191787f, 0.01912431f, 0.05962393f, 0.00455606f, 0.03390782f, -0.05536361f, 0.00573302f, 
    0.10814632f, 0.23828398f, 0.44635862f, 0.09414449f, -0.08984598f, -0.05840211f, 0.10857442f, 0.21233296f, 
    -0.07716376f, 0.02123425f, -0.03356120f, 0.24549291f, 0.01065953f, -0.04759378f, 0.14052433f, 0.27168575f, 
    -0.00406373f, 0.01434837f, 0.07768416f, 0.05914453f, 0.07571255f, 0.10367164f, 0.00902630f, 0.14716080f, 
    -0.37590969f, 0.37354076f, 0.54291594f, 0.09906516f, 0.09296802f, 0.06621088f, 0.15187116f, 0.01641639f, 
    0.11567821f, -0.00618048f, 0.01338346f, -0.05198338f, -0.15138501f, 0.15893863f, 0.06448838f, -0.05112543f, 
    0.07806545f, 0.07747109f, -0.00257069f, 0.02949112f, 0.02596811f, 0.02572210f, 0.08048321f, 0.11745160f, 
    0.29801896f, 0.17111416f, -0.13401444f, -0.42189616f, 0.29759717f, 0.01732262f, -0.01703850f, 0.07286769f, 
    -0.13851230f, -0.10977389f, -0.09698786f, 0.06615437f, -0.68947905f, -0.22569205f, 0.24145092f, 0.00626654f, 
    -0.00036284f, 0.00657348f, -0.01300502f, 0.06641465f, -0.04358567f, -0.15637465f, -0.00009814f, 0.07732079f, 
    -0.43063205f, -0.31148449f, -0.05589208f, -0.14925578f, 0.02015057f, 0.01107326f, 0.05893314f, 0.01731106f, 
    -0.03243069f, 0.01618009f, -0.04199088f, 0.09567375f, 0.09447482f, 0.30600616f, 0.29179436f, 0.01244065f, 
    0.05500021f, 0.26445818f, 0.12117131f, -0.20967148f, -0.06556416f, 0.20761314f, 0.00998730f, -0.11038921f, 
    -0.20673993f, -0.19246267f, -0.03257169f, -0.00697398f, 0.09520099f, -0.01585428f, 0.01842690f, 0.02421595f, 
    -0.10073290f, 0.18203601f, -0.23165113f, -0.19755204f, 0.21228397f, 0.21826996f, 0.08721320f, -0.18534011f, 
    0.17710771f, 0.15406194f, -0.02888712f, 0.01238230f, 0.00285908f, 0.06679900f, 0.06122377f, -0.06645034f, 
    -0.18720412f, 0.18273650f, -0.58774227f, 0.09230196f, -0.05351393f, -0.11445893f, 0.04509835f, 0.25234655f, 
    -0.01770682f, 0.13880794f, -0.04214911f, -0.06007987f, -0.29667914f, -0.12073001f, -0.10895439f, 0.01858206f, 
    0.01063666f, 0.07968887f, 0.01929046f, 0.07590035f, 0.05856042f, -0.09459147f, 0.10028663f, -0.03348666f, 
    -0.09985220f, -0.28427690f, -0.23731981f, -0.10958314f, 0.04227594f, -0.02155071f, 0.19051021f, -0.06193659f, 
    -0.03206237f, 0.06446408f, -0.01512770f, 0.01229269f, 0.13876182f, 0.46873465f, -0.07831489f, -0.20070943f, 
    -0.08052098f, 0.18514715f, 0.16771939f, 0.03015994f, -0.14366369f, -0.01942442f, 0.03317069f, -0.01547719f, 
    -0.08346225f, -0.00286219f, 0.41682097f, 0.00415046f, 0.00923098f, -0.05620543f, 0.08805807f, -0.19476053f, 
    0.01752038f, 0.01441480f, 0.03640620f, 0.09927029f, 0.33444831f, 0.09264530f, -0.42389134f, -0.36576530f, 
    0.06309511f, 0.21458676f, 0.17554744f, 0.13082044f, 0.03352747f, 0.06170892f, 0.07792516f, 0.06417562f, 
    -0.06593655f, 0.02797431f, -0.03352317f, 0.03328124f, 0.02465640f, 0.02416671f, -0.08933600f, 0.00974053f, 
    -0.04350318f, 0.02822394f, 0.06143628f, -0.06405108f, -0.03380803f, 0.02880277f, -0.07408156f, -0.00900930f, 
    -0.05509025f, 0.04195638f, -0.01461686f, -0.04347958f, 0.01996283f, 0.03964965f, 0.01599141f, -0.00071371f, 
    0.05793326f, -0.00113880f, 0.03284116f, -0.02265131f, -0.05503508f, -0.04751614f, -0.02343496f, 0.05797188f, 
    -0.05298570f, -0.01596720f, 0.01925248f, 0.07521357f, 0.04554628f, 0.03912323f, -0.03478720f, -0.07492448f, 
    0.04385035f, -0.05410765f, -0.07295834f, 0.05155317f, -0.05894326f, -0.04245686f, 0.03930820f, 0.01761791f, 
    -0.04498131f, 0.05890197f, -0.00643332f, 0.01175163f, 0.00190965f, -0.03351842f, -0.04882845f, -0.01865128f, 
    -0.01495971f, -0.07061996f, 0.01680958f, 0.02616059f, 0.01124518f, -0.06658142f, -0.03132132f, 0.03149948f, 
    -0.05495763f, -0.06567989f, -0.07624891f, 0.02061874f, -0.03663464f, -0.01568999f, -0.01631286f, -0.05487365f, 
    0.06104838f, 0.05080245f, -0.00308708f, 0.04708884f, -0.02844994f, -0.07513434f, 0.02784298f, -0.06064375f, 
    0.03076974f, -0.06183645f, -0.04497906f, 0.01516817f, 0.06406505f, 0.03839695f, -0.07346720f, -0.06412488f, 
    0.00267697f, -0.02040811f, -0.00295457f, 0.01563118f, -0.03799932f, -0.04198427f, 0.04578936f, -0.01857761f, 
    0.03480321f, 0.00089382f, -0.00115695f, -0.05096021f, 0.04577480f, -0.02202510f, -0.04934178f, 0.01254825f, 
    -0.04889667f, 0.06849857f, -0.00815362f, -0.04926490f, -0.02494161f, 0.04411799f, -0.06343162f, -0.05483137f, 
    -0.03554795f, -0.02034745f, 0.07104125f, 0.00154210f, -0.06502067f, -0.05059386f, -0.05246298f, -0.04772694f, 
    -0.07387095f, 0.02850571f, 0.00375128f, 0.00836563f, 0.05667987f, 0.05437090f, 0.02583856f, -0.07273301f, 
    -0.02432772f, 0.00796134f, -0.04546443f, -0.08119857f, 0.02145618f, -0.02964440f, -0.01055199f, -0.05574267f, 
    0.04338056f, -0.06766411f, 0.05378744f, -0.05647494f, -0.05853587f, -0.01670454f, 0.02465796f, -0.04841467f, 
    0.04787922f, -0.03234659f, 0.01269811f, 0.02268306f, -0.04750313f, 0.00428164f, -0.06967823f, -0.05672638f, 
    0.04773625f, -0.07956592f, -0.04414475f, -0.06699500f, 0.02823713f, -0.05049026f, 0.03426016f, -0.00157225f, 
    0.04904209f, 0.04607831f, -0.01611866f, 0.03100281f, 0.03802810f, -0.00365938f, 0.03683159f, 0.06742120f, 
    -0.01526835f, -0.05579819f, 0.03353876f, -0.07912455f, -0.05691146f, -0.01450596f, -0.04338307f, -0.06452955f, 
    -0.04629129f, 0.03558975f, -0.03369158f, -0.00362463f, -0.00142189f, -0.03208049f, -0.01742375f, -0.06702739f, 
    -0.02924333f, 0.05926009f, -0.05598467f, 0.04488094f, -0.04521111f, -0.04019066f, -0.00467377f, -0.05952981f, 
    -0.05016234f, -0.04355232f, 0.03447763f, -0.02826504f, -0.04843087f, -0.02719135f, 0.04206586f, 0.01260443f, 
    -0.05062312f, 0.02852057f, -0.00676151f, -0.00117255f, -0.01512958f, 0.04107211f, 0.02038429f, -0.02303924f, 
    0.03393436f, -0.06689418f, 0.05036434f, -0.06030098f, 0.00391901f, -0.07032610f, 0.02345277f, -0.01448461f, 
    -0.03549905f, -0.04178871f, -0.00167846f, 0.05179252f, 0.06277417f, 0.04069141f, -0.00227350f, -0.00683264f, 
    -0.06281045f, -0.01563077f, 0.05093814f, -0.03392228f, 0.01457828f, 0.04936922f, -0.05026294f, 0.01194509f, 
    -0.01155263f, 0.02767182f, -0.06951512f, 0.04985348f, -0.03921944f, -0.06163137f, -0.03492424f, -0.00431449f, 
    0.01144067f, -0.06028034f, 0.05798382f, -0.01256173f, -0.00863477f, -0.04933179f, -0.02793642f, 0.02561527f, 
    -0.02555626f, -0.04674381f, 0.02629332f, -0.04540076f, -0.03903421f, 0.00069087f, -0.03577549f, -0.04806510f, 
    0.01018713f, 0.01172456f, 0.00245280f, -0.04181213f, 0.03756220f, 0.00069320f, -0.03691187f, 0.00684205f, 
    -0.04043758f, 0.03116193f, -0.03459211f, 0.02737496f, 0.03752745f, -0.03185851f, -0.06332964f, -0.02939169f, 
    0.01223859f, 0.02581460f, -0.01301796f, 0.05837342f, -0.07630258f, -0.05936158f, -0.01353436f, -0.07125858f, 
    0.00468695f, -0.07880746f, -0.06016522f, -0.03489441f, 0.03418875f, 0.02291090f, -0.03962858f, 0.04798429f, 
    -0.02408417f, -0.05022712f, 0.01853021f, -0.02280407f, -0.00192624f, -0.05480038f, -0.04322045f, 0.04012166f, 
    0.01025370f, -0.03590755f, -0.02931101f, 0.03826911f, -0.01969938f, -0.04921676f, -0.01560924f, 0.05686031f, 
    -0.01403615f, -0.07835314f, -0.04614305f, -0.02822598f, 0.01306789f, -0.03509895f, -0.06296336f, 0.03277500f, 
    -0.03104571f, -0.05553397f, -0.07492101f, -0.07882620f, 0.03886030f, -0.02418530f, -0.00544271f, -0.06494414f, 
    0.00115778f, 0.04672315f, -0.01610200f, -0.00872821f, -0.02862971f, -0.00290759f, -0.01447269f, -0.02196191f, 
    0.00275370f, 0.00612766f, 0.02519654f, 0.04320213f, 0.05809909f, 0.01843315f, -0.05565708f, -0.00330867f, 
    -0.07133655f, 0.03312103f, -0.04758712f, -0.01744798f, -0.05667800f, 0.03573082f, 0.01919396f, -0.06111743f, 
    -0.01940882f, 0.05877081f, -0.02828849f, 0.03418279f, -0.07775921f, -0.01731523f, 0.00155099f, -0.03932504f, 
    0.05900669f, -0.07930192f, 0.01627062f, -0.00340986f, -0.06818011f, -0.02602569f, 0.00088887f, 0.02857944f, 
    -0.05336700f, -0.07934985f, -0.04027222f, -0.03920006f, 0.00978963f, -0.02671851f, 0.01851624f, 0.06155125f, 
    -0.02103513f, -0.06670912f, 0.01079327f, -0.00918728f, -0.04403190f, -0.00025047f, 0.00902289f, -0.03468576f, 
    -0.03180150f, -0.07419046f, 0.04124423f, 0.03927540f, -0.00387788f, 0.02275555f, 0.03720843f, -0.06024244f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.13848002f, -0.01437758f, 0.06322626f, 0.30731553f, 0.05157721f, -0.05813764f, 0.18817982f, 0.17656881f, 
    0.08969229f, 0.04431813f, 0.10213237f, 0.03559473f, 0.17547657f, 0.20829400f, -0.20451482f, 0.00065969f, 
    0.03803734f, -0.01412555f, 0.17071177f, 0.18083675f, -0.03663320f, 0.35820019f, -0.26112857f, -0.06266961f, 
    0.09072460f, 0.09332346f, 0.11986552f, -0.07103969f, 0.03581247f, -0.06447813f, 0.01567699f, -0.04841471f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.17776249f, -0.11557055f, -0.16407618f, -0.83968443f, 0.09181287f, -0.08882021f, -0.18835080f, -0.78785354f, 
    0.17984831f, 0.10037312f, -0.25328350f, -0.29410014f, -0.05148471f, -0.16197942f, 0.29998952f, -0.17856401f, 
    0.09262777f, 0.02611583f, -0.44775769f, -0.73401690f, -0.02228533f, -0.62910944f, 0.32651982f, 0.08275423f, 
    0.03158181f, -0.03785668f, 0.30676883f, 0.06679393f, -0.12303799f, 0.44523233f, 0.08232805f, -0.13103634f, 
    -0.12157257f, -0.02171850f, -0.25499010f, -0.10177238f, 0.02503090f, 0.15825756f, -0.50705689f, 0.10377126f, 
    0.50850177f, 0.00665623f, 0.16230248f, 0.54720116f, 0.34923297f, -0.43552765f, 0.49438897f, -0.34398648f, 
    0.29140833f, -0.07584967f, -0.16928044f, -0.11835948f, 0.07967459f, 0.15568940f, -1.21945715f, -0.76521367f, 
    0.15439785f, -0.16018216f, 0.14145878f, -0.13078657f, 0.10008321f, -0.01292344f, -0.11717919f, -0.00572764f, 
    0.03165608f, 0.09156000f, 0.02418143f, 0.28140023f, -0.04298441f, 0.09607437f, -0.11093767f, 0.58711690f, 
    0.31591809f, -0.05143326f, -0.06487311f, -0.92409712f, -0.08372919f, -0.61404657f, -1.03674006f, 0.02602862f, 
    -0.22512136f, 0.02220361f, -0.50877267f, 0.05693812f, 0.06973776f, 0.18612249f, -0.64281088f, 0.59188968f, 
    -0.02979968f, -0.35424203f, 0.06448015f, 0.11263865f, -0.00732924f, 0.09686787f, -0.09065314f, 0.06973550f, 
    0.35697338f, -0.09777261f, -0.16438711f, -0.35896227f, 0.10204764f, 0.03670538f, -0.02565596f, 0.59740287f, 
    -0.43694574f, 0.12862821f, -0.11645082f, -0.51248330f, -0.67450339f, -0.30768704f, -0.07031093f, -0.36025295f, 
    -0.06442672f, 0.12627032f, 0.34944224f, 0.33986589f, -0.03643964f, -0.72645396f, -0.16291715f, 0.12829772f, 
    0.44171706f, 0.40955952f, -0.22903048f, -0.14374647f, 0.05106056f, -0.01149336f, -0.14351259f, 0.13421708f, 
    0.14601339f, 0.01969099f, 0.20841363f, -0.19655061f, 0.13696362f, -0.16199441f, -0.24809046f, 0.11364284f, 
    0.06223393f, 0.08575757f, 0.22918691f, -0.50997323f, 0.17253299f, -0.04622067f, 0.00284074f, 0.32384703f, 
    0.22446387f, 0.00165027f, -0.28314993f, -0.24032068f, -0.13751009f, -0.27894586f, 0.59626549f, -0.05162593f, 
    -0.44403312f, -0.10793265f, -0.27802664f, 0.14270088f, -0.04847525f, -0.23958081f, -0.15410402f, -0.00938463f, 
    0.37344137f, -0.10049332f, 0.44345638f, 0.23129556f, -0.16712767f, 0.15914105f, 0.07815619f, -1.01731694f, 
    -0.55264091f, -0.17221624f, 0.05838210f, -0.19871786f, 0.38401943f, 0.43218592f, -0.22670995f, -0.27437642f, 
    -0.06756938f, -0.00193559f, 0.00262293f, -0.11910461f, 0.01115489f, -0.07887899f, -0.43243033f, -0.43333530f, 
    -0.08940116f, -0.21293734f, 0.30288622f, -0.01572881f, 0.16093619f, -0.07036334f, 0.02796105f, 0.16336107f, 
    -0.92324990f, -0.14477539f, -0.34420308f, 0.54907542f, 0.11143124f, 0.16108234f, 0.25079653f, 0.31303325f, 
    -0.57944816f, 0.13515854f, 0.04744932f, 0.38121495f, -0.30123973f, -0.08407864f, -0.35650307f, 0.27316445f, 
    -0.99594700f, 0.02729347f, -0.06897711f, -0.32318506f, -0.01109789f, 0.39686552f, -0.30439681f, 0.16925977f, 
    -0.17918739f, -0.71488118f, -0.43794543f, 0.04605038f, -0.06717206f, 0.00893448f, -0.07381234f, -0.03265639f, 
    -0.47988072f, -0.10730590f, -0.20208336f, -0.62771386f, -0.12520692f, -0.07231781f, 0.31282789f, -0.86781377f, 
    -0.00539844f, -0.06290985f, 0.43815899f, 0.14047676f, -0.08671655f, -0.45361087f, 0.06228298f, -0.14226070f, 
    -0.56720912f, 0.15641640f, -0.00158231f, 0.25941828f, -0.17013694f, -0.18160816f, 0.13749342f, 0.45476288f, 
    0.48235339f, -0.39887166f, -0.17077853f, 0.00074201f, 0.05441886f, -0.74752629f, 0.11104400f, 0.01126500f, 
    -0.30269703f, 0.08955010f, -1.33451617f, -0.49385130f, 0.03364863f, -0.06178593f, 0.68981677f, 0.01984332f, 
    0.00272777f, 0.16472572f, 0.35353893f, -0.34154400f, -0.31569958f, 0.52530050f, -0.42852470f, -0.60397941f, 
    -0.50463235f, 0.09510151f, 0.38670468f, 0.18664692f, -0.04274560f, 0.10317135f, -0.69754231f, -0.70555842f, 
    0.09634434f, -0.47467095f, 0.24371500f, -0.04200225f, -0.11959704f, 0.06998583f, 0.02483917f, -0.01466460f, 
    -0.37037298f, 0.05659390f, 0.26596817f, -0.10184889f, 0.14361857f, -0.08890173f, 0.04419323f, -0.55139291f, 
    0.12857397f, 0.10037449f, -0.20614029f, 0.44636410f, -0.10013970f, -0.45780730f, -0.46843353f, 0.16051467f, 
    0.14141333f, 0.11744796f, -0.38300803f, 0.54630190f, -0.05075442f, 0.27333888f, 0.29563519f, 0.36522588f, 
    -0.71595389f, 0.39887384f, -0.20939001f, 0.12570569f, -0.11518215f, -0.02312389f, 0.10465135f, -0.09989236f, 
    -0.54258120f, -0.10025837f, 0.47494859f, 0.14093037f, -0.15476012f, 0.06470571f, 0.44479114f, 0.54426861f, 
    0.20286779f, -0.05220142f, -0.51602763f, -0.58192462f, -0.40976733f, 0.29510161f, 0.40703398f, 0.00214298f, 
    0.01186342f, -0.11402367f, 0.02140282f, 0.15803780f, -0.02814520f, -0.18421514f, -0.91029257f, -0.80897337f, 
    0.28388518f, -0.49391890f, -0.27191955f, 0.00467268f, -0.14145714f, 0.12650070f, 0.00189723f, -0.14397626f, 
    -0.26701325f, -0.03386278f, -0.23021832f, -0.01523549f, -0.06370850f, 0.03138685f, -0.94113463f, 0.62233347f, 
    0.16841391f, -0.00911963f, 0.02338814f, 0.01500977f, -0.29268664f, 0.37981242f, -0.70751262f, -0.07507841f, 
    -0.31178421f, 0.11810344f, 0.43579397f, -0.86880493f, -0.01397743f, 0.20755897f, -0.30150315f, -0.05918030f, 
    -0.61324370f, 0.38998038f, 0.39140600f, -0.05386592f, -0.11982260f, -0.33555850f, -0.16809443f, -0.09347003f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.12186224f, 0.00233737f, 0.22005117f, 0.13472272f, -0.06205540f, 0.09709216f, -0.21087818f, -0.07515502f, 
    0.14733875f, -0.11947674f, -0.09672989f, -0.02316877f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
