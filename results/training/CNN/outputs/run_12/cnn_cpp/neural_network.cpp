#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.05537534f, 1.04418778f, 0.51434904f, -0.79651344f, -0.68224263f, 0.17580226f, 0.27781284f, 0.03776272f, 
    -0.23251761f, -0.81233877f, -0.84318942f, -0.42036337f, -0.43323743f, 0.18431917f, -0.56799871f, 0.43539268f, 
    -0.01149048f, -0.24238281f, -0.20990105f, -0.89648241f, 0.57966983f, -0.30193377f, -0.69764936f, -0.32187220f, 
    0.13446428f, 0.02997576f, -0.47173288f, 0.55801022f, 0.13683100f, -0.79319173f, -0.14125833f, 0.26502690f, 
    -0.60338229f, -0.28764191f, 0.52157581f, 0.65085810f, 0.77172786f, 0.39747798f, 0.78920531f, 0.54205626f, 
    -0.38002774f, 0.10623644f, -0.02933881f, -0.25370115f, 0.21238543f, 0.59448367f, 0.00720810f, 0.50709462f, 
    0.29965207f, 0.61764723f, 0.58092970f, -0.36609882f, 0.16148432f, 0.17259797f, 0.58428663f, -0.50103885f, 
    -0.96455455f, -0.91132814f, 0.58588922f, 0.77105254f, 0.09835242f, -0.20696248f, -0.06784777f, 0.47562504f, 
    0.90372282f, 0.94375682f, -0.36964992f, 0.80918288f, -0.18252157f, 0.33852389f, 0.32500514f, -0.14307727f, 
    -0.81170529f, -0.11939844f, 1.06958747f, 1.04077685f, 0.60055047f, 0.09694367f, 0.29337382f, 0.30095896f, 
    -0.04839187f, -0.69891584f, 0.33742616f, 0.18939528f, -0.63584828f, -0.51091850f, -0.83070427f, 0.43011567f, 
    -0.49528727f, 0.23021868f, 0.39802977f, 1.01975834f, -0.49638757f, 0.81291860f, -0.53350490f, -0.57039189f, 
    -0.41681531f, -0.56400615f, -0.18010031f, 0.72139031f, -0.22128086f, -0.51127559f, 0.89875168f, 0.73972517f, 
    -0.22620794f, -0.01603058f, 0.18167281f, -0.26444751f, -0.90012985f, 1.04543734f, 0.34682316f, -0.81945276f, 
    0.52757341f, 0.60983193f, -0.26980728f, 0.47116730f, -0.13022959f, -0.26665494f, 0.79960155f, -0.47412843f, 
    0.17814144f, -0.55383736f, -0.49445927f, 0.29640773f, 0.47357112f, 0.42101961f, 0.87186319f, -0.92792583f, 
    -0.18946539f, 0.81344724f, -0.13143997f, 0.03459709f, -0.14911804f, -0.24543475f, -0.15444553f, -0.77811790f, 
    -1.22083127f, -0.60181963f, 0.32953298f, 0.72636294f, 0.32638398f, -0.41065088f, -0.00894789f, 0.05905306f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.26657879f, -0.00524420f, 0.24493589f, 0.34822336f, -0.02965204f, 0.34033373f, -0.23367833f, 0.32680407f, 
    0.33918190f, 0.10338783f, -0.18391889f, -0.08216432f, 0.13760011f, -0.18557444f, -0.02296455f, 0.30553365f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.00265022f, 0.24525619f, 0.00451217f, -0.14334135f, 0.02829662f, -0.05443875f, 0.07122073f, -0.04859858f, 
    -0.24996793f, -0.02681119f, -0.09731410f, 0.02278301f, 0.10351684f, -0.31306177f, -0.01931504f, 0.01108337f, 
    0.07216761f, -0.07597543f, 0.01148757f, 0.03526528f, 0.30898663f, 0.10360932f, 0.07595304f, -0.12256690f, 
    -0.03031054f, -0.00334763f, -0.04937286f, -0.05861884f, -0.15325198f, -0.19493569f, -0.03286427f, 0.11165105f, 
    -0.00853213f, -0.02709465f, 0.09418339f, 0.06491056f, -0.02266340f, 0.03989633f, 0.24254684f, 0.14214128f, 
    0.26722327f, -0.09051552f, -0.06327645f, -0.08351726f, -0.05331264f, -0.01366338f, 0.00811511f, 0.04546608f, 
    0.02306852f, 0.05023076f, -0.00968127f, 0.04691142f, -0.16435747f, 0.03861161f, -0.09522684f, 0.13202758f, 
    -0.02480451f, -0.02393514f, 0.16468517f, 0.15590625f, -0.15641791f, 0.14022191f, -0.04831279f, -0.09725231f, 
    0.05981643f, 0.05183117f, 0.01434263f, -0.12395412f, 0.06443783f, -0.06513041f, -0.13291343f, 0.19361712f, 
    -0.13999063f, 0.02415778f, -0.00139898f, -0.00291158f, 0.01453996f, 0.03164445f, -0.09049614f, 0.01098453f, 
    0.02796338f, 0.08955915f, -0.03687762f, -0.25545043f, 0.08028181f, -0.15615781f, -0.02519435f, -0.15654005f, 
    -0.10735667f, -0.19011176f, -0.19923601f, 0.06344793f, -0.10905974f, 0.04039405f, -0.01239807f, -0.02901467f, 
    0.05358903f, 0.02537740f, -0.32031628f, -0.15094668f, -0.25910270f, -0.19045946f, -0.23812437f, -0.07099699f, 
    -0.08972861f, 0.08715395f, 0.15991499f, 0.02891279f, -0.05063856f, -0.05050223f, -0.08577964f, -0.06846559f, 
    0.03371023f, -0.00996541f, 0.09006692f, -0.04526347f, 0.10836964f, -0.15933043f, -0.23420034f, -0.13506933f, 
    0.09136767f, 0.53222454f, -0.02631098f, 0.05043636f, 0.11517535f, 0.02801669f, 0.06199082f, 0.18244489f, 
    0.02570046f, 0.06097890f, -0.12949021f, -0.07213074f, 0.22419389f, -0.00225722f, 0.01760704f, 0.04627925f, 
    0.16453744f, -0.13671876f, 0.00726181f, -0.11046178f, 0.21550235f, -0.08422569f, 0.08133819f, -0.04569532f, 
    0.04061355f, 0.07476127f, -0.04307175f, -0.09406294f, -0.08977897f, -0.03499632f, -0.05588158f, 0.04583535f, 
    -0.17848659f, -0.00609023f, 0.02435625f, -0.08117101f, -0.01627764f, -0.02456059f, 0.08384667f, -0.14647293f, 
    0.39248320f, -0.00340478f, -0.04981824f, -0.15224908f, -0.05286360f, -0.10124468f, 0.01764836f, 0.13611451f, 
    0.09457739f, 0.08549509f, -0.01591301f, 0.14155729f, 0.01082401f, 0.05374925f, -0.02112633f, 0.12261064f, 
    -0.03251756f, -0.19635458f, -0.04725614f, 0.01921360f, -0.02542275f, -0.11555874f, -0.31140664f, -0.09983487f, 
    0.05050621f, 0.00271911f, 0.02370429f, -0.22896697f, -0.06832939f, 0.05942744f, 0.02164397f, 0.05541597f, 
    -0.04690060f, -0.09887305f, -0.06060862f, 0.18714209f, 0.00711849f, 0.03351522f, 0.33234090f, -0.00882138f, 
    0.28773314f, 0.13181768f, 0.23732795f, -0.04964013f, -0.02547286f, -0.07360112f, -0.01036796f, -0.27282697f, 
    -0.02730998f, -0.17341101f, 0.08022661f, 0.08293178f, 0.07336200f, 0.20945193f, 0.10278781f, 0.19738530f, 
    0.15540203f, -0.03749045f, -0.18616906f, -0.15185431f, -0.18573396f, 0.04112674f, 0.15155143f, -0.14735042f, 
    0.22139627f, -0.13624552f, 0.04664428f, 0.06590036f, 0.04968421f, 0.13842155f, 0.07346489f, 0.02065194f, 
    0.05335799f, 0.08065172f, 0.02050380f, 0.08311317f, -0.09812874f, 0.14838235f, -0.29224002f, -0.05090582f, 
    0.43233210f, -0.09030768f, 0.11685078f, 0.10409478f, 0.10443976f, 0.12673523f, -0.03538663f, -0.13704321f, 
    -0.00201871f, 0.00717860f, -0.17594284f, -0.02528524f, 0.02836975f, 0.04758353f, 0.03845714f, 0.12811770f, 
    0.01632993f, -0.24924743f, 0.04085493f, 0.07102980f, -0.02968030f, 0.06047839f, -0.00488902f, -0.21293861f, 
    -0.00319137f, 0.23756671f, -0.07347548f, -0.11499721f, -0.08321492f, -0.20078695f, -0.05960832f, 0.12465064f, 
    -0.00186586f, -0.01968086f, -0.09671518f, 0.19908522f, 0.11136273f, 0.28635558f, 0.09762772f, 0.15741265f, 
    0.13578880f, -0.08053750f, 0.17873430f, -0.10297246f, 0.15947838f, 0.01337905f, 0.02463317f, 0.18460065f, 
    0.13738111f, 0.05693056f, -0.12560046f, -0.06268806f, 0.06179651f, 0.05235506f, 0.21463178f, 0.16135070f, 
    0.22449082f, 0.19437872f, -0.27095789f, 0.09784538f, 0.27690074f, 0.05761160f, 0.22757137f, -0.04793090f, 
    0.16981991f, -0.08060616f, 0.01779438f, -0.05165144f, 0.08825525f, -0.02960388f, -0.00405545f, -0.04982039f, 
    0.02172313f, 0.27626097f, -0.05813006f, -0.05191511f, 0.09578147f, -0.04181242f, -0.00919338f, 0.06953590f, 
    -0.02330368f, 0.09248897f, 0.23068999f, -0.07640321f, -0.05446967f, -0.10914255f, 0.01539363f, 0.01734742f, 
    -0.00254597f, 0.01458182f, 0.04305550f, 0.00870225f, 0.02702404f, -0.15378281f, 0.03976565f, -0.00876488f, 
    0.08046082f, -0.06954931f, -0.01422807f, 0.01484470f, -0.04252762f, 0.29494497f, -0.26501638f, 0.13470893f, 
    0.03185153f, -0.07141380f, -0.14926738f, 0.02506057f, 0.05625454f, -0.18097354f, 0.03887764f, -0.02927016f, 
    0.04850299f, -0.18252628f, 0.12926909f, 0.03866484f, -0.14590341f, 0.03803077f, 0.15637490f, 0.12100855f, 
    0.38586378f, 0.20442940f, -0.03126165f, 0.01517702f, -0.03296813f, 0.12095801f, -0.04763961f, 0.15157907f, 
    -0.03376343f, 0.08808190f, 0.00720389f, 0.04272482f, -0.07833698f, -0.09180267f, -0.00076889f, 0.06555604f, 
    -0.06436272f, 0.15757945f, 0.29972669f, 0.21013498f, -0.09983973f, -0.11006604f, 0.30430794f, -0.02151700f, 
    0.16125154f, 0.08007822f, 0.11744212f, -0.04286534f, 0.08879850f, -0.10920657f, -0.02688407f, 0.03525253f, 
    -0.11729351f, 0.04106678f, -0.03766943f, 0.03873737f, 0.15486950f, 0.21352346f, 0.10780613f, 0.03127269f, 
    -0.07549631f, -0.10968670f, -0.08752457f, -0.15758581f, -0.10816527f, -0.07470934f, -0.09105704f, 0.07542855f, 
    -0.02944921f, -0.02025118f, -0.07232279f, 0.04074591f, -0.08484339f, 0.03173308f, 0.02499840f, 0.08360890f, 
    -0.02719077f, -0.07836599f, 0.04791812f, -0.06001111f, -0.34345880f, -0.30129337f, -0.10211898f, 0.01001958f, 
    -0.08026908f, 0.00499142f, 0.03866473f, 0.03849395f, -0.04265692f, -0.07623833f, -0.10450432f, 0.04928066f, 
    0.06110212f, 0.04767327f, 0.01158776f, 0.00591377f, 0.04385608f, -0.11312308f, -0.13169205f, -0.09879405f, 
    -0.27703962f, 0.05281321f, 0.08007932f, 0.02154220f, 0.20820709f, -0.00168885f, 0.12625146f, 0.05602758f, 
    -0.02575158f, -0.00441040f, -0.05906009f, -0.03715027f, 0.27257866f, -0.01942901f, 0.04076537f, 0.08256773f, 
    0.20897384f, -0.03230538f, -0.08489020f, 0.02845863f, -0.16477986f, 0.04126575f, 0.09228916f, 0.01611499f, 
    -0.12299507f, 0.08054699f, -0.02019523f, -0.03457070f, -0.03655185f, -0.09240958f, -0.03909687f, 0.03194278f, 
    0.03781904f, 0.05530640f, 0.06551602f, -0.04374251f, -0.02148549f, 0.01777480f, 0.08104867f, -0.14184441f, 
    -0.11868425f, -0.00069057f, -0.08921468f, 0.08741850f, -0.09178198f, 0.12852260f, -0.04242936f, 0.01479642f, 
    -0.00869942f, 0.00385594f, 0.07402603f, 0.06902891f, 0.15871988f, -0.00455590f, 0.03063848f, -0.06668387f, 
    -0.01290233f, 0.00459316f, 0.03181043f, 0.00412198f, 0.04370809f, 0.18555112f, 0.23102139f, 0.08849685f, 
    0.19239788f, -0.05295885f, 0.07279274f, -0.14932819f, 0.06554486f, 0.15444471f, 0.02506994f, 0.00565052f, 
    -0.03701133f, -0.10824073f, 0.03776960f, 0.06094043f, 0.09209707f, 0.18487783f, 0.31067508f, 0.00907266f, 
    0.14897613f, 0.16148448f, 0.01789449f, -0.01150747f, 0.19334464f, -0.05735599f, 0.11239836f, 0.03828014f, 
    0.00197010f, 0.00623233f, -0.01815517f, 0.08494216f, -0.12484378f, 0.17486730f, -0.03266551f, 0.21052599f, 
    0.08411852f, 0.09331311f, -0.20814122f, 0.10838731f, -0.35969970f, -0.10357349f, 0.00375309f, -0.03775449f, 
    0.02415694f, 0.12738210f, 0.14982425f, 0.09008607f, 0.15346363f, 0.08029965f, -0.02967337f, 0.23126115f, 
    0.03100863f, -0.02400248f, -0.05304549f, 0.04693662f, -0.13475460f, 0.19236098f, -0.08768685f, 0.01607179f, 
    0.02611080f, -0.01799247f, 0.13293649f, 0.09762916f, 0.19958700f, 0.05533027f, -0.08679467f, 0.02684570f, 
    0.09159761f, 0.00332752f, 0.02574703f, -0.02832025f, 0.20231386f, -0.09900980f, 0.08893923f, 0.04060469f, 
    0.09923554f, 0.00527566f, 0.11365287f, 0.04659639f, 0.16258122f, -0.14792590f, 0.25890031f, 0.11166473f, 
    -0.02330250f, 0.05219582f, 0.00971656f, -0.06723379f, 0.00193478f, -0.10187428f, -0.09420945f, 0.04249372f, 
    -0.07994612f, 0.00172305f, -0.07268473f, -0.05546609f, 0.12495270f, 0.19375432f, 0.00905621f, -0.01511445f, 
    0.26572940f, -0.21985643f, -0.10282788f, 0.02887080f, 0.12806807f, 0.13705973f, 0.05907902f, 0.15465738f, 
    0.09351340f, 0.17694703f, -0.21886507f, 0.02379214f, 0.11077771f, 0.10602008f, 0.13180944f, 0.08653127f, 
    -0.05499937f, 0.15112700f, -0.15926790f, 0.19680904f, 0.30706912f, 0.03516568f, -0.18118489f, -0.15328528f, 
    -0.24298778f, -0.00176065f, 0.01537289f, -0.06952764f, -0.01503466f, -0.06070107f, 0.03651247f, 0.02367610f, 
    0.05690032f, 0.27441952f, 0.07675064f, -0.01323792f, -0.03212254f, -0.02977356f, -0.01098284f, 0.12501729f, 
    0.01582133f, 0.00106237f, 0.00323926f, 0.00514502f, -0.01428390f, 0.03412047f, 0.01749218f, -0.00180713f, 
    -0.05416086f, -0.03010510f, 0.04736889f, -0.02503811f, -0.03874711f, 0.00654703f, 0.04541399f, -0.00782996f, 
    -0.05928040f, -0.05484602f, -0.00234345f, 0.01785417f, 0.02285120f, -0.06319252f, -0.00789982f, -0.01147700f, 
    0.01673496f, -0.05954954f, -0.04005238f, -0.02435301f, 0.02231552f, -0.01144533f, -0.02199435f, 0.01338329f, 
    0.04769785f, -0.04396624f, 0.04891401f, -0.01046288f, -0.00733745f, -0.05886644f, -0.03333025f, -0.02018017f, 
    0.00014783f, -0.05187819f, 0.01654257f, -0.05400373f, -0.03399226f, 0.02450937f, 0.02905695f, -0.04397748f, 
    0.00816361f, -0.00352030f, 0.00092808f, 0.03667106f, -0.03320897f, -0.02171543f, 0.00805349f, -0.05288131f, 
    -0.02511717f, 0.03283371f, 0.00120004f, 0.02353386f, -0.04854363f, 0.01395677f, -0.01356918f, -0.00144731f, 
    -0.04023362f, -0.05781425f, -0.02431188f, -0.04048870f, -0.03106541f, -0.05231727f, -0.02693699f, -0.00064328f, 
    0.01723227f, -0.02303396f, 0.00329768f, 0.03941211f, -0.00258814f, -0.00934213f, 0.01454955f, 0.01759137f, 
    -0.00212017f, 0.02186238f, -0.02948594f, -0.04617501f, -0.04743107f, 0.02805471f, -0.02216625f, -0.02175588f, 
    0.00524023f, 0.01105629f, -0.05849886f, -0.00421727f, -0.00415274f, 0.02138041f, -0.00905085f, 0.01489540f, 
    0.04799860f, 0.02698430f, 0.04786816f, 0.01275469f, -0.05105108f, 0.01303041f, -0.05372647f, -0.02863572f, 
    0.01038730f, -0.04761801f, -0.05773856f, 0.01592433f, -0.02863572f, -0.03776339f, 0.02799145f, 0.03710370f, 
    -0.01668085f, 0.03154067f, -0.00660220f, -0.03441578f, 0.03048915f, -0.02309216f, 0.04336132f, 0.04597158f, 
    0.00729109f, -0.00923494f, -0.00544278f, -0.03685191f, -0.01937133f, -0.05341725f, 0.00490488f, -0.06065619f, 
    -0.00597427f, 0.01437907f, 0.01368007f, 0.04557500f, 0.00158592f, -0.04349074f, -0.01181523f, -0.00514900f, 
    -0.00933065f, -0.01590825f, -0.01409820f, -0.03464529f, -0.01612017f, 0.01855193f, 0.03677607f, -0.01061299f, 
    -0.02863068f, 0.02516688f, -0.05150970f, 0.02916189f, 0.00736393f, 0.04342842f, 0.00466816f, 0.00504601f, 
    -0.00933262f, -0.02414437f, -0.03002754f, 0.03641846f, -0.03666183f, -0.05332760f, -0.00084701f, -0.04308496f, 
    0.02474276f, 0.00682843f, -0.01956376f, -0.00692508f, -0.00082698f, 0.00141206f, 0.04311245f, 0.02362269f, 
    -0.05080679f, -0.00293839f, -0.06347921f, -0.01414805f, 0.00042522f, 0.03697942f, -0.02147151f, -0.00591482f, 
    0.01773018f, -0.00223900f, -0.00939135f, 0.01353515f, 0.00629218f, 0.03002717f, -0.02243147f, 0.02757907f, 
    -0.02991012f, 0.03313143f, -0.04609703f, 0.01650839f, 0.02576125f, 0.02303371f, -0.01494236f, 0.03215179f, 
    0.01316821f, 0.03335435f, -0.00645630f, 0.04432010f, -0.06049163f, 0.00775376f, 0.03305296f, 0.03444993f, 
    0.03146439f, 0.00618076f, 0.03891326f, -0.03304962f, -0.06261874f, 0.02488516f, -0.04160189f, -0.03198478f, 
    -0.02567409f, -0.00481107f, 0.01705694f, 0.02271461f, 0.00783867f, 0.01199754f, -0.04026463f, -0.03439943f, 
    -0.00015591f, 0.01470642f, 0.00871920f, -0.01444760f, -0.05265444f, 0.00296743f, -0.00285873f, -0.02184568f, 
    -0.02562243f, -0.05759476f, 0.03183981f, -0.01677261f, -0.02794367f, 0.01797277f, -0.03239125f, 0.04391808f, 
    0.00242552f, 0.04819971f, -0.04186890f, -0.02189010f, -0.00465440f, -0.02231620f, 0.04170946f, -0.02130699f, 
    0.02398657f, 0.04536489f, -0.00852584f, -0.05735621f, -0.05410054f, -0.05528951f, -0.01867221f, 0.03725803f, 
    -0.05864984f, -0.03266536f, -0.05422596f, 0.03890860f, -0.03003011f, 0.03128746f, 0.00550716f, -0.03054670f, 
    0.04299867f, 0.03139227f, -0.01679585f, 0.03802960f, -0.05864249f, -0.05045011f, -0.01247211f, 0.04351908f, 
    -0.03218543f, 0.00892832f, 0.01996507f, 0.04310161f, 0.00562137f, -0.03368391f, 0.03408989f, -0.01674759f, 
    -0.04746632f, -0.04799354f, -0.02433486f, -0.03090534f, 0.00593866f, -0.03338603f, -0.01270019f, 0.04642640f, 
    -0.03204974f, 0.00681616f, -0.04319773f, -0.02920437f, -0.04378819f, -0.03235981f, -0.05397945f, 0.04015614f, 
    -0.04332691f, 0.00270822f, -0.06301201f, -0.04999164f, 0.04919206f, -0.00176238f, -0.01829021f, 0.00478463f, 
    -0.06370770f, -0.02599026f, 0.04004037f, 0.03072006f, 0.04692697f, -0.01431063f, 0.04478604f, -0.03111946f, 
    -0.03752575f, 0.04713175f, 0.01774498f, -0.03087139f, -0.04783757f, -0.04155656f, -0.02643793f, -0.01158461f, 
    0.01282117f, 0.02793312f, 0.03383352f, 0.02936848f, 0.01597598f, -0.03100016f, -0.02021071f, -0.06239768f, 
    -0.04960326f, -0.03318607f, 0.03781315f, -0.04408859f, 0.02027185f, 0.03349513f, 0.03961575f, -0.02651516f, 
    0.02680572f, 0.02147258f, -0.01066261f, -0.01610425f, -0.02382124f, 0.04434735f, -0.02134471f, -0.02464376f, 
    -0.00482658f, 0.00596250f, -0.05654868f, 0.00179269f, 0.00804443f, 0.05476775f, 0.02977671f, -0.01046140f, 
    -0.02108894f, 0.05189976f, -0.01812459f, -0.01282296f, -0.04818126f, -0.04884119f, -0.05745140f, -0.04774992f, 
    -0.00853543f, -0.04397335f, 0.00290639f, 0.03232426f, 0.02014538f, 0.04494744f, 0.02562163f, -0.06269893f, 
    -0.06300892f, 0.04720824f, 0.04660423f, 0.01481445f, -0.02982701f, -0.03325157f, 0.02297395f, -0.03144518f, 
    -0.01123205f, -0.00256010f, -0.03313729f, 0.02905370f, 0.03009723f, -0.01658324f, 0.02924528f, 0.03045737f, 
    -0.00368505f, -0.02545897f, 0.03486057f, -0.00678553f, 0.03038402f, -0.02219909f, 0.01241796f, 0.04333214f, 
    0.03932250f, -0.00630748f, -0.02679570f, 0.04161014f, -0.05904729f, 0.05229057f, 0.00902288f, 0.02263856f, 
    0.01419747f, 0.04180890f, 0.01807530f, -0.01706647f, 0.00857473f, -0.05017385f, 0.03745509f, 0.04967294f, 
    -0.00643890f, -0.01626519f, 0.01579005f, -0.01269852f, 0.04800414f, 0.01715444f, 0.03081544f, 0.01369179f, 
    0.00532694f, 0.00905699f, -0.05071552f, -0.04711788f, 0.04392347f, 0.01978571f, 0.00694078f, -0.00038402f, 
    -0.04875773f, -0.03926037f, -0.02053220f, -0.01610301f, -0.05315753f, 0.02191406f, -0.03685207f, 0.03785284f, 
    -0.01461856f, -0.01220474f, -0.03170009f, -0.05914265f, 0.01589969f, -0.01635132f, -0.00789737f, 0.00744750f, 
    -0.03007399f, -0.04616736f, 0.01127153f, 0.02667747f, 0.04308687f, -0.05917967f, -0.02960294f, -0.00967996f, 
    -0.05006624f, 0.01232060f, -0.04705502f, 0.03540739f, -0.03158796f, -0.04738104f, -0.00055822f, -0.01986974f, 
    -0.03357253f, 0.03713619f, -0.05591324f, 0.03785547f, 0.02928577f, 0.02211478f, 0.03129483f, -0.02200307f, 
    -0.00317011f, -0.05408520f, 0.05026359f, -0.03234661f, -0.07306830f, -0.04971504f, 0.00445870f, -0.01962430f, 
    -0.05977371f, 0.04540442f, 0.03122002f, -0.00253746f, 0.03924474f, -0.05583997f, 0.02551590f, -0.00219829f, 
    -0.01883633f, -0.04850444f, 0.03577771f, 0.00074626f, 0.00587322f, 0.01418794f, -0.00177951f, -0.00691330f, 
    -0.02505980f, -0.01388939f, -0.03668544f, -0.04642224f, 0.01076108f, -0.00349418f, 0.02589201f, -0.04973095f, 
    -0.05538798f, 0.01670641f, -0.00820633f, 0.04144179f, -0.01079308f, -0.05597974f, -0.01637815f, -0.02900890f, 
    0.04011799f, 0.01409948f, 0.02686790f, -0.04015921f, -0.02173639f, 0.00843493f, -0.00049720f, 0.01851910f, 
    0.00637269f, -0.04541632f, 0.00719332f, 0.01234547f, 0.05043274f, -0.03022419f, -0.03946691f, 0.04300266f, 
    0.04662500f, 0.02084932f, 0.01187853f, -0.01385027f, -0.01773436f, 0.02196114f, -0.00149249f, 0.04200532f, 
    0.01776444f, -0.00751107f, -0.01142510f, 0.02232946f, -0.01169494f, -0.03685109f, -0.01527767f, 0.00137518f, 
    -0.01268616f, 0.02699915f, -0.04181024f, -0.00292146f, -0.02420582f, -0.06127723f, 0.02024233f, 0.03570560f, 
    0.01468683f, -0.02359937f, 0.01496733f, -0.04957626f, -0.02340641f, 0.04879461f, -0.06841487f, 0.01501294f, 
    0.04895734f, 0.03627387f, -0.00460925f, 0.01268579f, 0.02148297f, -0.02595375f, 0.01657826f, -0.00033043f, 
    0.00408647f, -0.00258931f, -0.00162835f, -0.00379713f, -0.01813741f, -0.04179642f, 0.01873649f, 0.02899277f, 
    -0.01575270f, 0.00029467f, 0.00562594f, -0.05263120f, -0.04500499f, -0.04487722f, -0.02465849f, -0.01930563f, 
    -0.03633318f, 0.00682615f, -0.05166097f, -0.05162108f, -0.01343620f, 0.01802189f, -0.02381685f, -0.02179866f, 
    -0.01963887f, -0.04975873f, -0.02462715f, -0.05174803f, -0.04284430f, -0.01537954f, 0.00978464f, 0.04200253f, 
    0.03538004f, -0.00064815f, 0.04606289f, -0.00261935f, -0.03866812f, -0.02835652f, 0.04247145f, -0.03924407f, 
    -0.00784406f, -0.00045423f, -0.01598307f, 0.02729362f, -0.04706167f, 0.03069165f, 0.02871373f, 0.00185414f, 
    0.01095591f, 0.03026748f, -0.04698915f, -0.03053644f, -0.01429254f, -0.05912602f, 0.03487236f, 0.02479720f, 
    -0.01045434f, 0.00937788f, -0.01390078f, -0.02507691f, -0.02578399f, -0.05463699f, -0.00632710f, -0.01232470f, 
    0.01057475f, -0.02193252f, -0.02830858f, -0.03406293f, -0.06017332f, -0.01169866f, 0.02227045f, -0.04835897f, 
    0.01166559f, -0.02524898f, 0.00253763f, -0.03695943f, 0.02742734f, -0.00155056f, -0.01417245f, -0.03002848f, 
    0.03453771f, 0.03468198f, -0.02060770f, -0.01775847f, -0.04238671f, 0.00749308f, 0.00506682f, -0.05467530f, 
    -0.02514158f, 0.02420170f, 0.04988568f, -0.00000652f, -0.03130954f, 0.01091803f, -0.02202624f, 0.03963299f, 
    -0.04763588f, 0.04141960f, -0.01833360f, -0.04423781f, -0.02351539f, -0.01313985f, -0.00177134f, 0.00097598f, 
    -0.00382657f, 0.02787004f, -0.05854860f, -0.03784476f, -0.04116813f, 0.01856893f, -0.01081621f, -0.04837669f, 
    -0.02100195f, 0.04627633f, 0.03435625f, -0.05435792f, -0.00673295f, 0.04192031f, 0.04237980f, -0.04881765f, 
    0.01019476f, 0.05210958f, 0.03814143f, 0.03963742f, 0.00472927f, 0.00376511f, -0.01248121f, 0.00734451f, 
    -0.04292409f, -0.03480453f, -0.06062932f, -0.00168806f, -0.05618959f, 0.04378858f, 0.03820214f, 0.04738617f, 
    0.01108666f, -0.02032096f, -0.00643511f, 0.03927407f, -0.05971960f, 0.03342345f, 0.00606192f, -0.05509807f, 
    -0.03712447f, 0.02180214f, 0.00958498f, -0.02683010f, -0.06089393f, -0.03828400f, 0.00724987f, -0.03004152f, 
    0.04619458f, 0.01379152f, -0.04424686f, -0.04036077f, -0.04391440f, 0.02130968f, 0.03058053f, 0.03020556f, 
    -0.02573083f, -0.05736312f, 0.03810459f, 0.00694012f, -0.03751747f, -0.05779433f, 0.04245229f, 0.01612456f, 
    0.00414235f, -0.04224550f, 0.03295864f, -0.00435433f, 0.04631027f, -0.00349981f, 0.02995977f, 0.01880087f, 
    0.02699348f, -0.02670212f, -0.03895618f, -0.05375779f, -0.05913800f, -0.04997883f, 0.01436244f, 0.03088668f, 
    -0.04587707f, -0.02625568f, -0.03567337f, -0.00252023f, -0.01186162f, -0.02486816f, 0.00877126f, 0.02413736f, 
    0.02652217f, -0.03286933f, -0.03695832f, 0.02027446f, -0.03176500f, 0.03814715f, 0.02890093f, 0.03355526f, 
    -0.01115748f, -0.00832819f, -0.03309710f, 0.00409897f, -0.04046027f, 0.03407986f, -0.05132047f, 0.00774873f, 
    0.02355521f, 0.03492162f, 0.00813141f, 0.03457915f, -0.00220259f, -0.02662822f, -0.00752374f, -0.05058220f, 
    -0.01790729f, -0.04584131f, -0.02324371f, 0.02395268f, 0.04491831f, 0.00268316f, -0.04872402f, -0.02477661f, 
    0.01158208f, -0.02879647f, -0.03550985f, -0.01779648f, -0.05647205f, -0.03589721f, -0.06117135f, -0.04974149f, 
    -0.02635633f, 0.01605915f, 0.04002925f, -0.04118450f, 0.02014090f, -0.02820120f, 0.02651694f, -0.02705562f, 
    0.00829834f, 0.04332562f, -0.00282862f, 0.01756698f, -0.01279759f, 0.03465886f, -0.05545593f, -0.01636265f, 
    -0.00782054f, -0.02413868f, 0.00028804f, -0.01906505f, 0.01866929f, 0.00027078f, 0.01761178f, 0.03660578f, 
    -0.03460138f, 0.04086351f, 0.03612895f, -0.02035767f, -0.00459157f, -0.02918772f, 0.01904697f, -0.01852894f, 
    -0.04536810f, 0.03133511f, -0.00202118f, -0.03584293f, -0.00831299f, -0.04291215f, 0.02066809f, 0.02947633f, 
    0.02545777f, 0.03890806f, -0.01320403f, 0.01152869f, -0.02622060f, -0.01793944f, -0.02439788f, -0.06057208f, 
    0.03712575f, -0.04032331f, 0.02873145f, -0.05287955f, 0.04281899f, -0.05558474f, -0.03267958f, 0.03565589f, 
    -0.05317216f, 0.00711596f, 0.00805867f, 0.01674972f, -0.01108764f, -0.05630967f, -0.02435968f, -0.04670264f, 
    0.00323874f, 0.00158384f, 0.02784650f, -0.01959212f, -0.03169941f, -0.00490277f, 0.03646242f, -0.04551057f, 
    0.01752490f, -0.04101786f, 0.00865869f, 0.00276049f, 0.02151257f, 0.00154723f, 0.00723145f, -0.04290272f, 
    -0.00725864f, 0.00418340f, -0.05575524f, -0.05762053f, 0.00211793f, 0.01979833f, -0.01864780f, -0.05341926f, 
    0.05988941f, 0.02284059f, 0.00005524f, 0.02787141f, -0.03944204f, 0.00568073f, -0.05059270f, 0.00475231f, 
    -0.01000430f, 0.01920627f, -0.00109192f, 0.00322495f, -0.04855648f, -0.03793513f, 0.01599734f, -0.05225550f, 
    -0.05980885f, 0.00074376f, 0.02616803f, -0.03862825f, -0.05977108f, -0.04625214f, -0.04788760f, 0.01068602f, 
    0.01799832f, 0.00438759f, 0.01503358f, 0.03182994f, 0.00444004f, -0.03966636f, -0.05079677f, -0.00441007f, 
    0.00528024f, 0.02724891f, 0.04939924f, 0.02966043f, -0.05456164f, -0.01206231f, 0.02602489f, -0.04867465f, 
    0.02927250f, -0.02942747f, 0.01477595f, 0.01610106f, -0.01537687f, 0.00451672f, 0.04411190f, -0.05529729f, 
    0.02283260f, -0.03980369f, -0.04002305f, -0.01708556f, -0.05128004f, 0.00767286f, -0.00828636f, -0.01855038f, 
    -0.04433485f, 0.03633897f, -0.00299320f, 0.01483822f, -0.02502986f, 0.00799185f, 0.04501452f, -0.05696465f, 
    0.02408810f, 0.00113221f, 0.05424410f, 0.03683388f, 0.00681449f, -0.02216165f, -0.02643414f, -0.02863470f, 
    0.04499946f, -0.02651263f, -0.03552376f, 0.02990843f, -0.01031622f, 0.04172612f, -0.05347452f, -0.05714833f, 
    -0.05132040f, -0.01825446f, 0.04824596f, -0.04598354f, -0.05416452f, 0.01400354f, 0.01309715f, 0.02076182f, 
    0.12636563f, 0.22345565f, 0.01028965f, -0.27637124f, -0.19900750f, 0.19522221f, 0.08632250f, -0.05889444f, 
    -0.02029720f, -0.03007563f, 0.06264254f, 0.03388854f, 0.06753304f, 0.19897136f, 0.06272069f, 0.00875687f, 
    0.04320186f, 0.09028856f, -0.19263969f, 0.02078459f, 0.29619429f, -0.02709087f, 0.05883155f, 0.16604015f, 
    -0.16165277f, -0.13457522f, -0.05314282f, 0.08951030f, -0.15840185f, 0.23095438f, -0.00706351f, 0.06711404f, 
    -0.19638944f, 0.08874481f, 0.00882466f, 0.07544574f, 0.00863430f, 0.01588207f, -0.06380016f, -0.03632221f, 
    -0.15456700f, 0.06961555f, -0.05683715f, -0.03570623f, 0.08484646f, -0.04224652f, -0.03863928f, 0.07285062f, 
    0.11192302f, -0.07252719f, -0.05644163f, -0.16700527f, 0.11748768f, 0.02752029f, 0.01952661f, 0.05130265f, 
    0.14370783f, -0.14818749f, -0.08394818f, -0.10157564f, -0.09726011f, 0.22546007f, -0.03050884f, -0.10616089f, 
    0.11803611f, 0.10509215f, -0.04685573f, 0.15093198f, 0.17805609f, 0.05249573f, -0.09828609f, -0.02627547f, 
    0.03465134f, 0.03296712f, 0.09231508f, -0.00141129f, -0.03737310f, 0.05690531f, -0.00687602f, 0.07613633f, 
    0.17814517f, -0.19209094f, -0.06113974f, -0.23932169f, -0.09794381f, -0.04938988f, -0.06255779f, 0.02247976f, 
    -0.09903469f, 0.08260187f, 0.08240545f, 0.03499872f, 0.01428938f, 0.04661627f, 0.11323877f, 0.07139183f, 
    -0.05273981f, -0.02666643f, -0.05145409f, 0.08655074f, 0.04429885f, 0.07774402f, -0.06174214f, -0.01513646f, 
    -0.03061303f, 0.03913055f, 0.16821058f, 0.09249406f, -0.04934731f, 0.00570561f, 0.04672369f, 0.15539098f, 
    0.00671823f, -0.05780093f, 0.02876963f, -0.09313879f, 0.02001730f, 0.12586854f, 0.05432426f, 0.15134327f, 
    0.00358930f, 0.06742074f, -0.02813965f, 0.28665739f, -0.16708550f, -0.06161518f, 0.05291014f, -0.10586083f, 
    0.04732744f, -0.08782724f, 0.08665777f, 0.03450786f, -0.04920807f, -0.00171118f, 0.00203433f, -0.10291369f, 
    -0.04627556f, -0.00761853f, -0.02415310f, -0.00502757f, 0.41629457f, -0.07624418f, -0.02191437f, -0.26888791f, 
    -0.05075489f, 0.05887810f, 0.10678490f, 0.00847286f, -0.04407958f, 0.06605013f, -0.03164553f, -0.03311917f, 
    -0.02098159f, 0.13045126f, 0.02538520f, 0.01500595f, -0.02927551f, 0.11452086f, -0.04214064f, 0.14035910f, 
    0.02109224f, 0.04266118f, 0.14692928f, 0.00687764f, 0.14489517f, 0.09010579f, 0.14783667f, -0.05487185f, 
    -0.02770689f, 0.20954978f, -0.10444985f, -0.02044759f, -0.02321108f, -0.01003021f, -0.00108280f, -0.09003193f, 
    -0.06208928f, 0.07942592f, -0.03834080f, 0.01667238f, -0.07199303f, -0.01522929f, -0.18620594f, -0.20870505f, 
    0.04233943f, -0.03310945f, -0.00520364f, 0.03886399f, 0.13001373f, -0.00756449f, -0.06773009f, -0.00095149f, 
    0.13496824f, 0.03656986f, 0.05616880f, 0.01961106f, 0.08295904f, -0.05687981f, -0.04890419f, 0.07042277f, 
    -0.51333052f, -0.29128680f, 0.13271520f, -0.35565412f, 0.08965117f, 0.14828195f, 0.04847216f, -0.02411818f, 
    -0.08951467f, -0.14779459f, 0.10808680f, 0.04855981f, -0.01965554f, -0.11487745f, 0.13605817f, 0.03899390f, 
    -0.08571336f, -0.14960986f, 0.05290771f, -0.09078178f, -0.03311547f, -0.03624304f, 0.09918626f, 0.03075869f, 
    -0.21609418f, 0.09523628f, 0.01358461f, 0.00735845f, 0.08740003f, -0.00266748f, 0.07245336f, 0.01000135f, 
    -0.04126967f, -0.06413693f, 0.03344717f, -0.03902336f, 0.02429431f, -0.05656864f, 0.12029354f, -0.02506495f, 
    -0.03256599f, -0.17150360f, -0.12396108f, -0.21190381f, 0.01475719f, -0.01858954f, 0.03895300f, -0.18078731f, 
    0.00687473f, 0.02820864f, 0.03700162f, 0.03791819f, 0.11409305f, -0.10517003f, 0.06505199f, 0.10458860f, 
    0.07825430f, 0.20317614f, -0.12677558f, 0.07744213f, -0.08263956f, 0.12045804f, -0.39866242f, -0.23721892f, 
    0.15364075f, 0.15013056f, -0.02368356f, 0.01462994f, 0.08062481f, 0.14201868f, 0.11822596f, 0.09672065f, 
    0.13219774f, -0.14540511f, 0.06098724f, 0.06963754f, 0.10455652f, -0.10142098f, 0.09313919f, -0.00879054f, 
    0.21402949f, -0.16467024f, 0.17146131f, 0.12364583f, -0.15133364f, 0.12266733f, -0.07437781f, 0.02585398f, 
    0.05163000f, 0.17634226f, 0.00773025f, -0.07845946f, 0.07924259f, 0.04686041f, 0.02278315f, 0.00734050f, 
    0.04169363f, -0.19743827f, 0.15375313f, -0.19118281f, 0.59852147f, 0.07021235f, 0.13889566f, 0.22119761f, 
    -0.22588761f, -0.11004783f, -0.00211608f, -0.03817014f, -0.00597233f, -0.04804050f, -0.05747248f, -0.03956178f, 
    -0.07876504f, -0.05661311f, -0.03623250f, -0.02064808f, -0.09138777f, 0.01764060f, -0.14433470f, 0.02288664f, 
    0.01009748f, -0.03744625f, 0.00261747f, -0.01380241f, 0.02608192f, -0.05589725f, -0.04361548f, 0.02856787f, 
    0.03886844f, 0.02003125f, 0.04376701f, -0.01125696f, 0.01071278f, -0.01599982f, -0.00669763f, 0.05241059f, 
    -0.05004263f, -0.03136575f, -0.03047667f, -0.00939575f, -0.00291831f, 0.00391851f, 0.00983416f, 0.03298820f, 
    0.02229203f, -0.00592192f, -0.01634950f, 0.00737537f, 0.00158694f, 0.02794350f, -0.00879824f, 0.01577993f, 
    0.02589455f, -0.04256861f, 0.02208178f, -0.03005755f, -0.04180667f, 0.01681812f, -0.04466433f, 0.02708302f, 
    -0.01745862f, 0.05254085f, -0.03358028f, -0.00827746f, 0.03822705f, 0.00877399f, -0.00850266f, -0.05614172f, 
    -0.04057133f, 0.02821829f, -0.03510998f, -0.04118473f, 0.00995675f, -0.03624132f, -0.01690660f, 0.02879480f, 
    -0.04498273f, -0.00672281f, -0.03315677f, 0.04051617f, -0.05205829f, -0.04628278f, -0.01011762f, 0.00424939f, 
    -0.04069309f, -0.01622753f, 0.00260591f, 0.00771984f, -0.02297201f, 0.03983679f, -0.04808220f, -0.03145973f, 
    0.00026916f, 0.04087155f, -0.05677153f, -0.02512548f, 0.00485949f, -0.04272367f, -0.05752597f, -0.04124111f, 
    0.02403208f, 0.04636772f, 0.00416518f, 0.01995791f, 0.04704982f, 0.01532387f, 0.02043117f, -0.02285221f, 
    0.01995987f, -0.02868845f, -0.01310851f, 0.04599267f, -0.01041438f, -0.05608024f, 0.03116420f, 0.05142828f, 
    -0.02379186f, -0.05169694f, -0.05345470f, 0.02867259f, -0.00406082f, 0.04480425f, 0.03620289f, 0.03222536f, 
    0.03373086f, 0.03774407f, 0.00225084f, -0.02863922f, -0.02898074f, -0.01157848f, -0.04609995f, -0.02924730f, 
    0.02036932f, 0.01569692f, 0.05119462f, -0.04065577f, 0.04014574f, 0.01793484f, 0.01832260f, -0.06079853f, 
    -0.01458728f, -0.05466103f, -0.03709548f, 0.04378290f, -0.02259092f, 0.02225507f, 0.02968143f, 0.03835862f, 
    -0.00129433f, 0.01384035f, -0.01131156f, 0.02823029f, 0.02402729f, 0.04579297f, 0.02668911f, -0.00179826f, 
    -0.01041041f, 0.01166811f, 0.01002896f, 0.02635311f, 0.02685765f, 0.02919905f, 0.04000662f, -0.05768337f, 
    0.00071573f, -0.02356130f, 0.01710421f, -0.02337144f, -0.05047252f, -0.02298547f, 0.02855224f, 0.02627481f, 
    0.00252935f, 0.03167230f, -0.05721796f, 0.01708995f, -0.01342402f, -0.05337824f, -0.00102400f, -0.03884290f, 
    -0.00383686f, 0.04895664f, -0.04120094f, 0.02469035f, -0.05969746f, 0.04192844f, 0.04477064f, 0.02395400f, 
    0.02836904f, -0.00063943f, -0.00434919f, -0.01525352f, 0.00042918f, -0.05872823f, 0.04683674f, -0.01202219f, 
    -0.03652830f, 0.00077990f, -0.04680073f, -0.03505231f, 0.00021029f, 0.01370913f, -0.04813304f, -0.01954741f, 
    -0.05120164f, 0.03322290f, -0.03235462f, -0.02843589f, 0.01430670f, -0.00373128f, 0.02116149f, -0.01287641f, 
    0.02419442f, -0.01339592f, -0.00130058f, 0.00469483f, 0.03208186f, 0.03568250f, -0.03651898f, 0.01564441f, 
    -0.01487071f, -0.04460744f, -0.01628746f, 0.04081069f, 0.05006823f, -0.05547064f, -0.02377554f, 0.01582454f, 
    -0.04800152f, -0.02023710f, -0.01147093f, -0.02150629f, -0.03964602f, 0.04187723f, -0.01871359f, -0.04373529f, 
    0.03069089f, 0.03394604f, 0.05043422f, -0.05864423f, 0.00591154f, -0.02004557f, -0.02541312f, -0.01524023f, 
    0.01262856f, -0.02747291f, 0.04122701f, -0.01691088f, 0.03686955f, -0.05991920f, 0.04565456f, -0.00737998f, 
    0.00501734f, -0.01081982f, 0.03098704f, 0.01495872f, 0.04756068f, -0.04674758f, -0.03736257f, 0.00978345f, 
    -0.00079524f, -0.04702449f, 0.02977006f, -0.03837275f, -0.03208830f, 0.01893569f, 0.04224668f, 0.00651723f, 
    -0.04601599f, -0.04465376f, 0.04133533f, -0.01361850f, -0.03958031f, 0.02319175f, 0.03825207f, -0.04173516f, 
    0.01851207f, -0.04704332f, 0.04406381f, -0.05434850f, 0.00205503f, -0.04111894f, -0.03460370f, -0.01279129f, 
    -0.00948474f, 0.04636171f, -0.01852597f, 0.02849176f, -0.03735452f, 0.01900640f, -0.04664171f, 0.00217402f, 
    -0.01802456f, -0.04016775f, -0.01279003f, -0.03159835f, 0.01323418f, -0.00121980f, -0.04962157f, -0.01536883f, 
    -0.03829490f, 0.04865582f, -0.04384329f, -0.05124880f, -0.02235870f, -0.05182015f, 0.03224959f, 0.02328105f, 
    -0.00892574f, -0.01993015f, -0.00833036f, -0.01007952f, -0.03146698f, -0.06410572f, -0.03393841f, -0.02660024f, 
    -0.02238892f, -0.01319599f, -0.04440917f, 0.01578940f, -0.03651213f, 0.02879850f, 0.00904119f, -0.05845524f, 
    0.02827026f, -0.03226488f, 0.04135462f, -0.00999769f, -0.03291621f, -0.02283264f, 0.03340248f, -0.02016552f, 
    0.02264722f, -0.06142667f, -0.03234143f, -0.01926203f, 0.04415531f, -0.05435773f, 0.02996063f, 0.00122572f, 
    0.04267491f, 0.01549231f, -0.06298758f, 0.02406612f, -0.02961980f, 0.03755160f, -0.02645442f, 0.01198155f, 
    -0.00892394f, 0.04654568f, -0.03645243f, 0.01366145f, -0.02333659f, 0.01794895f, -0.05743685f, -0.00413415f, 
    0.00346109f, -0.03882866f, -0.05505602f, -0.01107299f, -0.00587372f, -0.03275596f, -0.04769535f, 0.00860795f, 
    -0.04424981f, 0.01080510f, -0.03960827f, -0.02879985f, 0.03336770f, 0.04329452f, 0.03963257f, -0.01898533f, 
    0.01498659f, -0.01234596f, 0.00163000f, -0.04292985f, 0.04099436f, -0.05925792f, 0.00071927f, 0.03332216f, 
    0.03804335f, -0.06141512f, -0.03295570f, 0.02404178f, -0.03035342f, 0.02279130f, -0.03192442f, -0.03161522f, 
    -0.02556858f, 0.00055120f, -0.01438994f, -0.02600256f, 0.01631716f, 0.01923766f, -0.05834302f, -0.05585327f, 
    -0.00009116f, 0.03827815f, -0.04560336f, -0.00468223f, -0.01029088f, 0.02847914f, 0.03812061f, 0.00231999f, 
    -0.02809964f, -0.04338670f, -0.02004277f, 0.02868017f, 0.00847989f, -0.05441605f, 0.03015588f, -0.03988439f, 
    0.00912025f, 0.04393778f, 0.00551567f, -0.03082206f, -0.03299413f, 0.04035558f, 0.00856449f, 0.02645163f, 
    0.06014626f, -0.04889081f, 0.04737297f, -0.03912222f, -0.02650179f, 0.00050986f, -0.04596758f, -0.03412151f, 
    -0.02699403f, -0.00337602f, 0.03044201f, 0.01401287f, -0.00753613f, 0.03256179f, 0.01782811f, -0.02910275f, 
    0.01638398f, -0.01930699f, -0.05829665f, 0.04068946f, -0.04252679f, -0.00863092f, -0.02651381f, 0.00492824f, 
    -0.05500197f, 0.02798316f, -0.05822571f, 0.00785484f, 0.04912910f, -0.02190172f, -0.02265619f, -0.03028314f, 
    0.02313185f, -0.06010780f, -0.01858160f, 0.01283379f, -0.05731248f, 0.00866012f, -0.01390434f, 0.02128269f, 
    -0.00663233f, 0.04083740f, 0.00419341f, -0.01067933f, -0.02736129f, 0.02823401f, -0.03769156f, -0.01458082f, 
    0.03593996f, 0.01753145f, 0.02256786f, 0.00327713f, -0.01291423f, 0.04662770f, 0.04584142f, 0.01550357f, 
    0.03158785f, 0.03735618f, -0.03315969f, -0.02402093f, 0.03295048f, 0.02741092f, 0.04366657f, -0.00787621f, 
    -0.01151577f, 0.02234613f, 0.00887667f, 0.01059674f, 0.00478356f, 0.04329482f, -0.03161426f, 0.02317917f, 
    -0.05417240f, -0.04387374f, -0.00127033f, -0.01324636f, -0.03672050f, 0.00540438f, -0.02478256f, 0.02072910f, 
    -0.02181109f, -0.01549549f, -0.02492858f, -0.02693616f, 0.03423359f, -0.02941420f, 0.00198134f, -0.03393709f, 
    -0.02470381f, 0.00403707f, -0.04281194f, 0.01149921f, 0.03417809f, -0.05418247f, -0.05474247f, -0.02895340f, 
    -0.03440669f, -0.00927803f, 0.01671639f, 0.04350698f, -0.05761329f, -0.03748839f, 0.04064034f, -0.02999396f, 
    -0.02213673f, -0.03037113f, 0.01263920f, 0.03643034f, -0.00216738f, 0.04480185f, 0.03660132f, -0.01549663f, 
    0.03228753f, -0.03881498f, -0.01545162f, 0.04243033f, 0.03516193f, -0.05935721f, -0.04409311f, 0.05070005f, 
    -0.02385432f, -0.04307628f, 0.04358466f, 0.01653296f, -0.01898012f, 0.00428126f, -0.03511040f, -0.04599171f, 
    -0.04008121f, 0.00560532f, -0.06196998f, -0.05934229f, 0.03849876f, -0.06282873f, 0.03265375f, -0.00369376f, 
    0.02672290f, 0.00732195f, 0.00451694f, -0.04265041f, 0.03684251f, -0.05690977f, 0.02694110f, -0.04493650f, 
    -0.00984836f, 0.04714315f, -0.01471962f, 0.00145473f, 0.01203424f, 0.02854427f, -0.03564847f, -0.02111394f, 
    -0.03605215f, -0.01430370f, -0.00509821f, 0.03391948f, -0.01916033f, 0.01351160f, 0.05130867f, 0.00833461f, 
    -0.01772437f, 0.03101518f, -0.02983509f, -0.05067303f, 0.02064739f, -0.01629579f, -0.05759342f, -0.03682800f, 
    0.02419030f, -0.05382572f, -0.00091825f, 0.00768697f, -0.05575904f, 0.03329120f, 0.01832025f, -0.04858790f, 
    0.03480349f, 0.03005837f, -0.04902502f, -0.04000162f, -0.04283983f, -0.05019835f, -0.00859579f, -0.03904631f, 
    -0.05635959f, -0.04085740f, 0.02507247f, 0.00894844f, -0.00158241f, -0.03755122f, 0.00103780f, -0.04450275f, 
    0.04174932f, 0.04722586f, 0.03966204f, -0.03452600f, -0.03904747f, 0.04722384f, -0.03674742f, -0.02279095f, 
    0.03535774f, -0.00103067f, -0.05476863f, -0.06021561f, 0.00646605f, -0.04866974f, 0.04440956f, 0.01736734f, 
    0.01528151f, -0.02857395f, 0.04129226f, -0.02955476f, 0.03762728f, 0.01268028f, 0.02822236f, 0.04215330f, 
    -0.00387361f, -0.03629533f, -0.05228807f, -0.03669607f, 0.02067330f, 0.04396459f, -0.06278285f, 0.01991690f, 
    0.03252865f, 0.03347649f, -0.01999427f, 0.04338452f, 0.02473651f, -0.04844834f, -0.00853083f, -0.02706708f, 
    0.02966112f, 0.04075294f, -0.01456014f, -0.05456899f, 0.04547202f, -0.00551446f, -0.05392960f, -0.01818479f, 
    -0.03226132f, -0.01582940f, -0.02668883f, -0.04545912f, -0.01412216f, -0.03454464f, 0.02425187f, 0.01783841f, 
    -0.04901659f, -0.04102714f, 0.03133446f, -0.04166504f, -0.02612909f, -0.04877268f, -0.02531685f, -0.04721897f, 
    -0.04155979f, 0.02513924f, -0.05823932f, 0.02980715f, -0.02227370f, 0.02129226f, 0.02426627f, -0.04365255f, 
    -0.03917731f, 0.00082283f, -0.00652920f, 0.03934913f, 0.01587199f, 0.04607043f, 0.04489654f, -0.05311053f, 
    0.04094254f, -0.02732414f, -0.04989792f, -0.03079280f, -0.03054439f, -0.01667474f, -0.00771048f, -0.01087105f, 
    -0.00004774f, 0.00006737f, 0.04774705f, 0.02064551f, -0.03630752f, 0.01805114f, 0.03630930f, 0.04446854f, 
    0.00579956f, -0.01172613f, 0.02470532f, -0.01735967f, 0.03687306f, -0.04673389f, -0.06037965f, -0.05938125f, 
    0.02394923f, -0.00689425f, 0.04043360f, -0.00213543f, -0.03220114f, 0.02833642f, -0.06204862f, -0.04977570f, 
    -0.03927445f, 0.02949183f, -0.04825478f, 0.04889257f, 0.02899628f, 0.01151985f, -0.06000534f, -0.04853154f, 
    0.02539876f, 0.01305337f, 0.04210507f, -0.03388181f, 0.00894504f, 0.04475393f, 0.01349762f, 0.02554529f, 
    -0.02657940f, -0.02032304f, 0.01487187f, -0.02240753f, 0.02990192f, 0.02947786f, 0.01476388f, 0.02516075f, 
    0.01366054f, 0.02318506f, -0.06124696f, 0.00441966f, 0.00882886f, -0.02766901f, 0.00327216f, -0.03073331f, 
    -0.01075180f, 0.01271946f, 0.00316327f, 0.02203279f, 0.03248418f, -0.05021382f, 0.04561667f, 0.01210356f, 
    0.03491908f, -0.00008577f, -0.03497369f, 0.02918260f, -0.00942855f, -0.01947638f, -0.00378257f, -0.04220721f, 
    -0.01392615f, -0.02262694f, -0.01507412f, -0.05481182f, -0.00023756f, -0.01092356f, -0.02592001f, -0.02340036f, 
    0.01202715f, 0.02659047f, -0.03904744f, -0.05364869f, -0.02406725f, -0.00169400f, -0.03395058f, 0.03192633f, 
    -0.03669685f, -0.00370146f, -0.06037924f, -0.01436152f, -0.01714077f, 0.00947150f, -0.02070106f, 0.01802132f, 
    -0.01387007f, -0.01795165f, -0.02165163f, 0.04513370f, -0.05256007f, 0.00942896f, -0.04957115f, -0.02864497f, 
    -0.04229207f, 0.01575055f, -0.02812503f, 0.03297278f, 0.04017110f, -0.01052277f, -0.05811555f, -0.03228361f, 
    -0.01056590f, -0.04840435f, 0.00164939f, 0.04658778f, -0.01373321f, -0.02750679f, -0.05447966f, -0.05654461f, 
    -0.02168418f, 0.00575152f, -0.00791247f, 0.01624102f, -0.02737449f, 0.03631924f, -0.01311340f, -0.05789713f, 
    -0.00734632f, -0.01059764f, -0.02149655f, -0.04441043f, 0.02126421f, -0.01525086f, 0.03284039f, 0.01460627f, 
    -0.04592039f, -0.02662619f, -0.03515209f, -0.00008626f, -0.01538523f, -0.06118612f, -0.02169668f, 0.02521548f, 
    0.03067216f, -0.02327446f, -0.04714200f, -0.05031861f, 0.03629164f, 0.03351184f, -0.04973897f, -0.02080701f, 
    0.04083034f, 0.04248247f, -0.00023840f, -0.05023642f, 0.00969083f, 0.00958405f, -0.00769666f, 0.04316711f, 
    0.00526381f, -0.03220335f, 0.02417496f, 0.03097587f, -0.04527846f, -0.01181059f, -0.03184984f, 0.02561169f, 
    -0.04531162f, -0.00550081f, -0.02018677f, 0.01302184f, -0.05569742f, -0.04803417f, 0.04555945f, 0.01408691f, 
    -0.06021947f, 0.01048168f, 0.01388118f, -0.00932923f, 0.00226852f, -0.00353287f, 0.03172861f, 0.04443911f, 
    -0.02006954f, 0.02266743f, 0.01571497f, -0.03525417f, -0.00588528f, 0.03004660f, 0.03943251f, -0.01538914f, 
    -0.01741130f, -0.01189392f, -0.04941939f, 0.04434047f, 0.00830494f, 0.01360925f, -0.03460077f, -0.04816141f, 
    -0.06001890f, -0.01797581f, -0.03822500f, 0.04746540f, 0.03264974f, 0.02545622f, -0.06039486f, -0.00113349f, 
    0.01084708f, 0.02204289f, 0.01982123f, -0.04218955f, -0.04495832f, 0.01349928f, -0.05743064f, 0.00430319f, 
    0.03575197f, -0.01863572f, 0.02801335f, 0.03348003f, -0.06024959f, 0.02479789f, -0.03134367f, 0.04587847f, 
    0.03246419f, 0.00227314f, -0.04067877f, -0.04019014f, 0.03463888f, -0.01919075f, -0.05368190f, 0.04086059f, 
    0.04824095f, -0.06047265f, 0.02494665f, -0.05079110f, -0.03746193f, 0.03125329f, 0.01192148f, 0.01890169f, 
    -0.03077057f, 0.03206170f, -0.04215729f, -0.02380647f, -0.03333619f, -0.01431077f, 0.03070495f, -0.05791336f, 
    -0.04853962f, 0.01533819f, -0.01842654f, -0.05945351f, -0.05531878f, 0.02903171f, 0.02656973f, 0.00598992f, 
    -0.03997216f, -0.00958715f, 0.04126951f, 0.00683358f, -0.03529394f, 0.01001253f, -0.04379574f, -0.01678753f, 
    0.02145830f, 0.02310924f, -0.00373470f, -0.01597912f, 0.01712398f, -0.01059814f, -0.01673976f, -0.03874063f, 
    -0.06076762f, 0.00704855f, -0.01250140f, -0.03524584f, -0.02553585f, -0.04002839f, 0.04370495f, 0.00768495f, 
    -0.03665867f, -0.00352637f, 0.01056194f, 0.03371961f, 0.02503143f, -0.00185943f, -0.01790425f, -0.00542001f, 
    0.02819297f, 0.00104538f, -0.03625131f, 0.03192693f, -0.02147607f, 0.03501221f, -0.02576269f, -0.02900562f, 
    -0.02517168f, 0.03763279f, 0.01317382f, -0.01514739f, 0.02638598f, 0.00296914f, -0.04133188f, -0.01604247f, 
    -0.02259143f, 0.03905740f, -0.00646351f, -0.03125372f, 0.02805691f, -0.01722090f, -0.02620418f, 0.02955627f, 
    -0.04275176f, -0.04092312f, 0.03181148f, -0.00773642f, -0.00852579f, 0.02184216f, -0.01434167f, -0.04472694f, 
    -0.05128531f, -0.01148095f, 0.01901727f, -0.04042083f, 0.02528352f, -0.06138634f, 0.00343190f, 0.04346468f, 
    0.03157064f, 0.02400795f, 0.02056872f, 0.00592924f, 0.02849442f, -0.01863256f, 0.03023324f, -0.01730791f, 
    -0.06157383f, 0.00416745f, -0.00712563f, -0.02007370f, 0.01600576f, 0.04489134f, -0.01447432f, 0.01570852f, 
    -0.04840096f, -0.02584485f, -0.03590420f, -0.03341371f, 0.03013876f, -0.02081259f, -0.06341770f, 0.01971792f, 
    -0.02271369f, -0.04151916f, -0.02539781f, -0.02765347f, -0.03222806f, 0.03657834f, 0.00047031f, -0.04564375f, 
    -0.00640951f, -0.04187619f, -0.05462547f, 0.02361720f, 0.01932553f, 0.02986343f, 0.01167616f, 0.01224601f, 
    0.01804717f, 0.02803806f, 0.02106720f, 0.00019777f, 0.04865744f, -0.01964580f, 0.00021054f, -0.00365041f, 
    -0.04543204f, -0.04692398f, 0.02507058f, -0.04785013f, -0.04500129f, 0.01123766f, 0.01918308f, -0.04740959f, 
    -0.05803631f, 0.00207711f, 0.01627636f, 0.01102574f, 0.04467204f, -0.02563625f, -0.02324769f, -0.01676508f, 
    -0.04618062f, -0.04505287f, -0.01942373f, -0.03316282f, 0.02232412f, -0.04989187f, -0.02080596f, 0.00542231f, 
    -0.02884504f, 0.04285859f, -0.02724210f, 0.01626632f, -0.03237946f, 0.03786934f, -0.04076936f, -0.04032368f, 
    -0.05252661f, -0.00878829f, 0.03383408f, 0.00708720f, 0.04514759f, -0.00730924f, -0.04275740f, -0.03526618f, 
    0.00154647f, 0.00828142f, -0.03982285f, 0.00291092f, 0.01891168f, 0.02637805f, 0.04099258f, 0.03686184f, 
    0.01245687f, -0.02850230f, 0.00565796f, -0.01676757f, -0.01213968f, -0.03337802f, 0.04472560f, -0.01283454f, 
    -0.01731141f, 0.00709861f, 0.02577825f, 0.03756176f, -0.04069834f, 0.02232127f, 0.03677280f, -0.02470775f, 
    0.01786336f, -0.04378186f, -0.04200632f, 0.05038060f, -0.04608353f, -0.02651776f, 0.03586559f, -0.01254813f, 
    0.02486412f, -0.03685894f, 0.01097434f, -0.01844522f, -0.04699668f, -0.01916374f, -0.02089791f, -0.05797285f, 
    0.02605245f, -0.00881068f, 0.02931743f, 0.03527460f, -0.06324545f, 0.02725967f, -0.00409465f, -0.00026222f, 
    -0.01696231f, 0.03055532f, -0.04315326f, -0.03912370f, -0.02856682f, -0.05122283f, 0.00133142f, 0.01183878f, 
    0.02138929f, -0.03254812f, 0.04284815f, -0.06432875f, 0.01004786f, -0.05233371f, -0.04300950f, 0.04282681f, 
    0.00863914f, -0.04412265f, -0.01766871f, -0.04569890f, 0.03115251f, 0.01793218f, 0.00346374f, -0.01792010f, 
    -0.00396364f, -0.03338815f, -0.05523112f, -0.00366973f, 0.02229749f, 0.04748455f, 0.00554208f, -0.01704373f, 
    0.03451853f, 0.04312021f, 0.00138106f, -0.00815677f, -0.00045242f, -0.02044780f, 0.00024305f, 0.01849320f, 
    0.01098321f, -0.05082798f, 0.00020337f, -0.03852477f, -0.03055698f, 0.00156332f, -0.05760298f, 0.01691557f, 
    -0.00484635f, -0.01172388f, 0.00530238f, 0.03750878f, 0.03338682f, 0.04154626f, -0.02258876f, 0.01221756f, 
    0.04762645f, 0.04207288f, -0.01885636f, -0.00864233f, 0.01108869f, 0.02828085f, 0.00285470f, 0.04890181f, 
    -0.05367201f, 0.00692812f, -0.05242838f, 0.02876266f, -0.04100116f, -0.02336177f, -0.01008877f, -0.04019946f, 
    -0.00559120f, 0.00001983f, -0.04255746f, -0.05687172f, -0.00691137f, 0.02873704f, 0.05105381f, 0.02373850f, 
    -0.02716020f, -0.04531897f, 0.01212298f, -0.05241375f, -0.05343240f, -0.01978945f, 0.00643094f, -0.00381209f, 
    0.03601998f, 0.00971004f, 0.01021922f, -0.03151945f, 0.03771963f, 0.04742756f, -0.02512805f, -0.06032160f, 
    0.01358759f, -0.03453630f, 0.00940117f, 0.01849350f, -0.06552487f, -0.01559336f, 0.02156774f, -0.00700735f, 
    0.05510015f, -0.04202349f, -0.06080714f, 0.00848997f, -0.00458311f, -0.05749988f, -0.01627658f, -0.05361519f, 
    -0.02208266f, -0.05685781f, -0.04298962f, 0.03718511f, -0.01158792f, 0.03989254f, 0.03557876f, 0.02047264f, 
    0.01987060f, 0.02557818f, 0.00662660f, -0.05844504f, 0.02825486f, -0.01087797f, 0.03486409f, -0.06084031f, 
    0.00749147f, -0.01173993f, 0.00346958f, -0.03085174f, 0.01667905f, -0.04657204f, 0.02767728f, -0.05212693f, 
    0.22948530f, -0.32575420f, 0.00487509f, 0.09263800f, 0.19872710f, -0.09530908f, 0.02623271f, -0.12742694f, 
    -0.08055198f, 0.14683709f, 0.09753986f, 0.00712238f, 0.02781128f, -0.00698363f, 0.18600662f, -0.05375151f, 
    0.05168619f, -0.02912868f, 0.10000288f, 0.07028069f, -0.27857685f, 0.20988563f, 0.20125937f, -0.09689514f, 
    0.07395887f, 0.05811134f, -0.12229224f, 0.07303987f, 0.03026809f, -0.10169329f, -0.01896546f, 0.02747083f, 
    0.08079191f, 0.06190111f, -0.02481422f, -0.02876947f, -0.10091266f, 0.10369337f, 0.02547192f, -0.01705417f, 
    0.09947418f, 0.09016968f, 0.15419120f, 0.25902805f, 0.40585014f, 0.08588754f, 0.04819588f, -0.08347213f, 
    0.01795208f, 0.05212634f, 0.01965262f, 0.27391973f, -0.03349081f, -0.00956749f, 0.00813774f, -0.02292242f, 
    -0.02241688f, -0.00917316f, 0.07501233f, -0.01733243f, 0.08825995f, -0.07562508f, -0.08596538f, 0.23578559f, 
    0.01320631f, -0.04194953f, 0.05299620f, -0.02717618f, 0.04744311f, -0.00310925f, 0.11372217f, 0.02103365f, 
    0.02774093f, 0.08735230f, -0.01030358f, 0.00949946f, 0.04094943f, -0.10522582f, 0.10000872f, 0.08374082f, 
    0.08834043f, -0.25734943f, -0.12008023f, -0.16154794f, -0.12429494f, 0.11180617f, 0.07082488f, -0.09316188f, 
    0.03221717f, -0.03061917f, -0.00922710f, -0.03506457f, -0.04113670f, 0.01141952f, 0.01939353f, -0.09867622f, 
    0.01275022f, 0.01382582f, 0.08091650f, -0.17355049f, -0.26976949f, -0.21545191f, -0.14598833f, -0.19291659f, 
    -0.07900953f, 0.17913637f, 0.07120102f, -0.02423089f, 0.08429318f, 0.08943959f, -0.00103475f, 0.01446195f, 
    0.01803095f, -0.00099959f, 0.03729292f, 0.00138454f, 0.00698434f, -0.01019357f, -0.02071179f, 0.12182481f, 
    -0.43488255f, 0.30957469f, -0.00664782f, -0.20576558f, 0.02430702f, 0.09732915f, 0.12886465f, 0.16674572f, 
    -0.16121303f, 0.05175174f, 0.00390704f, -0.05179887f, -0.01787269f, -0.01092630f, 0.01155666f, 0.07781006f, 
    0.04345007f, -0.01324490f, 0.01007781f, -0.00150203f, -0.26419118f, 0.01202247f, -0.12953277f, -0.10325176f, 
    -0.05315202f, 0.01428078f, -0.01968765f, 0.04456167f, 0.08631925f, 0.12087901f, 0.06342377f, 0.07110082f, 
    0.02538144f, 0.01558780f, 0.13264319f, -0.00722335f, 0.04166145f, 0.01477225f, 0.16026853f, 0.00312157f, 
    -0.27548435f, 0.17220128f, -0.01497763f, -0.14647855f, -0.03349490f, 0.13155317f, -0.08463533f, 0.04139621f, 
    0.06441563f, -0.09557173f, 0.13312794f, 0.04280050f, 0.15908694f, 0.08259238f, -0.11726121f, -0.05610925f, 
    0.07577909f, -0.08107634f, -0.08619487f, -0.08073188f, -0.05966553f, 0.11137221f, 0.16565281f, 0.30564898f, 
    0.05933294f, -0.09278168f, 0.00246437f, -0.12764281f, -0.01246271f, 0.03945480f, 0.05933651f, 0.03394273f, 
    -0.05719968f, 0.06562093f, 0.05508667f, 0.05318417f, -0.00963296f, -0.02958960f, 0.01685957f, 0.05847447f, 
    0.25808698f, 0.20384048f, -0.01632292f, 0.30773392f, -0.06190125f, 0.05403741f, 0.00387455f, 0.07243694f, 
    0.00570598f, 0.08886987f, 0.09655787f, 0.06342728f, 0.03838279f, 0.05648188f, 0.08645113f, 0.05321529f, 
    -0.00951611f, -0.10763550f, -0.07543080f, -0.04742464f, -0.22768158f, 0.20697616f, -0.17461763f, -0.01774372f, 
    -0.00874512f, 0.12580402f, 0.05551309f, 0.10341073f, -0.14725733f, -0.08541974f, 0.05630092f, -0.01484644f, 
    -0.04783700f, -0.02634789f, 0.07642303f, -0.10033363f, 0.10599807f, 0.00228297f, 0.03336531f, -0.00626212f, 
    -0.17226103f, 0.21169142f, 0.19456495f, 0.19775088f, 0.02618091f, 0.04023612f, 0.00448902f, -0.07195096f, 
    0.16128027f, 0.11143997f, 0.08672000f, -0.02389445f, -0.09596378f, 0.13049315f, 0.09683143f, 0.03434140f, 
    -0.00191961f, -0.07617836f, 0.01544399f, 0.00951160f, 0.25107574f, -0.07028183f, 0.09894709f, 0.21487480f, 
    -0.09459908f, -0.10901049f, 0.07614650f, -0.01224448f, 0.06040071f, -0.07586925f, 0.03809830f, -0.11527428f, 
    -0.03481174f, 0.16162549f, 0.06254514f, -0.03638623f, 0.02028367f, -0.04952696f, -0.02862194f, 0.07780565f, 
    -0.09220265f, 0.09877444f, -0.24455665f, 0.03137845f, -0.18166234f, 0.03698896f, -0.03909068f, 0.06293588f, 
    -0.03263477f, -0.12073132f, -0.02561990f, 0.09637949f, -0.00521460f, 0.07909987f, -0.00713818f, -0.02020757f, 
    -0.01797011f, 0.12710650f, -0.07257935f, -0.01511637f, -0.34957477f, 0.31844398f, -0.13751732f, 0.02109519f, 
    0.06719261f, 0.18603234f, 0.12638003f, 0.19419801f, 0.06244165f, 0.02039529f, -0.06249721f, 0.01953356f, 
    0.11010420f, -0.03895160f, 0.05292242f, 0.03985023f, 0.03800249f, 0.00429634f, 0.04691856f, 0.00916333f, 
    -0.05137127f, 0.54336017f, 0.07403579f, 0.04302702f, -0.34854728f, 0.18246193f, 0.18085253f, 0.12401554f, 
    -0.06899520f, -0.01310117f, 0.04851559f, -0.09037061f, 0.03408431f, 0.04485719f, 0.12561700f, -0.01467481f, 
    0.07283112f, 0.09584582f, 0.01483100f, 0.03389660f, 0.00846146f, 0.18577410f, 0.03551355f, -0.31290406f, 
    0.27692804f, 0.10776214f, -0.08720397f, -0.01544475f, -0.18555541f, -0.18310975f, -0.02588153f, 0.06864867f, 
    0.08880901f, -0.14728355f, -0.07375587f, -0.04734176f, -0.08993845f, -0.00683358f, -0.06647138f, 0.07215269f, 
    0.10069053f, 0.15044700f, -0.20355466f, -0.21195251f, 0.66650170f, 0.13458078f, -0.05007466f, 0.03948350f, 
    -0.00038150f, 0.07622050f, -0.06323438f, -0.06215538f, -0.01761547f, -0.01385029f, 0.20444131f, 0.16972102f, 
    0.05676187f, 0.15803032f, 0.11450925f, -0.04099832f, -0.20569058f, 0.33545068f, -0.02827929f, 0.21943660f, 
    0.03990326f, 0.12238469f, 0.13440447f, 0.04856730f, -0.05337461f, 0.01646817f, 0.08440714f, 0.01558284f, 
    -0.05515690f, 0.05707932f, -0.03731198f, 0.10336476f, 0.06906186f, 0.16563737f, 0.09824634f, 0.15849212f, 
    0.13222207f, 0.10973596f, 0.05436428f, 0.06521468f, -0.14616409f, 0.02541881f, 0.10376046f, 0.04510765f, 
    -0.05527579f, 0.05919169f, 0.02039973f, 0.02066026f, 0.10483874f, -0.13385433f, 0.04349685f, 0.09125529f, 
    -0.00819502f, -0.05917620f, 0.06770954f, -0.11329532f, -0.12319883f, -0.08649506f, 0.18675353f, 0.22696507f, 
    0.02761628f, -0.01592375f, 0.07744159f, 0.09514917f, -0.12683460f, 0.08813238f, -0.10792949f, -0.03021434f, 
    -0.04211248f, -0.00484212f, 0.05056300f, 0.01341626f, -0.07984035f, -0.04921170f, -0.05945425f, -0.22572871f, 
    -0.26271659f, 0.30627957f, -0.00779220f, 0.02181796f, 0.11758015f, 0.34577236f, 0.11517724f, 0.06102642f, 
    0.04113828f, 0.00738655f, 0.07041045f, 0.05885340f, 0.07808296f, -0.01872598f, -0.01240516f, 0.03312645f, 
    0.09568160f, -0.09226423f, 0.05300823f, 0.14439541f, 0.42324665f, -0.31104493f, 0.12364664f, 0.21468255f, 
    -0.46704870f, 0.17947163f, 0.14763975f, -0.00058700f, -0.13391855f, -0.00283581f, -0.02743684f, -0.02865373f, 
    0.05674177f, 0.17444177f, 0.08401972f, 0.04082047f, 0.02425049f, 0.07609906f, 0.04639458f, -0.02348774f, 
    0.41880238f, -0.27863160f, -0.20883659f, 0.25142375f, 0.03922975f, 0.07580484f, 0.15830603f, -0.15201752f, 
    0.11042392f, 0.10129696f, 0.02595224f, 0.06365297f, -0.03127920f, 0.12525612f, 0.04916636f, 0.00628997f, 
    0.05789111f, -0.01871257f, -0.01295630f, -0.08418822f, 0.31673658f, -0.19602439f, -0.03236217f, 0.00427810f, 
    0.21266417f, -0.24059010f, -0.05458886f, -0.10284169f, -0.05722457f, -0.07912929f, -0.03015363f, -0.01533054f, 
    0.05831078f, 0.03066356f, 0.17874968f, -0.00561135f, 0.11417209f, 0.09580380f, 0.13846922f, 0.14857563f, 
    -0.08402237f, 0.27583244f, -0.08090466f, 0.01260993f, -0.42914259f, 0.10363988f, 0.24436398f, 0.00112958f, 
    0.03990423f, 0.05618926f, 0.09114005f, 0.03242152f, 0.20656095f, -0.00205446f, -0.01726646f, -0.05246467f, 
    0.02256081f, -0.03380963f, -0.10170245f, 0.00570235f, -0.47535932f, -0.05995622f, -0.01386179f, 0.05973533f, 
    0.08850951f, 0.14901531f, 0.24964994f, 0.03097826f, -0.01599417f, 0.20101734f, 0.12231348f, 0.07781020f, 
    -0.04529465f, -0.16525815f, -0.08456019f, 0.01299521f, 0.09601322f, -0.04950071f, 0.03456466f, -0.15943019f, 
    0.60401911f, -0.26559365f, 0.17239082f, 0.23896724f, -0.36861232f, -0.04838923f, -0.08088935f, 0.00042529f, 
    -0.05912415f, 0.07629845f, -0.01033141f, 0.10927351f, 0.16703145f, -0.03479433f, 0.11036864f, 0.11464841f, 
    0.06814977f, 0.11723089f, 0.01600968f, 0.03948304f, 0.00939982f, -0.01859926f, 0.01159551f, 0.24628121f, 
    -0.20661101f, 0.04865442f, 0.11917720f, -0.01449701f, 0.03455298f, 0.06999272f, -0.04169763f, -0.11187930f, 
    0.11154038f, 0.05748565f, -0.14326793f, -0.09617002f, -0.01322074f, -0.06943046f, 0.09316879f, 0.08718035f, 
    -0.12667172f, -0.21253558f, -0.05913183f, -0.14933074f, 0.59760660f, -0.04538564f, 0.01495872f, 0.09015369f, 
    0.15833105f, 0.11994652f, -0.04062246f, -0.02103783f, -0.00664332f, 0.02232123f, 0.01385622f, 0.03140563f, 
    0.08689505f, 0.12200274f, 0.01570871f, 0.00093291f, 0.09429272f, -0.06758653f, -0.07205974f, -0.29751918f, 
    0.38401148f, -0.03342488f, 0.14319162f, -0.09881128f, -0.11289628f, -0.10088944f, -0.01602538f, -0.00063104f, 
    0.07874466f, 0.10645577f, -0.04831845f, 0.06114848f, 0.01795414f, -0.08676100f, -0.00695141f, -0.03620977f, 
    -0.34465349f, -0.17518516f, -0.24581747f, 0.01223048f, 0.06289480f, 0.20942049f, 0.15971887f, 0.02575981f, 
    0.05805283f, -0.21300879f, 0.06070508f, 0.00153932f, -0.04247018f, 0.04743031f, -0.12830894f, 0.00394310f, 
    -0.01779830f, -0.01201245f, -0.06835852f, -0.12932368f, 0.27496952f, 0.09722343f, 0.21713825f, -0.11679936f, 
    -0.16908689f, -0.04287985f, -0.05966611f, -0.06578082f, 0.04089063f, 0.17760056f, 0.10169177f, -0.06405752f, 
    -0.03536027f, 0.19839315f, 0.12278623f, -0.04620712f, 0.02420162f, 0.08296885f, -0.02881191f, -0.01118908f, 
    -0.11813136f, 0.34207913f, 0.35967872f, -0.05119830f, -0.26887915f, -0.11958126f, 0.13042176f, -0.02813546f, 
    0.02312367f, 0.04253441f, 0.03960910f, -0.04013979f, 0.14337048f, -0.04497934f, 0.05153028f, 0.04352225f, 
    0.08841843f, 0.00538476f, -0.03652129f, -0.00146979f, 0.12331241f, 0.10073280f, -0.09909534f, -0.03694708f, 
    0.05839775f, 0.01516830f, 0.05208794f, 0.06191754f, 0.01244669f, 0.09019366f, 0.00580807f, -0.02125417f, 
    0.05051156f, 0.11007562f, -0.02828515f, 0.16611049f, 0.12213788f, 0.12945749f, -0.04849379f, 0.10720520f, 
    -0.43917200f, -0.21913226f, 0.06806248f, 0.14370672f, 0.00354847f, 0.02150351f, 0.02390145f, 0.03406347f, 
    -0.09148228f, -0.05412161f, -0.01015288f, -0.09901877f, -0.08551221f, 0.03314990f, -0.03059214f, 0.14366451f, 
    0.00380066f, 0.03878896f, 0.03542582f, -0.03176562f, 0.11784852f, -0.04511753f, 0.06383102f, 0.11798456f, 
    0.00026113f, -0.07931037f, -0.05002502f, 0.00524171f, 0.04212658f, -0.04326653f, 0.11641160f, -0.06711236f, 
    0.10549989f, -0.02376317f, 0.00137016f, 0.14294489f, 0.02968282f, 0.03216113f, 0.09025677f, 0.00730916f, 
    0.41337305f, -0.44509143f, -0.02898933f, 0.03274185f, -0.03325206f, -0.14513183f, -0.07747038f, 0.06867911f, 
    0.00209766f, -0.00418993f, 0.03818083f, 0.02921726f, 0.01428825f, 0.04096268f, 0.13047872f, -0.02699997f, 
    -0.02411281f, 0.01879179f, 0.08469727f, 0.14137577f, -0.11192336f, 0.09330733f, -0.18822223f, 0.06470593f, 
    0.09231851f, 0.00506125f, 0.03405982f, -0.07080846f, 0.04077516f, -0.06654743f, -0.08932202f, 0.00208019f, 
    -0.02193642f, -0.04451521f, -0.11622383f, 0.04774276f, 0.03105585f, -0.06681816f, 0.06750768f, 0.06641026f, 
    0.09463974f, -0.10164710f, -0.00246727f, 0.07956512f, -0.01298561f, -0.01596966f, -0.03494780f, -0.07704177f, 
    0.01419311f, -0.03651632f, 0.03033750f, -0.03706894f, -0.03705669f, 0.04835683f, 0.08989993f, 0.01790892f, 
    -0.11397311f, 0.08007085f, -0.04497548f, 0.03383854f, 0.20488583f, 0.38654724f, -0.02584783f, -0.12797369f, 
    0.02553109f, 0.21739271f, 0.06637567f, 0.12879547f, 0.04500090f, -0.02485970f, -0.13366111f, 0.00519903f, 
    0.09826121f, -0.11549692f, -0.02705424f, 0.07773478f, 0.07419748f, 0.10732232f, 0.05018117f, -0.02800867f, 
    -0.32920742f, -0.12837903f, -0.22145240f, -0.01488788f, 0.22710045f, 0.03748014f, 0.13581020f, -0.11303514f, 
    -0.06147993f, -0.02149472f, 0.10850564f, -0.14596421f, -0.04835922f, 0.07434101f, -0.00644055f, -0.01172469f, 
    -0.00854880f, 0.01830105f, 0.09904393f, 0.07393450f, 0.22398210f, 0.03335242f, -0.15863983f, 0.04310480f, 
    -0.16463634f, -0.10952704f, -0.04415612f, -0.07001225f, 0.09961557f, 0.06693151f, -0.16300938f, -0.07036295f, 
    0.05540277f, 0.04689807f, 0.02678358f, 0.01087332f, 0.00678314f, -0.11544880f, 0.04601075f, 0.03188256f, 
    -0.34519729f, 0.16410805f, -0.10182761f, -0.13900031f, -0.01320460f, 0.11341944f, 0.07981427f, -0.03965084f, 
    -0.08023426f, -0.03812944f, -0.05727851f, 0.08971931f, 0.00111435f, 0.08439840f, -0.01003091f, 0.04517882f, 
    0.10032292f, -0.00865815f, 0.14561859f, -0.02309130f, 0.33047569f, 0.24905945f, -0.30742344f, -0.00971588f, 
    0.06334154f, 0.15430321f, 0.05855707f, 0.11220627f, 0.06062572f, 0.03989673f, 0.06956394f, 0.15835902f, 
    0.02174369f, -0.09091847f, -0.06318317f, 0.15712126f, 0.01786152f, -0.00902604f, 0.14075597f, 0.01145415f, 
    -0.07027407f, 0.21847177f, 0.15396272f, -0.05108349f, -0.03233635f, -0.04346976f, 0.10554637f, 0.06275253f, 
    -0.00566792f, 0.06920406f, 0.06419506f, 0.09780507f, 0.04760557f, -0.04654933f, -0.10097464f, -0.01356616f, 
    -0.01152932f, -0.07385509f, 0.13071480f, 0.06126358f, 0.55380660f, -0.16276652f, 0.11669818f, 0.02225698f, 
    -0.30207986f, -0.27684784f, -0.25204131f, 0.11461240f, 0.02215049f, 0.04939296f, -0.01548003f, 0.03572850f, 
    0.08242085f, -0.11029818f, 0.08493836f, -0.12518501f, -0.04623904f, -0.04242844f, -0.01919420f, -0.07779399f, 
    0.04259324f, -0.00997072f, -0.02363483f, 0.02659304f, 0.03427821f, -0.05470268f, 0.03892348f, -0.03120675f, 
    0.00707030f, -0.04785942f, 0.04194910f, 0.03306409f, -0.03589775f, 0.02601043f, 0.02673853f, 0.03598558f, 
    0.00591605f, -0.04258739f, 0.02140118f, -0.05832615f, -0.00273463f, -0.00010766f, 0.02741874f, 0.00656481f, 
    0.01555262f, -0.03663640f, 0.00912351f, 0.00689007f, 0.00392374f, -0.06025603f, -0.04814201f, -0.03043290f, 
    0.04945562f, -0.02621338f, -0.02245080f, 0.03949851f, -0.05462668f, 0.03193635f, -0.02525628f, -0.04392884f, 
    0.05404593f, 0.01375639f, -0.04228636f, 0.03636825f, -0.04678271f, -0.03128850f, 0.01244886f, -0.03470896f, 
    -0.01088679f, 0.01514817f, -0.03580978f, -0.00244202f, 0.03414011f, -0.00246956f, -0.05630859f, 0.02628996f, 
    -0.03151281f, 0.01016207f, -0.04824657f, -0.00474654f, -0.05869482f, -0.01904132f, -0.04932049f, 0.02879836f, 
    0.03125301f, -0.05442168f, 0.03444549f, -0.00187609f, -0.06585154f, -0.00331532f, -0.02196486f, 0.03705729f, 
    -0.02529994f, -0.03962062f, -0.04950687f, -0.04748586f, 0.01511018f, -0.01304775f, 0.00284544f, 0.03091259f, 
    0.03311862f, 0.00596374f, 0.05679486f, 0.04928061f, 0.02774109f, 0.03009756f, 0.03684724f, -0.04863763f, 
    0.04961035f, 0.01271816f, -0.04542803f, 0.04292550f, 0.02802301f, 0.05461523f, -0.01717970f, 0.01589734f, 
    0.02194945f, 0.02086123f, 0.03014505f, -0.03243897f, 0.02907832f, -0.02971027f, -0.03890261f, -0.03718649f, 
    -0.04227407f, -0.06063962f, -0.05571652f, 0.04390981f, -0.00296216f, 0.04371496f, 0.02469466f, -0.03724472f, 
    0.03317898f, 0.04262052f, -0.02633210f, 0.03489228f, -0.03386351f, -0.03522587f, -0.05845553f, -0.05929459f, 
    0.01387198f, -0.03374101f, 0.02314975f, -0.04757633f, 0.02231269f, 0.00561871f, -0.02907971f, 0.00814736f, 
    0.02054177f, -0.05969696f, 0.04869157f, -0.02569254f, 0.01094304f, 0.05015338f, 0.03377769f, 0.00936816f, 
    0.04716419f, 0.00867113f, -0.00306850f, -0.03729373f, 0.02751389f, -0.05483178f, 0.05438431f, 0.01663182f, 
    0.03207522f, -0.00264852f, 0.01928480f, -0.04268477f, -0.05675034f, 0.01523528f, 0.03054623f, -0.03464958f, 
    -0.03044009f, 0.00058694f, 0.01180261f, -0.01673354f, -0.06141476f, -0.01861028f, -0.03641506f, -0.02645331f, 
    -0.04748270f, 0.02316372f, 0.02947107f, -0.03707596f, -0.00779704f, -0.03600835f, 0.01822997f, 0.03543481f, 
    -0.05305875f, 0.03583175f, 0.02066115f, 0.01823279f, 0.01243581f, -0.03842792f, 0.03138556f, -0.00124743f, 
    0.02119862f, 0.02491428f, -0.02329686f, -0.00853616f, 0.00901286f, 0.02105580f, -0.06495985f, -0.02042012f, 
    0.00256276f, -0.02356761f, -0.01561951f, -0.03068281f, -0.00121982f, 0.03955832f, -0.01919893f, 0.02367284f, 
    -0.04288530f, 0.05366485f, -0.03828866f, -0.00391552f, -0.01685604f, 0.03081901f, -0.04563677f, -0.05551226f, 
    -0.03289741f, -0.02603127f, -0.00072903f, 0.04285783f, 0.02034916f, 0.01713002f, -0.06143457f, -0.00316998f, 
    -0.06131229f, 0.01251102f, -0.04135263f, 0.02099412f, -0.00331858f, -0.02424546f, -0.01821442f, 0.01810349f, 
    -0.00624127f, 0.04849179f, -0.00469177f, 0.02155763f, 0.00674985f, -0.00230421f, 0.01267581f, -0.00733711f, 
    0.08283561f, 0.01031192f, -0.06792162f, 0.02112448f, 0.03146265f, -0.02180285f, -0.04289967f, -0.01249011f, 
    -0.04964740f, 0.05757936f, -0.03879869f, 0.03764135f, -0.04063808f, -0.00033939f, -0.02966131f, -0.03237259f, 
    0.03198689f, 0.00534361f, 0.02390795f, -0.03307595f, 0.00044479f, 0.02685868f, 0.01282588f, -0.01613165f, 
    -0.03229696f, -0.04177985f, 0.00391021f, -0.00679326f, 0.00613060f, -0.00355128f, -0.00706684f, -0.05978541f, 
    0.01206580f, 0.02774673f, 0.01285698f, -0.03846239f, -0.00518076f, 0.01215315f, 0.03872641f, 0.00460103f, 
    -0.02788378f, -0.02085221f, 0.02015064f, -0.04027041f, -0.03587658f, -0.01129049f, 0.00253318f, 0.01763738f, 
    -0.03816250f, -0.04822617f, 0.04393065f, -0.06953201f, -0.05156789f, -0.00051056f, 0.00767872f, 0.03742154f, 
    0.00569880f, 0.03826223f, 0.03299280f, 0.04292020f, 0.01239664f, 0.00422367f, -0.06177889f, 0.03474324f, 
    0.03247517f, -0.02814585f, -0.06339491f, -0.04302126f, -0.05121172f, -0.04563320f, -0.03122123f, -0.04996417f, 
    -0.02582229f, 0.04323775f, 0.02567573f, -0.02152193f, -0.00673275f, -0.01327392f, -0.01291013f, 0.01110974f, 
    -0.06302101f, -0.01175410f, 0.04075572f, -0.04916268f, -0.00267852f, -0.02892923f, -0.00989972f, -0.02908701f, 
    -0.03585469f, -0.01466059f, -0.04975806f, -0.06246239f, -0.04668577f, 0.02363452f, 0.01832013f, 0.01113332f, 
    0.66186190f, -0.26726127f, -0.07140899f, 0.10215101f, 0.34643438f, -0.07207425f, 0.10098498f, 0.04567847f, 
    0.04310443f, 0.14089958f, 0.17507464f, 0.06858981f, -0.02487647f, -0.17978798f, 0.04913757f, -0.00067343f, 
    0.01661434f, 0.05954522f, 0.15290147f, -0.02263378f, -0.27421072f, -0.08874717f, -0.04804273f, -0.18442069f, 
    -0.05844194f, -0.01034875f, -0.08343102f, -0.00038408f, 0.07383174f, -0.06336591f, 0.03611118f, 0.07183387f, 
    0.09310369f, 0.09708733f, 0.04143483f, 0.06402858f, 0.08182972f, 0.08681998f, 0.14404607f, 0.02429973f, 
    -0.14442773f, -0.22345714f, 0.02559227f, -0.12225986f, 0.01710097f, -0.09117988f, 0.01635957f, 0.03091971f, 
    0.02425453f, -0.01881604f, -0.04220387f, 0.06405836f, 0.00490552f, 0.03730633f, -0.02549166f, -0.08053043f, 
    0.04053047f, 0.13800862f, 0.05911312f, 0.00474046f, 0.23016435f, -0.01998535f, -0.18508898f, 0.07696787f, 
    -0.23560667f, 0.03729649f, -0.02635084f, -0.14316046f, -0.00406050f, -0.15586193f, 0.04260132f, 0.00142590f, 
    0.00346649f, -0.09048757f, 0.02790418f, -0.06276060f, -0.07691152f, -0.05081357f, -0.07125140f, -0.07395595f, 
    0.62077135f, -0.01948470f, -0.16697887f, 0.01029703f, 0.25985166f, 0.04242750f, 0.03673754f, -0.11864194f, 
    0.12384367f, -0.04307561f, 0.12744322f, 0.03443776f, -0.01446094f, 0.03339304f, -0.12840000f, 0.00152063f, 
    0.17778778f, 0.07254017f, 0.03303891f, -0.12421940f, -0.10517434f, -0.14981671f, -0.19165339f, -0.13524348f, 
    -0.09289331f, 0.24285211f, 0.06301192f, -0.03584370f, 0.15703736f, 0.12093003f, 0.02001555f, 0.02828756f, 
    0.03962298f, -0.01445628f, 0.00956298f, 0.00173438f, -0.06623866f, 0.05422578f, -0.03841516f, -0.20058563f, 
    -0.26762116f, 0.49305576f, -0.06141392f, 0.08239156f, -0.33809513f, 0.09978960f, -0.06986270f, 0.07926953f, 
    0.03759659f, 0.17144328f, -0.05034485f, -0.11377860f, 0.00664368f, -0.00358755f, -0.00704224f, 0.05042253f, 
    0.01413031f, -0.01433142f, 0.01502721f, -0.03589291f, 0.39429513f, 0.07602914f, -0.01198444f, 0.17785212f, 
    0.16583432f, -0.01043610f, -0.10571080f, 0.03093813f, 0.06862671f, 0.01084579f, -0.00434599f, 0.02183850f, 
    0.00733591f, -0.09771633f, -0.04669004f, -0.05895014f, -0.02506404f, -0.08986695f, 0.02593917f, -0.00070848f, 
    -0.10418680f, 0.02680813f, 0.12343936f, -0.14906226f, 0.03115547f, -0.01157746f, 0.00530453f, 0.13779074f, 
    0.00578318f, -0.03976518f, -0.05283795f, -0.01709382f, 0.06949303f, 0.02022537f, -0.05821257f, 0.09077439f, 
    0.04219797f, -0.17023198f, -0.01868041f, -0.07955024f, -0.39379147f, -0.20198806f, -0.12634164f, 0.04303945f, 
    -0.11985639f, -0.06248674f, 0.16180722f, 0.05768191f, 0.05368249f, -0.06336634f, 0.08839113f, 0.03655635f, 
    0.00780208f, 0.01981775f, -0.06946557f, 0.03817371f, -0.09715992f, 0.00259415f, -0.02217229f, -0.06007561f, 
    0.48666057f, -0.01525884f, -0.16683283f, 0.22024763f, 0.11744145f, -0.01588097f, 0.04078001f, 0.00148221f, 
    0.07494630f, 0.01068962f, 0.11325496f, -0.06628409f, 0.08368197f, 0.07063522f, 0.08449464f, -0.04854511f, 
    0.23061553f, 0.05316297f, 0.04462881f, 0.03973518f, 0.21659203f, 0.05167061f, -0.02331936f, 0.17861366f, 
    0.05010706f, 0.13106211f, 0.04254244f, 0.09273589f, -0.06197169f, 0.04463093f, 0.00920248f, -0.08584929f, 
    0.01376793f, 0.04952992f, -0.02492570f, 0.05031851f, 0.08686955f, 0.02798971f, -0.04503685f, 0.03246921f, 
    -0.19031215f, 0.17885311f, 0.22807518f, -0.01663159f, 0.15361303f, -0.10287765f, 0.03272060f, 0.12222888f, 
    0.16099562f, -0.08246742f, -0.00007333f, 0.01393868f, -0.05099681f, -0.03812727f, 0.03851125f, 0.07087559f, 
    -0.11252581f, -0.15017566f, 0.11569380f, -0.03507230f, 0.22199017f, 0.06934018f, 0.05308860f, 0.01129945f, 
    0.08543056f, 0.00060935f, 0.10567833f, 0.04374629f, -0.01606688f, -0.04668136f, 0.07965170f, -0.06211226f, 
    0.00160496f, 0.08381512f, 0.20786659f, 0.04587239f, -0.19946383f, 0.10422511f, -0.04959159f, 0.02334067f, 
    0.15193780f, 0.08033243f, -0.10153048f, 0.05556345f, -0.29861125f, 0.15386924f, -0.06611942f, 0.04180498f, 
    0.00066460f, -0.07811705f, 0.01861267f, -0.02441231f, 0.02252147f, 0.09036619f, 0.04179987f, 0.00459781f, 
    0.10099073f, 0.05655945f, 0.02655095f, -0.00841810f, -0.32957390f, 0.04057109f, 0.07916822f, 0.07748714f, 
    -0.00137449f, 0.15707123f, -0.07470357f, 0.00238023f, 0.03037357f, 0.04814448f, 0.03870584f, -0.02207082f, 
    0.05989814f, 0.07245310f, 0.16242604f, -0.06809776f, 0.00016745f, 0.05984525f, 0.02037297f, -0.01854255f, 
    0.25997329f, -0.16768956f, -0.28888112f, -0.12809139f, 0.18207748f, 0.13785177f, 0.06515423f, -0.13661554f, 
    -0.00798348f, 0.03166746f, -0.03460880f, 0.00574235f, 0.08842585f, 0.08646321f, -0.03709338f, -0.01979692f, 
    0.05856575f, 0.02219987f, -0.00864697f, -0.03636855f, 0.05519278f, 0.02925725f, 0.36349061f, 0.20213191f, 
    0.09705360f, -0.08179644f, 0.07686044f, -0.01054022f, -0.02154327f, 0.17247441f, 0.03828139f, -0.02285643f, 
    -0.07194299f, 0.15463763f, 0.03831642f, 0.03376722f, 0.01992053f, 0.06185629f, 0.00138222f, -0.14511122f, 
    0.00104181f, 0.04901069f, 0.09971639f, 0.15755166f, 0.20585956f, -0.04396306f, 0.09818668f, -0.03353316f, 
    -0.04493760f, 0.01222559f, -0.02826436f, 0.04184337f, 0.17942497f, 0.07840350f, -0.00721236f, -0.06195328f, 
    0.21418038f, -0.22482197f, -0.10814448f, -0.05800136f, 0.05839409f, 0.11451837f, -0.08269817f, -0.02683591f, 
    0.10871059f, 0.08250862f, -0.04823333f, 0.00850872f, 0.14416291f, 0.10968972f, 0.01246690f, 0.08679195f, 
    0.04672809f, 0.04496519f, -0.05275070f, 0.04223878f, 0.04172904f, 0.02082724f, 0.03009746f, 0.11435650f, 
    0.17877442f, -0.44880456f, -0.16552289f, -0.11212534f, -0.06010075f, 0.08886696f, -0.07297377f, -0.01763585f, 
    0.01269120f, -0.07164910f, 0.08653402f, -0.08947749f, -0.03115765f, 0.00567253f, -0.02289901f, 0.01360798f, 
    0.01703476f, 0.09415604f, -0.05905014f, 0.03789203f, 0.08649494f, 0.10204590f, -0.09854830f, -0.09600831f, 
    -0.12115508f, 0.06102533f, 0.07285260f, 0.13255520f, 0.01303862f, -0.13544233f, 0.08516900f, 0.13499276f, 
    -0.09272096f, -0.02135926f, -0.12468174f, -0.10075707f, 0.04459718f, 0.13999133f, 0.09205699f, 0.24799797f, 
    0.04628362f, 0.04206962f, 0.10389924f, 0.13891138f, -0.11560831f, -0.16950172f, -0.00129289f, -0.01522677f, 
    0.00540146f, 0.04445651f, -0.04702983f, 0.12588604f, -0.16184750f, 0.02536254f, 0.16184714f, -0.07679946f, 
    -0.08316354f, 0.06563578f, -0.05603116f, 0.05206834f, 0.12083526f, -0.12549920f, -0.14899586f, -0.05184448f, 
    -0.03978266f, -0.00623266f, 0.04323082f, 0.06860155f, 0.06165677f, -0.06229731f, -0.04501049f, 0.10538982f, 
    -0.01098135f, 0.00206954f, -0.02357712f, -0.03233220f, 0.07226997f, 0.03060414f, 0.04997280f, 0.08533345f, 
    -0.39935097f, 0.25151029f, 0.40702957f, -0.01158060f, 0.10170735f, 0.04605680f, 0.04980457f, -0.03750236f, 
    -0.01474928f, -0.09021679f, -0.03680978f, 0.03723311f, 0.05144840f, 0.00049617f, 0.00515903f, -0.05478914f, 
    0.10665009f, -0.01951237f, 0.08499897f, 0.02934378f, -0.01946274f, 0.17159104f, -0.13486888f, -0.07262452f, 
    -0.14455001f, 0.06120203f, -0.00938789f, 0.08306229f, 0.10250838f, -0.08614118f, -0.01365371f, 0.01198509f, 
    0.06176320f, 0.02670725f, -0.10394677f, 0.03979246f, 0.00260407f, -0.02850896f, -0.06814246f, 0.13128798f, 
    -0.03304334f, 0.04215785f, 0.09048596f, -0.12221631f, 0.28885019f, 0.13268360f, -0.12837096f, -0.16025612f, 
    -0.01364582f, -0.03923167f, 0.02010797f, -0.06175511f, 0.06525382f, 0.06509986f, -0.00100163f, 0.03554183f, 
    -0.03706814f, -0.14912954f, 0.09334043f, -0.10428972f, 0.04130160f, 0.24144311f, -0.07796660f, 0.08041828f, 
    -0.03322664f, -0.11401428f, -0.03691244f, -0.03010621f, -0.00355858f, -0.07976452f, 0.04436252f, -0.02005206f, 
    0.02127446f, -0.09859136f, 0.06968313f, -0.04584464f, 0.12762235f, -0.13018213f, 0.07523862f, 0.00293982f, 
    -0.17014380f, 0.11696763f, -0.04810682f, -0.03707606f, 0.01635304f, 0.03972593f, 0.07962943f, -0.19722815f, 
    0.00779805f, 0.00142972f, 0.04796695f, 0.05469157f, -0.01883653f, 0.08276217f, 0.00829816f, 0.01946053f, 
    0.04439247f, -0.11756214f, -0.07902030f, 0.05817976f, 0.19112168f, 0.28712645f, -0.35602316f, -0.14626017f, 
    0.03849526f, 0.06583703f, -0.10562826f, 0.03821816f, 0.19009371f, 0.01970094f, 0.16108814f, 0.15131256f, 
    0.04674388f, -0.05495921f, 0.00230278f, 0.16938663f, 0.05798748f, -0.13866529f, 0.07449637f, -0.03581492f, 
    0.08463298f, 0.17083260f, 0.09331801f, 0.15362914f, -0.27139518f, -0.01930365f, 0.08736722f, -0.04519266f, 
    0.02495210f, 0.02588576f, 0.08092012f, 0.14796378f, 0.08071051f, 0.00520033f, 0.03759402f, -0.00806013f, 
    0.01936003f, -0.09145209f, 0.12241319f, -0.15010259f, 0.23853070f, 0.23340571f, 0.09957367f, 0.27602333f, 
    -0.12255558f, 0.11391635f, -0.01812187f, 0.11348142f, -0.03072665f, 0.04879598f, -0.02420796f, -0.02209638f, 
    0.00095126f, -0.23403503f, 0.01065902f, -0.09032171f, -0.01422538f, 0.04852077f, -0.05320746f, 0.01048221f, 
    -0.01117981f, 0.05049693f, -0.11357828f, -0.03660009f, 0.09707495f, -0.10852314f, -0.08629943f, -0.11271186f, 
    -0.05246129f, -0.08591595f, -0.18097976f, -0.21284445f, 0.09407359f, 0.03509575f, -0.00376978f, -0.07957891f, 
    0.00942189f, 0.03506170f, -0.03185420f, 0.00815948f, -0.04588483f, 0.13519934f, 0.22486128f, 0.09189958f, 
    0.27975836f, 0.18272607f, 0.11089362f, 0.15671514f, -0.10717065f, 0.10172740f, 0.12134323f, 0.15541017f, 
    0.00818110f, 0.15021692f, -0.09218896f, 0.09832109f, 0.02274048f, 0.02121728f, -0.12844488f, -0.08938014f, 
    0.09465724f, 0.15520613f, 0.12894835f, 0.47079274f, 0.41187987f, 0.10922565f, 0.12274551f, -0.00397895f, 
    0.05661008f, -0.01776668f, 0.05626104f, 0.04108723f, 0.03239516f, 0.04118754f, 0.20790471f, 0.00919523f, 
    0.03478161f, -0.02929452f, -0.24739926f, -0.02704530f, 0.01365084f, 0.06490117f, 0.00577037f, 0.05489978f, 
    0.06766257f, -0.17026564f, -0.15788725f, 0.11104290f, 0.03814032f, 0.15310127f, 0.14076196f, -0.02573804f, 
    0.04085480f, 0.03157521f, -0.06152488f, 0.04360774f, -0.00969057f, -0.08452075f, 0.10155734f, -0.00257667f, 
    -0.10355210f, -0.25122666f, -0.13146582f, 0.11460058f, 0.09584834f, -0.09330767f, -0.11987422f, 0.04030729f, 
    -0.11780386f, -0.20129281f, 0.10531675f, -0.08658750f, -0.08450149f, -0.08184151f, 0.01726967f, 0.07037150f, 
    -0.14665680f, 0.04948769f, -0.06246734f, 0.09030312f, -0.05950583f, -0.00779220f, 0.01354359f, -0.15557395f, 
    -0.18630838f, -0.14876625f, -0.09405331f, 0.07778577f, -0.07572707f, -0.13241513f, 0.01261318f, -0.05337747f, 
    -0.24991040f, -0.09992895f, -0.08742888f, 0.03771050f, 0.01535416f, 0.02977237f, 0.17495763f, 0.25717330f, 
    -0.03935838f, 0.09573188f, 0.08318572f, -0.36457092f, 0.10483788f, -0.06375236f, 0.15214358f, 0.04138094f, 
    -0.00358794f, -0.04906735f, 0.08405213f, 0.02556084f, -0.19488366f, 0.03773026f, 0.10842871f, -0.06754676f, 
    0.04302138f, 0.14788909f, -0.03919119f, -0.01628684f, -0.14180662f, -0.29480037f, -0.04215337f, -0.04848045f, 
    -0.16643935f, -0.06775502f, 0.00118026f, 0.00809573f, -0.01705095f, -0.22318849f, -0.07125880f, -0.04738261f, 
    -0.05585742f, -0.02406042f, 0.00605368f, 0.11864612f, 0.02019309f, -0.02284265f, 0.08060120f, 0.04632846f, 
    -0.48412398f, 0.25089592f, 0.15558608f, 0.01597174f, -0.20232415f, -0.04097267f, 0.01729988f, -0.04230019f, 
    -0.13788317f, -0.03728249f, 0.11066681f, -0.04136819f, 0.02724231f, -0.02004710f, -0.04593614f, 0.11990823f, 
    0.10200541f, 0.14011821f, 0.06610005f, 0.06625276f, 0.02822622f, 0.20299950f, 0.11714529f, 0.22931811f, 
    -0.07412706f, -0.00210698f, -0.17449754f, -0.09598131f, -0.02484987f, 0.08001196f, -0.05947482f, 0.07377251f, 
    0.19219688f, 0.09377678f, 0.04571385f, -0.09725507f, -0.05966501f, -0.01908363f, -0.04678721f, 0.06015500f, 
    0.15438646f, 0.22136086f, 0.30358264f, 0.08955387f, 0.08083498f, 0.06608122f, -0.14935699f, 0.01433034f, 
    0.00569184f, 0.04655704f, 0.00173409f, 0.04540801f, -0.04155803f, 0.09592114f, -0.04775522f, 0.08739661f, 
    -0.01342874f, -0.12584545f, 0.00004308f, -0.11173436f, -0.15832569f, 0.16056021f, -0.00254334f, -0.10870551f, 
    -0.18679696f, -0.05211126f, -0.07942747f, 0.10025840f, -0.12804253f, 0.00904078f, 0.01028760f, 0.08203548f, 
    -0.11105118f, -0.14026250f, -0.01020037f, 0.00321693f, 0.26370966f, 0.04963006f, 0.20525444f, 0.04670280f, 
    0.05621555f, -0.05166494f, -0.02042549f, 0.00119822f, -0.08183193f, 0.01546327f, -0.05606390f, -0.12283567f, 
    -0.05424973f, -0.01117594f, 0.06157929f, -0.02964509f, 0.09214252f, 0.08783446f, 0.03433234f, -0.11196362f, 
    0.11565552f, 0.08323699f, -0.05092497f, -0.09166867f, -0.20621480f, 0.17934558f, 0.05501848f, 0.09310101f, 
    -0.37145361f, -0.15001793f, -0.13549450f, 0.03076303f, 0.02872973f, 0.05211457f, -0.07412203f, 0.04147867f, 
    0.01178482f, -0.06743956f, -0.18399148f, 0.04631230f, 0.27186531f, -0.11657384f, 0.01124880f, -0.00591850f, 
    -0.04035211f, 0.14953211f, 0.04357249f, 0.03414278f, -0.10695162f, -0.11374331f, 0.00995229f, 0.00756025f, 
    -0.01947203f, 0.08555701f, -0.02241968f, 0.10808778f, -0.07305743f, -0.05637498f, 0.06471309f, -0.01128330f, 
    0.00524533f, 0.00960509f, 0.13690569f, -0.09602541f, -0.12753221f, 0.34202141f, 0.01323767f, -0.04073903f, 
    0.00748195f, 0.16388187f, 0.29549351f, 0.25902149f, -0.02212322f, 0.07589155f, -0.00694098f, 0.06404630f, 
    0.05444702f, -0.18190908f, 0.05005357f, 0.04261120f, 0.10050020f, -0.01666871f, 0.08619564f, -0.02908705f, 
    -0.34938130f, -0.31322575f, 0.15011734f, 0.13986020f, -0.15292631f, -0.11556295f, -0.07784084f, 0.01286332f, 
    -0.02705240f, 0.05432699f, -0.11812911f, -0.08590674f, -0.04557012f, 0.02657421f, -0.00624993f, -0.04038581f, 
    0.04107501f, 0.03189294f, 0.11628757f, 0.08419973f, -0.12261896f, 0.10334352f, 0.18557729f, 0.07685072f, 
    0.31119075f, 0.21368678f, 0.23870897f, 0.01582154f, 0.08870157f, 0.05703658f, -0.00636836f, 0.02670649f, 
    0.11533514f, -0.02067059f, -0.05127135f, -0.06547352f, 0.06966519f, -0.00970477f, -0.04438128f, 0.01040486f, 
    0.12828253f, 0.03371518f, 0.10210521f, 0.20759404f, 0.08968879f, 0.17927000f, -0.00873733f, -0.08750287f, 
    0.02389129f, 0.10766918f, 0.06599586f, 0.15867829f, -0.01577071f, -0.05055017f, -0.05253071f, 0.00551955f, 
    -0.07742807f, 0.05443458f, 0.01672179f, 0.05220929f, 0.01837644f, -0.09626650f, 0.07754156f, 0.16539140f, 
    0.04318541f, -0.12376253f, 0.16557841f, 0.12009926f, 0.01528936f, 0.06158654f, 0.09996276f, -0.11102580f, 
    0.06842788f, 0.06712066f, -0.04792373f, -0.03058003f, -0.00107046f, -0.05679341f, 0.13193066f, 0.04008199f, 
    -0.21526356f, 0.37702149f, 0.18271017f, 0.08739453f, -0.08172344f, 0.09251357f, 0.10308136f, 0.00529127f, 
    0.06478382f, -0.06271707f, -0.00930910f, -0.03318576f, 0.04719767f, -0.11347508f, -0.10928924f, -0.04865405f, 
    -0.05098225f, 0.04199727f, 0.05624821f, 0.15355431f, 0.29521784f, -0.08025397f, 0.12433425f, 0.03536844f, 
    -0.01170023f, -0.01813724f, -0.07965843f, -0.09000261f, -0.07116970f, -0.05177512f, 0.08159250f, 0.00309451f, 
    -0.08648843f, 0.03076309f, -0.01585927f, 0.08622823f, 0.03560436f, -0.01088850f, 0.04783227f, 0.14767961f, 
    0.22747451f, -0.11462598f, 0.04297775f, -0.26684448f, 0.22702207f, -0.03158313f, 0.07994926f, -0.09515627f, 
    -0.02488320f, 0.00316951f, 0.00578387f, -0.00481568f, -0.11197555f, -0.03284746f, -0.00128684f, 0.06203714f, 
    0.03009204f, 0.04497723f, -0.01905809f, 0.01827378f, -0.59132260f, -0.00720100f, 0.19214770f, -0.08882204f, 
    -0.01744495f, 0.05513078f, 0.03070264f, 0.07932355f, 0.08612791f, -0.04041521f, 0.06807286f, -0.02375197f, 
    0.05781638f, 0.00227541f, 0.00914526f, -0.02482575f, 0.09315021f, -0.04937072f, 0.10673524f, -0.04181791f, 
    0.10119805f, 0.19543892f, -0.18091422f, -0.00925064f, -0.01643034f, 0.08301179f, -0.15629224f, -0.07266325f, 
    -0.10481293f, -0.01638209f, 0.08502869f, -0.03380331f, -0.03946367f, 0.00105440f, -0.01134158f, 0.05641662f, 
    0.05958684f, -0.02603965f, -0.02431140f, -0.01542191f, -0.10016126f, 0.06081552f, 0.26968136f, 0.10674214f, 
    0.11706474f, 0.07365384f, -0.12442750f, -0.07271217f, -0.09912843f, 0.11479160f, -0.04843884f, -0.00884311f, 
    0.04693106f, 0.05663891f, 0.15928879f, -0.00636665f, 0.05845028f, -0.04734981f, -0.15890114f, -0.03419869f, 
    -0.02646456f, 0.29145899f, 0.22519277f, 0.16270238f, -0.11726401f, -0.10262949f, -0.12350217f, 0.03873412f, 
    0.15331352f, 0.08514677f, -0.12479822f, 0.00900073f, 0.05316547f, -0.03618662f, 0.00381417f, 0.05880773f, 
    -0.01921570f, 0.04741774f, 0.11198045f, 0.08475709f, -0.08460587f, 0.30401883f, -0.06418271f, -0.02183017f, 
    0.07658799f, -0.07656434f, -0.03261301f, -0.01073400f, -0.04325127f, -0.04723148f, 0.03013909f, 0.03096048f, 
    0.08203376f, -0.04096705f, 0.15645051f, -0.02978624f, -0.04136826f, 0.02536023f, 0.02989667f, -0.02948779f, 
    0.35731140f, -0.27679124f, 0.12214480f, 0.14845866f, -0.13786574f, 0.07341322f, -0.10056683f, 0.10327363f, 
    -0.14330104f, 0.10121305f, 0.14667256f, 0.02586820f, -0.04660685f, 0.11611599f, -0.03249152f, -0.14088546f, 
    0.04404619f, 0.10822413f, -0.07371680f, -0.10491668f, -0.24564515f, 0.00300032f, 0.13984975f, 0.00440141f, 
    -0.13915524f, -0.14477293f, 0.01760403f, -0.04131759f, 0.06522214f, -0.08703209f, -0.13045284f, -0.23015493f, 
    -0.05551180f, 0.10971583f, -0.01518696f, -0.10585587f, 0.11510792f, -0.05069205f, 0.07078399f, 0.08917602f, 
    -0.21161933f, 0.30180737f, -0.20667914f, 0.02372112f, 0.19323961f, -0.08078106f, 0.04762457f, -0.15102676f, 
    0.01992444f, -0.11236523f, 0.07114759f, -0.02331081f, -0.07778357f, -0.02603344f, 0.00155740f, 0.05789889f, 
    -0.07344875f, 0.02774688f, -0.02863109f, 0.02430751f, -0.35422558f, 0.04476882f, 0.04703992f, 0.07729516f, 
    0.23641714f, 0.07704996f, 0.06345409f, 0.02037190f, 0.06172471f, 0.19975345f, 0.01139567f, 0.06079898f, 
    0.10450420f, 0.07117493f, 0.06111489f, 0.09296822f, 0.13386288f, 0.06024147f, 0.18009429f, 0.08805313f, 
    0.12736604f, 0.29583752f, -0.35464409f, -0.06516033f, 0.38543332f, 0.06822743f, -0.02992452f, -0.13128817f, 
    0.12133709f, -0.07563756f, 0.10244545f, 0.01541207f, 0.00086167f, 0.22910228f, 0.00377002f, 0.10548209f, 
    0.04889242f, -0.05392011f, -0.00024093f, 0.09564316f, 0.06353474f, 0.27170646f, 0.33120602f, -0.12671527f, 
    -0.06759319f, 0.04928735f, -0.16918530f, -0.01009830f, 0.09442388f, -0.04921649f, -0.00216739f, -0.00388440f, 
    0.02390501f, 0.05841774f, -0.01911351f, 0.13189699f, -0.07499371f, -0.06055165f, -0.03343753f, -0.09236094f, 
    -0.28515929f, 0.28763694f, 0.17588302f, 0.14649160f, 0.14574704f, -0.04675557f, 0.03896829f, -0.00100091f, 
    0.04458185f, -0.01977572f, -0.11792691f, -0.02877423f, 0.03841352f, 0.03130970f, 0.07458894f, -0.06146484f, 
    -0.08353557f, -0.15454347f, -0.17366198f, 0.00378969f, 0.34724343f, -0.07141352f, 0.03646916f, -0.08863705f, 
    0.08242447f, 0.02698713f, -0.02562208f, -0.03970304f, -0.02157981f, 0.11897164f, -0.07418634f, -0.04131489f, 
    0.12877707f, -0.01057781f, 0.08681229f, -0.01269468f, 0.10194530f, -0.13188720f, -0.04557127f, -0.09769283f, 
    -0.03673131f, -0.06945730f, -0.03664379f, 0.32318264f, 0.04903246f, -0.06549595f, -0.11077983f, 0.04669695f, 
    0.03343895f, 0.06147880f, -0.03894304f, 0.01383783f, 0.08245673f, 0.04045445f, 0.14698732f, -0.00494318f, 
    0.02970597f, 0.15595289f, 0.12763852f, 0.03336210f, 0.16310975f, 0.25444576f, 0.04414573f, -0.08612403f, 
    0.05076021f, -0.13053025f, -0.01937937f, -0.11126331f, -0.05478007f, 0.20533521f, 0.01647273f, -0.00749659f, 
    0.06513582f, 0.01583720f, 0.05985235f, 0.03854952f, -0.01898201f, 0.06240207f, -0.02692587f, 0.00350075f, 
    0.23847784f, -0.14706120f, 0.13969105f, 0.00228057f, 0.11822727f, -0.04880989f, 0.00160139f, 0.12061775f, 
    0.02780832f, -0.08164515f, 0.04425349f, 0.00893538f, -0.07063144f, -0.00648772f, 0.01796768f, -0.02639306f, 
    0.05682222f, 0.00992051f, 0.18497489f, 0.11491767f, 0.27673948f, 0.19525516f, -0.25027999f, 0.11938827f, 
    0.02801222f, -0.03472030f, -0.06907497f, 0.00587660f, 0.05658987f, 0.04568365f, 0.08701326f, -0.05601544f, 
    0.08454469f, 0.05573974f, -0.06989728f, -0.03019453f, -0.00626034f, 0.06408434f, -0.08434388f, -0.06904449f, 
    -0.28236401f, -0.11200630f, 0.25195223f, 0.22580670f, -0.09146142f, -0.11043955f, 0.22556318f, -0.01328495f, 
    0.02289373f, -0.07748763f, -0.01005128f, 0.05338753f, 0.01112961f, 0.01706833f, 0.03810341f, 0.00752564f, 
    0.06939698f, 0.19183026f, -0.07904674f, 0.04257923f, 0.27086180f, -0.00415937f, -0.05482579f, 0.03318400f, 
    0.09727910f, 0.14306867f, -0.07459026f, 0.03254526f, 0.02447686f, -0.06933507f, -0.00652664f, 0.00435836f, 
    0.03977421f, 0.07175504f, -0.06652828f, 0.11294222f, -0.01986278f, -0.02447972f, -0.06005118f, 0.01021342f, 
    0.46614873f, 0.06019667f, -0.25904021f, 0.21812618f, 0.19543397f, 0.00488523f, -0.03945560f, -0.07453832f, 
    0.04638148f, -0.12668209f, 0.05794564f, 0.01398089f, 0.13008907f, 0.00642344f, -0.01331082f, -0.03096103f, 
    -0.00829831f, -0.07967551f, 0.10243113f, -0.13214435f, 0.38856122f, -0.41814092f, -0.16509159f, -0.21008116f, 
    0.06295156f, -0.06580525f, -0.03465844f, -0.04755956f, -0.02233564f, 0.03887578f, -0.04790041f, -0.07620545f, 
    -0.08888064f, 0.07351144f, -0.03847384f, 0.07117645f, 0.17025676f, -0.12243412f, 0.18781577f, 0.08023325f, 
    -0.58568460f, 0.52860022f, -0.07202928f, -0.17887288f, 0.04617598f, 0.07486457f, 0.06420578f, -0.01533157f, 
    -0.05626884f, 0.13008569f, 0.07595572f, 0.08864237f, -0.10666686f, 0.18299954f, -0.02008295f, 0.02092018f, 
    0.02485538f, 0.01824577f, 0.12376438f, -0.02874966f, 0.06442949f, 0.13233845f, -0.00063599f, 0.28196281f, 
    0.22269113f, 0.20155461f, -0.02879659f, 0.05245531f, 0.01524014f, 0.12009049f, 0.06985745f, 0.18749325f, 
    -0.04309253f, 0.14520572f, 0.07520774f, 0.07264633f, -0.01157481f, -0.04735104f, -0.11454809f, 0.02725370f, 
    0.08090308f, -0.17429824f, 0.04254841f, -0.18597184f, 0.08827507f, -0.12347545f, 0.06654763f, -0.06443796f, 
    -0.10917818f, -0.10773536f, 0.09860887f, 0.07926992f, -0.03115084f, -0.08727646f, -0.04563368f, 0.04311164f, 
    0.06863577f, -0.02044215f, 0.09708595f, 0.03882264f, 0.13508448f, 0.20391811f, 0.03930555f, -0.10443231f, 
    -0.20305023f, -0.00933945f, 0.11601631f, 0.12210384f, -0.05491606f, -0.09722959f, -0.02315192f, 0.08080665f, 
    0.01889025f, -0.04979702f, -0.03727022f, -0.03868784f, 0.06726902f, -0.03527893f, -0.05145601f, 0.05828861f, 
    -0.31593484f, -0.55279481f, -0.06239489f, 0.07843754f, -0.05820380f, 0.02777431f, 0.08128937f, 0.13829914f, 
    -0.13304347f, 0.00558057f, 0.11313702f, 0.11439256f, -0.10822281f, 0.06556814f, 0.13865896f, -0.02250578f, 
    -0.01411724f, 0.08814869f, -0.08353151f, -0.05078150f, 0.28023434f, 0.00526112f, 0.01187241f, -0.00057734f, 
    0.14727460f, 0.03920214f, 0.12429059f, -0.09578343f, 0.04186852f, 0.25043359f, -0.03749464f, -0.08122516f, 
    0.08852654f, 0.20192082f, -0.06193257f, -0.09348670f, 0.11510833f, 0.13245350f, 0.24403152f, 0.03285013f, 
    0.17945679f, 0.09638721f, 0.24895282f, 0.07284426f, -0.02706615f, 0.08936398f, 0.12517643f, -0.18722680f, 
    -0.00906041f, 0.01338149f, 0.05810554f, 0.06128678f, 0.09878781f, 0.08676179f, -0.10566830f, 0.07634680f, 
    0.17924979f, -0.01406341f, 0.18869276f, 0.10279735f, 0.16156663f, -0.09180466f, -0.19953144f, 0.20470674f, 
    -0.09369254f, 0.04119821f, 0.11421937f, 0.08291475f, 0.09399050f, -0.11059754f, 0.13902029f, 0.04631485f, 
    0.01663700f, -0.08701646f, 0.12374810f, 0.03185233f, 0.10870771f, -0.00155476f, 0.03423833f, 0.11192935f, 
    -0.42100528f, 0.11981659f, 0.09016475f, -0.16024368f, 0.08077693f, 0.10395337f, 0.15548915f, -0.15092114f, 
    0.01393002f, -0.04401189f, 0.04129223f, -0.03737539f, 0.06202557f, 0.06727887f, -0.06082151f, -0.05290351f, 
    0.06918532f, -0.03473631f, 0.00533500f, 0.04012062f, -0.16215916f, -0.04329355f, 0.14486621f, -0.08630907f, 
    -0.02342678f, -0.01850699f, 0.00875301f, 0.03122145f, 0.04007734f, 0.03872743f, 0.19759685f, 0.00814924f, 
    0.13955536f, 0.01382771f, 0.11340474f, 0.08904460f, 0.06211387f, 0.07845341f, 0.05780842f, 0.08392274f, 
    0.56550360f, -0.50728530f, -0.06019088f, -0.21794750f, -0.05218076f, 0.05935480f, -0.00371372f, -0.06480033f, 
    0.08081850f, 0.11197133f, -0.01827415f, 0.00727766f, -0.00793072f, -0.00812145f, -0.04091406f, 0.10250905f, 
    -0.03004267f, 0.01990366f, 0.07300191f, -0.06512231f, -0.40062359f, 0.04207887f, 0.06243696f, -0.08967063f, 
    0.13937669f, -0.05559959f, 0.09644699f, -0.01121747f, 0.01494503f, 0.09101897f, 0.10401685f, 0.07577083f, 
    -0.00583560f, -0.09004110f, 0.01175103f, 0.15963109f, 0.08958411f, -0.12147938f, -0.06786840f, 0.15733212f, 
    0.37768805f, 0.18896407f, -0.39293084f, -0.30990705f, 0.08335871f, 0.12149601f, -0.06284718f, -0.06254999f, 
    0.08567318f, -0.01678654f, 0.07175694f, -0.08553305f, -0.04702789f, 0.00781110f, 0.06715886f, 0.01873369f, 
    -0.04920020f, -0.05804784f, 0.03450123f, 0.02579779f, 0.10539712f, 0.32280114f, 0.12647542f, 0.02658886f, 
    0.00546924f, 0.27617127f, 0.20939510f, 0.04489186f, 0.01367752f, 0.08627619f, -0.09838390f, -0.02432684f, 
    -0.12780477f, -0.06794494f, 0.14562525f, 0.02002135f, 0.10884012f, -0.08978227f, -0.11394335f, 0.06461373f, 
    -0.02454688f, -0.13269375f, -0.03975041f, 0.04024559f, -0.15093108f, 0.04279272f, 0.08813647f, 0.03498131f, 
    -0.06167578f, 0.10502416f, -0.02751376f, -0.09299572f, 0.01415104f, -0.03576048f, 0.02619564f, -0.04499152f, 
    0.04259257f, 0.05412108f, 0.12211222f, 0.09342913f, 0.00344957f, -0.06939908f, 0.15724266f, 0.03014299f, 
    -0.33550915f, -0.05399565f, -0.05943611f, 0.06126262f, -0.09677600f, 0.08813827f, -0.20680234f, -0.05729154f, 
    0.10944194f, 0.10796007f, 0.03582799f, 0.01097234f, -0.10500265f, -0.11178927f, -0.01303504f, -0.02886186f, 
    0.17021912f, 0.20034400f, -0.10403624f, -0.04357020f, -0.04779236f, -0.00203001f, 0.16979299f, 0.13805333f, 
    0.05183584f, 0.08132403f, -0.06309585f, -0.09931350f, -0.02075841f, 0.01441015f, 0.01742366f, 0.00708066f, 
    0.11806927f, -0.01254516f, 0.00689403f, 0.05295469f, 0.11495505f, 0.00886912f, -0.14874870f, -0.23784976f, 
    -0.09883459f, 0.05069716f, 0.02892055f, -0.08433282f, 0.17371960f, -0.10228937f, 0.02935400f, -0.02930301f, 
    0.02476323f, -0.14941411f, -0.06097469f, 0.03931047f, 0.00505810f, 0.03973686f, 0.08580988f, 0.11078431f, 
    -0.51178181f, 0.10686441f, -0.04275803f, 0.09841719f, -0.19862628f, 0.09309291f, -0.05632912f, 0.01272473f, 
    -0.06600863f, 0.06804778f, 0.04029005f, -0.08170351f, 0.01472779f, 0.03256591f, -0.11125811f, -0.10309254f, 
    -0.12014059f, -0.03368731f, -0.09468891f, 0.05071337f, 0.06885557f, -0.12673262f, 0.20748149f, 0.28032395f, 
    0.36093247f, -0.08837229f, -0.22159500f, -0.07826751f, 0.21771811f, 0.23681746f, -0.11268672f, 0.04668351f, 
    0.09267183f, 0.04289554f, 0.03918338f, -0.00950362f, 0.06332289f, 0.08301898f, 0.15893830f, -0.06979626f, 
    -0.04553095f, -0.02602871f, 0.04712422f, -0.02244872f, 0.04751363f, -0.04034878f, 0.00159278f, 0.01011816f, 
    0.00098780f, 0.01524750f, -0.05494088f, 0.03296516f, -0.01710674f, -0.00670912f, 0.02111466f, 0.02787020f, 
    -0.04907876f, -0.04996395f, 0.03308565f, -0.06346180f, 0.04809665f, 0.00858973f, -0.00238581f, -0.03114639f, 
    -0.00807605f, -0.04198131f, 0.02244338f, -0.01248914f, 0.04310459f, 0.03308128f, 0.04959994f, -0.03007048f, 
    -0.00269217f, -0.01272718f, -0.02033556f, -0.00688047f, 0.02749831f, 0.02208919f, -0.02658278f, 0.00500185f, 
    0.04693773f, -0.00604063f, -0.01353107f, 0.02477789f, 0.03337310f, 0.00365589f, 0.02873422f, -0.02724397f, 
    0.04432656f, 0.02239981f, -0.01160830f, -0.01687940f, 0.00932130f, 0.02197857f, -0.06099698f, 0.02265911f, 
    -0.01143460f, 0.03468459f, 0.02410120f, 0.03945218f, -0.04241587f, -0.04687756f, 0.00051862f, -0.05704734f, 
    -0.00801760f, 0.00238551f, 0.00796179f, 0.01913757f, 0.04431552f, -0.03955860f, -0.03815686f, 0.04445543f, 
    -0.00947296f, 0.00258766f, 0.00999385f, 0.01722662f, -0.06188492f, -0.03810188f, 0.01026706f, 0.01842196f, 
    -0.00254481f, -0.04514533f, 0.03855063f, -0.02122119f, -0.04049273f, 0.03443582f, 0.02969554f, -0.01148948f, 
    -0.05028846f, 0.05063859f, 0.04385989f, -0.02258622f, -0.02362343f, 0.00396364f, 0.04618401f, 0.01522654f, 
    0.00549718f, 0.00596262f, 0.01531081f, -0.03732670f, -0.05381389f, -0.02978026f, -0.04027203f, -0.03188502f, 
    -0.01397504f, 0.00530194f, -0.05400970f, -0.06340691f, 0.01868374f, -0.01659873f, 0.02243263f, -0.01162586f, 
    0.03508214f, 0.04281189f, -0.03034469f, 0.02730812f, -0.01210842f, -0.05329999f, 0.02719342f, -0.00770988f, 
    -0.04902070f, 0.04153625f, -0.05648135f, 0.02734334f, -0.01198609f, 0.01235284f, 0.03695768f, -0.05212948f, 
    0.04047181f, -0.01620312f, 0.04513484f, -0.00163543f, -0.06356844f, 0.01858901f, -0.04970447f, -0.04578582f, 
    0.02218502f, 0.02943627f, 0.00812438f, -0.01159750f, -0.02995308f, -0.05650237f, 0.04386220f, -0.00432163f, 
    -0.02917270f, -0.01837938f, -0.03818558f, -0.04451854f, -0.04139064f, 0.03878084f, -0.05163822f, -0.04849154f, 
    -0.05039018f, -0.02689684f, 0.03170802f, 0.00974357f, 0.02099177f, -0.03909059f, -0.03589547f, 0.02961058f, 
    0.02926991f, 0.00725084f, 0.02446118f, -0.06239894f, 0.03367329f, -0.02830623f, 0.02359975f, 0.00938625f, 
    -0.00486036f, -0.02282245f, -0.00465008f, -0.05617652f, -0.04970348f, -0.05574286f, 0.00157287f, 0.00059371f, 
    0.04039904f, -0.04713669f, -0.03946985f, -0.04341099f, -0.05074278f, -0.04958903f, -0.00292238f, -0.04838488f, 
    -0.05603582f, -0.03162018f, -0.00708076f, -0.00891461f, -0.04613871f, 0.01500579f, -0.01747665f, -0.04863045f, 
    0.00622228f, 0.00940032f, 0.03126254f, 0.00878984f, -0.04100655f, 0.02989686f, 0.01196650f, -0.01123689f, 
    -0.00735642f, -0.05234648f, 0.00620850f, 0.03976823f, -0.04942056f, -0.05025190f, 0.04459871f, -0.03603939f, 
    0.01713833f, -0.01616902f, -0.00245015f, -0.04548116f, 0.04547869f, -0.02813939f, -0.04611393f, 0.02115683f, 
    -0.02642143f, 0.02594280f, -0.00895411f, 0.01309754f, -0.00074028f, 0.02420645f, 0.01799931f, -0.02497664f, 
    0.04673323f, -0.01688715f, 0.05766165f, 0.03650898f, -0.02012034f, -0.03957167f, -0.01829694f, 0.00753937f, 
    0.00333439f, 0.04175257f, -0.05305366f, -0.03047789f, -0.03405849f, 0.04368993f, 0.00425815f, 0.03470620f, 
    0.04588612f, 0.00857866f, -0.05251203f, 0.00276886f, -0.04322707f, 0.02101433f, -0.00229866f, -0.02969172f, 
    -0.02482051f, 0.02158736f, -0.00054166f, -0.01533223f, 0.01490357f, -0.05114018f, -0.04301244f, -0.01296510f, 
    -0.00800159f, -0.01014126f, 0.04524763f, -0.03156015f, -0.05725091f, -0.04593717f, 0.00834490f, -0.01510058f, 
    -0.05545627f, 0.05109386f, 0.04567898f, 0.00863749f, -0.02557220f, 0.02805427f, 0.01299354f, -0.00263059f, 
    -0.02662263f, 0.01745132f, -0.00534723f, 0.04005572f, 0.02829506f, -0.02049674f, -0.00726098f, -0.01993352f, 
    -0.03038362f, -0.03599931f, -0.03186687f, -0.04743671f, -0.05823228f, -0.02704613f, 0.02763539f, 0.03286040f, 
    -0.04413956f, 0.04259973f, -0.00117627f, 0.02728796f, 0.00422386f, 0.00545574f, 0.04201350f, 0.00695803f, 
    -0.04342010f, 0.01361798f, 0.01779348f, -0.01948136f, -0.03188450f, 0.03918104f, -0.01945028f, -0.05962866f, 
    -0.05272170f, 0.01293137f, -0.03135319f, 0.02082672f, -0.03593942f, 0.01280058f, 0.03692115f, 0.04684064f, 
    -0.06283066f, 0.03567849f, -0.00017419f, 0.02847683f, -0.02162027f, -0.05743940f, -0.02528133f, 0.03442479f, 
    0.00091456f, 0.01446391f, 0.02493521f, -0.04549336f, -0.00170400f, 0.02242027f, -0.01328951f, 0.00427678f, 
    0.04363392f, 0.03980831f, 0.02023615f, -0.03999608f, -0.05972347f, -0.01233005f, 0.04888631f, -0.04920411f, 
    0.01548949f, 0.01567372f, -0.00572879f, -0.04607358f, -0.00082998f, 0.02535056f, 0.05328115f, 0.02468872f, 
    0.00722916f, -0.03707550f, -0.02240120f, -0.02600363f, -0.03682269f, -0.02372713f, -0.02519475f, 0.04035799f, 
    0.00887026f, 0.00763153f, 0.04793013f, -0.05756772f, -0.06044659f, 0.03566410f, -0.03404964f, 0.04950005f, 
    -0.04229353f, -0.00660701f, 0.03698903f, 0.04344560f, 0.04369725f, -0.03137877f, -0.01396621f, 0.02046596f, 
    -0.05439172f, 0.00241298f, -0.03922470f, -0.01385915f, 0.01599624f, -0.05604476f, -0.03257586f, -0.00360460f, 
    0.00058353f, 0.03715691f, 0.01195089f, -0.02959064f, -0.02414548f, -0.01265790f, -0.04358077f, -0.04278263f, 
    0.01260212f, -0.04711804f, -0.03528362f, -0.01360686f, -0.01260743f, 0.04242261f, -0.04294718f, -0.02538236f, 
    -0.02100498f, -0.01174657f, -0.00045282f, -0.04302954f, -0.02875210f, 0.04460796f, -0.05741615f, -0.02239469f, 
    -0.00795357f, 0.01747335f, -0.00719583f, -0.05562703f, -0.02689432f, 0.03817140f, -0.03951417f, 0.00641482f, 
    -0.04134097f, 0.02987139f, 0.02921896f, -0.01302558f, -0.04078309f, -0.05846868f, -0.02953562f, 0.01874121f, 
    0.01999667f, -0.00018282f, 0.04375494f, 0.04320760f, 0.02516116f, -0.05711314f, -0.01636481f, -0.05692523f, 
    0.03454819f, 0.04409707f, -0.05662213f, -0.03287266f, 0.04662909f, -0.01927512f, 0.03024577f, 0.03374752f, 
    -0.03701086f, 0.04614653f, 0.04068770f, -0.05728918f, -0.00826684f, 0.02305101f, -0.01922548f, -0.02709622f, 
    0.01797654f, -0.00785807f, 0.00178027f, -0.01710444f, -0.03295418f, 0.02357850f, -0.00632763f, 0.03575461f, 
    0.00539352f, -0.02621086f, -0.00664537f, 0.01234473f, 0.04591649f, -0.00019329f, -0.05646109f, 0.01570478f, 
    -0.00020988f, 0.02859881f, 0.03039480f, -0.04102799f, -0.04629016f, 0.02124898f, 0.03906519f, -0.01482717f, 
    -0.03417201f, -0.04932958f, -0.03956129f, -0.05046899f, 0.00152591f, 0.04208456f, -0.03008910f, -0.03451667f, 
    0.04708387f, -0.02719608f, -0.04824452f, -0.05004114f, -0.00508947f, -0.04320446f, -0.03813743f, -0.00094984f, 
    0.02123125f, 0.04439500f, -0.02313454f, -0.05991220f, -0.02607684f, 0.04902621f, -0.02808985f, -0.04484352f, 
    0.02028851f, -0.04520466f, -0.04237416f, -0.01088854f, 0.03704933f, 0.04829903f, -0.05428521f, -0.04089350f, 
    -0.03689713f, -0.00201033f, -0.05864082f, 0.04777124f, 0.00777959f, -0.03478142f, -0.01771460f, 0.04738319f, 
    -0.01870630f, 0.03990369f, -0.05296826f, 0.03373663f, -0.01574957f, 0.04338156f, -0.04053442f, -0.01970236f, 
    0.04269687f, 0.02712895f, 0.04356850f, 0.00098423f, 0.04343024f, -0.04720298f, 0.01331015f, -0.01075150f, 
    0.02403784f, -0.04146415f, -0.00014909f, -0.00559721f, -0.05524651f, -0.03413963f, -0.05167203f, 0.04457775f, 
    -0.02210991f, -0.05021762f, -0.01601174f, -0.05441587f, 0.00867549f, -0.00246153f, -0.01477646f, 0.01335301f, 
    -0.02457018f, -0.03488449f, -0.03660444f, -0.03823998f, -0.00924884f, -0.02185912f, -0.04345170f, 0.02339598f, 
    -0.00525746f, 0.01089313f, -0.01771236f, -0.01206418f, -0.01465777f, -0.02502000f, -0.05984083f, 0.03284930f, 
    -0.04475188f, -0.05737137f, 0.00499592f, -0.04070242f, -0.04495707f, -0.01844213f, -0.04051368f, -0.01528055f, 
    0.03072528f, 0.03432933f, -0.00385142f, -0.05394310f, 0.04824175f, -0.01762913f, -0.00605831f, -0.02543942f, 
    -0.01852280f, -0.00316639f, -0.02484621f, 0.01634582f, 0.02794749f, 0.03870377f, 0.01343714f, -0.01520795f, 
    -0.04370747f, 0.02167744f, -0.01366238f, 0.01246707f, 0.04616477f, 0.01169042f, -0.00561272f, -0.02959454f, 
    -0.06084930f, 0.04789371f, -0.03872711f, 0.00966113f, 0.00858126f, 0.04980834f, -0.04483821f, 0.04989161f, 
    0.00952139f, -0.00101239f, 0.03688192f, 0.00112242f, -0.04944788f, -0.02334460f, 0.04910090f, -0.01820693f, 
    0.04066316f, 0.05046016f, -0.02388262f, 0.03851227f, 0.02688310f, -0.03410665f, -0.01616491f, -0.03153780f, 
    -0.04072735f, -0.05009640f, -0.05924212f, 0.03509018f, -0.05933201f, -0.02697836f, 0.04403950f, 0.04183840f, 
    -0.02852683f, -0.04281159f, -0.04357592f, 0.00812206f, -0.00659153f, -0.06104766f, -0.02418149f, -0.01271874f, 
    0.02240617f, 0.02420828f, 0.05001443f, 0.02241980f, 0.03201470f, -0.05652120f, -0.04223505f, -0.00655232f, 
    0.01150251f, -0.04896535f, 0.03591180f, 0.01977382f, -0.01994619f, -0.05946069f, -0.01698801f, -0.02974939f, 
    0.01597094f, 0.00605653f, 0.04761619f, -0.00193885f, -0.04828662f, 0.01738319f, 0.03186117f, -0.05356979f, 
    -0.01595736f, 0.01833282f, -0.03343631f, -0.03039655f, -0.05386306f, 0.01659588f, 0.04942250f, -0.03879361f, 
    0.00793325f, -0.00179633f, 0.01046905f, -0.00122538f, -0.00155162f, 0.00936126f, -0.06181387f, 0.02720879f, 
    0.02832738f, 0.04547095f, -0.00290440f, -0.04721412f, -0.02289549f, -0.05217149f, -0.01343269f, -0.02257464f, 
    -0.01989785f, 0.01247864f, 0.03653963f, 0.00901983f, 0.03062017f, 0.04797490f, -0.05624512f, -0.05007516f, 
    -0.01222635f, 0.04115064f, -0.05065843f, -0.06045517f, 0.01007891f, 0.02442916f, 0.02275118f, 0.00840305f, 
    -0.00330626f, -0.03577353f, -0.01986929f, 0.02488413f, -0.02802889f, 0.00183691f, -0.02222555f, -0.05733047f, 
    0.00539428f, 0.02158124f, 0.04472827f, 0.02234210f, -0.05630960f, 0.01630919f, -0.05018818f, -0.04641129f, 
    0.00290138f, -0.04401096f, -0.00888520f, -0.06010456f, -0.02314501f, -0.02948712f, -0.03357921f, 0.03148300f, 
    -0.05126963f, -0.00771922f, -0.05516307f, 0.00838898f, 0.03179384f, -0.04892822f, -0.03177906f, -0.01404693f, 
    -0.00198540f, -0.00496400f, 0.02962958f, -0.00097477f, 0.00005509f, 0.01017578f, -0.00306925f, -0.03522129f, 
    -0.03577576f, 0.04054843f, -0.04529347f, -0.04254919f, 0.00323840f, -0.01297832f, -0.04676250f, -0.04533753f, 
    0.01564478f, -0.01808532f, -0.00984007f, -0.00663821f, 0.00329528f, 0.00378450f, -0.04189610f, -0.05788686f, 
    -0.01936830f, -0.05375181f, 0.00263738f, 0.01895058f, 0.03191744f, -0.00616081f, -0.02895266f, -0.00669717f, 
    -0.02451130f, -0.05448987f, -0.03714047f, 0.00641253f, -0.03824039f, 0.04486372f, 0.01169375f, 0.00111403f, 
    0.04185809f, -0.04063885f, -0.00267661f, -0.05161384f, -0.00117369f, -0.02757275f, -0.04649854f, -0.02849966f, 
    -0.01253070f, -0.03766997f, 0.01917848f, 0.03292846f, -0.00340388f, 0.03405988f, -0.00979922f, -0.00017341f, 
    -0.03702350f, 0.05196205f, -0.01997682f, -0.00884019f, 0.01593611f, 0.00183296f, -0.04139811f, -0.05405198f, 
    0.03424040f, -0.05988726f, -0.03588824f, 0.00751449f, -0.02698963f, 0.04230985f, -0.02679119f, 0.04976519f, 
    0.04889592f, -0.01803818f, -0.04777713f, 0.01039722f, -0.06012987f, 0.02037890f, -0.04562051f, -0.06060153f, 
    -0.01385101f, 0.04186033f, 0.03181674f, -0.01087642f, -0.04206741f, 0.04928537f, -0.02664838f, 0.04028110f, 
    0.01941660f, -0.04660770f, -0.01516003f, -0.05395219f, -0.04657302f, 0.01639514f, 0.02613242f, -0.00736300f, 
    -0.03855166f, -0.02117086f, 0.02051746f, 0.02261361f, 0.03802233f, 0.01219361f, -0.03912187f, 0.00822983f, 
    -0.02386498f, -0.04844270f, -0.01289483f, -0.02626438f, -0.02141510f, -0.00259039f, -0.00976364f, -0.01008365f, 
    -0.04712557f, -0.00992473f, -0.01830257f, -0.02691954f, -0.01236095f, 0.02685375f, 0.02908522f, -0.04767263f, 
    0.03547059f, 0.04485285f, 0.02772316f, -0.04767302f, 0.01013372f, 0.05144592f, -0.00923691f, 0.05464853f, 
    0.03490831f, -0.01373451f, -0.02415795f, -0.02080010f, 0.02878498f, -0.03869472f, -0.01112069f, 0.02700118f, 
    -0.01346856f, 0.01345783f, -0.04543336f, -0.05510669f, -0.04456605f, -0.03253597f, -0.02927882f, 0.03555793f, 
    0.04733953f, -0.01053355f, 0.01341719f, 0.02268233f, 0.03831682f, -0.00090819f, -0.03370290f, -0.04151833f, 
    -0.06032700f, 0.01123788f, -0.03975308f, -0.00998501f, -0.05878977f, -0.00447903f, 0.04175339f, 0.04584221f, 
    -0.00639872f, -0.05514020f, 0.04078121f, 0.01960611f, -0.02031474f, -0.02825599f, 0.03934630f, 0.01400226f, 
    -0.00101501f, -0.02144676f, 0.01667660f, -0.05854812f, 0.04092260f, -0.01396704f, -0.01370243f, 0.00558074f, 
    -0.05477753f, -0.03607149f, 0.03888390f, -0.01202427f, 0.00395208f, -0.03153715f, 0.04321264f, 0.00162715f, 
    0.03673721f, -0.01810635f, -0.01815937f, 0.04007420f, -0.04867946f, -0.02690763f, -0.01481405f, -0.00563903f, 
    -0.02082025f, -0.00830824f, -0.02909590f, 0.03450025f, 0.01961989f, -0.03758314f, -0.04735482f, 0.04241347f, 
    -0.02183370f, -0.05055869f, 0.02703851f, -0.00351877f, 0.01951078f, -0.00167054f, -0.05260547f, 0.00706150f, 
    0.03604932f, -0.04330773f, -0.02592446f, -0.02361878f, 0.00069931f, -0.05832420f, 0.04818805f, 0.01879420f, 
    -0.05138070f, 0.02286650f, -0.00921078f, 0.02906492f, -0.00663679f, -0.00418506f, 0.00927742f, 0.04435051f, 
    -0.04804360f, 0.01641725f, 0.00595177f, 0.00378217f, 0.04257270f, 0.00040124f, 0.02776499f, -0.00471098f, 
    -0.05622538f, 0.02992418f, -0.04524408f, 0.02096524f, 0.01981419f, 0.03131438f, -0.03471595f, 0.00432959f, 
    0.01995734f, -0.02962173f, 0.36970079f, -0.00971975f, -0.07757758f, 0.01102795f, -0.00535513f, -0.04030875f, 
    -0.07529919f, 0.03572479f, -0.13570830f, 0.00274708f, 0.05044448f, -0.05750994f, 0.00783372f, -0.04149476f, 
    0.05874519f, 0.11596850f, 0.02356877f, -0.04500761f, -0.13696313f, -0.42968738f, -0.14621399f, 0.20418593f, 
    0.02578601f, -0.00244299f, 0.25052169f, 0.03414887f, -0.02986866f, 0.06953490f, 0.07691326f, 0.15417407f, 
    -0.08119893f, 0.03227959f, 0.07686257f, -0.06448814f, -0.00216762f, 0.00576215f, -0.12971842f, -0.02073037f, 
    0.13023244f, -0.26186559f, -0.13465033f, -0.10016327f, -0.09701069f, 0.09786776f, -0.06975502f, 0.07232546f, 
    0.05594006f, -0.04886233f, 0.10074264f, -0.01780039f, 0.04871798f, 0.00295394f, -0.06123625f, -0.00352203f, 
    0.05702588f, 0.07583715f, -0.05353044f, 0.02578941f, -0.39661282f, 0.09482204f, -0.05945925f, -0.01293222f, 
    0.02121215f, -0.03444759f, -0.02010245f, 0.16170111f, 0.06732428f, 0.12032719f, 0.05317994f, 0.09992678f, 
    -0.04877576f, 0.05862126f, -0.07786467f, 0.02173993f, -0.08764315f, -0.02762296f, 0.09706904f, 0.20612516f, 
    0.17480507f, 0.03014014f, 0.11553371f, -0.08123360f, 0.08477129f, -0.00148896f, 0.10808716f, -0.06497210f, 
    -0.01498331f, -0.01793242f, 0.05720913f, -0.01244691f, -0.08163127f, -0.11326189f, -0.00004242f, 0.10302468f, 
    -0.01843143f, -0.02590790f, -0.09389858f, 0.08505151f, 0.18766269f, 0.02244447f, -0.03155989f, 0.16674890f, 
    0.10916923f, 0.18586114f, 0.14444394f, 0.04949636f, -0.04220776f, -0.10861848f, -0.02396158f, 0.04409035f, 
    -0.13202940f, 0.01365255f, -0.09679406f, -0.11538462f, 0.08389165f, 0.05801895f, 0.18771940f, 0.16791788f, 
    -0.30429256f, 0.34310573f, -0.16105437f, 0.04238288f, -0.14052348f, 0.05990798f, -0.02887915f, -0.07028653f, 
    -0.04586261f, -0.02443305f, 0.05299671f, 0.02107253f, 0.00815226f, 0.00777920f, 0.05773886f, -0.03059065f, 
    -0.07423134f, 0.12036103f, -0.11537554f, -0.09086175f, -0.07417245f, -0.22521131f, 0.11895722f, -0.02851761f, 
    0.08429123f, 0.16306628f, 0.04904695f, -0.03744903f, -0.02713426f, -0.00682911f, -0.05990723f, -0.01075581f, 
    -0.08178575f, 0.08120584f, 0.08474603f, 0.00934330f, 0.06127923f, 0.11037424f, 0.10376336f, 0.15120624f, 
    0.08137257f, 0.15925688f, 0.11234415f, -0.05213940f, 0.14445616f, 0.17025009f, -0.09551662f, 0.11903598f, 
    0.00769157f, 0.04884951f, 0.06116993f, 0.01907009f, 0.04314385f, 0.00847225f, 0.03085251f, -0.01188538f, 
    0.03302928f, -0.03091760f, 0.10412309f, -0.02820709f, -0.20759647f, -0.10250995f, 0.00587236f, -0.11461319f, 
    -0.03846860f, -0.08700930f, -0.03389596f, 0.01360092f, 0.03628516f, 0.03463660f, 0.16606048f, 0.12691955f, 
    0.09937595f, 0.06665324f, 0.16212957f, -0.08482201f, -0.04862954f, 0.04421930f, 0.01396229f, -0.01113029f, 
    -0.52866876f, -0.18760869f, 0.41485617f, -0.23629460f, 0.07731719f, 0.07490578f, 0.01681895f, -0.03469170f, 
    -0.03022432f, 0.05944893f, 0.07524525f, 0.04613892f, -0.05749285f, -0.08851846f, 0.05966557f, 0.10737422f, 
    0.05103455f, 0.03299242f, -0.02171007f, 0.03656078f, -0.18150075f, 0.58917689f, 0.27043298f, 0.12348461f, 
    0.09157330f, 0.02526678f, 0.08209217f, 0.03517181f, 0.07893507f, -0.00984299f, 0.22751842f, 0.15162319f, 
    0.08867515f, -0.07922939f, 0.03956359f, 0.00665258f, -0.09069383f, 0.14812593f, 0.15873459f, -0.02512444f, 
    0.47565314f, -0.53824472f, 0.00967037f, 0.25433585f, 0.07043112f, -0.03986369f, -0.07213336f, -0.09560456f, 
    0.04771201f, -0.01231777f, -0.03584019f, 0.00675334f, 0.22590959f, -0.05819642f, 0.06283633f, 0.05120802f, 
    -0.04393512f, 0.11135339f, -0.07171495f, 0.07192584f, -0.09533374f, -0.02307875f, -0.10493503f, -0.31151688f, 
    -0.17533807f, -0.16950606f, -0.07637446f, 0.06973413f, -0.00725845f, 0.00483063f, 0.03342971f, -0.09397334f, 
    0.11999030f, 0.00899710f, -0.05757537f, 0.07910530f, 0.12985405f, -0.07625163f, 0.18502146f, -0.02861661f, 
    0.17810886f, 0.24520235f, 0.12893617f, 0.21099919f, -0.13273866f, 0.15897277f, -0.02743001f, 0.03338050f, 
    0.09106841f, 0.10215080f, 0.07199547f, -0.00344344f, 0.02146898f, 0.09120741f, 0.08826514f, 0.04161682f, 
    0.05130037f, 0.02201613f, 0.07326057f, -0.18247692f, -0.16605249f, -0.02400276f, -0.08971123f, 0.12160867f, 
    -0.05290609f, 0.21749984f, 0.09027071f, -0.00246593f, 0.09438270f, 0.12366469f, 0.07952349f, -0.01634259f, 
    -0.07282944f, -0.03694429f, 0.01880510f, 0.05304516f, -0.04718713f, 0.06034599f, 0.01895796f, -0.01561402f, 
    0.09502494f, 0.44034976f, 0.05480044f, 0.02031869f, -0.08565864f, 0.05338487f, -0.00420139f, 0.10771949f, 
    0.06468552f, -0.05222918f, 0.07532255f, 0.01452512f, -0.06924193f, 0.16066526f, -0.08259709f, 0.10922608f, 
    -0.02998099f, 0.03945047f, -0.03544132f, -0.04972395f, 0.17018387f, -0.07716866f, -0.07688430f, 0.03323694f, 
    -0.06337682f, 0.11498402f, 0.09429340f, 0.10758996f, 0.12235176f, 0.14522478f, -0.05605787f, 0.04721983f, 
    -0.04288653f, 0.03937237f, 0.02227075f, 0.09747686f, 0.06898455f, -0.11053582f, -0.10921564f, 0.05175309f, 
    -0.13308468f, 0.10054045f, -0.11405766f, -0.09227854f, -0.07519723f, 0.01499671f, -0.01880045f, 0.03725266f, 
    0.07876110f, 0.00112713f, 0.01869919f, -0.11608253f, 0.12726551f, 0.05649164f, 0.11947303f, 0.03561282f, 
    -0.04072398f, -0.03841515f, -0.10825022f, 0.02388466f, 0.00380716f, -0.04843087f, 0.14954987f, -0.06787799f, 
    0.11342548f, 0.00412732f, 0.00977157f, -0.00988701f, -0.02798223f, 0.18542311f, 0.00929154f, -0.02755716f, 
    0.09902987f, -0.02463384f, 0.06598737f, -0.02547647f, 0.02503651f, 0.07091940f, -0.07761050f, -0.06095867f, 
    0.07308322f, 0.31715506f, 0.16834506f, 0.25782362f, 0.05172922f, -0.09793645f, -0.07810501f, 0.13201827f, 
    0.01822141f, 0.09015143f, -0.08381493f, 0.07204921f, 0.04003851f, 0.06601969f, 0.18951078f, 0.13458279f, 
    0.02452184f, -0.02290499f, 0.03985102f, 0.10987375f, 0.32982367f, 0.37919188f, 0.13452412f, 0.17362882f, 
    0.11717052f, -0.11741974f, -0.02631774f, -0.05053470f, 0.00861242f, 0.13013327f, 0.06219848f, -0.05245002f, 
    0.03819915f, 0.00127330f, -0.03174373f, 0.07815592f, 0.00601305f, 0.06414086f, 0.04513423f, -0.11981081f, 
    0.26227906f, -0.29393679f, 0.03678624f, 0.11713704f, 0.12699175f, -0.02073762f, -0.05452508f, -0.09503048f, 
    0.06223711f, -0.03672871f, 0.03635957f, 0.01425131f, 0.00415757f, 0.00734165f, -0.05138189f, -0.05319414f, 
    0.06610999f, 0.07683179f, 0.12672143f, 0.08076529f, 0.32011348f, 0.18124339f, 0.08162541f, 0.15249552f, 
    0.05776145f, -0.05276157f, 0.00227306f, 0.01939886f, -0.03358649f, 0.00307099f, 0.03005595f, -0.04920244f, 
    0.05941472f, 0.02633986f, -0.05836594f, 0.04476578f, 0.00680326f, 0.07652823f, -0.09266905f, -0.01016336f, 
    0.12265607f, -0.16944210f, 0.12907781f, 0.14995313f, -0.09272563f, -0.10603087f, 0.14833215f, -0.03744496f, 
    0.07513528f, 0.08075108f, -0.05183795f, 0.03776184f, -0.06840000f, -0.08454910f, 0.11469214f, 0.10087688f, 
    -0.00832843f, 0.20621735f, -0.02785436f, 0.05564684f, 0.16454107f, -0.16305986f, -0.02988738f, -0.09603443f, 
    0.00991711f, 0.01123361f, -0.01790655f, 0.03030463f, 0.03616670f, 0.03636621f, -0.05858485f, -0.01773583f, 
    0.08251277f, 0.05151999f, 0.02972283f, 0.04391337f, 0.02642469f, 0.01849682f, 0.00487988f, -0.00699080f, 
    -0.02916873f, -0.08355766f, -0.11291070f, -0.14374360f, 0.08548773f, -0.08987372f, -0.05826299f, 0.09479376f, 
    0.02539059f, -0.07402711f, -0.03778455f, 0.05810760f, 0.02529983f, -0.06633683f, -0.08443905f, -0.04190377f, 
    0.00635832f, 0.02011606f, 0.02505337f, -0.01663113f, 0.32038933f, -0.37767333f, 0.07271441f, -0.14691588f, 
    0.07328086f, 0.05098099f, -0.01653095f, -0.08460405f, -0.00514915f, 0.04089490f, 0.06552385f, -0.05365089f, 
    -0.02299280f, 0.08896521f, -0.04678472f, 0.11649176f, 0.00457042f, -0.09752225f, -0.02452309f, -0.03889743f, 
    -0.06409725f, 0.03600176f, -0.20313467f, -0.20914383f, -0.04954433f, -0.05345613f, 0.00237864f, -0.02734737f, 
    -0.08058986f, 0.00816963f, 0.08455081f, 0.05500776f, 0.06334100f, 0.04229096f, -0.00594708f, -0.02267284f, 
    0.04011422f, 0.08205409f, 0.08217833f, 0.02999812f, -0.30014861f, -0.05280938f, 0.09636784f, 0.03781496f, 
    0.17796956f, 0.09434386f, -0.03288178f, 0.03606484f, -0.17231885f, 0.17255044f, -0.00173057f, 0.09380624f, 
    -0.00280932f, -0.00575748f, -0.00861171f, 0.08404962f, 0.02738514f, -0.07348428f, -0.12554955f, -0.04162868f, 
    0.16271907f, -0.19677240f, 0.19851086f, -0.17976002f, 0.19029240f, 0.02299162f, 0.10813826f, -0.11388284f, 
    -0.04436738f, 0.01417659f, 0.14221689f, 0.02744061f, -0.02814186f, -0.01869093f, -0.04410899f, 0.08812412f, 
    0.10594934f, -0.05046126f, 0.03341484f, 0.03386544f, 0.12571643f, -0.14620343f, -0.04574854f, -0.14298309f, 
    -0.06911419f, -0.03444550f, 0.16377391f, 0.00405498f, -0.06432108f, -0.00158613f, 0.09110412f, 0.05464960f, 
    0.00681907f, -0.00413147f, 0.02101388f, 0.05228535f, 0.06640883f, -0.01339039f, -0.03738036f, 0.08503036f, 
    -0.23857106f, 0.18325444f, -0.01328417f, 0.12628928f, 0.34268650f, 0.15241195f, 0.01831002f, -0.10588432f, 
    0.01638905f, -0.11730947f, -0.07936327f, -0.05009082f, 0.12640880f, 0.17725970f, 0.03056361f, 0.09141944f, 
    0.05809307f, 0.12695001f, -0.08792269f, -0.12530953f, -0.32059747f, -0.41775143f, 0.03666337f, -0.24262531f, 
    -0.25496659f, 0.05012012f, 0.16576794f, 0.05532844f, 0.13100052f, 0.00113464f, -0.05051031f, 0.00256244f, 
    -0.08892768f, 0.11910611f, 0.00761644f, 0.06965222f, -0.00217727f, 0.02244907f, -0.27358791f, -0.00100007f, 
    -0.41962212f, -0.49486396f, -0.01321289f, -0.09680052f, -0.25608474f, 0.01307501f, 0.00805269f, -0.15049168f, 
    0.07268084f, -0.24065569f, -0.00922808f, 0.12958600f, -0.04159265f, 0.05849837f, 0.00141349f, 0.03837903f, 
    -0.04363197f, 0.00771392f, -0.24990100f, 0.02432446f, 0.02026100f, 0.09164031f, -0.16319183f, -0.11382543f, 
    -0.13521819f, -0.02036873f, 0.02697246f, 0.09620806f, -0.09392884f, 0.09018590f, 0.03115530f, -0.00134917f, 
    0.09666269f, 0.05942662f, -0.10447066f, 0.06002039f, -0.07443901f, -0.17200433f, 0.03335458f, 0.06014363f, 
    -0.04780014f, 0.39621162f, 0.25717774f, 0.40586868f, 0.41748285f, 0.09373167f, 0.11159078f, -0.13309012f, 
    -0.05405409f, -0.08113160f, 0.01117435f, 0.03091994f, 0.21861731f, 0.02453592f, 0.04253655f, -0.10462645f, 
    0.07434936f, 0.02763657f, -0.10304840f, -0.01741998f, 0.36531073f, 0.38534063f, 0.21329521f, 0.06205139f, 
    0.32776159f, 0.09312423f, -0.01066720f, -0.01005818f, -0.04361836f, 0.04312296f, 0.05571409f, -0.02034046f, 
    0.03053465f, 0.06158023f, 0.05101882f, 0.00015766f, 0.02239844f, 0.02147418f, 0.14500950f, -0.01463301f, 
    0.12789734f, 0.18039963f, -0.12330238f, -0.12585331f, -0.03759522f, -0.08393302f, -0.04400941f, 0.01346652f, 
    0.08645363f, 0.06331898f, 0.05282966f, -0.04146999f, -0.02395200f, -0.00842030f, 0.01241236f, 0.04710287f, 
    0.02291219f, 0.09344519f, 0.16472639f, 0.10036492f, 0.22440624f, 0.11564995f, 0.02450309f, 0.18693256f, 
    0.36058474f, 0.05855296f, 0.01117320f, 0.05091995f, 0.00356739f, -0.02302659f, 0.09659833f, 0.01655503f, 
    0.14024282f, -0.03764233f, 0.07994006f, 0.03870359f, 0.04573794f, -0.05948588f, -0.03991948f, -0.06652743f, 
    0.29499945f, 0.11868609f, 0.15179312f, 0.06581566f, -0.05112211f, -0.10200025f, 0.01122748f, 0.07406899f, 
    -0.01402596f, -0.03263330f, 0.10975566f, -0.07349818f, -0.03231307f, -0.04291061f, 0.03373392f, 0.12664977f, 
    -0.02894335f, 0.04050598f, -0.00662366f, 0.03391429f, -0.11648244f, -0.19039442f, -0.18727121f, -0.30722228f, 
    -0.34216484f, 0.08729671f, -0.27825022f, -0.04912172f, -0.18575536f, -0.09833855f, -0.05025858f, 0.01648461f, 
    -0.01069037f, 0.06589169f, 0.18888432f, -0.05155720f, -0.02432618f, -0.13083944f, -0.21793050f, -0.14762157f, 
    -0.04018032f, -0.11006992f, 0.01759916f, 0.00435072f, -0.16397798f, 0.03890493f, -0.10007451f, -0.04987433f, 
    -0.05590886f, -0.03383182f, -0.02227111f, 0.02009530f, 0.24640612f, -0.03531788f, 0.14968830f, 0.03014344f, 
    -0.14684458f, -0.07306534f, 0.06848866f, -0.06454060f, 0.38920107f, 0.17026852f, 0.26065388f, -0.13856903f, 
    0.18944022f, -0.05042411f, -0.09364143f, 0.01543841f, 0.07452267f, 0.05949951f, 0.15911138f, -0.08979648f, 
    0.13827895f, 0.15459923f, 0.14694528f, 0.00341106f, 0.03748682f, -0.08174334f, 0.04400516f, -0.02534097f, 
    0.18267150f, 0.18917131f, -0.08048125f, 0.11503810f, -0.10859740f, 0.14310329f, -0.01850385f, 0.06780112f, 
    -0.15302576f, 0.09479495f, 0.02168544f, 0.11823336f, 0.04654045f, 0.07232410f, -0.01809581f, -0.18948393f, 
    0.00456555f, 0.03420113f, 0.00898091f, -0.06363988f, -0.12073366f, 0.22402003f, -0.06110124f, -0.18988343f, 
    -0.24236017f, -0.03376620f, -0.05088043f, 0.02596043f, -0.21898459f, 0.07118342f, 0.02732736f, -0.03523489f, 
    0.00282502f, -0.04626452f, 0.08402790f, 0.11084073f, -0.05339176f, 0.00350088f, 0.04770266f, 0.15673438f, 
    -0.24643679f, 0.28820118f, 0.30914211f, -0.11152717f, -0.01038676f, -0.15914086f, -0.00196220f, -0.04618369f, 
    0.00946657f, 0.00771607f, 0.22221871f, -0.03685789f, -0.12826933f, 0.01192128f, -0.02256864f, -0.10193295f, 
    0.03350796f, -0.05249618f, 0.03644097f, -0.13688278f, -0.59581035f, -0.03486178f, 0.15605679f, -0.15966207f, 
    0.14787766f, 0.02341851f, 0.06844927f, 0.00842998f, -0.05869609f, 0.12538910f, 0.04182734f, -0.02219703f, 
    -0.12349836f, -0.10202576f, 0.02013292f, -0.04807970f, 0.15713501f, 0.01492762f, 0.00243298f, -0.06765641f, 
    -0.09238354f, 0.13064700f, 0.31578147f, 0.28475496f, -0.00223654f, 0.07476634f, 0.09111843f, 0.01597938f, 
    -0.08336303f, 0.04890711f, 0.01370969f, 0.05617483f, 0.01376012f, 0.20434391f, 0.07723667f, 0.04851213f, 
    0.11321414f, 0.05305310f, -0.07846905f, 0.00758156f, -0.15490189f, -0.15329389f, -0.28661215f, -0.04835828f, 
    -0.08070619f, 0.10205900f, -0.07319902f, -0.01634863f, 0.07151369f, 0.03194350f, -0.07351249f, -0.01628723f, 
    -0.06463289f, 0.03424821f, -0.05532125f, -0.05197298f, 0.02986381f, 0.07434876f, -0.09513231f, 0.01868054f, 
    -0.00330715f, 0.27320457f, -0.01471467f, 0.00683072f, -0.08504535f, 0.06437668f, -0.14835340f, -0.12631692f, 
    0.05082122f, 0.15546998f, 0.04675723f, 0.05098772f, 0.14110734f, 0.02766788f, 0.16269599f, 0.08893911f, 
    0.10179465f, 0.00499086f, 0.08041514f, -0.05922216f, -0.03417375f, -0.11373485f, 0.00120823f, 0.13180952f, 
    0.14438735f, 0.06611070f, 0.00483722f, 0.21748371f, -0.03969151f, 0.06517878f, 0.10050727f, -0.10375980f, 
    0.00391043f, 0.03907230f, 0.07288187f, 0.18650222f, 0.11020995f, 0.06006596f, 0.07926670f, 0.14688727f, 
    -0.10571931f, -0.05302872f, 0.22479518f, 0.14124797f, -0.21195929f, 0.05939594f, 0.13290627f, 0.01492807f, 
    -0.18501480f, 0.11335780f, -0.03453021f, -0.09437900f, -0.07168429f, 0.01342243f, 0.10597128f, 0.10203279f, 
    -0.06212569f, -0.03889666f, 0.00886994f, -0.04022135f, 0.14391145f, 0.12247497f, 0.13065207f, 0.13382040f, 
    0.18330047f, -0.07470728f, 0.15906954f, -0.00494287f, -0.07917076f, -0.00338364f, -0.05866537f, -0.00513773f, 
    0.00277662f, -0.05572378f, 0.10193765f, 0.08139851f, 0.01886306f, 0.03914739f, 0.11364739f, 0.07340240f, 
    -0.36145562f, -0.34880155f, -0.21227814f, 0.10433556f, 0.02997917f, 0.18308759f, 0.03103800f, -0.02969156f, 
    -0.15959971f, -0.11145121f, 0.00999468f, 0.09571680f, -0.01342846f, 0.01861360f, 0.02474191f, -0.00215209f, 
    0.08619655f, 0.03604189f, -0.10162434f, 0.01526815f, -0.28145748f, 0.14855148f, 0.01304554f, 0.08937512f, 
    -0.02069707f, 0.05390836f, 0.08604693f, -0.02209690f, -0.07458670f, 0.13416074f, 0.06233034f, 0.07921876f, 
    0.06523519f, 0.02671930f, 0.04555484f, 0.10888831f, 0.11169249f, 0.09042578f, 0.08101415f, 0.12089697f, 
    -0.07648841f, -0.06904425f, -0.18354115f, 0.01682034f, -0.10834479f, 0.09602423f, 0.02671241f, -0.06046889f, 
    -0.01528631f, 0.20866665f, 0.03005208f, 0.01225813f, -0.00543786f, 0.01278459f, -0.09279151f, -0.06024432f, 
    0.11707806f, 0.16128671f, -0.09996939f, -0.00801506f, 0.25247851f, 0.25678903f, 0.22782041f, -0.01083689f, 
    0.21881022f, -0.01858864f, 0.05901039f, 0.04528109f, -0.03293480f, -0.00589860f, -0.03239886f, 0.13711163f, 
    0.07651591f, 0.04199857f, 0.22239985f, 0.03855729f, 0.15492171f, 0.04416980f, -0.07266852f, 0.16633107f, 
    -0.45490018f, -0.16541588f, -0.10446217f, -0.07993694f, -0.08441987f, 0.15204705f, 0.17109104f, 0.12812071f, 
    -0.15102844f, 0.04662754f, 0.08924163f, 0.02071700f, 0.02116528f, -0.10718524f, 0.04528509f, 0.04602267f, 
    -0.01375609f, 0.05985514f, -0.05719960f, 0.10593740f, -0.06650285f, 0.06986655f, -0.17161912f, -0.12002800f, 
    -0.08116051f, 0.27356035f, 0.04951806f, 0.13825843f, -0.02313162f, -0.01250691f, 0.06762014f, 0.00396856f, 
    0.09093654f, -0.05215400f, 0.03240816f, 0.09528354f, 0.08001420f, -0.08347081f, -0.07526327f, -0.02385668f, 
    -0.16030918f, 0.12008722f, -0.22685337f, 0.07981389f, 0.07132840f, -0.07010844f, 0.07092751f, -0.06068289f, 
    0.11567729f, 0.09514659f, 0.09031571f, 0.19590402f, 0.13486475f, -0.01418994f, 0.14974096f, 0.01956461f, 
    0.03126883f, 0.13608736f, -0.04280991f, 0.11726107f, 0.17381024f, -0.14509352f, -0.11100248f, 0.08585720f, 
    -0.02235885f, -0.10069884f, 0.07199645f, 0.00563565f, -0.00981545f, 0.12427223f, 0.02906334f, 0.04565153f, 
    -0.07285666f, 0.03223075f, -0.11361182f, 0.01917038f, 0.11824252f, -0.23075221f, -0.00280548f, 0.02449939f, 
    -0.08459882f, -0.05784073f, -0.07613847f, -0.14265133f, 0.05268661f, 0.08575165f, 0.02111272f, 0.09617886f, 
    0.01850429f, 0.11026430f, 0.10359998f, -0.00961616f, 0.10198984f, 0.01009351f, -0.01877912f, -0.05112793f, 
    -0.03822804f, 0.07106607f, 0.03128948f, -0.10400828f, 0.16372605f, -0.09394906f, -0.36429596f, -0.17663063f, 
    -0.13997832f, -0.00074951f, -0.04865771f, 0.01342370f, 0.10944825f, 0.06469958f, -0.04790786f, -0.00412643f, 
    -0.00070929f, -0.06908114f, 0.00068246f, 0.14265634f, 0.03703097f, 0.00395628f, 0.07302997f, 0.06939106f, 
    -0.05390942f, 0.04972949f, -0.00384005f, -0.03628063f, -0.05034470f, -0.02950350f, 0.02716539f, 0.01525890f, 
    -0.04400578f, -0.02372916f, -0.05298371f, 0.00948841f, -0.05453838f, 0.05097106f, 0.01289009f, -0.04441877f, 
    0.00230132f, -0.04584692f, -0.05679661f, -0.04238568f, -0.05065290f, 0.05582738f, 0.03060428f, 0.00495972f, 
    0.05007668f, 0.02263505f, -0.03346788f, 0.02696737f, 0.01141206f, -0.00425023f, 0.03960638f, -0.00717129f, 
    0.02400009f, -0.03944533f, -0.00553969f, 0.01121457f, -0.05613393f, 0.01912524f, -0.02883272f, -0.05144123f, 
    -0.05567454f, -0.01584630f, 0.03953249f, -0.02730073f, -0.00190433f, -0.03607360f, -0.01112868f, -0.05326543f, 
    -0.02697636f, 0.00821622f, -0.04014253f, -0.02373576f, 0.04437811f, 0.01393762f, -0.00867265f, -0.00738361f, 
    0.00311517f, -0.04704998f, 0.00874855f, -0.02015466f, -0.04666381f, -0.01238197f, -0.03324210f, -0.01181898f, 
    0.03540002f, 0.00235350f, -0.05046393f, 0.00789468f, 0.01966882f, 0.00323059f, -0.03924255f, -0.05408381f, 
    -0.02869930f, -0.03800350f, 0.03817476f, 0.01955533f, -0.05178664f, -0.03746227f, 0.01108804f, 0.02611853f, 
    -0.03328484f, 0.04687024f, -0.04059816f, -0.05028728f, -0.01037377f, 0.05171036f, 0.02117425f, 0.01825540f, 
    -0.02045575f, -0.01715907f, -0.01382129f, 0.02747457f, -0.03152707f, 0.04137965f, 0.00849393f, -0.03920696f, 
    0.02373286f, -0.05496169f, 0.04125438f, -0.03449928f, 0.01623910f, 0.03516402f, -0.05500542f, -0.04076047f, 
    0.01977154f, -0.03230255f, 0.01099282f, 0.05035516f, 0.01196207f, -0.01269563f, 0.01211260f, -0.05603177f, 
    -0.05796513f, -0.05951426f, -0.02468502f, -0.01827781f, 0.04723110f, -0.01653723f, -0.03205086f, 0.03885034f, 
    -0.00010980f, 0.03211586f, -0.01860340f, -0.02781846f, -0.01079680f, 0.05086591f, -0.00080712f, 0.04866281f, 
    -0.01387391f, -0.03906941f, -0.03744875f, -0.03142282f, 0.02491156f, -0.04300354f, -0.01492546f, 0.01883565f, 
    -0.00305633f, -0.02823851f, -0.00125254f, 0.05100178f, 0.04196964f, -0.03104226f, -0.02526173f, -0.02704207f, 
    0.04973946f, 0.03989805f, 0.00734079f, 0.02486670f, -0.00676871f, -0.05834587f, 0.04110849f, -0.04435893f, 
    0.00313257f, 0.03105067f, 0.03735793f, -0.02919691f, 0.02127754f, 0.01761860f, 0.04355015f, -0.03651413f, 
    -0.03457124f, -0.02521451f, -0.01798240f, -0.00876159f, -0.02180601f, -0.05018218f, 0.00412682f, -0.02981606f, 
    0.00106614f, 0.02274870f, 0.00850247f, 0.00861255f, -0.05178584f, -0.03137409f, 0.02793968f, -0.04224792f, 
    0.00275213f, -0.04194373f, 0.02101717f, 0.03026739f, 0.02879209f, -0.03090474f, -0.00096352f, 0.01962601f, 
    0.03051771f, -0.04646726f, -0.03783937f, -0.01966646f, 0.05421806f, -0.05640348f, -0.04286316f, -0.03835529f, 
    -0.01483279f, -0.01042539f, 0.03733993f, -0.02155308f, -0.01092678f, -0.00182446f, -0.02280406f, -0.04394511f, 
    -0.02058035f, 0.00715443f, 0.04111650f, -0.05105269f, -0.03480543f, 0.04599490f, -0.03733002f, -0.04750825f, 
    -0.01283747f, -0.03501861f, -0.01196391f, 0.01824998f, -0.04924899f, -0.03972665f, 0.02768106f, -0.03819519f, 
    0.01801555f, 0.01785212f, 0.02723262f, 0.00865392f, -0.01155803f, -0.00753483f, -0.00749334f, 0.00913602f, 
    0.02189237f, -0.00462906f, -0.05604375f, -0.02280126f, 0.02994490f, -0.02692628f, 0.04463563f, -0.05068401f, 
    -0.02100942f, 0.03739854f, -0.03716481f, -0.00494091f, 0.02821609f, -0.01415793f, -0.05031785f, 0.00722516f, 
    -0.04972918f, 0.00675759f, -0.05764258f, 0.00527465f, -0.01771856f, 0.00909663f, -0.04128927f, -0.02460664f, 
    0.04080618f, 0.03910867f, 0.03638496f, -0.01098521f, -0.03396001f, -0.00797179f, -0.02707136f, -0.03136210f, 
    -0.05157215f, 0.01659775f, 0.00595661f, -0.00161345f, -0.01620351f, -0.05664560f, 0.02680507f, -0.05506598f, 
    -0.02277364f, 0.02951926f, 0.03960035f, 0.00418931f, 0.01150102f, -0.05928364f, -0.00427835f, 0.01445808f, 
    0.03861031f, 0.04766980f, 0.01981270f, 0.02528379f, 0.05490456f, 0.00998642f, -0.05176455f, 0.02434137f, 
    0.02080904f, 0.04398498f, 0.03824373f, -0.04393785f, -0.01657172f, 0.03924999f, 0.04590118f, 0.01911314f, 
    -0.03784899f, 0.00451402f, -0.01249984f, -0.01342045f, 0.01516212f, -0.05175687f, -0.01860634f, 0.02885227f, 
    0.00147876f, 0.05153717f, 0.01279291f, -0.02185021f, -0.01600549f, -0.04384765f, -0.00021593f, -0.01568215f, 
    -0.03004402f, 0.00781010f, 0.01324520f, -0.01632428f, 0.04684298f, -0.02470857f, 0.04163013f, -0.00851859f, 
    -0.01389985f, 0.04019040f, 0.01545672f, 0.03764253f, 0.01942499f, -0.00428826f, -0.03324556f, 0.03906301f, 
    0.00446155f, 0.02707615f, 0.04157481f, -0.03118756f, -0.05966792f, -0.05774088f, 0.00766423f, -0.01665738f, 
    -0.06368936f, -0.04642771f, -0.06507703f, -0.03274661f, -0.00079490f, 0.02151954f, -0.05162985f, 0.00017226f, 
    -0.03544293f, -0.04514928f, -0.01631197f, 0.02754005f, -0.01962369f, 0.00670467f, -0.00406955f, 0.00244376f, 
    -0.06396449f, 0.04015294f, -0.03949765f, 0.01669883f, -0.04878340f, -0.01737097f, 0.00955860f, 0.04110997f, 
    0.02181361f, -0.00637590f, -0.05367200f, -0.03464404f, 0.01365047f, 0.04179523f, 0.00576779f, -0.02670407f, 
    -0.05893081f, -0.04130533f, -0.00207060f, -0.06431898f, -0.03663276f, -0.04995076f, -0.00483689f, 0.03691898f, 
    0.01256678f, 0.03197387f, -0.00361271f, -0.03946670f, 0.01698833f, -0.00731558f, -0.04345227f, -0.00599783f, 
    -0.03537779f, -0.02360722f, -0.00408899f, -0.01586454f, -0.01067923f, -0.06319014f, 0.02066223f, -0.01147812f, 
    -0.05712096f, 0.00840260f, -0.02447822f, 0.03546605f, 0.04314100f, 0.02663590f, -0.00433003f, -0.05162852f, 
    0.03320238f, -0.05122821f, 0.01184485f, -0.02909062f, -0.05627944f, -0.01325998f, -0.01938015f, -0.04000122f, 
    -0.02729964f, 0.04121343f, -0.05100159f, 0.02869269f, -0.06114037f, 0.01391563f, 0.00440721f, -0.05048049f, 
    -0.01958549f, -0.00867069f, -0.02859209f, 0.00237818f, -0.04443662f, 0.03434063f, 0.04015053f, -0.02235145f, 
    -0.03450461f, -0.01656350f, -0.03703963f, -0.01842169f, 0.01169966f, 0.03992891f, -0.00202792f, 0.03973383f, 
    0.02192440f, 0.03203833f, 0.01368706f, 0.04115707f, 0.01372760f, -0.04094396f, 0.03975318f, -0.03192240f, 
    0.03259680f, 0.04480963f, 0.03213535f, 0.01281361f, 0.02867744f, -0.04122259f, -0.02534711f, 0.00584464f, 
    -0.02115626f, 0.01683901f, -0.02092186f, -0.02514217f, 0.01499507f, 0.01215555f, -0.00382285f, 0.01766704f, 
    0.03593547f, -0.06448665f, -0.04699117f, -0.01679213f, -0.02429651f, -0.03174388f, 0.01468756f, -0.04061319f, 
    -0.03283799f, -0.01679155f, 0.04355851f, -0.01739592f, 0.02194102f, 0.00892519f, 0.01701957f, 0.04238687f, 
    -0.01265800f, -0.00860155f, 0.00470090f, -0.03305455f, 0.02730080f, 0.00965798f, 0.00111727f, 0.02430522f, 
    -0.04125955f, -0.05999106f, -0.05958684f, 0.00322185f, -0.02910266f, -0.04113927f, -0.01616619f, 0.02194982f, 
    0.01704967f, -0.04400388f, -0.01768110f, -0.01554598f, -0.00852154f, 0.02384001f, 0.00550304f, -0.03872075f, 
    -0.04725340f, 0.02375166f, -0.06025726f, 0.00544244f, -0.02911817f, 0.02599132f, -0.06260797f, -0.03923941f, 
    -0.01122318f, 0.01531325f, -0.02707762f, -0.03010356f, 0.00276052f, -0.04325721f, 0.04542628f, -0.05535299f, 
    -0.04093634f, 0.03493742f, -0.01806542f, 0.03438250f, -0.05491702f, -0.05467843f, 0.00127466f, 0.04241671f, 
    0.01399295f, -0.02349842f, -0.03588287f, 0.01272921f, 0.02387447f, -0.02598186f, 0.03054786f, 0.03173974f, 
    -0.02347691f, 0.04498077f, -0.04825152f, 0.02081494f, -0.02489868f, 0.00780645f, 0.03569080f, -0.04026511f, 
    0.01861135f, 0.00792944f, 0.00910365f, 0.04313917f, 0.04523327f, -0.03346656f, -0.02744576f, -0.04325093f, 
    -0.05350948f, -0.04676194f, -0.04005634f, 0.01602820f, -0.04164631f, 0.02839163f, -0.02111831f, 0.03040254f, 
    -0.02323069f, -0.05820875f, -0.03458601f, 0.01127039f, -0.05054976f, 0.01609355f, -0.04189635f, -0.04755756f, 
    -0.04070825f, -0.02713616f, 0.02364592f, -0.01735263f, -0.01777275f, -0.01875372f, 0.03651224f, -0.05530295f, 
    0.01440167f, 0.03777328f, 0.02978189f, -0.03105313f, 0.02792376f, 0.02102305f, 0.00261613f, 0.02641071f, 
    -0.05563074f, 0.03345810f, -0.00972363f, 0.03043278f, 0.03391182f, -0.02915852f, -0.05223752f, -0.02348285f, 
    -0.06502306f, 0.03660184f, -0.02095416f, 0.02285338f, 0.02075803f, -0.04673267f, -0.02075177f, 0.02434529f, 
    -0.02066546f, 0.02151868f, -0.03402639f, 0.03054036f, -0.05493136f, -0.01470372f, 0.02363805f, -0.05441461f, 
    0.01242598f, 0.01336734f, -0.04712236f, 0.00594045f, -0.00494908f, -0.04103003f, -0.05787807f, 0.03196450f, 
    -0.00077675f, 0.01687466f, -0.01584997f, -0.06301562f, 0.00111382f, -0.04742318f, -0.05213630f, -0.03572505f, 
    0.01982379f, -0.05808469f, -0.06446321f, 0.04921115f, 0.00746063f, 0.00785102f, -0.00659135f, -0.06411140f, 
    -0.06492240f, -0.05110289f, -0.00022255f, 0.03003404f, 0.03550590f, 0.04068902f, -0.03786347f, 0.03368985f, 
    -0.05919535f, 0.03585146f, -0.03493806f, 0.00305174f, -0.04233365f, -0.04823101f, 0.02626322f, -0.04780927f, 
    0.03863571f, -0.00610082f, 0.03972108f, -0.04021556f, 0.01290325f, 0.03790358f, -0.06211258f, 0.04253903f, 
    0.03151897f, -0.00920912f, -0.04544071f, -0.05655731f, -0.01672083f, -0.03268743f, 0.03698462f, 0.04670445f, 
    -0.04537313f, 0.02443808f, -0.05384317f, 0.01645489f, -0.03449297f, -0.04125240f, 0.01383989f, 0.04646455f, 
    -0.02728763f, -0.06315298f, 0.00912314f, -0.04001243f, 0.01017574f, -0.01538025f, 0.00882806f, -0.04665001f, 
    -0.00295250f, -0.01571255f, -0.05126354f, -0.02790087f, 0.02167322f, 0.05332655f, -0.00854755f, 0.02059334f, 
    0.01799069f, -0.00181644f, -0.01297445f, 0.00676259f, 0.01397418f, -0.05365829f, 0.01436489f, 0.03386091f, 
    -0.05821155f, -0.04447122f, 0.04700286f, -0.02543537f, 0.01522510f, -0.05801964f, -0.01528295f, -0.02212578f, 
    -0.06209636f, 0.02535317f, 0.00737484f, 0.02902321f, 0.03077524f, -0.02397329f, -0.04662286f, -0.02015319f, 
    -0.06559325f, -0.01934042f, -0.00136644f, -0.01447720f, 0.00893220f, -0.01906230f, -0.00214945f, -0.06652597f, 
    0.01330367f, 0.00506180f, 0.02511444f, 0.04795099f, 0.03966136f, 0.01806556f, 0.01514941f, -0.01698902f, 
    -0.00554030f, -0.04552910f, -0.04296092f, 0.00736505f, -0.05140008f, 0.04619037f, 0.02712849f, -0.00841850f, 
    -0.04766645f, -0.04350913f, -0.00943693f, -0.05208991f, 0.02400161f, -0.04728951f, 0.02320551f, -0.03829376f, 
    0.01085640f, -0.04919672f, -0.02070207f, -0.05802649f, -0.01218580f, -0.00185999f, -0.02376208f, -0.02473583f, 
    -0.04279919f, -0.02367077f, -0.06945470f, -0.05010350f, -0.05815751f, -0.03578012f, 0.01411541f, -0.05989322f, 
    0.03486942f, 0.02563608f, -0.02669860f, 0.00674835f, 0.00656759f, 0.03368724f, -0.05999623f, -0.05192939f, 
    -0.05567009f, 0.01087284f, -0.00259907f, 0.01238220f, -0.05112762f, 0.00427174f, -0.05326792f, 0.01309442f, 
    0.04515014f, 0.02589742f, -0.00222359f, -0.05578494f, 0.02566230f, -0.04242422f, -0.02649718f, 0.04305619f, 
    -0.04607297f, -0.05436765f, 0.04235567f, -0.00533004f, -0.02588311f, 0.02494664f, -0.04385206f, -0.00411206f, 
    0.03023914f, -0.02563674f, -0.03262925f, -0.01903834f, -0.06103963f, -0.03106675f, 0.01929163f, -0.02763179f, 
    -0.03366555f, 0.03864366f, -0.02390440f, 0.03905837f, 0.01267925f, 0.00224579f, -0.04522663f, 0.00187924f, 
    0.01083146f, 0.00505882f, -0.01175680f, 0.00468996f, 0.04354401f, 0.01291636f, 0.02586379f, 0.00484419f, 
    -0.01934888f, -0.00155225f, -0.03898793f, -0.02767516f, -0.05017271f, 0.01274889f, -0.01119490f, 0.01709897f, 
    0.04520297f, 0.04147189f, -0.05703118f, 0.01154759f, -0.06252211f, -0.02967059f, -0.03111676f, 0.03140535f, 
    0.00413556f, -0.05570783f, 0.03996181f, 0.03761623f, -0.00901397f, 0.02521821f, -0.03602149f, -0.03905107f, 
    0.00184875f, -0.04579721f, 0.02567547f, -0.03468848f, 0.02673435f, 0.03549683f, -0.06101614f, -0.00254634f, 
    0.02086636f, -0.02817313f, -0.02061711f, -0.03225656f, -0.01912837f, -0.03331272f, 0.04669686f, -0.01605171f, 
    -0.01328327f, -0.03728635f, -0.04602586f, -0.01065308f, 0.00524921f, 0.01947114f, -0.03479584f, -0.03789995f, 
    0.04309156f, 0.02740938f, -0.01528887f, -0.01331278f, -0.03839249f, 0.02973304f, -0.00128828f, 0.01074992f, 
    -0.05576083f, -0.03493759f, -0.01036085f, -0.02661696f, -0.00790861f, -0.00613744f, -0.00318282f, -0.01814232f, 
    -0.03136027f, -0.00607944f, 0.04103765f, 0.00805739f, -0.02452251f, 0.05022185f, -0.00433679f, -0.02030536f, 
    -0.00544649f, 0.02396415f, 0.04296917f, -0.02293372f, -0.03704729f, 0.01650559f, -0.00299424f, -0.01666061f, 
    0.03224846f, 0.01240861f, -0.01280808f, -0.01992583f, -0.03737115f, 0.00964801f, -0.04838275f, -0.04951353f, 
    0.02378954f, 0.00375841f, 0.03798190f, -0.05446164f, -0.05435794f, 0.01087053f, -0.01807918f, -0.03420478f, 
    0.01343604f, -0.05242049f, -0.05752980f, -0.01522927f, -0.05102076f, -0.04147546f, 0.04559471f, -0.04733942f, 
    0.00311023f, 0.00030674f, -0.03726954f, -0.03881590f, 0.01780079f, 0.00539153f, -0.02380451f, 0.02380874f, 
    0.03107773f, -0.01627553f, -0.01585414f, 0.04411354f, -0.06001576f, 0.02002155f, -0.01816936f, 0.02940407f, 
    -0.03432031f, 0.01685645f, 0.04652487f, 0.01589199f, 0.02631071f, 0.01342930f, -0.06267000f, -0.02530551f, 
    -0.03754533f, -0.00054948f, 0.02453741f, -0.03758248f, 0.03166173f, 0.05038776f, -0.00143190f, -0.02192044f, 
    -0.00468649f, 0.03617463f, -0.01511751f, -0.05434201f, 0.01348614f, -0.03453959f, 0.03761452f, 0.00623850f, 
    -0.06088301f, 0.01163464f, 0.00253579f, -0.03094640f, 0.00739550f, 0.03477922f, 0.02071313f, -0.06028077f, 
    -0.00760250f, 0.03082155f, -0.05626300f, -0.05699599f, 0.04436211f, -0.01555995f, 0.02060559f, -0.02136346f, 
    -0.29072613f, -0.35743403f, -0.25521982f, -0.18297003f, -0.06691904f, 0.08190803f, 0.08043218f, 0.13866016f, 
    -0.07238260f, -0.00336246f, 0.15907788f, 0.14653580f, -0.03531833f, -0.10286923f, 0.06796534f, -0.05387606f, 
    0.03845669f, 0.08356004f, 0.05053362f, 0.03618459f, 0.42904747f, 0.21449021f, 0.32311612f, -0.05135344f, 
    0.07664090f, -0.06834248f, -0.00476642f, -0.12839688f, -0.11239190f, -0.05711719f, 0.09797195f, 0.00356966f, 
    0.10374779f, -0.03623639f, -0.04580672f, -0.02828994f, -0.03860903f, 0.07621939f, 0.25756004f, -0.01694593f, 
    0.26568481f, 0.00279438f, 0.20606375f, -0.07409664f, 0.20284209f, 0.05588790f, 0.14225030f, -0.07129010f, 
    -0.05682059f, -0.01571978f, -0.01402738f, 0.07013148f, 0.02850486f, -0.04233894f, -0.09711312f, 0.02124433f, 
    0.11843416f, 0.04958316f, 0.17762648f, 0.00588089f, 0.02945397f, 0.15502606f, -0.21221384f, 0.15253364f, 
    -0.16835344f, 0.03111773f, 0.07687740f, -0.05014233f, 0.05101889f, -0.18955378f, 0.06687521f, 0.14634472f, 
    -0.03582258f, -0.03258077f, 0.07659388f, 0.05022890f, 0.11005782f, 0.09794586f, -0.05766075f, -0.01150106f, 
    -0.33212283f, -0.06673242f, -0.16617143f, -0.25387105f, 0.17250302f, 0.18342519f, 0.10897706f, -0.01614742f, 
    0.01335248f, 0.03593747f, 0.04527322f, 0.02800742f, 0.08110558f, 0.02299464f, -0.05794812f, -0.17310895f, 
    0.06474936f, 0.07096684f, -0.02785943f, -0.05731208f, -0.39755499f, -0.28327248f, 0.03238565f, -0.17002863f, 
    -0.00251005f, -0.00493494f, -0.01999141f, 0.09570010f, 0.04561901f, 0.11670876f, 0.04719231f, -0.02868541f, 
    0.14722912f, -0.03680984f, 0.12776351f, -0.04631194f, -0.05776936f, 0.03202183f, -0.00796556f, -0.05284540f, 
    0.28135794f, 0.15150668f, 0.12607187f, -0.00204758f, -0.06307888f, 0.14963180f, -0.07101735f, 0.09530178f, 
    0.12168176f, 0.18328434f, 0.02525413f, 0.03127245f, 0.08737335f, -0.06277423f, 0.02568446f, 0.01018692f, 
    -0.00122606f, -0.06147202f, 0.06510016f, 0.04299464f, 0.07741310f, -0.18327169f, -0.05297561f, -0.04133250f, 
    0.03100180f, 0.01523817f, 0.11806189f, 0.01991662f, 0.05447730f, 0.01415111f, -0.00409387f, -0.02450672f, 
    -0.00929167f, -0.00990724f, 0.00548175f, 0.15266012f, -0.03031037f, -0.15384957f, 0.04665690f, 0.08397908f, 
    0.50680768f, 0.05305346f, -0.25293863f, -0.13536777f, 0.26479751f, 0.03608522f, 0.01216050f, -0.01633931f, 
    0.09322754f, -0.01334234f, 0.04738021f, -0.03140276f, -0.00897827f, 0.05164042f, 0.07664198f, 0.10569946f, 
    -0.03317828f, -0.13383718f, 0.00120609f, 0.03000323f, 0.10472471f, 0.08842068f, -0.13040560f, 0.13916762f, 
    -0.01623003f, 0.00023572f, 0.11283207f, -0.00859797f, -0.01115578f, -0.05153807f, 0.05906379f, -0.08607752f, 
    -0.11822087f, -0.13101850f, 0.08461189f, 0.02747780f, -0.01505100f, -0.10150748f, 0.02885870f, 0.06100949f, 
    0.18658976f, 0.02945825f, -0.16378704f, 0.16826053f, -0.28709158f, 0.17212097f, 0.08545476f, -0.03404526f, 
    -0.01817148f, 0.05807896f, -0.01949701f, -0.07462952f, 0.12973648f, 0.06361412f, 0.04414053f, -0.04629336f, 
    0.03436716f, 0.06310303f, 0.05274445f, -0.02816279f, -0.11869163f, -0.13243927f, 0.14969152f, 0.17340447f, 
    -0.18822488f, -0.05758037f, -0.00198363f, 0.08365281f, -0.05087968f, 0.21487877f, -0.11813808f, -0.03799399f, 
    0.02063747f, 0.08876798f, -0.06900593f, -0.03180306f, -0.10559453f, 0.07536592f, 0.02944417f, -0.00822037f, 
    0.26854813f, 0.17999896f, 0.04850029f, 0.05994959f, -0.13807508f, -0.05829585f, 0.16033331f, 0.09272376f, 
    0.04513242f, -0.03194505f, -0.08248781f, -0.05528705f, -0.04192140f, -0.03377654f, 0.03756385f, 0.08150868f, 
    0.10281032f, -0.05979315f, -0.02205833f, 0.07430717f, 0.15106091f, 0.21627957f, -0.15427342f, -0.08874476f, 
    -0.03678129f, 0.23263848f, -0.00521737f, -0.07065719f, 0.16786264f, -0.15740366f, 0.11814466f, 0.00256868f, 
    0.11268611f, -0.13335809f, -0.04454168f, 0.02682851f, -0.01659620f, 0.21282017f, 0.16522676f, 0.16246557f, 
    -0.43676764f, 0.13978381f, 0.09551734f, 0.16697668f, -0.02363031f, -0.02994564f, -0.11171498f, 0.14110433f, 
    0.05133141f, 0.09384440f, -0.08156192f, -0.14194696f, -0.07484052f, 0.03060795f, -0.01839880f, -0.13336064f, 
    -0.05408777f, 0.03555590f, -0.00630500f, 0.01236859f, 0.20624214f, 0.03899319f, 0.48365894f, 0.27301422f, 
    0.46802068f, -0.16064219f, -0.16848046f, -0.10332822f, 0.07897940f, 0.02252479f, -0.05111669f, 0.00836414f, 
    0.03560114f, 0.04557533f, -0.06277600f, -0.10603304f, -0.00480616f, -0.01030581f, -0.02624792f, -0.02616627f, 
    0.43821603f, 0.01833921f, 0.35336575f, 0.15524222f, 0.42923847f, -0.24215668f, -0.01902067f, -0.04870587f, 
    0.07169028f, -0.04404873f, 0.08462497f, 0.00291300f, 0.00249553f, 0.00489458f, 0.02941095f, 0.16598706f, 
    0.00708858f, -0.00148846f, 0.04604184f, -0.03140215f, -0.11001101f, -0.23923549f, -0.30269653f, 0.24876671f, 
    -0.13111019f, 0.04408569f, 0.21406099f, 0.07805414f, 0.34034008f, 0.34154844f, 0.00526259f, 0.03262584f, 
    0.00711183f, 0.12101961f, 0.13288581f, 0.25423840f, 0.06110529f, -0.08147603f, 0.17868730f, 0.12013913f, 
    -0.14031895f, -0.20498151f, -0.08937852f, 0.22813873f, -0.52675438f, 0.08911787f, 0.10274940f, -0.01853974f, 
    0.04077782f, 0.03007866f, 0.18243955f, -0.00603909f, 0.10016029f, 0.11380897f, -0.08440824f, -0.06006967f, 
    0.03727539f, -0.05734433f, 0.02631273f, 0.21748079f, 0.28190514f, -0.29754263f, 0.21494052f, -0.18115996f, 
    -0.06775598f, -0.05381596f, -0.16772486f, 0.03938906f, 0.10578965f, 0.03498971f, -0.07041758f, 0.09377148f, 
    0.06488267f, -0.05016653f, 0.10680065f, -0.10931182f, 0.05326125f, -0.01798756f, 0.01977995f, -0.05859259f, 
    0.33934391f, 0.35456890f, 0.26247305f, -0.00132439f, 0.21428907f, -0.15696560f, 0.00575174f, -0.01014530f, 
    0.05828719f, -0.02117200f, 0.03046796f, 0.00370082f, -0.09255302f, 0.18211915f, 0.14102829f, 0.02443719f, 
    0.08476480f, -0.03035950f, -0.03697144f, 0.18873459f, 0.25629115f, 0.44517726f, -0.09283449f, -0.12168773f, 
    0.02112338f, 0.17338264f, 0.03221806f, 0.09552003f, 0.14086504f, 0.04259037f, 0.13190775f, 0.02923319f, 
    0.09060784f, 0.15634051f, 0.11845086f, -0.00053723f, 0.13137244f, 0.03659797f, 0.03187515f, 0.14388022f, 
    0.18177129f, 0.11212225f, 0.00971999f, 0.21354173f, -0.07339352f, -0.24490248f, 0.00887758f, 0.00163817f, 
    0.08645931f, 0.11574709f, -0.04793079f, -0.10009641f, 0.07457574f, 0.12773581f, -0.05999545f, 0.05543492f, 
    0.01031607f, 0.12208711f, 0.00129542f, -0.13803259f, -0.05194008f, 0.48883480f, 0.19016987f, -0.10839673f, 
    0.48705563f, -0.09070661f, -0.08489109f, 0.05803975f, 0.08209611f, 0.04269795f, 0.14734244f, 0.06725813f, 
    0.00952319f, -0.00665965f, 0.12021088f, -0.09889578f, 0.04255588f, -0.04717308f, -0.11567502f, 0.07493464f, 
    -0.29812017f, 0.35528824f, 0.28104591f, -0.15875192f, -0.07585593f, 0.04658941f, -0.09859098f, 0.21169205f, 
    -0.03482386f, 0.06309176f, -0.08651891f, 0.03167404f, 0.04217301f, -0.00872716f, 0.03576780f, 0.05078576f, 
    0.10451488f, -0.03688728f, 0.07231628f, 0.09022569f, -0.27746084f, 0.04177376f, 0.09750050f, -0.03203366f, 
    -0.08030345f, 0.17747393f, 0.09534527f, 0.07586345f, 0.05494548f, 0.18808596f, 0.02824814f, 0.04023029f, 
    0.09276524f, 0.11515985f, -0.11940876f, 0.02806400f, -0.05277044f, 0.00097045f, -0.03591634f, -0.00459939f, 
    0.38117602f, -0.13800041f, 0.34957322f, -0.12930535f, 0.48452473f, -0.09462110f, -0.12456696f, 0.16623811f, 
    -0.04467618f, -0.03212929f, -0.11838474f, -0.00341394f, -0.03295634f, -0.02302101f, -0.01840912f, 0.08136754f, 
    0.07181514f, 0.10827843f, -0.01178308f, -0.04187860f, 0.43759567f, -0.09917621f, 0.20561495f, -0.15609153f, 
    0.04813768f, 0.09330066f, -0.12972644f, 0.04161465f, 0.06775478f, -0.02675415f, 0.07054140f, 0.00758714f, 
    -0.01838342f, 0.14010030f, 0.00650647f, 0.10408675f, 0.04630108f, 0.03027748f, -0.06444816f, 0.10144244f, 
    -0.31631720f, 0.29537687f, -0.09704293f, -0.18219920f, 0.42587617f, 0.10260254f, 0.09705183f, 0.12935974f, 
    0.17164324f, -0.00655387f, 0.03337200f, -0.07330009f, 0.08914513f, 0.06310055f, -0.08779602f, -0.03525202f, 
    -0.02531237f, -0.01159295f, 0.06130088f, -0.01258750f, -0.14073007f, -0.16074388f, 0.20544794f, -0.14635125f, 
    0.17970808f, -0.04927196f, -0.04750951f, 0.07872074f, -0.09746218f, 0.09320090f, 0.02429235f, 0.10963833f, 
    -0.12636140f, 0.02097618f, 0.21799563f, 0.11690655f, 0.02779678f, 0.12765981f, -0.02105879f, -0.06389222f, 
    0.39132261f, -0.02691641f, 0.13752711f, 0.08133179f, -0.39737606f, 0.22314793f, 0.06115688f, 0.07646260f, 
    -0.08181236f, 0.09071903f, 0.18751785f, -0.05196853f, 0.05765999f, 0.13225403f, 0.14004287f, 0.15149298f, 
    0.04452376f, 0.02167450f, -0.01481673f, 0.06763216f, -0.17641446f, 0.12729326f, -0.14881039f, 0.16464897f, 
    -0.35536748f, 0.18251705f, 0.09736528f, 0.10694460f, 0.21776865f, 0.29478276f, 0.12112657f, 0.08911163f, 
    0.02623693f, 0.11576521f, 0.07198755f, 0.03615223f, 0.15696834f, 0.13831037f, 0.07450326f, 0.06510010f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04994034f, 0.03448477f, 0.00453771f, -0.02214815f, 0.03669135f, 0.05189622f, -0.01730789f, 0.04146262f, 
    0.03664352f, -0.04766522f, 0.04247876f, 0.03845020f, 0.01456878f, 0.01422986f, -0.00886838f, 0.01977018f, 
    -0.02162129f, 0.00088650f, -0.06970100f, 0.14829293f, -0.04963376f, -0.05315876f, 0.00491386f, 0.02317950f, 
    0.02808676f, -0.01386632f, 0.23040408f, 0.04203938f, 0.01555033f, 0.02694501f, -0.00886953f, -0.01762609f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.78388518f, 0.12115174f, -0.07695642f, 0.13615923f, 0.10861835f, 0.31218517f, 0.09634117f, -0.11988506f, 
    -0.06135825f, 0.11047460f, -0.07274467f, -0.10074996f, 0.36945358f, 0.07745139f, 0.29780006f, 0.25438520f, 
    -0.36991820f, -0.07071650f, -0.11168483f, 0.17981301f, -0.16791034f, 0.06317541f, -0.10398924f, 0.23588522f, 
    -0.13965732f, -0.31332377f, -0.16927251f, 0.07170336f, -0.15808305f, 0.11172011f, 0.29624197f, 0.14307721f, 
    -0.55281878f, 0.10082010f, -0.14335883f, 0.16204791f, -0.12981674f, 0.41656882f, -0.05115789f, -0.13470317f, 
    0.01282693f, -0.02891806f, 0.03892497f, -0.20983927f, 0.34388217f, -0.13064124f, -0.30021235f, 0.08314677f, 
    -0.03487394f, -0.25990447f, 0.22051568f, 0.31557781f, 0.01161955f, -0.10770543f, 0.00236425f, -0.11847273f, 
    0.11282245f, -0.19618601f, 0.47017181f, 0.04132557f, 0.00901673f, 0.04159611f, -0.05000912f, 0.10805751f, 
    -0.06659982f, 0.04580013f, -0.11481676f, -0.15044992f, -0.17122994f, -0.58404523f, 0.04561795f, -0.07114266f, 
    0.07622775f, -0.10383262f, 0.17030253f, 0.11361322f, -0.02505663f, 0.17177612f, -0.14542751f, -0.15270533f, 
    0.16881329f, 0.48135930f, 0.35857394f, 0.25305739f, -0.01855642f, -0.09200463f, -0.05412921f, -0.37407181f, 
    0.21894248f, 0.01460860f, -0.10100298f, -0.17899571f, -0.08550822f, 0.16278800f, 0.12971701f, 0.03984566f, 
    0.10635015f, 0.09147012f, 0.10510881f, 0.16406217f, -0.12231173f, -0.66843098f, 0.12160875f, 0.01677267f, 
    -0.16807425f, 0.08805042f, 0.37841198f, 0.33096811f, 0.09035253f, -0.16201404f, 0.40004930f, -0.20405670f, 
    -0.20881702f, 0.02768178f, 0.26479095f, 0.00145552f, -0.12832598f, -0.11759200f, -0.08897603f, -0.12608947f, 
    0.15258217f, 0.08370468f, 0.32691658f, 0.09378356f, -0.03512161f, -0.15816763f, -0.15871239f, 0.09977950f, 
    -0.16764396f, -0.05004657f, -0.11362650f, -0.04754569f, 0.14804167f, 0.04756453f, 0.09435005f, -0.02593608f, 
    -0.05904163f, -0.03220520f, 0.20860389f, 0.05562744f, 0.68069804f, -0.06170916f, -0.08803973f, 0.32521927f, 
    0.39781797f, 0.02473103f, 0.10927492f, 0.17592205f, -0.13245450f, 0.13804613f, 0.16751307f, -0.05760729f, 
    -0.29050624f, 0.15398020f, 0.16918400f, -0.00795238f, -0.00716001f, 0.05023514f, 0.23300801f, -0.18680556f, 
    0.22559178f, 0.05180232f, 0.06277521f, -0.13953371f, -0.12140172f, 0.35971275f, 0.16702652f, -0.08871809f, 
    0.12893742f, 0.11437812f, -0.49730751f, 0.22524458f, 0.33349094f, -0.15597282f, -0.41203073f, 0.06367866f, 
    -0.05556779f, 0.07494351f, -0.46813464f, 0.17543191f, -0.07910850f, -0.12030329f, 0.06895000f, 0.47649428f, 
    0.11694863f, -0.13612238f, 0.19185990f, 0.05441140f, 0.14454509f, -0.13727263f, 0.05633117f, -0.02504445f, 
    0.14759979f, 0.30313322f, -0.05334217f, 0.13994192f, 0.04817491f, -0.34302819f, -0.06074740f, -0.15993842f, 
    -0.07414016f, 0.04081505f, 0.44614026f, -0.33092111f, 0.18352775f, -0.10813414f, -0.35023296f, 0.20335793f, 
    0.36446601f, 0.13812231f, 0.04432483f, 0.15331727f, -0.02451571f, 0.14430042f, -0.15598451f, -0.11978243f, 
    -0.37946656f, -0.18377203f, 0.16169864f, -0.07386283f, 0.09117956f, 0.10156146f, -0.14863929f, 0.17385085f, 
    0.06377073f, -0.03802598f, -0.06610558f, -0.06615204f, 0.03478504f, -0.18009928f, -0.15343559f, -0.00931233f, 
    -0.02199151f, -0.04345795f, -0.12065440f, -0.15982963f, 0.12458127f, -0.03903431f, -0.09228126f, -0.04315165f, 
    0.09623223f, -0.05114840f, 0.08209047f, -0.06240050f, 0.13671422f, -0.15216626f, -0.09883495f, -0.06710126f, 
    -0.03915621f, 0.13535611f, 0.15218301f, -0.10453704f, -0.04722346f, -0.04885129f, 0.04962020f, -0.18438947f, 
    0.23285474f, 0.23773447f, -0.11721344f, -0.07321133f, 0.03489302f, 0.27784172f, -0.12590964f, -0.00756913f, 
    -0.07534724f, -0.11513634f, 0.07721855f, 0.21593803f, -0.13598414f, -0.05492446f, -0.40632960f, -0.04723527f, 
    0.38458022f, 0.39507946f, -0.02558153f, -0.03078527f, -0.06683447f, -0.06091437f, 0.13754301f, 0.05378964f, 
    -0.02317576f, -0.01476715f, -0.21140902f, -0.09655828f, 0.03202969f, -0.09737349f, 0.06202860f, -0.23103477f, 
    0.18295246f, 0.03508335f, 0.07570281f, -0.10914035f, -0.14236072f, 0.30497175f, -0.08283377f, -0.16514403f, 
    0.06060702f, -0.16353604f, 0.01097253f, 0.14413743f, -0.00318928f, 0.02245939f, -0.21310237f, 0.23345062f, 
    0.24775991f, 0.28597382f, -0.06785694f, 0.07598072f, 0.02454668f, -0.16345695f, -0.11023653f, -0.10262001f, 
    0.02748414f, -0.34737042f, -0.24945529f, -0.06999565f, 0.03212370f, -0.06020769f, 0.13368230f, -0.13338783f, 
    -0.11360040f, -0.16958897f, -0.11241604f, -0.00247434f, -0.16638580f, 0.36092940f, 0.00526454f, 0.05012423f, 
    -0.04183385f, 0.16796817f, 0.17062879f, 0.19231887f, -0.03340218f, -0.13396272f, 0.33373764f, 0.33265513f, 
    0.18821271f, -0.36951050f, 0.20897900f, -0.13177074f, -0.06972527f, 0.00759142f, -0.10864743f, -0.24333468f, 
    -0.10938712f, -0.46785134f, -0.07764768f, 0.06240930f, 0.09803648f, 0.05891253f, 0.21543036f, -0.02101437f, 
    0.46977091f, 0.01043699f, -0.10671514f, -0.10569463f, -0.14650455f, -0.11376669f, 0.01505608f, 0.12099642f, 
    0.17427370f, 0.08386934f, 0.33360776f, -0.20710836f, -0.28289148f, -0.07402688f, 0.24825592f, -0.04638301f, 
    0.15622346f, -0.02614710f, -0.22303547f, 0.07325039f, -0.11796631f, -0.02751365f, 0.14717026f, 0.38135412f, 
    -0.24586537f, 0.17016351f, -0.19356747f, -0.12603384f, -0.11398029f, 0.05450907f, 0.16465604f, 0.18992877f, 
    0.79415649f, 0.36917409f, 0.04568656f, -0.15054630f, 0.13346414f, -0.18916678f, 0.09987632f, 0.01610340f, 
    -0.14259961f, -0.05264106f, -0.26493478f, 0.13316406f, 0.07750410f, 0.00628580f, 0.15842512f, -0.33024904f, 
    -0.53187394f, -0.17514542f, 0.25941607f, -0.07626874f, -0.08389057f, 0.03483420f, 0.16451044f, -0.16542923f, 
    0.15854408f, 0.10732718f, -0.20519698f, -0.05108869f, 0.04899137f, 0.15673456f, 0.32407302f, 0.15761299f, 
    0.25887242f, 0.29452437f, 0.00127051f, 0.01132696f, -0.06181077f, 0.12642515f, 0.08460813f, -0.05695521f, 
    0.16225673f, -0.06335056f, 0.15110829f, 0.17924279f, -0.22347945f, -0.03471095f, -0.11913770f, -0.00392001f, 
    -0.49077293f, -0.34933516f, 0.30094010f, -0.13667254f, 0.06483857f, -0.05850528f, 0.03465445f, -0.17383829f, 
    0.27131137f, -0.37857619f, 0.15048781f, -0.04541399f, -0.13697378f, 0.11376291f, 0.04489689f, 0.17724332f, 
    -0.42174771f, 0.11953957f, 0.13023603f, 0.13022102f, 0.00478854f, 0.22179629f, -0.11802549f, 0.01078231f, 
    0.05162159f, -0.08126815f, 0.14429133f, -0.13365100f, 0.18659273f, -0.13817368f, 0.34955236f, 0.05122746f, 
    -0.23566912f, -0.12004297f, 0.06076864f, 0.02561658f, -0.00818650f, 0.07560240f, 0.14228545f, 0.09474154f, 
    0.22206785f, -0.14638151f, 0.34164611f, 0.09670383f, -0.07734723f, -0.13501365f, -0.38460228f, 0.28922606f, 
    0.06212726f, -0.08554369f, 0.15025429f, 0.15465821f, -0.08403210f, 0.33492154f, 0.01435359f, 0.08072168f, 
    0.03338872f, -0.08669843f, -0.18179074f, 0.28581706f, 0.34183523f, -0.12873045f, -0.47518161f, 0.24895574f, 
    0.22914876f, 0.00639087f, 0.29750177f, -0.00918055f, 0.06088280f, 0.11213605f, 0.02066750f, 0.10418972f, 
    0.13786727f, 0.35842288f, -0.22009040f, -0.08515730f, -0.14867729f, -0.10359340f, 0.05509234f, -0.12066554f, 
    0.03315608f, -0.07702091f, 0.12334678f, -0.09000634f, -0.03501813f, -0.00630851f, -0.12563390f, -0.08174376f, 
    0.07960930f, 0.05384654f, -0.09196722f, 0.13721704f, 0.01612608f, 0.09550378f, -0.13287655f, 0.09056817f, 
    -0.15167253f, -0.14525230f, -0.05109545f, -0.02598699f, 0.10739999f, -0.01662857f, -0.06512865f, -0.04571405f, 
    -0.11303386f, 0.02575494f, -0.10270876f, -0.08900797f, -0.17113952f, -0.08711383f, 0.02783153f, 0.06009748f, 
    0.17244925f, -0.14031008f, -0.01697283f, 0.06867827f, -0.00112092f, 0.36369643f, 0.16259316f, 0.13698114f, 
    -0.02423237f, 0.02576634f, 0.02394229f, -0.37449211f, 0.56394166f, -0.09287701f, -0.19777013f, 0.57704800f, 
    0.20715633f, 0.04759515f, 0.39614254f, 0.18073177f, 0.12699102f, 0.00314491f, 0.12529752f, -0.24631388f, 
    0.09307370f, 0.04676612f, -0.27198243f, 0.07250146f, -0.09690072f, 0.07388234f, 0.30237344f, 0.16043502f, 
    -0.05493348f, 0.05389046f, -0.09702307f, 0.13832203f, -0.13620047f, 0.12924096f, -0.11873570f, 0.03436210f, 
    0.12810822f, -0.12561999f, -0.16833541f, 0.12829416f, 0.14427155f, -0.15546764f, -0.03105736f, -0.03164916f, 
    -0.04546528f, -0.10112105f, -0.14089011f, -0.09396934f, -0.01385807f, 0.04817595f, -0.10262625f, -0.01152868f, 
    -0.05955102f, -0.04410571f, -0.06163597f, 0.08984772f, 0.03756536f, -0.08928264f, -0.04871485f, -0.07044300f, 
    0.03483162f, -0.06770110f, 0.01346414f, -0.09106151f, 0.04003303f, 0.06331394f, -0.00613573f, 0.12437768f, 
    0.15317485f, -0.12397262f, 0.07621656f, 0.11168183f, -0.26580644f, 0.11502054f, 0.20761584f, 0.12077511f, 
    0.12097174f, -0.07227100f, 0.38099545f, -0.54443085f, -0.09735325f, -0.03126480f, -0.07891751f, 0.32225689f, 
    0.23133174f, 0.36689582f, -0.08448958f, 0.08678754f, 0.04811179f, -0.17187099f, -0.51199573f, 0.25893122f, 
    -0.03929667f, 0.38637087f, -0.11149224f, 0.12493456f, 0.05021349f, 0.33872572f, -0.03522676f, 0.03889747f, 
    0.10741987f, 0.03964618f, 0.15519673f, 0.25609878f, 0.07513413f, 0.17635192f, -0.14086050f, 0.18575881f, 
    0.22149058f, -0.02965208f, 0.01864325f, -0.53080982f, -0.14818121f, -0.15910788f, 0.02212427f, 0.12990886f, 
    0.07989163f, -0.40494457f, 0.13923241f, -0.12651512f, -0.07264411f, -0.06210786f, -0.42280740f, 0.18276444f, 
    0.20513964f, 0.28645572f, 0.01954275f, -0.11855749f, 0.17465203f, -0.30740595f, -0.11041063f, 0.09156252f, 
    0.00493320f, 0.12275090f, 0.34363261f, -0.17108157f, -0.03114896f, -0.05695443f, 0.19743983f, 0.14045246f, 
    -0.08346677f, 0.13095015f, -0.31516299f, 0.33974296f, 0.12578893f, -0.15698200f, 0.00426091f, -0.03964797f, 
    -0.29698351f, -0.37213656f, -0.07863979f, 0.08549181f, -0.06883134f, -0.05773797f, 0.11893960f, 0.26130506f, 
    0.19596349f, 0.20596424f, -0.13904563f, -0.11455078f, -0.14040853f, 0.38169637f, -0.03734318f, -0.03977881f, 
    -0.07255843f, -0.05251163f, -0.12277960f, 0.57008988f, 0.03284690f, -0.08805215f, -0.29261124f, -0.30925018f, 
    -0.27075198f, -0.03131189f, -0.21451224f, 0.32389325f, -0.11136170f, 0.15047877f, -0.06158453f, 0.14994863f, 
    0.00147399f, -0.28976664f, 0.43022195f, 0.10322893f, 0.15914451f, -0.02742356f, 0.17597526f, -0.13808702f, 
    -0.19638774f, -0.29387492f, -0.11666815f, 0.16465653f, -0.14396550f, -0.15206119f, 0.09309622f, -0.08791316f, 
    0.02940315f, 0.12319173f, 0.31572166f, 0.30332789f, -0.04307075f, -0.12483573f, 0.19598314f, 0.14797108f, 
    0.14339378f, 0.27401853f, -0.04292139f, 0.21004447f, -0.03028267f, 0.11088785f, -0.00019204f, 0.19714820f, 
    -0.22440907f, 0.44969034f, -0.06842741f, -0.16091718f, 0.03026159f, -0.03469290f, 0.37337372f, -0.21956991f, 
    0.19955368f, 0.09923550f, 0.03149416f, 0.12474933f, -0.04062440f, -0.08982319f, 0.02197930f, 0.01345243f, 
    0.06684663f, 0.16530605f, 0.17331858f, 0.14915672f, -0.78561050f, -0.13477276f, 0.01366427f, -0.13517489f, 
    0.26129234f, 0.35928369f, -0.26301572f, -0.13880891f, -0.07049479f, 0.11610341f, -0.02855419f, 0.54083866f, 
    -0.09012824f, 0.27047965f, 0.05863882f, -0.05825134f, 0.12930417f, 0.03566581f, -0.39979294f, 0.25347570f, 
    -0.00488182f, -0.31702805f, -0.17320989f, -0.05991274f, 0.13662980f, -0.01098059f, 0.12244321f, -0.05721180f, 
    0.10035021f, -0.09219470f, -0.29124671f, -0.30445752f, 0.24827927f, -0.09371705f, 0.19614843f, 0.04813902f, 
    -0.17185523f, -0.00447618f, 0.08487043f, 0.35994416f, -0.09459527f, -0.01063265f, 0.15104857f, 0.14020661f, 
    -0.10805177f, 0.40945247f, -0.15688701f, 0.07637389f, 0.07433361f, 0.16202247f, 0.18171282f, 0.29752660f, 
    0.09621691f, -0.31198114f, -0.13243344f, 0.05122621f, -0.09122343f, 0.52496821f, -0.01840126f, 0.10369989f, 
    -0.06391663f, 0.17231572f, -0.29981449f, -0.03476060f, -0.06267517f, 0.00226735f, 0.21137267f, 0.44151881f, 
    0.46219975f, -0.35657066f, 0.19534045f, -0.02523644f, -0.08545871f, -0.08908904f, 0.03321083f, -0.01477852f, 
    0.29155827f, 0.34633255f, -0.30489171f, 0.03902237f, 0.04305440f, 0.01906869f, -0.04972388f, 0.29125738f, 
    0.27361271f, 0.01866430f, -0.08681589f, 0.14795494f, -0.10518505f, 0.45412803f, -0.17508513f, -0.12579563f, 
    -0.03256270f, -0.10248013f, 0.32288185f, 0.18200575f, -0.33217216f, -0.06441902f, -0.11088839f, 0.21710733f, 
    0.49060619f, -0.23882222f, -0.26326957f, -0.07091184f, -0.11827544f, -0.06426039f, -0.00274304f, 0.37065065f, 
    -0.22285976f, -0.08909682f, 0.18340261f, 0.00767323f, -0.16619180f, -0.14226167f, 0.28210619f, -0.04483404f, 
    -0.19803667f, -0.22690578f, -0.13851357f, 0.08866009f, -0.16064972f, -0.25937825f, 0.13731706f, -0.07815763f, 
    -0.01883339f, -0.01784782f, -0.20109822f, -0.01331587f, 0.24916202f, 0.16666706f, -0.31721786f, -0.23692639f, 
    -0.26780292f, 0.21149115f, 0.04713169f, 0.39315566f, -0.02308261f, 0.01519582f, 0.06116881f, -0.22593729f, 
    0.29783586f, 0.54372579f, 0.16607603f, 0.09711749f, -0.11628698f, -0.14039981f, 0.26339039f, 0.19932887f, 
    0.22861747f, 0.05959413f, 0.01488606f, -0.08288963f, 0.09085567f, -0.21217044f, -0.15948938f, -0.09066885f, 
    0.15023245f, -0.01594144f, 0.35101295f, 0.32290068f, -0.47480938f, -0.02295047f, 0.10092583f, -0.00108896f, 
    0.05866919f, 0.13795944f, -0.30864197f, 0.36817428f, 0.16573013f, -0.04025271f, -0.15507524f, 0.03204257f, 
    -0.19046661f, -0.03291801f, -0.17295375f, 0.01668860f, -0.14540374f, 0.00567775f, 0.45476076f, 0.05278810f, 
    -0.60464543f, -0.09667698f, 0.16555685f, -0.15706106f, -0.15662271f, -0.02877740f, 0.07776010f, -0.16205561f, 
    0.14273238f, -0.02157017f, 0.45545784f, -0.11892199f, 0.04881128f, 0.02344641f, 0.11884005f, 0.33212063f, 
    0.76897895f, -0.06018637f, 0.48197603f, 0.04958359f, 0.03862078f, 0.13366449f, -0.11250774f, -0.20242329f, 
    -0.12771089f, 0.10639361f, 0.08877321f, -0.06100293f, -0.16201335f, 0.16920367f, -0.06554174f, 0.04200576f, 
    -0.62152261f, -0.15851620f, -0.09483608f, -0.05096842f, -0.15658872f, 0.30685407f, 0.03173025f, 0.16110870f, 
    0.12120940f, 0.03364884f, -0.11285924f, -0.24043082f, -0.10188930f, 0.01476242f, -0.07204895f, 0.10940752f, 
    0.28835189f, 0.32864687f, -0.18148972f, 0.12865710f, -0.07617486f, -0.02853902f, 0.00516926f, 0.49679714f, 
    0.21198729f, 0.24425144f, 0.31260875f, -0.09023628f, 0.04715790f, 0.08525393f, -0.26832369f, 0.35355482f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.12922928f, 0.09605566f, 0.11198787f, 0.09862711f, -0.10205881f, 0.04161133f, 0.06652060f, -0.04702982f, 
    -0.14836942f, -0.07330371f, 0.12463658f, -0.09468909f, 0.05767809f, -0.03777779f, 0.27880341f, 0.00105450f, 
    -0.11952811f, -0.02812327f, 0.02367508f, 0.13751090f, -0.07204191f, -0.10564146f, 0.26155537f, 0.13297996f, 
    0.14158170f, 0.02261995f, -0.22549823f, -0.07698104f, 0.00011525f, 0.00116346f, 0.02105610f, 0.23081063f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.18352036f, -0.21983296f, -0.19390696f, -0.06590729f, -0.42200339f, -0.43393132f, 0.37528539f, 0.08865152f, 
    -0.46905276f, -0.71203816f, -0.70374244f, 0.34765229f, 0.16740780f, 0.09317381f, 0.09452221f, -0.26234767f, 
    0.15475819f, 0.08747055f, -0.15138152f, 0.44979480f, 0.26649112f, 0.09305258f, -0.63626790f, -0.63307250f, 
    0.29038748f, -0.05358745f, 0.06664112f, 0.08462530f, -0.46913370f, -0.35897228f, -0.06914731f, -0.07619663f, 
    -0.06939653f, 0.26920450f, -0.07107639f, -0.12326951f, -0.26667297f, -0.05945015f, -0.59801340f, -0.08966076f, 
    -0.32061455f, 0.23768707f, 0.25216702f, -0.46970573f, -0.12782015f, 0.05267770f, 0.29397619f, 0.09005018f, 
    0.08911788f, 0.21901903f, -0.03432972f, 0.15461661f, -0.01782075f, -0.19281392f, -0.28422058f, -0.52406287f, 
    -0.16129312f, 0.19859314f, 0.27568385f, -0.74894303f, 0.20131068f, -0.46925181f, 0.01287691f, 0.30166250f, 
    0.28672138f, -0.09317249f, -0.05473571f, -0.24039553f, -0.02661453f, 0.40029022f, -0.32335272f, 0.15731788f, 
    -0.33171442f, -0.41617432f, -0.58035737f, -0.08417896f, 0.44294256f, -0.10272567f, -0.19701727f, 0.18907043f, 
    -0.12915848f, 0.19630256f, 0.01201899f, -0.19131254f, -0.44299963f, -0.12549572f, 0.14314418f, -0.16240411f, 
    -0.37213421f, 0.25354451f, 0.15452050f, -0.13301550f, 0.37869567f, 0.02158031f, -0.75716001f, -0.10149771f, 
    0.14814994f, -0.01569016f, 0.23710155f, 0.07195765f, 0.39817330f, -0.68870151f, 0.42030928f, 0.05512026f, 
    -0.55681133f, -0.13434236f, 0.20020247f, -0.06451815f, -0.11647438f, -0.20721245f, -0.01122529f, -0.29442352f, 
    0.16489430f, 0.29306561f, 0.11998867f, -0.56833696f, -0.08545751f, 0.42260632f, -0.35413501f, 0.05899313f, 
    -0.56486207f, 0.08676597f, -0.33577734f, -0.19800015f, -0.23028274f, 0.05469961f, 0.24252863f, -0.37005970f, 
    -0.05798716f, -0.19039258f, 0.20744322f, 0.07776272f, -0.15416959f, -0.32807240f, 0.29322335f, -0.09981143f, 
    0.00267325f, -0.00565988f, -0.24055356f, 0.37283313f, -0.15622297f, -0.15657192f, -0.06245559f, -0.64547509f, 
    0.10185991f, -0.28336939f, -0.07919158f, -0.23575598f, -0.35356149f, 0.30297944f, -0.06522862f, 0.27008149f, 
    0.21053143f, 0.28510180f, -0.39386186f, 0.11088270f, 0.22552192f, 0.35880548f, -0.10242385f, 0.05376974f, 
    -0.71467716f, -0.02903867f, 0.16100405f, 0.13338079f, -0.02216825f, -0.08811355f, 0.13702922f, 0.09940960f, 
    -0.29996791f, -0.43995056f, 0.15187576f, -0.26843861f, -0.36597621f, -0.12444391f, 0.01608367f, 0.09693972f, 
    0.09379476f, -0.29751381f, 0.01568738f, 0.28761759f, 0.26522794f, -0.20064814f, -0.05238232f, 0.08863152f, 
    0.29427961f, -0.48270878f, -0.17240530f, 0.04917303f, -0.12024774f, -0.16038650f, 0.25791061f, 0.27219519f, 
    -0.03505543f, -0.22524197f, 0.30825824f, 0.35115007f, -0.01805701f, 0.10546728f, -0.18590629f, 0.02161493f, 
    -0.04671507f, -0.44318140f, -0.64606154f, -0.40026620f, 0.42608193f, 0.17883442f, -0.00592995f, 0.06551842f, 
    0.13097958f, -0.38675871f, -0.01693900f, -0.00953459f, 0.14347786f, -0.18384714f, 0.44312799f, -0.04437874f, 
    -0.02522716f, -0.59605581f, -0.77722722f, -0.36756980f, 0.22328547f, -0.06432925f, -0.53780383f, -0.32582116f, 
    0.01363889f, -0.60328835f, 0.27924663f, -0.40308088f, 0.11154336f, -0.08609401f, 0.13457480f, 0.05196790f, 
    0.67295003f, 0.41112217f, 0.10314133f, 0.06370578f, -0.02141361f, -0.19424339f, -0.62675953f, 0.45423719f, 
    -0.06421154f, 0.29344317f, -0.15968639f, -0.14917807f, -0.15988165f, -0.08662340f, -0.22206292f, 0.26665592f, 
    0.08328608f, -0.09899648f, 0.13032065f, 0.12388466f, -0.07012621f, 0.19639310f, 0.01868674f, -0.53337145f, 
    0.01537910f, -0.35296726f, -0.38143763f, -0.06260043f, 0.35340613f, -0.21981847f, -0.56926620f, -0.17405137f, 
    -0.03388159f, -0.04360640f, -0.05927313f, 0.17222910f, -0.31664595f, -0.48202762f, -0.03984921f, 0.16841635f, 
    -0.09878223f, 0.13442230f, -0.01800281f, 0.21714920f, -0.40961114f, -0.61651403f, -0.53622282f, 0.56953216f, 
    -0.20621790f, 0.32110125f, 0.21642019f, 0.01500886f, 0.07927232f, -0.18719710f, 0.14449441f, 0.11866678f, 
    0.37794212f, -0.21728282f, -0.58291930f, -0.20538978f, -0.06923655f, 0.56987500f, -0.18820603f, -0.12147497f, 
    0.30302364f, 0.25723401f, 0.12305646f, 0.18233874f, -0.23515806f, -0.18743277f, 0.01960703f, -0.25118455f, 
    -0.15367478f, -0.33778226f, -0.11684059f, -0.16950314f, 0.22425555f, 0.24263710f, 0.30504885f, -0.03338497f, 
    0.24719195f, -0.11892994f, -0.25661820f, 0.41455182f, -0.64751446f, 0.16822985f, -0.82805759f, 0.15190388f, 
    -0.08280629f, 0.41051999f, -0.18156818f, -0.34995729f, 0.33223814f, 0.40168777f, 0.25410098f, 0.04959598f, 
    0.21809290f, -0.03964446f, 0.08282860f, -0.58205396f, -0.47642004f, -0.01062301f, -0.00348031f, 0.12912171f, 
    0.05385484f, 0.21594064f, -0.09854039f, -0.52235889f, 0.01767284f, -0.28345323f, 0.38079333f, -0.04981616f, 
    -0.68135744f, -0.08229122f, -0.38568553f, 0.26523235f, 0.09880176f, -0.26159126f, 0.18807212f, 0.05499771f, 
    0.14168587f, -0.02644782f, -0.19089074f, 0.16224410f, -0.04482314f, -0.51545978f, -0.44895923f, -0.01806155f, 
    -0.43454081f, -0.37617919f, 0.79009622f, -0.17879401f, 0.19909005f, 0.27445528f, 0.08134932f, -0.12639244f, 
    -0.14586239f, -0.09654176f, -0.07227608f, 0.04446204f, 0.10363023f, -0.11809774f, 0.23320740f, -0.06634513f, 
    -0.38055879f, -0.29075882f, 0.08591527f, 0.30073389f, -0.60184878f, 0.09161856f, 0.00904270f, -0.64878434f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.00069832f, -0.09821931f, 0.17668699f, -0.16815199f, 0.19153172f, -0.02117159f, 0.08292383f, -0.31542742f, 
    0.09457757f, -0.05088183f, -0.11120367f, -0.01078325f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
