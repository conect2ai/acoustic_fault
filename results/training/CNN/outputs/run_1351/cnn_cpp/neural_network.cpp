#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.80455208f, -0.41648936f, -0.31796330f, 0.59401733f, 0.51486325f, 0.09782875f, 0.51983035f, 0.48523480f, 
    -0.05339635f, 0.07984444f, 0.15396428f, -0.12891354f, 0.11693419f, 0.35565343f, -0.51679516f, 0.07348113f, 
    0.17061414f, -0.21540333f, -0.20670159f, 0.04283493f, 0.17759360f, -0.04787308f, 0.30180404f, 0.17943265f, 
    -0.14127560f, 0.51092750f, 0.35969332f, 0.31454873f, 0.63737732f, -0.21054572f, -1.08297944f, -0.98176759f, 
    -0.28623733f, -0.76655686f, -0.95118541f, 0.00540197f, -0.12006370f, -0.14871769f, 0.53617364f, -0.29520893f, 
    0.26202837f, -0.19077246f, 0.08242675f, -0.38409820f, -0.21779825f, -0.37109950f, -0.08043724f, -0.17782773f, 
    -0.13434474f, -0.00713699f, 0.58645016f, 0.86939704f, 0.53547204f, 0.08627038f, -0.42735580f, 0.10528083f, 
    -0.42634475f, -0.53668958f, -0.39174366f, -0.37350130f, 0.27951577f, 0.10452046f, -0.01165548f, -0.01967140f, 
    -0.02942752f, -0.19654973f, -0.21383506f, -0.18615325f, 0.27196860f, 0.04843696f, 0.20051005f, 0.18652049f, 
    -0.10718894f, -0.11649504f, 0.05779838f, -0.87002945f, -0.62009829f, 0.44030267f, 0.11818568f, 0.12483774f, 
    0.28474683f, -0.35902238f, -0.79263508f, -0.40649995f, -0.43724966f, -0.22279005f, 0.26226163f, -0.20760204f, 
    -0.47147474f, -0.44526026f, 0.15768960f, 0.16462976f, -0.05041692f, 0.16968937f, -0.07187435f, 0.23318383f, 
    0.24295934f, 0.24246646f, 0.15168686f, 0.15742081f, -0.19413182f, -1.38072467f, -1.17699802f, 0.31463295f, 
    1.01596987f, -0.27507207f, -0.24387535f, -0.38334891f, -0.07260449f, -0.48790357f, -0.39818078f, -0.57375932f, 
    -0.03983661f, -0.41124597f, -0.11230937f, -0.13935305f, -0.10924995f, -0.14522299f, -0.05508846f, 0.40772888f, 
    0.10656769f, -0.54728687f, -0.29716146f, -0.17167348f, -0.03922523f, -0.27807337f, -0.50006890f, -0.57771957f, 
    -0.30554143f, -0.67951679f, -0.51524365f, -0.56030887f, -0.38475761f, -0.69009149f, -0.69051903f, 0.07975709f, 
    -0.34207076f, -0.21525888f, -0.03167090f, -0.14030676f, 0.28936523f, 0.12159997f, -0.03000742f, 0.30655164f, 
    0.29854399f, -0.04844529f, -0.12457850f, -0.09754394f, 0.03470407f, 0.24729094f, 0.21153350f, 0.37751994f, 
    -0.54876834f, 0.22671846f, 0.05409676f, -0.71144402f, -0.10943360f, 0.00998534f, 0.46415761f, 0.60229629f, 
    -0.14796741f, 0.28456107f, -0.00887071f, 0.10253774f, 0.00237096f, -0.01614851f, -0.06340733f, 0.01569114f, 
    -0.38649940f, -0.05586157f, -0.00961713f, 0.00536171f, 0.04655575f, -0.04071265f, -0.07208485f, 0.38147530f, 
    -1.32881021f, 0.19534712f, 0.21278642f, 0.63376659f, -0.20178609f, 0.02723815f, -0.64564282f, -0.06908587f, 
    0.53111249f, -0.19677827f, -0.37898535f, 0.27629498f, -0.20027764f, 0.28446421f, 0.24069132f, -0.22334310f, 
    -0.20120540f, 0.12634701f, -0.14202431f, -0.26598221f, -0.10395064f, -0.17230791f, 0.01263286f, 0.14515226f, 
    0.53455234f, 0.20935132f, 0.33187133f, 0.30602759f, 0.22285679f, 0.34118098f, 0.28839171f, 0.19263537f, 
    0.18451941f, 0.11557901f, 0.22465710f, 0.03099109f, -0.14476344f, 0.07515717f, 0.13540718f, 0.20116392f, 
    0.09487902f, -0.01909468f, -0.05803869f, -0.11371052f, -0.18653084f, 0.34900320f, 0.15684269f, -0.08290256f, 
    -0.18967400f, 1.36297286f, -1.25318873f, 0.31981084f, -0.14790142f, -0.32443467f, 0.53132874f, 0.16220269f, 
    0.31441349f, -0.54140663f, -0.40875959f, -0.01743926f, -0.20879488f, 0.34464777f, -0.19632033f, -0.15035319f, 
    -0.11574398f, -0.40832442f, 0.14272960f, 0.11631848f, -0.21553998f, -0.45477098f, -0.27971119f, -0.20032266f, 
    -0.06057373f, -0.31664190f, -0.46351841f, -0.52014279f, -0.54724324f, -0.68694019f, -0.01276786f, -0.84312165f, 
    -0.41699147f, -0.47969231f, -0.34092104f, -0.48068467f, 0.88430840f, 0.55710077f, 0.62130910f, 0.08639596f, 
    -0.31393346f, 0.12753265f, -0.35179073f, -0.25057846f, -0.41206717f, -0.45241711f, 0.39135310f, -0.08042593f, 
    -0.11762635f, 0.18367156f, 0.11396293f, -0.65390062f, 0.18349519f, -0.01675675f, -0.12514740f, 0.46000907f, 
    0.26166359f, -0.04765693f, -0.30836263f, 0.03959341f, 0.27412856f, -0.02602518f, -0.24152775f, -0.20638604f, 
    0.31280652f, -0.27639061f, -0.08119375f, -0.02464563f, -0.30151457f, 0.35975182f, 0.31456402f, 0.11891600f, 
    -0.20822529f, 0.04165676f, 0.15031475f, -0.64956886f, -0.73079753f, 0.22543347f, 0.39724427f, 0.06059962f, 
    0.18960603f, 0.09854183f, -0.54002088f, -0.07080028f, 0.27650249f, 0.21644861f, 0.22178875f, 0.16574331f, 
    -0.28634751f, -0.17218025f, -0.23271300f, 0.23213302f, -0.07036000f, -0.09016112f, -0.31679291f, -0.18377811f, 
    -0.35670689f, -0.41264090f, -0.45434403f, -0.50544083f, -0.78492236f, 0.02390740f, 0.59662855f, 0.15073839f, 
    -0.53697449f, -0.10196146f, -0.37625918f, 0.16934185f, 0.29742932f, 0.19554032f, -0.23579061f, -0.03467157f, 
    0.40602407f, -0.22315444f, 0.23291951f, -0.51197171f, 0.24469049f, -0.20541219f, -0.05175472f, 0.16650158f, 
    -0.20892955f, -0.16541202f, 0.30116814f, 0.37014207f, -0.04590636f, -0.30540732f, 0.15909971f, -0.01290499f, 
    -0.08336493f, 0.24939822f, 0.03818725f, -0.13551643f, 0.17454445f, -0.32199904f, -0.36474413f, 0.10046643f, 
    -0.04124314f, -0.00074654f, -0.11159166f, 0.44704884f, -0.26620919f, 0.29719454f, 0.14562079f, 0.18590055f, 
    -0.18406166f, -0.26626357f, -0.29908660f, 0.12707597f, 0.01646521f, 0.22878797f, 0.01392928f, 0.56692886f, 
    0.56942028f, -0.11689109f, -1.06373858f, -0.80532432f, -0.42390290f, 0.20425318f, 1.13675833f, -0.33524063f, 
    -0.46895498f, -0.36233723f, -0.17387563f, 0.16113955f, -0.02471498f, 0.02202277f, 0.38069806f, -0.00687145f, 
    -0.45381388f, -0.18182749f, -0.13532634f, -0.06569996f, -0.34258637f, 0.26669922f, 0.21736409f, 0.05603139f, 
    -0.64777046f, -0.39052838f, -0.18220247f, 0.47989509f, 0.58722091f, -0.88632572f, -0.65856570f, 0.49304229f, 
    0.68082339f, 0.58233690f, -0.15936528f, 0.00130378f, -0.37587214f, -0.07895834f, 0.33336547f, -0.15274325f, 
    0.19276848f, -0.04630132f, -0.14103018f, 0.14641401f, -0.29861099f, -0.11591690f, 0.23242047f, 0.28317881f, 
    -0.00563599f, -0.65710872f, -0.59963894f, -0.21342474f, 0.62105030f, 0.55935925f, 0.08537553f, 0.46424800f, 
    0.68621320f, -0.48114982f, -0.53101826f, -0.08463476f, -0.51441771f, -0.08336741f, -0.12906197f, 0.14480193f, 
    0.07757372f, -0.02634010f, -0.15649801f, 0.01582120f, -0.00100920f, 0.19719872f, -0.09368178f, -0.03980668f, 
    -0.00727861f, -0.20661278f, 1.01728034f, 0.19585279f, -0.10829382f, -0.07535785f, -0.03308339f, 0.52848864f, 
    0.28638226f, 0.21663362f, -0.30114895f, -0.25504228f, 0.19759369f, 0.08740721f, -0.53893024f, -0.50161046f, 
    -0.03370949f, -0.13979723f, -0.07551026f, 0.42634112f, -0.44788131f, -0.24181390f, -0.22231011f, -0.33732560f, 
    -0.04313129f, 0.31052327f, 0.21152663f, 0.26533690f, -0.53707695f, -0.19181882f, 0.02340677f, 0.11279499f, 
    0.52832341f, 0.09044557f, 0.88958067f, -0.79385960f, -0.22933242f, -0.36400139f, 0.27394882f, -0.18365790f, 
    -0.14049232f, -0.18887563f, -0.16796853f, 0.03412437f, -0.06167478f, -0.25603887f, 0.53273082f, 0.13515843f, 
    -0.19288900f, -0.05922533f, 0.02427173f, 0.16021077f, -0.23966256f, 0.40969881f, 0.26963237f, 0.35209939f, 
    -0.53722739f, -0.41667685f, -0.31211767f, -0.06927949f, 0.06263341f, 0.45498288f, 0.05462926f, 0.15273635f, 
    0.07361055f, -0.31345618f, 0.23707098f, -0.00070051f, 0.10655086f, 0.14018939f, 0.08904051f, -0.30417737f, 
    0.21159893f, -0.13689314f, -0.24934709f, 0.28636304f, 0.28683731f, -0.22767138f, -0.03585560f, -0.47106585f, 
    -0.67495394f, -0.50012738f, 0.56046146f, 0.33637279f, 0.37980142f, -0.20005938f, -0.54240584f, 0.25737900f, 
    0.33246151f, -0.03019588f, 0.13907017f, 0.34141824f, 0.14691944f, -0.04061401f, 0.01827363f, 0.04507134f, 
    0.13974015f, 0.17772947f, -0.19008031f, -0.19141796f, 0.27594230f, -0.28330564f, 0.16562650f, 0.53189629f, 
    -0.56464279f, -0.75264925f, -0.92604786f, -0.44275939f, -0.43260425f, -0.03267439f, 0.01838469f, 0.47579896f, 
    0.38134736f, 0.26266953f, 0.04531506f, 0.45552441f, 0.19760425f, 0.13717809f, -0.19573657f, -0.11624949f, 
    0.07605605f, 0.09494028f, 0.13582745f, 0.03374180f, -0.46724737f, 0.06072048f, -0.36985531f, -0.58305627f, 
    -0.38898388f, -0.11665980f, -0.47203320f, -0.27091753f, -0.18802994f, -0.57235217f, 0.11996139f, 0.50973314f, 
    -0.25395358f, -0.53685594f, -0.29537755f, -0.14108004f, 0.82881725f, -0.29563889f, 0.26574823f, -0.12715492f, 
    0.12043994f, 0.23698823f, 0.32605252f, 0.07422151f, 0.17260842f, 0.15009058f, -0.51075774f, -0.36659184f, 
    0.53527498f, -0.12525460f, 0.14740607f, 0.44075096f, -0.99906361f, 0.31864908f, -0.16502665f, -0.20352471f, 
    -0.24172671f, 0.11732501f, 0.11812031f, -0.42351311f, -0.19041315f, -0.06274323f, 0.25386524f, -0.20355710f, 
    -0.05924625f, -0.01446007f, 0.17975596f, -0.51657712f, -0.34878179f, -0.31268832f, -0.15241604f, -0.58086771f, 
    -0.71162790f, 0.38087985f, 0.25818390f, -0.29445627f, -0.01990202f, 0.01115950f, 0.13735481f, -0.08857048f, 
    -0.10078436f, 0.26751828f, 0.12867180f, -0.11757527f, 0.26273182f, -0.01475087f, -0.07181112f, 0.04026474f, 
    -0.19333841f, -0.05485611f, -0.27430952f, -0.20711967f, -0.17575470f, -0.15760919f, -0.15837638f, -0.20606059f, 
    -0.26772922f, -0.14304116f, 1.37592137f, -0.85261369f, -1.26922286f, -0.77918679f, -0.48412123f, 0.68764365f, 
    0.36986887f, 0.36938640f, 0.27199402f, -0.22930130f, 0.07322628f, 0.59324038f, 0.08438152f, -0.15902779f, 
    0.16507033f, -0.22526246f, -0.07776961f, -0.34696692f, -0.20064311f, 0.09078480f, 0.28423113f, -0.15088312f, 
    -0.02410497f, 0.32700753f, -0.00785582f, 0.92482716f, 0.90250814f, 0.16072406f, 0.24580733f, -0.80017608f, 
    -0.57829338f, -0.57080626f, 0.05724548f, 0.46505192f, -0.59740704f, 0.23880053f, -0.32050315f, 0.24587309f, 
    0.13813488f, -0.44948810f, -0.06638210f, 0.00687834f, 0.24823399f, 0.01107786f, 0.12349154f, -0.01516254f, 
    -0.03839964f, -0.19598646f, 0.22929786f, -0.00199970f, -0.34537461f, -0.75665754f, -0.70314109f, -0.56117862f, 
    0.00648225f, 0.01654078f, -0.87506866f, -0.72610867f, -0.59940809f, -0.59705853f, -0.14161953f, 0.19918822f, 
    -0.04947059f, 0.45492703f, -0.38861203f, -0.05793320f, -0.54347080f, -0.14514157f, -0.06613055f, -0.34966421f, 
    -0.57744598f, -0.08309402f, 0.09099557f, -0.10215453f, -0.30735692f, -0.83704329f, -0.64392334f, -1.15760207f, 
    -0.93673009f, -0.94903392f, 0.85593379f, 0.34886310f, 0.21007140f, 0.42085448f, 0.78999650f, -0.31933278f, 
    0.30066475f, -0.58365792f, -0.20727772f, -0.40920189f, 0.10037326f, -0.04174536f, 0.16689187f, 0.24786699f, 
    -0.16773029f, 0.10727073f, 0.01647499f, 0.10875352f, -0.12865059f, 0.26590011f, -0.02254172f, -0.15044458f, 
    0.37581924f, -0.34748027f, -0.17305429f, 0.07826099f, -0.16204798f, -0.10779592f, -0.12091415f, 0.36750084f, 
    0.11201545f, 0.02949148f, -0.45719627f, 0.31156361f, 0.16396344f, -0.38446629f, 0.18307731f, 0.10763831f, 
    -0.14458142f, 0.19477634f, 0.34680545f, 0.20492616f, 0.45848289f, -0.07829238f, -0.48400137f, -0.94729507f, 
    -0.86253154f, -0.57016045f, -0.44102558f, -0.76911491f, 0.07775046f, 0.34159359f, 0.12230728f, 0.10040969f, 
    -0.03672407f, -0.07743384f, -0.08312328f, -0.11461583f, 0.36163169f, 0.20609763f, -0.16690636f, -0.22646438f, 
    -0.32859752f, -0.32512936f, -0.28991219f, -0.22151703f, -0.38602057f, 0.01668027f, 0.19579621f, -0.43223000f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.10448493f, -0.00916479f, 0.20100749f, 0.35502499f, 0.09897715f, -0.28398994f, 0.45804465f, 0.38935503f, 
    -0.17222321f, 0.20651940f, 0.30300850f, 0.30307183f, -0.08353135f, 0.27952743f, -0.06461956f, 0.55487251f, 
    0.49077138f, 0.20085125f, 0.52065152f, -0.00671355f, 0.14479768f, 0.00500785f, 0.28313240f, -0.04888591f, 
    -0.10921986f, 0.13107549f, 0.49186078f, 0.52778834f, -0.43537444f, -0.22872832f, 0.31662101f, -0.02143811f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.29255635f, 0.06772075f, 0.01613153f, -0.09298845f, -0.01898565f, 0.06515476f, 0.13235737f, 0.02639610f, 
    -0.08842888f, -0.13383496f, -0.31628507f, -0.19370170f, 0.14996520f, 0.05622200f, 0.08798514f, -0.29626039f, 
    0.02435237f, -0.12231308f, 0.01470040f, 0.08240253f, -0.01125812f, 0.09566152f, -0.03359316f, 0.06815315f, 
    -0.38976431f, -0.52432942f, -0.55602217f, 0.16521519f, 0.02187005f, 0.06641989f, -0.04968679f, -0.04973719f, 
    -0.04117691f, 0.04410318f, 0.03393587f, -0.00215513f, 0.48336929f, 0.38120326f, -0.21469793f, -0.40142566f, 
    -0.08197135f, 0.06924727f, 0.12095360f, 0.08929452f, 0.02160542f, -0.05682721f, -0.04155196f, -0.05867161f, 
    0.59801227f, -0.00381171f, 0.06136288f, -0.17985280f, 0.19815859f, 0.06826564f, 0.40325263f, -0.04590879f, 
    -0.01071758f, 0.03517745f, -0.11080997f, -0.16164997f, 0.34221795f, 0.17866531f, -0.03714659f, -0.20275380f, 
    0.19122866f, 0.13888749f, 0.13794895f, 0.19216062f, 0.01560142f, 0.03665382f, 0.03238860f, -0.00831802f, 
    -0.53663307f, 0.00347131f, 0.03040777f, -0.04361981f, -0.01891102f, -0.01793628f, 0.01364273f, -0.00498562f, 
    -0.13302368f, -0.10892013f, -0.17216131f, -0.00138562f, 0.30534300f, 0.04212815f, -0.08085689f, -0.22627954f, 
    -0.15822913f, -0.13339508f, 0.08151590f, -0.45794377f, -0.14200109f, -0.06292408f, -0.13861701f, -0.03451231f, 
    -0.06568085f, 0.00538588f, -0.00299113f, 0.04540913f, 0.03238159f, 0.03800371f, 0.05408165f, 0.01058413f, 
    -0.15588962f, -0.03465383f, 0.03031201f, -0.00336324f, -0.06153923f, -0.65194571f, -0.26093745f, -0.08082179f, 
    -0.00459724f, -0.09482994f, 0.00470257f, -0.01025292f, 0.07686920f, 0.12130766f, -0.23768254f, 0.18004699f, 
    0.29446179f, 0.36907548f, -0.09413131f, -0.31149545f, -0.00380686f, 0.06907909f, 0.00545245f, -0.10373718f, 
    0.05938902f, -0.07718441f, 0.00869468f, -0.03464896f, -0.07203499f, 0.12336910f, -0.07695419f, 0.02283267f, 
    -0.01844333f, -0.02635046f, -0.01153867f, 0.02455932f, -0.07112080f, 0.04619603f, -0.21624847f, -0.08550940f, 
    -0.24203505f, 0.11015071f, 0.07497755f, 0.00332939f, 0.03062999f, 0.00011211f, 0.04113249f, 0.07953316f, 
    -0.10347315f, 0.12182459f, 0.08467316f, 0.23895112f, -0.40479302f, -0.30447367f, -0.37604120f, 0.00443430f, 
    -0.07077697f, 0.05929175f, 0.00033770f, 0.10884511f, -0.10508263f, -0.05671209f, -0.10489166f, 0.08166277f, 
    -0.06093403f, 0.05337227f, 0.07456210f, -0.05380673f, 0.12412199f, -0.28077576f, 0.03172581f, 0.00751999f, 
    -0.12208113f, 0.00991386f, -0.04657570f, -0.01238565f, -0.12775475f, -0.30012769f, -0.00244193f, 0.15585338f, 
    0.05659591f, 0.07858434f, -0.13828512f, -0.22362408f, -0.12153176f, -0.00977713f, -0.06310128f, -0.12845327f, 
    -0.34063256f, 0.31351033f, 0.23736747f, -0.40332156f, -0.11248154f, 0.06030584f, 0.04333542f, -0.00954327f, 
    -0.02290699f, -0.40210643f, -0.17876790f, -0.21476825f, 0.53641576f, -0.45567805f, -0.06829000f, -0.44787923f, 
    -0.05176662f, -0.00330967f, 0.09549912f, -0.10126238f, -0.09964558f, -0.01909934f, -0.05686829f, 0.08422922f, 
    -0.23702264f, -0.72991282f, -0.53807443f, 0.23082855f, -0.03054447f, 0.01821920f, -0.03387174f, 0.02659199f, 
    -0.08321835f, -0.02869111f, -0.14365001f, 0.03637923f, 0.26695722f, -0.17455526f, -0.32392099f, -0.22959836f, 
    -0.08166365f, -0.07484906f, 0.13905379f, 0.02807567f, -0.06739944f, 0.02134106f, 0.13879906f, -0.24198437f, 
    0.07072470f, -0.02373107f, 0.15703043f, -0.05406761f, -0.41057262f, -0.04332528f, -0.18283097f, -0.04393224f, 
    0.07275342f, -0.07604578f, -0.11128378f, -0.05715883f, 0.27972299f, 0.00286955f, -0.08654160f, 0.06580928f, 
    0.14534651f, 0.16231959f, -0.51151830f, -0.13621053f, -0.19233181f, -0.04426806f, 0.00417989f, 0.01905745f, 
    0.21766490f, 0.06945055f, 0.02023167f, 0.01138986f, -0.01017277f, 0.01742277f, -0.20508465f, -0.20056126f, 
    -0.10329603f, 0.05418584f, 0.09406172f, 0.06167031f, 0.16198933f, 0.10488641f, 0.12367642f, -0.28718862f, 
    -0.11143301f, 0.32529041f, 0.06187087f, 0.13405205f, 0.06332679f, 0.00066746f, 0.03479564f, 0.00591354f, 
    -0.17722231f, -0.24526848f, -0.11867789f, -0.22316417f, -0.02902358f, -0.14321880f, -0.18123876f, 0.01168278f, 
    -0.17865583f, -0.20640551f, 0.21379624f, 0.42935002f, -0.52422875f, -0.17573112f, -0.11418988f, 0.08456096f, 
    0.01849984f, -0.00649512f, 0.02128293f, -0.02035506f, -0.16451696f, 0.11274330f, -0.03014578f, -0.02047187f, 
    0.11605220f, -0.13007239f, -0.66744447f, 0.07629680f, 0.05194178f, -0.00681858f, -0.12569964f, -0.04642135f, 
    -0.08749055f, -0.08608706f, -0.11247847f, -0.01343448f, -0.39373094f, -0.37391806f, -0.01254179f, -0.19238873f, 
    0.06112790f, -0.05036914f, -0.24864915f, 0.01031443f, -0.05101089f, 0.03346614f, -0.04163359f, 0.00551785f, 
    0.52620268f, 0.25676557f, -0.17204075f, -0.21764866f, 0.17844282f, 0.17475042f, 0.00106195f, 0.03924498f, 
    -0.09820491f, -0.10813372f, -0.01110710f, -0.11570633f, 0.32386169f, -0.08905099f, -0.13117272f, -0.10882533f, 
    0.13145845f, 0.26736051f, 0.21454473f, 0.06105778f, 0.01866477f, 0.14323570f, 0.08012218f, -0.08088876f, 
    -0.08513558f, -0.01370774f, 0.02630138f, -0.01493516f, -0.24249262f, -0.10791396f, -0.20714286f, -0.06435434f, 
    -0.12704736f, -0.07859994f, -0.23392822f, -0.11871213f, 0.36737692f, 0.08557232f, -0.01283932f, -0.05137996f, 
    0.10695466f, 0.04157401f, -0.10334763f, -0.08340625f, -0.01721575f, -0.15341596f, -0.14954767f, 0.12065681f, 
    -0.12011775f, -0.26016983f, 0.03327791f, 0.03423687f, -0.04722454f, -0.05607440f, 0.10691493f, -0.11660960f, 
    -0.17897496f, -0.15245759f, -0.04424174f, 0.07705466f, -0.06047891f, -0.15439716f, -0.55752534f, -0.51233709f, 
    -0.10067089f, -0.11706011f, 0.11455178f, 0.06862674f, -0.04601658f, -0.00370005f, -0.08320852f, 0.07288387f, 
    0.35174963f, 0.08346972f, 0.06723300f, -0.21189550f, 0.02089031f, -0.23190670f, -0.28960046f, -0.06384952f, 
    -0.02898459f, -0.06084412f, 0.05876442f, 0.04860533f, 0.00390189f, 0.02382217f, -0.14983706f, 0.13817261f, 
    -0.08019225f, -0.00348025f, 0.18258600f, 0.30104080f, 0.04104574f, 0.04769803f, -0.03291879f, 0.08532333f, 
    -0.13154604f, 0.02155375f, 0.04514710f, 0.18687651f, -0.06295155f, -0.23267949f, 0.00497611f, -0.46197844f, 
    0.15263990f, -0.06825325f, -0.01595507f, -0.17303622f, 0.13711321f, 0.24033114f, 0.24914904f, -0.05066546f, 
    -0.06380740f, -0.07729317f, -0.05239081f, -0.49382558f, -0.05853064f, 0.00859097f, -0.06806949f, -0.01048700f, 
    -0.47745925f, 0.00211570f, 0.28264815f, -0.03206531f, 0.01955814f, 0.06103418f, -0.07035812f, 0.05897456f, 
    0.17835537f, -0.01663157f, -0.06496985f, 0.08702794f, -0.11070345f, 0.15756969f, -0.34953088f, 0.19721425f, 
    0.08598951f, 0.08182129f, 0.06247321f, -0.07836516f, -0.10667165f, 0.06530226f, 0.23764341f, -0.16588250f, 
    0.16282952f, 0.14016417f, 0.21733297f, 0.16140667f, -0.04544462f, -0.02106641f, -0.06432353f, -0.04531837f, 
    -0.08065715f, 0.02820142f, 0.00341140f, 0.05350339f, 0.57620913f, -0.06973600f, -0.02250913f, -0.06225536f, 
    -0.04017516f, -0.00623127f, -0.03358778f, -0.11899663f, -0.12780498f, -0.36502740f, 0.14763318f, -0.05797076f, 
    -0.29442036f, -0.22159961f, -0.07588084f, 0.11481199f, 0.02685502f, 0.15007849f, 0.05721309f, 0.16179134f, 
    0.08007672f, -0.08083440f, 0.04212972f, 0.14581265f, 0.10932704f, 0.00498296f, -0.12209357f, 0.08484684f, 
    -0.06917044f, 0.18735453f, -0.12073996f, 0.07311145f, -0.07401816f, -0.02040171f, 0.22498915f, 0.05532366f, 
    0.04485191f, 0.07649685f, 0.04673091f, 0.01924085f, 0.06983455f, -0.02669346f, -0.04275689f, 0.07033758f, 
    -0.53654963f, -0.35472599f, -0.33982095f, -0.40486556f, 0.11292036f, -0.18586618f, 0.30286309f, 0.01725421f, 
    -0.04706377f, -0.17296329f, 0.08683446f, -0.00440634f, 0.05464204f, -0.09699516f, -0.14130583f, 0.09622474f, 
    0.07270857f, 0.08132316f, -0.03872643f, -0.03426997f, -0.00042968f, -0.10242337f, -0.00095809f, -0.08227006f, 
    -0.07692815f, -0.00264383f, -0.02657298f, -0.01848840f, 0.35657629f, -0.27466017f, -0.07263130f, 0.06909873f, 
    -0.11455273f, 0.00783191f, 0.23573399f, -0.11466981f, -0.04445824f, 0.06703435f, -0.01886933f, -0.05866101f, 
    -0.80537641f, 0.34558782f, 0.05926985f, 0.08689892f, 0.11221938f, 0.10524988f, 0.03949232f, -0.07902873f, 
    0.11023739f, 0.07607359f, -0.07572159f, 0.32806784f, -0.27860740f, -0.20902306f, 0.36591348f, 0.25788653f, 
    0.05578295f, -0.07026636f, -0.03461254f, 0.04922858f, 0.15010674f, -0.01907787f, 0.03626348f, -0.12333515f, 
    0.85117710f, 0.28504235f, 0.54951644f, 0.25865433f, -0.03926365f, -0.05351969f, 0.04466046f, -0.04677111f, 
    0.06987972f, 0.00796350f, -0.07399511f, 0.19804351f, 0.57341617f, -0.29882452f, -0.06453928f, -0.14625008f, 
    -0.07467864f, -0.03506061f, 0.04160842f, -0.06620273f, 0.17119150f, 0.11735470f, -0.12169757f, 0.00981412f, 
    -0.06552043f, 0.09488836f, 0.05502385f, -0.10700980f, 0.16667387f, 0.08440811f, -0.11332730f, -0.18255953f, 
    -0.06241002f, -0.06548182f, 0.08932740f, -0.10669305f, -0.06988978f, -0.16617137f, -0.01509383f, -0.17598383f, 
    0.00134264f, 0.09913687f, 0.08059800f, -0.16457783f, -0.10409363f, 0.02221584f, 0.11884661f, 0.02571869f, 
    -0.29162306f, -0.34830540f, 0.02442666f, -0.18795615f, 0.11972370f, 0.07188077f, -0.22523728f, 0.10595383f, 
    0.15781561f, -0.10181704f, -0.03857535f, 0.05880070f, -0.40343496f, 0.06239178f, -0.08623555f, 0.06965514f, 
    -0.13095954f, -0.07564954f, -0.31172255f, 0.10249321f, -0.19977343f, -0.09879685f, 0.01058070f, -0.07998691f, 
    0.03051914f, 0.04879041f, 0.10860037f, -0.20507175f, -0.02746128f, -0.04048404f, -0.02908306f, -0.00264857f, 
    -0.08755948f, -0.03873249f, -0.09391700f, -0.35688710f, 0.07658637f, 0.03153222f, 0.07402576f, -0.04694559f, 
    -0.01349762f, -0.00017406f, -0.01280755f, 0.04954158f, -0.14249219f, -0.02096859f, -0.28113469f, -0.37075523f, 
    0.81792021f, -0.43640533f, -0.27132472f, -0.18155658f, -0.00621857f, 0.14176273f, 0.13971408f, -0.08440195f, 
    0.20575115f, 0.13267051f, -0.09385690f, -0.06564429f, 0.10499214f, -0.04135253f, 0.38371521f, -0.21195896f, 
    0.05284984f, -0.14956707f, -0.11480489f, -0.13031469f, -0.07178245f, -0.05809626f, -0.02090835f, 0.05789057f, 
    0.11163900f, 0.06056147f, 0.00378164f, 0.58696860f, -0.10514279f, 0.08480627f, -0.00954362f, -0.08160972f, 
    -0.01187625f, -0.02508962f, 0.00063881f, 0.05361767f, 0.35329062f, 0.47140938f, -0.18445189f, -0.24944082f, 
    -0.19312605f, 0.02544983f, -0.03407083f, -0.09207574f, -0.04251800f, -0.02408361f, -0.21971659f, -0.10350990f, 
    -0.01400952f, 0.01645909f, -0.02067973f, -0.17932907f, 0.07120144f, -0.02832878f, -0.06448185f, 0.15243457f, 
    -0.22369418f, -0.04413077f, 0.08787811f, -0.10310986f, 0.05524230f, -0.12193123f, 0.24737969f, -0.13946898f, 
    0.13498306f, 0.08656886f, 0.09219007f, -0.16096488f, 0.01569967f, -0.02614207f, 0.20009856f, -0.12317603f, 
    -0.07599904f, -0.67484552f, 0.11308394f, 0.14479566f, 0.02384245f, -0.00586073f, 0.11340209f, 0.05267846f, 
    0.01156363f, -0.09295543f, 0.01406019f, 0.00859535f, -0.99477261f, -0.19530217f, -0.04946380f, 0.02910076f, 
    -0.05033480f, -0.23382229f, -0.32762012f, -0.40332693f, 0.02942764f, -0.08309640f, 0.01955761f, 0.01848001f, 
    -0.48072961f, 0.19803371f, 0.45092487f, -0.85572696f, 0.03330252f, 0.00628681f, -0.32696849f, 0.26097372f, 
    0.01633414f, -0.02322628f, 0.09050144f, 0.00716706f, -0.08793828f, -0.15062962f, -0.11756421f, -0.10983735f, 
    -0.00963796f, -0.12027809f, 0.05448535f, 0.15514454f, 0.03609411f, -0.04503240f, -0.05044895f, 0.01275737f, 
    0.11438136f, 0.11965197f, 0.25120887f, 0.35113302f, 0.00242810f, -0.07272850f, 0.13101953f, 0.24080603f, 
    -0.03557998f, 0.01001599f, -0.03291308f, -0.08925974f, -1.11217153f, -0.52162182f, -0.32966205f, -0.38820046f, 
    -0.07422289f, 0.03107188f, 0.12357588f, -0.14260368f, -0.00108150f, -0.03399842f, 0.01158723f, -0.00252618f, 
    0.00680405f, -0.04723387f, 0.06398632f, 0.12275591f, 0.02038705f, 0.04738048f, 0.02493417f, -0.05931054f, 
    0.01301211f, -0.04011971f, -0.07888584f, 0.21671507f, 0.01361404f, 0.09285244f, -0.16923030f, 0.15529555f, 
    -0.04153635f, 0.11098189f, -0.25926930f, 0.05917234f, -0.04035838f, 0.07938224f, 0.03035505f, -0.19071780f, 
    -0.14221263f, -0.14267276f, 0.02121597f, -0.02381168f, -0.02667166f, -0.07593534f, 0.00077849f, 0.04958776f, 
    -0.13737351f, -0.09475967f, -0.03568115f, 0.07894869f, -0.11455218f, 0.08697682f, 0.02372499f, -0.07099506f, 
    -0.06213961f, -0.07495853f, -0.04614685f, -0.08793861f, 0.03037408f, 0.04577163f, 0.39081317f, -0.09950338f, 
    -0.06545507f, -0.21664299f, -0.39387622f, -0.26911166f, 0.06651218f, -0.07632782f, 0.08315431f, -0.11990873f, 
    0.05681091f, 0.00860348f, -0.08391666f, 0.07257017f, 0.02764908f, -0.06247038f, -0.20195909f, 0.20165649f, 
    0.15513389f, -0.10656410f, 0.21623601f, 0.12046418f, 0.22183459f, 0.07952208f, 0.07777806f, -0.09484762f, 
    0.03280527f, -0.06802154f, -0.13669571f, 0.04373027f, -0.00189654f, -0.01211510f, 0.01788702f, 0.01920915f, 
    0.09489722f, -0.02090946f, -0.06724080f, 0.28432429f, 0.15025748f, -0.18850636f, -0.09192348f, -0.14398733f, 
    -0.00880451f, -0.00678170f, 0.08787275f, -0.02638554f, 0.06904963f, -0.25966734f, 0.01393778f, 0.17931476f, 
    -0.12105072f, -0.14169453f, 0.00328586f, 0.06836212f, -0.02648663f, -0.12361923f, 0.05920633f, 0.08235507f, 
    0.00129329f, -0.12179978f, 0.09700973f, 0.03628440f, 0.22406872f, 0.23075105f, 0.28889495f, -0.21700363f, 
    -0.11191391f, -0.04955633f, 0.04922269f, -0.20018028f, 0.04394567f, -0.01832965f, -0.04180218f, -0.15155469f, 
    -0.05997036f, 0.00759437f, -0.19000325f, 0.22469312f, 0.02646242f, 0.13331810f, 0.03495160f, -0.08370404f, 
    -0.12697533f, 0.18916997f, -0.06006301f, 0.06374899f, 0.19010808f, 0.03074731f, -0.14558494f, 0.32492006f, 
    0.14198954f, 0.00418033f, 0.10705793f, -0.00345296f, 0.03962265f, 0.04773330f, 0.04228288f, 0.08412713f, 
    -0.26836628f, -0.01807471f, -0.00135390f, -0.40103284f, 0.11402144f, -0.00638951f, -0.00019174f, -0.03919601f, 
    0.00269098f, -0.01537822f, -0.07109218f, -0.07803386f, 0.03024032f, -0.04343812f, -0.40794721f, -0.02189119f, 
    0.03084681f, 0.01934536f, 0.06316306f, -0.03384278f, 0.10574869f, 0.10152123f, -0.17717293f, -0.12319744f, 
    -0.00692885f, -0.03892919f, 0.10206144f, -0.02551275f, 0.02145380f, 0.09524105f, -0.07560082f, 0.22599433f, 
    -0.08303373f, -0.01611262f, 0.08285876f, 0.01101032f, -0.00239636f, -0.01856155f, 0.30834472f, -0.04044704f, 
    -0.12576063f, -0.34762928f, 0.20107862f, -0.09926055f, 0.08189245f, 0.04747947f, -0.02965754f, -0.01491643f, 
    0.21712042f, 0.15796417f, 0.00750712f, 0.21356878f, 0.00223858f, -0.03869584f, -0.19077891f, -0.13691851f, 
    0.17942196f, 0.11682264f, -0.04234220f, 0.07580093f, -0.31828901f, 0.03795599f, -0.08990534f, 0.39408353f, 
    -0.14424139f, -0.04609365f, 0.08299424f, -0.08509960f, -0.01058911f, 0.03307065f, 0.11407957f, -0.15176506f, 
    -0.27378875f, 0.17046328f, 0.10237751f, -0.14690429f, -0.03341460f, -0.04777635f, -0.15133202f, -0.14801219f, 
    0.13379329f, 0.14320925f, 0.00596774f, 0.01459232f, -0.15904349f, 0.08774189f, 0.04676762f, 0.04444901f, 
    -0.02586734f, -0.02725068f, 0.03134494f, -0.02914246f, -0.10627119f, -0.05587093f, -0.03988988f, 0.14595155f, 
    -0.52739769f, 0.56148124f, 0.40625843f, 0.07437453f, -0.14327125f, -0.02187844f, 0.05807607f, -0.25979847f, 
    0.00010168f, -0.02056315f, -0.23380898f, 0.05699107f, -0.84851736f, 0.03437247f, 0.38344091f, -0.53872150f, 
    0.01749572f, 0.09280695f, 0.03070117f, 0.12219210f, -0.01116811f, -0.05247446f, 0.05984464f, 0.01243512f, 
    -0.99287534f, -0.21978055f, -0.09400141f, -0.16387008f, 0.05214398f, -0.01983282f, 0.07163697f, -0.17849381f, 
    0.00118856f, 0.00550320f, -0.01498337f, -0.08989628f, -0.21715093f, 0.56939435f, 0.73903340f, 0.38337499f, 
    -0.30991456f, -0.03801230f, 0.02916045f, 0.10238993f, 0.04646627f, -0.05211075f, -0.01514172f, 0.02947755f, 
    0.09787094f, -0.04450301f, -0.07236072f, 0.06558934f, 0.17957063f, -0.12676692f, 0.03424937f, 0.00433559f, 
    0.22421464f, 0.03870794f, 0.06746846f, 0.02357947f, 0.33179495f, 0.33431494f, 0.64824468f, 0.21471199f, 
    -0.11276990f, -0.08514494f, 0.21155423f, -0.05778108f, -0.20724827f, -0.06083988f, 0.05682076f, -0.02287598f, 
    -0.03154596f, 0.46041521f, -0.10251809f, -0.92766637f, 0.24113773f, 0.29222530f, 0.02474432f, -0.05812395f, 
    -0.32120365f, -0.06378926f, 0.04112002f, -0.00330518f, 0.15418184f, -0.26715785f, 0.17632739f, 0.26792145f, 
    -0.01178916f, 0.10465275f, 0.04525583f, 0.19864468f, 0.04500910f, 0.00676284f, 0.16965458f, 0.03630010f, 
    -0.56633890f, 0.00421284f, 0.53641623f, 0.25114200f, -0.09768160f, 0.14036478f, -0.17032836f, -0.09229723f, 
    0.14979421f, -0.09177949f, -0.06096947f, 0.12510510f, -0.13587622f, 0.06039249f, -0.11539644f, 0.11164289f, 
    0.03394597f, -0.06831134f, -0.07381942f, 0.02023486f, -0.16145365f, 0.07627070f, -0.07129201f, 0.09235485f, 
    -0.08174052f, 0.49569154f, -0.50512487f, 0.06247437f, 0.17622033f, 0.00672723f, -0.06052261f, -0.00786084f, 
    -0.01796547f, 0.14763805f, -0.02937097f, -0.03881511f, -0.06687394f, -0.25603008f, -0.05599899f, 0.21302114f, 
    -0.01126778f, 0.07679744f, 0.01876469f, -0.05148019f, 0.09953738f, 0.01841747f, -0.12941377f, -0.13926518f, 
    -0.09497437f, 0.10699851f, -0.19707091f, -0.25285015f, -0.33195710f, -0.19896801f, -0.18023974f, 0.02233659f, 
    -0.06677123f, -0.00915159f, -0.28043416f, -0.04229407f, -0.99660760f, 0.48144731f, -0.38267809f, 0.06074496f, 
    -0.06180955f, -0.22303964f, 0.01472670f, -0.37728328f, 0.01199361f, -0.08376408f, -0.05136185f, -0.16541922f, 
    -0.66614777f, -0.47866768f, -0.31676206f, 0.08733946f, -0.23377700f, 0.23345523f, 0.02897689f, 0.05196928f, 
    -0.15158136f, 0.18742627f, 0.02867600f, -0.15187159f, -1.08716094f, 0.51454657f, -0.06952063f, 0.26432672f, 
    0.15964475f, -0.10014242f, 0.12083752f, -0.14994168f, -0.00511035f, -0.01006811f, 0.04015458f, -0.06399786f, 
    0.02911536f, -0.12434453f, -0.03818010f, 0.19131225f, 0.09896664f, 0.05820478f, 0.01882223f, 0.23930538f, 
    0.03938983f, 0.19107723f, 0.01365805f, -0.18646792f, 0.39665097f, 0.17852475f, -0.36461237f, -0.64254647f, 
    -0.17477526f, 0.15113467f, 0.08539072f, -0.12504366f, -0.03843028f, -0.24685556f, 0.23016363f, 0.05866367f, 
    0.18842506f, 0.19054884f, -0.13977104f, -0.06290398f, -0.14333080f, 0.06315066f, -0.04364524f, -0.04229925f, 
    0.05524044f, 0.13886675f, -0.12546681f, -0.09275156f, 0.34012392f, 0.10778242f, -0.14296564f, -0.07964551f, 
    -0.17402792f, 0.03335768f, -0.27942100f, 0.11929680f, -0.12592982f, -0.10194968f, 0.13310060f, 0.03704946f, 
    0.18751040f, 0.08054252f, -0.37032056f, 0.36418003f, -0.29471761f, -0.25132534f, -0.14146297f, -0.24117728f, 
    -0.14188108f, 0.17766404f, -0.00739641f, 0.14772707f, 0.27771243f, -0.01448297f, 0.00344864f, 0.28710830f, 
    -0.12790698f, -0.14198248f, -0.25026247f, -0.09536487f, -0.04299281f, 0.03787937f, 0.12252833f, 0.13669485f, 
    0.28617463f, -0.08314951f, 0.00660662f, -0.73756069f, 0.09808478f, -0.15212162f, -0.01604988f, -0.17378789f, 
    -0.09460560f, 0.04264477f, -0.07806987f, -0.03730943f, -0.12048434f, 0.67329639f, -0.41835380f, -0.15997033f, 
    0.01981859f, 0.12618259f, -0.14569746f, 0.18595326f, -0.15010859f, 0.00861809f, 0.06934261f, 0.14192733f, 
    -0.65483797f, 0.36964142f, -0.10778178f, 0.09565902f, 0.13974577f, -0.08669544f, 0.02980381f, -0.07977211f, 
    -0.04400887f, 0.21300200f, 0.06237315f, -0.06172242f, 0.00268992f, 0.69176465f, -0.19339488f, -0.22863089f, 
    0.07735530f, 0.08974286f, 0.10689995f, 0.20257244f, -0.10804208f, -0.28531575f, -0.11893288f, -0.16197003f, 
    0.25532824f, 0.02443793f, -0.01436624f, -0.01029717f, -0.16560297f, -0.09591656f, -0.15485348f, -0.33955675f, 
    -0.08783796f, 0.22659118f, -0.30168656f, -0.00063563f, -0.16850145f, -0.16274698f, -0.06907635f, 0.48296681f, 
    0.24462719f, 0.11601552f, 0.24884266f, -0.04501176f, 0.03283699f, -0.14782308f, 0.19351371f, -0.24118367f, 
    -0.14010526f, 0.05975381f, -0.09645787f, 0.25195426f, 0.04558779f, 0.11053742f, 0.13871339f, 0.04249268f, 
    -0.10098115f, -0.23654085f, 0.08590783f, -0.05737201f, 0.40361145f, -0.18949668f, -0.05805095f, 0.13180536f, 
    -0.07873955f, -0.02986348f, -0.09871823f, -0.09983952f, 0.00492250f, -0.00959419f, 0.18093054f, -0.00556364f, 
    -0.39282897f, -0.04943988f, 0.32495451f, 0.39630091f, -0.11585787f, 0.13798322f, -0.09476738f, -0.02853340f, 
    0.03723084f, 0.18045290f, 0.02560242f, -0.06837300f, -0.33789375f, 0.04310823f, -0.24236751f, 0.02431934f, 
    -0.07382660f, -0.00820285f, -0.23576099f, -0.07521591f, 0.04405607f, 0.12489948f, -0.14498466f, -0.05772756f, 
    -0.28961051f, 0.20375627f, -0.00143286f, 0.48644477f, 0.03390086f, -0.04089213f, 0.18372682f, -0.08174215f, 
    -0.05796348f, -0.05019777f, 0.05292730f, 0.10416476f, -0.22971453f, -0.40422919f, 0.11996014f, -0.08628658f, 
    -0.20725967f, -0.07704078f, -0.25973877f, 0.04704405f, 0.01660069f, 0.15637086f, -0.07598379f, -0.24583240f, 
    -0.19234718f, -0.19429027f, -0.21989504f, 0.24259029f, 0.02506950f, 0.04104143f, -0.03900512f, 0.12418249f, 
    -0.02074393f, -0.05903114f, 0.07799451f, 0.03308661f, 0.24289809f, -0.25218976f, -0.09136314f, 0.26935592f, 
    0.22858566f, 0.06195486f, 0.03166613f, 0.03636616f, -0.11701178f, -0.03252156f, 0.18108927f, 0.10739667f, 
    -0.19805652f, -0.26025227f, 0.03465666f, -0.06729456f, 0.05640602f, -0.05397437f, -0.12245476f, -0.31224132f, 
    0.04252744f, 0.05828079f, -0.21192086f, 0.17662545f, 0.01517632f, -0.04591018f, 0.01266393f, 0.21826848f, 
    0.02994959f, -0.00467289f, 0.05001895f, -0.05797565f, -0.06543253f, 0.03650891f, 0.00044423f, 0.04417865f, 
    0.24252433f, -0.31879288f, 0.10815670f, -0.18908103f, -0.31686389f, -0.14759684f, 0.00061895f, -0.01936726f, 
    0.00386135f, 0.04129012f, -0.19028084f, -0.02015130f, 0.15135664f, 0.44453058f, 0.30737764f, 0.25545290f, 
    0.06681047f, 0.24845563f, -0.14063379f, 0.22322810f, 0.01808935f, -0.00842349f, 0.03390411f, -0.03962321f, 
    0.23556311f, 0.22257435f, -0.23691304f, 0.43990165f, 0.21376820f, -0.00901190f, 0.23621082f, 0.06284990f, 
    0.02099657f, 0.07355409f, 0.01169312f, -0.03833319f, -0.07668239f, -0.14427960f, 0.17039494f, 0.06632546f, 
    0.09905498f, -0.01267307f, -0.08570539f, -0.23810214f, -0.02558735f, 0.03031867f, 0.04929275f, -0.06721456f, 
    -0.19640824f, -0.42428347f, 0.24618581f, -0.15858600f, -0.26078478f, 0.16905119f, -0.41301373f, -0.11295672f, 
    -0.06680875f, -0.03931556f, -0.01166984f, 0.12088633f, 0.01168552f, 0.18066508f, 0.19533299f, 0.20341198f, 
    -0.11157030f, -0.03555081f, -0.02682844f, 0.13595475f, 0.00436941f, -0.00947500f, 0.00375498f, 0.02309803f, 
    -0.55504221f, -0.10785937f, -0.18400988f, 0.00824584f, 0.04510950f, 0.09029699f, 0.06412806f, -0.06169740f, 
    -0.12840411f, -0.02101433f, 0.09846208f, -0.09484449f, 0.18376303f, -0.42811999f, 0.01933468f, -0.45921072f, 
    -0.23643336f, 0.10405803f, -0.15745746f, 0.10471751f, -0.13491069f, -0.00857616f, -0.19672978f, 0.18957718f, 
    0.03074686f, 0.02719728f, -0.01867266f, -0.04380480f, 0.17148855f, 0.02773549f, 0.03879144f, 0.05857078f, 
    0.20762753f, 0.05306346f, 0.00649156f, 0.10071904f, -0.17293562f, -0.17798111f, -0.05921962f, -0.17666763f, 
    0.03197654f, -0.10602459f, 0.06353165f, -0.00775614f, -0.17722201f, 0.12385862f, -0.13503520f, 0.18991774f, 
    0.29882613f, 0.18456237f, 0.21193349f, 0.28170544f, -0.11857355f, -0.10648943f, -0.14359236f, -0.20394543f, 
    0.02248451f, 0.12834671f, -0.07598075f, -0.01471719f, -0.06849203f, -0.08041599f, 0.19279353f, -0.01241031f, 
    0.04072445f, -0.27942100f, -0.24386396f, -0.05713549f, -0.15326972f, 0.12765577f, -0.47725180f, 0.17734866f, 
    0.20028803f, -0.22756268f, -0.12603801f, 0.05572730f, 0.04933975f, -0.05713072f, 0.00494900f, -0.06052793f, 
    0.20257883f, 0.05074090f, 0.40678248f, 0.47169948f, 0.19918156f, 0.01618647f, -0.18523562f, -0.03648844f, 
    0.25653297f, -0.14074595f, -0.04179339f, -0.19674541f, 0.05086721f, -0.15748942f, 0.05802968f, -0.24867651f, 
    -0.01879983f, 0.04292948f, 0.07232787f, 0.09282647f, -0.08106932f, 0.26508823f, -0.05757491f, 0.14700517f, 
    0.08002819f, -0.02706168f, -0.09087376f, -0.08816364f, -0.31063053f, 0.10793420f, -0.11601685f, -0.00062400f, 
    0.04418680f, 0.00528502f, -0.24421720f, -0.13438176f, -0.13797863f, -0.10505406f, -0.04585080f, -0.12718819f, 
    -0.09615407f, -0.11984736f, -0.23728901f, -0.15941615f, -0.13082774f, -0.05020269f, 0.01542697f, 0.09027177f, 
    -0.07445176f, -0.12729089f, -0.13290186f, -0.05568688f, -0.21885885f, -0.52643698f, 0.15892459f, -0.05396591f, 
    -0.03344133f, 0.00965256f, -0.10145875f, -0.12145191f, -0.01417701f, -0.11419657f, -0.03036185f, -0.00639622f, 
    -0.40213406f, 0.05960341f, -0.35060403f, -0.35696507f, 0.10245989f, 0.00967065f, 0.02371383f, 0.06737573f, 
    -0.14499180f, 0.01404594f, 0.00375866f, -0.28748339f, -0.35912487f, -0.08953699f, 0.23564574f, -0.05898698f, 
    0.03266536f, 0.14216089f, -0.03307528f, -0.03997415f, -0.08578698f, 0.02172263f, -0.05785321f, -0.13034917f, 
    -0.09593099f, 0.03291294f, 0.01750443f, 0.10009389f, -0.14637595f, -0.19321443f, 0.04024944f, -0.05309603f, 
    0.07265785f, -0.04156052f, -0.08788237f, -0.03491168f, 0.22344542f, 0.03659142f, -0.05215031f, 0.02419880f, 
    0.01144757f, -0.14487180f, -0.15937504f, -0.12285943f, -0.00899200f, -0.02211537f, -0.05718730f, 0.15298954f, 
    -0.08671827f, 0.07648481f, 0.05686061f, 0.04641589f, 0.06600915f, 0.08261555f, -0.02104837f, -0.11912035f, 
    0.12700388f, 0.03510300f, -0.21656214f, 0.01478260f, -0.18015571f, 0.03616568f, 0.23685277f, -0.08029254f, 
    -0.15490419f, -0.11214454f, -0.11991525f, -0.06809223f, 0.02342477f, 0.03117205f, -0.09413970f, 0.16050461f, 
    0.01375492f, 0.18477112f, -0.36426947f, -0.04558791f, 0.01327893f, -0.13299470f, 0.06304365f, -0.10442197f, 
    0.22678636f, 0.11317938f, -0.13832583f, 0.27942142f, -0.14747836f, -0.08276774f, 0.03705750f, -0.05891304f, 
    -0.00437079f, -0.05609911f, 0.01326769f, -0.04062010f, -0.02218521f, -0.06337513f, 0.13875838f, 0.27127230f, 
    0.10679030f, -0.13294894f, 0.23849177f, -0.07690871f, 0.04648642f, -0.10044001f, -0.11375872f, -0.02406585f, 
    -0.06386389f, -0.35724646f, -0.08047164f, 0.15844180f, 0.03525289f, -0.06220920f, -0.16093177f, 0.25693578f, 
    -0.21343726f, -0.01570353f, -0.02728873f, 0.24308005f, 0.13201323f, -0.01169412f, 0.04670883f, -0.06886666f, 
    0.07160376f, 0.10428264f, 0.34703866f, 0.07684059f, -0.05167980f, -0.03496595f, -0.00719985f, 0.13226920f, 
    0.10168350f, 0.12972945f, 0.07466972f, 0.08974067f, -0.14806829f, 0.16048194f, 0.13456458f, 0.24089123f, 
    -0.14399332f, -0.05528126f, -0.08990052f, -0.04477993f, 0.00910616f, 0.01263568f, 0.07043488f, 0.06084454f, 
    -0.08269176f, 0.13019159f, -0.17051457f, -0.01609530f, -0.13526070f, -0.02347697f, -0.05209507f, -0.27873868f, 
    0.09651509f, -0.07437182f, -0.13703962f, -0.00838378f, 0.06711715f, 0.15631784f, 0.05371469f, 0.15968452f, 
    -0.15291120f, -0.18563916f, 0.06348071f, -0.01130274f, 0.03604008f, 0.06723891f, 0.02309746f, 0.12415130f, 
    -0.39325690f, 0.17244501f, -0.12318105f, 0.24058005f, 0.07800650f, -0.19023582f, -0.13406381f, 0.06612707f, 
    0.29799083f, 0.08232121f, 0.05466020f, -0.03237464f, 0.07646257f, -0.05023010f, 0.01581357f, 0.28055397f, 
    -0.07325679f, -0.05511932f, -0.14363378f, -0.01910054f, 0.02657878f, -0.02262778f, 0.03674683f, -0.11009682f, 
    -0.01677775f, -0.20701185f, -0.63990957f, 0.10695267f, 0.09153377f, 0.03650042f, 0.14646502f, 0.13318673f, 
    -0.00579635f, -0.07762104f, -0.16640185f, -0.00337125f, -0.02209007f, 0.14627479f, 0.33811873f, -0.13540603f, 
    0.04018258f, 0.02963158f, 0.15609555f, -0.01825978f, 0.05546905f, 0.07496206f, 0.11198777f, 0.04082144f, 
    0.06409212f, 0.18865772f, 0.32658887f, -0.05552837f, -0.02135289f, -0.15144651f, 0.02124846f, 0.15368749f, 
    -0.05487845f, -0.00600192f, -0.05534964f, 0.23153414f, 0.09898835f, 0.16648868f, -0.00138213f, 0.11781398f, 
    0.19596472f, 0.12827590f, -0.02061353f, 0.11063521f, -0.02517667f, 0.00145144f, 0.04041402f, 0.16866972f, 
    0.62065876f, -0.05166366f, -0.02301856f, 0.24302351f, 0.00058917f, -0.24427281f, 0.02936991f, 0.11415723f, 
    -0.02405928f, 0.08288605f, 0.01082043f, -0.14943779f, 0.28443018f, -0.20997687f, 0.51166606f, 0.02432837f, 
    -0.07741150f, -0.05551958f, -0.17320177f, 0.11218429f, 0.22385654f, -0.04700807f, -0.17156354f, 0.20674530f, 
    -0.12854730f, -0.18886974f, -0.01881636f, -0.02769712f, 0.03501000f, -0.03087793f, -0.02521880f, -0.08896347f, 
    0.16312888f, -0.16679968f, -0.12249848f, -0.05067125f, 0.23731641f, 0.15627241f, -0.23006341f, -0.13373835f, 
    -0.05597618f, 0.10183462f, -0.00941569f, -0.07571076f, 0.07091036f, -0.00802079f, -0.17301160f, -0.36943540f, 
    -0.00067808f, 0.13127489f, 0.10610728f, -0.09666142f, 0.09166004f, 0.16783431f, 0.14466998f, -0.04498019f, 
    -0.04831101f, -0.08888543f, -0.05605456f, 0.01004251f, -0.62331361f, -0.07820915f, 0.27900434f, 0.13289854f, 
    -0.02057127f, -0.15543561f, 0.27488750f, 0.11681459f, 0.02115574f, 0.02977698f, -0.12721090f, -0.22743443f, 
    -0.25318301f, -0.17994504f, -0.02140129f, 0.10848367f, 0.05369371f, 0.04258863f, -0.01129819f, -0.00928546f, 
    0.06906008f, -0.45222333f, -0.43462765f, -0.30456379f, -0.30983493f, 0.23038077f, -0.35094491f, 0.10607273f, 
    0.01905223f, -0.05508025f, -0.05756173f, -0.04856706f, 0.00485320f, 0.26702011f, 0.03567086f, -0.18551277f, 
    -0.08266965f, -0.02947878f, -0.06782051f, -0.15527011f, -0.04569169f, -0.01808437f, -0.10282648f, 0.03223542f, 
    0.02513130f, -0.07836945f, 0.07210688f, 0.03356023f, 0.14821002f, 0.13013837f, -0.15521885f, -0.24856031f, 
    0.18386829f, -0.04633227f, -0.12520218f, 0.17772780f, 0.24426907f, -0.04542176f, -0.05159174f, 0.10573754f, 
    -0.03620549f, -0.49343109f, 0.26202780f, 0.33043364f, -0.14656210f, -0.11164050f, 0.01277987f, 0.02581214f, 
    -0.06271173f, 0.04709641f, -0.05036269f, -0.06596544f, 0.07080362f, 0.25760028f, -0.01358956f, -0.02090542f, 
    -0.23535189f, -0.25291303f, 0.12121310f, -0.02931119f, -0.09404249f, -0.03521984f, -0.23647517f, -0.11996696f, 
    -0.28500667f, -0.28404179f, -0.85413677f, -0.03916121f, 0.10586917f, 0.09115195f, -0.05392327f, -0.02202878f, 
    0.13495409f, -0.24532554f, 0.01775247f, 0.20614444f, -0.25471708f, 0.09413962f, -0.25923851f, 0.56141728f, 
    -0.04316653f, -0.00995351f, -0.05493881f, 0.00925843f, -0.13176326f, -0.00011187f, 0.08444716f, 0.07569016f, 
    0.05376469f, -0.04692287f, -0.15086320f, -0.01912768f, 0.05033670f, 0.15266266f, -0.03407330f, 0.25914440f, 
    -0.21116093f, 0.03562709f, -0.02768651f, 0.09616319f, -0.13836709f, 0.27942103f, -0.46008274f, -0.19632711f, 
    -0.01699716f, -0.01592076f, 0.04586313f, 0.21174625f, 0.16330206f, 0.04508520f, -0.14044015f, -0.06356233f, 
    0.04068110f, -0.02791173f, -0.10199232f, 0.02469472f, -0.02330386f, -0.13839021f, 0.02632828f, 0.13460547f, 
    -0.28038877f, 0.22914641f, 0.09497826f, -0.14214417f, 0.05712924f, -0.10781132f, -0.00113262f, -0.01513850f, 
    0.29418340f, -0.08156297f, 0.16991666f, 0.16254221f, 0.01076201f, 0.16930975f, -0.07253948f, -0.10976748f, 
    0.21339700f, -0.12469138f, -0.06840082f, -0.29283339f, 0.07560648f, 0.09755775f, -0.00141938f, 0.16239488f, 
    -0.16690251f, -0.33630735f, -0.20393954f, -0.49665698f, 0.26519480f, -0.10983095f, -0.02487647f, 0.07776796f, 
    0.05386560f, 0.02427679f, 0.01493960f, 0.01774957f, 0.14426947f, -0.09975450f, 0.26193950f, -0.19970815f, 
    -0.27371442f, -0.28245583f, -0.37918690f, -0.40533021f, 0.11534601f, 0.03404421f, -0.05158218f, -0.00240289f, 
    0.12351837f, 0.08188906f, 0.15738508f, -0.12835963f, 0.37508002f, -0.04374264f, -0.70759356f, 0.38776845f, 
    0.18273160f, 0.13558438f, 0.03381354f, -0.05586234f, 0.03501723f, -0.05895081f, -0.00771989f, 0.08930421f, 
    0.06125532f, 0.16346224f, 0.09795111f, -0.36309192f, 0.20002450f, 0.04746090f, 0.03861422f, -0.25530824f, 
    0.05174900f, -0.07368771f, 0.01258279f, 0.01226746f, -0.55093408f, -0.39137629f, -0.16434634f, -0.48290822f, 
    0.12696156f, 0.01905094f, 0.01576604f, 0.03460070f, -0.08998094f, -0.08963399f, 0.07708163f, 0.10947752f, 
    -0.02161379f, -0.13033244f, -0.00687282f, 0.06275600f, 0.01408618f, -0.01917041f, 0.25116929f, 0.30959395f, 
    0.03837758f, 0.25111306f, 0.24864280f, -0.14633390f, -0.19010097f, 0.05497571f, -0.24391849f, -0.14370078f, 
    0.10484924f, 0.11073571f, -0.12666778f, 0.07026158f, 0.08472960f, -0.01996239f, -0.27083719f, -0.29596928f, 
    -0.17352811f, -0.09963914f, 0.39873135f, -0.24322255f, -0.05977239f, 0.04287277f, -0.05554338f, 0.02315743f, 
    -0.17617078f, 0.10661712f, 0.11811611f, 0.06927855f, -0.38802236f, -0.94915307f, -0.65249407f, -0.24747729f, 
    -0.10450345f, 0.14144312f, 0.28898129f, -0.32367411f, -0.04400663f, 0.01549620f, -0.02348502f, 0.05249342f, 
    0.28799191f, -0.66376531f, -0.15479790f, 0.03356276f, 0.05762563f, 0.15149044f, 0.22290434f, -0.12354684f, 
    0.00450986f, -0.04523001f, 0.03436340f, -0.03679332f, -0.33907515f, -0.77664876f, -0.28199413f, 0.20078532f, 
    -0.03153043f, 0.03192759f, -0.32703656f, -0.50878304f, -0.07834800f, -0.04641324f, -0.06123634f, -0.05036042f, 
    -0.69139808f, -0.34348428f, -0.70707059f, 0.41228294f, -0.19874465f, -0.14783111f, 0.04420072f, 0.02670182f, 
    -0.04605434f, 0.03611677f, 0.04088899f, -0.01518465f, -0.52308798f, -0.66018409f, -0.78169459f, -0.20154791f, 
    -0.14674412f, -0.15058316f, 0.04670870f, -0.25340360f, 0.01054208f, -0.02606099f, -0.00818204f, -0.07331589f, 
    0.18038844f, 0.20100394f, -0.13706931f, 0.04380503f, -0.08450968f, -0.04375452f, -0.00038493f, 0.25300068f, 
    -0.14015456f, 0.06221392f, 0.15184417f, -0.08172578f, -0.18952061f, -0.29476854f, -0.05936576f, 0.27152339f, 
    0.03363549f, 0.08044245f, 0.17194389f, 0.38215858f, 0.05426068f, 0.03260846f, 0.02858539f, 0.03545506f, 
    -0.02277857f, -0.12817137f, -0.14710203f, -0.02452954f, -0.01675708f, -0.02228495f, -0.08021502f, 0.01890462f, 
    -0.03128107f, -0.27552822f, -0.17173582f, -0.28208140f, -0.23118600f, 0.30546576f, 0.04858115f, 0.02680865f, 
    0.07948656f, -0.03356732f, -0.02311692f, 0.06012104f, 0.04605755f, 0.07579219f, 0.08159266f, 0.20834012f, 
    -0.90563738f, -0.11209696f, 0.13861056f, -0.54682940f, -0.21781391f, -0.35734755f, -0.26606739f, -0.18286616f, 
    -0.09627582f, 0.01411114f, -0.03304259f, -0.12333687f, 0.13876425f, -0.08284392f, 0.16896312f, 0.07586378f, 
    -0.09034449f, 0.00439699f, -0.10486761f, 0.09844264f, 0.06387333f, 0.02662703f, 0.33099967f, -0.01192369f, 
    -0.02732887f, 0.02888346f, -0.09469932f, -0.05467116f, 0.00498684f, 0.02809760f, 0.05976024f, 0.02000936f, 
    0.18048681f, 0.16013318f, 0.14280418f, -0.19086210f, 0.18918081f, 0.05894180f, 0.05717942f, -0.10197081f, 
    -0.00346609f, -0.03640908f, -0.07552777f, 0.14548627f, 0.04435399f, 0.18064250f, -0.00399214f, -0.36754197f, 
    0.08373154f, -0.16390583f, -0.21137258f, -0.09850180f, -0.09301186f, 0.17636506f, 0.09875639f, -0.05010973f, 
    -0.08394597f, 0.03507384f, -0.17583004f, -0.07892222f, 0.50125217f, 0.09978397f, -0.03923008f, -0.27689499f, 
    -0.09162223f, 0.02472698f, 0.11378706f, 0.14806174f, 0.13059951f, 0.07037064f, -0.00842040f, 0.04319798f, 
    0.09776559f, -0.04918452f, -0.27514663f, 0.27519438f, -0.25613174f, -0.00428535f, -0.16302134f, 0.42129025f, 
    -0.00459577f, -0.12088192f, 0.26482421f, -0.17776379f, -0.20604013f, 0.00614034f, -0.20140272f, -0.11286876f, 
    0.03814326f, 0.16295600f, 0.00582308f, -0.10169731f, -0.02635052f, 0.09484982f, 0.13068289f, -0.06241073f, 
    -0.07715642f, -0.21658362f, 0.00420104f, -0.32426414f, 0.08398569f, -0.01016708f, 0.00575015f, 0.02525127f, 
    -0.01257965f, 0.17082714f, -0.08281819f, 0.02822284f, -0.17138730f, -0.02043820f, 0.31118339f, 0.11063592f, 
    0.15557565f, -0.06298998f, 0.08325391f, -0.03078561f, -0.12528068f, -0.03696088f, -0.02046117f, 0.06496335f, 
    0.14630875f, -0.22818244f, -0.20736873f, 0.11802495f, -0.23221089f, 0.01221674f, 0.39130983f, 0.05020598f, 
    0.04283167f, -0.02251412f, -0.13059680f, -0.11377338f, -0.00692040f, 0.23561554f, 0.15101336f, -0.12464150f, 
    -0.04150111f, -0.13002019f, -0.09375728f, -0.18076508f, 0.02009687f, -0.03071457f, -0.00203656f, -0.08578590f, 
    0.56598437f, 0.16178057f, -0.19754778f, 0.01182697f, -0.08416494f, 0.05528158f, 0.03235278f, 0.22548814f, 
    0.24012256f, -0.07918905f, 0.08647463f, -0.02976413f, -0.51801652f, -0.51800019f, -0.33334824f, -0.53199965f, 
    0.20421866f, 0.28066948f, -0.03994283f, -0.08488110f, 0.09402393f, -0.08385369f, -0.01097981f, 0.13570385f, 
    0.19062619f, -0.04643525f, -0.06517765f, 0.10804928f, -0.03287402f, 0.04133156f, 0.14260405f, 0.02431751f, 
    0.07757160f, 0.08872470f, 0.08872543f, 0.13247107f, 0.04380593f, 0.18424866f, -0.00004441f, 0.00886078f, 
    -0.02174657f, 0.00906386f, 0.07444099f, 0.08941731f, -0.05128030f, 0.07192926f, 0.15619026f, 0.21934457f, 
    0.19478697f, 0.89907640f, 0.03846501f, -0.01541039f, 0.03934665f, -0.04125922f, -0.01858660f, -0.12789294f, 
    0.05840438f, -0.03635617f, 0.12717499f, 0.06178198f, 0.34828073f, -0.19005986f, -0.26386198f, -0.58803773f, 
    0.01165796f, 0.09298934f, 0.52200425f, -0.13013057f, 0.00541165f, 0.09781232f, -0.14123645f, -0.03855778f, 
    -0.68544644f, -0.71036607f, -0.27448374f, 0.01226733f, -0.26597142f, -0.08283574f, -0.41331044f, -0.17812052f, 
    -0.05246503f, 0.02036937f, -0.02786514f, -0.01588081f, -0.56835133f, -0.18809925f, 0.36663774f, 0.76875281f, 
    -0.04628403f, -0.32094738f, -0.01809595f, 0.04113431f, 0.02814639f, 0.09899866f, 0.00919574f, 0.02047348f, 
    0.20471787f, -0.04553972f, -0.03968103f, 0.25274792f, 0.04515267f, 0.08783671f, -0.12311558f, -0.27048248f, 
    0.14919226f, -0.23967463f, 0.05526849f, -0.03807330f, -0.45941311f, 0.09695854f, 0.18267760f, -0.34908915f, 
    -0.17200182f, 0.05681074f, -0.13687192f, -0.03993207f, -0.08147420f, 0.05706690f, 0.18965107f, 0.10691496f, 
    0.52605569f, 0.36440858f, -0.32141477f, -0.19768834f, 0.05623861f, 0.00070508f, -0.03859279f, -0.02298613f, 
    -0.10266682f, 0.21650176f, -0.07044077f, -0.13005789f, -0.63872385f, 0.48024440f, -0.03350362f, 0.10026057f, 
    -0.03808338f, -0.08081675f, -0.09087598f, -0.02354264f, -0.01502387f, -0.00347308f, -0.04063198f, -0.00551919f, 
    -0.31633127f, 0.21473798f, 0.04055532f, -0.19240735f, -0.02425571f, -0.03561066f, -0.07196730f, 0.21609439f, 
    0.13795649f, 0.13863079f, 0.05069247f, -0.04488306f, -0.43629235f, -0.73003709f, 0.37349960f, 0.09434442f, 
    0.08835410f, -0.05019241f, -0.41480377f, 0.13250272f, -0.01629955f, 0.02691671f, 0.02020230f, -0.03577799f, 
    0.06595203f, -0.92003483f, 0.27144277f, -0.34782586f, 0.02484740f, 0.00160656f, 0.03626153f, 0.20785937f, 
    -0.04926179f, -0.00066899f, -0.11014037f, 0.00872844f, -0.31747371f, -0.08038695f, -0.24853063f, -0.06304465f, 
    0.11003801f, -0.15504670f, 0.02207565f, 0.18824203f, 0.02267620f, -0.00584718f, -0.11463840f, -0.03929482f, 
    0.14969260f, -0.23392889f, -0.07130548f, -0.21802050f, -0.03396694f, -0.00943384f, -0.07873289f, -0.06116570f, 
    -0.01032121f, -0.11436313f, -0.10491091f, -0.38458905f, -0.02937900f, -0.14660163f, 0.16945542f, -0.32450992f, 
    0.06819500f, -0.16079347f, -0.03778132f, -0.12195059f, 0.10804279f, -0.01378633f, 0.03191450f, -0.02365736f, 
    0.07206766f, 0.02837885f, 0.09366506f, -0.03023535f, 0.00550261f, 0.03006317f, -0.01865710f, 0.01905280f, 
    0.03093430f, -0.09589966f, -0.00417893f, 0.03971168f, 0.05406850f, 0.12272518f, -0.08328678f, -0.09112802f, 
    0.00351177f, -0.02559976f, -0.04011058f, 0.10711503f, -0.02930578f, 0.29327253f, 0.05967168f, -0.03556276f, 
    -0.51650947f, -0.61531717f, -0.26409081f, 0.56859279f, 0.15479150f, -0.04450625f, -0.04128241f, 0.10396649f, 
    -0.03832824f, -0.02842004f, 0.00813166f, 0.00863261f, 0.24557739f, 0.13268678f, -0.02769257f, -0.21075028f, 
    -0.00194201f, 0.00582366f, -0.28064030f, -0.11098508f, -0.05344184f, -0.08348384f, 0.03459802f, -0.07955601f, 
    0.21871978f, -0.07143652f, 0.13327089f, -0.02515393f, -0.00102489f, 0.01526752f, 0.01507412f, -0.02166307f, 
    0.16919990f, -0.06598978f, 0.05447015f, 0.05780823f, -0.27775100f, 0.07554968f, 0.00128076f, 0.15977991f, 
    -0.01353508f, 0.01740873f, 0.11123124f, -0.05004727f, 0.01253445f, -0.05017492f, -0.06110751f, -0.02790415f, 
    0.03512988f, 0.03322535f, -0.01328779f, -0.04932629f, -0.05690686f, 0.05353382f, -0.00102705f, -0.04803830f, 
    0.00140872f, 0.00594731f, -0.05495226f, -0.02879766f, -1.06281531f, 0.72885770f, -0.63792658f, 0.61552829f, 
    0.05994017f, 0.04278036f, 0.21259670f, -0.11094283f, -0.03867618f, -0.04931884f, 0.01508815f, 0.04742628f, 
    0.57026821f, -0.63045776f, -0.05299160f, -0.12351399f, 0.09364787f, 0.06290171f, 0.00436806f, -0.12474111f, 
    -0.12953727f, 0.15121637f, 0.06299069f, -0.37271714f, 0.27309862f, -0.06789850f, -0.35074645f, -0.02135561f, 
    0.04887880f, -0.22623420f, 0.02946435f, -0.03365717f, -0.05121223f, 0.18185054f, -0.07516823f, -0.04966103f, 
    0.08419180f, 0.02588166f, 0.16712940f, -0.02192012f, 0.00686562f, 0.00455632f, -0.00052086f, -0.03219113f, 
    0.02052599f, -0.12613910f, 0.09124064f, -0.13173582f, 0.07236376f, 0.29030469f, -0.19851460f, -0.07202599f, 
    -0.00140962f, 0.00513040f, 0.12974893f, 0.03264703f, -0.09958901f, 0.04575883f, 0.01809192f, -0.13698313f, 
    0.10162603f, -0.10097454f, -0.02095166f, 0.02015994f, -0.21557538f, 0.02266042f, -0.23017894f, -0.01839538f, 
    -0.00456659f, 0.00020251f, -0.00787215f, 0.09983286f, -0.10724609f, 0.12234312f, 0.01280980f, 0.03965777f, 
    0.07619398f, -0.11237947f, -0.01351092f, -0.06578502f, 0.05472336f, 0.03237740f, 0.06798864f, 0.10073818f, 
    -0.23540984f, -0.24484080f, -0.21111344f, -0.08819430f, 0.04861508f, -0.00100605f, 0.13978831f, 0.14817931f, 
    -0.00429076f, 0.05778888f, 0.10754219f, 0.10956362f, -0.33656964f, 0.20198101f, -0.14789689f, -0.14857705f, 
    0.22848214f, 0.07234780f, -0.02917579f, -0.15866134f, 0.00209461f, 0.00650467f, -0.02229363f, 0.00810812f, 
    0.29766697f, -0.13608116f, 0.01132398f, -0.04502581f, -0.00208310f, 0.01323204f, -0.07659072f, -0.05933847f, 
    0.17516127f, 0.19091403f, 0.08311297f, 0.23725615f, 0.03147380f, -0.09026932f, 0.00451777f, -0.17211574f, 
    -0.03987871f, -0.00456351f, 0.01322141f, -0.02321623f, 0.14513183f, -0.06162962f, -0.02896700f, -0.12074169f, 
    -0.51503682f, -0.28237826f, -0.41194063f, 0.07823506f, -0.04105468f, -0.17220195f, 0.12475864f, -0.02412955f, 
    -0.20309833f, -0.04954130f, 0.07666888f, 0.12584284f, -0.18400131f, 0.17273419f, -0.05530278f, -0.02879991f, 
    -0.05437532f, -0.01365540f, -0.25091642f, -0.16800916f, 0.08309164f, 0.08710414f, 0.04953438f, 0.00662602f, 
    -0.38784111f, -0.41840059f, 0.41581535f, 0.05231829f, -0.05786552f, 0.11708000f, 0.12936474f, 0.21046324f, 
    -0.08589178f, -0.10322755f, -0.07670704f, -0.08432663f, 0.24456328f, -0.79558194f, -0.75268316f, -0.75400394f, 
    -0.02354753f, -0.06697755f, 0.04185567f, 0.24126533f, 0.09932576f, 0.02691093f, -0.02803664f, -0.05926703f, 
    0.02771176f, -0.00923614f, 0.05726821f, -0.01842378f, -0.18150607f, -0.03601137f, -0.07773737f, 0.06750566f, 
    -0.00609328f, -0.03108931f, 0.02893860f, -0.09353812f, 0.50361985f, -0.58149809f, -0.63154513f, -0.54023153f, 
    -0.12337969f, -0.26914465f, -0.04606273f, 0.11546141f, 0.20350644f, 0.07965292f, -0.11529564f, 0.07532291f, 
    0.09996270f, -0.16333765f, -0.29529667f, -0.34254807f, -0.09408095f, -0.01487545f, 0.00785732f, -0.00982518f, 
    0.14810622f, 0.09197149f, 0.14037755f, 0.07934531f, 0.03675827f, 0.40118027f, 0.02173401f, -0.14303574f, 
    0.15913180f, -0.06709071f, -0.06741376f, -0.30413586f, -0.02433670f, -0.01035082f, -0.05016916f, -0.07770971f, 
    -0.30417353f, -0.07493758f, 0.18724981f, -0.07261522f, -0.04924327f, -0.08729156f, -0.34730506f, -0.07749150f, 
    -0.14497244f, 0.04085981f, -0.06240370f, -0.02413587f, 0.32596540f, 0.19118208f, -0.00786882f, -0.23138756f, 
    -0.18342161f, -0.05233968f, -0.11402818f, -0.25025588f, 0.05528682f, 0.14308900f, -0.00036962f, 0.08252364f, 
    0.56535262f, 0.19777989f, -0.29607630f, 0.02769737f, 0.11330261f, 0.02762264f, 0.20059505f, -0.19493422f, 
    0.06939376f, -0.07297171f, 0.02016728f, -0.00650262f, -0.18471670f, -0.51930493f, -0.26257595f, -0.03439004f, 
    -0.17814420f, -0.02024094f, -0.02492751f, -0.33147410f, -0.00505776f, -0.05505135f, 0.03299328f, -0.01666525f, 
    0.11153140f, 0.09190567f, -0.16111842f, -0.18663722f, 0.11741977f, 0.08673156f, -0.01309403f, -0.07248762f, 
    0.02441062f, 0.09933825f, 0.14079644f, 0.20097795f, 0.89835060f, -0.08697122f, 0.08026495f, -0.06982317f, 
    0.20642518f, 0.10568965f, 0.02467125f, -0.03566027f, 0.05566969f, 0.01501836f, -0.08135103f, -0.06189496f, 
    -0.26658845f, 0.02118845f, -0.03068625f, -0.15283483f, -0.03577953f, -0.10605848f, 0.01219514f, 0.00350301f, 
    -0.01707261f, 0.04987838f, -0.02038900f, 0.05607320f, 0.18529563f, -0.15916535f, 0.03821671f, 0.23497847f, 
    0.00560645f, 0.10308617f, -0.11510336f, -0.00183289f, -0.12845448f, -0.22683285f, -0.28004318f, -0.12574045f, 
    -0.07921886f, -0.93487668f, -0.85692877f, -0.24184141f, -0.16057265f, 0.11030775f, 0.02548820f, 0.03526812f, 
    -0.07566727f, 0.12606733f, 0.08254149f, 0.01066527f, 0.13309798f, 0.04281339f, -0.03986084f, -0.22564280f, 
    -0.02512375f, -0.02097561f, -0.07580420f, -0.06971966f, 0.05189617f, 0.02910863f, -0.05284393f, 0.19207890f, 
    -0.17080490f, -0.05211484f, -0.09474949f, -0.20189118f, 0.08372373f, -0.10875961f, -0.02049398f, -0.03475812f, 
    -0.42473063f, 0.01151786f, -0.35923207f, -0.58880174f, -0.08159120f, 0.17826669f, -0.02603474f, -0.08052790f, 
    -0.17083043f, 0.14562991f, -0.08148152f, 0.01339899f, -0.05778457f, 0.11438917f, 0.03720289f, 0.11992380f, 
    -0.25140658f, 0.00650564f, 0.12710153f, -0.01279857f, 0.06300664f, -0.06080166f, 0.07543620f, -0.01337676f, 
    0.16114324f, 0.20614004f, 0.08025508f, 0.07736593f, -0.76272744f, -0.07963332f, 0.06230623f, 0.34756345f, 
    0.05380213f, 0.06501333f, -0.13256930f, 0.15412460f, 0.03543263f, 0.07236714f, 0.18693340f, 0.28103796f, 
    0.52517819f, 0.08479080f, -0.37908813f, -0.40365869f, 0.12856032f, -0.05293375f, 0.09340885f, 0.00647403f, 
    0.34354636f, 0.02156048f, 0.20739116f, 0.21683083f, 0.32909197f, -0.04304802f, -0.13562605f, -0.18104219f, 
    -0.19009821f, -0.02770102f, 0.19918483f, -0.08480848f, -0.02950672f, 0.02024654f, -0.02353035f, 0.02254595f, 
    -0.43459943f, -0.06192099f, 0.12359962f, 0.01527486f, -0.17282464f, -0.00512554f, -0.02405655f, 0.06477970f, 
    0.02140363f, -0.16226289f, 0.04553818f, -0.02544941f, 0.14543439f, -0.06518656f, -0.08642390f, -0.08463753f, 
    -0.21340886f, -0.12643260f, -0.04421221f, -0.07899696f, 0.14105879f, 0.01646852f, 0.17277668f, 0.08583491f, 
    0.08390181f, 0.00646612f, -0.00981053f, 0.09367155f, 0.18404944f, -0.11618710f, 0.00977703f, 0.09245554f, 
    0.12236439f, 0.02136659f, 0.17543748f, 0.07827210f, -0.04890274f, -0.16812490f, -0.00817185f, -0.07254548f, 
    -0.11747868f, 0.04173319f, 0.02814939f, 0.16175981f, 0.05932253f, -0.03969001f, -0.05295067f, -0.08848785f, 
    -0.23250160f, -0.33239943f, -0.12918895f, 0.01067150f, -0.03008135f, 0.07441277f, -0.08177309f, 0.10964590f, 
    -0.54915875f, -0.23723382f, 0.04491672f, -0.12485136f, 0.31940171f, -0.39755085f, -0.18185949f, 0.25984031f, 
    0.23286079f, 0.19930530f, 0.29379979f, 0.21935351f, -0.13304897f, -0.14165154f, -0.03464902f, -0.07818012f, 
    -0.03408230f, 0.15660197f, 0.09030607f, 0.11006407f, 0.01403709f, -0.07541658f, 0.04305740f, 0.04687287f, 
    -0.11960891f, -0.07254420f, -0.37122580f, -0.51717812f, -0.22956844f, -0.02130460f, -0.00328411f, -0.09995295f, 
    -0.00516236f, 0.02022798f, -0.08773264f, -0.03894106f, -0.05601151f, 0.03999972f, -0.28590551f, -0.09555084f, 
    -0.58474833f, -0.36493701f, 0.02585212f, 0.19356866f, 0.01094121f, 0.27122709f, 0.12659340f, 0.03147815f, 
    -0.06412744f, 0.11547638f, 0.02138249f, 0.07944781f, -0.44113150f, 0.31725892f, 0.10730190f, 0.21369606f, 
    0.11757639f, -0.00187203f, -0.08823037f, 0.07842105f, -0.01968917f, 0.00985912f, 0.02349402f, -0.01430804f, 
    0.02662755f, -0.66214186f, -0.43760234f, -0.40756264f, -0.21209370f, -0.11742239f, -0.02670045f, -0.18880627f, 
    0.04424970f, -0.05687804f, 0.04273835f, 0.03133558f, -0.26547334f, -0.73399597f, -0.36754373f, 0.52473128f, 
    0.01116118f, 0.12963051f, 0.19501306f, 0.03570135f, -0.10429133f, -0.02265299f, -0.06105273f, 0.06002026f, 
    -0.10490046f, 0.03087166f, -0.01712915f, -0.01799732f, 0.22203684f, 0.06510778f, -0.04153261f, 0.10031399f, 
    0.01900110f, 0.05131044f, 0.20406649f, 0.24608228f, -0.61908585f, -0.67633390f, -0.43772388f, -0.14399889f, 
    0.16043350f, 0.30966547f, 0.22795698f, 0.29279676f, 0.07324041f, -0.06904005f, 0.02888337f, -0.05263245f, 
    -0.09603026f, 0.12210207f, 0.14562778f, 0.86118841f, 0.09977873f, -0.06719569f, -0.45149964f, -0.25970098f, 
    0.12050267f, -0.02108838f, 0.06172908f, 0.00463622f, 0.20208462f, -0.02350811f, -0.70481539f, 0.01199895f, 
    0.17258465f, -0.05353492f, 0.20990069f, 0.20667626f, 0.01791311f, 0.06227158f, 0.01744654f, -0.08042885f, 
    0.02497266f, 0.22538993f, -0.44111446f, 0.04187106f, -0.03849198f, 0.15604225f, 0.23522970f, 0.02179154f, 
    0.06783157f, 0.01632364f, -0.06337631f, -0.03759450f, -0.26157767f, -0.34481847f, -0.11234332f, -0.08176386f, 
    -0.15413943f, 0.09258919f, -0.22417361f, 0.21788517f, 0.06150967f, -0.07803758f, 0.02198914f, -0.03269060f, 
    -0.47852081f, -0.35825440f, 0.27071390f, -0.16449830f, 0.07381599f, -0.05730982f, -0.08109418f, 0.05983870f, 
    0.04979266f, 0.07894340f, 0.00123398f, 0.07283345f, -0.39815471f, 0.05884684f, 0.29428551f, -0.23813921f, 
    -0.19728480f, -0.19725640f, 0.10956591f, 0.15260719f, -0.00158593f, 0.04811886f, 0.04641379f, -0.09092148f, 
    -0.04070557f, -0.00263737f, 0.13141085f, -0.08363356f, -0.00346036f, -0.01468488f, -0.05134429f, -0.22235616f, 
    0.26636371f, 0.02751116f, 0.02353874f, -0.05991194f, -0.03946592f, -0.41670978f, -0.07398532f, -0.17957963f, 
    0.17880084f, 0.10153243f, 0.04904073f, -0.17459995f, -0.11008193f, -0.01871113f, 0.03936971f, 0.05316863f, 
    -0.07942484f, -0.17092760f, -0.15469483f, -0.07278779f, 0.05055399f, 0.10116990f, 0.10654176f, 0.03723885f, 
    0.12690961f, 0.17535338f, 0.18292141f, 0.07037247f, 0.04175615f, -0.26865652f, 0.25070235f, -0.21423632f, 
    0.07430883f, -0.04206400f, -0.05642452f, 0.03069960f, 0.01836626f, 0.12328779f, -0.06402518f, 0.26486224f, 
    -0.54460847f, 0.44429189f, 0.29477930f, -0.15980136f, 0.02909138f, -0.36570495f, 0.17103815f, 0.17262077f, 
    -0.05387227f, -0.08904407f, -0.00389398f, -0.07706000f, -0.15098137f, -0.23049997f, -0.04590509f, 0.09037655f, 
    0.01471673f, 0.20865704f, -0.22035502f, -0.25341579f, -0.02633976f, -0.28743583f, 0.00696033f, 0.12332346f, 
    -0.00256642f, -0.05095682f, 0.04036060f, 0.17764425f, -0.02699417f, 0.17335054f, -0.04770963f, -0.10100292f, 
    0.22056140f, 0.28290707f, 0.30188954f, 0.12419593f, -0.39978227f, 0.09370901f, -0.22644123f, 0.13576163f, 
    0.07071891f, 0.01277978f, 0.15899499f, -0.09689237f, 0.11029298f, -0.14203513f, -0.16212708f, -0.03140613f, 
    -0.05755462f, -0.32620263f, 0.04577420f, -0.03193734f, 0.27910432f, 0.05658134f, -0.07848945f, 0.20718037f, 
    0.07105769f, -0.11707775f, -0.07462946f, -0.21024852f, -1.00323021f, 0.14452545f, -0.18318881f, -0.53124011f, 
    -0.01300503f, -0.27610084f, -0.01358317f, -0.25951409f, 0.00615034f, 0.08392724f, 0.02842833f, -0.07555319f, 
    -0.01332708f, 0.02692161f, 0.39484066f, 0.24336576f, 0.12774047f, -0.12195051f, -0.01632204f, -0.17727533f, 
    -0.04811501f, -0.05337182f, 0.06269967f, -0.10494066f, -0.39706320f, -0.00618676f, 0.01855158f, 0.26174060f, 
    0.15825616f, 0.13994983f, -0.22790074f, 0.20904569f, 0.10230228f, -0.06851925f, 0.05155224f, -0.02332865f, 
    0.01782891f, -0.22502299f, 0.10449884f, -0.09471794f, -0.03668636f, 0.08412226f, 0.00871869f, 0.09639455f, 
    -0.04172141f, -0.02942351f, 0.05063087f, -0.36810496f, -0.33752143f, 0.05104307f, -0.26590440f, -0.32095376f, 
    0.16393974f, 0.16820236f, -0.18848734f, 0.14941657f, 0.01577591f, -0.22030675f, 0.08107023f, 0.03664206f, 
    -0.15817857f, -0.01199136f, -0.29548326f, 0.06324627f, 0.02208743f, -0.08170886f, 0.19787911f, -0.18371728f, 
    0.17799130f, -0.06794913f, -0.06065436f, 0.01931502f, -0.06090782f, 0.02691614f, 0.02291455f, -0.13661267f, 
    0.03936448f, 0.13221359f, -0.20815673f, -0.02207437f, 0.07214718f, -0.00314752f, 0.05002670f, 0.09530262f, 
    -0.17804337f, 0.58897913f, 0.38969266f, -0.44589147f, -0.21116337f, -0.17808633f, 0.10423894f, -0.26653352f, 
    -0.07418080f, 0.10176884f, 0.04377777f, 0.05750564f, -0.30947003f, 0.32184210f, -0.22110648f, 0.11371339f, 
    -0.18329802f, -0.24457084f, -0.12211905f, -0.22809425f, 0.09351131f, -0.01857108f, 0.09777909f, 0.22083722f, 
    0.36865216f, -0.36919522f, 0.02234490f, -0.24128559f, -0.05762123f, 0.05594952f, 0.06669126f, 0.16665772f, 
    -0.08281445f, 0.02388811f, 0.18739015f, 0.23755531f, 0.06890215f, -0.09875098f, 0.13985936f, 0.07765367f, 
    0.03280013f, -0.03919188f, -0.04946869f, -0.00056610f, 0.03554273f, 0.07696862f, 0.19901013f, 0.02665082f, 
    0.25704709f, 0.11127754f, 0.82724953f, -0.62397307f, 0.12509289f, -0.30189523f, -0.19994117f, -0.03999972f, 
    -0.05227403f, 0.14491172f, -0.00398699f, 0.08044101f, -0.40984926f, -0.02053357f, -1.02257705f, 0.27613962f, 
    0.14220281f, 0.08535077f, 0.12991129f, 0.01748622f, 0.01656065f, 0.00222175f, -0.20423196f, -0.03257479f, 
    -0.29327050f, -0.17168519f, 0.32193330f, -0.16506724f, -0.13242827f, -0.11517235f, 0.12894398f, 0.22573504f, 
    0.06198954f, 0.16899586f, 0.04455081f, -0.07585008f, 0.44974959f, -0.20933209f, 0.16425678f, -0.52429086f, 
    -0.09395425f, -0.22031610f, -0.25614807f, -0.23403876f, 0.00267910f, -0.01934482f, -0.00861799f, 0.07292981f, 
    0.17553492f, 0.02945950f, -0.16103029f, -0.08482859f, -0.05768923f, 0.19696252f, -0.16069274f, -0.08923608f, 
    -0.02014471f, -0.15419522f, -0.23021193f, 0.12514253f, -0.08894197f, 0.11361424f, -0.07605312f, 0.22928499f, 
    -0.14287072f, -0.17497568f, -0.12641779f, -0.14126875f, -0.13887884f, 0.05702328f, 0.16538990f, 0.07299141f, 
    -0.00816467f, 0.43187165f, 0.31306073f, -0.15135871f, -0.05816579f, -0.00927065f, 0.03134885f, 0.14108868f, 
    -0.11546569f, 0.12898746f, -0.08791971f, 0.13310674f, -0.41056353f, -0.00557036f, -0.19512612f, -0.13266666f, 
    -0.10065525f, 0.07756642f, 0.09328137f, -0.14714797f, -0.08633475f, 0.07973150f, -0.06214811f, -0.09233288f, 
    -0.07347406f, -0.76388508f, -0.05804070f, 0.11119632f, -0.11484997f, -0.13730723f, 0.00161390f, -0.17668718f, 
    0.08221851f, 0.22926502f, -0.03179955f, -0.16607924f, -0.01224139f, -0.13348402f, -0.11489554f, 0.26490602f, 
    0.11047160f, -0.13719201f, 0.12951584f, 0.03363881f, -0.06502293f, -0.03540212f, 0.08384492f, 0.07606885f, 
    -0.61031556f, 0.26224387f, -0.68986487f, 0.13965736f, -0.07564047f, 0.22738625f, -0.30335680f, -0.12411807f, 
    -0.09461036f, -0.05838230f, 0.08411104f, -0.27118972f, -0.20717396f, -0.49286124f, -0.36521268f, 0.09153588f, 
    0.14812492f, 0.06518099f, -0.12275114f, -0.15064584f, 0.11188722f, 0.03955189f, 0.02910105f, 0.01466441f, 
    -0.46075195f, 0.31699800f, -0.13670707f, -0.21162386f, -0.10675915f, -0.03048192f, 0.35516450f, -0.15760872f, 
    -0.10487042f, -0.18439901f, 0.13208131f, -0.01184882f, -0.80500013f, 0.40178171f, 0.28286445f, 0.16001047f, 
    0.09222698f, 0.02949478f, 0.21252015f, 0.33362940f, -0.09545923f, -0.04981882f, 0.08831309f, -0.10687266f, 
    -0.20067501f, -0.40247142f, -0.64019382f, -0.54973453f, -0.35037979f, -0.31362304f, -0.10911662f, -0.10380121f, 
    -0.12423795f, 0.14931639f, -0.05054989f, -0.01106184f, -0.44501644f, 0.11850265f, -0.07944557f, 0.43246880f, 
    0.14474164f, -0.09179050f, -0.21139058f, 0.40180308f, -0.02203456f, -0.36400712f, -0.10678963f, -0.23555410f, 
    -0.20314248f, -0.25338614f, 0.06526776f, 0.24587961f, -0.12725733f, 0.01797211f, -0.09655052f, -0.14238529f, 
    0.08161447f, -0.10232770f, -0.01766851f, 0.14718749f, -0.07864334f, 0.21340890f, 0.14095889f, -0.21447180f, 
    -0.05043842f, 0.08440057f, -0.08941848f, -0.11517338f, -0.04458056f, 0.13118903f, -0.16897415f, -0.23911908f, 
    -0.03365766f, 0.05761368f, -0.01733150f, -0.16651346f, 0.09385031f, -0.07511636f, -0.00678598f, -0.01062147f, 
    -0.22844559f, -0.09918431f, -0.53238237f, -0.46255362f, 0.32886165f, 0.07411540f, 0.38116717f, -0.17526393f, 
    -0.26376736f, 0.02522933f, 0.11588519f, 0.02441547f, -0.10853545f, 0.25771308f, 0.13393150f, 0.25265691f, 
    -0.10165185f, 0.19535473f, 0.02754707f, -0.03380467f, -0.03157363f, 0.20326978f, 0.03064257f, -0.04440396f, 
    -0.11700015f, 0.31540558f, -0.01728393f, 0.13377008f, 0.26445386f, -0.77058131f, 0.27981633f, 0.09704246f, 
    0.03475613f, 0.15171006f, 0.09215161f, 0.08731556f, 0.17489100f, -0.01511479f, -0.05204742f, 0.12760273f, 
    -0.64879489f, 0.21133038f, 0.11148718f, -0.23905107f, -0.05492029f, 0.10330345f, 0.05612345f, 0.01598280f, 
    -0.10339820f, -0.07933261f, -0.00593632f, -0.14023517f, -0.12655590f, -0.22751918f, 0.34867945f, -0.22716236f, 
    -0.38735002f, 0.11519319f, -0.29025948f, 0.12290424f, -0.10151000f, -0.05078926f, -0.07346206f, 0.13938765f, 
    0.07351027f, 0.15870151f, 0.00352790f, 0.10818478f, 0.05683567f, -0.14709903f, -0.20930390f, 0.01700115f, 
    0.05913016f, 0.00080094f, -0.06617817f, 0.08737882f, -0.34435144f, -0.32374066f, 0.71613973f, 0.36547104f, 
    -0.18510632f, -0.21496783f, -0.20329221f, 0.10834627f, 0.09323011f, 0.02287132f, 0.33324441f, 0.13776417f, 
    -0.20839748f, -0.39357978f, 0.18253994f, -0.11963869f, -0.09994861f, 0.15838291f, 0.15293773f, 0.00721869f, 
    0.10054088f, -0.07010718f, 0.11694125f, 0.22549243f, 0.20823187f, -0.17925572f, 0.19021785f, 0.26497066f, 
    0.08028027f, 0.24792874f, -0.13552433f, 0.12052498f, -0.29839590f, 0.19559455f, 0.15700324f, -0.08479503f, 
    -0.06067447f, -0.16937299f, -0.02667114f, -0.15330966f, 0.08258402f, 0.08131008f, 0.38882154f, -0.05530313f, 
    0.01207527f, -0.11888793f, -0.08267215f, -0.15636888f, -0.01555121f, 0.42338294f, -0.13789719f, 0.06298023f, 
    -0.04756844f, -0.32036728f, 0.01830601f, 0.13568154f, -0.15422787f, 0.16250339f, -0.29134390f, -0.14365943f, 
    -0.08490930f, 0.03808176f, 0.00643529f, 0.14894506f, -0.05310514f, 0.11402113f, 0.17423989f, 0.02633700f, 
    -0.20819145f, -0.29872975f, -0.57577664f, -0.46593118f, -0.19351211f, 0.21813150f, -0.10855738f, -0.17635261f, 
    0.01324700f, -0.00349828f, 0.01212993f, -0.02998037f, 0.03325755f, -0.21172662f, -0.06359468f, -0.08000308f, 
    -0.08192206f, 0.44411862f, 0.26385784f, 0.14082699f, 0.02414093f, 0.00410179f, -0.20116225f, 0.14712971f, 
    0.04094185f, -0.07252937f, 0.09320156f, -0.13447799f, -0.01720566f, 0.48751131f, -0.11770767f, 0.22842605f, 
    -0.22866587f, -0.05168266f, 0.27216330f, -0.17872176f, 0.02738475f, 0.12473147f, 0.03581593f, 0.07951465f, 
    -0.21729162f, 0.06218600f, -0.31477311f, 0.15003197f, 0.12174210f, -0.15275647f, 0.27152461f, 0.04434770f, 
    0.18794131f, 0.17697318f, -0.09490135f, -0.13240252f, 0.05269162f, -0.12715450f, 0.08803712f, 0.19635944f, 
    -0.01498555f, -0.17558971f, 0.18458919f, 0.07155894f, -0.06226072f, 0.01668609f, -0.06734933f, -0.14007451f, 
    0.00639487f, 0.11639190f, 0.12993740f, 0.09832967f, -0.01284941f, -0.37825796f, 0.19691421f, 0.07315447f, 
    -0.26793110f, 0.09065793f, 0.06260531f, 0.19342430f, -0.16260034f, 0.20652397f, -0.12819600f, -0.03628485f, 
    0.15398780f, 0.03823829f, -0.24529177f, 0.08228908f, -0.00757142f, 0.08103497f, -0.00277091f, -0.32770655f, 
    -0.64442003f, -0.17739534f, -0.44695488f, 0.31852850f, 0.16152936f, 0.19961704f, -0.00070801f, 0.03687621f, 
    0.03219101f, 0.06628817f, 0.10974713f, 0.00674980f, 0.57470906f, -0.17257260f, 0.64925718f, -0.31045809f, 
    -0.14060773f, -0.23509748f, -0.26235723f, -0.09779172f, 0.00366922f, 0.07496905f, 0.06028708f, -0.04402129f, 
    0.26781255f, 0.33103663f, 0.46241355f, -0.03771480f, -0.18800977f, 0.05534831f, -0.06576804f, -0.08087759f, 
    -0.15124527f, 0.03474151f, 0.10287447f, 0.13586490f, -0.37823102f, -0.09821388f, 0.11987656f, 0.10030268f, 
    -0.04839068f, -0.06004336f, 0.15268990f, -0.38932222f, -0.01466091f, -0.08465019f, -0.17196932f, -0.07856404f, 
    -0.50449282f, -0.75457799f, 0.27083066f, 0.09655929f, -0.00202234f, 0.03211538f, 0.02766594f, -0.02437407f, 
    0.09381523f, 0.16754523f, 0.13843033f, 0.09390830f, 0.23702005f, -0.13651595f, -0.10949401f, -0.14293420f, 
    -0.46114779f, -0.34773111f, -0.21473615f, -0.07071075f, -0.02781340f, -0.08834204f, -0.13614751f, -0.08211555f, 
    0.38331714f, -0.15905467f, -0.14163670f, 0.26580697f, -0.01045826f, 0.20712656f, -0.11761415f, 0.06298763f, 
    -0.23721792f, 0.11989257f, 0.05808010f, 0.00961224f, -0.27273163f, 0.32734850f, -0.17376906f, 0.23975369f, 
    -0.01342229f, -0.15848093f, 0.12754725f, 0.09307796f, -0.03484683f, 0.15596792f, 0.17400184f, 0.05008837f, 
    -0.00452268f, 0.05108130f, -0.24520074f, -0.04677610f, -0.11650647f, -0.03385653f, -0.02535928f, 0.08508501f, 
    -0.07749052f, 0.01617345f, -0.04517293f, -0.19852678f, -0.28583279f, 0.06050337f, 0.29910883f, 0.11032211f, 
    -0.09403884f, 0.06971206f, 0.12194148f, 0.15650772f, -0.12976803f, 0.12584332f, 0.20345905f, 0.02118859f, 
    -0.23582499f, -0.52399701f, -0.06847163f, -0.02840019f, 0.02843957f, -0.15533884f, -0.06954983f, -0.09122259f, 
    -0.05968103f, 0.13850729f, 0.10252098f, -0.06473573f, -0.13783883f, -0.19156787f, -0.31258923f, 0.06922109f, 
    0.19176532f, 0.04215415f, 0.24764064f, -0.08358999f, 0.05531047f, 0.01246083f, -0.03853193f, 0.08416571f, 
    -0.06091947f, 0.03569739f, -0.03771980f, -0.06994614f, 0.02401028f, -0.04767913f, -0.11647981f, 0.01180873f, 
    0.05938189f, 0.14645335f, 0.15787975f, 0.10208304f, 0.25892341f, -0.19742343f, 0.17441013f, -0.03165654f, 
    0.05867149f, 0.23615991f, -0.10120238f, 0.00075210f, -0.29835808f, 0.00806465f, 0.17099485f, 0.14378963f, 
    0.12987000f, 0.23630708f, 0.08118957f, 0.13061839f, 0.08061602f, -0.03340350f, 0.13096468f, 0.06735887f, 
    -0.06201074f, 0.05816693f, 0.08576661f, -0.28403834f, 0.40303043f, -0.19628085f, 0.60433400f, -0.52907270f, 
    -0.25469512f, 0.07363967f, -0.07469399f, 0.28408101f, -0.05765659f, -0.09212119f, -0.05920913f, -0.02818820f, 
    0.05369910f, -0.25213015f, -0.11386541f, 0.07310288f, 0.24276380f, 0.25528809f, -0.00305413f, -0.01019191f, 
    -0.04107820f, 0.20964020f, 0.07195286f, -0.02894348f, -0.27652240f, 0.16322765f, 0.08678240f, -0.08550674f, 
    0.19427127f, 0.14949785f, 0.10073610f, -0.07961857f, 0.06676048f, -0.13433436f, 0.14246003f, 0.02894194f, 
    -0.16487439f, 0.12873033f, -0.21084155f, 0.16997218f, -0.08051208f, -0.02660824f, -0.04276967f, 0.02500386f, 
    -0.34175044f, 0.15502103f, 0.08905011f, -0.16231778f, -0.32574710f, 0.13193239f, 0.26390022f, -0.06795514f, 
    0.13801622f, 0.05071669f, -0.08870644f, -0.01427957f, -0.12626621f, -0.07840416f, -0.17982742f, 0.13710888f, 
    0.05728678f, 0.17172837f, 0.03270758f, -0.10152895f, 0.22607705f, -0.20947376f, 0.17677845f, 0.01138508f, 
    -0.09475550f, -0.05569766f, -0.21596767f, -0.06378692f, -0.26748550f, 0.19290257f, 0.33356169f, 0.12830473f, 
    -0.06884471f, 0.00483170f, 0.16542356f, 0.02353057f, -0.25493282f, -0.08605942f, -0.23382345f, 0.01440008f, 
    -0.05179498f, -0.33669490f, 0.23342374f, -0.00401818f, 0.02134305f, -0.16279876f, 0.00604363f, -0.21345414f, 
    -0.00534551f, 0.15101621f, -0.08812166f, 0.12095627f, 0.67405647f, -0.52129245f, 0.46645212f, -0.52658814f, 
    0.08990311f, -0.06159343f, 0.16798954f, -0.12231515f, 0.19964416f, -0.03633789f, 0.12075894f, -0.07573313f, 
    -0.26458856f, 0.29405627f, -0.01496631f, 0.27976149f, 0.10193728f, -0.10052723f, 0.12825574f, 0.02258073f, 
    0.08437340f, 0.15489185f, 0.25703564f, 0.15716474f, 0.11948622f, -0.01113093f, -0.08330977f, 0.13179769f, 
    -0.01753785f, 0.03856315f, -0.08437311f, 0.01714798f, 0.02138568f, -0.02095916f, 0.11725338f, -0.00026038f, 
    -0.70583588f, -0.69211823f, 0.13719498f, 0.36744532f, -0.13185398f, 0.15747441f, 0.01798489f, 0.32406113f, 
    -0.22846493f, 0.01028755f, -0.09997937f, -0.12551099f, 0.55227131f, -0.28252295f, 0.62480801f, 0.14060234f, 
    0.04770488f, -0.08970268f, -0.14115018f, 0.14701673f, -0.16053562f, -0.03874608f, -0.08191168f, -0.08232918f, 
    -0.17983630f, -0.52950048f, -0.08060832f, 0.02083956f, -0.24494928f, -0.20980799f, -0.34469232f, -0.17336510f, 
    0.06311728f, -0.06747366f, -0.04919161f, 0.05002174f, -0.31216821f, 0.22094864f, -0.24489559f, -0.46792641f, 
    0.03998445f, 0.11796856f, -0.06733210f, -0.20688030f, -0.01664905f, -0.01259081f, 0.03400073f, -0.06298742f, 
    -0.10894821f, 0.22214495f, 0.29696691f, 0.07648934f, -0.04820868f, 0.16213945f, 0.20160265f, -0.24943408f, 
    0.14082158f, 0.03492865f, -0.33044344f, 0.00093816f, -0.52065873f, -0.37614295f, -0.09806553f, -0.39658785f, 
    -0.23845017f, -0.27871788f, 0.08846617f, -0.00783343f, -0.13092011f, 0.07283070f, 0.00691477f, 0.11818194f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.24175204f, 0.03760807f, 0.15094292f, -0.09591299f, -0.04460309f, 0.10291235f, 0.04343497f, -0.16117255f, 
    0.07958026f, 0.02347339f, 0.03059123f, -0.03161075f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
