#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.00219101f, 0.82305396f, 0.20170023f, 0.28310493f, 0.65333247f, -0.75094610f, -0.97310728f, -0.49794531f, 
    0.15244085f, -0.08724617f, -0.49400878f, -0.28403497f, -0.45607275f, -0.15891138f, 0.02306393f, 0.27772066f, 
    0.14805430f, 0.05612117f, -0.13047217f, -0.13981792f, 0.00955989f, -0.10557222f, -0.31333894f, 0.25903422f, 
    0.31422311f, 1.47461927f, -0.80942768f, -0.29192990f, -0.35471541f, -0.90141052f, 0.71581483f, 0.43173939f, 
    0.54482996f, -0.22885312f, -0.24562947f, -0.00162123f, -0.03530814f, 0.22470693f, -0.46445766f, -0.27379644f, 
    -0.17584552f, 0.05413429f, 0.24471724f, -0.07065174f, 0.02032980f, -0.12689336f, 0.17159566f, -0.02885479f, 
    0.08075768f, 0.00417273f, 0.23666209f, 0.37103489f, 0.94892454f, 0.58790064f, 0.87338966f, 0.08661810f, 
    -0.66411018f, -0.59873521f, -0.38780615f, -0.19323497f, 0.10306960f, -0.13331018f, 0.04655463f, 0.15141918f, 
    0.24850526f, -0.47634190f, -0.47899356f, 0.23820484f, 0.07535021f, 0.19814835f, -0.02783018f, 0.27798697f, 
    0.26529041f, -0.31149974f, -0.41596624f, 0.40453553f, 0.10008957f, -0.67671764f, 0.92071092f, -0.68938833f, 
    -0.55245435f, -0.33380356f, -0.69361323f, 0.10531938f, 0.60742390f, -0.17866711f, 0.26285207f, -0.31800601f, 
    -0.28666741f, 0.25246716f, -0.25541699f, 0.30091810f, 0.25114319f, 0.17306778f, -0.01324285f, -0.06194448f, 
    -0.10842594f, -0.15825284f, -0.22253405f, -0.33267167f, 0.88246977f, -0.40378234f, -0.93500334f, -1.11667800f, 
    -1.08023381f, 0.30130085f, -0.16646625f, -0.02456727f, -0.10718035f, 0.33817077f, 0.28256536f, 0.42263901f, 
    0.40305308f, 0.02552379f, -0.13351409f, 0.25022358f, 0.22828600f, -0.09966311f, -0.10336611f, -0.20798983f, 
    0.18344425f, -0.29678828f, -0.24552067f, 0.03448258f, 0.20862606f, 0.89023411f, 0.35371065f, -0.62807322f, 
    -0.71744615f, -0.47959661f, 0.12346682f, 0.22224607f, 0.09972625f, 0.47317183f, 0.10051321f, 0.41654101f, 
    -0.37108111f, 0.30972642f, -0.20333020f, 0.13710503f, -0.14790674f, -0.32118878f, -0.39271051f, 0.06815736f, 
    0.45903888f, 0.32241696f, -0.22893658f, 0.14753294f, 0.14415684f, 0.10655008f, -0.24221720f, -0.39361671f, 
    -0.96024668f, -0.96916926f, -0.68424714f, 0.12259629f, -0.24084795f, 0.19634396f, -0.03192761f, 0.11310973f, 
    0.43559584f, -0.13427292f, -0.00841540f, 0.11796002f, 0.18692718f, -0.55764711f, -0.34981334f, 0.02453983f, 
    -0.12657109f, -0.74319679f, -0.20854498f, -0.32935932f, 0.48221275f, -0.23090914f, 0.45054108f, -0.15521628f, 
    -0.76967716f, 0.07685068f, -0.06444548f, 0.03331905f, -0.06029583f, -0.70298839f, -0.92724741f, -0.91857851f, 
    -0.80710721f, 0.30082715f, -0.01472747f, -0.10642463f, 0.23352194f, -0.06731565f, 0.13945079f, 0.31349033f, 
    0.13435820f, 0.21641634f, 0.22505747f, -0.41222462f, -0.24625574f, -0.19105285f, 0.14810485f, 0.17493622f, 
    -1.45385945f, -0.03361275f, -0.67269337f, -1.26412141f, -0.44454205f, 0.63366598f, 0.53249258f, -0.32914776f, 
    -0.28179210f, 0.39589506f, -0.21562512f, -0.36519885f, -0.56617349f, -0.38317949f, -0.13569309f, 0.14104263f, 
    -0.08319587f, -0.13783617f, -0.01002326f, -0.31212971f, -0.02422196f, -0.03755712f, -0.25751954f, -0.14763206f, 
    -0.31622660f, -0.85376745f, -1.03716445f, -0.30008444f, 0.25150555f, -0.25927773f, -0.45606723f, -0.20198929f, 
    -0.81592882f, -0.98798686f, -0.25342286f, -0.19132705f, 0.08060213f, -0.12979732f, -0.54441708f, -0.60280770f, 
    -0.27203479f, 0.02893370f, -0.13907179f, -0.08235758f, -0.00738854f, -0.12897418f, -0.29698318f, -0.14272992f, 
    -0.04554522f, -0.11032147f, 0.08988036f, -0.95532197f, -0.28989708f, -0.43245500f, 0.09796394f, 0.24036640f, 
    0.00147573f, 0.13590008f, 0.22128820f, 0.52033466f, 0.32595670f, 0.10120876f, -0.07881424f, -0.28495866f, 
    0.26883101f, -0.43653342f, 0.08420834f, -0.05276648f, -0.01895295f, -0.12631285f, -0.29846436f, 0.36793011f, 
    -0.17769670f, -0.57451832f, -0.10236512f, 0.13209656f, -0.30051756f, -0.52953994f, -0.48011979f, -0.48416406f, 
    0.49509931f, -0.08697633f, 0.42793724f, 0.33945233f, 0.11769760f, -0.19890872f, 0.42106780f, -0.19732152f, 
    -0.33145773f, 0.33533591f, -0.47017437f, 0.38355163f, 0.23895212f, -0.17012945f, -0.43789813f, 0.19377843f, 
    0.20600966f, -0.06793792f, 0.23728152f, 0.54270726f, 0.69000143f, 0.04076641f, -1.04886901f, 0.29493058f, 
    0.72726464f, -0.25262976f, 0.50304639f, -0.55963349f, -0.61191219f, -0.44123709f, 0.33015767f, 0.39868483f, 
    0.34225869f, -0.13469143f, -0.09704755f, -0.11265747f, 0.23202552f, 0.29839572f, 0.12439186f, 0.05339957f, 
    -0.22732341f, -0.34867549f, 0.24697839f, -0.06961509f, -0.27139780f, 0.41026592f, -0.67965275f, -0.23175858f, 
    0.35181963f, 0.24385984f, -0.22775675f, -0.12326956f, 0.07230903f, -0.20022474f, -0.30730122f, 0.12706201f, 
    0.16015255f, 0.06077549f, -0.17360635f, -0.06107401f, 0.21377957f, -0.07475358f, -0.20739836f, -0.34886044f, 
    0.46399105f, 0.11628961f, 0.34831548f, 0.48661718f, 0.40702799f, 0.50036865f, -0.58437812f, -0.77767092f, 
    0.08866802f, 0.76330048f, 0.30131131f, 0.82691497f, 0.23656549f, 0.30570436f, 0.56971037f, 0.68768734f, 
    0.23420227f, -0.14216903f, -0.09530745f, 0.37256786f, 0.09821318f, -0.29772300f, -0.00113667f, -0.18293019f, 
    -0.30828002f, -0.16719073f, 0.01728889f, -0.22426258f, 0.05837747f, 0.24976189f, -0.19440743f, 0.41290370f, 
    0.42312023f, 0.19096567f, 0.53964216f, 0.53468949f, 0.46106467f, 0.11838084f, 0.05993797f, 0.12529229f, 
    0.21305737f, 0.22211719f, 0.36162028f, -0.16791326f, -0.26117477f, 0.08486015f, 0.23879266f, 0.28893280f, 
    -0.05772511f, -0.08572182f, -0.28664038f, -0.04809446f, -0.14520703f, 0.27425510f, -0.05277990f, -0.02579902f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.05256134f, 0.50457019f, 0.31720012f, 0.47258922f, 0.76737154f, 0.45947888f, 0.37735891f, -0.10086393f, 
    -0.05147472f, 0.12265740f, 0.01720278f, 0.07670862f, -0.05783069f, 0.39713648f, 0.29487041f, 0.05481707f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.05429143f, 0.11901928f, 0.11410489f, -0.32634655f, 0.19548500f, -0.23084746f, -0.16199990f, -0.11193199f, 
    -0.13294701f, -0.04104970f, 0.08792140f, 0.02683504f, 0.70547962f, -0.01037752f, 0.19397682f, -0.06176128f, 
    -0.19215290f, 0.17402673f, -0.17097950f, -0.00589949f, 0.14875095f, 0.06733932f, 0.18696345f, 0.07649746f, 
    0.44425794f, 0.53292793f, 0.17699870f, -0.42624402f, 0.03130397f, -0.09783112f, -0.08433870f, -0.12353022f, 
    -0.17027166f, -0.04583227f, 0.05682983f, -0.09610631f, -0.07706883f, 0.01449924f, 0.15495917f, -0.13840094f, 
    0.05995126f, -0.12126753f, -0.13833307f, 0.17500830f, 0.16105339f, -0.03448747f, -0.01131023f, 0.12843430f, 
    -0.16438377f, -0.20383412f, 0.23550749f, -0.21987532f, 0.11419220f, 0.21434206f, 0.13485219f, 0.04218891f, 
    -0.08126088f, -0.04014439f, 0.12315624f, 0.14131045f, -0.05440663f, -0.15109414f, 0.37128246f, -0.23798592f, 
    0.03745439f, 0.13752341f, 0.22044937f, 0.02677568f, 0.11474213f, 0.26689664f, 0.16172893f, 0.01499770f, 
    -0.35484385f, -0.29458418f, 0.10726158f, -0.27657369f, 0.15607341f, 0.31240028f, 0.28734052f, 0.21260574f, 
    0.14057864f, 0.07833509f, 0.09725586f, 0.00971267f, -0.10969765f, -0.03191117f, 0.05161455f, -0.28233409f, 
    -0.15551421f, -0.06781150f, 0.19332296f, -0.19518717f, -0.07370048f, -0.06198714f, -0.03392941f, 0.05517339f, 
    0.14839828f, 0.11515843f, 0.03354660f, 0.02380558f, -0.00239415f, 0.22504200f, 0.01236264f, 0.02390068f, 
    0.00496124f, 0.08825281f, -0.01414496f, -0.00387510f, 0.30003074f, 0.30217075f, -0.04639635f, -0.18559808f, 
    0.14215571f, -0.01686118f, 0.05168069f, 0.12645589f, 0.12453446f, -0.03736827f, 0.02247010f, 0.06734214f, 
    0.13014509f, -0.08975817f, -0.17914529f, 0.11999224f, -0.09392008f, -0.09396769f, -0.08680989f, -0.17090121f, 
    0.03203249f, 0.05679045f, -0.10730860f, 0.03681760f, -0.30697143f, -0.13307513f, -0.06145540f, -0.13283457f, 
    0.06323641f, 0.10216584f, -0.06365503f, -0.04569511f, -0.21806122f, 0.01747332f, -0.25479633f, -0.06323808f, 
    0.01767638f, 0.03250055f, -0.09495252f, 0.01686623f, -0.07250764f, 0.16093653f, 0.24623773f, 0.09901955f, 
    0.01117790f, 0.21948521f, -0.30319828f, 0.08796782f, -0.11888510f, -0.03686761f, -0.15078714f, 0.10696458f, 
    0.20583653f, 0.09531593f, 0.08201566f, -0.31506488f, 0.09493297f, 0.16616127f, -0.02042280f, 0.07391031f, 
    0.13594018f, 0.00355790f, 0.06043489f, 0.19057356f, -0.21577306f, -0.11122556f, -0.05958524f, -0.17876881f, 
    0.13708970f, 0.00898773f, 0.18355171f, 0.14896756f, 0.09558873f, 0.23917091f, 0.25067958f, 0.19964705f, 
    -0.02297190f, -0.09346080f, -0.03875715f, -0.04378150f, 0.08237282f, 0.09678862f, -0.04946660f, 0.19201492f, 
    0.28328374f, -0.33401945f, -0.73532110f, -0.11793859f, -0.06445078f, 0.31577855f, 0.03923113f, 0.10815071f, 
    -0.05251881f, 0.01859758f, -0.03090400f, 0.00686916f, 0.54683328f, 0.03459636f, 0.47696963f, -0.38556102f, 
    0.26721191f, -0.26742384f, 0.06358936f, 0.26938510f, -0.14864454f, 0.09474325f, 0.04840242f, 0.06525388f, 
    0.30195597f, 0.26147875f, -0.19472808f, 0.27979848f, -0.10568032f, 0.10072202f, 0.08626089f, -0.08711489f, 
    -0.13209467f, -0.08391815f, 0.00509980f, 0.00317269f, -0.04601285f, 0.11983893f, -0.16231571f, 0.15868296f, 
    -0.10595798f, -0.01941978f, 0.42204636f, -0.06678313f, 0.17523645f, 0.13700700f, -0.01913682f, -0.04342907f, 
    0.07945128f, 0.27448279f, 0.26057339f, -0.21177363f, -0.00204936f, -0.12369142f, -0.01625860f, 0.00917367f, 
    0.24551392f, 0.04259046f, -0.06664629f, -0.18614946f, 0.63267851f, 0.13229077f, 0.36519361f, -0.04168013f, 
    -0.04410454f, 0.11733141f, 0.15239458f, 0.18868509f, 0.02767970f, 0.00552793f, -0.15723938f, -0.00657204f, 
    -0.02427004f, 0.15235597f, 0.18548325f, -0.06831688f, -0.09450380f, -0.20100300f, 0.08418668f, 0.25955832f, 
    -0.07070427f, -0.03030846f, 0.08823580f, 0.13851890f, -0.19153196f, -0.18130526f, 0.00459068f, 0.18184173f, 
    -0.07745745f, -0.04896137f, -0.16659689f, -0.08597367f, 0.04285241f, 0.00825817f, -0.09082024f, 0.01253348f, 
    -0.26254112f, 0.06866018f, 0.22492042f, 0.16528676f, -0.01387963f, -0.14440961f, -0.09745074f, -0.02770975f, 
    0.10171549f, 0.22941430f, 0.12556711f, 0.10941218f, -0.14330386f, -0.24238884f, 0.17593685f, 0.22155549f, 
    -0.26039007f, -0.02168451f, -0.01670494f, -0.17145930f, 0.10695715f, 0.20617095f, 0.10486841f, 0.08039705f, 
    -0.17501925f, 0.24649240f, -0.06998269f, 0.02506744f, -0.03499054f, -0.11443438f, -0.00896153f, -0.01995349f, 
    0.05424604f, 0.10915117f, -0.02637882f, 0.07727408f, 0.05455659f, 0.35510430f, 0.08371941f, 0.01263827f, 
    -0.15996866f, -0.23558223f, 0.19571981f, 0.09953374f, -0.18953776f, -0.05802253f, -0.13066700f, -0.20152850f, 
    -0.02942188f, -0.22975489f, -0.05726473f, 0.04001695f, 0.05006738f, 0.08779762f, 0.07183738f, 0.07109930f, 
    -0.21832485f, -0.02136795f, 0.00296542f, 0.15309365f, -0.05753437f, -0.02645332f, -0.00791339f, -0.07635652f, 
    -0.02067933f, 0.18642540f, 0.00721706f, 0.43292794f, -0.18975234f, -0.17427911f, -0.11082684f, -0.02379597f, 
    -0.33195382f, 0.06429548f, -0.10559695f, 0.44857177f, 0.01912834f, -0.06721634f, 0.02581766f, -0.03278071f, 
    0.04673092f, 0.04238267f, 0.15796770f, 0.19021952f, 0.20540850f, 0.07153421f, -0.32031336f, 0.25214103f, 
    -0.04175051f, 0.10666165f, -0.04448738f, -0.01325280f, -0.06648048f, 0.13310686f, -0.06847575f, -0.03707587f, 
    0.63039756f, -0.06266235f, -0.08714965f, 0.16389267f, -0.06254903f, 0.05173368f, -0.22853033f, 0.18643445f, 
    -0.02894798f, -0.08195732f, -0.02582840f, -0.00319578f, -0.18538958f, -0.10708075f, 0.36904204f, -0.15934896f, 
    0.15200089f, -0.05402390f, 0.20192409f, 0.32072544f, -0.14178535f, 0.14258221f, 0.11527456f, -0.08984898f, 
    0.23272741f, 0.15895304f, 0.02493542f, 0.12385020f, -0.05678663f, -0.08428026f, 0.08240650f, -0.03231528f, 
    -0.01038841f, 0.01649788f, 0.12664726f, -0.05862487f, -0.17804517f, -0.08944682f, -0.10367586f, 0.02915459f, 
    -0.07144506f, -0.01066502f, 0.03370624f, -0.16987014f, 0.04740246f, -0.02251131f, 0.21280184f, 0.03605190f, 
    -0.41521412f, -0.20685379f, 0.12895493f, -0.04285669f, -0.03435002f, -0.02312244f, -0.06770539f, -0.03265185f, 
    0.12115850f, -0.09448893f, 0.07719962f, -0.11113072f, 0.09010863f, -0.08420713f, 0.07353222f, -0.21291988f, 
    0.08334673f, 0.08558885f, 0.13416870f, 0.02323578f, 0.01454721f, 0.15065327f, -0.09623366f, 0.20068587f, 
    0.06420904f, -0.10329050f, 0.06834654f, 0.13484186f, -0.02278282f, -0.28719166f, 0.04183755f, 0.11727175f, 
    -0.03744444f, 0.01101969f, -0.07789211f, 0.04136292f, -0.09719321f, 0.01835505f, 0.37389329f, 0.31106532f, 
    -0.04881147f, 0.16375110f, 0.07011009f, 0.18069787f, -0.05906225f, 0.00478349f, -0.15223326f, 0.00819508f, 
    0.01551317f, -0.13808990f, -0.10766240f, 0.25538248f, 0.18971598f, -0.05094163f, -0.07222994f, 0.04131717f, 
    -0.00474474f, 0.01901314f, 0.05359334f, 0.28873804f, -0.33346516f, -0.14432646f, 0.12887375f, 0.22676092f, 
    0.00588510f, 0.06416602f, -0.00399908f, 0.23178226f, -0.02256671f, 0.01131493f, 0.01546945f, 0.11902041f, 
    0.00403211f, -0.13503322f, -0.06089265f, -0.13880278f, 0.02011695f, -0.04400144f, -0.03104776f, -0.03988467f, 
    0.11669274f, -0.09981015f, -0.02495362f, -0.13807282f, 0.23616751f, 0.10127687f, 0.05080019f, -0.19769865f, 
    -0.15382116f, -0.14411494f, 0.04913048f, 0.05424180f, -0.10513046f, -0.07725047f, -0.05765975f, -0.10663439f, 
    0.15813215f, 0.10926514f, 0.06850398f, 0.08082410f, 0.10677363f, 0.11592777f, -0.07412652f, 0.18860111f, 
    -0.03680715f, 0.09621971f, 0.23111749f, 0.12174975f, 0.10317662f, -0.00653106f, 0.03739472f, -0.03162970f, 
    0.02790897f, 0.02989404f, 0.03941507f, 0.15006033f, -0.06343919f, -0.11688167f, -0.06285304f, 0.02352059f, 
    0.42164361f, 0.18695128f, -0.01495473f, -0.05792958f, 0.05007103f, -0.11822585f, 0.02942636f, -0.07873328f, 
    -0.19502874f, -0.04472786f, -0.20084327f, -0.10573195f, 0.24585150f, 0.20563345f, 0.01523292f, 0.02799612f, 
    -0.07192387f, 0.08564260f, 0.11569496f, -0.08407860f, 0.06176179f, 0.16349301f, 0.00925814f, 0.05076737f, 
    0.29564148f, 0.07748188f, 0.48195055f, -0.06551530f, 0.08704964f, -0.13743789f, -0.18080825f, 0.04778424f, 
    -0.24244358f, 0.02521065f, -0.07176357f, -0.04667104f, -0.42608443f, 0.70566106f, 0.01164933f, -0.04708284f, 
    -0.28923604f, 0.06401303f, 0.22049081f, 0.12723748f, 0.03195076f, 0.12475208f, 0.05533735f, 0.04392666f, 
    -0.06478476f, 0.61003315f, 0.19213232f, -0.37989095f, 0.00852420f, -0.10450036f, -0.17795187f, -0.06066281f, 
    -0.00656475f, -0.18417837f, -0.04565578f, 0.01164378f, -0.21847263f, 0.01339215f, -0.06027111f, 0.05460047f, 
    -0.10573478f, 0.06215956f, -0.13010962f, 0.01153408f, 0.10316087f, 0.15075703f, 0.11633350f, 0.35272545f, 
    -0.25481415f, 0.09506932f, 0.03202800f, 0.13982737f, -0.04320903f, 0.17296383f, 0.13271213f, -0.12423044f, 
    0.01133437f, 0.13312651f, 0.07268734f, 0.17731726f, -0.33003169f, -0.11343577f, -0.08275984f, -0.13958588f, 
    0.06813124f, 0.08703392f, 0.19337235f, -0.07444561f, -0.11297657f, 0.04719687f, -0.16041848f, -0.15099975f, 
    0.04733571f, 0.21715257f, 0.12525670f, 0.16427815f, -0.03837896f, 0.01917085f, 0.02897317f, -0.08871255f, 
    -0.02817666f, 0.12790281f, -0.01244143f, 0.00112490f, 0.00223903f, -0.12132828f, -0.15324886f, 0.02006434f, 
    0.06315266f, 0.10594589f, -0.00814754f, 0.16041377f, -0.08355387f, 0.04523731f, 0.04536369f, -0.06649018f, 
    0.68956083f, 0.00022098f, 0.20685083f, 0.43469730f, 0.12399240f, 0.14160113f, 0.00145690f, 0.11704282f, 
    0.09622610f, 0.09267925f, 0.17882282f, 0.40255505f, 0.12607354f, 0.13238838f, -0.21921447f, 0.08774765f, 
    0.10810157f, 0.06670615f, -0.13418432f, 0.11297091f, -0.24332538f, -0.04693693f, -0.13453856f, -0.10905976f, 
    0.10128940f, 0.20567162f, -0.27394688f, 0.14007437f, 0.11544006f, -0.02592315f, 0.05593912f, -0.23023665f, 
    0.18709888f, 0.30851895f, 0.17224503f, 0.16695996f, 0.03197691f, 0.33736488f, 0.06208815f, -0.05352174f, 
    -0.05068987f, 0.12700310f, -0.14936164f, 0.02671534f, -0.31889886f, -0.31237578f, -0.41551563f, -0.35441130f, 
    0.48105186f, 0.56798309f, -0.12695797f, 0.62062043f, 0.03173200f, 0.16461129f, 0.28565526f, 0.24025515f, 
    -0.02542782f, 0.07686882f, 0.22979204f, 0.03003143f, -0.09868267f, 0.21017520f, -0.10000859f, 0.02754035f, 
    -0.01042458f, -0.26070926f, 0.08906834f, -0.12864640f, -0.60696471f, -0.45511100f, -0.35375321f, -0.76889384f, 
    0.33772707f, 0.14165351f, 0.03193847f, -0.20225371f, 0.03555578f, -0.14354742f, 0.17236748f, -0.22702564f, 
    -0.23297197f, 0.08775373f, -0.00929570f, -0.03515284f, -0.00116203f, 0.02229870f, -0.16335207f, 0.17860575f, 
    -0.18442516f, -0.10482410f, 0.08175460f, 0.28698027f, -0.17350683f, -0.05293319f, -0.02650219f, -0.05867779f, 
    0.18536036f, 0.54323822f, -0.23939364f, 0.06823488f, 0.11868815f, 0.11823146f, 0.18078423f, 0.10019147f, 
    -0.38003108f, -0.07487385f, -0.05404601f, -0.26724499f, -0.03346116f, -0.60333121f, -0.15016358f, 0.47378400f, 
    0.21229908f, -0.18801440f, 0.12803468f, 0.25206417f, -0.12202987f, -0.13842548f, -0.01258564f, 0.21510403f, 
    -0.04327681f, -0.06646214f, -0.10484897f, 0.25213572f, 0.15803607f, 0.07871865f, 0.17227477f, -0.12472712f, 
    -0.33266157f, 0.01248614f, -0.21619433f, 0.22071788f, -0.16003837f, 0.43442696f, 0.04724235f, 0.00382281f, 
    -0.07872283f, 0.18792698f, -0.02310628f, -0.06777268f, 0.07325644f, -0.07335515f, 0.10069971f, -0.04997238f, 
    0.18410735f, -0.32266518f, -0.22086342f, 0.16257459f, -0.26218542f, 0.05090386f, -0.15811473f, 0.08396898f, 
    0.12234458f, 0.02147527f, 0.01607428f, 0.06647994f, -0.33005986f, -0.39152610f, -0.17010380f, 0.19756129f, 
    0.06065943f, -0.07955457f, -0.12475981f, -0.00095046f, -0.15976843f, -0.29223374f, -0.06202810f, -0.16224663f, 
    0.42048597f, 0.13629845f, 0.06482762f, 0.23258938f, 0.06063581f, -0.08635303f, -0.08090850f, 0.11823528f, 
    0.16522214f, -0.06258548f, -0.00746457f, 0.09810345f, 0.48288399f, 0.31791222f, 0.06426018f, 0.13553391f, 
    0.07650816f, 0.02393493f, 0.09504700f, 0.23486955f, -0.10857556f, 0.06355051f, -0.10683650f, -0.08469409f, 
    0.13988754f, 0.00333378f, -0.03990367f, 0.21868944f, 0.06623077f, 0.06331289f, -0.10329098f, 0.16968848f, 
    0.03417688f, 0.02530421f, 0.09909111f, 0.33745930f, 0.36753854f, 0.02169669f, 0.11893953f, 0.11348426f, 
    -0.11812860f, 0.01323731f, 0.16614909f, 0.12170826f, -0.18814930f, -0.10891852f, 0.12377757f, 0.16264915f, 
    -0.11648058f, 0.31292790f, -0.22505514f, 0.10410446f, -0.02255394f, -0.09887362f, 0.32059273f, -0.20032395f, 
    0.35374650f, 0.10806736f, 0.23128854f, -0.05347742f, 0.32116589f, 0.06385820f, -0.07161803f, 0.15508100f, 
    -0.00339463f, 0.02118006f, 0.08054299f, -0.06686567f, -0.08567100f, 0.01325631f, -0.06590327f, -0.32348794f, 
    0.07542454f, 0.21606530f, 0.10840160f, 0.10730639f, 0.04922650f, -0.23773275f, -0.07650205f, 0.09598692f, 
    0.10261890f, 0.16832161f, 0.15055983f, 0.08354715f, -0.11906216f, -0.03783283f, 0.01974957f, -0.18061623f, 
    -0.21176772f, -0.04544862f, -0.01602627f, 0.04821883f, -0.57118481f, -0.44106799f, -0.26552051f, -0.43010774f, 
    0.18865851f, 0.15885237f, -0.26484764f, -0.08184553f, -0.06438731f, 0.14735247f, 0.08030398f, -0.25258675f, 
    0.21786866f, -0.14101754f, -0.14052115f, -0.10785348f, -0.18939228f, 0.09982491f, -0.03625323f, 0.18797275f, 
    0.09689055f, 0.17873414f, 0.16155280f, -0.19127439f, -0.28842813f, 0.05584622f, 0.00291930f, 0.09977344f, 
    -0.19725972f, -0.14998692f, 0.18151325f, 0.31501579f, -0.06142391f, 0.09238322f, 0.00107854f, 0.21033570f, 
    0.02914017f, -0.10610304f, 0.05391993f, -0.16951863f, -0.48790482f, 0.65213364f, 0.31199452f, 0.07602975f, 
    0.12695506f, -0.10280281f, -0.06253716f, -0.07975499f, -0.06605171f, -0.07013459f, -0.08691068f, -0.10544735f, 
    -0.57224244f, -0.06553346f, -0.09053677f, 0.32393506f, -0.02198759f, -0.09078209f, 0.05199722f, 0.02138981f, 
    -0.01063272f, 0.00179377f, -0.13605709f, 0.06713617f, 0.19668286f, -0.16068238f, -0.14604589f, 0.26124215f, 
    0.23895961f, 0.17491879f, 0.22843383f, 0.17883575f, 0.02079697f, 0.09940876f, -0.06399759f, -0.13333072f, 
    0.32971203f, 0.52904767f, -0.11057521f, 0.32292292f, 0.13037281f, 0.03794456f, 0.05245009f, 0.05408145f, 
    0.14663792f, -0.06956633f, -0.13023159f, -0.03507826f, 0.01995665f, 0.50314265f, 0.01428801f, 0.52192295f, 
    -0.07854590f, 0.23056598f, -0.26876873f, 0.09819621f, 0.17478588f, -0.07199802f, -0.03184808f, 0.17133066f, 
    -0.03143561f, 0.39643210f, 0.20192426f, 0.22029120f, -0.11686489f, -0.05614955f, 0.12237826f, 0.02963138f, 
    0.06095592f, -0.06050199f, 0.01157932f, -0.03537050f, -0.30776450f, -0.01095010f, 0.05887816f, 0.13973688f, 
    0.00381820f, 0.01567679f, -0.15480585f, 0.00132589f, -0.06416114f, 0.10361997f, -0.04310516f, -0.05938999f, 
    -0.57936549f, 0.06389214f, 0.47993806f, 0.21427420f, -0.04256007f, -0.24591029f, -0.04794605f, 0.00223098f, 
    -0.09634575f, -0.16032073f, -0.09383621f, -0.07313538f, -0.37644121f, -0.23833983f, 0.24403276f, 0.14822781f, 
    0.00640418f, 0.21869050f, -0.06203760f, -0.02096904f, 0.03943286f, 0.09273625f, 0.06276217f, -0.00031561f, 
    -0.13213030f, 0.17204893f, -0.03630629f, 0.12418392f, -0.05564092f, 0.01069567f, -0.02890381f, 0.32622305f, 
    0.04952492f, -0.01053056f, 0.18895657f, 0.00291334f, -0.09583738f, 0.21077845f, 0.18725997f, 0.22354259f, 
    -0.21143378f, 0.02125495f, 0.04645769f, 0.02415415f, 0.11761343f, -0.10530166f, 0.18041609f, 0.04935515f, 
    -0.41932467f, -0.36382341f, 0.10743940f, -0.24450494f, -0.07081514f, -0.03402433f, -0.24818057f, -0.00489361f, 
    0.13289534f, -0.24824442f, 0.23438078f, -0.21278116f, 0.05139282f, -0.09975576f, 0.05792294f, -0.06128499f, 
    -0.08189121f, 0.20924577f, -0.06118964f, 0.19344349f, 0.31313547f, -0.21110173f, -0.19622582f, 0.02350540f, 
    -0.24468496f, 0.07498163f, 0.02471829f, 0.10238497f, 0.07738613f, -0.03001172f, -0.10837574f, 0.10422888f, 
    0.10264292f, 0.06076879f, -0.06017651f, 0.17569309f, -0.23729242f, -0.12204459f, -0.28776819f, -0.16869369f, 
    0.07622234f, -0.09945095f, -0.16547790f, -0.02983190f, 0.10890738f, -0.06392010f, 0.03590437f, 0.00455048f, 
    -0.03995783f, -0.00623484f, -0.02380240f, -0.07033404f, -0.05809323f, 0.00933215f, -0.06489448f, -0.02517379f, 
    -0.01656202f, -0.03332491f, -0.01223186f, -0.00423837f, 0.02029745f, -0.00352840f, 0.02452436f, -0.07219481f, 
    -0.01727566f, -0.04601188f, -0.03435143f, 0.02105609f, -0.05407875f, -0.02097480f, 0.02208742f, -0.01007553f, 
    -0.05060501f, -0.07111375f, 0.04738278f, -0.06632511f, -0.02794014f, -0.03808208f, 0.05225953f, -0.03311969f, 
    0.05703147f, -0.07253183f, -0.01260014f, -0.03828815f, -0.08181500f, 0.05822600f, 0.03002760f, 0.04960060f, 
    -0.04575571f, -0.07261080f, -0.03213349f, -0.03007399f, -0.08062289f, -0.04690212f, -0.06422788f, 0.05131784f, 
    -0.01360870f, -0.03274566f, -0.07884313f, -0.02081441f, 0.05668622f, -0.01012476f, 0.01412371f, 0.05909669f, 
    -0.04412163f, -0.00269553f, 0.00721399f, 0.05208310f, -0.03631092f, -0.01530740f, 0.02500217f, 0.00909683f, 
    -0.06649228f, -0.06522936f, 0.04783409f, 0.01764919f, -0.00238676f, 0.04129148f, -0.02948442f, 0.02446177f, 
    -0.03183143f, -0.04180840f, -0.03874459f, -0.01518111f, 0.01317006f, 0.04194316f, 0.03427014f, -0.00209362f, 
    -0.03214414f, -0.07748505f, 0.02179795f, 0.03084384f, 0.05907334f, -0.01084785f, -0.00280951f, -0.05195193f, 
    0.01588670f, 0.00970880f, -0.04124722f, -0.00085703f, -0.04886001f, -0.02924602f, -0.03922810f, -0.05436561f, 
    -0.03544372f, 0.02024450f, 0.00228634f, -0.00568175f, 0.00403028f, -0.05563790f, -0.07635187f, -0.06098183f, 
    -0.04713139f, -0.03720509f, 0.02317655f, -0.03150079f, 0.06256983f, -0.03774506f, 0.04235416f, -0.00616851f, 
    -0.01044469f, -0.03657949f, 0.02167754f, -0.03716336f, -0.01020521f, 0.00348403f, 0.01211805f, -0.01168040f, 
    -0.03110160f, 0.02470940f, -0.07303450f, -0.03669433f, 0.03506403f, 0.03473737f, -0.05172519f, 0.01966217f, 
    0.02489174f, -0.02595682f, -0.04790861f, -0.07874151f, 0.01926911f, -0.01520084f, 0.04993775f, -0.01228198f, 
    0.06362630f, 0.04800969f, -0.03524996f, 0.03691651f, -0.05309027f, -0.07035811f, 0.05987568f, -0.01363790f, 
    -0.00245781f, -0.03077700f, -0.00942542f, -0.04918168f, -0.02721940f, -0.00262993f, -0.06344280f, -0.04315810f, 
    -0.00288752f, 0.02851099f, 0.00953018f, -0.07095740f, 0.03251221f, 0.05997254f, -0.00530538f, -0.06135788f, 
    0.01857724f, 0.00035490f, -0.07638209f, 0.02188297f, -0.06747282f, 0.05505259f, -0.03609079f, 0.05431659f, 
    0.02044892f, 0.02545312f, 0.02436243f, -0.00391537f, -0.01427384f, -0.05446686f, -0.00273447f, -0.03931847f, 
    0.01751860f, 0.00364392f, -0.01849171f, -0.05339210f, -0.06749494f, -0.05430187f, 0.02339512f, 0.03172873f, 
    -0.03241260f, -0.07763947f, 0.03106309f, -0.04622108f, -0.05482596f, 0.04861693f, 0.03479879f, -0.05358739f, 
    -0.13393216f, 0.05407954f, -0.22908872f, -0.30786043f, 0.02380616f, 0.11971680f, -0.10415041f, 0.10570633f, 
    0.04653635f, 0.03332495f, 0.00730204f, 0.18962297f, 0.96427602f, 0.11872368f, 0.09698864f, -0.20369118f, 
    -0.17556885f, 0.09025425f, -0.12677144f, 0.02281361f, 0.16011997f, -0.02885773f, 0.28137282f, 0.07283090f, 
    0.17159617f, 0.24999198f, -0.19355206f, -0.02426272f, -0.31618717f, -0.30137777f, -0.02797193f, 0.07890125f, 
    -0.08221766f, -0.01729342f, -0.02213113f, -0.31838343f, 0.14256378f, 0.12803681f, 0.10278566f, 0.10814933f, 
    0.28680936f, -0.08530609f, -0.12039928f, 0.18825717f, 0.20275553f, 0.03098573f, -0.09617662f, -0.12183388f, 
    0.16259706f, -0.09124602f, -0.10319866f, -0.08149705f, 0.05098342f, 0.13519955f, 0.08923591f, 0.08288322f, 
    0.20516814f, 0.07470576f, 0.11254112f, 0.06984533f, 0.01326309f, 0.03836316f, 0.06380444f, 0.15264329f, 
    -0.10748275f, 0.07396059f, 0.18552122f, 0.18297741f, 0.43693715f, 0.17547141f, 0.12822410f, 0.18990636f, 
    -0.37764028f, 0.11482593f, 0.03759468f, -0.33078417f, 0.03254093f, 0.18511803f, 0.24362180f, 0.10938608f, 
    0.16600458f, 0.06584018f, -0.00814018f, 0.06971599f, -0.20784014f, -0.12094891f, -0.04251657f, -0.35605708f, 
    0.08381927f, -0.04121082f, 0.03896902f, -0.32647574f, -0.02276202f, -0.03749642f, 0.04951084f, 0.16277839f, 
    -0.31389284f, 0.30190289f, 0.49898255f, -0.07036325f, 0.04207420f, -0.03893638f, -0.03973041f, 0.22046418f, 
    0.02569990f, -0.03082650f, -0.12096854f, -0.03118943f, 0.18822846f, 0.10472441f, 0.20678484f, 0.02177102f, 
    0.07276147f, 0.12526408f, 0.01170007f, 0.00263020f, 0.11173015f, -0.13144228f, 0.01611677f, 0.08983582f, 
    -0.14719962f, -0.13755029f, -0.20826636f, 0.09449214f, -0.23809144f, -0.10964444f, -0.14794423f, 0.08370063f, 
    -0.28640664f, -0.08264346f, -0.02367637f, 0.06190633f, -0.46604022f, -0.21042867f, -0.14002380f, -0.13368697f, 
    -0.12216494f, 0.14359622f, -0.09031800f, -0.08613919f, 0.22393593f, 0.16221370f, 0.08421399f, -0.00310215f, 
    -0.23694390f, -0.00450515f, -0.14811057f, -0.05701298f, -0.27800509f, 0.01989452f, 0.23900123f, 0.06678272f, 
    -0.00938927f, -0.07275463f, -0.04673764f, 0.05444142f, -0.03352698f, 0.11583897f, -0.10912758f, 0.08855828f, 
    0.19219638f, 0.18827437f, 0.30969387f, -0.12550171f, 0.10111690f, 0.01007673f, 0.02754782f, 0.33661747f, 
    -0.18995127f, -0.23446512f, -0.12302563f, 0.05766297f, -0.11984930f, -0.18073334f, -0.15105546f, -0.06308186f, 
    0.10793163f, 0.01476263f, 0.20565566f, 0.12097970f, 0.23263039f, 0.14874102f, 0.15601212f, 0.06504344f, 
    -0.16971940f, -0.19135214f, -0.17412390f, -0.16292042f, -0.00830872f, -0.11223906f, 0.02256209f, 0.01134415f, 
    0.23518340f, -0.07757500f, 0.45921537f, 0.05368080f, -0.12387758f, 0.03968459f, 0.02046356f, -0.05220870f, 
    -0.02731946f, -0.02766273f, -0.05268288f, 0.03158905f, -0.40571520f, 0.03186927f, -0.05668314f, 0.57451701f, 
    -0.12947777f, 0.08237982f, -0.05457012f, 0.10508184f, -0.02335653f, 0.25553235f, 0.02267618f, 0.08955705f, 
    -0.19692330f, 0.32627013f, 0.08942869f, 0.06138734f, 0.07430085f, -0.00130052f, -0.07660877f, -0.17439471f, 
    -0.04131465f, 0.00722158f, -0.12967017f, 0.08086199f, -0.15298592f, 0.25134993f, -0.27282649f, 0.33643928f, 
    0.33957195f, 0.23696363f, 0.32778725f, 0.30677387f, -0.08590256f, 0.06590273f, -0.08114301f, 0.09409867f, 
    -0.07299407f, -0.15114646f, -0.51022804f, 0.42452225f, 0.01889428f, 0.19254868f, 0.10304789f, 0.13743232f, 
    -0.16780241f, -0.11092511f, 0.02178471f, -0.10781186f, 0.24256380f, 0.04496798f, -0.02697205f, 0.43801951f, 
    -0.14771451f, 0.12700893f, -0.02006909f, 0.14744708f, -0.04590559f, -0.12478486f, 0.18444520f, -0.03053136f, 
    0.04662419f, -0.14523657f, -0.28175357f, 0.38878164f, 0.00474665f, 0.07987645f, -0.12258130f, 0.08200340f, 
    0.11413379f, 0.05688933f, -0.06551413f, 0.04099721f, 0.12655576f, 0.20596547f, -0.45547980f, 0.21723421f, 
    0.15746431f, -0.05351038f, 0.11955088f, -0.18208544f, 0.05905712f, 0.01236677f, 0.03516924f, 0.05181843f, 
    0.52337205f, 0.08842149f, -0.29728189f, -0.11434773f, 0.09271980f, 0.02052728f, 0.20880391f, -0.02345914f, 
    -0.08198968f, -0.03270345f, 0.04227121f, 0.00283213f, 0.11258817f, 0.19272994f, -0.37735236f, 0.07767839f, 
    0.16437042f, 0.01694974f, 0.05914970f, -0.20910122f, -0.06713148f, 0.07900596f, -0.04580294f, 0.00187343f, 
    -0.31913567f, 0.35547084f, -0.23272303f, 0.10352338f, -0.06324681f, 0.00942476f, 0.13934156f, 0.11474374f, 
    -0.05395727f, 0.27883369f, 0.07483416f, -0.05354073f, -0.28943381f, 0.00915107f, 0.03965077f, 0.31403646f, 
    0.00213905f, 0.02200142f, 0.01390294f, 0.02008342f, 0.00130030f, -0.06408848f, 0.19414891f, 0.00687416f, 
    -0.06331959f, 0.02934145f, -0.22463158f, 0.46370980f, 0.03452820f, 0.08625823f, 0.20039687f, 0.01528442f, 
    -0.00571397f, 0.17901422f, -0.07027455f, -0.14062095f, -0.11480199f, 0.08527724f, 0.03602291f, -0.08404014f, 
    -0.00439597f, 0.03744314f, -0.09425747f, 0.04792176f, -0.05188796f, 0.11359336f, 0.11943954f, -0.01728370f, 
    -0.54468721f, 0.14205365f, -0.24646243f, -0.02184591f, 0.07027632f, 0.00063530f, 0.06043090f, 0.02230325f, 
    0.18496577f, 0.10665648f, 0.05863884f, 0.15097548f, -0.07421025f, 0.18215886f, -0.19751917f, 0.00081751f, 
    -0.11100253f, -0.02615097f, -0.09172765f, -0.05925637f, -0.04591569f, 0.06969016f, -0.05047471f, -0.02242355f, 
    -0.12118734f, 0.20925115f, -0.04180419f, 0.19224662f, 0.14278315f, 0.15955442f, -0.06330466f, -0.12748682f, 
    -0.00060420f, 0.06552669f, 0.03524931f, 0.08441078f, 0.99507946f, -0.20158906f, -0.16897188f, -0.18277985f, 
    -0.02886742f, -0.10188621f, -0.19039053f, 0.13500385f, 0.11592980f, 0.09940846f, 0.07079233f, -0.26470265f, 
    0.04045281f, 0.18290214f, 0.09475597f, 0.21797261f, 0.02341783f, -0.23004246f, -0.03625789f, 0.04920845f, 
    -0.10283259f, 0.08118088f, -0.02517030f, -0.01046377f, -0.10692712f, 0.10656337f, 0.29986212f, 0.02971579f, 
    0.17063707f, 0.15483703f, -0.04868909f, 0.09370901f, 0.12051119f, -0.20234674f, 0.12916751f, -0.27559707f, 
    0.12300503f, -0.45915839f, -0.39411443f, -0.04550811f, 0.00174465f, 0.11688140f, -0.17442618f, 0.07373951f, 
    0.06616601f, -0.26173213f, 0.00012262f, -0.03958554f, 0.07298350f, 0.12755358f, -0.04169631f, 0.04461840f, 
    -0.08746898f, 0.10123981f, 0.00324388f, 0.02202780f, 0.27437028f, 0.07856613f, -0.03942651f, -0.10566846f, 
    0.03991959f, 0.11697494f, 0.00632961f, 0.06727798f, -0.22609688f, 0.17485571f, 0.11594639f, 0.11136884f, 
    0.23415779f, -0.14385235f, -0.09478163f, -0.16542631f, 0.02424757f, 0.08417098f, 0.20342308f, -0.05599986f, 
    0.17507996f, 0.13756679f, 0.06882646f, 0.04484385f, 0.04636259f, 0.03222974f, 0.08893106f, 0.15874048f, 
    -0.30087733f, 0.28179786f, 0.23193835f, -0.15101813f, -0.10256709f, -0.10178857f, -0.05857291f, 0.19694345f, 
    0.07138228f, -0.02027081f, -0.20403934f, -0.23884831f, 0.09292196f, 0.02032188f, 0.36989176f, 0.10782111f, 
    -0.03118022f, 0.20449178f, -0.04870372f, 0.01980301f, 0.05634161f, 0.02852610f, 0.06419370f, 0.03731890f, 
    0.02098504f, -0.19399624f, -0.30637389f, -0.15798284f, -0.09604559f, 0.01245271f, 0.04841581f, 0.11075155f, 
    -0.00909231f, -0.14677115f, -0.02482673f, -0.13204278f, -0.04816874f, -0.03289684f, -0.05749812f, 0.05164593f, 
    -0.29697132f, 0.10271831f, -0.01166329f, 0.01105359f, -0.08462420f, 0.08855947f, 0.03994285f, -0.06135245f, 
    -0.10999289f, 0.06035726f, -0.03972920f, -0.19517310f, 0.09918513f, -0.09665155f, 0.40491679f, 0.14192481f, 
    -0.05827897f, -0.06513204f, -0.00785157f, 0.05301790f, 0.08085993f, 0.00108779f, -0.00073973f, 0.13249785f, 
    -0.04747002f, 0.09942762f, -0.03862871f, -0.08133569f, -0.10592052f, 0.02221845f, -0.01703636f, 0.27848351f, 
    0.04435354f, -0.15210319f, -0.06292154f, -0.08161643f, -0.12058093f, -0.09080220f, 0.00958771f, -0.01304217f, 
    0.17811765f, 0.05586371f, -0.07669701f, -0.04599901f, 0.17846967f, 0.19787867f, 0.10551690f, 0.15397100f, 
    -0.04342014f, -0.04085959f, -0.02906788f, -0.12094209f, -0.01483546f, 0.00151979f, 0.04076819f, 0.13698702f, 
    0.37382698f, -0.01526527f, 0.42140135f, 0.25812039f, 0.17054395f, 0.00744190f, -0.03563183f, 0.24277763f, 
    0.02390063f, -0.07860401f, -0.12581249f, -0.10061232f, -0.47492239f, -0.00885452f, 0.13753122f, -0.28580815f, 
    0.14499851f, 0.00514010f, 0.00126536f, 0.03258891f, -0.27769044f, -0.02767196f, -0.08724063f, -0.11711954f, 
    0.16838574f, -0.14752021f, 0.38549924f, -0.16056480f, 0.21513629f, -0.05039073f, 0.11227987f, 0.00856036f, 
    -0.06413446f, -0.19909064f, 0.03310233f, 0.07031661f, 0.58607662f, -0.26259896f, 0.20191522f, -0.12710361f, 
    0.00263850f, -0.25061733f, 0.07463729f, -0.04922310f, -0.08748792f, 0.30080485f, 0.12057160f, 0.15098093f, 
    -0.10674134f, 0.11660746f, 0.39479208f, -0.10429315f, -0.03707375f, 0.02439803f, -0.03446537f, 0.11321831f, 
    -0.02008960f, 0.15343098f, -0.04718917f, 0.02428282f, -0.14820109f, -0.11619692f, 0.03738656f, -0.52655870f, 
    0.01188604f, 0.25391373f, -0.20353504f, 0.06149440f, -0.08349424f, 0.13625568f, -0.02507214f, 0.11010957f, 
    0.27541533f, 0.11811921f, 0.31021020f, 0.15162252f, 0.02627836f, -0.11406066f, 0.13856713f, 0.09560929f, 
    -0.01249851f, 0.06254668f, -0.00612980f, -0.06260990f, 0.24291237f, 0.13003163f, 0.59817308f, 0.24410225f, 
    -0.09270414f, 0.19603042f, -0.01822612f, 0.17016441f, 0.01410199f, -0.01966943f, -0.09355949f, -0.11090805f, 
    -0.65679246f, 0.14957044f, -0.01008710f, -0.03392373f, -0.12177514f, 0.02159140f, -0.04755247f, -0.01739783f, 
    0.24042220f, -0.07297169f, 0.18361506f, 0.31042129f, 0.01580674f, 0.11093613f, 0.42327341f, 0.04555304f, 
    0.02010666f, 0.01647228f, 0.09138305f, 0.04286414f, -0.03228394f, 0.16014920f, 0.14339341f, -0.05890373f, 
    0.35298437f, -0.37428996f, 0.19609319f, -0.08997314f, 0.17774883f, 0.04421078f, -0.15913968f, -0.18397504f, 
    0.40820324f, -0.02522120f, 0.00180247f, 0.03281125f, 0.25453144f, -0.16674657f, 0.05595782f, -0.15466769f, 
    -0.12185190f, 0.02155397f, -0.14247771f, 0.12828822f, -0.15251964f, -0.30119881f, -0.10737816f, -0.07042886f, 
    0.36245924f, 0.02420530f, 0.05483392f, -0.47533989f, 0.20794930f, 0.11045058f, -0.22659992f, 0.15008415f, 
    -0.02789261f, 0.10759317f, 0.10813760f, -0.12613146f, 0.15325981f, -0.16139740f, 0.08670363f, -0.09618846f, 
    0.10684079f, 0.23986328f, 0.03429050f, 0.08512066f, -0.04039194f, -0.21954878f, -0.54084510f, -0.44742242f, 
    0.14907067f, -0.30838138f, 0.12886725f, 0.13231277f, -0.01879975f, -0.24201965f, 0.00194316f, 0.03392682f, 
    0.10720136f, 0.22973728f, -0.06666340f, 0.18256582f, -0.13773152f, -0.17838424f, -0.30679205f, -0.10672846f, 
    0.32550302f, 0.16421829f, -0.10804592f, 0.11022672f, 0.14518854f, 0.06852269f, 0.10540558f, -0.03223283f, 
    0.21261866f, -0.23686267f, 0.61730564f, 0.05358294f, 0.23894137f, -0.13890176f, -0.05144031f, -0.21909618f, 
    0.09638441f, 0.02623072f, 0.04572909f, -0.06758257f, -0.61302936f, -0.00245510f, 0.44626561f, 0.61519343f, 
    -0.16452633f, 0.22058894f, 0.12206133f, -0.00726825f, 0.00203285f, -0.00658144f, 0.07581881f, 0.03693367f, 
    0.02096568f, 0.01606711f, 0.16910875f, -0.42172450f, -0.09636957f, 0.01886380f, -0.10896502f, -0.19778104f, 
    0.02656724f, 0.10970364f, 0.04491443f, -0.10696147f, 0.02444595f, 0.00186217f, 0.17811765f, 0.00061508f, 
    0.17131594f, 0.06909106f, -0.01994458f, 0.18924344f, -0.16232245f, -0.03080266f, -0.04138505f, 0.08447491f, 
    -0.58737630f, -0.20369573f, 0.22450003f, 0.16960356f, -0.10344904f, -0.03942788f, 0.11908256f, 0.28348738f, 
    -0.15420170f, 0.08935006f, -0.06447238f, 0.02954288f, -0.17854024f, 0.02984366f, 0.23033197f, -0.00326313f, 
    -0.07526408f, 0.04071102f, 0.11360804f, -0.06209226f, -0.08808350f, 0.23465374f, 0.28501746f, 0.14433049f, 
    0.00667674f, -0.34847894f, -0.12247556f, 0.13741371f, 0.17123033f, 0.03589264f, 0.25094917f, 0.05870577f, 
    0.09369425f, 0.15201068f, 0.10975457f, 0.11224154f, -0.17815219f, 0.01966074f, 0.02411839f, 0.08121169f, 
    -0.04780122f, -0.05225172f, 0.21441211f, 0.04674806f, 0.04423530f, -0.00874950f, -0.00623698f, -0.04901026f, 
    0.34312198f, -0.10399487f, -0.18043715f, -0.05050884f, 0.07222195f, -0.00424356f, 0.04889276f, 0.14510463f, 
    0.06267777f, 0.05321768f, -0.13360044f, -0.10182400f, -0.26433787f, 0.12079121f, -0.07764199f, 0.15067595f, 
    0.09785850f, 0.03911508f, -0.09780987f, 0.19749838f, 0.06392372f, 0.07495853f, -0.10057513f, 0.00302754f, 
    0.09519868f, -0.20714945f, 0.12056491f, -0.15487905f, 0.04145474f, -0.12583299f, 0.06711011f, -0.14673568f, 
    -0.07092385f, 0.00309155f, -0.07278024f, -0.20670247f, -0.02598518f, -0.22718506f, 0.05321671f, 0.05995629f, 
    0.12136675f, 0.07276822f, 0.10808137f, 0.09291868f, 0.06498326f, 0.03710214f, 0.07635658f, 0.22447117f, 
    0.04104801f, 0.00583950f, 0.12379281f, 0.04250682f, -0.08557656f, 0.29998791f, 0.06435084f, -0.02187139f, 
    0.21658023f, -0.10232893f, -0.06724049f, -0.03301575f, -0.17998835f, 0.02363599f, 0.02786579f, -0.00942726f, 
    0.06578220f, 0.15354088f, 0.04050709f, 0.00361244f, 0.23452550f, 0.18303122f, 0.22377236f, 0.08647808f, 
    -0.01856618f, 0.17852540f, -0.08809034f, -0.29728392f, -0.04111359f, 0.09553687f, -0.07182946f, -0.16234520f, 
    0.12764792f, -0.00360152f, 0.12571052f, 0.00848883f, -0.04600680f, -0.04839217f, -0.04087099f, -0.23736425f, 
    -0.02013185f, -0.09353897f, 0.04063579f, -0.08974521f, 0.06512294f, 0.01401397f, 0.11258169f, 0.09977885f, 
    0.19731002f, 0.38926050f, 0.79948747f, -0.00947340f, 0.26179662f, -0.05170798f, -0.20123239f, 0.15854800f, 
    -0.03544335f, 0.05324073f, 0.02619450f, -0.02146552f, -0.04951603f, -0.13050854f, 0.14385730f, 0.28128290f, 
    -0.13822249f, 0.06604490f, -0.22535881f, 0.03946827f, 0.06916966f, 0.14750455f, -0.07007180f, -0.00639651f, 
    0.01864843f, 0.63007259f, 0.21595292f, -0.26086065f, 0.05540855f, -0.17288265f, -0.01302801f, -0.04361105f, 
    -0.11983497f, 0.04671072f, -0.03143394f, 0.05539682f, 0.17166157f, 0.26084417f, 0.09247898f, 0.26740491f, 
    0.44935143f, -0.10736852f, 0.25793451f, 0.26390165f, -0.03973342f, 0.07241864f, 0.01015185f, -0.07437547f, 
    -0.00591614f, -0.31789199f, -0.28334597f, 0.34885088f, 0.08335168f, 0.37490222f, -0.00974498f, 0.28027943f, 
    0.04692658f, -0.09330782f, -0.08871862f, 0.00136887f, -0.21571070f, -0.26750797f, 0.16592613f, 0.21153930f, 
    0.02358270f, 0.31901571f, -0.07588770f, 0.25496465f, -0.10462097f, -0.00486725f, 0.06878044f, 0.14654134f, 
    -0.06680119f, -0.15802753f, 0.00465983f, 0.10023725f, -0.00749883f, 0.23305175f, 0.14178549f, -0.00147639f, 
    0.25864258f, -0.03269444f, -0.12809199f, -0.08172017f, 0.48417798f, 0.40636876f, 0.04769401f, -0.13832784f, 
    -0.08166131f, -0.04410141f, 0.13545741f, -0.06815606f, 0.02459898f, 0.06855734f, 0.12890962f, 0.05206529f, 
    -0.30416834f, 0.55430329f, 0.00054987f, -0.02180326f, -0.02575440f, 0.07629146f, -0.08116497f, 0.01970489f, 
    -0.01914672f, -0.16654040f, -0.00920669f, 0.05202244f, 0.67336464f, 0.24657674f, 0.04864412f, -0.37971529f, 
    0.13531809f, 0.05154398f, 0.04150052f, -0.17578737f, 0.11066230f, -0.05869243f, 0.08769269f, 0.04764040f, 
    -0.19277850f, -0.00109473f, -0.33532193f, 0.11611376f, -0.01092924f, -0.00169822f, 0.06530623f, 0.10321391f, 
    0.11131686f, 0.14561315f, -0.12677994f, -0.03249044f, -0.38380393f, -0.17451110f, -0.03208893f, 0.27184638f, 
    -0.09851436f, 0.21900816f, -0.28750575f, -0.07903285f, -0.00567018f, -0.05985538f, -0.10038280f, 0.06178115f, 
    0.00424187f, 0.15829855f, -0.13818952f, 0.17986985f, -0.15752739f, -0.16918378f, 0.01664555f, 0.11981474f, 
    0.07616608f, 0.15768868f, -0.07524997f, -0.25671723f, 0.07302261f, 0.06300154f, -0.02917812f, 0.04705602f, 
    -0.01450377f, 0.19631918f, -0.08380225f, -0.20794666f, -0.00005693f, 0.13070197f, -0.10399365f, 0.10196912f, 
    -0.41905764f, -0.21827430f, -0.27498755f, 0.02603121f, 0.03710036f, 0.02991081f, 0.12889113f, 0.07389075f, 
    0.26258659f, 0.03805890f, -0.01773589f, 0.10154394f, -0.11851578f, 0.13937898f, -0.12404700f, 0.12591347f, 
    0.00238969f, -0.08821736f, -0.03092076f, 0.10088021f, -0.06950932f, 0.00007888f, 0.12960322f, 0.17154810f, 
    0.54437822f, -0.10049434f, -0.02197612f, -0.00263833f, 0.02067068f, 0.19525914f, 0.06099278f, -0.00834465f, 
    0.06335363f, -0.01562333f, -0.06903455f, -0.05122598f, 0.40691695f, 0.07035839f, 0.34237334f, -0.15891343f, 
    -0.03043934f, 0.12823670f, -0.23874196f, 0.21392164f, -0.13367629f, 0.00199088f, 0.04969619f, -0.02398244f, 
    0.12121070f, 0.12863541f, -0.13401414f, -0.20503016f, -0.06188557f, -0.02974090f, -0.16104548f, -0.05077380f, 
    -0.06068466f, -0.02570253f, -0.01405563f, 0.02427646f, 0.08428164f, 0.27621216f, 0.17885728f, -0.01834704f, 
    -0.13909043f, -0.16428560f, -0.01427483f, 0.05290212f, 0.23496513f, -0.03102386f, 0.11820650f, -0.00614947f, 
    0.04149644f, 0.24712849f, 0.27992165f, -0.08064279f, -0.05985070f, 0.29634669f, 0.01880243f, -0.15925194f, 
    -0.04282063f, -0.07049293f, -0.08961475f, 0.00838465f, -0.10704755f, 0.03487299f, 0.20560262f, -0.15082134f, 
    -0.00656583f, 0.33182043f, -0.00265250f, 0.08754759f, 0.18748592f, 0.32007295f, 0.04583978f, 0.11590484f, 
    0.13031806f, 0.11454736f, 0.22251166f, -0.15011057f, -0.08054711f, 0.04051647f, 0.39260355f, 0.15036277f, 
    0.02582391f, 0.04957672f, 0.04463433f, -0.01490560f, -0.27633125f, -0.02839185f, 0.16788200f, 0.19063795f, 
    -0.13582432f, -0.05037148f, -0.18861824f, -0.18575950f, 0.06037744f, -0.04339207f, 0.00440043f, -0.00622746f, 
    0.07673801f, 0.39545342f, 0.26987839f, 0.25939074f, -0.00657151f, -0.06620232f, 0.00132089f, -0.01885448f, 
    0.15319635f, 0.02564139f, 0.06343459f, -0.05607345f, -0.35483953f, -0.04213845f, 0.22149149f, 0.37182632f, 
    -0.15265982f, 0.10907584f, -0.02969843f, -0.03539835f, 0.18227257f, 0.07522471f, 0.22607201f, 0.09490337f, 
    -0.23897049f, -0.05703622f, -0.01066591f, -0.00366117f, -0.03381017f, -0.05473750f, -0.14864753f, -0.04758626f, 
    -0.08018236f, -0.16735858f, -0.08830981f, -0.02849847f, 0.09817970f, 0.22003455f, 0.21819842f, -0.02362133f, 
    0.21283385f, 0.24529848f, 0.12521055f, -0.10278061f, -0.04671516f, -0.08093321f, 0.03462741f, 0.06021897f, 
    0.13915473f, -0.10295603f, -0.10332092f, -0.13973850f, -0.08793368f, 0.06910771f, -0.01518750f, 0.02662216f, 
    0.14044704f, -0.21838073f, -0.00097358f, -0.02820403f, 0.04985018f, 0.02179463f, -0.04468073f, -0.07231106f, 
    0.24230754f, 0.24844646f, -0.02816853f, 0.07980583f, 0.02988826f, -0.01682449f, 0.05261642f, 0.05083822f, 
    -0.55227482f, -0.00664265f, -0.13123316f, 0.13738541f, 0.04850027f, -0.07513432f, -0.07540609f, -0.14385776f, 
    -0.04806661f, -0.04324629f, 0.14366187f, 0.20971380f, -0.25039300f, -0.25317222f, -0.42672637f, 0.04952871f, 
    -0.18334541f, -0.07233456f, 0.06129120f, -0.09754613f, 0.05836400f, 0.17792834f, -0.02740577f, 0.22645439f, 
    0.03958394f, -0.09086848f, 0.15827553f, -0.23455809f, 0.16541129f, -0.00668616f, 0.00540796f, -0.15463652f, 
    -0.00592372f, 0.12269326f, 0.09923758f, 0.08218346f, 0.18251950f, 0.12491439f, -0.35972589f, 0.41908017f, 
    -0.19469345f, 0.09665504f, 0.19432558f, -0.01578430f, 0.04372776f, -0.05157715f, 0.07160966f, 0.05466547f, 
    0.11310984f, 0.03840730f, 0.04737513f, 0.07444714f, 0.15209845f, 0.17543279f, -0.08748767f, 0.09058012f, 
    -0.08193868f, -0.07154577f, 0.03807820f, 0.00752207f, 0.08057946f, -0.09215666f, -0.08769286f, 0.07628104f, 
    -0.01988801f, -0.12953447f, 0.00945364f, 0.29681617f, 0.12829816f, -0.14729750f, -0.03879217f, 0.21612222f, 
    -0.02511131f, -0.21060205f, -0.28205457f, -0.12081163f, 0.03215952f, 0.05262907f, 0.22818513f, 0.13711891f, 
    0.17589451f, 0.01098835f, -0.25226381f, 0.01316188f, 0.21225569f, -0.09320199f, -0.12324166f, 0.32370991f, 
    -0.02310302f, 0.02736813f, 0.21397299f, -0.04959930f, 0.33302590f, -0.02597946f, 0.15388812f, -0.03812513f, 
    -0.25986940f, -0.28146335f, -0.21363178f, -0.02495647f, 0.02874248f, 0.32720575f, -0.06318304f, 0.04065054f, 
    0.35371238f, 0.10270741f, 0.06648905f, -0.07879048f, -0.23845743f, -0.09380608f, -0.08984318f, -0.09753717f, 
    0.17639710f, 0.05705404f, 0.04837728f, -0.20853485f, 0.04906303f, -0.04677659f, 0.15978223f, 0.07906649f, 
    -0.11628238f, -0.17014691f, -0.25696683f, -0.19663639f, 0.09923860f, 0.12250840f, -0.03643635f, 0.03667893f, 
    -0.01538490f, 0.09678941f, 0.04623472f, 0.02108475f, -0.09576928f, -0.01237381f, -0.23420732f, -0.01840447f, 
    0.13335709f, -0.05667046f, 0.14195050f, 0.08060977f, 0.05055791f, 0.11432318f, -0.00334169f, 0.05240413f, 
    -0.00306820f, 0.02340607f, 0.06407126f, -0.01749325f, -0.03832982f, 0.07586091f, -0.02567599f, 0.05507347f, 
    0.04214939f, 0.01986471f, 0.08247235f, 0.05127513f, -0.25896811f, -0.18493903f, -0.03373773f, -0.03966074f, 
    -0.00584967f, 0.01622604f, 0.23941617f, 0.08134939f, 0.13166192f, 0.06721963f, -0.05540400f, 0.00299134f, 
    -0.23031324f, 0.17691633f, -0.07228073f, -0.09192413f, 0.24189733f, 0.28246999f, 0.34940723f, -0.10491066f, 
    0.05528639f, 0.13603438f, -0.13978033f, 0.08626085f, -0.15883732f, -0.01799690f, -0.06810819f, -0.02072557f, 
    0.16280143f, 0.00491525f, 0.13841139f, -0.11879254f, 0.00050495f, 0.11916456f, 0.02900903f, -0.06353478f, 
    0.00043468f, -0.10230804f, 0.06933363f, -0.15180698f, 0.01883176f, 0.06592164f, -0.11563963f, 0.06194883f, 
    0.07830225f, 0.07742315f, 0.17422307f, -0.05409991f, 0.11672144f, 0.09667098f, 0.20050442f, -0.01335838f, 
    -0.05426849f, -0.08862403f, -0.10044347f, -0.05277874f, -0.13128994f, -0.10533282f, -0.01860068f, -0.11680976f, 
    -0.37816489f, -0.03247130f, -0.24688031f, 0.24018763f, 0.04896145f, 0.16347855f, 0.36019811f, -0.00664958f, 
    0.13858613f, -0.08143962f, -0.07387123f, -0.02981986f, 0.03910521f, -0.49951074f, -0.18859893f, 0.27323452f, 
    0.14549434f, 0.02546323f, -0.29030094f, 0.33301714f, -0.05738097f, 0.00096265f, 0.04879160f, -0.05650653f, 
    -0.32988614f, -0.61199516f, -0.05819527f, 0.17625892f, 0.13441001f, 0.18180509f, 0.27499112f, -0.15520844f, 
    -0.16401649f, -0.02377081f, -0.22497712f, -0.24394670f, 0.41073474f, 0.18630055f, 0.25914285f, -0.24089436f, 
    0.12361426f, 0.26508251f, 0.15790440f, 0.24220966f, -0.14607927f, 0.04629697f, 0.15098739f, -0.11898619f, 
    0.07069971f, 0.39565596f, 0.08453447f, -0.00454273f, -0.11895218f, -0.06111336f, -0.08893227f, 0.32536510f, 
    -0.29613835f, -0.12632388f, 0.10260805f, -0.03231961f, 0.05126080f, 0.30507603f, -0.16112539f, -0.00520211f, 
    -0.31295112f, -0.12371674f, 0.02809406f, -0.03815113f, 0.08598362f, 0.10404614f, 0.03907597f, 0.03697246f, 
    0.37924635f, 0.00832198f, -0.04543309f, -0.07375608f, -0.04181909f, -0.17336498f, 0.12586948f, 0.13196249f, 
    -0.15720798f, -0.06356500f, -0.09970801f, 0.05580610f, 0.28701377f, 0.09752143f, -0.16426244f, -0.29652396f, 
    0.17041054f, -0.12941188f, 0.08813798f, 0.08489119f, -0.08400895f, 0.01330473f, 0.07923314f, 0.09871492f, 
    -0.24253601f, 0.20016810f, -0.28262833f, -0.56439537f, 0.05574634f, 0.08623824f, 0.00425407f, 0.20815396f, 
    -0.00626908f, -0.03368460f, -0.13330582f, -0.17543177f, 0.16942413f, 0.28533012f, 0.25577557f, -0.04576043f, 
    0.24411874f, 0.13735345f, -0.02978026f, 0.16339384f, 0.04623999f, -0.03125102f, 0.08221493f, -0.07066946f, 
    0.19008999f, -0.11740965f, 0.22183904f, 0.03344259f, 0.04950671f, -0.18017243f, 0.09318134f, 0.00401843f, 
    -0.18475306f, 0.00204666f, 0.11883143f, -0.04337798f, 0.11249635f, -0.41798785f, 0.03295182f, 0.10504138f, 
    0.10036046f, 0.14803064f, 0.01311126f, 0.04254383f, 0.25573280f, 0.10121858f, 0.52574712f, 0.30413818f, 
    0.05552193f, -0.53612983f, 0.04992434f, -0.47445181f, 0.33921155f, -0.05196382f, 0.09639548f, 0.04420040f, 
    0.10595018f, -0.17862545f, -0.04163470f, -0.02030508f, -0.11199313f, -0.17149499f, 0.11872746f, -0.09483857f, 
    0.02480579f, 0.04098513f, 0.02562588f, 0.29036650f, 0.37922651f, 0.12199500f, 0.26398784f, 0.10646695f, 
    -0.14481823f, -0.00388489f, 0.25800738f, 0.26114345f, -0.03337462f, -0.10342225f, -0.30369067f, -0.02974546f, 
    0.18879491f, 0.08395734f, 0.03507674f, -0.00654510f, -0.37176874f, -0.45674437f, -0.15706128f, -0.05010810f, 
    -0.04163579f, 0.08699838f, -0.08350906f, -0.06670849f, 0.09703507f, -0.10136734f, 0.11815261f, -0.03485652f, 
    -0.42741477f, -0.22702248f, -0.21950138f, -0.03481292f, -0.12118817f, -0.13121517f, -0.15980713f, -0.10059673f, 
    0.06456393f, -0.09334681f, -0.07689018f, -0.08387614f, 0.67228431f, 0.09785461f, -0.29264712f, -0.02780338f, 
    0.14124238f, 0.01035736f, 0.17547137f, 0.01567826f, -0.10218687f, 0.00079947f, 0.19418815f, 0.21987024f, 
    -0.48916659f, -0.42814359f, -0.25525326f, -0.15720835f, -0.02471609f, -0.03734306f, -0.10614502f, 0.14803135f, 
    0.14252891f, 0.04049518f, 0.09631485f, 0.09461279f, 0.04140254f, 0.12631877f, 0.15581279f, -0.02908526f, 
    -0.17136350f, -0.16788982f, -0.29170528f, -0.20845628f, 0.02496150f, 0.03517337f, -0.02783748f, -0.12013859f, 
    0.13531023f, -0.03479102f, 0.07421587f, 0.14324258f, 0.11625937f, 0.12450565f, 0.00285819f, -0.12910300f, 
    -0.00771271f, 0.06252661f, -0.12694369f, 0.07865500f, -0.05105998f, -0.11468019f, -0.26497358f, 0.06926215f, 
    0.01648914f, -0.13780884f, 0.13297482f, -0.12973584f, 0.29003206f, 0.03667746f, 0.08582155f, 0.03590641f, 
    0.28764069f, 0.34842780f, 0.23294459f, 0.27981314f, 0.17339371f, -0.01797313f, -0.00640653f, -0.09236070f, 
    0.17625481f, 0.02307661f, 0.08822798f, 0.00594479f, 0.30845234f, 0.37183607f, 0.19523090f, 0.32876244f, 
    0.05792192f, -0.02406589f, -0.05033009f, -0.00642561f, 0.07090100f, 0.04618530f, -0.05331272f, 0.00053379f, 
    0.85000855f, 0.06333148f, 0.13968855f, 0.29845306f, 0.29181427f, 0.14298877f, -0.02871246f, -0.07647278f, 
    -0.20905037f, -0.07305023f, 0.11467506f, 0.19721813f, 0.01183588f, 0.13899192f, 0.05024183f, 0.22493082f, 
    0.00836618f, 0.06167956f, -0.02224576f, 0.02823328f, -0.04129261f, -0.15596688f, -0.11493021f, 0.01545746f, 
    -0.26473707f, -0.16368328f, -0.22584966f, 0.00158381f, 0.09377027f, 0.04360922f, -0.03676848f, -0.02482396f, 
    -0.14907074f, 0.04870532f, -0.20115222f, -0.10537045f, 0.40802407f, 0.28017715f, 0.08238011f, -0.03324419f, 
    0.33129296f, 0.01284138f, 0.14365235f, 0.05458128f, -0.03395199f, 0.15687925f, -0.00800509f, -0.03547928f, 
    0.21601047f, 0.15584585f, -0.01872999f, 0.15903273f, 0.11267498f, -0.20075685f, 0.26492813f, -0.05551527f, 
    -0.03062479f, 0.11665266f, 0.16433977f, 0.19489761f, 0.13878016f, 0.06783760f, 0.01725233f, 0.05743941f, 
    -0.01002637f, -0.09763957f, 0.01549593f, -0.07123712f, -0.09518708f, 0.00347030f, 0.02517972f, 0.16779064f, 
    -0.27037194f, -0.20564388f, -0.23652992f, -0.28656849f, 0.06352055f, 0.03856319f, -0.08617419f, -0.07538645f, 
    -0.29694960f, 0.04469238f, 0.00293926f, -0.06074553f, -0.30796823f, -0.25403073f, -0.14904831f, -0.24217823f, 
    0.02538142f, -0.01865797f, 0.00848155f, -0.05311853f, 0.09452289f, 0.25777754f, 0.14385366f, 0.19711255f, 
    0.41149080f, -0.18601432f, -0.39177006f, 0.12609990f, 0.00069592f, 0.01856267f, 0.20847929f, -0.06978287f, 
    -0.01478379f, 0.08430532f, 0.02681941f, 0.07275757f, 0.41958708f, -0.35871923f, 0.06956910f, 0.10518848f, 
    0.08687725f, -0.08770500f, 0.12417754f, -0.11767116f, -0.10198975f, 0.11411681f, 0.21218336f, 0.09472427f, 
    0.37853327f, -0.02246066f, -0.01272931f, 0.52075076f, 0.02210250f, 0.28084737f, 0.02653314f, -0.04692601f, 
    -0.08792526f, -0.01999917f, -0.10121769f, 0.13009246f, 0.05286668f, -0.07725173f, -0.29672238f, 0.07864543f, 
    -0.02561314f, -0.05939461f, 0.54503179f, 0.20765078f, 0.01566890f, 0.11335409f, 0.05254516f, 0.15056573f, 
    0.08664540f, 0.16745462f, 0.19016980f, -0.16255915f, 0.18824634f, 0.02478690f, 0.14872290f, -0.05442420f, 
    0.04549328f, -0.10379953f, -0.08265343f, -0.17499965f, 0.62904006f, -0.09210376f, 0.19801073f, -0.08252517f, 
    0.04718211f, -0.00667744f, 0.01270829f, -0.09100491f, -0.12372059f, -0.04943214f, 0.31974420f, 0.08521900f, 
    -0.08921195f, -0.24793002f, 0.23284447f, 0.10675086f, 0.01478135f, -0.08839518f, -0.01047217f, 0.29400620f, 
    0.00264904f, -0.00282874f, 0.02675212f, 0.03274731f, 0.35347453f, 0.12647706f, 0.03250379f, 0.19955899f, 
    -0.16710465f, -0.26309565f, 0.22083093f, -0.15147167f, -0.00688230f, -0.02938450f, -0.01664514f, -0.01345176f, 
    -0.98008811f, -0.38129196f, -0.45908201f, -0.23082787f, -0.04701907f, 0.09488130f, 0.16526356f, -0.18105932f, 
    -0.13038677f, 0.18140373f, 0.24689858f, -0.06031555f, -0.19756158f, 0.15244155f, -0.13046606f, -0.02357453f, 
    -0.21956490f, -0.12790067f, 0.14507946f, -0.35862663f, 0.13190158f, 0.11428281f, 0.12622429f, -0.07568914f, 
    -0.15732475f, 0.10614546f, 0.08302186f, -0.15470019f, -0.11601096f, 0.03606991f, -0.01864933f, -0.02637900f, 
    0.05848065f, 0.13465369f, 0.01631425f, 0.08279578f, 0.00333986f, -0.10716894f, -0.17221363f, 0.20271468f, 
    0.09506129f, -0.39428449f, 0.22914404f, 0.01391955f, -0.04058934f, -0.17609085f, -0.24585596f, -0.08918055f, 
    -0.00195956f, -0.01653331f, -0.07306685f, 0.20319320f, 0.14310458f, 0.46320745f, 0.29972094f, -0.14845407f, 
    -0.01411556f, 0.18602577f, -0.31725967f, 0.16935709f, -0.09200017f, -0.09335512f, -0.06889108f, 0.07154478f, 
    -0.00032939f, -0.00222776f, -0.06938357f, 0.10924082f, -0.03157290f, -0.07159797f, 0.10545845f, -0.10836775f, 
    -0.07125027f, -0.06917991f, -0.09708145f, 0.11293971f, -0.04545997f, -0.11568814f, -0.11313652f, -0.13205692f, 
    0.31694180f, 0.17677103f, 0.18179169f, 0.25927186f, 0.24738708f, 0.09910630f, -0.07195117f, 0.09680006f, 
    0.07972004f, 0.05668179f, -0.05629451f, -0.01815480f, -0.02807517f, 0.24092568f, -0.12328377f, -0.11285244f, 
    -0.24997845f, -0.05251645f, -0.50203550f, 0.25233835f, -0.04330721f, 0.10402534f, 0.20523506f, 0.08275641f, 
    0.06590346f, 0.05278032f, 0.01599070f, -0.05531466f, -0.01771948f, -0.28561652f, -0.00737031f, -0.45807433f, 
    0.17022659f, 0.07476149f, -0.12637763f, 0.20037095f, 0.04579809f, 0.11036861f, -0.12852742f, -0.04059111f, 
    0.02516369f, -0.39194947f, -0.01324672f, 0.33517081f, 0.06506833f, 0.15639235f, 0.17789793f, -0.02644084f, 
    -0.05409202f, -0.04468585f, -0.06382363f, 0.06322283f, 0.33271158f, 0.27147087f, 0.10371073f, -0.23342603f, 
    -0.05002535f, 0.14169435f, 0.24244079f, 0.08958643f, 0.01247393f, 0.07112037f, 0.18712567f, 0.07750455f, 
    0.18888755f, 0.68664426f, 0.34788075f, -0.12458054f, -0.05442607f, -0.20055459f, -0.05544759f, 0.09087467f, 
    -0.08799983f, 0.16272137f, 0.13682951f, -0.01831146f, 0.21643971f, 0.23140827f, 0.27266729f, -0.09840196f, 
    -0.08643953f, -0.00469297f, -0.12561888f, -0.01445464f, 0.11907015f, -0.12786292f, -0.27058682f, 0.06361342f, 
    0.50692797f, 0.22619580f, 0.02195689f, -0.22153088f, -0.13073355f, -0.35757744f, 0.02607345f, 0.09575445f, 
    -0.10273849f, 0.11195217f, 0.03399594f, 0.13296133f, 0.24514581f, -0.12010115f, -0.23847218f, -0.17218065f, 
    0.07636554f, -0.23454230f, -0.03208128f, 0.08828459f, 0.01427402f, 0.17024854f, 0.12052117f, -0.05435375f, 
    -0.26741472f, 0.13494453f, -0.07266151f, -0.17616819f, -0.11346434f, 0.17605087f, -0.09001137f, 0.05552620f, 
    0.12994918f, 0.08304682f, 0.04979977f, 0.02907860f, 0.18360122f, 0.04982858f, 0.20249575f, -0.02051052f, 
    -0.02686871f, 0.04098878f, -0.07061915f, -0.00046605f, -0.02321056f, 0.17064027f, 0.18355718f, -0.01427309f, 
    0.20550951f, 0.20689918f, 0.19887209f, 0.04626709f, 0.01922777f, -0.13465253f, 0.15317738f, -0.04535021f, 
    0.06882114f, 0.11086417f, 0.16821446f, 0.06866521f, 0.29646391f, 0.07392420f, 0.07699410f, -0.04148850f, 
    0.00078513f, -0.22607629f, -0.06673834f, -0.17563538f, 0.11505097f, -0.11030447f, 0.15960412f, 0.04658823f, 
    0.19938461f, -0.24754675f, 0.05812737f, -0.17372967f, 0.30410314f, -0.04345116f, -0.11693370f, -0.03909335f, 
    -0.05037635f, -0.09239827f, -0.13805391f, -0.23214614f, -0.05177410f, -0.17576760f, 0.12781925f, -0.03930858f, 
    0.07132543f, 0.07959571f, -0.15857880f, 0.17066617f, -0.03358380f, -0.14041789f, 0.12394407f, -0.18833856f, 
    -0.19114935f, 0.16148001f, 0.23619327f, 0.36535355f, 0.02297547f, -0.04998760f, -0.08486274f, -0.03555247f, 
    0.04216370f, -0.03749124f, 0.15897079f, 0.02239525f, -0.10437249f, -0.26298106f, -0.31601948f, 0.10911657f, 
    0.07714941f, 0.11460452f, 0.07222334f, -0.06996492f, -0.01201645f, 0.07451487f, 0.13477619f, -0.15515479f, 
    -0.36824214f, -0.01538409f, -0.55861461f, -0.25413609f, 0.12082107f, -0.18159793f, -0.20031062f, -0.04988758f, 
    0.10305691f, -0.06255977f, 0.01706068f, 0.10569533f, 1.13566351f, -0.21624361f, -0.14729534f, -0.32694915f, 
    -0.08664193f, 0.06241775f, 0.10831038f, 0.03570656f, -0.10040074f, -0.13626967f, 0.00263931f, 0.18822874f, 
    -0.21700126f, -0.35838252f, -0.64160937f, -0.42611164f, 0.09652349f, 0.16615580f, 0.30407190f, 0.06945914f, 
    0.07177714f, 0.18688506f, 0.13716204f, -0.15424207f, -0.00916031f, 0.15083501f, 0.24860993f, -0.15189673f, 
    0.10214801f, 0.00512592f, 0.04545919f, 0.05813458f, 0.18821013f, -0.03403560f, 0.05855556f, -0.09709327f, 
    0.32904664f, -0.21193416f, 0.07521980f, -0.22312959f, -0.04519773f, 0.05495450f, -0.11548619f, 0.12908751f, 
    0.06786317f, -0.01628332f, 0.11081473f, -0.07342174f, 0.01738120f, -0.61601830f, 0.04250149f, -0.19829397f, 
    0.02590297f, 0.07616691f, 0.22737691f, 0.10919742f, -0.10844240f, 0.06979045f, 0.12801529f, 0.01213526f, 
    0.06890324f, 0.19275917f, 0.13383655f, -0.14912511f, 0.08670423f, 0.11798038f, 0.10822536f, -0.01095176f, 
    0.15044861f, -0.01925092f, -0.18481891f, 0.08392793f, 0.20476927f, 0.04892076f, 0.22723539f, -0.05164202f, 
    -0.02783628f, -0.01174871f, 0.04032677f, -0.02584274f, -0.01008860f, 0.00023938f, -0.15197517f, -0.03757187f, 
    -0.01460872f, 0.35896179f, 0.15016000f, 0.09053800f, 0.15585476f, 0.14521033f, -0.01721944f, 0.04523227f, 
    0.01102489f, -0.02950323f, -0.16288131f, -0.16507368f, 0.49924472f, 0.10747977f, 0.32229111f, -0.06430876f, 
    0.09035417f, -0.05260031f, 0.04527245f, -0.08959433f, 0.00089850f, -0.18257986f, -0.07356077f, 0.08741383f, 
    0.17978533f, -0.28385472f, -0.24289532f, -0.17688610f, 0.04372296f, -0.00721975f, -0.23128812f, -0.14130765f, 
    0.15055983f, -0.13960630f, -0.03658623f, -0.00475384f, 0.28381953f, 0.08565632f, -0.02749333f, -0.18601328f, 
    0.01116789f, 0.22944181f, 0.22215152f, 0.05107002f, 0.10194058f, 0.23113135f, -0.10730781f, -0.06833977f, 
    -0.04764393f, 0.19936612f, -0.50344253f, -0.23276220f, -0.15149526f, -0.01180835f, 0.17117874f, -0.03409539f, 
    -0.13570970f, -0.02102189f, -0.09454454f, 0.01006727f, 0.22605301f, -0.03842378f, 0.01902401f, 0.13162303f, 
    0.05278370f, 0.13074435f, 0.18509784f, -0.10063049f, 0.05046729f, 0.14274238f, 0.08236281f, 0.18697898f, 
    -0.16897053f, -0.52165401f, -0.46382654f, -0.13340819f, -0.30078438f, -0.20844851f, 0.04297523f, -0.16310698f, 
    0.03988208f, 0.06229963f, 0.06690758f, -0.00983969f, -0.16543104f, -0.33266449f, -0.01512988f, -0.30056712f, 
    -0.09125007f, 0.03106247f, 0.07606553f, -0.06123753f, -0.00717444f, 0.01503630f, -0.06221265f, 0.02997926f, 
    -0.04634257f, 0.06941343f, -0.00413538f, 0.02033305f, 0.06750005f, -0.07606761f, -0.08344983f, 0.04286394f, 
    0.05046339f, -0.06539410f, -0.00936162f, -0.02317498f, -0.01642058f, 0.00887024f, 0.02587626f, 0.01104265f, 
    0.01601332f, -0.08133901f, -0.01838810f, 0.01157733f, 0.03257095f, -0.04353111f, -0.09289925f, -0.04407523f, 
    -0.01827620f, -0.04177718f, -0.07463716f, -0.03464302f, -0.02601100f, -0.05654796f, -0.05373221f, -0.00435957f, 
    0.00954288f, 0.03493291f, -0.06096005f, -0.09420422f, -0.00460580f, -0.07718628f, -0.04669239f, 0.02851359f, 
    -0.05127594f, 0.06265417f, -0.05272066f, 0.01916956f, -0.08184529f, 0.06535681f, -0.01362084f, -0.03503938f, 
    -0.02617625f, -0.01388260f, -0.07692777f, -0.05606197f, -0.09817699f, -0.02451405f, -0.02623539f, 0.03481472f, 
    -0.01439914f, -0.03598232f, -0.00682086f, -0.02901024f, -0.03540910f, 0.04469295f, -0.08332691f, 0.01839019f, 
    -0.02956142f, -0.08882824f, -0.00822024f, 0.01565020f, -0.06112407f, 0.00513253f, -0.08855093f, -0.04060711f, 
    -0.01151120f, 0.05167044f, -0.01239406f, 0.02870977f, -0.05719002f, -0.04185403f, -0.03635989f, 0.04684316f, 
    -0.00133396f, -0.05790853f, 0.01194810f, -0.07734607f, 0.01009857f, -0.01494843f, -0.00860244f, 0.03610638f, 
    -0.03623320f, -0.04180738f, 0.02641402f, -0.06527913f, -0.06839242f, 0.02074958f, 0.00613322f, -0.04170060f, 
    0.00442737f, -0.00971862f, -0.01053825f, -0.07579565f, -0.03059269f, 0.03177888f, -0.02357391f, 0.04910326f, 
    -0.04569860f, -0.00329787f, 0.06602647f, -0.03025525f, 0.03084557f, -0.04231221f, -0.05513794f, 0.02051063f, 
    0.06109007f, 0.04699088f, -0.03591468f, -0.07151241f, -0.01518844f, 0.01838370f, -0.05853676f, -0.03036531f, 
    -0.00527034f, -0.07823727f, -0.06949041f, 0.01040528f, -0.05523108f, -0.00682162f, 0.04589857f, -0.04863028f, 
    -0.08303776f, 0.02173188f, -0.07844122f, 0.01142171f, 0.03460515f, -0.01387124f, -0.07414790f, -0.08725610f, 
    -0.06569561f, -0.02356878f, 0.03185925f, -0.01581873f, -0.00037165f, 0.02903140f, 0.01658477f, 0.01009650f, 
    -0.06514809f, 0.01441696f, -0.04163310f, 0.02915218f, -0.05693711f, 0.02633607f, -0.08710775f, -0.05563002f, 
    0.02827897f, 0.00796743f, 0.03465290f, 0.00294053f, 0.00070803f, 0.04349114f, -0.06941251f, -0.07895596f, 
    0.01187260f, -0.08139396f, -0.01409780f, -0.01848853f, -0.04146233f, 0.00123088f, -0.00792724f, -0.07796289f, 
    0.01497577f, 0.02220853f, -0.02242703f, 0.02748236f, -0.01083510f, -0.02054920f, -0.07639032f, -0.07660662f, 
    0.04027858f, 0.03954392f, -0.04507230f, 0.01645677f, -0.02609851f, -0.01226673f, -0.07030027f, -0.05151350f, 
    -0.03283100f, -0.02382522f, 0.02925116f, -0.04778722f, -0.04538519f, -0.05157911f, -0.08349342f, -0.07104460f, 
    0.31841704f, -0.31749567f, -0.10844637f, 0.05026713f, 0.15642259f, 0.08972440f, -0.04902559f, -0.00320655f, 
    0.01940755f, 0.04668187f, 0.04344010f, 0.04480074f, -0.43957469f, 0.29320186f, 0.56655777f, 0.17805798f, 
    0.05246945f, 0.08434880f, 0.39712590f, 0.18791389f, -0.10409277f, -0.06686701f, 0.19219829f, -0.04498508f, 
    0.04199010f, -0.10430636f, -0.04020964f, 0.16049848f, -0.08834701f, 0.18448122f, 0.10324703f, -0.01558669f, 
    0.11590492f, -0.06964586f, 0.06069163f, -0.08390549f, 0.06056168f, -0.42109072f, -0.19168989f, 0.27825990f, 
    0.06153604f, 0.08345500f, 0.18218258f, -0.00410993f, 0.14101374f, 0.00277810f, 0.01906568f, 0.02544019f, 
    -0.20828922f, 0.08470766f, 0.12246800f, 0.06138823f, -0.03822257f, -0.11614972f, 0.18685102f, 0.00607412f, 
    0.28489006f, 0.27384660f, -0.06557073f, -0.04421864f, 0.11877578f, -0.01648201f, 0.03951497f, 0.08273953f, 
    0.01709974f, 0.06559312f, 0.08883995f, 0.13014299f, -0.04460853f, -0.11048603f, 0.18368113f, 0.16106722f, 
    -0.11713475f, -0.05408661f, 0.08444932f, 0.20013365f, 0.05689261f, -0.10610687f, 0.11225140f, 0.07146449f, 
    0.11098442f, 0.30676025f, 0.15554902f, 0.09956310f, -0.43771544f, -0.03009675f, 0.55453539f, 0.44313598f, 
    -0.01431023f, 0.04677048f, 0.06200633f, 0.07134809f, 0.03339816f, -0.02482960f, -0.05241472f, -0.07129658f, 
    -0.29502881f, -0.26843157f, 0.09062864f, -0.06837965f, 0.10656174f, -0.22877072f, 0.09436756f, 0.06270259f, 
    0.03303149f, 0.05650851f, 0.10681254f, 0.11332149f, -0.54288512f, -0.24477655f, 0.17949255f, 0.21531552f, 
    -0.02536005f, 0.03432429f, -0.04041589f, 0.01482486f, -0.04173864f, 0.00747762f, 0.14822786f, 0.11621474f, 
    0.06071748f, -0.04591683f, 0.07273804f, -0.14532082f, -0.06994034f, 0.06788477f, 0.10218599f, 0.05461221f, 
    0.05938807f, -0.10875697f, 0.19533703f, -0.15876615f, 0.11800054f, -0.05700444f, 0.02234123f, -0.17227331f, 
    -0.23654154f, -0.05200317f, 0.25705940f, 0.10454290f, 0.15158370f, 0.04336366f, 0.10256255f, -0.15057707f, 
    -0.02650064f, 0.01317346f, 0.25551745f, -0.04749081f, -0.09008028f, 0.44827282f, -0.02173750f, 0.19455311f, 
    0.01057984f, -0.15101635f, 0.14136399f, -0.02173559f, -0.06774776f, 0.01500824f, 0.10850646f, -0.09323018f, 
    -0.10883652f, 0.13346517f, 0.17256719f, 0.24186325f, -0.08761516f, -0.00628934f, 0.00568401f, -0.03503584f, 
    0.09754384f, -0.03914879f, -0.17784175f, -0.22644371f, 0.00494957f, -0.02094723f, -0.07345176f, -0.06895834f, 
    0.10970420f, 0.03376513f, -0.09781013f, 0.18642649f, 0.16537686f, 0.06374592f, -0.00839112f, -0.15476099f, 
    0.05573766f, -0.00996488f, 0.03096482f, -0.02360419f, 0.00101450f, -0.12363420f, -0.02491710f, -0.17942621f, 
    -0.06742007f, -0.31318998f, 0.33535999f, 0.21438189f, -0.05190358f, 0.02564558f, 0.17279506f, 0.01755830f, 
    0.01146230f, -0.06975704f, -0.02477149f, -0.04065265f, -0.64830428f, 0.61840796f, 0.26115760f, 0.15342353f, 
    0.10252670f, 0.05772508f, 0.03580871f, -0.12743545f, -0.02612080f, -0.01439100f, 0.10977124f, -0.05021687f, 
    -0.29786202f, -0.46347040f, 0.07600092f, 0.05900564f, 0.01029257f, 0.15406665f, -0.07903916f, 0.01793484f, 
    0.13734761f, -0.31202313f, -0.12840238f, -0.05866191f, 0.29474449f, -0.38779145f, -0.08410822f, 0.28096065f, 
    0.04233302f, 0.15157411f, 0.05182266f, 0.18306305f, 0.00802150f, 0.13209942f, -0.04717902f, -0.02329685f, 
    -0.14046517f, 0.31261346f, 0.07128409f, 0.19250658f, 0.00400109f, 0.02774446f, 0.20248193f, 0.04994594f, 
    0.01087666f, 0.15296765f, -0.08489779f, -0.03475430f, 0.04217365f, 0.65575838f, -0.20333256f, 0.24170449f, 
    -0.09555937f, -0.16168392f, -0.24402945f, -0.13511980f, 0.12967458f, 0.24809971f, 0.20594397f, 0.02415735f, 
    -0.05406885f, 0.05084008f, 0.00724125f, 0.18832780f, -0.01692924f, 0.04749442f, 0.00518664f, -0.07605015f, 
    0.10445491f, 0.08141818f, 0.05173740f, -0.09061256f, -0.47656590f, -0.08863937f, 0.11481405f, 0.13763776f, 
    0.06330609f, 0.13953756f, 0.03732539f, 0.05750404f, -0.00569120f, -0.11532907f, 0.09495186f, 0.04053554f, 
    -0.18381938f, -0.13252261f, 0.11344130f, -0.03671480f, -0.05643862f, -0.10731898f, 0.15784720f, 0.06158469f, 
    0.10845659f, 0.01438969f, 0.03363155f, 0.00918025f, -0.47812948f, -0.08654098f, 0.10547829f, 0.02553487f, 
    0.06222528f, 0.18302616f, 0.02875888f, 0.10235798f, 0.11358342f, 0.22301228f, -0.00258549f, -0.01902540f, 
    0.09817920f, -0.18876952f, 0.29755625f, -0.06523439f, -0.02035041f, 0.12201577f, 0.05189083f, 0.20973650f, 
    -0.01837882f, -0.12878115f, 0.14593950f, 0.06969943f, -0.12319936f, -0.14175320f, 0.02705720f, -0.00277999f, 
    -0.03492992f, -0.05340099f, 0.05898276f, -0.01940582f, 0.20606081f, 0.04034698f, 0.12829833f, 0.24766417f, 
    -0.24990979f, -0.30943608f, 0.44052336f, -0.31662947f, 0.27812496f, 0.22516009f, 0.01058130f, 0.01920054f, 
    0.20497924f, -0.21407254f, 0.28953296f, -0.01969699f, -0.15068756f, -0.03757351f, 0.04484152f, -0.10890494f, 
    0.05993721f, 0.07147486f, -0.12777229f, 0.01983816f, 0.17628071f, 0.12503628f, -0.09423788f, -0.10260280f, 
    0.18599926f, 0.06929268f, 0.11556326f, -0.30035752f, 0.05496056f, 0.08834054f, -0.19288550f, 0.15529738f, 
    0.17356734f, 0.19243334f, 0.07404743f, 0.09432034f, -0.13387616f, -0.22981080f, 0.04196295f, -0.32179230f, 
    0.12444974f, -0.03001962f, -0.23086104f, 0.09656993f, 0.07164010f, -0.18393710f, 0.03522526f, -0.08788467f, 
    0.21260215f, -0.35429287f, 0.26674366f, -0.12594469f, -0.21943045f, -0.02127459f, 0.01788009f, -0.00328524f, 
    -0.07355077f, 0.06618936f, -0.02471345f, -0.10163762f, -0.84071904f, 0.65251428f, 0.39598373f, 0.50805497f, 
    -0.00976114f, -0.07644256f, 0.02523592f, -0.12146210f, 0.07028868f, 0.19108281f, -0.15283768f, 0.25741667f, 
    -0.13761123f, 0.23628178f, -0.18028650f, 0.02699179f, 0.00753304f, 0.14261380f, 0.08659033f, -0.01998612f, 
    0.00295920f, -0.03141311f, 0.00876494f, 0.01224256f, -0.10053625f, -0.15068419f, -0.41295707f, 0.53004879f, 
    0.23740217f, 0.11540315f, 0.33343259f, 0.11860014f, -0.03937719f, 0.14277603f, -0.18200049f, 0.03818462f, 
    0.05438170f, 0.15266100f, -0.11259959f, 0.24598236f, -0.05066656f, 0.09443177f, 0.10754253f, 0.01295459f, 
    0.06765337f, 0.09358653f, -0.08817701f, -0.01420532f, 0.28228307f, 0.00656014f, 0.13004361f, 0.33295754f, 
    0.00992900f, 0.04654954f, -0.02828146f, 0.17091586f, -0.23250206f, -0.13423727f, 0.17703831f, 0.04220073f, 
    -0.19507857f, 0.21891202f, 0.00572684f, 0.40525591f, 0.06408720f, 0.06267542f, 0.09044714f, 0.01826206f, 
    -0.00161992f, 0.12168307f, 0.10971548f, 0.09687537f, -0.21782246f, -0.03843249f, -0.34069774f, 0.27755696f, 
    -0.21881357f, -0.11604483f, -0.03043309f, -0.29861256f, -0.06361301f, -0.00936877f, 0.02118661f, -0.03419740f, 
    0.35599214f, -0.12213323f, 0.27394423f, 0.43607917f, -0.05418526f, 0.00234416f, 0.17553477f, -0.29043448f, 
    -0.07471720f, 0.13567162f, 0.16884317f, -0.02403408f, -0.26971146f, -0.20762007f, -0.37957916f, 0.11585813f, 
    -0.25149754f, -0.05579567f, 0.02216831f, -0.38396722f, -0.08193507f, -0.01101814f, -0.03230566f, -0.03991159f, 
    -0.11021870f, 0.24934484f, -0.00259604f, 0.06170327f, 0.07772472f, 0.06546188f, 0.01845594f, 0.06659751f, 
    -0.06666346f, 0.05542458f, 0.10555232f, 0.07667718f, -0.31053096f, 0.25859249f, 0.08504297f, 0.30084282f, 
    0.08599245f, 0.01886893f, 0.08175276f, 0.16423437f, -0.04642549f, -0.06169143f, -0.06107898f, 0.07185928f, 
    -0.22362162f, -0.07719941f, -0.05973317f, 0.32027066f, -0.22647874f, -0.00272274f, -0.30888957f, -0.04336887f, 
    -0.04341155f, 0.10637336f, 0.04495129f, -0.15176333f, -0.06148717f, -0.03745061f, -0.10972399f, -0.01403565f, 
    -0.12514950f, -0.05182669f, 0.06697213f, 0.18336821f, 0.04925483f, 0.15210786f, 0.03875585f, -0.03530955f, 
    -0.20013794f, 0.07419784f, -0.17385298f, -0.01391205f, 0.16107731f, 0.08566780f, 0.10996232f, 0.03658731f, 
    -0.00764224f, 0.11115634f, 0.06421108f, 0.20859204f, 0.04995821f, 0.09051637f, -0.10242444f, -0.13881491f, 
    -0.02241487f, -0.01363484f, -0.00319158f, 0.08324009f, -0.12694511f, -0.03739924f, -0.07724655f, -0.09046316f, 
    0.18670523f, 0.22700085f, 0.17330828f, 0.16617428f, -0.01168420f, -0.09208693f, -0.04110586f, -0.12000002f, 
    -0.00600158f, -0.12495985f, -0.02509014f, -0.08671307f, -0.34061155f, -0.06732811f, 0.33044899f, 0.41799992f, 
    0.23560302f, -0.00792411f, 0.03581645f, -0.30008581f, 0.10742596f, 0.02567768f, -0.17518775f, 0.16415067f, 
    -0.30001113f, -0.14858188f, -0.05341699f, 0.04307174f, 0.12116807f, -0.11209860f, -0.23861654f, -0.21447466f, 
    -0.12456042f, -0.04558244f, -0.04562042f, 0.15469356f, -0.40118706f, -0.03703422f, -0.04735906f, 0.08282578f, 
    -0.03299867f, -0.04324839f, -0.06322577f, -0.07417128f, -0.00317854f, -0.14311475f, 0.06383452f, -0.02161492f, 
    0.01206205f, -0.48672155f, -0.07171600f, 0.34220359f, 0.00982522f, 0.07530680f, -0.00686030f, -0.14952379f, 
    -0.01936815f, -0.02043548f, 0.05377965f, 0.07923814f, -0.35228154f, 0.10713854f, -0.10427789f, 0.24309069f, 
    0.11703897f, -0.04062181f, -0.17580399f, -0.15075234f, 0.10788724f, 0.19048828f, 0.05206633f, -0.01984914f, 
    0.15755291f, -0.13897213f, -0.05886370f, 0.38248593f, 0.11098005f, 0.17040165f, 0.06867495f, 0.07141626f, 
    0.08549860f, 0.07150349f, 0.13862598f, 0.16192196f, -0.04571305f, 0.16909853f, 0.11614237f, 0.34679207f, 
    -0.12198941f, 0.10660098f, 0.19003211f, 0.25979492f, 0.08901600f, 0.05798349f, 0.03409796f, -0.02399070f, 
    0.72880012f, -0.35398346f, -0.12118880f, 0.41304332f, 0.20746019f, 0.06135268f, 0.12851249f, -0.33249095f, 
    -0.02713685f, 0.10283475f, 0.11357448f, 0.05789726f, -0.29698712f, -0.08600336f, -0.19693942f, 0.11815654f, 
    -0.14816456f, 0.02604112f, 0.04300327f, -0.04162740f, 0.03633524f, 0.04164273f, 0.06440917f, 0.15383819f, 
    -0.11896574f, 0.04358370f, 0.04645928f, -0.02267057f, 0.00555260f, 0.04736586f, -0.05717100f, -0.18600790f, 
    0.03354723f, 0.02247821f, -0.17469226f, -0.05067614f, 0.10723554f, 0.15201107f, 0.01626405f, 0.16317119f, 
    0.31045681f, -0.01651015f, 0.36632121f, 0.10969239f, -0.01774146f, 0.03073965f, -0.07025090f, 0.13454412f, 
    0.00179963f, -0.06884378f, 0.18773091f, 0.27038139f, -0.02085833f, -0.17166866f, -0.11305975f, -0.24666025f, 
    0.20656413f, 0.00729350f, 0.03503206f, -0.02654382f, -0.00262081f, -0.01675924f, -0.02926066f, 0.05067284f, 
    0.01489402f, -0.04813272f, 0.11411341f, 0.00387454f, 0.05390664f, 0.13275474f, 0.24548346f, 0.14524513f, 
    0.25045702f, 0.46119034f, -0.08983614f, -0.58791333f, -0.09161064f, 0.10113864f, 0.06401554f, -0.07411981f, 
    -0.11380299f, 0.04730326f, -0.02651660f, 0.02102893f, -0.27706650f, -0.05658830f, 0.03542409f, -0.40457582f, 
    -0.03313439f, -0.15309468f, 0.07730673f, -0.16464278f, -0.06390459f, 0.22327034f, 0.04037174f, 0.26744479f, 
    0.06045885f, -0.00788598f, 0.02852011f, 0.04579030f, -0.06424142f, -0.07455225f, 0.03690123f, 0.04877361f, 
    0.02560835f, 0.00993199f, 0.05088061f, 0.01986872f, -0.03069886f, 0.02520160f, 0.01423287f, -0.05662626f, 
    0.00281126f, -0.04730144f, 0.05037592f, -0.00843174f, -0.06035328f, 0.05017838f, 0.05179210f, -0.04194796f, 
    -0.05652791f, -0.05392043f, -0.07057320f, -0.00546051f, 0.00645857f, 0.04395649f, -0.03034238f, -0.03143708f, 
    -0.02069952f, 0.05494653f, 0.03810471f, -0.06409130f, -0.01165114f, -0.03702998f, 0.01676677f, 0.03566897f, 
    0.01740689f, -0.00578027f, -0.00736841f, -0.01632349f, 0.00058154f, -0.02652319f, -0.01768158f, -0.04065004f, 
    -0.01861393f, -0.04576697f, -0.08204264f, -0.04544669f, -0.03862339f, 0.05413464f, 0.03798782f, -0.04753638f, 
    0.03573645f, 0.03941284f, 0.01968077f, -0.08518386f, -0.04117824f, -0.07035694f, -0.04968012f, 0.03808577f, 
    -0.03337429f, -0.05053002f, -0.01607836f, 0.03099352f, -0.04133246f, 0.03817533f, -0.00674614f, -0.01360299f, 
    -0.05958351f, -0.02274279f, -0.03304221f, 0.04402726f, -0.00429406f, -0.01294069f, -0.03509244f, 0.00557047f, 
    -0.04720610f, -0.03973303f, -0.07755017f, -0.04361323f, -0.03368629f, 0.05590248f, 0.02980641f, -0.03685058f, 
    -0.01823035f, 0.03109360f, -0.02995047f, 0.06001716f, -0.03339299f, -0.02895238f, -0.05635455f, 0.06323797f, 
    -0.07214395f, 0.03576662f, 0.05371068f, -0.01146540f, -0.03480410f, -0.05700292f, -0.05412995f, -0.05142438f, 
    -0.02566137f, -0.01286130f, -0.00630391f, -0.01823340f, -0.05025510f, -0.03735033f, -0.01552292f, 0.04858798f, 
    -0.02456101f, 0.00565340f, -0.03636791f, -0.07579606f, 0.03397864f, 0.03825011f, 0.02627358f, -0.03486044f, 
    -0.00564391f, 0.03566086f, -0.01027161f, -0.04122671f, -0.00533893f, -0.06021138f, 0.02661738f, 0.00457872f, 
    0.02171060f, 0.01528492f, 0.03858760f, -0.01523696f, -0.04349801f, 0.02622817f, 0.03437752f, -0.01043345f, 
    -0.00676853f, -0.07471593f, -0.02690586f, -0.08036117f, -0.04123475f, -0.07444253f, 0.05854187f, -0.07462730f, 
    -0.06412957f, 0.01791656f, 0.02348798f, -0.04524449f, -0.00823584f, 0.03248154f, -0.03224418f, -0.00645113f, 
    0.01093146f, -0.06575083f, 0.01524118f, -0.02239028f, 0.05604796f, -0.03558704f, 0.04933291f, 0.01948897f, 
    0.01838566f, 0.05400410f, -0.03978341f, -0.08361699f, -0.04105638f, 0.06050280f, 0.06788666f, -0.06386129f, 
    0.01151063f, 0.00479018f, -0.06314696f, 0.02426369f, -0.02248810f, 0.00115532f, 0.01511091f, -0.04805453f, 
    -0.03949848f, 0.02441653f, 0.05191088f, -0.04571854f, -0.04973920f, -0.01537099f, -0.01265593f, 0.04601301f, 
    -0.04628948f, -0.02197009f, -0.01393541f, 0.02170496f, 0.01470628f, 0.01560476f, 0.02168856f, -0.02071901f, 
    0.00131496f, -0.04739583f, -0.02037797f, 0.02959619f, -0.06474692f, 0.02472369f, -0.03123940f, -0.03414718f, 
    -0.02775799f, -0.03215844f, -0.05209029f, -0.08422507f, -0.04052965f, 0.06893494f, 0.01767899f, 0.02098313f, 
    0.03097762f, -0.02204481f, -0.06393722f, 0.03215407f, 0.04908976f, 0.04808769f, 0.00260320f, -0.05725015f, 
    0.00302995f, 0.02321089f, 0.01168673f, -0.02867791f, 0.03966448f, -0.03678198f, -0.06068152f, 0.05972938f, 
    0.05449484f, -0.07613546f, 0.00063516f, 0.01115394f, -0.04551709f, -0.03453023f, 0.04654733f, 0.01464155f, 
    0.04907651f, -0.03738765f, 0.04947613f, 0.00767704f, -0.04525195f, -0.04724533f, 0.04062820f, -0.00994224f, 
    -0.04136001f, -0.04883012f, -0.00214695f, 0.01799269f, -0.04224945f, 0.00268132f, -0.01469990f, -0.01194986f, 
    0.02251020f, -0.03748859f, 0.01743604f, -0.05614471f, 0.05046162f, -0.04865744f, 0.03109647f, 0.02370349f, 
    -0.03974051f, 0.01672905f, -0.04209427f, -0.05254486f, 0.02618179f, 0.03700326f, 0.04427171f, 0.04479069f, 
    -0.03584491f, -0.07421222f, -0.01082015f, -0.07161582f, 0.03166544f, -0.01860842f, 0.00261385f, 0.02056772f, 
    0.02028608f, -0.04572703f, -0.01257123f, 0.05909618f, -0.01263920f, 0.05324297f, 0.05399465f, -0.05693326f, 
    -0.03566993f, -0.01059143f, -0.08347437f, -0.05869344f, 0.00254498f, -0.04224668f, 0.04641248f, 0.00596413f, 
    -0.08979288f, -0.04244372f, -0.04870220f, -0.01662942f, -0.06926688f, 0.03301579f, -0.05500302f, -0.01939338f, 
    0.03867052f, -0.07879363f, -0.00596591f, -0.07660092f, 0.01119600f, 0.06206047f, -0.04770562f, 0.04726074f, 
    0.03590028f, 0.02755615f, -0.04360429f, -0.01798575f, -0.06954595f, -0.01621938f, 0.05351475f, -0.06798571f, 
    -0.00370431f, -0.04612111f, -0.01562150f, -0.05165936f, -0.03335150f, 0.04296902f, -0.06288026f, 0.00335069f, 
    -0.01472739f, 0.01925530f, -0.00231113f, -0.02798907f, -0.06404241f, -0.07293305f, 0.00920831f, 0.03384685f, 
    0.01588714f, 0.00613775f, 0.04351694f, -0.08967322f, -0.02988982f, -0.05858859f, 0.05355635f, -0.01396048f, 
    -0.00786935f, -0.07378208f, 0.00993794f, 0.00652749f, -0.02666096f, -0.03827941f, 0.05839828f, 0.05802795f, 
    0.02253338f, -0.05659403f, -0.03798767f, -0.02424090f, -0.02595975f, -0.03175212f, -0.04375551f, 0.02431629f, 
    -0.04861223f, -0.00008527f, 0.03856574f, 0.03895093f, -0.03968807f, -0.01052701f, 0.06293885f, -0.04056140f, 
    0.03688888f, -0.06100941f, -0.00331881f, 0.01824876f, 0.03706396f, -0.03311372f, 0.05490287f, 0.00571629f, 
    -0.05611792f, -0.03324187f, -0.01247914f, -0.04400333f, -0.02433723f, -0.03746261f, -0.04297992f, 0.02177943f, 
    0.01794670f, -0.03048311f, -0.00623518f, 0.05642817f, -0.07120899f, -0.01760965f, 0.06178038f, 0.04845411f, 
    -0.07670875f, -0.03517299f, 0.03743982f, 0.05569887f, 0.01376121f, 0.04348616f, 0.02812079f, -0.03759323f, 
    0.03524970f, 0.05189340f, -0.07680517f, 0.04567322f, -0.05409063f, -0.03795982f, 0.05592659f, 0.05079614f, 
    0.04153927f, -0.02647315f, 0.02725929f, -0.01966945f, 0.01490489f, -0.05979285f, 0.01875907f, -0.02021316f, 
    0.04367079f, 0.01795460f, -0.04780256f, 0.03825206f, -0.01529558f, 0.02439640f, 0.05260539f, 0.01498508f, 
    -0.04029627f, 0.00082153f, -0.03958551f, 0.04292491f, -0.02878021f, -0.00817018f, 0.01965575f, -0.03133871f, 
    0.01644692f, 0.04687134f, -0.03474797f, 0.00506289f, 0.04059371f, -0.06696434f, -0.03951466f, 0.01029914f, 
    -0.01433037f, 0.05623290f, 0.05405771f, 0.00765190f, -0.04537860f, -0.01258795f, 0.03725766f, -0.07756077f, 
    -0.07749079f, -0.01725402f, -0.02970193f, 0.06026668f, 0.01313848f, 0.02020368f, 0.04762859f, 0.03367559f, 
    0.04066544f, -0.07293858f, -0.01094000f, 0.00753458f, -0.06528243f, -0.04596886f, 0.04902783f, -0.00032725f, 
    -0.02694717f, -0.00415096f, -0.05501068f, 0.03750441f, -0.00847667f, 0.00642404f, -0.01440341f, -0.08168956f, 
    -0.08250087f, -0.02413799f, 0.01763595f, -0.04223168f, 0.01996906f, -0.05111226f, -0.04711279f, -0.00939225f, 
    -0.07005713f, 0.04622975f, -0.07301053f, -0.07771511f, 0.05837243f, -0.03973130f, -0.06317680f, 0.00537692f, 
    -0.03791669f, 0.05568445f, -0.05715015f, 0.04401077f, -0.05919595f, -0.00489541f, -0.04592346f, -0.07313899f, 
    -0.04322081f, -0.01062891f, 0.02914294f, 0.03877241f, -0.06078322f, -0.04959493f, 0.02259943f, 0.02921509f, 
    -0.01144388f, -0.01025220f, 0.02834633f, 0.00481924f, 0.02718830f, 0.01837257f, 0.03968976f, 0.01250484f, 
    0.04309615f, -0.05427248f, -0.03780762f, -0.02988369f, -0.02880712f, -0.03480399f, 0.02132521f, 0.01915240f, 
    0.02293889f, 0.00945408f, -0.08045334f, -0.07362026f, -0.07487894f, -0.01535055f, -0.05593442f, -0.01886498f, 
    0.05146294f, -0.03584705f, -0.06243464f, -0.04529177f, -0.05775020f, -0.04882671f, 0.04578167f, 0.02043713f, 
    -0.01299199f, -0.04989533f, 0.03878764f, 0.00083307f, -0.04046113f, 0.00315214f, 0.03919578f, 0.00414450f, 
    -0.07539378f, -0.02301279f, -0.01911088f, 0.00548430f, 0.00259330f, 0.03472285f, 0.01438814f, -0.01208532f, 
    0.00765133f, 0.00303114f, 0.00552239f, -0.03844104f, -0.05163324f, -0.03384153f, -0.03376572f, 0.02936133f, 
    -0.07275679f, 0.01087461f, 0.05231432f, -0.02412748f, -0.00850856f, -0.01425116f, -0.00920837f, 0.01471250f, 
    -0.06167348f, -0.04699909f, -0.03062126f, -0.00362818f, -0.04415628f, 0.05103961f, -0.08349272f, 0.03393968f, 
    -0.04291766f, -0.02530800f, 0.04091628f, -0.01155396f, -0.03032266f, 0.05511422f, -0.05714393f, -0.04114828f, 
    -0.00562509f, 0.00054464f, 0.51546496f, 0.07201188f, -0.18918096f, -0.18530604f, 0.05797154f, 0.14787380f, 
    -0.06831235f, 0.03696500f, -0.09647413f, 0.13539079f, -0.55249614f, 0.46088174f, -0.43590593f, 0.04880380f, 
    0.07963821f, 0.04039778f, -0.04279527f, -0.26284087f, 0.06413693f, -0.02776367f, 0.04965591f, 0.02528326f, 
    -0.19608094f, -0.21234208f, 0.47340304f, 0.18745276f, 0.31042328f, 0.16734003f, -0.29219961f, -0.08750253f, 
    0.11649586f, -0.27382618f, -0.16707227f, 0.01423872f, 0.27500439f, -0.16394494f, -0.16001192f, 0.05287805f, 
    -0.12558457f, -0.04284083f, 0.05128507f, 0.27044883f, -0.19942039f, 0.22178327f, -0.03288285f, 0.34682333f, 
    -0.11155807f, 0.28583530f, -0.02679949f, 0.11030784f, -0.05728764f, 0.09787323f, 0.24736953f, 0.03909373f, 
    -0.13600455f, 0.07933681f, -0.14363880f, 0.01012426f, 0.24010062f, 0.24235077f, -0.43536672f, 0.06677170f, 
    0.01903543f, -0.15229781f, -0.15960294f, -0.05004545f, 0.04959472f, 0.02778002f, 0.18473449f, -0.18530810f, 
    0.14976014f, 0.04486588f, 0.09666704f, 0.09082682f, 0.10342380f, -0.01108853f, 0.00696195f, -0.08937984f, 
    -0.09548762f, 0.14842503f, 0.05675556f, -0.14665809f, 0.14291894f, 0.16340572f, -0.03122673f, 0.18938757f, 
    0.12249771f, 0.13881861f, -0.05150742f, -0.03567028f, -0.01019743f, -0.02864756f, 0.11014318f, 0.08089784f, 
    0.14894582f, 0.09798127f, -0.11792287f, -0.10581835f, 0.12792931f, 0.19051199f, 0.13614011f, 0.00186464f, 
    -0.02265584f, -0.01818129f, 0.15528910f, 0.21759139f, 0.06252169f, 0.24962595f, -0.12050050f, 0.03764449f, 
    0.17592716f, 0.01094818f, 0.08441271f, -0.00443468f, -0.17673466f, 0.07444923f, -0.02235239f, 0.00007438f, 
    0.07553201f, -0.14175680f, 0.21438546f, 0.11185171f, 0.13235544f, 0.01048025f, 0.03730657f, 0.08869816f, 
    0.05340444f, 0.17940630f, 0.08533168f, 0.17152584f, 0.00216060f, -0.39960971f, -0.13905853f, 0.15053499f, 
    0.11919755f, -0.08774307f, -0.13982776f, -0.00755654f, -0.01208328f, -0.12754163f, 0.09190951f, 0.11384664f, 
    -0.04520671f, -0.14876708f, -0.28411829f, 0.23655413f, 0.21146397f, -0.04099124f, 0.05296262f, -0.14412376f, 
    0.06289992f, 0.16459461f, -0.00675707f, 0.09217443f, -0.12375419f, 0.04239213f, -0.14052308f, 0.03717898f, 
    0.25407913f, -0.15575631f, -0.19881156f, -0.14837669f, -0.00347765f, -0.19230041f, -0.42929062f, -0.54277974f, 
    -0.01106382f, -0.10413247f, 0.24199319f, -0.11671107f, 0.29518315f, 0.08199761f, -0.18538216f, 0.17342162f, 
    -0.04221266f, 0.18742286f, 0.14029466f, 0.13995425f, -0.18836474f, -0.30233064f, -0.24306914f, 0.02167789f, 
    0.28518236f, 0.06342369f, -0.41530633f, 0.25281116f, 0.09242123f, 0.08690298f, 0.10089250f, -0.09057818f, 
    -0.39715597f, 0.03353946f, -0.43806934f, -0.16949026f, -0.02259830f, 0.08623905f, 0.06438809f, -0.21919228f, 
    -0.02992558f, 0.03296005f, 0.00563208f, -0.08045662f, 0.34715682f, 0.41500026f, 0.49044994f, 0.17791413f, 
    0.07114508f, -0.25689721f, 0.10976450f, -0.08127499f, 0.15830542f, 0.08980146f, 0.01160949f, 0.35528508f, 
    -0.08861049f, 0.09762245f, -0.33064473f, -0.06490998f, -0.19268999f, 0.14983703f, -0.01204733f, 0.04528371f, 
    -0.07695638f, 0.02427587f, 0.07519721f, 0.04615008f, -0.38271466f, 0.14375845f, -0.09455215f, -0.11771150f, 
    0.02627822f, 0.27815315f, -0.05514532f, -0.24827161f, 0.12342419f, -0.04912457f, 0.00858959f, 0.06395264f, 
    0.20706381f, 0.07638878f, 0.19008628f, -0.04290639f, 0.04597150f, 0.11502438f, 0.22354572f, -0.16491976f, 
    0.19799544f, 0.11350185f, 0.02376476f, 0.07270855f, 0.01155482f, 0.25597975f, -0.01359644f, 0.24510708f, 
    0.14259395f, -0.08380389f, 0.24608941f, -0.05063659f, -0.02929061f, 0.11400890f, 0.05711315f, -0.14947614f, 
    -0.10841717f, 0.19614750f, 0.04039828f, -0.08280699f, 0.12885073f, 0.18655713f, 0.14935037f, 0.03003356f, 
    0.02012385f, 0.07673698f, 0.05020772f, 0.09181287f, -0.35646510f, -0.29908377f, -0.43147907f, -0.35145408f, 
    -0.00801510f, 0.04693452f, 0.07625136f, 0.05283356f, -0.00329912f, -0.00145654f, -0.03588147f, -0.09009603f, 
    0.49960381f, -0.29116070f, 0.38665166f, 0.48666167f, -0.03140260f, -0.02253666f, -0.04912378f, -0.02618397f, 
    -0.02547011f, 0.16480599f, -0.06620678f, -0.07842071f, -0.20696172f, -0.43150824f, -0.29212993f, -0.11703815f, 
    -0.15580063f, 0.02875496f, -0.00557334f, 0.10258079f, 0.05110744f, 0.02509069f, -0.06592219f, -0.01909630f, 
    -0.06114537f, 0.17204885f, 0.19126722f, 0.04222368f, -0.03643831f, 0.02746125f, -0.07615901f, -0.07082687f, 
    0.08336598f, 0.14453404f, 0.14004235f, 0.13151927f, 0.03681807f, 0.44889703f, 0.16130406f, 0.01448694f, 
    0.04307269f, 0.02475868f, 0.10592528f, 0.01445173f, -0.20557246f, 0.04961672f, -0.20273431f, 0.05944801f, 
    -0.25086877f, -0.17538324f, -0.02175873f, -0.02967906f, -0.10991647f, 0.02352685f, -0.01130256f, 0.10321852f, 
    0.22243804f, -0.08412945f, -0.04254877f, 0.09018906f, 0.00374036f, -0.04280809f, -0.01081655f, 0.06723324f, 
    -0.09573255f, -0.19465628f, 0.03047591f, 0.09308977f, -0.16311184f, 0.01032698f, 0.02339021f, 0.01458638f, 
    0.27561805f, 0.25763148f, 0.25566822f, -0.06503306f, -0.15925014f, 0.08752531f, -0.05239586f, -0.01072092f, 
    -0.00955483f, 0.02630258f, 0.18400845f, -0.08210654f, 0.05405023f, -0.08312775f, 0.18096165f, -0.01569678f, 
    -0.13404983f, 0.00390460f, -0.00248879f, -0.00640727f, -0.08836225f, 0.10989498f, -0.06103611f, 0.15894951f, 
    -0.34041035f, 0.37208840f, -0.29872453f, 0.21324922f, -0.03943549f, -0.08307688f, 0.08892206f, 0.22044544f, 
    -0.00499425f, -0.07603613f, -0.02067936f, 0.01252672f, 0.57484233f, 0.12572557f, -0.15821838f, -0.57483900f, 
    0.08453900f, 0.01290845f, 0.04509778f, -0.08339228f, 0.14106558f, -0.07416179f, 0.06895141f, -0.03986255f, 
    0.08660302f, -0.23057634f, -0.05133862f, 0.13232733f, 0.04915759f, -0.09933568f, 0.17980270f, 0.30372393f, 
    -0.03851748f, 0.01142204f, 0.14365649f, -0.02993772f, 0.13141058f, 0.00856171f, 0.23705834f, -0.23641895f, 
    -0.10794261f, 0.00608496f, -0.23268741f, -0.21158375f, 0.18321469f, 0.07124297f, 0.24141634f, -0.02134923f, 
    0.28751504f, 0.12022852f, 0.45061737f, -0.21322726f, 0.05100159f, 0.09972899f, -0.00788641f, -0.13576101f, 
    0.06414726f, 0.09191120f, 0.17277831f, 0.12651686f, -0.35182258f, 0.06659424f, -0.16769058f, -0.30773041f, 
    0.06566816f, -0.12953861f, -0.10463236f, 0.00772133f, 0.08566683f, 0.02803160f, -0.22612870f, -0.00712262f, 
    0.22025697f, 0.31107062f, 0.30219474f, -0.24456674f, -0.05791022f, -0.07695282f, 0.00913184f, 0.03235805f, 
    -0.10402077f, -0.11248116f, -0.09173873f, -0.05569828f, 0.34719956f, 0.04655173f, 0.21501510f, -0.23700798f, 
    0.02154347f, 0.15800714f, -0.06885408f, 0.37894893f, 0.01224476f, 0.03123022f, 0.01979165f, -0.09466749f, 
    -0.26645434f, 0.06618564f, 0.20977682f, 0.04976125f, 0.00060018f, 0.03475387f, -0.21541668f, 0.15166579f, 
    0.10163582f, -0.01565645f, -0.06005923f, 0.09582398f, 0.31704858f, 0.02177144f, 0.34204647f, -0.18973926f, 
    0.01070473f, 0.03081352f, 0.11651477f, 0.21373758f, 0.04954415f, -0.09375346f, 0.01236937f, 0.12642862f, 
    0.35442331f, -0.18471576f, 0.20469242f, 0.02286866f, 0.06149123f, 0.10373543f, -0.07459924f, -0.09902075f, 
    0.26784682f, -0.11984622f, -0.01727449f, 0.23346777f, 0.37670502f, 0.03133881f, -0.00676105f, -0.17949843f, 
    -0.03781156f, 0.07837249f, -0.05953989f, -0.08730311f, 0.04951185f, 0.04777595f, -0.08271026f, -0.01667274f, 
    0.06390212f, 0.04074158f, 0.01558159f, -0.42212296f, 0.16425429f, -0.28996503f, -0.08725166f, 0.05452757f, 
    0.01822297f, -0.01369910f, 0.25736615f, 0.10413983f, 0.23690931f, -0.09086644f, -0.01821460f, 0.15120231f, 
    0.02542564f, 0.01000183f, 0.13206121f, -0.19776337f, -0.11359034f, -0.14757007f, -0.20101264f, -0.01760832f, 
    0.72552758f, -0.05757409f, 0.29975054f, 0.00648858f, -0.12348529f, -0.00935211f, -0.01717888f, 0.06315396f, 
    -0.04129771f, -0.01991361f, -0.09230377f, -0.09021807f, 0.12068391f, -0.10465599f, 0.24389404f, 0.13201608f, 
    0.05398611f, -0.04617976f, 0.06966489f, 0.07849079f, 0.08814603f, -0.00563454f, 0.05906266f, 0.17537495f, 
    -0.00984623f, -0.03045865f, 0.05930078f, 0.03596509f, -0.04229471f, -0.05496637f, -0.02763395f, -0.03617859f, 
    0.02674453f, -0.00363556f, -0.01089657f, -0.03428461f, 0.03307316f, -0.01874007f, -0.06814772f, -0.07818121f, 
    0.01605344f, 0.04505326f, 0.06015465f, -0.01716589f, -0.04560361f, -0.05336815f, -0.01240918f, -0.07102010f, 
    0.05493235f, -0.01245177f, 0.04333007f, -0.05126045f, 0.03344917f, 0.00375497f, 0.02237037f, 0.03730649f, 
    -0.01123227f, -0.02129066f, -0.03034418f, -0.04632655f, -0.02622959f, 0.05758501f, 0.05892065f, -0.01883939f, 
    -0.04574266f, -0.03557868f, -0.05719822f, -0.03819142f, -0.02229378f, 0.03760788f, -0.04849774f, -0.05209726f, 
    0.05839808f, 0.03624734f, 0.03878836f, -0.04856123f, -0.07077456f, -0.00492997f, 0.04435463f, 0.04272728f, 
    0.02262021f, 0.04406343f, -0.03323740f, -0.06455474f, -0.03773801f, 0.00635128f, -0.00230627f, -0.02469679f, 
    -0.07924141f, 0.04594994f, -0.00761420f, 0.02301662f, 0.02500206f, 0.04829795f, -0.04192144f, -0.06508312f, 
    0.04431313f, 0.01675696f, -0.00233452f, -0.06235057f, -0.06058935f, -0.01208353f, 0.01738788f, -0.01181541f, 
    -0.00919490f, -0.04337963f, -0.05387901f, -0.05894479f, -0.03027717f, -0.06800856f, -0.04804724f, 0.05623987f, 
    0.06480844f, -0.00826429f, -0.04942910f, -0.02999705f, -0.02639238f, 0.05125713f, 0.02868582f, -0.04595177f, 
    -0.05749962f, 0.06297969f, -0.05404695f, 0.07348461f, 0.03212509f, -0.07632353f, 0.02813687f, -0.05289834f, 
    -0.03338306f, -0.06586245f, 0.01278311f, -0.03678031f, 0.03227805f, -0.05212155f, 0.05963857f, -0.03960107f, 
    -0.05768077f, 0.05882468f, -0.04959191f, -0.06517419f, -0.05226862f, -0.02903740f, 0.01287307f, 0.00027476f, 
    0.02443291f, -0.06641398f, 0.06024316f, -0.03284682f, -0.00501005f, 0.03390856f, -0.02750571f, 0.05529419f, 
    0.04107186f, -0.07259849f, -0.01697739f, -0.01668699f, -0.01119577f, 0.03489198f, -0.06855694f, -0.03581275f, 
    0.05461068f, -0.02200883f, 0.01592268f, 0.03334083f, -0.07940667f, -0.04706730f, 0.04063261f, -0.06520123f, 
    0.03919752f, -0.01572106f, 0.02599420f, 0.05705210f, 0.04936970f, -0.02519554f, 0.05831722f, -0.03992315f, 
    -0.04149004f, -0.07099653f, 0.00097418f, -0.05323737f, 0.05282328f, -0.06140719f, 0.00819757f, 0.06003519f, 
    0.03458360f, -0.00405844f, 0.05563842f, -0.07342692f, 0.04110294f, -0.00664840f, -0.04299832f, 0.01787524f, 
    0.02275559f, 0.03468420f, -0.04331166f, -0.07427696f, 0.02272945f, 0.04787231f, -0.01977476f, 0.04894366f, 
    -0.06080809f, -0.05596195f, -0.06648713f, -0.03885395f, -0.03543988f, -0.05836092f, -0.06239111f, -0.07990689f, 
    0.02954173f, 0.04152951f, -0.02513656f, 0.02322173f, 0.01969403f, -0.02576226f, 0.01866518f, -0.04739152f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.27411294f, 0.21376881f, -0.03662470f, -0.14931023f, -0.19607349f, 0.20166627f, 0.01406142f, 0.35384235f, 
    -0.05147538f, 0.18008310f, -0.04763028f, -0.00084179f, 0.17393126f, 0.20916745f, 0.01649319f, 0.09893790f, 
    -0.08279882f, 0.10464648f, 0.04973518f, 0.00028588f, -0.07636946f, 0.02182208f, 0.13665922f, -0.04724209f, 
    0.00327976f, -0.06234512f, -0.00110652f, -0.04605341f, -0.04121381f, 0.19642951f, 0.08295685f, -0.05660556f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.04092330f, -0.42780313f, -0.57486516f, 0.31912968f, 0.40702412f, -0.43930802f, 0.12875058f, -0.24466114f, 
    0.18846624f, -0.01165045f, -0.16855389f, -0.43305022f, 0.26033494f, -0.32860693f, -0.21995191f, 0.28936404f, 
    0.18540075f, -0.15067165f, 0.03351419f, 0.34912452f, 0.10381792f, -0.85195637f, -0.93488884f, -0.14822918f, 
    -0.20438230f, -0.00544589f, 0.16268247f, 0.10530784f, 0.29145196f, -0.10890315f, 0.27627444f, 0.06125238f, 
    0.39924368f, 0.09576137f, 0.08778687f, -0.22311883f, -0.00717446f, -0.33058527f, -0.13086356f, 0.44242522f, 
    -0.11214378f, 0.30403453f, -0.55580610f, -0.26792708f, 0.07164906f, 0.13183047f, 0.08134840f, -0.29042071f, 
    0.24947813f, 0.06428327f, -0.26209989f, 0.73292083f, -0.13283929f, -0.24594592f, -0.61169708f, -0.25652561f, 
    -0.00474975f, -0.16580977f, 0.07391204f, 0.07164949f, -0.75697893f, 0.30959669f, 0.21581726f, -0.12847072f, 
    0.05979316f, -0.01697187f, -0.20127322f, 0.49652907f, -0.93676353f, 0.65880561f, -0.13922545f, 0.21048288f, 
    -0.15024760f, -0.25835809f, -0.04882296f, -0.10435771f, 0.13983449f, 0.09037910f, -0.20505902f, -0.26941991f, 
    -0.30287316f, -0.75313503f, -0.00041542f, -0.71479505f, 0.02506222f, -0.18874665f, 0.20533189f, 0.23360075f, 
    -0.22177246f, -0.06854863f, 0.04531318f, -0.10551380f, -0.12799048f, 0.34483910f, 0.21062547f, -0.07345521f, 
    -0.18717901f, -0.45570523f, 0.25114343f, 0.38829672f, -0.05233285f, -0.07239401f, 0.17114909f, -0.53492188f, 
    0.28073221f, -0.33315468f, -0.04945078f, 0.21507818f, -0.12509580f, 0.02385346f, 0.16769542f, -0.25481373f, 
    0.30896109f, -0.68547881f, -0.38949555f, -0.42873687f, -0.12418860f, -0.09794436f, 0.12238313f, 0.27546942f, 
    0.54739875f, -0.11295177f, 0.11526784f, -0.04920297f, 0.49404973f, -0.02926310f, -0.28301549f, -0.00035186f, 
    -0.44229826f, -0.00555494f, 0.30215240f, -0.14671217f, 0.31299245f, 0.28143531f, 0.00319523f, -0.48239174f, 
    -0.12485271f, 0.09353469f, 0.41105700f, -0.40780962f, 0.01976532f, 0.05424308f, -0.26188263f, -0.04875746f, 
    0.09844164f, 0.07630931f, -0.04436944f, -0.01508754f, 0.08140111f, 0.05625607f, -0.13956945f, -0.05370867f, 
    0.23194157f, -0.12251673f, -0.18506683f, 0.07228538f, -0.13680929f, -0.24747859f, 0.24976115f, 0.05697335f, 
    0.10781111f, -0.22391112f, -0.29470983f, -0.63792032f, -0.29852194f, 0.17907079f, -0.09471270f, 0.23614432f, 
    -0.07278410f, 0.19009039f, 0.26050955f, -0.05270123f, 0.23098038f, 0.09031589f, 0.21335471f, 0.54876125f, 
    -0.07600361f, -0.00781010f, -0.02678590f, 0.16836886f, 0.12165982f, -0.12406497f, 0.15438978f, -0.28311142f, 
    -0.51032346f, 0.03627934f, 0.11014989f, 0.06295867f, 0.14853215f, -0.72261339f, 0.09766228f, -0.05538642f, 
    -0.41544786f, 0.23181039f, -0.44902977f, -0.48931873f, 0.04742149f, 0.39868379f, 0.15802164f, -0.05896342f, 
    0.03135853f, -0.33880350f, -0.38384885f, -0.63106960f, -0.42005980f, -0.31703219f, 0.31444162f, -0.21061130f, 
    -0.96778166f, 0.37304202f, 0.14817622f, -0.75441897f, 0.03208901f, 0.18877825f, 0.38138583f, 0.37691927f, 
    -0.53552061f, 0.01362754f, -0.07663953f, -0.04017019f, 0.44513145f, 0.29172853f, -0.06262831f, 0.03654451f, 
    -0.01203461f, -0.59787923f, 0.28654277f, 0.31112495f, 0.13202113f, -0.71663404f, 0.11452907f, -0.13752501f, 
    -0.28164622f, -0.07519419f, 0.27226841f, 0.38569558f, -0.18959460f, -1.03544712f, 0.17378882f, -0.45427555f, 
    -0.16606656f, -0.20624763f, -0.69322532f, -0.08143901f, 0.05273817f, 0.36462048f, 0.45150003f, -0.14798194f, 
    0.06801420f, 0.16716607f, 0.10992669f, -0.03330660f, -0.28533259f, 0.18958169f, 0.16370274f, -0.05339571f, 
    0.42580786f, -0.49851066f, -0.25235358f, -0.76461542f, -0.87463135f, -0.33082071f, -0.16589455f, -0.12582073f, 
    0.28304932f, -0.15523446f, -0.40704444f, 0.56752294f, 0.38361934f, -0.26661357f, 0.14568624f, -0.09111643f, 
    -0.41492957f, 0.15444490f, -0.51157314f, -0.72220713f, -0.09228344f, -0.10677776f, -0.07080033f, 0.31698132f, 
    0.54568160f, 0.04987048f, 0.11362857f, 0.03540537f, -0.26371273f, 0.10120620f, -0.39429110f, -0.11997674f, 
    0.17276053f, 0.16546097f, 0.25310487f, -0.05129393f, -0.25245652f, -0.31825829f, 0.14799398f, -0.35869992f, 
    -0.86577636f, -0.70663792f, 0.42611641f, 0.07475540f, -0.73096943f, 0.22474453f, -0.31408566f, 0.34438661f, 
    -0.11770342f, 0.20245163f, 0.55369759f, -0.19708501f, 0.01188739f, -0.07101799f, -0.05885346f, -0.55501318f, 
    -0.16318464f, 0.10923478f, -0.01342937f, -0.08064885f, 0.04832297f, 0.12002423f, 0.34000546f, -0.11495235f, 
    -0.48939529f, 0.09535361f, 0.01608807f, -0.47429326f, 0.46412989f, 0.29494694f, -0.04495207f, -0.07580201f, 
    0.40774989f, 0.26406616f, -1.12727356f, 0.21365754f, -0.14721295f, 0.27293870f, -0.16972832f, 0.51474965f, 
    0.11892069f, -0.33102721f, 0.21303876f, -0.42060086f, -0.11071216f, -0.00758126f, 0.07411931f, 0.00305707f, 
    0.22970469f, 0.03661698f, -0.09860081f, 0.11985892f, -0.85843652f, 0.24899966f, -0.54048562f, 0.07968099f, 
    0.07195203f, 0.50474375f, 0.28972659f, 0.27879566f, -0.38728547f, -0.23783977f, -0.11492850f, -0.07818804f, 
    0.34407806f, -0.36761922f, 0.28099081f, 0.01629143f, 0.26654240f, 0.25451237f, -0.04629021f, -0.72678673f, 
    -0.47936422f, 0.20545720f, -0.11653945f, -0.21370991f, -0.12427187f, 0.15363339f, -0.49091506f, 0.36873111f, 
    -0.80898529f, -0.17294002f, -0.03037840f, -0.03067059f, -0.02515923f, -0.39783061f, -0.61159611f, -0.14972523f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.04698706f, 0.08182745f, 0.17883921f, -0.21189339f, -0.04792844f, 0.10871060f, 0.09416869f, -0.18713735f, 
    0.10660890f, 0.11205433f, 0.12522009f, -0.10276141f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
