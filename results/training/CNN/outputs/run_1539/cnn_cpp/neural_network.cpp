#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.28329563f, 0.20852153f, -0.17766759f, 0.13754234f, 0.35350677f, 0.20521298f, -0.19685459f, -0.65697354f, 
    -0.37352023f, -0.09733306f, 0.27423504f, 0.31912255f, 0.27730310f, -0.24475010f, -0.39834636f, 0.26193553f, 
    0.20989931f, 0.20331685f, 0.09844690f, 0.38674060f, -0.11020116f, 0.13718086f, -0.33286646f, -0.27735153f, 
    -0.36579660f, 0.03067511f, -0.74330813f, -0.14803787f, 0.52898729f, 0.58743137f, -0.31496242f, 0.92163748f, 
    -0.72147804f, -0.44687381f, -0.09101301f, 0.11707436f, -0.25669852f, -0.14950436f, -0.09396233f, -0.07657424f, 
    -0.08956048f, -0.38594031f, -0.06604275f, 0.39402473f, -0.01938945f, 0.14720632f, -0.33527204f, 0.20992909f, 
    -0.10872020f, -0.03504786f, -0.65890950f, 0.28359824f, -0.01776269f, -0.28095636f, -0.14197159f, -0.27432960f, 
    0.12341779f, 0.47124952f, 0.25803566f, 0.15402216f, -0.17926231f, -0.03229694f, 0.38336992f, -0.24531241f, 
    0.01919728f, -0.53639978f, -0.26087627f, -0.29170120f, -0.00268732f, 0.22095637f, 0.29796374f, 0.10717502f, 
    0.29298571f, 0.24869001f, 0.21848288f, -0.95423400f, 0.35254174f, 0.55028301f, 1.00705540f, 0.43332684f, 
    -0.28264782f, -0.87805092f, -0.44376308f, 0.17264809f, 0.12867208f, -0.20536974f, -0.13142997f, -0.15743789f, 
    0.21073528f, 0.46508089f, -0.12317324f, 0.01971898f, -0.16371165f, -0.23068024f, 0.32065466f, -0.11392770f, 
    0.06569184f, -0.02446431f, 0.17840387f, -0.17921221f, 0.17247412f, -0.49700621f, -0.07169896f, 0.10646285f, 
    0.44792417f, -0.02038805f, -0.17773448f, -0.28286228f, -0.47949845f, -0.64011180f, -0.10829638f, -0.11790396f, 
    0.79650718f, -0.50182539f, -0.09818776f, -0.08299867f, 0.26027369f, -0.00441021f, 0.09286757f, 0.20381203f, 
    -0.38674074f, -0.03600212f, -0.24970293f, 0.01350380f, 0.32698572f, -0.37761444f, -0.64483267f, 0.15594226f, 
    0.26402435f, 0.04709408f, 0.02896260f, -1.14947140f, -0.82857621f, 0.15184480f, -0.11305669f, 0.22790383f, 
    0.15935068f, 0.26017186f, 0.65573460f, -0.39059958f, -0.16374204f, -0.09977376f, 0.07575133f, -0.62492877f, 
    -0.36642858f, -0.08417398f, 0.07037237f, -0.17569724f, -0.03549577f, -0.30459118f, -0.60935235f, -0.02953865f, 
    -0.25308394f, -0.78739911f, -0.80661911f, -0.02689986f, 0.19432087f, -0.03189750f, 0.08013115f, 0.48241052f, 
    -0.05964421f, 0.45398712f, -0.29477313f, -0.21440804f, -0.45931309f, -0.09834360f, 0.32462963f, -0.38703319f, 
    -0.33805591f, 0.10772030f, -0.16361950f, -0.18383849f, -0.33006859f, 0.25074655f, 0.04880911f, -0.62599796f, 
    -0.48324820f, -0.92153919f, -0.65955883f, -0.57484454f, 0.70118409f, 0.51654136f, 0.24420664f, -0.62370449f, 
    -0.25941908f, -0.19190092f, -0.29880723f, -0.26437113f, -0.14647211f, 0.12199355f, 0.06940379f, 0.26250994f, 
    -0.13987866f, -0.31532073f, -0.16978683f, 0.05917827f, -0.22750267f, -0.10804179f, 0.25552872f, 0.02672429f, 
    -1.05443311f, -0.73728001f, -0.90900171f, -0.15136696f, -0.10842475f, 0.55936122f, 0.44452521f, -0.02061916f, 
    0.32477498f, 0.84348100f, 0.28339919f, 0.12920229f, 0.23917431f, 0.06130916f, 0.05321606f, -0.10720850f, 
    0.10258894f, -0.05369208f, -0.09475219f, -0.19177237f, -0.09050338f, 0.17342125f, 0.05182599f, 0.04842895f, 
    0.00178827f, -0.03757189f, -0.47393823f, -0.33395892f, -0.38045231f, -0.26409915f, 0.00401979f, -0.44575733f, 
    -0.67379683f, -0.61837280f, -0.52006412f, 0.29183757f, 0.26078561f, 0.44667384f, -0.21086463f, -0.25312379f, 
    -0.25898311f, -0.18074811f, -0.04307995f, 0.11949112f, -0.06141793f, 0.29579240f, 0.04352068f, -0.03177192f, 
    0.33423370f, 0.44318524f, -0.62645727f, -0.24066690f, 0.00139098f, 0.23265876f, 0.43778396f, 0.26408035f, 
    0.63078362f, 0.46462187f, -0.50895900f, -0.46460649f, 0.23667851f, -0.08399135f, -0.01092751f, 0.24395660f, 
    -0.48441049f, -0.01659066f, 0.23939180f, -0.22891925f, -0.31541115f, 0.19410440f, 0.14206865f, -0.20696393f, 
    -0.12219545f, 0.24678960f, 0.18098849f, 0.85112435f, -0.53193682f, -0.47047624f, -0.92974311f, -0.60313708f, 
    0.22463505f, -0.04100237f, 0.36825109f, 0.06518713f, 0.05600326f, -0.04705631f, 0.22085500f, 0.07902670f, 
    -0.19660690f, 0.05859593f, -0.28744176f, -0.11744171f, -0.18863624f, -0.33526349f, -0.31898534f, -0.38428178f, 
    0.05363208f, -0.14624970f, -0.39661705f, -0.44354165f, 0.25732982f, -0.56696332f, -0.28807127f, -0.08253800f, 
    -0.46463832f, -0.82948273f, -0.71917963f, -0.53768629f, -0.23456246f, 0.12534492f, -0.09761241f, -0.35600963f, 
    -0.16400395f, 0.03839459f, 0.34669104f, -0.20601285f, -0.05421215f, -0.16699117f, 0.13038583f, 0.03618814f, 
    -0.11735614f, -0.18670298f, -0.23893291f, -0.29736829f, -0.35686514f, 0.65645051f, -0.26369935f, -0.39920947f, 
    -0.47431460f, -0.71767998f, 0.77685803f, -0.63992125f, -0.02012003f, 0.05353332f, -0.25928855f, 0.26395771f, 
    0.14149907f, 0.11360908f, 0.05300262f, 0.04716766f, 0.23251179f, -0.09962744f, 0.23092161f, 0.31003049f, 
    -0.01584585f, 0.07600716f, -0.03016335f, 0.33198375f, -0.33345509f, -0.08535013f, -1.20726895f, -0.21765706f, 
    0.31078130f, -0.93602610f, -0.67231715f, 0.24697527f, -0.03443057f, -0.47905609f, -0.18895672f, 0.08122224f, 
    -0.31926152f, -0.32798773f, -0.33687627f, -0.60060376f, -0.16392834f, 0.12492434f, -0.06665198f, -0.32643440f, 
    0.06017312f, -0.24234863f, 0.01909111f, 0.01579764f, 0.12957898f, -0.16310681f, 0.01452100f, 0.49290478f, 
    0.60409689f, 0.56645715f, -0.26466906f, -0.05423629f, 0.05656625f, 0.04215657f, 0.24003331f, 0.07555754f, 
    -0.33851969f, -0.10576160f, -0.29193294f, -0.02611054f, 0.29901513f, -0.10820270f, -0.00058688f, -0.07637548f, 
    -0.15208180f, -0.13282850f, 0.02475493f, -0.17047840f, -0.25235027f, -0.31886294f, -0.34226951f, -0.43178785f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.12749048f, 0.44720268f, 0.20144041f, 0.25086460f, 0.23846596f, 0.07569200f, 0.10524437f, -0.15263100f, 
    0.20746228f, 0.33494473f, 0.63938874f, 0.09441539f, -0.24802911f, 0.06940841f, -0.29282817f, 0.06941389f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.02440458f, -0.09230049f, 0.09640280f, -0.28399733f, 0.02110851f, 0.08523545f, 0.19644469f, 0.07315422f, 
    0.20654117f, 0.05005112f, 0.13171302f, -0.00673930f, -0.16344208f, 0.16380674f, 0.10609821f, 0.33534390f, 
    0.04046803f, 0.06999403f, 0.09331001f, 0.09374919f, 0.10640815f, 0.12478188f, -0.15371841f, 0.00870857f, 
    0.10758077f, -0.32748839f, -0.03180636f, 0.05877011f, -0.03342626f, -0.01989058f, -0.16690189f, -0.08437292f, 
    0.14816374f, 0.09987082f, 0.10951307f, -0.02192194f, 0.48428878f, -0.41507626f, 0.21153732f, 0.12016909f, 
    -0.09179574f, 0.26285875f, 0.16224831f, -0.05426463f, 0.08080112f, -0.12809230f, -0.01950284f, 0.06253342f, 
    0.02268872f, -0.04023689f, 0.45866030f, 0.14291964f, 0.15439318f, 0.15239286f, -0.04988703f, 0.13214941f, 
    -0.15845579f, 0.00650210f, 0.04766571f, 0.11950097f, 0.17181282f, -0.21405742f, 0.38407207f, 0.09257972f, 
    0.00801834f, 0.20825869f, -0.09183949f, -0.23170589f, 0.07226697f, 0.18999702f, -0.15869029f, -0.00018255f, 
    -0.19072761f, -0.11506910f, 0.03214787f, 0.09195261f, -0.00789897f, -0.16197154f, 0.10628991f, 0.13165757f, 
    0.10589707f, 0.11893701f, 0.11226936f, -0.06093922f, -0.28385013f, 0.03472196f, -0.41237038f, -0.02970094f, 
    -0.00357253f, -0.06018925f, 0.05146523f, 0.12034754f, -0.06775111f, -0.11607995f, -0.08186237f, 0.10280707f, 
    -0.14279972f, 0.00347626f, 0.15936133f, -0.13524525f, 0.05369196f, -0.01467960f, 0.05092378f, 0.02011561f, 
    0.20450646f, 0.09700174f, -0.03446093f, -0.00994164f, -0.03849676f, 0.05521568f, 0.15455978f, 0.16640079f, 
    -0.07409839f, 0.00674231f, 0.11519767f, 0.09667950f, -0.10098617f, 0.00645996f, 0.00826073f, -0.05567018f, 
    -0.12545733f, 0.33795455f, -0.21807641f, 0.03266371f, 0.04178750f, 0.02991357f, -0.24753840f, 0.08226749f, 
    -0.02733286f, -0.05829335f, 0.08789212f, 0.01427906f, -0.15594839f, -0.01947336f, -0.08224580f, -0.08073547f, 
    0.08866274f, -0.11050359f, 0.00237158f, 0.01236619f, 0.10709433f, 0.01165854f, 0.17971729f, -0.14185388f, 
    0.06480051f, -0.19943118f, 0.08451910f, 0.30115861f, -0.09548507f, 0.00857659f, 0.10509348f, 0.29233822f, 
    0.00668046f, -0.13686866f, -0.05486733f, -0.02569710f, -0.05512791f, 0.10182713f, 0.17957895f, 0.32032764f, 
    0.06741713f, 0.05513595f, -0.01690968f, 0.16376851f, 0.10469992f, -0.11274077f, -0.14097653f, -0.02818930f, 
    -0.34681347f, -0.35444653f, -0.03189037f, 0.04657696f, 0.06894518f, -0.01342929f, 0.17422816f, -0.16513506f, 
    -0.03695919f, -0.04701396f, 0.00316762f, 0.06731049f, -0.16507150f, -0.20392366f, 0.01323896f, -0.02050807f, 
    -0.02369041f, -0.00535416f, -0.04000020f, -0.07033776f, -0.14625120f, -0.03923155f, -0.08904907f, -0.11853945f, 
    -0.06996004f, 0.03835254f, -0.06649690f, 0.02185199f, -0.06469478f, -0.00700242f, 0.01701772f, 0.04804860f, 
    0.04390885f, -0.02555935f, 0.01363248f, -0.06303980f, -0.00424326f, -0.03251569f, -0.06254940f, 0.03703243f, 
    -0.07262105f, -0.01327421f, 0.00631188f, -0.05520234f, -0.02625312f, -0.04923031f, -0.06243901f, -0.06178618f, 
    0.02719346f, 0.03340155f, -0.04165029f, -0.06118165f, -0.06614462f, -0.02083748f, -0.04204195f, 0.04382535f, 
    -0.05972285f, -0.02874272f, -0.03069731f, 0.03690416f, -0.01442670f, -0.01037101f, 0.04305488f, 0.03812824f, 
    0.04339281f, 0.00754202f, -0.03240096f, -0.01368021f, -0.03111541f, -0.00820857f, 0.00020819f, 0.04135039f, 
    -0.05613954f, 0.03806321f, 0.01321651f, -0.03308221f, 0.04475462f, 0.02429598f, 0.04195894f, -0.04272492f, 
    0.04864074f, -0.04341295f, -0.00007315f, -0.01236143f, -0.05699438f, -0.02640864f, 0.05972449f, -0.06443669f, 
    -0.06382401f, 0.04103594f, 0.05005180f, -0.00936742f, 0.00756976f, 0.01803015f, 0.03611502f, 0.06220307f, 
    0.03324128f, 0.05344797f, 0.03135396f, -0.06964254f, 0.02547912f, 0.00348869f, 0.00959282f, -0.02833897f, 
    -0.02791152f, -0.05561540f, -0.06020579f, 0.03249691f, 0.05983701f, -0.01162719f, -0.05530282f, -0.06112118f, 
    -0.00548836f, -0.00348459f, 0.03751037f, -0.01669543f, 0.01301162f, -0.05789934f, 0.03572595f, -0.07513594f, 
    -0.01552484f, 0.02054276f, 0.00497992f, -0.01680582f, 0.05554917f, 0.02275022f, -0.01363080f, 0.04690021f, 
    -0.04878417f, -0.05907609f, 0.01406915f, -0.01262404f, 0.01955384f, -0.06451998f, 0.01286528f, -0.02362489f, 
    -0.05123203f, -0.00316555f, -0.06519441f, 0.02285555f, -0.02600532f, 0.03288295f, -0.00951024f, 0.00790865f, 
    -0.07098038f, -0.07278454f, -0.02723087f, 0.03547472f, 0.03043499f, -0.04234267f, 0.03107352f, 0.02915948f, 
    -0.07499241f, -0.00834081f, 0.02479444f, -0.00246843f, -0.01902033f, -0.07500408f, -0.06593219f, -0.00349146f, 
    -0.04594375f, 0.02626181f, -0.01636586f, -0.01474452f, -0.02636045f, 0.00792718f, -0.00445001f, -0.04671853f, 
    -0.02641907f, 0.01174240f, 0.00836974f, -0.05005736f, -0.00952974f, -0.04578559f, -0.02389654f, 0.07212830f, 
    -0.01764654f, -0.01624795f, 0.02452959f, -0.02417710f, -0.00145940f, 0.02661963f, -0.07880808f, -0.03381475f, 
    0.04799272f, -0.02200396f, -0.03376932f, 0.00590452f, 0.00109395f, 0.01719962f, -0.04299160f, 0.02057448f, 
    0.00287131f, 0.04839388f, -0.03065901f, -0.00645245f, 0.03028804f, -0.06851287f, 0.03406039f, -0.06014829f, 
    0.02483197f, -0.05456229f, 0.06718683f, 0.03247240f, -0.02275804f, 0.02152672f, -0.07614461f, 0.06055564f, 
    -0.01627255f, -0.07860547f, -0.07366475f, -0.00731290f, -0.03028845f, -0.05672528f, -0.02983993f, -0.04362339f, 
    -0.06060641f, 0.07586299f, 0.06273880f, 0.01698273f, -0.09572186f, -0.08744989f, 0.11660011f, 0.12466500f, 
    0.15826565f, 0.06996136f, 0.00223890f, 0.03228874f, -0.28702685f, 0.22193691f, -0.36771527f, -0.05278734f, 
    -0.03481403f, -0.07081695f, 0.07477469f, -0.01507529f, -0.03662731f, -0.06181188f, -0.09678401f, 0.00513315f, 
    -0.21956898f, -0.08989562f, 0.17792277f, -0.03089139f, 0.10342228f, 0.00115508f, -0.03505053f, -0.02269365f, 
    0.03548780f, 0.19754130f, -0.16086590f, -0.04939472f, -0.19113131f, 0.27013654f, 0.27789694f, 0.03912186f, 
    0.16531555f, -0.05993024f, 0.11082961f, 0.03809850f, -0.08461916f, -0.03947738f, -0.06768096f, -0.08563653f, 
    0.23740339f, 0.22158502f, 0.13446254f, -0.11214644f, -0.08388423f, -0.10620318f, -0.08731223f, 0.00043373f, 
    0.05199333f, -0.01074660f, -0.09603000f, -0.05733613f, 0.07574957f, 0.23380774f, 0.11536632f, 0.20134191f, 
    -0.01743148f, -0.03712253f, 0.16996826f, -0.04766556f, -0.12285147f, -0.11225700f, 0.09918396f, 0.12560403f, 
    0.07006516f, 0.12599027f, -0.07845221f, -0.66848296f, 0.14942157f, -0.15647006f, 0.07309569f, -0.03055665f, 
    0.05904260f, 0.20553593f, 0.06131326f, 0.19171582f, 0.31277627f, 0.48247910f, 0.16222157f, -0.16395481f, 
    0.11181114f, 0.19283156f, 0.02940215f, 0.05872827f, -0.01596798f, -0.07506578f, -0.12583350f, 0.01941768f, 
    -0.15347241f, -0.02130842f, -0.22921216f, -0.04801755f, 0.10188250f, 0.00674091f, -0.04825380f, -0.13883737f, 
    -0.01410557f, -0.05578149f, 0.00991451f, -0.05328159f, 0.29309273f, 0.44105130f, 0.10265104f, 0.18623616f, 
    0.05762823f, 0.02857237f, -0.04653755f, 0.18430002f, -0.05794311f, -0.04971331f, -0.11310853f, -0.03406671f, 
    -0.18309419f, -0.08005691f, 0.07692695f, 0.44453835f, 0.26724324f, 0.01404650f, 0.07675085f, 0.07917387f, 
    0.05995576f, -0.01848882f, -0.01268563f, 0.03508651f, 0.15903564f, -0.22395526f, 0.23332213f, -0.31600872f, 
    -0.08759693f, -0.09255945f, -0.03745006f, 0.06781637f, -0.06195304f, -0.05790007f, 0.10573851f, -0.03883345f, 
    0.33861566f, 0.23252101f, 0.21654892f, -0.15366551f, 0.06125959f, -0.35662025f, -0.14245214f, 0.08166664f, 
    -0.04396999f, 0.06332546f, 0.09175356f, 0.12184960f, 0.15582092f, -0.09589201f, 0.03697379f, -0.13508396f, 
    -0.02806085f, 0.10583165f, 0.00770364f, 0.04968445f, -0.06320080f, 0.07730760f, -0.08923389f, -0.07035591f, 
    0.23509702f, 0.60452497f, 0.32473478f, -0.16061758f, 0.00872317f, 0.12090793f, 0.08602121f, -0.00083409f, 
    -0.11314046f, -0.03950074f, 0.03744137f, 0.00063024f, 0.27109385f, -0.00813393f, 0.11155991f, 0.01957723f, 
    -0.04589132f, 0.05689481f, 0.12362014f, -0.05678210f, 0.28974977f, 0.16721642f, 0.10436393f, 0.11470930f, 
    -0.01360086f, 0.03530610f, -0.05602968f, 0.05280222f, 0.04600168f, 0.04051671f, -0.01642266f, 0.04668064f, 
    0.00496508f, -0.01648172f, -0.06330349f, -0.05051878f, 0.00210829f, -0.06883814f, -0.02825915f, -0.02434670f, 
    0.05832251f, -0.02363387f, 0.01454535f, 0.03201974f, 0.00341375f, -0.02601729f, -0.01793762f, -0.03556714f, 
    -0.07758423f, 0.01474684f, -0.06649332f, -0.03894640f, 0.02884185f, -0.07349835f, 0.02380337f, -0.07459771f, 
    -0.04374332f, 0.05116906f, -0.06087325f, -0.00277459f, 0.04096903f, 0.03373635f, 0.04825146f, 0.02581873f, 
    0.00892531f, 0.05892789f, -0.03286253f, 0.01826876f, -0.01181601f, -0.00382554f, 0.04474863f, 0.06282812f, 
    0.04848322f, 0.01211658f, 0.03474062f, 0.03908717f, -0.01665958f, -0.01540052f, -0.06088365f, -0.03967774f, 
    -0.06126204f, 0.00467679f, -0.07438048f, 0.06220892f, 0.04983106f, 0.01244639f, -0.07408987f, -0.02619195f, 
    0.00878425f, 0.00017018f, -0.02425208f, -0.05182061f, -0.03180397f, 0.03956906f, -0.00381825f, 0.05367234f, 
    -0.08121968f, 0.03417809f, 0.00022352f, 0.00927198f, -0.07142238f, 0.01653657f, 0.00699840f, 0.03983175f, 
    -0.03985515f, -0.00279289f, -0.04956416f, -0.02491234f, 0.04921766f, -0.07365183f, 0.00562353f, -0.04141758f, 
    -0.07597904f, 0.06978790f, 0.01479325f, -0.02311687f, -0.01313554f, 0.06522416f, -0.05099795f, -0.07617345f, 
    0.04558479f, -0.00016957f, 0.00545144f, -0.02123044f, 0.00331813f, -0.01793873f, 0.01536153f, 0.05868129f, 
    -0.02962858f, 0.00322145f, 0.03622261f, -0.04330003f, -0.03534683f, -0.05840427f, -0.06574930f, -0.07278402f, 
    0.00795489f, -0.03026623f, 0.05938474f, -0.01888066f, -0.01262559f, 0.00323163f, 0.04694694f, 0.02323696f, 
    0.06483921f, -0.04750871f, -0.00401372f, -0.06970511f, -0.03744765f, 0.03318684f, -0.06414931f, -0.04671444f, 
    -0.00331829f, -0.06101185f, 0.01837861f, -0.05694981f, -0.06528270f, -0.04867453f, -0.01622875f, -0.04563303f, 
    -0.05677804f, 0.06201956f, 0.01514672f, -0.01417142f, -0.07695332f, -0.04505835f, -0.05653663f, 0.01574427f, 
    0.01604264f, -0.06723021f, -0.05754334f, -0.01722618f, 0.07322697f, 0.02999378f, 0.05904701f, 0.03744776f, 
    0.00582004f, -0.07768582f, -0.02795996f, 0.02206582f, -0.04646347f, 0.03411335f, 0.05515542f, 0.02411523f, 
    -0.06504814f, -0.03835618f, -0.05013426f, 0.03027312f, -0.07126287f, -0.00011403f, -0.01118114f, 0.03938511f, 
    -0.06738804f, -0.04154482f, -0.03072448f, -0.06624714f, -0.04166497f, -0.06448003f, -0.01736080f, -0.06201385f, 
    0.05512170f, -0.03586036f, 0.01813677f, 0.06451014f, 0.02717062f, 0.01670630f, -0.04873263f, -0.06684762f, 
    -0.05274822f, -0.00336332f, -0.00192457f, -0.04818615f, -0.04080374f, 0.02521003f, -0.03943755f, -0.05553455f, 
    -0.11575399f, -0.01566873f, 0.09933082f, 0.07866310f, 0.19729246f, 0.27931109f, 0.05330327f, -0.04321063f, 
    0.11320007f, -0.02109510f, 0.02625957f, -0.13460414f, -0.47155997f, -0.32556069f, 0.07416449f, -0.18889706f, 
    -0.06569146f, 0.09115326f, -0.19461830f, -0.07563819f, -0.07389653f, 0.02659392f, -0.08600177f, -0.06818100f, 
    0.05943101f, 0.32792696f, 0.08669835f, 0.14549498f, -0.03986603f, -0.11262094f, 0.02847459f, -0.21539369f, 
    0.06707698f, 0.18415421f, -0.06148442f, 0.00796613f, 0.20373714f, -0.38600942f, 0.00509409f, 0.05158760f, 
    -0.12786534f, 0.36455795f, 0.10602358f, 0.02303974f, -0.06938487f, -0.20224923f, 0.12583877f, 0.05231950f, 
    -0.43017077f, -0.22329810f, -0.16851401f, -0.09609699f, 0.23227316f, 0.01783556f, 0.08466252f, 0.28567764f, 
    -0.00442527f, -0.12321833f, -0.09700388f, -0.01215040f, -0.39293733f, 0.16075334f, 0.03095796f, -0.02463221f, 
    -0.13500963f, 0.12073332f, -0.03143215f, 0.06557957f, -0.07330483f, 0.15068111f, 0.05326810f, 0.09606936f, 
    -0.47384790f, -0.43418887f, 0.15673752f, -0.00164182f, -0.18966860f, -0.17656122f, 0.05745105f, 0.08639988f, 
    0.00846985f, 0.09449939f, 0.23247090f, -0.12999652f, -0.06502213f, -0.37878558f, -0.34462917f, -0.13613677f, 
    0.01098931f, -0.26197219f, 0.07050329f, 0.16079837f, -0.10083092f, 0.10709897f, -0.06696192f, 0.04828351f, 
    0.30600956f, 0.09303790f, 0.15378605f, -0.22139491f, -0.01324760f, -0.00939616f, -0.18713517f, -0.02082596f, 
    -0.03102526f, -0.05758488f, -0.14046937f, -0.04951188f, -0.42830428f, -0.03619332f, 0.03396940f, -0.12568559f, 
    0.01686682f, -0.05966086f, 0.03442823f, -0.05270467f, -0.06628234f, -0.14431787f, -0.00371219f, -0.01363225f, 
    0.00790876f, 0.21021850f, 0.11495934f, 0.30465311f, 0.26709041f, 0.11411656f, -0.00008255f, -0.14518291f, 
    0.05998000f, 0.22254030f, 0.05892282f, 0.11839631f, 0.22826080f, -0.11579585f, -0.10585041f, -0.32521498f, 
    -0.13830741f, -0.11353423f, 0.06900876f, 0.00174826f, -0.13737050f, -0.04676562f, 0.18933493f, 0.07700451f, 
    0.12307529f, -0.18501127f, -0.04985324f, 0.38314509f, 0.01327596f, 0.42307621f, 0.24496308f, 0.08349888f, 
    -0.10139467f, -0.07660276f, 0.10815538f, 0.21463603f, 0.28330839f, -0.01303195f, -0.15169147f, -0.24787825f, 
    0.15620817f, 0.42827824f, 0.14573255f, 0.17509763f, 0.00185073f, -0.16472012f, -0.02194877f, -0.02010756f, 
    -0.34868249f, -0.09971456f, -0.30494535f, -0.44481915f, 0.07365370f, -0.14625607f, 0.11059116f, 0.17677394f, 
    -0.08394311f, 0.00414247f, 0.10330238f, 0.01116393f, 0.20789617f, 0.16095991f, 0.10659969f, 0.25361642f, 
    -0.04119808f, 0.03852028f, 0.08745662f, 0.01694138f, 0.42022294f, 0.30271441f, 0.42198858f, 0.31171256f, 
    -0.02596231f, 0.00010698f, -0.00815590f, -0.14465533f, 0.11947197f, 0.16760448f, 0.14084673f, 0.00582296f, 
    0.08612441f, 0.07496389f, 0.09950545f, 0.06533372f, 0.10013528f, 0.27284041f, 0.00286455f, 0.05205186f, 
    0.00981761f, 0.06658716f, 0.02646863f, 0.13508455f, -0.03144966f, -0.03815624f, 0.00699829f, -0.13540851f, 
    0.43732420f, 0.01670495f, -0.15383771f, 0.11537647f, -0.06253420f, -0.00638061f, 0.02252415f, -0.08412099f, 
    0.10557196f, -0.01154923f, 0.13828653f, 0.00558933f, 0.82569820f, 0.30183747f, 0.34689921f, -0.33822942f, 
    -0.01879335f, 0.17443191f, -0.05775205f, -0.16050917f, -0.04836087f, 0.04069870f, -0.16035059f, -0.04196322f, 
    0.01937145f, 0.10923830f, -0.00336568f, 0.12456923f, 0.19023828f, 0.14083785f, -0.11281308f, 0.03592523f, 
    -0.02801589f, 0.08019006f, -0.00644472f, -0.12257900f, 0.13510114f, -0.04086147f, -0.02033110f, -0.00265354f, 
    0.11515045f, 0.13838948f, -0.10027243f, 0.13406996f, 0.06348629f, 0.13855419f, 0.06074047f, -0.00410177f, 
    -0.04181065f, 0.02611014f, -0.01297293f, 0.10307970f, 0.15748955f, -0.03152737f, 0.06189748f, 0.02146703f, 
    -0.00947430f, -0.00733519f, -0.02346137f, 0.26269421f, -0.17711498f, -0.12819006f, -0.31619555f, 0.25648281f, 
    0.13983965f, 0.02826417f, -0.01788263f, 0.13323563f, -0.04247674f, -0.03248917f, 0.12609221f, 0.15380599f, 
    0.45487556f, -0.28079903f, -0.00775474f, 0.06740214f, 0.16002077f, -0.10213479f, 0.03370236f, -0.02268986f, 
    0.09546596f, -0.00122349f, -0.04623657f, 0.05073688f, -0.04250309f, -0.06489109f, -0.08866945f, 0.11220738f, 
    -0.00032207f, 0.01147137f, 0.11769980f, 0.07632888f, 0.07789999f, 0.13110209f, 0.00181394f, -0.10540264f, 
    -0.03721514f, 0.53458214f, -0.46555281f, -0.26047003f, -0.04303376f, -0.00028829f, -0.23871857f, 0.17392357f, 
    -0.29144412f, -0.17659077f, -0.04122187f, 0.09102174f, -0.40291455f, -0.01825813f, 0.07082817f, 0.30223218f, 
    -0.03890553f, 0.00762576f, 0.07300054f, -0.06921241f, 0.08932410f, 0.12800106f, -0.08316493f, 0.01664608f, 
    -0.18668361f, -0.32498702f, 0.03609973f, 0.09708545f, 0.01617844f, 0.02597531f, 0.17160541f, 0.22124267f, 
    0.02178444f, 0.03352255f, 0.12413702f, -0.01287500f, -0.49967816f, -0.21189551f, -0.02109684f, 0.10636907f, 
    0.17083301f, 0.05394092f, 0.10627680f, 0.02519869f, -0.05014986f, -0.09290332f, 0.04976904f, 0.04494509f, 
    0.13590716f, -0.43417212f, 0.01610979f, 0.22833443f, -0.00152885f, -0.02121205f, -0.15934764f, -0.01856781f, 
    0.05406260f, 0.02820547f, -0.02003679f, 0.06438124f, -0.44775942f, -0.06737353f, -0.05921384f, -0.08234667f, 
    -0.06788167f, -0.10295503f, -0.04861321f, -0.01235912f, 0.04163323f, -0.06432815f, 0.10528131f, -0.01912149f, 
    -0.17340198f, -0.05467322f, -0.20442267f, 0.09024549f, 0.03997644f, -0.08068011f, -0.01076297f, 0.05925215f, 
    0.00038149f, 0.03557216f, 0.10747916f, 0.03267147f, -0.12530792f, 0.37377468f, -0.30714104f, 0.18241189f, 
    0.01006900f, -0.05834143f, 0.11502033f, 0.16255172f, 0.04841714f, -0.05503990f, -0.01422753f, 0.08148383f, 
    -0.16204421f, -0.08998749f, 0.19569953f, -0.18661471f, -0.05215779f, 0.11294682f, 0.00688124f, 0.11464711f, 
    -0.10572305f, 0.10469503f, 0.04083215f, -0.12806308f, -0.79414618f, 0.34588313f, -0.14731777f, 0.05451913f, 
    0.11347921f, 0.04567388f, -0.01277499f, 0.16243720f, -0.02976049f, 0.05873903f, -0.14700833f, -0.17142364f, 
    0.00498174f, 0.08854152f, -0.40309885f, 0.36518157f, -0.00133005f, 0.08239627f, 0.11978111f, 0.09369903f, 
    0.12012998f, -0.03777946f, 0.13644652f, -0.02681034f, -0.06865888f, 0.34211016f, -0.34559560f, -0.08321422f, 
    0.18069158f, 0.00971325f, 0.08070669f, 0.12855224f, -0.12210079f, -0.12269277f, -0.03296621f, 0.14608243f, 
    0.39517242f, 0.03934737f, -0.08755434f, 0.01213923f, 0.21702585f, 0.08752396f, -0.01853654f, 0.05197794f, 
    0.04936999f, 0.08369892f, 0.06377824f, 0.07479747f, 0.34416145f, 0.19801018f, 0.32338321f, 0.09101763f, 
    0.09116230f, 0.08950602f, 0.00150893f, -0.00936612f, -0.05571752f, 0.01968640f, -0.07425315f, -0.18546155f, 
    -0.21259542f, 0.35088950f, -0.01513965f, -0.12651823f, -0.14797954f, -0.13402879f, 0.03051591f, -0.11360443f, 
    -0.12902001f, 0.04668432f, 0.06532679f, 0.00615980f, 0.13330896f, 0.15341660f, -0.01835470f, 0.02123865f, 
    0.16535980f, 0.02798915f, -0.05214156f, -0.00181245f, 0.05348500f, -0.20496577f, -0.04484125f, 0.16796508f, 
    0.15211301f, -0.24829558f, 0.16259679f, 0.01297736f, 0.13311830f, -0.02832133f, 0.16225195f, -0.01781241f, 
    -0.01394115f, 0.04895944f, 0.01220955f, -0.02007921f, 0.27237317f, 0.12575726f, 0.02421509f, 0.02078502f, 
    0.00373991f, 0.04868466f, -0.09493223f, -0.01242344f, -0.08049345f, 0.04934039f, 0.06762968f, 0.13722344f, 
    -0.02970765f, 0.24994349f, -0.01439164f, -0.14618534f, 0.05310283f, -0.01272513f, -0.00721130f, -0.17488560f, 
    0.05075903f, -0.00796788f, 0.06218822f, 0.07622398f, 0.04058878f, 0.06061858f, -0.32512265f, -0.14609063f, 
    -0.07682429f, 0.04941802f, 0.16118033f, 0.05583920f, -0.00476913f, 0.06385894f, 0.01839413f, -0.03700501f, 
    0.53082883f, 0.30395547f, 0.14458700f, 0.05336315f, 0.03772995f, 0.08178911f, 0.11435261f, 0.15811434f, 
    -0.02245678f, -0.05290296f, -0.14449394f, -0.16068354f, 0.26264036f, -0.00606232f, 0.05738829f, 0.02136832f, 
    -0.10491784f, -0.09066645f, 0.01587202f, -0.00819549f, 0.09088762f, 0.02832166f, -0.06297330f, -0.16907465f, 
    0.07341029f, -0.04462516f, 0.05468203f, 0.01264314f, 0.02093838f, 0.09994314f, 0.03888459f, 0.00178150f, 
    0.13456540f, 0.12043208f, 0.06852172f, -0.04595456f, 0.03191857f, -0.14323397f, 0.33926880f, -0.20776118f, 
    0.03642640f, 0.03916278f, -0.15321262f, 0.03845814f, -0.12484822f, -0.00462494f, -0.16622545f, 0.03776939f, 
    -0.14855017f, 0.07348358f, 0.01925241f, -0.01424539f, -0.01917382f, 0.06654577f, -0.08046446f, 0.08430326f, 
    0.13537668f, -0.04158670f, -0.00322330f, -0.04038551f, -0.46453908f, -0.08495832f, -0.18568680f, -0.01405618f, 
    -0.20166993f, -0.05496801f, 0.06128604f, -0.04730781f, -0.08919818f, 0.04859051f, -0.02680564f, 0.15722853f, 
    0.39224464f, -0.07954265f, 0.03185027f, -0.01455872f, 0.11403926f, 0.08729954f, 0.14712404f, 0.17463905f, 
    0.13252917f, -0.03537836f, 0.09799879f, 0.03277947f, 0.17186946f, 0.49061286f, 0.03525861f, -0.11857394f, 
    -0.10647677f, -0.01924168f, 0.14583668f, 0.08951276f, -0.07008690f, -0.04838593f, -0.02729248f, 0.05936251f, 
    0.21214916f, -0.13954288f, 0.09073436f, 0.06384076f, 0.04967966f, 0.07012633f, -0.00615456f, -0.10192492f, 
    -0.14104988f, -0.14396347f, 0.00656357f, -0.13967054f, 0.21279418f, -0.06246090f, 0.04368639f, 0.23629534f, 
    0.05171487f, 0.01423236f, -0.01226423f, 0.03294575f, -0.03948477f, -0.01698874f, 0.02461679f, -0.02067807f, 
    0.02611997f, 0.02594864f, 0.01559724f, 0.26247162f, 0.04935082f, 0.11588036f, 0.10311509f, 0.13636053f, 
    0.13520359f, -0.11618111f, 0.00677558f, 0.01774055f, 0.29485837f, 0.19858934f, 0.09466267f, 0.19167382f, 
    0.01551731f, 0.11007418f, 0.04547578f, 0.18212499f, 0.05371881f, 0.11425666f, 0.09412219f, 0.06606996f, 
    0.00750836f, -0.30670708f, -0.00098293f, -0.16233024f, -0.11432452f, 0.09802257f, 0.02429061f, -0.00866675f, 
    0.04689105f, 0.08603449f, 0.17383401f, -0.05128368f, 0.17127545f, 0.07291992f, 0.10754333f, 0.11755666f, 
    0.06761573f, 0.00037408f, -0.05330455f, -0.04690830f, 0.05058458f, -0.25399843f, -0.09210052f, -0.02599222f, 
    0.07414719f, 0.39703280f, 0.15153657f, 0.15219864f, 0.11191319f, 0.00650713f, -0.10682722f, 0.01665291f, 
    0.02015951f, 0.10967072f, 0.03019058f, 0.05912774f, 0.20201991f, 0.05824083f, 0.02693781f, 0.17544426f, 
    0.17175245f, 0.01645217f, -0.08089799f, -0.08176800f, 0.11422382f, 0.04204869f, -0.04976674f, -0.03160088f, 
    -0.00266305f, 0.07526328f, -0.08702519f, 0.16235788f, 0.07875683f, -0.11169063f, 0.08761965f, 0.07962786f, 
    0.07275891f, 0.05935065f, 0.00945134f, 0.08494420f, -0.32532972f, -0.23789510f, -0.22546425f, -0.03528640f, 
    0.01160014f, 0.00153268f, -0.04337211f, 0.03921292f, 0.01147856f, -0.02567147f, -0.11905866f, -0.14504388f, 
    -0.03466921f, 0.04401835f, -0.02980779f, -0.06560416f, 0.02871703f, 0.05572939f, 0.01655271f, 0.01147773f, 
    0.04408952f, -0.02734975f, 0.04163507f, 0.01461499f, -0.01374169f, -0.05189504f, -0.00115609f, -0.07398795f, 
    0.05533816f, 0.03589100f, -0.04545315f, 0.04766852f, 0.03924737f, -0.07791299f, 0.06083364f, -0.01612970f, 
    -0.05837050f, 0.00782235f, 0.00000830f, -0.03497607f, 0.03962684f, 0.02425105f, -0.04022474f, 0.03848970f, 
    -0.06658269f, -0.08189324f, 0.00043225f, -0.03959473f, -0.02529661f, 0.00866242f, -0.05194753f, 0.04061015f, 
    -0.02945394f, 0.06020956f, 0.03744861f, -0.03340401f, 0.04934929f, -0.03846273f, -0.06877235f, -0.00906705f, 
    -0.01009785f, 0.04607579f, -0.00482178f, -0.04346301f, -0.07654127f, 0.05507636f, 0.00226885f, 0.00406878f, 
    0.05901059f, -0.05901369f, -0.06483006f, -0.02743104f, 0.04011576f, 0.02794218f, -0.07626884f, -0.02195049f, 
    0.00213085f, 0.05163477f, 0.00411227f, 0.04501575f, -0.07293867f, 0.06209503f, 0.02131863f, 0.04240983f, 
    -0.05851307f, -0.02957636f, 0.07322229f, -0.05502693f, -0.05127140f, 0.03714089f, -0.04678845f, 0.05994193f, 
    -0.07442594f, -0.04634361f, 0.02835811f, -0.04805620f, -0.06045805f, -0.04470143f, -0.02584824f, -0.02725589f, 
    0.05878593f, 0.05419124f, 0.04229441f, -0.02306324f, -0.01666249f, -0.01994650f, -0.00859925f, 0.05262636f, 
    -0.05580072f, 0.03649900f, 0.01216968f, 0.03067370f, -0.06572274f, 0.06422642f, 0.05316642f, -0.01193313f, 
    -0.06514376f, -0.06338608f, 0.02153427f, -0.05163339f, 0.06762539f, -0.06009712f, 0.02779280f, -0.05274981f, 
    -0.02079867f, 0.04855447f, -0.03751223f, 0.02773524f, -0.04311403f, -0.04066466f, 0.03714323f, -0.08140857f, 
    -0.07422648f, -0.00488706f, 0.02060974f, -0.06824911f, 0.00010118f, 0.02400302f, -0.04619762f, -0.06802541f, 
    0.02827443f, 0.04318734f, 0.01585219f, 0.01344425f, -0.00673740f, -0.04833773f, 0.01026252f, -0.08017498f, 
    0.06195582f, -0.07293022f, 0.01770149f, 0.03765727f, -0.01895854f, -0.01458769f, -0.02934163f, -0.06750268f, 
    0.00909849f, -0.06365518f, 0.03761571f, 0.02694499f, -0.01695330f, 0.03683625f, 0.05577024f, 0.03407943f, 
    -0.05159479f, 0.01603477f, -0.03329477f, -0.07422513f, -0.00613685f, -0.05078183f, 0.03594138f, -0.04880866f, 
    -0.04766440f, 0.00721170f, 0.01647292f, -0.02801814f, -0.03287235f, -0.02367462f, 0.01985771f, -0.05782224f, 
    0.03323084f, -0.00877624f, -0.03857372f, -0.07157645f, 0.03358439f, -0.06695236f, -0.05310280f, -0.07762030f, 
    0.05582599f, -0.06642690f, 0.00229251f, 0.03059111f, 0.01310841f, -0.06647950f, -0.00758708f, 0.05731447f, 
    0.02306536f, -0.07194855f, -0.05690732f, -0.01315333f, 0.00871583f, -0.05184674f, -0.07505088f, 0.05363866f, 
    0.01447986f, -0.04861962f, -0.00912942f, 0.06381304f, 0.01399900f, -0.01719091f, 0.01550279f, 0.02186719f, 
    -0.01029982f, 0.00763522f, -0.05922677f, -0.01861576f, -0.00322421f, -0.00567384f, -0.02760066f, 0.04945147f, 
    -0.06970970f, -0.04482195f, 0.02455582f, -0.01058087f, -0.03697302f, -0.01273765f, -0.05961607f, 0.02858145f, 
    0.00359701f, -0.08656231f, -0.00249383f, -0.04764444f, -0.08949907f, -0.03094989f, 0.04783548f, -0.00116868f, 
    -0.01315919f, -0.06492132f, 0.01923990f, -0.03689636f, 0.00401853f, -0.00952504f, -0.08218053f, -0.00287049f, 
    0.01373191f, -0.00898782f, 0.02185256f, -0.05839532f, -0.02589568f, 0.01647509f, -0.00099890f, -0.07029719f, 
    -0.06826562f, -0.04680968f, -0.04660480f, 0.00400025f, -0.01141457f, 0.05531378f, -0.00018932f, -0.06611045f, 
    0.04101128f, -0.01804726f, -0.02595558f, -0.07425434f, 0.00472081f, 0.03082597f, 0.05253641f, -0.02803630f, 
    0.01607941f, 0.04522352f, 0.01651744f, -0.04388605f, 0.02344360f, -0.00542359f, -0.01018513f, 0.00722219f, 
    0.02443151f, -0.01307644f, -0.00217028f, 0.01803678f, -0.06448868f, 0.00901773f, -0.00627008f, 0.05876251f, 
    -0.00281841f, -0.04626960f, -0.00801334f, -0.07709982f, -0.04821740f, 0.03833045f, -0.04244083f, -0.08442155f, 
    -0.03351354f, 0.03906668f, 0.03946513f, 0.06014761f, -0.07945167f, -0.02046574f, -0.01874283f, -0.00940274f, 
    0.03244496f, 0.00596977f, -0.05593131f, 0.06581783f, 0.04162070f, 0.00506545f, 0.01414812f, -0.05372174f, 
    -0.05974327f, -0.07944336f, -0.03583669f, 0.03292681f, -0.07584806f, 0.03069437f, 0.04610718f, -0.02617125f, 
    -0.02000559f, -0.10019697f, -0.01236327f, 0.04794337f, 0.00079957f, 0.04567412f, -0.05757119f, 0.06437940f, 
    -0.01437497f, -0.03339521f, -0.03481094f, -0.01783593f, -0.06401064f, -0.03071211f, 0.02954620f, -0.06188012f, 
    0.01182638f, 0.02590986f, -0.07500027f, -0.04224309f, -0.00671857f, -0.04509623f, 0.02068205f, 0.03170523f, 
    -0.01547646f, -0.03873768f, -0.04839770f, -0.04284023f, 0.02222496f, -0.03918589f, -0.02979377f, -0.01404523f, 
    -0.07150481f, 0.00601518f, -0.06524233f, -0.00064436f, 0.05562661f, 0.06093533f, -0.01348901f, -0.00660408f, 
    -0.04072034f, -0.05408712f, -0.01864550f, 0.03377802f, -0.07615926f, 0.03648666f, 0.01167343f, -0.01951627f, 
    -0.04209895f, -0.05391210f, -0.08079550f, -0.04945157f, -0.00309501f, 0.06463061f, -0.02891492f, -0.00940401f, 
    0.06154186f, 0.06429229f, -0.06099179f, 0.04066318f, -0.01789822f, -0.00669449f, -0.03629543f, -0.05169514f, 
    -0.05205542f, 0.03804412f, -0.00860803f, -0.03348673f, -0.06728354f, 0.04740591f, -0.09301963f, -0.05698507f, 
    -0.07958151f, -0.04279336f, -0.05542148f, -0.06749382f, -0.00935454f, 0.03953422f, 0.02092388f, -0.06355065f, 
    0.09090190f, -0.21831425f, 0.02887173f, 0.13730511f, 0.17847227f, 0.20462644f, 0.08212256f, -0.00460244f, 
    0.04854327f, 0.09784914f, 0.01488767f, -0.03712168f, -0.07347953f, -0.44024155f, 0.29854149f, 0.25390288f, 
    0.19731835f, 0.19498158f, -0.06734566f, 0.08802535f, -0.04063219f, 0.05785750f, -0.03149353f, 0.08784524f, 
    -0.15773509f, 0.20688090f, 0.07710584f, -0.09145558f, 0.07781571f, -0.12534139f, 0.04984961f, 0.15050387f, 
    0.16100764f, -0.19689386f, 0.00082395f, 0.03326615f, -0.32190952f, -0.01070484f, -0.45321977f, 0.40634522f, 
    -0.10605855f, 0.21341480f, 0.10476875f, 0.15600105f, 0.02588775f, -0.06235152f, -0.04820294f, 0.01633554f, 
    -0.15911698f, -0.31561944f, 0.00564435f, 0.05017791f, -0.03383623f, 0.07904740f, 0.12196256f, 0.17614278f, 
    -0.01144154f, -0.01524105f, -0.00058232f, 0.06041906f, -0.16749892f, 0.04089250f, -0.12459935f, -0.03456103f, 
    0.01663712f, -0.03558732f, -0.00976310f, 0.06542292f, 0.00922760f, 0.03124708f, -0.00708750f, 0.18095994f, 
    0.00062113f, 0.23719466f, 0.23407909f, 0.08111922f, -0.08861138f, 0.14544716f, -0.02950922f, 0.08694641f, 
    -0.03345331f, 0.02181391f, 0.05787842f, -0.18104511f, -0.03891663f, -0.13345072f, 0.21663034f, -0.00223327f, 
    -0.09704859f, -0.06549194f, -0.03494362f, -0.15367649f, 0.03276164f, 0.04659257f, -0.00720159f, -0.03056637f, 
    -0.17965439f, 0.45797798f, 0.32451791f, 0.16084746f, -0.15788054f, -0.09356272f, -0.09098675f, 0.09715112f, 
    0.09578838f, 0.06212540f, 0.10566134f, 0.10003779f, -0.02624424f, -0.05717728f, -0.00627481f, -0.21089527f, 
    -0.00707718f, -0.13445392f, -0.00921079f, -0.07400841f, -0.04115886f, -0.05197132f, 0.03080943f, 0.02783903f, 
    -0.04494814f, -0.47780681f, 0.63871467f, 0.00281909f, 0.06676079f, 0.06102731f, 0.02125442f, -0.00783169f, 
    0.27016041f, 0.14669237f, 0.18691190f, -0.09104288f, 0.05307675f, 0.38213816f, 0.06523506f, -0.07356977f, 
    0.00821294f, -0.15006746f, 0.01451897f, 0.02705831f, -0.00492762f, 0.12184606f, 0.01708692f, 0.24732046f, 
    -0.00214617f, 0.15639763f, -0.18372175f, -0.14239265f, -0.07691097f, 0.09733593f, -0.04482734f, -0.20615096f, 
    0.03777894f, 0.10182821f, 0.00158457f, 0.09213063f, 0.06547763f, 0.00643095f, 0.09869017f, 0.11280947f, 
    0.09614388f, 0.02321052f, -0.00943204f, -0.10266493f, 0.08314138f, 0.00609811f, -0.01877743f, 0.12638678f, 
    -0.21631765f, -0.09062482f, -0.18407081f, -0.12367412f, -0.15996350f, -0.08134127f, 0.00861907f, -0.13323398f, 
    -0.09884208f, 0.03413719f, 0.08142284f, -0.06397069f, 0.15410875f, 0.14930606f, -0.09676987f, -0.12385024f, 
    -0.02054050f, -0.15771808f, 0.05984677f, -0.01659054f, -0.05427312f, 0.05852653f, -0.05358544f, 0.29145741f, 
    0.05910705f, -0.00111446f, -0.04489499f, -0.03307631f, 0.03813327f, 0.05990405f, 0.01008562f, -0.03859874f, 
    0.03437792f, -0.03209417f, -0.01124494f, -0.03263278f, -0.01609473f, -0.08012884f, 0.04045411f, -0.03742810f, 
    -0.03819761f, -0.05462353f, -0.06460461f, -0.03295041f, 0.00889979f, -0.06349003f, -0.03340472f, 0.00354836f, 
    -0.04244070f, -0.08145563f, -0.07119273f, -0.00071496f, -0.00145360f, -0.01608673f, -0.05679850f, -0.06719543f, 
    0.04510345f, -0.01523300f, 0.05126939f, 0.01040740f, -0.02096695f, 0.04249753f, 0.01886147f, 0.01329297f, 
    0.02385701f, -0.04852556f, -0.05456092f, 0.00632214f, 0.04827830f, -0.02648941f, -0.07724186f, -0.06209036f, 
    -0.02260049f, -0.03338268f, -0.00811294f, 0.05823936f, -0.03256403f, -0.07332702f, -0.03650110f, -0.02825782f, 
    0.02597082f, 0.04741595f, 0.02723254f, -0.03983552f, -0.02089720f, -0.08370616f, -0.03834121f, -0.05279399f, 
    0.06186757f, 0.05055096f, -0.03764207f, 0.04473026f, 0.00619937f, 0.03858804f, 0.03299240f, 0.01912265f, 
    0.03901557f, -0.03460816f, -0.03029096f, -0.07285316f, 0.01447738f, -0.04937630f, -0.04139176f, 0.05278726f, 
    -0.07700398f, -0.06236427f, 0.04413117f, -0.02217273f, -0.07441841f, -0.02468111f, -0.00326128f, 0.04122031f, 
    -0.00063083f, 0.01553583f, 0.04100436f, -0.07072374f, 0.02431006f, -0.06021233f, -0.05804421f, 0.05644803f, 
    -0.00529808f, -0.01042008f, 0.00128396f, -0.02497565f, -0.02328018f, -0.02638245f, 0.05821140f, -0.00951102f, 
    -0.04691468f, -0.04769406f, -0.07062536f, -0.04795206f, 0.05478077f, 0.04718620f, -0.07476274f, -0.00840581f, 
    0.03294845f, 0.04119236f, -0.06286928f, 0.05450246f, 0.00734174f, 0.00611699f, -0.05901745f, -0.05911629f, 
    -0.00197762f, -0.04948599f, -0.06117014f, 0.01128654f, -0.01245820f, 0.04475528f, -0.05064460f, -0.07868817f, 
    0.05611739f, 0.05009744f, -0.06647167f, 0.03445121f, 0.00926824f, -0.04584453f, -0.00909227f, 0.02076326f, 
    -0.02277184f, 0.00284506f, 0.06447408f, 0.04089526f, -0.06010687f, -0.02641763f, -0.05449132f, 0.04783491f, 
    -0.03635937f, -0.04697160f, 0.00474349f, 0.03949501f, -0.04346457f, 0.04620359f, -0.00193924f, 0.00327248f, 
    0.02003917f, -0.05712193f, -0.07661348f, 0.02966513f, 0.06095171f, -0.08052518f, 0.04336471f, -0.05919671f, 
    0.03815853f, -0.04892654f, 0.04877976f, -0.05233191f, 0.02051405f, -0.00732580f, -0.01868565f, -0.07487987f, 
    0.02791000f, -0.00297193f, 0.02049458f, 0.05579994f, 0.03967260f, -0.04662023f, -0.00196346f, 0.05617557f, 
    0.05186778f, -0.06664568f, -0.00073993f, -0.05091477f, -0.02562003f, 0.00042534f, 0.01476038f, -0.00931378f, 
    0.01374271f, 0.05611912f, 0.00922752f, -0.01743812f, 0.04008596f, -0.07997412f, 0.02713009f, -0.06685302f, 
    -0.13354671f, -0.02849031f, -0.01453982f, 0.00076991f, 0.18568821f, -0.09752513f, -0.01661018f, 0.09002265f, 
    -0.02162562f, 0.09234342f, 0.11543840f, -0.13058794f, 0.36268759f, 0.36890510f, -0.02242585f, -0.06164648f, 
    -0.02431861f, -0.19866334f, 0.14489689f, 0.05762681f, -0.00703722f, -0.02062092f, 0.08464277f, 0.00404598f, 
    -0.09381755f, -0.00291889f, 0.25458384f, 0.17123669f, -0.04341142f, -0.08768442f, -0.17149128f, -0.02709769f, 
    0.00621324f, 0.04721305f, 0.11407764f, 0.01261572f, -0.55547786f, 0.25505283f, 0.28555024f, -0.01706851f, 
    -0.01163678f, 0.21840248f, 0.02329488f, 0.09407843f, 0.04333358f, -0.04084301f, 0.04493104f, 0.08174725f, 
    0.05028770f, 0.06392597f, -0.46639803f, 0.17009440f, -0.01342772f, 0.00668147f, -0.01525468f, -0.10263743f, 
    0.09777660f, 0.08512506f, 0.06136537f, 0.07841122f, 0.19267994f, 0.11504485f, -0.32792425f, -0.27144215f, 
    -0.10753776f, -0.02247221f, 0.00905427f, -0.01067832f, 0.04426386f, -0.15200135f, -0.11624612f, -0.13868310f, 
    0.01136839f, 0.06345282f, -0.09381007f, 0.05366626f, 0.08228086f, -0.01436152f, -0.01013572f, 0.11623710f, 
    0.02267990f, 0.06200623f, -0.09533647f, 0.02656494f, 0.20684938f, 0.17028533f, -0.20832860f, -0.11848012f, 
    -0.01326113f, 0.07425434f, -0.16005170f, -0.15192245f, -0.06615271f, -0.05801383f, 0.00137087f, -0.02768758f, 
    -0.57209986f, 0.03592727f, 0.06803858f, 0.01868827f, 0.02719966f, 0.13614160f, 0.15814427f, 0.05809756f, 
    -0.07712130f, 0.14881626f, -0.08834678f, -0.17502265f, 0.07903242f, -0.06623250f, -0.29306671f, -0.17271343f, 
    0.03021284f, 0.10084706f, 0.05871307f, -0.01139193f, 0.04437789f, 0.03976581f, 0.01607947f, 0.02949750f, 
    0.10576933f, -0.04385704f, 0.02400630f, -0.06049643f, 0.04964113f, -0.29865986f, 0.13610153f, 0.13765238f, 
    -0.15072997f, 0.11512464f, -0.03870471f, 0.17929177f, 0.16500686f, -0.00300248f, -0.18612881f, 0.04675869f, 
    0.04749109f, 0.03407620f, 0.11500298f, -0.07620406f, -0.03911479f, 0.07083949f, 0.03712448f, -0.12769832f, 
    0.00269935f, 0.03242976f, 0.06326890f, -0.10218713f, 0.03037523f, -0.13243902f, -0.15600017f, 0.06180074f, 
    0.04158416f, -0.02950117f, 0.05128444f, -0.12687421f, -0.03126910f, -0.06871966f, -0.35354966f, 0.00688060f, 
    0.11770400f, 0.18494567f, 0.06571257f, 0.22910552f, -0.00856936f, -0.01646038f, -0.02143586f, -0.04720370f, 
    0.33223239f, 0.17224342f, 0.14303580f, -0.09914053f, 0.09200815f, 0.04493481f, 0.18277664f, 0.21744175f, 
    0.00971657f, 0.07717229f, 0.01276552f, 0.00369105f, -0.15651764f, -0.06622858f, -0.02156281f, 0.03453847f, 
    -0.04842271f, 0.12162729f, -0.03888338f, -0.01604464f, 0.05876624f, 0.04590558f, -0.12602030f, -0.15163627f, 
    -0.07046304f, 0.00222955f, -0.07650905f, -0.00570372f, 0.11273540f, 0.02835505f, 0.00167548f, -0.05579585f, 
    -0.07128280f, -0.07289953f, -0.05913600f, 0.02173284f, -0.03524631f, -0.02580657f, 0.11044960f, 0.04729792f, 
    0.00362839f, -0.01459966f, -0.03126696f, 0.06505188f, -0.01575748f, 0.03198413f, -0.06177648f, 0.04229015f, 
    -0.03515258f, 0.02678703f, 0.07797799f, -0.03134167f, 0.00866889f, -0.04399682f, -0.02652755f, -0.07427618f, 
    0.04513615f, -0.06683689f, 0.05471227f, -0.03784979f, 0.03398996f, 0.00608478f, -0.07227487f, 0.03856155f, 
    -0.02858375f, -0.06820492f, 0.05721645f, 0.00886068f, 0.04977167f, 0.03030718f, 0.01801316f, 0.04281715f, 
    -0.06127866f, 0.03256502f, 0.06138637f, 0.07191683f, 0.06972694f, -0.01565520f, 0.14244798f, 0.00701298f, 
    -0.06438435f, -0.03341224f, -0.10428288f, 0.02951270f, 0.11236803f, 0.00050962f, -0.06100420f, 0.07520966f, 
    0.03773917f, -0.08589334f, -0.05239698f, -0.06026259f, -0.01775732f, -0.04055410f, -0.14068650f, 0.02144423f, 
    0.04969679f, 0.07853634f, 0.05020511f, 0.06317665f, -0.06119463f, 0.01801710f, 0.03933017f, -0.06557080f, 
    -0.00242696f, 0.01054757f, 0.05003412f, 0.02922913f, 0.06493481f, -0.00068049f, -0.00498020f, -0.01648697f, 
    -0.03193387f, 0.06008283f, 0.06803292f, 0.10091256f, -0.06746749f, -0.11029694f, -0.01324174f, -0.10298433f, 
    -0.00044373f, -0.01724084f, -0.03583980f, -0.03485968f, 0.04308440f, 0.04585125f, 0.02418731f, 0.03477893f, 
    0.09118379f, 0.03864970f, 0.05617810f, 0.05045464f, 0.05138877f, -0.02411645f, 0.11384632f, 0.01915515f, 
    0.11507379f, 0.00676566f, 0.04107383f, 0.04702482f, -0.10643615f, -0.06346899f, -0.13303699f, 0.02085480f, 
    -0.05597062f, -0.04556272f, -0.00796100f, 0.05735586f, 0.00445101f, -0.02672753f, -0.07673042f, -0.06387489f, 
    0.05337181f, -0.03416578f, 0.06585165f, 0.00760234f, 0.05225389f, 0.02523440f, 0.01979570f, -0.08259842f, 
    -0.08395923f, -0.03195710f, 0.01064444f, 0.02240276f, 0.07449561f, 0.07430651f, 0.04272320f, 0.02234300f, 
    -0.02004187f, 0.03057524f, 0.00128081f, 0.07915664f, -0.02997042f, 0.02028469f, -0.03586816f, -0.05815012f, 
    -0.04285634f, 0.04005820f, -0.05954216f, -0.07656960f, -0.03191301f, 0.00404639f, -0.04513214f, 0.01167806f, 
    0.08418832f, 0.01288721f, 0.02088445f, -0.02049552f, -0.01168627f, -0.03680675f, -0.07512541f, -0.07144452f, 
    0.02254646f, 0.10293530f, 0.08956785f, 0.10039907f, 0.05179856f, 0.04281879f, -0.02132930f, 0.11213157f, 
    -0.07861663f, -0.06949369f, -0.07700231f, -0.06312473f, -0.06240737f, -0.04865001f, -0.10128357f, -0.07597707f, 
    -0.00086832f, -0.07385750f, -0.01305085f, 0.04829583f, -0.00578887f, 0.06781613f, 0.03641305f, 0.13193119f, 
    -0.12276538f, -0.05900119f, 0.15826619f, -0.01756425f, 0.08775108f, 0.18933886f, 0.08543894f, 0.05018324f, 
    0.37490410f, 0.25236562f, 0.05331852f, -0.05101297f, -0.19168049f, -0.06094552f, -0.36721122f, -0.20811556f, 
    0.14529416f, 0.20522897f, -0.08093090f, 0.12441918f, 0.01187706f, 0.02638699f, 0.09024089f, 0.00502651f, 
    -0.09093381f, 0.03951256f, -0.37422353f, 0.13899897f, 0.13456595f, -0.17298064f, -0.08269577f, -0.07768362f, 
    -0.01523813f, 0.07473728f, -0.09324235f, 0.11170134f, 0.31388083f, -0.11610307f, -0.29129076f, 0.34554869f, 
    0.11596521f, 0.16429844f, -0.10460530f, 0.13479294f, -0.08278245f, -0.05032609f, 0.07084164f, -0.02891888f, 
    -0.28426737f, -0.04133123f, -0.12117460f, 0.09004258f, 0.00929901f, 0.02859377f, 0.20257102f, -0.13896468f, 
    -0.02066449f, -0.01190038f, -0.09874435f, 0.01785148f, -0.07253222f, -0.41851321f, -0.03095581f, 0.24405842f, 
    0.01663051f, -0.12599811f, -0.10097451f, 0.02190390f, 0.05346602f, 0.10382392f, 0.04082786f, 0.09839225f, 
    0.00446800f, 0.39885485f, 0.01681887f, 0.04173116f, 0.05157590f, -0.22480500f, 0.11766405f, 0.00242935f, 
    0.04862992f, 0.21833034f, -0.11891726f, 0.19425304f, -0.26590943f, 0.21897687f, 0.31817508f, -0.03484026f, 
    0.11837550f, 0.03970226f, 0.03588467f, 0.05290821f, 0.08720945f, 0.01572338f, -0.04731122f, -0.02835865f, 
    -0.00741519f, -0.06566165f, 0.26652864f, 0.16090646f, 0.03544897f, -0.08736315f, -0.11145153f, 0.01660770f, 
    0.03985436f, -0.07410538f, 0.05366484f, 0.09789987f, -0.18480287f, 0.09863190f, 0.10127264f, -0.00894268f, 
    -0.01979078f, 0.02285200f, -0.06509793f, -0.01637011f, -0.01807401f, 0.02220315f, -0.18079612f, -0.04587187f, 
    -0.47727105f, -0.06053486f, 0.12119421f, 0.12259908f, 0.33536458f, -0.02869473f, -0.13948095f, -0.01855634f, 
    0.12366241f, 0.01756171f, 0.12153264f, -0.07703084f, 0.20959553f, 0.25365508f, 0.23909734f, -0.20499413f, 
    -0.10469774f, -0.02015294f, 0.04896263f, -0.00587303f, 0.10399035f, 0.12969662f, 0.26659769f, 0.07269059f, 
    -0.18195952f, -0.29509312f, -0.06569497f, 0.11045656f, -0.12426701f, 0.05993722f, 0.08790288f, -0.07683186f, 
    -0.00909911f, 0.01522541f, 0.02094247f, 0.13002665f, 0.04879685f, 0.12207095f, 0.14137705f, -0.39910296f, 
    0.07338937f, 0.15314277f, -0.09784778f, -0.00624946f, 0.08728170f, 0.14475861f, 0.07194767f, -0.06703179f, 
    -0.30502245f, 0.05046754f, 0.24112061f, 0.18141808f, -0.09907711f, -0.08590377f, -0.14593250f, -0.26690328f, 
    0.07783923f, 0.00829783f, 0.06352373f, -0.01653281f, 0.15215878f, 0.09991702f, -0.03445952f, -0.10402313f, 
    0.03170107f, 0.05575497f, 0.00472147f, -0.11121312f, 0.06997649f, 0.03526031f, 0.26917467f, 0.23107815f, 
    -0.15294226f, 0.12518504f, -0.05656697f, -0.02510374f, -0.03969598f, 0.16331947f, -0.12205955f, -0.02266539f, 
    -0.19923773f, -0.20609750f, -0.05292451f, -0.10431338f, 0.07407758f, 0.27171999f, -0.13697523f, 0.19888374f, 
    0.02698658f, 0.10880573f, 0.03115508f, 0.09530547f, -0.15626632f, 0.03607758f, 0.20484251f, 0.02288682f, 
    0.15395419f, 0.00316829f, -0.14192149f, -0.11292653f, 0.02633224f, 0.07121502f, 0.15373471f, -0.00765772f, 
    -0.08422491f, 0.08220675f, 0.14403565f, 0.18980788f, 0.50986397f, 0.38603470f, -0.04795174f, -0.24725512f, 
    0.11129013f, -0.00111910f, 0.04339202f, -0.03429732f, -0.06076770f, -0.04934125f, 0.04371772f, 0.01215675f, 
    -0.09794043f, 0.27155370f, 0.09964298f, 0.26199266f, 0.04418010f, -0.00889565f, 0.22755647f, 0.06568853f, 
    0.08005409f, -0.11660197f, -0.07617638f, -0.04812196f, -0.18623272f, -0.09847359f, -0.12610304f, 0.18484035f, 
    0.03362330f, 0.00461894f, 0.06569909f, 0.26553252f, -0.13542600f, 0.08607370f, 0.04187106f, 0.11319577f, 
    -0.02352810f, -0.34782955f, -0.11209995f, 0.12633482f, 0.02400227f, 0.07933684f, 0.02586851f, 0.03373310f, 
    0.10122088f, 0.02350790f, 0.12211626f, 0.16941147f, -0.02305191f, -0.21926147f, -0.06769350f, 0.10264059f, 
    0.06373548f, 0.08694112f, 0.10585450f, 0.03861455f, 0.01051183f, 0.14358312f, 0.13275038f, 0.05664162f, 
    0.29826212f, -0.21305029f, -0.43060461f, -0.16957568f, -0.02451421f, 0.04750859f, 0.03364022f, -0.02196619f, 
    -0.09686877f, 0.17813483f, 0.00767052f, 0.09216531f, -0.28233704f, -0.33948502f, -0.08488168f, 0.08791802f, 
    0.04882236f, 0.05283412f, 0.12269583f, 0.05701979f, -0.08041308f, -0.01820195f, 0.08888126f, -0.01486225f, 
    -0.05787700f, 0.31177655f, -0.20193492f, -0.45507541f, 0.01725969f, 0.05612501f, 0.19524084f, -0.02080475f, 
    -0.02891721f, 0.06511542f, 0.16046001f, 0.02640164f, -0.16499801f, -0.09850562f, -0.10255095f, 0.21794169f, 
    0.00053005f, 0.07233687f, -0.03608475f, 0.00804433f, -0.09739720f, 0.08665224f, -0.04228246f, 0.06095436f, 
    -0.24888989f, -0.18453737f, -0.15197770f, 0.20507808f, -0.09713252f, -0.04469084f, 0.01367113f, -0.03553929f, 
    0.04568500f, -0.01586003f, -0.01812597f, 0.02632423f, -0.30249396f, -0.24006283f, -0.14242867f, 0.12256695f, 
    -0.02644227f, 0.07184257f, 0.15203643f, 0.04280286f, -0.04016128f, -0.00728578f, 0.04832817f, 0.10504863f, 
    0.26481983f, -0.29590496f, -0.08366518f, 0.08580749f, -0.00616543f, 0.06482528f, 0.04289337f, 0.02519294f, 
    -0.06693787f, 0.03690640f, 0.01631412f, 0.00837073f, -0.03468490f, 0.01721849f, 0.24190001f, 0.00198509f, 
    -0.18112409f, -0.05195980f, -0.14189607f, -0.07908855f, -0.08849769f, -0.04557446f, 0.18630205f, 0.08397715f, 
    0.00792764f, 0.09112868f, 0.02478252f, -0.07056387f, 0.01578300f, -0.02157443f, 0.10469441f, 0.10049362f, 
    0.05107560f, 0.20378448f, -0.15903038f, -0.19695868f, 0.43635917f, 0.41376546f, -0.16936541f, 0.15046757f, 
    -0.25297800f, -0.05387736f, 0.23818514f, 0.10412382f, 0.00681223f, 0.04542887f, 0.06630655f, -0.07544042f, 
    -0.01838678f, -0.24060801f, 0.15938149f, 0.10744934f, 0.04638863f, 0.11375302f, 0.00255710f, -0.08342569f, 
    -0.03000197f, -0.03052491f, -0.01801128f, 0.02575160f, 0.31481761f, 0.19354333f, 0.52167779f, -0.24641904f, 
    0.11636867f, -0.20196529f, 0.02231750f, -0.15352067f, 0.11279313f, -0.04896126f, -0.01434524f, 0.02528305f, 
    0.52227277f, 0.26477963f, 0.11694685f, 0.09034446f, -0.04624108f, 0.11313581f, 0.00119759f, -0.07682001f, 
    0.06972434f, 0.03524109f, 0.03745716f, 0.04114052f, 0.42584440f, 0.02022820f, 0.15102229f, -0.11897796f, 
    -0.04934840f, -0.01102791f, 0.02504201f, -0.25040531f, 0.15922092f, 0.02065638f, 0.09342580f, -0.11100882f, 
    -0.19726889f, -0.03082526f, -0.25071564f, 0.00240793f, 0.17021555f, 0.03136516f, 0.03129378f, -0.09592790f, 
    0.05262373f, -0.10099132f, 0.15713699f, 0.09137554f, -0.04382692f, 0.18868123f, -0.39258361f, -0.11647061f, 
    -0.09831919f, 0.13330521f, -0.08559097f, -0.03322739f, -0.04369143f, -0.16113061f, 0.05064579f, 0.11644143f, 
    -0.57197243f, -0.29929575f, -0.43302554f, -0.16459714f, 0.06671598f, 0.13496763f, 0.21991788f, 0.17696375f, 
    0.24253573f, 0.02660544f, -0.06568063f, -0.09231251f, 0.31318849f, 0.03395465f, -0.12376708f, 0.03372322f, 
    0.01858928f, 0.24467140f, 0.13764617f, 0.17802934f, 0.06289756f, 0.08743377f, 0.07239123f, -0.01376797f, 
    0.11805490f, 0.05333372f, -0.39977437f, 0.05080618f, -0.15137707f, -0.02316494f, 0.06501718f, 0.12770666f, 
    0.12700397f, -0.15351425f, 0.14678258f, 0.24823228f, -0.12094440f, -0.34337649f, -0.06941682f, -0.02041756f, 
    0.05023146f, 0.08921919f, 0.02488387f, 0.03565886f, 0.03019450f, 0.11835496f, 0.12344225f, -0.27012485f, 
    0.22620791f, -0.05577542f, 0.28412637f, 0.02030725f, 0.03590064f, -0.22573550f, -0.08034509f, 0.15761460f, 
    0.02659541f, 0.03500062f, 0.06618411f, -0.04276279f, -0.00092577f, -0.11785565f, -0.07346991f, 0.03937525f, 
    0.05515020f, 0.08644830f, 0.10930342f, 0.20832737f, -0.01451671f, 0.03685163f, -0.02722516f, -0.16379185f, 
    -0.01329624f, 0.11537144f, 0.05675013f, -0.05918558f, -0.01795905f, 0.04576845f, 0.17142884f, -0.07267380f, 
    0.00463293f, 0.07334945f, 0.04538365f, 0.05711421f, -0.15648039f, -0.25594395f, -0.00836557f, 0.01273239f, 
    -0.04074708f, 0.09667963f, 0.01707559f, -0.11128810f, -0.19141121f, 0.02891368f, -0.28546190f, -0.10262516f, 
    -0.11411987f, -0.29798743f, -0.11223717f, -0.19186807f, 0.28310335f, 0.07402143f, -0.00215481f, 0.06369045f, 
    0.06067031f, -0.01400835f, 0.01952673f, -0.14604601f, 0.34364292f, -0.41607329f, 0.75099277f, -0.49060518f, 
    0.06491928f, 0.17742896f, 0.01145919f, 0.13254574f, 0.08045353f, 0.00020956f, 0.14671402f, -0.05441641f, 
    -0.28483078f, 0.30633813f, -0.05445504f, 0.08681244f, -0.10448643f, 0.04130979f, 0.12941357f, 0.04099416f, 
    0.06824940f, 0.09160590f, 0.20677873f, 0.14440307f, -0.24497943f, -0.45932454f, -0.39924437f, 0.10870419f, 
    -0.01829321f, 0.05288558f, 0.01955831f, -0.06292529f, -0.07271452f, -0.06223766f, 0.04052236f, -0.12148908f, 
    -0.03252038f, -0.11250381f, -0.28559846f, -0.10387028f, 0.02364964f, 0.08293289f, 0.24635321f, -0.04081718f, 
    0.19023195f, -0.09366582f, 0.12369113f, 0.02918683f, 0.02994077f, 0.23449363f, -0.18838120f, -0.05544582f, 
    -0.03358093f, -0.07535179f, 0.04747768f, 0.16394724f, -0.01341408f, -0.07759650f, 0.08833061f, -0.11316494f, 
    0.04978184f, 0.06050574f, 0.26081702f, -0.09508785f, -0.06896143f, 0.23771858f, -0.08115329f, 0.10794330f, 
    -0.04331373f, 0.01311145f, -0.01739070f, -0.17266244f, 0.10993892f, -0.08451515f, 0.35591489f, -0.07273859f, 
    -0.03148660f, -0.02935012f, 0.15845250f, 0.05743957f, 0.14163770f, 0.01116941f, 0.01004999f, -0.10980780f, 
    0.31572887f, -0.13935409f, 0.39846668f, 0.08937868f, -0.14721727f, -0.05303224f, -0.04522557f, 0.16297016f, 
    0.14618911f, -0.15297472f, 0.01914494f, 0.07186814f, -0.01024962f, -0.13368110f, 0.14655325f, -0.15885074f, 
    0.10853747f, 0.15298112f, 0.15730849f, 0.17882571f, 0.04082997f, -0.13235490f, 0.11825120f, 0.16090098f, 
    0.10664577f, -0.11494473f, 0.41768974f, 0.20385519f, 0.00234231f, -0.00099236f, 0.04471829f, -0.04086937f, 
    0.38341549f, 0.24903670f, 0.18094157f, 0.14944524f, 0.32782432f, 0.16298096f, 0.15885209f, -0.18133347f, 
    0.08415153f, 0.00890419f, 0.01443923f, 0.01974155f, 0.11074489f, -0.02459226f, 0.04748606f, -0.18956891f, 
    0.02758252f, -0.04705270f, -0.08036352f, -0.03732740f, 0.08761985f, -0.01066265f, -0.16648471f, -0.18153879f, 
    0.21969476f, 0.07767695f, -0.02012690f, -0.11968838f, -0.02249330f, -0.04421598f, -0.10344031f, -0.39080650f, 
    -0.08260127f, 0.00792649f, -0.01987586f, 0.10027324f, 0.04990843f, 0.00420434f, 0.13818373f, 0.08978754f, 
    -0.19357251f, 0.26390156f, 0.09714919f, -0.20998295f, -0.02632016f, -0.00697387f, -0.12411784f, 0.33728305f, 
    0.03030586f, -0.03041500f, -0.11238972f, -0.11968109f, -0.11835773f, 0.16606911f, -0.17879748f, 0.00061607f, 
    -0.01755351f, -0.07458903f, -0.04339584f, -0.10138117f, -0.15261602f, -0.20513372f, -0.23881850f, -0.08068854f, 
    -0.03699209f, 0.00323286f, 0.04162548f, -0.03132118f, 0.02235076f, 0.00548641f, 0.04518369f, 0.00069623f, 
    0.03116896f, -0.04868415f, 0.01925111f, -0.06877376f, -0.03815344f, 0.06030307f, 0.04544669f, -0.02721147f, 
    -0.05920127f, -0.06533881f, -0.01356872f, 0.05847620f, 0.00794693f, 0.03601316f, 0.05415406f, 0.00976217f, 
    0.05482027f, -0.00193348f, -0.02409286f, -0.07147292f, 0.02827785f, -0.01105894f, 0.05849066f, -0.01978365f, 
    0.00787750f, -0.06617820f, -0.07109207f, -0.03398573f, -0.05947074f, -0.03982660f, -0.07945708f, -0.05323355f, 
    -0.06101825f, 0.05641173f, -0.03424341f, 0.01163123f, -0.06954000f, 0.05733011f, -0.02725558f, 0.00982663f, 
    -0.03686553f, 0.04783685f, -0.05723509f, 0.01992549f, 0.03640984f, -0.00278537f, 0.05632485f, 0.03532533f, 
    -0.06429321f, -0.07952119f, -0.02982487f, 0.01512004f, -0.05321603f, 0.04699031f, -0.07058607f, 0.04279299f, 
    0.07202723f, 0.01937142f, 0.04915660f, -0.01835153f, 0.00310311f, -0.00101643f, -0.01825406f, 0.05204849f, 
    0.05068322f, 0.03722875f, 0.03643052f, -0.07802012f, 0.03725574f, -0.04972986f, 0.05678741f, -0.00443586f, 
    0.01784467f, -0.04776638f, -0.06436748f, -0.02953031f, 0.02628625f, -0.03050559f, 0.04111203f, -0.01106238f, 
    -0.06522428f, 0.02538747f, -0.05903706f, 0.01067508f, 0.03800092f, -0.02226268f, -0.06586425f, 0.00006747f, 
    0.01813480f, 0.00915126f, -0.04340914f, -0.07479801f, 0.05577074f, 0.00674307f, -0.03918648f, -0.07298884f, 
    0.04045246f, -0.07646144f, -0.07274225f, 0.00745086f, 0.03802837f, -0.00472475f, -0.07916088f, -0.00835223f, 
    -0.06672575f, -0.05527130f, 0.01984667f, -0.04489772f, -0.05161986f, 0.02491950f, 0.05248625f, -0.05345055f, 
    -0.04880343f, 0.03300792f, -0.07999953f, -0.00873210f, -0.07021395f, -0.07681625f, 0.03162529f, -0.03775842f, 
    -0.02151894f, 0.02783267f, 0.06183356f, 0.00844278f, -0.01541428f, -0.05679208f, 0.01751705f, 0.04620181f, 
    -0.04633840f, -0.05954137f, -0.02731253f, -0.04868717f, -0.06081097f, -0.06244520f, 0.01047290f, 0.00478866f, 
    -0.02151738f, -0.02183228f, -0.00024129f, 0.02214974f, -0.02880316f, -0.03775483f, -0.00334033f, -0.07754695f, 
    -0.01155841f, -0.02498284f, -0.03964909f, -0.03480100f, -0.04394550f, 0.05266603f, 0.03381174f, 0.04300459f, 
    -0.06428043f, -0.07777807f, -0.03154832f, 0.00675076f, 0.00928483f, -0.02548063f, -0.04963484f, -0.02821846f, 
    0.03666966f, -0.00445618f, 0.02038218f, 0.04259615f, -0.03495291f, 0.04201963f, -0.03423760f, -0.00522477f, 
    -0.03326273f, -0.06027089f, -0.01207432f, -0.02630737f, 0.06225963f, 0.00629345f, 0.02975326f, 0.01501437f, 
    -0.04927379f, -0.02475006f, 0.01284560f, -0.00731846f, -0.06270771f, 0.00155589f, 0.02227577f, -0.00112450f, 
    -0.00527924f, -0.32079577f, 0.06247411f, -0.01195870f, 0.19587557f, 0.00592226f, 0.20848939f, 0.21434902f, 
    0.21724097f, 0.21156232f, 0.28291017f, -0.12695995f, 0.14304931f, -0.12654980f, 0.36246797f, -0.22062951f, 
    0.12808491f, 0.10156373f, -0.02187320f, 0.29491031f, -0.01021628f, 0.01516870f, -0.22268389f, 0.08849926f, 
    -0.02296255f, 0.02100370f, 0.23195317f, 0.04765994f, -0.15388244f, -0.06965184f, -0.12841758f, 0.05340104f, 
    0.20482919f, -0.07052250f, -0.07255668f, -0.08814599f, -0.37475228f, -0.39531758f, 0.09729902f, 0.08146524f, 
    0.03112883f, 0.24003719f, 0.08899482f, 0.03467460f, -0.04880294f, -0.07207941f, -0.12813829f, -0.03168717f, 
    0.13980202f, -0.20051371f, -0.18320547f, -0.08703989f, 0.04581044f, 0.15598884f, 0.04109407f, 0.24158026f, 
    0.04531977f, 0.05947813f, 0.13048646f, -0.02226743f, 0.36170799f, 0.31123126f, -0.05207226f, -0.09669130f, 
    0.04489508f, 0.11613157f, 0.06794289f, -0.09454583f, -0.02008185f, -0.17579196f, -0.02716648f, -0.05263338f, 
    0.06060479f, 0.16972059f, 0.22014657f, -0.15834521f, 0.01269254f, 0.04915305f, 0.00205386f, 0.10515142f, 
    -0.15946414f, -0.08874151f, -0.02473430f, 0.05578505f, -0.05802372f, 0.13196880f, -0.08281733f, -0.11136676f, 
    -0.08787826f, 0.01020295f, -0.09713125f, 0.13720118f, 0.00837092f, -0.11079657f, -0.12433376f, -0.00263954f, 
    0.00744275f, 0.19108549f, 0.44892162f, 0.24088421f, -0.04368478f, -0.06420015f, -0.03364065f, 0.03863993f, 
    0.01357657f, -0.10742129f, 0.14201361f, 0.04305152f, 0.29261741f, 0.19418222f, 0.00167227f, -0.23245564f, 
    0.08341029f, 0.15864022f, 0.11575621f, 0.11589797f, 0.11717840f, 0.00976818f, 0.08034377f, -0.00696208f, 
    0.19202021f, -0.20148323f, 0.03597962f, 0.34567499f, -0.00706089f, 0.00506370f, -0.21428151f, 0.16254236f, 
    0.02422952f, 0.06120512f, 0.01304276f, 0.15663913f, 0.15731892f, 0.22067837f, 0.22278000f, -0.16148587f, 
    0.01911096f, -0.12039095f, 0.00618398f, 0.05683162f, -0.01271830f, -0.09619890f, 0.03972238f, -0.10905291f, 
    0.14084683f, 0.16909377f, 0.16123366f, -0.09550403f, 0.09906169f, -0.04815466f, -0.03585631f, 0.11111894f, 
    -0.02456823f, -0.03222853f, 0.02309340f, -0.01647799f, 0.05720913f, 0.06702847f, -0.08302226f, -0.00817553f, 
    0.16349022f, -0.07042041f, -0.07357650f, 0.11016519f, -0.02646257f, 0.16418505f, 0.11508281f, -0.00904504f, 
    -0.22762027f, 0.18188255f, 0.22201486f, -0.17308789f, 0.01269635f, 0.00011088f, 0.05839699f, 0.14115089f, 
    -0.03976988f, -0.04948418f, -0.01988038f, 0.05314269f, -0.46128276f, -0.15312651f, -0.46559089f, -0.09649088f, 
    0.02965013f, 0.05306266f, 0.02376220f, -0.10270612f, 0.15295613f, 0.02973837f, -0.26011989f, -0.01654705f, 
    -0.11727811f, 0.01662235f, 0.05043447f, -0.06596038f, 0.11247122f, 0.03445517f, 0.10515944f, 0.15438820f, 
    -0.02064036f, 0.07564745f, 0.10321078f, -0.07976637f, 0.46878690f, -0.17073998f, -0.06717540f, -0.28976941f, 
    -0.08650056f, -0.03613228f, 0.30501360f, 0.01703335f, 0.08087599f, 0.01953069f, 0.07786566f, 0.00945866f, 
    -0.41857147f, -0.34654275f, -0.09049906f, 0.01924702f, 0.12699413f, 0.07495593f, -0.10802805f, -0.15145999f, 
    -0.04863060f, 0.12223425f, -0.11565340f, 0.01143186f, 0.14945778f, -0.21792442f, 0.27914235f, 0.00153979f, 
    0.21009676f, -0.07200544f, 0.06873680f, -0.09188280f, 0.05206348f, -0.11316909f, -0.13332075f, 0.01919692f, 
    0.36674923f, -0.00676191f, -0.04074103f, -0.21214232f, 0.02435134f, -0.06312518f, 0.04770706f, -0.13037576f, 
    0.05158730f, 0.07377768f, -0.05588890f, 0.13294218f, 0.31203482f, -0.07140615f, 0.30951726f, -0.15763894f, 
    0.02367151f, -0.07288129f, 0.00033139f, -0.13806793f, 0.18029477f, -0.15656881f, 0.19646554f, -0.02459846f, 
    -0.16638027f, 0.22152741f, -0.21638285f, -0.32556444f, 0.06875235f, 0.02237599f, 0.00502991f, 0.09986217f, 
    -0.04807673f, -0.06597171f, 0.20311189f, 0.04224386f, 0.14528288f, 0.30657700f, 0.04880961f, -0.37362424f, 
    -0.07822178f, 0.02731383f, 0.14693303f, 0.01202494f, -0.12576246f, -0.24909452f, -0.10332613f, 0.07480662f, 
    -0.37180832f, -0.23588350f, -0.20206946f, -0.08714373f, -0.11906783f, 0.04297042f, -0.02958483f, 0.11058835f, 
    0.09191395f, -0.14328644f, 0.00587966f, -0.15895696f, 0.35032883f, 0.28332680f, 0.02717512f, -0.01912285f, 
    -0.03162229f, 0.16095133f, -0.02172524f, 0.14994588f, -0.05028673f, -0.04841417f, -0.13754570f, 0.05012536f, 
    0.03574922f, -0.26313397f, -0.10129324f, 0.45529822f, 0.07520839f, 0.04357659f, 0.16928177f, 0.05804403f, 
    0.23068632f, -0.10792729f, 0.07286699f, 0.20251434f, 0.27430698f, -0.24776584f, -0.00250374f, -0.21675953f, 
    -0.04770037f, 0.06583186f, 0.06216112f, 0.14456131f, 0.15592852f, 0.07974125f, 0.25097385f, -0.08432905f, 
    0.39145747f, 0.03363670f, 0.16221938f, -0.09522985f, 0.09636075f, -0.22655828f, -0.06920722f, 0.04160993f, 
    0.00889407f, -0.05256527f, 0.09177382f, 0.00548240f, 0.22538844f, -0.13162147f, 0.09519652f, -0.30132160f, 
    -0.06269643f, 0.21180262f, 0.04640832f, 0.24261163f, 0.01892482f, 0.07444102f, 0.02003232f, -0.07980490f, 
    -0.25609761f, 0.61047983f, 0.11040458f, -0.21207625f, 0.06865115f, 0.10067736f, 0.10988560f, 0.10507542f, 
    0.03338996f, -0.06046819f, -0.04073144f, 0.13511994f, -0.02651524f, -0.03679468f, 0.07223625f, 0.01496809f, 
    0.05357962f, 0.13267826f, 0.06924444f, -0.07573609f, -0.10797258f, 0.00732274f, -0.11500264f, 0.11248665f, 
    -0.10674389f, -0.08825341f, -0.12660624f, -0.05885607f, 0.13051166f, 0.09481338f, -0.01065178f, -0.16874261f, 
    0.20712028f, 0.22166982f, -0.06944152f, -0.08885007f, 0.20668034f, -0.16144173f, 0.16550709f, 0.18910332f, 
    0.25468865f, 0.36603120f, 0.05349949f, -0.04577980f, 0.06626575f, -0.03804807f, 0.09461216f, 0.04278886f, 
    -0.19436990f, -0.01855650f, 0.05791755f, -0.03028566f, 0.01649597f, 0.02940270f, 0.01159276f, 0.07169130f, 
    -0.01735405f, 0.10350771f, 0.18670198f, 0.01964191f, 0.47459224f, 0.03134349f, -0.23659551f, -0.02529593f, 
    0.22820406f, 0.26514012f, 0.27821487f, -0.07077087f, -0.06718948f, -0.06561793f, 0.07172852f, -0.06626531f, 
    -0.28785437f, -0.09559561f, -0.18731365f, -0.00722199f, 0.02041750f, -0.06815244f, -0.03924474f, -0.05179944f, 
    0.11732919f, 0.07634328f, 0.00834533f, 0.12357645f, 0.01360889f, -0.28600439f, -0.24898978f, -0.07618491f, 
    0.01997488f, -0.10235005f, 0.08018853f, 0.09989640f, 0.22826640f, 0.21996525f, 0.04326113f, 0.14871639f, 
    -0.21056566f, 0.33488217f, 0.21940824f, 0.10119054f, -0.09380473f, 0.04641008f, 0.05552769f, 0.39164820f, 
    0.04508031f, 0.25436595f, 0.25475666f, -0.05644222f, -0.21374331f, -0.12753519f, -0.09445620f, -0.16949522f, 
    -0.01573003f, -0.10418778f, 0.07582495f, 0.12648569f, -0.05468610f, 0.03840068f, 0.07572695f, -0.01872228f, 
    -0.17991620f, 0.31702867f, 0.19882579f, 0.15115200f, -0.05437891f, 0.00583553f, -0.09659995f, 0.02675414f, 
    -0.09945548f, 0.17458636f, 0.09114944f, -0.08177354f, -0.30840307f, -0.31618091f, -0.33018464f, -0.36753771f, 
    -0.05791736f, -0.14540158f, 0.10350025f, 0.00413810f, -0.04787726f, 0.05958742f, 0.01524897f, -0.05223463f, 
    -0.15071720f, 0.15793227f, 0.15710303f, 0.09913899f, 0.25605318f, -0.10323320f, 0.08770689f, 0.04257664f, 
    0.13311094f, 0.13564274f, 0.09956135f, 0.15013546f, -0.04191307f, 0.23889402f, 0.06443585f, -0.12510243f, 
    0.04507382f, -0.02209361f, 0.03107836f, 0.17375864f, 0.07011541f, 0.33006620f, 0.29761332f, 0.12207545f, 
    -0.12942475f, -0.31197253f, -0.31436703f, -0.28049257f, -0.07647728f, 0.17428493f, 0.15603177f, 0.02450702f, 
    0.09965055f, 0.00024296f, -0.03291810f, 0.00368802f, -0.08562119f, -0.02735863f, -0.00138779f, -0.03633443f, 
    -0.24617694f, 0.31681350f, 0.00957878f, 0.18056883f, 0.17726447f, -0.03545687f, 0.04722197f, 0.04411183f, 
    -0.35467708f, -0.20808354f, -0.19984742f, -0.26996589f, -0.15287566f, 0.24881320f, 0.01303349f, 0.04700968f, 
    -0.05350251f, 0.02289067f, -0.07790202f, 0.02323579f, 0.05720053f, -0.01724996f, 0.08888381f, -0.14935203f, 
    -0.07090327f, -0.06814142f, -0.08357482f, 0.00439904f, -0.17235927f, -0.09090636f, -0.01246452f, 0.20245731f, 
    -0.03457374f, 0.01006852f, 0.04464381f, -0.00350902f, -0.04517087f, -0.07196004f, -0.01384302f, -0.06631596f, 
    -0.05224799f, 0.06171430f, -0.02563292f, -0.03301253f, -0.02972682f, -0.05691560f, -0.02001718f, 0.01814545f, 
    -0.00152752f, 0.00034974f, -0.02028069f, 0.03895752f, -0.04132362f, 0.03057801f, -0.06803392f, -0.00995639f, 
    -0.02710663f, -0.00189733f, -0.01652894f, 0.02800181f, 0.02265070f, 0.04159221f, -0.00965245f, -0.00011721f, 
    0.02717841f, -0.00038691f, -0.06998008f, -0.04099989f, -0.07366263f, -0.07830575f, 0.02839168f, -0.05452294f, 
    0.00799669f, 0.04761225f, 0.05715033f, -0.03337557f, 0.01936989f, -0.01133333f, -0.01283017f, 0.02708412f, 
    -0.07137091f, 0.00357293f, -0.06230104f, -0.05399365f, -0.03323309f, 0.02803110f, 0.05827138f, 0.03201566f, 
    0.05638691f, -0.05950212f, 0.05560628f, -0.05295863f, -0.06318405f, -0.02353909f, -0.01696933f, 0.03980140f, 
    -0.04765746f, -0.06936734f, -0.06069389f, -0.01635040f, -0.01729971f, -0.02459791f, -0.03886862f, -0.02334347f, 
    -0.03972607f, -0.04366602f, -0.06870754f, 0.00062466f, 0.02646236f, -0.07317952f, -0.03413483f, -0.00430233f, 
    -0.03429254f, -0.05225984f, 0.05133711f, -0.04265036f, 0.01216792f, 0.03037291f, 0.02438562f, -0.00300719f, 
    0.04650396f, -0.01021567f, -0.01610063f, 0.00750314f, -0.01709218f, -0.05625626f, 0.03841275f, -0.00530390f, 
    -0.07491803f, 0.05895499f, -0.02763162f, -0.02525310f, 0.05480012f, 0.00622902f, -0.06623328f, 0.02085507f, 
    -0.04507503f, 0.03975721f, -0.04936587f, 0.01149429f, 0.02689059f, 0.04662114f, -0.06840928f, -0.00422779f, 
    -0.07220760f, 0.03278450f, -0.00699045f, 0.00053948f, 0.02942627f, 0.04376523f, -0.07272467f, 0.00466056f, 
    0.03983061f, 0.03751590f, -0.06798728f, -0.00051390f, 0.01516342f, -0.07480618f, 0.03845828f, 0.03954788f, 
    -0.03611473f, -0.04791803f, 0.02082742f, -0.07486124f, -0.04216835f, 0.03081802f, 0.03886990f, -0.01042196f, 
    -0.04003401f, -0.06881125f, -0.07375802f, -0.02929160f, -0.05119239f, -0.07125060f, 0.00026996f, 0.02320219f, 
    -0.04739852f, -0.05793281f, -0.04407784f, -0.03200670f, 0.04516045f, 0.00329823f, -0.01393014f, -0.07944459f, 
    -0.04603976f, -0.06856008f, 0.01321198f, 0.05151324f, 0.02752919f, -0.02086410f, -0.06461017f, 0.00076940f, 
    0.01284486f, -0.04760605f, -0.01877289f, 0.03268125f, -0.06518029f, 0.03691207f, -0.00944203f, 0.03750188f, 
    -0.00706613f, 0.06129149f, -0.04354879f, 0.01801191f, -0.01242568f, 0.01038206f, -0.04134674f, -0.04239239f, 
    -0.05796836f, 0.03302882f, -0.01925251f, 0.00516875f, -0.03835032f, -0.02697111f, 0.02395013f, -0.06517549f, 
    0.03693260f, -0.02929407f, 0.00503653f, -0.05184049f, -0.01464410f, 0.01832927f, -0.01573257f, -0.03767228f, 
    0.01678289f, -0.03966007f, 0.00657091f, 0.04831337f, -0.08420746f, -0.03655754f, -0.01067735f, 0.10225682f, 
    0.07499472f, -0.14371382f, -0.10514280f, 0.01325513f, -0.37755397f, -0.13441958f, 0.06952421f, 0.19010532f, 
    0.10564536f, 0.24262697f, -0.14826657f, 0.04070662f, -0.08829483f, -0.09859373f, -0.03785047f, -0.01163406f, 
    -0.12278198f, 0.10234849f, 0.05896395f, -0.18371530f, 0.17036080f, 0.11513436f, 0.04845273f, 0.01861416f, 
    -0.01734292f, -0.01920492f, -0.11771666f, 0.03589839f, -0.44403639f, 0.54730970f, -0.27495360f, 0.18362504f, 
    0.22474600f, -0.06990393f, 0.04694663f, 0.14515422f, -0.13569717f, 0.00477457f, 0.06836168f, -0.04317648f, 
    0.04921140f, -0.06736591f, 0.17362322f, -0.03299223f, -0.15460491f, 0.10817907f, 0.03585697f, 0.14418453f, 
    -0.00919312f, -0.14481838f, -0.00568759f, -0.11664470f, -0.37861654f, 0.20407453f, -0.10781406f, 0.26501393f, 
    0.03683259f, -0.17787024f, 0.13422139f, 0.09606364f, -0.08333699f, 0.03594954f, 0.11584395f, 0.12479465f, 
    0.25131553f, 0.15272541f, 0.11367463f, -0.06693215f, 0.06067963f, 0.02770961f, -0.06332431f, -0.13671832f, 
    0.02825328f, 0.10541976f, -0.02651170f, 0.00779268f, 0.19072649f, 0.05857703f, 0.56723547f, 0.20489964f, 
    -0.06409831f, 0.05739749f, 0.02594190f, -0.00002653f, -0.04783372f, 0.07258771f, -0.03428830f, -0.11676877f, 
    0.01405142f, 0.35309935f, -0.14722523f, 0.04450575f, -0.08867201f, -0.03813045f, -0.04762532f, 0.02389754f, 
    -0.07169120f, -0.08147491f, 0.04553945f, -0.14437668f, -0.08805725f, 0.05052221f, 0.23457667f, 0.20256117f, 
    0.02613969f, -0.04496077f, -0.12598661f, 0.00922342f, -0.11084770f, -0.10174704f, -0.16254902f, 0.06786106f, 
    -0.07739868f, -0.16265824f, 0.41503605f, 0.14939398f, 0.19664000f, 0.10038701f, 0.20819303f, -0.12015343f, 
    0.20660228f, 0.15247598f, 0.12097258f, 0.04627058f, -0.01522099f, 0.13025519f, 0.17993200f, -0.06115245f, 
    -0.06476944f, -0.08692776f, -0.14737977f, -0.14599806f, -0.15408346f, -0.19633028f, -0.19912063f, 0.12541787f, 
    -0.06434961f, 0.24593841f, -0.10442773f, -0.22002091f, -0.01840846f, -0.03623475f, -0.08756865f, -0.26005730f, 
    0.04970193f, 0.25795063f, 0.06323045f, 0.08317176f, -0.00526203f, -0.08885717f, 0.11127767f, 0.06725517f, 
    -0.03635142f, 0.04499505f, 0.03630712f, -0.15763375f, -0.05449977f, -0.01473616f, -0.12109959f, -0.13645492f, 
    0.01235008f, 0.03471233f, -0.00351808f, 0.10392544f, -0.03525879f, -0.04630910f, 0.07680190f, -0.03932429f, 
    -0.01693054f, 0.04008282f, -0.05720950f, -0.09237899f, 0.46126744f, 0.09204432f, 0.06887268f, 0.00444083f, 
    -0.06739642f, 0.00732315f, -0.04159886f, -0.03516543f, 0.17554075f, 0.21690914f, 0.11772919f, 0.11989746f, 
    -0.17705968f, -0.03871994f, -0.17850539f, 0.20667475f, -0.03469477f, -0.07930527f, 0.01765857f, -0.01688643f, 
    -0.07461238f, -0.06628556f, -0.03348922f, -0.00048683f, 0.23727161f, 0.17035830f, -0.12425543f, 0.49240911f, 
    0.00697124f, -0.00426586f, 0.06935531f, -0.04319392f, 0.00128716f, 0.07998221f, 0.16130152f, -0.01589785f, 
    -0.19084366f, -0.05989737f, 0.14093459f, -0.03826354f, 0.03509238f, 0.19932730f, -0.03729859f, 0.11944320f, 
    -0.04944350f, 0.11802199f, -0.00127704f, 0.03043457f, -0.30393857f, 0.64446914f, -0.16527003f, 0.00198518f, 
    0.18572848f, -0.08950497f, 0.12944123f, 0.18801951f, -0.09935872f, 0.07110713f, 0.09293687f, -0.06956375f, 
    0.12178946f, 0.29263118f, 0.05241165f, 0.10447297f, -0.14359774f, 0.14718400f, 0.06136914f, -0.11857516f, 
    0.03214972f, -0.02866609f, -0.06132317f, 0.03725661f, -0.31622097f, 0.06587245f, -0.27344474f, -0.06426756f, 
    0.02860532f, -0.14835472f, 0.20434096f, 0.03929375f, -0.04758732f, -0.07115740f, 0.00555470f, 0.17104223f, 
    0.27401593f, 0.08724741f, -0.07080209f, 0.00216624f, -0.01010725f, 0.22937380f, 0.00487050f, 0.06951059f, 
    0.15047236f, 0.10276546f, 0.05660205f, -0.09096535f, 0.28632629f, 0.06090302f, 0.42754513f, 0.07234485f, 
    -0.12015886f, 0.16656528f, 0.06765036f, -0.18684535f, -0.13371283f, -0.05399349f, -0.01089376f, -0.01299693f, 
    -0.45185506f, 0.31847963f, -0.17313911f, 0.13781549f, -0.03803395f, 0.11140800f, 0.19541760f, 0.11707683f, 
    -0.14271002f, 0.13362123f, 0.00322762f, -0.28103817f, 0.02481722f, -0.27840540f, -0.11633126f, 0.05689263f, 
    0.06560455f, -0.03355680f, -0.08043414f, -0.15515897f, -0.06500442f, 0.03437893f, -0.10644618f, -0.01691229f, 
    0.11375786f, -0.10568481f, 0.32089061f, -0.12957148f, 0.11720864f, -0.00899313f, 0.35572571f, 0.01541330f, 
    0.18889254f, 0.19372271f, 0.21542415f, 0.06297054f, -0.02807548f, 0.04581426f, -0.14391680f, 0.06587216f, 
    0.10977150f, 0.10344534f, -0.01276333f, -0.00604238f, -0.12125884f, 0.03725315f, -0.14395019f, 0.14258878f, 
    -0.01793859f, 0.14765982f, -0.19104940f, -0.19872682f, 0.00178001f, -0.05847082f, -0.07355867f, -0.21861166f, 
    0.04007232f, -0.03158849f, 0.01992402f, 0.10592947f, -0.13739483f, -0.04067525f, -0.13322613f, 0.19664432f, 
    -0.07689279f, 0.11694872f, 0.05973758f, 0.09218547f, -0.02211056f, -0.06370627f, -0.12606883f, -0.11607806f, 
    0.32539245f, 0.12550826f, -0.09202442f, 0.02000921f, -0.00707760f, 0.11355794f, 0.18678480f, -0.03494095f, 
    -0.10863494f, 0.02511855f, -0.06718457f, -0.03991861f, 0.23714918f, -0.10177118f, 0.20447792f, -0.03614742f, 
    0.01181758f, 0.01604483f, -0.07226364f, -0.00435457f, -0.03821551f, 0.03707090f, -0.03881763f, 0.05189051f, 
    0.00446786f, 0.18309127f, -0.02574705f, 0.08422978f, 0.02635115f, 0.13256529f, -0.10304502f, -0.10859783f, 
    0.09115864f, 0.25161409f, -0.03683442f, 0.06737968f, 0.33586469f, 0.10303988f, -0.07290992f, -0.01045416f, 
    -0.02675630f, -0.03867691f, 0.01756961f, -0.14698230f, -0.15845183f, -0.01993230f, 0.10880048f, 0.00580287f, 
    0.34280494f, 0.15041488f, -0.00783457f, 0.11678293f, 0.21882191f, 0.11060157f, 0.17878921f, 0.01754934f, 
    0.06267821f, 0.05354150f, 0.14914210f, 0.18253994f, 0.54022205f, 0.17278820f, 0.10330316f, -0.15056735f, 
    0.03776974f, -0.20828186f, -0.15550448f, -0.17558591f, 0.00835327f, 0.00693938f, -0.08349396f, 0.16357394f, 
    0.32363141f, 0.08238034f, -0.15214968f, 0.07412097f, 0.07525904f, -0.08031392f, 0.00094430f, -0.12203890f, 
    0.03723478f, -0.05137599f, 0.01567414f, -0.08025934f, 0.22748750f, -0.07109796f, -0.20064445f, -0.30093575f, 
    0.10537840f, 0.08967096f, -0.06233716f, 0.31452191f, -0.03188722f, 0.15735252f, -0.12068546f, -0.06174119f, 
    0.10244246f, -0.23327737f, -0.27589190f, 0.15671912f, 0.07393610f, 0.02766749f, 0.03956735f, -0.05490515f, 
    -0.07812741f, -0.10316936f, 0.13034503f, 0.06082472f, 0.27808368f, -0.14743827f, -0.17902993f, 0.28009811f, 
    0.08834466f, -0.01627099f, 0.04366522f, -0.11710874f, -0.04824065f, -0.06088238f, 0.09389584f, 0.11909475f, 
    0.55293071f, -0.01275802f, -0.26692173f, -0.11432044f, 0.02492936f, 0.09895440f, 0.19471425f, 0.16110091f, 
    0.15044934f, 0.16529752f, -0.05744993f, 0.12120267f, 0.07997017f, 0.06394511f, -0.13837498f, 0.17732933f, 
    -0.04942716f, 0.06815013f, 0.13646318f, 0.03812030f, 0.06412537f, -0.01877994f, 0.10703137f, -0.00068827f, 
    0.10922871f, 0.04629805f, -0.22049080f, -0.39557782f, -0.29959276f, 0.05288257f, 0.02834773f, -0.13515443f, 
    -0.19055054f, -0.05334367f, -0.00414279f, -0.03859965f, -0.23855822f, -0.13026236f, -0.06236650f, 0.24511151f, 
    -0.06063218f, 0.02539171f, -0.04122023f, -0.01824084f, 0.10801001f, 0.07151863f, -0.24185033f, 0.00685539f, 
    -0.00363768f, -0.14428249f, -0.04762212f, 0.00673912f, 0.13023712f, 0.09880428f, 0.19661783f, 0.08815044f, 
    -0.01172168f, -0.08488465f, -0.05971357f, -0.01075990f, -0.02137441f, -0.01953286f, 0.08036785f, 0.07062562f, 
    0.09926977f, -0.02371139f, 0.10507943f, -0.08403731f, -0.01721758f, -0.05309486f, 0.05516851f, -0.07433806f, 
    0.37495545f, -0.11285991f, -0.12386147f, 0.34648064f, -0.03709179f, 0.01855102f, -0.16073178f, -0.01734960f, 
    -0.06970678f, -0.00721405f, -0.06468228f, 0.11181247f, -0.32245502f, -0.07279380f, 0.07719656f, -0.03758452f, 
    0.04052931f, -0.03089320f, -0.08469713f, 0.01548261f, -0.07266697f, 0.01313743f, 0.16085720f, 0.08135843f, 
    0.06130692f, -0.06498544f, 0.13092422f, 0.05832529f, -0.03360784f, 0.12297253f, 0.01587720f, 0.12043457f, 
    0.12901133f, 0.06140624f, 0.10719147f, 0.05991578f, -0.40462032f, -0.06834733f, 0.14488649f, -0.02891645f, 
    0.09290383f, 0.11484203f, -0.08804860f, 0.06797885f, 0.05278767f, -0.02428630f, -0.13072206f, 0.02002113f, 
    0.20567766f, -0.05357549f, -0.30562839f, -0.11376522f, 0.01212646f, 0.02916466f, 0.00685455f, -0.02231324f, 
    -0.08230410f, -0.16059561f, -0.19384854f, -0.10552377f, 0.06091601f, -0.44694704f, -0.22710453f, 0.38021418f, 
    -0.12667738f, -0.00204136f, -0.09785673f, 0.07387424f, -0.01859404f, 0.01263615f, -0.01665944f, 0.01168749f, 
    -0.16141783f, -0.24404109f, 0.25316399f, -0.22371218f, 0.07917669f, 0.08033472f, -0.01071598f, 0.17582996f, 
    -0.09086491f, -0.06603982f, -0.02117814f, -0.03113724f, -0.02949258f, -0.12514947f, 0.30815488f, 0.21105362f, 
    0.08281500f, 0.07389931f, -0.05187696f, -0.03854615f, 0.01091748f, 0.00082905f, 0.08337422f, 0.03824902f, 
    0.04598598f, 0.18974346f, 0.08295384f, 0.06383578f, -0.07869796f, -0.12606075f, 0.08097806f, -0.03788750f, 
    -0.06705318f, -0.09421162f, 0.02677913f, 0.08096877f, -0.21254817f, 0.02422615f, 0.13776290f, -0.00719780f, 
    0.07625868f, -0.04516030f, 0.08114725f, 0.13171421f, 0.08652082f, 0.08238527f, -0.08475447f, -0.01034679f, 
    0.39138019f, -0.03096703f, 0.26207262f, 0.00035013f, -0.02243667f, -0.19255573f, -0.09634963f, -0.11992572f, 
    0.13028304f, -0.12545179f, 0.09457979f, 0.10062479f, -0.07865804f, 0.15511328f, 0.22917672f, 0.03299192f, 
    0.05514604f, 0.01531269f, 0.00425405f, 0.10866618f, 0.01524430f, -0.06924611f, -0.02616244f, 0.00811117f, 
    0.00825499f, -0.02631877f, 0.02018364f, 0.05367764f, -0.02220352f, 0.10020694f, -0.18050510f, -0.05759402f, 
    0.02415600f, -0.04998099f, -0.02277573f, -0.20484473f, -0.12121153f, 0.07039823f, -0.03653010f, 0.05723925f, 
    -0.02572980f, -0.10564180f, 0.11149359f, -0.01017991f, 0.19446808f, -0.04797309f, 0.18674503f, 0.16531660f, 
    -0.10523696f, -0.04252114f, -0.03429663f, 0.05911034f, 0.05296555f, 0.27498820f, 0.11136278f, 0.04336084f, 
    0.01326635f, 0.07137301f, -0.02210226f, 0.08479183f, 0.01339645f, 0.19233793f, 0.16094646f, -0.09942693f, 
    0.05240677f, -0.17462428f, -0.03647179f, -0.22292045f, 0.10681488f, 0.07815392f, 0.07181478f, 0.07125270f, 
    -0.44440550f, -0.15781450f, -0.05505615f, 0.09411263f, -0.07731615f, -0.03482477f, -0.07315715f, -0.09121615f, 
    0.01308264f, -0.06192150f, 0.06535000f, 0.05780172f, 0.23155577f, 0.15216675f, 0.02491494f, 0.06134530f, 
    0.06734496f, -0.05166543f, 0.04087287f, 0.01807848f, 0.02692273f, 0.06348822f, 0.22881345f, 0.18358865f, 
    -0.03425908f, -0.18216762f, 0.21608365f, -0.26870078f, 0.07851704f, 0.12628961f, 0.11666700f, 0.18339391f, 
    0.28076234f, 0.17177382f, 0.27123287f, 0.03195097f, -0.36208001f, 0.20493659f, 0.04131962f, 0.22218589f, 
    0.14807953f, 0.09672358f, 0.00514865f, 0.17764904f, 0.06218125f, -0.02079928f, -0.26906076f, -0.00575913f, 
    0.16072394f, -0.04512450f, 0.01452227f, 0.13738169f, -0.11517287f, -0.15501419f, -0.34786808f, -0.20594478f, 
    0.13223381f, -0.03591394f, -0.18461186f, -0.04062335f, -0.13030384f, -0.42979142f, 0.25167361f, 0.43467441f, 
    -0.02929266f, 0.37951332f, -0.09463587f, 0.02683424f, 0.01845181f, -0.20416883f, -0.22715189f, 0.11529778f, 
    -0.11633430f, -0.17899290f, 0.21952356f, 0.15671778f, 0.23281616f, 0.11611422f, -0.10915148f, 0.24109055f, 
    -0.10953393f, 0.10180563f, -0.07101125f, 0.19215974f, 0.15277371f, -0.15388726f, 0.13746920f, 0.06298383f, 
    0.08596979f, 0.12463682f, -0.00810351f, -0.28306070f, 0.11071059f, 0.19508591f, 0.10056840f, 0.02759747f, 
    -0.15542510f, 0.20799799f, 0.25123453f, 0.12008773f, 0.01748007f, -0.22018848f, 0.18264432f, 0.08562654f, 
    -0.03964745f, 0.14115760f, 0.08682088f, 0.12952185f, -0.34835917f, 0.13911620f, -0.25331530f, -0.05207662f, 
    0.05885981f, -0.08327144f, -0.08896248f, 0.09139736f, -0.03690816f, -0.09563020f, -0.07764785f, 0.13833934f, 
    -0.26068246f, 0.12436699f, 0.63244504f, 0.05343110f, 0.12871210f, 0.00889568f, -0.08674776f, 0.08508600f, 
    -0.02913341f, -0.05143953f, 0.02491603f, 0.01870724f, 0.03930916f, 0.17989179f, 0.12703915f, -0.08309491f, 
    0.08473014f, 0.10615699f, 0.06884201f, -0.06776743f, -0.02183009f, 0.03809034f, -0.03273568f, -0.25053552f, 
    -0.09286215f, 0.28860655f, -0.06324336f, 0.10987950f, 0.22449951f, 0.07482930f, -0.42227155f, 0.06769232f, 
    -0.13443376f, -0.01420477f, 0.02163809f, 0.03942434f, 0.00549675f, 0.22005807f, 0.12328063f, -0.03791595f, 
    0.08090764f, -0.21678859f, 0.15526332f, 0.04129064f, 0.21187228f, 0.14477845f, 0.28883323f, 0.01023907f, 
    -0.10137409f, -0.22837339f, 0.03394419f, 0.19351208f, -0.01597956f, 0.12552303f, 0.15261325f, 0.18906052f, 
    0.05877972f, 0.14340369f, 0.01393069f, 0.02254218f, -0.06799690f, 0.28840482f, 0.06749162f, 0.08195245f, 
    0.18021035f, 0.10132156f, 0.06415658f, 0.04543882f, 0.08791876f, -0.03498235f, -0.03310386f, -0.07248355f, 
    -0.30461124f, -0.23792432f, 0.05720547f, 0.05189100f, -0.02928338f, -0.05102910f, 0.05663877f, -0.16215537f, 
    0.02774823f, -0.07020478f, 0.15060861f, 0.19756930f, -0.28521410f, -0.28891203f, -0.30220744f, -0.28500831f, 
    0.00796821f, 0.01369074f, 0.11526212f, -0.11611988f, 0.17919172f, 0.14982933f, 0.06391122f, 0.00095191f, 
    -0.06945964f, -0.04142331f, -0.05092660f, -0.02912919f, -0.07595386f, -0.07571433f, -0.07786787f, 0.03522006f, 
    0.03630272f, -0.05571237f, -0.03727579f, -0.01251012f, -0.02371677f, -0.01951546f, -0.08110056f, -0.02437930f, 
    -0.04013857f, 0.01874876f, -0.03177847f, 0.01733691f, -0.07419985f, 0.02080866f, -0.03019153f, 0.05539511f, 
    -0.07905917f, -0.05836890f, 0.04237511f, -0.04110509f, 0.04545277f, -0.03433306f, -0.03148842f, -0.01037799f, 
    -0.00650185f, -0.02902736f, 0.01789925f, 0.05557711f, 0.00690653f, 0.01726338f, 0.01644426f, -0.03700400f, 
    -0.05959563f, -0.07138871f, -0.07406451f, 0.02846915f, 0.05777428f, 0.03020810f, 0.04935527f, -0.00934360f, 
    0.00086827f, -0.04666356f, -0.04487624f, 0.04718064f, -0.03354739f, -0.04629549f, -0.03385885f, -0.05586616f, 
    0.04651012f, 0.01847075f, -0.07854401f, 0.03248448f, 0.03034813f, -0.02787312f, -0.00775282f, -0.00458581f, 
    -0.01934006f, 0.04074400f, 0.04513015f, -0.07208475f, 0.00953179f, 0.00512128f, 0.02660088f, -0.02595885f, 
    -0.00100490f, 0.05737253f, 0.02111563f, -0.06920455f, 0.00494757f, 0.01528188f, -0.06308335f, -0.02882402f, 
    -0.06301332f, -0.02816215f, 0.03824157f, -0.03171907f, 0.01644858f, 0.05466044f, 0.05654725f, 0.06121761f, 
    0.04662437f, 0.00847603f, 0.05705013f, -0.00194173f, 0.00104693f, 0.01276388f, -0.03289064f, 0.03123988f, 
    -0.07873271f, -0.00734909f, -0.05909124f, 0.02303220f, -0.01727024f, 0.00366872f, -0.04749575f, -0.02951898f, 
    -0.03122026f, -0.04743093f, 0.00562123f, -0.03911258f, -0.01460134f, -0.03425862f, -0.02840729f, -0.08134609f, 
    -0.02116896f, 0.00919896f, 0.00929012f, 0.03385845f, 0.02492417f, 0.02549627f, 0.00849157f, -0.08395599f, 
    0.02078676f, 0.03536788f, -0.06690612f, 0.05321928f, -0.06328334f, -0.00139128f, -0.08356259f, -0.01652033f, 
    0.03399029f, -0.04257329f, -0.03602706f, 0.01251701f, -0.02670855f, -0.03394870f, -0.07974186f, -0.04060532f, 
    -0.06069509f, -0.03535298f, 0.01076455f, -0.00613412f, 0.04330671f, -0.01227752f, 0.00510146f, -0.00074203f, 
    -0.05571898f, 0.00070071f, 0.03080323f, -0.05024036f, 0.00438714f, 0.01055721f, 0.01685897f, 0.02362080f, 
    -0.00368074f, -0.05981901f, -0.01942109f, -0.07824222f, 0.06099799f, 0.05748859f, 0.00925350f, 0.02154651f, 
    -0.04762906f, 0.05624172f, -0.01339986f, -0.00796143f, 0.04243023f, 0.04156841f, 0.05064776f, -0.03454966f, 
    -0.05688724f, -0.06728712f, -0.07690065f, -0.00724109f, 0.00277420f, 0.01070659f, -0.06519913f, 0.02085940f, 
    -0.02732321f, 0.01769478f, -0.03255652f, 0.05376594f, 0.00996212f, -0.06842831f, 0.05525428f, 0.03270450f, 
    -0.00785173f, -0.07945155f, -0.06755786f, 0.02684916f, 0.01702419f, -0.03953154f, 0.05498382f, 0.02229016f, 
    -0.29359314f, -0.14507148f, -0.06597857f, -0.50507885f, 0.12179103f, -0.05131637f, 0.19690326f, 0.21349196f, 
    -0.04072402f, -0.16811638f, -0.10096282f, -0.21069869f, 0.26488546f, 0.15462893f, 0.41364044f, 0.04107992f, 
    0.01252416f, 0.08022653f, 0.25244749f, 0.24323267f, 0.21178597f, 0.13122523f, 0.01070643f, 0.06747849f, 
    0.00306875f, -0.25330091f, 0.16260344f, -0.11352675f, -0.22369330f, 0.07461774f, -0.21262614f, 0.02100705f, 
    0.20005573f, 0.24899012f, 0.19990152f, 0.08196466f, 0.27304438f, -0.18978965f, 0.24411109f, -0.18030781f, 
    0.08685101f, 0.06841799f, 0.13120164f, 0.01462899f, 0.04391064f, 0.01779635f, 0.00149513f, -0.06511725f, 
    0.04612616f, 0.05124244f, 0.21721098f, -0.04963187f, 0.01269693f, 0.12769175f, 0.08363903f, -0.06369893f, 
    -0.08557453f, 0.07592807f, 0.12277167f, 0.26644963f, 0.15523671f, 0.16687171f, 0.05661942f, -0.05457722f, 
    0.09613408f, 0.16820368f, 0.05892830f, -0.08281486f, -0.02678162f, -0.10346090f, -0.03927048f, -0.18688042f, 
    -0.13287894f, -0.11574794f, 0.11736979f, -0.24224862f, 0.08607436f, 0.00890690f, 0.00231227f, 0.17692947f, 
    0.09983064f, 0.01099441f, 0.06257238f, -0.09680665f, 0.03594514f, 0.14920607f, -0.21095516f, -0.12819019f, 
    -0.04352827f, 0.05031541f, 0.04410613f, 0.17807779f, -0.00589077f, -0.19492221f, -0.00551790f, -0.03973446f, 
    -0.55008286f, -0.33315381f, -0.07298799f, -0.19827422f, 0.06753851f, -0.10479371f, -0.25083628f, 0.02822031f, 
    -0.02158058f, 0.08213493f, 0.01565417f, -0.19620970f, 0.06908830f, -0.10560425f, 0.09162934f, 0.07847570f, 
    0.02281052f, 0.19634992f, 0.19091451f, 0.22906044f, 0.13184072f, 0.05086168f, 0.10540406f, 0.03399522f, 
    -0.06841628f, 0.47836548f, -0.02156582f, 0.49521306f, 0.03348013f, 0.12810324f, -0.23355387f, 0.18112563f, 
    0.17961068f, -0.02924000f, 0.09379923f, 0.18778260f, 0.05864199f, -0.06863669f, 0.08666615f, -0.26600331f, 
    0.01391156f, -0.13809790f, 0.00739614f, 0.23879726f, -0.07107852f, -0.02154696f, -0.03777931f, -0.47659469f, 
    0.14419110f, -0.08582669f, 0.03038130f, -0.01441476f, 0.07623081f, -0.32219160f, -0.15466237f, 0.17659713f, 
    -0.30958611f, -0.24549827f, -0.02499128f, -0.22472201f, -0.08371627f, -0.10799631f, -0.29795709f, -0.06311808f, 
    0.00786205f, 0.07538623f, 0.10807124f, 0.38782373f, -0.02681398f, 0.16480857f, 0.09583654f, -0.02526944f, 
    -0.00077781f, 0.00189307f, 0.11237878f, -0.26741111f, 0.07255893f, -0.02667071f, 0.12771301f, 0.22884165f, 
    0.01608811f, 0.14331385f, -0.07192916f, 0.04598821f, -0.29150784f, -0.17985672f, 0.10825409f, 0.07986023f, 
    -0.13764165f, 0.14563604f, 0.07115825f, -0.06068515f, -0.14273103f, -0.09882059f, -0.36543339f, -0.30818859f, 
    -0.00338712f, 0.00941364f, -0.03091725f, -0.03191327f, -0.06678424f, -0.05566584f, -0.03449145f, -0.02120786f, 
    -0.02652476f, -0.01921919f, -0.05905331f, -0.00101637f, -0.06086902f, -0.07258967f, -0.00022723f, -0.01554489f, 
    0.00094305f, -0.00923504f, -0.06036706f, -0.01103479f, 0.02547644f, 0.03263141f, 0.04453261f, -0.03742804f, 
    -0.00532438f, -0.07399412f, 0.00098689f, 0.05428913f, 0.00464424f, -0.01370823f, -0.00468158f, -0.00430051f, 
    -0.03816064f, -0.02684439f, 0.04615927f, -0.05066797f, 0.05501584f, -0.03315538f, -0.05013340f, -0.08034620f, 
    0.00331207f, -0.01654104f, -0.03198166f, -0.03605247f, 0.06568351f, 0.05067417f, -0.05389615f, -0.04678684f, 
    0.02764024f, 0.02513121f, 0.02869821f, -0.03581166f, -0.05779953f, 0.02259052f, 0.02958398f, -0.05044373f, 
    0.05470907f, 0.00264832f, 0.04763446f, -0.02554601f, -0.01012562f, 0.06023788f, 0.03577939f, -0.08043133f, 
    -0.05800182f, 0.04176668f, -0.02297034f, 0.02347762f, -0.01765449f, -0.07183885f, -0.03314871f, 0.06433304f, 
    -0.03353655f, 0.05827465f, -0.06506404f, -0.02527505f, -0.03348155f, 0.06385130f, -0.03259224f, 0.02445961f, 
    0.03434056f, 0.05168203f, -0.02729823f, 0.04030732f, 0.03507543f, -0.00952108f, -0.05094073f, -0.01551306f, 
    0.05220110f, -0.01144174f, -0.05391460f, 0.03511810f, -0.00325323f, 0.01367252f, 0.00489558f, -0.04012815f, 
    -0.00582443f, -0.01679808f, 0.07198976f, -0.00218601f, 0.03756677f, -0.07734548f, -0.02064409f, 0.00877699f, 
    -0.05814727f, -0.01187171f, 0.01237937f, -0.00789349f, 0.04531721f, -0.02403173f, -0.02365218f, -0.05782777f, 
    0.02589837f, -0.07809925f, -0.03190693f, 0.02703418f, -0.04963571f, 0.00237164f, -0.07598824f, 0.04808682f, 
    -0.07709730f, 0.05318077f, -0.01895921f, -0.00423356f, 0.06377110f, 0.03271814f, 0.03910280f, 0.05981872f, 
    -0.00684356f, -0.01795392f, 0.01351762f, 0.01296974f, -0.06658832f, -0.05165723f, 0.04002326f, -0.00022464f, 
    0.01054907f, -0.01756952f, -0.05845560f, -0.04752754f, 0.05640953f, 0.03195561f, -0.04229494f, 0.05492505f, 
    0.00159906f, -0.00688317f, -0.03252454f, 0.04239757f, 0.03727662f, 0.04457656f, 0.02920239f, -0.07890975f, 
    -0.04105464f, -0.07343910f, -0.05309619f, -0.06640834f, -0.02076362f, 0.01742820f, 0.02700236f, -0.05888591f, 
    0.01382199f, 0.00762698f, 0.00145063f, -0.05314960f, -0.03228009f, 0.00102913f, -0.05231046f, 0.04479992f, 
    -0.06554410f, 0.03916568f, -0.01497106f, -0.02339074f, -0.02084265f, -0.04257778f, 0.06251067f, -0.08065186f, 
    -0.02031738f, 0.04474111f, -0.05511851f, 0.02121591f, 0.01647332f, 0.02526377f, -0.03822996f, -0.02580268f, 
    -0.00804231f, 0.03118123f, -0.05545175f, -0.02855702f, -0.05554161f, -0.02145302f, -0.02902286f, -0.06558355f, 
    -0.15497084f, -0.07846256f, -0.08344282f, -0.22485524f, 0.03980603f, -0.12569538f, 0.09911007f, 0.04468475f, 
    -0.13345151f, -0.10934759f, 0.00704996f, -0.11698624f, -0.04324260f, 0.54278940f, 0.06992529f, 0.45803368f, 
    -0.02683921f, 0.07227510f, 0.19820282f, 0.09990076f, -0.01623609f, 0.10617920f, -0.13239403f, 0.02563385f, 
    0.20344199f, -0.18679951f, 0.40735501f, -0.04226992f, -0.18882960f, 0.18404627f, -0.12597100f, -0.07771356f, 
    0.09060012f, 0.16015857f, 0.14402564f, 0.10223341f, -0.02043766f, -0.00469333f, 0.51219785f, -0.10198599f, 
    0.01566375f, 0.06826179f, -0.01129404f, -0.00571402f, -0.02030249f, 0.04864731f, -0.08754200f, 0.09861388f, 
    0.01025721f, -0.02391499f, 0.36123264f, 0.10402785f, 0.07438600f, 0.18052706f, -0.20193766f, -0.04116166f, 
    -0.07892662f, 0.12498214f, 0.12299269f, 0.17078984f, 0.07308847f, 0.06278651f, 0.09614487f, -0.04894949f, 
    0.05933926f, 0.05591463f, 0.18641125f, -0.27503607f, 0.00798524f, 0.03156268f, -0.00057305f, -0.05301400f, 
    -0.14755915f, -0.19502261f, -0.05830616f, 0.03854991f, 0.02433313f, 0.02242222f, 0.02684560f, 0.12359162f, 
    0.08440661f, -0.02386143f, 0.09721331f, -0.05858063f, -0.00030172f, 0.08020961f, -0.29526266f, 0.10485791f, 
    -0.04148670f, -0.04644550f, -0.15130632f, 0.04997415f, -0.01786752f, -0.08215960f, 0.01406987f, 0.03650121f, 
    -0.57674670f, -0.11709202f, -0.27613583f, -0.36280975f, 0.01464697f, -0.00616713f, -0.03288715f, -0.01424884f, 
    0.08726042f, 0.11247675f, 0.01885582f, -0.10008334f, 0.18298191f, -0.06163559f, 0.02903393f, 0.03932475f, 
    0.03612124f, 0.13642563f, 0.03471703f, 0.11562614f, -0.00290460f, 0.10514788f, 0.06205185f, 0.02490421f, 
    0.23427603f, 0.35253176f, -0.01814395f, 0.19831999f, 0.00924538f, 0.10385536f, -0.17581753f, 0.00664619f, 
    0.00311140f, 0.09868110f, 0.12711783f, 0.17826894f, -0.05601112f, -0.08259679f, -0.16233140f, 0.12175293f, 
    0.11274116f, -0.05731152f, 0.05122356f, 0.18439107f, -0.12757117f, -0.03443953f, -0.03767289f, -0.26753363f, 
    0.07391822f, 0.00962462f, 0.02406479f, 0.03059531f, -0.05141899f, -0.23132835f, -0.02296430f, 0.11079979f, 
    0.01889880f, -0.07063096f, -0.13431260f, -0.04109720f, -0.17965621f, -0.15369505f, -0.36499223f, 0.39484468f, 
    0.14076224f, 0.08836499f, 0.15947685f, 0.18859577f, 0.02964747f, -0.03324473f, -0.02661586f, -0.04038196f, 
    0.05424165f, -0.22846870f, 0.10349604f, -0.04678255f, -0.02576048f, -0.11785513f, 0.26309994f, 0.09012632f, 
    -0.08188660f, 0.08883969f, -0.04316908f, 0.08964016f, -0.00689011f, -0.19688125f, 0.21937224f, 0.03993412f, 
    -0.08718409f, -0.02650086f, -0.06711051f, -0.06880021f, -0.08092717f, -0.02588275f, -0.36632571f, -0.34762186f, 
    0.04704313f, 0.06530908f, 0.01892907f, 0.07104212f, -0.05316421f, 0.16218215f, 0.03576136f, 0.00400902f, 
    0.05780524f, 0.04066456f, -0.06301948f, -0.05777323f, -0.06824168f, -0.10992438f, 0.12925369f, 0.02314823f, 
    -0.11029610f, 0.05015460f, -0.06503128f, -0.00248051f, 0.00664839f, -0.01712134f, -0.15254083f, 0.03424970f, 
    0.22329237f, -0.13803247f, 0.35627383f, -0.14928514f, 0.10307360f, -0.01025582f, -0.00686641f, -0.05629763f, 
    0.12527683f, -0.12169947f, 0.09690253f, -0.08102772f, 0.49727786f, 0.30260187f, 0.30978480f, -0.36560315f, 
    -0.04610392f, -0.07491688f, 0.03706600f, -0.15004346f, 0.08163282f, -0.00106336f, -0.11969057f, 0.05738957f, 
    0.24099067f, -0.09571154f, 0.41047630f, -0.03983811f, 0.14612547f, -0.00889289f, -0.21023895f, 0.16909245f, 
    -0.00697678f, 0.05983223f, 0.01851168f, -0.04988847f, 0.30738011f, 0.22958928f, 0.26508600f, 0.00810548f, 
    0.08593950f, 0.14310651f, -0.03034970f, -0.18486050f, -0.02714870f, 0.09091437f, -0.06739580f, -0.00312210f, 
    -0.21334091f, -0.09688244f, 0.16842644f, -0.34952074f, 0.13017604f, -0.11608452f, 0.07150175f, -0.00269015f, 
    -0.10770255f, 0.05442245f, 0.16804004f, 0.04485649f, 0.18292496f, -0.12172617f, -0.54495209f, 0.01150861f, 
    0.07829838f, 0.14167035f, -0.04216142f, 0.16622093f, -0.10044027f, 0.02241237f, -0.00788534f, 0.11026543f, 
    0.35342053f, 0.12381838f, -0.13167006f, 0.02346279f, 0.12903722f, 0.09551362f, 0.00377941f, -0.17372634f, 
    0.08059640f, -0.06084163f, -0.00452513f, 0.12607558f, 0.28800046f, 0.24963634f, -0.13467737f, 0.04072542f, 
    -0.04632651f, 0.03492974f, 0.11598065f, 0.16346200f, 0.00565984f, -0.03385434f, 0.08669402f, -0.15863459f, 
    -0.07505248f, 0.05657573f, -0.09055298f, 0.16229872f, -0.16088733f, 0.19109218f, -0.22815327f, 0.03111982f, 
    -0.16826314f, -0.21073817f, -0.05666824f, 0.02308482f, -0.26396534f, -0.17827772f, 0.16776811f, 0.00370996f, 
    0.05833643f, -0.07323605f, -0.07483806f, 0.05529906f, 0.02308163f, 0.05786307f, 0.03280389f, 0.02987970f, 
    0.34138837f, 0.16519691f, 0.19687612f, -0.14838207f, 0.11436904f, -0.05746691f, 0.09562479f, 0.36151877f, 
    -0.05381202f, 0.08955961f, 0.14079289f, 0.12320156f, 0.19019674f, -0.20863852f, 0.13718507f, 0.16145499f, 
    0.04322624f, -0.13881356f, -0.00721680f, 0.05291662f, -0.10505963f, 0.03868013f, 0.00310186f, 0.02862955f, 
    0.12545550f, -0.00350686f, -0.14763279f, -0.03963451f, -0.01938725f, -0.04716031f, -0.02914910f, -0.16099116f, 
    0.03396338f, 0.03426464f, -0.00572984f, 0.07656071f, -0.22809216f, -0.18511064f, -0.02749701f, 0.03112928f, 
    -0.02686498f, 0.00183245f, 0.12794665f, -0.01129820f, -0.01417557f, 0.12257094f, 0.07976716f, 0.08538868f, 
    -0.01124242f, 0.07765903f, 0.01063462f, 0.02657108f, 0.09884617f, -0.17942971f, -0.06048011f, 0.10871929f, 
    0.07512727f, 0.17932180f, 0.12141857f, 0.05235314f, 0.14669122f, 0.51848304f, -0.42051086f, -0.11175797f, 
    0.01710072f, -0.05820410f, 0.08180220f, 0.15709683f, -0.11856987f, -0.06222445f, 0.12347711f, -0.09891110f, 
    -0.01394972f, 0.06560444f, -0.09165022f, 0.17939979f, 0.08932213f, 0.00991747f, -0.06995887f, 0.06193589f, 
    0.02203738f, 0.13473600f, -0.05970675f, 0.03147480f, -0.37362021f, 0.32789075f, 0.00266416f, 0.08440332f, 
    -0.03181536f, -0.01463623f, -0.15996091f, 0.07935619f, -0.09393425f, 0.14527185f, -0.00189332f, 0.09537898f, 
    -0.07491685f, 0.30203170f, -0.46956080f, 0.20535953f, -0.01549561f, 0.00770702f, 0.14023894f, -0.05534421f, 
    0.06540442f, -0.00632466f, -0.01746194f, -0.04654506f, 0.03903738f, -0.13034883f, -0.22632387f, -0.02416257f, 
    0.02508214f, 0.00103969f, 0.06121188f, 0.16595019f, 0.01998837f, -0.03331799f, -0.09138358f, -0.09055909f, 
    0.26779023f, 0.11135058f, -0.12475945f, 0.32360333f, 0.04925203f, 0.00034352f, 0.01674702f, 0.01049663f, 
    0.08461617f, -0.03776689f, -0.26963651f, 0.14847448f, -0.02017833f, 0.19049515f, 0.31901899f, 0.14947952f, 
    0.10413511f, -0.01541706f, -0.06427620f, -0.08034975f, 0.02684308f, 0.02525234f, 0.09539095f, 0.02674072f, 
    -0.28509837f, -0.21641763f, 0.07394335f, 0.24222882f, 0.13445903f, 0.07652134f, 0.08984677f, 0.00826043f, 
    -0.00010502f, 0.07569469f, -0.03252692f, 0.03347082f, -0.06317106f, -0.04889404f, -0.07373741f, 0.06875726f, 
    0.14055483f, 0.18246897f, 0.03823084f, -0.00136786f, 0.06785895f, 0.01259510f, 0.00087494f, 0.08459389f, 
    0.08573446f, -0.08953408f, -0.16093129f, -0.26463538f, 0.03759731f, -0.25940743f, 0.18825363f, 0.05864223f, 
    0.00738205f, 0.05816914f, 0.05531083f, 0.08103166f, 0.12853563f, 0.04828538f, -0.05633699f, 0.29069531f, 
    0.09598116f, 0.15577662f, -0.02720737f, -0.11888354f, 0.17059776f, 0.02519014f, 0.01343097f, 0.06732877f, 
    -0.24132212f, -0.07859231f, -0.07559536f, 0.15517482f, -0.06896925f, -0.00719046f, -0.03188596f, -0.13201766f, 
    -0.01705670f, -0.09731676f, -0.08861810f, 0.01538557f, -0.25710917f, 0.20777456f, -0.14301935f, -0.07046921f, 
    0.06904363f, 0.17688040f, -0.10498261f, 0.08225687f, -0.00956090f, 0.12338912f, 0.11785325f, -0.04900993f, 
    0.23800069f, -0.07046996f, 0.32123718f, 0.30301356f, 0.13365182f, -0.00313574f, 0.08223128f, 0.17986882f, 
    -0.04739476f, 0.00519906f, 0.03529843f, 0.01133282f, -0.24281898f, -0.08536194f, -0.09823557f, -0.09647879f, 
    -0.04309387f, 0.00360121f, -0.06003522f, -0.09133814f, 0.04546963f, 0.01759838f, -0.11524765f, -0.18212706f, 
    -0.33568782f, 0.13284995f, -0.08484428f, -0.01747396f, -0.04954887f, 0.02782409f, -0.04674970f, 0.06463630f, 
    0.03442080f, 0.02724137f, -0.13248430f, -0.04756257f, 0.10845090f, 0.26299557f, -0.54154962f, 0.25391039f, 
    0.04760404f, 0.05885496f, 0.21166180f, -0.00291176f, -0.02621157f, 0.06362267f, 0.36888513f, 0.04591480f, 
    -0.02094449f, -0.13680404f, 0.12037824f, -0.00020778f, 0.13970597f, -0.10304560f, -0.01487961f, 0.04630066f, 
    -0.10814793f, 0.12669195f, 0.07268985f, 0.02343774f, 0.60705084f, 0.61415011f, -0.08357304f, -0.28516519f, 
    0.27761337f, -0.15329315f, 0.04599286f, 0.04696426f, 0.05562853f, -0.01695751f, 0.22502393f, 0.03247469f, 
    -0.03038064f, 0.23684634f, -0.09577268f, 0.23286895f, 0.05654896f, -0.08924231f, 0.08274840f, -0.13885137f, 
    0.06469601f, -0.05417165f, -0.16248599f, 0.03139577f, -0.08132470f, -0.17183930f, -0.30082911f, 0.06333183f, 
    0.06201535f, -0.17632532f, -0.03184814f, 0.20691270f, 0.06764331f, 0.00272881f, 0.12780727f, 0.18483087f, 
    0.07741258f, 0.05956347f, -0.11413430f, 0.08153778f, 0.13823806f, -0.03516481f, 0.12052088f, 0.10985623f, 
    -0.02111202f, 0.20214885f, 0.06390457f, 0.18269373f, 0.06865487f, 0.01307866f, 0.06216184f, 0.13063408f, 
    0.09236366f, 0.02408436f, 0.02414969f, -0.10225886f, -0.16070512f, -0.16594990f, 0.07506704f, 0.07680319f, 
    -0.48453927f, 0.01640062f, -0.13598569f, 0.08154307f, -0.01902432f, -0.02765091f, 0.05373523f, 0.01439564f, 
    -0.10582189f, 0.03665932f, -0.03628843f, -0.07409222f, -0.06093438f, -0.11503946f, -0.14052549f, 0.11242761f, 
    0.05146398f, -0.01950757f, -0.02327503f, -0.02629544f, -0.13192014f, -0.10691876f, -0.10363884f, -0.16836274f, 
    -0.39577129f, 0.12381990f, -0.05400941f, -0.12347936f, 0.28351212f, -0.02944975f, 0.23246416f, 0.12121274f, 
    -0.03530513f, 0.01809938f, 0.10450866f, 0.10546368f, -0.12351175f, 0.12326363f, 0.12335094f, 0.07499409f, 
    -0.12500536f, 0.13049294f, 0.01644649f, 0.01739290f, -0.08003369f, 0.28642187f, 0.01962537f, 0.14536062f, 
    -0.05382480f, -0.28326905f, -0.14235939f, -0.08377995f, -0.07741764f, -0.21580158f, 0.09397306f, -0.08055064f, 
    -0.07681960f, -0.04687663f, 0.03511342f, 0.06302121f, -0.35194546f, -0.14984187f, -0.00688965f, -0.22413588f, 
    -0.16183390f, 0.25245371f, 0.12284508f, 0.01658321f, -0.12866779f, -0.08723231f, 0.05586959f, -0.07913898f, 
    0.37698063f, -0.02936540f, 0.02793940f, 0.06050954f, -0.00495233f, 0.05513904f, -0.00297065f, -0.04337857f, 
    -0.03460731f, 0.02730665f, -0.01255102f, -0.03641528f, -0.00250071f, -0.19890024f, 0.27733922f, -0.29188636f, 
    -0.10992903f, -0.01830201f, 0.07947257f, 0.04088376f, -0.01099468f, 0.11198324f, 0.25467405f, 0.06935070f, 
    0.05524460f, -0.07113962f, -0.11171769f, -0.12728864f, 0.13584571f, -0.03274133f, -0.05112372f, 0.06788409f, 
    0.31211615f, -0.06539176f, -0.04889783f, 0.04068468f, -0.55948013f, -0.01908076f, -0.19022363f, -0.03831508f, 
    0.10010505f, 0.25122619f, 0.12375545f, -0.02994516f, 0.00333609f, 0.02495459f, -0.00120046f, 0.03509863f, 
    -0.07022507f, 0.00118152f, 0.00348183f, 0.01168990f, -0.07663735f, 0.06016923f, 0.06161833f, 0.10270271f, 
    0.06666475f, 0.21790308f, 0.03827100f, 0.06743785f, 0.37233636f, 0.19465648f, -0.09724250f, -0.19377172f, 
    -0.03759373f, 0.07764133f, 0.14665464f, 0.17110193f, -0.14539941f, 0.03001767f, 0.08010196f, 0.00627919f, 
    -0.03752168f, -0.19007824f, 0.40763831f, -0.31894374f, -0.14629290f, 0.10117952f, 0.00566948f, -0.00728662f, 
    -0.12766083f, 0.02735842f, 0.01959372f, 0.06094293f, 0.11275414f, -0.38072801f, -0.02713257f, -0.18211824f, 
    0.19341297f, 0.12241147f, -0.00588418f, 0.16474043f, -0.15346496f, -0.01384578f, -0.04175657f, -0.12285495f, 
    0.05092005f, 0.32255670f, 0.11101910f, -0.25178555f, -0.06632376f, 0.00005614f, 0.03603763f, -0.20948587f, 
    0.13928515f, 0.14902152f, -0.00474102f, -0.09357855f, -0.03758235f, 0.00724388f, -0.13480350f, 0.00064609f, 
    -0.04357667f, 0.20435637f, -0.16808805f, -0.41091186f, 0.13744771f, -0.02060525f, -0.01903213f, 0.05253459f, 
    0.33063781f, 0.34225357f, 0.18590042f, 0.28176391f, -0.02673415f, -0.12253880f, -0.11253534f, -0.22931023f, 
    0.20880215f, 0.23201315f, 0.15235806f, 0.11632390f, 0.04332306f, 0.14721382f, -0.10810944f, -0.34220669f, 
    -0.14846160f, -0.35553536f, -0.25511333f, -0.11711834f, -0.04572925f, -0.08026282f, -0.03924827f, 0.01922644f, 
    -0.20335512f, 0.10036133f, -0.11253464f, -0.19692868f, 0.28718990f, 0.06449257f, 0.00500479f, -0.02193936f, 
    0.22134665f, -0.05714157f, 0.11627258f, 0.09405169f, 0.17421240f, 0.09824681f, 0.14518981f, -0.17673641f, 
    -0.02851297f, -0.07408687f, -0.05513577f, -0.03787877f, -0.13897082f, 0.08301647f, 0.04733654f, -0.31501955f, 
    -0.09159331f, -0.32056779f, -0.20141770f, -0.33087039f, -0.10420583f, 0.20354144f, 0.04529040f, -0.22135191f, 
    -0.06801361f, 0.04185373f, 0.01094092f, -0.07542254f, -0.03254296f, -0.00583144f, 0.08344992f, 0.10915926f, 
    0.01694205f, -0.00161855f, 0.11632159f, -0.16032019f, 0.04014857f, 0.02536011f, -0.07960617f, 0.08163223f, 
    -0.21616508f, -0.01808129f, 0.01759553f, -0.16493270f, -0.20170611f, 0.11594581f, -0.15651421f, -0.24924895f, 
    0.00822000f, 0.05301291f, -0.01028675f, -0.25688496f, -0.08200637f, -0.04003478f, 0.08192466f, -0.01056345f, 
    0.08011383f, 0.09056687f, -0.02952866f, -0.05670596f, -0.35856801f, -0.33250266f, 0.15884139f, 0.30635673f, 
    -0.12920788f, -0.00581937f, -0.01617465f, -0.26167437f, 0.18494861f, -0.10942065f, 0.12222711f, 0.14722787f, 
    -0.03619469f, -0.09361148f, -0.02446676f, 0.04344634f, 0.34767589f, -0.00921355f, 0.30986869f, -0.27090308f, 
    0.00179877f, -0.03386007f, 0.15601669f, 0.10513870f, 0.11815705f, 0.09836770f, 0.03052236f, -0.07768144f, 
    -0.04642522f, -0.07511054f, -0.13694496f, 0.06091866f, -0.05420380f, 0.06900959f, 0.07902801f, -0.07946962f, 
    0.08214838f, 0.24011697f, 0.12186538f, 0.14379904f, 0.16109824f, -0.55403173f, 0.21504341f, -0.10576408f, 
    0.06026417f, 0.02885492f, 0.08694360f, 0.00643858f, -0.00969966f, 0.04526118f, 0.03532087f, -0.14251713f, 
    -0.04276195f, 0.06117617f, -0.12373712f, -0.12641211f, 0.03385228f, -0.07600380f, 0.14729401f, -0.08525658f, 
    0.04044476f, 0.05483622f, 0.03757003f, 0.04481084f, 0.12924930f, -0.09102909f, 0.17206199f, -0.06985107f, 
    0.00199669f, 0.11478530f, 0.10268559f, -0.04386653f, 0.14359814f, -0.06231304f, -0.02604840f, -0.21828416f, 
    -0.25530916f, -0.06500389f, -0.01599207f, -0.24278313f, 0.00994714f, 0.09243491f, -0.02669399f, 0.17215681f, 
    0.01306815f, -0.09607804f, 0.01277594f, -0.01422109f, -0.04660532f, 0.17108402f, -0.09406736f, -0.17505734f, 
    0.06455681f, -0.07889239f, 0.12903035f, 0.12322021f, 0.12837018f, -0.02231506f, -0.03613852f, -0.02666872f, 
    -0.00480434f, -0.49431622f, 0.04728346f, -0.07169516f, -0.01471529f, 0.05299692f, -0.07185739f, 0.00546430f, 
    0.02919546f, 0.02930134f, 0.08578297f, 0.02398525f, -0.09917466f, -0.04028733f, 0.08985790f, -0.03375040f, 
    0.03506835f, 0.19335844f, 0.16432658f, 0.22897646f, 0.02256181f, 0.05695949f, 0.05771200f, 0.12053146f, 
    0.07526403f, 0.34456152f, -0.22190532f, 0.20781708f, -0.00400714f, -0.06282026f, -0.00950818f, 0.07389124f, 
    0.19752894f, 0.03920200f, -0.00127139f, 0.19719024f, 0.21279116f, -0.17263517f, 0.02832352f, -0.10821690f, 
    0.09806163f, 0.03164020f, -0.04693965f, 0.01384214f, 0.14738367f, -0.05340732f, 0.12962560f, -0.25630975f, 
    0.06234556f, -0.15223430f, 0.06288581f, 0.08898782f, 0.09502909f, -0.16464140f, -0.19785771f, 0.04804697f, 
    -0.04844282f, -0.12375310f, -0.03527427f, -0.25223878f, 0.05813912f, -0.03884679f, -0.20154420f, -0.27552274f, 
    -0.05968157f, 0.13107628f, 0.10813677f, 0.25347570f, 0.02268221f, -0.02215437f, 0.06139715f, 0.07124880f, 
    -0.24678892f, 0.19816042f, 0.13535899f, -0.12970029f, 0.02057319f, 0.05336168f, -0.05207776f, 0.41219714f, 
    -0.00637243f, 0.04619391f, -0.12361155f, -0.02401736f, -0.19533737f, 0.08136170f, -0.04472402f, 0.10398907f, 
    -0.02711322f, -0.03016455f, -0.09032922f, -0.07481093f, -0.14407684f, -0.23627989f, -0.12482919f, -0.21365678f, 
    0.02621324f, -0.04847334f, 0.06805239f, 0.05439629f, 0.00580401f, -0.22633182f, -0.01707714f, 0.04193381f, 
    0.05576184f, 0.11882924f, 0.10591893f, 0.20813061f, -0.05972887f, 0.21755594f, -0.13251750f, -0.24396694f, 
    0.06370182f, -0.03419675f, -0.04969346f, 0.08191407f, 0.04323322f, 0.09047976f, -0.17153549f, -0.07753593f, 
    -0.04126482f, 0.13436142f, 0.08302891f, 0.07937066f, 0.03530453f, 0.00576439f, 0.06499328f, -0.01485351f, 
    -0.03342184f, -0.00564179f, -0.14630997f, -0.12866785f, -0.20441239f, 0.22212765f, 0.24176317f, 0.23616940f, 
    0.10788465f, -0.02417699f, 0.16981666f, -0.01515869f, -0.12704638f, 0.12010491f, 0.04935786f, -0.09213840f, 
    -0.04931765f, 0.07527754f, 0.06372802f, -0.13139954f, 0.05110272f, 0.17711540f, 0.04803510f, 0.08398595f, 
    -0.01377781f, 0.07146618f, 0.06769989f, -0.02697980f, -0.02900615f, 0.06146802f, 0.25271130f, -0.09289518f, 
    0.01474320f, -0.06393351f, 0.02837991f, -0.11546088f, 0.14165555f, 0.03370864f, 0.13234329f, 0.01274400f, 
    -0.03430206f, -0.08009928f, -0.39185429f, -0.45648533f, -0.00467826f, -0.10836254f, -0.15375982f, 0.00021269f, 
    0.02283882f, 0.19521160f, 0.10738309f, -0.03445828f, -0.38638243f, -0.31152910f, -0.52258289f, -0.19614731f, 
    0.09592772f, -0.11874896f, -0.30292541f, 0.20616578f, 0.02396938f, 0.02024491f, -0.14286110f, -0.09613936f, 
    -0.02353890f, -0.33764514f, -0.12660144f, 0.00406773f, -0.08673537f, -0.09304357f, -0.01607124f, 0.07408664f, 
    -0.01301695f, -0.11547591f, -0.03415489f, -0.06997178f, -0.20120843f, 0.08970851f, -0.04772339f, -0.03905245f, 
    0.29234624f, 0.33347130f, -0.05133162f, 0.19342774f, 0.00062940f, 0.06963681f, -0.01441452f, -0.03915802f, 
    0.10131536f, 0.12416457f, 0.02281781f, 0.35928354f, 0.12956150f, 0.02070428f, 0.03828611f, -0.04710523f, 
    0.14576596f, 0.04264338f, -0.01115326f, 0.20990179f, 0.30481794f, -0.22619487f, -0.20602362f, -0.31394455f, 
    -0.09010995f, 0.00349424f, -0.03346089f, -0.15164088f, 0.10837425f, -0.01490998f, 0.22694282f, 0.14773536f, 
    -0.08222999f, -0.09420586f, -0.02602231f, -0.44111565f, 0.20496608f, -0.02493568f, -0.12299668f, 0.09799892f, 
    0.08876088f, 0.00287343f, 0.05584224f, -0.00122458f, 0.07153486f, -0.00497805f, -0.01583575f, -0.15118280f, 
    0.00603065f, -0.20417270f, 0.00304162f, -0.00126954f, -0.08129479f, 0.10893688f, -0.07684417f, -0.08961042f, 
    -0.42684633f, 0.15228648f, -0.31146169f, -0.25628167f, 0.19785874f, -0.09242447f, 0.01681759f, 0.07213441f, 
    -0.03624728f, -0.03590305f, -0.01740378f, 0.08879863f, 0.30259201f, 0.15905654f, 0.05449393f, 0.19719779f, 
    -0.00282116f, 0.02741439f, 0.10758331f, -0.01581669f, 0.46076673f, 0.22108068f, 0.04058471f, 0.10728106f, 
    -0.03962800f, -0.02285700f, 0.04122545f, -0.09932691f, 0.05803779f, -0.02965943f, 0.08051082f, -0.05980673f, 
    -0.14927962f, -0.05754892f, -0.05291782f, 0.05326057f, 0.15681654f, 0.03032007f, 0.10621246f, -0.11819096f, 
    -0.04371797f, -0.21310435f, 0.15554124f, 0.09572043f, 0.03663701f, -0.02857456f, -0.15310539f, 0.06531193f, 
    -0.05964017f, -0.11143427f, 0.13799864f, 0.26084468f, -0.13715421f, -0.10183239f, 0.00229821f, -0.07249898f, 
    0.15257078f, 0.09694412f, 0.12845726f, 0.21509039f, -0.01835757f, -0.50965559f, 0.35149431f, -0.03302665f, 
    -0.22355908f, -0.01587187f, 0.09768373f, 0.01698985f, 0.03796965f, -0.10124476f, 0.01433953f, 0.04269096f, 
    0.16678809f, 0.00029784f, -0.14660165f, 0.15778351f, 0.10581854f, -0.01862434f, 0.07641209f, -0.01490512f, 
    -0.05287142f, -0.04057959f, 0.03032985f, 0.13031439f, 0.50191104f, 0.39716002f, 0.16088410f, -0.15314433f, 
    -0.10108024f, 0.11109211f, 0.10846447f, -0.08176070f, -0.02261553f, 0.19650169f, 0.00066837f, -0.03987859f, 
    -0.15330328f, -0.23957267f, 0.09281738f, 0.05850349f, 0.14316298f, -0.18700512f, 0.08083627f, -0.02259286f, 
    0.01490845f, -0.12037756f, 0.02326617f, -0.01958956f, 0.03559056f, 0.20870931f, -0.43258601f, 0.03871736f, 
    0.18778358f, -0.14099474f, -0.26475176f, -0.09470755f, 0.01867309f, -0.06797892f, 0.08286118f, 0.01217881f, 
    -0.18979952f, -0.22838129f, -0.18664360f, -0.18692480f, 0.13060586f, 0.09245919f, -0.06913037f, 0.05066036f, 
    0.18960021f, 0.00224956f, -0.11157200f, -0.07416567f, 0.28612095f, 0.32291523f, 0.21623962f, 0.24393812f, 
    -0.01094337f, 0.14456604f, 0.08673839f, -0.00191542f, 0.03974598f, 0.07971478f, 0.12910637f, 0.04675811f, 
    0.03225897f, 0.17612989f, -0.23914893f, 0.09278136f, -0.04296681f, -0.01040507f, -0.04610606f, -0.06956346f, 
    -0.11274598f, -0.12236556f, -0.03089526f, 0.23697957f, 0.25285974f, -0.25661626f, 0.02193463f, -0.03888100f, 
    0.11480066f, 0.04477407f, -0.08212265f, 0.01601260f, 0.01060586f, -0.20558167f, 0.03472426f, -0.24793459f, 
    0.31117606f, 0.10354868f, 0.33187386f, 0.21982877f, 0.01152598f, 0.00171904f, 0.04518508f, 0.17940921f, 
    0.00640010f, -0.15169354f, -0.05440982f, -0.01342264f, 0.14059219f, 0.00780473f, -0.19001646f, 0.07848433f, 
    0.16093910f, 0.13708492f, 0.04779759f, 0.15355740f, 0.01531659f, -0.04359959f, -0.03128503f, 0.06486416f, 
    0.14186230f, 0.05608124f, 0.13488516f, 0.05863828f, 0.00095105f, -0.06026139f, 0.08041088f, -0.00036787f, 
    0.08080924f, 0.05090165f, 0.12335204f, 0.07379066f, -0.23985504f, -0.05853515f, -0.09712090f, 0.06225374f, 
    0.06056308f, 0.08498699f, -0.00192186f, -0.03245961f, 0.03353482f, 0.05022286f, -0.15541439f, -0.19035786f, 
    0.11826971f, 0.18004407f, -0.02073447f, 0.11380520f, -0.05890837f, 0.09268047f, -0.04870948f, -0.13073452f, 
    0.08614168f, -0.04860260f, -0.02056744f, 0.18118790f, 0.12580821f, -0.40175769f, 0.09898011f, -0.44623128f, 
    0.03527398f, -0.20994712f, -0.03543071f, -0.23453102f, -0.09507822f, 0.01598636f, -0.01253471f, 0.06268278f, 
    -0.13842709f, 0.18839245f, -0.13815261f, 0.06896190f, 0.18397570f, 0.07772391f, 0.20629205f, 0.02570313f, 
    -0.14678869f, 0.08461751f, -0.03875562f, 0.02619366f, 0.09536532f, -0.04784639f, -0.16962610f, -0.21013510f, 
    0.07863285f, -0.23426124f, 0.06204436f, -0.02564004f, 0.07784171f, -0.03082042f, 0.13665010f, -0.11516484f, 
    0.25898817f, 0.01950753f, -0.14573580f, -0.11560832f, 0.10345510f, -0.12384399f, 0.10983947f, -0.03699841f, 
    0.09333362f, 0.02263127f, -0.07642136f, -0.03124164f, 0.03199700f, 0.05413895f, 0.01307790f, -0.04192968f, 
    -0.05418916f, -0.03446241f, -0.00538025f, 0.29109606f, 0.07656008f, 0.01119198f, -0.09470576f, 0.02945948f, 
    -0.00630519f, -0.06041676f, -0.00696824f, -0.30565518f, -0.01514180f, 0.02273913f, 0.03592382f, 0.08062829f, 
    -0.02098026f, 0.02717196f, 0.11144165f, 0.00540301f, 0.40023711f, -0.08881330f, -0.02842172f, -0.14217810f, 
    0.02539902f, 0.04467899f, 0.17430975f, 0.00192403f, -0.01359950f, -0.07609888f, -0.07988715f, 0.09124042f, 
    0.78730744f, -0.00464886f, -0.14423069f, 0.05765743f, 0.10151076f, 0.06305534f, -0.05664736f, -0.11762804f, 
    0.00692672f, -0.02333673f, 0.05044682f, 0.04323260f, 0.03819240f, 0.15569177f, -0.02138725f, 0.00551853f, 
    -0.02039528f, -0.09583452f, 0.03419290f, 0.00849690f, -0.06467623f, -0.10847511f, -0.04814897f, 0.07633234f, 
    -0.13077050f, -0.17492674f, -0.07532672f, -0.00120578f, -0.18065099f, 0.00153243f, 0.14625685f, -0.22174565f, 
    -0.11041693f, -0.07968761f, -0.12743697f, -0.12530999f, 0.18774909f, -0.06684069f, 0.12209082f, -0.10553324f, 
    -0.03056321f, 0.04871442f, -0.19530840f, 0.00559366f, 0.01282622f, 0.03758249f, -0.03515127f, 0.29122928f, 
    0.23187105f, 0.12111772f, 0.00681837f, -0.14090581f, 0.14210962f, 0.14370525f, 0.03661274f, 0.11362460f, 
    -0.00928384f, 0.03826256f, 0.04041468f, -0.01225741f, 0.25916070f, -0.04190560f, 0.06468462f, -0.14197968f, 
    -0.06414149f, 0.02493888f, 0.03126368f, -0.00843079f, -0.10387944f, 0.00628059f, 0.01023443f, 0.08901162f, 
    0.29843521f, 0.37931091f, -0.20325230f, -0.02979016f, 0.04255710f, 0.18784571f, -0.11531118f, 0.26926112f, 
    0.00924114f, -0.08328675f, -0.02974028f, -0.09158587f, -0.04325094f, -0.03009366f, -0.01248162f, 0.14201310f, 
    0.06274536f, 0.00165008f, 0.03287853f, 0.10914562f, 0.07826775f, 0.05206386f, 0.29402655f, 0.27530581f, 
    0.09045363f, 0.27670813f, -0.16286817f, 0.13018587f, -0.05252038f, -0.13943192f, 0.02263703f, -0.06660027f, 
    -0.02003247f, 0.19946824f, 0.12955333f, 0.12580319f, -0.05189802f, 0.37497103f, -0.02450478f, 0.14899735f, 
    0.11503352f, -0.08303811f, 0.03754018f, -0.20018260f, -0.19342484f, -0.16338043f, -0.32647142f, 0.10533529f, 
    0.14564194f, 0.00498854f, -0.00529740f, 0.07976806f, -0.12693378f, -0.15321863f, -0.08461231f, -0.18379179f, 
    -0.00723404f, -0.27171355f, -0.17492868f, -0.07595477f, -0.15439719f, 0.17052910f, 0.36066279f, 0.00132262f, 
    -0.07418557f, 0.32670328f, -0.10860591f, -0.07806627f, -0.29127070f, -0.07856052f, -0.06012979f, -0.07487813f, 
    -0.11067588f, 0.13923977f, 0.06136985f, 0.05702014f, 0.20303878f, -0.06881095f, -0.11571731f, 0.23062071f, 
    -0.04484300f, 0.02663105f, -0.08177020f, -0.19052982f, 0.25515810f, 0.31109807f, 0.15805209f, 0.01272989f, 
    0.11065049f, 0.06900360f, -0.16530047f, 0.18149716f, 0.01300881f, 0.28606862f, -0.00532670f, 0.02711732f, 
    0.09514027f, -0.14853156f, 0.25892967f, 0.36626911f, 0.00804373f, -0.01524914f, -0.04979906f, 0.02725095f, 
    0.14151919f, 0.03961334f, 0.05107677f, 0.14097226f, 0.08173047f, -0.05085489f, -0.41800189f, 0.28460726f, 
    0.17401621f, -0.05660880f, -0.07343496f, 0.09957756f, -0.06095775f, 0.15694061f, 0.06551252f, 0.04708773f, 
    0.42079422f, 0.36924857f, 0.13181622f, 0.10241693f, 0.17436355f, -0.04536270f, -0.04143112f, -0.16460286f, 
    -0.07418438f, 0.13718808f, -0.06505712f, -0.01109643f, 0.00861225f, 0.11895785f, -0.14991240f, 0.08670063f, 
    0.11451036f, -0.00222024f, 0.02714334f, -0.06423181f, -0.01477823f, 0.09794416f, -0.01521995f, -0.34099758f, 
    0.11032571f, 0.36959207f, -0.30945882f, -0.60163879f, -0.04173779f, -0.26140448f, -0.17044537f, -0.05975909f, 
    -0.30349788f, -0.09709348f, -0.20306203f, 0.01898542f, -0.07791640f, 0.00157902f, -0.05569433f, 0.38003430f, 
    -0.10048040f, -0.09335152f, -0.04865731f, -0.20091754f, 0.08424386f, 0.17541194f, -0.09109056f, 0.23162925f, 
    0.14132670f, 0.21086140f, 0.12545729f, 0.17934358f, 0.05118679f, 0.26335213f, 0.18389930f, 0.31742811f, 
    0.13720502f, 0.02710763f, -0.10212981f, 0.00306722f, -0.18053970f, -0.31441659f, -0.48347250f, 0.46943957f, 
    0.01493233f, -0.03161916f, -0.00135890f, -0.11081661f, 0.05134853f, -0.01108088f, -0.22022969f, -0.01225499f, 
    0.37797701f, -0.18523046f, -0.00515222f, 0.15652606f, 0.22932526f, 0.12587112f, -0.04418924f, 0.04976650f, 
    -0.00619285f, -0.02232704f, 0.07259254f, -0.07262729f, -0.12164900f, 0.05252388f, -0.07672910f, 0.16114089f, 
    -0.20194435f, -0.03740992f, -0.25697103f, -0.05801876f, 0.07511464f, -0.16658473f, 0.24713553f, 0.05180385f, 
    -0.02258175f, -0.05497948f, -0.10243960f, 0.19347161f, -0.09095729f, -0.07705954f, -0.06926391f, -0.07315159f, 
    -0.14022937f, -0.11082121f, -0.01474961f, 0.16675483f, -0.34339330f, 0.02471097f, 0.00337577f, 0.23593110f, 
    0.01201794f, 0.00395092f, -0.11562152f, -0.04183333f, -0.09393992f, -0.13619331f, -0.06706928f, -0.12215342f, 
    0.09436069f, 0.28409022f, 0.13183349f, -0.14253885f, 0.05529296f, 0.11023098f, 0.10728862f, 0.08968785f, 
    0.04191533f, 0.01451875f, 0.03502676f, 0.03771099f, -0.41368601f, 0.31602177f, -0.28071991f, 0.06923535f, 
    -0.03913751f, -0.11111474f, 0.09954045f, -0.04860503f, -0.15781476f, 0.12220133f, -0.06530955f, -0.13486502f, 
    0.01741170f, 0.01387642f, 0.27181923f, 0.09701957f, -0.15961900f, 0.09034911f, 0.04239197f, 0.05750643f, 
    0.01318320f, -0.09943534f, -0.01481604f, -0.16394989f, -0.28184068f, 0.15659401f, 0.05412890f, 0.27451956f, 
    -0.03581172f, -0.13016611f, 0.06538014f, 0.24571382f, -0.12629700f, 0.01548129f, 0.09620456f, 0.14488108f, 
    0.32856169f, -0.12677164f, -0.01766527f, 0.09031955f, 0.03278181f, 0.16315585f, 0.03471288f, -0.10258397f, 
    0.02376496f, 0.00036199f, -0.11442132f, -0.14041321f, 0.20949475f, -0.00676020f, 0.35091984f, 0.29601705f, 
    0.05114531f, 0.05015168f, 0.02024539f, 0.06271285f, -0.01861012f, 0.09367719f, -0.07608732f, -0.18464781f, 
    0.42024902f, 0.12107778f, -0.15094253f, 0.00156278f, -0.08671693f, -0.09058235f, 0.04922791f, 0.05437944f, 
    -0.10540652f, 0.04562669f, -0.02755608f, -0.05512188f, 0.05631529f, 0.07970592f, 0.19115460f, 0.33151159f, 
    0.11345417f, 0.01758601f, -0.05577544f, 0.10515759f, -0.10139322f, -0.00383871f, -0.08171995f, 0.01311295f, 
    0.08276933f, -0.17020252f, 0.31695896f, 0.01363049f, -0.03263612f, 0.11534179f, 0.14959463f, -0.18475334f, 
    0.16678283f, 0.12045276f, 0.12653434f, -0.04323018f, -0.00517356f, 0.06163455f, 0.05348407f, 0.19154850f, 
    -0.04491036f, -0.03795160f, -0.12597120f, 0.02922967f, -0.17661941f, -0.28690302f, -0.24937539f, 0.04487889f, 
    -0.13843937f, 0.24943557f, -0.06369601f, 0.04713549f, -0.04068249f, 0.12178097f, 0.00048553f, -0.15800667f, 
    0.09433626f, 0.09810927f, -0.08819031f, -0.00267489f, -0.10126496f, -0.05346010f, 0.09607577f, 0.17734872f, 
    -0.02444697f, -0.09332691f, -0.04097637f, -0.17958514f, -0.04626986f, -0.04893169f, -0.03385010f, 0.00513080f, 
    0.20074414f, 0.04566200f, 0.01387795f, 0.23322763f, 0.10569217f, -0.05194921f, -0.01778216f, 0.06309631f, 
    0.00809776f, -0.06182985f, -0.03613073f, 0.01291076f, 0.27211189f, 0.07343124f, 0.05984088f, 0.03550381f, 
    -0.08402600f, -0.05603963f, -0.06429425f, -0.04772780f, 0.16438402f, 0.10347124f, 0.14194146f, 0.12883401f, 
    -0.14656641f, 0.02450338f, -0.08216245f, 0.18636979f, 0.09188809f, -0.06963462f, 0.00087626f, 0.13757831f, 
    0.07613381f, 0.21928801f, 0.01799766f, 0.08696090f, 0.00625818f, 0.57162374f, -0.41596526f, -0.10388637f, 
    -0.05886538f, -0.08767048f, 0.25222850f, 0.17468520f, -0.06770194f, -0.00745959f, 0.16802281f, 0.03543778f, 
    -0.00752963f, 0.01390281f, -0.13650437f, 0.18310581f, 0.03111312f, -0.05714776f, -0.00736594f, -0.00210726f, 
    -0.16705380f, 0.02227559f, -0.04485032f, -0.05040150f, -0.46330935f, 0.43964684f, -0.16241732f, 0.04296042f, 
    0.07259770f, -0.13394617f, -0.19415198f, 0.11766020f, -0.17550050f, 0.14363687f, 0.12349955f, -0.14370522f, 
    0.04457956f, 0.19856852f, -0.43722564f, 0.32807496f, 0.00295939f, -0.05902167f, 0.15659757f, -0.06173407f, 
    0.02549339f, 0.02757177f, 0.09467595f, -0.00938474f, 0.01449726f, -0.07159656f, -0.31828028f, -0.08247189f, 
    0.16265447f, -0.04511188f, 0.05940444f, 0.16133918f, -0.03568943f, -0.11045622f, 0.01291771f, 0.02521717f, 
    0.30569315f, 0.16354275f, -0.20012245f, 0.20668401f, 0.14666870f, -0.05839210f, -0.09784484f, 0.03156573f, 
    0.06780460f, 0.03298752f, -0.09582755f, 0.24736935f, 0.04500869f, 0.14981686f, 0.29486430f, 0.08647358f, 
    0.14463638f, -0.03748399f, -0.16905972f, -0.20383790f, 0.09026204f, -0.02458786f, 0.05490397f, -0.05523708f, 
    -0.16249955f, -0.00824425f, 0.07645955f, 0.06717194f, -0.13696149f, -0.10850409f, -0.08459224f, 0.02790472f, 
    0.00650338f, 0.05600367f, -0.04633748f, 0.08042690f, 0.02663062f, 0.08860530f, -0.19545287f, -0.00841884f, 
    0.20511270f, 0.10296270f, 0.00834048f, -0.03356746f, 0.02358984f, -0.17004356f, -0.05604154f, 0.08040527f, 
    0.07638838f, -0.08331250f, -0.17626956f, -0.15374558f, 0.19877057f, -0.17801780f, 0.08650213f, -0.03226582f, 
    -0.14007905f, -0.03116038f, -0.08226564f, 0.05390009f, 0.18838656f, 0.10935500f, -0.00911417f, 0.20279647f, 
    -0.15891023f, 0.14729218f, 0.00732590f, 0.02337448f, 0.01244647f, 0.00425034f, -0.00726921f, 0.18195565f, 
    -0.29200959f, -0.09353357f, -0.02054800f, 0.07484320f, -0.02940733f, 0.05989191f, -0.05383178f, -0.12347614f, 
    -0.01177772f, 0.02005451f, 0.06930370f, -0.01615331f, -0.32558849f, 0.12007733f, -0.47937417f, -0.53475422f, 
    0.04681094f, 0.13676102f, 0.06880763f, -0.00780657f, 0.13217859f, 0.15002105f, 0.27900437f, 0.06313889f, 
    0.33707067f, 0.18784450f, 0.28510681f, 0.21309209f, 0.03075739f, 0.08891743f, 0.03788772f, 0.10491721f, 
    0.09531657f, -0.07646435f, -0.16355184f, -0.07730324f, 0.00489549f, 0.02590549f, 0.15468676f, -0.11203965f, 
    -0.10315733f, -0.08262721f, -0.01790966f, -0.04280685f, 0.03502410f, 0.03329565f, 0.08132712f, -0.21518098f, 
    -0.02587096f, 0.03968938f, 0.05348669f, -0.07423793f, -0.07358871f, -0.06408639f, -0.00478009f, 0.00963100f, 
    0.00986276f, 0.03703780f, -0.00193214f, 0.01843106f, -0.01846655f, -0.05928794f, -0.00103498f, -0.03115974f, 
    -0.02022930f, -0.02014446f, -0.03291677f, -0.04100844f, -0.03841763f, -0.03273202f, 0.02011844f, 0.02278206f, 
    -0.04092893f, -0.06732357f, 0.03458754f, -0.02507355f, 0.01175673f, 0.01726823f, -0.01567199f, 0.01488184f, 
    0.01964397f, -0.03152889f, -0.00290020f, -0.06885413f, -0.03146227f, 0.01897886f, -0.06417762f, 0.02447490f, 
    -0.06557964f, 0.03948027f, 0.02287399f, -0.07305323f, -0.00312658f, 0.04206120f, -0.07776763f, 0.02557788f, 
    -0.00690063f, -0.05632242f, 0.03551126f, -0.02446022f, -0.00370970f, -0.07799967f, 0.01179184f, 0.04168878f, 
    -0.03582181f, 0.03560670f, 0.05793612f, 0.00269088f, -0.05025466f, -0.00177480f, -0.01689884f, 0.00134899f, 
    0.06026749f, 0.01181346f, -0.06140040f, -0.01118450f, -0.02461638f, -0.02919869f, -0.03533012f, 0.04083647f, 
    -0.04180807f, -0.03414592f, -0.00292784f, 0.05310296f, -0.01782068f, 0.02683513f, -0.00970424f, 0.03289687f, 
    0.03517780f, -0.02571713f, -0.06502857f, -0.06813627f, 0.00874297f, -0.04303908f, 0.03336680f, -0.01066762f, 
    -0.03121268f, 0.03295090f, -0.01084623f, 0.04515044f, 0.00363620f, -0.02205681f, 0.05122467f, 0.03224864f, 
    0.01672066f, 0.04022204f, -0.07024175f, 0.01784292f, -0.00826348f, -0.08296247f, -0.06327911f, -0.04675795f, 
    0.03509782f, -0.03035581f, -0.00728038f, -0.07922871f, -0.05263200f, -0.07121529f, 0.06417046f, -0.05742636f, 
    -0.05893454f, -0.02971702f, -0.01602910f, -0.04024036f, 0.00593255f, 0.04318830f, -0.04181184f, 0.04443989f, 
    0.04410165f, -0.04254232f, -0.00071053f, -0.04822476f, -0.04710782f, -0.04067611f, 0.03892894f, -0.05382363f, 
    0.00797202f, -0.01457232f, -0.03484081f, -0.07835594f, 0.01232107f, -0.04579677f, 0.01037538f, 0.05014681f, 
    -0.05836150f, 0.03713580f, 0.04617340f, -0.07631334f, -0.01503624f, -0.07271666f, -0.06442509f, 0.02370663f, 
    -0.07058854f, 0.04971395f, 0.01085462f, 0.01175004f, 0.03991802f, 0.00805605f, -0.04620252f, 0.06744985f, 
    -0.03702988f, -0.04862406f, 0.01461753f, 0.05837355f, 0.00386111f, -0.03000368f, 0.02105256f, -0.03844726f, 
    -0.04501328f, 0.03315122f, -0.02606547f, 0.04497889f, 0.00280513f, 0.00240900f, -0.00121316f, -0.02026048f, 
    0.03520150f, -0.01422633f, -0.05181932f, 0.01522143f, 0.03180688f, -0.00307382f, -0.03878388f, -0.02604062f, 
    -0.04263172f, 0.02411226f, -0.05655847f, -0.06390296f, 0.02124429f, 0.02197212f, 0.04973372f, -0.04850049f, 
    -0.03580994f, -0.00118026f, 0.00386865f, 0.01513661f, 0.00788390f, -0.00922412f, 0.01363943f, 0.06003289f, 
    0.09950585f, 0.04465547f, 0.12782422f, -0.06095352f, 0.07097787f, -0.16410677f, 0.07100262f, 0.12201916f, 
    -0.04367579f, 0.03847753f, 0.11722214f, 0.07704725f, 0.08932133f, -0.04941699f, 0.41313171f, -0.52973330f, 
    -0.08154970f, 0.00789695f, -0.04931780f, 0.13929293f, -0.05748356f, -0.01838538f, -0.13000615f, -0.02986201f, 
    0.08291626f, 0.07231009f, -0.17457363f, 0.07720853f, -0.02528560f, 0.16281307f, 0.07673804f, 0.03534368f, 
    -0.02397451f, -0.06287643f, -0.07595260f, -0.00057832f, -0.29119983f, -0.42886645f, 0.20646490f, 0.19196877f, 
    -0.01624857f, -0.22265300f, -0.00106749f, -0.08305109f, -0.09893717f, 0.10480780f, -0.02299477f, -0.03984920f, 
    0.24287352f, -0.01684248f, 0.13105440f, -0.34244841f, -0.08937155f, 0.03385269f, 0.17764875f, 0.16795187f, 
    0.01711753f, -0.07745300f, -0.02315252f, -0.00517964f, 0.05841404f, 0.17277960f, 0.40312797f, 0.16921058f, 
    -0.00722807f, -0.00488821f, 0.09333196f, -0.12777844f, -0.00839279f, -0.09895518f, 0.08390345f, -0.18953344f, 
    0.06329919f, -0.02877326f, -0.19666223f, -0.11553778f, 0.07730505f, 0.08256732f, -0.02860985f, -0.11444701f, 
    -0.09767246f, -0.11782449f, -0.19574849f, 0.00179852f, -0.10228103f, 0.21555550f, 0.13367379f, -0.05540286f, 
    0.05122803f, -0.00520931f, 0.05189143f, 0.18653883f, 0.02159500f, -0.05716652f, -0.04269848f, -0.08170009f, 
    0.59027082f, -0.36356291f, -0.07601508f, -0.01611994f, -0.04767652f, 0.00988534f, 0.02185572f, -0.02030599f, 
    0.19118521f, -0.22496253f, 0.10218325f, 0.00276255f, 0.12793353f, 0.26846567f, 0.31263658f, 0.12233333f, 
    0.08099573f, 0.25795919f, 0.05963494f, 0.24860305f, 0.11159734f, 0.06193386f, 0.06125568f, 0.00992667f, 
    0.17868845f, 0.07849301f, -0.02929172f, 0.29558519f, -0.12976858f, 0.02035683f, -0.06602312f, -0.00610177f, 
    0.20013613f, -0.01550799f, -0.02814571f, 0.09007575f, 0.29934743f, -0.23600571f, 0.10357595f, -0.13000353f, 
    -0.05771726f, -0.08912665f, -0.05988020f, -0.13056678f, 0.19989175f, -0.15895024f, -0.02299793f, -0.19048710f, 
    0.05111923f, 0.19891980f, 0.20863108f, 0.19234446f, 0.12858672f, -0.00194240f, -0.15057346f, 0.11063654f, 
    0.04256561f, -0.03540224f, -0.12393851f, -0.04803248f, 0.09909902f, 0.08560275f, 0.12452650f, -0.23880085f, 
    0.13140705f, -0.13853739f, -0.06887704f, -0.01100284f, -0.02373682f, 0.02192639f, 0.02582325f, 0.03634139f, 
    -0.35385868f, 0.18576747f, 0.26216105f, 0.13349555f, 0.18245316f, -0.07542236f, 0.03749347f, 0.25620112f, 
    0.00164605f, -0.02934218f, -0.01047499f, 0.10273127f, 0.09306669f, 0.02806939f, -0.13571307f, 0.20693277f, 
    0.05623135f, 0.01066539f, -0.03461822f, -0.09922674f, 0.14918144f, 0.08815800f, -0.00342004f, -0.10106828f, 
    0.03054901f, -0.07539976f, 0.01346750f, -0.04690522f, -0.03890081f, -0.04277502f, -0.05502439f, 0.01057267f, 
    -0.05513025f, 0.00457698f, -0.03961851f, -0.04006556f, -0.04514573f, 0.03700454f, 0.04015331f, -0.06351411f, 
    0.01202348f, -0.07101811f, -0.04520473f, -0.03941019f, -0.04862585f, -0.08566889f, -0.07718159f, -0.02639366f, 
    -0.00702016f, -0.05877895f, 0.05894845f, 0.00802547f, -0.06397881f, 0.06463122f, -0.05671339f, 0.01155016f, 
    -0.04953018f, 0.00394743f, -0.07483979f, 0.04954660f, -0.04517301f, 0.05258128f, -0.04932953f, 0.04584081f, 
    -0.00893557f, -0.04115485f, 0.04992881f, 0.05619424f, 0.00694690f, -0.05574354f, -0.02671529f, -0.04037787f, 
    -0.03636911f, 0.04031922f, -0.02682608f, 0.05593193f, -0.07115535f, -0.07150076f, -0.01315423f, -0.06908543f, 
    -0.08544144f, -0.01373047f, -0.08361289f, -0.05530354f, -0.03667929f, -0.03775818f, -0.00642618f, 0.01191194f, 
    0.04938474f, -0.06679995f, -0.00535018f, 0.05440326f, 0.03123217f, 0.04838870f, 0.00349160f, 0.04789589f, 
    0.03778788f, -0.05863838f, -0.04255269f, 0.03561253f, 0.00342425f, 0.04097151f, 0.04586806f, 0.00624001f, 
    -0.05230558f, -0.01381100f, -0.07188127f, 0.03287534f, -0.01501779f, 0.01932058f, -0.02572899f, -0.05338183f, 
    0.02451509f, -0.01267846f, -0.06711750f, -0.06436661f, -0.06586965f, -0.06490720f, -0.03422012f, -0.03861606f, 
    0.02372948f, -0.02382871f, -0.04601274f, 0.04445477f, -0.04456384f, -0.02071426f, 0.05088323f, -0.05249559f, 
    0.06141904f, 0.05992571f, -0.00243507f, 0.01212331f, -0.06001907f, 0.06057993f, -0.02335715f, -0.01867774f, 
    0.01087485f, -0.06916826f, 0.02702803f, 0.00388242f, 0.05174656f, 0.03117675f, -0.03283238f, 0.03042054f, 
    -0.04207262f, 0.05500938f, 0.00602985f, -0.02953350f, -0.05774122f, 0.04305857f, -0.05482770f, 0.04687557f, 
    0.03327842f, -0.05777483f, -0.01915313f, 0.04043751f, 0.04991855f, 0.00409199f, 0.00562163f, 0.01045138f, 
    -0.03602717f, -0.05251653f, -0.06804214f, -0.01950986f, -0.02313992f, 0.02890956f, -0.05838108f, 0.05648446f, 
    -0.05298150f, 0.03359092f, -0.05273494f, 0.02223226f, -0.07553794f, -0.09330442f, 0.02728222f, -0.06987015f, 
    -0.06350557f, -0.07375672f, 0.00811447f, 0.05671388f, -0.06676247f, -0.07973576f, -0.01555437f, -0.07472298f, 
    0.06870052f, -0.01341239f, -0.05952149f, 0.03634556f, 0.06604921f, -0.02252716f, -0.06891135f, -0.01241320f, 
    -0.04741034f, 0.00994981f, -0.01100112f, -0.04813388f, -0.01950302f, 0.03354336f, -0.06433911f, -0.01740512f, 
    0.04546036f, -0.00945906f, 0.00542559f, -0.00119742f, -0.00811304f, 0.00225011f, -0.08295537f, -0.05857709f, 
    -0.07282235f, -0.00179902f, 0.04576473f, 0.04389280f, -0.01300213f, 0.00876178f, 0.01032625f, -0.01304966f, 
    0.12691186f, -0.17534558f, 0.16510525f, 0.05515508f, -0.02966108f, 0.07343869f, 0.10819384f, -0.08586928f, 
    0.39550081f, 0.33674875f, 0.12953638f, 0.05240762f, 0.06609312f, -0.33947089f, 0.21320367f, 0.04537564f, 
    0.26997954f, 0.09778625f, -0.11523745f, -0.21691999f, -0.09419572f, 0.00065914f, -0.28637311f, 0.13536409f, 
    -0.06931191f, 0.12944266f, 0.03577938f, 0.06550512f, 0.13356060f, -0.25616270f, -0.06777352f, -0.09802039f, 
    0.13772596f, -0.26037300f, -0.31406650f, -0.13160494f, 0.19522846f, -0.41081515f, 0.29951102f, 0.33403358f, 
    0.04855993f, 0.38840705f, -0.04998542f, -0.06955656f, -0.11247603f, -0.35135320f, 0.04785372f, -0.00299286f, 
    -0.05998069f, -0.18782802f, 0.02693817f, -0.06480082f, 0.23007302f, -0.07000434f, 0.03680279f, 0.15565650f, 
    -0.01834822f, 0.08690631f, -0.09858588f, -0.01956234f, 0.28220817f, 0.16583441f, 0.10851905f, -0.18227246f, 
    -0.04903803f, 0.05382438f, -0.07435589f, -0.02548947f, 0.20979175f, 0.30003744f, -0.03655687f, 0.21794271f, 
    -0.22014311f, 0.10794209f, 0.28722712f, 0.15583546f, -0.07608049f, -0.12798689f, 0.13549325f, 0.09912981f, 
    -0.13640198f, 0.14350516f, 0.23359568f, 0.00668910f, 0.00131811f, -0.03755005f, -0.30111074f, -0.06374650f, 
    0.01644816f, 0.09372928f, -0.06306161f, -0.00832012f, -0.12361864f, -0.17641929f, 0.01369068f, 0.03602949f, 
    0.08649758f, 0.39196810f, 0.45258707f, 0.25510111f, -0.02371845f, -0.14736083f, -0.24278499f, -0.12266243f, 
    -0.01732053f, 0.01573749f, -0.07245054f, -0.05749149f, 0.17796235f, 0.25454614f, -0.08369673f, -0.03665335f, 
    -0.01553927f, -0.10431809f, 0.13638359f, 0.02547697f, -0.02920816f, 0.07862989f, 0.02458176f, -0.21112625f, 
    -0.08421425f, -0.15186875f, 0.10626253f, 0.06903685f, 0.01166890f, 0.04669117f, -0.37008715f, -0.14512734f, 
    -0.05227368f, -0.15133996f, 0.01131171f, -0.00670839f, -0.01922440f, 0.16629191f, 0.14936540f, -0.05996132f, 
    -0.04976797f, -0.22170982f, -0.08887933f, -0.12313989f, 0.13627385f, 0.24738711f, 0.20431592f, 0.20552033f, 
    0.30209401f, 0.12189158f, 0.14519358f, 0.14216664f, 0.02289955f, 0.14136958f, 0.24254288f, 0.20428941f, 
    0.04180804f, -0.01547191f, -0.01504736f, 0.22229420f, 0.40131280f, -0.09773627f, 0.34748527f, 0.14165203f, 
    0.03440504f, 0.04911627f, -0.30653563f, -0.02223210f, 0.13273078f, -0.07826453f, -0.34243587f, -0.19438288f, 
    -0.08731143f, -0.04686503f, -0.20321749f, -0.11711625f, 0.06920779f, 0.01465058f, 0.05512305f, -0.11813001f, 
    -0.12388316f, -0.07029183f, 0.03757485f, 0.08156653f, -0.23254438f, 0.05325158f, -0.33857694f, 0.02595511f, 
    0.11868928f, 0.05247334f, -0.09242223f, -0.24938387f, 0.01614624f, -0.03849319f, 0.15884867f, 0.37832293f, 
    -0.14148074f, 0.09878080f, 0.03005221f, -0.05497704f, 0.02876843f, -0.18671012f, -0.06162997f, 0.12034585f, 
    -0.05971579f, -0.10499712f, 0.01819484f, 0.26244062f, -0.26843780f, 0.40876347f, -0.29683369f, 0.12804708f, 
    -0.01798271f, -0.05228589f, 0.05038629f, 0.15682676f, -0.04402618f, -0.01281310f, -0.01647050f, -0.16037741f, 
    0.22567657f, 0.20030914f, -0.13916929f, 0.10648528f, 0.08184181f, 0.16745432f, -0.05614933f, 0.04142787f, 
    -0.12889470f, 0.17566544f, 0.04647121f, 0.09639729f, 0.01852876f, 0.31429231f, -0.06448879f, -0.13014314f, 
    0.06575795f, -0.06125887f, -0.00104286f, -0.05319001f, -0.12977828f, 0.10996038f, 0.10842527f, -0.05538732f, 
    -0.15647422f, 0.29620376f, 0.07030974f, 0.21422365f, -0.01239062f, 0.15861100f, 0.04721423f, -0.08665743f, 
    0.04533187f, 0.01581273f, -0.02055890f, -0.08820471f, -0.24527280f, -0.09072014f, -0.12732138f, 0.21796492f, 
    0.02872024f, -0.09255816f, 0.07532232f, 0.30059439f, -0.08406112f, 0.05930799f, 0.02327793f, 0.08580194f, 
    0.13061802f, -0.08250509f, -0.14894091f, 0.18224587f, 0.08251710f, -0.00494489f, -0.07218713f, -0.10552574f, 
    0.05620196f, -0.03373737f, -0.14455330f, 0.15400907f, -0.05483914f, 0.14715232f, 0.21958636f, 0.13587652f, 
    0.16042426f, -0.02162207f, 0.08085129f, 0.07033899f, -0.00459428f, 0.01125144f, -0.08097997f, 0.00081655f, 
    0.27703121f, -0.25539449f, -0.22656921f, -0.13659573f, 0.04964794f, -0.03745575f, 0.04694757f, -0.05200266f, 
    -0.20726912f, 0.01623523f, 0.02622129f, -0.07759970f, -0.18354927f, -0.06317986f, 0.00298964f, 0.16631246f, 
    0.13914807f, 0.14334574f, 0.00814485f, 0.06730236f, -0.03824539f, 0.02101112f, -0.03502805f, 0.05356999f, 
    -0.04084600f, 0.45586342f, -0.00404363f, -0.10178751f, 0.18932466f, 0.00023214f, 0.20613141f, -0.12460722f, 
    0.02391833f, 0.05085137f, 0.09077920f, 0.09278737f, -0.02353765f, -0.10018947f, -0.09858291f, 0.09147771f, 
    -0.06757229f, 0.09051548f, -0.05212669f, 0.04299952f, -0.01867291f, -0.06161478f, -0.15480581f, -0.10164792f, 
    -0.28822181f, -0.24266729f, -0.11816269f, 0.14997536f, -0.06465833f, -0.09421232f, -0.04023762f, -0.00922198f, 
    -0.00547350f, 0.04561435f, -0.00921149f, -0.11530897f, -0.19916059f, 0.02654869f, -0.12199586f, -0.01923271f, 
    -0.06352454f, 0.06240171f, 0.10445657f, -0.05228564f, -0.16809507f, -0.07462426f, 0.03695225f, 0.00173747f, 
    0.29055306f, -0.16864029f, 0.23616894f, 0.20967935f, 0.10048170f, -0.05011924f, 0.04749165f, 0.13776810f, 
    0.02967478f, 0.00982647f, -0.15292889f, 0.02496489f, 0.11865752f, 0.04133532f, 0.07179728f, -0.01468727f, 
    -0.01875998f, -0.10242765f, 0.00722605f, 0.03958647f, 0.20083573f, 0.05340198f, 0.22957593f, -0.12380335f, 
    -0.01185920f, 0.05905368f, -0.17005871f, -0.10243420f, 0.13163115f, 0.17284372f, 0.12962036f, 0.12063706f, 
    -0.16083393f, 0.15185854f, -0.10151432f, -0.10133965f, 0.60117698f, 0.11489499f, 0.14552756f, -0.17087471f, 
    -0.04431293f, 0.04998150f, 0.13298321f, 0.03525002f, -0.06390805f, 0.03950826f, 0.08385358f, 0.04288416f, 
    -0.11690091f, -0.06996527f, 0.21419792f, -0.08984921f, 0.07246063f, 0.05260969f, 0.01906724f, 0.00119762f, 
    -0.08892756f, -0.00719089f, 0.19127107f, -0.10712480f, 0.51438171f, 0.60253191f, 0.16528283f, -0.44790250f, 
    0.29478705f, -0.26281023f, 0.02835551f, -0.08261734f, -0.15203738f, -0.00248201f, -0.08023510f, 0.07023315f, 
    0.25465110f, 0.26480809f, -0.10925699f, 0.03577742f, -0.01489952f, 0.04084053f, 0.30294785f, 0.10749356f, 
    0.06900515f, 0.00680086f, 0.02105952f, -0.18791877f, 0.13642600f, 0.33190385f, -0.20517986f, -0.06004825f, 
    0.01916891f, -0.06598768f, 0.11144195f, 0.27190033f, -0.04955438f, -0.07852762f, 0.04603389f, -0.00479327f, 
    0.07963396f, -0.09823519f, -0.06705516f, -0.26422894f, 0.08611853f, 0.13284777f, -0.03395891f, -0.09788897f, 
    0.05426614f, -0.11338311f, 0.08144628f, -0.02415129f, 0.47944605f, -0.04682604f, 0.00464832f, 0.08841872f, 
    -0.01242961f, 0.22804941f, 0.05632959f, 0.03167392f, -0.03669687f, -0.05611994f, 0.08224485f, -0.03769655f, 
    0.12119957f, -0.25370723f, -0.41457930f, 0.04917101f, -0.01898429f, -0.09671352f, -0.03772309f, -0.17980099f, 
    0.04870554f, 0.07180652f, -0.02838023f, 0.02151169f, 0.22453801f, -0.04546826f, -0.19543661f, 0.12097289f, 
    0.03821203f, 0.15570974f, 0.21499640f, 0.41699421f, 0.11937343f, 0.08318198f, 0.12629013f, 0.04444979f, 
    0.09541813f, -0.18175010f, -0.08186515f, -0.03201332f, -0.15707502f, 0.02848191f, 0.22268571f, 0.03970072f, 
    0.12432494f, 0.00416980f, 0.04616838f, 0.06613426f, -0.00014182f, -0.27274513f, 0.08046547f, 0.09962854f, 
    0.01920280f, 0.02278749f, -0.08772592f, -0.03179342f, -0.01955493f, 0.07921208f, -0.12842566f, -0.05710607f, 
    0.09446920f, 0.12462591f, 0.05888797f, -0.20033219f, 0.21576844f, -0.23823287f, -0.09085002f, 0.15419275f, 
    -0.03939842f, 0.07363026f, 0.00909907f, -0.07517634f, -0.03401430f, -0.47055826f, -0.12601522f, -0.16691165f, 
    0.05101671f, 0.06277231f, 0.06457356f, 0.11093493f, -0.13665241f, 0.05435070f, 0.06696660f, -0.07341141f, 
    0.46061933f, 0.28598738f, -0.03528653f, -0.05399621f, 0.13386236f, 0.16463381f, -0.01301743f, 0.26389429f, 
    -0.08223332f, -0.01696021f, -0.11705207f, -0.05444085f, -0.21063481f, -0.00169786f, 0.02240842f, -0.00246006f, 
    -0.00255356f, -0.05582574f, -0.09678358f, -0.11467157f, 0.03366740f, -0.10414543f, -0.02827326f, -0.00470951f, 
    0.03784458f, -0.03490708f, 0.08884431f, 0.01165106f, 0.08506228f, 0.12155481f, 0.03223257f, 0.10753979f, 
    0.13435851f, 0.12837386f, 0.23287767f, 0.14234397f, -0.08778823f, 0.03310184f, 0.06607819f, -0.09895936f, 
    0.09621976f, 0.09523071f, 0.02684286f, -0.14373921f, -0.19683766f, -0.06455741f, -0.18956706f, 0.02594359f, 
    -0.06670187f, 0.14219162f, -0.30206445f, 0.10783013f, 0.12284655f, -0.16636008f, -0.10653490f, -0.18757598f, 
    -0.16255146f, -0.27478775f, -0.38434905f, -0.40719056f, 0.31158370f, 0.19331877f, 0.17074700f, 0.17577106f, 
    0.20820680f, 0.16941172f, -0.15675312f, -0.11063536f, -0.22407822f, -0.07116450f, -0.16362558f, 0.04905878f, 
    -0.05433503f, 0.13833585f, 0.19865552f, 0.04733085f, 0.12068226f, 0.08217555f, -0.06226259f, 0.11617656f, 
    -0.10812899f, -0.06493708f, -0.12139389f, -0.23986593f, 0.17951868f, -0.12017267f, 0.23998959f, 0.22920413f, 
    -0.03829003f, -0.07506178f, -0.03124091f, 0.19622816f, 0.22695827f, 0.22719118f, 0.17653000f, 0.17768130f, 
    0.17126453f, 0.25113875f, 0.02080385f, 0.28540641f, -0.07191934f, -0.06085400f, 0.07055970f, -0.03888454f, 
    0.00194146f, 0.08651287f, -0.07855931f, 0.24866293f, -0.31268919f, -0.21048097f, 0.00453120f, 0.11302991f, 
    0.10447645f, 0.11413332f, 0.09186898f, 0.19060206f, -0.03645612f, -0.10404363f, -0.07596283f, 0.13739838f, 
    0.64180738f, 0.09722809f, 0.42020085f, 0.46110806f, -0.13408184f, -0.27377078f, 0.00272231f, -0.03904926f, 
    0.05490110f, -0.07502287f, -0.05778906f, 0.02702046f, -0.11952050f, 0.09163439f, -0.01008588f, -0.02901248f, 
    0.08992850f, -0.12654443f, -0.05234339f, 0.11189625f, -0.10658184f, -0.03557816f, -0.06612555f, -0.40871397f, 
    -0.01097523f, 0.21849713f, -0.21822330f, -0.28296992f, -0.10470623f, -0.04213786f, -0.16455911f, -0.10152141f, 
    -0.07753173f, 0.04660620f, -0.09432001f, -0.22053252f, -0.21301939f, 0.11041734f, 0.02079067f, 0.27829057f, 
    -0.06621147f, -0.10208984f, 0.06604390f, -0.20969050f, 0.27190596f, 0.17096463f, 0.10990234f, 0.26221246f, 
    -0.19970459f, -0.05075334f, 0.00369695f, 0.19402625f, 0.07201544f, 0.34557450f, 0.27335805f, 0.22593418f, 
    0.20300351f, 0.24312681f, 0.03141574f, 0.25000027f, -0.55130899f, 0.04421624f, 0.26996303f, -0.04952291f, 
    0.04170720f, -0.09972759f, 0.05956345f, -0.25665769f, -0.07481037f, -0.01435119f, -0.12821215f, -0.12021130f, 
    -0.23505549f, -0.26325685f, -0.09435396f, 0.29302531f, -0.01470810f, 0.18948570f, -0.08984331f, 0.07434052f, 
    -0.03079014f, -0.16330795f, 0.12842914f, 0.00226167f, -0.15206268f, 0.03458317f, -0.10959354f, -0.06678783f, 
    0.06719981f, -0.22159615f, -0.07646662f, -0.10593539f, -0.03040652f, 0.15780210f, 0.35074276f, 0.25151289f, 
    -0.02365796f, -0.06323383f, 0.05374615f, -0.00142441f, 0.09200046f, 0.31760511f, 0.08102527f, -0.09992617f, 
    0.12306720f, -0.01890196f, -0.14043118f, 0.03191860f, 0.39173329f, 0.12897526f, 0.13175051f, -0.02266518f, 
    0.23441748f, 0.29267940f, -0.10854220f, 0.00117358f, 0.02190796f, 0.05842753f, 0.16472256f, -0.07236958f, 
    -0.06102693f, 0.27551007f, -0.11361930f, 0.13908644f, 0.08083457f, -0.01393550f, 0.17766342f, -0.09726094f, 
    0.17905852f, 0.25111860f, 0.12410856f, 0.18686707f, 0.22849166f, 0.02497772f, 0.12518078f, 0.24250673f, 
    -0.28802025f, 0.35947084f, 0.16198717f, 0.00230596f, -0.15634379f, -0.14828040f, 0.05544261f, 0.12252031f, 
    -0.23105927f, -0.02343684f, -0.14066692f, 0.22694588f, 0.03848796f, 0.13163231f, 0.06632483f, 0.25661111f, 
    0.05963752f, -0.01117461f, -0.17936167f, -0.06634309f, -0.48015538f, -0.10221603f, 0.02113695f, -0.37309158f, 
    0.04901857f, 0.23005854f, -0.09474027f, 0.04352411f, -0.02110932f, 0.10976484f, 0.02225146f, -0.00915900f, 
    -0.61171514f, -1.04893696f, -0.15632100f, 0.48720199f, -0.08284588f, 0.15215988f, 0.04274754f, 0.23678748f, 
    -0.06360985f, 0.03109829f, 0.17212103f, -0.19632643f, -0.33934593f, -0.87140316f, -0.92779475f, -0.15648565f, 
    0.09707087f, -0.33669174f, 0.03199782f, -0.11397929f, -0.25056115f, -0.05610836f, -0.02474496f, -0.03101566f, 
    -0.10785278f, -0.15805270f, -0.03003621f, -0.34599000f, -0.12108963f, 0.18119639f, -0.05215434f, 0.23240858f, 
    -0.12431417f, 0.04209079f, -0.05280347f, -0.05487304f, -0.38289532f, -0.52171260f, -0.18860796f, -0.08408556f, 
    0.06254619f, -0.11643739f, -0.12447327f, -0.04154557f, -0.04135191f, 0.04409823f, 0.07725503f, 0.02589737f, 
    0.24948624f, 0.09374802f, 0.23351422f, 0.05537241f, 0.11948627f, 0.10782872f, 0.22143149f, -0.23790696f, 
    0.15493281f, 0.29346085f, 0.19232237f, 0.17278221f, 0.33691075f, -0.09805659f, -0.25508755f, -0.27346244f, 
    -0.05764481f, 0.15126224f, -0.02469769f, -0.14866036f, 0.01543318f, 0.03330236f, 0.13718963f, -0.08350889f, 
    0.11423162f, -0.17088620f, -0.39939395f, 0.49723804f, 0.07485799f, 0.38596660f, 0.17397451f, -0.07836424f, 
    -0.06437004f, -0.20270270f, -0.10999446f, 0.08265693f, 0.10174768f, -0.01511951f, -0.14862774f, -0.15963265f, 
    0.22328304f, 0.10088540f, -0.21736671f, 0.09345144f, 0.03863615f, 0.01531777f, 0.00764773f, -0.00617277f, 
    -0.28020203f, -0.71752661f, -0.93694204f, -0.33479500f, 0.31312299f, -0.09221832f, 0.06881579f, 0.11942398f, 
    -0.12281644f, -0.09634136f, -0.04747037f, 0.05739282f, 0.05923074f, 0.27421260f, 0.14708924f, 0.16455767f, 
    -0.02358763f, -0.01302621f, 0.05719438f, 0.00032356f, 0.27754858f, 0.17324626f, 0.15444794f, 0.11547816f, 
    0.04293311f, 0.11645399f, 0.07220329f, 0.03097770f, -0.01091425f, 0.03204880f, 0.10828010f, -0.04160363f, 
    -0.19039345f, 0.16933726f, -0.04677065f, -0.03198894f, 0.06346189f, -0.21495925f, -0.12350286f, 0.10949138f, 
    -0.12585035f, 0.04935965f, -0.08378651f, 0.10421144f, 0.01650218f, 0.04030784f, 0.00321237f, -0.00138154f, 
    0.14551449f, -0.10923786f, -0.00602894f, -0.05340888f, -0.01690741f, -0.02076861f, -0.04764342f, 0.11955484f, 
    -0.07053742f, 0.00571263f, 0.15304148f, 0.10222192f, 0.15539150f, -0.14134979f, -0.02967606f, 0.13453995f, 
    0.03141893f, -0.11263895f, 0.01167478f, 0.06516582f, 0.09950193f, 0.07830783f, 0.06006998f, 0.06642738f, 
    -0.04595545f, 0.04601244f, -0.30957058f, 0.18835066f, 0.21404102f, 0.04401319f, 0.25506440f, 0.41328007f, 
    -0.09345552f, -0.11485671f, 0.03254118f, -0.05099924f, 0.22163229f, 0.34345651f, 0.15965162f, 0.15612046f, 
    0.02832433f, 0.06500679f, -0.09569193f, -0.26716015f, -0.10109600f, -0.15981698f, -0.08347914f, -0.06404375f, 
    -0.08449472f, 0.07108735f, -0.02618790f, -0.06688696f, 0.00830291f, 0.16379701f, 0.10823234f, -0.23732819f, 
    -0.11608966f, -0.23167773f, 0.10823643f, -0.00872846f, -0.28302118f, 0.05044631f, 0.07219278f, -0.09640632f, 
    -0.12216114f, -0.06201833f, -0.11475165f, -0.23797658f, 0.06090932f, 0.01231867f, 0.07529303f, 0.03237582f, 
    0.19792284f, -0.08595866f, -0.03899521f, -0.04065674f, 0.19186898f, -0.02929716f, 0.10461325f, -0.01990995f, 
    -0.05137775f, 0.09723347f, -0.00829936f, 0.11891132f, 0.09702782f, 0.08678184f, 0.17819177f, -0.03628115f, 
    -0.22035006f, -0.19370677f, -0.00826498f, -0.38321221f, 0.14044647f, 0.02234561f, -0.00645752f, 0.02210313f, 
    0.08770988f, -0.08014237f, -0.09065828f, 0.09346897f, -0.01784058f, 0.07729483f, -0.00162047f, 0.15046744f, 
    -0.12571181f, -0.24760705f, -0.31075221f, -0.10353739f, -0.23796372f, -0.06104733f, -0.04330613f, 0.04602498f, 
    -0.04083400f, 0.06601771f, 0.06033669f, -0.14810175f, 0.09509770f, 0.14260280f, 0.01391891f, 0.00699361f, 
    0.19959216f, 0.19118774f, 0.26781774f, -0.10390758f, -0.17324562f, -0.07464442f, -0.10473422f, -0.34726009f, 
    -0.11177080f, -0.16601790f, -0.11790563f, 0.00689637f, 0.11990611f, 0.08324000f, 0.06572484f, -0.01259928f, 
    0.04984152f, -0.22552720f, 0.02869859f, -0.36149305f, 0.06299111f, 0.07550824f, 0.07190982f, 0.04669373f, 
    -0.25461492f, -0.04033399f, 0.03981948f, -0.02345236f, -0.34609693f, -0.06181787f, -0.10655534f, -0.22907481f, 
    -0.06355478f, 0.02489134f, 0.03654287f, 0.06528186f, 0.08853301f, 0.01208285f, 0.01313955f, 0.06506716f, 
    0.08104435f, 0.05155753f, 0.00734352f, 0.06621630f, 0.00054196f, -0.03331143f, -0.07532471f, -0.30512089f, 
    -0.08499438f, -0.15862995f, 0.15390244f, -0.11779726f, 0.11078115f, -0.12055217f, -0.05451441f, 0.16757588f, 
    0.12924951f, 0.11836188f, 0.09886874f, 0.02151329f, -0.06530193f, 0.33264145f, -0.21243808f, -0.01109556f, 
    0.10234008f, 0.04849149f, -0.02836748f, 0.17882390f, 0.04897483f, 0.00143378f, 0.07605612f, -0.01240438f, 
    0.23233746f, 0.03914221f, -0.35312134f, 0.20067033f, 0.01822307f, -0.03508957f, -0.03931295f, -0.01782853f, 
    0.04886831f, 0.14350055f, 0.01334126f, 0.21824367f, 0.14985704f, -0.25976738f, 0.01045671f, 0.31802735f, 
    0.08632731f, 0.24184053f, -0.05954964f, 0.13011882f, -0.06397868f, -0.01589386f, 0.03148812f, 0.02579183f, 
    -0.19072314f, 0.07731157f, -0.05925518f, 0.15942998f, 0.02065682f, 0.19739066f, 0.17291260f, -0.13298899f, 
    -0.08816849f, -0.13453588f, -0.03780475f, 0.15281306f, -0.07576077f, -0.24488436f, 0.01139372f, 0.15574758f, 
    -0.00075886f, 0.04180992f, 0.00016680f, 0.02103098f, 0.04251368f, 0.09150898f, 0.11783405f, 0.09474988f, 
    0.08933424f, 0.04237494f, -0.03030506f, 0.37116325f, 0.04561296f, -0.06199995f, -0.02864197f, -0.09940870f, 
    0.05517557f, 0.04340425f, -0.06796175f, 0.16952664f, -0.18899611f, 0.02379630f, 0.14655645f, 0.08696520f, 
    0.07771886f, -0.11161441f, -0.00457183f, -0.09670827f, 0.03868253f, -0.06694172f, -0.04065317f, 0.10483594f, 
    -0.25641841f, -0.20209563f, 0.07966588f, -0.15908679f, -0.03109486f, -0.01270506f, -0.02299084f, -0.05375500f, 
    0.06013413f, 0.00030564f, 0.11096729f, 0.15527613f, -0.19497564f, -0.09730826f, 0.08249754f, 0.08332899f, 
    0.13394003f, 0.22073391f, 0.00005766f, -0.06183796f, -0.09056803f, 0.10917909f, 0.04817661f, 0.04606992f, 
    -0.00339396f, 0.33294162f, 0.04164053f, -0.16512242f, 0.13152538f, -0.08364998f, -0.12434544f, 0.00847990f, 
    0.10073249f, 0.00549257f, 0.08148570f, 0.13956463f, 0.02970572f, 0.15897399f, 0.00494771f, 0.17659006f, 
    -0.02145734f, 0.08236269f, 0.07703909f, -0.05801409f, 0.16971391f, 0.02659713f, 0.04108342f, -0.09647937f, 
    -0.27077866f, -0.19117227f, -0.04388162f, 0.22113252f, -0.14526713f, 0.00783344f, 0.02994788f, -0.05285845f, 
    0.00188819f, -0.05142479f, -0.10250349f, -0.02657948f, -0.22555032f, 0.12250780f, -0.07160912f, -0.25207371f, 
    0.09374070f, 0.13289730f, 0.03348910f, -0.02304043f, 0.17060953f, -0.05363685f, 0.04736025f, 0.01373127f, 
    -0.11006078f, -0.24378446f, 0.21107315f, 0.22968340f, -0.05347768f, -0.02080715f, -0.03122420f, -0.04498380f, 
    -0.02245378f, -0.10059095f, 0.04819250f, 0.18141003f, -0.02631239f, 0.12205611f, 0.01501932f, -0.03927930f, 
    -0.07972826f, 0.01897116f, -0.06087445f, -0.13131171f, -0.03713568f, 0.09184472f, 0.07533475f, -0.09188956f, 
    -0.05123923f, 0.06451639f, -0.01505657f, -0.01521532f, 0.04248631f, -0.05533515f, -0.00211742f, -0.02505847f, 
    -0.02008537f, -0.05995564f, -0.04551019f, -0.02305434f, -0.01508662f, 0.02458680f, -0.06859428f, 0.01281404f, 
    -0.07699925f, -0.07955757f, -0.06580396f, -0.00032329f, 0.00807568f, -0.04173983f, 0.03571252f, -0.00793681f, 
    -0.00110678f, -0.02722566f, -0.05029057f, 0.01881977f, 0.03290642f, -0.07479888f, 0.02846204f, -0.05927065f, 
    0.01727170f, -0.07300206f, -0.03458068f, 0.02599573f, -0.05612102f, 0.04500440f, 0.00545412f, 0.03781730f, 
    -0.03048158f, 0.01996667f, 0.02918154f, -0.07657605f, 0.05551317f, 0.05508950f, -0.04523195f, -0.02154111f, 
    -0.01568422f, -0.07958918f, 0.05117126f, 0.03859172f, 0.03016785f, -0.05628482f, -0.07024337f, -0.06762633f, 
    0.04148637f, 0.02667238f, -0.01324209f, 0.03762379f, -0.00601718f, 0.05188428f, -0.05669417f, 0.04005041f, 
    -0.04719747f, 0.04868102f, -0.06901606f, 0.01112233f, -0.02244685f, -0.01677268f, 0.02178697f, -0.01339808f, 
    -0.07386637f, 0.02105389f, 0.01849110f, 0.05150663f, -0.04488631f, -0.01763136f, 0.03281708f, -0.00536589f, 
    0.04764263f, -0.02771466f, 0.01031000f, -0.02346333f, -0.02529619f, -0.06254232f, -0.05850142f, 0.01522692f, 
    0.01436612f, -0.02603164f, -0.04664180f, 0.04569035f, 0.05523469f, -0.05114943f, -0.01338584f, 0.01770951f, 
    -0.04565628f, -0.01181915f, 0.00682734f, -0.00668554f, -0.05647500f, 0.03188467f, 0.00432471f, -0.05312282f, 
    0.03249060f, -0.07951880f, 0.04360007f, -0.05714504f, -0.05416322f, 0.03116438f, 0.04293614f, -0.00320080f, 
    -0.00969207f, 0.03022248f, -0.06908091f, -0.01826510f, -0.01755789f, -0.01048918f, 0.00534810f, 0.00034117f, 
    -0.04288281f, -0.01174979f, -0.02862619f, 0.06090873f, -0.04031220f, -0.02309593f, 0.05673835f, -0.00079804f, 
    -0.06169927f, 0.02661015f, 0.05003007f, -0.04956490f, 0.05030195f, -0.08016418f, 0.05538339f, -0.05201366f, 
    -0.01357159f, -0.03913622f, 0.06254514f, -0.06161313f, -0.00758117f, -0.07142630f, -0.01887259f, -0.04336142f, 
    -0.03908111f, 0.03325155f, -0.05951707f, -0.05839862f, -0.05683764f, -0.06323983f, -0.05072843f, 0.01293072f, 
    0.01960856f, -0.00093946f, -0.00894069f, 0.06321453f, 0.02531128f, -0.06806921f, 0.04987396f, 0.02282452f, 
    -0.01258205f, -0.01570608f, 0.04888594f, -0.06171273f, -0.03775363f, -0.06224889f, -0.03706547f, 0.00912017f, 
    0.05164111f, 0.02422708f, -0.02489290f, 0.05514142f, 0.05729870f, -0.02640138f, 0.04220543f, -0.00972117f, 
    -0.02859324f, 0.05295455f, -0.02759595f, 0.06338886f, -0.06623659f, -0.04759752f, 0.01776947f, -0.02531007f, 
    -0.04890070f, -0.01657778f, 0.01803963f, -0.02330159f, -0.00373987f, 0.00948174f, 0.03170950f, -0.01296846f, 
    -0.10480160f, -0.08775133f, -0.07708202f, 0.01030435f, 0.11950712f, -0.02594396f, 0.02887265f, 0.16042063f, 
    -0.09900664f, 0.00856565f, 0.01271114f, -0.07560626f, 0.64721721f, 0.08543859f, 0.22874816f, 0.10243735f, 
    -0.09471736f, -0.05098060f, 0.10956686f, 0.02050993f, 0.02156188f, 0.08271133f, 0.07149310f, -0.02591489f, 
    -0.21084502f, -0.10858545f, -0.04278358f, 0.15703584f, -0.09343385f, 0.08549953f, -0.08049432f, 0.00738422f, 
    -0.03511368f, -0.00769866f, -0.01529071f, -0.01087118f, -0.46405908f, -0.36376199f, 0.17300738f, 0.20750633f, 
    0.12529069f, -0.07023975f, -0.01610593f, 0.12780888f, -0.02363997f, -0.02735427f, 0.00937861f, 0.02420656f, 
    0.26819330f, 0.12506233f, -0.08602463f, -0.03548400f, 0.00658185f, 0.05076413f, 0.03755383f, -0.11901799f, 
    -0.05225935f, 0.05946822f, 0.06775142f, 0.14973296f, 0.05966745f, -0.14758931f, 0.21639463f, -0.19472364f, 
    -0.08692511f, -0.01398278f, 0.07463258f, -0.20987713f, 0.11832567f, -0.07186379f, 0.03842348f, 0.03347056f, 
    0.03680469f, 0.07605592f, -0.28849915f, 0.10237938f, -0.01515581f, 0.24078676f, -0.06128736f, 0.19680531f, 
    0.13560978f, -0.18709747f, 0.03281315f, -0.10165719f, -0.03535812f, 0.09817568f, 0.16865508f, -0.21758030f, 
    -0.07773106f, 0.10410254f, 0.07370761f, -0.16509755f, 0.00152245f, -0.13254921f, -0.01786905f, 0.01963413f, 
    -0.57377189f, -0.19610088f, -0.13411202f, -0.18292764f, -0.23462245f, 0.04321231f, 0.08459017f, 0.31341287f, 
    0.16598409f, 0.05505558f, -0.04277854f, -0.02768315f, 0.21837813f, -0.08648791f, 0.00693161f, 0.07041163f, 
    0.18409400f, 0.21275610f, -0.00968432f, -0.07105439f, -0.05556636f, 0.06784038f, -0.06923928f, 0.04514870f, 
    0.42558351f, -0.04994486f, 0.13302405f, 0.03517803f, -0.02204483f, -0.05473457f, 0.25677717f, -0.02043789f, 
    0.37327427f, 0.16444062f, 0.11942142f, 0.17036554f, 0.23301077f, -0.09546012f, -0.30357668f, -0.14090754f, 
    0.09640533f, 0.16903706f, 0.04477286f, 0.06309912f, 0.07570532f, -0.01090080f, 0.04665994f, -0.09671048f, 
    0.22338365f, 0.13499784f, -0.00589486f, 0.02536656f, 0.01191917f, 0.07943147f, -0.22158672f, -0.18901338f, 
    0.08980680f, -0.17082150f, -0.11549063f, -0.04870561f, -0.03001852f, 0.03192721f, -0.03946994f, -0.15028316f, 
    0.07834492f, 0.10685458f, 0.03971567f, 0.23561206f, 0.01277773f, -0.17044294f, -0.12792633f, -0.10465494f, 
    -0.34897384f, 0.31636584f, -0.05291402f, -0.08821745f, 0.03222429f, 0.01714500f, 0.21790119f, 0.11183276f, 
    -0.09053743f, -0.02707326f, -0.01755518f, 0.05812168f, 0.10006387f, 0.02793464f, 0.04097396f, 0.06465073f, 
    0.07073223f, -0.03112006f, -0.14317970f, -0.04773463f, -0.10003206f, -0.02420919f, -0.24138078f, -0.14386827f, 
    0.08752654f, 0.07630557f, 0.07082630f, 0.06337965f, -0.27203727f, 0.04001483f, 0.07921829f, 0.07789481f, 
    -0.02246551f, -0.16758148f, -0.10358384f, 0.14699277f, -0.49479797f, 0.22057594f, -0.15498036f, 0.54923540f, 
    0.01328361f, 0.14729331f, -0.07500810f, 0.03780409f, -0.01483918f, 0.05237399f, -0.09393061f, 0.01387281f, 
    0.31143928f, -0.06456856f, -0.03539355f, -0.11782174f, 0.14161970f, 0.07862465f, -0.03464870f, 0.10226693f, 
    0.00839397f, -0.02917773f, -0.16381060f, 0.00673201f, 0.38743615f, 0.17516240f, -0.11163801f, 0.24724351f, 
    0.00844040f, -0.01478359f, -0.04707286f, -0.01697522f, -0.08040645f, -0.01487747f, -0.02511456f, 0.07626151f, 
    -0.09628639f, -0.00180031f, 0.65180957f, 0.07012581f, -0.00853748f, 0.15974312f, -0.08159437f, 0.10644854f, 
    -0.16368331f, -0.05769813f, -0.05117665f, -0.05770035f, -0.14900571f, -0.17037505f, 0.27368349f, 0.40900388f, 
    0.11426134f, -0.02707109f, 0.10534623f, -0.14216387f, -0.04326542f, 0.17492783f, 0.14890626f, 0.20513456f, 
    -0.04112525f, -0.14405560f, -0.01858923f, 0.16397503f, 0.08720560f, -0.02051562f, 0.06920279f, -0.12069770f, 
    0.08640574f, -0.02134129f, 0.05131250f, -0.00187988f, -0.21899484f, 0.00471421f, 0.23169868f, 0.19544339f, 
    0.03002876f, -0.01926665f, 0.10118069f, 0.02282778f, 0.03748104f, 0.15566899f, -0.09934831f, 0.01713004f, 
    0.22584549f, 0.13047253f, -0.26700455f, -0.05700757f, -0.09037644f, -0.06025620f, 0.03599081f, -0.03792895f, 
    0.09813704f, 0.01991372f, 0.02850094f, -0.01009963f, -0.14717379f, 0.02202451f, 0.28236040f, 0.28675494f, 
    0.01257892f, -0.02298746f, -0.04616605f, 0.09110761f, -0.09425751f, 0.04617218f, -0.17100817f, -0.06530688f, 
    -0.11300377f, 0.09087370f, 0.22690839f, 0.06311829f, 0.05762368f, 0.23247620f, 0.01482352f, -0.01779035f, 
    0.11631302f, 0.08586075f, 0.11154769f, -0.07134373f, -0.37117746f, 0.02062237f, -0.02626447f, 0.00269509f, 
    -0.02215998f, -0.05713331f, -0.00942880f, 0.07292310f, -0.09037074f, -0.09343084f, -0.03383310f, 0.14083970f, 
    -0.02342963f, 0.09007066f, 0.04210662f, 0.10607252f, -0.08745361f, 0.12341787f, 0.01629613f, -0.06602382f, 
    0.01193284f, 0.08036230f, -0.09358941f, 0.18936235f, -0.16159166f, 0.02481930f, 0.30640683f, 0.28095639f, 
    0.04094153f, -0.15193990f, 0.01794855f, -0.16881499f, -0.02366040f, -0.14049765f, -0.04048561f, 0.03525985f, 
    -0.05114586f, -0.29911724f, -0.12492078f, 0.22979772f, 0.00196321f, -0.08459050f, -0.02175762f, -0.28810450f, 
    0.00724335f, -0.03563572f, -0.04921537f, 0.06489810f, 0.43257070f, 0.00069958f, 0.18289320f, -0.04899704f, 
    -0.09242164f, -0.05312941f, 0.01616968f, -0.11934969f, 0.07460724f, 0.21140474f, 0.18492006f, 0.04535409f, 
    -0.08565276f, -0.09194117f, -0.17303804f, 0.06181275f, 0.07442161f, 0.04957823f, 0.01302178f, 0.00890363f, 
    -0.04234570f, 0.08459057f, -0.03232770f, -0.05091779f, 0.03004920f, 0.21809573f, 0.01992930f, 0.33755842f, 
    0.02798510f, 0.31054458f, -0.05523990f, 0.09655274f, -0.04161293f, 0.01225094f, 0.07990243f, -0.02399507f, 
    0.14087582f, 0.09126057f, -0.01311058f, -0.01696423f, 0.02880374f, 0.12558858f, 0.01702087f, 0.11233100f, 
    0.07791564f, -0.00340136f, 0.23301905f, 0.03904875f, 0.17887031f, 0.60272908f, -0.34598333f, -0.23352326f, 
    0.16471316f, 0.10498067f, -0.04835738f, 0.06063189f, -0.10230535f, 0.12015671f, 0.02765686f, 0.01434458f, 
    -0.19442527f, 0.12232871f, -0.14447185f, 0.25797972f, -0.09829114f, 0.14552447f, 0.04826461f, -0.02342302f, 
    0.13838564f, 0.05813623f, 0.08517071f, -0.02708302f, -0.25162232f, -0.03050797f, -0.41141480f, 0.00161296f, 
    0.05254881f, -0.07885329f, 0.05140184f, 0.21463665f, -0.02336213f, -0.03062459f, -0.09716206f, 0.04976544f, 
    0.20079298f, -0.03154287f, 0.12193765f, 0.37041718f, -0.06387215f, 0.29200265f, -0.00871585f, 0.03562636f, 
    0.08510402f, -0.00578290f, -0.01375512f, 0.10959320f, 0.04101165f, -0.24171714f, 0.40168166f, 0.41157076f, 
    -0.10565694f, 0.04993591f, 0.01404379f, -0.07712892f, 0.01911561f, 0.01472278f, 0.07574589f, -0.02568352f, 
    -0.23804283f, 0.02646615f, 0.13247125f, 0.14533472f, 0.00173600f, 0.03893368f, 0.11632188f, 0.11430137f, 
    -0.10385536f, 0.09517375f, 0.03721208f, 0.03031776f, -0.16449930f, -0.37512541f, -0.18446319f, 0.05179080f, 
    0.05574739f, 0.03884206f, 0.01499884f, -0.08193936f, -0.04131191f, 0.07084565f, 0.02910788f, -0.02629408f, 
    -0.00689037f, 0.01331614f, 0.10425480f, -0.24600975f, -0.06414133f, -0.01043341f, 0.21381517f, 0.13822570f, 
    0.18523915f, 0.29444492f, 0.26796079f, 0.14810739f, -0.22376756f, 0.17012516f, -0.01783986f, 0.35439748f, 
    -0.02049284f, 0.09891215f, 0.01146605f, 0.02039406f, -0.05594737f, 0.07431019f, -0.19527268f, -0.08312807f, 
    -0.43229923f, -0.14973173f, -0.28889042f, -0.05254481f, -0.10372267f, -0.05322993f, -0.04804333f, -0.29937166f, 
    0.06342070f, 0.03003863f, -0.00150665f, -0.08082635f, -0.35545596f, -0.15093450f, -0.18980362f, 0.22447981f, 
    0.00028012f, 0.07972695f, 0.18488160f, -0.06316601f, -0.02285331f, 0.08580811f, 0.08670696f, -0.00488693f, 
    0.22081497f, -0.40975782f, 0.02620492f, 0.22727802f, -0.03993402f, -0.03673683f, -0.00824541f, -0.01047632f, 
    -0.04353701f, -0.02260902f, -0.06032594f, -0.09906531f, -0.17201827f, -0.04302141f, 0.10106292f, -0.29157075f, 
    -0.05363569f, -0.17127191f, -0.01738908f, 0.04051078f, -0.20445164f, -0.19342445f, -0.10846166f, -0.07069580f, 
    -0.13782962f, -0.02197176f, 0.04880778f, 0.04815920f, -0.01087314f, 0.21363540f, -0.02570129f, 0.02260983f, 
    0.15313396f, -0.02921017f, -0.11646213f, -0.25417104f, -0.19240496f, 0.15009077f, -0.28745797f, 0.26343647f, 
    0.18098366f, 0.13314132f, 0.19941726f, 0.16897549f, -0.01788061f, 0.16720471f, 0.12719506f, 0.07435739f, 
    0.06424416f, -0.05996405f, -0.04196018f, -0.05134813f, 0.04861047f, -0.04593753f, 0.06313732f, 0.00587226f, 
    -0.20186238f, -0.00594563f, -0.00523778f, -0.10480676f, 0.45680228f, 0.59559619f, -0.28933081f, -0.01362531f, 
    0.21109454f, 0.09401816f, 0.07119553f, -0.00005762f, -0.00571406f, -0.10205129f, 0.10344923f, 0.03503214f, 
    -0.37630185f, 0.14611317f, -0.07032453f, 0.08621281f, -0.04306209f, -0.04772518f, 0.08686668f, -0.04902460f, 
    -0.00304075f, 0.08846480f, -0.16306706f, -0.08207519f, -0.15871452f, -0.48318449f, -0.17693074f, 0.09073962f, 
    0.13797082f, -0.11593541f, -0.02854666f, -0.02520078f, 0.06871319f, -0.05187459f, 0.21763103f, 0.15568946f, 
    0.10363175f, 0.46711650f, -0.06478636f, 0.11197224f, -0.24907567f, -0.08060177f, 0.16432713f, 0.21580151f, 
    -0.13571692f, 0.14650142f, 0.21988286f, 0.11036971f, -0.15894614f, -0.08263411f, 0.40550554f, -0.01259210f, 
    -0.22898759f, -0.02750545f, 0.22433753f, 0.22500300f, -0.02425829f, -0.09082508f, -0.11666057f, -0.10846731f, 
    -0.35779735f, 0.38418666f, 0.19971114f, 0.28646791f, -0.12994707f, 0.02555897f, 0.06984726f, 0.02961672f, 
    0.01779372f, -0.05214933f, -0.10198367f, -0.14738145f, -0.40613455f, -0.26001289f, -0.19117889f, -0.26431519f, 
    0.16054800f, -0.23136953f, -0.06400020f, 0.04147287f, -0.06714998f, 0.03171483f, -0.17153345f, -0.15175876f, 
    -0.11331760f, 0.12911366f, 0.04605405f, -0.01190862f, 0.37848267f, -0.02793746f, 0.15758413f, 0.24176665f, 
    0.05420670f, 0.18872812f, -0.00417723f, 0.04741172f, -0.23040080f, 0.35372454f, 0.16672498f, -0.16718625f, 
    -0.14368896f, 0.07254309f, -0.05739625f, 0.05826421f, 0.05665143f, 0.43629247f, 0.19062951f, 0.31157455f, 
    -0.14106067f, -0.38937125f, -0.28127685f, -0.07414929f, -0.12444708f, 0.03701930f, 0.14067388f, -0.11908651f, 
    -0.15725012f, -0.05557830f, 0.13694900f, 0.02165068f, -0.14784862f, 0.05206305f, 0.11532979f, -0.01031639f, 
    -0.09955386f, 0.23796792f, 0.16601732f, 0.08658215f, -0.02473553f, -0.06874664f, -0.01318830f, 0.02469335f, 
    0.06958174f, -0.10963015f, 0.07419411f, -0.02450123f, -0.27219349f, 0.26357812f, 0.12184287f, 0.01717341f, 
    -0.12521991f, -0.09799404f, -0.07375003f, -0.21559410f, 0.16406298f, -0.18901739f, 0.22605059f, -0.25062966f, 
    0.01763966f, -0.00189634f, 0.10977581f, 0.08204528f, 0.17686044f, 0.15322423f, 0.22034077f, 0.29939470f, 
    0.15919949f, -0.03761169f, 0.12548290f, -0.14480224f, 0.07812883f, 0.20650989f, 0.07470092f, 0.11160064f, 
    0.08006933f, 0.09747452f, 0.15899926f, 0.02806828f, 0.16716729f, -0.36891153f, 0.25240853f, -0.45926765f, 
    0.11206293f, 0.03831734f, 0.02149674f, 0.00119414f, -0.11424468f, -0.11452231f, -0.16523023f, 0.00842266f, 
    -0.23703341f, 0.06643084f, -0.27468872f, 0.01671255f, 0.03584083f, -0.00954777f, 0.10066904f, -0.00748747f, 
    -0.14362456f, -0.21610186f, -0.29169416f, -0.23524337f, -0.00317660f, -0.01283618f, 0.11631903f, -0.01623745f, 
    0.16538592f, -0.19647230f, -0.04440024f, -0.16858849f, -0.17975701f, -0.06420638f, -0.21305336f, -0.00831277f, 
    0.22254977f, -0.00089876f, 0.10891239f, -0.22354580f, 0.11936898f, 0.00661207f, 0.08123779f, 0.12355421f, 
    -0.06274675f, -0.06629182f, -0.06143395f, -0.23661627f, 0.11067522f, 0.09159188f, 0.29422003f, 0.15610664f, 
    0.07579608f, 0.10312264f, 0.04681721f, 0.23908938f, 0.08106466f, 0.00704090f, 0.05052091f, 0.02187066f, 
    0.17891850f, 0.27618152f, -0.02631307f, -0.16059522f, -0.03736190f, 0.02352130f, 0.03517214f, -0.10166597f, 
    -0.03775189f, -0.00696981f, -0.10252205f, 0.13722749f, 0.06778996f, 0.00053805f, 0.17518397f, 0.03577979f, 
    0.01471399f, 0.04278472f, 0.11566263f, 0.20898165f, 0.01426051f, 0.03642226f, -0.08635747f, 0.01002331f, 
    0.81640011f, -0.20543021f, 0.07243787f, 0.39675874f, -0.21444170f, -0.21329747f, -0.13551511f, -0.15110190f, 
    0.17490892f, -0.14807394f, 0.02879712f, 0.12587325f, 0.20228507f, 0.27414185f, 0.11290798f, -0.09323129f, 
    0.06622506f, 0.07797936f, 0.05696128f, 0.23712271f, -0.06560488f, -0.05502530f, -0.00693869f, -0.18328133f, 
    -0.16025485f, -0.25448313f, -0.14176458f, -0.03851695f, -0.18748622f, -0.11714514f, -0.08531766f, 0.10586835f, 
    0.01947771f, -0.06388461f, -0.02729548f, -0.14846966f, 0.04625212f, -0.01644491f, 0.25304922f, 0.00578107f, 
    -0.03972135f, 0.00447167f, 0.00597826f, -0.16617502f, 0.27596259f, 0.11582290f, 0.06868757f, 0.19106697f, 
    0.01690129f, 0.17852050f, 0.19343063f, -0.05505415f, 0.26583746f, 0.09086916f, 0.08326413f, 0.15561208f, 
    0.02229051f, 0.13705303f, 0.02992132f, 0.11206099f, 0.01512757f, -0.15603876f, 0.41648388f, -0.48445886f, 
    0.02770869f, -0.05498004f, -0.00232306f, -0.10356452f, -0.08045811f, 0.04959546f, 0.09857790f, -0.09879965f, 
    -0.22771227f, 0.29513690f, 0.06130461f, 0.00840813f, -0.04668821f, 0.23154360f, -0.07667356f, 0.28179601f, 
    -0.02584711f, -0.09840688f, 0.14472727f, 0.01548200f, -0.27755606f, 0.09097756f, -0.37695289f, 0.09194677f, 
    0.00553640f, -0.06458583f, 0.03406117f, -0.10444018f, 0.07471200f, 0.04314562f, 0.10668372f, 0.33577091f, 
    -0.07207777f, 0.02148421f, -0.06062877f, 0.01606879f, 0.03125825f, 0.01974455f, -0.00537575f, 0.00373783f, 
    0.03696797f, -0.06680036f, -0.07390608f, -0.04934996f, -0.05947198f, 0.03296057f, -0.01762421f, -0.07162692f, 
    0.00729135f, 0.01660836f, -0.02616815f, 0.00920122f, 0.00485073f, -0.03782754f, -0.01800261f, -0.03943392f, 
    -0.03903534f, -0.02010102f, -0.02607193f, -0.00989223f, -0.02795332f, -0.06302838f, -0.00150290f, -0.06983405f, 
    -0.07328767f, 0.01839933f, -0.03321012f, -0.00115935f, -0.05013758f, -0.07834188f, 0.02283709f, -0.02529191f, 
    -0.04878233f, 0.03570721f, -0.07812002f, -0.01848057f, 0.03635305f, -0.07236640f, -0.03888982f, -0.00144691f, 
    -0.04109645f, 0.06724313f, -0.04789140f, -0.02201865f, 0.06444546f, -0.07779139f, -0.00527034f, 0.01117037f, 
    0.00881681f, -0.00038452f, 0.04750874f, 0.03083529f, -0.03575607f, 0.01381855f, 0.05928454f, -0.03174800f, 
    0.02477461f, 0.06827112f, -0.02169073f, 0.00297412f, 0.00999970f, 0.05678120f, -0.03072422f, -0.03215189f, 
    -0.00353532f, -0.02800201f, 0.05087170f, -0.07078934f, -0.03725714f, 0.06391674f, -0.02008568f, -0.06217577f, 
    0.02346569f, -0.06685175f, 0.01625251f, -0.03046942f, 0.05616087f, -0.00717132f, 0.07132951f, 0.01785550f, 
    -0.03698758f, 0.03008195f, 0.06384505f, -0.04679785f, -0.06038577f, -0.04533263f, 0.00087582f, -0.07179092f, 
    0.02277731f, -0.07987598f, -0.04459471f, 0.05702643f, 0.01572598f, -0.03821247f, -0.04533465f, -0.00565265f, 
    0.02382186f, -0.02075208f, -0.03965629f, 0.05534245f, 0.02002763f, -0.02652080f, 0.07343634f, -0.00602118f, 
    -0.00902757f, -0.01646489f, -0.02489880f, -0.04690903f, 0.05738951f, 0.06847769f, 0.01631142f, -0.00473783f, 
    -0.03426831f, -0.00132004f, -0.06199623f, -0.00637061f, -0.00587440f, 0.05554290f, -0.01839259f, 0.03994467f, 
    -0.05487242f, -0.07219896f, -0.06158193f, 0.05354869f, 0.07076733f, 0.04821009f, -0.02460078f, -0.04667984f, 
    -0.04545804f, 0.03937624f, 0.04309756f, -0.00301023f, 0.04908717f, -0.07503121f, -0.03501158f, -0.02012053f, 
    -0.04782126f, -0.03629813f, 0.05015942f, 0.01941599f, 0.05120709f, 0.00191569f, -0.00101915f, -0.03300268f, 
    -0.07992647f, 0.05590165f, -0.07047752f, -0.03392142f, -0.02283358f, 0.01956331f, 0.00312683f, 0.05185895f, 
    -0.01514528f, 0.00763875f, 0.00909055f, -0.04415893f, 0.06504755f, -0.02913798f, -0.00415415f, 0.02193833f, 
    -0.06506740f, -0.03100105f, -0.05406337f, 0.04562777f, -0.07580502f, 0.04242039f, -0.01472036f, -0.00860006f, 
    0.04336511f, 0.04208072f, -0.03230461f, -0.01148397f, -0.02674148f, -0.06443088f, 0.03293005f, -0.02366422f, 
    -0.07817956f, -0.04420055f, 0.01112635f, -0.03605083f, 0.05499783f, 0.04110745f, -0.06606235f, -0.01537471f, 
    0.04303556f, -0.18290555f, 0.07474181f, -0.24923211f, 0.21542288f, 0.02309864f, 0.14001006f, 0.17107317f, 
    0.04668309f, 0.03794054f, 0.15482940f, -0.06905684f, -0.27970225f, 0.02332515f, 0.41973984f, 0.15408717f, 
    0.10236441f, 0.21369030f, 0.06190232f, 0.27613717f, 0.19425912f, 0.05074980f, -0.02652747f, 0.07400929f, 
    0.14710395f, -0.16838746f, 0.00910700f, -0.13415310f, -0.12839228f, 0.00372582f, -0.03554428f, 0.05340763f, 
    0.06512569f, 0.05326088f, -0.04269466f, 0.08283827f, -0.02592710f, -0.60789555f, -0.03486502f, 0.29340702f, 
    0.00366307f, 0.19855946f, 0.13111851f, 0.05844200f, -0.00676124f, -0.05002249f, 0.00690212f, 0.03752684f, 
    -0.27148095f, -0.22318989f, 0.29613483f, -0.16623844f, 0.01995287f, 0.12008057f, -0.06629030f, 0.24649414f, 
    -0.09014815f, 0.01744180f, 0.04388725f, 0.15797339f, -0.05022585f, -0.09177053f, 0.27013025f, 0.18036015f, 
    -0.00282562f, 0.14438762f, -0.04208244f, -0.34210205f, 0.16077587f, 0.03385564f, 0.10115518f, 0.02708656f, 
    -0.23152938f, 0.10883842f, 0.16411807f, -0.03283988f, -0.11513964f, -0.08468606f, -0.02691734f, 0.14911671f, 
    0.10109001f, -0.06169461f, 0.14229806f, 0.04271473f, -0.40855026f, 0.09999808f, -0.03973804f, -0.16944841f, 
    0.01999621f, -0.11997125f, -0.02155836f, 0.25491920f, 0.06092368f, 0.11949860f, -0.04197866f, 0.00880682f, 
    -0.15265653f, -0.10368223f, 0.35411525f, -0.15733799f, -0.06814520f, -0.06032725f, -0.04279320f, 0.07704803f, 
    0.07003960f, 0.05907603f, 0.09834211f, 0.09054223f, -0.02474258f, -0.03556859f, 0.23023230f, -0.16243163f, 
    0.00421750f, 0.15450256f, 0.09033132f, 0.06496301f, 0.00952122f, 0.01200985f, 0.02898312f, 0.04464664f, 
    -0.00165334f, 0.20615493f, 0.17866234f, 0.41548747f, 0.19909346f, 0.06946862f, -0.17393279f, 0.14253874f, 
    0.13899763f, 0.06937054f, 0.05505948f, 0.10921831f, -0.01183166f, 0.07335316f, -0.08111962f, -0.17991678f, 
    -0.02277760f, -0.12700406f, 0.08078802f, 0.12996304f, 0.11115630f, -0.04930136f, 0.22155079f, -0.11948217f, 
    -0.10875126f, -0.00072366f, -0.02535485f, -0.01331148f, 0.00581134f, 0.03818464f, -0.01077421f, -0.01399347f, 
    -0.00518386f, -0.03942242f, -0.07051775f, -0.07230220f, -0.00175584f, 0.20155185f, -0.04653873f, -0.06116064f, 
    0.02548199f, -0.02519172f, 0.04967032f, 0.12597524f, 0.12945145f, 0.12267218f, 0.05511488f, -0.00508867f, 
    -0.55321425f, -0.05681403f, 0.04306338f, -0.15572844f, -0.09092820f, -0.06965080f, 0.16568060f, -0.01889029f, 
    0.02172580f, -0.02443353f, 0.10891189f, 0.06486234f, 0.15211292f, 0.11902069f, -0.12039647f, 0.10799836f, 
    0.04157964f, 0.04444848f, 0.03641576f, -0.12174759f, 0.08641202f, 0.07264848f, -0.08951547f, -0.06335288f, 
    -0.20451625f, -0.16761585f, 0.07896183f, -0.00905138f, -0.13710546f, 0.19232529f, 0.03471324f, 0.02527383f, 
    0.10015487f, -0.07129024f, -0.03066908f, 0.09175191f, -0.40952328f, -0.16652989f, -0.16620053f, 0.34997743f, 
    0.22107582f, 0.26324573f, -0.02502369f, 0.00744065f, 0.08441804f, -0.00265606f, 0.10558818f, 0.04604999f, 
    -0.17363040f, -0.06151873f, -0.07526289f, -0.09321677f, 0.05388023f, -0.00693099f, -0.03613511f, 0.07061123f, 
    0.07159969f, 0.12509502f, -0.06743121f, 0.03246828f, 0.31367090f, 0.08416543f, -0.45366368f, 0.28244570f, 
    0.16857687f, 0.11851060f, 0.04763487f, 0.10579041f, -0.02949089f, -0.04321281f, 0.06310995f, -0.04523353f, 
    -0.20441428f, -0.04938807f, 0.17245069f, 0.22758263f, -0.17328854f, 0.15441905f, 0.06894486f, -0.01536799f, 
    0.02859274f, -0.05122871f, -0.17229633f, 0.02080301f, -0.20747958f, -0.28762802f, -0.14434092f, 0.37349823f, 
    -0.01574151f, -0.13096762f, 0.18180421f, 0.03945515f, 0.05468513f, 0.25347608f, 0.18848518f, 0.22398230f, 
    0.02448624f, 0.14153586f, 0.17620651f, 0.07580425f, 0.00458149f, -0.10586511f, -0.01375036f, -0.04753121f, 
    0.09628227f, 0.27656522f, 0.00922944f, 0.08658791f, -0.04788998f, -0.00047038f, 0.32932422f, 0.05117512f, 
    0.01134018f, -0.02351616f, 0.14446974f, -0.04308280f, 0.03632069f, 0.00328214f, 0.08577618f, -0.00944842f, 
    -0.40629095f, 0.15742165f, -0.05836704f, -0.03215832f, -0.14269538f, -0.04398018f, -0.09742431f, -0.11027011f, 
    -0.14383531f, 0.00666604f, -0.02976129f, -0.01049873f, -0.14625454f, -0.00458081f, 0.18308492f, 0.13081820f, 
    -0.03708839f, -0.13324115f, -0.07359567f, -0.02213179f, -0.08018552f, 0.07494232f, -0.02883753f, 0.01129580f, 
    -0.47418886f, -0.04462058f, 0.51478255f, 0.06383868f, 0.28812194f, 0.15978168f, 0.02493692f, -0.09733705f, 
    0.21576139f, 0.09236278f, 0.30917656f, -0.11491791f, 0.05306140f, 0.35581282f, 0.30307695f, -0.21074048f, 
    0.02694598f, -0.03568827f, -0.01758352f, 0.14604694f, -0.08816780f, -0.03784340f, 0.00700506f, 0.02053764f, 
    -0.02216963f, -0.07194067f, -0.19363283f, -0.00742015f, -0.17583868f, -0.11156984f, 0.01626932f, -0.18926591f, 
    0.15761329f, 0.19350524f, 0.13309576f, 0.17097886f, -0.06808060f, 0.05015583f, 0.14917611f, -0.18539558f, 
    -0.06317905f, 0.18499230f, -0.00093858f, -0.11512137f, 0.00398584f, -0.05643822f, -0.06726574f, -0.04081819f, 
    -0.12043745f, -0.21003133f, -0.07125206f, 0.03564424f, -0.19837010f, -0.15870894f, -0.06325183f, -0.35941780f, 
    0.01727876f, 0.00928504f, 0.14827286f, -0.08364819f, 0.38811305f, 0.13577493f, 0.18447094f, -0.13285759f, 
    0.03201929f, 0.02500500f, -0.03056432f, -0.02069901f, -0.01038939f, 0.08077709f, 0.18748069f, 0.15930267f, 
    -0.22472042f, 0.02421390f, -0.07919160f, -0.22757398f, 0.05799605f, -0.03314475f, -0.06566056f, 0.03850979f, 
    0.02570270f, -0.19883764f, -0.05992771f, 0.14148888f, -0.17662421f, -0.05261153f, 0.40275222f, -0.25146818f, 
    -0.00967941f, 0.09289802f, -0.08702260f, 0.20553409f, -0.02380853f, -0.10910971f, 0.02138068f, -0.09523018f, 
    -0.01022906f, 0.22990784f, 0.12470192f, -0.05128054f, -0.04711467f, 0.05031027f, 0.07242710f, -0.02920152f, 
    0.14369217f, 0.32167211f, 0.17759751f, 0.33758083f, -0.16357102f, -0.01891780f, -0.12027831f, -0.14295430f, 
    0.04126101f, 0.12400752f, 0.14006713f, -0.02422052f, -0.06220315f, -0.01932758f, -0.06037513f, -0.12898925f, 
    -0.25170982f, -0.08882906f, -0.19771449f, 0.16276294f, 0.04916737f, 0.03577016f, 0.25054604f, -0.08990123f, 
    0.10575631f, 0.02867537f, 0.06440265f, -0.03542601f, -0.12575564f, 0.41751444f, -0.26178944f, 0.21534249f, 
    0.00327753f, -0.01471937f, 0.14975463f, 0.31516290f, -0.14159673f, -0.03734506f, 0.01187745f, -0.10287344f, 
    0.11218979f, -0.25435576f, 0.15812682f, -0.19777547f, 0.11120270f, 0.05368477f, -0.12510353f, -0.01621744f, 
    -0.05953000f, 0.02354207f, -0.07809619f, 0.03796680f, 0.18410522f, -0.02616065f, 0.04278782f, 0.10046693f, 
    0.17072953f, -0.07884867f, -0.05390063f, 0.14858988f, 0.11646362f, 0.04477903f, 0.01930384f, -0.07100130f, 
    0.27440917f, -0.24814411f, -0.17176127f, -0.13788138f, 0.09551474f, -0.06870283f, -0.19985269f, -0.18259183f, 
    -0.10626165f, 0.01206936f, 0.02322146f, 0.09824731f, -0.18055727f, -0.06551895f, 0.15091158f, 0.08950839f, 
    0.04059570f, 0.12691088f, 0.21548527f, 0.29313740f, 0.10773360f, -0.02824671f, 0.16305754f, 0.11382544f, 
    -0.21988744f, 0.18614383f, 0.35394263f, 0.27604482f, 0.03598966f, 0.16455355f, -0.00211571f, -0.00757341f, 
    0.17571492f, 0.12022222f, 0.13603321f, 0.05246403f, 0.23943727f, -0.01965732f, 0.14300205f, -0.19699451f, 
    -0.00791627f, -0.06466927f, -0.08204094f, 0.03681951f, -0.03295923f, -0.17552429f, -0.19383535f, -0.30204564f, 
    -0.18743923f, 0.00626478f, -0.01245947f, -0.00595183f, -0.02803675f, -0.18987562f, -0.05360227f, 0.17137223f, 
    -0.07387142f, 0.14212546f, -0.03614265f, -0.24938481f, 0.02197774f, -0.20192796f, -0.10633893f, -0.24376336f, 
    -0.10409260f, 0.05300679f, -0.00412858f, 0.05536019f, -0.10889363f, 0.04750329f, 0.18679883f, -0.02901213f, 
    0.31277278f, 0.01202197f, 0.21119772f, 0.08369991f, 0.09198245f, 0.01718246f, -0.10047064f, 0.27134037f, 
    0.00429188f, 0.07875632f, -0.07784514f, -0.15447462f, -0.01228650f, 0.10013012f, 0.01728561f, 0.15726830f, 
    -0.02148280f, -0.09123990f, 0.08489212f, -0.06099109f, 0.09053368f, -0.18785264f, -0.15569268f, -0.19078261f, 
    -0.05877819f, -0.07826689f, -0.03110636f, -0.00898818f, 0.02354538f, -0.04742197f, 0.03419309f, 0.03373978f, 
    -0.04592632f, -0.00281530f, 0.00254617f, 0.02009835f, 0.02269032f, -0.00504922f, 0.02177216f, -0.02617293f, 
    -0.01780438f, -0.01074133f, -0.01870160f, -0.02216434f, 0.00586782f, -0.06194752f, 0.02843485f, -0.03525234f, 
    -0.02675216f, -0.04955701f, -0.04434407f, -0.01745986f, -0.04075333f, -0.03087997f, -0.02339328f, 0.04455829f, 
    0.03647044f, -0.05271625f, -0.07047261f, -0.04133347f, 0.06178813f, 0.04223090f, -0.04101958f, -0.01607759f, 
    0.03326654f, -0.06218739f, 0.04468714f, 0.01446106f, 0.03245464f, -0.04945701f, -0.01319379f, -0.02566569f, 
    0.04601023f, 0.05093691f, -0.05915482f, 0.03048109f, 0.03482981f, 0.02652072f, 0.01913859f, -0.05617043f, 
    -0.07097236f, -0.00092490f, 0.02422957f, 0.02168548f, -0.00309750f, -0.02759229f, 0.01845296f, -0.05695247f, 
    -0.03423822f, -0.04443633f, -0.04427144f, 0.03237957f, -0.04361982f, -0.06596885f, -0.07051452f, 0.05135189f, 
    -0.02942290f, -0.04280272f, -0.05506711f, 0.01718532f, -0.05967460f, 0.06019934f, -0.00885974f, 0.01786035f, 
    0.03302994f, 0.02344582f, -0.04073222f, -0.03519708f, -0.03193572f, -0.06849750f, 0.00054165f, 0.04529338f, 
    -0.07057028f, 0.03137212f, 0.01163703f, -0.02545448f, 0.05106426f, -0.03178823f, -0.01102344f, -0.05228285f, 
    -0.03502817f, 0.03848387f, -0.03744284f, 0.02342594f, 0.02134985f, 0.05250512f, -0.03084732f, -0.06407031f, 
    -0.01661313f, -0.07781337f, 0.04740169f, 0.00261129f, 0.04630475f, 0.00595873f, -0.00618205f, -0.05136907f, 
    -0.00330151f, 0.02186165f, -0.04314239f, -0.06561223f, 0.04675744f, -0.08038016f, 0.01071245f, -0.03904770f, 
    -0.05440887f, 0.04965048f, 0.02494067f, -0.03419195f, 0.04783893f, 0.02450773f, -0.05951722f, -0.07797378f, 
    -0.05796586f, -0.07523169f, 0.02424923f, -0.01047156f, 0.01546117f, 0.03504404f, 0.01759272f, 0.00432879f, 
    0.00766065f, -0.00619341f, -0.01779291f, 0.01474966f, 0.00167622f, 0.02183068f, 0.01750100f, -0.07792483f, 
    -0.02153539f, -0.02278402f, -0.06429423f, -0.05798625f, 0.01847153f, -0.06360763f, -0.06470154f, 0.01106984f, 
    -0.05550496f, -0.03761037f, 0.05676279f, 0.01632292f, -0.06232278f, -0.02205796f, 0.03133160f, 0.04313782f, 
    0.04125309f, 0.03296555f, 0.03569570f, -0.03493604f, 0.05209243f, 0.00909860f, -0.07937207f, 0.02538278f, 
    -0.07019170f, -0.03463718f, -0.06276709f, 0.03269466f, -0.05008755f, -0.02611849f, -0.03820135f, 0.00824097f, 
    0.06115745f, -0.06843607f, -0.00600320f, -0.06725499f, 0.03843460f, 0.04029278f, 0.05104842f, -0.02853838f, 
    -0.06700900f, -0.03213622f, -0.07374916f, 0.06268778f, -0.02973338f, -0.02442869f, -0.00998433f, 0.00880681f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.06358304f, -0.06089745f, 0.03823740f, -0.01360433f, 0.15285118f, -0.16151026f, 0.11054896f, -0.09214695f, 
    0.00016968f, -0.03555815f, 0.15659784f, -0.04579125f, 0.11583290f, -0.05869928f, 0.18934758f, 0.00239115f, 
    0.10127506f, 0.28133827f, 0.04306076f, 0.18618833f, 0.07484684f, 0.16070199f, -0.03677071f, 0.11784931f, 
    0.17979294f, -0.12828472f, -0.07303928f, 0.03703985f, 0.05651638f, 0.26274881f, -0.00573169f, 0.14019910f, 
    -0.15728477f, 0.04343625f, 0.07770689f, -0.03876980f, 0.20386837f, 0.02946755f, -0.04158879f, -0.09136747f, 
    -0.30807912f, -0.03217153f, 0.02500269f, -0.01035429f, 0.14297111f, 0.03560918f, -0.08974183f, -0.02113201f, 
    0.10286118f, -0.08575770f, 0.30719668f, 0.03005959f, 0.22715831f, 0.03622444f, 0.28547013f, 0.02573818f, 
    0.10107517f, 0.17016912f, -0.05839831f, 0.04307501f, 0.22653659f, 0.19040966f, 0.19397888f, -0.03105860f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.50006014f, -0.04004856f, 0.17826520f, -0.05723601f, 0.00741096f, -0.14566004f, 0.22131908f, 0.13809812f, 
    0.04719258f, -0.12075602f, -0.08378945f, -0.10061579f, 0.27878842f, -0.16199201f, -0.27852961f, -0.49657783f, 
    0.13106701f, -0.13744625f, 0.01600902f, 0.15704338f, 0.26324424f, -0.11381783f, 0.02214069f, -0.15125464f, 
    0.10742372f, 0.15534371f, -0.23860306f, -0.28073618f, 0.10943750f, -0.02658984f, 0.06984394f, -0.02737060f, 
    0.23307963f, -0.00834912f, -0.11061235f, 0.08608412f, -0.13539426f, -0.05049758f, 0.09090186f, 0.26975143f, 
    0.27128658f, -0.12338786f, 0.10429414f, 0.01567934f, -0.07764784f, -0.12963365f, 0.25858152f, -0.38273776f, 
    0.24322265f, -0.05891066f, -0.43325931f, 0.01485685f, -0.55573970f, -0.02537098f, 0.05915301f, -0.45138887f, 
    -0.32880640f, -0.07745764f, 0.15315831f, -0.12527703f, -0.36639583f, -0.67402887f, -0.26236767f, 0.08933188f, 
    -0.60369700f, -0.00567878f, 0.22206174f, -0.05159571f, 0.37232435f, -0.58818054f, 0.28356060f, 0.11940136f, 
    -0.06675921f, 0.07238932f, -0.07046819f, 0.01819248f, 0.08308350f, 0.00307250f, 0.07085323f, 0.05105296f, 
    -0.08620064f, 0.24143165f, -0.03753255f, -0.07950858f, 0.15278295f, -0.08123308f, -0.10306004f, 0.25357500f, 
    0.23545815f, -0.10293278f, -0.11852658f, -0.70265532f, -0.05885220f, -0.04123727f, 0.00869431f, -0.12308237f, 
    -0.25745970f, 0.16066575f, 0.02227613f, -0.07208627f, 0.12624013f, 0.18045542f, -0.03014953f, 0.10333780f, 
    -0.46103647f, 0.13967261f, 0.26165679f, -0.00272585f, 0.07626002f, -0.07036913f, -0.76151663f, 0.23814507f, 
    0.17793994f, -0.52005798f, 0.50905877f, -0.08707037f, 0.01879384f, 0.04825908f, 0.15695222f, -0.07640496f, 
    -0.02676720f, -0.19166441f, -0.02421485f, 0.01307961f, -0.14035487f, 0.08753185f, 0.33501256f, 0.00707137f, 
    -0.36234656f, -0.04508749f, -0.30967513f, 0.03154070f, -0.69357806f, 0.13434188f, 0.11954229f, 0.03076036f, 
    -0.01354502f, -0.04674781f, 0.11872634f, 0.00957690f, 0.07458477f, -0.13339345f, 0.13622013f, -0.15274395f, 
    -0.19492225f, 0.23586598f, -0.01567805f, 0.19020204f, -0.28876939f, 0.02332309f, -0.12400115f, 0.10162424f, 
    0.12253861f, -0.12277040f, 0.03579593f, 0.10046656f, 0.09193987f, -0.14755662f, 0.05269352f, -0.31841922f, 
    -0.31158060f, 0.28619400f, 0.05036793f, -0.02067268f, -0.05306948f, -0.09103033f, -0.52051646f, -0.24812701f, 
    -0.39943835f, -0.03248153f, 0.50856280f, -0.06901310f, -0.07024108f, 0.01199136f, -0.46950322f, 0.08666727f, 
    -0.15318131f, 0.32140625f, -0.67796743f, 0.04313826f, 0.18085672f, -0.08872243f, 0.01962108f, -0.11113889f, 
    0.25675350f, 0.40406105f, 0.15593967f, -0.10708779f, 0.02727130f, -0.04333472f, -0.22577840f, -0.05198203f, 
    0.05556526f, -0.03099164f, 0.04489752f, -0.09892073f, -0.22685862f, 0.47005710f, 0.16111912f, 0.02923456f, 
    0.00633597f, -0.07959379f, -0.52137309f, -0.07121082f, 0.16534005f, 0.04899771f, 0.06412233f, 0.32754633f, 
    0.00333598f, -0.72059280f, 0.10388622f, -0.12150677f, -0.41511497f, -0.19846039f, 0.08516327f, -0.07547275f, 
    -0.07524244f, 0.34925729f, -0.09829250f, 0.11042093f, -0.00769746f, -0.25467795f, 0.06148801f, 0.05943647f, 
    0.09999622f, 0.26632634f, 0.30694395f, -0.39508533f, -0.38654435f, -0.39891294f, 0.13174300f, -0.10053773f, 
    0.31280106f, 0.02536622f, 0.29947844f, 0.01424738f, -0.14931551f, 0.04206932f, -0.12293769f, 0.44949457f, 
    0.03582468f, 0.10735269f, -0.37353346f, -0.49712500f, 0.21710260f, 0.01367823f, -0.58848494f, 0.06142698f, 
    0.05043787f, 0.00034866f, -0.17299004f, -0.03850884f, -0.31418055f, -0.07490186f, 0.07866611f, -0.09746390f, 
    0.14716606f, 0.10664308f, -0.00991244f, -0.13279121f, -0.44475970f, -0.05368480f, -0.03666308f, 0.17647801f, 
    -0.05346896f, 0.07720972f, 0.09436502f, -0.07909828f, -0.19128382f, -0.05848844f, -0.00718428f, -0.24571140f, 
    -0.01067149f, -0.23193525f, 0.01308716f, 0.11435827f, -0.06856612f, -0.53121310f, 0.00071851f, 0.12241762f, 
    -0.11074043f, 0.08642810f, 0.18208733f, 0.15263350f, 0.08615687f, -0.56686175f, -0.11974554f, -0.08663630f, 
    0.12631792f, -0.03823834f, -0.67581421f, -0.22025511f, -0.35204083f, 0.11503216f, 0.06563089f, -0.02540421f, 
    0.16481705f, 0.13834019f, -0.12911057f, -0.05405146f, 0.17383133f, -0.01876012f, 0.33334440f, -0.18551159f, 
    -0.06143254f, 0.26527777f, 0.17564705f, 0.14276968f, 0.00120461f, -0.11903390f, 0.04733529f, 0.26605844f, 
    -0.29952842f, -0.72700310f, 0.24481137f, 0.02719654f, 0.00403347f, -0.00839485f, -0.32447851f, -0.10438930f, 
    0.27398604f, -0.06232451f, 0.17325102f, 0.10860074f, -0.46515518f, -0.17470780f, 0.03382009f, 0.04212695f, 
    -0.00785824f, -0.09507757f, -0.23269853f, -0.02757930f, 0.17328449f, -0.03925958f, 0.04874749f, -0.40830439f, 
    0.19839670f, 0.04594978f, -0.10809489f, 0.20569846f, 0.32594225f, -0.03615997f, 0.09037694f, -0.14385416f, 
    -0.13462128f, -0.23313367f, -0.06996407f, 0.25813442f, -0.09494817f, 0.46694371f, 0.09928109f, 0.22257845f, 
    -0.06055302f, 0.03044899f, -0.29229090f, -0.21939160f, 0.23926513f, 0.25929034f, 0.24319918f, -0.24845932f, 
    -0.23391123f, -0.21484093f, 0.01027755f, -0.08747815f, 0.13486952f, 0.08309378f, -0.08057432f, -0.14930592f, 
    -0.04430584f, -0.42771345f, -0.39203110f, 0.08176208f, 0.10685831f, 0.08488580f, 0.24525253f, -0.18444186f, 
    -0.33774206f, -0.64346832f, -0.08982338f, 0.02221561f, 0.19044586f, -0.15930691f, 0.01446162f, 0.02964426f, 
    0.14265536f, -0.06166890f, -0.69231898f, 0.03129757f, 0.18281633f, -0.39676371f, 0.04101451f, -0.19099198f, 
    -0.05570193f, 0.01088672f, 0.38187534f, 0.09958611f, 0.00018113f, -0.01728243f, 0.20679659f, -0.12542282f, 
    -0.72932416f, 0.08049911f, 0.10258122f, -0.18367709f, -0.29399875f, 0.20127003f, 0.06786629f, -0.01456611f, 
    0.06641409f, -0.26527870f, 0.05378927f, 0.26164511f, 0.12580605f, -0.42596850f, -0.04019938f, -0.21067525f, 
    -0.58738166f, -0.07740206f, 0.12251612f, 0.07843038f, -0.10324586f, -0.12554692f, -0.05843784f, -0.13121864f, 
    -0.01047062f, -0.15384798f, -0.05757772f, 0.06426850f, -0.54808915f, -0.09616984f, 0.33084428f, -0.33332995f, 
    -0.81694633f, -0.07414792f, 0.23778574f, 0.01269039f, 0.26810169f, 0.10264245f, 0.17864846f, -0.04164267f, 
    -0.00048724f, 0.21888684f, -0.91211033f, -0.01354164f, 0.17555414f, 0.26291686f, -0.54308540f, 0.09886585f, 
    0.26050302f, -0.06584113f, -0.39837939f, -0.00232296f, 0.14624403f, 0.36642858f, -0.77197915f, -0.32785445f, 
    -0.11536960f, -0.00122706f, -0.27543485f, 0.02955518f, -0.36912656f, -0.04021309f, 0.01727205f, 0.26011822f, 
    -0.28004971f, 0.18106644f, 0.09735112f, -0.66644526f, -0.02998796f, -0.06021005f, -0.03869796f, -0.28694931f, 
    -0.34425193f, 0.09415816f, 0.20017254f, -0.11156171f, 0.01200803f, 0.07673178f, -0.06906073f, -0.17501268f, 
    0.03223661f, -0.28395686f, -0.31085393f, 0.00836107f, 0.33346787f, 0.12845881f, -0.09481670f, 0.25750715f, 
    0.20023236f, 0.02392541f, -0.60397518f, -0.02421532f, 0.19610882f, -0.07815389f, -0.40940049f, 0.21276857f, 
    -0.13843165f, 0.36993241f, 0.14827903f, 0.16573504f, 0.07845432f, 0.10670498f, -0.09923825f, 0.09537464f, 
    -0.19858646f, -0.36075413f, 0.45316461f, -0.03780285f, 0.16447969f, -0.25769755f, 0.14712349f, 0.07856739f, 
    0.14823525f, -0.04096249f, -0.70857781f, -0.02627184f, -0.33541533f, 0.44634879f, -0.62618685f, -0.04178854f, 
    -0.03526464f, -0.04639056f, -0.18016000f, 0.00642717f, 0.04233930f, -0.06738033f, -0.10935663f, 0.35579345f, 
    0.39873824f, 0.12285841f, 0.08570700f, -0.20157884f, 0.15000705f, 0.14485894f, -0.03872759f, -0.55570745f, 
    0.06398828f, 0.28845495f, -0.46199065f, -0.55458724f, 0.00764414f, 0.34208167f, 0.08798040f, 0.19828838f, 
    0.08046314f, -0.08216481f, 0.26318863f, -0.15856546f, 0.22880006f, -0.30119082f, 0.06559198f, -0.16467640f, 
    -0.19261378f, -0.36758339f, -0.37976915f, -0.00914990f, -0.25975311f, 0.02714330f, 0.00224424f, -0.10038020f, 
    0.42753500f, -0.41754267f, 0.12830518f, -0.17695093f, 0.08512450f, -0.05289052f, 0.20893867f, -0.23688747f, 
    0.27626458f, -0.02986476f, -0.47659519f, -0.11612804f, -0.20827216f, -0.14426656f, -0.08380733f, -0.05456832f, 
    -0.03664450f, 0.07218841f, 0.12605281f, 0.04365317f, 0.17799363f, 0.09882782f, -0.27282500f, 0.02771982f, 
    0.10480364f, -0.02223397f, 0.17944366f, 0.08010952f, -0.24529181f, 0.05776860f, 0.24878092f, -0.28946468f, 
    -0.40313014f, 0.28962815f, -0.03490911f, 0.23855199f, 0.03999450f, 0.11216414f, -0.03200853f, -0.05345202f, 
    -0.69822174f, -0.23551404f, 0.09883866f, 0.21142949f, -0.08949856f, 0.07557943f, 0.07626993f, -0.73046243f, 
    0.27676171f, -0.50095975f, -0.13884549f, 0.25905368f, 0.09897490f, 0.09070064f, 0.01811981f, 0.23943427f, 
    -0.22083896f, -0.28110683f, -0.45982406f, 0.08658703f, -0.01947085f, 0.10448942f, 0.47080079f, -0.58361739f, 
    -0.13086726f, 0.12454753f, -0.10862138f, -0.20934662f, -0.13707894f, 0.02400518f, -0.77288371f, -0.25984696f, 
    -0.33581516f, -0.02452297f, 0.35341889f, -0.11541231f, 0.12470610f, 0.14347146f, 0.30344376f, -0.11440632f, 
    0.06098326f, -0.00380271f, -0.22321002f, -0.00224392f, 0.19879742f, -0.00289692f, 0.17487423f, 0.14720067f, 
    0.03093699f, 0.09199708f, 0.26511279f, -0.11214584f, 0.20030788f, -0.11893523f, -0.53252667f, 0.18559393f, 
    -0.19602188f, 0.17656231f, -0.08413364f, 0.15832022f, -0.96891129f, 0.03679669f, -0.11564147f, 0.24830976f, 
    0.28294513f, -0.22112866f, -0.18593039f, -0.01936474f, 0.08173499f, 0.41301188f, 0.11128395f, 0.46211529f, 
    0.12495692f, -0.19926146f, -0.42448601f, -0.41619977f, -0.01580696f, -0.72623014f, 0.09738640f, -0.57690895f, 
    0.24664870f, 0.23543170f, -0.42978546f, 0.04092170f, -0.14012901f, -0.04059144f, -0.24234380f, 0.09004872f, 
    0.07677728f, -0.60968107f, -0.43267304f, -0.32760793f, -0.18262710f, -0.06094120f, -0.14043383f, 0.12801841f, 
    0.30160508f, -0.57391912f, -0.61273813f, -0.10684035f, 0.19712718f, -0.05338780f, 0.44102082f, -0.08032679f, 
    0.17510071f, -0.13095178f, 0.43508103f, -0.08118510f, -0.21007687f, -0.05359614f, 0.05054863f, -0.30175355f, 
    -0.07402632f, -0.02835668f, -0.07814338f, 0.02007027f, -0.26541650f, -0.02115363f, 0.11629299f, 0.09721449f, 
    0.13195431f, -0.80046588f, -0.06905400f, -0.44557199f, 0.14715216f, 0.11184029f, -0.11014783f, 0.30601090f, 
    0.42166227f, -0.28369230f, -0.06315276f, -0.02961085f, -0.03415096f, 0.16492388f, -0.12188904f, 0.21663043f, 
    0.21353954f, -0.39920193f, 0.45717457f, 0.57195908f, -0.28041640f, -0.00617623f, -0.55620176f, -0.27051598f, 
    -0.33056325f, -0.02426257f, -0.22818623f, -0.11113410f, -0.44917169f, -0.12295311f, -0.31812984f, 0.10712982f, 
    -0.04957394f, -0.14908904f, -0.38364002f, -0.26524797f, -0.14678861f, 0.09524919f, -0.15784721f, 0.47251245f, 
    -0.01805642f, 0.46816978f, -0.33742243f, -0.10358839f, 0.02700069f, 0.35735297f, -0.48437789f, -0.02212996f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.16213320f, 0.04616688f, -0.01142740f, -0.04690795f, 0.03193308f, 0.03318127f, -0.03683306f, 0.01567144f, 
    0.12869932f, -0.07901787f, 0.16298635f, 0.08106191f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
