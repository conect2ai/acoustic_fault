#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.30689254f, -0.83276254f, 0.72769064f, 0.69985098f, -0.53719002f, 0.27313665f, -0.35185763f, -0.73891628f, 
    -0.30475697f, 0.54704297f, -0.16283354f, 0.27244297f, 0.84226185f, 0.10683610f, -0.75384182f, 0.14352311f, 
    -0.32464066f, 0.45845145f, 0.40033036f, -0.53924066f, 0.00312930f, -0.46220341f, -0.42126781f, -0.41367278f, 
    -0.60493857f, 0.33027533f, 0.43354091f, 0.49152535f, 0.33150128f, -0.72239876f, -0.74344021f, -0.13001399f, 
    -0.73903424f, 0.38830563f, 0.37300479f, 0.05778602f, -0.34392148f, -0.68323296f, -0.51600921f, -0.55003524f, 
    -0.28593883f, -0.18071468f, -0.41902667f, -0.04901988f, -0.19071285f, 0.34765810f, -0.60588151f, 0.41960466f, 
    -0.45014983f, -0.56989110f, -0.63368130f, -0.16963650f, -0.19838649f, -0.29907683f, -0.60277659f, -0.04985678f, 
    -0.10933013f, -0.01554533f, 0.74913406f, -0.49637213f, -0.25593373f, 0.18084748f, 0.08194962f, -0.57485694f, 
    -0.40755582f, -0.77996820f, 0.53954881f, -0.05608224f, 0.19073765f, -0.52359718f, -0.15151209f, -0.24043199f, 
    0.08811042f, -0.50328344f, -0.59873766f, 0.08093755f, -0.43628037f, -0.55136949f, -0.30827323f, -0.22383767f, 
    0.00647425f, 0.57934970f, 0.44185531f, 0.50518709f, 0.47795576f, 0.33832213f, 0.02525529f, 0.20173596f, 
    0.55907840f, -0.00203460f, 0.44931206f, 0.09444933f, -0.28108001f, 0.33906856f, 0.44652799f, 0.32670334f, 
    -0.66004926f, 0.13266738f, 0.61006296f, -0.13630106f, -0.67972106f, -0.67264557f, -0.34057227f, -0.87649900f, 
    0.41441095f, 0.25004244f, 0.01384583f, 0.42946166f, 0.09307551f, 0.30712166f, -0.41279438f, 0.09989056f, 
    0.13095725f, -0.64742213f, 0.19589412f, -0.13852532f, 0.58749557f, 0.60545486f, 0.73499340f, 0.63994730f, 
    -0.70788753f, 0.45802256f, -0.21716610f, 0.16797490f, -0.01822203f, -0.06407582f, -0.70332152f, -0.65735966f, 
    -0.67911935f, -0.07750435f, -0.16084240f, -0.18145627f, 0.41086879f, 0.15436545f, -0.15287626f, -0.49133423f, 
    -0.26198140f, 0.20171817f, 0.52527153f, 0.70759213f, -0.41023692f, 0.00481001f, -0.06464482f, -0.41569036f, 
    -0.24554548f, 0.74066389f, 0.00015630f, 0.55618840f, 0.29628232f, -0.60005695f, 0.23653387f, 0.56117845f, 
    0.11131393f, -0.69393313f, -0.02076080f, -0.36093664f, 0.04869919f, 0.64724231f, 0.65819693f, 0.35767296f, 
    0.08452838f, 0.59188980f, 0.17180559f, 0.60778594f, -0.79849875f, -0.06521521f, -0.25184831f, 0.40369090f, 
    -0.37806377f, -0.21702783f, -0.47606868f, -0.40484074f, 0.47845590f, 0.10434838f, -0.61644328f, -0.43116900f, 
    -0.25755173f, -0.66821194f, 0.22826281f, 0.08751328f, 0.61486673f, -0.26023963f, -0.60618943f, -0.70486110f, 
    0.54257029f, -0.35553223f, -0.31614777f, -0.23463933f, 0.11118093f, -0.27957892f, -0.33878115f, -0.68820995f, 
    0.15379339f, 0.75946134f, 0.67431873f, 0.29784697f, -0.48752952f, -0.01683181f, 0.43556470f, 0.42827398f, 
    0.61317980f, 0.23089072f, 0.09401652f, -0.28980622f, 0.09447838f, -0.14495283f, 0.05592303f, -0.62922198f, 
    0.58714104f, -0.53495270f, 0.66227704f, -0.39269415f, -0.63722527f, -0.04045714f, 0.14132497f, -0.40730092f, 
    -0.90723985f, -0.05224478f, 0.15788795f, 0.50143921f, 0.22746547f, 0.39121991f, -0.01932593f, 0.18968955f, 
    0.28405803f, -0.73609394f, -0.44283828f, -0.40803751f, 0.41769341f, 0.05395481f, -0.35120532f, 0.34042102f, 
    -0.15263449f, 0.47131905f, 0.64426208f, 0.27159229f, 0.15931484f, -0.05902814f, -0.58414304f, -0.39367610f, 
    0.39921910f, -0.24683602f, 0.35733634f, 0.53637022f, 0.48687947f, 0.53916371f, 0.28919205f, -0.51475847f, 
    0.41782588f, -0.32565641f, 0.38402545f, -0.26098713f, -0.64872497f, 0.20390069f, -0.28637394f, -0.22124836f, 
    0.69291645f, -0.28444633f, 0.32541257f, 0.07195704f, -0.30722529f, 0.18723410f, 0.17332673f, 0.33267501f, 
    -0.79611057f, -0.71222800f, -0.22878450f, 0.00901208f, 0.46868232f, -0.51051605f, 0.45635438f, 0.41774076f, 
    0.36737096f, 0.23226190f, -0.72312337f, 0.27549642f, 0.50906676f, -0.04151428f, 0.04721133f, 0.48848680f, 
    0.39813992f, 0.54068273f, -0.16247761f, -0.21138753f, 0.53367037f, -0.35802132f, -0.03298179f, 0.32600215f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.01466465f, -0.26085451f, 0.16557288f, 0.08086709f, -0.10792964f, -0.22084577f, -0.16046308f, -0.13562508f, 
    0.03484144f, 0.06071827f, 0.16635661f, -0.22282958f, -0.00783736f, -0.09125654f, 0.09354420f, -0.11235121f, 
    -0.32228285f, -0.02738376f, -0.13302264f, 0.28857225f, -0.05522729f, -0.31109196f, 0.27091920f, -0.13747199f, 
    0.00599757f, 0.04162130f, -0.29049763f, 0.13004264f, -0.05380253f, 0.10821198f, -0.21560064f, 0.11279467f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.04132920f, -0.01754768f, 0.01280419f, 0.00672711f, -0.02183283f, 0.03687758f, 0.02970670f, 0.04897410f, 
    -0.05193435f, 0.04570986f, -0.01745676f, -0.04617016f, -0.06331326f, -0.02843519f, -0.05812325f, -0.05551206f, 
    -0.00696293f, 0.01010259f, -0.02871135f, 0.02268039f, 0.05688158f, 0.04572717f, -0.01962148f, -0.03122916f, 
    -0.05050733f, -0.03498962f, -0.02338617f, 0.01442876f, 0.00216324f, 0.02624196f, -0.04079027f, 0.01795943f, 
    -0.00855648f, -0.00021262f, 0.04897056f, 0.01254143f, -0.03560687f, -0.05151835f, -0.02378343f, -0.03374280f, 
    -0.03775061f, 0.01765357f, 0.02910469f, -0.02267119f, -0.01026285f, -0.01633622f, 0.04344551f, 0.01175930f, 
    0.04479009f, 0.00786275f, -0.01400809f, 0.03162620f, -0.06364699f, 0.01834919f, -0.06036552f, -0.01344257f, 
    -0.01249553f, 0.04729915f, -0.07278287f, -0.00124644f, 0.02595907f, -0.00033846f, -0.04306784f, 0.04534622f, 
    -0.00272995f, -0.06086393f, 0.00680827f, -0.00627620f, -0.05585320f, -0.01467373f, 0.00526196f, -0.05084489f, 
    -0.02961122f, 0.00995585f, -0.01012043f, 0.05297807f, -0.05294979f, -0.06628879f, -0.00381620f, 0.05067063f, 
    -0.01152122f, -0.03238484f, -0.00174916f, 0.02368626f, -0.02003497f, 0.04516016f, -0.04885698f, -0.02042508f, 
    -0.04961361f, -0.01067330f, 0.03723687f, 0.01129005f, 0.00283914f, 0.03581844f, 0.01709352f, -0.00390207f, 
    0.04432719f, 0.03535341f, -0.04346167f, -0.02022934f, 0.03031381f, 0.02257447f, 0.04538965f, -0.05217358f, 
    -0.05043243f, 0.00654839f, -0.02675522f, 0.02250561f, -0.01257353f, 0.01102551f, -0.05400439f, 0.00357198f, 
    0.01126162f, -0.03672729f, -0.03124680f, 0.03799269f, -0.00691695f, -0.05399818f, -0.03767891f, -0.03786691f, 
    -0.06339470f, 0.02287275f, -0.04084701f, -0.05546278f, -0.02331894f, -0.02103163f, 0.00972161f, -0.04721232f, 
    0.00888854f, -0.01222725f, -0.03454381f, 0.01314313f, -0.04934916f, 0.01555498f, -0.01217287f, 0.05338117f, 
    0.04091504f, 0.04186535f, 0.04231781f, -0.02471055f, -0.02741303f, -0.00453432f, -0.03200178f, -0.04045543f, 
    -0.03977500f, -0.02345063f, 0.01889742f, -0.01164941f, -0.03056967f, -0.01949032f, -0.01354249f, 0.04175043f, 
    -0.03302557f, 0.00468846f, -0.02879673f, -0.05187176f, -0.04141323f, 0.04761674f, -0.00196968f, -0.04104666f, 
    -0.01211427f, -0.02182397f, -0.03509840f, -0.05476750f, 0.04670442f, -0.04565331f, -0.05813606f, -0.06365182f, 
    0.01094240f, -0.06259713f, -0.05041228f, -0.02829349f, -0.02765190f, 0.00447807f, -0.00801104f, 0.01696857f, 
    0.00440211f, -0.00124374f, 0.03039868f, -0.00039596f, 0.01148809f, -0.03005749f, 0.00106543f, 0.01279154f, 
    0.04592704f, -0.05724018f, 0.03342567f, 0.04031366f, -0.06279692f, -0.03406898f, -0.00514052f, -0.06707820f, 
    0.02667736f, -0.05330677f, -0.04752018f, -0.03091470f, 0.01932094f, 0.01785039f, 0.04423452f, -0.06382915f, 
    -0.02321397f, -0.00881632f, 0.00087126f, -0.06135589f, -0.04136897f, -0.05106759f, -0.00052301f, 0.00673258f, 
    -0.01996711f, 0.02832738f, -0.04572643f, -0.02443710f, -0.06745635f, -0.04256440f, -0.01852989f, -0.04769055f, 
    -0.04872530f, -0.03068520f, 0.02654381f, -0.02484962f, 0.01619441f, -0.01150105f, 0.04773036f, -0.04867063f, 
    0.03172088f, -0.04153393f, 0.02715031f, -0.06115098f, 0.05321052f, 0.04472256f, 0.02172837f, 0.03312167f, 
    -0.04013817f, 0.00771644f, 0.04027784f, 0.01797279f, -0.05713714f, -0.01747756f, 0.02047736f, 0.02072684f, 
    0.02823330f, -0.03834954f, 0.03060876f, -0.05345086f, 0.04657570f, 0.00441785f, -0.02858478f, 0.01936866f, 
    0.01533564f, 0.00172198f, 0.03005936f, 0.00013087f, 0.02198041f, 0.03669285f, 0.02156584f, 0.05017911f, 
    0.04753547f, 0.02498530f, 0.01365756f, -0.02163882f, -0.01611950f, 0.01862538f, -0.04409843f, 0.01020096f, 
    0.00302057f, 0.03915571f, 0.00005099f, 0.02160243f, -0.04003736f, 0.02853146f, -0.01318171f, 0.04475855f, 
    0.00206719f, 0.00975359f, 0.01489652f, -0.05475772f, -0.00495626f, -0.00767525f, 0.01653292f, 0.04427708f, 
    -0.05911518f, -0.02982475f, -0.02846043f, -0.05144924f, 0.02563997f, -0.03900431f, 0.03555257f, -0.00233988f, 
    -0.02283138f, -0.01706339f, -0.06348293f, 0.00682158f, 0.04655252f, -0.04126529f, 0.00796759f, 0.02635098f, 
    -0.03976011f, 0.01227206f, 0.03032294f, -0.04005780f, 0.02597286f, 0.00554176f, -0.03385149f, -0.02177026f, 
    0.02238657f, -0.02246279f, -0.01122507f, 0.04519339f, 0.03174435f, 0.01773529f, -0.02020624f, -0.05061945f, 
    0.03725661f, -0.01814982f, 0.04713911f, -0.04224927f, 0.00643110f, 0.01399927f, 0.00551481f, 0.03848552f, 
    -0.01712385f, -0.01750592f, 0.02224993f, 0.02192320f, 0.04732869f, -0.01744612f, 0.00648948f, 0.04428621f, 
    -0.00043595f, 0.00957639f, 0.01537364f, -0.04470230f, -0.01364989f, -0.06869088f, 0.00978715f, 0.03079249f, 
    0.02623104f, 0.04609424f, -0.00798054f, -0.02011058f, 0.04009872f, 0.04849484f, -0.06359167f, -0.01637013f, 
    -0.06807151f, 0.00543466f, 0.01376770f, 0.04819643f, -0.05628844f, 0.04805729f, -0.02652326f, 0.03236358f, 
    -0.01414608f, -0.06887782f, -0.03927869f, -0.03676919f, -0.00104130f, -0.05780507f, -0.00273521f, -0.05574532f, 
    -0.04829508f, -0.04701320f, -0.01999400f, -0.02936317f, -0.04813279f, 0.02050669f, -0.00636838f, 0.00707239f, 
    -0.06079560f, -0.03855794f, -0.06062939f, -0.06201307f, -0.03119823f, -0.04001994f, -0.03776835f, -0.00991569f, 
    0.00959213f, -0.00182060f, -0.01139695f, -0.01167629f, -0.03528899f, -0.05785429f, 0.00661458f, -0.04913726f, 
    -0.05463069f, -0.02718621f, -0.05911343f, -0.00057683f, -0.04742302f, -0.04476616f, 0.04629336f, -0.05848569f, 
    0.00969943f, 0.03966293f, -0.06010067f, 0.01861477f, 0.04024708f, 0.02468567f, -0.02130145f, 0.04886644f, 
    0.03696993f, -0.03287719f, -0.05276196f, 0.04557801f, 0.01512590f, -0.00409141f, 0.00965041f, 0.04997054f, 
    -0.05162622f, 0.00287407f, -0.03912016f, -0.04751900f, 0.00338359f, -0.05143971f, 0.03535379f, 0.02116277f, 
    0.03804171f, 0.01741221f, -0.04790800f, -0.00460164f, -0.02568952f, -0.05737653f, 0.02110844f, -0.01410197f, 
    0.02120506f, 0.04417856f, -0.01593513f, 0.00055771f, -0.02003086f, 0.01412892f, 0.02888035f, -0.05783085f, 
    0.02814749f, -0.00795106f, -0.00941825f, 0.02838917f, 0.00172919f, -0.01119302f, -0.00076590f, -0.01512384f, 
    -0.03151620f, -0.06390193f, 0.00700093f, 0.01020624f, 0.00146168f, 0.00025050f, 0.02438518f, 0.03595986f, 
    0.02159447f, -0.01318017f, -0.01700490f, -0.00782059f, 0.03052347f, 0.03312223f, 0.00316357f, 0.00574500f, 
    0.03070542f, 0.02882675f, 0.01376765f, 0.02966976f, -0.05555527f, -0.00632913f, 0.03833355f, -0.00436591f, 
    0.01007243f, 0.00427601f, 0.00790895f, -0.03536088f, 0.00920646f, -0.04007825f, -0.03468427f, 0.04248753f, 
    0.03479485f, 0.04157339f, 0.02196570f, 0.04504263f, -0.02801988f, 0.04364721f, -0.05967848f, -0.05500302f, 
    0.02462404f, 0.03116748f, -0.05182404f, 0.00926331f, 0.04779116f, 0.00538229f, -0.06368144f, -0.06291237f, 
    0.01784557f, 0.01516667f, 0.01086678f, -0.02846884f, -0.04907051f, -0.00358998f, 0.03691791f, 0.01835236f, 
    -0.00583956f, -0.00488178f, 0.00874241f, -0.02002978f, -0.04074813f, -0.00189320f, -0.06096201f, 0.05027539f, 
    -0.03211571f, 0.02785032f, 0.02811710f, -0.05445610f, -0.06065145f, 0.01959004f, -0.03231876f, -0.01822624f, 
    0.03446924f, -0.06347124f, -0.06154651f, -0.02620429f, 0.00767840f, 0.01633643f, -0.03233622f, -0.04549514f, 
    -0.05400011f, -0.01989228f, 0.03389242f, -0.00787446f, -0.03876991f, -0.00555374f, 0.02948935f, -0.03610543f, 
    -0.05063630f, -0.02246275f, 0.03471479f, 0.04922904f, -0.04559740f, 0.04055683f, 0.02221511f, -0.00203096f, 
    -0.03287218f, 0.04673667f, 0.02048382f, -0.02830401f, -0.05962541f, -0.04563517f, -0.03595416f, 0.04444553f, 
    0.01297915f, 0.04049377f, -0.03967555f, -0.00979315f, 0.01824476f, -0.03684873f, -0.03800123f, -0.04552896f, 
    -0.05569287f, -0.01997042f, 0.03748854f, -0.01406945f, 0.04218927f, -0.05995503f, -0.05059003f, -0.03509350f, 
    -0.02215953f, -0.04765784f, 0.04248887f, -0.02650594f, 0.00234136f, -0.02822532f, -0.05891468f, -0.02254223f, 
    0.01395708f, -0.05121363f, 0.01154426f, 0.04031801f, 0.00910587f, -0.00390424f, -0.05973525f, 0.00409520f, 
    -0.11821553f, 0.01809544f, 0.15467103f, 0.00745125f, -0.03027631f, 0.05615291f, -0.00644031f, 0.01704190f, 
    -0.13154680f, 0.05610892f, -0.15784933f, 0.20613809f, -0.03232241f, -0.02177708f, -0.10989297f, -0.17049211f, 
    0.27242705f, -0.02492101f, -0.03386340f, -0.14533508f, -0.25254259f, 0.09086479f, -0.00344872f, 0.09139264f, 
    0.01752215f, -0.03010983f, 0.07141773f, 0.27318209f, -0.18020412f, -0.16752061f, -0.07405136f, -0.17016944f, 
    0.11384357f, -0.07466239f, -0.08061738f, -0.03972426f, 0.27812165f, 0.14851592f, -0.02968866f, 0.03043647f, 
    0.04036050f, -0.20305108f, 0.08290706f, -0.05179094f, 0.06260221f, -0.14075831f, -0.11880276f, -0.18273854f, 
    0.10837085f, -0.01692019f, -0.05122073f, -0.08777416f, 0.23511270f, 0.09858028f, -0.14932859f, 0.09405031f, 
    -0.15669306f, -0.17721082f, 0.05393951f, 0.05985486f, 0.15311940f, 0.06637455f, -0.04364031f, 0.07141493f, 
    0.23746951f, -0.03755004f, 0.02041879f, 0.10151324f, 0.12905501f, -0.21010616f, -0.10789739f, -0.14409578f, 
    0.23383604f, 0.05430494f, -0.20123972f, -0.03572495f, 0.15690830f, -0.02304699f, -0.08765604f, -0.18977629f, 
    0.08504461f, 0.15725100f, -0.12103287f, 0.08886440f, -0.06384913f, 0.07690428f, -0.07721003f, 0.07783622f, 
    -0.06526530f, 0.04300817f, 0.15400589f, -0.13249192f, -0.01163230f, 0.19731866f, -0.03397962f, 0.12393770f, 
    -0.05629460f, -0.13792978f, -0.04361061f, -0.12770014f, 0.37540868f, -0.20016141f, 0.05184770f, -0.17670366f, 
    0.19860068f, 0.04236376f, -0.00350166f, 0.16921382f, -0.00798446f, -0.10723157f, 0.00780699f, -0.11320835f, 
    -0.08268385f, -0.03260404f, 0.00626768f, 0.09341958f, -0.06723882f, -0.08914769f, -0.18971758f, -0.13257954f, 
    0.04624494f, -0.12193814f, 0.12958904f, -0.07478166f, 0.05925708f, 0.00123496f, 0.08855117f, 0.45781493f, 
    -0.14053644f, 0.11482066f, -0.01726977f, 0.00193016f, -0.03457877f, 0.05664594f, 0.05624834f, 0.03797074f, 
    0.14618874f, -0.17112403f, -0.12950464f, -0.02728909f, -0.14284483f, 0.02089403f, 0.14738607f, 0.19518897f, 
    0.08684359f, -0.07188062f, 0.08782139f, 0.03366222f, -0.04755364f, 0.08598087f, 0.01993687f, 0.05825260f, 
    0.22919315f, -0.00255425f, 0.12226117f, 0.17898670f, 0.16715503f, -0.09264930f, 0.06231974f, -0.11613242f, 
    0.18465625f, 0.00186222f, 0.07349962f, 0.29508010f, -0.11508564f, 0.09816028f, -0.14884186f, 0.14018297f, 
    -0.05462641f, -0.01092357f, 0.04955007f, -0.33319846f, -0.04945903f, -0.05539712f, -0.09296730f, -0.03279458f, 
    -0.01454689f, -0.02374451f, 0.02544911f, -0.14663674f, 0.28595579f, -0.26916796f, -0.22738244f, -0.02651613f, 
    -0.02982649f, -0.03130452f, 0.04471425f, -0.16008222f, -0.14627211f, 0.13075368f, 0.03731660f, -0.03131034f, 
    0.07273191f, 0.09787725f, -0.09660197f, -0.00687721f, 0.04512677f, 0.01651501f, 0.11031821f, -0.10774209f, 
    0.09146423f, 0.03908598f, -0.18417677f, -0.16051041f, -0.15035580f, 0.11483359f, -0.03085318f, -0.43378508f, 
    -0.10691590f, -0.07942940f, -0.02530048f, 0.08843662f, -0.00819743f, 0.02921265f, -0.19266425f, 0.11061535f, 
    -0.27403548f, 0.04792773f, 0.09207530f, 0.06949403f, 0.08312004f, -0.01092881f, -0.09506853f, 0.12383392f, 
    -0.00767146f, -0.16017243f, 0.36677629f, 0.09304138f, -0.06550264f, 0.07656878f, -0.04843061f, 0.00244984f, 
    -0.00454463f, -0.03357729f, 0.27576303f, -0.19472183f, -0.00584781f, 0.05881062f, -0.06246020f, -0.21330406f, 
    -0.06101808f, 0.02998465f, -0.08996855f, 0.12641680f, -0.03049912f, 0.03550303f, 0.20152825f, -0.07174507f, 
    -0.03519068f, 0.18133038f, -0.15132003f, -0.10782567f, -0.00980607f, 0.08622441f, -0.15141234f, 0.11510441f, 
    0.01904041f, -0.00192910f, -0.03382258f, 0.16050020f, 0.08668393f, -0.34728900f, -0.30145362f, -0.04197171f, 
    -0.07997274f, -0.08310805f, -0.04424549f, 0.02754145f, -0.12269086f, 0.09976795f, 0.35161948f, -0.17770082f, 
    0.21618462f, 0.08328135f, -0.12714700f, 0.09623803f, 0.14471681f, -0.09195091f, 0.09560987f, 0.03817013f, 
    0.05181280f, -0.04334636f, 0.22738160f, -0.06660326f, 0.08311011f, -0.11093152f, -0.17599669f, 0.08288544f, 
    0.33500025f, 0.12575145f, 0.05862810f, -0.15704785f, -0.12542914f, -0.06215261f, 0.07595026f, 0.05462647f, 
    0.05468769f, 0.11230064f, 0.09711708f, -0.00020284f, -0.02694130f, -0.01834993f, 0.00407697f, 0.08257155f, 
    0.00363062f, 0.12491909f, -0.00868578f, -0.06641997f, -0.19192572f, 0.18175574f, -0.08756586f, 0.04731158f, 
    0.04927896f, -0.02325092f, -0.15812160f, 0.06372717f, 0.18084076f, -0.27723220f, 0.11780065f, -0.03836131f, 
    0.03712604f, 0.07235017f, 0.06832393f, -0.11776178f, -0.14298588f, -0.13689010f, 0.17739582f, 0.06905643f, 
    0.00886992f, -0.08396026f, 0.04020678f, -0.14739063f, 0.07076407f, 0.00561600f, -0.21481776f, -0.09693047f, 
    0.20753036f, -0.05605837f, -0.11053728f, -0.04025185f, 0.10076685f, 0.21831146f, -0.06131323f, -0.27397275f, 
    -0.14842238f, -0.05441579f, 0.03183502f, 0.18401541f, -0.00279939f, -0.05132444f, -0.05225401f, -0.17255846f, 
    0.16761954f, 0.30061045f, -0.01394268f, -0.10371409f, 0.05607857f, 0.14274779f, -0.05429811f, 0.09306090f, 
    0.21220376f, -0.19151312f, 0.08285706f, -0.12665147f, -0.03032043f, -0.02517691f, 0.09775900f, -0.01183653f, 
    -0.07104241f, 0.25584105f, 0.11432745f, 0.02419536f, 0.20608108f, -0.20484588f, -0.02783738f, 0.04808712f, 
    0.10451189f, -0.09642891f, 0.11206307f, 0.13679415f, -0.06137767f, -0.02546100f, -0.05424813f, 0.03839049f, 
    0.08753726f, 0.19353089f, -0.06598581f, -0.41152373f, -0.08507699f, 0.06893983f, -0.21316905f, -0.06208735f, 
    0.00489219f, -0.09096915f, -0.06234457f, 0.02021079f, -0.02851493f, 0.00947331f, -0.42296755f, 0.15667437f, 
    -0.02622988f, -0.08263440f, -0.08183875f, 0.07253868f, 0.14420742f, -0.12401094f, -0.16126260f, -0.08689898f, 
    0.08978148f, 0.15868860f, 0.06198137f, 0.11410116f, 0.03665288f, 0.00790215f, -0.40002707f, -0.10030170f, 
    0.42451623f, -0.14352678f, -0.06787657f, -0.09418736f, -0.03953137f, -0.02744236f, -0.06453105f, -0.17250976f, 
    -0.35810852f, 0.01642269f, -0.17071728f, -0.09779263f, 0.22565985f, -0.01288434f, 0.00562521f, -0.01387110f, 
    0.23917024f, 0.14314573f, -0.42282546f, 0.04250201f, -0.16382354f, -0.09955211f, -0.06347857f, 0.06975388f, 
    0.12078119f, 0.18050382f, -0.03690595f, 0.22550817f, -0.23073998f, -0.03347283f, 0.06641081f, -0.16360560f, 
    0.01316542f, 0.18341763f, -0.17947184f, -0.18408470f, -0.13852340f, 0.12454323f, 0.10646264f, -0.07216846f, 
    0.05770239f, 0.26604021f, -0.00748836f, -0.25161153f, -0.24878943f, -0.06587394f, 0.07400355f, 0.05254561f, 
    0.01638477f, 0.10984077f, 0.00366292f, 0.04164440f, 0.10402127f, 0.20727886f, -0.22282076f, -0.09586313f, 
    0.09222122f, -0.00391307f, -0.06962774f, -0.01075737f, 0.01176964f, 0.04196685f, 0.06585927f, 0.24894825f, 
    -0.19880340f, -0.05802524f, -0.09859999f, -0.19598179f, 0.04926566f, 0.09680836f, 0.00344274f, 0.16395876f, 
    -0.06499498f, 0.05617258f, 0.03182765f, -0.08683386f, -0.03409332f, 0.03397610f, 0.01037856f, -0.36871707f, 
    -0.28107125f, -0.29563370f, 0.02010451f, 0.04220854f, -0.01926596f, 0.03987266f, -0.07002863f, 0.07892918f, 
    0.17929889f, -0.23589301f, 0.07020217f, -0.03628216f, 0.04045826f, 0.07451568f, 0.03656936f, -0.05866610f, 
    0.12501138f, -0.26862848f, -0.11992912f, 0.22471482f, -0.05281570f, -0.15851162f, 0.14443766f, -0.08088882f, 
    0.08786918f, 0.13054192f, 0.24898015f, 0.15508915f, 0.19301233f, -0.02235271f, -0.06067068f, -0.01167430f, 
    -0.02512041f, 0.03473541f, -0.06777476f, 0.02521032f, 0.07452729f, -0.12139183f, 0.13092314f, 0.08190617f, 
    -0.00020485f, 0.09185341f, 0.13111170f, -0.03973120f, -0.33906540f, -0.46981779f, -0.26839408f, 0.04408855f, 
    0.06856913f, 0.16592859f, 0.04418915f, 0.11876396f, -0.18126914f, -0.04451844f, -0.20448869f, -0.17224610f, 
    0.11665911f, 0.12301699f, -0.14002196f, 0.07734770f, 0.02106432f, -0.09307711f, 0.19566591f, 0.29006857f, 
    0.20081821f, 0.08708227f, 0.14414622f, -0.18584123f, 0.20993282f, -0.07954036f, 0.05576008f, -0.02055223f, 
    -0.05587576f, 0.01478508f, 0.09748055f, 0.05970812f, -0.04665400f, -0.09872223f, 0.07153037f, 0.06968003f, 
    0.02611198f, 0.00013363f, 0.01126070f, 0.00003479f, -0.06661682f, -0.00864600f, 0.04457931f, -0.05503094f, 
    -0.05175726f, -0.05303344f, 0.03031097f, 0.03269526f, 0.02074567f, -0.05176659f, -0.07144936f, -0.00104394f, 
    -0.06098170f, -0.02427059f, 0.01504021f, -0.01599090f, 0.01890484f, -0.05479811f, 0.00926730f, 0.01121654f, 
    0.04159152f, -0.05679988f, 0.01053271f, -0.05768170f, 0.04019562f, -0.04398474f, -0.04697207f, 0.01994941f, 
    0.00285157f, -0.06381933f, 0.02074685f, -0.00398389f, -0.04993686f, -0.02600911f, 0.00417590f, 0.00826881f, 
    -0.05297872f, 0.00343026f, 0.03207534f, 0.03746661f, -0.06775384f, -0.04081234f, 0.01601340f, 0.01245998f, 
    0.01734973f, -0.03281311f, -0.02245270f, -0.04846796f, 0.03822851f, -0.04265561f, -0.03478680f, -0.00828919f, 
    -0.05662482f, -0.03496810f, 0.04790070f, 0.00194214f, -0.00152417f, 0.00354046f, 0.01230493f, -0.01281475f, 
    0.01321946f, 0.03764525f, -0.00061975f, -0.05125960f, 0.03366124f, -0.00844295f, -0.04606655f, -0.07666552f, 
    0.04175765f, 0.05197245f, -0.01452871f, -0.08081203f, -0.03197737f, 0.00891138f, -0.02337992f, 0.00409099f, 
    -0.04770052f, -0.04416461f, -0.01125591f, 0.01916290f, -0.03684829f, -0.01646150f, -0.03493233f, 0.02299039f, 
    -0.06481658f, -0.01210044f, 0.02862070f, 0.00128476f, -0.06686761f, 0.00524590f, -0.00543977f, -0.03655378f, 
    0.03808177f, 0.01588723f, -0.02478672f, -0.02006121f, 0.02083210f, -0.00119915f, -0.02067538f, -0.02601593f, 
    -0.03841970f, -0.00694351f, -0.03575554f, 0.01082701f, 0.03277097f, -0.01223099f, -0.01968725f, -0.02913381f, 
    -0.01052041f, -0.06793288f, -0.02776884f, 0.03376944f, 0.01409863f, -0.01472000f, -0.04209883f, -0.00561538f, 
    -0.04868800f, 0.00297749f, -0.06766120f, -0.04170828f, -0.05004193f, 0.04221202f, 0.02241818f, -0.01873303f, 
    0.00073781f, -0.02458153f, -0.02308475f, -0.07276157f, -0.06769248f, -0.00431737f, -0.03730633f, -0.00897804f, 
    -0.01262335f, -0.02553212f, 0.04394467f, -0.04279894f, 0.03328525f, 0.04046426f, 0.02155598f, -0.00360043f, 
    0.00943303f, 0.03423747f, -0.01725664f, 0.00270249f, -0.01221906f, 0.03482826f, -0.01874064f, 0.02413490f, 
    -0.01344568f, -0.05080310f, -0.00161153f, -0.04722994f, 0.00174569f, 0.02086264f, -0.05248405f, -0.03808672f, 
    -0.06392048f, -0.04485258f, -0.04964969f, -0.04250877f, -0.02814488f, -0.07469697f, -0.02374299f, -0.06893711f, 
    -0.03662466f, -0.06306782f, -0.01261876f, -0.06900784f, -0.06307042f, -0.00705719f, -0.07776648f, -0.00775636f, 
    0.00734163f, -0.07275591f, -0.02564765f, 0.01148993f, 0.03427537f, 0.03739030f, -0.04267997f, -0.04968961f, 
    0.01913681f, -0.00987170f, -0.01444026f, -0.04717731f, -0.04712975f, -0.05199425f, 0.05410109f, -0.01367623f, 
    0.06025026f, -0.00900550f, -0.05042327f, -0.06452915f, 0.03047210f, 0.01278769f, 0.03407868f, 0.01569435f, 
    0.00685772f, -0.01582039f, 0.01368260f, -0.00683500f, -0.06445105f, 0.00886666f, -0.05023707f, -0.00155297f, 
    -0.04634851f, -0.02898546f, 0.04092770f, -0.05125767f, -0.02761278f, 0.02313917f, 0.01176022f, -0.06576901f, 
    -0.07179334f, -0.03823889f, 0.01363298f, -0.05713650f, -0.05852289f, 0.00099224f, -0.02124338f, -0.04915534f, 
    0.00634675f, 0.01330491f, -0.02445096f, -0.01727135f, 0.03720210f, -0.07588254f, 0.02260582f, -0.07278378f, 
    -0.03925389f, -0.05432491f, -0.01885350f, 0.00243379f, 0.00506266f, -0.03199971f, -0.04821797f, -0.01768662f, 
    -0.04562019f, -0.04237893f, -0.00280250f, -0.02453925f, -0.01249950f, -0.07046123f, -0.00688773f, 0.02666033f, 
    -0.07034566f, 0.01542761f, -0.03856426f, -0.05178500f, 0.02635697f, 0.00843890f, -0.00784412f, 0.01537340f, 
    -0.01384625f, -0.01093375f, -0.01734096f, -0.01906869f, 0.02916500f, -0.01120243f, -0.01744073f, -0.02168310f, 
    -0.01734459f, -0.07003974f, -0.05632951f, -0.05202265f, -0.05617499f, -0.04420817f, -0.01499840f, 0.00667065f, 
    0.03073330f, -0.06600443f, -0.02908047f, 0.00977893f, -0.01426276f, 0.00864160f, -0.03567604f, -0.06426455f, 
    -0.01016934f, 0.00224541f, -0.00036478f, 0.01894778f, 0.00876474f, -0.04865245f, -0.05623964f, -0.02171743f, 
    -0.00028431f, -0.07137969f, -0.13039458f, -0.09041087f, -0.11744819f, 0.06947638f, -0.20617832f, -0.08529496f, 
    0.06548112f, 0.18060943f, 0.03332537f, -0.30246964f, -0.06695946f, -0.04437192f, -0.01540079f, -0.12019888f, 
    0.03499243f, -0.06986732f, -0.00665597f, 0.05413749f, -0.14551063f, 0.15280615f, -0.08370394f, -0.06924561f, 
    0.08866188f, 0.06280617f, -0.21063189f, 0.12648280f, 0.22945896f, -0.29000670f, 0.14989857f, 0.06864423f, 
    0.03770065f, 0.12288347f, 0.11760457f, -0.03881621f, 0.10360667f, 0.16719851f, 0.17526256f, 0.02838945f, 
    -0.02757722f, -0.03718664f, -0.01019095f, -0.07623401f, 0.02002626f, -0.06639265f, -0.01514313f, -0.16035704f, 
    0.01901671f, -0.01895891f, 0.11159416f, -0.10463659f, 0.00342079f, 0.17671543f, -0.31330597f, 0.02520428f, 
    0.11677605f, 0.04200853f, 0.04154385f, 0.05440269f, -0.09588801f, -0.01622150f, 0.19528738f, -0.11336362f, 
    -0.14506939f, 0.21616352f, 0.03448302f, 0.03488823f, -0.10130853f, -0.05458315f, -0.10290094f, 0.12826814f, 
    0.24115932f, 0.06785799f, -0.13291141f, 0.03948596f, 0.09854484f, -0.18042026f, -0.12825607f, 0.05040591f, 
    0.09265184f, 0.36360887f, -0.22451770f, -0.10787559f, -0.21036965f, 0.08330817f, 0.10350397f, -0.05956824f, 
    -0.06631786f, 0.04951628f, 0.03788294f, 0.00802667f, 0.06247890f, -0.05242162f, 0.12357654f, 0.03101443f, 
    -0.00341500f, -0.07595670f, -0.12348752f, -0.11377475f, 0.02549597f, -0.01191621f, 0.22790395f, 0.22922234f, 
    -0.06142328f, 0.03990365f, -0.18425374f, -0.14205231f, 0.13605468f, -0.09169546f, -0.25469920f, 0.12905400f, 
    -0.04305015f, 0.08413786f, 0.16357021f, 0.04485935f, -0.00214817f, 0.41476530f, 0.34358811f, -0.12237453f, 
    -0.23345554f, -0.10998585f, -0.11436368f, -0.00860358f, -0.01516146f, 0.05727010f, 0.10733693f, 0.18724930f, 
    0.08967617f, 0.08298055f, 0.00891854f, -0.16568375f, 0.04444689f, 0.01603111f, -0.00309740f, -0.39268586f, 
    -0.39668146f, -0.10080615f, 0.05246235f, -0.05536168f, 0.02803382f, -0.14553776f, 0.00050965f, 0.10445470f, 
    0.14445059f, -0.01645213f, -0.02390573f, -0.05533227f, 0.20505127f, 0.15113288f, -0.15248108f, -0.08667573f, 
    0.02702094f, -0.38980776f, -0.01304397f, 0.23221295f, -0.04133759f, 0.03299638f, 0.01940610f, -0.01068128f, 
    -0.03917786f, -0.02445684f, 0.00957070f, 0.10882977f, 0.12138515f, -0.11964601f, 0.06537756f, 0.09915534f, 
    -0.01819977f, -0.09486651f, 0.05760873f, -0.19596753f, 0.07251107f, 0.04485814f, 0.03915370f, 0.00830797f, 
    -0.03285226f, 0.11140034f, -0.13818957f, -0.01407640f, 0.05977184f, 0.08491214f, 0.20037870f, 0.06733701f, 
    -0.00536508f, 0.15364693f, 0.00524131f, -0.14366293f, -0.02509592f, -0.44739091f, -0.29776838f, 0.07063951f, 
    0.05409433f, 0.03514988f, 0.00969094f, -0.00711465f, -0.10647824f, 0.06509792f, 0.31875455f, 0.23003490f, 
    -0.16853310f, -0.14126830f, -0.16309007f, -0.01137315f, 0.17031789f, 0.03347011f, 0.01998440f, 0.04946917f, 
    -0.10675517f, 0.07311752f, -0.00492883f, 0.07382963f, -0.00472292f, -0.00520772f, -0.00768828f, -0.11900286f, 
    -0.20719928f, 0.02886961f, 0.13698281f, 0.09287951f, 0.12384817f, 0.15819634f, -0.06823526f, -0.06465718f, 
    -0.16903518f, 0.27119875f, 0.08178666f, 0.09655058f, 0.08979339f, -0.04665786f, 0.10456662f, 0.09197495f, 
    0.20654853f, -0.13557433f, 0.34954855f, 0.20669174f, -0.25943989f, 0.07148708f, -0.01850353f, -0.08322208f, 
    0.17267120f, 0.03966521f, -0.12995984f, 0.34105653f, 0.05610549f, 0.11492661f, -0.07140343f, 0.05506606f, 
    0.06891163f, 0.06256259f, -0.04999936f, 0.09499753f, -0.16512562f, 0.29449543f, 0.00918172f, 0.12409810f, 
    0.11657783f, 0.01792750f, -0.08953216f, 0.13229719f, 0.13841729f, 0.06462015f, 0.11409689f, -0.15531497f, 
    0.22314568f, 0.16617163f, 0.03078373f, 0.01376203f, 0.08200471f, -0.03356237f, 0.27733833f, -0.11121323f, 
    -0.13837342f, -0.04248180f, 0.05979920f, 0.02243416f, 0.12302256f, 0.06434593f, -0.16446310f, 0.19953978f, 
    0.33226353f, 0.23084901f, -0.00216956f, 0.00649724f, -0.01986728f, -0.01976162f, -0.11568657f, 0.14689547f, 
    -0.03518354f, 0.04217537f, -0.03862983f, -0.03173045f, -0.00860252f, -0.04351328f, -0.04770156f, 0.00068489f, 
    -0.01311965f, -0.01175540f, 0.00750695f, 0.05209654f, -0.02153185f, 0.02324412f, -0.03143141f, 0.05036608f, 
    0.01851947f, 0.03350047f, 0.04429857f, -0.02998474f, -0.00957799f, -0.04836727f, 0.00512609f, 0.03328701f, 
    0.04679232f, -0.00921976f, -0.02019322f, 0.00721816f, -0.04913379f, -0.03931028f, 0.04465980f, -0.05358841f, 
    -0.02182073f, -0.01759510f, -0.00205851f, -0.01044697f, -0.02898336f, 0.02297410f, 0.00386834f, 0.02258525f, 
    0.00666146f, 0.00028535f, 0.00043350f, 0.05189894f, 0.01898258f, -0.04369345f, -0.00941619f, 0.01853733f, 
    0.03006684f, -0.04220362f, -0.00601324f, 0.04035988f, -0.01924128f, -0.04141045f, -0.05614873f, -0.06403995f, 
    0.04708672f, -0.00259450f, 0.03813815f, -0.04918459f, 0.02594538f, -0.02483243f, 0.00222314f, 0.03484512f, 
    -0.05095390f, -0.04367615f, 0.04086613f, -0.06489204f, -0.00153929f, 0.04046236f, -0.02416926f, 0.00307595f, 
    0.01758433f, 0.03908568f, -0.02012682f, 0.00939595f, -0.00413508f, 0.03685088f, 0.04681066f, 0.03486193f, 
    0.01910265f, -0.02077633f, 0.04730390f, 0.02401753f, 0.00776122f, 0.03547559f, -0.02750860f, 0.00440256f, 
    -0.05112953f, -0.04555624f, 0.00077641f, -0.02222726f, -0.06470596f, -0.04304822f, 0.01888259f, 0.03743946f, 
    0.00224420f, -0.04180325f, 0.04882488f, 0.01006416f, 0.04117192f, 0.03382745f, -0.05292252f, -0.06446318f, 
    -0.00160027f, 0.00429512f, -0.04532743f, 0.03663221f, 0.03717131f, -0.01346120f, -0.06079197f, 0.02545756f, 
    0.05024722f, 0.05128450f, -0.02342050f, 0.01345286f, -0.00859809f, -0.03090818f, -0.03382435f, -0.00442878f, 
    -0.04722623f, -0.03411967f, -0.06012410f, -0.04818246f, -0.00205493f, -0.04660622f, -0.03127960f, -0.00587111f, 
    -0.04280004f, -0.06009886f, -0.03786734f, -0.03641982f, -0.05591748f, 0.02329946f, 0.03493256f, 0.04922006f, 
    -0.02844325f, 0.01234329f, 0.02687476f, -0.02257315f, -0.05441579f, -0.03478357f, -0.05520988f, 0.02420834f, 
    -0.02200592f, -0.01547536f, -0.01642873f, -0.03796522f, -0.02654609f, 0.02801958f, -0.03849612f, 0.03034818f, 
    -0.03577041f, 0.05105174f, 0.03877271f, 0.01970842f, -0.01568598f, -0.04652918f, -0.04770677f, -0.02896105f, 
    0.03911365f, 0.00706690f, -0.05021346f, 0.04983721f, 0.05116314f, 0.00670898f, -0.01596262f, -0.03223595f, 
    -0.02700198f, -0.04479190f, -0.04475773f, -0.00172023f, 0.02710988f, -0.03527044f, -0.04110093f, -0.01769707f, 
    -0.05366075f, 0.01491219f, -0.02891127f, 0.02694063f, 0.02903501f, -0.01950430f, -0.04786485f, -0.04235014f, 
    -0.05732678f, 0.04766283f, -0.01407279f, 0.01447154f, 0.01316859f, 0.00641913f, -0.04373568f, 0.03981643f, 
    -0.05330090f, -0.01640379f, -0.04824886f, -0.04558522f, 0.00265341f, -0.02485666f, 0.00904430f, -0.06378982f, 
    -0.03168605f, -0.05808455f, 0.04287307f, -0.05003868f, 0.04260509f, -0.01218789f, -0.03282306f, -0.05071846f, 
    -0.02160289f, 0.00721400f, -0.02245048f, -0.00261330f, -0.01938404f, 0.05037587f, -0.02434609f, -0.00185326f, 
    0.03942490f, -0.06207475f, -0.01756909f, -0.04626673f, -0.04380264f, 0.03155528f, -0.03605066f, -0.02072357f, 
    -0.04496842f, -0.00971167f, -0.01634343f, -0.04197917f, -0.05642413f, -0.03147817f, -0.02392807f, -0.02662069f, 
    -0.05098562f, -0.06019190f, 0.01047879f, -0.03083321f, -0.02979138f, -0.00121780f, 0.00340649f, -0.01398603f, 
    0.02031389f, -0.05393807f, 0.00692171f, 0.00794369f, -0.04344071f, 0.01311391f, 0.02498529f, -0.02397733f, 
    0.03422449f, 0.02760053f, 0.02346575f, -0.00705938f, 0.03459410f, 0.05253647f, 0.02366537f, -0.06051423f, 
    -0.03634922f, -0.05811832f, -0.00137778f, 0.03513908f, -0.05932418f, -0.02547773f, -0.06030356f, -0.04196521f, 
    -0.01257339f, -0.01708352f, 0.04249321f, -0.00451792f, -0.03368755f, -0.04572820f, 0.00740556f, 0.01705975f, 
    -0.04275903f, -0.05053867f, -0.02776681f, 0.03692763f, 0.03568819f, 0.03259546f, -0.00107401f, 0.02747513f, 
    0.01077859f, -0.02846415f, -0.00625524f, -0.02194290f, -0.03092456f, -0.03133192f, -0.03264336f, -0.05773379f, 
    -0.26253822f, -0.03089466f, -0.16836837f, 0.03929470f, 0.01909017f, 0.04432185f, -0.02600294f, 0.05726096f, 
    -0.01704919f, 0.01181034f, -0.27349901f, -0.43696600f, 0.28928429f, 0.10539801f, 0.23809494f, 0.15014884f, 
    -0.14862829f, 0.08463541f, 0.09688819f, -0.08379679f, -0.04533518f, 0.20228526f, -0.02272048f, 0.06859282f, 
    0.02000196f, 0.15108015f, 0.16999646f, 0.35322657f, 0.29676941f, -0.08958013f, 0.15985449f, 0.10019180f, 
    -0.13918026f, 0.18877316f, 0.00847111f, -0.06921438f, 0.03457355f, -0.05199911f, 0.02630765f, -0.10293032f, 
    0.16449752f, 0.18059853f, 0.05942932f, 0.06042382f, 0.20144230f, -0.02103390f, 0.00679733f, -0.26553327f, 
    0.30819595f, 0.07220580f, 0.10445362f, -0.06890543f, 0.13303737f, 0.14933755f, -0.07350967f, -0.04228185f, 
    -0.05577948f, -0.00684826f, -0.18973674f, -0.13618882f, -0.08718723f, 0.03827520f, 0.26684862f, 0.03767743f, 
    -0.11066093f, 0.07900015f, -0.18202579f, -0.18665133f, 0.12715834f, -0.13286546f, 0.01293942f, 0.14573905f, 
    -0.14578342f, 0.05405019f, 0.13084079f, -0.18803549f, 0.16170070f, 0.04395526f, 0.18566720f, 0.07226399f, 
    0.16693600f, 0.30596268f, -0.39309344f, 0.14946985f, 0.21075734f, 0.20414560f, 0.13775854f, 0.24632455f, 
    0.03462305f, 0.03643767f, 0.03438080f, -0.21622433f, 0.07388899f, 0.08837349f, 0.03085352f, 0.09023623f, 
    0.20369871f, 0.11047358f, -0.02534207f, 0.25134236f, -0.05667422f, -0.11181443f, 0.02750940f, 0.10003558f, 
    -0.07543939f, 0.08922341f, 0.07073984f, -0.06917339f, 0.28746140f, -0.08807542f, -0.25608194f, 0.03598930f, 
    0.04450854f, -0.05474091f, 0.14744003f, -0.01055027f, 0.19413555f, 0.48930842f, -0.01938098f, 0.07357323f, 
    0.15356821f, -0.17916985f, 0.01454550f, 0.10010561f, 0.19440928f, 0.07476029f, 0.01179655f, 0.07346062f, 
    -0.10394354f, -0.22271870f, -0.00701814f, 0.12550616f, 0.06227200f, 0.04294441f, 0.19425292f, -0.28943321f, 
    -0.20032831f, 0.03668938f, 0.00357025f, -0.26690191f, -0.07748122f, -0.08306065f, 0.05066394f, 0.28648597f, 
    0.26143336f, -0.16320018f, -0.19218931f, 0.01039283f, -0.05606739f, 0.14204569f, -0.06448640f, -0.12364236f, 
    -0.13050234f, 0.15735611f, 0.29636356f, 0.25416207f, -0.03519363f, 0.17136174f, 0.06912380f, -0.16767994f, 
    -0.03187355f, -0.11014245f, 0.20834304f, -0.04238467f, -0.00227015f, 0.11875166f, -0.06316211f, 0.11784212f, 
    -0.07626047f, 0.16523787f, -0.03716379f, -0.00999604f, 0.21809563f, -0.02553349f, -0.00858751f, -0.09394496f, 
    0.10669038f, 0.01966280f, -0.08027159f, 0.06866580f, 0.06942760f, 0.20212127f, 0.01686092f, -0.04048051f, 
    0.14231160f, 0.10951800f, -0.03085167f, 0.03312962f, 0.12472828f, 0.04512338f, 0.08456243f, 0.17607827f, 
    -0.08912180f, -0.00595155f, 0.26464868f, -0.06660637f, 0.00409677f, -0.02649620f, 0.28071579f, -0.19637311f, 
    -0.09287801f, 0.23544216f, 0.17888165f, 0.08356102f, 0.15499648f, 0.08897840f, 0.12757009f, -0.05945415f, 
    -0.22901449f, -0.25417086f, 0.01247495f, -0.21778673f, 0.03710810f, -0.04285869f, -0.24357952f, -0.03228661f, 
    0.18425842f, 0.21069022f, -0.05889976f, -0.02120634f, -0.17577113f, 0.22158366f, -0.31680942f, 0.10274263f, 
    -0.02335122f, 0.19911237f, 0.03658349f, 0.09877225f, -0.24823205f, -0.10215742f, 0.04894223f, 0.12637596f, 
    -0.00695058f, 0.22104868f, 0.59820116f, 0.16543049f, -0.02353924f, 0.15507106f, -0.14062047f, -0.03871539f, 
    0.12899837f, 0.19006699f, -0.06486271f, 0.19322422f, -0.15891887f, 0.00016296f, 0.19491041f, 0.06189074f, 
    0.05666476f, 0.12321894f, 0.02000899f, 0.06584530f, -0.01464131f, -0.14583930f, -0.03330020f, 0.00951709f, 
    -0.12923139f, -0.16806962f, -0.11146440f, 0.11420664f, 0.31972533f, 0.42054686f, 0.14303017f, 0.07555517f, 
    0.18207410f, -0.08194978f, -0.02943119f, 0.23871493f, 0.05348979f, 0.12123673f, 0.38164943f, 0.01201592f, 
    0.05984190f, 0.07668401f, -0.00580249f, 0.12819709f, 0.13738057f, 0.24809916f, -0.10455343f, -0.04900851f, 
    -0.07751600f, -0.06634517f, 0.27064931f, 0.29669091f, 0.00774790f, -0.02988727f, -0.02176126f, 0.03807732f, 
    -0.05339316f, 0.01669529f, 0.02266632f, -0.01492614f, 0.04985027f, -0.02271388f, -0.02682502f, -0.05576270f, 
    -0.03875723f, -0.05048386f, -0.00893584f, -0.03717714f, -0.03123475f, 0.01659391f, 0.01725280f, -0.05214834f, 
    -0.06148508f, 0.05050035f, -0.02540111f, 0.01335749f, -0.02396845f, -0.03472135f, 0.03685553f, -0.00834783f, 
    0.03889088f, 0.01116910f, -0.00395566f, 0.00867885f, -0.04988299f, -0.01563464f, -0.04746386f, -0.04392479f, 
    -0.05449458f, 0.05352021f, 0.00197852f, -0.04239658f, -0.06085162f, 0.02175578f, -0.02998417f, 0.02710850f, 
    0.04234340f, 0.00921372f, -0.00780749f, 0.01930247f, 0.03917221f, 0.02304158f, -0.04345262f, -0.04867286f, 
    0.02896304f, 0.02784097f, -0.03479834f, 0.01759595f, 0.04371369f, -0.01686294f, 0.03374409f, -0.04475858f, 
    -0.04418153f, 0.02034655f, -0.04313994f, -0.02659716f, -0.04887047f, -0.03524925f, -0.05166503f, -0.00037186f, 
    -0.01838994f, 0.05087611f, 0.02401442f, -0.04400100f, 0.05043416f, -0.00655287f, 0.01492790f, 0.04174689f, 
    0.01391199f, -0.03281351f, 0.04295172f, -0.06208837f, -0.05834601f, 0.00094860f, -0.01818127f, -0.02709814f, 
    -0.01370196f, 0.02437861f, 0.03043759f, 0.01782848f, -0.00957468f, 0.03634533f, -0.03251733f, -0.05277900f, 
    0.03969216f, -0.00742905f, -0.06340905f, 0.02498991f, -0.05605738f, -0.03507274f, -0.04829923f, -0.03575199f, 
    -0.06399803f, -0.01181815f, -0.04903778f, -0.03497697f, -0.03787650f, 0.02865209f, -0.06219464f, -0.01420324f, 
    0.00433034f, 0.05076801f, -0.04599150f, -0.05586956f, -0.04482039f, 0.01906443f, -0.00065952f, -0.03284889f, 
    -0.02471382f, 0.02941368f, 0.01639996f, 0.01591116f, -0.04672282f, 0.01190916f, -0.01932739f, -0.03142349f, 
    0.03921818f, -0.02079420f, -0.05376061f, -0.03988626f, 0.02613465f, -0.01740409f, -0.06247933f, -0.06162089f, 
    0.01111335f, 0.04577419f, -0.02286132f, 0.04452625f, -0.02819488f, -0.04576299f, 0.01012391f, -0.01012522f, 
    0.04533606f, -0.04937606f, -0.02730730f, 0.04451299f, 0.00344507f, 0.00072992f, 0.04328730f, 0.01289080f, 
    -0.00601790f, 0.00870440f, -0.03871400f, -0.04970642f, 0.01990071f, -0.02555859f, -0.02136434f, 0.03725252f, 
    0.01569282f, -0.02543049f, 0.04086141f, -0.00141889f, -0.04384832f, -0.00300360f, 0.04549938f, -0.05159452f, 
    0.03304964f, 0.00182200f, 0.04990972f, 0.02875436f, -0.03026859f, 0.05321599f, 0.04856134f, 0.04426124f, 
    -0.05288045f, -0.00339171f, 0.00831960f, -0.00966443f, 0.03068207f, -0.05047025f, 0.00078094f, 0.04336531f, 
    -0.00851321f, 0.04012669f, -0.06121127f, 0.01279374f, -0.05433686f, 0.03173444f, -0.04051663f, -0.02394860f, 
    -0.00000329f, -0.00576945f, 0.00509103f, 0.00081880f, 0.03243172f, -0.03810175f, -0.06086605f, 0.03417546f, 
    0.01757347f, -0.05547421f, 0.02836981f, -0.02931022f, 0.01737698f, 0.00156097f, 0.05199700f, 0.03189443f, 
    -0.05788866f, -0.02068709f, -0.00352683f, -0.03486652f, -0.01805241f, 0.05465104f, -0.01208285f, 0.03323458f, 
    0.04440526f, -0.02107983f, -0.05802475f, 0.01956236f, -0.03532430f, -0.05746380f, 0.00146882f, 0.01309315f, 
    0.01862602f, -0.03659962f, 0.00657805f, 0.04046717f, 0.00623513f, -0.05498265f, -0.02101461f, 0.02186393f, 
    -0.02075380f, -0.03578032f, -0.01721578f, -0.04586013f, 0.00109806f, -0.01813449f, 0.03550374f, 0.01250045f, 
    -0.04504146f, -0.06114798f, 0.01810000f, 0.01557055f, 0.02940784f, -0.06794934f, 0.03569109f, -0.04807422f, 
    -0.06476133f, 0.01739559f, -0.04086706f, -0.03509331f, -0.04737088f, -0.04861333f, -0.00266274f, 0.01618754f, 
    -0.02968818f, -0.04130768f, 0.01589742f, -0.05654872f, -0.04829657f, 0.00104982f, -0.03347624f, -0.06088735f, 
    -0.03795804f, -0.03030810f, -0.04700647f, 0.01385821f, 0.05280736f, 0.02012255f, 0.04371903f, 0.03563095f, 
    -0.05851804f, -0.01901839f, -0.02303709f, 0.03250127f, 0.04508899f, 0.03871581f, -0.00474299f, 0.04182160f, 
    -0.02322278f, 0.01793254f, 0.02925981f, -0.04664804f, -0.01558709f, -0.06097276f, -0.02448925f, -0.00893410f, 
    0.01429995f, 0.01314672f, -0.05698992f, 0.05153681f, -0.00494764f, -0.05187392f, 0.04017397f, -0.00856874f, 
    0.46602538f, 0.04995917f, -0.23432170f, 0.02113488f, -0.07505231f, 0.10172642f, 0.03738451f, 0.07958224f, 
    0.18122575f, -0.24366869f, -0.06692858f, -0.12375916f, 0.05760498f, 0.02103850f, -0.03676632f, 0.08724539f, 
    -0.10623065f, 0.18795228f, -0.01213758f, 0.10809421f, -0.43816763f, 0.06849155f, 0.07606319f, 0.15711817f, 
    0.02306523f, -0.11543047f, -0.01592951f, 0.09456766f, 0.05503508f, -0.00608309f, 0.00972058f, -0.00075754f, 
    0.01443760f, -0.03538127f, -0.12515537f, -0.03886851f, -0.02116746f, 0.10041957f, -0.30713975f, 0.04737028f, 
    -0.07153536f, 0.06594616f, -0.09709729f, -0.05621324f, -0.13256687f, 0.11181547f, -0.02455396f, -0.13561155f, 
    -0.12689784f, 0.18375729f, 0.35459375f, -0.09323450f, 0.08530258f, 0.06365936f, 0.10652683f, -0.30135369f, 
    -0.04850851f, 0.03840290f, 0.15210184f, 0.12766953f, 0.01151232f, -0.15985668f, -0.07944734f, -0.14449565f, 
    0.33944917f, -0.02160766f, -0.04490449f, -0.11397748f, 0.00510242f, 0.04064208f, 0.07391389f, -0.25590938f, 
    -0.10149312f, -0.06009481f, -0.18780239f, 0.04517418f, 0.09490613f, 0.10752492f, -0.15625870f, 0.07072473f, 
    -0.02060026f, 0.05177034f, 0.04807588f, 0.10610783f, -0.19465186f, 0.06556037f, 0.06026952f, -0.07182670f, 
    0.11127662f, -0.13554792f, -0.33330083f, 0.02627748f, 0.21206637f, 0.08721769f, -0.09178913f, 0.00489119f, 
    -0.07191228f, -0.06736635f, 0.11214010f, -0.03157477f, -0.12592241f, -0.32826418f, 0.01430664f, 0.06181566f, 
    0.08886884f, -0.04495935f, 0.00522224f, 0.02164081f, 0.04251920f, -0.06285072f, 0.20814610f, 0.27880153f, 
    -0.01654345f, 0.02785761f, 0.02477514f, -0.12463249f, 0.09573911f, 0.15877382f, 0.07499408f, 0.13640365f, 
    -0.00377295f, 0.10061613f, -0.00283297f, -0.11370827f, 0.12503980f, -0.07762010f, -0.28737506f, 0.17013733f, 
    -0.24032331f, -0.07086318f, -0.01436726f, -0.01749691f, 0.14644472f, 0.02425453f, -0.05890854f, -0.27038461f, 
    -0.53796679f, -0.42479965f, 0.16260993f, 0.07246218f, -0.03571517f, 0.10067447f, -0.07453115f, 0.00754961f, 
    -0.00569198f, -0.27496290f, -0.07946348f, 0.05989364f, 0.02114932f, 0.09918210f, 0.04645478f, -0.10581532f, 
    -0.01305899f, -0.32358474f, -0.30545986f, -0.20977910f, -0.20968255f, -0.06590331f, -0.11817961f, -0.02974544f, 
    -0.09348839f, -0.11192571f, 0.18916005f, 0.01528596f, 0.41268215f, -0.01469415f, 0.17930950f, 0.17903553f, 
    -0.14485119f, 0.01526614f, 0.04002750f, 0.08540729f, -0.16278170f, -0.09212480f, 0.15272398f, -0.09147447f, 
    0.14054558f, 0.09116927f, 0.16192819f, 0.02664475f, -0.35486069f, 0.00795777f, 0.00750550f, 0.10220318f, 
    -0.03723171f, 0.01545796f, 0.07413718f, -0.08018515f, -0.03334846f, -0.06294742f, 0.10198362f, -0.18281834f, 
    0.05735541f, 0.07326271f, 0.06972209f, -0.06271449f, 0.06654622f, -0.20426503f, 0.09790295f, -0.01359172f, 
    0.12515871f, 0.10408062f, -0.10270174f, -0.09686975f, 0.11747231f, 0.06521285f, -0.01494754f, -0.47154748f, 
    -0.04010080f, 0.30188382f, 0.06341349f, -0.02816913f, 0.20583154f, 0.00617024f, -0.04097641f, 0.15023246f, 
    -0.27666324f, -0.22421864f, -0.09813189f, 0.06805383f, 0.02339156f, 0.13297428f, -0.12460683f, -0.20719069f, 
    -0.03409702f, -0.06746717f, -0.10618189f, -0.04634318f, -0.04013151f, -0.06761533f, -0.13830948f, -0.01388400f, 
    -0.00187663f, 0.05664954f, 0.06496141f, 0.14895494f, -0.27650246f, 0.02706025f, -0.25480887f, -0.04958493f, 
    0.03757937f, 0.00271170f, -0.04614624f, 0.15538158f, 0.25819042f, 0.01854106f, 0.05066332f, -0.14446166f, 
    0.09866303f, 0.02145688f, 0.02305801f, 0.14955370f, 0.06097846f, -0.48608777f, -0.28669304f, -0.28476521f, 
    0.05205555f, -0.22795767f, 0.05620168f, -0.05033974f, -0.05313741f, 0.05150831f, 0.11282794f, 0.02430367f, 
    0.11614481f, 0.13875479f, 0.12270910f, 0.11508517f, 0.04320801f, -0.03846208f, 0.14187005f, 0.20260291f, 
    -0.02339908f, -0.02028682f, 0.01689759f, 0.02721917f, 0.09815903f, 0.25600314f, -0.05272214f, 0.00537746f, 
    0.23292609f, 0.12558931f, -0.00468993f, -0.09570234f, -0.07441171f, 0.02476429f, -0.15564342f, 0.08027242f, 
    -0.59133351f, 0.19537811f, 0.25648808f, 0.04562693f, 0.14630324f, 0.15256056f, -0.12111184f, -0.13732778f, 
    -0.14540450f, -0.21402977f, -0.22097461f, -0.03956870f, -0.15647091f, 0.07754301f, -0.17013057f, 0.12849623f, 
    -0.09289414f, 0.14066733f, -0.05689053f, 0.13075025f, -0.07216918f, 0.11885150f, -0.04285941f, 0.22898459f, 
    0.02092748f, -0.13639142f, -0.04848177f, 0.22074945f, 0.01149422f, 0.04572547f, 0.13623358f, -0.20661429f, 
    0.15759064f, 0.11302959f, -0.01437482f, -0.21984953f, -0.02597205f, -0.08989315f, -0.09053678f, -0.04636220f, 
    -0.01978040f, 0.10363004f, -0.02397608f, -0.00408300f, 0.18131129f, -0.05969963f, 0.29922301f, -0.07857644f, 
    0.07311375f, 0.04051556f, 0.08244745f, -0.16699453f, -0.09765737f, -0.25430146f, -0.08034419f, -0.14568928f, 
    -0.14766078f, -0.11777325f, 0.06917891f, 0.08884154f, 0.04957059f, 0.04196552f, -0.06052834f, 0.14538674f, 
    0.05294159f, -0.03749788f, -0.16679342f, -0.10934982f, -0.00761609f, -0.05071329f, 0.15098213f, 0.13152170f, 
    -0.13117744f, 0.10221447f, -0.22440019f, 0.10797459f, 0.07285529f, 0.07353366f, -0.14275563f, 0.08333673f, 
    -0.03228541f, -0.08068282f, -0.02682462f, -0.00003359f, 0.02060311f, 0.01870755f, -0.00521505f, 0.12888436f, 
    0.07808474f, 0.22860350f, 0.04902186f, -0.10818360f, 0.05576576f, 0.00978769f, 0.14862545f, -0.04104688f, 
    0.03497494f, -0.11724021f, 0.34042743f, 0.02059913f, 0.05454706f, 0.02304813f, 0.03600173f, -0.05785585f, 
    0.14427570f, 0.05728495f, 0.04397278f, -0.09468055f, 0.11231341f, -0.11845972f, -0.11959901f, 0.10426682f, 
    -0.10344991f, 0.08931786f, -0.00328885f, 0.07900824f, 0.04565521f, 0.14078140f, -0.00629341f, -0.14697127f, 
    0.06180442f, -0.05194715f, 0.18664919f, 0.01988165f, 0.00748945f, -0.04560292f, 0.09777369f, 0.08762433f, 
    -0.03120499f, 0.06123579f, -0.07739190f, -0.02079996f, 0.08041418f, 0.08788553f, -0.11176410f, 0.06879872f, 
    -0.33408365f, -0.16523936f, -0.14802210f, -0.07404608f, 0.07903704f, -0.07840535f, 0.05820679f, -0.11213665f, 
    -0.19896449f, -0.20018518f, 0.13430093f, -0.00044160f, -0.00236037f, -0.20585418f, -0.03078707f, -0.02243335f, 
    0.25765070f, 0.11395729f, 0.20560162f, 0.04583856f, 0.04282247f, 0.03505983f, -0.10563299f, 0.03335491f, 
    0.01554973f, -0.05961246f, 0.10649674f, 0.06811269f, 0.03011529f, -0.01647503f, 0.06538507f, 0.01057333f, 
    -0.09092316f, -0.02289293f, -0.09510791f, 0.28830892f, 0.11657514f, -0.17930298f, 0.03271409f, 0.11006406f, 
    -0.05189905f, 0.00861376f, -0.01720086f, -0.00269637f, -0.12224270f, 0.02459724f, 0.10208581f, -0.05562347f, 
    0.14555456f, 0.19236699f, 0.11400180f, -0.05368227f, -0.05245861f, 0.15800002f, -0.08084090f, -0.08321916f, 
    -0.08823143f, -0.00813421f, -0.22791880f, -0.04839454f, 0.06030394f, -0.02683337f, -0.08171473f, -0.10637955f, 
    0.06908803f, 0.01941623f, 0.04390213f, 0.04997089f, -0.03352313f, -0.17088045f, 0.05228230f, -0.25969729f, 
    -0.27876592f, -0.03886021f, 0.02924359f, -0.00479902f, 0.06267688f, -0.18936136f, 0.00357520f, -0.14088945f, 
    0.13121761f, 0.10920385f, -0.05296980f, -0.02727332f, -0.10546426f, -0.00747277f, 0.10206974f, 0.16390435f, 
    0.09716781f, 0.12454100f, 0.07276738f, -0.06598949f, -0.09082393f, -0.00445455f, -0.09083235f, 0.19134401f, 
    -0.04209734f, -0.05304720f, 0.03862900f, 0.16895966f, -0.08735149f, -0.01840506f, 0.03946386f, 0.03150984f, 
    -0.03832725f, 0.01648163f, -0.05138966f, -0.22292770f, -0.07438440f, -0.15041767f, -0.01775092f, -0.07661344f, 
    0.03423448f, -0.01156683f, 0.01538187f, 0.12361893f, 0.01242333f, 0.04963406f, -0.01084531f, -0.05754578f, 
    -0.01058353f, -0.00935278f, -0.08206502f, 0.04197406f, -0.04694456f, 0.28009740f, 0.07279269f, -0.32214925f, 
    0.00309228f, -0.14782669f, 0.05506917f, 0.04297340f, -0.02687440f, -0.06888945f, 0.00712964f, 0.20432110f, 
    -0.08948030f, 0.04698159f, -0.04336359f, 0.08053429f, 0.12362940f, 0.09957231f, 0.00389981f, -0.08385783f, 
    0.00963473f, -0.19253346f, 0.02008463f, 0.08298818f, -0.00616676f, -0.00921252f, -0.14809699f, 0.09477191f, 
    0.27628464f, 0.04338419f, 0.01895885f, -0.20305540f, -0.09502520f, 0.05850272f, 0.26772210f, 0.02172636f, 
    0.03680194f, 0.09504102f, -0.00614351f, -0.31518316f, -0.04175364f, -0.05825723f, 0.11252621f, 0.10412779f, 
    0.26187751f, -0.17937796f, -0.00454896f, 0.04928800f, -0.22434314f, -0.20057152f, 0.05428602f, -0.08156510f, 
    -0.08586119f, 0.05969029f, 0.00191796f, -0.30309471f, 0.03285689f, -0.06575403f, -0.19355905f, -0.00420803f, 
    -0.23535191f, 0.03337399f, 0.06521166f, 0.18893580f, 0.13809927f, 0.03505579f, 0.19777597f, 0.24708803f, 
    -0.04800436f, 0.07944354f, -0.02570610f, -0.03576085f, 0.12410479f, -0.02028266f, -0.02973807f, 0.07128972f, 
    -0.25459513f, -0.06117209f, 0.09141906f, 0.09926081f, -0.07479691f, 0.02955461f, 0.04605361f, 0.31922165f, 
    0.34788531f, 0.19751325f, -0.15350984f, 0.07167383f, -0.21887760f, 0.01799695f, -0.02015008f, 0.46368402f, 
    0.04587875f, 0.22082992f, 0.16143154f, -0.05193987f, 0.12080128f, 0.08626150f, 0.11676612f, 0.05469668f, 
    0.11575712f, 0.14071032f, 0.14565448f, -0.09552725f, 0.15998040f, 0.02238445f, -0.00770417f, -0.01758927f, 
    0.15969990f, 0.03650216f, 0.11743794f, 0.05062844f, 0.11326970f, -0.01204243f, -0.04025053f, 0.01488820f, 
    -0.00316150f, -0.03824966f, 0.18344972f, -0.03841371f, -0.17979862f, -0.04083155f, 0.10640073f, 0.11991297f, 
    0.18809995f, 0.19475009f, -0.19041595f, 0.09628590f, -0.05679561f, 0.03264890f, -0.06242873f, 0.16518381f, 
    -0.19756839f, 0.09105168f, 0.17337283f, 0.09118152f, -0.17345531f, 0.17111690f, 0.05289800f, -0.10928723f, 
    -0.01570779f, -0.08463304f, -0.02778054f, 0.04247479f, -0.08464113f, 0.00359567f, 0.01206596f, -0.06433169f, 
    -0.15653220f, 0.00856435f, 0.14416128f, 0.07468434f, -0.04857491f, -0.04324542f, -0.08300491f, 0.03005576f, 
    0.11716709f, 0.30131409f, 0.15471485f, -0.00289077f, 0.13161154f, -0.01248750f, 0.12822503f, 0.13415217f, 
    0.55074334f, 0.18306057f, 0.12827368f, 0.05901162f, -0.03588770f, 0.14093907f, -0.04568133f, 0.20650637f, 
    -0.06360781f, 0.25518975f, 0.05927056f, 0.08050869f, 0.01416326f, 0.01520909f, 0.05431133f, -0.05321443f, 
    -0.15848292f, 0.24946328f, -0.06316528f, -0.14847055f, 0.12025584f, 0.02338493f, 0.15707964f, -0.01286549f, 
    -0.19058481f, 0.09770294f, 0.04519042f, 0.03975245f, -0.27362642f, -0.07579286f, -0.08933104f, 0.38948941f, 
    0.08785516f, 0.01928654f, -0.06088152f, -0.05024686f, 0.09808354f, -0.08083019f, -0.08675630f, 0.00303719f, 
    -0.07471432f, -0.09828131f, 0.06965464f, -0.01557237f, -0.01289769f, -0.15336224f, -0.24639553f, 0.02762796f, 
    0.11815307f, -0.06725360f, 0.01899147f, 0.02191340f, -0.12605742f, 0.28567296f, 0.14004822f, -0.10761601f, 
    -0.00884864f, 0.22741039f, 0.04770150f, 0.11562227f, -0.03535296f, 0.21773864f, 0.10458197f, -0.03113908f, 
    -0.01592974f, 0.06333566f, -0.06707715f, -0.02063324f, 0.03080321f, 0.07198824f, 0.07581224f, 0.06219256f, 
    0.09421266f, 0.03507042f, -0.04702623f, 0.17822611f, -0.15135016f, -0.12871347f, 0.02564816f, 0.07631441f, 
    0.31296140f, 0.08340559f, -0.06471438f, 0.01387161f, 0.05711819f, 0.03665135f, -0.02075718f, -0.00232470f, 
    0.09013472f, -0.03317800f, 0.05203833f, -0.04235733f, 0.20697479f, 0.16291396f, 0.14816751f, -0.09764671f, 
    -0.05972726f, 0.01379198f, -0.26440984f, 0.21751595f, -0.37524959f, -0.25545642f, -0.10865051f, -0.16185005f, 
    0.02207022f, 0.14034212f, -0.06166802f, 0.18111731f, 0.09506062f, -0.03745851f, -0.09133274f, 0.10365219f, 
    -0.12619197f, -0.14364976f, 0.25566509f, -0.16296525f, 0.00988748f, 0.39800778f, 0.18664831f, 0.21669289f, 
    -0.01123197f, 0.15784264f, -0.29171056f, -0.17216367f, -0.03237267f, -0.16106541f, -0.10088265f, -0.13532721f, 
    -0.13556261f, 0.07969134f, -0.00809994f, -0.08511382f, 0.08623347f, -0.01879753f, -0.22519977f, 0.08923939f, 
    -0.37695479f, -0.00334691f, -0.06086657f, -0.11803813f, -0.08900806f, -0.04554445f, -0.11375330f, 0.23241208f, 
    -0.02110884f, -0.10767399f, -0.14748070f, 0.05010839f, -0.15346752f, -0.07317853f, 0.10519792f, -0.09314514f, 
    0.05595726f, 0.14377050f, -0.10950646f, -0.07194009f, -0.03470938f, 0.02870248f, -0.02633415f, 0.11291087f, 
    -0.17772394f, -0.14504695f, 0.04190679f, 0.00029894f, -0.05345555f, -0.34433463f, 0.12556246f, -0.13998897f, 
    0.09012098f, -0.01926679f, 0.27373824f, 0.03026406f, -0.00928239f, 0.05763402f, 0.06977307f, -0.03983867f, 
    0.14391387f, -0.03821773f, -0.00827237f, 0.15934396f, -0.06346974f, -0.01821835f, -0.02561843f, 0.12424295f, 
    -0.10502823f, 0.02175067f, 0.13131882f, 0.02787344f, 0.03000327f, -0.05590332f, 0.20430660f, 0.02552294f, 
    -0.01718722f, 0.09730291f, 0.00850471f, -0.08853279f, 0.03908258f, 0.01804967f, 0.04113052f, 0.13146056f, 
    0.00645689f, 0.17650536f, -0.24530664f, 0.09987029f, -0.06644393f, 0.12205486f, 0.16213313f, 0.02300207f, 
    0.06295839f, 0.12426895f, -0.21887930f, -0.04500124f, 0.02899890f, 0.00517001f, -0.06030664f, -0.00820467f, 
    -0.28476351f, 0.26353756f, -0.13348919f, 0.05264613f, 0.06168761f, -0.02305369f, 0.06816358f, 0.08794676f, 
    0.19335456f, 0.12279324f, 0.18466389f, -0.11919872f, 0.07622955f, -0.14153300f, 0.03416676f, 0.08371773f, 
    0.10120640f, -0.12953924f, -0.16362125f, -0.10909825f, 0.07173938f, 0.03738642f, 0.17504162f, -0.01959369f, 
    0.00185267f, -0.19294812f, 0.11858389f, -0.21660031f, 0.06321898f, -0.00155785f, 0.03815033f, 0.03205674f, 
    -0.06501842f, 0.07130837f, -0.22235940f, -0.02643409f, -0.06900959f, -0.05269457f, -0.04515148f, -0.05744545f, 
    0.06719116f, 0.02407689f, -0.01371526f, -0.07969303f, 0.00672634f, -0.10943126f, 0.10020605f, -0.07863376f, 
    -0.22908583f, 0.06995475f, -0.13556920f, -0.10861769f, 0.12615606f, 0.00256675f, 0.02028312f, 0.08831242f, 
    0.10957052f, 0.10759408f, 0.10374998f, 0.05865522f, -0.06401110f, -0.32637960f, 0.06691475f, -0.22353564f, 
    0.05932472f, 0.02572658f, 0.11719873f, -0.12993349f, -0.12595630f, -0.18567319f, 0.06283313f, -0.10303216f, 
    0.06185253f, 0.01533109f, 0.08577462f, -0.04859736f, -0.02460373f, -0.08498093f, 0.16565721f, 0.00019757f, 
    0.01125302f, 0.10406305f, 0.18388803f, -0.07400714f, -0.13779753f, -0.09045511f, -0.03085433f, 0.00820727f, 
    -0.02452336f, 0.01029988f, -0.07158404f, 0.03925648f, -0.13952377f, -0.05030503f, -0.06558653f, 0.06144191f, 
    0.03338762f, 0.22986872f, 0.14593330f, 0.29261658f, -0.11975548f, -0.02569647f, 0.02223684f, 0.05648797f, 
    0.06505141f, -0.23049924f, -0.03018021f, 0.06949110f, 0.08476011f, 0.09643723f, 0.07144694f, 0.05357185f, 
    -0.19525574f, 0.04238552f, -0.00180347f, 0.09749059f, 0.03649323f, -0.06437533f, -0.04355351f, 0.20138179f, 
    -0.00014409f, -0.03295273f, 0.06210925f, -0.00835148f, -0.14126869f, -0.04567491f, -0.05262449f, 0.10784157f, 
    -0.02077884f, 0.10370053f, 0.04237220f, 0.03634525f, 0.02511225f, 0.04509670f, -0.10184014f, -0.07144358f, 
    -0.03945348f, 0.17124438f, -0.08434512f, 0.20839719f, 0.03422692f, -0.08358394f, -0.04880880f, 0.15530272f, 
    -0.00729975f, 0.04610505f, -0.08532251f, -0.13276640f, 0.07445713f, -0.08325314f, 0.05586646f, -0.13851149f, 
    -0.02329826f, -0.05031514f, -0.04984949f, -0.14257115f, 0.06756017f, -0.09206394f, 0.22642438f, -0.12971807f, 
    -0.07980537f, -0.01426507f, 0.10925497f, 0.04445888f, 0.03002762f, 0.08238579f, -0.04480399f, -0.00398186f, 
    0.06020238f, 0.16918741f, -0.06288894f, -0.03223950f, 0.21663383f, 0.02824247f, 0.03129529f, -0.07141474f, 
    0.09958773f, 0.02126772f, -0.06387614f, -0.15468203f, -0.05666297f, -0.15149750f, 0.04709487f, 0.16510911f, 
    0.13958634f, -0.00360697f, -0.04653983f, -0.07165214f, 0.14073157f, 0.14986807f, 0.03511550f, -0.17127869f, 
    -0.00490757f, -0.18365394f, -0.14041710f, 0.14652331f, 0.05299751f, 0.09067140f, -0.09144466f, -0.11527977f, 
    0.06699808f, 0.11287092f, -0.10039517f, 0.13780513f, 0.04895139f, -0.05376053f, -0.04414220f, -0.27208900f, 
    -0.11420279f, 0.00970075f, 0.01281386f, 0.08635353f, 0.07082763f, 0.01055040f, -0.29319021f, -0.20213464f, 
    0.07316706f, -0.17743932f, 0.05348734f, 0.13872732f, 0.14505836f, -0.11429083f, 0.02208438f, -0.01924415f, 
    -0.32209525f, 0.14699936f, 0.18271552f, 0.01878126f, 0.14193574f, -0.17661703f, -0.05830641f, -0.06119496f, 
    0.00609336f, -0.32055396f, -0.32122108f, 0.01456276f, 0.00784503f, 0.01559577f, -0.08566010f, -0.12222637f, 
    0.04111007f, 0.05401605f, 0.07729287f, 0.06263533f, 0.07386681f, 0.08201150f, 0.12761821f, 0.22980674f, 
    -0.05661970f, 0.09998581f, -0.18707605f, 0.24697261f, 0.24249956f, -0.01757185f, -0.02256405f, 0.08884624f, 
    0.17312855f, -0.18715581f, 0.01672791f, 0.12631011f, -0.18150024f, 0.00802851f, -0.00461563f, 0.22515558f, 
    0.10293642f, 0.07216226f, 0.03129849f, -0.08351412f, -0.08480712f, -0.15857452f, -0.16064794f, 0.08102341f, 
    0.09570851f, 0.08895707f, 0.20906988f, 0.07258105f, 0.06572708f, -0.14844611f, 0.17367186f, -0.15547819f, 
    -0.17277457f, 0.04398751f, 0.08855774f, 0.13658082f, 0.13646558f, -0.29163951f, -0.10028730f, 0.25450760f, 
    -0.16533522f, -0.44401959f, 0.08272781f, -0.04009253f, -0.07574724f, -0.24690740f, -0.02785576f, -0.08020946f, 
    -0.40892965f, -0.17907567f, -0.15513314f, 0.22548413f, -0.01147081f, 0.18596023f, 0.02043705f, -0.12312022f, 
    -0.07848091f, 0.01664876f, 0.06987652f, 0.01322517f, 0.02522749f, 0.01321573f, 0.02636065f, 0.00722659f, 
    0.12913387f, 0.03095715f, -0.02961378f, -0.00563580f, 0.13419156f, -0.05749332f, -0.11075822f, 0.31525752f, 
    0.05856266f, 0.17520265f, 0.08591559f, 0.10146138f, -0.12866054f, -0.27327952f, 0.18665709f, -0.11629482f, 
    -0.00472322f, 0.00600197f, -0.06148880f, -0.04779193f, 0.18331392f, 0.08789090f, -0.06384221f, 0.17934358f, 
    0.01232301f, 0.00936276f, -0.01888135f, 0.11615097f, 0.11538491f, 0.32390583f, 0.20819837f, -0.22312838f, 
    -0.10149445f, -0.03740779f, 0.09953145f, 0.00825158f, 0.07790992f, 0.03884387f, -0.13751462f, -0.04438604f, 
    0.09763060f, -0.05722080f, 0.00999942f, 0.19251607f, 0.13591497f, -0.05913499f, 0.03648401f, 0.38804719f, 
    -0.14170885f, 0.02767307f, -0.11952880f, 0.00074042f, -0.07096595f, 0.04031128f, -0.01198903f, 0.02313703f, 
    0.07702068f, 0.04020922f, -0.06051891f, 0.14886233f, -0.03890037f, -0.27222344f, -0.19430996f, 0.04052933f, 
    0.12271453f, 0.31709307f, 0.18876864f, 0.22050150f, -0.12756607f, -0.02259808f, 0.07290830f, 0.11581631f, 
    -0.10104690f, -0.16313969f, 0.08630478f, 0.14071889f, -0.15427540f, 0.00705337f, -0.33140135f, 0.10071076f, 
    0.05456158f, 0.00015539f, 0.12107211f, 0.18359679f, -0.01728951f, -0.01068075f, 0.16082972f, 0.02210221f, 
    0.04410731f, 0.05927313f, 0.19109344f, -0.09515301f, 0.04116327f, -0.24227056f, -0.05300215f, -0.03164250f, 
    0.22654815f, 0.29791099f, -0.11551499f, 0.02327384f, -0.01463323f, 0.45251966f, 0.00379327f, -0.09623487f, 
    -0.17617124f, -0.09482534f, -0.08573388f, 0.11836451f, -0.07511120f, 0.03562441f, 0.15389954f, 0.19118711f, 
    0.19246967f, 0.00298293f, 0.00049092f, 0.00590622f, 0.02202700f, 0.10252926f, 0.03675721f, 0.03002188f, 
    -0.18036440f, -0.06412362f, 0.09007549f, 0.16786818f, 0.07973377f, -0.11878077f, -0.22477126f, 0.01767330f, 
    0.38397661f, -0.01698026f, 0.22294705f, 0.01867506f, -0.03446763f, 0.16091914f, -0.04713305f, 0.13709234f, 
    -0.11846288f, 0.16894105f, -0.23215914f, -0.12696497f, 0.00112109f, 0.05855969f, -0.04070016f, 0.09339224f, 
    0.04945368f, -0.22598879f, -0.15290470f, 0.18312007f, -0.13358553f, 0.02395697f, -0.08565582f, 0.15260111f, 
    0.01959142f, -0.12976503f, -0.10284406f, 0.17232548f, 0.19011445f, -0.06587532f, -0.06691796f, -0.04824302f, 
    0.06325894f, -0.01063024f, 0.04680705f, 0.11082125f, 0.30879521f, -0.03044437f, -0.17873557f, -0.04986806f, 
    0.16117787f, 0.06492154f, -0.10046746f, -0.14566305f, -0.07029992f, 0.18933582f, 0.07428887f, -0.22319295f, 
    0.00944328f, -0.13948780f, 0.17484783f, 0.13295604f, 0.25443235f, 0.11772965f, -0.13680826f, 0.15610465f, 
    -0.03564830f, -0.05482670f, 0.02154559f, 0.04243677f, 0.01671397f, 0.06260232f, -0.05678571f, 0.11871406f, 
    0.15811962f, -0.09397911f, 0.01810069f, -0.01900513f, 0.04781097f, -0.02057078f, 0.07225323f, 0.05347040f, 
    -0.00665146f, 0.03397613f, -0.02668158f, 0.04529313f, -0.03914262f, 0.04691745f, -0.03883424f, -0.06189233f, 
    0.05103382f, 0.04879618f, -0.00563486f, 0.04551352f, -0.03044585f, -0.02668354f, 0.04366307f, -0.01293488f, 
    -0.03305268f, -0.02180623f, -0.02469244f, -0.06436943f, -0.02448005f, 0.03405533f, -0.00394886f, -0.03273343f, 
    0.01965450f, -0.04515133f, 0.03564469f, 0.00304220f, 0.04163662f, 0.04496709f, -0.04703909f, 0.03623429f, 
    0.05322464f, 0.04520052f, -0.03125122f, -0.01246473f, -0.04823698f, -0.04654888f, -0.00611885f, -0.04786182f, 
    -0.05604356f, 0.02631059f, 0.00851035f, 0.00501241f, 0.00887865f, -0.01366231f, -0.03365425f, -0.05020763f, 
    -0.05767322f, -0.05647427f, -0.02032226f, 0.02776347f, 0.04588781f, 0.00154238f, -0.00050414f, -0.00988243f, 
    0.04348786f, -0.06202673f, 0.01834647f, 0.00656411f, -0.03525747f, -0.02982550f, -0.02009179f, -0.02570894f, 
    -0.06012109f, 0.02629717f, 0.01430772f, -0.02048986f, -0.02226888f, 0.01850462f, -0.03509252f, -0.00133646f, 
    -0.04394107f, -0.06416671f, 0.02090104f, -0.02251136f, 0.04052078f, 0.01323926f, -0.02632609f, -0.05166107f, 
    0.02982292f, -0.05398868f, -0.05939581f, -0.02353389f, -0.02340542f, -0.06144539f, 0.02999532f, -0.03162638f, 
    -0.05563419f, -0.03096628f, -0.00532990f, 0.01543364f, 0.00474818f, 0.04605426f, -0.06141550f, -0.04941420f, 
    0.03073403f, 0.01765731f, -0.03172350f, -0.01729100f, 0.02336209f, 0.00743951f, 0.01072695f, -0.06190134f, 
    0.03091932f, -0.06349810f, -0.03241505f, 0.02407949f, 0.04419070f, -0.00757120f, 0.01484410f, 0.02884504f, 
    0.00985908f, 0.04887187f, -0.02511567f, 0.05332758f, -0.06388941f, -0.02926994f, 0.00528893f, 0.00939088f, 
    0.04372849f, -0.05432025f, -0.01430785f, -0.00038246f, -0.00239236f, 0.00452820f, -0.03949167f, 0.04002544f, 
    -0.06455548f, -0.02653051f, -0.05663597f, -0.04192160f, -0.05707487f, 0.02106119f, -0.01591010f, -0.01419917f, 
    -0.01571857f, -0.04730070f, 0.01083961f, -0.05079051f, -0.06080402f, -0.02491320f, -0.00353592f, -0.04771783f, 
    -0.00002503f, -0.04123463f, -0.01329836f, -0.03364697f, -0.00177024f, -0.00185863f, -0.04872093f, -0.05948376f, 
    0.04259220f, 0.04903329f, -0.01924923f, -0.06739343f, -0.04258521f, 0.04879276f, 0.02740097f, -0.06388865f, 
    0.03933197f, -0.00430107f, -0.03525889f, 0.02183240f, 0.04340202f, 0.03177934f, -0.05705023f, 0.01053952f, 
    -0.03014855f, -0.04157398f, 0.03082422f, 0.02757493f, 0.00777645f, 0.04101307f, -0.00078591f, -0.01714310f, 
    -0.03738957f, 0.04384083f, -0.01044536f, 0.02400055f, 0.04476153f, -0.05492294f, -0.02953735f, 0.00610943f, 
    -0.02447090f, -0.05676285f, 0.01164316f, 0.00161901f, 0.00345932f, -0.02328730f, 0.03192389f, 0.00659957f, 
    0.04792607f, -0.02039122f, 0.01847551f, -0.04492696f, -0.06148729f, -0.03523576f, -0.00474314f, -0.03748425f, 
    0.03173325f, 0.03496956f, -0.04294095f, -0.05270259f, -0.05315009f, -0.01551014f, -0.06311836f, 0.03683408f, 
    -0.00801601f, 0.03203500f, 0.02773550f, -0.05726724f, 0.04019909f, -0.00487518f, -0.05395845f, -0.02722413f, 
    0.01984284f, -0.04444410f, 0.00485715f, -0.06450905f, 0.01121941f, 0.04399441f, 0.04631713f, 0.01387533f, 
    0.01109380f, -0.01656138f, -0.06216615f, 0.02307623f, -0.06348811f, 0.05099547f, 0.03694855f, -0.06189909f, 
    -0.03769424f, 0.00356928f, -0.05680740f, -0.06341115f, -0.04548907f, -0.01540602f, -0.03687131f, -0.00614875f, 
    -0.03174896f, 0.02807897f, -0.04020939f, -0.06217660f, -0.01948608f, 0.02207401f, 0.03503080f, 0.02461846f, 
    0.04736120f, -0.03952861f, -0.00154264f, 0.00748002f, -0.02680984f, -0.00891903f, 0.01552484f, 0.03929523f, 
    -0.04755248f, 0.02578292f, -0.02191639f, 0.02097321f, -0.04549358f, 0.01065813f, -0.05216354f, -0.04457926f, 
    -0.03140410f, -0.01574571f, -0.05973244f, -0.01636673f, 0.02911709f, 0.01903404f, 0.04813644f, 0.00682838f, 
    0.02294224f, 0.04772034f, 0.03763444f, 0.01409035f, 0.00148857f, -0.04064320f, -0.00634177f, -0.05807032f, 
    0.03395750f, -0.02453172f, 0.02998034f, 0.02460967f, 0.03112813f, -0.02292787f, -0.00272309f, 0.01698324f, 
    0.01267690f, 0.01096179f, -0.03908109f, 0.04304874f, -0.00405721f, -0.05901096f, -0.00683489f, 0.04689936f, 
    -0.05506481f, -0.04281598f, -0.04647496f, 0.00976179f, -0.04274928f, -0.02173368f, 0.03836394f, 0.04183878f, 
    -0.00995715f, 0.01458081f, -0.03177046f, -0.05462059f, 0.01139553f, -0.06100411f, 0.02133399f, 0.04372400f, 
    -0.00863565f, -0.01554778f, 0.04423916f, 0.02273402f, 0.01015074f, -0.05613476f, -0.00450591f, 0.00526083f, 
    0.00519906f, 0.04699329f, -0.01703569f, 0.04929544f, -0.02565042f, -0.01528417f, 0.00821734f, -0.03291827f, 
    -0.04621528f, 0.03776811f, -0.05650643f, -0.04375720f, 0.01679991f, -0.00933519f, -0.03624154f, 0.04021192f, 
    0.03806866f, -0.00473369f, -0.04383626f, 0.03569732f, -0.00124761f, -0.01645025f, -0.01745749f, -0.01322873f, 
    -0.03362932f, -0.05165005f, -0.07092586f, -0.06086627f, -0.04995519f, 0.02943975f, -0.01782540f, -0.03549540f, 
    0.00163324f, -0.03712188f, -0.00534870f, -0.02386858f, 0.00583460f, 0.02582437f, -0.03251813f, 0.04039034f, 
    0.02827397f, -0.04637054f, -0.00545150f, 0.02406221f, -0.02578140f, -0.06595892f, -0.00867213f, 0.03748864f, 
    -0.03625580f, 0.00215416f, 0.01469231f, 0.04167630f, -0.05497018f, -0.04688183f, 0.00161149f, -0.01331902f, 
    -0.03479249f, -0.05567240f, -0.05176146f, -0.02428723f, 0.01663043f, 0.02399771f, 0.03384592f, -0.04876924f, 
    -0.00423446f, -0.00348450f, -0.01067490f, -0.00943992f, 0.03851019f, -0.03615623f, -0.06186357f, 0.00131339f, 
    0.03076643f, 0.02111773f, 0.02840310f, 0.03317572f, 0.03790964f, -0.00261950f, 0.02305797f, -0.04191487f, 
    0.04567114f, 0.03807762f, -0.04239707f, -0.02904646f, 0.01832758f, -0.04036539f, -0.02673241f, 0.01951292f, 
    -0.01871776f, 0.02815638f, 0.04002835f, 0.02971740f, -0.02476034f, 0.02429095f, -0.01831398f, -0.04749304f, 
    -0.06364077f, -0.00286063f, -0.03892885f, 0.03696533f, -0.03080077f, -0.06610953f, 0.02828072f, -0.02243094f, 
    0.03098761f, 0.00168124f, -0.01879096f, 0.04555108f, -0.04380990f, -0.05702490f, 0.00062691f, -0.04781105f, 
    0.01810480f, -0.05006118f, -0.02704127f, 0.03687175f, 0.00134380f, -0.04943220f, -0.02497194f, -0.00522580f, 
    0.01123178f, 0.04478575f, -0.01054926f, 0.02186304f, 0.04676056f, -0.01192215f, -0.03008761f, -0.06577177f, 
    0.01314345f, 0.01775346f, 0.05117505f, -0.03689644f, 0.03176814f, 0.00542813f, -0.04567973f, -0.01707239f, 
    0.01702812f, 0.04555676f, 0.02758665f, 0.04176279f, 0.04594742f, -0.00985989f, 0.00979233f, 0.02025266f, 
    -0.03608937f, 0.01716505f, 0.04314655f, -0.05568403f, -0.05780990f, 0.04120651f, 0.02927576f, 0.04124254f, 
    0.00191950f, 0.01091760f, 0.04127985f, -0.00683027f, -0.03867436f, 0.01279163f, -0.05542673f, -0.01240972f, 
    0.01051894f, 0.00232134f, 0.01880966f, -0.01664249f, -0.05034356f, 0.01540133f, -0.03777396f, 0.04034991f, 
    0.03353043f, 0.00355960f, -0.02551732f, -0.00653403f, -0.06193064f, 0.02594233f, -0.06031076f, -0.05429879f, 
    -0.04117204f, -0.04769629f, -0.05191905f, -0.04495926f, -0.01202660f, -0.04482215f, 0.02839521f, -0.00044713f, 
    0.03904624f, 0.00218370f, 0.00490586f, -0.03138607f, 0.02093131f, -0.02532060f, 0.02025484f, -0.01021388f, 
    -0.01826470f, -0.02706567f, -0.00164598f, 0.02933983f, -0.05577132f, -0.05693555f, 0.03644111f, -0.01862307f, 
    0.04461250f, 0.02948814f, -0.02753847f, 0.01123772f, -0.00057745f, -0.02004151f, -0.04759957f, 0.03162464f, 
    -0.04360200f, 0.02435727f, -0.00369155f, 0.04509407f, -0.04790135f, 0.02532557f, 0.00468315f, -0.02126542f, 
    -0.05817406f, 0.02858387f, 0.00118013f, 0.02895210f, -0.00775903f, -0.02620207f, 0.00704430f, -0.02661598f, 
    0.02212561f, -0.06143313f, 0.02618537f, 0.03688084f, 0.00848866f, 0.01590995f, -0.03356365f, -0.02918789f, 
    -0.02305717f, 0.00161141f, 0.00500576f, 0.04123751f, -0.06304538f, 0.04458064f, -0.03729505f, -0.01006436f, 
    0.04727327f, -0.05348581f, -0.01531985f, -0.04936019f, -0.06681990f, -0.01740105f, 0.02809964f, -0.02367949f, 
    -0.02098795f, -0.05861568f, -0.05114533f, -0.06032469f, -0.01912347f, -0.02512809f, 0.03926009f, -0.06052574f, 
    0.02574044f, -0.00005672f, 0.00243673f, -0.00187782f, -0.00682296f, -0.06412100f, -0.05697482f, 0.02725086f, 
    0.00272877f, -0.03586693f, 0.01647974f, 0.04192396f, -0.00170102f, -0.04109721f, -0.03939626f, -0.04315715f, 
    -0.05934013f, 0.01369810f, -0.03762370f, -0.04204619f, -0.02851361f, -0.03360616f, 0.04400095f, -0.02394677f, 
    0.04628567f, -0.02396512f, -0.03019803f, 0.03746892f, 0.04923287f, -0.03161063f, 0.01893880f, 0.00456116f, 
    0.04965211f, 0.02130812f, 0.04743201f, 0.01170467f, 0.00973698f, 0.03522235f, 0.03597583f, 0.03290330f, 
    -0.01304419f, -0.02642969f, -0.05020301f, 0.00452179f, 0.01695783f, -0.06365914f, 0.04508958f, 0.03835287f, 
    0.04312140f, -0.02176654f, 0.03246616f, -0.05810895f, -0.05235633f, -0.03626000f, -0.06194572f, 0.01228655f, 
    -0.05050409f, 0.00602454f, -0.01998301f, 0.05185446f, -0.02314870f, 0.00027236f, 0.05006479f, -0.06349196f, 
    0.02437071f, 0.03259200f, -0.01696244f, -0.04426534f, 0.03337077f, -0.05975146f, 0.01962648f, -0.00642120f, 
    0.00838864f, 0.03383775f, 0.00781267f, 0.04351980f, -0.00458163f, -0.00723532f, -0.05474263f, -0.03869452f, 
    0.03396833f, 0.04252232f, -0.03856785f, 0.00216225f, -0.05910740f, -0.00068226f, -0.05930471f, -0.03158666f, 
    0.01644579f, -0.03458190f, 0.04568254f, -0.03684908f, 0.01463473f, 0.04830814f, -0.03830526f, -0.02745709f, 
    -0.04788033f, 0.04243158f, -0.02125028f, 0.03541285f, -0.00752096f, -0.04912270f, 0.03570146f, 0.00955444f, 
    0.02199607f, 0.00144943f, 0.00396944f, -0.02041545f, -0.02253177f, 0.01071598f, -0.03358349f, 0.01943325f, 
    -0.06213404f, -0.03719344f, 0.00042436f, 0.02759136f, -0.01352615f, -0.02082521f, -0.01229430f, -0.00924349f, 
    0.01401327f, -0.01469786f, 0.02309167f, 0.02969169f, -0.00565066f, -0.03322120f, 0.01891387f, 0.01640712f, 
    -0.05694839f, -0.00417600f, -0.05575205f, -0.01149697f, 0.00685246f, 0.00574750f, -0.00130943f, -0.06331152f, 
    0.04174995f, 0.03025558f, 0.02647208f, 0.00790345f, -0.05401189f, 0.03986538f, -0.03401924f, 0.00209421f, 
    0.05145378f, 0.01144904f, -0.03217753f, 0.04429287f, -0.03766353f, -0.01403321f, 0.00857970f, -0.01258487f, 
    -0.05286639f, 0.02202593f, 0.04490191f, 0.01499698f, 0.00424194f, -0.02830197f, -0.03507054f, -0.05648037f, 
    -0.03069300f, -0.05121368f, -0.00756906f, -0.04204209f, 0.00985125f, 0.02193880f, -0.05243469f, -0.00282116f, 
    -0.02929886f, -0.04898816f, 0.02979007f, -0.02791779f, 0.01619747f, -0.04012115f, -0.01385204f, -0.05062651f, 
    0.04747359f, 0.02948442f, -0.05475805f, 0.05144522f, 0.01236860f, 0.01767545f, -0.03997697f, 0.00193063f, 
    -0.01625085f, 0.03948938f, -0.02075621f, 0.02882838f, 0.01832982f, -0.01659372f, 0.00468101f, 0.00254001f, 
    -0.02599745f, -0.06532215f, 0.02710380f, -0.03588438f, -0.00218781f, -0.03911491f, -0.04648820f, -0.01056689f, 
    -0.01725751f, -0.04215270f, -0.03041781f, -0.02698273f, -0.02493296f, -0.01021869f, 0.04717866f, 0.02012624f, 
    -0.02760677f, -0.04733740f, -0.03691306f, -0.02790355f, 0.04452702f, 0.02580250f, 0.00498544f, -0.05389294f, 
    -0.00771370f, 0.03590044f, -0.03001145f, -0.03664240f, -0.05725653f, 0.00536834f, -0.02896568f, -0.03344614f, 
    0.04632632f, 0.04033300f, 0.01173365f, -0.01649756f, -0.03160660f, -0.05803302f, -0.03174781f, 0.02559537f, 
    -0.01860640f, -0.04718940f, -0.03338462f, 0.04526613f, 0.04961526f, -0.04408685f, -0.00557015f, 0.00105282f, 
    -0.02132365f, 0.02442113f, -0.00441285f, -0.04229118f, 0.02611183f, -0.04627908f, 0.00456019f, -0.01004620f, 
    -0.05692793f, 0.01215673f, 0.02677288f, -0.05851663f, -0.01191613f, -0.02783326f, -0.04966334f, -0.05393429f, 
    -0.05313598f, 0.03966283f, 0.05526723f, 0.04884533f, -0.00069246f, 0.01145852f, -0.01019305f, 0.01230141f, 
    -0.06452660f, -0.03628124f, -0.00816867f, -0.00633730f, 0.02869481f, -0.00487132f, -0.03767642f, 0.02959810f, 
    0.01902809f, -0.03793460f, -0.00096986f, -0.03807047f, 0.04526069f, 0.02731270f, 0.00759177f, 0.00021106f, 
    -0.00619137f, -0.01673608f, 0.00416622f, -0.03356095f, 0.02267594f, -0.01681437f, 0.04529954f, -0.05958751f, 
    -0.09017891f, -0.04763774f, -0.29273024f, 0.12490147f, 0.00521903f, 0.31033078f, 0.06799764f, -0.10707486f, 
    -0.14548072f, -0.02900924f, -0.19861366f, -0.15918340f, -0.10128321f, -0.02731724f, 0.04890487f, 0.13708855f, 
    0.05171203f, 0.00987425f, 0.08897792f, -0.17193335f, -0.14475714f, -0.01664537f, -0.03808887f, -0.10624940f, 
    0.10454929f, -0.05613016f, 0.10512909f, -0.00330220f, -0.03410798f, 0.11069156f, 0.18558283f, -0.01050308f, 
    0.03194429f, 0.04323091f, 0.00436668f, 0.00780576f, -0.09949654f, 0.03966295f, -0.03967266f, 0.08265333f, 
    -0.00758191f, -0.03958504f, 0.14298970f, 0.06126283f, 0.18332282f, 0.19934590f, 0.12124678f, -0.03935528f, 
    -0.06331614f, 0.07501224f, -0.22653878f, 0.12685673f, -0.16435272f, 0.02144028f, 0.09200429f, 0.03418982f, 
    -0.24276881f, 0.05550210f, 0.03410243f, -0.19301182f, -0.04029615f, -0.14833295f, 0.11911657f, -0.17692162f, 
    -0.35343674f, -0.20780085f, 0.04592933f, 0.11425307f, 0.00946574f, 0.12875666f, 0.02798983f, 0.16729668f, 
    0.17613794f, 0.01984442f, -0.10007773f, 0.06650878f, 0.03577019f, -0.10622212f, 0.07478958f, 0.00484193f, 
    0.29608080f, -0.00773917f, 0.16213405f, 0.00080150f, 0.02817431f, -0.01117016f, 0.12851574f, -0.00207959f, 
    0.05959466f, 0.17031078f, -0.02704681f, -0.08976998f, 0.00232734f, -0.10071208f, 0.04869434f, 0.13533844f, 
    0.15615985f, -0.05920950f, -0.16251288f, -0.13682830f, -0.16456391f, -0.20057157f, -0.05342192f, 0.01794486f, 
    0.13320613f, 0.18516918f, -0.19630729f, 0.00087179f, 0.03038848f, -0.00954638f, -0.06918521f, -0.04505134f, 
    0.11736699f, 0.01661891f, -0.07154125f, -0.03125320f, 0.13623402f, -0.01057346f, 0.33532605f, 0.04057449f, 
    0.06289947f, 0.02931886f, -0.02874921f, 0.13104276f, -0.14665142f, 0.04701700f, -0.02408614f, -0.04656649f, 
    0.04940877f, 0.01991178f, -0.07352648f, -0.01044236f, 0.13548814f, 0.04295312f, 0.14738654f, 0.10904629f, 
    -0.04564134f, -0.25880384f, 0.01671893f, -0.16847742f, -0.09893893f, -0.08407203f, -0.00065808f, 0.17409623f, 
    -0.09702919f, -0.10618394f, -0.18196346f, -0.06913399f, -0.02003556f, 0.10130383f, -0.36432070f, 0.08748750f, 
    -0.20014493f, 0.15543382f, -0.00797952f, 0.05278303f, 0.01799504f, 0.07710779f, 0.10073430f, 0.06768247f, 
    -0.09517983f, -0.16317408f, -0.09171975f, 0.06051425f, 0.07725660f, -0.07768410f, 0.09666692f, 0.19656613f, 
    -0.03373863f, 0.05483585f, -0.12166446f, -0.08071857f, 0.13633057f, 0.13785066f, 0.04322541f, 0.04987508f, 
    -0.14614849f, 0.09591978f, -0.06182895f, 0.00503656f, -0.10341915f, -0.02191955f, 0.18269840f, -0.03685218f, 
    -0.06346130f, 0.10992438f, 0.05547834f, 0.11883751f, -0.04982132f, -0.13235383f, 0.09859871f, -0.01866230f, 
    0.28758124f, 0.12635893f, 0.02381895f, 0.11837603f, -0.02251871f, -0.01115849f, 0.09789730f, 0.06741274f, 
    0.02266022f, -0.01379325f, 0.04041743f, -0.02979840f, 0.22457026f, 0.07057195f, 0.21873070f, 0.13856915f, 
    -0.00158200f, 0.00926039f, -0.08506861f, -0.34871840f, -0.12732419f, 0.12420696f, 0.16979995f, 0.11610643f, 
    0.15106906f, -0.27028248f, 0.03496198f, -0.11082526f, 0.16356564f, 0.06893373f, 0.12653948f, -0.01571535f, 
    -0.10478553f, 0.04195703f, -0.01417975f, -0.15874144f, -0.00437419f, 0.07373475f, 0.07387783f, 0.12539598f, 
    0.11540554f, 0.10062104f, 0.03370506f, 0.12807913f, 0.05790943f, 0.21737726f, -0.19889347f, -0.06039998f, 
    0.02527385f, -0.02705367f, -0.03020788f, 0.05896511f, 0.11486997f, 0.04480151f, 0.05751742f, 0.18008015f, 
    0.09879348f, 0.02306063f, 0.00702570f, 0.04155779f, 0.12667447f, 0.10097511f, -0.04042703f, -0.08799843f, 
    -0.09998114f, -0.13331467f, -0.12588075f, 0.01788338f, 0.10121521f, 0.07774976f, 0.23887295f, -0.00532774f, 
    0.22347771f, 0.12980694f, -0.18062285f, 0.12830083f, -0.10978054f, 0.15941757f, -0.04371695f, 0.08077708f, 
    -0.05249754f, 0.29817674f, -0.09022591f, 0.00345462f, 0.08425815f, 0.08026229f, -0.13204429f, -0.01608691f, 
    0.18301353f, 0.23538788f, -0.08750477f, 0.16878095f, 0.04272553f, 0.23277982f, 0.02364972f, -0.05833822f, 
    -0.00375637f, 0.01799036f, 0.06816678f, -0.00896651f, 0.12292149f, -0.03176114f, 0.07259598f, 0.09985692f, 
    -0.15487078f, -0.00780076f, -0.21908571f, 0.13292947f, -0.02738820f, -0.10229593f, 0.01980549f, -0.02165450f, 
    -0.02674475f, 0.02375388f, -0.19320428f, -0.19757155f, -0.05032909f, 0.04694806f, 0.08364026f, 0.15014821f, 
    0.02131383f, 0.00151028f, 0.13048667f, 0.29694903f, -0.43545747f, -0.06675366f, -0.04188008f, 0.05459549f, 
    0.07846366f, -0.08599591f, -0.01931722f, -0.09498833f, -0.21684447f, -0.18208896f, 0.01989329f, 0.07855521f, 
    0.00354381f, 0.17332895f, -0.08753540f, 0.02310793f, 0.11712003f, -0.26198834f, -0.04158382f, -0.04272076f, 
    0.10951871f, 0.18024981f, -0.07159898f, -0.04196450f, 0.12472448f, -0.00591743f, -0.42345095f, -0.17122561f, 
    -0.24236245f, -0.07951346f, 0.14225471f, -0.08825649f, 0.12813620f, 0.03085208f, -0.08961479f, 0.09511771f, 
    0.14399108f, -0.08413994f, 0.00534631f, 0.01620568f, -0.10299955f, 0.04280183f, 0.15184224f, 0.04874786f, 
    -0.08800282f, -0.02341036f, -0.16353457f, 0.02917153f, 0.16987966f, 0.14520644f, -0.12758645f, -0.01671007f, 
    0.01852698f, -0.12104848f, 0.02002093f, 0.04440536f, -0.01877828f, 0.13430302f, -0.05250679f, -0.03054328f, 
    0.00032605f, 0.16829319f, 0.08397485f, 0.01317110f, 0.08632970f, -0.01855289f, -0.08694945f, 0.01614262f, 
    0.09413040f, 0.10667860f, 0.20584485f, -0.23188160f, 0.04293663f, 0.14706811f, -0.01844217f, -0.04272187f, 
    0.09188071f, 0.03247751f, -0.07735139f, 0.18578903f, 0.09102738f, -0.22239278f, -0.03466846f, -0.12028189f, 
    -0.02535602f, -0.06619252f, -0.07089155f, -0.00030818f, 0.06604344f, 0.10777232f, 0.13676028f, -0.12083141f, 
    -0.06162075f, 0.02768086f, 0.05858825f, -0.01581750f, 0.04140826f, -0.04212068f, 0.19722062f, 0.31394851f, 
    0.02984055f, -0.00382796f, -0.11618136f, -0.02028330f, 0.14327133f, -0.02106945f, -0.01518724f, 0.01241174f, 
    -0.10858917f, -0.04810202f, -0.08002523f, 0.05996271f, 0.01721015f, -0.06719888f, 0.09833571f, -0.01073129f, 
    -0.23040093f, -0.09148665f, 0.14879216f, -0.01442702f, -0.06617305f, -0.23596664f, -0.00667450f, 0.02650400f, 
    0.21973424f, 0.27287182f, 0.29257461f, -0.06451084f, -0.00926363f, -0.00445351f, -0.01624943f, 0.00243763f, 
    0.02356452f, -0.09514282f, -0.01709261f, -0.09494583f, -0.04689914f, 0.08346502f, -0.08300831f, 0.02710867f, 
    -0.06479871f, -0.00507059f, 0.04728597f, -0.20061292f, 0.02458444f, -0.22643234f, -0.06515353f, 0.07841562f, 
    0.04032908f, 0.02948057f, -0.02737553f, -0.00539409f, 0.04601901f, -0.35102251f, -0.02963712f, 0.05592908f, 
    -0.00006820f, 0.04720099f, -0.03197229f, -0.05752772f, -0.03164859f, 0.57326055f, 0.01495622f, 0.08914110f, 
    0.02936437f, 0.07645806f, -0.27299225f, 0.07121063f, 0.09764750f, -0.03043876f, -0.08187625f, -0.03573936f, 
    0.11898450f, -0.04764711f, -0.03083003f, 0.03956028f, -0.11848419f, -0.02387441f, 0.03748913f, -0.10052404f, 
    -0.29608127f, -0.34695697f, 0.08084217f, -0.06177872f, 0.02717520f, -0.08863941f, 0.10430624f, 0.01085668f, 
    -0.34461695f, 0.20447649f, -0.09782465f, 0.05698355f, -0.01587157f, -0.03795426f, -0.00647913f, 0.03007484f, 
    0.05163283f, -0.13509396f, 0.26414812f, -0.28439119f, 0.23795086f, 0.01290404f, 0.15550548f, 0.11817682f, 
    -0.00785211f, -0.11894522f, -0.08165342f, -0.00022915f, 0.11873256f, -0.01053659f, -0.04117455f, -0.01206193f, 
    0.07476594f, -0.17783280f, -0.07353392f, 0.03888559f, -0.08221990f, 0.00188296f, -0.02375724f, 0.01886559f, 
    0.03115927f, 0.02313852f, 0.05920535f, 0.10300443f, -0.03617016f, -0.10371444f, -0.19750756f, 0.00104330f, 
    0.04497810f, 0.05234209f, 0.06574091f, -0.02226187f, -0.19764809f, -0.32973677f, 0.01511336f, -0.09055471f, 
    0.00723033f, -0.02208861f, 0.01672856f, 0.07648856f, 0.00328931f, 0.01256814f, -0.18718201f, -0.02313709f, 
    0.23396306f, 0.06630953f, -0.11780031f, 0.02275599f, 0.01445971f, -0.08755873f, 0.12352907f, -0.05381258f, 
    -0.06702803f, -0.10181322f, 0.07548832f, -0.14200817f, -0.04693298f, 0.11312115f, -0.06644386f, 0.11292117f, 
    0.16473937f, 0.05886998f, -0.20689660f, -0.09397301f, -0.02060362f, 0.15611699f, 0.05055632f, 0.13872793f, 
    -0.08389796f, -0.13903674f, -0.05364728f, -0.18282275f, 0.02584930f, 0.00317886f, 0.18850951f, 0.00347955f, 
    0.14594057f, -0.02772290f, -0.05893835f, 0.00064877f, 0.02031966f, -0.06353194f, -0.16805319f, 0.01972644f, 
    0.03352723f, 0.02086339f, 0.00079060f, -0.09104171f, 0.08533919f, 0.05201848f, -0.05217190f, -0.03710065f, 
    -0.21783708f, 0.01938285f, 0.10296506f, 0.02915564f, -0.07468831f, -0.00072616f, 0.06030979f, -0.23398067f, 
    -0.16842185f, 0.00929263f, 0.20438458f, -0.08795893f, 0.05619237f, 0.11527362f, 0.07406428f, -0.01118053f, 
    -0.23686244f, -0.00633731f, -0.14021781f, 0.10879737f, 0.17965955f, -0.03191824f, -0.13985747f, -0.00362672f, 
    0.21491547f, 0.22481671f, -0.24731070f, -0.01124817f, 0.03266067f, 0.05238939f, -0.11997154f, -0.19319071f, 
    -0.31509286f, 0.05075023f, -0.04426316f, 0.07725672f, 0.01026729f, 0.03024490f, 0.04834110f, 0.22227509f, 
    0.08164976f, 0.00204427f, 0.05259662f, -0.03226645f, 0.03050051f, -0.11261597f, 0.08590192f, 0.11581345f, 
    0.11258914f, -0.21461911f, -0.02516635f, -0.20262870f, 0.10018554f, 0.11632591f, 0.07984100f, -0.06553113f, 
    0.00526603f, 0.01334131f, -0.13423003f, -0.05862555f, 0.22223115f, 0.11708154f, 0.05306210f, -0.14109622f, 
    -0.16051440f, -0.00373416f, -0.20199470f, -0.05482266f, -0.17935662f, -0.00622284f, 0.09738543f, -0.00635270f, 
    0.21663946f, -0.02692041f, 0.13871609f, -0.11959383f, -0.06511402f, 0.04730007f, 0.00880968f, -0.00818883f, 
    0.03854044f, -0.00432838f, 0.10270951f, -0.02370157f, -0.05721278f, 0.11254889f, 0.22300194f, 0.10639635f, 
    -0.02822368f, -0.14111324f, 0.12264588f, -0.10661799f, -0.07672663f, -0.12717855f, -0.00784821f, 0.15310287f, 
    -0.05038919f, -0.02749618f, 0.03202598f, 0.03205554f, -0.14447761f, -0.05058331f, 0.03632936f, 0.02300827f, 
    -0.32087740f, -0.16812012f, 0.20177802f, -0.05560644f, 0.02803588f, 0.13766994f, -0.05433462f, -0.05339066f, 
    -0.05756995f, -0.05489342f, -0.13611791f, -0.09567956f, 0.03395235f, 0.00902602f, 0.01771085f, 0.03676953f, 
    -0.00221618f, -0.10843322f, 0.14216796f, -0.09588864f, 0.24913983f, -0.02723383f, -0.02358888f, -0.12325869f, 
    -0.13770053f, -0.29008704f, 0.09204266f, -0.00134974f, 0.16879892f, -0.16397253f, 0.07313064f, -0.03097842f, 
    0.16248882f, 0.12300722f, -0.24990796f, -0.18899481f, 0.11119762f, 0.19845925f, -0.01195052f, 0.07942583f, 
    -0.06657869f, -0.10590326f, -0.09848762f, 0.13492133f, -0.08108505f, 0.17755277f, -0.01127305f, -0.11799061f, 
    0.02691662f, -0.01197123f, -0.03180424f, 0.04627476f, 0.18500623f, -0.16354845f, 0.13559404f, -0.05232758f, 
    0.23213662f, 0.16445948f, 0.08632928f, -0.22210324f, 0.04866951f, 0.20001574f, 0.02664591f, 0.10743732f, 
    0.02379068f, -0.04484716f, -0.02019859f, 0.02122753f, -0.02042904f, 0.15416700f, -0.01329345f, 0.20559548f, 
    0.11090901f, 0.03206559f, -0.09802812f, 0.07045116f, -0.10858833f, 0.20900786f, 0.08867460f, 0.20366713f, 
    -0.00201470f, -0.07763022f, -0.05894295f, -0.02082207f, 0.03007320f, 0.13937818f, -0.03610408f, 0.03941785f, 
    0.03225442f, 0.02582889f, -0.05391778f, 0.13690692f, 0.07859683f, -0.05660798f, -0.06361945f, 0.11585765f, 
    -0.00882049f, -0.04635967f, 0.04154397f, -0.02902417f, 0.13947175f, -0.01844356f, 0.08723769f, 0.12870589f, 
    -0.04826417f, 0.15146130f, 0.04594933f, 0.09368496f, -0.04106487f, -0.00563874f, -0.00281198f, 0.32669997f, 
    -0.12331148f, 0.09011883f, -0.12239357f, -0.02905620f, 0.04499732f, 0.07744467f, 0.00427925f, 0.02035033f, 
    -0.17590867f, 0.02553143f, -0.18678358f, 0.02493459f, -0.08798012f, 0.06939723f, 0.04159553f, 0.03902672f, 
    0.03496423f, -0.04032624f, -0.09098731f, 0.00033327f, 0.04919534f, 0.05371528f, -0.02810114f, -0.18610711f, 
    0.04833554f, -0.18074395f, 0.13313149f, 0.05109897f, -0.05159163f, -0.10261259f, 0.04170877f, 0.03435004f, 
    0.03965694f, 0.02514107f, 0.11638640f, 0.16151077f, -0.11582597f, 0.10657915f, -0.10525326f, -0.09290792f, 
    0.01818269f, -0.01289700f, -0.03471512f, -0.01590537f, 0.00212589f, -0.00351786f, -0.00275471f, 0.03852402f, 
    -0.04377100f, 0.01865435f, 0.04496605f, 0.01609334f, -0.06766137f, -0.06668702f, 0.00705375f, 0.01351116f, 
    -0.05617492f, -0.04804615f, -0.03706442f, -0.05112829f, -0.02373456f, 0.01039132f, -0.05626412f, 0.01657438f, 
    0.02041638f, 0.02535469f, -0.04831308f, 0.00448995f, -0.02224806f, -0.01207969f, -0.05683295f, -0.00508995f, 
    -0.05850615f, -0.02332745f, -0.05264682f, -0.00634896f, 0.02473674f, -0.00301361f, 0.03362181f, -0.04461204f, 
    -0.02822712f, 0.02262609f, -0.04734724f, -0.02377238f, 0.05611172f, 0.02775581f, 0.03749479f, 0.05468204f, 
    -0.05566891f, 0.00778904f, -0.05498209f, -0.05305764f, -0.05425350f, 0.01688102f, -0.02660870f, 0.00826363f, 
    -0.01882915f, -0.04775331f, -0.03977506f, 0.01970039f, 0.04481199f, 0.01431989f, -0.01260586f, -0.01160544f, 
    -0.01649276f, 0.05513278f, 0.01672921f, 0.04755996f, 0.04401192f, 0.04935545f, 0.00433655f, 0.01610374f, 
    -0.05084191f, -0.03705397f, -0.05144581f, -0.04052992f, -0.02137887f, -0.01730002f, 0.03539180f, 0.04312865f, 
    0.02264160f, 0.03495852f, -0.00388423f, -0.05741902f, -0.05238082f, -0.02293833f, 0.02595844f, -0.05488900f, 
    0.03511747f, 0.03946446f, -0.05894219f, 0.04563958f, 0.03271744f, -0.01178889f, -0.03532442f, -0.00450551f, 
    -0.03342266f, 0.02643760f, 0.04092448f, -0.03691335f, -0.05476077f, 0.02481550f, -0.04265777f, -0.00231297f, 
    -0.05993267f, -0.04478880f, -0.03230305f, -0.00640939f, -0.04576169f, 0.02907390f, -0.02823628f, -0.02979456f, 
    -0.02616273f, 0.02858620f, 0.01864716f, 0.00017484f, -0.00254081f, -0.05105684f, -0.01667088f, 0.02838467f, 
    0.04969366f, -0.05400391f, 0.04261879f, -0.02196836f, -0.05517773f, -0.05867215f, 0.02482911f, -0.04219898f, 
    -0.02959417f, -0.03039774f, -0.02866636f, -0.06043804f, -0.01258265f, -0.00856896f, -0.01849289f, -0.03975011f, 
    0.03587632f, -0.03810746f, 0.02379647f, 0.01264231f, 0.02660936f, -0.05913669f, -0.05321437f, -0.00058973f, 
    -0.01521706f, 0.03830446f, 0.01513766f, -0.00510383f, -0.05040731f, -0.06423379f, 0.02459102f, 0.04436660f, 
    0.02620196f, 0.03339149f, -0.05068343f, 0.03967978f, 0.03712818f, -0.00476111f, 0.02366734f, 0.00213136f, 
    0.00054659f, -0.02393532f, 0.02389206f, -0.05923437f, -0.05850900f, 0.04988472f, -0.01132214f, -0.00863939f, 
    0.02911594f, -0.04125150f, -0.06399398f, -0.05672999f, -0.00983452f, -0.01470112f, 0.02630591f, 0.04225354f, 
    -0.04236992f, -0.01627752f, -0.01352263f, -0.01202008f, -0.05898974f, 0.01230817f, 0.02373123f, -0.06110510f, 
    -0.02890451f, 0.03376922f, -0.01618287f, -0.05634449f, 0.03391022f, -0.03367657f, 0.02297292f, 0.01120598f, 
    -0.04202129f, 0.00834547f, 0.00138846f, 0.00285038f, -0.02352367f, -0.03571304f, -0.05491267f, 0.01774048f, 
    -0.03197410f, 0.02969144f, -0.01716423f, -0.02815211f, -0.05318162f, -0.00099644f, -0.00139148f, 0.02627562f, 
    -0.03951703f, -0.05336140f, 0.00482701f, 0.00804040f, -0.01091116f, -0.02838262f, 0.03831042f, -0.04447988f, 
    -0.06588303f, 0.03601751f, -0.04241984f, -0.00011694f, -0.06079158f, 0.00419048f, -0.03714762f, -0.06038633f, 
    0.02008324f, -0.00983016f, -0.03399582f, -0.05730562f, -0.03303989f, -0.02641103f, 0.01557291f, -0.05374718f, 
    -0.00612611f, 0.00452409f, 0.00174502f, -0.03072043f, -0.02038111f, -0.06533936f, 0.00855964f, 0.04198058f, 
    -0.06511117f, -0.00364290f, -0.03813232f, 0.04023443f, 0.04055756f, 0.00714602f, 0.01628209f, -0.02013549f, 
    -0.00738574f, -0.03893739f, -0.04883130f, -0.01740531f, -0.04070596f, 0.00513296f, -0.03529868f, 0.03962452f, 
    -0.03413492f, -0.01861744f, 0.03927755f, 0.01580920f, 0.03970721f, -0.04324360f, 0.02224432f, -0.01621660f, 
    -0.04386153f, -0.04004724f, -0.01390803f, 0.04261661f, -0.01278310f, -0.04557220f, 0.03026627f, -0.03091048f, 
    0.02494511f, -0.05303570f, -0.00056367f, -0.04349408f, 0.01975569f, -0.02926180f, -0.02490678f, -0.01600653f, 
    -0.03380406f, -0.03028991f, 0.03752235f, 0.03602448f, -0.06412531f, -0.02854103f, -0.02951727f, -0.04929461f, 
    0.35030776f, 0.08427423f, -0.03522689f, 0.06809314f, -0.09069815f, -0.07902848f, 0.16040872f, 0.07548130f, 
    0.03196671f, 0.14613703f, 0.11034689f, -0.14907283f, -0.11655558f, -0.23114705f, 0.06396618f, -0.17781873f, 
    0.01681060f, -0.05231595f, -0.01804603f, -0.02136451f, 0.06515963f, -0.01291022f, -0.05561846f, -0.15192699f, 
    0.04179703f, -0.04825567f, -0.03280922f, -0.05338326f, -0.05352053f, -0.13613974f, -0.06020197f, 0.12456945f, 
    -0.00050312f, -0.03871144f, 0.02116547f, 0.03816279f, 0.04117524f, -0.16079190f, 0.34407234f, 0.03226404f, 
    -0.10034408f, -0.08193361f, -0.00783110f, 0.06808510f, -0.03918855f, 0.16060573f, -0.03705744f, 0.08625321f, 
    -0.02183142f, 0.03063035f, -0.18978818f, 0.05439130f, 0.18073958f, -0.22260799f, -0.10133498f, 0.12192090f, 
    0.07727968f, -0.04739067f, -0.32948890f, 0.02242565f, 0.10052454f, -0.08681189f, 0.15553249f, -0.14405861f, 
    -0.39446709f, 0.34592941f, 0.10879593f, 0.05816307f, 0.29701215f, -0.14663923f, -0.12616186f, 0.03362277f, 
    -0.00010163f, 0.12399256f, 0.30323511f, 0.12025254f, -0.03745471f, -0.15264405f, -0.04579793f, 0.01162174f, 
    0.05072740f, 0.06872835f, 0.01844734f, -0.18399155f, -0.14244224f, -0.09280885f, 0.13679749f, 0.08442806f, 
    -0.02834776f, 0.03075527f, 0.05990026f, -0.20511810f, 0.18220067f, -0.02716188f, -0.05843836f, -0.03599902f, 
    0.11080869f, -0.02791338f, -0.08665004f, -0.20889294f, -0.14366223f, 0.08244913f, 0.07826380f, -0.05107164f, 
    0.10135006f, 0.09285983f, -0.11560947f, 0.03908411f, -0.11917102f, 0.12266036f, -0.08554035f, 0.01011156f, 
    -0.20228800f, 0.08444355f, -0.11005858f, -0.18801354f, 0.10522892f, -0.23172310f, 0.12214356f, 0.07044712f, 
    -0.00729538f, -0.04033348f, 0.10811110f, 0.09230683f, -0.11763204f, 0.04745812f, -0.03958245f, -0.17665298f, 
    0.08211833f, 0.03329856f, -0.09869273f, 0.21983826f, 0.09101357f, 0.11330582f, -0.01305956f, 0.21950305f, 
    -0.17061472f, -0.16176286f, -0.13403325f, -0.13196826f, -0.01261485f, 0.12698890f, 0.05600523f, -0.05796854f, 
    0.01332248f, 0.04351482f, 0.02744501f, -0.07194073f, -0.05138297f, 0.14249040f, 0.10619384f, -0.09886370f, 
    0.10807351f, 0.06300168f, -0.04306810f, 0.05974203f, 0.13932459f, -0.03190289f, -0.00561283f, -0.07973236f, 
    -0.03588561f, -0.02613163f, -0.09404581f, -0.03152385f, -0.02661969f, 0.02692764f, 0.11821190f, -0.07570817f, 
    -0.03569493f, 0.06884604f, 0.09208889f, 0.08049810f, -0.12228890f, 0.17971104f, 0.09819844f, 0.12289353f, 
    -0.15019518f, 0.01321016f, -0.01297855f, 0.08145263f, -0.12853612f, -0.01330161f, 0.09577340f, -0.02923056f, 
    0.02602759f, -0.03973763f, -0.10766333f, -0.11273494f, 0.12137412f, -0.09699433f, 0.09733053f, 0.22626837f, 
    -0.03834115f, 0.10978002f, 0.07452412f, 0.00937517f, 0.11839961f, 0.03950810f, 0.01203986f, 0.02651731f, 
    0.01397399f, -0.10488255f, -0.12899078f, 0.17673667f, -0.05972444f, 0.00062418f, 0.11902201f, -0.00748775f, 
    -0.14201379f, -0.10018322f, -0.03713671f, 0.19892445f, 0.00104199f, -0.01035034f, -0.14574504f, 0.21876067f, 
    -0.01948438f, 0.04600485f, 0.13061327f, -0.02335260f, -0.02735287f, 0.00602003f, -0.04739849f, -0.10977081f, 
    0.06613962f, -0.06568795f, -0.18910496f, 0.18653591f, 0.05072071f, -0.03897237f, -0.03068794f, 0.06030764f, 
    0.13794000f, 0.00257754f, -0.08466940f, 0.11463646f, 0.20792349f, 0.04890780f, 0.01862070f, -0.22448544f, 
    -0.15079498f, -0.17789164f, 0.01431574f, 0.01072442f, -0.07423783f, 0.08504777f, -0.06459690f, 0.15053369f, 
    0.15313913f, 0.05629688f, 0.02419775f, -0.16802858f, 0.18142042f, 0.06639913f, 0.14572088f, -0.03357983f, 
    -0.05790951f, -0.05697724f, -0.18749537f, -0.01994843f, 0.05171072f, -0.15733489f, 0.02141065f, 0.01994629f, 
    -0.08298527f, 0.00314775f, -0.25606695f, 0.06629790f, 0.24074695f, -0.09274648f, -0.20758477f, 0.01808658f, 
    0.08654217f, -0.02631523f, 0.07961710f, -0.09204177f, -0.04173065f, 0.03288735f, -0.00466035f, -0.01341343f, 
    0.15565997f, 0.03213227f, -0.05352793f, 0.03530268f, 0.06479507f, 0.10731016f, -0.00259376f, 0.18302371f, 
    -0.05252909f, -0.03556153f, 0.00343668f, -0.02506116f, 0.02719753f, -0.02449654f, 0.04193665f, -0.01006171f, 
    0.01975483f, 0.02274528f, -0.00805841f, 0.02591777f, -0.01575921f, -0.08204868f, 0.04121003f, -0.02747290f, 
    0.05781062f, -0.05862431f, -0.04788146f, 0.02810045f, 0.00910916f, -0.03301276f, -0.06362423f, -0.04134822f, 
    -0.05703212f, 0.03513155f, -0.00830636f, -0.01148804f, 0.01980694f, -0.01327938f, 0.01516098f, -0.02800876f, 
    -0.01108301f, 0.03462803f, -0.06542424f, -0.03894854f, 0.04549738f, 0.01008789f, -0.02340780f, 0.00217381f, 
    -0.01117981f, -0.03139691f, -0.03210692f, -0.02001626f, -0.05557813f, 0.01132973f, -0.00384953f, -0.05778968f, 
    0.00640200f, 0.03772596f, 0.01273546f, -0.01888364f, 0.01709190f, 0.03514668f, 0.02980177f, -0.05707977f, 
    -0.03938112f, -0.01754046f, -0.04128130f, -0.01443308f, -0.05096984f, -0.03423346f, 0.02859823f, -0.04187311f, 
    0.02300473f, -0.01887201f, -0.04165575f, -0.05468813f, -0.03398565f, -0.04813956f, -0.02195635f, 0.00083949f, 
    -0.02915225f, 0.00329494f, 0.01234906f, -0.03757695f, 0.04926495f, -0.00961417f, -0.04517742f, 0.02370752f, 
    0.03928689f, -0.05777946f, -0.01813365f, -0.04505012f, -0.02467199f, -0.05036849f, -0.01791102f, -0.05981010f, 
    0.00036167f, 0.00790107f, -0.06229422f, 0.04725067f, -0.02443229f, 0.00146117f, 0.01406571f, -0.04563945f, 
    0.01811453f, -0.01804379f, 0.03809552f, -0.05004112f, 0.00314239f, -0.00912763f, -0.00486544f, -0.05128968f, 
    -0.00871542f, -0.04138215f, -0.06283324f, 0.02640107f, -0.02975474f, -0.00612609f, 0.03943808f, 0.02493528f, 
    0.03238281f, -0.02775156f, 0.03563243f, -0.03727003f, -0.00652350f, -0.01145443f, 0.04447340f, -0.01233798f, 
    -0.03515287f, 0.00857838f, -0.03921498f, 0.00314404f, -0.00182564f, 0.04930599f, 0.01270794f, 0.02688280f, 
    -0.03726890f, 0.04086525f, 0.03141551f, -0.01704545f, -0.00940430f, -0.02699091f, -0.01591357f, -0.06637175f, 
    0.02350950f, 0.02937746f, -0.04353842f, 0.00790535f, 0.02597213f, -0.02208812f, 0.00705066f, 0.00953512f, 
    -0.03964124f, 0.03143261f, -0.04544450f, -0.05327231f, 0.00765430f, -0.01058225f, -0.05660004f, -0.00795562f, 
    0.05853005f, -0.02181883f, -0.01729350f, -0.01014907f, 0.03850456f, -0.05961964f, -0.04876538f, -0.02307517f, 
    -0.03223316f, -0.00164381f, 0.01990597f, -0.05596417f, -0.01844530f, -0.00768388f, -0.03453538f, -0.04067093f, 
    0.02983703f, 0.01876669f, -0.07001439f, 0.00506404f, 0.00228652f, 0.01768102f, -0.07056447f, 0.01981841f, 
    0.01107588f, -0.04189093f, 0.00045049f, 0.04185138f, -0.00971622f, -0.00879338f, 0.00418305f, 0.03013858f, 
    0.03412976f, -0.05128483f, 0.02070214f, -0.05613613f, 0.00118082f, -0.04683542f, 0.01988510f, -0.05564391f, 
    0.04414882f, 0.03736397f, -0.04456676f, -0.04264645f, 0.05858691f, 0.01737079f, 0.00164325f, 0.02729873f, 
    -0.01726424f, -0.00959040f, -0.05410382f, -0.02740643f, 0.04103203f, 0.05015617f, 0.04009825f, -0.03165838f, 
    0.01694307f, -0.03274537f, -0.01192556f, -0.02276626f, -0.05202166f, -0.06018837f, -0.00849539f, -0.04613417f, 
    -0.03978987f, -0.04818008f, 0.00008956f, -0.03305284f, -0.01172883f, -0.03388064f, 0.01632577f, -0.00312290f, 
    0.00283796f, -0.07249347f, -0.01799197f, -0.07257344f, -0.03670838f, 0.01773626f, -0.00710184f, -0.05724547f, 
    -0.04349994f, -0.06921968f, -0.01964478f, -0.03330187f, 0.04053172f, 0.00319729f, -0.05546029f, 0.00669720f, 
    -0.04813986f, 0.03285163f, 0.03936867f, -0.02011403f, 0.01074130f, -0.03816753f, -0.06726868f, -0.05128372f, 
    0.02932772f, 0.00835572f, -0.06077635f, -0.06499412f, 0.02706281f, 0.01679964f, -0.05478435f, 0.01247614f, 
    0.01136107f, -0.01334981f, 0.03063136f, -0.01248555f, 0.03765261f, 0.02268998f, -0.05946498f, 0.04668073f, 
    -0.05100608f, 0.04096613f, 0.00313482f, 0.00760570f, -0.03490420f, -0.04973587f, 0.04484045f, 0.02529931f, 
    0.02246073f, -0.02113223f, -0.01821058f, -0.03064070f, 0.03459066f, 0.02516774f, 0.01402471f, 0.04198739f, 
    -0.05254460f, -0.04962578f, -0.05420282f, -0.02803202f, -0.02644759f, 0.03841132f, -0.03859073f, 0.01008672f, 
    -0.02315018f, -0.03927429f, 0.02851489f, -0.00033007f, 0.04734658f, 0.04679415f, -0.05125578f, -0.01049406f, 
    0.04480178f, -0.03960660f, -0.05471427f, -0.04003683f, 0.03598845f, 0.04555513f, 0.04510391f, 0.04888885f, 
    -0.00511765f, -0.00382627f, -0.03808309f, 0.01980660f, -0.05140826f, -0.00209175f, -0.04585997f, -0.04017176f, 
    -0.05378192f, 0.02814101f, -0.02503763f, -0.02921868f, -0.01756472f, 0.04319885f, -0.00511560f, -0.02378221f, 
    -0.03347056f, 0.01021093f, -0.00164961f, -0.06325334f, 0.03044433f, 0.03329487f, -0.01702859f, 0.02990545f, 
    0.01270194f, -0.02737316f, -0.03866323f, 0.02355562f, -0.05560046f, -0.02235545f, 0.02924790f, 0.05068908f, 
    -0.04187849f, -0.03639600f, -0.01468902f, 0.02419266f, -0.02514466f, -0.03129645f, -0.01853611f, 0.02336486f, 
    0.04504468f, -0.03402170f, -0.04336494f, -0.00682345f, 0.02224626f, 0.02407027f, -0.01727675f, 0.01836851f, 
    0.04041418f, 0.02649817f, -0.02175732f, 0.02300204f, -0.06330100f, -0.05553452f, 0.02425343f, 0.01809769f, 
    0.04061208f, 0.01548282f, -0.01421286f, -0.01833614f, 0.00620425f, -0.04555524f, 0.05500795f, -0.06466837f, 
    -0.05274941f, 0.00540676f, -0.05892374f, 0.01994575f, -0.02161460f, -0.01279784f, -0.05593668f, -0.06766281f, 
    -0.05407655f, 0.02412594f, 0.02917013f, 0.00386458f, -0.00968388f, 0.00436170f, 0.04701930f, 0.03799079f, 
    -0.05286685f, 0.01853698f, 0.02766523f, -0.06398082f, 0.04125979f, -0.01695711f, 0.03789188f, 0.00724973f, 
    0.02506704f, 0.05290106f, -0.00649986f, 0.02977884f, -0.02900291f, 0.01154056f, -0.06356550f, -0.03953995f, 
    0.04705857f, -0.03710452f, 0.04607063f, -0.06207569f, -0.03166223f, -0.04634272f, -0.01543835f, 0.00506971f, 
    0.03769888f, 0.00107350f, 0.04135909f, -0.01684376f, -0.05916595f, 0.04231132f, -0.05546876f, -0.02727430f, 
    0.00112899f, -0.00285224f, -0.00718165f, -0.00115264f, 0.02499860f, 0.03659505f, -0.00247689f, -0.00732108f, 
    -0.02210346f, -0.03520041f, -0.04365568f, -0.05869586f, -0.06019450f, 0.02413732f, 0.03162633f, -0.03465179f, 
    0.03139744f, -0.02743129f, -0.00994175f, 0.00321989f, -0.05590701f, -0.05592675f, 0.00099566f, -0.02733936f, 
    -0.04166875f, -0.03698540f, -0.03468258f, 0.05711424f, 0.02723670f, -0.02311911f, -0.05446339f, -0.01466703f, 
    0.01695593f, -0.02477169f, -0.00553396f, -0.03642616f, -0.04144178f, 0.03724275f, -0.02246526f, 0.02737792f, 
    -0.06598246f, -0.00101475f, -0.05196358f, -0.03042088f, -0.01673749f, 0.01158879f, 0.03660775f, 0.04112940f, 
    0.00682936f, 0.01432351f, 0.03370973f, 0.02629716f, 0.03853264f, -0.02043276f, 0.02966933f, -0.04878775f, 
    0.04537178f, 0.04069658f, -0.01627118f, -0.03053289f, -0.02815598f, 0.05224586f, -0.06258529f, 0.03516595f, 
    -0.03118925f, 0.03558612f, 0.03538163f, 0.02751875f, -0.01579013f, 0.01972129f, 0.02142816f, -0.02107314f, 
    -0.00690943f, 0.01503319f, 0.04666521f, 0.00501456f, 0.03815039f, -0.03614275f, -0.04957537f, -0.06257591f, 
    0.01911472f, -0.03908568f, -0.03190991f, -0.01011558f, 0.01375949f, -0.00887187f, 0.04055797f, -0.02549064f, 
    -0.02629652f, -0.01660732f, -0.03189375f, 0.03571709f, -0.02654642f, 0.04121142f, -0.05510400f, -0.06146953f, 
    0.00801238f, -0.02382438f, -0.01776488f, 0.02852990f, -0.01874933f, 0.01880693f, -0.02269650f, -0.04924957f, 
    -0.02038061f, 0.04074347f, -0.02584158f, -0.05033867f, -0.04706132f, -0.05200643f, 0.02157769f, -0.00344430f, 
    -0.02294489f, 0.03846372f, -0.01628433f, -0.04384502f, -0.05509458f, -0.00244093f, 0.04905235f, 0.03257574f, 
    -0.01605025f, -0.02225883f, -0.06450167f, 0.03599300f, -0.02757005f, -0.01931019f, -0.05462601f, 0.01034129f, 
    -0.01372773f, -0.02273535f, -0.00425589f, -0.01138857f, -0.02312183f, -0.02791471f, -0.00714761f, -0.01415421f, 
    -0.01843798f, -0.03873878f, -0.03799809f, 0.00361187f, 0.03786134f, -0.01709381f, -0.06729442f, 0.04693647f, 
    -0.06392726f, 0.01122132f, 0.00021696f, 0.00498687f, 0.01572972f, 0.04055205f, -0.05430112f, -0.04222718f, 
    0.01022023f, 0.01841948f, -0.01815696f, 0.01003387f, 0.03293549f, 0.01597431f, 0.02682473f, -0.04182004f, 
    0.00541649f, -0.18545362f, -0.05622930f, 0.09950429f, 0.17667639f, -0.03587657f, -0.01862755f, -0.04336558f, 
    -0.05878933f, -0.22050200f, 0.01160700f, -0.05346524f, -0.21959166f, 0.10780071f, 0.12466577f, 0.03929702f, 
    0.10083387f, 0.19593257f, 0.13101016f, 0.10829072f, 0.15704988f, -0.01748014f, 0.02514068f, -0.05650142f, 
    0.21085374f, -0.16533822f, 0.06744702f, -0.07991017f, -0.13629793f, -0.04852621f, -0.07073877f, -0.03077782f, 
    -0.06579625f, -0.05204739f, -0.01860780f, 0.13348182f, -0.20115773f, 0.25427642f, -0.08649267f, 0.00481349f, 
    -0.05802954f, 0.02191523f, -0.07520472f, -0.11292573f, -0.13421384f, -0.01607130f, 0.22804374f, 0.13417435f, 
    0.05528211f, 0.09954274f, 0.04311578f, -0.00796044f, 0.05414743f, -0.03918749f, -0.04085781f, 0.04327104f, 
    0.08170808f, -0.07903563f, 0.13539146f, 0.22362161f, -0.18944767f, -0.13460688f, 0.02319857f, 0.08271427f, 
    0.09857692f, -0.06152787f, 0.02483971f, 0.08045480f, -0.02651931f, 0.05640171f, 0.16161868f, -0.02787117f, 
    0.10501884f, 0.25784349f, -0.11236878f, -0.07154329f, 0.11464220f, 0.08825684f, -0.10793880f, -0.09228645f, 
    -0.06313094f, -0.22397135f, -0.07894098f, -0.14448741f, -0.05523424f, 0.04782410f, 0.06114312f, 0.10123329f, 
    0.10697763f, -0.01731955f, -0.01349731f, -0.24515347f, -0.13328026f, 0.03984409f, 0.06300737f, 0.06586500f, 
    0.12002265f, 0.03500412f, 0.00874714f, 0.29691878f, 0.01860772f, -0.37919652f, -0.03641119f, -0.09596560f, 
    -0.05196231f, -0.09709547f, 0.12397952f, -0.01401821f, 0.04005375f, -0.08340485f, 0.21203962f, -0.03669958f, 
    0.01557152f, -0.01671033f, -0.07405885f, 0.01342275f, -0.06045543f, -0.24648476f, -0.09658482f, 0.23580216f, 
    0.11871915f, 0.07402562f, 0.07361352f, 0.10812227f, -0.11715955f, 0.02057481f, 0.06679760f, 0.06807143f, 
    -0.06704503f, -0.11173925f, 0.03709489f, -0.10724625f, 0.00673141f, 0.09059708f, -0.05248228f, -0.09065840f, 
    0.07089610f, -0.05093627f, -0.06441099f, 0.05183507f, -0.00661310f, -0.13693792f, 0.06611498f, 0.14129148f, 
    0.61568749f, -0.14160348f, -0.17535153f, 0.00384671f, -0.01675192f, -0.21638186f, -0.03507452f, 0.10915045f, 
    -0.07978202f, 0.04651293f, 0.19468676f, -0.09449917f, 0.00714113f, 0.07053605f, -0.20948265f, 0.02014922f, 
    0.01430159f, 0.06666365f, 0.08223163f, -0.17309903f, 0.13251552f, -0.05278639f, 0.12948650f, 0.08889667f, 
    -0.09760893f, -0.16354115f, -0.10822690f, -0.04590203f, -0.11206774f, 0.21546076f, 0.11103601f, -0.13085800f, 
    -0.08950916f, 0.07253583f, 0.01022270f, -0.03494998f, -0.07332665f, 0.23209617f, -0.11119971f, 0.00572458f, 
    0.04431847f, 0.18031792f, -0.10790861f, -0.02723269f, -0.01015043f, 0.18313701f, -0.01148059f, -0.13554369f, 
    0.20347370f, -0.01948052f, -0.07907204f, -0.02235181f, 0.09762226f, 0.01600939f, -0.40328261f, -0.17951500f, 
    0.01569218f, -0.16296923f, 0.01861069f, 0.14739405f, 0.02819459f, 0.12471741f, 0.09799425f, 0.54581666f, 
    -0.10898839f, -0.06815691f, 0.00842925f, -0.02928618f, -0.08510280f, 0.08393478f, -0.00889876f, 0.10523494f, 
    -0.06980176f, 0.10955900f, -0.01810293f, -0.10632925f, -0.08523478f, 0.01711589f, -0.06089581f, 0.16258161f, 
    0.00023352f, -0.11363710f, 0.27319548f, -0.09595207f, -0.01067036f, -0.01552445f, 0.17463739f, -0.04218619f, 
    0.08038458f, 0.09290759f, 0.30630130f, -0.50826734f, 0.07610452f, 0.07101046f, 0.04381774f, 0.04325344f, 
    -0.03456266f, 0.06447838f, 0.09860836f, -0.30684137f, -0.28762242f, 0.18229979f, 0.02857449f, 0.01248052f, 
    -0.06999230f, -0.03463926f, 0.01609252f, -0.02363129f, -0.01837266f, 0.18013549f, 0.05249549f, 0.17160441f, 
    -0.07605565f, -0.04244306f, -0.04035532f, -0.07094187f, -0.08391154f, -0.03314238f, -0.11012638f, 0.18347077f, 
    -0.02221258f, 0.11032771f, -0.00421981f, 0.09021669f, -0.05377241f, -0.03452565f, -0.01011562f, -0.64901412f, 
    -0.21217144f, 0.22018211f, 0.01889776f, 0.23961377f, -0.06360075f, -0.01256617f, -0.06455979f, -0.26582679f, 
    -0.35402191f, 0.12452713f, -0.07128897f, 0.09581713f, -0.09624374f, 0.11891513f, -0.02090496f, -0.10016120f, 
    -0.05948986f, -0.37995103f, -0.02959089f, 0.20646115f, 0.00346167f, -0.10986792f, -0.00264405f, 0.05938906f, 
    0.11795450f, -0.11024714f, -0.12163381f, -0.07960102f, 0.10519413f, -0.16622026f, 0.10333040f, -0.00305070f, 
    -0.01058337f, 0.17363617f, 0.15109736f, -0.10651881f, 0.01238243f, 0.02194262f, -0.10804234f, 0.04755384f, 
    0.10064939f, -0.10960834f, 0.10346939f, -0.27999234f, -0.15124999f, -0.07757127f, -0.00820635f, -0.13306627f, 
    -0.11456072f, 0.05046932f, -0.10684334f, -0.09455335f, 0.02952162f, 0.24757729f, 0.09085115f, -0.00647952f, 
    -0.09418924f, -0.23919010f, 0.01884227f, 0.07384397f, 0.00967529f, 0.13240151f, -0.05062605f, 0.07121182f, 
    -0.10294823f, -0.09139736f, 0.00871473f, -0.02115910f, 0.12364315f, -0.10310295f, 0.05649114f, 0.01945562f, 
    0.18117006f, -0.07084313f, -0.12911840f, 0.12174777f, -0.01760180f, 0.09261453f, -0.07941322f, 0.24546075f, 
    0.14832497f, 0.00863457f, -0.03301092f, -0.00917861f, -0.06808031f, 0.17186362f, 0.08281792f, -0.03210558f, 
    0.13719139f, 0.07478989f, -0.05575573f, 0.06670422f, 0.07029665f, 0.00168523f, 0.09186760f, -0.00837103f, 
    -0.06097519f, -0.11723080f, 0.02213910f, -0.13917160f, 0.02623919f, 0.03054429f, -0.06900277f, 0.19446357f, 
    -0.07137357f, 0.18920246f, -0.03275813f, -0.17214020f, -0.10903202f, 0.10913667f, 0.00699604f, 0.08417993f, 
    -0.01890080f, 0.03682517f, 0.26394278f, 0.18667363f, 0.07578545f, -0.29948315f, 0.18102542f, -0.30216637f, 
    -0.01862678f, 0.10751078f, 0.03828137f, -0.05487281f, -0.12405692f, -0.23189732f, 0.14899787f, 0.18858862f, 
    0.04755041f, -0.05273510f, -0.03673570f, -0.15363976f, -0.07948103f, -0.27357098f, 0.21682203f, -0.15421547f, 
    0.01041600f, 0.09665874f, 0.10832175f, 0.01841299f, 0.04554895f, 0.05573036f, 0.07701631f, 0.09920933f, 
    -0.00799781f, -0.11006875f, -0.10272459f, -0.02183560f, 0.03727574f, 0.09057622f, -0.03073987f, 0.20071723f, 
    0.16412057f, -0.00011959f, 0.16509357f, -0.25734198f, -0.04102229f, 0.06613095f, 0.19202545f, -0.14669687f, 
    0.23078215f, -0.14872842f, -0.28443524f, -0.03320304f, 0.07910316f, -0.25290325f, 0.16749638f, -0.05801507f, 
    0.02883745f, 0.02565568f, 0.24349484f, 0.01551680f, 0.00245027f, 0.06433029f, 0.03367663f, -0.02839015f, 
    -0.05706065f, 0.10145134f, -0.04325726f, 0.21548149f, -0.10179280f, -0.07527199f, 0.12485103f, 0.07187194f, 
    0.01406676f, 0.04746201f, 0.03571505f, 0.16842188f, -0.07668936f, 0.10266998f, -0.13923940f, -0.18293864f, 
    0.13589835f, -0.20412436f, -0.10749958f, 0.12721619f, -0.29966906f, 0.18126810f, 0.00722496f, 0.04747503f, 
    0.08085787f, -0.02916377f, -0.13783950f, 0.07291451f, 0.17021926f, 0.15303218f, 0.13993473f, -0.24888739f, 
    0.11536057f, -0.00165195f, -0.01599335f, 0.09608546f, -0.05649159f, -0.06425514f, -0.06585561f, 0.08759987f, 
    -0.00675933f, -0.10857347f, 0.01687584f, 0.15539563f, -0.01942080f, 0.05863498f, 0.09620839f, 0.43485123f, 
    -0.21894792f, -0.11075980f, 0.02894077f, -0.06410561f, -0.05540331f, -0.03302751f, 0.18952377f, -0.18649289f, 
    -0.13089074f, 0.14992820f, 0.19617209f, -0.10442038f, 0.07989085f, -0.07125796f, -0.01371401f, 0.05678504f, 
    0.21851122f, 0.09511618f, 0.15695028f, 0.05961609f, -0.09910250f, 0.08258541f, 0.12473857f, 0.05493262f, 
    0.07513312f, -0.15434702f, 0.18513280f, -0.19841076f, -0.00449953f, -0.18007617f, 0.01761570f, 0.12403669f, 
    0.09995156f, -0.00727717f, -0.08064158f, 0.07087199f, -0.09777652f, 0.07385420f, 0.04856454f, -0.03582767f, 
    -0.08934838f, 0.10482320f, -0.05346451f, 0.18288587f, 0.31677604f, 0.17601129f, 0.13721958f, -0.01149648f, 
    -0.03489886f, -0.02685757f, -0.05829210f, -0.15831962f, -0.20110397f, 0.07305551f, -0.24701396f, 0.01973188f, 
    -0.18502764f, 0.00962551f, 0.12617135f, 0.06283657f, 0.11755004f, -0.07488482f, 0.03213063f, -0.30907035f, 
    -0.13478044f, 0.11004700f, -0.19718730f, 0.16892402f, -0.17545430f, 0.10966244f, -0.02832192f, 0.08107512f, 
    0.05145870f, -0.03412425f, -0.14614984f, -0.03111750f, -0.10765915f, 0.15243024f, 0.10692710f, 0.15330835f, 
    0.11694686f, 0.16843988f, -0.10533751f, 0.17996545f, 0.10337219f, 0.04542653f, 0.00769623f, 0.02215341f, 
    -0.03409459f, 0.10527964f, 0.07576998f, -0.05114884f, -0.04965764f, -0.01907093f, -0.01534157f, -0.07969426f, 
    0.22075745f, -0.12291951f, 0.18574834f, 0.09278552f, 0.04774034f, 0.00375127f, 0.00710920f, 0.15072741f, 
    -0.24093008f, -0.06028462f, -0.03824858f, -0.10341137f, -0.15770142f, 0.18373425f, 0.02558059f, -0.05261950f, 
    0.19873255f, 0.03272369f, 0.01103254f, -0.24205905f, 0.25156572f, 0.29734996f, 0.14665571f, 0.07424837f, 
    0.10887882f, 0.05725610f, 0.02752518f, 0.06957723f, -0.11621299f, 0.29288208f, -0.05553925f, -0.12438972f, 
    -0.10168908f, -0.04190348f, 0.12886553f, -0.09233005f, 0.06840903f, -0.01280694f, 0.02735564f, 0.09602301f, 
    0.16380987f, 0.08311097f, 0.01779810f, -0.00360544f, -0.09719323f, 0.15877283f, -0.07517187f, 0.25971374f, 
    0.19166283f, 0.14270054f, 0.25266448f, 0.26065660f, 0.07577845f, 0.11739504f, 0.07372204f, -0.00433110f, 
    0.01250194f, 0.10358710f, 0.08775476f, -0.01457267f, 0.08642194f, 0.21321534f, -0.12153296f, -0.05032691f, 
    -0.21123174f, -0.06962181f, 0.03283450f, -0.03761198f, 0.05197716f, -0.12525815f, -0.12978674f, -0.01315226f, 
    -0.07288972f, 0.24996400f, 0.20354700f, -0.05025663f, 0.06283353f, -0.02269065f, -0.00050491f, -0.11751711f, 
    -0.06639241f, 0.07876330f, 0.14009278f, 0.11530277f, 0.23573841f, 0.01099568f, -0.01262570f, 0.05444812f, 
    0.15395974f, -0.04362580f, 0.15559401f, -0.07601494f, -0.27136657f, 0.00486421f, 0.06749506f, 0.02468980f, 
    0.05315291f, 0.02843675f, 0.14929414f, -0.00248635f, -0.17649479f, -0.29427469f, -0.28462484f, 0.02430292f, 
    0.10241990f, 0.18554688f, 0.05096536f, -0.06047833f, 0.01305453f, 0.13687295f, 0.06790655f, 0.29366434f, 
    0.27424547f, 0.10896706f, 0.07800567f, 0.17339037f, 0.04604618f, 0.19790858f, 0.03610655f, 0.20941986f, 
    0.36265716f, -0.00285671f, 0.02197908f, 0.06669094f, -0.01436478f, 0.02469161f, 0.00329199f, 0.17670141f, 
    -0.09945130f, -0.03409619f, -0.02841610f, 0.01799582f, -0.00657789f, -0.03685491f, 0.10079923f, -0.00774164f, 
    0.00196290f, -0.06010915f, -0.02876223f, 0.25264987f, 0.02231080f, 0.04960989f, 0.07642083f, 0.10985149f, 
    0.12244108f, -0.06513237f, 0.28062505f, -0.06942343f, 0.01973500f, 0.12897798f, 0.04327925f, -0.11254998f, 
    0.02292807f, -0.04821803f, 0.10649396f, 0.05328262f, -0.14493756f, 0.11122140f, -0.14304088f, -0.06725232f, 
    0.14399168f, -0.01464354f, -0.00861660f, -0.12371663f, 0.27064705f, -0.10934776f, 0.15761277f, 0.29522261f, 
    0.02644694f, 0.04302259f, -0.11697427f, -0.05513485f, 0.06485393f, -0.02935677f, -0.02835637f, 0.04019633f, 
    -0.04492167f, 0.08309560f, -0.13953516f, 0.24618018f, 0.15431343f, -0.03725313f, -0.20768338f, 0.11443696f, 
    -0.11923801f, -0.13547112f, -0.02034544f, -0.02029992f, -0.03204609f, 0.02497153f, -0.03062052f, -0.03898485f, 
    0.24418022f, 0.21282291f, 0.17514434f, -0.11319180f, -0.03094916f, -0.17127611f, 0.09242746f, -0.18384759f, 
    0.01288295f, -0.02292885f, 0.05285640f, 0.11266501f, 0.14194268f, 0.01316715f, 0.11628072f, -0.04729891f, 
    0.01232383f, 0.23595200f, 0.08765841f, 0.16994865f, 0.07613381f, 0.08592032f, 0.13977164f, 0.10004216f, 
    -0.00898068f, -0.19673137f, 0.09202161f, -0.10786876f, -0.08790553f, 0.02661471f, 0.04037640f, 0.09343760f, 
    -0.13252142f, 0.06485029f, -0.03115517f, 0.19455785f, -0.01076491f, -0.06671074f, 0.06153836f, -0.18176736f, 
    0.02735755f, 0.02008137f, -0.00169340f, 0.05427559f, 0.18228342f, 0.11530504f, 0.26451483f, 0.13012609f, 
    -0.00989934f, -0.04044180f, 0.15374903f, -0.11153439f, -0.00776049f, -0.03817737f, -0.28472060f, -0.11763195f, 
    0.01604389f, -0.12383392f, -0.08162179f, -0.09702977f, 0.03775947f, 0.00340275f, -0.04086639f, -0.03498221f, 
    -0.09851161f, 0.02292207f, 0.05165054f, -0.02029050f, -0.14734246f, 0.18325379f, -0.00614362f, 0.27102393f, 
    -0.14774017f, -0.06561770f, -0.08584858f, -0.18078108f, -0.05176675f, 0.04168528f, 0.04742865f, 0.02655901f, 
    0.61861014f, -0.09746155f, -0.19748521f, -0.09894434f, -0.18693933f, 0.00258667f, -0.01014869f, -0.15094282f, 
    0.04048177f, -0.18953590f, -0.25870451f, -0.19798450f, -0.01678788f, 0.02743930f, -0.24062812f, 0.13177066f, 
    -0.05608135f, 0.21471077f, -0.08156580f, 0.00970174f, -0.11700814f, -0.08274993f, 0.07108825f, -0.12229017f, 
    0.03694689f, 0.10681675f, 0.01084378f, -0.15532885f, 0.16736671f, 0.11991575f, -0.06347445f, 0.09020720f, 
    0.02147724f, -0.04898035f, -0.05007664f, -0.02244858f, 0.20429142f, -0.11802416f, 0.15419197f, 0.09187593f, 
    0.07621276f, 0.05192947f, -0.03436501f, -0.12430695f, 0.06376177f, 0.13914150f, -0.02906271f, -0.04751151f, 
    -0.19619675f, 0.00647129f, 0.18720141f, -0.19639404f, -0.09577228f, 0.18170139f, 0.16631983f, -0.42222935f, 
    0.12080733f, 0.08297756f, -0.08093205f, 0.05656761f, -0.12651333f, -0.01131035f, 0.04616746f, -0.12282896f, 
    0.09332670f, -0.29687402f, 0.20821464f, 0.14375050f, 0.00644972f, 0.06444352f, -0.05257032f, 0.07113916f, 
    0.09612039f, 0.09175506f, 0.08013430f, 0.23851007f, -0.01300654f, -0.05791222f, 0.03016933f, 0.04950660f, 
    0.14660856f, -0.05607862f, 0.11525770f, 0.09491199f, 0.03399625f, 0.05924072f, -0.17447940f, -0.07716032f, 
    0.07541871f, 0.18601052f, -0.02826419f, 0.00387162f, 0.06089451f, 0.04271438f, -0.16918014f, 0.07581432f, 
    -0.03136456f, 0.15403208f, -0.06276110f, -0.04258737f, -0.36892116f, -0.00784518f, 0.08109472f, 0.06129524f, 
    -0.01868731f, -0.19774145f, -0.03900256f, -0.00005971f, -0.13086310f, 0.11345043f, -0.01705102f, 0.08888195f, 
    0.04776456f, 0.03983471f, -0.02790489f, -0.04644156f, -0.10543451f, -0.11146755f, -0.00100902f, 0.19288437f, 
    -0.01100949f, 0.14652032f, -0.01205635f, -0.11174642f, 0.01870377f, 0.06168222f, -0.54209411f, -0.19384463f, 
    0.10211531f, 0.13124715f, 0.15470321f, 0.03696586f, 0.24467856f, -0.05019675f, -0.13556263f, -0.42005423f, 
    -0.16364025f, -0.11319971f, 0.18606882f, 0.05596931f, 0.10553214f, 0.21920574f, 0.01248573f, 0.11137154f, 
    0.12600218f, -0.37761623f, -0.14874423f, 0.15423399f, -0.13160209f, -0.21495232f, 0.05282618f, 0.04652431f, 
    -0.00308722f, 0.33011165f, -0.18487093f, -0.23105128f, 0.12034170f, 0.09241898f, 0.04769016f, 0.04108735f, 
    -0.06550074f, -0.12212294f, 0.03960191f, -0.13955806f, 0.21884947f, -0.03222272f, -0.06040666f, -0.08685306f, 
    -0.22385512f, 0.15543294f, -0.01411928f, 0.02567236f, -0.01817566f, 0.12895329f, -0.14447524f, 0.08502422f, 
    0.00563250f, 0.03490490f, 0.02706083f, 0.19505706f, -0.17101707f, 0.10141370f, -0.16635801f, -0.26601812f, 
    -0.24305825f, 0.04407676f, -0.02848879f, 0.01866884f, -0.04005188f, -0.02499703f, -0.17909269f, -0.05599642f, 
    0.15797988f, -0.10918721f, 0.00027277f, 0.02230941f, 0.02133813f, -0.02786372f, -0.02603563f, -0.01655579f, 
    0.14397714f, 0.06898945f, 0.03675693f, -0.19941941f, 0.10728242f, 0.01023603f, 0.12962767f, -0.32073468f, 
    -0.02179167f, 0.04626177f, 0.09065281f, 0.04686891f, -0.06033585f, 0.07983633f, -0.01703022f, 0.00220588f, 
    0.21269023f, -0.06274684f, -0.14258240f, 0.09023079f, 0.02061058f, 0.09053747f, 0.02498826f, -0.01824798f, 
    0.01650641f, -0.41391668f, 0.04467799f, -0.11081146f, 0.20656693f, 0.09109233f, 0.04836249f, -0.03245034f, 
    -0.07561342f, -0.17261401f, -0.01538045f, 0.04583169f, 0.12019211f, -0.08027294f, -0.13878164f, -0.24515371f, 
    -0.05478793f, 0.09802847f, -0.06891010f, -0.00995798f, 0.14666016f, 0.14243959f, -0.05359721f, -0.01316885f, 
    0.23068903f, -0.02310314f, 0.08859388f, -0.00015350f, -0.22636077f, -0.45689020f, 0.09668575f, 0.00176227f, 
    0.20499970f, 0.01384694f, -0.13650866f, -0.08697049f, -0.13921814f, 0.15414847f, -0.08826946f, 0.23531437f, 
    -0.24446604f, -0.02835688f, 0.08413986f, 0.06106895f, 0.13346756f, 0.12038187f, -0.16004798f, -0.12317014f, 
    0.22232386f, -0.04385876f, -0.04788712f, 0.09168938f, -0.07617227f, 0.02814993f, 0.05005550f, -0.08439893f, 
    -0.02972871f, 0.04982014f, -0.01506897f, 0.13870393f, -0.14871016f, -0.05478941f, -0.03846416f, 0.04708294f, 
    0.01511792f, -0.00125882f, -0.06045038f, 0.03911595f, 0.00194560f, -0.02599096f, 0.01750446f, -0.05319522f, 
    -0.04464735f, -0.01556606f, -0.00611945f, -0.04750616f, -0.04911576f, -0.00648072f, -0.00186638f, -0.04583154f, 
    -0.03714426f, 0.03440516f, -0.01885170f, 0.01416461f, -0.04430564f, 0.02991078f, -0.04960176f, 0.03886339f, 
    -0.00064878f, 0.04895583f, -0.04763134f, 0.02137348f, 0.04450142f, 0.04308429f, 0.02831981f, -0.00598279f, 
    -0.00382519f, 0.02309550f, -0.04237467f, -0.05416369f, 0.00042733f, -0.01426465f, 0.01562615f, 0.02336929f, 
    -0.00365871f, 0.01060189f, -0.03046527f, -0.05831119f, -0.03472739f, -0.05963563f, 0.02463815f, -0.03198854f, 
    0.01340158f, -0.01865085f, 0.03307891f, 0.03103272f, -0.00834364f, -0.00205478f, -0.03039537f, 0.01139821f, 
    0.02470204f, -0.01607537f, -0.05812526f, -0.03435669f, 0.05024763f, 0.04123996f, -0.01197707f, -0.00012862f, 
    -0.01054740f, -0.00881694f, 0.03074288f, 0.01204167f, -0.01151324f, 0.03148467f, -0.06256583f, 0.00314312f, 
    0.02769195f, -0.04690086f, 0.04573622f, 0.01731141f, 0.01632977f, -0.04557256f, -0.04657856f, 0.00705055f, 
    -0.04871064f, -0.00678153f, 0.00603134f, -0.02411430f, -0.05971330f, -0.05014042f, 0.00010264f, -0.00634304f, 
    0.03211285f, 0.05237929f, 0.02840798f, 0.00541711f, 0.03616108f, -0.04718840f, 0.02233993f, 0.03292484f, 
    -0.00307358f, -0.01266571f, -0.05959695f, -0.03841566f, -0.02959335f, 0.04411545f, 0.02592612f, 0.04241252f, 
    -0.02845828f, -0.06123708f, 0.04694998f, 0.03235344f, -0.00059423f, -0.04251164f, -0.04672369f, 0.01665834f, 
    -0.06790364f, 0.04551616f, 0.00671538f, -0.05941790f, 0.03554618f, 0.05146286f, -0.04546272f, 0.02792376f, 
    -0.05224556f, -0.02014281f, -0.05018151f, 0.02488526f, -0.04761075f, 0.03670467f, -0.01516770f, -0.06431871f, 
    -0.04877031f, 0.01811449f, -0.01975450f, -0.03922017f, 0.00313806f, 0.04005937f, -0.05397795f, 0.00699692f, 
    -0.04475139f, 0.01569109f, -0.02519564f, 0.00984158f, 0.03075848f, 0.00091754f, -0.01747475f, 0.03067531f, 
    -0.00582816f, -0.05548873f, 0.00796443f, -0.02944838f, -0.06050849f, 0.05296532f, 0.01989625f, 0.04102099f, 
    -0.03052903f, 0.01223369f, -0.05296464f, -0.04352858f, 0.04213616f, -0.04580171f, 0.02174537f, -0.04424582f, 
    -0.05935850f, 0.04120304f, -0.01774182f, 0.02906422f, -0.03693987f, -0.02718176f, 0.04148677f, -0.03548008f, 
    -0.02626397f, 0.04520615f, -0.06217558f, 0.01518466f, -0.03689606f, -0.00018566f, -0.02608543f, -0.03513196f, 
    -0.00810267f, 0.03111654f, -0.01460529f, -0.03907622f, -0.02097811f, -0.03996813f, -0.01528766f, -0.02143954f, 
    0.03276116f, 0.04211831f, 0.02624719f, -0.06148741f, 0.00954974f, 0.03548022f, -0.00010240f, -0.04300940f, 
    -0.02835298f, -0.00372845f, -0.01210546f, 0.04087301f, -0.01879171f, -0.06355765f, -0.02017590f, -0.04630703f, 
    -0.03183720f, 0.04587983f, 0.04483564f, -0.02704464f, -0.00754062f, -0.02468733f, -0.02074935f, -0.02621759f, 
    -0.01999028f, 0.01078927f, 0.02591739f, 0.03776480f, 0.02581814f, -0.05149802f, 0.01035898f, -0.00320664f, 
    0.01585922f, 0.01558876f, 0.02504031f, -0.00792376f, 0.01844454f, 0.00778703f, 0.01889469f, -0.05790475f, 
    -0.04624343f, 0.04273687f, 0.01535204f, -0.01199673f, 0.00820383f, 0.04566154f, -0.00692599f, -0.04103156f, 
    -0.05577336f, 0.00127335f, -0.00531295f, 0.05898802f, -0.05367330f, -0.02357858f, -0.00556546f, 0.02526708f, 
    -0.00926667f, -0.04269705f, -0.06631313f, -0.03787512f, 0.03426508f, -0.05350531f, 0.00324656f, -0.06349717f, 
    0.04220384f, 0.04857963f, 0.04137376f, 0.04982442f, -0.01849387f, 0.04326600f, -0.02455135f, 0.04394336f, 
    -0.01320685f, 0.04315525f, -0.05840660f, 0.00249760f, 0.04354208f, -0.02168290f, -0.01935849f, 0.05317647f, 
    -0.05361360f, 0.02256584f, 0.05223277f, -0.02953950f, 0.04794126f, -0.00964532f, -0.03602303f, 0.02714999f, 
    -0.04842284f, 0.03345081f, -0.00424487f, 0.01168391f, -0.01678154f, 0.02279866f, -0.03012522f, 0.00052771f, 
    -0.03272753f, 0.00965175f, 0.04463455f, 0.02364567f, -0.00417728f, 0.01405254f, -0.05567769f, -0.02510161f, 
    -0.12229816f, 0.08777179f, 0.00472819f, 0.09164222f, -0.15629469f, 0.21862873f, 0.08150902f, -0.11693946f, 
    0.08902287f, -0.29444733f, 0.02996814f, -0.13569340f, -0.27821845f, -0.00727785f, 0.00894213f, -0.04684306f, 
    0.21257600f, 0.04346513f, -0.18476583f, 0.14067392f, 0.00401208f, -0.01699634f, 0.18838967f, 0.08387055f, 
    -0.16523217f, 0.09375362f, -0.01458508f, 0.05056035f, -0.12796603f, 0.24565639f, 0.07831128f, -0.06680557f, 
    0.09118303f, -0.01442857f, 0.14832960f, 0.08717502f, -0.33699417f, 0.03142588f, -0.17127962f, 0.04184960f, 
    0.17693709f, -0.10924887f, -0.13197733f, -0.08786774f, -0.09161311f, -0.07406197f, 0.11443655f, 0.09978811f, 
    -0.05671147f, 0.04895140f, 0.04538347f, -0.02386814f, 0.12673625f, -0.05623024f, -0.26742658f, -0.02941485f, 
    -0.53863448f, 0.04039954f, 0.00592333f, 0.10052060f, 0.02697398f, -0.10476816f, -0.11032116f, -0.11199810f, 
    0.00977805f, -0.28771368f, 0.00207010f, -0.12077795f, -0.10710267f, 0.15212519f, 0.01591864f, -0.06075397f, 
    -0.19568154f, 0.09425299f, -0.34582725f, 0.03568404f, 0.10285755f, -0.24275330f, 0.05997138f, -0.00865569f, 
    -0.06424423f, 0.16485268f, 0.10429335f, 0.15778679f, 0.07032331f, 0.10405065f, 0.08947184f, -0.02820730f, 
    0.10508145f, -0.24774265f, -0.27505943f, 0.12573385f, -0.08359488f, -0.09560915f, -0.03931346f, 0.08269877f, 
    0.07669114f, -0.01273151f, 0.19568023f, -0.40067372f, -0.18031849f, 0.27057657f, -0.06270470f, 0.08499762f, 
    -0.28544936f, 0.11010512f, -0.17847256f, -0.14140218f, 0.10788248f, -0.02368807f, 0.11530579f, -0.10082026f, 
    -0.07397743f, -0.05140454f, 0.10544763f, 0.09904817f, 0.23465914f, 0.37205157f, 0.14072634f, 0.13809073f, 
    -0.01129824f, 0.05930232f, 0.05196364f, 0.10212669f, -0.01428380f, 0.12087516f, -0.27260140f, 0.21888860f, 
    0.03375934f, 0.11667918f, 0.00289032f, -0.01198734f, 0.01548244f, 0.04050611f, -0.02131554f, -0.24712253f, 
    -0.25725284f, -0.17481637f, 0.00957428f, 0.16030772f, 0.07245060f, 0.20787868f, 0.02708474f, -0.03637067f, 
    -0.26181859f, 0.08005171f, -0.23672885f, -0.08295940f, 0.03714138f, 0.02890547f, -0.13395604f, 0.14180702f, 
    -0.07288326f, -0.14572079f, -0.17054589f, -0.10956798f, 0.05388664f, -0.14712453f, 0.02672763f, -0.08959866f, 
    -0.30516544f, -0.19575082f, -0.18125804f, 0.02215374f, 0.11879404f, 0.07289834f, -0.12344968f, 0.06834757f, 
    0.05514011f, 0.13808693f, 0.00902402f, 0.19328985f, 0.07396732f, -0.10026845f, 0.13196425f, 0.11186623f, 
    0.06345635f, -0.06068246f, 0.07004488f, 0.22710711f, -0.29217607f, -0.28196013f, 0.12731375f, 0.00861317f, 
    0.01710894f, -0.17285740f, -0.00284484f, -0.01498337f, 0.10734521f, 0.09035484f, -0.19167449f, -0.23809633f, 
    0.03499713f, 0.07496620f, 0.04208370f, -0.01490226f, -0.05278365f, -0.10088550f, 0.30436733f, 0.10937276f, 
    0.17844951f, -0.02530640f, 0.05261995f, 0.15889123f, -0.00842633f, 0.06031439f, -0.02756201f, -0.34224719f, 
    0.27915174f, 0.14662968f, -0.03672096f, -0.09578940f, -0.03814225f, 0.32473961f, 0.07487523f, 0.09685317f, 
    -0.18305546f, -0.31328025f, 0.10143945f, -0.01164340f, -0.05848069f, -0.00633762f, 0.11336941f, 0.05168860f, 
    0.02847150f, -0.12718409f, -0.10224761f, -0.00392037f, -0.05889283f, -0.06443198f, -0.19024169f, 0.10640543f, 
    0.09350314f, -0.05692767f, 0.08414889f, 0.07212056f, -0.02282988f, -0.22889742f, 0.04306813f, 0.04712108f, 
    0.05717386f, -0.01719214f, 0.06438711f, 0.20678382f, 0.11948926f, 0.30417040f, -0.04141019f, -0.03725297f, 
    0.08043717f, 0.06193876f, 0.15428278f, -0.00924425f, -0.49427921f, -0.04595654f, -0.08384225f, -0.18545142f, 
    0.07127039f, -0.09380671f, -0.06885044f, -0.12974143f, -0.03690406f, 0.18288362f, 0.27449355f, 0.02598243f, 
    -0.07616791f, -0.08945613f, 0.06449950f, 0.17149545f, 0.05403123f, 0.03726729f, 0.13956991f, 0.08726773f, 
    0.07414196f, -0.01504019f, 0.12304858f, 0.17349480f, 0.01061511f, 0.06366751f, -0.03774419f, 0.15544881f, 
    0.13435343f, 0.23426975f, 0.03788063f, -0.06506811f, 0.06153258f, 0.03594484f, 0.00724404f, 0.08739050f, 
    -0.17268239f, -0.14664300f, 0.07631534f, 0.06988852f, 0.02576099f, -0.15751380f, -0.10120381f, 0.02603538f, 
    0.07067587f, -0.22939140f, 0.02143651f, -0.18005976f, -0.06543937f, -0.01779071f, -0.06730490f, -0.04489588f, 
    0.05649458f, -0.00487549f, 0.04312042f, -0.02402550f, 0.01603286f, 0.04117582f, 0.01779667f, -0.08319450f, 
    0.03882019f, -0.01798256f, 0.14018683f, 0.00970112f, -0.31333110f, -0.00794716f, -0.02845161f, 0.03211432f, 
    0.12627351f, -0.02391353f, -0.15309550f, 0.13712056f, -0.10382487f, -0.16722813f, 0.08742948f, 0.15051907f, 
    0.03317993f, 0.07310860f, -0.06331784f, 0.09210817f, 0.09225051f, -0.00439965f, -0.01052569f, 0.26650798f, 
    0.06569211f, 0.18309742f, -0.14220557f, -0.22455190f, 0.00597965f, 0.22527373f, 0.08012008f, 0.23136958f, 
    -0.07002720f, -0.12973800f, -0.09969354f, 0.03215051f, 0.01391560f, 0.05876513f, -0.19434671f, 0.31801012f, 
    0.16567148f, 0.21052855f, -0.16090918f, 0.07818098f, 0.00910881f, 0.05036514f, 0.19704999f, 0.07345971f, 
    -0.16071035f, -0.16259971f, 0.09237951f, -0.13964951f, 0.13282353f, 0.05429279f, -0.01537792f, 0.02871087f, 
    -0.00959875f, -0.31228194f, -0.07626855f, -0.09997807f, 0.22981198f, 0.00951318f, -0.03161252f, -0.02663150f, 
    -0.07741330f, -0.01467268f, 0.11191501f, 0.15981501f, 0.07766297f, 0.04162164f, -0.02994809f, -0.04335508f, 
    0.02637920f, 0.00907670f, 0.11793405f, 0.02776613f, -0.13481970f, -0.13957536f, -0.06868941f, -0.00082874f, 
    -0.21750735f, -0.04768936f, 0.17356330f, -0.11184807f, 0.01194064f, 0.06144721f, -0.11712121f, -0.16585138f, 
    -0.07833105f, -0.01111134f, 0.04984702f, -0.00232259f, 0.03452944f, -0.27586946f, 0.16752000f, 0.07808922f, 
    0.02442056f, 0.09890801f, 0.01336333f, -0.03178756f, -0.03987864f, -0.27053371f, 0.08957769f, -0.11970549f, 
    0.09709346f, 0.14842276f, -0.13410279f, 0.01035728f, -0.06457403f, -0.03580620f, 0.08227254f, 0.16606063f, 
    0.06653428f, 0.01607080f, -0.05540822f, 0.04627302f, 0.20106588f, 0.21020554f, 0.28234765f, -0.11454917f, 
    0.06526029f, 0.12743767f, -0.09030756f, -0.25478002f, -0.12434649f, -0.14131290f, 0.06706274f, 0.06460004f, 
    0.03242468f, 0.25542939f, 0.18666007f, 0.04577078f, -0.04614701f, 0.13437198f, -0.13447303f, -0.09349507f, 
    0.05872890f, 0.05783175f, -0.17962515f, -0.18656895f, -0.04373287f, -0.04213558f, 0.14751081f, 0.13415657f, 
    0.06316373f, -0.12709923f, -0.02984546f, 0.13170807f, -0.08270580f, -0.06405614f, -0.00030004f, -0.06347298f, 
    -0.01606840f, -0.10604285f, 0.16264422f, -0.02707763f, -0.04160606f, -0.14059582f, -0.03640383f, -0.14251439f, 
    0.00996374f, 0.10219313f, -0.09933437f, -0.07351880f, 0.01734502f, 0.31666806f, 0.15037519f, 0.09320451f, 
    0.06841924f, 0.02242248f, 0.06734137f, -0.21706116f, -0.08928228f, 0.00564513f, -0.33449811f, -0.04571782f, 
    -0.03838092f, 0.07094198f, 0.04031781f, 0.08135587f, -0.09497567f, -0.02025063f, -0.05749092f, 0.15796784f, 
    -0.11846052f, 0.06233019f, -0.04930846f, 0.13478732f, 0.07699026f, 0.10716888f, 0.04805542f, 0.07054275f, 
    0.12818484f, 0.15795162f, -0.00375748f, -0.09968760f, 0.04476525f, -0.07393257f, 0.09522466f, 0.05264495f, 
    -0.02400793f, 0.18092941f, 0.41722411f, -0.01410996f, -0.27437422f, -0.17255081f, 0.10686229f, 0.11318859f, 
    0.16334446f, -0.03949123f, -0.01762778f, -0.20278157f, 0.02856138f, -0.07006763f, 0.14508805f, 0.04904970f, 
    0.01430744f, 0.10572164f, -0.09048029f, -0.36561143f, -0.09904259f, 0.06781096f, 0.02122145f, 0.05410535f, 
    0.13978659f, -0.04656865f, -0.00202947f, -0.01468845f, 0.18747944f, 0.22290476f, 0.06349286f, 0.01144048f, 
    -0.14801759f, 0.06583030f, 0.17159313f, -0.05672753f, 0.22728460f, 0.00010190f, 0.02701030f, -0.02073677f, 
    -0.07809011f, 0.06601509f, -0.01757121f, 0.00514924f, 0.15481538f, 0.10244889f, -0.09194387f, -0.24472106f, 
    -0.30799410f, 0.12889193f, -0.08387084f, 0.10738382f, -0.08400374f, -0.17137460f, -0.20105810f, -0.18836613f, 
    -0.24517299f, 0.02079374f, 0.17145529f, 0.17007831f, 0.04553099f, -0.05520731f, 0.00170333f, 0.04716576f, 
    -0.00826087f, -0.01781351f, 0.04970830f, 0.02734477f, -0.05063675f, 0.01791657f, 0.00277259f, 0.02910463f, 
    0.02082236f, -0.04783195f, -0.05149383f, -0.02734130f, 0.01198387f, 0.02417661f, -0.04616912f, 0.02516044f, 
    0.03961409f, 0.00240046f, -0.02185812f, 0.02819069f, -0.05932954f, -0.05385952f, -0.06009881f, -0.06231838f, 
    0.03715364f, -0.00915847f, -0.01140807f, 0.02517465f, 0.01322061f, 0.00069882f, 0.00759700f, 0.02372271f, 
    0.03142358f, 0.01629000f, 0.04964072f, -0.06122652f, -0.02047108f, -0.05179562f, 0.03716816f, 0.05094027f, 
    -0.02780666f, 0.01442579f, 0.03925630f, -0.02313392f, 0.04640070f, -0.05828712f, 0.01677851f, -0.04840434f, 
    -0.02015577f, 0.03830388f, -0.03245332f, -0.02587680f, 0.05154708f, 0.02402883f, -0.05118519f, -0.04903641f, 
    -0.02227556f, 0.03128913f, -0.01906464f, -0.05612073f, 0.00252451f, -0.01834707f, 0.04359083f, -0.00940454f, 
    0.01860213f, 0.00716371f, -0.04952199f, -0.01468765f, -0.00959551f, 0.05099383f, 0.00103156f, -0.01129946f, 
    -0.03495690f, 0.01596600f, -0.03285029f, 0.02201954f, 0.01396151f, 0.04609840f, 0.03852590f, -0.06003838f, 
    0.05242830f, -0.04951124f, 0.00693946f, -0.03840351f, -0.05315299f, 0.00972888f, -0.03009114f, -0.00763032f, 
    -0.01867191f, 0.02716732f, -0.05681928f, 0.01555655f, 0.00248479f, 0.04312719f, -0.03027708f, -0.04183750f, 
    0.03982029f, 0.03420564f, -0.00452462f, -0.02177619f, 0.01901695f, 0.03653787f, -0.02210129f, -0.02138582f, 
    -0.02635707f, -0.05576799f, 0.03332212f, -0.01154586f, -0.04993682f, 0.02755466f, -0.01958253f, -0.01113702f, 
    -0.04224948f, 0.02185777f, 0.03707035f, -0.00197784f, -0.01787811f, -0.01706065f, 0.01504731f, -0.03705901f, 
    0.02702718f, 0.01694908f, -0.02668591f, -0.04526923f, -0.02850401f, -0.06322597f, -0.05924403f, -0.05344018f, 
    -0.00156989f, -0.04911723f, 0.03330126f, 0.04063086f, 0.01137969f, -0.02218576f, 0.00276125f, 0.05733950f, 
    -0.05182240f, 0.05386863f, -0.01950117f, -0.01330134f, -0.01774247f, 0.04892159f, -0.00506760f, -0.03981810f, 
    0.04490143f, -0.05033860f, -0.04658935f, -0.01770030f, -0.05356729f, 0.01890788f, -0.04703806f, 0.03950392f, 
    0.01134585f, 0.00187157f, 0.02170614f, -0.03904713f, 0.03034950f, -0.00924842f, -0.02821662f, -0.02338121f, 
    -0.06013274f, 0.02198490f, 0.02835676f, -0.01765793f, -0.04711266f, -0.01832906f, -0.04155976f, -0.00924987f, 
    -0.05677926f, -0.04373987f, 0.01225299f, -0.06339239f, 0.04799498f, 0.00739642f, 0.01232770f, 0.04760608f, 
    0.02413607f, 0.04664377f, -0.04854620f, 0.00371599f, -0.02478793f, 0.02924151f, -0.02457668f, -0.04395345f, 
    0.00874497f, 0.04532880f, -0.03278013f, -0.02866159f, 0.00398633f, -0.02537751f, 0.03386150f, -0.05612263f, 
    -0.00016644f, 0.03550631f, 0.01417849f, -0.00361183f, -0.04035317f, 0.04409211f, 0.01312235f, -0.06149324f, 
    -0.04578361f, -0.00403208f, 0.02627554f, -0.04824685f, 0.04513627f, 0.00057597f, -0.00330516f, 0.01237467f, 
    -0.05270848f, -0.06259374f, 0.05254662f, 0.00135003f, 0.05500528f, 0.02957361f, -0.03195206f, 0.05321910f, 
    -0.00260418f, -0.02681705f, -0.04869825f, -0.01514869f, -0.00208289f, 0.02056913f, -0.03004291f, 0.01132356f, 
    -0.01891590f, 0.00945005f, -0.01629704f, 0.01981631f, 0.04812855f, -0.00598549f, 0.03018992f, 0.03982746f, 
    -0.05881566f, 0.04327520f, -0.00786594f, -0.03297143f, 0.00877784f, -0.04374074f, -0.03167625f, 0.00131078f, 
    -0.04432830f, -0.00756519f, -0.04189689f, -0.03229717f, 0.04892281f, 0.05218631f, 0.02960044f, -0.01596359f, 
    -0.00262112f, -0.01326945f, -0.04082194f, -0.01064709f, -0.02501474f, -0.04874527f, -0.01464475f, 0.02103491f, 
    -0.02550741f, 0.01424723f, -0.02710231f, 0.01093337f, -0.03154099f, -0.01932487f, -0.02132572f, 0.01240562f, 
    0.01531510f, 0.02770643f, 0.02466354f, -0.03614516f, -0.02042456f, -0.03649043f, -0.04798952f, 0.00503970f, 
    0.02325157f, 0.01276963f, -0.04692414f, -0.03733275f, 0.01946050f, -0.03294923f, -0.04051386f, -0.00913862f, 
    0.03921958f, -0.02485409f, -0.06242146f, -0.04455486f, -0.01598490f, 0.04539338f, 0.03396174f, 0.04073184f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.04848833f, 0.04290186f, -0.04166271f, 0.06856477f, -0.04032990f, -0.00146656f, -0.03113437f, -0.01065318f, 
    -0.01687607f, 0.02543333f, 0.10328216f, -0.00222388f, 0.02367306f, 0.09786691f, -0.00700578f, -0.02644391f, 
    0.04363324f, 0.11487135f, 0.12816073f, -0.06720529f, -0.00687914f, 0.04277757f, 0.03758648f, 0.02188784f, 
    0.04612535f, 0.14004657f, -0.01981051f, 0.17754947f, 0.00289808f, 0.07407361f, 0.06142487f, -0.02436506f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.15940110f, 0.15996385f, 0.11691441f, 0.06564226f, 0.05538606f, 0.35257170f, 0.08359356f, 0.29134974f, 
    -0.14329545f, -0.11556723f, -0.04424337f, 0.08875793f, 0.06566246f, 0.25638443f, 0.06072083f, 0.03288167f, 
    -0.04113339f, 0.21717049f, -0.51995319f, 0.18410295f, -0.06530442f, -0.04456968f, 0.09310550f, -0.02371824f, 
    -0.52786881f, -0.10250680f, -0.27989456f, 0.01200673f, -0.01307520f, -0.25159410f, -0.30960906f, -0.06471658f, 
    0.04613926f, 0.08805668f, -0.43578231f, -0.52406925f, -0.14926088f, -0.06813312f, -0.13805158f, 0.05272924f, 
    -0.16183306f, -0.25727347f, 0.10388608f, 0.01728180f, 0.20605683f, 0.13540038f, 0.09840195f, -0.09863502f, 
    -0.12129503f, 0.17648211f, -0.26070258f, 0.07123009f, -0.03769676f, 0.07606020f, 0.02830951f, 0.17183693f, 
    0.31865054f, 0.27121648f, -0.06820378f, -0.30043018f, 0.12919772f, 0.20203246f, 0.43812841f, -0.14629814f, 
    0.06552497f, -0.09244504f, -0.19219606f, -0.10172513f, 0.00395603f, -0.06160488f, -0.03454198f, 0.01411661f, 
    0.05647474f, -0.02688957f, 0.47635922f, -0.11038800f, -0.39961636f, 0.15666236f, -0.12747033f, -0.07749048f, 
    -0.00631316f, -0.04108021f, 0.46000293f, -0.36568871f, 0.00994202f, -0.32569271f, 0.08720903f, 0.09625134f, 
    -0.09652115f, 0.25379512f, 0.33481440f, -0.34624496f, 0.16621131f, 0.16510563f, 0.20568417f, -0.05773263f, 
    0.15979703f, -0.15172532f, -0.11260266f, -0.20345885f, 0.16364692f, -0.18111737f, 0.04330193f, -0.04700916f, 
    0.07069473f, 0.13340075f, -0.03209494f, -0.10407530f, 0.05325701f, 0.00067988f, 0.11622576f, 0.00482815f, 
    -0.05108228f, 0.01479722f, 0.04108163f, 0.00508908f, 0.16701633f, -0.08382354f, -0.00219345f, -0.06158107f, 
    0.11406072f, -0.09183575f, -0.01595682f, -0.06506332f, -0.05575119f, 0.05826589f, -0.15191534f, -0.07760220f, 
    -0.00146363f, 0.02419880f, -0.07304900f, -0.11697036f, -0.12782726f, -0.00761657f, -0.07895748f, -0.16965245f, 
    -0.10994351f, -0.10288341f, -0.07227116f, -0.03428349f, -0.10357644f, -0.03644710f, -0.03990004f, -0.12431911f, 
    -0.12103803f, -0.16183226f, -0.00800059f, 0.11210021f, 0.09749986f, 0.08702546f, -0.17494795f, 0.03839102f, 
    -0.14015582f, -0.16602853f, 0.06516984f, 0.10957137f, -0.09826995f, 0.14496320f, -0.09902827f, 0.03600719f, 
    0.04686980f, 0.07741168f, -0.04284730f, -0.18094297f, 0.00260671f, 0.02291257f, 0.10978156f, 0.13736200f, 
    0.12276963f, 0.02602489f, -0.31576154f, 0.13391550f, 0.04109163f, -0.16937152f, 0.00416111f, 0.04395622f, 
    -0.16117822f, 0.39723921f, -0.16132644f, 0.42882434f, 0.12219513f, 0.33650428f, 0.14986388f, -0.07194541f, 
    0.17765442f, 0.01276318f, -0.21832360f, 0.39036977f, 0.04826849f, 0.33886126f, -0.33623025f, -0.17985226f, 
    -0.08683209f, -0.08160686f, -0.06583167f, -0.06364068f, 0.06203470f, -0.00029435f, -0.13692151f, -0.02896369f, 
    0.01675655f, 0.07777891f, -0.10560854f, -0.15393822f, 0.04196671f, -0.12190213f, -0.00528052f, -0.02835977f, 
    0.14457759f, 0.05525091f, -0.05471232f, -0.06619314f, -0.14267275f, -0.08817215f, -0.11706331f, 0.15458237f, 
    -0.08024018f, 0.01608684f, 0.01393459f, 0.13880196f, 0.13545609f, -0.17627090f, 0.05977300f, -0.15757929f, 
    -0.02543758f, -0.08582881f, 0.11520065f, 0.01733998f, -0.07765900f, 0.22136059f, -0.06542293f, 0.24439719f, 
    -0.07281543f, -0.25003996f, 0.34782693f, -0.23595846f, 0.16788669f, -0.23860319f, -0.15824382f, 0.04237042f, 
    -0.09381071f, 0.10718122f, -0.03786179f, 0.06793264f, 0.11159389f, -0.07809042f, 0.10547459f, -0.07043990f, 
    0.43405366f, 0.28114593f, 0.12568985f, -0.50621533f, -0.13635844f, -0.42309245f, 0.21772370f, 0.10597418f, 
    0.01202215f, 0.04995234f, 0.39278406f, 0.35566252f, -0.12795925f, -0.18299665f, -0.10286152f, 0.00915948f, 
    0.17250928f, -0.00880957f, 0.09973750f, 0.02063646f, -0.35829252f, 0.11270240f, 0.14985362f, 0.11620817f, 
    -0.15691632f, -0.04118203f, 0.45173973f, -0.37682897f, 0.11628716f, -0.17589870f, 0.10639802f, 0.11076155f, 
    0.00135324f, 0.14510362f, 0.32372689f, 0.04530229f, 0.05783319f, 0.03103984f, -0.15288311f, 0.05211665f, 
    0.13609420f, -0.10794671f, 0.16825229f, -0.37072790f, -0.07378098f, -0.20643708f, 0.05874114f, 0.15537477f, 
    -0.12951654f, -0.86844683f, -0.01187063f, 0.18135725f, 0.38814092f, -0.00530094f, -0.05597925f, -0.02579407f, 
    -0.10869589f, -0.09312325f, 0.71701556f, 0.07883198f, -0.13621372f, -0.10029717f, -0.14001083f, -0.01341220f, 
    0.26031101f, 0.40225422f, 0.17365783f, -0.16770738f, 0.02291219f, -0.36915842f, 0.27736801f, -0.06914194f, 
    0.11668485f, 0.11886743f, 0.59943426f, 0.23780175f, 0.15910913f, 0.29431790f, -0.12780231f, 0.24011710f, 
    -0.06791800f, -0.08283731f, -0.05828976f, -0.11257814f, 0.23918433f, -0.22746399f, -0.11258078f, -0.13335142f, 
    0.02410602f, 0.00969373f, -0.20053092f, 0.29334730f, 0.00388364f, -0.06796306f, -0.07825809f, -0.16972627f, 
    -0.19625129f, -0.09923544f, 0.03240354f, 0.38223243f, 0.16805770f, -0.43009439f, -0.24080785f, 0.03031537f, 
    -0.03951027f, 0.07752343f, -0.03201393f, -0.04797329f, 0.01385538f, 0.07785939f, -0.02472657f, -0.06005327f, 
    -0.03493001f, -0.12786797f, -0.18480229f, -0.06425872f, 0.11799335f, -0.16718864f, -0.15652226f, 0.14296570f, 
    0.01895435f, -0.04578257f, 0.07096437f, -0.07820548f, 0.04531016f, -0.15440063f, 0.14402218f, 0.16881074f, 
    0.11532129f, 0.04680595f, -0.12997714f, 0.00098487f, 0.05471666f, 0.07154036f, 0.10785524f, 0.08684216f, 
    -0.15357876f, -0.02338954f, -0.15591963f, -0.03506603f, 0.14603338f, -0.00427930f, -0.13848251f, -0.17139633f, 
    0.06774645f, -0.13797873f, 0.04968368f, -0.15920234f, -0.08723112f, -0.03720564f, -0.10385453f, -0.04507285f, 
    -0.03990931f, 0.10192254f, -0.02225986f, 0.17507195f, 0.08772862f, -0.11803332f, -0.08269388f, -0.15070219f, 
    0.05517644f, -0.05547770f, -0.17337851f, -0.13511017f, 0.01283818f, 0.02315223f, -0.05603048f, 0.07767514f, 
    0.11291347f, -0.12049137f, 0.10194836f, 0.06304888f, 0.08837351f, -0.00241596f, -0.08418430f, -0.02462997f, 
    0.15590605f, -0.12023865f, -0.11515903f, -0.11092762f, 0.00618320f, -0.04997035f, -0.17571793f, 0.02355720f, 
    0.05811618f, 0.05442696f, -0.09869323f, -0.03889471f, -0.14422393f, 0.04646079f, -0.08676327f, -0.06778555f, 
    0.07174308f, -0.13343191f, -0.00580191f, -0.05035415f, 0.15360965f, -0.05450964f, -0.03638651f, -0.04198939f, 
    0.03485674f, -0.03705573f, 0.14756688f, -0.03288963f, -0.02237292f, -0.02732410f, 0.13315968f, -0.01436006f, 
    0.01382487f, 0.31715381f, 0.48747900f, -0.20421430f, -0.02845202f, 0.24862397f, 0.02594881f, 0.04543227f, 
    -0.02144557f, -0.12258086f, 0.61887467f, -0.22587800f, 0.06885533f, -0.38615367f, -0.03732138f, -0.15359539f, 
    0.17294319f, -0.10474641f, 0.14374922f, -0.24122015f, 0.11988641f, 0.21651037f, 0.30450490f, 0.10725570f, 
    -0.06318714f, -0.07991408f, -0.06632548f, -0.10443391f, 0.17730726f, 0.10170060f, 0.10621225f, -0.13286658f, 
    -0.17077434f, -0.05965534f, -0.02689437f, 0.07315189f, 0.02186170f, -0.04290854f, 0.12462695f, -0.02479648f, 
    -0.00130724f, -0.06566269f, 0.10559205f, -0.10434917f, -0.15221933f, -0.12433829f, -0.11243654f, -0.05260175f, 
    -0.15747082f, -0.04016004f, -0.16923919f, -0.02826487f, -0.05442496f, 0.13488998f, 0.13889018f, 0.07419333f, 
    -0.08975965f, 0.05987095f, 0.11128130f, -0.09277517f, -0.06550184f, 0.00474742f, -0.11671194f, -0.14569218f, 
    0.02577530f, -0.00607964f, -0.18099494f, -0.14000201f, 0.12590177f, -0.07934733f, -0.13127878f, -0.09931848f, 
    -0.03398750f, -0.02899190f, 0.06843619f, -0.17475046f, -0.11782035f, -0.05145252f, 0.06573582f, -0.03336602f, 
    -0.20838383f, 0.05792320f, 0.08324145f, -0.08686142f, -0.02274555f, -0.17322505f, 0.00830610f, 0.09556919f, 
    0.10395857f, -0.14366892f, 0.51021814f, 0.27499920f, 0.17608230f, 0.12523142f, 0.13785154f, 0.22545704f, 
    0.12528126f, 0.64396155f, 0.23787950f, -0.09166392f, -0.32539481f, 0.07729182f, 0.08055218f, 0.15098779f, 
    -0.07151407f, -0.21264470f, 0.11638124f, -0.27411783f, -0.14659815f, -0.23980559f, 0.14434211f, 0.10562434f, 
    -0.30136549f, -0.05653459f, 0.13096982f, -0.06265485f, -0.05988694f, 0.22602870f, -0.15472619f, 0.04802297f, 
    0.02970007f, -0.07798611f, -0.46644321f, 0.24657489f, 0.12186845f, 0.20254247f, -0.04170674f, 0.20212924f, 
    -0.12793793f, 0.75097120f, 0.05804620f, 0.05238117f, -0.21934536f, 0.32124671f, -0.01400737f, -0.14073902f, 
    0.10263131f, 0.10231423f, -0.88193369f, 0.15504636f, -0.13748041f, -0.09705520f, 0.05909047f, 0.14974076f, 
    -0.54085898f, 0.08317106f, 0.15657774f, 0.51634884f, 0.11962377f, 0.37489837f, -0.26977509f, -0.08805189f, 
    -0.15414980f, -0.12365767f, 0.34230202f, 0.68142796f, 0.06179220f, -0.22864211f, 0.01636518f, -0.08895035f, 
    0.00378135f, -0.40362731f, -0.44128600f, 0.38839638f, 0.12427328f, -0.20094818f, 0.17699975f, -0.12652393f, 
    -0.03949477f, -0.00124101f, 0.35078946f, -0.23121829f, -0.07836507f, 0.53002053f, 0.18843354f, 0.00688652f, 
    -0.11122802f, 0.15307382f, 0.41140097f, 0.63959730f, 0.16293436f, -0.08038072f, 0.24181008f, -0.00553146f, 
    0.02163036f, 0.15084562f, -0.08026222f, -0.02043392f, -0.16370265f, -0.13708533f, -0.14149228f, -0.16348334f, 
    0.08158361f, -0.00861088f, 0.11591236f, -0.15939268f, -0.05241627f, -0.05066557f, -0.12488577f, 0.11249006f, 
    0.04774949f, 0.06352521f, -0.15184063f, 0.12725244f, -0.04766705f, -0.05982922f, 0.11648466f, 0.01906067f, 
    -0.00781868f, 0.08791129f, 0.14017421f, 0.07585628f, -0.14777158f, -0.15105729f, -0.12703510f, -0.07575017f, 
    -0.08039195f, -0.12331901f, 0.14354198f, 0.45809129f, -0.01514228f, 0.36810386f, 0.00998181f, 0.19700205f, 
    0.02391855f, -0.08009330f, 0.20857507f, -0.35946527f, 0.30715445f, -0.22254793f, 0.09712374f, 0.00898668f, 
    0.07543371f, 0.01092353f, 0.04037170f, 0.17574163f, 0.13161749f, 0.15284762f, 0.15390642f, -0.12142340f, 
    0.44955543f, 0.00411206f, -0.09874980f, -0.28690878f, -0.14959292f, -0.12196766f, 0.27436584f, -0.10312145f, 
    -0.07410511f, 0.02563102f, -0.10858853f, 0.02149569f, 0.10592848f, -0.14700253f, 0.09650646f, -0.11217830f, 
    -0.00605555f, -0.09944007f, -0.17322551f, -0.19890761f, 0.00515909f, 0.06629827f, -0.07355406f, -0.07151672f, 
    -0.15844558f, 0.06798731f, -0.10208586f, 0.02116065f, 0.03257536f, 0.11000607f, -0.10444643f, -0.15968616f, 
    -0.08768365f, -0.21634300f, -0.01595278f, -0.15569638f, 0.11380247f, 0.05606150f, -0.19468847f, 0.08756322f, 
    0.05197152f, -0.02766497f, -0.35261565f, -0.46336782f, -0.08709216f, 0.29456323f, 0.09178334f, 0.11830483f, 
    0.13759321f, -0.04001736f, 0.03645902f, 0.08353764f, 0.15990347f, 0.31952918f, -0.16025610f, -0.06111384f, 
    -0.10761542f, 0.35838982f, -0.03270487f, 0.28861880f, 0.03524252f, 0.01106073f, 0.06973884f, 0.03168206f, 
    -0.26503006f, -0.34235576f, -0.26306716f, -0.35386735f, 0.01948846f, 0.22081514f, -0.07300039f, 0.10977694f, 
    0.14185511f, 0.06120768f, -0.28384876f, 0.47223800f, -0.06072903f, 0.45484126f, -0.03925583f, 0.29755414f, 
    -0.03620832f, -0.00845922f, 0.38245246f, -0.10217530f, 0.20416999f, 0.12541451f, 0.00237596f, 0.11407533f, 
    0.00387701f, -0.01309055f, -0.22497082f, 0.29171455f, -0.01231061f, -0.14614804f, 0.11132178f, 0.02303690f, 
    -0.35071334f, -0.35816535f, -0.22961898f, -0.19007304f, 0.04660967f, -0.23910134f, 0.32337192f, -0.14721777f, 
    0.08830336f, 0.04856556f, -0.30724454f, 0.48014784f, -0.09860675f, 0.01658777f, -0.08520657f, -0.02383655f, 
    -0.02067099f, -0.29358232f, 0.24213599f, -0.08082127f, -0.02581297f, 0.31780183f, -0.08280849f, 0.08932201f, 
    -0.11576418f, -0.12806891f, 0.90285635f, -0.05921169f, -0.07122375f, -0.14609991f, -0.00041353f, 0.16147125f, 
    -0.37897831f, -0.22016026f, 0.22205783f, 0.06453510f, -0.16396953f, 0.02883945f, 0.25369704f, -0.08092147f, 
    0.15903118f, -0.11400615f, -0.13376731f, 0.07952889f, 0.11483815f, -0.12981480f, -0.10293335f, -0.12405778f, 
    0.11853988f, -0.16171952f, -0.16538160f, -0.08219825f, -0.12944648f, -0.13975817f, 0.00936233f, 0.06588640f, 
    0.16592623f, 0.14317980f, -0.05648158f, 0.08185124f, -0.15253413f, -0.13356528f, 0.08937863f, -0.14996478f, 
    0.01137720f, -0.01976956f, 0.08465157f, 0.09602278f, -0.08175127f, -0.00044305f, -0.10890461f, 0.01986493f, 
    0.13668820f, -0.03398806f, -0.44373566f, -0.36368239f, -0.11706702f, 0.08631144f, -0.07407117f, 0.03111176f, 
    -0.16403155f, -0.44226834f, 0.01878888f, 0.19254784f, 0.12460566f, 0.08683201f, -0.01214838f, -0.01846164f, 
    0.06274916f, 0.26959330f, -0.33241272f, 0.04893384f, 0.13971667f, 0.27124858f, 0.01479387f, 0.10075528f, 
    0.46797097f, 0.42141137f, -0.11653179f, -0.39650536f, 0.13296984f, -0.17477866f, 0.21249919f, -0.00059420f, 
    -0.08409971f, 0.09335097f, 0.26783597f, -0.33449221f, 0.17109160f, 0.05260585f, 0.01059743f, 0.09396082f, 
    -0.16892259f, 0.42700458f, -0.31197640f, 0.04769661f, 0.06849335f, -0.19000982f, -0.12855405f, 0.10524709f, 
    0.15788661f, 0.19123290f, -0.12286498f, 0.36997801f, 0.16266610f, 0.35371026f, -0.09989728f, 0.03780347f, 
    0.06434325f, -0.15844694f, 0.06938021f, 0.50457311f, 0.04112397f, 0.28594562f, -0.37474653f, 0.04856964f, 
    0.10194986f, 0.14920430f, 0.13824701f, 0.10143604f, 0.04863618f, -0.10679997f, 0.04717957f, -0.13834667f, 
    -0.08036835f, -0.17727627f, 0.02069244f, -0.03825413f, -0.01530490f, -0.06957170f, 0.16984370f, 0.05461055f, 
    0.08625128f, 0.12976773f, -0.10277396f, 0.14538732f, 0.14493355f, 0.13917494f, -0.15666912f, 0.16748090f, 
    -0.09102767f, -0.14714362f, -0.07665300f, 0.12625924f, 0.10170004f, -0.05024739f, -0.16510831f, 0.00310473f, 
    -0.01109591f, 0.00279610f, -0.31802630f, -0.83368731f, 0.04259909f, -0.28203005f, 0.00537377f, 0.05916151f, 
    0.01640816f, -0.28402355f, 0.07334530f, 0.25996727f, -0.16782276f, 0.23030645f, -0.15098295f, 0.12780079f, 
    0.06931067f, 0.36816984f, -0.08912666f, 0.20313498f, -0.11120473f, -0.05554875f, 0.02179293f, -0.03383901f, 
    0.03875882f, 0.46229899f, 0.21955173f, 0.14776509f, 0.03691433f, 0.21721408f, 0.06181122f, 0.07477540f, 
    -0.16164787f, -0.16476603f, 0.79808748f, -0.46607754f, 0.00931679f, 0.26947787f, -0.09988748f, 0.12769783f, 
    0.06887217f, 0.69315666f, -0.05484800f, -0.12634180f, -0.30670530f, 0.04164371f, -0.14640296f, 0.16416612f, 
    -0.06934147f, 0.17896248f, 0.18153906f, 0.17840368f, -0.01140350f, -0.46798342f, 0.05170927f, -0.11824371f, 
    0.05633118f, -0.10525180f, 0.22341011f, 0.26192388f, -0.16163693f, 0.06794558f, -0.53656167f, -0.04912867f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.14703971f, -0.04805072f, 0.13069417f, -0.15003493f, 0.09460231f, -0.02425797f, -0.04606758f, -0.18774515f, 
    0.19995332f, 0.02817274f, -0.11282994f, 0.12362581f, 0.06229989f, -0.01767928f, 0.14708811f, -0.03387781f, 
    0.10439860f, -0.07677779f, 0.26334438f, -0.14319633f, 0.08078932f, -0.25624412f, 0.11516611f, 0.26413015f, 
    0.11750419f, 0.09480353f, -0.16991647f, 0.20814212f, -0.06579964f, -0.00826462f, 0.35567519f, 0.15215428f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.06238076f, -0.06512281f, 0.49281365f, -0.14050525f, -0.17482905f, -0.29717290f, 0.07356490f, 0.26911747f, 
    0.55686778f, 0.38798639f, 0.13680832f, -0.14162882f, -0.15711476f, 0.12586829f, 0.42824328f, 0.04041245f, 
    0.00166346f, 0.01602331f, -0.09734798f, 0.21318825f, -0.07572811f, 0.22498769f, 0.04251930f, 0.00462736f, 
    -0.04601944f, 0.49732837f, -0.03062845f, 0.08060203f, -0.30836526f, 0.15586782f, 0.00808003f, 0.03489228f, 
    0.06002796f, -0.07115235f, -0.20451774f, 0.05189664f, 0.01392880f, 0.07414932f, -0.16706096f, 0.06900930f, 
    -0.10828467f, 0.05698609f, 0.03166984f, 0.15478741f, -0.10260081f, -0.00773626f, -0.14768390f, -0.10206797f, 
    0.07086893f, -0.08990077f, -0.07623378f, 0.02391415f, 0.10708296f, -0.11686520f, 0.15669855f, -0.15488188f, 
    0.09692089f, -0.00753333f, -0.00954731f, -0.06072266f, 0.00257733f, 0.01799402f, -0.14571507f, 0.00103362f, 
    0.22820605f, -0.15442747f, -0.45374697f, 0.05494466f, -0.05161872f, 0.39231861f, -0.04008880f, -0.24222299f, 
    0.08430214f, -0.27976045f, 0.00197526f, 0.00264445f, -0.15133016f, 0.10963624f, 0.01564063f, 0.00993473f, 
    0.06230066f, 0.19069530f, 0.34548384f, -0.21369024f, -0.07972671f, -0.11433747f, -0.16829419f, 0.33078247f, 
    0.34635308f, -0.05867645f, 0.06124523f, 0.09938280f, 0.31968990f, 0.10557742f, 0.07250758f, 0.23722388f, 
    0.19376785f, 0.06408091f, -0.15354931f, 0.15630464f, 0.07281032f, 0.48079634f, -0.11546249f, -0.17270055f, 
    -0.36481193f, -0.27453822f, 0.28783348f, -0.02450069f, -0.05895120f, -0.06235666f, -0.14148095f, -0.16631135f, 
    0.12275907f, -0.02820433f, 0.39249018f, -0.41644526f, 0.00035093f, -0.43139622f, -0.00426710f, 0.41259778f, 
    0.23473960f, -0.05156243f, -0.02153647f, -0.09981593f, 0.36295682f, -0.08457018f, 0.26725921f, 0.35672548f, 
    -0.28335497f, 0.38900527f, -0.10802665f, 0.11339261f, 0.06909504f, -0.06111874f, 0.08575311f, 0.20384109f, 
    -0.02414794f, 0.40106568f, -0.34127039f, -0.14558728f, 0.07219976f, -0.09028200f, -0.20766181f, -0.15597080f, 
    0.10216051f, -0.51120347f, -0.04996571f, 0.76339805f, 0.04813625f, -0.13202713f, -0.12362154f, -0.26738772f, 
    -0.57395661f, -0.39341933f, 0.04034455f, 0.50758481f, 0.17624752f, 0.09300712f, 0.19168633f, -0.06194145f, 
    0.09933889f, -0.25311962f, 0.27357528f, 0.06333920f, 0.16733578f, 0.04339584f, 0.16940449f, -0.20849100f, 
    0.47077543f, -0.12299361f, 0.18048701f, -0.01874887f, 0.13394976f, 0.09636810f, -0.22322407f, -0.01570416f, 
    -0.03605084f, 0.37135357f, 0.28998354f, 0.55705720f, -0.00862694f, -0.34516436f, 0.03329143f, -0.14565013f, 
    -0.15479864f, -0.01179256f, -0.05944476f, -0.20968650f, 0.14545862f, 0.13936742f, 0.21429731f, 0.05226395f, 
    -0.17544460f, -0.06067386f, -0.00640306f, -0.05002392f, -0.12178352f, 0.13892843f, -0.14904153f, -0.16289002f, 
    -0.09597486f, -0.06900712f, 0.13113353f, 0.11298539f, 0.03122487f, -0.00640162f, -0.10945341f, 0.02274282f, 
    0.15764205f, 0.01130969f, -0.20369735f, -0.17482127f, 0.03073304f, 0.10720354f, 0.16718534f, -0.00029334f, 
    0.07815162f, 0.02530311f, -0.12012815f, 0.01640887f, -0.00750907f, -0.09567516f, 0.04812821f, 0.07417249f, 
    -0.17888972f, -0.02926875f, 0.18115820f, -0.02346033f, 0.09962187f, 0.06801613f, 0.17004910f, -0.06371257f, 
    0.13704219f, -0.08192924f, -0.31889099f, 0.02368080f, 0.13319342f, 0.05544696f, 0.36000216f, 0.17616756f, 
    0.07198104f, 0.05290484f, 0.07256453f, 0.09925008f, -0.09653381f, -0.05598396f, -0.07280172f, -0.03302893f, 
    -0.08174057f, 0.31543502f, 0.12529446f, -0.06096460f, 0.01566607f, -0.07362112f, -0.09496554f, -0.05868097f, 
    0.29584354f, 0.58358043f, -0.00084890f, 0.15786617f, 0.05799172f, 0.17914927f, 0.05347036f, 0.32109949f, 
    -0.40005422f, 0.41358447f, -0.31628430f, 0.17781448f, 0.00547108f, -0.07147176f, -0.07129850f, -0.10875826f, 
    0.11745592f, -0.38709140f, -0.06215646f, -0.27669364f, 0.03576776f, 0.13409764f, 0.11918318f, 0.37075576f, 
    0.38821268f, -0.07056729f, -0.08669081f, 0.61208242f, -0.12567186f, 0.06804470f, 0.36122236f, -0.28277323f, 
    0.41034883f, 0.05628360f, -0.35324252f, 0.12161227f, 0.17471832f, 0.46963236f, 0.14919323f, -0.72434169f, 
    -0.00730362f, -0.01488622f, -0.24160610f, -0.03954539f, 0.14131187f, 0.05443784f, -0.28968602f, -0.11311636f, 
    -0.09877273f, -0.22524178f, 0.29176071f, 0.43294564f, 0.12014379f, -0.38866675f, 0.02328055f, 0.36467949f, 
    -0.01360603f, 0.65470839f, 0.06318493f, -0.13203281f, 0.26817513f, 0.15319274f, 0.09068979f, -0.10410653f, 
    -0.18808855f, -0.16028142f, 0.32033098f, -0.05709546f, 0.10610761f, -0.26626536f, 0.04405943f, -0.04228995f, 
    0.15752576f, -0.03186191f, -0.11401279f, -0.07737254f, 0.05253187f, 0.02540768f, 0.51269501f, -0.04965481f, 
    0.14190722f, 0.29756895f, 0.00863043f, 0.22939809f, 0.07069854f, 0.39417654f, -0.02821205f, -0.12875083f, 
    0.38459873f, 0.67220294f, 0.06069616f, -0.11499310f, -0.19738437f, 0.06894264f, -0.21107610f, -0.12227546f, 
    -0.03539715f, -0.06686670f, 0.06279692f, 0.06802815f, -0.13300198f, -0.12298317f, -0.08337738f, 0.06285360f, 
    -0.04302396f, -0.13219121f, 0.03349427f, -0.00015416f, -0.03864069f, -0.16062726f, 0.09654155f, 0.05303081f, 
    0.06539539f, -0.02553072f, -0.01843356f, -0.11224768f, -0.05407266f, -0.16831471f, -0.00399398f, -0.05966078f, 
    -0.17422037f, -0.03786054f, 0.00573709f, -0.08786870f, -0.03886686f, 0.01815355f, -0.15422620f, 0.11446038f, 
    0.46930194f, 0.01679905f, -0.16978267f, -0.15164776f, -0.02144202f, 0.09286638f, -0.11656547f, -0.10284572f, 
    -0.35468677f, -0.05932042f, 0.56855762f, 0.01751760f, 0.02326774f, 0.02686118f, -0.61040890f, -0.09981474f, 
    0.12421449f, 0.02714264f, 0.22455154f, -0.01763762f, -0.01947752f, -0.07575790f, 0.04248853f, 0.17838132f, 
    0.47014663f, -0.12799022f, -0.12164562f, 0.00368900f, -0.05416432f, -0.17814210f, 0.03673762f, -0.02790001f, 
    0.00037987f, 0.29316208f, 0.71349788f, 0.11912012f, 0.12114740f, -0.14128257f, -0.00571391f, 0.03583525f, 
    0.23435548f, 0.04802042f, -0.88791686f, -0.15099642f, -0.15664163f, 0.01280567f, 0.64787328f, -0.09127931f, 
    -0.08294266f, 0.20840193f, 0.13269946f, -0.37789586f, 0.09681276f, -0.28402215f, -0.06419937f, 0.27576131f, 
    -0.04895199f, 0.42457774f, 0.16605908f, 0.14642930f, -0.14647955f, -0.16646710f, 0.32395199f, -0.00349038f, 
    0.14453503f, 0.07336366f, -0.43294308f, 0.07005247f, 0.02279647f, 0.11050465f, -0.13351470f, -0.04315937f, 
    -0.26927119f, 0.30422339f, 0.15116581f, -0.15495151f, -0.04872827f, 0.15826818f, -0.47734308f, -0.03837419f, 
    -0.15110159f, -0.58587301f, 0.00660568f, 0.73868757f, 0.05546757f, -0.07163510f, 0.10718340f, 0.05947888f, 
    0.08301206f, 0.28996041f, 0.13246515f, 0.27728480f, -0.00773804f, 0.17520015f, -0.00160052f, -0.12011211f, 
    -0.23592383f, 0.00105603f, 0.04519458f, -0.06555890f, 0.07387023f, 0.40660802f, -0.11883561f, 0.13343360f, 
    0.20321366f, 0.02826299f, 0.02852012f, -0.08287953f, -0.17209660f, -0.10211322f, -0.41087958f, 0.03345071f, 
    0.11716758f, -0.00726594f, 0.19210255f, 0.54941505f, 0.01517183f, -0.07634836f, -0.03465495f, -0.19468068f, 
    -0.36438799f, -0.25224933f, 0.17507397f, 0.18302050f, 0.22745143f, 0.15776645f, 0.25439030f, 0.02460327f, 
    -0.18109277f, 0.31141832f, 0.73439503f, 0.04957704f, -0.17354019f, -0.38941959f, 0.13053949f, -0.14109482f, 
    0.34234905f, 0.01021863f, -0.69340980f, 0.01757536f, 0.14473984f, 0.10423466f, 0.36095375f, -0.15842289f, 
    0.03569551f, 0.05418457f, 0.23335148f, 0.00566132f, 0.15840343f, -0.49505001f, -0.01359826f, 0.09242160f, 
    -0.15088017f, 0.46333370f, 0.14998646f, 0.14336087f, -0.25405955f, -0.15502962f, 0.32090229f, -0.01609928f, 
    0.16063517f, -0.23538318f, 0.02802082f, -0.12879059f, -0.16036266f, 0.17163485f, -0.07680582f, -0.12144919f, 
    0.42245224f, 0.05694255f, 0.33228797f, 0.14807853f, -0.01998298f, 0.02515998f, 0.18972990f, -0.04991979f, 
    -0.03165670f, 0.65619576f, 0.14376654f, 0.33209336f, 0.13661419f, -0.26284820f, 0.09259176f, 0.12325189f, 
    -0.33427507f, -0.20951913f, -0.12186804f, -0.38211054f, 0.20990868f, 0.13752519f, -0.11119680f, 0.54212457f, 
    0.01747066f, 0.05597438f, -0.07297517f, 0.02673103f, -0.17580441f, 0.21550418f, 0.14454442f, 0.27964514f, 
    -0.03650043f, 0.38335246f, 0.28831246f, 0.09004492f, 0.17168352f, 0.08379864f, -0.23528101f, 0.06244424f, 
    0.10276461f, -0.25168571f, -0.08483631f, -0.14121112f, 0.00199489f, -0.07633269f, 0.16218036f, 0.09401833f, 
    -0.18291087f, -0.37582859f, -0.10114774f, 0.38931546f, 0.19809966f, 0.09121703f, 0.20801309f, 0.25374794f, 
    -0.14484750f, 0.09373792f, 0.00612009f, -0.06474525f, -0.01843754f, -0.01182510f, 0.13378744f, -0.07548204f, 
    0.01997746f, -0.02014771f, 0.14761358f, -0.17576765f, -0.17637408f, 0.02575248f, 0.08259036f, -0.12391209f, 
    -0.01194741f, -0.08172268f, -0.02818358f, -0.12354606f, -0.10412421f, -0.01312491f, 0.09259323f, 0.03133389f, 
    -0.00539633f, -0.16437469f, 0.00353962f, -0.00086579f, 0.04753839f, -0.10174438f, -0.02529615f, -0.11275806f, 
    0.02616928f, 0.02603062f, -0.07840919f, 0.15495828f, -0.05866207f, -0.09214345f, 0.11264390f, -0.09718560f, 
    -0.05213683f, -0.08122168f, 0.11985344f, -0.05511092f, 0.04309077f, 0.01935145f, 0.06480069f, -0.01655301f, 
    -0.15767805f, -0.10291376f, 0.06232087f, 0.04146133f, 0.03179057f, -0.06359589f, 0.04576187f, -0.14716779f, 
    0.00098344f, -0.06105805f, 0.07789635f, -0.16716282f, -0.02472403f, -0.03289290f, -0.15534456f, -0.00051696f, 
    -0.05166776f, -0.00980213f, -0.16189452f, 0.13627429f, 0.06250513f, 0.08495312f, 0.14611036f, 0.01037150f, 
    -0.10380855f, 0.01431756f, 0.10389408f, 0.03415865f, -0.08761460f, 0.11903214f, 0.11689527f, 0.08427376f, 
    0.00431957f, 0.11563618f, -0.16335721f, -0.17095095f, -0.17388009f, 0.05339683f, 0.11904961f, -0.15534949f, 
    -0.07172359f, -0.01539561f, -0.16128966f, -0.00437183f, -0.12848112f, -0.11132036f, -0.16579156f, -0.06033568f, 
    0.28008664f, -0.04602860f, -0.00343141f, 0.02336589f, -0.09155246f, -0.28997469f, 0.01734147f, 0.54296625f, 
    -0.04372239f, -0.11852655f, 0.53582925f, 0.05983931f, 0.17237127f, 0.12872906f, 0.19135942f, -0.15783042f, 
    0.01925176f, 0.55969059f, 0.30108365f, -0.55390555f, 0.13153882f, 0.74511510f, 0.10863981f, 0.03266415f, 
    0.55006498f, -0.18733282f, 0.05094547f, 0.04505803f, 0.06796235f, -0.09820253f, -0.16080883f, 0.44746298f, 
    0.32142034f, -0.08712846f, 0.10558515f, -0.13286802f, -0.11882102f, -0.24142581f, 0.10480269f, 0.21751928f, 
    -0.12674026f, -0.08178218f, 0.42769393f, 0.08646960f, 0.08752120f, -0.00588924f, -0.11672421f, 0.17646152f, 
    -0.08178551f, 0.19522315f, 0.23035234f, 0.06307419f, -0.09483241f, 0.18513101f, -0.03663168f, 0.00374473f, 
    0.58213812f, 0.11846753f, 0.01558135f, 0.05385465f, -0.22725946f, 0.10575517f, -0.28211984f, -0.23104121f, 
    -0.37265491f, 0.22779731f, -0.08306648f, 0.11936513f, -0.09399837f, 0.31890810f, 0.05061202f, 0.35000288f, 
    -0.03892119f, -0.14107414f, 0.24034308f, 0.09587059f, -0.13250203f, 0.09731905f, 0.11757281f, 0.16689187f, 
    0.15464067f, -0.34955949f, -0.05486356f, -0.07321184f, 0.02482111f, 0.58165723f, 0.08521370f, -0.02738080f, 
    0.05770871f, 0.04541005f, 0.11090577f, 0.01191283f, 0.30777678f, -0.07645954f, -0.09274658f, -0.10157222f, 
    -0.15482059f, 0.07390010f, -0.17251076f, -0.03862258f, 0.11563340f, 0.12902939f, -0.11229431f, 0.05289283f, 
    -0.01310492f, -0.25975078f, -0.08610628f, -0.10157249f, 0.06735585f, 0.15270834f, -0.15170971f, -0.02900660f, 
    -0.09013529f, -0.13744235f, -0.08623279f, 0.02820323f, 0.16035248f, -0.08543574f, 0.05932903f, 0.03707692f, 
    -0.25997794f, -0.13288589f, -0.04850350f, -0.09949891f, -0.05419572f, 0.03692209f, -0.02208465f, 0.10612120f, 
    0.26037407f, -0.33771110f, 0.08928765f, -0.06987525f, -0.17099516f, -0.21779159f, -0.03371961f, 0.19221824f, 
    0.53121817f, 0.25143960f, 0.45914665f, -0.00268328f, -0.00879059f, -0.16332915f, -0.12389556f, -0.05294327f, 
    -0.02391046f, 0.24267419f, 0.07865745f, 0.13460864f, -0.10094676f, -0.09752756f, 0.05291487f, -0.19686089f, 
    0.28236735f, 0.49182630f, 0.11395570f, -0.32034755f, -0.13243976f, -0.00592079f, 0.05620439f, 0.13790262f, 
    0.34615082f, 0.36144450f, -0.02253997f, 0.05948078f, -0.06624186f, 0.44327369f, -0.03927142f, 0.00033402f, 
    -0.38085437f, -0.04864129f, -0.10975771f, -0.17848067f, 0.10392011f, 0.11436275f, -0.17392801f, -0.13653812f, 
    0.02762749f, -0.15347075f, 0.23757060f, -0.63165426f, 0.06524149f, 0.08857479f, 0.16395094f, 0.27477467f, 
    -0.04395040f, -0.37519911f, 0.17111029f, 0.37034449f, 0.22673009f, -0.04025736f, 0.21407406f, 0.19834149f, 
    -0.23564337f, -0.00815297f, 0.12358952f, -0.12026039f, -0.09862109f, -0.35409561f, -0.03242353f, 0.21958962f, 
    0.13860463f, 0.27637893f, 0.47065714f, 0.09521042f, 0.13302812f, 0.14087422f, 0.23427962f, -0.13005850f, 
    -0.09997590f, 0.09177900f, -0.23343284f, 0.12659805f, -0.04040437f, 0.05765112f, 0.04280450f, -0.24124974f, 
    -0.18007553f, 0.27386507f, -0.07966193f, -0.03317873f, 0.05918035f, 0.16896203f, 0.13486053f, 0.05215850f, 
    -0.02278407f, -0.16829646f, 0.35551295f, 0.17282598f, -0.01987441f, 0.13917212f, 0.15698090f, -0.28161675f, 
    0.16819298f, 0.00310436f, -0.17567778f, -0.13970277f, -0.11451396f, -0.02398257f, 0.13977768f, -0.00217724f, 
    -0.01416083f, 0.15350752f, 0.12394716f, 0.03241409f, -0.01989847f, -0.22065285f, -0.05787607f, 0.11582400f, 
    0.10347711f, 0.51132846f, -0.00210880f, -0.27505946f, 0.31606787f, -0.13668598f, 0.13208519f, 0.38777038f, 
    0.13251744f, 0.17953369f, -0.23140933f, 0.11168206f, -0.08048413f, 0.20460346f, -0.15335089f, 0.52292806f, 
    -0.28869531f, 0.23098026f, 0.39467540f, -0.09705017f, -0.03139438f, 0.10303969f, -0.19276983f, 0.01329381f, 
    -0.05924954f, -0.29210940f, -0.24739024f, 0.00445423f, 0.17612135f, 0.68469030f, -0.10435379f, 0.22361678f, 
    0.33763415f, 0.11390738f, 0.05100130f, 0.30448270f, -0.09514500f, -0.02740935f, 0.02901709f, 0.01446600f, 
    -0.07965867f, -0.07434144f, 0.08100198f, -0.12974837f, -0.14988579f, 0.13354680f, 0.01808964f, 0.00997761f, 
    -0.17765497f, -0.10041657f, -0.08787120f, 0.04979606f, 0.13409312f, -0.16293962f, -0.08059175f, 0.04708422f, 
    0.11801589f, 0.02345582f, 0.02500958f, 0.13099860f, -0.09665404f, -0.08977307f, -0.03202229f, 0.02005990f, 
    -0.02199708f, -0.05488951f, 0.03055134f, 0.07203928f, -0.10082231f, 0.06919741f, -0.20135152f, -0.15534385f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.03650871f, -0.06193882f, 0.04533608f, 0.08192836f, 0.00923538f, 0.17267720f, -0.17732847f, -0.03371831f, 
    0.22424784f, 0.38337433f, 0.20653632f, 0.09575232f, 0.08561340f, 0.30394632f, 0.07145797f, 0.07013894f, 
    0.24380089f, 0.04825360f, 0.23790120f, -0.16625498f, -0.09439162f, -0.15307052f, 0.19152436f, -0.22491874f, 
    0.19328797f, -0.01032839f, -0.13149478f, 0.10665084f, -0.48200119f, 0.37163126f, 0.06962782f, -0.20437986f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.04003087f, -0.07853451f, 0.04869423f, -0.06483988f, 0.13525386f, -0.13149944f, 0.04015273f, -0.18081817f, 
    0.32448611f, 0.26843825f, -0.55276841f, 0.10654873f, -0.02813322f, 0.28577328f, 0.22726817f, -0.09070567f, 
    0.33414152f, -0.27430809f, 0.13588247f, 0.10472164f, 0.09240983f, -0.06702232f, -0.42911348f, -0.47090968f, 
    -0.56970507f, 0.09719104f, -0.00464850f, 0.01466918f, -0.91106677f, -0.04589605f, -0.06749185f, -0.11120476f, 
    0.34945506f, 0.01788593f, -0.03740489f, -0.11142778f, -0.05695705f, 0.06283141f, -0.11726508f, 0.23211688f, 
    -0.44266441f, 0.17469198f, 0.29703781f, -0.08397070f, -0.69061083f, 0.24329324f, -0.28830993f, -0.27225751f, 
    0.30345663f, 0.18595116f, -0.31344670f, 0.02189094f, 0.00225864f, -0.13815737f, -0.17758210f, -0.66703326f, 
    0.15578371f, 0.12055951f, 0.25226873f, -0.58621049f, 0.13800585f, 0.24769415f, -0.34339729f, -0.00056222f, 
    -0.21045806f, -0.12892233f, 0.21326709f, 0.21688588f, -0.97214556f, -0.18884374f, -0.01783277f, -0.18814473f, 
    0.21322171f, 0.09325705f, 0.18459871f, -0.15310094f, 0.29944745f, 0.17715904f, -0.27100626f, -1.19925010f, 
    -0.01269293f, -0.31132600f, -0.79329544f, -0.15929984f, -0.01665793f, 0.09348731f, 0.15001984f, 0.42730054f, 
    -0.07542378f, 0.09952176f, 0.00790842f, -0.00566287f, -1.03738344f, -0.04941354f, 0.09171233f, -0.01529079f, 
    -0.03411222f, 0.12912352f, -0.16690324f, -0.49336946f, 0.24323182f, -0.97596186f, 0.11158660f, 0.12610596f, 
    0.33739242f, -0.62551433f, -0.18591917f, 0.01501045f, -0.29478863f, -0.07492322f, -0.04380424f, 0.12964261f, 
    -0.26285467f, -0.67624038f, 0.30701670f, 0.12249567f, 0.12183595f, -0.15713310f, 0.04765256f, -0.66323787f, 
    0.52791321f, 0.05042767f, -0.65845925f, 0.27781674f, -0.33552665f, -0.68206418f, 0.31867701f, -0.00520799f, 
    -0.19509585f, 0.06865439f, -0.04117910f, 0.08443981f, 0.07013693f, -0.02890204f, -0.06267070f, -0.19453803f, 
    0.16903184f, 0.23641859f, 0.22990447f, 0.14456299f, 0.30685410f, -0.47554383f, 0.38212618f, 0.18287708f, 
    -0.59229672f, -0.33542418f, -0.00756256f, -0.10003004f, -0.08269917f, -0.04109608f, -0.35377711f, -0.16410209f, 
    0.23249970f, -0.04093163f, 0.05384875f, 0.01331402f, -0.31217200f, -0.00529212f, 0.29476470f, 0.02724830f, 
    -0.05659486f, -0.16736929f, 0.01552592f, 0.18477166f, 0.42597950f, 0.34306848f, 0.00740293f, -0.09334998f, 
    -0.25114843f, -0.00287066f, -0.41007161f, -0.09242156f, -0.07826822f, 0.17032844f, -0.60414326f, 0.25691676f, 
    0.25637585f, 0.17207748f, -0.09822985f, 0.11890437f, -0.10928257f, -0.00196754f, -0.12032966f, -0.02145362f, 
    -0.37247112f, -0.06563831f, 0.12578095f, 0.08273306f, 0.24241623f, 0.03541131f, -0.60609955f, -0.01332012f, 
    -0.70093125f, 0.08209957f, 0.35358375f, 0.49319714f, -0.85237718f, -0.16573569f, -0.00429453f, -0.26536137f, 
    0.13728786f, 0.06802736f, -1.01140189f, 0.03353335f, -0.04270079f, 0.05090007f, -0.52069467f, -0.18902048f, 
    -0.17221506f, 0.16257982f, 0.12532660f, 0.14319047f, 0.01666476f, -0.01008062f, 0.13821480f, -0.89697814f, 
    0.10897730f, -0.06062415f, -0.48665336f, 0.43514273f, -0.52953947f, 0.18187387f, -0.14342210f, 0.06846782f, 
    0.07954717f, 0.03046675f, -0.63016456f, -0.74562484f, 0.46772671f, 0.16344383f, -0.04646795f, 0.02982961f, 
    0.09086043f, -0.27614591f, -0.24841808f, 0.03792861f, -0.10274278f, -0.30535394f, 0.43682688f, 0.47918734f, 
    0.11120839f, 0.11950571f, 0.12152299f, 0.03388206f, -0.00012996f, 0.13871273f, -0.77647322f, -0.24232170f, 
    -0.15214053f, -0.05195683f, -0.33602577f, -0.47785646f, -0.06236409f, -0.45591220f, -0.06501939f, 0.17187572f, 
    0.13388319f, -0.02666071f, 0.12007871f, -0.60312110f, -0.05422160f, 0.30690858f, -0.07641858f, -0.03112961f, 
    -0.85697097f, -0.54532784f, 0.34617436f, -0.16876227f, -0.26405314f, -0.30984202f, -0.45513600f, 0.08198150f, 
    -0.38187551f, 0.46708933f, -0.63770968f, -0.10115668f, 0.22680126f, -0.12409691f, 0.29718485f, 0.36426911f, 
    0.15395427f, 0.07765056f, 0.29936469f, -0.78540874f, 0.03729594f, 0.10198899f, -0.08258995f, 0.03171140f, 
    -0.57054120f, 0.08577972f, 0.28421697f, 0.27965853f, -0.05076861f, 0.09322170f, -0.06022780f, -0.24683039f, 
    -0.32057270f, 0.28427523f, -0.59821212f, 0.11456482f, 0.40624678f, -0.70011723f, 0.11010306f, 0.23676719f, 
    -0.72552639f, 0.07887196f, -0.09293417f, 0.08344616f, -0.05898074f, 0.07130875f, 0.10082393f, 0.22629116f, 
    -0.14994685f, 0.03271721f, 0.19272356f, -0.00179832f, -0.32077065f, 0.03815927f, -0.22818547f, -0.00320180f, 
    0.13923050f, -0.13665804f, -0.28377950f, -0.26788354f, -0.17079523f, -0.43229508f, -0.11005743f, 0.18241750f, 
    0.26481420f, -0.91658676f, 0.26547208f, -0.04030841f, -0.54129177f, 0.24888116f, -0.01422190f, -0.28116009f, 
    0.48067018f, -0.68321651f, -0.10876743f, 0.03081525f, 0.10737716f, -0.02065564f, 0.29516631f, 0.09682581f, 
    0.12182656f, -0.08339301f, -0.12481326f, -0.02295889f, -0.37987870f, -0.05004441f, 0.13507661f, 0.12974459f, 
    0.17734833f, 0.12706725f, -0.06899999f, 0.16615900f, -0.70869696f, -0.31687984f, -0.09678508f, -0.20375179f, 
    0.18436290f, -0.69212383f, -0.33869106f, -0.04388059f, 0.32890922f, -0.12152064f, -0.25503102f, -0.54193103f, 
    -0.33704469f, 0.02505296f, 0.34384319f, -0.17333291f, -0.03595130f, -0.12522969f, 0.35021293f, 0.00856657f, 
    -0.11718509f, -0.16021934f, 0.33876088f, 0.06901303f, 0.08860802f, -0.24769491f, 0.36166021f, -0.17842214f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.01905862f, 0.10524435f, -0.26667139f, 0.15518206f, -0.11838894f, 0.05549816f, 0.08149962f, -0.22405313f, 
    0.08294318f, -0.09359035f, 0.15685549f, -0.01947239f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
