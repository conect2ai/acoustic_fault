#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.93657529f, 0.08434286f, 0.74652225f, -0.28371149f, 0.07224283f, 1.02738309f, -0.50452292f, -0.80768269f, 
    0.41581777f, 0.71388859f, 1.17938757f, -1.08304906f, 0.11684190f, 0.23160000f, 0.52402544f, 0.60972106f, 
    0.13533355f, 0.46878135f, 0.84851551f, 1.40718353f, -0.60309649f, 1.01000917f, 0.10194452f, -0.34581664f, 
    -0.07585097f, 0.08426671f, -0.45475873f, -0.82922810f, -0.98031092f, -0.89548618f, 0.79391235f, 1.31161082f, 
    0.11794689f, -0.20789531f, -0.00646617f, -0.23574050f, -1.12213552f, 0.30430073f, 0.90099430f, 0.90235049f, 
    -0.20372182f, 0.59586942f, 0.38307646f, 0.56942511f, -0.30571261f, -0.54924285f, -0.22535586f, 0.97839189f, 
    1.18570065f, 0.80277705f, 1.03879714f, -0.20822842f, -0.22885033f, -0.05312563f, 1.24698865f, 1.32531130f, 
    0.77096987f, -1.04660368f, 0.14625420f, -0.69837475f, 0.04464090f, 0.13688324f, 0.34905010f, -0.42183200f, 
    -0.64749932f, 0.28632954f, -0.65507281f, 0.82287174f, -1.07167912f, -0.59072328f, -0.60766864f, -0.44585234f, 
    -1.05365121f, 0.13792385f, 0.25641301f, -0.74525797f, 1.38298869f, -0.21873353f, 0.49647084f, 0.42116958f, 
    -0.11007082f, -1.51189303f, -1.20285213f, -0.81234211f, -0.07891575f, -0.87181205f, 0.05921524f, -0.10410409f, 
    -0.01056499f, 0.05831043f, 0.39752376f, -0.21122244f, -0.56720495f, 0.95736259f, 0.60633159f, 0.29649779f, 
    -0.44955915f, 0.97547090f, -0.06717182f, -0.90359330f, 0.51917702f, 0.62387866f, 0.54134059f, 0.69557899f, 
    0.41712642f, -0.10212764f, 0.33063170f, 0.91982442f, 1.03975117f, 0.75803703f, 1.11575329f, 0.67223448f, 
    0.53921682f, 0.40628603f, 0.10636364f, 0.75049806f, 0.15650974f, 0.01501500f, -1.44534171f, -1.29650140f, 
    -0.45320132f, 0.18224005f, 0.38905612f, -0.29604307f, 0.42381769f, 0.14213961f, -1.46376503f, 0.68061483f, 
    -0.03093354f, 0.77676928f, 1.31302404f, 0.78975427f, 0.15070072f, -0.04490840f, -0.42860225f, -0.69226938f, 
    1.33539653f, -0.30193612f, -0.40263239f, -0.92786705f, -1.25040710f, 0.18116128f, 0.08754008f, -0.07029965f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.73390836f, -0.24841729f, -0.03273852f, 0.15092927f, -0.24793184f, 0.31059834f, 0.18568003f, -0.06255940f, 
    0.08497899f, -0.37864411f, 0.01291234f, 0.02133057f, 0.63164485f, 0.27335793f, 0.04837372f, 0.39625141f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.59117091f, -0.59496814f, 0.00710817f, 0.11043081f, 0.12334210f, -0.10869051f, 0.19910298f, 0.23638271f, 
    0.08542942f, 0.07290173f, 0.20061512f, 0.20842670f, 0.10386378f, 0.00411948f, -0.23212132f, -0.22001198f, 
    0.02964877f, 0.05641312f, 0.38614318f, 0.26885191f, -0.63456142f, -0.23204277f, -0.02730937f, -0.16019315f, 
    -0.08431474f, -0.16028090f, -0.05102289f, 0.39560091f, 0.24003851f, 0.05858514f, 0.24757597f, -0.06593581f, 
    -0.05459100f, 0.05001182f, 0.15159279f, 0.09196346f, -0.13635524f, -0.08376645f, -0.30431169f, 0.19105624f, 
    -0.00832573f, -0.05817235f, 0.10796320f, 0.07675691f, -0.11399208f, -0.07889876f, -0.25956601f, 0.18784907f, 
    -0.03106295f, 0.06896390f, 0.20140457f, -0.18179193f, 0.03114045f, -0.00839973f, -0.60320270f, -0.78781396f, 
    0.27249897f, 0.27180821f, 0.18216336f, 0.26598993f, -0.08764662f, -0.12855576f, 0.18747111f, -0.30352405f, 
    0.14799252f, 0.02705764f, 0.02705163f, 0.06038355f, 0.32674134f, -0.07172612f, -0.20723943f, -0.31005719f, 
    -0.02399635f, 0.22888061f, -0.26449731f, 0.26879081f, -0.34192312f, -0.09958676f, -0.05238012f, -0.05053157f, 
    -0.19482645f, 0.39865217f, 0.52175760f, 0.23577754f, -0.12341522f, 0.00515904f, -0.27238363f, 0.01812511f, 
    0.08193310f, -0.05552785f, -0.02529501f, 0.17085965f, -0.05303006f, 0.05730417f, 0.13342109f, -0.14957002f, 
    0.04007587f, -0.09858520f, 0.14103025f, -0.33413360f, 0.10360055f, 0.16236486f, 0.01380888f, -0.05115138f, 
    -0.05775398f, -0.00747415f, -0.11028712f, 0.15396249f, -0.45084688f, -0.38102445f, -0.18247013f, 0.06535319f, 
    0.06197495f, 0.24681698f, 0.19619730f, -0.00184266f, -0.04166174f, 0.20888960f, 0.30549210f, 0.04789450f, 
    -0.05651670f, -0.51868135f, -0.11567698f, 0.05818050f, 0.50122291f, -0.08509259f, 0.16012178f, 0.07006687f, 
    -0.04990954f, 0.20145854f, 0.14205119f, 0.08182520f, -0.17059515f, 0.32567886f, 0.09920286f, 0.82177752f, 
    -0.42690498f, 0.21463464f, 0.20847632f, -0.43823633f, -0.31250638f, -0.01840167f, -0.09435333f, -0.47362664f, 
    -0.17416514f, 0.31225440f, -0.13545276f, 0.19184168f, 0.04685199f, 0.20980021f, 0.08373432f, -0.19988370f, 
    -0.04527374f, -0.09681732f, -0.08134200f, 0.01626107f, 0.12791701f, 0.16191778f, -0.25569814f, 0.08033270f, 
    -0.11680736f, -0.45685464f, 0.19497605f, 0.12067706f, -0.00376257f, 0.37828213f, 0.05210241f, 0.11525454f, 
    0.28715724f, -0.00556312f, -0.06837483f, -0.04049071f, -0.23598231f, 0.18798643f, -0.03951037f, 0.02922673f, 
    0.05850439f, -0.19957811f, 0.21608612f, 0.22242299f, 0.28838938f, -0.01245621f, -0.23459481f, -0.12721205f, 
    0.26536629f, 0.09911679f, 0.12623322f, -0.05872879f, 0.05624564f, -0.49167651f, -0.52496094f, -0.07351557f, 
    0.14884202f, 0.40687722f, 0.23681737f, -0.22489083f, 0.06251927f, -0.28410682f, 0.59113204f, 0.68300974f, 
    -0.01907458f, 0.27963665f, -0.34363133f, -0.07457561f, 0.11295517f, 0.00059767f, 0.09219579f, -0.32613224f, 
    -0.19216467f, 0.12625931f, 0.08783589f, -0.33862814f, 0.40709257f, -0.05699845f, 0.25440925f, 0.07617293f, 
    0.19610023f, 0.20558318f, -0.10681055f, 0.03917488f, -0.18909429f, 0.04089493f, 0.01003032f, 0.25913605f, 
    0.12243447f, 0.22201900f, 0.27529100f, -0.23716471f, 0.12768897f, -0.14110856f, 0.09385156f, -0.04209115f, 
    -0.18664619f, 0.08354630f, -0.28978455f, -0.26711965f, 0.03126604f, 0.19302453f, 0.22625141f, -0.10210322f, 
    -0.02729100f, -0.12691531f, -0.23932116f, -0.14653219f, 0.07085948f, -0.09181945f, 0.08724267f, 0.25613615f, 
    0.24120726f, 0.25185528f, 0.10224012f, -0.60441661f, -0.03394340f, -0.37972927f, -0.16082302f, -0.07766867f, 
    0.12186918f, 0.15633485f, 0.19655749f, 0.13265662f, -0.00141803f, -0.07765833f, -0.02964442f, 0.10110441f, 
    0.17014578f, -0.12365094f, -0.00095144f, 0.09480310f, 0.05144328f, -0.18364605f, -0.00009023f, -0.06565381f, 
    0.20863700f, -0.20005360f, -0.00088063f, 0.29306662f, -0.06253745f, 0.08706253f, -0.09814392f, 0.11740025f, 
    0.08705324f, -0.01678625f, -0.27516031f, -0.07487143f, -0.17116237f, 0.32090107f, 0.22636022f, 0.05120228f, 
    -0.05040028f, 0.10442554f, -0.24637905f, 0.04674929f, -0.23863943f, 0.02124010f, 0.23029409f, -0.16277519f, 
    0.15038876f, 0.36447141f, -0.81853986f, 0.00629629f, 0.21520615f, -0.02834762f, -0.13935761f, -0.06901868f, 
    -0.07791185f, 0.08664007f, -0.05045725f, -0.44044745f, 0.04070151f, -0.27497292f, -0.31494728f, 0.06444859f, 
    -0.26597330f, 0.06107376f, -0.09343971f, 0.61817151f, -0.49661398f, -0.24772422f, -0.04279620f, -0.00967748f, 
    0.09279567f, -0.02327016f, 0.27316499f, -0.03348775f, 0.18133122f, -0.14220779f, -0.19148774f, 0.04294986f, 
    0.12171286f, -0.15854295f, 0.05631261f, -0.15639141f, -0.12522396f, -0.38196641f, 0.41648787f, 0.26009306f, 
    -0.00883790f, 0.04733500f, -0.26288530f, -0.03181867f, 0.05524747f, -0.09075671f, 0.50864297f, 0.06475560f, 
    -0.11456939f, -0.08129403f, -0.29054680f, 0.11798660f, 0.09395444f, -0.10369884f, 0.12631555f, -0.27812549f, 
    -0.39592478f, -0.39164057f, 0.08317323f, -0.02160671f, 0.30586219f, 0.13436049f, -0.01116635f, -0.06614058f, 
    -0.12696761f, 0.10853682f, -0.25715631f, -0.10194253f, 0.20854130f, 0.21429943f, -0.09303081f, -0.13489917f, 
    -0.12496705f, 0.11926947f, 0.37268385f, -0.00601823f, 0.09525699f, -0.17410672f, 0.19933368f, 0.18693277f, 
    0.00761287f, 0.13221736f, 0.16690193f, -0.00398688f, 0.11533143f, -0.02596140f, 0.00342366f, -0.03893288f, 
    0.08860768f, -0.33658573f, -0.02490121f, -0.24055159f, 0.31939560f, 0.02869217f, -0.19842121f, 0.17202662f, 
    -0.16820337f, 0.10314855f, -0.07276143f, -0.03450917f, 0.22065440f, 0.38611946f, 0.36715800f, -0.26941124f, 
    -0.08065096f, -0.05339201f, 0.08148475f, 0.13259928f, 0.06326652f, 0.02709895f, -0.33898538f, 0.37308174f, 
    -0.07371570f, 0.26650324f, -0.07615793f, -0.16497901f, 0.07640228f, -0.10074059f, -0.08429325f, 0.13714671f, 
    -0.07558603f, -0.03210563f, 0.09500556f, 0.17371155f, 0.08516514f, 0.07049364f, 0.04921536f, -0.33868942f, 
    -0.05140566f, -0.40214732f, 0.16634732f, 0.22901557f, -0.13268408f, 0.07391413f, 0.16097479f, 0.24017717f, 
    -0.20580263f, 0.11962963f, -0.29353824f, 0.09581831f, 0.08047270f, 0.19863020f, 0.25110257f, 0.15038314f, 
    0.07924095f, -0.48588541f, -0.11905783f, 0.04030722f, -0.48369604f, -0.03607849f, -0.16133034f, -0.15291429f, 
    -0.02015444f, 0.07182473f, -0.08744950f, 0.08496540f, 0.03355960f, 0.08634899f, 0.05163401f, -0.09006546f, 
    -0.24559161f, 0.25980151f, 0.23979802f, 0.23719841f, -0.07282068f, -0.67031974f, 0.31636092f, 0.25235656f, 
    0.25756517f, 0.12196814f, -0.23886357f, -0.31055063f, -0.78092462f, -0.52588218f, 0.30910718f, -0.12093674f, 
    0.33820230f, -0.05276477f, 0.08960584f, -0.02416738f, 0.11806630f, 0.11505944f, 0.51853412f, 0.19598910f, 
    0.17392163f, 0.04187113f, 0.07165691f, -0.03874197f, -0.15289706f, 0.16110227f, 0.64938170f, 0.43980867f, 
    -0.10393339f, -0.04899342f, 0.11952366f, 0.10956140f, -0.19591349f, 0.09543121f, 0.07123183f, -0.20904927f, 
    -0.26972008f, -0.12516598f, 0.10751558f, 0.04107711f, 0.09455921f, 0.17840779f, -0.03920906f, 0.03313110f, 
    0.05341984f, -0.55205989f, -0.19371700f, 0.06396284f, 0.12195040f, 0.10690398f, -0.06728695f, -0.17116752f, 
    -0.14376020f, -0.76281959f, 0.23916151f, -0.26201704f, 0.02677875f, 0.34473011f, -0.03772417f, -0.34388950f, 
    0.25519770f, -0.07456686f, -0.10721991f, -0.43780920f, -0.03923824f, 0.09259707f, -0.11922700f, -0.17704467f, 
    -0.18112637f, 0.05472703f, 0.11640973f, 0.37099144f, 0.14964113f, 0.14617553f, -0.05350744f, -0.23138909f, 
    -0.00485403f, 0.17914668f, 0.02672599f, -0.08192802f, 0.37880209f, 0.40225607f, 0.20424229f, -0.03029772f, 
    0.11374369f, -0.07998000f, 0.05513050f, 0.26028356f, -0.10447587f, -0.22192191f, -0.22027330f, -0.37140527f, 
    -0.06121731f, 0.08428706f, -0.05516021f, 0.04277189f, 0.00900528f, -0.28228995f, 0.52456695f, 0.02280650f, 
    -0.20318891f, 0.01942416f, -0.20384957f, -0.34632087f, 0.10141991f, -0.07243855f, -0.08361600f, 0.31820491f, 
    -0.16400462f, -0.05755509f, 0.08569085f, 0.02885019f, 0.02549856f, 0.03607240f, 0.04311416f, 0.17463169f, 
    -0.07529490f, -0.15057191f, -0.12830861f, 0.25828627f, 0.07079054f, 0.01409603f, -0.07352496f, 0.14391378f, 
    0.08124344f, -0.32196817f, 0.30576760f, -0.34089175f, -0.08353183f, -0.12370303f, -0.12691437f, 0.05055629f, 
    -0.13477197f, -0.13669913f, 0.28203443f, 0.28562418f, 0.02043521f, 0.09958002f, -0.20327239f, -0.16560149f, 
    -0.02097047f, -0.07666694f, 0.01591655f, -0.03942881f, -0.61734354f, 0.40657747f, -0.03351049f, -0.02204707f, 
    0.10282464f, -0.03330122f, -0.03063668f, 0.13891463f, -0.19485374f, 0.01744944f, -0.40098855f, -0.12330600f, 
    -0.15162367f, 0.15490830f, 0.02181981f, -0.21265309f, -0.07145790f, 0.16422369f, -0.23796396f, -0.19002503f, 
    0.00396476f, -0.02338012f, -0.18591365f, 0.07423127f, -0.04894738f, 0.09686575f, -0.21833707f, 0.12709935f, 
    -0.31940943f, 0.17735943f, -0.00310924f, -0.10853282f, -0.04971037f, 0.04924619f, -0.32419464f, -0.03760290f, 
    -0.05106244f, -0.02239863f, -0.06391142f, 0.14803284f, 0.18964596f, -0.07628612f, 0.20249011f, 0.18031943f, 
    -0.90891832f, 0.19909801f, -0.19562770f, 0.07301613f, 0.05786365f, 0.22569357f, -0.05373065f, -0.10717092f, 
    -0.14940697f, 0.15562312f, -0.59164488f, 0.49466917f, 0.20217328f, -0.10355145f, -0.14381053f, -0.01677199f, 
    0.14046401f, 0.02262696f, 0.25861022f, 0.24725433f, 0.30441442f, -0.19453306f, -0.18051079f, 0.09447010f, 
    0.08805834f, -0.01909917f, -0.09838037f, -0.31563729f, 0.06891925f, -0.05174020f, 0.30849031f, 0.09093316f, 
    0.01110578f, 0.30933642f, -0.06048065f, 0.15561663f, 0.17288652f, 0.19065528f, -0.06606007f, 0.17869072f, 
    0.04668045f, 0.18877065f, -0.01933574f, 0.07624035f, 0.18088138f, 0.04714758f, -0.30376977f, 0.12204125f, 
    -0.03797213f, -0.05556139f, 0.02030641f, 0.00855126f, -0.02872516f, 0.18911313f, -0.18690692f, 0.35081276f, 
    0.15705292f, 0.05600556f, -0.03712205f, 0.05104636f, -0.20224926f, 0.18860716f, -0.06025671f, 0.11172740f, 
    0.27877468f, -0.34166807f, 0.05407413f, 0.05520626f, -0.00378060f, 0.03422550f, 0.23835309f, -0.09556434f, 
    -0.00281985f, 0.33154494f, 0.22156675f, 0.18732519f, 0.23449023f, -0.09918227f, -0.00624192f, 0.14641044f, 
    -0.04785870f, -0.36674458f, -0.06588760f, -0.03020946f, -0.38811079f, -0.12100079f, -0.31181076f, 0.06650236f, 
    0.09577154f, -0.14921977f, -0.19168401f, 0.10131514f, 0.31969327f, 0.10070971f, -0.11418865f, -0.03836117f, 
    -0.19261065f, -0.00103477f, -0.00509501f, -0.37743053f, -0.41817841f, -0.10946643f, 0.01766937f, 0.10251755f, 
    0.13812187f, 0.10563054f, -0.05584602f, -0.14345431f, 0.27491713f, -0.70079345f, -0.12439914f, -0.12423658f, 
    -0.24734364f, 0.17098227f, -0.18879266f, -0.18367684f, 0.04816881f, 0.40109405f, -0.60591006f, -0.25864506f, 
    0.36646283f, 0.06872948f, 0.15815094f, -0.06694030f, -0.19903494f, -0.00523924f, 0.10911039f, 0.43873188f, 
    0.63395858f, -0.11784418f, 0.11098485f, 0.00087739f, -0.11070450f, 0.19789018f, -0.16693307f, -0.04352139f, 
    0.07976097f, -0.76067853f, -0.14625126f, 0.17637031f, -0.02454447f, 0.05919763f, 0.22777146f, -0.07835817f, 
    -0.54678249f, -0.05753567f, -0.52132368f, 0.05264359f, 0.20899491f, 0.06673758f, -0.04895860f, -0.07763524f, 
    -0.02784497f, -0.68991238f, -0.21464820f, -0.20503283f, 0.01516978f, 0.07943080f, 0.15685318f, 0.05057636f, 
    -0.12763704f, -0.20232119f, 0.02388840f, -0.42497441f, 0.42397809f, 0.11739056f, -0.21987453f, 0.04341605f, 
    -0.02681357f, -0.08816907f, -0.33690384f, 0.34320179f, -0.43680003f, 0.00263708f, -0.04012609f, 0.12342852f, 
    0.00547424f, 0.00187159f, 0.09769236f, -0.32737914f, -0.33417973f, 0.41858697f, 0.59165061f, 0.11374576f, 
    0.06538571f, 0.22285742f, 0.25225684f, 0.23429298f, -0.02985986f, 0.57250929f, -0.23159781f, -0.14477764f, 
    0.20900647f, -0.12397704f, -0.00981297f, -0.03203832f, 0.05442849f, 0.12259403f, 0.31003597f, -0.18790531f, 
    -0.17847306f, 0.08470681f, -0.03319995f, -0.00511374f, 0.10714749f, -0.09446599f, 0.11856894f, 0.15653744f, 
    0.32063389f, 0.03776643f, -0.04203732f, 0.28523472f, -0.00689429f, -0.00370209f, 0.05768507f, 0.22260202f, 
    -0.28727540f, 0.17742538f, -0.19057234f, 0.03339642f, -0.16797315f, 0.08215491f, -0.11376305f, 0.04205125f, 
    0.12368701f, 0.50550103f, 0.03915092f, -0.28022149f, -0.07018958f, -0.04381542f, 0.00566102f, -0.06128606f, 
    -0.12680903f, -0.11047197f, -0.09940571f, -0.37263867f, -0.26264870f, -0.08914318f, 0.11274827f, 0.06944341f, 
    0.01257346f, 0.00338417f, 0.07571045f, -0.13449624f, 0.22411016f, 0.24863204f, -0.01416523f, 0.14017518f, 
    0.18271255f, 0.12132555f, -0.08221832f, 0.09545299f, 0.16671294f, -0.20236282f, -0.26532099f, 0.04459547f, 
    -0.10094256f, -0.01180695f, 0.08280742f, -0.22490859f, -0.06713693f, 0.26916912f, 0.04285661f, 0.21822405f, 
    -0.12806907f, -0.02951215f, -0.17349569f, 0.05773699f, 0.16578090f, 0.15569708f, -0.06283969f, 0.08060871f, 
    -0.13224620f, -0.00987556f, -0.00270598f, -0.02265732f, -0.24327758f, -0.02141263f, -0.01962830f, 0.10421704f, 
    -0.45054922f, -0.11498175f, 0.14178823f, 0.13305181f, -0.04200821f, -0.05102831f, -0.12754874f, 0.03863703f, 
    0.09060977f, -0.04881847f, -0.27158085f, -0.17427400f, 0.27444723f, 0.20795134f, -0.15368314f, -0.12298942f, 
    -0.07002101f, 0.54535711f, 0.47626656f, 0.21618402f, 0.17046903f, -0.09481245f, 0.04543686f, -0.17760354f, 
    0.25383347f, 0.13302021f, 0.09522052f, 0.24247983f, 0.28983805f, 0.27979052f, -0.23546113f, -0.01318136f, 
    0.00419225f, 0.10412477f, -0.04726277f, 0.27332029f, 0.07535987f, -0.17187522f, 0.12485866f, 0.04550660f, 
    0.19756511f, -0.20473771f, 0.09165694f, 0.15080021f, 0.42801183f, 0.42326856f, 0.24716352f, 0.03020434f, 
    -0.07876056f, -0.16419934f, 0.01024922f, 0.06624936f, 0.28763658f, 0.15802777f, 0.20281963f, 0.45883811f, 
    0.13908860f, -0.10483848f, 0.14348187f, -0.06929079f, 0.04223395f, 0.01542093f, 0.13131823f, 0.02949854f, 
    -0.04913441f, 0.07600400f, 0.09119829f, -0.13659333f, 0.16128106f, 0.17190892f, -0.04221029f, -1.00504458f, 
    -0.38285577f, -0.65778315f, 0.16563554f, 0.08349761f, -0.15636155f, -0.06362160f, 0.02995100f, -0.03713715f, 
    0.07289301f, -0.45695409f, -0.48715183f, -0.57244337f, 0.14606798f, -0.20401414f, 0.03952151f, 0.22638474f, 
    -0.19021446f, -0.49806041f, 0.21616568f, -0.19818197f, -0.07534228f, -0.42344382f, 0.09035040f, -0.23830327f, 
    0.22436140f, 0.00648560f, 0.65466440f, 0.68516213f, 0.09101062f, -0.40840268f, -0.20670064f, 0.28092223f, 
    0.27250242f, 0.16350617f, -0.07460380f, 0.07901789f, 0.60300714f, 0.16771643f, 0.19016819f, -0.01853302f, 
    0.51237106f, 0.12312898f, 0.14164034f, 0.21957302f, 0.16574517f, 0.01203279f, 0.11726663f, -0.09080154f, 
    0.11908904f, 0.03117536f, -0.25704667f, -0.01652867f, -0.17790598f, -0.03025430f, 0.07809407f, 0.02633052f, 
    -0.07367133f, 0.06434151f, -0.06151136f, 0.19611564f, -0.13409914f, 0.06607404f, -0.33160463f, -0.50364447f, 
    -0.24066839f, -0.33425254f, -0.36215168f, -0.07081281f, 0.00603822f, 0.01185496f, -0.03255016f, -0.01932075f, 
    0.09779374f, 0.00740115f, 0.04928756f, 0.28969795f, 0.23423660f, 0.14450924f, -0.08252253f, 0.26969343f, 
    0.04707685f, 0.62616670f, 0.35749450f, 0.06445176f, -0.09923583f, 0.13386665f, -0.27882448f, -0.42355770f, 
    -0.08552264f, -0.07347687f, 0.15226257f, 0.28919160f, 0.36361632f, -0.15056726f, 0.22151262f, 0.06684934f, 
    -0.00411037f, 0.08394075f, 0.09132353f, -0.02336842f, -0.28700310f, -0.09502167f, 0.07029994f, 0.02922621f, 
    0.10193237f, 0.05402007f, -0.12957217f, 0.13435592f, 0.01835677f, 0.17205605f, -0.04924602f, 0.05833789f, 
    0.02564345f, -0.16655374f, -0.07737231f, -0.08544317f, -0.30014977f, 0.16212994f, 0.11963666f, -0.01977804f, 
    -0.32694638f, 0.10189675f, 0.06691688f, 0.15819204f, -0.16588868f, 0.05356314f, 0.55525458f, -0.11593173f, 
    -0.31101063f, 0.48104799f, -0.06542722f, 0.07642133f, -0.23378667f, 0.12017076f, 0.34811896f, 0.58509386f, 
    0.11376089f, 0.06047035f, 0.00264150f, 0.08209457f, 0.06428496f, 0.08359757f, 0.29792207f, -0.12691315f, 
    -0.09753120f, -0.09015800f, -0.15852065f, -0.02618474f, -0.27274919f, 0.05204120f, 0.00708340f, 0.17210142f, 
    -0.22000784f, 0.00794884f, -0.40429938f, 0.03465991f, -0.10820461f, 0.13103175f, 0.06549762f, 0.07920250f, 
    0.01215715f, 0.09565529f, 0.06757151f, -0.29695767f, -0.07894580f, -0.09846401f, -0.21712005f, -0.19428347f, 
    -0.04935328f, 0.10759959f, 0.09633120f, -0.69279122f, 0.11388289f, -0.09396362f, -0.00526644f, 0.08200036f, 
    -0.09771352f, -0.08133064f, -0.10782413f, 0.10910387f, 0.05046856f, 0.23803091f, -0.06735114f, -0.03079309f, 
    0.09096336f, 0.02946941f, -0.06027436f, -0.00107727f, 0.12641124f, -0.00474683f, 0.10137771f, -0.15977634f, 
    0.11806852f, 0.09506053f, -0.13176505f, 0.18904074f, -0.18198268f, 0.47899801f, 0.26310498f, 0.28842592f, 
    0.11070348f, 0.11545175f, 0.03276402f, 0.19649148f, 0.03509994f, 0.00919931f, -0.20535702f, 0.23438299f, 
    -0.00425570f, 0.11735296f, 0.21042939f, -0.13326107f, 0.18369986f, -0.22462721f, 0.03176648f, -0.34304172f, 
    0.12146816f, -0.23770677f, 0.22808054f, 0.04916273f, 0.01774719f, 0.01809821f, -0.03215480f, 0.18514897f, 
    -0.04226219f, 0.05539628f, -0.34841433f, 0.00631249f, 0.01369451f, -0.00586490f, -0.21838601f, -0.07717083f, 
    -0.07944272f, -0.69877881f, -0.42133138f, -0.12772822f, -0.22184579f, 0.07469825f, -0.04685646f, 0.07128780f, 
    0.03990375f, 0.05733667f, 0.15173772f, -0.01191694f, 0.39575678f, -0.01392938f, -0.12185254f, 0.21806519f, 
    -0.02157648f, 0.18506108f, -0.08966710f, 0.49333313f, 0.07389617f, 0.19789082f, -0.09688367f, -0.25258178f, 
    -0.10019662f, 0.02477855f, 0.01268673f, 0.02011329f, -0.74304944f, -0.33657292f, -0.16247752f, -0.07853220f, 
    0.03229711f, -0.05002443f, -0.06241950f, 0.04719243f, -0.07137400f, 0.70187646f, 0.25893441f, 0.01236042f, 
    -0.21316543f, -0.00199937f, -0.09200481f, -0.14994873f, 0.05006665f, -0.09247687f, 0.87534112f, 0.04475755f, 
    0.06380139f, -0.22262467f, -0.16958776f, 0.23273973f, -0.08283965f, 0.13598585f, 0.09767416f, 0.26117143f, 
    0.02447595f, -0.33815223f, -0.01905981f, 0.00734720f, -0.16648600f, 0.16465883f, 0.04833058f, -0.07251473f, 
    -0.17882372f, -0.18414237f, 0.41956198f, 0.14326826f, 0.17401879f, -0.08857225f, 0.13629092f, 0.06012451f, 
    -0.08694782f, -0.26968339f, 0.59380627f, -0.26980886f, -0.25609139f, -0.05360408f, -0.19861093f, 0.02145944f, 
    0.26377869f, -0.04880926f, 0.48114604f, 0.44642571f, -0.07063284f, 0.16259776f, -0.08886493f, -0.13080052f, 
    -0.04331600f, -0.21931747f, 0.13150297f, 0.27250808f, -0.44031021f, 0.27812725f, 0.06989713f, -0.01890884f, 
    -0.10501809f, -0.07149081f, -0.14561041f, 0.04498934f, -0.36243418f, -0.27616680f, -0.04992508f, -0.14549308f, 
    -0.14086711f, -0.00394746f, -0.02828008f, 0.19501595f, -0.01654245f, 0.15536572f, 0.34185961f, 0.16045891f, 
    -0.04221850f, 0.09956791f, -0.01848761f, 0.07801539f, 0.15879972f, 0.03984399f, -0.11386165f, -0.04193493f, 
    -0.34806171f, 0.15755737f, -0.02212090f, 0.05229351f, -0.09604357f, 0.02233856f, 0.03101682f, -0.31510204f, 
    -0.30868065f, -0.23273782f, 0.13642421f, 0.13994333f, 0.11547361f, 0.14478536f, 0.14268659f, 0.36395830f, 
    -0.61671919f, -0.56187922f, 0.15804458f, -0.01104877f, 0.00945890f, -0.21140550f, 0.05484832f, -0.08848893f, 
    -0.24992678f, 0.05731653f, -0.10516485f, 0.82290959f, 0.01230482f, 0.00688138f, -0.12262595f, -0.13433029f, 
    -0.07215739f, 0.04403252f, 0.42620960f, -0.23906367f, -0.03375075f, -0.05444654f, -0.21876980f, 0.28583297f, 
    0.10733523f, 0.10976900f, -0.12097946f, 0.06914395f, -0.00219141f, 0.05526724f, 0.01797046f, -0.07239795f, 
    -0.17113756f, -0.17576700f, -0.02418544f, 0.27126908f, 0.16130447f, 0.21925908f, 0.02995260f, 0.33104026f, 
    -0.16452292f, -0.06279325f, 0.05890783f, 0.20897524f, 0.06348393f, -0.08957669f, 0.36670017f, 0.18301173f, 
    0.15755135f, -0.18481614f, 0.04794788f, -0.13928446f, -0.07466548f, -0.14656764f, -0.37513563f, -0.16627800f, 
    0.01714485f, 0.06348325f, -0.24705657f, -0.13452372f, 0.13559112f, -0.16792518f, 0.20930415f, -0.25923494f, 
    0.09051391f, -0.80652034f, 0.12082671f, 0.10563866f, 0.00674142f, 0.02600635f, 0.08156481f, -0.07868872f, 
    0.03089146f, 0.02290017f, 0.05814463f, 0.02844269f, -0.08292275f, -0.03986381f, -0.01446607f, 0.04575974f, 
    -0.07920188f, -0.06977049f, 0.04600664f, 0.01533013f, -0.00754645f, 0.01753950f, 0.01804828f, -0.02579281f, 
    0.06276513f, 0.03628666f, -0.04071067f, 0.05071721f, -0.01891916f, 0.03736109f, 0.03490563f, -0.07978988f, 
    -0.06844852f, -0.04789973f, 0.05337328f, -0.05251588f, 0.02820846f, -0.01662258f, 0.00355988f, 0.00807945f, 
    0.02110297f, 0.02661601f, -0.06324928f, 0.03506286f, 0.02221616f, -0.04028921f, 0.02155171f, -0.00634347f, 
    -0.08149444f, 0.07354382f, -0.00160578f, -0.05135256f, 0.02175656f, -0.02029110f, -0.01187157f, 0.03937064f, 
    0.04955325f, 0.04842437f, -0.05330936f, -0.04705219f, -0.00620172f, -0.03352072f, 0.04599062f, 0.02085022f, 
    0.00987255f, 0.05899449f, 0.01727541f, 0.00607224f, 0.01558760f, 0.01370209f, -0.00481975f, -0.02016450f, 
    0.07071382f, -0.07446298f, 0.00472308f, 0.02566088f, -0.01150775f, -0.05183043f, -0.01341946f, -0.06388605f, 
    0.05788321f, -0.09087592f, 0.06965364f, 0.03378981f, -0.00485308f, 0.02517897f, -0.00380481f, -0.01136246f, 
    -0.03660166f, 0.05932154f, 0.02487481f, -0.05198450f, -0.00020572f, 0.04956475f, -0.04777706f, 0.04081783f, 
    -0.02390053f, 0.00322559f, -0.01625373f, -0.03377673f, 0.06122004f, -0.06910589f, 0.02409413f, 0.05211858f, 
    0.03752391f, -0.01033502f, 0.00826756f, 0.00381216f, -0.00359418f, -0.04658583f, 0.06120600f, -0.03512795f, 
    -0.03714161f, -0.02446381f, -0.08889383f, -0.02095695f, -0.01541661f, -0.01914228f, 0.02238441f, -0.08674101f, 
    0.01334398f, -0.08249722f, -0.07036698f, -0.03652586f, -0.08454259f, -0.07831054f, 0.06716494f, -0.06757490f, 
    0.05704929f, -0.08785147f, 0.06496380f, -0.06898513f, -0.00809352f, 0.00061383f, 0.06065880f, -0.08216505f, 
    -0.05927532f, 0.02718709f, -0.03967233f, -0.05697040f, -0.07935717f, -0.02958017f, -0.00124294f, -0.03322843f, 
    -0.03040077f, -0.07490983f, 0.05738770f, -0.05528933f, -0.06831387f, -0.00958870f, 0.04076412f, -0.07825289f, 
    -0.02090198f, -0.37791950f, 0.16245341f, 0.24755572f, 0.02483750f, 0.07254259f, 0.11259712f, 0.09377835f, 
    0.06566035f, 0.28006011f, 0.05683948f, 0.19653966f, -0.02300534f, 0.06196352f, -0.13235013f, 0.08118755f, 
    0.07399371f, -0.13281585f, 0.65953332f, 0.01377088f, 0.03378333f, 0.21175413f, -0.08751623f, 0.08911568f, 
    -0.08842836f, 0.03479758f, 0.17262600f, -0.28677064f, 0.22307312f, -0.05094769f, -0.02276597f, -0.00589975f, 
    0.00655696f, -0.13060032f, 0.18868844f, -0.03790526f, -0.05247817f, -0.13615929f, -0.25005621f, 0.09730274f, 
    0.16769744f, 0.03983911f, -0.08778540f, -0.01004592f, 0.03864639f, -0.56017751f, -0.10766163f, -0.13087562f, 
    -0.14505605f, 0.08164730f, -0.14899415f, -0.03099877f, 0.03460465f, 0.05941898f, 0.99377239f, -0.26260448f, 
    -0.09799439f, 0.20910479f, 0.23571871f, 0.05857051f, 0.06979644f, -0.07116292f, 0.15994950f, -0.21811162f, 
    0.23329823f, -0.17345548f, -0.03318207f, -0.01748783f, 0.22934125f, -0.27035677f, -0.11515727f, 0.17335197f, 
    -0.03587897f, -0.03701526f, -0.02650590f, 0.01666789f, -0.01821643f, 0.10428425f, -0.12632503f, 0.00345901f, 
    -0.15290558f, 0.04993269f, 0.17360485f, -0.33917579f, -0.17636433f, -0.09163950f, 0.11216124f, -0.18979241f, 
    -0.01460157f, 0.02741282f, -0.23977470f, 0.14570329f, 0.04355726f, 0.04470471f, -0.02840489f, -0.14410403f, 
    -0.30651084f, -0.31219995f, 0.09382639f, -0.16951209f, -0.02607348f, 0.13911633f, -0.11118276f, 0.05738402f, 
    -0.07251988f, 0.07275143f, -0.06139709f, -0.00292912f, 0.19914265f, -0.22908349f, 0.16535695f, 0.00950456f, 
    -0.07523480f, 0.13493644f, 0.16176021f, 0.03111312f, -0.07555314f, 0.12191293f, 0.23065835f, -0.42420992f, 
    0.07515761f, 0.04131436f, -0.12755127f, 0.16587871f, 0.19754764f, -0.03028779f, -0.59323746f, -0.04379530f, 
    0.08436902f, -0.01358808f, 0.00423859f, -0.11811608f, -0.20224157f, 0.05526942f, -0.02575798f, 0.28973579f, 
    -0.12486690f, -0.12600312f, 0.14578733f, -0.04735598f, -0.12240383f, 0.05293550f, -0.02156156f, -0.01845500f, 
    0.08286268f, 0.01296822f, 0.06336176f, 0.13345017f, 0.20208766f, -0.04851959f, 0.05650363f, 0.20098197f, 
    -0.04799265f, -0.31497341f, -0.27875438f, -0.30275819f, -0.44953153f, -0.24365823f, -0.01960973f, -0.07075807f, 
    0.08685818f, 0.25665155f, -0.51074505f, -0.01995251f, -0.24351658f, 0.11996680f, -0.07472730f, -0.32189792f, 
    -0.06238346f, -0.13537079f, 0.02254500f, 0.33063656f, 0.25014287f, -0.03447804f, -0.34722897f, 0.22905196f, 
    -0.32623112f, 0.19825022f, 0.04206142f, -0.14977783f, -0.43215612f, 0.21012124f, 0.25234491f, 0.25457829f, 
    -0.32399085f, -0.11147793f, -0.11058475f, 0.07275259f, 0.17221983f, 0.26981115f, 0.53496826f, 0.22295627f, 
    -0.07125615f, 0.09129770f, -0.21047913f, 0.32261464f, 0.00444643f, 0.00702774f, -0.34384230f, -0.25738919f, 
    0.00103422f, -0.02869679f, 0.01579194f, -0.02280204f, -0.25930870f, -0.19449121f, 0.44983020f, -0.12127057f, 
    0.01695609f, 0.00021673f, -0.05368530f, 0.12705503f, 0.06027874f, 0.03787781f, 0.12869339f, -0.36272365f, 
    -0.29053140f, 0.03075541f, 0.11093052f, -0.04687415f, 0.16306210f, 0.05576036f, 0.15244651f, -0.15614608f, 
    -0.20165451f, -0.06457080f, 0.47843745f, 0.10478049f, 0.11547497f, -0.03533765f, 0.08508305f, -0.24282572f, 
    0.14693010f, -0.06930522f, 0.47400698f, 0.10578726f, -0.30141324f, -0.14420359f, -0.25625622f, 0.03317038f, 
    0.32316053f, 0.01703102f, 0.21875396f, -0.28847837f, -0.00001621f, 0.18829915f, 0.12404241f, -0.24127795f, 
    -0.14814934f, 0.01254140f, 0.28407654f, 0.03880615f, -0.01049612f, -0.03651594f, 0.01192115f, 0.33907491f, 
    -0.04578801f, -0.33385894f, 0.16692078f, 0.06890799f, 0.40469626f, -0.16127938f, 0.02470831f, -0.23074594f, 
    0.04303802f, 0.10656354f, 0.01093450f, 0.10159399f, 0.10877056f, 0.21991366f, 0.21324791f, -0.05445474f, 
    0.20962201f, 0.25897709f, 0.14697587f, -0.06247072f, 0.18052797f, 0.01866253f, 0.08812586f, 0.15552051f, 
    -0.15027922f, -0.02083024f, 0.11788061f, 0.00646157f, 0.22104146f, -0.17853034f, 0.02896094f, -0.02172175f, 
    -0.06436955f, 0.01800921f, 0.06857882f, 0.01902672f, -0.09551217f, -0.01552618f, 0.02646554f, 0.02268981f, 
    -0.05023620f, 0.04726985f, 0.03439839f, -0.04526278f, -0.00324150f, 0.01777801f, 0.02111468f, -0.06788631f, 
    0.05944911f, -0.01978492f, -0.06725676f, 0.06441488f, 0.00535234f, 0.01918291f, -0.06400942f, 0.02062022f, 
    -0.02683051f, -0.03380094f, 0.04137577f, -0.02890375f, -0.02951655f, 0.04870537f, -0.05204961f, 0.01605779f, 
    -0.02642821f, 0.01508108f, 0.01625521f, 0.03686163f, 0.03770933f, -0.02336958f, 0.04376797f, -0.07911136f, 
    0.03041182f, -0.07291595f, -0.01410037f, 0.01804153f, -0.07834575f, -0.06448854f, 0.03574297f, 0.05856010f, 
    0.01505224f, -0.00466416f, -0.06887110f, 0.05726847f, 0.05140847f, -0.00137205f, -0.09122107f, -0.05787022f, 
    0.03249970f, -0.08185969f, 0.06855329f, 0.03755209f, -0.01205767f, 0.01701367f, 0.05416737f, 0.04411437f, 
    -0.02634751f, -0.08012141f, 0.01527074f, 0.03521482f, 0.04844864f, -0.03586992f, -0.08696403f, 0.04908206f, 
    0.00547128f, -0.08047450f, -0.05779196f, 0.03162334f, 0.05147748f, -0.06953486f, -0.06958705f, -0.03965788f, 
    0.05752181f, -0.04875279f, -0.04743870f, -0.07916061f, -0.07073948f, -0.04308883f, 0.03146026f, 0.06122491f, 
    -0.09006535f, 0.00059609f, -0.02072351f, 0.01393001f, 0.02866499f, 0.01967890f, -0.05442369f, -0.09045418f, 
    0.00423664f, 0.04737794f, 0.00925594f, -0.05720116f, -0.00471962f, -0.09222100f, -0.06248261f, 0.01628362f, 
    0.01741054f, -0.01845213f, 0.02063815f, -0.05105224f, 0.01546411f, 0.00373098f, -0.07443815f, -0.06969916f, 
    -0.07116352f, 0.05918931f, 0.01342475f, 0.00312555f, -0.07388467f, -0.03142589f, -0.02803691f, -0.07636318f, 
    0.00762278f, -0.05129667f, -0.05749003f, 0.03638184f, -0.00853373f, -0.07677601f, -0.00950242f, 0.03891225f, 
    -0.09114470f, -0.02027107f, -0.03891959f, 0.05100146f, -0.01306003f, 0.03504781f, -0.09371105f, 0.05288421f, 
    -0.06892293f, 0.02829078f, -0.00641210f, -0.07248104f, -0.02641203f, 0.03008951f, -0.07105298f, -0.08437778f, 
    -0.31623331f, -0.00304120f, -0.00231570f, 0.27225280f, -0.02447863f, 0.04069598f, 0.31637168f, 0.11821546f, 
    0.18497673f, -0.49118355f, -0.43950519f, -0.12616506f, -0.16797705f, -0.10741206f, -0.01676315f, 0.05860176f, 
    -0.04203315f, 0.00813577f, -0.48098999f, -0.53779447f, 0.07654148f, -0.26715779f, 0.05712280f, 0.27023324f, 
    -0.03480380f, -0.28009060f, 0.07798851f, 0.46231461f, -0.23769820f, -0.24207863f, -0.23661336f, -0.12671399f, 
    0.24246244f, 0.17472829f, 0.09381676f, -0.05676906f, 0.14421031f, -0.06332111f, 0.00955945f, -0.02040214f, 
    -0.06654406f, -0.22391482f, 0.15766700f, 0.10400399f, -0.13151683f, 0.06560195f, -0.06258167f, -0.07437688f, 
    0.22638632f, 0.01246161f, -0.24881661f, 0.07684030f, -0.07291642f, -0.06229586f, -0.27600262f, 0.29055434f, 
    0.10078826f, 0.19763662f, 0.16705112f, 0.27024806f, 0.01229899f, -0.09458559f, 0.01575191f, -0.39421454f, 
    -0.00403792f, -0.11341007f, -0.10174790f, -0.03056538f, 0.16480526f, -0.02203414f, 0.02936121f, 0.01316920f, 
    -0.13507763f, 0.31101403f, -0.37383392f, 0.21266080f, 0.05832124f, -0.13706362f, -0.06354804f, 0.07520557f, 
    0.00347916f, -0.13593124f, -0.44161284f, 0.33305591f, -0.36604184f, 0.09256632f, 0.09564058f, -0.31868654f, 
    0.07858723f, 0.13348970f, 0.00010992f, 0.31863624f, 0.08706290f, -0.25788558f, -0.05062363f, -0.29938471f, 
    0.04676808f, -0.16514251f, 0.19493237f, -0.17628811f, 0.34222254f, -0.19957820f, -0.29686770f, -0.01807157f, 
    -0.04541935f, 0.21871653f, 0.07860550f, 0.13931364f, -0.74740404f, -0.12607878f, 0.15929520f, 0.02287802f, 
    0.18929933f, 0.16087376f, -0.02784786f, -0.10921714f, 0.12586595f, 0.17606705f, -0.38607475f, 0.45424986f, 
    -0.09899440f, 0.15583779f, 0.00471479f, 0.03567577f, -0.01228317f, -0.14251596f, 0.33070970f, 0.04965577f, 
    -0.23061262f, 0.08311411f, 0.14017475f, 0.02672946f, -0.13491130f, -0.03023189f, 0.14530276f, 0.50660890f, 
    0.23266569f, -0.40453705f, 0.06368429f, 0.21449929f, 0.03089849f, -0.11197093f, 0.17411561f, 0.14106242f, 
    -0.08282885f, -0.05254233f, -0.01099789f, -0.05344503f, -0.04584660f, 0.04868140f, -0.00127170f, 0.04446834f, 
    0.03297935f, 0.00780637f, 0.00717184f, -0.09937452f, -0.09569179f, -0.04311836f, 0.04691133f, -0.02457297f, 
    -0.01722138f, 0.02108057f, -0.07270186f, 0.00981287f, -0.08447581f, 0.05334554f, -0.09806514f, -0.00257551f, 
    0.01310378f, -0.05466606f, -0.06533115f, 0.03565834f, 0.04470588f, -0.00684919f, -0.06926955f, 0.02209477f, 
    -0.07688158f, 0.01654040f, -0.03313139f, 0.06533660f, -0.05088081f, 0.00678985f, 0.02388089f, -0.01681346f, 
    -0.03265578f, 0.00751977f, 0.04578354f, -0.08670562f, -0.07251211f, 0.05936203f, 0.00808808f, 0.05657673f, 
    -0.06382407f, -0.08749006f, 0.00803824f, -0.04407646f, 0.05174334f, 0.04801654f, 0.06081757f, -0.01278082f, 
    0.04800366f, 0.06647946f, 0.03823161f, 0.03706055f, 0.04691117f, 0.00722180f, -0.04649866f, -0.05716541f, 
    -0.06162191f, -0.07218707f, -0.04736824f, -0.04340682f, -0.01209198f, -0.01803682f, -0.05506919f, -0.09037277f, 
    0.06204262f, -0.03727685f, -0.08696447f, -0.02400379f, -0.00885837f, 0.03990556f, -0.00441773f, 0.05519710f, 
    0.04028690f, -0.01745092f, -0.04747634f, -0.01585026f, -0.08262650f, -0.01782613f, 0.04504500f, 0.02770185f, 
    0.00494701f, 0.02911957f, 0.01532844f, -0.07836246f, 0.01114003f, -0.03622223f, 0.01998639f, -0.08612723f, 
    0.06580012f, -0.04685097f, 0.01526712f, 0.05500377f, 0.00920148f, -0.04997454f, 0.05908773f, -0.02586980f, 
    -0.06531638f, 0.02920528f, -0.06264862f, -0.06008720f, 0.04441008f, 0.04809912f, -0.03872925f, 0.02250477f, 
    0.00002168f, 0.05333693f, 0.05702823f, 0.04515674f, 0.02517353f, -0.03920505f, -0.04230666f, -0.06622364f, 
    0.03824990f, 0.06570242f, -0.02672992f, -0.09602535f, -0.09340312f, 0.01319956f, -0.09096148f, -0.03080944f, 
    0.06008764f, -0.02750852f, -0.08032482f, 0.06071566f, -0.08164085f, 0.04277699f, -0.01455757f, -0.01409890f, 
    -0.02602632f, 0.03638459f, -0.04260384f, -0.04446849f, -0.08141797f, 0.03169141f, -0.00246481f, -0.09082647f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.04140174f, 0.28173876f, 0.19183415f, 0.10503320f, 0.12504058f, 0.14497451f, -0.03253974f, -0.31833908f, 
    0.05879902f, 0.06508520f, -0.05598646f, -0.04099269f, 0.16352396f, 0.03322330f, 0.24645823f, -0.05942380f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.32796177f, -0.06148468f, 0.12008739f, 0.43661797f, -0.15233032f, -0.58465147f, -0.31350896f, 0.55630195f, 
    0.17546426f, -0.05042585f, 0.05714269f, -0.95088643f, 0.18124442f, -0.19431680f, -0.20867684f, -0.15721364f, 
    -0.33799365f, -0.34942186f, 1.02747548f, 0.08877227f, -0.88841730f, 0.00201626f, 0.38965672f, -0.21389820f, 
    -0.62747878f, 0.05627067f, -0.15832257f, -0.31068906f, 0.15210404f, -0.14293450f, 0.29405028f, -0.20720614f, 
    -1.12802482f, -0.15155008f, -0.28855243f, -0.07804197f, -0.16858722f, -0.09904141f, 0.53977597f, -0.29290041f, 
    1.24318230f, -0.31361181f, -0.20423965f, 0.01001133f, -0.54058021f, 0.22644326f, 0.22101001f, -0.23512803f, 
    0.68028057f, -0.11333518f, -0.49358526f, -0.68394983f, 0.50838047f, -0.36259672f, -0.77488333f, 0.05884076f, 
    -0.06009855f, -0.30635729f, 0.20504826f, 0.65025812f, 0.03457827f, -0.08029966f, 0.64164907f, -0.10839072f, 
    -0.01383955f, 0.22499669f, -0.16256094f, -0.67270941f, 0.46270823f, 0.44515908f, 0.09681927f, 0.15631527f, 
    0.01762342f, -0.36425504f, 0.19397341f, -0.57596529f, -0.16827041f, -0.10860774f, -0.17478690f, 0.20232597f, 
    -0.17355432f, -0.35836542f, -0.12363545f, 0.40570939f, -0.08477844f, 0.33699882f, 0.07822456f, 0.13173389f, 
    -1.08805895f, -0.66820103f, 0.07802320f, -0.45108414f, 0.49618062f, -0.10258930f, -0.30068022f, -0.00343151f, 
    -0.47189376f, 0.24905564f, 0.14481284f, 0.14987600f, -0.74630660f, 0.89194381f, -0.84019017f, 0.10353413f, 
    -0.32242525f, -0.17793159f, -0.11251919f, 0.42097628f, -0.41410771f, -0.18871322f, -0.25529200f, -0.01545698f, 
    0.56687385f, -0.37340143f, -0.44630283f, -0.61460841f, -0.35663810f, -0.45708606f, 0.43983892f, 0.80889547f, 
    -0.33487430f, -0.34572127f, -0.03514167f, -0.30137369f, -0.33362621f, 0.18056239f, -0.56346470f, -0.10985097f, 
    -0.14477417f, -0.74021947f, -0.17387064f, -0.08294139f, 0.02727781f, -0.46838135f, 0.26296347f, -0.30256414f, 
    0.35568604f, 1.21797061f, 0.19704376f, 0.14224875f, 0.64765978f, -0.11243095f, -0.88422388f, -0.18159783f, 
    -0.09559838f, 0.11381936f, -0.35221639f, 0.01072974f, 0.91658032f, 0.41519666f, -0.31715268f, 0.16925672f, 
    -0.09378029f, 0.50968546f, -0.05924920f, -0.42068630f, -0.38411012f, 0.10358619f, -0.70308077f, -0.14671783f, 
    0.39529505f, -0.11781155f, -0.55264801f, -0.45516607f, -0.02772179f, -0.76108629f, -0.33774969f, -0.48818389f, 
    0.38131952f, 0.28509018f, 0.20612055f, -0.03995503f, 0.58383727f, -0.10108421f, 0.72253913f, -0.11059610f, 
    0.16553104f, 0.60566711f, 0.01014844f, -0.31621253f, -0.23858632f, -0.30196998f, -0.31592804f, -0.25244254f, 
    0.25452560f, -0.51746511f, -0.10922604f, 0.84469861f, -0.31446952f, -0.18904899f, -0.39393550f, -0.15315874f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.14801517f, -0.20811988f, -0.07876832f, -0.55263680f, 0.54457289f, 0.41492149f, -0.11867782f, -0.45493144f, 
    -0.30068758f, 0.10468060f, 0.47706434f, -0.10400712f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
