#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.84055102f, 0.33018827f, 0.25981531f, 0.49026522f, -0.06336881f, 0.30891261f, -0.26258329f, -0.14083619f, 
    0.00445619f, -0.11025988f, -0.33995745f, 0.27898607f, 0.00440240f, 0.06663998f, -0.12177937f, -0.12451231f, 
    -0.05773801f, -0.11206111f, -0.35320410f, -0.23311727f, -0.25783920f, -0.16298071f, -0.05440142f, -0.24402241f, 
    -0.50016099f, 0.32720479f, -0.39560330f, -0.37133214f, 0.02894870f, -0.12892549f, 0.27549919f, 0.08267959f, 
    0.10392394f, -0.05858184f, -0.28586933f, 0.01939074f, 0.15192574f, -0.24983957f, 0.02111786f, 0.08938061f, 
    0.03848668f, -0.27953342f, 0.11985932f, 0.13797991f, -0.22401576f, 0.21851155f, -0.31169742f, 0.14680870f, 
    0.35741174f, 0.25426155f, 0.49785554f, -0.45997161f, 0.02184154f, 0.40877956f, -0.31129092f, -0.08967981f, 
    0.00794322f, -0.27237374f, 0.13824655f, -0.01867297f, 0.40051559f, -0.33811569f, -0.27865440f, 0.06708747f, 
    0.04505239f, 0.15036233f, -0.33575830f, -0.07103520f, 0.24379312f, -0.13781551f, -0.05859203f, -0.00270872f, 
    0.01786396f, -0.24076614f, -0.22133207f, -0.58915752f, -0.70349514f, -0.28780642f, 0.15381077f, 0.04664730f, 
    0.33572724f, -0.15370728f, -0.69395190f, -0.52273232f, -0.36546597f, -0.26746300f, -0.09961317f, 0.05188808f, 
    -0.30779070f, -0.33014154f, -0.14490847f, -0.29759127f, -0.19633612f, 0.12338230f, 0.08068267f, 0.07970136f, 
    -0.23458907f, -0.32708400f, 0.01809172f, -0.37023434f, -1.08724415f, -0.37848726f, 0.35916942f, 0.68420047f, 
    0.49140427f, -0.69217312f, -0.67008567f, -0.20260535f, 0.30953112f, 0.28534842f, -0.00273635f, 0.22453710f, 
    -0.46506682f, 0.31022841f, 0.23757355f, -0.08724079f, -0.11661877f, -0.07999976f, -0.15808262f, -0.33219087f, 
    -0.03402811f, -0.11238462f, -0.01904286f, 0.04827376f, 0.00433877f, 0.55437380f, 0.34886548f, -0.09298451f, 
    -0.36239031f, -0.24299544f, 0.09625877f, 0.01056741f, -0.07102922f, 0.32723394f, -0.33143830f, 0.40755084f, 
    -0.24906537f, -0.06094551f, -0.21975578f, 0.05047148f, 0.21688774f, 0.28337681f, -0.05348980f, -0.25983182f, 
    0.02061430f, -0.20787169f, 0.41749230f, 0.31658313f, -0.27363634f, -0.22944005f, -0.70251161f, -0.85189283f, 
    0.07387457f, 0.55216169f, 0.73330414f, 0.16824636f, -0.07107832f, 0.73594725f, -0.60307467f, -0.36591485f, 
    -0.19536152f, -0.25018352f, 0.19929565f, -0.23708889f, -0.02667563f, -0.12118046f, -0.17649311f, -0.07804527f, 
    0.07072455f, 0.28441763f, -0.00550734f, -0.02392962f, -0.16506486f, 0.01698890f, 0.26408744f, -0.44862607f, 
    -0.28583771f, 0.52006912f, -0.22921202f, -0.18719472f, 0.02988588f, 0.35634530f, -0.34679338f, -0.21924527f, 
    0.28447038f, 0.07334699f, -0.06887434f, 0.19042172f, -0.22590044f, 0.13521908f, 0.07254404f, -0.14584804f, 
    -0.30553570f, -0.14972235f, -0.18226618f, 0.11227825f, 0.19792289f, 0.17272697f, 0.22381938f, 0.36155683f, 
    -0.64988351f, -0.65686655f, -0.44097969f, 0.41494927f, 0.63753992f, 0.29899272f, -0.07362168f, -0.07725824f, 
    0.05476217f, 0.55663836f, -0.06175404f, -0.07307015f, -0.25827664f, 0.16451569f, -0.25129867f, 0.36708787f, 
    -0.20484436f, 0.17473242f, 0.03224178f, -0.04953618f, -0.20174707f, -0.08100293f, 0.08766170f, -0.18865928f, 
    0.08279586f, -0.40386060f, -0.31507605f, -0.40220046f, -0.32742918f, -0.14701292f, -0.54278827f, -0.44252613f, 
    -0.32623380f, -0.23099004f, -0.04400458f, 0.26077941f, -0.13226873f, 0.15115696f, -0.19054297f, -0.07597005f, 
    0.27281737f, 0.24151979f, 0.12034421f, 0.22903584f, 0.08686780f, 0.04701956f, -0.04961307f, -0.08076750f, 
    -0.09588113f, -0.09863588f, -0.57164240f, 0.24790034f, -0.47077936f, -0.33592400f, -0.26147997f, 0.16681471f, 
    -0.20295238f, -0.31571797f, -0.64792997f, -0.48249519f, -0.17882568f, 0.05026383f, -0.02634537f, -0.27421084f, 
    0.27957854f, -0.31502646f, -0.57731110f, -0.06596445f, -0.25030431f, -0.23180573f, -0.00546505f, -0.00837951f, 
    -0.15323019f, 0.03235009f, 0.19623968f, -0.40628085f, -0.13775536f, -0.25961652f, -0.59419984f, -0.38468772f, 
    0.16835238f, 0.31604815f, 0.24737634f, 0.22082506f, 0.04327900f, 0.04250949f, 0.22718768f, -0.13744198f, 
    0.06075365f, -0.41467178f, -0.23909895f, 0.12541300f, -0.02677735f, 0.24497895f, -0.11935773f, -0.08165992f, 
    0.05351308f, -0.05425631f, -0.29674673f, -0.45474020f, -0.75734991f, -0.02309856f, -0.42329532f, -0.39632270f, 
    0.09113083f, -0.34042570f, 0.24177031f, -0.10992684f, -0.00142448f, 0.22766648f, -0.24774817f, -0.30929852f, 
    -0.49566153f, -0.38157120f, 0.21823555f, 0.16279395f, 0.14800286f, 0.12800498f, -0.12209546f, -0.25014335f, 
    -0.09890196f, 0.14452061f, -0.06500867f, -0.28914738f, -0.36710611f, 0.44629440f, -0.23663007f, -0.10604405f, 
    0.39762571f, 0.31835896f, 0.41488636f, 0.12606746f, 0.00863605f, -0.08714966f, 0.16444543f, 0.12739563f, 
    0.45877033f, -0.23075822f, -0.39770085f, -0.00595290f, -0.24411705f, -0.18197890f, -0.04408234f, 0.02761684f, 
    -0.12690967f, 0.07187370f, -0.18098979f, 0.03964719f, -0.01996282f, 0.05774096f, -0.54136139f, -0.31369492f, 
    -0.44365370f, -0.33151996f, -0.42312986f, 0.16229358f, 0.32655203f, 0.31752789f, 0.19471246f, -0.01419041f, 
    -0.10399617f, -0.27122965f, 0.14804170f, 0.50785565f, 0.00453356f, -0.08925896f, -0.01560824f, -0.04292205f, 
    -0.22856592f, -0.28685758f, 0.00636538f, 0.34654883f, 0.25945136f, 0.11798813f, -0.04571034f, -0.54267120f, 
    -0.34503907f, -0.41475081f, -0.61236942f, -0.70104903f, 0.58297354f, 0.04038447f, 0.25694883f, -0.11482819f, 
    0.57874167f, -0.01187724f, 0.17774332f, -0.39863238f, -0.14865521f, -0.09018739f, -0.26812890f, -0.00959439f, 
    0.10098165f, 0.12203338f, 0.00437399f, -0.10753220f, -0.01049908f, 0.01503282f, 0.22171724f, -0.11581764f, 
    0.55515909f, -0.09739372f, 0.04369338f, 0.27353331f, -0.28288317f, -0.04231748f, -0.33244348f, -0.05467054f, 
    0.01003159f, 0.10091474f, -0.23438926f, 0.10430118f, 0.27154195f, -0.00060055f, -0.14960855f, -0.08537788f, 
    0.08906663f, -0.03100048f, 0.06546012f, -0.22836941f, -0.21439683f, 0.02129816f, 0.14727470f, 0.12536527f, 
    0.11897473f, 1.20702541f, -0.78148109f, -0.58376938f, -0.64286965f, -0.55727226f, 0.66315782f, 0.13307516f, 
    0.38618523f, 0.10320988f, 0.05546774f, -0.13764100f, 0.17299575f, 0.14262067f, -0.18222128f, 0.07608702f, 
    -0.07652947f, -0.02899425f, 0.25740451f, -0.16762295f, -0.14948736f, 0.01804931f, -0.03312288f, -0.17182015f, 
    0.07368003f, 0.26656288f, 0.61873281f, 0.12572218f, 0.55172414f, -0.01444445f, -0.61708790f, -0.36571753f, 
    0.19064058f, -0.15043998f, 0.04453894f, -0.29524988f, -0.16096774f, -0.31155223f, -0.01288790f, 0.08744425f, 
    0.36567459f, 0.18235840f, 0.08449119f, -0.19893336f, 0.13572712f, 0.10389874f, -0.01494397f, -0.13582623f, 
    -0.24327631f, -0.44993371f, -0.42745644f, 0.21244456f, -0.06639116f, -0.05834947f, 0.12283171f, 0.09925693f, 
    0.04879458f, -0.09198975f, 0.25593495f, 0.11091263f, -0.24234754f, 0.06250986f, 0.34086418f, -0.07750443f, 
    -0.35518181f, 0.03315587f, 0.25830534f, -0.20916928f, 0.11266097f, -0.29774129f, -0.24852557f, -0.16364348f, 
    -0.19540830f, 0.11387992f, 0.20255183f, 0.33980766f, -0.75334692f, 0.03135899f, -0.14314137f, -0.23145768f, 
    -0.52082276f, -0.22414745f, 0.31708756f, -0.54101729f, -0.37209657f, 0.43807685f, 0.17213023f, -0.02225254f, 
    -0.18994969f, -0.20680423f, -0.16994867f, -0.05275749f, -0.02025736f, -0.18619251f, -0.31698868f, -0.50003773f, 
    0.06027344f, 0.01542482f, -0.08018038f, 0.10147627f, 0.21809776f, -0.28701335f, 0.28808585f, 0.32746449f, 
    -0.02396229f, -0.34064838f, -0.54144770f, 0.02053404f, -0.23359807f, 0.38360333f, 0.37540400f, 0.09286303f, 
    -0.09120435f, -0.18309364f, 0.24350218f, -0.06376015f, 0.09393107f, 0.28175431f, -0.22365752f, -0.26574630f, 
    0.20734282f, -0.10902747f, 0.17974065f, -0.01189106f, -0.32539245f, 0.22185327f, -0.78221613f, -0.46519139f, 
    -0.64069420f, 0.10912190f, -0.08732083f, -0.15818341f, 0.07532054f, 0.37245095f, 0.31549138f, 0.60006183f, 
    0.24245885f, 0.05293072f, 0.30065063f, -0.19660671f, 0.35510331f, -0.11645371f, -0.11375684f, -0.13873205f, 
    0.12365095f, -0.08055981f, -0.10229465f, 0.20531638f, -0.11612149f, -0.13716727f, 0.14357331f, 0.57046974f, 
    -0.93208456f, -0.26797366f, 0.14386258f, -0.00476998f, -0.39805421f, -0.10255478f, -0.12049975f, 0.22439012f, 
    -0.34664583f, 0.18801768f, 0.35088605f, -0.22118899f, -0.27546886f, 0.36867878f, -0.22920130f, -0.12219259f, 
    0.03387155f, 0.22864904f, -0.24938397f, -0.30046967f, -0.24715623f, 0.04408532f, -0.24323045f, 0.38382044f, 
    -0.29938781f, 0.17144124f, -0.26419261f, -0.19517128f, 0.14038265f, -0.03928487f, 0.07450700f, 0.32397643f, 
    -0.26967970f, -0.16581663f, 0.08225338f, 0.08910459f, 0.37676740f, -0.21116085f, 0.02562409f, 0.20872103f, 
    -0.40682811f, -0.38083923f, 0.05652957f, -0.24073732f, 0.02098729f, 0.39876813f, 0.00918991f, -0.15600571f, 
    0.42529458f, 0.30409661f, 0.48526716f, 0.39183334f, 0.06024698f, -0.93564010f, -0.47284427f, -0.56413347f, 
    -0.54380220f, -0.28829411f, 0.05927661f, 0.35915288f, 0.32423377f, -0.16790166f, 0.09136889f, 0.23934850f, 
    -0.10853196f, -0.17729224f, 0.22023174f, -0.17334940f, -0.42481908f, 0.13757847f, 0.00394312f, 0.02438007f, 
    -0.09086034f, 0.06362122f, -1.27063477f, 0.96780950f, -0.21507218f, -0.40343508f, 0.10461532f, 0.01376945f, 
    0.21484081f, 0.27357283f, 0.13076892f, -0.04095899f, -0.39008370f, -0.19212699f, 0.07669075f, -0.13954203f, 
    0.16373901f, -0.03601417f, 0.13033606f, -0.13284095f, 0.14999396f, 0.23938340f, -0.11022659f, 0.27725193f, 
    0.01022886f, -0.08546799f, -0.28387958f, -0.18105157f, -0.38742477f, -0.23237257f, 0.72249037f, 0.45070082f, 
    -0.04359652f, -0.33179668f, -0.40305507f, -0.45337126f, 0.02182088f, 0.30138242f, -0.20247719f, 0.15444064f, 
    -0.25510603f, 0.45489317f, -0.20366345f, 0.15886599f, 0.17858587f, -0.00217988f, 0.33254021f, -0.11046662f, 
    -0.19801646f, 0.02646861f, -0.10565323f, -0.21038966f, -0.05653833f, -0.35644275f, -0.73347938f, -0.71387810f, 
    -0.06334309f, 0.11421124f, -0.18060927f, -0.10365368f, -0.37701795f, -0.52474689f, 0.58878708f, 0.45753568f, 
    0.42838883f, -0.03808546f, -0.16827632f, -0.13123854f, 0.03136514f, -0.12262820f, -0.28410518f, -0.17264330f, 
    -0.10823532f, -0.31607524f, 0.08714403f, 0.12339291f, -0.44132999f, -0.77012789f, -1.09042192f, 0.04414802f, 
    0.41699135f, 0.10287333f, 0.56199932f, 0.68789667f, 0.07626126f, -0.34860045f, 0.03108382f, -0.22501302f, 
    -0.05348135f, 0.10591467f, 0.08045067f, -0.05862095f, 0.09381140f, -0.25915861f, -0.13870798f, 0.20741072f, 
    0.17240065f, -0.05730741f, -0.13666151f, -0.10097734f, 0.17140189f, -0.02226331f, 0.47522002f, 0.34335601f, 
    0.16036320f, 0.15409867f, 0.41465193f, 0.11113503f, -0.03314212f, -0.16553490f, -0.06386524f, -0.18723854f, 
    0.13858642f, 0.23983540f, -0.06647456f, -0.09114359f, 0.11351670f, 0.03244608f, 0.06296249f, -0.17321123f, 
    -0.15953611f, 0.23020312f, -0.11272515f, -0.06868029f, 0.13545217f, 0.02426795f, 0.01892093f, 0.45084655f, 
    0.18388104f, -0.25482413f, -0.27518502f, -0.44235280f, 0.55204481f, 0.13758449f, 0.32319838f, -0.50526357f, 
    -0.35792786f, -0.01055563f, 0.14849915f, 0.30234274f, -0.29410002f, -0.28871182f, -0.02024658f, 0.30359486f, 
    0.18797639f, -0.45382544f, 0.06981341f, 0.14050885f, 0.07175044f, -0.37793586f, 0.21496886f, 0.16093998f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.12533496f, -0.24300008f, 0.19286016f, -0.05454322f, 0.12481732f, 0.28012660f, 0.26023716f, -0.04965861f, 
    0.13402411f, -0.13315448f, 0.08181500f, 0.07598313f, -0.07384522f, -0.18905663f, 0.02306229f, -0.20521773f, 
    0.10573637f, 0.13589413f, 0.05314785f, -0.05864880f, 0.00773191f, 0.25504223f, 0.14215311f, 0.30744776f, 
    0.02846725f, 0.17647398f, 0.08854424f, 0.23233122f, 0.04110959f, 0.07780838f, -0.08806041f, 0.39905322f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.03479829f, -0.04961546f, -0.01548345f, -0.00544013f, 0.03613073f, -0.00630340f, -0.00763627f, 0.02566951f, 
    -0.05052907f, 0.01676130f, 0.04715529f, -0.03955173f, -0.03346963f, 0.00538872f, -0.00726326f, 0.01478679f, 
    0.03877282f, 0.04815990f, -0.04498960f, 0.01652610f, -0.00431583f, 0.03863694f, -0.02286490f, -0.04261609f, 
    0.00572096f, 0.01522398f, -0.04762182f, -0.02847450f, -0.05152067f, 0.02775179f, -0.04640162f, -0.05067123f, 
    -0.00199413f, 0.03276562f, 0.02790638f, 0.02004756f, -0.06203556f, -0.01818368f, 0.02450331f, 0.01977587f, 
    0.01574942f, -0.04809955f, 0.00815666f, -0.01933728f, 0.00844962f, -0.02972400f, -0.05568124f, -0.01398276f, 
    -0.04502558f, 0.04028478f, -0.04323810f, 0.04027565f, -0.04172099f, -0.04741208f, 0.03536386f, 0.01285131f, 
    -0.02680996f, 0.01314035f, -0.03654362f, -0.04738955f, 0.00271108f, -0.03508206f, 0.00683888f, 0.02189278f, 
    -0.05094368f, -0.02123890f, -0.04911092f, 0.02244427f, 0.01119466f, 0.02016772f, 0.01656322f, 0.01172523f, 
    -0.00629128f, -0.04710903f, 0.00355442f, 0.02496600f, 0.02513829f, -0.04428767f, -0.03820713f, -0.02512032f, 
    -0.02289333f, 0.01234961f, -0.02588419f, -0.03012772f, 0.02391556f, 0.03319737f, 0.03286789f, 0.03602651f, 
    -0.01199238f, 0.00584165f, 0.02525284f, 0.03830472f, 0.02615297f, -0.01434865f, -0.01022890f, 0.02021552f, 
    0.01268225f, 0.01135065f, -0.05280956f, -0.02283307f, 0.03293737f, -0.05003510f, -0.02904250f, 0.01004529f, 
    0.02618681f, 0.02162930f, 0.04027321f, 0.01199915f, 0.02617585f, -0.00874469f, 0.01532603f, 0.03037668f, 
    -0.06088370f, 0.01137923f, 0.01910559f, 0.03167324f, 0.02715403f, 0.01068033f, -0.02275656f, 0.01079431f, 
    0.00616178f, 0.00208095f, 0.03223171f, -0.05843487f, 0.04463718f, -0.04368019f, 0.00789698f, 0.03592363f, 
    -0.03035894f, 0.03419124f, 0.00590338f, -0.00960490f, -0.05600351f, -0.01456582f, -0.03744774f, -0.01011653f, 
    -0.03754824f, 0.01665796f, 0.02022728f, 0.02573563f, -0.03830940f, 0.00177373f, -0.00093247f, 0.04376297f, 
    0.01424067f, -0.02908759f, -0.02643996f, -0.02548706f, -0.04426936f, -0.04636912f, -0.01532383f, -0.05210128f, 
    -0.03859016f, 0.01467723f, -0.04776382f, -0.03787381f, 0.02533646f, -0.04740512f, 0.02686795f, 0.01700888f, 
    -0.02135771f, -0.03240994f, -0.02813069f, -0.02192983f, 0.00924882f, -0.04055611f, -0.00455103f, -0.03942386f, 
    -0.04937755f, 0.02662492f, 0.00845709f, -0.04517559f, 0.00189198f, -0.01075577f, 0.00154273f, -0.00109272f, 
    -0.03170418f, 0.02564921f, -0.01869790f, -0.00534890f, 0.01388801f, -0.05055758f, -0.00362281f, -0.01643078f, 
    -0.03311122f, -0.01668441f, -0.03392608f, -0.02609334f, -0.04681171f, -0.01435201f, -0.05567346f, 0.01505598f, 
    -0.04925654f, 0.02969963f, -0.00505518f, 0.04072789f, 0.04522445f, -0.00530419f, 0.01456427f, 0.00499924f, 
    -0.05851941f, -0.03323567f, -0.01157042f, 0.02983470f, 0.01909339f, -0.01914142f, -0.04247169f, -0.04981673f, 
    0.03447008f, -0.02422351f, 0.00274298f, -0.00073542f, 0.03611642f, -0.00962053f, 0.01212257f, -0.01761910f, 
    0.02245440f, 0.01978854f, 0.01946118f, -0.02667978f, -0.03272434f, 0.03406298f, 0.02756808f, -0.02631965f, 
    0.00003273f, -0.04616361f, 0.03801586f, 0.01491516f, 0.04099164f, 0.03656266f, -0.04842351f, -0.00953687f, 
    -0.02576279f, -0.02307674f, 0.03562357f, -0.02859514f, -0.05548169f, 0.04598781f, 0.01494465f, -0.03574179f, 
    -0.04993809f, 0.02170671f, 0.04162602f, -0.03287261f, 0.03220747f, -0.05170171f, -0.04285569f, -0.01764595f, 
    0.03439087f, -0.00709623f, 0.00841018f, 0.01914130f, 0.00229256f, -0.00978931f, -0.01718400f, 0.01576612f, 
    -0.04162533f, -0.05283850f, -0.04298889f, 0.03459922f, -0.01730390f, -0.04137788f, -0.01151345f, -0.05143121f, 
    0.02748590f, 0.03271836f, -0.04852846f, -0.03960292f, -0.01012895f, -0.02478838f, -0.04474467f, -0.00887073f, 
    -0.04054440f, 0.03976396f, -0.05296723f, 0.03700170f, 0.04225053f, -0.04221781f, 0.01305997f, -0.03008161f, 
    0.03017171f, -0.03827818f, 0.00747877f, -0.03922221f, -0.02766744f, 0.01866058f, 0.03609142f, -0.01807713f, 
    -0.03366497f, -0.03437833f, -0.03105442f, 0.01407518f, -0.03240135f, -0.01306169f, -0.05053242f, 0.02777843f, 
    -0.03458350f, -0.04118470f, 0.00337000f, -0.01812308f, 0.04597034f, -0.02139975f, -0.01561121f, -0.02997460f, 
    -0.03190713f, 0.01564598f, 0.03145747f, -0.05207403f, -0.04837563f, -0.05288437f, -0.01729470f, -0.01458846f, 
    -0.01357921f, 0.04760932f, 0.00935157f, -0.02745333f, 0.02548836f, -0.01421005f, -0.03230525f, -0.04937474f, 
    0.02651211f, 0.02208193f, -0.05962422f, -0.01467094f, -0.00469736f, 0.00431384f, -0.01471599f, 0.02192902f, 
    0.02928375f, 0.01694074f, 0.03835498f, -0.01538128f, 0.03106235f, 0.01389540f, 0.01667263f, -0.04171340f, 
    0.01707656f, 0.00008353f, 0.00838479f, 0.02511498f, 0.00888125f, 0.02906933f, 0.01757310f, -0.01978411f, 
    -0.03956646f, -0.03513567f, 0.01653692f, 0.03428726f, 0.04014113f, -0.03506905f, -0.05350765f, -0.05639483f, 
    -0.04753881f, 0.04893463f, -0.00197523f, -0.03037794f, -0.03267004f, 0.03229408f, -0.05469050f, -0.04539303f, 
    0.00486187f, 0.01795820f, -0.00093510f, 0.01721510f, 0.01391319f, 0.00531442f, 0.00712190f, -0.00071881f, 
    0.01988092f, -0.04806291f, 0.02287671f, -0.01772606f, -0.01104630f, 0.03492773f, 0.01693662f, -0.00429512f, 
    -0.04406581f, -0.01686471f, -0.03688194f, -0.01138892f, -0.06435267f, -0.01247866f, -0.00032959f, 0.03649488f, 
    -0.03814385f, -0.32632673f, 0.04300543f, 0.09654262f, -0.02199776f, -0.03199183f, -0.05301270f, -0.06442113f, 
    -0.02098230f, -0.00103867f, 0.15253319f, 0.03065726f, 0.21202889f, -0.07564677f, -0.07198767f, -0.03564027f, 
    0.04999707f, 0.03554629f, -0.13043244f, 0.08050521f, -0.04954516f, -0.14036186f, -0.16913207f, 0.04531059f, 
    0.04044663f, -0.09261696f, 0.03566610f, 0.07658426f, -0.14515917f, 0.02002469f, 0.02140990f, 0.07019580f, 
    -0.00049148f, 0.05658299f, -0.08367813f, 0.06878831f, 0.21722241f, -0.09551973f, -0.00975698f, -0.00887260f, 
    -0.06679495f, -0.01598953f, 0.04964615f, 0.01124173f, 0.07735356f, -0.03511106f, -0.04409603f, -0.04473858f, 
    -0.32125455f, -0.01779745f, 0.02068293f, 0.06487420f, -0.01942108f, 0.01660545f, 0.05654654f, -0.04931137f, 
    0.01631053f, -0.04873738f, 0.08563798f, -0.00444475f, 0.10612942f, -0.16050626f, 0.08033554f, 0.24885246f, 
    -0.07620077f, -0.05430431f, 0.03734243f, -0.04076022f, 0.07372920f, 0.07072780f, 0.06408630f, -0.07332740f, 
    -0.03569385f, -0.51103622f, 0.37278333f, 0.00223147f, 0.05323087f, 0.10505861f, 0.04234888f, 0.01600115f, 
    0.11740748f, 0.04080964f, 0.03690468f, -0.07317175f, -0.06445830f, 0.15689692f, -0.07091529f, 0.03807330f, 
    0.09608336f, -0.05276737f, 0.33727798f, -0.07970775f, -0.12235469f, -0.14248285f, -0.01482691f, -0.07943212f, 
    -0.05998050f, -0.03119987f, 0.01241139f, 0.40620211f, -0.05303727f, 0.02301229f, 0.04973224f, -0.06575021f, 
    0.18554880f, 0.12985726f, 0.03830776f, 0.10307116f, 0.06631171f, 0.10136760f, 0.10327519f, 0.03796803f, 
    -0.10494912f, -0.10478465f, -0.01826489f, -0.02194559f, 0.02486328f, 0.01598158f, -0.02440192f, -0.12763833f, 
    0.09811602f, 0.15613365f, 0.03029038f, 0.04586369f, -0.04915191f, -0.03210701f, 0.05922337f, 0.00060934f, 
    0.04361955f, 0.05699788f, -0.00349173f, 0.05968176f, -0.01960034f, 0.06166623f, -0.00983727f, -0.19151624f, 
    -0.03940650f, -0.10007596f, -0.07759549f, -0.02916089f, 0.01566119f, 0.06973999f, 0.06510989f, 0.04688870f, 
    -0.10059786f, 0.12566970f, 0.03531872f, 0.11637561f, -0.00483616f, 0.11836471f, 0.03240764f, -0.07197548f, 
    0.08090876f, 0.07870475f, 0.03798861f, -0.01132998f, 0.20402223f, 0.08409543f, -0.06880125f, 0.21311229f, 
    -0.16035853f, 0.00541456f, -0.04019805f, 0.07288561f, -0.05349351f, -0.05673501f, -0.08229882f, -0.10050718f, 
    0.09263983f, 0.24585333f, 0.05145504f, 0.01234388f, -0.05533181f, -0.14413127f, -0.04710566f, 0.01329289f, 
    0.00657863f, -0.14943437f, 0.06411251f, -0.10119934f, 0.12216019f, 0.34570044f, 0.15058455f, -0.09086840f, 
    -0.10561556f, -0.01442374f, 0.04354928f, -0.02794516f, -0.06730559f, -0.01758514f, -0.05146986f, -0.08257774f, 
    0.23566025f, 0.10973666f, 0.04768584f, -0.05612384f, -0.00612665f, 0.15606731f, 0.10194150f, 0.15045740f, 
    -0.07454997f, -0.11716232f, 0.12331528f, -0.06104517f, 0.51715583f, -0.32524955f, 0.08035620f, -0.16321626f, 
    -0.15671861f, -0.06773897f, -0.19926937f, 0.09097597f, -0.13379689f, -0.15338363f, -0.03069837f, -0.03423893f, 
    0.07733662f, 0.14067805f, -0.00883174f, -0.16107914f, 0.06875972f, -0.13848440f, -0.06273817f, -0.02656116f, 
    0.00825884f, 0.02261788f, 0.00701915f, 0.25722006f, 0.06690633f, 0.07666410f, -0.10834686f, 0.20586233f, 
    -0.19390583f, -0.02457759f, -0.07386862f, 0.03560308f, -0.09723133f, -0.11192822f, -0.04867006f, -0.11983842f, 
    0.02483319f, 0.16808587f, -0.03997301f, 0.00765722f, -0.08196495f, -0.03610201f, 0.03288706f, -0.00302440f, 
    0.03100411f, -0.10320959f, 0.08036074f, -0.06916249f, -0.25843218f, 0.07228683f, 0.03682461f, -0.01786821f, 
    0.07380821f, -0.06268091f, 0.05140954f, 0.00434774f, 0.01064002f, 0.04205244f, -0.04988604f, 0.00738979f, 
    0.06330679f, 0.11384454f, -0.07629067f, -0.09749986f, -0.08001722f, -0.08048151f, -0.03567487f, -0.09453697f, 
    0.15033005f, 0.01273950f, 0.05338636f, 0.04329180f, 0.06088841f, 0.03234477f, 0.07415088f, -0.02040493f, 
    0.12139532f, -0.01950741f, -0.03197929f, 0.09517945f, 0.00412266f, -0.04174495f, -0.01254316f, -0.06646884f, 
    0.19566819f, -0.07467700f, 0.17713679f, -0.00716755f, -0.19248021f, 0.09496929f, -0.01547819f, 0.00567445f, 
    0.00741304f, -0.12276621f, -0.12942301f, 0.10226421f, -0.02849049f, 0.13471799f, 0.16474088f, -0.06653602f, 
    -0.01797628f, 0.04460122f, 0.13626578f, 0.11376902f, -0.05474484f, 0.05884184f, 0.08848288f, -0.04323817f, 
    -0.64660114f, -0.21811563f, -0.02117667f, -0.16821502f, 0.09420234f, 0.10358972f, -0.08187961f, -0.02480764f, 
    0.02964670f, 0.06880359f, -0.15199588f, -0.07241889f, -0.01161896f, 0.08583666f, 0.08514254f, -0.11056994f, 
    0.02723356f, -0.05207050f, 0.06250574f, 0.07768444f, -0.15227175f, -0.10248823f, -0.00169782f, -0.11218821f, 
    0.24276008f, 0.01460900f, 0.13773462f, 0.00760396f, -0.02797453f, -0.08833472f, -0.15890822f, 0.13199975f, 
    0.08416465f, 0.05868402f, 0.09884422f, 0.01357817f, 0.47547129f, -0.39667049f, -0.04837150f, 0.22299157f, 
    0.06438111f, -0.01794687f, -0.01976302f, -0.10629196f, 0.16853976f, 0.03249392f, 0.00797819f, 0.22520936f, 
    0.26935464f, 0.09350231f, -0.13026530f, 0.08332671f, -0.15832452f, 0.10118399f, -0.00150119f, 0.06320895f, 
    -0.07972813f, 0.03042985f, 0.02955684f, -0.05777856f, 0.20422399f, -0.21000633f, 0.00000463f, -0.13032970f, 
    0.02963613f, 0.05052574f, 0.09043428f, 0.02809139f, 0.06952835f, -0.02939959f, 0.04751693f, -0.13792458f, 
    -0.12565051f, 0.14867413f, -0.09079587f, -0.05412848f, 0.04186298f, -0.07474772f, -0.00771919f, 0.02138796f, 
    0.02151251f, 0.04698980f, -0.04475144f, -0.01505413f, -0.36302671f, 0.01085173f, 0.02213025f, -0.01234301f, 
    0.05840746f, 0.01053803f, 0.02798757f, 0.06435365f, -0.05722897f, -0.04296479f, 0.03982501f, -0.07393380f, 
    -0.11608101f, 0.20952025f, -0.04839439f, 0.18657708f, 0.04451913f, 0.00145684f, 0.09386840f, -0.02628703f, 
    0.00524758f, 0.05122521f, 0.05399784f, 0.09622493f, -0.01683589f, 0.08856992f, -0.10811060f, 0.06848466f, 
    0.03335020f, 0.00733953f, 0.07787286f, -0.14792570f, -0.04327685f, -0.04447002f, 0.03264687f, -0.08146192f, 
    0.33642760f, 0.27167690f, -0.03862525f, -0.04420218f, 0.02888614f, -0.01498154f, 0.07014788f, 0.08110684f, 
    0.11537153f, 0.02642028f, 0.00297371f, 0.02981460f, -0.13119090f, 0.02498860f, -0.02413676f, 0.07884007f, 
    -0.05369950f, 0.15556180f, -0.08439044f, -0.02459859f, -0.02065458f, 0.08108407f, 0.00684262f, 0.11730457f, 
    0.32166499f, 0.52195722f, -0.08537983f, 0.22587669f, 0.05707808f, -0.05707752f, 0.11144904f, -0.01488615f, 
    0.02374479f, -0.04656057f, 0.12355507f, 0.13208432f, -0.10096406f, -0.10838962f, 0.07358712f, -0.06196310f, 
    -0.03460746f, -0.07947674f, -0.18298471f, 0.06829223f, 0.11532006f, 0.16775277f, -0.08030135f, -0.06521938f, 
    -0.18199621f, 0.14528520f, -0.06387859f, -0.18791592f, 0.10097110f, -0.07906528f, -0.02898965f, 0.09839386f, 
    0.00844320f, -0.10471214f, 0.17062464f, 0.02287411f, -0.02831193f, -0.08329239f, -0.13548306f, -0.16370548f, 
    0.10953157f, 0.09285038f, 0.08361962f, 0.08525542f, -0.09010500f, -0.04437414f, 0.04799907f, -0.06924325f, 
    -0.08927106f, -0.14009202f, -0.14500938f, -0.16148676f, 0.07525907f, 0.00001067f, -0.08341173f, -0.07705236f, 
    -0.08881098f, -0.00008136f, -0.02556172f, -0.10244241f, 0.12335566f, 0.17765021f, 0.06288776f, 0.11285298f, 
    -0.11292803f, -0.00368724f, 0.04261387f, 0.08604340f, 0.02641582f, 0.03065067f, 0.13150169f, 0.00442911f, 
    0.12210653f, 0.00043433f, 0.05226235f, -0.05914215f, -0.03774885f, -0.02632068f, 0.07136581f, 0.10794057f, 
    -0.11270067f, -0.08217111f, 0.04749650f, 0.00024673f, -0.27138817f, -0.03551807f, -0.27248362f, -0.02639770f, 
    -0.16059203f, -0.05362488f, -0.12531072f, -0.10266045f, 0.02751052f, -0.02353858f, 0.10643335f, 0.03182070f, 
    -0.07078643f, -0.06990893f, 0.01350193f, -0.03762515f, 0.05607093f, 0.13083434f, 0.01004944f, -0.04304624f, 
    0.05809433f, 0.09142868f, -0.16260538f, -0.00148525f, -0.29273152f, -0.17461611f, 0.05766723f, 0.22409731f, 
    0.08630122f, 0.04484244f, -0.00797203f, -0.00868160f, -0.02312280f, -0.07226392f, 0.07366042f, -0.04259194f, 
    -0.13079715f, 0.13342446f, 0.12579283f, 0.04504916f, 0.02084569f, -0.15688670f, -0.09193051f, -0.07151108f, 
    0.03366696f, 0.04843203f, -0.06740823f, 0.04290649f, -0.54210466f, 0.42263329f, -0.03226748f, 0.19338813f, 
    0.05996548f, 0.06639263f, -0.01696537f, 0.09379783f, 0.12006232f, 0.00176018f, -0.02961233f, -0.06065680f, 
    -0.13096905f, -0.26086730f, 0.03562685f, 0.09202259f, -0.01293875f, 0.13037881f, 0.08712190f, 0.10563090f, 
    0.03778428f, 0.01707885f, 0.00838715f, -0.20684870f, 0.01265568f, -0.14478768f, -0.13559474f, -0.06273544f, 
    0.00399995f, 0.02479253f, -0.18700081f, -0.07411929f, 0.17117523f, 0.03471512f, 0.07258026f, 0.11131271f, 
    0.05951651f, -0.09552599f, -0.00629299f, -0.13999462f, -0.01827319f, 0.09542543f, -0.00639714f, 0.02825718f, 
    0.03579479f, 0.04798789f, -0.11766889f, -0.05645839f, 0.19637160f, -0.13631332f, 0.08718915f, 0.06967969f, 
    -0.01081798f, -0.03087068f, -0.02634181f, 0.06406812f, 0.03004011f, 0.03855558f, 0.08605024f, 0.12651610f, 
    -0.21622047f, 0.13879532f, 0.23606262f, 0.10169064f, -0.05065714f, -0.04382475f, -0.02520536f, 0.15878908f, 
    -0.03722999f, 0.05818724f, 0.18503435f, -0.00454864f, -0.16078421f, 0.00858873f, -0.13136014f, 0.12804022f, 
    0.10313912f, 0.13538489f, 0.14322799f, 0.07431116f, -0.00566750f, 0.04690623f, 0.16907179f, -0.00436487f, 
    -0.07769843f, 0.07700716f, -0.14094545f, -0.13276340f, 0.13789269f, 0.15736727f, -0.02747989f, 0.08072438f, 
    0.09095798f, 0.14278701f, 0.21056722f, 0.03182516f, 0.00404465f, -0.18337809f, -0.10325175f, -0.15948337f, 
    0.17989059f, 0.09752501f, -0.00710382f, -0.08261186f, -0.03139238f, -0.01043376f, -0.01016638f, 0.00473581f, 
    0.36878365f, 0.24756005f, 0.05289108f, 0.07879780f, 0.00364327f, 0.07558076f, 0.26644441f, 0.17572841f, 
    -0.04696288f, 0.06753594f, 0.08703287f, -0.00813257f, -0.06073207f, 0.03738207f, -0.22219828f, 0.04227662f, 
    0.04934227f, 0.11281309f, 0.07989481f, 0.01723835f, 0.16484497f, 0.08346692f, 0.00494488f, 0.09937793f, 
    -0.15478328f, -0.09218706f, -0.21532747f, -0.15597282f, 0.03522459f, 0.09224600f, 0.08288142f, -0.04179961f, 
    -0.13566507f, -0.06776341f, -0.16181923f, -0.01899698f, -0.29356772f, 0.32280833f, 0.11188903f, -0.10905115f, 
    -0.00865232f, -0.08814818f, -0.10955796f, -0.02597832f, -0.10209416f, -0.01151470f, -0.04230402f, -0.01903342f, 
    -0.24258882f, -0.05000893f, -0.07522209f, -0.08261988f, -0.16837344f, -0.15792708f, -0.22546495f, -0.08656684f, 
    -0.08513463f, -0.17134763f, -0.06377402f, 0.09037586f, -0.34187907f, 0.06152511f, 0.07372513f, 0.07661919f, 
    0.03841647f, 0.14973058f, -0.11587073f, 0.01551400f, -0.00876378f, 0.08833160f, 0.10305577f, 0.16174422f, 
    -0.15320574f, 0.21603318f, -0.00708597f, -0.02506437f, -0.00763936f, 0.07210495f, -0.01109403f, 0.01195313f, 
    -0.19501835f, -0.30107334f, -0.20583893f, -0.34981635f, 0.00098493f, -0.04293178f, -0.02241893f, -0.01792879f, 
    0.00829306f, 0.00980730f, 0.12087703f, 0.16161603f, -0.00450523f, 0.05616889f, -0.00730263f, -0.07897504f, 
    -0.06164882f, 0.09986929f, 0.05167799f, 0.20009114f, -0.06277505f, 0.11634208f, -0.06663161f, 0.06726093f, 
    -0.00610909f, -0.11948231f, 0.26955596f, -0.07246771f, -0.07803595f, 0.12447817f, 0.01562310f, 0.02099282f, 
    0.00489159f, -0.03319502f, -0.10473871f, 0.09043756f, 0.05532254f, -0.01577182f, -0.02594987f, 0.03860534f, 
    -0.14515489f, 0.06992281f, -0.09105133f, -0.00679223f, 0.05073651f, 0.04749900f, 0.05036240f, 0.06921654f, 
    0.01768616f, 0.04782822f, -0.04497360f, -0.25424981f, 0.00758325f, 0.01286096f, 0.01577943f, 0.02882816f, 
    -0.01612757f, 0.03786488f, -0.01434266f, -0.00448299f, -0.06986279f, 0.11253695f, -0.10266771f, 0.17479835f, 
    -0.30517435f, 0.32656854f, -0.03179258f, 0.13435021f, 0.17609945f, -0.01113015f, 0.02530125f, 0.14247876f, 
    0.12848631f, 0.01723623f, 0.01034696f, 0.12476791f, -0.08797190f, -0.15319005f, 0.06245632f, -0.11017266f, 
    0.09052812f, 0.10987207f, -0.02696588f, 0.15123636f, 0.12659441f, 0.12879126f, 0.01321711f, 0.08624875f, 
    -0.15801437f, 0.07879632f, -0.15668058f, 0.10920780f, 0.07767574f, -0.03081904f, -0.11354993f, -0.13057232f, 
    0.07958772f, -0.05585529f, 0.03188716f, 0.07889341f, -0.14868468f, 0.03711102f, -0.04659874f, 0.01201369f, 
    -0.04140450f, -0.15039016f, -0.06419824f, -0.08399594f, -0.13035606f, -0.03645063f, -0.03790483f, 0.08435058f, 
    -0.09468197f, 0.00222250f, 0.19918235f, 0.00441274f, 0.03662431f, 0.28410447f, -0.03313985f, 0.21617125f, 
    -0.00232935f, 0.03061860f, 0.01822470f, -0.01647572f, 0.08375126f, 0.02828379f, -0.09620956f, -0.20981953f, 
    -0.08527809f, -0.13068494f, -0.09106977f, -0.05468892f, 0.06874680f, -0.16050565f, 0.02897723f, 0.07155186f, 
    0.20423986f, 0.03573148f, 0.28714415f, 0.11766002f, 0.12993991f, -0.11104300f, -0.06357400f, 0.07166419f, 
    0.02996260f, -0.04192818f, -0.06768610f, -0.07861236f, 0.19626491f, 0.10241991f, 0.01148852f, 0.14964543f, 
    -0.17592631f, 0.02778891f, -0.13679202f, -0.00482621f, -0.01096472f, -0.01774700f, -0.02791039f, -0.06564020f, 
    -0.06316642f, -0.01148314f, -0.02213497f, 0.06810559f, -0.01779371f, -0.00546989f, 0.14253618f, 0.07953304f, 
    0.00767150f, -0.06399214f, -0.03557895f, -0.10566796f, 0.25598642f, -0.01051275f, 0.04759641f, -0.22483483f, 
    -0.10536933f, -0.00598777f, 0.04044351f, 0.04415418f, -0.00262084f, -0.06319749f, -0.11405955f, -0.10548183f, 
    0.26707116f, 0.27976134f, 0.21840455f, 0.19976154f, -0.09864705f, -0.09145483f, -0.03524116f, -0.07343633f, 
    0.03592240f, 0.04367241f, 0.03854480f, 0.01672558f, 0.34677389f, 0.05427215f, 0.24584600f, -0.26508519f, 
    -0.06976415f, 0.06474394f, -0.11635791f, -0.10285340f, 0.02592869f, 0.05045641f, 0.08777539f, -0.10853306f, 
    0.02842559f, -0.04637836f, 0.05271041f, -0.24866556f, -0.05230116f, -0.08273955f, -0.10435615f, 0.17066802f, 
    -0.01823734f, 0.03854964f, -0.01787636f, -0.20862317f, 0.09675808f, -0.05631707f, 0.01960367f, 0.15847847f, 
    -0.10451168f, -0.01034573f, -0.01963346f, -0.11294043f, -0.02167789f, 0.00042338f, -0.05705256f, 0.13081355f, 
    0.15956561f, 0.00288730f, 0.12531088f, -0.11537959f, 0.06128450f, 0.10175710f, -0.19784881f, 0.15530965f, 
    0.06307694f, 0.04091157f, 0.03658675f, 0.02636523f, 0.04510358f, 0.13041109f, 0.11458303f, -0.10833947f, 
    0.06878535f, -0.08519805f, -0.08436228f, -0.02059391f, 0.13812698f, 0.16320655f, -0.00524632f, 0.07783929f, 
    -0.13437872f, -0.27121237f, -0.02342260f, 0.05195777f, 0.07371551f, 0.04063661f, -0.18978319f, -0.23731083f, 
    -0.01479976f, 0.15611817f, 0.15432148f, -0.00137763f, -0.10312895f, 0.20613667f, -0.02726468f, 0.13609622f, 
    0.09233238f, 0.10832060f, -0.07288257f, -0.00714315f, -0.07272872f, 0.10487580f, 0.08489534f, 0.05298272f, 
    -0.01733762f, -0.18673562f, -0.01607903f, 0.00492820f, -0.12494463f, 0.21496673f, -0.00579328f, -0.00850689f, 
    0.04971059f, 0.01013591f, 0.06691933f, 0.13332762f, -0.13799466f, 0.19370115f, 0.13268115f, -0.26009575f, 
    -0.00882431f, 0.03208410f, -0.20555763f, 0.06624048f, 0.01568715f, -0.02418733f, -0.00903642f, 0.10454505f, 
    -0.18267417f, 0.33741945f, 0.02153296f, 0.14315733f, 0.07149838f, -0.02545054f, -0.02711196f, -0.04097139f, 
    -0.01024543f, 0.09976962f, -0.09797146f, -0.02753301f, -0.07839006f, 0.05658437f, -0.23858637f, -0.27430058f, 
    -0.13315652f, 0.10248233f, 0.06767575f, 0.01083768f, -0.01599135f, -0.04830991f, 0.03713105f, -0.02122354f, 
    -0.28832048f, -0.21709020f, 0.04137133f, 0.06061481f, 0.12070128f, 0.12350211f, 0.21135470f, 0.19040403f, 
    -0.08054876f, 0.02302422f, -0.02410156f, 0.10917471f, -0.07620926f, 0.09258076f, 0.14827918f, 0.16198745f, 
    0.18505257f, 0.02896648f, -0.09406645f, 0.00035385f, 0.13553654f, -0.02639090f, 0.16726305f, -0.02055690f, 
    0.20567635f, 0.11558055f, 0.00351585f, 0.02466284f, -0.16181502f, -0.08485162f, -0.13222307f, -0.08212913f, 
    0.02921236f, 0.00983193f, -0.13513364f, -0.04368404f, 0.17719610f, -0.00485614f, 0.01292098f, -0.00992298f, 
    0.08837003f, 0.08442113f, 0.20267105f, 0.18560742f, 0.08328959f, 0.06926320f, 0.04146617f, 0.10482335f, 
    0.02145922f, -0.03273722f, -0.03003848f, -0.02747750f, 0.01306088f, -0.04244892f, 0.02344403f, 0.03043279f, 
    -0.03554339f, 0.02076743f, -0.03004284f, -0.00192582f, 0.04204397f, 0.01926571f, -0.03795749f, -0.00320278f, 
    -0.04813333f, -0.03933814f, -0.04216428f, -0.04155313f, -0.02038211f, 0.00696118f, 0.02277210f, 0.03458090f, 
    -0.02442920f, -0.02051438f, 0.01682295f, 0.02120742f, -0.02419200f, 0.01433200f, -0.04066036f, 0.04086574f, 
    0.00175399f, 0.01750738f, 0.04561872f, -0.03806753f, 0.00657029f, -0.00906478f, -0.04616659f, -0.02986926f, 
    -0.03190242f, -0.00912053f, 0.00416993f, -0.00798549f, 0.04477227f, 0.04856384f, -0.00031590f, -0.01886610f, 
    -0.02947585f, 0.03545684f, -0.01296800f, 0.04935099f, -0.05015885f, 0.00196724f, -0.03325742f, 0.00976744f, 
    -0.03221632f, 0.02105085f, -0.04015939f, -0.04234191f, -0.02508657f, -0.04657655f, 0.00118595f, 0.00920315f, 
    0.04269011f, -0.03525208f, 0.03587069f, 0.03418304f, 0.01658411f, -0.03011684f, 0.02518391f, 0.00342062f, 
    -0.02523528f, 0.02735563f, -0.01353548f, 0.03507796f, 0.03256104f, -0.02417308f, 0.02420731f, 0.04671288f, 
    -0.00105571f, -0.03307810f, 0.01680338f, -0.03530858f, 0.01028267f, -0.00069758f, 0.02407121f, 0.00643563f, 
    0.03621002f, -0.02507411f, 0.04729655f, -0.03991387f, -0.02361043f, -0.00570577f, 0.01845916f, 0.01101512f, 
    -0.05350333f, -0.00139828f, -0.04703734f, 0.02571928f, -0.02743936f, 0.04761025f, 0.00732474f, -0.04532281f, 
    -0.02233403f, 0.03921969f, -0.01533575f, -0.05156441f, -0.04007895f, 0.03608711f, 0.03046765f, -0.01704492f, 
    0.04616887f, 0.05113674f, -0.02164261f, 0.02577703f, -0.00551260f, 0.01198985f, 0.03780714f, -0.03661746f, 
    0.02228915f, 0.03242927f, 0.02933584f, -0.00412876f, 0.03797076f, -0.03995742f, -0.02081301f, 0.00860868f, 
    0.01643276f, 0.02001167f, 0.02200370f, 0.00664906f, 0.02402434f, 0.02399627f, -0.00171612f, 0.04502834f, 
    -0.02403833f, -0.03948241f, 0.02336657f, -0.05445635f, -0.03363578f, -0.03663366f, 0.00600983f, -0.01318077f, 
    0.00799545f, 0.00483167f, -0.01393407f, -0.03339769f, -0.01010221f, -0.01210051f, 0.00975120f, 0.02177248f, 
    -0.00639638f, 0.03966406f, -0.04314231f, 0.00864990f, -0.01505397f, -0.01043993f, 0.02864952f, -0.00632134f, 
    0.03973870f, 0.01820925f, -0.02945873f, -0.02868920f, 0.03211045f, 0.01401625f, 0.01577478f, 0.02317925f, 
    -0.02710088f, 0.00027186f, -0.03720237f, 0.00824528f, 0.01037386f, -0.00813209f, 0.00403214f, 0.00669283f, 
    -0.00897959f, 0.00873918f, -0.04801367f, 0.02638942f, 0.04695528f, -0.01553725f, -0.00704038f, -0.04075953f, 
    0.02281385f, -0.05496804f, 0.03840552f, 0.01420848f, -0.04528230f, 0.02749474f, 0.01906906f, -0.02797435f, 
    0.00442672f, 0.00188622f, -0.00698210f, -0.02790457f, -0.04118482f, 0.00422998f, -0.02187855f, -0.04793667f, 
    -0.00554684f, -0.00599539f, 0.01399258f, 0.02738140f, -0.00482779f, -0.00832306f, -0.04465357f, 0.00287279f, 
    -0.02670505f, 0.03439939f, 0.00324593f, -0.04200305f, 0.03716581f, -0.00834004f, -0.01995889f, 0.00701293f, 
    0.04455110f, -0.03089049f, -0.01758658f, -0.05055487f, 0.01262748f, -0.05074440f, 0.03283372f, -0.00154760f, 
    0.03492656f, -0.02067408f, -0.02895147f, -0.01005863f, -0.02830941f, -0.00082330f, 0.02969538f, 0.01505983f, 
    0.03995809f, -0.03980665f, -0.01709817f, -0.04999102f, -0.02154229f, -0.00447871f, 0.03211009f, 0.02073198f, 
    -0.01056285f, -0.04901827f, 0.01266911f, -0.04525423f, -0.00600511f, -0.02856258f, 0.03257330f, -0.02437625f, 
    0.03728016f, 0.00369726f, -0.01898674f, -0.02070865f, 0.00214366f, -0.01817962f, -0.03175140f, -0.02379075f, 
    0.03459857f, 0.01551624f, -0.02649416f, 0.04074021f, -0.01716297f, -0.02028293f, 0.03402385f, -0.00851089f, 
    0.03480338f, -0.00098885f, 0.00696005f, -0.03115994f, -0.00429218f, 0.03122182f, -0.04503442f, -0.03913299f, 
    -0.02699118f, -0.01882269f, -0.02803310f, 0.03274130f, 0.04626725f, 0.03453461f, -0.01148320f, -0.05388586f, 
    -0.03482552f, 0.02938075f, -0.03994421f, -0.02059605f, -0.04943477f, 0.02129481f, 0.01348137f, -0.04431785f, 
    -0.02634164f, -0.03158179f, -0.04801119f, -0.04954250f, -0.00288997f, -0.04216836f, 0.00907487f, -0.04706576f, 
    0.03669945f, -0.00444219f, -0.03214655f, 0.04838637f, -0.04228896f, -0.01364002f, 0.02591292f, 0.00503620f, 
    0.02787453f, -0.01705868f, -0.02253358f, -0.00494232f, -0.04253809f, 0.00600380f, -0.00854952f, -0.01463750f, 
    0.02350356f, -0.04049432f, -0.05643730f, 0.01275884f, 0.00624680f, -0.02760139f, -0.03158077f, 0.00276015f, 
    0.04562528f, -0.04099838f, -0.04780073f, 0.02611179f, -0.05373953f, -0.05092941f, -0.03312350f, -0.00622259f, 
    -0.05234043f, 0.00120569f, -0.02125636f, 0.01748801f, 0.00634013f, -0.00999012f, -0.02885081f, -0.01112145f, 
    -0.03019581f, -0.04759960f, 0.01791132f, -0.03864585f, 0.03694078f, -0.01289311f, 0.00993995f, -0.02355248f, 
    0.01447008f, 0.01019403f, -0.03355325f, -0.02382248f, 0.03815590f, 0.03703414f, -0.04861486f, 0.01699066f, 
    -0.04415045f, 0.01384260f, -0.02935347f, -0.03548952f, -0.02436640f, -0.03033663f, -0.04848999f, 0.01882067f, 
    0.02941521f, -0.00208329f, 0.00935818f, -0.03640993f, -0.03498949f, -0.01407501f, -0.03581391f, -0.03918330f, 
    -0.02639229f, 0.03994076f, -0.02459713f, 0.04256100f, -0.01254565f, 0.01877822f, 0.02022566f, 0.03190829f, 
    -0.01349996f, 0.01286026f, -0.02532995f, -0.03277826f, -0.01064566f, 0.03385570f, -0.02546534f, -0.01598548f, 
    0.14808933f, 0.13835166f, 0.27018794f, 0.06462325f, -0.08890390f, -0.02322803f, -0.12199219f, -0.05003156f, 
    0.00655791f, -0.22702740f, 0.07424146f, 0.08964887f, -0.04933231f, -0.03709602f, 0.03405939f, 0.01896925f, 
    0.06145697f, -0.11739562f, -0.10486349f, -0.05950791f, -0.07728522f, -0.09192883f, -0.05282533f, -0.07013197f, 
    0.20971383f, 0.09616017f, -0.02652568f, 0.00860251f, 0.01280725f, 0.06364265f, -0.05429632f, -0.00305328f, 
    0.01020518f, 0.21765664f, 0.15823053f, 0.03886145f, -0.38008440f, -0.45488393f, -0.63113451f, -0.24470562f, 
    0.09329707f, -0.14010784f, -0.11557082f, -0.07068193f, -0.07076237f, 0.07245461f, 0.06522940f, 0.03498156f, 
    -0.32800007f, 0.11156249f, -0.07852858f, -0.40685755f, -0.04664094f, -0.00994650f, -0.07095528f, 0.01631754f, 
    -0.12360322f, 0.04620097f, 0.09620281f, 0.00784941f, 0.18495394f, 0.11994535f, -0.00008078f, 0.05778141f, 
    0.10583816f, 0.08831325f, 0.01615876f, 0.08132572f, -0.01399005f, 0.12538715f, -0.02274001f, -0.01329928f, 
    -0.23706861f, -0.18659288f, 0.07795832f, -0.25799870f, 0.10794218f, -0.06135863f, -0.08735145f, 0.12206530f, 
    0.00227849f, -0.05057644f, 0.10360689f, -0.06259588f, -0.00242401f, -0.08717159f, 0.03308413f, 0.11395798f, 
    -0.02184436f, 0.01589854f, -0.13105170f, -0.03377704f, -0.09540158f, -0.07408099f, -0.08275143f, -0.12104468f, 
    0.05009386f, 0.08649003f, 0.00945682f, 0.05757196f, -0.07856172f, 0.06432001f, -0.00530299f, 0.06055307f, 
    -0.08593138f, 0.14947034f, -0.01373291f, 0.09587108f, -0.31407818f, 0.05132477f, 0.03997420f, 0.01752241f, 
    -0.01089703f, -0.03745765f, 0.02638951f, 0.07864945f, -0.11223752f, -0.14967979f, -0.09605519f, -0.10468412f, 
    -0.29903802f, -0.59056270f, -0.58917511f, -0.12670861f, 0.09410918f, 0.08162757f, 0.07830472f, 0.13822550f, 
    -0.07394057f, -0.05278231f, 0.01467512f, 0.09361812f, -0.13220511f, -0.27460468f, 0.10661540f, -0.04289403f, 
    -0.14482468f, -0.00943092f, -0.00462520f, -0.08981924f, 0.14039968f, 0.00947426f, 0.11043341f, -0.00568376f, 
    -0.11964276f, -0.51870018f, -0.65467352f, -0.36494821f, -0.07766074f, -0.11001670f, -0.03874814f, -0.01304297f, 
    -0.16756433f, -0.10235381f, 0.02990356f, 0.15720980f, 0.26779470f, 0.18600723f, 0.14711110f, 0.17018807f, 
    0.04068344f, -0.03910830f, -0.10526291f, -0.08926035f, 0.04680390f, 0.00619562f, -0.03762261f, 0.15166597f, 
    -0.17406677f, -0.29217464f, 0.00138593f, -0.01394806f, -0.00615096f, -0.09735681f, -0.05225507f, 0.03879926f, 
    -0.03810962f, -0.09964544f, 0.02224402f, -0.05370880f, -0.36985877f, -0.69626856f, -0.39889354f, -0.23897403f, 
    -0.17162520f, -0.25636354f, -0.03388313f, 0.15571019f, -0.15084614f, -0.04082216f, 0.07942440f, -0.00815501f, 
    0.33360025f, 0.29910788f, 0.05589304f, 0.28557923f, 0.05213475f, -0.11312749f, -0.01748336f, 0.01135964f, 
    -0.05828357f, -0.07224426f, -0.05202907f, 0.02364323f, 0.38133311f, 0.02844951f, 0.00135752f, -0.11010001f, 
    -0.01141142f, -0.05717313f, -0.07129233f, -0.02281276f, 0.34107020f, 0.10261792f, -0.05778867f, -0.03240674f, 
    -0.03312672f, -0.08517331f, -0.11682510f, -0.03786326f, -0.00018853f, 0.13438323f, 0.15778534f, 0.21859932f, 
    0.18372044f, 0.07345318f, 0.19895481f, 0.20454691f, 0.15969893f, 0.18636662f, 0.16589987f, 0.07573112f, 
    0.04046025f, -0.06558588f, -0.02147193f, -0.02027791f, 0.03971958f, 0.01346699f, -0.06287421f, 0.03290919f, 
    -0.67533469f, -0.46340492f, -0.33664918f, -0.44496104f, 0.03380287f, 0.08650532f, 0.03612969f, 0.12774374f, 
    -0.07601637f, -0.10317094f, 0.13124865f, -0.04158657f, -0.00082468f, 0.16205719f, 0.01645438f, -0.01922074f, 
    0.10608999f, 0.19498679f, 0.00656513f, 0.06740703f, 0.08779278f, 0.10692047f, 0.04229305f, -0.04243220f, 
    -0.20206709f, 0.14801516f, 0.07795343f, -0.01512174f, -0.12852924f, -0.02739367f, 0.00452593f, -0.02544753f, 
    -0.01539485f, 0.22737463f, 0.05584785f, 0.04329931f, -0.13848633f, -0.07739698f, -0.16002570f, -0.41975856f, 
    -0.02124093f, 0.05281493f, 0.09176699f, -0.01959328f, 0.17724799f, 0.10269698f, -0.02712283f, 0.00274873f, 
    -0.03042501f, -0.00566153f, 0.10030058f, 0.16123126f, -0.01373607f, 0.05030239f, 0.05988523f, 0.00104757f, 
    -0.01661002f, -0.01111550f, -0.17798951f, -0.02839760f, 0.39666790f, 0.20588718f, -0.08721104f, -0.06500811f, 
    -0.05828625f, 0.43002099f, 0.14490809f, 0.19338764f, 0.00157316f, 0.00305408f, -0.00335718f, 0.04262902f, 
    -0.40953842f, 0.00359346f, -0.00311925f, -0.07157709f, -0.21665074f, 0.00710642f, 0.06157883f, 0.00407560f, 
    -0.00931691f, -0.13471784f, -0.03313761f, 0.08821284f, -0.08374794f, -0.06712496f, 0.07691269f, 0.01968971f, 
    0.22019109f, 0.04009001f, 0.15560293f, 0.24174154f, 0.10955780f, 0.13332631f, -0.08732831f, 0.01291160f, 
    -0.07103446f, 0.11893375f, 0.10597602f, -0.16748714f, 0.19935453f, 0.12563048f, 0.10811093f, 0.33944571f, 
    0.20325275f, 0.16580111f, 0.03133443f, 0.02965822f, -0.02963215f, -0.02965094f, -0.10357375f, -0.07055417f, 
    0.03697371f, 0.01142168f, -0.05634205f, -0.05795373f, 0.12892252f, -0.06794986f, -0.02329518f, 0.12165969f, 
    0.12777978f, 0.15090062f, 0.14960817f, 0.12961850f, 0.07835674f, -0.00769900f, -0.03335364f, -0.07178636f, 
    -0.03475251f, -0.02740576f, -0.06691390f, 0.08126320f, 0.12675907f, 0.02587661f, -0.07572049f, 0.13488039f, 
    0.30360824f, 0.05717057f, 0.21914540f, 0.16659959f, 0.07907926f, 0.01025558f, -0.04450256f, -0.04849025f, 
    -0.09458392f, -0.03682290f, 0.00106829f, 0.13521504f, -0.02932059f, -0.02533288f, 0.08245071f, 0.01052679f, 
    -0.05991459f, 0.31603369f, 0.39999700f, 0.24078475f, -0.03227697f, 0.01983225f, 0.01919195f, -0.04058571f, 
    0.05469160f, -0.06108977f, 0.12053423f, 0.05900583f, -0.15712440f, -0.04908286f, -0.09944516f, -0.06556272f, 
    0.10624298f, -0.00430965f, 0.06775334f, 0.24458164f, -0.10577828f, -0.00420950f, 0.01868539f, 0.04084253f, 
    0.19148575f, -0.10571902f, 0.33640468f, 0.20045885f, -0.02318557f, -0.35025781f, -0.17444043f, -0.00249638f, 
    -0.25916383f, 0.02539365f, -0.02121569f, 0.23149927f, -0.00995936f, 0.02341109f, -0.05655546f, 0.01366493f, 
    -0.10591418f, -0.22856137f, -0.30089778f, 0.32219842f, -0.07714631f, 0.16960734f, -0.03185312f, -0.06617008f, 
    -0.03942823f, -0.05729489f, 0.01362780f, 0.00281381f, 0.06353552f, 0.00172469f, 0.00341028f, 0.02222521f, 
    0.02649767f, 0.14811699f, 0.21284311f, 0.10491356f, 0.06253172f, 0.09716225f, 0.08354719f, -0.01884340f, 
    -0.28648484f, -0.04379588f, 0.03768342f, 0.02870360f, 0.22045697f, 0.10050530f, -0.19221576f, 0.02063146f, 
    -0.07450706f, 0.02619393f, 0.03150965f, -0.06882837f, 0.00084582f, -0.00384664f, -0.03035748f, 0.01022301f, 
    0.01889529f, 0.02011701f, -0.03641659f, 0.02247970f, -0.14498399f, -0.15888411f, -0.14197285f, -0.11163004f, 
    0.08440332f, -0.00120147f, 0.14650975f, 0.19159326f, 0.05283913f, 0.08983861f, -0.04916257f, -0.01250341f, 
    0.26895192f, 0.21698762f, 0.09243013f, 0.06323265f, -0.05030338f, -0.05885193f, -0.14377113f, -0.39350227f, 
    -0.16856492f, -0.19156232f, -0.00463801f, -0.17219827f, 0.06369726f, 0.06397163f, -0.03027773f, -0.04506964f, 
    -0.33821312f, -0.17655587f, -0.18846016f, -0.21376587f, -0.16759558f, -0.28391531f, -0.04233412f, -0.01879898f, 
    -0.01267379f, -0.10152201f, -0.08844059f, 0.02059850f, 0.05669509f, 0.18203828f, 0.27275249f, 0.15061879f, 
    -0.00518923f, -0.03453866f, 0.01500920f, -0.07978040f, 0.19876586f, 0.06189594f, 0.07555690f, 0.28276959f, 
    -0.06875639f, -0.26732683f, -0.03303370f, 0.03512155f, 0.00937411f, 0.02182356f, -0.01346438f, -0.13612722f, 
    0.04921749f, 0.04163490f, 0.07371083f, -0.02802797f, -0.16175461f, -0.12674741f, -0.05247005f, 0.09801956f, 
    0.04130865f, 0.04251601f, 0.00253460f, 0.06330486f, -0.05297775f, 0.01821616f, -0.12170370f, -0.11002698f, 
    0.14303657f, 0.18928845f, 0.13205115f, 0.03323797f, 0.10735562f, -0.08357254f, -0.03589386f, -0.08013386f, 
    -0.01320146f, -0.07922968f, 0.03640649f, -0.06450253f, 0.10182086f, 0.20890765f, 0.10400638f, -0.27966452f, 
    -0.18705773f, -0.31780747f, -0.01773930f, 0.11574437f, 0.01613619f, 0.04711980f, -0.05536786f, 0.06462297f, 
    0.04278120f, 0.07900760f, 0.11128574f, -0.13773271f, -0.00505994f, 0.01013113f, 0.10181496f, 0.03792626f, 
    -0.05404202f, -0.12725137f, -0.03351967f, -0.11623711f, -0.08107887f, 0.31282708f, 0.40883470f, -0.05366739f, 
    0.00404904f, -0.07063591f, -0.09191942f, -0.02687243f, -0.10081486f, 0.01110143f, 0.10288957f, 0.16027872f, 
    0.06754845f, 0.06832809f, -0.11713800f, -0.21465267f, 0.14257467f, -0.00274479f, 0.19719096f, 0.02786048f, 
    0.10463800f, -0.00258661f, 0.19512592f, 0.31813121f, -0.01621058f, -0.08441105f, -0.22169042f, 0.01811793f, 
    -0.03857465f, 0.04448568f, 0.02978404f, 0.03698033f, -0.03219515f, 0.06402172f, -0.17520103f, -0.20916517f, 
    -0.14189516f, -0.01161041f, -0.11940023f, -0.21425313f, -0.20391101f, -0.24023402f, -0.01930081f, -0.14943120f, 
    0.03787694f, -0.00402255f, -0.03000350f, -0.05071849f, 0.06023033f, 0.05738541f, -0.04151482f, 0.03198255f, 
    0.09363787f, 0.10377213f, 0.14308488f, 0.08120485f, 0.13526866f, 0.00523016f, -0.00144302f, 0.08327423f, 
    0.31290174f, 0.18535884f, 0.39322042f, 0.22923049f, 0.05183488f, -0.05389990f, -0.01029630f, -0.16582294f, 
    -0.00229904f, -0.02310589f, 0.10197444f, 0.16305573f, -0.16692109f, -0.21035287f, 0.05389716f, -0.07939571f, 
    0.06766328f, -0.10306755f, -0.04863631f, 0.13680892f, -0.04421534f, 0.08451150f, 0.05189900f, 0.02261596f, 
    -0.04318972f, 0.02710609f, 0.07049445f, -0.07994406f, 0.05997192f, -0.08446905f, -0.08244519f, -0.00720520f, 
    0.04463095f, -0.06736432f, -0.04640454f, -0.03155449f, 0.14783283f, 0.12657967f, -0.12072615f, 0.04239373f, 
    -0.09080950f, 0.02742810f, -0.03095888f, -0.11879429f, 0.12269661f, 0.03880903f, 0.03221406f, 0.02473183f, 
    -0.15598917f, 0.07992370f, 0.11106475f, 0.07108386f, 0.01894172f, 0.10807046f, -0.10480352f, -0.19276555f, 
    0.17217967f, -0.02338992f, 0.02167507f, 0.13661230f, 0.04027993f, -0.14731655f, -0.08452301f, 0.01402628f, 
    -0.02343312f, 0.12969619f, -0.12339789f, 0.05629280f, 0.04093779f, -0.01816528f, -0.06737237f, -0.04670186f, 
    -0.16321507f, -0.09469186f, 0.31305403f, -0.26026985f, -0.10878702f, -0.13430436f, -0.10001994f, 0.04043593f, 
    0.01299953f, 0.08394625f, 0.03048014f, 0.08343687f, 0.05369166f, -0.05238901f, 0.18004221f, 0.29756361f, 
    0.01277443f, 0.02354107f, -0.04108062f, -0.07873429f, 0.06261996f, -0.05350748f, 0.11668915f, 0.26246148f, 
    0.13438945f, 0.00385712f, -0.09107324f, -0.03804204f, -0.04373040f, 0.10680881f, 0.03859112f, 0.10334597f, 
    -0.02328045f, 0.05624297f, -0.03899796f, -0.10651793f, -0.00793713f, 0.03273015f, 0.24085769f, -0.16191924f, 
    -0.02635609f, -0.05596865f, 0.18214616f, 0.18400815f, -0.02638833f, 0.01523638f, -0.04430581f, -0.09605654f, 
    -0.21708798f, -0.01197503f, -0.14528741f, 0.05556944f, 0.00399088f, -0.04042410f, -0.01126551f, -0.01093753f, 
    -0.33764678f, -0.09441833f, -0.02364779f, -0.08400033f, 0.09368727f, 0.12886912f, -0.00325902f, 0.11200608f, 
    0.06493409f, 0.07313543f, 0.19228314f, -0.03869363f, -0.02082309f, -0.00982155f, 0.01981805f, -0.06146652f, 
    -0.27562675f, -0.06334617f, -0.12159003f, -0.15088709f, -0.05636121f, -0.10066999f, -0.08163864f, -0.07619179f, 
    -0.04303143f, -0.00508559f, 0.22945905f, 0.00733267f, 0.11112075f, 0.17920871f, 0.18959112f, 0.29807854f, 
    0.02165790f, 0.00370021f, 0.05142543f, 0.13010237f, 0.06710420f, -0.02737714f, -0.05307853f, 0.02766269f, 
    -0.26405567f, 0.21814942f, 0.10294197f, 0.04234726f, -0.08061134f, -0.08305280f, -0.06785963f, 0.02534595f, 
    0.00828965f, -0.04722802f, -0.08577580f, -0.19520447f, -0.09367631f, -0.20616323f, -0.09619300f, -0.12310217f, 
    0.02054848f, -0.04154804f, -0.03851587f, -0.00188525f, -0.07560281f, 0.10628421f, -0.11975631f, 0.06324011f, 
    -0.35707369f, 0.33265296f, -0.03705042f, 0.01270906f, 0.13520430f, -0.09458327f, 0.01461806f, -0.01690295f, 
    0.04697387f, -0.00451494f, -0.06100217f, -0.02028898f, 0.16174135f, 0.12837110f, 0.08565633f, 0.07340145f, 
    0.19668934f, 0.06291550f, -0.01223736f, 0.06094901f, -0.00130017f, 0.08565094f, -0.01136689f, 0.00300908f, 
    -0.13553175f, -0.03882995f, -0.01326911f, 0.04887829f, 0.04591952f, 0.00813340f, 0.00472007f, -0.00895635f, 
    0.02501906f, -0.01222612f, -0.00615972f, 0.09253103f, 0.05499423f, 0.20280848f, 0.12846608f, 0.18949993f, 
    -0.00508585f, 0.06855846f, 0.05161292f, -0.05173064f, -0.01584516f, -0.01879342f, -0.05564911f, 0.04946131f, 
    0.21517475f, 0.19506681f, 0.35706055f, 0.21496263f, 0.09376989f, 0.11251985f, -0.02655161f, 0.20401949f, 
    -0.13873279f, -0.03703814f, -0.08542933f, -0.09023784f, 0.13765672f, 0.01279652f, -0.14822708f, 0.00742380f, 
    -0.04040807f, -0.02929553f, -0.02469098f, -0.01350601f, 0.01533709f, -0.08255479f, 0.16265993f, 0.22820488f, 
    0.32422221f, 0.11036815f, 0.42124486f, 0.23476906f, 0.19059291f, -0.01946282f, -0.06016865f, 0.02334856f, 
    -0.05492375f, -0.01411927f, -0.04712219f, -0.00058383f, -0.13397634f, -0.32254505f, -0.24372140f, -0.14094464f, 
    -0.09306520f, -0.06346745f, -0.06999357f, 0.00865009f, -0.08107419f, 0.12466832f, -0.04673635f, 0.07384498f, 
    0.20894833f, 0.14009242f, 0.29913649f, 0.33740538f, -0.01799162f, -0.00726893f, 0.11698148f, 0.04847930f, 
    0.09484331f, -0.03962930f, 0.06635768f, -0.06191776f, 0.47260022f, 0.36297542f, 0.17520222f, -0.15892887f, 
    0.12261850f, 0.09443992f, 0.24665302f, -0.02953199f, 0.01480173f, -0.06579168f, -0.01951867f, -0.03376683f, 
    -0.06570930f, -0.04672211f, 0.00240606f, -0.13041797f, -0.04858731f, -0.10440796f, -0.02450363f, -0.08311024f, 
    -0.08916174f, -0.08209479f, -0.00087971f, -0.02592133f, 0.33460909f, 0.00249585f, 0.04273112f, -0.17801066f, 
    -0.10793016f, 0.11281726f, 0.05120351f, -0.21669890f, -0.02101352f, 0.02474121f, 0.08675159f, 0.00880568f, 
    0.00959452f, -0.00315035f, -0.05073278f, -0.15604156f, -0.11019526f, -0.17106076f, -0.13894585f, -0.03760326f, 
    -0.00583662f, 0.06283822f, 0.15221334f, 0.04519977f, -0.05743458f, -0.12349115f, -0.08235291f, 0.11607722f, 
    -0.09546576f, 0.00483941f, 0.01231797f, -0.12394391f, -0.05674534f, 0.03360615f, -0.06266122f, 0.11793542f, 
    0.36276671f, 0.26306608f, 0.37892073f, 0.23775145f, 0.04370490f, 0.06302880f, -0.12366333f, -0.03203159f, 
    0.03117719f, 0.04489205f, -0.00150432f, 0.05198447f, -0.06597292f, -0.05914399f, 0.06738369f, -0.05628352f, 
    0.06473941f, -0.01344255f, -0.06491898f, -0.03314482f, 0.06892109f, 0.12911083f, 0.02702384f, -0.01411884f, 
    -0.17309041f, -0.03598309f, -0.09859646f, 0.15274590f, 0.05062699f, 0.02049417f, -0.04199367f, -0.12335555f, 
    0.06994080f, 0.18883784f, 0.09595431f, -0.05359401f, -0.05576706f, 0.19683377f, 0.16392812f, -0.00465471f, 
    -0.04858842f, 0.13041109f, -0.15816174f, -0.07206469f, 0.08647077f, -0.02528919f, -0.07274674f, -0.02806413f, 
    0.11258844f, 0.15438883f, -0.00255490f, 0.22485010f, 0.08107261f, 0.05300486f, 0.07522606f, 0.06401111f, 
    -0.13128772f, -0.03953949f, 0.09810326f, 0.06817785f, -0.03598921f, 0.21267354f, 0.27274433f, -0.11291502f, 
    -0.05861715f, 0.02110257f, -0.10814279f, 0.15134966f, 0.01238307f, -0.02857415f, -0.06758306f, 0.14211883f, 
    0.04761138f, 0.11374298f, 0.14686489f, 0.20923586f, 0.18798363f, 0.04502339f, -0.20419058f, -0.03208158f, 
    -0.10236052f, 0.08397882f, -0.02518805f, 0.03986431f, 0.16618414f, 0.08191446f, 0.04748700f, -0.08762997f, 
    -0.16536802f, -0.01325895f, -0.04580844f, 0.01851785f, 0.00648347f, -0.00392559f, -0.00900479f, -0.06621075f, 
    0.20346867f, 0.09942030f, 0.05470117f, 0.16835521f, 0.08783678f, 0.00645742f, 0.16737911f, 0.16618930f, 
    0.07125298f, 0.07815436f, -0.02105145f, 0.09009545f, -0.13726327f, 0.04387401f, 0.16981277f, 0.20032781f, 
    0.11588328f, 0.02104059f, 0.05904232f, 0.00721850f, 0.07411953f, -0.02282093f, 0.14942151f, -0.02959323f, 
    -0.10493978f, -0.18485039f, -0.15814626f, -0.05097775f, -0.15834589f, -0.07899807f, -0.09570955f, -0.01807935f, 
    0.05636470f, 0.06720448f, 0.02925910f, 0.03384607f, 0.23916429f, -0.04161590f, -0.15698312f, -0.12429571f, 
    -0.09561856f, -0.04707468f, 0.17559546f, -0.00847011f, -0.06923267f, -0.05243165f, -0.17546704f, 0.00308263f, 
    0.22898738f, -0.11348841f, 0.00462470f, -0.05726817f, -0.04232877f, -0.00300618f, -0.02350146f, 0.04466206f, 
    -0.04710432f, -0.00775663f, 0.01531505f, -0.00001378f, 0.14433527f, 0.01549522f, 0.03683241f, 0.04031109f, 
    -0.12980260f, -0.08253365f, 0.15826632f, 0.00417253f, 0.05287305f, -0.03062571f, -0.02037194f, -0.03890350f, 
    0.13326544f, 0.07250834f, -0.01236119f, -0.16262494f, -0.00869353f, 0.02204889f, 0.03723342f, -0.00254636f, 
    0.15025614f, 0.02641140f, 0.24159977f, -0.03701547f, 0.07870995f, -0.12966654f, 0.03263131f, -0.03810671f, 
    -0.02418481f, -0.06072618f, 0.04014118f, 0.14516231f, 0.02312789f, -0.03913481f, -0.03732080f, -0.02999651f, 
    -0.16204189f, -0.20311758f, -0.16988364f, 0.12141872f, -0.05575532f, 0.10916659f, -0.10328624f, 0.01847391f, 
    -0.03443810f, -0.00279656f, 0.02814302f, -0.05146577f, 0.13488476f, -0.00934833f, 0.19925101f, -0.00193779f, 
    0.00705381f, -0.15949820f, 0.13289380f, 0.04079055f, 0.02890251f, 0.12682398f, -0.11567863f, 0.07420138f, 
    -0.05769701f, -0.26157585f, -0.19944684f, -0.05213077f, 0.02794635f, 0.07029785f, 0.07206997f, -0.06236143f, 
    0.13065067f, 0.15993610f, 0.00439835f, -0.08472295f, 0.09282488f, -0.00867658f, 0.01670980f, 0.10113768f, 
    -0.03533652f, 0.03911559f, 0.07003071f, 0.11635417f, -0.09050847f, -0.01767489f, 0.00890048f, 0.02974066f, 
    0.14812933f, -0.08331590f, 0.02812507f, 0.12653142f, 0.05176267f, 0.02434905f, -0.03287563f, -0.09042150f, 
    0.02819713f, 0.01844031f, -0.11411849f, 0.03063617f, -0.19107817f, 0.02381388f, -0.05769539f, 0.07866187f, 
    -0.12262133f, -0.03762683f, -0.05459812f, -0.06740596f, -0.00019735f, -0.07534669f, -0.05331827f, 0.03261379f, 
    -0.10097784f, 0.00105378f, 0.19470124f, 0.11900985f, 0.06630521f, 0.06468308f, -0.06219921f, 0.07819305f, 
    -0.04578950f, 0.04060232f, -0.05252124f, 0.06490285f, 0.06646146f, 0.14120656f, 0.11592241f, -0.06695463f, 
    -0.01186298f, -0.06355387f, -0.06004793f, -0.02169676f, 0.03459194f, -0.05099323f, -0.16500388f, 0.10695969f, 
    -0.07435007f, -0.10763551f, 0.02033074f, 0.00698656f, 0.13173769f, 0.02785005f, -0.09826804f, -0.11808801f, 
    0.02241817f, 0.03674959f, -0.04842233f, -0.09550469f, 0.33462933f, 0.06044228f, 0.20898275f, -0.01381544f, 
    0.02098665f, 0.04622058f, 0.04840666f, -0.02429364f, 0.05070546f, 0.08433692f, -0.08627331f, -0.02005375f, 
    -0.02004186f, -0.01646861f, 0.16369250f, 0.02120617f, -0.14276582f, -0.07001257f, 0.06148985f, 0.03630191f, 
    -0.08231280f, -0.11578103f, 0.15818842f, -0.04948375f, 0.27385157f, 0.31944022f, 0.00630248f, -0.04705336f, 
    -0.14055783f, -0.13265014f, -0.00112428f, 0.04715640f, -0.08635018f, 0.07069581f, -0.15162361f, -0.05639182f, 
    0.17603651f, 0.10051528f, 0.15397464f, -0.11953300f, 0.01319761f, -0.01517152f, 0.07233395f, -0.00242902f, 
    0.01923431f, 0.03843619f, 0.00567073f, -0.03632251f, 0.73380220f, 0.12368126f, 0.16486236f, -0.21562605f, 
    -0.08207019f, 0.06119401f, 0.03692046f, -0.07121761f, -0.08372086f, 0.15533061f, -0.12662682f, -0.03753838f, 
    0.03090105f, 0.22757307f, -0.12759897f, -0.05669523f, -0.00039518f, -0.07144520f, -0.12765911f, -0.04834642f, 
    0.11687105f, 0.02513652f, -0.00568780f, 0.13266566f, 0.15113050f, -0.02403463f, 0.06015997f, 0.10050388f, 
    -0.00883083f, 0.08200832f, 0.06070061f, 0.01630704f, -0.05730907f, 0.01240418f, -0.13876349f, 0.02838511f, 
    0.01901451f, -0.02535131f, 0.08253479f, -0.01571823f, 0.07467426f, 0.08053206f, -0.17038722f, 0.00472041f, 
    0.04697727f, 0.02013804f, -0.02165519f, 0.01796291f, 0.00804504f, 0.05730588f, 0.03766114f, -0.03167257f, 
    0.08287651f, 0.11241559f, -0.09363224f, -0.01493924f, 0.08313732f, 0.02008915f, -0.01504538f, 0.09655689f, 
    0.07448794f, -0.04205788f, -0.16482280f, 0.04113090f, -0.03565999f, 0.05413819f, -0.06648240f, -0.09380224f, 
    -0.04435917f, 0.01334630f, 0.10351311f, 0.07350742f, 0.05848764f, -0.04817343f, 0.00522752f, -0.08530112f, 
    -0.00385915f, 0.22711456f, -0.05239784f, -0.17470978f, 0.06216478f, 0.03228706f, 0.01467231f, 0.04348464f, 
    0.15902062f, -0.06127235f, -0.07931354f, 0.17300281f, -0.06487260f, -0.21450318f, 0.15982671f, 0.04768329f, 
    -0.08870737f, -0.06367008f, -0.10475361f, 0.08912066f, -0.27261001f, -0.08627079f, 0.08949108f, -0.04456051f, 
    0.00092523f, -0.02717488f, -0.23170665f, 0.07207679f, 0.09999636f, -0.05735921f, 0.00685325f, 0.04538963f, 
    -0.18366651f, 0.00050226f, 0.00622816f, 0.07584272f, 0.01432460f, -0.11313031f, -0.22246671f, -0.09991697f, 
    -0.04237207f, 0.06412138f, -0.02020019f, -0.00658437f, -0.06751822f, -0.08742386f, -0.03792880f, -0.09269013f, 
    0.03242390f, -0.04179971f, -0.04022914f, -0.05661202f, -0.10352843f, -0.00629025f, 0.01577723f, 0.03907914f, 
    0.07381119f, -0.01213123f, 0.13989826f, 0.01887492f, 0.01048221f, -0.04261840f, 0.06832677f, 0.08749659f, 
    0.18332079f, 0.10239013f, 0.07787843f, 0.09108967f, 0.42585793f, -0.21484315f, 0.16780610f, 0.12803617f, 
    -0.13232960f, -0.06383112f, 0.09766179f, 0.04378237f, 0.09853274f, -0.12879537f, 0.16650115f, -0.03262344f, 
    0.12322950f, 0.00639831f, 0.15443866f, 0.07813525f, 0.00101790f, -0.02677087f, 0.06165056f, -0.01575289f, 
    0.06958997f, 0.03418961f, 0.00097322f, 0.01855801f, 0.20896593f, -0.03166391f, 0.12648255f, -0.20693110f, 
    0.03800074f, -0.11065559f, 0.17505527f, 0.03157201f, 0.11454263f, 0.05365277f, -0.15644017f, 0.03240308f, 
    -0.02849762f, -0.04155222f, 0.09728986f, 0.18192904f, 0.01102950f, -0.02066718f, 0.00919316f, -0.02594290f, 
    0.00679240f, -0.09273260f, 0.02137657f, -0.02102853f, -0.21787383f, 0.01982180f, -0.10312016f, -0.06628720f, 
    0.01984198f, 0.16913331f, -0.03521613f, 0.08924446f, -0.04089410f, -0.02485036f, -0.06653778f, -0.05580770f, 
    -0.01632925f, 0.07913516f, 0.02197975f, 0.34207007f, -0.05614272f, -0.01621229f, 0.09656532f, 0.08323371f, 
    -0.09249195f, 0.08112940f, -0.13584420f, 0.12368027f, -0.18103813f, -0.05069221f, 0.10015245f, 0.10202397f, 
    0.00954742f, 0.02833117f, 0.02525889f, -0.04407552f, -0.07068304f, 0.03647868f, -0.00548707f, 0.05565472f, 
    -0.22946146f, 0.08714951f, 0.20770128f, 0.27078292f, 0.08380383f, -0.04536701f, 0.06075786f, -0.02196537f, 
    0.01898652f, 0.03932478f, -0.04935043f, 0.05795118f, 0.09787055f, -0.00232326f, 0.00294969f, 0.20651090f, 
    -0.01479419f, 0.07915565f, -0.09664208f, -0.06967000f, 0.10189846f, -0.02978029f, 0.22954653f, 0.10660941f, 
    -0.02274937f, -0.08685719f, 0.38641110f, 0.21477085f, 0.01857780f, 0.18059848f, 0.02088896f, 0.02191804f, 
    -0.01364428f, -0.06573760f, -0.00110795f, 0.02520935f, -0.12595369f, 0.11287826f, -0.08804730f, -0.12924144f, 
    0.10320143f, -0.13845804f, 0.13837694f, -0.15415777f, 0.03126905f, 0.03874834f, -0.07538638f, -0.01481506f, 
    -0.26458105f, 0.16301157f, -0.15596554f, -0.13436756f, 0.08236843f, 0.02749908f, -0.08957189f, -0.07370531f, 
    -0.09755652f, -0.05455517f, 0.12599859f, 0.04918278f, 0.05877968f, -0.08649684f, 0.02194573f, -0.06001244f, 
    0.21368581f, 0.02884763f, 0.02379541f, 0.11719975f, -0.05430621f, 0.01396347f, -0.02611419f, -0.06376142f, 
    0.01564030f, 0.04704133f, -0.02868109f, 0.00415014f, -0.01820353f, 0.05229289f, 0.01701232f, 0.02416145f, 
    0.04352100f, 0.08113209f, -0.10957389f, -0.06457344f, 0.06692246f, 0.04085042f, -0.21159235f, -0.18484280f, 
    -0.00154423f, -0.08279811f, 0.01994266f, -0.02747509f, -0.05505431f, 0.03452450f, 0.16749249f, -0.03213279f, 
    -0.19399506f, 0.11231469f, -0.00199623f, 0.19378677f, -0.05059337f, -0.04239560f, 0.11160081f, 0.08453578f, 
    -0.08202239f, -0.01872343f, 0.05467918f, -0.04136843f, -0.18921849f, 0.17059483f, -0.33589357f, 0.20782651f, 
    -0.03916476f, 0.01993259f, -0.02249941f, 0.02280281f, -0.01944634f, -0.14080243f, 0.01288307f, -0.17045227f, 
    0.11051303f, 0.08926827f, 0.03570529f, -0.04935251f, 0.07344439f, -0.08568975f, 0.02114222f, 0.00085957f, 
    0.01464171f, 0.08825714f, -0.09083363f, -0.04524871f, -0.44993746f, 0.11286493f, 0.11682323f, -0.12502873f, 
    0.06761224f, -0.02887545f, -0.12734078f, -0.13707587f, 0.05736046f, -0.01489218f, -0.05000158f, -0.08231562f, 
    0.13747625f, 0.19663326f, 0.15629685f, 0.06509211f, -0.04021171f, -0.00909355f, 0.03990702f, 0.14432499f, 
    -0.12593743f, -0.03003008f, 0.09138408f, -0.05839479f, -0.67043126f, 0.02135481f, -0.19750693f, 0.25591862f, 
    -0.12066440f, -0.00201059f, -0.03651899f, 0.17007037f, -0.05703409f, -0.06231985f, 0.03544525f, -0.08126137f, 
    0.04179934f, -0.01551878f, 0.03001001f, 0.12482175f, -0.03312439f, -0.06649870f, 0.03663398f, 0.15283640f, 
    0.05652468f, 0.02366189f, 0.02178985f, -0.16769648f, 0.01026509f, -0.04745830f, -0.17441574f, 0.03127293f, 
    0.02518206f, -0.06352005f, -0.15796642f, -0.05444534f, -0.02563885f, -0.07955975f, 0.03913276f, 0.02546302f, 
    -0.01998898f, 0.10848655f, 0.00812372f, 0.09487092f, -0.04739773f, -0.05163425f, 0.03543728f, 0.06568261f, 
    0.03594100f, -0.05173441f, -0.06685425f, 0.01536877f, 0.12850834f, -0.18849175f, 0.08608600f, 0.22067922f, 
    0.02430852f, -0.05089793f, 0.09387156f, 0.02880163f, -0.03943075f, 0.13390106f, 0.00002051f, -0.01165531f, 
    0.02476172f, 0.05082839f, 0.05245522f, -0.20563148f, -0.10910247f, -0.03756487f, -0.02613703f, 0.00949573f, 
    0.02533463f, 0.08681237f, 0.14811514f, -0.20725439f, -0.06808268f, 0.12272249f, -0.00744847f, 0.38110414f, 
    0.11823673f, 0.02789503f, 0.05091335f, 0.08484460f, -0.00154438f, 0.03133205f, 0.07318268f, -0.03164177f, 
    0.03949790f, -0.06052644f, 0.16463244f, -0.12628505f, -0.07259858f, 0.22661020f, -0.01594839f, 0.08313277f, 
    0.17044996f, -0.05615871f, 0.25329378f, 0.03919584f, -0.07179120f, 0.11978347f, 0.22314975f, 0.18920349f, 
    0.16473989f, -0.02254060f, 0.08154960f, -0.02026297f, -0.16550146f, 0.03519896f, -0.05459366f, 0.00252644f, 
    0.27281535f, 0.01310344f, -0.05053679f, -0.14891300f, 0.01827706f, 0.08082338f, 0.22179046f, 0.13565223f, 
    -0.04956887f, 0.09307698f, -0.05110722f, -0.16609220f, -0.09609938f, 0.24045970f, -0.04736685f, -0.02032190f, 
    -0.12234838f, 0.03437478f, 0.10626181f, 0.06421383f, 0.02998381f, 0.09627554f, 0.12071263f, -0.00950408f, 
    -0.12205260f, -0.08107229f, -0.12148668f, 0.09871934f, -0.16190252f, 0.00335191f, -0.10010690f, -0.11191194f, 
    -0.03180680f, 0.04559999f, -0.04378525f, -0.05720345f, -0.25483081f, 0.14564213f, -0.08635565f, -0.15584411f, 
    0.11170825f, -0.08522727f, -0.03661702f, -0.09868217f, -0.00628000f, 0.16256930f, -0.10482401f, 0.04598689f, 
    0.17492469f, 0.09486949f, -0.06696213f, 0.01023663f, -0.10785075f, 0.02305678f, -0.15652004f, 0.02930850f, 
    -0.00705925f, -0.03253100f, -0.01990216f, -0.09813359f, -0.11988149f, 0.12943260f, 0.03355607f, 0.11167991f, 
    -0.03016031f, 0.09797954f, -0.03440366f, 0.12064428f, -0.08033459f, -0.00887162f, 0.05489644f, -0.04519069f, 
    0.20809352f, 0.00478184f, 0.09790264f, 0.04165952f, 0.02902888f, 0.01645189f, 0.02232534f, 0.01460992f, 
    0.04410881f, 0.01118703f, 0.02273179f, -0.07712966f, 0.11130359f, -0.06495123f, -0.01036465f, -0.06992480f, 
    -0.09938914f, 0.09529915f, 0.07152998f, -0.07539514f, 0.02865162f, -0.00443284f, -0.03999457f, 0.13304141f, 
    0.20829177f, -0.14542143f, 0.11840364f, -0.20699178f, 0.01016481f, 0.01715256f, -0.08108945f, -0.03446563f, 
    0.01766958f, -0.12964365f, -0.07254060f, 0.03914297f, 0.25202593f, 0.21069863f, 0.12080938f, -0.25795895f, 
    0.07074562f, 0.01424706f, 0.13957298f, 0.12391253f, 0.05429933f, -0.09455108f, -0.01725516f, -0.08212365f, 
    0.45595890f, -0.10828386f, 0.48259532f, -0.08414209f, 0.02645143f, 0.05325377f, 0.04306475f, -0.06022548f, 
    0.06444176f, 0.04039903f, -0.01503394f, 0.02372889f, -0.16754347f, -0.03107770f, -0.09644186f, -0.11810903f, 
    -0.02855751f, 0.11594249f, 0.06889240f, 0.10302625f, -0.11137681f, 0.00510257f, -0.08053932f, 0.10103839f, 
    0.50111282f, 0.07439384f, -0.29226309f, -0.07047037f, 0.00448955f, -0.11883669f, 0.26364943f, 0.01506252f, 
    0.03667641f, 0.05879354f, -0.06421863f, -0.10039756f, -0.01794483f, -0.07826034f, 0.04107442f, -0.01577693f, 
    -0.05211974f, 0.17705736f, -0.21709886f, 0.00939261f, 0.09552108f, 0.10630678f, 0.03486841f, 0.07783926f, 
    0.35798633f, -0.13800690f, 0.04142969f, -0.01026847f, -0.04674274f, 0.04276229f, 0.04289462f, -0.11377767f, 
    0.08709460f, -0.06286241f, 0.02560746f, 0.07755031f, 0.10920031f, 0.25957558f, 0.03523002f, -0.16665509f, 
    0.08486879f, 0.12386263f, 0.08110055f, 0.23095532f, -0.05974633f, -0.07068262f, 0.04400274f, 0.04266106f, 
    -0.01480335f, 0.26828802f, -0.16292191f, -0.20454292f, 0.01754046f, 0.04901346f, 0.05230721f, 0.07931767f, 
    -0.08363678f, 0.03476356f, -0.01747998f, -0.09667890f, -0.09304591f, -0.09448644f, -0.12691462f, 0.05441998f, 
    -0.03298902f, -0.01963175f, -0.07986403f, 0.09280299f, 0.02084449f, 0.06297565f, 0.03171502f, 0.03537644f, 
    0.05559048f, 0.14670718f, 0.21436477f, -0.05605986f, 0.09237679f, -0.08002768f, 0.08265530f, 0.03823078f, 
    -0.04817054f, -0.06320980f, -0.07157445f, 0.00563734f, 0.08666825f, -0.05367446f, 0.20954822f, -0.19106829f, 
    -0.06339908f, -0.00647295f, -0.03409155f, -0.00721001f, 0.03816712f, -0.05771216f, 0.15813465f, 0.03989070f, 
    -0.15206887f, -0.22889423f, -0.10857508f, -0.02625477f, -0.01448648f, 0.11607501f, -0.04214336f, 0.04116165f, 
    -0.02160319f, -0.03437331f, 0.00247259f, 0.03668597f, 0.06887490f, -0.13125148f, -0.20227872f, -0.21865851f, 
    -0.05651164f, 0.11958869f, 0.07517322f, 0.10311242f, 0.02232733f, -0.06988538f, 0.03081510f, 0.08522993f, 
    -0.09719426f, -0.09864654f, 0.14738375f, 0.02545952f, 0.11865401f, 0.01974189f, -0.10829640f, -0.07269170f, 
    0.11535884f, -0.01109385f, 0.03334840f, 0.06401581f, 0.09404067f, -0.28277859f, 0.07872081f, -0.17123340f, 
    -0.07857728f, 0.09370472f, -0.01311642f, -0.15880904f, 0.15506916f, 0.11054274f, -0.01532543f, 0.08760459f, 
    -0.23482959f, -0.08036772f, -0.03813044f, -0.06594666f, 0.10831628f, 0.11169409f, -0.04797032f, -0.01916034f, 
    -0.08443952f, 0.14424455f, 0.03160966f, -0.00519899f, 0.02899564f, -0.06210986f, 0.08361379f, -0.06008396f, 
    -0.00128282f, -0.00401182f, 0.00368769f, -0.08201025f, 0.10341839f, -0.14176567f, 0.18077148f, 0.09603181f, 
    -0.00714103f, 0.04681484f, 0.06022371f, -0.24650860f, 0.06162084f, 0.18897453f, -0.01590476f, 0.10022908f, 
    0.00907475f, -0.02347962f, 0.01443502f, 0.01727858f, -0.11872528f, 0.11269358f, 0.01129785f, -0.01528275f, 
    0.06300832f, 0.08418412f, -0.11181472f, 0.08140331f, -0.19927737f, -0.01544844f, 0.06123889f, 0.20642073f, 
    0.32299080f, -0.15736915f, -0.12280324f, 0.10618345f, 0.01675492f, -0.06039439f, -0.00129313f, -0.01862220f, 
    -0.01416729f, -0.10111096f, -0.06412524f, 0.03201346f, 0.37137470f, -0.13994828f, 0.10568884f, -0.10635197f, 
    0.12425123f, -0.07580101f, 0.14506656f, 0.03764215f, 0.03644158f, 0.01364559f, -0.11497279f, 0.05295072f, 
    0.02490463f, 0.08137698f, -0.26093730f, 0.12211161f, 0.07026901f, -0.03583226f, 0.14061703f, -0.20844324f, 
    -0.05753232f, 0.10446252f, -0.15495758f, 0.06615355f, -0.24019866f, 0.09048007f, -0.07886222f, -0.14319241f, 
    0.00674923f, 0.03109483f, -0.19289581f, 0.17473866f, 0.00031180f, -0.03521678f, 0.07001136f, 0.00056489f, 
    -0.26657647f, 0.21726322f, -0.10671557f, 0.14553156f, -0.11715301f, -0.06507085f, 0.05601718f, 0.05805603f, 
    -0.03014877f, 0.05790737f, 0.02884888f, -0.01635475f, 0.19213131f, -0.07604047f, 0.10955846f, -0.31952718f, 
    -0.01093097f, 0.04466446f, 0.00223449f, 0.04381467f, 0.08008989f, 0.05615033f, -0.03064370f, -0.04083030f, 
    0.27798560f, 0.15709560f, -0.22416191f, -0.19859345f, 0.06840263f, 0.10994434f, 0.17053089f, 0.18008721f, 
    0.00810116f, -0.04560778f, -0.04242821f, -0.04411112f, 0.59166479f, -0.21312228f, -0.09156664f, 0.01774418f, 
    -0.02917160f, -0.00735850f, -0.04878848f, 0.06825054f, 0.24129833f, -0.06066671f, 0.05983394f, 0.01027189f, 
    -0.17820963f, -0.03799993f, 0.01314659f, -0.11326122f, -0.04936444f, -0.03543800f, -0.03737333f, -0.02748168f, 
    -0.04090841f, -0.07027287f, 0.00601396f, 0.00054415f, -0.03711827f, 0.08064275f, -0.19208692f, 0.13321663f, 
    0.16486035f, 0.13324982f, -0.03248351f, 0.10042760f, 0.04419998f, -0.06974337f, 0.08616549f, 0.03565056f, 
    0.02703859f, 0.06074456f, -0.04004640f, -0.22391030f, 0.02234593f, -0.04732322f, -0.03977519f, 0.05299099f, 
    -0.01040125f, 0.09374903f, -0.27264568f, -0.09505245f, -0.03802752f, -0.01794874f, -0.07202254f, 0.12192681f, 
    0.05326970f, 0.05325196f, 0.04780675f, -0.07729761f, 0.03131852f, -0.00568363f, 0.00691290f, -0.05978862f, 
    -0.13927601f, 0.16522923f, -0.03647517f, -0.00269689f, 0.02863007f, -0.07354137f, 0.06732633f, 0.01414151f, 
    -0.06071949f, 0.12127572f, 0.21590389f, -0.11942556f, 0.31344798f, -0.00132260f, -0.22399673f, 0.22885478f, 
    0.06279965f, 0.03702101f, 0.10875137f, -0.23064195f, 0.04172784f, -0.00417744f, -0.08102731f, 0.01862848f, 
    0.10926820f, 0.32514709f, -0.32905528f, -0.47415367f, 0.02482922f, 0.05263249f, 0.04801240f, 0.11230004f, 
    0.11691914f, -0.03384760f, 0.07128815f, 0.01502410f, 0.01593624f, -0.07597774f, 0.15815999f, 0.19302021f, 
    -0.01116749f, -0.01191387f, -0.15524231f, -0.08420782f, -0.19231583f, 0.19159837f, -0.01497339f, -0.03624744f, 
    0.25644499f, -0.14620493f, 0.05929871f, -0.20520675f, 0.03012935f, -0.02774222f, 0.13832739f, -0.15144981f, 
    0.17655534f, 0.01202845f, 0.08455094f, 0.08753611f, -0.05223535f, -0.01101589f, -0.02854190f, 0.02937613f, 
    0.12364446f, 0.10280471f, 0.21152180f, 0.03384036f, 0.02606653f, 0.00460368f, 0.09202121f, 0.02561434f, 
    -0.04630435f, 0.09615435f, -0.28329363f, -0.14856449f, 0.05128939f, 0.08800476f, 0.00618513f, -0.04909725f, 
    0.03396330f, 0.03095917f, 0.08866844f, 0.02381631f, 0.23922729f, 0.08922447f, -0.06640046f, 0.02206093f, 
    -0.10932135f, 0.05982723f, -0.04660419f, -0.09138972f, -0.07669810f, -0.06514164f, -0.10369013f, -0.11261387f, 
    0.11391571f, -0.14601798f, -0.01339913f, 0.22194523f, 0.02845791f, 0.10231166f, -0.04087973f, 0.04184573f, 
    0.03208326f, 0.00841800f, 0.03117509f, -0.00026454f, -0.01187347f, -0.13734202f, -0.04766289f, -0.07336392f, 
    -0.04658803f, 0.02610638f, -0.00921617f, 0.05909281f, -0.13062079f, 0.04975453f, -0.14770590f, -0.11964791f, 
    0.30642873f, 0.05668443f, 0.02784874f, -0.11534591f, -0.01843752f, 0.19123381f, -0.08501280f, -0.10599909f, 
    -0.02185899f, 0.06116234f, -0.03398101f, -0.01057602f, 0.13404931f, 0.13432856f, -0.07183006f, 0.10827175f, 
    -0.12078269f, 0.01885496f, -0.00992555f, -0.11089108f, 0.00430074f, 0.04376869f, 0.02791566f, 0.14138600f, 
    -0.25555265f, -0.11319642f, 0.23325887f, 0.02780402f, -0.03577155f, 0.14969675f, 0.09734058f, 0.19252546f, 
    -0.15585177f, 0.01414575f, -0.02848925f, 0.00146866f, 0.31057626f, 0.07821805f, -0.07735246f, 0.29552996f, 
    0.11428019f, 0.14441144f, 0.10285665f, 0.05416429f, -0.06519037f, 0.02016052f, -0.01101092f, 0.05949844f, 
    0.11269584f, 0.17217331f, 0.07565317f, 0.12943593f, 0.08293113f, -0.07951365f, -0.01658702f, 0.00405685f, 
    -0.01569072f, 0.13710457f, -0.00243614f, 0.05293074f, 0.33962631f, -0.12204056f, -0.27592456f, 0.14630535f, 
    0.00579062f, 0.01220959f, 0.09150209f, 0.02351506f, 0.15404229f, 0.18543497f, -0.04915079f, -0.00234073f, 
    -0.11810178f, -0.12387340f, 0.27464390f, 0.03967278f, -0.02433864f, 0.05323765f, 0.05964236f, 0.05729407f, 
    0.03457291f, -0.04294764f, 0.06293269f, -0.16576147f, 0.06442961f, 0.09217882f, 0.05701734f, 0.07328250f, 
    -0.00405042f, -0.03203382f, -0.03554686f, 0.04359854f, 0.01220401f, 0.09278364f, -0.01393422f, 0.13470308f, 
    0.20011453f, 0.00041616f, -0.05610569f, 0.03837460f, 0.13497077f, 0.09870606f, 0.06783044f, 0.01869853f, 
    -0.10294668f, 0.09417684f, 0.03964809f, -0.06469069f, -0.00413638f, 0.05631943f, 0.11834197f, -0.03961457f, 
    0.01191918f, -0.01664910f, -0.03042243f, 0.02393588f, 0.16256699f, -0.03979753f, 0.03285987f, -0.05058022f, 
    -0.25555986f, -0.01682475f, -0.30789605f, -0.20538035f, 0.02788738f, 0.08043828f, 0.04350364f, 0.00010403f, 
    0.16415545f, 0.13962403f, 0.03602406f, -0.08001205f, 0.14908819f, 0.16269872f, -0.19051272f, 0.04863121f, 
    -0.02245577f, 0.18355192f, -0.05502386f, -0.01240379f, 0.15027043f, -0.06680004f, 0.05408873f, 0.06394558f, 
    0.11959751f, -0.16928059f, -0.03730151f, -0.00733517f, -0.06958149f, -0.01001233f, 0.10663025f, 0.07186759f, 
    -0.04970225f, 0.06712950f, 0.04643027f, 0.06113821f, 0.03323701f, -0.30049258f, 0.21264389f, 0.05425690f, 
    0.10752176f, 0.05238484f, 0.07004056f, 0.06450399f, -0.04148067f, 0.07019249f, 0.11717084f, 0.06157620f, 
    -0.01363613f, -0.11653733f, 0.06317270f, -0.16364054f, 0.05704552f, 0.18701866f, -0.08399229f, 0.17395797f, 
    -0.14828274f, -0.02519397f, -0.08839256f, -0.08221558f, -0.02496723f, 0.23305257f, -0.09444150f, 0.10102881f, 
    0.05790694f, -0.06905998f, 0.03889735f, -0.06360153f, 0.10588484f, 0.00071497f, -0.01304928f, 0.05018273f, 
    0.13915141f, -0.16470891f, -0.30718520f, 0.26003110f, -0.10965186f, 0.18576171f, 0.05533786f, 0.04827795f, 
    0.05949533f, 0.19929948f, -0.01917247f, -0.03577607f, 0.03941813f, 0.01807434f, -0.16374721f, -0.01026648f, 
    -0.06267942f, 0.00878521f, 0.19663252f, -0.07721015f, 0.12803701f, -0.10399891f, -0.06921420f, -0.01445352f, 
    0.01440341f, 0.11668181f, 0.10288426f, 0.09283493f, -0.07425516f, -0.04720823f, -0.01991788f, -0.08730794f, 
    0.02141419f, 0.07133862f, 0.01764560f, 0.06580263f, 0.06653064f, -0.13183475f, 0.15051289f, 0.13900650f, 
    -0.05674424f, 0.00130101f, 0.12767521f, -0.13745114f, -0.04829086f, -0.02697148f, -0.00671605f, 0.04695011f, 
    0.00624208f, -0.00067999f, 0.02514298f, -0.02002415f, -0.05339264f, -0.05101385f, -0.00037443f, -0.03523970f, 
    -0.00110260f, 0.04226169f, -0.05400878f, -0.03603772f, 0.02861298f, -0.01072340f, -0.04613562f, -0.00612731f, 
    -0.01000608f, -0.04641536f, -0.05029994f, -0.00682697f, -0.00961733f, 0.01908752f, -0.03937691f, -0.04614851f, 
    0.00222120f, -0.05336227f, 0.04191994f, -0.01996026f, -0.03609757f, -0.01755759f, -0.04317648f, -0.03866554f, 
    -0.00970564f, 0.04222443f, 0.00926893f, 0.04667031f, -0.03360333f, -0.03783943f, -0.00852546f, 0.04487168f, 
    0.01919011f, -0.01013600f, -0.04084523f, -0.05466001f, 0.03829316f, -0.00434257f, -0.03262196f, -0.01559703f, 
    0.03095693f, -0.04237830f, -0.04432655f, -0.02689140f, -0.04918675f, 0.01424722f, -0.04965676f, 0.02097362f, 
    -0.00243481f, -0.03617967f, -0.02623367f, 0.00588750f, 0.02194522f, 0.03565045f, 0.00386439f, 0.02580125f, 
    -0.04240449f, -0.00393005f, -0.00686262f, 0.00926857f, 0.01655176f, -0.00325783f, 0.03784718f, -0.00211236f, 
    0.02608290f, 0.01627529f, 0.04542321f, 0.04127206f, -0.03436409f, -0.05117641f, -0.03293825f, 0.01967227f, 
    0.01934869f, 0.00728656f, 0.02542941f, -0.03151352f, 0.00922583f, -0.02079088f, 0.04608112f, -0.02943997f, 
    0.00445782f, -0.04984523f, -0.04020645f, -0.01072835f, 0.01150414f, -0.01347783f, 0.03717102f, -0.04285045f, 
    -0.01181742f, -0.01089090f, 0.01603200f, -0.01169287f, 0.01945983f, 0.00210625f, 0.03690893f, -0.04958832f, 
    0.00490993f, -0.03620484f, -0.04203049f, 0.01838927f, -0.00378267f, 0.01157295f, 0.04240419f, -0.02914661f, 
    0.03560531f, -0.00120033f, -0.04336001f, -0.02678811f, 0.02574908f, -0.04039759f, -0.01414336f, 0.03523827f, 
    -0.01579071f, 0.01210721f, -0.00405214f, -0.05408242f, -0.04710388f, 0.04010351f, 0.02789044f, -0.05090340f, 
    0.03334772f, -0.03746908f, 0.02739384f, -0.02010994f, -0.00813588f, -0.01864143f, -0.00803115f, -0.03586361f, 
    -0.04238818f, -0.01902124f, -0.04618685f, 0.01165284f, 0.02398895f, 0.02065489f, 0.01183119f, -0.00063998f, 
    -0.04930979f, -0.02065860f, 0.00839564f, -0.03483064f, 0.00910386f, -0.04139609f, -0.02509254f, 0.03190954f, 
    0.04499418f, 0.00322540f, -0.03747417f, 0.02947539f, -0.04081814f, 0.00854698f, -0.04749692f, -0.03517209f, 
    0.01224950f, -0.01072400f, -0.02709738f, -0.03667225f, 0.04147830f, 0.02707093f, 0.03924483f, 0.02427445f, 
    -0.00631918f, -0.01685764f, -0.05423984f, -0.02654273f, 0.01782031f, -0.00581376f, -0.00480899f, -0.05382784f, 
    -0.05608237f, -0.02986286f, -0.01647451f, -0.05323267f, 0.00048537f, 0.04456521f, -0.04378568f, 0.02061358f, 
    -0.03504184f, -0.03533654f, -0.03506118f, -0.04598143f, -0.00324258f, -0.04356967f, -0.04754433f, -0.00783849f, 
    -0.00006247f, 0.02691125f, -0.01657847f, 0.00890677f, -0.02305175f, -0.04922316f, 0.03658360f, -0.02566867f, 
    0.00629134f, -0.04916935f, -0.00942244f, 0.02190731f, -0.02489530f, 0.02023084f, 0.03725832f, -0.01330897f, 
    -0.00695364f, 0.03770754f, -0.01137675f, -0.00525947f, -0.04812971f, 0.04680973f, 0.04311728f, -0.02391115f, 
    -0.01322965f, 0.03762400f, -0.00767306f, 0.02757256f, 0.00206228f, 0.01290404f, -0.05224316f, 0.02261825f, 
    0.00886374f, -0.01150998f, -0.05676538f, -0.05464653f, 0.00700219f, 0.00768002f, 0.01721437f, 0.00710902f, 
    0.01381647f, -0.00127426f, -0.01553695f, -0.00244099f, -0.00002371f, -0.04356645f, -0.02570489f, -0.01503730f, 
    -0.04188843f, 0.04598655f, -0.02021994f, -0.04327168f, 0.03321048f, -0.02303010f, 0.02934941f, 0.03975380f, 
    0.02790325f, 0.03995866f, 0.00451126f, 0.03552133f, -0.01401877f, 0.02336116f, -0.03642365f, 0.04248374f, 
    -0.03063072f, -0.03096628f, 0.03448071f, -0.04589916f, 0.03137507f, -0.05230957f, -0.02670192f, -0.03278666f, 
    -0.00240783f, -0.00914503f, -0.00775204f, 0.00962444f, 0.02162885f, -0.00557636f, 0.00275910f, 0.00008656f, 
    -0.03804205f, -0.02421701f, 0.01711478f, 0.02393044f, -0.04465667f, 0.03410890f, 0.00653116f, -0.05212677f, 
    -0.01683512f, -0.04959705f, -0.02121195f, -0.04366573f, -0.01491822f, -0.02018595f, -0.05448341f, 0.04133606f, 
    0.04012165f, -0.00075300f, -0.04882565f, 0.00242553f, -0.03517950f, 0.01974170f, -0.00229324f, 0.02275048f, 
    -0.02662719f, 0.03104730f, 0.00236365f, 0.00476281f, 0.03297766f, -0.04222322f, 0.02974590f, 0.04223163f, 
    -0.02899153f, -0.02880250f, -0.03610507f, -0.04831729f, 0.00833068f, 0.03263928f, -0.03008457f, -0.00006489f, 
    0.01554017f, 0.02210798f, 0.03398467f, -0.03596087f, -0.03319942f, 0.00504911f, -0.00971915f, -0.02978519f, 
    -0.05554010f, 0.03692697f, -0.04432042f, 0.02885748f, 0.02296935f, -0.05521807f, -0.01609116f, 0.00581651f, 
    0.01926210f, 0.03949086f, 0.04244822f, -0.02231700f, -0.03805696f, -0.05495501f, -0.01716629f, -0.01584297f, 
    -0.04854347f, -0.03523609f, 0.00133551f, -0.03424123f, 0.03003632f, 0.00407700f, -0.01850452f, 0.03602550f, 
    0.03916077f, -0.00389024f, -0.04060575f, 0.04117634f, 0.02685723f, -0.04639792f, -0.03310428f, -0.00117520f, 
    0.03476977f, 0.04321175f, -0.04973797f, -0.01898194f, 0.04367663f, 0.02276652f, -0.05070435f, 0.02191556f, 
    -0.04050268f, -0.03802741f, -0.02328146f, 0.02030021f, 0.00443838f, 0.00932003f, 0.03260264f, -0.02972437f, 
    -0.04084705f, -0.01825335f, 0.01930968f, 0.03182375f, -0.01423803f, 0.03168509f, -0.02322799f, -0.03384471f, 
    -0.01749840f, -0.00882293f, -0.02123366f, -0.03801878f, 0.03487501f, 0.01227282f, -0.04273090f, -0.03366846f, 
    -0.04638803f, -0.04828368f, 0.01737012f, -0.02697180f, -0.02303208f, 0.03353503f, -0.03133754f, 0.02931412f, 
    -0.04938098f, 0.03837550f, -0.01464660f, -0.04433627f, 0.01985311f, -0.01532376f, -0.00563272f, -0.02548709f, 
    0.00810529f, -0.02125821f, -0.03602046f, 0.03791290f, -0.05087564f, -0.00033648f, 0.01210162f, 0.00912041f, 
    -0.05513492f, -0.03905323f, -0.03028001f, 0.00380613f, -0.05460205f, -0.01859268f, 0.02170884f, 0.00016597f, 
    -0.01489354f, -0.04796573f, -0.04462875f, 0.01574600f, -0.00819261f, 0.00348128f, -0.04524522f, 0.04310236f, 
    0.01936427f, 0.00050402f, -0.03315853f, -0.03361693f, -0.05135958f, -0.02510740f, -0.04661844f, -0.02147694f, 
    -0.03305545f, -0.02230456f, 0.04128566f, 0.00902616f, -0.01038804f, 0.03122110f, 0.01176298f, 0.02345588f, 
    0.04204703f, -0.03816693f, -0.02969026f, -0.05493989f, 0.03205871f, -0.05696340f, -0.03057902f, -0.03801525f, 
    -0.03519382f, -0.01092086f, -0.03157615f, -0.04795036f, -0.02460825f, 0.01060368f, 0.01199159f, -0.03767870f, 
    0.00669066f, -0.05384445f, -0.03978687f, -0.02023057f, 0.01715822f, -0.00539168f, 0.01195058f, -0.05281026f, 
    -0.03986667f, -0.01649713f, -0.04169139f, 0.03903273f, -0.00555574f, 0.02461210f, 0.04071048f, -0.03973475f, 
    -0.00705785f, 0.00324934f, -0.00297387f, 0.00151710f, -0.02154300f, 0.01863226f, 0.00197106f, -0.02559045f, 
    -0.03822572f, 0.01584223f, -0.05233990f, -0.02178474f, -0.02601537f, -0.03443160f, -0.05359135f, 0.02346456f, 
    -0.04570831f, 0.03598466f, -0.04469344f, -0.00638113f, -0.02618760f, -0.03411494f, -0.01191889f, 0.00853328f, 
    -0.01768821f, -0.02602286f, -0.02545146f, 0.02095727f, -0.03710981f, 0.02354414f, -0.05062222f, 0.00641963f, 
    -0.00507456f, -0.01197676f, 0.04012918f, -0.03908765f, 0.03810263f, 0.01004337f, 0.00582463f, 0.01809535f, 
    -0.01277289f, -0.05306916f, 0.03394604f, -0.01479158f, 0.00054478f, -0.02126985f, 0.00270423f, -0.03814600f, 
    0.01012254f, -0.05791892f, 0.03856073f, -0.04697257f, 0.02402033f, -0.04604227f, 0.00861231f, 0.01268978f, 
    0.01701653f, 0.03065769f, 0.01156408f, -0.00961951f, 0.00347256f, -0.05152695f, -0.05177271f, 0.04039568f, 
    0.02873622f, 0.00659203f, -0.00872510f, 0.00129318f, -0.05591667f, -0.02557327f, -0.04252023f, 0.00556677f, 
    -0.04816731f, -0.00270850f, 0.04110616f, 0.01329483f, 0.02531247f, -0.00533760f, -0.04934168f, -0.02012018f, 
    -0.00966397f, -0.00887640f, 0.00070809f, -0.05129139f, -0.01237966f, 0.00366689f, 0.03622045f, -0.02635481f, 
    0.00643507f, -0.01736698f, -0.03399456f, -0.05430602f, 0.03350882f, 0.02924458f, -0.02307572f, -0.05760104f, 
    0.02956318f, 0.04288583f, -0.00981529f, 0.02244882f, 0.01301628f, -0.02687045f, -0.05114045f, -0.05314943f, 
    0.04010093f, 0.02754394f, 0.00812601f, -0.03874548f, 0.03614013f, 0.00744158f, -0.03104340f, 0.04072174f, 
    0.01938525f, -0.02702044f, 0.00703480f, 0.00309679f, -0.00149998f, 0.00578189f, -0.02090408f, 0.01295433f, 
    -0.00442701f, -0.01242870f, 0.03148244f, -0.03214438f, 0.03960181f, -0.02655224f, 0.02928245f, -0.03909978f, 
    -0.00548665f, -0.03948755f, -0.04299751f, -0.00625255f, 0.01778018f, 0.03830287f, 0.04162521f, 0.02111077f, 
    0.03067086f, -0.01783452f, 0.03271664f, -0.04150410f, -0.00628851f, 0.00204252f, 0.00383670f, -0.01447921f, 
    0.02761692f, -0.01437553f, 0.02583173f, 0.02199017f, 0.00734781f, -0.00008254f, 0.00003382f, -0.03882389f, 
    0.02734615f, 0.01189891f, -0.03204035f, 0.01629187f, -0.02668484f, -0.01272796f, 0.01894858f, -0.04389910f, 
    0.01582020f, -0.00632184f, 0.04089411f, -0.01088176f, 0.01434570f, 0.01511733f, -0.00585979f, -0.04407224f, 
    0.01343719f, -0.01848672f, 0.01067130f, -0.02612430f, 0.01930148f, -0.03237265f, 0.00690591f, -0.00985557f, 
    0.03770272f, -0.05148300f, 0.00599927f, -0.02505877f, 0.02264956f, 0.00310218f, 0.00202898f, 0.02858375f, 
    0.03257544f, -0.01851939f, 0.00859175f, 0.00411220f, 0.01220773f, 0.01473131f, -0.04029982f, 0.01881214f, 
    0.01365278f, -0.02766097f, -0.01721619f, -0.02483729f, 0.03545212f, -0.03021917f, -0.04737836f, 0.02902315f, 
    0.00344805f, 0.03001127f, 0.03299806f, -0.04648540f, -0.04840941f, 0.00270251f, 0.02297447f, -0.01797510f, 
    -0.03170034f, -0.01981221f, 0.00560519f, 0.04097064f, -0.03606971f, 0.01587001f, -0.03894547f, -0.01262151f, 
    0.03676379f, 0.00779412f, -0.03946883f, -0.01639570f, -0.05869512f, 0.01966997f, -0.05457158f, 0.03641161f, 
    -0.04338745f, 0.01947329f, -0.01458421f, -0.02806788f, -0.04813552f, 0.00080520f, -0.01366834f, -0.01111070f, 
    0.03821096f, 0.03683009f, -0.00308798f, 0.02570396f, -0.02572561f, 0.03969247f, -0.00711159f, 0.00369954f, 
    0.00857530f, -0.02587390f, 0.02448583f, 0.02339478f, -0.04092234f, -0.05714751f, 0.04109683f, 0.00129182f, 
    -0.03265395f, -0.02252060f, -0.04706340f, 0.01031567f, 0.00106558f, 0.03456047f, 0.04169378f, 0.02307277f, 
    -0.04013832f, 0.03413983f, -0.00934051f, -0.05010735f, -0.00499196f, 0.04229141f, -0.00755756f, -0.05180088f, 
    -0.05346950f, -0.04440631f, -0.05221063f, -0.00165991f, 0.03632427f, -0.00983083f, -0.05708924f, 0.02899845f, 
    -0.03062522f, 0.00433092f, -0.05738937f, 0.01918904f, -0.04402243f, 0.01683386f, -0.05501604f, 0.00369456f, 
    -0.02759225f, -0.03271419f, -0.02484100f, 0.00490758f, -0.05702272f, -0.05313335f, -0.04405602f, 0.00368746f, 
    -0.01266242f, -0.02288626f, -0.05063653f, 0.04004831f, -0.02046067f, -0.02394355f, -0.05794249f, -0.04037383f, 
    0.00274454f, -0.00282166f, -0.02295110f, -0.03806233f, -0.01681017f, 0.04432689f, -0.03153668f, -0.01779651f, 
    0.02086332f, -0.05124424f, 0.02101380f, 0.03390051f, -0.03167731f, -0.01854417f, 0.03507701f, 0.01065923f, 
    0.03974140f, 0.02364068f, -0.03964267f, -0.04323812f, 0.03844777f, 0.02998415f, -0.00638423f, 0.01242282f, 
    0.00046158f, -0.00929331f, -0.03080182f, 0.00694660f, 0.01550770f, -0.02912969f, 0.00866845f, -0.03114721f, 
    -0.05380780f, -0.03129709f, -0.03187443f, 0.03523853f, 0.00676404f, -0.05085241f, -0.05620138f, -0.00437394f, 
    0.00146077f, 0.02383795f, -0.01518550f, -0.04407016f, -0.03059106f, -0.00752229f, 0.02292484f, 0.01940885f, 
    -0.00358230f, 0.04541965f, -0.04371662f, 0.02083361f, 0.00137792f, -0.04236302f, 0.02295383f, 0.02530764f, 
    -0.05160792f, -0.04169864f, -0.03101026f, -0.02313212f, 0.00583576f, -0.03378047f, -0.03180905f, -0.05137055f, 
    0.00102408f, -0.04287603f, 0.04243695f, 0.03375536f, 0.05359070f, -0.02346830f, -0.05212340f, -0.01997648f, 
    0.03535761f, 0.01493050f, -0.02941230f, 0.01820963f, -0.00061157f, -0.00412983f, -0.00277197f, -0.01481288f, 
    0.02201104f, -0.03335244f, 0.00128437f, 0.01486096f, 0.05655145f, 0.01472160f, 0.02644571f, -0.01243149f, 
    -0.02079354f, -0.03331238f, 0.03325882f, -0.05408303f, 0.00723970f, -0.00858002f, -0.03500430f, 0.00858460f, 
    0.00091408f, -0.05181897f, -0.02372655f, 0.00514041f, 0.03667267f, 0.01720862f, 0.02014683f, -0.02130685f, 
    0.01096722f, -0.05324437f, -0.03967602f, -0.05431151f, 0.01392192f, 0.00627120f, 0.01367469f, -0.01380046f, 
    0.02780128f, -0.02398511f, 0.02495398f, 0.01473583f, 0.03919231f, -0.01693365f, 0.02300527f, -0.03087779f, 
    -0.03424484f, 0.05186083f, -0.05357230f, 0.04474747f, -0.01097484f, -0.02127699f, 0.02676932f, -0.02567729f, 
    0.02985692f, 0.04233347f, -0.00265874f, 0.00508856f, -0.02939457f, 0.02798114f, 0.04954354f, -0.02127927f, 
    0.00564946f, 0.04238027f, -0.03104762f, -0.00229445f, 0.03157729f, -0.05001130f, 0.00564307f, -0.03560840f, 
    -0.02086384f, 0.02381987f, -0.01213940f, -0.04700914f, 0.02095920f, -0.05546665f, 0.01319986f, -0.05595670f, 
    -0.04455023f, 0.00630867f, 0.01870308f, 0.00235949f, -0.05663584f, 0.02259471f, -0.04286459f, -0.01022593f, 
    0.03557611f, -0.01654508f, 0.01354492f, -0.00982813f, -0.05703584f, 0.03181303f, 0.00659777f, 0.02819896f, 
    -0.01166984f, -0.00024484f, -0.01484817f, 0.00049309f, -0.04723137f, -0.03453331f, 0.00025385f, 0.02872303f, 
    -0.00848111f, 0.02979250f, -0.03117342f, 0.01504127f, 0.04452290f, 0.02561388f, 0.01293674f, -0.01051700f, 
    -0.04881803f, -0.05143647f, -0.04468687f, -0.01714670f, -0.04248109f, -0.05031763f, 0.01295434f, -0.03885832f, 
    -0.04625620f, -0.04850760f, -0.03354692f, 0.04241789f, -0.02795153f, -0.00804487f, -0.03076484f, -0.02456700f, 
    -0.04009438f, 0.01012321f, 0.00658407f, -0.04613341f, 0.02676434f, 0.03667830f, 0.01960170f, 0.04968023f, 
    0.02412606f, -0.02434481f, -0.04065137f, 0.03258826f, 0.00737996f, -0.04050656f, -0.00294792f, 0.03420634f, 
    -0.04792341f, -0.04193219f, -0.03664747f, -0.04048856f, -0.02489419f, 0.03506017f, 0.01821366f, 0.00537275f, 
    -0.02654175f, -0.00488792f, 0.03956683f, 0.04027842f, -0.02935352f, 0.03558527f, 0.00514458f, -0.03230135f, 
    0.01492472f, 0.03529160f, -0.03232776f, -0.02358224f, -0.02563530f, -0.01908801f, 0.00181639f, -0.02095230f, 
    -0.03918072f, 0.01141655f, -0.04947464f, -0.01919861f, -0.00220532f, -0.05580424f, -0.02204759f, 0.01794806f, 
    0.02800089f, 0.00060072f, 0.03824705f, -0.02294754f, -0.01235351f, -0.01722348f, -0.00705970f, 0.00031331f, 
    -0.02082582f, -0.00308630f, -0.01142744f, -0.04039238f, -0.04319230f, 0.00088942f, -0.05478291f, -0.04784838f, 
    -0.03385457f, -0.01225481f, 0.01760829f, 0.04285686f, -0.04672158f, 0.04066970f, -0.01634542f, 0.01822990f, 
    0.02971724f, -0.02334097f, -0.03565643f, 0.03298748f, 0.00339869f, -0.00997523f, -0.01110808f, 0.02400099f, 
    0.01697814f, -0.05658872f, 0.01455856f, 0.02616329f, -0.03046348f, 0.04378142f, 0.00919819f, 0.03454608f, 
    0.05058803f, 0.01502446f, -0.01504035f, 0.00072431f, -0.04037271f, -0.04937835f, 0.03912549f, -0.03055928f, 
    0.05371682f, 0.02185642f, -0.04465863f, -0.01176593f, 0.03106989f, -0.05112216f, -0.03457208f, -0.02672985f, 
    -0.04491312f, 0.02219085f, -0.00850617f, -0.05277049f, 0.00899117f, -0.01501766f, -0.02373352f, -0.03573212f, 
    -0.03012834f, 0.00837608f, 0.03796281f, 0.03339474f, 0.04395217f, 0.01306130f, -0.05146790f, -0.04146264f, 
    -0.01548918f, 0.01929428f, -0.04350256f, -0.00302856f, -0.05333076f, 0.04327117f, -0.00113247f, 0.01508114f, 
    0.02227709f, -0.04173637f, -0.03777113f, -0.05311172f, 0.01533438f, 0.01864513f, 0.00079601f, -0.04850261f, 
    -0.03902114f, -0.04455644f, -0.03666779f, -0.01680334f, 0.00470451f, 0.02415396f, 0.02359270f, -0.03547134f, 
    0.02311949f, 0.02724679f, -0.05574358f, 0.00801134f, -0.02523931f, -0.02907216f, -0.03279895f, -0.04292694f, 
    -0.01833113f, 0.03210607f, -0.01239754f, 0.01687076f, 0.00684912f, 0.04290661f, 0.01306193f, 0.02123904f, 
    0.02756475f, -0.01523087f, -0.01255282f, -0.00147272f, -0.05129304f, -0.03027443f, -0.02481674f, 0.03514191f, 
    0.00269961f, 0.05508118f, -0.01026709f, 0.02286157f, -0.00874132f, -0.04191413f, -0.00491149f, 0.04098545f, 
    -0.05521532f, -0.05262928f, 0.00277798f, 0.01827793f, -0.02197339f, 0.02968176f, 0.02485621f, -0.00059648f, 
    -0.29531798f, -0.07403290f, 0.07092953f, 0.11535756f, -0.00210406f, -0.08919907f, -0.01176178f, -0.03997961f, 
    0.04865984f, 0.03808415f, 0.12031836f, 0.20719814f, 0.02197391f, -0.02191357f, 0.01209924f, -0.09644053f, 
    0.22449313f, -0.04166967f, -0.08424575f, 0.04150443f, -0.06945895f, -0.04080172f, -0.05940067f, -0.04059697f, 
    -0.05002350f, -0.08565337f, -0.08223537f, 0.15656109f, 0.00488117f, -0.05805181f, 0.06722319f, -0.00172544f, 
    0.05139600f, 0.09381060f, 0.01122610f, 0.09615703f, -0.25261989f, 0.06863505f, 0.11498249f, 0.16993439f, 
    -0.05004632f, -0.03263229f, -0.01844050f, -0.03291145f, -0.05566064f, 0.10609794f, 0.06605355f, 0.03699848f, 
    -0.15685087f, -0.09861060f, 0.09751071f, 0.14647706f, 0.00857450f, -0.17797399f, 0.02592945f, -0.02781412f, 
    -0.10785677f, -0.09880128f, 0.04003959f, 0.15753749f, 0.16589081f, 0.02157732f, -0.17262122f, -0.14177473f, 
    0.01884153f, 0.11459902f, -0.09227826f, -0.02311553f, 0.20565675f, -0.10635060f, 0.19299707f, -0.21030545f, 
    -0.38225779f, 0.35194817f, 0.15366444f, 0.04701860f, 0.11176653f, 0.02084861f, -0.18561988f, 0.08182651f, 
    -0.16704692f, -0.11394307f, -0.04543187f, 0.02889504f, -0.04908674f, 0.02747568f, -0.05075024f, 0.00770592f, 
    0.13978980f, 0.00924473f, -0.11262693f, -0.16181445f, 0.03818931f, -0.03669030f, -0.05364029f, -0.03228271f, 
    -0.11560962f, -0.14231996f, 0.18838778f, 0.05590605f, -0.04908045f, -0.10127134f, 0.01175117f, 0.12076733f, 
    -0.11902578f, 0.07973669f, -0.01031299f, 0.08859997f, 0.07334244f, 0.07120604f, 0.19910374f, 0.09049660f, 
    0.09899540f, -0.02707366f, 0.09294377f, -0.03977357f, 0.03183763f, -0.00883387f, 0.02550494f, 0.03956253f, 
    -0.04523398f, 0.05828079f, 0.07081423f, 0.02025019f, 0.00744184f, -0.10851952f, -0.03202143f, -0.19192868f, 
    -0.02424501f, -0.03147202f, 0.07184556f, 0.00607657f, -0.06362524f, -0.05582426f, -0.02260820f, -0.00787320f, 
    0.06926642f, 0.05826353f, 0.11061555f, -0.03595165f, 0.04739534f, -0.08143274f, 0.33185673f, 0.14262024f, 
    -0.05549767f, 0.05820922f, -0.04785974f, -0.06008973f, -0.12888892f, -0.13162163f, 0.10292059f, -0.03255666f, 
    0.03520806f, -0.02935131f, 0.07975616f, 0.10778790f, -0.10020051f, -0.06139752f, -0.17867921f, 0.14095464f, 
    0.14730847f, 0.01090987f, 0.04985144f, 0.04860052f, -0.06924734f, 0.00673112f, -0.03800659f, -0.01388897f, 
    0.16065912f, 0.05213326f, -0.13844202f, 0.14184001f, 0.15864071f, -0.03496519f, -0.06039074f, -0.11451338f, 
    0.21601035f, 0.09474014f, 0.06652628f, 0.01479569f, -0.17611770f, -0.11511233f, -0.15279774f, -0.07247560f, 
    0.15551011f, -0.01915538f, -0.00059169f, -0.06602883f, 0.00275796f, -0.04842284f, 0.21029063f, 0.17310373f, 
    0.16988273f, -0.08909468f, -0.10595284f, 0.05599134f, -0.09704719f, -0.07461274f, 0.00112940f, -0.00217278f, 
    0.02440300f, -0.02538280f, -0.06981213f, -0.02226141f, -0.30876467f, 0.07596686f, 0.05660162f, -0.09507820f, 
    0.07942735f, 0.00316521f, -0.08757841f, -0.05615523f, 0.02298848f, -0.05888243f, 0.07260150f, 0.07486075f, 
    0.11339621f, 0.06928836f, -0.13751633f, 0.02843894f, -0.02311936f, 0.02392008f, 0.08050825f, 0.01111476f, 
    0.13584261f, 0.06770625f, 0.11931635f, 0.15230586f, -0.01498302f, 0.06619743f, -0.02135576f, 0.09694348f, 
    0.08915557f, -0.05066079f, -0.01439210f, 0.05485732f, -0.07701825f, -0.00302847f, -0.06385831f, -0.13533024f, 
    -0.08360026f, 0.19491154f, 0.01844662f, 0.08095189f, -0.08810800f, -0.24062693f, 0.05043251f, -0.21083952f, 
    0.05634460f, 0.07665686f, 0.08238068f, 0.03427185f, -0.02326272f, -0.08903498f, -0.13143425f, 0.12593755f, 
    -0.05610203f, -0.11657617f, 0.09954768f, 0.01550817f, 0.08536124f, 0.03430935f, -0.06009768f, -0.08536740f, 
    -0.23292500f, -0.06940703f, 0.18470924f, 0.13174047f, 0.06282429f, -0.04261952f, 0.00127492f, 0.10421271f, 
    0.04821660f, -0.03155810f, 0.03793490f, 0.13906257f, -0.19098093f, -0.11552767f, 0.18365279f, 0.00341315f, 
    0.04414705f, -0.13232499f, 0.04660470f, -0.00446074f, 0.03968700f, -0.07292312f, 0.11046773f, 0.00363664f, 
    -0.24409823f, 0.34807751f, 0.11762158f, -0.00648804f, 0.16251531f, 0.06265117f, -0.21774715f, 0.02213387f, 
    0.02791245f, -0.07653732f, 0.08052043f, -0.10034781f, 0.47500592f, 0.45965046f, -0.22160898f, 0.05537342f, 
    -0.02058622f, 0.01669906f, 0.19426455f, 0.01438965f, -0.00205716f, 0.06129382f, -0.17052601f, -0.05361108f, 
    -0.02112851f, 0.08872085f, -0.00110577f, 0.02747625f, 0.15098116f, 0.07239994f, 0.04144111f, -0.05357746f, 
    0.15690218f, -0.13906091f, 0.00543108f, 0.20124823f, 0.13862032f, -0.14657153f, 0.10413674f, 0.24801436f, 
    -0.03648484f, -0.00721675f, 0.00282548f, 0.11058930f, 0.07306410f, -0.04909900f, 0.04284144f, 0.01201907f, 
    -0.17222619f, 0.17592007f, 0.27029139f, -0.11865547f, 0.07400143f, 0.09370395f, 0.05482338f, -0.17913534f, 
    -0.04421018f, -0.03198574f, 0.03435590f, 0.00609749f, -0.58505309f, 0.23472871f, 0.00794568f, -0.06887580f, 
    0.09190556f, -0.00531549f, -0.06415737f, 0.01911278f, -0.23054600f, 0.06668480f, -0.06459566f, 0.15867169f, 
    0.10668668f, -0.03267825f, -0.07095955f, 0.14495394f, 0.07823829f, 0.15845560f, -0.01892666f, 0.00409079f, 
    -0.00399954f, -0.06605252f, 0.06235098f, 0.01118957f, 0.01090886f, 0.11476558f, -0.12214849f, -0.17721632f, 
    0.02608870f, 0.00891623f, -0.07478283f, -0.03753299f, -0.08593117f, 0.15737197f, -0.09815297f, -0.06401865f, 
    0.04744426f, 0.35084012f, 0.04926573f, 0.00785102f, 0.00821215f, 0.06273440f, 0.06479628f, 0.04313313f, 
    -0.07510424f, -0.18349923f, -0.24852759f, -0.20693056f, -0.07374765f, -0.04140412f, 0.07763994f, 0.04456006f, 
    0.03157304f, -0.04969481f, -0.15311791f, -0.01313100f, 0.18377435f, 0.10501164f, 0.08966809f, 0.11192775f, 
    -0.07568312f, 0.16356380f, -0.05776957f, -0.10671898f, 0.11077963f, 0.06154636f, -0.15522280f, 0.00845929f, 
    -0.24399662f, -0.08356073f, -0.21574011f, -0.09877869f, 0.02101498f, 0.14441730f, -0.12565549f, -0.10039899f, 
    0.16458192f, 0.03977806f, -0.02513021f, -0.11147860f, 0.05840697f, 0.04497242f, 0.00589184f, -0.16021505f, 
    0.23601307f, 0.33183852f, 0.21838753f, -0.22782625f, 0.05152872f, -0.01404521f, 0.02013940f, 0.13867278f, 
    0.09129539f, 0.10655358f, -0.04232248f, -0.08166295f, -0.17435133f, -0.06440616f, -0.23407392f, 0.05103175f, 
    -0.11591811f, -0.11182258f, -0.11442031f, 0.03067104f, -0.26670319f, 0.02271978f, -0.13551337f, 0.17454731f, 
    0.20003958f, 0.35627386f, 0.12526469f, 0.25695252f, -0.08244259f, -0.11451606f, 0.06058795f, 0.18964048f, 
    0.12501195f, 0.05697171f, 0.13108592f, 0.14592610f, -0.03774988f, -0.15189354f, 0.21711929f, -0.10222384f, 
    -0.08150686f, 0.08043771f, -0.07326590f, 0.11513738f, 0.09206896f, 0.08623368f, 0.12973374f, 0.11356634f, 
    -0.06798884f, 0.22043383f, -0.02408803f, -0.06641569f, -0.03716255f, 0.05614304f, -0.00525317f, 0.01801255f, 
    -0.07595320f, -0.10824323f, -0.01482771f, 0.05845024f, -0.01810175f, -0.06185084f, -0.03300975f, -0.07330447f, 
    0.16602899f, 0.16831738f, 0.03309227f, 0.20649908f, 0.00254661f, 0.04669551f, 0.08972075f, 0.06209777f, 
    0.14486265f, -0.08830942f, -0.12351198f, -0.06662504f, 0.07323749f, 0.12455052f, 0.18075663f, 0.13994096f, 
    -0.00355523f, -0.06387567f, 0.06237492f, -0.12995580f, 0.03062766f, -0.11008755f, 0.01130168f, 0.11305905f, 
    0.00630628f, 0.05639667f, 0.00131933f, 0.02266476f, -0.05008912f, 0.06280871f, -0.20111440f, -0.17058267f, 
    0.15519266f, 0.08302812f, 0.05848892f, 0.01300821f, 0.01527880f, 0.00174132f, 0.01757434f, 0.17143434f, 
    0.05669407f, 0.01330866f, 0.00144796f, -0.00571248f, -0.13680270f, -0.27467346f, -0.00174699f, -0.19379768f, 
    -0.10077498f, -0.02946319f, -0.11898612f, -0.11597695f, 0.01142821f, 0.01430397f, 0.17247312f, 0.05831869f, 
    -0.14083698f, 0.12041195f, -0.13443431f, 0.14983580f, 0.15741180f, 0.13116693f, 0.12659211f, 0.09422462f, 
    0.04853958f, 0.09721425f, -0.09388970f, 0.02872325f, 0.08322328f, -0.34599063f, 0.17119768f, 0.31622300f, 
    0.06072630f, 0.15255257f, -0.05824170f, 0.01547242f, 0.10588844f, -0.05466377f, 0.06320403f, -0.02045582f, 
    -0.31875846f, -0.18195313f, -0.13635093f, 0.13170747f, 0.12324546f, 0.05115855f, -0.05019616f, 0.01165273f, 
    0.04173182f, 0.01643918f, 0.07105030f, 0.17974569f, -0.02951587f, 0.01205922f, -0.00045215f, 0.12039348f, 
    0.12206474f, 0.04270417f, -0.10088296f, 0.08235002f, 0.21688227f, 0.15269537f, 0.17542334f, 0.09886672f, 
    -0.17101477f, -0.19804306f, 0.10794671f, -0.03399739f, 0.10693013f, 0.07038122f, -0.04902571f, 0.08471459f, 
    -0.18918347f, -0.07153075f, -0.17201558f, -0.26839212f, -0.22179258f, -0.14978762f, -0.03498790f, -0.17791112f, 
    -0.05720741f, -0.05726193f, -0.10616674f, -0.12327788f, 0.03877949f, -0.09769034f, 0.21925455f, 0.24344371f, 
    0.15486202f, -0.13579141f, 0.15064444f, -0.12904891f, -0.00157771f, 0.19501790f, 0.18413189f, 0.18089312f, 
    0.01742169f, -0.09612427f, -0.00132713f, 0.00412181f, -0.19267748f, 0.06057694f, -0.08928044f, -0.13446078f, 
    -0.02281225f, -0.03812897f, -0.00369319f, 0.02622441f, -0.08574326f, -0.02491203f, 0.16590041f, 0.12864953f, 
    -0.25849965f, 0.12632178f, 0.25184315f, 0.04911636f, 0.00311466f, 0.08301329f, -0.00266799f, 0.02605670f, 
    -0.02310975f, -0.03002689f, -0.05695243f, -0.00333031f, 0.12260336f, 0.29920262f, -0.00728238f, -0.13082175f, 
    0.02235164f, -0.03547540f, -0.03659386f, 0.22688134f, 0.06251082f, 0.00620528f, -0.05029355f, 0.01792719f, 
    0.04811209f, -0.16441891f, 0.06481988f, 0.06092580f, 0.09209413f, 0.15678376f, 0.10117677f, -0.06158748f, 
    0.11360361f, 0.22669235f, 0.06898177f, 0.06841341f, 0.08505173f, -0.12522876f, -0.16898927f, -0.27135581f, 
    0.07749129f, 0.08229503f, -0.00138913f, 0.02296807f, -0.04445718f, -0.00072635f, -0.05536993f, 0.08899964f, 
    0.07188373f, -0.00151782f, 0.06941890f, 0.03067344f, -0.09793504f, 0.02577300f, 0.16298972f, 0.16283427f, 
    -0.00323896f, 0.12679873f, 0.05359185f, -0.10657225f, 0.06222979f, 0.09975994f, -0.03666233f, -0.04308655f, 
    0.12344366f, 0.15076086f, 0.09324426f, 0.15259629f, 0.08544599f, 0.05681745f, -0.03505429f, -0.01390571f, 
    0.09643023f, -0.07508483f, -0.21110523f, 0.04659258f, 0.08100472f, 0.03738493f, -0.00453499f, 0.13300590f, 
    -0.04172132f, -0.15634379f, -0.17240009f, -0.04655693f, -0.04709989f, 0.21547897f, 0.01649908f, -0.13051093f, 
    0.04727861f, 0.06172249f, -0.06021960f, 0.09652630f, 0.11647669f, 0.07479981f, 0.01827899f, -0.00945423f, 
    -0.42300379f, -0.32040152f, -0.13911763f, -0.13518633f, -0.05261241f, -0.12606882f, -0.13383065f, -0.15876685f, 
    -0.04597931f, -0.03778231f, 0.01646249f, -0.01388852f, -0.08511279f, -0.17086437f, -0.04790584f, 0.17924146f, 
    0.12831105f, 0.13810615f, -0.03685290f, 0.08945898f, 0.04762223f, -0.07647948f, 0.10943047f, 0.22102733f, 
    -0.04789697f, 0.03347823f, 0.01995669f, 0.00121206f, 0.00899801f, -0.03124948f, -0.03093560f, -0.01481323f, 
    -0.04991218f, -0.04213906f, -0.00821072f, -0.05480952f, -0.01221480f, -0.02445108f, 0.02473812f, 0.00144454f, 
    -0.01523913f, 0.00074616f, -0.02165590f, -0.05312533f, 0.02094255f, -0.00529312f, -0.02509242f, -0.04303912f, 
    0.04190870f, -0.00603925f, -0.01815733f, -0.01356442f, 0.01322324f, -0.00744313f, -0.00442509f, 0.04305940f, 
    -0.04183045f, -0.02367682f, -0.05197210f, -0.04191548f, -0.03994994f, -0.00164274f, -0.02759509f, -0.00830719f, 
    -0.00049773f, -0.05625977f, -0.05780445f, 0.02347284f, -0.02823368f, -0.00787763f, 0.02118017f, -0.01729003f, 
    -0.04408409f, -0.02018866f, 0.03620037f, 0.03766873f, -0.03636415f, 0.00952631f, -0.00634334f, -0.00098024f, 
    -0.00401827f, 0.02872911f, -0.01685674f, 0.03949636f, 0.04051267f, 0.01631731f, -0.02790907f, 0.00075607f, 
    0.03201476f, -0.01131710f, -0.02071565f, -0.00880137f, -0.02005622f, -0.03066982f, -0.04961650f, -0.03567234f, 
    -0.04114137f, -0.02610375f, 0.01359648f, -0.05671761f, -0.03645707f, -0.02230310f, -0.00895692f, 0.03747564f, 
    -0.05115883f, -0.02454777f, -0.00184327f, -0.00429810f, -0.04959608f, -0.03227986f, 0.00229134f, -0.00678877f, 
    0.04369718f, 0.00801285f, -0.03087309f, -0.03434632f, 0.02641883f, 0.03829273f, -0.02674426f, -0.01991665f, 
    0.04302068f, -0.03288994f, -0.01776630f, -0.01978107f, -0.00390123f, -0.01668376f, -0.03589347f, -0.03101599f, 
    -0.04085779f, -0.02782036f, 0.02145492f, 0.00530218f, -0.01980460f, -0.02241064f, -0.01319428f, 0.04996236f, 
    0.02395804f, -0.05272038f, -0.04131992f, -0.02591051f, -0.00173434f, -0.00802104f, 0.01053086f, -0.05372119f, 
    -0.01793762f, 0.04183811f, 0.00550254f, 0.03617731f, -0.01701583f, -0.05446726f, -0.03596795f, -0.02778479f, 
    -0.02847347f, -0.00699598f, 0.01547763f, -0.00892835f, -0.04516650f, -0.05648012f, -0.00953841f, 0.01353950f, 
    -0.05596209f, 0.02127774f, -0.00319590f, -0.04461723f, 0.00506471f, 0.00364862f, 0.01280531f, 0.04148149f, 
    -0.00856180f, -0.04543391f, -0.01303650f, -0.02064385f, 0.02205858f, -0.03183404f, -0.04807847f, -0.04816932f, 
    -0.05767937f, -0.02557137f, 0.02256439f, 0.03587990f, 0.02803245f, -0.03270470f, 0.03579156f, 0.01047349f, 
    -0.03295304f, 0.04823843f, -0.04659379f, 0.02029954f, -0.02619891f, 0.01614657f, -0.00479527f, -0.00241536f, 
    -0.02713169f, 0.04335934f, 0.01900500f, -0.03296914f, -0.03698449f, -0.04731090f, 0.04047954f, -0.02981619f, 
    0.01886497f, -0.03076330f, -0.03087956f, 0.03658445f, -0.00032442f, -0.00141679f, -0.02691965f, 0.01550958f, 
    -0.02380029f, -0.03660170f, 0.01157563f, -0.03936180f, -0.00393635f, 0.00718449f, 0.03046463f, -0.01521702f, 
    0.01704908f, -0.04388490f, 0.01739141f, -0.03940983f, -0.05515378f, -0.05650846f, 0.02752217f, 0.04039368f, 
    0.02434644f, -0.02199694f, 0.03717948f, -0.00622247f, 0.03726459f, 0.04859978f, -0.02263367f, -0.05633912f, 
    -0.04119861f, -0.05167537f, -0.00618751f, -0.04319697f, -0.03637736f, 0.02911933f, 0.04534557f, 0.02863030f, 
    0.00490796f, 0.01540148f, -0.01310482f, -0.04041801f, -0.02045988f, 0.00671439f, -0.01817065f, 0.00889114f, 
    0.03536028f, -0.00308742f, -0.02858805f, 0.00806249f, -0.03768602f, -0.03559281f, 0.00323136f, 0.03797184f, 
    0.04221243f, -0.02368626f, -0.02835230f, -0.04105776f, -0.04867501f, 0.01132630f, 0.04776795f, -0.00154996f, 
    0.00473096f, -0.02856576f, -0.00182251f, -0.04610684f, 0.02852326f, -0.01846975f, -0.05661654f, 0.01697917f, 
    -0.05084928f, 0.03271209f, 0.03382454f, 0.02010458f, -0.02819647f, -0.02525969f, 0.00000580f, 0.03146443f, 
    -0.05084452f, 0.02046534f, -0.03737684f, 0.00003675f, -0.04659017f, 0.00033804f, -0.00162342f, -0.03246517f, 
    0.02360081f, -0.05352015f, -0.01351303f, -0.05117942f, -0.01894413f, 0.01398344f, 0.02431451f, -0.04926468f, 
    0.01816870f, -0.04451480f, -0.03923012f, 0.01816674f, -0.03559412f, 0.02030249f, 0.00601181f, -0.04904616f, 
    -0.03261714f, 0.00439344f, -0.02911461f, 0.04087503f, -0.02669838f, -0.02340753f, -0.00552088f, -0.03706901f, 
    0.02757888f, 0.00541403f, -0.04099912f, -0.05726278f, 0.02761678f, -0.02534445f, -0.04849194f, -0.03188531f, 
    -0.03636392f, -0.04301970f, -0.03761168f, -0.00846173f, -0.02571323f, 0.01459073f, 0.02381431f, -0.00388122f, 
    -0.05394535f, -0.01329245f, 0.01618804f, 0.03305522f, -0.00618345f, 0.04153369f, -0.00848417f, -0.02021827f, 
    -0.05657675f, 0.03548539f, -0.01919522f, 0.02768914f, -0.02678577f, 0.00275864f, 0.03484431f, 0.00313318f, 
    -0.02112225f, 0.03534031f, 0.01083949f, -0.00132816f, 0.03904267f, 0.03495065f, 0.00632931f, 0.02495755f, 
    0.00481228f, -0.00706248f, -0.03593247f, 0.03287647f, -0.05768021f, -0.00905740f, 0.03676610f, 0.03515141f, 
    -0.00393194f, 0.03668835f, -0.00326944f, 0.03213735f, 0.02721105f, 0.01626601f, -0.01891222f, 0.01985505f, 
    -0.04017831f, 0.02990696f, -0.03689061f, 0.02881473f, -0.03125893f, -0.00176570f, 0.00610302f, -0.00389533f, 
    0.04202711f, 0.01692892f, 0.00763650f, -0.00726007f, -0.01985811f, -0.04728625f, 0.03809796f, 0.02008181f, 
    0.03880575f, 0.01945747f, 0.00292641f, -0.02499985f, 0.02498000f, 0.01171142f, -0.05642456f, -0.04939454f, 
    0.03752581f, -0.04436321f, -0.04930984f, -0.01765678f, -0.00433822f, 0.00031768f, 0.03635918f, 0.01599126f, 
    -0.04051251f, 0.02345246f, 0.01690871f, 0.04155320f, -0.00800707f, -0.02355189f, -0.04033416f, 0.03767184f, 
    -0.19470899f, -0.28339475f, 0.01171787f, 0.12125315f, 0.08199722f, -0.00759625f, 0.05009497f, -0.10245477f, 
    0.26591799f, -0.14558649f, 0.05337036f, 0.00574792f, -0.02710846f, -0.13445149f, -0.06259720f, -0.13042599f, 
    0.11714508f, 0.11336105f, -0.09997170f, 0.14503609f, -0.02536908f, -0.02136633f, -0.05967183f, -0.02212891f, 
    0.31943831f, 0.04452928f, -0.02317387f, 0.22345626f, 0.09320404f, 0.04199420f, -0.03487392f, -0.02457996f, 
    -0.00700468f, 0.04747852f, -0.15854988f, 0.01554906f, -0.12695661f, -0.00505123f, 0.23815879f, -0.02198872f, 
    -0.09226894f, -0.01583792f, -0.06479449f, -0.13661839f, 0.02335824f, 0.14429253f, 0.10495070f, -0.00456251f, 
    -0.15561604f, -0.26620543f, 0.09053619f, 0.11333239f, 0.08772100f, 0.00270715f, 0.03644338f, 0.01093762f, 
    0.06127460f, 0.05587303f, 0.20446379f, 0.06189914f, 0.23532073f, 0.12024732f, -0.07131404f, -0.00239543f, 
    0.03200192f, 0.18203534f, -0.04134629f, 0.08152356f, 0.17055166f, -0.08199350f, 0.24308646f, -0.08147249f, 
    -0.12239043f, -0.11898902f, 0.34134161f, 0.24037181f, 0.07995550f, -0.00445599f, -0.04611953f, 0.09756880f, 
    0.00609440f, 0.05847022f, 0.05701544f, 0.07234613f, -0.25639582f, 0.02482727f, -0.17662372f, -0.06617846f, 
    0.01375470f, -0.06211874f, 0.06269975f, -0.11752939f, 0.15054312f, 0.03764746f, -0.05011274f, -0.08506618f, 
    -0.16676785f, -0.20249264f, 0.11228532f, -0.00961752f, -0.04662519f, -0.09552649f, -0.07441740f, 0.08514689f, 
    0.11542719f, -0.00637322f, 0.07470454f, 0.10834897f, -0.09775276f, -0.12088005f, 0.13288274f, 0.02001782f, 
    -0.00220769f, 0.01659970f, 0.03134080f, 0.07012144f, 0.03517223f, -0.00461639f, 0.02513650f, -0.09160051f, 
    -0.08830778f, 0.06678775f, 0.10495204f, -0.12741859f, -0.00348256f, -0.01954787f, 0.04821409f, -0.10627101f, 
    0.16572951f, 0.07887827f, 0.13213383f, 0.10052902f, -0.19512352f, -0.05495797f, -0.01119017f, -0.18362662f, 
    -0.03534357f, -0.02852574f, -0.01172828f, -0.06793339f, -0.00597195f, 0.02919643f, 0.16142818f, -0.02688579f, 
    -0.24182875f, 0.12825182f, -0.06850308f, 0.02433568f, -0.12486589f, -0.07067081f, 0.06764563f, 0.06391037f, 
    0.00850280f, -0.00318943f, 0.08725068f, -0.01976406f, 0.01357195f, 0.01095423f, 0.01055339f, 0.15449759f, 
    0.00687512f, 0.03078774f, -0.06666877f, -0.01014473f, -0.00428841f, -0.06411325f, 0.14892402f, 0.00503124f, 
    -0.15625723f, 0.12128938f, -0.10836691f, -0.11561859f, 0.00111046f, -0.06023999f, -0.01576720f, 0.01763294f, 
    0.05459948f, 0.02574034f, -0.08571225f, -0.10454904f, -0.28849033f, -0.07317092f, -0.10344944f, -0.02020297f, 
    -0.04049257f, 0.01537318f, -0.12129777f, -0.14216010f, 0.01273013f, -0.04401174f, 0.11990567f, -0.08379560f, 
    0.40540543f, 0.00424911f, -0.21745344f, 0.08401462f, 0.06042675f, -0.09699433f, -0.00161835f, 0.03807217f, 
    0.09876719f, 0.05046125f, -0.00097319f, 0.06929860f, 0.00009610f, -0.05618082f, -0.03719135f, -0.19839163f, 
    0.04498423f, -0.11006442f, 0.03713601f, 0.24000071f, 0.12535183f, -0.03727078f, -0.02168951f, -0.01418226f, 
    0.11828984f, 0.03922905f, -0.20330317f, 0.00528227f, 0.01223961f, 0.03599906f, 0.12857005f, 0.16656640f, 
    -0.07564505f, 0.04742402f, 0.03149459f, -0.06368654f, 0.00222585f, 0.03284216f, 0.00105091f, 0.06670901f, 
    0.07529756f, -0.02664771f, -0.07670627f, -0.00891422f, 0.08156378f, -0.02236850f, 0.13602144f, 0.07345229f, 
    -0.29437444f, 0.04233491f, -0.00536935f, -0.05168874f, -0.02494868f, -0.11241860f, 0.06409242f, 0.13607571f, 
    0.06862972f, 0.05904419f, 0.10796252f, -0.07773026f, -0.08791212f, -0.01406112f, -0.12719673f, 0.19919546f, 
    0.10372810f, -0.04108480f, 0.13570084f, 0.13421430f, 0.00758515f, 0.10946554f, 0.12261634f, 0.04454462f, 
    -0.25867087f, 0.01790892f, 0.17818138f, 0.01592598f, -0.10384941f, -0.13896088f, -0.01481614f, 0.12883943f, 
    0.03629630f, -0.04339639f, 0.03924934f, 0.02912561f, 0.24158044f, -0.00057418f, 0.10794202f, 0.08444495f, 
    0.10240868f, -0.08805424f, 0.12206899f, 0.12083906f, 0.05658905f, -0.09875967f, -0.01462578f, 0.06408633f, 
    -0.18665281f, 0.04784887f, 0.27603298f, -0.14404063f, -0.11041225f, -0.00148577f, 0.01834541f, 0.04833318f, 
    0.11910401f, 0.08026370f, 0.07538652f, 0.09217792f, 0.40344104f, 0.33793449f, -0.15698168f, 0.17265549f, 
    0.04795529f, -0.01251568f, 0.30901450f, 0.01912975f, -0.11280785f, -0.00535066f, -0.14890517f, -0.03148828f, 
    -0.40734711f, 0.15462759f, -0.09651411f, -0.14182404f, 0.19322130f, 0.02266906f, 0.11481760f, 0.10259905f, 
    0.18424428f, -0.03889043f, -0.03320369f, -0.00457753f, -0.12222215f, -0.08324516f, 0.11946010f, 0.13658601f, 
    0.16608346f, 0.03062133f, 0.14328791f, 0.05614898f, 0.07652068f, -0.03071265f, 0.00116053f, 0.03651341f, 
    -0.12856169f, 0.17643048f, 0.28879118f, -0.12997089f, -0.08769029f, 0.12801212f, -0.11765560f, -0.13517025f, 
    0.02111041f, -0.11378244f, -0.06227420f, -0.09730572f, -0.34504628f, 0.04651912f, -0.05025187f, -0.03387507f, 
    -0.01576565f, -0.09564570f, -0.05236863f, 0.04593364f, 0.06462133f, 0.12885492f, -0.13483180f, 0.09805624f, 
    0.06281409f, -0.01414330f, -0.05565118f, 0.05526413f, 0.10726666f, 0.20770127f, 0.01828277f, 0.06125623f, 
    0.01124473f, -0.09867737f, -0.00453407f, 0.04326076f, -0.06629086f, 0.08422986f, 0.00098671f, -0.03183872f, 
    0.21222125f, 0.05447944f, 0.00550069f, 0.07711823f, 0.10799508f, -0.03116874f, 0.07629935f, 0.08415945f, 
    -0.02531159f, -0.24045883f, 0.01007531f, 0.24511789f, -0.03726631f, -0.08362942f, -0.00584902f, -0.06771954f, 
    0.21702677f, -0.04675914f, 0.22175910f, 0.13108709f, -0.01972110f, -0.05999338f, 0.05286274f, -0.15818444f, 
    0.05484516f, 0.05258045f, -0.16772556f, -0.05888668f, 0.01081348f, 0.01668535f, -0.02091497f, -0.04393693f, 
    0.10720418f, -0.07095647f, -0.08338885f, 0.01285207f, 0.01286741f, 0.02979642f, -0.05210823f, -0.06256269f, 
    -0.01863480f, -0.01253548f, -0.16829844f, 0.11341061f, -0.20425305f, -0.01873959f, 0.20214133f, -0.06149505f, 
    0.00031132f, -0.07864692f, 0.01822907f, -0.01887390f, -0.01350307f, 0.13888475f, 0.15401112f, -0.02230114f, 
    -0.08481861f, -0.25777444f, 0.19613077f, 0.30622685f, -0.02030768f, -0.07054496f, -0.02765736f, -0.04292719f, 
    -0.01209452f, -0.03554976f, 0.13195610f, 0.12567320f, 0.10716325f, 0.05335083f, -0.26680988f, -0.13025403f, 
    0.14652646f, 0.15110514f, 0.04415861f, -0.00860801f, 0.22214402f, -0.04907541f, 0.06556281f, 0.05155927f, 
    -0.07936920f, -0.11919691f, 0.18660861f, 0.33101064f, -0.03417772f, -0.07952888f, -0.02006178f, 0.11068261f, 
    -0.07891023f, 0.03028900f, -0.00347962f, -0.05095278f, -0.12199475f, -0.03943431f, -0.09027775f, 0.00978755f, 
    0.01536123f, 0.04510948f, -0.22327328f, -0.12615439f, -0.02845412f, -0.09220907f, -0.12888065f, -0.01458273f, 
    -0.09351609f, -0.23397931f, 0.27042955f, 0.10146011f, -0.10346065f, -0.15719411f, -0.00485106f, 0.18025711f, 
    0.10448215f, 0.07466123f, 0.03944315f, 0.08441215f, -0.19149449f, -0.02285155f, 0.08343264f, 0.06644266f, 
    0.04454414f, 0.02925978f, 0.06930793f, 0.06040759f, 0.01909637f, 0.01998725f, -0.00965186f, -0.01947423f, 
    -0.05837634f, 0.03170538f, 0.00557932f, -0.17006072f, 0.04457561f, -0.03856967f, 0.00314381f, -0.08031479f, 
    0.08127139f, 0.02553801f, 0.12460230f, 0.06969239f, -0.17895517f, 0.22845222f, 0.14667043f, 0.04898816f, 
    -0.02083404f, -0.05801936f, 0.06675924f, -0.02752119f, 0.11886244f, 0.08816078f, 0.15132211f, 0.11224519f, 
    -0.30383417f, -0.00078524f, 0.02744324f, 0.00962695f, -0.02012347f, -0.11017069f, 0.14011759f, 0.02060005f, 
    0.04925843f, -0.08859742f, 0.05139649f, 0.05256004f, -0.05769119f, -0.16456841f, 0.03858091f, -0.08446676f, 
    0.05371335f, -0.00751703f, -0.05348242f, 0.06767918f, -0.04003796f, -0.06879333f, 0.02956868f, 0.01764965f, 
    -0.08011686f, 0.21873102f, -0.06494574f, 0.06145115f, 0.01903129f, -0.01996592f, 0.09575001f, -0.06226718f, 
    0.19535856f, -0.01240555f, -0.02825364f, -0.06704652f, -0.34123677f, 0.14155839f, 0.23703010f, 0.10147928f, 
    -0.05275745f, -0.01643311f, -0.09338886f, -0.07243895f, 0.01727471f, -0.05422808f, 0.02666542f, -0.03293836f, 
    0.02070579f, -0.17725144f, -0.22496633f, -0.10987460f, 0.02248121f, -0.04755862f, 0.01713377f, 0.01106566f, 
    -0.00468378f, -0.10751250f, -0.03657503f, -0.03127569f, -0.20867231f, 0.28434664f, 0.19765425f, -0.15884469f, 
    0.01248944f, -0.05974675f, -0.13494129f, -0.06903629f, 0.04212999f, -0.07802448f, -0.00837868f, 0.12301033f, 
    -0.00031147f, 0.00891916f, -0.33163825f, -0.09954163f, -0.01976679f, -0.00893363f, 0.05466066f, -0.16759135f, 
    0.00701093f, -0.02363335f, -0.02346330f, 0.19719481f, -0.10450029f, -0.05876620f, -0.02553011f, -0.04691859f, 
    0.07729467f, -0.00694121f, -0.08309691f, 0.01119775f, 0.00163008f, -0.08536405f, 0.03921279f, -0.00915774f, 
    -0.21312197f, 0.10269713f, 0.06380560f, -0.03579856f, -0.05353973f, -0.01840962f, 0.03152283f, 0.02327281f, 
    0.05286919f, -0.07654572f, 0.06822022f, 0.01966466f, -0.04872957f, -0.07287021f, -0.25210595f, 0.17222072f, 
    0.06574485f, -0.09451897f, 0.05134505f, 0.02689497f, 0.07157845f, 0.01547460f, -0.04143764f, 0.20633861f, 
    -0.26690510f, 0.09109525f, 0.26048219f, 0.22524987f, -0.11393985f, -0.11466148f, -0.07562757f, 0.13299403f, 
    0.11550982f, -0.01113844f, 0.00647776f, 0.13834174f, 0.10955258f, -0.03128451f, 0.29963100f, -0.03206590f, 
    0.00264544f, -0.03723058f, 0.13910255f, 0.15328929f, 0.10366943f, -0.06003958f, 0.06169142f, 0.04185922f, 
    -0.19572864f, 0.04741438f, -0.03639463f, -0.19699949f, 0.01887134f, 0.07338531f, -0.12504935f, -0.00426976f, 
    0.00111141f, -0.03152324f, -0.07906301f, -0.02892239f, 0.19296062f, 0.21261978f, -0.21001017f, -0.01192110f, 
    0.07416451f, 0.01625965f, 0.14981540f, 0.02224266f, 0.05511996f, 0.04647825f, -0.07277562f, -0.09806866f, 
    -0.28981641f, 0.06936054f, -0.05855955f, 0.05908570f, 0.16127948f, -0.12492171f, 0.05354454f, 0.14608468f, 
    0.19313075f, 0.01843311f, 0.03753847f, 0.05094338f, 0.02601331f, -0.20665146f, 0.20242451f, 0.08951229f, 
    0.18142097f, 0.01494224f, 0.06252874f, 0.19201435f, -0.02979596f, -0.04068584f, -0.06064182f, 0.02810192f, 
    -0.03079612f, 0.26799548f, 0.33745155f, -0.26507175f, -0.06010066f, -0.10129482f, -0.06375068f, -0.07569766f, 
    0.05585179f, -0.10102893f, 0.08439120f, -0.13333191f, -0.09703837f, -0.10310161f, 0.21272813f, 0.02050732f, 
    -0.04403093f, -0.01668194f, -0.02181325f, 0.10487032f, 0.11464319f, 0.22242735f, -0.06097189f, 0.11652852f, 
    -0.11372310f, -0.18833990f, -0.10055650f, -0.01343280f, 0.10684781f, 0.13391453f, 0.04794041f, 0.02540433f, 
    -0.01556500f, -0.13454376f, -0.03390343f, 0.06503805f, -0.06674887f, 0.00931924f, -0.08215459f, -0.20469329f, 
    0.16637580f, 0.11885484f, -0.09889363f, 0.02533213f, 0.00305749f, 0.03057364f, 0.05452551f, -0.05065927f, 
    0.11438982f, 0.23198991f, -0.00245132f, -0.28150842f, -0.09460826f, 0.08894148f, 0.02892510f, 0.01515453f, 
    -0.04243874f, -0.24769230f, -0.37979230f, -0.40589362f, -0.04974294f, -0.03016096f, -0.00313612f, -0.00350551f, 
    -0.09325756f, -0.05075823f, -0.04997193f, 0.01769383f, 0.00648896f, 0.03227033f, 0.10618264f, -0.03362952f, 
    0.07180607f, 0.09170451f, 0.00803199f, -0.02839170f, 0.01989660f, 0.09923677f, -0.05494118f, -0.06724053f, 
    -0.00194015f, -0.04941544f, 0.19907874f, -0.22443567f, 0.03827076f, -0.07704751f, -0.08364476f, 0.01854634f, 
    0.04052349f, -0.02334140f, -0.06378957f, -0.02978188f, 0.02052245f, -0.07630730f, -0.04940024f, -0.04415978f, 
    0.01043488f, 0.03560946f, -0.34029835f, -0.21160512f, -0.02644058f, 0.11577237f, -0.03327302f, 0.14488243f, 
    0.02956596f, 0.00258317f, 0.10109109f, -0.14720395f, 0.05725794f, 0.08590131f, 0.10924010f, 0.07894724f, 
    -0.05327697f, -0.04683809f, 0.02133131f, -0.02833294f, -0.11370651f, 0.17630094f, -0.09681606f, 0.13027284f, 
    -0.03000554f, 0.03990749f, -0.04577043f, 0.11871751f, -0.07307180f, -0.03185866f, 0.08629794f, 0.09977663f, 
    0.17303294f, -0.00382356f, 0.04810372f, 0.20804422f, -0.05535635f, -0.15650517f, 0.11459374f, -0.10722899f, 
    -0.03985288f, 0.04704215f, -0.02930673f, 0.10695847f, 0.07969585f, 0.05826932f, 0.15031564f, 0.07111008f, 
    -0.10135345f, 0.02502994f, -0.23623323f, -0.09088945f, -0.00918543f, -0.03828992f, -0.03932193f, -0.09387565f, 
    0.05615631f, -0.02089250f, 0.07311489f, -0.00298342f, -0.19295228f, -0.16975367f, -0.17106523f, 0.06547011f, 
    -0.07098828f, -0.04767182f, -0.02682849f, -0.02642439f, -0.10353487f, -0.09562390f, -0.05656866f, -0.00007310f, 
    -0.09515344f, -0.16431269f, 0.14121221f, 0.10619987f, -0.05819717f, 0.16953132f, 0.04611258f, 0.17427945f, 
    -0.00803521f, -0.04086924f, 0.09807659f, 0.00215148f, 0.02764681f, 0.03500700f, 0.11277842f, -0.06819053f, 
    -0.05868031f, -0.01613919f, -0.07178349f, -0.06506237f, -0.02715484f, -0.00009962f, -0.26358461f, -0.19661683f, 
    0.17967859f, -0.09153682f, 0.07272203f, 0.03181941f, 0.09103616f, 0.04920224f, -0.17775336f, 0.00294047f, 
    -0.10394082f, -0.03387276f, -0.02938984f, -0.11631137f, 0.15286264f, 0.02068339f, 0.11621675f, -0.06574675f, 
    -0.12833016f, -0.06881505f, -0.18161209f, -0.14073631f, -0.02194819f, -0.00708140f, -0.00370249f, 0.07348841f, 
    -0.26116648f, 0.04855555f, -0.01075375f, -0.05927033f, -0.04323024f, 0.00253094f, 0.10317110f, 0.14565256f, 
    -0.06586579f, 0.08433893f, -0.05510166f, -0.00167583f, 0.15921280f, -0.05874045f, 0.00216629f, 0.22258569f, 
    -0.02616474f, -0.00982225f, 0.03752522f, -0.02578789f, -0.03116138f, 0.02808540f, 0.04342431f, -0.02535975f, 
    0.24358813f, 0.11867604f, 0.06641872f, 0.24738066f, -0.00521265f, -0.13038501f, -0.09430087f, -0.09322151f, 
    -0.00700044f, 0.08528076f, -0.00905217f, 0.06313653f, 0.56920475f, 0.02491188f, 0.05221123f, -0.05006425f, 
    0.02893378f, -0.00519004f, 0.04184861f, -0.03831944f, 0.19305257f, 0.20950145f, 0.06714377f, 0.05603828f, 
    0.03582303f, -0.04525383f, 0.14429146f, -0.12633960f, -0.05396396f, -0.04618231f, -0.03888867f, -0.07414469f, 
    -0.17063285f, -0.09442346f, -0.18390258f, -0.32120991f, 0.06299610f, -0.04024936f, 0.07197461f, -0.05779811f, 
    -0.15052800f, -0.06278989f, -0.03405125f, -0.08005038f, 0.08874718f, 0.04271530f, 0.05331956f, 0.07893060f, 
    -0.01933217f, -0.11199002f, 0.00770581f, -0.07502019f, 0.09172425f, 0.15585594f, -0.01839498f, 0.11408859f, 
    -0.01652411f, 0.07578395f, 0.08351389f, 0.07724845f, -0.00709135f, 0.12538567f, -0.01676666f, -0.06068089f, 
    0.04681421f, -0.05437893f, -0.01627771f, -0.00773497f, 0.03638448f, 0.04847198f, 0.05319845f, 0.11808313f, 
    -0.21094985f, -0.19519149f, -0.18298683f, -0.05912744f, -0.05341850f, 0.00856074f, -0.07321554f, -0.11827637f, 
    0.09059080f, 0.11489764f, 0.05885561f, 0.02893659f, -0.04310861f, 0.24966693f, -0.16219361f, 0.07487259f, 
    0.04437042f, 0.20760638f, -0.05860240f, 0.10200690f, 0.01090519f, 0.06531745f, 0.08842406f, 0.03586572f, 
    0.01827701f, -0.22631562f, 0.11542846f, 0.05604960f, -0.03307509f, 0.09673220f, 0.18584035f, -0.00794362f, 
    -0.06202960f, 0.13366960f, -0.01708449f, 0.17298381f, 0.00969685f, -0.29605791f, 0.05069337f, -0.14543244f, 
    0.03746311f, 0.04295804f, -0.03660124f, 0.01715376f, 0.07823429f, -0.01119520f, 0.05620430f, 0.00257648f, 
    -0.09194311f, 0.00925457f, -0.09393226f, -0.00837832f, 0.12916256f, 0.06968243f, 0.04949619f, 0.11814851f, 
    -0.08346105f, 0.08070726f, -0.05716248f, -0.07844267f, -0.15312213f, -0.03975625f, -0.13892910f, -0.09697963f, 
    0.05038985f, 0.15091512f, 0.02663743f, -0.06080621f, -0.11235904f, -0.11840279f, -0.01354370f, 0.04800528f, 
    -0.26037383f, -0.18173213f, -0.07240679f, 0.02067877f, 0.01324506f, 0.05410801f, 0.08568885f, 0.13769113f, 
    0.08032387f, 0.01771005f, -0.02791405f, -0.03753336f, -0.01898919f, -0.07657668f, 0.02494564f, -0.10041013f, 
    -0.00600937f, 0.04196231f, -0.02493674f, -0.00283194f, 0.17007393f, -0.01327526f, 0.11843700f, -0.11306728f, 
    -0.08645435f, -0.04736336f, 0.09921759f, -0.04183861f, -0.14950413f, -0.15443188f, -0.10207529f, -0.10957589f, 
    0.02338017f, -0.06552500f, -0.06487798f, -0.07390280f, 0.09418557f, -0.15081942f, 0.19293535f, 0.13734922f, 
    0.16528034f, 0.11010376f, 0.18149848f, 0.08580872f, 0.12575258f, -0.00490182f, 0.07449071f, 0.05926459f, 
    0.23147216f, 0.02349564f, -0.05308823f, -0.09078591f, 0.05411825f, -0.03826538f, -0.03097120f, 0.03381356f, 
    0.01554813f, 0.01868178f, -0.12776524f, 0.01996262f, -0.01358957f, -0.02965763f, -0.04280431f, 0.09413169f, 
    0.03952727f, 0.22345294f, -0.06246801f, -0.04892657f, 0.06480950f, 0.00645246f, 0.04954537f, 0.04622893f, 
    -0.11529224f, -0.03816120f, 0.13486689f, -0.04255233f, 0.03586707f, 0.01090809f, 0.06803019f, 0.08845029f, 
    -0.00081362f, 0.10006067f, -0.10133307f, -0.01084048f, 0.26994950f, 0.00465200f, -0.13624129f, -0.04908294f, 
    0.12401367f, -0.04243830f, 0.09741086f, -0.07417493f, -0.00501219f, -0.10287067f, -0.00783768f, 0.09384456f, 
    0.24661945f, 0.33810660f, 0.11957376f, -0.16756313f, 0.09517187f, 0.01223630f, 0.01462376f, -0.01668417f, 
    0.11101230f, -0.03412610f, -0.08573773f, 0.12048430f, -0.12319573f, -0.01554111f, 0.12138943f, 0.25950596f, 
    -0.03260598f, 0.02283960f, -0.00584658f, -0.08063332f, -0.12267427f, 0.15796036f, 0.09141716f, 0.05823546f, 
    0.38399488f, -0.24027106f, 0.15340999f, -0.16368392f, -0.20262039f, 0.11710670f, 0.03334502f, -0.15482186f, 
    0.09375596f, -0.12144144f, 0.02990776f, -0.02497205f, 0.06008747f, 0.07880803f, -0.07194185f, -0.04615454f, 
    0.07181944f, 0.12096278f, 0.15641543f, -0.05153036f, 0.00512116f, -0.00435351f, 0.09626053f, 0.07369514f, 
    -0.01654594f, 0.13599668f, -0.25873646f, -0.15844002f, 0.00006843f, 0.08390432f, -0.00325409f, -0.05638525f, 
    -0.07591303f, 0.06778923f, 0.05975417f, -0.02015574f, 0.28981203f, 0.13757393f, 0.12031338f, 0.16946039f, 
    0.10426290f, 0.07285496f, -0.10342927f, -0.00010380f, -0.06005709f, -0.01078370f, -0.03706001f, -0.06074349f, 
    0.16568920f, 0.02425111f, -0.19185972f, 0.14467391f, -0.03909691f, 0.05657690f, 0.10440540f, 0.06264069f, 
    0.05295813f, 0.07148322f, 0.00428182f, 0.04060106f, 0.05523695f, -0.17792746f, -0.07916038f, -0.05216661f, 
    0.06746801f, 0.02766472f, 0.01697993f, 0.12689121f, -0.13348058f, 0.02567129f, -0.15059476f, -0.36073124f, 
    0.08910887f, 0.08021681f, -0.09405813f, 0.02083316f, -0.08326796f, 0.18597686f, 0.09253946f, -0.05106195f, 
    -0.03808356f, 0.00379241f, -0.00423714f, 0.08594663f, -0.10494494f, 0.09559404f, -0.11687326f, 0.00953655f, 
    -0.00352960f, -0.00977154f, 0.01344519f, 0.03617464f, 0.05201965f, 0.00453591f, 0.20687389f, 0.11074059f, 
    0.00527980f, -0.10866268f, -0.00535629f, 0.00030766f, 0.02218279f, 0.07534159f, 0.03382629f, 0.03252510f, 
    -0.06802501f, 0.03693485f, -0.15565877f, -0.01771794f, 0.06532732f, 0.13279304f, 0.08760294f, 0.13066635f, 
    0.08794986f, 0.18002138f, 0.02784459f, -0.04682715f, -0.04403404f, -0.02045821f, 0.00129930f, -0.03554476f, 
    -0.17651439f, 0.08924253f, 0.23188803f, 0.28736082f, 0.09536369f, 0.03881383f, -0.03493863f, 0.02866920f, 
    -0.00963628f, 0.03732125f, 0.06952963f, 0.05993528f, -0.39205509f, -0.45009640f, -0.07438556f, 0.35412583f, 
    0.01075911f, 0.07201140f, 0.02549670f, 0.07275552f, -0.02857867f, -0.00614268f, 0.03761185f, 0.06671152f, 
    -0.10807200f, -0.05757093f, 0.23205283f, 0.08619349f, -0.03753654f, -0.01698895f, -0.07453003f, 0.11078068f, 
    -0.04468268f, -0.00040707f, 0.01662928f, -0.12245662f, 0.07121903f, 0.08948500f, -0.00084788f, -0.04955057f, 
    0.03428959f, -0.01890011f, 0.00090597f, 0.04155097f, 0.10713275f, -0.00326408f, 0.12795594f, 0.05084329f, 
    0.20351565f, 0.07502785f, -0.14168675f, 0.07228995f, 0.07739894f, 0.16950552f, 0.00748458f, 0.06412531f, 
    -0.05266627f, -0.02968120f, -0.01308027f, 0.08294313f, -0.03394772f, 0.08992384f, 0.22795714f, -0.08307891f, 
    -0.03493129f, -0.04790889f, 0.05839393f, 0.04253200f, -0.02101857f, 0.05924086f, 0.00323297f, -0.01362171f, 
    0.13732043f, -0.07406075f, -0.13611495f, -0.20995489f, 0.06816422f, 0.13642673f, 0.09049417f, 0.03155113f, 
    0.08620707f, 0.01759201f, -0.09120630f, -0.12485705f, 0.21845627f, 0.10865248f, -0.05790609f, 0.09705159f, 
    0.03865982f, -0.02355145f, -0.06720814f, 0.15883963f, 0.02122799f, 0.03865498f, -0.04738933f, 0.01945018f, 
    0.17849679f, -0.25742167f, -0.07403643f, -0.12993558f, -0.08926668f, 0.18716015f, 0.01879548f, -0.00489018f, 
    0.03145127f, -0.07111780f, 0.03028006f, 0.02242406f, -0.24436790f, 0.02841254f, 0.42496625f, 0.16915399f, 
    0.12749831f, -0.00115158f, -0.00563511f, -0.07394316f, -0.05141410f, 0.03393340f, 0.08695972f, -0.05083411f, 
    0.25715026f, -0.16743308f, 0.02325749f, -0.11142631f, -0.10949595f, 0.11880492f, 0.13807705f, 0.15159568f, 
    -0.18539909f, 0.07995525f, -0.01158128f, -0.14692816f, 0.12662968f, 0.29618970f, -0.05856886f, -0.01888315f, 
    -0.05221042f, -0.12985770f, -0.09789837f, -0.09965848f, 0.02473276f, 0.09102509f, 0.02143616f, -0.07541113f, 
    0.32655868f, -0.15975399f, -0.22171158f, 0.29538032f, -0.05130335f, 0.02092155f, -0.02999959f, 0.13723660f, 
    0.00208680f, 0.02253742f, 0.03742140f, -0.04209866f, 0.16809687f, -0.04497864f, -0.18836589f, -0.05325772f, 
    0.06890465f, 0.06719011f, 0.04849115f, 0.01943748f, -0.00141156f, -0.06959103f, -0.12353929f, -0.05183101f, 
    0.01281136f, 0.13023597f, 0.02305753f, 0.04130398f, -0.08267926f, -0.04960793f, 0.01845226f, 0.03608966f, 
    -0.02396819f, 0.11557945f, 0.07715694f, 0.08113508f, -0.00411458f, -0.04151035f, 0.07021476f, 0.32729176f, 
    -0.06063431f, 0.18489179f, -0.05334117f, -0.10419194f, -0.08362060f, -0.06472756f, 0.13884193f, -0.01044354f, 
    0.02914044f, 0.02994127f, -0.00168141f, -0.00046139f, -0.05073106f, -0.03572589f, -0.00445055f, -0.03833293f, 
    -0.04902656f, -0.01057037f, -0.04849415f, -0.00850034f, 0.02404953f, 0.03980682f, 0.01148317f, -0.03403572f, 
    -0.03264258f, 0.02383688f, -0.03744400f, -0.02517489f, -0.01813786f, 0.02458594f, -0.00293615f, -0.01629065f, 
    0.00546507f, -0.04259547f, -0.04457861f, 0.02596446f, -0.02336002f, -0.02056374f, -0.05526770f, 0.00823015f, 
    -0.03017488f, 0.04151013f, 0.03561913f, 0.03725151f, 0.03362699f, 0.02407041f, 0.02394926f, -0.02536852f, 
    -0.00855053f, -0.02474636f, -0.00193258f, -0.00738770f, -0.05283802f, -0.02884902f, -0.02561403f, -0.03561347f, 
    -0.04085284f, 0.01626232f, 0.01355775f, 0.03378747f, -0.04460882f, 0.00653639f, -0.02700691f, -0.02237878f, 
    -0.04433610f, 0.00448379f, -0.03032242f, -0.02603645f, 0.01743897f, -0.01979708f, -0.00215906f, 0.03671025f, 
    -0.03617974f, -0.00051759f, 0.00013819f, -0.04313293f, -0.01839911f, -0.01359666f, -0.02937122f, -0.01180911f, 
    -0.02258626f, -0.03058730f, -0.02233638f, -0.01224294f, 0.02150934f, 0.00028807f, -0.02678556f, -0.02688919f, 
    -0.01512777f, -0.02356884f, 0.04070684f, -0.00682237f, 0.00110513f, -0.00918292f, 0.01540753f, -0.00065721f, 
    -0.00146088f, 0.00177669f, -0.04004497f, 0.00377227f, -0.04648331f, 0.04418311f, -0.00449008f, 0.02157180f, 
    0.01032470f, -0.04365508f, 0.01370827f, -0.02082426f, -0.05585165f, -0.05371688f, 0.02177840f, 0.00700812f, 
    -0.04043189f, -0.04038473f, -0.01102520f, -0.01054846f, 0.03449043f, -0.00783079f, 0.01565553f, -0.03536909f, 
    -0.04724676f, -0.05155212f, -0.00368713f, 0.01016735f, -0.01434417f, -0.04434254f, 0.02759613f, 0.03190712f, 
    0.01296757f, -0.02946739f, -0.01546320f, 0.01309718f, -0.00952117f, 0.02598740f, 0.03299984f, -0.01359270f, 
    -0.03853501f, 0.03104417f, 0.00601573f, 0.03890806f, -0.01350853f, 0.03343181f, 0.03361049f, 0.01211804f, 
    -0.04659746f, -0.03828952f, -0.00934657f, 0.01404198f, 0.00745123f, -0.01232449f, -0.03707414f, 0.03138688f, 
    -0.01214377f, -0.02371306f, -0.02291456f, 0.02375282f, -0.03763549f, -0.03160864f, 0.00768684f, -0.00255555f, 
    0.03167114f, -0.03610140f, -0.01817637f, -0.02124115f, -0.03617626f, -0.05008954f, -0.03855232f, 0.04326681f, 
    -0.01866420f, -0.01919542f, 0.02734950f, 0.03357230f, -0.04436282f, -0.02458883f, -0.00081519f, -0.03279787f, 
    0.03457861f, -0.02223690f, -0.00506304f, 0.03215824f, -0.01500525f, -0.00349573f, -0.02316066f, -0.00030437f, 
    -0.01189204f, -0.03881064f, -0.00222087f, -0.01032789f, -0.03569543f, 0.04211140f, 0.03602149f, -0.04824752f, 
    0.01093903f, -0.00187684f, -0.05374587f, -0.03726210f, -0.01703264f, -0.00747057f, -0.02472840f, -0.05693225f, 
    0.01174232f, -0.04960224f, 0.00308646f, -0.05168356f, 0.00809090f, 0.01922523f, -0.00910514f, 0.00754041f, 
    0.02088573f, -0.02275627f, -0.05707982f, -0.00582490f, 0.01986121f, -0.02290952f, -0.05811615f, -0.04641264f, 
    -0.02780902f, -0.02018660f, -0.03489769f, -0.05855621f, 0.01660685f, 0.01186347f, -0.00969148f, 0.01705584f, 
    0.02080622f, 0.01404966f, -0.04484499f, 0.02307186f, 0.02933445f, -0.04069843f, -0.04631746f, -0.02263065f, 
    -0.00297251f, -0.00506013f, 0.04028151f, 0.00162421f, 0.02714673f, 0.00495785f, 0.01777882f, 0.01130419f, 
    -0.02376165f, -0.00516552f, 0.03215056f, 0.01445354f, -0.03135578f, -0.00062215f, 0.02811749f, -0.05671985f, 
    0.03845054f, 0.04165498f, 0.03794168f, 0.03798799f, 0.01078141f, 0.00707371f, -0.05670078f, -0.05208405f, 
    -0.00087008f, 0.01116356f, 0.04042524f, -0.04844078f, -0.01593238f, 0.00244602f, -0.02506932f, -0.03752448f, 
    0.03714950f, -0.00863108f, -0.05451034f, -0.04093756f, -0.05638194f, -0.00557125f, -0.03338270f, 0.02687497f, 
    0.03535324f, -0.00192185f, -0.04793588f, -0.01553804f, 0.01611452f, -0.03399237f, -0.01311804f, -0.01004870f, 
    0.01018864f, 0.03060145f, 0.00224778f, 0.01090304f, -0.03461269f, -0.04651800f, 0.03367539f, 0.04179006f, 
    -0.01596047f, 0.02603628f, -0.01523458f, -0.04296227f, 0.02811027f, -0.00571853f, -0.03491615f, 0.03976980f, 
    -0.01977937f, 0.00642447f, 0.02045236f, 0.02034433f, -0.03277090f, -0.00353070f, -0.03839401f, -0.03145429f, 
    0.00999019f, 0.02331795f, 0.00389178f, -0.02409348f, -0.05826456f, -0.04273037f, -0.05464415f, -0.01422164f, 
    -0.02438762f, 0.03183949f, 0.00375228f, 0.00246127f, 0.01446226f, 0.01174619f, -0.03150390f, 0.02243947f, 
    -0.05923595f, -0.00262516f, 0.00265111f, -0.05353530f, -0.05106990f, 0.00758082f, -0.00489958f, -0.01873898f, 
    -0.02515510f, -0.04190706f, -0.03729149f, -0.02075729f, -0.01774805f, -0.03129968f, -0.01714183f, 0.03071491f, 
    -0.05577650f, -0.02026019f, 0.01523574f, -0.03107333f, 0.00353207f, 0.02881198f, 0.00839461f, -0.03275190f, 
    0.00112783f, 0.01652752f, 0.02428603f, 0.00981429f, 0.03911811f, -0.04633689f, -0.05516786f, -0.03307822f, 
    -0.03804459f, 0.00539415f, 0.01473787f, -0.01675945f, -0.00546279f, 0.01472332f, 0.02523722f, -0.02814324f, 
    -0.02877736f, -0.02271921f, -0.05096699f, 0.00485276f, 0.03640829f, 0.00956866f, -0.04718814f, -0.05752635f, 
    -0.03301828f, -0.02796238f, -0.01830120f, -0.03137083f, -0.03314502f, -0.04790938f, -0.04191854f, 0.00264491f, 
    0.00249890f, -0.01035467f, 0.00599295f, -0.01976726f, -0.01740683f, 0.01074592f, -0.02258756f, -0.03044727f, 
    -0.01206409f, 0.01270559f, -0.03361286f, -0.05625734f, 0.02275539f, 0.03130950f, -0.00129703f, -0.00272451f, 
    -0.16355599f, -0.24241959f, 0.06625978f, 0.21268715f, -0.04992791f, -0.01912374f, -0.05647695f, -0.01575131f, 
    0.00135115f, -0.20244958f, -0.06023960f, -0.06893142f, 0.03994865f, 0.00346363f, -0.03773829f, 0.03096757f, 
    -0.02631611f, 0.03454495f, -0.16569333f, 0.04675223f, -0.05098338f, 0.01680172f, -0.02255216f, -0.02524176f, 
    -0.01028498f, 0.00043891f, -0.02843722f, 0.14017855f, -0.00883180f, 0.04232512f, 0.04098220f, 0.04357466f, 
    -0.02536881f, 0.22256336f, -0.21389446f, 0.00436094f, -0.04669700f, -0.00406264f, 0.14051211f, 0.08556068f, 
    0.01512336f, -0.01160488f, -0.10128633f, -0.02670692f, 0.02022106f, 0.04985723f, 0.01174881f, 0.08053833f, 
    -0.46000227f, -0.05768747f, 0.17377016f, 0.11726675f, 0.00967510f, -0.03212685f, 0.05420253f, -0.02869107f, 
    0.01025922f, -0.02576689f, 0.02860135f, 0.00953600f, 0.16493721f, -0.03042056f, 0.00163100f, 0.09577287f, 
    0.06312221f, -0.07041726f, -0.09092668f, -0.05805779f, 0.02737104f, -0.00949726f, 0.13842754f, 0.02459637f, 
    -0.34456918f, -0.34507734f, 0.56954128f, 0.19722913f, 0.04410598f, 0.16222125f, -0.01937686f, 0.04549280f, 
    0.14017981f, -0.05433818f, 0.02153582f, -0.00295511f, -0.01764787f, 0.07936011f, -0.07092293f, -0.04516269f, 
    0.10770484f, -0.03045096f, 0.17977722f, -0.17515093f, -0.01173945f, -0.07116723f, -0.00822054f, 0.02796846f, 
    -0.21721740f, 0.09461884f, -0.03636689f, 0.09628367f, -0.01211808f, 0.03308873f, -0.07436979f, -0.03540633f, 
    -0.08420164f, 0.00546065f, -0.01918827f, 0.08682229f, 0.07727785f, 0.12028979f, 0.22574466f, 0.29694173f, 
    0.06055596f, -0.01776565f, -0.03803129f, 0.01257175f, -0.02888315f, -0.03552135f, -0.01971564f, -0.02992486f, 
    0.18405324f, 0.21320432f, 0.20856442f, 0.15099235f, 0.00765082f, 0.17491460f, 0.06049050f, 0.03779313f, 
    0.09407692f, 0.13408364f, 0.01088005f, 0.07934611f, -0.04986002f, -0.04915597f, -0.06555159f, -0.21670923f, 
    -0.03509656f, -0.07879589f, -0.01435851f, -0.02808737f, -0.05667854f, -0.01506388f, 0.08240202f, -0.03832193f, 
    -0.17051351f, 0.12728268f, 0.05321596f, 0.18896213f, -0.05229837f, 0.12182683f, -0.00233972f, -0.00671861f, 
    0.03402933f, -0.03225734f, 0.08317783f, 0.00973972f, 0.11362917f, 0.18936564f, -0.07246099f, 0.16083033f, 
    -0.04449692f, -0.01827783f, -0.03260965f, 0.01757232f, 0.01078091f, -0.01728025f, 0.00143922f, -0.02476546f, 
    0.04027694f, 0.20006713f, 0.00868840f, -0.08674073f, -0.10479838f, -0.16516346f, -0.04630518f, -0.04750671f, 
    -0.03615844f, -0.05476132f, -0.05556850f, -0.07437737f, -0.02045747f, 0.33990356f, 0.17237528f, -0.12783967f, 
    -0.08698044f, 0.01853937f, -0.00241266f, -0.17251684f, -0.08022600f, -0.01253329f, -0.05123499f, -0.25149181f, 
    0.25535882f, 0.17144330f, -0.12702183f, 0.15135504f, -0.07025967f, -0.01682692f, 0.02161177f, 0.06894749f, 
    -0.03579009f, -0.04142817f, 0.04834060f, 0.00287510f, 0.21303129f, -0.15160531f, -0.05947290f, -0.12760973f, 
    -0.06120872f, -0.01031504f, -0.04268257f, 0.16267569f, -0.11721200f, -0.11569136f, 0.03174685f, -0.14577729f, 
    0.09816255f, 0.12499198f, -0.00707377f, -0.07404533f, -0.08499039f, -0.19630915f, 0.03851192f, 0.12504922f, 
    0.00326104f, 0.05336821f, 0.00851057f, -0.08167002f, 0.01880363f, 0.11819042f, 0.03611231f, 0.14421463f, 
    0.02700398f, -0.01272335f, -0.00589515f, -0.01236895f, -0.06786951f, -0.03410633f, 0.06195268f, 0.05650129f, 
    0.02867475f, 0.24949281f, 0.08562416f, 0.12650163f, 0.02143188f, -0.06707484f, 0.07112803f, 0.05648122f, 
    0.06211622f, -0.11259543f, 0.02739944f, -0.01673222f, -0.15047053f, -0.01672483f, 0.03404317f, 0.04449745f, 
    0.03063277f, -0.06305894f, 0.06706474f, -0.04310773f, 0.10922147f, 0.01832924f, -0.04711678f, -0.03049177f, 
    -0.33571365f, 0.06413314f, -0.04128913f, -0.14378813f, -0.05276921f, -0.00031468f, -0.02403318f, 0.04572662f, 
    0.04656360f, 0.09320284f, -0.06107440f, -0.11817713f, 0.00306313f, 0.16501242f, 0.12042850f, 0.10823755f, 
    -0.02531711f, 0.00907594f, -0.02239312f, 0.12143710f, 0.01936179f, -0.03607827f, -0.00217909f, -0.10291762f, 
    0.02015900f, -0.14473422f, 0.31086805f, -0.00400080f, -0.22804165f, 0.14329310f, -0.02424801f, 0.09134081f, 
    -0.01293592f, -0.12623931f, -0.01361887f, 0.05967383f, -0.02414047f, 0.29872450f, 0.19368856f, -0.03580883f, 
    -0.05011167f, 0.11604246f, 0.15335196f, 0.07902040f, -0.17916664f, -0.02439702f, -0.03761986f, 0.04242860f, 
    -0.20438577f, -0.06498925f, -0.02588803f, -0.10374627f, 0.15059383f, -0.04693143f, 0.05568388f, 0.04969627f, 
    -0.01444098f, 0.08154689f, -0.04713384f, -0.08750784f, -0.11045508f, 0.12634180f, 0.08676909f, 0.01852312f, 
    0.06494661f, -0.14715496f, 0.02582779f, 0.13249688f, -0.05873856f, -0.02852098f, 0.02380832f, -0.01751814f, 
    0.09855792f, 0.07620700f, 0.25157568f, 0.18470526f, -0.02694457f, -0.01918047f, -0.11370499f, 0.10517889f, 
    0.05618348f, 0.02146667f, 0.02674487f, -0.02699547f, -0.13311900f, 0.02460604f, -0.08672040f, -0.02110625f, 
    0.05274852f, -0.08237086f, -0.06256019f, -0.04220257f, 0.01525752f, 0.06784831f, -0.08946382f, 0.04387016f, 
    0.07506541f, 0.09714002f, -0.01564620f, 0.12992676f, 0.05236985f, 0.09017725f, -0.00923763f, -0.03292245f, 
    -0.03255555f, 0.02965071f, 0.00854403f, -0.04066357f, 0.18167447f, -0.08796597f, -0.09477767f, 0.07408574f, 
    0.05212848f, 0.15049025f, -0.00483578f, -0.08322999f, -0.01549375f, -0.03505453f, 0.02019599f, -0.09297732f, 
    0.16827701f, 0.13930741f, 0.05519579f, 0.18920200f, -0.05851027f, -0.00074288f, -0.03404530f, -0.07282657f, 
    -0.00767792f, 0.11641733f, 0.01855475f, 0.14579433f, 0.05931969f, 0.04971056f, -0.19841503f, -0.27116460f, 
    0.13621858f, -0.09619267f, 0.09354610f, 0.17523760f, -0.22784981f, -0.09054101f, -0.04849996f, -0.01087152f, 
    0.19856253f, -0.26715276f, 0.14652365f, 0.06950372f, -0.22987311f, 0.08604031f, 0.07643298f, 0.04175586f, 
    -0.00918671f, 0.06659680f, -0.10241468f, 0.07189816f, -0.01541526f, 0.22796217f, 0.11307184f, -0.18457155f, 
    0.01895405f, 0.10392209f, -0.02737312f, 0.25877741f, -0.01499670f, 0.08926674f, 0.08663011f, 0.07066881f, 
    0.22751395f, -0.01468848f, 0.51366228f, 0.18419571f, 0.03700044f, 0.05106137f, -0.01996031f, -0.15672162f, 
    0.01221998f, 0.11919711f, -0.10056332f, 0.07339955f, -0.09818051f, 0.00804891f, -0.19931911f, -0.20491534f, 
    0.00169705f, 0.15828210f, 0.02768536f, 0.03497380f, -0.08718035f, -0.10433675f, 0.10533077f, 0.01500392f, 
    -0.06805312f, 0.32187721f, -0.01167240f, -0.09811410f, 0.11525898f, 0.15717217f, -0.13800578f, 0.08206269f, 
    -0.10273198f, -0.04692735f, -0.00113858f, -0.07706396f, 0.00138061f, -0.07723033f, -0.15822269f, -0.16475369f, 
    -0.04620204f, 0.06622145f, -0.29774478f, -0.04619485f, 0.03675053f, -0.23047698f, -0.31289777f, -0.14289655f, 
    0.21820751f, -0.05232686f, 0.20756149f, 0.04565912f, 0.03107257f, 0.02978689f, -0.15968889f, -0.22550815f, 
    -0.01029262f, 0.03031950f, 0.05146284f, -0.03192580f, 0.24902119f, 0.19980712f, 0.25658241f, -0.05008014f, 
    0.29405755f, 0.03269662f, 0.10221273f, 0.14128964f, -0.07291216f, -0.02689471f, 0.15730873f, 0.08858693f, 
    0.09752669f, 0.31182113f, -0.06209159f, -0.09625046f, 0.01355247f, -0.04045027f, 0.04751677f, 0.03493353f, 
    0.05169481f, 0.04630245f, -0.05141257f, 0.05164456f, 0.05938769f, -0.09459465f, -0.20125437f, 0.15379328f, 
    0.09589089f, 0.00722587f, -0.00410687f, 0.02412873f, 0.07858178f, 0.08785105f, 0.14132941f, 0.13194193f, 
    0.14483540f, 0.09353006f, -0.08084944f, 0.11201770f, 0.19344963f, -0.07061528f, 0.16148064f, 0.05085839f, 
    0.01255313f, -0.13359071f, 0.16528171f, 0.16103929f, -0.04632967f, -0.01524310f, 0.24061367f, -0.11685845f, 
    0.06754383f, 0.11503068f, -0.09778804f, -0.11930750f, 0.14585258f, 0.14430724f, 0.02995436f, -0.06257515f, 
    0.40658596f, -0.05761845f, -0.32788432f, 0.19286560f, 0.07302941f, -0.04746516f, -0.05331274f, -0.04033716f, 
    -0.01587934f, -0.14483868f, 0.01217976f, 0.06457344f, 0.01380257f, -0.43800995f, -0.10417562f, -0.37839019f, 
    0.07304113f, 0.03052897f, -0.07011724f, 0.08240093f, 0.06497271f, 0.09242817f, 0.04793669f, 0.14984410f, 
    -0.01853331f, -0.15350877f, 0.06341107f, 0.12154987f, 0.03105686f, -0.00726467f, -0.15960461f, 0.09604313f, 
    -0.10594979f, -0.20478573f, 0.02042342f, -0.05879420f, -0.43693015f, -0.32031792f, 0.21701670f, -0.28285515f, 
    -0.07787892f, -0.09526371f, -0.07869086f, -0.13177097f, -0.15777726f, -0.00283560f, -0.07248448f, 0.00048361f, 
    -0.15329646f, 0.17525609f, -0.30151030f, -0.00052334f, 0.06771619f, 0.03331160f, 0.16497549f, 0.38687474f, 
    0.09567562f, 0.14621170f, 0.04519350f, 0.18264900f, -0.06024366f, 0.08587298f, -0.09885954f, 0.03463870f, 
    0.14251964f, -0.10744119f, -0.04595325f, -0.08898419f, -0.08634649f, -0.09039450f, -0.02838971f, -0.34054774f, 
    -0.00883696f, 0.09840868f, -0.04317893f, -0.00430574f, 0.01333793f, 0.01752921f, 0.02247115f, 0.03952026f, 
    0.06912012f, -0.01297396f, -0.02028499f, -0.00907055f, -0.18993323f, -0.06949105f, -0.15595734f, -0.08573642f, 
    -0.13601346f, 0.12853198f, -0.04012843f, -0.26920781f, -0.09603279f, -0.10259390f, -0.04418783f, -0.04822632f, 
    0.32928541f, -0.17005135f, 0.17483619f, 0.14836700f, 0.15102482f, -0.10054684f, -0.01386634f, -0.17477277f, 
    0.06908799f, 0.05719991f, -0.05487752f, -0.07409009f, 0.19680566f, -0.32505578f, 0.31728587f, -0.05558601f, 
    0.11820193f, -0.16858545f, 0.04984149f, 0.02050078f, -0.06263043f, 0.11652975f, -0.09461688f, -0.15175295f, 
    -0.09331765f, 0.20990072f, -0.11223821f, 0.00458088f, -0.05724030f, 0.02987084f, -0.21799542f, -0.01983580f, 
    0.01988602f, -0.10025188f, -0.00313732f, -0.20274179f, 0.02277301f, 0.47696972f, 0.01592758f, 0.29342812f, 
    -0.14178880f, 0.08990782f, -0.03520799f, -0.11204931f, -0.09398141f, -0.08141369f, -0.12555930f, 0.01809753f, 
    0.30327255f, 0.11484276f, -0.29905537f, 0.06678776f, -0.04244915f, -0.02360892f, 0.05318294f, -0.12746575f, 
    0.07909071f, -0.11608478f, 0.05689825f, 0.18211780f, 0.54345441f, -0.26079413f, 0.17781132f, -0.36145860f, 
    -0.00865480f, 0.15820248f, 0.06790687f, 0.12010074f, 0.08959507f, 0.15183741f, -0.08287746f, -0.13456021f, 
    0.22072375f, 0.20343819f, 0.01849919f, 0.06545114f, 0.28794786f, 0.11095347f, 0.11375760f, -0.02870663f, 
    0.04348738f, 0.04913718f, -0.05990712f, 0.00446883f, -0.09355690f, 0.17967485f, -0.31684157f, -0.04448700f, 
    -0.04464874f, 0.11624767f, -0.16124259f, 0.07193589f, -0.02385294f, -0.06022342f, 0.05433274f, -0.00509312f, 
    0.11239811f, -0.02720514f, -0.05646203f, -0.06886049f, 0.12374677f, 0.01599201f, 0.03678516f, 0.13254058f, 
    0.11256466f, 0.02702672f, 0.01704488f, -0.13911887f, -0.22137438f, 0.27144516f, -0.23430195f, 0.14951190f, 
    0.03064750f, 0.03295262f, 0.00320597f, 0.13753767f, -0.14553280f, 0.03528727f, -0.06794892f, -0.11685948f, 
    -0.03424895f, 0.00939688f, 0.01884624f, 0.04781275f, -0.05367003f, -0.05339078f, 0.04635309f, 0.02082454f, 
    0.01806675f, -0.00964463f, -0.03103334f, -0.04544773f, 0.02899904f, 0.00675822f, -0.03832690f, 0.03275782f, 
    0.04239985f, -0.03601385f, 0.01328333f, -0.00019775f, -0.00682823f, -0.04847806f, -0.03763545f, -0.03042954f, 
    -0.00646856f, 0.03597395f, 0.02007848f, -0.03339403f, -0.05355514f, 0.01238810f, -0.01586632f, -0.04471225f, 
    -0.03578369f, -0.02127025f, 0.02414689f, -0.02585525f, -0.04704108f, -0.02450309f, 0.03281260f, -0.00307722f, 
    -0.03794694f, -0.01194778f, -0.02219764f, -0.00004176f, -0.00991889f, -0.04227579f, -0.04249404f, 0.01552958f, 
    -0.00209200f, -0.04483250f, -0.03688966f, -0.04007169f, 0.04126441f, 0.03855358f, -0.01722449f, 0.04618361f, 
    0.04576895f, 0.04208058f, -0.02979149f, -0.04168294f, 0.00869499f, -0.01645498f, 0.03356889f, -0.04739712f, 
    0.02963292f, -0.04332220f, 0.00910419f, -0.00457925f, 0.04111818f, 0.03479385f, 0.03650627f, -0.03002417f, 
    -0.01929838f, -0.02201034f, 0.00025724f, -0.04478151f, -0.01436389f, -0.04257873f, 0.01650197f, 0.02210237f, 
    -0.02503631f, -0.02557151f, 0.04872739f, 0.03974874f, -0.02921792f, 0.01616856f, -0.04198416f, 0.01372447f, 
    -0.00268814f, 0.00509996f, -0.02920323f, -0.03795938f, -0.01819195f, -0.02493490f, -0.03218000f, -0.01763501f, 
    0.00717888f, -0.05471633f, -0.00876279f, -0.02563201f, -0.00280203f, 0.01899416f, -0.01040024f, 0.01157566f, 
    0.03506873f, 0.01270519f, 0.00223095f, 0.01696849f, -0.04341881f, -0.03045345f, 0.02061838f, 0.01374309f, 
    -0.02936622f, -0.02801270f, -0.01926358f, 0.00423479f, 0.01971091f, -0.04792187f, 0.00052141f, 0.02411617f, 
    -0.05385220f, -0.03076214f, 0.02488582f, 0.01353994f, 0.00113419f, 0.01705892f, -0.03734381f, -0.03302692f, 
    0.04979604f, 0.00341767f, -0.01282750f, 0.02898542f, 0.03391896f, 0.01490752f, -0.01483101f, 0.01171913f, 
    -0.01590504f, 0.02919482f, -0.00409362f, -0.00763661f, 0.02576236f, -0.04423674f, -0.00484694f, -0.03483059f, 
    0.01239260f, -0.05228569f, 0.04554236f, -0.00655892f, -0.01683998f, 0.03385716f, -0.00127814f, 0.03096561f, 
    0.00970933f, -0.02166900f, 0.00663276f, -0.04533145f, 0.00387314f, -0.00936759f, 0.04514139f, -0.02169111f, 
    0.03956217f, -0.03750758f, 0.03288615f, -0.01778061f, 0.02052738f, -0.02161168f, -0.00957147f, -0.00266782f, 
    -0.04546654f, 0.04033035f, 0.02365183f, -0.02796488f, -0.01752828f, -0.04951310f, -0.02665643f, 0.00566647f, 
    0.05033790f, 0.03527486f, 0.02766686f, -0.01432254f, 0.00401918f, 0.03950511f, -0.03264974f, 0.03860571f, 
    0.03899207f, 0.01698817f, 0.01076786f, 0.01154133f, 0.04388993f, -0.03224816f, 0.01072779f, 0.00346055f, 
    0.02056491f, 0.04305175f, -0.03562623f, -0.02772633f, -0.02777343f, -0.04770023f, 0.00044298f, -0.04773646f, 
    0.03689608f, 0.02054514f, 0.00129510f, -0.02876332f, -0.04643980f, 0.00720076f, -0.03136668f, 0.00030070f, 
    0.01273458f, -0.04524394f, 0.02094521f, 0.00998093f, 0.05392602f, -0.04580252f, -0.02475056f, -0.03061432f, 
    0.01512258f, 0.03667593f, -0.01673868f, -0.04618790f, -0.02065319f, 0.03342851f, -0.05659625f, 0.05294719f, 
    -0.00717707f, 0.02219994f, -0.02493638f, 0.03385146f, -0.04937269f, -0.01045863f, -0.01505353f, 0.01440929f, 
    -0.03918081f, -0.01190543f, 0.00980664f, 0.00707954f, 0.00338116f, 0.01882960f, -0.01954186f, -0.01502399f, 
    -0.04979656f, 0.00848083f, -0.02999149f, 0.03452225f, 0.01399458f, -0.03051510f, -0.01331287f, 0.00057457f, 
    -0.03290742f, 0.04190315f, 0.00077522f, 0.02940576f, 0.03907719f, 0.02405252f, -0.03964540f, -0.03833725f, 
    0.01448002f, -0.01131348f, 0.00704646f, 0.02450220f, -0.02092317f, -0.01258056f, 0.03193647f, 0.02638940f, 
    0.01951242f, -0.00055349f, 0.00642313f, -0.04345191f, 0.01134731f, -0.01482440f, -0.00815161f, -0.05133254f, 
    -0.03144352f, -0.01848623f, 0.00453009f, -0.01346535f, -0.03328924f, -0.02870903f, 0.04148236f, -0.05239724f, 
    -0.03696733f, 0.00438552f, -0.02480768f, 0.01221503f, 0.00572470f, -0.02837651f, 0.01786755f, 0.03522026f, 
    -0.00357258f, -0.04553529f, 0.04177827f, 0.00987605f, 0.03904574f, 0.03986849f, -0.04101089f, 0.03559319f, 
    0.00150595f, -0.03228729f, 0.00658226f, 0.00404495f, -0.01174268f, -0.01086853f, 0.00142163f, 0.00965544f, 
    -0.02201425f, 0.00108180f, 0.02749027f, 0.03243760f, -0.03889637f, -0.02753765f, -0.02575746f, -0.05166891f, 
    0.01344871f, 0.04338257f, 0.03428422f, 0.04383657f, 0.03088418f, 0.03256664f, -0.00385851f, -0.00349125f, 
    0.02966928f, -0.04751867f, -0.00195829f, 0.04614733f, -0.00203266f, 0.02762649f, 0.01768941f, 0.04194912f, 
    0.01898133f, -0.03719411f, -0.00304502f, -0.01701521f, -0.03211936f, 0.01865241f, 0.04198354f, -0.03916873f, 
    -0.04670903f, -0.01912663f, 0.00145359f, 0.00651109f, -0.01087623f, -0.04314438f, -0.03024849f, 0.04150395f, 
    -0.03126233f, 0.03787535f, -0.02827352f, 0.00104810f, -0.01366656f, -0.05099606f, -0.04851666f, -0.03576499f, 
    -0.05152294f, -0.04099833f, -0.00545718f, 0.01920478f, 0.02942414f, 0.03951540f, -0.04249529f, -0.04988383f, 
    0.02559146f, -0.04311104f, -0.05141434f, 0.03552041f, -0.04852892f, 0.02416105f, -0.05530522f, -0.02655645f, 
    0.02643333f, 0.01907697f, 0.01576466f, 0.03229411f, 0.02378692f, -0.00769187f, -0.02192825f, -0.03446575f, 
    -0.04340196f, 0.04472424f, -0.01118137f, -0.05458674f, -0.02478058f, 0.02884486f, 0.03921444f, 0.00302860f, 
    -0.05224936f, -0.09332355f, 0.11926866f, 0.23034379f, 0.00804588f, -0.10198113f, 0.02810559f, -0.03623150f, 
    -0.11288212f, -0.19604298f, -0.03189233f, 0.03589135f, 0.04637488f, 0.06833180f, -0.09055334f, 0.07420812f, 
    0.01868081f, 0.16759719f, -0.02082029f, -0.03240437f, -0.01623362f, 0.06231179f, -0.03223113f, -0.01466882f, 
    -0.18909720f, -0.05147224f, -0.04226184f, 0.03499708f, -0.04662613f, -0.01825529f, -0.02645420f, 0.01308432f, 
    -0.15512960f, 0.10626630f, -0.23494495f, 0.12380248f, 0.15024197f, 0.28389755f, 0.18028092f, 0.05518145f, 
    0.18407680f, -0.03939319f, 0.10889103f, 0.03335057f, -0.07708254f, 0.01095719f, -0.01303419f, -0.04453595f, 
    -0.18588531f, 0.22841960f, 0.46882385f, 0.04431403f, 0.02532059f, -0.10556699f, 0.04407682f, -0.09544923f, 
    -0.04602195f, -0.07802605f, -0.18766934f, 0.12247957f, 0.03897639f, -0.10715831f, -0.22629315f, 0.02503900f, 
    0.07985597f, -0.06645129f, -0.04254850f, -0.04311269f, 0.10859102f, 0.04529920f, 0.07602301f, 0.00061767f, 
    0.16811632f, -0.15148261f, 0.41757283f, 0.03891901f, -0.10460025f, 0.10547745f, 0.04113961f, -0.08755145f, 
    0.07303710f, -0.05865216f, -0.06859815f, -0.04452965f, 0.06327984f, 0.19291648f, -0.01473820f, 0.10484981f, 
    0.23594119f, -0.04482747f, 0.08466032f, -0.10008059f, 0.00820428f, -0.06928816f, -0.05111547f, 0.07756921f, 
    -0.21539915f, 0.05150177f, 0.05305022f, 0.03361311f, -0.01162238f, 0.12494960f, 0.02075475f, 0.00324774f, 
    -0.16743822f, -0.01905363f, 0.00596929f, 0.10586984f, 0.38092646f, 0.36938676f, 0.33502907f, 0.26212147f, 
    0.17490675f, 0.05562121f, -0.08208590f, 0.10538889f, 0.05037443f, 0.05601641f, 0.02959623f, 0.05431796f, 
    0.27106786f, 0.32571101f, 0.02624141f, 0.11974338f, 0.12195276f, 0.16618368f, 0.07073917f, 0.11760817f, 
    -0.04995634f, -0.05664162f, -0.03610385f, -0.04067670f, 0.03158828f, 0.01594580f, -0.13517106f, -0.11080201f, 
    0.02947710f, -0.07419254f, -0.06468999f, 0.04824169f, 0.03683503f, 0.02050102f, 0.18204480f, -0.03127277f, 
    -0.01517672f, 0.29342112f, 0.15891437f, 0.24618834f, -0.01678128f, 0.03851801f, 0.09135207f, 0.00549283f, 
    -0.02022152f, -0.02289066f, -0.03979573f, 0.07493279f, -0.14465357f, -0.04024440f, -0.32651687f, 0.11332168f, 
    -0.04750092f, -0.00268280f, -0.04196726f, 0.09706094f, 0.03451079f, -0.09560535f, 0.08704307f, 0.00766096f, 
    0.17741820f, 0.03983835f, 0.11022897f, 0.09084491f, 0.03816086f, 0.01774072f, 0.03106185f, -0.02612126f, 
    0.04442732f, -0.00303683f, 0.01473306f, -0.05837433f, -0.02559007f, 0.41214162f, 0.15521739f, -0.04664933f, 
    0.11196718f, 0.12388603f, 0.04529835f, -0.06666949f, -0.00218890f, -0.02120489f, 0.01208351f, -0.05788041f, 
    -0.10005890f, -0.00073931f, -0.05430774f, 0.16011029f, -0.03840992f, 0.02084324f, -0.02705461f, 0.02471515f, 
    -0.09320106f, -0.08103345f, 0.06595796f, -0.09391047f, -0.22055364f, -0.18234068f, -0.07106214f, 0.07971912f, 
    -0.05195578f, 0.07344819f, -0.10492930f, -0.03397610f, 0.02516176f, -0.05334204f, 0.07523921f, -0.01468452f, 
    -0.02977706f, 0.05047914f, 0.03046905f, -0.00941176f, -0.11051839f, -0.05166478f, 0.06809668f, 0.04824584f, 
    0.08577902f, 0.12160854f, 0.00770282f, -0.05140338f, -0.10911774f, -0.06975475f, -0.10357379f, 0.08614710f, 
    0.00152994f, -0.00691605f, -0.03021333f, -0.08460463f, -0.02815171f, -0.07285053f, 0.06011570f, 0.14285348f, 
    0.19909096f, 0.21594153f, 0.14599097f, 0.18205455f, 0.12330822f, 0.08814093f, -0.00080060f, 0.02245592f, 
    0.05545979f, -0.14556217f, -0.04951449f, 0.03760759f, -0.17700613f, -0.26308683f, 0.15149598f, -0.02035210f, 
    -0.05682140f, -0.11305978f, 0.02809067f, -0.05588844f, -0.01008385f, 0.13401118f, -0.04917066f, 0.04023387f, 
    -0.09588622f, 0.10942980f, -0.07149968f, -0.11203383f, -0.00593135f, 0.09536751f, 0.00714510f, 0.09564869f, 
    -0.01527980f, 0.06884372f, -0.04511174f, 0.01131559f, 0.06319099f, 0.17004906f, 0.17976058f, 0.11492029f, 
    0.03765801f, -0.04179418f, -0.04767498f, 0.09261449f, 0.00476036f, 0.04967102f, -0.11484680f, -0.06533418f, 
    0.15231846f, 0.04062658f, 0.01598936f, 0.07624274f, 0.01931616f, 0.13554224f, 0.08452839f, -0.01879031f, 
    -0.05158620f, -0.07715028f, -0.02150225f, 0.08023472f, -0.08217017f, 0.35051513f, 0.34227997f, 0.03376107f, 
    -0.04726674f, -0.00613507f, 0.07264270f, 0.04388231f, -0.05268056f, 0.01550922f, -0.01242387f, -0.05174277f, 
    -0.13236102f, 0.04383773f, 0.15968393f, 0.05076766f, 0.05180176f, 0.09016475f, 0.09765867f, 0.12942554f, 
    -0.05812372f, 0.08387329f, 0.06195486f, -0.08069059f, 0.15898949f, 0.28998125f, 0.11918302f, 0.02936800f, 
    -0.04909778f, -0.19219525f, 0.01140151f, 0.11089804f, 0.07722472f, 0.11368780f, 0.07311771f, -0.00257687f, 
    0.42727727f, 0.24009599f, -0.05698318f, 0.14681669f, 0.08486152f, 0.02284597f, -0.01907181f, 0.00931645f, 
    -0.09286441f, 0.06019814f, 0.04615441f, -0.04544609f, 0.04492465f, -0.07780290f, 0.03470792f, -0.02703173f, 
    0.06015980f, 0.00261926f, 0.08121890f, -0.01089676f, 0.00340488f, 0.12138693f, -0.14047292f, 0.04422571f, 
    -0.04934181f, 0.00967534f, -0.19167477f, 0.06560871f, -0.04132188f, -0.04064403f, -0.08540888f, -0.03078136f, 
    -0.01612147f, 0.00495756f, 0.06780903f, 0.09682003f, 0.23662640f, -0.00081884f, -0.23904622f, 0.02899368f, 
    0.09045307f, 0.16712683f, -0.04261675f, -0.14680634f, -0.01261669f, -0.00331656f, 0.10094266f, -0.09743905f, 
    -0.01477521f, 0.01454409f, -0.05100484f, -0.05651900f, -0.02561310f, 0.00587228f, 0.03140184f, 0.02766446f, 
    -0.03543770f, -0.04555025f, 0.00572739f, -0.04147094f, 0.01487206f, -0.01329787f, 0.03108692f, -0.03638046f, 
    -0.04095528f, -0.00912959f, -0.03689045f, -0.06119526f, -0.00765919f, 0.01785367f, 0.03769977f, -0.00155890f, 
    0.02569569f, -0.01979024f, 0.03502655f, 0.00602331f, 0.04009825f, -0.03019310f, 0.00097845f, 0.03551314f, 
    -0.04891396f, -0.03617175f, 0.01782459f, 0.02173427f, 0.04286947f, -0.02174091f, -0.02789262f, -0.00611765f, 
    0.01430503f, 0.02320568f, 0.04836034f, -0.04515151f, 0.02645286f, 0.01614069f, 0.01366369f, -0.04526605f, 
    0.03459592f, 0.02234611f, -0.05053412f, 0.02768034f, -0.00254672f, 0.02559458f, -0.05420119f, 0.01505222f, 
    -0.04443583f, -0.01400692f, -0.05410394f, -0.03253504f, -0.01009432f, -0.06404627f, -0.00619374f, 0.04003930f, 
    0.03389359f, 0.01875564f, -0.04628980f, -0.01104018f, -0.05567410f, -0.00191957f, 0.00909016f, -0.00978818f, 
    0.02343337f, -0.01132257f, -0.05329895f, 0.00909171f, 0.01610231f, 0.02839715f, -0.04550653f, -0.03544147f, 
    0.02326901f, -0.05188945f, 0.04470551f, -0.01319643f, -0.00763620f, -0.04893429f, -0.04215420f, -0.04036681f, 
    -0.01826296f, -0.01354004f, -0.02225249f, -0.00814142f, -0.02906547f, -0.00208855f, -0.03056661f, -0.00494645f, 
    0.03432860f, 0.02485901f, -0.05412015f, 0.01117741f, 0.02689864f, -0.00643691f, -0.05064120f, 0.03121781f, 
    -0.04144637f, 0.03051895f, -0.02036359f, 0.00623397f, 0.03944808f, 0.03701582f, -0.02815957f, -0.01556372f, 
    -0.00160315f, -0.03888046f, 0.04605483f, -0.02943616f, 0.03581946f, 0.02009021f, 0.04002165f, -0.04625672f, 
    0.04356354f, -0.04188981f, -0.03883012f, -0.02003502f, -0.01738937f, -0.02781557f, 0.03920421f, 0.01967665f, 
    0.01506474f, -0.02465841f, -0.00820505f, -0.00437544f, -0.05459414f, 0.00761727f, 0.04103609f, -0.04142959f, 
    0.01472389f, -0.05114877f, 0.01957217f, 0.03131305f, 0.03581380f, -0.00914958f, 0.04360908f, -0.01677630f, 
    -0.03891266f, 0.01363540f, -0.03523517f, 0.02809781f, 0.01438006f, -0.05847601f, 0.03816029f, 0.01777777f, 
    0.00444882f, 0.01860382f, -0.02531532f, -0.00556383f, 0.01076235f, -0.02675314f, -0.04661720f, 0.01313793f, 
    0.03970892f, 0.01252189f, -0.05115107f, -0.03890874f, 0.04430713f, -0.02250470f, 0.02028626f, -0.01764390f, 
    0.00468636f, 0.02890325f, 0.04003558f, -0.02383125f, 0.01037298f, 0.00352120f, 0.03269267f, 0.04224827f, 
    0.03871173f, -0.04446986f, 0.01390556f, -0.03293372f, 0.03802683f, -0.04578131f, 0.01420287f, -0.00159342f, 
    0.02102496f, -0.00568031f, -0.05617399f, -0.03402902f, -0.03478932f, -0.05530132f, 0.03810770f, -0.00260269f, 
    0.03536342f, 0.00809652f, 0.02640803f, 0.00879465f, -0.04266535f, -0.03460212f, -0.03955534f, 0.04320820f, 
    0.00773723f, -0.03227265f, 0.02106241f, 0.04956719f, 0.01157846f, -0.00394348f, 0.02121428f, -0.01298659f, 
    0.02564370f, -0.01218276f, -0.01516141f, 0.02217713f, -0.02626382f, -0.04952648f, 0.02808388f, 0.03307420f, 
    -0.04890213f, 0.01422415f, 0.00429399f, -0.03565948f, 0.03348792f, -0.00206772f, -0.01747616f, 0.02690155f, 
    -0.00701025f, 0.00164489f, -0.00616527f, -0.00789021f, 0.00844464f, 0.03610341f, -0.00081687f, -0.02765698f, 
    -0.05861531f, 0.01231052f, 0.01664592f, -0.04014401f, -0.03026950f, -0.00031723f, 0.02422426f, -0.03806058f, 
    0.01871918f, -0.00724628f, -0.01935737f, 0.04371877f, 0.01701265f, 0.00674236f, 0.02673445f, -0.00454201f, 
    -0.00662080f, -0.01945248f, -0.05761004f, 0.01157215f, -0.06020614f, -0.00458619f, -0.01648414f, -0.02373279f, 
    -0.05069709f, 0.00794061f, 0.01033472f, -0.00261695f, -0.01400246f, -0.05282372f, -0.02194007f, 0.03407810f, 
    -0.01533226f, -0.01863338f, -0.04819211f, 0.04689228f, -0.01395689f, 0.01178171f, -0.05184119f, -0.04608314f, 
    -0.02539393f, -0.01989464f, 0.03842239f, 0.02248796f, 0.02887269f, -0.01186104f, 0.03898512f, -0.01757596f, 
    -0.03017157f, 0.00820730f, 0.03194168f, 0.00796842f, 0.04757077f, -0.03414095f, 0.03774945f, -0.03204439f, 
    0.00401723f, 0.00502507f, -0.03411450f, 0.01802091f, -0.01895572f, -0.02938167f, 0.03742895f, -0.03277756f, 
    -0.02703404f, -0.03677845f, -0.04341591f, 0.04238695f, -0.04855536f, 0.02867490f, -0.05706289f, -0.03448166f, 
    0.01923938f, -0.04700261f, -0.03913132f, 0.02149286f, -0.00040420f, -0.01708216f, -0.03176768f, -0.03852600f, 
    0.02863793f, 0.02247348f, 0.04184231f, -0.03165830f, 0.01817800f, 0.00790760f, -0.04727033f, -0.03268168f, 
    0.00575512f, -0.04549340f, -0.04438240f, -0.02554173f, 0.00787485f, -0.02099930f, -0.01879816f, 0.01038088f, 
    0.01079954f, 0.00641120f, -0.01963231f, -0.04770201f, 0.01451591f, -0.04511095f, -0.00483401f, -0.00695023f, 
    -0.00879706f, 0.01258724f, 0.04427567f, 0.01615268f, 0.04048230f, 0.03909770f, 0.02483453f, -0.00633017f, 
    -0.02140945f, -0.02227071f, -0.04154274f, 0.04215977f, -0.05821574f, 0.03293071f, 0.03741015f, 0.02459338f, 
    -0.05276933f, -0.00845865f, -0.05138484f, -0.03461135f, -0.05301688f, -0.00488203f, -0.01294929f, -0.00481728f, 
    -0.00050801f, -0.00071045f, -0.00620391f, 0.01526631f, 0.03370968f, -0.00710111f, -0.04122690f, 0.04279575f, 
    0.03400585f, -0.03942582f, 0.00686108f, -0.02268881f, 0.00193896f, -0.02039823f, -0.05135443f, -0.04211551f, 
    -0.04320255f, -0.00531524f, 0.01382367f, -0.03721032f, -0.04300191f, -0.00588202f, 0.01242162f, 0.03386622f, 
    0.34517992f, -0.25833821f, -0.06235239f, 0.06176121f, -0.08430206f, -0.10321513f, -0.09856132f, -0.11500945f, 
    0.10822566f, 0.22339104f, 0.10806500f, 0.17006059f, -0.02764202f, -0.00076623f, 0.07589222f, -0.02804356f, 
    -0.13775310f, 0.08628178f, 0.03269138f, -0.08647016f, 0.06092426f, 0.00126584f, 0.00005387f, 0.05279003f, 
    0.08142246f, 0.08642925f, -0.02191889f, -0.08507352f, -0.07088891f, -0.07368082f, -0.04005717f, -0.06222697f, 
    0.10768005f, 0.05957942f, -0.08129666f, 0.13565603f, -0.08572626f, -0.21034589f, 0.15234195f, -0.05009240f, 
    0.00935634f, 0.01922790f, -0.02226772f, 0.12523733f, -0.02195482f, -0.05967478f, -0.04879356f, 0.06085509f, 
    -0.06720313f, -0.19372229f, -0.16070347f, 0.33519134f, -0.12938300f, -0.07726208f, -0.06311102f, -0.16538921f, 
    -0.13769215f, -0.01095932f, -0.00446714f, 0.15308113f, 0.08385218f, 0.15384503f, 0.15580568f, -0.00335532f, 
    0.16967279f, -0.06826203f, 0.05268414f, -0.09878817f, 0.20865649f, -0.12132258f, 0.02184635f, 0.12266961f, 
    0.02364219f, -0.35262012f, 0.01404771f, 0.17884693f, -0.20342022f, -0.05432222f, -0.05232083f, -0.03849309f, 
    -0.02594769f, 0.07130805f, -0.11802845f, -0.13058111f, 0.08535950f, 0.05877607f, -0.00969904f, 0.06934731f, 
    0.02219918f, -0.01290390f, 0.05837873f, -0.03859935f, -0.10473047f, -0.01527885f, -0.02669564f, 0.00734754f, 
    0.05276790f, -0.27464277f, 0.07418691f, 0.03470566f, -0.05746560f, -0.00749694f, 0.05883437f, 0.02178604f, 
    0.04778323f, 0.08782153f, 0.02918110f, 0.03861939f, -0.18125843f, -0.05148376f, -0.05590666f, 0.17547552f, 
    -0.11435350f, -0.02020145f, 0.01590440f, 0.00084601f, 0.04445279f, -0.05686732f, -0.09934103f, -0.11198200f, 
    -0.09147859f, 0.01403782f, 0.09422604f, 0.05828413f, 0.07527046f, -0.02348115f, 0.05402467f, 0.06741855f, 
    -0.04861001f, -0.05065504f, -0.05261103f, 0.02270946f, -0.04688261f, 0.24526402f, 0.20957959f, 0.08907683f, 
    -0.03115170f, -0.13813406f, -0.06070610f, -0.05522051f, 0.10745194f, -0.01923449f, -0.03320032f, 0.05285273f, 
    -0.20314349f, -0.21774623f, -0.10010553f, 0.01931106f, -0.02604662f, 0.04853096f, 0.02114743f, -0.06258047f, 
    0.03789202f, -0.14293636f, -0.13252787f, 0.06454773f, 0.05757181f, 0.11318952f, 0.02769245f, -0.13443533f, 
    -0.00569430f, -0.04630815f, 0.05150746f, 0.03526787f, -0.01141643f, 0.05880282f, -0.09212165f, 0.03254806f, 
    -0.01547988f, 0.13939016f, 0.16810274f, -0.01068393f, -0.11193252f, -0.05371809f, 0.12555341f, 0.07613670f, 
    0.06199112f, -0.07521524f, 0.03706710f, 0.02142539f, -0.15443896f, 0.28803739f, 0.29363927f, 0.17744331f, 
    -0.02627528f, -0.05446472f, -0.03896541f, 0.05022882f, 0.02576093f, -0.07114899f, -0.06072443f, -0.05015586f, 
    -0.02480473f, 0.14180908f, 0.07045395f, -0.08541512f, 0.05133035f, 0.10122497f, 0.02082188f, -0.06203288f, 
    0.08475459f, 0.02776483f, -0.00914851f, -0.08653311f, 0.09209950f, 0.21805014f, 0.19355765f, 0.02456633f, 
    -0.06549382f, -0.04235942f, -0.03176533f, -0.03027262f, -0.12889846f, 0.08613112f, 0.08591877f, 0.14776534f, 
    0.05307085f, 0.13940376f, -0.20659624f, 0.01311344f, -0.07505989f, -0.10093167f, -0.07096666f, -0.27306357f, 
    0.10414268f, -0.01048345f, -0.08626761f, 0.29935747f, -0.00556466f, 0.03789216f, 0.03480285f, -0.09626477f, 
    0.04168539f, -0.07731935f, 0.07118002f, -0.00679503f, -0.03541755f, -0.00649544f, -0.08364889f, 0.00074051f, 
    -0.06424612f, -0.00784151f, 0.02302728f, 0.13286938f, 0.07075460f, 0.02097399f, -0.00257047f, -0.04957255f, 
    -0.10654294f, -0.07872528f, -0.05224665f, 0.05625172f, 0.06296547f, 0.01168772f, -0.00944970f, 0.02354982f, 
    -0.05920680f, 0.00468320f, 0.04941169f, 0.06478252f, 0.07812926f, 0.00228403f, -0.07293458f, 0.06063914f, 
    0.20362704f, -0.01850955f, 0.02182893f, -0.00075191f, -0.15162323f, 0.07069771f, 0.05078863f, 0.09345726f, 
    0.05192176f, 0.07435178f, 0.09355683f, 0.06631411f, -0.06827492f, 0.06157546f, 0.10008303f, -0.01319298f, 
    -0.12650543f, 0.15010127f, 0.00543446f, -0.00102994f, 0.02398865f, 0.03198693f, 0.04425939f, -0.03898368f, 
    0.10930963f, -0.08989889f, 0.04524380f, -0.06435013f, -0.10370437f, -0.04752774f, -0.03789742f, 0.02421684f, 
    -0.04942329f, -0.12714747f, -0.11529505f, 0.06159978f, -0.25867665f, -0.04269835f, 0.22536913f, 0.27043691f, 
    0.16018727f, -0.11557178f, -0.11834750f, -0.01292171f, 0.08882230f, -0.02251514f, -0.00028503f, -0.06053367f, 
    0.11227556f, -0.24044453f, -0.07707668f, -0.00450151f, 0.14381090f, -0.17375419f, 0.05297722f, -0.00134434f, 
    0.08719075f, -0.01869524f, -0.06101963f, -0.07357253f, -0.17438713f, -0.05807519f, 0.07029004f, 0.09050246f, 
    0.08617978f, -0.06875511f, -0.03197188f, 0.00369397f, -0.12039999f, -0.05472952f, -0.07298461f, 0.02151844f, 
    -0.06989144f, 0.01616909f, 0.14683610f, 0.01468594f, -0.08361153f, -0.24812700f, -0.14056690f, -0.04272261f, 
    0.15881324f, 0.07657041f, 0.07128918f, -0.06361039f, 0.22870204f, -0.27894545f, 0.20579499f, 0.07542273f, 
    -0.08549637f, 0.04019635f, 0.02185299f, 0.08395644f, 0.02602552f, 0.15414542f, 0.03485718f, 0.02817050f, 
    -0.01644247f, 0.10550685f, 0.11980562f, -0.07606773f, 0.10520095f, 0.02281630f, 0.08339485f, 0.02426916f, 
    0.04013258f, 0.02661069f, -0.03878310f, 0.01521451f, 0.03169331f, 0.03271943f, 0.14838813f, -0.19804889f, 
    0.07224767f, -0.11669903f, 0.12565486f, -0.02536231f, 0.03870492f, -0.00165426f, 0.01474920f, -0.06025281f, 
    -0.00817146f, 0.23692663f, -0.08671761f, 0.06787132f, -0.08430845f, 0.04525232f, -0.05833541f, -0.01751123f, 
    -0.14597757f, 0.08384509f, -0.09756205f, 0.06310669f, -0.01898219f, 0.06976773f, -0.01928116f, 0.11207307f, 
    -0.02215805f, -0.17843719f, -0.09381991f, -0.02840794f, -0.12180078f, -0.06362841f, 0.00435171f, -0.06885347f, 
    -0.26156688f, 0.19686410f, 0.00379271f, 0.15796949f, -0.10998343f, 0.00349210f, 0.01846946f, 0.06802730f, 
    0.03013082f, 0.11217469f, 0.21507642f, 0.03619033f, -0.16708854f, -0.21396174f, -0.10195237f, 0.28472295f, 
    -0.00327380f, 0.05695782f, -0.05526654f, 0.00504280f, 0.04649907f, 0.06129272f, 0.02338826f, 0.02951487f, 
    -0.51357949f, 0.26396799f, -0.52195913f, 0.01201511f, 0.01962905f, 0.03363759f, 0.00012549f, 0.03442738f, 
    -0.11241436f, -0.03555783f, 0.02384161f, 0.03143045f, 0.17168513f, -0.11852166f, 0.13386147f, 0.18689044f, 
    0.05810367f, -0.06475710f, -0.00301205f, -0.02879272f, 0.02063939f, 0.22429700f, -0.13748193f, 0.02628324f, 
    -0.45806101f, -0.11043257f, 0.19730347f, 0.03803155f, 0.14625353f, 0.19949424f, -0.15328224f, -0.03179415f, 
    0.13352969f, -0.04059540f, 0.09952931f, 0.01374383f, 0.03746476f, 0.02957847f, 0.03409213f, 0.06282367f, 
    0.05498026f, -0.04873056f, 0.14479223f, -0.05224449f, -0.09481335f, -0.02217510f, -0.01267745f, -0.03091861f, 
    -0.19197077f, 0.08703237f, -0.07032660f, 0.23900525f, 0.05208182f, 0.03923045f, 0.05300188f, -0.03018331f, 
    -0.01300497f, 0.05148133f, 0.06283657f, -0.01506134f, -0.14205678f, -0.11244756f, -0.06991822f, 0.11274727f, 
    -0.21452636f, -0.18193474f, -0.08417577f, -0.19582589f, 0.00483451f, -0.05850026f, -0.06844629f, -0.01757261f, 
    -0.02747438f, -0.23117454f, 0.13645899f, 0.20821178f, -0.06791279f, 0.10245170f, 0.00737740f, 0.14448246f, 
    0.02281821f, -0.00058790f, -0.06044806f, 0.08774421f, 0.17145678f, 0.13784239f, 0.20166083f, 0.06999778f, 
    -0.08714907f, -0.07907095f, 0.00195028f, -0.11697301f, 0.04073697f, -0.01711927f, -0.00685521f, 0.17454761f, 
    0.01337504f, -0.23806737f, -0.01554015f, 0.11422648f, 0.05209742f, 0.15570337f, -0.09562100f, -0.04736657f, 
    -0.06076463f, -0.01179022f, -0.00765181f, 0.06653806f, 0.04945895f, 0.04169754f, -0.12687942f, 0.14738649f, 
    -0.01410498f, -0.00697027f, -0.07288335f, 0.06977857f, -0.09209809f, 0.00892078f, -0.18726626f, 0.03585523f, 
    0.03216428f, 0.14114563f, 0.34239477f, 0.13365765f, -0.04829575f, -0.00771968f, 0.17963494f, -0.04359416f, 
    0.01026803f, -0.09548709f, 0.01182760f, 0.00079871f, 0.19946657f, 0.42619586f, 0.37728435f, 0.11394797f, 
    -0.04533133f, -0.09714051f, 0.08470520f, -0.08432313f, -0.10772656f, 0.03341921f, -0.11872730f, -0.04423658f, 
    -0.01217458f, 0.23944885f, 0.02046420f, 0.02359389f, 0.01078452f, 0.01987781f, 0.09687603f, 0.05477247f, 
    -0.13356300f, -0.01319465f, 0.02563609f, -0.11435902f, 0.26144511f, 0.33495423f, 0.22611101f, 0.01988839f, 
    0.00102961f, 0.01145482f, 0.01027862f, -0.02525413f, -0.11990165f, 0.08817310f, 0.03782686f, -0.01790164f, 
    0.07315765f, 0.14173825f, 0.06919637f, -0.10962016f, -0.01456030f, -0.20567648f, -0.05771244f, -0.06218702f, 
    0.18709888f, 0.00392692f, -0.04637551f, 0.13247040f, 0.08193849f, -0.00032329f, -0.01269836f, 0.14415677f, 
    -0.04126043f, 0.00427727f, -0.00557204f, -0.04248536f, -0.06367968f, 0.11336233f, -0.05595388f, -0.07332836f, 
    0.16231592f, 0.04617171f, 0.07671250f, 0.12919211f, 0.00684337f, 0.01513879f, -0.05074151f, -0.03173362f, 
    0.00685196f, 0.02094909f, -0.00154590f, 0.08097709f, 0.00797515f, 0.02851596f, 0.00203415f, 0.00399208f, 
    0.01161869f, 0.08497291f, 0.08667324f, -0.06290916f, 0.16817415f, 0.04568281f, -0.07550519f, -0.04984444f, 
    -0.32670856f, 0.20269500f, 0.13416891f, 0.14045724f, -0.04521691f, 0.06473880f, -0.06394837f, -0.10842755f, 
    0.06194270f, 0.11056913f, 0.07534611f, 0.00906117f, -0.34216258f, 0.23801218f, 0.00406900f, 0.05497898f, 
    -0.04395503f, 0.17463663f, -0.12919983f, -0.00889599f, 0.07888591f, 0.04563858f, 0.04404266f, -0.09643127f, 
    0.10532156f, -0.13462089f, 0.18071678f, -0.02805635f, -0.05165903f, 0.05223111f, -0.01732221f, 0.12732545f, 
    -0.04437594f, -0.05875344f, -0.00835781f, -0.04544635f, -0.08604646f, -0.05304760f, 0.22627865f, -0.02317313f, 
    0.05958651f, 0.01430783f, -0.01204389f, -0.02102336f, 0.01513373f, 0.01900410f, 0.07874287f, 0.10313525f, 
    0.13448153f, -0.15261295f, 0.07139024f, -0.02738136f, 0.11877214f, 0.03756892f, -0.15006073f, -0.01025567f, 
    -0.02839865f, 0.03483626f, -0.00198685f, -0.01681284f, -0.13926293f, 0.15191536f, -0.18866372f, 0.18209809f, 
    -0.00429086f, -0.09407052f, -0.10103257f, 0.04830386f, -0.02076631f, 0.01996932f, -0.02489615f, 0.00963319f, 
    -0.04508484f, -0.15295517f, 0.25801718f, 0.27732271f, 0.02772479f, -0.06727245f, 0.05979460f, 0.04720868f, 
    0.19290759f, 0.28238520f, 0.06154712f, 0.03117937f, -0.16051613f, 0.05644468f, 0.18165626f, 0.17124350f, 
    0.02598931f, 0.02517576f, 0.03308642f, -0.00696682f, 0.03561628f, -0.10448463f, 0.11079624f, -0.00155546f, 
    0.11834277f, 0.02785249f, 0.00797966f, 0.06110934f, -0.02806584f, 0.05103265f, -0.01727671f, 0.06779566f, 
    0.03111495f, 0.06729812f, -0.02312931f, -0.00035068f, 0.19997667f, -0.07616729f, 0.17287320f, -0.09154983f, 
    -0.04403004f, -0.13023682f, 0.07500601f, 0.08833686f, -0.07113644f, 0.10252160f, -0.02227188f, -0.07156322f, 
    -0.28655785f, 0.15662393f, -0.05934270f, 0.00694358f, -0.00126527f, 0.09200365f, 0.04501459f, 0.06379352f, 
    0.08250846f, -0.09795521f, 0.06923714f, -0.12072992f, -0.13341628f, 0.02195973f, 0.01390052f, -0.06721711f, 
    0.00439769f, -0.20630802f, -0.12989412f, 0.07397120f, -0.04500812f, -0.04994437f, -0.12504056f, -0.20860983f, 
    -0.20213908f, 0.26041687f, 0.02230795f, 0.29162362f, -0.03411482f, 0.04941474f, -0.01339447f, 0.04931865f, 
    0.06705008f, -0.04782933f, 0.25185394f, 0.14002495f, -0.09416137f, -0.16559848f, -0.21847503f, 0.04437917f, 
    0.09623123f, 0.01047092f, -0.05344317f, -0.13870645f, -0.02917496f, 0.02999971f, -0.00316845f, -0.05088028f, 
    -0.32413349f, 0.12397089f, -0.36266026f, -0.05975820f, -0.05737512f, 0.07994249f, -0.00034654f, 0.12883262f, 
    -0.01615089f, 0.04069804f, 0.14279109f, -0.07277849f, 0.23644480f, -0.03500171f, -0.00208046f, 0.19270250f, 
    -0.13226087f, -0.08675079f, 0.00448465f, -0.03336434f, -0.08087082f, 0.20377558f, -0.07747536f, 0.12513043f, 
    -0.18123525f, -0.07078452f, 0.28934854f, 0.40325990f, 0.23788571f, -0.06457112f, 0.14011176f, 0.12545754f, 
    0.11341802f, -0.09508777f, 0.15710217f, 0.21594945f, -0.09176361f, -0.15969439f, 0.12414477f, -0.11357558f, 
    -0.10598343f, -0.12955534f, 0.09381766f, 0.03641400f, -0.03113461f, -0.08134786f, 0.02300733f, -0.08485662f, 
    -0.19797853f, 0.23015682f, -0.09411199f, 0.26056847f, 0.10169773f, -0.07785645f, 0.01682242f, 0.12753367f, 
    0.14308067f, 0.05957788f, 0.14723614f, 0.03529560f, -0.22830263f, -0.13069481f, -0.21791704f, -0.16849867f, 
    -0.09012036f, -0.06789847f, -0.00739477f, -0.03565304f, -0.07825895f, 0.01832402f, -0.05334137f, -0.07890592f, 
    -0.17662130f, -0.20744163f, -0.11279478f, -0.21512721f, -0.04731161f, 0.06582910f, 0.04980275f, 0.06521641f, 
    0.07834373f, -0.02016137f, 0.04993749f, 0.02508714f, 0.04773614f, 0.17419368f, 0.14508304f, -0.07074150f, 
    -0.00378980f, 0.03250131f, 0.04336574f, -0.05310765f, 0.02602162f, 0.22347051f, 0.08509476f, 0.11051989f, 
    0.03697997f, -0.08631171f, 0.11363493f, 0.05613643f, -0.06240712f, 0.10817973f, -0.06586857f, 0.11513114f, 
    -0.02186591f, 0.02890569f, 0.12475067f, -0.01787463f, -0.14503449f, -0.07914187f, -0.24516833f, 0.22490612f, 
    -0.13658851f, -0.03797161f, -0.10569505f, -0.02499461f, -0.16537124f, -0.12125600f, -0.03694221f, -0.03871666f, 
    -0.16583170f, 0.32028362f, 0.18054487f, -0.05709661f, 0.01131274f, -0.07814492f, 0.01793073f, 0.03030096f, 
    0.01143351f, -0.01192725f, -0.09255759f, 0.00718360f, -0.03461324f, -0.00776388f, 0.16639982f, 0.20501339f, 
    -0.03380833f, 0.02572218f, -0.00237117f, -0.02341252f, -0.10747088f, -0.02349054f, -0.06035374f, -0.20151666f, 
    0.05482168f, 0.14545940f, -0.17397395f, -0.09890577f, -0.08783572f, -0.04421530f, 0.03917795f, 0.07920756f, 
    -0.16671613f, 0.05832779f, 0.04094959f, 0.01537227f, 0.27462405f, 0.56155080f, 0.02493563f, 0.02073438f, 
    -0.00154887f, 0.01766477f, 0.05034083f, 0.17572184f, 0.00624791f, -0.00216476f, 0.09841724f, -0.11311422f, 
    0.16125996f, -0.18629503f, 0.06742369f, -0.22671238f, 0.03790393f, 0.01068980f, 0.04132030f, 0.01815020f, 
    0.01031214f, -0.15225677f, 0.00307851f, 0.05207358f, 0.02890265f, -0.09222960f, -0.10740522f, -0.01464678f, 
    -0.16758041f, -0.00446366f, -0.12708005f, -0.04358567f, -0.11303262f, -0.02610059f, -0.05189230f, -0.06762021f, 
    -0.02627251f, -0.11378514f, -0.00007032f, -0.25546482f, -0.10025782f, -0.02710894f, 0.09904184f, 0.18175109f, 
    -0.00331817f, 0.00127573f, 0.06064674f, -0.06068499f, 0.11049105f, 0.00945736f, -0.06397475f, 0.08729197f, 
    0.05930382f, -0.00354730f, 0.08525325f, 0.08983011f, 0.16682610f, 0.09534073f, 0.08718242f, -0.00545426f, 
    -0.33233416f, 0.27884284f, 0.36580086f, 0.17626159f, -0.07301895f, -0.07429663f, -0.10245977f, -0.04245488f, 
    0.00385675f, 0.11229838f, 0.16777591f, 0.02554067f, -0.38285545f, 0.31582627f, -0.13892940f, 0.09529158f, 
    0.12220868f, 0.08993664f, 0.04098698f, 0.22671498f, 0.07637729f, 0.09091257f, 0.20527139f, -0.08620110f, 
    0.10996883f, -0.14519963f, 0.28033265f, -0.05939980f, -0.05016945f, 0.12477184f, 0.08368231f, 0.07644099f, 
    -0.01166352f, 0.04871352f, 0.08971146f, 0.08229512f, 0.24301520f, -0.35446995f, -0.11669984f, -0.52848375f, 
    0.04313966f, 0.10499104f, 0.12884182f, 0.00411128f, 0.07986283f, 0.10512827f, 0.07275629f, 0.08564691f, 
    -0.26084536f, -0.08703409f, 0.00567945f, -0.05278033f, 0.03609518f, 0.17158875f, 0.16417891f, 0.06437301f, 
    0.06544357f, 0.09553435f, -0.00857402f, -0.02353691f, -0.36810228f, -0.06785095f, -0.17174733f, 0.14005587f, 
    0.12665507f, 0.18860625f, 0.14274983f, 0.09597637f, 0.02317307f, -0.04228547f, 0.06777396f, 0.06257864f, 
    -0.16583829f, -0.13055377f, 0.03222764f, -0.10408174f, -0.10849305f, -0.05910028f, -0.03609720f, 0.11684706f, 
    -0.07262518f, 0.16225177f, -0.04818210f, -0.02433702f, -0.12334009f, 0.04375938f, 0.25961265f, 0.06403470f, 
    0.08877660f, 0.09252967f, -0.06669503f, -0.03231565f, 0.02811169f, -0.01261362f, 0.13876624f, 0.00215456f, 
    0.03965186f, -0.06043954f, -0.10043408f, 0.06270748f, -0.16111392f, -0.00923062f, -0.11862017f, -0.05705754f, 
    -0.07858560f, 0.00352029f, -0.08655733f, -0.12610956f, 0.05686875f, -0.24795263f, 0.15479001f, -0.12473430f, 
    0.00403374f, 0.11753688f, 0.10173545f, 0.05899025f, 0.01530795f, 0.01133305f, -0.02984255f, 0.09783157f, 
    -0.20383130f, -0.17848496f, -0.08293844f, -0.06664452f, 0.11597862f, 0.02364972f, -0.02591269f, -0.03718875f, 
    0.01922107f, -0.25760418f, -0.14410605f, -0.32000014f, -0.09339415f, -0.14130546f, 0.00409932f, -0.03298862f, 
    0.07363115f, 0.16097337f, -0.05322228f, 0.08558304f, -0.02058231f, -0.02987210f, -0.01314598f, 0.00099263f, 
    0.21552706f, 0.11742847f, -0.05881339f, 0.19721332f, 0.05783445f, -0.00782239f, -0.04650410f, -0.02819041f, 
    0.03187952f, -0.05059666f, 0.11710884f, -0.02581711f, 0.10192337f, 0.15019824f, 0.18029743f, -0.05588203f, 
    0.00326576f, -0.06341488f, 0.02346534f, -0.03843314f, 0.08283246f, 0.03039697f, 0.03071895f, -0.12832552f, 
    0.23123784f, -0.08231481f, 0.07339701f, -0.12924747f, 0.14774686f, -0.07610594f, 0.13757440f, 0.09824423f, 
    0.10519591f, 0.07928605f, 0.12423552f, 0.03329599f, -0.00012103f, -0.07975410f, 0.04279883f, 0.04865700f, 
    -0.02603173f, 0.15486577f, -0.04043420f, 0.00513676f, 0.02814921f, 0.07414742f, 0.03623572f, 0.15592189f, 
    0.24256124f, 0.02897479f, 0.04889625f, 0.13505495f, 0.20472378f, -0.05637652f, 0.29938561f, 0.05430428f, 
    0.14868347f, 0.14890544f, 0.06244124f, 0.10326482f, -0.24578622f, -0.07532561f, -0.17827629f, -0.04268279f, 
    0.17412862f, 0.10192560f, -0.06730083f, 0.05033454f, 0.16655937f, 0.02097179f, -0.04990548f, 0.00339651f, 
    -0.05742358f, -0.13524091f, -0.17462803f, 0.05553948f, -0.02762134f, -0.09236018f, -0.02901027f, -0.02542192f, 
    0.18549766f, -0.03735356f, 0.16690697f, 0.18878335f, -0.11845293f, 0.01855595f, 0.00278688f, -0.08530249f, 
    0.02921171f, 0.01769944f, 0.06269873f, 0.00033731f, -0.07538449f, -0.01728330f, -0.04540035f, -0.03453456f, 
    -0.12616344f, 0.19659705f, -0.00615826f, -0.12989905f, 0.01211249f, 0.10812733f, -0.11046348f, -0.07694201f, 
    0.01019800f, 0.03908570f, 0.08104100f, 0.03189495f, -0.12994976f, 0.07674800f, -0.19332211f, -0.15529841f, 
    -0.04000220f, -0.04138055f, -0.07463928f, -0.00545774f, -0.04526937f, -0.02929098f, 0.14768466f, -0.06206508f, 
    -0.07692603f, 0.18618588f, 0.23128338f, -0.02935728f, -0.11068145f, -0.05397562f, 0.08937500f, -0.00255019f, 
    0.05135755f, 0.00688003f, -0.00639722f, -0.07958008f, 0.15221006f, 0.12513423f, -0.11198229f, 0.20137355f, 
    -0.18393694f, -0.11232927f, -0.09066229f, -0.06623486f, 0.02291595f, 0.00088298f, 0.14591171f, 0.09671316f, 
    -0.41513053f, -0.13190170f, -0.03109026f, -0.06618998f, -0.03409412f, 0.04487634f, 0.03417041f, 0.04798865f, 
    -0.07268454f, 0.01113738f, -0.11759518f, -0.09632846f, -0.13332729f, 0.04732877f, -0.16110325f, -0.09548159f, 
    -0.16105808f, -0.01070958f, -0.02520409f, -0.03930967f, -0.01140587f, -0.12019283f, 0.02942992f, -0.08400804f, 
    0.32901081f, 0.15025696f, 0.11838959f, 0.11003737f, 0.13724312f, -0.11545296f, -0.09208054f, -0.01729827f, 
    0.08510444f, 0.06611280f, -0.06208783f, 0.01906107f, 0.17657070f, -0.17163979f, 0.02243320f, -0.20074357f, 
    -0.01766833f, 0.05923732f, -0.06993888f, 0.04923263f, 0.17236489f, -0.00975771f, -0.05890981f, -0.04447730f, 
    -0.04126994f, -0.15278868f, -0.03455588f, -0.09065937f, 0.11785208f, 0.05134384f, -0.06551148f, 0.16209373f, 
    -0.02180608f, -0.04061905f, -0.07055627f, -0.23926389f, 0.01377255f, 0.03344543f, 0.04007342f, 0.13171202f, 
    -0.08378918f, -0.09800705f, -0.07947586f, -0.08884195f, 0.11133558f, -0.04281991f, 0.06891323f, 0.16552195f, 
    -0.12569547f, 0.08086447f, 0.03479178f, -0.14104278f, 0.11743215f, 0.17169204f, -0.05304705f, 0.20025916f, 
    0.06658018f, 0.01167528f, 0.00615608f, -0.01519453f, 0.00526336f, 0.00947046f, 0.07269242f, 0.01972639f, 
    0.15987386f, -0.05220264f, -0.04912083f, 0.05757206f, 0.10034110f, 0.08010042f, 0.18669206f, 0.16729441f, 
    -0.26903421f, -0.17177022f, -0.19580990f, -0.09763083f, -0.10639817f, -0.08833048f, -0.05645774f, 0.03222411f, 
    0.05604673f, 0.09716653f, 0.07005869f, 0.01509045f, 0.27174902f, 0.00067382f, -0.05292981f, 0.26096836f, 
    0.13305187f, 0.13202584f, 0.14620470f, -0.01914695f, 0.09672960f, -0.00975016f, -0.02905873f, 0.14327079f, 
    -0.16729990f, -0.13985680f, -0.17548135f, -0.16810767f, -0.08279889f, -0.02471482f, 0.10938378f, 0.03430216f, 
    0.09694654f, 0.14698461f, 0.02288960f, 0.11524698f, 0.04369362f, 0.11860535f, -0.03212331f, -0.09867016f, 
    0.08396693f, 0.02729996f, 0.03150018f, 0.17593405f, -0.04778986f, -0.07226364f, 0.01303335f, 0.06218316f, 
    -0.47949100f, 0.23774196f, -0.04313727f, -0.05236093f, 0.15725280f, 0.02068550f, 0.06304853f, 0.14972262f, 
    0.04747897f, 0.07597210f, -0.08807321f, -0.05988171f, -0.01980999f, 0.07641336f, -0.08414261f, -0.11212201f, 
    0.00339321f, -0.05614519f, 0.23334511f, 0.05839599f, 0.04333602f, 0.00768934f, -0.07575128f, -0.05356351f, 
    -0.10073096f, -0.02766373f, -0.09333088f, -0.23884074f, -0.07247499f, 0.12529199f, 0.06860232f, -0.02321877f, 
    -0.13810131f, -0.04337023f, -0.08849365f, -0.09170722f, -0.01657696f, -0.17133287f, -0.09465920f, 0.10576603f, 
    -0.03322679f, -0.09419949f, -0.00122508f, 0.02615885f, 0.22870615f, -0.00721209f, 0.05314333f, -0.01446323f, 
    0.09192863f, 0.19145428f, 0.05450701f, 0.00073233f, -0.15593489f, -0.06374430f, -0.06821378f, -0.03939592f, 
    0.01417695f, -0.13768294f, -0.00443346f, 0.05340850f, -0.07661483f, 0.05707340f, -0.06804936f, -0.01336595f, 
    0.15015478f, 0.16048776f, 0.00212960f, 0.14321734f, 0.08118846f, 0.08071858f, 0.09375194f, 0.09179691f, 
    0.07145726f, -0.13262524f, 0.00972436f, 0.36298192f, 0.05714652f, -0.06986247f, -0.02203295f, -0.23421495f, 
    0.16484453f, -0.00448306f, 0.22959988f, 0.17513311f, -0.02234795f, -0.14536117f, 0.09718058f, -0.10036732f, 
    0.08072487f, 0.14544655f, 0.04041791f, 0.04077960f, 0.11929911f, 0.02021950f, -0.15614244f, -0.05567748f, 
    0.03958366f, -0.03602188f, -0.16741903f, -0.11742227f, 0.12703411f, -0.00785539f, 0.06788965f, -0.01804951f, 
    0.03339747f, 0.14370377f, -0.28298193f, 0.15937003f, -0.04614830f, 0.07393456f, 0.08014955f, -0.13180837f, 
    0.07255727f, -0.09502801f, 0.02538523f, 0.07799128f, 0.09449004f, 0.11299574f, 0.03640633f, -0.03358231f, 
    0.06756618f, -0.07925636f, 0.39163387f, 0.26810884f, 0.02939244f, -0.09407034f, -0.04642948f, -0.04970083f, 
    -0.02418919f, -0.00351296f, -0.10896655f, 0.13205673f, -0.01127359f, -0.00821534f, -0.30348146f, -0.20508109f, 
    0.08882185f, 0.09599461f, 0.10995070f, 0.13871723f, 0.29386738f, -0.11671373f, 0.04418050f, 0.17820354f, 
    0.14774525f, -0.03110403f, 0.10122348f, 0.20606117f, -0.04323814f, 0.03764221f, -0.03116794f, -0.01660085f, 
    0.04959084f, 0.08023901f, -0.06384361f, -0.09329996f, 0.05302969f, -0.01015110f, -0.12034962f, 0.14427875f, 
    0.16828737f, 0.07768609f, -0.05359302f, 0.00284103f, -0.09767793f, -0.25184983f, -0.29257113f, -0.17783618f, 
    -0.02053892f, -0.30425328f, 0.62673843f, 0.19088055f, -0.11654935f, 0.02463265f, -0.18708310f, 0.05890895f, 
    -0.08004142f, 0.01391024f, 0.10213102f, 0.13651256f, -0.05299374f, 0.13712944f, 0.09532434f, 0.11839721f, 
    0.14922030f, 0.08639982f, 0.00166515f, 0.14388616f, 0.07019807f, -0.01068137f, 0.19939624f, 0.11304462f, 
    0.09697987f, 0.14608157f, -0.07654635f, -0.09358938f, 0.06063932f, 0.01992655f, 0.02425976f, -0.07219265f, 
    0.04826848f, 0.02932095f, -0.02039020f, -0.01575744f, -0.15687513f, 0.26273760f, 0.10700645f, 0.10358959f, 
    -0.03993978f, -0.21440630f, -0.04344500f, -0.04508236f, 0.04469908f, 0.02504434f, 0.13709804f, 0.05752306f, 
    -0.27759886f, 0.06817783f, 0.03636867f, 0.03767417f, -0.04562842f, -0.07972410f, 0.05948563f, 0.08138503f, 
    0.09412832f, -0.09344868f, 0.01978969f, 0.06707506f, 0.00114973f, -0.17644548f, 0.09902220f, -0.02046132f, 
    0.02905537f, -0.00487621f, -0.17956787f, 0.02519477f, 0.13253354f, 0.03486822f, 0.14064194f, 0.15113506f, 
    0.08184612f, 0.19063915f, 0.00940532f, 0.09731507f, -0.05256392f, -0.03380698f, -0.02026618f, -0.16958703f, 
    0.09147697f, -0.17110398f, 0.02852597f, -0.10343934f, -0.21311909f, 0.12901643f, 0.32485077f, 0.03520997f, 
    -0.11012733f, -0.11567622f, -0.13594574f, -0.09097075f, -0.08079101f, -0.10625724f, -0.05992902f, -0.05487131f, 
    -0.28737056f, -0.11874208f, -0.14175883f, -0.07538021f, -0.07248802f, 0.10506410f, -0.07212939f, -0.03483737f, 
    -0.00223353f, -0.29612464f, -0.10683887f, -0.17947309f, -0.13048224f, 0.25946641f, 0.34292224f, -0.22238219f, 
    -0.19877340f, -0.02117790f, -0.24468648f, -0.02270501f, 0.02099582f, -0.08389961f, -0.02116086f, 0.02601871f, 
    -0.26951787f, 0.13539860f, -0.25753415f, -0.02882977f, 0.15696980f, 0.03227615f, 0.02184864f, 0.00717070f, 
    0.13191658f, 0.12327651f, 0.09374533f, 0.17733261f, -0.21306966f, -0.08996926f, -0.05837794f, 0.17046587f, 
    -0.03327829f, 0.10539535f, -0.08060455f, 0.01789585f, -0.08479525f, -0.22233193f, 0.01986263f, 0.03798414f, 
    -0.04630446f, 0.10948586f, 0.03025123f, -0.02955688f, 0.02012415f, 0.00537570f, 0.07334757f, 0.06341108f, 
    0.06003699f, -0.17398141f, -0.16570523f, 0.03271965f, -0.31199735f, -0.20397918f, -0.44793513f, 0.21353655f, 
    -0.02112753f, 0.04765785f, -0.02564579f, 0.07237648f, -0.05391572f, 0.02036426f, 0.02924286f, 0.29601559f, 
    0.09467140f, 0.39429554f, 0.46997732f, 0.27997577f, -0.25305390f, -0.17367268f, -0.04247163f, 0.31722343f, 
    -0.00554683f, -0.00461065f, 0.00460669f, 0.05057327f, 0.03524936f, -0.08882473f, 0.19182132f, -0.07456174f, 
    0.02754078f, -0.01892055f, 0.08146539f, 0.14162204f, 0.06641537f, 0.07039901f, -0.00879265f, 0.03975888f, 
    0.02360814f, 0.09591894f, -0.09200818f, -0.06469344f, 0.00839890f, -0.00408402f, 0.09504258f, -0.05147236f, 
    0.04766845f, -0.14939259f, -0.16867661f, -0.05072955f, -0.10033371f, 0.20495440f, -0.13903795f, -0.16157420f, 
    0.19473910f, 0.06196819f, -0.03416526f, -0.02920325f, -0.02967355f, -0.11175758f, -0.08085991f, -0.02859719f, 
    -0.39776373f, -0.00935348f, -0.03451142f, 0.07200790f, -0.12978214f, -0.17066154f, -0.00101973f, 0.01578034f, 
    0.18004026f, 0.11437622f, -0.00161076f, 0.01914140f, 0.06136626f, -0.11052460f, 0.26120931f, -0.02036414f, 
    0.13629298f, 0.00736967f, -0.05400771f, 0.18852121f, -0.02193693f, 0.17940278f, -0.03477966f, -0.00447503f, 
    0.29576439f, 0.25834656f, 0.19213985f, -0.16812778f, 0.04973823f, -0.14301136f, -0.10067739f, 0.02655182f, 
    0.01317163f, -0.14956488f, 0.15111265f, 0.05464505f, 0.26930106f, -0.14550872f, 0.35379258f, 0.07040660f, 
    -0.09844127f, -0.10929431f, -0.26712096f, -0.00444183f, -0.00159228f, 0.14786638f, 0.02174175f, 0.07367243f, 
    -0.40439066f, -0.24601640f, -0.00053807f, 0.10284232f, 0.17877065f, 0.16960678f, -0.03184666f, 0.02092540f, 
    -0.05769400f, -0.08090345f, 0.01141989f, 0.13182342f, -0.17803954f, 0.02892293f, -0.11179089f, -0.09533062f, 
    0.09713081f, 0.12620611f, -0.04905686f, 0.04074398f, 0.06645098f, -0.09304197f, -0.01747430f, -0.14401560f, 
    -0.22995956f, -0.03412119f, 0.05553587f, 0.09625425f, 0.06027626f, -0.04868399f, -0.02877468f, -0.05247561f, 
    0.03904403f, -0.08046036f, 0.01950202f, -0.08131887f, -0.10658841f, -0.06519260f, -0.11354032f, -0.06107339f, 
    0.13834825f, 0.10784262f, 0.06477264f, 0.10624164f, -0.04093451f, -0.10963819f, -0.06313808f, -0.05050476f, 
    0.04722142f, -0.03012983f, -0.01711153f, 0.20423737f, 0.01276152f, -0.06587178f, 0.07589192f, 0.04114567f, 
    -0.02419692f, -0.01142744f, 0.02802145f, 0.10127738f, 0.08854796f, 0.30539975f, 0.08590954f, -0.01154351f, 
    0.05753529f, -0.01867860f, 0.17735010f, -0.01156210f, -0.02504632f, 0.05394620f, 0.06374975f, 0.06647969f, 
    0.32630217f, 0.10496390f, 0.32968155f, -0.18742844f, 0.13829765f, -0.08152059f, -0.02145462f, -0.07460748f, 
    0.03319629f, 0.03156005f, 0.06349503f, 0.10342239f, -0.18640499f, -0.14843585f, -0.05918589f, 0.05484156f, 
    -0.02683640f, 0.17120633f, -0.09424237f, 0.09539820f, -0.09464902f, -0.12869450f, 0.05197776f, 0.05495981f, 
    0.21508709f, 0.33726215f, 0.03504249f, -0.09772509f, 0.16610011f, -0.01856365f, 0.15271513f, 0.00110632f, 
    0.04179944f, -0.00913140f, -0.00648352f, 0.02438433f, -0.27078009f, 0.07732068f, -0.22685438f, -0.00966238f, 
    0.18189785f, 0.01926378f, -0.10317480f, -0.11237726f, 0.11945016f, 0.01694500f, -0.16857237f, 0.00391621f, 
    -0.11924911f, -0.07215535f, -0.12318206f, -0.11625699f, 0.05510527f, -0.06350186f, 0.06787361f, 0.03333990f, 
    -0.02064925f, -0.02786652f, 0.19541946f, 0.04559177f, 0.24143018f, 0.18199642f, 0.08577100f, -0.12280283f, 
    0.10839725f, 0.00147626f, 0.12917624f, 0.10829225f, -0.03282563f, -0.05114317f, 0.03564980f, -0.01739246f, 
    0.01810569f, 0.16789211f, -0.14765103f, -0.15738028f, -0.03657617f, 0.05133661f, -0.13857087f, -0.09031990f, 
    0.00774325f, 0.07371914f, -0.03226949f, -0.03921555f, 0.00188480f, -0.15316115f, -0.31824237f, -0.08250086f, 
    0.06312043f, 0.05229421f, 0.02652664f, 0.09006798f, -0.01380211f, 0.04871639f, 0.22578502f, -0.05159695f, 
    0.08929270f, 0.27291644f, 0.17677583f, -0.00348637f, -0.09203832f, -0.03708552f, 0.21216612f, 0.03772772f, 
    0.03734132f, -0.02484796f, 0.06262430f, 0.01474038f, -0.13063964f, 0.03033758f, -0.29410461f, 0.13929813f, 
    -0.01158442f, 0.00714143f, 0.06756452f, 0.01616549f, 0.00784121f, -0.01043343f, 0.13561295f, 0.08404649f, 
    -0.12646490f, -0.32850143f, -0.11662233f, 0.04360849f, 0.09797515f, 0.12241116f, -0.02000127f, 0.01170864f, 
    0.06177855f, -0.01563505f, -0.10692861f, -0.14460930f, -0.25838146f, -0.19890513f, -0.28415596f, -0.22651377f, 
    0.16209905f, 0.21652417f, 0.08027537f, -0.10964626f, 0.04681884f, -0.05756985f, 0.16228753f, 0.06870326f, 
    0.11377893f, 0.05637578f, 0.18627018f, 0.18381377f, 0.12581153f, -0.13089304f, -0.08937520f, -0.02485146f, 
    0.05747229f, 0.00290060f, -0.00319529f, 0.04060303f, -0.63060975f, -0.39388499f, -0.10012995f, 0.03907388f, 
    -0.00670415f, 0.12879209f, -0.00930756f, 0.01371787f, 0.06030528f, -0.05257899f, -0.14326198f, -0.04283746f, 
    -0.14940277f, -0.19932063f, 0.04933425f, 0.03785965f, 0.01422900f, 0.09702324f, 0.13134979f, 0.18506353f, 
    -0.00616987f, 0.08675109f, 0.10690562f, -0.17951703f, -0.02053010f, -0.07422338f, -0.09850465f, 0.13188259f, 
    0.01874094f, -0.03332661f, -0.13665208f, 0.01727377f, 0.07823557f, -0.02403756f, 0.03808178f, 0.08859567f, 
    -0.01145257f, 0.15596628f, 0.03814387f, -0.01163773f, 0.07021669f, 0.04616637f, 0.05864585f, 0.06238335f, 
    0.01532321f, 0.06615661f, -0.05490064f, 0.05704409f, 0.03711014f, -0.10787377f, 0.12331291f, 0.06512216f, 
    0.06791265f, -0.20788272f, -0.01000008f, -0.01715025f, -0.01803318f, 0.02910757f, 0.18913990f, 0.00514949f, 
    -0.11264614f, -0.18892729f, -0.17473038f, -0.04447376f, 0.07249313f, -0.00401907f, 0.03506715f, 0.02480828f, 
    0.04660875f, -0.03699311f, 0.07846390f, -0.17357858f, 0.23337078f, -0.12550738f, 0.05475703f, 0.27140605f, 
    0.14866517f, 0.00838960f, 0.05973847f, 0.02089598f, 0.07631405f, 0.00289827f, 0.00955372f, 0.06434009f, 
    -0.13148798f, 0.03201270f, -0.25177568f, -0.11697739f, -0.00447576f, 0.01698486f, -0.09596579f, 0.03725966f, 
    0.00616134f, -0.02702310f, 0.10978585f, -0.03273139f, 0.18012071f, 0.37507957f, 0.07204293f, 0.11092867f, 
    0.13486694f, 0.01114137f, 0.10536425f, 0.07756475f, -0.15048574f, -0.03677081f, -0.03529216f, -0.02570786f, 
    -0.02132731f, 0.27973759f, -0.05034570f, -0.07240030f, 0.02626421f, 0.12411935f, 0.04066555f, 0.11178359f, 
    -0.01489410f, 0.05970959f, 0.00261739f, -0.03716321f, 0.17441855f, 0.16629055f, -0.03131904f, -0.17050609f, 
    -0.14126086f, -0.12236863f, 0.07401664f, 0.00448155f, 0.19340046f, 0.14327607f, -0.01803985f, -0.08497306f, 
    0.12021384f, 0.05553266f, -0.23829703f, -0.15050817f, -0.12310030f, 0.13826713f, 0.15618283f, -0.10574713f, 
    -0.08689602f, -0.05477993f, -0.07720805f, -0.07919852f, -0.22600132f, 0.00091785f, -0.29716450f, -0.04241692f, 
    0.06436648f, -0.00685645f, 0.04843316f, 0.00202739f, 0.02319658f, 0.04083715f, -0.15785953f, -0.01769798f, 
    0.03548818f, 0.17718397f, -0.02044432f, 0.00385215f, 0.00044485f, 0.10739378f, -0.02650386f, -0.00628882f, 
    -0.07881597f, -0.06587068f, 0.04148181f, 0.03215283f, -0.23693566f, 0.16566397f, -0.17382492f, 0.12059104f, 
    0.06685883f, 0.05609985f, -0.14251454f, 0.07991587f, -0.10367179f, -0.01470384f, 0.00616030f, 0.06099907f, 
    0.26810750f, 0.09040549f, -0.02964661f, -0.03244447f, -0.03747382f, -0.05413560f, -0.10359342f, -0.09405404f, 
    0.16988350f, 0.38497224f, 0.12383996f, 0.36541921f, -0.14880142f, 0.06139265f, -0.13435224f, 0.02160551f, 
    0.05558551f, -0.03043262f, 0.01351140f, -0.05281949f, -0.22914360f, -0.12672874f, 0.06802857f, -0.06299271f, 
    -0.06439778f, -0.01751459f, 0.05055557f, 0.16325130f, -0.03942082f, -0.01501058f, 0.03627105f, -0.02137018f, 
    0.18240303f, 0.07173400f, 0.16067408f, 0.16842306f, -0.23486124f, -0.22247492f, 0.02509339f, 0.10219768f, 
    -0.07920328f, 0.04281731f, -0.01880406f, 0.06751360f, 0.01272204f, 0.04866813f, 0.05843421f, 0.12414572f, 
    0.27416253f, 0.00668354f, -0.31812352f, 0.33519682f, 0.01813051f, -0.06204093f, 0.03131646f, -0.11610734f, 
    0.00811764f, 0.10025133f, 0.08472530f, 0.12381290f, -0.12723857f, 0.13606101f, 0.15714379f, -0.16358572f, 
    0.06826759f, 0.07659891f, -0.23281059f, -0.14662603f, 0.06367130f, -0.05558495f, 0.09401870f, -0.11161111f, 
    -0.23357849f, 0.19892475f, -0.14309995f, 0.01729893f, 0.07211993f, -0.00974706f, -0.17367440f, 0.03656767f, 
    -0.15045337f, 0.08131451f, 0.06218033f, 0.04522790f, 0.00887348f, 0.14014113f, -0.20376524f, 0.11585876f, 
    -0.00618385f, 0.08092280f, -0.11885662f, -0.28020984f, -0.08383101f, 0.03604832f, -0.15342720f, -0.13754065f, 
    -0.11928907f, -0.18209800f, -0.03776239f, -0.26677483f, 0.10520522f, 0.02345008f, 0.00352265f, 0.13438120f, 
    0.08143335f, 0.05398919f, 0.04519436f, 0.05668535f, -0.14877585f, -0.22548123f, -0.02908657f, 0.11871646f, 
    -0.05788606f, -0.01698428f, 0.12779611f, -0.00920952f, -0.03970043f, -0.05858612f, -0.17518273f, -0.08166848f, 
    -0.13434745f, -0.26648322f, 0.07943858f, 0.12535000f, 0.00003381f, -0.07321198f, 0.05706254f, 0.02205764f, 
    -0.00072930f, 0.00243981f, -0.07185698f, -0.01738580f, 0.07160414f, 0.07656255f, 0.15255307f, 0.20251311f, 
    0.08474830f, 0.04834668f, 0.04722274f, 0.07466154f, 0.10633741f, -0.02493021f, 0.11257824f, 0.12959939f, 
    -0.07562264f, -0.24133883f, -0.23058745f, -0.00541339f, 0.01342702f, 0.06676678f, 0.06708654f, 0.04412225f, 
    0.01355575f, 0.02217546f, 0.04271710f, 0.07651187f, -0.23300837f, -0.09697387f, -0.12721972f, -0.22983602f, 
    -0.04847322f, -0.11318877f, 0.10543713f, -0.06217356f, -0.05901463f, 0.06042549f, -0.13391508f, -0.01149784f, 
    0.13684291f, -0.07003085f, 0.12433534f, 0.13245901f, 0.04125746f, -0.06870806f, 0.01698600f, 0.08842824f, 
    0.00742387f, -0.04696780f, -0.11813758f, -0.01129273f, -0.12309664f, -0.04246738f, -0.03617427f, 0.21974276f, 
    0.12573312f, -0.10165306f, 0.10190545f, 0.08624062f, -0.02581143f, -0.02810243f, 0.06576148f, 0.15147807f, 
    0.10230254f, 0.13300732f, 0.24296665f, 0.18253279f, 0.05146872f, -0.18754423f, -0.13008709f, -0.01203932f, 
    -0.05978779f, -0.00057429f, 0.03018924f, -0.18347560f, -0.44922689f, 0.27235430f, 0.39881593f, 0.14935713f, 
    0.01296401f, -0.05207412f, 0.05668534f, 0.02973268f, -0.19802643f, 0.04186991f, -0.00580671f, 0.05256949f, 
    0.02661425f, 0.19488257f, -0.05783392f, 0.27747074f, 0.09571724f, 0.16505645f, 0.10309149f, 0.08384196f, 
    0.13918036f, 0.07184768f, 0.16085462f, 0.19004448f, -0.02423891f, 0.01638564f, -0.07346289f, -0.17763488f, 
    -0.00001175f, -0.13302054f, -0.02256370f, 0.02165608f, -0.11332183f, 0.12177461f, -0.02137346f, -0.20058426f, 
    -0.10353482f, -0.15265329f, -0.12379345f, 0.25571427f, 0.00147474f, -0.11204642f, 0.08171302f, -0.16876669f, 
    0.00447910f, 0.15942319f, 0.04014351f, 0.07841414f, 0.15640672f, -0.11747906f, -0.14178388f, -0.01408056f, 
    0.05620800f, 0.09700259f, 0.05486025f, -0.04921439f, 0.10440799f, -0.01357267f, -0.01620873f, -0.24594769f, 
    0.40574536f, -0.07560432f, 0.01147374f, -0.02013682f, -0.01423856f, -0.08870567f, 0.07050590f, 0.04526001f, 
    0.15745439f, 0.09047057f, 0.08888173f, -0.00135847f, -0.05112344f, -0.08456417f, 0.06740218f, 0.11806335f, 
    -0.02340370f, 0.06133500f, 0.03169927f, 0.13396759f, 0.10046806f, 0.03228813f, 0.07804280f, -0.06316872f, 
    0.03788252f, 0.15491016f, 0.22251990f, 0.03436271f, 0.10336907f, -0.14555237f, -0.21931854f, 0.09766286f, 
    -0.03055359f, 0.05668765f, 0.17978898f, -0.17620471f, 0.01239824f, 0.06629655f, 0.14005136f, 0.49965498f, 
    0.20142084f, 0.00976941f, 0.14324984f, -0.02753761f, -0.01243748f, 0.03560454f, -0.01694476f, -0.00988819f, 
    0.82458568f, -0.08536644f, -0.01583970f, 0.06430404f, 0.13453923f, 0.05942081f, -0.01617793f, 0.14311796f, 
    -0.14521699f, -0.22437896f, 0.00076000f, 0.19512762f, -0.04017805f, -0.00713378f, 0.06567547f, 0.19125262f, 
    0.09114996f, 0.06135807f, 0.11417076f, 0.03148627f, 0.15851989f, 0.00838523f, -0.14744194f, 0.00677801f, 
    -0.26993406f, -0.05393168f, 0.17490986f, 0.11389737f, -0.05817986f, 0.00800299f, 0.09993927f, -0.08446255f, 
    0.18305723f, 0.15995499f, -0.05010162f, -0.02577074f, -0.46978563f, 0.20536529f, 0.03061079f, 0.01083096f, 
    -0.05339743f, 0.05492957f, -0.00392466f, 0.12102174f, -0.05668240f, -0.08573911f, -0.04044278f, -0.00707466f, 
    0.02146867f, -0.04478233f, 0.01056632f, -0.19472420f, 0.00471410f, -0.03298398f, -0.07019965f, -0.03911058f, 
    -0.02147418f, -0.05503460f, -0.00115639f, -0.07217259f, -0.23552762f, 0.19361463f, 0.26526406f, 0.08554341f, 
    -0.04770094f, -0.13275185f, 0.09384774f, -0.12495624f, -0.17293715f, 0.09081117f, -0.08364906f, -0.03597602f, 
    -0.09666147f, 0.16058983f, 0.02890000f, 0.11213969f, -0.15229261f, 0.03987495f, 0.01970928f, -0.07465491f, 
    0.13029879f, 0.35616207f, 0.15621620f, 0.37923792f, 0.06469978f, 0.00845709f, -0.15613109f, 0.04860011f, 
    0.23722970f, -0.26459730f, -0.08665524f, -0.09291420f, -0.16231705f, -0.26369464f, -0.25288352f, -0.22228245f, 
    -0.15945335f, -0.20330384f, 0.02670885f, -0.09511640f, -0.08062078f, -0.04965824f, 0.05221980f, 0.02041866f, 
    0.10219993f, 0.12637517f, 0.09145166f, 0.00496103f, 0.08177291f, 0.05769597f, -0.18834063f, 0.08727160f, 
    0.04818977f, 0.17253624f, 0.09563420f, -0.03172547f, -0.06691951f, 0.02335439f, 0.08116110f, 0.04977277f, 
    -0.02929377f, 0.18511638f, 0.00971932f, -0.15120745f, 0.03013264f, -0.07672911f, -0.08045731f, -0.07328261f, 
    -0.03983163f, 0.03616815f, 0.12729722f, 0.07567660f, 0.00447491f, -0.12422950f, -0.15820222f, 0.00882457f, 
    -0.01501833f, -0.08814617f, 0.00098078f, 0.10910541f, -0.17244887f, 0.10205902f, -0.06808334f, -0.16140799f, 
    -0.12572937f, 0.17057317f, 0.02744091f, -0.14640337f, 0.09505615f, 0.07869603f, -0.01778700f, -0.00300155f, 
    -0.19689804f, -0.13729782f, 0.11608356f, 0.09494188f, 0.02119462f, -0.02973312f, -0.02182779f, -0.06415754f, 
    -0.15964261f, 0.14666393f, 0.02718223f, -0.07000257f, -0.41639161f, -0.38938308f, -0.29875079f, -0.24778657f, 
    0.21678208f, 0.18388946f, 0.13497010f, 0.04338491f, 0.05385452f, 0.00964721f, 0.15100195f, -0.07349788f, 
    0.08474132f, 0.18554507f, 0.06162648f, 0.00250481f, 0.17282560f, 0.08250522f, -0.01672976f, -0.11551396f, 
    -0.00940904f, 0.00490123f, 0.10552412f, 0.03015196f, -0.01997830f, 0.08362100f, -0.01971286f, -0.03316101f, 
    0.13302870f, -0.09344432f, -0.15644962f, 0.00654821f, 0.01460030f, -0.12692206f, 0.09828798f, 0.00645462f, 
    -0.01873197f, -0.08773595f, 0.07026540f, 0.00858528f, 0.04417768f, -0.13816483f, 0.17734033f, 0.23094521f, 
    0.07058822f, 0.15645981f, 0.09054007f, 0.04035443f, 0.06358248f, 0.27539414f, 0.03905579f, 0.23549624f, 
    0.18772596f, 0.02016534f, -0.14139397f, -0.06326050f, 0.09594125f, 0.08494551f, 0.10327862f, -0.04144727f, 
    -0.04647636f, 0.00629588f, 0.05007822f, 0.16940710f, -0.10136291f, -0.19264087f, 0.11555705f, 0.14215979f, 
    0.18231693f, 0.03933578f, -0.13395961f, -0.44109982f, -0.15951173f, 0.13383332f, 0.01614358f, 0.13861680f, 
    0.21071693f, 0.11256324f, -0.04786399f, 0.14339697f, 0.07437249f, 0.04814078f, -0.09051052f, -0.06957827f, 
    0.02850559f, -0.10870970f, -0.13015912f, 0.05480661f, 0.18955697f, -0.25696284f, -0.00461430f, 0.14689365f, 
    0.10264521f, -0.02775342f, 0.05741476f, 0.00440322f, -0.06374687f, 0.01678746f, 0.04666194f, 0.16083878f, 
    -0.09826100f, -0.24317476f, -0.10336106f, 0.01324665f, 0.04788938f, -0.03127022f, 0.08198857f, -0.03917992f, 
    -0.33393255f, -0.18170652f, -0.21220084f, 0.02856143f, -0.08929317f, 0.07626306f, -0.03671710f, 0.19187550f, 
    0.07024083f, 0.03246092f, 0.09336346f, -0.03256679f, -0.12274570f, 0.00477773f, -0.03799101f, 0.08836972f, 
    0.05837190f, -0.07606236f, 0.02404565f, -0.15591504f, 0.04153604f, 0.14704771f, 0.18644759f, 0.04755987f, 
    0.10026886f, 0.07522791f, 0.17421669f, 0.23945948f, -0.14454333f, 0.10019888f, -0.02665672f, -0.00403252f, 
    0.10043646f, 0.02232671f, 0.10705489f, 0.11479128f, -0.18864881f, -0.08665649f, -0.04691732f, -0.47482878f, 
    0.06904171f, 0.05012898f, -0.05005186f, 0.05570335f, -0.00814339f, -0.03607409f, 0.17183718f, -0.08739228f, 
    -0.14860225f, 0.07941183f, -0.05383819f, 0.05126593f, -0.07269041f, 0.00082785f, -0.33080760f, -0.26156250f, 
    -0.04599330f, 0.18257497f, 0.12522492f, -0.07375024f, 0.00297543f, -0.05714143f, 0.02735588f, -0.29838896f, 
    0.17680807f, 0.35440034f, 0.34443155f, 0.20205067f, 0.15923674f, -0.15840480f, 0.05341750f, -0.21692547f, 
    0.00483395f, -0.02078408f, -0.03355847f, 0.07060879f, -0.08196247f, -0.16782585f, 0.08958347f, -0.21207431f, 
    0.04297731f, -0.14416605f, 0.03851312f, 0.19042803f, 0.19950286f, -0.02891306f, 0.03019436f, -0.13034144f, 
    0.01382762f, 0.11431105f, 0.11668302f, 0.07302311f, 0.14538580f, -0.18115395f, -0.29989481f, 0.00790486f, 
    -0.31058776f, -0.10420876f, -0.05064312f, -0.38796759f, 0.41294381f, 0.03394371f, -0.25060523f, -0.16584460f, 
    -0.02485625f, 0.10688832f, 0.21488686f, -0.05925175f, -0.06488113f, 0.09923235f, -0.05422877f, -0.03255469f, 
    0.15355937f, -0.42011142f, 0.09678288f, -0.18226402f, 0.00724297f, 0.16653089f, -0.09901261f, -0.09760076f, 
    0.08844499f, -0.16255546f, 0.06949522f, 0.20005549f, 0.09429115f, -0.31035286f, -0.02411538f, 0.21185631f, 
    0.10317621f, 0.04645623f, 0.09529250f, 0.01102974f, 0.15321776f, 0.01067815f, -0.10968396f, -0.05808888f, 
    0.14426076f, 0.20079017f, 0.04413480f, 0.13535722f, 0.02454571f, 0.04653022f, 0.08113552f, 0.13208641f, 
    0.11496117f, 0.19551149f, 0.01765468f, 0.05335014f, -0.19107579f, 0.20098233f, -0.15880845f, -0.05566292f, 
    -0.03569497f, 0.18090175f, 0.00584778f, -0.18845432f, -0.00503251f, -0.11377899f, 0.11072958f, 0.12229871f, 
    0.07985977f, -0.25498763f, -0.16553897f, 0.11043500f, 0.24104659f, 0.23068440f, 0.24099067f, 0.02146282f, 
    -0.17428130f, 0.00056843f, 0.05664718f, -0.12980837f, -0.11079305f, -0.12602912f, -0.03790264f, 0.12900616f, 
    -0.00470329f, -0.07365672f, -0.11615112f, 0.07365078f, -0.16724271f, -0.15965988f, -0.27891636f, -0.12932140f, 
    0.01683082f, -0.04256618f, -0.01604421f, 0.04161606f, -0.00882928f, 0.02657718f, 0.00427388f, 0.02260839f, 
    0.02494403f, -0.04001573f, -0.05505510f, 0.01881764f, 0.04966530f, -0.03526055f, -0.01628956f, 0.01260409f, 
    0.05179374f, 0.03028023f, 0.04268518f, -0.01857208f, -0.02117936f, -0.00557127f, 0.01905829f, 0.01925526f, 
    -0.02816526f, -0.00470899f, -0.01438711f, -0.01129462f, -0.01664833f, 0.03182492f, -0.04175816f, 0.01553231f, 
    -0.04661546f, -0.01531385f, -0.03877082f, -0.06137538f, -0.03899409f, 0.04376622f, 0.00320081f, -0.02064538f, 
    -0.00183023f, 0.01948405f, 0.00785177f, 0.00071121f, 0.00012268f, 0.03556170f, 0.02673432f, 0.03322676f, 
    -0.05793854f, 0.01814086f, -0.03719086f, 0.03692995f, 0.03557589f, -0.00829391f, -0.00840085f, -0.03870620f, 
    -0.02441314f, 0.03553055f, 0.02525144f, -0.02910471f, 0.01750021f, -0.01235554f, -0.02238785f, 0.01313267f, 
    -0.00514690f, 0.04132241f, -0.05602800f, -0.00416288f, -0.00588577f, 0.02859208f, 0.00963696f, -0.02782716f, 
    -0.01876802f, 0.02784751f, 0.02315494f, -0.04022745f, 0.00968598f, -0.05632152f, -0.03621511f, 0.04072459f, 
    -0.04616910f, 0.01418831f, -0.05053835f, -0.04861748f, -0.04245145f, 0.05069550f, 0.02426551f, 0.01073037f, 
    0.00928864f, -0.01516612f, -0.05664791f, -0.05623960f, -0.03121339f, 0.04220117f, -0.00457584f, -0.00840092f, 
    0.03758401f, 0.01757463f, -0.03903652f, 0.03017611f, 0.01672867f, 0.03032178f, 0.04622740f, 0.03297116f, 
    -0.01607227f, -0.02859304f, -0.01481036f, -0.00220255f, -0.02265117f, -0.02421505f, -0.02746276f, -0.03190775f, 
    -0.04669381f, -0.03288113f, 0.00289185f, -0.04630673f, -0.05737512f, -0.04194256f, 0.02402753f, 0.03156128f, 
    -0.01053544f, -0.04614813f, -0.01799438f, 0.03281021f, -0.01046273f, -0.02028530f, 0.02706044f, -0.03518059f, 
    0.00582585f, 0.00608011f, 0.03492815f, -0.03472107f, 0.03992095f, -0.03860066f, -0.04447567f, 0.03766847f, 
    0.03943420f, -0.03005041f, 0.03869274f, -0.02944467f, 0.01935275f, 0.04537389f, -0.04169178f, 0.03076787f, 
    -0.03659632f, -0.00389459f, 0.02339256f, -0.04270840f, 0.01636389f, -0.02965379f, -0.04592002f, -0.04124917f, 
    0.03138237f, 0.02383343f, 0.01347247f, -0.02228490f, -0.01775546f, 0.00447707f, 0.01196899f, 0.02039168f, 
    -0.05106902f, -0.03230950f, -0.04753970f, 0.03611009f, -0.04532202f, -0.00984341f, 0.00889887f, -0.04975676f, 
    0.04973499f, -0.02536664f, -0.04223770f, 0.02072407f, -0.01454779f, -0.04542875f, -0.01763925f, 0.00617324f, 
    0.04319982f, -0.05073619f, -0.06029902f, 0.00894679f, 0.02083587f, -0.02250933f, 0.02123241f, -0.03786574f, 
    -0.00184829f, -0.02134193f, -0.02342646f, -0.01515588f, -0.00101509f, 0.02363300f, 0.02795046f, 0.02407003f, 
    0.02430583f, -0.01936545f, 0.00538058f, -0.04691555f, 0.03015612f, 0.03041662f, -0.01558949f, 0.03063922f, 
    -0.05872176f, 0.03365673f, 0.00628484f, -0.02220037f, -0.02508867f, -0.05280407f, -0.00943246f, 0.00486279f, 
    -0.00099102f, 0.01327008f, -0.04024781f, -0.00109151f, -0.05823907f, -0.00837987f, 0.00545418f, 0.02919451f, 
    -0.00944387f, -0.02641129f, -0.01050222f, 0.04390518f, -0.05165222f, -0.00621649f, -0.03876443f, -0.04715421f, 
    -0.05523303f, -0.05080288f, 0.03459596f, 0.03143105f, -0.01101286f, 0.02781297f, -0.05404917f, -0.02842645f, 
    -0.03374590f, -0.04302830f, -0.01529620f, 0.00179585f, -0.00668578f, -0.01399314f, -0.01073114f, -0.03526307f, 
    0.01801524f, 0.04880687f, -0.03378219f, -0.01703621f, -0.03552611f, 0.03787793f, 0.02873643f, -0.01136930f, 
    -0.04216317f, 0.00633047f, -0.00467089f, 0.01328114f, -0.01004786f, 0.03339555f, 0.00605228f, 0.04180698f, 
    -0.05819324f, -0.05095918f, -0.00898668f, -0.01541485f, -0.01854450f, -0.00870346f, -0.00831057f, 0.03504467f, 
    -0.01100179f, 0.03958539f, -0.03654528f, 0.02983147f, -0.00443363f, -0.02294445f, 0.03514583f, -0.04965620f, 
    -0.00133003f, -0.02020243f, -0.02267682f, -0.00529802f, -0.00356010f, -0.01577270f, -0.05720760f, -0.02874907f, 
    -0.01803013f, -0.02399477f, -0.04265593f, -0.02041536f, 0.02616213f, -0.02906104f, -0.03197850f, -0.02178299f, 
    -0.03489901f, 0.03863171f, -0.04094869f, -0.04963081f, -0.04587165f, 0.01263987f, -0.02360816f, 0.03700586f, 
    0.05168580f, -0.03443156f, -0.05126974f, -0.02956667f, 0.04161381f, -0.04367224f, -0.03336091f, 0.03377949f, 
    -0.04465516f, 0.02962300f, -0.00782088f, -0.02350288f, 0.03830392f, -0.00853843f, 0.03008609f, 0.00887510f, 
    -0.01464087f, -0.00790516f, 0.02525211f, -0.03992252f, 0.04257154f, -0.01115134f, 0.00803901f, 0.02303291f, 
    -0.00735229f, -0.01216851f, 0.01872938f, 0.01917619f, -0.00065033f, -0.05129245f, 0.04006369f, -0.00586087f, 
    -0.01033149f, -0.04055852f, -0.00953526f, -0.03370478f, -0.02557490f, 0.02911240f, 0.02572155f, -0.00606784f, 
    0.03090117f, 0.00042840f, -0.03369640f, 0.01397737f, -0.05475809f, 0.01700390f, -0.00852653f, -0.03124150f, 
    -0.05260439f, -0.00539521f, -0.00328286f, -0.02778980f, -0.02276009f, -0.00543087f, 0.00257503f, 0.01555522f, 
    -0.03938654f, -0.03676606f, -0.00833113f, -0.00680146f, -0.03573166f, -0.00125032f, -0.03602987f, 0.03423489f, 
    -0.04384030f, 0.02904083f, -0.03806759f, -0.04206568f, -0.05136279f, 0.02279230f, 0.03817139f, -0.03579963f, 
    0.00316300f, -0.04455308f, -0.02609829f, 0.03886500f, -0.03089243f, -0.00686211f, -0.03475828f, -0.00455552f, 
    0.01309575f, -0.06105956f, -0.06049377f, 0.03790719f, -0.04737399f, -0.04042247f, -0.03215844f, 0.00986659f, 
    -0.00767321f, 0.01347467f, -0.00933283f, -0.00720873f, 0.01233485f, 0.03245204f, -0.04174869f, -0.01274150f, 
    0.01322431f, -0.01335132f, -0.00862847f, 0.02921196f, -0.05186608f, 0.03633880f, -0.00340770f, 0.04468416f, 
    -0.05306870f, 0.01876111f, -0.03113455f, 0.01316659f, 0.03730268f, -0.04062321f, -0.01151343f, 0.00854047f, 
    -0.04742022f, -0.05526026f, 0.00776216f, -0.01413280f, 0.03061101f, -0.00838154f, -0.05183512f, -0.03267265f, 
    0.02650416f, -0.03712595f, 0.03097042f, -0.02058799f, 0.01279801f, 0.03877347f, 0.01375281f, -0.03226139f, 
    -0.03539874f, 0.03583763f, -0.05258875f, 0.03230765f, -0.02365679f, 0.00055924f, 0.00352564f, 0.02857958f, 
    0.04253655f, 0.00350022f, -0.00907397f, -0.02202922f, -0.03588625f, -0.00878191f, 0.01885534f, -0.05411664f, 
    -0.04543050f, -0.02060485f, -0.04407008f, -0.00771961f, 0.00046956f, 0.01905390f, -0.02026201f, -0.05566336f, 
    0.00334746f, -0.04705437f, -0.02812091f, 0.02269587f, 0.03656140f, -0.04602935f, 0.03993565f, -0.03429750f, 
    0.01227182f, 0.00141344f, -0.01318150f, -0.01968963f, -0.05686079f, -0.04345099f, 0.01925850f, -0.03703656f, 
    0.01157569f, -0.05185403f, 0.02917022f, -0.01082519f, -0.00828405f, 0.03686861f, 0.03751098f, 0.01805618f, 
    -0.02364247f, -0.01392825f, 0.00134335f, -0.02983886f, -0.01124766f, -0.01407534f, 0.00315253f, 0.01043004f, 
    0.03342008f, 0.02602867f, -0.03237118f, -0.05112918f, 0.01172057f, 0.02683991f, -0.04382657f, -0.04746394f, 
    0.03533100f, 0.00687905f, -0.00977420f, -0.01193540f, -0.03882905f, 0.03184124f, -0.01499789f, 0.01177114f, 
    -0.03249952f, -0.02753408f, -0.03847957f, -0.00265981f, -0.01463265f, -0.03852266f, 0.04325748f, 0.01290856f, 
    -0.03303759f, -0.02059572f, -0.05386475f, -0.03722086f, 0.03606754f, 0.01820679f, -0.03974856f, -0.00414967f, 
    0.00043490f, 0.02359647f, -0.04610420f, -0.00567106f, -0.03496841f, -0.03020086f, -0.02637549f, -0.00433764f, 
    -0.03036947f, -0.05526207f, 0.04032290f, -0.04380461f, 0.01148027f, -0.03851698f, -0.01022878f, -0.01558840f, 
    0.01386457f, 0.00126453f, -0.05370094f, 0.02447648f, -0.03536581f, -0.03813477f, 0.00507187f, 0.03499931f, 
    -0.01684354f, -0.04509830f, 0.00064461f, -0.05627682f, 0.02780194f, -0.04775199f, 0.00891825f, 0.04319622f, 
    -0.01542560f, -0.04841180f, -0.04121348f, -0.01043760f, 0.00552730f, 0.03207133f, 0.02082885f, 0.01887901f, 
    0.04437970f, -0.02521013f, 0.02164502f, 0.01684488f, 0.00077264f, 0.01997869f, 0.02600612f, 0.00373785f, 
    0.01114014f, 0.01842427f, 0.03342172f, -0.03444900f, 0.00175926f, 0.01818981f, -0.03368158f, -0.05127035f, 
    0.00689715f, 0.02677643f, 0.03304258f, 0.02812513f, -0.00846104f, -0.03786142f, -0.03475273f, -0.03814613f, 
    -0.00688960f, -0.03222894f, -0.04585098f, 0.02446074f, -0.02207619f, 0.02169641f, 0.02246043f, -0.05027017f, 
    -0.02730198f, 0.03557681f, -0.03467008f, -0.05480417f, 0.03268797f, 0.04014531f, -0.05458393f, 0.03922126f, 
    -0.05225175f, -0.00033504f, 0.01748368f, 0.00457563f, 0.02320230f, -0.02868731f, -0.00940879f, 0.01005881f, 
    0.01708403f, 0.02466308f, 0.00453146f, 0.01544532f, 0.02775990f, 0.03399252f, 0.01888533f, -0.00329514f, 
    -0.00087713f, -0.01382930f, -0.05267862f, 0.01921605f, -0.03269853f, -0.02956479f, 0.00630973f, -0.01190124f, 
    -0.05290168f, 0.04462507f, -0.00084335f, 0.01200205f, -0.01835124f, 0.00037973f, -0.04628820f, 0.00584187f, 
    0.01266305f, 0.01825827f, -0.05538397f, 0.03508765f, -0.03488393f, -0.00913168f, -0.05467884f, 0.00322967f, 
    0.02086233f, 0.03553195f, -0.01504229f, -0.04937160f, -0.04632000f, -0.01938464f, 0.03379102f, 0.03142787f, 
    -0.00965939f, -0.05335769f, 0.00392856f, 0.04087137f, 0.03549124f, 0.00660262f, -0.04054783f, -0.02635084f, 
    -0.03090778f, 0.00209016f, -0.02999255f, 0.00964470f, -0.01789101f, 0.02459146f, 0.03659352f, -0.02315686f, 
    0.04244412f, -0.02599771f, -0.02527352f, -0.02105919f, -0.03957273f, 0.02357659f, -0.02501372f, -0.01557445f, 
    -0.05084490f, -0.02224592f, 0.01655849f, 0.03179182f, -0.02554411f, -0.00617927f, -0.01564090f, -0.02273319f, 
    -0.03131019f, -0.01415188f, -0.02454567f, -0.02005203f, 0.00828318f, -0.04435445f, 0.02756798f, -0.04498469f, 
    0.04366095f, -0.04897510f, -0.03482212f, 0.00830068f, -0.05419702f, -0.00214460f, -0.05158137f, 0.02459672f, 
    -0.01145648f, -0.01857006f, -0.01686394f, 0.02868178f, 0.00182957f, 0.03098203f, 0.02017995f, -0.00468962f, 
    -0.03687529f, -0.01119003f, -0.04025432f, -0.04520591f, -0.00879480f, 0.01208573f, 0.02632034f, 0.01559721f, 
    -0.00133218f, 0.00562379f, 0.03345917f, 0.03449035f, -0.05407110f, -0.02931692f, -0.03835031f, -0.02258798f, 
    0.01394475f, -0.04095047f, 0.01151381f, 0.02449152f, -0.02747307f, 0.01447062f, 0.02785217f, -0.01798689f, 
    -0.03843975f, 0.02709233f, -0.04305979f, -0.05156121f, -0.05633132f, -0.02297891f, 0.00862431f, 0.04324218f, 
    0.01600257f, -0.02551921f, -0.00424585f, -0.02779107f, 0.01932926f, -0.05083742f, -0.00270454f, 0.01348713f, 
    -0.03151390f, -0.01138067f, 0.02948322f, 0.01497351f, -0.00692518f, -0.05025314f, 0.02880592f, -0.04512248f, 
    -0.03278747f, -0.04771442f, -0.03218928f, 0.02536357f, 0.03217594f, -0.01466974f, 0.00012514f, -0.00153785f, 
    -0.00249883f, -0.04575522f, -0.02791619f, 0.00741266f, -0.05340433f, 0.03506971f, -0.01742708f, -0.01993504f, 
    -0.02374641f, 0.01237007f, -0.03933061f, 0.00210099f, 0.01003743f, -0.03449056f, 0.01335790f, -0.03337429f, 
    0.40008527f, 0.18818039f, 0.07543738f, 0.15262708f, -0.09110535f, -0.15461360f, -0.03486342f, 0.00655689f, 
    -0.03352461f, 0.38721433f, 0.14342397f, 0.33800173f, 0.04994592f, -0.06185184f, -0.11600481f, 0.14796469f, 
    0.03361965f, -0.04050300f, 0.20286684f, -0.17183506f, -0.23429863f, -0.19091940f, -0.15451735f, -0.11320449f, 
    -0.15082063f, -0.05022721f, 0.13115960f, -0.23815165f, -0.19224834f, -0.00037098f, 0.14024208f, -0.01576285f, 
    0.11171923f, 0.14187618f, 0.00296523f, 0.18969554f, -0.01255812f, 0.03203652f, 0.08341028f, 0.06271498f, 
    -0.00524732f, 0.10977445f, 0.07672427f, 0.30221274f, -0.11634053f, -0.04684172f, -0.00181379f, 0.02031508f, 
    0.08990914f, 0.12167791f, 0.08314400f, 0.24260484f, -0.18902244f, -0.01769987f, -0.00948022f, -0.07890506f, 
    -0.08482732f, -0.03762119f, -0.05259938f, 0.17307569f, -0.11366702f, -0.05191491f, 0.07806981f, -0.11782852f, 
    0.02819212f, -0.07519550f, -0.01736780f, -0.12865706f, 0.07691643f, -0.07096973f, -0.19995329f, -0.05561617f, 
    -0.00886071f, 0.06235311f, -0.27929136f, -0.27111152f, -0.12277275f, -0.00694921f, 0.01666350f, 0.02622997f, 
    0.00077217f, 0.12544191f, -0.02645978f, -0.01117752f, 0.30062452f, 0.06321618f, -0.06341281f, 0.17365691f, 
    0.05784481f, 0.14953925f, -0.07084454f, -0.02526686f, -0.30529356f, -0.33260423f, -0.19562772f, -0.15417622f, 
    0.24969903f, 0.01436912f, 0.08038998f, -0.15896004f, -0.20758958f, 0.11377379f, 0.03198038f, -0.16406752f, 
    0.02126965f, 0.09956806f, -0.00826984f, 0.01275314f, 0.11966499f, 0.06189390f, -0.00864101f, 0.13522419f, 
    -0.01256589f, 0.05680128f, 0.08304396f, 0.00624114f, -0.05785960f, -0.03977638f, -0.01858933f, 0.04832102f, 
    0.12312187f, -0.00470499f, 0.08120325f, 0.23066224f, 0.11748268f, -0.00376532f, 0.05571520f, 0.07925689f, 
    -0.08733366f, -0.01910267f, -0.09312458f, 0.06310219f, 0.15397458f, 0.06925056f, 0.01353748f, 0.19177218f, 
    -0.05459965f, 0.08290617f, -0.02261452f, -0.06225253f, 0.08270555f, -0.00583211f, -0.08416887f, 0.30338293f, 
    0.07009398f, -0.09818980f, -0.05383292f, 0.07028598f, 0.19833300f, 0.04493812f, 0.06035379f, 0.00080987f, 
    0.11221786f, 0.00411324f, -0.10120817f, 0.12642850f, 0.17489816f, 0.12097564f, 0.21882895f, -0.20121814f, 
    -0.01044761f, -0.23311055f, -0.07254479f, -0.29943976f, -0.12509979f, 0.08116654f, -0.24905418f, 0.14419405f, 
    0.24212879f, -0.07577550f, 0.19182472f, 0.16132723f, -0.01694502f, 0.08178274f, 0.07159126f, 0.09598888f, 
    0.01613355f, -0.18636967f, 0.10358289f, 0.18602130f, 0.23421022f, 0.12637928f, 0.20778812f, 0.16759424f, 
    0.01198567f, 0.00053898f, 0.14025632f, 0.06868853f, 0.00312005f, 0.02115343f, -0.00474244f, 0.16244955f, 
    -0.08800323f, 0.05462236f, 0.23262782f, -0.03926368f, -0.05461543f, 0.20579775f, -0.28142610f, -0.11803386f, 
    -0.36466938f, -0.21724376f, -0.19434795f, -0.26248828f, 0.05068525f, -0.01486710f, 0.15930407f, 0.01854693f, 
    -0.18700559f, 0.05540608f, -0.08154327f, -0.31815609f, -0.09387911f, 0.12227288f, -0.08578740f, 0.06045541f, 
    -0.23456934f, 0.27981833f, 0.14165767f, 0.08532512f, 0.11020935f, 0.10418307f, 0.05489190f, -0.07224166f, 
    0.17799328f, 0.25129482f, 0.08477524f, 0.31279615f, -0.00295771f, 0.09188882f, 0.08508276f, -0.00060290f, 
    -0.06681664f, -0.13677402f, 0.21619301f, -0.21251690f, -0.34683555f, 0.03966362f, -0.17973748f, -0.38842347f, 
    0.20760421f, 0.08692840f, 0.14111084f, 0.27740225f, 0.07055091f, 0.05391015f, 0.03083836f, -0.08500846f, 
    -0.03348355f, -0.03780967f, 0.05020167f, 0.09488496f, -0.10340798f, -0.09744744f, -0.00258797f, -0.22034986f, 
    -0.14020148f, 0.08353738f, -0.03608635f, -0.20725039f, 0.05787234f, -0.09978003f, -0.03408865f, -0.07334789f, 
    0.43962890f, -0.06613510f, -0.25594303f, -0.04633365f, -0.05493868f, -0.05871170f, -0.08502588f, -0.37445956f, 
    0.08685327f, -0.02862571f, -0.00116598f, 0.12764908f, -0.03030779f, -0.11160120f, 0.17176911f, -0.01485876f, 
    -0.10370541f, 0.08667361f, 0.10974471f, 0.01590494f, 0.07035486f, 0.09593260f, 0.03614536f, 0.02353391f, 
    0.28701794f, 0.13872249f, -0.08918956f, 0.22084440f, 0.12497855f, -0.24905397f, -0.07968913f, -0.09417398f, 
    -0.16018158f, -0.12061962f, -0.20768268f, -0.19678578f, -0.23464945f, 0.06174912f, 0.22753155f, 0.24132940f, 
    -0.02145492f, 0.10562990f, -0.07289092f, 0.05926086f, 0.08857954f, 0.01191696f, 0.06292852f, -0.05383387f, 
    0.58654368f, -0.45243385f, -0.12864469f, 0.03193483f, 0.01904499f, -0.08116185f, -0.14176551f, -0.13605127f, 
    0.02685068f, -0.13723737f, 0.02532819f, 0.20445611f, 0.03846802f, 0.00957500f, 0.10654969f, -0.16407701f, 
    0.07698046f, 0.10700671f, -0.06509492f, 0.02727051f, -0.07617205f, -0.01889850f, -0.10259401f, 0.00450294f, 
    0.24205612f, 0.07573090f, 0.01694013f, 0.22296186f, 0.16906653f, -0.07861266f, 0.23983584f, 0.19157229f, 
    0.17441754f, 0.11707978f, 0.13741404f, 0.13967226f, 0.24448344f, -0.04894629f, 0.03347901f, -0.11456543f, 
    -0.09778007f, -0.01025289f, 0.06378945f, 0.16342790f, -0.01929712f, 0.14052843f, 0.04799620f, 0.01551662f, 
    -0.05117117f, 0.01735014f, 0.13377419f, 0.04031903f, -0.00592280f, -0.26199403f, -0.11794217f, -0.23857929f, 
    -0.11392339f, 0.05491946f, -0.06134707f, -0.14565741f, 0.20032346f, -0.04892313f, -0.04711068f, -0.09761484f, 
    0.04439056f, -0.11942724f, 0.00763412f, -0.04903112f, -0.11765256f, -0.04131494f, -0.18963856f, -0.28504181f, 
    0.02966867f, -0.00879769f, 0.01222970f, -0.04841840f, 0.03875251f, 0.00152828f, 0.02569590f, -0.02807362f, 
    -0.05337569f, 0.02509865f, 0.01076693f, 0.03070778f, 0.01488094f, -0.01730819f, -0.00246550f, 0.03437744f, 
    0.03241523f, -0.04196558f, 0.00707068f, -0.02953716f, -0.01396453f, 0.00047454f, 0.02241112f, 0.04212018f, 
    0.00567411f, -0.01216334f, -0.01230720f, -0.00172000f, 0.03433738f, -0.02728171f, -0.01149437f, -0.05228566f, 
    -0.02395944f, 0.02280365f, -0.05540312f, 0.02269405f, -0.00133789f, 0.02015845f, 0.00725698f, -0.03598770f, 
    -0.01545018f, -0.00661973f, -0.03235201f, -0.00251826f, -0.02626593f, -0.02937630f, -0.04684285f, 0.02723644f, 
    0.04424471f, 0.01612864f, 0.02647594f, -0.04733083f, 0.02047489f, 0.00684785f, -0.04714238f, -0.02070244f, 
    -0.01245785f, -0.03619450f, 0.00469706f, -0.00424340f, 0.00952086f, -0.03234035f, -0.02688460f, -0.03518591f, 
    -0.03781713f, -0.04523324f, -0.03785473f, 0.02537196f, -0.00476656f, 0.03958256f, 0.00226380f, -0.03801626f, 
    -0.04857738f, -0.05488311f, 0.01473477f, 0.01442825f, -0.01180867f, -0.00895985f, -0.04673029f, 0.00878884f, 
    -0.03487788f, 0.01770379f, 0.03800550f, 0.00271292f, -0.00409539f, -0.03812240f, -0.00298491f, -0.02801263f, 
    -0.05603815f, -0.00904842f, 0.01628870f, -0.04804488f, -0.00425335f, -0.03219089f, 0.00065755f, -0.05856558f, 
    -0.05998386f, 0.01886703f, -0.04320503f, -0.01253125f, 0.00065768f, -0.02417085f, 0.01015509f, -0.05065659f, 
    -0.00198717f, 0.02736346f, -0.01750468f, 0.00049716f, -0.01747050f, -0.04646452f, -0.02084756f, 0.03881935f, 
    0.01338135f, 0.02298018f, -0.02864663f, 0.03066045f, 0.00239989f, -0.00062490f, -0.04971636f, 0.03303793f, 
    -0.02884455f, -0.04785173f, -0.00301066f, -0.01368432f, 0.00682606f, -0.05994991f, -0.03103070f, -0.01389987f, 
    0.01083341f, -0.01434187f, -0.00844453f, -0.00305056f, -0.01229390f, 0.01999301f, 0.00602146f, -0.04368710f, 
    -0.03788084f, 0.02786680f, -0.03247704f, 0.02282191f, -0.03826958f, 0.02171397f, -0.05880900f, -0.06259917f, 
    -0.04422895f, 0.00542738f, 0.01183842f, 0.00417141f, 0.03124282f, 0.00098681f, -0.04314457f, -0.04983894f, 
    -0.04911692f, -0.01059594f, -0.01594513f, 0.01685353f, 0.00328574f, 0.01598812f, -0.01136710f, 0.00894978f, 
    -0.02173288f, 0.01591974f, -0.00809189f, -0.01319479f, -0.01889839f, -0.03230935f, 0.02886678f, -0.02779913f, 
    0.03578005f, -0.04189428f, -0.03627599f, 0.01539293f, -0.02123090f, -0.01922738f, -0.05681222f, -0.02507016f, 
    -0.03654720f, -0.03547397f, 0.00656945f, -0.04051058f, 0.03941237f, -0.04563662f, -0.04091187f, -0.00600153f, 
    0.01270262f, -0.05687868f, -0.03633353f, -0.02154664f, -0.00800593f, -0.03284824f, -0.02051417f, -0.05681252f, 
    0.01621699f, 0.02580501f, -0.03253710f, 0.02963203f, -0.03284356f, -0.02598146f, -0.06101115f, 0.03858963f, 
    0.00531035f, -0.00570298f, 0.02952944f, 0.02411021f, -0.03943057f, -0.04119985f, -0.00668250f, 0.04457880f, 
    -0.04363616f, -0.00997821f, -0.01298262f, 0.03624944f, -0.04244487f, 0.03907689f, 0.03662959f, 0.00030480f, 
    0.02996192f, -0.01605134f, -0.02100490f, 0.00474873f, -0.01600241f, -0.05560955f, -0.05374179f, 0.01952341f, 
    0.00675825f, -0.02094908f, -0.04681772f, -0.04677562f, -0.05017944f, -0.05840305f, 0.03696046f, 0.01782777f, 
    -0.06111487f, -0.01916956f, -0.04803645f, -0.00451663f, -0.04013156f, -0.03541934f, -0.03135646f, 0.03706104f, 
    -0.02246002f, -0.05279671f, 0.03618044f, -0.04738167f, -0.00946050f, -0.04402858f, 0.03355174f, -0.05244872f, 
    -0.00224728f, -0.00662869f, 0.04314706f, -0.01119377f, -0.01633630f, -0.00561611f, 0.00039221f, -0.05346000f, 
    -0.02846927f, -0.01675529f, -0.01732095f, 0.01650582f, 0.02449178f, 0.03512079f, -0.02275726f, 0.03634629f, 
    0.01338365f, -0.05580721f, 0.01041734f, 0.00451944f, 0.02499585f, 0.01811105f, -0.03070857f, 0.00130988f, 
    0.02773066f, -0.01974137f, -0.01517211f, 0.02410306f, 0.02341080f, 0.01053560f, -0.02833002f, -0.00899382f, 
    -0.00197651f, -0.05759490f, -0.02297436f, 0.01766162f, 0.01760752f, -0.04430524f, -0.04289501f, 0.00909981f, 
    -0.02394566f, 0.01533703f, -0.04348773f, -0.04223360f, 0.02094344f, -0.05560940f, 0.01892398f, -0.01294396f, 
    -0.02028299f, 0.04697760f, 0.00354568f, 0.04108806f, -0.04757379f, 0.00572588f, 0.03252934f, -0.02938404f, 
    0.01346372f, -0.01445154f, 0.03135005f, 0.02354721f, -0.03648826f, -0.04798235f, -0.03082738f, 0.02643622f, 
    -0.05298756f, -0.04566564f, 0.00125250f, -0.03843945f, -0.06193603f, 0.01594269f, -0.04087472f, 0.04486278f, 
    -0.00967036f, 0.01182413f, -0.00259184f, -0.00286308f, -0.01767100f, 0.01367650f, 0.03439077f, 0.04515601f, 
    -0.02533602f, 0.02677100f, -0.05076760f, -0.05103200f, -0.03110194f, -0.03879851f, 0.00209438f, -0.04396686f, 
    -0.00864700f, 0.00063335f, -0.05576679f, 0.00397387f, -0.00377896f, -0.00985613f, 0.04249311f, 0.00762676f, 
    -0.02691586f, -0.02844177f, 0.04098532f, 0.00920792f, 0.00206298f, -0.03958364f, -0.00058897f, 0.02144381f, 
    0.01214368f, -0.05334095f, -0.00651444f, 0.02662076f, 0.01133467f, -0.05217525f, -0.02897187f, 0.02939999f, 
    -0.01674703f, -0.05962656f, 0.00852010f, -0.02402842f, -0.03445181f, -0.05919090f, -0.01206481f, 0.02172266f, 
    0.02763324f, 0.01443428f, 0.01496553f, -0.04431622f, 0.01304268f, 0.02789657f, 0.00471469f, 0.02852730f, 
    0.01627951f, -0.01644695f, -0.02697780f, -0.00421650f, -0.04695896f, -0.00948055f, 0.03752394f, -0.03764866f, 
    -0.00700019f, -0.03038322f, -0.02911783f, -0.03296682f, -0.00840781f, -0.03018373f, -0.02100357f, -0.00635205f, 
    0.01910312f, 0.03792233f, 0.01392983f, -0.04840568f, -0.04208337f, -0.00624663f, 0.04465257f, -0.05233546f, 
    0.00557229f, -0.04635002f, -0.05319703f, -0.02963858f, 0.02294379f, 0.04315162f, -0.02546134f, -0.05204391f, 
    0.04680572f, -0.02475786f, -0.01865705f, 0.00697506f, -0.04240915f, -0.01931904f, 0.00881769f, 0.00868464f, 
    0.01401373f, -0.00265544f, -0.03224970f, 0.03499423f, 0.03800493f, -0.05160305f, -0.03867334f, 0.01596125f, 
    0.03350333f, 0.01667315f, 0.00351914f, -0.04251442f, 0.04145458f, -0.05741819f, 0.03325793f, 0.01951142f, 
    -0.02723304f, -0.00521752f, -0.05844652f, 0.00882946f, -0.05766108f, 0.02918228f, 0.01529948f, 0.00550746f, 
    -0.02724475f, -0.05496573f, -0.03215746f, -0.02093213f, 0.01756366f, 0.01477739f, -0.03283164f, -0.02148504f, 
    0.03792672f, 0.02096068f, -0.00937669f, 0.00081924f, -0.03104527f, -0.03240955f, -0.00868081f, 0.04271119f, 
    0.03151473f, 0.01316555f, 0.03851133f, 0.00706863f, 0.00549837f, -0.00743475f, -0.03162688f, -0.00394880f, 
    -0.02038673f, 0.02543070f, 0.02026753f, 0.03060726f, -0.04893859f, 0.04332522f, 0.04163393f, 0.05028607f, 
    -0.04241933f, -0.05279355f, -0.00897663f, 0.03148807f, 0.04059425f, -0.03426281f, 0.03056208f, -0.03569554f, 
    -0.03774752f, 0.02134757f, -0.03391198f, 0.04533941f, -0.04397313f, 0.04200578f, -0.05546834f, -0.02665877f, 
    0.00561850f, -0.03898902f, 0.00100464f, -0.04989092f, -0.01096950f, -0.01797857f, 0.01068875f, 0.01700646f, 
    0.01158389f, 0.01999943f, -0.05760916f, 0.00430119f, 0.02199560f, -0.03801411f, 0.00630687f, -0.02487235f, 
    -0.00515336f, 0.02598554f, 0.00619465f, -0.01273641f, -0.00483329f, 0.01694249f, -0.03768611f, 0.04206677f, 
    -0.01520525f, -0.01353245f, -0.01692531f, -0.00395377f, -0.01967448f, -0.05341045f, 0.00673671f, 0.03546362f, 
    0.00744591f, -0.02293419f, -0.05006827f, 0.04201737f, -0.04771313f, -0.03538016f, -0.04336197f, -0.00795432f, 
    0.02055406f, -0.03910822f, 0.02798508f, -0.01466592f, -0.01832248f, -0.02361465f, -0.01920806f, 0.00811626f, 
    0.03393484f, 0.02648969f, -0.03156875f, -0.01393993f, 0.00002183f, 0.03710813f, -0.03066977f, 0.04937616f, 
    -0.03731325f, -0.05381636f, -0.04109950f, 0.04757896f, -0.00563493f, -0.03655585f, 0.05017233f, 0.00528833f, 
    0.03717291f, -0.04833808f, -0.04640020f, -0.02544004f, -0.04001787f, 0.00619681f, -0.02891353f, -0.04701377f, 
    -0.02848517f, -0.05252852f, -0.04005612f, 0.01973416f, -0.04195813f, -0.00268005f, -0.02604754f, 0.02871784f, 
    0.00073520f, -0.05213219f, 0.02422615f, -0.02512605f, 0.01378947f, -0.04045165f, 0.01503482f, 0.02845318f, 
    -0.04950346f, -0.04992009f, -0.00407064f, 0.00080419f, -0.05857237f, 0.01811322f, 0.03571268f, -0.03335631f, 
    0.04005313f, -0.05003283f, -0.04369324f, 0.00565760f, -0.00041063f, 0.02811634f, 0.02964827f, -0.03980464f, 
    -0.01168904f, 0.03765560f, 0.01856706f, 0.02702791f, -0.04318427f, -0.04082546f, -0.02485530f, -0.00692365f, 
    0.01696233f, 0.03413360f, -0.02442572f, -0.02221016f, 0.00772095f, -0.00599765f, 0.04074726f, 0.01552513f, 
    -0.01633712f, -0.00395104f, 0.00426498f, -0.00901136f, -0.00902010f, 0.01942987f, -0.00156345f, 0.03525501f, 
    -0.00251351f, 0.00360510f, 0.00605329f, -0.04828229f, 0.01693136f, 0.05525192f, -0.00009849f, 0.02641875f, 
    -0.02172736f, -0.01445538f, 0.01906400f, 0.00170369f, -0.03162647f, -0.01047017f, 0.04247876f, -0.02424975f, 
    0.02559597f, -0.00638788f, -0.05082161f, -0.00515295f, -0.05186436f, -0.00629673f, 0.02571554f, -0.01206505f, 
    0.01313601f, -0.00956844f, 0.02254985f, 0.01673897f, 0.04603598f, 0.03174128f, -0.04510701f, 0.03175329f, 
    0.02195556f, -0.05084427f, -0.02354723f, -0.02555950f, -0.03376010f, 0.01510825f, 0.01451843f, -0.02251062f, 
    0.03894132f, 0.00690913f, 0.01043248f, 0.04180130f, 0.03269421f, 0.03434303f, -0.05212939f, -0.05132519f, 
    -0.00681285f, 0.01571122f, 0.02006904f, -0.05431046f, -0.05822383f, 0.03594067f, -0.02165092f, 0.00971449f, 
    -0.05583715f, -0.03270294f, -0.03791889f, -0.04145997f, 0.02997659f, -0.00775090f, -0.03287192f, -0.01760447f, 
    0.01586742f, 0.02434118f, -0.03052816f, -0.01641295f, 0.02766576f, -0.01815599f, -0.02449575f, -0.01957097f, 
    -0.03557050f, 0.01736609f, 0.03054123f, -0.05061739f, -0.03545653f, -0.05801043f, 0.02911857f, -0.00065628f, 
    0.00505494f, -0.02122996f, 0.02378556f, -0.04653956f, 0.04404096f, -0.02275882f, -0.02700534f, -0.03518214f, 
    -0.00944524f, -0.00601809f, 0.04347740f, 0.02734810f, -0.04600348f, 0.00999446f, -0.01581914f, -0.05061342f, 
    0.03545284f, 0.00467564f, -0.00528404f, 0.00015680f, 0.03462845f, -0.04031168f, 0.00209777f, 0.01431358f, 
    0.02389227f, 0.03889155f, -0.02133699f, -0.01956580f, 0.04121992f, 0.03002875f, -0.04735477f, 0.01704792f, 
    -0.00318352f, -0.03665558f, 0.01314059f, -0.04977848f, 0.02119159f, -0.01468861f, -0.02269177f, 0.03178320f, 
    -0.03224489f, -0.00939306f, -0.04585320f, 0.04560882f, -0.02073882f, -0.00049512f, 0.03266077f, -0.02490742f, 
    -0.03492476f, 0.04130927f, 0.04415661f, -0.05132605f, 0.00655069f, 0.00966251f, -0.03394146f, -0.03061363f, 
    0.04510678f, -0.01021029f, -0.02915049f, -0.00492574f, 0.01304642f, -0.04732225f, 0.04121694f, 0.02794603f, 
    -0.05580206f, 0.02058954f, 0.01285351f, 0.02707830f, -0.01926992f, -0.03339626f, 0.04032654f, -0.04637671f, 
    -0.02920049f, -0.02158791f, -0.03450586f, 0.00357960f, 0.02839688f, 0.01204889f, 0.02598831f, 0.04057228f, 
    0.02318088f, -0.02359622f, 0.01145723f, -0.04346997f, 0.03079990f, -0.01808943f, 0.02851722f, 0.03985832f, 
    0.01174788f, -0.03644444f, -0.04341577f, -0.02781424f, 0.00032755f, -0.00781923f, -0.01220119f, -0.01203215f, 
    0.04759643f, -0.05088861f, -0.03736639f, 0.01113826f, -0.01838467f, -0.04770396f, -0.02063276f, -0.03130435f, 
    -0.00261523f, -0.01225524f, 0.01785476f, -0.05360060f, 0.02737084f, 0.02028718f, 0.01582913f, 0.03709901f, 
    -0.01813204f, 0.01910781f, -0.03042649f, 0.04080848f, -0.01267553f, -0.02522161f, -0.01646565f, 0.03780899f, 
    0.02909225f, -0.04170389f, 0.02675365f, -0.00930407f, -0.03213429f, 0.00766933f, 0.03648223f, -0.04364637f, 
    0.03154284f, 0.01669288f, -0.03166332f, -0.01184889f, -0.05024025f, 0.03346238f, 0.03890640f, 0.01823408f, 
    -0.01167960f, -0.04031964f, 0.01501361f, -0.02582503f, 0.01160693f, 0.00886881f, -0.00004482f, 0.01832712f, 
    -0.02546722f, -0.05710361f, 0.01011463f, 0.02817684f, -0.04064910f, -0.05636663f, -0.02651675f, -0.03067555f, 
    0.03283785f, -0.03474131f, -0.05484259f, -0.00958580f, 0.01704060f, 0.01555365f, -0.01093625f, 0.03441143f, 
    0.04082106f, 0.00501139f, -0.01899835f, -0.02524984f, 0.03607858f, 0.01053884f, 0.03327338f, -0.00679458f, 
    -0.04828306f, 0.03482487f, 0.00440692f, 0.02346121f, -0.05948017f, 0.03889134f, -0.05564617f, 0.01585637f, 
    -0.01370293f, 0.02752704f, -0.02033897f, -0.03043504f, 0.03911927f, -0.04566544f, -0.04837806f, 0.03927390f, 
    -0.03973712f, -0.00412654f, 0.00221299f, 0.01302717f, -0.01394392f, -0.00224795f, 0.03314727f, -0.03533003f, 
    -0.03589750f, -0.03289402f, -0.01735932f, -0.03393467f, -0.01719380f, -0.02446403f, -0.05401683f, 0.02554111f, 
    -0.04763027f, -0.02744975f, 0.01061926f, -0.01997575f, -0.04171184f, -0.02056859f, 0.02513462f, 0.03601160f, 
    0.00164628f, -0.02709668f, 0.02820521f, -0.01656082f, -0.05266642f, 0.01344596f, -0.02852891f, 0.02872087f, 
    0.00168626f, -0.00080575f, -0.01358296f, -0.00767255f, 0.02091797f, -0.00907631f, -0.05131361f, -0.03859917f, 
    -0.00059580f, -0.03138845f, -0.01145166f, 0.03509160f, 0.02505719f, -0.00125150f, -0.00628535f, -0.02137255f, 
    -0.04333901f, 0.03540847f, -0.04745030f, -0.05246259f, 0.03069986f, -0.04486667f, -0.00495113f, -0.01599577f, 
    -0.05892397f, 0.01819229f, 0.01615769f, 0.02510393f, 0.03401831f, -0.03213327f, 0.03131146f, 0.00514828f, 
    0.02271128f, -0.04513258f, 0.03873699f, -0.03313417f, -0.04486777f, -0.05425598f, 0.02628645f, 0.02370238f, 
    -0.05398682f, 0.01468591f, 0.04536247f, -0.00356756f, 0.00020795f, -0.06115580f, -0.04404767f, -0.00224665f, 
    0.00601494f, 0.02441711f, -0.04241142f, 0.00850141f, 0.02883335f, -0.04643326f, -0.03474366f, -0.01633856f, 
    0.02576240f, -0.01175143f, -0.00639849f, -0.04379058f, 0.00774887f, 0.01905360f, 0.03892217f, -0.04659949f, 
    0.00943281f, -0.04723546f, -0.04134306f, 0.03089134f, -0.00477966f, -0.03528436f, 0.01383400f, -0.03175277f, 
    0.03517831f, 0.01846887f, 0.03872911f, 0.02119993f, -0.03638458f, -0.03088772f, 0.00815840f, 0.03017071f, 
    -0.02213200f, -0.00197906f, 0.02265063f, -0.00158608f, -0.00320833f, -0.01692877f, 0.04124897f, -0.01915638f, 
    -0.02695405f, 0.00072409f, 0.01018490f, -0.02153893f, 0.04271936f, 0.04129576f, 0.01062280f, 0.01467949f, 
    -0.04165231f, 0.01832529f, -0.02633481f, 0.00627001f, 0.00742045f, 0.03996801f, 0.00756409f, -0.00651308f, 
    0.00531732f, 0.03272096f, 0.02374371f, -0.05319776f, -0.00580471f, 0.03322343f, 0.00890550f, -0.00750122f, 
    0.02783935f, 0.04635597f, -0.03230779f, -0.01152270f, 0.00895913f, 0.03736442f, 0.02661015f, -0.02112859f, 
    -0.03013173f, 0.00485041f, 0.03596381f, 0.03243434f, -0.01184256f, 0.02608781f, -0.05479912f, 0.00643878f, 
    -0.03919588f, -0.02046981f, -0.03623442f, -0.01415916f, 0.02015458f, -0.02878192f, -0.03369391f, -0.06073196f, 
    -0.03792271f, 0.03186297f, -0.00234299f, -0.00037527f, -0.03847906f, 0.01572914f, -0.05575081f, 0.00910944f, 
    -0.00955495f, 0.01214768f, 0.00612035f, 0.00956747f, -0.05420060f, -0.04997510f, 0.02074505f, 0.02673444f, 
    -0.03507960f, 0.01133670f, -0.01138727f, 0.03507509f, 0.03442706f, -0.03382038f, -0.00236879f, 0.00572255f, 
    -0.05943833f, -0.00014842f, -0.02104433f, 0.03459124f, 0.02994199f, 0.02474043f, -0.03365412f, 0.01510877f, 
    -0.00914046f, 0.00835023f, 0.04555505f, -0.00859996f, -0.03652478f, 0.00989554f, 0.03731022f, -0.01303219f, 
    -0.01809512f, 0.03474634f, -0.05254913f, -0.02341084f, -0.04774019f, -0.02941828f, 0.01175348f, 0.03396147f, 
    -0.04124513f, 0.01713036f, 0.00710094f, -0.04700957f, 0.02336108f, 0.03953545f, -0.03907020f, -0.04407905f, 
    -0.05716636f, 0.01669292f, 0.00671364f, 0.01491136f, 0.02595836f, 0.02236487f, 0.00473808f, 0.02507633f, 
    -0.00168974f, 0.00847215f, -0.01002421f, -0.03939019f, 0.00285044f, -0.00970292f, -0.02778411f, -0.00468238f, 
    0.00381129f, -0.02433896f, 0.03047660f, 0.03100422f, 0.04291286f, -0.05472288f, -0.01782620f, -0.04467094f, 
    0.03750767f, -0.03749901f, -0.03891870f, 0.00183028f, -0.01591190f, -0.03762744f, -0.01267039f, -0.04574048f, 
    0.00411847f, -0.02437114f, 0.02771809f, 0.01699937f, -0.04383686f, -0.00826691f, -0.00107019f, -0.04246265f, 
    -0.01369115f, 0.03341124f, -0.02840479f, 0.03315106f, -0.00465788f, 0.01388556f, -0.06216423f, 0.00791033f, 
    0.13330621f, 0.19439887f, -0.14237384f, 0.02276897f, -0.08214299f, -0.03613713f, -0.02980482f, -0.05743881f, 
    0.13003938f, 0.12511575f, 0.02202668f, 0.17577364f, -0.05047773f, -0.02297369f, 0.03459704f, 0.16676879f, 
    -0.00640010f, 0.00423245f, 0.02682849f, -0.13115624f, -0.01066162f, -0.17951663f, 0.03245632f, -0.23925070f, 
    -0.30427149f, 0.27571565f, -0.13822934f, -0.09128124f, 0.03072686f, -0.02630956f, -0.06861027f, 0.04326702f, 
    0.15271214f, 0.13213563f, 0.13227327f, 0.07663428f, -0.35366622f, -0.17575721f, -0.16145428f, 0.11966223f, 
    0.05340753f, 0.04017048f, 0.02847934f, -0.08563834f, 0.03119632f, 0.11503102f, 0.02428111f, 0.06188001f, 
    -0.02848977f, 0.17902172f, -0.45125073f, 0.14015149f, -0.04033819f, -0.05931354f, 0.00894200f, 0.06243588f, 
    -0.08585823f, 0.08474123f, 0.02917809f, 0.10516521f, 0.01355771f, 0.05658218f, 0.11416743f, -0.07717353f, 
    0.18032412f, -0.21994756f, -0.21051277f, -0.08169679f, 0.11158583f, 0.07744084f, -0.08599051f, 0.03156871f, 
    -0.21826302f, 0.25835991f, -0.13091069f, 0.22563925f, -0.07028244f, 0.04980447f, -0.01027338f, -0.02475786f, 
    -0.03948373f, -0.02892566f, -0.05355668f, 0.00838616f, 0.12251016f, 0.00110767f, -0.02697264f, 0.05430666f, 
    -0.08202249f, 0.02291995f, -0.06766868f, -0.06892230f, -0.19724405f, -0.08665003f, -0.10862184f, -0.12546664f, 
    -0.16028149f, -0.02470212f, 0.09316992f, -0.00077743f, -0.02575868f, 0.05543699f, 0.05832465f, 0.11667749f, 
    -0.04794316f, -0.00974158f, 0.01433212f, 0.04055611f, -0.19574112f, -0.16532600f, -0.15448153f, 0.09464037f, 
    -0.06674601f, 0.00890831f, 0.09593797f, -0.12065026f, -0.01332457f, 0.00444730f, -0.06196140f, -0.09559710f, 
    -0.07937621f, -0.33535999f, 0.08111997f, 0.16385756f, 0.03790151f, 0.01819587f, 0.11831454f, 0.12350615f, 
    -0.06126907f, -0.01274057f, 0.03881229f, 0.03734122f, 0.09610182f, 0.29155198f, 0.37008205f, 0.21357881f, 
    0.03585017f, 0.01821429f, 0.02231926f, -0.12554720f, 0.14246447f, -0.03337224f, -0.02814445f, 0.18450867f, 
    -0.04167946f, -0.34908119f, -0.06044035f, 0.01090182f, 0.05943372f, -0.00507495f, -0.14889765f, 0.05165897f, 
    0.07238002f, -0.02108217f, -0.05814917f, 0.15993002f, -0.18650009f, -0.23969762f, -0.25394306f, -0.17918724f, 
    -0.07534238f, -0.15197007f, -0.05366638f, -0.17551771f, -0.03087587f, -0.06885867f, -0.22500814f, 0.07405808f, 
    0.03640939f, 0.28015593f, 0.29434288f, 0.11699013f, -0.03996904f, -0.07124368f, 0.07723532f, 0.10372050f, 
    -0.00399005f, -0.05175811f, -0.00122526f, 0.06917266f, -0.15907493f, 0.20696369f, 0.30270976f, 0.41855493f, 
    0.03396592f, -0.12947883f, -0.02349432f, -0.04854928f, -0.10643372f, -0.03966813f, -0.02300185f, -0.03985120f, 
    -0.22122745f, 0.05059311f, -0.08179200f, -0.10611200f, -0.12821862f, -0.04241421f, -0.06286223f, -0.17199342f, 
    -0.12846062f, -0.05495014f, -0.00538365f, -0.27280068f, 0.10366450f, 0.81410623f, 0.39158961f, 0.22211896f, 
    0.07021119f, 0.01459195f, -0.04183498f, -0.09264585f, -0.09413210f, 0.09476347f, 0.06586840f, 0.06183590f, 
    -0.02220817f, 0.05955571f, 0.00627204f, 0.00202810f, 0.12603730f, 0.03518805f, -0.02997855f, -0.11043178f, 
    0.16005842f, 0.08625248f, 0.06059925f, 0.10488386f, -0.04533177f, -0.09500159f, -0.07170366f, -0.18376087f, 
    -0.14097686f, -0.05523595f, 0.04083035f, -0.02515182f, -0.08730698f, 0.04617540f, -0.06039677f, -0.16759430f, 
    0.09428422f, -0.13758564f, 0.09871916f, 0.20452870f, 0.03557434f, -0.08733857f, 0.08200887f, -0.10139460f, 
    0.03942764f, 0.07542605f, -0.04166442f, 0.06278466f, 0.17864569f, 0.01719268f, -0.27719149f, 0.05562196f, 
    0.00745518f, -0.00857796f, -0.01530909f, 0.09583987f, 0.03733933f, 0.16144587f, -0.05759921f, -0.07929036f, 
    -0.04414350f, 0.22814924f, 0.23636016f, 0.14174716f, -0.09619491f, -0.00193413f, -0.09143172f, -0.00409864f, 
    -0.00155882f, 0.06064605f, 0.04667547f, 0.00074637f, -0.29455855f, 0.17098501f, -0.03610980f, -0.01161805f, 
    -0.11271250f, 0.20118240f, -0.01988773f, 0.09273650f, 0.14236093f, 0.01947953f, 0.11758932f, -0.00072372f, 
    0.24564721f, -0.07374334f, 0.15475693f, 0.05489086f, 0.10723799f, -0.07423361f, -0.07430477f, 0.14304762f, 
    0.01404552f, -0.09138253f, -0.05724285f, -0.06887428f, -0.11848151f, -0.28204867f, -0.09574391f, -0.10098369f, 
    0.26373929f, 0.02601079f, -0.05279954f, -0.07777156f, 0.07193954f, -0.04294018f, -0.03493014f, -0.09508549f, 
    0.52540773f, -0.34942031f, -0.02239155f, 0.01397257f, 0.16861054f, -0.08258333f, -0.02925403f, -0.01755990f, 
    -0.01661915f, -0.09255890f, -0.00371239f, -0.00950616f, -0.30769140f, -0.12367967f, -0.10149977f, 0.33507645f, 
    0.21133256f, 0.07257414f, -0.05358341f, 0.04511987f, -0.00482969f, -0.02645634f, -0.13036557f, 0.08398721f, 
    -0.19056588f, 0.01536287f, 0.13534129f, 0.13667075f, 0.00328656f, -0.10813643f, 0.07342219f, -0.05860021f, 
    0.19655655f, 0.03375269f, 0.06418707f, 0.07033867f, -0.23662771f, 0.06510208f, 0.44469678f, -0.00108388f, 
    -0.00266780f, 0.09541145f, -0.04694254f, 0.04938621f, -0.03716758f, 0.09613965f, 0.08848142f, -0.14823301f, 
    -0.30989784f, -0.25546166f, 0.02365281f, 0.00887880f, -0.08946075f, -0.15591154f, -0.06543648f, -0.10531735f, 
    -0.10167055f, -0.07151680f, -0.14076968f, -0.12221947f, -0.00915543f, -0.18743771f, 0.24540754f, -0.06480678f, 
    0.04083551f, -0.12666903f, 0.05640690f, -0.09515247f, -0.02768718f, -0.05112907f, -0.10645811f, 0.06919156f, 
    0.07807365f, 0.36227188f, -0.00700150f, 0.03141056f, -0.06626923f, 0.03804117f, -0.02393920f, -0.00870773f, 
    -0.01846291f, -0.11800077f, -0.21876858f, -0.14449108f, -0.18763295f, 0.07663497f, -0.01813339f, 0.16790864f, 
    -0.02747799f, -0.02343494f, -0.14521913f, -0.15129997f, 0.13632120f, 0.09672663f, 0.14022122f, 0.05182963f, 
    -0.26339388f, 0.14507177f, -0.14305905f, -0.02391323f, 0.02563383f, -0.04339746f, -0.09827007f, 0.02913393f, 
    -0.13111556f, 0.06790920f, -0.17391165f, 0.02169890f, -0.14490977f, 0.08152170f, -0.10248431f, 0.14810550f, 
    0.14914116f, -0.04993006f, -0.03305811f, -0.17090853f, -0.04783227f, 0.07237092f, -0.02909436f, -0.04357127f, 
    0.16800399f, 0.36091995f, -0.03984730f, -0.16835126f, -0.01716387f, -0.16027518f, -0.07948044f, 0.06820285f, 
    -0.09645769f, 0.01937616f, -0.07374460f, -0.01595255f, -0.20516840f, 0.05766307f, -0.19384514f, -0.11571208f, 
    -0.00110417f, -0.19730245f, -0.10168172f, -0.03921861f, -0.13422161f, 0.03804539f, -0.07349930f, 0.16914603f, 
    0.04306420f, 0.38968852f, 0.06092272f, 0.17757306f, -0.06963227f, -0.05994264f, -0.06904359f, 0.08407474f, 
    -0.00812591f, -0.15798832f, -0.02859161f, 0.06450714f, 0.07411113f, -0.11934681f, 0.20682576f, -0.03246905f, 
    -0.03777444f, -0.06647641f, -0.12736596f, 0.01614447f, 0.06433320f, 0.12474873f, 0.10430619f, 0.05846846f, 
    -0.15234485f, 0.15078853f, -0.07047025f, -0.18151851f, -0.05197131f, -0.00191145f, -0.04077675f, 0.08590674f, 
    -0.27053559f, -0.14692821f, -0.03618255f, 0.02638616f, 0.01206206f, -0.06614468f, 0.02616394f, 0.16835003f, 
    0.12213185f, 0.09777430f, -0.01933011f, 0.08196583f, -0.10235417f, -0.05590575f, 0.01159691f, 0.08764965f, 
    0.16719399f, -0.08683183f, 0.07810175f, 0.10427080f, 0.09444599f, 0.11163746f, 0.09686486f, 0.10099777f, 
    0.01999046f, -0.05493633f, -0.01574616f, -0.09690391f, 0.05906762f, 0.05508123f, 0.05667200f, 0.19684610f, 
    0.02758571f, -0.02315893f, 0.16432483f, -0.00171877f, 0.00122556f, -0.05131944f, -0.06311640f, -0.15881898f, 
    0.12695028f, -0.06919302f, -0.00539143f, -0.00784625f, -0.06533263f, -0.09312060f, -0.08301299f, 0.12624480f, 
    -0.02279932f, -0.07828120f, 0.01457298f, 0.05763205f, -0.24036717f, -0.18267870f, -0.11938500f, -0.15610076f, 
    -0.03744036f, -0.12221639f, -0.12527196f, -0.10949305f, -0.02110943f, -0.05643074f, -0.03570239f, 0.08283961f, 
    0.11982349f, 0.05745488f, 0.02873848f, 0.13776211f, 0.10491556f, 0.20481987f, 0.08498462f, 0.07720340f, 
    0.15015788f, 0.14129040f, -0.09379011f, 0.14918016f, -0.07576780f, -0.13591504f, 0.23748271f, 0.43471539f, 
    0.10333038f, 0.20584989f, 0.09782628f, -0.03364763f, 0.03205943f, -0.00607277f, 0.05299855f, -0.02096836f, 
    -0.25320694f, 0.04755450f, -0.13911654f, 0.13553973f, -0.06353086f, -0.07012553f, -0.11144505f, 0.00909632f, 
    -0.02546083f, 0.07872279f, -0.04753748f, 0.09253450f, -0.35369962f, 0.33028269f, 0.02691890f, 0.25123149f, 
    0.14488882f, -0.02430132f, -0.01043675f, 0.10145747f, 0.14246517f, 0.08022700f, 0.07581083f, -0.02301833f, 
    -0.06163528f, -0.07863030f, 0.15989964f, 0.09272224f, -0.04867841f, 0.01291614f, -0.04367036f, 0.05534085f, 
    0.01857679f, -0.05731186f, -0.12011769f, -0.25257275f, -0.20270966f, -0.15996216f, -0.00403278f, -0.27802283f, 
    -0.02244967f, -0.13892652f, -0.07919338f, -0.08177204f, 0.07421306f, -0.06054083f, 0.05151780f, 0.13643105f, 
    0.14833526f, -0.03058393f, 0.20770219f, 0.20104411f, 0.08956631f, 0.05113385f, 0.19330035f, 0.10092518f, 
    -0.06103061f, -0.02834109f, -0.00457100f, 0.08398959f, 0.01014932f, -0.13945246f, -0.09343453f, -0.05326107f, 
    -0.03863198f, -0.17166279f, -0.13569860f, -0.04854125f, -0.10070178f, 0.03855522f, 0.03620290f, -0.10455521f, 
    -0.25422099f, 0.02956539f, 0.18348262f, -0.10756486f, 0.00245464f, 0.10370416f, -0.00324977f, 0.06915350f, 
    -0.06716816f, 0.10011544f, 0.02144034f, -0.05341433f, -0.09757561f, 0.34945655f, 0.00296616f, 0.05437073f, 
    -0.08978143f, 0.11988609f, -0.02017790f, 0.11738150f, 0.08952416f, 0.00935457f, -0.04444858f, -0.03585995f, 
    0.13898969f, -0.03032895f, 0.07711464f, 0.07756935f, 0.09051694f, 0.18452175f, 0.04943401f, -0.06526393f, 
    0.04671803f, 0.07289067f, 0.13376491f, 0.11576350f, -0.00735438f, -0.16694514f, 0.04638556f, 0.04975356f, 
    0.15864430f, 0.07387242f, -0.04939063f, -0.05606081f, -0.05825780f, 0.04200762f, -0.01041405f, 0.08830047f, 
    0.56815267f, -0.00669173f, 0.01375788f, -0.02106490f, -0.07434706f, -0.02710527f, 0.05686566f, 0.08994810f, 
    -0.05296745f, 0.01695390f, 0.07186225f, -0.06182172f, -0.01887938f, 0.11425360f, -0.06536643f, 0.24413735f, 
    0.09736843f, 0.06210251f, 0.02011016f, 0.16184215f, 0.02095973f, 0.05614217f, -0.00016843f, 0.09529025f, 
    -0.01670262f, -0.07406837f, -0.04877024f, 0.18581106f, 0.07122458f, 0.09712206f, 0.08924088f, 0.00708733f, 
    -0.05429562f, -0.10500364f, -0.03394201f, 0.00228060f, -0.28860152f, 0.29300755f, 0.16558565f, -0.28592592f, 
    0.11449175f, 0.07319124f, -0.02600866f, 0.03946468f, -0.10257079f, 0.13161246f, -0.10800223f, -0.09746696f, 
    -0.39479819f, -0.22777556f, -0.10078675f, -0.15793003f, -0.06688017f, -0.18510750f, -0.14581163f, -0.20669998f, 
    0.00235984f, -0.01812751f, 0.02656726f, 0.02955494f, -0.13735852f, -0.03840068f, 0.07634465f, 0.23940873f, 
    0.02345107f, 0.09277087f, -0.02534881f, -0.02615998f, -0.02320878f, -0.00670873f, 0.09966702f, 0.15559098f, 
    -0.03001896f, 0.01286569f, 0.03826845f, -0.03565717f, 0.02952812f, -0.04444582f, 0.02338688f, -0.04276295f, 
    -0.02314619f, -0.02731268f, -0.00952037f, -0.00533442f, -0.06172449f, 0.01246490f, -0.00615100f, -0.04421519f, 
    -0.00895527f, 0.02165532f, -0.05275326f, -0.03650003f, 0.02862166f, 0.01728044f, -0.03711122f, -0.02509794f, 
    -0.02071616f, 0.03522674f, -0.03831246f, -0.00278817f, -0.02993419f, -0.03480583f, 0.01627031f, 0.01222838f, 
    -0.05367490f, 0.03605628f, 0.00508743f, -0.02138981f, -0.00554274f, -0.04845263f, 0.03305497f, 0.02390260f, 
    0.03274350f, 0.01834546f, 0.01322123f, -0.04343031f, 0.00098370f, -0.00604552f, 0.01493406f, -0.04205889f, 
    -0.03758091f, -0.01618119f, -0.02458974f, 0.00957076f, 0.01093936f, 0.01096470f, -0.02690412f, -0.04126933f, 
    -0.01655950f, -0.04326313f, 0.01152305f, 0.00761387f, 0.00481323f, -0.01592967f, 0.02304932f, 0.01075113f, 
    -0.02162621f, 0.00437315f, -0.04866068f, -0.03904430f, -0.01919196f, -0.01839203f, -0.04751601f, -0.02621306f, 
    0.02226653f, -0.00739688f, 0.04266431f, -0.04264574f, 0.02334496f, -0.04999205f, 0.01852291f, -0.01583384f, 
    -0.04236026f, -0.03882086f, 0.00214770f, -0.00959344f, -0.04868586f, -0.04609086f, 0.01431771f, -0.00832724f, 
    -0.00740360f, 0.00638346f, 0.01045988f, 0.01793753f, -0.01818790f, 0.03415630f, -0.03750870f, -0.02683201f, 
    -0.03586735f, 0.04829714f, 0.03538415f, 0.02999190f, 0.01678626f, -0.03927853f, 0.02191865f, 0.04156227f, 
    -0.03813582f, -0.01647551f, -0.02313141f, 0.02110519f, -0.05491538f, 0.00506292f, 0.00886828f, 0.01851283f, 
    0.02049798f, 0.03100947f, -0.00323872f, 0.01753994f, 0.02211498f, -0.01636932f, 0.03134083f, -0.00330914f, 
    0.01622654f, -0.00808431f, -0.02116641f, 0.04502185f, 0.03748168f, -0.01993545f, 0.03741074f, 0.05446661f, 
    -0.03427517f, 0.02989629f, -0.01165410f, -0.03466928f, -0.01949688f, 0.04333081f, 0.05629238f, 0.00845854f, 
    -0.01134584f, -0.00289779f, -0.02400523f, 0.01339177f, -0.04677204f, 0.02482264f, -0.00234848f, -0.00353830f, 
    -0.03609511f, -0.01898134f, 0.00126225f, -0.00895855f, 0.00813538f, -0.01585166f, 0.00159936f, -0.00860955f, 
    -0.02095237f, 0.05248062f, 0.01048249f, 0.02312227f, 0.01880039f, -0.01687117f, -0.02934307f, 0.01311581f, 
    0.04904370f, -0.03541334f, 0.01506280f, 0.01558121f, 0.01475745f, -0.05553353f, 0.02649710f, -0.04410036f, 
    0.03483961f, -0.01736136f, -0.00258130f, 0.03467147f, 0.02310377f, 0.01458554f, -0.03385031f, 0.00335564f, 
    0.03718097f, -0.00124459f, -0.02650641f, 0.00954504f, -0.02080646f, 0.02918580f, 0.02210973f, -0.00165405f, 
    0.03128219f, -0.03024921f, -0.03889026f, 0.00643128f, 0.04367726f, 0.03071454f, 0.00283823f, 0.03932447f, 
    0.04097906f, 0.02256999f, 0.01216631f, 0.00018976f, -0.00837572f, 0.03682731f, 0.04357819f, 0.00941989f, 
    -0.02038086f, 0.04312371f, 0.00659322f, -0.04083398f, 0.02670980f, 0.02423442f, -0.02416361f, -0.04342316f, 
    -0.01657726f, 0.01987001f, -0.04791928f, -0.04392421f, -0.00368121f, -0.06435152f, 0.01948209f, -0.01028743f, 
    -0.02676736f, 0.01225905f, -0.01174380f, -0.03536570f, -0.05686854f, -0.02583355f, -0.03424769f, -0.04864386f, 
    0.00625856f, 0.01261937f, 0.01495368f, 0.04496853f, 0.03413907f, -0.00018101f, -0.02990580f, -0.02180080f, 
    -0.04297568f, -0.00779298f, 0.04390610f, 0.00212421f, 0.00372860f, -0.00056161f, 0.01660053f, -0.02207764f, 
    -0.00307332f, 0.02712944f, -0.04191091f, 0.03144341f, -0.03974527f, -0.01028690f, -0.02756938f, 0.00598975f, 
    0.00839979f, -0.04863743f, 0.02490014f, 0.00637001f, 0.01004222f, 0.03514564f, -0.02042404f, 0.04939207f, 
    0.00693835f, -0.03510335f, 0.01652836f, -0.04073597f, -0.03450063f, -0.04109272f, 0.01767631f, 0.00273103f, 
    0.01013907f, -0.04704294f, 0.03193713f, -0.05121373f, -0.04303692f, -0.03698380f, -0.03115268f, -0.04169701f, 
    -0.03338430f, 0.04655963f, 0.00499876f, 0.02432723f, 0.03147240f, -0.03696756f, -0.02862107f, 0.03146948f, 
    -0.02118414f, -0.04694454f, -0.02830636f, 0.03595003f, -0.01950466f, 0.03261539f, -0.04459685f, 0.00105216f, 
    -0.04371858f, -0.03957754f, -0.05047922f, 0.03838471f, -0.05010042f, 0.00488830f, 0.03793921f, 0.02173020f, 
    0.02356417f, -0.02453431f, -0.00822460f, 0.00683935f, -0.01928812f, -0.00565095f, -0.04150063f, -0.03032601f, 
    -0.04321192f, 0.04300841f, -0.02253720f, -0.01175415f, -0.00166060f, -0.04938981f, 0.03836557f, 0.03754935f, 
    0.04435867f, 0.01925213f, -0.02319517f, -0.05664861f, -0.04826073f, -0.05383744f, 0.03248275f, 0.03988262f, 
    0.01259647f, -0.03111475f, 0.00635750f, 0.03073297f, 0.02224370f, -0.04934373f, -0.01286804f, 0.00335784f, 
    0.04205383f, -0.00530160f, 0.03565812f, 0.03629806f, 0.02812537f, 0.04480327f, -0.05445866f, 0.03824283f, 
    0.02290461f, 0.01731423f, 0.02533106f, -0.01868912f, -0.02502721f, -0.01847821f, -0.04556348f, -0.02637480f, 
    -0.03598097f, -0.04895825f, 0.01336312f, -0.02037698f, -0.03364943f, -0.03099563f, 0.05110162f, 0.04864559f, 
    0.02205634f, -0.04184956f, -0.06156605f, -0.02637742f, -0.05513775f, -0.03642224f, 0.03296152f, 0.00646718f, 
    -0.04701038f, 0.04248213f, 0.03664868f, -0.02672875f, 0.00763168f, -0.01383519f, -0.05214269f, 0.01804521f, 
    0.00835282f, -0.04374058f, -0.05435139f, -0.01919494f, 0.00020459f, 0.00279998f, -0.01176520f, -0.03247864f, 
    -0.02300788f, 0.01395013f, 0.03557820f, 0.03219524f, -0.04815022f, -0.01654125f, -0.03839450f, 0.02146810f, 
    0.26645893f, 0.07330243f, -0.12841515f, 0.08696472f, 0.06397519f, -0.15473136f, -0.14169568f, -0.15204462f, 
    -0.02205318f, 0.17026028f, 0.08461768f, 0.21466604f, -0.17138627f, -0.05065044f, -0.07690731f, -0.02117747f, 
    0.11553777f, 0.19507223f, 0.12207897f, 0.00619779f, -0.11606098f, -0.13697545f, 0.02588254f, 0.00597307f, 
    -0.14177594f, 0.00433110f, -0.07414477f, 0.10453289f, -0.00692065f, -0.16592820f, 0.01157310f, 0.03115121f, 
    0.17747961f, 0.07192770f, 0.15414731f, 0.13299711f, -0.21107493f, -0.00035317f, 0.05762095f, 0.09501798f, 
    -0.03862217f, -0.04936240f, 0.07707935f, 0.12930432f, -0.03730706f, -0.03115063f, -0.04501956f, 0.04420587f, 
    0.44914100f, 0.06527456f, -0.16936310f, 0.13297503f, 0.10676098f, -0.11542977f, -0.05559808f, -0.12271107f, 
    -0.02584933f, 0.01592297f, 0.05637612f, 0.19893190f, -0.37753969f, 0.04187413f, 0.09888087f, -0.14579462f, 
    0.15373708f, 0.21344079f, -0.13889667f, -0.03876955f, 0.14559712f, -0.01743168f, 0.01665048f, -0.04355462f, 
    -0.02804289f, 0.42867631f, -0.42613000f, -0.09235928f, 0.08465183f, -0.02824683f, -0.08187059f, -0.02198230f, 
    -0.04052456f, 0.02228988f, -0.07034133f, -0.04306481f, 0.00108292f, 0.02540805f, -0.24025995f, 0.05946559f, 
    0.15729548f, 0.23854589f, -0.18448055f, 0.00890243f, 0.10566212f, 0.03487333f, -0.20901458f, -0.11061781f, 
    0.12165340f, -0.29536304f, 0.02753930f, -0.22026497f, -0.00650618f, -0.01413569f, -0.05396245f, 0.06849043f, 
    0.00905773f, -0.04178913f, 0.05331344f, 0.08768269f, -0.03888219f, -0.04921839f, 0.02950036f, 0.05062839f, 
    -0.00381390f, -0.03131516f, 0.10579813f, -0.09750974f, -0.05991461f, -0.12838024f, -0.00577792f, -0.09637567f, 
    -0.09939234f, -0.11048164f, 0.03109050f, 0.02932891f, 0.03611808f, -0.02884492f, -0.05906329f, -0.01162708f, 
    -0.04314278f, 0.04224290f, -0.10824285f, 0.01610085f, -0.00412559f, 0.09709320f, 0.00618377f, 0.20880237f, 
    0.05748247f, 0.05799362f, 0.08437966f, 0.09907734f, 0.08873812f, -0.18877648f, 0.15688288f, 0.24196593f, 
    -0.02959432f, -0.13470624f, 0.02909743f, -0.02208312f, 0.02010716f, -0.06424584f, 0.09611159f, -0.01442799f, 
    0.02534616f, -0.03871065f, -0.03168616f, 0.10716875f, -0.10155423f, -0.07881324f, -0.10804569f, -0.24354029f, 
    -0.11002871f, -0.11311787f, 0.15331489f, -0.02714631f, 0.01629140f, 0.09789591f, -0.05888278f, 0.20982365f, 
    0.12685217f, -0.19778822f, 0.14288336f, 0.25779709f, 0.04141895f, 0.06306080f, 0.09788556f, 0.11225296f, 
    0.13794667f, -0.17360257f, 0.00634456f, -0.05994399f, -0.08565979f, 0.09784131f, 0.01628054f, 0.07805163f, 
    0.14715315f, -0.04766881f, 0.12217896f, 0.01379720f, -0.05761682f, -0.10999601f, 0.04273220f, 0.19091345f, 
    -0.03315237f, 0.01382736f, 0.40224940f, 0.12658590f, 0.10183060f, -0.15297222f, -0.21757330f, -0.25536591f, 
    0.04223477f, -0.09346427f, -0.11188362f, -0.13159478f, -0.66343057f, 0.12765415f, 0.36769804f, 0.08796994f, 
    0.01507480f, 0.15283941f, -0.04273079f, -0.10994118f, -0.01584764f, 0.04377225f, -0.04393493f, 0.05848043f, 
    -0.26425606f, 0.14037849f, -0.03594805f, 0.15978171f, 0.11116916f, 0.10630064f, -0.03293215f, 0.02267793f, 
    0.12775603f, 0.10220990f, 0.13992043f, 0.05019167f, -0.08146502f, 0.02347497f, 0.01445654f, 0.11410333f, 
    0.07216460f, -0.13776405f, -0.03548830f, -0.06399034f, -0.01918299f, 0.13287087f, -0.12399209f, -0.07814087f, 
    0.04078882f, -0.03252430f, -0.06552909f, 0.19345047f, 0.07509927f, -0.01354640f, -0.02114820f, -0.18440676f, 
    0.05164922f, 0.10702787f, -0.05021935f, 0.07708132f, 0.19068478f, -0.08513733f, -0.11048297f, -0.08748762f, 
    0.11183596f, -0.06279429f, -0.11886790f, -0.01485513f, 0.07543296f, -0.02640727f, 0.02879382f, 0.09784444f, 
    0.29014769f, -0.14246361f, -0.10205926f, 0.04480122f, 0.04937362f, 0.00507882f, 0.01780474f, 0.09986498f, 
    0.07279825f, 0.01297378f, 0.02943625f, -0.02276032f, 0.01319054f, -0.17771752f, 0.13878386f, 0.15642479f, 
    -0.00699553f, 0.13544586f, 0.10603163f, -0.06492555f, 0.05210200f, -0.04670460f, -0.01784656f, 0.05374123f, 
    0.11098416f, 0.09941091f, -0.26473668f, -0.08446541f, 0.10534313f, -0.03553823f, -0.16360435f, 0.04618949f, 
    -0.01764621f, -0.03689678f, 0.07868032f, -0.17938609f, -0.23638785f, 0.28417167f, 0.15256035f, 0.35067257f, 
    0.28102508f, 0.01893946f, -0.11415391f, 0.06631991f, 0.07466161f, -0.01270993f, -0.03363011f, -0.05333102f, 
    0.52890253f, 0.15556802f, -0.06000798f, 0.20370746f, 0.24522069f, -0.00772780f, -0.06336862f, 0.13752297f, 
    -0.06367251f, -0.17555498f, 0.01348393f, 0.16646597f, 0.13587566f, -0.01639071f, 0.00740737f, -0.02481592f, 
    -0.10273580f, -0.05625686f, 0.01255652f, 0.05029520f, 0.06315789f, 0.05345355f, -0.16975462f, -0.01891048f, 
    -0.12706168f, -0.05872740f, 0.02106654f, 0.00930701f, 0.01966196f, -0.07458286f, 0.15996699f, -0.19364394f, 
    0.02896530f, 0.01629162f, 0.02739660f, 0.04909711f, -0.25457042f, -0.09778568f, -0.01729048f, 0.13116986f, 
    0.02041626f, -0.04455881f, -0.01144598f, 0.11643060f, -0.06390867f, -0.09802979f, -0.02889292f, -0.09855750f, 
    -0.09486180f, 0.15576318f, 0.11558095f, -0.01583593f, -0.06678169f, -0.09488032f, -0.05714678f, 0.03724108f, 
    0.05022742f, -0.07984381f, -0.03714527f, 0.11041544f, -0.35365766f, 0.22673085f, 0.01376613f, -0.01246010f, 
    -0.02668705f, -0.05025669f, -0.03540170f, -0.03541511f, -0.17441662f, 0.14575955f, -0.09125294f, -0.03386284f, 
    -0.05450183f, 0.04048218f, -0.05185343f, -0.03768842f, 0.03144890f, 0.03883008f, -0.00555912f, -0.02307057f, 
    0.02191709f, 0.00467377f, -0.05227553f, -0.00200300f, 0.02995426f, 0.01769934f, 0.02039891f, -0.03579114f, 
    0.01747815f, -0.00842143f, 0.02742913f, 0.00626348f, 0.03374821f, 0.02986042f, -0.00567692f, -0.03528422f, 
    -0.02231929f, -0.02656993f, -0.05326898f, 0.03180396f, 0.01816359f, 0.01500926f, 0.01614151f, -0.00104710f, 
    0.01489048f, -0.05640164f, -0.01098750f, 0.03228197f, -0.04466644f, -0.05234832f, 0.04219477f, -0.01833119f, 
    -0.02091517f, -0.03644579f, -0.05407008f, 0.04111561f, 0.02547908f, -0.04462789f, -0.00125821f, 0.00352084f, 
    -0.02390567f, -0.00901094f, 0.04218077f, 0.03699377f, 0.02015771f, 0.02695153f, 0.00363802f, -0.02134082f, 
    0.00292842f, 0.01483598f, -0.03081933f, -0.05280514f, -0.01214618f, 0.03820084f, 0.00597255f, 0.00017843f, 
    0.01640614f, 0.01742899f, -0.04213473f, -0.00842017f, -0.02267368f, 0.02004145f, 0.04192420f, 0.03459190f, 
    -0.05473424f, 0.04403434f, -0.00838501f, -0.00396000f, -0.04494991f, 0.01428571f, -0.05034421f, -0.05140979f, 
    -0.01727737f, -0.00801089f, 0.02069699f, 0.01555417f, 0.02127640f, 0.00938475f, -0.04263010f, -0.00218339f, 
    -0.03070172f, 0.00266714f, -0.05200571f, 0.01279662f, 0.04221982f, -0.04041892f, -0.03578597f, 0.03052398f, 
    -0.03092186f, 0.03062791f, -0.04268856f, -0.05322466f, 0.00867717f, 0.00139485f, -0.05512574f, -0.03514448f, 
    -0.00800816f, -0.03567690f, -0.04691800f, -0.02673428f, -0.02054289f, -0.00935245f, -0.05715452f, -0.02247846f, 
    -0.05684596f, 0.00071352f, -0.00140948f, -0.02476573f, -0.02917863f, 0.01306387f, -0.00683476f, -0.04545415f, 
    -0.03160321f, 0.04250790f, -0.04904830f, -0.05694842f, 0.04328569f, 0.00274787f, -0.03925725f, 0.04090314f, 
    0.01701324f, 0.02777541f, 0.03460930f, -0.03080735f, -0.04883252f, -0.00267303f, 0.00903434f, -0.05491264f, 
    -0.00013574f, -0.03029653f, 0.01962284f, 0.01841960f, 0.01069341f, 0.03785189f, -0.03809812f, 0.02207352f, 
    0.02970245f, 0.00350220f, 0.02681860f, -0.04800486f, -0.03229912f, 0.03505814f, -0.03582485f, 0.00349310f, 
    0.00102565f, 0.00170473f, 0.01182837f, -0.01225137f, 0.04310292f, -0.04220815f, -0.05313003f, -0.01629074f, 
    -0.03346850f, -0.01513469f, 0.01392927f, 0.03127482f, -0.05209536f, 0.03805651f, -0.05565297f, 0.00702224f, 
    0.04349620f, -0.05428902f, -0.05147136f, -0.04461920f, 0.03159885f, -0.05802073f, -0.00054507f, 0.04069739f, 
    -0.03044663f, 0.00709272f, -0.02585448f, -0.01732001f, -0.00247958f, -0.05731181f, -0.03147008f, 0.02042427f, 
    0.00754164f, 0.02794167f, 0.03803463f, -0.02796067f, -0.00193778f, 0.02010524f, -0.04112776f, -0.03715619f, 
    -0.05179364f, 0.03829376f, 0.00289234f, 0.00478422f, 0.04406354f, -0.05043429f, -0.04716022f, 0.04240495f, 
    -0.02999080f, 0.00528354f, -0.01712646f, -0.03060343f, -0.04385386f, 0.03509299f, -0.02128083f, 0.03863534f, 
    -0.00156561f, -0.02989757f, -0.03493533f, -0.04717361f, 0.00625029f, 0.04962055f, 0.02746377f, 0.02910466f, 
    -0.01429847f, 0.00574779f, -0.04941915f, -0.04404840f, 0.00014497f, -0.01549393f, 0.03151188f, 0.02103097f, 
    -0.02890456f, 0.02097880f, 0.03256826f, 0.01583622f, -0.04785173f, -0.01003221f, -0.00991517f, -0.03377890f, 
    0.01799017f, -0.01901452f, -0.02960584f, -0.00340944f, -0.04541147f, -0.05753652f, -0.01617652f, 0.00618555f, 
    -0.05754728f, -0.00095493f, 0.02872380f, 0.01588909f, -0.04036200f, -0.02673027f, 0.03745674f, -0.04773951f, 
    0.00279545f, -0.00961948f, 0.02586666f, -0.02843153f, -0.00486846f, 0.00216731f, -0.03505233f, 0.00724365f, 
    0.00552538f, -0.05544737f, -0.01408588f, -0.01272471f, 0.01370268f, -0.04269367f, 0.03493033f, -0.02534030f, 
    -0.05339320f, -0.04633362f, -0.02161049f, -0.01174112f, 0.02424231f, 0.03100516f, 0.04361531f, -0.01327864f, 
    0.00294640f, -0.04665410f, 0.03999226f, 0.04192588f, -0.03952681f, -0.02056103f, -0.00338179f, -0.02306320f, 
    0.03182159f, 0.01522270f, 0.01480532f, -0.00096916f, -0.01827571f, -0.01527991f, -0.03182827f, -0.00056945f, 
    0.03606233f, -0.01179958f, 0.02997065f, -0.02521929f, 0.04057383f, -0.03823286f, 0.03376178f, -0.01370599f, 
    -0.00442743f, 0.02465257f, -0.00760600f, -0.00379543f, -0.03542832f, -0.04122313f, -0.05504543f, 0.03341860f, 
    -0.01760340f, -0.00766402f, 0.03246342f, 0.00387109f, -0.01078578f, 0.02813544f, 0.04136482f, -0.01600257f, 
    0.04404326f, 0.04024759f, -0.00973675f, -0.02377883f, 0.01588851f, -0.03598974f, -0.05613767f, -0.02218008f, 
    -0.01569954f, -0.02132804f, 0.03670958f, -0.02117012f, -0.00218184f, -0.04682574f, -0.00791445f, -0.05816961f, 
    -0.05747113f, -0.02551672f, 0.00038436f, -0.01045170f, -0.05159846f, 0.00074218f, -0.04101698f, -0.04091739f, 
    0.02860407f, -0.05082360f, 0.02908153f, -0.05497979f, -0.02766282f, 0.00515096f, -0.02299056f, 0.02300861f, 
    -0.01748771f, -0.00357729f, 0.02689964f, -0.05836655f, -0.00113463f, 0.01222572f, -0.04142718f, 0.00204904f, 
    -0.04292538f, -0.01070242f, 0.02505646f, -0.01751628f, 0.03701540f, -0.04998313f, -0.05509514f, 0.00771327f, 
    -0.00683861f, -0.00841528f, 0.02084655f, 0.01423864f, -0.01134884f, 0.03339627f, -0.02523936f, -0.02117355f, 
    -0.05759333f, -0.02117245f, -0.04034802f, 0.02902388f, -0.05412636f, 0.04366429f, -0.04958114f, 0.00868268f, 
    -0.04036397f, -0.00293530f, 0.04115381f, -0.03273177f, -0.04629084f, 0.00247958f, 0.00687988f, 0.01274122f, 
    0.02964657f, -0.02375896f, -0.04680336f, -0.05308564f, 0.04405797f, -0.02177014f, -0.05157718f, 0.00729426f, 
    -0.05631666f, 0.03874342f, 0.00947628f, 0.02052214f, 0.02218315f, -0.03519905f, 0.02642784f, 0.00582849f, 
    -0.04239333f, -0.01482072f, -0.01726581f, 0.04992754f, -0.00975451f, -0.04844801f, -0.04792679f, 0.02637520f, 
    -0.04607930f, 0.03123364f, -0.01900775f, -0.04052386f, -0.05389817f, -0.01705658f, -0.00624214f, 0.02099694f, 
    -0.01268324f, -0.02683467f, 0.03458088f, -0.01845101f, -0.01543715f, 0.04309237f, 0.00900009f, -0.05386789f, 
    -0.02574087f, 0.03466933f, -0.05229686f, -0.01938934f, -0.03781011f, 0.04010059f, -0.04052922f, 0.04545216f, 
    -0.02332725f, 0.03903295f, -0.00260945f, -0.01954636f, -0.00327600f, -0.01435897f, -0.01851384f, -0.01464065f, 
    -0.03882349f, -0.05192515f, 0.03631682f, -0.00288813f, -0.04294021f, 0.00604576f, 0.02157824f, 0.02283565f, 
    -0.04272638f, -0.03645901f, 0.01643661f, 0.01589287f, -0.05067651f, 0.03618586f, 0.01218228f, 0.03724374f, 
    0.00976342f, 0.03714558f, 0.04108277f, -0.02659361f, -0.03853324f, 0.02443954f, 0.00280986f, -0.01069157f, 
    0.04060901f, 0.02294487f, -0.04053773f, 0.02396696f, -0.03328899f, -0.00127963f, -0.05479335f, -0.01983456f, 
    -0.00262841f, 0.01096077f, 0.02247804f, 0.04589592f, -0.01622702f, -0.03032156f, -0.00550810f, -0.04976229f, 
    -0.01773871f, -0.01023456f, 0.04019120f, -0.02363723f, 0.01494079f, -0.03927241f, -0.01387269f, -0.04163461f, 
    0.04014468f, -0.02727592f, 0.02765243f, -0.05411037f, 0.00589767f, 0.01357172f, -0.05593760f, -0.04784217f, 
    -0.03596072f, 0.02042765f, 0.01197638f, -0.03150387f, 0.02367690f, -0.00486655f, 0.03095336f, -0.02968461f, 
    0.00106645f, -0.02125212f, -0.03821449f, 0.03308113f, 0.02908581f, -0.00967989f, 0.00418098f, 0.03424814f, 
    0.03903611f, 0.02023457f, 0.02608813f, -0.00966118f, -0.01364570f, 0.03737510f, -0.04005849f, -0.03440878f, 
    0.00506945f, 0.04572973f, -0.03451188f, 0.00293548f, -0.01183198f, -0.02330410f, 0.04246495f, 0.03016593f, 
    -0.02954376f, -0.00958233f, -0.04346777f, -0.01428415f, 0.00470206f, 0.02892868f, -0.00043543f, 0.04439009f, 
    -0.01718205f, -0.03807106f, -0.01152403f, -0.05047608f, 0.00520136f, 0.03399807f, -0.01265848f, 0.00537043f, 
    -0.04371005f, 0.00934406f, -0.02327724f, -0.03601580f, -0.03853239f, -0.04896155f, -0.02472439f, 0.00682724f, 
    -0.04546376f, -0.04257952f, -0.01959414f, -0.03545927f, -0.01981274f, -0.04644569f, -0.03240855f, 0.04196974f, 
    -0.03392345f, -0.02022270f, 0.02245771f, -0.01083541f, 0.02954344f, 0.00186226f, -0.01439281f, -0.03180109f, 
    0.00642915f, -0.01357741f, 0.00132797f, -0.00265354f, -0.02132397f, 0.00087524f, 0.04040238f, 0.03757032f, 
    -0.00694256f, 0.01512641f, -0.01096634f, 0.02026778f, 0.03015765f, 0.00760648f, -0.01382090f, -0.00955703f, 
    -0.04276459f, 0.03157654f, 0.00491607f, 0.00882793f, 0.00156788f, 0.03717963f, -0.03888272f, 0.02814029f, 
    0.04165336f, -0.00194550f, 0.04590000f, -0.01760126f, -0.03525290f, -0.01242092f, 0.03376705f, 0.04117014f, 
    -0.00858350f, -0.00560404f, -0.04267293f, -0.03628771f, -0.04222607f, 0.01414502f, -0.01992540f, -0.03077269f, 
    -0.02080174f, -0.04069439f, 0.02081496f, 0.01109440f, -0.00717805f, 0.01820442f, -0.01358898f, -0.02091398f, 
    0.04004179f, -0.01723766f, 0.01859369f, -0.00982117f, -0.01629585f, -0.01869402f, -0.01377053f, -0.05304325f, 
    -0.05709569f, -0.04068094f, 0.03677456f, 0.03596815f, 0.01377875f, 0.02357230f, -0.01639209f, 0.03794549f, 
    0.03195258f, -0.05400481f, -0.00487498f, 0.01399950f, 0.02150333f, 0.03604360f, -0.04690892f, 0.01618302f, 
    -0.02010313f, -0.01784691f, 0.00821156f, 0.01452438f, -0.05436119f, -0.01774647f, -0.00952325f, -0.02221826f, 
    -0.03800711f, 0.02732290f, 0.04124499f, 0.02348453f, -0.04586104f, 0.01032282f, -0.00470555f, -0.03090987f, 
    0.04646686f, -0.00846985f, 0.01314271f, 0.01320592f, 0.03956232f, -0.04975039f, 0.00932250f, 0.03811526f, 
    -0.05430778f, -0.02721110f, 0.00538248f, -0.04675588f, 0.04400294f, -0.05307472f, -0.04854736f, 0.04329330f, 
    -0.05378312f, -0.04730466f, -0.02909095f, -0.04495561f, 0.00775000f, -0.03383965f, -0.03672400f, 0.04253577f, 
    -0.04532357f, 0.01636039f, 0.01792563f, 0.01722512f, -0.04724145f, -0.01696715f, -0.04848366f, -0.02761465f, 
    -0.00562674f, 0.01533072f, -0.00207110f, -0.05113455f, -0.02827494f, 0.01099136f, -0.05723258f, -0.01036454f, 
    -0.04981472f, 0.03830159f, 0.03191673f, 0.02013863f, 0.01027790f, 0.00912455f, -0.02305174f, -0.01030352f, 
    -0.05869463f, -0.04897291f, -0.00268207f, 0.03778668f, 0.00072654f, 0.02185551f, -0.01996345f, -0.02298768f, 
    -0.02393003f, 0.00270868f, -0.03418714f, 0.02320368f, 0.02303535f, 0.02438501f, -0.05674894f, -0.02928294f, 
    -0.04087121f, 0.01316389f, -0.04469414f, -0.05281952f, -0.00086237f, 0.02148218f, -0.02530180f, -0.02021927f, 
    0.00087923f, -0.05506689f, -0.00778806f, -0.00301143f, 0.00093103f, -0.02077410f, 0.03610430f, 0.01454875f, 
    0.00571426f, 0.03380691f, 0.01380057f, 0.00781830f, -0.03979633f, 0.00638479f, 0.01480212f, -0.00257373f, 
    0.03687348f, -0.02880168f, -0.00048168f, -0.04823530f, 0.01867517f, -0.04327260f, -0.01202722f, -0.01040189f, 
    -0.02026370f, -0.03350368f, 0.00813182f, -0.03209751f, 0.02520126f, 0.03387813f, -0.00203502f, 0.00735291f, 
    0.00776954f, -0.00327748f, 0.03361885f, 0.00443759f, 0.03178304f, -0.03992777f, -0.05297358f, 0.03892320f, 
    -0.09662502f, -0.12129938f, -0.07265967f, 0.04404991f, 0.03091702f, 0.00181288f, -0.04995609f, -0.07614668f, 
    -0.14799482f, -0.14902568f, -0.05902516f, -0.08021435f, 0.26391494f, -0.04732239f, 0.06103231f, -0.11035508f, 
    0.14788485f, -0.06259418f, -0.02796586f, 0.18033120f, -0.02031594f, -0.04132641f, 0.06406832f, -0.00275521f, 
    0.20902647f, -0.26182026f, -0.03141801f, -0.09624454f, -0.10779392f, -0.05403158f, -0.20609316f, 0.05053364f, 
    0.01998324f, -0.10995265f, 0.16571440f, -0.20556030f, -0.00050849f, 0.04023143f, 0.17027271f, -0.12782416f, 
    -0.07741010f, -0.03182748f, -0.15012564f, 0.12091666f, 0.05674949f, 0.00079051f, 0.05368498f, 0.01312425f, 
    -0.19677709f, -0.39129803f, -0.05949160f, 0.08084580f, 0.09981160f, -0.02252144f, -0.00557221f, -0.04829213f, 
    -0.08363894f, 0.04864196f, 0.06432787f, -0.08821617f, -0.01982290f, -0.13773341f, -0.24234113f, -0.18359885f, 
    0.01150859f, 0.10382729f, 0.00960418f, 0.11684731f, -0.04386280f, 0.10164803f, 0.07536455f, -0.07272247f, 
    -0.61832541f, -0.07265116f, 0.04116627f, -0.06539823f, 0.07136276f, -0.00659355f, -0.11230826f, 0.16567589f, 
    0.05943051f, 0.05044274f, 0.01627991f, -0.04524819f, -0.12323786f, -0.07275651f, -0.09484839f, 0.03250936f, 
    0.03748833f, 0.31772336f, -0.02331372f, -0.00826609f, 0.09065468f, 0.01917039f, 0.04135427f, 0.06191272f, 
    0.10521749f, -0.21459784f, 0.04927366f, 0.35866088f, -0.06196295f, -0.07059462f, -0.11601890f, -0.08781895f, 
    0.14567894f, 0.04392676f, 0.03189885f, 0.00783110f, -0.04508893f, 0.04074530f, 0.18107593f, 0.18107539f, 
    -0.12340869f, -0.16550723f, -0.04420020f, -0.11536626f, -0.03223874f, -0.02276218f, 0.02243353f, -0.00777639f, 
    -0.01420857f, 0.14372745f, 0.15632690f, 0.04579062f, -0.07385340f, 0.06275047f, 0.12339986f, 0.00827534f, 
    0.03542116f, 0.05790105f, 0.07018330f, 0.05147408f, -0.06628349f, -0.12892337f, 0.01962581f, -0.01400607f, 
    0.01042749f, -0.12346461f, -0.05717426f, -0.04344962f, 0.04945994f, -0.00365615f, 0.02154658f, 0.14448763f, 
    -0.00759573f, 0.10341393f, 0.12011810f, 0.06882218f, 0.09508037f, 0.04460696f, 0.06315694f, -0.11523650f, 
    -0.03076042f, -0.11450519f, -0.00952525f, 0.06182670f, 0.14038180f, -0.30675274f, 0.15841185f, -0.08043737f, 
    -0.10097405f, -0.06016796f, -0.13545965f, -0.08217629f, -0.00799869f, 0.15796947f, -0.02443423f, 0.13057217f, 
    0.09963940f, 0.11273306f, -0.10536176f, 0.21927536f, -0.06562241f, -0.10904036f, -0.06336112f, 0.11839349f, 
    0.01353085f, -0.14404288f, 0.06284656f, -0.06121962f, 0.31842333f, -0.04710060f, -0.09453415f, -0.35938200f, 
    -0.03322851f, -0.02853784f, 0.19476108f, 0.05905245f, -0.09544593f, -0.03854181f, 0.08275639f, 0.03793694f, 
    0.41501230f, -0.12181532f, -0.10279617f, 0.13908496f, 0.08185282f, -0.11480872f, 0.01095655f, 0.00754424f, 
    0.04253842f, -0.04869450f, 0.00199962f, -0.02228469f, 0.70283270f, -0.24918912f, 0.41871276f, -0.63113099f, 
    -0.06355201f, -0.06965576f, -0.10683969f, -0.05389185f, 0.05951629f, 0.07932635f, 0.06943195f, 0.00022280f, 
    -0.01083550f, 0.19160655f, -0.18220939f, -0.27412599f, 0.07948966f, -0.01275837f, -0.03553928f, 0.10976339f, 
    -0.02132555f, 0.12534717f, 0.06209174f, 0.22799645f, -0.09475280f, 0.07150640f, 0.02925044f, 0.10656723f, 
    0.02326380f, 0.00766576f, 0.05352484f, 0.04439712f, 0.01714289f, -0.00015244f, 0.02227947f, 0.00960445f, 
    -0.11953285f, 0.21025243f, 0.07004645f, -0.15229851f, 0.00890510f, 0.04593487f, 0.00155231f, -0.04432030f, 
    -0.00923418f, -0.02916234f, 0.11813460f, -0.01921253f, -0.26136482f, 0.24112280f, -0.36620206f, -0.21031748f, 
    0.22061636f, -0.00833258f, 0.05241925f, 0.07329652f, 0.03836903f, 0.06584772f, -0.00279172f, -0.01430922f, 
    0.06260438f, -0.19211736f, -0.00295000f, 0.19262671f, 0.02455339f, -0.13190854f, -0.13399073f, -0.14159307f, 
    -0.02382055f, 0.01519601f, -0.04839430f, 0.16942070f, 0.08311662f, -0.22739914f, 0.14209704f, -0.13286667f, 
    0.09548377f, -0.10669775f, -0.09435048f, 0.11284270f, 0.02826164f, -0.05712545f, -0.04431019f, -0.12162847f, 
    -0.12853073f, -0.01255601f, 0.16059320f, 0.07524089f, -0.13958448f, 0.08356080f, -0.02341102f, 0.03165967f, 
    -0.15884241f, 0.02337310f, -0.01434537f, -0.03821837f, 0.33378392f, 0.54725283f, -0.14778775f, -0.05364338f, 
    -0.18347712f, 0.02845280f, 0.09007966f, 0.18521263f, -0.01121498f, 0.01015930f, -0.06734457f, 0.13797723f, 
    -0.64062226f, 0.15875214f, -0.03013504f, 0.10794797f, 0.04620177f, -0.01212698f, -0.16270746f, -0.13358104f, 
    0.16347696f, -0.01673186f, -0.12036158f, 0.19127761f, 0.20575880f, -0.39408344f, 0.10671691f, -0.21629032f, 
    -0.02926869f, 0.04336672f, 0.03394265f, 0.02317755f, -0.05234761f, -0.07033999f, -0.08039758f, -0.05840009f, 
    -0.13583608f, 0.02110502f, 0.40015098f, -0.02466362f, 0.18118767f, 0.08025316f, 0.11210289f, 0.15876238f, 
    0.01974161f, 0.07340243f, 0.00606999f, 0.01248067f, -0.13865207f, -0.20549248f, -0.06125640f, 0.31567243f, 
    -0.02712674f, 0.03364741f, -0.09592532f, 0.09851014f, 0.10287753f, -0.07946552f, 0.13752629f, 0.11414730f, 
    -0.01644327f, -0.23676956f, -0.23636420f, -0.09912375f, -0.00017098f, 0.02157215f, 0.00207222f, 0.02812096f, 
    0.05535135f, 0.01290903f, -0.01818887f, 0.00095504f, 0.20915367f, 0.01171245f, -0.05615201f, -0.05441647f, 
    0.16204642f, 0.00997191f, 0.26293924f, 0.17036097f, 0.14199077f, 0.06760995f, -0.16915408f, -0.00471603f, 
    0.02753159f, -0.05595625f, 0.02595444f, 0.03781354f, 0.01500731f, -0.01010542f, -0.01032069f, -0.02399908f, 
    0.00875335f, -0.03040808f, 0.01857982f, -0.02166040f, 0.01329541f, -0.00551143f, -0.02154310f, 0.00308504f, 
    0.03078192f, 0.03804623f, -0.04095849f, -0.00119021f, -0.00040414f, 0.01449472f, 0.03765921f, 0.02165899f, 
    -0.00111665f, -0.04301620f, -0.00399982f, -0.05678055f, -0.05068841f, -0.02047253f, 0.00046951f, -0.01310391f, 
    -0.00480015f, -0.03044611f, -0.05546034f, -0.00075379f, -0.03734630f, -0.01801727f, -0.03439629f, -0.05340901f, 
    -0.00065379f, -0.02559564f, -0.04812019f, -0.04609807f, 0.02460575f, 0.00010832f, -0.03037295f, -0.01804025f, 
    0.01763592f, 0.02624717f, -0.01588750f, 0.03277097f, -0.05641251f, 0.03324485f, -0.00153962f, -0.03287588f, 
    0.02389866f, -0.02299370f, -0.02620234f, -0.01566987f, 0.01848715f, -0.02363308f, -0.00857125f, -0.04986975f, 
    -0.00473979f, 0.01901549f, -0.04744841f, -0.00087729f, 0.00949878f, -0.00914602f, 0.01068495f, -0.05009430f, 
    -0.03505476f, -0.00816157f, 0.00231037f, 0.03819785f, 0.01075398f, -0.04158957f, -0.04941173f, -0.03317850f, 
    0.01233921f, -0.05155193f, 0.02146871f, -0.02592566f, 0.03780413f, -0.03635642f, -0.04117916f, -0.01381438f, 
    -0.01629926f, -0.02112069f, -0.00276888f, 0.03895028f, 0.03862317f, -0.01715494f, 0.01822813f, 0.01257779f, 
    -0.04694399f, 0.00325807f, -0.03182644f, -0.03060924f, -0.02746394f, -0.03096785f, -0.05690585f, 0.00710576f, 
    -0.03210776f, -0.01661262f, -0.00300753f, 0.01354546f, -0.02080875f, -0.03029076f, -0.00262813f, 0.03507299f, 
    -0.01606492f, 0.01807154f, -0.00329480f, -0.03481392f, 0.00439778f, 0.02678332f, 0.02066558f, 0.00311012f, 
    -0.00768826f, -0.00917127f, -0.01085270f, -0.05380302f, 0.03191876f, 0.00564904f, 0.00522858f, -0.03230891f, 
    0.01321317f, -0.02580585f, -0.01898308f, -0.05402253f, -0.02861708f, 0.01621612f, 0.02614516f, -0.04065473f, 
    0.01693758f, -0.04225518f, 0.04179758f, 0.01779672f, -0.05057799f, -0.02581920f, -0.04930149f, -0.04677466f, 
    0.01828178f, 0.03135283f, -0.03397571f, 0.00808888f, 0.01634813f, -0.04915375f, 0.00605230f, -0.05104452f, 
    -0.05076605f, -0.05703948f, -0.04246310f, 0.03720640f, 0.00853851f, 0.03313015f, 0.00632632f, -0.03138699f, 
    -0.02613685f, -0.01588898f, -0.03725157f, 0.02110511f, 0.02980584f, 0.01400349f, -0.02876944f, -0.03154949f, 
    -0.03474418f, 0.00559613f, 0.03461640f, -0.00075005f, -0.02672266f, -0.01113664f, 0.00785470f, 0.02927966f, 
    0.00652888f, 0.01813158f, -0.03343382f, 0.04110079f, -0.01657770f, -0.04113527f, -0.03001375f, 0.01496911f, 
    -0.04761458f, -0.04195379f, 0.00344060f, 0.02517460f, -0.02969504f, -0.05233651f, -0.00751967f, 0.00450564f, 
    0.01186377f, -0.04742146f, -0.04680216f, -0.05542453f, -0.03769417f, 0.04183911f, -0.01136544f, 0.01135282f, 
    0.04266593f, -0.03508400f, -0.01160382f, -0.00442810f, -0.05262008f, -0.00386900f, 0.01107637f, 0.02605520f, 
    -0.01184990f, -0.03856717f, 0.02091613f, -0.03089413f, -0.00914996f, 0.04333718f, 0.04170565f, 0.00237828f, 
    -0.00841079f, -0.03090232f, 0.00380962f, 0.03116187f, 0.03094498f, -0.01402474f, 0.01270634f, 0.00761132f, 
    0.00529954f, -0.05142372f, 0.00968235f, -0.01994096f, -0.02207235f, -0.00668747f, -0.00288017f, 0.02460102f, 
    -0.05199967f, 0.00704594f, 0.02898010f, 0.01858336f, 0.04178145f, 0.03496809f, 0.02072063f, -0.02466554f, 
    -0.02575823f, 0.00605239f, -0.03193088f, 0.00347565f, 0.00084416f, 0.00668529f, -0.03406902f, 0.02791465f, 
    -0.00490576f, -0.00044055f, -0.03898286f, -0.02660985f, -0.01071003f, -0.02398105f, 0.04057576f, -0.00902565f, 
    -0.02899928f, 0.03176825f, 0.03234213f, -0.00262977f, -0.05342329f, -0.04444392f, 0.03089126f, -0.05254163f, 
    -0.04728679f, -0.01231475f, 0.01711277f, -0.00605727f, -0.00026966f, 0.01123775f, -0.03471392f, -0.01689851f, 
    0.01039153f, 0.00677040f, 0.02249723f, -0.00718903f, -0.00993273f, -0.05322702f, 0.04178747f, -0.02506888f, 
    -0.05660160f, -0.00795173f, 0.01131274f, -0.01517915f, -0.04713918f, -0.03835961f, -0.01915776f, -0.04248416f, 
    0.02487481f, -0.04163181f, -0.00419655f, -0.01949016f, 0.02427043f, -0.03335642f, -0.01317319f, -0.00571506f, 
    -0.02749086f, -0.02339770f, 0.00642468f, -0.04217211f, 0.02313955f, -0.00794228f, 0.04353202f, -0.05112848f, 
    0.02414890f, 0.00989653f, 0.02187375f, -0.01600980f, 0.02974244f, -0.01687682f, -0.01802642f, 0.02678443f, 
    -0.02321502f, 0.01862509f, -0.04032417f, -0.00353532f, -0.00346772f, 0.04387515f, -0.02561114f, 0.01242992f, 
    0.02096477f, -0.00262427f, -0.01478815f, 0.03377916f, -0.00687147f, -0.02261247f, -0.01805717f, 0.01094958f, 
    -0.01302621f, 0.03898743f, -0.01365105f, -0.03275080f, -0.05115430f, -0.02647135f, 0.03716491f, 0.00213361f, 
    0.02897818f, -0.05535262f, 0.00846454f, -0.04963599f, -0.05631308f, -0.03223738f, -0.03964038f, 0.00597126f, 
    0.03699144f, -0.01988365f, -0.00293697f, -0.00529219f, 0.02414066f, -0.02577391f, -0.04437652f, -0.03903568f, 
    0.00671944f, -0.03055241f, 0.03389541f, -0.04364126f, -0.01024929f, 0.04326585f, 0.04006158f, 0.00657696f, 
    -0.00090604f, -0.01825703f, -0.03834669f, 0.01284238f, 0.01892322f, -0.04392105f, 0.02496718f, -0.02462401f, 
    -0.00928685f, 0.02338275f, -0.05629691f, -0.03190054f, 0.04269482f, 0.00061663f, -0.03221156f, -0.03921349f, 
    0.01110207f, 0.03748120f, 0.00177832f, 0.03940272f, -0.04348653f, -0.02194657f, -0.02409608f, 0.03165183f, 
    0.08982041f, 0.29704621f, 0.11462126f, -0.10340133f, -0.06651023f, 0.06232841f, -0.08197342f, 0.10031182f, 
    0.00248557f, 0.14919941f, 0.08098133f, 0.05855503f, -0.08540756f, -0.04944596f, -0.02731440f, 0.08143764f, 
    -0.02686233f, -0.10272150f, 0.15130961f, -0.01760723f, -0.21498655f, -0.07671817f, -0.07294174f, -0.17280594f, 
    -0.10780232f, 0.08409031f, 0.15119907f, 0.18593986f, -0.02789552f, 0.10708473f, 0.09527163f, 0.03371913f, 
    0.13655849f, 0.01721403f, 0.50289845f, 0.07230865f, -0.02462837f, -0.00936753f, -0.11388848f, 0.12101217f, 
    -0.01085686f, 0.02011705f, 0.17917216f, 0.14272992f, -0.07517388f, 0.00625196f, -0.00928390f, 0.06541465f, 
    0.10154936f, 0.11909911f, -0.25493473f, -0.02367880f, -0.01968458f, -0.04873515f, -0.12808394f, 0.11714073f, 
    -0.14406250f, -0.08121698f, 0.09651227f, -0.03503730f, 0.05077125f, 0.17822593f, 0.24754441f, 0.20021364f, 
    -0.15300959f, 0.20114462f, 0.06145644f, -0.07162309f, 0.03246351f, 0.02377675f, -0.09964057f, -0.07297964f, 
    0.03690720f, 0.12871693f, -0.19254956f, -0.29226109f, 0.20250633f, 0.03936176f, 0.10731803f, 0.18372390f, 
    -0.03922385f, -0.06141551f, 0.10394774f, 0.03349331f, 0.02286607f, -0.00707195f, 0.07012077f, 0.06512757f, 
    -0.05902920f, -0.03555898f, -0.02268076f, -0.10515437f, -0.18158169f, -0.11440130f, -0.11031438f, -0.19010764f, 
    0.15665306f, 0.20091325f, -0.32712159f, -0.12982872f, 0.25750136f, 0.00962622f, 0.18231362f, 0.09676132f, 
    0.02572559f, 0.05306467f, 0.08370576f, 0.01829126f, -0.02690320f, -0.18670334f, -0.14342706f, -0.15229730f, 
    -0.01647201f, 0.01089054f, 0.12073422f, 0.01434256f, -0.11778424f, -0.04277582f, -0.04730636f, -0.07979181f, 
    -0.15943697f, -0.21483320f, 0.00624503f, 0.06361885f, -0.06397395f, -0.01191305f, -0.04216179f, 0.04915583f, 
    -0.11128987f, -0.07910321f, -0.02917117f, 0.04519002f, 0.18917309f, -0.10459702f, -0.08063394f, -0.16331515f, 
    -0.15780069f, 0.04185816f, 0.07336994f, -0.03742948f, 0.16671246f, 0.01022134f, 0.06539763f, 0.18878187f, 
    0.18094018f, -0.11414215f, 0.05060578f, -0.01087162f, -0.01283657f, 0.08681259f, 0.01663566f, 0.04259909f, 
    -0.11485162f, -0.00698879f, 0.01217474f, -0.06168306f, 0.21344297f, 0.20936106f, -0.02360792f, 0.26032045f, 
    -0.04904086f, 0.00518529f, 0.07925304f, -0.02610621f, 0.02477297f, 0.17373610f, 0.00033665f, 0.04189378f, 
    -0.08967347f, -0.25921583f, 0.10300608f, 0.09844774f, -0.14688665f, -0.14200604f, 0.01102622f, 0.04176503f, 
    -0.02550283f, 0.01737610f, -0.00883931f, -0.09234876f, 0.05383211f, -0.07420722f, -0.15342422f, -0.13525532f, 
    -0.07668214f, -0.16140237f, 0.14660199f, 0.05391977f, -0.06346196f, 0.02329824f, 0.01005778f, -0.03704536f, 
    0.24523038f, 0.35833153f, 0.40512747f, 0.10652439f, -0.22595079f, -0.15186353f, -0.01314486f, -0.02845304f, 
    0.04099771f, 0.05822145f, -0.04676013f, -0.08514748f, 0.05614157f, 0.09688598f, 0.00080067f, 0.04321425f, 
    -0.12958995f, -0.00450422f, 0.06353876f, -0.04340135f, 0.11626488f, 0.06363506f, -0.14672905f, -0.05278791f, 
    0.01219865f, 0.02854679f, 0.19741882f, 0.06324620f, -0.10819338f, 0.13210663f, 0.19906047f, -0.03419667f, 
    0.18280786f, 0.02474240f, 0.21765542f, 0.15074928f, 0.21543851f, 0.11072215f, 0.13284104f, 0.10406167f, 
    -0.05051354f, -0.09481792f, 0.01476653f, 0.01361318f, -0.10042200f, 0.10683578f, -0.10282852f, -0.09557447f, 
    0.01084659f, -0.13312900f, -0.03403995f, 0.02565254f, 0.00300635f, 0.03533192f, -0.03906626f, -0.05613117f, 
    -0.03140098f, 0.14357367f, 0.13207200f, -0.01099561f, 0.20003995f, 0.02291485f, 0.19872651f, 0.00186223f, 
    0.02623460f, 0.08347441f, 0.06257387f, 0.07789163f, 0.16771720f, 0.01866281f, 0.07150365f, -0.19689853f, 
    0.19579905f, -0.09067617f, -0.34984064f, -0.05248021f, 0.05463329f, -0.09689179f, -0.07745923f, -0.11369848f, 
    -0.04748638f, 0.09328838f, 0.14742054f, -0.05427058f, -0.27736092f, -0.03749106f, -0.16047832f, 0.13664068f, 
    0.07495397f, 0.13090178f, 0.10593956f, -0.03354716f, 0.01721088f, 0.08002310f, 0.05753165f, 0.08978489f, 
    0.02514344f, 0.10652590f, 0.07130168f, 0.05837618f, -0.13279095f, -0.08827624f, -0.09706475f, -0.09016906f, 
    -0.05180334f, 0.03600298f, 0.00280201f, -0.17904949f, -0.09285663f, -0.13191010f, 0.24373919f, 0.15638995f, 
    -0.09582292f, 0.15930831f, 0.10309606f, -0.02270797f, 0.00069353f, -0.08413953f, 0.11587823f, 0.08210860f, 
    0.40266439f, -0.04042783f, -0.06726734f, -0.00085939f, -0.04265677f, 0.13663484f, 0.08085208f, -0.00327854f, 
    -0.03334420f, -0.14818271f, -0.05670546f, 0.10208407f, -0.12410654f, 0.02983062f, -0.13755716f, 0.07370899f, 
    0.03603630f, 0.12021171f, 0.13385044f, 0.22949332f, -0.04215894f, -0.05295625f, 0.00901146f, 0.03042350f, 
    -0.35210630f, -0.30328634f, -0.09436566f, 0.01822308f, 0.03789115f, -0.03504606f, 0.18136083f, 0.12979110f, 
    -0.02791457f, 0.18654279f, 0.02182995f, 0.01886244f, -0.03781407f, 0.14303090f, -0.06843131f, -0.01027891f, 
    0.02417632f, -0.02420812f, 0.09450404f, 0.06520314f, -0.09504589f, -0.04149762f, 0.16098779f, -0.07209553f, 
    0.32033488f, 0.21642347f, 0.19140874f, 0.06068042f, -0.09013251f, -0.00206827f, -0.05200393f, 0.08572745f, 
    0.05026390f, 0.05953021f, -0.07097009f, -0.05636778f, 0.03642245f, 0.10424263f, 0.11414166f, 0.01330023f, 
    -0.08018060f, -0.10033632f, 0.12800822f, -0.02943720f, -0.08902054f, 0.14192303f, -0.11128318f, 0.02153130f, 
    0.08930613f, 0.02749363f, 0.10787411f, -0.06343050f, -0.01618512f, 0.01620577f, 0.00585808f, -0.02153429f, 
    0.25985697f, -0.04536525f, 0.00361596f, -0.09882271f, 0.02201737f, 0.01159784f, 0.01632839f, -0.12798698f, 
    -0.05545935f, 0.12974800f, 0.15865690f, 0.01542130f, 0.05896814f, 0.14919844f, 0.04578358f, 0.10828931f, 
    0.11422382f, -0.11292368f, 0.05211785f, -0.13007122f, 0.11773166f, 0.04047736f, -0.01570786f, -0.11734597f, 
    0.04538511f, 0.03408416f, -0.21488106f, 0.02695299f, -0.23831259f, 0.12340859f, 0.16308163f, -0.13891606f, 
    -0.00933285f, 0.03248160f, -0.11125261f, 0.04628992f, -0.12923294f, 0.01501066f, 0.01198365f, 0.01920421f, 
    0.38262141f, -0.20348705f, 0.31609458f, 0.17347236f, 0.02302040f, 0.00951087f, -0.05273883f, -0.01748290f, 
    -0.01662588f, 0.17086281f, -0.05230008f, 0.02342856f, -0.02797227f, 0.22208023f, 0.01266300f, -0.14352547f, 
    -0.02640436f, -0.01783523f, 0.05165363f, 0.07821875f, 0.08507625f, -0.26534927f, 0.22126216f, -0.02186906f, 
    0.31102031f, 0.30495828f, -0.14611630f, 0.06338455f, -0.08629700f, -0.25517476f, 0.03216739f, 0.15449619f, 
    -0.19609258f, 0.02667576f, -0.13234834f, 0.06048794f, 0.05348267f, -0.02330550f, 0.08144704f, -0.06940228f, 
    -0.07070982f, -0.05733179f, -0.04583571f, 0.02029111f, 0.07323460f, 0.05999237f, 0.09327513f, 0.09785782f, 
    0.14484397f, -0.05875719f, 0.14670184f, -0.28869560f, 0.00901530f, -0.05594598f, -0.03122993f, 0.08501439f, 
    -0.13351744f, 0.01413956f, -0.08909614f, 0.01256644f, -0.11365861f, -0.19108278f, -0.03097255f, 0.02963277f, 
    0.15941079f, 0.20794769f, 0.13812399f, 0.26134819f, 0.00653272f, -0.04616233f, 0.00203353f, 0.03305167f, 
    -0.11186802f, 0.11435970f, 0.00747378f, 0.02686505f, 0.10704205f, -0.09088132f, 0.08090458f, -0.10156297f, 
    -0.03248303f, -0.04535880f, 0.02524201f, 0.00077925f, -0.08809182f, -0.04031979f, -0.12192470f, -0.01747780f, 
    0.01608435f, -0.00257878f, 0.08403071f, -0.05989170f, 0.07616795f, -0.03935814f, 0.02986998f, -0.14750831f, 
    -0.11027204f, 0.00068981f, -0.02620795f, -0.04037648f, -0.01478020f, -0.20281048f, 0.06159096f, 0.21485171f, 
    -0.08215457f, -0.11007245f, 0.01121140f, -0.00782240f, -0.09790950f, 0.05493844f, 0.16232035f, -0.22329424f, 
    0.03918369f, -0.12330713f, -0.03395400f, -0.01938544f, 0.09198363f, -0.06155605f, 0.05628280f, -0.07396164f, 
    0.15477987f, 0.01881620f, -0.27680996f, -0.16134205f, 0.11933534f, 0.00573146f, -0.02230131f, 0.06725976f, 
    0.12902565f, 0.20998161f, -0.02139019f, 0.11316668f, -0.37860110f, -0.31453186f, -0.16501513f, 0.12112695f, 
    0.03331783f, 0.05310271f, -0.04899998f, 0.01826018f, 0.10255331f, -0.02478154f, 0.18288250f, 0.03485833f, 
    0.06814615f, -0.11062877f, -0.04254693f, -0.04122742f, -0.10896335f, 0.08939495f, -0.01089643f, -0.04820064f, 
    0.12097576f, -0.01151593f, -0.01877267f, 0.08837774f, -0.20702459f, 0.05829440f, -0.21904464f, 0.05706605f, 
    0.00646894f, 0.00228283f, 0.10139760f, 0.11042551f, 0.26928690f, -0.00381805f, 0.10327259f, 0.06220085f, 
    0.11976825f, -0.08002087f, -0.11825985f, 0.17706573f, -0.16476464f, 0.11594901f, 0.12725696f, 0.02745920f, 
    -0.11524650f, -0.04751765f, 0.04017777f, -0.14597090f, 0.04770134f, 0.03517829f, 0.11718515f, -0.14636889f, 
    0.05519072f, 0.01830671f, -0.01049086f, -0.00582938f, 0.01601048f, -0.12247825f, -0.00013333f, 0.08930121f, 
    -0.19800164f, -0.18359879f, 0.00842201f, 0.01957684f, 0.01765975f, -0.01729228f, 0.15015949f, 0.08193360f, 
    0.01984129f, -0.05830146f, -0.01864397f, -0.05876704f, 0.15284355f, -0.17907175f, -0.09692326f, 0.05921984f, 
    0.05275288f, 0.01937881f, 0.03868517f, 0.07600185f, -0.17233938f, 0.02297664f, 0.14915565f, 0.06138498f, 
    0.26726028f, -0.29366133f, -0.11719277f, -0.18266128f, -0.04705436f, -0.09728940f, -0.00308989f, 0.11309677f, 
    -0.04525446f, -0.01718780f, 0.03021162f, 0.01628575f, 0.00688184f, 0.04233319f, 0.04485000f, 0.07205074f, 
    0.07660306f, 0.02511681f, 0.18663700f, 0.02040408f, 0.04126107f, -0.00661541f, 0.03553693f, 0.03257050f, 
    0.05161122f, 0.21960759f, 0.06116398f, 0.10234202f, 0.15676437f, -0.03956338f, 0.21778853f, -0.03304541f, 
    0.05035583f, 0.11082886f, 0.07889944f, 0.11324058f, -0.01277460f, -0.19549078f, -0.18854657f, 0.19591081f, 
    0.09874105f, -0.06229462f, 0.11775957f, 0.05549250f, 0.02745962f, 0.03028552f, -0.00176479f, -0.07797877f, 
    0.26341397f, 0.10769679f, -0.07302921f, 0.13029648f, -0.02210832f, -0.03699385f, 0.23916434f, 0.09095411f, 
    0.00292059f, -0.04460672f, 0.09502165f, 0.05282724f, -0.11318880f, -0.17859380f, 0.13596390f, -0.01379597f, 
    0.20021090f, 0.23523062f, 0.11408706f, 0.05149901f, 0.07337263f, 0.05141028f, 0.08886972f, 0.00070624f, 
    -0.24091807f, 0.12591682f, -0.12756799f, -0.20745277f, 0.16267517f, 0.08121773f, 0.05764738f, -0.08258577f, 
    -0.09558439f, -0.21831375f, -0.04944092f, -0.06801715f, -0.02717576f, 0.24581279f, 0.04661436f, -0.24361868f, 
    0.06861328f, -0.03291842f, -0.12583253f, 0.10796210f, -0.07809772f, 0.28266361f, -0.07638562f, -0.01133028f, 
    -0.10902030f, -0.03991633f, 0.06158653f, -0.06964806f, 0.07320811f, -0.07412333f, -0.06608488f, -0.09337141f, 
    0.03376386f, -0.04406609f, 0.07645957f, -0.02126431f, -0.12556005f, 0.14816418f, -0.06285908f, 0.18442285f, 
    0.17793646f, -0.00914106f, 0.04881950f, 0.05572372f, 0.08428393f, -0.06086054f, 0.10672124f, 0.07530710f, 
    0.31200424f, 0.33876672f, 0.02941380f, 0.09270258f, 0.05076956f, 0.00746087f, 0.04309419f, -0.06593689f, 
    0.05398239f, 0.17809691f, 0.02888428f, 0.20218316f, -0.15013550f, -0.05955952f, -0.01089811f, -0.08971827f, 
    0.01965045f, -0.06291019f, 0.10220166f, 0.21376479f, -0.12432212f, 0.01546070f, 0.04001490f, 0.00901818f, 
    0.14763631f, 0.00423003f, 0.05642621f, 0.21398002f, 0.00478540f, 0.06706396f, -0.08914511f, 0.07527152f, 
    0.15512457f, -0.03843674f, 0.13475838f, -0.04163740f, -0.30348790f, -0.13477068f, -0.04244506f, -0.00155852f, 
    -0.09692603f, 0.00863028f, -0.01569595f, 0.06702790f, 0.04980369f, 0.09628144f, 0.04751979f, 0.03442091f, 
    0.20565066f, -0.02474191f, -0.30456725f, 0.24046054f, 0.16159098f, 0.10956343f, -0.04351015f, -0.11671896f, 
    -0.06832270f, 0.04120289f, 0.10649786f, 0.10178544f, -0.14754400f, 0.02449567f, 0.01509400f, -0.02379375f, 
    0.05490133f, 0.06903663f, 0.00872268f, 0.06009430f, 0.07177375f, -0.01347825f, 0.08066152f, -0.00139050f, 
    -0.24016578f, 0.33212492f, -0.24057889f, 0.02643694f, 0.11247469f, 0.19667891f, -0.13025938f, 0.18382965f, 
    -0.06547917f, 0.04915825f, 0.11570162f, 0.02692886f, -0.07172968f, -0.08268563f, -0.09274383f, -0.08794696f, 
    -0.10541029f, 0.11515968f, -0.00717586f, 0.01079415f, 0.03489285f, 0.07539563f, -0.04984722f, -0.07527588f, 
    0.04425478f, -0.03171216f, -0.07474034f, -0.09561221f, 0.08294565f, 0.02639975f, -0.12783235f, -0.00501259f, 
    0.20054267f, -0.02263203f, 0.10692563f, 0.01556217f, -0.20920803f, -0.23187688f, -0.13305996f, -0.06455403f, 
    -0.00965801f, -0.07480323f, 0.05850225f, 0.07575277f, 0.00012474f, 0.01348996f, -0.03764693f, -0.04277780f, 
    -0.22721355f, -0.20288838f, 0.00221941f, 0.04990475f, -0.09335639f, -0.05097277f, 0.09512011f, 0.09516697f, 
    0.13297062f, 0.10157809f, 0.04789254f, 0.02420888f, 0.11380660f, 0.09488614f, 0.19549327f, 0.07225345f, 
    0.06799515f, -0.05249059f, 0.06261372f, 0.01234045f, 0.21155356f, -0.00695449f, 0.01373206f, 0.05184167f, 
    -0.00727736f, -0.24520230f, -0.12508065f, -0.03627267f, 0.06938975f, -0.00955570f, 0.02848735f, 0.01342646f, 
    0.06025372f, 0.05826231f, -0.00693991f, 0.08698193f, -0.14632113f, -0.20405431f, 0.02248656f, -0.19400389f, 
    -0.12832674f, -0.09779756f, -0.08820823f, -0.02943810f, -0.02960637f, -0.08817560f, -0.06382467f, -0.01079989f, 
    0.07608423f, -0.05544797f, -0.00604062f, 0.12000827f, 0.00218229f, -0.14236043f, 0.08627100f, 0.10455931f, 
    0.02267187f, 0.03667366f, -0.07493296f, 0.07610222f, -0.06780195f, -0.26736596f, -0.07134518f, 0.01716780f, 
    -0.00026115f, -0.14604458f, 0.00976331f, 0.03516860f, 0.08250657f, 0.07620774f, 0.04921773f, 0.12921946f, 
    0.08363766f, 0.03397880f, 0.16807839f, 0.23216620f, 0.03876889f, -0.11237914f, 0.03518590f, 0.02024001f, 
    0.00906426f, -0.03078807f, -0.06368992f, -0.07602349f, -0.45637038f, 0.12891701f, 0.49077365f, 0.08861191f, 
    -0.00905633f, -0.08148325f, 0.00010777f, -0.01613127f, -0.09815052f, 0.03840132f, 0.00072762f, 0.18007873f, 
    -0.03028907f, 0.13040167f, -0.04260776f, 0.11041556f, 0.10355806f, 0.06049347f, 0.09612591f, 0.15656677f, 
    -0.04231650f, 0.06699395f, 0.10222002f, 0.00592779f, -0.11467709f, -0.12812720f, -0.10196846f, -0.11428083f, 
    0.01438215f, -0.07014358f, -0.05394617f, -0.01181894f, 0.03738310f, 0.01871088f, -0.09821308f, -0.20632729f, 
    -0.16689530f, -0.17016017f, -0.11761972f, 0.10974968f, -0.06383975f, -0.13227032f, 0.03085613f, -0.07504562f, 
    0.07111258f, 0.10222255f, 0.00558109f, 0.03711002f, 0.06592421f, 0.05930401f, -0.12603870f, -0.10388372f, 
    0.01168946f, -0.00576924f, 0.03957508f, -0.07732252f, 0.01097454f, 0.00829760f, 0.08038376f, 0.01777830f, 
    0.37136379f, -0.12690832f, 0.10936770f, 0.07604330f, -0.01763877f, -0.08425592f, -0.01592406f, -0.04140825f, 
    0.04275052f, -0.01613658f, 0.10103932f, 0.04364947f, -0.08077992f, -0.06366616f, 0.04946302f, 0.17639962f, 
    0.04298595f, 0.11311275f, -0.05805648f, 0.17919159f, 0.04476075f, 0.08323015f, 0.06351566f, -0.01877740f, 
    -0.07246316f, 0.01078459f, 0.20056722f, -0.05988215f, 0.04769565f, -0.02525447f, -0.12829798f, 0.09812428f, 
    0.08674616f, 0.02676047f, 0.29166684f, -0.04788525f, 0.08276941f, 0.10606492f, 0.09717302f, 0.24834585f, 
    0.02972314f, -0.02883490f, 0.11655010f, -0.08052617f, 0.08091023f, -0.01498425f, -0.00949602f, -0.00365633f, 
    0.53252125f, 0.03813689f, -0.13401854f, 0.04662389f, 0.05739693f, 0.00174286f, 0.04348619f, 0.08288096f, 
    -0.07362453f, -0.09759514f, 0.00925242f, 0.03551159f, 0.02316151f, -0.05478274f, -0.05545786f, -0.06445975f, 
    -0.01611575f, 0.24319993f, 0.00020351f, 0.03966598f, 0.04182879f, 0.08997961f, -0.02507959f, 0.00512140f, 
    -0.34634152f, -0.19387755f, 0.21197644f, 0.01622224f, 0.06113238f, 0.00575583f, 0.05527264f, -0.03817752f, 
    0.15750338f, 0.02694226f, -0.04608069f, 0.00466922f, -0.34267408f, 0.14603855f, 0.02817125f, 0.04266062f, 
    -0.05613748f, -0.00866231f, -0.11917301f, 0.10105916f, 0.00895570f, -0.05151469f, 0.03055639f, 0.08676037f, 
    0.00346250f, -0.15982848f, -0.11365116f, -0.26885635f, -0.13951072f, -0.05704923f, 0.01733820f, -0.01582512f, 
    -0.01661473f, -0.09236973f, -0.12621489f, -0.17088258f, -0.23931955f, 0.01021793f, 0.18030210f, 0.17353088f, 
    -0.04175208f, -0.04694417f, 0.13297045f, 0.04043376f, -0.06564903f, -0.02637019f, -0.05269293f, -0.04300926f, 
    -0.05199790f, -0.03171989f, 0.02894618f, 0.00811197f, 0.02108359f, 0.04081123f, -0.05637607f, 0.05246080f, 
    0.03805295f, 0.02422660f, -0.02603991f, -0.05019270f, 0.02833785f, -0.05643501f, -0.01355007f, -0.04025438f, 
    -0.02416175f, -0.05013182f, 0.03831675f, 0.04049724f, -0.02034388f, -0.00912821f, -0.02113527f, -0.04453871f, 
    0.02570684f, -0.03922656f, 0.00037823f, 0.03700458f, -0.00774846f, 0.00772208f, -0.00413774f, -0.04712765f, 
    0.02499743f, -0.04541340f, -0.00640453f, 0.01181398f, -0.04433035f, 0.03911341f, -0.04475526f, 0.03806108f, 
    -0.00730844f, -0.04445466f, -0.04559278f, -0.05639676f, 0.02144251f, 0.04082349f, -0.01077497f, 0.00067587f, 
    0.00401730f, 0.02881408f, -0.03023945f, 0.04218926f, 0.02392954f, -0.03430984f, 0.01578097f, -0.01299620f, 
    0.04224182f, -0.04589852f, -0.03620895f, 0.01118188f, 0.02034543f, 0.04084942f, 0.00535050f, -0.03025302f, 
    -0.00842759f, 0.03042016f, 0.02621380f, 0.00952438f, -0.04002492f, -0.01166751f, -0.01423963f, 0.03982161f, 
    0.01954459f, 0.00891597f, -0.05405625f, 0.02320958f, 0.01013159f, -0.04745582f, 0.03065059f, 0.00431810f, 
    -0.03982707f, -0.04479582f, 0.03003112f, 0.00780703f, -0.03278391f, 0.04333748f, 0.03467267f, -0.01836244f, 
    0.03268317f, -0.03482516f, -0.01813488f, -0.03107866f, 0.02122493f, -0.00115071f, -0.00565424f, 0.04333623f, 
    -0.00504149f, -0.01457928f, 0.02032265f, -0.03272136f, -0.05130853f, -0.01667568f, -0.04124184f, -0.02221840f, 
    0.05425711f, -0.03582026f, -0.03631851f, -0.05830497f, 0.03517301f, -0.00734783f, -0.01162302f, -0.04540132f, 
    0.00460248f, -0.03586752f, -0.03771788f, -0.03699646f, -0.01481406f, 0.01145410f, -0.03843787f, -0.03565745f, 
    0.03172919f, 0.02461654f, -0.05025383f, 0.04356152f, -0.05630840f, 0.01902506f, -0.00996024f, 0.00214995f, 
    0.03804079f, -0.02270314f, 0.04533213f, -0.04161232f, 0.03819152f, 0.03974852f, -0.02337986f, 0.03579970f, 
    -0.03591813f, -0.03258118f, 0.04020767f, 0.03567478f, 0.02133402f, 0.00871394f, 0.02184471f, 0.02731443f, 
    0.01866440f, 0.01526942f, -0.00756261f, -0.02828154f, 0.03770341f, -0.00935320f, -0.03640893f, -0.03726000f, 
    -0.05426934f, -0.00758701f, 0.01016396f, -0.02982628f, -0.02247855f, -0.05565664f, 0.01043581f, 0.02326573f, 
    -0.00069688f, -0.03530795f, -0.03946203f, -0.03657050f, 0.04475502f, 0.02013475f, 0.02245666f, -0.05113836f, 
    -0.04049229f, 0.00251627f, -0.01688118f, -0.03866062f, 0.03145697f, 0.01293170f, -0.01696001f, -0.00362702f, 
    0.00359133f, 0.00729862f, -0.00520350f, -0.01213390f, 0.02185024f, 0.04013577f, 0.03272671f, -0.03270791f, 
    0.03143798f, -0.00381774f, -0.00582263f, -0.01367069f, 0.01277148f, -0.01013625f, -0.02288214f, -0.03136416f, 
    0.00015306f, -0.04215454f, 0.00159927f, 0.03515026f, -0.03264697f, 0.03323143f, 0.01227877f, 0.01387916f, 
    0.01300498f, -0.02091987f, 0.03969486f, 0.00216149f, 0.05024816f, -0.00994373f, -0.05065859f, 0.01625174f, 
    0.01120682f, -0.04127944f, -0.00256332f, -0.05611195f, 0.02457986f, 0.00706455f, 0.05612079f, 0.03793125f, 
    -0.00137359f, 0.01054315f, -0.00675311f, -0.05324442f, -0.00670427f, 0.00285277f, -0.03474453f, 0.04150944f, 
    -0.02177122f, -0.00901601f, -0.00860479f, -0.01941546f, 0.05637015f, -0.05034278f, -0.01552090f, -0.03712540f, 
    -0.01357059f, -0.03147585f, -0.04424773f, 0.01020014f, -0.01395928f, -0.03010072f, 0.02735966f, -0.01650785f, 
    0.03728434f, 0.02289831f, 0.02344382f, 0.02560467f, -0.04272378f, 0.01606081f, -0.01658091f, 0.02427706f, 
    -0.05382800f, -0.04935173f, -0.02295884f, -0.03941061f, 0.02188555f, 0.02152081f, -0.04741299f, -0.02417781f, 
    0.00088156f, -0.04963161f, -0.01940190f, -0.03787623f, -0.00374040f, -0.01458450f, -0.02392062f, -0.02855444f, 
    0.00033074f, 0.04731042f, -0.05342731f, -0.03368609f, -0.02497154f, 0.02634884f, -0.01830251f, 0.03314664f, 
    -0.02034444f, 0.02560307f, 0.03045611f, -0.04662527f, 0.02303479f, -0.03955549f, -0.01600235f, -0.05425118f, 
    -0.00373288f, -0.03925334f, 0.00735140f, 0.02001629f, 0.02117506f, 0.02127535f, -0.02034006f, 0.00344582f, 
    -0.00253528f, -0.04849304f, -0.01309163f, 0.02768890f, 0.01858429f, -0.02208363f, -0.00732804f, -0.00317858f, 
    -0.00623527f, -0.03459875f, -0.03753072f, -0.03888090f, -0.00680899f, -0.00337045f, 0.01372207f, -0.04873531f, 
    0.02611767f, -0.02614149f, -0.03632807f, -0.05087533f, 0.01962508f, 0.02695581f, -0.05136171f, -0.04877746f, 
    0.00760987f, 0.04334430f, -0.01908737f, 0.01768150f, -0.01333431f, -0.04421361f, -0.03708494f, 0.03363978f, 
    -0.00501311f, -0.01075796f, -0.03139121f, -0.00125828f, 0.03331722f, 0.03787150f, -0.02508027f, 0.02179826f, 
    -0.00307795f, 0.01762352f, -0.03751837f, -0.00051245f, -0.00673948f, -0.01658016f, 0.02044016f, -0.05489748f, 
    0.03420613f, 0.01580516f, 0.02770377f, -0.04909067f, -0.02711238f, -0.05217410f, 0.03228975f, -0.00021803f, 
    0.04181628f, -0.02213677f, -0.04696755f, 0.01494730f, -0.01470378f, -0.04590714f, -0.03098123f, 0.00182372f, 
    -0.03309139f, -0.00396772f, 0.00776280f, -0.04574800f, -0.04681632f, 0.01237376f, -0.05030846f, -0.04326473f, 
    -0.04035553f, -0.04448560f, 0.03802466f, 0.03401098f, -0.05442107f, -0.00590029f, 0.03142498f, 0.02464514f, 
    0.03470520f, -0.00996020f, -0.04868761f, -0.00463230f, -0.04673023f, 0.04107752f, 0.01230003f, -0.03155759f, 
    -0.03960040f, 0.02266674f, -0.01325651f, -0.02232749f, 0.00216254f, -0.02105443f, -0.02581816f, 0.03586287f, 
    -0.29044777f, 0.12382928f, 0.04626746f, -0.03299959f, -0.08305095f, 0.06997853f, 0.09971592f, 0.05497421f, 
    -0.02172294f, 0.14563073f, 0.17439522f, 0.11048216f, 0.02661651f, 0.04829959f, 0.01769480f, 0.04455598f, 
    0.10626649f, -0.21469949f, 0.03535200f, -0.10683445f, -0.05732624f, -0.03083350f, -0.03959652f, -0.06084113f, 
    -0.16671327f, 0.02726796f, -0.04036937f, -0.01735727f, 0.03111944f, 0.00432162f, 0.00751944f, -0.01195256f, 
    0.00473591f, -0.07861901f, 0.14761055f, 0.09019003f, 0.20882942f, 0.09910376f, -0.21890254f, 0.05799971f, 
    0.12078360f, 0.11126167f, 0.11470457f, -0.08032203f, -0.02424349f, -0.00635327f, -0.05162150f, -0.01932220f, 
    -0.19925535f, 0.04333669f, -0.05367732f, -0.28308889f, -0.10002659f, 0.05350817f, 0.04541259f, 0.09395840f, 
    -0.04121328f, -0.05523840f, -0.01566062f, -0.08925597f, 0.16373987f, -0.13806422f, -0.10058337f, -0.07062862f, 
    -0.05342637f, -0.17783178f, 0.04117613f, 0.04056316f, -0.01046680f, 0.05984817f, -0.09791131f, -0.19606918f, 
    0.01986637f, 0.03955926f, -0.00533714f, -0.01967517f, 0.08294147f, -0.11542799f, -0.00931281f, -0.00999903f, 
    -0.07147415f, -0.05667337f, 0.08991159f, 0.04670208f, 0.03649040f, -0.08727661f, 0.08188335f, 0.03203050f, 
    -0.02564233f, -0.08008317f, 0.01887380f, 0.12045157f, -0.00129711f, -0.17517592f, -0.08611964f, -0.07440078f, 
    -0.02371593f, 0.15306236f, 0.16773951f, 0.14922693f, -0.03473517f, 0.02165521f, 0.10657170f, 0.02168806f, 
    0.04701660f, 0.11495948f, -0.00788627f, -0.05187331f, 0.06535620f, 0.15818889f, -0.06660524f, -0.21386358f, 
    -0.08152648f, 0.12021779f, 0.08585908f, -0.05660634f, 0.01242471f, 0.09310036f, 0.05401889f, 0.03443323f, 
    0.04910183f, -0.09972195f, -0.15627663f, -0.11815082f, 0.02725755f, -0.05712551f, -0.05563053f, -0.10667800f, 
    -0.08615771f, -0.09531015f, -0.04274657f, -0.02183522f, -0.01950434f, 0.00900118f, 0.27233887f, 0.11814098f, 
    -0.00761124f, 0.09877016f, -0.04174836f, -0.11235485f, 0.14662971f, 0.09822094f, -0.00011153f, 0.21593612f, 
    0.19282664f, -0.02766392f, -0.05239837f, -0.11393312f, 0.07550069f, 0.07663526f, -0.06853540f, 0.03086609f, 
    0.06929247f, -0.00140475f, 0.06513806f, 0.04351515f, -0.01099955f, -0.08790564f, 0.00483316f, 0.11368213f, 
    0.03030496f, -0.01771946f, -0.02326431f, -0.03839531f, -0.06258332f, 0.06425771f, -0.01420330f, -0.03011852f, 
    -0.11845569f, 0.20232740f, 0.09610164f, 0.00630778f, 0.12945785f, 0.03493750f, -0.10835272f, -0.05812971f, 
    -0.00119511f, 0.03605550f, 0.00563835f, 0.03749383f, 0.18099919f, -0.07333685f, 0.01031934f, 0.13804799f, 
    -0.01374934f, -0.00345324f, -0.08721955f, 0.04076599f, -0.03239713f, 0.00854691f, 0.07718385f, 0.10662830f, 
    -0.00857955f, -0.08788440f, -0.30870140f, -0.29276600f, -0.15127586f, 0.02436587f, 0.08269742f, 0.05861290f, 
    -0.09907138f, -0.01541013f, -0.12482059f, -0.00051731f, 0.33693850f, 0.36815411f, -0.29987788f, -0.06739776f, 
    0.06213547f, -0.15431190f, -0.02313456f, -0.09747887f, 0.03947793f, 0.08314601f, 0.14403675f, 0.00601067f, 
    0.01200597f, -0.10590366f, -0.00648956f, -0.13173477f, -0.00656090f, 0.01443270f, 0.03560225f, -0.09901926f, 
    0.05900782f, -0.11456544f, 0.05303188f, 0.11576547f, -0.03520555f, -0.10455977f, 0.00733198f, -0.06921817f, 
    -0.01081692f, 0.06204933f, 0.05716786f, 0.05939951f, -0.06890240f, 0.09527703f, -0.13152903f, -0.08746009f, 
    0.05337572f, -0.04286486f, 0.06468347f, -0.20352370f, 0.02080150f, -0.05232822f, 0.07489844f, -0.03069539f, 
    -0.05660279f, -0.01773341f, 0.00883400f, -0.14243472f, 0.01250764f, 0.01545687f, -0.10640054f, -0.01117541f, 
    -0.11681193f, 0.06747676f, 0.12612166f, 0.03120473f, 0.08138063f, -0.07425283f, -0.10408189f, -0.07601371f, 
    -0.31439567f, 0.35113651f, 0.30384600f, 0.15140291f, 0.02595283f, 0.01338282f, -0.03785488f, -0.01721230f, 
    0.03899153f, 0.02894882f, -0.01550329f, 0.26671240f, -0.24700584f, -0.07128469f, -0.15551245f, -0.31319326f, 
    -0.03478423f, -0.10800389f, 0.06011222f, -0.02701246f, -0.01643067f, -0.08304612f, 0.03351739f, 0.00113342f, 
    -0.13040029f, 0.22117786f, 0.05002230f, 0.15286085f, 0.18614230f, -0.12882893f, -0.05595503f, 0.02735256f, 
    0.01202909f, 0.03651305f, -0.15984194f, -0.09815059f, 0.37498176f, -0.35073453f, -0.44967884f, -0.28369197f, 
    -0.07279847f, 0.16337244f, 0.08269784f, 0.00480960f, 0.06675694f, 0.03057509f, -0.01435156f, 0.03137808f, 
    -0.26259992f, -0.06022477f, 0.15114111f, 0.06758583f, 0.04868529f, 0.20779879f, -0.06691128f, -0.02971047f, 
    0.04902519f, -0.02998481f, 0.07559507f, 0.14418495f, -0.09016410f, -0.18471058f, 0.01216541f, 0.13634780f, 
    0.17857991f, 0.09434959f, -0.02178966f, -0.02007929f, 0.05269496f, -0.08188117f, -0.00360175f, 0.03268562f, 
    0.06364892f, 0.14588343f, -0.00769992f, -0.17295276f, -0.00676940f, 0.03143198f, -0.17043480f, 0.01622194f, 
    -0.10565357f, 0.06224316f, -0.01029361f, 0.07425167f, -0.10187129f, 0.04959117f, 0.09586299f, 0.05167354f, 
    0.03220581f, 0.04262491f, 0.04907969f, -0.11895441f, -0.08684561f, 0.01218645f, 0.10716294f, 0.11801371f, 
    -0.06552581f, -0.16182561f, -0.07642831f, 0.01858140f, 0.08014465f, -0.01274052f, -0.01960460f, 0.01119074f, 
    -0.08813636f, -0.05264167f, 0.01563152f, -0.00082074f, 0.13309653f, -0.12261743f, -0.10609575f, -0.20655753f, 
    -0.10145535f, -0.05631507f, -0.03004535f, -0.05006492f, -0.03450843f, 0.05470971f, -0.00360706f, 0.03500655f, 
    -0.11900231f, 0.04082958f, 0.18072924f, 0.09283588f, 0.00016395f, -0.04024931f, -0.02987673f, 0.00432006f, 
    -0.00855985f, -0.13203177f, -0.02114733f, -0.19798164f, 0.15235761f, -0.06472740f, -0.05771143f, -0.16980264f, 
    0.01586652f, 0.09280656f, 0.09757619f, -0.01424388f, 0.04540512f, 0.04865757f, -0.05773678f, 0.09772328f, 
    0.24315517f, -0.27623889f, -0.01368052f, -0.33218393f, -0.05277406f, 0.05979401f, -0.05914075f, -0.02386655f, 
    -0.09662066f, -0.04863617f, 0.00836510f, -0.00714670f, 0.27990407f, 0.34102339f, 0.22959748f, -0.18147346f, 
    0.15863083f, 0.04256379f, 0.04366015f, 0.17649704f, -0.02960944f, 0.02035968f, 0.01736510f, 0.06872033f, 
    -0.04520462f, -0.11033604f, 0.54852110f, -0.07622769f, 0.11187878f, 0.17143184f, -0.08066922f, 0.02067942f, 
    0.03910355f, -0.05284106f, -0.11919823f, -0.04083296f, 0.04867859f, -0.11789043f, -0.22135139f, -0.23901395f, 
    -0.07454807f, -0.02965459f, 0.16080710f, 0.21247999f, -0.05081124f, -0.00832419f, -0.00801929f, -0.05077443f, 
    0.17398924f, 0.06953703f, -0.09162348f, -0.17574537f, 0.10184176f, 0.00718494f, 0.13819000f, 0.10470895f, 
    -0.02957801f, 0.09723317f, -0.04101176f, -0.00574699f, 0.02129450f, -0.23519820f, 0.03762536f, -0.09101867f, 
    0.05649557f, 0.11452159f, -0.13136403f, 0.15812582f, 0.08117689f, -0.03939399f, -0.00549947f, 0.06167147f, 
    0.23204143f, -0.07145463f, 0.17139947f, 0.01384717f, -0.08026025f, 0.00860911f, -0.03704705f, -0.06133130f, 
    0.07599851f, 0.01324790f, -0.03680786f, 0.06037936f, 0.13132001f, 0.29343367f, 0.23684396f, 0.04402041f, 
    0.18920787f, 0.17345594f, 0.05347412f, 0.10134637f, -0.01352435f, -0.03717460f, 0.06391592f, 0.09007771f, 
    0.21888608f, 0.46258220f, -0.00056044f, -0.05657979f, 0.19798008f, 0.12253156f, -0.02529781f, -0.03919055f, 
    -0.08843821f, -0.02457837f, -0.01969873f, 0.06828932f, -0.11267409f, -0.22035341f, -0.28399211f, -0.12233695f, 
    0.00103201f, 0.00193382f, -0.06341111f, 0.11458480f, 0.01251724f, -0.02869373f, 0.09694413f, 0.00634545f, 
    0.16889431f, 0.37259775f, 0.24031720f, 0.03286663f, 0.16468458f, -0.04083695f, 0.08696420f, 0.05483208f, 
    -0.05034676f, -0.08764569f, -0.11070170f, 0.03210839f, 0.27991363f, 0.03675985f, 0.40450171f, -0.05880623f, 
    0.07237065f, -0.00886425f, -0.09147254f, -0.10320520f, 0.00777972f, -0.02345608f, 0.08701190f, 0.00594232f, 
    0.09422269f, -0.03408569f, -0.26710179f, -0.04721542f, 0.11580659f, 0.02240306f, -0.07978353f, 0.03633642f, 
    0.04608370f, -0.04643911f, 0.10080697f, 0.01259657f, 0.23879559f, -0.17455080f, -0.22151083f, -0.37372920f, 
    0.06356807f, 0.07908689f, 0.06911885f, 0.09964187f, 0.08312280f, -0.06940829f, 0.04486200f, 0.06331959f, 
    0.23248141f, -0.21031526f, -0.09926318f, -0.09034148f, -0.05353062f, 0.03247727f, -0.03581760f, -0.06560802f, 
    0.00488951f, -0.12196762f, -0.08277912f, 0.10704776f, 0.57414681f, -0.46696463f, -0.27063909f, -0.51765227f, 
    -0.01681757f, -0.03576657f, 0.01071615f, -0.08342169f, 0.21626380f, -0.02000451f, 0.06887849f, 0.00225496f, 
    0.00468929f, -0.06984868f, -0.13962501f, -0.15226860f, -0.11948492f, -0.03868944f, 0.14433274f, 0.09293055f, 
    0.01081848f, 0.10526071f, 0.12042263f, 0.00406957f, 0.01450928f, -0.08796467f, 0.11011124f, 0.00137490f, 
    -0.01846959f, -0.00571763f, -0.01745149f, -0.19057299f, 0.01275145f, -0.13387845f, -0.04927191f, 0.11208145f, 
    0.08671406f, 0.11391351f, 0.22288470f, -0.10018176f, 0.04465973f, 0.12403160f, -0.03562921f, 0.16435508f, 
    0.03990372f, -0.17089444f, -0.01938681f, 0.00355629f, -0.26441103f, -0.07334994f, -0.11087424f, -0.09611624f, 
    -0.02065407f, 0.01162088f, -0.01248726f, -0.07292179f, -0.00624067f, 0.07602857f, 0.04501890f, 0.09722305f, 
    -0.00216278f, -0.14047551f, -0.15947932f, 0.01732233f, 0.05623365f, -0.06286567f, -0.07391272f, -0.15252940f, 
    -0.00222810f, -0.02201670f, -0.10966748f, 0.12786967f, 0.24268603f, -0.18579285f, 0.05994692f, -0.09471072f, 
    0.15881154f, -0.05172749f, 0.10285197f, -0.04633259f, -0.01792215f, 0.07096262f, -0.05434382f, 0.05250634f, 
    -0.10134111f, 0.32448635f, -0.03949371f, 0.22532284f, 0.05837967f, -0.02932418f, 0.14293216f, -0.19739059f, 
    -0.06202535f, 0.04027257f, -0.08913983f, 0.07158903f, 0.11432219f, 0.19709536f, -0.14437687f, -0.09874763f, 
    -0.19694389f, 0.09694214f, -0.07336396f, 0.23936832f, 0.03542022f, -0.07969075f, -0.12470432f, 0.01169876f, 
    -0.58346552f, 0.29496697f, 0.00755591f, 0.12016722f, 0.06718357f, -0.02643554f, 0.05078544f, -0.05722311f, 
    0.18520167f, 0.02247796f, -0.01693261f, 0.08531974f, 0.18487282f, -0.20813550f, 0.16714439f, -0.30266759f, 
    0.11976286f, 0.17589654f, 0.04532297f, 0.11106382f, 0.10007077f, -0.02278494f, 0.11427428f, 0.05248021f, 
    0.25228402f, 0.16339220f, -0.03797460f, -0.08990915f, 0.28661689f, 0.12750056f, 0.12338708f, 0.16490963f, 
    -0.01268465f, -0.04961159f, 0.12439785f, 0.09623230f, 0.19838867f, -0.05787298f, -0.24554604f, -0.08127451f, 
    0.04469962f, -0.11160509f, -0.04342973f, -0.00767603f, 0.13455111f, 0.05705338f, 0.10473352f, 0.03360645f, 
    -0.13041107f, -0.20515047f, -0.10606849f, 0.05752556f, 0.05424976f, -0.06847549f, 0.02588858f, -0.10760602f, 
    0.01824728f, -0.07961578f, 0.03947818f, 0.01078907f, 0.17734824f, -0.02139356f, -0.31291413f, -0.01702018f, 
    0.15594824f, 0.06691007f, 0.00581085f, 0.08219282f, 0.02715144f, -0.06445830f, 0.05980594f, -0.01176916f, 
    -0.09004785f, 0.04875044f, 0.02095433f, -0.09563501f, 0.08565094f, 0.03846684f, -0.00522414f, 0.00845016f, 
    -0.09232800f, -0.29030669f, -0.23943385f, -0.36385036f, -0.04504235f, -0.06501566f, -0.05427393f, -0.09098192f, 
    0.07705334f, 0.06520209f, 0.02244218f, 0.09281275f, -0.06736260f, -0.00457275f, 0.02119629f, -0.02787680f, 
    0.29141590f, 0.05344138f, 0.02854501f, 0.13179158f, 0.08017579f, 0.14177933f, -0.09796383f, 0.03697250f, 
    0.10363597f, -0.08657850f, 0.32893929f, -0.17331338f, 0.01727546f, 0.09252463f, 0.06050020f, -0.00357765f, 
    -0.09772614f, -0.00303817f, -0.09691888f, -0.04785862f, 0.07636615f, 0.03349622f, 0.04184065f, 0.04984089f, 
    0.07270796f, -0.07369059f, -0.15563412f, -0.15971103f, 0.10950146f, 0.03317694f, 0.10517762f, 0.10180870f, 
    0.01228241f, 0.10092313f, 0.10476170f, -0.10611486f, -0.00704564f, -0.04197965f, 0.08004760f, 0.02643901f, 
    0.00260813f, 0.17522219f, 0.03643280f, 0.08862644f, -0.08190647f, 0.15589035f, 0.01797544f, 0.09641327f, 
    -0.16751879f, 0.17385522f, -0.03894676f, 0.02668482f, 0.16723581f, 0.00032532f, 0.10298509f, 0.12061273f, 
    0.09719119f, 0.09716931f, 0.05772684f, 0.18447281f, -0.25621697f, -0.11930092f, -0.05425064f, -0.16069886f, 
    0.05068535f, 0.20490390f, -0.01422143f, 0.13994107f, 0.17611271f, 0.07110088f, 0.05460316f, -0.03731531f, 
    -0.01770188f, -0.03902863f, -0.24381074f, 0.02574464f, 0.08594773f, -0.04749510f, -0.10839187f, -0.08574524f, 
    0.18436730f, -0.03402314f, 0.10766145f, 0.07651944f, -0.13092992f, -0.08665604f, -0.06714676f, -0.02604735f, 
    -0.05725260f, -0.05862011f, -0.01971218f, -0.01887582f, -0.08877888f, -0.09530070f, -0.08276151f, -0.05086017f, 
    -0.07693271f, -0.00750792f, 0.14035189f, -0.08460438f, 0.00804493f, 0.20120195f, 0.01471537f, 0.08530945f, 
    0.00949776f, 0.10025115f, 0.09921438f, 0.08114926f, 0.03096291f, -0.06175113f, -0.13812603f, -0.13605846f, 
    -0.07580515f, -0.02977626f, -0.09761153f, -0.05840585f, -0.00228642f, -0.12665878f, -0.05285025f, -0.02615270f, 
    0.08421719f, 0.13480210f, 0.21056056f, -0.00934880f, 0.02809425f, 0.01036468f, -0.07834473f, 0.05417636f, 
    -0.01126207f, 0.05498800f, -0.05751548f, -0.05858919f, 0.21940958f, 0.09901082f, 0.18081616f, 0.14732739f, 
    -0.12860674f, -0.02015608f, -0.12620884f, -0.06075427f, -0.05282533f, 0.02294746f, 0.06807258f, 0.04751616f, 
    -0.26175290f, -0.14444220f, -0.15374701f, -0.00926860f, 0.06175288f, 0.01019318f, 0.06361204f, 0.15399121f, 
    -0.10810498f, -0.01311150f, -0.00389969f, -0.04068451f, 0.21371439f, -0.13003969f, -0.30613980f, -0.24717987f, 
    -0.01971713f, -0.01405380f, 0.02856273f, 0.01671697f, -0.00717449f, -0.05415638f, 0.05214036f, 0.03048606f, 
    0.48791760f, 0.15816760f, 0.16032813f, 0.25941369f, 0.12343254f, -0.13887024f, -0.05421708f, -0.05899071f, 
    0.03661896f, 0.06802126f, 0.00053395f, 0.05960578f, 0.45190790f, -0.19199504f, 0.14860970f, -0.27899316f, 
    0.00395574f, -0.07208960f, 0.06655506f, -0.04062080f, 0.17749432f, 0.05977203f, 0.01678301f, -0.01437637f, 
    0.00789052f, -0.03043378f, -0.00097251f, -0.09712080f, 0.13720693f, 0.08835256f, 0.03260480f, 0.16309090f, 
    -0.08343325f, -0.03443557f, 0.00357683f, -0.16168763f, 0.05820389f, -0.00950983f, 0.07798239f, 0.10684554f, 
    0.00008159f, -0.01172974f, -0.00864604f, -0.03083715f, 0.02995939f, 0.02035926f, -0.04634444f, 0.05917730f, 
    -0.09215856f, -0.01205362f, 0.02094333f, -0.20084739f, 0.10033928f, 0.11392647f, -0.04332964f, 0.21155635f, 
    0.08084098f, 0.08736915f, 0.12736341f, 0.08982052f, -0.04118888f, 0.10119116f, 0.00329985f, -0.05230074f, 
    0.14098406f, -0.04683015f, -0.00714127f, 0.01497023f, 0.09670302f, 0.13620153f, 0.10075539f, 0.03709900f, 
    -0.11393084f, -0.27677605f, -0.24898328f, -0.02593356f, -0.05763201f, -0.00987555f, -0.15334256f, -0.12162431f, 
    0.07213429f, 0.04007586f, 0.05424389f, 0.07477548f, 0.19531778f, 0.04460898f, -0.05475025f, 0.10535286f, 
    0.09686028f, 0.02652066f, -0.03918903f, -0.01632529f, -0.03660516f, -0.06513298f, 0.08094516f, 0.13937075f, 
    -0.12315065f, -0.04923732f, 0.07188948f, 0.02272405f, -0.12500845f, 0.07966319f, 0.13433477f, 0.08334088f, 
    0.01343623f, 0.14538762f, 0.02524405f, 0.07829788f, 0.17394096f, 0.10840391f, -0.04147758f, -0.05467695f, 
    -0.04221449f, 0.02104585f, -0.00508001f, 0.13702400f, 0.04066461f, -0.08501041f, -0.00536904f, 0.08173730f, 
    -0.36770591f, 0.25390148f, 0.00809751f, -0.02186617f, 0.14687017f, 0.06321504f, 0.00126867f, 0.07788575f, 
    0.06713838f, 0.07886314f, -0.09898143f, -0.01821048f, -0.07626394f, -0.07821641f, -0.16272478f, -0.23282844f, 
    -0.03311997f, 0.18605597f, 0.08381779f, 0.00769058f, 0.02509453f, -0.10271108f, 0.02050762f, -0.05301924f, 
    -0.23729481f, -0.11601058f, -0.01407376f, -0.04177160f, 0.02014152f, 0.13741131f, 0.10342649f, 0.17858809f, 
    -0.03432478f, -0.04419704f, 0.01403526f, 0.00722511f, -0.15677895f, 0.02585501f, -0.08247925f, 0.09891737f, 
    -0.00950993f, -0.02230619f, -0.08671746f, 0.01800439f, 0.29585505f, -0.07473718f, 0.11030237f, 0.06878999f, 
    0.15967937f, 0.06661788f, 0.05534650f, 0.04250271f, -0.08544414f, -0.06195766f, -0.10792363f, -0.08883805f, 
    0.03430473f, -0.01493624f, -0.00276409f, 0.00623143f, -0.00171990f, -0.06175168f, 0.03940738f, 0.02262623f, 
    0.14815021f, 0.07494769f, 0.24084437f, 0.15636821f, 0.07318538f, 0.11606286f, 0.05438163f, 0.19002326f, 
    -0.03206304f, 0.01012841f, 0.01984316f, 0.01558026f, -0.02648224f, 0.01724405f, -0.01519156f, -0.00462103f, 
    -0.01360611f, -0.01718999f, -0.01056471f, 0.00553278f, 0.00998946f, 0.04165847f, -0.01868933f, 0.00220405f, 
    0.03825109f, -0.01003507f, 0.01986517f, -0.04268829f, -0.03782689f, -0.00383931f, -0.04658899f, -0.01959091f, 
    -0.04053381f, 0.00949686f, -0.03828546f, 0.00297147f, 0.01256791f, -0.00633580f, 0.03467232f, 0.04513748f, 
    0.00794982f, -0.03436320f, 0.00713646f, 0.00386104f, 0.01285748f, -0.00024984f, -0.03561528f, -0.04630558f, 
    0.04252557f, 0.00225018f, -0.03431612f, 0.00356457f, 0.01195624f, -0.03356074f, -0.01313596f, 0.04816991f, 
    -0.00846258f, 0.03218284f, -0.05273427f, -0.03729524f, -0.02317825f, 0.01823851f, 0.03639892f, -0.02368891f, 
    0.01857926f, 0.00968796f, 0.00136440f, 0.04305070f, -0.04603464f, 0.01057293f, -0.03598702f, 0.01796707f, 
    -0.03476911f, 0.02527441f, 0.02830658f, -0.02754067f, 0.00179615f, -0.03158471f, -0.03365789f, 0.02280875f, 
    -0.02258920f, -0.00384490f, -0.00982529f, -0.01483200f, -0.01854388f, 0.02340295f, 0.02011130f, -0.02356744f, 
    -0.04882571f, 0.02029854f, 0.00364727f, -0.05434624f, 0.02550377f, 0.03518079f, -0.03937676f, -0.04228664f, 
    0.00006556f, 0.02548687f, -0.01960523f, -0.02472923f, -0.02230531f, 0.02778169f, 0.00117230f, 0.04215166f, 
    0.01124850f, -0.01527255f, -0.03592630f, -0.05308024f, -0.04544770f, 0.00310197f, 0.04677938f, 0.03986182f, 
    -0.01440402f, -0.03293957f, -0.04249635f, 0.01515520f, 0.01401922f, -0.03077845f, 0.01071089f, 0.01768945f, 
    -0.00021911f, -0.00148767f, -0.05593928f, -0.02453266f, -0.02841365f, -0.04200172f, -0.00692079f, 0.01241499f, 
    -0.00419276f, -0.01720936f, 0.02942167f, -0.00870513f, 0.01549999f, 0.02939461f, -0.02214290f, 0.00626836f, 
    0.02250596f, -0.00934681f, 0.02593855f, 0.01717403f, -0.04445885f, -0.02423947f, -0.04770583f, 0.03538295f, 
    0.01730665f, -0.05302063f, 0.04679231f, -0.00028835f, -0.04406553f, 0.03277811f, -0.04721499f, 0.03169596f, 
    0.04130169f, -0.01565730f, -0.02761944f, -0.02136056f, -0.02591500f, 0.04250798f, -0.01720129f, -0.03913146f, 
    -0.04975223f, -0.01336200f, -0.03789925f, 0.04551126f, -0.05375909f, -0.02524022f, -0.04623261f, 0.00631166f, 
    -0.04721939f, 0.02401903f, 0.02893439f, -0.01263599f, 0.03087944f, 0.04655346f, -0.03727540f, 0.04267479f, 
    0.03018206f, -0.02260539f, 0.03269488f, -0.00605383f, -0.05770477f, -0.00498017f, 0.00939367f, -0.03284615f, 
    0.02124907f, -0.01848570f, -0.05081184f, -0.00462323f, 0.04096086f, 0.03914647f, 0.02020912f, -0.01171922f, 
    -0.00236643f, 0.00221191f, 0.01201684f, -0.01513824f, -0.02635288f, 0.01150341f, 0.00017669f, -0.00965827f, 
    0.01172708f, 0.01383607f, 0.03320392f, 0.01293483f, -0.04792013f, -0.01306512f, -0.03612249f, -0.02788683f, 
    -0.02003914f, 0.04186402f, 0.00517343f, 0.01567695f, -0.03470001f, 0.04734380f, -0.05654966f, 0.04408241f, 
    -0.02855276f, 0.00731985f, -0.02359037f, -0.03156999f, -0.02541463f, -0.00192304f, 0.01118764f, -0.05517525f, 
    0.03408693f, 0.05193786f, -0.03986322f, 0.00788487f, -0.03575583f, 0.04473637f, 0.02469461f, 0.04887396f, 
    0.04603226f, -0.05353673f, -0.00372554f, -0.00642638f, -0.01825536f, -0.04473740f, -0.05174408f, -0.03473737f, 
    0.03980389f, -0.04293593f, 0.05638963f, -0.03716967f, 0.03108947f, 0.03836633f, 0.02698573f, 0.03815787f, 
    -0.03292867f, 0.00207839f, -0.01121361f, -0.05107731f, -0.00365158f, 0.03621371f, 0.04280867f, 0.02187689f, 
    -0.04056223f, -0.03156924f, -0.05145938f, -0.00355305f, 0.04659628f, 0.03052880f, -0.04627222f, 0.01417084f, 
    0.03952133f, 0.02334332f, -0.01003612f, -0.03885133f, -0.03081532f, -0.01815149f, -0.02879126f, 0.03511425f, 
    -0.02579969f, -0.01785164f, -0.05478001f, -0.03759231f, 0.04152294f, 0.01540198f, 0.00664209f, -0.04969211f, 
    -0.03642818f, 0.00549233f, -0.02804448f, 0.01375461f, -0.02747463f, -0.04555004f, 0.03056119f, -0.01690778f, 
    -0.00745846f, 0.02599908f, -0.05056438f, 0.00021286f, -0.01729780f, -0.02546719f, 0.03758758f, 0.02119820f, 
    0.00848255f, 0.04453680f, 0.04250006f, -0.04247620f, -0.03247314f, 0.04181543f, 0.03546259f, 0.00521039f, 
    -0.01236999f, -0.01242581f, -0.02319433f, -0.04321254f, 0.04692986f, 0.00199451f, 0.04496316f, -0.03390514f, 
    0.03574587f, 0.03205115f, 0.00998133f, -0.03573480f, -0.01177506f, -0.03899836f, 0.01339660f, -0.01450257f, 
    -0.04694616f, 0.04769535f, -0.02744488f, 0.03488388f, -0.04944475f, -0.04678228f, -0.04432844f, -0.00577675f, 
    -0.04895390f, 0.04342775f, -0.00495847f, 0.04488686f, -0.01021738f, 0.04283747f, 0.01903045f, 0.02073792f, 
    -0.02944770f, 0.01957621f, 0.04229757f, -0.00669194f, -0.02450173f, -0.02592935f, 0.04029641f, -0.00165676f, 
    -0.03714085f, 0.01600170f, -0.05310646f, 0.00575406f, -0.03283703f, -0.02644103f, -0.02278913f, -0.02913046f, 
    -0.04634590f, -0.01697656f, -0.02245875f, 0.00840147f, -0.01466343f, 0.04020234f, -0.03313506f, -0.02967079f, 
    -0.04796847f, -0.02679811f, -0.01935410f, 0.03395113f, 0.00136299f, -0.03064242f, -0.00548870f, 0.02092304f, 
    0.01638616f, 0.02631554f, 0.01759008f, 0.00097365f, -0.03742294f, 0.00150674f, -0.03175743f, 0.03654206f, 
    -0.04820566f, -0.03372534f, -0.05006788f, -0.02537323f, -0.03322581f, 0.00168580f, 0.01615668f, -0.04290556f, 
    -0.03389942f, 0.02783080f, -0.01177837f, 0.03003432f, -0.01952212f, 0.03264417f, -0.03006974f, 0.04422883f, 
    0.15230820f, -0.32312524f, -0.04390748f, 0.04585494f, 0.00381288f, -0.03624967f, -0.01422085f, -0.01563152f, 
    0.19725275f, 0.01480551f, 0.09800351f, 0.00950498f, -0.01587422f, -0.05160880f, 0.06926609f, -0.17105210f, 
    -0.07074787f, 0.04240907f, 0.06280738f, -0.01419274f, 0.08182496f, 0.04007323f, -0.01812512f, 0.01589719f, 
    0.39980751f, -0.06784622f, -0.00741810f, -0.08487451f, 0.05316035f, 0.01001433f, 0.06196395f, -0.05585391f, 
    0.03883764f, 0.03620290f, -0.00769192f, 0.07649852f, -0.10912403f, 0.00160886f, 0.20746037f, -0.11744839f, 
    -0.01743842f, -0.02103029f, 0.05321481f, 0.03098067f, 0.05728932f, 0.08248773f, 0.11590786f, -0.01984494f, 
    -0.09062913f, -0.38983193f, 0.16848178f, 0.28825301f, -0.00863449f, -0.08720110f, 0.00663866f, 0.08687488f, 
    0.02902400f, 0.05499616f, 0.16835119f, 0.09836478f, 0.23299403f, 0.08533462f, 0.05537019f, -0.18969209f, 
    0.08553917f, 0.07739375f, 0.06255710f, -0.10161824f, 0.25252280f, -0.18505515f, 0.05298232f, 0.02433559f, 
    0.04850607f, -0.23208554f, -0.07537742f, 0.18966055f, 0.01422529f, -0.13014233f, 0.06252630f, 0.03056938f, 
    0.08267686f, 0.20281404f, -0.11680636f, -0.05201092f, -0.03098836f, -0.05299995f, -0.02094711f, -0.00773972f, 
    -0.00682392f, -0.12663947f, -0.10491504f, 0.03666119f, 0.01583264f, 0.10800572f, 0.04009304f, 0.06036000f, 
    0.05069343f, -0.36586970f, 0.23799661f, 0.04786278f, -0.05770550f, -0.15151320f, 0.01561407f, 0.09480173f, 
    0.00420180f, 0.01002671f, 0.00153212f, 0.01569820f, -0.22222459f, -0.05620240f, 0.04682273f, 0.05196678f, 
    -0.03884978f, 0.03420059f, 0.09923673f, 0.01180610f, 0.08809022f, 0.06935542f, 0.00849429f, -0.03677969f, 
    -0.09638147f, 0.18239760f, 0.20040566f, -0.00311619f, 0.11055101f, 0.02993971f, -0.02747663f, -0.12163264f, 
    0.07332347f, 0.12164386f, 0.10839707f, 0.11076879f, -0.18469229f, 0.22161455f, -0.02089968f, -0.09309508f, 
    -0.08378372f, -0.04709340f, -0.02822532f, -0.03365548f, 0.04447367f, -0.04737833f, 0.01959541f, 0.03881473f, 
    -0.22555432f, 0.06979251f, -0.00907913f, 0.03482658f, 0.00276422f, -0.05430436f, 0.05573599f, -0.02259702f, 
    0.04516167f, -0.10477886f, -0.00625207f, -0.09693763f, 0.31553906f, 0.14892116f, 0.18704687f, -0.12102354f, 
    0.02906629f, -0.00251537f, 0.00094085f, -0.03940297f, 0.02267945f, -0.13303427f, -0.08438485f, -0.04521222f, 
    -0.18748590f, 0.05061651f, -0.01892243f, -0.08986264f, -0.09556918f, -0.01146228f, 0.02937621f, 0.01194016f, 
    0.09563891f, 0.00813095f, 0.09714128f, -0.04239915f, -0.32693639f, 0.19169529f, 0.00614264f, -0.03923394f, 
    -0.12625276f, -0.09427112f, -0.07858370f, -0.00000304f, -0.02615055f, -0.00626551f, -0.03291317f, -0.07833721f, 
    0.31396428f, 0.04387619f, -0.07709318f, -0.13436000f, 0.04219064f, 0.03576409f, -0.01714269f, 0.02161811f, 
    0.08668224f, -0.02262799f, -0.01655160f, 0.04891162f, 0.36863577f, 0.18029182f, 0.05055607f, -0.31392553f, 
    -0.10132947f, -0.01193418f, 0.07304601f, 0.02101268f, 0.01614942f, -0.02946472f, -0.10890348f, -0.03027172f, 
    0.22749452f, 0.20257884f, -0.33825204f, -0.06167991f, -0.04664967f, 0.01045574f, 0.03068478f, -0.10759625f, 
    0.07689016f, -0.07148394f, -0.08053950f, 0.00586051f, 0.05926593f, 0.08016755f, 0.07175010f, 0.05465675f, 
    0.08286294f, -0.02605338f, -0.01612835f, 0.02802200f, -0.03192440f, -0.00572284f, -0.05667548f, -0.00635921f, 
    -0.16381499f, -0.01919773f, 0.02550498f, -0.00986051f, 0.06258377f, 0.00780355f, -0.00697765f, 0.13523439f, 
    -0.01445723f, 0.00536486f, 0.13981818f, 0.02090345f, 0.00059093f, -0.05212554f, -0.08520272f, 0.15877104f, 
    0.15595894f, -0.00390163f, -0.12621884f, 0.07412531f, 0.02342684f, -0.03437431f, 0.01120617f, 0.18688439f, 
    -0.03809768f, -0.10348091f, -0.06521434f, 0.05765188f, -0.08846088f, -0.05542061f, -0.03818228f, 0.08954599f, 
    0.00278819f, -0.07721723f, 0.09180433f, 0.07603687f, 0.15316775f, 0.01901432f, 0.07195493f, 0.03064698f, 
    -0.09128301f, 0.07513151f, 0.22158101f, -0.04475681f, 0.07100229f, 0.03137880f, 0.07730444f, 0.03985731f, 
    -0.02111687f, 0.02711314f, -0.03150088f, -0.04762575f, -0.04459909f, -0.11377252f, 0.13924192f, -0.00091010f, 
    -0.01356378f, -0.02510462f, -0.07505022f, 0.08459480f, -0.07743061f, -0.02368319f, -0.03966641f, 0.10851268f, 
    -0.00108258f, -0.08216244f, -0.01346870f, 0.01481623f, 0.04009805f, -0.04509710f, 0.03499905f, 0.01876686f, 
    -0.31332648f, 0.14864968f, -0.13949181f, 0.10914569f, 0.00852988f, -0.15488225f, 0.00612630f, 0.09629868f, 
    0.15077545f, -0.03990424f, -0.02167347f, 0.03858013f, -0.06074649f, -0.16036695f, 0.12867737f, 0.03476133f, 
    0.09357454f, 0.03187520f, 0.18083309f, 0.17990646f, -0.00666478f, -0.02167741f, 0.09535655f, 0.05735216f, 
    -0.11824651f, 0.25700635f, 0.25302637f, -0.18515119f, -0.06254117f, -0.04071070f, 0.04773997f, -0.09350317f, 
    0.05675001f, -0.03577990f, 0.02250017f, -0.03229989f, 0.21495278f, -0.19626038f, 0.11774479f, 0.00884314f, 
    -0.06231047f, -0.07397650f, 0.04539154f, 0.07460519f, 0.06396753f, 0.13859947f, 0.01284301f, 0.03248517f, 
    0.02985412f, 0.07753993f, 0.19208902f, 0.05715958f, 0.08161385f, -0.05392691f, 0.00079706f, -0.00287160f, 
    -0.01173047f, -0.03662562f, -0.05777480f, 0.00917350f, 0.06019915f, 0.15524147f, -0.05705093f, -0.23713228f, 
    0.18782534f, -0.03076578f, 0.11469810f, 0.05478410f, 0.17350209f, -0.02155186f, -0.08158608f, 0.04248378f, 
    0.12913199f, -0.07549806f, 0.10224524f, 0.13974085f, 0.00565270f, 0.02050978f, 0.01083177f, -0.05973235f, 
    0.28600442f, 0.15422711f, 0.07921431f, 0.23729919f, 0.03367002f, 0.00595997f, -0.08155236f, -0.17014354f, 
    0.04350485f, 0.15917711f, 0.00216665f, 0.14292559f, 0.06235979f, -0.00293303f, 0.03441342f, 0.05555968f, 
    0.23599979f, -0.09735089f, 0.12194568f, 0.01050607f, -0.00166120f, -0.07542574f, 0.02935050f, 0.00884850f, 
    0.12922445f, 0.15502980f, -0.18794447f, -0.01414906f, -0.14758727f, -0.23219003f, 0.05416275f, -0.16283906f, 
    -0.05238325f, 0.06955216f, -0.10347262f, 0.01948307f, -0.09213450f, 0.01708321f, 0.04565474f, 0.10787297f, 
    -0.02514384f, -0.23054282f, 0.10773145f, 0.29621038f, 0.04582975f, 0.03262160f, 0.00209155f, -0.18717453f, 
    0.00262080f, -0.03911441f, 0.00668886f, 0.16357380f, -0.05770971f, 0.22241755f, -0.05101216f, 0.13359353f, 
    0.02872099f, 0.12227593f, 0.11342268f, 0.08427320f, 0.11226691f, -0.03964304f, 0.28248334f, -0.05607694f, 
    0.11873406f, -0.29600617f, 0.31014895f, 0.13966911f, -0.18993852f, 0.07994800f, -0.15086044f, -0.00088529f, 
    -0.15887669f, -0.12238141f, -0.06208996f, 0.02312989f, -0.02840094f, 0.11249165f, -0.06411300f, -0.06935298f, 
    -0.07700468f, 0.05089625f, 0.14292875f, -0.05685856f, -0.04460467f, 0.02838218f, 0.02123718f, 0.03812738f, 
    0.09288285f, -0.00839560f, 0.00167795f, -0.12704085f, -0.02880274f, 0.00478132f, -0.07040002f, -0.03353898f, 
    0.03477122f, 0.18384032f, 0.07720984f, 0.05567388f, -0.03089722f, -0.20786391f, 0.02140177f, 0.14925349f, 
    -0.00619433f, -0.08137359f, 0.05292223f, 0.09336544f, -0.00642952f, -0.00032198f, -0.01033612f, -0.03381559f, 
    -0.03688489f, -0.03496072f, -0.04817098f, -0.04472131f, -0.15080272f, -0.14749460f, 0.12459391f, -0.04570804f, 
    0.10690111f, 0.02352376f, 0.06983559f, 0.07085491f, -0.01865324f, 0.04684383f, 0.18617144f, -0.02744052f, 
    -0.00852515f, -0.13175532f, -0.05309640f, 0.10240597f, -0.04720804f, 0.12503536f, -0.02956625f, -0.13888791f, 
    -0.24861634f, -0.07300139f, -0.28358746f, 0.02562456f, -0.05393421f, 0.12736459f, 0.09127995f, 0.03504085f, 
    -0.06043555f, 0.04317845f, 0.06423998f, 0.11038560f, -0.08128369f, -0.02281048f, 0.04875628f, -0.09269974f, 
    0.03473500f, -0.02261933f, 0.03066247f, -0.04019573f, -0.00724877f, -0.08065175f, -0.03166834f, -0.03022553f, 
    0.38016021f, 0.27104521f, -0.22718635f, -0.19788492f, 0.05515241f, -0.16580142f, -0.03365408f, 0.18515664f, 
    0.01112992f, 0.17598765f, -0.02907079f, 0.10154957f, -0.16968501f, -0.17980149f, 0.05495992f, 0.05956494f, 
    0.02957046f, -0.08130322f, -0.02872652f, 0.02749688f, 0.00089082f, 0.01938758f, 0.15520547f, -0.01560898f, 
    0.09613787f, -0.13100405f, -0.03070329f, 0.21166602f, 0.00840486f, 0.06343646f, 0.01518388f, 0.02157982f, 
    0.06461817f, -0.02758857f, 0.02254646f, 0.01647114f, -0.29937276f, -0.04750721f, 0.03593700f, 0.18340342f, 
    0.03917521f, -0.13132358f, 0.08836943f, 0.28994417f, -0.01769252f, -0.08784630f, 0.10608852f, 0.16573413f, 
    0.12383177f, 0.04603887f, 0.01449764f, 0.04750031f, 0.01810420f, -0.03841791f, 0.18948105f, 0.13944834f, 
    -0.08658122f, 0.13370220f, 0.08067654f, 0.11909693f, 0.10547338f, 0.10947318f, 0.02282334f, -0.01046012f, 
    0.05254066f, -0.02915110f, -0.06703334f, 0.01007053f, 0.01690811f, -0.08430001f, 0.02965275f, -0.05803936f, 
    -0.31372312f, -0.08657991f, -0.20122972f, 0.06947812f, -0.09723877f, -0.14198141f, 0.19441682f, 0.00943147f, 
    0.00166916f, -0.06067314f, 0.05560168f, 0.10137861f, 0.08801159f, -0.00930113f, -0.12109212f, 0.04133554f, 
    -0.06990174f, -0.03362080f, 0.15400384f, 0.12237950f, 0.01764940f, 0.10079448f, -0.02489060f, 0.02498985f, 
    0.38049036f, 0.00377490f, 0.02377800f, -0.16493563f, -0.02159342f, -0.05001467f, -0.02334670f, -0.02625004f, 
    0.07025761f, -0.01683127f, 0.03923962f, 0.09855905f, 0.08044662f, -0.04318803f, 0.13405244f, 0.08749419f, 
    0.10515296f, -0.09155172f, 0.02594163f, 0.23046078f, -0.08707377f, -0.01964252f, 0.12803274f, -0.07310804f, 
    0.08757266f, 0.12239441f, 0.30968490f, -0.04411751f, -0.02852471f, 0.17427291f, -0.00695597f, -0.00254679f, 
    0.04922158f, 0.02857140f, 0.18406785f, 0.09615038f, 0.21097617f, 0.10458642f, -0.05932713f, 0.30235574f, 
    -0.00326616f, -0.09430338f, 0.31626526f, -0.01692995f, -0.06605739f, 0.11764582f, 0.00999383f, -0.16758618f, 
    0.17743237f, -0.17336093f, -0.05463703f, -0.17063449f, 0.04977506f, 0.05288398f, 0.18665805f, 0.08959180f, 
    0.09406633f, -0.04308981f, 0.04873285f, 0.02864709f, 0.03299363f, -0.13143219f, 0.01137037f, 0.11795317f, 
    0.09829378f, 0.18451618f, 0.13165835f, -0.05004606f, -0.07079245f, -0.02526348f, 0.05169961f, -0.03768296f, 
    -0.06054869f, 0.06894772f, 0.21900646f, 0.02197827f, 0.00596151f, -0.00645474f, -0.27366158f, -0.00078264f, 
    -0.00781352f, -0.07989251f, 0.16112193f, -0.02877615f, 0.00683014f, 0.02823121f, -0.00207972f, -0.07881710f, 
    -0.05054879f, 0.00266585f, -0.14068675f, 0.01855252f, 0.01224595f, 0.10163429f, -0.14102867f, 0.17440489f, 
    0.05357157f, 0.00251884f, -0.02904755f, -0.02861637f, 0.09915099f, 0.02608223f, 0.03766320f, 0.07881106f, 
    -0.02955731f, 0.02485142f, 0.05864801f, -0.04239504f, -0.08558536f, 0.01084938f, 0.22278078f, 0.17580882f, 
    0.06433166f, 0.19817869f, 0.13469861f, 0.03481842f, 0.01927982f, -0.12093777f, 0.07479807f, 0.04109399f, 
    0.05427569f, -0.09867350f, -0.13486713f, -0.07663505f, 0.01003912f, -0.06732459f, -0.01646087f, 0.02274802f, 
    -0.16119838f, 0.11695915f, 0.00402216f, 0.03725579f, -0.04010189f, 0.03819070f, 0.03874882f, 0.18291414f, 
    -0.17736824f, -0.07687951f, 0.06435632f, -0.04948343f, -0.02381708f, -0.05784817f, -0.01977509f, -0.09496009f, 
    -0.17909534f, 0.08158732f, -0.00882856f, 0.02881546f, -0.02227399f, -0.00697316f, 0.08607764f, 0.08519302f, 
    0.01933677f, 0.03317252f, 0.26332149f, 0.11448013f, 0.27055719f, 0.01048541f, -0.18864690f, 0.06760171f, 
    -0.00694782f, 0.02394155f, 0.17394483f, 0.09851497f, 0.02361239f, -0.02878443f, -0.07366691f, 0.03317623f, 
    0.03069006f, 0.15614693f, -0.21639001f, -0.17975006f, -0.07309397f, -0.02360566f, 0.00673662f, 0.01088072f, 
    0.05592302f, -0.09919450f, 0.01169239f, 0.01235163f, 0.01211358f, -0.10933330f, 0.32865992f, 0.13492958f, 
    0.01159383f, -0.10973000f, 0.07284880f, -0.06071145f, -0.16115879f, 0.16809297f, -0.14174737f, 0.13258138f, 
    0.38869014f, -0.25543246f, -0.10711420f, -0.15533346f, 0.06555809f, 0.05936450f, 0.16844890f, -0.16805094f, 
    0.20998810f, 0.05424924f, 0.01618429f, -0.03370950f, 0.07508354f, 0.05412326f, -0.04972513f, 0.13296700f, 
    0.12364616f, -0.00573966f, 0.09805811f, 0.03928358f, -0.10929889f, -0.07794242f, -0.08670497f, -0.08091930f, 
    0.00886633f, -0.00217310f, -0.24618800f, 0.14771514f, 0.03997595f, 0.15735312f, 0.12689368f, 0.03426809f, 
    0.05290613f, 0.03069868f, 0.04470986f, 0.00855399f, 0.12077994f, 0.12442373f, -0.11798047f, -0.09657037f, 
    -0.11550199f, 0.00081216f, -0.03904189f, -0.13844007f, -0.06497610f, -0.02732443f, 0.01381173f, 0.01010414f, 
    -0.05708223f, -0.01900456f, 0.01220080f, 0.11455556f, 0.06914961f, 0.02903000f, -0.06827694f, 0.08184241f, 
    -0.00938587f, -0.04530074f, -0.10231821f, 0.01339711f, 0.04897231f, 0.04764668f, -0.06547794f, 0.09358139f, 
    -0.00521072f, 0.05961384f, 0.00302555f, -0.04172936f, -0.01495430f, 0.03879970f, 0.02963967f, 0.11154069f, 
    0.03127633f, -0.01747208f, 0.06750145f, -0.09856990f, 0.02062408f, 0.15355672f, -0.04063793f, -0.12959726f, 
    -0.02177584f, 0.01955354f, -0.00989141f, -0.08970310f, 0.13338281f, 0.17612591f, -0.20250827f, 0.05612241f, 
    -0.13364112f, -0.00574998f, 0.06991543f, 0.08122434f, -0.01896140f, 0.04431641f, -0.08014617f, 0.02169914f, 
    -0.28583080f, -0.21001197f, 0.28996804f, 0.02878893f, -0.04418163f, 0.13416824f, 0.19907588f, -0.04243595f, 
    -0.13010387f, -0.14676099f, 0.03091124f, -0.01238817f, 0.21137877f, 0.39619842f, 0.04845116f, 0.03527588f, 
    0.02965072f, 0.05964905f, 0.07801645f, 0.05913480f, -0.05736383f, 0.05597546f, -0.20187877f, 0.00650242f, 
    -0.08136436f, 0.26786762f, 0.25900513f, -0.12537690f, 0.07313925f, 0.06333958f, 0.04077989f, 0.00826318f, 
    -0.06645171f, 0.00087595f, 0.10248484f, -0.08583417f, 0.23446810f, -0.02778221f, -0.07697098f, 0.12325162f, 
    -0.06171251f, 0.17398414f, 0.02920456f, -0.09518750f, -0.10362693f, 0.12672976f, -0.11815664f, -0.12018329f, 
    -0.08801900f, -0.02135487f, 0.13465017f, -0.02717950f, 0.04262174f, -0.02793194f, -0.16603084f, -0.10852969f, 
    0.13063812f, -0.02247122f, -0.07678250f, 0.13663739f, 0.18478993f, -0.08663533f, -0.12931959f, 0.04647514f, 
    -0.09152222f, 0.06932255f, 0.04464237f, -0.00537889f, 0.00019232f, 0.18123072f, -0.11826334f, 0.03284328f, 
    0.23730160f, 0.03896227f, -0.05788005f, 0.01451729f, 0.06359531f, 0.07655893f, -0.06127165f, 0.03277273f, 
    0.00031207f, 0.05872092f, -0.06468400f, 0.04632816f, 0.09005341f, 0.08796147f, 0.25487626f, 0.00727556f, 
    0.04936787f, 0.01700700f, -0.12945619f, -0.08979109f, 0.04897889f, -0.03366750f, -0.10296768f, 0.00169806f, 
    -0.09674931f, 0.11419454f, -0.16492409f, 0.07399307f, -0.01604102f, 0.14016058f, 0.09031315f, -0.04520013f, 
    0.04298606f, 0.07387049f, 0.07442425f, -0.06434559f, 0.01710532f, 0.01090969f, -0.13043717f, 0.04823724f, 
    -0.04695343f, 0.23299332f, -0.09218524f, -0.15536632f, 0.06698932f, 0.07075159f, 0.01569964f, 0.12212496f, 
    0.19201764f, -0.20713577f, -0.23739067f, 0.02254340f, -0.02526413f, -0.10329016f, 0.02087939f, 0.06202604f, 
    -0.02619486f, -0.02051656f, -0.06405822f, -0.02168971f, -0.28445569f, -0.15876105f, 0.23186016f, -0.03700649f, 
    0.07389805f, -0.02077464f, -0.15598547f, -0.00856337f, 0.03953246f, -0.04913081f, 0.18365996f, 0.09862342f, 
    -0.03844947f, -0.05071958f, 0.05886171f, -0.00649174f, -0.04926547f, 0.09198754f, -0.18681268f, -0.03321373f, 
    -0.11160580f, 0.12034015f, 0.01487308f, -0.02644791f, 0.00385267f, 0.20989244f, -0.14420170f, -0.01270019f, 
    -0.11966566f, -0.23308524f, -0.02676587f, -0.08467073f, 0.05794322f, -0.01156787f, -0.05063038f, -0.00782134f, 
    0.22559842f, -0.13923231f, -0.21086702f, 0.09116996f, -0.05684899f, 0.00075197f, 0.05662386f, 0.01903829f, 
    0.06365503f, 0.18442988f, 0.00518689f, 0.02402271f, 0.40439156f, -0.35718268f, -0.03990950f, 0.14743634f, 
    -0.03441313f, 0.07678638f, 0.22271958f, -0.00524502f, 0.06203255f, -0.10179842f, 0.09679639f, -0.09708651f, 
    0.14267421f, 0.23711172f, 0.12528616f, 0.04759881f, -0.11542407f, -0.08527140f, 0.01777719f, -0.01636042f, 
    -0.06995435f, 0.16244946f, -0.06734782f, 0.04791093f, 0.10407199f, -0.00806923f, 0.11632172f, -0.16371129f, 
    -0.18893842f, -0.05417211f, -0.00825956f, 0.07310954f, -0.04628870f, 0.07655994f, 0.01685842f, -0.03452754f, 
    -0.12588890f, -0.16564107f, 0.04503459f, -0.06682336f, 0.00107657f, 0.05297257f, 0.01736779f, 0.04076420f, 
    0.17724378f, -0.02324496f, 0.09409989f, -0.09917754f, -0.15373234f, -0.14422332f, 0.03443214f, -0.17182915f, 
    -0.09632468f, 0.05104938f, 0.02114616f, -0.08425912f, 0.01863408f, -0.03456672f, -0.13465594f, -0.07675249f, 
    0.07096053f, 0.14763103f, -0.02371890f, 0.03528550f, 0.21012160f, 0.05206764f, 0.11373115f, -0.10140765f, 
    0.14932637f, -0.00458336f, 0.16028139f, 0.14736743f, 0.16408123f, 0.03399732f, 0.01890595f, -0.00994561f, 
    0.06167179f, 0.05138762f, 0.09163468f, -0.04669720f, -0.05555407f, 0.05623378f, 0.06701443f, 0.04564296f, 
    0.04743178f, -0.11309569f, 0.12638198f, 0.06816953f, -0.08657411f, 0.05022115f, 0.09384991f, 0.21139733f, 
    0.11506099f, -0.06301775f, 0.01162538f, 0.04372230f, 0.28456604f, 0.02036206f, 0.14239576f, 0.04929167f, 
    -0.09463736f, 0.10742152f, 0.13416074f, -0.04662420f, 0.12657818f, 0.01547798f, 0.02119986f, -0.01157964f, 
    0.58057821f, -0.14735232f, -0.00199444f, 0.25687483f, 0.07510547f, -0.06286509f, 0.32460129f, -0.02054717f, 
    0.05079582f, 0.12323540f, -0.02576795f, 0.09171637f, -0.10655698f, -0.21319149f, 0.02798610f, -0.12761199f, 
    0.05448721f, -0.17499737f, 0.00052466f, 0.02630745f, -0.04308333f, -0.05613005f, 0.01816982f, -0.02007566f, 
    0.00502831f, -0.07761750f, 0.02489151f, -0.03648294f, -0.02191694f, -0.10491993f, 0.10356876f, 0.19943953f, 
    0.06022486f, 0.00668042f, 0.16146807f, 0.10589845f, -0.11761159f, 0.01271976f, -0.16803783f, -0.18157975f, 
    0.05651283f, 0.15953256f, 0.07754431f, 0.03212683f, -0.04666420f, -0.03350246f, 0.00255209f, -0.03776935f, 
    -0.09393785f, 0.06463201f, -0.02576573f, -0.15450826f, 0.06236567f, 0.09103365f, -0.09698029f, -0.14250959f, 
    -0.01374275f, -0.01265247f, 0.03201836f, 0.07261569f, -0.06695902f, 0.15959270f, -0.05131516f, -0.07190914f, 
    -0.20891429f, 0.04390511f, 0.11907671f, -0.04396791f, 0.02333820f, 0.05775828f, 0.05977902f, 0.02342623f, 
    -0.09789838f, 0.11824619f, 0.15130743f, -0.00013298f, -0.06082817f, -0.02400252f, -0.04014007f, 0.07615250f, 
    -0.03780349f, -0.05496267f, 0.07048462f, -0.12090869f, 0.02257751f, 0.26485196f, -0.11844058f, 0.05093419f, 
    -0.07765251f, -0.08926813f, -0.06888419f, -0.00094810f, 0.00358970f, -0.10655619f, 0.03007951f, -0.09839612f, 
    -0.38597506f, -0.02323966f, 0.14489622f, -0.20965269f, -0.04136661f, 0.10653175f, 0.05302826f, -0.04508420f, 
    -0.02483113f, 0.04633874f, 0.03026021f, -0.02781427f, -0.28095999f, 0.15277255f, -0.03503394f, 0.07001651f, 
    -0.10607956f, 0.08899417f, -0.08390772f, 0.00419687f, -0.00361013f, -0.06017890f, 0.01911230f, -0.06438114f, 
    0.14647517f, 0.16077410f, -0.05743338f, -0.22742848f, -0.15976104f, -0.02951366f, -0.02013642f, -0.01812791f, 
    0.06610171f, -0.00289326f, -0.09306132f, 0.05729095f, 0.22439730f, 0.27780622f, -0.36246079f, -0.22200368f, 
    -0.08272759f, -0.03789566f, 0.11889508f, 0.03856793f, 0.15636833f, 0.05566017f, 0.02651192f, -0.05329481f, 
    0.10106605f, -0.18591970f, -0.13881959f, -0.03411848f, -0.09410639f, 0.06945238f, 0.08642857f, -0.07969884f, 
    0.07861914f, -0.02264821f, 0.03283331f, -0.13517751f, 0.15823506f, -0.11849770f, -0.09693392f, -0.14352493f, 
    -0.10975381f, -0.02520291f, -0.17115369f, -0.04283906f, -0.00907707f, 0.00462367f, -0.06307556f, 0.17095406f, 
    -0.08664843f, -0.04636769f, 0.00032160f, -0.20766063f, 0.10817406f, 0.15163293f, -0.06326357f, 0.24477233f, 
    -0.04590727f, 0.04730123f, 0.05238799f, 0.00093558f, 0.09649313f, -0.17288962f, 0.17710334f, 0.19393414f, 
    -0.01024469f, -0.02685378f, -0.02427270f, 0.11816878f, 0.02642149f, 0.08748345f, 0.01274293f, 0.18725173f, 
    -0.31446618f, 0.13761051f, -0.05197689f, 0.02448503f, -0.15020716f, 0.03763287f, -0.07154823f, 0.22379255f, 
    -0.01398795f, 0.07053070f, 0.14828181f, 0.08485438f, 0.05007648f, 0.10446413f, -0.08206913f, 0.08920328f, 
    0.03480466f, 0.18339948f, 0.15056273f, -0.03520492f, 0.09895042f, 0.08109375f, 0.13635994f, 0.21039717f, 
    -0.03757470f, 0.04288206f, -0.11276890f, -0.06775842f, 0.11125353f, -0.11148737f, 0.23168568f, -0.02492147f, 
    0.04101157f, 0.13386144f, -0.09222095f, 0.09877216f, 0.01470502f, -0.35653350f, -0.10934055f, -0.23458812f, 
    0.11716331f, 0.00877446f, -0.00242300f, 0.09006153f, 0.08299764f, -0.07781323f, 0.07514910f, -0.02055100f, 
    -0.60771805f, 0.18464454f, 0.03671255f, 0.02028240f, 0.05054163f, 0.11148562f, 0.12874906f, 0.17897904f, 
    0.07029018f, 0.08170195f, 0.02005555f, -0.05491862f, -0.29299223f, 0.00294936f, -0.12423308f, 0.07076971f, 
    0.09759472f, 0.05206519f, 0.10691605f, 0.07307158f, 0.03721964f, -0.11347176f, 0.07937726f, 0.10348123f, 
    -0.07074681f, 0.12818590f, -0.08154171f, -0.25585377f, -0.08238669f, 0.10578895f, -0.05616277f, -0.01985177f, 
    -0.04590692f, -0.03180197f, 0.02597012f, 0.00311016f, 0.32170469f, -0.08909716f, 0.21748781f, -0.04378786f, 
    0.03431242f, -0.18950795f, -0.00431190f, 0.03583970f, 0.07568012f, 0.17464051f, 0.07199037f, 0.00176739f, 
    -0.14619914f, 0.10610732f, 0.13701221f, 0.01994887f, -0.11886351f, -0.08367880f, -0.07038037f, -0.04997616f, 
    -0.07275897f, -0.19675723f, -0.17073493f, -0.01243101f, 0.05136350f, 0.05322545f, -0.02087985f, -0.25429007f, 
    0.09903795f, 0.10046402f, 0.05135783f, -0.04554955f, 0.09614079f, 0.06371769f, 0.10979276f, 0.00840757f, 
    -0.06614336f, -0.14049284f, 0.04373504f, 0.01077884f, -0.03506533f, 0.07585702f, 0.01732393f, 0.03112941f, 
    -0.05095331f, -0.12741199f, -0.06612992f, -0.12157231f, 0.13150366f, 0.11251266f, 0.04050712f, 0.02025474f, 
    -0.11463551f, -0.06077501f, -0.03476272f, -0.12644032f, 0.07489454f, 0.04150607f, -0.01252989f, -0.04059219f, 
    -0.07260205f, -0.05769834f, -0.00568085f, -0.22960262f, -0.03845441f, 0.03979031f, 0.02970118f, 0.00059175f, 
    -0.05088552f, 0.08981527f, -0.15075889f, -0.01219075f, 0.25949472f, 0.05621212f, 0.09855556f, -0.04147393f, 
    0.13425300f, 0.07982254f, -0.10757963f, 0.07867324f, -0.00587729f, -0.01990203f, -0.01492912f, 0.02013587f, 
    -0.47688791f, -0.03426027f, 0.31798446f, 0.05700668f, -0.03551881f, 0.07100033f, 0.03186119f, 0.05861416f, 
    0.07636000f, -0.01454305f, -0.13964072f, -0.16223668f, 0.20221090f, 0.07468111f, 0.02301471f, 0.12556022f, 
    -0.01793755f, -0.24218094f, -0.01329073f, -0.08616505f, -0.08144930f, 0.06032756f, 0.01511172f, -0.06093385f, 
    0.00123386f, -0.45084754f, 0.42776111f, 0.01833022f, -0.12708357f, 0.07291067f, 0.11808728f, -0.00641736f, 
    0.13406530f, 0.03694666f, -0.05936971f, 0.00045643f, 0.19219591f, 0.08166057f, 0.21268916f, -0.01672839f, 
    -0.06570772f, -0.07372802f, 0.24987251f, -0.03585535f, -0.07745962f, 0.06197555f, 0.12447665f, 0.04978323f, 
    -0.04609133f, 0.16683622f, 0.02258907f, 0.06078295f, 0.00241292f, 0.15612179f, 0.08374178f, -0.03220774f, 
    -0.17561579f, -0.13061526f, -0.24284343f, 0.01470415f, 0.10315285f, 0.20105436f, 0.16736920f, 0.16985083f, 
    0.03216317f, 0.03380293f, -0.07416772f, 0.01757460f, -0.01633499f, 0.04600677f, -0.02378691f, 0.09397986f, 
    0.25631857f, 0.23933107f, 0.13406277f, 0.18809895f, 0.13140850f, 0.11514260f, 0.03623512f, 0.19215073f, 
    0.01634388f, -0.03673848f, 0.02000833f, -0.04193165f, 0.02292199f, -0.10107085f, -0.08653177f, -0.17290884f, 
    0.03856746f, -0.04292496f, -0.06966051f, 0.03695888f, -0.07791170f, 0.02581739f, -0.16476554f, -0.15214160f, 
    0.01780937f, 0.15640989f, 0.04085778f, 0.09278998f, 0.08597171f, 0.09508768f, -0.06885887f, 0.00661865f, 
    -0.03187849f, -0.00295909f, -0.03688719f, 0.04368611f, 0.24434306f, 0.17805800f, 0.10714044f, -0.00464492f, 
    0.07208883f, -0.01010205f, 0.01293352f, 0.05583185f, 0.04485609f, 0.02475293f, 0.07138790f, -0.05059586f, 
    0.10724096f, 0.18453826f, 0.12462668f, -0.15011001f, -0.03556838f, -0.08731291f, -0.08500246f, -0.05940558f, 
    -0.16905758f, 0.01126704f, 0.02394111f, -0.04723820f, 0.30715206f, 0.23904607f, 0.20563038f, -0.04448692f, 
    -0.05890017f, 0.07279839f, 0.01989528f, 0.00048586f, -0.00892152f, 0.05136225f, -0.12885864f, -0.23493050f, 
    0.09833711f, 0.03609961f, -0.13164578f, -0.02737339f, -0.15876327f, 0.13181993f, 0.01207860f, 0.04164658f, 
    -0.05241220f, 0.00560148f, 0.12464779f, 0.07320465f, 0.72176498f, -0.22538641f, -0.30595642f, -0.01156137f, 
    -0.08692133f, 0.03764574f, 0.00703064f, 0.09152119f, -0.04837470f, -0.03080882f, 0.06718411f, -0.16144073f, 
    0.10521343f, 0.05064170f, 0.04115353f, 0.01678495f, -0.06847379f, -0.14155535f, -0.10161410f, 0.12260290f, 
    -0.04524181f, -0.05922926f, -0.03231732f, -0.16545254f, 0.08570761f, 0.12804766f, 0.05211307f, 0.02190467f, 
    0.00338922f, 0.06203885f, 0.07240978f, -0.04664841f, -0.02489443f, -0.09449156f, 0.03735638f, 0.15513429f, 
    0.15332060f, 0.13700297f, 0.18475729f, 0.06112071f, 0.11021379f, 0.10183970f, 0.01111767f, 0.07530743f, 
    0.06558745f, -0.03569610f, -0.02644779f, -0.03398397f, -0.13827921f, -0.03935215f, 0.10398552f, -0.02006740f, 
    -0.10617866f, 0.01303748f, -0.05070492f, 0.03175847f, -0.07032289f, 0.06797817f, -0.10787725f, -0.11317540f, 
    -0.13081606f, 0.09164003f, -0.03086006f, -0.05677218f, 0.01613253f, 0.01383086f, 0.07721892f, 0.00220480f, 
    -0.07784463f, 0.07325425f, -0.11170471f, -0.09038343f, -0.01277409f, 0.13684566f, -0.01423255f, -0.12941849f, 
    0.00628033f, -0.04548631f, 0.06403461f, 0.00787742f, -0.00511959f, 0.00353860f, -0.09926388f, -0.01056384f, 
    0.19184129f, -0.08857778f, 0.16530125f, 0.25848967f, -0.09347504f, 0.04662755f, 0.18793556f, -0.04095402f, 
    -0.01394721f, -0.02117684f, -0.05783603f, 0.10569937f, -0.17915790f, -0.13581699f, 0.04672381f, -0.25061059f, 
    -0.15475242f, 0.15101661f, -0.03626778f, 0.09744129f, -0.07169386f, -0.02057021f, 0.01176919f, 0.00912895f, 
    -0.16118787f, -0.03902581f, 0.06554236f, 0.03034089f, -0.15465571f, -0.01147509f, 0.01062254f, 0.00805771f, 
    -0.12192917f, 0.08502387f, -0.00065680f, -0.05531721f, -0.06265136f, 0.06282090f, 0.07591652f, -0.01920270f, 
    0.06965765f, -0.06667311f, 0.05057803f, 0.07033688f, -0.04350260f, 0.04514433f, 0.08004694f, 0.01724844f, 
    0.24312742f, 0.05283136f, -0.11874712f, 0.21016790f, 0.13002829f, 0.08714818f, -0.06735760f, 0.25265223f, 
    0.05762113f, 0.05777263f, 0.03488165f, 0.02302130f, 0.28688800f, 0.03567828f, -0.03186033f, -0.00179031f, 
    0.00744991f, 0.02885374f, 0.05368005f, -0.02341451f, 0.00466955f, 0.06600358f, -0.06192263f, -0.01328803f, 
    0.07932809f, -0.01996008f, -0.05876639f, 0.10120088f, -0.03294805f, -0.05300540f, -0.06976977f, -0.03259213f, 
    0.00153193f, 0.12110819f, 0.05203791f, 0.03617888f, 0.33681136f, -0.04774166f, -0.08294224f, 0.09016480f, 
    0.06628372f, 0.02917414f, 0.05992350f, -0.17267549f, -0.01045301f, -0.06617115f, 0.08700176f, 0.04848666f, 
    0.14611655f, -0.14276302f, 0.13632616f, 0.26348829f, -0.02708894f, -0.12887941f, 0.01232054f, -0.07896706f, 
    0.05628324f, 0.09141470f, 0.22543712f, 0.18546267f, -0.09288777f, -0.06239157f, -0.17434120f, -0.16587049f, 
    0.08879983f, 0.09806141f, 0.03668166f, 0.07316887f, -0.11458482f, -0.06805593f, -0.16098459f, 0.08137645f, 
    0.07980624f, -0.20211937f, 0.12546384f, 0.15127231f, -0.12769194f, 0.02685694f, 0.11670950f, 0.09185397f, 
    -0.01649620f, 0.03927603f, -0.31454873f, 0.14491792f, 0.04802106f, 0.11736780f, 0.25516537f, -0.09298991f, 
    -0.01895705f, -0.04178581f, -0.05129081f, 0.18794738f, -0.09172873f, 0.07825194f, -0.03584761f, 0.04154243f, 
    0.00627919f, -0.10288502f, 0.60925370f, 0.33163804f, 0.02805160f, -0.01717464f, 0.02819082f, -0.17786048f, 
    0.01897978f, 0.03437341f, -0.21853264f, 0.09219061f, -0.04103451f, 0.06062652f, -0.08694245f, -0.06127595f, 
    -0.05366071f, 0.10150553f, 0.09842881f, 0.03323749f, 0.05182705f, -0.22258966f, 0.10894081f, -0.00538604f, 
    0.11191991f, -0.15013154f, 0.29700971f, -0.10237549f, 0.05128144f, 0.19246088f, -0.04612929f, -0.02225279f, 
    -0.05859073f, 0.02182679f, -0.01988029f, -0.15929772f, -0.02345441f, 0.12466948f, -0.09399877f, 0.00435185f, 
    0.17673010f, -0.06854133f, -0.00463281f, -0.16834173f, -0.04960251f, -0.21852219f, -0.22619931f, -0.06648830f, 
    0.05651348f, -0.03021049f, 0.14011964f, -0.01947497f, -0.03729083f, 0.12247470f, -0.08326893f, -0.14054337f, 
    0.09508742f, 0.07723886f, 0.00495097f, 0.03514975f, 0.22877128f, 0.17114036f, 0.24826479f, 0.06172686f, 
    0.24628508f, 0.01839629f, 0.09755114f, 0.16228582f, 0.05878878f, -0.01272697f, 0.14614032f, 0.03807966f, 
    0.14964813f, 0.33851576f, 0.03746948f, 0.06372152f, 0.06276278f, 0.01429951f, -0.00477011f, -0.01747474f, 
    0.08663693f, -0.02116852f, -0.05957899f, 0.10601076f, -0.01958450f, -0.00543170f, -0.31330454f, -0.08815645f, 
    0.01934835f, -0.13264610f, -0.00652568f, 0.13236484f, 0.07209525f, 0.04731529f, 0.22464336f, 0.09566244f, 
    -0.08595458f, 0.22556239f, 0.02776561f, 0.13845174f, 0.05040814f, -0.04649338f, 0.18330930f, 0.09939801f, 
    0.02605194f, -0.09594721f, 0.08604558f, 0.04817329f, 0.02648091f, 0.16823176f, 0.06152611f, 0.03249048f, 
    0.05966752f, 0.01406272f, 0.01724659f, 0.06732487f, 0.00263322f, -0.10607585f, 0.11716634f, -0.09268545f, 
    0.32629707f, -0.04285856f, -0.13380963f, -0.03183407f, 0.02083976f, -0.04882488f, -0.09626477f, -0.09921936f, 
    -0.05788527f, -0.05848826f, -0.06490143f, -0.05077777f, -0.11369853f, 0.00769424f, 0.05964525f, -0.34818274f, 
    -0.01362409f, 0.05456631f, -0.08938359f, 0.00096679f, 0.03554941f, 0.00195738f, 0.01428084f, 0.07064556f, 
    0.07506590f, -0.02704928f, 0.14801285f, 0.02417563f, -0.09839638f, 0.13242485f, -0.09905537f, 0.12143670f, 
    -0.17969672f, -0.16832778f, 0.00775532f, -0.07525267f, -0.58921564f, -0.50390685f, -0.09770372f, -0.15217818f, 
    -0.27444610f, -0.05187682f, -0.08776639f, 0.03407097f, -0.10064208f, -0.11209680f, -0.05758249f, -0.06842689f, 
    -0.04046720f, 0.09428237f, -0.11235436f, 0.06780790f, -0.04077019f, 0.02489520f, 0.07332830f, 0.21696593f, 
    0.17064776f, 0.15177923f, 0.05904246f, 0.13814668f, -0.09575839f, 0.06160289f, -0.06059279f, 0.02655426f, 
    0.06518271f, -0.00561779f, -0.10167339f, -0.02904705f, -0.20383616f, -0.09014565f, -0.04067254f, -0.08497433f, 
    -0.07070987f, 0.21931003f, 0.02856591f, 0.12057860f, -0.00889398f, -0.04560712f, 0.03166879f, 0.06847826f, 
    0.05034105f, -0.16846184f, -0.06873433f, -0.01036926f, -0.17152065f, -0.38721880f, 0.10367920f, 0.02559208f, 
    -0.06522821f, -0.03483921f, 0.04789582f, -0.12459573f, -0.09102046f, -0.07304817f, -0.03184927f, -0.03105613f, 
    0.37536764f, -0.14104727f, 0.02918895f, -0.13877796f, -0.04770507f, -0.08806675f, -0.01427289f, 0.04656691f, 
    0.06019007f, -0.05049532f, -0.01007752f, -0.10568871f, 0.19609205f, -0.14943263f, 0.23567009f, 0.11755034f, 
    0.16956832f, -0.07453943f, 0.10415836f, 0.09933203f, -0.09482445f, 0.13919823f, -0.11616816f, -0.04117036f, 
    0.00214913f, 0.10918494f, 0.05043741f, -0.04338649f, 0.01755421f, 0.04545117f, -0.06497368f, -0.03939639f, 
    -0.01346527f, -0.23070262f, 0.07917827f, -0.03735254f, -0.12933077f, 0.45524937f, 0.23404762f, 0.26918679f, 
    -0.06580867f, 0.03895948f, 0.02790498f, 0.01446060f, -0.13632622f, -0.08595458f, -0.08928523f, -0.02059160f, 
    -0.04411501f, 0.07366225f, -0.07608952f, 0.00383404f, -0.11411675f, -0.06342365f, 0.09791253f, 0.08077275f, 
    0.10903730f, -0.01512287f, -0.02184242f, 0.04618313f, 0.20549989f, 0.10549877f, 0.22861773f, -0.31642151f, 
    0.04592036f, 0.05855253f, -0.00109178f, 0.07903840f, 0.01665734f, 0.18877974f, 0.03437723f, -0.13067476f, 
    0.27496323f, 0.25960246f, 0.01820663f, 0.08031727f, 0.16028585f, 0.00584309f, -0.00048798f, 0.05048511f, 
    0.04947065f, 0.02379355f, 0.01407820f, -0.00179256f, 0.07965562f, -0.02699359f, -0.28473949f, -0.16355363f, 
    0.03359427f, -0.11355188f, -0.16580509f, 0.00285056f, 0.00807037f, 0.13371703f, -0.14168178f, 0.08170740f, 
    0.12739058f, 0.07877742f, -0.07850014f, -0.09428044f, -0.00743496f, -0.01298372f, -0.10098536f, 0.04387008f, 
    -0.08544842f, -0.01391591f, -0.02506554f, -0.06553869f, -0.09115091f, 0.22702824f, -0.18453065f, 0.08055570f, 
    0.03691459f, 0.04358952f, -0.08175093f, 0.04660451f, -0.10147862f, -0.05687497f, -0.01320633f, -0.11764930f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.01606518f, 0.01859123f, 0.14465871f, 0.18122144f, -0.03032151f, 0.17075473f, 0.07352418f, 0.05629015f, 
    0.07878742f, 0.00770375f, -0.00315064f, 0.05857557f, 0.00692158f, 0.01117644f, 0.00323470f, -0.02969829f, 
    0.06886888f, -0.02959113f, 0.09254977f, 0.08333815f, 0.17761339f, -0.05497058f, 0.03815917f, 0.02077665f, 
    -0.05647629f, 0.01486428f, -0.02453596f, -0.00957023f, 0.08176762f, 0.07432389f, 0.13364086f, 0.19868036f, 
    0.10974295f, 0.05604836f, -0.02301396f, -0.03133184f, -0.05160197f, -0.04355936f, -0.13009161f, -0.04008250f, 
    -0.03488281f, -0.02353531f, 0.06329313f, 0.02931676f, -0.01353674f, -0.02107059f, 0.02211336f, -0.00571621f, 
    0.03904185f, 0.01509530f, 0.10849723f, 0.00912178f, 0.03536392f, -0.05366831f, -0.08931221f, 0.01013380f, 
    0.21289891f, -0.05389237f, 0.16141659f, -0.00663089f, 0.02840397f, 0.12280940f, -0.00185714f, -0.08578565f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.08908743f, 0.16185193f, -0.03387432f, -0.26447853f, -0.11148226f, 0.02275173f, 0.02799043f, 0.03916980f, 
    -0.19556339f, -0.16220398f, 0.23133008f, 0.07095030f, -0.06638054f, -0.08359005f, 0.02304528f, -0.05519758f, 
    0.10245289f, 0.02199100f, -0.41361949f, -0.24158944f, -0.20199217f, 0.14372182f, -0.05494566f, -0.06774628f, 
    0.20849103f, -0.07205424f, 0.19116703f, -0.00715916f, -0.49977651f, -0.27183995f, -0.05456489f, -0.15566981f, 
    0.09719442f, 0.15301052f, -0.62387919f, 0.29090866f, -0.11836290f, -0.00515805f, 0.14936130f, 0.01098752f, 
    -0.11808394f, -0.04936228f, -0.46169832f, -0.05206934f, -0.07924844f, -0.21160816f, 0.07624728f, -0.07211046f, 
    -0.24378853f, 0.03805903f, -0.25663182f, -0.14518364f, -0.59622538f, -0.11209590f, 0.17046687f, 0.27823746f, 
    -0.29388973f, -0.06338219f, -0.28908235f, -0.12804313f, 0.19658278f, 0.03188887f, 0.16411580f, 0.19782068f, 
    -0.03457240f, 0.26718223f, -0.37172019f, 0.29428476f, -0.09093817f, 0.46370971f, -0.12120702f, 0.25855547f, 
    0.20395818f, -0.29557729f, 0.04628633f, 0.15351717f, -0.04539308f, 0.11463580f, 0.10733221f, -0.17713420f, 
    0.02870136f, -0.08667970f, -0.05996643f, -0.25745600f, 0.21680199f, -0.06485857f, -0.02711789f, 0.05534169f, 
    -0.63427287f, -0.04838810f, 0.04198304f, -0.00973580f, 0.02023479f, 0.21795550f, 0.08280835f, 0.14292845f, 
    -0.16802229f, -0.19326030f, -0.43791607f, -0.32522431f, 0.02019776f, -0.07393602f, -0.03932455f, -0.10566124f, 
    -0.06286131f, 0.03214440f, -0.06588978f, -0.07201008f, 0.10215133f, -0.21717225f, -0.03650615f, -0.12264870f, 
    0.12469859f, -0.02600911f, 0.28217125f, -0.14798966f, -0.24499910f, 0.02678959f, 0.00345931f, 0.18479663f, 
    0.20823331f, 0.00618871f, 0.10300611f, -0.31329414f, 0.25373390f, 0.14186183f, 0.15819557f, -0.27536589f, 
    -0.09476920f, -0.12702377f, 0.41474751f, 0.20962587f, 0.06050360f, -0.67523456f, 0.13478357f, 0.04480701f, 
    0.06817050f, -0.08156484f, 0.08183967f, -0.22733761f, -0.08325872f, 0.01472032f, 0.07054246f, -0.01190673f, 
    -0.00734769f, -0.11027344f, -0.26394203f, 0.19816923f, 0.00045940f, -0.09961858f, -0.11662009f, -0.18156932f, 
    -0.19892523f, -0.07469577f, -0.07082034f, 0.06491052f, 0.25754184f, 0.18414344f, 0.17498949f, 0.02212901f, 
    0.31215474f, -0.20155135f, 0.07769491f, -0.35553446f, -0.12312531f, -0.00745068f, 0.19647792f, -0.03659852f, 
    0.07656340f, -0.09789610f, 0.43825617f, 0.00760035f, 0.10241538f, 0.31270489f, -0.06008865f, -0.09713822f, 
    -0.27814534f, -0.05902508f, 0.00227875f, -0.11115604f, 0.03866453f, -0.00031558f, 0.03461592f, -0.34672061f, 
    -0.16749772f, -0.10931809f, 0.06713717f, -0.21341141f, 0.23705152f, 0.25105560f, -0.11704917f, -0.22168747f, 
    -0.01268160f, -0.61887234f, 0.28133610f, 0.07495918f, -0.05038834f, -0.30991596f, -0.42417401f, 0.18233460f, 
    -0.42397431f, 0.02685287f, -0.18830463f, 0.07464738f, -0.03710284f, -0.05377646f, -0.09739517f, 0.21120964f, 
    0.14711332f, 0.09536352f, -0.33827811f, -0.46031693f, -0.01577099f, 0.04183575f, -0.12262342f, -0.10807998f, 
    0.16448958f, -0.04891019f, 0.03503665f, 0.01863338f, -0.30889672f, 0.11015396f, -0.26006350f, -0.40216249f, 
    -0.14390033f, 0.10797572f, 0.35624877f, 0.19639511f, 0.05788947f, -0.05011014f, 0.19076817f, 0.06106045f, 
    -0.08964349f, -0.01754301f, 0.22577992f, 0.27980870f, 0.09799199f, 0.31318712f, 0.08247612f, -0.02507702f, 
    -0.25862205f, 0.03433196f, 0.29123691f, 0.20637478f, 0.19714284f, 0.07680847f, -0.02942587f, -0.05916888f, 
    -0.11130209f, 0.04131988f, -0.42961138f, -0.14156608f, -0.08715578f, -0.47880948f, -0.08750804f, -0.06865966f, 
    -0.00165321f, 0.23720226f, -0.57138520f, -0.31965268f, -0.08519662f, -0.13131513f, -0.18972129f, 0.02252336f, 
    0.02066091f, -0.00140187f, -0.09569932f, -0.06564812f, 0.03179922f, 0.06270048f, -0.09789354f, 0.11415950f, 
    -0.12042458f, 0.03394873f, 0.06137648f, 0.21374717f, -0.20615846f, 0.06089465f, -0.09582910f, 0.15780616f, 
    0.07727590f, -0.09171991f, 0.14882244f, -0.03987162f, 0.30996624f, 0.10038009f, -0.47011381f, -0.26354784f, 
    0.23372768f, -0.15366247f, 0.12200643f, 0.04612306f, -0.04575434f, 0.01223303f, 0.25148445f, 0.09332415f, 
    -0.08072351f, 0.08635778f, 0.10012300f, -0.04291728f, 0.00815854f, 0.11052214f, 0.10992333f, 0.02716126f, 
    -0.04296777f, -0.10034032f, -0.56110871f, -0.08227880f, -0.08933306f, -0.05328002f, -0.12142925f, -0.06476141f, 
    -0.34716189f, -0.08610493f, 0.12198064f, 0.20331495f, 0.02506534f, -0.27519348f, 0.08517410f, 0.15486775f, 
    -0.12692450f, -0.03931561f, 0.11977787f, 0.09463335f, 0.06005632f, -0.00365232f, -0.31696218f, 0.03507991f, 
    -0.13210919f, 0.09839817f, 0.13624288f, -0.15672530f, -0.02482780f, 0.02979294f, -0.12317190f, 0.10561708f, 
    0.04559797f, -0.10804626f, 0.33419058f, 0.23544481f, -0.03555562f, -0.07538395f, -0.00256145f, 0.05035001f, 
    0.08227900f, -0.07561344f, 0.13939756f, 0.04763696f, -0.14154254f, -0.39678410f, -0.12817925f, 0.18463744f, 
    0.20631202f, 0.21277490f, -0.31711766f, -0.38319290f, -0.04303670f, 0.05010945f, -0.33881781f, -0.11395799f, 
    -0.06029359f, -0.08129227f, -0.34168062f, -0.00920511f, -0.10271779f, -0.07063720f, 0.02280667f, 0.08645721f, 
    0.00500502f, 0.01145871f, -0.52099794f, 0.25333017f, -0.17373271f, 0.02218794f, -0.07583832f, 0.27709767f, 
    0.07541609f, -0.05851453f, 0.21444115f, -0.02174794f, -0.13916081f, 0.15480526f, 0.04627391f, 0.16347998f, 
    -0.05936648f, -0.12169212f, 0.25440413f, -0.24100259f, 0.04106548f, -0.03865575f, 0.16900654f, -0.54538167f, 
    -0.06576178f, -0.18858238f, -0.33485088f, -0.08678745f, -0.05416306f, 0.06296576f, -0.01843029f, 0.11423444f, 
    -0.03342025f, -0.04516888f, 0.20722915f, 0.21503882f, 0.04943103f, -0.48468500f, -0.03315006f, -0.18609764f, 
    -0.61131674f, 0.00023461f, -0.64827257f, 0.08892629f, 0.02170922f, 0.03007505f, 0.38631836f, -0.14003220f, 
    -0.12003054f, -0.43076181f, 0.23212925f, 0.35628748f, -0.04900866f, 0.05513604f, -0.38763699f, -0.09504813f, 
    0.01343472f, -0.02240075f, 0.37961301f, -0.07406386f, -0.01697442f, -0.18403910f, -0.09258296f, 0.03646024f, 
    -0.35611257f, 0.07368026f, 0.00204371f, 0.18654868f, 0.04063942f, 0.08088492f, 0.28307611f, -0.30652359f, 
    -0.08387256f, -0.09182382f, 0.16829860f, 0.20168303f, -0.16109473f, 0.34833506f, -0.18284203f, -0.57269263f, 
    0.07875477f, -0.13372181f, -0.24395919f, 0.07923711f, 0.05099254f, -0.16406773f, 0.05018762f, -0.47822839f, 
    0.17582305f, -0.05777869f, 0.21090464f, -0.16129160f, -0.06261404f, -0.06358165f, -0.08434579f, -0.16246323f, 
    -0.41872415f, -0.07743035f, -0.21054345f, -0.28165919f, 0.05254598f, -0.01056043f, -0.12924232f, -0.14707191f, 
    0.45874843f, 0.03278065f, -0.23652175f, -0.10855009f, 0.16365726f, -0.27053273f, -0.49038720f, -0.11219954f, 
    -0.41490203f, -0.19690068f, 0.23664623f, -0.40417600f, -0.05897558f, -0.01634564f, 0.42224857f, 0.00370756f, 
    -0.11059164f, 0.06750172f, -0.55235469f, -0.30878168f, -0.02788129f, 0.06060987f, -0.06651170f, 0.03760576f, 
    -0.06043053f, 0.06815618f, 0.12011710f, 0.30419600f, 0.16588558f, 0.01620960f, -0.23663816f, 0.16939287f, 
    0.01673819f, -0.12455510f, 0.17441685f, 0.23372883f, 0.06431929f, 0.01646356f, 0.06864709f, 0.33685517f, 
    -0.08981785f, -0.47618240f, 0.31347013f, -0.05729950f, -0.10902999f, -0.04490422f, -0.29073724f, -0.47762793f, 
    -0.07631622f, -0.28629452f, 0.25857687f, 0.28562582f, 0.04509664f, -0.11546149f, 0.02346689f, -0.36099899f, 
    0.22611266f, 0.02307417f, 0.04568005f, -0.10965274f, 0.24038102f, 0.26101118f, 0.10790935f, -0.35637984f, 
    -0.27984115f, 0.00811525f, -0.31701243f, -0.01352472f, 0.02156275f, -0.39479271f, -0.20050950f, 0.24154127f, 
    -0.34397262f, 0.19982150f, 0.09553936f, -0.50144887f, -0.05919990f, 0.07885904f, -0.30663261f, -0.06982180f, 
    -0.08905689f, 0.00001203f, -0.19015715f, 0.03483159f, -0.11664260f, 0.20292003f, 0.08395540f, 0.02512382f, 
    -0.24165991f, 0.01212133f, -0.04648343f, 0.07894089f, 0.17433400f, 0.01720894f, -0.24235062f, -0.21080858f, 
    0.21592471f, -0.01687181f, 0.03830362f, 0.09491450f, 0.17762372f, 0.09421162f, -0.33511350f, -0.59982085f, 
    0.00895154f, 0.17528170f, -0.29060495f, 0.13591994f, 0.10005781f, 0.10182603f, 0.32650045f, 0.06872531f, 
    0.04126020f, -0.64967209f, 0.07027190f, -0.49716216f, 0.02346846f, 0.06089620f, 0.00260035f, 0.13798685f, 
    0.02458461f, -0.05315012f, 0.11041017f, 0.22297269f, -0.07759739f, -0.41991591f, 0.10149884f, -0.09565164f, 
    0.51552039f, -0.01862811f, -0.30335337f, -0.07622923f, -0.09081379f, 0.00176822f, 0.05428588f, -0.09733906f, 
    0.19924554f, -0.27948451f, 0.05577366f, 0.33497640f, -0.05289797f, 0.04884062f, -0.06492844f, -0.03828337f, 
    0.09853498f, -0.07293859f, -0.08165197f, -0.27210292f, 0.09177501f, 0.01057011f, 0.08823384f, 0.01618991f, 
    0.63171315f, 0.02502238f, -0.17613332f, -0.16079025f, 0.22735220f, -0.01359164f, 0.09881510f, 0.16768235f, 
    0.10236409f, -0.07402150f, -0.01430085f, 0.09491228f, -0.42678481f, -0.37058192f, -0.16286331f, -0.03822904f, 
    -0.01336720f, 0.08433585f, 0.19560696f, 0.21320133f, 0.11132690f, -0.29525560f, -0.32325697f, -0.08363166f, 
    -0.35629022f, 0.44594169f, -0.38386035f, 0.03514220f, 0.00317174f, -0.00870828f, -0.00587963f, -0.54924619f, 
    0.34716150f, 0.11390532f, -0.03269732f, -0.23153585f, 0.25700349f, 0.19668427f, -0.07560797f, 0.19555265f, 
    -0.34828252f, 0.00356890f, 0.03578004f, -0.02506267f, 0.06413803f, 0.26927111f, 0.45467448f, -0.17577744f, 
    -0.11321919f, -0.52747601f, -0.09477652f, -0.13488345f, 0.06192350f, -0.03418840f, -0.42752519f, 0.09208729f, 
    0.02248375f, -0.05465044f, 0.16607952f, 0.24715468f, -0.01257186f, -0.55319917f, -0.04001716f, -0.06597611f, 
    -0.55154437f, -0.09568711f, -0.24632747f, 0.04180813f, 0.07493306f, -0.08550756f, -0.23106921f, -0.43737254f, 
    -0.05425586f, -0.00524916f, -0.22885408f, 0.26957706f, -0.22452974f, -0.14079668f, 0.23486845f, -0.10503400f, 
    0.08692624f, 0.37822738f, 0.17243378f, 0.10948803f, 0.04060131f, -0.24999495f, 0.17612506f, -0.01636124f, 
    -0.23886888f, 0.55010325f, -0.41529784f, 0.06691670f, 0.03031905f, -0.08735231f, 0.11817922f, 0.15724953f, 
    -0.52197647f, 0.01419441f, 0.16276594f, -0.21470988f, -0.12353559f, 0.08041084f, 0.03818952f, 0.09895178f, 
    0.05584966f, -0.11343253f, 0.02942616f, -0.11887361f, -0.16084842f, 0.23712189f, 0.15756649f, 0.18519279f, 
    -0.48721066f, 0.42609161f, 0.27273521f, -0.17315739f, -0.01287208f, -0.02124373f, -0.33544338f, -0.10051033f, 
    -0.02856761f, 0.06093314f, -0.35418969f, -0.36139953f, 0.06626372f, 0.18533348f, -0.08805170f, -0.11697237f, 
    -0.24751723f, 0.04941610f, 0.28066176f, -0.26990512f, 0.17749625f, 0.02608690f, -0.25519773f, -0.60855490f, 
    0.07368986f, 0.01126145f, -0.09436715f, 0.08810262f, 0.20526510f, -0.01051611f, -0.36792186f, 0.14693321f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.18264264f, 0.18742198f, 0.06389886f, -0.04780701f, 0.04512503f, 0.04206378f, -0.00274656f, -0.01642371f, 
    0.13396865f, -0.11420141f, 0.10729136f, -0.01901330f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
