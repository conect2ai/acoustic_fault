#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.73108041f, 0.06909802f, -0.25124246f, 0.43583366f, 0.26448277f, 0.54281175f, 0.44287765f, -0.42726493f, 
    0.02314721f, 0.21589160f, -0.36384693f, 0.36805874f, -0.28680599f, 0.45985079f, -0.07720836f, -0.21763630f, 
    -0.33349019f, -0.48152134f, -0.08615962f, -0.28747216f, 0.23661318f, 0.04232606f, 0.12408578f, -0.10836925f, 
    0.12498141f, 0.63543534f, -0.17801143f, 0.40172723f, 1.00739634f, 0.63145798f, 0.25789064f, 0.12960236f, 
    -0.28695905f, -0.00674745f, 0.13494954f, -0.68164545f, 0.13859469f, 0.18011995f, 0.18363076f, -0.06121379f, 
    0.17301565f, 0.51003957f, 0.26432693f, 0.04882576f, 0.17632742f, 0.11345645f, 0.06472184f, -0.15873788f, 
    0.09140839f, 0.00359451f, 0.39737421f, -0.45544878f, -0.36342329f, 0.10625469f, -0.18109240f, -0.00177504f, 
    0.69550294f, -0.06789353f, 0.46746185f, 0.19663315f, 0.27369270f, 0.05707509f, 0.16381331f, -0.12367408f, 
    -0.61526036f, -0.14229992f, -0.25679213f, -0.14470498f, 0.39337757f, -0.26101008f, -0.08440349f, 0.30595499f, 
    -0.21792120f, -0.26339343f, 0.46588722f, 0.65397137f, 0.11869588f, -0.84374511f, 0.19592981f, -0.27914327f, 
    -0.37181133f, -0.02096313f, 0.18025441f, 0.52199131f, -0.52088952f, -0.20493136f, -0.25652710f, 0.03174185f, 
    0.17886294f, -0.16752580f, 0.24675317f, 0.00369746f, -0.04842751f, -0.13953778f, 0.11508785f, -0.01039738f, 
    0.29150033f, -0.06251720f, 0.02023582f, -0.11799690f, 0.49238378f, 0.00909293f, -0.63950384f, -0.43078440f, 
    -0.73172468f, 0.07646893f, 0.47347438f, 0.10966957f, 0.39238259f, 0.65993536f, 0.17543529f, 0.24690533f, 
    -0.12995592f, -0.05388238f, 0.27623099f, -0.09496340f, -0.14514083f, 0.15475568f, 0.32140282f, 0.45454872f, 
    0.02586348f, 0.09576011f, 0.12878792f, 0.04119557f, -0.32279912f, 0.27769276f, -0.48709929f, 0.06892918f, 
    0.05953798f, -0.19910848f, -0.25023043f, -0.40009433f, -0.48036060f, 0.13549945f, 0.42346314f, 0.39251897f, 
    0.28078160f, 0.32473770f, 0.35317495f, -0.05441433f, -0.46045816f, -0.37675929f, -0.24251744f, -0.30596310f, 
    -0.08285344f, 0.24708928f, 0.09444422f, 0.24221380f, 0.26872030f, -0.22014627f, -0.22671071f, -0.50654989f, 
    -0.51278204f, 0.23728150f, -0.31755584f, 0.52918386f, 0.12002521f, -0.09956050f, 0.03267615f, -0.47614685f, 
    -0.43658036f, 0.37000054f, 0.10036555f, 0.33738363f, 0.17159757f, -0.34358791f, -0.20699221f, -0.33678585f, 
    0.36519751f, -0.06793806f, -0.16062534f, 0.26967913f, 0.14210697f, -0.40438074f, -0.14747179f, 0.20932548f, 
    0.41559169f, 0.66032994f, 0.60490686f, 0.77393222f, -0.09205700f, 0.00909019f, -0.53459644f, 0.23398630f, 
    -0.32518423f, 0.16515437f, 0.14816478f, 0.10699406f, 0.22048818f, 0.15710615f, -0.31389251f, 0.04780692f, 
    -0.04416558f, -0.03243994f, 0.37010846f, -0.05174370f, 0.25966510f, 0.21741037f, -0.00446563f, 0.00601862f, 
    0.46060035f, -0.89439952f, 0.58953983f, 0.73209035f, 0.19871290f, -0.10528505f, 0.49579564f, -0.09491242f, 
    -0.65277165f, 0.51309663f, 0.04356531f, 0.09864315f, 0.12509127f, 0.06347163f, 0.00331452f, -0.36702144f, 
    0.13588932f, -0.11836866f, 0.04342313f, -0.14443642f, -0.27278557f, 0.02956339f, 0.13856475f, -0.07881258f, 
    0.09864466f, 0.93137515f, 0.13219260f, 0.72638786f, 0.15957366f, -0.29856998f, 0.19658151f, -0.45314601f, 
    0.03896555f, 0.56810963f, -0.19896458f, -0.10391929f, -0.00252090f, -0.14087950f, -0.04776073f, 0.13434120f, 
    0.19936074f, -0.16552632f, -0.09157980f, -0.26360199f, 0.21838719f, -0.31201473f, -0.06457932f, 0.31607002f, 
    0.07203450f, 0.16976772f, 0.36384067f, 0.31026399f, 0.06879063f, 0.17736973f, 0.60263598f, 0.64333391f, 
    -0.38425443f, 0.35257065f, 0.18100600f, 0.03844557f, 0.06579948f, -0.13828857f, -0.05724337f, 0.16552737f, 
    0.09082033f, 0.09063607f, 0.03502549f, -0.04595993f, -0.03270764f, 0.33319554f, 0.23654214f, -0.00918037f, 
    0.40935916f, -0.15996403f, 0.37888268f, 0.74856424f, 0.46635851f, -0.51880163f, -0.13769595f, -0.08482914f, 
    -0.00187775f, -0.01356433f, -0.56545401f, -0.43386337f, 0.02204868f, 0.07494736f, 0.35059202f, 0.03834112f, 
    0.10163534f, -0.09496717f, 0.20473018f, -0.11168525f, 0.04226319f, 0.21425971f, -0.16786112f, 0.12036461f, 
    0.27663833f, 0.10551303f, -0.11152824f, 0.30017951f, -0.67065901f, -0.18935405f, -0.19731054f, -0.67192882f, 
    -0.39462256f, 0.11450907f, 0.17583041f, 0.23312727f, 0.41545534f, 0.30206454f, 0.39659154f, 0.18890552f, 
    -0.26201567f, -0.26723516f, -0.25210822f, 0.18391618f, 0.14631464f, 0.36935666f, -0.09178814f, 0.06306195f, 
    -0.05278599f, -0.11176067f, 0.08474359f, -0.09786746f, 0.32510179f, 0.96802723f, 0.58482081f, 0.03478219f, 
    0.08761155f, 0.04328359f, -0.29436779f, 0.10766710f, -0.24574718f, 0.47969320f, 0.40967339f, -0.05434151f, 
    -0.26079896f, -0.02852424f, -0.19910316f, 0.29654554f, -0.03017459f, 0.08841712f, -0.22723722f, -0.24827163f, 
    -0.12984747f, 0.01661442f, 0.08492619f, -0.08661175f, -0.11540749f, 0.01675330f, -0.28502584f, 0.67429537f, 
    -0.01476333f, -0.25046504f, -0.48867753f, 0.10927171f, 0.59164393f, -0.02437783f, -0.08877697f, 0.05826396f, 
    -0.11718427f, 0.09765730f, -0.38759035f, 0.28528932f, 0.25420767f, 0.18154995f, 0.00790109f, 0.02320466f, 
    0.00441295f, -0.08853307f, 0.15760779f, 0.39309049f, -0.20849562f, -0.04935982f, 0.48452970f, -0.36532167f, 
    0.16181791f, -0.33058718f, 0.51681459f, 0.01585709f, -0.00136156f, -0.38273948f, 0.01234168f, -0.03390835f, 
    -0.64527363f, -0.10132612f, -0.12652874f, -0.33506289f, 0.03526926f, 0.03150014f, -0.22310977f, 0.42528728f, 
    0.11137471f, 0.35276926f, 0.04466618f, -0.39005131f, -0.61774492f, -0.39409620f, -0.19540432f, -0.32028580f, 
    -0.42645857f, -0.53751433f, -0.24757992f, -0.52302319f, 0.48851344f, -0.03455507f, -0.38676456f, -0.63433784f, 
    -0.66230202f, 0.03218321f, -0.12551977f, 0.28638613f, 0.15147561f, 0.10189180f, 0.22846985f, 0.14439917f, 
    -0.26629826f, -0.30686927f, -0.16607626f, 0.26632744f, 0.14232482f, 0.05329109f, 0.02749080f, 0.16378613f, 
    -0.22662801f, 0.73308861f, 0.60667223f, 0.36507982f, 0.65310436f, 0.47974083f, -0.10952032f, -0.65512246f, 
    -0.20443578f, -0.72509772f, 0.18785901f, -0.02733671f, 0.50340009f, 0.18060264f, -0.02905954f, -0.12034386f, 
    -0.00978139f, 0.11942162f, -0.08095477f, 0.11223599f, -0.20251694f, 0.48137924f, 0.07571525f, 0.19346371f, 
    -0.00130145f, -0.07532923f, 0.09327817f, -0.48963374f, -0.42252487f, -0.48095036f, 0.13388543f, -0.38068110f, 
    0.69200855f, 0.12801267f, 0.18884762f, 0.30023083f, -0.02462132f, 0.39064503f, -0.24823090f, -0.01250721f, 
    -0.17500679f, 0.31217608f, -0.13873850f, -0.46589440f, -0.51541591f, -0.29752305f, -0.21268684f, -0.06098126f, 
    0.02872000f, 0.20137984f, -0.40051025f, -0.98618412f, 0.07096379f, 0.71562254f, -0.47326103f, 0.29400516f, 
    0.76166046f, -0.50828809f, 0.25176424f, -0.04997796f, -0.45581150f, -0.40236571f, 0.09642501f, 0.11096843f, 
    -0.13196914f, -0.32508755f, -0.34845921f, 0.10255640f, -0.19981907f, -0.46739841f, -0.31521443f, -0.02300474f, 
    -0.09508727f, 0.03611777f, 0.07284061f, 0.04115238f, -0.59008110f, -0.00253293f, 0.57410336f, -0.23975599f, 
    0.45133150f, -0.13360170f, -0.01371936f, -0.33696568f, 0.08329439f, -0.61692047f, 0.50079721f, -0.02148939f, 
    -0.15213159f, -0.15041123f, 0.03967255f, 0.33130634f, -0.02992599f, -0.05181591f, 0.35634014f, 0.36146623f, 
    0.41136274f, 0.24386214f, -0.31743920f, -0.05227920f, -0.00849392f, 0.30896088f, -0.11829137f, -0.07223504f, 
    -0.11607094f, 0.43132821f, -0.60880876f, -0.76542634f, -0.24465285f, -0.18888257f, -0.65607399f, 0.17541341f, 
    0.16365312f, -0.05473398f, 0.15829517f, 0.23856287f, 0.29056635f, -0.10878628f, 0.11648334f, -0.24955840f, 
    -0.18582688f, -0.22002941f, 0.01074333f, -0.02106605f, 0.39990553f, 0.53388649f, 0.11078008f, 0.00011758f, 
    -0.48454815f, -0.26518664f, -0.44900322f, 0.03880360f, 0.20850423f, -0.48008740f, 0.17747232f, -0.73611081f, 
    0.29753965f, 0.02775935f, -0.03327817f, 0.22950579f, -0.01234198f, 0.16082810f, 0.17912979f, -0.41607705f, 
    -0.30704141f, -0.16494536f, 0.24107517f, 0.30316848f, 0.41974717f, 0.28981006f, -0.14020082f, -0.09904535f, 
    -0.18794376f, -0.49504167f, -0.53245223f, 0.13650911f, 0.09864416f, -0.37511423f, 0.21346702f, 0.55354679f, 
    -0.17185308f, -0.52752399f, -0.00724907f, -0.24121946f, -0.17541586f, -0.47724921f, -0.29949513f, 0.08766580f, 
    -0.23013142f, 0.24126814f, 0.09067915f, -0.39048922f, -0.32853028f, -0.35136190f, -0.08213753f, 0.12007581f, 
    0.44478461f, 0.25556180f, 0.51749009f, 0.76617998f, 0.60869431f, -0.11116841f, 0.31160426f, 0.31292939f, 
    0.28642744f, 0.19135298f, -0.28560746f, 0.05766848f, -0.09450448f, -0.12874891f, 0.24894594f, -0.27553758f, 
    -0.21671158f, 0.03731519f, 0.27430147f, -0.32977849f, -0.16571446f, -0.24384761f, -0.33578604f, -0.10994267f, 
    -0.17496316f, 0.61487740f, -0.64294010f, -0.38173249f, -0.59861612f, 0.27841824f, 0.01287082f, 0.15807822f, 
    -0.39407840f, -0.30697656f, -0.15747178f, -0.38082254f, 0.10357684f, 0.01751049f, -0.12383793f, -0.25371596f, 
    0.22390123f, -0.02431451f, 0.13381395f, -0.07264164f, -0.28561199f, -0.06784917f, -0.22954768f, 0.24764119f, 
    0.23139736f, 0.02578361f, 0.96696097f, -0.04912652f, 0.09930863f, -0.51760840f, -0.17829221f, 0.46894428f, 
    -0.01519409f, -0.01905541f, 0.33498853f, 0.37015671f, -0.09700063f, -0.10160022f, -0.47791597f, -0.37367532f, 
    -0.01042209f, -0.19593160f, 0.08217070f, 0.04715719f, 0.12152363f, -0.16859283f, 0.45604861f, 0.32532567f, 
    -0.10489332f, -0.14315191f, 0.00512546f, -0.53644133f, 0.66846043f, -0.65089160f, -0.25771075f, -0.74377304f, 
    0.79352999f, 0.09687432f, 0.15072946f, 0.38068160f, 0.44068143f, -0.29028955f, 0.05064735f, -0.44930086f, 
    -0.12827347f, -0.25516105f, 0.01251416f, 0.21316913f, -0.25409165f, 0.03874825f, -0.16977020f, -0.26013163f, 
    -0.04519831f, -0.21576585f, -0.32767838f, 0.20427506f, 0.59127796f, 0.72161651f, 0.77166718f, 0.78262365f, 
    0.33610615f, 0.15286393f, 0.06919926f, -0.49556038f, -0.57871056f, -0.24426222f, 0.34246236f, 0.14180860f, 
    -0.03029914f, 0.07530267f, -0.23393945f, 0.06776288f, 0.16458337f, 0.31461111f, -0.20828907f, -0.08362456f, 
    0.06304818f, 0.25554779f, 0.09754220f, 0.23626588f, 0.17368658f, 0.26942471f, -0.47499692f, 0.48861510f, 
    -0.02744117f, 0.12779975f, -0.75629610f, -0.54661864f, -0.33383209f, -0.02601781f, -0.25473818f, 0.30180421f, 
    0.19152963f, -0.33060870f, -0.14466248f, -0.35106647f, -0.10874177f, -0.06887543f, -0.10203627f, 0.10983745f, 
    0.09285401f, 0.21798822f, -0.19488207f, -0.22743711f, -0.41501978f, -0.11137801f, -0.61091757f, 0.07896422f, 
    0.29677734f, -0.50917578f, -0.42340848f, -0.41782954f, 0.52535003f, 0.48602948f, 0.21597597f, -0.21035473f, 
    -0.48550829f, 0.28808105f, -0.28487533f, -0.12694687f, -0.23811571f, 0.05216333f, -0.34653419f, 0.06443847f, 
    -0.09898938f, 0.04165991f, 0.14032692f, -0.16147681f, 0.32402474f, 0.05235253f, 0.06328753f, -0.28585833f, 
    -0.24277537f, -0.43434229f, -0.30940813f, -0.54448605f, 0.68287784f, 0.88297147f, -0.32506773f, 0.13622825f, 
    0.10014874f, -0.29920968f, -0.40140331f, 0.33177263f, 0.14020155f, 0.04122705f, -0.31074145f, -0.19754048f, 
    -0.00887424f, -0.04733853f, 0.02227906f, 0.17595057f, -0.22978289f, 0.11424228f, 0.03168437f, 0.02547197f, 
    0.31725651f, -0.74132943f, -0.55508608f, 0.15805286f, 0.03741717f, 0.57828408f, 0.37173274f, 0.16247772f, 
    0.50388795f, -0.02762659f, -0.14708549f, 0.22126940f, -0.28599563f, 0.33841211f, 0.21173003f, -0.12545905f, 
    0.06303085f, -0.02374346f, -0.02868936f, 0.31354824f, -0.09324934f, -0.00466493f, -0.27621409f, -0.05666605f, 
    0.29107580f, -0.35383961f, -0.75664544f, -0.54666173f, 0.61117452f, 0.30383390f, -0.31781888f, 0.77921057f, 
    0.53634608f, -0.38612807f, 0.09008844f, 0.33500415f, -0.05800385f, 0.12833896f, -0.35689360f, 0.38688427f, 
    -0.30123243f, -0.15810251f, -0.46444845f, -0.28244376f, -0.25512901f, -0.06274392f, 0.13652518f, 0.23030294f, 
    0.27915528f, 0.04787656f, 0.87308133f, 0.34477845f, 0.93674248f, -0.59918308f, 0.47417736f, 0.21218133f, 
    0.00825196f, -0.12213867f, -0.36191621f, 0.02489070f, 0.19098632f, 0.27258235f, -0.05532327f, -0.00861700f, 
    0.17850845f, 0.15470827f, 0.11786523f, -0.02403627f, -0.08701152f, 0.17976204f, -0.18303734f, -0.19298497f, 
    -0.21248229f, -0.17370525f, 0.26085499f, -0.47110468f, 0.75632393f, -0.11458656f, 0.76258487f, 0.08364252f, 
    -0.12975787f, -0.08000794f, -0.62020010f, 0.58269584f, -0.06702990f, -0.00116436f, -0.30434158f, -0.50602263f, 
    0.26976630f, -0.25209758f, -0.10048552f, 0.14663130f, 0.19384700f, 0.11615618f, 0.28652328f, 0.06772017f, 
    0.06763662f, -0.13836312f, -0.03294418f, -0.18976161f, -0.62232697f, -0.39823213f, -0.39665294f, -0.24659702f, 
    -0.03612622f, 0.35300717f, 0.83400929f, -0.21517079f, 0.28540224f, 0.52102929f, -0.04841018f, -0.33041006f, 
    0.33485663f, -0.15170506f, 0.11248016f, 0.15866755f, 0.27247894f, 0.16658650f, 0.32312536f, -0.12593064f, 
    0.01746715f, -0.06895628f, -0.29284433f, 0.03613284f, 0.16109210f, -0.41384012f, -0.67860472f, 0.29932988f, 
    0.54345065f, -0.02461901f, 0.46524301f, 0.55956835f, 0.22318748f, 0.44136739f, 0.21372458f, 0.06144906f, 
    0.36755544f, 0.20469883f, 0.29198170f, -0.24386175f, -0.20832512f, -0.18039472f, 0.02816387f, -0.00305008f, 
    -0.05287638f, 0.03809028f, -0.23725347f, 0.17181897f, -0.19669126f, -0.40195444f, -0.55018741f, 0.27897069f, 
    0.60441178f, 0.53898191f, -0.62772292f, -0.42598525f, -0.46037924f, 0.16941838f, -0.25944585f, -0.31191558f, 
    -0.31233466f, 0.16460535f, -0.40210131f, -0.05604514f, -0.03589581f, -0.38321704f, -0.06333038f, -0.12237381f, 
    0.20632212f, 0.06031470f, 0.18417178f, -0.15425146f, -0.09659691f, -0.18312751f, -0.25792682f, 0.61074317f, 
    -0.13874090f, -0.40177888f, 0.70661181f, 0.06277609f, -0.17296359f, -0.33012787f, 0.39228800f, 0.42157876f, 
    -0.44222027f, -0.35021749f, -0.19465303f, 0.22766536f, -0.11334455f, 0.04423407f, -0.31558073f, -0.19935763f, 
    0.41452065f, -0.07296589f, -0.08355052f, 0.25140601f, -0.10957677f, 0.19229540f, -0.28562373f, 0.11635216f, 
    0.34349099f, 0.45885473f, -0.05468712f, 0.18087235f, 0.32044142f, -0.01900207f, 0.40078351f, 0.68078709f, 
    0.27611619f, -0.07581064f, -0.26406819f, -0.23728232f, -0.28304043f, -0.26175681f, -0.46962869f, -0.10330163f, 
    -0.10933001f, -0.40718660f, -0.13017602f, -0.21541081f, 0.07966049f, -0.31863028f, 0.20840909f, 0.08194378f, 
    -0.18222612f, -0.77175367f, -0.66523653f, 0.11959723f, 0.43012077f, 0.13162899f, 0.43642831f, 0.45092726f, 
    0.47746035f, 0.36692372f, -0.06959029f, 0.09965076f, 0.00414891f, 0.37965104f, 0.32054386f, -0.19246423f, 
    0.18819556f, 0.21655002f, 0.17981216f, 0.02135707f, 0.06329460f, -0.23678742f, -0.11377557f, -0.04118153f, 
    -0.19522972f, 0.04775485f, 0.05306111f, 0.69913042f, 0.26737168f, -0.44244626f, 0.46097377f, -0.10223983f, 
    0.31897816f, 0.42653319f, 0.27827260f, 0.53190887f, -0.18146293f, -0.18906640f, -0.18485269f, -0.52172256f, 
    0.07287367f, -0.11143168f, -0.10589009f, -0.22607562f, 0.39482054f, 0.05070756f, -0.40105861f, -0.22261323f, 
    -0.06264506f, 0.04561058f, -0.02447281f, -0.26425368f, -0.61389267f, -0.21329308f, 0.19375691f, -0.40859240f, 
    -0.12245782f, 0.04726474f, -0.20293543f, 0.46979859f, -0.20853302f, 0.19081350f, 0.11914083f, -0.10139416f, 
    0.08190945f, -0.26911339f, -0.31477985f, 0.01009404f, -0.21195841f, -0.20875968f, -0.08195172f, 0.12647374f, 
    0.13711649f, 0.25279495f, -0.08148137f, -0.11531876f, 0.36338624f, -1.11162090f, 0.43702415f, -0.42231885f, 
    0.21496554f, 0.66572696f, -0.92660201f, 0.80793136f, 0.16467859f, -0.15517832f, 0.10011876f, -0.14925121f, 
    -0.27183214f, 0.20019564f, 0.06789179f, 0.24094029f, 0.02686097f, 0.08924569f, 0.01200001f, 0.26770583f, 
    -0.04856297f, 0.10239074f, 0.02653282f, -0.09542255f, 0.01213997f, -0.21676636f, -0.28552091f, 0.17806940f, 
    -0.29158133f, -0.35690036f, 0.67178202f, 0.04045954f, -0.02697727f, 0.59497350f, 0.44137374f, 0.12850046f, 
    -0.48212236f, 0.45818979f, -0.05413613f, -0.23290682f, 0.12736057f, -0.20724146f, -0.15197165f, -0.21894889f, 
    0.08821900f, -0.44365358f, 0.23574279f, -0.02906508f, 0.16065261f, 0.22087008f, 0.12394594f, 0.47119880f, 
    0.47850516f, 0.61571687f, 0.66018617f, 0.36123821f, 0.33433738f, 0.47345436f, 0.13419443f, 0.27829239f, 
    -0.40075946f, -0.13947399f, -0.07466920f, 0.20629540f, -0.23309143f, -0.06415497f, -0.22524792f, 0.27661940f, 
    -0.13815320f, -0.01697517f, -0.31642115f, -0.23392871f, 0.14205489f, -0.07939999f, -0.18142568f, -0.35304865f, 
    0.07112523f, 0.12821694f, -0.68906748f, 0.20911942f, 0.10953827f, -0.23787601f, -0.25184023f, -0.59053367f, 
    -0.39088979f, -0.32143503f, 0.10341150f, -0.21752721f, 0.27684441f, 0.07513396f, -0.10738220f, 0.23586738f, 
    -0.05058119f, 0.19893484f, 0.49111724f, 0.24407952f, -0.27972654f, 0.03344171f, 0.22765896f, 0.14876737f, 
    -0.58930230f, -0.31874120f, 0.67052913f, 0.17901361f, -0.38223714f, 0.27335194f, -0.35518205f, 0.33792108f, 
    0.17970131f, -0.05406872f, -0.02754320f, 0.20405602f, 0.31372347f, 0.23233603f, 0.43128452f, -0.19232661f, 
    -0.22969723f, -0.13055170f, -0.54130679f, -0.21443282f, 0.32773548f, 0.05282708f, -0.30470586f, -0.09209694f, 
    0.25437942f, -0.77430868f, 0.70682561f, 0.39176217f, 0.32515255f, 0.66061515f, -0.24326916f, 0.64725274f, 
    0.56327236f, -0.21582408f, 0.51293343f, -0.37336305f, 0.04097605f, 0.23579170f, -0.40448692f, -0.13029739f, 
    0.12594843f, -0.25644580f, -0.09144641f, 0.18670674f, 0.24786769f, 0.13139783f, 0.03234225f, -0.07529409f, 
    -0.11136749f, 0.03720820f, -0.09016161f, 0.03080668f, -0.02102591f, -0.68641281f, -0.05004267f, -0.20817256f, 
    -0.60750788f, -0.53283036f, 0.37901464f, -0.41308036f, -0.01222205f, -0.47563154f, 0.21419613f, 0.07204139f, 
    -0.37145606f, -0.08360346f, 0.30952498f, -0.24007761f, -0.21471909f, 0.28354904f, -0.09953050f, 0.13254242f, 
    0.24224190f, -0.04633441f, 0.31320012f, -0.21356787f, -0.79633629f, -0.08334756f, -0.15564717f, -0.45833361f, 
    0.12835279f, 0.75255632f, 0.64182383f, -0.70240784f, 0.20857330f, -0.40455440f, -0.05341782f, -0.29968026f, 
    -0.35791907f, -0.17291875f, -0.35002729f, 0.05980749f, -0.02833069f, -0.00942817f, -0.15626116f, 0.02830521f, 
    0.07701732f, -0.23706158f, -0.19400133f, 0.09864829f, -0.49155253f, -0.48861119f, -0.67418844f, -0.53946650f, 
    -0.12231445f, 0.14338401f, 0.10785553f, 0.23316929f, 0.39561233f, 0.02013751f, -0.13926810f, -0.02508504f, 
    0.11273897f, 0.03998270f, 0.01717207f, -0.04066265f, 0.12944326f, 0.09788464f, 0.05472094f, -0.30542353f, 
    0.46292987f, -0.04037856f, 0.25391185f, 0.23835918f, -0.00816516f, -0.70145375f, 0.03032975f, 0.90582669f, 
    -0.21442562f, -0.62021887f, 0.11988569f, 0.10119569f, -0.07701777f, -0.29292873f, 0.01627336f, -0.29806000f, 
    0.09925352f, 0.04138222f, 0.28749454f, 0.31781849f, 0.23618264f, 0.14394033f, 0.07307421f, 0.06392247f, 
    -0.26561648f, 0.28132689f, -0.03617870f, -0.40886259f, -0.08990899f, -0.16304137f, -0.48854899f, -0.61680013f, 
    -0.23161304f, -0.26894134f, 0.44013229f, -0.16439535f, -0.12352475f, -0.50852603f, 0.15108410f, 0.45668635f, 
    -0.28729865f, 0.28213248f, 0.07061087f, 0.01364030f, 0.07125606f, -0.47414914f, 0.19236894f, 0.33652127f, 
    0.31795630f, -0.40679738f, -0.16559504f, -0.24739423f, -0.31661105f, 0.10036129f, 0.22357348f, 0.70133668f, 
    0.74728602f, 0.21422946f, 0.00634273f, 0.45414117f, 0.48766574f, -0.19291395f, -0.72654539f, 0.16332734f, 
    -0.50731105f, 0.27976635f, 0.12021713f, -0.11510858f, 0.05063793f, -0.25013283f, 0.21141241f, -0.00798790f, 
    0.07749137f, 0.17685822f, -0.05476953f, 0.37772718f, 0.02243592f, -0.21421655f, -0.25855187f, 0.37182322f, 
    -0.66080445f, -0.28717625f, -0.59983975f, -0.42481560f, -0.30569461f, 0.59869647f, 0.38277677f, -0.17410775f, 
    0.33994818f, 0.57152611f, -0.07633219f, -0.29580948f, 0.18063980f, 0.22555374f, 0.02052519f, -0.32129571f, 
    0.10075878f, 0.06287258f, 0.10388023f, -0.20647734f, -0.11749471f, 0.05798035f, 0.02358003f, 0.09382956f, 
    0.00722419f, -0.46836665f, -0.85999721f, 0.08291594f, 0.60870963f, 0.28979996f, -0.93004680f, -0.18935135f, 
    0.64236152f, -0.37479898f, -0.53518397f, 0.25804853f, 0.07042354f, 0.02863232f, 0.24390754f, 0.14874528f, 
    0.19575563f, 0.02338350f, 0.18144429f, -0.03287060f, 0.17812599f, -0.03894028f, -0.02809450f, -0.04455903f, 
    0.24004063f, -0.07936190f, 0.73148596f, 0.85237813f, -0.32907373f, -0.62337816f, -1.08104134f, 0.00963969f, 
    -0.26312748f, -0.15206562f, -0.39709887f, 0.13557591f, 0.39391074f, 0.00617992f, 0.15384263f, 0.19560604f, 
    -0.17912300f, -0.04530722f, 0.08679231f, -0.14096665f, 0.07492273f, 0.05756104f, -0.14498948f, 0.07747384f, 
    0.31466126f, 0.13869312f, 0.21662623f, -0.34007362f, -0.32284585f, -0.22247705f, -0.64215708f, -0.04802401f, 
    -0.11271106f, -0.49792612f, -0.24549773f, 0.40051195f, -0.20227650f, -0.14020440f, -0.42633873f, -0.15422463f, 
    -0.14644988f, -0.25244647f, -0.01451440f, 0.26284400f, 0.04583358f, 0.19109996f, 0.12002202f, 0.31317741f, 
    0.10879310f, 0.36732465f, 0.05982415f, -0.16304429f, -0.43593308f, -0.82358432f, -0.58536237f, -0.34423399f, 
    -0.20623241f, -0.71078849f, -0.25925943f, 0.20292546f, -0.18130863f, 0.18705943f, 0.39136297f, 0.14462546f, 
    0.41814595f, -0.16470969f, 0.31583235f, -0.07746339f, 0.14397888f, 0.09668826f, 0.21225704f, 0.00511386f, 
    -0.28786460f, -0.44855967f, -0.19698310f, -0.14210500f, 0.01374130f, -0.20863771f, -0.86847526f, -0.17516126f, 
    0.55058128f, -0.11560181f, -0.56231666f, 0.42476016f, -0.23161079f, -0.60811085f, -0.04960023f, 0.34327218f, 
    0.38023189f, 0.14887626f, -0.07762998f, 0.14838526f, -0.50135511f, -0.11379229f, 0.30661899f, -0.26563948f, 
    -0.43054673f, 0.30727139f, -0.31691834f, 0.11353842f, 0.06265467f, -0.06623022f, 0.83059812f, 0.64158535f, 
    -0.84956467f, -0.36079299f, 0.17883889f, -0.51700217f, 0.63966137f, 0.62999386f, -0.20606661f, 0.01556126f, 
    -0.29708192f, 0.11309762f, 0.38856393f, -0.10989998f, -0.33136877f, -0.11375881f, -0.04200585f, -0.01816164f, 
    0.03934043f, 0.01273125f, 0.15050052f, -0.11496469f, 0.13753490f, -0.12671927f, -0.04787435f, -0.94745314f, 
    0.88083482f, 0.52388668f, -0.86289257f, -0.04839253f, -0.31103030f, 0.30051282f, -0.08934294f, -0.22510652f, 
    -0.09064157f, -0.08320433f, 0.38156238f, 0.24370193f, 0.17281730f, -0.17779347f, -0.35331714f, -0.06989343f, 
    -0.13902508f, 0.03737066f, -0.03756033f, 0.05180220f, 0.22835301f, 0.18472393f, 0.22293037f, -0.08921116f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.05083251f, 0.15557870f, -0.01814757f, 0.01823153f, 0.24522179f, 0.03238127f, -0.01354562f, 0.26576385f, 
    0.13765103f, 0.22910319f, 0.32892153f, 0.25845808f, 0.11488063f, 0.24194381f, -0.10602612f, 0.15470025f, 
    0.04747975f, 0.11314867f, 0.10739825f, 0.08477098f, 0.10140217f, 0.03460456f, 0.22133340f, 0.15307844f, 
    0.15931241f, 0.27436942f, 0.10332853f, 0.11168242f, 0.22705401f, 0.00740658f, 0.01294932f, 0.21398579f, 
    -0.00318454f, 0.02961266f, 0.06491576f, 0.09211674f, 0.09285747f, 0.23806229f, 0.19494538f, 0.07045908f, 
    0.22551790f, 0.09869190f, 0.05475931f, 0.09405170f, 0.07492074f, -0.08850449f, 0.04111033f, 0.19812326f, 
    0.15118223f, 0.02853242f, 0.12565954f, 0.08845153f, 0.18777359f, 0.16810404f, 0.25208047f, 0.11698041f, 
    0.11346825f, 0.23178492f, 0.17572244f, 0.18226689f, 0.27783641f, 0.11071741f, 0.14612381f, 0.10840875f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.00397596f, -0.01963720f, -0.00885680f, 0.02304377f, -0.01432074f, -0.03326426f, -0.02595561f, 0.00575417f, 
    -0.02429344f, -0.01771941f, -0.00404992f, 0.02722905f, -0.00168227f, 0.00756051f, 0.00625291f, -0.01232823f, 
    0.01453178f, 0.02610235f, 0.01832314f, 0.01564255f, -0.01332546f, -0.02800793f, 0.00593562f, -0.03607441f, 
    -0.00133527f, -0.00172246f, -0.02919349f, -0.01819868f, -0.02279468f, 0.01038753f, -0.03379866f, 0.01846954f, 
    -0.03222953f, 0.03054100f, -0.02865263f, -0.00843598f, -0.04263072f, 0.00352514f, 0.00973942f, -0.01359397f, 
    0.01412798f, -0.00297674f, 0.01154933f, -0.01519791f, -0.01977527f, 0.02466373f, -0.01759962f, -0.01169582f, 
    -0.02078073f, -0.00899179f, 0.02903480f, -0.03435699f, 0.00461140f, -0.03207571f, 0.00590027f, 0.00432507f, 
    -0.01103096f, -0.00255322f, -0.01683446f, -0.02947776f, 0.03020836f, -0.03215924f, 0.00749753f, 0.01148785f, 
    -0.04171900f, 0.00937185f, 0.01557835f, 0.01860051f, -0.01150152f, 0.02528491f, 0.00025381f, -0.01714410f, 
    0.01746070f, -0.01748548f, 0.01857689f, -0.03855356f, 0.00621037f, 0.02134912f, -0.04470233f, -0.01036348f, 
    -0.00620086f, -0.00378710f, -0.00791024f, -0.03489172f, -0.03194807f, 0.04007195f, 0.03251755f, -0.01657164f, 
    0.01690139f, 0.02647326f, -0.01620392f, 0.02763534f, -0.01222099f, 0.01178093f, 0.03137233f, -0.00783536f, 
    -0.01503361f, 0.01506832f, 0.02502727f, -0.03121661f, 0.02846015f, -0.01727019f, -0.02034214f, 0.00436465f, 
    0.01799149f, -0.02737657f, -0.01152073f, -0.02590930f, -0.01136685f, -0.03118803f, -0.02236184f, 0.00037367f, 
    0.01735565f, -0.03137393f, -0.04059203f, 0.01777780f, -0.01521067f, -0.03309172f, -0.04211236f, -0.01928335f, 
    -0.00665845f, -0.02927921f, 0.02311749f, -0.00191567f, -0.02832403f, -0.04196755f, 0.02638832f, -0.03541016f, 
    0.01307571f, 0.01210586f, -0.03638638f, -0.01190549f, -0.04001967f, -0.01601773f, 0.01032041f, 0.00392383f, 
    0.01366365f, 0.01563835f, -0.02471682f, 0.00781334f, -0.03363400f, 0.02644685f, -0.00256213f, -0.02803577f, 
    0.02302136f, -0.00121035f, 0.00732516f, 0.02723990f, -0.04156950f, -0.00054381f, -0.00808085f, -0.03018554f, 
    0.00602167f, 0.03257642f, 0.01942288f, -0.01859996f, -0.01631572f, 0.01666310f, 0.00126287f, -0.00569111f, 
    -0.03815341f, -0.03293007f, 0.02432291f, -0.04265461f, -0.02155868f, 0.02660827f, 0.02157072f, 0.02689500f, 
    0.02264425f, 0.00538615f, -0.03121756f, 0.01835470f, 0.03594509f, 0.02698587f, -0.03282452f, 0.01917335f, 
    -0.01858702f, -0.01087672f, 0.00810490f, 0.01188801f, -0.01297203f, -0.02706801f, 0.02013367f, 0.02655931f, 
    -0.03836327f, 0.00614638f, 0.01967339f, 0.00015575f, 0.01276325f, 0.02915631f, -0.01618280f, -0.00692433f, 
    0.02052093f, 0.00939173f, 0.01127323f, 0.02320009f, -0.02138785f, 0.02207076f, -0.01859912f, -0.03873164f, 
    0.00366783f, -0.01752613f, 0.00243294f, -0.01523849f, -0.01512195f, -0.02637641f, 0.00434685f, -0.00128809f, 
    0.01757489f, -0.01141870f, 0.00286738f, 0.00528545f, -0.00284409f, -0.01000327f, -0.00812164f, -0.03839110f, 
    -0.01383194f, -0.02553549f, 0.00101272f, 0.02463950f, 0.01416938f, 0.01470904f, -0.03726190f, -0.00747538f, 
    0.03617780f, 0.02309948f, 0.02214075f, -0.00502248f, 0.00691902f, 0.00347847f, -0.01873316f, 0.00809795f, 
    0.02590261f, 0.02327007f, -0.00259127f, -0.00828912f, -0.02454844f, -0.03201875f, 0.01171038f, 0.01630825f, 
    -0.04260311f, -0.01010204f, -0.03380475f, -0.04523275f, 0.00894963f, -0.00804859f, -0.02776131f, 0.01106433f, 
    0.01118944f, -0.01285107f, -0.03928173f, 0.02065405f, -0.02144676f, 0.00254182f, -0.03781975f, -0.03775613f, 
    -0.01335017f, -0.03541346f, -0.01356943f, -0.03858944f, -0.03666858f, 0.03172375f, 0.01906682f, -0.02832287f, 
    -0.00712112f, 0.02282206f, 0.01797521f, 0.01409943f, -0.02863915f, 0.00319845f, -0.00397935f, 0.01644641f, 
    -0.00108789f, -0.03957661f, -0.03818476f, -0.02237131f, -0.01689683f, 0.00987756f, 0.01469374f, 0.00842798f, 
    -0.03540188f, 0.02173908f, -0.00282116f, -0.01385519f, -0.03100393f, -0.03102304f, 0.02837862f, -0.01567278f, 
    0.03611556f, -0.00833213f, -0.03169612f, -0.00568531f, -0.00999239f, 0.01560672f, -0.01252165f, 0.02775767f, 
    0.00514166f, 0.00039778f, -0.02405122f, 0.00440953f, -0.02814960f, -0.03063900f, -0.01085747f, -0.03867015f, 
    -0.02507920f, 0.03316465f, 0.01950776f, -0.02277102f, 0.00759680f, -0.00553127f, -0.03731640f, -0.00536917f, 
    0.00800157f, -0.02184448f, -0.03896048f, -0.02090347f, 0.00345251f, -0.01586107f, -0.03368035f, -0.02877931f, 
    -0.01521256f, 0.02908847f, -0.02028090f, -0.00409776f, 0.00176062f, 0.02268986f, -0.01627783f, -0.01303230f, 
    -0.00081848f, 0.02567658f, 0.02920226f, -0.01014906f, 0.02585612f, -0.01233296f, 0.00925818f, -0.00537147f, 
    -0.00910279f, -0.02720839f, 0.02034811f, 0.00257548f, -0.00825374f, -0.01518811f, -0.00164970f, -0.03039389f, 
    -0.03656251f, 0.02937041f, 0.00017468f, 0.00808507f, -0.00079712f, -0.03290679f, -0.01112475f, -0.00916248f, 
    0.02411971f, -0.02233442f, 0.00040506f, -0.03920250f, 0.01637865f, 0.00420689f, -0.00760803f, -0.03249900f, 
    -0.01673399f, 0.01200387f, -0.00791449f, -0.01620705f, 0.03137790f, 0.01497710f, 0.00020206f, -0.00188038f, 
    -0.03293610f, -0.01682071f, -0.00404498f, -0.00973574f, -0.01035572f, -0.00104665f, 0.02097719f, -0.00764681f, 
    0.02150220f, -0.03646552f, 0.00973682f, -0.00468393f, -0.03745880f, 0.03150954f, 0.02561017f, -0.02003201f, 
    -0.00260055f, 0.02089615f, -0.00813910f, 0.02042679f, 0.00525521f, -0.02668512f, -0.01461444f, 0.01255045f, 
    0.02272793f, -0.01811916f, -0.00102446f, 0.02649982f, 0.00219538f, -0.02854365f, -0.01514488f, 0.03194886f, 
    0.02260089f, -0.00487164f, -0.01985262f, -0.00412411f, 0.00744510f, 0.02046731f, 0.01028377f, -0.04510397f, 
    -0.00991994f, 0.00898077f, -0.03516063f, 0.01934679f, 0.00266705f, 0.00751913f, -0.02855982f, -0.02656359f, 
    -0.00694490f, 0.01123315f, 0.01263042f, -0.00564298f, -0.00251195f, -0.03099283f, -0.02187975f, -0.03085737f, 
    -0.02975828f, 0.01406690f, 0.02493602f, -0.02845308f, 0.01199765f, 0.02743125f, 0.02058945f, -0.00640474f, 
    -0.00514610f, 0.01514283f, -0.00330985f, 0.01726924f, -0.02138227f, 0.01195433f, -0.01227857f, -0.00067582f, 
    -0.03957260f, -0.01666111f, -0.00519629f, -0.01956514f, 0.00915142f, 0.00173703f, -0.00504377f, -0.01056852f, 
    0.00765960f, -0.00997988f, 0.00354262f, 0.00310255f, -0.01034626f, -0.03403285f, -0.03771991f, 0.02170386f, 
    -0.01645003f, 0.00818432f, -0.03765590f, 0.00208759f, -0.00515883f, 0.00616553f, -0.02904146f, 0.01294145f, 
    -0.01059219f, 0.02057760f, 0.00331207f, -0.00064121f, -0.04130400f, -0.03302986f, 0.01051818f, -0.03169480f, 
    0.01434826f, 0.00357017f, -0.02829050f, -0.01120301f, 0.01623037f, -0.00975887f, 0.00028306f, 0.03043393f, 
    -0.03984604f, -0.02407950f, -0.03842804f, -0.02252543f, 0.00616607f, 0.00683167f, 0.00399618f, -0.01376786f, 
    0.02668341f, 0.00368122f, 0.02053040f, -0.03916892f, -0.00778533f, -0.03436976f, -0.02109635f, 0.02718275f, 
    -0.04272067f, 0.02232930f, -0.02259593f, -0.00693177f, -0.00642291f, 0.03123186f, -0.02991760f, 0.01675414f, 
    0.00880113f, -0.00960312f, -0.01054455f, 0.01047391f, -0.02662476f, -0.03343798f, -0.01605718f, -0.03787062f, 
    0.02165933f, -0.01365288f, 0.02351115f, -0.01415150f, -0.02125088f, -0.03236202f, -0.03923784f, 0.02078203f, 
    0.02542854f, -0.03586526f, -0.03284751f, 0.03094729f, 0.01252563f, -0.03038620f, 0.02452498f, -0.03831435f, 
    0.00540543f, 0.00653752f, -0.01456155f, 0.02889421f, -0.00994800f, -0.04529059f, -0.01265073f, -0.03541542f, 
    -0.02576960f, -0.01140952f, -0.03337266f, -0.02877600f, -0.01778735f, 0.02548288f, 0.00465527f, 0.02817864f, 
    -0.03097554f, 0.00036726f, -0.02832759f, 0.00286884f, -0.02713605f, 0.00372156f, -0.00538824f, -0.03304640f, 
    -0.02378119f, 0.00356043f, 0.02417343f, 0.02518911f, -0.02525414f, -0.00810765f, 0.00933874f, 0.01869349f, 
    -0.00009635f, 0.01647890f, 0.00879080f, 0.02039684f, -0.00814964f, -0.03970245f, -0.01695057f, 0.00210937f, 
    -0.03564577f, -0.03763841f, -0.00092000f, 0.00895055f, -0.02682481f, 0.02043726f, -0.01895234f, 0.00563332f, 
    0.00184988f, -0.00871889f, 0.02244348f, 0.00300960f, -0.02230188f, -0.03931205f, -0.03668466f, 0.01802460f, 
    0.01285210f, 0.03267414f, -0.02524461f, -0.03614696f, 0.01684577f, 0.03279852f, -0.01680009f, -0.04235423f, 
    -0.04095956f, 0.00502571f, -0.02939447f, -0.03076963f, -0.00115519f, -0.00935714f, -0.04174684f, -0.00106284f, 
    0.01220296f, -0.00999922f, -0.00249321f, -0.02578404f, 0.02932071f, 0.00838444f, -0.00492737f, -0.00025114f, 
    -0.04142476f, 0.00585813f, 0.01169592f, 0.02316370f, -0.01080456f, 0.00569126f, 0.02698528f, -0.00598159f, 
    0.03000753f, -0.02488819f, -0.02461533f, 0.02745673f, 0.00703578f, -0.03572970f, 0.00826965f, -0.03967855f, 
    0.00901095f, 0.00840545f, -0.01297796f, -0.03503980f, -0.00797806f, -0.00055606f, 0.02201146f, -0.04694709f, 
    -0.00716233f, -0.03065126f, -0.03318306f, -0.03020363f, 0.01556568f, -0.01397771f, 0.02238261f, -0.00295665f, 
    -0.03515366f, 0.03081449f, 0.00857686f, 0.01481531f, 0.00155186f, 0.00704441f, -0.01187702f, -0.02455892f, 
    0.02006729f, 0.02061849f, -0.00083886f, 0.02243201f, -0.01721432f, 0.00821425f, -0.03102043f, -0.03503480f, 
    0.03017449f, 0.02320603f, -0.01315291f, 0.01323830f, -0.03657026f, -0.01242040f, -0.02676988f, -0.00459728f, 
    0.01871852f, 0.01571884f, 0.01105641f, -0.02956834f, -0.02827931f, 0.00968049f, -0.00081913f, -0.01828353f, 
    -0.01719365f, -0.03116748f, 0.00103871f, -0.00895402f, -0.02332003f, -0.00324453f, 0.01740767f, 0.01408009f, 
    -0.00408110f, 0.00171348f, -0.00504822f, -0.01290883f, -0.00286557f, -0.03034306f, 0.00071781f, -0.03196856f, 
    0.00404861f, -0.02485958f, 0.02631002f, -0.01477781f, -0.00695947f, 0.01719255f, -0.00503288f, -0.00761396f, 
    -0.03857752f, 0.00122866f, -0.01058652f, -0.03038142f, -0.00481767f, -0.01449274f, 0.00010506f, -0.04087000f, 
    -0.03667196f, 0.01621934f, -0.03450340f, 0.01091256f, 0.02304341f, -0.01413877f, -0.03460796f, -0.00827193f, 
    -0.01510170f, 0.02692758f, 0.00190662f, -0.04321342f, -0.00692817f, -0.02724096f, -0.03655893f, 0.02687289f, 
    0.02386299f, -0.00510193f, 0.02729439f, 0.01224043f, 0.02592618f, 0.00366368f, -0.00897910f, -0.01210585f, 
    -0.03248115f, -0.01570228f, 0.02098896f, 0.02635422f, -0.02730058f, -0.00863524f, 0.01222562f, -0.02482302f, 
    0.01365725f, 0.02007135f, 0.00049796f, -0.02321338f, 0.03227310f, 0.00934962f, 0.02316222f, 0.00872855f, 
    0.02094856f, -0.00342073f, 0.03059201f, 0.03228526f, 0.00283291f, 0.01380526f, -0.03580758f, 0.00853510f, 
    -0.01135755f, 0.00595178f, 0.00183043f, -0.02662425f, 0.01429356f, -0.00128517f, -0.03252518f, -0.03378511f, 
    0.03130934f, -0.00332090f, -0.02916726f, -0.03464802f, -0.03111742f, -0.01125528f, -0.02231573f, 0.00526455f, 
    -0.03132864f, -0.00097802f, -0.03070970f, -0.03145976f, 0.00356272f, -0.01460524f, -0.03230828f, -0.02612726f, 
    0.02551495f, 0.01961420f, -0.00965033f, -0.03545922f, 0.01713794f, -0.02903114f, 0.00788730f, -0.00184703f, 
    -0.01505573f, 0.02246812f, -0.00537667f, 0.01241634f, -0.02027369f, -0.02848713f, 0.00470478f, 0.02226046f, 
    0.00892344f, -0.00218848f, -0.02460919f, -0.02892451f, -0.01113502f, -0.03195637f, -0.02863617f, 0.02468593f, 
    -0.01394950f, 0.01350091f, -0.03084378f, 0.00737924f, 0.01391920f, 0.00398609f, -0.03625387f, -0.02578542f, 
    -0.03756364f, -0.01157026f, -0.02158075f, -0.00171628f, 0.02094043f, -0.03763001f, -0.00131806f, 0.02763185f, 
    0.01258160f, 0.00004621f, -0.01122318f, 0.03508820f, 0.01975135f, 0.00705542f, -0.04030707f, -0.03493180f, 
    -0.01989128f, -0.00731675f, -0.01391757f, 0.00197549f, -0.00602357f, -0.01678143f, 0.01879430f, -0.02261733f, 
    -0.02208084f, 0.00252583f, 0.00998798f, 0.00950390f, -0.02958987f, 0.01430430f, -0.01499297f, 0.00184242f, 
    -0.03752354f, -0.03998896f, -0.02798652f, -0.01848464f, 0.00260966f, -0.02655688f, 0.02207440f, -0.02015672f, 
    -0.01385820f, 0.03156772f, -0.00890612f, -0.00563429f, -0.03193131f, -0.00289930f, 0.01873186f, -0.02618971f, 
    -0.03320771f, 0.01598429f, -0.01890224f, 0.02632844f, 0.01573967f, 0.01746812f, -0.00522218f, 0.02002849f, 
    0.01081240f, 0.02755607f, -0.02437375f, -0.00735874f, -0.00835564f, 0.00925323f, -0.02553512f, 0.03444823f, 
    -0.00339156f, 0.02336152f, -0.01134950f, -0.01451177f, -0.02046212f, -0.02026512f, -0.04364020f, -0.00376769f, 
    -0.02753358f, 0.00920492f, -0.03015357f, -0.03471986f, 0.02024520f, -0.04240994f, 0.00278011f, -0.01804206f, 
    -0.03060037f, -0.01202333f, 0.00307750f, -0.00541722f, -0.03517711f, 0.00690159f, -0.03527099f, 0.02720806f, 
    0.00713277f, 0.03234052f, -0.00506160f, -0.01020937f, -0.00850151f, -0.03558530f, 0.02269673f, -0.02404842f, 
    0.03766288f, 0.02351216f, 0.00912123f, -0.00398513f, -0.01212195f, -0.01021832f, 0.00894582f, -0.01005766f, 
    -0.02820819f, -0.02974763f, 0.01138992f, -0.02370776f, -0.01476364f, 0.01405720f, 0.01255597f, -0.00156623f, 
    -0.00746682f, -0.03097103f, -0.03119392f, -0.02844165f, 0.02484272f, 0.00804439f, -0.02151730f, 0.01598414f, 
    -0.00220594f, -0.00156018f, -0.03779130f, -0.01009604f, -0.02680355f, -0.03706148f, -0.04271580f, 0.00443433f, 
    0.02469517f, -0.03977634f, 0.01885122f, -0.00961951f, -0.00058794f, 0.01391003f, -0.00914633f, -0.01926111f, 
    -0.02563899f, 0.00479941f, 0.01066361f, -0.01984231f, -0.01511503f, 0.02306406f, 0.01955597f, -0.01272163f, 
    0.00781870f, 0.02420183f, 0.01903208f, -0.00052141f, -0.01624546f, -0.00181316f, 0.01318603f, -0.02071125f, 
    -0.03709800f, 0.02650179f, -0.01147403f, 0.00638300f, 0.01046972f, 0.01528580f, -0.04323262f, -0.01167979f, 
    -0.01098505f, -0.03637442f, 0.01866773f, -0.02699941f, -0.02714909f, -0.01083236f, 0.01070290f, -0.00072347f, 
    -0.03191347f, -0.04192898f, -0.03745304f, -0.00969052f, -0.01933164f, 0.00766987f, -0.02985948f, 0.02635061f, 
    -0.01648246f, -0.00169300f, -0.02616921f, 0.00615335f, 0.00935095f, 0.02703970f, 0.00901526f, -0.02564567f, 
    0.01338326f, -0.01355699f, -0.02311633f, -0.00449553f, 0.01147382f, 0.00465785f, 0.00569953f, 0.02649728f, 
    -0.02766404f, -0.02166998f, -0.02112282f, 0.01810309f, -0.03442156f, -0.00420650f, -0.04126507f, -0.00716373f, 
    0.02510846f, -0.03170199f, 0.01576636f, 0.01415595f, 0.03050620f, 0.02110421f, 0.00615991f, 0.03251158f, 
    -0.02057376f, -0.00677728f, 0.00324054f, -0.02098999f, -0.03973311f, -0.01571096f, 0.03577664f, -0.00479474f, 
    0.02661887f, -0.02933238f, -0.03627777f, -0.01969265f, 0.00683293f, -0.00646259f, -0.00151884f, -0.00561097f, 
    -0.02514586f, -0.00902981f, -0.02909874f, -0.04245652f, 0.01079852f, -0.03809805f, 0.00076256f, -0.03506823f, 
    -0.00287970f, -0.01836822f, -0.01543445f, 0.02118402f, -0.02881340f, 0.02493617f, 0.01498495f, 0.00798342f, 
    0.00070977f, 0.02522841f, -0.01929827f, 0.01257443f, -0.01249181f, -0.00055827f, 0.01935195f, -0.01173013f, 
    0.00248162f, -0.03940601f, -0.02888912f, -0.02047152f, -0.01551703f, 0.00997987f, -0.01954922f, -0.03802538f, 
    -0.02469830f, -0.00528100f, 0.01539032f, -0.02552237f, -0.01162416f, -0.02071202f, -0.01110732f, 0.01248510f, 
    0.00257261f, -0.02207801f, 0.01753164f, 0.00115207f, -0.02800469f, -0.03234738f, 0.00598133f, -0.01010401f, 
    -0.03181491f, -0.00610355f, 0.00110570f, 0.01597773f, -0.03569498f, 0.01228568f, 0.02821877f, -0.03004972f, 
    0.01187261f, -0.04162460f, -0.01759007f, 0.00659890f, -0.00477882f, -0.00641717f, 0.00126122f, 0.00044619f, 
    -0.00770834f, 0.01835785f, -0.02351829f, 0.02875816f, -0.04117772f, 0.00594226f, 0.02457258f, -0.03513497f, 
    0.00977993f, -0.03989103f, -0.01430445f, 0.02067268f, -0.02539193f, 0.01392417f, -0.02365482f, -0.04298914f, 
    -0.02827153f, 0.00175648f, -0.00437310f, -0.01710238f, 0.01240987f, 0.00075368f, -0.03394900f, -0.01955971f, 
    -0.02600192f, -0.04056917f, 0.01567493f, -0.03374130f, -0.01777435f, -0.00429803f, -0.00001354f, 0.00329119f, 
    0.00759642f, -0.03721647f, 0.03096157f, -0.01399528f, 0.02427567f, 0.02291616f, -0.01528550f, 0.01138386f, 
    -0.03483059f, -0.04006669f, -0.02836174f, -0.00544619f, -0.04410134f, -0.02983730f, 0.00528840f, -0.03726073f, 
    0.02151186f, -0.01237760f, -0.03505104f, 0.00461784f, -0.01859156f, 0.01256868f, 0.02597263f, -0.01380350f, 
    -0.00779744f, 0.01040252f, 0.01598516f, -0.03740776f, 0.02988624f, -0.03959641f, 0.02578745f, -0.04020746f, 
    -0.02115512f, -0.01038057f, 0.00884178f, 0.02750541f, -0.01392435f, 0.02159799f, -0.01774191f, 0.02289511f, 
    -0.03149569f, -0.03162846f, -0.01433613f, -0.00480325f, -0.02819166f, -0.01627302f, -0.02004969f, 0.01962453f, 
    0.02704280f, 0.00248753f, 0.02412587f, -0.00494367f, 0.02245566f, -0.00452087f, -0.01985979f, 0.02654950f, 
    -0.02472660f, -0.00954168f, -0.02339070f, -0.02207149f, 0.01379210f, 0.01021963f, -0.03105371f, -0.03397857f, 
    0.02227709f, 0.01485515f, -0.01067692f, -0.04046998f, -0.01701021f, -0.03791022f, 0.02718021f, 0.01735673f, 
    0.01483401f, 0.01139745f, -0.01110697f, -0.01391866f, 0.02731051f, 0.02102021f, -0.00186106f, 0.01512484f, 
    -0.01430080f, -0.03150333f, -0.01422283f, 0.01327927f, -0.01280941f, 0.02060463f, -0.01897996f, -0.03844281f, 
    -0.03200154f, -0.01186634f, -0.00805733f, 0.01625312f, -0.01600462f, -0.02593353f, 0.03314462f, 0.01983022f, 
    -0.03581845f, -0.03423585f, 0.01998641f, 0.02136847f, -0.02553265f, -0.01932348f, -0.01783615f, 0.00444419f, 
    0.02395986f, -0.02262068f, -0.02153261f, 0.01833565f, -0.03719299f, 0.03290354f, -0.02592887f, 0.02311774f, 
    -0.01936209f, 0.03096107f, -0.00396241f, -0.03941766f, 0.00736506f, -0.01125080f, -0.00185196f, 0.01200208f, 
    0.01208883f, 0.00038786f, -0.03279385f, -0.03560896f, -0.02365114f, -0.02934029f, 0.02648887f, 0.02103509f, 
    -0.00828985f, -0.00167332f, -0.00199650f, -0.03797549f, -0.00489949f, -0.01217787f, -0.00357389f, 0.00643806f, 
    0.00658024f, 0.02065885f, 0.02441336f, 0.01046598f, -0.00595067f, -0.04120486f, 0.00017096f, 0.02895072f, 
    0.01713161f, 0.02685203f, -0.01028273f, 0.02107797f, -0.00824687f, -0.01811569f, 0.01856289f, -0.00679874f, 
    -0.01635465f, 0.02626045f, -0.03200462f, -0.03420637f, -0.02219335f, -0.03431564f, 0.03305368f, -0.00812352f, 
    -0.00224942f, -0.01648893f, -0.01255471f, -0.03694821f, -0.02038314f, -0.03513502f, 0.00265055f, 0.00832775f, 
    -0.02852037f, 0.00843672f, 0.00250077f, -0.01534040f, -0.03558426f, -0.03018644f, 0.00820982f, -0.00924745f, 
    -0.03357316f, -0.02730103f, 0.01391403f, 0.00949155f, 0.00907809f, -0.01229052f, 0.01154376f, 0.01550223f, 
    0.01763134f, -0.02585222f, 0.01645621f, -0.02648283f, -0.02538492f, -0.01742924f, 0.00424153f, 0.01974560f, 
    -0.02515071f, 0.01879828f, -0.00899680f, -0.02646869f, -0.02065599f, 0.00025465f, 0.00511976f, 0.00897641f, 
    0.00760565f, 0.00768828f, 0.01325281f, 0.01739102f, 0.02257665f, 0.00657932f, -0.01505195f, -0.01201299f, 
    0.00105260f, 0.02165178f, 0.02299673f, 0.01917415f, 0.00382854f, -0.03615791f, -0.01576745f, -0.02857145f, 
    0.00883200f, 0.01537518f, 0.02432822f, 0.02420017f, -0.04335226f, -0.01354566f, -0.03579467f, 0.02354044f, 
    -0.03290582f, -0.01377548f, 0.00462782f, 0.01343628f, 0.00925831f, 0.00409647f, 0.00597764f, -0.01896764f, 
    -0.01626115f, 0.02298545f, 0.01454389f, 0.00912179f, -0.03038486f, 0.01968122f, -0.02077026f, 0.00766430f, 
    0.00125265f, -0.03431418f, -0.03677653f, 0.02171586f, -0.02244800f, -0.02272496f, -0.00811293f, -0.02414504f, 
    -0.00479974f, -0.01195030f, -0.02607195f, 0.03271414f, 0.00042202f, -0.04238383f, -0.01163106f, -0.03254318f, 
    0.00968779f, -0.04160428f, 0.02414522f, -0.03168875f, -0.01218094f, 0.01655478f, 0.00663699f, -0.01600562f, 
    0.00308236f, -0.03791248f, -0.03831362f, 0.00736809f, -0.02614373f, 0.00564277f, 0.02681462f, 0.00743634f, 
    -0.01456706f, 0.00476392f, 0.01956105f, 0.02157699f, 0.00660552f, 0.02023762f, 0.01441938f, 0.00419005f, 
    0.02186191f, -0.03858601f, -0.02776597f, -0.00949652f, -0.02972237f, 0.00210942f, -0.03350217f, 0.02331591f, 
    0.00235184f, -0.04071270f, -0.00464920f, 0.00913300f, 0.00156562f, 0.01694973f, 0.02832237f, 0.02319427f, 
    -0.00501777f, -0.02712908f, 0.01847233f, 0.00776205f, 0.02373677f, 0.01653228f, 0.01810252f, 0.03702685f, 
    0.00075186f, -0.03222130f, -0.01608619f, -0.00944055f, -0.01993440f, -0.00199892f, 0.02250106f, 0.01160850f, 
    -0.01288408f, -0.01927758f, 0.00659580f, -0.03980244f, -0.01014991f, -0.01276052f, 0.01794375f, -0.02758168f, 
    -0.00845115f, -0.00257429f, 0.00542843f, 0.00752371f, -0.02806244f, -0.00862316f, 0.01830270f, -0.04293150f, 
    -0.01490407f, -0.03019281f, -0.01447132f, 0.02026547f, -0.00861954f, -0.02278103f, 0.02328080f, 0.00652323f, 
    0.00585564f, 0.02763812f, -0.01860065f, -0.02570468f, -0.00244848f, -0.02800792f, 0.02013111f, -0.02857937f, 
    -0.03361017f, -0.00837984f, -0.04350837f, 0.03027418f, -0.02511485f, -0.00921945f, -0.00738510f, 0.00381024f, 
    0.00909146f, -0.00833361f, -0.03588368f, -0.03061202f, 0.00377382f, -0.03677825f, -0.01262506f, 0.01902749f, 
    -0.00396981f, -0.03867384f, 0.00184050f, -0.01641492f, -0.03197280f, -0.00439651f, 0.02304501f, 0.01565219f, 
    0.00993217f, 0.01415498f, -0.02414123f, 0.01083810f, -0.04000075f, -0.01156919f, 0.02540725f, 0.00708109f, 
    0.00344383f, -0.01163843f, -0.00135116f, -0.00499196f, -0.00753295f, 0.02042631f, -0.03515128f, 0.03186886f, 
    0.00271320f, -0.01582335f, -0.01177948f, 0.01912738f, -0.01419255f, -0.00663871f, -0.03167582f, -0.00370575f, 
    -0.02812324f, 0.01266119f, -0.01799254f, -0.02409312f, -0.02774777f, 0.00087954f, 0.01315411f, 0.01211383f, 
    0.02230858f, 0.00468901f, 0.01265503f, -0.02216524f, 0.01653043f, -0.01283424f, 0.02081670f, 0.00939526f, 
    0.12131865f, 0.01509581f, 0.06453652f, 0.01177970f, -0.00811854f, -0.03629857f, 0.02919811f, 0.22780822f, 
    -0.03356583f, 0.11359903f, 0.07606968f, -0.06982086f, 0.13826314f, 0.11781277f, 0.19730856f, 0.02318659f, 
    -0.02578683f, -0.02228564f, -0.09645095f, 0.04626265f, 0.02403711f, 0.10979080f, 0.11419155f, -0.18449852f, 
    0.20131947f, 0.00223129f, 0.09043343f, 0.03806536f, 0.01571090f, 0.01968119f, 0.15352283f, 0.00309117f, 
    -0.03566656f, 0.05921759f, 0.15426205f, 0.03397056f, -0.26153293f, -0.17792447f, -0.07150377f, 0.18028875f, 
    0.05394041f, -0.02759741f, 0.09081042f, 0.14920509f, 0.03935653f, 0.01752956f, 0.00991987f, 0.05151751f, 
    -0.02252546f, 0.02929998f, 0.04146695f, 0.09112564f, -0.01386617f, -0.03110604f, 0.14252141f, 0.03613581f, 
    -0.03084802f, -0.05227919f, 0.06278117f, -0.11940859f, -0.20555003f, -0.05278793f, 0.15844622f, 0.02055568f, 
    -0.06217739f, -0.05384955f, -0.07008263f, -0.09049416f, -0.06538053f, 0.08801389f, -0.08128232f, 0.05864578f, 
    -0.09579008f, -0.07078165f, 0.08271921f, -0.24131061f, -0.06401094f, -0.08249811f, 0.06288679f, -0.00071047f, 
    -0.07291230f, 0.11633029f, -0.02003324f, -0.09797774f, 0.09956255f, 0.19307667f, 0.10423862f, -0.13541922f, 
    0.02213986f, -0.02943050f, -0.04667363f, 0.01163716f, -0.00450198f, 0.02828313f, 0.00734732f, 0.00733093f, 
    0.39492613f, -0.01336441f, 0.06920414f, 0.01783306f, -0.07485892f, 0.03481474f, -0.00213457f, 0.05533164f, 
    0.06017744f, 0.08225188f, 0.05706855f, -0.00299575f, -0.24143310f, 0.13468601f, 0.08731806f, 0.18158732f, 
    0.01235564f, 0.06206538f, 0.06881764f, -0.05480551f, -0.00140531f, 0.21482702f, 0.00898390f, -0.06075928f, 
    0.02168765f, 0.15430845f, 0.14070304f, 0.01787639f, 0.04631086f, 0.00962568f, 0.07335562f, 0.02433274f, 
    0.06240655f, -0.02774177f, -0.00729826f, -0.08905084f, -0.09571245f, -0.02288354f, 0.00592520f, -0.09645972f, 
    -0.01301828f, 0.12030834f, 0.03337329f, 0.03946218f, 0.05727441f, 0.00929473f, 0.06669950f, -0.03957900f, 
    -0.01365719f, -0.13379133f, -0.05412905f, 0.24607477f, 0.08109839f, -0.06361111f, 0.01950603f, 0.04024817f, 
    -0.12585230f, 0.05028012f, 0.04987029f, 0.04636640f, -0.24636829f, 0.01752413f, 0.16381857f, 0.05991660f, 
    0.01118839f, 0.04331347f, 0.02416839f, 0.03865541f, -0.07876641f, -0.04927684f, 0.05463829f, -0.03967077f, 
    0.12084432f, 0.11811758f, -0.11654966f, -0.03173763f, 0.04885947f, 0.11315516f, -0.00087328f, -0.05502005f, 
    -0.06608267f, -0.01739143f, -0.04612619f, -0.16253173f, -0.03514272f, -0.04490138f, -0.09869730f, 0.02701697f, 
    0.02830596f, -0.02597714f, -0.03412071f, 0.13863197f, 0.09853952f, 0.03138877f, -0.06973033f, -0.03501067f, 
    -0.11151034f, -0.09050467f, 0.09957260f, -0.30885524f, 0.09105005f, -0.00615944f, -0.03131620f, -0.08435381f, 
    -0.01920891f, -0.02554452f, 0.03905797f, -0.00551569f, -0.18627167f, 0.21640059f, 0.24361826f, -0.18055597f, 
    -0.03114754f, 0.10746585f, 0.02554058f, 0.02467949f, -0.01548717f, 0.02513635f, 0.02892608f, -0.11417305f, 
    0.06035395f, -0.07285351f, 0.03537498f, -0.10700994f, -0.01380139f, 0.13421601f, 0.01479915f, 0.03095041f, 
    0.11510456f, -0.08009648f, -0.06671854f, 0.07229599f, 0.12964272f, 0.06463206f, -0.03391836f, -0.02791725f, 
    -0.06340472f, -0.03923874f, -0.03679472f, -0.06120452f, 0.09176853f, 0.14528316f, 0.00709924f, 0.11906920f, 
    0.21341199f, -0.16563229f, -0.10766796f, -0.05314035f, 0.03118111f, 0.08890128f, 0.01110804f, -0.10270677f, 
    0.04191306f, -0.00210847f, -0.06130366f, -0.07550638f, -0.04953792f, -0.02083143f, -0.24512966f, -0.31762204f, 
    -0.10601309f, 0.04351420f, -0.06465849f, -0.01829735f, 0.06110235f, -0.00441854f, 0.05548275f, 0.07069606f, 
    -0.19922136f, 0.06375611f, -0.00867967f, 0.00902328f, 0.00712943f, -0.07206772f, -0.03621846f, -0.04568639f, 
    0.04557799f, 0.04129399f, 0.04247297f, 0.06056501f, -0.29848802f, -0.06537980f, -0.06996135f, -0.08074461f, 
    0.00081751f, 0.01815152f, 0.09020201f, 0.00144175f, 0.00903117f, 0.06514735f, -0.02831903f, 0.04789818f, 
    0.20763853f, 0.18045837f, 0.21657152f, 0.16507971f, -0.00516036f, 0.06601983f, -0.04320522f, 0.04374916f, 
    0.07418047f, 0.05040804f, -0.02900913f, -0.01869171f, -0.06996921f, 0.02162849f, -0.04406998f, -0.30235741f, 
    -0.06648989f, -0.05028309f, -0.07139477f, -0.03520143f, 0.03231984f, -0.05541409f, 0.03091323f, 0.07414065f, 
    0.02683040f, 0.13844395f, 0.00889401f, 0.19758689f, -0.04616069f, -0.01282138f, 0.08481281f, 0.04224927f, 
    0.03900209f, -0.03283932f, 0.11854397f, -0.04943619f, 0.17405677f, 0.02454673f, 0.05379371f, 0.17326933f, 
    0.02351731f, -0.08641830f, 0.04730908f, 0.07354812f, 0.00662237f, 0.03917146f, 0.10029177f, 0.09313707f, 
    -0.04207401f, 0.35831374f, 0.16716486f, -0.07873960f, 0.09425529f, 0.09955266f, 0.07537331f, 0.07414310f, 
    0.01852982f, -0.01973703f, -0.04591067f, 0.03096025f, -0.05648327f, -0.12944968f, 0.10658987f, -0.23759726f, 
    -0.03586269f, 0.01755158f, 0.09702231f, -0.09453511f, -0.00670834f, -0.00959380f, -0.01708360f, 0.04437489f, 
    0.32772958f, -0.31522736f, -0.25722775f, 0.05504011f, -0.00372065f, -0.09280225f, 0.11582404f, -0.06221311f, 
    -0.05283383f, 0.04936586f, -0.01829228f, 0.09277558f, 0.15134378f, 0.09254198f, 0.11002381f, -0.10460921f, 
    -0.05184530f, -0.01625821f, -0.02336583f, 0.02126542f, 0.02764372f, 0.09062240f, 0.09729629f, 0.04586906f, 
    -0.05270827f, 0.04147694f, 0.08218264f, -0.03798977f, 0.01486068f, 0.06971630f, 0.03132826f, 0.08176505f, 
    0.06304372f, -0.08477024f, -0.04410080f, -0.00053728f, 0.41682869f, -0.18729261f, -0.01108452f, -0.02848512f, 
    -0.08341885f, -0.06247937f, 0.03341544f, -0.04857032f, 0.01334468f, -0.00495928f, 0.12200771f, -0.01562866f, 
    -0.11970628f, 0.25595656f, 0.24241628f, 0.00033752f, 0.10931861f, 0.00546154f, -0.06604750f, 0.02218142f, 
    0.06149813f, -0.02155569f, -0.01243381f, 0.03000037f, -0.08972073f, -0.09338087f, 0.20376390f, 0.14286277f, 
    0.02242661f, 0.02645296f, 0.03445401f, -0.08711850f, 0.00602112f, 0.06425041f, 0.05921808f, -0.05511511f, 
    -0.00212805f, -0.11961821f, -0.00148722f, -0.01660531f, 0.02368568f, 0.09098458f, 0.07573736f, -0.06274170f, 
    0.07831313f, 0.04385014f, 0.00225693f, 0.09224965f, 0.30161718f, -0.22752924f, 0.09117392f, 0.14719093f, 
    -0.15758909f, 0.02713537f, 0.06293780f, 0.00824800f, -0.03024695f, 0.04031434f, 0.01113567f, -0.04756900f, 
    -0.08121914f, -0.05045191f, -0.04872660f, -0.21646249f, 0.07696124f, -0.06924073f, 0.06259540f, 0.03951278f, 
    0.04668967f, 0.02465058f, 0.01560654f, -0.00386309f, -0.03462359f, -0.04049490f, 0.03729575f, 0.04695437f, 
    0.02436788f, 0.02688465f, 0.05263959f, 0.06268364f, -0.00446162f, -0.01964746f, -0.04660238f, -0.07359502f, 
    0.16423039f, 0.02718738f, 0.03929865f, 0.10320421f, -0.02729904f, -0.00505219f, 0.01303073f, 0.01057976f, 
    -0.03821381f, 0.08580341f, -0.02392645f, 0.12759301f, 0.02949673f, -0.36253899f, -0.06746444f, 0.06956917f, 
    -0.04227506f, 0.07426188f, 0.04730842f, 0.09561189f, -0.00469005f, -0.11221821f, -0.07798277f, 0.01101761f, 
    0.23245686f, 0.09875391f, 0.11082767f, 0.25827917f, 0.00671125f, 0.02540296f, 0.02438664f, -0.10896156f, 
    -0.03711062f, -0.02166841f, 0.00176836f, 0.09701818f, -0.06877714f, -0.10417490f, 0.09156743f, -0.01011336f, 
    0.08082455f, -0.04569737f, -0.03917769f, -0.06907174f, -0.05344266f, -0.03997136f, -0.11665445f, 0.08726021f, 
    -0.32917282f, 0.08989567f, 0.02256657f, -0.06102450f, 0.07264818f, 0.07291505f, -0.01175144f, 0.00448765f, 
    0.08275582f, 0.00370153f, -0.00464852f, 0.06595553f, 0.12859687f, -0.04202474f, 0.04227375f, 0.08320335f, 
    -0.14844856f, 0.01710369f, 0.05703440f, -0.09072084f, -0.01005885f, 0.18077706f, 0.11893535f, 0.04574386f, 
    0.25654244f, 0.15856753f, 0.21098043f, 0.25857654f, 0.03181352f, 0.02099638f, -0.03010218f, -0.00714171f, 
    -0.00252656f, 0.06489844f, 0.02346324f, 0.08680209f, -0.12528071f, -0.07111109f, -0.12112311f, -0.27880350f, 
    0.03426300f, 0.07545903f, -0.10481819f, 0.10002804f, 0.08246680f, 0.10135280f, 0.02277898f, -0.00454186f, 
    0.24255484f, -0.02657450f, 0.03869299f, 0.02795995f, 0.06142344f, 0.04399526f, -0.07136106f, 0.07215080f, 
    0.01934725f, 0.10619584f, 0.06106744f, -0.10183305f, 0.48533002f, -0.04459635f, 0.00964336f, 0.34464020f, 
    -0.02126253f, -0.02068785f, 0.07692604f, -0.12540014f, 0.05561649f, -0.05401564f, 0.03317748f, 0.01318193f, 
    -0.30847189f, -0.11704055f, -0.01630427f, -0.17139958f, -0.03739051f, 0.04256735f, 0.00104266f, -0.04288206f, 
    -0.02327652f, 0.02642964f, 0.05836635f, -0.07639222f, 0.18172714f, -0.01382231f, -0.05596224f, -0.05418738f, 
    0.01960433f, -0.04631928f, 0.04285490f, 0.04748096f, -0.01441752f, -0.00951111f, 0.05341732f, 0.07886461f, 
    -0.16296490f, -0.08924921f, 0.04503063f, -0.01371941f, 0.03953239f, 0.01531208f, 0.00370644f, 0.08282370f, 
    -0.04924076f, -0.07879297f, -0.07266989f, 0.01665160f, 0.20441292f, -0.08554751f, -0.22111411f, -0.11333048f, 
    0.13770133f, -0.02818486f, 0.03058145f, 0.07323658f, -0.10502209f, 0.06011370f, -0.00621236f, -0.11374987f, 
    -0.23549461f, -0.13989899f, 0.02240952f, -0.12326863f, 0.00532820f, 0.14159232f, -0.08908259f, 0.01850343f, 
    -0.06956459f, 0.02893601f, 0.06176160f, 0.03138346f, -0.35113680f, 0.14029594f, 0.22393310f, -0.18994622f, 
    -0.00887396f, 0.00622420f, 0.09540725f, 0.02777865f, 0.09456098f, -0.02640651f, 0.07932533f, 0.01516472f, 
    0.13933438f, 0.00188412f, 0.10152442f, 0.02665736f, -0.03418770f, 0.00929942f, 0.02834860f, 0.03336550f, 
    -0.05083458f, 0.13909046f, 0.02500559f, 0.05406529f, 0.44839105f, -0.13165721f, -0.12322938f, -0.02927388f, 
    0.02016793f, 0.09846935f, 0.05550722f, 0.08307763f, -0.00060982f, 0.03306559f, 0.05977963f, 0.02422596f, 
    -0.21310444f, 0.20830572f, 0.02556708f, 0.07987814f, -0.00491200f, 0.07482524f, 0.12231724f, -0.02747451f, 
    -0.10791823f, -0.04388294f, -0.02292227f, 0.03625331f, -0.30991179f, -0.14308481f, -0.09569398f, -0.05644676f, 
    -0.02516811f, 0.01346172f, -0.03204818f, 0.04517025f, -0.07534655f, 0.03181429f, 0.06076592f, -0.00411421f, 
    -0.05440909f, -0.20352635f, -0.08059095f, -0.07065085f, 0.00253260f, 0.07226817f, -0.06586674f, 0.16450685f, 
    0.00988545f, -0.04094272f, -0.01622720f, -0.01866009f, 0.29725194f, -0.16785181f, -0.01765416f, -0.14443256f, 
    -0.03701313f, 0.05535534f, 0.05980180f, 0.13885833f, 0.01567348f, 0.08017001f, 0.00844005f, -0.04016451f, 
    -0.09084074f, -0.15289846f, -0.10599314f, 0.02178795f, -0.04416309f, -0.00668352f, 0.00511010f, -0.03666819f, 
    0.03272810f, 0.03654321f, 0.10069336f, -0.03586487f, 0.21322092f, -0.07126401f, -0.19567427f, -0.24111533f, 
    0.01650867f, 0.03176126f, 0.01316923f, -0.11662529f, -0.02806226f, 0.03267556f, -0.04852157f, 0.06889471f, 
    0.28221881f, 0.00151994f, 0.03570968f, -0.11623236f, 0.00719961f, -0.00531463f, 0.02324647f, -0.11717790f, 
    0.00678956f, 0.07189880f, -0.14507517f, 0.15004322f, 0.20222300f, 0.02821159f, -0.02873003f, -0.01251925f, 
    0.04131933f, 0.18437466f, 0.05524379f, -0.01458706f, 0.06298219f, -0.14285912f, -0.15273575f, -0.01164363f, 
    0.09605164f, -0.03933614f, 0.08437318f, 0.05563765f, -0.04551395f, -0.04578742f, 0.04875013f, 0.10921581f, 
    -0.00628145f, 0.02953506f, 0.05155830f, -0.01817739f, 0.27066678f, -0.05704991f, -0.28839087f, -0.07584735f, 
    -0.05705447f, -0.00935461f, 0.05634521f, 0.03243356f, -0.02301288f, 0.16624521f, -0.03100941f, 0.01663174f, 
    0.16328344f, -0.26513660f, 0.21929589f, -0.01679293f, 0.01651951f, 0.05090460f, -0.03247255f, 0.08246339f, 
    -0.18500428f, -0.01162522f, -0.07555938f, 0.02672026f, -0.07094690f, 0.01815919f, 0.00852168f, -0.10740420f, 
    0.07760829f, 0.12862787f, -0.01998314f, 0.03040238f, 0.01322501f, -0.01108383f, -0.06859573f, 0.03561370f, 
    -0.03245246f, 0.16226164f, -0.06268165f, -0.02809206f, -0.06456881f, 0.08059730f, -0.03573572f, 0.00798731f, 
    0.00270053f, -0.08471407f, -0.08418254f, 0.11630600f, 0.31435329f, 0.08395894f, 0.06270970f, 0.23000088f, 
    -0.01629979f, 0.06142922f, 0.02064324f, -0.03170183f, -0.08102976f, -0.07705652f, 0.02122614f, -0.04817224f, 
    -0.23242164f, 0.10357724f, 0.15414231f, -0.02892213f, 0.14051165f, 0.18797004f, 0.01496542f, 0.08999114f, 
    0.04818501f, -0.02549472f, -0.01951815f, 0.00779329f, 0.14303058f, 0.09570543f, -0.05549281f, -0.11442442f, 
    -0.01181082f, -0.06360485f, -0.00430847f, 0.11642359f, -0.01729720f, -0.07854044f, 0.13576542f, -0.07677600f, 
    0.14502865f, -0.05585109f, -0.08798438f, 0.06413200f, 0.01507048f, -0.04162684f, -0.01530634f, 0.03888594f, 
    -0.11134844f, -0.06349403f, 0.06642912f, 0.04085384f, 0.22578470f, -0.01030178f, 0.14829919f, -0.11458033f, 
    0.01911230f, -0.12178051f, 0.06969652f, -0.02066940f, -0.10442991f, -0.02812663f, 0.00630358f, -0.05517185f, 
    0.05587151f, -0.04857171f, -0.06068631f, -0.00752523f, -0.13087374f, 0.02404811f, -0.00276277f, 0.09741734f, 
    0.07955317f, 0.00582355f, 0.06353367f, 0.01086820f, 0.44945636f, 0.01135806f, -0.04814226f, -0.05019262f, 
    -0.03766948f, -0.13696967f, 0.11318698f, 0.04097609f, -0.07736866f, 0.12989719f, 0.05690325f, -0.00283656f, 
    -0.04771130f, 0.06693704f, 0.01510939f, -0.17445441f, -0.06403766f, -0.17618616f, 0.12063170f, 0.01023005f, 
    0.08912592f, -0.03539400f, 0.01389561f, -0.07864841f, -0.05299624f, 0.00909406f, -0.16037796f, -0.10405943f, 
    0.10523874f, 0.06442991f, 0.02786086f, -0.04554182f, -0.07708578f, -0.05001707f, -0.10353863f, 0.07513680f, 
    -0.02896318f, -0.03118999f, 0.01047719f, 0.05405115f, -0.06181733f, -0.04162275f, -0.06549897f, 0.10587125f, 
    0.01691362f, 0.06930666f, -0.02663677f, -0.07460716f, 0.11576256f, 0.03463436f, 0.04115346f, 0.25305793f, 
    0.10435877f, 0.02358257f, -0.00723828f, -0.04393903f, 0.03658292f, -0.05984240f, 0.04475699f, 0.07470068f, 
    0.11675597f, -0.01237015f, 0.05387128f, 0.02254007f, 0.01964867f, 0.02980653f, 0.06621618f, 0.02957418f, 
    -0.06559072f, 0.10338554f, 0.11357200f, -0.03631659f, 0.28383952f, -0.03324522f, -0.16814040f, -0.17996138f, 
    -0.09086161f, 0.04331325f, 0.00667739f, 0.05809919f, -0.08177000f, 0.14429058f, -0.02411254f, 0.06939737f, 
    0.02501044f, 0.09963307f, -0.06847596f, 0.17058060f, -0.07848635f, 0.04573814f, -0.03119852f, -0.00058685f, 
    -0.04858622f, -0.00926836f, -0.09541419f, -0.15288445f, -0.06010754f, -0.02958327f, 0.14454907f, 0.07743774f, 
    0.07664905f, -0.02171952f, 0.07213259f, -0.01144499f, 0.00565612f, 0.00285155f, -0.02228492f, -0.18571335f, 
    0.14521183f, -0.16328645f, -0.14533114f, -0.16050081f, 0.01228251f, -0.05923903f, 0.02435652f, 0.05935165f, 
    0.01140535f, -0.01432441f, -0.10953230f, 0.02386276f, -0.09596910f, -0.08332036f, -0.05661003f, 0.12236093f, 
    -0.07512889f, -0.01122882f, -0.03554710f, 0.05016996f, 0.00549291f, 0.09990955f, 0.05319159f, 0.05510230f, 
    0.07902816f, 0.04260752f, -0.08298369f, 0.03019224f, 0.10256147f, 0.03367416f, 0.09944373f, 0.13604605f, 
    0.08427680f, 0.11618595f, 0.03009756f, 0.15660578f, 0.07566312f, -0.05499568f, 0.10449982f, -0.09295416f, 
    0.11727601f, -0.02018587f, 0.03658358f, 0.02233131f, -0.05107520f, 0.05525647f, -0.08500949f, 0.07266819f, 
    -0.07342093f, 0.02114738f, 0.27815524f, -0.15201303f, 0.04172949f, -0.06007610f, -0.00797104f, -0.02440415f, 
    -0.03129399f, -0.07960691f, -0.00082686f, 0.06084082f, -0.18127145f, -0.14192370f, -0.06213115f, -0.04122274f, 
    0.00161451f, 0.00548993f, 0.07676734f, 0.04126658f, -0.01513574f, 0.16753416f, 0.11451569f, -0.02332171f, 
    0.37082234f, 0.02281069f, 0.22445938f, 0.18837537f, -0.01306493f, 0.04086581f, 0.00431585f, -0.02372926f, 
    0.01774673f, 0.01323127f, 0.07588401f, -0.04267632f, -0.21562169f, 0.00194635f, -0.07308394f, 0.23108578f, 
    0.03305928f, 0.01209038f, 0.01085474f, 0.02417602f, 0.09225037f, -0.00801726f, 0.05804953f, -0.08096789f, 
    -0.37470713f, 0.28011119f, -0.17149535f, -0.05934342f, -0.03969392f, -0.10782596f, -0.08624738f, 0.04303472f, 
    -0.00429678f, -0.02814902f, 0.05647821f, -0.01394975f, -0.20970881f, -0.26346534f, 0.03279123f, 0.14073317f, 
    0.10480357f, -0.09980414f, -0.00333215f, 0.08254089f, -0.00876519f, -0.01540312f, -0.01934658f, 0.13364121f, 
    0.07045661f, -0.10325599f, 0.00730251f, 0.06411310f, 0.03417940f, -0.02202436f, -0.04636291f, 0.11279635f, 
    -0.18969354f, -0.04739227f, 0.11908864f, -0.03527306f, 0.16547701f, 0.05805258f, 0.04111991f, 0.00997803f, 
    0.11286695f, 0.07420933f, -0.09355801f, -0.04671419f, -0.02279712f, -0.13603266f, 0.09603169f, 0.04812717f, 
    0.20136863f, -0.04349276f, -0.04138663f, 0.01464771f, 0.08353541f, 0.04443152f, 0.07490137f, 0.03429613f, 
    -0.00539237f, 0.02879740f, 0.01042379f, -0.06597840f, 0.38677961f, 0.07177311f, -0.22990356f, -0.00715729f, 
    -0.03376148f, 0.17100084f, 0.08907181f, -0.01987853f, -0.02267406f, -0.14654431f, 0.02600987f, -0.01918633f, 
    0.08890879f, -0.06506671f, -0.00961522f, 0.05492326f, -0.01514269f, -0.13049261f, 0.07694474f, 0.04933474f, 
    0.02704419f, 0.07117590f, -0.04877370f, -0.06173105f, -0.05978610f, 0.10051223f, -0.03203915f, -0.13870782f, 
    0.00120324f, 0.08667996f, -0.01827407f, 0.00913242f, -0.01669687f, 0.00445330f, 0.00219426f, 0.03415316f, 
    0.01936823f, -0.02879751f, -0.14137591f, -0.03049610f, -0.09504672f, 0.13745160f, -0.06289520f, -0.03459380f, 
    -0.08703842f, -0.10085437f, 0.03333930f, -0.02295222f, -0.00206661f, 0.07170293f, -0.06430966f, 0.04459333f, 
    0.07657343f, -0.01828982f, -0.09826701f, -0.03296351f, 0.07144862f, -0.06235436f, -0.08617357f, 0.10575370f, 
    -0.02349242f, -0.01547747f, 0.05407948f, 0.15141088f, 0.19151652f, -0.03231395f, 0.11341028f, 0.10278679f, 
    0.10020182f, -0.00018420f, 0.08957539f, -0.00194711f, 0.05524750f, 0.20667499f, -0.14225028f, 0.05025304f, 
    -0.03302433f, -0.05284305f, -0.10928224f, -0.00388347f, 0.01143265f, 0.07060392f, -0.00998138f, 0.00699118f, 
    0.03199781f, 0.07750040f, 0.00067017f, -0.05828988f, 0.03450496f, 0.05019629f, 0.08495516f, 0.21883497f, 
    -0.00088506f, 0.10742661f, 0.14151824f, 0.05235281f, -0.04007686f, -0.06577068f, -0.23222055f, -0.01391666f, 
    -0.00853104f, 0.12388930f, -0.03714827f, 0.02003053f, 0.12162230f, 0.11663271f, 0.07540673f, 0.04817735f, 
    -0.08452369f, 0.03413592f, -0.03233039f, 0.10756069f, -0.01621288f, -0.00719947f, -0.04309145f, 0.03563774f, 
    -0.01554453f, -0.12160572f, 0.04926822f, -0.10684221f, -0.21763518f, 0.09787748f, 0.04840959f, 0.04861734f, 
    0.19889061f, -0.05580993f, -0.06501464f, 0.14542577f, -0.03283971f, 0.05595813f, -0.01939230f, -0.00403376f, 
    0.06765356f, -0.03153558f, -0.15653880f, -0.00154017f, 0.02530318f, 0.05523318f, 0.08172265f, 0.07425742f, 
    0.00214354f, 0.05184579f, 0.02564734f, 0.14930859f, 0.00244521f, 0.01071940f, 0.08904727f, 0.12611741f, 
    -0.06456263f, -0.14841563f, 0.00940315f, -0.00341292f, -0.10357361f, -0.02512180f, -0.01690228f, 0.04475104f, 
    0.05565941f, 0.21902968f, -0.07080159f, -0.17385346f, -0.19465536f, 0.05596812f, 0.06273804f, 0.00762788f, 
    0.07280520f, -0.09829929f, -0.04677951f, 0.05348060f, -0.02450604f, 0.11995591f, -0.15783702f, -0.02755798f, 
    0.05193213f, 0.12613443f, 0.13555826f, 0.14352477f, -0.03245866f, 0.05977036f, 0.08965480f, -0.04953351f, 
    -0.04000805f, -0.04655527f, -0.11464804f, 0.11715948f, 0.08104584f, -0.07305495f, 0.06684259f, 0.06063286f, 
    -0.06318969f, 0.06291252f, 0.10455091f, 0.10283249f, -0.31581357f, -0.02707151f, -0.03031870f, 0.11382539f, 
    -0.01216891f, -0.02107246f, 0.04146216f, -0.03941502f, 0.06908717f, 0.03708200f, 0.09552698f, 0.07368059f, 
    0.11363856f, 0.00945671f, -0.03200924f, 0.11945704f, -0.02808686f, -0.05508682f, -0.02710583f, 0.01171934f, 
    0.05905234f, -0.05347570f, -0.01879710f, 0.04818693f, -0.00449684f, 0.18474959f, -0.02729345f, -0.10327309f, 
    -0.21877548f, 0.07784849f, 0.06283084f, -0.01291595f, 0.08051436f, 0.06031848f, -0.07848555f, 0.10994858f, 
    0.30713391f, -0.05592602f, -0.02866295f, 0.13166371f, -0.11908799f, -0.19763011f, 0.06248377f, 0.17785725f, 
    0.05914672f, 0.02477463f, 0.03462026f, -0.01373489f, 0.38654119f, -0.17560244f, 0.11369172f, 0.16585837f, 
    -0.03803091f, -0.08457267f, -0.01446108f, -0.04173930f, -0.07792875f, 0.04862655f, -0.02215432f, -0.07648087f, 
    0.14763290f, -0.01313169f, -0.08662581f, 0.04179944f, -0.02771831f, -0.01398218f, 0.00360623f, 0.05945598f, 
    0.02768580f, -0.03900702f, -0.04496280f, 0.06554594f, -0.13263531f, 0.05523518f, -0.04827889f, 0.16113070f, 
    -0.06378620f, 0.00234843f, -0.05139581f, -0.06560571f, -0.02139396f, -0.09417179f, 0.01974336f, -0.11567903f, 
    0.26135969f, -0.27145225f, -0.05509008f, -0.19760989f, -0.04705579f, 0.01572147f, 0.08134820f, 0.00341539f, 
    -0.09840789f, 0.13339850f, 0.08810858f, -0.11654533f, 0.11508774f, -0.14640360f, 0.08460606f, 0.09857040f, 
    -0.04773795f, 0.00443094f, 0.00371630f, 0.01537693f, 0.04744741f, 0.01060738f, 0.00067768f, 0.17221512f, 
    0.31804869f, -0.01541305f, -0.05901706f, 0.16079499f, -0.05031062f, -0.03675115f, 0.02321099f, -0.00241644f, 
    -0.00717619f, 0.06497034f, -0.00016011f, -0.06611685f, -0.10581578f, -0.08829258f, -0.08535498f, 0.06699678f, 
    -0.01759923f, 0.07841512f, -0.16288215f, -0.02494224f, 0.09277201f, -0.09180969f, 0.00387808f, 0.01295121f, 
    0.30645943f, 0.25296763f, 0.08609211f, -0.16398890f, 0.10791477f, -0.10471563f, 0.17446470f, -0.00853156f, 
    -0.03779318f, -0.09564900f, -0.04140795f, 0.03598566f, -0.04495342f, 0.27584857f, -0.04245170f, -0.09126142f, 
    -0.13197164f, 0.00553892f, 0.09328786f, 0.11352532f, 0.00848058f, 0.02054521f, 0.07335906f, -0.01219630f, 
    -0.02767543f, -0.04202542f, -0.00932237f, -0.00317937f, 0.01718107f, 0.02717905f, -0.03765513f, -0.01980824f, 
    -0.03496138f, -0.01906429f, -0.02251127f, -0.00191288f, -0.03950689f, -0.03287634f, -0.01051756f, -0.00422105f, 
    0.01009759f, 0.00214885f, -0.02114472f, -0.01694782f, -0.00993463f, -0.02784659f, -0.00318019f, 0.00379902f, 
    -0.01189258f, 0.00360934f, 0.00533443f, -0.00678533f, -0.03647084f, -0.01526550f, -0.03738581f, 0.01931254f, 
    -0.04122999f, 0.01150567f, 0.02088259f, -0.00795865f, 0.00079978f, -0.01200177f, 0.01645146f, 0.01335226f, 
    0.02554029f, -0.00103502f, 0.01893594f, -0.00396548f, -0.00307394f, -0.03457600f, -0.00494091f, 0.01562523f, 
    -0.03563422f, -0.03893716f, 0.01959003f, -0.01095176f, 0.02492603f, -0.02202963f, 0.00296992f, 0.00561891f, 
    0.00531214f, 0.01352613f, 0.00120690f, -0.00677215f, 0.02274931f, -0.01930877f, 0.02281901f, -0.01048916f, 
    -0.00562223f, -0.01288687f, 0.00293618f, 0.01079335f, 0.01896879f, 0.02090702f, -0.01604318f, 0.00340226f, 
    -0.00040014f, -0.02680276f, -0.04236060f, -0.02334499f, -0.01567014f, -0.03377714f, -0.03178935f, -0.00137987f, 
    0.00902665f, 0.00679180f, 0.01074201f, 0.00924005f, -0.03764173f, -0.00447380f, 0.03859615f, 0.02319244f, 
    0.02585387f, -0.02964366f, -0.02531981f, -0.04162847f, 0.02421948f, -0.00080888f, 0.00155369f, -0.02097417f, 
    0.01393042f, 0.00557294f, -0.01905270f, 0.01538708f, 0.00554582f, -0.03939277f, -0.02205965f, -0.01962504f, 
    0.02822166f, 0.01035948f, -0.02090709f, -0.03147290f, 0.02148792f, -0.01406093f, 0.02791242f, 0.01977604f, 
    -0.01106261f, 0.00488947f, 0.00225485f, 0.01583062f, 0.01251848f, 0.01536275f, 0.00781710f, -0.02568981f, 
    -0.02372962f, 0.01513525f, -0.02608101f, -0.02408400f, -0.00591906f, 0.01465354f, -0.00156995f, 0.00725092f, 
    0.00186717f, -0.02134530f, -0.03614069f, -0.01050714f, -0.00355541f, 0.00149067f, 0.02046152f, -0.00367386f, 
    -0.01122611f, 0.00916004f, -0.03324207f, 0.01654116f, 0.01635569f, 0.01314093f, -0.03600194f, -0.01502442f, 
    0.02345777f, -0.00899871f, 0.01764208f, -0.04398370f, 0.00428552f, -0.04224185f, 0.02789583f, 0.01698889f, 
    -0.00275694f, -0.00235375f, -0.04372385f, -0.02591334f, -0.04169497f, -0.04256518f, 0.03411896f, 0.02264749f, 
    -0.01953361f, -0.00860442f, 0.00081045f, 0.01496506f, 0.00497339f, 0.03432051f, 0.01913994f, -0.00479565f, 
    -0.00883149f, 0.01570723f, -0.03684828f, -0.02680238f, 0.02210623f, -0.01983473f, -0.01482898f, 0.02158943f, 
    -0.02315165f, 0.00820242f, -0.03395404f, -0.03441039f, 0.00350971f, -0.01628396f, 0.01910290f, -0.02034342f, 
    0.02547335f, -0.03615540f, -0.03346372f, -0.04002228f, -0.02343993f, -0.02108032f, -0.03232690f, 0.02503373f, 
    -0.02780077f, -0.03952213f, -0.00457157f, -0.03755878f, 0.02398062f, -0.00326876f, -0.01953136f, 0.00280737f, 
    -0.01123307f, -0.00443701f, 0.00375553f, -0.01721291f, 0.02029668f, -0.01496015f, 0.00694196f, -0.01776874f, 
    -0.02009895f, 0.01942132f, -0.02177912f, -0.01631786f, 0.02528822f, 0.01602854f, 0.00884940f, -0.02615820f, 
    0.00051485f, 0.00104637f, -0.03864874f, 0.02389773f, 0.00160093f, -0.01281148f, -0.02035349f, 0.00369753f, 
    -0.00565707f, -0.01908447f, -0.04040633f, -0.02289736f, -0.02888172f, -0.00266155f, 0.02232114f, 0.02489613f, 
    -0.00818937f, -0.03886605f, 0.01828972f, -0.00768661f, -0.02124984f, -0.03029324f, 0.02038461f, 0.00817738f, 
    0.00495319f, 0.01539914f, -0.03688204f, -0.00971332f, 0.02776905f, -0.03342659f, 0.03673913f, -0.03519697f, 
    0.00169765f, -0.02246459f, -0.03863361f, -0.02352427f, 0.02073492f, -0.00980317f, -0.02466492f, 0.00728448f, 
    -0.02581288f, -0.02280783f, 0.02458662f, -0.00940425f, -0.03869475f, -0.01061118f, -0.04276848f, 0.01771699f, 
    -0.00856240f, 0.00484736f, -0.00040461f, -0.00631901f, 0.00485555f, 0.00621932f, -0.00406804f, -0.00564005f, 
    -0.01976104f, 0.03008259f, -0.00196442f, -0.00155151f, -0.02709176f, 0.00718861f, 0.02393354f, -0.00601434f, 
    -0.02148660f, -0.03719398f, 0.02114503f, -0.01380964f, -0.03225115f, -0.04287500f, 0.01930444f, -0.02725636f, 
    -0.01498825f, 0.02570153f, 0.02010719f, -0.04262840f, -0.00045764f, -0.01043621f, 0.01604754f, 0.01008912f, 
    0.02532477f, 0.02231410f, -0.03514339f, 0.01092144f, -0.04270828f, -0.03117173f, 0.01439667f, 0.01177681f, 
    0.02645361f, -0.01097032f, 0.01800460f, -0.00264124f, 0.00021512f, -0.00773285f, 0.01502168f, -0.01069350f, 
    0.01778075f, 0.01470697f, -0.01446496f, -0.00257106f, -0.00379151f, -0.01360719f, 0.02678264f, -0.02447151f, 
    -0.01787212f, 0.00211374f, -0.01486339f, 0.01421633f, 0.00913335f, -0.02193705f, 0.02122653f, 0.02368484f, 
    -0.01736505f, -0.02555279f, -0.02585088f, -0.03854654f, -0.00311744f, 0.01101041f, 0.00432564f, 0.01364446f, 
    -0.00665609f, -0.00647146f, 0.02152307f, -0.00900210f, -0.00233418f, -0.01637760f, 0.01278664f, -0.03049129f, 
    0.02031516f, -0.04292598f, 0.02502963f, -0.02334404f, -0.02113018f, 0.01080008f, 0.01623769f, -0.00947034f, 
    0.01825700f, -0.01043748f, -0.03713607f, 0.00967939f, 0.01447262f, 0.00124086f, -0.04139723f, 0.02678844f, 
    0.02761727f, -0.03331752f, -0.03673912f, -0.01625255f, -0.00569307f, -0.00168176f, -0.02474781f, -0.01372468f, 
    -0.02310610f, -0.00002414f, -0.03378442f, -0.01959772f, 0.00661176f, -0.02399229f, -0.02237159f, 0.02032999f, 
    -0.00371013f, 0.01734434f, 0.00477372f, -0.04390138f, 0.02059739f, -0.00703745f, -0.03332037f, 0.00547514f, 
    -0.01395047f, 0.00321290f, -0.01633915f, 0.01979692f, -0.03437154f, -0.03579613f, 0.01590081f, 0.00895497f, 
    -0.02934036f, 0.00036217f, -0.00767072f, -0.02894833f, -0.02356960f, -0.01443571f, -0.00350098f, -0.03913671f, 
    0.02310767f, -0.02206506f, 0.00362272f, -0.00792561f, 0.02596036f, -0.02556030f, -0.03056132f, 0.02440930f, 
    -0.02614797f, -0.01556127f, -0.00814346f, -0.00846317f, 0.01967139f, -0.01631508f, -0.00065890f, -0.04055118f, 
    0.01896214f, -0.02669351f, -0.02980756f, -0.00616308f, 0.02124699f, 0.01682833f, -0.02258097f, -0.02082634f, 
    0.01976193f, -0.04321174f, 0.00944112f, -0.03690401f, -0.03443824f, 0.00995337f, -0.01982132f, -0.03955008f, 
    0.02277624f, -0.02001283f, -0.01776564f, 0.00055424f, 0.01199492f, 0.00717689f, -0.03143125f, 0.02587774f, 
    -0.00322219f, -0.03456394f, -0.00841261f, -0.02735122f, -0.03887587f, 0.02297333f, 0.00770933f, 0.01265824f, 
    -0.00088185f, 0.02851505f, -0.02004179f, -0.03488496f, 0.00101595f, -0.03390681f, -0.03898467f, -0.00146399f, 
    0.01050422f, -0.03156447f, -0.00275702f, -0.04227858f, 0.01357912f, 0.02495640f, -0.02440987f, -0.00984857f, 
    -0.01766039f, -0.01368988f, -0.02333278f, -0.00955081f, -0.03804855f, -0.01446530f, -0.01614396f, -0.03213640f, 
    -0.03873466f, 0.00047827f, -0.00523819f, -0.01247836f, -0.00355663f, 0.00742159f, 0.02132364f, -0.00101316f, 
    -0.02009316f, 0.01416677f, -0.02277780f, 0.00035552f, 0.00733060f, -0.01031459f, 0.00888593f, -0.02600880f, 
    0.01018121f, 0.01150513f, -0.00745696f, 0.01562881f, -0.02267666f, -0.02796981f, -0.02156788f, 0.01607555f, 
    0.00668388f, -0.01475903f, -0.04114152f, -0.02809953f, 0.02826374f, 0.02799185f, -0.00545871f, 0.01869641f, 
    -0.00429375f, 0.02961034f, 0.02497799f, -0.03840455f, 0.00887075f, -0.01415572f, 0.01275019f, 0.00097930f, 
    0.01400620f, 0.02532866f, 0.00042442f, -0.02546987f, 0.01946507f, -0.01326245f, 0.01495908f, -0.03159139f, 
    0.00375897f, -0.01992233f, 0.01244219f, -0.03141088f, -0.02644229f, 0.00194294f, -0.03357088f, -0.00523327f, 
    -0.02936365f, -0.01269718f, 0.02561661f, 0.02340713f, -0.02490165f, 0.01804459f, -0.01236705f, 0.02589739f, 
    0.02384662f, -0.02029790f, 0.01543328f, -0.01939716f, -0.02609852f, -0.02576725f, -0.04147374f, -0.01767280f, 
    0.01341647f, 0.01473023f, -0.02050179f, 0.01118153f, -0.01190863f, 0.00297325f, -0.04206126f, -0.01292141f, 
    -0.00130290f, -0.00832625f, -0.00795817f, 0.02728639f, 0.01386138f, 0.01780807f, -0.00816419f, -0.00936419f, 
    -0.00818655f, -0.00464622f, 0.01235441f, -0.03354288f, 0.02461671f, 0.02225008f, 0.00238938f, 0.01247448f, 
    -0.01151263f, -0.01290050f, 0.00378789f, -0.00111557f, -0.01678985f, -0.00561230f, -0.01106462f, 0.02941588f, 
    -0.01807875f, -0.02085036f, -0.02278324f, -0.02802904f, -0.00822802f, -0.03619540f, 0.02710724f, -0.00947831f, 
    0.01178668f, 0.02276294f, -0.03986084f, -0.03607301f, 0.01255996f, 0.02559702f, -0.02794669f, -0.04134613f, 
    0.00726107f, 0.01793854f, 0.01450442f, -0.04026138f, -0.02997262f, -0.02482252f, 0.03010423f, -0.00484537f, 
    0.01126641f, -0.02163791f, 0.01433284f, -0.02095300f, -0.00515131f, -0.01686836f, -0.04053210f, 0.02644597f, 
    -0.00363850f, -0.01814604f, 0.01440777f, 0.02093672f, 0.01451916f, -0.00189729f, -0.03538594f, -0.02013931f, 
    -0.00062043f, -0.04186103f, 0.02452477f, 0.01952892f, -0.01087710f, -0.01729286f, -0.04317581f, 0.01943814f, 
    0.01636584f, 0.02675143f, 0.01324024f, -0.03210402f, -0.04117872f, 0.01052745f, -0.01994198f, -0.01382033f, 
    0.00899386f, -0.02117513f, -0.00800782f, -0.04208537f, -0.01185255f, 0.02774869f, -0.03098660f, -0.02403522f, 
    0.01981339f, -0.03210933f, -0.01764228f, -0.02173622f, 0.01270875f, -0.01477386f, 0.00140662f, 0.02193487f, 
    0.02406942f, 0.02656749f, -0.01463152f, 0.02018336f, -0.01050729f, -0.00631336f, 0.02614159f, -0.03623947f, 
    -0.00223312f, 0.02823478f, 0.02527350f, 0.00280157f, 0.00466140f, -0.02452279f, -0.02669999f, -0.01425703f, 
    0.02725421f, -0.01030099f, -0.01874662f, -0.00313612f, -0.03523835f, -0.01716253f, 0.00761204f, 0.01452253f, 
    -0.02377207f, 0.00889678f, 0.00551537f, -0.03011265f, -0.00566261f, 0.00989574f, 0.02247484f, -0.00192333f, 
    0.00324369f, -0.02382803f, 0.02119900f, -0.03112537f, -0.00566068f, 0.01817838f, 0.01242487f, -0.00021319f, 
    -0.02063376f, 0.00422125f, 0.02300774f, -0.03010724f, -0.02698152f, 0.01385368f, -0.03388600f, -0.01615719f, 
    0.02118140f, -0.03041434f, -0.03664572f, -0.02268939f, -0.00891191f, -0.03997051f, -0.02627436f, 0.03092715f, 
    -0.00894107f, 0.00276078f, 0.01511449f, -0.02560917f, -0.01576651f, 0.02461636f, 0.02501095f, -0.00025541f, 
    -0.03314046f, -0.03580103f, 0.03019441f, 0.00453541f, 0.00742143f, -0.03915232f, 0.00610333f, -0.01359791f, 
    0.02248733f, 0.00357510f, -0.01576164f, -0.03256783f, -0.00097620f, -0.01413858f, -0.03865976f, -0.01503832f, 
    -0.03187082f, -0.01846108f, 0.01542870f, 0.03135467f, 0.00212514f, -0.02928279f, -0.01505552f, 0.01931471f, 
    0.01972818f, -0.02460390f, -0.00538841f, -0.03483948f, 0.02538100f, -0.01920427f, -0.00832003f, 0.01838736f, 
    -0.00804076f, -0.01861863f, -0.00193628f, 0.02617572f, 0.00043392f, -0.00973816f, -0.04160518f, -0.01682558f, 
    0.00437358f, -0.00351381f, 0.03045145f, -0.02321393f, -0.02640791f, -0.04318401f, 0.00865258f, -0.01570787f, 
    0.01504263f, -0.01929341f, 0.02173736f, 0.00513053f, -0.03450435f, -0.02603579f, -0.02518878f, -0.04309161f, 
    -0.34951839f, -0.03477196f, 0.01068142f, -0.00393570f, -0.01701130f, 0.09550500f, 0.06734986f, 0.13489568f, 
    0.02920049f, 0.02090752f, 0.09097961f, -0.09607315f, -0.16683716f, -0.08321221f, 0.00715974f, -0.14117001f, 
    0.09973878f, -0.10320416f, 0.00407398f, -0.02725558f, -0.05338435f, 0.12670644f, 0.04186805f, 0.04151549f, 
    -0.02514699f, 0.00571083f, -0.02012257f, -0.05550000f, 0.01157515f, -0.04447825f, -0.02782734f, -0.07225412f, 
    -0.10641313f, 0.04960267f, -0.07314633f, 0.04244900f, -0.31685224f, -0.01268246f, 0.06498888f, 0.03960580f, 
    0.12143388f, 0.04073965f, 0.04220982f, 0.00359185f, 0.02602828f, -0.03787454f, -0.03669546f, -0.06279991f, 
    0.01910378f, -0.06092753f, -0.03922360f, -0.15896186f, 0.08191004f, -0.13776349f, 0.20779376f, 0.03630010f, 
    0.12611529f, -0.07050993f, 0.09338526f, 0.00526934f, -0.06575542f, -0.08035468f, -0.03761317f, 0.01028085f, 
    -0.16226092f, -0.01995254f, 0.03455508f, -0.04729954f, 0.04496561f, -0.00202281f, -0.00350495f, 0.02273398f, 
    -0.16399288f, -0.07167993f, 0.06500544f, 0.16497675f, -0.13053888f, -0.05897927f, 0.02156355f, -0.01167080f, 
    -0.08135470f, 0.03338071f, 0.10744780f, -0.14760669f, -0.00693125f, 0.02500713f, -0.12869556f, -0.37770960f, 
    0.07021052f, -0.02812275f, 0.01483339f, 0.05365068f, -0.07177203f, -0.06161457f, -0.01663147f, 0.17196679f, 
    0.23373580f, -0.06137484f, 0.00835457f, 0.03021996f, -0.14018801f, 0.04376956f, 0.03800828f, 0.00826408f, 
    -0.14728548f, 0.04759840f, 0.03237660f, -0.02812028f, 0.00357873f, -0.03538183f, -0.15664455f, 0.04932445f, 
    0.10756003f, 0.08873542f, 0.09893487f, 0.02237339f, -0.06941547f, -0.01893008f, -0.04334051f, 0.04877569f, 
    -0.11485673f, 0.11655263f, 0.14674480f, -0.17090592f, 0.09355567f, -0.00932197f, 0.07542163f, 0.06688860f, 
    0.04637200f, 0.13549547f, -0.06848256f, 0.13113366f, -0.25299385f, 0.04678496f, 0.14347509f, 0.13039505f, 
    0.04399316f, 0.07453699f, 0.05835330f, 0.03025515f, 0.00857741f, 0.07562510f, 0.04422743f, 0.11519123f, 
    0.15163168f, -0.19091973f, 0.05726177f, 0.09670740f, 0.09546237f, -0.08759302f, 0.05280817f, -0.00736844f, 
    0.03977661f, -0.06518383f, -0.11997946f, 0.01754152f, -0.18554020f, -0.11769890f, 0.04777678f, -0.14201428f, 
    0.04728633f, 0.06298993f, 0.01318426f, -0.00156793f, 0.06849413f, -0.07217722f, 0.05159149f, 0.03875424f, 
    0.06981912f, -0.07475340f, 0.10090114f, 0.06378653f, 0.05390340f, 0.20067096f, -0.04963982f, -0.06088474f, 
    0.00190050f, 0.04467088f, 0.04591105f, 0.04100985f, -0.10025827f, 0.06564412f, 0.11046729f, 0.12079009f, 
    -0.04760326f, -0.02519499f, -0.10704361f, 0.08841177f, 0.05502360f, 0.07940674f, 0.03639802f, -0.07750695f, 
    0.20736726f, -0.21367656f, -0.02753890f, -0.04957850f, 0.06533382f, 0.05011988f, -0.04123251f, -0.04446539f, 
    -0.07192096f, 0.06308699f, 0.06809361f, 0.09733316f, -0.08545162f, 0.15827242f, -0.08211514f, -0.25561047f, 
    0.03865804f, -0.00134844f, 0.04774304f, -0.01409598f, -0.20090893f, 0.02419308f, 0.00567460f, 0.07373252f, 
    0.17522831f, -0.10770859f, -0.11889701f, -0.14664799f, -0.03263415f, 0.00522737f, -0.04817680f, 0.01770912f, 
    0.13840827f, -0.08367718f, -0.09983011f, -0.11353850f, -0.40393725f, -0.00351863f, 0.23270793f, 0.31905550f, 
    0.09788541f, 0.00597194f, -0.08473282f, 0.02364015f, -0.02984479f, -0.03621934f, 0.00857513f, -0.00900920f, 
    0.12606350f, -0.16403441f, -0.06209951f, 0.04951722f, 0.07342891f, 0.05491727f, 0.07766633f, -0.06983034f, 
    0.06248721f, 0.01134496f, 0.09120981f, 0.08175517f, 0.09266001f, -0.02013591f, -0.14149694f, 0.00113439f, 
    0.01151056f, -0.02678093f, -0.07887700f, -0.00490370f, -0.04931201f, -0.01355833f, 0.16739206f, 0.13875487f, 
    -0.34046426f, 0.05590630f, 0.13251244f, 0.33904806f, -0.08446012f, 0.07081393f, -0.06444043f, -0.00303290f, 
    0.14397758f, 0.04330220f, 0.06615523f, 0.00139747f, 0.14526573f, 0.18604904f, 0.00350935f, -0.01295392f, 
    0.06154076f, 0.09452166f, 0.12399081f, -0.06711762f, -0.00595273f, -0.04125607f, 0.00442536f, -0.02661430f, 
    -0.11957003f, -0.03171292f, -0.00006639f, -0.16478275f, 0.02748115f, 0.06495278f, 0.00293450f, -0.12099484f, 
    -0.13583195f, -0.09865388f, 0.00943593f, -0.08174256f, -0.13981563f, -0.03305405f, -0.05635149f, 0.15307374f, 
    -0.05053144f, 0.04301435f, 0.00770408f, -0.02177266f, 0.06910081f, -0.01618573f, 0.07322089f, -0.00330980f, 
    0.21884146f, -0.11064317f, -0.11965225f, 0.15161203f, 0.11987223f, -0.00137275f, 0.06106836f, 0.14603245f, 
    0.04493923f, 0.07573280f, 0.01265290f, 0.10779139f, 0.22893095f, 0.16726743f, 0.05209611f, -0.13752156f, 
    0.19643295f, -0.00817876f, 0.03123916f, -0.04370825f, -0.02830242f, 0.00585887f, -0.08057513f, -0.02872746f, 
    -0.19485439f, 0.05636820f, -0.13910961f, -0.22980018f, 0.04000787f, -0.01058055f, 0.01506511f, 0.00338474f, 
    -0.10078569f, 0.05177671f, -0.08562361f, 0.02873005f, 0.13984644f, 0.06756406f, -0.00031590f, -0.03800883f, 
    -0.10373294f, 0.03472764f, 0.07559466f, -0.02398791f, 0.02655448f, -0.04549455f, -0.04929218f, 0.06711279f, 
    0.45195550f, -0.05100938f, -0.09386113f, 0.16405353f, 0.05077665f, -0.01479497f, -0.00936713f, 0.07534804f, 
    0.03794430f, 0.09007473f, 0.03381907f, -0.02672069f, 0.27183461f, 0.32142022f, -0.00811177f, -0.10866744f, 
    -0.00815653f, 0.06138260f, 0.02857941f, 0.11975358f, 0.12243507f, 0.03621359f, 0.09730572f, -0.01559156f, 
    0.00212783f, 0.12698029f, -0.09137876f, -0.14057344f, 0.01365721f, 0.04037114f, 0.02781719f, -0.07308383f, 
    0.17226134f, 0.04381306f, -0.03467068f, 0.12210096f, 0.09209058f, -0.01547616f, -0.05875142f, -0.05012637f, 
    -0.07632416f, -0.01697453f, -0.11609750f, 0.02835890f, 0.07019588f, 0.13371246f, 0.05508155f, -0.08297258f, 
    -0.23519608f, 0.10632447f, 0.20998986f, -0.20989458f, 0.05984015f, 0.04958738f, 0.08094272f, 0.07288207f, 
    -0.06571182f, -0.03926700f, -0.03057522f, 0.10823313f, -0.36017567f, -0.16236186f, 0.24205975f, -0.00989969f, 
    -0.01101267f, -0.07695681f, -0.04077491f, 0.00686584f, -0.03429956f, 0.08746506f, -0.00785578f, 0.08158826f, 
    0.30646068f, 0.14978622f, 0.04159179f, -0.11591171f, 0.08193228f, 0.04669035f, -0.06723402f, 0.05678259f, 
    0.04110380f, -0.02851427f, 0.02245513f, 0.06333061f, 0.14913952f, 0.03129704f, -0.10524386f, -0.05363492f, 
    0.02690469f, -0.07344998f, -0.02890797f, -0.08419426f, 0.04223522f, -0.00743261f, -0.02936675f, -0.05109216f, 
    -0.02616331f, 0.20273753f, -0.11318186f, 0.23145424f, 0.01878435f, -0.14358911f, -0.03989183f, 0.05592408f, 
    -0.01797418f, 0.11629891f, -0.04721064f, -0.02065284f, -0.16437395f, 0.07165545f, -0.07599679f, -0.00397253f, 
    -0.06909550f, 0.00879254f, 0.08481863f, 0.03319009f, -0.01469671f, 0.02722068f, 0.05736079f, 0.01527663f, 
    -0.03899235f, 0.10082289f, -0.11345366f, -0.14512700f, -0.03029790f, 0.09601373f, -0.05549163f, -0.04167713f, 
    0.01796496f, 0.01500045f, -0.02102038f, 0.00692877f, 0.18324427f, 0.00196133f, -0.00566364f, -0.02503402f, 
    0.07891914f, 0.11428787f, 0.03123913f, 0.02344700f, 0.09488500f, -0.04658527f, -0.06150585f, 0.04736617f, 
    0.18589570f, -0.10759044f, 0.10074506f, -0.09240425f, -0.00084390f, 0.05032427f, 0.05177019f, -0.08026458f, 
    -0.00524910f, -0.01632557f, -0.04257376f, -0.01809435f, -0.05573859f, -0.00886882f, -0.00799052f, 0.14206503f, 
    -0.04534326f, 0.03288876f, 0.01760629f, 0.02555875f, -0.01070764f, -0.01257017f, -0.04917059f, -0.05880085f, 
    0.16830793f, 0.07369186f, -0.01781165f, 0.01400503f, 0.04445915f, -0.06246665f, 0.06231013f, 0.03695505f, 
    0.01828783f, 0.00449084f, -0.04179861f, 0.03892965f, 0.25455207f, -0.03518807f, -0.08882374f, -0.03901194f, 
    -0.14926848f, -0.13082422f, 0.07309875f, -0.09254988f, 0.00650134f, 0.00936001f, -0.03774898f, 0.01158797f, 
    -0.13363647f, -0.01471384f, 0.08589034f, -0.16555102f, 0.09950904f, 0.02444600f, -0.01753130f, -0.14314415f, 
    0.04367263f, 0.03941960f, -0.00392013f, 0.03524918f, -0.10186070f, -0.15444368f, -0.08619154f, -0.00171204f, 
    0.07157101f, 0.02551040f, -0.05846493f, 0.05344770f, 0.09126944f, 0.04179411f, 0.02333109f, 0.08994288f, 
    0.01549338f, 0.06028984f, -0.15518709f, 0.16252543f, 0.03806197f, -0.05382578f, 0.05693390f, 0.02899075f, 
    -0.09339387f, 0.14258648f, -0.08965123f, 0.06128081f, 0.24508995f, -0.25024372f, 0.06477316f, -0.17012656f, 
    0.05427476f, -0.06980155f, -0.04855164f, -0.13041209f, 0.11239728f, -0.03935286f, 0.05691008f, 0.10944334f, 
    -0.23292081f, 0.03696511f, 0.11997919f, 0.11149932f, 0.04652558f, 0.01290449f, -0.01872540f, -0.09771656f, 
    -0.08324844f, -0.11974365f, -0.02353514f, -0.03172428f, 0.47777018f, 0.23947045f, -0.10800181f, -0.05249560f, 
    0.05099718f, -0.10493173f, 0.02685691f, 0.11094801f, 0.00643605f, 0.01347520f, -0.05209070f, -0.09715847f, 
    -0.05371025f, 0.06381647f, -0.07774933f, 0.07557223f, 0.01641749f, -0.00920568f, -0.04755160f, 0.07810946f, 
    0.11557548f, 0.00837238f, -0.03471867f, 0.05687573f, -0.00158468f, -0.04560151f, -0.03844516f, 0.20624302f, 
    0.08427896f, 0.06188864f, -0.03141081f, 0.00926133f, -0.01982542f, -0.00991072f, 0.04726914f, -0.01267319f, 
    -0.09061255f, -0.11894233f, -0.06014878f, -0.13910963f, 0.05987234f, 0.18373640f, 0.06503246f, -0.12691918f, 
    -0.12919913f, 0.01558281f, 0.06393915f, 0.01553951f, -0.23268387f, -0.04116157f, 0.00366508f, -0.18692924f, 
    0.17523794f, 0.09435619f, 0.10927582f, -0.01226852f, 0.01127471f, 0.09167410f, 0.02136933f, 0.06909779f, 
    0.06655881f, 0.15479520f, -0.08277796f, -0.04512778f, 0.10676855f, -0.03426366f, 0.03967219f, 0.04198204f, 
    0.04163594f, 0.00389160f, 0.03455722f, 0.03027817f, 0.63440174f, -0.03167640f, -0.22093679f, -0.02172421f, 
    -0.06890617f, 0.01189765f, -0.01992174f, 0.08113772f, 0.08814103f, 0.06260258f, 0.07703516f, 0.01619362f, 
    -0.41910872f, 0.21921355f, 0.39711860f, 0.09819126f, -0.00422734f, -0.05151828f, 0.07767485f, 0.07163366f, 
    -0.01228952f, -0.13949637f, -0.04045778f, 0.04293909f, -0.18176091f, -0.07646035f, 0.02110941f, 0.04549817f, 
    0.11292201f, 0.07061481f, -0.05729254f, 0.02485981f, 0.04526552f, 0.04746891f, 0.04253297f, -0.06377791f, 
    -0.05476296f, -0.14958696f, -0.05023240f, -0.03784531f, -0.01086518f, 0.02931412f, -0.04926953f, -0.04794299f, 
    -0.04950012f, -0.05643096f, -0.07325462f, -0.02477406f, 0.36869153f, -0.07967957f, 0.06717035f, 0.15259382f, 
    -0.04566162f, 0.01065879f, 0.01702975f, 0.02112783f, 0.03621942f, 0.05459097f, 0.09337382f, -0.12933271f, 
    -0.28408739f, -0.06932780f, 0.06150783f, -0.12901053f, 0.00049921f, 0.03468025f, 0.10175736f, 0.13997114f, 
    -0.03735041f, 0.09171101f, 0.04434288f, 0.04362560f, 0.10601772f, -0.27093667f, 0.03407084f, 0.10187620f, 
    0.12742774f, 0.05833456f, -0.10229392f, -0.04762136f, -0.03635198f, 0.05003643f, 0.00357419f, 0.02715887f, 
    0.22925834f, 0.13830587f, 0.00820359f, 0.10588116f, 0.00083886f, 0.09185683f, -0.00804246f, 0.04836314f, 
    0.00965917f, 0.06627247f, -0.00425142f, -0.04550718f, 0.17531317f, -0.04660835f, -0.20158707f, 0.33816734f, 
    -0.02641001f, -0.04135666f, -0.04191682f, 0.03627358f, 0.07005867f, -0.02787414f, 0.07962526f, 0.06990325f, 
    0.15857235f, -0.00116099f, -0.12486945f, 0.14394353f, 0.13555041f, -0.04848202f, -0.06499717f, 0.05771005f, 
    0.04788222f, -0.00407838f, -0.21119861f, 0.01717089f, -0.16478038f, -0.15868756f, -0.02815040f, -0.10680647f, 
    -0.05407640f, -0.04340743f, -0.08200047f, 0.15507543f, 0.09193007f, 0.00459485f, 0.02651362f, -0.02981639f, 
    0.27216664f, 0.02816282f, -0.01740456f, -0.20791629f, 0.13216022f, -0.05446476f, 0.17248490f, 0.00988078f, 
    -0.03583258f, -0.01903126f, -0.00240522f, 0.15990028f, 0.00309180f, -0.05135862f, 0.06663318f, 0.02926874f, 
    0.07480352f, 0.16392456f, 0.07737980f, 0.06992715f, 0.08213573f, 0.04537971f, 0.01099162f, -0.04882513f, 
    -0.00283201f, 0.00471892f, 0.04931059f, -0.00517468f, -0.07853106f, -0.15013173f, 0.04360840f, -0.08436376f, 
    0.01579881f, 0.05489655f, -0.02507446f, -0.11632556f, 0.07634619f, -0.09925795f, -0.21683167f, 0.09229303f, 
    0.05314567f, 0.04725664f, -0.00562404f, -0.04215169f, 0.03332552f, 0.02125871f, 0.01031451f, -0.01067805f, 
    -0.02021135f, 0.06709565f, -0.20775691f, 0.20225064f, -0.11668419f, -0.03237937f, 0.10635447f, 0.02906461f, 
    -0.03008905f, 0.04446976f, 0.13696633f, 0.03890569f, 0.42184961f, -0.16627851f, 0.04105730f, -0.04105332f, 
    0.05023067f, -0.12293670f, -0.07293760f, -0.01366694f, 0.04348552f, -0.11410061f, 0.07502662f, 0.03877510f, 
    0.15604690f, 0.00062147f, 0.09372926f, 0.12477878f, 0.02301633f, -0.01391094f, -0.06453134f, 0.01762452f, 
    -0.11774123f, 0.05848764f, -0.02157648f, 0.06924970f, 0.14178717f, 0.19546810f, 0.06270097f, -0.23975152f, 
    0.03605502f, -0.04239671f, 0.06475970f, 0.02533848f, -0.02845911f, -0.00510447f, 0.00489092f, 0.04683205f, 
    0.03081056f, -0.03093633f, 0.02801881f, -0.26878956f, 0.05678415f, 0.11782035f, -0.02673667f, 0.20862027f, 
    0.07224139f, -0.02050163f, -0.07242282f, -0.00848076f, 0.15910222f, -0.04560536f, -0.09574476f, 0.02629560f, 
    -0.00079453f, -0.13496269f, 0.07220108f, -0.03359205f, 0.04364014f, -0.01803141f, -0.05661070f, -0.06008571f, 
    0.23413020f, 0.00446984f, -0.15069108f, -0.27169555f, -0.07849394f, 0.06756289f, 0.02386027f, 0.00378244f, 
    -0.05152668f, 0.01120898f, 0.01373347f, 0.07986102f, -0.21532211f, -0.02124238f, -0.18282798f, -0.00698556f, 
    0.11840121f, -0.02777041f, -0.01964447f, 0.09978109f, -0.07306697f, -0.00875603f, -0.04210185f, -0.01447923f, 
    -0.14366563f, -0.09429038f, -0.00099215f, -0.13167804f, -0.01570392f, -0.07801747f, 0.08045110f, -0.00465202f, 
    0.06173166f, -0.03502417f, 0.01807954f, 0.02609397f, 0.06707106f, 0.11415195f, -0.00152215f, -0.05792081f, 
    0.00896656f, -0.00733616f, 0.04154516f, 0.02389648f, 0.02008382f, 0.01134415f, -0.00516682f, 0.01660115f, 
    0.05893649f, 0.08899287f, -0.05648759f, -0.11851572f, -0.04898544f, 0.10129918f, -0.07796919f, 0.02010694f, 
    0.00372932f, -0.05880933f, 0.01587401f, -0.06498303f, -0.30534083f, 0.23238224f, 0.10128368f, -0.06777835f, 
    0.01348068f, 0.00169907f, 0.01255983f, -0.09739135f, 0.04566472f, -0.03960231f, -0.03299695f, -0.03118660f, 
    -0.24565020f, -0.04513571f, -0.01859982f, 0.06307676f, -0.04281403f, -0.02571775f, -0.04197243f, 0.04792939f, 
    0.01790715f, -0.02472481f, -0.07723462f, 0.00452832f, -0.11860782f, -0.10377479f, -0.09181984f, -0.19983186f, 
    0.07071044f, 0.10180816f, -0.05997209f, 0.08536828f, 0.09427051f, 0.10105062f, -0.01791075f, -0.00336846f, 
    -0.06410960f, -0.15192367f, -0.11549583f, -0.13542514f, -0.04748514f, 0.06045488f, 0.05131845f, 0.03507634f, 
    0.02869219f, -0.10443757f, -0.01375999f, -0.05910516f, -0.12259079f, -0.00238202f, 0.05616797f, -0.18539129f, 
    0.06953383f, 0.00084923f, -0.06344885f, 0.08521775f, -0.01761642f, -0.01659904f, 0.05574846f, 0.01602436f, 
    0.05784412f, 0.01888060f, -0.13381898f, 0.38615662f, 0.06328333f, -0.02849722f, -0.02295636f, -0.03970709f, 
    0.08134903f, -0.01033316f, -0.04061441f, 0.03919934f, -0.09611717f, -0.08098745f, 0.05356435f, -0.14404592f, 
    -0.01353428f, -0.04425871f, 0.09668082f, -0.09066250f, -0.11024221f, -0.04428954f, 0.04988183f, -0.05852830f, 
    0.34296265f, 0.11006930f, 0.05625240f, -0.00904232f, 0.12862758f, -0.00720101f, 0.02146812f, 0.01992117f, 
    -0.01441032f, 0.03138246f, -0.04064220f, 0.00434041f, 0.02298644f, -0.08409859f, 0.00294387f, -0.27821729f, 
    0.07920530f, -0.16560709f, 0.05394204f, -0.01940740f, 0.11383622f, 0.02566394f, -0.09833626f, -0.04879973f, 
    0.11778826f, 0.08701195f, -0.15515956f, -0.09110424f, 0.05701405f, 0.00054175f, 0.04660739f, 0.00992761f, 
    -0.04063343f, 0.00131232f, 0.00148472f, 0.00173052f, -0.09873780f, -0.28717944f, -0.17345564f, -0.21187617f, 
    -0.07975791f, 0.00287555f, -0.05955578f, 0.05232175f, 0.01938528f, 0.08039692f, -0.06060366f, -0.00053588f, 
    -0.08107944f, -0.03027602f, 0.13985525f, -0.20005061f, -0.00922182f, 0.02686951f, 0.03083663f, 0.12984744f, 
    0.08395980f, 0.07373371f, 0.08284408f, -0.04967733f, 0.29074988f, -0.01344918f, 0.10721561f, -0.20453259f, 
    0.07816454f, -0.02164505f, -0.03871317f, 0.11226200f, -0.04031460f, 0.04883161f, -0.05582165f, 0.04729986f, 
    0.51901269f, -0.12887363f, 0.04942359f, -0.02671522f, 0.10642780f, 0.08456297f, -0.08949340f, 0.09443617f, 
    0.02615317f, 0.13284867f, 0.06031958f, 0.00594469f, 0.00167049f, 0.17256981f, 0.00369042f, 0.17406149f, 
    0.03989411f, 0.07419834f, -0.17508925f, -0.06330917f, -0.05797327f, 0.08743702f, 0.07416452f, 0.08893069f, 
    0.27097785f, 0.06051180f, -0.05152159f, -0.37688038f, -0.01584749f, -0.00454943f, -0.09123845f, -0.02214787f, 
    0.06803101f, -0.02723397f, -0.00802926f, 0.08833077f, -0.25154787f, -0.27212209f, -0.16572015f, 0.10584452f, 
    -0.04657369f, -0.11430120f, -0.07638834f, 0.00465292f, 0.05383908f, 0.01108401f, 0.03176652f, 0.08738422f, 
    0.48045725f, 0.05137395f, 0.10773455f, -0.07904150f, 0.10392258f, 0.01115312f, -0.01826167f, 0.11580350f, 
    -0.04029402f, 0.04808194f, -0.03172021f, 0.01780580f, 0.23089027f, 0.08072448f, -0.04612484f, 0.22601098f, 
    -0.10035273f, 0.09960392f, 0.01323718f, -0.05434999f, -0.04204077f, -0.03615724f, 0.07821023f, -0.02875717f, 
    -0.18451336f, -0.01053153f, -0.13786474f, 0.23749232f, 0.10782412f, -0.13093765f, -0.03478281f, -0.20700301f, 
    -0.01663783f, -0.00146630f, 0.02042998f, 0.02838367f, -0.27291995f, -0.05297699f, -0.08986397f, 0.40104163f, 
    -0.04363494f, -0.00620075f, -0.06010373f, 0.12058044f, 0.08794194f, 0.06042089f, 0.00095759f, -0.01452989f, 
    0.12971908f, 0.12510690f, 0.03661928f, 0.16796483f, -0.04904651f, 0.11218791f, -0.03722015f, 0.00043210f, 
    0.00598696f, 0.05419593f, 0.07274546f, -0.01776843f, 0.31596646f, 0.28417680f, 0.02711404f, 0.13155468f, 
    0.04286135f, -0.00912344f, 0.07201114f, 0.03452699f, -0.01490267f, 0.02412587f, -0.07099465f, -0.00064003f, 
    0.29762986f, 0.10940872f, 0.14834456f, 0.12735240f, 0.00374415f, 0.01167564f, 0.01334296f, 0.03259258f, 
    0.08664780f, -0.01493946f, -0.07425625f, -0.04658366f, 0.01656342f, -0.15374111f, -0.05647418f, 0.13245541f, 
    0.00881280f, 0.06226942f, 0.04757110f, 0.09854732f, 0.05381790f, -0.06589115f, -0.04724509f, -0.05816881f, 
    0.37968773f, 0.16032696f, 0.09988689f, -0.14755690f, -0.05968865f, 0.01342761f, -0.07494262f, 0.01959608f, 
    -0.08843907f, 0.05190407f, 0.06896886f, 0.09810425f, 0.03649120f, 0.01685847f, 0.14988394f, -0.04879366f, 
    0.17147373f, -0.10920839f, 0.08764520f, 0.13015185f, -0.09248070f, 0.07575658f, 0.04352339f, -0.03680651f, 
    0.15596308f, -0.01345406f, -0.03804637f, 0.19420186f, 0.11918066f, 0.06733003f, -0.07515509f, -0.03823800f, 
    0.03492835f, -0.00314397f, -0.03053726f, 0.00888706f, -0.20178714f, 0.01135918f, -0.10606542f, -0.19357672f, 
    0.02605087f, 0.07245474f, -0.00284148f, -0.02850904f, -0.03178868f, 0.07569437f, -0.05803361f, 0.05736919f, 
    -0.02215468f, 0.14402691f, 0.00293637f, 0.16748932f, -0.04599936f, -0.09145724f, 0.12111494f, -0.07015832f, 
    0.10582546f, -0.10624278f, 0.00582645f, -0.01277583f, 0.33634901f, -0.00631923f, 0.02707582f, 0.14762743f, 
    0.14125025f, 0.03830811f, -0.04450189f, -0.16874109f, 0.03738368f, 0.01472178f, 0.00365714f, 0.12258117f, 
    -0.28130215f, -0.11453649f, 0.05899544f, -0.29375815f, 0.05920443f, 0.05319352f, 0.00396360f, 0.16075772f, 
    -0.03364129f, 0.12055618f, 0.17459244f, -0.12626182f, 0.06635130f, 0.22215833f, 0.03860915f, -0.07214381f, 
    -0.00331552f, -0.02319632f, 0.06697746f, -0.02318358f, 0.06461512f, 0.04467172f, -0.07290865f, 0.02342076f, 
    0.08219855f, 0.11613764f, 0.05319559f, -0.16349943f, 0.02068644f, -0.04860460f, -0.02507303f, 0.10809953f, 
    0.08713005f, -0.07365218f, -0.05972787f, 0.09511773f, -0.17432459f, 0.08998558f, 0.03156992f, 0.08448756f, 
    -0.07795051f, -0.01650731f, 0.10114420f, -0.00926932f, 0.03832027f, 0.01543295f, -0.01432897f, 0.00220317f, 
    -0.04573792f, -0.18878762f, 0.15555051f, 0.01200858f, -0.09368712f, -0.01726161f, -0.03772167f, 0.01052374f, 
    -0.08513226f, 0.01461735f, 0.00934210f, -0.01617916f, 0.05655409f, 0.00985854f, 0.23567255f, -0.10952771f, 
    -0.03983031f, -0.00400678f, -0.05654036f, 0.03660720f, -0.03520004f, 0.05759383f, 0.00882497f, 0.00480270f, 
    0.16673841f, 0.05666896f, 0.12093528f, -0.12952514f, 0.14741848f, -0.04964205f, -0.04894427f, 0.10463898f, 
    0.02431833f, -0.00231834f, 0.02484195f, -0.00921238f, -0.08054317f, 0.15365292f, -0.18245703f, 0.24518076f, 
    -0.13631827f, 0.03491811f, -0.11447285f, 0.04154192f, 0.03317185f, 0.02550465f, 0.14488019f, 0.11321408f, 
    0.17755704f, 0.29528594f, 0.14133629f, -0.40240949f, -0.08444422f, -0.11431917f, 0.00534739f, -0.07281439f, 
    -0.10057790f, -0.03688444f, 0.17387274f, 0.15186237f, -0.25519931f, -0.13707109f, 0.10557831f, -0.15272155f, 
    0.08141027f, 0.00554584f, 0.01207668f, 0.06918845f, 0.03260923f, 0.04843806f, 0.11895068f, 0.05600176f, 
    0.07789434f, 0.06814497f, 0.07791423f, -0.05580701f, -0.03092952f, -0.06253395f, 0.05400027f, -0.05623765f, 
    -0.08038037f, 0.00763264f, 0.07066610f, -0.07026074f, -0.16228601f, -0.15860167f, -0.21179941f, 0.18923441f, 
    -0.10533705f, -0.02362981f, 0.04604317f, 0.00263182f, 0.05920883f, -0.04873649f, 0.07855465f, 0.05123550f, 
    0.03459525f, 0.29373163f, 0.08173102f, -0.37457809f, -0.05540419f, -0.08630329f, -0.13246262f, 0.12236714f, 
    -0.01554015f, 0.02825364f, 0.00620127f, 0.09897234f, -0.19834159f, -0.07460220f, -0.01829545f, -0.32877907f, 
    0.03408542f, 0.11787128f, -0.04748899f, 0.00107716f, 0.02335734f, -0.02825922f, 0.07513374f, -0.10252559f, 
    -0.25554171f, 0.28672656f, -0.10295615f, 0.05422881f, 0.06291513f, 0.06272656f, 0.01605571f, -0.10972842f, 
    0.02622443f, -0.07469025f, 0.10078505f, 0.00021056f, -0.18157396f, 0.26928365f, -0.01879754f, -0.04981628f, 
    0.16738141f, -0.07613406f, 0.03693450f, -0.01411206f, -0.07160167f, 0.04005919f, -0.04083990f, 0.01027199f, 
    -0.07335862f, 0.12865897f, 0.08272614f, -0.00758436f, 0.00634621f, 0.02046838f, 0.01967645f, -0.06344311f, 
    -0.02930211f, 0.03805324f, -0.01893258f, 0.10615665f, 0.09486323f, 0.43646002f, -0.03038851f, -0.08677953f, 
    0.06171419f, 0.05703317f, -0.03701789f, -0.03567953f, 0.05847890f, -0.03284314f, 0.03518913f, 0.00216733f, 
    -0.12784253f, 0.31911415f, -0.07079850f, 0.08374076f, -0.09195539f, 0.12862797f, -0.11461718f, 0.02372339f, 
    0.13083182f, 0.02923843f, -0.01923343f, -0.05585028f, 0.03419699f, 0.13794282f, -0.02096573f, -0.04748143f, 
    -0.09286483f, -0.07781876f, 0.03088774f, 0.00359677f, -0.00598960f, 0.05876232f, 0.09639671f, 0.01640939f, 
    -0.01552350f, 0.05723464f, 0.12764084f, 0.10660989f, 0.13188136f, 0.07955144f, 0.05873924f, 0.04664877f, 
    0.07064177f, -0.01785247f, 0.01329881f, 0.04151939f, -0.24698691f, -0.08726195f, -0.11461801f, -0.06779712f, 
    0.12219975f, 0.00745068f, -0.04890366f, -0.07126006f, -0.01932236f, -0.05764597f, -0.06439766f, -0.01277004f, 
    0.06553259f, -0.01681360f, -0.12180887f, -0.36754113f, 0.05351558f, -0.04564326f, 0.03369439f, 0.01808132f, 
    -0.00012624f, 0.01280711f, -0.13804957f, 0.02705530f, 0.18568923f, 0.04052413f, 0.01862921f, -0.09931210f, 
    -0.00598425f, 0.09839062f, -0.03635699f, -0.01685837f, -0.04231778f, 0.04176421f, 0.01052366f, -0.07818508f, 
    -0.01904665f, 0.16879977f, -0.09126585f, -0.06514415f, -0.00090098f, 0.04414817f, -0.05197052f, -0.10567300f, 
    0.03082334f, -0.03443566f, -0.02500521f, -0.07304411f, -0.13694039f, 0.25158793f, -0.13353854f, 0.18564248f, 
    0.03636277f, 0.03250900f, -0.03143718f, -0.06479267f, -0.00018002f, -0.00940130f, -0.03748806f, 0.02668122f, 
    0.01080221f, 0.08885100f, 0.10002618f, 0.17871398f, 0.14225510f, 0.09670987f, 0.04333550f, 0.00741583f, 
    0.03518509f, 0.00639419f, 0.04616613f, -0.01204679f, -0.06873576f, 0.22604902f, -0.03825403f, -0.08482376f, 
    0.10946527f, 0.10209992f, -0.03705500f, -0.05014139f, 0.06628481f, -0.02479492f, 0.03798824f, 0.00592886f, 
    0.12789646f, -0.01436112f, 0.19042192f, 0.18246455f, 0.14375685f, 0.02185777f, -0.01332620f, 0.00150073f, 
    -0.03329927f, -0.07758989f, 0.07323248f, 0.16292894f, -0.02244676f, -0.00637834f, 0.11805724f, 0.01446884f, 
    -0.08912458f, 0.00374687f, 0.04528486f, -0.01296242f, 0.09880101f, -0.04426287f, 0.14914785f, -0.00543656f, 
    -0.21000400f, 0.04802159f, -0.04232237f, 0.14613135f, 0.05046330f, 0.06402901f, 0.01946466f, -0.00355124f, 
    0.04335456f, 0.00369783f, 0.01832096f, -0.03567614f, -0.21949223f, -0.03307470f, -0.20108503f, -0.01200081f, 
    0.06958579f, -0.03869294f, -0.03663928f, -0.00326706f, -0.00209496f, 0.05760101f, 0.01273031f, -0.03369056f, 
    -0.18663006f, 0.06106144f, 0.03862663f, 0.15784842f, 0.09286527f, 0.01863612f, 0.00323874f, 0.11352666f, 
    0.01457153f, 0.09783354f, 0.06882300f, 0.08774356f, 0.04582384f, -0.01161160f, 0.00074934f, 0.14789124f, 
    0.15170987f, -0.00009540f, 0.00312359f, 0.02213094f, -0.02161249f, -0.10112528f, 0.09896503f, 0.15480775f, 
    -0.01829793f, -0.04911223f, 0.09914367f, 0.08308510f, 0.05920547f, -0.10745215f, 0.01473064f, -0.02584763f, 
    0.08669452f, 0.00392093f, 0.06640577f, -0.00666152f, -0.07894459f, 0.04502146f, -0.17943902f, 0.00873076f, 
    -0.07372235f, 0.00473437f, -0.10171036f, -0.11515781f, 0.01068349f, 0.11414301f, 0.02995622f, -0.10236705f, 
    0.02245914f, 0.24703164f, 0.02675565f, 0.17811197f, -0.01504814f, 0.02966475f, -0.04971412f, -0.00302127f, 
    -0.04542269f, 0.06986381f, 0.11610313f, 0.05491016f, 0.22335042f, 0.12671503f, 0.08105318f, 0.22303647f, 
    0.03204545f, -0.00063031f, 0.04489898f, 0.03781077f, 0.05366775f, 0.08829250f, 0.07188314f, 0.03725516f, 
    -0.11593129f, 0.03834676f, 0.03946410f, -0.09169033f, 0.04431671f, 0.00137977f, 0.02591930f, -0.08754230f, 
    -0.06731123f, 0.00658565f, 0.07977003f, -0.09446169f, -0.06006114f, 0.15881030f, -0.31682318f, 0.27149948f, 
    -0.03899908f, -0.07337963f, -0.02658513f, 0.01684760f, 0.04859452f, 0.08299697f, 0.04853532f, 0.02216069f, 
    0.12532780f, 0.24177322f, -0.21348925f, 0.06417404f, -0.07364213f, 0.11962215f, 0.03457304f, 0.08131755f, 
    -0.06678851f, 0.04604598f, 0.06613821f, -0.03989877f, -0.04348425f, 0.06193257f, 0.13887343f, 0.09414233f, 
    0.01555285f, 0.08769558f, -0.02322795f, 0.08215395f, 0.04019107f, -0.04687366f, 0.04702767f, 0.00162489f, 
    -0.20008203f, -0.08598416f, -0.15073040f, 0.06585310f, 0.07071991f, -0.01918334f, -0.02192505f, -0.00102272f, 
    0.02162014f, 0.00574460f, -0.09376459f, 0.02306535f, 0.09899387f, -0.12889427f, -0.15788174f, -0.04567979f, 
    -0.05128336f, -0.00286444f, 0.03076709f, 0.01143691f, 0.06715094f, 0.10741231f, 0.03324568f, 0.10890824f, 
    0.15825999f, -0.08907906f, 0.18686067f, 0.26100391f, 0.09808569f, 0.05668679f, 0.03915651f, 0.06555977f, 
    -0.03712982f, -0.03194027f, 0.02350309f, 0.12046450f, -0.19757453f, 0.12265837f, 0.10088404f, 0.08162026f, 
    0.05015774f, 0.12302610f, -0.01321416f, -0.07980546f, 0.04119499f, -0.02605371f, -0.02888279f, -0.09255777f, 
    -0.17820208f, 0.22812209f, 0.17716876f, 0.04221689f, 0.03210630f, -0.00172783f, 0.05754913f, -0.00825070f, 
    0.11176763f, 0.04656194f, -0.08748449f, -0.09344620f, -0.13788639f, -0.01263322f, -0.01118888f, -0.14661917f, 
    0.00155312f, 0.01284169f, 0.06127519f, 0.06787816f, -0.02892002f, 0.09084632f, 0.00009511f, 0.01801356f, 
    0.16041000f, -0.05838373f, -0.09238535f, 0.22213294f, 0.11309430f, 0.05142768f, 0.04582254f, -0.02919606f, 
    -0.06727619f, 0.01587536f, -0.01847976f, -0.03677507f, -0.22953482f, 0.02401169f, 0.08229525f, -0.07167535f, 
    0.02624781f, 0.00103648f, -0.06079841f, -0.12010565f, 0.00735692f, -0.05484450f, 0.02358087f, -0.05001741f, 
    -0.24927662f, -0.01281283f, 0.07160850f, 0.06141781f, 0.05016099f, 0.04004765f, -0.02578149f, -0.02525557f, 
    -0.04198162f, -0.07639352f, 0.08646670f, 0.00913751f, -0.03593967f, -0.04557269f, 0.11842464f, -0.06179343f, 
    0.06061571f, 0.00705712f, 0.00139812f, -0.08474048f, 0.05019678f, 0.00761727f, -0.08118372f, 0.01056977f, 
    0.15530965f, -0.18669948f, 0.08714885f, 0.03859469f, -0.01274305f, -0.02654937f, 0.01267270f, -0.00749431f, 
    0.07324254f, 0.07073483f, -0.02216391f, 0.02228539f, 0.12660806f, 0.28100374f, 0.13886689f, -0.30772078f, 
    0.01998940f, 0.02970244f, 0.06357157f, -0.11236278f, 0.00074683f, -0.03211703f, 0.05599613f, -0.10147835f, 
    0.08085071f, -0.09258321f, -0.07213110f, -0.02941491f, -0.00026136f, 0.00321355f, -0.02384626f, -0.06210611f, 
    -0.01071763f, 0.07909010f, 0.05315911f, -0.02977617f, 0.07852811f, -0.14791062f, 0.19770217f, 0.03849145f, 
    0.14327687f, -0.05594725f, 0.04059151f, -0.08323040f, 0.02682404f, 0.04700032f, 0.07108593f, 0.00429520f, 
    0.08605430f, -0.10919178f, -0.04639937f, 0.08954427f, 0.01196301f, 0.00549104f, -0.01489956f, -0.02985913f, 
    0.07697055f, 0.02644750f, 0.11550254f, -0.04235073f, -0.03503352f, 0.06618576f, 0.21424094f, 0.07149474f, 
    0.00807711f, 0.01411123f, 0.02024332f, 0.02904888f, -0.04143227f, 0.05129432f, 0.00020068f, -0.03464898f, 
    0.24516827f, 0.04271537f, -0.19920625f, -0.01116940f, -0.05374390f, -0.13563104f, 0.03313878f, 0.02154616f, 
    0.03329982f, -0.09656678f, -0.01054414f, 0.02914453f, 0.05637887f, 0.07975087f, 0.08188475f, 0.04879495f, 
    0.03553707f, 0.01451622f, 0.05659622f, 0.01117047f, 0.15403879f, -0.02388672f, 0.00354637f, -0.07919811f, 
    0.06221507f, 0.01744766f, 0.01354099f, -0.03638856f, 0.00463125f, 0.00131563f, -0.04369189f, -0.10415601f, 
    0.11620476f, -0.02650756f, -0.00491582f, -0.08790769f, 0.01009174f, -0.01159288f, -0.06051621f, 0.14599742f, 
    -0.00939691f, 0.00202334f, -0.00149864f, -0.03168377f, 0.05823558f, -0.09922902f, -0.01987011f, -0.06118048f, 
    0.18924907f, -0.09895746f, 0.06147030f, -0.11759046f, 0.13743414f, -0.02682651f, -0.02871237f, -0.11189789f, 
    0.00011719f, 0.10106641f, 0.01272376f, 0.07275096f, 0.26344362f, -0.19623861f, 0.11583814f, 0.06444005f, 
    -0.04569302f, -0.03391662f, -0.00366093f, -0.07317588f, -0.03158541f, -0.08217317f, -0.05714910f, -0.03093622f, 
    0.20579819f, 0.17340401f, -0.13205667f, 0.09622973f, -0.07906838f, 0.04523080f, -0.09903822f, -0.08005655f, 
    0.09392647f, 0.01256264f, -0.03173166f, 0.09316895f, 0.17900005f, -0.00256294f, 0.11325984f, 0.02621369f, 
    0.06586983f, -0.00719639f, 0.08304466f, 0.02386603f, -0.11788355f, 0.09946816f, 0.02383336f, 0.07305665f, 
    -0.17458057f, 0.03107565f, 0.11310308f, 0.16152041f, 0.04436135f, -0.02245205f, 0.04957867f, -0.00631959f, 
    -0.08212882f, 0.00655496f, 0.06870472f, 0.00805003f, 0.27121946f, -0.17600220f, 0.19939372f, -0.09592305f, 
    0.19885811f, -0.05791038f, 0.04794503f, -0.02113953f, 0.02648227f, -0.07754221f, -0.02735016f, 0.04951981f, 
    -0.19427922f, 0.10512722f, 0.03499912f, -0.02485779f, 0.08707573f, 0.08897106f, -0.04548396f, -0.12821516f, 
    0.09728503f, 0.06756649f, 0.04088936f, -0.03876244f, -0.12159459f, 0.37603119f, -0.13134785f, 0.02763354f, 
    0.07616618f, -0.05972333f, 0.05137757f, -0.04426727f, -0.00600093f, -0.01155489f, -0.02490734f, 0.02387216f, 
    -0.27445015f, -0.01412356f, 0.13246591f, 0.10143241f, 0.10396392f, 0.03266070f, -0.00052511f, -0.06032858f, 
    0.07618631f, -0.01564500f, 0.09693072f, -0.01617141f, 0.07609958f, -0.08533173f, 0.18550727f, -0.07901749f, 
    -0.07050151f, -0.01977462f, 0.05498906f, -0.00886560f, 0.05019501f, 0.07735255f, -0.02792097f, -0.07217554f, 
    0.10280452f, 0.17424048f, 0.19242367f, 0.16173698f, -0.04458012f, -0.07300675f, -0.04709072f, -0.07744671f, 
    0.12215804f, -0.04078854f, 0.00266120f, -0.00945993f, 0.11772148f, 0.18218660f, -0.09023090f, 0.14488816f, 
    0.00582358f, 0.07410646f, 0.01124696f, 0.02556859f, 0.00950470f, -0.03975534f, 0.02849406f, -0.04876836f, 
    -0.04429146f, 0.07707386f, 0.07756995f, -0.01795701f, 0.04480655f, 0.00856090f, 0.04336405f, 0.01413847f, 
    0.01734399f, -0.02902128f, -0.02540142f, 0.01531942f, -0.07914995f, 0.02520179f, 0.22561291f, -0.07129047f, 
    0.04263373f, -0.06974165f, 0.01918054f, -0.14773150f, -0.04366118f, 0.21031213f, -0.02833722f, 0.04238569f, 
    0.06562490f, 0.11104645f, -0.07636163f, 0.28881338f, 0.12101764f, 0.07845630f, 0.00689435f, 0.00760987f, 
    -0.02784102f, 0.10775556f, -0.07346860f, -0.03752311f, 0.46254399f, -0.24963838f, 0.27856818f, 0.12566184f, 
    0.04594952f, -0.07546475f, -0.07879503f, -0.04616553f, -0.02683312f, -0.08339063f, -0.02081680f, 0.10209603f, 
    -0.04080695f, -0.00287347f, -0.00512398f, -0.01112765f, 0.01861072f, 0.00174451f, -0.02729109f, -0.04004227f, 
    -0.03641200f, -0.02427600f, -0.03087970f, -0.03294222f, 0.00264661f, -0.03246962f, 0.00306479f, 0.00693187f, 
    0.02996667f, -0.00702687f, -0.01276586f, 0.00324704f, -0.01972744f, -0.01019094f, -0.00494306f, 0.02250580f, 
    0.01486441f, 0.00582777f, -0.03466559f, 0.03040705f, -0.03236758f, 0.00125441f, -0.00728097f, -0.02403125f, 
    -0.01437973f, -0.01077669f, -0.00289826f, -0.02342408f, -0.03119333f, -0.04115630f, 0.01840095f, 0.01485904f, 
    0.01133307f, -0.01737748f, -0.01613562f, 0.00133353f, -0.03587713f, 0.00714393f, -0.01110326f, -0.01633919f, 
    0.02239545f, -0.02818337f, -0.02417109f, -0.02362343f, 0.01615003f, -0.04035893f, 0.01302098f, -0.03218376f, 
    -0.00935274f, 0.01117016f, -0.04106806f, -0.03157755f, -0.00680754f, -0.03582369f, -0.02312982f, -0.03807887f, 
    -0.00177803f, 0.00388868f, -0.03306609f, -0.02185072f, -0.03019702f, -0.03793051f, 0.02843713f, -0.03566428f, 
    -0.00762664f, -0.01054666f, -0.00023483f, -0.00391327f, -0.02074555f, -0.02415891f, -0.00355072f, -0.02767276f, 
    -0.00538149f, -0.02605585f, 0.01754252f, -0.02133403f, 0.01689245f, 0.02385022f, -0.02453949f, 0.00683466f, 
    0.00004952f, 0.01026879f, -0.02497307f, -0.03446216f, -0.01290808f, 0.01870192f, 0.00856746f, -0.01913736f, 
    -0.02036551f, -0.00851893f, -0.01084274f, 0.01154052f, -0.03582482f, -0.03232885f, 0.00092987f, -0.00914502f, 
    -0.02587152f, 0.01132516f, 0.00324622f, 0.02946078f, -0.01842725f, 0.01729706f, -0.03501756f, 0.01879651f, 
    -0.03826341f, -0.02234514f, -0.00867622f, -0.00490539f, -0.02937794f, -0.02624906f, -0.02157721f, 0.01600734f, 
    0.01167458f, 0.02283047f, 0.02598334f, -0.03202865f, 0.02439386f, 0.00698289f, 0.01517646f, -0.03780446f, 
    -0.03011497f, 0.01055042f, 0.01836852f, 0.00621332f, 0.00163923f, -0.04098300f, -0.00736182f, -0.02462629f, 
    -0.00116278f, -0.03315922f, -0.02558956f, -0.00342456f, 0.00839598f, 0.01626569f, -0.04075510f, -0.02803661f, 
    -0.02265611f, -0.01139615f, 0.00019070f, -0.01505661f, 0.00697568f, 0.03073616f, -0.03832785f, -0.01861896f, 
    -0.01549419f, -0.03431636f, -0.02342029f, -0.02130117f, -0.02011527f, -0.03391824f, 0.02858597f, -0.01833498f, 
    -0.02345525f, -0.02498667f, -0.01091598f, -0.01889636f, -0.03338296f, 0.01494370f, 0.01538613f, 0.00262927f, 
    0.01652235f, 0.02443221f, 0.02285376f, -0.01865885f, 0.02207840f, 0.02416421f, -0.00080278f, 0.01784915f, 
    0.02582349f, -0.02196478f, 0.02830928f, 0.02660945f, -0.01811247f, -0.00095483f, -0.01147270f, -0.02255083f, 
    -0.03603585f, 0.02320050f, -0.02530327f, 0.01593617f, -0.00623441f, 0.02355255f, 0.01304969f, 0.02665825f, 
    0.03024034f, 0.00771888f, 0.03480937f, -0.00460140f, -0.01637039f, 0.01736772f, 0.00543602f, 0.01337003f, 
    -0.02589320f, 0.00946417f, 0.00051764f, 0.01444595f, -0.02262458f, 0.00020912f, -0.01645782f, 0.01798288f, 
    0.02571135f, 0.02352672f, -0.01597504f, -0.02659469f, 0.02284282f, 0.02785254f, 0.02176637f, -0.03002352f, 
    -0.00443709f, -0.03760476f, -0.01406194f, -0.02712254f, 0.00105801f, -0.03567800f, -0.01890774f, 0.02555638f, 
    0.00964631f, -0.01006358f, -0.03881202f, -0.01844777f, 0.00846971f, 0.01062058f, -0.01339466f, 0.01723783f, 
    -0.01146773f, 0.01460859f, -0.03482802f, 0.02802995f, -0.02150295f, -0.03851251f, -0.00024963f, 0.00197261f, 
    0.02448287f, 0.02556026f, 0.00932994f, -0.01481017f, 0.00672670f, 0.02061151f, -0.01627976f, -0.03111239f, 
    0.03019430f, 0.02511485f, -0.03067533f, -0.00100829f, -0.00655089f, -0.00502940f, -0.03255650f, 0.00565674f, 
    -0.02248623f, -0.01222600f, -0.03466925f, 0.00212780f, -0.00530196f, 0.01059680f, -0.00752739f, -0.03330217f, 
    -0.02894302f, -0.00404759f, -0.01314476f, -0.03669766f, -0.01243020f, 0.01568438f, -0.01056749f, 0.01505404f, 
    -0.00734646f, 0.00798069f, -0.00569565f, 0.00500771f, -0.03976455f, 0.00865991f, 0.01375851f, -0.03736518f, 
    -0.00632647f, -0.02042857f, -0.00010067f, 0.02789847f, -0.03979550f, -0.03247536f, 0.01923936f, 0.02062359f, 
    0.02628508f, -0.00985040f, 0.00556905f, -0.02918187f, -0.01874441f, -0.00137086f, 0.00330711f, -0.03195677f, 
    -0.01686123f, 0.00247304f, -0.02419601f, 0.00438389f, 0.00377306f, -0.03542372f, -0.00587287f, 0.01165756f, 
    -0.00392223f, 0.02998066f, -0.00037633f, 0.00122179f, -0.03274482f, -0.03252872f, -0.02658470f, 0.02708390f, 
    0.02383836f, 0.01747219f, -0.01499723f, -0.01853871f, -0.01514829f, 0.01729303f, 0.02012499f, 0.00018286f, 
    -0.00847169f, 0.00734763f, -0.01949281f, -0.01276378f, -0.03783895f, 0.02877405f, 0.02169950f, 0.02909232f, 
    -0.03318610f, -0.01302544f, -0.03375548f, -0.00805500f, 0.00397599f, -0.02268482f, -0.03818579f, 0.01725125f, 
    0.02524396f, 0.00598273f, -0.00689475f, 0.03172759f, 0.00394304f, 0.01140937f, 0.01628830f, -0.00490298f, 
    -0.00254439f, -0.03095089f, 0.00808910f, -0.01841648f, 0.00052833f, 0.02004983f, -0.00344879f, 0.01214134f, 
    0.01400947f, -0.02998608f, -0.03847067f, -0.01482601f, 0.01932634f, -0.01929722f, 0.01253880f, 0.02349368f, 
    0.02331880f, -0.03738020f, -0.01921159f, -0.00898652f, -0.02930543f, -0.01620387f, -0.03394777f, -0.01053016f, 
    0.01848754f, 0.02825361f, -0.03020381f, -0.01358331f, -0.02511817f, -0.00332122f, 0.00140549f, 0.00332305f, 
    -0.01509779f, 0.02396407f, 0.00733229f, -0.00660454f, -0.02402100f, -0.04025132f, -0.02051512f, 0.02170019f, 
    0.01332717f, 0.01237286f, -0.01795813f, 0.01483502f, -0.01960351f, -0.02285523f, 0.00529908f, 0.02350337f, 
    0.00529473f, 0.01543043f, -0.00922935f, 0.01003888f, 0.01990969f, -0.01719004f, 0.02240908f, -0.01483244f, 
    0.01238708f, 0.01460606f, 0.02517460f, -0.01049844f, 0.00259349f, 0.01641087f, 0.02265650f, -0.01753715f, 
    -0.01036588f, 0.01216175f, 0.02941779f, -0.00372216f, -0.03725650f, 0.02173290f, -0.02869629f, -0.01825022f, 
    -0.02616674f, 0.01856199f, 0.01102969f, -0.03362859f, -0.03178044f, 0.02095033f, -0.03908670f, 0.02523167f, 
    0.01835544f, -0.00704218f, -0.02681119f, 0.01299146f, -0.03951541f, 0.00754794f, 0.00663040f, -0.01799944f, 
    0.00014462f, -0.00507699f, -0.03630125f, 0.00931007f, 0.02800347f, 0.02138962f, -0.00486585f, -0.02599108f, 
    -0.01900144f, 0.02595612f, 0.00108296f, 0.01896798f, 0.01555278f, 0.01360075f, -0.02492372f, 0.01184317f, 
    -0.01551051f, -0.02993970f, 0.00284583f, -0.00880626f, -0.03509894f, -0.00621440f, -0.03780280f, 0.02112318f, 
    -0.03355045f, 0.00958516f, 0.00230841f, 0.01652591f, -0.01358900f, 0.00392299f, -0.01280561f, 0.00125613f, 
    -0.01795881f, 0.01569251f, 0.02615765f, -0.02066499f, -0.00465561f, 0.02860192f, 0.01521225f, 0.00832596f, 
    -0.02301504f, -0.01252977f, -0.01508558f, -0.02375517f, -0.02875073f, 0.02274335f, -0.00834686f, -0.03719553f, 
    -0.01685252f, -0.02034132f, 0.00273326f, -0.01359958f, 0.00294314f, -0.03428483f, 0.03028920f, 0.02448020f, 
    -0.01524697f, -0.00679508f, -0.01292599f, 0.01076848f, 0.02467938f, -0.02279339f, 0.00757621f, -0.02854783f, 
    -0.03624198f, 0.01691122f, -0.00903568f, -0.02942090f, 0.03217595f, -0.01825083f, 0.03231181f, 0.00994004f, 
    -0.01942062f, -0.03764864f, 0.02784746f, 0.02411227f, 0.02458232f, 0.02787871f, -0.02691980f, -0.03144415f, 
    -0.02996700f, 0.01898229f, -0.01689703f, 0.01648826f, 0.00566424f, 0.00754709f, -0.03476297f, 0.01267224f, 
    -0.02302494f, -0.03135112f, -0.03788211f, 0.00202951f, 0.01551573f, 0.00111628f, -0.02305966f, -0.02027003f, 
    0.00667059f, 0.01114839f, -0.02864130f, 0.03091281f, 0.01372603f, 0.00647688f, 0.00748543f, 0.01994482f, 
    -0.01029187f, -0.03426803f, 0.02913235f, -0.03338776f, -0.00846674f, -0.01858097f, 0.01720080f, -0.03501556f, 
    -0.01192684f, -0.03869557f, -0.01495823f, -0.01754309f, 0.01113777f, -0.02881483f, 0.02565457f, 0.02985339f, 
    -0.00449657f, 0.02735505f, -0.02734241f, 0.00861375f, 0.02120325f, 0.01378562f, -0.02336291f, 0.01314301f, 
    -0.03122523f, -0.00045806f, 0.01886004f, 0.00354704f, 0.02979702f, 0.00521351f, -0.00436358f, -0.01416678f, 
    0.01744069f, 0.02113591f, -0.02817660f, -0.03685960f, 0.03003436f, -0.02413089f, 0.02410886f, -0.01742738f, 
    -0.03833664f, 0.00663296f, 0.00425735f, 0.00448113f, -0.03943024f, 0.00533071f, -0.00345038f, -0.02715240f, 
    -0.03521179f, -0.00580382f, 0.01787770f, -0.04031262f, -0.01396071f, -0.02979857f, 0.01280334f, -0.00147331f, 
    -0.03299817f, -0.02911491f, -0.03890648f, -0.00240652f, 0.02876699f, -0.02611891f, -0.00288653f, 0.00778205f, 
    -0.02440762f, 0.02865009f, -0.03087112f, -0.03262676f, -0.01225670f, -0.01424086f, -0.00348024f, -0.01511516f, 
    0.02460350f, -0.03952111f, -0.02820856f, -0.02046912f, 0.01966388f, -0.03126834f, -0.00655454f, -0.02634572f, 
    0.02600241f, 0.02472715f, 0.01428841f, 0.02920085f, 0.02342055f, 0.01049909f, 0.00681248f, 0.00474814f, 
    -0.03507700f, 0.02802680f, -0.01574051f, 0.01266621f, 0.01911366f, -0.00034146f, -0.00499511f, -0.00321461f, 
    0.01869772f, 0.00909607f, 0.00764643f, 0.01596038f, 0.02669337f, -0.02624466f, 0.02241417f, -0.03469944f, 
    0.02543321f, -0.00876853f, -0.03832530f, 0.03039414f, -0.02246078f, 0.02934110f, 0.00802498f, -0.03511592f, 
    -0.02975417f, 0.00929762f, -0.00247228f, 0.00824508f, 0.02211783f, -0.02999071f, -0.01078409f, -0.03519208f, 
    -0.01557897f, -0.02275717f, 0.03035446f, 0.01510206f, 0.02378667f, -0.04023430f, -0.03526015f, 0.02013217f, 
    -0.01199994f, 0.00361196f, -0.00868760f, 0.02830734f, -0.01668196f, -0.01004050f, -0.03936030f, 0.02912145f, 
    0.01779080f, -0.02347188f, -0.01451289f, -0.01745605f, 0.01524313f, -0.02923825f, -0.04025993f, -0.03779288f, 
    0.03076256f, 0.01772905f, -0.00683355f, -0.01886115f, -0.03649909f, 0.00074858f, -0.01233554f, -0.02543746f, 
    0.01209366f, -0.03238384f, 0.01776359f, 0.02911998f, -0.00973314f, 0.01632762f, -0.01146969f, 0.01246181f, 
    0.01596545f, -0.00361464f, -0.03328294f, -0.02690965f, -0.02518106f, 0.01547514f, 0.02666483f, -0.01124179f, 
    0.00400110f, -0.00010293f, 0.02492107f, -0.00906415f, 0.02473218f, 0.00570235f, 0.01736052f, -0.03315127f, 
    0.02147221f, 0.02269096f, -0.03937181f, -0.02889273f, 0.02703459f, -0.02208312f, -0.00015145f, -0.03231412f, 
    -0.02793347f, -0.01212565f, 0.03146828f, -0.01370290f, 0.03201926f, -0.02925909f, -0.00106494f, -0.02982741f, 
    0.00377479f, 0.01882624f, -0.02531688f, -0.02760416f, -0.00372152f, -0.02348479f, 0.02965287f, 0.00121413f, 
    0.01746500f, 0.00516389f, -0.02728673f, 0.02818852f, -0.02403545f, 0.00859008f, -0.00897769f, 0.00937617f, 
    -0.03249545f, 0.02288010f, 0.01779461f, -0.01032045f, 0.02166646f, 0.00011628f, -0.01059179f, 0.00333460f, 
    -0.02209159f, 0.01580508f, 0.00196319f, 0.01910105f, 0.02058041f, 0.00526349f, -0.00007371f, -0.01196311f, 
    -0.03540254f, 0.02541288f, -0.00150613f, 0.02226523f, 0.00903599f, 0.01705467f, -0.02174187f, -0.03501281f, 
    -0.03140311f, -0.03471929f, -0.00493591f, 0.02442954f, 0.02774924f, 0.01432987f, -0.01403937f, 0.01420211f, 
    -0.03221861f, -0.03199399f, 0.01396386f, -0.01765892f, -0.00935447f, 0.00680860f, 0.00208783f, -0.00126939f, 
    0.00744850f, 0.00893761f, -0.04072811f, -0.02552953f, -0.02674536f, -0.01580852f, -0.02469751f, -0.04243746f, 
    0.02771556f, 0.01483362f, 0.01112158f, 0.03337885f, 0.00481313f, -0.01558994f, -0.03820994f, -0.02388619f, 
    -0.01907903f, -0.03866697f, -0.00473553f, -0.02202647f, -0.02403043f, 0.01769193f, -0.00672580f, 0.01675986f, 
    -0.00318531f, 0.00134229f, -0.01801042f, 0.01277232f, 0.02598569f, 0.02109089f, -0.00535595f, 0.01893983f, 
    -0.02447069f, 0.02527512f, 0.03536805f, 0.01426640f, -0.02636226f, 0.01504074f, -0.03365001f, -0.02941117f, 
    -0.02624338f, 0.00886114f, -0.00305098f, 0.01936972f, -0.00280509f, -0.01949441f, 0.01440664f, -0.01681925f, 
    -0.01461937f, -0.00982990f, -0.03719364f, 0.02801155f, 0.01350669f, -0.00269323f, -0.00050283f, 0.00159147f, 
    -0.02152722f, 0.01320808f, 0.01089368f, -0.00845488f, -0.02655362f, -0.00634816f, 0.02091649f, -0.03553504f, 
    0.01481745f, -0.04116175f, -0.03070703f, 0.02474758f, -0.00171774f, 0.02342024f, 0.00258802f, 0.01323761f, 
    -0.01151379f, -0.01320668f, 0.02374106f, 0.01340119f, -0.04190918f, -0.01114074f, 0.02980478f, -0.00398564f, 
    -0.03024163f, -0.02922363f, -0.00028493f, 0.01600067f, -0.01881483f, 0.00999627f, -0.03688384f, 0.00520081f, 
    -0.01977832f, -0.01595809f, -0.01744740f, -0.02395192f, -0.02597165f, 0.00048754f, -0.03464377f, -0.02677198f, 
    -0.02336370f, -0.02150583f, -0.02783566f, 0.02445211f, -0.00745288f, 0.01910388f, 0.00282559f, -0.01256573f, 
    0.01502505f, -0.02471011f, -0.03155890f, -0.00648130f, -0.02472445f, -0.02399524f, 0.02616791f, 0.01688680f, 
    0.01629049f, -0.00498476f, -0.03407227f, -0.02333980f, 0.02631038f, 0.02595916f, 0.02350470f, -0.00692186f, 
    -0.03835208f, 0.02581637f, 0.02016755f, 0.00637434f, -0.00644756f, -0.00243373f, 0.02130224f, -0.01352103f, 
    -0.01573934f, -0.02491178f, 0.00244148f, -0.02204456f, 0.01883593f, 0.02191663f, 0.00040070f, -0.01362102f, 
    0.00013625f, 0.00386411f, 0.01772497f, 0.02258258f, -0.01363080f, 0.00115152f, -0.02243096f, 0.02976238f, 
    0.02377319f, 0.00542891f, 0.00729774f, 0.02796993f, 0.02642434f, -0.02822607f, -0.00047020f, 0.03016733f, 
    0.01120456f, 0.01461675f, 0.00081698f, -0.00592464f, 0.00557627f, 0.02571479f, -0.00164467f, 0.02532671f, 
    -0.01282153f, -0.00013671f, -0.00843696f, -0.03934246f, 0.00921860f, -0.01117671f, -0.03903842f, -0.03007799f, 
    -0.01934494f, 0.01365450f, -0.00573029f, 0.02875437f, -0.00584782f, 0.01861239f, 0.02353657f, -0.03252936f, 
    -0.02415991f, -0.02619804f, 0.02817862f, -0.01509878f, 0.01759575f, -0.02226664f, -0.02483848f, 0.00861475f, 
    0.02358911f, -0.00855891f, -0.01890696f, -0.00222157f, -0.02042259f, -0.02607259f, -0.01160037f, -0.01309815f, 
    -0.03869805f, 0.00904576f, -0.02319704f, -0.00461230f, 0.01942823f, 0.02570620f, -0.04222405f, -0.02232024f, 
    -0.04147507f, -0.02801798f, -0.01964477f, 0.00901505f, -0.01484360f, 0.02850690f, -0.00043773f, -0.03979281f, 
    -0.00796766f, -0.04042632f, 0.00733955f, -0.03434912f, -0.03815892f, 0.00803777f, -0.00373674f, 0.02915581f, 
    -0.02534011f, -0.02276029f, -0.02619498f, 0.00392594f, 0.01775967f, 0.01461986f, -0.03593399f, 0.01838611f, 
    -0.02608289f, -0.00750692f, -0.00499769f, 0.00763497f, -0.02074083f, 0.00842666f, -0.01874244f, -0.03751494f, 
    -0.03812519f, 0.02898377f, 0.01532420f, 0.00699783f, 0.02198442f, 0.02827887f, -0.02613193f, -0.04026344f, 
    -0.00222399f, 0.02105167f, 0.02845392f, -0.02841539f, -0.03564985f, 0.02409191f, 0.00774041f, 0.03036881f, 
    -0.02775517f, 0.02140011f, -0.03145217f, 0.00172883f, 0.02182715f, -0.03880757f, 0.00449008f, 0.01265119f, 
    0.02864636f, -0.03430239f, 0.00239693f, -0.01734245f, -0.04090028f, 0.01614149f, -0.00844201f, 0.01578176f, 
    0.01314932f, 0.01308581f, 0.01508155f, -0.03172754f, 0.02461528f, -0.00568899f, -0.00676082f, -0.02739022f, 
    -0.02126785f, 0.02408955f, -0.02942871f, 0.01646166f, 0.01317105f, -0.00567412f, 0.02298079f, 0.01267208f, 
    0.02837197f, 0.02236344f, -0.03475934f, -0.03603253f, -0.00718908f, 0.00544036f, -0.00333314f, 0.02528477f, 
    -0.03308422f, -0.03704169f, 0.02173503f, -0.02873328f, -0.01309793f, -0.04170517f, 0.01489356f, -0.02917948f, 
    0.02592246f, -0.00878266f, -0.03782928f, 0.02530762f, 0.01236811f, -0.03260387f, -0.02780652f, -0.01869718f, 
    -0.00295870f, -0.00038614f, 0.02472547f, 0.01358050f, 0.00138573f, 0.02350010f, -0.03443166f, 0.02921045f, 
    -0.02076711f, -0.03770772f, 0.02566842f, -0.03707736f, -0.02540194f, 0.02797658f, -0.03387568f, -0.01701898f, 
    -0.00806374f, -0.01512202f, -0.00636207f, 0.01607185f, -0.01323495f, -0.02011916f, -0.02799813f, -0.01155932f, 
    -0.00429076f, 0.01626448f, -0.04058432f, -0.01197426f, 0.01227043f, -0.02959447f, -0.03170639f, 0.02620356f, 
    -0.00327541f, -0.02467323f, -0.03364890f, 0.00589681f, 0.00692093f, -0.03369467f, -0.00434290f, -0.03956936f, 
    0.03018690f, -0.03472855f, -0.02818550f, 0.00726505f, 0.02535496f, -0.01479227f, 0.01751408f, -0.00981983f, 
    -0.01668370f, -0.00790299f, 0.00490169f, 0.00977506f, -0.02607072f, -0.01364011f, 0.02012680f, -0.03908826f, 
    -0.03613357f, -0.01597980f, -0.02145533f, -0.02275565f, -0.03476629f, -0.00443893f, -0.00716342f, 0.02048563f, 
    0.01960929f, -0.02485989f, -0.02788967f, 0.00925690f, -0.01612049f, -0.03685981f, -0.01676876f, -0.02572579f, 
    -0.03512836f, 0.00524890f, 0.02472092f, -0.01948569f, -0.01754084f, 0.01401036f, 0.00800957f, -0.02569873f, 
    -0.00505635f, -0.02232710f, 0.01069999f, 0.00256818f, -0.00435330f, 0.01080456f, -0.04154084f, -0.03088314f, 
    -0.03908104f, 0.02003074f, -0.04071275f, -0.02743355f, 0.02220152f, 0.01638093f, 0.02576882f, -0.01533154f, 
    0.03616406f, 0.01491984f, 0.01996800f, 0.00598416f, -0.02644432f, -0.03782251f, -0.01682007f, 0.02845831f, 
    -0.03663889f, -0.01207663f, 0.00549998f, -0.02896523f, 0.02270481f, 0.00217689f, -0.04005922f, 0.00414351f, 
    0.01496498f, -0.01758828f, 0.02060544f, 0.03335642f, -0.01653761f, 0.00370210f, 0.01764607f, -0.00926735f, 
    0.02412659f, 0.01010978f, -0.00480416f, 0.00614393f, -0.01059644f, 0.03048454f, 0.00389634f, -0.00772260f, 
    0.00253570f, -0.00891791f, -0.02258541f, -0.00941301f, 0.02041798f, -0.00541822f, -0.00970236f, -0.01245285f, 
    -0.02530614f, -0.03605208f, -0.00024895f, -0.01508818f, 0.00516409f, -0.02951342f, -0.01201668f, -0.00977109f, 
    0.02929599f, 0.01356234f, -0.04058902f, 0.01322704f, -0.01645064f, 0.02734000f, -0.02346924f, -0.01350429f, 
    0.01998519f, 0.03048417f, -0.01924567f, -0.01046478f, 0.01660475f, -0.01611071f, -0.01381278f, -0.03974760f, 
    0.00626956f, -0.02141388f, -0.02240732f, -0.00694825f, 0.01650112f, -0.03463031f, 0.01346032f, -0.01241537f, 
    -0.01672530f, -0.03982211f, 0.01875452f, 0.01669830f, -0.02916176f, 0.01671143f, -0.02034408f, 0.01336269f, 
    -0.00758794f, -0.01658386f, 0.02064786f, 0.01363057f, -0.01931488f, 0.01143133f, 0.00730897f, -0.01975450f, 
    0.01570156f, -0.02894931f, -0.00812983f, -0.03127166f, -0.00406128f, 0.04543887f, -0.01636476f, -0.02409774f, 
    0.01034102f, -0.02822933f, -0.01387976f, 0.00717063f, -0.04439295f, 0.02308616f, 0.01163292f, -0.01073617f, 
    -0.03254382f, -0.03753166f, -0.03944670f, 0.02641739f, -0.02154182f, -0.03406895f, -0.03430261f, -0.02031893f, 
    -0.04298855f, -0.02183685f, -0.01709056f, -0.03789137f, -0.03557973f, -0.03366233f, 0.00510977f, -0.02564232f, 
    -0.03987861f, -0.02970621f, -0.02188335f, -0.00180518f, 0.01369618f, 0.01919806f, -0.02835799f, -0.01982458f, 
    -0.02237236f, 0.02868930f, -0.03878176f, 0.01907060f, 0.01820698f, -0.02023418f, -0.03570511f, -0.01312384f, 
    -0.03460615f, -0.01162114f, 0.01491883f, 0.03240914f, 0.01250101f, -0.00267179f, -0.03006253f, -0.01789567f, 
    -0.00588481f, -0.03604070f, -0.01222771f, 0.02608938f, -0.00868953f, -0.01328762f, 0.02432287f, 0.00498351f, 
    0.02049508f, 0.02660796f, 0.02662306f, -0.02727644f, -0.02961081f, 0.01633965f, 0.01685113f, 0.01333570f, 
    -0.02793805f, 0.02472127f, 0.01972315f, -0.00547061f, -0.01884278f, -0.00327646f, -0.01354112f, -0.01060928f, 
    -0.00595778f, -0.00022439f, -0.03001331f, -0.03130098f, -0.01569164f, 0.01404406f, -0.00605426f, 0.02041700f, 
    0.02453675f, 0.00263105f, -0.00259341f, 0.02608626f, 0.01281467f, -0.03598067f, 0.02401630f, -0.00848492f, 
    -0.02952992f, 0.00269061f, 0.00406588f, 0.01623648f, 0.02410328f, 0.02638437f, -0.01476059f, -0.03921124f, 
    0.01198744f, 0.02295545f, -0.03895435f, -0.00989712f, -0.03611072f, -0.03798341f, -0.00010822f, -0.01147941f, 
    -0.01097714f, 0.02070084f, 0.01936445f, -0.02088125f, 0.00211246f, -0.02998576f, -0.03232716f, 0.01884490f, 
    -0.03156126f, 0.02637591f, -0.01006444f, -0.01592957f, -0.02293120f, 0.00075418f, -0.01741035f, -0.04118876f, 
    -0.01159629f, 0.00701816f, -0.02785537f, 0.00724174f, 0.01795847f, -0.02162461f, -0.00267811f, 0.01504505f, 
    0.00234661f, -0.02170229f, -0.02093900f, -0.00522143f, -0.00922437f, -0.03782253f, 0.01688254f, -0.02652017f, 
    0.00904877f, 0.02661840f, -0.00812986f, -0.00995776f, -0.02975337f, 0.01054017f, 0.02306642f, -0.01391979f, 
    -0.01989473f, 0.02533350f, -0.01218194f, 0.02219568f, -0.03830460f, -0.02466158f, 0.00337882f, -0.00250059f, 
    -0.02856273f, -0.00362038f, -0.02573125f, 0.01106482f, -0.00468737f, -0.00216484f, -0.04111331f, 0.02896903f, 
    -0.02970134f, -0.03155803f, 0.02361110f, 0.00093922f, 0.00252839f, 0.01535549f, -0.02043638f, -0.02434408f, 
    -0.00420761f, -0.04117154f, -0.01479789f, -0.01188677f, -0.01979498f, 0.01725854f, -0.01986447f, -0.02992314f, 
    0.02625829f, -0.01999771f, -0.03694526f, 0.00606497f, -0.03778287f, -0.02557096f, -0.00289697f, -0.01205907f, 
    -0.02653218f, 0.00303743f, -0.03573294f, 0.02509076f, -0.01150063f, -0.00965118f, 0.02990195f, -0.00170730f, 
    -0.00787332f, -0.02475668f, 0.00856117f, -0.02975469f, 0.00120961f, -0.00518297f, 0.00687198f, -0.00624703f, 
    -0.01518085f, -0.03355023f, -0.02450559f, 0.02332488f, 0.02293480f, -0.03235038f, -0.00678974f, 0.00245856f, 
    -0.00017667f, -0.02472799f, 0.00494853f, -0.02033392f, -0.03055800f, -0.01015502f, -0.01011648f, -0.04000501f, 
    0.03011277f, -0.03093006f, 0.00003309f, 0.00771346f, 0.02894930f, 0.02551557f, -0.03431242f, 0.01234452f, 
    -0.00367747f, -0.04131043f, 0.01715186f, -0.00193689f, 0.00754562f, -0.03377851f, 0.00036849f, 0.01988031f, 
    0.00016095f, 0.00025785f, -0.00819659f, -0.00789446f, 0.01617126f, 0.01093128f, 0.01618657f, -0.02268080f, 
    -0.01011111f, 0.00955559f, -0.03364126f, 0.00171212f, 0.03192978f, -0.03950215f, 0.00729744f, -0.00114753f, 
    0.02657014f, 0.00334591f, -0.01487014f, 0.01864352f, -0.00908946f, -0.03017005f, 0.02652870f, 0.01925663f, 
    -0.03875375f, -0.04361988f, -0.03397294f, -0.00495511f, -0.02916133f, -0.05152642f, 0.00252267f, 0.01408950f, 
    0.01291183f, -0.04452669f, 0.00160462f, -0.01842300f, 0.01455726f, -0.03744402f, -0.00472952f, -0.04188210f, 
    0.00395655f, 0.02212367f, -0.03416227f, 0.00127341f, -0.03899523f, 0.02020987f, 0.01024905f, -0.03309015f, 
    0.02551748f, -0.02785988f, -0.01691120f, 0.01183876f, -0.03746971f, 0.01644963f, 0.00975802f, -0.01753156f, 
    0.00929967f, -0.01517659f, 0.01264852f, -0.03005988f, -0.01778427f, 0.01300591f, -0.01114722f, 0.00733913f, 
    -0.01545712f, 0.02536116f, -0.00043130f, -0.02985926f, -0.00486716f, -0.04094111f, 0.02690308f, 0.00363451f, 
    -0.04632276f, -0.04480154f, -0.01514143f, 0.01825300f, -0.00408220f, -0.03218576f, 0.00629750f, 0.01361949f, 
    0.00646568f, -0.02961634f, -0.02273063f, -0.00500812f, 0.00627009f, 0.03189240f, -0.01083484f, -0.03469374f, 
    -0.04501077f, 0.00315469f, -0.03472634f, 0.00407127f, 0.00848858f, -0.02067848f, -0.01383881f, -0.00427610f, 
    -0.04602491f, -0.03644926f, -0.00804513f, -0.02959331f, 0.00305244f, 0.01645841f, -0.01750692f, 0.01591082f, 
    -0.01756913f, -0.05319369f, 0.01031828f, 0.00762478f, -0.03649376f, -0.03533215f, 0.01435141f, 0.01553777f, 
    -0.04043511f, 0.00532643f, 0.01290864f, -0.03454362f, 0.00305029f, -0.02006241f, 0.01109620f, 0.00941012f, 
    -0.00653706f, 0.01065062f, -0.02060679f, -0.02764693f, -0.01488825f, -0.02870878f, -0.01710542f, -0.03660820f, 
    -0.03603517f, 0.01546311f, -0.01015208f, -0.01773162f, -0.02223320f, 0.02133543f, 0.00647215f, -0.04287957f, 
    -0.04324382f, -0.00715518f, 0.00553897f, -0.04741254f, -0.03054396f, -0.04054938f, 0.01299751f, -0.00735859f, 
    0.01686900f, -0.00096462f, -0.04194913f, -0.01936682f, -0.02049186f, 0.00459098f, 0.00575597f, -0.03720672f, 
    -0.02601182f, -0.03152504f, 0.00187545f, 0.01742769f, -0.01999616f, -0.04969599f, -0.03598760f, 0.02939825f, 
    -0.01732218f, 0.01378567f, -0.03591541f, -0.03760973f, -0.01345341f, -0.03518330f, -0.04695605f, -0.01036554f, 
    -0.02410501f, -0.02721400f, -0.01181527f, -0.00393621f, -0.03239335f, 0.01278371f, 0.00837277f, 0.00114974f, 
    -0.03820881f, -0.01012008f, -0.04307420f, -0.04417165f, 0.01217298f, -0.03003685f, -0.02259555f, 0.02624053f, 
    -0.02183943f, 0.01965882f, 0.00220985f, -0.04583060f, -0.00529097f, 0.00058664f, -0.00590480f, -0.01332962f, 
    -0.04997463f, -0.01970608f, -0.02169577f, -0.03913206f, -0.04774051f, -0.04052064f, 0.01709804f, -0.02062928f, 
    0.00391509f, -0.00299243f, 0.01125113f, -0.00820562f, 0.00674611f, -0.02094952f, 0.01450637f, -0.03070044f, 
    -0.01918477f, -0.03354330f, 0.01552221f, 0.00762604f, -0.02040563f, 0.00019387f, -0.03623183f, -0.02534045f, 
    0.00062629f, -0.03683149f, -0.02669948f, 0.03644225f, -0.00697912f, 0.00888737f, -0.03927587f, 0.02284948f, 
    -0.02931513f, -0.05103841f, -0.02358149f, -0.02958367f, -0.04938104f, 0.01558008f, -0.04788289f, 0.03233445f, 
    0.03546460f, -0.00068459f, 0.01091304f, -0.02616392f, 0.00135525f, -0.00161100f, -0.02010028f, 0.03016036f, 
    -0.01905878f, 0.00177088f, -0.02721520f, -0.02912252f, -0.03578642f, -0.04803249f, -0.00447421f, 0.02103860f, 
    0.02288424f, -0.04116623f, -0.00893490f, -0.02851034f, 0.01216723f, -0.02049377f, -0.04089969f, -0.02540007f, 
    0.01324812f, -0.04152032f, -0.02894691f, -0.02715548f, -0.03152416f, -0.03070291f, -0.04009497f, -0.00452027f, 
    -0.03113811f, -0.03604788f, -0.00327689f, -0.01804355f, -0.02671806f, 0.01645838f, -0.01396873f, -0.04401059f, 
    -0.04390062f, -0.03297100f, 0.01726813f, 0.02591442f, -0.01372737f, -0.03633656f, -0.00366157f, -0.01292168f, 
    0.01690326f, 0.01869711f, -0.04540776f, -0.04781476f, -0.02973496f, -0.01300901f, -0.01373833f, -0.00442646f, 
    -0.03588709f, -0.02244682f, 0.02493216f, -0.02105743f, -0.03658337f, 0.00360474f, -0.01223591f, -0.01023584f, 
    -0.04453079f, -0.04025541f, -0.00116531f, -0.03386593f, 0.02554121f, -0.03329591f, -0.04683138f, 0.02687777f, 
    -0.00989552f, 0.01883957f, 0.00644905f, -0.00663332f, 0.01318281f, -0.02318989f, 0.01245514f, 0.00065945f, 
    -0.02491224f, -0.01195096f, -0.04811083f, 0.03804782f, 0.02047521f, 0.02439789f, -0.02753780f, -0.04220522f, 
    -0.03796869f, 0.02609987f, -0.02802905f, -0.02816017f, -0.03101774f, -0.02129526f, 0.00655037f, -0.03493966f, 
    0.00200585f, -0.01728176f, -0.01280084f, -0.03801679f, 0.00825500f, -0.04778164f, -0.03167062f, 0.00269575f, 
    0.00577103f, -0.03858102f, 0.01265385f, 0.02369601f, -0.01211832f, -0.03108018f, 0.02179354f, -0.02474602f, 
    0.00969039f, -0.04825247f, 0.01410863f, -0.00525173f, -0.02198513f, -0.04528483f, -0.01203865f, -0.01493923f, 
    -0.01629806f, 0.01399135f, -0.03760848f, 0.00397526f, 0.01567583f, -0.01875589f, -0.01782711f, -0.00176025f, 
    0.00590098f, 0.01343042f, -0.00222477f, -0.00166986f, -0.02495510f, -0.02126142f, 0.00327284f, -0.03621082f, 
    -0.04277544f, 0.00603061f, -0.00752848f, -0.01553993f, 0.00381568f, -0.01878480f, -0.02348851f, 0.02408003f, 
    -0.01430673f, -0.03840232f, 0.01815218f, -0.03319376f, -0.03771717f, -0.02127243f, -0.00528741f, 0.00425971f, 
    -0.03042521f, -0.03414379f, 0.00983737f, -0.03602111f, -0.00088652f, -0.02206461f, -0.03892824f, -0.03049208f, 
    -0.02489783f, -0.03273433f, -0.02374662f, 0.01400667f, -0.00308764f, -0.02412654f, 0.00418801f, -0.02060166f, 
    0.01397766f, -0.00316455f, 0.00061647f, 0.02195458f, -0.03774604f, -0.02754968f, -0.03894015f, 0.00638609f, 
    0.00217994f, 0.01337620f, -0.01621989f, -0.03420056f, -0.03114149f, -0.04372667f, 0.01293264f, -0.02099021f, 
    0.00354067f, -0.02650478f, 0.01441103f, 0.01900020f, -0.03073541f, -0.00823558f, -0.01337645f, -0.00340833f, 
    -0.02615096f, 0.02323482f, -0.03587577f, -0.01186641f, -0.03372450f, 0.00361048f, 0.00562148f, -0.00433310f, 
    -0.01698867f, -0.01227163f, 0.00738846f, 0.02370650f, 0.01780280f, -0.04154792f, -0.02865768f, -0.04296618f, 
    0.00406579f, -0.02384103f, -0.01913204f, 0.03034656f, -0.01809291f, -0.00977373f, -0.00222439f, 0.02685653f, 
    -0.04012851f, -0.01119614f, -0.03198224f, -0.01751764f, -0.01318368f, -0.03301962f, 0.01644246f, -0.01361455f, 
    -0.04228993f, -0.03855412f, -0.02816769f, -0.03711890f, -0.00460033f, -0.02022670f, -0.04554947f, -0.01781103f, 
    -0.01558504f, -0.02061237f, -0.00319050f, 0.01420595f, 0.01635723f, 0.00257333f, -0.03090409f, -0.04936256f, 
    -0.03370329f, -0.03067771f, 0.00141558f, -0.01962535f, -0.01441664f, -0.02745907f, -0.02296541f, -0.03727997f, 
    -0.00226004f, -0.01996952f, -0.03961501f, -0.03255984f, -0.03042189f, 0.00142502f, 0.01323070f, -0.02947752f, 
    0.00969909f, -0.01504396f, 0.02198879f, -0.04329722f, 0.01705022f, -0.01315328f, -0.00328945f, -0.01031614f, 
    -0.03902150f, -0.00453540f, -0.00684844f, -0.04501090f, -0.04359737f, 0.00577066f, 0.00655601f, 0.01139762f, 
    0.02065092f, -0.01587245f, -0.00214312f, -0.03000208f, -0.05443827f, -0.04574252f, -0.00370998f, -0.03727817f, 
    0.01756659f, 0.00207656f, -0.01024708f, -0.02548782f, -0.04558573f, 0.01728281f, -0.04361024f, -0.01831488f, 
    -0.03905347f, 0.02798885f, 0.00693527f, -0.03232532f, -0.01190505f, -0.02631013f, -0.02253004f, -0.01639570f, 
    0.00831627f, 0.02501394f, -0.05048626f, -0.03114254f, -0.01633000f, -0.04913377f, -0.01346855f, -0.02759334f, 
    -0.02621211f, 0.02531089f, -0.00419915f, 0.00834556f, -0.00632900f, 0.01244816f, -0.00687485f, 0.03218312f, 
    -0.04846895f, -0.03486848f, -0.04121067f, 0.01869647f, -0.04499488f, -0.03150147f, 0.01739581f, -0.03157426f, 
    0.01048889f, -0.03997871f, -0.00909010f, -0.02734496f, -0.04822534f, -0.03338636f, 0.01891224f, -0.03644035f, 
    -0.04555351f, -0.01655157f, -0.03950534f, -0.00251586f, -0.00105790f, -0.01585259f, -0.04618783f, 0.01008366f, 
    -0.03140920f, 0.01586268f, 0.01025346f, -0.03650808f, 0.00022755f, -0.04367043f, -0.04045355f, -0.00835793f, 
    0.00505272f, -0.04355375f, -0.02424306f, -0.01785347f, -0.00302857f, -0.02240596f, -0.00336191f, -0.02768177f, 
    -0.04561691f, -0.04290711f, 0.00503476f, -0.00952781f, -0.02287367f, 0.00027743f, -0.02903936f, 0.02784388f, 
    0.02500049f, -0.03951744f, -0.04799145f, -0.00714016f, -0.05071867f, -0.02190241f, -0.05508100f, -0.01815509f, 
    -0.04421454f, -0.00401331f, -0.02716051f, 0.01210960f, -0.04130890f, 0.02175468f, 0.02056090f, -0.01227937f, 
    0.01538215f, 0.00308755f, -0.00640829f, -0.04243154f, 0.01898622f, 0.01589557f, -0.02195512f, -0.03372779f, 
    -0.03818114f, -0.01751940f, -0.00648814f, 0.00893358f, -0.03617970f, 0.02249422f, -0.04609264f, -0.00831094f, 
    0.00147043f, -0.00532506f, -0.02453608f, 0.00491225f, -0.02012473f, -0.04223533f, -0.02588457f, 0.00337272f, 
    -0.02049292f, -0.01138123f, -0.01737003f, 0.00343718f, -0.01384602f, -0.01824096f, -0.00192900f, 0.02594092f, 
    -0.00014772f, -0.02857375f, -0.04480207f, 0.01521441f, -0.02100168f, 0.02052386f, -0.01679456f, 0.01602691f, 
    -0.00373786f, -0.01608338f, -0.02497813f, -0.01958274f, -0.02073929f, 0.02543554f, 0.00360201f, -0.02711814f, 
    -0.03801632f, -0.01061942f, -0.00094267f, -0.01953699f, -0.05217718f, -0.01119235f, 0.01013965f, -0.00028385f, 
    -0.00919616f, 0.00816750f, 0.00350909f, -0.03520780f, -0.02180839f, -0.04214804f, 0.01165910f, -0.02526093f, 
    -0.01169906f, 0.00288573f, -0.04228584f, -0.02921200f, -0.00917963f, -0.00239565f, 0.01074410f, -0.01906199f, 
    0.02844016f, -0.01218202f, -0.01358100f, -0.01260510f, 0.00404946f, -0.03591860f, -0.01565169f, -0.03684749f, 
    -0.01815474f, -0.04337358f, -0.02136421f, -0.02807906f, 0.00183760f, -0.03436263f, 0.01878723f, 0.01173174f, 
    0.02035683f, -0.00870879f, -0.01641022f, -0.02831554f, -0.01335432f, -0.01983344f, -0.02215919f, 0.01725275f, 
    -0.00351975f, -0.04556321f, -0.03075919f, 0.01969934f, -0.02946349f, -0.04772338f, -0.00839334f, -0.01768397f, 
    0.01396673f, -0.01217248f, -0.05229617f, -0.00489202f, -0.02404572f, -0.03926383f, -0.04077119f, -0.00828683f, 
    -0.01689787f, 0.01161790f, -0.00436745f, 0.00861431f, 0.01168979f, -0.01054199f, 0.01267352f, -0.03677974f, 
    0.01436697f, -0.04299686f, -0.04547454f, 0.02651590f, 0.01020707f, -0.02621473f, -0.00324261f, 0.01860412f, 
    -0.01485249f, -0.05170108f, -0.02780720f, -0.00630865f, -0.00976148f, -0.04497077f, -0.03838699f, -0.02804020f, 
    0.00267247f, -0.01196377f, -0.01682770f, -0.00437603f, 0.01364349f, 0.00780272f, 0.00100127f, 0.03091496f, 
    0.01970511f, -0.00402458f, -0.01268930f, -0.05202600f, -0.03186345f, 0.02369774f, -0.00750137f, -0.03263318f, 
    -0.00326365f, -0.02417954f, -0.02231040f, -0.02523096f, -0.04355398f, -0.05106090f, -0.03162272f, -0.00520761f, 
    0.00292063f, -0.02556281f, 0.02298025f, -0.01287782f, 0.00154380f, -0.04829203f, -0.00313714f, -0.02455418f, 
    -0.05180537f, -0.01923725f, 0.00390425f, -0.01000597f, -0.00813279f, 0.01115732f, -0.03914102f, 0.00468112f, 
    -0.04319293f, -0.03258942f, 0.00492379f, 0.00528198f, -0.05421725f, -0.02420369f, -0.05030388f, 0.00200725f, 
    0.00260517f, -0.03643848f, -0.00830260f, 0.00645532f, 0.00186094f, -0.00569616f, -0.02188328f, -0.02638059f, 
    -0.02133932f, 0.02495486f, 0.01096276f, 0.03275121f, -0.00251953f, -0.00234307f, -0.03913344f, -0.01912118f, 
    -0.00969496f, -0.02980926f, 0.02826813f, 0.03976155f, 0.01145526f, 0.02534325f, 0.02869830f, -0.00520823f, 
    -0.00849503f, 0.00036561f, -0.03780895f, 0.00272714f, -0.03481486f, 0.01950347f, -0.02415308f, -0.00018306f, 
    0.01015958f, -0.03673317f, 0.00959363f, -0.01183014f, 0.03502943f, 0.02617922f, -0.03880401f, -0.01728735f, 
    0.00342125f, 0.02226982f, -0.02682608f, -0.00208003f, 0.02645633f, 0.02962534f, 0.02714784f, 0.02764736f, 
    0.02816466f, -0.00972292f, 0.00515827f, -0.01128217f, -0.00177749f, -0.03341908f, -0.03531705f, 0.02094251f, 
    0.03024876f, -0.00466821f, 0.01853421f, -0.03316291f, 0.02493694f, -0.03227238f, -0.02963367f, 0.02301126f, 
    0.00082069f, 0.02379392f, 0.03477572f, -0.01010869f, 0.01251432f, -0.01006174f, -0.02886364f, -0.00206688f, 
    0.01324725f, -0.03688418f, -0.03279373f, 0.00751093f, 0.01079740f, -0.02508855f, 0.02043084f, 0.00417544f, 
    0.03261399f, 0.02274927f, -0.01132157f, -0.00660611f, 0.02772651f, 0.01276485f, 0.02098400f, -0.01827004f, 
    0.02268304f, -0.00305563f, -0.03395844f, 0.03479723f, -0.01350397f, 0.00133467f, -0.01934479f, 0.02373143f, 
    -0.03484635f, -0.03972074f, 0.00851435f, 0.01072842f, 0.02450304f, 0.00963452f, -0.03029502f, -0.02078753f, 
    -0.00378417f, -0.03584412f, -0.01212512f, -0.02697873f, -0.03076959f, -0.00430636f, 0.01330586f, -0.00958957f, 
    0.03033564f, 0.03073702f, -0.02792815f, 0.01746468f, -0.01501839f, -0.03710218f, -0.00562470f, 0.02555183f, 
    0.01520064f, 0.01413834f, -0.03642667f, 0.03105564f, -0.02952392f, -0.01707742f, -0.00575357f, 0.03118442f, 
    0.01032498f, -0.00492062f, 0.02217081f, 0.03223931f, -0.00653672f, -0.00206163f, -0.04480763f, -0.00315359f, 
    -0.03377759f, 0.02785548f, -0.03087678f, -0.03983079f, 0.01105631f, -0.03494065f, 0.02134947f, -0.01988843f, 
    0.01342874f, -0.01151317f, 0.02388798f, -0.01618815f, -0.02056565f, 0.00351748f, -0.03006158f, -0.00753857f, 
    -0.02605013f, 0.02216049f, -0.01931440f, -0.02891063f, 0.00422783f, -0.01093826f, -0.01579143f, 0.02329763f, 
    -0.01121048f, 0.00892120f, -0.00635050f, -0.03369490f, -0.02078572f, 0.02169888f, -0.00298954f, -0.02693544f, 
    0.01648199f, -0.02483466f, -0.02336000f, 0.01834706f, 0.01062801f, -0.03550254f, -0.01800464f, -0.01820863f, 
    0.03696422f, 0.01666360f, -0.01859343f, -0.02016355f, -0.00953420f, -0.00199414f, -0.00018012f, 0.01448211f, 
    0.02914451f, 0.00161135f, 0.00117066f, 0.02254591f, 0.00523488f, -0.01146424f, 0.02686728f, 0.01374700f, 
    0.01399592f, 0.03667681f, -0.00282133f, 0.00087388f, -0.03806936f, -0.02481456f, -0.01578742f, -0.03021327f, 
    -0.02794375f, 0.00990457f, -0.00696058f, -0.03805445f, -0.00508515f, 0.00125428f, -0.00785194f, 0.01435716f, 
    0.01638389f, 0.02480283f, 0.01260509f, -0.01728736f, -0.02526850f, -0.00966080f, -0.03486278f, -0.01793422f, 
    -0.02087912f, -0.00233046f, -0.04038750f, -0.02494046f, 0.01051487f, -0.00832569f, -0.03635750f, 0.01447495f, 
    -0.00405819f, -0.03898258f, -0.00931384f, 0.03948747f, 0.01159402f, -0.03138663f, 0.03120003f, -0.01459209f, 
    -0.00241618f, -0.02209228f, -0.00128957f, 0.01739025f, 0.01934793f, -0.03962746f, 0.00666355f, -0.03641896f, 
    -0.02631710f, -0.00502299f, 0.00436577f, -0.02789159f, -0.00619683f, -0.00918281f, 0.01034644f, 0.02317433f, 
    -0.01930572f, -0.02482971f, -0.00274921f, 0.00633637f, -0.02608231f, -0.02641315f, 0.02243036f, 0.01922973f, 
    -0.03808431f, -0.02910551f, 0.02210427f, 0.01836132f, -0.01717460f, -0.03413143f, -0.02376504f, -0.03467160f, 
    -0.00897289f, -0.01950525f, 0.00111563f, -0.04328621f, -0.00512864f, 0.00494773f, 0.02213002f, -0.02355674f, 
    0.01455232f, -0.03533965f, -0.02512068f, -0.00086068f, -0.03942263f, 0.03126341f, 0.00124418f, 0.02261767f, 
    -0.00306897f, -0.00594522f, 0.01642318f, 0.01430592f, 0.01681667f, -0.04145312f, 0.01336013f, -0.02920919f, 
    0.01802777f, -0.01692707f, 0.00962132f, -0.01552880f, 0.01351382f, -0.00845435f, -0.03329423f, -0.04055619f, 
    0.02877899f, -0.02734307f, 0.00661713f, 0.02180505f, -0.01409201f, 0.03017114f, -0.01518912f, -0.02010764f, 
    -0.03035905f, -0.03860657f, -0.02430770f, 0.00959599f, 0.00463776f, 0.02807715f, 0.00230708f, 0.02774803f, 
    0.00336094f, -0.01058590f, 0.01060653f, 0.00204240f, -0.01629847f, -0.01406014f, -0.00631301f, 0.03107010f, 
    -0.02841432f, -0.02492914f, -0.03561203f, 0.02289418f, -0.01268823f, -0.02363345f, -0.00470475f, -0.02486930f, 
    0.00220238f, -0.04161567f, 0.01450625f, -0.01789485f, 0.02968624f, -0.03868898f, -0.03705876f, -0.02971083f, 
    0.01363223f, 0.01073334f, -0.02634099f, 0.01309842f, -0.00631638f, 0.00367097f, 0.00643762f, -0.00753109f, 
    0.00328899f, -0.01473377f, -0.01658782f, -0.01093542f, -0.03718254f, -0.02728757f, 0.00008118f, -0.03559209f, 
    0.02187221f, -0.00077943f, -0.00895373f, 0.02808638f, -0.00158177f, 0.02117035f, -0.03198117f, 0.00397636f, 
    -0.02677436f, -0.01972856f, 0.02233908f, 0.03661723f, 0.02610704f, -0.00478456f, 0.00161659f, -0.02068919f, 
    -0.00384612f, 0.00409411f, -0.02341865f, -0.00531719f, -0.00251225f, -0.02750043f, -0.00172572f, -0.02944018f, 
    -0.01340132f, -0.01090872f, -0.03845203f, -0.00233519f, -0.01589501f, 0.00440155f, -0.01445215f, 0.00124973f, 
    -0.01118187f, 0.01153427f, -0.04106927f, -0.01338681f, -0.02366789f, 0.01051200f, -0.00582819f, 0.03737248f, 
    0.01717629f, 0.01573671f, -0.03035857f, -0.00170270f, -0.02049802f, -0.00369969f, -0.02923990f, -0.02279726f, 
    -0.02890596f, 0.02556285f, -0.00184660f, -0.00923622f, -0.00524624f, 0.01334608f, -0.02986718f, -0.02324101f, 
    0.00673693f, -0.01521623f, -0.03914670f, 0.01677591f, -0.01800378f, 0.02009202f, -0.03142425f, -0.03546433f, 
    0.01150474f, -0.01205911f, -0.02946745f, 0.01239580f, -0.01737357f, 0.00230994f, -0.03055355f, 0.00632533f, 
    -0.02361838f, -0.01622793f, 0.02420639f, -0.00103000f, 0.02692141f, -0.03556292f, -0.00199891f, -0.02808910f, 
    -0.00304390f, 0.03094215f, -0.01560469f, -0.01359369f, -0.02658990f, -0.04065584f, 0.02272386f, -0.03648460f, 
    -0.02426900f, -0.01739030f, 0.03094396f, -0.00492120f, -0.01554725f, 0.01785048f, -0.00054621f, -0.01337325f, 
    0.01316622f, 0.00826171f, -0.04091943f, -0.03215268f, -0.01037399f, 0.00884289f, 0.02192138f, 0.02845175f, 
    -0.00799663f, 0.00372433f, -0.00532452f, 0.01913229f, -0.01341917f, 0.00907821f, 0.02922968f, -0.00387935f, 
    0.01013921f, -0.00449262f, -0.02577660f, -0.03903501f, -0.03729229f, 0.00170434f, -0.03129167f, 0.02410290f, 
    0.00535218f, 0.02163113f, 0.02290091f, 0.02415267f, -0.03056524f, 0.01352393f, 0.02000275f, 0.01457102f, 
    -0.00743171f, 0.02605457f, -0.01107013f, -0.02282563f, -0.00457256f, -0.01038666f, -0.03834343f, -0.01833557f, 
    -0.03616545f, 0.00747450f, -0.03010440f, -0.02578406f, 0.01561033f, -0.02847888f, -0.02293481f, 0.02007174f, 
    -0.02773328f, -0.00584188f, 0.01234985f, 0.02295733f, -0.01245085f, 0.01168437f, 0.00566122f, -0.02883009f, 
    -0.04375498f, 0.00908490f, 0.01340436f, 0.00299164f, -0.02554802f, -0.04164733f, -0.02756376f, 0.03054101f, 
    0.01127484f, -0.01467987f, 0.00823203f, 0.01634775f, -0.00622648f, -0.00414548f, 0.00791918f, -0.00494403f, 
    -0.02103749f, -0.00616278f, -0.00074177f, -0.04164242f, -0.02413779f, -0.03020183f, -0.03127277f, -0.00368661f, 
    -0.02849385f, 0.00471467f, 0.03124698f, -0.03561483f, -0.02535377f, -0.01154543f, 0.01814508f, -0.02502343f, 
    -0.02987053f, -0.03927032f, 0.01475432f, 0.01170730f, 0.01374522f, -0.01965659f, -0.00228846f, 0.02048207f, 
    -0.00103684f, -0.02940623f, -0.01012907f, 0.01243634f, 0.00236060f, -0.00729944f, 0.02215604f, 0.01882118f, 
    -0.00536558f, 0.00513969f, 0.00091408f, 0.03082402f, -0.00715618f, -0.03804768f, -0.00836059f, 0.02473002f, 
    -0.03874153f, -0.00713888f, 0.03240377f, -0.03228203f, 0.00659638f, -0.01858671f, 0.02292161f, -0.03646013f, 
    -0.02481159f, 0.02963189f, 0.00736368f, -0.01914430f, -0.03223931f, -0.02704281f, -0.03473336f, 0.01957384f, 
    0.00949231f, 0.01526561f, -0.01030690f, 0.00892918f, -0.02102580f, -0.01224675f, 0.00149205f, -0.00101673f, 
    0.02305842f, 0.02257119f, 0.03314433f, -0.01794401f, -0.00580308f, -0.00921907f, -0.01954200f, -0.00713732f, 
    0.00983029f, 0.01130207f, -0.02813580f, -0.02262493f, 0.02163524f, 0.01195922f, 0.02799153f, 0.03376623f, 
    0.01513344f, -0.01842601f, -0.02623101f, -0.01036424f, -0.01926913f, 0.01210537f, 0.01843525f, 0.00223091f, 
    0.03383153f, -0.03440847f, 0.01626540f, 0.00755684f, 0.00140857f, -0.00784916f, 0.01418004f, 0.02813340f, 
    -0.02118539f, 0.02826227f, -0.03856776f, -0.03382351f, -0.00460360f, 0.02125939f, -0.03416179f, 0.02710754f, 
    0.03890226f, 0.01633468f, 0.03762051f, -0.02501638f, 0.00220754f, 0.00770045f, 0.02247763f, 0.02128038f, 
    -0.00759842f, 0.00093869f, 0.01726967f, -0.02004030f, 0.03042130f, 0.01980071f, 0.00815246f, 0.01194139f, 
    -0.02710816f, -0.03897757f, -0.00590737f, 0.01380845f, 0.01494026f, 0.02577697f, -0.02957682f, 0.00660242f, 
    -0.04086997f, 0.02190058f, -0.00666172f, -0.00374491f, -0.00259730f, 0.01927444f, -0.01136184f, -0.01538669f, 
    -0.04404550f, -0.00999460f, 0.00467359f, 0.03268514f, 0.00538128f, -0.00384039f, -0.04009971f, -0.01401320f, 
    -0.00278697f, -0.02532194f, -0.03978480f, 0.02798236f, -0.01288980f, -0.00213362f, 0.02738782f, 0.03696014f, 
    0.02894993f, -0.02335262f, 0.00983577f, -0.01662048f, -0.03038106f, -0.00744813f, -0.02495192f, 0.01667233f, 
    0.01674117f, -0.00810462f, -0.00729185f, -0.02469384f, -0.01416985f, 0.01538162f, -0.02387704f, 0.00913837f, 
    -0.00717878f, -0.01371396f, 0.03123282f, 0.01904475f, -0.03940337f, -0.01730758f, -0.03844339f, -0.01552156f, 
    -0.02571577f, -0.02769158f, -0.04317725f, -0.02443394f, -0.01076581f, -0.02203571f, -0.00231100f, -0.01059545f, 
    0.02028971f, 0.01436440f, -0.03054209f, -0.03379068f, 0.02502423f, -0.02642347f, 0.02585606f, -0.02662443f, 
    -0.03762074f, 0.02240054f, 0.00300496f, 0.01689086f, 0.01582093f, 0.02428803f, -0.02989859f, -0.01414919f, 
    0.01923083f, 0.02716929f, -0.02517519f, 0.00100233f, -0.01893306f, -0.00970409f, -0.03109452f, 0.00628260f, 
    -0.00578942f, 0.02283475f, 0.02096096f, -0.03065708f, -0.01380574f, 0.03231575f, 0.00685132f, -0.00640303f, 
    0.01084214f, 0.00604090f, 0.01209975f, -0.03553369f, -0.03195954f, 0.02131979f, -0.01326213f, -0.02196729f, 
    0.01298009f, -0.01476807f, 0.01685384f, 0.01309422f, 0.03312862f, -0.03632274f, 0.00353323f, 0.00604753f, 
    0.00891291f, -0.02968660f, 0.00763463f, -0.03130531f, -0.02451275f, -0.00097917f, -0.00514381f, 0.02157167f, 
    -0.02719934f, -0.01347690f, 0.00203518f, -0.01201890f, -0.02084136f, 0.02605353f, 0.01241618f, 0.01375793f, 
    0.02253408f, -0.03547299f, -0.00378630f, -0.01277979f, 0.01737749f, -0.00867609f, -0.03195519f, -0.01348053f, 
    0.02736846f, 0.00803547f, -0.02943438f, 0.02355937f, 0.01955157f, -0.01030837f, -0.01324461f, 0.00421041f, 
    -0.03050757f, -0.02225656f, -0.00980472f, 0.01248550f, 0.01228155f, 0.02154086f, -0.00474695f, 0.02382603f, 
    -0.02974506f, -0.01270312f, 0.02313612f, -0.02557222f, 0.01857405f, 0.02839923f, -0.02344506f, 0.00470059f, 
    -0.00340056f, -0.02468192f, -0.01521711f, 0.02686826f, -0.01292466f, -0.03512822f, -0.03545596f, -0.02874771f, 
    0.01433014f, 0.00739738f, 0.01344707f, -0.01735627f, -0.00166668f, 0.01666528f, 0.00609645f, 0.01337662f, 
    0.00639956f, -0.01432625f, -0.02654078f, -0.02561966f, -0.01078219f, 0.02212494f, 0.02011918f, 0.00730412f, 
    -0.02852278f, -0.03217916f, 0.02501821f, -0.00889130f, -0.02135455f, -0.03326278f, -0.00481129f, -0.03180489f, 
    -0.02327782f, 0.02824209f, -0.03128618f, 0.00546384f, 0.02130970f, -0.03890027f, 0.02037768f, -0.02765071f, 
    0.00982203f, -0.00934991f, 0.02976140f, -0.02159300f, 0.01061667f, -0.02967250f, 0.00293759f, 0.02524797f, 
    -0.01198813f, -0.00490279f, -0.02045380f, 0.02504594f, -0.01627772f, 0.02450825f, -0.00595577f, 0.03470625f, 
    0.02303593f, -0.02367810f, -0.02534746f, 0.00675746f, 0.00893364f, 0.02585181f, 0.01058179f, 0.01786689f, 
    -0.01953200f, 0.00734960f, -0.03981666f, -0.01874741f, -0.02631823f, -0.00655201f, 0.03059332f, -0.01720983f, 
    0.02457041f, 0.02699980f, -0.03781968f, 0.00399568f, -0.01501710f, -0.01400647f, -0.00483432f, -0.01274464f, 
    0.02952600f, 0.02721462f, -0.03216271f, -0.04049651f, -0.00318834f, 0.00179800f, -0.01818667f, -0.00292812f, 
    -0.01257595f, -0.01175674f, -0.03625294f, -0.01559243f, -0.01048287f, -0.03176333f, 0.00981178f, -0.03849277f, 
    -0.03462755f, -0.01488034f, 0.03021764f, -0.02784526f, 0.01244453f, 0.01630397f, 0.01488471f, -0.03460601f, 
    -0.03863602f, -0.03154830f, -0.01563357f, -0.03645262f, -0.03971677f, -0.02164481f, 0.03042028f, 0.01151387f, 
    0.01462737f, 0.01043054f, -0.02294056f, -0.00619319f, 0.00978898f, -0.01315345f, 0.00578747f, -0.01085961f, 
    -0.00536076f, -0.00613465f, -0.02114622f, 0.01389373f, -0.02007573f, -0.01679720f, -0.01660483f, 0.02103150f, 
    0.01474923f, 0.02456382f, -0.00478639f, -0.03876493f, 0.01843407f, -0.01201101f, 0.02041191f, 0.01719488f, 
    0.02453391f, -0.02901122f, 0.00227853f, -0.02797443f, -0.00444420f, -0.03061231f, -0.00608238f, 0.02815009f, 
    0.03053813f, -0.03770895f, -0.02142614f, -0.01787998f, -0.01786100f, -0.03025069f, 0.02294721f, 0.03075438f, 
    -0.02059692f, 0.00619099f, -0.03935506f, 0.01443047f, -0.01687823f, -0.00288898f, -0.02715112f, -0.00228573f, 
    -0.00830085f, -0.00496536f, -0.03824333f, -0.02461632f, 0.01625066f, 0.01921699f, -0.02166742f, -0.02383901f, 
    -0.02475359f, -0.01429126f, 0.00833105f, 0.01690583f, 0.00595424f, -0.02776529f, 0.01509773f, 0.01118547f, 
    -0.03444832f, -0.02252556f, 0.01421267f, -0.03696125f, -0.02522605f, -0.03676493f, 0.00150100f, -0.00196756f, 
    -0.02911867f, -0.00748470f, 0.01492258f, -0.01130132f, -0.01722401f, 0.02261761f, 0.00105088f, 0.01316151f, 
    0.00210876f, -0.00229482f, 0.01790513f, -0.02336062f, -0.01778114f, -0.00093841f, -0.00645460f, 0.00512771f, 
    0.02197300f, -0.03616416f, -0.03497255f, 0.01266765f, -0.00531727f, -0.02189617f, -0.00968321f, 0.00390298f, 
    0.00066138f, -0.01644037f, 0.01526672f, 0.02775796f, 0.01734507f, 0.01366458f, -0.00673455f, 0.00714172f, 
    -0.00574055f, 0.01644400f, 0.02689049f, 0.01945600f, -0.02439130f, 0.00070458f, -0.01135117f, 0.01365562f, 
    -0.00791828f, -0.01474018f, 0.00850368f, -0.03350680f, -0.00138500f, 0.02343347f, -0.01662775f, 0.01287017f, 
    -0.00336484f, -0.00014008f, 0.01413865f, -0.00668666f, -0.02130638f, -0.02705083f, -0.02735870f, -0.01341397f, 
    -0.04032090f, 0.03310873f, 0.02066918f, 0.00021971f, -0.03495497f, -0.03313276f, 0.01490669f, -0.01719318f, 
    -0.03229090f, 0.00882063f, 0.00957737f, 0.00154380f, -0.02906979f, 0.03112531f, -0.00460046f, 0.00760860f, 
    -0.00847375f, -0.00884086f, -0.02916130f, -0.02044711f, -0.00254724f, 0.01366578f, 0.01770299f, 0.01204586f, 
    0.02472131f, 0.00758163f, 0.02361966f, -0.03893340f, -0.02248332f, -0.01452059f, 0.01224050f, 0.01853289f, 
    0.00025863f, -0.02263812f, -0.03113564f, 0.02656623f, -0.00438364f, -0.00494730f, -0.03176991f, -0.02013018f, 
    -0.04027766f, -0.00741152f, -0.02887947f, -0.00183342f, -0.00980080f, 0.02726421f, 0.00537606f, -0.03659725f, 
    0.02182150f, -0.03002914f, 0.00526881f, -0.03332347f, 0.00758019f, 0.00748191f, -0.00631169f, 0.01136141f, 
    -0.00195597f, 0.02785360f, -0.03291291f, -0.03827954f, 0.01603709f, 0.00234116f, -0.03014100f, 0.01200203f, 
    0.01977949f, -0.01154204f, 0.02780980f, 0.00047508f, -0.01670231f, -0.01461363f, -0.01138009f, -0.00403718f, 
    -0.03742537f, 0.02022710f, 0.02561775f, -0.03269929f, -0.02536659f, -0.00139539f, 0.02638108f, 0.01329797f, 
    0.00881288f, -0.03238006f, 0.00409302f, -0.02585830f, 0.00373147f, 0.02565701f, -0.00624899f, -0.03117255f, 
    0.00985477f, 0.02913607f, -0.00875820f, -0.00976107f, 0.00533076f, 0.02328645f, 0.01870110f, 0.01629310f, 
    -0.01404726f, 0.00521378f, -0.00689283f, 0.02418202f, 0.02701074f, -0.02716181f, -0.03848843f, 0.01595096f, 
    -0.00576682f, -0.02416085f, 0.00663005f, 0.02259586f, 0.01662817f, 0.01367451f, -0.00795739f, -0.00494704f, 
    0.00322100f, 0.00995997f, 0.00833540f, -0.03626552f, -0.02148707f, 0.00540669f, -0.02445761f, -0.03642992f, 
    0.02952821f, -0.03397829f, 0.02025481f, 0.02779638f, -0.00028309f, 0.00249860f, 0.01846762f, 0.00806343f, 
    -0.01068974f, 0.00729540f, 0.01207236f, 0.01406784f, -0.00895871f, 0.00445940f, -0.02782511f, -0.00695743f, 
    0.02329354f, -0.02539688f, 0.02774418f, -0.02109960f, -0.02691895f, 0.02710418f, -0.00683178f, -0.03912008f, 
    -0.03794900f, -0.00880586f, -0.03083507f, -0.02574071f, -0.00094570f, -0.03369881f, 0.02578778f, -0.03219538f, 
    -0.01194054f, 0.00742868f, -0.02882267f, -0.03953173f, 0.00601535f, -0.01699813f, -0.01890347f, -0.03431587f, 
    -0.02089060f, 0.00686901f, -0.02607670f, 0.00905932f, 0.00344423f, 0.00115323f, 0.00270260f, -0.03329892f, 
    -0.03056576f, -0.01659524f, -0.03712724f, -0.01544612f, 0.02177696f, -0.00559503f, 0.00592149f, 0.00499897f, 
    -0.02908512f, -0.01127086f, -0.03014556f, 0.00255196f, -0.03727254f, 0.00086337f, 0.02197682f, -0.02668913f, 
    -0.01382469f, -0.02086484f, 0.00474111f, -0.01556946f, 0.03043248f, -0.01306238f, 0.01354672f, -0.03920799f, 
    -0.02562064f, -0.00351994f, -0.00616962f, 0.02902381f, -0.02560771f, -0.02518345f, -0.01177299f, 0.00327141f, 
    -0.01727553f, -0.02641618f, 0.01344904f, -0.00752327f, 0.00393934f, -0.03864392f, -0.02773317f, -0.00347912f, 
    0.03206360f, -0.01934185f, 0.02874830f, 0.02635709f, -0.03227036f, -0.02984776f, 0.01722797f, -0.03350457f, 
    -0.01653350f, 0.00082305f, 0.01965361f, 0.01166066f, -0.01073856f, 0.01522690f, -0.00520441f, -0.00724562f, 
    -0.01367688f, -0.01714925f, 0.00010498f, 0.02041105f, 0.03090899f, 0.00828213f, 0.03454936f, 0.01139907f, 
    0.01573525f, -0.02925203f, 0.03587108f, 0.02535207f, -0.00610601f, 0.00495348f, 0.01826997f, 0.02534090f, 
    -0.01100531f, -0.02749128f, -0.01731358f, 0.01608383f, 0.00391782f, -0.03880663f, 0.01205206f, 0.00548002f, 
    0.02207476f, 0.00075772f, -0.03138165f, -0.02184015f, 0.01229721f, -0.03510039f, -0.01223150f, -0.03857073f, 
    -0.01258920f, -0.00930260f, 0.00760555f, 0.02431644f, -0.02431304f, -0.00270150f, 0.01071353f, -0.01350302f, 
    0.02225554f, 0.02790547f, -0.00304891f, -0.01931178f, 0.00941526f, -0.03742148f, 0.00469486f, -0.01696468f, 
    -0.02473219f, -0.00239509f, 0.02083472f, 0.01313360f, -0.00137783f, 0.02054604f, 0.01191802f, 0.00525868f, 
    0.00444379f, 0.01817191f, 0.03451818f, 0.00828473f, 0.01417335f, 0.00592191f, 0.01598763f, 0.03209963f, 
    0.01125280f, 0.00028152f, -0.02005888f, 0.02441312f, -0.03282785f, -0.00309942f, 0.01834786f, 0.02000991f, 
    0.02318982f, 0.01157230f, -0.00466376f, -0.00176763f, 0.01099442f, 0.02714594f, 0.01023075f, 0.00890309f, 
    -0.00892717f, 0.01706555f, -0.02215176f, -0.02555446f, 0.01769347f, -0.01467408f, 0.02372004f, 0.02986106f, 
    -0.03965268f, -0.01259723f, -0.01181777f, 0.01506284f, 0.00325357f, -0.01407185f, -0.01868515f, -0.01815848f, 
    -0.02736317f, -0.03287254f, -0.02644165f, 0.01338122f, -0.00515962f, -0.00495622f, -0.03543353f, -0.03204131f, 
    -0.03980583f, -0.01251115f, -0.01472176f, 0.02326573f, -0.00822865f, 0.01096139f, 0.02708327f, -0.00358430f, 
    -0.02742686f, 0.02484906f, -0.02400413f, -0.03297087f, -0.00971542f, 0.00754224f, -0.00294704f, -0.03390563f, 
    -0.02559894f, 0.01574918f, -0.00378287f, 0.00956029f, 0.02694342f, 0.00131137f, 0.01466983f, -0.03868815f, 
    0.02280507f, 0.00147246f, -0.01372303f, 0.02453663f, -0.00240832f, -0.01502225f, 0.02412821f, -0.01419958f, 
    -0.03452521f, 0.01549717f, -0.01390188f, 0.02321875f, 0.02806526f, 0.00574739f, -0.03953025f, -0.00142435f, 
    0.00415268f, -0.01435996f, 0.00306595f, -0.00904148f, 0.00549914f, -0.01704310f, -0.00018669f, 0.01950756f, 
    -0.01545568f, -0.02135958f, 0.00102538f, -0.00584978f, 0.02776878f, -0.03262206f, 0.00276790f, -0.02495582f, 
    -0.02627636f, 0.02962717f, 0.02646555f, -0.03057861f, -0.01600445f, 0.02568673f, 0.02652449f, -0.02840078f, 
    -0.00521888f, 0.01107093f, 0.00579448f, -0.00229411f, 0.01454369f, 0.02584441f, -0.02886614f, 0.01938279f, 
    -0.01587755f, -0.01654324f, 0.00060919f, -0.02667578f, 0.00210533f, -0.02426737f, 0.01653718f, 0.01082369f, 
    -0.02568079f, 0.02212684f, 0.00591106f, -0.00550751f, 0.01136051f, 0.00899641f, -0.00268507f, -0.00418818f, 
    -0.02369435f, 0.03111022f, -0.02620009f, -0.00161066f, 0.01637678f, 0.00809971f, 0.00726720f, -0.00154376f, 
    0.02330946f, 0.00816882f, -0.01800225f, -0.02486710f, -0.01177884f, -0.00681561f, 0.00768879f, -0.00572533f, 
    -0.00959077f, -0.03514954f, 0.01535163f, 0.00432039f, -0.00310344f, -0.03998049f, 0.01956405f, -0.02014961f, 
    0.02649308f, 0.00191422f, 0.00846643f, -0.03250534f, -0.01650403f, 0.01271323f, 0.01176553f, 0.01424885f, 
    -0.02282416f, 0.02764544f, 0.01171108f, -0.01887221f, 0.01760556f, -0.03856850f, 0.01283314f, 0.00352183f, 
    -0.02708356f, -0.01215340f, 0.01720496f, 0.01970084f, 0.01727773f, -0.00345936f, 0.02088170f, -0.00084988f, 
    -0.00815805f, -0.01945454f, -0.03541781f, -0.00789923f, 0.02400035f, -0.00519998f, -0.02692268f, -0.00859792f, 
    0.02602417f, -0.00940750f, -0.02369201f, -0.03116470f, 0.02464605f, -0.00989794f, -0.01888790f, -0.02301353f, 
    -0.01557898f, 0.01020059f, -0.04125068f, -0.01287557f, -0.02217305f, 0.02136349f, -0.00478261f, -0.03206400f, 
    0.00988242f, -0.02429767f, 0.01037849f, 0.00384294f, -0.00482421f, 0.02738793f, -0.02786669f, -0.02405871f, 
    -0.26244611f, 0.42004642f, -0.02648247f, 0.09633610f, 0.18500870f, 0.10058652f, 0.04962621f, -0.11578102f, 
    0.06472423f, -0.00684897f, 0.13102134f, 0.14552777f, -0.06567329f, 0.25092945f, -0.17392866f, -0.11434361f, 
    0.11237124f, -0.06414527f, -0.03690481f, 0.12407589f, -0.01959278f, -0.02558987f, -0.07161212f, 0.04153521f, 
    -0.30750397f, 0.03067511f, 0.08237009f, 0.01892445f, 0.12341588f, 0.04107707f, -0.01157884f, 0.00129722f, 
    -0.00377105f, 0.12767728f, -0.02547647f, 0.11584664f, -0.19329645f, 0.03786534f, 0.11431234f, -0.05314583f, 
    -0.02027911f, -0.02833770f, -0.00694010f, -0.01933108f, 0.01272829f, 0.00880606f, 0.03401187f, 0.09736983f, 
    -0.11256609f, 0.08369249f, 0.15121509f, 0.04664881f, 0.02120415f, 0.14624014f, 0.03871791f, 0.12423375f, 
    0.06280794f, -0.09585089f, -0.02303599f, 0.09007525f, -0.06566297f, 0.08671619f, -0.00241672f, -0.02225923f, 
    0.10695078f, 0.01980754f, 0.06161961f, 0.04680759f, 0.03731145f, -0.15620680f, -0.16815315f, 0.10966235f, 
    -0.15885082f, 0.15138528f, 0.05581363f, 0.18390214f, 0.13945505f, -0.06011813f, 0.05518667f, 0.01364019f, 
    0.08108377f, 0.01888549f, -0.01274226f, 0.11661087f, -0.13098396f, 0.06106986f, -0.10701595f, -0.12184151f, 
    0.09837405f, 0.01802943f, -0.05725930f, 0.00452495f, 0.07728686f, -0.10523000f, 0.04455010f, 0.00623930f, 
    -0.32210010f, 0.09258167f, -0.09179848f, -0.19583723f, 0.19291624f, 0.01776051f, 0.00510985f, 0.08492609f, 
    -0.00409553f, 0.05200633f, 0.10157076f, 0.12394434f, 0.10125189f, -0.12639554f, 0.19131635f, -0.15512951f, 
    0.13284783f, 0.08308739f, -0.08929615f, -0.04185826f, 0.08867473f, -0.00968642f, 0.01733033f, 0.01299173f, 
    0.04753719f, 0.00685031f, -0.15345731f, -0.11121403f, 0.08701908f, 0.00094286f, -0.08554778f, 0.06817262f, 
    0.00071526f, -0.01470710f, 0.08372454f, 0.00965384f, -0.06856237f, 0.20228478f, 0.10387830f, 0.01051905f, 
    0.08286994f, 0.04399126f, 0.01026572f, -0.06030214f, 0.01443928f, -0.03727604f, -0.02680643f, 0.01880485f, 
    -0.11192976f, -0.19511214f, -0.08248632f, -0.04015471f, -0.05690031f, 0.03495699f, 0.01205043f, 0.17776398f, 
    -0.06982633f, -0.02399380f, 0.05076035f, 0.00885608f, 0.02254879f, 0.04541886f, 0.10301358f, 0.05024896f, 
    0.09687502f, 0.07983386f, 0.05659711f, -0.08101439f, 0.15152311f, 0.02109381f, -0.00839196f, 0.11004701f, 
    -0.10939369f, -0.09451225f, 0.23229125f, 0.03850835f, 0.11139205f, -0.10828239f, -0.04421576f, 0.01116976f, 
    0.00471912f, -0.05115991f, -0.04201978f, 0.10466965f, -0.04038966f, 0.00467857f, -0.14166252f, -0.02119361f, 
    -0.01283174f, 0.04276219f, 0.12071672f, 0.02616916f, 0.07204858f, 0.01934183f, 0.02171210f, 0.08603424f, 
    -0.14403228f, 0.02139696f, -0.20360453f, 0.07729515f, 0.09852537f, 0.04537242f, 0.09522028f, 0.06412266f, 
    0.17819619f, -0.04302056f, -0.05129778f, -0.09888712f, -0.19255407f, -0.01717835f, -0.08330122f, -0.02157004f, 
    0.08650914f, 0.10892313f, -0.02349726f, -0.06274796f, 0.11289878f, 0.03964906f, 0.00189421f, -0.00291743f, 
    -0.25201806f, -0.04738729f, -0.10971316f, 0.13173257f, 0.02702719f, -0.09933477f, 0.00252387f, 0.10445274f, 
    0.01114113f, 0.07541987f, 0.09910128f, -0.00989872f, 0.15131535f, 0.02623039f, -0.16602772f, -0.30768770f, 
    0.03203781f, 0.02187911f, -0.02037181f, -0.00318056f, 0.05654080f, -0.01006635f, 0.22230719f, 0.17739052f, 
    -0.04412848f, 0.24308160f, -0.05561919f, -0.04290371f, 0.12912712f, -0.17007013f, 0.04975247f, 0.00594726f, 
    0.04951084f, -0.01501013f, 0.07627903f, -0.04010155f, 0.00084628f, 0.04089244f, 0.16003317f, -0.00225332f, 
    -0.04935854f, 0.16190398f, 0.05225283f, -0.05867977f, 0.01303076f, -0.02462762f, 0.03659175f, -0.09606086f, 
    -0.08801092f, -0.00593245f, -0.02110608f, 0.01262708f, 0.12290961f, 0.08520995f, 0.00172909f, -0.00202132f, 
    -0.10480317f, -0.01313604f, 0.04970266f, -0.00286061f, -0.18242687f, -0.08216251f, 0.03760026f, 0.03892794f, 
    -0.11716742f, -0.16147262f, -0.01085618f, 0.09529466f, 0.05683533f, 0.13847826f, 0.10994315f, 0.10701142f, 
    -0.15536873f, -0.08586758f, -0.12042526f, 0.06481412f, 0.04528802f, -0.04596997f, -0.00026249f, -0.02196934f, 
    0.06996998f, 0.14355907f, 0.02737395f, 0.03776758f, -0.04133620f, 0.08879271f, -0.09068509f, 0.12356102f, 
    0.03913030f, -0.04181103f, -0.00067552f, 0.01824749f, -0.03743762f, 0.01514932f, 0.07087129f, -0.01941831f, 
    -0.02451739f, 0.24778165f, 0.11118244f, 0.12172701f, 0.01462951f, 0.17667308f, -0.00617613f, 0.00717643f, 
    -0.08350636f, -0.06192986f, 0.02524912f, 0.06179730f, -0.29400316f, -0.25645420f, 0.21474965f, 0.00122028f, 
    -0.02088791f, 0.11795685f, 0.00689026f, 0.16320544f, 0.14753142f, -0.04081588f, 0.05074349f, 0.05389908f, 
    -0.16255580f, 0.10750226f, -0.00356369f, -0.23304637f, 0.12183484f, 0.03610335f, -0.11997484f, 0.00931809f, 
    -0.03009946f, -0.05876910f, 0.00384832f, -0.08180670f, -0.03315422f, 0.03244974f, 0.12173475f, -0.13914928f, 
    -0.02077317f, 0.01262425f, 0.06623535f, 0.03467867f, 0.09292926f, 0.07384802f, 0.05723998f, 0.00523041f, 
    -0.12869015f, 0.07742912f, 0.19534780f, -0.01152756f, -0.03942649f, -0.02657959f, 0.02149256f, 0.02828018f, 
    -0.05579122f, -0.01620473f, 0.01139562f, 0.12778883f, -0.25338054f, -0.10613468f, 0.17136614f, 0.08287330f, 
    0.07973030f, 0.02015450f, -0.06219885f, -0.02848339f, 0.06573983f, -0.08637920f, 0.00099788f, 0.02703650f, 
    -0.00673185f, 0.14081194f, 0.05804129f, 0.11459338f, 0.11741067f, 0.04355156f, 0.08758055f, 0.17387097f, 
    0.01813929f, 0.02781210f, -0.05132632f, 0.02863003f, -0.11224596f, 0.10272785f, -0.18812275f, 0.10437544f, 
    -0.05402614f, 0.01565647f, -0.03625363f, 0.12143067f, -0.09119608f, -0.01335369f, 0.00960302f, 0.01154500f, 
    0.11601104f, -0.05346235f, -0.05528662f, -0.15092689f, 0.10893968f, 0.03956425f, -0.04225526f, 0.00475264f, 
    0.02425435f, 0.00672203f, 0.09652265f, 0.04495316f, -0.00649263f, -0.07575636f, 0.10913100f, 0.16481978f, 
    -0.02839535f, 0.01952745f, 0.02856230f, 0.05674175f, -0.01301926f, -0.11490177f, -0.11362682f, 0.03380999f, 
    -0.07894973f, -0.32282919f, 0.06315458f, 0.09767095f, 0.02354390f, -0.08891096f, 0.02921737f, 0.12876606f, 
    -0.08068010f, 0.02969571f, 0.03432419f, 0.07576840f, -0.00905223f, 0.01872018f, 0.00647321f, -0.04498323f, 
    0.04503411f, 0.01100217f, -0.01559256f, 0.06091273f, 0.05669584f, 0.02723500f, -0.08073603f, 0.01442753f, 
    -0.07498723f, -0.03392044f, 0.15430725f, -0.02614671f, -0.09004519f, 0.08542714f, 0.00378577f, 0.02368486f, 
    0.02209913f, 0.06147667f, 0.00919828f, 0.09115029f, -0.13847058f, 0.06235624f, -0.14270756f, 0.07682316f, 
    0.02045901f, 0.04007081f, 0.08432228f, -0.11350623f, 0.09175402f, 0.04304290f, -0.00366872f, -0.00079894f, 
    -0.02464729f, -0.05038885f, -0.06316649f, 0.11507478f, 0.08233827f, -0.01219140f, -0.04108616f, 0.02500127f, 
    0.05283925f, 0.06084640f, 0.09161595f, 0.07275899f, 0.28801394f, 0.16060464f, -0.11179430f, 0.08202443f, 
    0.03113827f, -0.11130992f, 0.06038661f, 0.18469478f, 0.01658999f, 0.06698254f, -0.01571949f, -0.00405046f, 
    0.03303919f, -0.16359003f, -0.08155479f, -0.01045661f, 0.05339523f, 0.02762275f, -0.02572886f, 0.16771822f, 
    0.06454042f, 0.12885906f, 0.17206198f, -0.05055728f, -0.08885325f, -0.02754929f, -0.02111047f, 0.05492382f, 
    -0.02107411f, -0.01521798f, 0.00979352f, 0.02613646f, 0.03686509f, -0.01363090f, 0.02963389f, 0.06071776f, 
    0.53065467f, -0.20745258f, -0.08304127f, -0.09890579f, -0.02972515f, -0.01362226f, 0.08915387f, 0.11052824f, 
    -0.00163185f, 0.02961141f, -0.00443472f, 0.01832254f, -0.01328390f, -0.06016095f, 0.07196365f, -0.10674106f, 
    0.09001465f, -0.11008979f, 0.12529145f, 0.05091411f, 0.14245763f, 0.09317096f, 0.09301551f, 0.07536818f, 
    -0.02036125f, 0.00043766f, -0.27309576f, -0.05309397f, 0.05342840f, 0.08737494f, -0.08531514f, 0.02902743f, 
    0.07002623f, 0.04485894f, -0.07498446f, 0.00566747f, -0.02468558f, -0.00132548f, -0.13239953f, -0.07697683f, 
    0.00536573f, -0.02988140f, 0.05108736f, 0.09872147f, 0.01610249f, -0.03650537f, -0.04362364f, 0.00052723f, 
    0.15690596f, 0.03611067f, -0.03322661f, -0.12914470f, 0.09494588f, -0.08991119f, 0.06338319f, -0.08938728f, 
    -0.00219035f, 0.02332711f, 0.00370123f, 0.09627475f, 0.23776016f, -0.15725741f, -0.02221819f, 0.11921048f, 
    0.07337372f, -0.00160743f, 0.03869699f, 0.08796348f, 0.03696935f, -0.10774447f, -0.06467068f, 0.05298947f, 
    0.04345298f, -0.15308493f, 0.04422174f, -0.15642385f, -0.11384967f, 0.10932238f, -0.01222933f, 0.05674794f, 
    0.08963128f, -0.02935672f, -0.01977554f, 0.11205208f, -0.23761809f, 0.01267130f, 0.02766166f, -0.07912455f, 
    0.02795598f, -0.03681575f, 0.04000856f, -0.12177423f, -0.13459624f, 0.11522359f, 0.05841978f, 0.10951522f, 
    -0.05272815f, -0.17128988f, 0.05103721f, 0.01808350f, -0.03676925f, -0.14912036f, 0.00173446f, 0.07998787f, 
    0.01406980f, -0.02050585f, -0.04627955f, 0.01999030f, -0.01862773f, -0.04337109f, 0.21376780f, -0.25038591f, 
    -0.01855123f, 0.01276141f, -0.01482317f, -0.06093315f, -0.02528924f, -0.02557426f, -0.07568748f, 0.10514873f, 
    -0.02698222f, -0.04553114f, 0.10660927f, 0.08885582f, 0.02564720f, -0.08264209f, 0.01179968f, 0.04361266f, 
    0.10654962f, 0.13561144f, 0.06385636f, 0.04155837f, 0.07044645f, 0.21815053f, 0.17349739f, -0.14749357f, 
    0.02048141f, -0.06832647f, -0.02213008f, 0.01439389f, -0.06288432f, -0.03150585f, 0.03550128f, -0.12120760f, 
    -0.15586898f, -0.26089391f, 0.11209686f, -0.06509364f, -0.02502085f, -0.06270770f, -0.03908709f, 0.05975883f, 
    0.08556461f, 0.00620585f, 0.06335678f, 0.03931473f, -0.31432498f, 0.13095386f, 0.00586728f, 0.13183121f, 
    -0.03167304f, 0.00547514f, 0.07734139f, 0.11212759f, -0.02151603f, 0.07958431f, 0.01394089f, 0.00716888f, 
    0.23270948f, -0.08206207f, 0.20547716f, -0.05090183f, 0.02276138f, 0.07432094f, -0.02297263f, -0.07138544f, 
    0.03398335f, 0.04656788f, 0.04375881f, 0.03640183f, 0.04599679f, -0.16214056f, 0.00037496f, -0.05657838f, 
    -0.05849541f, 0.01475536f, -0.03684249f, 0.02757328f, 0.00047190f, -0.00977264f, 0.05925144f, 0.12165286f, 
    -0.06599604f, -0.03020306f, -0.04129613f, 0.07330255f, 0.00345710f, -0.00372934f, 0.05498101f, 0.01963567f, 
    0.04772603f, 0.03762760f, 0.06311060f, -0.09889612f, -0.48776799f, 0.06937397f, 0.01837722f, -0.01975404f, 
    -0.01169272f, 0.01465130f, 0.06875196f, -0.04724899f, -0.00523205f, 0.11699294f, -0.10220913f, 0.04403996f, 
    -0.03908353f, -0.14934032f, 0.02215840f, 0.08862334f, 0.06622025f, 0.12152556f, 0.06081900f, 0.00155860f, 
    -0.03653402f, 0.05293631f, 0.01974555f, 0.04460401f, -0.04385222f, -0.09366935f, 0.04762399f, -0.38580093f, 
    -0.07690278f, -0.05877218f, 0.02527874f, 0.01327292f, -0.01925574f, -0.07711830f, 0.10541371f, 0.05812547f, 
    0.23079759f, -0.26583749f, -0.11186182f, -0.05890244f, 0.05676585f, -0.03633546f, 0.04053462f, -0.09639315f, 
    -0.00965294f, 0.04365342f, 0.17346787f, 0.06014690f, -0.21621272f, -0.29639417f, 0.08025879f, 0.15563124f, 
    0.12806660f, 0.00042189f, 0.07630751f, -0.01056671f, -0.00477981f, -0.05350788f, -0.10597225f, -0.00616035f, 
    0.10320687f, 0.10205084f, 0.05542313f, 0.00782670f, 0.01621456f, 0.03926051f, 0.15567517f, 0.12705058f, 
    -0.04400107f, 0.04199097f, 0.10926991f, -0.00625726f, -0.08296726f, 0.13486658f, -0.01690754f, 0.02833910f, 
    0.01797751f, 0.04528082f, 0.04493435f, -0.03782487f, 0.12236682f, 0.03082195f, 0.05582309f, -0.00416924f, 
    -0.14337902f, 0.23178373f, -0.01243310f, 0.23294672f, -0.13773847f, 0.07561823f, -0.07923684f, 0.03445202f, 
    0.03844552f, -0.01316977f, -0.03783716f, -0.05237084f, 0.21308434f, 0.14078176f, 0.12904257f, 0.03042247f, 
    -0.01732724f, 0.03348163f, -0.13393885f, 0.04955351f, 0.06860694f, 0.21110599f, 0.13121091f, 0.00374327f, 
    0.17225310f, -0.11331902f, 0.04345338f, -0.21076296f, 0.01568754f, 0.03755298f, 0.01492873f, 0.13069639f, 
    0.14471306f, -0.07268067f, 0.00830146f, 0.02462412f, 0.11441001f, -0.10521236f, -0.14728558f, 0.27417013f, 
    0.17508987f, 0.02993969f, -0.09849757f, -0.03970439f, 0.07678311f, 0.04922840f, 0.00766561f, 0.02013775f, 
    0.21289039f, -0.16111420f, -0.06930263f, -0.05678722f, 0.10541128f, 0.02624827f, -0.01900079f, 0.04037371f, 
    0.02621683f, 0.04489099f, -0.11069861f, 0.16149534f, -0.33148581f, -0.05003386f, -0.01927842f, -0.16012572f, 
    0.09449919f, 0.11604076f, -0.07244252f, 0.11137535f, -0.00655473f, 0.10295897f, 0.01577593f, -0.02713853f, 
    -0.03397582f, -0.03054402f, -0.05579058f, 0.03721022f, 0.08583562f, 0.05707391f, 0.03229750f, -0.06347305f, 
    0.02461705f, -0.05667028f, 0.08783023f, -0.03343970f, 0.01815372f, -0.01135560f, -0.18869893f, -0.01231055f, 
    0.12523556f, 0.03025757f, 0.07285931f, -0.06056200f, 0.06127765f, 0.11855188f, 0.06776609f, 0.05289657f, 
    0.05787006f, 0.20634893f, 0.27196267f, 0.16416489f, -0.18861152f, -0.02868538f, 0.00553272f, -0.09038591f, 
    -0.02335480f, 0.07531448f, 0.03496903f, -0.01717411f, -0.17970617f, -0.01225850f, -0.01138632f, -0.00339198f, 
    0.10266206f, 0.11721024f, 0.13695069f, -0.03076717f, 0.07328340f, 0.02571345f, 0.02848943f, 0.00025888f, 
    0.21412823f, 0.02395910f, -0.01703620f, 0.03875720f, -0.03102729f, 0.00238116f, 0.00201843f, -0.01427338f, 
    -0.15950204f, -0.07953451f, 0.04911465f, -0.00906694f, 0.09406478f, -0.14472172f, 0.11542654f, 0.02165417f, 
    -0.03663616f, 0.07808633f, 0.09423405f, 0.04167043f, -0.04351446f, -0.10729175f, 0.06164438f, -0.03272939f, 
    0.13630877f, 0.07484297f, 0.01708772f, 0.00473671f, -0.01865004f, 0.01918961f, -0.06122182f, -0.02028079f, 
    0.09794335f, -0.04674277f, 0.02882136f, -0.04077945f, 0.01212000f, -0.17773521f, -0.24673793f, 0.03729762f, 
    0.15485486f, -0.01329170f, 0.02151811f, -0.03001771f, 0.13085307f, 0.02236469f, 0.13671903f, -0.05291800f, 
    0.02239364f, 0.24436069f, 0.06605932f, 0.17207308f, -0.07867184f, -0.05679409f, 0.11431023f, 0.04748964f, 
    -0.04162893f, 0.07856992f, 0.10951438f, 0.03838018f, 0.32813537f, 0.13829920f, 0.12406109f, -0.01987281f, 
    -0.03700896f, -0.00133767f, -0.03340544f, 0.09321568f, 0.03575034f, 0.06427033f, -0.05840131f, 0.01662023f, 
    0.14795706f, 0.01285145f, 0.13479275f, 0.17863360f, -0.02533583f, -0.03936088f, -0.02049560f, 0.14308651f, 
    0.07780831f, -0.15070513f, 0.05616159f, 0.01786003f, -0.01346679f, 0.04884428f, -0.08803236f, -0.02873965f, 
    0.10294586f, 0.01810365f, 0.01936982f, -0.06287152f, 0.08273260f, 0.03374486f, -0.00259723f, -0.14100274f, 
    0.20312920f, 0.14142492f, 0.01992450f, -0.18972310f, -0.02280353f, -0.17040050f, 0.03468173f, -0.05194670f, 
    -0.10239521f, -0.06172386f, 0.05155167f, 0.01623942f, -0.17787775f, 0.07336754f, -0.08765323f, 0.14618114f, 
    -0.06846432f, 0.04901902f, 0.07249065f, 0.02906356f, 0.10295457f, 0.03288701f, -0.04953676f, 0.02715117f, 
    -0.18454964f, -0.09159425f, -0.14227547f, -0.14936320f, 0.10039524f, -0.01291290f, -0.05036182f, 0.05508910f, 
    0.03927073f, -0.02269226f, 0.12901296f, -0.00743161f, -0.22957611f, 0.08533247f, -0.17821367f, -0.02208504f, 
    -0.08713522f, -0.08174473f, 0.05379158f, -0.05859283f, -0.02808918f, 0.12057211f, -0.01528970f, 0.07021156f, 
    -0.27905449f, 0.04257172f, -0.09427027f, -0.06205948f, -0.02283683f, 0.02613552f, 0.13256568f, -0.01584386f, 
    -0.00917842f, 0.03465756f, 0.12246002f, -0.02803553f, 0.07457995f, 0.16210395f, -0.02553686f, 0.19487602f, 
    -0.19833829f, 0.06218459f, 0.07341145f, 0.04323403f, -0.09676643f, 0.00737398f, 0.04306399f, 0.06830637f, 
    0.11611513f, -0.23419027f, -0.23206055f, 0.17644258f, 0.18456525f, 0.04105125f, -0.04264556f, -0.01465155f, 
    0.09064645f, 0.00111305f, 0.00255316f, 0.07721160f, -0.01807063f, 0.25330836f, -0.04487194f, 0.02077550f, 
    0.20482516f, 0.05384834f, -0.05843279f, 0.05030039f, 0.05779812f, 0.06499656f, -0.01235268f, -0.05302805f, 
    0.05503169f, 0.39160845f, 0.01963976f, -0.00510277f, -0.15551712f, 0.14566016f, 0.06759020f, 0.07332000f, 
    -0.03918715f, 0.00273322f, 0.00343969f, 0.04131174f, 0.24973181f, 0.09749943f, 0.03401237f, 0.07806736f, 
    -0.08376046f, -0.10579868f, 0.04928300f, -0.10660839f, -0.07464431f, -0.05175926f, 0.03320052f, -0.01573463f, 
    -0.03486501f, 0.04971870f, 0.19032106f, 0.06309635f, -0.14009176f, -0.09988078f, 0.13607663f, 0.02160653f, 
    0.04904689f, -0.06352268f, 0.07109525f, -0.10481259f, 0.20429125f, -0.06684474f, 0.09522427f, 0.13663174f, 
    0.00526898f, -0.12505484f, 0.10336788f, -0.03870548f, 0.09180676f, 0.04710421f, 0.01529286f, 0.00951152f, 
    -0.04012364f, -0.13339062f, -0.19689362f, 0.21793370f, 0.10186999f, 0.02138316f, 0.09289280f, -0.03073227f, 
    0.00650287f, 0.04103422f, 0.04957240f, -0.00643092f, 0.24082467f, 0.06141628f, -0.17227504f, 0.04553425f, 
    -0.00936456f, 0.03385591f, -0.02568812f, -0.06257930f, -0.03433682f, 0.02616383f, 0.03014838f, 0.03109213f, 
    0.10532343f, 0.06125601f, 0.03844110f, 0.19003019f, -0.18001552f, -0.06821647f, 0.11582474f, -0.01086314f, 
    -0.05798088f, -0.08769820f, 0.04955108f, -0.03148055f, 0.12934761f, -0.14810441f, 0.11271331f, -0.06323267f, 
    -0.06351422f, 0.11264474f, 0.02893105f, 0.14823282f, -0.01901012f, 0.05856785f, 0.00190566f, 0.04862761f, 
    -0.01133725f, -0.04260045f, 0.13451855f, -0.15869325f, 0.00441715f, 0.06094703f, -0.01227972f, 0.11822425f, 
    0.09665435f, -0.00624876f, 0.04302621f, 0.05351644f, 0.05479943f, 0.07804379f, 0.09420631f, -0.11950684f, 
    0.17396151f, -0.03678080f, 0.13877524f, 0.07604489f, 0.15265110f, 0.05322555f, 0.05382881f, 0.04192677f, 
    -0.01902158f, -0.15572090f, -0.14448979f, -0.17651030f, 0.07973348f, -0.01416801f, 0.02501734f, 0.01311398f, 
    -0.05593920f, 0.03448780f, 0.08230776f, 0.04001837f, 0.07125282f, -0.11723830f, 0.18647739f, -0.07045133f, 
    -0.09534784f, -0.06515377f, 0.00934068f, 0.04814488f, -0.02390097f, -0.01115060f, 0.03622525f, -0.06312966f, 
    -0.12110981f, 0.02587341f, -0.24848279f, 0.03486570f, 0.04017546f, 0.05983699f, -0.01984792f, 0.04616787f, 
    0.04656434f, 0.05042424f, 0.00202544f, -0.07879753f, 0.15813985f, 0.00804336f, 0.25805858f, -0.19531627f, 
    -0.06511504f, -0.08649600f, -0.10840303f, 0.03045112f, 0.03788380f, 0.15816090f, 0.04880078f, -0.06997491f, 
    -0.39533231f, 0.26119623f, 0.00387940f, 0.11119836f, -0.03979053f, 0.01395626f, -0.07992319f, 0.05715386f, 
    -0.08130062f, -0.05060106f, 0.04452959f, -0.01888782f, 0.09167807f, 0.10953654f, 0.08910526f, 0.02558793f, 
    -0.00984348f, 0.07683817f, 0.05113207f, 0.13128899f, 0.00157101f, -0.04436341f, 0.01737586f, 0.07353598f, 
    -0.08943675f, -0.17683624f, -0.14140032f, -0.10108994f, 0.11231694f, -0.00872077f, -0.03290518f, -0.03989543f, 
    -0.02176076f, -0.00398401f, 0.03627864f, -0.05802399f, 0.05352470f, 0.03127275f, 0.11973653f, 0.05113231f, 
    -0.07971370f, -0.01462633f, -0.03060221f, -0.03236602f, -0.00459968f, -0.10121631f, 0.07977927f, -0.04258605f, 
    0.08590383f, -0.11988309f, -0.01241029f, -0.16493043f, 0.00322939f, 0.07741879f, -0.01107919f, 0.03411873f, 
    0.13782503f, 0.09425218f, 0.06679205f, -0.01035861f, -0.20362094f, 0.07904883f, -0.10455573f, 0.08699477f, 
    -0.05486324f, -0.02680406f, -0.05895430f, 0.10684967f, 0.02605174f, 0.07612593f, -0.06306707f, -0.06723654f, 
    0.12321937f, 0.10648993f, -0.14407858f, 0.13758214f, -0.04292303f, 0.03759209f, -0.06970418f, -0.00698379f, 
    0.12411680f, 0.10756521f, -0.01510818f, 0.04555584f, 0.14110336f, -0.12295013f, 0.07739729f, -0.01019766f, 
    -0.13750292f, -0.01791319f, 0.03008113f, 0.10516109f, 0.06967169f, 0.06574284f, 0.05126959f, 0.09560840f, 
    0.06308441f, 0.16116275f, 0.11449162f, 0.14941503f, -0.24399288f, -0.05919295f, 0.00848492f, 0.01539712f, 
    -0.12267340f, 0.06075634f, 0.05583707f, -0.02378020f, 0.24454504f, -0.05494143f, -0.10978950f, -0.17883559f, 
    -0.03701960f, 0.03745501f, 0.08514663f, 0.10933888f, 0.07053228f, -0.01725235f, 0.08580265f, -0.01190689f, 
    0.01118980f, 0.05909359f, 0.04139796f, 0.12932242f, -0.18783726f, -0.04260752f, -0.09268302f, 0.04467245f, 
    0.05194091f, 0.06160111f, -0.09110594f, 0.08925270f, 0.14344545f, -0.01207550f, -0.27813441f, 0.10075817f, 
    0.16789475f, -0.01176456f, 0.04212980f, -0.03372080f, 0.12328783f, -0.05087206f, 0.13822584f, -0.02251589f, 
    0.19721165f, 0.06171317f, 0.14574908f, 0.20376359f, -0.18704200f, -0.01579642f, -0.01208142f, -0.06562263f, 
    -0.04750588f, -0.04031742f, 0.01668461f, -0.02700673f, 0.09710247f, -0.07405161f, 0.18311802f, -0.04025066f, 
    -0.01056273f, 0.08041598f, 0.06082197f, -0.06191754f, -0.00450331f, 0.00448108f, -0.07291663f, -0.05374943f, 
    0.09630258f, 0.04872485f, -0.13026655f, 0.06118289f, 0.05395937f, 0.03163596f, 0.01610082f, -0.06642960f, 
    0.12570556f, 0.02161945f, 0.00081998f, 0.07479755f, -0.02435556f, 0.14183666f, 0.01496137f, 0.11742934f, 
    -0.09731312f, -0.06982709f, -0.01050853f, -0.06742346f, -0.03396926f, 0.06230105f, -0.01590150f, 0.02245678f, 
    0.08865815f, 0.17235731f, 0.07055540f, -0.14465456f, -0.10243421f, -0.00748452f, 0.06217259f, -0.03635625f, 
    0.00236568f, -0.02351825f, 0.02517131f, -0.02575795f, 0.35995305f, 0.18277290f, 0.16100878f, -0.12296446f, 
    0.03004639f, 0.02918577f, -0.00008966f, -0.05621906f, -0.00912598f, 0.21150303f, -0.06487759f, -0.02532610f, 
    -0.26055160f, 0.16537105f, -0.30215248f, 0.17127623f, 0.15029579f, 0.05647087f, 0.14903174f, -0.06765389f, 
    0.02349829f, 0.03951143f, -0.01931142f, 0.08675089f, 0.49753636f, 0.24828617f, -0.07107753f, 0.06653957f, 
    0.01762684f, 0.04931068f, -0.05934980f, 0.00301303f, 0.07826467f, 0.00805237f, -0.06849995f, 0.09243571f, 
    0.03554121f, -0.23232895f, 0.04307259f, 0.06781273f, -0.03108390f, -0.02269265f, 0.01319364f, 0.10277529f, 
    0.01814176f, -0.02895783f, 0.09138991f, 0.06741764f, -0.17876108f, -0.32501769f, 0.01403807f, 0.07475955f, 
    -0.05336376f, -0.01056004f, 0.07633593f, -0.00963140f, -0.03943054f, -0.01376638f, 0.03777429f, 0.07771336f, 
    0.10034286f, 0.01993214f, -0.09510532f, -0.11819047f, 0.04578779f, 0.01855354f, 0.12201446f, -0.02315088f, 
    0.07660311f, 0.00584844f, 0.10718558f, 0.01132103f, 0.02453814f, -0.05711123f, 0.35488659f, 0.15539050f, 
    0.09274768f, 0.13521510f, 0.08883050f, -0.09970305f, 0.02812426f, -0.00386678f, -0.00793516f, 0.07868953f, 
    -0.18547544f, -0.15426417f, -0.17943296f, -0.16153876f, 0.01369635f, 0.01505590f, -0.00186850f, -0.06176340f, 
    0.11087447f, 0.00303713f, 0.01499562f, -0.02031884f, 0.26689124f, 0.10031175f, -0.07863716f, 0.09897197f, 
    0.04855868f, -0.05133684f, -0.02784777f, -0.06260818f, 0.03748664f, 0.01776204f, 0.10979361f, 0.04970126f, 
    0.27769336f, -0.09123071f, -0.00214960f, -0.05143139f, -0.06461934f, -0.01514523f, -0.04590759f, 0.02733019f, 
    0.08917063f, -0.02673673f, 0.09185377f, 0.11728664f, 0.02823611f, -0.01108920f, 0.06799632f, -0.01059109f, 
    0.00252835f, 0.04417583f, -0.00010673f, 0.08048820f, 0.09529715f, 0.02486133f, 0.06179446f, -0.01507221f, 
    0.15879871f, -0.23424086f, 0.03858912f, 0.26047385f, 0.01125083f, 0.05732682f, -0.03676546f, 0.00698243f, 
    0.02522377f, 0.05976675f, 0.00443268f, 0.09685449f, -0.30386806f, -0.10181798f, -0.07190651f, 0.10243505f, 
    0.04537071f, 0.12754439f, 0.06464309f, 0.04729900f, 0.09185874f, 0.06164527f, -0.08101500f, 0.10483260f, 
    -0.11501402f, -0.00638798f, 0.02171900f, 0.05052391f, -0.06849688f, 0.04164826f, 0.13443726f, 0.03945508f, 
    0.13373633f, 0.01491241f, 0.04688325f, 0.02425398f, -0.00241435f, -0.26113600f, 0.07692006f, 0.18511827f, 
    0.08782269f, 0.13122262f, -0.03798503f, 0.16383472f, 0.01624650f, 0.02600954f, 0.02063558f, -0.00543791f, 
    -0.09254223f, 0.02381444f, -0.08415452f, -0.26949102f, -0.08394461f, -0.09924790f, -0.03358068f, -0.12008781f, 
    -0.06801567f, 0.05732749f, 0.01381516f, -0.05711954f, -0.38706264f, -0.11720215f, -0.02229074f, 0.13567156f, 
    0.01329831f, 0.13416927f, 0.07722563f, 0.08759765f, 0.05719033f, -0.05204343f, 0.09787995f, 0.06565604f, 
    -0.12224494f, 0.05661725f, 0.07919229f, 0.16833790f, -0.01029513f, 0.04800560f, 0.07653911f, 0.02515926f, 
    -0.04254126f, 0.09144599f, -0.05850321f, -0.02939754f, 0.17176406f, 0.05119959f, 0.16365889f, 0.26242808f, 
    -0.02296543f, -0.01949321f, 0.16795009f, -0.01201824f, 0.18727359f, 0.02011573f, 0.04892315f, 0.07020342f, 
    0.21034645f, 0.07548306f, 0.04248557f, -0.00303308f, 0.06150937f, 0.03455460f, -0.04417452f, 0.01009169f, 
    -0.01442219f, -0.08923148f, 0.09234259f, 0.01456041f, 0.32562426f, -0.19920896f, -0.02712570f, 0.05917653f, 
    0.07704408f, 0.11559275f, 0.01237838f, 0.06253839f, 0.11097761f, 0.01165191f, 0.04039592f, -0.00829150f, 
    0.09843891f, 0.05241936f, -0.01142263f, 0.05677863f, -0.05220151f, -0.03193558f, 0.00578205f, -0.03000480f, 
    0.03091051f, -0.02747726f, 0.05626535f, 0.02662653f, 0.04933687f, -0.04893007f, 0.10639100f, 0.10351662f, 
    0.03878850f, -0.02073986f, 0.05754250f, 0.06115095f, 0.00302033f, 0.01802917f, -0.03750317f, -0.05153443f, 
    0.03411432f, 0.16325955f, 0.20791247f, 0.04567704f, 0.07757439f, 0.15554202f, 0.01188761f, 0.02158318f, 
    -0.01563295f, 0.00435231f, 0.14500412f, 0.02327208f, 0.18470661f, -0.01568435f, 0.23309210f, 0.13788420f, 
    0.04427886f, -0.02906356f, 0.17040485f, 0.02522619f, 0.11797152f, -0.01770332f, -0.08256599f, -0.01953419f, 
    0.18460047f, 0.01775740f, 0.14194389f, 0.05031312f, 0.02976588f, -0.04250963f, -0.05379276f, -0.09675272f, 
    0.03317372f, 0.06970058f, 0.05474791f, 0.01959464f, -0.05279554f, -0.01212431f, 0.04254526f, -0.06546144f, 
    0.02752020f, -0.12050066f, 0.12584259f, -0.01616799f, 0.13727419f, 0.06590628f, 0.02117544f, 0.03006796f, 
    -0.11733240f, -0.08397050f, 0.03634350f, -0.18498322f, -0.07909857f, 0.04470219f, -0.00756791f, 0.01205427f, 
    -0.00240694f, 0.06632004f, 0.08890498f, 0.03992798f, -0.01727943f, -0.03412620f, 0.17177224f, 0.04429470f, 
    0.00762611f, 0.02493170f, -0.05305805f, 0.14385282f, 0.06373478f, 0.11772331f, 0.04787648f, -0.00107258f, 
    -0.30293149f, -0.16889277f, -0.00381106f, -0.05589920f, 0.00732158f, 0.03347157f, 0.01180842f, -0.02063520f, 
    -0.00468801f, 0.06739125f, 0.07195080f, 0.06649027f, 0.00644865f, 0.20071581f, -0.05433412f, -0.02184187f, 
    -0.22107621f, 0.02984576f, 0.03684663f, 0.05794699f, 0.02386189f, -0.01093194f, -0.01994592f, 0.03330206f, 
    -0.13561812f, -0.21183133f, -0.09332882f, -0.04316870f, -0.01717871f, -0.04484067f, 0.02209552f, 0.11212952f, 
    0.03321189f, 0.01594110f, 0.08463280f, 0.02529481f, 0.10135590f, 0.37759665f, 0.17256537f, 0.21584646f, 
    0.17636925f, 0.08766967f, 0.01377156f, -0.00027309f, -0.06719597f, 0.04512226f, 0.02584691f, -0.01436424f, 
    -0.04787889f, 0.05375366f, 0.04371192f, -0.11784012f, -0.11499888f, 0.11748492f, 0.09877223f, -0.02187435f, 
    -0.02633106f, 0.08508705f, 0.01969735f, -0.01555787f, 0.19867533f, 0.01605936f, -0.19493116f, -0.15760723f, 
    -0.15039150f, -0.01317803f, 0.04648107f, -0.07632944f, 0.00371558f, 0.02424033f, 0.05361395f, 0.10258041f, 
    -0.04231039f, -0.10132047f, -0.13787432f, -0.16687413f, -0.05280026f, -0.11148681f, 0.05586092f, -0.07241449f, 
    0.05163108f, -0.05496994f, 0.01858706f, -0.06615024f, 0.02313892f, 0.01597638f, 0.03975299f, 0.21234652f, 
    0.01759992f, -0.04218799f, 0.07338145f, 0.04026985f, 0.07348692f, 0.04666723f, -0.06768243f, 0.02232459f, 
    -0.25604612f, 0.05783666f, 0.03077614f, 0.13144605f, -0.11698505f, 0.01659152f, 0.14756742f, 0.09655416f, 
    0.04008671f, -0.05743965f, 0.10124239f, -0.00444021f, 0.27060509f, 0.27227929f, 0.03123263f, 0.16522594f, 
    0.08704653f, 0.01967681f, 0.12001342f, 0.02880579f, 0.01844958f, 0.16561945f, 0.04189636f, 0.02627573f, 
    -0.02619424f, 0.11783571f, -0.19721597f, -0.13453743f, -0.14233543f, 0.00118663f, 0.04188684f, -0.06043844f, 
    -0.00843450f, -0.06704693f, -0.01795782f, 0.03319960f, -0.04539760f, -0.02827224f, -0.08938540f, -0.04673305f, 
    0.05023462f, 0.03415519f, 0.05527443f, 0.14732543f, 0.10383811f, 0.06643789f, 0.03128156f, 0.01806521f, 
    -0.06805296f, 0.26515818f, 0.15443605f, 0.11256722f, 0.08598131f, 0.04522776f, 0.07472870f, 0.09392948f, 
    0.02565478f, 0.05190620f, 0.09356719f, 0.09850525f, 0.24730334f, -0.12386107f, 0.09057316f, -0.00433158f, 
    0.09382201f, 0.11417447f, 0.13952047f, 0.00027418f, -0.04444039f, 0.00870123f, 0.08965003f, 0.09618708f, 
    -0.26296148f, 0.03607891f, -0.03177344f, -0.12426852f, -0.06880684f, -0.00286418f, 0.01098667f, 0.06609252f, 
    -0.05896413f, 0.06556110f, 0.03746693f, 0.10475462f, -0.09883211f, -0.04233495f, -0.06100740f, -0.08218158f, 
    -0.06433944f, 0.00816051f, 0.06866154f, 0.04627680f, 0.03474047f, 0.01291298f, 0.01646771f, -0.04206803f, 
    -0.47953603f, 0.01349623f, -0.07767792f, -0.10268406f, -0.02252262f, 0.00049726f, 0.01246773f, -0.05850684f, 
    0.05585083f, -0.06552920f, -0.06975248f, 0.06767811f, 0.19917133f, 0.07085463f, -0.01149543f, -0.11254965f, 
    -0.03365446f, -0.13819073f, 0.03159039f, 0.03035785f, 0.02010744f, -0.01570811f, 0.09760845f, -0.04657960f, 
    0.05581400f, -0.17251453f, 0.11914933f, 0.11642215f, 0.03381428f, 0.08349939f, 0.09037355f, -0.02065197f, 
    -0.06396453f, 0.08680897f, 0.04049603f, 0.05018918f, 0.20569393f, -0.11949389f, -0.13115089f, -0.15358981f, 
    -0.12978707f, 0.11974663f, -0.02024139f, -0.06602642f, 0.11115048f, -0.08172818f, 0.04901476f, 0.17285740f, 
    -0.24680737f, -0.05101356f, 0.03514153f, -0.17799830f, -0.10489251f, -0.07205238f, 0.02821394f, 0.01756553f, 
    0.01395940f, 0.00683599f, 0.01647505f, 0.02387278f, 0.15996630f, 0.04452939f, 0.12752193f, 0.05961005f, 
    0.00935954f, 0.09234980f, -0.05825721f, 0.01398445f, 0.08475301f, -0.06733866f, 0.04833791f, 0.02472168f, 
    -0.03222613f, -0.12668522f, 0.04306189f, 0.08298628f, 0.03161607f, 0.05954522f, 0.03985059f, 0.04224166f, 
    0.08625086f, 0.02853497f, 0.10889079f, -0.05038214f, -0.42619613f, 0.11083268f, 0.01209943f, -0.10081521f, 
    0.06230590f, -0.11253314f, -0.11085431f, 0.09546061f, 0.08403035f, -0.01275858f, -0.03822789f, 0.09776510f, 
    0.14323401f, 0.12114384f, 0.07988396f, -0.04339499f, -0.04122388f, -0.06839103f, 0.00487859f, -0.01213579f, 
    0.11276019f, 0.02202304f, -0.00759047f, 0.02098421f, 0.12741876f, -0.19086230f, 0.05007113f, -0.22751957f, 
    -0.05155193f, 0.14143337f, -0.01838744f, 0.03199765f, -0.00159148f, -0.03663383f, 0.06835984f, 0.08933375f, 
    0.08457300f, 0.04117635f, -0.10913973f, -0.23917274f, -0.13832207f, -0.06402603f, 0.02967252f, -0.03487026f, 
    -0.07175754f, 0.09481868f, -0.05701836f, -0.01745457f, -0.16391324f, 0.13516231f, 0.00677050f, 0.22644189f, 
    0.00973643f, -0.00898640f, 0.07801065f, 0.09906380f, -0.06852412f, 0.00631062f, 0.10081845f, 0.01248266f, 
    0.00176084f, 0.14992118f, -0.03447088f, -0.09199096f, -0.08470502f, 0.03168857f, -0.10470691f, -0.14777617f, 
    0.03645243f, 0.06095674f, -0.07190788f, 0.11727230f, 0.04867176f, -0.10114957f, -0.07016993f, -0.01991118f, 
    0.06013433f, 0.09803850f, 0.05491763f, 0.08675941f, 0.08666372f, -0.00129854f, 0.04472711f, 0.02798022f, 
    0.02956427f, 0.12953654f, -0.15708701f, -0.24308182f, -0.19946010f, -0.00168768f, 0.00573588f, -0.06512052f, 
    -0.03087308f, -0.00600444f, -0.03750997f, 0.09076796f, -0.10060756f, 0.11740936f, 0.28269610f, -0.00765683f, 
    0.06331448f, 0.05234614f, 0.03667898f, -0.02963411f, 0.07121481f, 0.00657856f, -0.03042190f, 0.01709727f, 
    -0.08896422f, -0.19381507f, -0.09845713f, 0.28736502f, 0.10065451f, 0.19570377f, -0.07839997f, 0.18230781f, 
    0.04315684f, 0.03326148f, -0.10911660f, 0.11176537f, -0.00012019f, 0.14345856f, 0.03714471f, -0.07194997f, 
    -0.13242747f, -0.13436982f, -0.00022560f, 0.03642056f, -0.00319785f, 0.03881179f, -0.03595857f, -0.04092881f, 
    -0.28356972f, 0.01865299f, -0.06819451f, -0.15153596f, -0.04523893f, 0.01908689f, -0.00232091f, 0.05863417f, 
    0.11526166f, -0.04059282f, -0.05434964f, 0.11378856f, 0.04670604f, 0.24507041f, 0.07781880f, 0.01728831f, 
    0.02670715f, -0.02413617f, 0.05081831f, -0.01548655f, 0.08394159f, 0.14983097f, -0.05730605f, 0.04952974f, 
    -0.29992211f, -0.30179796f, 0.08666007f, 0.09795029f, -0.02840544f, 0.08813589f, -0.04156871f, 0.06309791f, 
    -0.05457083f, 0.04486923f, 0.00696715f, 0.10322152f, -0.06407835f, 0.23963249f, 0.07027917f, 0.13442615f, 
    0.04043051f, 0.11087243f, -0.01436776f, 0.10524949f, 0.08630756f, 0.04803517f, -0.12530342f, 0.18483864f, 
    0.10991440f, -0.19002053f, -0.02947518f, -0.02270331f, -0.01626943f, -0.05192503f, 0.06833074f, 0.13218996f, 
    0.05779270f, -0.02331888f, -0.08953532f, -0.07341764f, 0.20739375f, 0.07380100f, 0.17606896f, 0.11853749f, 
    0.09486455f, -0.10018295f, -0.07006680f, 0.02502422f, 0.05046205f, 0.20177105f, 0.11345088f, 0.25526595f, 
    -0.01883193f, 0.02805637f, -0.09279855f, 0.03752311f, -0.18355350f, -0.01785072f, -0.00362025f, 0.01577384f, 
    0.07753623f, -0.23633814f, 0.09617518f, -0.03751529f, 0.04309541f, -0.00964757f, -0.18044721f, -0.09268734f, 
    -0.03388584f, 0.01711753f, -0.02380797f, -0.09216021f, 0.01036546f, -0.01916627f, 0.00485105f, -0.00822259f, 
    0.21990606f, 0.05540143f, -0.12326168f, 0.06218498f, 0.06129250f, -0.15038592f, 0.00510550f, -0.12581646f, 
    0.04053935f, 0.20173185f, 0.06295695f, 0.04583192f, -0.10892858f, -0.26531458f, -0.01149473f, 0.09377433f, 
    0.04820903f, -0.10297126f, 0.19071932f, 0.11201772f, -0.08697530f, 0.03627102f, 0.08974717f, 0.00571567f, 
    -0.25508246f, 0.05680748f, -0.21604648f, -0.17308240f, 0.02257299f, 0.17114510f, -0.10399007f, 0.08866821f, 
    -0.05870825f, 0.10455504f, 0.10104591f, -0.07962508f, 0.08924542f, -0.03561327f, 0.11494041f, 0.18551350f, 
    -0.00363545f, -0.04688821f, 0.03162504f, 0.07287121f, -0.01897063f, 0.14061537f, 0.01493439f, 0.09680762f, 
    -0.22955333f, 0.25026608f, 0.10854968f, 0.08996805f, -0.03008760f, -0.05604794f, 0.00471028f, -0.04276764f, 
    -0.02839087f, -0.14941664f, 0.05274198f, 0.00473990f, 0.10194747f, 0.16232063f, -0.02132513f, 0.18730748f, 
    -0.08491935f, 0.08600911f, 0.07711124f, -0.12073356f, -0.08291377f, -0.05207716f, -0.00701611f, 0.07859632f, 
    0.22355533f, -0.14151053f, 0.12579471f, 0.04805176f, 0.03876669f, -0.09400867f, 0.06633320f, 0.00184841f, 
    0.13030609f, 0.12468988f, -0.05811913f, 0.06266633f, 0.02189849f, -0.00662440f, 0.16500741f, 0.08971015f, 
    -0.08664530f, 0.00881080f, 0.01917532f, 0.05773562f, 0.08980481f, -0.06048101f, 0.06926239f, 0.11409450f, 
    0.23171723f, 0.04258949f, 0.03043118f, 0.03156940f, 0.08114590f, 0.01910514f, -0.04725815f, -0.08857930f, 
    0.08224620f, -0.05324464f, -0.00631398f, 0.24207094f, 0.47216687f, -0.22375689f, 0.06524221f, -0.03079222f, 
    -0.04670281f, -0.03395578f, -0.02335932f, 0.01806629f, 0.03716316f, 0.07544038f, -0.06118435f, 0.00302636f, 
    0.16220489f, -0.08838173f, -0.05839497f, -0.15443143f, -0.12205710f, 0.04738979f, -0.14303777f, -0.03510563f, 
    0.27571207f, 0.12447657f, 0.13949107f, 0.13673387f, -0.08594137f, 0.00354600f, 0.02866482f, -0.28362119f, 
    -0.01344216f, 0.00309230f, -0.21496868f, -0.05444001f, -0.06373338f, 0.12557448f, 0.07192129f, 0.08705122f, 
    -0.24646913f, -0.13387497f, 0.07663997f, 0.13161157f, -0.00204699f, -0.01949790f, -0.00509237f, 0.06969676f, 
    -0.15576802f, 0.15455151f, 0.00190141f, 0.16135295f, 0.15258263f, -0.00351980f, 0.22985290f, 0.27489904f, 
    -0.05720095f, -0.16142976f, 0.05532853f, 0.02790196f, 0.02302449f, 0.05579321f, -0.06889760f, 0.10590741f, 
    -0.20449059f, 0.13262044f, 0.02710480f, -0.23656851f, 0.08034465f, -0.04101151f, 0.03904317f, -0.04664730f, 
    0.00234064f, 0.04442035f, -0.27996573f, -0.06004615f, -0.25099203f, -0.14635541f, 0.27516571f, -0.03519060f, 
    0.00817452f, 0.06715196f, 0.00025022f, 0.01138440f, -0.00489798f, -0.12292685f, -0.03384337f, -0.14101088f, 
    -0.16144124f, -0.02528851f, 0.12969452f, -0.12192193f, 0.02882876f, -0.07492379f, 0.00886406f, 0.05627234f, 
    0.09001368f, 0.17753609f, -0.03244471f, 0.26002884f, 0.04484469f, 0.02285220f, 0.20233192f, 0.21470845f, 
    -0.02844668f, 0.01467433f, 0.03049008f, 0.08836671f, -0.18839017f, -0.18763493f, 0.08758263f, 0.23008087f, 
    -0.05571986f, 0.10132661f, 0.12739040f, -0.09903991f, 0.01674798f, 0.01433205f, 0.08105429f, 0.12573272f, 
    0.19025427f, 0.16427283f, -0.10391182f, 0.06731388f, 0.12955455f, -0.10081258f, -0.07041659f, 0.04580223f, 
    0.13172741f, 0.20826025f, -0.13289563f, -0.09944118f, -0.15048002f, -0.17573306f, -0.03174486f, -0.16224071f, 
    0.19730239f, 0.07327630f, 0.06943652f, 0.05197913f, 0.04147820f, -0.04575662f, -0.03300596f, 0.02069008f, 
    -0.06151331f, 0.01202067f, 0.05608628f, -0.16315649f, 0.00816939f, -0.05865834f, 0.23857100f, -0.02825722f, 
    0.04017189f, 0.07095496f, 0.13833968f, -0.01253716f, 0.16835614f, -0.21314439f, 0.10163960f, -0.02239627f, 
    0.15927237f, -0.29932770f, 0.06881374f, -0.08313327f, -0.03362995f, -0.05969442f, -0.05636460f, 0.07583696f, 
    0.12221878f, -0.01685419f, -0.04319136f, 0.03304972f, 0.43545347f, -0.02617788f, -0.17329553f, -0.09469473f, 
    0.16880724f, 0.05743296f, -0.08042725f, -0.13981013f, -0.08942904f, -0.13041195f, -0.00664198f, -0.00321815f, 
    0.21136688f, 0.03516122f, 0.24825186f, 0.26073712f, -0.05862409f, 0.09244799f, 0.05399364f, -0.03312278f, 
    -0.01394913f, 0.05913436f, 0.06463601f, 0.16646034f, -0.07348765f, -0.15658928f, 0.06356976f, 0.09674097f, 
    -0.05484068f, -0.10630763f, -0.05350420f, 0.06179513f, 0.04953161f, -0.00990093f, 0.01660047f, 0.08170873f, 
    -0.06244347f, 0.03877012f, -0.20148170f, -0.00263054f, 0.00365634f, 0.03075004f, 0.00410948f, 0.02034580f, 
    0.11343627f, 0.04088429f, -0.14288890f, 0.06647018f, -0.08221657f, 0.06947870f, -0.09178223f, -0.07916202f, 
    0.00389777f, 0.11552256f, 0.20875622f, 0.03727972f, 0.03118042f, 0.03124251f, 0.16538540f, -0.16884044f, 
    -0.19285625f, 0.19225739f, -0.15084814f, 0.02588255f, -0.10088044f, 0.04915345f, -0.05478026f, -0.19243816f, 
    -0.02513846f, 0.03197847f, 0.09010076f, 0.18070762f, -0.60681844f, 0.30868855f, -0.01537724f, -0.28288686f, 
    0.02970326f, -0.00975600f, 0.11070068f, 0.07836363f, 0.03205717f, -0.13177027f, -0.09908359f, -0.01818395f, 
    0.15739845f, 0.04588749f, 0.19523793f, -0.06596937f, 0.07078224f, 0.09256771f, 0.02575197f, -0.07104337f, 
    -0.08703838f, 0.04697483f, -0.11565369f, 0.16426843f, 0.05346078f, 0.02141543f, 0.11913265f, -0.00806630f, 
    -0.01478174f, -0.00583075f, -0.03262709f, 0.12861216f, 0.10343526f, 0.03968140f, -0.00951081f, 0.10219362f, 
    -0.17506622f, 0.17745848f, 0.00274413f, 0.03035694f, 0.00735685f, 0.09197579f, -0.10685890f, -0.12668963f, 
    0.14279838f, -0.06613000f, 0.12647106f, -0.05216520f, -0.31354868f, 0.22463673f, -0.01819978f, -0.00536406f, 
    0.13222986f, -0.07384544f, 0.00202386f, -0.01036237f, 0.02280971f, -0.01960754f, 0.04449227f, 0.00097292f, 
    0.02962499f, -0.06647230f, -0.04363193f, -0.02288584f, -0.04402535f, 0.03237447f, -0.04757170f, 0.12883009f, 
    -0.00750795f, 0.05245522f, -0.07272979f, -0.11306262f, 0.11360521f, -0.07791115f, -0.11077383f, 0.01846950f, 
    -0.05097439f, -0.00507224f, -0.09990449f, 0.04591728f, -0.05329933f, -0.03403879f, 0.07381397f, -0.09641583f, 
    0.27850926f, 0.09522191f, 0.13277519f, -0.06713831f, 0.00981759f, 0.11561196f, 0.09584191f, -0.01150910f, 
    0.14152342f, -0.09273003f, -0.16402014f, -0.13563496f, -0.59122497f, 0.13342287f, 0.05578450f, -0.13352562f, 
    0.03872064f, 0.12800446f, -0.03866468f, -0.08172759f, 0.05414772f, -0.02291160f, 0.02485326f, 0.05966231f, 
    0.28495261f, 0.07744770f, 0.02699625f, -0.14089401f, -0.02001784f, -0.07381982f, -0.04333735f, -0.18194857f, 
    -0.13652970f, 0.02054138f, 0.04274599f, 0.06000232f, -0.31769988f, -0.01276015f, -0.15760916f, 0.00522668f, 
    0.09697526f, 0.08644331f, 0.12353349f, 0.08776212f, -0.01593907f, -0.00541584f, -0.08949839f, -0.03077453f, 
    -0.42720759f, -0.04410709f, 0.15192711f, 0.04756024f, -0.00698633f, -0.12359568f, -0.14296106f, -0.01032095f, 
    0.10771940f, 0.00297505f, -0.07410776f, 0.03746781f, 0.00835119f, -0.11757656f, -0.16626957f, 0.14057355f, 
    -0.06625197f, 0.07168371f, -0.07225691f, -0.04825030f, -0.14443435f, -0.24414398f, -0.09590594f, -0.05461451f, 
    0.12787251f, 0.12680036f, 0.14241464f, 0.20483875f, 0.11417560f, -0.02987079f, 0.11049411f, 0.01574064f, 
    0.00575644f, 0.03772609f, 0.03543938f, -0.08252890f, -0.21522586f, -0.12383334f, 0.28735957f, 0.18644015f, 
    -0.01990335f, -0.13464761f, 0.14667918f, 0.06295425f, -0.01852562f, 0.22395316f, 0.02665775f, 0.03672725f, 
    -0.18629140f, -0.08646066f, -0.08713342f, 0.10807031f, 0.00068118f, 0.04354387f, -0.10144851f, 0.17872794f, 
    -0.06826106f, 0.01642712f, -0.02262754f, 0.07494603f, -0.30647582f, 0.23159412f, 0.11936142f, -0.10825937f, 
    -0.06397646f, -0.02779159f, -0.00421669f, 0.04077412f, -0.05758605f, 0.13451983f, 0.14654428f, -0.08370029f, 
    -0.07232434f, -0.04397205f, 0.17876776f, 0.24780524f, 0.09652103f, 0.07019514f, 0.05858213f, -0.04128506f, 
    -0.01578391f, -0.10612248f, -0.10311551f, 0.06520267f, -0.38628772f, 0.25351277f, -0.08320073f, 0.02799051f, 
    -0.00043259f, 0.01954830f, -0.08286661f, 0.11200435f, 0.05659586f, -0.10893323f, -0.02815630f, -0.12532058f, 
    -0.07992961f, -0.04755340f, -0.10261706f, -0.06159697f, 0.12420484f, 0.19187897f, 0.07609127f, 0.01626563f, 
    0.19691221f, 0.00745712f, 0.14414434f, -0.03264074f, -0.20364839f, -0.02639537f, -0.02468243f, 0.04887296f, 
    -0.00649130f, 0.01816503f, -0.21100399f, 0.03240909f, 0.07452560f, 0.11082373f, 0.08811047f, -0.01787131f, 
    -0.06260286f, 0.01471435f, -0.08046427f, 0.14561713f, 0.21487457f, 0.13973573f, 0.03626807f, 0.09062617f, 
    -0.06129701f, -0.04953361f, 0.10678167f, -0.08613845f, 0.09361881f, -0.19025619f, 0.00428195f, 0.16751616f, 
    0.04150827f, 0.14849481f, -0.02467521f, 0.05345401f, 0.09188965f, -0.03861655f, -0.01894322f, 0.19886057f, 
    0.10469668f, -0.04710991f, -0.08847800f, 0.13896768f, 0.12313528f, 0.09342575f, 0.16365097f, 0.03941729f, 
    0.05696635f, -0.09424368f, 0.02185571f, -0.11730541f, -0.37511677f, -0.10942726f, -0.22534563f, -0.11926642f, 
    0.17019241f, -0.04716078f, -0.01834987f, 0.01553942f, -0.01213258f, 0.04919633f, -0.02454114f, 0.13174970f, 
    -0.03264374f, 0.11042456f, -0.11846482f, -0.06909207f, 0.08373470f, -0.03113727f, 0.14411372f, 0.00863277f, 
    0.02394180f, -0.07488567f, -0.00337098f, 0.02575289f, 0.17658560f, -0.09409256f, 0.04577433f, 0.10993131f, 
    0.15891419f, 0.04466715f, 0.13234401f, 0.01721366f, 0.07445349f, 0.07459681f, -0.06077698f, -0.02796199f, 
    -0.22016069f, -0.03559003f, -0.00768653f, 0.10058647f, 0.15085484f, 0.03840072f, -0.02474807f, 0.09838083f, 
    0.09232231f, 0.09696323f, 0.09146845f, 0.17769748f, -0.25704929f, -0.00743332f, -0.06904153f, -0.05331767f, 
    0.15670489f, -0.09399832f, 0.01058194f, 0.10412320f, -0.09710540f, -0.15475309f, 0.10187646f, -0.04159667f, 
    0.15290365f, 0.00207866f, -0.00466630f, -0.07964708f, -0.01197104f, 0.08490915f, -0.02003082f, -0.12592253f, 
    0.12835933f, -0.03534229f, 0.01951732f, -0.09020209f, -0.34510800f, 0.18835080f, -0.04498168f, 0.24283348f, 
    0.05717074f, -0.11343197f, 0.08615182f, 0.06172860f, 0.04385411f, 0.02896526f, 0.04766740f, -0.06541932f, 
    0.01795596f, -0.02727211f, -0.00201075f, -0.03858020f, -0.03776715f, -0.02250815f, -0.00356690f, 0.02771277f, 
    -0.02461162f, -0.00068412f, -0.00342269f, 0.02590619f, 0.01419650f, -0.00476823f, 0.02897329f, -0.01624631f, 
    -0.03150533f, -0.00190479f, -0.03676163f, 0.00754611f, -0.01839683f, -0.01112794f, 0.00119036f, -0.02529477f, 
    0.00149552f, 0.01886875f, -0.00381472f, -0.02946656f, 0.01589472f, -0.00777386f, -0.03340695f, -0.00709535f, 
    0.00557864f, -0.03376694f, -0.00283752f, 0.00762207f, 0.01964276f, 0.00746516f, -0.00830897f, -0.02000480f, 
    -0.01369127f, -0.00562676f, 0.02948814f, -0.04086009f, -0.03710210f, 0.02067955f, -0.03893697f, 0.02139720f, 
    0.01382412f, 0.01573028f, -0.00374928f, 0.01027119f, -0.03215741f, -0.03291771f, -0.01378661f, 0.01524978f, 
    -0.04044920f, 0.02671937f, -0.03444875f, 0.02343950f, -0.02422768f, 0.02460406f, 0.00698244f, -0.01219572f, 
    -0.03167329f, -0.00029647f, -0.01307278f, -0.00957245f, 0.01227662f, -0.03445626f, -0.02784784f, 0.01943654f, 
    -0.02162125f, -0.01093498f, 0.02628852f, 0.01717369f, -0.02857270f, -0.03510725f, -0.00784436f, -0.01699308f, 
    -0.03693154f, -0.01939930f, 0.02546763f, 0.00424730f, -0.00067929f, 0.00145054f, -0.00675288f, 0.00896175f, 
    0.01489213f, 0.02754529f, -0.03698907f, -0.03621653f, 0.00831900f, -0.04084447f, 0.00350427f, -0.01405839f, 
    0.00502078f, 0.00229878f, 0.01126575f, 0.00317717f, -0.00715850f, -0.02288541f, -0.01519258f, -0.00441166f, 
    -0.04101754f, 0.01827572f, -0.01632462f, 0.02221010f, 0.01871218f, -0.03909529f, -0.01144958f, -0.03664010f, 
    0.00737687f, -0.03307193f, -0.02691115f, 0.03900909f, 0.01914288f, -0.00173187f, -0.00266803f, -0.02076992f, 
    -0.03000769f, -0.00610392f, -0.03907684f, -0.03823473f, 0.00052322f, -0.03898696f, 0.01433047f, 0.00131747f, 
    -0.00201999f, -0.01305714f, 0.01546349f, -0.03796080f, -0.03079227f, 0.01504607f, 0.01258025f, -0.00931172f, 
    0.01289348f, 0.01163292f, -0.02949087f, 0.02811144f, -0.01666299f, -0.02004209f, -0.03807367f, -0.01711048f, 
    0.00897499f, 0.01113892f, 0.00095241f, -0.00363529f, -0.03099851f, 0.02837315f, -0.00398934f, 0.00434720f, 
    -0.01247837f, 0.01742204f, 0.01671376f, 0.02600134f, 0.00951408f, -0.01329288f, 0.02494592f, 0.00100969f, 
    0.00891988f, -0.00072971f, -0.02466068f, -0.02446341f, 0.00713640f, -0.01034036f, -0.03582245f, -0.01197603f, 
    0.01269856f, -0.00295139f, 0.02444233f, -0.02326639f, 0.00088118f, -0.01906070f, 0.02875032f, 0.00438955f, 
    -0.02208329f, -0.02210080f, 0.01809523f, 0.00108953f, -0.02067460f, 0.01344224f, -0.02521913f, -0.00121518f, 
    -0.02555283f, -0.00167419f, -0.01238720f, 0.00681783f, -0.01330866f, 0.01168424f, 0.02281927f, -0.03923962f, 
    -0.03416292f, 0.02025183f, -0.00996469f, 0.01559610f, 0.00652650f, -0.00843246f, -0.03957796f, 0.02296312f, 
    -0.02114860f, -0.03067758f, -0.00009722f, 0.01502722f, -0.03492025f, -0.03248848f, 0.02671161f, -0.03229179f, 
    0.01343479f, -0.04065188f, 0.01121131f, -0.03219366f, -0.00662260f, 0.02341986f, 0.00064290f, 0.01134431f, 
    0.01576170f, -0.00243539f, 0.02917648f, 0.00053605f, -0.03573281f, 0.00086713f, -0.04152386f, 0.02854647f, 
    0.02858674f, -0.03966698f, 0.02386188f, -0.02557047f, 0.02337035f, -0.01868343f, -0.00135132f, -0.00810322f, 
    0.02556007f, -0.02376025f, 0.01484330f, 0.01669202f, -0.03038201f, -0.00716003f, 0.02430863f, 0.02237309f, 
    -0.01252586f, -0.00638629f, -0.03937959f, -0.01162938f, 0.01256747f, 0.00587600f, 0.01892781f, -0.01163467f, 
    0.00500488f, -0.03052116f, -0.02291719f, -0.01688947f, -0.03042158f, -0.02541289f, -0.03806432f, 0.00034615f, 
    -0.02580108f, 0.01278863f, -0.02888546f, -0.03621889f, 0.02046770f, -0.02142265f, -0.02514607f, -0.00380527f, 
    -0.03132577f, -0.00674252f, 0.02269883f, -0.00752778f, -0.00960574f, 0.02385641f, 0.00907953f, 0.00832483f, 
    -0.02964031f, 0.01336818f, -0.01331679f, -0.03075751f, 0.01444687f, -0.00201355f, -0.01702929f, -0.00854755f, 
    -0.03851016f, -0.04086852f, -0.02007830f, 0.02770056f, -0.00117329f, 0.02786774f, -0.03347323f, -0.01401443f, 
    -0.01416203f, -0.02538965f, -0.01122524f, -0.03419600f, -0.01536353f, -0.01608566f, 0.01254000f, -0.04191948f, 
    0.01253130f, -0.03508847f, -0.01528001f, -0.03066339f, -0.04196871f, 0.00973164f, -0.02011161f, -0.02480034f, 
    -0.02111013f, -0.00206400f, -0.02391195f, -0.01036144f, -0.01405308f, 0.02667068f, 0.00499543f, -0.03926655f, 
    0.00389132f, 0.00455925f, 0.02363432f, -0.00122184f, 0.01607543f, -0.01334168f, -0.02050009f, 0.02860824f, 
    -0.00364151f, 0.02980689f, 0.00837001f, -0.03509251f, -0.02684757f, -0.04011453f, -0.03756656f, 0.01339397f, 
    -0.03398164f, -0.02897088f, 0.02072055f, -0.02157832f, -0.02342140f, 0.02010424f, -0.01470941f, 0.01738385f, 
    -0.01544663f, -0.02850163f, 0.01805369f, -0.00469094f, 0.02429225f, 0.02774284f, 0.00545707f, -0.01269801f, 
    -0.00436757f, -0.00200767f, 0.01022586f, -0.01362489f, -0.00877028f, -0.03482639f, 0.00912264f, -0.03558663f, 
    0.00432011f, 0.02139428f, -0.03351036f, -0.02840000f, 0.01885952f, -0.01261893f, -0.03067660f, -0.02891907f, 
    0.00279749f, -0.02948003f, 0.01271206f, -0.01170928f, -0.03651625f, -0.01988408f, 0.00273514f, 0.02981079f, 
    0.00683344f, 0.02672342f, -0.02037301f, -0.00968212f, 0.01572965f, -0.01912658f, -0.02770306f, 0.02937442f, 
    -0.03486215f, -0.01635433f, 0.02911766f, -0.03520328f, -0.03548238f, -0.01091144f, -0.02326517f, 0.02179308f, 
    -0.02555953f, -0.03722780f, -0.03804589f, 0.00674273f, -0.02102295f, 0.01508410f, -0.03750719f, 0.00474952f, 
    0.00703785f, -0.02719725f, -0.02211749f, -0.01560812f, 0.02889051f, -0.01553489f, 0.01008764f, 0.01080474f, 
    -0.01911275f, 0.01876020f, -0.02061450f, -0.01700548f, -0.03002958f, 0.01011595f, 0.00520901f, 0.00303063f, 
    -0.00664162f, 0.02711924f, 0.01453613f, -0.00760405f, 0.01029553f, -0.03312508f, -0.00698454f, -0.01430837f, 
    -0.01188359f, 0.00237441f, -0.03965605f, -0.02058330f, -0.00859384f, -0.00823469f, -0.01397693f, 0.02256938f, 
    -0.00557564f, -0.03837311f, -0.01660493f, -0.03730620f, 0.00680884f, 0.03006490f, 0.02254780f, -0.00414563f, 
    0.02855692f, 0.00995696f, 0.01068948f, 0.02779199f, -0.00989201f, 0.01843224f, 0.02774055f, 0.02382239f, 
    -0.00246404f, 0.02972883f, -0.00583218f, -0.01619568f, 0.01480065f, 0.01115285f, -0.03479077f, -0.00522335f, 
    -0.03161313f, -0.01723404f, 0.03577418f, -0.02463073f, -0.01666814f, -0.01629149f, -0.01238384f, -0.01026057f, 
    -0.00975477f, 0.01017429f, -0.01240059f, -0.00457061f, 0.01211821f, -0.00160538f, 0.02028720f, 0.00763932f, 
    -0.01696885f, -0.03698899f, 0.02817165f, -0.04119143f, 0.02823234f, -0.01064852f, 0.02478955f, -0.02277017f, 
    -0.00919500f, -0.00478111f, -0.03590749f, 0.01096481f, 0.02173391f, 0.02437443f, -0.02364847f, -0.00154637f, 
    -0.03440216f, 0.01765319f, -0.01161909f, 0.02142001f, 0.02158344f, 0.01822360f, -0.03098728f, -0.02294988f, 
    0.02832253f, -0.03014711f, -0.02161309f, 0.00346399f, -0.01924236f, -0.03077821f, 0.02141576f, -0.01050066f, 
    -0.01279001f, -0.01737824f, -0.00177543f, 0.02236567f, -0.01180160f, 0.02436012f, -0.02756286f, -0.00648322f, 
    -0.00013692f, -0.00688940f, 0.00880978f, -0.00304005f, -0.01947908f, -0.00810412f, -0.01825355f, 0.00165151f, 
    -0.00908346f, -0.01577864f, -0.02724265f, -0.01622059f, -0.00484903f, 0.01545085f, -0.03201463f, 0.02636070f, 
    0.01199215f, -0.01737952f, -0.00210271f, -0.00656055f, 0.01054486f, 0.02450234f, 0.01596978f, 0.01668523f, 
    -0.03542733f, -0.03006739f, 0.02159798f, 0.00112179f, -0.01476059f, 0.02157969f, -0.01789662f, 0.02315943f, 
    0.02371376f, -0.01195868f, -0.00886538f, 0.00740273f, -0.00877444f, -0.00422946f, -0.00686306f, -0.00680234f, 
    -0.00980627f, -0.02175328f, -0.01919005f, -0.00183208f, 0.01029016f, 0.02436277f, -0.00938625f, -0.01088069f, 
    -0.04110370f, 0.02632343f, -0.04126203f, -0.01016908f, 0.00899721f, -0.00897660f, -0.00102137f, -0.00533295f, 
    0.01498675f, 0.01586671f, 0.00094120f, 0.02814263f, 0.00525197f, -0.03575777f, -0.03905424f, 0.00173403f, 
    -0.03865077f, -0.00406079f, -0.02378828f, 0.01018142f, -0.01635001f, 0.01693220f, -0.01008377f, -0.02451144f, 
    -0.02041481f, 0.02486921f, -0.01717506f, -0.00429553f, 0.02255772f, 0.01815470f, 0.01889383f, -0.01302974f, 
    -0.01812290f, 0.02342066f, -0.04156449f, 0.00225237f, 0.01785446f, 0.02837829f, 0.00010677f, 0.02481884f, 
    0.02968821f, -0.00812392f, 0.00173841f, -0.00081091f, 0.00766332f, 0.03153829f, 0.02668891f, -0.01654436f, 
    -0.01942432f, -0.02873786f, -0.01168517f, -0.00877465f, -0.03180935f, 0.02164571f, -0.00057846f, -0.04157389f, 
    0.00643827f, -0.01600806f, -0.00888628f, 0.02564339f, -0.00700609f, -0.01352193f, -0.04183366f, 0.04061770f, 
    0.01033938f, -0.03815320f, 0.00007107f, -0.01830495f, 0.02820600f, -0.01402297f, -0.02678099f, -0.01005097f, 
    -0.00995469f, -0.03475004f, -0.03128535f, -0.01070607f, -0.01734914f, 0.02804461f, -0.03985151f, -0.03994653f, 
    -0.03088453f, -0.03827080f, 0.00590761f, -0.00116316f, -0.02371797f, -0.02213699f, -0.03592961f, -0.01303469f, 
    -0.00958338f, -0.01143278f, -0.02823108f, -0.01363052f, -0.03503238f, 0.01185391f, 0.02767719f, 0.01007193f, 
    -0.02305650f, 0.00619850f, 0.00825745f, 0.01812536f, -0.01375231f, -0.01858928f, -0.00393993f, -0.01061828f, 
    -0.04155412f, -0.00860196f, 0.00993723f, -0.02037883f, -0.01660986f, 0.01221197f, -0.03093315f, -0.02348040f, 
    -0.02743453f, -0.01431936f, 0.02380408f, 0.02270191f, -0.02732937f, -0.01927853f, 0.01833439f, 0.00336135f, 
    0.01163187f, -0.03860914f, -0.02698227f, -0.00455232f, 0.01812647f, -0.02945264f, 0.00552525f, -0.00745643f, 
    -0.01753326f, -0.02550568f, -0.03454453f, 0.01756597f, -0.02034220f, -0.01158997f, -0.00162639f, -0.00677734f, 
    -0.00757805f, -0.01580181f, -0.03998391f, 0.01162078f, 0.00753145f, -0.02799760f, -0.02856420f, 0.02867625f, 
    -0.01441326f, 0.02260493f, 0.02690837f, -0.00224574f, -0.00135653f, -0.02567479f, -0.00677693f, 0.00033730f, 
    -0.03049835f, 0.01004606f, -0.00682993f, -0.00671211f, -0.03629251f, -0.02439812f, -0.01475963f, 0.01428386f, 
    -0.04093393f, 0.03006685f, 0.02575412f, -0.02561938f, 0.01693603f, 0.01218476f, -0.00112207f, -0.01431953f, 
    0.02388257f, 0.02044682f, 0.01860921f, 0.02107855f, 0.01871227f, -0.02558180f, -0.03246664f, -0.02358806f, 
    -0.00643762f, -0.03667893f, -0.00909895f, -0.01832756f, -0.02165448f, -0.01690766f, 0.01022754f, -0.02815830f, 
    -0.02819895f, 0.00172123f, -0.01957541f, 0.02120536f, -0.03021079f, 0.01905356f, -0.00826081f, -0.03349864f, 
    -0.01550868f, -0.00454994f, -0.03748548f, -0.02747983f, -0.00758988f, -0.03359412f, 0.01291857f, 0.02979747f, 
    -0.03235170f, 0.01223070f, -0.01084939f, 0.01613320f, 0.01121163f, -0.00473799f, 0.00682361f, 0.01254750f, 
    -0.03645171f, -0.03186915f, -0.02574425f, -0.00024691f, 0.02080515f, -0.01022125f, 0.00382289f, -0.03012000f, 
    0.21704368f, -0.11417716f, -0.00069190f, 0.05618648f, -0.07197713f, -0.05206933f, -0.05037714f, 0.02662538f, 
    -0.11018591f, 0.10292251f, -0.08029852f, -0.02967784f, 0.14660378f, -0.19868711f, -0.08850110f, 0.28847235f, 
    -0.21005280f, 0.07629232f, 0.08571141f, -0.09332136f, 0.08541390f, -0.02849057f, 0.00079435f, 0.00849954f, 
    0.20314828f, 0.03889643f, -0.08995105f, -0.00107634f, 0.02975366f, -0.00815252f, 0.03551230f, 0.04736849f, 
    0.06120291f, 0.05066014f, -0.09942052f, -0.05641749f, 0.27732161f, -0.15008660f, 0.10327585f, 0.04144574f, 
    -0.06460099f, 0.01737150f, 0.03013285f, 0.07574904f, -0.08856162f, 0.03526248f, 0.06122229f, -0.03243202f, 
    0.12124632f, -0.22196895f, -0.01753824f, -0.35971528f, 0.07145806f, -0.03290263f, 0.05591651f, -0.09293628f, 
    -0.06912984f, 0.00691340f, 0.01942263f, 0.06593311f, 0.13489039f, -0.03376544f, 0.00867523f, 0.03281535f, 
    0.02112586f, 0.16137375f, -0.05376184f, -0.07551038f, 0.05273992f, -0.00715824f, 0.01855073f, -0.01073323f, 
    0.22784221f, 0.04342898f, -0.08942957f, -0.04416131f, -0.12527877f, -0.03260987f, -0.03408309f, 0.00350039f, 
    -0.04766034f, -0.03203816f, 0.02209644f, 0.03592411f, 0.00119591f, -0.04952730f, 0.04390641f, 0.12171263f, 
    -0.15192263f, -0.01327284f, 0.04917475f, 0.00277641f, -0.05525710f, 0.02959679f, -0.01743366f, -0.07478338f, 
    -0.00533517f, -0.03129015f, 0.03587128f, 0.36079603f, -0.15182057f, 0.06302861f, -0.01823078f, 0.02248175f, 
    0.06784931f, 0.05130603f, 0.03102400f, -0.00236906f, 0.13134155f, -0.08904007f, -0.13771196f, 0.12635852f, 
    -0.07795142f, -0.11649169f, 0.01818839f, 0.09315624f, 0.01049384f, -0.01140218f, 0.02020887f, 0.01512830f, 
    0.06956009f, -0.05659585f, 0.05918847f, 0.15227249f, -0.18087824f, -0.02174199f, -0.01611832f, 0.05546974f, 
    -0.11339796f, -0.01289230f, 0.05796646f, 0.07428776f, 0.11470936f, -0.22409067f, 0.14340526f, -0.05196939f, 
    -0.00630440f, -0.00378070f, 0.00628157f, 0.13086781f, -0.03957564f, 0.04450168f, 0.01552325f, -0.04052203f, 
    0.08472381f, 0.21394016f, 0.02636129f, -0.27045029f, 0.02146892f, 0.01320181f, -0.01575736f, 0.03118377f, 
    0.03520771f, 0.02378518f, -0.03129764f, -0.00082386f, 0.01163842f, -0.15017548f, -0.14619783f, 0.04211460f, 
    -0.12325571f, -0.11546330f, 0.03718675f, 0.05201248f, -0.01606965f, 0.05237859f, 0.01330285f, -0.02028819f, 
    -0.02029665f, 0.16874982f, -0.08420254f, -0.16131228f, -0.02128665f, 0.02570312f, 0.09535995f, 0.02881584f, 
    0.00926172f, 0.07751513f, -0.06066627f, -0.00725205f, -0.02368404f, 0.07274805f, 0.00832386f, 0.22135200f, 
    0.14240833f, 0.10578586f, 0.05844378f, 0.05098303f, 0.10531113f, -0.04720481f, -0.05112830f, 0.03653199f, 
    0.15100366f, 0.00352462f, 0.11459666f, -0.08236524f, -0.04039209f, 0.01038170f, -0.03691850f, -0.02226212f, 
    0.02767097f, -0.04816227f, 0.06416469f, 0.01011483f, 0.19290134f, -0.07245313f, 0.12298080f, 0.22003549f, 
    -0.05802861f, -0.00360706f, 0.01698183f, -0.00139474f, -0.01138923f, -0.06909177f, -0.00522961f, 0.02408992f, 
    0.19496290f, 0.08691945f, 0.03017432f, -0.01012229f, -0.10776792f, 0.06561692f, -0.01704719f, -0.02109133f, 
    -0.03103694f, -0.00553182f, 0.08141911f, -0.02021560f, 0.03801734f, 0.22696061f, 0.04621767f, 0.02887978f, 
    0.01451375f, -0.03093752f, 0.07513710f, -0.00378192f, -0.05016267f, 0.06197817f, -0.15532441f, -0.15512055f, 
    -0.20570228f, 0.09004176f, 0.03145253f, 0.01946238f, -0.05220032f, 0.16191879f, -0.04800083f, -0.01856404f, 
    -0.08472943f, -0.03471148f, 0.00943122f, -0.01542205f, 0.04725888f, -0.07765489f, 0.17767534f, 0.13000335f, 
    0.11931945f, -0.02038226f, 0.05279301f, 0.00779375f, 0.11390776f, 0.09266246f, -0.05081237f, -0.02036195f, 
    0.08093932f, -0.13108380f, -0.06284251f, -0.11002547f, -0.04791092f, 0.06450862f, 0.00356309f, 0.01099295f, 
    0.00848252f, -0.05062332f, -0.02948082f, -0.02392770f, 0.11915368f, 0.09267234f, 0.09027047f, -0.15437037f, 
    0.08914518f, -0.03531175f, 0.04195093f, 0.04134188f, 0.07807339f, -0.00966378f, 0.01876171f, 0.00938128f, 
    0.01794267f, -0.06073279f, -0.03574780f, 0.22762701f, -0.14668640f, 0.06734324f, 0.08001937f, 0.01691273f, 
    0.07838012f, -0.00865907f, -0.04264098f, 0.04637564f, 0.08160008f, -0.11959735f, 0.32905477f, -0.13812290f, 
    0.04090702f, 0.10455490f, 0.03758410f, 0.00308682f, -0.08401924f, -0.02476841f, 0.00931576f, -0.07410236f, 
    0.03698562f, -0.20356356f, 0.11758653f, -0.15182343f, 0.08117577f, -0.13301034f, -0.06538225f, -0.03128613f, 
    0.02221885f, 0.05461159f, -0.09146168f, 0.10625145f, 0.12985559f, 0.12796110f, -0.12673922f, -0.17883618f, 
    0.01266528f, -0.13359506f, 0.11473611f, 0.01732828f, 0.00706027f, 0.09660458f, -0.03052596f, -0.02049790f, 
    -0.02612168f, -0.09528180f, -0.00285151f, 0.14207031f, -0.21435595f, -0.10114109f, 0.00588332f, 0.00550447f, 
    -0.02575447f, -0.01641612f, -0.00014167f, -0.02431147f, -0.02751328f, 0.05213576f, 0.01356729f, 0.24319160f, 
    0.03681381f, 0.00631503f, -0.04232999f, 0.00662429f, -0.09066195f, 0.00276623f, 0.02249139f, -0.03442526f, 
    -0.12207342f, 0.11617319f, 0.02228554f, -0.17794077f, 0.03113743f, 0.03724350f, 0.03209543f, 0.02218927f, 
    0.03403812f, -0.01549278f, 0.10699964f, -0.15698668f, 0.19544435f, -0.03232610f, -0.04316019f, -0.15511122f, 
    -0.00670818f, -0.05059881f, 0.00959517f, 0.05851810f, -0.03213497f, 0.09456395f, -0.04270476f, 0.16939345f, 
    0.30913463f, -0.19615561f, -0.10794554f, -0.05822958f, -0.03209073f, -0.00038232f, -0.07650676f, -0.04727084f, 
    -0.07541426f, 0.04589897f, 0.12353482f, 0.00580321f, 0.16816561f, 0.09135818f, 0.10341372f, 0.07918490f, 
    0.06078610f, 0.08952908f, -0.10459073f, -0.02269371f, -0.01258995f, 0.05020910f, -0.00054942f, 0.12495227f, 
    -0.15468709f, -0.04056733f, -0.01055494f, -0.22844298f, -0.13911647f, 0.00851126f, 0.02192408f, 0.10797980f, 
    0.10185485f, -0.06016700f, 0.03378158f, 0.01801506f, 0.02187688f, 0.06104777f, -0.22163877f, 0.05096193f, 
    0.03596727f, -0.02416595f, 0.09304203f, 0.02250229f, -0.00643950f, 0.01470278f, 0.05383459f, -0.03690374f, 
    0.17584436f, 0.21189864f, 0.00238050f, -0.07346462f, 0.04511647f, 0.01284686f, -0.00561532f, 0.02747933f, 
    -0.04737188f, 0.07297383f, -0.05601856f, 0.07552613f, 0.05251867f, 0.19479828f, -0.12237675f, 0.03491337f, 
    -0.06194185f, 0.06900796f, -0.01031786f, 0.01207201f, 0.01948242f, -0.03144389f, 0.06486081f, -0.00351094f, 
    -0.05950994f, 0.16321024f, -0.13352028f, 0.33508730f, 0.10142913f, -0.00445906f, 0.05680343f, -0.10328303f, 
    -0.02140483f, -0.06935361f, 0.03187035f, 0.03572140f, 0.18533970f, -0.12760186f, -0.03720452f, 0.32788387f, 
    -0.03916110f, 0.08522262f, -0.04466665f, 0.00271978f, -0.03734554f, 0.08432986f, -0.06454059f, 0.13447420f, 
    -0.10937647f, 0.13228379f, 0.08710478f, 0.11408924f, -0.10430585f, 0.01505299f, 0.03449672f, -0.01275841f, 
    -0.01846919f, -0.04759487f, 0.03994976f, -0.05172826f, 0.04306735f, 0.25031525f, -0.13797750f, 0.05229653f, 
    0.00597498f, 0.05978923f, 0.05606075f, 0.01239167f, 0.03889735f, 0.03063605f, -0.05871383f, 0.01959014f, 
    -0.14687409f, 0.15244702f, 0.09416524f, -0.05395463f, -0.07522974f, 0.00631336f, 0.09354763f, 0.04261702f, 
    0.11365864f, -0.12737457f, -0.12865436f, 0.04973707f, 0.26735112f, 0.12705606f, -0.12877327f, 0.07198281f, 
    -0.00204379f, 0.07757953f, 0.05237401f, 0.13081487f, 0.05319049f, -0.03565247f, 0.01522171f, 0.00475161f, 
    0.20420630f, -0.00977856f, 0.14728490f, -0.04288528f, -0.03479684f, 0.17122878f, -0.05883796f, -0.05907255f, 
    -0.04426722f, 0.05289793f, 0.01185805f, 0.02245214f, 0.05355074f, 0.14368105f, -0.04628415f, -0.02396947f, 
    0.08892483f, 0.02285083f, -0.05492978f, -0.00099583f, -0.08820534f, 0.10493731f, 0.05429809f, 0.03075837f, 
    -0.06840345f, -0.07843997f, -0.04249345f, 0.15507665f, -0.15898149f, -0.06694304f, -0.00080129f, -0.00629748f, 
    -0.04845274f, -0.01352680f, -0.03295570f, 0.04184362f, 0.13795350f, 0.19151127f, 0.15249115f, -0.11351980f, 
    0.12840925f, 0.07745203f, 0.00977685f, 0.00073898f, 0.02195872f, -0.05322814f, -0.00214947f, 0.07171211f, 
    -0.10201596f, 0.12525661f, -0.04329759f, 0.10194550f, -0.11745758f, -0.00084692f, 0.16258356f, -0.07770051f, 
    0.09184519f, -0.06114076f, 0.00472664f, -0.07475639f, -0.16764703f, 0.13387263f, -0.00655572f, -0.00071611f, 
    0.06493607f, 0.05513431f, -0.05472838f, -0.06594098f, 0.09849133f, 0.07328671f, 0.01624446f, 0.10974520f, 
    -0.01803218f, 0.09568845f, 0.08986224f, -0.08285253f, 0.10440595f, -0.07704169f, 0.09176573f, 0.09908907f, 
    -0.05606158f, 0.02368235f, 0.12595588f, -0.10186220f, 0.13957097f, 0.10612570f, 0.20396234f, -0.02040676f, 
    0.05053541f, 0.07931408f, 0.05805897f, 0.00183060f, 0.07784410f, 0.01222731f, -0.03259743f, 0.01242787f, 
    0.26895234f, 0.19242892f, -0.03735078f, -0.14220725f, 0.01851540f, -0.03811058f, 0.07410125f, 0.00248642f, 
    -0.03510423f, 0.00558033f, -0.04118881f, 0.03076664f, -0.12822431f, 0.21657278f, -0.04404606f, 0.34215710f, 
    -0.00725055f, 0.00457229f, 0.13321337f, 0.03618973f, 0.05481930f, 0.03026155f, -0.01198705f, -0.02284932f, 
    0.07527201f, -0.02482712f, 0.07282659f, -0.06748957f, -0.04492785f, -0.05043724f, 0.04945376f, 0.02051641f, 
    -0.02957728f, -0.11836322f, -0.05081053f, 0.00714014f, 0.10246779f, -0.21101269f, 0.09365458f, -0.00847847f, 
    -0.18768774f, 0.00638277f, -0.03527499f, 0.07796785f, -0.07369539f, 0.10156956f, 0.03172416f, -0.01415011f, 
    0.26286906f, 0.29099831f, -0.09624203f, -0.12667777f, 0.01719703f, 0.02233131f, 0.01575885f, 0.05702611f, 
    -0.03402841f, -0.01522673f, -0.04144866f, 0.08612832f, -0.01056150f, 0.06997748f, 0.05035366f, 0.21627042f, 
    -0.01215120f, 0.02869534f, -0.03568884f, -0.08800191f, -0.00216953f, -0.02162858f, 0.07595523f, -0.00204794f, 
    -0.18553415f, -0.13618910f, -0.07242297f, -0.26154464f, -0.03220406f, 0.04327286f, 0.01298802f, 0.09670880f, 
    -0.11943476f, 0.06107300f, 0.02376863f, 0.00387392f, -0.01885249f, 0.11593714f, 0.12050801f, -0.08435911f, 
    0.06477530f, -0.05454767f, 0.10609271f, 0.05803272f, 0.06279508f, 0.03678247f, 0.00582369f, 0.03028351f, 
    0.19010139f, 0.01389413f, 0.04822477f, 0.02101062f, -0.03828458f, -0.04959963f, 0.03212789f, 0.00044557f, 
    -0.03970964f, 0.00754256f, -0.02875763f, 0.03025853f, 0.06998691f, -0.09727778f, -0.04899257f, 0.20633234f, 
    -0.02540560f, 0.00323183f, -0.03764397f, 0.08215387f, 0.02747953f, -0.04844243f, -0.04187792f, 0.07805438f, 
    0.14780596f, -0.00024814f, 0.14517352f, -0.37206030f, -0.15156206f, -0.15178774f, -0.12282774f, 0.13373365f, 
    -0.08529508f, -0.06370204f, 0.02303838f, 0.03774541f, -0.20302972f, 0.24109729f, 0.00070193f, -0.06234682f, 
    0.01873407f, 0.13087156f, 0.03402890f, 0.11284592f, 0.08402395f, 0.06800552f, -0.00035129f, -0.04351964f, 
    0.15620130f, -0.18917674f, 0.11208875f, -0.07308638f, -0.06763937f, 0.03793290f, 0.04169118f, 0.03450746f, 
    0.09889640f, -0.00798948f, -0.11063949f, 0.00175198f, 0.00212292f, -0.18867233f, 0.13122503f, -0.22157165f, 
    -0.13182901f, 0.11272415f, -0.06913147f, 0.00742963f, 0.08435269f, 0.02057747f, 0.13908236f, -0.16416466f, 
    0.21524464f, -0.13772275f, -0.00214079f, 0.06678248f, 0.12210908f, -0.04834541f, -0.13088305f, 0.10840932f, 
    0.07310616f, -0.06000691f, 0.09065256f, 0.07656186f, -0.22336136f, -0.27716231f, 0.08422934f, 0.02890154f, 
    -0.00638377f, -0.00149803f, -0.05577424f, 0.10223709f, 0.04778254f, 0.02719105f, 0.07134830f, -0.02484946f, 
    0.12107977f, -0.04141985f, 0.10331659f, 0.09329824f, 0.10675667f, -0.04484344f, 0.10335664f, 0.04976477f, 
    -0.06539266f, 0.09805627f, -0.08527677f, -0.02880967f, 0.06154874f, 0.01155972f, 0.11544613f, -0.06330245f, 
    0.12139019f, 0.05320048f, -0.02797648f, 0.11532763f, 0.05209510f, 0.04189012f, -0.03477338f, -0.06381265f, 
    0.11172508f, -0.08814954f, 0.13475090f, 0.01107073f, -0.03360183f, -0.06444173f, 0.04365955f, -0.17763591f, 
    -0.04675174f, 0.11533542f, -0.10060900f, -0.08860680f, 0.24485838f, -0.00130987f, -0.01346265f, 0.06733369f, 
    -0.01866941f, -0.00568158f, 0.08899771f, 0.04651601f, 0.06032491f, 0.12156373f, 0.14847831f, 0.03260929f, 
    0.21509384f, -0.09810951f, 0.04553962f, 0.12287705f, 0.04434662f, 0.00388670f, 0.09893631f, -0.02031842f, 
    0.10778798f, -0.00855616f, 0.16187139f, -0.04018020f, -0.20446958f, 0.08563741f, 0.11802785f, -0.13793705f, 
    0.10422240f, -0.06354017f, 0.07849273f, 0.01529066f, 0.02622369f, 0.04855087f, 0.01163394f, 0.08573496f, 
    -0.08577956f, -0.00135944f, 0.11500854f, 0.09762743f, 0.04778518f, 0.05861451f, 0.04820999f, 0.08253431f, 
    -0.03958925f, 0.09307268f, 0.00026661f, 0.09067351f, 0.16707270f, -0.11454372f, -0.17343274f, -0.09785645f, 
    0.10188293f, -0.01213514f, 0.03234625f, -0.00202799f, 0.06269250f, 0.11618671f, 0.09651496f, -0.02033700f, 
    -0.04957926f, -0.07932282f, 0.00506252f, 0.05715251f, -0.05427842f, 0.07576658f, 0.00413159f, -0.07999149f, 
    0.05192178f, 0.00863858f, -0.08583584f, -0.07075763f, 0.03870697f, 0.14197281f, 0.05872882f, 0.09902980f, 
    0.11113407f, -0.01252983f, -0.00393176f, 0.05148198f, -0.06575871f, 0.03932327f, -0.02917254f, -0.04582814f, 
    -0.01163834f, -0.06384040f, -0.26783326f, 0.01458746f, -0.12258172f, -0.02236100f, 0.05833253f, 0.01581394f, 
    -0.01603439f, 0.08692281f, 0.11791385f, -0.21879983f, 0.08447208f, 0.02505465f, -0.10202730f, 0.05031604f, 
    0.09788191f, 0.01444909f, -0.17370509f, -0.07243621f, -0.22292708f, 0.02366578f, -0.11357704f, -0.08087499f, 
    0.34641761f, 0.10639670f, -0.08047649f, -0.15344614f, -0.05846354f, -0.11931987f, 0.08095818f, 0.00124315f, 
    0.04490382f, 0.10809976f, -0.03602480f, 0.12389834f, 0.03636861f, 0.19484204f, -0.07317020f, -0.21713819f, 
    0.07552303f, -0.05217443f, 0.02638736f, 0.05265751f, 0.04027759f, 0.05404882f, 0.14154604f, -0.02040478f, 
    0.36333090f, -0.09930100f, -0.02667718f, -0.04907106f, -0.03417547f, 0.04516812f, -0.04086779f, -0.13077766f, 
    -0.02897261f, -0.21455050f, -0.08906943f, 0.08972879f, -0.15097219f, -0.01808592f, -0.02459074f, 0.05807846f, 
    -0.09111270f, 0.11619690f, 0.05486593f, 0.00129899f, 0.09138624f, 0.04853095f, -0.03911465f, 0.06667691f, 
    0.17871816f, -0.13733259f, -0.09862755f, 0.10013933f, -0.05254300f, 0.11142371f, -0.08698899f, 0.04503928f, 
    -0.02002866f, 0.00343561f, -0.13001254f, -0.01776489f, -0.12053462f, 0.07198546f, -0.19415508f, -0.24867627f, 
    0.14790343f, 0.08203717f, 0.00273174f, 0.22540730f, -0.02833837f, 0.06275411f, -0.05231322f, 0.22200736f, 
    0.15277515f, -0.19929725f, -0.01138569f, -0.10546608f, 0.10217492f, -0.04243083f, 0.06467486f, -0.02271458f, 
    -0.04418958f, -0.04459667f, -0.04428880f, -0.00091688f, -0.11177886f, -0.03688013f, -0.03084461f, -0.05197188f, 
    0.00494942f, 0.02900083f, -0.07266043f, 0.01756292f, 0.04189700f, -0.02195940f, -0.11009566f, -0.06603672f, 
    0.06256074f, 0.10117739f, 0.00191701f, -0.11625601f, 0.14674690f, -0.05993907f, -0.08195950f, 0.05728812f, 
    0.08524265f, 0.00831645f, -0.11311083f, 0.13711859f, 0.10467375f, -0.04386539f, -0.06185713f, -0.07517080f, 
    0.00192389f, 0.06437070f, 0.06682432f, -0.06257553f, -0.00597166f, -0.04265540f, -0.09817775f, 0.06814368f, 
    -0.03475396f, -0.01449803f, 0.05850602f, 0.06094118f, -0.00858722f, 0.06467388f, 0.01949032f, 0.04987042f, 
    0.12540728f, -0.07574400f, 0.03869963f, -0.10412695f, -0.29909649f, -0.00186549f, -0.01835801f, 0.02725757f, 
    -0.01328064f, -0.09363107f, 0.00081701f, -0.12640040f, 0.04602633f, 0.10336788f, -0.03874762f, -0.07048865f, 
    0.30338109f, 0.01258204f, -0.00435912f, -0.19875874f, 0.08875211f, 0.02043439f, 0.10720924f, -0.09175741f, 
    0.02027104f, 0.03549196f, 0.15036224f, 0.01786502f, -0.06406350f, 0.02863220f, -0.07432891f, -0.26158229f, 
    0.14056009f, 0.03429829f, -0.16437314f, 0.09591330f, 0.02447714f, -0.10988329f, -0.01457936f, 0.00202775f, 
    -0.07931051f, -0.08063104f, -0.12794663f, -0.11742122f, 0.09384290f, -0.00709734f, -0.09918071f, 0.00112405f, 
    -0.02211399f, 0.04537851f, 0.03063960f, -0.08696831f, 0.18622702f, -0.11045066f, -0.00811310f, 0.14716300f, 
    -0.01340821f, -0.04113390f, 0.03298660f, 0.02008808f, -0.00990230f, 0.04636241f, 0.00967306f, 0.03238492f, 
    0.23787217f, -0.29600301f, 0.11785853f, 0.00682322f, 0.04507719f, 0.10523932f, -0.06596531f, 0.15038538f, 
    -0.02775120f, 0.09893402f, 0.00455258f, 0.01045235f, 0.44195324f, -0.25756216f, 0.04819516f, 0.13997003f, 
    -0.00109366f, 0.00097503f, -0.01776392f, -0.03750779f, 0.08194994f, 0.03080994f, 0.04242742f, 0.00934061f, 
    0.17001994f, 0.12670925f, -0.12580012f, 0.25608221f, -0.04851833f, -0.11335103f, -0.08622794f, -0.15938626f, 
    -0.03577058f, 0.01755514f, -0.07409184f, 0.00896426f, -0.08868617f, -0.23896579f, -0.15831614f, -0.14800330f, 
    0.06461222f, -0.09754485f, -0.01127693f, 0.14636722f, -0.01262761f, 0.02312457f, 0.04053110f, 0.08767042f, 
    0.26805279f, -0.06952582f, -0.01255098f, 0.09733584f, 0.01100014f, 0.04063347f, 0.01105381f, 0.09285227f, 
    0.02430027f, 0.05291656f, 0.01208588f, -0.05717785f, 0.21659678f, -0.08231268f, 0.05489563f, 0.07142491f, 
    -0.06429685f, 0.04652516f, -0.03091658f, 0.00603564f, -0.01257977f, -0.08674452f, 0.01690592f, 0.05793457f, 
    0.06928008f, -0.03939959f, -0.00380084f, -0.19342478f, 0.04059021f, -0.00723423f, -0.05502702f, -0.05729622f, 
    -0.05457665f, -0.05895936f, -0.03764716f, 0.02418117f, -0.47688559f, -0.10983867f, 0.08492445f, -0.03212317f, 
    0.05518752f, -0.10446066f, -0.00966653f, 0.15670237f, 0.12640564f, -0.04325491f, 0.01294306f, 0.05563173f, 
    0.03028574f, 0.03032716f, 0.05601866f, -0.00985275f, 0.08752647f, 0.12119122f, 0.00288278f, 0.09880963f, 
    0.00895215f, -0.05974904f, -0.00720060f, 0.02246671f, 0.15764560f, 0.01754874f, -0.03821100f, -0.07596508f, 
    -0.10657443f, 0.00653469f, -0.01707510f, 0.07007522f, -0.10200766f, -0.05658657f, 0.06846251f, 0.02252363f, 
    0.00111100f, 0.09324588f, 0.04467062f, 0.06864642f, 0.07619991f, -0.02658595f, 0.00206892f, 0.05134594f, 
    0.03076577f, 0.03132058f, -0.13314825f, -0.03862317f, 0.05818024f, -0.16381264f, 0.08981380f, -0.07125939f, 
    0.02294162f, 0.03810650f, -0.06640372f, -0.06787004f, 0.07565428f, -0.07361713f, 0.02873422f, 0.03327669f, 
    -0.43874806f, 0.17458437f, 0.07678807f, 0.05117693f, 0.08187989f, 0.09121275f, -0.04709442f, 0.14944758f, 
    -0.03634381f, 0.15035874f, 0.07047372f, 0.04578062f, -0.24513854f, -0.06296778f, 0.18594810f, 0.03900946f, 
    -0.03573503f, -0.02760834f, 0.00024874f, 0.06984956f, -0.01592569f, 0.04217932f, 0.02135730f, -0.01219670f, 
    0.13719745f, 0.00931321f, 0.06249281f, -0.20538731f, 0.14496656f, 0.00307902f, -0.05967870f, 0.00543621f, 
    -0.11687194f, 0.02026416f, 0.08063766f, 0.11772259f, 0.12839587f, -0.04248143f, -0.02760295f, 0.20985684f, 
    -0.05861622f, 0.07299545f, -0.00266792f, -0.05166347f, 0.03010908f, 0.22191381f, -0.03377277f, 0.04945533f, 
    -0.19690257f, 0.10952025f, 0.06514147f, 0.01126728f, -0.04631680f, 0.09293859f, -0.02484187f, 0.12352805f, 
    0.02138163f, -0.13231686f, 0.01134071f, -0.05981982f, 0.08228981f, 0.04858019f, -0.20085159f, -0.17978303f, 
    0.20935163f, 0.07116689f, -0.04117243f, -0.01274495f, 0.01045879f, 0.10217761f, 0.11958492f, 0.04124203f, 
    -0.05205498f, -0.09317818f, -0.01229731f, 0.01778843f, 0.10043313f, 0.01094833f, 0.06556278f, 0.10938039f, 
    -0.09990174f, 0.07978410f, 0.03422755f, -0.04513252f, 0.20015153f, -0.06169396f, -0.24343975f, 0.16392092f, 
    -0.11017000f, -0.00706761f, -0.05763674f, -0.07994260f, 0.07418441f, -0.07654405f, -0.08088757f, -0.15380135f, 
    0.17017460f, 0.03067899f, 0.07940798f, 0.08222022f, -0.07605147f, 0.05490129f, -0.01040368f, -0.09873807f, 
    0.04232450f, -0.01580601f, 0.03603865f, 0.02559435f, -0.03433234f, -0.03569146f, -0.24142893f, 0.12142628f, 
    -0.11161960f, 0.04413279f, -0.08892679f, -0.01697223f, 0.00716681f, 0.02100736f, 0.13517018f, -0.02942430f, 
    0.22235589f, 0.05669950f, -0.07980582f, 0.10581701f, -0.00998898f, -0.04315346f, -0.02076860f, 0.13868214f, 
    -0.00386444f, -0.09711979f, 0.07824504f, -0.03667518f, -0.02839594f, -0.21838713f, 0.03945876f, 0.16079873f, 
    0.09382544f, -0.03420866f, -0.04468580f, -0.04671206f, -0.02866763f, 0.07976547f, 0.00212888f, 0.03636536f, 
    0.09304874f, -0.00187676f, -0.02564821f, 0.11105361f, -0.03331641f, 0.02828622f, 0.00325427f, -0.00388026f, 
    -0.06701563f, 0.08318582f, -0.01012622f, -0.10195700f, 0.10478318f, 0.08438402f, -0.10034135f, -0.12507756f, 
    0.03901200f, 0.08138700f, -0.04147607f, 0.06315275f, 0.00008304f, -0.01898922f, 0.02461273f, 0.06868605f, 
    0.19390599f, 0.14167441f, -0.09122576f, 0.08097380f, 0.09856013f, -0.08178942f, -0.01398024f, -0.02438739f, 
    0.01015783f, 0.13060383f, 0.02435866f, 0.07149257f, -0.12049465f, -0.05363645f, 0.07259390f, -0.02097417f, 
    0.01938184f, 0.04451799f, -0.05828175f, -0.15119311f, 0.06282954f, 0.02561985f, -0.04949579f, 0.01331997f, 
    0.23493133f, 0.16017264f, 0.10492443f, -0.01707303f, -0.02053189f, 0.07912394f, -0.02929337f, -0.05489945f, 
    -0.10814649f, -0.01540052f, 0.09693272f, -0.05846461f, 0.42678455f, 0.07803946f, -0.21110769f, 0.07649101f, 
    0.01028674f, 0.14741279f, 0.03145739f, 0.05753434f, 0.04776097f, -0.26698333f, 0.17078389f, -0.00564896f, 
    -0.07193585f, 0.28305224f, -0.01470176f, 0.00075439f, 0.11014661f, 0.01136741f, 0.00094745f, 0.00363738f, 
    0.11655083f, -0.08481929f, 0.03745268f, 0.05063002f, -0.26899123f, -0.09154668f, -0.26146641f, 0.01289870f, 
    -0.03022218f, 0.07541040f, 0.05881289f, 0.02993064f, 0.04013764f, 0.17902167f, 0.07298426f, -0.11295030f, 
    0.02273341f, -0.15752348f, 0.11036617f, 0.05912049f, -0.03902789f, 0.10120977f, 0.04226976f, 0.12922421f, 
    0.17765769f, -0.09312782f, -0.03033338f, 0.02259990f, 0.08687470f, -0.16723609f, 0.19659929f, -0.16408513f, 
    -0.08264090f, -0.06872512f, -0.06450661f, 0.08975983f, 0.09759291f, 0.10137870f, 0.24588545f, 0.02983749f, 
    0.08461566f, -0.14078780f, -0.07522565f, 0.04450897f, 0.13111784f, -0.07091613f, -0.09550126f, 0.02270184f, 
    0.14286153f, -0.15935701f, 0.12740810f, 0.08511170f, -0.24167758f, -0.20923470f, 0.20411162f, 0.00720958f, 
    0.08875557f, 0.08867568f, -0.02665341f, 0.03217253f, 0.04551012f, -0.05177693f, 0.00322802f, -0.01038538f, 
    0.10929452f, -0.06269418f, -0.14968961f, 0.04463533f, 0.12969381f, -0.07086638f, 0.08510859f, 0.03743429f, 
    -0.00210732f, 0.11773245f, -0.05869545f, 0.05163169f, 0.16170041f, -0.03694898f, 0.01363353f, 0.07058028f, 
    0.17973699f, -0.08763673f, 0.15480164f, 0.09526308f, 0.03563663f, -0.07391249f, 0.08289664f, -0.02866401f, 
    0.00610385f, -0.16025357f, 0.05265000f, 0.03884559f, 0.13042067f, -0.01711751f, -0.05988358f, -0.07887398f, 
    -0.05069136f, 0.12323973f, -0.01441913f, -0.04658473f, 0.21797213f, -0.04060457f, 0.09198580f, 0.01095852f, 
    0.05815285f, 0.03282688f, 0.08019822f, 0.14254063f, 0.11483873f, 0.11108194f, 0.09032964f, 0.04801529f, 
    0.11237521f, -0.06428774f, 0.05589189f, 0.27356169f, 0.06944185f, -0.08173887f, 0.02969710f, -0.07359601f, 
    0.06070530f, -0.02404040f, 0.25776452f, -0.01565802f, -0.11726905f, 0.05928252f, 0.11652319f, 0.01236806f, 
    0.07581913f, 0.06849974f, 0.12823996f, -0.06721537f, 0.06714410f, -0.03787809f, -0.03842389f, 0.17490371f, 
    -0.11054490f, -0.02561523f, 0.18684632f, 0.02082756f, 0.07935754f, 0.05855793f, 0.11320641f, 0.05180412f, 
    0.14898187f, 0.13786812f, -0.00244725f, 0.10863503f, 0.21787290f, -0.02848037f, -0.08233164f, 0.08286344f, 
    0.08160815f, 0.04600158f, 0.02403851f, 0.12149400f, 0.10142460f, -0.02384129f, 0.04158266f, -0.00483108f, 
    -0.11698587f, -0.15338488f, -0.16600935f, -0.13022350f, -0.05545269f, 0.07258928f, -0.02121000f, -0.12735011f, 
    0.03768200f, -0.00597406f, -0.04924634f, -0.01929164f, 0.09687669f, 0.11928042f, 0.03229716f, 0.18729478f, 
    0.05411561f, 0.07572285f, -0.04146628f, 0.06680834f, 0.08312772f, 0.02100138f, -0.01562604f, -0.02861586f, 
    0.04332066f, -0.14368510f, -0.15791300f, 0.05255324f, -0.11226275f, 0.03370671f, -0.05932699f, 0.08872211f, 
    0.11396614f, 0.12674619f, 0.11736645f, -0.02582126f, 0.07880291f, 0.01826901f, 0.04534809f, 0.02897111f, 
    0.02060094f, -0.06071785f, -0.13471016f, -0.11466248f, -0.08449548f, 0.09588122f, 0.05215760f, 0.02018134f, 
    0.19178338f, 0.10661542f, -0.12441520f, -0.08720548f, 0.01985949f, -0.08597263f, 0.10472194f, 0.05937022f, 
    -0.05772316f, 0.08014358f, -0.01057009f, 0.16225314f, 0.31985879f, 0.12661037f, -0.01382318f, -0.06898487f, 
    0.10438008f, -0.01561170f, 0.07331467f, 0.12784702f, 0.09712082f, 0.04403302f, 0.08045483f, 0.02303101f, 
    0.09875192f, -0.09236635f, -0.06959513f, -0.08520166f, 0.04136727f, -0.01022522f, -0.00841708f, -0.13357697f, 
    0.01390445f, -0.16797853f, -0.20812498f, 0.08537766f, -0.33027413f, -0.25219911f, 0.15411089f, 0.10316070f, 
    0.01659102f, 0.09507880f, 0.04223586f, -0.00869474f, 0.14579637f, -0.05502142f, 0.06496830f, 0.01836225f, 
    -0.00193490f, -0.07515875f, 0.11371810f, -0.02858124f, 0.01940997f, 0.05025141f, -0.01981713f, 0.08502450f, 
    0.04788893f, 0.17997912f, 0.03242740f, 0.15085167f, -0.05171073f, 0.13759317f, 0.03556189f, -0.09186502f, 
    0.14236565f, 0.10040256f, 0.06670435f, 0.21527836f, -0.02754695f, -0.11988743f, -0.05553620f, 0.35871896f, 
    0.08367980f, -0.09701946f, 0.06344297f, 0.03120477f, 0.16889985f, 0.02974124f, 0.05926132f, 0.07226352f, 
    0.09118362f, 0.07831176f, -0.04992663f, -0.00193660f, -0.10172692f, -0.13970257f, 0.01884345f, -0.15113263f, 
    0.01996291f, 0.05593502f, -0.10145808f, -0.10327872f, -0.04030086f, -0.07087997f, -0.05314978f, -0.06767006f, 
    0.11215288f, 0.13613108f, 0.09001093f, -0.13488349f, 0.13017619f, -0.00340693f, -0.09025453f, 0.05513274f, 
    0.00155953f, -0.02374683f, -0.02116480f, 0.08672573f, 0.11418832f, 0.04686023f, 0.00633478f, -0.00825413f, 
    0.02116281f, 0.09497193f, 0.05458595f, 0.01997779f, 0.15047872f, -0.05783495f, 0.06748725f, 0.02256828f, 
    0.07658734f, -0.03573510f, 0.03304801f, 0.05620800f, -0.05932413f, 0.09748651f, -0.01537773f, 0.11639438f, 
    0.14539690f, 0.00014819f, 0.00582911f, -0.07636208f, -0.19600627f, 0.01847841f, 0.01930490f, -0.07490234f, 
    0.01249343f, 0.04951778f, -0.07401335f, -0.05896258f, 0.09461406f, -0.05391477f, -0.09316584f, -0.04393660f, 
    0.34324339f, 0.00082172f, -0.02448677f, -0.10174246f, 0.11465822f, 0.07039012f, 0.06426997f, 0.00062143f, 
    -0.01046650f, -0.00932849f, 0.15581946f, 0.07450943f, 0.03273107f, 0.16577229f, 0.00933035f, -0.15446259f, 
    0.11493211f, 0.01238983f, -0.10848641f, 0.13355690f, -0.02618936f, 0.03032718f, 0.01818468f, 0.06276046f, 
    -0.17951541f, -0.17651135f, -0.11474502f, -0.20089407f, 0.02135426f, 0.06152647f, -0.01735026f, -0.00911931f, 
    0.01553644f, 0.09168071f, -0.04930408f, -0.00471601f, 0.16795048f, -0.09298880f, -0.19575182f, -0.06882479f, 
    -0.06144495f, 0.11047781f, 0.11259840f, -0.01222910f, 0.02239259f, 0.00176197f, 0.05441905f, -0.07590123f, 
    0.13031505f, -0.18674088f, -0.00516837f, -0.03376962f, 0.06099689f, 0.05573130f, -0.04576157f, -0.03187597f, 
    0.07851832f, 0.11305051f, -0.05663080f, 0.07350407f, -0.13112082f, -0.01558207f, 0.01463402f, 0.12694685f, 
    -0.01273881f, -0.00425659f, 0.12444402f, 0.02604063f, 0.05114120f, -0.00202221f, -0.06011089f, -0.02932004f, 
    0.28103724f, 0.25081977f, 0.05281535f, 0.28162411f, -0.08998469f, -0.01074763f, -0.03476771f, -0.10189696f, 
    -0.01757525f, 0.05649491f, -0.02734982f, 0.13294917f, 0.02177398f, -0.12864307f, 0.11570970f, -0.01320403f, 
    0.12081556f, -0.12549454f, -0.01136842f, 0.19378802f, 0.08777581f, 0.15888315f, -0.00175457f, 0.05525459f, 
    0.10094427f, -0.02897752f, -0.10809131f, -0.06954323f, -0.00383020f, 0.10016388f, -0.02290704f, 0.05034393f, 
    0.08744886f, -0.02335094f, 0.09437622f, -0.06020525f, 0.02882379f, -0.14127384f, 0.04607453f, 0.10502601f, 
    0.07937174f, -0.05341803f, 0.01050319f, 0.04545236f, 0.00042458f, -0.09291540f, 0.08105337f, 0.06862241f, 
    0.00030426f, 0.03038969f, 0.13526709f, -0.15715043f, 0.03195605f, -0.05477403f, -0.00598178f, 0.08500239f, 
    0.01696905f, 0.05145378f, 0.03156354f, 0.05394587f, -0.32999048f, -0.16888605f, 0.10069139f, -0.02681869f, 
    -0.04095348f, -0.01797796f, 0.02450884f, 0.12226580f, 0.02306641f, -0.04816701f, 0.13245174f, 0.00230743f, 
    -0.01298681f, 0.13043858f, 0.12145140f, -0.00548708f, 0.02064841f, 0.12716818f, -0.04700689f, 0.06466321f, 
    0.02358587f, 0.01504658f, -0.13979442f, 0.00190600f, -0.07407696f, -0.00297641f, 0.00889575f, -0.03111661f, 
    -0.04380134f, 0.04535466f, 0.04482495f, -0.00632515f, -0.04395990f, 0.00803376f, 0.08985822f, 0.00517784f, 
    -0.06035498f, 0.04594161f, 0.08053610f, 0.04737564f, 0.10799318f, -0.04584802f, -0.06986121f, -0.03186870f, 
    -0.00990542f, 0.03650191f, -0.08722385f, -0.00200210f, -0.03069420f, -0.20431446f, 0.01858210f, -0.06754859f, 
    0.10766999f, -0.03364997f, 0.09657772f, -0.05896708f, 0.04594152f, -0.11618548f, 0.04959047f, -0.04416473f, 
    -0.18927014f, 0.00644897f, 0.16203755f, 0.03631673f, 0.10217726f, 0.01137346f, 0.03153488f, 0.14336884f, 
    0.01284224f, 0.08744547f, -0.00169693f, 0.09812690f, -0.13022345f, -0.28015780f, 0.04437830f, -0.06174708f, 
    -0.12325612f, 0.06960195f, 0.00529378f, -0.01681493f, 0.03401487f, -0.12250155f, -0.06171340f, 0.08787949f, 
    0.06392318f, 0.13660157f, 0.20244247f, -0.12587185f, 0.13267748f, -0.04291995f, -0.00027372f, -0.01421702f, 
    -0.01906505f, 0.02811604f, 0.08331783f, 0.04179387f, 0.06957436f, -0.13846143f, 0.00798672f, 0.19949281f, 
    -0.03330031f, 0.07139450f, 0.02143626f, -0.01962454f, 0.04624163f, 0.22710474f, -0.01620435f, 0.05424140f, 
    -0.26203346f, -0.09550049f, 0.17415997f, 0.15739803f, 0.04152788f, 0.05075813f, -0.09911244f, 0.22891998f, 
    -0.04854207f, -0.03252433f, 0.07103091f, 0.00952112f, -0.18607849f, 0.10766714f, 0.01245923f, -0.15700895f, 
    0.18464214f, -0.03411338f, -0.08110502f, 0.01966619f, 0.02064543f, 0.05495710f, 0.07184383f, 0.00223666f, 
    0.03665362f, -0.08125100f, 0.15889955f, -0.03658233f, -0.01262113f, 0.01038074f, 0.03946469f, 0.02229543f, 
    0.01947524f, -0.01372825f, -0.05666203f, 0.01151805f, -0.02986848f, -0.10666535f, -0.27066198f, -0.01225299f, 
    -0.05347953f, 0.08052912f, -0.06337341f, -0.02389280f, 0.03356782f, -0.10746939f, -0.04319552f, -0.11833211f, 
    0.05593657f, -0.14111266f, -0.06012962f, -0.14067915f, 0.00713599f, 0.07237443f, 0.00407167f, -0.07357854f, 
    0.11333799f, 0.02957365f, 0.08740722f, 0.02826739f, -0.29670939f, -0.03970927f, -0.05787088f, 0.17472938f, 
    -0.06796031f, -0.00058730f, -0.16176939f, -0.08118273f, -0.00141161f, 0.02607887f, 0.20104034f, 0.03673190f, 
    0.04306236f, 0.14829758f, -0.12395234f, 0.07467441f, 0.13076736f, 0.09475336f, -0.03089501f, 0.01926303f, 
    0.01360267f, -0.04381111f, 0.09841687f, -0.02168412f, 0.05969433f, -0.10083623f, 0.01132772f, 0.11462995f, 
    0.11063328f, 0.16572051f, -0.04729408f, -0.01583213f, 0.01259199f, 0.01976763f, -0.00068865f, 0.05990247f, 
    -0.08014143f, -0.17341426f, -0.04843409f, -0.14258130f, -0.02589876f, 0.10120647f, 0.04186958f, -0.03100702f, 
    0.00881391f, 0.01123200f, 0.01061771f, -0.08454619f, -0.37686357f, 0.20909666f, 0.03861502f, -0.20208819f, 
    0.18474621f, -0.01848125f, 0.02386819f, 0.05745045f, 0.06661531f, 0.05059597f, 0.03209028f, 0.17074400f, 
    0.29813904f, 0.20429635f, -0.12775190f, 0.19316548f, 0.13418062f, 0.02317689f, -0.09357945f, 0.09512108f, 
    0.07153247f, 0.04027944f, 0.01205462f, 0.12059386f, -0.04238736f, -0.12272379f, -0.00745587f, -0.08409993f, 
    0.02097465f, -0.01710766f, 0.01006482f, -0.08587459f, 0.08595923f, 0.02364255f, -0.07436015f, -0.04301965f, 
    -0.27040961f, 0.08815978f, 0.00761062f, -0.11650915f, 0.04575067f, 0.12219957f, -0.02417363f, 0.00986797f, 
    0.04555329f, 0.01389630f, 0.17635165f, 0.12218646f, -0.04046952f, 0.18823525f, -0.20110358f, 0.06153614f, 
    0.10026862f, 0.03862331f, 0.09767064f, 0.06651095f, 0.05170899f, -0.18931381f, 0.18920617f, 0.03960285f, 
    -0.18537834f, 0.08723191f, 0.03167685f, 0.16588314f, 0.06170602f, 0.04416139f, -0.08552966f, 0.07124870f, 
    0.12184951f, -0.05774474f, 0.06689432f, 0.00849411f, -0.45307484f, -0.05481274f, -0.13684957f, 0.09298971f, 
    0.00517423f, 0.00679502f, 0.08323416f, 0.10228973f, 0.06272583f, 0.13773410f, 0.03579246f, -0.01067737f, 
    -0.01394236f, 0.02995676f, -0.01939261f, 0.01139364f, 0.01702262f, 0.01448175f, 0.01671225f, 0.01206988f, 
    0.02516502f, -0.01390317f, -0.03271561f, -0.00542840f, -0.01313893f, 0.00445602f, 0.02161047f, 0.02139449f, 
    0.02688852f, 0.02232465f, 0.01671460f, 0.00311189f, -0.00567805f, -0.02121174f, 0.01304010f, 0.01102200f, 
    -0.01509981f, 0.00428143f, -0.01743411f, -0.00268199f, 0.03171363f, -0.00751904f, 0.01570114f, 0.01789659f, 
    0.01251720f, -0.01510881f, -0.02337688f, 0.00767679f, 0.00055796f, -0.00561854f, -0.02904668f, -0.03056927f, 
    0.01456684f, -0.03198503f, 0.01481297f, -0.01434866f, 0.00953111f, -0.01539546f, -0.01713043f, 0.01724733f, 
    0.02828683f, 0.01802049f, 0.01374113f, -0.02271818f, -0.00767263f, 0.01913709f, -0.02232346f, -0.03923547f, 
    0.00678687f, -0.02301246f, 0.00789567f, 0.02887261f, -0.02547443f, -0.00450750f, 0.02194801f, -0.04187687f, 
    0.03131876f, -0.00903686f, 0.00772673f, -0.01903875f, -0.00450304f, 0.03110781f, -0.03626667f, -0.00916790f, 
    -0.01133479f, 0.02429578f, 0.00576035f, -0.02457631f, -0.00396624f, -0.01354544f, -0.04066169f, -0.00967885f, 
    0.00714045f, 0.01343608f, -0.00839029f, -0.02542603f, -0.01733209f, -0.02684969f, -0.02421648f, 0.02382452f, 
    -0.01958830f, 0.03037173f, 0.01754233f, 0.00807544f, -0.02454702f, -0.02291969f, 0.01314355f, 0.02319952f, 
    0.00022460f, -0.00253816f, 0.00569994f, 0.01442786f, 0.03060317f, -0.02033484f, -0.03773662f, -0.03056915f, 
    0.01652304f, -0.01617372f, 0.00892479f, -0.02693478f, -0.01432226f, 0.02042409f, 0.00674930f, 0.01040442f, 
    -0.00074001f, 0.02560982f, 0.00837886f, 0.00640648f, 0.01122832f, -0.03176336f, -0.02488799f, 0.00076078f, 
    -0.01466566f, -0.04186863f, 0.01559597f, 0.01431951f, -0.02175668f, 0.00684911f, -0.03243135f, -0.01323627f, 
    0.00473153f, -0.03008594f, -0.00345275f, -0.03717348f, 0.03680078f, -0.02147882f, -0.00983857f, -0.02517360f, 
    0.02841366f, -0.01046748f, 0.02920006f, 0.00174872f, 0.01099343f, -0.00324972f, -0.03396183f, 0.00384116f, 
    -0.01807645f, -0.03252394f, -0.03338903f, -0.00143560f, -0.00193614f, 0.01021437f, 0.03388099f, -0.02203487f, 
    -0.01692203f, -0.01721451f, -0.00528671f, -0.00600315f, -0.01219440f, -0.00611057f, -0.00294833f, 0.00662956f, 
    0.02699872f, 0.01348720f, -0.01622064f, -0.00954413f, 0.00658221f, -0.03696650f, -0.02708125f, -0.00120415f, 
    -0.00988361f, -0.03162543f, -0.01319632f, -0.00334148f, -0.02006835f, -0.02760812f, 0.00879237f, 0.02710802f, 
    0.01424654f, -0.02098193f, 0.01426551f, 0.01086243f, -0.00116603f, -0.01914768f, 0.00351693f, -0.00290871f, 
    0.01738100f, -0.01835017f, 0.00358003f, -0.00096404f, -0.02786964f, 0.03597309f, -0.01457858f, -0.03440428f, 
    -0.02006864f, 0.02838608f, -0.03488903f, -0.01877371f, 0.00513102f, 0.01994185f, 0.01100595f, -0.02175377f, 
    0.00153496f, 0.01436580f, 0.03577968f, 0.01977490f, -0.01819636f, 0.02084839f, 0.01433006f, 0.02183138f, 
    -0.01730416f, 0.02111408f, -0.02934685f, -0.01418565f, 0.03255427f, -0.02262767f, 0.00153644f, -0.02671132f, 
    0.02830038f, 0.02601380f, -0.03282887f, 0.01002679f, -0.01745119f, 0.03135427f, -0.01922635f, 0.00230931f, 
    -0.03691842f, -0.01080708f, -0.04262258f, 0.03270520f, 0.01411269f, 0.01043578f, 0.02648265f, -0.03924538f, 
    0.02404231f, -0.00834604f, 0.00452324f, -0.00029343f, -0.01836322f, -0.02508449f, 0.01511406f, 0.02777641f, 
    0.02038174f, -0.01088346f, -0.01558435f, -0.01484151f, 0.03006802f, -0.03857165f, 0.03037288f, 0.01966570f, 
    0.03022347f, -0.01370556f, -0.00905569f, 0.00662174f, -0.01273986f, -0.03356477f, 0.00354722f, 0.02608029f, 
    -0.02321878f, 0.00189927f, -0.03659370f, -0.00630039f, 0.00018901f, -0.01021436f, -0.00552248f, -0.00410146f, 
    0.01878254f, -0.01028580f, -0.00273668f, -0.02052112f, -0.03359106f, -0.00864113f, -0.02430675f, 0.01515970f, 
    0.02135369f, 0.00121324f, 0.01146157f, -0.01398193f, -0.00701676f, -0.00213355f, -0.00794781f, -0.03674646f, 
    -0.00342432f, 0.00306658f, -0.02388548f, -0.00340055f, 0.00206552f, 0.00849720f, -0.01621568f, -0.02798352f, 
    -0.02349981f, -0.00169724f, -0.01625355f, 0.01689213f, -0.01638768f, -0.02434189f, -0.03646592f, -0.01357554f, 
    -0.03577095f, -0.00514368f, 0.01909056f, -0.00434517f, -0.01261748f, 0.02301737f, -0.00564853f, -0.02819889f, 
    -0.02403902f, -0.00097738f, 0.00798335f, 0.00434687f, 0.01761893f, 0.02680369f, 0.02022864f, -0.02752956f, 
    -0.03626472f, 0.02618044f, 0.01203378f, 0.02031175f, 0.01174332f, -0.00893346f, 0.00234476f, -0.02054988f, 
    0.00026224f, -0.03354536f, 0.01431434f, 0.02451811f, 0.02365821f, 0.00210820f, -0.03803093f, -0.00231503f, 
    -0.02127272f, -0.00167551f, -0.02008649f, -0.02642016f, 0.00092469f, -0.01792898f, 0.01626452f, 0.00824520f, 
    0.01547624f, -0.02442895f, -0.02077975f, -0.03555771f, -0.00030467f, 0.03909718f, 0.01216949f, -0.02641703f, 
    -0.02144746f, 0.02532865f, -0.01329973f, 0.03644664f, -0.02370488f, 0.00794888f, 0.02967689f, -0.02072202f, 
    0.00188442f, -0.01987990f, -0.02136997f, -0.03604947f, 0.02067358f, -0.01624219f, 0.00171767f, 0.01347867f, 
    0.02312797f, -0.01753612f, -0.00811753f, -0.03274694f, 0.03282231f, 0.01450343f, -0.00249562f, 0.01635634f, 
    0.00737780f, 0.00453129f, -0.04196719f, -0.00575796f, -0.00210187f, 0.02253376f, 0.00760013f, -0.02289412f, 
    0.03175622f, -0.01302490f, 0.01408745f, 0.01569434f, -0.03397290f, -0.00185118f, 0.01875798f, -0.02586805f, 
    -0.02821349f, -0.03555707f, -0.04140021f, -0.03119081f, -0.01190149f, -0.03680287f, -0.01644532f, -0.00187848f, 
    0.00305301f, -0.01138968f, -0.01743300f, -0.02112466f, 0.01588983f, 0.00302816f, -0.03085408f, 0.00868597f, 
    0.03011296f, -0.01450336f, -0.01769468f, 0.02466205f, -0.01753488f, -0.03071916f, -0.02368887f, 0.01474450f, 
    -0.03927343f, 0.01337131f, 0.00023113f, -0.01286083f, 0.02863240f, -0.00468881f, 0.00757084f, 0.00200232f, 
    -0.02229408f, 0.02234257f, -0.00061455f, -0.00046199f, 0.02578922f, 0.01500663f, -0.01355924f, -0.00925280f, 
    -0.03759230f, -0.02295944f, 0.03351840f, -0.01701792f, -0.01609220f, 0.03223318f, 0.03439058f, 0.00075843f, 
    0.00048504f, -0.02285925f, 0.01147343f, -0.00015620f, 0.01214633f, 0.02959057f, -0.01530183f, 0.00957157f, 
    0.02781158f, 0.02111270f, 0.00681410f, 0.01906206f, -0.03970282f, 0.03431059f, 0.01876729f, -0.02489429f, 
    0.03001385f, 0.02361145f, 0.00169704f, -0.00978214f, -0.02295873f, 0.00146893f, -0.03158511f, -0.01283727f, 
    0.00851594f, -0.03559332f, 0.01763297f, 0.02085537f, 0.00826269f, 0.01024725f, 0.01986733f, -0.02144350f, 
    0.00631406f, 0.01968243f, -0.00514558f, 0.01650390f, -0.03213576f, -0.01449166f, -0.00816447f, -0.01358992f, 
    -0.03087276f, 0.00464965f, -0.01531272f, -0.00862139f, -0.00758607f, -0.01056773f, 0.03496234f, -0.01005000f, 
    -0.03750134f, -0.00482813f, -0.00031658f, -0.02418342f, 0.02541604f, 0.02960928f, 0.01587577f, 0.00268410f, 
    0.00440063f, 0.00879975f, -0.02132203f, -0.00341994f, 0.01551131f, 0.01922780f, 0.02154330f, 0.00008249f, 
    0.00443586f, -0.02105865f, -0.02395472f, -0.01357505f, -0.03956125f, -0.00883576f, -0.01446012f, -0.01689222f, 
    -0.00397924f, -0.02577484f, -0.03290414f, -0.00334161f, 0.01341432f, -0.00868552f, -0.03250710f, -0.02502553f, 
    0.01837272f, 0.00149598f, -0.02211334f, 0.02452279f, -0.01380919f, -0.01660609f, 0.03032300f, -0.02979615f, 
    0.01318957f, 0.02439193f, -0.00859742f, -0.03053244f, -0.03317011f, -0.00947791f, -0.02533094f, 0.01600374f, 
    0.01392973f, 0.02197884f, -0.00284836f, -0.02955520f, 0.01579628f, -0.00833303f, 0.02381971f, -0.01029608f, 
    -0.02090965f, -0.01187939f, 0.02326626f, -0.03077792f, -0.03200426f, -0.02644530f, 0.02427980f, 0.01225649f, 
    -0.02077064f, 0.03959107f, -0.03072600f, -0.02257115f, 0.00093237f, 0.01959303f, -0.01722733f, -0.01275059f, 
    0.00080371f, 0.01979729f, -0.01391312f, -0.02024765f, 0.04111422f, -0.02660344f, -0.03073316f, 0.01142478f, 
    0.00089960f, 0.00631558f, -0.02032427f, 0.01681625f, -0.00333952f, -0.00335771f, -0.03525586f, -0.02574119f, 
    -0.02393238f, 0.00996768f, 0.00055491f, -0.00403510f, 0.02768996f, -0.01375093f, 0.01747125f, 0.00555480f, 
    0.00912281f, -0.03271098f, -0.04101180f, -0.00903281f, 0.01162746f, 0.02455124f, -0.02990341f, 0.03152796f, 
    -0.00182667f, 0.02662258f, -0.02047342f, 0.00406801f, -0.01557239f, -0.02060276f, -0.03375959f, -0.00149465f, 
    0.00918765f, -0.03874393f, 0.01576076f, 0.03099115f, -0.03397443f, -0.01759548f, 0.02639452f, 0.00789967f, 
    -0.00799615f, -0.02718548f, -0.00679357f, 0.02523718f, 0.02467942f, 0.00751435f, 0.03099526f, -0.02844025f, 
    0.01506220f, -0.01128279f, 0.01606535f, -0.04227519f, 0.01018827f, -0.03864565f, 0.01952675f, -0.04042912f, 
    -0.00948854f, -0.01369078f, 0.00102575f, -0.01756654f, 0.00865139f, 0.02976494f, -0.01761517f, 0.01505072f, 
    0.00047512f, -0.03534777f, 0.01055404f, -0.02034139f, 0.03436359f, -0.02000161f, -0.02138492f, 0.02344787f, 
    0.00932790f, 0.03084430f, 0.00516322f, -0.02634343f, 0.02179885f, 0.00264099f, -0.03074934f, -0.01635378f, 
    -0.03092756f, 0.01352387f, 0.02125512f, -0.02429440f, 0.01066529f, -0.00343509f, 0.00151568f, 0.01390532f, 
    0.01060566f, -0.01263067f, -0.00535166f, 0.00416147f, -0.02619312f, -0.01046195f, 0.00829459f, -0.02510481f, 
    -0.02921805f, -0.00775432f, -0.00098185f, 0.01865005f, 0.01050233f, 0.00825965f, -0.00902170f, 0.02732739f, 
    0.01064018f, 0.00767565f, -0.01324666f, -0.02165391f, 0.00223993f, 0.02281457f, 0.00455331f, -0.02802382f, 
    -0.01777128f, 0.00862089f, -0.03307715f, 0.03781356f, -0.02693364f, 0.01278839f, -0.03843902f, 0.02584882f, 
    0.01867907f, -0.03052807f, 0.01901396f, -0.03491062f, -0.01183195f, -0.00739313f, 0.02027362f, -0.00437521f, 
    0.00824935f, -0.02898517f, 0.03129729f, -0.02880762f, -0.03988581f, 0.01790035f, -0.02347030f, 0.02638011f, 
    0.03518114f, -0.04005449f, -0.02534939f, -0.03237711f, -0.00009465f, -0.01234288f, -0.00225652f, -0.01140662f, 
    0.00128423f, 0.01367294f, -0.02747743f, -0.04035270f, -0.01529545f, 0.01648803f, -0.03719367f, 0.02199793f, 
    0.00486897f, -0.01663210f, -0.01342697f, -0.00034584f, -0.01635199f, -0.00483531f, 0.01041108f, -0.02242852f, 
    0.02505169f, -0.01572867f, -0.00207805f, 0.00687026f, 0.01226134f, -0.00814243f, -0.01957630f, -0.01455249f, 
    -0.00707200f, -0.00902459f, -0.00167441f, -0.01520757f, 0.02154983f, -0.00963965f, -0.02260471f, 0.02249441f, 
    0.01149316f, -0.03230979f, -0.01334454f, -0.03041224f, 0.01832946f, -0.01793454f, 0.03645244f, -0.01870994f, 
    0.00836213f, -0.00023579f, -0.01598431f, 0.00382608f, 0.00257367f, 0.00808239f, 0.01679681f, -0.03969866f, 
    0.00894124f, -0.01482752f, 0.01687998f, -0.01621739f, -0.01306854f, -0.00675623f, 0.01653087f, -0.00391797f, 
    -0.01435263f, -0.01395176f, -0.02213845f, -0.01337845f, -0.02975645f, 0.02099180f, -0.00993977f, 0.02263722f, 
    0.03457047f, -0.00959733f, 0.00393317f, 0.02083102f, 0.01135801f, 0.01515254f, -0.00720825f, -0.00853486f, 
    0.01950625f, 0.00492871f, 0.02873863f, 0.00623443f, 0.00013649f, -0.02700245f, 0.02646376f, 0.00971949f, 
    0.01486442f, -0.03814020f, 0.02305504f, 0.02220109f, 0.02965233f, 0.02357690f, 0.00741526f, -0.01742330f, 
    -0.00029140f, -0.02048288f, -0.01009301f, 0.01068179f, 0.02327473f, 0.01542720f, 0.00983777f, 0.02775076f, 
    -0.04157588f, -0.02103759f, -0.02546303f, 0.01926330f, -0.01235164f, 0.02446439f, -0.03193719f, -0.01564167f, 
    -0.00043545f, 0.01959595f, -0.00684573f, -0.04042983f, -0.03939879f, 0.01645864f, -0.00284799f, 0.00639111f, 
    -0.00006435f, 0.00627385f, -0.01316610f, 0.00986300f, 0.02642644f, 0.00231500f, -0.03584346f, -0.02425724f, 
    0.02088459f, -0.01963280f, 0.01430691f, -0.03679935f, 0.02369459f, -0.03310288f, -0.02206915f, -0.02306931f, 
    0.02120367f, -0.00370463f, -0.01498094f, -0.02242723f, 0.03019544f, -0.01798229f, -0.03750351f, 0.00925964f, 
    0.01824150f, -0.02365300f, 0.00696420f, 0.02235657f, 0.02209387f, -0.03978036f, -0.03921779f, 0.03141865f, 
    -0.01158935f, 0.02931338f, 0.01310372f, -0.02062100f, -0.02538618f, -0.03841271f, -0.02283230f, 0.00097375f, 
    0.02464393f, 0.02363695f, 0.00346511f, 0.02577324f, 0.02116799f, -0.02069940f, -0.02869990f, -0.01242830f, 
    0.00236563f, -0.01973310f, -0.01084734f, -0.01060234f, -0.01439040f, 0.01045353f, -0.02117765f, -0.01427968f, 
    0.01336988f, -0.00771676f, -0.03833994f, 0.01884438f, 0.02978790f, 0.00987384f, 0.01411527f, -0.02244002f, 
    -0.03341592f, 0.00381487f, -0.00710182f, 0.00196204f, 0.00736448f, 0.02604354f, -0.02664922f, -0.04193706f, 
    0.00122593f, 0.00691589f, -0.01378682f, -0.03541486f, 0.01381093f, -0.00090226f, 0.02216763f, -0.00707238f, 
    -0.03296249f, -0.03447582f, -0.02831865f, 0.01708528f, 0.02746354f, 0.01007649f, 0.01231657f, 0.01094737f, 
    -0.03439226f, 0.02839406f, -0.00902406f, -0.02620025f, -0.02585504f, 0.01239711f, -0.01895219f, -0.01740808f, 
    0.01801056f, -0.03641916f, -0.02860816f, -0.01622462f, -0.03309015f, 0.02023837f, -0.02769474f, -0.01227866f, 
    0.00737892f, 0.03072638f, -0.02523243f, -0.01202731f, 0.01962016f, 0.01919332f, 0.02241448f, -0.03712723f, 
    -0.03637370f, -0.04083422f, 0.02201439f, 0.01972403f, -0.02574114f, -0.02920527f, -0.00895174f, -0.03948721f, 
    0.01251673f, -0.00655238f, 0.03023093f, -0.02412073f, 0.00604454f, -0.02235420f, -0.03589966f, -0.02029931f, 
    0.02287536f, -0.01362179f, 0.02819093f, -0.00639188f, 0.01316894f, 0.00045987f, 0.01779417f, -0.03441403f, 
    0.00458133f, -0.00264050f, 0.01607783f, 0.03158753f, -0.02793740f, -0.00064892f, -0.01305203f, -0.02481386f, 
    -0.03018354f, 0.02488489f, 0.01115027f, 0.01931933f, 0.00353907f, -0.03694012f, -0.01021766f, -0.00643913f, 
    0.01024034f, 0.00141877f, 0.01297776f, -0.01282409f, -0.01647691f, 0.01740723f, -0.03751349f, 0.02252048f, 
    -0.00051351f, 0.00951539f, -0.03955578f, -0.02580851f, -0.01089219f, -0.00016695f, 0.01006845f, 0.01882018f, 
    0.02426570f, -0.02438340f, -0.02668653f, 0.02597258f, 0.01254587f, -0.02092235f, 0.00742923f, -0.01283827f, 
    -0.03721911f, -0.01728167f, -0.01346223f, 0.00481629f, 0.02475185f, -0.01268876f, -0.03067735f, -0.00592163f, 
    -0.01835659f, 0.01509700f, 0.00409273f, -0.03902625f, -0.00738134f, -0.03653088f, 0.00197870f, 0.00427061f, 
    -0.02100596f, -0.03442632f, 0.01333045f, -0.02889676f, 0.00127334f, 0.02387832f, -0.01254075f, 0.02903948f, 
    -0.02429390f, -0.00438662f, 0.01756490f, 0.02417973f, -0.01103026f, 0.02390065f, -0.03439025f, -0.03398270f, 
    -0.02702431f, 0.02666556f, 0.02612965f, 0.02791394f, -0.00025353f, 0.01624077f, -0.01442716f, 0.02794562f, 
    -0.01336600f, 0.01080717f, 0.02043915f, -0.03683983f, -0.03699698f, -0.02418246f, -0.02733485f, -0.00123719f, 
    -0.01122576f, 0.00350970f, -0.02034131f, -0.00682968f, 0.00191802f, -0.02080308f, 0.03293415f, 0.01494310f, 
    -0.02586624f, 0.02624849f, -0.02136770f, -0.01581395f, 0.02263243f, -0.00196492f, -0.02333276f, 0.01520681f, 
    0.02270917f, -0.02479854f, -0.01819907f, -0.02688382f, -0.00292168f, -0.02486246f, -0.03332397f, 0.00312058f, 
    0.00683894f, -0.01448548f, 0.02719911f, -0.01311107f, 0.02437194f, -0.01532332f, 0.00682865f, -0.01501751f, 
    0.01262042f, 0.00848326f, 0.02065992f, -0.01724372f, -0.01418583f, -0.03937482f, -0.00104687f, 0.02351421f, 
    -0.03877337f, 0.02537954f, -0.02554619f, 0.01919840f, 0.02580976f, 0.01737933f, -0.01644234f, 0.00151190f, 
    0.00106160f, -0.04033963f, -0.01417751f, -0.03087346f, -0.01204365f, -0.01010633f, -0.00617051f, 0.01184300f, 
    -0.03311361f, -0.00166515f, -0.03886143f, 0.02529391f, -0.01574988f, 0.01959008f, 0.02047762f, 0.02192879f, 
    -0.02181909f, 0.02522842f, 0.00722358f, -0.01975348f, -0.00223283f, 0.00148947f, 0.02293701f, -0.01266334f, 
    0.02828300f, -0.01357325f, -0.02758197f, -0.02400730f, 0.00040039f, -0.03039241f, 0.00260878f, -0.00457824f, 
    -0.03882136f, -0.02743600f, 0.00073918f, -0.02197363f, -0.02944019f, -0.02644484f, 0.00506479f, 0.01134156f, 
    0.03513260f, -0.02632196f, 0.02807082f, -0.04147753f, 0.01834416f, -0.00297515f, 0.02187506f, -0.00513390f, 
    -0.01419865f, -0.02648155f, -0.04037457f, 0.00154984f, -0.01472089f, 0.02808717f, 0.01292102f, -0.00031602f, 
    0.00676549f, -0.01199325f, -0.00731694f, -0.03686545f, -0.00511258f, 0.00786354f, 0.00081746f, 0.00730659f, 
    -0.00917564f, 0.04157903f, 0.02428281f, -0.00321211f, -0.01728248f, -0.02969078f, -0.00308561f, 0.03224344f, 
    0.00786219f, -0.00409535f, -0.00133325f, -0.00219902f, -0.01387782f, -0.00856816f, -0.01133221f, -0.02045741f, 
    -0.02955908f, 0.03078756f, 0.01006254f, -0.01920592f, 0.02098764f, 0.00132591f, 0.01793235f, 0.01991964f, 
    0.00129863f, 0.02452142f, -0.01310551f, 0.03425364f, 0.01770498f, 0.01215429f, -0.02518825f, -0.02583928f, 
    -0.01866546f, 0.00115559f, -0.02895598f, -0.01460558f, -0.00826663f, -0.02104140f, 0.00845386f, 0.00975968f, 
    -0.01082595f, -0.01475684f, 0.00037062f, -0.03652935f, -0.02750597f, 0.00741902f, 0.01216263f, -0.01534212f, 
    0.02599884f, 0.02741130f, -0.02788364f, -0.03422229f, -0.03685032f, -0.01753025f, -0.03009008f, 0.01596826f, 
    -0.03861377f, 0.01772790f, 0.02253883f, -0.00434156f, 0.01169985f, -0.02214582f, -0.03347770f, 0.01201213f, 
    -0.00098487f, 0.02657370f, 0.00049507f, -0.02182817f, -0.03581407f, -0.00031010f, 0.02299692f, -0.00812465f, 
    0.01649126f, 0.02923093f, 0.02726558f, 0.02752825f, -0.03393498f, -0.02222790f, 0.02036276f, 0.02456172f, 
    0.01257177f, -0.01964065f, 0.01871324f, -0.03684721f, -0.02127809f, -0.01738705f, 0.01974087f, -0.02068472f, 
    0.01644689f, -0.03020918f, 0.02666874f, -0.00289284f, -0.01866639f, -0.00831045f, -0.03211209f, 0.02719716f, 
    -0.01561307f, -0.02471341f, -0.02727558f, 0.01481102f, 0.02719160f, -0.02052364f, -0.02588467f, -0.02476977f, 
    0.02548680f, -0.01672451f, 0.01398883f, -0.01472831f, 0.01099859f, 0.02125246f, 0.01775950f, -0.03019062f, 
    0.00145515f, 0.02230614f, 0.00862600f, 0.02302873f, 0.02360733f, -0.01077368f, -0.03763535f, -0.04051472f, 
    0.02918649f, 0.02085840f, -0.02651658f, -0.02844440f, -0.01045111f, -0.02037488f, -0.04011304f, 0.01534790f, 
    0.00703070f, 0.02011731f, -0.01301626f, -0.00133983f, 0.00310771f, -0.02346815f, -0.00173031f, -0.01546734f, 
    0.02066170f, 0.01405479f, 0.02982126f, -0.03310953f, 0.01979815f, -0.04016470f, -0.02226070f, -0.00049615f, 
    0.02196602f, -0.00479560f, 0.01588580f, -0.00695734f, 0.01774030f, -0.01616453f, 0.00289994f, -0.01514869f, 
    -0.01718520f, 0.01154777f, -0.02708817f, 0.00073845f, -0.03617619f, 0.01502525f, -0.01607453f, -0.00759106f, 
    0.00718446f, -0.01702359f, 0.02262979f, -0.00032270f, -0.00805188f, -0.03485910f, -0.02920598f, 0.02411296f, 
    -0.01218328f, 0.03313922f, -0.02237729f, 0.01406741f, 0.01691464f, -0.00605678f, 0.01099075f, 0.01933511f, 
    -0.00418276f, 0.00944398f, -0.00486089f, 0.01056437f, -0.04183559f, 0.02087577f, 0.02080859f, 0.01165490f, 
    -0.00882232f, -0.00390985f, -0.00323498f, -0.03965102f, -0.00542022f, -0.02998174f, -0.03664120f, -0.00153441f, 
    -0.01913027f, -0.03348773f, 0.02098392f, -0.03275216f, 0.02756157f, -0.02626736f, 0.00730803f, 0.00402977f, 
    -0.00440568f, -0.02327044f, -0.01505555f, -0.03783626f, -0.00936838f, -0.01949898f, 0.01231482f, -0.00308946f, 
    0.01363174f, 0.01981231f, -0.01491305f, -0.03042022f, 0.00914725f, -0.00983099f, -0.03656460f, 0.03053877f, 
    0.02421920f, 0.02868477f, 0.00573923f, -0.03501574f, 0.02485960f, -0.01554244f, 0.00267653f, 0.01041556f, 
    -0.01860391f, 0.01010702f, -0.02394392f, 0.01647681f, -0.02979774f, 0.01963983f, 0.02046040f, -0.02123045f, 
    -0.02740589f, 0.01124877f, -0.02280459f, -0.01935538f, -0.03112165f, -0.04079663f, -0.03805545f, 0.02829302f, 
    -0.00924940f, 0.02553390f, -0.00884231f, -0.03973778f, -0.00903726f, 0.00087481f, -0.03834298f, -0.00952490f, 
    -0.03936924f, 0.01217439f, -0.01441743f, 0.01222226f, -0.00279162f, -0.00207324f, 0.00132069f, -0.03176734f, 
    -0.03109434f, 0.00501259f, 0.02504607f, 0.01781824f, 0.00300546f, -0.02489446f, 0.01979641f, -0.03686264f, 
    -0.03975564f, -0.02158318f, -0.03197360f, 0.02812969f, -0.00910367f, -0.01976351f, 0.01895227f, 0.01776320f, 
    -0.01319325f, 0.02350275f, 0.00733861f, -0.02592056f, -0.00063897f, -0.02605212f, -0.00176610f, -0.03514377f, 
    -0.02621552f, 0.02121075f, 0.02269422f, 0.01526391f, 0.01947060f, -0.01260109f, 0.02567966f, -0.01560487f, 
    -0.03744036f, -0.03977774f, -0.03212544f, -0.01745580f, -0.01926049f, 0.02279564f, 0.00132273f, -0.01660934f, 
    -0.03106741f, 0.00601888f, 0.00732087f, -0.02339051f, -0.01267401f, -0.03007973f, 0.00808079f, -0.00543359f, 
    -0.02501444f, -0.02465815f, 0.00528788f, -0.02946378f, 0.02037419f, -0.00573812f, -0.02592453f, -0.02226706f, 
    -0.00282702f, -0.02621073f, -0.04168591f, -0.00652680f, -0.01029703f, 0.00087615f, 0.00894713f, 0.01342401f, 
    -0.00605740f, -0.02709213f, -0.02570632f, -0.01965409f, 0.01592234f, 0.00240185f, 0.02593000f, -0.02865450f, 
    -0.00746059f, 0.01130728f, 0.03051199f, 0.02384688f, -0.00544766f, -0.01663602f, -0.00994603f, 0.02826850f, 
    -0.02222020f, 0.00301467f, 0.03065769f, -0.01913715f, -0.03746142f, -0.03297154f, 0.00242717f, -0.00242589f, 
    0.02057276f, -0.02793073f, 0.02012849f, 0.01520051f, -0.02657947f, -0.02125517f, 0.02127419f, 0.01910132f, 
    -0.03045945f, -0.00871904f, -0.02637366f, -0.00752523f, -0.01635579f, 0.01066917f, 0.01425613f, 0.01548944f, 
    -0.01179589f, -0.03018390f, -0.00334093f, 0.01779512f, 0.00986743f, -0.03797192f, 0.02818183f, -0.00138094f, 
    0.01376666f, 0.01996374f, 0.02475844f, 0.01833055f, 0.02928482f, -0.03519288f, -0.02328476f, -0.03974232f, 
    0.03471690f, 0.00340616f, -0.01106393f, -0.01404773f, 0.01347870f, 0.00877530f, -0.01288049f, -0.00310194f, 
    -0.04145861f, -0.03247248f, -0.00943234f, 0.00017072f, -0.00477011f, 0.02725790f, -0.00630376f, -0.02296531f, 
    -0.03565413f, -0.01163044f, -0.00803845f, -0.03659431f, -0.02134426f, 0.00624875f, -0.02439273f, -0.03344115f, 
    -0.03597735f, 0.00579891f, -0.03149698f, 0.01867480f, 0.02745043f, 0.02294574f, 0.02239470f, -0.01127144f, 
    0.01087367f, -0.03803320f, -0.03862650f, 0.00670615f, -0.01444189f, 0.02867579f, -0.01480142f, -0.01691663f, 
    -0.02174229f, 0.01404511f, 0.01832736f, 0.02083755f, 0.00781464f, -0.02445596f, -0.03033590f, 0.02577761f, 
    0.02197162f, -0.02539126f, -0.03346621f, -0.00075071f, -0.02634251f, -0.01830081f, 0.00734111f, 0.00955695f, 
    0.00518911f, -0.01227357f, 0.02075784f, -0.00489157f, -0.00017622f, -0.01245341f, 0.00192893f, 0.01875825f, 
    0.02310962f, 0.02793971f, 0.00839181f, -0.01952316f, 0.02033831f, -0.02706223f, -0.04037094f, -0.01984992f, 
    -0.01812397f, 0.01747367f, 0.01450724f, 0.02231507f, -0.00702567f, -0.02325151f, 0.01552055f, 0.02337657f, 
    0.02744656f, -0.00145133f, 0.01475922f, -0.00865502f, -0.03733898f, -0.02654566f, -0.01272519f, 0.01909396f, 
    0.00000150f, -0.00104562f, -0.02473314f, -0.01797534f, 0.00015411f, -0.03015246f, -0.01742151f, -0.01104654f, 
    -0.03392578f, -0.00454770f, -0.00909921f, 0.02159115f, 0.02253632f, 0.02538618f, 0.00503305f, 0.00229020f, 
    0.00430578f, 0.02223639f, 0.00613199f, -0.02648627f, 0.01904952f, -0.03542483f, -0.03400325f, 0.00218690f, 
    -0.03752072f, -0.02788772f, 0.01150554f, -0.00280662f, 0.01851280f, -0.02903411f, 0.00298435f, -0.00224202f, 
    -0.01331630f, -0.00036687f, 0.01878435f, 0.02263478f, -0.04046792f, -0.02007855f, -0.03897596f, -0.02052061f, 
    0.01379080f, -0.02209942f, -0.01710813f, -0.00054411f, 0.02533560f, -0.04079645f, -0.00200599f, -0.01518451f, 
    -0.02390395f, -0.01869621f, 0.01065742f, 0.01479383f, -0.02625805f, 0.00513089f, 0.02920448f, -0.03474061f, 
    -0.03456770f, 0.02101606f, -0.03294982f, -0.00727247f, -0.01768635f, -0.01190688f, 0.01908649f, 0.02449312f, 
    0.01218081f, -0.01250021f, -0.00609609f, -0.03506483f, -0.01220004f, 0.01510917f, 0.02581453f, 0.00813330f, 
    -0.01678641f, -0.01575189f, -0.02655809f, 0.02846514f, 0.02011382f, -0.02844149f, -0.03887676f, -0.01845190f, 
    0.00750342f, -0.01040825f, 0.00646515f, 0.02565425f, -0.03286142f, 0.02019753f, -0.03051144f, -0.01021717f, 
    -0.02889857f, 0.01886481f, -0.00930561f, 0.02424205f, -0.04014423f, -0.00823218f, -0.03106624f, 0.00606079f, 
    -0.03930035f, -0.03131451f, -0.01199985f, 0.00248672f, 0.01245959f, -0.04141543f, 0.00661520f, -0.01082406f, 
    -0.02967107f, -0.03657185f, 0.00709069f, 0.02527375f, -0.02129462f, 0.01042451f, -0.03428527f, -0.03003747f, 
    0.00826062f, -0.02416240f, 0.00889227f, -0.00847564f, -0.04065435f, -0.02236499f, -0.02788175f, 0.00486700f, 
    0.00106276f, 0.00065723f, 0.01706764f, -0.03533887f, 0.02345552f, -0.00088863f, -0.03694835f, -0.00448809f, 
    -0.02529485f, -0.03079863f, -0.01660971f, 0.02069312f, -0.02781863f, 0.01844379f, -0.04138405f, -0.01766476f, 
    0.01294732f, -0.00576139f, -0.02245093f, -0.03796896f, 0.00297624f, -0.04110225f, -0.01275548f, -0.01362181f, 
    0.00259285f, -0.02747801f, 0.00331260f, -0.01500349f, 0.00799684f, -0.00262196f, -0.03764058f, -0.04171224f, 
    -0.02441035f, -0.00844086f, -0.02045990f, 0.01305845f, 0.02392844f, -0.03246598f, -0.00839588f, -0.01232972f, 
    0.02428249f, -0.00948713f, -0.03596647f, -0.02361752f, -0.03646546f, 0.01610032f, -0.00934366f, 0.02853838f, 
    0.00541706f, 0.02604451f, -0.01111056f, -0.04084343f, 0.02295334f, 0.02629386f, -0.01594648f, -0.00154130f, 
    0.01592187f, -0.00014222f, -0.00409202f, -0.03793204f, -0.01618793f, -0.02537402f, -0.01727138f, -0.02471495f, 
    -0.03810878f, 0.00249535f, -0.01806040f, 0.00425054f, -0.03685552f, -0.01229209f, -0.01319817f, 0.01693879f, 
    0.00998391f, -0.01907561f, -0.00945793f, -0.00752710f, -0.01117687f, 0.02003799f, 0.01804265f, -0.01045162f, 
    0.00162575f, -0.03112615f, -0.01399833f, -0.00817147f, 0.02800907f, -0.02714804f, -0.02744114f, 0.00805863f, 
    -0.01801971f, -0.01083524f, -0.03585418f, 0.02172911f, 0.00656748f, -0.01053313f, -0.02580170f, -0.02205801f, 
    0.01941081f, -0.04105182f, 0.00999524f, 0.02546578f, 0.02834247f, -0.00106151f, 0.00825027f, 0.00067166f, 
    0.00076986f, -0.03508433f, -0.03983699f, 0.01462244f, 0.02219878f, 0.01931353f, 0.01845571f, -0.01173703f, 
    -0.01376972f, 0.02485432f, 0.00507458f, -0.03812511f, -0.01409594f, -0.01945615f, -0.00323911f, -0.02590563f, 
    -0.03894974f, -0.01189232f, -0.02501114f, -0.01229078f, 0.02220768f, -0.02180743f, 0.01138468f, 0.01581927f, 
    -0.03067024f, -0.00461503f, -0.00482671f, 0.02134455f, -0.00643973f, -0.01067478f, -0.02162729f, 0.02253909f, 
    -0.03687982f, -0.03189411f, -0.02568399f, 0.00880424f, 0.00706056f, -0.02258556f, -0.01216378f, 0.01248173f, 
    0.01092410f, -0.01672721f, -0.02700348f, -0.04178780f, -0.04132894f, -0.03163405f, -0.01382765f, -0.03615814f, 
    -0.01970047f, 0.00306269f, 0.02673643f, -0.01512872f, -0.01929149f, -0.02315413f, -0.04115656f, -0.03091842f, 
    -0.02020983f, -0.02736112f, -0.00331786f, 0.00324738f, -0.02551853f, -0.00940376f, 0.00679159f, 0.02409139f, 
    -0.00404731f, 0.01393810f, -0.00116327f, -0.03248833f, -0.02439995f, -0.02354476f, -0.02645708f, -0.02522680f, 
    -0.04086339f, 0.00249123f, 0.02234215f, 0.00424331f, 0.02645484f, 0.01931451f, -0.04001797f, 0.01383807f, 
    -0.00039861f, -0.03784981f, -0.03550237f, 0.02282131f, -0.00325323f, 0.00415600f, -0.00073304f, 0.01834309f, 
    -0.01494125f, 0.02464571f, -0.00460270f, -0.00916554f, -0.03593541f, -0.00127618f, -0.03887143f, 0.00198837f, 
    0.01052831f, -0.04118327f, -0.02688609f, -0.03977605f, 0.02662563f, 0.01538709f, 0.00282652f, -0.04029236f, 
    -0.03809309f, -0.03453537f, 0.02288730f, -0.03679138f, -0.03140310f, -0.03631685f, 0.01811408f, 0.00352466f, 
    0.00699733f, -0.00320254f, -0.03047390f, -0.02797893f, -0.03554850f, -0.00492330f, 0.01881724f, -0.02055238f, 
    -0.02729173f, 0.01667615f, -0.00948204f, -0.04066322f, -0.02470298f, 0.02665487f, -0.00135078f, -0.01124740f, 
    -0.00535586f, -0.00526206f, -0.01235817f, 0.01065442f, -0.00318613f, -0.03038052f, 0.01325970f, 0.01008310f, 
    -0.03030795f, 0.02382693f, 0.01539825f, 0.01859646f, -0.02489320f, -0.01708546f, 0.02083752f, 0.00402893f, 
    -0.03965556f, -0.00188271f, -0.01565886f, 0.00661366f, -0.00633799f, 0.01364680f, -0.02027327f, 0.02096088f, 
    0.02298322f, -0.01960184f, -0.00775624f, -0.02888908f, -0.02592602f, 0.00288129f, -0.02429898f, 0.00529267f, 
    0.00244914f, 0.02626411f, 0.01469158f, -0.01454511f, 0.00407356f, 0.01852071f, -0.00687285f, 0.00373707f, 
    -0.01253644f, -0.00037336f, -0.03285849f, -0.00493859f, 0.00082263f, -0.03109334f, 0.02538957f, 0.00513352f, 
    -0.02427325f, -0.03938424f, 0.02950034f, 0.02939025f, -0.03302454f, -0.03614670f, 0.01227926f, 0.01533359f, 
    -0.03572679f, -0.00057137f, 0.00656198f, -0.00152788f, -0.03011082f, -0.03849998f, -0.01321242f, -0.00137525f, 
    -0.02450415f, -0.02067150f, -0.03621608f, -0.01282415f, -0.00684138f, -0.02690566f, 0.01116004f, -0.03829895f, 
    0.01587637f, 0.00704291f, 0.01691908f, 0.02734941f, -0.01926865f, -0.03447216f, -0.01268156f, -0.03864456f, 
    -0.01774273f, -0.03788808f, 0.00071193f, -0.03533036f, -0.01409802f, 0.00890892f, -0.00043554f, 0.02788054f, 
    -0.01351742f, -0.03881476f, -0.00270676f, -0.00774307f, 0.02604119f, -0.00010463f, -0.02718024f, -0.00760648f, 
    0.01893302f, -0.01170385f, 0.02682760f, -0.04077347f, 0.02465565f, 0.00750763f, 0.01497804f, -0.02119413f, 
    0.01620056f, -0.00708491f, 0.01374015f, 0.02300638f, 0.02109043f, 0.02547092f, -0.01472664f, -0.02016662f, 
    -0.02857598f, -0.03340422f, -0.01353535f, 0.02729406f, 0.00748494f, -0.00272032f, -0.00327860f, 0.02352303f, 
    -0.02851132f, 0.00608349f, 0.00422586f, -0.04086646f, 0.02919698f, -0.00205525f, -0.03555691f, 0.02493883f, 
    -0.00003665f, -0.01056666f, -0.01482340f, -0.00990210f, -0.03319633f, -0.00340590f, 0.02132386f, -0.03461001f, 
    0.00135915f, 0.01618342f, -0.04114810f, 0.00146556f, -0.01784234f, 0.02947031f, 0.02483648f, -0.02235206f, 
    -0.03174767f, -0.02938530f, -0.01312563f, -0.03791065f, -0.01546152f, -0.02146533f, 0.00359306f, -0.03782413f, 
    -0.02140996f, 0.00163022f, -0.01843645f, -0.03948991f, 0.00760225f, 0.02011345f, 0.00120146f, 0.02881185f, 
    -0.03961765f, -0.00436518f, -0.03654547f, -0.04060019f, -0.02595587f, -0.01606289f, -0.04006156f, -0.02887647f, 
    0.02313573f, 0.00735276f, 0.01152282f, -0.03301853f, 0.00074956f, -0.00904049f, 0.02479905f, 0.01406463f, 
    -0.00845089f, -0.04179536f, -0.01925904f, -0.00545029f, 0.01993513f, 0.01693464f, 0.02736970f, -0.04143028f, 
    -0.02264338f, 0.02776141f, 0.00627524f, 0.00352435f, -0.01899556f, -0.01123197f, 0.01082523f, -0.02575481f, 
    -0.03037607f, -0.00028022f, -0.00299720f, -0.01416632f, -0.01743152f, 0.01819444f, -0.00860625f, -0.00114910f, 
    -0.02668780f, 0.00966308f, -0.00674147f, 0.02171896f, 0.00024206f, -0.03363908f, -0.00182832f, -0.01139983f, 
    -0.00527701f, 0.02502067f, -0.00955777f, 0.01347591f, 0.01649670f, 0.01868082f, 0.01728874f, 0.00071189f, 
    0.00209213f, -0.01997283f, -0.00639615f, -0.04078034f, -0.00698956f, -0.01703125f, -0.01210542f, -0.02007735f, 
    0.02254912f, 0.02704254f, 0.00577858f, -0.00967709f, 0.02608836f, 0.00842542f, 0.02839633f, -0.02541752f, 
    -0.01617149f, 0.01884985f, 0.01056701f, 0.00065734f, -0.03950895f, -0.02428078f, -0.03308976f, -0.01132540f, 
    -0.03972944f, 0.02093687f, -0.01753512f, -0.02540929f, -0.01607423f, -0.01410753f, -0.03171295f, -0.02931040f, 
    -0.03436015f, -0.02033035f, 0.00379222f, 0.02016502f, 0.00335876f, 0.00196758f, -0.00720327f, -0.00841997f, 
    0.01616863f, -0.00893021f, 0.00528696f, -0.01796073f, 0.01235810f, -0.00286948f, -0.03934575f, 0.00264020f, 
    0.02839691f, -0.00489952f, 0.02130296f, -0.03706240f, -0.00365123f, -0.01438956f, 0.02216917f, -0.02333002f, 
    -0.04177284f, -0.04201598f, 0.00734217f, -0.03960714f, -0.02338302f, 0.02307411f, 0.02279527f, 0.02339807f, 
    0.02419343f, -0.00792246f, -0.03111676f, 0.02514049f, -0.03811368f, 0.00283016f, 0.02634410f, -0.02741730f, 
    0.02110336f, -0.00534126f, 0.01412240f, -0.00275150f, -0.00250549f, -0.03410279f, 0.01072044f, -0.01013727f, 
    -0.03994146f, 0.01581711f, -0.03051890f, -0.01263222f, 0.00383386f, -0.00220866f, -0.00784677f, -0.02197705f, 
    -0.03146367f, 0.00962132f, 0.00247540f, 0.01413639f, 0.02297486f, 0.01287720f, 0.00692273f, 0.01557833f, 
    -0.00142442f, -0.01199277f, -0.03806426f, -0.02971304f, -0.01365973f, -0.03842743f, 0.01837856f, -0.03544567f, 
    -0.00293282f, -0.00623331f, -0.00276757f, 0.01351001f, 0.01598903f, -0.02124901f, 0.00966763f, -0.01841095f, 
    0.01465024f, 0.02272490f, -0.03857489f, -0.00844300f, 0.00930698f, -0.03381361f, 0.01689587f, 0.02972107f, 
    -0.00741274f, -0.01842758f, -0.00413327f, 0.00384148f, 0.01275924f, 0.01743009f, -0.00133521f, 0.01649363f, 
    -0.01158162f, -0.01491210f, -0.03742654f, -0.03348026f, 0.01072980f, 0.00949612f, -0.00335483f, -0.04040507f, 
    0.01060298f, -0.01363121f, 0.02659225f, -0.03425411f, -0.01320811f, 0.00683036f, -0.03425341f, 0.01583689f, 
    -0.01634257f, -0.00879396f, -0.02191341f, -0.03497237f, -0.00429663f, -0.04303195f, 0.02275686f, 0.00822430f, 
    0.02538108f, -0.02967299f, -0.03791164f, 0.00749203f, -0.02520061f, -0.00933959f, 0.01966187f, 0.01363072f, 
    0.02719644f, 0.01934866f, 0.00540077f, -0.02058012f, -0.03269108f, -0.02516338f, -0.02689813f, -0.00904507f, 
    0.00195138f, 0.00200828f, -0.01144025f, 0.01604010f, 0.03389853f, -0.02228025f, 0.01239476f, -0.03999378f, 
    -0.00846078f, 0.01900698f, -0.00494862f, -0.02908360f, 0.00765837f, -0.04138003f, -0.00253447f, 0.02008229f, 
    -0.01668343f, -0.03314870f, 0.01631247f, 0.00454040f, -0.01287788f, 0.01408965f, -0.03456081f, 0.01715671f, 
    -0.00805108f, 0.02650869f, -0.00110380f, 0.02357753f, 0.02670339f, 0.02116789f, -0.02976101f, 0.00992750f, 
    0.03168189f, -0.01141861f, 0.02790905f, -0.02546947f, -0.01815597f, -0.04140145f, 0.02000479f, 0.02248333f, 
    -0.02081787f, -0.03835142f, 0.00272455f, 0.01383490f, 0.00221656f, -0.01928717f, -0.02354525f, -0.00431899f, 
    0.00096675f, 0.02325301f, 0.00770453f, 0.01407719f, 0.01414359f, 0.00564844f, -0.01394078f, -0.02403542f, 
    -0.02159737f, -0.02912131f, -0.00430309f, -0.03460949f, 0.02584562f, 0.00489938f, -0.01787144f, -0.00001906f, 
    -0.03571837f, -0.01305266f, -0.00267953f, -0.02403068f, -0.03503240f, -0.02198747f, 0.00340487f, -0.00285311f, 
    0.00314668f, -0.03895036f, 0.00773492f, -0.02670680f, 0.01335967f, -0.01724186f, -0.03182381f, -0.00739875f, 
    0.01201013f, -0.02497695f, 0.02245109f, 0.02458855f, -0.02605905f, 0.03011940f, -0.03930762f, -0.00742908f, 
    0.01032211f, 0.01281565f, -0.00167641f, -0.02027014f, 0.00748062f, -0.02291658f, 0.02451414f, -0.00183891f, 
    -0.01052869f, 0.02394064f, -0.00127268f, -0.03077549f, 0.02197536f, 0.00577524f, -0.01983988f, -0.01386657f, 
    -0.04332137f, 0.01189602f, 0.02491087f, -0.04304192f, 0.02427761f, -0.01560304f, 0.00916419f, 0.02028575f, 
    -0.01796197f, 0.01182823f, -0.02878970f, -0.02149728f, -0.04060046f, 0.00274260f, -0.02070558f, 0.00945678f, 
    0.02119588f, 0.02249335f, 0.00812569f, 0.00622679f, 0.03139828f, -0.00402466f, -0.03075284f, -0.01367815f, 
    -0.00681538f, -0.01217797f, -0.01439646f, 0.01628853f, 0.01118921f, -0.01679834f, -0.00405795f, -0.00412050f, 
    -0.03656214f, -0.02868974f, -0.00209675f, -0.02027162f, 0.02025729f, -0.01468481f, 0.00714806f, 0.01432735f, 
    -0.00206238f, -0.02210375f, -0.01618529f, 0.01832568f, 0.01469185f, 0.01715429f, 0.00688091f, -0.01337562f, 
    0.01691386f, 0.02116101f, 0.02973969f, 0.02079788f, 0.00077760f, -0.03042058f, 0.00623686f, -0.01916352f, 
    -0.01108602f, -0.00355081f, -0.00456458f, 0.02813815f, 0.02239262f, 0.00270037f, -0.02000061f, -0.01226374f, 
    -0.03355505f, -0.04077139f, 0.01897300f, 0.03972210f, -0.01502033f, -0.02653189f, -0.02798143f, -0.02826622f, 
    -0.00707526f, 0.01076316f, -0.02718838f, -0.00698328f, -0.02565823f, -0.00574530f, -0.02289777f, -0.00455487f, 
    0.00579620f, -0.01368185f, 0.00190211f, 0.02451812f, -0.01004391f, 0.01742137f, -0.03932705f, -0.04338239f, 
    0.01703540f, 0.00034659f, -0.03248049f, 0.02886052f, 0.02482416f, -0.00018717f, -0.02193906f, 0.00802575f, 
    -0.04236368f, -0.03197968f, 0.02746397f, -0.03081732f, -0.01459854f, -0.01531613f, -0.03242199f, -0.00045631f, 
    -0.03005634f, 0.00193833f, -0.00155011f, 0.02271685f, -0.01150658f, -0.00908657f, -0.02334968f, -0.01327450f, 
    0.01044635f, -0.01813827f, 0.00285805f, 0.00256362f, -0.00827435f, 0.01297304f, -0.03437682f, 0.01184104f, 
    0.01871754f, -0.01127121f, -0.02997679f, -0.02017585f, 0.01055020f, 0.03877278f, 0.01012180f, 0.01632208f, 
    -0.00019430f, 0.00464617f, -0.00482899f, -0.02800239f, 0.01615940f, 0.02632623f, 0.01210306f, -0.04056518f, 
    0.01037379f, -0.01051722f, -0.01041086f, 0.00276599f, 0.00871708f, -0.01542408f, -0.00010079f, -0.02969980f, 
    0.02486825f, -0.03702822f, -0.01030669f, 0.01197810f, 0.02983875f, -0.01052686f, -0.02068411f, 0.00058776f, 
    0.02429064f, -0.04382935f, -0.00728720f, -0.01865462f, -0.01807374f, 0.03030615f, -0.00039643f, -0.02810914f, 
    -0.01760062f, -0.03057669f, 0.00511639f, -0.00954605f, -0.01219352f, -0.01891950f, -0.01919058f, -0.00463952f, 
    0.00512082f, -0.01980470f, -0.00608550f, 0.00732651f, -0.00435629f, -0.03037441f, 0.01882646f, -0.01570185f, 
    0.02103660f, -0.02271104f, 0.01296530f, 0.01447912f, 0.01970694f, -0.03964213f, 0.03013990f, -0.04186906f, 
    -0.01805755f, -0.01688765f, -0.01629785f, 0.01320629f, -0.02868632f, 0.02287967f, -0.04031490f, -0.01868754f, 
    0.02611285f, 0.00411828f, 0.00010152f, -0.02587949f, 0.02191860f, 0.01721306f, -0.01317316f, 0.02752977f, 
    0.00760789f, -0.01497638f, 0.03237730f, 0.00043127f, 0.00155959f, 0.00999284f, -0.02012966f, 0.01080558f, 
    -0.00947316f, 0.01803753f, -0.02134986f, -0.03905448f, 0.01515819f, -0.03861715f, 0.04121530f, 0.00699751f, 
    -0.03935149f, 0.00030468f, -0.02410829f, -0.00472181f, 0.01827573f, -0.03290918f, -0.02448939f, 0.02577159f, 
    -0.01031488f, -0.04042150f, -0.03235594f, 0.01025417f, -0.01513454f, -0.03426198f, 0.00528887f, -0.02563933f, 
    -0.01404749f, 0.00311535f, 0.02043896f, 0.02749296f, 0.01555228f, 0.01222269f, -0.02261726f, -0.02020235f, 
    0.01897050f, -0.04268513f, 0.01037813f, -0.02190398f, -0.03092818f, -0.02301923f, -0.02992205f, 0.00233758f, 
    -0.01238811f, 0.01593166f, -0.01846422f, -0.02748462f, -0.00913295f, 0.00071172f, 0.02122990f, -0.00092636f, 
    0.00863488f, 0.01545572f, -0.02083705f, 0.01156253f, 0.01049866f, -0.02283341f, -0.03845552f, -0.02151731f, 
    -0.01541017f, -0.00732790f, 0.00963404f, 0.00430976f, -0.00841854f, -0.02186680f, -0.03159397f, 0.00300742f, 
    0.00223218f, 0.02662414f, -0.01142719f, -0.03299802f, 0.01469017f, -0.02592199f, 0.02308122f, -0.03152378f, 
    -0.00665651f, -0.00281874f, 0.02142850f, 0.01648616f, 0.02800512f, 0.02072988f, -0.03646654f, 0.02027993f, 
    -0.04197184f, 0.02043361f, 0.02609625f, 0.00671245f, 0.00424206f, -0.02995414f, -0.01156699f, -0.02890136f, 
    -0.00748804f, -0.03832498f, 0.00539321f, -0.02304827f, -0.00487133f, -0.03385803f, -0.03676814f, 0.02240261f, 
    -0.01521243f, -0.01345165f, -0.00919591f, -0.04097026f, 0.01214791f, 0.01177754f, -0.00813019f, 0.01720747f, 
    -0.03549806f, -0.01531425f, 0.02008038f, -0.00251207f, -0.03859282f, 0.00648446f, 0.02632738f, 0.02522572f, 
    0.01514705f, -0.01140226f, -0.00596961f, -0.03384480f, -0.03762476f, -0.02249273f, 0.00795720f, 0.00747292f, 
    0.01300445f, -0.00314259f, 0.02404636f, 0.01646539f, -0.01394665f, 0.01260808f, 0.03950205f, 0.00173403f, 
    0.01880667f, -0.00987651f, 0.00568653f, 0.02170557f, 0.02864661f, -0.02776699f, -0.01503628f, -0.02573198f, 
    0.02849913f, 0.02531792f, 0.01016757f, -0.01468611f, 0.00282304f, 0.00016095f, 0.00801107f, -0.00459567f, 
    -0.03711281f, 0.02001198f, -0.01956503f, -0.01180685f, -0.00348690f, -0.00368542f, -0.01206415f, 0.00095981f, 
    0.02538351f, 0.01000991f, 0.02212950f, -0.03240148f, -0.02536488f, -0.02061331f, -0.00766941f, -0.03928971f, 
    -0.00376815f, 0.01631585f, -0.03583970f, 0.02102909f, 0.01007090f, 0.00666516f, -0.01614529f, 0.01316048f, 
    -0.01511197f, 0.01756141f, -0.01528337f, -0.02800391f, 0.01877729f, -0.02047376f, 0.02353482f, 0.02760368f, 
    -0.00820933f, 0.01714465f, -0.03691307f, -0.02351395f, 0.01908960f, -0.02001680f, 0.00677413f, -0.01751278f, 
    -0.02286430f, 0.00044979f, 0.02792963f, 0.03087584f, 0.01642363f, -0.03051452f, 0.00625431f, -0.00236293f, 
    -0.02534442f, 0.00037659f, 0.01259752f, -0.03508906f, 0.00054059f, 0.00089104f, -0.03827905f, -0.02188849f, 
    0.01236992f, -0.03896053f, -0.02715911f, -0.01224625f, -0.02637642f, 0.02648420f, -0.01871183f, -0.00043635f, 
    -0.03997463f, 0.02895464f, 0.02296442f, -0.00654199f, -0.04243092f, -0.00265209f, -0.00223649f, -0.02801507f, 
    -0.01252222f, 0.02006728f, -0.02907894f, -0.03123137f, -0.01839491f, 0.00701463f, -0.00511745f, -0.03218454f, 
    0.00129125f, 0.01586844f, 0.00224390f, 0.01972995f, 0.00445286f, -0.03464699f, -0.00058686f, 0.01099554f, 
    -0.02905971f, 0.02585595f, -0.00747425f, 0.01515205f, -0.04149117f, -0.01469894f, -0.01036467f, 0.02759338f, 
    -0.02431310f, 0.03530547f, 0.00402674f, -0.02412438f, -0.01402354f, -0.00365467f, 0.02901860f, -0.01246983f, 
    0.01702549f, -0.00817939f, -0.02702234f, -0.03631550f, -0.00557125f, -0.02479670f, 0.00433006f, 0.02334641f, 
    -0.01052640f, 0.02326393f, 0.02455783f, -0.01708553f, -0.02937474f, -0.00998292f, 0.00705519f, 0.00820438f, 
    0.00978849f, -0.01806933f, -0.04068333f, -0.01680410f, 0.02040880f, -0.01443500f, 0.00358830f, -0.02539620f, 
    -0.02311152f, 0.00172692f, 0.01018245f, 0.03092215f, -0.02935168f, 0.01426926f, -0.02562964f, 0.00329654f, 
    0.03020312f, -0.03054990f, 0.01334798f, 0.02627318f, -0.00820719f, -0.01225488f, 0.01222839f, 0.00604877f, 
    0.01406213f, -0.03252723f, -0.00112105f, -0.04286226f, -0.01331264f, -0.01922961f, -0.03889233f, -0.03011859f, 
    -0.02425911f, 0.00098336f, 0.01461706f, -0.02935417f, 0.03356463f, 0.01918556f, -0.01816447f, -0.01822547f, 
    0.00127370f, -0.01632877f, 0.00935829f, -0.03999777f, 0.00676072f, -0.01176705f, 0.02136268f, -0.00203318f, 
    0.01857871f, -0.01415185f, 0.00346231f, -0.01616917f, -0.01720287f, -0.00633322f, 0.01801546f, -0.02167570f, 
    -0.00541019f, -0.02248866f, -0.03345593f, -0.03900350f, -0.02341135f, -0.01954155f, 0.01381756f, 0.02387276f, 
    0.01639747f, -0.04081839f, 0.02853184f, 0.01329742f, -0.04010711f, -0.00544280f, -0.04267593f, 0.01886114f, 
    0.02551042f, 0.00522621f, -0.02516319f, 0.01131954f, 0.01299447f, 0.01165434f, -0.00908739f, -0.01252437f, 
    0.01166274f, -0.03853158f, 0.00961017f, -0.02044465f, -0.02775881f, 0.01543108f, 0.01800935f, 0.00645302f, 
    -0.01226551f, 0.01505160f, -0.03450067f, -0.03960652f, 0.02076251f, 0.00635259f, -0.03533202f, -0.01537372f, 
    -0.02322069f, 0.02027223f, 0.01330986f, 0.03719231f, -0.03988924f, -0.02565842f, -0.04326888f, 0.00148686f, 
    0.02491932f, -0.02313868f, 0.01564740f, -0.03723040f, 0.01409610f, 0.00709871f, 0.01251363f, 0.01469187f, 
    -0.04222276f, 0.00091076f, 0.01084426f, 0.00678387f, -0.03626693f, -0.03757048f, -0.04017534f, 0.02265204f, 
    -0.00275357f, -0.00023050f, 0.00120140f, -0.02425984f, 0.00219564f, 0.02743685f, -0.00126040f, 0.01931475f, 
    0.01098478f, -0.02348803f, 0.00300571f, -0.02241722f, 0.01023980f, -0.02140926f, 0.03397271f, 0.00260985f, 
    -0.04171598f, 0.02694662f, 0.00660144f, -0.03337818f, -0.01307938f, -0.02111934f, -0.00619455f, -0.00049153f, 
    0.01059148f, 0.01845250f, -0.03822694f, -0.00090211f, -0.04164248f, 0.01153948f, 0.01038261f, -0.02373780f, 
    -0.03927946f, 0.01695334f, 0.00966163f, -0.02976756f, 0.01753432f, -0.03095484f, 0.01846737f, -0.00039687f, 
    0.01852927f, -0.02612601f, 0.02757626f, 0.00178487f, 0.02629139f, -0.02319932f, 0.01562343f, -0.03858138f, 
    0.01706286f, -0.00264003f, -0.00307362f, 0.01478289f, 0.01784904f, -0.00706343f, -0.02529271f, -0.01864217f, 
    0.00203641f, -0.03300026f, 0.00577241f, 0.00119652f, -0.02199055f, 0.00759016f, -0.04354719f, -0.02877352f, 
    0.02453095f, 0.02640088f, 0.01756318f, 0.00128740f, 0.00563625f, -0.03374293f, 0.00565232f, 0.00728649f, 
    -0.00551870f, 0.00224914f, -0.01971770f, 0.00833495f, 0.02063221f, -0.01043953f, -0.02012397f, -0.00956168f, 
    0.02204017f, -0.02633437f, -0.02995730f, 0.02102163f, 0.02030192f, 0.02000575f, -0.04240907f, 0.01558441f, 
    0.00945600f, -0.01071203f, 0.00780670f, -0.01764381f, 0.00802521f, -0.02030168f, 0.02024432f, -0.00760870f, 
    0.00961405f, -0.03530361f, -0.02141175f, -0.02442941f, -0.02779521f, -0.00278865f, -0.03291338f, 0.01981564f, 
    -0.03913344f, -0.03779969f, -0.03304092f, -0.03382884f, 0.00046898f, 0.01253436f, 0.00648964f, 0.03026404f, 
    -0.03441484f, -0.02502720f, 0.01218588f, -0.03816384f, -0.00763744f, -0.03042776f, 0.02403592f, 0.01574643f, 
    -0.02708541f, 0.00634625f, 0.00863587f, 0.01536724f, -0.01909843f, -0.01758076f, 0.02016674f, -0.00426547f, 
    -0.01998571f, -0.00669329f, 0.01377839f, 0.02183695f, -0.03124591f, 0.02940211f, 0.02221544f, -0.00562534f, 
    0.00733810f, 0.02086801f, 0.00623371f, 0.01291640f, -0.01557910f, -0.01685268f, 0.01332933f, 0.00289462f, 
    0.02325273f, -0.03616745f, -0.04190754f, -0.03812961f, -0.02858441f, -0.02630919f, 0.01556610f, 0.00544606f, 
    -0.01110667f, -0.02986504f, -0.00636957f, -0.02494299f, 0.02553419f, 0.03155072f, -0.02844603f, 0.01061545f, 
    0.00608826f, -0.03722948f, -0.01525332f, 0.02760461f, -0.01524956f, 0.00293228f, 0.00870526f, 0.00981535f, 
    0.00448664f, -0.02823851f, 0.01313989f, -0.03192315f, -0.00606210f, -0.03273299f, 0.01697695f, -0.03367925f, 
    0.00544559f, -0.03892063f, -0.00081963f, -0.03183537f, -0.00022650f, -0.01274868f, -0.04464791f, -0.00250837f, 
    -0.00055637f, 0.01379624f, -0.00473504f, 0.01665898f, 0.02253392f, -0.00413145f, 0.01415880f, 0.00661157f, 
    0.01211272f, -0.02905616f, 0.01321920f, 0.01567085f, 0.01552572f, 0.02158638f, -0.03379778f, -0.02803906f, 
    -0.01000196f, -0.02576272f, 0.01916000f, 0.02163157f, -0.00644432f, 0.01895142f, 0.01485721f, -0.03817737f, 
    -0.02522192f, 0.00979586f, -0.02034649f, -0.00448606f, -0.02511227f, -0.00578041f, -0.01931483f, -0.02547054f, 
    -0.03512585f, -0.03312150f, 0.00287042f, 0.00348984f, -0.00058109f, -0.02476464f, 0.00871663f, 0.00956733f, 
    0.00009488f, 0.01801599f, 0.01162730f, 0.01012417f, 0.01642330f, 0.03111110f, -0.02751151f, 0.00014916f, 
    0.01503673f, -0.04264133f, 0.01788075f, -0.03056327f, -0.02455283f, -0.01295205f, 0.00139064f, -0.03259913f, 
    0.00678615f, -0.01716714f, -0.02894076f, 0.00259611f, 0.02835455f, -0.03005766f, -0.03886108f, -0.03125316f, 
    0.01950474f, -0.02739500f, -0.01964220f, -0.03540419f, -0.01572470f, -0.02319350f, -0.02046617f, -0.03573802f, 
    -0.01565165f, 0.00339616f, 0.00314769f, -0.03521184f, -0.00819659f, 0.02655008f, 0.02026001f, -0.01833849f, 
    -0.03664248f, 0.02095046f, -0.01753779f, -0.04435464f, -0.03981074f, 0.00440333f, -0.03638153f, -0.01592482f, 
    -0.01886891f, -0.03245983f, 0.03139494f, -0.02932574f, 0.02414648f, -0.01920656f, -0.01679298f, -0.01824748f, 
    0.00311891f, 0.00567078f, 0.01804148f, 0.00372815f, -0.02391146f, -0.00449342f, 0.02084002f, -0.01964274f, 
    0.01598918f, -0.00868922f, -0.00139857f, -0.01605696f, 0.00009704f, 0.02282803f, -0.03346980f, -0.00586819f, 
    -0.01958864f, 0.01076468f, -0.00408858f, -0.01172720f, 0.01217493f, -0.04203282f, -0.02910500f, -0.02533804f, 
    0.02261762f, 0.01725353f, -0.00762772f, -0.02967572f, -0.01130035f, -0.00408592f, 0.01838005f, 0.02293556f, 
    0.02309454f, -0.00181764f, 0.00395889f, -0.02607957f, -0.00713993f, -0.02629382f, -0.00220237f, -0.04111599f, 
    0.01380833f, 0.01475387f, 0.00690040f, -0.03539986f, -0.02349286f, -0.02658264f, 0.01704132f, -0.01346652f, 
    -0.03215095f, -0.03121310f, -0.02071784f, -0.01943056f, 0.02841241f, 0.02253883f, -0.02218249f, 0.01614143f, 
    -0.02720283f, -0.00227934f, -0.02163323f, -0.02788103f, -0.00074196f, -0.02891175f, -0.03226517f, -0.03344303f, 
    -0.03557751f, 0.00101307f, 0.00500413f, 0.02079120f, 0.02111768f, 0.00815794f, -0.00889839f, -0.03987572f, 
    -0.03886701f, -0.03452385f, -0.02879040f, -0.01911686f, -0.00530222f, 0.02332740f, -0.03141369f, 0.00284445f, 
    0.00511882f, 0.02891144f, -0.03872527f, 0.01450198f, -0.00140643f, 0.00452971f, -0.01195822f, 0.01393119f, 
    -0.00137526f, 0.02286093f, 0.01217942f, -0.01509546f, -0.01224581f, 0.01062815f, -0.02507238f, -0.02174169f, 
    -0.02129447f, -0.01882804f, -0.00601273f, -0.00034768f, 0.01458687f, -0.03058336f, -0.00422388f, -0.02362707f, 
    0.02963170f, -0.04060444f, -0.01179688f, -0.02334590f, 0.02248857f, -0.01009300f, 0.00637583f, 0.01644719f, 
    0.01324016f, 0.01771840f, -0.03068265f, 0.02229371f, -0.04003146f, -0.04049096f, 0.01859735f, -0.03722442f, 
    0.00865930f, -0.02718206f, -0.03443092f, -0.00710774f, 0.02690452f, 0.01089352f, 0.01691091f, 0.02586885f, 
    0.02981275f, -0.04008395f, -0.01062265f, -0.00023859f, 0.01745253f, -0.03728246f, 0.02227988f, -0.01224449f, 
    -0.03422951f, 0.00591807f, 0.00271503f, -0.01886329f, 0.02409992f, -0.00303666f, 0.02165372f, -0.00370303f, 
    0.02808155f, -0.01690545f, -0.03913760f, 0.00878690f, 0.01702130f, 0.01805686f, -0.03700839f, -0.01161782f, 
    0.01949660f, -0.03285664f, -0.04169870f, -0.04355961f, 0.03050007f, 0.02260629f, 0.00995713f, -0.03443825f, 
    0.00983874f, 0.01654725f, -0.03124532f, -0.03537852f, -0.02819457f, 0.00007126f, -0.01188367f, 0.03065092f, 
    -0.00560899f, 0.02380889f, -0.04414868f, 0.02231888f, 0.01069559f, -0.01690557f, 0.01670968f, 0.00550923f, 
    0.01025454f, -0.03127198f, -0.03999448f, -0.04043348f, 0.01283685f, 0.01401952f, -0.04180657f, 0.00913768f, 
    0.01589053f, 0.02613539f, 0.01165480f, 0.02794108f, -0.02210121f, 0.01311459f, 0.01959174f, 0.00985993f, 
    -0.01637094f, 0.01212433f, -0.03095703f, -0.01378115f, -0.03922619f, 0.03200807f, -0.01369651f, 0.00242254f, 
    -0.02828788f, -0.02773091f, 0.00624351f, -0.03504793f, -0.00178560f, -0.01037789f, -0.01739661f, 0.01826796f, 
    0.03119640f, -0.03005679f, 0.02734919f, -0.01633216f, -0.03066566f, 0.02747290f, -0.01798491f, -0.01077322f, 
    -0.03033580f, -0.02317393f, 0.02493533f, -0.02613206f, 0.02570771f, 0.02294445f, -0.00073127f, -0.01651241f, 
    -0.02456967f, 0.01319017f, -0.02196887f, -0.00695177f, -0.02597291f, -0.02676333f, -0.00204087f, -0.02125636f, 
    0.02498440f, -0.02629914f, 0.00174881f, -0.03389447f, -0.02052581f, -0.03104719f, 0.01374380f, -0.04237356f, 
    -0.03094655f, 0.01923059f, 0.00311427f, -0.00188703f, 0.00916853f, -0.01484780f, 0.01290019f, -0.01367905f, 
    0.04130102f, 0.02112080f, 0.00415696f, 0.00035582f, 0.01104189f, -0.01672908f, 0.02060715f, 0.02109074f, 
    0.00980777f, -0.02652111f, 0.02349054f, 0.00375157f, -0.02062128f, -0.03355353f, -0.00688302f, -0.01552971f, 
    -0.01475789f, -0.03707224f, -0.02662590f, -0.02124074f, -0.04280180f, -0.04044482f, 0.01760812f, -0.00432369f, 
    -0.01639837f, 0.00724249f, 0.01476797f, 0.00396497f, 0.01768234f, -0.03786798f, -0.02728957f, 0.00851054f, 
    -0.00437819f, -0.01893809f, 0.00547271f, -0.03682749f, 0.01687463f, 0.02014116f, -0.02102835f, -0.03914071f, 
    0.00514427f, 0.00472923f, 0.01939648f, -0.03044431f, -0.03280669f, 0.02335992f, 0.00194329f, -0.00921628f, 
    -0.01695363f, -0.01276704f, -0.00598122f, -0.00245486f, -0.03564298f, -0.00209865f, -0.02028341f, -0.01142674f, 
    0.02461768f, -0.03729032f, -0.01984737f, -0.02624348f, -0.03235178f, 0.00868552f, -0.00823294f, -0.03027846f, 
    -0.00386551f, 0.01385463f, -0.00137681f, -0.02268231f, -0.02781476f, -0.03374188f, -0.01883434f, -0.04002072f, 
    -0.01386859f, -0.00100197f, -0.04228700f, 0.02909868f, 0.03235350f, -0.01822904f, 0.01642059f, -0.01849788f, 
    -0.00726515f, -0.01119335f, -0.02175462f, -0.00429395f, -0.00353326f, -0.01738411f, -0.00072244f, -0.02697602f, 
    -0.02909981f, -0.03193882f, 0.01690651f, 0.01593835f, -0.01991626f, 0.02892175f, -0.02281928f, -0.00304692f, 
    -0.03570952f, 0.01212880f, -0.02958019f, -0.00562877f, -0.01878635f, -0.04437875f, -0.01218059f, -0.02045916f, 
    0.03085410f, -0.01585830f, 0.00838658f, 0.02670908f, 0.01519179f, 0.03539218f, -0.01949332f, -0.00916926f, 
    -0.04105755f, -0.02033577f, -0.01876726f, 0.00708297f, 0.03089279f, 0.01670002f, 0.00290603f, 0.02738695f, 
    -0.03125494f, -0.00797681f, 0.00928764f, -0.01959003f, 0.01451391f, -0.04660960f, -0.03621222f, -0.02086339f, 
    -0.03660790f, -0.01499632f, -0.03173276f, 0.00727862f, -0.03893908f, -0.02845730f, -0.04282414f, 0.02008104f, 
    0.02313095f, -0.03556400f, -0.00240994f, -0.01065155f, 0.01982088f, 0.01308792f, -0.02533066f, -0.00092014f, 
    -0.04136226f, -0.04118964f, -0.03959826f, -0.01297040f, -0.00586612f, -0.01880930f, 0.00145038f, -0.02396134f, 
    0.01301859f, -0.00431147f, 0.00395623f, -0.00630940f, 0.01800203f, -0.00213384f, 0.01922727f, -0.00786251f, 
    -0.03497723f, -0.01051190f, 0.00713633f, -0.02847446f, -0.00820842f, -0.04341330f, -0.03388904f, -0.00359756f, 
    0.00281568f, -0.00711390f, -0.01833092f, 0.01603909f, -0.01619617f, -0.03954731f, 0.02348003f, -0.03510476f, 
    0.02395012f, 0.02412591f, -0.01240775f, 0.00595562f, 0.02301650f, -0.00002468f, -0.02566881f, 0.00070256f, 
    -0.03558198f, -0.01127347f, -0.01069771f, 0.00447486f, -0.02131558f, -0.02617261f, -0.01862627f, -0.02895718f, 
    0.01248773f, 0.01865097f, -0.03603573f, 0.00755586f, 0.01055149f, -0.00759802f, 0.00933247f, 0.02777471f, 
    0.01110266f, -0.01344794f, 0.01508172f, 0.01144301f, -0.00848319f, -0.03211849f, -0.03303179f, -0.00168885f, 
    -0.03315366f, 0.00623393f, -0.02046247f, 0.00793768f, -0.03322935f, 0.02250535f, -0.01060602f, 0.00728609f, 
    -0.01322167f, -0.02680196f, -0.01974119f, 0.02261659f, 0.00721180f, 0.01125890f, -0.02042266f, -0.03607388f, 
    0.00865644f, -0.00124412f, 0.01911635f, 0.01965621f, -0.03494192f, -0.02939676f, -0.03066213f, 0.01087070f, 
    0.00479753f, -0.02111802f, -0.01693697f, 0.00589282f, 0.02223463f, -0.02442704f, 0.02126888f, -0.03634840f, 
    -0.00717102f, 0.03985015f, -0.04691726f, -0.01863090f, 0.00135781f, -0.02717386f, -0.01559607f, 0.01982691f, 
    0.02807911f, -0.03365281f, -0.01777221f, -0.03605513f, -0.00067603f, 0.00116358f, 0.02247098f, -0.00968116f, 
    0.01286303f, -0.03030801f, -0.00733287f, -0.04077924f, -0.00468778f, 0.01614869f, 0.00737632f, -0.02355568f, 
    -0.03957837f, -0.00642897f, 0.02954214f, 0.00244923f, 0.02014480f, 0.00625397f, -0.02499254f, -0.00746126f, 
    0.00139438f, 0.01149427f, 0.02761950f, -0.02800892f, -0.02484449f, -0.01168434f, 0.02036862f, -0.03474689f, 
    0.02983420f, 0.01256812f, -0.02229518f, -0.02728407f, -0.03839141f, 0.00945263f, -0.03065506f, -0.00934759f, 
    -0.03201919f, -0.02773376f, -0.01051533f, -0.02604364f, -0.01550149f, -0.03066747f, 0.00863301f, -0.03802436f, 
    -0.03121914f, 0.00736415f, 0.00269619f, -0.02892466f, -0.02198601f, 0.01665436f, -0.02203922f, 0.01113339f, 
    0.00001305f, -0.01236484f, -0.00045326f, -0.00524722f, -0.01796469f, -0.01321194f, -0.01515440f, -0.01246226f, 
    -0.01023583f, -0.02949418f, -0.04049575f, 0.01167260f, -0.03007193f, 0.00076729f, 0.01362174f, 0.00755838f, 
    0.00079297f, -0.03993381f, -0.03667375f, -0.03263481f, -0.01125898f, -0.03484526f, -0.03458150f, -0.01459409f, 
    0.01192423f, -0.00089106f, -0.01731688f, -0.02699116f, -0.04009141f, -0.02600105f, 0.00194031f, 0.02998978f, 
    -0.02900822f, -0.00115997f, 0.01052282f, -0.00676754f, -0.01424283f, 0.02981420f, -0.02377573f, -0.03464052f, 
    0.01287123f, -0.00026061f, 0.01230961f, -0.02949058f, -0.00684274f, 0.02418193f, 0.02643061f, -0.03668677f, 
    -0.04120136f, 0.01066338f, -0.02970427f, 0.02963570f, 0.01505000f, -0.02300420f, -0.02049056f, -0.03707483f, 
    0.02957861f, 0.02935604f, 0.02304615f, -0.00014922f, 0.00719978f, -0.01673362f, -0.01044399f, 0.00170142f, 
    -0.01187380f, 0.02814724f, 0.00062072f, -0.02097039f, -0.00850205f, -0.02459978f, 0.00847965f, -0.02382605f, 
    -0.02170622f, -0.03824066f, -0.03961082f, -0.00198538f, 0.02803048f, 0.00623272f, -0.00548163f, 0.00097598f, 
    0.02009368f, 0.00526725f, -0.01957853f, -0.01702281f, -0.02387901f, -0.03544459f, 0.01005955f, 0.02623835f, 
    -0.01911418f, -0.00440516f, 0.00084207f, 0.01640350f, -0.00070365f, -0.03515219f, -0.01263826f, 0.00536659f, 
    0.00953943f, -0.03272513f, 0.01290662f, 0.01550141f, 0.01786792f, 0.02164706f, -0.00896677f, 0.00541303f, 
    0.01317735f, -0.00773453f, -0.01754152f, 0.00098002f, -0.00651678f, 0.02462332f, 0.02611934f, 0.01306421f, 
    -0.01820807f, -0.01349020f, 0.00249919f, 0.02514737f, 0.00586259f, -0.03595024f, -0.00206620f, -0.04052515f, 
    -0.00239390f, 0.01652992f, -0.00824117f, -0.03253658f, 0.02336699f, 0.00405654f, 0.02905732f, 0.00462883f, 
    0.00045395f, -0.01125279f, 0.01007985f, -0.03490090f, 0.00058204f, -0.03142744f, -0.00501492f, 0.01356459f, 
    -0.02825243f, -0.03829215f, 0.00159461f, 0.02123638f, -0.03265998f, 0.02097644f, 0.00196203f, -0.02124200f, 
    -0.03430226f, 0.02201590f, 0.01880304f, 0.00945602f, -0.01817537f, 0.01227970f, -0.01298425f, -0.02964208f, 
    0.00038329f, -0.02198717f, -0.02661066f, -0.02704647f, 0.00564428f, -0.03175391f, 0.02288501f, -0.00097768f, 
    -0.03576210f, -0.00507553f, 0.00281183f, 0.01050089f, -0.03037349f, 0.02742940f, -0.00417187f, -0.00605648f, 
    -0.01004344f, -0.00236811f, -0.03516839f, 0.02979025f, 0.00287520f, 0.01205680f, 0.01163472f, 0.02084704f, 
    -0.02258524f, -0.01515457f, -0.00561585f, 0.03059920f, -0.04115429f, 0.00336200f, -0.03128446f, -0.01038939f, 
    0.00694579f, 0.02547145f, -0.01759112f, -0.03469362f, -0.00981010f, 0.00817662f, -0.03499670f, -0.01485280f, 
    -0.02414810f, -0.04109269f, -0.01128624f, 0.02890886f, -0.02303711f, -0.00088016f, 0.00033556f, 0.00737592f, 
    -0.00566419f, -0.03078360f, -0.00619754f, -0.02455707f, 0.02537771f, 0.00175762f, -0.02323974f, -0.00750083f, 
    -0.02600078f, -0.00762648f, -0.02084729f, -0.02513186f, -0.00188131f, 0.01225539f, -0.00916520f, -0.00528565f, 
    0.03058296f, 0.00900718f, 0.02901838f, -0.01775390f, 0.02821708f, 0.00757325f, 0.01151386f, -0.02308975f, 
    -0.00640322f, -0.01566152f, -0.01497211f, 0.02117197f, -0.02973140f, -0.03071032f, 0.02681641f, 0.01597244f, 
    -0.02260994f, -0.02677067f, 0.02622272f, -0.02201504f, 0.02977051f, 0.01623787f, -0.02594115f, -0.01222251f, 
    0.01532662f, -0.02802330f, 0.02062813f, -0.03822745f, 0.01989165f, -0.00858234f, -0.01860593f, -0.01447739f, 
    0.02661991f, -0.00709810f, -0.02545412f, 0.02461974f, -0.00595168f, -0.02379052f, 0.01013290f, 0.01519486f, 
    -0.01283720f, 0.00471267f, 0.00016789f, -0.00914255f, -0.03508204f, -0.03978451f, -0.00362934f, -0.01011683f, 
    -0.03023934f, -0.03106697f, -0.02533620f, -0.03375750f, -0.03218026f, -0.04008368f, 0.02754231f, -0.02354368f, 
    -0.02985143f, -0.01711482f, 0.00219232f, 0.01075045f, 0.01001463f, 0.02051795f, -0.01771675f, -0.00323881f, 
    -0.00968794f, 0.02794680f, 0.00776809f, 0.02938355f, -0.01375420f, 0.00199909f, -0.03758938f, 0.02058408f, 
    -0.03636082f, -0.01854778f, 0.00832573f, -0.01861133f, 0.02546436f, -0.01885777f, -0.00180237f, -0.01192173f, 
    0.02252646f, 0.00326991f, -0.00816620f, -0.04104932f, -0.04012144f, -0.00927461f, 0.00482561f, -0.01924341f, 
    -0.01508470f, 0.02373482f, -0.02234237f, -0.02278474f, 0.00676849f, 0.01102750f, 0.02448871f, -0.03300013f, 
    0.00053698f, -0.00626764f, 0.02055291f, -0.02093349f, -0.03611011f, -0.00946893f, -0.00845945f, 0.00529391f, 
    -0.03660817f, 0.00991675f, -0.00754680f, -0.02755028f, -0.03494876f, -0.01819997f, -0.02487261f, -0.02068194f, 
    -0.01628583f, -0.04067308f, -0.00133744f, -0.02832555f, -0.00643057f, -0.00497182f, -0.03364133f, -0.02336826f, 
    0.00369639f, -0.01694267f, -0.00455646f, 0.00689011f, 0.00136529f, 0.00357581f, -0.00952774f, -0.00031758f, 
    -0.02443571f, -0.01003657f, -0.01837184f, -0.01821008f, -0.04072933f, -0.02628849f, -0.04048260f, -0.03018714f, 
    -0.01307757f, -0.00856005f, -0.00894442f, 0.02634336f, -0.01902241f, -0.02194458f, -0.01531452f, -0.03180579f, 
    -0.00585349f, -0.02028354f, 0.01566433f, -0.01865224f, 0.00582154f, -0.00113239f, 0.02487243f, 0.02831244f, 
    -0.03098820f, -0.01601528f, -0.03642170f, 0.02601794f, 0.01405711f, -0.00524135f, -0.03225451f, -0.01906928f, 
    0.02491863f, -0.00069903f, 0.02069302f, -0.01795752f, 0.00224179f, -0.03789389f, 0.00006272f, -0.01843465f, 
    0.00561930f, 0.02205819f, -0.00994017f, -0.03148885f, 0.02189613f, 0.00827094f, -0.00360248f, -0.01420822f, 
    0.01117438f, 0.01093114f, -0.02420731f, -0.01577838f, -0.01465988f, 0.02450709f, -0.01568785f, -0.03409880f, 
    -0.00106841f, 0.02454301f, -0.02540304f, -0.01233815f, -0.01647077f, -0.02739027f, 0.01720268f, 0.00224435f, 
    -0.00576513f, -0.02589772f, -0.03464969f, -0.02568532f, -0.01435568f, -0.03929697f, 0.01220901f, -0.00678098f, 
    -0.03736323f, -0.01327776f, -0.04052460f, -0.00212543f, 0.01852870f, 0.00837453f, -0.03907342f, 0.00361182f, 
    -0.02528991f, 0.00444737f, -0.03802183f, -0.03401368f, 0.00760336f, 0.01624043f, -0.03628249f, -0.02259433f, 
    0.00295174f, -0.00080700f, -0.02956812f, 0.00551356f, 0.00175399f, -0.01762361f, 0.01788360f, 0.01764601f, 
    -0.00973043f, 0.00770180f, 0.01461655f, -0.02056060f, -0.00121987f, -0.01147023f, 0.01302203f, 0.01074155f, 
    -0.00868550f, -0.00909287f, 0.01998860f, -0.00499332f, -0.03294062f, -0.02615712f, -0.03487338f, -0.01213960f, 
    -0.00724443f, -0.00981582f, -0.01529279f, 0.02907628f, 0.00877722f, 0.02115242f, -0.01518483f, -0.03090416f, 
    0.02677214f, -0.02591645f, -0.00508339f, -0.01778604f, -0.02147808f, -0.01123330f, 0.01199078f, -0.01322016f, 
    0.00311567f, 0.01708848f, -0.01638483f, -0.01125977f, 0.01070083f, -0.01257948f, -0.03975169f, -0.02176107f, 
    0.02288254f, 0.00096739f, -0.02688326f, -0.03617299f, -0.00260007f, 0.02546747f, 0.01634100f, -0.02133204f, 
    -0.00755583f, 0.02663316f, 0.02669916f, 0.02130552f, 0.01981716f, -0.02199385f, -0.03270771f, -0.00717616f, 
    -0.00041849f, -0.02003980f, -0.00848801f, -0.01433046f, -0.04043617f, -0.03012004f, -0.01812285f, 0.00524576f, 
    -0.02462932f, -0.01900908f, -0.01844401f, -0.03346590f, 0.02224042f, -0.01588711f, -0.00654063f, -0.03810603f, 
    -0.01292662f, -0.00236494f, -0.03396778f, -0.00407438f, -0.02624961f, 0.02578279f, -0.02726761f, 0.00718495f, 
    -0.03694065f, 0.02673444f, -0.02011005f, -0.00763369f, -0.01765230f, -0.02126949f, -0.02003008f, 0.00094089f, 
    -0.01406335f, 0.02731208f, -0.02604809f, -0.02301206f, 0.01006977f, -0.02070403f, -0.02490541f, -0.00616224f, 
    -0.00916097f, -0.02604407f, -0.03697794f, -0.03536553f, 0.02429840f, -0.03232120f, 0.02285646f, 0.00973966f, 
    0.02864648f, -0.02424582f, -0.01601671f, -0.02229664f, -0.01243212f, -0.00748714f, -0.00259040f, 0.02523099f, 
    -0.00188312f, 0.02198781f, -0.00392798f, 0.01495229f, -0.01199300f, -0.03606432f, 0.01978230f, 0.01942201f, 
    -0.03007563f, -0.02732556f, 0.01480005f, -0.01228460f, 0.00616447f, -0.03880379f, -0.03492149f, 0.00248627f, 
    0.00872026f, -0.02057612f, 0.00888206f, -0.00109683f, 0.02990822f, -0.02802498f, 0.00096756f, 0.02297890f, 
    -0.01816481f, -0.03477160f, -0.00929568f, -0.01985207f, 0.02364601f, -0.04049066f, -0.03755719f, 0.01565614f, 
    -0.01208788f, -0.00361579f, -0.00735175f, -0.01854803f, -0.01372017f, -0.00359487f, -0.00563797f, 0.01344343f, 
    0.00676822f, 0.01950563f, -0.02725876f, 0.00073487f, -0.00574387f, 0.01713816f, -0.01807701f, -0.00883226f, 
    0.00438326f, -0.02824811f, 0.02999316f, -0.03317661f, -0.00458435f, 0.01389280f, -0.03343310f, -0.01291985f, 
    0.00652100f, -0.03002569f, 0.01190711f, 0.02091959f, -0.01315814f, 0.00243026f, -0.00833194f, 0.01209860f, 
    -0.00321148f, -0.03643861f, 0.01465860f, 0.01410593f, 0.02939815f, -0.00419419f, 0.02774003f, 0.00620413f, 
    -0.03382722f, -0.02625011f, 0.02018404f, -0.03142082f, 0.02522096f, -0.01669975f, 0.00424180f, 0.01882645f, 
    0.02104929f, 0.02175946f, 0.01780262f, -0.00163684f, -0.00186286f, 0.01661046f, -0.02512795f, 0.00030015f, 
    0.02752491f, -0.03938459f, 0.00999616f, -0.01302790f, -0.02197502f, -0.01418849f, 0.02798812f, 0.02626158f, 
    -0.02991859f, -0.00981082f, -0.01673909f, -0.03852598f, -0.01692597f, -0.02270823f, 0.01744711f, 0.03016331f, 
    -0.02648938f, 0.00070961f, -0.03236192f, -0.01643783f, -0.02057355f, -0.00349393f, -0.03746598f, 0.00133587f, 
    -0.01563067f, -0.00167072f, -0.00113271f, -0.00792678f, 0.01536298f, -0.01799620f, -0.01756189f, -0.02925763f, 
    0.01850891f, -0.00052271f, -0.02050621f, 0.02535818f, 0.00167968f, 0.00170531f, -0.01547412f, -0.00440127f, 
    -0.00709032f, 0.02724752f, 0.00332653f, 0.00387933f, -0.00687992f, -0.01374584f, -0.02591300f, 0.01142778f, 
    0.01673948f, 0.02792947f, -0.02067911f, -0.02413910f, -0.02382217f, 0.01657460f, 0.01659101f, -0.01115087f, 
    0.01561629f, 0.01505823f, -0.00987656f, 0.02346505f, 0.02209195f, -0.02195739f, -0.02315331f, -0.00773009f, 
    -0.03146387f, -0.03280977f, -0.02314394f, 0.02275175f, -0.03633751f, 0.02150862f, -0.01848884f, -0.03351536f, 
    0.01246622f, 0.00446133f, 0.01021578f, -0.02758538f, -0.02212999f, 0.01601183f, -0.04117659f, -0.00665664f, 
    -0.01146112f, 0.02271177f, -0.00574255f, -0.01192490f, -0.03216388f, 0.00884493f, 0.01944350f, 0.02590074f, 
    0.06418296f, 0.15977532f, 0.10945280f, 0.07590551f, 0.01630727f, -0.00370528f, -0.04238449f, -0.05158545f, 
    -0.07278512f, -0.01132522f, 0.04401715f, 0.10064847f, 0.22694615f, 0.28899297f, 0.18624254f, -0.05518705f, 
    0.14206843f, 0.09295759f, 0.05082620f, -0.03564568f, -0.05663331f, -0.06844017f, -0.08717558f, 0.00302757f, 
    -0.03888091f, -0.03508784f, 0.16476420f, 0.07699755f, -0.03457193f, -0.03796686f, 0.05975880f, -0.01454096f, 
    -0.01232654f, 0.10896271f, 0.05282487f, 0.12848805f, 0.05961217f, 0.06647876f, -0.16008805f, 0.07362954f, 
    0.06671438f, 0.03164976f, 0.07213146f, 0.03323282f, 0.00584319f, 0.04345020f, -0.02093661f, 0.01843616f, 
    -0.03065724f, -0.06434534f, -0.02704919f, 0.05499941f, -0.03838130f, 0.04156038f, -0.08107265f, 0.12890638f, 
    -0.05918409f, -0.07997407f, -0.02086996f, -0.07439366f, -0.16437855f, 0.07858349f, 0.01096537f, -0.04134803f, 
    0.01690391f, -0.11206825f, 0.04636956f, 0.05143403f, -0.12914357f, -0.00985826f, -0.03823101f, 0.07357138f, 
    -0.14297050f, 0.07692978f, 0.05889405f, -0.03576640f, 0.05620986f, 0.07735851f, -0.06602564f, 0.02349047f, 
    0.00460120f, 0.00817564f, 0.05713240f, 0.10414107f, 0.31201926f, 0.15395917f, 0.20430331f, -0.03199317f, 
    -0.01057066f, 0.03340044f, -0.02085778f, -0.00298698f, -0.05880295f, -0.11337201f, -0.08097927f, -0.01869992f, 
    0.09605379f, 0.12713407f, 0.11108430f, -0.11806145f, 0.04173313f, 0.03918872f, 0.10965408f, 0.04274464f, 
    0.03185258f, -0.00676972f, -0.01468316f, -0.01108514f, 0.21996206f, 0.24528874f, 0.01936403f, 0.08844138f, 
    -0.06036437f, 0.05091886f, 0.09080305f, 0.07021022f, 0.00953355f, 0.00945990f, 0.11083729f, -0.16069101f, 
    0.04996756f, 0.13049617f, 0.07342890f, 0.04624198f, -0.00824658f, 0.02555287f, -0.04573669f, -0.03142342f, 
    0.02180543f, -0.11673536f, 0.00047605f, -0.09452470f, 0.14712931f, 0.15217929f, 0.04766870f, 0.03906249f, 
    -0.02693305f, 0.05044030f, -0.05258133f, 0.06244950f, -0.11438919f, -0.05966059f, -0.05485224f, 0.01352491f, 
    -0.10044540f, -0.21487778f, -0.25693405f, -0.04297094f, 0.01615930f, 0.00109209f, -0.04740138f, 0.04720394f, 
    0.01438783f, -0.02818710f, 0.07032517f, 0.07549631f, 0.22689657f, 0.28020245f, 0.14628591f, 0.03375477f, 
    0.01849866f, 0.01909344f, 0.02559802f, 0.07195760f, -0.05521116f, 0.00933768f, 0.08601850f, 0.04356716f, 
    -0.00553868f, 0.08095723f, 0.11864801f, 0.01980980f, 0.06947595f, -0.07056124f, 0.10927939f, 0.04346611f, 
    -0.02679750f, -0.03749697f, 0.00235823f, 0.03752736f, 0.03749146f, 0.01699588f, -0.01498629f, 0.00455112f, 
    -0.00213241f, 0.01248674f, 0.08900108f, 0.04298627f, 0.15556115f, 0.05965842f, 0.14608720f, 0.12045630f, 
    -0.33438206f, -0.03982905f, -0.03229121f, 0.01736576f, 0.07517524f, 0.09797549f, -0.05995449f, 0.13794586f, 
    -0.03206073f, 0.03633490f, 0.07559405f, -0.08420184f, 0.13665281f, 0.12558801f, 0.09711061f, 0.07109646f, 
    0.02475413f, 0.12115321f, 0.02937862f, 0.04563368f, -0.03363655f, -0.07546026f, -0.01700161f, 0.00721558f, 
    -0.17452668f, -0.13376234f, 0.00820148f, -0.04418476f, 0.14474519f, 0.00058181f, -0.03975610f, 0.12576042f, 
    0.11429108f, 0.19509202f, 0.06334132f, 0.16392668f, 0.15886152f, -0.34577140f, -0.10129634f, 0.06328677f, 
    -0.05142492f, 0.01914573f, 0.06842482f, -0.01841951f, 0.05006712f, 0.13401370f, 0.13126412f, 0.26300395f, 
    0.08603557f, -0.10508330f, 0.01322643f, 0.08757947f, 0.06117161f, 0.00056138f, 0.03861516f, -0.12171438f, 
    -0.06894569f, 0.06564870f, -0.02243406f, -0.08263773f, -0.07869764f, 0.07833948f, 0.01963837f, -0.08799481f, 
    -0.02342740f, -0.03333608f, 0.06011308f, -0.00323670f, 0.00198029f, -0.03668981f, -0.07411292f, -0.14858326f, 
    -0.06687620f, 0.03166886f, -0.07209760f, 0.12280158f, 0.11567008f, 0.04809917f, 0.00962104f, 0.01200246f, 
    -0.05154044f, 0.03234332f, -0.04610245f, 0.02813795f, -0.10850251f, -0.06655170f, 0.00420580f, 0.02220483f, 
    -0.05486846f, -0.00391235f, 0.05738619f, -0.06533326f, 0.00366095f, 0.17356628f, 0.21063572f, 0.08996674f, 
    0.21731751f, 0.18329607f, 0.17948492f, 0.04580145f, -0.00019417f, 0.07240032f, 0.11962078f, 0.05179257f, 
    0.07451501f, 0.06133982f, 0.16419493f, 0.12357547f, 0.07023223f, 0.07707123f, -0.12873682f, -0.03215965f, 
    0.10334418f, -0.01799714f, -0.06148487f, 0.13612820f, 0.06337266f, 0.10448753f, -0.02577916f, 0.14458981f, 
    0.17373440f, 0.23365265f, 0.08404425f, 0.08517846f, -0.12429284f, -0.00036059f, -0.05052665f, 0.13126288f, 
    -0.07753472f, -0.07361047f, 0.06879148f, 0.04434073f, -0.06967361f, -0.02179865f, -0.00002962f, 0.02069318f, 
    0.02347381f, 0.07346346f, -0.04649735f, 0.10796280f, 0.05293482f, 0.03480454f, 0.12219563f, 0.08153249f, 
    0.30619639f, 0.23922552f, 0.22302094f, 0.20590258f, 0.02768867f, 0.04588578f, 0.02010448f, 0.01258644f, 
    -0.03768485f, -0.03545285f, 0.01869273f, -0.07380860f, -0.05681875f, 0.03924247f, 0.01241762f, 0.10531691f, 
    -0.01124444f, 0.10569090f, 0.22423126f, -0.00155374f, 0.10191909f, 0.03390556f, 0.08068569f, 0.03310798f, 
    -0.12150265f, -0.03140415f, -0.10297834f, 0.11485934f, 0.02830869f, -0.10107731f, 0.00342413f, -0.05316932f, 
    0.03221464f, 0.01814899f, 0.00415418f, 0.14607474f, -0.20670898f, -0.12903102f, 0.09542647f, -0.08453428f, 
    0.06897409f, 0.08621112f, -0.05558443f, -0.03664656f, 0.01505807f, -0.01297699f, 0.01880758f, 0.08371200f, 
    -0.17472927f, 0.11566947f, -0.02177091f, -0.09262058f, 0.09850131f, -0.09899762f, 0.01339581f, -0.05614141f, 
    0.03915929f, -0.09410939f, -0.01236064f, -0.09665471f, -0.04368358f, 0.04666601f, 0.08129030f, -0.08739317f, 
    0.03129219f, 0.08407475f, 0.05674247f, -0.05893769f, 0.05095344f, -0.06339148f, 0.17703597f, -0.02075716f, 
    0.28884518f, 0.32561973f, 0.16443965f, 0.32387626f, 0.04698687f, 0.05616140f, 0.12502581f, 0.05337714f, 
    -0.03662414f, 0.03250754f, 0.03880933f, -0.04311784f, 0.34063637f, 0.12614040f, 0.11289656f, 0.05535224f, 
    -0.00734209f, 0.14967829f, 0.07881376f, -0.06979267f, -0.04521323f, -0.04652884f, 0.04234554f, -0.11442657f, 
    -0.23835015f, -0.21279259f, -0.05393639f, -0.19201119f, -0.01205635f, 0.00269756f, -0.00437329f, 0.02921136f, 
    0.08858766f, 0.00757397f, -0.09654840f, 0.07688116f, -0.00168948f, -0.18919851f, 0.04423991f, -0.03504837f, 
    0.05746856f, 0.04546745f, 0.01646602f, -0.03602068f, 0.08574866f, 0.10961859f, 0.00457037f, 0.00570566f, 
    0.03848155f, -0.04051767f, -0.06126568f, -0.10735542f, -0.00949192f, 0.06481317f, 0.04257079f, 0.11332727f, 
    0.01271449f, 0.03887500f, 0.04167317f, 0.06857765f, 0.13899767f, 0.11749404f, 0.02357527f, -0.15141122f, 
    0.01952154f, 0.00653484f, 0.05222288f, -0.10203476f, -0.09275538f, -0.12997340f, -0.02477929f, -0.02628754f, 
    -0.02941464f, 0.07577271f, 0.11219797f, 0.14606506f, 0.07982819f, -0.04914656f, 0.01105751f, 0.05529146f, 
    -0.00166037f, 0.10994525f, 0.09800841f, 0.10891549f, -0.09087996f, -0.17932138f, -0.01968651f, 0.05234427f, 
    0.00872690f, -0.01457001f, 0.01025487f, -0.07735121f, 0.13745017f, 0.08665298f, 0.04623710f, -0.05816392f, 
    0.11116515f, 0.03256342f, 0.09253123f, 0.03582074f, 0.02439898f, -0.00579615f, 0.04776102f, 0.05801267f, 
    -0.05803718f, 0.11251101f, 0.16524953f, 0.04838073f, -0.10700474f, -0.06411617f, -0.14315949f, 0.02590801f, 
    0.06484896f, -0.02100722f, 0.06796655f, -0.05337780f, 0.02325611f, 0.10761445f, 0.04914322f, 0.06330729f, 
    0.10289609f, -0.15002599f, -0.14102395f, 0.05344199f, -0.02567238f, 0.03239772f, 0.14192645f, 0.02802004f, 
    0.10918555f, -0.16193992f, 0.00107859f, 0.00960787f, -0.05634573f, -0.16929494f, -0.06836772f, -0.04656711f, 
    0.00515963f, 0.05943843f, 0.00101446f, -0.04808578f, 0.09556789f, 0.03121922f, -0.03459595f, 0.01138263f, 
    0.23958509f, 0.18293844f, 0.26962462f, 0.16115932f, -0.11737239f, 0.05413981f, 0.14222169f, 0.04830278f, 
    0.10980768f, 0.06858157f, 0.02890123f, 0.10838804f, -0.11551615f, -0.10634816f, -0.04731058f, -0.10096525f, 
    -0.02228150f, -0.05008191f, 0.02312145f, 0.05853188f, -0.03158393f, -0.01475475f, 0.04703661f, -0.00132643f, 
    0.14084999f, 0.01538780f, 0.11728506f, -0.06344037f, -0.00748942f, 0.03214702f, -0.06650505f, -0.00075864f, 
    -0.00798554f, 0.13569485f, 0.04630916f, 0.09750879f, 0.23079418f, -0.10120794f, 0.18414253f, 0.14323132f, 
    -0.10323113f, 0.07498119f, 0.19088949f, -0.01019817f, -0.01880459f, -0.02986120f, 0.01699358f, -0.07966898f, 
    -0.02973323f, -0.06896188f, -0.07149850f, -0.09466679f, -0.12831464f, -0.07018020f, 0.00469090f, -0.07048259f, 
    0.05175338f, -0.04379939f, 0.07366619f, 0.05188266f, -0.13649002f, -0.10730189f, -0.08700459f, -0.04808929f, 
    0.06985290f, 0.00471315f, 0.04991604f, 0.03649398f, -0.11428276f, 0.09268492f, 0.15168998f, 0.12159411f, 
    -0.14039601f, -0.10751525f, -0.11883038f, -0.08755867f, 0.07225601f, 0.01873276f, -0.02311858f, 0.03708134f, 
    -0.01592221f, -0.01481928f, 0.00765691f, 0.03359403f, 0.04242880f, 0.05253076f, 0.15402198f, -0.15700538f, 
    0.01587525f, -0.08281585f, 0.05035899f, -0.02217643f, 0.00560889f, 0.01913706f, -0.04360193f, 0.11606833f, 
    -0.05275254f, -0.03271969f, 0.03055625f, -0.13846186f, 0.03847686f, -0.05946933f, -0.05649611f, 0.00488225f, 
    0.10281469f, 0.08376840f, 0.07339755f, 0.08114201f, 0.22984178f, 0.28441554f, 0.07911798f, 0.10653403f, 
    0.02568624f, -0.02044112f, 0.02818551f, -0.04753798f, -0.08197670f, 0.01786010f, -0.08412948f, -0.03718576f, 
    -0.16015211f, -0.21349843f, -0.02239472f, -0.25843236f, -0.01242103f, 0.06053091f, 0.01258318f, -0.01832958f, 
    0.02536797f, 0.00732595f, -0.02689430f, 0.05172685f, -0.12734528f, -0.05378165f, 0.10023003f, -0.00840662f, 
    0.03700411f, 0.03367067f, 0.09810487f, -0.05133988f, 0.09081674f, -0.00220136f, -0.03562338f, -0.15858297f, 
    0.27196345f, -0.05198149f, 0.00395425f, 0.05144807f, -0.01933186f, 0.03940675f, -0.04710242f, 0.16408703f, 
    -0.07861811f, -0.00531138f, -0.01489308f, -0.03797574f, 0.04821176f, -0.14049612f, -0.11859663f, -0.09797736f, 
    -0.07405769f, -0.00405687f, -0.05993938f, 0.11238393f, -0.05777036f, -0.04309135f, 0.03746138f, 0.10443530f, 
    -0.18787743f, -0.20832923f, -0.14078717f, 0.06078554f, 0.01448652f, 0.02790990f, 0.03772853f, 0.08987663f, 
    0.10939194f, 0.00476314f, 0.03126318f, 0.03457376f, -0.26858428f, -0.09822603f, 0.02682709f, -0.12746893f, 
    0.08119234f, 0.01352033f, 0.00630974f, -0.01829699f, 0.13518044f, 0.15100992f, 0.05024678f, 0.04065124f, 
    0.14476964f, -0.03174178f, 0.01711861f, 0.16527948f, 0.14858229f, -0.04362407f, 0.05758186f, 0.03940355f, 
    -0.04376308f, 0.07276361f, -0.07722881f, 0.05120875f, 0.11173207f, -0.04578828f, 0.15590623f, -0.04972045f, 
    -0.06870963f, -0.05664081f, 0.10147804f, 0.06067676f, -0.06891348f, -0.07322653f, 0.03216222f, 0.13940299f, 
    0.00820873f, 0.01252688f, 0.00999075f, 0.01615384f, 0.01030346f, -0.03307728f, -0.00705700f, -0.01195048f, 
    0.01988972f, -0.03492776f, -0.00555704f, -0.03629521f, 0.01009009f, 0.00561136f, -0.03724776f, -0.00099106f, 
    -0.04140969f, 0.02139839f, -0.00106081f, -0.03530079f, 0.01570096f, 0.01187135f, -0.02378782f, 0.00365763f, 
    0.00419087f, -0.01728211f, -0.04111006f, 0.00436474f, -0.02758166f, -0.01526922f, -0.00209493f, -0.00444132f, 
    -0.00721868f, 0.00767917f, 0.02114300f, -0.00568493f, 0.02805959f, 0.02039547f, 0.00972025f, 0.02111571f, 
    -0.02875082f, 0.01640696f, 0.02732310f, 0.00211288f, 0.02415557f, -0.00466462f, -0.00178306f, 0.01331524f, 
    -0.02275045f, -0.03648927f, 0.00316194f, 0.01320309f, 0.00166030f, -0.00730673f, -0.03993588f, 0.02191878f, 
    0.01141604f, -0.03308845f, -0.04064238f, -0.03473011f, -0.02708870f, -0.03493976f, -0.00630688f, 0.02418919f, 
    0.00824406f, 0.02833252f, 0.01524782f, 0.02800832f, -0.04127770f, -0.03418273f, -0.03799506f, -0.03421838f, 
    -0.00944477f, -0.02029823f, -0.01206140f, 0.00538063f, -0.03097992f, -0.04164210f, 0.02634830f, 0.01922530f, 
    0.00267152f, 0.02453967f, -0.03808724f, -0.02676650f, -0.00869499f, -0.03436737f, -0.02979400f, -0.00011796f, 
    0.01295922f, 0.02852150f, -0.02972635f, 0.01093350f, -0.04214744f, 0.01029634f, 0.00331455f, -0.01272327f, 
    -0.01173606f, -0.04065062f, 0.02411883f, -0.01987824f, -0.03291498f, -0.03689022f, -0.03784594f, -0.02093747f, 
    0.01834210f, -0.00958621f, -0.04203848f, 0.00645384f, -0.03446247f, -0.01848645f, 0.00950356f, 0.00399849f, 
    -0.00200919f, 0.00615433f, 0.01528559f, -0.02010800f, 0.01369918f, -0.01034846f, 0.02753739f, 0.02076983f, 
    0.00494389f, -0.02852569f, 0.00151674f, -0.03588568f, -0.01676524f, -0.01021101f, 0.02540155f, -0.04122008f, 
    -0.02893367f, -0.00203182f, 0.01985024f, -0.03390270f, -0.00694708f, -0.04092471f, -0.00251093f, 0.01350452f, 
    0.01980644f, -0.03317795f, 0.00395473f, 0.01527645f, 0.00022582f, 0.01963605f, -0.02961389f, 0.01418023f, 
    -0.02164905f, -0.02038987f, -0.01781223f, -0.04073286f, 0.00389332f, -0.01706305f, -0.00568046f, 0.01176463f, 
    -0.00867251f, 0.02337500f, -0.02673130f, 0.01622421f, -0.03549244f, -0.03407850f, -0.01270488f, -0.02689925f, 
    -0.03977032f, 0.00847315f, -0.01714914f, 0.01387236f, -0.02197076f, -0.01774707f, 0.02928393f, -0.02651736f, 
    0.01944806f, 0.00668573f, 0.01219643f, -0.02252679f, 0.01038925f, -0.01475929f, -0.04414551f, 0.00310396f, 
    -0.02780373f, -0.00437158f, -0.02290310f, -0.00201685f, -0.01684614f, 0.02025531f, 0.01386920f, -0.02985591f, 
    0.01903640f, 0.01411747f, -0.00617902f, -0.03548319f, 0.01788350f, -0.03437367f, -0.04130662f, 0.02101160f, 
    -0.03754498f, 0.01033539f, -0.01611976f, 0.01068550f, -0.03737685f, -0.00631403f, -0.03234603f, 0.02412671f, 
    0.02394071f, -0.03434388f, 0.01538156f, 0.02719064f, -0.01082033f, -0.00149512f, -0.01770067f, 0.02476290f, 
    -0.03226245f, 0.01044077f, 0.01070775f, 0.00785165f, -0.01492907f, -0.00687236f, -0.01696164f, 0.01855456f, 
    -0.00082637f, -0.01027931f, -0.03072858f, -0.02771699f, -0.00390423f, -0.02638141f, -0.03557507f, -0.00552235f, 
    -0.03740944f, 0.02083067f, -0.02119834f, 0.00351356f, -0.00119266f, 0.02139998f, 0.02530357f, 0.01712086f, 
    -0.00621955f, 0.00429447f, -0.00902680f, -0.02446201f, 0.00942937f, 0.01879315f, 0.02179224f, -0.01424359f, 
    0.01684472f, -0.00840091f, -0.00824322f, -0.00911727f, 0.00413773f, -0.02800700f, -0.00421342f, 0.00973081f, 
    0.00181150f, -0.02313644f, 0.00006442f, 0.00384635f, -0.01010139f, -0.02464159f, -0.01955690f, -0.02746849f, 
    -0.01325664f, -0.03427323f, 0.00237049f, 0.02311192f, 0.02424934f, -0.00744430f, -0.04057204f, 0.02272464f, 
    0.02611953f, 0.00341668f, -0.01066892f, -0.01927854f, 0.01201012f, -0.04152667f, -0.02881060f, 0.00090909f, 
    -0.03167836f, 0.00048929f, -0.01961648f, 0.00813301f, 0.00732018f, 0.01173593f, 0.00773394f, -0.03251512f, 
    -0.01342175f, -0.03003296f, 0.01869549f, -0.02288926f, -0.01424961f, -0.01460871f, -0.01059528f, 0.00270661f, 
    -0.01580616f, 0.01877283f, -0.04011356f, -0.02149105f, 0.02358312f, 0.01682524f, 0.02622147f, -0.00278060f, 
    -0.03207158f, -0.03290418f, -0.02626408f, -0.00029065f, -0.04344922f, 0.00799748f, -0.01201714f, 0.00017255f, 
    0.01806337f, 0.00747376f, -0.04378605f, -0.01762310f, 0.01934419f, -0.02970359f, 0.00560765f, 0.00585872f, 
    -0.03805564f, 0.02351413f, 0.00419785f, -0.03927179f, -0.02236595f, 0.01097031f, 0.00087405f, 0.01286372f, 
    -0.02592100f, -0.00350725f, -0.01792798f, -0.01800080f, -0.03383158f, 0.02526339f, 0.02643659f, 0.01645546f, 
    -0.00146717f, 0.02800432f, 0.00024418f, 0.00438516f, 0.01764485f, -0.03443892f, 0.01696923f, -0.00215571f, 
    -0.00503552f, 0.02110650f, -0.02780368f, -0.02855005f, -0.02976637f, -0.01754376f, -0.02000003f, -0.03211002f, 
    0.00320755f, 0.02814920f, -0.02286300f, -0.03953579f, -0.00171455f, -0.02636635f, 0.00798238f, -0.01144631f, 
    0.00857162f, 0.00217170f, -0.03234240f, -0.03975765f, 0.02582224f, -0.00363865f, 0.01245347f, -0.02304262f, 
    0.00517091f, -0.00266754f, -0.02548074f, 0.01943409f, -0.00339432f, -0.01491218f, 0.01900351f, 0.01375475f, 
    0.02701407f, -0.02621883f, 0.02138807f, 0.00967922f, -0.02410856f, -0.00394120f, 0.02193928f, 0.00442577f, 
    -0.01819601f, -0.02299294f, -0.02308140f, 0.01720821f, -0.03695353f, -0.00939559f, -0.00783144f, -0.00861827f, 
    0.01573399f, -0.01487737f, -0.00486050f, -0.02209340f, -0.04203551f, 0.00730929f, -0.01657319f, 0.02921430f, 
    -0.03499352f, -0.00994807f, 0.02554697f, 0.00807666f, 0.00437477f, -0.03713868f, -0.02499702f, -0.01053816f, 
    -0.02398887f, -0.01881542f, 0.00935574f, -0.00668056f, -0.03248283f, 0.01015077f, 0.00581152f, -0.01433346f, 
    -0.01413442f, 0.00990104f, -0.01566540f, -0.03096556f, 0.00515661f, -0.02115395f, -0.03262182f, -0.02536156f, 
    -0.00133602f, -0.00659244f, -0.00285702f, -0.01399116f, -0.01791297f, 0.02314498f, 0.02596679f, -0.01533387f, 
    -0.02381475f, -0.01208305f, -0.02726577f, -0.02297068f, -0.02447054f, 0.01389387f, -0.03884811f, -0.04293234f, 
    -0.01052008f, 0.02612002f, 0.00404748f, -0.03224638f, -0.01324596f, 0.00948741f, -0.01984665f, -0.03273546f, 
    -0.00932609f, -0.00805469f, -0.04129404f, -0.00964631f, -0.02935787f, -0.03212213f, -0.02121432f, 0.01016067f, 
    0.02186238f, -0.03908705f, 0.00445756f, -0.00999188f, -0.01847757f, 0.00678266f, -0.03835110f, -0.02274845f, 
    -0.03090732f, -0.03882207f, -0.03806274f, -0.01927591f, -0.03625588f, 0.00451211f, 0.02161113f, 0.01430233f, 
    -0.03348437f, -0.02890696f, 0.01763186f, -0.01722966f, -0.00038385f, 0.00760660f, -0.03883249f, 0.00987645f, 
    -0.01355302f, -0.01879581f, 0.01332743f, 0.00572390f, -0.03439816f, 0.02450330f, -0.00018823f, 0.00062753f, 
    -0.00236309f, -0.00815977f, 0.01116426f, 0.02148286f, -0.00500539f, -0.00770596f, -0.00629430f, 0.02708941f, 
    0.01507264f, -0.03426118f, -0.00631322f, -0.02645693f, 0.01465182f, -0.00606688f, 0.02884461f, 0.00142664f, 
    -0.01855868f, -0.00384381f, -0.00380722f, 0.01406635f, 0.01810865f, -0.03333222f, 0.02591272f, 0.02203063f, 
    -0.00059049f, -0.01914961f, 0.00176640f, -0.01767871f, -0.01936579f, 0.02857530f, 0.00939027f, -0.00037995f, 
    -0.00335214f, -0.00442375f, -0.03713052f, 0.00846438f, -0.01135686f, 0.00221584f, -0.02423876f, 0.01213119f, 
    0.02108478f, -0.02406046f, -0.04368575f, 0.01201455f, -0.00448544f, 0.01098044f, 0.00062796f, 0.02663838f, 
    0.00926392f, -0.02628783f, 0.01164219f, 0.01311054f, -0.01138816f, -0.04272210f, -0.02047321f, -0.01027921f, 
    -0.03083152f, -0.03105765f, -0.02072905f, 0.01677553f, -0.01983369f, 0.00689798f, -0.00596172f, -0.02990614f, 
    -0.03137358f, -0.01741302f, 0.02099168f, 0.00351483f, -0.02474619f, 0.01404121f, 0.00385285f, -0.04072347f, 
    0.01601657f, -0.02230803f, -0.03369829f, 0.01594553f, -0.03572211f, 0.01169912f, 0.00448828f, 0.02138802f, 
    0.01544093f, 0.01974612f, -0.01769674f, 0.00209775f, -0.03359393f, 0.02156639f, 0.02627582f, 0.01670521f, 
    0.02469092f, -0.00081130f, -0.04128564f, 0.02238741f, 0.02628795f, -0.00447110f, -0.00224517f, 0.02142627f, 
    -0.00607805f, -0.00823417f, 0.02660457f, 0.00731309f, 0.01758631f, 0.01796228f, 0.00529749f, 0.00530129f, 
    -0.01163807f, -0.02613579f, 0.00362619f, -0.02127812f, -0.01344032f, 0.01652951f, 0.00083247f, -0.01451198f, 
    -0.03138834f, -0.00871652f, -0.00983468f, -0.00354797f, -0.03907431f, 0.00715241f, 0.02243655f, 0.02285441f, 
    0.00024591f, 0.00597785f, 0.01738730f, 0.01412083f, 0.02464327f, 0.02125664f, -0.01261402f, 0.00862373f, 
    0.02445783f, -0.00836837f, -0.01380509f, -0.03197912f, 0.01377816f, -0.04117749f, -0.03278245f, 0.01208624f, 
    -0.02818488f, 0.01497924f, -0.03029736f, 0.02256117f, -0.01889571f, -0.03055366f, -0.00913001f, -0.03343457f, 
    0.00469336f, 0.02979206f, 0.01651128f, -0.02375283f, -0.03559002f, -0.00984068f, -0.02665010f, -0.01361563f, 
    -0.01506112f, -0.02017003f, -0.02441161f, -0.01435127f, -0.04148508f, -0.00722264f, -0.01234566f, -0.00968563f, 
    -0.02511609f, 0.02522689f, -0.03432434f, -0.01016863f, 0.01077547f, -0.00749924f, -0.02416331f, -0.00164494f, 
    -0.00993431f, 0.00348547f, 0.01837617f, 0.01848838f, 0.00997044f, -0.00206199f, 0.00699465f, 0.00670123f, 
    0.00282952f, 0.02196441f, 0.02373318f, -0.02388221f, 0.00867171f, -0.02710402f, -0.01615862f, 0.00244972f, 
    -0.02725728f, 0.00685917f, -0.01100108f, 0.00953388f, -0.01780015f, -0.02249611f, -0.02690796f, 0.00256600f, 
    -0.02750586f, 0.00479789f, 0.02157338f, 0.02469422f, -0.00567362f, -0.03064385f, -0.03319183f, -0.02641188f, 
    0.01677624f, 0.00346744f, -0.03948094f, 0.02078613f, -0.00601756f, -0.03616247f, -0.00255371f, -0.03769729f, 
    -0.01190960f, -0.01050217f, 0.02136402f, 0.01067156f, -0.01299981f, -0.02255813f, -0.04197894f, -0.01761206f, 
    0.01893899f, -0.00082384f, -0.03598938f, -0.04089061f, -0.03619274f, -0.00854295f, 0.00717721f, -0.02477223f, 
    0.03706209f, 0.01833341f, 0.02484200f, -0.03743715f, 0.00007249f, 0.01594614f, -0.01288927f, -0.02321814f, 
    -0.01258408f, -0.02516328f, -0.00414525f, 0.00962721f, -0.01267170f, -0.03951024f, -0.02315758f, 0.00538296f, 
    0.01188818f, 0.00545578f, -0.03097532f, 0.00222326f, -0.00679267f, -0.02786962f, -0.03430832f, 0.00140786f, 
    -0.03675794f, -0.00607323f, 0.00982653f, -0.03043379f, 0.02498089f, 0.00085881f, 0.01436426f, 0.02221874f, 
    0.01660431f, 0.02826734f, -0.01057533f, -0.03300834f, 0.01686424f, 0.02266511f, 0.00454853f, -0.00303965f, 
    -0.03438129f, -0.00054847f, 0.02044142f, 0.00662313f, 0.02008346f, -0.04094705f, -0.01075134f, -0.01370444f, 
    0.02683552f, 0.00244070f, -0.01961120f, 0.02348152f, 0.00005183f, -0.03401905f, 0.01308679f, -0.00450625f, 
    -0.00716379f, -0.04026430f, 0.01816977f, -0.04278078f, -0.04027221f, 0.02233372f, -0.02300883f, -0.03783739f, 
    0.00559401f, 0.03460602f, -0.00209126f, 0.02512196f, -0.00576961f, -0.00665865f, -0.00512607f, -0.01967597f, 
    -0.03432576f, -0.00433112f, 0.01537661f, -0.00093986f, 0.00966834f, 0.02573138f, -0.01546957f, 0.01268343f, 
    -0.00894001f, -0.03901221f, 0.02186815f, 0.00368044f, 0.00130768f, 0.02268332f, 0.00564695f, -0.02276204f, 
    -0.00696834f, -0.03188802f, -0.03753620f, 0.02460103f, -0.03219457f, -0.02059764f, -0.00324240f, -0.01209927f, 
    0.00849133f, -0.00090082f, 0.01928687f, -0.04034995f, 0.01114723f, 0.00974583f, -0.00168426f, 0.01380386f, 
    -0.02291721f, 0.00352367f, -0.00222597f, -0.01089796f, -0.01906327f, -0.00264765f, 0.00561510f, 0.02408327f, 
    -0.00104685f, -0.03144148f, 0.02635358f, 0.00648456f, 0.02384916f, -0.03529756f, 0.00142045f, -0.00481664f, 
    -0.04012921f, -0.02593777f, -0.02434912f, -0.00778991f, 0.01235624f, 0.02816864f, 0.01017589f, -0.01367944f, 
    -0.00273270f, -0.01045432f, -0.02950686f, -0.02711697f, 0.02205554f, 0.00118106f, -0.04102293f, -0.01560075f, 
    -0.00734748f, 0.00735114f, -0.00344187f, 0.01829438f, 0.00919368f, -0.01804537f, -0.02934295f, 0.00445225f, 
    0.02542400f, 0.01622788f, -0.03595961f, 0.01577350f, -0.02057151f, -0.00649971f, -0.02464268f, 0.00919468f, 
    0.01870266f, -0.00260332f, -0.01172677f, -0.01412963f, -0.02505117f, -0.02672929f, -0.01947989f, -0.03728912f, 
    -0.04077555f, -0.00098143f, -0.02531855f, 0.00455717f, 0.00439717f, 0.00884744f, 0.00548085f, 0.00023531f, 
    0.02009833f, 0.00664776f, -0.02161740f, 0.02903162f, -0.00689680f, 0.01735439f, 0.01363763f, -0.00262808f, 
    0.00980608f, -0.01312098f, 0.01988382f, -0.03695534f, 0.02762114f, -0.01831645f, 0.02259361f, 0.00586388f, 
    -0.02941247f, -0.01750562f, -0.01150213f, -0.00006610f, 0.01757815f, -0.02073349f, -0.04243945f, -0.03610115f, 
    -0.01533898f, -0.00790463f, -0.00739783f, 0.00260775f, -0.01363712f, 0.01164447f, 0.02983885f, 0.01662461f, 
    0.02546810f, -0.01896433f, 0.02772781f, -0.01381583f, -0.03828345f, 0.00599241f, 0.00986034f, 0.00254542f, 
    0.00253038f, -0.01019365f, -0.00000646f, 0.00292491f, 0.00960813f, -0.00518363f, -0.00066555f, -0.00949488f, 
    -0.03257588f, -0.03278720f, -0.01655720f, -0.00334528f, -0.04271058f, 0.01395126f, -0.03413215f, 0.02274883f, 
    0.00706340f, -0.00600685f, -0.03885621f, -0.01006230f, -0.02358695f, -0.02740096f, 0.00730359f, -0.03720364f, 
    -0.01093987f, -0.03184032f, -0.00453270f, 0.02782630f, 0.00167039f, -0.00723915f, -0.03115614f, -0.03048302f, 
    0.02451835f, -0.02379690f, 0.00634944f, -0.01561786f, 0.03459521f, 0.03151644f, -0.01126599f, -0.02226955f, 
    0.03545563f, -0.03057334f, -0.00235264f, -0.00917761f, -0.02592684f, 0.00569372f, 0.00963951f, -0.02728147f, 
    -0.01411742f, 0.02627864f, 0.00142023f, 0.02942112f, -0.03115129f, -0.03939659f, 0.01051531f, -0.02736873f, 
    -0.00123265f, -0.00407281f, -0.04330194f, -0.00331818f, -0.02841281f, -0.00656670f, -0.03039711f, -0.01301869f, 
    -0.03041393f, -0.02909515f, -0.01489254f, -0.02269650f, 0.00204574f, -0.02017508f, -0.01872363f, 0.02619397f, 
    -0.03818405f, 0.02238481f, -0.02382372f, -0.03137010f, -0.00547532f, 0.01388424f, -0.01442436f, -0.02103325f, 
    0.00723272f, -0.01399172f, 0.02864624f, -0.01997880f, -0.03633556f, -0.03613941f, 0.00088149f, 0.00981637f, 
    0.00030618f, 0.02201903f, 0.00248996f, -0.02381754f, -0.00027720f, -0.03805197f, -0.02217715f, -0.00907651f, 
    -0.00376138f, -0.01551891f, -0.03602575f, -0.01369567f, -0.03256303f, -0.01504992f, -0.01335741f, 0.00151034f, 
    0.01172467f, -0.03429595f, -0.02123004f, 0.01327447f, 0.02038972f, -0.01364507f, -0.00458876f, -0.00852763f, 
    -0.03013351f, -0.03233232f, 0.00360000f, -0.00338458f, 0.01573373f, 0.00901731f, -0.01607876f, -0.02621266f, 
    -0.00426907f, -0.00499368f, -0.01345344f, 0.00489400f, 0.02551224f, 0.00684928f, -0.01281532f, -0.01900366f, 
    0.01650308f, -0.00724036f, 0.00062021f, -0.02030816f, -0.02606796f, -0.03121445f, -0.00431005f, 0.01892675f, 
    0.02796372f, 0.01718999f, 0.02929608f, -0.02867412f, 0.00869587f, 0.01655725f, -0.04011970f, -0.00649706f, 
    0.02285309f, 0.02690864f, 0.00294147f, 0.00500913f, -0.00816484f, 0.01451016f, 0.01408268f, -0.00263067f, 
    0.00957802f, 0.01742736f, 0.02776479f, 0.02732386f, -0.00792071f, -0.00146016f, -0.01353405f, -0.03380349f, 
    0.01491097f, 0.02276536f, 0.00978667f, -0.00073023f, 0.00575976f, -0.01432112f, 0.01801947f, 0.00582002f, 
    0.02830518f, -0.01539165f, 0.02191159f, 0.01166867f, 0.00189065f, 0.00802355f, -0.00287486f, -0.02375719f, 
    0.01776304f, -0.02077895f, 0.02248474f, 0.02637044f, -0.01891454f, -0.03650838f, 0.01250707f, 0.00653494f, 
    0.01698993f, -0.03379696f, 0.02747674f, 0.01332943f, 0.00776431f, -0.01798114f, -0.03769704f, 0.02469542f, 
    -0.03660164f, -0.02026936f, -0.03666965f, 0.01687413f, -0.02119339f, -0.01776053f, -0.02191935f, 0.00620831f, 
    0.01163142f, -0.02204233f, 0.01719369f, 0.02145756f, -0.03204067f, 0.02646692f, -0.01561725f, -0.02084115f, 
    -0.03370877f, 0.01981264f, -0.03604140f, 0.01701007f, 0.02663942f, 0.01490086f, 0.01474170f, 0.00894302f, 
    0.01525544f, 0.00607061f, 0.00182227f, 0.01711039f, 0.02304788f, -0.01838963f, -0.04100265f, 0.02868815f, 
    -0.00000647f, 0.01729646f, -0.01901183f, 0.00339557f, -0.02978064f, -0.03384337f, 0.00818194f, 0.01738951f, 
    -0.02062928f, 0.00091153f, -0.02356514f, -0.02700404f, 0.01363795f, 0.03136886f, -0.02724321f, 0.01417667f, 
    0.02966658f, -0.02089244f, -0.01037530f, -0.02051362f, 0.02151269f, 0.00531734f, -0.03623513f, -0.02016010f, 
    0.00875010f, 0.00085584f, -0.01127860f, 0.00699555f, -0.03375049f, 0.00130521f, 0.00969051f, -0.00997046f, 
    -0.02456338f, 0.00962380f, -0.03046034f, -0.00321226f, -0.01746518f, -0.01533392f, -0.01636810f, -0.03082642f, 
    -0.00614787f, -0.03149727f, -0.01043774f, -0.00695208f, -0.01978473f, 0.00499042f, 0.01734712f, -0.00548686f, 
    0.01609747f, 0.02920470f, 0.02808278f, -0.01300576f, -0.01585189f, 0.00956508f, -0.00145763f, 0.02404496f, 
    -0.03373056f, -0.02887016f, -0.00412914f, 0.02934869f, -0.03757692f, 0.01556484f, 0.01546702f, -0.02424053f, 
    -0.01789132f, -0.01249623f, -0.02893956f, 0.00390584f, -0.03627810f, 0.02319512f, -0.01269745f, -0.00580381f, 
    0.00007784f, 0.01737208f, -0.03625204f, 0.02525980f, -0.03125594f, 0.00607241f, 0.00119654f, 0.01934095f, 
    0.00930748f, 0.02828846f, -0.01166796f, 0.01362627f, -0.01430389f, -0.03620594f, -0.03213229f, -0.03743542f, 
    -0.02165977f, 0.00816770f, 0.00237048f, 0.00016841f, -0.00388548f, -0.02367303f, 0.01248846f, -0.00952217f, 
    -0.02356009f, 0.02560623f, 0.00676074f, -0.01275178f, -0.01868561f, -0.04126957f, -0.03250979f, 0.00326223f, 
    0.00451851f, -0.03702951f, -0.02742178f, -0.00673883f, 0.01990951f, -0.00327785f, 0.00448517f, -0.02978569f, 
    -0.00579244f, 0.01425485f, -0.01635996f, -0.01494973f, -0.03902246f, -0.03518222f, -0.01906265f, 0.00721970f, 
    -0.03021945f, 0.02434705f, 0.01640670f, -0.01035734f, 0.00169090f, 0.02201242f, 0.02002469f, 0.02277647f, 
    0.01166954f, 0.02664631f, -0.03934827f, -0.02446459f, -0.03907605f, -0.04102445f, 0.00221660f, 0.01821834f, 
    -0.04101515f, -0.02942763f, -0.02027755f, -0.00891915f, 0.00453094f, 0.02384138f, -0.02674471f, 0.01754686f, 
    0.00222482f, -0.03784992f, -0.01716392f, -0.03582413f, -0.01294638f, 0.03000267f, -0.02039706f, -0.03519702f, 
    -0.02262340f, -0.04129977f, -0.00375215f, -0.03965989f, 0.01940232f, 0.01555484f, -0.01114140f, 0.01323904f, 
    -0.02033294f, 0.01147798f, 0.01201486f, -0.03214918f, -0.00493863f, 0.01547129f, -0.01605547f, 0.02529792f, 
    0.00622374f, 0.01268458f, -0.03121598f, 0.01259671f, 0.00099214f, -0.01996726f, -0.01209933f, 0.00365317f, 
    0.02387944f, 0.03039683f, -0.00891773f, -0.03344778f, 0.02852777f, -0.02493821f, -0.03091566f, -0.01401357f, 
    -0.01841032f, 0.01298179f, -0.00064633f, 0.02925731f, 0.01145849f, -0.01308279f, 0.03577933f, 0.01646740f, 
    -0.02049902f, 0.03198978f, -0.03715341f, 0.02216931f, -0.00837835f, 0.03345473f, -0.03286686f, -0.02478025f, 
    -0.02653163f, -0.01890050f, 0.02043759f, 0.00797626f, 0.02789649f, 0.01297992f, -0.00658467f, -0.01312845f, 
    -0.01985310f, -0.01118786f, 0.00199157f, -0.04072759f, -0.01111977f, -0.02187350f, -0.04152092f, -0.01998618f, 
    -0.02039194f, -0.01186580f, 0.01951830f, 0.01319208f, -0.03968367f, -0.02722584f, -0.00445399f, -0.03803201f, 
    0.02093052f, 0.02664100f, 0.02578126f, 0.00078201f, -0.01952367f, 0.00339954f, -0.03145095f, 0.01162129f, 
    -0.02362585f, 0.00357703f, 0.02175894f, -0.01619876f, -0.01798512f, 0.02254908f, -0.00167107f, -0.01531912f, 
    -0.03398323f, -0.02769378f, -0.01400274f, -0.01759016f, -0.00519065f, -0.03828825f, -0.04351820f, -0.02913806f, 
    0.02397115f, -0.02796243f, -0.04151185f, -0.02172364f, -0.03064965f, -0.02658571f, 0.01842376f, -0.02998693f, 
    0.02531949f, -0.01110390f, -0.02227269f, 0.02689586f, -0.04185799f, 0.01836797f, -0.03923558f, 0.02038313f, 
    0.01387786f, -0.00763625f, -0.03054866f, -0.01155363f, -0.02575975f, -0.00475768f, -0.02236376f, -0.02116555f, 
    -0.01460836f, -0.00521269f, -0.02210630f, -0.02659637f, -0.02363108f, -0.01590187f, -0.00173160f, -0.01827811f, 
    -0.01429090f, -0.01835072f, 0.02396665f, 0.01816490f, 0.00676540f, -0.02733792f, -0.01534279f, -0.02110472f, 
    0.00531060f, -0.00519086f, -0.01153412f, -0.00780065f, 0.00900050f, 0.01923849f, 0.02020115f, 0.02683977f, 
    -0.02474657f, 0.01162159f, -0.00132427f, -0.02827427f, -0.00753917f, 0.02401361f, -0.03437325f, 0.02666786f, 
    0.02546727f, -0.00001739f, -0.01835579f, -0.01022971f, 0.01607135f, 0.02798743f, 0.01988191f, 0.00435198f, 
    0.01338085f, 0.01433467f, 0.03089340f, 0.00874855f, -0.03005495f, -0.00050535f, -0.02240510f, 0.02791597f, 
    -0.01140236f, 0.00605904f, 0.02811216f, -0.01657994f, 0.01648179f, -0.03138264f, -0.03160152f, -0.02013487f, 
    0.00234441f, -0.00065187f, -0.03677541f, 0.01901934f, 0.00106909f, 0.02355690f, -0.02342636f, 0.02603765f, 
    0.00092597f, -0.03206658f, -0.02408423f, 0.00181498f, -0.02209653f, -0.00452230f, -0.00639716f, 0.02574236f, 
    -0.03110817f, 0.01737983f, -0.04136191f, 0.01168890f, 0.04191471f, -0.01239820f, -0.02315178f, 0.02469865f, 
    -0.01912555f, 0.00288830f, -0.03074423f, -0.00719261f, 0.01129829f, 0.01322231f, -0.00254461f, -0.03411547f, 
    -0.02122062f, -0.03844213f, 0.02329388f, 0.02629521f, 0.00069516f, 0.02159681f, -0.01205891f, 0.03038404f, 
    0.02608450f, -0.03185770f, -0.03528003f, -0.01098324f, 0.01931684f, 0.00351447f, -0.01276662f, -0.00806981f, 
    -0.03540789f, -0.01999179f, 0.02264298f, 0.03166284f, -0.02150877f, 0.00034344f, -0.02053733f, 0.02391986f, 
    0.01647096f, 0.00683880f, -0.01041892f, -0.04101124f, 0.02697432f, 0.01198714f, -0.00984014f, -0.02147060f, 
    0.02114193f, -0.02632883f, -0.01199275f, -0.03385191f, 0.03170551f, 0.01525286f, -0.03406735f, -0.03644738f, 
    -0.02045736f, 0.10522703f, -0.09283518f, -0.12121735f, 0.05670160f, 0.08811826f, 0.12295032f, 0.02089240f, 
    0.09853464f, -0.09444006f, -0.07020434f, -0.00001628f, -0.02971315f, 0.16227011f, -0.01496392f, 0.00703974f, 
    0.05702951f, 0.00849802f, -0.07046159f, -0.01799984f, 0.15463965f, 0.02232721f, 0.16436449f, 0.04552797f, 
    0.18010138f, -0.14726914f, 0.01795045f, 0.08377022f, -0.13776693f, 0.08950786f, -0.14988321f, 0.10545666f, 
    0.01785036f, -0.15818022f, 0.05996528f, -0.00889946f, 0.36917275f, -0.39276013f, -0.13474834f, -0.09235763f, 
    -0.14531018f, -0.07697199f, 0.02197123f, 0.10899460f, -0.07308587f, -0.00283878f, -0.05747493f, 0.04819271f, 
    0.20297074f, -0.03926342f, 0.04090989f, -0.04295712f, -0.07228530f, 0.07601477f, 0.03275616f, 0.05029326f, 
    0.01306816f, 0.06743529f, 0.03602315f, 0.24073438f, -0.07995775f, 0.06803641f, 0.21697764f, -0.00136139f, 
    0.00038697f, 0.00773052f, 0.11783566f, -0.04057720f, 0.09591383f, -0.01578290f, -0.06344595f, -0.10333505f, 
    -0.01127935f, 0.17199916f, -0.24260956f, 0.11652414f, -0.09010670f, 0.02850102f, 0.07010146f, 0.15534706f, 
    -0.16034125f, 0.07289959f, 0.00513012f, -0.10078496f, -0.21864149f, -0.09197916f, 0.11457192f, 0.12528111f, 
    0.08898612f, 0.03949684f, 0.06551710f, -0.02896944f, -0.04818282f, 0.10577952f, 0.07570193f, 0.03042371f, 
    -0.48010477f, 0.03957045f, 0.11951517f, -0.06781422f, 0.02041895f, 0.09819175f, 0.00228980f, -0.02138209f, 
    0.10280534f, -0.10165737f, 0.13921832f, -0.08220006f, -0.14908746f, -0.02139144f, 0.05314592f, 0.01326689f, 
    -0.02408820f, -0.05391369f, 0.04608034f, -0.14894387f, 0.01408582f, -0.00356696f, 0.05171281f, 0.17371646f, 
    -0.02293336f, 0.10766748f, -0.16034956f, -0.04327162f, 0.00637957f, -0.07299531f, 0.04232371f, -0.03616997f, 
    0.04957083f, 0.12497672f, -0.07610410f, 0.09827189f, -0.19999821f, -0.12614132f, 0.10651524f, -0.03269133f, 
    -0.05202424f, -0.10368017f, -0.03291326f, 0.01879893f, 0.09629589f, -0.06804621f, 0.09495765f, 0.08775695f, 
    0.04533103f, 0.10782617f, 0.07892986f, 0.10103741f, 0.07817318f, 0.06339461f, 0.04670169f, 0.06917007f, 
    0.21539941f, -0.02774843f, 0.11479178f, 0.28905749f, 0.15499039f, -0.41483772f, -0.02786846f, -0.11188980f, 
    -0.02248222f, 0.01045719f, -0.07461957f, -0.06917745f, 0.01109337f, 0.00795242f, -0.12639152f, 0.07245619f, 
    -0.37641573f, -0.01681622f, -0.12054686f, -0.21170694f, 0.02754269f, -0.07843940f, -0.13801016f, 0.07183154f, 
    0.11414118f, 0.02198312f, 0.08119898f, 0.09576637f, -0.05286957f, -0.02766218f, -0.08466544f, -0.19308148f, 
    0.10517858f, 0.02708163f, -0.06329746f, -0.01728261f, -0.14005807f, 0.09798593f, 0.00364241f, 0.09410819f, 
    0.30940115f, 0.21148905f, 0.11963033f, 0.14299892f, -0.08113419f, -0.05112711f, 0.03320366f, -0.07690214f, 
    -0.04782172f, 0.18285832f, -0.04648145f, 0.02511716f, -0.37675524f, -0.25151211f, 0.08299635f, 0.33235285f, 
    0.04640635f, 0.00705074f, -0.02297570f, -0.08808192f, 0.02590243f, 0.05160824f, 0.01437267f, 0.14079516f, 
    0.18932582f, -0.01801825f, 0.02213643f, 0.08971594f, -0.00657688f, 0.03659778f, 0.02711362f, -0.07954743f, 
    -0.05306828f, -0.09910837f, -0.14374237f, 0.08638308f, 0.23274890f, 0.27759212f, -0.21770592f, -0.19722319f, 
    0.07795281f, -0.05835781f, 0.00932832f, 0.00812859f, 0.09327910f, -0.06074822f, -0.00549861f, -0.16888678f, 
    -0.15346256f, 0.09970959f, -0.15243952f, -0.23887622f, 0.14995959f, -0.08462120f, 0.05950822f, 0.10720846f, 
    0.07358620f, 0.19121253f, 0.05065330f, 0.13788903f, -0.00813768f, -0.05729650f, 0.07522937f, 0.08836318f, 
    -0.03436182f, 0.14084619f, -0.09754480f, -0.01552257f, 0.00305445f, 0.04231716f, 0.14777043f, 0.21008770f, 
    0.08161266f, -0.03277664f, 0.02391129f, -0.03436215f, -0.08882602f, 0.02964820f, 0.07866989f, 0.10642643f, 
    0.13721155f, 0.12283494f, -0.00418768f, 0.11809468f, 0.06614476f, -0.05691741f, 0.13164508f, 0.12609303f, 
    0.03627525f, 0.01822803f, -0.10044425f, 0.02682101f, -0.11287985f, -0.08518458f, -0.00422677f, -0.01634155f, 
    -0.00108102f, 0.00562658f, 0.01910375f, 0.19131453f, 0.04246752f, 0.04449591f, -0.03830025f, -0.03594236f, 
    -0.03742132f, -0.00422742f, 0.02876153f, -0.11706270f, 0.07758291f, -0.01613754f, 0.22257710f, 0.07635430f, 
    0.04993784f, 0.20827937f, 0.05294356f, -0.01973676f, 0.18100473f, -0.12604640f, 0.10648089f, -0.00777351f, 
    -0.02100462f, -0.15031487f, 0.14485146f, 0.00274003f, 0.05261726f, -0.00434257f, 0.03907764f, -0.03521867f, 
    0.23347232f, -0.07033551f, -0.12059804f, -0.07525988f, -0.27746031f, 0.07456385f, -0.02345217f, -0.07204735f, 
    0.12691045f, -0.01856036f, -0.03685521f, -0.02305536f, 0.00648772f, -0.04121217f, 0.02597880f, 0.02954258f, 
    -0.38528678f, -0.19329140f, 0.23426051f, 0.22149892f, -0.02436524f, 0.17377387f, 0.02005448f, -0.00321706f, 
    0.04649489f, 0.01445255f, 0.05648613f, 0.02633567f, -0.29051426f, -0.11767451f, 0.16023333f, 0.09855480f, 
    -0.01914467f, -0.01352194f, -0.12888257f, 0.07474525f, -0.02281060f, 0.04449651f, 0.01662616f, 0.05980479f, 
    0.16862348f, -0.02772972f, -0.01368658f, -0.07543973f, 0.13423887f, -0.08559106f, 0.03427693f, 0.05743198f, 
    -0.03899095f, -0.07023039f, -0.09561288f, 0.09085430f, -0.41352367f, 0.09875386f, -0.01531759f, 0.08243927f, 
    -0.00943531f, -0.11136620f, 0.14444152f, 0.11330970f, 0.01443507f, 0.01433157f, 0.07469727f, -0.18877387f, 
    0.09949823f, 0.19816524f, -0.03713600f, 0.13707758f, -0.02603718f, 0.11420213f, -0.07560056f, 0.05402889f, 
    -0.12930003f, 0.04805568f, 0.09441888f, 0.14171372f, 0.21570398f, -0.00198174f, -0.10496561f, -0.05010917f, 
    -0.02591471f, 0.09040958f, 0.00972979f, 0.14486986f, -0.05565435f, -0.05471333f, -0.18902349f, -0.01741915f, 
    -0.34169754f, -0.17786482f, -0.02459085f, -0.05345144f, 0.18129666f, 0.09906418f, -0.16524467f, -0.06534462f, 
    -0.11168595f, 0.00357628f, -0.10962147f, 0.00350503f, -0.03520292f, -0.10392573f, -0.04845459f, 0.05357505f, 
    0.12117185f, -0.09684037f, -0.05215063f, 0.09842505f, 0.11382711f, -0.00134163f, 0.12044353f, 0.00880530f, 
    -0.30541879f, 0.09848718f, -0.04575982f, 0.06669796f, 0.02478923f, -0.08333016f, -0.05733285f, 0.01178758f, 
    0.07023877f, 0.00264155f, 0.12486549f, -0.06391612f, 0.09106904f, 0.24863437f, 0.03453670f, -0.06384575f, 
    -0.00266907f, -0.09815633f, -0.10638596f, -0.05962846f, -0.10159390f, 0.04515230f, 0.05745505f, -0.06553206f, 
    0.05121194f, -0.19356576f, -0.18541110f, 0.03061023f, 0.00253294f, -0.02131650f, -0.11594792f, 0.02907070f, 
    -0.08311368f, 0.02745947f, -0.03497250f, 0.01489943f, 0.15892933f, -0.14720114f, -0.11615348f, 0.00771588f, 
    -0.12495624f, -0.11489410f, -0.03997244f, 0.04682152f, 0.05109286f, 0.03257143f, -0.02791429f, 0.00802954f, 
    0.40882409f, -0.06522861f, 0.04825555f, 0.13579985f, -0.03160081f, 0.07307148f, 0.00673985f, 0.07467750f, 
    0.07264063f, -0.03288421f, -0.14994761f, -0.07024133f, 0.11568595f, 0.14768252f, -0.03554403f, -0.00070492f, 
    -0.02483088f, -0.11131322f, -0.04479380f, -0.02420056f, -0.03595919f, 0.02188731f, 0.09164144f, 0.05311225f, 
    0.20088869f, 0.02569076f, -0.02279934f, -0.03148976f, 0.00055576f, -0.04949713f, -0.11161054f, 0.00954025f, 
    -0.01645868f, 0.08377203f, 0.04111090f, 0.06296451f, 0.05825086f, -0.03320150f, 0.07121386f, 0.21053775f, 
    -0.05977811f, 0.14391153f, -0.03089907f, 0.09181679f, -0.01258005f, 0.01265431f, -0.05628888f, -0.00333193f, 
    -0.16017267f, 0.17512529f, -0.01408353f, -0.00846545f, -0.05865173f, -0.03577922f, -0.05696442f, -0.04445481f, 
    0.20266056f, 0.21000950f, 0.01538556f, -0.01370507f, -0.31190631f, 0.22797836f, -0.02417147f, 0.02956894f, 
    0.01575807f, -0.03931321f, -0.01683387f, -0.02747102f, -0.01002765f, -0.02670546f, 0.05967533f, -0.08019036f, 
    0.11077637f, 0.06288347f, -0.04010669f, 0.16561565f, 0.10805915f, -0.00866836f, -0.04854779f, -0.01375419f, 
    -0.02781720f, 0.02796228f, -0.02064381f, -0.07595495f, 0.36283126f, 0.05821374f, 0.15026778f, -0.03596961f, 
    0.04264320f, -0.08673563f, 0.14657401f, -0.00299022f, -0.00096041f, 0.14385653f, 0.07298668f, 0.01323605f, 
    0.17411433f, 0.11220234f, -0.15165982f, -0.13976364f, -0.01522086f, -0.01867456f, 0.04237683f, -0.03030464f, 
    -0.01613938f, -0.02602671f, -0.08120950f, 0.00547506f, 0.09724140f, 0.12216920f, -0.01025575f, 0.05064766f, 
    0.10563906f, 0.04160912f, -0.01951419f, 0.06241161f, -0.01074487f, 0.11041698f, 0.01788246f, -0.01471377f, 
    -0.09502244f, -0.03310925f, 0.20079303f, 0.12026487f, 0.19603932f, 0.03181512f, 0.05955721f, 0.06703076f, 
    -0.07419082f, 0.05866639f, -0.05125942f, 0.21761011f, 0.18934028f, 0.12894826f, -0.06605641f, 0.05661764f, 
    -0.00782365f, -0.08834987f, 0.02393575f, 0.07451697f, 0.07881288f, 0.00020736f, -0.11065373f, -0.19538377f, 
    0.13506617f, -0.04708235f, 0.02455130f, 0.15155952f, 0.07344478f, 0.04953264f, 0.12024774f, 0.04018364f, 
    0.12299540f, -0.06793322f, 0.00122841f, -0.00114636f, 0.00784275f, -0.05456298f, 0.01221887f, -0.15647651f, 
    0.07905634f, 0.03944503f, -0.09760121f, 0.01297678f, -0.09001911f, 0.03750637f, -0.02974884f, 0.14069618f, 
    0.08072712f, 0.12199504f, -0.02214575f, 0.10304901f, 0.02187467f, -0.01661560f, 0.06804127f, 0.04926691f, 
    0.02973597f, -0.14002973f, 0.24002981f, -0.12857334f, -0.16884248f, -0.25006136f, -0.00954249f, 0.13777106f, 
    -0.03271175f, -0.01406371f, -0.01818126f, -0.00347599f, -0.06031438f, 0.06812588f, 0.05094284f, 0.09053674f, 
    -0.26062915f, 0.21614510f, -0.04682329f, 0.12167232f, -0.01111903f, -0.14709871f, 0.11050030f, 0.02242832f, 
    0.02707049f, -0.06560335f, 0.08929448f, -0.11916142f, 0.06936184f, -0.19758905f, -0.01256559f, 0.04108592f, 
    0.01206770f, -0.15315850f, -0.01904896f, 0.05347371f, -0.13065751f, 0.07602812f, -0.07545161f, 0.19906554f, 
    -0.16437310f, -0.09055575f, -0.06314533f, -0.11077432f, -0.00255696f, -0.06167549f, 0.11958244f, 0.03593586f, 
    -0.01147245f, 0.01381192f, 0.07430596f, 0.01209871f, 0.14752787f, -0.07969917f, 0.21793686f, 0.16121349f, 
    0.13520174f, 0.09001357f, 0.14680147f, 0.03927447f, 0.16051266f, 0.06194885f, -0.10014461f, 0.05479125f, 
    0.53600538f, -0.04457217f, 0.08904306f, 0.15167756f, -0.03298451f, 0.04671915f, -0.07882108f, 0.03040605f, 
    -0.10778438f, 0.01346697f, 0.13512443f, 0.09799828f, 0.12948528f, 0.04724169f, 0.21293044f, 0.05135207f, 
    0.02192400f, 0.05009468f, -0.07074119f, 0.07988551f, -0.02274976f, -0.24519622f, 0.09486004f, 0.03470040f, 
    0.54765475f, -0.17824358f, 0.01628396f, -0.13813931f, -0.06472275f, 0.10968442f, -0.01379029f, -0.09824899f, 
    0.04964120f, -0.01921688f, -0.00061557f, -0.02197251f, 0.00744376f, 0.24385732f, -0.01074146f, -0.15257177f, 
    0.02100529f, -0.12581395f, 0.08672813f, 0.07784624f, 0.01281069f, 0.18590347f, 0.07263537f, -0.07891818f, 
    -0.24985123f, 0.28266469f, -0.03466396f, 0.06095922f, 0.09806310f, -0.06114088f, 0.03859578f, 0.02495475f, 
    -0.01405018f, 0.15036486f, 0.14038578f, 0.01934368f, 0.00152211f, 0.25704581f, -0.20222268f, -0.03822184f, 
    0.06475422f, 0.03672497f, 0.05994074f, 0.04776123f, -0.06483319f, 0.06531359f, -0.13288815f, 0.00501355f, 
    -0.37939522f, 0.19475026f, 0.03012783f, -0.05621680f, -0.01788632f, 0.16990431f, 0.22455949f, -0.04194755f, 
    -0.01424879f, 0.17374875f, -0.05377247f, -0.05606772f, 0.09454057f, 0.33835825f, -0.06794353f, 0.04300860f, 
    0.02133866f, 0.02882616f, 0.02344492f, -0.13705195f, 0.02652667f, 0.07039052f, 0.06246762f, 0.04846416f, 
    -0.20239043f, 0.06144629f, 0.13067831f, 0.05286340f, 0.01129612f, 0.02644681f, 0.07532971f, -0.08299019f, 
    0.03637519f, 0.00031145f, 0.06439228f, -0.00548667f, -0.05476034f, -0.10756675f, -0.14215547f, 0.01784074f, 
    -0.01001987f, 0.05276687f, -0.10244495f, 0.02799632f, 0.00955611f, -0.02835383f, -0.04901655f, 0.16927932f, 
    -0.08375375f, 0.14474328f, -0.00686836f, 0.12287954f, 0.03777961f, 0.04002177f, 0.17051266f, 0.01636839f, 
    0.16280545f, -0.04200276f, 0.02595926f, 0.10745846f, -0.28444025f, 0.20637599f, -0.08887606f, -0.17755394f, 
    -0.07852487f, -0.10645319f, -0.03449446f, -0.01085299f, 0.04177938f, -0.09516577f, -0.10032528f, 0.02819568f, 
    -0.14902379f, 0.23868421f, -0.10543022f, -0.18365708f, -0.00712766f, 0.02019389f, -0.07516009f, 0.05554506f, 
    -0.05361595f, 0.17740913f, -0.11263925f, 0.10058916f, 0.09345432f, 0.03899122f, 0.13239881f, -0.01325493f, 
    -0.02793025f, -0.01203656f, -0.11935604f, 0.01523128f, -0.02719612f, 0.01847444f, 0.00248584f, -0.03272489f, 
    0.16748999f, -0.08357018f, -0.05132855f, -0.10479426f, 0.05939636f, -0.03715459f, -0.07278719f, 0.12824628f, 
    -0.01589445f, -0.06735224f, 0.04563288f, 0.00386645f, -0.27089265f, -0.00421478f, 0.19003566f, 0.18215491f, 
    0.00215652f, 0.03038807f, 0.01987786f, -0.04622280f, 0.06671372f, 0.00527507f, -0.07888804f, -0.02145820f, 
    0.14905685f, 0.19295809f, 0.14237021f, 0.13031727f, 0.06109688f, -0.03619307f, 0.08292364f, 0.24060024f, 
    -0.14763358f, 0.04548678f, 0.12663850f, -0.05729802f, -0.17951417f, -0.01326811f, 0.11937184f, -0.05921360f, 
    -0.05548782f, -0.00482327f, 0.03471444f, 0.03779544f, 0.07962130f, 0.06509563f, 0.14603516f, 0.06016387f, 
    0.01051829f, -0.03512836f, 0.31738403f, 0.15759414f, 0.15966821f, -0.00468464f, 0.02724445f, -0.10981257f, 
    0.00942812f, 0.02337192f, -0.13199022f, 0.06814946f, 0.03728723f, 0.09594695f, 0.02428222f, -0.00255894f, 
    -0.05833078f, 0.02401812f, 0.14628769f, 0.10704465f, 0.12614648f, -0.00986976f, 0.00911661f, 0.01918608f, 
    -0.17277831f, -0.22237952f, 0.07881200f, 0.11419671f, 0.09146867f, 0.06367901f, 0.09105227f, 0.05747346f, 
    0.08468638f, -0.08686708f, -0.00969119f, -0.00598154f, -0.16885646f, 0.05873950f, 0.16195787f, -0.11391121f, 
    -0.06803139f, -0.04052617f, -0.04631518f, 0.00447282f, -0.02040816f, -0.02579940f, -0.05271348f, 0.03472321f, 
    -0.22732107f, 0.01249725f, 0.03862563f, 0.11791182f, -0.03513711f, -0.00315848f, 0.07132820f, 0.26086569f, 
    -0.02123887f, 0.10427617f, 0.21401837f, -0.16758607f, 0.16800946f, 0.28697240f, -0.07160552f, -0.12422054f, 
    0.05415593f, -0.00738344f, -0.04414153f, 0.07204942f, -0.09752470f, 0.09484076f, 0.08494249f, 0.08728847f, 
    0.02403272f, 0.24386370f, -0.04477382f, -0.07497442f, -0.05222239f, -0.00840735f, 0.06104036f, -0.04975092f, 
    0.01232060f, -0.15981276f, 0.08992814f, -0.04899769f, 0.13520263f, -0.11332066f, 0.09112423f, 0.26227152f, 
    -0.12781319f, -0.06302397f, 0.03545071f, -0.11674034f, 0.04054231f, 0.03334688f, 0.06258605f, -0.21178471f, 
    -0.26927242f, 0.07763661f, 0.04635591f, 0.05869814f, 0.00187228f, 0.07494390f, 0.00995373f, -0.00288137f, 
    -0.01487427f, 0.00275457f, 0.07707998f, 0.03806285f, 0.20887943f, 0.14107147f, -0.03827124f, 0.18828188f, 
    0.02315391f, -0.03301469f, 0.11404685f, 0.16485588f, 0.07514741f, 0.05795433f, 0.05259956f, 0.03113413f, 
    -0.07673551f, -0.04321690f, -0.11918538f, -0.05149592f, -0.09558985f, -0.04398916f, 0.06479591f, 0.05560997f, 
    0.00575045f, 0.07771178f, -0.03118333f, -0.04662229f, -0.11236772f, -0.07271151f, 0.04005110f, 0.20970502f, 
    -0.02448732f, -0.09725334f, -0.01603640f, -0.00361292f, -0.08707082f, 0.05543223f, 0.06197202f, -0.12343975f, 
    -0.11033856f, -0.03503978f, 0.02953534f, 0.03026554f, 0.09554718f, -0.04930892f, 0.05911935f, -0.14058441f, 
    -0.10982504f, 0.08170196f, 0.01848778f, 0.14867671f, 0.27009979f, -0.21216521f, 0.14137749f, 0.16506819f, 
    0.00818519f, -0.00384083f, 0.15719682f, 0.06202865f, -0.07138820f, 0.07370227f, 0.07245059f, 0.07491048f, 
    -0.24635868f, 0.23341879f, 0.00597814f, -0.24065040f, -0.10961410f, -0.05211812f, -0.05459033f, 0.04683432f, 
    0.02428302f, 0.08868465f, -0.05680504f, -0.04114194f, 0.10921819f, -0.22274378f, 0.08509236f, 0.04127889f, 
    -0.09502175f, -0.01793857f, 0.07117376f, -0.06824275f, 0.03079954f, -0.05954626f, 0.06259325f, 0.06240431f, 
    0.16020675f, 0.06354976f, 0.15321656f, 0.16664498f, -0.01064840f, 0.01735982f, 0.02063495f, -0.00750351f, 
    0.03433919f, 0.00579602f, 0.12455139f, -0.00140188f, -0.11187834f, 0.13672401f, 0.13013875f, 0.11417016f, 
    0.06566393f, 0.06044785f, -0.03974251f, -0.01582655f, 0.17157157f, 0.00785843f, -0.03202881f, 0.17500056f, 
    -0.26769686f, 0.10703181f, -0.06872583f, 0.09991581f, 0.03972277f, -0.01363767f, 0.12334054f, 0.06690997f, 
    0.07177749f, -0.04559490f, 0.01535274f, 0.09343536f, -0.16297148f, 0.08016056f, -0.12368014f, -0.07293066f, 
    0.08810319f, 0.01345148f, -0.13819437f, 0.12431391f, -0.07741487f, -0.02793727f, 0.02366796f, 0.12256651f, 
    -0.15195741f, -0.17660353f, 0.17330624f, -0.42327705f, -0.00981325f, 0.04414476f, 0.03220874f, 0.11997423f, 
    0.11155003f, -0.07604932f, 0.12202793f, -0.03737629f, -0.17956054f, 0.17696711f, 0.16839461f, -0.03414491f, 
    -0.13214202f, 0.12411544f, 0.05081594f, -0.05600806f, 0.04679899f, -0.10246535f, -0.08444286f, 0.08510224f, 
    -0.01734990f, -0.00129185f, 0.12151488f, 0.14094025f, 0.07859555f, 0.00101678f, 0.06224382f, 0.00445608f, 
    0.03436131f, 0.07405533f, -0.03445992f, 0.07791986f, -0.14183421f, 0.22589664f, -0.11482865f, -0.07171060f, 
    0.08375019f, 0.04828836f, 0.04295414f, 0.13888296f, 0.07160243f, 0.06253380f, -0.09272580f, -0.00259667f, 
    0.05056033f, 0.03777149f, 0.10891310f, 0.09378736f, -0.05890397f, 0.10662699f, 0.07102948f, 0.00760142f, 
    0.09307443f, -0.06637882f, 0.06946199f, -0.05214498f, 0.15190804f, 0.24318622f, -0.07145820f, 0.13259320f, 
    -0.02417486f, 0.12707219f, 0.05197282f, -0.15903451f, 0.03542905f, 0.11317945f, -0.07619045f, 0.12871535f, 
    -0.01557291f, 0.01728524f, -0.03943100f, -0.05852282f, 0.00584404f, 0.00227230f, 0.03390586f, 0.00968560f, 
    0.04763080f, -0.07343520f, 0.15934646f, 0.06714406f, 0.08103786f, 0.11089727f, -0.11490327f, 0.00509144f, 
    0.17069387f, 0.09517273f, 0.01757138f, 0.16431232f, 0.08958248f, 0.04153610f, -0.11095892f, 0.01963414f, 
    -0.04758273f, -0.09060322f, 0.01100202f, -0.01336973f, 0.02385178f, 0.11700749f, 0.06147278f, 0.00114382f, 
    0.08693068f, -0.02427865f, 0.04317652f, 0.05005627f, -0.00695190f, 0.31479105f, -0.00102136f, 0.03960848f, 
    0.02596404f, 0.05835291f, 0.04118407f, 0.04268894f, -0.05164250f, 0.07570769f, 0.01148993f, 0.04851354f, 
    0.32366294f, -0.19920395f, -0.02998160f, -0.04389171f, 0.05396727f, -0.06084079f, 0.02156481f, -0.00312974f, 
    -0.04403047f, -0.06358816f, -0.02142535f, -0.07086941f, 0.28332400f, 0.21197736f, -0.08378452f, 0.05434566f, 
    0.12442572f, -0.01042585f, 0.02407764f, 0.02532825f, 0.04509842f, 0.09184034f, 0.03876492f, 0.04056275f, 
    -0.19813786f, 0.00291255f, -0.24804808f, -0.08655550f, -0.07688721f, 0.07698657f, 0.04745744f, 0.08945233f, 
    0.01689184f, -0.02084295f, -0.09310965f, 0.04103513f, -0.08479375f, 0.09267247f, 0.03190207f, 0.09068509f, 
    0.07009960f, 0.00914850f, -0.01459537f, 0.14215794f, 0.02234401f, -0.10552959f, -0.03976405f, 0.07419262f, 
    0.13166974f, -0.01705599f, -0.14707276f, 0.00922328f, 0.08714606f, -0.02375247f, 0.07077251f, -0.05163575f, 
    -0.05042678f, 0.05018402f, -0.03386531f, 0.05719993f, 0.01767371f, -0.08494642f, -0.11246056f, -0.01452150f, 
    -0.05821488f, 0.03664220f, 0.08718573f, 0.14720102f, 0.09081682f, -0.08665684f, -0.00116980f, 0.08034437f, 
    0.05447073f, 0.04064573f, 0.03334197f, 0.18499364f, -0.01103837f, -0.00407444f, 0.01214939f, -0.00735423f, 
    0.03017797f, 0.03920770f, 0.04862972f, 0.00068746f, -0.19642863f, 0.17776148f, 0.28607300f, -0.03297560f, 
    0.10143909f, 0.01061733f, 0.09145055f, -0.08806924f, -0.01831843f, 0.11887717f, 0.13274333f, 0.19770429f, 
    0.01544048f, 0.08816855f, 0.01488240f, 0.06373621f, 0.09744300f, -0.02100357f, 0.04140193f, 0.11775631f, 
    -0.07982796f, 0.01606946f, 0.00510940f, -0.04058461f, 0.20821041f, -0.03203954f, 0.10464095f, 0.06929313f, 
    0.06404342f, 0.05989407f, 0.06342832f, -0.00874283f, 0.02541155f, 0.00156885f, -0.11677392f, 0.00266926f, 
    -0.08282661f, -0.14976865f, 0.03201067f, 0.05763772f, 0.06846835f, 0.05205779f, 0.07076482f, 0.10024567f, 
    0.01451400f, 0.14663701f, -0.10715722f, 0.00265253f, -0.23227996f, 0.22386923f, 0.10508127f, -0.23346250f, 
    -0.06308085f, -0.05169607f, 0.07945811f, 0.00700826f, 0.14673610f, -0.08556852f, 0.02720736f, -0.06099574f, 
    0.14400820f, 0.00851431f, 0.00708117f, 0.17743875f, 0.09892801f, 0.03495383f, 0.01597511f, 0.12842794f, 
    0.07273450f, 0.06235787f, 0.02309601f, 0.14469996f, 0.12426437f, -0.03812497f, -0.23082282f, 0.18825595f, 
    -0.02124635f, 0.01685354f, -0.05998638f, 0.03856409f, -0.00964636f, -0.01256476f, 0.02679461f, -0.09864178f, 
    -0.44172344f, -0.22679031f, 0.23371494f, 0.04965469f, -0.01737386f, 0.07757733f, 0.09653582f, -0.11401284f, 
    0.01874247f, 0.00550317f, -0.01057921f, -0.12428585f, 0.18086194f, 0.15781586f, -0.06657566f, 0.16464368f, 
    0.03783988f, 0.05558693f, 0.03901380f, 0.05467528f, -0.03979741f, 0.05297806f, 0.06456121f, 0.01663582f, 
    0.13432416f, 0.07208922f, 0.03512533f, 0.13506563f, 0.08266219f, -0.05703082f, 0.08365889f, 0.06587885f, 
    0.00917411f, 0.03267286f, -0.16306403f, -0.10828362f, -0.15728702f, -0.10986137f, 0.13185218f, 0.04708911f, 
    0.02743529f, -0.06309925f, 0.01202806f, -0.08418529f, -0.12358349f, 0.18799101f, -0.13109504f, -0.00898963f, 
    -0.02665525f, -0.17533594f, 0.09938394f, 0.00993880f, -0.03700575f, 0.07855824f, 0.08520079f, -0.06404749f, 
    -0.00338551f, -0.00370348f, 0.01510271f, -0.07410806f, 0.11819208f, -0.10929941f, 0.09073030f, 0.05602822f, 
    0.00068297f, 0.03223957f, -0.07155992f, -0.11267458f, 0.02049318f, -0.07959232f, -0.00483962f, -0.00207811f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.02357109f, -0.04130930f, -0.00006230f, -0.00584600f, -0.03468059f, 0.03645423f, -0.05160110f, -0.00032268f, 
    0.02796936f, 0.01290198f, 0.02060722f, 0.02444699f, -0.01044304f, 0.02717803f, 0.01231137f, 0.09733834f, 
    0.05603851f, 0.02376442f, 0.00109102f, 0.01326576f, 0.11288235f, 0.02846732f, -0.02918719f, -0.03905750f, 
    0.02820580f, 0.01185696f, 0.00625514f, 0.02014591f, 0.02860422f, 0.00045638f, 0.05287712f, 0.00183916f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.03165986f, 0.03925980f, 0.00979362f, -0.12022953f, 0.16357961f, 0.23936704f, 0.49575973f, -0.28550327f, 
    0.14636904f, -0.16625267f, 0.02947816f, -0.11197384f, 0.11290749f, -0.17012557f, -0.35905799f, 0.01974744f, 
    0.20186058f, 0.12463944f, 0.43980259f, -0.36773089f, -0.04895315f, -0.17971270f, -0.16518314f, -0.10806476f, 
    -0.02478714f, 0.14816809f, 0.09737162f, -0.03065428f, -0.04071772f, -0.16258150f, -0.45893395f, 0.18750204f, 
    0.12922658f, -0.08410621f, -0.01909601f, 0.29178825f, -0.07011548f, -0.29178792f, 0.30692235f, -0.38222498f, 
    0.04299206f, -0.11826643f, -0.05007505f, -0.08321571f, 0.08126030f, -0.09909642f, -0.47746679f, -0.26942399f, 
    0.01042188f, -0.17698355f, 0.27688420f, 0.36166900f, 0.14595924f, 0.02038615f, -0.10343707f, 0.16113263f, 
    -0.13994689f, -0.02699436f, 0.03259783f, 0.03726569f, -0.16091852f, 0.01313173f, 0.35789517f, -0.29178527f, 
    0.06447067f, -0.13916381f, 0.36084238f, 0.22278878f, -0.08009835f, 0.36550871f, 0.11780720f, -0.27850822f, 
    -0.14449364f, 0.00959573f, -0.15547019f, -0.01689726f, -0.16017997f, -0.26511639f, 0.24134362f, -0.44359970f, 
    -0.25982133f, 0.04987125f, -0.04010182f, 0.25538951f, -0.26805961f, 0.03963382f, -0.16782762f, -0.07437387f, 
    0.04922767f, 0.05322291f, 0.14381981f, -0.07027142f, -0.14132141f, 0.05225910f, 0.06154325f, -0.05511031f, 
    -0.14218669f, -0.03469495f, -0.67193490f, 0.11632480f, -0.06421401f, -0.23886934f, -0.31604913f, -0.00386472f, 
    -0.08534388f, -0.17181055f, -0.10220791f, 0.14044331f, -0.13852903f, -0.07648070f, 0.24127814f, 0.34840357f, 
    -0.37145093f, -0.03976021f, 0.25043839f, -0.37734383f, -0.14020818f, 0.09618952f, -0.16262454f, -0.00636051f, 
    0.05251596f, -0.01773043f, -0.14332704f, 0.01821276f, -0.16140096f, -0.11671636f, 0.17688628f, -0.15446453f, 
    0.11897105f, 0.09201536f, -0.09951223f, 0.20555875f, 0.02717602f, -0.56094557f, -0.34910846f, 0.00870341f, 
    -0.08271229f, -0.03736822f, 0.09831832f, -0.10659789f, 0.07237772f, 0.22914907f, -0.08892956f, -0.19487742f, 
    0.23558961f, 0.15373014f, -0.18519840f, -0.43272379f, -0.19853112f, 0.12231427f, -0.13258384f, -0.03110998f, 
    0.04909121f, 0.14249556f, 0.10650963f, 0.13769643f, -0.16299517f, 0.11984290f, 0.25037515f, 0.30367565f, 
    -0.04075328f, 0.11458651f, -0.01232225f, -0.14313604f, 0.13166386f, 0.39364815f, -0.32866120f, -0.00723117f, 
    -0.03224725f, 0.03567287f, 0.01790163f, -0.04695609f, -0.14535181f, -0.22909926f, -0.32865968f, -0.10639205f, 
    0.59089655f, 0.16267735f, -0.26182637f, -0.07682432f, 0.21618065f, 0.05909349f, -0.03374871f, -0.13237841f, 
    0.17656209f, -0.16640103f, 0.00793886f, 0.16478902f, -0.14133497f, -0.03339951f, 0.10773450f, -0.17275511f, 
    0.02293716f, -0.11466342f, 0.37906036f, -0.20485316f, 0.05834249f, 0.00879971f, -0.44041204f, -0.04734921f, 
    -0.09568091f, -0.12138965f, -0.03875901f, -0.09548599f, 0.06199278f, -0.07737587f, -0.02181458f, 0.23183347f, 
    -0.39244741f, -0.02723677f, -0.19931741f, 0.15198393f, 0.17942610f, -0.10790520f, 0.16368747f, -0.06371322f, 
    0.07715936f, -0.14445862f, 0.04571802f, 0.26390839f, 0.00760290f, -0.09007598f, -0.70043242f, -0.09751160f, 
    -0.04251775f, 0.04369899f, -0.09172830f, -0.23458073f, -0.14142196f, 0.28560972f, -0.05144672f, 0.44851691f, 
    0.01009422f, -0.02506680f, 0.01071699f, 0.00815231f, -0.00736918f, -0.49379712f, 0.05536500f, -0.16470048f, 
    -0.39151850f, 0.08365215f, 0.11747994f, -0.10372757f, -0.39843082f, -0.01939425f, 0.08792332f, -0.10891295f, 
    0.08179841f, -0.10151341f, 0.17000698f, -0.24125075f, -0.09413952f, 0.12999596f, 0.16569521f, 0.26499444f, 
    -0.05050313f, 0.00146737f, 0.21628192f, -0.38052171f, 0.00785985f, -0.37209255f, 0.36184728f, 0.20217296f, 
    0.09353163f, 0.07152175f, 0.00164833f, 0.11008400f, 0.07562697f, -0.07783581f, 0.32308716f, -0.33557323f, 
    0.07987987f, 0.16536632f, -0.37021545f, 0.14026792f, 0.15861918f, 0.03409659f, 0.02663591f, 0.10635469f, 
    0.01369057f, 0.12635845f, -0.13182490f, -0.06940293f, -0.09470891f, -0.05795545f, 0.10704141f, -0.53247201f, 
    0.13465154f, 0.01079246f, -0.05043342f, -0.13511558f, -0.11338433f, 0.40029925f, 0.28534621f, 0.30217814f, 
    -0.10976920f, 0.09148744f, -0.00424858f, -0.03576975f, 0.05667880f, 0.49719688f, -0.36835936f, -0.31335506f, 
    -0.52510172f, -0.11456720f, -0.36216512f, -0.26412219f, -0.09435654f, 0.01305167f, 0.15911719f, -0.07591268f, 
    0.13443185f, 0.16003832f, 0.03090425f, 0.17892039f, 0.13516496f, -0.00210197f, -0.10025030f, 0.17840040f, 
    -0.00756021f, -0.12182418f, -0.07963449f, -0.37019655f, -0.08941370f, 0.38230821f, -0.02488145f, -0.36901402f, 
    0.13126394f, -0.05609483f, -0.05664934f, -0.00771209f, 0.05644896f, -0.07930624f, 0.03659059f, 0.21164951f, 
    -0.04765984f, -0.13273846f, 0.11568490f, 0.34776089f, 0.23432861f, 0.09819421f, -0.12260176f, -0.09784533f, 
    -0.07933179f, -0.03725652f, 0.01514882f, -0.62657607f, 0.13266078f, 0.17213957f, 0.23060811f, 0.01853099f, 
    0.08882333f, -0.07213369f, -0.80710560f, 0.30775893f, 0.05911689f, -0.44868025f, 0.00603892f, 0.00923391f, 
    0.15752800f, -0.10116049f, 0.09268603f, 0.08131026f, 0.11820133f, 0.03353982f, 0.28365749f, -0.00227587f, 
    -0.00057885f, 0.03332590f, -0.11114544f, 0.34987462f, 0.23226400f, -0.08889567f, -0.12348396f, 0.11106884f, 
    0.08376911f, -0.11319961f, 0.12998065f, 0.04350088f, -0.15488474f, 0.11740974f, -0.66231406f, -0.06447399f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.09801380f, -0.11661287f, -0.18426342f, -0.15420777f, -0.08615969f, -0.06434501f, 0.18950339f, 0.07442754f, 
    -0.04661443f, 0.12787580f, 0.05472516f, 0.22554922f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
