#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.58846158f, 0.33448005f, 0.32695109f, -0.20197271f, -0.42521715f, -0.44962457f, 0.14851180f, 0.01183959f, 
    0.14655028f, 0.68822318f, 0.50270611f, 0.69187099f, -0.18215141f, -0.14097957f, -0.28052354f, -0.28844795f, 
    0.04049868f, 0.09985957f, -0.86788285f, 0.39828262f, -0.09317578f, 0.46724948f, 0.39135870f, -0.27007464f, 
    0.00137591f, 0.03823067f, -0.03475930f, 0.22293992f, 0.21796948f, -0.62230921f, 0.19993728f, -0.36388960f, 
    0.05274763f, 0.13087226f, -0.00092156f, 0.42310339f, 0.34928712f, 0.28124300f, -0.41727820f, 0.38337374f, 
    -0.22016166f, 0.24613830f, -0.56123430f, -0.38667420f, 0.00778814f, 0.15758879f, 0.15116397f, 0.44512045f, 
    0.31615889f, 0.23035063f, 0.36962622f, 0.21663500f, -0.48248652f, -0.48007008f, 0.27473956f, 0.32316774f, 
    -0.14089525f, -0.46852723f, -0.53524858f, -0.50813955f, -0.02394522f, 0.04937845f, 0.35399613f, -0.67468035f, 
    -0.74861342f, -0.47389835f, 0.44022593f, 0.40474311f, 0.09005799f, 0.04601483f, -0.04493674f, 0.07471278f, 
    0.52895170f, 0.64033985f, 0.16828248f, -0.54096389f, 0.40595940f, -0.05437506f, 0.29722974f, 0.01050037f, 
    -0.13929494f, 0.34633467f, 0.06629451f, 0.53575897f, 0.70966154f, 0.29626328f, -0.28425717f, 0.03529318f, 
    0.33531636f, 0.15850061f, 0.13205053f, -0.60588634f, -0.50178713f, -0.16178510f, -0.42850959f, -0.40129736f, 
    -0.31118390f, -0.13069634f, 0.01017804f, -0.42409116f, -0.35291812f, 0.31661192f, -0.63753825f, -0.22892138f, 
    0.58627325f, 0.17425060f, 0.17248592f, 0.35720736f, -0.16654207f, -0.13566171f, -0.01482474f, -0.44572231f, 
    -0.08328461f, -0.48493034f, 0.14133412f, 0.37688392f, -0.53526175f, 0.35581017f, 0.17411937f, 0.08220101f, 
    0.59267139f, 0.28648987f, 0.47740477f, 0.42124441f, -0.26132938f, 0.30180484f, -0.13561365f, -0.43929380f, 
    0.37081382f, -0.04164615f, -0.40343848f, -0.00780339f, -0.39203465f, 0.35206273f, -0.08702121f, -0.40493712f, 
    -0.27035382f, -0.54512089f, -0.01859390f, -0.26502830f, 0.56841356f, -0.26366198f, 0.02510116f, -0.07479727f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.15908217f, 0.07347396f, -0.24051991f, -0.21475165f, 0.03497527f, 0.19204786f, 0.13064252f, 0.11483625f, 
    -0.24177255f, -0.32776162f, 0.22323599f, -0.04367394f, -0.01490257f, -0.48934510f, -0.11021924f, -0.11390948f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.05191586f, -0.13283981f, -0.28366688f, -0.05762258f, -0.17825837f, 0.05986345f, 0.01808280f, -0.03075285f, 
    0.06186738f, -0.49775660f, -0.27089030f, 0.14975505f, 0.03564745f, -0.10992130f, -0.02702628f, -0.12539980f, 
    -0.02683342f, 0.02090268f, 0.03287189f, -0.06681710f, -0.07067540f, -0.03315479f, 0.01492216f, 0.04163631f, 
    0.02924940f, 0.02548342f, 0.04509709f, 0.16011034f, -0.05810545f, 0.04809917f, 0.19639587f, -0.00062236f, 
    0.10575395f, 0.02467076f, 0.11360930f, 0.02319031f, -0.04589814f, 0.08401538f, -0.09746512f, -0.08023493f, 
    0.00752897f, -0.01798398f, 0.12881483f, 0.00030271f, -0.19575231f, -0.00257703f, -0.01088796f, -0.10979153f, 
    0.06270864f, 0.14305146f, -0.05189325f, 0.01329556f, 0.13600288f, 0.10237917f, 0.02509499f, -0.22086209f, 
    0.00516206f, 0.03234087f, 0.08671751f, -0.09225528f, 0.02087767f, -0.03627278f, -0.05254295f, 0.24116425f, 
    0.44263113f, 0.14766213f, 0.01373586f, 0.08184057f, 0.06652559f, 0.13350803f, 0.14869978f, 0.02412080f, 
    -0.52082461f, -0.33586261f, -0.07927868f, 0.01036784f, 0.00782666f, -0.12441034f, -0.02091796f, -0.11855936f, 
    0.03978412f, -0.32969993f, -0.04870817f, -0.12932031f, -0.07458387f, -0.07284837f, -0.02794004f, 0.03574248f, 
    0.07817474f, 0.07688005f, 0.16011609f, 0.27428982f, 0.15376098f, 0.10441927f, 0.01909450f, 0.12894098f, 
    -0.04102843f, -0.06528612f, 0.12088137f, -0.30118817f, 0.08003957f, -0.11305639f, -0.15079351f, -0.10709530f, 
    -0.08661179f, -0.00768099f, 0.11642951f, 0.21134745f, -0.02431397f, 0.06791888f, 0.06594650f, -0.12168191f, 
    -0.09767342f, 0.05728398f, -0.03008391f, 0.06893431f, -0.05944154f, 0.06991041f, 0.23510465f, 0.06202932f, 
    0.13045490f, 0.05140724f, 0.00766420f, -0.04241931f, 0.16334963f, 0.03923738f, 0.27622452f, 0.17370485f, 
    0.04955072f, -0.07670087f, -0.12386735f, -0.03264830f, 0.12146261f, -0.02690805f, -0.07842962f, 0.06929661f, 
    0.18199268f, 0.05977881f, -0.03377667f, 0.05824873f, 0.02957768f, -0.06530935f, -0.04241388f, 0.04928368f, 
    0.05233087f, 0.00743813f, 0.03833812f, -0.08800653f, 0.01700269f, -0.10509840f, 0.03697804f, -0.06375620f, 
    -0.06054299f, -0.09511488f, 0.03892281f, -0.01821836f, -0.05770253f, 0.01733964f, -0.09445596f, -0.02337802f, 
    -0.05944054f, 0.04851373f, -0.03083661f, 0.06734082f, -0.01034576f, 0.04689337f, -0.00303298f, -0.03917152f, 
    -0.06478525f, -0.05875902f, 0.02450605f, 0.00022397f, -0.06678955f, 0.00020872f, -0.01014174f, -0.00968970f, 
    -0.01661052f, 0.00496636f, -0.09159791f, 0.05814422f, 0.03610632f, -0.07110202f, -0.07574530f, -0.08104844f, 
    -0.02616049f, -0.02614162f, 0.04588996f, 0.03994755f, -0.06213341f, -0.00246459f, -0.03453460f, -0.08676694f, 
    -0.06159322f, -0.00352480f, -0.03562614f, -0.02561066f, -0.02411421f, -0.07338972f, 0.02447251f, -0.08506905f, 
    -0.07519476f, -0.03589802f, -0.00508554f, 0.00375759f, -0.04105670f, -0.07528110f, -0.07834238f, 0.01573262f, 
    -0.08394793f, -0.04007982f, 0.02118603f, 0.03008952f, -0.07426456f, 0.02593691f, 0.02391004f, -0.02557591f, 
    0.03130371f, -0.01810916f, 0.04883366f, 0.03280995f, -0.07426307f, 0.05052971f, 0.00337420f, -0.04253419f, 
    0.01772579f, -0.06818095f, -0.04495458f, -0.02141996f, -0.02169706f, 0.05937570f, -0.02653029f, -0.01110311f, 
    -0.03418791f, 0.03743445f, -0.05884442f, 0.02144259f, 0.03716375f, -0.09115040f, -0.04520281f, -0.04276165f, 
    -0.00097533f, 0.03085306f, -0.06778316f, -0.00148389f, 0.04831277f, 0.00915160f, -0.09186237f, -0.00629874f, 
    0.01211031f, -0.04238077f, -0.10332853f, -0.08866193f, -0.03171509f, -0.02629953f, -0.00104927f, -0.00763421f, 
    -0.04287640f, -0.06810977f, 0.02871696f, -0.04182205f, -0.07026185f, -0.04649266f, 0.01248502f, -0.05475543f, 
    0.03314319f, 0.03348467f, 0.03631417f, -0.10167399f, -0.00902570f, -0.00998622f, 0.00867653f, -0.08377733f, 
    0.04052559f, 0.02704977f, -0.09245928f, 0.03484321f, 0.03701242f, -0.02913666f, -0.00435082f, -0.01453589f, 
    0.01643896f, -0.09101251f, -0.07101173f, -0.02905779f, 0.05281223f, -0.00471601f, 0.05381032f, -0.01468837f, 
    -0.28106025f, -0.00444876f, -0.13391919f, 0.02740329f, -0.13076258f, -0.14568208f, 0.05861750f, 0.23335604f, 
    0.19675572f, 0.14518204f, 0.15140375f, 0.27469838f, 0.06768321f, -0.08689720f, 0.08470603f, -0.03386267f, 
    -0.04818514f, 0.06220061f, 0.34057885f, -0.03733961f, 0.14713903f, 0.10485372f, 0.07469273f, -0.06401882f, 
    0.06676459f, -0.07105275f, -0.02526497f, -0.22058867f, -0.40261161f, -0.14554539f, -0.10186420f, -0.06177802f, 
    0.02928267f, -0.12266389f, -0.11097653f, -0.07953624f, 0.20223324f, -0.06787646f, 0.09399709f, -0.07795871f, 
    0.15555626f, -0.04162888f, 0.12292534f, -0.00496384f, -0.03578474f, 0.04462813f, 0.06131415f, 0.09929141f, 
    0.00548792f, -0.14631379f, 0.10198718f, 0.12658390f, 0.21892063f, 0.05010362f, 0.09609129f, -0.04291218f, 
    0.09159444f, -0.28554606f, 0.06789038f, 0.14581391f, -0.18272814f, -0.00949491f, 0.19624117f, 0.02316845f, 
    0.22917268f, -0.33184147f, 0.00569517f, 0.24083495f, -0.03194392f, 0.03089769f, -0.00006293f, 0.02084250f, 
    -0.12854685f, 0.27416968f, -0.12194638f, -0.16875896f, -0.09087203f, -0.02645358f, -0.12282237f, -0.04493793f, 
    0.12511173f, -0.28327900f, 0.01545519f, 0.41938728f, -0.23244405f, 0.16828102f, -0.01966571f, 0.03068172f, 
    0.10125990f, 0.03473818f, -0.25441748f, -0.30074129f, 0.40927997f, 0.01713664f, 0.08832365f, -0.06684405f, 
    -0.04089008f, 0.00600943f, -0.14738651f, -0.55004168f, -0.28057036f, -0.16323628f, 0.04697241f, 0.01881607f, 
    -0.17993070f, -0.04682143f, -0.04217936f, 0.03755622f, -0.03860477f, -0.01622940f, -0.06216701f, 0.02688817f, 
    0.05564800f, 0.02765871f, 0.05418839f, 0.10947466f, -0.08806190f, -0.32015321f, -0.08163428f, -0.07568653f, 
    0.21809418f, 0.01296020f, 0.05124971f, -0.11722372f, 0.06477406f, -0.12571570f, -0.24724133f, -0.06931719f, 
    -0.02766147f, -0.00210639f, -0.08188885f, -0.19433863f, -0.07036097f, 0.01465024f, -0.11286614f, -0.09849128f, 
    0.00133007f, -0.40245017f, 0.33354530f, 0.16981946f, 0.13344768f, 0.18278374f, -0.09533290f, 0.02256213f, 
    0.30753377f, -0.08870831f, -0.26527119f, 0.00304864f, 0.01837891f, -0.15429358f, -0.15166771f, -0.01510236f, 
    -0.03053603f, -0.27055401f, 0.01085778f, 0.06278996f, 0.08289723f, 0.23017594f, 0.26812878f, -0.13155881f, 
    0.08832675f, -0.01345152f, 0.34262934f, 0.14498256f, -0.22069275f, -0.02156615f, -0.05180405f, -0.10831503f, 
    0.05461735f, 0.13277447f, -0.02907740f, -0.08892912f, 0.23063192f, -0.12182236f, -0.10201111f, -0.17733796f, 
    -0.12553960f, -0.19490968f, 0.03421556f, -0.04577088f, 0.16768003f, 0.07533635f, 0.04271537f, -0.07772093f, 
    -0.01320964f, 0.20983462f, -0.15876694f, -0.05280570f, 0.05981238f, -0.03995703f, 0.11497553f, -0.04816579f, 
    0.02484602f, 0.01396726f, 0.07320459f, 0.10911834f, 0.02871062f, 0.08149459f, -0.12980752f, -0.10946065f, 
    -0.15331025f, -0.00174574f, -0.13942847f, 0.06008370f, -0.13214880f, -0.03825630f, -0.06250225f, 0.19076353f, 
    0.08216434f, 0.37847519f, -0.14663187f, 0.02101520f, 0.01218837f, -0.02163489f, 0.00642782f, 0.04983386f, 
    -0.03449917f, -0.01985112f, -0.10883081f, 0.10117589f, 0.09007403f, 0.15816958f, -0.10202609f, -0.11032581f, 
    0.05992681f, -0.05025529f, -0.31127748f, 0.09011267f, -0.00070320f, -0.02353588f, 0.00688830f, 0.09160753f, 
    0.06641384f, -0.01390423f, 0.15932520f, -0.13343205f, 0.14988571f, -0.11158315f, 0.10029178f, -0.09033199f, 
    -0.02209999f, -0.02068669f, -0.05881843f, 0.26711461f, -0.11644934f, -0.07009431f, -0.30713743f, -0.00190722f, 
    -0.13349949f, -0.01911069f, 0.03050989f, 0.04067368f, -0.08851108f, 0.01307283f, -0.09172173f, 0.08783969f, 
    0.15600203f, -0.09085885f, -0.09743091f, 0.16198198f, -0.14810859f, -0.02689488f, 0.29262778f, 0.08674791f, 
    -0.11590824f, -0.03638757f, 0.18201268f, -0.09335383f, -0.08248693f, -0.04559030f, -0.31707907f, 0.01304810f, 
    -0.01909217f, -0.12807049f, -0.14731596f, -0.06753897f, -0.01754802f, -0.08506806f, -0.04823483f, 0.28774622f, 
    0.11011086f, 0.24344249f, 0.05803464f, 0.04315035f, 0.04108272f, 0.11982535f, -0.02871817f, -0.00777173f, 
    -0.09466223f, -0.14412810f, 0.05105394f, 0.04891875f, 0.11304814f, 0.07655478f, 0.02961676f, -0.01036872f, 
    -0.14502543f, 0.21388945f, 0.17158158f, -0.15506692f, 0.23411080f, -0.01750635f, 0.05038135f, -0.09760927f, 
    0.07205817f, 0.04434607f, -0.76853442f, -0.11395404f, -0.10389709f, 0.06150193f, 0.03937506f, 0.10231318f, 
    -0.05860545f, -0.04924170f, -0.09290996f, 0.13960637f, -0.07684949f, -0.18060397f, 0.06598834f, -0.08973268f, 
    0.04175458f, 0.12169112f, -0.01055763f, 0.06488484f, 0.05127788f, -0.25067705f, 0.02964261f, -0.12335533f, 
    -0.09103756f, -0.06228400f, -0.04884003f, -0.14569445f, 0.00987307f, 0.24808915f, -0.04322445f, 0.02026129f, 
    0.10107235f, 0.12478206f, 0.00131643f, 0.01996242f, -0.02359487f, -0.00156728f, 0.12495454f, -0.21420959f, 
    -0.03044220f, -0.02214139f, 0.04120115f, 0.18200591f, -0.10895886f, -0.06209543f, -0.09412422f, 0.22149758f, 
    0.31383714f, -0.16145702f, -0.18085681f, -0.06552351f, 0.04145700f, 0.10053229f, -0.00287853f, -0.02188916f, 
    0.33345702f, -0.11859718f, 0.06527045f, 0.16012695f, 0.04325695f, 0.16584995f, 0.18670873f, 0.11758743f, 
    0.06241228f, -0.16094394f, -0.18907133f, 0.07340460f, -0.11733820f, 0.04243990f, -0.07424073f, 0.13273656f, 
    -0.07176001f, 0.26357278f, 0.10474582f, 0.00946643f, -0.36121130f, 0.01054280f, 0.02175570f, 0.20568708f, 
    -0.03430593f, -0.03487914f, -0.16478720f, -0.19141388f, 0.27984661f, -0.11375355f, 0.08531664f, -0.17470121f, 
    -0.06102776f, 0.11190864f, 0.11462999f, 0.10175670f, 0.24999166f, -0.10006703f, -0.38315955f, -0.04941400f, 
    0.20177421f, 0.26621622f, 0.02514938f, 0.04467649f, -0.09617153f, -0.00303571f, -0.04484952f, 0.13302855f, 
    -0.05763467f, -0.07041400f, -0.05591070f, 0.08393874f, 0.18448143f, -0.07439239f, 0.05323187f, 0.00434398f, 
    0.04209741f, -0.14162119f, 0.06864988f, 0.20273840f, -0.03423870f, -0.00075410f, -0.10747662f, 0.00471390f, 
    0.17563275f, -0.07907300f, 0.01334061f, -0.05912787f, -0.04902473f, 0.09479003f, 0.07250267f, -0.09436470f, 
    -0.07406627f, -0.04504254f, -0.06161232f, -0.04120858f, -0.01596801f, 0.05271573f, -0.00061273f, -0.00099693f, 
    0.04955875f, -0.04378208f, -0.02714147f, 0.01968326f, -0.04014950f, -0.01430552f, 0.04895244f, -0.06071290f, 
    0.03483763f, 0.00573379f, -0.04719207f, -0.06389807f, 0.07583947f, -0.02263273f, -0.02680024f, -0.05019177f, 
    -0.01225193f, 0.00410448f, -0.06962291f, -0.05696265f, 0.07460679f, 0.00296307f, -0.00286954f, -0.03613862f, 
    0.02977739f, -0.00719355f, -0.05004618f, 0.00155582f, -0.00799593f, -0.03425384f, -0.00722767f, -0.05892601f, 
    -0.05815214f, 0.02776326f, -0.02610389f, -0.08588696f, -0.07927350f, 0.03601240f, -0.00368788f, -0.07138760f, 
    -0.08760689f, -0.05820414f, -0.08268145f, -0.08330679f, -0.01617197f, -0.06339844f, 0.01786863f, -0.00267967f, 
    0.05561507f, -0.08462616f, 0.04599508f, 0.00188123f, -0.08653562f, 0.02854046f, -0.07820343f, -0.01554907f, 
    0.00069609f, -0.02133311f, 0.02198338f, -0.08392794f, -0.03050720f, -0.02397956f, -0.04860436f, -0.02331886f, 
    -0.02842082f, -0.03934210f, -0.06264392f, 0.06993313f, 0.03974614f, -0.07746791f, -0.07675386f, -0.04868884f, 
    0.00848093f, 0.03346778f, -0.05896230f, -0.00285171f, -0.02703641f, -0.01244527f, 0.06659640f, -0.07049864f, 
    0.02785286f, -0.03516006f, -0.03494005f, -0.08804595f, -0.03687484f, -0.02722803f, -0.06785722f, 0.02228312f, 
    -0.06861319f, 0.02311845f, 0.05758214f, 0.01234182f, 0.00901635f, 0.07246891f, -0.06735521f, 0.02021025f, 
    0.00614367f, -0.02393767f, 0.07427450f, 0.07113729f, -0.05119199f, -0.06015257f, -0.03276592f, -0.04636464f, 
    0.03493315f, -0.05044625f, -0.01033386f, 0.04128485f, 0.05330445f, 0.05117658f, 0.04558220f, 0.01690752f, 
    -0.04389634f, 0.05847245f, 0.02625571f, 0.07432315f, -0.03671765f, -0.00298750f, 0.06600466f, -0.02545252f, 
    0.05995219f, -0.05838614f, 0.05239249f, -0.07083874f, -0.03832439f, 0.02829689f, -0.06091486f, -0.01816526f, 
    -0.02494023f, 0.06795272f, -0.08585420f, 0.02911586f, 0.07077472f, 0.06071077f, 0.01115901f, 0.05093497f, 
    -0.09736598f, 0.03392010f, -0.01107169f, 0.09357920f, 0.06913154f, -0.10356866f, 0.16012670f, 0.11069889f, 
    -0.05973848f, 0.23381346f, -0.10580654f, -0.04416809f, 0.02093585f, 0.23455100f, -0.05626166f, 0.06898622f, 
    0.13197687f, -0.01270052f, 0.05563701f, -0.35569990f, -0.20702280f, -0.09116412f, -0.02634338f, -0.09480900f, 
    -0.10687653f, -0.10898713f, -0.10444694f, -0.18668056f, 0.10509741f, 0.19791324f, -0.08788856f, -0.06048867f, 
    -0.04807083f, -0.12331768f, 0.02289843f, 0.05600182f, -0.09902252f, 0.14091994f, -0.03481522f, 0.01691211f, 
    0.03133786f, 0.05416721f, 0.16859263f, 0.13146055f, 0.02835501f, 0.32879955f, 0.08539339f, 0.02189522f, 
    0.13907926f, -0.05410625f, -0.11972350f, 0.06270789f, 0.05652926f, 0.08478907f, -0.00101795f, 0.13473751f, 
    -0.39014116f, 0.16894652f, -0.03984065f, -0.02605282f, 0.00065538f, 0.02865015f, 0.09043438f, -0.33221388f, 
    -0.16303933f, -0.02836508f, -0.10683572f, -0.22130443f, 0.04596853f, -0.04894807f, -0.10441178f, -0.08097915f, 
    0.26078472f, -0.09002298f, 0.03863393f, 0.07763778f, 0.00606325f, -0.05511434f, 0.05764943f, -0.06767803f, 
    0.08324763f, 0.03854430f, 0.43214375f, -0.14687866f, -0.09254615f, -0.11993945f, 0.00197000f, -0.13649230f, 
    -0.03963890f, 0.05774035f, 0.06515047f, 0.19529890f, -0.15545481f, 0.05638410f, -0.11816844f, 0.14631480f, 
    -0.08055323f, 0.02498501f, -0.03678902f, -0.08486567f, -0.21963781f, 0.27659029f, -0.04802740f, -0.02351083f, 
    0.06829562f, -0.02970427f, 0.04981408f, 0.06763315f, -0.24870323f, -0.18007024f, -0.19154957f, 0.12304297f, 
    0.27230433f, 0.13270697f, -0.10025344f, -0.04948996f, 0.14461780f, 0.07768087f, 0.21783179f, -0.02054921f, 
    0.02818824f, 0.15231280f, -0.04300182f, -0.02143823f, 0.10076835f, -0.03054558f, -0.02438412f, 0.19461179f, 
    -0.04896874f, 0.04328837f, 0.08170837f, 0.05109157f, 0.13909170f, -0.09052250f, 0.01165176f, -0.33703038f, 
    0.10313082f, 0.19822001f, 0.03316335f, -0.17899840f, 0.01293060f, -0.10162260f, -0.01415673f, -0.19520074f, 
    0.16920502f, -0.04859303f, 0.06808349f, 0.10253698f, -0.10210073f, -0.06990470f, -0.10811990f, -0.03784470f, 
    0.02044571f, 0.08576831f, 0.40410426f, 0.38213119f, -0.08060405f, 0.03173396f, -0.14277828f, 0.00143688f, 
    0.04562206f, -0.05677358f, 0.21367590f, -0.18071209f, -0.13774121f, -0.02823237f, -0.00212121f, 0.00308404f, 
    -0.08469135f, -0.04502269f, 0.00348018f, -0.07002492f, 0.08810066f, 0.01204258f, 0.14163259f, -0.13988805f, 
    -0.12291846f, 0.09392069f, -0.05690851f, -0.02736124f, -0.17956480f, -0.08664183f, -0.01164138f, 0.07127082f, 
    0.24554719f, -0.17041446f, -0.09045849f, 0.01242201f, -0.05238004f, 0.19315892f, -0.22596249f, 0.14696071f, 
    0.05511024f, 0.17485939f, 0.09195855f, 0.26934519f, -0.15195841f, 0.19838339f, 0.03074548f, 0.02873336f, 
    -0.12261534f, -0.03710077f, 0.22856086f, -0.02053132f, -0.09616604f, 0.09851688f, 0.04091446f, -0.06924569f, 
    -0.11738192f, -0.14890862f, 0.21604833f, 0.00217583f, -0.08204724f, -0.00629804f, -0.09998560f, 0.13146968f, 
    -0.02769957f, 0.25812331f, 0.20364641f, -0.10343596f, -0.08746739f, 0.00018221f, -0.19795817f, 0.04366074f, 
    -0.15598343f, -0.33744416f, -0.26093167f, -0.28691250f, -0.05159153f, -0.04788065f, 0.04778934f, -0.01521747f, 
    -0.04226216f, -0.05354812f, -0.05791901f, 0.21154281f, -0.10674328f, 0.03544413f, 0.06487152f, -0.05911374f, 
    -0.16894546f, 0.04413327f, 0.06122111f, 0.01965319f, -0.36036003f, 0.10914933f, 0.00147098f, 0.05248988f, 
    -0.05591328f, -0.03097219f, -0.01334211f, -0.19562112f, 0.00178357f, 0.09650062f, -0.10212444f, 0.12128849f, 
    0.11942292f, 0.10420663f, -0.05675177f, 0.16939676f, -0.12983793f, -0.59727156f, -0.32219082f, 0.16739240f, 
    0.19971725f, 0.08459796f, 0.28449157f, -0.15534583f, 0.01993284f, -0.08393668f, -0.07963035f, 0.00300871f, 
    0.05471401f, -0.11268737f, 0.10439034f, 0.08257857f, -0.00250227f, -0.16529283f, 0.03327687f, -0.17434953f, 
    0.04161553f, -0.43076670f, 0.03013601f, 0.01455921f, 0.15602173f, -0.09072353f, -0.26684347f, 0.00061608f, 
    -0.20687391f, 0.03081997f, -0.04816192f, -0.02720726f, -0.18503760f, 0.00460493f, 0.05411229f, 0.06576460f, 
    0.12324568f, 0.06024039f, 0.18000659f, -0.27860710f, 0.07405819f, 0.04843293f, -0.00407775f, -0.01006017f, 
    -0.00302509f, 0.13622178f, 0.16717076f, 0.04211475f, 0.30047810f, -0.17584781f, -0.11411852f, -0.02044845f, 
    -0.06098227f, 0.04610861f, -0.06712740f, 0.06444816f, -0.02953616f, 0.05589264f, 0.19051735f, 0.14997616f, 
    0.14378779f, -0.07213065f, -0.09198555f, -0.24028370f, 0.27982602f, 0.16015084f, 0.06589574f, 0.12678036f, 
    -0.02298009f, 0.19208138f, -0.02283720f, 0.06428602f, -0.14456120f, -0.03541970f, 0.05186966f, -0.16815192f, 
    -0.06067381f, 0.18137005f, 0.16121943f, 0.04389639f, 0.02855169f, -0.10429960f, 0.02346449f, 0.01062526f, 
    -0.04396428f, 0.04379290f, -0.12360740f, -0.07361065f, 0.22017907f, -0.02446159f, 0.11333884f, -0.16488297f, 
    -0.17211774f, 0.16914280f, 0.11656114f, 0.04234670f, -0.02755617f, -0.06649851f, 0.07475129f, -0.07349551f, 
    -0.08335540f, 0.15891366f, 0.08373050f, 0.07973208f, 0.01672610f, -0.14696763f, -0.07920393f, -0.00780497f, 
    0.06638910f, 0.20244409f, 0.09216283f, -0.12428777f, 0.25383091f, 0.17688793f, 0.28596544f, -0.10392708f, 
    0.09474534f, -0.08689258f, 0.14041471f, 0.14222281f, 0.16201618f, 0.15564084f, -0.10431302f, -0.00439921f, 
    -0.00117226f, 0.10182119f, 0.23527454f, -0.07524247f, -0.01774864f, -0.15352684f, 0.03294669f, 0.09443112f, 
    -0.00536386f, 0.06331467f, 0.00699233f, -0.31445050f, -0.12505059f, 0.30991197f, -0.13475704f, 0.07516567f, 
    -0.10321680f, -0.12430482f, 0.01464684f, -0.00752462f, 0.17735215f, -0.07269267f, -0.03455486f, -0.11813403f, 
    0.42135438f, -0.02025825f, -0.06173853f, -0.08436771f, -0.01369714f, 0.01159308f, -0.13420554f, -0.18776928f, 
    -0.20283109f, -0.14632231f, 0.09797329f, 0.09490795f, -0.14167707f, -0.15455097f, 0.03435216f, 0.05590829f, 
    -0.08661930f, 0.13847031f, -0.13368222f, 0.11866225f, 0.04081356f, -0.04717842f, 0.09162059f, 0.03685754f, 
    -0.06337555f, -0.01875894f, -0.00458294f, 0.05864010f, 0.01177544f, -0.01364272f, -0.07687642f, 0.05014983f, 
    -0.09801754f, 0.01646717f, -0.04424569f, 0.03078420f, 0.03351898f, 0.02358215f, 0.03746299f, -0.01619604f, 
    -0.00394773f, -0.00798637f, -0.09362075f, -0.08347321f, 0.04606576f, -0.10450763f, -0.08400374f, -0.03607591f, 
    -0.06108064f, -0.07711841f, 0.05595081f, -0.04822987f, 0.03000819f, 0.02783387f, -0.07458719f, -0.08313906f, 
    -0.01622609f, 0.06531405f, -0.05663973f, -0.07813896f, 0.03750280f, -0.06800784f, -0.07267812f, -0.02385547f, 
    -0.06377787f, -0.03940383f, -0.00899193f, 0.01518359f, -0.02286205f, -0.04078149f, 0.04354697f, -0.07525588f, 
    -0.07248152f, -0.07699163f, 0.04816166f, 0.06211785f, 0.02540857f, -0.03219452f, -0.04801376f, -0.08700486f, 
    0.01746864f, 0.02390604f, -0.05348211f, -0.00878547f, -0.06752890f, -0.07046460f, -0.08162650f, -0.09545596f, 
    -0.09026041f, 0.00421679f, -0.09202774f, -0.03576608f, -0.09301959f, -0.00972666f, -0.01053630f, -0.10684060f, 
    -0.02211833f, -0.01518945f, -0.06250238f, -0.07479447f, -0.00245701f, -0.02149944f, 0.05550216f, 0.00394010f, 
    0.04080967f, 0.05647038f, 0.06290255f, -0.01877351f, -0.03066923f, 0.01561000f, 0.06129607f, 0.03184255f, 
    -0.08577280f, 0.05883019f, 0.00640858f, -0.05967113f, -0.00594830f, -0.05961947f, -0.06897886f, 0.01070417f, 
    -0.02814157f, -0.07775395f, -0.09505041f, -0.03859282f, -0.04812922f, 0.01246703f, 0.02771777f, 0.07031912f, 
    -0.06788826f, 0.05975903f, 0.03847851f, 0.02532813f, -0.09491628f, -0.04446773f, -0.06813147f, 0.04526627f, 
    0.03280478f, -0.07090460f, -0.04826428f, 0.06475630f, -0.01553412f, -0.06358820f, -0.06040843f, -0.05266792f, 
    0.04362965f, -0.07250240f, -0.08153205f, -0.08321362f, 0.01638111f, -0.01157882f, 0.04902527f, -0.05845476f, 
    -0.10634096f, -0.04250178f, 0.04347574f, -0.00181512f, 0.04167303f, -0.10957737f, -0.02717493f, -0.04379633f, 
    -0.02957745f, 0.03945501f, -0.03644558f, 0.04578744f, -0.03124631f, 0.02168756f, 0.00325409f, 0.01351710f, 
    0.26504371f, 0.16850886f, 0.04232643f, -0.07300805f, 0.07919865f, -0.08166540f, -0.00719809f, 0.20801340f, 
    -0.09487262f, -0.07309958f, 0.19363089f, 0.22301483f, 0.15499642f, 0.08211865f, -0.05479426f, 0.23865558f, 
    0.00249115f, -0.17464608f, 0.34327739f, 0.04092602f, -0.08201293f, -0.03027320f, -0.03264471f, -0.06521255f, 
    0.13310036f, -0.02932168f, 0.07388832f, -0.05227181f, -0.31235373f, -0.04851786f, -0.22973019f, 0.03107171f, 
    -0.09349817f, -0.09250093f, 0.09496333f, -0.01581164f, -0.35553575f, 0.08851246f, 0.10261843f, 0.04360523f, 
    -0.00889450f, -0.04936539f, 0.04144264f, 0.08151805f, -0.14303470f, 0.12119420f, -0.06782679f, -0.06759653f, 
    -0.09725992f, 0.02309662f, 0.21328120f, -0.16317134f, -0.11967078f, 0.17341632f, -0.23513582f, 0.04216872f, 
    0.02716701f, 0.05964446f, 0.15203625f, -0.16766562f, -0.11168940f, 0.00615601f, 0.05259092f, -0.04926229f, 
    -0.33368564f, 0.16776344f, -0.05344776f, -0.15766479f, -0.06159529f, -0.03433011f, -0.00359696f, 0.02403484f, 
    -0.52016419f, 0.23785177f, 0.12087258f, -0.10396742f, 0.02421609f, 0.22057696f, -0.02209651f, 0.14568050f, 
    -0.06686755f, -0.24389565f, -0.22251841f, -0.44117218f, -0.05868514f, -0.13910554f, 0.15092875f, 0.03438821f, 
    -0.00212900f, -0.01418361f, 0.21138562f, -0.11646242f, 0.30303508f, -0.02319246f, 0.06733997f, -0.05532151f, 
    0.04931995f, -0.10641101f, -0.02813545f, -0.05298473f, -0.10485031f, -0.08689696f, -0.03807721f, -0.05877984f, 
    -0.12811989f, -0.00407438f, 0.01639308f, 0.04412698f, 0.15104879f, 0.01497498f, 0.19493692f, -0.02863763f, 
    -0.06609300f, -0.08602337f, -0.05809829f, 0.12894765f, 0.11113669f, 0.09501319f, 0.00242911f, 0.06647920f, 
    0.03617549f, 0.07247239f, 0.03883196f, -0.01693724f, 0.01563333f, -0.03505038f, 0.16964819f, 0.10716034f, 
    0.05044435f, 0.17188701f, 0.02929615f, -0.00914460f, 0.08604612f, -0.06284520f, 0.21459813f, -0.11365824f, 
    -0.27137434f, 0.09034897f, -0.02676272f, 0.12780151f, -0.02407398f, -0.07264007f, -0.25374508f, 0.12210517f, 
    -0.07614281f, 0.00288293f, -0.05117513f, -0.09214912f, 0.04165088f, -0.10956822f, -0.03748957f, -0.05740381f, 
    0.02182254f, 0.09159920f, -0.05404248f, 0.01254276f, -0.05365494f, 0.04530220f, -0.01584556f, -0.01418817f, 
    -0.06690470f, -0.04952069f, 0.02739975f, -0.04034142f, -0.08320947f, -0.06457610f, 0.00977859f, -0.02401289f, 
    -0.08840391f, -0.04273253f, 0.05002876f, -0.01654266f, -0.05667175f, 0.03212693f, -0.02622803f, 0.00413835f, 
    -0.01921808f, -0.01996754f, -0.07496851f, -0.05096481f, -0.01040210f, 0.02765889f, 0.02403538f, -0.08758747f, 
    0.00058929f, 0.03946162f, -0.02608606f, 0.01955870f, -0.05149226f, -0.04390612f, -0.01024244f, 0.01203636f, 
    0.02955181f, 0.04466392f, 0.00396447f, -0.06441456f, -0.04865786f, -0.05220953f, -0.06195102f, 0.00331385f, 
    -0.03140412f, -0.02731023f, 0.03030998f, -0.08988738f, 0.01850078f, -0.05763168f, 0.08352502f, -0.05845778f, 
    -0.02794656f, -0.00951494f, -0.03436585f, -0.00749413f, 0.05878512f, 0.00787811f, -0.02575186f, 0.05394466f, 
    -0.06967852f, 0.04397018f, -0.03930856f, -0.03588773f, 0.04962602f, -0.07367816f, -0.03365871f, -0.01348053f, 
    -0.09677243f, -0.09045893f, -0.06289581f, -0.02441482f, -0.08035998f, 0.01835120f, -0.06329011f, -0.01121404f, 
    0.01401257f, 0.00259849f, 0.07231245f, -0.05197769f, 0.06134547f, -0.00223536f, -0.01355710f, 0.00074826f, 
    -0.09261014f, -0.06389868f, 0.07714013f, 0.03702598f, 0.00049151f, -0.01956557f, 0.06537994f, -0.12833780f, 
    -0.02132062f, 0.02424147f, 0.01138380f, -0.07727327f, -0.03871049f, -0.02787594f, 0.05827769f, -0.08362115f, 
    0.03709542f, -0.03306765f, 0.03644149f, 0.06498524f, 0.02251312f, 0.04226167f, -0.04032423f, -0.05632022f, 
    0.00201044f, -0.06267737f, -0.09359890f, -0.04856393f, -0.08832194f, -0.04717635f, -0.01677383f, 0.02932728f, 
    -0.08906787f, 0.04309916f, -0.11949568f, -0.01901786f, 0.00899416f, -0.00230381f, -0.03186523f, -0.00094552f, 
    -0.10253642f, -0.01927496f, -0.08260170f, -0.00570107f, -0.04723245f, 0.02656430f, 0.00457794f, 0.09047262f, 
    0.19390249f, -0.09300286f, 0.12585953f, 0.10545895f, 0.05230205f, 0.11363597f, -0.05518048f, -0.05352470f, 
    -0.01365730f, 0.12093019f, -0.09028656f, 0.04996051f, 0.17748164f, 0.13234471f, 0.06983322f, -0.04691885f, 
    -0.00789248f, 0.04902357f, 0.04401731f, -0.03525922f, 0.08490539f, -0.08238843f, -0.16002333f, -0.07206813f, 
    -0.10555801f, -0.02796944f, 0.07924823f, 0.16201302f, -0.20493349f, -0.02877213f, -0.07612227f, 0.04543361f, 
    -0.16153324f, 0.13642922f, 0.05327319f, -0.07091896f, -0.03910815f, -0.05030643f, 0.00389589f, 0.19276485f, 
    0.01450301f, 0.10209503f, -0.11532543f, -0.11298833f, -0.12326350f, -0.42460650f, -0.16629647f, 0.05316358f, 
    -0.03001684f, 0.04937410f, 0.14763388f, 0.17237896f, 0.29247686f, -0.01015683f, 0.33239681f, 0.18068707f, 
    0.00365986f, 0.16437502f, -0.04408240f, 0.04571152f, 0.11998444f, 0.10545301f, 0.00671547f, 0.00769698f, 
    0.16487390f, -0.02090438f, -0.27434903f, -0.09126293f, -0.11624773f, -0.03269593f, 0.07626567f, -0.08555739f, 
    0.15687071f, -0.15865090f, -0.29405242f, 0.11302806f, -0.00443892f, -0.00141010f, 0.06437859f, 0.12213286f, 
    0.02545455f, -0.36184943f, -0.26234522f, -0.04351181f, 0.09071104f, 0.03515947f, -0.04897653f, -0.04920379f, 
    0.01235686f, -0.10089259f, 0.05421012f, -0.03832609f, -0.27884871f, -0.03514652f, 0.05800097f, -0.16877158f, 
    0.02415559f, 0.01575292f, -0.02858699f, 0.03983611f, 0.17870624f, -0.04071750f, -0.11860015f, -0.27960208f, 
    -0.00343980f, -0.02597509f, 0.19999024f, -0.06683838f, 0.29514483f, 0.18789630f, -0.01220245f, 0.08853543f, 
    0.22587663f, -0.14953132f, -0.15199427f, -0.08514593f, 0.06477485f, -0.17337057f, -0.23909429f, -0.21364646f, 
    0.21950854f, -0.09028063f, -0.00077756f, -0.19111983f, 0.01993566f, 0.05387507f, -0.17637128f, -0.01261790f, 
    -0.00854142f, 0.11813775f, -0.07100382f, -0.28086647f, 0.19168851f, 0.01882239f, 0.09351735f, 0.14135830f, 
    -0.20097992f, -0.13496411f, -0.17784971f, 0.04423862f, -0.05651433f, -0.14813274f, 0.04130755f, 0.14486651f, 
    -0.04873148f, 0.03539663f, 0.05047391f, -0.06683304f, -0.02325689f, -0.06089437f, 0.00285037f, -0.08650757f, 
    -0.05824943f, -0.04429049f, -0.01834948f, 0.06362607f, -0.06142609f, -0.04337330f, 0.04062936f, -0.00246808f, 
    0.05922617f, 0.00655944f, -0.05677174f, -0.04459400f, -0.04726546f, -0.06716607f, 0.06119553f, 0.03777340f, 
    0.00253197f, 0.03947541f, 0.04017675f, -0.07445215f, -0.06219804f, -0.06715186f, 0.01656732f, -0.01050782f, 
    0.01692300f, -0.00903672f, -0.03667489f, -0.02445087f, -0.08299341f, 0.03070614f, -0.01822045f, -0.07906079f, 
    -0.05978946f, -0.00243035f, -0.00743216f, 0.01885244f, -0.06926180f, -0.05975527f, -0.06343386f, -0.06591781f, 
    -0.07604024f, 0.00771921f, -0.00421681f, 0.06944980f, -0.01142155f, 0.01523034f, 0.07383469f, -0.00910941f, 
    0.03288160f, -0.05165405f, 0.03032473f, -0.06521465f, -0.02774935f, -0.00234637f, 0.04995261f, -0.02497952f, 
    0.04556820f, -0.08173075f, 0.05452755f, -0.02333701f, -0.01637151f, 0.03140878f, -0.03774339f, -0.00769899f, 
    -0.03705403f, -0.03606018f, -0.02633162f, -0.07971525f, -0.01656247f, -0.02024293f, -0.05397616f, 0.07164582f, 
    -0.03742905f, -0.02392686f, -0.05898717f, -0.05162966f, -0.01601661f, -0.06944808f, 0.00608857f, 0.05448547f, 
    0.04757197f, -0.01880868f, 0.02614687f, 0.07552505f, -0.02406695f, 0.05237482f, -0.01156850f, -0.03144372f, 
    0.01558225f, 0.06370647f, -0.00343511f, 0.07501172f, -0.01633197f, -0.01035528f, -0.06312437f, -0.04917833f, 
    -0.03665858f, 0.00018338f, 0.02716056f, 0.00904286f, 0.04598869f, -0.07745148f, 0.07088491f, -0.03995325f, 
    -0.04832076f, -0.01749728f, -0.06718038f, 0.02398769f, 0.03609284f, 0.00132514f, -0.03167624f, 0.01737531f, 
    0.06989536f, 0.00237663f, -0.05765076f, -0.07875565f, -0.05430217f, -0.03550332f, -0.08628102f, 0.04263208f, 
    -0.03826920f, 0.07208463f, -0.04471385f, -0.04398522f, -0.00994275f, 0.04588013f, -0.07663435f, 0.02374895f, 
    -0.00782099f, -0.00429663f, -0.07768803f, 0.06006360f, -0.07463003f, 0.06043194f, 0.03678994f, -0.08184745f, 
    -0.02983290f, -0.01995843f, -0.01756430f, -0.07756720f, -0.02318976f, -0.07179517f, 0.00955462f, -0.04894924f, 
    -0.08650467f, 0.04352267f, -0.06476935f, -0.08061011f, 0.03331813f, -0.00747241f, -0.00000555f, 0.07354867f, 
    0.06622268f, -0.00807491f, 0.01399314f, -0.03169926f, -0.04100759f, -0.01078697f, 0.01008265f, -0.07787208f, 
    0.05453739f, -0.00000674f, -0.06659408f, 0.00373814f, 0.01555283f, -0.08213863f, -0.00786628f, -0.05473002f, 
    0.00533075f, -0.05714465f, 0.07158310f, 0.02797016f, 0.01307438f, 0.04420121f, 0.06763155f, 0.02949853f, 
    -0.07097098f, -0.06152175f, -0.02645868f, 0.03534634f, -0.06022190f, 0.05003348f, 0.05800208f, 0.01153977f, 
    -0.03218046f, 0.05894395f, -0.04412182f, -0.04866983f, 0.04427734f, -0.02220476f, 0.04125988f, -0.02859829f, 
    -0.08218589f, 0.07356636f, -0.07400185f, 0.01824698f, 0.02377824f, -0.07581572f, -0.01102895f, -0.05544110f, 
    -0.08470585f, 0.06345581f, 0.04311299f, 0.03569744f, 0.00219238f, -0.08602571f, 0.06075811f, -0.02087896f, 
    -0.00851655f, -0.06030272f, -0.08397745f, -0.03183531f, -0.03283364f, -0.01238807f, -0.05405086f, 0.00988755f, 
    0.04325793f, 0.00819650f, 0.02988045f, 0.06112809f, 0.00913035f, -0.00164163f, -0.05216777f, -0.02844936f, 
    -0.06062823f, 0.04512183f, 0.05823915f, 0.05313491f, 0.05838203f, -0.05200868f, -0.02014158f, 0.02346885f, 
    -0.05670729f, 0.04741934f, -0.06580942f, -0.02165220f, 0.06917313f, -0.00470919f, -0.08054803f, -0.03575500f, 
    -0.07226514f, -0.06693354f, 0.04115018f, -0.08716611f, 0.04000248f, -0.04106283f, 0.02733687f, -0.03835677f, 
    -0.04164070f, 0.01017307f, 0.01008822f, 0.04691020f, 0.06679108f, -0.08470932f, 0.01768097f, -0.06945709f, 
    -0.06024775f, 0.04670714f, -0.06070361f, -0.03872995f, -0.06044962f, -0.02872470f, -0.04274169f, -0.04284139f, 
    -0.09069839f, -0.02588112f, -0.06922104f, -0.05925211f, 0.02570922f, 0.07150256f, -0.08045213f, -0.05872394f, 
    -0.08455874f, 0.01600951f, 0.05090213f, -0.08709214f, -0.08247062f, 0.01815574f, 0.02019239f, -0.01769085f, 
    0.29174852f, 0.12496496f, -0.11458077f, 0.08352523f, 0.04392528f, -0.00769781f, -0.00920713f, 0.13737783f, 
    0.21742748f, -0.03190527f, 0.30546600f, 0.14626831f, 0.16389540f, 0.17620558f, -0.07951190f, 0.02934808f, 
    0.13982745f, -0.03502789f, -0.58000773f, -0.11786966f, 0.02891399f, 0.11300088f, -0.03909649f, 0.17021693f, 
    0.11983742f, -0.00074348f, 0.03513915f, -0.13255499f, 0.06238131f, -0.09450603f, -0.12145308f, -0.20311172f, 
    -0.00900090f, 0.02420460f, -0.23014791f, 0.11911571f, 0.58066106f, 0.14570482f, -0.05775524f, -0.08637593f, 
    0.06980197f, -0.01558983f, -0.15392751f, -0.04667637f, 0.12976550f, 0.25295949f, -0.03126985f, 0.01948295f, 
    -0.04711156f, -0.02440769f, -0.06173553f, 0.11130930f, 0.08677471f, -0.04590808f, -0.02283799f, 0.22312942f, 
    -0.09018101f, -0.11943392f, 0.05954530f, 0.06585640f, 0.01590564f, -0.02850151f, 0.06846681f, -1.12639940f, 
    -0.42402914f, 0.12404753f, -0.05811045f, 0.07249033f, 0.02613719f, 0.03327960f, -0.08848128f, 0.09766126f, 
    -0.03578280f, 0.17092778f, 0.09669391f, -0.07122774f, -0.07462873f, 0.10207207f, -0.05307775f, 0.00763748f, 
    0.07608793f, -0.14513712f, -0.08120845f, -0.01607797f, -0.00126444f, -0.00043277f, -0.02330259f, 0.10123048f, 
    -0.07961468f, 0.08758158f, 0.01088243f, -0.04283300f, 0.03646535f, -0.02593117f, -0.05588853f, -0.10827623f, 
    -0.04939378f, 0.13485557f, -0.12446262f, -0.36335832f, -0.37568718f, -0.26841429f, 0.10310341f, 0.04525053f, 
    0.08540750f, 0.10188681f, 0.03292659f, 0.07480043f, -0.09374911f, 0.17433351f, -0.22277685f, 0.14735016f, 
    0.15765907f, -0.10029986f, 0.05878161f, -0.00070214f, -0.02658108f, -0.00771165f, -0.07159422f, 0.27367449f, 
    -0.02346408f, -0.02830677f, -0.08101779f, -0.11806948f, 0.00257461f, -0.15180477f, 0.07876588f, -0.24135453f, 
    -0.15488656f, 0.03102037f, -0.03003164f, -0.04424444f, 0.05337194f, 0.06257773f, 0.18618080f, -0.19300766f, 
    -0.37369716f, 0.08341412f, 0.04097895f, 0.27034256f, -0.07468239f, 0.01844506f, -0.26704729f, -0.10596599f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.04518594f, -0.07611980f, 0.11693066f, -0.07035462f, 0.12939137f, -0.04694476f, 0.12059152f, 0.08691119f, 
    0.15132663f, -0.01152280f, 0.16391122f, 0.00558058f, 0.03267158f, -0.03509652f, 0.01377391f, 0.13219891f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.08036818f, 0.09920931f, 0.16029888f, 0.13930757f, 0.18897580f, -0.06984669f, -0.28075793f, -0.24381866f, 
    0.28729904f, -0.09081613f, -0.09300343f, -0.18972948f, 0.09323727f, 0.06213951f, 0.20982382f, -0.23433504f, 
    0.41451332f, 0.20856036f, -0.04066422f, 0.04632978f, 0.17302760f, -0.02548665f, -0.10207713f, -0.53536791f, 
    -0.10743806f, 0.23230273f, -0.23068856f, -0.23524123f, -0.04763439f, -0.11582798f, -0.12997849f, 0.33195478f, 
    -0.22064790f, 0.23617423f, -0.12473527f, 0.14720893f, -0.13010633f, 0.20274362f, -0.05669338f, 0.05952230f, 
    -0.20634365f, -0.21323976f, -0.16037646f, 0.03589588f, 0.10795179f, 0.05703732f, 0.02183405f, 0.01417848f, 
    -0.03119484f, 0.17472593f, -0.07372849f, -0.05178352f, -0.05791210f, -0.22438723f, -0.31612542f, 0.24089414f, 
    0.30967006f, -0.22207491f, 0.25139856f, 0.00941506f, 0.45120174f, 0.15712938f, -0.23186477f, -0.09231599f, 
    0.30534849f, -0.02152586f, 0.40472540f, -0.11548191f, 0.27201205f, -0.10066035f, 0.28822985f, -0.29479739f, 
    -0.34059551f, 0.12122406f, -0.13307317f, -0.18109673f, -0.14432651f, -0.15564531f, 0.10550907f, 0.01109352f, 
    0.25966343f, 0.19564693f, -0.42941573f, 0.52017158f, 0.06259543f, 0.15671843f, -0.21708944f, -0.01536202f, 
    0.23094296f, 0.07816853f, -0.32277426f, 0.11904147f, -0.35594508f, 0.00994229f, -0.10214189f, -0.26358497f, 
    -0.61955982f, 0.04662292f, 0.26548320f, 0.13948709f, 0.09778229f, 0.00053199f, -0.46371880f, 0.04448314f, 
    0.29932851f, -0.05673635f, -0.05448304f, 0.00278116f, 0.36020496f, -0.05471926f, 0.11783881f, 0.13385759f, 
    0.25449157f, -0.21301045f, 0.03170854f, 0.25408566f, 0.16962026f, 0.05838277f, -0.43468252f, -0.20661514f, 
    0.14195734f, -0.21318188f, 0.31192574f, -0.00519353f, -0.28691643f, 0.14980967f, 0.18276238f, -0.14028867f, 
    0.24901570f, 0.17766431f, 0.56935459f, 0.23859249f, -0.20771131f, 0.09798035f, -0.31520858f, -0.32209489f, 
    0.06044846f, -0.00841277f, -0.25358599f, 0.21804194f, 0.02387720f, -0.08515083f, -0.03449233f, 0.10582221f, 
    -0.10924458f, -0.10971239f, -0.31383979f, 0.24116492f, -0.07071018f, -0.07815024f, 0.12269544f, -0.31078583f, 
    0.36509842f, -0.16808851f, 0.40912125f, 0.06660075f, -0.57322609f, 0.12366746f, -0.25550199f, -0.07502780f, 
    0.25058639f, -0.22120908f, 0.28632545f, -0.29085824f, -0.28758273f, 0.10801095f, -0.06425469f, -0.00799193f, 
    0.18165945f, 0.23059252f, -0.09206133f, 0.07635650f, 0.44595760f, 0.19374335f, -0.18812370f, -0.22051582f, 
    -0.02775955f, -0.22268368f, -0.15563667f, 0.28182462f, -0.12742421f, 0.00618938f, 0.10859551f, -0.29831836f, 
    0.38260689f, -0.21372670f, 0.27783114f, 0.00854531f, 0.12625346f, 0.22557335f, -0.10608263f, -0.10629731f, 
    0.25751099f, -0.13124759f, -0.61910236f, 0.17477287f, -0.17063086f, 0.03342943f, -0.43137044f, 0.13183920f, 
    -0.03256315f, -0.03634510f, 0.11940406f, 0.03685297f, 0.13030677f, 0.19063687f, -0.12443554f, 0.11601435f, 
    -0.09216034f, 0.19656938f, 0.22937737f, -0.39318204f, 0.26821324f, -0.03790392f, 0.03547410f, 0.24550721f, 
    -0.10186449f, 0.10869652f, 0.39125609f, -0.06041434f, 0.23577356f, -0.17031957f, 0.23122956f, -0.01149172f, 
    -0.38141900f, 0.01645223f, 0.07563411f, -0.08352205f, 0.07992098f, 0.15587878f, -0.14654474f, -0.24280624f, 
    0.09273888f, 0.01132008f, 0.30660304f, 0.18102051f, -0.00637705f, -0.21128038f, 0.07560335f, 0.32507217f, 
    0.00866820f, -0.02492466f, -0.60530484f, -0.09001449f, 0.35394806f, 0.06279221f, 0.29535440f, -0.08635809f, 
    0.19842380f, 0.16457197f, 0.26395068f, 0.05306805f, 0.14224984f, 0.21406798f, -0.08575201f, -0.03146216f, 
    -0.18453108f, -0.06325853f, 0.04137409f, -0.27155173f, 0.25017139f, 0.17133906f, 0.33722374f, 0.35388947f, 
    0.10103147f, -0.01784217f, 0.16950540f, 0.20957470f, 0.04631346f, -0.06223839f, -0.07638822f, -0.01771893f, 
    0.15325187f, 0.19934264f, -0.05734311f, -0.02230250f, -0.34797150f, -0.06745553f, -0.59003079f, 0.60851645f, 
    0.09194116f, -0.12009292f, -0.20391731f, 0.17201538f, 0.14053462f, 0.12545003f, -0.13082869f, 0.37808618f, 
    -0.19897215f, 0.08678390f, -0.31480575f, 0.13355184f, 0.12847662f, 0.11927450f, 0.14557320f, 0.14195830f, 
    0.39840400f, 0.08149424f, -0.59922612f, -0.20011370f, 0.20309563f, 0.03766218f, 0.18710092f, -0.01471858f, 
    0.35314703f, 0.27352712f, 0.32147431f, -0.39245328f, 0.08438332f, 0.00720429f, 0.14546932f, -0.22359081f, 
    0.30092704f, -0.04723100f, -0.32646701f, -0.04285674f, 0.20219722f, 0.08315003f, 0.08983076f, -0.23096615f, 
    0.10967745f, -0.10315908f, -0.20185809f, -0.25561273f, -0.25584671f, -0.20175360f, -0.24637759f, -0.07493868f, 
    0.28796831f, -0.13838020f, 0.19730741f, 0.18271391f, 0.48464456f, -0.24375060f, -0.23648854f, 0.40625635f, 
    -0.22936821f, -0.18041393f, -0.19584802f, -0.00298929f, -0.17838839f, 0.23888281f, -0.09362042f, -0.24779740f, 
    0.03360355f, -0.10860407f, 0.11235869f, -0.22239536f, -0.07598123f, 0.23738265f, -0.24836585f, 0.03245899f, 
    0.16478631f, 0.03264352f, -0.39747998f, -0.06686805f, 0.23396158f, 0.24193110f, -0.12276863f, 0.30504254f, 
    0.10655645f, 0.19614770f, 0.34143236f, 0.23542452f, 0.58529419f, 0.14387156f, -0.22874056f, -0.13740821f, 
    -0.15777563f, -0.02855456f, 0.23702732f, -0.07904726f, 0.42091393f, 0.05952223f, 0.20052795f, 0.07658435f, 
    -0.08516114f, 0.14679264f, -0.27613130f, 0.12764129f, -0.17744796f, -0.09679637f, -0.18651874f, 0.01796505f, 
    -0.32248476f, -0.21033269f, 0.21032953f, -0.31435451f, -0.22421815f, -0.17887411f, 0.35018757f, -0.60384721f, 
    0.08696125f, -0.20802204f, -0.00506174f, 0.07423436f, -0.03698108f, 0.16410094f, -0.21627918f, 0.10651223f, 
    -0.06968209f, -0.08980575f, -0.02248052f, -0.03947976f, -0.04429707f, -0.23161453f, -0.03524244f, -0.14560068f, 
    0.03596792f, -0.01855177f, -0.22547039f, -0.10763204f, -0.24296579f, 0.16555780f, 0.03615862f, -0.14557612f, 
    0.16254213f, -0.19010355f, -0.58455110f, 0.04385823f, 0.28199100f, 0.20142195f, 0.00205385f, 0.29743859f, 
    0.28813940f, -0.18639472f, -0.25560781f, -0.23725607f, 0.22544658f, 0.12219840f, 0.07134479f, -0.56537718f, 
    0.39488995f, -0.06086959f, 0.35302895f, 0.10139219f, 0.15443011f, 0.06769744f, -0.13356391f, -0.24231401f, 
    -0.02254887f, -0.02039539f, 0.12452237f, -0.17766628f, 0.06678455f, 0.04740390f, -0.24860832f, -0.28808990f, 
    -0.33830914f, -0.06788746f, 0.02187113f, 0.30136746f, -0.14357445f, 0.11784974f, 0.37384418f, 0.17172658f, 
    0.12958619f, -0.17779584f, 0.07722507f, -0.14410086f, 0.23164827f, -0.19282061f, 0.08470053f, -0.06920689f, 
    0.33429667f, -0.12436324f, -0.30092931f, 0.29573846f, 0.00728536f, -0.09894437f, -0.30794823f, -0.24386351f, 
    0.10482521f, -0.21177904f, 0.16518840f, 0.05393595f, 0.13499673f, 0.20053235f, -0.24322119f, 0.35314935f, 
    0.01266955f, -0.23771742f, 0.27674079f, -0.00918948f, 0.00008120f, -0.17553131f, 0.06701516f, 0.49329844f, 
    -0.26102597f, 0.16797748f, 0.48382300f, -0.04540001f, 0.36965093f, 0.04220080f, -0.19123614f, 0.16503592f, 
    -0.05975485f, -0.20568316f, 0.35272619f, 0.44582757f, 0.06263855f, -0.14897916f, -0.13575134f, -0.24879247f, 
    0.02202012f, -0.19632860f, -0.02471144f, -0.02182929f, 0.23756854f, 0.24879062f, 0.16902716f, -0.15332730f, 
    0.27876565f, -0.16173670f, -0.46046400f, 0.10580834f, 0.34779000f, 0.22575521f, 0.03624241f, -0.26773971f, 
    -0.01708235f, 0.12837115f, -0.44292837f, -0.15095714f, -0.13798878f, 0.05988520f, -0.17597066f, 0.14707041f, 
    0.24903099f, 0.23017605f, 0.22411235f, 0.32382223f, -0.11940943f, 0.15048011f, -0.07839134f, -0.24392129f, 
    -0.03256765f, -0.02365422f, 0.33319142f, 0.25798544f, 0.43421453f, 0.22277561f, -0.08629042f, -0.07318761f, 
    -0.40165055f, 0.16097870f, -0.01197409f, 0.30053633f, -0.31038344f, 0.19550459f, -0.19275802f, 0.03323524f, 
    0.24256827f, 0.17424554f, 0.35226887f, 0.16711695f, 0.06461533f, 0.07314047f, 0.10360526f, 0.20436133f, 
    -0.25069803f, 0.16695216f, 0.00750919f, 0.09778429f, -0.01393627f, 0.12922040f, -0.14843532f, -0.15949337f, 
    -0.10848597f, -0.08942547f, 0.17796351f, 0.00925085f, -0.10863038f, -0.18173170f, 0.06402443f, -0.17619376f, 
    -0.13692370f, -0.20686437f, 0.36457473f, -0.26838133f, 0.10592997f, 0.03166877f, -0.21058571f, -0.02589546f, 
    -0.09181727f, -0.00618942f, 0.13115536f, -0.18403897f, 0.19814509f, 0.04898958f, -0.20822489f, 0.12873219f, 
    -0.06082032f, 0.06295671f, 0.35210851f, -0.25298122f, 0.19723698f, -0.11449118f, 0.26815951f, 0.56633371f, 
    -0.09990251f, 0.04693693f, -0.07958288f, 0.17631540f, -0.07277625f, 0.17825359f, -0.23289588f, 0.39962628f, 
    -0.18025248f, 0.12011653f, -0.19087030f, 0.08616932f, -0.04788196f, -0.09743196f, 0.06056206f, -0.09805968f, 
    -0.19437121f, -0.18732879f, -0.14291628f, -0.22803748f, -0.02791223f, -0.14193502f, -0.04843009f, 0.02305387f, 
    -0.35069779f, 0.06385858f, 0.04435125f, 0.30943736f, -0.11368424f, 0.14598662f, 0.02991391f, 0.37973779f, 
    -0.13361289f, 0.22883567f, -0.35334262f, -0.08217224f, -0.21319117f, 0.22594810f, 0.04691035f, 0.17906907f, 
    -0.44766471f, 0.09474343f, -0.06611805f, 0.15707785f, -0.22738543f, -0.02242558f, 0.18379205f, 0.33705181f, 
    0.26428968f, 0.09345709f, 0.39747560f, 0.19348979f, 0.19449660f, 0.02387255f, 0.10176599f, 0.07003661f, 
    0.01833641f, 0.13027850f, 0.26979551f, -0.23723765f, 0.49057332f, -0.23837095f, 0.40818071f, 0.13854571f, 
    -0.20922138f, -0.13210690f, -0.02002888f, -0.14560965f, -0.22589040f, -0.16432291f, -0.14976853f, 0.01011152f, 
    -0.15923281f, -0.01549730f, 0.38105738f, 0.33102307f, -0.10282599f, 0.06075019f, -0.41053730f, 0.56821990f, 
    -0.27974439f, 0.17672840f, -0.14668994f, -0.04277524f, -0.17915998f, -0.19705454f, -0.21737212f, -0.00572102f, 
    0.35050091f, -0.00903725f, -0.14029659f, 0.22585310f, 0.11776590f, -0.05098900f, -0.26582867f, -0.64428878f, 
    -0.26252753f, 0.12566523f, 0.37205291f, 0.14474660f, 0.42743075f, -0.16714907f, 0.14990619f, -0.03139376f, 
    0.24175067f, -0.00596978f, -0.17975484f, -0.33828029f, 0.10743856f, -0.07372192f, 0.38382310f, 0.57680714f, 
    0.21050195f, -0.20490028f, 0.04563037f, 0.03759281f, -0.25687754f, -0.11845291f, 0.17674935f, 0.16706912f, 
    0.21805550f, -0.05163410f, 0.32846200f, -0.23291911f, -0.07311583f, -0.07427330f, 0.07325025f, -0.32151774f, 
    0.19104357f, 0.02352294f, 0.34006438f, 0.12565762f, -0.64135033f, 0.20774047f, -0.20789094f, -0.58683592f, 
    -0.61993748f, -0.19739582f, 0.19600518f, 0.17884864f, 0.02541237f, -0.07837029f, 0.06385002f, -0.04908488f, 
    0.33471331f, -0.11161284f, 0.39063108f, -0.12904866f, 0.18342073f, -0.11200849f, 0.22194779f, -0.17365032f, 
    -0.14141122f, 0.06889099f, -0.25338107f, -0.08259136f, -0.03028523f, -0.15880358f, -0.19368899f, 0.01634572f, 
    0.11649556f, -0.02855517f, -0.15642963f, -0.11837689f, 0.48460427f, 0.20052779f, 0.19072723f, 0.15348941f, 
    -0.00286007f, -0.07849118f, -0.42513475f, 0.12648530f, -0.19546133f, -0.02454549f, -0.17539519f, -0.23377895f, 
    0.23852278f, 0.24255764f, 0.42697439f, -0.11690452f, 0.39603311f, -0.14650792f, -0.15470904f, 0.07113673f, 
    0.08433712f, 0.01017867f, -0.25952518f, 0.01335979f, 0.24361168f, -0.00873813f, -0.19247822f, 0.17380722f, 
    0.16632551f, -0.08707957f, -0.31130400f, 0.21055168f, 0.35455358f, -0.15629983f, -0.10080233f, -0.21605782f, 
    -0.25633976f, 0.07559115f, -0.22116607f, 0.13327606f, 0.02314553f, -0.14720258f, 0.48751733f, -0.18336229f, 
    0.13274355f, 0.24012376f, -0.30451518f, -0.04445802f, 0.02755572f, -0.00100410f, 0.16550153f, 0.56567281f, 
    -0.47259939f, 0.11430046f, 0.37899584f, -0.61082071f, 0.12959749f, -0.12622857f, 0.07595098f, -0.36794320f, 
    0.34051108f, 0.06783339f, 0.23156774f, 0.07031099f, -0.30627349f, -0.01512358f, -0.13041812f, 0.05643800f, 
    0.29527140f, -0.16569014f, 0.17465992f, -0.54034936f, -0.25726107f, 0.00259265f, -0.30363637f, 0.06357708f, 
    0.42725587f, -0.05933484f, 0.07052641f, 0.21663992f, -0.01482173f, -0.20369627f, 0.15016095f, 0.25915539f, 
    -0.50237930f, 0.15294944f, 0.38100785f, -0.30167210f, -0.02095497f, -0.08293857f, -0.24016054f, 0.39028093f, 
    0.39708525f, 0.22018903f, 0.32730010f, -0.06146232f, -0.06942093f, 0.13312972f, 0.12462175f, -0.01240686f, 
    -0.39751148f, -0.10601009f, -0.14935623f, 0.17492169f, -0.15391807f, 0.15276925f, 0.49734581f, -0.09996447f, 
    -0.06638790f, -0.13058938f, 0.46740437f, -0.00847067f, -0.14700247f, -0.22337703f, -0.12632227f, 0.06229823f, 
    -0.16475552f, -0.16265830f, -0.19992456f, -0.04745300f, -0.08921726f, -0.20505649f, 0.04892603f, 0.17703298f, 
    -0.09781684f, 0.17049098f, -0.09737786f, -0.23793837f, 0.01022800f, -0.11888164f, 0.13016605f, -0.01247744f, 
    0.20886280f, 0.02461767f, -0.33607230f, 0.26635987f, -0.25150245f, 0.22754140f, -0.08592396f, -0.37923172f, 
    -0.04346419f, -0.11424138f, 0.48056257f, -0.08117685f, -0.04499249f, -0.14652795f, 0.13183667f, 0.16331975f, 
    0.08872528f, -0.11060081f, 0.35007456f, 0.08237262f, -0.19226223f, 0.05282027f, -0.55789399f, 0.47776413f, 
    0.24542692f, -0.16969961f, 0.04001317f, -0.00633495f, -0.22734733f, 0.12212775f, 0.09766266f, 0.16058904f, 
    0.19082336f, 0.12291529f, -0.28109574f, 0.43904507f, 0.06143887f, 0.09974217f, -0.12754013f, -0.51142198f, 
    0.00107620f, -0.16641293f, 0.13103701f, -0.00029205f, 0.14607051f, -0.15696281f, 0.13945144f, 0.34283784f, 
    -0.03011839f, 0.17340551f, -0.06471546f, -0.17597267f, -0.04749756f, -0.00297251f, 0.33606920f, 0.29963458f, 
    -0.13570353f, -0.11172404f, -0.31948081f, -0.22260709f, -0.05076558f, 0.00475881f, -0.06910893f, 0.51553726f, 
    0.07227931f, 0.01843044f, 0.59214002f, 0.50365853f, -0.27712265f, -0.19793960f, -0.14874156f, 0.29645163f, 
    -0.28809163f, -0.17304578f, -0.35730785f, 0.13523224f, -0.20771019f, -0.09461477f, -0.04215372f, -0.07659031f, 
    -0.02236698f, 0.20932558f, 0.22581463f, -0.06026816f, -0.28824350f, -0.21816492f, -0.00133344f, -0.06143181f, 
    0.29914752f, -0.19041204f, 0.30258182f, -0.04415072f, 0.07340498f, -0.19024149f, -0.05686275f, -0.09403183f, 
    -0.08802345f, 0.04351711f, -0.12833047f, 0.19671272f, 0.34999961f, 0.22280237f, 0.19557033f, 0.03259160f, 
    -0.41364917f, -0.23266138f, -0.16759562f, -0.15342008f, 0.24834751f, -0.02152291f, -0.08389886f, 0.13191846f, 
    0.27896884f, 0.18936761f, -0.22068098f, -0.31149492f, -0.12978317f, 0.05403891f, -0.06400559f, -0.36249417f, 
    0.30144748f, 0.22043630f, 0.23646908f, 0.23254529f, 0.03500212f, 0.15160447f, -0.11123155f, 0.16603671f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04829507f, 0.20605953f, -0.07568330f, 0.25982213f, 0.25541627f, -0.19588025f, 0.12255025f, -0.17386419f, 
    0.23527732f, 0.16160509f, -0.14394443f, 0.23531391f, -0.02661265f, 0.40998113f, 0.31210759f, 0.17805463f, 
    0.19288391f, 0.01214903f, 0.04466971f, 0.01994997f, 0.22100420f, -0.22173306f, 0.32227266f, 0.61463189f, 
    0.25309435f, -0.02125925f, 0.17869990f, -0.05208317f, 0.05454957f, 0.03379238f, -0.13051331f, -0.13111658f, 
    0.21313025f, -0.18685886f, 0.23875743f, -0.11093555f, 0.64764035f, 0.37223715f, 0.07135223f, 0.04299983f, 
    -0.23829721f, 0.05583994f, -0.33641192f, -0.35889930f, 0.05454638f, 0.45935738f, 0.25875381f, 0.39635637f, 
    -0.08078049f, 0.55702311f, -0.18591066f, 0.35353678f, 0.34842688f, 0.39001450f, 0.29422107f, 0.00911226f, 
    0.12537153f, -0.20837648f, -0.18696520f, 0.00347291f, 0.06035888f, 0.18604234f, 0.16756222f, 0.48631811f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.24901499f, -0.04959820f, 0.07121250f, -0.14182211f, 0.19203685f, 0.50309062f, 0.09015371f, 0.22561258f, 
    0.14013302f, 0.17572585f, 0.00520648f, 0.16260517f, -0.14481205f, -0.47277543f, -0.26919997f, 0.03561879f, 
    -0.19727838f, -0.51921368f, 0.33129004f, 0.08879041f, -0.42050231f, 0.06491618f, -0.27871013f, -0.19965361f, 
    -0.30112445f, -0.06764157f, 0.37522459f, 0.21881253f, 0.31106350f, -0.15698954f, -0.33510795f, 0.33910352f, 
    0.22836623f, 0.14867163f, -0.12098907f, -0.00642708f, -0.43542814f, -0.42634687f, -0.03653240f, -0.19024880f, 
    0.15883523f, 0.05128641f, 0.16767855f, 0.20787545f, -0.30676857f, -0.03833107f, 0.06585132f, -0.32957566f, 
    0.15619235f, -0.03442448f, -0.08112181f, -0.26423314f, -0.79781628f, -0.28837889f, -0.29841390f, 0.06709269f, 
    -0.36321786f, 0.02466480f, 0.15084267f, -0.49723655f, 0.20995545f, -0.24754789f, 0.02456886f, -0.08321490f, 
    -0.13366334f, -0.48511145f, 0.03243951f, -0.06219300f, -0.01015664f, 0.55051142f, 0.09148403f, -0.08033501f, 
    -0.25967139f, 0.56440639f, -0.02029071f, 0.10490845f, 0.07404465f, 0.10536701f, 0.32890287f, 0.00561784f, 
    0.21647622f, 0.24718370f, -0.33254567f, -0.17291799f, -0.07398177f, -0.01111215f, -0.21704921f, 0.11318314f, 
    0.38024563f, -0.06748731f, 0.01603385f, -0.22198226f, 0.30152681f, -0.32477385f, 0.18365364f, -0.28242293f, 
    -0.47256854f, -0.12006855f, 0.14787993f, 0.00675479f, 0.03751296f, 0.21706504f, -0.11201970f, 0.09884097f, 
    0.29265675f, 0.09968107f, 0.15085848f, 0.14055434f, 0.02179155f, 0.38267070f, 0.26544711f, -0.43373016f, 
    0.11367714f, -0.28612441f, 0.09027129f, 0.45360005f, -0.09522533f, 0.31758046f, 0.60850167f, 0.05557894f, 
    0.18915269f, 0.00854219f, -0.30027211f, 0.21102269f, -0.31851760f, 0.30496594f, -0.00437365f, -0.10045880f, 
    0.04474378f, 0.32476193f, 0.04992549f, -0.07399806f, 0.08951966f, 0.67569846f, 0.23290683f, -0.21390080f, 
    -0.10792320f, -0.01734482f, -0.47488919f, -0.13166764f, -0.31160760f, 0.03962679f, 0.35021916f, 0.11959940f, 
    0.11965751f, 0.15485360f, 0.50654685f, -0.07902953f, 0.16494128f, 0.03584380f, 0.20140897f, 0.31952566f, 
    0.08954243f, -0.05504766f, 0.32454404f, -0.27384874f, 0.00282483f, -0.05726860f, 0.01717527f, -0.27490479f, 
    0.39015132f, -0.34269246f, 0.06591669f, 0.08021910f, 0.13091509f, 0.31442520f, 0.06626607f, -0.20318799f, 
    0.19645938f, 0.13039671f, -0.85941619f, -0.28034747f, 0.31715316f, -0.44511148f, 0.02764623f, 0.29968685f, 
    -0.14614099f, 0.09402693f, 0.63426399f, -0.07457314f, 0.08096865f, -0.04209911f, 0.00880449f, 0.01826098f, 
    -0.64794093f, -0.16463359f, -0.09221593f, 0.60918254f, -0.72228736f, -0.21546076f, 0.07485484f, 0.07506871f, 
    -0.11694751f, -0.03813532f, -0.00215046f, 0.03741325f, 0.04632832f, -0.09329592f, 0.06878675f, -0.06775698f, 
    0.03138858f, 0.07487031f, 0.03156061f, 0.03211293f, -0.05824124f, -0.05525189f, 0.00639064f, -0.04242158f, 
    -0.13003482f, -0.06151943f, -0.08432399f, 0.06908491f, -0.01021967f, -0.00198674f, 0.04143984f, -0.13393214f, 
    0.03610384f, 0.06175207f, 0.08156128f, 0.07082083f, 0.00815349f, -0.10508293f, 0.04843672f, -0.03842561f, 
    -0.01998063f, 0.04983688f, -0.07871933f, 0.07007268f, -0.11668056f, -0.02615671f, -0.10140343f, -0.02840890f, 
    0.00018930f, -0.05743649f, -0.08868703f, -0.02987666f, -0.09569579f, 0.02329023f, -0.11570645f, -0.04818093f, 
    0.06388113f, -0.07145642f, 0.02626293f, -0.01480372f, -0.04064614f, 0.08686021f, -0.02141600f, 0.03693745f, 
    -0.14715840f, -0.09104992f, 0.02674568f, 0.01413430f, -0.09571970f, -0.04463632f, -0.04894658f, 0.00101583f, 
    0.11462334f, 0.25198069f, -0.00032121f, -0.09561741f, 0.40980190f, -0.16725934f, 0.08027760f, -0.01339887f, 
    0.18046263f, 0.05696595f, -0.59171051f, 0.02967565f, -0.01325470f, -0.05410507f, 0.28984830f, 0.27862301f, 
    0.09988863f, -0.41618136f, 0.37984994f, 0.03858943f, -0.19001304f, -0.02171719f, -0.09358089f, 0.38196757f, 
    0.19862178f, -0.07130571f, 0.29105300f, 0.13526493f, -0.17710237f, 0.01375518f, -0.08115309f, -0.10334172f, 
    0.52985489f, -0.02243857f, -0.16433336f, 0.09226155f, -0.01478623f, -0.00093425f, -0.10165334f, 0.11946351f, 
    -0.06346113f, 0.33861962f, 0.27904084f, 0.00241155f, 0.05496697f, -0.10598453f, -0.06341722f, 0.10882255f, 
    0.02603399f, 0.00041815f, 0.27813816f, -0.03664078f, -0.25724325f, -0.31243002f, 0.14737380f, -0.04692821f, 
    0.02951259f, -0.18817262f, 0.34727657f, -0.03717358f, 0.11743677f, -0.24562311f, 0.25533053f, 0.07657968f, 
    0.14505327f, -0.12063003f, 0.10710871f, -0.08577631f, 0.35288125f, -0.43436986f, -0.00034790f, 0.03446820f, 
    0.26635209f, 0.14207782f, 0.80273116f, 0.07463578f, 0.34169176f, 0.05432190f, -0.03564039f, -0.26082793f, 
    0.03099078f, -0.20799100f, -0.18353175f, 0.24014816f, -0.36185345f, 0.07057326f, -0.20591854f, 0.11419588f, 
    -0.12064403f, -0.01672012f, -0.26636380f, 0.29614875f, 0.34704667f, -0.12376446f, -0.06326672f, 0.22752072f, 
    -0.20583946f, 0.11908987f, 0.08320642f, -0.15565968f, 0.06188727f, -0.06261005f, 0.08979741f, 0.36098620f, 
    0.08684172f, 0.12237184f, 0.07847254f, 0.06200438f, -0.02505845f, 0.07633907f, 0.34598389f, -0.21594748f, 
    0.06984321f, -0.06905227f, -0.28432548f, 0.36414197f, -0.01782525f, 0.23246863f, 0.29347920f, -0.09197596f, 
    0.18684100f, -0.10162114f, -0.19722071f, -0.33137533f, 0.08881456f, 0.18766432f, 0.28398573f, -0.05031658f, 
    -0.00481927f, 0.03969106f, -0.12359503f, -0.03721616f, -0.08675811f, 0.04883172f, 0.06195077f, 0.01197279f, 
    -0.12884481f, -0.02381286f, 0.02418093f, 0.06652498f, 0.07934990f, -0.12678584f, -0.08503520f, -0.00366405f, 
    -0.07826807f, -0.01589236f, -0.19847579f, -0.18357743f, 0.06159588f, -0.04971318f, 0.11351484f, -0.03163464f, 
    0.09993201f, -0.05091825f, -0.09305137f, 0.04485020f, -0.07870904f, -0.00989787f, -0.01700977f, -0.00182074f, 
    -0.00728804f, 0.10022208f, -0.11561063f, 0.11557877f, -0.08649512f, 0.07980324f, -0.03331234f, 0.03913959f, 
    -0.03721913f, -0.00210131f, -0.02575813f, -0.09819719f, -0.13859716f, -0.02028732f, -0.12762992f, 0.00474713f, 
    -0.12434953f, -0.09257583f, 0.08656657f, 0.05575422f, -0.02134077f, -0.04987301f, 0.10853551f, -0.02420400f, 
    -0.08724364f, 0.03068362f, 0.00769587f, 0.05131593f, -0.11313671f, -0.12362809f, 0.08953291f, 0.04019951f, 
    -0.02916740f, 0.00868385f, 0.05672145f, 0.27172804f, -0.17170595f, -0.95407814f, -0.11581856f, 0.20542437f, 
    -0.18965898f, 0.12259456f, 0.31611729f, 0.11423603f, 0.40687910f, 0.26147509f, -0.35844350f, 0.24499227f, 
    0.09846132f, -0.20449208f, -0.65987068f, 0.01156005f, 0.21955757f, -0.01016323f, 0.45914283f, -0.31659669f, 
    0.05891638f, 0.10729924f, -0.40232351f, 0.11772584f, -0.13453034f, 0.18847622f, 0.16358335f, -0.15160570f, 
    -0.15972626f, 0.08836023f, 0.05969125f, 0.02067822f, 0.04031345f, -0.21862482f, 0.03128049f, 0.44216841f, 
    0.01195640f, 0.06840202f, 0.25897771f, 0.18922949f, 0.07744905f, 0.40591156f, -0.13465706f, 0.11196999f, 
    0.28647354f, 0.10878572f, -0.10289841f, -0.06729978f, 0.10534614f, -0.13266784f, 0.33231193f, 0.11353360f, 
    0.25541595f, 0.07597210f, 0.10412636f, -0.10380894f, -0.14247657f, 0.08051774f, 0.32474628f, 0.19754992f, 
    0.04659476f, -0.07799718f, -0.00330316f, -0.11707579f, 0.03220502f, -0.01029922f, 0.02046678f, -0.06991453f, 
    -0.01991678f, -0.10037097f, 0.06981747f, 0.09928328f, -0.00061646f, -0.09630719f, 0.01836861f, -0.07807227f, 
    -0.13038598f, 0.08490039f, -0.00951758f, -0.03425361f, 0.10025773f, 0.11243765f, -0.03330936f, 0.05700215f, 
    0.01582474f, -0.04071732f, -0.04465167f, -0.08305804f, -0.01564964f, 0.00827579f, -0.07932723f, -0.12927131f, 
    -0.02885858f, -0.08323435f, -0.14635117f, -0.04697409f, 0.06123906f, -0.12519626f, -0.05801429f, -0.11658505f, 
    0.07229292f, -0.02320606f, 0.10033754f, 0.05484940f, -0.04619912f, -0.10944265f, 0.03347532f, 0.08476360f, 
    -0.11121716f, -0.13558175f, -0.01993237f, -0.07378270f, -0.11975794f, -0.00717888f, 0.07868391f, 0.02192450f, 
    0.03468037f, -0.14241980f, -0.00486122f, 0.05631857f, 0.06386814f, 0.01923804f, -0.11457841f, 0.02839336f, 
    -0.14598857f, -0.01509151f, 0.00764461f, 0.02092524f, -0.11017341f, -0.00991999f, 0.06626815f, 0.00071601f, 
    0.09759825f, -0.07006900f, 0.05648097f, -0.09868202f, 0.00559845f, -0.09268989f, -0.06772003f, 0.04962143f, 
    0.07060050f, -0.06601971f, 0.01622602f, -0.15389545f, 0.09803481f, 0.09550767f, -0.09000474f, -0.10529243f, 
    -0.11991189f, 0.02488516f, -0.03135927f, 0.04102861f, -0.07347746f, -0.08462512f, -0.08489662f, 0.07215872f, 
    0.01359081f, 0.04246660f, 0.10805277f, -0.04093664f, -0.05417462f, -0.04386636f, -0.07022543f, -0.01279186f, 
    -0.03514329f, -0.14949434f, 0.07786900f, -0.14154017f, -0.13158853f, 0.10053577f, -0.00160363f, -0.11775680f, 
    -0.06134044f, -0.09477238f, -0.02417466f, 0.00487800f, -0.10465383f, -0.08957130f, 0.02225253f, 0.07473715f, 
    -0.00189120f, -0.00842346f, -0.07188347f, -0.08935367f, 0.05015586f, -0.06642757f, -0.02386035f, 0.10742234f, 
    -0.02442729f, -0.01910108f, -0.07940239f, 0.10252459f, -0.10925955f, -0.12864904f, 0.01088392f, -0.04516862f, 
    0.08467136f, 0.07122953f, 0.03203915f, -0.14439338f, 0.08980064f, -0.08697004f, -0.08381777f, 0.07417800f, 
    0.03781268f, -0.11158099f, -0.04409004f, -0.09172467f, 0.01033611f, -0.07392769f, -0.01820429f, -0.05982590f, 
    0.04297199f, -0.07999641f, -0.09765505f, -0.05716564f, -0.04388256f, -0.05587203f, -0.04553398f, 0.04052719f, 
    -0.05210043f, -0.03343423f, -0.07385400f, -0.11738417f, -0.04426783f, -0.01029661f, 0.00754245f, -0.05497437f, 
    -0.10781407f, -0.10407978f, -0.05961310f, 0.02474888f, 0.08465670f, -0.13662650f, -0.11634071f, 0.01247951f, 
    -0.07383891f, -0.11171401f, -0.07810055f, -0.12185188f, 0.01237361f, -0.08055366f, -0.16881056f, 0.05870891f, 
    -0.12203606f, -0.06972943f, -0.08624242f, 0.01478516f, 0.00808430f, -0.05572139f, -0.15368825f, 0.00262991f, 
    -0.16451328f, -0.09646907f, 0.08238937f, -0.04447246f, 0.28663749f, 0.31836003f, 0.07230400f, -0.21229121f, 
    -0.05065212f, 0.26247123f, 0.52918828f, 0.07335261f, 0.11646625f, 0.33579746f, 0.50299978f, -0.13343495f, 
    0.12538195f, 0.72117180f, -0.15352191f, 0.14457348f, -0.18851408f, 0.02929728f, -0.16892985f, 0.39655089f, 
    0.76022381f, 0.08042592f, 0.10958573f, -0.21254784f, 0.17390482f, -0.25591898f, -0.02325880f, 0.02114284f, 
    -0.08322698f, -0.21445905f, 0.09779572f, 0.04609924f, 0.27099210f, 0.36007798f, -0.07838640f, -0.21207848f, 
    0.14000808f, 0.20926018f, -0.03470749f, -0.55108958f, 0.18294230f, -0.06879993f, 0.24161738f, -0.02971542f, 
    -0.25443277f, 0.01964618f, -0.10354392f, 0.63148695f, 0.20008048f, 0.36566585f, 0.54870260f, 0.13554603f, 
    -0.10306115f, 0.08566047f, -0.40696758f, 0.24843863f, -0.08332669f, 0.24709776f, -0.01669597f, 0.09781782f, 
    0.14039786f, -0.13194509f, -0.11751914f, 0.06998210f, -0.05679456f, -0.21819948f, 0.39454183f, -0.05715657f, 
    0.01854284f, 0.09936719f, 0.32232448f, 0.27419195f, -0.31171352f, -0.02966669f, 0.16984744f, -0.11209618f, 
    -0.02696721f, -0.28366467f, -0.03214118f, 0.05352947f, 0.11802454f, 0.01737753f, -0.08889846f, 0.05567428f, 
    0.26126841f, 0.08645807f, -0.17203392f, -0.10617808f, 0.29751155f, 0.03928289f, 0.03234612f, 0.27620104f, 
    -0.30596989f, 0.02403732f, 0.27982134f, 0.03978555f, 0.11889986f, -0.15206131f, 0.09125561f, -0.11619430f, 
    0.12304705f, -0.03832560f, -0.32480285f, -0.05654528f, -0.20694982f, -0.54151529f, 0.39318296f, 0.09468240f, 
    0.26161045f, -0.02290875f, 0.03505386f, 0.20015426f, 0.02846176f, 0.41203377f, 0.14861576f, -0.04573384f, 
    -0.08384880f, 0.03374628f, -0.00421077f, -0.27659035f, -0.04352489f, 0.21547554f, -0.00376723f, 0.06649777f, 
    0.12207129f, 0.14286470f, 0.07339950f, 0.01346733f, 0.29351595f, 0.08480138f, -0.01203402f, 0.31174603f, 
    0.23303123f, -0.02354331f, 0.44084677f, -0.05095024f, 0.37876007f, 0.15153570f, -0.08365019f, 0.08617695f, 
    0.08876674f, -0.43825069f, -0.21210791f, 0.30679384f, 0.02184155f, 0.06993334f, 0.33681443f, 0.03871464f, 
    -0.19629687f, -0.00239889f, 0.00268778f, 0.33972910f, -0.20437993f, 0.02706728f, 0.08109590f, -0.02604823f, 
    0.04606306f, 0.20497595f, -0.20136733f, -0.03966495f, 0.20194088f, 0.03834940f, -0.04319659f, 0.07429149f, 
    -0.12221026f, 0.20399353f, 0.00896549f, 0.43483838f, 0.12871733f, 0.01867006f, -0.14799190f, -0.16272037f, 
    -0.11597309f, 0.05371686f, -0.17175686f, 0.37690321f, 0.10757310f, 0.02763786f, -0.25041628f, 0.09713754f, 
    0.37711525f, -0.04455898f, 0.00176357f, 0.24752648f, 0.09704790f, 0.01512067f, 0.31179392f, 0.16366625f, 
    -0.07667709f, -0.10375492f, 0.09159434f, -0.08241244f, 0.04141894f, -0.12735531f, 0.03814140f, 0.01984516f, 
    -0.05493756f, -0.01926398f, -0.06675522f, -0.02845911f, 0.09460264f, -0.12792447f, 0.03564456f, -0.10049705f, 
    -0.02443233f, 0.03374464f, -0.02434868f, -0.02794203f, -0.10566258f, -0.02086309f, -0.03846887f, 0.03770778f, 
    -0.07289243f, 0.12008771f, -0.06787702f, -0.10986410f, -0.05611809f, -0.00955403f, -0.08337402f, 0.09740872f, 
    -0.14129709f, -0.01904776f, -0.07487464f, 0.09617853f, -0.09114247f, -0.00899264f, -0.07718325f, 0.08515878f, 
    -0.04918500f, -0.05538006f, 0.12439919f, 0.01927636f, -0.09046315f, 0.11166020f, -0.14551081f, -0.04075659f, 
    0.08543366f, -0.05418826f, 0.05943765f, 0.04126954f, 0.08673784f, 0.01289594f, -0.01192835f, -0.10650136f, 
    0.04361250f, -0.12032031f, 0.03639237f, -0.10970844f, -0.04226464f, -0.00720472f, 0.08516226f, -0.06924460f, 
    0.11793920f, -0.09109466f, -0.04992601f, 0.42177850f, -0.28432688f, -0.32497680f, 0.16027439f, -0.23901805f, 
    -0.11302403f, 0.11008648f, -0.54457879f, 0.47980830f, 0.00687234f, 0.07835421f, 0.01133990f, 0.17499349f, 
    0.08112651f, -0.50786352f, 0.19463514f, -0.07601970f, 0.43794608f, 0.10188095f, 0.37683502f, -0.03320233f, 
    -0.39052629f, 0.10908006f, -0.16302525f, -0.07808571f, 0.14807512f, 0.28217861f, -0.00299819f, 0.06481160f, 
    -0.17500228f, 0.12893179f, 0.26564023f, 0.05980147f, 0.08688629f, -0.11304063f, 0.04153747f, 0.02577332f, 
    0.11759914f, -0.22578356f, -0.16670105f, -0.05962988f, -0.10928261f, 0.28008115f, 0.19705459f, 0.55899233f, 
    0.57868457f, 0.23332120f, -0.02058955f, -0.20234101f, -0.00092178f, -0.08228955f, -0.20156230f, -0.15495263f, 
    0.09265942f, -0.01230203f, 0.17310475f, -0.00076999f, -0.26155499f, 0.16754782f, -0.03574973f, -0.00784365f, 
    0.34970886f, -0.01861395f, 0.10702445f, 0.36983067f, -0.51365095f, 0.44342673f, 0.09785447f, 0.41378993f, 
    -0.12554784f, 0.06585660f, 0.14138405f, -0.02139729f, 0.41044724f, -0.03564528f, -0.03432496f, 0.24636284f, 
    -0.18448131f, 0.48812115f, 0.26890233f, -0.06711620f, -0.09114728f, -0.03335629f, 0.31425792f, -0.20823009f, 
    0.61878759f, 0.00894594f, 0.63781577f, 0.05364453f, -0.18319832f, 0.11988166f, -0.34919924f, 0.11035887f, 
    0.21893699f, -0.05570939f, -0.20079711f, 0.03329664f, 0.00265711f, -0.29374513f, 0.00286002f, -0.42199075f, 
    -0.03846437f, -0.32162046f, 0.04918366f, 0.21742627f, 0.00703804f, -0.31915849f, 0.00199241f, 0.24364205f, 
    0.38864690f, 0.43550462f, -0.58599943f, 0.36705649f, 0.08281207f, 0.29732513f, -0.27146181f, -0.06488901f, 
    0.26636815f, 0.03447756f, 0.07459979f, -0.72049433f, 0.10854056f, -0.06539432f, 0.00657807f, 0.10152502f, 
    0.28432387f, 0.18969135f, -0.03211625f, 0.16466632f, 0.35848567f, -0.59216809f, -0.05976087f, -0.02535103f, 
    0.71923190f, -0.28662175f, 0.28516108f, 0.30748066f, -0.28186598f, -0.15816556f, -0.29358751f, -0.17389821f, 
    -0.18921602f, -0.51404262f, 0.31803691f, 0.37875924f, 0.11562617f, -0.10401256f, 0.03772698f, 0.09303446f, 
    0.45037887f, -0.03839198f, 0.40947169f, 0.34351856f, 0.09793899f, -0.14484297f, -0.18244788f, 0.26541594f, 
    -0.05313337f, 0.19541661f, -0.03274634f, -0.07315231f, -0.03864164f, -0.19219771f, -0.00816964f, 0.03539579f, 
    -0.14402449f, -0.06509467f, -0.24272981f, 0.43998435f, -0.18336692f, 0.33315516f, 0.19630636f, 0.31904790f, 
    0.06559061f, 0.09860048f, -0.09414849f, 0.16887096f, 0.24926296f, -0.04626241f, -0.79319721f, -0.02924012f, 
    -0.14414062f, -0.05338830f, -0.18537323f, -0.13301982f, 0.15215299f, 0.34241018f, -0.04446620f, 0.10203786f, 
    0.07347298f, 0.21986412f, -0.03805929f, 0.01351106f, 0.18107340f, 0.27491388f, -0.19554736f, 0.43607271f, 
    0.27976963f, 0.11042363f, 0.26953143f, 0.01155447f, 0.35349044f, 0.22837317f, 0.04990212f, 0.06744696f, 
    -0.02439527f, 0.30138555f, -0.29109082f, 0.19270301f, 0.41508302f, -0.08201431f, -0.01831851f, 0.08039977f, 
    0.39125493f, -0.08843626f, -0.22621889f, 0.18667202f, -0.26219168f, 0.20021796f, 0.04806806f, -0.09376283f, 
    0.12857711f, 0.12504637f, -0.07804791f, -0.04485194f, 0.11788206f, 0.02110356f, 0.01128732f, -0.36750755f, 
    0.04115837f, -0.00202001f, -0.16965166f, -0.24454939f, 0.19789338f, -0.32770625f, -0.18672611f, -0.06474239f, 
    0.10705262f, -0.13549657f, -0.05545955f, 0.54803717f, 0.61022669f, -0.10062119f, -0.01924157f, -0.11716433f, 
    0.24530435f, 0.09942037f, 0.00853852f, 0.05392686f, -0.24891946f, 0.16607015f, -0.31448796f, 0.26474297f, 
    -0.18317977f, 0.29536748f, -0.09089176f, -0.11862749f, 0.28144690f, 0.69885665f, -0.21426281f, 0.07428219f, 
    0.13651150f, 0.21113530f, -0.03852710f, -0.21106762f, 0.48524019f, 0.14438440f, 0.03784657f, -0.10528504f, 
    0.13608021f, 0.48877779f, -0.05673976f, 0.00416867f, 0.01513052f, -0.06437151f, -0.11085769f, 0.12835814f, 
    0.02877725f, -0.08420058f, -0.22315022f, 0.02583306f, -0.07118471f, 0.03853992f, 0.02867026f, -0.17016992f, 
    0.20526659f, 0.09636937f, 0.13339767f, -0.01600672f, 0.10991149f, 0.35411209f, 0.01889371f, -0.27522552f, 
    -0.07360212f, 0.26510164f, 0.18175687f, -0.25960225f, 0.24827875f, 0.27531937f, -0.26140746f, -0.32208082f, 
    -0.22300290f, -0.01620470f, -0.09415145f, 0.51770496f, 0.41119054f, -0.19728486f, 0.29333702f, -0.13256755f, 
    0.28561127f, 0.05207115f, 0.06989395f, 0.25618610f, -0.01656809f, 0.26817730f, -0.28625149f, 0.22130774f, 
    -0.09418865f, -0.06763335f, 0.10511565f, 0.34848547f, 0.03955498f, -0.42939529f, -0.01981975f, 0.03095650f, 
    -0.22368193f, -0.01844374f, 0.21889435f, 0.07146132f, -0.08040572f, 0.32299080f, -0.10113011f, 0.16246513f, 
    0.31399238f, -0.11731683f, -0.19532029f, 0.00078852f, -0.11958791f, 0.12483385f, 0.53455192f, -0.07202628f, 
    -0.46978158f, 0.04242757f, -0.09622045f, -0.01779167f, 0.02197767f, -0.04541408f, 0.35333693f, -0.08979379f, 
    -0.00771514f, 0.18345594f, -0.03340160f, -0.10365593f, -0.00864786f, -0.02503983f, 0.09138437f, -0.14034684f, 
    0.21492299f, 0.01143394f, -0.15030821f, 0.16796745f, 0.10116317f, -0.02785904f, -0.03143209f, -0.04132321f, 
    0.13412133f, 0.20136115f, -0.03868968f, -0.10112567f, -0.15372950f, 0.13804479f, 0.22614512f, -0.03683894f, 
    -0.13258746f, -0.08179599f, -0.06788440f, -0.13801745f, 0.26574218f, -0.04669761f, 0.54065537f, -0.05931565f, 
    -0.09858216f, 0.11285767f, 0.07517794f, -0.08466940f, 0.01790607f, -0.45209008f, -0.11287147f, 0.02582135f, 
    -0.07595509f, -0.11759289f, 0.00014625f, -0.01179708f, 0.19587301f, 0.02075923f, -0.03943295f, 0.21789105f, 
    -0.01060171f, -0.46630070f, -0.07319749f, -0.19236036f, -0.20981456f, 0.01045901f, 0.26418528f, 0.12879342f, 
    -0.37065849f, 0.03641106f, -0.14734139f, 0.06082891f, 0.08261532f, 0.16243160f, 0.26899669f, 0.08715219f, 
    0.17691472f, 0.03017273f, 0.01196189f, 0.05053030f, -0.00364511f, -0.02940522f, 0.05396246f, 0.18714364f, 
    0.20209891f, 0.26476276f, 0.22206938f, 0.59889275f, 0.00675665f, 1.04304171f, 0.04452632f, -0.22125807f, 
    -0.02270441f, 0.10840458f, 0.30554482f, -0.42201281f, -0.48999202f, -0.25619128f, 0.44992405f, 0.00551939f, 
    0.06203613f, -0.17121887f, 0.23830642f, 0.31272417f, -0.15508866f, -0.00053537f, 0.48166487f, 0.05128592f, 
    -0.16829692f, -0.10366313f, 0.01834287f, 0.37057623f, -0.21510191f, -0.08165778f, -0.01619613f, -0.02614187f, 
    -0.04478680f, -0.16826756f, -0.14606166f, -0.09461944f, -0.20281975f, 0.18273206f, -0.08867861f, -0.08033589f, 
    0.16491085f, -0.47026405f, -0.15138936f, 0.16822094f, 0.21337251f, 0.00807692f, 0.38839847f, -0.22155938f, 
    -0.00202514f, -0.10476306f, 0.28232181f, 0.06108135f, 0.13187297f, -0.16461651f, 0.27049872f, -0.15935554f, 
    -0.36505660f, -0.06991545f, 0.08278645f, 0.02325385f, 0.13757081f, -0.04217716f, 0.02398011f, 0.02846392f, 
    0.19911073f, -0.19788288f, -0.28145966f, -0.03281288f, 0.26246464f, -0.18377392f, 0.00003654f, 0.16011825f, 
    -0.10142038f, 0.08133610f, -0.17132774f, 0.59481907f, 0.46302646f, 0.49674460f, -0.22295955f, 0.09715784f, 
    -0.21473809f, 0.16839552f, -0.45575014f, 0.31498402f, -0.06295878f, 0.15866524f, -0.22619314f, 0.20351669f, 
    0.23458157f, -0.08299944f, -0.04932483f, 0.06963102f, -0.09325834f, -0.50595582f, 0.19584394f, 0.11257275f, 
    -0.16852899f, 0.37832102f, 0.43036228f, 0.30300406f, 0.28572354f, -0.04278632f, 0.11366136f, -0.03630113f, 
    -0.07400508f, -0.03499197f, -0.06193774f, -0.10178147f, -0.10543995f, -0.04494639f, -0.06662104f, -0.02520947f, 
    -0.05848937f, 0.05565992f, -0.55456460f, -0.05489801f, 0.01181797f, 0.15096559f, -0.03215066f, 0.19953316f, 
    -0.12538633f, 0.02929193f, 0.16052848f, 0.08580474f, 0.08876628f, -0.08028229f, 0.08917622f, 0.45527542f, 
    0.05742904f, -0.11447174f, 0.11991609f, 0.09431119f, -0.24104550f, -0.12793234f, 0.35407451f, -0.01782316f, 
    0.57906842f, 0.10505270f, -0.05863008f, -0.07283334f, -0.19256109f, 0.16139880f, 0.27571708f, -0.10955855f, 
    0.58192855f, -0.18520854f, 0.21182042f, -0.58519584f, -0.05507409f, -0.02436851f, 0.13729845f, -0.01376131f, 
    -0.11854799f, -0.06059444f, -0.00338894f, 0.06184313f, -0.10729145f, 0.03407179f, -0.07564834f, -0.01168129f, 
    -0.03270438f, -0.03060348f, 0.07198366f, 0.05203394f, -0.12262142f, -0.03691113f, 0.07119580f, 0.06642232f, 
    0.06061224f, 0.09517492f, -0.07909774f, 0.06404881f, -0.12262221f, -0.06299846f, -0.12120877f, -0.07014923f, 
    -0.11645158f, 0.06897506f, 0.00791024f, -0.16769159f, -0.16878611f, -0.16294363f, -0.10501231f, -0.14642689f, 
    -0.00813986f, 0.05235893f, -0.07993930f, -0.05919068f, 0.03574590f, -0.04946392f, 0.08019316f, 0.04866026f, 
    -0.15281388f, -0.15086655f, -0.07896419f, 0.07625472f, -0.00299417f, 0.06670717f, -0.08655463f, -0.08769597f, 
    -0.12123379f, 0.01562786f, -0.11194479f, -0.13828002f, -0.05448113f, 0.07071842f, 0.05979439f, 0.00908104f, 
    -0.04751927f, -0.07034008f, -0.07395422f, -0.04952454f, 0.03762452f, 0.05560813f, -0.07302855f, -0.09165859f, 
    -0.01964929f, -0.09557204f, 0.06781909f, 0.08467089f, 0.09166471f, -0.11805567f, -0.02342157f, -0.10387278f, 
    -0.09465631f, 0.02552986f, 0.06673759f, 0.03421446f, -0.07936057f, -0.01874021f, 0.07659858f, -0.13615903f, 
    -0.10758606f, -0.05852785f, -0.10705122f, 0.03697284f, -0.10198429f, -0.03672394f, -0.02762721f, -0.10601146f, 
    -0.04950620f, -0.02218503f, -0.14468133f, -0.01599544f, -0.04351329f, -0.04984085f, 0.05082597f, 0.06510349f, 
    -0.03695045f, -0.04555369f, -0.00136153f, 0.10732165f, -0.06643931f, -0.06586993f, 0.05260336f, 0.02464583f, 
    -0.11928677f, -0.16618007f, 0.10299827f, -0.03883760f, -0.10229392f, 0.06748632f, -0.01653609f, 0.03758452f, 
    -0.08803689f, 0.01319986f, 0.08008430f, -0.09836535f, -0.05467544f, -0.01145528f, 0.00457717f, 0.04723324f, 
    -0.12124979f, -0.01110481f, 0.06676450f, 0.08343233f, -0.15124604f, -0.07225484f, 0.06747474f, -0.07601088f, 
    0.05175219f, 0.07783047f, -0.00996749f, 0.06256595f, -0.09105223f, -0.04515437f, -0.11530510f, -0.03036465f, 
    0.01581438f, 0.03534074f, 0.05399489f, -0.06377266f, 0.07451554f, 0.01323650f, -0.07301581f, -0.10640764f, 
    0.02285935f, -0.01792404f, -0.09804997f, 0.07185674f, -0.05091453f, 0.10382731f, -0.00934267f, 0.05666390f, 
    0.09871305f, -0.06786941f, -0.12502299f, -0.00691412f, -0.09167063f, -0.06669211f, 0.00133339f, -0.10666525f, 
    -0.02316130f, 0.10518361f, -0.07551791f, -0.10059046f, -0.06399076f, -0.13165100f, -0.00980107f, 0.04190065f, 
    0.03517593f, 0.06494626f, 0.00125659f, 0.05461805f, 0.08736292f, 0.00699555f, -0.06161945f, 0.00946093f, 
    -0.06045951f, -0.02427958f, 0.07172579f, 0.07670502f, -0.14534229f, 0.08270533f, -0.00871929f, -0.06855799f, 
    -0.01345432f, -0.06855333f, 0.01899046f, 0.00617317f, -0.06738566f, -0.12281007f, -0.10361622f, -0.04031688f, 
    -0.10355753f, -0.01139458f, -0.11034308f, 0.19132055f, -0.28119567f, 0.43212917f, 0.24385753f, -0.05608990f, 
    -0.00566936f, 0.38525632f, -0.18033233f, 0.06473514f, -0.06694753f, -0.06189568f, 0.38827235f, 0.05541025f, 
    0.04085312f, 1.15503204f, 0.14127073f, -0.08813717f, 0.11551303f, 0.08277090f, -0.00846169f, 0.07529046f, 
    0.63598275f, 0.04678504f, 0.03674104f, -0.25253391f, -0.01583832f, 0.20878997f, -0.09973913f, -0.00003290f, 
    0.19145094f, 0.00462243f, 0.19535482f, 0.05054063f, 0.13377953f, 0.05370937f, -0.01376198f, -0.59361023f, 
    0.07737028f, -0.19520533f, -0.40431371f, -0.78407162f, 0.02287749f, -0.83558327f, 0.08504430f, 0.19216608f, 
    0.17230222f, 0.01625569f, 0.06525182f, 0.29613551f, 0.35168177f, 0.15959759f, 0.03252416f, -0.01699465f, 
    -0.29040274f, 0.27663076f, 0.21943702f, -0.13483645f, -0.41302359f, 0.04881971f, -0.42447618f, 0.08166858f, 
    -0.10209972f, 0.15319365f, -0.08933613f, 0.04761571f, 0.00033000f, 0.31425190f, 0.18101144f, -0.13269421f, 
    -0.05111998f, 0.10996863f, -0.60843301f, 0.07925996f, -0.31772545f, -0.11248979f, 0.26887512f, 0.17444119f, 
    -0.03624425f, 0.49699610f, 0.40106159f, 0.04661161f, 0.06906054f, -0.01498340f, 0.10296496f, 0.29704860f, 
    0.66310883f, 0.01184294f, 0.39462870f, -0.25934437f, 0.02282281f, 0.08533269f, -0.15923190f, -0.17490010f, 
    0.53370732f, -0.22294648f, 0.25199667f, 0.06492248f, 0.21096739f, 0.06381784f, 0.09046486f, -0.39128751f, 
    0.02010802f, -0.12651603f, -0.43916047f, -0.27928486f, 0.12803529f, 0.00970432f, -0.03975269f, 0.30213457f, 
    -0.02034581f, 0.25910378f, 0.26508912f, -0.10338558f, 0.20787175f, -0.09501613f, -0.05802068f, 0.07433168f, 
    -0.17415464f, -0.09264251f, 0.03462388f, 0.41480708f, -0.69277275f, -0.07931181f, 0.07513338f, 0.13163291f, 
    0.27891809f, 0.31932092f, -0.10928260f, 0.03973551f, -0.05761694f, 0.34348086f, 0.26426008f, 0.40628722f, 
    0.40014374f, -0.14341228f, -0.09906484f, -0.05531412f, 0.40841502f, -0.28214705f, 0.11448319f, -0.12788168f, 
    -0.45252705f, 0.77773815f, -0.09369782f, -0.20543478f, 0.07853508f, -0.02438655f, 0.03704392f, -0.08459006f, 
    -0.50444645f, 0.09669814f, -0.23546171f, 0.22458024f, -0.54886043f, 0.44940367f, -0.11559550f, 0.24720944f, 
    0.42605698f, 0.03514794f, -0.03033471f, -0.10357647f, -0.02253503f, -0.13300747f, -0.00207963f, -0.00164708f, 
    -0.17240606f, -0.21076213f, 0.08264985f, 0.22276969f, -0.19559647f, -0.42530861f, -0.08883747f, -0.04923331f, 
    0.10131755f, -0.05170419f, -0.55574715f, -0.06171020f, 0.13162033f, -0.07606675f, -0.12459191f, -0.02438228f, 
    0.60859549f, 0.31159103f, 0.44964802f, -0.12730788f, 0.30358627f, -0.09976311f, 0.09318876f, -0.05446491f, 
    -0.07206947f, -0.07780481f, -0.08768378f, -0.05032362f, -0.16075578f, -0.14785305f, -0.01320579f, 0.06186324f, 
    0.05878908f, 0.05007283f, 0.07899089f, -0.16530707f, -0.02160496f, 0.06300268f, -0.11878346f, -0.05111863f, 
    -0.11654431f, 0.09136808f, 0.03022310f, -0.15283227f, -0.08885990f, 0.10247765f, 0.06287030f, 0.04020390f, 
    -0.05796055f, 0.09052244f, 0.10792960f, -0.05031119f, -0.12023451f, -0.07522319f, -0.11788043f, -0.12010929f, 
    0.04372837f, 0.03935359f, -0.12694208f, -0.11283830f, -0.13530475f, -0.15956391f, -0.06767108f, 0.04569754f, 
    -0.01972447f, 0.07069574f, 0.03476354f, -0.01613678f, -0.07479583f, -0.10415021f, -0.02059985f, 0.04416450f, 
    -0.01459067f, 0.01844397f, -0.12276295f, -0.09037459f, -0.03115545f, 0.08808733f, -0.09780842f, 0.09691128f, 
    -0.00579062f, 0.06837276f, 0.05762914f, -0.04560813f, 0.09351601f, 0.11625241f, -0.02652394f, -0.06857680f, 
    0.06779896f, -0.11467098f, -0.06388295f, 0.08597149f, 0.10684461f, -0.01663285f, 0.02794293f, 0.07046697f, 
    -0.07183629f, 0.02668807f, 0.01542650f, 0.04210256f, -0.04847452f, 0.00445043f, 0.05635169f, 0.08227213f, 
    -0.07958657f, 0.04478808f, -0.06090352f, -0.02446376f, -0.12335735f, 0.06637827f, -0.09044509f, 0.05353405f, 
    0.04809684f, 0.11815383f, 0.09224436f, 0.04868643f, -0.08946905f, 0.00499737f, -0.10073167f, 0.06439990f, 
    -0.12746598f, -0.13275138f, 0.08115105f, 0.08043078f, -0.10778701f, -0.12337418f, 0.10125887f, 0.06616172f, 
    -0.08693770f, -0.01678406f, -0.01542915f, -0.11386311f, -0.12959088f, -0.05471219f, -0.12550806f, 0.09889112f, 
    -0.01124673f, 0.05675975f, 0.09077661f, 0.06773499f, -0.02383854f, -0.11946572f, 0.03578879f, -0.03511345f, 
    -0.14357223f, 0.02372224f, -0.00446483f, 0.10865285f, 0.00737952f, -0.11945681f, 0.07433558f, -0.10819143f, 
    0.16660258f, -0.13026053f, 0.05105415f, 0.18011519f, -0.12710410f, -0.92992228f, -0.00880137f, -0.09104053f, 
    0.05943027f, 0.06786300f, 0.03229158f, 0.47019595f, -0.18947820f, -0.04254470f, -0.50231457f, 0.14878729f, 
    -0.03560695f, -0.37929294f, 0.34499538f, 0.26884767f, 0.26443553f, -0.00040372f, 0.18948619f, -0.18624137f, 
    -0.50761628f, -0.05996375f, -0.04360291f, 0.18261011f, 0.20101269f, -0.11496866f, -0.04042449f, 0.05493922f, 
    -0.14286560f, 0.11760328f, 0.04887527f, -0.13935617f, 0.04525658f, -0.02404248f, -0.10970144f, 0.41076759f, 
    0.24571913f, -0.07321400f, 0.37692094f, -0.03891302f, 0.19830827f, 0.39348674f, 0.17433815f, 0.32551494f, 
    0.43450314f, 0.16726026f, 0.13490452f, -0.14087875f, 0.07416220f, -0.15634583f, -0.45533523f, -0.04229432f, 
    -0.21506204f, -0.01471583f, -0.08582812f, -0.20401040f, 0.40235919f, 0.16623423f, -0.19956245f, 0.04526719f, 
    0.07791545f, 0.44300765f, -0.04787916f, -0.19085902f, 0.22744346f, 0.02217990f, -0.17925371f, 0.01035773f, 
    0.12529069f, -0.23186150f, -0.60579956f, -0.21948609f, -0.01531537f, 0.11623932f, 0.02403306f, 0.17729197f, 
    0.11235567f, -0.04179261f, 0.00483163f, 0.06021633f, -0.01502013f, 0.00786512f, 0.06763310f, 0.27007046f, 
    0.07259930f, -0.02366418f, 0.36922652f, 0.10413347f, -0.33195513f, 0.23099087f, 0.10099841f, 0.03100612f, 
    0.28440979f, -0.06512389f, -0.25547206f, 0.01407282f, 0.19829009f, 0.18016244f, 0.05813066f, 0.07781345f, 
    -0.24648768f, 0.39369917f, 0.02582338f, 0.42336166f, 0.05073255f, -0.04996902f, -0.26203829f, 0.11360514f, 
    -0.07747302f, 0.04101582f, 0.23247363f, -0.29080418f, -0.10015643f, -0.32058346f, -0.09055226f, 0.08006049f, 
    0.24416332f, -0.06508812f, 0.11477797f, 0.44264358f, -0.06417467f, -0.24184591f, 0.41234806f, -0.00021227f, 
    0.14114805f, 0.29427338f, 0.02503540f, -0.03022150f, 0.08590586f, 0.14287156f, 0.01626057f, -0.09229892f, 
    -0.13195845f, 0.12365177f, -0.29425868f, 0.20991021f, -0.18751194f, -0.05609696f, 0.17755623f, 0.17754243f, 
    -0.02448514f, 0.16806784f, 0.53189218f, 0.09369905f, -0.16148116f, 0.10574286f, -0.01246431f, 0.05081999f, 
    0.57631105f, -0.08222823f, 0.30895951f, -0.12710786f, 0.08221424f, 0.03326588f, -0.27641693f, -0.29162052f, 
    0.72236741f, -0.18906856f, -0.08809853f, -0.06238899f, -0.21221596f, -0.01608696f, 0.05513084f, 0.06618413f, 
    0.06657983f, 0.18256387f, -0.34562835f, -0.06987271f, 0.04011077f, -0.22667283f, -0.10622245f, 0.23004702f, 
    0.11547146f, 0.24067156f, 0.35121605f, -0.18570903f, -0.23915607f, -0.15325639f, 0.18805298f, -0.04658484f, 
    -0.03272645f, -0.19564173f, 0.11586151f, 0.14123023f, -0.85931081f, -0.15211275f, 0.09066610f, 0.17080785f, 
    -0.01190149f, 0.12742144f, -0.04918511f, 0.29164168f, -0.11109543f, -0.30429959f, 0.28228304f, 0.09819105f, 
    0.20318800f, 0.06501456f, 0.04765219f, 0.29257163f, -0.39724189f, -0.06868455f, 0.17213669f, 0.08445356f, 
    -0.09551257f, -0.42247054f, -0.20880717f, 0.07816035f, 0.62179810f, 0.03413050f, -0.00821353f, -0.14715028f, 
    0.44730908f, 0.02208079f, 0.05813363f, -0.05079922f, -0.03607945f, -0.00333983f, -0.03388995f, -0.00235134f, 
    -0.07425068f, 0.07931378f, 0.17722452f, -0.01216164f, 0.16542061f, -0.17165735f, 0.04529100f, -0.00976971f, 
    0.12214927f, -0.16175753f, -0.28679681f, -0.14594479f, -0.11157250f, -0.58503997f, 0.24645722f, 0.37404799f, 
    0.35683009f, 0.03835035f, -0.04891707f, 0.33168882f, 0.50066686f, 0.21150501f, -0.24065521f, -0.03297611f, 
    0.09970973f, 0.27469742f, 0.09903151f, -0.07532424f, -0.19473673f, 0.42848030f, -0.29358312f, 0.26286107f, 
    0.18775111f, 0.21234187f, -0.12317893f, 0.05109455f, 0.35213760f, -0.63719511f, 0.03894024f, -0.22095495f, 
    0.47574487f, -0.44546494f, 0.01932930f, -0.16776164f, -0.33429497f, 0.17598374f, -0.09462491f, -0.07357677f, 
    0.00927567f, 0.38627943f, 0.16973963f, 0.30906922f, -0.06969228f, -0.02797112f, 0.08715244f, 0.30173394f, 
    0.11447070f, -0.03063588f, 0.30768505f, 0.29997486f, 0.03821859f, -0.21951590f, 0.09475189f, 0.27781883f, 
    0.09611348f, 0.09705032f, -0.13928474f, -0.05227184f, 0.02150877f, 0.21620700f, -0.08198313f, 0.35499266f, 
    -0.15614460f, 0.23616935f, 0.54932588f, 0.16722056f, 0.03502766f, -0.40153766f, 0.04792715f, 0.13026915f, 
    -0.06692453f, 0.13567936f, 0.04686331f, -0.44235450f, -0.00984227f, 0.04921527f, -0.16818063f, 0.09836465f, 
    -0.39962232f, -0.10810303f, -0.07819437f, 0.26536348f, 0.44252601f, -0.03023074f, 0.26309294f, -0.07324145f, 
    -0.00401179f, 0.00386809f, 0.10402346f, -0.10170802f, 0.02933275f, 0.07166841f, 0.05504999f, -0.01357735f, 
    -0.05856006f, 0.02316380f, 0.06537704f, -0.03005283f, -0.12317332f, -0.03967568f, 0.00737702f, -0.09424805f, 
    -0.11084273f, 0.00310966f, 0.07154070f, -0.16590056f, -0.06960197f, -0.04113673f, 0.07044339f, -0.09703135f, 
    -0.06053245f, -0.11666717f, -0.02127893f, 0.03642654f, 0.04710542f, 0.01801585f, -0.01232304f, -0.14848137f, 
    -0.01327252f, 0.01129035f, -0.01132076f, 0.11815830f, -0.15204595f, -0.09483550f, -0.08489738f, -0.05354506f, 
    -0.01034098f, 0.07335849f, -0.08908451f, -0.01966635f, -0.12771386f, 0.01823021f, 0.02086071f, -0.02592385f, 
    -0.05306221f, -0.00314689f, 0.05811435f, -0.07445805f, -0.11832277f, -0.13715751f, -0.10219418f, 0.10668546f, 
    -0.02574136f, 0.01806052f, -0.09701752f, -0.12060767f, -0.04326932f, -0.03551257f, -0.13176258f, -0.02527028f, 
    -0.24067654f, 0.01212876f, 0.09261207f, -0.01267925f, -0.31367135f, -0.76957965f, -0.12329441f, -0.17819521f, 
    -0.09848134f, 0.08356643f, 0.74871153f, 0.09688532f, 0.68944573f, -0.05737934f, -0.00419830f, 0.13607237f, 
    -0.24825631f, 0.10381135f, -0.18848167f, -0.23964804f, 0.26013523f, 0.08616301f, 0.12064849f, -0.20103607f, 
    -0.04334758f, 0.04892261f, -0.60408521f, -0.11854053f, 0.25259486f, 0.31743613f, 0.04886840f, 0.03535182f, 
    -0.00051567f, 0.28105226f, 0.23207837f, 0.01319443f, -0.05234348f, -0.20747058f, 0.04323381f, 0.15491629f, 
    0.21566485f, -0.35081315f, 0.03632542f, 0.47197282f, -0.03952754f, 0.45689982f, 0.07066439f, 0.16236758f, 
    0.56266552f, -0.16236724f, 0.24676526f, -0.61355233f, -0.37584856f, -0.42947483f, 0.37923041f, -0.13619669f, 
    0.79134750f, -0.24144714f, 0.66832852f, 0.05727070f, -0.17883800f, 0.03827908f, 0.37008941f, 0.03222826f, 
    -0.02669762f, 0.06021995f, -0.04375744f, 0.07683785f, 0.12315386f, 0.29922462f, 0.28433773f, -0.22109738f, 
    -0.03606324f, -0.09787337f, -0.42011523f, -0.10075785f, -0.20617302f, 0.20500816f, 0.43400297f, 0.07556574f, 
    0.23930007f, 0.47624278f, 0.20165759f, -0.10568367f, -0.03845714f, 0.00654271f, 0.09556945f, 0.38157174f, 
    0.04137934f, -0.04754633f, 0.10803897f, -0.29042923f, 0.15410024f, 0.04421761f, 0.25608921f, -0.12395903f, 
    0.15637675f, -0.16739681f, 0.28523636f, 0.05545756f, 0.06724304f, 0.30569136f, -0.00770896f, -0.04841530f, 
    0.07967923f, 0.08935853f, -0.31634286f, -0.24023949f, 0.14305598f, -0.25863808f, 0.13848472f, 0.03150028f, 
    -0.16879450f, 0.26941180f, 0.22174945f, -0.00747423f, -0.08915837f, 0.18080476f, 0.35856822f, -0.13170980f, 
    -0.30090052f, 0.03859412f, 0.02588117f, 0.38135415f, -0.17983177f, -0.00783486f, 0.10734174f, 0.02033782f, 
    -0.18990600f, -0.11239629f, 0.05986471f, 0.29399842f, -0.62870628f, -0.46420681f, -0.09924472f, -0.09326872f, 
    -0.23002470f, 0.32504633f, -0.00652885f, 0.34712675f, 0.50518286f, -0.21403839f, -0.13718487f, 0.24477240f, 
    0.05264961f, 0.29389229f, -0.11382988f, -0.06255303f, 0.28132433f, -0.02776462f, 0.22297437f, -0.29462481f, 
    -0.11449127f, 0.09859231f, -0.14628081f, -0.39287436f, 0.12768817f, 0.27038810f, -0.14504579f, -0.57745689f, 
    0.14233512f, -0.21952409f, 0.12222122f, 0.07456207f, -0.19014367f, -0.17398326f, 0.12441868f, 0.41339538f, 
    0.07656100f, -0.21388310f, -0.79185253f, -0.07118925f, 0.26348361f, -0.44292951f, 0.10439083f, 0.17806888f, 
    0.47270152f, 0.05992501f, 0.06337101f, -0.17882210f, 0.35997513f, 0.07268283f, 0.18385291f, 0.07535660f, 
    0.33942017f, 0.16213006f, 0.25174123f, -0.01883616f, -0.32737961f, 0.24518634f, -0.63015854f, 0.22246619f, 
    0.03359998f, -0.01845510f, -0.00759280f, -0.02229713f, -0.03080968f, -0.09996004f, -0.09433579f, 0.07461112f, 
    0.03727338f, -0.03612993f, 0.00514189f, -0.05572496f, -0.00909543f, -0.12890789f, 0.08808447f, -0.01068958f, 
    0.06636194f, 0.08326487f, 0.11082073f, -0.15178092f, 0.07330033f, -0.06679468f, -0.00976313f, -0.10289857f, 
    0.04860170f, -0.09326495f, 0.01690514f, -0.07152410f, 0.02444790f, -0.05641386f, -0.09942356f, 0.00124239f, 
    -0.02718781f, 0.10155714f, -0.12747905f, -0.08778651f, 0.02403165f, -0.00190221f, -0.11974561f, -0.00440487f, 
    -0.06691665f, -0.00690672f, -0.00836478f, 0.05355155f, -0.12817976f, 0.12424213f, -0.09085752f, -0.11484485f, 
    -0.07040236f, -0.01655870f, -0.05561847f, 0.04764856f, -0.00289638f, -0.05783604f, 0.09885262f, -0.11793657f, 
    0.00560866f, 0.07971693f, 0.06742769f, -0.05487132f, -0.11113606f, 0.07045297f, 0.07189330f, -0.13537715f, 
    -0.08305591f, -0.15342201f, -0.03565656f, -0.07021737f, -0.07680084f, -0.03201178f, 0.00627279f, -0.12479850f, 
    -0.10959723f, -0.07933709f, -0.07867900f, 0.00323790f, -0.11583480f, -0.06761290f, 0.01598570f, -0.02258834f, 
    -0.10231102f, -0.01378314f, -0.03309424f, -0.02521353f, 0.08257146f, 0.08111662f, 0.02611329f, 0.04527462f, 
    0.02169226f, -0.05247587f, 0.06044927f, 0.00430936f, -0.12573498f, -0.02864305f, -0.03734874f, 0.00368364f, 
    0.06069646f, -0.03821957f, -0.12502441f, 0.10871491f, -0.12797880f, -0.04214586f, 0.11399026f, 0.05845836f, 
    0.00792876f, -0.11406587f, -0.07033540f, -0.04005601f, -0.06482835f, 0.10533662f, -0.01225764f, -0.11754718f, 
    -0.01597698f, -0.02689658f, -0.09041047f, 0.09109841f, -0.08031753f, -0.06290762f, 0.06297134f, -0.11744441f, 
    -0.06633918f, 0.08155995f, 0.07498522f, 0.02378867f, 0.04971197f, -0.02320042f, 0.03192366f, 0.00708206f, 
    0.09731368f, -0.37794077f, -0.04128464f, 0.44232610f, -0.37801686f, -0.40708140f, 0.29633662f, -0.01683225f, 
    -0.17005639f, 0.22881910f, -0.21030530f, 0.14694561f, 0.04669541f, 0.25108567f, 0.33029321f, 0.07394060f, 
    0.09313682f, 0.12453109f, 0.06457730f, -0.17496988f, 0.20294596f, -0.07752164f, 0.16442789f, 0.02590256f, 
    -0.24397147f, -0.01042370f, -0.21377251f, -0.22871210f, 0.22370018f, -0.05891770f, 0.05885850f, -0.10599924f, 
    -0.59648579f, 0.03806989f, 0.29204097f, 0.05466443f, 0.14613190f, -0.03594000f, 0.02578758f, 0.07231506f, 
    0.35921121f, -0.01313308f, -0.01158742f, -0.55728132f, 0.04027235f, -0.70638233f, 0.36536330f, 0.12043444f, 
    0.06967708f, 0.03926975f, -0.19660102f, 0.20314188f, 0.01439703f, 0.51137877f, 0.04601440f, -0.02989736f, 
    -0.09973125f, 0.27462295f, -0.21491936f, -0.17287037f, 0.46600291f, 0.25570682f, -0.21675687f, 0.11228751f, 
    -0.17271948f, -0.14712846f, 0.08801262f, 0.03940753f, -0.27900538f, -0.97950238f, 0.04539417f, 0.03849503f, 
    -0.29831067f, 0.29317045f, 0.40624040f, 0.37341481f, 0.42484373f, -0.15332587f, -0.04598609f, 0.03936402f, 
    -0.03877264f, 0.14178690f, -0.39469457f, -0.39988410f, 0.25175160f, 0.11046791f, 0.18835191f, -0.25505146f, 
    -0.18683338f, -0.01865670f, -0.72622472f, -0.02282800f, 0.34746036f, 0.06755868f, 0.04783571f, -0.07628400f, 
    -0.09862469f, 0.22616458f, 0.30645812f, -0.06309088f, -0.11321470f, -0.13744000f, -0.07755388f, 0.57470781f, 
    0.26103580f, -0.18584447f, 0.08389266f, 0.19708423f, 0.02784178f, 0.20419231f, 0.17334850f, 0.15824902f, 
    0.66847283f, -0.08026840f, 0.10914858f, -0.52539748f, -0.17305169f, 0.01890976f, 0.22019681f, 0.08919933f, 
    0.51873243f, -0.03091035f, 0.30205286f, -0.26327389f, -0.06139747f, 0.04420626f, 0.07376271f, 0.08605204f, 
    -0.07278059f, -0.06100285f, 0.01494184f, 0.34097910f, -0.33277324f, -0.19486427f, 0.29173771f, -0.41183925f, 
    0.07466806f, -0.32554770f, -0.06603062f, 0.01709016f, -0.27979046f, -0.00270052f, 0.02449987f, 0.07867424f, 
    0.14022554f, -0.45395544f, 0.37788332f, -0.02524695f, 0.21732062f, -0.11381361f, 0.19021790f, -0.31483114f, 
    -0.04916000f, -0.09373762f, 0.31559864f, -0.11110025f, 0.36506101f, -0.08399406f, 0.18630275f, 0.02943392f, 
    -0.23198099f, 0.09990001f, 0.20705301f, 0.03868758f, 0.02776594f, -0.10908506f, -0.03175699f, 0.08360573f, 
    0.36563230f, -0.31414565f, -0.26107472f, 0.30852214f, -0.10644659f, -0.06092384f, 0.13222487f, 0.40279314f, 
    0.31075442f, 0.18936390f, 0.29548317f, -0.10282186f, -0.09318288f, 0.12969847f, -0.17222314f, -0.05039604f, 
    -0.12589875f, 0.13904428f, -0.04441258f, 0.09364885f, -0.16032098f, 0.14745903f, 0.13235542f, 0.02175881f, 
    0.02187227f, -0.20928487f, 0.03253503f, 0.17221065f, -0.27126074f, 0.14051335f, 0.22979268f, 0.22044301f, 
    0.30447090f, 0.26531908f, 0.39906028f, 0.04321523f, 0.00702377f, -0.14933036f, -0.07968777f, -0.43512687f, 
    -0.12647486f, 0.60685199f, -0.53465331f, 0.00289577f, 0.38374296f, -0.05868225f, -0.12717158f, -0.16997972f, 
    -0.79711866f, 0.10002114f, -0.86243856f, 0.17554699f, -0.21655461f, 0.09667341f, 0.13425840f, 0.07963861f, 
    -0.41427642f, 0.15794770f, 0.13322885f, -0.00478673f, 0.11455214f, 0.08264381f, 0.03842285f, -0.41004199f, 
    0.14356855f, -0.24201477f, -0.11940911f, -0.35430035f, -0.05299893f, -0.35932022f, -0.00122835f, 0.28962964f, 
    0.18363981f, -0.11882545f, -0.60483545f, -0.04117230f, 0.50340903f, 0.25926074f, -0.17384905f, 0.11514857f, 
    0.09205735f, 0.27345535f, -0.19713245f, -0.14358284f, 0.09773294f, 0.40430850f, -0.66410589f, -0.09261885f, 
    0.23536463f, -0.42337051f, -0.07476468f, -0.36227512f, 0.27284756f, 0.42460054f, -0.07017536f, 0.24088317f, 
    -0.05638292f, 0.62157440f, 0.21414429f, 0.13086773f, 0.05752594f, -0.04511870f, 0.11558599f, 0.21202427f, 
    0.25597006f, 0.19793712f, 0.24222091f, 0.24530937f, -0.71091211f, 0.03833668f, -0.16724028f, 0.24662152f, 
    0.05456283f, 0.08540857f, 0.06013557f, 0.24342422f, 0.18734533f, -0.41370192f, -0.04092400f, -0.26301876f, 
    0.12501122f, -0.56984913f, -0.08503687f, 0.07433856f, -0.01043131f, 0.00667898f, -0.03519195f, 0.48818797f, 
    0.04084241f, 0.36161512f, 0.11807666f, -0.18062374f, 0.19581839f, 0.70149708f, 0.26297131f, -0.66458774f, 
    -0.29838327f, 0.00636264f, 0.07579166f, 0.29410538f, -0.20030914f, 0.13875657f, 0.34364805f, 0.00808948f, 
    -0.04688969f, -0.24166773f, -0.40852553f, 0.00345362f, -0.13958156f, 0.03530145f, -0.04930552f, -0.00941189f, 
    0.12750694f, 0.00607222f, 0.07509257f, 0.22351381f, -0.04701518f, -0.25575587f, 0.40158111f, -0.11238071f, 
    0.01332614f, 0.12395040f, -0.02181935f, 0.16661455f, -0.08275725f, 0.12750594f, 0.26445362f, 0.03218583f, 
    0.03331499f, 0.03082364f, 0.01027346f, -0.20775747f, 0.12695096f, 0.05841635f, 0.22680871f, -0.04269141f, 
    -0.01776979f, 0.07015258f, -0.04977453f, 0.07231642f, 0.29156202f, 0.04839915f, 0.07941767f, 0.11393372f, 
    -0.20244911f, 0.21298620f, 0.13772307f, -0.03774900f, 0.09837584f, 0.02572323f, 0.04647738f, -0.04009610f, 
    0.13394178f, -0.23704220f, -0.21586418f, -0.37417090f, -0.16427587f, -0.39009908f, 0.33533549f, 0.17544192f, 
    -0.02569674f, 0.10858873f, 0.02559787f, -0.17571057f, 0.01578532f, 0.35543305f, 0.01674090f, 0.07935708f, 
    -0.02083146f, -0.02081976f, -0.11734462f, -0.24348782f, -0.27266499f, 0.14964725f, 0.05453508f, 0.01042147f, 
    0.01557353f, -0.32081613f, 0.08428296f, 0.39394996f, -0.23810557f, 0.11459191f, 0.16593646f, -0.10579269f, 
    0.01130154f, 0.14115731f, -0.10259283f, 0.00591444f, -0.16602243f, 0.21645756f, 0.11915745f, -0.06548424f, 
    0.18143529f, 0.69919151f, -0.11871120f, -0.07800518f, 0.26073390f, -0.08361655f, 0.17425941f, -0.02508296f, 
    0.21262161f, -0.05425286f, 0.00065548f, -0.23623402f, 0.02570624f, -0.09909473f, 0.06640106f, -0.15638386f, 
    -0.49236640f, 0.04531309f, 0.23377039f, 0.07520532f, 0.06422912f, 0.22411764f, 0.06975077f, -0.39592412f, 
    0.19104417f, 0.02425036f, -0.42404765f, -0.97283185f, 0.10072262f, -0.86095554f, 0.26278946f, 0.01112088f, 
    -0.07129627f, 0.04779077f, -0.24844629f, 0.40385705f, 0.30540946f, 0.47869074f, 0.07570171f, 0.10076024f, 
    -0.47080538f, 0.45901749f, -0.38442957f, -0.05510111f, 0.07715955f, 0.31675908f, -0.48202860f, 0.04091949f, 
    -0.00968195f, 0.03874777f, 0.09326623f, -0.06131465f, -0.02360719f, 0.14146449f, -0.06526113f, -0.07821096f, 
    -0.13546585f, 0.07628493f, -0.10297485f, -0.00919766f, 0.04904516f, -0.12076310f, 0.12222867f, -0.01367938f, 
    -0.16634905f, -0.03486384f, 0.01364100f, -0.08441204f, -0.00734693f, 0.07135406f, 0.06979477f, -0.10058725f, 
    -0.00564721f, 0.05119897f, -0.04744179f, -0.00703888f, -0.11961856f, -0.01242237f, -0.03135730f, -0.00651328f, 
    -0.12781951f, -0.00378389f, -0.06736989f, 0.12383831f, -0.10180696f, 0.05573820f, -0.05452752f, 0.08698583f, 
    -0.08304064f, 0.07417430f, 0.10840003f, -0.05599397f, -0.14172946f, 0.00029188f, 0.01421949f, 0.05665997f, 
    0.06474736f, -0.02248490f, -0.02216637f, -0.08836558f, -0.06176938f, -0.11351039f, -0.05093819f, -0.07479043f, 
    -0.04574022f, -0.10266323f, 0.02729160f, 0.07149977f, 0.08755482f, 0.01878067f, -0.04210124f, 0.04780623f, 
    0.06814831f, 0.32200056f, -0.05986509f, -0.02468219f, 0.04704272f, 0.52509600f, -0.11072853f, 0.30235705f, 
    0.20824532f, -0.30309102f, 0.03412323f, -0.08563200f, 0.21845382f, -0.33894479f, -0.45642710f, -0.06287492f, 
    -0.21683487f, 0.61260360f, -0.19097047f, 0.08379884f, 0.27378362f, -0.07284234f, 0.00722366f, -0.23005500f, 
    0.05721981f, -0.09728003f, 0.16312687f, 0.25986573f, -0.07798884f, 0.42339829f, 0.15150166f, 0.17142364f, 
    0.28518769f, 0.27858502f, 0.16004267f, -0.03254576f, -0.04128762f, -0.02962761f, -0.03378174f, -0.28476715f, 
    0.00930075f, 0.10028913f, 0.12248306f, 0.25094700f, -0.06436352f, 0.09156917f, -0.41566479f, -0.02870050f, 
    0.10346850f, 0.05748931f, -0.06000609f, -0.50746071f, 0.21638553f, -0.41377616f, -0.42783171f, -0.06397695f, 
    0.39506939f, 0.30770791f, 0.34344509f, 0.26033872f, -0.22387865f, -0.09821866f, 0.09452982f, 0.17047945f, 
    -0.00511806f, -0.08666021f, 0.02059069f, 0.07166870f, -0.10128043f, -0.04758589f, -0.17711583f, 0.00561585f, 
    -0.15855095f, -0.02387846f, -0.07358756f, -0.07810252f, 0.09854118f, 0.00606699f, -0.08425587f, 0.03798568f, 
    -0.07715043f, -0.00011326f, -0.10322432f, 0.11449791f, -0.14424901f, 0.01345916f, 0.03461714f, -0.07362379f, 
    0.03686939f, 0.07139991f, -0.04464578f, -0.01204935f, 0.08968200f, 0.01189754f, -0.04130661f, -0.08158387f, 
    -0.09781249f, -0.06927814f, -0.00435109f, 0.07630318f, -0.01895089f, -0.05326426f, -0.09229295f, -0.12557887f, 
    -0.00246753f, 0.09642319f, 0.08504533f, -0.15784574f, -0.08333008f, 0.04697816f, -0.11240736f, 0.08093163f, 
    0.04730958f, 0.07690334f, 0.06333560f, 0.09115580f, -0.08030178f, -0.06953831f, 0.01916139f, -0.03161833f, 
    -0.03967804f, 0.05240510f, -0.08951605f, -0.10761612f, -0.13615783f, 0.05720100f, -0.16262197f, -0.08293364f, 
    0.11742999f, -0.16008022f, -0.09783562f, 0.30756319f, -0.11496505f, -0.79948539f, -0.10197423f, -0.04101978f, 
    0.00769729f, 0.25081003f, -0.35512492f, 0.33895895f, -0.52999312f, -0.02323885f, -0.43245777f, 0.26085186f, 
    0.06810091f, -0.42083237f, 0.25975963f, 0.27500853f, 0.23786664f, -0.07328542f, 0.46586597f, -0.05955031f, 
    -0.12731612f, 0.03428391f, 0.36122745f, 0.06150292f, 0.14340690f, -0.14775057f, -0.18445446f, -0.08193270f, 
    0.07440601f, -0.01981262f, -0.06951611f, 0.07709152f, -0.06322909f, -0.10374872f, 0.08685128f, 0.06217276f, 
    0.00212634f, -0.17111064f, -0.51674277f, 0.03809075f, 0.21707481f, 0.32977411f, -0.04782300f, 0.29929963f, 
    0.00445934f, 0.18114205f, 0.05471879f, -0.14946763f, 0.12138650f, 0.05599060f, -0.59339488f, 0.06771280f, 
    -0.42197689f, -0.08549061f, -0.31888348f, 0.12439964f, 0.11310405f, 0.13417673f, -0.00096454f, 0.13461901f, 
    -0.00302842f, -0.11479274f, -0.03975473f, -0.06395046f, 0.09376614f, 0.08061644f, -0.13217723f, -0.07559961f, 
    -0.00219518f, -0.03660440f, 0.01614833f, -0.03592654f, -0.07852519f, 0.03629986f, -0.05917834f, 0.09890988f, 
    -0.04178596f, 0.10878086f, 0.04007634f, -0.01888778f, 0.05897231f, -0.06557395f, -0.08434051f, 0.00628792f, 
    -0.02026476f, 0.07345648f, -0.00195151f, -0.07288364f, -0.05424370f, -0.13375723f, -0.04199423f, -0.14189810f, 
    0.07544637f, 0.07175861f, 0.06516902f, -0.01783890f, -0.11936319f, -0.09764083f, -0.06043373f, 0.07130035f, 
    0.07162566f, -0.08358228f, -0.01891099f, 0.00175552f, -0.13894059f, 0.04191869f, -0.09118478f, -0.07807000f, 
    0.07132304f, -0.13439707f, -0.00389057f, 0.00199711f, -0.06623694f, -0.07123838f, 0.10993086f, 0.06271650f, 
    0.07187463f, -0.14999780f, -0.10930567f, -0.03348162f, -0.06039305f, 0.03769037f, 0.05250074f, 0.06406281f, 
    0.26174927f, 0.07792441f, 0.08395329f, 0.22388847f, -0.11619188f, 0.27077806f, 0.24002744f, 0.08607791f, 
    0.13391840f, -0.43330574f, -0.50067997f, 0.08007775f, -0.21382342f, 0.16377306f, 0.14122377f, -0.02532570f, 
    -0.12588072f, -0.65051776f, -0.08335169f, -0.03931942f, 0.02076529f, 0.02589422f, -0.04875826f, 0.15252212f, 
    -0.50819719f, -0.06397581f, 0.30625886f, 0.06701503f, 0.02745374f, 0.00492075f, 0.01272692f, 0.07271799f, 
    -0.23530155f, 0.18563014f, 0.14815682f, 0.11748581f, 0.11848119f, -0.18116759f, 0.03082919f, 0.26251248f, 
    -0.05855870f, 0.10462393f, -0.24185306f, 0.20088522f, -0.05815236f, -0.24430105f, 0.16017494f, 0.19934869f, 
    0.16275889f, 0.01949972f, -0.10408989f, -0.41024250f, 0.02204379f, 0.12328885f, -0.43890002f, 0.02377800f, 
    0.12260824f, 0.03940054f, 0.11858629f, -0.09441517f, -0.17125724f, -0.05369764f, -0.06252443f, -0.11954844f, 
    -0.07198633f, -0.10558438f, -0.09264413f, -0.10782021f, -0.00718284f, -0.08523007f, -0.07242068f, -0.09253918f, 
    -0.00384137f, 0.07122044f, -0.08262193f, -0.03508451f, -0.09422795f, -0.01805046f, -0.06927560f, -0.08833727f, 
    0.00302975f, -0.10401151f, -0.04726014f, -0.03988575f, 0.02091213f, 0.09438981f, -0.02669141f, 0.03877337f, 
    -0.06371525f, 0.05796950f, 0.04845427f, 0.01836998f, -0.07059459f, 0.06250332f, -0.14046524f, -0.10616446f, 
    -0.12128685f, 0.01143944f, -0.05027632f, 0.05484528f, -0.09914438f, -0.13492051f, -0.09265333f, -0.00021208f, 
    0.02652818f, -0.09961192f, 0.07717340f, 0.07995426f, 0.09930100f, 0.00708714f, -0.11040564f, -0.06851107f, 
    0.08198320f, -0.03285607f, 0.09604609f, -0.13777907f, 0.01217371f, 0.07567107f, 0.06880040f, 0.11374992f, 
    0.06906991f, -0.10309235f, -0.00687587f, 0.03901511f, -0.12284112f, 0.04682680f, -0.02507488f, 0.03548421f, 
    -0.09318930f, -0.11239855f, -0.09264669f, -0.14317799f, -0.02213986f, -0.01039670f, -0.13181239f, -0.05840676f, 
    -0.02732722f, 0.00064916f, 0.03786582f, -0.15538621f, -0.02510499f, -0.08347768f, 0.04557966f, -0.04186727f, 
    0.06407511f, 0.07796265f, -0.04200230f, 0.00716667f, 0.02213084f, -0.03445131f, 0.03661523f, 0.07446791f, 
    0.03687339f, 0.00835469f, 0.00687509f, -0.02508994f, 0.04470043f, 0.06095498f, -0.06852543f, -0.06738620f, 
    -0.07785856f, -0.11108499f, -0.07378799f, 0.10529916f, -0.13366786f, 0.08125685f, 0.00453188f, 0.09789445f, 
    -0.03140071f, -0.11654319f, 0.07950312f, 0.07548179f, -0.02888125f, -0.04078270f, 0.01839127f, 0.06817435f, 
    0.02782237f, -0.04943317f, -0.12341218f, 0.10948651f, -0.09168907f, -0.07259424f, 0.01645504f, 0.11704661f, 
    0.08107572f, -0.07772542f, -0.02494117f, -0.08415568f, 0.03986591f, 0.07516667f, -0.06955373f, -0.09231224f, 
    -0.03044697f, 0.02018716f, 0.05744781f, 0.06224661f, 0.03885992f, -0.20517230f, 0.03991400f, 0.04390477f, 
    0.16696796f, 0.06490468f, 0.03416355f, -0.18176107f, 0.02166372f, 0.32078797f, 0.07188108f, 0.03780426f, 
    0.15440848f, -0.08908544f, -0.36650696f, 0.10398441f, -0.06545562f, -0.00657888f, 0.10434595f, 0.21499500f, 
    -0.49943954f, -0.01362613f, -0.45714349f, 0.07507098f, -0.04953958f, -0.15028827f, 0.25007597f, -0.07180253f, 
    -0.32453117f, 0.06206549f, 0.19510068f, -0.08932382f, 0.24340039f, 0.19298604f, -0.10244858f, -0.24089450f, 
    0.09392171f, 0.11252870f, -0.41656643f, -0.32429236f, 0.11689942f, -0.25538599f, 0.22368678f, -0.20221503f, 
    -0.34308785f, 0.23663040f, -0.26396608f, 0.12240982f, 0.13622625f, 0.34022838f, 0.09925573f, -0.12124582f, 
    -0.09177876f, 0.18682954f, -0.30284610f, -0.15076225f, -0.17515838f, 0.09295288f, -0.12760845f, 0.21236134f, 
    -0.02030005f, 0.04818182f, -0.03987680f, -0.09537558f, -0.08971139f, -0.02130886f, 0.00216926f, -0.08029082f, 
    0.04377695f, 0.09698713f, -0.12220475f, -0.06484500f, -0.09231278f, 0.01692547f, 0.03577380f, 0.06407367f, 
    -0.03477815f, 0.08979931f, 0.06421398f, -0.08433637f, -0.11395772f, -0.09717743f, -0.05073591f, -0.04058526f, 
    -0.05083562f, -0.03180940f, 0.07585143f, 0.03236503f, -0.07777257f, 0.07942949f, 0.00112579f, -0.06030674f, 
    0.07950956f, -0.14525914f, 0.02201178f, -0.09769177f, -0.00214063f, 0.00406938f, 0.08998486f, 0.09752344f, 
    0.01294751f, -0.12739287f, 0.05556402f, 0.11561255f, -0.10145725f, -0.08395019f, -0.05403051f, -0.07578001f, 
    -0.06179459f, -0.01039080f, 0.04831859f, -0.04121737f, 0.03673443f, -0.10450426f, -0.12299032f, -0.11381516f, 
    0.05319706f, 0.04798001f, -0.09905905f, 0.05002461f, 0.04871780f, -0.13234773f, -0.06411260f, -0.12858070f, 
    0.22803408f, 0.10084357f, 0.07042877f, 0.13148534f, 0.02955504f, -0.27634022f, 0.05949121f, -0.09083068f, 
    0.27833408f, -0.13504924f, 0.76367897f, 0.36643136f, 0.27383879f, -0.04586068f, -0.14350304f, 0.06013237f, 
    -0.12025063f, -0.02729412f, -0.37484288f, 0.09963749f, 0.42239979f, -0.06946692f, 0.09802923f, -0.39283708f, 
    0.39482170f, -0.10637501f, 0.01362936f, 0.21012662f, -0.05081117f, 0.27391654f, 0.01198186f, 0.02746319f, 
    0.12657045f, 0.32288638f, 0.18187185f, 0.09172203f, 0.01838108f, -0.26965743f, -0.03546162f, -0.22786172f, 
    -0.03576438f, -0.41497001f, -0.24699867f, 0.42690212f, -0.31335583f, 0.46061280f, 0.03921068f, 0.21507578f, 
    0.62630004f, 0.15346704f, -0.17674612f, -0.25388172f, 0.09634624f, -0.21080466f, -0.21949309f, -0.06412932f, 
    0.42529979f, -0.08622466f, 0.39261612f, -0.34393853f, -0.42810798f, 0.25657573f, 0.02663716f, 0.13959979f, 
    -0.13657562f, 0.35971609f, 0.02041309f, 0.08183053f, 0.13153906f, -0.47745633f, 0.12014246f, -0.35065693f, 
    -0.00859468f, -0.51707906f, -0.36926949f, -0.06829504f, -0.40590024f, 0.29993945f, 0.14539559f, 0.08134681f, 
    0.19280934f, -0.07251152f, 0.22043505f, -0.30257598f, -0.03419630f, 0.06018382f, 0.14691076f, 0.28898996f, 
    -0.15837844f, -0.08834544f, 0.05804377f, -0.26971996f, 0.07453454f, -0.01781316f, 0.21140330f, -0.07442141f, 
    0.29897887f, -0.12459902f, 0.03664192f, 0.14386511f, 0.20228410f, 0.32956281f, 0.00691841f, 0.14391942f, 
    -0.05876459f, 0.18306763f, -0.11038251f, 0.05763430f, 0.09236413f, 0.01643151f, -0.00087550f, 0.27402294f, 
    -0.21783818f, 0.25429422f, 0.41689458f, -0.41830254f, -0.09370256f, -0.08901677f, 0.11247393f, -0.12538815f, 
    -0.50472921f, -0.17554855f, -0.01401161f, 0.42604986f, -0.06002862f, -0.19352537f, 0.54249978f, 0.11930000f, 
    -0.06573228f, 0.00954234f, 0.10361756f, -0.08801071f, 0.21291530f, 0.05776685f, 0.07342849f, -0.05027741f, 
    0.28338301f, -0.35460323f, -0.20558290f, -0.09211554f, -0.30118772f, 0.12662308f, 0.08851316f, -0.25283793f, 
    0.11995207f, 0.18780266f, 0.08237390f, -0.00826008f, -0.00372917f, -0.06986600f, -0.23386467f, 0.17576545f, 
    0.28406855f, 0.04612449f, 0.34642428f, -0.04579404f, 0.08993711f, -0.16255045f, 0.06634052f, 0.09457650f, 
    0.00821217f, -0.03321561f, 0.09227660f, 0.09199575f, 0.21520038f, 0.31750560f, 0.06542508f, -0.24703331f, 
    0.03237712f, 0.02139115f, -0.03990490f, 0.08451883f, 0.06368520f, 0.07942677f, -0.13399987f, 0.08314611f, 
    -0.26787335f, 0.11566580f, -0.05178890f, 0.29356357f, 0.07822016f, 0.27521700f, -0.06906575f, 0.03211739f, 
    -0.29613888f, 0.12547903f, -0.29383016f, 0.33475956f, -0.00787703f, 0.09421197f, 0.10783709f, 0.09186187f, 
    0.20488839f, 0.03092746f, -0.04225115f, 0.12435455f, 0.37774238f, -0.39453486f, -0.05011423f, 0.05158018f, 
    0.29236928f, -0.05602002f, 0.14161581f, -0.01418418f, -0.06944392f, 0.16380893f, -0.05641381f, 0.17448360f, 
    0.09713245f, -0.01742839f, 0.19999284f, 0.44414741f, -0.13491693f, -0.01945476f, 0.12673208f, 0.16043264f, 
    -0.24597605f, 0.00834960f, 0.28398716f, 0.33859426f, 0.03358202f, -0.08392706f, 0.01568826f, 0.00464518f, 
    0.07496189f, -0.04662329f, -0.11474065f, 0.15366323f, 0.19670533f, 0.17676070f, -0.03517145f, -0.09003517f, 
    -0.11773930f, 0.28639802f, -0.07689022f, -0.08114406f, 0.11144765f, -0.69885200f, -0.05289477f, 0.10893623f, 
    -0.19239773f, 0.09843425f, -0.19662414f, 0.15340786f, 0.13122877f, 0.24206381f, -0.29849666f, 0.00022769f, 
    -0.05314309f, 0.10882945f, -0.23908088f, -0.03785064f, 0.18873566f, -0.01981504f, 0.30074841f, 0.07120302f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.47617477f, 0.12049262f, 0.09856233f, -0.04211702f, 0.15496592f, -0.00603762f, 0.01411431f, 0.02222423f, 
    -0.09646719f, 0.06070354f, -0.07671662f, 0.48532289f, -0.05036869f, 0.02087324f, 0.00448984f, 0.19106589f, 
    0.06672076f, 0.34639752f, 0.10147652f, 0.15611963f, 0.21251073f, 0.20731649f, 0.22200112f, 0.12877581f, 
    -0.15075170f, 0.06115585f, 0.02149928f, 0.03709707f, 0.34411404f, -0.33523330f, -0.14766316f, -0.12561241f, 
    -0.07451371f, 0.24293162f, 0.10813393f, 0.12749238f, 0.06669930f, -0.02341182f, -0.11332919f, 0.39440691f, 
    0.11345156f, 0.06071777f, -0.06579217f, 0.07513715f, -0.08879018f, -0.02528261f, -0.09472085f, 0.15108605f, 
    0.40319103f, 0.14326155f, -0.15231560f, -0.07580820f, 0.02190598f, 0.30474886f, 0.09385514f, 0.13463660f, 
    0.03862447f, -0.15051225f, 0.26702401f, -0.05500093f, 0.01948625f, 0.19905972f, 0.27566555f, 0.23716848f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.10040979f, -0.09145667f, -0.57793599f, -0.06932726f, -0.22704697f, 0.41270468f, 0.01798098f, -0.46461168f, 
    -0.12322436f, 0.10346963f, 0.11752533f, 0.16804039f, 0.01266492f, 0.07999878f, 0.04015286f, -0.25380063f, 
    0.04827587f, 0.24842104f, 0.05463828f, 0.13833776f, -0.07978699f, -0.35495150f, 0.14749078f, 0.01009108f, 
    -0.06980556f, -0.05121749f, 0.03821256f, -0.15799737f, -0.35548091f, -0.67042392f, 0.06919445f, -0.11196665f, 
    0.10592958f, -0.46875033f, 0.05178020f, 0.07979651f, 0.07223093f, 0.10422808f, -0.11652953f, -0.12660187f, 
    0.14999133f, 0.03778452f, 0.05638579f, 0.12026317f, 0.07409728f, -0.07499214f, 0.02961556f, 0.15244326f, 
    0.04918170f, 0.01879807f, -0.03258256f, -0.09624482f, 0.03614137f, 0.01850556f, 0.05286056f, 0.03952242f, 
    0.05144844f, -0.04897174f, 0.19282940f, 0.10261094f, 0.22203299f, -0.27415490f, 0.19192374f, 0.29984829f, 
    -0.44626799f, 0.34122705f, 0.01895297f, 0.01217378f, 0.06977235f, 0.10278479f, 0.04083196f, 0.18231714f, 
    -0.14914517f, 0.08798966f, -0.05629296f, 0.28274283f, -0.26073387f, 0.19441094f, -0.09150310f, -0.42311969f, 
    0.59807473f, 0.03101975f, -0.07668502f, 0.07804819f, 0.13238907f, 0.26472214f, 0.03288137f, -0.05616911f, 
    -0.00681497f, 0.07998945f, 0.02974056f, -0.29194707f, -0.25727418f, 0.47728449f, -0.08834839f, 0.07865246f, 
    -0.45364571f, 0.22074308f, -0.24779141f, -0.44953805f, 0.03066213f, -0.04554285f, 0.26385280f, 0.13953933f, 
    -0.69584352f, -0.03741631f, -0.06002975f, -0.09254491f, -0.27141011f, -0.40240747f, -0.79670000f, 0.39229682f, 
    -0.09713896f, -0.30077443f, -0.10703646f, 0.05321598f, -0.03183016f, -0.37616029f, 0.01590870f, -0.05191568f, 
    0.06349966f, 0.03199920f, 0.10398307f, -0.03055158f, 0.10612671f, 0.11153570f, 0.09285270f, 0.14604533f, 
    -0.28223881f, 0.11941201f, -0.00142600f, -0.10315289f, -0.05711561f, 0.08338444f, 0.08005176f, -0.15661825f, 
    0.04587604f, 0.09886623f, 0.01581284f, 0.06948192f, 0.18561038f, -0.82575554f, -0.11172660f, 0.13656689f, 
    -0.29305011f, 0.14804259f, -0.67384648f, -0.18346035f, -0.02889535f, 0.31186005f, -0.30642337f, 0.26922837f, 
    -0.05562807f, -0.07072910f, -0.10214636f, 0.08398654f, 0.05322547f, -0.48343849f, -0.08354590f, -0.04888380f, 
    0.03686786f, -0.25392100f, 0.03202417f, -0.06059342f, -0.07853441f, -0.03162849f, 0.51690114f, 0.10441147f, 
    -0.00363168f, 0.01328545f, -0.00855921f, 0.14965895f, 0.38497308f, 0.30205652f, -1.47090530f, 0.13156269f, 
    0.25530550f, -0.01693220f, -0.06674234f, -0.97800386f, 0.01541780f, -0.28668472f, -0.04264164f, 0.05688812f, 
    0.00246331f, 0.05918911f, -0.02642514f, 0.05203459f, -0.13257863f, 0.08031454f, 0.03268312f, -0.57598597f, 
    -0.04671125f, -0.80528998f, -0.71675825f, 0.00433656f, -0.13835272f, 0.09188738f, 0.08984812f, 0.32326445f, 
    -0.09873462f, -0.06296103f, 0.03993070f, -0.47667053f, 0.19446211f, 0.04270216f, -0.01625049f, 0.06257540f, 
    0.00683465f, 0.15579981f, 0.01589060f, -0.64091635f, 0.12930767f, 0.19499728f, 0.12132835f, 0.17141071f, 
    -0.01858717f, 0.02177978f, 0.08314731f, -0.54314077f, -0.48058179f, -0.00580095f, 0.01770268f, -0.07948916f, 
    0.27405575f, -0.11674815f, -0.28534439f, 0.22009407f, -0.17901379f, 0.02308516f, 0.20785855f, -0.70614702f, 
    0.17554629f, 0.04565019f, 0.10915482f, 0.04623799f, 0.22884464f, 0.36577189f, 0.11000416f, -0.47153562f, 
    -0.09149761f, -0.07336206f, -0.08812623f, -0.09409470f, 0.01720718f, 0.15354744f, -0.04689954f, 0.08281172f, 
    0.01406608f, -0.00250196f, -0.32983989f, 0.10771220f, 0.20624830f, -0.40943298f, -0.36870822f, -0.11665690f, 
    -0.62469494f, -0.14850305f, -0.27696002f, -0.07199318f, 0.21441609f, 0.01573960f, 0.10555700f, 0.19980651f, 
    0.03722668f, -0.03060961f, -0.00172692f, 0.07994141f, 0.12180768f, -0.18294480f, -0.12599413f, -0.02611011f, 
    -0.07632752f, -0.43701985f, 0.18894821f, 0.02948092f, 0.09944459f, -0.19803515f, -0.11005605f, 0.19063762f, 
    0.04481589f, 0.00441870f, 0.03333563f, 0.22658084f, -0.10972340f, -0.09967031f, -0.05425715f, -0.03177530f, 
    -0.01604953f, -0.27844885f, 0.20904259f, 0.11368922f, -0.03630029f, -0.01620686f, 0.02903434f, -0.06358208f, 
    0.24966325f, 0.00458918f, -0.00321131f, 0.19838947f, 0.15871401f, -0.22563474f, 0.43163276f, 0.16348070f, 
    0.16381301f, 0.23477516f, -0.04531942f, -0.18232115f, -0.03892281f, -0.05933295f, 0.03146983f, -0.22906587f, 
    0.09832727f, -0.00489950f, 0.08413319f, -0.10120466f, -0.05133246f, -0.34795889f, -0.13309427f, 0.02238890f, 
    0.14837818f, 0.11246669f, 0.12208392f, -0.11367781f, 0.09576990f, -0.24190663f, -0.03576592f, -0.39059612f, 
    -0.16391595f, -0.08663948f, 0.09506967f, 0.19782999f, -0.02858214f, -0.06509444f, 0.03315021f, -0.20768325f, 
    0.29059929f, -0.16335139f, 0.23707503f, 0.14864577f, -0.15960348f, -0.17776194f, 0.08504778f, -0.05482933f, 
    -0.10529742f, 0.01438669f, 0.08189498f, 0.31271783f, 0.18478842f, 0.09989922f, -0.00480178f, 0.04742820f, 
    -0.50653666f, 0.19808133f, 0.14319985f, 0.19762293f, -0.02908473f, -0.06086814f, -0.32249954f, 0.10455208f, 
    -1.23600447f, 0.09176096f, -0.06078580f, -0.10559868f, -0.50818074f, -0.07189751f, 0.23480323f, -0.26447532f, 
    0.04685053f, 0.07742602f, -0.03204164f, 0.36106926f, -0.07470332f, -0.39767906f, -0.04544111f, 0.19532473f, 
    0.08292397f, 0.07678103f, 0.02044929f, -0.04843706f, 0.01516807f, 0.03088686f, 0.15718983f, -0.02299941f, 
    -0.31409714f, -0.00170640f, 0.10905271f, 0.07329840f, -0.33594027f, -0.16168295f, 0.03324732f, -0.08628167f, 
    0.01126049f, -0.07440605f, 0.04787875f, 0.03157734f, -0.00826554f, -0.07925705f, 0.02390281f, 0.07233024f, 
    -0.46328744f, -0.76454997f, 0.06600972f, 0.17216766f, 0.17024077f, 0.01575475f, 0.21896887f, -0.06428803f, 
    0.11719625f, -0.07604244f, 0.06910223f, 0.00420418f, -0.19456366f, -0.34748822f, 0.03278611f, 0.03652045f, 
    0.09429179f, -0.21079946f, -0.54391593f, 0.11085317f, -0.16865301f, 0.09475518f, -0.83722556f, 0.16980426f, 
    -0.03944307f, 0.02752428f, 0.07438882f, 0.25964740f, -0.30145049f, 0.20605181f, -0.20576508f, -0.30847374f, 
    0.12238007f, 0.28312978f, -0.04103590f, -0.07290076f, -0.00226583f, 0.01188877f, 0.11311559f, 0.02006578f, 
    0.00304447f, -0.00807020f, 0.22304367f, -0.09119534f, -0.85935420f, 0.08248676f, 0.05172123f, -0.06396291f, 
    0.12889151f, 0.12464368f, 0.40513185f, 0.07717193f, 0.14715993f, 0.09917674f, -0.04012457f, 0.00710677f, 
    0.04786845f, -0.02168729f, 0.00192452f, -0.66401911f, -0.09530143f, 0.14797622f, -0.10530727f, -0.08636012f, 
    0.20576544f, 0.02146943f, 0.25830320f, 0.19359548f, -0.73172593f, -0.12940188f, -0.77805674f, 0.13768394f, 
    0.04542471f, 0.05042735f, -0.00177709f, 0.22206245f, -0.02432058f, 0.36920041f, -0.05745156f, 0.01903469f, 
    -0.05495032f, 0.11169175f, 0.14248657f, 0.13536659f, -0.26418656f, -0.00288188f, 0.21789964f, -0.36915180f, 
    0.11169714f, -0.08388881f, 0.09250140f, -0.63133228f, 0.21879902f, -0.74350333f, 0.22882442f, 0.06981412f, 
    -0.58866221f, -0.40553564f, -0.03205260f, 0.39822984f, -0.07114431f, -0.53040445f, 0.08614209f, 0.06157577f, 
    0.04638093f, -0.06745616f, -0.47646776f, 0.05892648f, 0.26449034f, -0.22085315f, -0.37378544f, -0.20647204f, 
    -0.04927225f, -0.23959738f, 0.34197256f, 0.11609389f, 0.39564627f, -0.54294032f, -0.08937931f, -0.11197003f, 
    -0.11372124f, -0.05751803f, -0.07792980f, -0.09076504f, -0.88755995f, -0.05990446f, -0.10141683f, -0.34536231f, 
    -1.12546682f, -0.00003606f, -0.16740812f, 0.21947947f, 0.01874720f, 0.32038286f, -0.62760568f, -0.61734384f, 
    -0.08491447f, -0.07582869f, 0.06260944f, -0.41514602f, 0.31761989f, -0.04861413f, 0.05856454f, 0.12388877f, 
    0.21192057f, 0.46072438f, 0.38863149f, -0.66078281f, 0.28697351f, -0.11314595f, -0.23289265f, 0.04385683f, 
    -0.07810629f, 0.00811029f, 0.02859983f, -0.72519004f, -0.74316937f, 0.07807469f, 0.16394432f, 0.17652182f, 
    -0.49630478f, -0.99076205f, -0.11586743f, 0.15820590f, 0.01827047f, 0.43720055f, 0.02614992f, -0.48634446f, 
    -0.00035257f, 0.05263032f, -0.16995952f, -0.06771020f, -0.39134502f, 0.23088923f, 0.12102097f, 0.07225291f, 
    0.64809310f, 0.19514298f, 0.25757167f, -0.10156471f, -0.53572989f, -0.02527176f, -0.12350948f, -0.11058719f, 
    -0.06227997f, 0.10522699f, 0.02953671f, 0.12302765f, 0.01270369f, -0.24067040f, -0.01414689f, 0.00837473f, 
    -0.42639574f, -0.01812116f, 0.13140562f, 0.06788915f, -0.03040759f, -0.21172944f, 0.16216783f, -0.15939872f, 
    -0.02007041f, 0.06100229f, -0.07839054f, 0.12656887f, 0.17172945f, -0.23860741f, -0.05053188f, -0.06151961f, 
    -0.08433431f, -0.34138152f, -0.03608924f, 0.10928533f, -0.52969283f, 0.01853794f, 0.06033871f, 0.06028225f, 
    0.10874986f, -0.08978201f, -0.10123061f, 0.06661712f, -0.08501595f, 0.10763378f, -0.00723545f, 0.12267648f, 
    -0.02869090f, 0.25380644f, 0.09967112f, 0.35949740f, -0.04973839f, 0.15450843f, 0.05577052f, -0.15195826f, 
    0.07328003f, 0.07548340f, -0.02387504f, -0.05462901f, -0.12532051f, -0.07738917f, 0.08582532f, -0.20798153f, 
    -1.04155672f, -0.73333353f, 0.05144659f, 0.09190090f, 0.12570743f, -0.32441378f, -0.08836603f, 0.32752529f, 
    -0.01757903f, -0.09532749f, 0.07456195f, -0.86769521f, -0.21367976f, 0.06532273f, -0.09722993f, 0.22168328f, 
    -0.07536675f, 0.09171945f, 0.07506597f, -0.02734326f, 0.00312713f, 0.32297808f, -0.05340654f, 0.10954490f, 
    -0.04493450f, 0.09840048f, 0.07500415f, -0.81300700f, 0.10219719f, -0.08915380f, -0.06244516f, -0.12685315f, 
    0.14494623f, 0.22272825f, -0.24782708f, 0.10989939f, -0.03823451f, 0.08853027f, 0.25138786f, -0.08257244f, 
    -0.10708649f, 0.10377371f, -0.02191514f, -0.68402475f, 0.09380891f, -0.13458288f, -0.28000939f, -0.54671228f, 
    -0.09251624f, -0.99476939f, -0.05940320f, -0.13643730f, 0.09001478f, 0.23599638f, 0.10174803f, 0.09244533f, 
    0.09785147f, -0.11953001f, -0.05278848f, 0.09576683f, 0.16648138f, 0.38861898f, -0.25502151f, -0.01340149f, 
    0.27556664f, -0.59565228f, 0.09577534f, -0.10201877f, 0.10785555f, -0.29289615f, 0.02827909f, -0.30757612f, 
    -0.09971954f, 0.06006337f, -0.01752436f, -0.23919946f, 0.10629842f, -0.11398818f, 0.02929359f, 0.11325486f, 
    0.13924274f, 0.29114231f, -0.19893776f, -0.48248726f, -0.11446903f, -0.37657836f, 0.12419818f, -0.01118957f, 
    0.03841462f, 0.04310431f, -0.03594547f, 0.04969751f, 0.17499432f, -0.15182790f, -0.04607285f, -0.08612053f, 
    0.18189506f, 0.04647589f, 0.18025917f, 0.18631670f, 0.35684088f, 0.10396241f, -0.67185211f, -0.03129838f, 
    0.18059774f, 0.03648722f, -0.05885683f, 0.25309753f, -0.25785384f, 0.24356593f, -0.46952495f, -0.61950254f, 
    0.08455104f, 0.15344165f, -0.08621912f, -0.62644857f, 0.04824176f, 0.22471549f, 0.04540254f, 0.26271123f, 
    -0.08743103f, -0.03529760f, -0.11309234f, 0.10137449f, -0.08411487f, 0.02461854f, -0.04580196f, 0.22875498f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.18604292f, 0.05614963f, 0.01194951f, -0.26220086f, -0.10400941f, 0.17740415f, -0.07574672f, -0.28551596f, 
    -0.26373056f, -0.03079468f, 0.44840741f, 0.08046895f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
