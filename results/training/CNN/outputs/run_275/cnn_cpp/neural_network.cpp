#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.20480216f, 1.08930409f, 0.04891317f, -0.82370430f, -0.06600112f, 0.06306615f, -0.26296890f, 0.27475047f, 
    -0.30355555f, 0.38781971f, 0.13135003f, 0.56595343f, -0.18127029f, 0.01375041f, -0.10528534f, -0.13480911f, 
    -0.13268931f, -0.40187722f, -0.26952830f, 0.16752039f, -0.12277281f, 0.19897792f, -0.13785830f, -0.18076175f, 
    -0.11577214f, -0.56651515f, -1.00474024f, -0.90836763f, -0.68576396f, 0.43757477f, -0.59014881f, 0.03879819f, 
    0.67746145f, -0.09067667f, -0.13658649f, 0.00951107f, -0.07086049f, 0.03227747f, 0.17228751f, 0.49231032f, 
    0.50025749f, 0.29242387f, -0.18281949f, 0.33071584f, 0.26092607f, 0.12853710f, -0.26191044f, -0.01728014f, 
    -0.23489070f, 0.38631842f, 1.11342657f, 0.32327783f, 0.90886039f, 1.06039786f, 0.56871784f, 0.64314997f, 
    0.13233341f, -0.46969271f, 0.40769869f, -0.09026165f, 0.21285652f, 0.06323145f, -0.56218356f, -0.21374430f, 
    -0.25931773f, -0.01150046f, -0.55888015f, -0.25956327f, -0.27054632f, -0.24108700f, 0.17741497f, 0.06624997f, 
    0.32285336f, 0.01662279f, -0.07240874f, 0.93908608f, 0.71426022f, -0.21664055f, 0.80904871f, 1.16201401f, 
    -0.30123335f, -0.41048783f, -0.29148662f, 0.66935378f, 0.40330058f, -0.11466870f, 0.52916318f, 0.02439546f, 
    0.51509994f, -0.29797578f, 0.11305875f, -0.01268396f, -0.03170612f, -0.08540087f, -0.33100981f, 0.30511340f, 
    0.01626986f, 0.03370978f, -0.00343554f, 0.41317004f, 0.60450828f, 0.57455057f, 0.73572230f, -0.87680984f, 
    -1.22601497f, 0.00485601f, 0.01073662f, -0.57105410f, -0.75982529f, -0.06472092f, 0.40462470f, 0.70165974f, 
    -0.37176284f, 0.00906899f, 0.28767660f, 0.01392761f, 0.09986625f, 0.19419207f, -0.01968414f, 0.35911447f, 
    0.10557157f, 0.09116955f, -0.03711915f, -0.01955696f, 0.30381492f, 0.18662304f, 0.10558776f, 0.20134968f, 
    0.51367188f, -0.93623686f, -0.85149282f, -0.47381628f, 0.19226223f, -0.45214799f, -0.60872823f, -0.46832234f, 
    0.02535016f, -0.05668825f, 0.22889370f, -0.64729178f, -0.29340824f, -0.30711812f, -0.35884947f, -0.19553719f, 
    -0.22202238f, -0.20191269f, 0.02737717f, -0.04250904f, 0.25717205f, 0.17493497f, 0.71897799f, -0.38307160f, 
    -0.62276697f, -0.37489337f, 0.07355365f, 0.60448813f, 0.61787611f, -0.09705123f, 0.68236339f, 0.06373131f, 
    0.29725561f, 0.45176780f, 0.02837487f, 0.14090814f, 0.08761587f, -0.47043097f, -0.43285254f, 0.41506401f, 
    -0.08573484f, -0.19488733f, -0.15213023f, 0.44838485f, 0.06454141f, 0.00904276f, -0.46787584f, -1.37538314f, 
    1.33084750f, 0.94773817f, -1.17856991f, 0.40081236f, -0.24746706f, 0.37428570f, 0.36353409f, 0.51763719f, 
    0.56700927f, -0.34728351f, 0.06037445f, -0.27136153f, -0.23327318f, -0.09451363f, -0.20621246f, -0.11586000f, 
    -0.34660336f, -0.17173693f, -0.15706038f, -0.18916801f, 0.19099544f, 0.13026249f, 0.33651343f, 0.05125104f, 
    0.78211230f, 0.49018648f, -0.26625225f, 0.01548529f, 0.40374321f, -0.78212297f, -0.79691994f, 0.23811597f, 
    -0.15932181f, -0.64043915f, -0.54259723f, -0.24467035f, 0.23150405f, 0.40031299f, 0.32821375f, 0.36305696f, 
    -0.13713886f, -0.27166536f, 0.53050804f, 0.50868499f, 0.19632611f, 0.01921723f, 0.28219897f, 0.19772790f, 
    -0.39453384f, -0.49588341f, -0.51703447f, -0.24870968f, -0.60461593f, -0.42869532f, 0.26590273f, -0.90093553f, 
    -0.66709912f, -0.64650190f, -0.40051720f, -0.06076768f, -0.35642961f, 0.22028480f, 0.45613721f, -0.28394726f, 
    0.21411131f, 0.48103160f, 0.19656737f, 0.56033558f, 0.37926680f, 0.37698001f, -0.33165419f, -0.03790804f, 
    0.17356031f, 0.42036450f, -0.50206023f, -1.15439463f, -0.72537798f, -0.47202080f, -0.28330258f, 0.12899254f, 
    0.64192742f, 0.19355525f, -0.19790287f, 0.54076415f, -0.64894891f, 0.42485347f, -0.09850893f, 0.22273986f, 
    0.00079167f, -0.34797063f, -0.04308952f, 0.33607525f, 0.02744333f, 0.03960997f, -0.32679144f, -0.22368959f, 
    -0.55729640f, -0.22035676f, 0.00684347f, 0.68037748f, 0.75761795f, -1.33237398f, -0.78158224f, -0.74505341f, 
    0.41352528f, -0.36805642f, 0.29513788f, 0.61043787f, -0.22558488f, -0.74370003f, -0.05503039f, 0.07331207f, 
    0.45161849f, -0.28466517f, 0.19785421f, -0.00026990f, 0.16849697f, 0.22081792f, 0.34043366f, 0.47753096f, 
    -0.07555077f, -0.16040249f, -0.23651238f, 0.27643958f, -0.84321690f, 1.36971557f, -0.63987839f, -0.19101204f, 
    -0.25423431f, -0.83577192f, 0.55136651f, 0.32733282f, -0.15172206f, -0.68924969f, 0.37264875f, 0.03797713f, 
    -0.04637485f, -0.38801321f, 0.23081741f, -0.05109931f, 0.39362293f, -0.05606033f, 0.29762685f, 0.05484352f, 
    0.23294614f, -0.16171978f, 0.09313203f, -0.13290383f, 0.08641703f, -0.66860318f, -0.63128930f, -0.17383060f, 
    -0.69275421f, -0.13622844f, -0.32891822f, -0.28510809f, 0.60197639f, 0.63870686f, -0.62946826f, -0.34590051f, 
    -0.06734702f, -0.30585417f, 0.05002942f, -0.82587397f, 0.05953479f, -0.09512562f, 0.04626304f, 0.13458268f, 
    0.24644326f, -0.17599623f, -0.15462221f, 0.15285048f, -0.22807540f, 0.24787021f, 0.98316479f, -0.89715427f, 
    -0.40296820f, -0.96921104f, -0.27890423f, 0.80850166f, -0.25056967f, 0.37525210f, -0.06974918f, -0.46459973f, 
    0.31043440f, -0.53666717f, -0.20410813f, 0.27866966f, -0.18172413f, 0.04896270f, 0.36830804f, -0.17784911f, 
    -0.09009454f, 0.01980969f, 0.25120431f, 0.12124266f, 0.29611737f, -0.18961623f, -0.45686901f, -0.43626943f, 
    -0.64668810f, 0.61291122f, -0.48361361f, -0.76672649f, -0.37835988f, 0.73847896f, 0.73744726f, -0.28389916f, 
    -0.39822555f, -0.03498294f, -0.03074383f, -0.27286658f, 0.49367142f, 0.01830782f, -0.25379589f, -0.13075331f, 
    0.13932572f, -0.22886111f, -0.11041676f, 0.29967943f, -0.02274089f, 0.08298099f, 0.11026932f, -0.39587879f, 
    -0.99202240f, -0.48146155f, -0.29276097f, -0.31936911f, -0.68659037f, 0.87330830f, 1.26058984f, -0.15266801f, 
    0.02742800f, 0.62429047f, -0.18237904f, -0.37338397f, 0.04824539f, -0.40551698f, 0.16694142f, -0.17415380f, 
    0.19790550f, -0.11839908f, 0.16876799f, -0.12576656f, -0.04583916f, -0.23920251f, 0.14844698f, 0.03593266f, 
    0.05116120f, -0.84004390f, -1.08534610f, -0.58260250f, 0.10096610f, -0.62544233f, 0.39753878f, 0.59084141f, 
    0.27224034f, 0.27262160f, 0.88880634f, 0.00486923f, -0.23063682f, -0.35601598f, -0.35678405f, -0.11359610f, 
    -0.12329603f, -0.16258393f, -0.02737411f, -0.44215861f, 0.06310897f, 0.07273155f, 0.10822855f, -0.23742028f, 
    0.50319761f, -0.17974131f, 1.15238500f, 0.56724763f, 0.09181612f, 0.68488944f, 1.26755559f, 0.56454718f, 
    0.43181929f, 0.65957880f, 0.32595333f, -0.10502913f, -0.25747842f, -0.26986879f, 0.20479293f, -0.11285655f, 
    0.39044192f, 0.02205504f, 0.09007237f, 0.21830331f, -0.06779689f, 0.07986923f, 0.14262539f, -0.00061181f, 
    0.18476568f, 0.06966383f, -0.14210550f, -0.59646600f, -0.81530923f, -1.29080892f, 0.44364619f, 0.66062450f, 
    -0.71768630f, 0.58971280f, 0.73166746f, 0.37272802f, 0.25662899f, 0.03250420f, -0.22932038f, 0.07783355f, 
    -0.11152533f, -0.23881102f, -0.12666489f, -0.24137399f, 0.17894967f, -0.17236578f, -0.35185051f, 0.18101165f, 
    0.26617163f, -0.13100402f, 0.39407980f, -0.16478084f, 1.62067580f, 0.60054922f, -0.04246982f, 1.12266684f, 
    0.20267934f, -0.42600569f, 0.13464388f, -0.13481705f, 0.17962742f, -0.15278332f, -0.25248572f, 0.25566572f, 
    0.00052441f, -0.15321234f, -0.25996023f, -0.16937038f, -0.07209569f, 0.19878237f, 0.03329412f, 0.33717871f, 
    0.26307949f, 0.06060888f, -0.32787451f, -0.61578989f, -0.11430155f, 0.51064634f, 1.18162715f, -0.29282701f, 
    0.01012315f, -0.25469467f, 0.06957326f, 0.18655673f, -0.59888643f, 0.84366101f, -0.38586894f, 0.51935178f, 
    -0.00626416f, -0.46041620f, 0.37812972f, -0.50704962f, 0.22553799f, 0.04624646f, 0.19908269f, 0.12011369f, 
    -0.18503141f, -0.34753987f, 0.18964238f, 0.03287615f, -0.01670313f, 0.37485594f, -0.69585574f, -0.85740268f, 
    0.16904843f, 0.87006944f, 0.90136009f, -0.57825691f, 0.37256384f, -0.45440629f, -0.42531654f, -0.17544590f, 
    0.63283598f, 0.39948091f, -0.07196400f, 0.02926188f, 0.22512737f, -0.09328903f, 0.32168910f, -0.27528372f, 
    0.22071624f, 0.13890694f, -0.07612955f, -0.34521973f, -0.38530910f, -0.19803052f, 0.06479251f, -0.73458016f, 
    0.48614863f, -0.93411696f, -0.68774205f, -0.45770636f, 0.21263938f, -0.37174177f, 0.25965387f, 0.75199682f, 
    0.14254011f, -0.67173064f, -0.43033242f, -0.18081214f, -0.44590884f, -0.62693697f, 0.58897603f, 0.04494066f, 
    -0.08679296f, -0.00228585f, -0.51083821f, 0.09824977f, 0.11971471f, 0.19372427f, -0.09859378f, -0.04699914f, 
    -1.01905048f, 0.30860630f, 0.65782577f, -0.03963976f, 0.49689290f, -0.97978693f, 0.42468500f, -0.30577075f, 
    -1.01138151f, -0.35607633f, 0.01601076f, 0.61212945f, 0.40497613f, 0.33463964f, -0.15780431f, -0.06678422f, 
    -0.58996511f, -0.05382641f, 0.16697378f, 0.35861883f, 0.27558213f, 0.34450200f, -0.06069911f, 0.51695675f, 
    0.07276095f, -0.26662058f, 1.13573515f, 0.14542650f, -0.73247492f, -0.13733420f, 0.07482269f, -0.01190888f, 
    -0.87056488f, -0.49308011f, -0.66138756f, -0.19826669f, -0.24120180f, -0.57503313f, -0.33787638f, -0.22608450f, 
    -0.82612556f, -0.32486799f, -0.37428373f, -0.72185421f, -0.43806127f, 0.03496609f, -0.22120696f, 0.10727507f, 
    0.33096552f, -0.18117298f, -1.11439312f, -0.65333229f, -0.08848119f, -0.76584119f, -0.23595439f, 0.34988293f, 
    -0.89574754f, -0.30156398f, 0.10964973f, 0.25603887f, 0.38205588f, -0.36329001f, -0.26696351f, 0.45326287f, 
    0.36686611f, -0.30051509f, 0.30158556f, -0.24562366f, -0.06270841f, 0.19711654f, 0.26843864f, 0.35661113f, 
    0.15857714f, 0.29574412f, -0.32760435f, 1.24085653f, 0.93428755f, 0.72820121f, 0.01791495f, -0.58895892f, 
    -0.15174274f, -0.34412301f, 0.64434868f, 0.36291185f, 0.66663462f, 0.01834844f, -0.08359658f, -0.26327309f, 
    -0.16036360f, -0.01366680f, 0.00256319f, -0.22068332f, -0.08014427f, -0.14181075f, -0.06770366f, 0.18100339f, 
    0.43588495f, -0.30229399f, 0.52046049f, 0.20217237f, 0.64457846f, 0.77853435f, 1.01210988f, 0.11764365f, 
    0.96186179f, -0.26807439f, -0.85468590f, -0.57156777f, -0.62077618f, -0.60437709f, 0.57026756f, 0.47538209f, 
    -0.16671211f, 0.15249415f, 0.15056141f, 0.25150448f, 0.21825774f, -0.21758577f, 0.03707685f, 0.47532892f, 
    0.32696739f, 0.12502213f, -0.13943051f, 0.34379503f, 0.40955237f, -1.02384055f, -0.51325059f, 1.10439551f, 
    0.53264046f, -0.91128457f, -0.61232299f, 0.07105792f, 0.88716513f, -0.00769499f, -0.54498297f, -0.00965197f, 
    0.19954255f, -0.00429494f, 0.22138387f, 0.33518830f, 0.17491880f, 0.22503194f, -0.07964942f, -0.33897990f, 
    -0.48645285f, 0.24818288f, 0.24470465f, 0.07444876f, 0.13790770f, 0.14055346f, -0.59594035f, 1.03961909f, 
    1.27872705f, 0.06483585f, 0.86102241f, 1.34377825f, -0.16890171f, -0.56364667f, -0.18049575f, -0.65056372f, 
    -0.08883157f, -0.25327432f, 0.15722838f, 0.13268571f, -0.49512944f, -0.10561503f, 0.04205017f, 0.16420916f, 
    -0.43006068f, -0.04723328f, -0.15157738f, 0.02284591f, -0.16658223f, -0.02899421f, -0.31811035f, 0.29421690f, 
    -0.64931750f, -0.11288732f, 1.27055085f, 0.27807811f, -1.15634060f, -0.65428472f, 0.08124690f, -0.87420911f, 
    0.15226817f, 0.24649949f, 0.51258194f, -0.16812831f, -0.07649015f, -0.02349219f, 0.05688275f, 0.17213354f, 
    0.11125065f, -0.08939302f, 0.24305061f, 0.22367822f, -0.10136514f, -0.15108390f, -0.20460388f, -0.01705660f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.23136860f, 0.51658076f, 0.28596908f, 0.14149076f, 0.15199231f, 0.29004788f, 0.35116199f, 0.23785211f, 
    0.31653228f, 0.25591177f, -0.07146730f, 0.08988537f, 0.25344345f, 0.14600910f, 0.06427987f, 0.33274820f, 
    0.08428918f, 0.23887394f, 0.23708224f, 0.20542608f, 0.25402433f, 0.05032618f, 0.13829118f, -0.15339877f, 
    0.13865477f, 0.22902779f, 0.33126992f, 0.31503123f, 0.30273548f, 0.44550514f, 0.23794502f, 0.12640961f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.02967397f, 0.09141904f, 0.11123955f, -0.69451267f, -0.04431899f, -0.01921152f, 0.13809007f, 0.17252673f, 
    0.03153354f, -0.07489775f, -0.03408038f, 0.08963900f, -0.27969885f, 0.08055664f, -0.21444745f, -0.00801199f, 
    -0.04575869f, 0.01058207f, -0.09545553f, 0.04878767f, 0.17015848f, -0.00798343f, -0.06799942f, -0.05358318f, 
    0.17516637f, 0.03886958f, -0.05435189f, 0.42766795f, -0.16059510f, -0.03166553f, -0.02964484f, 0.04604860f, 
    -0.05555322f, 0.02267453f, -0.13366385f, -0.25185236f, 0.19218369f, -0.10200544f, 0.33149892f, 0.18091485f, 
    -0.17038298f, 0.00478269f, -0.02331243f, -0.00737161f, -0.09581330f, 0.10187060f, 0.23221627f, -0.20051840f, 
    -0.54304630f, 0.33587742f, 0.39085492f, -0.12674020f, -0.04472986f, 0.07423414f, 0.06791800f, -0.00351696f, 
    0.01004598f, -0.10483237f, 0.07994121f, -0.01504947f, -0.01995023f, 0.07642152f, -0.08814596f, 0.37148988f, 
    -0.08654542f, -0.01780228f, -0.12272222f, -0.05962288f, -0.06911197f, 0.00832678f, -0.03948573f, 0.03028949f, 
    -0.05720228f, 0.04936799f, -0.16869614f, -0.18784681f, -0.00257250f, -0.01599385f, 0.28836483f, -0.07073959f, 
    0.04066109f, -0.03513488f, 0.02439968f, 0.02173871f, 0.01388673f, -0.03847754f, 0.29542813f, -0.01153532f, 
    -0.01826867f, 0.09816653f, 0.04519676f, -0.15766765f, -0.00081692f, -0.12872574f, -0.02000332f, -0.00381809f, 
    0.31654742f, 0.14782958f, -0.00833898f, -0.10154361f, -0.02008653f, -0.00216973f, -0.15111358f, 0.15356286f, 
    -0.05837722f, -0.22623429f, -0.08007771f, -0.07092305f, -0.44805619f, -0.30012020f, 0.02622762f, -0.11011667f, 
    -0.04079265f, -0.08622690f, 0.03396462f, 0.12871772f, 0.04521713f, 0.05123270f, -0.00437910f, 0.08809544f, 
    -0.16704501f, -0.13246785f, -0.03627554f, -0.49871024f, -0.09202810f, -0.09783097f, -0.06008548f, 0.02229892f, 
    0.19758791f, -0.15600929f, -0.07749211f, 0.01072520f, 0.09951391f, 0.04198102f, -0.07358117f, -0.54224312f, 
    0.00838935f, -0.09819438f, 0.12734532f, -0.10648687f, -0.12223587f, 0.00822878f, -0.03698895f, 0.22606583f, 
    0.05622003f, 0.18898454f, 0.13639911f, -0.05725595f, -0.11799183f, -0.16891640f, 0.06578272f, 0.02115528f, 
    -0.14692199f, -0.15386491f, -0.03638728f, -0.05878680f, -0.12027695f, 0.09851502f, -0.02984540f, -0.35391000f, 
    -0.00202669f, 0.01055569f, 0.20759918f, 0.02848626f, 0.21990982f, 0.04274820f, 0.12536120f, -0.19391046f, 
    0.08229790f, -0.12301677f, 0.22854725f, -0.39865664f, -0.04462888f, 0.12325165f, 0.02608350f, -0.13907509f, 
    -0.30967441f, -0.04490171f, 0.12980163f, -0.12399311f, -0.59277207f, 0.00319797f, -0.01440642f, 0.00130082f, 
    -0.09606341f, 0.06491444f, -0.07240863f, -0.00743914f, 0.14975937f, 0.07471476f, 0.04349798f, 0.05425418f, 
    0.59575123f, 0.29642329f, 0.18568364f, -0.33431357f, 0.09101199f, 0.08415614f, -0.08247481f, 0.08267232f, 
    0.02708054f, -0.02501217f, -0.07582099f, 0.15522420f, 0.20034783f, 0.17415269f, -0.15305839f, -0.15682270f, 
    0.00042319f, 0.16152912f, -0.07491625f, -0.04954582f, -0.13844939f, -0.04040725f, 0.00298942f, -0.03644633f, 
    0.28124657f, -0.05960171f, -0.03410053f, 0.15318324f, -0.25446814f, 0.07225293f, -0.04578542f, 0.05341713f, 
    -0.10149173f, 0.05693101f, 0.04472253f, -0.10695267f, -0.44816455f, 0.55395061f, -0.08066694f, 0.20373896f, 
    0.08421956f, 0.02609443f, -0.00580046f, -0.02639936f, -0.08048882f, 0.01428705f, 0.07943752f, 0.05159792f, 
    0.13493954f, 0.18457948f, -0.22673294f, 0.21265072f, -0.12205773f, 0.04555908f, -0.26577640f, 0.11079349f, 
    0.01265124f, 0.08024051f, -0.10047968f, 0.15033132f, -0.18613423f, 0.15065661f, -0.18796422f, -0.13299388f, 
    -0.05049485f, 0.04119307f, -0.06648657f, 0.13255014f, 0.16664009f, 0.07734182f, -0.06242201f, -0.02119711f, 
    -0.11499490f, -0.21312043f, -0.06543016f, 0.17319988f, -0.02556833f, 0.02341948f, -0.01367737f, -0.02266437f, 
    0.06909310f, -0.00251087f, -0.12598982f, 0.05400440f, 0.53979456f, 0.05459716f, -0.12528895f, -0.26165056f, 
    0.01628483f, -0.17891476f, 0.14446008f, -0.17455430f, 0.06473486f, 0.05790765f, 0.07538208f, -0.16560380f, 
    -0.59052557f, -0.17941357f, 0.11306447f, 0.22342126f, 0.03662035f, 0.07849960f, -0.05416371f, 0.10160457f, 
    0.01524403f, -0.14900011f, -0.09499977f, 0.01570493f, -0.22466230f, 0.15632269f, 0.22262996f, -0.21231842f, 
    -0.04131157f, 0.05056607f, 0.19729818f, -0.20430033f, -0.11036434f, 0.00827886f, -0.00337933f, 0.05977245f, 
    -0.29512024f, -0.37959221f, -0.11553541f, 0.03229328f, -0.02702480f, 0.03409630f, 0.03143670f, -0.02841075f, 
    -0.03056446f, -0.14564021f, 0.23212473f, -0.08606957f, 0.14090888f, -0.10798584f, -0.08209287f, 0.12081488f, 
    -0.18571800f, -0.16182181f, -0.08636989f, -0.00421788f, -0.06236325f, 0.04461937f, -0.00863261f, -0.03646205f, 
    0.11503352f, 0.12656689f, 0.12326472f, -0.23900850f, -0.10139087f, -0.02277185f, 0.03514535f, 0.01082452f, 
    0.11145491f, -0.16162643f, -0.04746932f, 0.06155054f, -0.34951955f, 0.12840313f, -0.05976610f, 0.46860775f, 
    0.07316688f, 0.07445762f, 0.08546861f, -0.04603904f, 0.08570185f, 0.20401438f, -0.04071694f, -0.04088907f, 
    -0.39097857f, -0.13392290f, 0.06738726f, 0.01754159f, -0.24584559f, -0.16642722f, 0.11012313f, -0.09961969f, 
    0.03958340f, -0.03742262f, -0.09487498f, -0.00657343f, 0.29282176f, -0.21793133f, -0.00239492f, 0.40666062f, 
    -0.14824663f, 0.03095334f, 0.06527676f, -0.09162593f, 0.04752170f, -0.11428742f, -0.08334479f, -0.04050404f, 
    0.30133462f, 0.15023893f, 0.13915426f, -0.07006294f, 0.05461927f, -0.11996847f, 0.10083770f, -0.10770155f, 
    -0.14301455f, 0.07774948f, -0.01438702f, 0.09854983f, 0.28540587f, -0.12189542f, 0.09352217f, -0.24878761f, 
    0.13754709f, 0.09743378f, 0.04412989f, 0.07123587f, -0.09539054f, 0.05252183f, 0.08364049f, 0.03842625f, 
    0.18263014f, -0.03531392f, 0.30768839f, 0.21915248f, -0.29309982f, 0.05901505f, 0.08001959f, 0.06705491f, 
    -0.09707232f, 0.00388515f, -0.03251446f, 0.03554307f, 0.32095841f, -0.04884428f, 0.19953299f, 0.24873655f, 
    0.04741544f, -0.04487618f, -0.08283363f, 0.07459249f, 0.06863751f, -0.07398977f, -0.22326837f, -0.06134903f, 
    -0.07708430f, 0.02533095f, -0.32693928f, -0.16677308f, -0.04065614f, 0.05737684f, 0.00631469f, -0.01795192f, 
    -0.01179539f, 0.08833453f, 0.08264785f, 0.05786098f, -0.39303964f, -0.18764707f, -0.40069768f, -0.03222985f, 
    -0.11275972f, 0.10273732f, -0.07394943f, 0.10751059f, -0.08516534f, -0.09866145f, 0.01096194f, -0.20802833f, 
    0.37786299f, -0.41868642f, 0.14247425f, -0.03664915f, 0.13978742f, -0.10896608f, -0.26110014f, -0.04221831f, 
    -0.14632253f, -0.06968690f, -0.13342217f, -0.00233760f, -0.45121479f, 0.19869296f, -0.01285898f, -0.20920801f, 
    0.03795939f, 0.06175169f, 0.12841988f, 0.07082603f, 0.01584424f, -0.01506274f, 0.00987800f, -0.10081524f, 
    -0.00586466f, -0.00065423f, 0.02528387f, -0.15845330f, -0.06685837f, -0.13082334f, 0.12885706f, 0.10637233f, 
    -0.08731358f, 0.16242278f, -0.13717677f, 0.11467259f, -0.00464263f, 0.15846699f, 0.07114588f, 0.07739022f, 
    0.07929992f, 0.19041580f, 0.22074901f, -0.02007257f, 0.01827296f, 0.25672376f, -0.07250930f, 0.00965205f, 
    0.30747309f, -0.06050865f, 0.03280910f, 0.01590163f, 0.14198050f, 0.12389861f, 0.10852909f, 0.00287680f, 
    -0.15325114f, -0.00191657f, 0.08697358f, 0.00171575f, -0.02278168f, -0.46503720f, 0.06379578f, -0.32249579f, 
    -0.12069590f, -0.16931114f, -0.06290808f, 0.33226228f, 0.03458495f, -0.02750157f, 0.04496812f, -0.14381233f, 
    0.02219531f, 0.00000017f, -0.34999606f, -0.37006569f, 0.02867379f, 0.25845611f, 0.01046416f, -0.00338913f, 
    0.00172491f, -0.09316277f, -0.08956189f, 0.20759274f, -0.03367573f, -0.10404781f, -0.07861007f, -0.12183738f, 
    -0.02287492f, 0.00527557f, -0.02031379f, 0.16102032f, 0.07194240f, 0.05244997f, -0.05309343f, 0.28764042f, 
    0.27916542f, -0.34736776f, 0.08797348f, -0.17384337f, 0.13731475f, -0.16435875f, 0.09418961f, 0.05975715f, 
    0.12919722f, 0.11241333f, -0.15078491f, -0.03993403f, -0.27338165f, 0.07492535f, -0.33157849f, 0.21715315f, 
    0.05560238f, 0.02278188f, -0.03091235f, -0.03124726f, 0.12100274f, -0.08374921f, -0.04215034f, -0.12060969f, 
    -0.19300972f, -0.03188649f, -0.23431931f, -0.07518168f, 0.02316821f, -0.10773838f, 0.03192122f, 0.01496947f, 
    0.06625191f, 0.07401631f, -0.05874403f, -0.08635023f, 0.15026090f, -0.01713658f, -0.04815982f, -0.02466931f, 
    0.06803346f, 0.00818801f, -0.08710814f, -0.14762306f, 0.11032531f, -0.06486993f, -0.07733499f, 0.18741313f, 
    0.14804953f, 0.07958904f, 0.08736616f, 0.32604730f, -0.10013539f, -0.00941397f, -0.07663513f, -0.03185328f, 
    0.09593630f, 0.21351628f, -0.06276610f, 0.17589310f, 0.45453393f, -0.15927874f, -0.16441138f, -0.03684537f, 
    0.01868072f, 0.07680389f, -0.00634936f, 0.12097992f, 0.06558029f, -0.06552146f, -0.01764933f, 0.12606348f, 
    0.39999434f, -0.29546931f, 0.12861390f, 0.27128160f, 0.00010865f, -0.15449613f, -0.04890614f, 0.00227318f, 
    0.06341443f, -0.05338027f, -0.02017738f, 0.01790413f, 0.17279008f, -0.07707998f, -0.01346113f, -0.01908273f, 
    -0.12764931f, -0.15179713f, -0.00467621f, 0.05277121f, -0.18817268f, -0.00067890f, 0.03041300f, -0.00303584f, 
    0.01950628f, -0.22083968f, -0.20419680f, -0.00538095f, -0.06211258f, 0.04283656f, -0.19027002f, -0.07337207f, 
    -0.19979337f, 0.02283977f, 0.03809275f, -0.03270687f, -0.54442120f, -0.14322338f, 0.06148497f, -0.26148582f, 
    0.06591246f, -0.05722027f, -0.11380180f, 0.00835187f, 0.39504039f, -0.22965421f, -0.17738171f, 0.00656728f, 
    -0.17398781f, 0.12733397f, -0.18759520f, -0.28439185f, -0.01607283f, -0.05543520f, 0.01858778f, -0.08968024f, 
    -0.09229387f, 0.19307756f, 0.06086831f, -0.12543009f, -0.19854894f, -0.13802610f, -0.36147881f, -0.24828292f, 
    -0.05231156f, -0.01216716f, 0.09946972f, 0.00601812f, -0.09571033f, -0.09465925f, -0.28925440f, 0.03867136f, 
    -0.16387650f, 0.25370136f, 0.15577126f, 0.07300959f, 0.01595992f, -0.16187079f, 0.04727618f, 0.04385905f, 
    -0.03963659f, -0.00178960f, -0.11530975f, 0.03604997f, 0.23333861f, 0.22294468f, 0.10196378f, 0.18975547f, 
    -0.07041492f, -0.07604410f, 0.05522150f, 0.05070530f, -0.04447579f, 0.04923295f, -0.01090745f, 0.14253835f, 
    -0.03949768f, -0.05079094f, 0.22981945f, -0.01569728f, -0.04351000f, 0.04798242f, 0.08272137f, 0.01395083f, 
    -0.02569889f, 0.23987597f, -0.02633552f, 0.05118421f, -0.57624477f, 0.20878503f, -0.19341236f, 0.04652614f, 
    -0.07684233f, -0.11951829f, -0.06689526f, -0.09121637f, 0.00850635f, -0.22217143f, -0.09000981f, 0.10549257f, 
    0.32463518f, 0.06806234f, 0.04776917f, -0.00878936f, -0.13598615f, 0.13434905f, -0.00470696f, -0.09722179f, 
    -0.19480401f, 0.05991924f, 0.05472223f, -0.12310555f, -0.51385885f, -0.34177178f, -0.14172854f, 0.20043452f, 
    -0.10199903f, -0.07525276f, -0.19836079f, 0.12681611f, -0.03898558f, -0.01148679f, 0.19433947f, 0.11465010f, 
    -0.10116050f, -0.01232329f, -0.02033650f, -0.19616668f, 0.03651086f, -0.10862954f, 0.15178613f, -0.05295783f, 
    -0.04967800f, -0.00188846f, 0.10168771f, -0.03686266f, 0.18793808f, -0.05219784f, -0.21336679f, 0.14698665f, 
    -0.12236247f, -0.14124018f, -0.11327762f, -0.01160271f, 0.00301322f, -0.09147242f, -0.02164697f, 0.04007469f, 
    0.12219235f, -0.00259011f, -0.03386150f, -0.05925643f, 0.08363163f, 0.12008511f, -0.04448396f, -0.04624198f, 
    0.08998103f, 0.13578355f, 0.06934981f, 0.01676878f, 0.20595871f, -0.18828532f, -0.08923128f, -0.10461712f, 
    0.07628687f, -0.01120516f, 0.09632480f, -0.07977705f, -0.00315415f, 0.06321276f, 0.08446860f, -0.05080098f, 
    -0.50789779f, -0.15184584f, 0.17777671f, -0.51088923f, -0.02413659f, 0.13181627f, 0.00509300f, 0.06262026f, 
    0.09192148f, -0.22480270f, -0.06316007f, -0.11009356f, -0.38322470f, -0.01114646f, -0.48902798f, -0.32295561f, 
    -0.10411713f, -0.02992458f, 0.00619961f, -0.07994912f, 0.06072180f, 0.17076725f, -0.06428331f, -0.00959628f, 
    0.10838100f, 0.08206299f, 0.04595578f, 0.09292843f, 0.00932567f, 0.08544615f, 0.07027458f, 0.02313856f, 
    -0.07755207f, -0.13349192f, 0.02157990f, -0.01304971f, 0.58930433f, -0.09040833f, -0.24133416f, 0.05002798f, 
    -0.02609579f, 0.17865053f, 0.10037880f, 0.16080967f, 0.00367725f, 0.12939295f, 0.06917240f, -0.01546921f, 
    -0.33407983f, 0.09486087f, -0.18569218f, -0.17153363f, 0.10666953f, 0.08193334f, -0.00327114f, -0.01654598f, 
    0.02913348f, -0.11031000f, 0.01646797f, 0.01932190f, -0.40267143f, -0.13241799f, -0.03479549f, -0.31405485f, 
    -0.02472305f, -0.09394058f, -0.17020544f, 0.04194162f, -0.01536638f, -0.12295210f, 0.03878419f, -0.07818062f, 
    0.29089314f, 0.16872086f, 0.12060321f, 0.12829109f, -0.27986372f, -0.29461959f, 0.03374125f, 0.24910638f, 
    -0.16413891f, 0.05222522f, -0.11928832f, -0.14191943f, -0.13219415f, 0.09982822f, -0.31994694f, 0.26903105f, 
    -0.10792036f, 0.02941485f, 0.07732257f, -0.03243241f, -0.11214651f, -0.10680231f, -0.00920626f, -0.04706142f, 
    -0.14492425f, 0.12941675f, -0.40243068f, -0.30098256f, -0.02180073f, -0.17775954f, 0.00436623f, -0.02692288f, 
    -0.19079657f, 0.00906096f, -0.00122687f, -0.22174206f, -0.28147110f, -0.06066350f, -0.15671359f, 0.08308157f, 
    -0.00025603f, -0.05729103f, -0.07666907f, -0.03802084f, -0.03123950f, 0.08183589f, -0.11330260f, 0.00962603f, 
    -0.55425113f, 0.09978789f, -0.10210712f, 0.04578672f, 0.03579053f, -0.00959685f, 0.05302695f, -0.01979120f, 
    0.01478705f, -0.18908966f, -0.05183586f, -0.06684101f, 0.28944373f, 0.18667294f, -0.14001001f, -0.13532215f, 
    -0.07234323f, -0.06891906f, -0.00987558f, -0.00577378f, -0.02145179f, 0.00008280f, -0.04287552f, -0.00790867f, 
    0.61255646f, 0.06317694f, 0.31480044f, 0.16814201f, -0.05970472f, -0.11629298f, -0.05191218f, 0.10050660f, 
    -0.06789251f, 0.00059947f, 0.01582002f, -0.06357671f, 0.25619680f, 0.00413438f, 0.25518081f, 0.26344618f, 
    -0.21277031f, -0.05147843f, -0.13327050f, 0.16382810f, 0.07047968f, 0.05034925f, 0.01849238f, -0.08316001f, 
    -0.02260209f, -0.01259409f, 0.04056576f, -0.09282319f, 0.26888058f, -0.03337996f, 0.10713778f, -0.03294097f, 
    0.00925799f, -0.01628120f, -0.00055374f, 0.04661503f, 0.51192069f, -0.17104588f, -0.08115032f, 0.22737110f, 
    -0.17398895f, 0.09762352f, -0.31357780f, -0.05283865f, 0.06559773f, 0.08961914f, 0.08465393f, -0.00376512f, 
    -0.00483003f, -0.01535617f, -0.03527600f, -0.05973545f, 0.07238153f, -0.03079540f, 0.08971436f, -0.00438537f, 
    -0.03847498f, 0.00190859f, -0.06501325f, -0.03704243f, 0.37404820f, -0.13538593f, -0.13157333f, -0.10676945f, 
    -0.09216296f, -0.17833401f, 0.03574967f, -0.00649817f, -0.29794237f, 0.08560087f, 0.03915633f, -0.07218176f, 
    0.55318189f, -0.38689312f, 0.00267044f, 0.12695399f, -0.06423508f, 0.07163558f, -0.01689463f, -0.07062081f, 
    -0.11496524f, -0.14056678f, 0.06288899f, 0.01546403f, -0.12798199f, 0.08523552f, -0.13000196f, 0.36918145f, 
    0.00480970f, 0.09920055f, 0.03541103f, 0.10404473f, -0.01205567f, -0.00219537f, 0.04391138f, -0.01618708f, 
    0.32935792f, 0.13371393f, -0.33811533f, -0.05781569f, 0.04006004f, -0.06938622f, -0.07438324f, -0.03198698f, 
    0.04557825f, -0.07441913f, -0.13687623f, -0.15461989f, 0.04192360f, -0.02966513f, -0.27303189f, -0.58401459f, 
    0.01149292f, 0.08047566f, 0.02739914f, -0.09658551f, 0.00531013f, 0.10790160f, -0.07831112f, 0.05493207f, 
    -0.03431378f, -0.01953521f, 0.13244104f, -0.10185222f, -0.17504546f, 0.04282580f, -0.11243663f, -0.10283452f, 
    0.04514058f, -0.17070217f, 0.01727795f, 0.06251873f, -0.03752672f, 0.16381356f, -0.00013059f, 0.12729563f, 
    -0.06256735f, -0.08417348f, 0.12719829f, 0.05761936f, -0.08286990f, -0.09551331f, -0.04410256f, 0.04703084f, 
    -0.01171929f, 0.11931734f, -0.10241479f, 0.10324166f, 0.20713408f, 0.10586030f, 0.05792367f, -0.06535997f, 
    0.02265826f, -0.13243818f, 0.04254779f, -0.13999589f, 0.22824576f, -0.11405177f, -0.34663481f, -0.21776937f, 
    -0.19309941f, 0.02408961f, -0.11925088f, 0.01384677f, 0.13033396f, 0.02027255f, -0.07277298f, -0.14438400f, 
    0.20003036f, -0.09766446f, 0.01809488f, 0.09211181f, 0.02829462f, 0.01133916f, -0.01170000f, -0.14038897f, 
    -0.04841111f, -0.04195337f, -0.18485659f, 0.11259300f, 0.37988472f, -0.08467997f, -0.12730877f, -0.00974833f, 
    0.04129604f, 0.14667098f, 0.03621415f, -0.02490765f, -0.07416233f, -0.02724911f, 0.02062021f, -0.21237628f, 
    -0.07176787f, -0.42701998f, -0.15392074f, 0.08961169f, -0.08815518f, -0.07914695f, -0.05983966f, 0.12449749f, 
    -0.05004667f, 0.07460493f, -0.16753298f, -0.03480022f, 0.09960721f, -0.02962710f, -0.06208507f, 0.07463627f, 
    -0.14160927f, -0.12135978f, -0.01120090f, -0.08104879f, -0.05689272f, -0.03718943f, -0.04653238f, -0.10628486f, 
    -0.41213050f, -0.58763981f, -0.24812125f, 0.06384195f, 0.01016466f, -0.04251245f, -0.09294210f, -0.05271915f, 
    0.04937873f, 0.11069126f, 0.18561937f, 0.08702539f, 0.14260806f, -0.23521769f, -0.19974831f, 0.02145975f, 
    -0.06878392f, 0.05419716f, 0.05087474f, -0.16983452f, -0.02986955f, -0.15857464f, -0.02207669f, 0.01619229f, 
    -0.18548200f, 0.06214669f, -0.02879274f, 0.07983233f, -0.00162055f, -0.11956500f, -0.09857891f, -0.01500350f, 
    0.03976504f, -0.06363889f, -0.17782865f, -0.19835919f, 0.21161583f, 0.04868237f, 0.23297778f, 0.05148319f, 
    -0.06367633f, 0.06454132f, 0.09284975f, 0.07279447f, 0.06232028f, 0.07928929f, -0.01910251f, 0.14810553f, 
    0.03469467f, -0.07850326f, -0.00197768f, 0.00159859f, -0.09906656f, 0.12503217f, -0.04300456f, 0.06219098f, 
    -0.13361332f, 0.04581296f, 0.03589746f, 0.08106291f, -0.27659220f, 0.20372364f, 0.06371269f, -0.42285216f, 
    0.13316210f, 0.06946056f, -0.11728861f, 0.16299322f, 0.01397400f, 0.02099027f, 0.00125800f, 0.07960202f, 
    0.21433675f, -0.15090394f, 0.03286473f, -0.15350384f, 0.02169516f, 0.13585213f, -0.09902655f, 0.00722149f, 
    0.10817301f, -0.16887145f, 0.09262518f, 0.02880190f, 0.26234370f, 0.11325274f, -0.07254227f, -0.04473861f, 
    0.06546488f, 0.04240391f, 0.09579913f, -0.06399480f, 0.08939665f, -0.11744708f, -0.06046559f, -0.10233358f, 
    -0.00708997f, -0.12914297f, 0.01217537f, -0.05631447f, -0.18410811f, -0.12333325f, 0.04303859f, 0.10297011f, 
    -0.11830972f, -0.03549010f, 0.06792839f, 0.20237064f, 0.14871435f, -0.27013439f, -0.03496546f, 0.04140062f, 
    -0.09043717f, -0.03093364f, 0.07412546f, -0.03668439f, -0.00188643f, 0.08902209f, -0.01206839f, 0.11068242f, 
    -0.31022668f, 0.27962142f, 0.13400869f, -0.15385017f, -0.11102661f, 0.15151465f, 0.09313788f, 0.26594648f, 
    0.03307736f, 0.12903984f, -0.12409456f, 0.01231253f, -0.11183213f, -0.03419129f, 0.13299876f, 0.05916978f, 
    -0.13555457f, -0.05785872f, 0.01136209f, -0.03384504f, -0.09942730f, 0.06823938f, 0.08624575f, -0.01932544f, 
    -0.02790557f, -0.01931701f, -0.13224593f, 0.21275707f, -0.15227272f, 0.15267846f, 0.00078160f, 0.09037992f, 
    -0.02204989f, -0.00080601f, -0.16165566f, 0.05321966f, 0.18036041f, 0.15577486f, 0.26664883f, -0.14712344f, 
    -0.03670193f, -0.09615470f, -0.02997387f, -0.16745716f, -0.00096952f, -0.08922590f, 0.07254113f, 0.10450520f, 
    -0.08753865f, -0.10243189f, -0.09761338f, -0.23360021f, -0.01768830f, -0.07676016f, -0.00225724f, -0.11612995f, 
    -0.06198013f, -0.23522048f, 0.06117778f, 0.02727605f, 0.03767044f, -0.01333695f, 0.02704420f, -0.17388001f, 
    -0.06632081f, -0.01948037f, 0.06420428f, 0.00624438f, -0.03621975f, -0.09619291f, 0.02314491f, -0.08959790f, 
    -0.78342897f, -0.57667124f, -0.13947217f, -0.17795421f, -0.07224346f, -0.01300995f, 0.03365840f, -0.09300534f, 
    -0.04849429f, -0.16101098f, 0.13986307f, -0.09719415f, 0.20851722f, 0.13279960f, 0.05062385f, 0.07084534f, 
    -0.05831464f, -0.14066756f, 0.18571365f, -0.09058117f, -0.13211115f, 0.09234586f, -0.08936787f, 0.00462800f, 
    0.11690474f, -0.57378018f, -0.18982548f, -0.04933619f, -0.01970463f, 0.00621416f, -0.03768161f, -0.00033639f, 
    0.02302653f, 0.12175944f, -0.05209451f, 0.03095888f, 0.38979417f, 0.24430791f, -0.11749421f, -0.08579628f, 
    -0.19653505f, 0.14738402f, 0.08435902f, 0.12313338f, -0.04211654f, 0.00562817f, 0.07920264f, -0.08270234f, 
    -0.49513203f, 0.19550343f, 0.33939055f, 0.21453440f, 0.01324028f, 0.08901455f, 0.06902746f, 0.05851505f, 
    -0.18437769f, 0.01053230f, -0.13989004f, -0.07654329f, -0.18913271f, 0.18114713f, -0.06515902f, -0.00837415f, 
    -0.25026780f, -0.02215844f, 0.14333597f, -0.00439845f, -0.03239197f, 0.12788029f, -0.08915281f, 0.01649899f, 
    -0.40537390f, 0.50738513f, 0.52400303f, 0.08079157f, 0.11433866f, 0.07919662f, -0.10891950f, 0.04415212f, 
    0.13149278f, -0.06463891f, -0.07515928f, 0.02565616f, 0.49432996f, 0.18419831f, 0.17502379f, -0.10156120f, 
    0.09796163f, 0.06155468f, -0.05149525f, 0.01381195f, -0.06080618f, 0.08749580f, 0.09928254f, -0.00956150f, 
    0.24947630f, 0.25171682f, -0.16746268f, -0.12324760f, -0.13241166f, -0.01675409f, -0.01535596f, 0.01333244f, 
    0.12049588f, -0.08696496f, 0.09773970f, 0.13485938f, -0.49073884f, -0.86297601f, -0.47329640f, -0.11713660f, 
    -0.12832394f, 0.06848576f, -0.06287008f, -0.05834355f, -0.13409354f, -0.08670831f, -0.00755753f, 0.04596831f, 
    -0.27680051f, -0.43194398f, -0.03056106f, 0.25221613f, 0.09082559f, 0.08378097f, 0.02604348f, -0.02613449f, 
    -0.11924328f, -0.05926177f, -0.14285041f, -0.32407412f, 0.07635561f, 0.22516988f, 0.14148736f, -0.13045037f, 
    -0.01958393f, -0.04056020f, -0.02194551f, -0.00071052f, -0.07960104f, -0.08367965f, 0.02806519f, 0.10110875f, 
    0.66209161f, -0.37437120f, -0.06353820f, 0.25127834f, 0.06801802f, -0.14635698f, -0.02009702f, 0.12718549f, 
    0.06398316f, -0.00492002f, 0.00043444f, 0.02278674f, 0.22343527f, -0.06468618f, 0.27685893f, 0.33056101f, 
    0.10043042f, 0.23668070f, 0.14233881f, -0.15394889f, -0.07501271f, 0.04325609f, -0.01136560f, -0.09089834f, 
    -0.27775115f, -0.53447324f, -0.08680083f, 0.03550427f, -0.07169855f, 0.04175694f, -0.04634877f, -0.07684512f, 
    -0.10048077f, 0.03829337f, 0.09948272f, -0.11529785f, 0.04157358f, 0.02148410f, -0.17248265f, 0.17312670f, 
    -0.06317448f, -0.22252089f, -0.03239886f, 0.15225229f, 0.01270252f, -0.12841357f, 0.08445568f, -0.07946651f, 
    -0.05932729f, 0.15265402f, 0.10802620f, -0.09795710f, 0.00971788f, -0.12348287f, 0.01981480f, 0.08198626f, 
    -0.00425728f, -0.09252804f, -0.05840588f, 0.03685004f, 0.11999033f, -0.18574582f, 0.03559490f, 0.27755874f, 
    -0.27970129f, 0.03898586f, 0.04780823f, -0.06314477f, 0.02233193f, 0.14011022f, -0.21346898f, 0.07496126f, 
    -0.04877900f, -0.33022836f, 0.20150764f, -0.34358647f, -0.04043026f, 0.17267096f, -0.00403716f, -0.04279608f, 
    -0.02993181f, -0.00552201f, -0.08514174f, -0.03971751f, -0.00637895f, -0.17224529f, 0.05424380f, -0.08746901f, 
    0.05171645f, 0.05201790f, 0.05149652f, -0.11033508f, -0.07074691f, 0.12441361f, 0.10223255f, 0.09449311f, 
    -0.42882341f, 0.17468135f, -0.10088084f, -0.08580051f, -0.01427107f, 0.14411306f, 0.10663114f, -0.13211939f, 
    -0.10240793f, 0.02463006f, -0.03546210f, 0.05812232f, 0.53411478f, 0.32215872f, -0.11676307f, 0.05815798f, 
    -0.12083045f, -0.10629468f, 0.02063930f, -0.07129502f, -0.02091775f, 0.00856732f, -0.05085390f, 0.00511930f, 
    0.10587703f, -0.10746688f, 0.07641574f, 0.25053218f, -0.05048186f, 0.02690403f, -0.00808970f, -0.26190773f, 
    0.04959519f, 0.10747383f, 0.11909038f, -0.10683320f, 0.13099517f, 0.15367435f, 0.31000370f, 0.08630842f, 
    -0.00054702f, 0.02521679f, 0.04571192f, 0.12092259f, -0.03883962f, 0.01553495f, 0.03150889f, 0.10359346f, 
    -0.53205174f, 0.28565571f, 0.23304012f, 0.34263268f, 0.19418009f, -0.01893887f, -0.02505235f, 0.11901291f, 
    0.11865310f, 0.10099940f, -0.01938047f, 0.12143459f, 0.02886652f, -0.25586465f, -0.15302700f, 0.07749718f, 
    -0.04526674f, 0.02181713f, 0.06341594f, -0.06628202f, -0.05934693f, 0.00197507f, -0.10536359f, -0.07102698f, 
    -0.07879750f, -0.09471555f, 0.15666279f, -0.05748506f, 0.15274930f, -0.04241136f, 0.10598349f, -0.06387375f, 
    0.15082738f, 0.04126852f, -0.12840106f, -0.08831183f, 0.15794982f, 0.15738457f, -0.16066335f, -0.02360719f, 
    -0.02216126f, -0.11133417f, -0.14496711f, -0.04655352f, -0.04167952f, -0.08074169f, 0.12826848f, 0.02842726f, 
    -0.25619534f, 0.10064713f, -0.09021831f, -0.00691653f, -0.17806375f, 0.00078594f, 0.00350848f, -0.09105974f, 
    -0.02432060f, -0.04915643f, 0.01645162f, 0.04742381f, -0.08750337f, -0.04226044f, 0.20912880f, -0.21390180f, 
    0.00311721f, 0.08992038f, 0.05615743f, 0.05757523f, -0.21069863f, -0.09963663f, -0.06824080f, 0.17414248f, 
    -0.62814695f, -0.13656211f, 0.09504675f, 0.23644091f, -0.01480595f, -0.04948347f, 0.06628319f, -0.03849158f, 
    -0.08397956f, 0.10508963f, -0.00976993f, 0.07244767f, -0.62452620f, -0.12287346f, 0.03350298f, 0.21873599f, 
    0.05042316f, 0.08084954f, -0.14343946f, 0.21490473f, -0.01006092f, -0.09892537f, 0.13158263f, 0.03803774f, 
    0.49079126f, -0.30406672f, -0.22215240f, 0.06318598f, 0.05029977f, -0.12473767f, 0.06669332f, 0.11056045f, 
    0.09647025f, 0.03727920f, -0.01170690f, 0.02882486f, -0.10049390f, 0.00178364f, -0.31575209f, -0.07129627f, 
    0.03582625f, 0.16722944f, 0.12193599f, -0.03066797f, -0.01182849f, -0.07102841f, -0.12026934f, 0.04039571f, 
    0.16833121f, 0.05781931f, 0.14042948f, 0.15869841f, -0.00584880f, 0.15795009f, 0.14414647f, 0.00651886f, 
    0.10456874f, -0.12176789f, 0.00151361f, -0.09774312f, 0.00849271f, 0.13644595f, -0.00650522f, -0.21972579f, 
    -0.11468714f, -0.09142371f, 0.13439953f, 0.03355153f, 0.16624142f, -0.05194765f, -0.13552655f, -0.05407129f, 
    -0.56691390f, 0.16498266f, 0.11316009f, -0.16068053f, -0.01505264f, -0.01301554f, 0.06657381f, -0.00111653f, 
    0.21298604f, 0.07994683f, 0.02975079f, -0.03712264f, 0.37446803f, -0.37368351f, -0.04756920f, 0.17049111f, 
    0.05770857f, -0.06599028f, 0.03275508f, 0.08350007f, -0.10580888f, 0.06186493f, 0.09396243f, 0.19375092f, 
    -0.52930266f, -0.04833722f, 0.14131187f, 0.00121194f, -0.07993973f, -0.12747745f, 0.01371329f, 0.07001416f, 
    -0.13944796f, -0.10384823f, 0.06688675f, 0.06673148f, 0.07660043f, 0.00306549f, 0.13297932f, 0.01257341f, 
    0.06146550f, 0.04623583f, 0.08730446f, -0.01357516f, 0.09196775f, -0.06806602f, 0.07777895f, 0.06056847f, 
    0.52766025f, 0.06017705f, -0.22385418f, 0.01620474f, 0.04061823f, 0.16482256f, -0.03009121f, 0.09577561f, 
    0.05899426f, -0.01049273f, -0.11852609f, 0.01270430f, -0.29373729f, -0.41810852f, 0.31379652f, 0.03734782f, 
    -0.05407088f, -0.07960419f, 0.01730710f, -0.04618870f, 0.08406667f, 0.04833230f, 0.04388790f, -0.08734341f, 
    -0.37834337f, -0.06344499f, 0.22551399f, 0.14675137f, -0.08662543f, -0.14961821f, -0.12605710f, -0.08622649f, 
    0.06222150f, -0.08594295f, -0.00798563f, -0.22920245f, 0.06109654f, -0.28692928f, -0.05939665f, -0.31392214f, 
    0.02596452f, 0.02894450f, 0.04422088f, 0.03519852f, -0.19746006f, -0.04567219f, -0.00911603f, 0.10135126f, 
    0.06875249f, 0.40476111f, -0.17692098f, -0.15119828f, -0.04310491f, 0.12287882f, 0.02684746f, 0.15834485f, 
    -0.15205085f, -0.05564135f, 0.03544867f, 0.12466194f, -0.34112194f, -0.28163192f, 0.01548273f, 0.25197139f, 
    -0.13455130f, 0.09787049f, -0.01829349f, -0.10057051f, 0.11581157f, 0.01050775f, -0.20810764f, -0.12781043f, 
    -0.06821050f, 0.08609550f, 0.16064540f, 0.11447185f, -0.05452541f, -0.16071013f, -0.04885725f, 0.10442311f, 
    0.02999117f, -0.03284166f, -0.19832982f, -0.04617026f, -0.44911677f, -0.04845968f, -0.12209085f, -0.14870234f, 
    0.10860061f, 0.14799795f, 0.01853841f, -0.11047636f, -0.12145379f, 0.20772551f, -0.17455970f, 0.17405394f, 
    -0.18344350f, -0.06588151f, -0.03836531f, 0.18019898f, 0.04925300f, 0.04562495f, -0.02326036f, 0.03920941f, 
    0.11690232f, 0.02689118f, -0.14266174f, -0.06551769f, -0.09329739f, 0.06849057f, -0.07325366f, -0.45682892f, 
    0.06267168f, -0.04929483f, 0.10995270f, -0.09387998f, -0.00729314f, -0.08100069f, 0.11131877f, 0.11121801f, 
    -0.20947461f, 0.17262454f, -0.09075326f, 0.07642938f, 0.00947731f, -0.16145481f, 0.10213831f, 0.01576321f, 
    0.00690636f, 0.08611862f, 0.05654197f, 0.17891110f, 0.18091300f, 0.21840268f, 0.04846148f, 0.03695668f, 
    -0.00514299f, -0.05554965f, 0.05135784f, 0.18113175f, -0.03379881f, -0.13062440f, -0.14615101f, 0.00822643f, 
    -0.06325424f, 0.01543877f, -0.07843724f, -0.15450172f, -0.13034138f, -0.39895126f, 0.01577611f, 0.06239723f, 
    -0.06254594f, -0.10600103f, 0.15799485f, 0.01768789f, -0.11346011f, -0.24074408f, 0.01831853f, 0.15945601f, 
    -0.08299893f, -0.26247615f, -0.00216372f, -0.24741356f, -0.09279191f, -0.05793977f, -0.07805490f, -0.08936394f, 
    0.13516736f, -0.01045907f, 0.20026353f, -0.01185562f, -0.01718602f, -0.19599646f, 0.00494186f, -0.14068390f, 
    -0.17502828f, 0.00916338f, 0.11312652f, 0.12086764f, -0.35460478f, -0.19373406f, -0.18316616f, 0.06081589f, 
    0.07019711f, -0.12331659f, -0.12842616f, -0.12855919f, 0.17070022f, -0.06300718f, 0.25159118f, 0.03646756f, 
    -0.19818877f, 0.12114379f, -0.60452175f, 0.09585274f, 0.14968793f, 0.04838653f, -0.18559934f, -0.06069523f, 
    0.02131158f, -0.18996190f, 0.27121586f, -0.07460673f, 0.37548345f, 0.13218832f, 0.05263778f, -0.04391851f, 
    0.11782673f, 0.12892395f, -0.17624092f, -0.15012610f, -0.07134566f, 0.11775170f, 0.20826349f, 0.02682529f, 
    -0.34024742f, 0.03883165f, 0.08914676f, 0.17382661f, -0.08169456f, -0.12659925f, -0.13170366f, 0.12033103f, 
    0.20479004f, 0.09915919f, -0.02908242f, 0.17989202f, 0.12673724f, -0.20228779f, -0.05069207f, 0.11205485f, 
    0.03214825f, 0.04546553f, -0.01743708f, -0.11456656f, -0.14519493f, -0.15131517f, -0.13453321f, -0.11338145f, 
    -0.16763029f, -0.34811783f, 0.00404429f, -0.02431385f, 0.19765763f, -0.07196566f, 0.02111413f, 0.09933788f, 
    0.30652437f, 0.19464175f, -0.07388000f, -0.01304273f, -0.20089492f, -0.10674457f, -0.28187609f, -0.01532054f, 
    0.02015119f, -0.13639501f, 0.09918229f, 0.13009194f, 0.02460430f, 0.12962671f, -0.01746333f, -0.08505026f, 
    -0.48518470f, 0.06518575f, -0.30622831f, -0.11636816f, 0.08609562f, 0.12679172f, 0.03542025f, -0.01271635f, 
    0.04580974f, -0.13199885f, 0.08193320f, -0.05171310f, -0.15523452f, 0.18041100f, -0.45878279f, -0.02319803f, 
    0.05815132f, -0.00104836f, 0.09428664f, 0.03061078f, -0.02022252f, 0.00091933f, -0.16385554f, -0.18150832f, 
    0.20278949f, 0.18246900f, 0.29270056f, -0.24307744f, 0.06944145f, -0.04832323f, 0.04403973f, -0.12674744f, 
    0.05126943f, -0.06049120f, 0.09473614f, 0.14097871f, -0.60765386f, 0.24399473f, -0.03349358f, -0.51581120f, 
    0.03160211f, 0.02284025f, -0.07197684f, -0.04827798f, 0.12641485f, -0.02661026f, -0.04477406f, -0.08370233f, 
    -0.05487905f, 0.01631473f, 0.09396110f, 0.00819136f, -0.13141066f, -0.06407719f, 0.02710524f, 0.13339576f, 
    -0.09778097f, 0.05965956f, 0.15932427f, -0.01708923f, -0.12452047f, 0.06527655f, -0.08359761f, 0.09537440f, 
    -0.06857698f, 0.03210040f, 0.05638750f, -0.09946924f, -0.11654240f, -0.26131621f, -0.03190265f, 0.11863133f, 
    -0.01269293f, 0.03643991f, -0.09342767f, -0.49472061f, 0.08027181f, 0.05537873f, 0.02232185f, -0.03555394f, 
    -0.01459988f, 0.06197162f, 0.09863405f, 0.03155951f, 0.24608463f, 0.11615177f, -0.18233854f, 0.01027270f, 
    0.29713762f, 0.23593350f, -0.04414014f, -0.09391609f, -0.17132737f, 0.00928981f, -0.15082291f, -0.01411120f, 
    0.17338213f, -0.17527340f, 0.03851109f, 0.20612256f, -0.03183568f, -0.05072468f, 0.17512701f, -0.00032767f, 
    -0.08323546f, 0.12000287f, 0.13396056f, 0.01847818f, -0.15521429f, -0.01022674f, 0.29940850f, 0.44314224f, 
    -0.00873765f, -0.12084950f, -0.02227339f, 0.22396742f, 0.02989296f, -0.16323893f, -0.03172776f, -0.59244519f, 
    -0.42488199f, -0.32247755f, 0.00607025f, 0.30145797f, 0.16768372f, 0.01016927f, 0.06144165f, -0.11352840f, 
    0.11293899f, 0.21973941f, -0.15189104f, 0.01420245f, 0.28927353f, 0.01235042f, 0.03981505f, -0.12683187f, 
    -0.04163809f, 0.20231724f, 0.05371250f, 0.05860996f, 0.15754627f, -0.00608302f, 0.09929122f, -0.01714832f, 
    0.18571538f, 0.00306086f, 0.11540381f, 0.17248195f, -0.19589598f, 0.08941887f, 0.00476276f, 0.01387833f, 
    -0.24936700f, 0.07027405f, -0.05007524f, 0.40026176f, 0.04198964f, -0.00375998f, -0.16761814f, 0.02909399f, 
    0.06288812f, -0.05686578f, -0.05538154f, 0.21645916f, 0.12841417f, -0.02225874f, 0.01887509f, -0.01981715f, 
    -0.34936014f, -0.24799158f, 0.35116827f, 0.36239582f, 0.11220959f, 0.04048468f, 0.07789887f, 0.02951298f, 
    -0.01791233f, 0.08284969f, -0.10663510f, -0.00405136f, 0.06413803f, 0.00769254f, -0.11925431f, -0.30357835f, 
    -0.11563212f, -0.00940158f, -0.09384289f, 0.07883892f, 0.06845527f, 0.02658769f, 0.00873738f, 0.16004209f, 
    -0.17487808f, 0.26117253f, -0.24860036f, 0.31257093f, -0.09795181f, 0.18679973f, -0.08425379f, 0.05022722f, 
    0.01058470f, -0.06101486f, 0.03893222f, -0.03398895f, -0.45965099f, -0.02409685f, 0.11472743f, 0.04916558f, 
    0.07241911f, -0.03216136f, 0.04753863f, -0.04476253f, 0.07128465f, -0.19734545f, 0.12939221f, -0.20044304f, 
    -0.11964607f, 0.16601512f, 0.01283395f, -0.29979026f, -0.10408798f, -0.12941290f, 0.02499856f, 0.07497040f, 
    0.03835035f, 0.00431882f, 0.23986180f, 0.24342740f, -0.15739816f, 0.28107312f, 0.23515974f, -0.35312355f, 
    0.04711095f, 0.14295517f, -0.13827537f, -0.02265402f, 0.08254371f, 0.01003536f, -0.01433394f, -0.06332318f, 
    -0.26136595f, -0.25119978f, -0.26746878f, 0.37109399f, 0.03427766f, 0.05221742f, -0.00725488f, -0.02265061f, 
    -0.08182143f, -0.12026080f, -0.17246059f, -0.39511591f, -0.24844697f, -0.02721909f, 0.03657430f, -0.19586128f, 
    0.14548840f, -0.12173932f, 0.03420848f, 0.00253609f, 0.13923122f, 0.08343977f, 0.07274009f, 0.16201425f, 
    -0.07317632f, -0.11613408f, 0.07211727f, 0.01479514f, 0.03743234f, 0.22694279f, 0.12167484f, 0.00793214f, 
    0.01876551f, 0.14822437f, -0.12071652f, 0.08403551f, -0.14444114f, 0.13938729f, -0.13869575f, 0.21288601f, 
    -0.13666104f, 0.04657585f, -0.04826004f, -0.02522861f, -0.09277270f, 0.04469341f, -0.00224029f, 0.10231949f, 
    -0.11672198f, 0.10609332f, 0.08833039f, -0.15350434f, 0.11138525f, 0.08742681f, -0.07767489f, -0.04271345f, 
    0.10789591f, -0.05575047f, 0.19266076f, -0.01447875f, -0.03521817f, -0.10048313f, -0.08544616f, -0.14085577f, 
    -0.04340498f, -0.03656270f, -0.15385127f, -0.05013970f, -0.18285128f, -0.14807412f, -0.09911904f, -0.17100181f, 
    -0.13112341f, -0.39780161f, -0.11897761f, -0.26526684f, -0.10246620f, 0.01967321f, 0.05364627f, 0.01325851f, 
    -0.02895280f, 0.16809158f, -0.03438334f, 0.28029439f, -0.01249778f, 0.07484792f, 0.10989905f, 0.47117186f, 
    0.05959063f, -0.11927105f, 0.29735503f, -0.11392154f, 0.11813080f, -0.08724900f, -0.04304049f, 0.02269486f, 
    0.00360386f, -0.08486583f, 0.27853212f, 0.59044570f, 0.17446162f, -0.10051906f, 0.23131028f, -0.14221258f, 
    -0.10792833f, -0.09357561f, 0.10115635f, -0.05809040f, -0.30615279f, -0.30650061f, -0.14630140f, -0.07353717f, 
    -0.04026491f, 0.01672453f, 0.24274726f, 0.06505927f, -0.04640813f, 0.01102983f, -0.01288967f, 0.01753069f, 
    -0.07272781f, 0.13081741f, -0.59179962f, 0.00155926f, -0.07138590f, 0.02396033f, 0.02223724f, -0.11253862f, 
    -0.19120699f, -0.15339245f, 0.06533471f, 0.07361925f, 0.08332459f, -0.30538034f, -0.18264225f, -0.02457266f, 
    -0.04181582f, -0.01177774f, -0.09919214f, -0.10840672f, -0.12234382f, -0.01422526f, 0.05430705f, 0.25338420f, 
    0.25227526f, -0.50448620f, -0.27375865f, 0.05195780f, -0.12804127f, 0.04839361f, -0.05055260f, 0.00365220f, 
    0.02558758f, 0.00389017f, 0.02765674f, 0.16730849f, 0.12211660f, -0.40456000f, 0.07934151f, -0.34972697f, 
    -0.17175877f, 0.02417018f, -0.02128188f, -0.23800950f, -0.12779032f, 0.14127308f, 0.22664453f, 0.16859493f, 
    -0.31297889f, 0.12381244f, 0.17073102f, -0.19552600f, -0.21594836f, 0.01356593f, 0.02100690f, 0.16153887f, 
    -0.05991444f, 0.00214692f, 0.06904017f, -0.08987249f, -0.18984880f, -0.23384310f, 0.19077282f, -0.07037628f, 
    0.05700518f, -0.06028311f, 0.18150271f, -0.11827709f, 0.00360429f, 0.00109421f, -0.00107355f, 0.08362550f, 
    -0.00713265f, 0.32333735f, 0.06847537f, -0.34708670f, -0.01703501f, 0.20084541f, 0.07645905f, -0.02171409f, 
    -0.10503954f, -0.12240323f, -0.09450908f, -0.05009281f, -0.34093407f, 0.17622982f, 0.09569047f, 0.28053513f, 
    0.22060576f, 0.00183796f, -0.02389717f, -0.10488192f, 0.16213278f, 0.20967576f, -0.02004292f, -0.01205737f, 
    0.53311658f, 0.09472712f, 0.03032409f, 0.17959782f, -0.13546684f, 0.05538009f, 0.07810864f, 0.12776296f, 
    0.16224600f, -0.10166366f, 0.00447109f, -0.02855743f, -0.35975429f, 0.22166830f, 0.18533884f, -0.04455403f, 
    -0.23686270f, -0.02943522f, 0.06647042f, -0.05716272f, -0.14535244f, 0.06054021f, 0.09133648f, 0.01656073f, 
    0.07082357f, -0.18797499f, -0.14129297f, -0.01194133f, 0.19820391f, 0.16592723f, -0.00815596f, -0.00916316f, 
    0.21141797f, -0.18415400f, -0.15234093f, -0.09238874f, -0.03283705f, -0.06275492f, -0.28327942f, -0.02908548f, 
    0.08143622f, 0.04483403f, -0.10751870f, 0.09865138f, -0.04210753f, 0.14385599f, -0.00135488f, 0.29733133f, 
    -0.13093431f, 0.00320226f, 0.01628004f, -0.48559454f, -0.07708015f, -0.03966736f, -0.08050535f, -0.05671393f, 
    -0.20907697f, 0.19344756f, 0.09062952f, -0.01055234f, -0.71334845f, 0.32261938f, 0.03568531f, 0.14684741f, 
    -0.11843956f, -0.06293692f, -0.03983711f, 0.09992275f, -0.09358435f, 0.00211617f, 0.02641354f, -0.12609619f, 
    0.00156526f, 0.14897838f, 0.05696493f, -0.29991186f, 0.03531321f, 0.04562341f, 0.01267586f, 0.00731003f, 
    0.15963016f, -0.13105637f, -0.10951787f, -0.19893566f, 0.01646218f, -0.37267864f, 0.14799216f, -0.20926358f, 
    0.02381452f, 0.00473364f, 0.07137895f, -0.07813698f, -0.07314295f, 0.01733389f, 0.06095460f, -0.11561615f, 
    0.46102694f, 0.02570598f, -0.08743288f, -0.16082907f, -0.04402909f, -0.09726154f, 0.11179526f, 0.12206872f, 
    0.13138667f, 0.03123346f, 0.01996038f, 0.03144164f, 0.42572212f, 0.26384827f, 0.10022444f, -0.30533361f, 
    0.12893958f, 0.10787317f, 0.09393116f, 0.07788017f, -0.16697957f, -0.06704357f, -0.19065526f, -0.09146043f, 
    -0.37247726f, -0.09645457f, -0.15375441f, -0.06598404f, 0.04713061f, -0.10691165f, -0.00019334f, -0.06066820f, 
    0.01621697f, -0.02869948f, 0.01771287f, -0.03142676f, 0.11097549f, 0.01972961f, 0.17037620f, 0.10535134f, 
    0.07176810f, 0.01140969f, -0.08657519f, -0.03932916f, 0.00377549f, -0.05137524f, -0.08573837f, -0.03040111f, 
    -0.28433716f, 0.06728808f, -0.34749714f, -0.15046668f, -0.07864591f, 0.06892476f, -0.03759089f, -0.18351471f, 
    -0.17063931f, -0.10500788f, -0.09292886f, -0.08130738f, -0.44994280f, 0.08411908f, -0.24623273f, -0.13006152f, 
    0.13023543f, -0.03147356f, -0.07602597f, -0.04586260f, -0.24760188f, 0.03364186f, 0.08082323f, -0.10114592f, 
    0.17022417f, -0.03954341f, 0.07708047f, 0.29194596f, 0.06389535f, -0.10495260f, -0.08328061f, -0.01403803f, 
    0.03012866f, -0.05075359f, -0.06190753f, -0.01416327f, 0.24150042f, -0.00772418f, 0.06730454f, 0.20091824f, 
    -0.14043503f, -0.02838480f, -0.05772104f, -0.10342684f, -0.07591036f, -0.03289412f, 0.05207647f, 0.01215941f, 
    -0.16509271f, 0.15762344f, -0.13831069f, 0.03724188f, -0.23432752f, 0.00956476f, 0.00185577f, -0.05562297f, 
    0.05114663f, 0.04870817f, -0.08471010f, -0.15062906f, 0.16448428f, -0.12896442f, 0.28355041f, -0.03527465f, 
    0.09756553f, -0.00340391f, -0.04255348f, -0.09801169f, -0.01986267f, -0.04999980f, -0.14920612f, -0.10295357f, 
    -0.06926658f, -0.01286231f, 0.00386079f, 0.10070642f, -0.09476497f, -0.05306068f, -0.13249716f, 0.01190853f, 
    0.00669757f, -0.04742248f, -0.10191772f, -0.10228032f, -0.04967244f, 0.15034610f, 0.07321688f, 0.35096037f, 
    0.09377483f, -0.02777848f, -0.06692490f, 0.00417733f, 0.03892766f, -0.03801782f, -0.02128727f, 0.00424660f, 
    0.05572857f, 0.12589858f, 0.15605538f, 0.04905050f, 0.01124924f, 0.16477267f, 0.09473212f, -0.01844212f, 
    -0.00529868f, -0.02919956f, -0.19366990f, 0.02505783f, 0.27282837f, 0.33169100f, -0.25605044f, 0.07747585f, 
    -0.14437780f, -0.06909308f, 0.00702215f, -0.03750848f, 0.00159317f, 0.08491116f, -0.03761689f, -0.00378536f, 
    0.11048170f, -0.15860757f, 0.15557189f, 0.01105592f, 0.06285349f, -0.17618303f, -0.08314212f, -0.00187844f, 
    -0.09666242f, -0.08478216f, -0.07484486f, -0.09637798f, 0.11477241f, 0.20147252f, 0.12683176f, 0.23736139f, 
    0.09034983f, 0.06252012f, 0.10052647f, -0.00176523f, 0.04041869f, 0.01971068f, -0.01117710f, -0.13755335f, 
    -0.12366576f, 0.22239511f, -0.10422610f, 0.10450052f, 0.04151909f, 0.05119797f, -0.21147543f, 0.07337692f, 
    -0.08050603f, -0.03202013f, 0.04338937f, -0.09744301f, 0.22242695f, 0.01542732f, 0.20923842f, 0.07243533f, 
    0.08287896f, 0.05911762f, -0.02687674f, -0.01564267f, 0.06401610f, -0.08960167f, -0.08100560f, 0.01543373f, 
    0.01561807f, 0.30393144f, 0.16626999f, 0.17981349f, 0.18179710f, 0.03004871f, 0.09421057f, 0.09073534f, 
    0.00172296f, 0.13442074f, 0.12154438f, 0.00847817f, -0.15865850f, 0.17071103f, 0.11336063f, 0.22124486f, 
    0.05300388f, -0.01377432f, 0.00746949f, -0.00942468f, -0.08523888f, 0.09436013f, 0.08904573f, -0.09056459f, 
    -0.09789431f, 0.15244183f, 0.00514009f, -0.06855539f, -0.04592641f, 0.07338694f, 0.02371940f, -0.11585464f, 
    -0.01366923f, 0.01318937f, -0.13295403f, -0.15078256f, 0.01269558f, -0.17522760f, 0.22271447f, -0.20969017f, 
    0.03706505f, -0.00808540f, -0.15851074f, -0.08077424f, -0.05106149f, 0.11110261f, -0.04688448f, -0.00491136f, 
    -0.14563876f, 0.19177504f, -0.05964097f, -0.08011390f, -0.06919279f, 0.02512619f, 0.04736550f, -0.09095094f, 
    -0.10274801f, -0.00629282f, -0.08695299f, -0.11165822f, -0.57930565f, 0.10146157f, -0.00947308f, -0.00302669f, 
    -0.09346811f, -0.06579192f, 0.07178955f, -0.03108360f, 0.02562539f, 0.00576250f, 0.07221379f, 0.03228275f, 
    -0.01918178f, -0.28756979f, 0.16711633f, -0.08580231f, -0.00394412f, -0.01285114f, -0.02934819f, -0.07573003f, 
    -0.01505135f, 0.05670190f, -0.12625128f, -0.14874098f, 0.27983862f, 0.32037041f, -0.05304800f, 0.21707627f, 
    0.03463549f, -0.14068137f, 0.05211217f, -0.16278432f, -0.06320968f, 0.06254081f, 0.06338064f, -0.10140014f, 
    0.25198179f, -0.40276265f, 0.21857753f, 0.05018688f, 0.05868576f, -0.08713564f, -0.03065912f, -0.08185599f, 
    0.02115392f, 0.02609413f, -0.13682234f, -0.08362543f, 0.03529125f, -0.04394272f, -0.02679536f, 0.26573092f, 
    -0.03357680f, -0.14406097f, -0.12681903f, 0.00278559f, -0.06260975f, -0.04180135f, -0.04778047f, 0.03967203f, 
    -0.10807036f, 0.20737256f, 0.15177490f, 0.26310408f, 0.07122882f, 0.00986964f, -0.04912185f, -0.08843908f, 
    -0.09101401f, -0.02961753f, -0.01566545f, -0.10543213f, -0.30097857f, -0.16862541f, -0.27427715f, -0.43910152f, 
    -0.02147963f, 0.02254521f, -0.08206312f, -0.09049595f, -0.03348663f, 0.06327631f, 0.05576734f, -0.03769718f, 
    -0.45000473f, -0.28090978f, -0.30736032f, 0.00207975f, -0.03169074f, -0.16415308f, -0.02914055f, -0.04395316f, 
    0.01350891f, -0.03154698f, 0.07205362f, -0.03385136f, 0.29606128f, -0.22382823f, 0.13463341f, -0.01065580f, 
    0.09588255f, -0.00534754f, -0.03462845f, -0.15233140f, -0.03361053f, -0.00282390f, 0.10128298f, -0.01826620f, 
    -0.23678117f, 0.15978277f, 0.01563669f, -0.05635696f, -0.01720140f, 0.00105287f, -0.05720459f, -0.17440411f, 
    -0.09765583f, 0.09563854f, 0.02630552f, -0.17303185f, 0.36817148f, 0.21634267f, -0.12131910f, -0.08768466f, 
    -0.13006730f, 0.03754520f, -0.03921039f, -0.06126871f, -0.03694094f, -0.02032583f, 0.02629310f, -0.08882486f, 
    0.13784309f, 0.27813095f, -0.36338559f, 0.03550559f, -0.06541809f, 0.03603058f, -0.17526785f, -0.04523361f, 
    0.12374829f, 0.07950671f, -0.10492982f, 0.11391799f, -0.35879254f, -0.03259604f, 0.07915447f, -0.21884067f, 
    -0.04997700f, -0.00967703f, -0.17687669f, -0.12059082f, 0.02704353f, 0.08740281f, -0.10227969f, 0.10758760f, 
    0.09883595f, -0.20212819f, 0.24094357f, 0.25705251f, 0.16119705f, 0.01240430f, -0.06726801f, -0.10346291f, 
    0.04052326f, 0.00913297f, -0.03254740f, -0.09082115f, -0.18887182f, -0.09285728f, 0.12424559f, 0.03390380f, 
    0.03360493f, -0.04660036f, -0.11936487f, -0.04289532f, 0.04974796f, -0.17958674f, 0.06510466f, -0.02488449f, 
    0.47710222f, 0.18572834f, -0.42134348f, -0.30038559f, -0.20479390f, -0.03689397f, 0.08571759f, -0.03181347f, 
    -0.05092887f, -0.07463934f, -0.08495954f, 0.23541999f, -0.22569646f, -0.33852848f, -0.21776621f, -0.25493720f, 
    0.02831521f, -0.12193954f, 0.11799697f, -0.01624481f, 0.16653399f, -0.15873986f, -0.04914564f, -0.08279321f, 
    0.25758418f, 0.12486389f, -0.01588536f, 0.17981471f, -0.01772080f, 0.01870475f, -0.16501416f, 0.11918062f, 
    0.04887433f, -0.01775389f, 0.14768033f, 0.01244329f, 0.24242252f, 0.18202463f, -0.06457359f, 0.09594391f, 
    0.06524789f, -0.06279007f, -0.09186347f, -0.02483072f, 0.03084523f, -0.02646975f, -0.24833694f, 0.02693600f, 
    -0.33482909f, -0.22401579f, -0.38889897f, -0.18952593f, -0.05376162f, 0.00008347f, -0.01843612f, 0.08135640f, 
    0.06602676f, 0.10874680f, 0.04756235f, 0.00764663f, -0.31593260f, 0.02764298f, 0.02167424f, -0.35101196f, 
    -0.25756693f, -0.01857274f, -0.01820501f, -0.11315742f, 0.05450897f, -0.06669296f, 0.10558498f, -0.01631767f, 
    -0.28235048f, 0.05653848f, 0.01867964f, -0.11994338f, 0.09378825f, 0.10123312f, -0.10026141f, -0.17866722f, 
    0.03530392f, -0.01967308f, -0.02229874f, -0.20695283f, -0.16923133f, 0.12230251f, -0.15689512f, 0.00349063f, 
    -0.01476688f, 0.06665930f, -0.26470998f, 0.05605812f, 0.06122449f, 0.00290949f, 0.17057364f, -0.35564733f, 
    0.11332234f, 0.17354141f, -0.05227621f, -0.14250599f, -0.26684698f, 0.06034897f, -0.32425871f, -0.19139250f, 
    -0.04706117f, 0.08251947f, 0.14797746f, 0.19125625f, -0.30523875f, -0.11455230f, 0.04995772f, -0.10968014f, 
    -0.05198256f, 0.16655286f, 0.00392628f, -0.03744374f, -0.06675994f, -0.14371650f, -0.01070744f, 0.06226967f, 
    -0.11501171f, 0.44765469f, 0.25889751f, -0.20423736f, -0.07996298f, -0.02336933f, -0.22796194f, 0.08871605f, 
    0.08854928f, -0.12323838f, -0.02548271f, -0.10330001f, 0.14992315f, -0.18496779f, -0.00133158f, -0.21676569f, 
    -0.05042167f, 0.03192142f, 0.22447939f, -0.08726322f, 0.05980450f, 0.04750561f, 0.16296472f, 0.11058734f, 
    0.13617006f, -0.09058812f, 0.11480074f, 0.09663498f, -0.26567328f, 0.00406515f, 0.12176001f, -0.00222102f, 
    -0.02591773f, -0.17828821f, -0.08304971f, -0.07662944f, -0.11996480f, -0.15472576f, 0.29933503f, 0.16422763f, 
    -0.09596125f, -0.07710503f, 0.05138730f, -0.04024578f, 0.00932509f, -0.04372876f, -0.29235277f, -0.02237326f, 
    0.24775572f, -0.07110911f, 0.15451398f, 0.24514821f, -0.03375239f, -0.01696234f, -0.00088525f, 0.02321732f, 
    -0.04652355f, -0.03301793f, 0.03646559f, -0.02290916f, 0.01565310f, 0.00178835f, 0.22896975f, 0.11975965f, 
    -0.13036446f, -0.13578242f, 0.05085455f, -0.07501143f, 0.08193627f, -0.12456322f, -0.14525691f, -0.08992744f, 
    0.05321534f, -0.19372229f, -0.02648784f, 0.18292984f, 0.08087163f, -0.14353934f, -0.10392125f, -0.04878870f, 
    0.10208520f, 0.10771931f, 0.11367391f, -0.05734585f, 0.10729311f, -0.08245675f, -0.25840345f, 0.02377805f, 
    0.15753634f, 0.10646490f, -0.12548780f, -0.00398985f, -0.03746593f, -0.07952800f, 0.13196585f, 0.18781775f, 
    -0.31870669f, -0.05924340f, -0.04094109f, -0.01508258f, -0.07210621f, -0.15527901f, -0.07751109f, -0.16960709f, 
    0.02810011f, -0.00673744f, -0.14115632f, 0.13295911f, -0.09896377f, 0.01936033f, 0.04078106f, 0.14501250f, 
    0.07109691f, -0.03701654f, -0.02351784f, 0.18769617f, 0.00108020f, -0.20710965f, -0.04166024f, 0.06293468f, 
    0.00635807f, 0.03120662f, -0.12191313f, -0.14719039f, -0.04498341f, 0.05663245f, 0.04638035f, -0.18046328f, 
    0.06695779f, 0.10150134f, 0.07474011f, 0.12074395f, 0.06651717f, -0.05915289f, -0.09618665f, -0.09423783f, 
    0.14084551f, -0.08640070f, -0.02289787f, -0.02582033f, 0.09858889f, -0.10963712f, -0.29460245f, -0.07808755f, 
    -0.24064869f, -0.17331111f, 0.27317643f, -0.13120878f, 0.10799433f, -0.21017936f, 0.14154133f, 0.04781209f, 
    -0.01992030f, 0.15024231f, -0.06403552f, 0.00288161f, 0.23062384f, -0.04481791f, -0.17280093f, 0.00453287f, 
    0.10264650f, 0.05130161f, -0.02171286f, -0.04181432f, 0.01395951f, -0.05811973f, -0.10091639f, -0.04703461f, 
    -0.15016733f, -0.03978837f, -0.12688658f, 0.03714244f, 0.09464142f, 0.00657575f, -0.02432990f, 0.02525126f, 
    0.08058199f, 0.17323965f, 0.09842625f, 0.06318323f, 0.02870575f, -0.25274307f, 0.18241166f, -0.24102069f, 
    0.04764575f, 0.04348220f, 0.05852274f, -0.01767041f, 0.03228772f, 0.16458161f, -0.01876477f, 0.13632874f, 
    0.09254370f, 0.06476130f, 0.06229315f, 0.21485661f, 0.20403560f, -0.11400569f, -0.21399888f, 0.13454106f, 
    0.11929436f, 0.02939230f, 0.06078592f, -0.13500342f, -0.04860667f, -0.19664797f, -0.14641573f, -0.27164763f, 
    -0.05109232f, -0.24553196f, 0.11355537f, 0.02055584f, 0.08969770f, 0.12185496f, -0.03337454f, 0.10920305f, 
    0.30119538f, 0.09201050f, 0.23238143f, 0.08145322f, -0.04432658f, 0.11490078f, 0.07060913f, 0.02890703f, 
    -0.00118232f, 0.06660663f, 0.04788421f, -0.08124645f, 0.31592900f, -0.31674409f, -0.34097204f, 0.16174316f, 
    -0.08023640f, 0.00919066f, 0.06996720f, -0.11802230f, -0.06621556f, -0.05662051f, -0.00763974f, -0.11589812f, 
    -0.05184006f, 0.38217697f, -0.14882071f, -0.50708437f, 0.14825861f, 0.08881193f, 0.12338858f, -0.20405611f, 
    -0.08656716f, -0.06705427f, 0.11600758f, -0.02411062f, -0.46473178f, 0.30820483f, 0.06379349f, -0.24331798f, 
    -0.09296451f, -0.05060399f, -0.03219014f, -0.17264511f, -0.03698038f, -0.09013576f, -0.01383684f, 0.13986966f, 
    0.18090098f, 0.20009281f, 0.27443326f, 0.09920635f, 0.03923275f, -0.08244186f, -0.05968317f, 0.18066688f, 
    -0.10194860f, 0.00038244f, -0.00186634f, 0.06386440f, 0.01787608f, -0.05295181f, 0.10373677f, 0.03600724f, 
    -0.04592767f, -0.04697616f, -0.01107503f, -0.03271550f, -0.03124676f, 0.08513330f, 0.06040983f, 0.03733638f, 
    -0.11167422f, 0.28216621f, 0.08880389f, 0.19846946f, 0.00746584f, 0.00999217f, -0.12706538f, 0.08704491f, 
    0.23462580f, 0.06298152f, 0.01175281f, -0.02057965f, 0.23976809f, -0.87299043f, 0.26416963f, -0.22259985f, 
    0.13989982f, -0.03093353f, -0.01684667f, 0.10341311f, -0.06849340f, 0.05295081f, 0.30253407f, -0.02763425f, 
    -0.07057972f, -0.29636493f, -0.13264985f, 0.01688796f, -0.16962209f, 0.12087969f, -0.04333464f, -0.05296022f, 
    0.03512442f, -0.12265731f, -0.13861969f, 0.01034143f, 0.01266946f, -0.17144276f, -0.21099520f, -0.29386595f, 
    0.08149867f, -0.03451572f, -0.09797897f, 0.01189873f, -0.10250326f, -0.20070708f, -0.15273853f, 0.08182760f, 
    -0.32679528f, -0.36519963f, 0.05943622f, -0.14494978f, -0.04085794f, 0.01252995f, 0.12235113f, 0.03139309f, 
    0.04143760f, 0.14296104f, -0.11599443f, -0.13383451f, -0.42238441f, 0.21209331f, 0.47096410f, -0.16369659f, 
    0.06074896f, -0.07879274f, -0.02282934f, 0.10896746f, 0.17845707f, -0.06137837f, -0.15478911f, 0.14759956f, 
    0.54525113f, -0.28112048f, -0.19165620f, -0.06531689f, -0.09507775f, 0.03046704f, 0.07591192f, 0.14357434f, 
    -0.03569971f, -0.05149480f, 0.09363954f, -0.14088212f, 0.19034249f, -0.25573394f, 0.08916387f, 0.21147175f, 
    0.05316093f, -0.02996210f, -0.14979616f, 0.10672311f, -0.08439334f, 0.08798004f, 0.10179505f, -0.00896965f, 
    0.51980376f, 0.29361683f, 0.16643628f, 0.30886197f, -0.03884054f, 0.11076529f, -0.02573196f, 0.09952240f, 
    -0.02206998f, -0.07084054f, 0.16606854f, -0.09250744f, 0.32818589f, -0.17203909f, 0.22188191f, 0.16325904f, 
    0.08051270f, 0.04424913f, 0.00792067f, -0.02653511f, -0.01021565f, 0.09924562f, -0.08916784f, -0.07846468f, 
    -0.22714049f, -0.02603517f, 0.09741342f, -0.10963549f, 0.16594648f, 0.01102249f, -0.02023827f, -0.06734354f, 
    0.01619565f, 0.06616083f, 0.00601589f, -0.00004595f, -0.16683649f, -0.00869776f, -0.09649012f, -0.19426605f, 
    0.12808540f, 0.00432937f, 0.01009556f, 0.03338619f, 0.07860217f, 0.14065833f, -0.03067373f, 0.04563712f, 
    -0.29878184f, 0.29196453f, -0.55097556f, -0.11062056f, 0.18128690f, 0.08703960f, 0.02461764f, -0.04366450f, 
    -0.05385842f, -0.14446300f, -0.07636783f, -0.02853601f, 0.13410039f, -0.41308498f, 0.17714739f, 0.31426573f, 
    -0.11125942f, 0.03243982f, -0.06177086f, 0.09144971f, -0.22508802f, 0.08305265f, -0.00092391f, -0.01021271f, 
    -0.61095899f, 0.12917040f, -0.07111295f, 0.07253505f, 0.07632930f, 0.00160690f, 0.16886562f, -0.11349596f, 
    -0.04526121f, 0.06108746f, -0.01607743f, 0.16689098f, -0.11986991f, -0.05701578f, 0.44910306f, -0.07363894f, 
    -0.01356241f, -0.01727957f, -0.07150298f, 0.04639437f, -0.11232051f, 0.02259936f, 0.02094780f, -0.22647826f, 
    -0.11946896f, -0.01072137f, -0.16693108f, 0.02678915f, 0.03196322f, -0.03614490f, 0.09472889f, -0.03015588f, 
    0.14694510f, 0.04415024f, 0.04410570f, -0.06679784f, -0.14952172f, -0.35739467f, 0.03749455f, 0.05190799f, 
    -0.02038511f, -0.08723143f, -0.01179640f, 0.35974896f, 0.03503855f, 0.02352179f, 0.08834787f, 0.09497257f, 
    0.25202119f, -0.32547790f, -0.26187178f, -0.12225634f, -0.04140189f, 0.03567613f, -0.10345814f, 0.03448053f, 
    0.00256517f, -0.14251985f, -0.19596182f, 0.01842621f, -0.09867264f, -0.21554907f, 0.02708273f, -0.13733299f, 
    -0.00127399f, 0.04102297f, -0.08933256f, -0.12659909f, -0.04342579f, 0.08048457f, 0.20099430f, 0.16240551f, 
    -0.14739248f, -0.36486536f, -0.23162772f, -0.16400209f, 0.02767392f, -0.07751022f, 0.09889077f, 0.10214421f, 
    0.10444333f, -0.26640216f, 0.21443893f, 0.06682711f, 0.46858105f, 0.07813486f, 0.23023029f, 0.06480656f, 
    0.03001203f, 0.19344503f, 0.14273323f, -0.17758593f, -0.04270749f, -0.10954293f, 0.04004056f, 0.03440522f, 
    0.07557165f, 0.13006976f, -0.28624839f, -0.51764590f, -0.08018327f, -0.08739185f, -0.03005392f, 0.03937719f, 
    -0.14012142f, -0.16462597f, 0.08187957f, -0.23936085f, 0.38889617f, 0.11597830f, 0.03820053f, 0.21804540f, 
    0.02721019f, 0.00930509f, 0.06032183f, -0.08955209f, -0.05913519f, 0.07053231f, -0.03643894f, -0.03363829f, 
    -0.26190472f, 0.16226570f, -0.24937667f, -0.50349349f, 0.04915183f, -0.04251303f, -0.10444669f, 0.11089941f, 
    -0.02378414f, -0.04407758f, -0.04676503f, -0.02071363f, -0.48214510f, 0.12037297f, 0.09883953f, -0.21592578f, 
    0.04402120f, -0.11909462f, 0.09375695f, 0.01668446f, -0.02679013f, 0.02681976f, 0.09559304f, -0.19311333f, 
    -0.52491391f, -0.42720285f, -0.08963066f, 0.03527540f, 0.04609190f, 0.00593538f, -0.07342823f, -0.11736523f, 
    0.11097567f, -0.01479113f, -0.03569615f, -0.06719218f, 0.22218002f, 0.03612143f, 0.23194355f, -0.13431527f, 
    0.14498948f, 0.08185212f, -0.01093944f, 0.12767610f, -0.07282043f, 0.10324890f, 0.04672024f, 0.12621808f, 
    -0.43565908f, -0.09149206f, -0.08125586f, -0.41100845f, 0.02849619f, 0.03846958f, 0.00512558f, -0.18226285f, 
    0.18074210f, -0.03202123f, -0.10224131f, 0.03636820f, -0.14345451f, -0.53235185f, -0.23354103f, 0.10925474f, 
    0.11938304f, -0.12237547f, 0.01374805f, 0.07376381f, 0.03373409f, 0.11570060f, -0.05861328f, 0.07419178f, 
    -0.35675603f, -0.09956780f, 0.01432442f, 0.07751884f, 0.15212341f, 0.01239248f, -0.02539229f, 0.01602112f, 
    0.06523960f, 0.13005479f, 0.09235194f, 0.16373816f, 0.04803671f, 0.12850451f, 0.12593453f, 0.02793583f, 
    0.16827968f, 0.07778091f, 0.05694531f, -0.04197321f, 0.16308177f, -0.12611035f, -0.09546160f, -0.00427387f, 
    0.08105941f, -0.04085368f, -0.02278317f, -0.03337587f, -0.10838058f, -0.14285871f, 0.08968926f, 0.07332645f, 
    0.27672783f, 0.05063598f, 0.00594628f, -0.19103999f, -0.75193983f, 0.34095404f, -0.15277214f, 0.10986663f, 
    0.10839846f, 0.02334899f, -0.16073786f, -0.10707188f, 0.15647669f, 0.12827896f, -0.24072725f, -0.04695914f, 
    -0.20231840f, -0.27206695f, 0.01999604f, 0.09602418f, 0.17738001f, 0.01527644f, 0.10781559f, 0.15637456f, 
    -0.04503327f, 0.18125695f, -0.01340889f, 0.09466746f, 0.15552321f, 0.20183861f, -0.02823496f, 0.02407438f, 
    -0.03305042f, 0.09182715f, 0.06859991f, 0.01055001f, -0.08971299f, 0.11895544f, -0.00198087f, -0.00239083f, 
    0.37932581f, 0.15618999f, -0.14399001f, -0.15940705f, -0.26817527f, 0.07677104f, -0.09872099f, -0.03935089f, 
    -0.07886061f, -0.18441397f, -0.07525706f, -0.33529609f, -0.46806246f, -0.27782404f, 0.15419340f, 0.02876151f, 
    -0.04799149f, 0.06381169f, -0.11929214f, 0.04684581f, 0.02040033f, 0.03117530f, 0.00975525f, -0.06444724f, 
    -0.05920639f, -0.05639221f, 0.15999855f, 0.00119122f, 0.07715512f, 0.00513325f, -0.08481635f, -0.03470531f, 
    0.07950350f, 0.13565992f, 0.09155300f, 0.19016406f, 0.10464847f, 0.11365608f, 0.08629137f, -0.38589969f, 
    0.06519815f, 0.11041544f, 0.01929753f, 0.09449407f, 0.00756099f, 0.11274465f, -0.10820387f, -0.07670399f, 
    -0.06128441f, -0.08386381f, 0.20294183f, 0.00683537f, -0.01189047f, -0.11108758f, 0.05593112f, -0.00480082f, 
    0.04556013f, -0.00161545f, -0.08629098f, 0.00292580f, 0.25785667f, -0.16848901f, -0.02377565f, -0.06121137f, 
    -0.19944966f, 0.11138604f, 0.11046590f, 0.05392951f, 0.02555360f, -0.00596181f, 0.00884116f, -0.00952069f, 
    0.26498839f, 0.23810790f, -0.08322762f, 0.04003679f, -0.27748317f, -0.13429478f, 0.08372295f, 0.02809462f, 
    0.10741308f, 0.07985208f, -0.00580961f, -0.22374839f, 0.23713548f, 0.02045628f, -0.03465488f, 0.07970282f, 
    -0.13043408f, -0.21095850f, 0.03311512f, 0.00633264f, 0.10539661f, -0.01165485f, -0.09713317f, 0.07038203f, 
    -0.44363657f, -0.47429529f, -0.39367884f, -0.22361059f, -0.03183767f, -0.11122349f, -0.03252790f, 0.05445047f, 
    -0.04364112f, 0.05541321f, -0.01088804f, 0.05718473f, 0.32061198f, -0.22190179f, -0.11087972f, 0.15921246f, 
    -0.06512665f, -0.04628797f, 0.06113795f, 0.21339244f, 0.07554139f, -0.07383572f, -0.04765653f, 0.05437686f, 
    -0.84238321f, -0.60341805f, 0.08626234f, -0.25759527f, 0.04866240f, -0.02128302f, -0.23015617f, -0.02339837f, 
    0.05814939f, 0.01907161f, -0.01075690f, 0.13137498f, -0.41739863f, -0.45292845f, 0.11978763f, 0.20709081f, 
    0.08545544f, 0.06477501f, -0.01007552f, 0.08161824f, 0.04786963f, 0.08148484f, -0.03359038f, 0.10460669f, 
    0.25651711f, 0.28740773f, 0.01353001f, 0.10047753f, -0.06507250f, -0.07066524f, -0.24374114f, 0.10073639f, 
    -0.05894541f, -0.16092999f, -0.08828630f, 0.07899136f, -0.05240259f, -0.21347493f, 0.15960401f, -0.04835962f, 
    -0.17396830f, 0.06196140f, 0.06447846f, -0.16278230f, 0.06504676f, -0.14020981f, -0.01418559f, -0.06703246f, 
    0.21786240f, 0.25629973f, -0.09833471f, -0.17284034f, -0.11529624f, 0.06567008f, 0.12983820f, 0.02594227f, 
    0.03783204f, 0.10801025f, 0.10399856f, 0.07043289f, -0.09305857f, 0.20612429f, 0.12606728f, 0.09172786f, 
    0.11139242f, -0.08633991f, -0.13548775f, -0.02574319f, 0.13534614f, -0.18573372f, -0.31966010f, -0.28351760f, 
    0.05280580f, 0.07526339f, -0.02370733f, 0.04135970f, 0.11616515f, 0.00940100f, 0.06435319f, -0.15482864f, 
    0.02780673f, 0.26302284f, -0.00492063f, 0.03287199f, -0.63519078f, -0.23035689f, -0.10419534f, 0.09561887f, 
    0.09799564f, 0.07432661f, 0.02014261f, -0.16284515f, 0.16854610f, 0.04147201f, -0.03626874f, 0.15613037f, 
    -0.00260858f, 0.13688579f, -0.09254314f, -0.32319552f, 0.12952492f, 0.07470990f, 0.03508860f, 0.06194282f, 
    0.09565994f, 0.17763624f, 0.07517113f, 0.24266881f, -0.16906416f, 0.00681222f, -0.11836069f, 0.12750778f, 
    0.06995293f, 0.30069780f, 0.08238278f, -0.00902778f, -0.01357589f, 0.00146789f, 0.02922536f, -0.03275548f, 
    -0.61291951f, -0.01565374f, -0.25084740f, -0.57281697f, 0.25062144f, -0.07919296f, -0.14866996f, 0.04708084f, 
    0.13591513f, -0.12390371f, 0.01554750f, -0.00639401f, 0.07698490f, 0.19970123f, 0.12429921f, -0.00397205f, 
    0.09833313f, -0.03907368f, -0.04271709f, 0.05995465f, -0.18305185f, -0.01767971f, -0.12842806f, 0.15492670f, 
    0.26321885f, 0.08522782f, 0.00917522f, 0.11830731f, 0.06245914f, 0.07632176f, 0.08569084f, -0.06193903f, 
    0.24812406f, 0.06497431f, 0.12857671f, -0.01716821f, 0.00384600f, 0.25234771f, 0.20446309f, 0.01266618f, 
    -0.08529072f, -0.08329035f, -0.01583879f, -0.14304596f, 0.04108046f, -0.01706653f, 0.04576195f, -0.00018483f, 
    0.43740869f, -0.44788823f, -0.20537570f, -0.32079422f, -0.00110934f, 0.01148660f, 0.04469885f, -0.00322130f, 
    0.10728729f, -0.08500775f, -0.00222835f, 0.00261852f, 0.16469932f, 0.29778120f, -0.38876581f, -0.01475563f, 
    0.09737483f, -0.06349939f, 0.06740084f, 0.11272026f, 0.01405922f, 0.10838617f, -0.01878350f, -0.02118380f, 
    0.58339161f, -0.21353076f, -0.15899229f, 0.14299178f, -0.10783651f, -0.04864108f, -0.09251839f, -0.07649857f, 
    0.15971470f, 0.08175752f, 0.11374547f, -0.00519764f, 0.10137583f, 0.19111556f, 0.15392096f, -0.11368582f, 
    0.10838872f, -0.05884271f, -0.05354803f, 0.17262332f, 0.15692821f, 0.03317028f, 0.08967378f, -0.08932173f, 
    -0.20876740f, -0.08935324f, -0.01584393f, 0.08711332f, 0.12742829f, 0.13039033f, 0.03730208f, -0.05862781f, 
    0.11667720f, 0.07490932f, 0.00335350f, -0.11205083f, -0.46835032f, -0.05483321f, -0.07741588f, 0.23796938f, 
    -0.13253556f, 0.16255467f, -0.07742904f, 0.25725728f, 0.10838318f, -0.06445135f, 0.09949405f, 0.01417489f, 
    -0.12722747f, 0.47313580f, -0.01176712f, 0.11563575f, 0.13967328f, -0.00051733f, 0.01068128f, 0.11075658f, 
    0.08692587f, -0.13405649f, -0.20761250f, -0.14657244f, 0.28847075f, -0.25617206f, -0.09849348f, 0.16205156f, 
    -0.27963340f, -0.01184964f, -0.08912702f, -0.17873761f, -0.08150486f, -0.02266970f, -0.18597163f, -0.10975003f, 
    0.00356758f, -0.06465101f, -0.19911057f, 0.06041374f, -0.18396536f, 0.01862548f, -0.06873201f, -0.11335504f, 
    0.00185415f, 0.06025128f, 0.09761257f, -0.18480721f, -0.15002531f, 0.34359038f, -0.32610089f, 0.15331343f, 
    0.06859817f, 0.09555613f, -0.10856805f, -0.08513568f, -0.09217941f, -0.05194569f, -0.01489517f, 0.04106754f, 
    -0.14465670f, -0.08380403f, -0.00937822f, -0.00719984f, -0.05273418f, 0.04534969f, -0.03015326f, -0.02333429f, 
    -0.29419062f, -0.02499725f, -0.03139646f, -0.23238729f, -0.08555581f, 0.28304192f, 0.05241470f, -0.04269417f, 
    -0.09934427f, -0.00149492f, -0.17175651f, -0.15671873f, 0.14912508f, -0.02971185f, -0.10385480f, -0.18226534f, 
    0.09932100f, -0.29493207f, -0.07761893f, 0.03435954f, 0.07424039f, -0.11888736f, -0.01577666f, -0.10101257f, 
    -0.19839799f, -0.17795850f, 0.21337967f, 0.07111505f, -0.59858334f, 0.28717229f, 0.12227256f, -0.09848345f, 
    0.02740225f, -0.06174178f, -0.09795213f, 0.02051109f, 0.04732390f, -0.04111169f, 0.11917290f, -0.08546430f, 
    -0.02162310f, -0.32668647f, -0.05233748f, 0.08831295f, -0.16320005f, 0.19169262f, -0.00405390f, 0.10282174f, 
    -0.24755727f, 0.04819139f, -0.05966982f, -0.14930373f, -0.05662077f, -0.08055656f, -0.04160331f, -0.14168723f, 
    -0.06626424f, -0.04192615f, 0.08434389f, 0.00903008f, -0.10747992f, 0.00162083f, -0.00860847f, -0.09826756f, 
    -0.37254629f, -0.28571117f, -0.15996285f, -0.11659164f, 0.07982691f, 0.01606993f, 0.02978800f, -0.01588589f, 
    0.02362636f, -0.11563411f, -0.06718070f, -0.04116842f, -0.16078389f, 0.15504506f, -0.00156944f, -0.16633953f, 
    0.14573883f, -0.21454829f, -0.03718842f, -0.14448933f, 0.09743864f, 0.11228558f, 0.17170714f, 0.05802697f, 
    0.05611850f, 0.25923535f, -0.07951496f, -0.25992179f, 0.08851343f, 0.16961677f, 0.00606695f, -0.16551933f, 
    0.15828337f, -0.13216524f, -0.00768992f, 0.03864801f, 0.43596497f, -0.22396992f, 0.03945642f, -0.06291931f, 
    -0.07429399f, 0.02341714f, -0.02976853f, -0.04607741f, -0.02026913f, 0.08056661f, -0.15172429f, -0.02299780f, 
    -0.06950601f, 0.18837667f, -0.06346903f, -0.05420054f, 0.01014352f, -0.19918887f, 0.06015177f, 0.03441732f, 
    -0.14403494f, 0.08263071f, 0.13184673f, 0.04392355f, -0.02065493f, 0.06735500f, -0.17085364f, -0.19667055f, 
    -0.02363336f, 0.02877397f, 0.04589412f, -0.04906795f, -0.18707921f, 0.06553103f, 0.02929819f, -0.14229594f, 
    0.06100534f, 0.09092034f, -0.10672176f, 0.25918350f, -0.05051278f, -0.07351468f, -0.03244495f, 0.16473448f, 
    0.02532172f, -0.16827783f, 0.01102909f, 0.02321650f, 0.13906285f, 0.18100755f, -0.15836842f, 0.23231137f, 
    -0.14210016f, 0.00180743f, -0.18275750f, -0.08242872f, 0.18421905f, 0.05165243f, 0.18164350f, 0.10412159f, 
    0.25831237f, -0.09330187f, 0.02034034f, 0.09667912f, -0.24714428f, 0.10094509f, -0.23325066f, 0.20424341f, 
    -0.07810191f, -0.08132445f, -0.07648320f, -0.09803394f, 0.30302459f, 0.26313320f, -0.20005953f, -0.34500417f, 
    0.10444875f, -0.08171313f, -0.21270202f, 0.12948234f, -0.03490087f, 0.07311434f, -0.11189302f, 0.04614291f, 
    0.39396155f, -0.13089295f, -0.23084100f, 0.37189332f, 0.05675097f, -0.10431036f, -0.01102954f, 0.05326425f, 
    -0.03241782f, 0.05775446f, 0.00426357f, -0.19374105f, -0.43476140f, 0.28232852f, 0.25117046f, -0.11510297f, 
    -0.27115458f, -0.19689906f, -0.13190827f, -0.01050866f, 0.03147090f, 0.04079890f, 0.12144656f, 0.06614435f, 
    0.02406842f, -0.20470650f, -0.18622462f, 0.18652083f, -0.08993771f, 0.08188196f, -0.02665091f, -0.13054273f, 
    0.10307052f, -0.01879134f, 0.12896198f, 0.07443264f, -0.28179350f, 0.19351430f, -0.11529071f, -0.23679544f, 
    0.24775986f, -0.02744316f, 0.01792346f, -0.05362595f, -0.00457146f, -0.05498226f, 0.11911287f, 0.01958160f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.12043678f, 0.01752128f, -0.10868971f, -0.00407762f, 0.01352704f, -0.01555381f, 0.02904496f, -0.05765340f, 
    -0.04583140f, 0.01474728f, 0.09294411f, 0.07191758f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
