#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.09596182f, -0.17990954f, 0.76951694f, -0.45405671f, -0.38645029f, -0.00889560f, 0.07242299f, -0.06037049f, 
    0.50241023f, 0.02926511f, 0.35427475f, 0.36135665f, 0.37758192f, -0.01077054f, 0.37470713f, -0.06207626f, 
    -0.42224514f, 0.23952739f, -0.71383190f, -0.35147604f, 0.80617064f, -0.20818707f, 0.15336524f, -0.36552089f, 
    -0.28164440f, -0.25122088f, 0.35664696f, -0.44665062f, -0.61528414f, 0.92749357f, -0.25600305f, -0.17037201f, 
    -0.41471466f, -0.10183620f, -0.17469195f, -0.51998919f, 0.06691322f, 0.01465029f, 0.15287407f, 0.02344402f, 
    0.13787130f, 0.40888652f, 0.20114827f, -0.08057717f, 0.46947926f, 0.15728073f, 0.23938283f, 0.01826563f, 
    -0.56587195f, -0.05775854f, 0.60816228f, -0.26309299f, 0.09161431f, 0.59387189f, 0.88065600f, -0.69200563f, 
    0.29774049f, -0.05688532f, 0.16492514f, -0.18744548f, 0.05685204f, 0.09611738f, 0.02557366f, 0.39034623f, 
    -0.10130681f, 0.30319172f, 0.14020607f, -0.24261996f, 0.35425696f, -0.48472178f, -0.41930622f, 0.08637147f, 
    -0.11142364f, -0.48577809f, -0.13979129f, 0.33764228f, -0.44133428f, 0.66794521f, -0.04323465f, -0.24117389f, 
    -0.41926968f, -0.15363950f, -0.10398900f, 0.03038382f, -0.86713725f, -0.35231736f, -0.36690623f, -0.17125510f, 
    0.62790215f, -0.09063733f, -0.60578710f, -0.12877102f, -0.08058862f, 0.48446673f, 0.46826082f, 0.59454626f, 
    0.16771661f, 0.11175150f, 0.11966521f, -0.31431556f, -0.37292436f, 0.03816647f, 1.41549397f, -0.82611752f, 
    -0.04576454f, 0.07121433f, -0.05112985f, -0.15765135f, -0.04984479f, 0.07287964f, 0.02976566f, 0.25103343f, 
    0.46159855f, -0.29765093f, 0.54614121f, -0.38176638f, -0.33297759f, -0.43012413f, -0.17094439f, -0.10441411f, 
    0.31781089f, -0.48406559f, -0.82944590f, -0.35997573f, 0.04268811f, -0.22959872f, -0.52799690f, 0.21194459f, 
    0.37307310f, -0.21152383f, -0.09073830f, 0.47355422f, 0.55521011f, -0.56926566f, -0.21917780f, -0.10223229f, 
    0.26760772f, -0.31945980f, -0.69417518f, 0.05806540f, -0.54229093f, 0.38838640f, 0.23562737f, 0.42506996f, 
    0.38874954f, -0.03184867f, 0.19997846f, -0.49510401f, 0.70423383f, -0.24166930f, 0.01532121f, -0.07486869f, 
    0.17746966f, -0.20189558f, -0.28187263f, 0.31519133f, 0.14211407f, -0.45840698f, -0.01505265f, -0.02378272f, 
    0.47932813f, 0.37256381f, 0.41738272f, -0.43088418f, -0.42119515f, 0.08227253f, -0.35224065f, -0.19672374f, 
    -0.15838851f, 0.52969116f, 0.56082147f, 0.40061504f, 0.52719247f, -0.02666575f, -0.43864664f, -0.64003563f, 
    -0.21832725f, 0.16500159f, 0.48294953f, -0.52313942f, 0.12174844f, 0.35961559f, 0.52128571f, 0.11450917f, 
    -0.08898536f, 0.43102780f, 0.20724370f, -0.22464085f, -0.02213048f, -0.48921216f, -0.53238118f, 0.35059163f, 
    0.51871824f, 0.50538266f, 0.57503074f, -0.49491337f, -0.38944754f, -0.35783082f, -0.31401423f, -0.18925248f, 
    -0.62098217f, -0.30721852f, -0.72423261f, -0.13066094f, -0.03045989f, -0.25487018f, 0.30796191f, 0.63672346f, 
    0.09503424f, -0.81675071f, -0.16570494f, 0.00418181f, 0.28513345f, 0.01379707f, -0.03617407f, 0.31614956f, 
    -0.18149409f, 0.47236291f, 0.23982793f, -0.01922897f, 0.60724384f, -0.55402130f, 0.25739908f, 0.31218120f, 
    0.13703172f, -0.77895403f, -0.72347009f, -0.09773223f, 0.03657088f, 0.26932585f, -0.29273060f, -0.04742604f, 
    -0.20690279f, -0.49967849f, 0.29928350f, 0.54521066f, 0.52972198f, 0.12500858f, -0.58231825f, -0.63995695f, 
    -0.29201359f, 0.16457193f, 0.36825478f, 0.74835593f, -0.70304495f, 0.21003827f, 0.32977235f, 0.11020559f, 
    -0.04500712f, -0.06240032f, 0.05837684f, 0.33494776f, -0.67280412f, -0.51800865f, -0.12143092f, -0.60212809f, 
    -0.62582451f, 0.70016927f, 0.11645840f, -0.01244561f, -0.00789471f, -0.59442830f, -0.68598980f, -0.72315347f, 
    0.84259969f, 0.58613652f, 0.11369685f, -0.27512220f, -0.24262638f, 0.28374496f, -0.63952357f, -0.01583781f, 
    -0.31629497f, 0.30335614f, -0.28898472f, -0.12693430f, 0.63523203f, -0.10076015f, 0.58932811f, 0.34370625f, 
    0.40923998f, 0.10981171f, -0.17991564f, 0.52418762f, -0.40953821f, -0.07224780f, -0.27865529f, -0.30022788f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.08732139f, 0.26744103f, 0.20967065f, -0.34478328f, -0.08772289f, 0.43042207f, 0.10245392f, -0.10870738f, 
    0.01038381f, -0.05537991f, 0.01011607f, -0.13372190f, 0.36443806f, 0.37586594f, 0.31921279f, 0.03677206f, 
    -0.20673686f, 0.02573824f, 0.03833899f, 0.37257349f, 0.19605733f, -0.13786586f, -0.37819922f, 0.36146867f, 
    -0.00548191f, 0.07897740f, -0.04850565f, 0.01193932f, -0.28546906f, -0.02905602f, 0.06810968f, 0.34269530f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.22758906f, 0.21495955f, 0.15444846f, 0.17989732f, 0.17894664f, 0.02014300f, 0.12101247f, 0.10954545f, 
    0.20219959f, -0.18240182f, -0.09597618f, -0.04891524f, 0.00072816f, 0.01292832f, 0.04121294f, -0.15277819f, 
    -0.24733904f, 0.06934302f, 0.27367869f, 0.30218062f, 0.05259882f, -0.13328888f, 0.10262991f, 0.06411812f, 
    -0.04303482f, 0.05353265f, -0.08019667f, 0.07533084f, 0.18555669f, -0.00492814f, 0.01501995f, 0.03588812f, 
    0.08488604f, 0.04896913f, 0.14537269f, -0.30923155f, -0.01251224f, -0.01874292f, -0.10052705f, -0.11518969f, 
    -0.15939507f, -0.11634075f, -0.10852565f, -0.01382162f, 0.14526409f, 0.06767979f, -0.06095024f, -0.01829476f, 
    0.07113705f, -0.01119897f, -0.06907650f, 0.01176421f, -0.03142949f, 0.28591940f, -0.03868492f, 0.00487630f, 
    0.04472529f, 0.02769916f, 0.07723604f, 0.12267370f, 0.01358901f, -0.03629366f, 0.03600086f, -0.02481795f, 
    -0.02826158f, 0.02035748f, 0.01135170f, 0.08304819f, -0.01535497f, -0.08332513f, -0.15800302f, 0.04347732f, 
    -0.09299202f, 0.21634747f, 0.00538281f, 0.12284613f, -0.09245355f, -0.06915566f, 0.02643397f, -0.01440815f, 
    -0.06450230f, -0.00295567f, 0.05840116f, 0.06843042f, 0.13695379f, 0.18274774f, 0.11880644f, 0.14751244f, 
    0.12825342f, 0.04302589f, -0.05800936f, -0.03271634f, -0.08176012f, 0.14073128f, -0.04978269f, -0.05066330f, 
    -0.17450315f, -0.08271055f, 0.05568574f, 0.43757498f, 0.35302317f, 0.25776657f, 0.12810059f, 0.12870325f, 
    0.09439081f, -0.09380594f, 0.06045387f, -0.09935480f, -0.10212087f, 0.12806474f, 0.13499917f, -0.06026933f, 
    0.01340556f, 0.01888838f, -0.18468693f, -0.04628586f, -0.06549714f, 0.24674116f, 0.13598906f, 0.11860657f, 
    -0.06247897f, 0.08057414f, 0.03488957f, -0.03742282f, -0.15620628f, -0.24685033f, -0.05303114f, -0.00697268f, 
    0.14224216f, 0.12877673f, -0.07692849f, -0.04295896f, -0.02410757f, -0.00188210f, -0.02686492f, 0.03544137f, 
    0.13040717f, 0.21300946f, -0.06579815f, 0.01577694f, 0.17366348f, 0.04590252f, 0.13371296f, 0.15510468f, 
    0.11595803f, 0.23448637f, 0.00964507f, 0.19013835f, -0.07713681f, 0.14141209f, -0.08326752f, 0.08192888f, 
    0.11672742f, 0.09560914f, 0.07822336f, 0.02944936f, -0.02905610f, 0.02226153f, -0.23527929f, 0.20143795f, 
    0.11747008f, 0.02162282f, -0.01456196f, -0.03958897f, 0.07865858f, 0.05467877f, 0.21745011f, 0.01532013f, 
    0.18196765f, -0.05433552f, 0.05740163f, -0.26413774f, 0.22345020f, -0.09860792f, -0.11596904f, 0.08241452f, 
    0.08785511f, -0.06761077f, 0.22998194f, -0.01168948f, -0.17773165f, -0.09827519f, -0.01864077f, -0.10843503f, 
    0.09049308f, 0.03574401f, -0.08223031f, -0.13388921f, 0.03835911f, -0.11196969f, 0.03820952f, -0.05091968f, 
    0.09843996f, 0.06576318f, -0.11987846f, -0.08338878f, -0.07745741f, -0.06562444f, 0.17256466f, 0.14270441f, 
    0.06867595f, 0.03152872f, 0.03781191f, 0.03630551f, 0.10545452f, -0.04206362f, 0.02481404f, 0.01566988f, 
    -0.06954642f, 0.14023149f, 0.02099044f, 0.05282953f, 0.22922648f, 0.09119525f, -0.09001102f, 0.09769172f, 
    -0.11820190f, 0.16111469f, -0.09217301f, -0.03317678f, 0.01324599f, -0.02694719f, -0.02801416f, 0.17390090f, 
    -0.03325468f, 0.26296648f, 0.11261273f, -0.16775809f, -0.02180833f, 0.00393291f, -0.02673319f, -0.11087649f, 
    -0.01049446f, 0.04835290f, -0.41379106f, -0.39931276f, -0.07114613f, -0.10955363f, 0.13684960f, 0.03901258f, 
    -0.02353307f, -0.00017859f, 0.06574791f, -0.04828152f, -0.09365838f, -0.05786332f, -0.00478238f, 0.00263656f, 
    0.05562980f, 0.00515100f, -0.05187880f, -0.05535011f, 0.15781614f, -0.05735410f, 0.05193656f, 0.05660829f, 
    -0.02433833f, 0.08008589f, 0.10130356f, 0.02149875f, -0.05017168f, 0.15366636f, 0.00944326f, -0.26342779f, 
    0.04919334f, -0.11907224f, -0.07077423f, -0.05558748f, -0.05089566f, -0.06602389f, 0.12645422f, 0.27187559f, 
    0.14929131f, -0.03418289f, 0.01352643f, -0.03418550f, -0.02043115f, 0.13046053f, 0.06794284f, -0.21764739f, 
    -0.04646629f, -0.11222612f, -0.04354059f, 0.00292457f, -0.03794875f, -0.15643086f, -0.03884057f, -0.11105800f, 
    -0.04525483f, -0.15332118f, -0.11989777f, -0.06493534f, 0.06462681f, 0.03801895f, 0.05978083f, 0.08776356f, 
    -0.03198014f, -0.10240323f, -0.07351115f, 0.14557225f, -0.11810491f, -0.11284877f, -0.21345665f, 0.09535241f, 
    -0.01365570f, -0.01258366f, 0.13640244f, -0.04857364f, 0.32359946f, 0.05929622f, 0.10642876f, 0.03015300f, 
    0.02620238f, 0.10230369f, 0.18482585f, -0.21855120f, -0.30483931f, 0.04229889f, 0.01130736f, -0.07539925f, 
    0.20950161f, -0.15742001f, 0.03167375f, -0.00219040f, -0.10707788f, 0.03503506f, -0.00184706f, 0.07764393f, 
    -0.02074303f, -0.03574888f, -0.02778604f, -0.06453843f, 0.02110644f, -0.05153691f, 0.10394676f, 0.02305392f, 
    0.01146246f, 0.17923723f, 0.09677599f, -0.08080940f, 0.19323400f, 0.10383107f, 0.29611412f, -0.02598579f, 
    -0.08819836f, -0.04282919f, 0.02172603f, 0.01673880f, -0.14938860f, -0.01149332f, 0.14925753f, 0.05230745f, 
    0.02007716f, 0.04868714f, -0.05818208f, -0.11865661f, -0.05919405f, -0.20294614f, -0.10263494f, -0.06228118f, 
    -0.02502185f, -0.06555467f, 0.15828788f, -0.04322939f, 0.00914142f, 0.18357471f, -0.12537400f, -0.10436506f, 
    0.02322791f, -0.21313243f, -0.09478118f, -0.00452432f, -0.00038422f, -0.06732085f, -0.14720970f, 0.18922442f, 
    0.06069167f, -0.01259586f, -0.15611543f, -0.07851187f, 0.09850906f, 0.01325297f, -0.01308772f, -0.06115766f, 
    0.08275983f, 0.01819442f, 0.01796108f, 0.02574095f, -0.31401038f, 0.32947591f, -0.04516038f, 0.04765668f, 
    -0.06990992f, -0.04329263f, -0.07659691f, -0.08230259f, 0.18262957f, 0.04792468f, 0.13474303f, -0.03110089f, 
    0.00455842f, 0.00620828f, 0.10317636f, 0.02743235f, 0.00669141f, 0.06998885f, -0.08103925f, 0.06110043f, 
    0.16565886f, 0.09274215f, 0.10172942f, 0.09108356f, -0.03208948f, 0.00287673f, 0.01215132f, 0.06696761f, 
    0.13725439f, 0.07009176f, 0.00680520f, 0.22775899f, 0.03409702f, -0.04076141f, -0.16604865f, -0.07421120f, 
    -0.05825532f, -0.14229625f, 0.07645328f, -0.07612712f, 0.00285288f, 0.10978410f, 0.15572004f, 0.05618012f, 
    -0.11697301f, -0.19396721f, 0.21084134f, -0.07348748f, 0.04159760f, -0.28466794f, -0.09365132f, -0.32803226f, 
    -0.16320492f, 0.03047588f, 0.00793917f, -0.06086648f, -0.02839077f, -0.10935675f, -0.00629835f, -0.05906187f, 
    0.13771772f, -0.01229881f, 0.05040086f, -0.12082683f, -0.16760051f, 0.10839743f, -0.08178894f, 0.03857056f, 
    0.04156119f, -0.00940280f, 0.16816415f, 0.10496800f, -0.10020677f, 0.02083925f, -0.07954600f, 0.09230126f, 
    0.05118025f, 0.01930510f, 0.07057310f, 0.12223604f, 0.05813998f, -0.07818677f, 0.18627873f, -0.04223326f, 
    -0.05514272f, -0.05732835f, 0.00334855f, -0.05962040f, -0.01958835f, -0.43719968f, -0.09643604f, 0.02407499f, 
    -0.22269514f, -0.01797448f, -0.04617358f, 0.05942783f, 0.11161228f, -0.18263534f, -0.35827550f, 0.12986436f, 
    -0.07403395f, -0.12898310f, 0.02036272f, 0.00053354f, 0.06466189f, -0.03136526f, 0.08960436f, 0.00130989f, 
    0.11759312f, 0.02822689f, 0.22066933f, 0.07219858f, 0.05971887f, 0.01653003f, 0.07535100f, 0.17068131f, 
    0.03012562f, -0.10958856f, 0.13533254f, 0.06732757f, 0.05306977f, -0.06792267f, 0.05099565f, -0.00046698f, 
    0.01555663f, -0.19592799f, -0.04098369f, 0.25196165f, 0.03769895f, 0.03084470f, 0.08716942f, -0.02330898f, 
    0.02948609f, -0.04481158f, -0.18179926f, -0.32108727f, 0.18398586f, 0.01390888f, -0.14676248f, -0.21476944f, 
    -0.02338716f, 0.24223685f, 0.04396610f, 0.21090856f, -0.02354289f, -0.14181809f, -0.10148390f, 0.16790627f, 
    0.36259696f, -0.10817332f, -0.12081242f, 0.15781499f, -0.40498447f, 0.10718670f, 0.02550428f, -0.01223812f, 
    0.02877641f, -0.02991467f, -0.04521567f, -0.01272608f, -0.00711564f, -0.33887237f, 0.02688488f, 0.21009207f, 
    0.03482584f, 0.05206884f, -0.02687959f, 0.01251044f, -0.08144777f, 0.06339434f, -0.07515291f, 0.16219732f, 
    0.24244498f, -0.11779740f, -0.09800305f, 0.04546507f, 0.09954903f, 0.01555411f, -0.06489138f, 0.13357511f, 
    -0.09373727f, 0.09479089f, -0.04358828f, 0.05343638f, -0.09881318f, -0.06180998f, 0.01997778f, -0.09150633f, 
    -0.13777293f, -0.06034887f, 0.06310912f, -0.02733935f, 0.04144436f, -0.06891812f, -0.00721140f, -0.01942518f, 
    -0.09577291f, 0.05743493f, -0.07785691f, -0.03869822f, -0.11200628f, -0.14566472f, -0.10687237f, -0.00050888f, 
    -0.00800418f, -0.11661546f, 0.14437610f, -0.05476171f, -0.13119479f, 0.02769119f, 0.00435513f, 0.06905691f, 
    0.07955883f, 0.11500845f, -0.05581119f, 0.33233353f, 0.07996660f, 0.02039345f, 0.01187425f, 0.05294393f, 
    0.13712656f, 0.13023852f, -0.13707611f, -0.07347674f, 0.07696654f, -0.35903203f, -0.21949896f, -0.04793552f, 
    -0.07119713f, 0.30621749f, 0.01880706f, -0.11991791f, 0.09837745f, -0.15013459f, -0.40838239f, -0.02675153f, 
    0.05911184f, -0.01636383f, -0.05340353f, 0.00757988f, -0.08006188f, -0.02796308f, -0.08497378f, -0.29673383f, 
    -0.32496461f, -0.13439016f, -0.00296615f, 0.05088028f, 0.06076417f, 0.04057333f, 0.02120556f, 0.01663185f, 
    -0.24481684f, -0.07676996f, -0.07390667f, -0.13565321f, -0.07436167f, 0.10840189f, 0.01546877f, -0.11056504f, 
    0.32667413f, -0.18599638f, 0.18984899f, -0.08662795f, 0.02597984f, 0.03949731f, 0.03173635f, -0.08164127f, 
    0.11521208f, 0.02559144f, 0.06853299f, 0.12020491f, -0.03220169f, -0.08251068f, -0.13092105f, -0.02144307f, 
    0.02141912f, 0.05682595f, -0.03411490f, -0.11127440f, -0.29841208f, -0.14259718f, -0.03861535f, 0.15289824f, 
    0.10259705f, -0.04737756f, 0.08164039f, 0.24069631f, -0.05390308f, -0.05479108f, -0.21066739f, -0.00854475f, 
    0.02247402f, 0.00235105f, 0.15077780f, 0.09656549f, 0.01307237f, -0.36380541f, -0.24587941f, -0.03400302f, 
    -0.10773027f, -0.09015124f, 0.03278114f, -0.00170162f, -0.02062526f, 0.06349491f, 0.10901028f, 0.09721503f, 
    -0.04843175f, 0.03754886f, -0.07264990f, 0.02313829f, -0.03878808f, 0.04968921f, -0.39586517f, -0.12975052f, 
    0.20221899f, 0.04347463f, 0.01764074f, -0.17268726f, -0.08471326f, 0.08051421f, 0.11765947f, 0.23217440f, 
    0.20768856f, 0.06034992f, -0.11310285f, -0.10401714f, -0.03477946f, 0.00475371f, 0.09840430f, -0.02399907f, 
    -0.33617628f, -0.30758417f, -0.37671930f, -0.07887901f, -0.32804722f, 0.18551864f, 0.03275876f, 0.09935594f, 
    0.03290592f, 0.01056641f, 0.31404763f, 0.55006468f, 0.03357419f, -0.05757630f, -0.03879799f, 0.06698707f, 
    0.03936532f, 0.27222124f, 0.28973332f, 0.17486434f, -0.01190992f, 0.05042089f, 0.02645008f, -0.08349436f, 
    0.16530779f, -0.17882925f, 0.04926324f, -0.07127158f, -0.01638698f, -0.12703823f, -0.05026351f, -0.01553467f, 
    -0.23096232f, -0.03814031f, 0.02977319f, 0.15303041f, -0.10079534f, -0.34876576f, -0.05053953f, 0.07677320f, 
    -0.09550294f, -0.04175516f, -0.03150000f, -0.10261039f, 0.03201460f, 0.23015557f, -0.27183276f, 0.03948436f, 
    -0.04578707f, -0.09100496f, 0.02870510f, 0.05805089f, 0.13587461f, 0.10697530f, 0.24952336f, 0.25191632f, 
    0.33036342f, -0.15044618f, 0.07864929f, 0.13685745f, 0.03798958f, -0.00855028f, 0.04855419f, 0.00367228f, 
    0.05819396f, -0.44931924f, 0.03917301f, 0.04104855f, 0.08754224f, 0.01413904f, -0.02179321f, -0.17422549f, 
    -0.00187173f, 0.01508693f, -0.04524714f, 0.10450135f, -0.08758730f, 0.12300657f, 0.13525023f, 0.16838767f, 
    0.01599305f, 0.37929961f, 0.07972285f, 0.12009934f, 0.09782115f, 0.05494891f, 0.09842440f, 0.10761949f, 
    -0.00159676f, -0.04391757f, 0.07477057f, -0.61528867f, -0.47071633f, 0.04715440f, 0.12710582f, -0.04989700f, 
    0.16022937f, 0.04242514f, -0.06096370f, -0.30757076f, 0.02977408f, -0.31760815f, -0.05687628f, -0.10950951f, 
    0.02042854f, 0.11400565f, 0.18670920f, 0.17682831f, 0.09037334f, 0.08179277f, 0.32487425f, -0.07466803f, 
    0.05873778f, 0.12629770f, 0.03124989f, 0.17316359f, -0.05340006f, 0.26262295f, 0.00748060f, -0.32601395f, 
    -0.00142014f, -0.03068892f, 0.16122171f, 0.02641576f, -0.00637165f, 0.03663378f, 0.04746358f, 0.22358193f, 
    -0.08455250f, 0.01314130f, 0.06599198f, 0.07585634f, 0.01871168f, 0.03675928f, -0.13993320f, -0.24680069f, 
    -0.14342515f, 0.04012002f, 0.05096802f, -0.14162622f, -0.04632069f, 0.06090530f, -0.10762873f, 0.02344915f, 
    -0.04305159f, -0.34304819f, -0.02236899f, -0.01417598f, -0.02134707f, -0.02947612f, -0.02854445f, -0.00575016f, 
    -0.15458088f, 0.19115205f, 0.23684013f, 0.16242200f, -0.12259059f, -0.03183184f, 0.00317858f, 0.00935563f, 
    0.01181437f, -0.05876594f, 0.00608978f, -0.16555250f, -0.01575758f, 0.08893307f, 0.14260603f, -0.00108511f, 
    0.06377269f, 0.23435524f, -0.03607104f, 0.08452063f, -0.27237156f, -0.73326290f, -0.25756320f, 0.05595488f, 
    -0.01821219f, 0.07079320f, -0.05732213f, 0.16467158f, 0.02256564f, 0.04206061f, -0.08828750f, -0.16713580f, 
    -0.11973469f, -0.04028424f, 0.03421847f, -0.01591587f, -0.03220735f, 0.07827662f, 0.02444593f, -0.13880011f, 
    -0.01136165f, -0.05580376f, 0.23204251f, 0.15978675f, -0.03083676f, -0.01733018f, 0.51699775f, 0.01792174f, 
    -0.08564977f, 0.10072134f, 0.00685135f, 0.08124192f, 0.17799301f, 0.03736385f, -0.06521671f, 0.06874725f, 
    0.18813528f, 0.10970642f, -0.04865472f, 0.13948384f, -0.09392099f, -0.09669994f, -0.00441239f, 0.14481674f, 
    0.10762174f, -0.30677041f, -0.41679579f, -0.00168063f, 0.11348481f, 0.13792530f, 0.10561006f, 0.07048611f, 
    -0.00484780f, -0.45692340f, 0.03194740f, -0.01770127f, 0.08536275f, 0.00155747f, -0.16622677f, 0.00138477f, 
    -0.07856135f, -0.00826751f, -0.14080183f, -0.05536744f, 0.02484868f, -0.15237220f, -0.00744489f, -0.06496802f, 
    -0.07226311f, -0.10558055f, 0.04328495f, -0.15712591f, -0.47305176f, 0.09314582f, -0.10649434f, -0.19251437f, 
    -0.12142210f, 0.19117200f, -0.08519156f, 0.02435437f, 0.04072480f, 0.09789310f, 0.13884307f, 0.00735153f, 
    0.16536437f, 0.12599462f, 0.13053766f, 0.03576861f, 0.17498940f, -0.14182565f, -0.46511212f, -0.26100832f, 
    0.07507145f, -0.04384424f, -0.05244918f, 0.03695151f, 0.01759315f, 0.12686749f, 0.01172540f, 0.23298730f, 
    0.14282951f, -0.01709035f, 0.02796238f, 0.11289260f, 0.08388463f, 0.18924922f, 0.22296269f, -0.17433727f, 
    -0.22293682f, 0.02804136f, 0.19758864f, 0.15637207f, 0.03555935f, 0.09742487f, -0.10016626f, 0.06811832f, 
    0.09675025f, -0.31874412f, 0.13179460f, -0.31785029f, -0.20197757f, -0.06832646f, 0.03413718f, -0.04164977f, 
    -0.16196126f, -0.39482683f, 0.06546596f, -0.12421926f, -0.01864303f, -0.09602387f, -0.09703435f, -0.02501874f, 
    -0.03419879f, -0.00628286f, -0.14077468f, -0.07165483f, -0.38895497f, 0.09052146f, -0.03704282f, -0.01549357f, 
    -0.13226655f, 0.02364482f, -0.08606089f, 0.31306124f, -0.15914319f, 0.00140931f, -0.00921720f, -0.01823350f, 
    0.02704125f, -0.01863834f, 0.09971170f, 0.11107671f, 0.30076560f, 0.16100924f, 0.12419119f, -0.05802890f, 
    -0.03160458f, -0.07481018f, -0.04486022f, 0.06463964f, 0.02548374f, -0.04209847f, -0.05020777f, -0.04133391f, 
    -0.16603252f, 0.01729047f, -0.02376213f, -0.08776830f, 0.00745206f, 0.16592979f, 0.05255482f, -0.21119890f, 
    -0.40030146f, -0.07940364f, -0.05131981f, -0.02818837f, -0.04746607f, 0.04685477f, 0.00425762f, 0.17267862f, 
    0.09360592f, -0.37366635f, 0.03160703f, -0.03695730f, 0.10705532f, 0.09528074f, 0.07572310f, -0.00406338f, 
    -0.04345446f, -0.16961887f, 0.14091447f, -0.18884659f, 0.04487870f, -0.05529343f, 0.13708095f, -0.07667369f, 
    0.03583486f, 0.05579011f, -0.44900757f, -0.54231459f, -0.34637105f, -0.04031851f, 0.04159411f, 0.11331278f, 
    -0.03054755f, 0.09064193f, -0.03582650f, -0.06093723f, -0.03033292f, -0.17020150f, -0.09259782f, -0.15186208f, 
    0.05502196f, 0.01027886f, 0.04382618f, 0.27155453f, 0.08678854f, -0.03321432f, -0.02230535f, 0.03258048f, 
    0.04868470f, 0.02617781f, 0.01334202f, -0.08314685f, -0.07441706f, -0.50638908f, -0.44977626f, -0.18186097f, 
    0.09774175f, -0.13652217f, -0.02046559f, -0.11299846f, 0.05155386f, -0.37891051f, -0.25559342f, -0.20696348f, 
    -0.05351199f, -0.02764221f, -0.00861592f, -0.09616554f, -0.02907566f, -0.12517123f, -0.23288961f, 0.17187060f, 
    0.06037590f, -0.05558271f, 0.19658174f, 0.05730693f, 0.11680629f, 0.01684420f, -0.05422287f, 0.18479770f, 
    0.15038782f, 0.15510204f, -0.02798148f, 0.04205428f, -0.01406963f, -0.08997142f, 0.09215266f, 0.20648621f, 
    0.03846220f, 0.01001250f, 0.01226759f, 0.00100277f, -0.03510216f, -0.03669224f, -0.00609581f, -0.04030590f, 
    0.02104404f, -0.03511621f, -0.00790732f, -0.05962912f, -0.01209695f, 0.00618168f, -0.00789125f, -0.02250541f, 
    0.00775484f, -0.01607945f, -0.00912380f, 0.02163435f, -0.05389683f, 0.02640607f, 0.00303438f, 0.04581313f, 
    0.01472760f, -0.00698124f, 0.01965204f, 0.00558929f, -0.00965407f, -0.05058013f, 0.04900443f, -0.04776009f, 
    -0.03479423f, 0.04977524f, 0.00938715f, 0.00214598f, -0.04026687f, -0.03486230f, -0.05331158f, -0.02509854f, 
    0.03991164f, 0.04584743f, -0.02616068f, -0.06157067f, 0.02577231f, -0.02467537f, 0.02441997f, -0.03294171f, 
    0.03463489f, 0.05152080f, -0.01248074f, -0.00335920f, 0.00089866f, -0.04019117f, -0.05865415f, 0.00755539f, 
    -0.04666778f, -0.04152315f, -0.05407115f, 0.02906243f, -0.02737244f, 0.04814503f, -0.00220777f, -0.01054524f, 
    -0.01675294f, 0.00970757f, -0.06438041f, 0.01008890f, 0.01150821f, -0.02178625f, 0.04424590f, 0.04775193f, 
    0.03205693f, -0.03212110f, 0.01734640f, 0.00257513f, 0.03286129f, -0.04797892f, -0.01735137f, 0.03741128f, 
    0.04102337f, -0.05551066f, -0.04951493f, -0.05169094f, -0.02392693f, -0.04379348f, 0.04255068f, -0.05767484f, 
    -0.05093713f, 0.03387013f, 0.02855697f, -0.01726165f, -0.04862218f, -0.04359960f, 0.01207799f, 0.00795588f, 
    -0.03942342f, -0.01749823f, -0.06291911f, 0.04599696f, 0.00649204f, -0.04719052f, -0.03061198f, 0.01119099f, 
    -0.00237875f, -0.00716514f, 0.02002225f, -0.04566484f, -0.03588726f, -0.03253071f, 0.01582024f, -0.02934659f, 
    -0.01099814f, 0.01635461f, -0.03946434f, -0.05021238f, -0.05924272f, -0.03993633f, -0.05220393f, -0.03590478f, 
    0.00390515f, -0.02352197f, 0.02658842f, -0.03340907f, 0.00543623f, -0.02482069f, -0.02310760f, 0.03433373f, 
    -0.03160870f, -0.02352138f, -0.01897980f, -0.02163576f, 0.01687487f, 0.04462124f, -0.03662021f, 0.04217453f, 
    0.04342155f, 0.02747535f, -0.03598090f, -0.02768043f, -0.01871162f, -0.02221116f, -0.00862160f, 0.02129303f, 
    -0.03292655f, 0.02093961f, -0.02689698f, 0.02858725f, 0.05617409f, -0.06117956f, 0.00884554f, 0.00121887f, 
    0.01584587f, 0.05100178f, -0.00808517f, -0.05638708f, -0.06199368f, -0.00708673f, 0.00996775f, -0.04900640f, 
    0.04101486f, 0.00162934f, 0.00572724f, -0.00243671f, -0.03127356f, -0.06222285f, -0.03918609f, -0.02646315f, 
    -0.01022978f, -0.00842889f, 0.02302118f, 0.02723141f, 0.02772486f, 0.02121420f, -0.02869495f, -0.01849143f, 
    0.01355481f, 0.00654286f, -0.00823811f, -0.04370051f, 0.02025446f, -0.02784112f, -0.00930854f, -0.03087319f, 
    0.01869711f, -0.00761167f, -0.01772818f, -0.05193594f, 0.02842979f, 0.04120895f, -0.02774800f, 0.02021423f, 
    -0.03990696f, -0.00637555f, -0.04630633f, -0.01806459f, -0.05512496f, -0.01071109f, -0.01195177f, -0.04686783f, 
    -0.03046474f, -0.00061347f, 0.03993436f, -0.04254589f, 0.03854118f, -0.02096502f, 0.03261733f, 0.03335313f, 
    0.02111547f, 0.00472018f, 0.04179819f, 0.02324512f, 0.03800682f, -0.05170366f, 0.00382393f, -0.01451513f, 
    -0.04810271f, -0.00275734f, -0.00998456f, -0.04161594f, 0.02513173f, 0.05134167f, 0.03620930f, -0.05870046f, 
    -0.00892256f, 0.04633411f, 0.01131377f, -0.04753041f, -0.00701680f, -0.03056671f, -0.05846830f, -0.05882344f, 
    0.04990231f, 0.02258479f, 0.04391662f, -0.02915287f, 0.02722333f, -0.00336654f, -0.02202814f, -0.04678649f, 
    0.02268985f, 0.03293976f, 0.00058029f, -0.01111428f, -0.03932991f, 0.00368217f, 0.02410943f, -0.03241222f, 
    -0.01951656f, 0.03927989f, -0.03833683f, -0.01377644f, 0.02531866f, 0.00180575f, -0.04178194f, -0.05666019f, 
    -0.01113646f, 0.01806973f, -0.03090271f, 0.04129483f, -0.01632971f, -0.00295925f, 0.01055902f, 0.03153203f, 
    -0.06419552f, -0.02114140f, -0.00135651f, -0.02979993f, 0.03340391f, 0.00373349f, -0.06066447f, -0.05324687f, 
    0.02033402f, -0.00474091f, -0.05417933f, 0.04035142f, 0.00984029f, -0.03574949f, -0.03750847f, 0.05074111f, 
    -0.04547962f, -0.06380531f, -0.01574765f, -0.05222543f, -0.03575854f, -0.00345800f, -0.05853245f, -0.06201318f, 
    -0.06248161f, 0.02852164f, 0.02011606f, -0.06424698f, -0.05678584f, -0.03575201f, 0.00762794f, -0.00527799f, 
    0.01560737f, 0.02669960f, -0.06778784f, -0.01044352f, 0.00847785f, -0.05615736f, -0.04446806f, -0.04254213f, 
    -0.00614665f, -0.03287352f, -0.04682172f, 0.02123920f, -0.05274976f, 0.03859304f, -0.00107499f, 0.02155484f, 
    0.04749163f, -0.04870950f, -0.03532177f, 0.02181301f, 0.04067710f, 0.01778137f, 0.00762816f, 0.01885526f, 
    0.04489729f, -0.05358076f, 0.02245859f, 0.02438808f, 0.03373541f, -0.04242927f, 0.05299925f, 0.04744128f, 
    0.00235049f, -0.02660155f, 0.00503081f, 0.05242764f, 0.00390557f, 0.01350532f, -0.01355393f, 0.00994168f, 
    0.01048089f, -0.02533738f, -0.01785024f, 0.04303669f, 0.03482211f, -0.01884652f, 0.00632664f, -0.03022517f, 
    -0.05093835f, 0.05151686f, 0.04679054f, -0.04659849f, -0.02022441f, 0.01138100f, -0.05550706f, 0.02222161f, 
    -0.01194228f, 0.04487744f, 0.00604164f, -0.01989327f, -0.00941162f, 0.02333516f, -0.00720374f, -0.02539809f, 
    0.00135056f, 0.00696741f, -0.05486197f, -0.06676380f, 0.04079317f, 0.01222826f, 0.00408727f, -0.00767019f, 
    -0.05463956f, 0.03623711f, -0.05304376f, 0.04432841f, -0.02654290f, 0.03926653f, -0.05599254f, -0.06015234f, 
    -0.05027562f, -0.02174713f, -0.05879853f, -0.06005275f, -0.02029424f, -0.01255445f, 0.00427464f, -0.05975630f, 
    -0.04666629f, -0.00984637f, 0.01302209f, -0.03931977f, 0.02892183f, -0.03351590f, -0.02354343f, 0.01765583f, 
    0.04942330f, 0.00833002f, 0.01273443f, -0.05254094f, 0.03179629f, -0.06075835f, -0.05349046f, -0.05170063f, 
    -0.03301053f, 0.03718200f, -0.04588120f, 0.01367120f, -0.02478730f, -0.04978954f, 0.01000868f, 0.01578813f, 
    -0.00063048f, 0.03992723f, -0.01408841f, -0.04248668f, 0.02711304f, 0.00633615f, 0.03374116f, -0.03238248f, 
    -0.00570199f, 0.01689870f, -0.03652861f, 0.04673981f, -0.00576735f, -0.03559518f, 0.03570619f, -0.01149305f, 
    -0.04490952f, -0.01709479f, 0.03209973f, 0.03673424f, 0.04521881f, 0.01366422f, -0.06511201f, -0.04404451f, 
    -0.02215781f, 0.01479392f, 0.00424336f, 0.02529486f, -0.00569386f, -0.04154354f, 0.04309124f, -0.02452001f, 
    -0.04043176f, 0.01121362f, 0.03128079f, 0.01210323f, 0.05005165f, 0.05626244f, -0.01454234f, 0.00066472f, 
    -0.05919361f, 0.01400824f, -0.02880618f, 0.03439999f, -0.02068045f, -0.01024763f, 0.00915928f, 0.02563099f, 
    0.01846401f, -0.04089611f, 0.04098872f, -0.00519536f, 0.03679314f, -0.01701391f, -0.04278387f, -0.00204153f, 
    0.01983314f, 0.01870331f, -0.00714014f, 0.02472561f, 0.00111871f, -0.05967251f, -0.06443571f, 0.04706941f, 
    -0.05036022f, 0.00880088f, -0.01818763f, 0.00075237f, 0.00161807f, -0.05802910f, 0.03912111f, 0.02731033f, 
    -0.01215420f, 0.03512914f, 0.00583600f, -0.02938334f, -0.02044413f, -0.03363394f, -0.01701088f, 0.04110610f, 
    -0.02094202f, 0.00361835f, -0.05245411f, -0.03907612f, -0.02500465f, -0.01275110f, 0.00484943f, -0.02560277f, 
    0.03373137f, -0.01386021f, -0.03501830f, 0.01289547f, 0.03985433f, 0.03593053f, 0.02655612f, -0.00825581f, 
    0.05038911f, -0.03345096f, 0.02982390f, -0.05706165f, -0.02550962f, -0.00741953f, -0.00118978f, 0.04600613f, 
    -0.03413903f, -0.04312469f, -0.01880402f, 0.04772809f, -0.07109609f, -0.00248263f, -0.01401648f, -0.04663299f, 
    0.03089502f, 0.01320221f, -0.04404790f, -0.03898313f, -0.06792381f, 0.05437575f, -0.01816900f, 0.01677687f, 
    -0.02451993f, -0.03075085f, -0.05051082f, 0.00437364f, -0.05894369f, -0.04948362f, 0.04709650f, 0.03687291f, 
    0.03748066f, 0.00424070f, 0.04653728f, -0.01438128f, -0.01350067f, -0.00001204f, 0.04108802f, 0.02738367f, 
    -0.02006886f, -0.00145555f, 0.04023772f, -0.02100292f, 0.03598166f, 0.01544360f, -0.04677403f, -0.03341015f, 
    0.03872069f, -0.05923568f, -0.04836071f, 0.03350660f, 0.00418898f, -0.00884798f, -0.01233280f, 0.03321078f, 
    -0.03904931f, -0.02427287f, 0.02107033f, -0.04358900f, -0.02618193f, -0.00795621f, -0.06523933f, 0.02009265f, 
    0.04607236f, -0.03525320f, 0.01471054f, -0.01563001f, -0.01616191f, -0.03272198f, 0.05006589f, -0.04114722f, 
    0.18781397f, -0.02666156f, -0.11394788f, -0.09777559f, 0.04886996f, -0.12856410f, 0.00036817f, -0.01291364f, 
    -0.01387195f, -0.11119751f, 0.04762281f, 0.07125720f, 0.07823901f, -0.12112057f, -0.03026578f, 0.04769503f, 
    0.00161011f, 0.09848819f, -0.08177348f, -0.40197068f, 0.12034799f, 0.04521992f, 0.15730105f, -0.06447557f, 
    0.07660736f, -0.04953997f, 0.02355089f, -0.14009596f, -0.39462447f, -0.22364496f, -0.42566785f, 0.15591849f, 
    0.07664501f, -0.06008276f, 0.05392724f, 0.00393257f, -0.03926647f, 0.19808362f, -0.06378144f, -0.02641917f, 
    -0.02002174f, -0.06975453f, -0.01063920f, -0.09150346f, 0.15018876f, 0.15807749f, 0.18101975f, 0.06570713f, 
    0.27826428f, -0.04650994f, 0.12432554f, 0.08147096f, 0.10294701f, 0.11237585f, 0.54434347f, -0.11736435f, 
    -0.14280866f, 0.01363378f, -0.06205225f, 0.00899207f, -0.05238905f, -0.07503848f, -0.04956715f, -0.21289220f, 
    0.06879602f, 0.22208236f, -0.06274486f, 0.00951959f, 0.04406528f, 0.10800043f, -0.09543175f, 0.07894327f, 
    -0.14836009f, 0.18564945f, 0.13277432f, -0.07726014f, 0.05215680f, 0.01723235f, -0.11047085f, -0.07589285f, 
    0.20879836f, -0.08520890f, -0.33587769f, 0.19711627f, 0.05540240f, -0.10849224f, -0.17466387f, 0.01585693f, 
    -0.01746873f, 0.03699508f, -0.23653653f, -0.14201277f, -0.15164077f, -0.13580330f, 0.08275784f, 0.01530291f, 
    0.01062393f, 0.02732771f, 0.02643934f, -1.04990661f, -0.32469785f, 0.32446754f, -0.30669314f, -0.01020086f, 
    -0.00199027f, -0.06380492f, -0.06067608f, -0.21151866f, 0.00624201f, 0.03163609f, 0.11967311f, 0.11074018f, 
    0.08603996f, -0.06654885f, 0.08121458f, 0.23555000f, 0.07659309f, 0.21701388f, 0.22372882f, 0.26926416f, 
    -0.07369675f, 0.00992047f, -0.13046890f, 0.01811687f, 0.09968147f, -0.03622676f, 0.13344361f, 0.12382794f, 
    0.09804343f, 0.05702825f, -0.02160870f, -0.01444495f, 0.07437240f, 0.26446441f, 0.12146638f, -0.34150711f, 
    -0.29795289f, 0.15360720f, 0.05777131f, 0.03401190f, -0.06390882f, 0.18581654f, 0.11434020f, -0.01223232f, 
    -0.01082775f, -0.28913045f, 0.09395312f, -0.06778091f, -0.07352720f, -0.27965614f, -0.12803172f, -0.23450819f, 
    -0.24954848f, -0.18254206f, -0.33490741f, -0.14398761f, -0.00209426f, -0.04305575f, -0.03985526f, 0.20725276f, 
    -0.07277025f, -0.04346380f, -0.18509313f, -0.30305374f, 0.09566922f, 0.01476386f, -0.05944404f, -0.08042426f, 
    0.13707271f, 0.13078699f, -0.03883811f, 0.17430428f, 0.25068361f, 0.29864773f, -0.07710060f, -0.11574106f, 
    -0.06248151f, 0.06325513f, 0.09797666f, 0.14608207f, 0.02313978f, 0.05171612f, 0.06740255f, -0.01159435f, 
    -0.11368427f, -0.04894844f, -0.03342452f, 0.03063707f, 0.04327228f, -0.02862374f, -0.22112194f, -0.17210698f, 
    -0.01174801f, 0.03885443f, -0.08345233f, -0.03768643f, -0.05726416f, 0.18933159f, 0.07494846f, 0.06643555f, 
    -0.32612538f, -0.15242554f, -0.09112819f, -0.18986666f, 0.11737413f, -0.04153582f, -0.08840008f, 0.03915483f, 
    0.03503178f, -0.12169477f, 0.14373538f, 0.16004843f, 0.16832848f, 0.03738072f, 0.09005549f, -0.00040087f, 
    0.03888363f, -0.11139870f, 0.02353840f, 0.05842131f, -0.29027796f, 0.01363068f, 0.05511696f, -0.04859297f, 
    -0.15157548f, 0.12487099f, -0.13838553f, -0.20743786f, -0.05181120f, 0.00772638f, 0.03891902f, 0.02061091f, 
    0.02818437f, -0.00854840f, 0.13894984f, 0.26576522f, -0.06801288f, -0.04919228f, -0.13739985f, -0.18851243f, 
    -0.02286859f, 0.01788515f, -0.00190660f, 0.14150888f, -0.14436141f, -0.14239551f, -0.12499265f, 0.00526367f, 
    -0.12177169f, 0.05644250f, -0.03173482f, -0.02001379f, -0.01509784f, 0.29728007f, -0.06457728f, -0.18128981f, 
    -0.30413467f, -0.05544671f, -0.00400945f, 0.02039658f, -0.07075514f, -0.16722529f, -0.40495381f, -0.26910728f, 
    -0.09917540f, 0.11507189f, -0.00190710f, -0.13453232f, -0.05052796f, -0.03436690f, -0.23650526f, -0.27161959f, 
    -0.11268849f, -0.09956045f, 0.12745413f, -0.00764880f, 0.08831300f, -0.04061910f, -0.06302641f, 0.17435409f, 
    0.04180967f, 0.13674939f, 0.13384187f, 0.03707331f, -0.14910798f, 0.09333974f, 0.07651436f, 0.11183535f, 
    0.04806722f, 0.02524070f, -0.02761791f, 0.03499708f, -0.02199378f, -0.04054651f, -0.03977397f, 0.04444939f, 
    -0.05403112f, 0.02368399f, -0.01820977f, -0.06464559f, -0.04355199f, -0.01343254f, 0.01868236f, -0.04064757f, 
    0.02619677f, -0.02976793f, -0.06467941f, -0.06363187f, -0.01572268f, 0.02819452f, 0.04983145f, 0.00554786f, 
    0.02860659f, 0.00383075f, -0.04584384f, 0.03671008f, 0.01910041f, 0.01985208f, 0.02450308f, -0.02968300f, 
    0.02362521f, 0.00456385f, 0.01988674f, -0.01809011f, 0.00091648f, 0.02183915f, 0.05226722f, -0.01010148f, 
    -0.02007664f, -0.01071731f, -0.05531925f, 0.01705580f, -0.03710555f, -0.01136464f, -0.02956538f, -0.03727719f, 
    0.00520953f, -0.04141905f, 0.02241971f, 0.01949803f, 0.01327762f, -0.01910674f, 0.04028982f, 0.01782126f, 
    -0.01910000f, -0.03957538f, -0.03840016f, 0.01803312f, -0.01589862f, -0.03231492f, 0.03055648f, -0.06400639f, 
    0.05091613f, -0.05040278f, 0.00614389f, 0.00686608f, 0.04163847f, 0.04423206f, 0.02850603f, 0.01356647f, 
    -0.00691414f, 0.02190659f, -0.04438511f, 0.04875760f, -0.03401865f, -0.03267105f, -0.00822595f, -0.02619201f, 
    -0.00516163f, -0.02112391f, 0.04520481f, 0.03503306f, 0.03348063f, -0.03020130f, -0.00529920f, 0.04530283f, 
    -0.01225365f, -0.02333956f, -0.03730468f, -0.02089634f, -0.05571034f, -0.03184804f, 0.02996032f, 0.00563757f, 
    -0.03864370f, -0.04853632f, -0.00921172f, 0.01006798f, -0.03424525f, 0.01262469f, 0.02869171f, -0.06149327f, 
    0.01021267f, 0.01685168f, -0.05348922f, 0.03844918f, -0.05519895f, 0.02947003f, -0.00620893f, 0.01374901f, 
    -0.04647396f, -0.03655583f, 0.01429757f, -0.00555543f, 0.02751609f, 0.01587448f, 0.04149732f, 0.04338969f, 
    -0.03324056f, 0.04846632f, -0.03884770f, -0.00418634f, 0.00061016f, -0.01516503f, -0.06617963f, -0.04333174f, 
    0.03858135f, -0.02609420f, -0.02864005f, -0.04688156f, 0.01717678f, 0.04305409f, -0.00174456f, 0.02901632f, 
    -0.00969363f, 0.00132997f, 0.00035602f, -0.01510855f, -0.02833402f, -0.01952413f, 0.02191958f, -0.04460197f, 
    0.00586617f, 0.03546918f, -0.01171401f, -0.03836186f, 0.06119653f, -0.03953329f, 0.03388780f, 0.04782541f, 
    -0.04598086f, -0.01004553f, 0.01130507f, -0.05831882f, 0.00234691f, 0.04661935f, -0.01059584f, 0.00447143f, 
    -0.06536829f, 0.05180190f, 0.02504853f, 0.03578513f, 0.02570430f, 0.00761536f, 0.01608271f, 0.02711636f, 
    0.02122997f, 0.01247498f, -0.04392320f, -0.04660668f, -0.00315698f, 0.00546201f, 0.00720720f, -0.03242445f, 
    -0.03948314f, -0.04947497f, -0.05228943f, 0.03020917f, -0.04569215f, -0.06534738f, -0.06135751f, -0.02522289f, 
    -0.03512644f, -0.03231002f, -0.06447063f, 0.01882003f, 0.01466816f, -0.00504394f, -0.01210200f, -0.02607253f, 
    0.00061882f, 0.00261416f, 0.04230398f, -0.03934547f, -0.05327185f, 0.00995610f, 0.00018573f, -0.01723052f, 
    -0.03311658f, -0.05082139f, 0.03358152f, -0.05010362f, -0.05387218f, 0.03171578f, 0.01609093f, 0.03033949f, 
    -0.00404086f, 0.04802387f, 0.02612970f, -0.04544728f, -0.00545516f, -0.04183575f, -0.05100422f, 0.00566298f, 
    -0.00063489f, 0.05136447f, 0.01412276f, 0.03594990f, -0.04106765f, -0.03140087f, -0.02875670f, -0.00069327f, 
    0.00690641f, -0.01775653f, 0.04545816f, -0.05671491f, 0.00246809f, -0.03389507f, -0.00644155f, -0.04080187f, 
    0.00799811f, -0.00260722f, -0.04667723f, -0.03039114f, -0.04288417f, -0.03573249f, 0.03846907f, 0.00975021f, 
    -0.04114849f, -0.05911733f, 0.01642089f, -0.04017013f, -0.02099022f, 0.02864536f, -0.00205084f, -0.01854852f, 
    0.00886676f, -0.02973399f, -0.03199749f, 0.03851953f, -0.00481549f, 0.04460654f, 0.02033442f, 0.04208562f, 
    -0.02821967f, -0.03473959f, -0.03104506f, -0.01819497f, -0.02453062f, -0.00076405f, 0.00429901f, -0.00128123f, 
    0.03671959f, -0.04529282f, -0.03849296f, -0.03427778f, -0.03674253f, -0.02417248f, 0.02140015f, -0.01949447f, 
    0.00872392f, 0.00238298f, -0.05538693f, -0.03942113f, -0.00321995f, -0.05360467f, -0.05874728f, -0.05575953f, 
    0.04717930f, -0.06583796f, 0.02553138f, 0.04974269f, -0.03910989f, -0.03493126f, -0.00233292f, 0.03234324f, 
    0.07541692f, 0.08734092f, 0.35988116f, 0.18818656f, 0.11594490f, 0.10176412f, 0.07559195f, -0.04752383f, 
    0.07078999f, -0.04875976f, 0.02003741f, 0.09994794f, 0.17131367f, -0.09059534f, -0.06615339f, -0.13202606f, 
    -0.17507286f, -0.13686796f, 0.11647648f, 0.00440695f, -0.04759264f, 0.04757441f, -0.18048897f, 0.12977035f, 
    0.08000239f, 0.01481808f, -0.03739212f, 0.00347961f, 0.18976969f, -0.08977128f, 0.14034849f, -0.10216961f, 
    0.20326650f, 0.05165588f, 0.04238126f, -0.19696704f, 0.17041709f, 0.08270916f, 0.06582866f, -0.11830515f, 
    -0.15401402f, -0.21361084f, -0.00420581f, 0.13348198f, 0.08622567f, 0.04686083f, -0.13285801f, 0.12852845f, 
    0.00905894f, 0.08862362f, -0.25476226f, 0.02114155f, 0.04702362f, 0.09594289f, -0.01043598f, -0.03380450f, 
    0.03832946f, 0.07093060f, 0.16609363f, 0.00274338f, -0.03781025f, 0.06147719f, 0.10238857f, -0.00308756f, 
    -0.00058845f, 0.01411115f, 0.20376204f, 0.06511719f, -0.11076540f, -0.20312461f, -0.11539066f, -0.27666953f, 
    0.17489114f, -0.07505818f, 0.07941575f, -0.13632840f, -0.10779145f, -0.16593014f, -0.10378691f, -0.25303823f, 
    -0.15603472f, 0.15305308f, -0.00776538f, 0.09571779f, 0.00614522f, 0.19213413f, 0.09593315f, -0.02147829f, 
    0.09763031f, -0.10783353f, 0.12042019f, -0.02808307f, -0.09312995f, 0.07489727f, 0.07132402f, -0.08072583f, 
    0.00849217f, 0.00735796f, 0.03374714f, 0.29961470f, 0.29585764f, -0.01134817f, -0.10239527f, 0.09120194f, 
    0.11546761f, 0.05236866f, 0.06450970f, -0.12706040f, 0.00167028f, 0.15495718f, 0.13408348f, 0.08104201f, 
    0.05045654f, -0.12793732f, -0.10500756f, -0.23122239f, -0.00979446f, -0.11583168f, 0.19537564f, -0.06814457f, 
    0.01705591f, -0.02358492f, 0.01356619f, -0.02973666f, -0.12113705f, -0.11513180f, 0.05340935f, 0.03218726f, 
    0.12226717f, -0.03873524f, -0.03252845f, -0.09515704f, -0.02096291f, -0.05040441f, -0.22025454f, 0.00418044f, 
    -0.01127247f, 0.04414390f, -0.09350725f, -0.05736063f, -0.04692649f, 0.01228363f, 0.09991974f, 0.01479861f, 
    0.21312812f, 0.12386070f, 0.18498141f, 0.10370253f, 0.11347889f, -0.07489421f, 0.08218214f, 0.10086813f, 
    0.00012088f, 0.18145008f, 0.01938848f, 0.01962205f, 0.10844812f, -0.14242314f, -0.07719440f, 0.11369541f, 
    0.13094996f, 0.18672957f, -0.02036009f, -0.05406505f, -0.02549837f, 0.03071729f, 0.09969960f, 0.00475714f, 
    -0.02011855f, 0.03598241f, 0.10048877f, -0.01220406f, 0.02514254f, 0.15162078f, -0.01768643f, -0.02151320f, 
    -0.08861288f, -0.12554112f, 0.19231699f, 0.07591384f, 0.08826845f, 0.01559958f, 0.10571030f, 0.04955292f, 
    -0.12401060f, -0.08903414f, 0.00897915f, -0.01891926f, -0.12554099f, 0.10793827f, 0.07508027f, -0.00857196f, 
    -0.02039578f, -0.09798034f, 0.07338463f, -0.10982982f, -0.21758720f, -0.26494700f, 0.21370475f, 0.05578480f, 
    0.11297805f, -0.00839154f, 0.06784146f, 0.03555902f, 0.00821381f, -0.06992229f, 0.03497276f, -0.22917736f, 
    -0.07560195f, 0.06723462f, -0.03499274f, 0.05298681f, -0.11892696f, -0.00999460f, 0.02267176f, 0.08846704f, 
    0.13714258f, 0.11680177f, 0.22760403f, -0.05118755f, -0.16405527f, -0.09100143f, 0.06640466f, 0.16138187f, 
    0.08706784f, 0.17888741f, -0.00943885f, -0.15538025f, -0.05626645f, -0.04758858f, -0.00987914f, -0.03502961f, 
    -0.03053095f, 0.07763221f, -0.18465775f, -0.12617247f, 0.14520000f, 0.06885704f, 0.00157242f, -0.02035146f, 
    0.20056124f, -0.09531002f, -0.07055183f, 0.07707695f, 0.02523581f, 0.12397031f, 0.13593540f, -0.04591266f, 
    -0.27520481f, 0.02325992f, 0.20807093f, 0.07433328f, 0.17770438f, -0.00348451f, 0.17875935f, 0.01981717f, 
    0.00608738f, -0.04843414f, 0.04680670f, 0.05429566f, 0.00561418f, 0.33578333f, -0.12965329f, -0.40235433f, 
    -0.11299556f, -0.14696637f, -0.06737455f, 0.02042316f, -0.12337259f, -0.03054602f, 0.20158052f, 0.16460775f, 
    -0.08751222f, 0.09029267f, -0.10062508f, 0.03020800f, 0.11795925f, 0.09625985f, -0.05493261f, -0.10482599f, 
    -0.11109962f, -0.00073051f, 0.06245288f, 0.03204937f, 0.04643573f, -0.12550604f, -0.24934046f, -0.20613083f, 
    -0.02995001f, 0.03007888f, 0.02532447f, -0.03689015f, 0.02634189f, 0.01204245f, -0.00220620f, -0.03079438f, 
    0.01589019f, 0.00530675f, -0.03453661f, -0.00905382f, 0.00267861f, -0.01748809f, -0.05775050f, -0.02961894f, 
    -0.05370646f, -0.00503044f, -0.00570380f, -0.00708905f, 0.00348825f, -0.05303536f, 0.01695337f, -0.00651282f, 
    -0.03890116f, -0.03668347f, 0.03297737f, -0.00593776f, -0.02753996f, -0.06258008f, -0.00367305f, -0.02582276f, 
    0.04476608f, 0.04880296f, -0.04578004f, 0.05131977f, -0.02256740f, 0.03251095f, 0.02689295f, 0.03940338f, 
    0.04149999f, 0.01547900f, 0.02043466f, 0.01161178f, 0.02088122f, 0.02335622f, -0.01089423f, 0.02043678f, 
    -0.00168056f, -0.04713941f, -0.03625239f, -0.04340905f, 0.04452704f, -0.02096655f, 0.00786038f, 0.00835501f, 
    -0.01659743f, 0.00753148f, -0.00530646f, -0.00671123f, 0.01969944f, -0.05763330f, 0.01104327f, -0.03384804f, 
    0.01543368f, 0.01561558f, -0.03196030f, -0.04969953f, -0.04437980f, 0.02031332f, -0.02049131f, 0.01237923f, 
    -0.01522024f, 0.04928790f, -0.03832301f, -0.04360181f, 0.00976102f, -0.05013229f, 0.04884538f, -0.05407753f, 
    -0.05559196f, -0.06510834f, 0.03464361f, 0.00466309f, 0.01977625f, -0.01905539f, 0.02230479f, 0.04526711f, 
    0.04220336f, -0.02380400f, 0.02583585f, 0.02972212f, -0.02732372f, -0.03482736f, -0.06081933f, -0.01629794f, 
    0.02834246f, 0.01788629f, 0.05548331f, -0.02899563f, 0.01271404f, 0.02194076f, -0.03000644f, -0.04063508f, 
    -0.00481303f, 0.04381163f, -0.03309756f, -0.06240049f, 0.01209740f, -0.05587051f, -0.02800463f, 0.01073783f, 
    0.02886744f, 0.03148494f, -0.05836116f, -0.04239437f, 0.04486455f, 0.00021815f, -0.04819871f, 0.01821316f, 
    0.02864114f, -0.04703683f, -0.05527653f, -0.05785644f, 0.02256665f, -0.02477304f, 0.03462098f, 0.00159063f, 
    0.05670958f, 0.04897606f, -0.05467040f, -0.02981171f, -0.02889760f, -0.05550405f, -0.05983360f, -0.00173410f, 
    0.02297670f, 0.03438945f, -0.03718814f, -0.04620399f, -0.02520185f, -0.04042734f, -0.04482230f, -0.01522782f, 
    0.05137669f, 0.05067722f, 0.01744898f, -0.02213148f, 0.00691973f, 0.02279082f, -0.00857105f, -0.00826833f, 
    -0.03354859f, -0.02300036f, -0.05879454f, 0.00071316f, -0.00115132f, -0.00911719f, 0.02561210f, -0.01259258f, 
    -0.01048938f, -0.06091695f, 0.02838558f, -0.02691841f, -0.05171289f, -0.03180976f, -0.02868314f, 0.03493903f, 
    0.00147851f, -0.00886345f, 0.03387161f, 0.05172639f, -0.00985855f, 0.01059186f, -0.04936481f, -0.03652844f, 
    0.05170930f, -0.03046129f, -0.05644142f, 0.03534620f, -0.00414768f, 0.03128303f, 0.01085611f, -0.02596089f, 
    -0.01543146f, -0.02692479f, 0.03864161f, -0.00247358f, -0.00583980f, 0.04135792f, 0.00987803f, 0.02463256f, 
    0.03671758f, 0.04028806f, 0.00620425f, -0.00186185f, -0.03148259f, 0.02013125f, 0.05667974f, -0.03846548f, 
    -0.01966503f, -0.05958153f, 0.04818115f, 0.04089120f, -0.00788981f, -0.01590410f, 0.03131624f, 0.03030598f, 
    0.00041076f, -0.02147027f, 0.01898463f, -0.06173724f, -0.01412824f, 0.00037909f, -0.05010806f, 0.02079990f, 
    -0.04248474f, -0.01152782f, -0.04218791f, -0.00275233f, -0.03235463f, -0.05002422f, -0.04971885f, 0.04708641f, 
    0.04636585f, -0.00022788f, -0.00141566f, -0.02479744f, 0.01194621f, -0.02183567f, 0.03322423f, -0.04557097f, 
    0.04345141f, 0.04343665f, 0.00842337f, 0.04705455f, 0.04400814f, -0.02367311f, -0.05548871f, 0.01275050f, 
    -0.00542810f, -0.00024432f, -0.04531826f, 0.05459417f, -0.05115232f, 0.04877439f, 0.03728923f, 0.03824518f, 
    0.03454978f, -0.03242570f, -0.03646078f, -0.04653079f, 0.01851234f, -0.01349104f, -0.00221324f, -0.00798366f, 
    0.04813214f, 0.05734688f, -0.05606217f, 0.01861460f, -0.05435645f, 0.01206370f, 0.04942130f, -0.03734176f, 
    -0.02538360f, 0.05167489f, -0.05686569f, -0.05674233f, 0.02703465f, -0.05945370f, -0.00200234f, -0.06005767f, 
    -0.01342666f, 0.05421945f, -0.03143775f, -0.02808004f, -0.02623131f, -0.03823434f, -0.02824294f, -0.03472724f, 
    -0.04896888f, -0.01934829f, -0.00154052f, -0.05636662f, -0.01743259f, 0.02202617f, 0.04204616f, -0.03507642f, 
    0.14295118f, 0.00557002f, -0.06329264f, -0.02682400f, 0.04299889f, -0.20571394f, 0.07845975f, 0.11299165f, 
    -0.12986012f, -0.02319817f, 0.09193707f, -0.22336459f, 0.04692711f, 0.19181474f, 0.06065559f, 0.08655900f, 
    -0.01299861f, -0.20117581f, 0.24544154f, 0.03299480f, -0.04209023f, 0.07398774f, -0.15031286f, -0.03779535f, 
    0.04432606f, 0.00605074f, 0.02405627f, 0.18768564f, 0.10635394f, 0.02376793f, 0.09974062f, 0.02772014f, 
    0.13840152f, -0.06487912f, 0.08195447f, -0.04366997f, -0.01104513f, -0.11324263f, -0.04550906f, 0.04944114f, 
    0.01093557f, 0.03392582f, -0.19292584f, -0.09797139f, -0.27181047f, -0.18862720f, 0.03654851f, -0.05720676f, 
    -0.00262579f, 0.04888684f, -0.13472807f, 0.05765615f, -0.02385398f, -0.20535450f, -0.00842844f, 0.13927731f, 
    -0.02928234f, 0.09648152f, -0.13582096f, -0.03993110f, 0.13531373f, 0.09477372f, 0.08583962f, -0.12345995f, 
    0.02112500f, -0.19412071f, 0.07302606f, 0.11873119f, 0.06276377f, 0.01873591f, 0.10613254f, -0.00721399f, 
    -0.02553016f, -0.08641190f, 0.06267037f, 0.06291017f, 0.01097565f, 0.20429933f, 0.12379691f, 0.19463511f, 
    0.19222076f, 0.02250146f, 0.10321905f, 0.08921315f, 0.26756540f, 0.07155119f, 0.28026137f, -0.15791686f, 
    -0.04602792f, -0.08791576f, 0.11199392f, -0.19286251f, 0.09014468f, 0.16044071f, 0.10113800f, 0.17080361f, 
    -0.21334179f, -0.23504451f, -0.26426554f, -0.16497588f, 0.06647810f, 0.19105759f, 0.09084447f, 0.12782539f, 
    0.20693786f, 0.00376525f, 0.13334888f, 0.22752710f, 0.03764652f, 0.14792846f, 0.05006256f, -0.02588148f, 
    0.14893238f, 0.03661112f, -0.04272749f, 0.02124151f, -0.02446256f, 0.16817464f, 0.07662537f, 0.17529289f, 
    0.10573511f, -0.09445356f, 0.00372450f, 0.11897131f, 0.03935053f, 0.14221393f, 0.15660623f, 0.07532047f, 
    -0.04014814f, -0.14700602f, 0.26289761f, -0.01842941f, -0.03903335f, -0.03068046f, 0.05788173f, 0.00415875f, 
    0.09595855f, 0.02964074f, 0.16631767f, 0.03521268f, -0.06019492f, -0.01994880f, -0.22859347f, -0.11208940f, 
    0.00922018f, 0.18714805f, -0.00835897f, 0.07061375f, 0.03718418f, -0.07126241f, 0.04858761f, -0.28027749f, 
    0.20963556f, -0.07614567f, -0.13691235f, -0.09796223f, 0.07035945f, -0.08787092f, -0.04405187f, -0.09573765f, 
    -0.12429710f, -0.29061639f, -0.06793895f, 0.03776051f, 0.04605908f, 0.13939606f, 0.00724843f, -0.07299756f, 
    -0.09616298f, 0.06695134f, -0.30786663f, 0.21441877f, 0.22304446f, -0.09432230f, 0.13338472f, 0.06646101f, 
    -0.01772591f, 0.09578649f, 0.01405073f, 0.03812475f, 0.05975924f, 0.05454931f, -0.05854798f, -0.11524286f, 
    0.03765020f, -0.04277751f, 0.01486526f, 0.06129355f, -0.15227784f, -0.02058510f, -0.14283611f, -0.18189937f, 
    -0.02255080f, 0.08739843f, 0.13431744f, -0.03437495f, 0.08910076f, -0.08327549f, 0.13063084f, -0.22215876f, 
    -0.05496379f, 0.13791274f, 0.01154942f, 0.10261125f, 0.02968560f, -0.00879549f, -0.02123323f, -0.20069164f, 
    0.03532388f, 0.13172211f, 0.04193149f, 0.08567607f, -0.19937265f, -0.03427410f, 0.03306950f, -0.13541590f, 
    -0.06576755f, -0.08972984f, -0.10880270f, -0.07768861f, -0.02200663f, -0.00493987f, -0.17987722f, -0.01363227f, 
    0.05810840f, -0.03750328f, -0.01934109f, 0.03488402f, -0.10385092f, -0.02778705f, 0.07724164f, -0.04376887f, 
    0.02192451f, 0.27802593f, 0.11266185f, 0.13698475f, 0.07236706f, 0.01058734f, -0.23622386f, -0.09762801f, 
    0.06403733f, 0.07615177f, -0.02305278f, 0.02589806f, 0.07228123f, -0.01426412f, -0.01538234f, -0.08956143f, 
    0.10795434f, -0.06902999f, -0.03758594f, -0.11115661f, 0.20931126f, -0.22433344f, 0.05014149f, 0.12458394f, 
    -0.01145953f, 0.11946885f, -0.02467332f, 0.05552694f, 0.09951517f, 0.08298171f, -0.34186935f, 0.08007098f, 
    0.17854166f, 0.13581671f, 0.16925296f, -0.07121132f, 0.04766888f, 0.15570930f, 0.08264390f, -0.01787408f, 
    -0.19438861f, 0.20331249f, 0.01022762f, 0.18247649f, 0.05875259f, 0.05987049f, -0.21044974f, 0.09733372f, 
    0.29902792f, 0.02146322f, 0.07060790f, 0.04557134f, 0.05209892f, 0.15019450f, 0.00604246f, -0.01373560f, 
    -0.04154531f, 0.06613353f, -0.38469481f, 0.01020047f, 0.03337741f, 0.09287718f, 0.04826684f, 0.12829331f, 
    0.15882492f, -0.01728087f, 0.05510459f, 0.06467061f, -0.11567951f, 0.01179886f, -0.10559389f, -0.05948252f, 
    -0.00607752f, -0.00994849f, 0.43476614f, -0.19780023f, -0.33475623f, -0.06883892f, 0.10784798f, 0.04538405f, 
    0.04439937f, 0.18161741f, 0.03108598f, -0.07156651f, -0.12835179f, -0.07857554f, -0.02824609f, -0.25139648f, 
    -0.11668275f, 0.06571356f, 0.23171553f, 0.15225893f, 0.02892748f, 0.06720223f, -0.15216713f, -0.15244231f, 
    -0.17685160f, 0.05132261f, -0.06611885f, -0.03133009f, 0.01747198f, -0.04143971f, 0.05667285f, -0.18826704f, 
    0.07957243f, 0.09525737f, 0.10289043f, -0.00115974f, -0.06673999f, 0.15453576f, 0.22903077f, -0.05338378f, 
    0.11188951f, -0.04236826f, -0.04991376f, 0.06491877f, 0.10697176f, 0.02083214f, 0.17123489f, -0.01367525f, 
    -0.02972563f, -0.06223445f, 0.05020390f, -0.06567727f, -0.06995514f, 0.02103856f, -0.16134958f, -0.11236715f, 
    0.11360329f, -0.50963312f, -0.14612286f, 0.03045366f, -0.04638434f, 0.06134700f, -0.01579896f, 0.18291488f, 
    0.12431098f, -0.17027506f, -0.02876042f, -0.30821320f, 0.07449457f, -0.02956090f, -0.11412325f, 0.14619637f, 
    -0.07359882f, 0.14170642f, 0.07759137f, 0.06722298f, -0.16993223f, -0.06562789f, 0.03421725f, -0.01331224f, 
    0.09136102f, 0.03988008f, 0.09155606f, 0.18606341f, -1.10516953f, 0.08062608f, -0.43646857f, 0.20272197f, 
    0.03176676f, 0.15904243f, -0.00217676f, 0.05221942f, 0.05275751f, 0.00630035f, 0.17185755f, -0.12948263f, 
    0.05904776f, -0.00147355f, 0.05886491f, -0.06884872f, 0.04889468f, -0.01451963f, -0.54634005f, 0.57746524f, 
    -0.09897153f, -0.04089927f, -0.10660369f, 0.09158096f, 0.00062972f, 0.09427585f, 0.16772346f, -0.04306528f, 
    0.13749154f, -0.01772484f, 0.01666967f, -0.10923728f, 0.07099327f, 0.00308486f, -0.05390318f, -0.02535748f, 
    -0.40475842f, -0.12996341f, -0.02075283f, -0.03459797f, -0.01177301f, 0.02229724f, -0.01830778f, 0.08472611f, 
    -0.00297891f, 0.01623865f, 0.02166014f, -0.09935035f, 0.05629874f, 0.06476962f, -0.03577162f, 0.14240272f, 
    0.17085715f, 0.19991314f, -0.08734365f, -0.09593610f, -0.00590885f, 0.08070634f, 0.02832681f, -0.00493106f, 
    0.02863148f, -0.05937901f, -0.22943848f, -0.29648915f, 0.49912259f, -0.19480915f, 0.16739593f, 0.11504093f, 
    0.02949386f, -0.09662938f, -0.11164720f, -0.47219303f, 0.15480278f, -0.05547866f, 0.07192823f, 0.09606227f, 
    0.03066256f, 0.07030693f, -0.03720643f, 0.12103611f, 0.00621471f, -0.02452434f, 0.11077178f, -0.02215596f, 
    0.03577020f, -0.02680600f, 0.04416846f, 0.01794297f, 0.06764630f, 0.07812828f, 0.02270121f, -0.10773874f, 
    -0.13938883f, -0.09493397f, -0.20833795f, -0.00823249f, 0.03008128f, 0.05757451f, -0.08436144f, -0.57106221f, 
    -0.41739228f, -0.10507318f, -0.01879194f, -0.12343764f, -0.16463755f, -0.03876819f, 0.14129251f, -0.31827375f, 
    -0.02405080f, 0.02760587f, 0.02159537f, -0.11490037f, 0.03123053f, 0.04073462f, 0.05524466f, 0.11447828f, 
    0.08742193f, 0.10219453f, 0.02717311f, -0.03345429f, -0.04566072f, 0.03118922f, 0.05622417f, 0.07498381f, 
    0.01988911f, 0.54325366f, -0.28892684f, -0.30196989f, -0.04685336f, -0.18203762f, -0.05691011f, 0.01168771f, 
    0.03552856f, -0.02731821f, -0.13178760f, 0.08851209f, 0.02389153f, 0.02341677f, 0.07074601f, 0.06876659f, 
    0.02251951f, -0.00338618f, 0.04586003f, 0.09365401f, -0.05149985f, 0.07664397f, -0.10474765f, -0.18832263f, 
    -0.18276633f, 0.29939494f, 0.02571745f, 0.00473512f, 0.58385956f, -0.72430080f, -0.46032694f, -0.05649668f, 
    -0.16247183f, -0.10186938f, 0.05167070f, 0.00096128f, -0.04264466f, 0.30208963f, -0.52165151f, -0.34222811f, 
    0.03435366f, -0.04389528f, 0.13079475f, 0.00058957f, -0.08312969f, -0.05216493f, 0.59048098f, -0.53413713f, 
    -0.20915432f, 0.10632396f, 0.07369793f, 0.02877980f, 0.05603768f, -0.02580153f, -0.04903170f, 0.02853724f, 
    0.05963616f, 0.06078724f, -0.02285424f, 0.05215288f, -0.03053130f, -0.05041860f, -0.14481831f, -0.03752123f, 
    0.03725044f, -0.05260911f, -0.13433141f, -0.08479626f, 0.08790851f, -0.04915858f, 0.15321943f, 0.19150206f, 
    -0.06305733f, -0.10303923f, -0.08060566f, -0.02309435f, -0.08803535f, 0.10546020f, 0.06883716f, 0.04426385f, 
    0.12588210f, -0.10840753f, 0.23423417f, 0.20177020f, -0.16458410f, 0.14173600f, 0.17621285f, 0.07731719f, 
    0.02041175f, 0.06992477f, -0.01443112f, 0.28573695f, -0.01758897f, -0.31431335f, 0.09909317f, -0.03473649f, 
    0.02082400f, -0.02811525f, -0.06984574f, -0.04856351f, -0.18662260f, -0.12748878f, -0.10091867f, 0.00849758f, 
    -0.02699327f, -0.08967506f, 0.11418241f, -0.07873127f, 0.08084086f, -0.28097168f, 0.15287569f, -0.07157600f, 
    0.09126681f, -0.10668225f, 0.07123455f, 0.10425269f, 0.05624856f, 0.16043647f, -0.18496634f, -0.13647684f, 
    -0.46012497f, 0.03544239f, -0.06407958f, 0.12273220f, 0.11075632f, 0.16903116f, 0.02998183f, 0.12765133f, 
    0.05920964f, 0.14621001f, 0.00440365f, -0.00645239f, 0.03280210f, 0.12250935f, 0.02355407f, -0.06016078f, 
    0.18108736f, 0.02838176f, 0.13795641f, 0.14204936f, -0.02335736f, -0.03511920f, 0.07607121f, -0.03880418f, 
    -0.14683911f, 0.19609891f, -0.20159885f, -0.22104031f, -0.23039857f, -0.32238308f, 0.04861708f, 0.03605396f, 
    -0.13151459f, 0.02616395f, -0.12595108f, -0.22191153f, -0.01549429f, 0.01288433f, 0.10861704f, 0.00243034f, 
    0.00856979f, -0.10323408f, 0.13969208f, 0.48122627f, -0.07277734f, -0.10558642f, 0.03423554f, -0.06751406f, 
    -0.07019801f, -0.03985864f, 0.36551771f, -0.02144808f, -0.21531588f, -0.23257476f, -0.19942720f, 0.03177059f, 
    0.06680363f, 0.11851376f, 0.08380229f, 0.18428960f, 0.04887231f, 0.30493644f, 0.08937737f, 0.05745744f, 
    -0.10964659f, -0.12020917f, 0.08240458f, -0.02287239f, -0.04802448f, 0.14845183f, -0.11451428f, 0.07570704f, 
    0.08180162f, 0.03856174f, 0.09863631f, -0.20404619f, 0.06510457f, -0.05578126f, -0.04181941f, 0.09661470f, 
    0.05575103f, 0.06256234f, -0.10810307f, -0.01394757f, 0.11343322f, -0.17289041f, 0.01201715f, 0.11123624f, 
    -0.23291878f, -0.01991420f, -0.20287439f, -0.02226750f, -0.10222136f, 0.05698543f, -0.05220475f, 0.06221899f, 
    0.26390472f, -0.05196718f, -0.11046679f, 0.03881529f, 0.10356856f, 0.08747281f, 0.15464637f, 0.03633926f, 
    0.08534582f, 0.06842533f, 0.07755856f, -0.03474085f, 0.13307822f, 0.01021469f, -0.03649336f, 0.00860079f, 
    0.07134115f, 0.10150954f, 0.13605535f, -0.24750641f, 0.09283010f, 0.20399292f, -0.09379138f, -0.06274186f, 
    -0.09996577f, -0.05608360f, 0.02843103f, 0.09596380f, -0.22637136f, -0.21780375f, -0.18590324f, -0.08739926f, 
    0.08778521f, 0.02980498f, 0.05945998f, 0.10863791f, 0.12315197f, -0.05889877f, 0.14827530f, 0.28241310f, 
    -0.07579167f, 0.10113765f, 0.00386018f, 0.07117269f, 0.12768713f, -0.25708771f, 0.26290771f, 0.08431559f, 
    -0.01362557f, 0.04457863f, -0.03756711f, -0.04986640f, -0.02255788f, -0.02942867f, -0.10647034f, 0.08306769f, 
    -0.09776697f, -0.06189159f, -0.06206519f, -0.06535828f, 0.21945007f, -0.01879476f, 0.07588618f, 0.07723745f, 
    -0.06908917f, 0.05533129f, -0.09237634f, 0.00298330f, -0.10581979f, -0.00716325f, -0.07302601f, -0.02549723f, 
    0.08303816f, 0.31933096f, 0.04020118f, -0.01870209f, 0.07455573f, -0.01878777f, -0.02261479f, 0.02343088f, 
    -0.12837766f, -0.07070701f, -0.31544349f, -0.15214063f, 0.08176769f, -0.36444572f, -0.13339929f, -0.09531317f, 
    0.13476539f, 0.03572769f, 0.13866590f, 0.19778195f, 0.00470216f, -0.33935541f, -0.06096590f, -0.05781449f, 
    -0.01307750f, 0.20221810f, 0.03153961f, -0.12618531f, 0.28752178f, 0.03494386f, 0.02108259f, 0.06705268f, 
    0.09531470f, 0.05776529f, -0.02601159f, 0.05160734f, -0.16738155f, 0.02831644f, 0.10301907f, 0.05834913f, 
    0.02174594f, 0.16622962f, 0.08963856f, 0.11230908f, 0.10606083f, -0.04492375f, 0.11836816f, 0.03143179f, 
    -0.02293595f, 0.06964722f, 0.15354195f, 0.06465322f, -0.06286868f, 0.30197719f, 0.00812061f, -0.39494562f, 
    -0.14246090f, 0.16587648f, -0.08083780f, -0.13573879f, 0.09825859f, 0.05225593f, -0.00412071f, 0.04855756f, 
    0.14325523f, -0.41227487f, -0.23275818f, 0.09443159f, 0.08755114f, 0.01390001f, 0.16538903f, 0.02461768f, 
    0.12188754f, -0.04187083f, -0.03324110f, -0.02306083f, -0.10441188f, 0.10153978f, 0.09799261f, 0.14013793f, 
    -0.05603078f, 0.00817576f, 0.34219292f, -0.06392390f, 0.26098835f, 0.16218357f, -0.19375812f, -0.03078507f, 
    0.03006447f, -0.04459874f, 0.17307159f, -0.21161555f, -0.49224824f, -0.18181325f, 0.21360114f, -0.01846218f, 
    0.05779111f, -0.16953920f, 0.00802649f, -0.17897344f, -0.21067621f, -0.18415114f, -0.18820748f, 0.12384930f, 
    -0.04216763f, 0.04613423f, -0.00014336f, 0.08047917f, 0.07119752f, 0.02321119f, -0.05256830f, 0.03375947f, 
    0.00970971f, -0.07264040f, 0.17680977f, 0.05156280f, 0.21636048f, 0.19405328f, 0.03285008f, -0.06894513f, 
    -0.18280010f, -0.01854513f, -0.02606435f, -0.05187183f, 0.10109040f, 0.06578395f, 0.08298131f, -0.01454000f, 
    -0.07542320f, -0.19630255f, -0.18257597f, -0.06595770f, 0.02494454f, -0.09557234f, -0.04608053f, -0.04437349f, 
    0.04372330f, -0.05592526f, 0.01178639f, -0.00216585f, -0.07957833f, 0.07672996f, -0.01752457f, 0.14939281f, 
    -0.05116400f, -0.23218018f, -0.47824520f, -0.24811032f, -0.05214361f, 0.09102038f, 0.02899549f, 0.05501288f, 
    0.04133207f, 0.01740205f, 0.00780430f, 0.02550632f, 0.02619416f, 0.15315807f, 0.13330974f, 0.04573104f, 
    0.02510738f, -0.02030724f, 0.04238630f, -0.22114232f, 0.09376103f, -0.46939945f, -0.08788307f, 0.03190117f, 
    -0.11916266f, 0.04460557f, 0.06618953f, -0.17977129f, 0.06020461f, 0.12326337f, -0.01973346f, 0.00266643f, 
    0.30820072f, 0.04309331f, 0.08144835f, 0.05430399f, 0.04889009f, 0.06403039f, -0.05361637f, 0.07965471f, 
    0.16457146f, 0.08747487f, 0.03142749f, 0.12635829f, -0.00023088f, 0.01599730f, 0.08239859f, -0.05173469f, 
    0.02515460f, 0.21725570f, 0.15887849f, -0.00899332f, 0.00516822f, 0.16461496f, -0.03694423f, 0.03526843f, 
    -0.02825830f, -0.02466176f, -0.04934399f, -0.01566503f, 0.18369678f, 0.07276665f, 0.14197475f, 0.10142589f, 
    -0.12860088f, -0.35403985f, -0.20950134f, -0.06475835f, -0.02676145f, -0.05118672f, 0.04251698f, 0.07451105f, 
    0.01690232f, -0.04081644f, -0.05897876f, 0.00210757f, 0.01677340f, -0.09785079f, -0.10554882f, 0.09677026f, 
    0.09605431f, 0.15194683f, -0.01863919f, -0.00806408f, -0.04731929f, -0.04422207f, 0.13608038f, -0.14001741f, 
    0.07789226f, 0.04618870f, 0.19053015f, -0.16101247f, 0.01644405f, 0.10559531f, 0.11271684f, 0.11939755f, 
    0.01904333f, 0.20573762f, 0.16095254f, 0.07229494f, -0.15090069f, -0.10956074f, -0.09033059f, -0.01924543f, 
    0.02380046f, 0.12226359f, -0.00159226f, 0.03219113f, 0.07531788f, -0.04553967f, -0.08801760f, -0.07041109f, 
    -0.14741929f, -0.15508807f, 0.05203857f, -0.08632413f, -0.15687813f, -0.21223739f, -0.22218469f, -0.29796663f, 
    -0.29126605f, -0.18875608f, -0.08551898f, -0.09701160f, 0.17614400f, -0.02588931f, -0.03505042f, 0.19873099f, 
    0.15432328f, 0.04765294f, 0.06880876f, -0.02067070f, 0.17065668f, 0.16763254f, 0.22982664f, 0.07337654f, 
    -0.18994482f, -0.07325357f, 0.03493695f, -0.01233564f, -0.03016962f, 0.00747330f, 0.07347795f, 0.10925110f, 
    0.25696370f, -0.11356432f, 0.09363698f, 0.23390988f, -0.04602151f, -0.08979750f, -0.01219581f, -0.28958288f, 
    0.03134005f, -0.08646894f, -0.41325486f, -0.27707979f, -0.19122700f, 0.05773884f, -0.11300911f, -0.03773165f, 
    0.04367774f, -0.05025350f, -0.15391082f, 0.09917197f, 0.04271957f, -0.12192141f, -0.03165735f, 0.00527439f, 
    -0.02871419f, 0.00473604f, -0.02603479f, 0.11205664f, -0.07220723f, -0.10457587f, -0.07753085f, -0.21153504f, 
    -0.04823820f, -0.06991133f, 0.02018411f, 0.05933620f, 0.05298281f, 0.09904887f, 0.29892477f, 0.26619694f, 
    -0.09862373f, -0.07431261f, -0.02694831f, -0.02522070f, -0.02995758f, 0.02624811f, -0.16729935f, -0.00664962f, 
    -0.06442957f, 0.03983492f, -0.13182582f, -0.07580461f, -0.04600798f, 0.16005398f, 0.16503285f, -0.10767242f, 
    -0.18848135f, 0.03174713f, -0.00041685f, 0.06336901f, 0.10967875f, -0.06387794f, -0.13895874f, 0.06506374f, 
    -0.08723493f, 0.38131279f, 0.10688200f, 0.18795708f, 0.11556495f, 0.19868419f, 0.11637286f, -0.02752905f, 
    0.11218177f, -0.08322892f, 0.06505556f, -0.01896163f, 0.07919719f, -0.00082566f, -0.02565929f, -0.04722068f, 
    -0.04569982f, -0.02144832f, 0.02372614f, -0.02156054f, 0.02064251f, -0.11230535f, 0.15170342f, 0.08573499f, 
    0.09378964f, -0.02578267f, 0.07950480f, -0.11920144f, 0.10504111f, 0.01930749f, -0.03292804f, 0.05983920f, 
    0.05162118f, -0.06652030f, 0.07213339f, 0.00897029f, -0.07541472f, 0.14981379f, -0.06203339f, 0.08454777f, 
    0.09186379f, 0.06655905f, -0.00754413f, 0.09215936f, 0.09086739f, 0.13137698f, 0.08501629f, 0.10501097f, 
    -0.03360762f, 0.16387996f, -0.17283726f, 0.02627870f, 0.13831651f, 0.15167432f, 0.01298757f, 0.22892776f, 
    0.26130158f, 0.02566589f, 0.08472314f, 0.01332143f, -0.05919368f, 0.01156068f, 0.24018914f, 0.09450166f, 
    0.12854224f, 0.14189602f, 0.02982558f, -0.18970251f, 0.07420747f, -0.15102617f, -0.16218452f, -0.13862933f, 
    0.11982469f, -0.02385177f, -0.01042307f, 0.07087041f, -0.16227017f, -0.14417364f, -0.17418884f, -0.19662631f, 
    -0.16335274f, 0.12633309f, -0.16878937f, -0.18921898f, 0.16437212f, 0.17984036f, 0.04139603f, 0.10144769f, 
    0.16234790f, 0.09575457f, -0.09429694f, -0.03334299f, -0.06828015f, 0.13639674f, 0.07151233f, 0.05547104f, 
    -0.04371072f, 0.07796339f, 0.02262813f, 0.09822709f, 0.14298393f, 0.12138294f, 0.12648344f, 0.02900403f, 
    0.13883641f, -0.23443829f, -0.21017781f, 0.04692850f, -0.01925443f, 0.05456115f, 0.00839036f, 0.01071168f, 
    -0.00560548f, 0.00928667f, -0.19103742f, 0.09747935f, -0.14264607f, 0.05419533f, -0.01320289f, -0.07007179f, 
    -0.12335136f, 0.05703898f, -0.00038057f, -0.02090367f, -0.18971559f, -0.01841925f, 0.10202562f, 0.01572926f, 
    0.07810387f, -0.09143582f, -0.11327463f, -0.02824611f, 0.00364354f, -0.07231550f, -0.14774080f, -0.03044328f, 
    0.07946381f, -0.13278650f, -0.06950488f, -0.14630611f, 0.08428957f, 0.03230270f, 0.29564404f, 0.13626827f, 
    -0.06156586f, 0.03481396f, 0.11378250f, -0.01435216f, 0.10641364f, 0.13046768f, 0.06921036f, 0.24063967f, 
    0.00579799f, -0.05696118f, 0.13004646f, -0.16264489f, 0.16814134f, 0.01082092f, -0.03229157f, 0.13995539f, 
    0.11526254f, -0.03301801f, -0.11840185f, -0.15264094f, -0.09864026f, -0.19396518f, -0.03351757f, 0.07605302f, 
    0.02274174f, 0.01072433f, 0.12471543f, 0.00630725f, 0.10444992f, -0.04498430f, 0.08277211f, 0.04273597f, 
    0.06262926f, -0.10026524f, 0.14925167f, 0.10398697f, -0.07585982f, 0.04517411f, 0.09447267f, 0.06338327f, 
    0.01622064f, -0.01785372f, -0.07308966f, -0.07905447f, -0.00247004f, 0.02945022f, -0.00337324f, -0.10603825f, 
    0.09014895f, 0.00774382f, 0.05350314f, -0.17181237f, -0.11531382f, -0.42288268f, -0.04838140f, 0.07253247f, 
    -0.06798649f, -0.19053325f, 0.01798697f, 0.01483700f, 0.09736811f, 0.07237537f, 0.05458306f, -0.01875579f, 
    0.02088680f, 0.22634999f, -0.08155907f, 0.18471307f, 0.09114004f, 0.10858721f, 0.12762207f, 0.05908483f, 
    -0.00414169f, 0.15071966f, 0.04694664f, 0.00893522f, 0.04560935f, -0.06706868f, 0.04446666f, 0.21512760f, 
    0.05987659f, -0.12214360f, -0.15030263f, 0.11411212f, 0.01897998f, -0.14471717f, -0.10414082f, -0.15118900f, 
    0.01355765f, -0.03524553f, -0.15355140f, 0.09498785f, 0.07145659f, 0.03701664f, 0.12363631f, 0.11979732f, 
    0.12566565f, -0.00812201f, -0.03179762f, -0.02165627f, 0.08687791f, 0.23814502f, 0.01511042f, 0.09659211f, 
    0.02103056f, -0.08739730f, 0.08077537f, 0.25001583f, -0.03528546f, -0.20167056f, -0.06636142f, -0.05176527f, 
    -0.09239335f, -0.00721490f, -0.04805975f, 0.03703300f, 0.19179285f, -0.19649863f, 0.06674396f, -0.04415563f, 
    0.11520032f, 0.11045286f, -0.04264408f, -0.09788276f, -0.17222062f, -0.17667022f, -0.09836400f, 0.08969180f, 
    0.07833626f, -0.05751148f, -0.16847926f, 0.06353924f, -0.02811919f, 0.09581106f, -0.04217203f, -0.07407349f, 
    0.00792458f, -0.01535433f, -0.05401618f, -0.09291857f, 0.03347792f, -0.02465565f, -0.03410390f, -0.19355454f, 
    -0.27476177f, -0.00492071f, 0.17684427f, -0.02996087f, -0.01017748f, -0.13490793f, -0.03999426f, -0.07874233f, 
    -0.24160855f, 0.05420663f, 0.10354492f, 0.11305117f, -0.01535954f, 0.07505481f, 0.04140151f, -0.04850876f, 
    0.04371554f, 0.03353140f, -0.38580546f, 0.00459754f, 0.00221142f, 0.04376908f, 0.10028379f, 0.15735482f, 
    -0.01819763f, 0.06609140f, -0.04247243f, -0.02607125f, -0.21110003f, -0.02091632f, 0.05574777f, 0.06284276f, 
    0.04861818f, -0.20209403f, 0.04388162f, 0.19150288f, 0.21362880f, 0.03340659f, -0.00902087f, 0.03284595f, 
    -0.06330309f, -0.02252077f, -0.00333989f, 0.01249358f, -0.14881994f, 0.11168270f, 0.02366741f, 0.06868024f, 
    -0.10289799f, 0.16604461f, 0.03459920f, 0.04018167f, 0.00943493f, -0.18945278f, 0.20184784f, 0.15955071f, 
    0.02570010f, 0.06353261f, 0.15252134f, -0.06183273f, 0.00444593f, -0.10954054f, -0.09351033f, 0.18610358f, 
    -0.03610775f, 0.12234933f, -0.02323020f, 0.00702481f, 0.08688039f, 0.15164202f, -0.01350697f, 0.13086955f, 
    -0.01074270f, -0.02889988f, -0.09611220f, 0.21208698f, 0.01409693f, 0.14366278f, -0.17016089f, 0.02093722f, 
    -0.20253085f, -0.19835392f, -0.33775541f, -0.04810554f, -0.24243538f, -0.00132504f, -0.17033471f, -0.01660808f, 
    0.02232895f, 0.07708581f, 0.16499777f, 0.05928180f, 0.11883716f, -0.11331258f, -0.25440985f, -0.09580223f, 
    0.15137380f, -0.01717317f, -0.04519011f, -0.20006843f, 0.28571263f, -0.11254821f, 0.06146522f, -0.23942830f, 
    -0.05467508f, -0.05596372f, 0.17347725f, -0.08224475f, 0.04602825f, 0.29463995f, 0.00777862f, -0.01488562f, 
    0.12751973f, -0.06628455f, 0.12084559f, -0.01868202f, -0.00078523f, -0.43937132f, -0.12960535f, -0.14918065f, 
    0.04897544f, -0.04991231f, -0.03587114f, 0.06048662f, 0.11247417f, 0.10306562f, -0.06839027f, 0.16728136f, 
    0.15835735f, 0.02140544f, 0.06555673f, 0.07662274f, 0.00977277f, 0.16274878f, -0.04783014f, 0.09274078f, 
    -0.04955313f, -0.15328728f, 0.16353093f, 0.00461768f, 0.04631762f, -0.04494395f, -0.16634612f, -0.11808348f, 
    0.16993982f, -0.04921101f, -0.08526348f, 0.01671960f, 0.12064921f, -0.11019602f, 0.13345143f, 0.02866179f, 
    0.02046520f, 0.04740123f, 0.19511601f, -0.09088279f, -0.01534015f, 0.09654650f, 0.13239434f, -0.18126507f, 
    -0.12669486f, -0.10469467f, 0.07507679f, 0.48181289f, -0.34306172f, -0.06354336f, 0.18625295f, 0.10750130f, 
    0.04109867f, 0.00102546f, -0.06800673f, -0.06521108f, -0.22035059f, 0.03538074f, 0.05184408f, 0.14068554f, 
    -0.20899475f, 0.12830874f, 0.04521882f, -0.22235493f, -0.01166885f, 0.12205529f, 0.18130463f, 0.11932983f, 
    0.03495913f, -0.05551349f, 0.06002181f, 0.14432482f, 0.08033761f, 0.00482235f, 0.13211046f, 0.33490190f, 
    0.15592231f, -0.11893140f, 0.11265524f, 0.09474672f, -0.01193848f, -0.06823991f, -0.14111976f, -0.00250876f, 
    -0.50575221f, -0.14760484f, 0.05224170f, -0.12427232f, 0.03468720f, 0.08766518f, -0.11541609f, 0.21693891f, 
    0.06575675f, -0.21637899f, -0.21517694f, 0.17285463f, -0.10936057f, 0.06839288f, 0.08603082f, -0.24171858f, 
    0.10590002f, 0.09428771f, -0.06673528f, 0.02331253f, 0.12495385f, 0.06370213f, -0.03545323f, -0.02252452f, 
    -0.10847302f, -0.14996319f, 0.01339722f, -0.00802172f, 0.18662018f, -0.08988398f, -0.02200667f, 0.00473492f, 
    -0.06654829f, -0.05579983f, 0.10323295f, -0.02373368f, 0.21113403f, -0.01490287f, 0.06739614f, -0.06570451f, 
    0.02285020f, -0.16653454f, 0.05103219f, 0.27271393f, 0.13114946f, 0.07754603f, 0.02199381f, 0.10430906f, 
    -0.02368902f, -0.03141932f, 0.08512359f, -0.09256327f, -0.21689324f, 0.21708050f, 0.26950634f, -0.21582770f, 
    0.09275797f, 0.02641762f, -0.15727200f, 0.15300865f, -0.08885542f, -0.20733757f, -0.09502924f, -0.11027817f, 
    0.05700878f, -0.16262902f, -0.08659778f, 0.09338018f, 0.11683159f, 0.09136752f, -0.18409103f, 0.14559823f, 
    -0.11486566f, -0.02575031f, 0.01661228f, 0.06716017f, 0.00017873f, -0.06576151f, -0.10479297f, 0.10209543f, 
    0.03403358f, 0.00345047f, 0.00582597f, 0.16633712f, -0.00215464f, 0.21301690f, -0.07830179f, 0.11535214f, 
    -0.00246790f, -0.43038157f, -0.12900598f, 0.08254655f, 0.02566124f, -0.16161381f, -0.08388646f, 0.00286442f, 
    -0.17562631f, 0.04639075f, 0.13858826f, -0.07039560f, 0.02455308f, 0.12678944f, 0.01109316f, 0.04469913f, 
    0.09693352f, 0.12299748f, 0.08651970f, -0.33232686f, -0.09179406f, 0.07087783f, -0.06301425f, -0.05571565f, 
    0.08392736f, 0.13409866f, 0.05601779f, 0.04137725f, -0.11746660f, -0.06553429f, 0.02385873f, 0.00449897f, 
    -0.23358780f, -0.00135382f, -0.01509712f, 0.19743328f, -0.00584613f, 0.01416273f, -0.08969564f, -0.02495919f, 
    0.10913087f, -0.06694409f, -0.12548134f, 0.08068394f, 0.17127447f, 0.06843086f, 0.03515906f, -0.19604957f, 
    0.11834759f, 0.14158002f, 0.00288497f, -0.03000265f, 0.01355641f, 0.02380550f, 0.20179474f, -0.06105253f, 
    -0.00008327f, 0.17656708f, -0.11063584f, 0.18246530f, 0.19147146f, -0.07855079f, -0.04700692f, -0.22594355f, 
    0.06152653f, -0.18987565f, -0.10004380f, 0.01112864f, -0.01925324f, -0.00342218f, 0.06782095f, 0.06275868f, 
    0.14044480f, -0.05412259f, 0.31575552f, -0.16869308f, 0.02721310f, 0.22042702f, 0.07199697f, 0.21338627f, 
    0.44082135f, -0.29939765f, -0.19404177f, 0.04099161f, -0.11578194f, -0.14865503f, 0.08132470f, -0.03984796f, 
    -0.13325636f, 0.08160440f, 0.13830964f, 0.12702872f, 0.14868397f, 0.02230923f, 0.07761306f, 0.08827933f, 
    -0.15176590f, 0.01134280f, 0.13887976f, -0.11013041f, -0.02573954f, 0.36822426f, -0.10518541f, -0.07297559f, 
    0.05005674f, 0.03413845f, 0.26834610f, 0.31725150f, 0.02850222f, 0.08804306f, 0.00156231f, 0.04525845f, 
    0.20986933f, 0.12092632f, 0.09864772f, 0.06432662f, 0.34767339f, -0.15018833f, -0.10142399f, 0.10154755f, 
    -0.12904377f, 0.00195723f, -0.18241961f, 0.05128139f, 0.10492432f, 0.17024779f, 0.15468071f, 0.24259830f, 
    0.11817150f, -0.00195405f, 0.15419494f, 0.06141758f, 0.01377327f, 0.13092780f, 0.24934767f, -0.11351831f, 
    0.00057723f, -0.08532931f, 0.02960470f, 0.20103769f, -0.05698210f, -0.05163947f, -0.15056506f, -0.20684858f, 
    0.05490105f, -0.23774745f, -0.04789330f, -0.02125166f, -0.15560776f, 0.04870906f, 0.13938968f, -0.07669100f, 
    0.04673959f, -0.14495140f, 0.03465469f, -0.02165446f, 0.02448544f, -0.10593208f, -0.10103436f, 0.09453218f, 
    -0.15523604f, -0.29861271f, -0.29995027f, 0.24284762f, 0.06740481f, 0.00157562f, -0.16299488f, -0.19727585f, 
    -0.02824988f, -0.18500254f, -0.25650615f, 0.10808116f, -0.23679434f, -0.05160272f, -0.01199513f, -0.05214341f, 
    0.02122405f, 0.22577533f, 0.05523043f, 0.14099933f, 0.11301839f, 0.13545136f, -0.06969900f, -0.06475682f, 
    0.03993055f, -0.11595944f, -0.04705985f, 0.05619594f, 0.06381861f, 0.02939496f, -0.01376928f, -0.06798425f, 
    -0.19668655f, -0.03481736f, -0.14164133f, 0.02058404f, 0.11407864f, 0.03304061f, 0.02017119f, -0.23614542f, 
    -0.10086890f, -0.03382998f, 0.06331915f, -0.13286872f, -0.12316341f, 0.00305082f, -0.01169372f, 0.03842611f, 
    0.20067012f, -0.01293510f, 0.09221356f, 0.13230331f, -0.14245094f, 0.09873013f, 0.08262870f, 0.14375336f, 
    -0.11114559f, -0.18282187f, 0.11157227f, -0.04150083f, 0.01513187f, 0.10422115f, 0.15585218f, -0.12026305f, 
    0.13768224f, -0.16121244f, -0.14606619f, 0.06732445f, -0.07127956f, -0.03137569f, 0.13607328f, -0.05901464f, 
    -0.02950056f, 0.26600975f, -0.06267224f, -0.03693125f, -0.14167441f, 0.00244301f, 0.03270597f, 0.08382416f, 
    0.08429855f, -0.07153846f, -0.15660442f, -0.06140309f, 0.06543744f, -0.02283248f, 0.11054464f, -0.05760345f, 
    0.06855627f, 0.08037258f, -0.02403248f, 0.07467558f, 0.13786203f, -0.22090299f, 0.10321085f, -0.04477797f, 
    -0.05661250f, 0.05932533f, -0.00901403f, 0.15273558f, 0.03698599f, 0.05719399f, -0.05007193f, 0.22797421f, 
    -0.22105154f, 0.05176061f, -0.04811391f, -0.04192588f, 0.13820192f, 0.21492763f, -0.07625685f, 0.06968875f, 
    0.11556762f, -0.00515311f, -0.18288308f, -0.09836401f, -0.19533184f, -0.18662015f, -0.23291011f, -0.05067422f, 
    0.02604411f, -0.00091351f, 0.00516427f, -0.02168108f, 0.06790012f, 0.12159257f, 0.16962616f, 0.15835707f, 
    -0.05210759f, -0.04977686f, 0.04952403f, -0.05534676f, -0.05840191f, -0.02392850f, 0.02205328f, -0.03550029f, 
    -0.01841655f, -0.02095951f, -0.03647862f, 0.03629124f, -0.05796245f, -0.00309571f, -0.00227928f, -0.06030263f, 
    -0.01448912f, -0.03107955f, -0.05523748f, -0.00204697f, -0.02624889f, 0.03767691f, -0.00966375f, -0.00008609f, 
    -0.05909467f, -0.01724387f, 0.00097364f, 0.00724186f, 0.01596059f, -0.05865546f, 0.05281093f, 0.04460562f, 
    -0.01641960f, -0.01029928f, -0.04729078f, 0.02982276f, 0.03884114f, 0.04022185f, -0.05828477f, -0.02326439f, 
    0.04438448f, 0.01494656f, 0.04502645f, 0.03908379f, -0.04295417f, 0.03429689f, -0.00660359f, 0.02659126f, 
    -0.00351837f, -0.01255528f, -0.00536883f, -0.00154529f, -0.04577339f, 0.00477755f, 0.00640251f, -0.00324463f, 
    0.00597804f, -0.05167621f, 0.04122920f, 0.03755041f, -0.01446517f, -0.03429282f, -0.02874029f, 0.02969559f, 
    0.03061933f, 0.02112085f, 0.02949822f, 0.00144438f, 0.03502346f, 0.02897241f, -0.04014632f, 0.04859772f, 
    0.00871466f, 0.00295359f, -0.05370374f, 0.04221386f, -0.01341281f, 0.03713746f, 0.02981004f, -0.02391117f, 
    -0.01085836f, 0.00143341f, -0.04294696f, 0.01572558f, -0.05173417f, 0.00135545f, -0.00360712f, 0.02526810f, 
    0.00583881f, 0.04989215f, -0.02466447f, 0.00273253f, 0.04148697f, 0.03931518f, -0.00562399f, 0.02444883f, 
    -0.04038642f, 0.02581797f, -0.01713684f, -0.04710815f, 0.01376541f, 0.03703682f, -0.01997988f, 0.03312624f, 
    -0.03952853f, -0.01476621f, 0.00860825f, 0.04862881f, -0.04801670f, -0.03048045f, -0.06339235f, 0.03583921f, 
    -0.03854017f, -0.02351394f, 0.01928456f, -0.05853132f, 0.04684540f, -0.00776194f, -0.03657532f, -0.02748661f, 
    -0.05228406f, -0.05049508f, -0.01487653f, 0.02421874f, 0.02487243f, -0.01426983f, -0.02817529f, 0.03633762f, 
    -0.05963228f, 0.01724200f, 0.02643323f, -0.06174973f, -0.03456884f, -0.05000843f, 0.00423614f, -0.02444307f, 
    0.05417977f, 0.05061969f, 0.02606237f, -0.02159212f, -0.03583161f, -0.04935193f, 0.04685962f, 0.01703751f, 
    -0.05649570f, -0.02556419f, -0.02749217f, 0.03842125f, 0.04071157f, 0.04806717f, -0.06014770f, -0.05911620f, 
    0.05666272f, -0.03412881f, -0.03088593f, 0.03564732f, -0.04166455f, 0.01699795f, 0.00932079f, -0.03032899f, 
    -0.02104044f, 0.05378680f, 0.05025660f, 0.00442769f, 0.05510047f, -0.00377785f, 0.04677346f, 0.00109362f, 
    -0.06392929f, -0.02968089f, 0.02107192f, 0.05166935f, 0.05512279f, -0.05015238f, 0.02396852f, -0.02371068f, 
    -0.04380777f, -0.03477006f, 0.02229463f, 0.01950924f, 0.03875117f, 0.04736817f, -0.01064157f, 0.01205948f, 
    -0.03939813f, -0.02040971f, 0.03466860f, 0.03187334f, 0.02291988f, -0.06060787f, -0.00682292f, 0.01043525f, 
    -0.00093720f, -0.06137809f, -0.03361164f, -0.04845105f, 0.04032001f, 0.02632881f, 0.03355110f, 0.00860048f, 
    -0.01220541f, 0.01923043f, 0.03883395f, 0.03309480f, 0.01451118f, -0.05805491f, -0.06434551f, -0.03755605f, 
    0.00401877f, -0.01611173f, -0.06278542f, 0.02547658f, 0.02094020f, -0.02428202f, 0.00985085f, -0.01877696f, 
    0.00388611f, -0.04010131f, -0.01060156f, -0.04459685f, 0.01928479f, 0.02544248f, -0.01158566f, -0.02187532f, 
    -0.04427832f, 0.04131665f, 0.00669798f, 0.03474892f, 0.03836179f, 0.02496412f, 0.02451528f, -0.03790681f, 
    -0.01982768f, 0.00820885f, 0.02476222f, -0.03910184f, 0.01967782f, -0.00556642f, -0.00679913f, 0.02960780f, 
    -0.03772886f, -0.01994579f, -0.05675731f, -0.01728969f, 0.04874248f, 0.02882039f, 0.01982993f, 0.01218558f, 
    0.03765947f, 0.03492096f, 0.00293926f, -0.04631041f, -0.04102630f, -0.03830293f, 0.02385169f, -0.00698307f, 
    0.00568903f, -0.05354636f, -0.04270554f, -0.03962148f, 0.01283220f, -0.02199088f, 0.04229443f, 0.03342289f, 
    -0.02950439f, -0.05405510f, -0.04611789f, 0.05199153f, 0.04017524f, -0.00959274f, 0.05212466f, -0.04497758f, 
    0.00729437f, 0.04623673f, -0.03959294f, -0.01284043f, -0.01849492f, -0.05308215f, -0.00900456f, -0.05206263f, 
    -0.03467001f, 0.00753997f, -0.06045595f, -0.04900473f, -0.02740215f, -0.02835912f, 0.01034329f, 0.01581087f, 
    -0.04697062f, -0.01791244f, -0.04672069f, 0.00259341f, 0.05555400f, 0.02375076f, 0.01291118f, -0.01518892f, 
    0.00136703f, 0.00587911f, -0.02334818f, -0.06089488f, -0.01453749f, -0.05866196f, 0.00476446f, 0.01370800f, 
    0.01972361f, -0.01742173f, -0.01477842f, -0.06283198f, -0.04344394f, -0.04012721f, -0.04847324f, 0.03157662f, 
    -0.02529775f, -0.03209136f, -0.05029508f, -0.01381763f, 0.00031888f, 0.01319883f, 0.05336779f, -0.02903401f, 
    -0.05897208f, -0.02834027f, -0.01922099f, -0.01939106f, -0.00136675f, -0.03794574f, -0.03362644f, -0.01397823f, 
    -0.01655542f, 0.02523875f, -0.03373766f, 0.00134896f, 0.02117611f, 0.02253305f, 0.01092815f, -0.00088086f, 
    -0.05620544f, -0.01528721f, -0.05318153f, -0.01749316f, -0.05108619f, -0.01516596f, -0.01086513f, -0.01743428f, 
    -0.03869314f, -0.05911026f, 0.02589621f, 0.01587038f, 0.05193312f, -0.01932443f, -0.01158323f, 0.04037727f, 
    -0.00986890f, -0.00758101f, -0.01135102f, -0.04659834f, 0.02988087f, -0.02541334f, 0.04418128f, 0.03839102f, 
    -0.05754884f, 0.00278162f, -0.05199309f, -0.04692911f, -0.03270137f, 0.02556891f, 0.02015698f, -0.00633143f, 
    -0.03959658f, -0.03738492f, -0.02191739f, 0.00501356f, -0.01848496f, -0.01922008f, -0.04863741f, -0.04867928f, 
    -0.02722064f, -0.05773431f, 0.03391417f, 0.03904250f, -0.05334594f, -0.01067176f, 0.05003092f, -0.05087768f, 
    0.00751506f, 0.03350286f, -0.00749657f, -0.04080768f, 0.02780259f, -0.02921649f, 0.01126403f, 0.01591886f, 
    -0.00780325f, 0.01141970f, 0.03651116f, -0.04015115f, -0.01918418f, -0.02905899f, 0.01135339f, -0.03781017f, 
    0.04443288f, 0.04410355f, -0.02722667f, 0.04679543f, -0.05762750f, -0.01448973f, 0.01820365f, -0.03330757f, 
    -0.00963161f, 0.02649221f, 0.04396229f, -0.05870692f, -0.01073861f, -0.04679715f, -0.05916563f, -0.01163105f, 
    0.00325177f, 0.02310954f, -0.04151335f, 0.00122791f, 0.03812307f, -0.03385085f, -0.00747439f, -0.01508613f, 
    -0.02752899f, -0.03788174f, 0.01558150f, 0.04794675f, -0.03265679f, -0.01697812f, 0.00639052f, 0.02385328f, 
    0.05104811f, 0.01954930f, 0.02787182f, 0.05766149f, 0.00691751f, 0.05369199f, -0.03243437f, -0.05361195f, 
    0.02948267f, 0.00461656f, -0.02279675f, -0.03859011f, 0.00015763f, 0.03081071f, 0.03552779f, 0.01162141f, 
    -0.04336416f, 0.00561864f, 0.01590532f, -0.03237575f, -0.05028933f, -0.00267567f, -0.00472365f, -0.04186419f, 
    -0.03701750f, 0.02997505f, 0.03451692f, -0.01795086f, -0.05208905f, -0.01380789f, -0.01072876f, 0.01520231f, 
    0.00219311f, 0.04348924f, -0.05917526f, -0.00781642f, -0.05744258f, 0.01487474f, -0.01235387f, 0.01472559f, 
    -0.03044758f, -0.02759678f, 0.02665557f, 0.01007383f, 0.00678748f, -0.04858354f, -0.04240628f, 0.00178878f, 
    0.00463274f, -0.02389852f, 0.01051831f, -0.01786807f, 0.00959594f, 0.01676666f, -0.06051056f, 0.04913245f, 
    -0.01943432f, 0.03378012f, -0.00175015f, 0.05476693f, -0.05807771f, -0.04437050f, -0.01993874f, -0.01694019f, 
    -0.04946876f, -0.00922829f, 0.03181897f, 0.02760063f, 0.03363635f, -0.00159205f, 0.04546706f, -0.05677541f, 
    -0.04253225f, -0.01945493f, -0.02036022f, 0.05829740f, -0.03813425f, 0.01747705f, 0.02544079f, 0.03033988f, 
    0.00403625f, -0.04679222f, -0.04341792f, 0.00952521f, -0.01611620f, 0.00018393f, 0.03589361f, -0.00667368f, 
    -0.04160733f, -0.01657744f, 0.02954049f, 0.01864339f, 0.00825573f, 0.03172203f, 0.04633198f, -0.01132788f, 
    0.02285154f, -0.02681082f, -0.04705107f, -0.01654661f, -0.03385832f, -0.00168046f, -0.00802559f, -0.04831783f, 
    -0.03223430f, -0.01201827f, 0.00112181f, -0.01047511f, 0.01421032f, 0.05386084f, 0.00169119f, -0.00353272f, 
    0.00136233f, -0.03424450f, -0.01845865f, -0.04090671f, 0.04792275f, -0.03123629f, 0.02035127f, -0.05088203f, 
    0.00911833f, -0.04790724f, 0.04006508f, 0.02265400f, 0.01566288f, -0.03434227f, -0.03313965f, -0.03597686f, 
    -0.02808359f, 0.03687315f, -0.02614622f, -0.04343599f, -0.00698122f, -0.01169235f, -0.05145202f, 0.04701280f, 
    -0.04987888f, 0.03656206f, -0.02831679f, -0.02913634f, -0.02630339f, -0.00821031f, -0.04764062f, 0.04358744f, 
    -0.00460588f, 0.03166297f, -0.04256302f, 0.03561352f, -0.02107072f, 0.01682222f, -0.01836083f, -0.00407078f, 
    0.01267478f, -0.03649957f, -0.04807578f, -0.03614403f, 0.05451672f, -0.05695662f, -0.01716961f, -0.00278580f, 
    0.00553539f, 0.02393323f, -0.00372944f, 0.02725313f, 0.01981490f, 0.03587284f, -0.05356842f, -0.05938402f, 
    -0.02550204f, -0.01760093f, -0.00965793f, 0.00644178f, 0.04969582f, 0.02101407f, -0.02737873f, -0.02237288f, 
    0.00248733f, 0.00682199f, 0.03461889f, -0.04586053f, 0.00995528f, 0.03844716f, -0.02559473f, 0.00941094f, 
    -0.01271898f, -0.04992978f, -0.01659548f, 0.01386097f, 0.03494387f, -0.04829943f, -0.04810928f, -0.03764851f, 
    -0.03328990f, 0.03773914f, -0.03453387f, -0.06052194f, -0.01465371f, -0.02350668f, 0.00682356f, 0.03639649f, 
    0.04259972f, -0.01916034f, -0.00415908f, -0.01078574f, -0.01346400f, -0.04872788f, 0.03993725f, -0.02571790f, 
    0.00721283f, -0.03161841f, -0.04275674f, -0.04900037f, -0.03045479f, -0.03595397f, 0.00735852f, 0.01656778f, 
    0.03895907f, 0.02544399f, -0.00000360f, -0.05550272f, -0.00206473f, -0.01827087f, -0.03148385f, -0.00326875f, 
    -0.06373858f, -0.02271920f, -0.02990644f, -0.05692159f, 0.02810468f, 0.04703269f, -0.02682008f, -0.02378249f, 
    -0.05342115f, 0.03761028f, 0.04917201f, 0.01798132f, -0.04102606f, -0.05160625f, -0.06091568f, -0.01853479f, 
    0.04306375f, 0.01501501f, -0.03711282f, 0.03824484f, -0.00946475f, -0.00411923f, -0.00090837f, 0.05208892f, 
    -0.02828100f, 0.03634773f, 0.00726181f, -0.05930549f, -0.01103795f, -0.05062786f, -0.01355005f, 0.03523122f, 
    -0.03949742f, -0.04564453f, 0.04958246f, 0.02922330f, -0.00722765f, -0.06575409f, -0.00547644f, -0.05690534f, 
    -0.04257960f, -0.04157991f, -0.02288489f, -0.05606131f, -0.05960426f, 0.03040655f, -0.00943946f, 0.00382294f, 
    0.03397399f, -0.06791233f, 0.01678275f, -0.01203113f, -0.03490645f, -0.04711832f, 0.00221615f, 0.02606946f, 
    -0.05814062f, -0.00119892f, 0.03423342f, -0.03567582f, 0.04407767f, -0.01352088f, 0.04860244f, 0.00116426f, 
    0.03151732f, 0.02918392f, -0.02876774f, -0.03973854f, 0.02461461f, -0.04159372f, 0.01150327f, 0.01332103f, 
    -0.04464617f, 0.00411425f, -0.00953887f, -0.03845283f, -0.01471398f, 0.05474219f, 0.02255274f, -0.03756920f, 
    -0.00433443f, 0.02474881f, 0.00719006f, -0.01797379f, -0.02914901f, -0.03054738f, -0.03879682f, 0.02240692f, 
    -0.05081630f, -0.03317601f, -0.03904656f, 0.05738457f, 0.05229285f, 0.01965057f, -0.04789294f, -0.04271526f, 
    0.05195481f, -0.01506341f, 0.03482972f, 0.00566769f, 0.02023998f, -0.00431987f, 0.04680816f, -0.05290643f, 
    -0.05256386f, 0.05139089f, -0.01689517f, -0.03116194f, -0.06494294f, 0.02095348f, 0.03494146f, 0.04704615f, 
    -0.01390634f, -0.00920760f, 0.00094341f, -0.03024477f, -0.03145798f, 0.02808091f, -0.03791136f, -0.05213374f, 
    -0.03328165f, 0.02082167f, -0.03644829f, -0.05844106f, -0.05321379f, -0.04370317f, -0.04260153f, 0.02684936f, 
    0.00226827f, 0.03042193f, 0.04159324f, 0.04469711f, -0.04104910f, 0.00931986f, 0.01704026f, 0.03361909f, 
    -0.02832145f, -0.00893097f, -0.02663547f, -0.04302299f, -0.05677245f, 0.01928837f, -0.03857852f, -0.01287070f, 
    0.04427211f, -0.01811163f, 0.02331134f, 0.01115915f, 0.05617027f, 0.02192802f, 0.05248379f, 0.02683066f, 
    0.00201610f, -0.00767802f, 0.04424720f, -0.02356788f, 0.00391616f, 0.01186174f, 0.02514981f, -0.02740022f, 
    -0.06426965f, 0.03933422f, -0.03935832f, -0.01722911f, 0.03490745f, 0.04237481f, 0.00341201f, 0.01705603f, 
    -0.02680270f, 0.01702561f, -0.04880811f, -0.04687377f, -0.03505528f, -0.03578558f, -0.06097976f, 0.04977586f, 
    -0.00634569f, -0.05963436f, -0.01928201f, -0.05331315f, -0.04212318f, 0.02365957f, 0.02019131f, -0.00595824f, 
    -0.01736040f, -0.05109598f, -0.03236794f, -0.03821606f, 0.01075058f, 0.00748711f, 0.00999661f, -0.00339170f, 
    0.04969359f, -0.02881080f, -0.03023703f, -0.01299855f, 0.03376601f, 0.04652120f, 0.02755090f, -0.04445834f, 
    -0.01608233f, 0.02766533f, -0.05510363f, -0.02293649f, 0.03078657f, 0.02532471f, 0.02573968f, 0.01273794f, 
    -0.05430515f, 0.04617260f, 0.01489812f, -0.00338192f, -0.05850841f, 0.02415099f, 0.01915856f, -0.02175939f, 
    0.02342082f, 0.01697269f, -0.04655708f, 0.01870076f, -0.02370297f, 0.00023727f, -0.03128443f, -0.02268551f, 
    -0.05077589f, 0.00621117f, -0.07474408f, -0.00219259f, -0.01827755f, -0.05419703f, -0.02767768f, 0.00963615f, 
    -0.01950458f, 0.03662541f, -0.01844178f, -0.04742516f, -0.05957272f, -0.00951929f, 0.02416822f, 0.05516600f, 
    0.02435615f, 0.01227342f, 0.01174513f, -0.06222030f, 0.04898955f, -0.04090361f, 0.01009863f, -0.01291043f, 
    0.00967423f, -0.05851893f, 0.02573575f, 0.00217597f, -0.04002375f, -0.04002207f, -0.03441837f, -0.03925437f, 
    0.00987402f, -0.05670940f, -0.02687500f, -0.06583042f, -0.01120718f, -0.00085085f, -0.03995343f, 0.04761470f, 
    -0.00090499f, 0.02610247f, -0.06877497f, -0.07401497f, -0.01258130f, 0.01387732f, -0.01773299f, -0.02689274f, 
    -0.01690657f, -0.06204181f, -0.03049284f, -0.05293658f, 0.01534201f, -0.03835265f, -0.06919789f, -0.06607042f, 
    0.03766580f, -0.03808260f, -0.02656090f, -0.06496132f, -0.06580060f, 0.04863995f, -0.04202401f, -0.00107113f, 
    -0.01209147f, -0.05846233f, -0.02242382f, 0.01214441f, 0.00895995f, -0.04700290f, 0.04673043f, -0.01768863f, 
    -0.06738049f, -0.05678354f, 0.02251344f, -0.04795334f, 0.02178823f, 0.01663844f, -0.01558007f, -0.05347838f, 
    -0.02782489f, 0.02823455f, -0.02937734f, -0.02844362f, -0.00744316f, -0.03734774f, 0.02994637f, -0.05817775f, 
    0.05958921f, 0.02459478f, 0.02577842f, 0.03791723f, -0.00724645f, -0.05961537f, -0.03713648f, -0.03728068f, 
    -0.04296209f, -0.06957929f, -0.06314331f, 0.00777819f, 0.02051379f, -0.05835605f, 0.01198173f, -0.06182533f, 
    0.02562968f, -0.01800054f, 0.05319219f, -0.01161568f, 0.04639087f, -0.07225669f, -0.00159031f, 0.04511276f, 
    0.01834291f, 0.00450606f, -0.02800667f, 0.00045874f, -0.00116775f, -0.02438597f, -0.05698269f, -0.04214899f, 
    -0.00278053f, -0.00448052f, -0.02729982f, -0.01063064f, 0.02857282f, 0.03876504f, 0.02635586f, -0.01353139f, 
    -0.01644504f, -0.01836818f, 0.02141444f, 0.01328565f, 0.00960138f, -0.06574949f, 0.01240269f, 0.03967087f, 
    0.02062590f, -0.00455641f, -0.00103358f, -0.03355941f, 0.00544579f, -0.04317956f, -0.00170585f, -0.03857818f, 
    -0.06027763f, 0.05043294f, 0.01482104f, 0.01514504f, -0.04520339f, -0.03083084f, -0.03926179f, -0.02474991f, 
    0.02650863f, -0.04677931f, 0.00771704f, -0.04868857f, -0.05127923f, -0.04454494f, 0.01312470f, 0.00765080f, 
    0.01140409f, 0.04043210f, -0.01832005f, -0.05177246f, 0.01195786f, -0.04549280f, -0.04637355f, -0.03303784f, 
    -0.06528116f, -0.03246571f, 0.04559904f, 0.04101501f, 0.02834368f, -0.05986585f, -0.03858321f, -0.03495233f, 
    0.01428214f, -0.07381737f, -0.02297756f, -0.01762247f, -0.05638879f, -0.06382103f, -0.06579158f, -0.04862006f, 
    0.02854280f, -0.01333236f, -0.06070961f, 0.04521666f, -0.04072342f, 0.03338952f, -0.08028877f, 0.01743109f, 
    0.02257116f, -0.05552362f, 0.02432950f, -0.00014034f, 0.02488960f, -0.06520887f, -0.04936819f, -0.02616315f, 
    -0.05169668f, -0.06471316f, -0.00683012f, -0.06203835f, 0.03655182f, -0.03057484f, -0.05827788f, 0.00811533f, 
    -0.05205499f, 0.00837854f, 0.01046107f, 0.02527438f, 0.03849023f, 0.05555253f, -0.03145262f, -0.06245087f, 
    -0.04190306f, 0.03792959f, 0.04448988f, -0.00816587f, 0.05190227f, 0.02017387f, 0.03680579f, -0.05161142f, 
    -0.07012515f, 0.03705764f, 0.01963140f, 0.04637353f, -0.04358139f, -0.05853548f, -0.02266081f, -0.00558487f, 
    0.00341284f, -0.05766152f, 0.01854132f, 0.01623323f, -0.00106649f, 0.01025228f, -0.05333760f, 0.02430733f, 
    -0.02400690f, 0.03368700f, -0.02030417f, -0.06374072f, -0.06337827f, 0.02851352f, 0.00952445f, -0.03019299f, 
    -0.05313628f, -0.00943164f, 0.00287286f, -0.02910070f, -0.04692484f, 0.04281837f, 0.02169966f, 0.01767733f, 
    -0.05889706f, 0.03085414f, 0.01647000f, 0.03753609f, -0.02769423f, 0.03154992f, 0.01202658f, 0.00796939f, 
    -0.01649195f, 0.01663421f, 0.04403224f, -0.00054604f, -0.02613144f, -0.00113651f, 0.01400384f, -0.00880619f, 
    -0.04699040f, -0.30234715f, -0.20615634f, -0.04343000f, 0.20119840f, -0.01990074f, 0.13964775f, 0.08691147f, 
    0.19049582f, 0.03099293f, 0.10423526f, 0.10256711f, 0.16044863f, -0.08395266f, -0.01964474f, 0.03400091f, 
    0.02940265f, -0.01971179f, 0.28611138f, 0.41025826f, 0.11922263f, 0.02459743f, 0.07550404f, 0.03819583f, 
    0.17395085f, 0.14928485f, -0.12028843f, 0.09752756f, 0.06288766f, -0.42067513f, 0.01015796f, 0.00596109f, 
    -0.13620654f, 0.11571311f, -0.11904120f, -0.19701129f, -0.01672312f, -0.03610620f, -0.01478510f, 0.04586422f, 
    -0.03617386f, 0.07480317f, 0.00959778f, -0.11440334f, -0.08671485f, -0.05322014f, -0.05130898f, 0.08692023f, 
    -0.14308651f, 0.12419860f, 0.15165807f, 0.00927354f, 0.10179820f, 0.10548852f, 0.04631710f, 0.05306606f, 
    -0.07394767f, -0.01340280f, 0.10335336f, 0.03900181f, -0.02914470f, -0.05291917f, 0.15726216f, -0.10447701f, 
    0.14973707f, 0.05570864f, 0.00289622f, -0.03022351f, 0.02733791f, 0.28203422f, -0.12976845f, -0.14497507f, 
    -0.17287505f, -0.04866990f, -0.18904012f, 0.04226242f, -0.02618478f, -0.06660412f, 0.01121575f, 0.00958936f, 
    0.05493634f, -0.28246221f, -0.74654204f, -0.15060847f, 0.18217504f, -0.03824609f, -0.07418890f, 0.08794618f, 
    -0.09230345f, 0.10879331f, 0.02218384f, 0.03279893f, 0.08454216f, -0.18008275f, -0.14624800f, -0.02754516f, 
    0.08074425f, -0.10335101f, -0.11809008f, -0.41333807f, 0.12047345f, -0.05693804f, -0.03565104f, -0.07179891f, 
    -0.07310870f, -0.02073778f, 0.08810634f, -0.02542592f, 0.08641691f, 0.00722364f, 0.00186164f, 0.14459683f, 
    -0.04987685f, -0.15261175f, -0.10424962f, 0.02705952f, 0.13494034f, 0.17911468f, -0.19955522f, -0.05042494f, 
    0.18678951f, -0.01933206f, -0.02817195f, 0.13230203f, -0.04978719f, 0.02628780f, 0.02794660f, 0.06098567f, 
    -0.15230937f, 0.07300859f, -0.02848575f, -0.03522700f, -0.02907468f, 0.08429123f, 0.26456240f, -0.25310269f, 
    -0.27160904f, 0.08421209f, 0.14301281f, -0.01288380f, 0.01518785f, 0.03588400f, -0.04150935f, -0.05962894f, 
    -0.02336560f, -0.11372575f, 0.12061371f, -0.03142995f, -0.09392820f, -0.09950879f, 0.03008447f, 0.04220888f, 
    -0.12975147f, -0.07532120f, 0.05735269f, 0.06122962f, -0.16194011f, -0.11708356f, 0.10851979f, 0.14623533f, 
    -0.04735822f, 0.07596737f, 0.07261212f, -0.08528246f, -0.45197737f, 0.13345668f, -0.07696095f, 0.03535984f, 
    -0.04755623f, -0.11396980f, 0.10382020f, 0.08112124f, -0.37927312f, -0.11769859f, -0.09074127f, 0.14325018f, 
    0.08777018f, -0.05133404f, 0.01570673f, 0.23637876f, 0.10872269f, 0.09490939f, 0.05122472f, 0.06924181f, 
    -0.01367257f, -0.00917797f, 0.03097514f, 0.03159513f, 0.16918214f, -0.18930526f, -0.05346937f, -0.01002837f, 
    -0.08390098f, 0.05412714f, -0.08500221f, 0.05654178f, -0.00614190f, -0.04297043f, -0.17554981f, 0.08695016f, 
    -0.06042717f, -0.03370075f, 0.00853048f, -0.12352771f, 0.07446789f, -0.09912506f, -0.08206809f, 0.12463600f, 
    0.08951391f, -0.00955093f, -0.02713655f, 0.09843107f, 0.11151508f, -0.00414184f, -0.09018502f, 0.04243560f, 
    -0.04151891f, -0.23018032f, 0.25385925f, 0.00437992f, 0.04183238f, -0.09544078f, 0.09409662f, 0.04564624f, 
    -0.00955371f, -0.01071001f, 0.18569055f, 0.22224790f, -0.09178324f, -0.01752131f, -0.13541687f, -0.01547637f, 
    -0.10230669f, 0.03039788f, -0.19496301f, -0.34649590f, 0.14127205f, -0.03290168f, 0.03790575f, -0.03884029f, 
    -0.10416277f, 0.03246969f, -0.01358776f, 0.19980730f, 0.13414426f, -0.06527521f, 0.02084524f, 0.16616033f, 
    0.20609713f, -0.03613640f, 0.07569573f, -0.01352895f, -0.17111574f, 0.11181673f, -0.31864628f, -0.07132817f, 
    0.21698827f, -0.04538278f, -0.10476030f, -0.03092786f, -0.12380079f, -0.07539254f, 0.18220845f, 0.19336867f, 
    -0.17226145f, 0.02780308f, -0.06672722f, 0.11009912f, -0.00669597f, 0.03038130f, -0.19790460f, 0.27549639f, 
    0.21683960f, -0.02770077f, -0.01747437f, 0.09618723f, -0.00839312f, -0.03238921f, -0.09982225f, -0.00216600f, 
    -0.00526398f, 0.16811579f, 0.07301763f, -0.06245758f, -0.05906722f, 0.02355526f, 0.04507745f, 0.08553138f, 
    -0.00602390f, 0.01570506f, -0.04499422f, -0.03615941f, 0.03611736f, -0.05396338f, -0.04320703f, 0.03957991f, 
    -0.03371543f, -0.06168848f, 0.02381670f, -0.02721453f, 0.02962367f, 0.01650852f, 0.02298129f, 0.03938157f, 
    0.03672757f, -0.02076639f, -0.02265260f, 0.04220169f, -0.04018492f, -0.01650302f, -0.04135342f, -0.05883304f, 
    0.00359097f, -0.02000990f, 0.03772943f, 0.00758318f, -0.06819491f, -0.00885961f, -0.05215393f, 0.02525783f, 
    0.05130556f, -0.04830047f, -0.01180505f, 0.03420409f, 0.01476257f, -0.04943208f, -0.01961212f, -0.00689441f, 
    0.04225812f, 0.00417268f, 0.04378391f, -0.03405764f, -0.03713815f, -0.05752360f, -0.01548555f, -0.02575101f, 
    -0.05525569f, -0.04506640f, -0.05401476f, 0.00179387f, 0.00138028f, 0.00658193f, 0.03550854f, -0.00510113f, 
    0.03312631f, 0.04715840f, -0.03098046f, 0.02235074f, -0.00386963f, -0.04415850f, 0.01750262f, -0.01702626f, 
    0.04257814f, 0.03692862f, -0.00228695f, 0.00006447f, 0.00112355f, -0.03616975f, 0.02333187f, -0.05128772f, 
    0.00065434f, -0.05203729f, -0.00380894f, 0.02026099f, -0.04864195f, -0.00597535f, 0.03927778f, -0.00615193f, 
    0.03866215f, -0.06233197f, -0.06543464f, -0.01986771f, 0.03712021f, -0.06856687f, 0.01152494f, -0.05924333f, 
    -0.06640369f, -0.02266272f, -0.01528774f, -0.00876313f, -0.04143136f, 0.01926885f, -0.04524707f, -0.04539360f, 
    0.05290168f, -0.03427166f, 0.00357100f, 0.02511183f, 0.00143900f, -0.06654973f, -0.03698745f, 0.03177089f, 
    0.03278052f, 0.00579145f, 0.03921789f, 0.01638757f, 0.03199045f, 0.04025737f, -0.03321183f, -0.00431592f, 
    0.00135335f, 0.02149350f, 0.01576264f, -0.05778170f, 0.03998680f, 0.02187029f, -0.00414470f, -0.05929241f, 
    -0.06334297f, 0.02243558f, -0.06546845f, 0.01776676f, 0.04507394f, -0.03126085f, -0.04294737f, -0.05106876f, 
    0.01201115f, -0.04432516f, -0.03482461f, 0.00927428f, -0.00115381f, -0.05166869f, -0.04351379f, -0.03427400f, 
    0.00356894f, -0.06205459f, 0.00550804f, 0.03343404f, 0.00518086f, -0.04738276f, 0.04004616f, 0.01822336f, 
    0.00313775f, 0.00835583f, -0.01273196f, 0.04349795f, -0.04216570f, 0.05018575f, 0.05882609f, -0.04379290f, 
    0.02314991f, -0.02018327f, -0.06019239f, -0.03274402f, 0.02734274f, -0.02833674f, 0.01482612f, -0.03418204f, 
    0.00104302f, 0.00774352f, -0.06580964f, -0.01140326f, -0.01690106f, 0.00744296f, 0.04199175f, 0.02324496f, 
    -0.04437175f, 0.02858131f, 0.04211267f, -0.05653355f, 0.02768465f, 0.05072841f, 0.00906814f, -0.05519579f, 
    -0.02606621f, -0.05240596f, 0.00616283f, -0.03160157f, -0.01077334f, 0.00915209f, -0.05084801f, -0.02084041f, 
    -0.03631640f, -0.01917623f, 0.03304103f, -0.05227937f, -0.02539678f, -0.05832086f, -0.03236516f, 0.00204653f, 
    -0.02865943f, -0.05601163f, 0.04195336f, -0.05622850f, -0.03653404f, 0.04480251f, -0.05195941f, 0.04471119f, 
    -0.04138248f, -0.03367168f, 0.00884534f, 0.01413178f, -0.02475948f, -0.00554426f, 0.04230930f, -0.05042865f, 
    0.03231103f, 0.04281399f, -0.01147232f, -0.03592125f, -0.00059197f, 0.03956505f, 0.02455956f, 0.03353260f, 
    -0.05657766f, -0.01514085f, 0.01248849f, 0.01479551f, 0.03326785f, -0.00525224f, 0.00594932f, -0.05218509f, 
    -0.05872885f, 0.04555668f, 0.03050767f, 0.01051515f, 0.00180583f, 0.00333242f, 0.02694911f, -0.03646215f, 
    -0.01601686f, 0.05069212f, -0.00001008f, 0.01761875f, 0.05712147f, 0.01974743f, -0.01088284f, -0.01882823f, 
    -0.04059453f, -0.04377025f, -0.06164189f, 0.01751129f, 0.00327341f, -0.03098758f, 0.02040125f, -0.05788468f, 
    -0.03071591f, -0.01617884f, -0.05845362f, 0.02780561f, -0.05522036f, 0.02728447f, 0.04303661f, -0.06450838f, 
    0.01663429f, 0.00003358f, -0.01933834f, 0.02661495f, 0.01786339f, -0.03162134f, 0.03997362f, 0.05128511f, 
    0.03250502f, 0.00939879f, -0.04267849f, -0.03212768f, 0.03245138f, -0.06002546f, -0.01690217f, -0.03422344f, 
    -0.04944159f, 0.04379578f, -0.02888242f, 0.03031595f, -0.00280044f, -0.04065651f, -0.02841569f, 0.04254767f, 
    -0.05097450f, -0.02197753f, -0.04140024f, 0.03328158f, 0.03470051f, 0.00516811f, 0.01727380f, -0.03628789f, 
    0.08083048f, 0.03588301f, 0.07278898f, -0.09064035f, 0.12214772f, 0.02368877f, -0.09516834f, -0.12207772f, 
    -0.23211406f, -0.02107353f, 0.05481308f, 0.08970149f, -0.00965552f, -0.06250576f, -0.02559794f, 0.10348248f, 
    0.00090627f, -0.00083529f, -0.02558245f, 0.20575580f, -0.09177749f, -0.06572633f, 0.02952300f, 0.04742838f, 
    0.08483069f, -0.00773795f, 0.16397233f, 0.22185688f, 0.14622064f, -0.10147479f, 0.06361034f, 0.17706853f, 
    0.00666489f, 0.01444023f, 0.04755996f, 0.00276712f, 0.07463223f, 0.00086390f, 0.00339809f, 0.03749580f, 
    -0.08056855f, -0.06415551f, 0.00864034f, -0.02506113f, 0.01333160f, 0.08384950f, 0.15776338f, 0.15906687f, 
    -0.00957813f, 0.11264849f, 0.05838189f, -0.03941078f, -0.02091466f, -0.17635280f, 0.10449985f, 0.09747370f, 
    0.21731749f, 0.09280764f, -0.00419022f, 0.05390939f, 0.03297689f, 0.18785898f, -0.26891848f, -0.12028562f, 
    -0.11073918f, 0.16482635f, -0.06429779f, 0.08072069f, -0.08484492f, 0.05513554f, 0.19660175f, -0.00819179f, 
    0.03272000f, 0.14659789f, -0.12765574f, 0.06956963f, 0.03994696f, 0.20144992f, 0.21653832f, 0.01635442f, 
    0.07483200f, -0.08237110f, -0.11280923f, -0.06166013f, -0.07546293f, 0.04899076f, 0.01860723f, 0.00104950f, 
    0.03176237f, -0.19381842f, 0.00035716f, 0.00869759f, -0.00726070f, 0.06264655f, 0.00882273f, 0.08366023f, 
    0.02087547f, -0.07389589f, -0.17906193f, 0.07678602f, -0.08207116f, -0.12815399f, -0.09515517f, 0.13336742f, 
    0.09473512f, -0.00763058f, 0.06295028f, -0.12663871f, -0.10307082f, 0.04013516f, 0.13805613f, -0.04815759f, 
    0.03439312f, -0.03401805f, 0.03258605f, 0.07925302f, 0.04376401f, -0.00342478f, -0.00184052f, -0.07701895f, 
    -0.00472951f, -0.01075665f, 0.07511108f, 0.14948030f, 0.05902593f, 0.01166357f, 0.05534089f, 0.15271905f, 
    0.06950082f, 0.07733496f, 0.07120650f, 0.08618180f, 0.10720778f, 0.09336946f, 0.02378239f, -0.07500841f, 
    -0.24330638f, -0.13673475f, 0.03576518f, 0.08864859f, -0.04261426f, -0.03929952f, -0.07342973f, -0.05885092f, 
    0.06288578f, 0.13715914f, -0.05738023f, -0.03201019f, -0.07196208f, 0.00493021f, 0.03643938f, -0.02959151f, 
    -0.04866720f, -0.17271379f, -0.07973366f, -0.02634299f, 0.05198061f, -0.04330237f, -0.13755147f, -0.00974232f, 
    -0.00437837f, -0.27493429f, -0.08037943f, -0.01864161f, 0.13982105f, 0.16320801f, -0.09885662f, -0.04468243f, 
    0.09486762f, -0.09229918f, -0.15995616f, 0.07603692f, 0.03232245f, 0.08229341f, -0.01432303f, 0.08622389f, 
    0.15870403f, 0.03516851f, 0.08202121f, -0.01766412f, 0.04040280f, 0.18004443f, -0.05732533f, 0.03222831f, 
    0.01941115f, 0.05048217f, 0.07928248f, -0.01910750f, -0.06280707f, 0.07154275f, 0.09243823f, -0.05452647f, 
    0.00291863f, -0.02882405f, 0.02112003f, 0.08749230f, 0.08419215f, -0.10431415f, -0.02180598f, -0.09156292f, 
    -0.36039129f, -0.08103403f, -0.10133030f, -0.16638424f, 0.12334471f, -0.13441676f, 0.02948700f, -0.09648447f, 
    0.07479221f, 0.19503275f, 0.13730875f, 0.03497842f, 0.04690133f, 0.08860718f, -0.03729058f, 0.03277372f, 
    -0.05872540f, 0.09745305f, -0.08027120f, -0.01613397f, 0.11332144f, 0.02999227f, -0.01503786f, -0.06943210f, 
    -0.21309021f, 0.29736811f, -0.05341880f, -0.54691905f, 0.05282035f, -0.06917956f, 0.16683593f, 0.08851939f, 
    0.09127633f, 0.12233824f, 0.12741411f, 0.21852680f, 0.10129025f, 0.01159492f, -0.05813299f, -0.00861313f, 
    0.00010317f, -0.02872654f, -0.00890722f, 0.00986331f, -0.00831102f, 0.17598692f, -0.10338981f, 0.00688334f, 
    0.00132944f, 0.00048701f, 0.13638671f, -0.08424895f, 0.05592030f, -0.11380980f, -0.24128598f, -0.07788666f, 
    0.00297042f, -0.01369141f, 0.19589870f, -0.22244126f, 0.12198605f, 0.30369836f, -0.15667631f, -0.17667778f, 
    -0.07426959f, -0.10010520f, 0.12069639f, -0.12576388f, -0.06229293f, -0.09751920f, -0.11932971f, -0.13762420f, 
    -0.33426726f, 0.06735344f, 0.10887904f, -0.18831563f, -0.05466986f, -0.16543512f, -0.16476952f, -0.16030733f, 
    0.16330433f, 0.16511287f, -0.06007172f, -0.03745160f, -0.03464979f, 0.04020211f, 0.10820286f, 0.16133666f, 
    -0.21670015f, -0.12560557f, -0.01513864f, 0.05115842f, -0.00702794f, -0.08633761f, -0.29011652f, -0.03629477f, 
    -0.13499880f, 0.02631452f, -0.17879432f, 0.02676732f, -0.06114663f, 0.03312714f, -0.03181241f, -0.07596114f, 
    0.03313179f, 0.09518442f, -0.27958947f, -0.12409210f, 0.03533875f, 0.14724110f, 0.04504354f, 0.05468553f, 
    0.03154371f, 0.21172373f, 0.17077142f, -0.38648224f, -0.12950732f, 0.24025755f, -0.02528439f, 0.03313615f, 
    -0.13632198f, 0.20199339f, -0.18966727f, -0.20478596f, -0.17849810f, -0.28872728f, -0.03334882f, -0.02717778f, 
    0.06458423f, -0.03255796f, 0.09730561f, 0.04389839f, 0.08609142f, -0.05435659f, -0.10238465f, -0.03580238f, 
    -0.00929841f, 0.02519881f, -0.05008320f, -0.00069650f, 0.09326141f, -0.11337046f, 0.02021388f, -0.48087224f, 
    -0.35438204f, -0.05071730f, 0.08600789f, -0.11580733f, 0.16878776f, 0.02053931f, -0.13327780f, -0.07185776f, 
    -0.40990454f, -0.23749092f, 0.11750568f, 0.04085744f, 0.01577460f, 0.02917001f, 0.22044879f, -0.08929516f, 
    -0.19806096f, 0.15500714f, -0.04169899f, -0.02629165f, 0.09861132f, 0.09492985f, -0.04137708f, -0.05659905f, 
    -0.13481531f, 0.00064823f, 0.25079688f, 0.46433163f, -0.04923216f, 0.10027581f, 0.11459520f, -0.04463541f, 
    -0.07552913f, -0.18504435f, -0.29422814f, -0.07028391f, -0.03548551f, -0.02302469f, 0.03994874f, 0.05257996f, 
    0.12149191f, 0.04024268f, 0.09994943f, -0.70021981f, -0.19534025f, 0.17378528f, 0.06738078f, 0.02402737f, 
    -0.02117290f, 0.08652212f, -0.19109324f, 0.04349797f, 0.04076859f, 0.03827838f, -0.05680406f, 0.13283154f, 
    -0.07317479f, -0.06885027f, 0.12297939f, -0.01601154f, 0.05468883f, -0.14107002f, 0.21189646f, 0.22039948f, 
    0.09772182f, 0.13451593f, 0.03150117f, 0.09831776f, 0.01656765f, 0.02150702f, -0.09357496f, 0.00984414f, 
    0.01798069f, 0.05807514f, 0.15299733f, -0.07515208f, 0.10608115f, 0.01236561f, 0.02717177f, 0.18824986f, 
    0.21706279f, 0.18767597f, -0.18378857f, 0.03418721f, 0.08596545f, -0.08870735f, -0.07039392f, -0.02137530f, 
    -0.39175144f, -0.10478044f, -0.52395743f, -0.21495268f, -0.01673933f, -0.21479896f, 0.00788355f, -0.00635106f, 
    0.04926951f, 0.31332049f, 0.14123480f, 0.32624972f, 0.10356939f, 0.10471149f, -0.05387835f, 0.14780805f, 
    0.11288451f, 0.17996529f, 0.25028223f, 0.13125816f, 0.05369652f, 0.01653404f, 0.08816785f, 0.00125309f, 
    -0.03408127f, -0.05810301f, 0.07098641f, 0.18239489f, 0.04801625f, -0.01117202f, 0.07159445f, 0.03334628f, 
    0.07981201f, 0.00947039f, 0.10502911f, 0.00192751f, -0.31400502f, -0.26701152f, 0.00889782f, 0.21300188f, 
    0.09337167f, -0.06355152f, -0.02413748f, 0.04618848f, -0.02162666f, -0.34222010f, 0.07275428f, -0.24784595f, 
    -0.04155743f, 0.04289089f, -0.19059563f, -0.06580473f, 0.05521135f, -0.06322097f, -0.09933391f, 0.32021087f, 
    0.09489444f, 0.10043035f, -0.09049414f, 0.12766439f, 0.14163803f, -0.10950338f, -0.17473650f, 0.03141509f, 
    0.00577477f, -0.31449926f, 0.05564405f, 0.07699323f, -0.06612648f, -0.10364199f, 0.09149149f, -0.11518794f, 
    0.09719945f, -0.00838567f, -0.34722617f, 0.13575536f, -0.09670911f, 0.14730652f, 0.10016391f, -0.03773880f, 
    0.04121718f, -0.20770271f, 0.02455957f, 0.04635779f, -0.02915060f, 0.03261782f, 0.01077056f, 0.18005927f, 
    -0.02888467f, 0.07566908f, -0.14992498f, -0.51883417f, -0.17675841f, 0.06940155f, -0.11448456f, 0.02473990f, 
    -0.25959125f, -0.06814800f, -0.05864280f, -0.20132381f, -0.51616192f, -0.33270606f, -0.18126968f, 0.05915636f, 
    -0.04474594f, 0.31051382f, 0.08213323f, 0.24456641f, -0.10402997f, 0.03797918f, 0.19515300f, 0.05818594f, 
    -0.05278134f, 0.05148692f, 0.17410737f, 0.08406758f, -0.15881819f, -0.24109481f, -0.01755139f, 0.06096733f, 
    -0.03309215f, 0.00344469f, 0.01302579f, 0.10092229f, -0.02658392f, 0.24145643f, 0.37066814f, 0.12626705f, 
    0.19071959f, 0.18662225f, -0.14097518f, -0.00598084f, -0.01720414f, 0.02895150f, 0.12275334f, 0.32067674f, 
    -0.14337811f, -0.21662788f, 0.15362319f, 0.07945618f, 0.04903438f, 0.14214729f, -0.12600480f, -0.03471464f, 
    -0.06644261f, 0.19153436f, -0.21998785f, 0.13213384f, 0.01096335f, 0.02992558f, -0.03010341f, -0.00403794f, 
    -0.02650608f, -0.06370892f, 0.10119212f, 0.13183707f, 0.00946684f, -0.01136312f, 0.06083706f, 0.13665558f, 
    0.03709880f, -0.09173784f, -0.63377202f, -0.09914937f, 0.07175913f, 0.02488547f, 0.08935307f, -0.30004963f, 
    0.08616713f, -0.06060517f, -0.00571900f, -0.22649963f, -0.20956159f, -0.05335240f, -0.07337102f, 0.40288302f, 
    -0.14135401f, -0.00580085f, -0.05135634f, 0.02742586f, 0.04219174f, 0.08983753f, -0.03030784f, -0.02355229f, 
    0.03517317f, -0.05898431f, 0.05837276f, 0.10952525f, 0.04920807f, 0.00085352f, 0.17154662f, -0.14433363f, 
    0.17109376f, -0.01192687f, -0.01514341f, 0.13592817f, 0.11610363f, 0.11555836f, 0.46828127f, -0.09748572f, 
    -0.07524903f, -0.09599295f, 0.01212680f, 0.07047742f, -0.00903519f, 0.08637100f, 0.04792799f, -0.02152403f, 
    0.11150346f, 0.09792180f, -0.03602708f, 0.00545373f, 0.05545434f, 0.02551245f, -0.01521662f, -0.15411985f, 
    -0.07598928f, 0.38389680f, -0.14524807f, 0.01581961f, -0.07436183f, -0.02105039f, -0.08381350f, -0.16309185f, 
    0.15382159f, 0.03548946f, -0.09634081f, 0.13680026f, 0.08779761f, 0.07416849f, -0.24473523f, 0.12780723f, 
    -0.11966639f, 0.04497257f, -0.03857023f, -0.11272582f, -0.17427537f, -0.02367504f, 0.08584622f, -0.07977688f, 
    -0.05529336f, -0.02775585f, 0.16217621f, -0.26019764f, 0.01510949f, 0.51381069f, -0.19849680f, 0.12019661f, 
    -0.09120768f, -0.25680307f, 0.01723475f, 0.09127161f, 0.06492949f, -0.06938662f, 0.15337022f, 0.03461561f, 
    0.09224775f, -0.00845505f, 0.09483541f, 0.00177042f, 0.15805955f, -0.11741529f, -0.04499224f, 0.21095535f, 
    -0.13073163f, 0.03258666f, -0.12040552f, -0.09553224f, 0.04910706f, 0.08333666f, -0.02956669f, 0.16645314f, 
    0.18131977f, 0.05920860f, 0.13978054f, 0.03144188f, 0.05493137f, -0.00772469f, -0.01833393f, -0.38438809f, 
    -0.16081776f, -0.16962096f, 0.22004613f, 0.07232648f, -0.06353363f, -0.02217052f, 0.10452826f, 0.00289060f, 
    0.25866365f, -0.13920386f, 0.07930242f, -0.17976178f, -0.06326053f, -0.05927711f, -0.08785751f, 0.04288148f, 
    -0.09626780f, -0.22300209f, 0.02340022f, 0.01780168f, -0.03365922f, 0.05313171f, -0.10406185f, 0.01989388f, 
    0.07135987f, -0.05405052f, -0.10584021f, -0.06551649f, -0.09508844f, 0.00839826f, -0.04098577f, 0.02441823f, 
    0.14090410f, -0.05632336f, -0.12460086f, 0.05849070f, -0.05557473f, 0.27578503f, -0.06278332f, -0.20386313f, 
    -0.02594123f, -0.10010032f, 0.11592545f, 0.13278294f, 0.11414983f, 0.12101015f, 0.12591554f, 0.02544165f, 
    -0.04581799f, -0.07195371f, 0.03571374f, 0.02531760f, -0.12413843f, -0.17532440f, -0.06611508f, -0.25062862f, 
    0.12826844f, 0.18324921f, -0.08608055f, -0.32035416f, -0.16611561f, 0.09300833f, 0.14019234f, 0.26632515f, 
    -0.22174440f, 0.08251218f, 0.02102299f, -0.17593297f, 0.06197043f, 0.02821283f, -0.01399470f, 0.17232712f, 
    0.00219572f, -0.26900077f, 0.19221595f, -0.04985994f, 0.27819633f, 0.02134151f, 0.04717362f, -0.05016885f, 
    0.02885106f, -0.01751825f, 0.07791566f, 0.10210784f, -0.07058858f, -0.09631488f, 0.04582949f, -0.02381048f, 
    0.14116248f, 0.01457278f, 0.02492901f, -0.11135297f, -0.05752555f, 0.03383656f, -0.16432783f, -0.05109949f, 
    0.09809660f, 0.06297708f, 0.20782068f, 0.20573004f, 0.05448842f, -0.08469579f, 0.04427098f, -0.08451304f, 
    0.05731653f, 0.09689143f, -0.00600688f, 0.32923430f, 0.04826627f, -0.01788591f, -0.11993746f, -0.03522814f, 
    0.06810641f, 0.03398772f, 0.03273386f, -0.20282917f, -0.15343983f, 0.49520743f, -0.17282739f, -0.09988649f, 
    -0.05519918f, -0.25352594f, 0.05217345f, -0.00240380f, -0.01315243f, -0.01662397f, -0.24726006f, -0.35505849f, 
    0.03187906f, -0.03499360f, -0.17581995f, -0.30372182f, 0.07281326f, 0.03782516f, -0.35906431f, 0.18305089f, 
    0.15648273f, 0.01439437f, 0.15957314f, -0.09086788f, -0.06633694f, 0.14917415f, -0.05787685f, 0.16123566f, 
    -0.20265855f, 0.16543628f, 0.00071287f, 0.01021336f, -0.00111861f, 0.08833680f, -0.01713690f, 0.01322423f, 
    -0.04068433f, -0.03830840f, -0.02058363f, 0.02772079f, -0.02754432f, 0.04578104f, 0.02187457f, -0.00875870f, 
    0.00283514f, -0.01892704f, -0.01721911f, -0.05691328f, 0.03640332f, 0.01724792f, -0.00122913f, 0.02705513f, 
    -0.00125592f, 0.00446327f, -0.04794306f, 0.05113118f, -0.04557248f, 0.00687569f, -0.05601099f, -0.04712375f, 
    0.03626116f, 0.02075023f, -0.01554501f, -0.01346081f, 0.02648710f, 0.03899856f, -0.04574312f, 0.01513423f, 
    -0.02566332f, -0.04358168f, 0.01273804f, -0.02878977f, -0.01138850f, -0.05967053f, -0.00020348f, -0.02202655f, 
    0.01689800f, 0.00287402f, 0.01868770f, -0.02423488f, 0.03872537f, -0.01051232f, 0.02867432f, -0.05898790f, 
    -0.03282828f, -0.00153763f, -0.01516244f, -0.01009877f, -0.03073012f, -0.03859446f, -0.04693345f, -0.01827331f, 
    -0.00669367f, -0.02051184f, -0.02789359f, 0.03558477f, -0.03471649f, -0.06336557f, -0.00170400f, -0.04488645f, 
    0.02704951f, 0.00285726f, -0.05846547f, 0.03262080f, -0.00997066f, -0.03074978f, -0.00257152f, 0.02583356f, 
    -0.04988077f, 0.02560740f, -0.00836055f, -0.04538388f, 0.00887801f, -0.06189694f, 0.01396862f, -0.00267854f, 
    0.00965792f, 0.01111386f, 0.01090264f, -0.00127621f, 0.02555974f, 0.05440802f, 0.03778889f, -0.02119153f, 
    -0.02429057f, 0.01378716f, 0.01587189f, -0.01588103f, 0.03417686f, 0.02168851f, 0.04906872f, 0.00965721f, 
    0.01278521f, 0.03347947f, 0.00014253f, 0.03859957f, -0.00888122f, -0.02541015f, -0.05125012f, 0.00236315f, 
    0.04006010f, -0.00055167f, -0.05655656f, 0.04747993f, -0.05108872f, 0.03834420f, -0.00653333f, 0.04750579f, 
    -0.03119328f, 0.00465918f, -0.04945042f, -0.01506270f, -0.02131377f, 0.00844081f, 0.02696897f, -0.05522104f, 
    -0.02031515f, 0.01745063f, 0.00192066f, 0.01553641f, -0.01225952f, 0.01356982f, 0.04224787f, -0.01772187f, 
    -0.06006207f, -0.04229428f, 0.00452310f, -0.01683433f, -0.03656726f, 0.05318472f, 0.04439532f, -0.03805400f, 
    0.02401318f, 0.02496616f, -0.02212635f, 0.00045051f, -0.04305003f, -0.04128866f, -0.02099327f, 0.02488548f, 
    -0.05000918f, -0.03581070f, -0.04481887f, -0.04864176f, -0.00323136f, 0.03444899f, -0.01559585f, 0.02667625f, 
    -0.01612171f, 0.00806352f, 0.02419663f, 0.05077064f, 0.02559139f, -0.03937488f, 0.02289523f, 0.02768454f, 
    -0.06484491f, -0.01652274f, 0.00619007f, -0.06082988f, 0.01368488f, 0.03567687f, 0.02199185f, 0.04156169f, 
    0.01592656f, 0.01882689f, -0.05964232f, 0.03365147f, -0.03616669f, -0.00668980f, 0.00770392f, 0.00253840f, 
    -0.02907225f, -0.03131215f, -0.00206143f, 0.04924136f, -0.03876173f, -0.04864171f, -0.01144349f, 0.01558160f, 
    -0.02608630f, -0.00340420f, -0.02148627f, -0.01019320f, 0.02263047f, 0.03063520f, 0.00147568f, -0.02286116f, 
    -0.05042200f, 0.00230774f, -0.02505451f, 0.03271219f, -0.02299613f, -0.04246895f, 0.03103689f, 0.02502345f, 
    -0.03173163f, 0.01324371f, -0.01285038f, 0.02298263f, 0.02843769f, 0.00548360f, 0.04768486f, -0.04940891f, 
    -0.02696460f, -0.02021951f, 0.04344938f, -0.05245843f, -0.00238920f, 0.04758903f, -0.05693074f, -0.03523502f, 
    -0.05201216f, 0.04190829f, -0.01639049f, -0.02103963f, 0.02010220f, 0.01336952f, -0.05160639f, -0.04545254f, 
    0.00467016f, -0.01391465f, -0.03192283f, 0.03950777f, 0.01253617f, -0.06387445f, -0.06443006f, -0.01779694f, 
    -0.06472177f, -0.05846838f, 0.00769265f, -0.00645973f, -0.02616293f, 0.02000652f, 0.04326652f, -0.04227757f, 
    0.02869203f, 0.04365881f, 0.01820788f, 0.03819776f, 0.01355429f, -0.05983425f, -0.00114194f, 0.03769802f, 
    -0.05478952f, -0.06024306f, 0.00702458f, 0.01537101f, -0.05312203f, -0.03441186f, 0.05066186f, 0.00025190f, 
    -0.05226254f, 0.00385854f, -0.05116242f, -0.04238184f, -0.00693934f, 0.02237343f, 0.01812679f, -0.05506463f, 
    0.03777785f, 0.02844927f, -0.05377600f, -0.00595055f, 0.02336674f, 0.01038362f, -0.01702107f, -0.04997917f, 
    -0.00611722f, 0.04066379f, -0.00946274f, -0.04917930f, -0.06364362f, 0.05043725f, -0.04412884f, 0.03864891f, 
    0.01719329f, -0.01967353f, 0.03171274f, -0.01670101f, -0.00837351f, -0.04468973f, 0.03452495f, -0.00410054f, 
    -0.49729386f, 0.36719128f, -0.07354888f, -0.07365882f, 0.18463443f, -0.00110209f, -0.07377615f, -0.07507483f, 
    -0.02590032f, -0.12939356f, 0.10007800f, 0.19165321f, 0.04546929f, -0.12828046f, -0.06047044f, -0.01174777f, 
    -0.00462335f, 0.07146180f, -0.34809190f, 0.01551049f, -0.14607617f, -0.02002163f, 0.06823325f, -0.18873706f, 
    -0.14866088f, 0.00114231f, 0.07188047f, -0.15963306f, -0.19584560f, 0.16205661f, 0.11174010f, -0.02570836f, 
    -0.08565187f, -0.04023632f, 0.07177808f, -0.04268399f, -0.01917548f, 0.22963127f, 0.04813847f, 0.08354878f, 
    -0.19061561f, 0.03650006f, -0.05537344f, 0.02498883f, 0.03449896f, -0.31897664f, 0.06540754f, -0.31444874f, 
    0.09328219f, 0.02480468f, -0.01927181f, 0.03552274f, -0.05135938f, -0.06944948f, 0.05942369f, -0.11129351f, 
    -0.07245907f, -0.08414532f, -0.02238411f, 0.23559658f, 0.15795082f, 0.06283478f, -0.12422407f, -0.27313063f, 
    -0.09753487f, -0.02957994f, -0.01357329f, -0.12953572f, 0.15228061f, 0.06160117f, -0.01641634f, 0.20030855f, 
    -0.11709987f, 0.04206505f, 0.26088512f, -0.05884877f, 0.05026113f, -0.05719879f, 0.05243380f, -0.07321414f, 
    -0.01034323f, -0.02481466f, 0.46479508f, 0.19749913f, -0.05215097f, -0.06542172f, -0.02588862f, 0.05456818f, 
    0.06684708f, -0.10328329f, 0.09587765f, 0.34456894f, 0.00593552f, -0.18842432f, -0.11469484f, -0.14064567f, 
    -0.02047673f, -0.11123309f, -0.05285121f, -0.55644870f, -0.80871093f, 0.49776170f, -0.20117159f, 0.00254867f, 
    -0.39495555f, -0.04635463f, -0.16529346f, 0.01738710f, 0.01826724f, -0.03215358f, 0.28475878f, -0.23541783f, 
    -0.01396107f, -0.08821449f, -0.03191671f, -0.02171257f, 0.16787547f, -0.13644086f, 0.06185124f, 0.19662607f, 
    -0.09778281f, 0.02465047f, -0.04543388f, 0.06278595f, 0.01763469f, 0.12755790f, -0.01565814f, 0.12308354f, 
    0.06092481f, -0.06944702f, -0.14211588f, 0.08976480f, 0.03903297f, -0.02791732f, 0.23020487f, -0.03466738f, 
    0.14195916f, 0.16545986f, 0.16303752f, 0.02244256f, -0.00546716f, 0.08524379f, 0.00581519f, -0.07500087f, 
    -0.11563673f, 0.26831278f, -0.28494319f, -0.07137112f, -0.08466773f, 0.18776201f, 0.03442047f, -0.01928267f, 
    0.02031791f, 0.14784873f, -0.05330819f, -0.00242461f, 0.00851739f, 0.11046609f, -0.00478691f, 0.31210428f, 
    -0.06551825f, 0.02709194f, 0.00543527f, 0.05561121f, 0.09572973f, -0.00130605f, -0.04320102f, 0.08930206f, 
    0.13281906f, 0.02891732f, 0.01487657f, 0.07616804f, 0.06523506f, 0.11652071f, 0.01802007f, 0.18516490f, 
    0.00108955f, -0.06435557f, 0.21755916f, -0.00954846f, -0.27266923f, 0.12802650f, 0.11621293f, 0.05257235f, 
    -0.06185307f, -0.05817524f, 0.03079411f, 0.05265315f, -0.04764693f, -0.07624343f, 0.27746469f, -0.24455562f, 
    -0.10080879f, -0.11470263f, -0.01461983f, 0.00269685f, -0.08704612f, 0.01716013f, 0.01125754f, 0.16908194f, 
    0.10167193f, -0.09098704f, -0.13182005f, 0.01689847f, 0.09219898f, 0.09376676f, -0.00502292f, -0.19406366f, 
    0.05955430f, -0.00003738f, 0.20024380f, 0.05478052f, 0.04378089f, -0.04231495f, 0.05567408f, 0.02265393f, 
    -0.04145046f, 0.05780400f, -0.23812145f, -0.11707970f, 0.05064846f, 0.00089174f, 0.13297871f, -0.00090778f, 
    0.10990586f, 0.08988009f, -0.14185970f, 0.00917234f, -0.05140828f, -0.02774498f, -0.20789993f, 0.00608515f, 
    0.03527535f, 0.06730035f, -0.13772336f, 0.01074765f, 0.10649676f, -0.04421869f, 0.06182382f, -0.12504421f, 
    0.04534434f, -0.04800017f, -0.04244545f, 0.11041016f, -0.25135747f, -0.04075897f, 0.04093614f, -0.01656912f, 
    0.15593497f, 0.08881677f, 0.15349965f, 0.05770349f, 0.02233266f, 0.18708892f, 0.26733828f, -0.06909899f, 
    -0.26377350f, -0.12496573f, 0.12338931f, -0.04178422f, 0.09676570f, 0.14839995f, -0.15299034f, -0.12933226f, 
    -0.17425016f, -0.14121835f, -0.16828279f, 0.02300243f, -0.02746841f, 0.07023585f, 0.25221658f, -0.02698974f, 
    0.28353217f, 0.16302504f, 0.02423707f, -0.15414962f, 0.00110193f, -0.01994245f, 0.03426369f, 0.14313982f, 
    0.08233593f, 0.08589818f, 0.01183587f, 0.00072430f, -0.01276018f, 0.02289777f, 0.03534374f, 0.05894613f, 
    0.22663166f, -0.10505623f, 0.27724859f, -0.03068719f, -0.11143237f, -0.10106956f, 0.09278142f, -0.04459501f, 
    -0.00224929f, -0.04915321f, 0.08536688f, 0.27465063f, -0.00070763f, -0.10853954f, -0.03151629f, -0.02748086f, 
    0.04209372f, 0.19354163f, 0.05719982f, 0.05076773f, 0.02574778f, 0.13719916f, 0.14960614f, -0.03013623f, 
    0.04323371f, 0.01935753f, -0.06084538f, 0.02724345f, 0.16824128f, 0.31700566f, -0.05799701f, 0.06897988f, 
    0.19384587f, 0.02215562f, 0.01036071f, -0.02623269f, 0.14388078f, -0.10171476f, -0.00465966f, 0.00097692f, 
    -0.11565567f, 0.01993408f, -0.13006130f, 0.04423827f, 0.13946417f, 0.06827232f, -0.07483905f, 0.03164161f, 
    0.02379269f, -0.00423840f, -0.02644073f, -0.04932795f, 0.23745672f, -0.03050948f, 0.01339230f, -0.06608251f, 
    -0.08845484f, 0.08982620f, 0.06777040f, 0.07268544f, 0.13858554f, -0.12977274f, -0.23993692f, -0.20129897f, 
    -0.15087913f, 0.20114669f, 0.06672692f, 0.05891800f, 0.01975431f, -0.09490837f, 0.06591775f, 0.16110714f, 
    -0.13834080f, -0.33764973f, -0.11830781f, -0.05178845f, -0.01847074f, 0.05227064f, 0.12618092f, -0.12646298f, 
    0.00491415f, 0.21942219f, -0.25894949f, 0.44445932f, 0.08638258f, 0.13441321f, 0.00212120f, -0.00603736f, 
    0.10626906f, 0.18106940f, 0.06716739f, -0.19510534f, -0.15094782f, -0.03086345f, -0.00829094f, 0.12819375f, 
    0.13892128f, -0.02983109f, 0.12525533f, -0.89917696f, 0.14541598f, -0.55233467f, 0.02028978f, -0.03739262f, 
    0.08576801f, 0.10604906f, -0.08469413f, -0.07569389f, -0.20284215f, 0.14643106f, -0.12082831f, 0.02344748f, 
    -0.02428545f, -0.07957378f, 0.09804200f, -0.13945849f, 0.23205021f, -0.17898804f, 0.35383812f, 0.00571772f, 
    0.09910031f, -0.07178093f, 0.06119360f, 0.00700756f, 0.04310621f, -0.04226235f, 0.34962958f, 0.30750224f, 
    0.01324019f, -0.01312347f, 0.02883436f, -0.12327004f, 0.12754487f, -0.09670171f, 0.13855264f, -0.06476866f, 
    -0.18116045f, 0.24006771f, -0.04834551f, -0.07969868f, -0.04095682f, -0.00089828f, 0.12844118f, -0.00678447f, 
    -0.05115216f, 0.15405610f, -0.08012352f, 0.04325949f, -0.09382931f, -0.26421022f, 0.04137383f, 0.12988396f, 
    -0.08050542f, 0.07523621f, -0.08150896f, -0.09507810f, -0.07382776f, 0.01891731f, -0.18418868f, 0.09962465f, 
    -0.01501086f, -0.12996548f, 0.01523331f, 0.07778170f, 0.01006318f, -0.11073653f, 0.00348021f, 0.02659610f, 
    -0.08447405f, 0.09784571f, -0.07990662f, 0.12595195f, 0.10033954f, 0.13312007f, -0.03727803f, 0.02869086f, 
    0.09015877f, 0.10440813f, 0.14052290f, 0.13240980f, -0.08738730f, 0.19627340f, 0.28119048f, -0.02707543f, 
    -0.10239138f, -0.05445351f, -0.05278135f, -0.10924487f, 0.11995342f, -0.02085900f, -0.40171459f, -0.34022444f, 
    -0.11114925f, -0.10985176f, 0.10686410f, 0.05444753f, -0.07607435f, 0.03136231f, 0.29452381f, 0.12146468f, 
    -0.00455851f, 0.11690025f, -0.03803677f, -0.09934366f, 0.00598726f, -0.05589664f, 0.05474323f, 0.01159992f, 
    -0.13545169f, -0.01058798f, 0.02581022f, 0.08931378f, -0.10770060f, 0.04449175f, 0.15124096f, -0.12918586f, 
    -0.14817181f, 0.15042207f, -0.02848116f, -0.03773313f, -0.11095432f, -0.07446741f, 0.09238798f, 0.05970030f, 
    -0.09759162f, -0.05372549f, -0.10994482f, -0.34314886f, 0.05381405f, -0.02083590f, 0.11098786f, -0.12280766f, 
    -0.07791528f, 0.02058201f, 0.01667585f, 0.24778111f, 0.22937645f, -0.18128338f, -0.17993359f, 0.02924629f, 
    0.00526045f, -0.02977882f, -0.05624732f, -0.06291365f, -0.16702028f, -0.20302668f, -0.02826235f, 0.07503673f, 
    0.03877481f, 0.06766162f, -0.01515638f, -0.19673504f, 0.26716983f, -0.09965268f, 0.10754433f, 0.02895866f, 
    0.05059901f, -0.11938405f, 0.12812705f, -0.10631574f, -0.09926754f, -0.10828535f, -0.47354111f, -0.66553235f, 
    -0.06173873f, -0.02716234f, 0.08593345f, -0.04181689f, 0.08711764f, 0.00199579f, 0.20769338f, -0.08761076f, 
    0.01779382f, 0.08697612f, -0.04148774f, 0.10508875f, -0.04053779f, -0.06594144f, 0.04986192f, -0.07778598f, 
    0.14418294f, 0.29161116f, 0.05434815f, 0.06906243f, -0.10942911f, -0.03977780f, -0.03971975f, 0.06418024f, 
    0.03198372f, -0.06674176f, -0.02008886f, -0.06622711f, 0.00117556f, -0.03996574f, -0.01902409f, 0.02193309f, 
    -0.04994481f, -0.03533603f, 0.01482550f, -0.04304673f, -0.00383281f, -0.06278744f, -0.02926330f, 0.00446448f, 
    0.02103897f, -0.02140816f, 0.02240749f, -0.01553348f, -0.04254720f, 0.04777031f, 0.03594073f, 0.00030279f, 
    -0.00982581f, 0.04918601f, 0.05217727f, -0.01961651f, 0.03045582f, -0.08138966f, 0.02795156f, -0.03508702f, 
    0.01005541f, 0.04085842f, -0.03963300f, 0.01237080f, 0.03812473f, 0.01272551f, 0.03371436f, -0.00025563f, 
    -0.03632003f, 0.04269107f, 0.02856800f, -0.00592656f, -0.06582122f, -0.04449116f, 0.01592985f, -0.00282659f, 
    0.04889597f, -0.01867049f, -0.02637492f, -0.00495522f, -0.05542828f, 0.00622969f, -0.02757348f, -0.05907842f, 
    -0.03571777f, 0.02756254f, -0.01668464f, -0.01637440f, -0.04292737f, -0.05612607f, -0.07877930f, 0.04056602f, 
    -0.05380371f, -0.05991662f, -0.03485677f, 0.02687483f, -0.02161706f, 0.01967008f, -0.02882665f, -0.02984635f, 
    0.03635236f, 0.01943991f, -0.03633899f, -0.00136309f, 0.01694313f, 0.07240272f, 0.02915542f, -0.02964954f, 
    0.06869451f, 0.05181551f, 0.00367709f, -0.03364422f, 0.04318644f, 0.02103932f, -0.04799275f, 0.03944436f, 
    0.01224349f, -0.03187377f, -0.03007153f, -0.06217295f, -0.04292983f, -0.06956349f, 0.05108745f, -0.04784001f, 
    0.04280502f, -0.04283834f, 0.02857400f, 0.05498563f, -0.08261149f, -0.04427276f, -0.00385453f, -0.00784956f, 
    -0.02036842f, -0.00881524f, 0.00377502f, 0.02978573f, 0.00376321f, -0.07125659f, 0.02265893f, 0.00117840f, 
    -0.00034831f, 0.00216061f, -0.03048053f, 0.02409102f, -0.05732398f, -0.04818735f, 0.04505731f, -0.02271491f, 
    -0.03587504f, 0.05145660f, 0.04262385f, 0.01856957f, -0.01807539f, 0.00843393f, 0.03632823f, -0.03517108f, 
    -0.07584639f, 0.04075891f, -0.04267895f, -0.05089748f, 0.00320500f, 0.03343500f, -0.05644800f, -0.03956651f, 
    0.05986969f, 0.04761732f, -0.04892911f, -0.03058488f, 0.00036244f, -0.04751848f, -0.01724434f, -0.03272292f, 
    -0.04909119f, -0.05073605f, -0.00859470f, -0.05050304f, -0.02723086f, -0.02156044f, -0.05180626f, 0.04237095f, 
    -0.01529779f, -0.03161396f, 0.01501734f, 0.00346817f, 0.02857111f, 0.04274714f, -0.03658998f, -0.04835139f, 
    0.01386103f, -0.05343359f, -0.00884352f, 0.03851733f, -0.03444624f, -0.02834203f, 0.03538666f, -0.08352694f, 
    -0.03842735f, 0.03731294f, 0.03016083f, 0.00119150f, -0.00159424f, 0.01773582f, 0.04097470f, -0.00208272f, 
    -0.06609908f, -0.03689153f, -0.06561170f, 0.02934202f, -0.06901109f, 0.01038359f, -0.02589805f, -0.03242537f, 
    0.02787166f, -0.02841497f, 0.04195086f, 0.00989689f, 0.02475053f, 0.02814142f, 0.01566294f, -0.00248356f, 
    -0.00075732f, 0.03062532f, -0.04391818f, 0.05995355f, 0.06464455f, 0.01593426f, 0.08430953f, -0.01200815f, 
    -0.04388518f, -0.04869303f, 0.02858605f, -0.02859638f, 0.00888489f, -0.03969440f, 0.02457380f, -0.04913398f, 
    -0.04891536f, -0.06869555f, -0.01206437f, -0.03933651f, -0.06415901f, 0.04686663f, -0.06919822f, -0.01104925f, 
    0.02561517f, 0.00500656f, 0.02132249f, 0.03119839f, 0.02984785f, 0.01468564f, -0.05277611f, -0.01366015f, 
    0.01112707f, -0.01471274f, -0.06670967f, -0.01867957f, -0.00070829f, -0.05886856f, -0.01548887f, 0.01740889f, 
    0.06357387f, 0.01257552f, -0.06947843f, 0.04590820f, 0.04546029f, -0.00242938f, 0.02151003f, -0.05382938f, 
    0.00914674f, -0.03764724f, -0.04960109f, -0.06284209f, -0.03044213f, -0.03036157f, 0.04851114f, 0.03423013f, 
    -0.02745352f, 0.04025750f, 0.01963564f, 0.03968291f, 0.02652255f, -0.03356576f, -0.02187409f, 0.07272564f, 
    -0.06975947f, 0.02706779f, -0.03533361f, 0.03511404f, 0.04190226f, -0.03901997f, -0.07637765f, 0.02678316f, 
    -0.05833947f, 0.04165652f, 0.02884295f, -0.02982965f, 0.03825445f, -0.02679111f, -0.02905775f, -0.00658711f, 
    0.02395024f, -0.03776852f, 0.00505766f, -0.04987089f, -0.05403127f, -0.06511459f, -0.01408709f, 0.00251387f, 
    -0.02203913f, -0.03142835f, 0.00944842f, -0.02391453f, 0.00026305f, -0.01329198f, 0.03790728f, 0.05061624f, 
    -0.29159150f, -0.10469957f, -0.20132230f, -0.26319870f, -0.06997819f, 0.05490793f, -0.21571662f, 0.04775529f, 
    -0.15388368f, -0.22812453f, -0.01352171f, -0.07015740f, 0.07061505f, 0.09558439f, 0.01159248f, 0.22227737f, 
    0.19925091f, -0.03021714f, 0.10668416f, 0.26619482f, 0.23775610f, 0.08409148f, 0.17310542f, -0.05273989f, 
    0.04044449f, 0.26031896f, -0.12718189f, -0.02663542f, 0.17877987f, 0.28053865f, -0.09455424f, 0.08099811f, 
    -0.11685771f, 0.16975033f, -0.02175271f, -0.26723111f, -0.35052159f, -0.17326400f, -0.18386351f, -0.10840613f, 
    -0.15703629f, -0.06028761f, 0.11366831f, 0.14051437f, -0.08765926f, 0.02032448f, -0.05089445f, -0.26469564f, 
    0.02632877f, 0.00449236f, 0.11295117f, 0.30103528f, 0.09520353f, 0.09683140f, -0.05742097f, -0.06441461f, 
    0.09440112f, 0.00673673f, 0.18087365f, 0.09178314f, -0.15031070f, 0.09361302f, 0.21191078f, -0.12391850f, 
    0.01134361f, -0.08972493f, 0.23990653f, 0.08238049f, 0.06225185f, 0.19494577f, -0.11232567f, -0.30866274f, 
    -0.06736163f, 0.24649531f, -0.14837286f, 0.14928304f, 0.03040855f, 0.08329529f, 0.13402794f, 0.20004484f, 
    0.07535683f, -0.02834557f, 0.02508574f, 0.21358426f, -0.14541502f, -0.04420732f, -0.07374922f, -0.06375960f, 
    -0.03759047f, -0.17181042f, -0.36344990f, -0.16936478f, -0.08089855f, 0.08087830f, -0.03049138f, -0.02393730f, 
    0.01100322f, 0.15471606f, 0.18398358f, -0.40351674f, 0.37012905f, 0.10513955f, 0.11225723f, 0.06010951f, 
    -0.17830847f, -0.07555743f, -0.00754692f, 0.26627025f, 0.02957928f, 0.14904360f, -0.17671220f, 0.16821262f, 
    0.07896079f, 0.03026326f, 0.20879629f, 0.13488671f, 0.13121998f, -0.01450992f, 0.16099551f, 0.27568540f, 
    0.17865175f, 0.04844223f, 0.03228634f, 0.05058517f, 0.04414509f, 0.14707424f, -0.16416861f, 0.10183035f, 
    -0.13950484f, 0.05688848f, 0.02714005f, 0.02637901f, 0.22156505f, 0.05399287f, 0.12295130f, -0.01927210f, 
    0.02551236f, 0.23292139f, 0.08408906f, 0.03035356f, 0.05729292f, -0.12245843f, -0.17501578f, -0.05070979f, 
    -0.38232818f, -0.02698497f, 0.01667821f, -0.34319866f, -0.09090126f, -0.00127460f, -0.04910820f, 0.02152631f, 
    0.09197417f, -0.16558973f, -0.26868954f, -0.04806262f, 0.05278426f, -0.08519670f, 0.04816435f, -0.04692338f, 
    -0.04501880f, 0.06714206f, -0.04707018f, -0.04415983f, 0.17668875f, -0.06611495f, -0.07715057f, 0.11643148f, 
    0.13554397f, -0.10370246f, -0.18613784f, -0.02218939f, 0.08070225f, 0.10652684f, -0.03463963f, 0.03639019f, 
    -0.02460176f, -0.11991734f, -0.13418405f, 0.11742453f, -0.36734426f, -0.11095830f, 0.07467765f, -0.19438531f, 
    -0.23491137f, -0.16037661f, 0.15374710f, 0.03405812f, 0.04641943f, -0.02056241f, 0.13162622f, -0.25012103f, 
    0.06699492f, 0.00023512f, -0.05426842f, 0.08585419f, 0.07949033f, 0.05546921f, -0.19073172f, -0.06638348f, 
    0.35768059f, 0.13317738f, -0.03408735f, 0.00166647f, 0.07578339f, -0.00555445f, -0.06740004f, 0.35741401f, 
    -0.00470666f, 0.25395870f, -0.06521027f, 0.02554476f, 0.20355433f, 0.08680262f, 0.11990257f, 0.04196156f, 
    -0.23196726f, -0.17761301f, -0.16399735f, 0.11287103f, -0.15840626f, -0.02626790f, 0.09229544f, -0.06100269f, 
    -0.03266209f, -0.13740249f, 0.23024546f, 0.00200062f, -0.02121273f, -0.03967344f, -0.02348176f, 0.25662705f, 
    0.10899697f, 0.03243868f, -0.38475299f, 0.04611883f, -0.05467811f, -0.31077650f, -0.07741336f, -0.13240173f, 
    -0.06975175f, 0.05200137f, -0.11889827f, 0.02985525f, -0.23924126f, -0.00214965f, -0.03782157f, 0.01723637f, 
    0.11053145f, 0.09247727f, 0.08093918f, 0.02256605f, -0.04556964f, -0.10392238f, -0.02036853f, -0.00254208f, 
    -0.00281406f, -0.18031819f, 0.03028150f, 0.11662298f, 0.00324271f, -0.30361569f, 0.27675769f, 0.15461807f, 
    0.13210285f, -0.01353013f, -0.13396059f, 0.19992945f, 0.07573030f, 0.14328770f, -0.23960085f, -0.02655164f, 
    0.36286384f, 0.06619606f, 0.11089559f, 0.15325309f, -0.02345640f, 0.08866332f, 0.12716155f, -0.10134190f, 
    0.13112864f, 0.10591178f, 0.02614808f, -0.11342543f, 0.10394735f, -0.04881727f, -0.12109191f, -0.07708946f, 
    0.04198938f, 0.02391990f, -0.03589593f, -0.03411018f, -0.02553307f, -0.03135598f, -0.01150151f, 0.04610832f, 
    -0.00973879f, 0.03004028f, 0.02872379f, 0.03540648f, 0.02219931f, -0.02094280f, -0.00702212f, 0.02958283f, 
    0.01435679f, -0.05227442f, 0.04815722f, -0.06850648f, -0.03417550f, -0.06879189f, -0.04491958f, -0.01863210f, 
    0.02936422f, -0.02319999f, 0.01034406f, -0.00699034f, 0.05609189f, -0.02807864f, 0.05731428f, 0.02971677f, 
    0.01874006f, -0.05741008f, -0.04813209f, -0.02259200f, -0.05413629f, 0.03550906f, 0.04660290f, -0.06527763f, 
    -0.06188083f, -0.00598674f, 0.02998666f, -0.06320432f, 0.02440811f, -0.04515528f, -0.04725381f, 0.04336401f, 
    0.03527122f, 0.03666691f, -0.01175079f, -0.00123160f, -0.00426541f, -0.02496498f, 0.03848568f, -0.02085304f, 
    0.04871575f, -0.03352138f, 0.03958738f, 0.00132678f, 0.04526685f, 0.00667315f, -0.03171190f, -0.03539558f, 
    0.01709144f, -0.06148483f, -0.05355827f, 0.00640415f, -0.00890588f, -0.02429748f, -0.01086518f, 0.01882508f, 
    0.00129252f, 0.03376334f, 0.05169891f, 0.05274909f, -0.06154952f, 0.02362755f, 0.01484112f, 0.01977025f, 
    0.00924129f, 0.03088470f, -0.01109162f, -0.06153660f, -0.02404117f, 0.05284172f, -0.02100979f, 0.00329356f, 
    0.04283458f, -0.06791854f, 0.05310746f, -0.02119546f, 0.02804191f, -0.03620949f, 0.04039009f, -0.05364674f, 
    0.01604149f, 0.02283574f, 0.04929936f, -0.02619034f, 0.00527455f, -0.00880256f, 0.01772285f, 0.00463604f, 
    -0.06340058f, -0.04030486f, -0.04423594f, 0.01883750f, -0.03760703f, 0.00930050f, 0.02031783f, -0.05882274f, 
    0.00175188f, 0.02088393f, 0.02577743f, -0.05684818f, 0.03086929f, 0.03466566f, 0.05014133f, -0.04550218f, 
    -0.02788301f, 0.00432535f, -0.01370782f, -0.04419379f, -0.01766934f, 0.00791725f, 0.00644255f, 0.00150296f, 
    0.03445505f, -0.04480816f, -0.05678124f, 0.02904746f, -0.05406387f, -0.03042768f, -0.00176800f, -0.06687023f, 
    0.03132850f, 0.00740564f, -0.00977265f, -0.04159721f, -0.00948270f, 0.00268624f, -0.02051710f, -0.03939949f, 
    0.01979216f, 0.00084328f, -0.03681915f, -0.02528996f, 0.01028220f, 0.00307699f, 0.03596979f, 0.02262071f, 
    -0.03098520f, 0.01510146f, -0.04589478f, -0.04840485f, 0.00185582f, 0.03010334f, -0.03636006f, -0.02622134f, 
    0.04026872f, -0.02492797f, -0.05430700f, -0.03729660f, -0.03419762f, -0.05569828f, -0.04719460f, -0.00691663f, 
    -0.01591994f, -0.00352838f, 0.02692717f, 0.03183335f, -0.05789179f, 0.03703528f, -0.05003421f, -0.06352989f, 
    -0.02565715f, -0.00760109f, 0.01849700f, -0.03673980f, 0.03532920f, -0.01105233f, 0.02596844f, 0.02702231f, 
    0.01439737f, -0.00409958f, -0.04640888f, -0.00015361f, -0.05405673f, -0.02335157f, -0.01509996f, 0.00784543f, 
    0.00485639f, 0.01310521f, -0.06643081f, 0.02572505f, -0.00081015f, -0.05166540f, 0.04201134f, 0.02520437f, 
    -0.05364041f, -0.05013114f, 0.01240227f, 0.00423231f, -0.03561150f, -0.00658685f, -0.01743969f, -0.02660004f, 
    -0.00599492f, 0.00524068f, 0.04504110f, -0.03879886f, 0.00803646f, 0.02255662f, 0.03505328f, 0.02581918f, 
    -0.01784243f, -0.03506747f, 0.02284501f, -0.04922581f, -0.02575276f, 0.01468747f, -0.03613112f, -0.01260316f, 
    0.00370115f, 0.04001084f, -0.05128074f, -0.03676835f, -0.04400042f, -0.03165484f, -0.00109685f, -0.02209665f, 
    -0.04521875f, -0.06564915f, 0.04860669f, -0.06765686f, 0.04751347f, -0.00451919f, -0.02261944f, -0.02592932f, 
    -0.01169582f, 0.03856380f, -0.00633326f, 0.01926217f, 0.00244169f, -0.05990994f, 0.04285498f, 0.00557929f, 
    -0.06844888f, 0.00357512f, 0.02792278f, -0.02893982f, 0.01871163f, -0.04767707f, 0.03846604f, 0.01687837f, 
    -0.01864993f, 0.02605567f, -0.04275201f, -0.04196919f, 0.00907921f, -0.05895855f, 0.02947404f, -0.01611446f, 
    -0.03419494f, 0.02727471f, 0.02821166f, -0.04289286f, -0.02571867f, 0.04701100f, -0.00148316f, -0.01208287f, 
    0.00253042f, -0.06641106f, -0.01706063f, 0.02349292f, 0.03793065f, 0.01375727f, 0.03521834f, 0.03492953f, 
    -0.05366611f, -0.06234015f, -0.04824927f, -0.04709049f, 0.02708648f, 0.03931346f, 0.04209436f, -0.03617311f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.09580525f, 0.19460113f, 0.00801320f, 0.15635565f, 0.04613565f, -0.05977371f, 0.21965884f, -0.00438143f, 
    -0.04118891f, 0.05278572f, 0.02726605f, 0.06336053f, 0.06675783f, 0.24945860f, 0.01414967f, 0.04232461f, 
    0.10591644f, 0.03053218f, 0.04984126f, -0.06300227f, 0.03878248f, 0.07034898f, -0.03986007f, 0.02822788f, 
    0.17189172f, 0.08241607f, 0.04245707f, 0.07541928f, 0.10543179f, -0.02233480f, 0.17512295f, -0.03555511f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.03758098f, 0.20580116f, 0.03204767f, 0.32332417f, -0.11419889f, -0.15635045f, -0.03494384f, 0.12367095f, 
    -0.01630004f, -0.07689721f, -0.19300458f, -0.33106118f, 0.17462026f, 0.03253908f, 0.20859355f, 0.04974781f, 
    -0.26689419f, -0.10253552f, -0.03065876f, 0.10039180f, 0.03745204f, 0.16817749f, -0.08977547f, -0.03727836f, 
    0.30881810f, 0.05597141f, -0.04770793f, 0.18050712f, -0.04998921f, 0.12933037f, -0.06535092f, 0.00132041f, 
    -0.25070953f, -0.00565430f, -0.46411216f, 0.35931921f, -0.04209279f, 0.14784710f, 0.48201585f, -0.09519340f, 
    -0.04967707f, -0.02073250f, 0.04743048f, -0.04249228f, 0.06125977f, -0.03015639f, -0.13492604f, -0.02605523f, 
    0.03998205f, 0.16543178f, 0.04214989f, 0.14545776f, -0.19719715f, -0.08868641f, -0.15859438f, -0.05510247f, 
    -0.08595664f, 0.44614807f, 0.02717980f, 0.01499675f, 0.04201815f, -0.17523496f, 0.14217861f, -0.05626553f, 
    0.25011504f, -0.32068205f, 0.36183381f, 0.10146692f, 0.16391747f, 0.18162796f, 0.33861187f, -0.12284891f, 
    0.23717988f, 0.04844888f, 0.11786035f, 0.48679143f, 0.26388922f, -0.15689102f, -0.06611563f, -0.10818355f, 
    0.02922558f, -0.16367409f, -0.07338790f, -0.08791603f, -0.15384199f, -0.35810542f, -0.04920400f, 0.18262206f, 
    0.22722436f, -0.12065758f, -0.06411727f, 0.06797505f, 0.60347682f, 0.18121114f, -0.18569599f, -0.05590312f, 
    -0.19254161f, 0.03684771f, 0.02784419f, 0.14730106f, 0.05867248f, 0.03060404f, -0.07293691f, -0.04913214f, 
    0.06507596f, 0.14010417f, -0.10324031f, -0.00638637f, -0.02915291f, -0.01987657f, -0.16512243f, -0.01421943f, 
    0.06509193f, 0.06835432f, -0.08785584f, 0.03869325f, 0.07119663f, 0.07267123f, -0.00004150f, -0.08783472f, 
    -0.06265195f, -0.10866990f, -0.15867756f, -0.10466627f, -0.09354576f, -0.02891039f, 0.08234955f, 0.00922864f, 
    0.22888792f, -0.19087876f, 0.06031610f, -0.59600312f, -0.12805185f, 0.12554629f, -0.17704959f, -0.01289473f, 
    0.11733431f, 0.06919950f, 0.05595127f, -0.15647304f, 0.12243912f, 0.42577493f, -0.02379524f, -0.08710305f, 
    0.03619941f, -0.00229037f, -0.13513328f, -0.03188857f, -0.02708008f, 0.04730461f, 0.17771479f, -0.13532732f, 
    0.26950875f, -0.43507820f, -0.00473062f, 0.40833578f, 0.21176735f, 0.09196021f, 0.01949887f, -0.10100851f, 
    0.26157382f, 0.03853787f, 0.31089848f, 0.00536525f, 0.08209209f, -0.14003305f, -0.30607483f, 0.10569873f, 
    0.21073200f, -0.03000473f, 0.04722160f, -0.24761331f, 0.10578719f, -0.20283663f, 0.20281830f, -0.09320882f, 
    -0.12732786f, -0.13520208f, 0.01516519f, 0.16762219f, -0.10942517f, -0.20771250f, -0.00053405f, -0.13347647f, 
    0.15034938f, 0.03708179f, 0.13454376f, 0.17055966f, -0.01164612f, 0.14282575f, 0.12850052f, 0.02164877f, 
    -0.20830353f, 0.30326071f, -0.02596415f, 0.02405247f, -0.12796135f, -0.14647338f, 0.04103172f, 0.00966948f, 
    -0.16446532f, -0.06231758f, -0.05363193f, -0.05547758f, -0.13399759f, -0.12312310f, 0.15480196f, 0.12786753f, 
    -0.10783884f, 0.00060252f, -0.04068694f, -0.07242481f, 0.14439023f, 0.04603282f, -0.10915245f, -0.02814998f, 
    0.26640168f, 0.21812162f, 0.10125440f, 0.36077073f, 0.12447941f, -0.02573496f, 0.06829023f, 0.07676691f, 
    -0.00105676f, -0.12355311f, -0.12279904f, -0.10528470f, -0.00531114f, -0.08515847f, -0.11530484f, -0.11335056f, 
    -0.16040844f, -0.13867885f, -0.11221443f, 0.03182504f, 0.09719598f, 0.04937293f, -0.06567425f, 0.06063602f, 
    -0.15915596f, -0.16585138f, -0.04978603f, -0.00467590f, 0.12550609f, -0.08500206f, -0.07555642f, -0.09147817f, 
    -0.02588351f, -0.02689103f, -0.09263837f, -0.14892489f, -0.02652384f, 0.13400719f, 0.10257953f, -0.02019045f, 
    -0.18050185f, 0.27681568f, -0.18668994f, -0.16124970f, -0.17310277f, -0.09480632f, 0.20425728f, -0.00269647f, 
    0.01682996f, -0.16122256f, -0.00260516f, -0.33850563f, -0.13234520f, 0.07247590f, 0.12938406f, -0.07169557f, 
    0.31369498f, 0.14151892f, -0.11621693f, -0.09818655f, 0.15631981f, 0.07160268f, -0.01258274f, 0.09859185f, 
    0.18410319f, -0.12024052f, -0.16952816f, -0.15047130f, -0.03626960f, 0.03227658f, 0.29688287f, -0.08127175f, 
    0.09126092f, 0.20641476f, -0.26778367f, 0.36629513f, 0.13686058f, -0.11593898f, -0.09562001f, 0.03109240f, 
    -0.12342525f, 0.09926960f, -0.00959889f, -0.29091486f, 0.22249383f, -0.16187820f, 0.07712017f, -0.06382128f, 
    0.04346057f, -0.07036994f, 0.15970613f, 0.15819773f, -0.06596380f, -0.05563796f, 0.10461247f, -0.18970601f, 
    -0.07980739f, 0.46442628f, 0.01738360f, -0.09705708f, -0.12022329f, 0.13520709f, 0.18494640f, 0.02369792f, 
    0.33950365f, 0.16448203f, 0.28071466f, 0.36506480f, 0.04601151f, -0.01973712f, 0.29001412f, 0.00050494f, 
    0.00664497f, 0.13201004f, -0.23936138f, -0.02499208f, 0.32245627f, 0.05217375f, -0.08697215f, -0.14717324f, 
    -0.24945655f, -0.14451459f, 0.17069082f, -0.00974182f, 0.07014036f, 0.02999038f, 0.07558662f, 0.37613824f, 
    0.02606477f, 0.03857175f, 0.14386153f, 0.24496461f, -0.00737569f, 0.13755234f, -0.19419207f, -0.05974254f, 
    0.20768598f, 0.33132035f, -0.03566910f, 0.13615967f, -0.06237914f, -0.00803636f, 0.24340366f, 0.06065998f, 
    0.04957462f, 0.07370657f, -0.28306523f, 0.35762569f, -0.29289889f, 0.11812142f, 0.15766107f, -0.25960210f, 
    0.04889000f, -0.06065581f, -0.17524679f, 0.00309302f, 0.09838925f, -0.24345736f, 0.17979878f, -0.07130848f, 
    0.28721020f, 0.09079417f, 0.14488016f, 0.06572495f, 0.25426653f, -0.14155076f, 0.04177668f, 0.11272769f, 
    0.18919764f, 0.11924703f, -0.39197850f, 0.35713699f, -0.07659357f, 0.14037512f, -0.02885315f, -0.08577575f, 
    0.07891878f, -0.01072998f, 0.16243301f, -0.33232057f, 0.00693015f, 0.35077593f, 0.07529043f, -0.23922724f, 
    -0.14488472f, -0.14473602f, 0.16103661f, 0.04010261f, 0.13307327f, 0.15313111f, -0.07548930f, -0.02474963f, 
    -0.02473447f, -0.29198930f, -0.14421856f, -0.17824358f, 0.09584506f, 0.14514033f, 0.20082919f, 0.18104318f, 
    0.15556096f, 0.17968859f, 0.32154417f, 0.41603798f, -0.01635782f, -0.07233981f, 0.31948131f, 0.07561880f, 
    0.07039060f, -0.09090072f, -0.21521582f, -0.17311226f, 0.34439376f, 0.06039338f, 0.12764464f, -0.12491220f, 
    -0.22739299f, 0.01616728f, 0.12780552f, -0.10007527f, -0.13024250f, 0.19332737f, -0.07830314f, 0.13487704f, 
    0.00416880f, 0.24042602f, -0.13572621f, -0.33789703f, 0.30066702f, 0.05456045f, -0.02474889f, -0.04259609f, 
    0.12764794f, 0.29461309f, 0.23886523f, 0.19096297f, 0.13044316f, 0.07278682f, 0.38745463f, 0.14133038f, 
    -0.05922310f, 0.00195318f, -0.04160456f, -0.09433838f, 0.34568009f, 0.05239698f, -0.00674867f, 0.01345655f, 
    0.26981336f, 0.17685403f, 0.04873018f, 0.15450810f, 0.05289178f, 0.03743691f, -0.05067556f, 0.04768947f, 
    -0.28947753f, 0.03483218f, -0.08053769f, -0.33687842f, -0.26837721f, -0.13697746f, -0.19323675f, -0.13185199f, 
    0.13762726f, 0.30641127f, -0.17383453f, -0.25572354f, -0.00469200f, -0.02707814f, -0.07948056f, 0.05502427f, 
    -0.21321402f, 0.11702001f, 0.18783933f, 0.13096750f, 0.12772422f, 0.18905592f, -0.08598563f, 0.15979734f, 
    0.03328533f, 0.01042043f, 0.12877227f, 0.05441882f, 0.13807710f, 0.25232041f, 0.01711627f, -0.22061007f, 
    -0.20052594f, -0.44134745f, -0.03898944f, -0.27473062f, -0.58480430f, 0.09077469f, 0.17280927f, 0.13774194f, 
    0.12924188f, 0.05082686f, 0.17136951f, 0.17277893f, -0.09362860f, -0.12376552f, 0.15249464f, 0.02951835f, 
    0.09155227f, 0.15979634f, 0.03732469f, 0.03828435f, 0.13939282f, -0.02193539f, 0.20099036f, -0.17867368f, 
    -0.28214151f, 0.05670121f, 0.07232022f, 0.05986167f, 0.07591305f, 0.13690189f, -0.07303435f, 0.18045115f, 
    0.18321194f, -0.21433850f, -0.03974326f, -0.16957216f, 0.28496271f, 0.13945819f, -0.23504515f, -0.15064742f, 
    0.04353590f, -0.16043821f, -0.10281824f, -0.09758379f, -0.00055012f, -0.17525657f, 0.08182886f, -0.07199651f, 
    0.10668126f, 0.04287487f, -0.12706824f, -0.17236306f, -0.14821139f, 0.04799589f, -0.07136744f, -0.08138184f, 
    -0.00092483f, 0.05175496f, -0.06092934f, -0.16216573f, 0.09080757f, -0.11018495f, 0.13713016f, -0.11393609f, 
    0.08923079f, 0.08966374f, -0.01448166f, -0.09379815f, -0.17233554f, -0.16033091f, 0.10908857f, 0.02874828f, 
    0.16756974f, -0.33501741f, 0.12671849f, 0.04711609f, -0.07957732f, 0.01534208f, -0.08487449f, -0.14689943f, 
    0.26531735f, -0.08727679f, -0.05238013f, -0.05147968f, 0.36466771f, 0.07581143f, -0.15191476f, -0.10578797f, 
    -0.04313322f, -0.04913431f, -0.09083436f, -0.13812944f, -0.16187721f, 0.00151699f, -0.06941409f, -0.25369892f, 
    0.27633241f, -0.29861426f, 0.11145959f, -0.41772008f, -0.08693753f, -0.06025326f, 0.08151442f, -0.11655743f, 
    -0.37182853f, 0.00742481f, -0.05259413f, 0.00295053f, 0.08958309f, 0.10237551f, -0.43516457f, -0.15954061f, 
    -0.44675645f, 0.10048994f, 0.20138875f, 0.33014071f, 0.12009335f, 0.15394638f, -0.50312454f, 0.18332599f, 
    0.33208638f, -0.12241607f, 0.06952024f, 0.09981211f, 0.06462265f, -0.21647412f, 0.09740411f, 0.24800855f, 
    0.13210319f, -0.29344076f, -0.03579871f, 0.19547486f, 0.27449682f, 0.05534545f, 0.10927624f, 0.08290099f, 
    -0.19492486f, 0.04456560f, -0.00536054f, -0.26785725f, 0.10181575f, 0.13249627f, -0.03360590f, -0.05452323f, 
    -0.35640180f, -0.14476961f, 0.15302333f, -0.75738317f, -0.11634614f, -0.09057161f, -0.08144911f, 0.02229544f, 
    0.34143987f, -0.07989699f, -0.14082673f, 0.11282600f, 0.16880339f, 0.04214675f, 0.02592289f, 0.03408078f, 
    0.20386295f, 0.12175953f, -0.03208084f, 0.58737504f, 0.30633801f, 0.04427483f, 0.15686955f, 0.05791510f, 
    -0.22236186f, -0.29538935f, -0.14889614f, 0.01301430f, 0.07904685f, 0.03500447f, -0.21936443f, 0.02875309f, 
    -0.11558635f, 0.11101523f, -0.14326349f, 0.12335613f, 0.17293125f, -0.19396105f, 0.20511660f, 0.14582975f, 
    -0.14371835f, 0.09602621f, 0.03780932f, 0.10936628f, -0.02217752f, 0.16962738f, -0.11196387f, -0.13539137f, 
    -0.03233103f, -0.00470847f, 0.04422436f, 0.21320505f, 0.12312368f, 0.00187203f, -0.25251552f, 0.02750796f, 
    0.00356762f, -0.12820654f, -0.14269526f, -0.16341870f, -0.14167956f, 0.17365299f, -0.16507277f, -0.07930477f, 
    0.03089619f, -0.08235479f, 0.07375281f, 0.14380525f, -0.11170202f, -0.17872351f, -0.02808041f, -0.09748826f, 
    -0.05907004f, -0.07992470f, -0.17137335f, 0.12227987f, -0.00225160f, -0.00280812f, -0.15788965f, -0.14565034f, 
    -0.09289557f, 0.04172663f, -0.08169551f, 0.14118567f, 0.12479910f, -0.13224566f, -0.08935234f, 0.05717685f, 
    0.22965686f, -0.14298134f, -0.30512637f, -0.44967923f, -0.07091115f, 0.06154534f, 0.49303430f, 0.17026833f, 
    -0.04906439f, -0.16651514f, -0.07655752f, 0.07531366f, -0.10391394f, -0.08599542f, 0.29859719f, -0.22599693f, 
    0.11766136f, -0.03849293f, 0.03001465f, -0.14757104f, 0.02999416f, -0.26119092f, -0.15896119f, -0.05903359f, 
    0.22997604f, 0.07267035f, -0.01790574f, 0.07681026f, 0.19749109f, 0.16932426f, 0.31231090f, 0.14163464f, 
    0.22220251f, -0.30480203f, 0.15803967f, -0.38546008f, -0.07989662f, 0.14567408f, -0.26264399f, 0.17141892f, 
    0.09929394f, 0.07689061f, 0.11901904f, 0.09258017f, 0.47561067f, -0.22091830f, 0.02696518f, -0.12208086f, 
    -0.07417042f, -0.00099871f, 0.05885127f, -0.15745533f, -0.00404166f, -0.04783193f, -0.07157753f, 0.13366061f, 
    -0.10947512f, -0.18471216f, -0.11123307f, -0.09057485f, -0.31151015f, -0.06194279f, 0.12208939f, -0.01754234f, 
    0.04643885f, -0.09809010f, -0.40598592f, -0.01590384f, -0.04981003f, -0.16442075f, 0.55157721f, 0.02401532f, 
    -0.09835558f, 0.04472293f, 0.20735289f, -0.21703181f, 0.05897850f, 0.22599488f, -0.08599809f, -0.51673019f, 
    0.35687149f, 0.06003893f, 0.17111595f, 0.12387182f, 0.01614574f, -0.04930673f, 0.03716479f, 0.21676621f, 
    0.08760770f, -0.09390879f, -0.11040199f, -0.18283041f, 0.17414403f, 0.00140412f, 0.02780522f, -0.04743152f, 
    0.24963932f, -0.07886172f, 0.37502921f, -0.16771190f, 0.00725467f, 0.05376985f, -0.14540835f, 0.10054140f, 
    0.14979972f, -0.05786092f, -0.16041368f, -0.32220945f, 0.36497083f, 0.21721151f, 0.13738137f, -0.19954267f, 
    -0.02904801f, 0.02434200f, 0.15887547f, -0.05101534f, 0.04493881f, -0.13505293f, 0.08560961f, -0.24126893f, 
    -0.13470116f, 0.14025533f, -0.08440507f, -0.26787063f, -0.51322043f, 0.09164142f, -0.01260455f, -0.15076789f, 
    -0.06689236f, -0.43946365f, 0.38555983f, -0.34456587f, -0.15376560f, 0.15941204f, 0.08603215f, -0.12846830f, 
    -0.00066066f, -0.08084717f, 0.16693343f, 0.30819365f, 0.12321480f, -0.03396969f, -0.38893393f, -0.20168930f, 
    0.20941497f, 0.04246771f, -0.10592008f, -0.10541075f, 0.14996611f, -0.41057321f, -0.11797982f, 0.32240394f, 
    0.10847361f, -0.05827227f, 0.08036637f, 0.42147419f, 0.40439168f, 0.13202532f, -0.05885226f, -0.02664236f, 
    -0.05004659f, -0.15491313f, -0.08329534f, 0.12007716f, 0.12473136f, 0.12625538f, -0.14640744f, 0.02856475f, 
    -0.14955311f, -0.02295391f, 0.10395165f, -0.14994234f, -0.07366221f, -0.00755002f, 0.13696606f, 0.03472791f, 
    -0.00486054f, -0.00540240f, 0.00752745f, -0.17440462f, -0.12208483f, -0.09392147f, 0.15885544f, -0.06325860f, 
    -0.11038473f, -0.01664205f, 0.10024520f, -0.07044739f, -0.06348891f, 0.16274266f, -0.07393738f, 0.16974303f, 
    -0.33344454f, 0.11776973f, 0.21123824f, 0.44962305f, -0.14398813f, 0.09740072f, 0.22252217f, -0.09565419f, 
    -0.20716389f, -0.11646076f, 0.04607442f, 0.08180737f, -0.09882856f, -0.13235159f, -0.07828037f, 0.15741682f, 
    0.07453690f, -0.15999885f, -0.18465483f, -0.10582216f, -0.14249176f, -0.15387164f, 0.14287789f, 0.38173494f, 
    0.25630990f, 0.23767564f, -0.12558059f, 0.34508461f, 0.20138633f, -0.08382225f, -0.22929171f, 0.14197105f, 
    -0.38196474f, -0.13983454f, 0.06842709f, -0.13671207f, 0.11164190f, 0.04965305f, -0.29964778f, -0.03011107f, 
    -0.29935524f, -0.02245765f, 0.25517952f, -0.27584991f, 0.03404541f, 0.27603453f, -0.29153773f, 0.04829929f, 
    0.21771909f, -0.15641916f, 0.13693111f, 0.00096904f, -0.01690246f, 0.21060948f, 0.07689929f, 0.19987822f, 
    0.16340077f, -0.16313052f, 0.16990522f, -0.08844693f, 0.23516452f, -0.08370819f, 0.25109041f, -0.16007446f, 
    0.00655395f, 0.05420776f, 0.44036120f, 0.23726001f, 0.07871766f, -0.11121759f, -0.28721449f, -0.11284093f, 
    0.11965577f, 0.03018544f, -0.08820244f, 0.52773488f, 0.18923837f, 0.25478065f, -0.09715594f, -0.11523736f, 
    0.03477574f, -0.08788466f, 0.12696481f, 0.18010277f, -0.03799068f, -0.17946838f, -0.10650118f, -0.10031146f, 
    0.20665598f, 0.10028955f, -0.00324338f, -0.42309070f, 0.51395631f, -0.04075668f, -0.15390384f, -0.08298804f, 
    -0.17710049f, -0.07553613f, -0.00161037f, 0.02664211f, -0.13369611f, 0.15622856f, 0.12752105f, -0.04875747f, 
    0.04736052f, 0.13394070f, -0.09799512f, 0.04533703f, -0.06526159f, 0.06169264f, 0.01546837f, -0.16038722f, 
    -0.09175885f, 0.01093811f, 0.01950698f, -0.12052947f, -0.11337149f, 0.03303263f, 0.03294999f, -0.16584784f, 
    -0.14046150f, -0.05327585f, 0.14507012f, -0.06538605f, 0.00212287f, 0.00978202f, -0.15468407f, -0.02245761f, 
    0.02636261f, 0.20441990f, -0.25397086f, 0.53580087f, -0.06116638f, 0.07583531f, 0.34646416f, 0.12330985f, 
    0.09499427f, -0.11670759f, -0.19883035f, 0.13782136f, -0.11724085f, 0.04705914f, -0.08228542f, -0.00720455f, 
    0.04921287f, -0.06296951f, -0.06707461f, -0.04236535f, 0.00665091f, 0.04110865f, -0.13528366f, 0.24324059f, 
    -0.14449756f, 0.39938024f, 0.12236891f, 0.10993294f, 0.23036736f, 0.05422347f, -0.23961534f, -0.09748070f, 
    -0.46540156f, -0.30486390f, -0.32112661f, -0.16863270f, -0.13132502f, -0.05531751f, -0.32681519f, 0.14138395f, 
    0.06728561f, 0.09806138f, -0.25352991f, 0.18343320f, -0.43789312f, 0.00334801f, 0.12002754f, -0.04978663f, 
    0.20807686f, 0.15441243f, 0.16905653f, -0.11589134f, 0.00288095f, 0.09256542f, 0.00060883f, 0.13370092f, 
    -0.33019319f, 0.20313194f, 0.14298864f, -0.29181588f, 0.12228882f, 0.09630375f, -0.11072829f, 0.13278374f, 
    0.00478271f, 0.24230489f, -0.04847621f, -0.32060662f, 0.10157937f, -0.10069349f, 0.31164652f, 0.14528486f, 
    -0.07111198f, -0.02929332f, 0.00823446f, 0.10524416f, -0.14371352f, 0.31126598f, 0.15400660f, 0.03807093f, 
    0.23954658f, 0.11120753f, -0.13404843f, 0.09144910f, 0.15792087f, -0.14325987f, -0.03436089f, 0.08355699f, 
    -0.08870384f, -0.03681104f, 0.08304106f, -0.14370833f, 0.19027443f, -0.02856970f, -0.00448146f, -0.14238836f, 
    0.02021846f, -0.28388309f, -0.23529814f, 0.13832857f, -0.04278466f, -0.06148720f, 0.21356027f, -0.18061697f, 
    -0.06737196f, -0.07761645f, 0.08800504f, 0.24089430f, 0.17788886f, 0.16927834f, -0.06421267f, -0.09409735f, 
    -0.06540236f, 0.17816561f, 0.17314069f, 0.05753246f, 0.05070255f, -0.03249007f, 0.11670883f, 0.08286215f, 
    -0.10824075f, 0.08472224f, -0.04717874f, -0.11292798f, -0.19304486f, 0.04871899f, 0.29094666f, -0.07442840f, 
    0.10530914f, -0.00095292f, -0.17980342f, -0.05700213f, -0.17063972f, -0.09979151f, 0.12134410f, -0.10928188f, 
    0.03245563f, -0.03851556f, -0.07012005f, 0.10026599f, 0.06427419f, -0.14768447f, -0.14559934f, -0.18480772f, 
    0.05786341f, -0.16945893f, 0.13983506f, 0.06498469f, -0.00447522f, -0.16219744f, 0.01793630f, -0.22402325f, 
    -0.11209143f, 0.05770267f, 0.09069166f, 0.06149424f, -0.03934836f, 0.15364148f, 0.03302576f, 0.07788794f, 
    -0.09840813f, 0.17286322f, 0.27106640f, -0.12680560f, -0.13988857f, -0.15581726f, 0.01654518f, 0.10509873f, 
    -0.22290829f, 0.06318139f, -0.06090783f, 0.04747558f, 0.35317591f, -0.03406400f, -0.23801363f, 0.22265840f, 
    -0.05607852f, 0.00369632f, 0.12141723f, -0.06440420f, -0.18528162f, 0.15696922f, -0.08832180f, 0.23332144f, 
    0.22028518f, -0.13127147f, -0.10942883f, -0.32924724f, -0.46608293f, 0.03934357f, 0.12103399f, -0.03228465f, 
    0.10412937f, 0.28449604f, -0.04630500f, 0.04982462f, -0.11274043f, 0.13286522f, 0.33540809f, -0.10644463f, 
    -0.36553496f, 0.13908067f, -0.10511195f, -0.15047580f, -0.19570246f, -0.03121696f, 0.07992456f, -0.10871510f, 
    -0.09445976f, -0.15993397f, 0.08488858f, -0.15986358f, -0.01314501f, 0.11137351f, -0.02589018f, -0.31924796f, 
    0.42570916f, -0.04111961f, -0.11231595f, 0.03187533f, -0.22262019f, -0.18493037f, 0.28732622f, 0.08103935f, 
    0.12346289f, 0.22741762f, -0.37929860f, 0.01930018f, 0.03840882f, 0.10708081f, 0.08952211f, -0.10404777f, 
    -0.40698916f, -0.00105342f, 0.12378249f, 0.01660496f, 0.18414803f, 0.31089073f, -0.10177960f, -0.51209247f, 
    0.11601509f, 0.08016837f, -0.03380248f, 0.12059198f, -0.12864962f, 0.51655746f, 0.01117746f, -0.01875160f, 
    -0.34704414f, -0.19837587f, -0.15492450f, 0.05311794f, -0.19043484f, 0.13210337f, 0.24881050f, -0.15917835f, 
    -0.23833853f, 0.17063373f, -0.28231695f, -0.33846167f, 0.16155031f, 0.15562685f, -0.17396715f, 0.15290733f, 
    -0.25053957f, 0.02913956f, 0.28206587f, -0.07530072f, -0.01905328f, -0.05642124f, -0.04800214f, 0.10979484f, 
    0.31369177f, 0.10587168f, 0.04894729f, -0.16674985f, 0.06271103f, -0.13376062f, 0.08133296f, 0.04475591f, 
    0.13511224f, 0.10196342f, 0.00279130f, 0.24712352f, -0.13093741f, 0.12603079f, 0.16706425f, -0.04154724f, 
    0.02950274f, 0.29399163f, 0.27907631f, 0.17482635f, 0.15212430f, -0.10571095f, -0.15160902f, -0.11993111f, 
    -0.17275451f, 0.04722436f, -0.14875786f, 0.29861104f, 0.37707087f, -0.27813280f, -0.03307752f, 0.21445535f, 
    -0.01490835f, -0.05654092f, 0.05652007f, -0.12833641f, 0.04378487f, -0.09507592f, 0.09728851f, 0.06242545f, 
    0.12646370f, 0.02768868f, -0.09883887f, 0.00121107f, -0.22143313f, 0.15593792f, -0.11808889f, -0.05735491f, 
    -0.27847153f, 0.06612247f, 0.36311603f, -0.02331509f, 0.05151917f, 0.13383420f, 0.15025797f, 0.11980478f, 
    -0.21023810f, -0.03334884f, -0.03023862f, -0.01029927f, -0.10838496f, -0.03435896f, -0.00863893f, 0.22959685f, 
    0.27891833f, 0.15572658f, 0.03260203f, -0.10088236f, -0.14258438f, 0.01991214f, -0.17913301f, 0.21232821f, 
    0.02516939f, 0.43958610f, 0.00047013f, 0.14053632f, -0.09223164f, -0.05504880f, -0.04301601f, -0.07015070f, 
    0.02150236f, 0.06657033f, -0.04756549f, 0.12321773f, -0.01187991f, 0.10207070f, 0.03935594f, -0.01253694f, 
    0.03031337f, 0.03660611f, -0.03879401f, 0.12220882f, 0.02538023f, -0.16773732f, 0.11316993f, -0.11757075f, 
    -0.14906643f, 0.03340074f, -0.08854721f, -0.11136066f, -0.04055811f, -0.16854964f, 0.09127401f, -0.18926905f, 
    0.00912561f, -0.00807504f, 0.08831956f, 0.03308763f, -0.02182385f, 0.12609877f, -0.12776662f, 0.14642039f, 
    0.10460193f, -0.00236331f, -0.07400119f, -0.45963335f, 0.02975166f, 0.11221413f, -0.28901193f, 0.13511661f, 
    -0.16302620f, 0.04123066f, 0.03162831f, 0.06328941f, 0.02050829f, 0.24479520f, 0.10402332f, -0.19054575f, 
    0.04890384f, -0.15526445f, -0.02704960f, 0.03087150f, -0.02553327f, -0.12012299f, -0.05338727f, -0.33069852f, 
    0.09838343f, -0.26570728f, 0.03498441f, 0.12809721f, -0.50531369f, -0.14837657f, 0.34658834f, -0.00343192f, 
    0.15647952f, 0.00214975f, 0.35438502f, -0.20198998f, 0.07628192f, -0.08043272f, -0.05396815f, 0.09100162f, 
    0.15852650f, -0.06564587f, 0.24805671f, 0.34799755f, -0.16760832f, 0.28634480f, -0.15049429f, 0.03987916f, 
    0.06043635f, 0.11838979f, -0.16645721f, -0.16169477f, 0.00315637f, 0.00644218f, -0.04933179f, -0.05787494f, 
    0.04547013f, -0.12944636f, 0.14431313f, -0.15542471f, 0.31245598f, 0.06074512f, -0.24696815f, -0.04916795f, 
    0.10561154f, -0.03168049f, 0.12292412f, -0.11252856f, -0.15456720f, -0.16326191f, 0.17778356f, -0.17996772f, 
    -0.01104124f, -0.11004152f, 0.06558749f, 0.29432654f, -0.29393396f, 0.06140841f, 0.07884631f, 0.01284132f, 
    -0.24363613f, -0.11324279f, -0.00752752f, 0.14671896f, -0.15386167f, -0.27667588f, 0.08522253f, 0.26056856f, 
    0.25688693f, -0.19066831f, -0.18191893f, 0.22064719f, 0.31158713f, 0.09701091f, 0.07669352f, -0.11897854f, 
    0.05846001f, 0.14280407f, 0.13508466f, -0.18433307f, 0.12940398f, 0.13744697f, 0.38655633f, -0.04088269f, 
    -0.03539421f, -0.06337650f, -0.15107267f, -0.13399394f, -0.03748860f, -0.14191541f, 0.14329539f, 0.02945112f, 
    -0.16301617f, -0.12371033f, 0.00453389f, 0.00704863f, -0.07523685f, -0.09262218f, 0.12562178f, 0.11569230f, 
    0.32550675f, 0.23881464f, -0.07622220f, 0.25966695f, 0.10291615f, -0.16227035f, 0.00381841f, 0.04693627f, 
    -0.21302766f, -0.02713854f, 0.04484165f, -0.04405574f, 0.01385230f, 0.15518001f, 0.20093144f, 0.07112671f, 
    0.12019291f, -0.03591615f, -0.18749721f, 0.13713446f, -0.18663660f, -0.18355468f, 0.10701425f, 0.18799706f, 
    -0.13053134f, 0.06183917f, -0.00089259f, 0.13096835f, -0.06796353f, 0.01226189f, -0.03345810f, -0.09213059f, 
    -0.23792374f, -0.08102672f, -0.05319142f, -0.13821936f, -0.03904586f, -0.06973298f, -0.36694685f, 0.03850246f, 
    0.18954149f, 0.21052344f, 0.25258338f, 0.26319391f, 0.17816272f, 0.11485495f, 0.13618258f, 0.11895468f, 
    -0.05479402f, 0.08053848f, -0.11564222f, -0.08522275f, 0.06306574f, -0.15517375f, -0.28357711f, 0.26187086f, 
    -0.21904725f, 0.05225339f, -0.02626191f, 0.15974587f, 0.07652932f, 0.15311317f, 0.14868256f, -0.33772758f, 
    0.42930683f, -0.10461864f, -0.04448007f, -0.45518550f, 0.03298589f, -0.01825972f, 0.25105959f, 0.05685120f, 
    0.24879846f, 0.14236154f, -0.14640440f, 0.41147703f, 0.10785850f, 0.05818310f, -0.03545791f, -0.04973996f, 
    0.06497439f, -0.04981155f, -0.23599140f, 0.13731432f, 0.01871237f, 0.17884830f, -0.05527682f, -0.11416110f, 
    -0.26239571f, 0.03455445f, 0.12427641f, 0.13552745f, 0.01931440f, 0.00338359f, 0.14904951f, -0.18142712f, 
    0.36110759f, -0.20013838f, 0.11653075f, 0.25756678f, -0.16314694f, -0.13395908f, 0.33418545f, -0.10595103f, 
    -0.05850179f, -0.03536876f, -0.05560242f, -0.05387651f, -0.09654222f, -0.12547734f, 0.09636283f, -0.14995414f, 
    -0.03914893f, -0.01704756f, -0.06108521f, 0.02858828f, -0.01123568f, -0.08563017f, 0.07832265f, -0.08896048f, 
    0.11855002f, 0.17357656f, 0.11535104f, 0.07926533f, 0.11328213f, -0.03939200f, -0.15444708f, -0.06659935f, 
    -0.06261629f, -0.15220077f, 0.16570550f, 0.11627286f, -0.13737871f, 0.11942792f, -0.01573868f, -0.09579115f, 
    0.26145765f, 0.16746238f, 0.12828662f, 0.11662310f, -0.11910044f, -0.06307120f, 0.27025464f, -0.02708888f, 
    0.05263530f, 0.06121877f, -0.09296907f, -0.08636130f, -0.31544289f, 0.20042358f, 0.28314105f, -0.06886493f, 
    -0.13559352f, -0.14635207f, 0.05498978f, 0.06694569f, 0.11728209f, -0.07493261f, 0.04939802f, -0.16338846f, 
    0.26860800f, 0.07349980f, 0.08513643f, -0.11914116f, 0.31872523f, -0.07430968f, -0.09642215f, -0.10314617f, 
    0.30103451f, -0.04362862f, 0.15141396f, 0.36711618f, -0.08737075f, -0.16891381f, 0.64829344f, 0.16608517f, 
    0.10288960f, 0.07740327f, -0.19578579f, -0.05938990f, 0.12731637f, -0.06967593f, 0.16999179f, -0.29255652f, 
    -0.08017059f, 0.00513836f, -0.08954974f, -0.16245273f, 0.08687633f, -0.00047516f, -0.14027898f, -0.02623263f, 
    -0.18626934f, 0.40490681f, 0.10379777f, -0.33875597f, 0.47101933f, -0.15765552f, 0.17320678f, 0.00126723f, 
    0.16194503f, -0.01746598f, -0.16436651f, 0.60886353f, 0.14912611f, -0.00079184f, 0.17380726f, -0.02896687f, 
    -0.09707648f, 0.03123741f, 0.03921882f, 0.07663832f, 0.27941748f, 0.29084569f, -0.12728202f, -0.17304483f, 
    -0.02714350f, -0.07341524f, -0.09446604f, 0.07707833f, -0.16380917f, 0.32300562f, 0.15578212f, -0.15198685f, 
    0.11965917f, -0.09094700f, 0.09955401f, -0.71529746f, -0.13759542f, 0.10594901f, 0.09657943f, -0.03219885f, 
    0.08186330f, -0.23562193f, 0.41488054f, -0.23522510f, 0.04720198f, -0.06335239f, 0.22019331f, 0.11662017f, 
    -0.21334727f, 0.03288357f, -0.06510702f, -0.30108282f, 0.17811762f, -0.46740586f, -0.37383214f, -0.17845412f, 
    0.02022310f, -0.15645544f, 0.16750012f, -0.14887272f, 0.10777330f, -0.32378349f, 0.11905333f, 0.21204166f, 
    0.31516743f, -0.03364765f, 0.14713055f, 0.26614305f, 0.48573750f, -0.04039479f, -0.06647541f, 0.16616766f, 
    0.19228625f, -0.11126995f, 0.26842120f, 0.31665641f, 0.04965441f, 0.04652046f, 0.28837636f, 0.06038746f, 
    0.17523195f, -0.02350301f, -0.24384573f, 0.27645600f, 0.27825037f, -0.00755772f, -0.03528174f, 0.12652515f, 
    -0.27457583f, 0.05194961f, 0.05774087f, -0.04417509f, 0.10099063f, 0.05876714f, 0.10764392f, 0.19539744f, 
    -0.02151345f, -0.04748754f, -0.05829128f, -0.14915082f, 0.36752000f, -0.17248817f, -0.05964184f, 0.17058627f, 
    -0.14476354f, -0.21709982f, -0.04716331f, 0.50776207f, -0.03096640f, 0.16024767f, 0.35364082f, 0.11619724f, 
    -0.00245680f, 0.09953437f, 0.09520622f, -0.23567420f, -0.07982768f, -0.16080916f, -0.13410565f, -0.07089662f, 
    0.19252510f, 0.11322978f, -0.13977271f, -0.04113822f, -0.08250505f, -0.19341356f, -0.04661348f, 0.14094439f, 
    -0.25162706f, 0.38128135f, -0.03387482f, 0.27006301f, 0.35433683f, 0.03129821f, 0.08544290f, -0.15718721f, 
    0.16376980f, -0.16282046f, 0.34551725f, -0.25134838f, 0.05881594f, 0.08346486f, -0.25502598f, 0.13759314f, 
    0.14667714f, -0.06183482f, 0.04207580f, -0.24838032f, 0.07648209f, -0.19948643f, 0.08703639f, 0.01026480f, 
    -0.01153581f, -0.00225878f, -0.17194721f, -0.01086848f, 0.00836365f, -0.21602899f, 0.10328375f, 0.05342671f, 
    0.05977350f, -0.18127115f, 0.17617989f, 0.34523293f, -0.26100275f, -0.15338986f, 0.16893916f, 0.10535397f, 
    0.12853208f, -0.04633716f, -0.10587909f, -0.11880159f, 0.01595040f, -0.16388142f, -0.01559568f, 0.15847106f, 
    -0.11279640f, 0.06277440f, 0.11053597f, -0.26242065f, -0.26285559f, -0.13826565f, 0.08674731f, -0.10709522f, 
    0.02728994f, 0.12537947f, -0.06442621f, 0.06182980f, 0.02318943f, -0.06937926f, 0.01691316f, 0.09009243f, 
    0.31565696f, 0.01302473f, 0.06832418f, 0.50172240f, 0.02474330f, 0.07029486f, 0.08606794f, -0.07420103f, 
    -0.13972311f, -0.18219565f, -0.13791133f, -0.11013969f, -0.10467929f, 0.17383918f, -0.12569833f, 0.07917401f, 
    0.12238698f, -0.04260806f, 0.12047533f, 0.01590860f, -0.12348218f, -0.04083104f, -0.03129285f, -0.15774305f, 
    -0.07264783f, -0.03826485f, 0.15745582f, -0.12099466f, -0.12730679f, -0.05396897f, 0.09836479f, 0.22692348f, 
    0.14337754f, 0.10933857f, -0.12258975f, -0.07425528f, 0.13680686f, 0.10506851f, -0.06146733f, -0.01260199f, 
    0.22578213f, -0.10424342f, 0.04359965f, -0.34879190f, 0.07516178f, 0.16222706f, 0.27936503f, -0.12598209f, 
    0.11729365f, -0.11486303f, 0.04639483f, 0.17414053f, 0.08432334f, -0.23682389f, -0.06376025f, -0.08465368f, 
    -0.01792815f, 0.04338449f, -0.01754677f, -0.00764221f, -0.01160918f, -0.17508395f, 0.09848512f, 0.20628990f, 
    -0.06624708f, 0.18449183f, -0.17948101f, 0.40806752f, 0.09718832f, -0.02832761f, -0.05205116f, -0.01422625f, 
    -0.03984934f, 0.15650250f, 0.38249984f, 0.01721957f, 0.03773585f, 0.08616471f, 0.07578710f, 0.06952197f, 
    0.08890394f, 0.04696274f, 0.08072564f, 0.09812956f, 0.15531500f, -0.20971212f, 0.04703106f, 0.25507817f, 
    -0.12854826f, 0.10907786f, 0.07416233f, -0.15340650f, 0.15021543f, -0.08200836f, 0.17128749f, -0.23790850f, 
    0.13578191f, 0.27945414f, 0.04624618f, -0.15664014f, 0.16730866f, -0.12550204f, -0.10828689f, 0.01885956f, 
    -0.22456236f, 0.15310563f, -0.02603463f, 0.10103276f, 0.00090988f, 0.07473038f, -0.36374640f, -0.03238224f, 
    0.02457419f, -0.07101217f, 0.09840956f, 0.22438374f, -0.17839067f, 0.13754573f, -0.22343752f, 0.20552686f, 
    -0.03393292f, -0.13757089f, 0.14162759f, 0.07233808f, 0.02192947f, 0.12600581f, 0.12585784f, -0.06644338f, 
    0.30867910f, -0.08756134f, 0.08273061f, -0.07101631f, 0.06120653f, -0.04379237f, 0.29871655f, 0.02897898f, 
    0.00251724f, 0.15629697f, 0.36690688f, 0.05288501f, 0.06139299f, 0.16715999f, 0.42598170f, 0.09958569f, 
    0.10035511f, 0.01092383f, -0.02255761f, -0.30057392f, -0.03123559f, -0.25397539f, -0.11047846f, 0.05575613f, 
    0.15392260f, -0.16001692f, 0.03970327f, 0.13749813f, 0.04737303f, -0.03310602f, -0.12413346f, -0.03418068f, 
    -0.03211334f, 0.32033452f, 0.13285320f, 0.15320133f, -0.18178773f, -0.06222283f, -0.14851207f, -0.04581660f, 
    0.11392585f, -0.25749463f, 0.07082935f, -0.44215664f, 0.00802752f, -0.08787518f, 0.42290962f, -0.02874272f, 
    -0.05831671f, 0.07355520f, 0.32362318f, 0.25125676f, 0.02889713f, 0.05683789f, -0.04127903f, -0.03932723f, 
    0.03091576f, -0.08043380f, 0.14514066f, -0.10168848f, -0.10669302f, -0.47300324f, 0.17133462f, 0.23951687f, 
    0.14912827f, -0.20653440f, 0.09644087f, 0.41833383f, 0.63941717f, 0.18617497f, -0.15343644f, 0.07666262f, 
    -0.11413063f, 0.01626811f, 0.01731397f, -0.20737809f, -0.06668592f, -0.09787015f, 0.05764466f, 0.15802363f, 
    -0.28103447f, 0.06679796f, 0.16574600f, 0.21954814f, -0.18960987f, 0.00091497f, 0.05857457f, 0.20944148f, 
    0.01491570f, -0.13159987f, 0.04119707f, 0.05729478f, 0.00376037f, -0.32202530f, 0.05053933f, -0.01242429f, 
    0.42595133f, 0.08465192f, -0.06551439f, 0.35419032f, 0.01654914f, -0.07175831f, 0.00540778f, -0.07143799f, 
    0.18575937f, 0.02223052f, 0.06189519f, -0.08613116f, 0.10228086f, 0.08107648f, 0.06214004f, 0.02329235f, 
    -0.27331182f, -0.02627221f, -0.03310925f, 0.11282744f, 0.17171739f, -0.24466011f, 0.04820747f, -0.10509597f, 
    0.15395124f, 0.07766800f, 0.00942177f, -0.15903789f, -0.14986785f, -0.21727769f, 0.15448880f, 0.24314827f, 
    -0.08736168f, -0.08092017f, -0.09803724f, 0.51622707f, 0.19930236f, 0.15241115f, -0.13221323f, -0.15403864f, 
    -0.19587585f, -0.14743944f, -0.05892606f, -0.09586193f, -0.13727111f, -0.15388669f, -0.24744454f, -0.04069955f, 
    -0.22002995f, 0.04479220f, 0.31395030f, 0.15345517f, 0.33093271f, -0.00262491f, -0.47588825f, 0.29225481f, 
    0.02923005f, -0.15454614f, -0.08982486f, -0.09941891f, 0.13680249f, -0.28144720f, -0.02599875f, 0.28688306f, 
    0.09000961f, -0.14856617f, -0.06360096f, -0.06288268f, 0.06086143f, 0.12881665f, 0.14596982f, -0.04709952f, 
    0.33977333f, 0.21917868f, 0.20745379f, -0.05842029f, 0.15562837f, 0.07257144f, -0.00813955f, -0.08872576f, 
    -0.16332142f, 0.16576777f, -0.00706966f, -0.26380423f, 0.23502102f, 0.14239885f, -0.01651105f, -0.01436122f, 
    -0.32513613f, 0.09714992f, -0.15496081f, 0.09710383f, 0.07485571f, -0.12113689f, -0.15605350f, -0.48637718f, 
    0.33786601f, -0.37000471f, -0.04281177f, -0.37309831f, -0.54736227f, 0.14699942f, 0.22604053f, -0.15958479f, 
    0.14534719f, 0.30760744f, -0.26100853f, -0.33545008f, -0.06564218f, -0.10030355f, 0.58989233f, 0.02805860f, 
    -0.11998913f, -0.14404450f, -0.18471260f, -0.21614507f, -0.12917167f, 0.24793898f, 0.29481551f, -0.07246185f, 
    -0.09509226f, -0.00379344f, -0.13146788f, -0.02229681f, -0.00239884f, 0.01475648f, -0.08026052f, 0.06419916f, 
    0.23470111f, 0.12770885f, 0.14832518f, -0.14130194f, 0.13459541f, -0.01220823f, 0.18005845f, 0.08460271f, 
    -0.03929541f, 0.12394199f, -0.28999314f, 0.10607496f, 0.00390996f, -0.04579936f, 0.25311163f, -0.16816922f, 
    -0.22786824f, -0.12994258f, 0.01141394f, -0.31525972f, 0.28224885f, 0.37566838f, -0.03378548f, -0.12575866f, 
    0.15091884f, 0.10189272f, -0.00472877f, -0.13593200f, -0.14931500f, 0.27846009f, 0.13150029f, 0.21639997f, 
    -0.10680638f, 0.02608100f, 0.14315608f, -0.44958940f, -0.08419869f, -0.10231323f, 0.29685163f, -0.13421719f, 
    -0.03703308f, -0.07441585f, -0.02717207f, -0.11878774f, 0.07419447f, 0.04313007f, -0.15282424f, 0.15053011f, 
    -0.16604416f, -0.14051037f, -0.16646577f, -0.09734891f, 0.04671371f, -0.11122695f, -0.13713278f, 0.07212392f, 
    0.11063758f, 0.09182774f, -0.10420345f, 0.12289581f, 0.06638407f, -0.03671107f, -0.17088570f, 0.03297800f, 
    -0.02639242f, -0.00985686f, -0.12141784f, 0.04789557f, 0.03856781f, 0.02794022f, -0.14475337f, 0.08856102f, 
    0.07596312f, 0.30221680f, -0.18208733f, -0.03722112f, -0.17832400f, -0.16535655f, 0.01220409f, -0.12330122f, 
    0.01027343f, -0.15546753f, 0.07595380f, -0.27184838f, -0.08856809f, -0.20153141f, 0.22675881f, -0.10713812f, 
    0.10798577f, -0.11409865f, 0.15706864f, 0.14419867f, -0.04187420f, -0.09711234f, 0.16647567f, -0.05377014f, 
    -0.01397726f, 0.34678781f, 0.15387067f, 0.08835026f, 0.08770946f, 0.08834042f, 0.07965758f, 0.00040236f, 
    0.16745231f, -0.07017434f, 0.21129230f, -0.04745946f, -0.15015298f, 0.04118021f, 0.24963906f, -0.13777658f, 
    0.16725183f, -0.14084107f, -0.13800506f, -0.10737568f, -0.03620766f, 0.01535927f, 0.15132272f, 0.02860598f, 
    -0.11071285f, 0.07695744f, -0.14933369f, -0.02320866f, 0.05134555f, 0.02688080f, 0.00586562f, -0.04618049f, 
    0.16441219f, -0.01740891f, 0.07718665f, -0.03941701f, 0.25613314f, -0.17526130f, 0.09115830f, 0.07784412f, 
    0.12341908f, -0.06921016f, 0.16792439f, 0.39748242f, -0.08043585f, 0.10153200f, 0.19113734f, 0.05785342f, 
    0.04062258f, 0.11421091f, -0.16876537f, 0.19306912f, 0.26437095f, -0.08096772f, -0.28257617f, 0.24563678f, 
    0.06063529f, 0.04110925f, 0.00507305f, 0.01011109f, -0.13591316f, -0.16034940f, 0.01873258f, 0.07672718f, 
    0.18441370f, 0.23294207f, -0.06110987f, -0.00211827f, -0.10928566f, 0.14324333f, -0.01829540f, -0.10194706f, 
    -0.06116593f, 0.43857390f, -0.09737845f, 0.25733939f, 0.06967542f, 0.09667986f, 0.39405659f, -0.04141241f, 
    -0.11688735f, 0.11066844f, -0.04173915f, -0.14462112f, -0.00066414f, 0.21050523f, 0.28126699f, -0.18691471f, 
    0.05574362f, -0.02018818f, 0.06849413f, 0.02961907f, -0.02667060f, 0.03763277f, 0.13012618f, -0.13061941f, 
    0.33505094f, -0.21647306f, 0.14896257f, 0.22060359f, -0.08200698f, -0.02981800f, -0.06302082f, -0.02476897f, 
    -0.06047751f, -0.01225148f, -0.04807930f, 0.09862567f, 0.17563562f, 0.12646042f, 0.02387529f, 0.02530100f, 
    0.12828599f, -0.13796154f, 0.11563981f, -0.00687932f, 0.17541698f, -0.09334542f, 0.17071822f, -0.09767574f, 
    0.02522388f, -0.03372014f, -0.04896093f, 0.11491232f, -0.16677010f, -0.15290928f, 0.11752209f, -0.09293176f, 
    -0.08409518f, 0.02900112f, 0.01475137f, 0.46061131f, -0.13753150f, 0.13742970f, -0.23748267f, -0.14999634f, 
    0.12089479f, 0.18792520f, -0.16212516f, 0.24320820f, -0.16263849f, -0.02645184f, -0.06338285f, -0.07351775f, 
    -0.10025145f, -0.00053140f, 0.10503236f, -0.13044159f, -0.00958497f, 0.20262581f, 0.06217735f, -0.26473531f, 
    0.18326390f, 0.06939822f, 0.08085430f, 0.03949527f, 0.03188944f, 0.21809676f, 0.08522289f, 0.12592177f, 
    -0.25403818f, -0.04509646f, -0.15469141f, -0.09933095f, -0.08020387f, -0.11305941f, -0.29216143f, -0.07749295f, 
    0.15032949f, 0.16189453f, -0.05602856f, -0.13841346f, -0.16086729f, 0.14971492f, 0.50607425f, -0.04857673f, 
    -0.04084393f, -0.02073705f, -0.00897339f, -0.49423552f, -0.20611306f, -0.18388350f, 0.14642785f, -0.12809603f, 
    0.15792100f, -0.13293754f, 0.08614967f, -0.07752410f, 0.13214870f, -0.05397443f, -0.10023408f, 0.05367953f, 
    0.18497200f, 0.19257446f, -0.05200752f, 0.31704187f, -0.06178430f, -0.00315172f, -0.03704488f, -0.14088367f, 
    0.01126659f, -0.29430300f, -0.12441141f, -0.42481181f, 0.07812647f, 0.00903639f, 0.14006124f, -0.10661110f, 
    -0.01229102f, -0.10219462f, 0.02475020f, 0.08076371f, -0.05799281f, 0.24907053f, 0.15292726f, -0.10763799f, 
    0.08733948f, -0.14827347f, 0.11353724f, -0.07358122f, 0.17138620f, -0.26364285f, -0.06203472f, -0.21865126f, 
    0.45273581f, -0.28752455f, -0.15905090f, 0.28139865f, 0.08423110f, 0.12317064f, 0.35582462f, 0.06237285f, 
    -0.28583768f, -0.03995769f, -0.17095569f, 0.08108744f, 0.07808412f, 0.03105362f, -0.10920322f, -0.12587962f, 
    -0.31422502f, 0.05927353f, 0.40252146f, -0.22585754f, 0.19126321f, -0.12197953f, -0.45791790f, -0.28151003f, 
    0.19440608f, -0.03415838f, -0.03718207f, -0.11438005f, 0.16840243f, 0.04421512f, -0.02430169f, 0.12434557f, 
    0.10092160f, -0.13914734f, 0.05821638f, 0.33457303f, 0.20205379f, 0.16795336f, -0.05177407f, 0.09892529f, 
    -0.19019184f, 0.04137718f, -0.13316846f, 0.03919003f, -0.07743654f, -0.13386458f, -0.43629807f, 0.10987785f, 
    -0.29157379f, 0.07910891f, 0.20700175f, -0.07640470f, 0.23371544f, 0.10586375f, -0.15056004f, -0.04275046f, 
    0.27664992f, -0.00161431f, -0.11827180f, 0.14753997f, -0.15633686f, 0.13558441f, -0.09106617f, 0.09316988f, 
    -0.18901749f, -0.03682656f, -0.10888989f, -0.02719057f, -0.25973615f, 0.12994428f, 0.05636702f, 0.15958719f, 
    0.32821092f, 0.07489015f, -0.14049441f, -0.19727769f, -0.04221844f, 0.18551192f, 0.74007869f, 0.07156155f, 
    0.03582876f, -0.16469629f, -0.07790653f, 0.52549076f, 0.05938326f, -0.04181763f, 0.12176836f, -0.44579619f, 
    0.03725879f, 0.12659536f, 0.08220094f, 0.14261855f, -0.03535783f, -0.06889842f, -0.12478294f, -0.00452349f, 
    0.25549823f, -0.19607393f, -0.16557081f, -0.49010703f, 0.16215692f, -0.06506637f, 0.25450373f, -0.12918930f, 
    0.14986452f, -0.38164529f, 0.13273259f, 0.28389603f, 0.01511944f, -0.05835138f, -0.09209991f, 0.15518954f, 
    0.29023448f, -0.07233752f, 0.11882194f, 0.16645283f, 0.34168547f, -0.24779733f, -0.09590513f, 0.02309831f, 
    -0.25430998f, 0.09408652f, 0.10828845f, 0.02187635f, 0.08282020f, 0.03784836f, -0.12048684f, 0.01433297f, 
    -0.08766595f, 0.14122877f, 0.15544526f, -0.09990553f, 0.26616240f, 0.06063392f, 0.15296713f, -0.10605376f, 
    0.29629251f, 0.11657173f, 0.13647056f, -0.03946143f, 0.09210068f, -0.13044481f, 0.28041488f, 0.09647494f, 
    -0.09861690f, 0.09047849f, -0.26903886f, 0.16412701f, 0.22456439f, 0.17516419f, 0.10322890f, -0.28332683f, 
    0.03507513f, 0.12483985f, -0.12589517f, -0.06894497f, -0.05925110f, 0.28658313f, 0.15280612f, 0.16092950f, 
    0.11961465f, -0.27812636f, -0.01363915f, -0.18418306f, -0.10520305f, -0.11306772f, -0.03174330f, -0.06603771f, 
    -0.26354170f, -0.02729636f, -0.22607766f, 0.59557354f, 0.13339521f, 0.16734208f, -0.20022915f, 0.16514915f, 
    -0.21514106f, 0.17300834f, 0.12585713f, -0.19831657f, -0.14144714f, 0.34541479f, -0.14374842f, 0.09954870f, 
    -0.00895838f, 0.12791741f, -0.07134174f, 0.14080556f, -0.06636065f, 0.18078069f, 0.07696025f, 0.13373482f, 
    0.12814566f, 0.13437343f, -0.15851387f, 0.08664389f, 0.21140730f, -0.08584510f, -0.10450397f, -0.04957687f, 
    -0.11226614f, 0.22140008f, 0.19039315f, 0.21459185f, -0.10079840f, -0.15642256f, -0.10554180f, 0.06256396f, 
    0.01462182f, 0.11670913f, -0.11177914f, 0.03799820f, 0.26560077f, -0.12640710f, -0.02175215f, 0.23932916f, 
    -0.14669403f, 0.04652047f, 0.14416403f, -0.13855688f, 0.04637110f, 0.18425593f, -0.13299505f, -0.13949382f, 
    0.05685157f, 0.12826647f, 0.17781101f, -0.07149521f, -0.35356700f, 0.04645950f, 0.13911733f, 0.04197941f, 
    0.05296457f, 0.23052457f, -0.19079792f, 0.24642757f, -0.16121073f, -0.16051999f, 0.22371459f, -0.02057863f, 
    0.01781443f, -0.17999910f, 0.02185230f, -0.33148962f, -0.14882699f, -0.06537320f, -0.05405473f, -0.00915138f, 
    0.17991318f, -0.08659198f, -0.15502273f, 0.06335864f, -0.07171533f, 0.26141062f, -0.10572212f, 0.04040625f, 
    0.11958944f, 0.30502951f, 0.15550613f, -0.39137229f, 0.22386488f, -0.03414036f, -0.03569653f, -0.00685780f, 
    -0.14248265f, -0.14889205f, -0.08025341f, 0.47263178f, 0.14850527f, 0.09320387f, -0.23567508f, -0.04365756f, 
    -0.23445284f, 0.17419378f, 0.16929424f, -0.46951395f, -0.10307699f, 0.33331507f, 0.06797875f, 0.00626045f, 
    0.14348988f, 0.06935099f, -0.15087980f, -0.16270487f, -0.18450119f, 0.05566835f, -0.05809608f, -0.11929927f, 
    0.16310528f, 0.16227758f, -0.04469022f, -0.37526289f, -0.12845959f, 0.06976252f, 0.29454967f, 0.06800248f, 
    0.13666828f, -0.21206860f, -0.09409980f, 0.07125658f, 0.03516995f, 0.12763828f, -0.11353103f, -0.12182028f, 
    0.05367764f, 0.04885086f, 0.00855097f, 0.35607609f, 0.08277773f, 0.00092455f, -0.07699830f, -0.04719022f, 
    -0.03560191f, -0.12559417f, 0.10114426f, 0.14717631f, -0.06214495f, -0.20003143f, -0.03522042f, -0.19764033f, 
    0.08200154f, 0.20758523f, -0.14748538f, -0.30819249f, 0.49810845f, 0.07588524f, 0.08140363f, -0.07855596f, 
    -0.13131642f, -0.22353701f, -0.00323809f, -0.28926256f, -0.14354430f, 0.04574859f, 0.13678300f, 0.07803597f, 
    -0.33094767f, -0.13828006f, 0.36031401f, -0.42311311f, 0.13422039f, -0.12549272f, -0.29530653f, -0.05452295f, 
    0.29231134f, 0.07932001f, 0.15848559f, -0.08314659f, 0.10531460f, -0.10137267f, 0.13318539f, 0.17490870f, 
    -0.08118059f, 0.38195500f, 0.00915944f, 0.01353277f, 0.00794410f, 0.08203851f, 0.21395528f, 0.06236307f, 
    -0.12266283f, 0.10493726f, 0.01017250f, -0.08110665f, -0.00644283f, -0.11706792f, 0.35999119f, 0.17401142f, 
    -0.10781956f, 0.04335762f, 0.00059690f, 0.00629832f, 0.19324398f, 0.07883292f, -0.07843614f, 0.06999747f, 
    0.17171365f, -0.12991339f, -0.07832238f, -0.09314168f, 0.09376148f, 0.04540165f, 0.03098585f, 0.22671999f, 
    -0.02832049f, 0.19148472f, -0.05618937f, -0.09032867f, -0.43661287f, -0.08346185f, 0.00011098f, 0.07252266f, 
    -0.03361683f, -0.00832811f, 0.14975092f, 0.19859955f, 0.03326409f, 0.13373192f, -0.12881054f, 0.13914578f, 
    -0.05530941f, -0.11900364f, 0.19249396f, -0.45781624f, 0.00593057f, -0.16898580f, 0.11781403f, 0.00918655f, 
    0.11950035f, 0.07393479f, 0.09825470f, -0.04949557f, 0.02745059f, 0.10645429f, 0.09142152f, -0.18161981f, 
    -0.02780163f, 0.27493569f, -0.00795720f, -0.10424942f, -0.10652891f, -0.20218161f, 0.24586283f, 0.09261592f, 
    0.13361596f, -0.14849479f, 0.07676949f, 0.14290208f, 0.02077673f, -0.18054745f, -0.23085068f, -0.11816806f, 
    0.08782906f, -0.04716899f, -0.10912868f, 0.07341255f, -0.10074441f, 0.10210349f, 0.12046900f, 0.12964918f, 
    -0.03159544f, 0.16007479f, 0.01126473f, 0.09394157f, 0.18538956f, -0.28146613f, 0.00314308f, 0.01437265f, 
    0.34695080f, -0.18176812f, 0.07604888f, 0.32942167f, 0.28180370f, 0.04889364f, -0.02354478f, -0.09616092f, 
    -0.04479108f, -0.07459228f, 0.30278119f, -0.02497773f, -0.01396085f, -0.15858874f, 0.07121528f, 0.15901740f, 
    0.29544750f, -0.11218177f, 0.08620732f, -0.19939567f, -0.03140192f, -0.09083050f, -0.30242997f, -0.15801640f, 
    0.17911464f, 0.11739151f, -0.14873341f, 0.13910933f, 0.10660850f, -0.42412260f, 0.10689147f, -0.16093604f, 
    0.28916556f, 0.12590288f, -0.09146581f, -0.28913105f, 0.40074092f, 0.07509649f, 0.26095098f, 0.05538241f, 
    0.17114246f, 0.07017905f, -0.27189308f, 0.19340774f, 0.00316723f, 0.03920466f, -0.37099898f, 0.16140683f, 
    -0.15884088f, 0.07043956f, -0.11377300f, -0.11919570f, 0.16786557f, 0.19229367f, 0.20416482f, 0.03028450f, 
    -0.16912994f, -0.11582998f, 0.12256851f, -0.00931165f, 0.18242873f, 0.29265386f, -0.03882995f, -0.07586881f, 
    -0.20672643f, -0.16872083f, 0.12269485f, 0.46372476f, -0.50660092f, 0.00284743f, 0.11572776f, 0.10766072f, 
    -0.18188016f, 0.11032821f, -0.21215969f, -0.25989628f, -0.15596652f, -0.15970480f, 0.03096486f, -0.11551096f, 
    -0.12799318f, 0.14276773f, 0.22492044f, 0.05478450f, -0.09242206f, 0.28606948f, 0.06818411f, -0.03865582f, 
    0.19723304f, 0.12227073f, -0.15637395f, -0.04861511f, -0.06588644f, 0.18574052f, 0.04513011f, -0.07678661f, 
    -0.03572146f, -0.20301782f, 0.06335155f, -0.18332778f, 0.00251856f, 0.10272274f, 0.10092995f, 0.11580567f, 
    0.00995624f, 0.27925542f, -0.02663602f, -0.08025552f, -0.09844880f, -0.14636518f, -0.21088745f, 0.10794114f, 
    -0.25287420f, 0.07578596f, -0.09022568f, 0.26440123f, 0.15105365f, 0.02876819f, -0.09819123f, 0.31131586f, 
    -0.10355719f, -0.03071953f, 0.11075114f, -0.03828574f, -0.08460651f, 0.09951334f, -0.15707137f, 0.09749214f, 
    0.18461907f, 0.04038175f, 0.15096843f, 0.22739112f, -0.42375332f, -0.07703176f, 0.00641487f, -0.13808188f, 
    0.09620725f, -0.00092038f, 0.32969388f, 0.29751557f, 0.00994080f, 0.16477820f, -0.18942593f, -0.01118963f, 
    -0.04775429f, 0.05330759f, -0.01218840f, -0.05461786f, 0.04323643f, -0.12733117f, 0.11476076f, 0.12389963f, 
    -0.29746073f, 0.06398296f, 0.07487081f, 0.16728345f, 0.01761300f, -0.00619919f, -0.14144765f, -0.03245343f, 
    0.13086960f, 0.23680995f, -0.12489071f, 0.17141360f, 0.20577972f, 0.16107096f, -0.04452651f, -0.09367698f, 
    0.05826229f, 0.22745018f, -0.37914565f, -0.24058352f, 0.11244516f, 0.13762785f, 0.50082988f, -0.13935335f, 
    -0.14243346f, 0.10091891f, -0.17207383f, -0.07892017f, 0.05185508f, -0.00521574f, 0.15928017f, 0.07233107f, 
    0.26245534f, -0.10486142f, 0.02582451f, 0.06679159f, 0.07466061f, -0.08918472f, -0.00489498f, 0.20663550f, 
    -0.09018019f, 0.16188906f, 0.10629170f, -0.15637434f, 0.04913573f, -0.05373589f, -0.10856524f, -0.04594547f, 
    -0.11106130f, 0.35711405f, 0.28469747f, 0.26757741f, -0.02101766f, -0.15555964f, 0.13176844f, 0.11734479f, 
    -0.00601396f, 0.17544010f, -0.16172999f, -0.24584264f, -0.01552304f, 0.12853470f, -0.05374124f, 0.16126165f, 
    0.15842329f, 0.11882348f, -0.03101835f, -0.10630721f, 0.04184556f, 0.09358887f, -0.08731166f, 0.15816243f, 
    0.01520869f, 0.16351904f, -0.03615222f, 0.07737587f, 0.07098361f, -0.09401317f, -0.08080756f, -0.03638668f, 
    -0.21132889f, 0.01313733f, 0.01486038f, 0.10372596f, 0.04068918f, -0.17571323f, -0.38418469f, -0.05284828f, 
    -0.64468944f, -0.03976245f, 0.29817635f, -0.06335428f, -0.07842144f, 0.08445397f, -0.45951745f, 0.00264436f, 
    0.26272365f, -0.12741764f, 0.12377518f, -0.17624284f, 0.07554183f, 0.12056934f, -0.01349717f, 0.31731984f, 
    0.09710733f, -0.36006203f, 0.02301263f, 0.57046252f, 0.11075183f, 0.00776753f, -0.03707686f, 0.02111942f, 
    0.04389388f, 0.10904350f, -0.29066938f, 0.00098818f, -0.14400588f, 0.09400616f, 0.12403297f, 0.08630437f, 
    0.03987808f, 0.13690972f, -0.07054276f, -0.13460945f, -0.05026818f, 0.34421080f, 0.02711258f, -0.42742187f, 
    0.30886114f, -0.06316363f, 0.08985347f, -0.11685346f, 0.12043491f, 0.05017834f, -0.16856480f, -0.08120669f, 
    -0.09877343f, -0.00373381f, 0.15894614f, 0.14481136f, 0.21665844f, -0.00602178f, 0.25919703f, -0.09296352f, 
    0.00332523f, -0.17723562f, -0.16501144f, 0.27725014f, -0.08362482f, 0.07649696f, -0.03069977f, 0.03386294f, 
    -0.22054721f, 0.01968245f, 0.10908040f, -0.36147514f, 0.25444621f, 0.18041267f, -0.07138039f, -0.12126616f, 
    0.23750442f, -0.12966642f, -0.06566574f, -0.17445894f, 0.06887040f, 0.27539173f, -0.10435994f, 0.25294837f, 
    -0.15057519f, 0.05092506f, -0.00057049f, -0.23270220f, -0.14741001f, -0.02108879f, 0.11369652f, 0.16617186f, 
    0.12166285f, -0.19558580f, -0.27122682f, 0.02481925f, -0.08108559f, -0.10543536f, 0.03595102f, 0.16140793f, 
    -0.25135615f, -0.17391132f, 0.20484865f, -0.44851440f, 0.03786058f, -0.07937797f, 0.18428706f, -0.04875737f, 
    0.04310267f, 0.11068578f, -0.00338439f, 0.02692599f, -0.12867863f, -0.27755719f, -0.14615424f, 0.17178313f, 
    0.08370492f, 0.13115546f, -0.15485941f, 0.44414070f, -0.00466694f, -0.12361093f, -0.04295934f, 0.11361249f, 
    0.28912205f, -0.03032138f, -0.07397565f, -0.52089989f, -0.12731038f, 0.19571790f, 0.57067615f, 0.00192794f, 
    0.07136584f, 0.03530849f, -0.24856924f, 0.09785876f, 0.20119867f, 0.29046878f, 0.17453377f, -0.42331389f, 
    0.14794572f, -0.06546240f, 0.04509902f, -0.10634857f, 0.13090087f, -0.03332058f, -0.02898070f, -0.30415922f, 
    0.25685680f, 0.12170371f, -0.11531384f, -0.13776164f, 0.11704841f, -0.07188250f, 0.22560984f, 0.03081640f, 
    0.08779625f, -0.00120308f, -0.29648209f, 0.14184189f, -0.14563493f, 0.16784500f, -0.06008559f, -0.16079554f, 
    0.29258823f, 0.03158000f, 0.14346412f, 0.22775929f, 0.35678780f, -0.13975379f, 0.10614196f, -0.21450235f, 
    -0.07841218f, 0.13904005f, -0.13632971f, 0.07145996f, 0.12405811f, 0.27631506f, 0.15840335f, -0.19015467f, 
    -0.04038573f, -0.15500933f, -0.00348181f, 0.29078177f, -0.32887501f, 0.13216780f, -0.08050887f, -0.04310375f, 
    0.00795020f, 0.20287296f, -0.03118915f, 0.08711696f, 0.06337639f, 0.11195292f, -0.25766081f, 0.16425224f, 
    -0.28113919f, 0.01509415f, -0.03467198f, 0.05611568f, -0.18305941f, -0.03064471f, -0.25912946f, 0.18186301f, 
    0.13492064f, -0.12826106f, 0.03066391f, -0.06374077f, 0.08110718f, -0.46073353f, 0.01650095f, 0.08316285f, 
    0.18036392f, -0.26103541f, -0.02121111f, 0.47319224f, 0.21897052f, 0.13824864f, 0.04075310f, 0.09810299f, 
    -0.14719218f, -0.17090897f, -0.08217567f, -0.10712414f, -0.02767243f, 0.12541319f, -0.47986317f, 0.14391170f, 
    -0.14191915f, 0.12370270f, 0.31191239f, 0.16579702f, -0.08351348f, 0.06969669f, -0.04758924f, 0.13207336f, 
    0.31499162f, 0.07845697f, -0.07973375f, -0.07965298f, 0.01577289f, 0.06862760f, -0.15719102f, 0.04883911f, 
    0.17790793f, -0.00741435f, -0.07447749f, 0.10691545f, 0.17167987f, -0.01112312f, -0.05420946f, -0.10177518f, 
    -0.03736879f, -0.13530253f, -0.10613933f, -0.13132313f, -0.16784804f, -0.10226745f, -0.05066814f, 0.08179709f, 
    -0.13375102f, -0.09317077f, 0.00645584f, -0.17710441f, 0.12085978f, -0.07535189f, -0.19486474f, 0.03840194f, 
    -0.03921907f, -0.15597858f, 0.09155254f, 0.03488965f, -0.17485014f, -0.17268494f, -0.00004373f, -0.13451180f, 
    0.03215344f, 0.09156971f, 0.15610197f, -0.15876126f, 0.09375408f, 0.07596701f, -0.02604937f, 0.15919882f, 
    -0.12004077f, -0.09309883f, 0.08784382f, -0.18141408f, -0.02472067f, -0.15729649f, -0.08296274f, -0.08109340f, 
    0.11006740f, 0.12693229f, 0.01413140f, -0.20178416f, -0.17868164f, -0.06344413f, -0.09321316f, 0.06978354f, 
    -0.17707038f, -0.10877676f, 0.05344463f, -0.02995054f, 0.13280082f, -0.11097326f, 0.00825822f, -0.14290540f, 
    -0.01545992f, -0.07067963f, -0.04422462f, 0.00897457f, -0.10483202f, 0.04308460f, -0.13532911f, -0.08830196f, 
    0.01020835f, -0.07853771f, -0.25789824f, 0.03738396f, -0.07518641f, -0.06699971f, 0.16827133f, -0.06738570f, 
    -0.29834500f, 0.02112653f, 0.22133623f, 0.08004127f, 0.09577117f, -0.12736978f, -0.28567329f, -0.36214349f, 
    0.34383568f, 0.04805676f, -0.12121410f, 0.10001751f, 0.14184207f, -0.08559239f, -0.11923380f, 0.26728913f, 
    -0.36628249f, 0.36939925f, 0.10062100f, 0.08885334f, 0.26702026f, 0.10548911f, 0.17222334f, 0.15866904f, 
    -0.16717425f, -0.15821819f, 0.05929581f, -0.15261620f, 0.03700483f, -0.16394919f, -0.17248954f, -0.12771259f, 
    -0.16686717f, -0.07638480f, 0.00079076f, 0.10558713f, -0.16914128f, -0.03479028f, -0.15694579f, 0.04595376f, 
    -0.07971183f, -0.11480322f, -0.02971930f, -0.08126083f, 0.11046318f, 0.05555132f, -0.09873622f, 0.16646235f, 
    -0.07586294f, 0.00845144f, 0.03086976f, 0.10182883f, -0.13439454f, 0.03129476f, -0.16884056f, 0.06685150f, 
    -0.23511218f, -0.01084312f, 0.20566562f, -0.84121507f, -0.08211720f, 0.01175608f, -0.12551183f, -0.08071773f, 
    -0.19869822f, 0.10789417f, 0.29411820f, -0.26241666f, 0.02014917f, 0.25220260f, -0.19042310f, 0.05107373f, 
    0.12556550f, -0.11455023f, -0.13029262f, -0.08953903f, -0.11521275f, -0.16466425f, -0.13957897f, -0.02687635f, 
    0.41127828f, -0.21321672f, -0.01002770f, 0.06545841f, -0.10397817f, 0.04564483f, 0.10566393f, 0.07968035f, 
    0.16030772f, -0.17588222f, -0.06823742f, 0.02184071f, 0.12005871f, 0.06061528f, 0.11041276f, -0.14540713f, 
    -0.13784574f, -0.01097380f, -0.14114149f, 0.12863910f, -0.06101841f, -0.02876499f, 0.06515443f, -0.05517041f, 
    -0.04042873f, -0.14813019f, -0.12663552f, -0.02818482f, 0.01245182f, -0.01843828f, 0.04462527f, -0.08188336f, 
    0.04840202f, -0.06415560f, 0.08715721f, -0.03573549f, -0.10540726f, -0.12031977f, -0.07111624f, -0.05721380f, 
    0.16673973f, -0.22289991f, 0.06851230f, 0.06832742f, -0.00146092f, -0.16507000f, -0.54963678f, 0.10605085f, 
    0.00496241f, -0.12190267f, 0.19406517f, 0.28387332f, 0.36053833f, -0.29338485f, -0.17246264f, 0.13012162f, 
    -0.03456697f, 0.02306426f, -0.06058428f, -0.16223286f, 0.12600255f, 0.09355663f, -0.00221554f, 0.00424183f, 
    -0.13440935f, 0.16002740f, -0.02010865f, 0.10736117f, -0.18153217f, -0.07715701f, 0.19244583f, -0.11784154f, 
    0.09716599f, 0.13278556f, 0.47368300f, -0.09788000f, 0.13123694f, 0.04810345f, 0.23096405f, 0.14270020f, 
    -0.07264914f, 0.08092713f, -0.13270721f, -0.48111582f, 0.18517710f, -0.06488483f, 0.02294077f, 0.02148171f, 
    -0.02543032f, -0.01660892f, -0.10975401f, -0.07948409f, 0.09442075f, 0.15278760f, -0.13165125f, -0.35490644f, 
    0.31009147f, -0.19765103f, 0.13098833f, -0.54253125f, 0.10232626f, -0.00237082f, 0.01126909f, 0.05299183f, 
    -0.11644364f, -0.09893984f, -0.27386162f, -0.21627317f, -0.03105784f, 0.12742552f, 0.31894720f, 0.16257761f, 
    0.10616741f, -0.01704783f, 0.09165971f, -0.18306826f, -0.13785242f, 0.07009386f, 0.17448753f, -0.12374591f, 
    0.38897344f, -0.02352794f, 0.01331958f, -0.15422712f, -0.03959578f, -0.12835398f, -0.00766136f, 0.01557677f, 
    0.28464589f, 0.17731106f, 0.06789839f, -0.00437068f, 0.22638847f, 0.12487178f, 0.06110040f, 0.12401803f, 
    0.24916588f, -0.29296908f, 0.03981220f, 0.14800122f, -0.10092835f, 0.10918898f, -0.08873964f, -0.11505753f, 
    0.13152702f, -0.03169283f, -0.06064053f, 0.01294798f, 0.37903067f, -0.05655078f, 0.08819094f, -0.21486939f, 
    -0.33224499f, 0.08424035f, -0.16194560f, -0.13405797f, 0.11967277f, 0.03601253f, -0.07552766f, -0.26692033f, 
    -0.08238591f, -0.05712188f, 0.00583738f, 0.32601947f, -0.03047506f, 0.14532295f, 0.40101847f, 0.05930001f, 
    -0.00732448f, 0.17464726f, -0.05095533f, 0.47445485f, -0.05399001f, 0.12392130f, 0.02359373f, -0.09304056f, 
    -0.21115717f, 0.01064634f, 0.00438730f, 0.08475228f, 0.25113764f, 0.17464365f, 0.04309372f, -0.19036463f, 
    -0.31717092f, -0.13926786f, -0.08026053f, 0.00728766f, 0.09311886f, 0.38720989f, -0.03697090f, 0.14361393f, 
    0.11124770f, -0.08155250f, -0.12357666f, -0.13755459f, -0.18376462f, 0.14824417f, 0.02188169f, 0.00002428f, 
    0.36883897f, 0.17663056f, -0.39606401f, -0.12857047f, -0.12461860f, -0.16938397f, 0.59122086f, 0.05728659f, 
    -0.25444230f, -0.04591768f, -0.32527524f, 0.31198436f, 0.15683232f, 0.25310096f, 0.19242604f, -0.46301100f, 
    -0.19900575f, -0.08249424f, -0.03734023f, -0.00812612f, -0.09446495f, 0.08758023f, 0.01618755f, 0.10091678f, 
    0.07320778f, -0.10425925f, -0.05723840f, -0.00233824f, 0.04912197f, -0.12455618f, 0.31829938f, 0.08430499f, 
    0.06480911f, -0.19824623f, -0.07375289f, -0.03073939f, -0.17060520f, 0.09258012f, -0.52937049f, 0.06063096f, 
    -0.17208000f, -0.16412644f, 0.19255133f, -0.02049474f, -0.21342124f, 0.18687351f, 0.08932883f, 0.13016494f, 
    -0.03304244f, -0.00565045f, 0.16672665f, 0.12078629f, 0.07145699f, 0.08115932f, -0.13354817f, -0.05061227f, 
    -0.13193014f, -0.02925337f, 0.10403164f, 0.13174380f, 0.18850662f, 0.05475986f, 0.13976169f, -0.03407947f, 
    -0.28652140f, 0.18815254f, 0.13342440f, -0.66594982f, 0.07359819f, -0.13650952f, -0.03843616f, 0.06206757f, 
    -0.17306738f, 0.11970001f, 0.33188209f, 0.06587695f, -0.25609475f, 0.13920672f, -0.22554745f, -0.16349231f, 
    0.13103338f, -0.12620462f, 0.10324609f, -0.05971564f, -0.13211983f, -0.00618182f, 0.13873346f, -0.21963322f, 
    0.36892617f, -0.17298026f, 0.05725342f, -0.11885218f, -0.03604773f, 0.15351105f, 0.34100798f, 0.04812048f, 
    0.12305558f, -0.36379722f, 0.06383719f, -0.27750918f, -0.08282330f, 0.10441118f, 0.23759024f, -0.09181619f, 
    -0.00861710f, -0.02956056f, 0.33282632f, 0.58879501f, 0.28723413f, 0.07363930f, -0.41339490f, -0.21022664f, 
    -0.06671931f, -0.13607532f, -0.06504972f, 0.07410143f, -0.04303857f, -0.30758882f, -0.15308766f, 0.35400167f, 
    -0.07800285f, 0.14586647f, -0.07508218f, -0.15083973f, 0.24484806f, -0.06769595f, -0.17759943f, -0.04835714f, 
    -0.03153737f, 0.12925845f, -0.05522215f, -0.08552398f, 0.14148906f, 0.11182369f, 0.03177574f, -0.05933126f, 
    -0.13792512f, -0.08690821f, 0.09887602f, -0.14884131f, 0.06322111f, -0.19251128f, -0.19440842f, 0.09244856f, 
    -0.23750490f, 0.03794063f, 0.13430788f, -0.04298747f, -0.06658413f, -0.04706284f, -0.14326313f, 0.06969795f, 
    -0.20659640f, -0.06912488f, -0.15570521f, -0.10797238f, -0.11179151f, -0.02076486f, -0.07079508f, 0.08196804f, 
    0.00738836f, -0.04117066f, -0.14809008f, 0.15004475f, -0.17524451f, 0.02999378f, -0.17625716f, -0.11690853f, 
    0.09721322f, -0.07556736f, -0.08279348f, -0.08078126f, -0.16873290f, 0.02195714f, -0.08132525f, -0.14531827f, 
    -0.13794594f, -0.06147408f, -0.12954618f, -0.08139207f, 0.03413903f, 0.04207296f, 0.09304994f, 0.02228340f, 
    -0.13644719f, 0.05190439f, -0.08093655f, 0.07513118f, -0.11291838f, 0.14573790f, -0.03336621f, -0.07541454f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.27518037f, 0.08152009f, 0.02354839f, -0.06946666f, 0.27428037f, -0.06577116f, -0.08934164f, -0.15999152f, 
    0.25424269f, 0.26337910f, -0.10642025f, -0.10269073f, 0.21314394f, -0.10971268f, 0.13887814f, -0.00191211f, 
    0.10978869f, 0.00474870f, 0.12082750f, -0.02088231f, 0.21372528f, -0.07470273f, -0.14377363f, 0.22029042f, 
    -0.14314279f, 0.18851492f, 0.11327038f, 0.00142279f, -0.00713152f, -0.02239833f, 0.15195167f, -0.16455804f, 
    0.09889216f, -0.03618923f, -0.11423874f, 0.19139427f, 0.05151652f, -0.02904653f, 0.35287067f, 0.04852445f, 
    0.25785291f, 0.21678063f, 0.02545534f, 0.08878142f, 0.03521039f, 0.20599258f, 0.00869062f, -0.11630278f, 
    -0.03260335f, 0.14431219f, 0.15903492f, -0.04441537f, -0.18065751f, 0.15379733f, 0.14631747f, 0.20444639f, 
    -0.14022224f, 0.02855463f, 0.13572447f, 0.11326670f, -0.07172532f, -0.08075058f, 0.09013996f, -0.26954451f, 
    -0.01674876f, 0.11165532f, -0.03490792f, -0.00798013f, -0.03164645f, -0.05745184f, 0.12591347f, 0.17002387f, 
    0.18475646f, 0.00419540f, -0.06265988f, 0.02499471f, -0.12126917f, 0.13215715f, -0.15863796f, -0.12866065f, 
    -0.05044986f, 0.17469159f, 0.24359994f, 0.17365594f, 0.07090327f, -0.28943273f, 0.06485861f, 0.02509672f, 
    0.02372186f, 0.14569244f, 0.36876991f, -0.05437018f, 0.04197551f, -0.15886927f, 0.13049592f, 0.09238508f, 
    0.13781866f, 0.09818085f, -0.01654853f, 0.18378423f, 0.14185704f, -0.05746406f, 0.06263415f, 0.23703890f, 
    0.26131827f, 0.31525284f, 0.02775706f, 0.16273117f, -0.16856249f, -0.11552065f, 0.02897837f, 0.01741420f, 
    -0.05935682f, 0.08236095f, -0.14254868f, 0.26160830f, -0.15371050f, -0.30611518f, 0.25435051f, 0.27385572f, 
    -0.02228351f, 0.20891079f, 0.08084414f, 0.23499766f, 0.32469058f, -0.13595614f, -0.04160998f, 0.00876010f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.02973595f, -0.01065706f, 0.12270584f, -0.09172889f, -0.06872187f, 0.14188367f, -0.03115786f, 0.03871748f, 
    -0.50479746f, -0.02642446f, 0.24580032f, -0.29282701f, -0.31880909f, 0.28895479f, 0.09846848f, 0.11909367f, 
    0.09358250f, -0.00499411f, 0.03431753f, -0.18640397f, -0.11565504f, 0.05411004f, -0.02376122f, -0.22908787f, 
    0.16980900f, -0.56470776f, 0.24830773f, 0.18876366f, -0.10377885f, -0.08799783f, -0.01019655f, 0.18338190f, 
    0.02885408f, -0.29904437f, -0.37614450f, -0.14231822f, -0.27091941f, 0.00822818f, 0.17598197f, -0.43347764f, 
    -0.29354203f, -0.40007198f, 0.34683993f, 0.00210269f, 0.05114501f, -0.07171003f, 0.15139383f, -0.05691792f, 
    -0.03558191f, -0.00924407f, 0.12032712f, -0.32458884f, 0.03157714f, -0.11358672f, 0.13847691f, -0.18218374f, 
    0.23030923f, 0.13831693f, -0.21519405f, 0.14002797f, -0.17025779f, -0.00755517f, 0.09952967f, 0.23684739f, 
    -0.15722795f, 0.14573541f, -0.05874211f, -0.23450938f, 0.10238703f, -0.01173229f, 0.02948578f, -0.39783302f, 
    -0.23658347f, 0.00535453f, -0.20253636f, 0.10365122f, 0.12290209f, -0.42418811f, 0.02144592f, -0.11389056f, 
    -0.18602753f, -0.20681286f, -0.39562947f, 0.12056308f, -0.04320518f, 0.17663848f, 0.10785543f, -0.17544204f, 
    0.13915311f, -0.33652177f, -0.45138156f, -0.05072770f, 0.02185588f, 0.02735899f, 0.02925520f, 0.00089419f, 
    0.15788884f, 0.00243298f, 0.05158085f, -0.08804464f, 0.13709971f, -0.30850366f, -0.05558980f, -0.50328571f, 
    -0.42575324f, -0.04600281f, -0.30208853f, -0.00233788f, -0.02170486f, -0.42992133f, -0.12969269f, -0.03097537f, 
    -0.05217469f, -0.14985020f, -0.03916690f, 0.05097185f, -0.07835175f, 0.13985141f, 0.29573393f, -0.42793721f, 
    0.09407710f, -0.07629044f, -0.49715453f, -0.08665390f, -0.08019245f, 0.14370252f, -0.01895323f, -0.08053624f, 
    0.18578775f, 0.37096718f, -0.19066596f, -0.07869687f, 0.01915557f, 0.11746541f, 0.06865051f, -0.08257673f, 
    -0.06514066f, 0.25766903f, 0.16518797f, -0.14911991f, 0.14258212f, 0.28429538f, 0.03743778f, 0.19462934f, 
    0.05849155f, -0.07214798f, 0.17401111f, -0.27266783f, -0.61493158f, -0.06321059f, 0.04577464f, -0.06384286f, 
    0.17488897f, -0.25803283f, 0.33918500f, -0.79022813f, -0.00471114f, 0.32570645f, -0.13592470f, 0.01912566f, 
    0.02738592f, 0.16478638f, -0.06580516f, -0.05996618f, 0.09473491f, 0.05472238f, 0.22514085f, 0.12433834f, 
    -0.00462204f, -0.20830631f, 0.23697284f, 0.10274236f, -0.01314427f, 0.15220040f, -0.14759806f, -0.12718165f, 
    -0.01317071f, -0.01873960f, 0.28567335f, 0.33786598f, -0.06630121f, -0.02553728f, 0.12260935f, 0.39806736f, 
    -0.79054368f, 0.07541145f, 0.28530383f, -0.00625555f, -0.10812701f, 0.02690088f, -0.18214399f, -0.00273404f, 
    0.03238240f, 0.04341155f, -0.83662629f, -0.21083705f, -0.36201659f, -0.05840096f, 0.42242455f, -0.00947746f, 
    0.07299712f, 0.00667311f, -0.01302592f, 0.04291081f, 0.16702995f, -0.04760452f, 0.08598144f, -0.11620390f, 
    -0.25915641f, -0.04876794f, -0.49619296f, -0.05354786f, 0.04468238f, 0.00525634f, 0.09168382f, 0.27212697f, 
    0.16682951f, 0.02590071f, 0.21007866f, -0.02254848f, -0.49095419f, 0.01665317f, 0.01022451f, -0.03363061f, 
    -0.06283484f, 0.06950287f, -0.11189721f, 0.13435180f, 0.09888729f, -0.10331988f, 0.12352827f, -0.49843869f, 
    -0.10724477f, 0.05805681f, -0.30303296f, 0.09573742f, 0.01731654f, -0.05637535f, -0.15053563f, -0.01836810f, 
    -0.12904659f, -0.34992385f, 0.06367588f, -0.09049867f, -0.08312882f, -0.00815922f, 0.22564140f, -0.13115811f, 
    0.26948035f, 0.27813828f, 0.11069670f, -0.02987164f, -0.18142094f, -0.61070079f, 0.01186410f, 0.06667469f, 
    0.02356231f, -0.11702085f, -0.71210760f, 0.02958725f, -0.02917491f, -0.31600228f, 0.01615015f, 0.03698573f, 
    0.17519785f, -0.10577265f, -0.71583706f, -0.13992171f, 0.03087489f, -0.40740615f, 0.02722915f, 0.41705477f, 
    -0.07498568f, -0.02969958f, -0.62930942f, 0.16796608f, 0.02815989f, 0.22451484f, 0.08345154f, 0.00491666f, 
    -0.32788801f, 0.17605059f, -0.51177526f, -0.67346656f, -0.00805826f, -0.49828303f, 0.30461875f, -0.21635322f, 
    0.03276810f, -0.21545160f, -0.03713521f, 0.01387602f, 0.11206804f, 0.05449272f, 0.26756111f, 0.22156838f, 
    0.34486142f, 0.11963709f, -0.01814051f, -0.07818606f, 0.05623991f, 0.13112433f, 0.04569613f, -0.26240632f, 
    -0.14651403f, 0.18903793f, 0.01108685f, -0.31915951f, -0.01334506f, -0.10462122f, -0.22872864f, 0.30040535f, 
    -0.73002064f, -0.17888625f, -0.48498660f, -0.08613230f, -0.13615496f, -0.06246963f, -0.27061865f, 0.00841394f, 
    0.11105160f, 0.07757053f, -0.55843234f, -0.05699160f, -0.36589822f, 0.09743659f, -0.15040047f, 0.06881005f, 
    0.28096560f, -0.05609468f, -0.07756624f, 0.03546655f, -0.23272909f, 0.03737704f, 0.19098251f, 0.06332745f, 
    -0.14287953f, 0.00480126f, 0.15227689f, 0.08113207f, 0.21776311f, -0.18105669f, 0.14994463f, -0.17170122f, 
    0.13277608f, -0.01226231f, 0.07807665f, -0.10034770f, 0.06959850f, 0.04058041f, -0.02325526f, -0.12294831f, 
    -0.19614537f, 0.07467052f, 0.17668316f, 0.16930433f, -0.16795009f, -0.07238156f, -0.08776183f, 0.13072713f, 
    0.06214597f, 0.15504009f, -0.43459931f, 0.15369949f, 0.15161449f, -0.18988015f, -0.00798354f, 0.01597870f, 
    -0.06261220f, 0.06422227f, -0.08027770f, 0.26807117f, -0.04922070f, -0.12257531f, -0.02016261f, 0.04716968f, 
    -0.46358275f, 0.11296960f, 0.20956524f, 0.02011686f, 0.44327092f, -0.16832992f, -0.08867302f, 0.04585643f, 
    -0.35661945f, -0.14224635f, 0.10493626f, 0.00865499f, 0.08085670f, 0.01737415f, -0.56487507f, 0.03899646f, 
    -0.15608126f, 0.04316148f, -0.09646267f, -0.49597186f, 0.11186320f, -0.10002192f, -0.22551651f, -0.08937611f, 
    -0.03390352f, -0.04349340f, 0.15412009f, 0.09620605f, -0.03777796f, 0.00209406f, -0.05297603f, 0.07448787f, 
    0.20681053f, 0.19856218f, -0.07410377f, 0.21320990f, -0.03157747f, -0.63936394f, 0.13884707f, 0.00748833f, 
    -0.04324927f, -0.30552354f, -0.04760718f, -0.19638732f, 0.29877120f, -0.04945954f, -0.09674080f, -0.36574873f, 
    0.07396301f, -0.05380540f, -0.32177776f, -0.71052283f, -0.04569047f, 0.11206105f, -0.09606692f, -0.01983548f, 
    -0.17292094f, -0.17005147f, -0.02212948f, -0.07803942f, 0.00578088f, -0.38772559f, 0.03755974f, 0.10581033f, 
    0.00633720f, 0.00347144f, 0.18794927f, 0.04175379f, -0.01341080f, -0.16138111f, 0.11246885f, -0.23759845f, 
    -0.07973640f, -0.62030315f, 0.09935997f, -0.21884404f, 0.02122110f, 0.23196220f, -0.11785916f, -0.28079942f, 
    0.05277823f, -0.04834193f, -0.09482859f, -0.07717325f, 0.01320706f, -0.38844168f, 0.42608252f, -0.18598118f, 
    -0.25923797f, 0.03680807f, 0.29974198f, 0.05606932f, 0.09947383f, 0.25808311f, -0.02170873f, -1.62253404f, 
    -0.19039527f, -0.13931596f, -0.11428791f, 0.21901782f, 0.24248360f, -0.03671319f, -0.03263925f, -0.01875045f, 
    0.13754627f, 0.22240423f, -0.06040045f, -0.44907120f, -0.18388370f, -0.28308043f, -1.06682634f, -0.00673744f, 
    0.06388360f, 0.15834972f, 0.11143858f, 0.04687673f, 0.47156331f, -0.14738882f, 0.02780417f, -0.06042939f, 
    -0.09561619f, 0.41676250f, -0.00768968f, 0.00799560f, 0.04458853f, 0.22968841f, -0.10608544f, 0.04491196f, 
    0.22667532f, -0.07882304f, -0.06395304f, 0.00766936f, 0.01619054f, 0.28096834f, -0.04754078f, -0.00299675f, 
    0.02610293f, -0.12236985f, 0.05341204f, 0.06098009f, 0.01436095f, 0.08285886f, 0.13783053f, 0.08028778f, 
    -0.08077917f, -0.16527845f, 0.01117301f, -0.04019298f, -0.17735507f, -0.25968418f, -0.18498169f, -0.31335413f, 
    -0.00458038f, -0.00779425f, -0.08451208f, 0.12966651f, 0.25457123f, 0.02210022f, -0.04430208f, -0.00773104f, 
    -0.03585834f, -0.27439868f, -0.35050774f, 0.15872431f, -0.03961715f, 0.21398035f, 0.00487914f, -0.05649747f, 
    -0.06815853f, 0.07829266f, 0.15362550f, -0.13439409f, -0.26006514f, -0.11417624f, 0.08294167f, 0.17944826f, 
    -0.53247333f, 0.11488542f, 0.15577659f, 0.10811393f, 0.01766513f, 0.09268349f, -0.02368771f, 0.13517730f, 
    0.11764482f, -0.03065361f, 0.10936262f, 0.07217427f, -0.00357127f, -0.09351085f, -0.47475839f, -0.42235401f, 
    0.17447548f, -0.10543407f, -0.54735994f, 0.11444052f, 0.13060059f, 0.03318679f, 0.10141324f, 0.07483406f, 
    0.11639178f, 0.15705296f, 0.09193265f, 0.28594679f, 0.09551736f, 0.03087664f, -0.00748761f, -0.17418513f, 
    -0.57699478f, -0.08903294f, 0.00236665f, -0.01980545f, 0.21155429f, 0.03755342f, 0.04269107f, 0.01490016f, 
    0.18996254f, 0.07434208f, 0.10719787f, -0.17156048f, -0.11327641f, -0.06539846f, -0.05786337f, -0.35211030f, 
    0.02483017f, -0.04026391f, -0.26986232f, 0.00464147f, -0.06097986f, 0.02600121f, -0.05548310f, 0.10366365f, 
    0.07445647f, -0.34718287f, -0.34231073f, 0.27244833f, 0.07180307f, -0.03439888f, 0.00322519f, 0.38553864f, 
    -0.29961956f, -0.22695480f, 0.09573652f, -0.12824808f, -0.00005277f, 0.33396044f, 0.05765162f, -0.01635155f, 
    -0.17423837f, -0.58968753f, 0.05670718f, 0.17054076f, 0.03423430f, 0.09028320f, -0.02782648f, 0.02147834f, 
    -0.06415483f, -0.04341723f, -0.27999872f, -0.12330309f, 0.14274126f, -0.17497048f, 0.02955064f, 0.03481516f, 
    0.01824630f, -0.24129404f, 0.04717767f, -0.00681415f, 0.06869532f, 0.15033706f, 0.06193320f, -0.05118151f, 
    0.12702876f, -0.03256100f, -0.19115424f, 0.23689525f, 0.08544434f, 0.09833472f, -0.14303558f, -0.39590803f, 
    0.08142138f, -0.02879865f, 0.04064352f, -0.40811092f, 0.06819414f, -0.36026615f, 0.01619165f, 0.18813615f, 
    -0.14024790f, 0.05712397f, 0.01671178f, -0.22796996f, 0.09618180f, -0.26961705f, 0.07635349f, 0.16605867f, 
    -0.05826902f, -0.15745938f, -0.39738864f, 0.03443873f, -0.15755279f, -0.06264671f, -0.16586815f, 0.21436538f, 
    -0.24935694f, -0.09537712f, -0.30283234f, -0.08874922f, -0.00939579f, 0.10536625f, 0.14216436f, 0.15302852f, 
    0.04172542f, -0.07553757f, 0.12579252f, 0.09313545f, -0.03190605f, 0.20146419f, 0.16141655f, -0.03262376f, 
    -0.17028508f, -0.04124454f, -0.04350658f, -0.02460563f, 0.06889673f, 0.08309309f, -0.10206613f, 0.10280328f, 
    0.06386960f, 0.07647649f, -0.01965597f, 0.08882275f, -0.28200957f, -0.41399351f, 0.10884145f, 0.09211841f, 
    -0.11887988f, 0.02733740f, 0.10354958f, 0.16248286f, -0.13040107f, 0.05004940f, -0.05430583f, -0.08408003f, 
    0.15780644f, 0.11314638f, -0.55853832f, -0.25048193f, 0.18338524f, -0.01552016f, 0.01762984f, -0.29659915f, 
    -0.13303161f, 0.15884359f, 0.12959263f, 0.15696421f, -0.25918382f, -0.13739698f, 0.09822594f, 0.05067584f, 
    0.21649863f, -0.70818263f, 0.02792261f, -0.46577275f, 0.05431814f, -0.13248491f, 0.01528279f, -0.91374069f, 
    0.11471301f, -0.17537083f, -0.13874012f, 0.19936508f, -0.20383598f, -0.15692562f, -0.00948611f, -0.01861591f, 
    -0.06102341f, -0.30530581f, 0.06670179f, 0.13595475f, -0.02559640f, -0.20492324f, 0.17711553f, 0.19189031f, 
    -0.02378224f, -0.10750851f, -0.05230842f, 0.04213664f, 0.14934382f, -0.65076196f, -0.07910976f, -0.05133023f, 
    -0.08360936f, 0.00650816f, -0.54195887f, -0.04269836f, -0.80250233f, 0.00572353f, -0.05168869f, -0.06357314f, 
    0.08526174f, 0.21262518f, -0.19609255f, -0.31255955f, 0.14418583f, -0.28678697f, 0.18911627f, 0.16572225f, 
    -0.18501268f, -0.05792777f, -0.40445134f, 0.11195292f, 0.22023255f, -0.17804144f, -0.09937834f, -0.81893760f, 
    -0.57760000f, 0.19486792f, -0.07722684f, -0.57730204f, -0.02612177f, -0.05494827f, 0.20112628f, -0.16643764f, 
    -0.07812050f, 0.07318520f, 0.00696724f, 0.04706810f, -0.04973102f, -0.01480347f, -0.23617922f, -0.19588889f, 
    0.37163529f, 0.15927653f, -0.24913360f, 0.08947245f, 0.00733564f, -0.73544019f, 0.01505655f, -0.53957558f, 
    -0.23233521f, 0.15899637f, -0.36073861f, -0.66809011f, -0.07174302f, -0.14251563f, -0.19780138f, 0.34396592f, 
    -0.12512518f, -0.29380906f, 0.00470038f, -0.13426560f, -0.08158901f, -0.20599636f, -0.25008950f, -0.17373589f, 
    0.05159410f, 0.03623612f, -0.63816553f, -0.18820137f, -0.12362082f, -0.00950951f, -0.12777621f, -0.09686370f, 
    0.21778795f, 0.04869309f, 0.14433309f, -0.28591102f, -0.13219130f, 0.09653315f, -0.03279613f, 0.32235634f, 
    -0.01389923f, -0.90637392f, 0.41318384f, 0.33112177f, -0.76180005f, -0.37475812f, -0.33462548f, 0.16586302f, 
    -0.02679864f, 0.17991014f, 0.38998702f, -0.18961616f, 0.14461978f, 0.12724479f, 0.17254990f, -0.24499141f, 
    -0.42493927f, 0.12609535f, 0.19946994f, -0.05551120f, -0.16274284f, 0.04102422f, 0.08923966f, 0.37755197f, 
    0.18802011f, 0.29441279f, 0.01028771f, -1.07579100f, -0.05325717f, -0.03618012f, 0.16037868f, 0.05013879f, 
    -0.11248629f, 0.17859806f, 0.03652478f, -0.43460461f, 0.04444705f, -0.01734171f, -0.39187050f, 0.09788000f, 
    -0.52201080f, 0.09376138f, -0.54594249f, 0.10154670f, -0.27764499f, -0.26427859f, -0.01130623f, 0.04037396f, 
    -0.10409537f, -0.05806511f, 0.23149008f, 0.06569101f, -0.74619299f, -0.13603552f, 0.06660328f, 0.04233463f, 
    -0.54848599f, -0.00361354f, -0.08507759f, 0.37711915f, -0.43765154f, -0.17165695f, -0.10528341f, -0.30284703f, 
    -0.00675675f, -0.04308110f, -0.25810683f, 0.37916130f, -0.23385957f, -0.06076140f, 0.07080330f, -0.02023145f, 
    -0.14677231f, -0.17578447f, -0.20853892f, 0.62825805f, -0.03033963f, -0.04363292f, -0.43061039f, 0.50470734f, 
    0.01628516f, 0.10117415f, -0.13951358f, 0.04880438f, 0.02444319f, 0.05316922f, -0.63545829f, -0.21220063f, 
    -0.23773581f, -0.00484298f, 0.05405130f, -0.03318272f, -0.05495750f, -0.19585279f, 0.18377143f, 0.00548334f, 
    -0.00022884f, -0.05660282f, -0.29135209f, -0.06845887f, -0.08600341f, 0.02477293f, 0.11096083f, -0.50129610f, 
    -0.31118309f, 0.13247424f, -0.05588436f, -0.04933112f, -0.05829640f, -0.06237531f, 0.07829398f, 0.13603756f, 
    0.10879065f, -0.13146117f, 0.34635305f, 0.01543363f, 0.20968571f, 0.25224414f, -0.20561600f, -0.07522339f, 
    -0.69377655f, 0.05195587f, -0.04150494f, -0.04154085f, 0.19066547f, -0.13946494f, -0.12815273f, -0.18564473f, 
    -0.31105724f, -0.55260837f, 0.19330101f, -0.05959446f, -0.03294535f, 0.13701606f, -0.01159407f, -0.17530066f, 
    0.00528017f, -0.04264031f, -0.66089201f, 0.17448004f, -0.08516334f, -0.06375792f, -0.03158157f, -0.01854608f, 
    0.06188167f, 0.11724207f, -0.08419608f, 0.03414015f, 0.11083193f, -0.07248827f, -0.10519437f, 0.16900906f, 
    0.02490866f, -0.98291510f, -0.35029107f, -0.30996835f, 0.03012465f, 0.29797307f, 0.06712426f, -0.10239343f, 
    -0.04780111f, 0.21510516f, 0.07034110f, -0.48763090f, -0.03267064f, 0.12204909f, -0.22042520f, -0.05911348f, 
    -0.28023815f, -0.24659066f, -0.12525626f, 0.06556439f, -0.24333625f, 0.62341553f, 0.03667157f, -0.08724695f, 
    0.00466048f, -0.19845919f, 0.24443023f, 0.06866641f, 0.07223021f, -0.21042632f, -0.11191335f, -0.10790668f, 
    -0.06435591f, -0.36172387f, 0.42671224f, 0.22210369f, 0.16575384f, 0.30702442f, 0.18576705f, -0.14655693f, 
    0.29440644f, 0.00871750f, -0.19678245f, -0.41469815f, -1.00223076f, 0.09793343f, 0.05553733f, 0.07047907f, 
    -0.24087593f, 0.28965300f, -0.58508474f, 0.00232559f, -0.12972088f, 0.00707101f, -0.71990675f, 0.13664931f, 
    -0.07076462f, 0.13694255f, 0.16829117f, 0.09204628f, -0.02946090f, 0.04309014f, -0.54867387f, -0.25736704f, 
    0.04391658f, -0.25903198f, -0.00451452f, -0.15070905f, 0.03846347f, -0.24001434f, 0.17674567f, 0.09047114f, 
    -0.00684151f, -0.03694544f, -0.53320533f, 0.00330238f, 0.01058053f, 0.15441334f, 0.13657457f, 0.23294732f, 
    -0.47601837f, 0.12038844f, -0.12155576f, -0.28265956f, -0.12330821f, -0.07193755f, -0.04892162f, -0.23692213f, 
    -0.27388662f, -0.34207886f, 0.25566119f, -0.17194167f, 0.03143834f, -0.36910158f, -0.57015103f, 0.14857867f, 
    0.09268517f, 0.06373487f, -0.07871008f, 0.03939994f, -0.02266071f, 0.15668732f, -0.07299235f, 0.29272151f, 
    -0.04573394f, -0.08717463f, -0.25728908f, -0.03848091f, 0.37779915f, -0.25710955f, 0.35939771f, -0.08213266f, 
    -0.31204623f, -0.04190776f, -0.38709873f, -0.08145878f, -0.86320275f, 0.04422378f, -0.52940166f, 0.01865982f, 
    -0.30893955f, -0.14149781f, 0.11275005f, -0.12156145f, -0.13560657f, 0.12187021f, -0.01644288f, -0.25950354f, 
    0.08321142f, -0.00713894f, -0.26984113f, 0.23782261f, -0.01865923f, -0.19207056f, -0.10688121f, -0.09465405f, 
    0.00539570f, -0.09864157f, -0.02979834f, -0.43501690f, 0.01483973f, -0.60486376f, -0.29088354f, 0.08526634f, 
    -0.15154326f, 0.23635130f, 0.33392751f, -0.12685823f, -0.55575275f, 0.19929814f, -0.07646767f, 0.06496377f, 
    -0.10585401f, -0.08446226f, -0.09723802f, 0.03064524f, 0.25748494f, -0.07458869f, 0.09146246f, 0.04922871f, 
    0.01731262f, -0.27286059f, -0.31277764f, -0.19181177f, -0.06752408f, -0.57705235f, -0.10038020f, -0.05010902f, 
    -0.16928306f, -0.09016892f, -0.25058720f, 0.27642468f, 0.25249261f, -0.17558487f, 0.03618015f, -0.15057185f, 
    -0.15497357f, -0.03916613f, -0.15165538f, 0.13527349f, -0.04848820f, 0.20982040f, 0.30931550f, -0.08278880f, 
    0.07990306f, -0.10191652f, -0.51213193f, 0.08136456f, 0.01780002f, 0.00766844f, -0.04456928f, -0.35777816f, 
    -0.18837121f, 0.13593264f, -0.15636949f, 0.13062957f, 0.01896612f, -0.02128076f, 0.20798063f, 0.19191447f, 
    -0.06435113f, -0.08503596f, -0.41963527f, -0.25226623f, -0.10137061f, -0.02464084f, -0.32643494f, -0.58298045f, 
    -0.61493456f, -0.06258049f, 0.01244043f, -0.01903111f, 0.05032500f, 0.11184692f, -0.01619263f, -0.25193676f, 
    0.11528529f, -0.32489765f, 0.40068102f, 0.27460173f, -0.02096718f, 0.30558413f, -0.40325877f, -0.01358485f, 
    -0.04661280f, -0.03382028f, -0.09665225f, -0.10706092f, -0.04047571f, -0.11599118f, -0.32419398f, -0.20815994f, 
    -0.18064216f, 0.14860809f, 0.08689980f, 0.11037057f, -0.43464893f, -0.32745305f, -0.31228769f, 0.09206460f, 
    -0.06484438f, -0.17540121f, 0.07762768f, -0.17973690f, 0.15466921f, 0.01291984f, -0.11867984f, 0.16578250f, 
    -0.03226627f, -0.18651849f, 0.08167417f, 0.24906980f, -0.01767433f, -0.06154543f, 0.03746532f, 0.24506123f, 
    -0.01158889f, -0.00678654f, 0.16445267f, -0.21683939f, -0.49062774f, 0.17488714f, 0.17031474f, 0.00546100f, 
    -0.02980642f, 0.01197448f, -0.04188276f, 0.32188803f, -0.01243050f, -0.15733293f, -0.88677377f, 0.05713312f, 
    -0.44315726f, -0.26275977f, -0.58485007f, 0.20632175f, 0.20914668f, 0.03108350f, 0.01769087f, -0.08829939f, 
    0.25209570f, -0.39979249f, -0.27831814f, 0.00902066f, 0.12591350f, 0.17645554f, 0.12500659f, 0.02355473f, 
    -0.04790290f, 0.19519165f, 0.24326117f, 0.20871526f, 0.16523172f, 0.06916308f, -0.23007607f, 0.01205652f, 
    0.10906483f, 0.00393160f, -0.60746217f, -0.32451022f, 0.18277065f, -0.42827237f, 0.03480725f, 0.23918480f, 
    -0.11216135f, -0.10088749f, 0.10958564f, -0.20627876f, -0.12154109f, -0.13795984f, -0.53785163f, -0.56984699f, 
    -0.10208631f, -0.08478946f, -0.17026515f, -0.03053764f, -0.03198102f, -0.04176139f, -0.41565338f, 0.19138891f, 
    0.18532316f, -0.16652054f, -0.35141978f, -0.45743382f, -0.07368402f, 0.08957043f, -0.29924804f, 0.13960117f, 
    0.17466986f, -0.33976936f, -0.36713016f, 0.25498593f, 0.08138088f, 0.12466405f, 0.12601851f, -0.16416848f, 
    -0.12013520f, -0.08291174f, -0.13185523f, 0.14924164f, 0.20343575f, -0.13406548f, 0.20656937f, -0.53498811f, 
    -0.32323959f, -0.17873093f, -0.09986404f, -0.09069713f, 0.25687549f, -0.81866473f, -0.35073063f, 0.15460752f, 
    -0.03036852f, 0.08566098f, 0.14322254f, 0.13355720f, -0.47889283f, 0.16424404f, -0.15886880f, 0.00930499f, 
    0.25981906f, 0.04359519f, 0.01533761f, -0.19329423f, -0.00670695f, -0.17140959f, 0.15085524f, -0.00251384f, 
    -0.20225798f, -0.16158025f, -0.20841065f, -0.33237725f, -0.50592530f, -0.16805208f, 0.02366089f, 0.18604334f, 
    -0.44891000f, 0.46417573f, -0.17433724f, -0.02216258f, 0.13543087f, -0.11022390f, -0.41247374f, 0.15585233f, 
    0.18957485f, -0.06306106f, 0.29255289f, 0.14305563f, 0.09046824f, 0.12139203f, -0.26883534f, 0.03749175f, 
    -0.01386637f, 0.00557305f, -0.05728519f, -0.35103863f, 0.07953243f, -0.16552047f, -0.49715009f, -0.03013135f, 
    0.29757446f, 0.13478415f, 0.39325985f, 0.08683078f, -0.57223457f, -1.18408108f, 0.05506397f, -0.07678582f, 
    -0.22388279f, 0.22466005f, -0.07883706f, -0.00768890f, -0.30012572f, -0.35178715f, 0.08672944f, -0.01195706f, 
    0.09804410f, 0.23564097f, -0.12156280f, 0.02400721f, -0.26716620f, -0.06376816f, 0.18320295f, -0.51882011f, 
    -0.28728816f, -0.02318285f, -0.19583392f, -0.48734435f, 0.09139649f, -0.07241788f, -0.06513035f, 0.37929264f, 
    -0.13062499f, 0.20536791f, -0.31136850f, -0.09995274f, -0.24942398f, 0.03618630f, -0.40780950f, -0.42843738f, 
    -0.02331655f, 0.02729785f, -0.38605258f, 0.10570651f, 0.07086878f, -0.08411822f, -0.47262928f, 0.09132265f, 
    -0.14351903f, 0.12261593f, -0.03150264f, 0.22073525f, -0.02740192f, -0.22967175f, -0.30198696f, -0.18038841f, 
    0.12298771f, -0.19986838f, -0.18264118f, -0.95843208f, -0.11085360f, -0.06753297f, 0.19157492f, -0.33966935f, 
    -0.46974424f, -0.08112044f, 0.17815177f, -0.34211129f, -0.01444437f, -0.04777293f, 0.22656956f, -0.07155105f, 
    -0.23029450f, 0.41130054f, -0.06285001f, -0.04047056f, 0.05604113f, -0.19565339f, -0.33958539f, 0.20619246f, 
    0.04671944f, -0.04811144f, 0.20580237f, -0.07301554f, 0.07682485f, -0.00842918f, -0.20424604f, -0.10477524f, 
    0.39645556f, -0.05343083f, 0.00526182f, -0.01916038f, 0.10845974f, -0.27621192f, -0.18715720f, -0.40509081f, 
    0.00270123f, 0.09595703f, -0.14050636f, -0.10484483f, 0.29728171f, 0.12837331f, 0.02610814f, -0.31477088f, 
    0.17870903f, -0.24586783f, -0.04371331f, -0.04102143f, -0.15173520f, 0.29510149f, 0.02966422f, -0.48231474f, 
    0.11885290f, -0.06394165f, 0.09807646f, 0.21265554f, -0.52898848f, -0.15414406f, -0.10352190f, -0.09468225f, 
    0.02491739f, 0.24315074f, -0.07264188f, -0.20221865f, 0.00292461f, -0.12859435f, -0.49281132f, 0.20877109f, 
    -0.50333089f, -0.33053398f, 0.11178878f, -0.12718029f, -0.03792634f, 0.02638383f, -0.02060888f, 0.06388737f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.09626997f, 0.03476759f, 0.10960484f, -0.08347758f, -0.07793039f, -0.01015689f, -0.09585086f, -0.02827644f, 
    0.04059862f, 0.16916209f, 0.03608508f, 0.08223193f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
