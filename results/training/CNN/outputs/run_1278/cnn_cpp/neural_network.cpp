#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.71344680f, -0.31594056f, -0.32889736f, 0.48859820f, -0.31243634f, -0.53225207f, -0.08985591f, 0.27038434f, 
    0.47005138f, -0.48669788f, 0.41108379f, -0.21822047f, -0.05975709f, -0.03333420f, -0.03023056f, 0.28548643f, 
    -0.00007285f, -0.28926238f, 0.07566126f, 0.02601226f, -0.05517476f, -0.01588157f, -0.13346598f, 0.19440053f, 
    -0.13050191f, -0.05898865f, 0.16209412f, 0.22474025f, 0.07673310f, -0.27238888f, -0.21799155f, 0.02407994f, 
    0.15267628f, 0.01814095f, -0.26048416f, 0.02113315f, 0.22059713f, -0.05099984f, 0.46772605f, -0.50903040f, 
    0.01495487f, 0.14098701f, 0.16043285f, 0.07145124f, 0.10430360f, 0.11513502f, 0.14006893f, 0.14783926f, 
    -0.13161792f, 0.32439354f, 0.27930874f, 0.32941520f, 0.37401900f, 0.18069568f, -0.25998363f, 0.02556807f, 
    0.15709472f, 0.26664671f, 0.02399496f, -0.00185100f, 0.31738567f, -0.00975951f, -0.18135785f, -0.06940856f, 
    0.07991323f, -0.00108336f, 0.06438605f, 0.07705117f, -0.27597308f, 0.14186934f, 0.07332357f, 0.03449673f, 
    -0.08419616f, -0.10757613f, 0.18848677f, -0.57042837f, -1.06095290f, -0.86214268f, 0.62940741f, 0.45126641f, 
    0.03192613f, 0.40646449f, -0.02806233f, -0.11082283f, -0.19991156f, -0.17257348f, 0.05670973f, 0.08511150f, 
    -0.14851020f, 0.27942228f, -0.03540153f, 0.20858014f, 0.18528678f, -0.05562914f, 0.20762856f, 0.20445767f, 
    -0.24805516f, 0.19086529f, -0.05248148f, -0.04354081f, 0.08775914f, -0.06171331f, -0.26147774f, 0.30401236f, 
    0.05489672f, -0.11813430f, 0.09411035f, -0.17864290f, -0.58911610f, -0.80526465f, 0.13488822f, 0.24003750f, 
    -0.27505347f, 0.42198873f, -0.20130435f, 0.17694305f, -0.26015607f, 0.09124754f, 0.10303547f, -0.09014422f, 
    -0.41144049f, -0.03873866f, 0.26211923f, 0.29540911f, -0.14876013f, -1.14279509f, -0.75537133f, -0.07946257f, 
    0.24417795f, 0.56351954f, 0.59085399f, 0.36759898f, -0.29998752f, -0.40826398f, 0.40448874f, -0.17023161f, 
    -0.39091218f, -0.54628140f, -0.11020116f, 0.28324908f, 0.13799745f, -0.08861528f, -0.06720892f, -0.18506932f, 
    0.02325874f, 0.02512139f, -0.38103619f, 0.01964992f, 0.03631348f, -0.06434979f, -0.45188627f, 0.59811234f, 
    0.42368007f, -0.12172989f, 0.07357298f, -0.43261763f, -0.46931887f, 0.14180589f, -0.11395004f, 0.00985077f, 
    0.03046955f, -0.45488438f, 0.30685452f, -0.05680431f, -0.10829436f, 0.17375982f, 0.31429413f, 0.16281977f, 
    0.12924014f, -0.36756209f, -0.16970149f, -0.12661429f, -0.09341746f, 0.35177559f, 0.11168338f, 0.16102970f, 
    -0.69789755f, -0.06813893f, 0.02243570f, -0.06041712f, -0.60829335f, -0.90433735f, -0.35251090f, 0.22349235f, 
    -0.52174276f, 0.50839627f, -0.03689232f, -0.33078605f, -0.07422658f, 0.45247239f, -0.40853882f, 0.30681178f, 
    -0.01434209f, -0.22927155f, -0.08784338f, -0.22566694f, 0.09130243f, 0.12266814f, -0.08909641f, -0.30741349f, 
    -0.61108202f, -0.07911689f, 0.54726410f, 0.11869904f, -0.28283569f, 0.21246146f, -0.00299931f, 0.42809933f, 
    -0.18758681f, -0.19599189f, 0.01422420f, -0.17223649f, 0.05108829f, 0.35171747f, -0.05814754f, -0.35110343f, 
    -0.27663431f, -0.17916021f, 0.19736212f, 0.28887090f, 0.25989905f, -0.05840070f, -0.00994114f, 0.14645448f, 
    -0.06125870f, -0.95126390f, -0.48527732f, -0.48283705f, -0.53573704f, -0.55663890f, 0.14486812f, 0.27517098f, 
    0.34064463f, 0.47131628f, 0.54023570f, -0.07000364f, -0.09403903f, -0.02132629f, 0.19962618f, -0.14401343f, 
    -0.12749073f, 0.24730819f, 0.02967904f, -0.05044373f, 0.14660308f, -0.30351874f, -0.01198623f, -0.19579764f, 
    -0.20923297f, -0.19847666f, 0.26786798f, 0.69653308f, 0.18653107f, -0.35308230f, -0.38429698f, -0.33440286f, 
    -0.16184357f, 0.03512825f, -0.01097926f, -0.56325549f, -0.14638309f, 0.29917216f, 0.20123491f, 0.31293461f, 
    -0.24023977f, 0.02923362f, -0.06910147f, -0.07975676f, 0.24651921f, -0.29011250f, -0.20502341f, -0.28927392f, 
    -0.41657144f, -0.33967710f, -0.19972286f, -0.02892274f, 0.37909833f, -0.13900226f, 0.07230426f, -0.37885231f, 
    -0.21358199f, 0.03458095f, -0.20619857f, 0.16779664f, 0.32233259f, 0.07633992f, -0.32822570f, -0.19855344f, 
    -0.28125194f, -0.01422725f, 0.00312639f, 0.19606382f, -0.00157351f, -0.04742755f, -0.21768890f, -0.11606639f, 
    -0.27244312f, -0.58539784f, -0.43144420f, -0.59679598f, -0.41113046f, 0.07150003f, -0.29321113f, 0.35438782f, 
    -0.14376114f, 0.16304158f, 0.11180616f, -0.38079935f, -0.28004658f, 0.25976014f, 0.18556218f, 0.07135177f, 
    -0.04608498f, -0.18662983f, 0.07451067f, -0.32697412f, 0.12830681f, 0.07197762f, -0.06189098f, -0.10493251f, 
    0.26502272f, -0.08687119f, 0.08886062f, 0.26157275f, 0.27104011f, -0.98429245f, -0.82174116f, 0.15959349f, 
    -0.03060130f, 0.41290355f, 0.22809765f, -0.28444487f, -0.20014898f, 0.29635063f, 0.75935352f, 0.08731013f, 
    0.16757886f, 0.00932651f, 0.12969455f, -0.21981624f, -0.12129755f, -0.04917313f, -0.36417320f, 0.08581070f, 
    0.16656792f, -0.30248484f, 0.37827015f, 0.18849243f, -0.17833352f, -0.05967380f, -0.42899102f, -0.16606192f, 
    -0.14965640f, 0.28838071f, 0.58288181f, 0.36227465f, 0.33145630f, 0.42870599f, 0.00831265f, -0.20968944f, 
    -0.48224112f, -0.36325604f, -0.13078789f, 0.57527113f, -0.52091706f, 0.01013909f, -0.14424548f, -0.20029657f, 
    0.08304189f, 0.01991362f, 0.05891906f, 0.06670138f, -0.09726652f, -0.13615113f, -0.00495705f, 0.63378197f, 
    0.26095447f, -0.09105866f, -0.40275306f, 0.20711251f, 0.47253776f, -0.33946964f, -0.15950029f, 0.44248709f, 
    -0.27775010f, -0.27878311f, 0.35851890f, -0.22051287f, -0.25363955f, -0.13068752f, -0.35955936f, 0.27357268f, 
    0.05810407f, -0.12362596f, -0.13135168f, -0.05086593f, 0.17906578f, -0.09979969f, 0.07944361f, -0.06365675f, 
    -0.53377986f, -0.53300881f, -0.00254230f, -0.09784181f, -0.15116794f, -0.36978066f, -0.23559432f, -0.21655987f, 
    -0.33811164f, -0.68981946f, 0.52728003f, -0.07916069f, 0.02179423f, 0.05377046f, -0.16649425f, 0.18670395f, 
    0.06725631f, -0.14883977f, -0.27728355f, 0.10031919f, 0.17844804f, 0.24260548f, 0.12441194f, -0.03582962f, 
    0.38239697f, 0.73040807f, -0.15561864f, 0.24066484f, 0.61713320f, 0.05980448f, -0.53327334f, -0.04800737f, 
    -0.18382466f, -0.39607161f, -0.34869975f, -0.07495952f, -0.08583814f, 0.23034084f, 0.18392287f, -0.05638196f, 
    -0.12395749f, 0.20121281f, 0.23836106f, -0.22310162f, -0.06227021f, -0.17094529f, -0.10390372f, 0.14590658f, 
    0.18283564f, -0.11701536f, -1.06831658f, 0.96381670f, -0.65795016f, -0.58008611f, 0.31694949f, 0.13478740f, 
    0.89177817f, 0.55013949f, -0.61293334f, -0.63222432f, -0.15959276f, 0.15425040f, -0.14087081f, -0.29699054f, 
    -0.04251264f, -0.18922545f, -0.27863875f, -0.12079160f, 0.15172462f, -0.26625031f, 0.27637306f, -0.14681412f, 
    -0.18426624f, 0.18907231f, -0.33394927f, -0.78290665f, -0.94671005f, -0.07310341f, 0.13923533f, -0.49447557f, 
    -0.35118806f, -0.03864033f, -0.36589107f, -0.18399796f, -0.09111314f, -0.44560614f, 0.09823345f, 0.00791367f, 
    -0.20014453f, -0.13575937f, -0.15081134f, 0.24653450f, -0.09398498f, -0.33273628f, 0.27741450f, -0.26006269f, 
    -0.42174739f, -0.36642599f, 0.32318491f, 0.16409215f, 0.76495636f, 0.64801592f, -0.43655190f, -0.70094711f, 
    -1.03964078f, -0.18407148f, 0.00050538f, 0.21360433f, 0.32412931f, 0.34981245f, 0.09515110f, 0.03357987f, 
    -0.00370004f, 0.19903687f, -0.17576537f, 0.17455783f, -0.15030070f, -0.37698510f, -0.26722947f, 0.32218492f, 
    0.11684556f, -0.06810076f, -0.12387879f, 0.05644825f, 0.27217305f, 0.62609947f, 0.37572014f, -0.05021017f, 
    0.10023185f, 0.36184967f, 0.09015665f, -0.05360261f, -0.13256989f, -0.46574679f, -0.53785199f, 0.14121069f, 
    0.13680130f, 0.07886983f, -0.10749991f, -0.19446567f, -0.22574282f, 0.06942520f, 0.13644531f, 0.01380691f, 
    -0.02977530f, -0.05940130f, -0.20945656f, 0.05768786f, 0.19901833f, -0.03465116f, 0.39110139f, 0.16064836f, 
    0.19141857f, -0.29749918f, 0.06113071f, 0.05535151f, 0.40302014f, -0.03948042f, -0.25248361f, -0.26268545f, 
    -0.28331023f, 0.17341551f, -0.03720991f, 0.14387400f, -0.08624311f, 0.25717050f, -0.27576587f, 0.09955300f, 
    0.06216204f, 0.03384859f, -0.09310158f, -0.17489129f, -0.07626848f, -0.18792395f, 0.11128525f, -0.35840893f, 
    -0.56825292f, -0.04777103f, -0.73106116f, 0.49974456f, 0.33724663f, -0.38788018f, -0.68660951f, -0.27477992f, 
    0.15771902f, 0.14035796f, 0.59895074f, 0.24581622f, -0.27226910f, 0.20754321f, -0.42910177f, -0.03065713f, 
    -0.14869037f, -0.14122432f, 0.19263409f, 0.02617450f, -0.04085476f, -0.26931071f, 0.28570777f, -0.16741079f, 
    -0.24138740f, -0.05929425f, -0.76473469f, 0.10595096f, -0.25564107f, -0.74111247f, -0.24759772f, -0.57489526f, 
    0.45810652f, -0.00919641f, 0.29490125f, 0.14224932f, 0.39028063f, 0.12869909f, -0.01643295f, -0.07713019f, 
    0.00181268f, 0.01797907f, -0.36923599f, -0.43039826f, -0.35940605f, -0.04890497f, -0.00463977f, -0.11776938f, 
    0.27236217f, 0.37769407f, -0.69277221f, -0.22085218f, -0.03230542f, -0.18996929f, -0.21041670f, -0.42029512f, 
    -0.55341631f, 0.01381723f, 0.39665881f, 0.29365441f, 0.21715736f, 0.08619442f, 0.19352612f, 0.08477773f, 
    -0.06571545f, 0.34525234f, -0.12776418f, -0.17117561f, -0.22683217f, -0.05315749f, -0.00223822f, -0.31539926f, 
    -0.15873481f, -0.33254078f, 0.98063004f, -0.52277756f, -0.22430699f, -0.11919983f, -0.28374392f, -0.02623647f, 
    0.53958428f, 0.21936132f, -0.05483568f, -0.41289216f, 0.10911326f, -0.05343158f, -0.13597451f, -0.47992826f, 
    0.28657404f, 0.11793213f, 0.36706924f, -0.07884674f, -0.08035902f, -0.06304708f, 0.11156373f, 0.12610050f, 
    -0.24767710f, 0.16974761f, -0.09832120f, -1.03884590f, 0.14381021f, 0.35390422f, -0.17268728f, -0.45588675f, 
    0.07938695f, 0.53115916f, -0.42170960f, 0.35918635f, 0.40250424f, -0.12923984f, 0.08617960f, 0.17269745f, 
    -0.40593693f, -0.13630946f, -0.01462537f, 0.06209645f, -0.03204644f, -0.03330677f, -0.01020812f, 0.00520320f, 
    0.10530578f, -0.01026178f, -0.19768728f, 0.31598732f, 0.12808347f, 0.10388824f, -0.30409378f, -0.24563211f, 
    0.42871943f, -0.21149379f, 0.09374144f, 0.29919139f, -0.44924521f, 0.26787868f, -0.07988624f, 0.28894097f, 
    0.24402027f, -0.31893310f, -0.22804727f, -0.21384174f, 0.23068143f, -0.23217759f, -0.01149711f, 0.06841183f, 
    -0.09135034f, 0.14652413f, 0.17595014f, -0.13874364f, -0.08604075f, 0.71062970f, -0.08431689f, -0.28639683f, 
    -0.23962089f, -0.45100564f, 0.43140009f, 0.36506471f, 0.44696125f, -0.16318877f, -0.08304307f, -0.16422756f, 
    -0.28986567f, -0.26908037f, -0.21092848f, -0.20920749f, 0.46005541f, 0.20038611f, 0.10183947f, -0.11847080f, 
    -0.24307746f, -0.19392242f, 0.15566193f, 0.04134874f, 0.16792277f, -0.21241705f, 0.94999415f, -0.40908816f, 
    -0.02936342f, -0.01950001f, -0.67258716f, 0.27856529f, -0.04707978f, 0.24028777f, 0.35360596f, -0.00269741f, 
    -0.16084523f, 0.23358656f, -0.05080121f, -0.28778541f, -0.04299900f, -0.14232223f, -0.24758013f, 0.00844802f, 
    0.05675722f, -0.17662843f, -0.36902913f, -0.37829551f, -0.15023078f, -0.24393320f, -0.42889577f, 0.45669678f, 
    0.44475988f, 0.21881899f, 0.55290550f, 0.19519348f, 0.08169623f, -0.42618683f, -0.38480183f, -0.24599157f, 
    -0.24394085f, -0.12306676f, -0.03988186f, 0.33184034f, 0.05823061f, -0.22116855f, -0.17113571f, 0.03177922f, 
    -0.01842381f, -0.04351625f, 0.25041750f, -0.00034479f, 0.03622728f, 0.13648003f, -0.28606287f, 0.02166505f, 
    0.63383561f, 0.17093588f, -0.44746357f, -0.37163332f, 0.01190084f, 0.44038925f, 0.31402722f, -0.13135956f, 
    -0.38433021f, -0.15964819f, -0.25437126f, 0.10981112f, 0.21714762f, 0.15555683f, -0.06717217f, -0.20559351f, 
    -0.08314767f, 0.23192824f, -0.06045087f, 0.02667037f, -0.18549877f, 0.11880493f, 0.33679467f, -0.08928789f, 
    -0.07858734f, 0.22743596f, 0.10154877f, -0.01846852f, -0.45286280f, 0.26681107f, 0.11865997f, 0.05168025f, 
    0.20991445f, 0.15689504f, -0.12137718f, -0.26192182f, -0.08850940f, 0.17674406f, -0.04498887f, 0.05844088f, 
    0.00058994f, -0.09949350f, -0.18497252f, -0.21230270f, 0.20458743f, -0.07076562f, -0.12267258f, -0.11152545f, 
    -0.30275521f, 0.07371520f, 0.33010042f, -0.39341438f, -0.43912169f, -0.40752757f, -0.17216836f, -0.67610252f, 
    -0.60872406f, -0.68745410f, -0.68650144f, -0.67007273f, 0.10940398f, 0.28341889f, 0.51488960f, 0.02439097f, 
    -0.02397336f, -0.14818877f, -0.11896314f, 0.04945555f, -0.07628670f, 0.21644180f, -0.08405243f, -0.06078568f, 
    -0.02329430f, 0.03979657f, -0.24583520f, -0.63233924f, 0.42622843f, 0.02125748f, -0.04819462f, 0.41737235f, 
    -0.48990920f, -0.17608541f, -0.09639265f, 0.62959236f, 0.17708169f, 0.46857822f, -0.30220461f, -0.11632720f, 
    -0.46637863f, -0.01254604f, 0.39521021f, -0.05915335f, -0.20105600f, -0.13900097f, 0.18222775f, 0.24420924f, 
    -0.29056633f, -0.16123848f, 0.21028480f, -0.20273384f, 0.43810096f, 0.26963153f, 0.18395102f, -0.10935668f, 
    -0.46343228f, -0.39452523f, 0.04454633f, -0.16104124f, -0.07814395f, 0.20247683f, 0.06095877f, 0.07643633f, 
    0.02742533f, 0.45419028f, 0.26506016f, -0.07043227f, -0.32691991f, -0.00783513f, 0.13674259f, 0.15137520f, 
    0.25846022f, 0.12854972f, 0.14010113f, 0.18701521f, -0.36481291f, 0.39825785f, 0.22061801f, -0.10496180f, 
    -0.03928144f, -0.29585350f, 0.26569635f, 0.02795526f, 0.20478640f, -0.08543228f, -0.34223643f, -0.37713775f, 
    -0.28762314f, -0.23558818f, 0.00949682f, -0.04243402f, 0.17080916f, -0.17361882f, 0.08449029f, -0.18001521f, 
    -0.19854346f, 0.00583386f, 0.16717876f, 0.28171915f, 0.09782960f, -0.00738576f, -0.68649447f, -0.10170548f, 
    0.32227027f, 0.17615044f, 0.31115043f, 0.82982916f, 0.37500924f, -0.55296338f, -0.56678659f, -0.61573458f, 
    0.09376083f, 0.41474447f, 0.06522287f, -0.10599666f, 0.01859454f, -0.21496718f, -0.29122001f, -0.09535906f, 
    0.13644470f, 0.31992525f, 0.09588227f, -0.01890572f, -0.14501888f, 0.19566956f, -0.22827134f, 0.47606602f, 
    0.78701240f, 0.13054611f, -0.57954365f, 0.06811430f, 0.05192760f, -0.14277382f, -0.00443678f, -0.52909088f, 
    -0.59960580f, 0.14723852f, 0.27910259f, -0.14456560f, -0.04664890f, -0.09551930f, -0.15223475f, 0.25692853f, 
    0.19145001f, 0.23823237f, 0.02213203f, 0.02391703f, -0.19064637f, -0.21308330f, 0.02517500f, -0.11207443f, 
    0.46897367f, 0.29565859f, -0.03948530f, -0.01038423f, 0.14558284f, -0.02959508f, -0.26743650f, -0.18061222f, 
    0.28499791f, 0.17193985f, -0.12424031f, 0.11478661f, 0.02874679f, -0.05867549f, -0.06938931f, 0.08359537f, 
    -0.20950785f, -0.22481082f, -0.18136404f, 0.18134271f, -0.07025111f, -0.27951464f, -0.11366418f, 0.18343765f, 
    -0.14628741f, 0.74132389f, -0.15994775f, -0.09968209f, 0.04280530f, -0.10061111f, -0.33650175f, 0.26081422f, 
    -0.05038898f, 0.02001589f, 0.44735152f, -0.15311408f, 0.03798381f, -0.20018786f, -0.03117992f, 0.05921981f, 
    0.17950872f, -0.31786364f, 0.20610401f, 0.23767352f, -0.24775808f, -0.05000977f, 0.27590692f, 0.15053378f, 
    -0.35166702f, -0.01193225f, -0.25973496f, -0.01340687f, -0.31084946f, -0.08156588f, 0.08990820f, -0.31724462f, 
    -0.44841185f, -0.45026800f, -0.36127636f, -0.23506007f, 0.37175813f, -0.37258312f, -0.16412184f, -0.32602337f, 
    0.40065566f, -0.14444970f, 0.16031012f, 0.03450235f, -0.13014778f, -0.18594319f, 0.19910969f, 0.03077188f, 
    0.27362531f, 0.09793533f, 0.26727638f, -0.74476141f, 0.25422144f, 0.44235051f, -0.87832177f, -0.56360686f, 
    0.09614094f, 0.10684916f, -0.43210503f, -0.19454819f, 0.58531618f, -0.31587312f, -0.29658416f, -0.07817142f, 
    0.37575966f, 0.24146876f, -0.03224130f, -0.19725011f, -0.27068686f, -0.24502686f, -0.01549389f, 0.09557161f, 
    0.01747560f, -0.28779134f, -0.25830111f, -0.51902980f, -0.75731206f, -0.31923664f, 0.18836598f, 0.07891558f, 
    -0.13908386f, 0.46688113f, -0.24539353f, -0.01813850f, 0.12803273f, 0.02301039f, -0.15500315f, 0.00963047f, 
    -0.13907418f, 0.24774227f, 0.17651188f, -0.11858548f, 0.06651834f, 0.23000744f, 0.02712256f, 0.10088286f, 
    0.13483655f, 0.17957461f, 0.19404601f, -0.15871130f, -0.33990115f, 0.77516979f, 0.31960934f, -0.37520057f, 
    -0.17683244f, -0.10805684f, 0.29172614f, 0.39625591f, 0.26675674f, -0.59225684f, -0.58084792f, -0.29053438f, 
    0.08295844f, -0.07722694f, -0.11487665f, -0.06404663f, -0.02440066f, 0.23145704f, 0.25148803f, -0.19826384f, 
    -0.12130039f, 0.15166534f, -0.27086151f, -0.35076383f, 0.21262513f, -0.02973172f, 0.35389602f, 0.40678707f, 
    -0.18152587f, -0.19353843f, -0.32387152f, -0.06575376f, -0.25336307f, 0.33581924f, 0.33609781f, -0.47422487f, 
    -0.15972413f, 0.09916079f, 0.21659277f, -0.50596589f, 0.30051389f, -0.03370919f, 0.05119267f, -0.06014256f, 
    -0.01119154f, 0.03576505f, -0.12937120f, 0.20871198f, -0.22760895f, -0.17178629f, 0.32929894f, -0.16589719f, 
    -0.53488857f, -0.27782229f, 0.17545667f, 0.34960839f, 0.12122320f, 0.23063414f, -0.04502194f, 0.27091774f, 
    0.27869329f, -0.16568103f, 0.45179176f, -0.33965158f, -0.24982069f, 0.28555909f, -0.45312858f, 0.04608354f, 
    -0.20263042f, -0.17475006f, -0.36649290f, 0.37475905f, 0.20737717f, 0.23183510f, 0.16696754f, 0.12030799f, 
    -0.11557141f, -0.20000006f, 0.46975327f, 0.22059198f, 0.32604298f, -0.66529804f, -1.04023612f, -0.60956913f, 
    -0.02777863f, -0.51346177f, 0.23873757f, 0.05586901f, 0.02426007f, 0.47477135f, 0.05765744f, -0.07193717f, 
    -0.20476213f, 0.14712371f, -0.34983596f, -0.00098437f, 0.00082585f, 0.01810017f, 0.15739667f, -0.31427702f, 
    0.03774454f, -0.20416161f, -0.59398955f, 0.13702838f, 0.31961945f, -0.05260770f, -0.06541027f, 0.00819595f, 
    -0.41549218f, 0.17084970f, 0.37755260f, 0.06146240f, 0.00618775f, -0.31888160f, -0.05469027f, 0.25942004f, 
    -0.43477371f, -0.11922166f, 0.16278504f, 0.26615942f, 0.15122922f, -0.17729554f, 0.09243710f, -0.20607445f, 
    0.43824792f, -0.10624709f, -0.64869189f, -0.57557154f, -0.64977956f, -0.54796916f, -0.66513634f, 0.02237615f, 
    -0.35396153f, -0.60095721f, -0.80785042f, -0.44462642f, -0.31665373f, -0.19709997f, 0.13506936f, -0.20270617f, 
    -0.32629830f, 0.06155650f, 0.02216373f, -0.03223399f, -0.15116809f, -0.00146016f, -0.10315887f, 0.18683344f, 
    0.26806054f, -0.16334817f, 0.04066132f, 0.50989664f, 0.61234391f, 0.11285031f, -0.40412825f, -0.30439490f, 
    -0.25652179f, 0.25075385f, 0.05865888f, -0.09675514f, -0.41309595f, -0.10936886f, 0.14606425f, -0.09383226f, 
    -0.29628867f, 0.20178539f, -0.25648102f, 0.17869431f, 0.07036280f, -0.12893389f, -0.05301605f, -0.26211143f, 
    -0.24858215f, -0.45409009f, -0.57660395f, -0.57529879f, -1.09133089f, 0.18532246f, -0.28059301f, -0.62612110f, 
    -0.58658862f, 0.12461304f, 0.11489832f, -0.38325012f, -0.26571676f, 0.33780590f, -0.06143586f, -0.03737342f, 
    0.03022254f, -0.44712809f, -0.17496395f, 0.34603524f, 0.28363398f, -0.18216695f, 0.29089603f, 0.29163030f, 
    0.10428002f, -0.16310930f, -0.25206885f, 0.10302418f, -0.15316449f, -0.85524923f, -0.53464764f, -0.56508589f, 
    -0.81374782f, -0.36896542f, 0.73232090f, 0.18137932f, 0.39432862f, 0.54176998f, 0.08170813f, -0.17495599f, 
    0.56628036f, -0.15147844f, -0.09174940f, -0.44331008f, -0.12053227f, -0.12584953f, 0.01735787f, -0.10228802f, 
    -0.23952433f, 0.06054466f, 0.23734358f, -0.22588837f, -0.09480262f, 0.08620436f, 0.26555622f, 0.25503796f, 
    0.34290761f, 0.06419590f, 0.35928616f, 0.18570615f, 0.37758756f, 0.43864518f, -0.03936503f, -0.08457264f, 
    0.15047368f, 0.15892462f, 0.20080164f, -0.21579398f, 0.04987876f, 0.20576271f, -0.07606701f, -0.25188175f, 
    -0.11280903f, 0.01061291f, 0.00726060f, 0.34416285f, -0.05528349f, -0.11782239f, -0.08302943f, -0.35257655f, 
    -0.18960325f, -0.32766348f, -0.57101566f, -0.48689154f, 0.29494262f, -0.27878842f, 0.09542529f, 0.36831060f, 
    0.03469190f, 0.19758052f, 0.09314300f, -0.09679314f, 0.10067777f, 0.49035680f, -0.05279226f, 0.14253034f, 
    -0.08702385f, -0.27429402f, -0.08038064f, -0.02321538f, 0.17640460f, 0.06716758f, 0.32463494f, 0.42288694f, 
    -0.58301806f, -0.20312515f, -0.18626830f, 0.76510870f, 0.49115077f, -0.46130997f, -0.41615385f, -0.35762838f, 
    -0.05603692f, 0.34243903f, 0.14187089f, -0.19977385f, -0.04437095f, 0.32870254f, 0.09268975f, 0.07785355f, 
    -0.05871762f, 0.13362712f, -0.15240191f, -0.04684897f, -0.22705096f, 0.21076868f, -0.02720783f, 0.15284240f, 
    -0.01123300f, -0.20495284f, 0.27215818f, 0.17418975f, -0.31598917f, 0.17312261f, -0.48582789f, -0.48833752f, 
    -0.19187380f, -0.52758861f, -0.59265673f, 0.08414113f, 0.36819005f, -0.25319150f, -0.14354652f, -0.27936664f, 
    -0.13158515f, -0.47255874f, -0.23681135f, -0.34347939f, -0.36529487f, -0.09847849f, 0.09210172f, -0.17612959f, 
    -0.45541301f, -0.34486330f, -0.70778406f, -0.14934595f, -0.24241295f, -0.31230873f, 0.09678806f, 0.19927000f, 
    0.25844127f, 0.15273045f, 0.53096724f, 0.61906105f, 0.20798810f, -0.06652480f, -0.18471991f, 0.00267624f, 
    -0.10364207f, -0.10348731f, -0.07322315f, -0.12441369f, 0.02518323f, -0.21656361f, -0.04928448f, -0.13386765f, 
    0.26738313f, -0.08922218f, 0.20350239f, -0.61362439f, -0.28173673f, -0.16708641f, -0.48748767f, 0.04473460f, 
    -0.31567737f, -0.49135011f, -0.44199330f, -0.63372886f, -0.55615699f, -0.24956095f, -0.08824859f, -0.07629079f, 
    -0.33780342f, -0.38515249f, -0.02016919f, -0.46775606f, -0.01330482f, -0.14718470f, -0.01978929f, -0.07980576f, 
    -0.06847370f, 0.14821769f, 0.06192008f, -0.03614656f, -0.07376179f, -0.49153358f, -0.14973712f, 0.16567755f, 
    0.43734494f, 0.43882504f, -0.07822593f, 0.23188405f, 0.40772873f, 0.23935936f, -0.07116900f, 0.01253030f, 
    -0.09269489f, 0.17154258f, 0.10923856f, 0.08049360f, -0.33007848f, 0.13464801f, -0.06654195f, -0.08363261f, 
    -0.10653899f, 0.11303359f, -0.22019003f, 0.22817224f, 0.04476303f, 0.44753754f, -0.29841158f, -0.71682769f, 
    -0.70643073f, -0.47557959f, -0.42578045f, -0.23220953f, 0.19649155f, 0.25257683f, 0.10477636f, 0.03692454f, 
    0.35317579f, 0.32562107f, 0.01205272f, 0.12299851f, -0.01737561f, -0.14842057f, 0.05582430f, -0.23161118f, 
    -0.18059024f, 0.04373131f, -0.24386512f, -0.07041249f, 0.08553817f, -0.16356593f, -0.81007785f, -0.56664568f, 
    0.19170894f, 0.61603093f, 0.49587587f, 0.47358686f, -0.19206926f, -0.56694847f, -0.51681131f, -0.13493080f, 
    -0.35652664f, -0.13858546f, -0.15121661f, -0.23162964f, -0.16351213f, 0.06254420f, 0.00643870f, 0.27804142f, 
    0.31242773f, 0.00638010f, 0.15047984f, -0.00156338f, -0.13468745f, 0.18083698f, -0.15871020f, -0.37401611f, 
    -0.55957323f, -0.46786216f, 0.09201609f, -0.44900417f, -0.17914893f, -0.38590351f, -0.33513781f, 0.18946895f, 
    -0.00407402f, 0.35645023f, -0.36825952f, -0.18564415f, 0.18917273f, -0.23825532f, 0.02295220f, -0.22387342f, 
    -0.37489107f, -0.39943704f, -0.51340353f, -0.03856497f, 0.16729547f, 0.29526186f, 0.14004959f, 0.10263420f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.11279698f, 0.41496831f, 0.03374748f, -0.01424509f, 0.20481449f, 0.44880256f, 0.17497687f, -0.05522569f, 
    0.29465863f, -0.03734832f, 0.13183621f, -0.20675822f, 0.22598396f, 0.22480710f, 0.18121238f, 0.41918647f, 
    0.02383510f, 0.05508473f, 0.26813024f, -0.01045810f, 0.35750794f, 0.03691563f, 0.06276207f, 0.39136791f, 
    0.35449573f, 0.00128209f, 0.21685377f, 0.17084277f, 0.36835304f, 0.26431134f, -0.08569200f, 0.28828508f, 
    0.13142274f, 0.22406591f, -0.10837923f, 0.29715598f, 0.11759450f, 0.06616950f, 0.20037523f, 0.12357515f, 
    0.29029042f, 0.17586203f, 0.10148476f, 0.18300672f, 0.27543041f, 0.32201317f, 0.29911691f, 0.20774668f, 
    0.10028181f, 0.31583402f, -0.60253787f, -0.01417450f, 0.22923137f, 0.19652964f, 0.02587865f, 0.24379440f, 
    0.28285170f, -0.18089260f, 0.35928112f, -0.34226146f, 0.22066590f, 0.29337034f, 0.26818335f, -0.06625390f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.01857623f, -0.08994859f, -0.01301336f, -0.07404397f, -0.06329524f, -0.05344816f, -0.08590472f, 0.03128438f, 
    -0.14617242f, 0.06826051f, -0.16331747f, 0.06134040f, -0.05218496f, -0.04764815f, 0.05008309f, -0.00899802f, 
    -0.32229489f, -0.28641060f, -0.17869090f, -0.01591340f, -0.04355230f, -0.03024959f, -0.04581557f, -0.08392631f, 
    -0.02695358f, -0.04159211f, -0.01088142f, 0.01832651f, -0.00349671f, -0.00599184f, -0.00906632f, 0.02542470f, 
    -0.05003832f, 0.04860934f, -0.01921809f, 0.05889608f, 0.40997154f, 0.00614309f, -0.01529885f, -0.01377933f, 
    0.06151995f, 0.05125739f, 0.17239484f, -0.16417731f, 0.02505354f, 0.04709673f, -0.02043367f, 0.03226326f, 
    0.17962778f, -0.08282776f, -0.23159036f, -0.18292178f, -0.03416087f, -0.22324836f, 0.11580121f, 0.01086290f, 
    -0.04001501f, 0.06879005f, -0.01957489f, -0.04848502f, 0.42397976f, 0.17739350f, 0.00750507f, -0.26296642f, 
    -0.14777762f, -0.04528621f, 0.07633314f, -0.11846741f, -0.10697339f, -0.03047032f, -0.05405104f, -0.05153870f, 
    -0.05845458f, 0.05960820f, 0.13344501f, -0.04574697f, -0.18713458f, -0.11696514f, -0.04131275f, 0.04158714f, 
    -0.02208345f, -0.10669559f, -0.04474064f, 0.01467436f, 0.27646551f, 0.15755390f, 0.06737030f, -0.26858172f, 
    0.05536495f, 0.06214492f, -0.05383400f, 0.10547289f, 0.02108436f, 0.03484289f, -0.05208995f, -0.04443601f, 
    -0.12375989f, -0.25297773f, 0.13258398f, -0.10686245f, 0.00935751f, -0.08456240f, -0.01820435f, 0.05945563f, 
    -0.17079177f, -0.04053722f, -0.13084702f, -0.13032265f, 0.07281388f, 0.09354246f, 0.07146466f, -0.00399678f, 
    0.10818825f, 0.14293668f, 0.13454920f, 0.03143839f, -0.03363115f, 0.16068581f, -0.00600757f, -0.02975849f, 
    -0.02938594f, -0.05280918f, -0.05345595f, 0.04694826f, -0.05271041f, -0.10766434f, -0.18100880f, 0.04872247f, 
    0.03733131f, 0.07367683f, -0.11721372f, -0.06644687f, -0.18308608f, 0.11654997f, 0.05673521f, 0.04089057f, 
    0.02417342f, 0.04697365f, -0.08707523f, -0.02261521f, -0.07173363f, -0.04212934f, 0.28190643f, 0.18289049f, 
    0.09029984f, 0.09871048f, 0.05073403f, 0.01717112f, -0.05355708f, 0.01774594f, -0.03986447f, -0.14118901f, 
    0.00091927f, -0.05275771f, -0.01805091f, -0.01765727f, 0.37369883f, 0.22534105f, 0.16654350f, -0.20447105f, 
    -0.02777649f, 0.11970937f, 0.09336922f, -0.07351559f, -0.06137738f, 0.03836694f, -0.04375819f, -0.07250977f, 
    0.44952801f, -0.12048402f, -0.09664600f, -0.05364996f, 0.01931400f, 0.04603840f, 0.08627496f, 0.05638327f, 
    0.04389812f, -0.00666711f, -0.07369509f, -0.03840631f, -0.29588979f, -0.13900229f, -0.72308165f, 0.10096383f, 
    -0.01058353f, -0.00403237f, -0.06134331f, 0.05511096f, -0.05525208f, 0.01058034f, -0.01495917f, -0.07552812f, 
    0.18828204f, 0.19240099f, -0.07160246f, -0.27395216f, 0.00882280f, 0.02284399f, 0.03444991f, 0.10520121f, 
    -0.01972493f, -0.03502056f, -0.02661699f, -0.04950351f, -0.07160074f, -0.22918302f, 0.24020018f, -0.36631048f, 
    -0.02212277f, -0.01430872f, -0.05774982f, -0.10071082f, 0.02126706f, 0.05784210f, 0.04421784f, 0.08611666f, 
    -0.08337857f, -0.01503600f, -0.36375406f, -0.06711557f, -0.08355379f, 0.05406545f, 0.05461622f, -0.06948990f, 
    -0.17634936f, -0.16466995f, 0.10589591f, 0.19489844f, 0.35019130f, 0.15504470f, 0.01729169f, -0.21323504f, 
    0.20230006f, 0.08563910f, 0.30177093f, 0.07087011f, -0.02523475f, -0.05668925f, 0.03955091f, -0.02373595f, 
    -0.09315714f, -0.37077573f, -0.04469066f, 0.04447628f, -0.04421028f, -0.04125005f, -0.01721815f, -0.23078692f, 
    -0.12397577f, -0.22736423f, 0.06371108f, -0.03196428f, -0.07474369f, -0.13869067f, -0.57244980f, 0.07858910f, 
    0.04396669f, -0.03543400f, -0.00661850f, -0.04380235f, 0.01144206f, 0.06239339f, 0.00386669f, 0.05166607f, 
    -0.05147240f, -0.14732297f, -0.05580374f, 0.03217189f, -0.01289536f, -0.01248207f, -0.00799800f, -0.09237474f, 
    -0.12163096f, 0.04655046f, 0.01969884f, -0.22711128f, 0.26010045f, 0.24828784f, -0.11592591f, -0.12235059f, 
    -0.14709587f, 0.05309637f, -0.18631427f, -0.02816804f, 0.03271694f, -0.07479785f, -0.02550045f, -0.07508536f, 
    0.24855931f, 0.22254716f, 0.02835527f, -0.26563320f, -0.05738705f, -0.07264539f, -0.04490141f, -0.09083045f, 
    -0.07275293f, -0.01706576f, -0.05755733f, 0.05421775f, 0.11873335f, 0.22106525f, 0.03388830f, -0.17716236f, 
    0.00475825f, -0.05291261f, 0.02932812f, -0.00508390f, 0.05572480f, 0.15848000f, -0.07892367f, 0.06744596f, 
    0.09418456f, -0.27676025f, -0.07643565f, -0.00224277f, -0.05997717f, -0.25863510f, -0.20069994f, -0.02704133f, 
    -0.06734209f, 0.10551855f, -0.00279953f, 0.01085120f, 0.07315060f, 0.06658889f, 0.10916315f, -0.13600910f, 
    -0.09187543f, -0.08729487f, 0.11021615f, -0.00400757f, 0.05447719f, -0.08722531f, -0.06972724f, -0.05324688f, 
    -0.39546287f, 0.37910908f, -0.34196448f, 0.04188237f, -0.03737708f, -0.05224714f, 0.07723723f, -0.00701107f, 
    -0.03390659f, -0.03930445f, 0.05213522f, -0.11705410f, 0.09069420f, -0.08342801f, -0.37190676f, -0.00363843f, 
    0.04949019f, 0.08077949f, -0.02617582f, 0.01242780f, -0.01039031f, 0.07859896f, -0.10629370f, 0.02124036f, 
    -0.35412654f, -0.31066501f, -0.02974613f, 0.04010246f, 0.04771488f, 0.00510077f, -0.04797708f, 0.03837721f, 
    -0.04092352f, -0.00167369f, 0.05587433f, 0.29714856f, -0.28548867f, -0.16863798f, -0.09014638f, -0.02741310f, 
    0.09124593f, -0.04330766f, -0.03166581f, 0.04817985f, -0.03405337f, 0.04458249f, -0.01117353f, 0.00095595f, 
    -0.07372330f, -0.31347179f, -0.29409954f, 0.19363730f, 0.12137179f, -0.00285743f, -0.01066374f, -0.04334126f, 
    -0.05894877f, -0.09301679f, -0.09803975f, -0.01506448f, -0.37406603f, -0.37094322f, -0.17332004f, 0.09520870f, 
    0.01814703f, 0.07409369f, -0.06751692f, 0.01337377f, 0.01656219f, -0.11072264f, 0.04009026f, -0.19515085f, 
    0.29835889f, 0.22778323f, -0.17434588f, -0.19288790f, 0.04895969f, -0.04568077f, -0.04315973f, 0.10913535f, 
    -0.00004592f, -0.02078611f, -0.00863245f, 0.02800568f, -0.71006060f, 0.26659060f, 0.12538619f, -0.13196211f, 
    -0.01298950f, 0.05641619f, -0.04910100f, 0.01995919f, -0.06136341f, -0.11548229f, 0.01576930f, 0.06051616f, 
    -0.05170253f, -0.05613602f, 0.01019927f, 0.03485580f, -0.05788372f, -0.04745414f, 0.02223001f, -0.02832779f, 
    0.00587754f, 0.01067522f, -0.05385222f, 0.01072876f, 0.03932538f, -0.08352724f, 0.00292882f, 0.01202315f, 
    -0.02453230f, 0.00452020f, -0.01855474f, 0.06190604f, -0.02305101f, -0.01378779f, 0.00972814f, 0.06285174f, 
    0.21648832f, 0.16325793f, -0.20473972f, 0.00134844f, -0.04576865f, -0.08983310f, -0.02747361f, 0.00023389f, 
    -0.24409197f, -0.09314923f, 0.01315320f, -0.07871746f, -0.01447082f, -0.12608083f, -0.52744240f, 0.15372124f, 
    -0.02880108f, -0.17794494f, -0.30113229f, -0.09984277f, -0.08249345f, 0.08560118f, -0.01510693f, -0.00701204f, 
    -0.49585292f, -0.13723701f, -0.18572852f, 0.00606563f, 0.04618158f, 0.03344036f, -0.00074791f, 0.01093667f, 
    -0.04955157f, 0.00294238f, -0.01138627f, 0.06919122f, -0.22456957f, 0.01300503f, -0.01192117f, -0.02934374f, 
    -0.02264686f, -0.02023558f, 0.11432420f, 0.03343664f, -0.10750562f, -0.04740534f, -0.23786153f, -0.12681203f, 
    0.18835531f, 0.19920324f, -0.13991000f, -0.35877004f, -0.01193590f, 0.13914876f, -0.02518381f, -0.15840533f, 
    0.01717808f, -0.03188494f, 0.01538221f, -0.06699008f, -0.01078446f, 0.02186540f, -0.11060982f, -0.09698728f, 
    -0.01868079f, 0.05164222f, -0.22575216f, -0.16373883f, 0.02818533f, -0.09288701f, -0.02069486f, 0.09038582f, 
    0.01336882f, -0.03612523f, 0.08157483f, -0.10649767f, -0.09525189f, 0.07180492f, -0.01575257f, 0.06506703f, 
    -0.01371493f, 0.03401444f, -0.06153534f, 0.05532710f, -0.13467856f, -0.66071212f, -0.35375819f, 0.03966843f, 
    0.00349238f, 0.00589147f, -0.08719334f, -0.01753576f, 0.00969864f, 0.04620257f, -0.04367553f, -0.04684136f, 
    -0.10693407f, -0.23982993f, -0.15448464f, 0.06701480f, -0.10633748f, -0.04300262f, -0.11932548f, -0.08447588f, 
    -0.00417731f, -0.03541989f, -0.02108552f, -0.24997947f, -0.08328862f, 0.09792616f, -0.15080664f, -0.07936957f, 
    0.03744014f, 0.07078657f, 0.03398045f, -0.04122634f, -0.05300501f, -0.00928134f, -0.15663290f, -0.21762142f, 
    0.12389676f, 0.24540928f, 0.02695745f, -0.28434914f, -0.08052655f, 0.02728808f, -0.12560320f, 0.10535027f, 
    0.04667936f, 0.04051974f, 0.03273378f, -0.01692496f, 0.12797813f, 0.09056151f, 0.15023570f, -0.13770458f, 
    -0.07034663f, -0.11810071f, -0.06506326f, -0.10160126f, 0.10921323f, -0.10990036f, -0.09600320f, -0.00815704f, 
    0.34552908f, 0.21760701f, -0.05559185f, -0.16126789f, 0.13351297f, 0.20142007f, 0.12407843f, 0.03337225f, 
    -0.02617349f, -0.02418632f, -0.00372282f, -0.01228418f, -0.05239477f, -0.15913545f, -0.01645293f, 0.07061886f, 
    0.05173076f, 0.00229141f, -0.16185071f, -0.02962326f, -0.05109455f, -0.01297107f, -0.00281821f, 0.02548276f, 
    0.16881676f, 0.19519453f, -0.05150365f, -0.04648119f, 0.10142153f, 0.19323637f, 0.01760354f, 0.08727457f, 
    0.02274496f, 0.01194934f, 0.01601977f, -0.00891085f, 0.11290884f, 0.01124212f, -0.10118475f, -0.08938131f, 
    0.03713193f, 0.21739459f, 0.07529923f, -0.05950410f, -0.01775089f, 0.08572260f, -0.02555686f, 0.06889573f, 
    -0.00830738f, -0.02739880f, -0.03576198f, 0.02542028f, 0.00059922f, 0.05141720f, 0.00404071f, 0.02894520f, 
    -0.05133043f, 0.00550165f, 0.03080105f, -0.03281909f, 0.20114443f, 0.02105529f, 0.08402330f, -0.02240295f, 
    -0.01601834f, 0.17478536f, -0.29697496f, -0.32971659f, -0.01104177f, -0.05327921f, 0.00752575f, -0.01129733f, 
    -0.01934190f, 0.18634327f, 0.23343830f, -0.20975570f, -0.03265077f, 0.01198007f, -0.02583900f, -0.13983400f, 
    -0.01320910f, -0.07131694f, -0.07056803f, -0.03036910f, 0.14356464f, 0.16798984f, -0.08126047f, -0.02942472f, 
    -0.16425136f, 0.12064375f, -0.06080261f, 0.02154375f, -0.10917663f, -0.04679046f, -0.03555565f, -0.11101690f, 
    -0.27887148f, -0.10617629f, 0.02041405f, 0.03866630f, 0.02466104f, 0.02459616f, 0.05358223f, 0.02701390f, 
    -0.05985679f, 0.06253681f, -0.13852181f, -0.17256960f, 0.28422457f, 0.20285867f, -0.10579442f, -0.11352684f, 
    0.04803360f, 0.22517805f, 0.15470114f, 0.12611298f, -0.02363421f, -0.06481949f, -0.03879355f, -0.07207953f, 
    -0.01583733f, 0.02378176f, 0.03716555f, 0.00571301f, -0.00752354f, 0.05083733f, 0.00147995f, -0.01121281f, 
    -0.15280558f, 0.03021200f, -0.02990722f, -0.26937538f, 0.17116851f, 0.01766589f, -0.06663656f, -0.03170018f, 
    0.08877506f, 0.02908745f, -0.13293251f, -0.16919450f, -0.16583255f, -0.03241795f, -0.01289977f, 0.08688945f, 
    0.39519542f, 0.22837149f, -0.14289472f, -0.22316037f, 0.05703577f, -0.08227808f, 0.06531917f, -0.00400562f, 
    -0.02900001f, 0.00843803f, -0.03185633f, -0.03067204f, 0.12082584f, 0.12480082f, 0.01786171f, -0.14674716f, 
    0.18048784f, 0.15098174f, 0.04173083f, -0.13022967f, -0.10714596f, -0.09798830f, -0.11001027f, -0.05855786f, 
    -0.17522275f, 0.02171919f, 0.01547681f, 0.05527899f, 0.00859221f, 0.01026123f, 0.11198468f, -0.17166832f, 
    0.10939412f, -0.16054058f, 0.12181006f, 0.20053872f, 0.01088213f, 0.00858068f, 0.01809577f, -0.05122944f, 
    0.16791490f, 0.09041676f, 0.00306584f, -0.08275472f, -0.07605555f, -0.09865886f, -0.03033403f, -0.01091813f, 
    0.14678842f, 0.07269119f, 0.06371199f, 0.06939005f, -0.01139623f, -0.04585928f, -0.01412431f, -0.02139015f, 
    0.05846097f, 0.03115948f, -0.02802614f, 0.01824001f, -0.24472846f, -0.11626095f, 0.20878825f, 0.15113471f, 
    -0.07659862f, -0.03774138f, 0.04057159f, -0.13734192f, 0.05894392f, -0.07297224f, -0.04477813f, -0.03293848f, 
    0.09364499f, -0.20940109f, -0.07965747f, -0.16925429f, -0.32900015f, 0.21926261f, 0.07296770f, 0.23930095f, 
    -0.03676241f, 0.05201799f, 0.03981731f, 0.08197792f, 0.40349677f, -0.18365164f, 0.11879733f, -0.06920412f, 
    0.09419941f, 0.02604913f, -0.04725568f, -0.02250376f, 0.20493934f, 0.01567696f, -0.02537643f, -0.13710204f, 
    -0.17859687f, -0.01979964f, -0.04609684f, -0.19086905f, 0.20942552f, -0.12078527f, 0.09465992f, -0.17819636f, 
    -0.00833028f, 0.07913552f, 0.02391089f, 0.02539709f, -0.20941260f, 0.12482355f, -0.01718637f, 0.02143661f, 
    -0.15446390f, -0.11031137f, 0.19972745f, 0.03096336f, -0.04649429f, 0.03176595f, -0.02975478f, 0.01442153f, 
    -0.07748009f, -0.22394814f, -0.00676563f, -0.24219932f, 0.02278332f, -0.02058361f, 0.13580716f, -0.03305575f, 
    0.05722512f, 0.03994489f, 0.20160218f, 0.21334489f, 0.05719062f, 0.00358710f, -0.08887411f, -0.06277473f, 
    -0.07271422f, 0.01069722f, -0.08329590f, -0.31799227f, 0.10214797f, -0.01050531f, -0.03848807f, -0.11115300f, 
    -0.01735326f, -0.18991168f, -0.06541896f, -0.16086547f, 0.05583169f, 0.04967422f, -0.00642323f, -0.02558595f, 
    0.01859059f, -0.36936447f, -0.09009212f, 0.16012703f, -0.07564802f, -0.02862707f, 0.08671687f, -0.12456214f, 
    0.00777732f, -0.03952565f, -0.19589725f, -0.06116000f, -0.25900483f, -0.25632572f, -0.11691781f, -0.02525528f, 
    -0.04527953f, 0.00585148f, 0.04724648f, -0.05824741f, 0.03827650f, -0.01297496f, -0.07665035f, 0.06777070f, 
    -0.01235737f, 0.01272564f, -0.02313221f, 0.01354906f, -0.02623896f, 0.18639255f, -0.23296833f, -0.01690919f, 
    -0.02839623f, 0.04819629f, 0.06957991f, 0.05270346f, -0.23918508f, 0.09641430f, -0.16095808f, 0.13726647f, 
    -0.11547316f, -0.15021428f, 0.28152636f, 0.39736718f, -0.09431310f, -0.02700355f, 0.04084585f, 0.00208869f, 
    0.06396204f, -0.00229511f, 0.03392441f, -0.01375148f, 0.37304235f, 0.14863434f, -0.15669765f, 0.24101374f, 
    0.00375707f, -0.04960049f, 0.00260097f, 0.01566781f, -0.05154070f, 0.08090881f, 0.01495916f, 0.07437856f, 
    -0.07550310f, 0.15245187f, 0.14116503f, 0.05284043f, 0.12420797f, -0.08771879f, 0.11380181f, 0.03502347f, 
    -0.05228181f, 0.03040363f, 0.01697411f, 0.03468743f, 0.02473738f, 0.31897241f, -0.06864020f, -0.13084590f, 
    -0.10690769f, 0.03699252f, 0.04523935f, -0.19267952f, -0.02438475f, -0.01467046f, 0.01472433f, 0.07239094f, 
    -0.19243242f, -0.81490314f, 0.23136662f, 0.04690275f, 0.04299550f, -0.05404464f, -0.02113204f, -0.02609777f, 
    0.12403802f, 0.02941979f, -0.02526024f, 0.02308751f, 0.15019819f, 0.12643105f, 0.11949966f, -0.00211563f, 
    0.01712328f, 0.16492900f, -0.16151904f, -0.32306525f, 0.10735531f, -0.03489463f, -0.03288193f, -0.02129401f, 
    0.13432354f, -0.31033379f, 0.09256904f, -0.30853972f, 0.03056424f, 0.02466843f, 0.11412116f, 0.03881695f, 
    0.04996645f, -0.02547338f, -0.27009693f, -0.11695118f, 0.10977185f, 0.07371230f, 0.01003662f, 0.09217242f, 
    -0.03736205f, -0.13664104f, -0.03580615f, -0.08536842f, -0.03812706f, 0.01638887f, 0.02815979f, 0.06153403f, 
    0.19291930f, 0.01512572f, 0.02420724f, 0.03206979f, 0.00147471f, -0.04876810f, -0.05456419f, -0.03172708f, 
    0.11040856f, 0.01558461f, 0.03552261f, -0.01391118f, -0.11659282f, -0.17016201f, -0.21319793f, 0.26703858f, 
    0.14298195f, 0.05416674f, -0.04667061f, 0.06592893f, 0.04754259f, 0.01409203f, -0.05949635f, 0.04004644f, 
    -0.45582357f, -0.08669978f, -0.20512001f, -0.17981924f, 0.15329614f, 0.07503620f, -0.07670841f, -0.23533671f, 
    0.28578359f, -0.10365544f, -0.07034642f, 0.08564517f, -0.25825706f, -0.10927197f, -0.08266936f, -0.03662534f, 
    -0.06981598f, 0.03365480f, 0.05682958f, -0.04360977f, -0.01278953f, -0.05275089f, 0.00175562f, -0.01863017f, 
    0.34473267f, -0.09129622f, -0.10893972f, 0.03618525f, -0.09040052f, -0.03728503f, 0.09184793f, -0.07949883f, 
    0.05230099f, -0.04090859f, -0.13617733f, 0.07837119f, 0.05666913f, 0.12964395f, -0.08178926f, -0.16764936f, 
    -0.06556927f, 0.13789207f, -0.09680766f, 0.01517261f, -0.02558512f, 0.02584082f, -0.06801874f, 0.01349550f, 
    0.08077587f, -0.09343214f, -0.09979186f, 0.10573038f, 0.04909456f, -0.02340652f, 0.04412561f, 0.01870125f, 
    0.01916184f, 0.05622267f, -0.08949260f, 0.16677286f, 0.54630834f, -0.05751155f, 0.15576394f, 0.08262107f, 
    0.01487092f, -0.11071118f, 0.02718605f, -0.03436109f, -0.01275905f, -0.04992982f, -0.22326553f, 0.12653421f, 
    0.39100501f, -0.08088327f, 0.01443757f, -0.13502882f, -0.05492523f, 0.02099238f, -0.07035284f, -0.05207526f, 
    -0.25786540f, -0.11574535f, 0.01474862f, -0.21118312f, 0.07795925f, 0.26871416f, -0.08652189f, -0.04856922f, 
    -0.03992338f, -0.06338040f, -0.08685131f, -0.05878065f, -0.05870783f, 0.01332211f, -0.01539664f, -0.00726108f, 
    0.42497411f, -0.02909768f, -0.08080603f, -0.08131874f, -0.01652724f, -0.05808328f, 0.04471085f, 0.11101437f, 
    -0.10009591f, 0.15993954f, 0.00133915f, 0.01084724f, 0.17719576f, 0.06517345f, 0.05545812f, 0.11082229f, 
    0.04394965f, 0.00049917f, -0.00977375f, 0.04246394f, -0.16734846f, 0.05884748f, -0.20673552f, -0.30795392f, 
    0.04316613f, 0.08798309f, 0.00640896f, 0.10976691f, -0.10525989f, 0.02922634f, -0.04485990f, -0.23372509f, 
    -0.02747058f, -0.02011587f, 0.04812876f, 0.07577358f, -0.27795473f, -0.09787557f, 0.09516536f, 0.19101419f, 
    0.02823258f, 0.07113330f, 0.04479298f, -0.20379658f, 0.05077901f, 0.11120024f, -0.04307296f, 0.09786550f, 
    0.10427538f, 0.03639157f, -0.02780240f, -0.12874343f, -0.01764038f, 0.06712245f, -0.15916389f, 0.04239959f, 
    0.05546650f, -0.07623946f, 0.05391391f, -0.01454245f, 0.42897296f, 0.07834161f, 0.15176068f, 0.09578992f, 
    -0.12221675f, -0.09332706f, -0.01692707f, -0.00223711f, -0.08918688f, 0.02492317f, -0.04963448f, -0.03239098f, 
    0.08027004f, -0.14760785f, -0.00537231f, -0.07970437f, 0.09123627f, -0.03225631f, 0.07862610f, 0.10752550f, 
    -0.00499378f, 0.01274830f, 0.14122392f, 0.13037038f, 0.07153320f, -0.05410872f, -0.08941363f, -0.14398222f, 
    -0.06722593f, -0.13236652f, 0.19363490f, -0.04093198f, 0.04267223f, -0.05862362f, 0.03791038f, 0.02932333f, 
    0.12663372f, 0.06019200f, 0.09987872f, 0.07963672f, 0.00558451f, -0.00632525f, 0.01146422f, 0.00394533f, 
    0.06383694f, 0.01347474f, -0.03928474f, 0.04301151f, 0.27346507f, 0.00478722f, 0.20259437f, 0.04315074f, 
    -0.04848259f, 0.01249610f, -0.05455478f, -0.05429427f, -0.03660870f, 0.04951802f, 0.06053080f, -0.14934812f, 
    -0.04537930f, 0.07466178f, 0.08643131f, -0.05208442f, 0.13378985f, 0.04880326f, 0.06032118f, -0.02664305f, 
    -0.08985221f, -0.00495231f, 0.00273654f, -0.00654692f, 0.09783626f, -0.14190648f, 0.06872898f, 0.06800865f, 
    0.14311580f, 0.03483701f, -0.33858222f, 0.08053179f, -0.30476120f, 0.01350079f, 0.20016475f, -0.31157139f, 
    -0.14331804f, 0.12141991f, -0.08254306f, -0.16747834f, -0.05456073f, 0.01808886f, -0.02125209f, 0.18852904f, 
    -0.13608234f, -0.06270923f, 0.04510661f, -0.08214153f, 0.66376728f, -0.09758935f, 0.16440046f, 0.11146832f, 
    0.00842995f, -0.10579843f, 0.04557782f, -0.11980507f, 0.10165505f, 0.05340195f, -0.04875787f, 0.14262116f, 
    0.23774245f, 0.05068831f, 0.00998188f, 0.01927207f, -0.02719875f, 0.07185245f, 0.07409459f, -0.27929571f, 
    -0.04200937f, 0.21388671f, -0.20839578f, -0.03407969f, -0.05418961f, 0.18767497f, 0.02019801f, -0.00896848f, 
    -0.14350568f, 0.07590277f, 0.02821720f, 0.10546960f, -0.00823875f, 0.05413518f, -0.13154432f, 0.03447855f, 
    -0.22957443f, 0.10206524f, -0.56425041f, -0.24433474f, -0.05385116f, -0.29234657f, 0.03131673f, 0.24267177f, 
    -0.04179690f, -0.01694311f, -0.01482075f, 0.06407814f, -0.07856215f, 0.15388979f, -0.07417827f, -0.10114016f, 
    -0.05485715f, -0.00528656f, -0.05507847f, 0.16806839f, 0.02230974f, -0.10085969f, 0.14013451f, 0.00391007f, 
    0.24153610f, 0.31720430f, 0.31992429f, 0.31350148f, -0.01425301f, 0.00776801f, -0.14805606f, -0.27333456f, 
    -0.00746637f, -0.02994627f, 0.04933997f, 0.02236217f, 0.07364747f, -0.06889416f, 0.10079986f, -0.15994029f, 
    -0.04151911f, 0.03859795f, -0.22619051f, 0.04003416f, -0.21723555f, -0.12954104f, -0.28466892f, 0.01711087f, 
    0.16921921f, 0.18887351f, 0.04562758f, 0.00121814f, -0.05221950f, 0.09098385f, -0.18162687f, -0.33651796f, 
    -0.00787959f, -0.04069659f, -0.06632222f, 0.01275307f, -0.07455067f, 0.05691018f, -0.45722285f, -0.32664704f, 
    -0.19080453f, 0.00187954f, 0.05292379f, 0.15315142f, -0.07525402f, 0.06851042f, -0.14693551f, -0.04114864f, 
    0.13388419f, 0.09499639f, 0.14189412f, 0.12700856f, -0.02893845f, -0.03894236f, -0.01560498f, -0.00326044f, 
    -0.01504615f, 0.03516775f, -0.02799307f, 0.01146369f, -0.15448900f, 0.06334521f, -0.03070529f, -0.13705361f, 
    0.13929048f, 0.07853483f, 0.03178908f, -0.05850827f, -0.19308949f, 0.02967679f, 0.06579348f, 0.00112362f, 
    -0.41914091f, 0.14638193f, -0.17128326f, -0.03777602f, -0.07377518f, -0.13160856f, 0.13597970f, 0.10580898f, 
    -0.09125627f, 0.10684873f, 0.05592839f, 0.00905150f, -0.01511037f, -0.13209607f, -0.35401881f, -0.25729367f, 
    0.00821542f, -0.03004073f, -0.06557663f, 0.33498138f, -0.03786877f, 0.03717706f, -0.11928325f, -0.03494783f, 
    0.04288232f, 0.16322066f, -0.01374168f, -0.13078494f, -0.00632755f, 0.00766245f, -0.03868197f, -0.05340495f, 
    0.05441525f, -0.03140487f, -0.04558329f, 0.08957786f, 0.03557871f, 0.07429653f, 0.06162918f, 0.19043303f, 
    -0.09009740f, 0.05843050f, 0.00960724f, -0.10639046f, 0.01570124f, 0.03444585f, 0.00976684f, -0.00735176f, 
    0.06860743f, 0.14802141f, 0.01700638f, 0.05534795f, -0.07840778f, -0.02309732f, 0.00242141f, -0.06803697f, 
    -0.06333706f, -0.03260957f, 0.02611106f, 0.08097855f, -0.07969860f, -0.25048071f, 0.02570539f, -0.03498166f, 
    0.06819619f, 0.15271564f, -0.00727267f, -0.16891326f, 0.17906956f, 0.05835098f, -0.03001298f, 0.03601163f, 
    0.02376623f, -0.10180511f, -0.13238303f, -0.17723383f, 0.06839653f, -0.01884262f, 0.08827275f, 0.11486482f, 
    0.04761178f, -0.03576543f, 0.01339206f, -0.06742517f, 0.07530196f, 0.15965958f, -0.00772121f, -0.04848971f, 
    0.16408099f, 0.03444980f, 0.22441280f, 0.10398170f, 0.00794935f, -0.03887714f, 0.06074389f, -0.10227421f, 
    -0.28575739f, 0.02781350f, -0.06557413f, 0.12389503f, -0.01242207f, 0.05752557f, -0.06375088f, -0.36274472f, 
    0.03724505f, 0.08471015f, 0.00553234f, 0.21005520f, 0.03351371f, 0.02983126f, -0.03006691f, -0.02499933f, 
    -0.09760591f, -0.06337687f, -0.00828612f, 0.08684245f, -0.02524481f, -0.01322386f, 0.01788875f, -0.00963537f, 
    -0.07728852f, -0.01411389f, -0.09952899f, -0.14173692f, 0.04621068f, -0.03092180f, -0.06669541f, 0.05770130f, 
    -0.02860302f, 0.03904955f, -0.08068264f, 0.05564490f, 0.15947793f, -0.13451129f, 0.27683482f, 0.12304763f, 
    0.08311571f, -0.27539206f, 0.08299964f, 0.17547329f, 0.06906687f, 0.02686561f, -0.04700292f, -0.02875837f, 
    -0.25951639f, -0.03536763f, -0.14782062f, -0.08640769f, -0.05457824f, -0.03256655f, 0.08283091f, -0.21350543f, 
    -0.03687330f, -0.00974991f, 0.03053859f, -0.04461839f, -0.02016916f, -0.17951897f, 0.56229317f, 0.34382331f, 
    0.09837702f, -0.00850833f, -0.07764983f, 0.08100889f, 0.00694355f, 0.07029775f, -0.07623703f, -0.01187602f, 
    -0.07079027f, -0.07177770f, 0.01386468f, 0.02477789f, 0.02367094f, -0.07594853f, 0.04782212f, -0.06329097f, 
    -0.02537936f, -0.02252848f, 0.02747929f, -0.00471737f, -0.94138592f, -0.14301524f, -0.30660570f, 0.02106885f, 
    -0.13461737f, 0.06794252f, 0.12216313f, -0.10933074f, 0.02714353f, 0.00410353f, -0.11321086f, 0.06810895f, 
    0.38427836f, 0.05245443f, -0.12551546f, -0.06638375f, 0.06477456f, -0.01545748f, 0.01850222f, 0.03192045f, 
    -0.00016042f, 0.02171243f, 0.07008538f, -0.23414020f, -0.00478124f, 0.33490875f, 0.21846010f, 0.28841224f, 
    -0.08852027f, 0.01430132f, 0.05914342f, 0.04819505f, 0.03271924f, -0.02113340f, 0.06808751f, 0.04323356f, 
    -0.01845477f, -0.06433069f, 0.02270139f, -0.07780166f, -0.04193635f, -0.06904222f, -0.05446882f, -0.07345469f, 
    0.01485085f, -0.02900139f, 0.21334121f, 0.04259198f, -0.01983574f, -0.05814647f, -0.00558522f, -0.11873231f, 
    0.02777406f, -0.01833125f, -0.09571370f, -0.07950830f, 0.13682307f, 0.13855065f, -0.10942167f, 0.20210925f, 
    0.00500514f, -0.09046938f, 0.08101475f, 0.00301498f, 0.11747768f, 0.01776106f, -0.11530267f, 0.07793011f, 
    -0.02508505f, -0.02144480f, -0.00369262f, -0.03255926f, 0.03737688f, 0.00310533f, -0.03193271f, 0.39565563f, 
    0.05244456f, 0.01928154f, -0.03587732f, -0.01218180f, 0.08728331f, -0.15990967f, 0.06382608f, -0.02442156f, 
    -0.12349514f, -0.17951596f, -0.17062049f, 0.03804624f, 0.01523856f, -0.01708296f, -0.01186083f, 0.04717544f, 
    0.04283640f, 0.00892878f, 0.12426964f, -0.11336058f, -0.08921104f, 0.06523652f, 0.19001380f, -0.11221743f, 
    -0.01643258f, -0.02370350f, -0.02489774f, 0.00792523f, 0.00475094f, 0.04641536f, -0.01925297f, 0.06247008f, 
    -0.17900278f, -0.03195509f, -0.26585263f, -0.21652132f, 0.04091765f, 0.01490897f, -0.04345637f, 0.07071760f, 
    0.02569217f, -0.01766430f, -0.04399597f, -0.00943016f, -0.38447544f, 0.09106198f, -0.17467818f, 0.11643386f, 
    -0.03368555f, -0.15675472f, 0.03241077f, -0.06245264f, -0.03508609f, -0.01072186f, 0.01796833f, -0.01344260f, 
    0.30451429f, -0.06053915f, 0.27051646f, -0.12168614f, -0.02381924f, -0.15033799f, 0.07539690f, 0.01005123f, 
    0.03461838f, -0.05170003f, -0.05157721f, -0.04802859f, 0.38353533f, -0.16715246f, 0.09277700f, 0.29957819f, 
    -0.09963704f, 0.00920953f, -0.04272825f, 0.07572053f, -0.08862938f, 0.00316170f, 0.04169466f, -0.02015098f, 
    -0.06544150f, 0.44407877f, -0.07680342f, 0.10393250f, -0.01879454f, 0.09567200f, -0.19417019f, 0.09872343f, 
    0.03546558f, -0.02243525f, -0.26414075f, 0.17629112f, -0.17693311f, -0.05284715f, 0.00384908f, -0.24173151f, 
    -0.04455332f, -0.05651123f, 0.01910278f, 0.00728606f, -0.02615217f, -0.03616835f, 0.02814737f, 0.02924261f, 
    0.05394904f, -0.07895104f, -0.09892455f, -0.23096108f, -0.05232781f, -0.04228497f, -0.01507889f, 0.02125029f, 
    0.01264443f, -0.11173062f, 0.04327587f, -0.03243237f, 0.16997796f, -0.19898628f, -0.03415944f, 0.38046658f, 
    0.00970534f, -0.12205806f, -0.11213927f, 0.14503965f, 0.00102900f, 0.08826929f, -0.07049804f, 0.03045238f, 
    0.05303474f, -0.10701532f, -0.24324134f, 0.10498089f, 0.04583186f, 0.07455846f, -0.00130791f, -0.20303547f, 
    -0.06648204f, 0.04668376f, 0.06029396f, 0.07555034f, -0.02222659f, 0.05884991f, -0.01348295f, 0.11064864f, 
    0.00840905f, -0.01187297f, -0.10748596f, -0.03009508f, 0.12605758f, 0.01965799f, -0.03988676f, 0.17299943f, 
    -0.13536979f, 0.06564135f, 0.18895067f, -0.08289313f, 0.05658237f, -0.03978059f, -0.16346408f, -0.17403144f, 
    0.05960692f, -0.00714214f, -0.01725413f, 0.12390599f, 0.26898909f, -0.07566097f, -0.01683898f, 0.15201470f, 
    0.05546406f, 0.07312401f, -0.26115707f, 0.11353660f, -0.00711477f, -0.00915794f, 0.11730354f, 0.11587057f, 
    0.16520067f, -0.22968064f, -0.10647023f, 0.09880430f, 0.00634935f, -0.02596104f, 0.09763701f, -0.01294198f, 
    0.03546533f, -0.00548957f, -0.04837148f, 0.04905544f, -0.12163257f, 0.01486029f, 0.33589470f, -0.15940596f, 
    0.02028246f, -0.03941110f, 0.03914040f, -0.01300747f, 0.05816945f, -0.05309517f, 0.04021864f, 0.12480389f, 
    -0.23749477f, 0.23167282f, -0.05602222f, 0.05686868f, -0.04967639f, 0.03037755f, -0.02286415f, -0.13183296f, 
    0.02564799f, 0.18085279f, 0.06905681f, 0.13742922f, -0.40017611f, 0.30077288f, 0.02201337f, -0.28981757f, 
    -0.03165940f, -0.03531554f, 0.00677157f, 0.02681621f, 0.06452861f, 0.03195783f, 0.02420733f, -0.02295126f, 
    -0.20002344f, -0.26844534f, 0.05406784f, -0.14503908f, 0.00431264f, -0.13712165f, 0.00473598f, -0.11306734f, 
    0.00734589f, -0.16724966f, -0.00128566f, -0.18494838f, 0.07060134f, 0.09141096f, -0.13388947f, 0.05771000f, 
    0.01843830f, -0.01402737f, 0.04830368f, -0.03915538f, -0.03834303f, 0.14540175f, -0.01103977f, 0.01130210f, 
    -0.62407655f, -0.51195431f, -0.27678666f, -0.07948106f, 0.00881420f, 0.16556951f, 0.04281903f, -0.16943988f, 
    0.03348236f, -0.03000492f, 0.02430074f, -0.04291276f, 0.12875059f, -0.15661548f, -0.18766941f, 0.04017052f, 
    0.06783415f, -0.02704743f, 0.06657231f, 0.03527683f, -0.09028639f, 0.05145614f, -0.13873403f, 0.19126073f, 
    -0.14220864f, -0.01505622f, -0.04176053f, 0.05187213f, 0.01729896f, -0.08122721f, -0.08551292f, -0.16756438f, 
    0.00873121f, -0.08033466f, -0.06252979f, -0.03470399f, -0.06908402f, -0.15664622f, 0.02191609f, -0.15336873f, 
    0.06664464f, -0.00000343f, 0.00851970f, 0.00459775f, -0.02372229f, 0.01727904f, -0.01913766f, 0.00266066f, 
    0.14705661f, 0.16989829f, -0.13745177f, -0.20872442f, 0.14100002f, -0.33789921f, -0.02520185f, 0.14275514f, 
    -0.09269191f, 0.06793618f, -0.01549244f, -0.15421496f, -0.04805986f, -0.05189077f, 0.10628640f, -0.41042525f, 
    -0.01277411f, -0.14350103f, -0.14290944f, 0.04526597f, 0.05074541f, -0.04880778f, -0.01637508f, 0.03698480f, 
    -0.22504646f, 0.13710654f, 0.08356494f, 0.06313863f, -0.02833382f, -0.01565843f, 0.01361287f, -0.01029496f, 
    0.01012642f, 0.01436043f, -0.03512381f, 0.02344038f, -0.14339620f, -0.11600018f, 0.02501003f, 0.04936893f, 
    -0.03233267f, 0.06729704f, -0.00663850f, 0.03112186f, 0.09530368f, -0.18732022f, 0.12666948f, 0.02757001f, 
    -0.54534161f, -0.42056012f, -0.11844920f, -0.00880852f, -0.06361585f, 0.05601934f, -0.07286271f, -0.11533716f, 
    -0.04258909f, -0.03397930f, -0.01915685f, 0.02289622f, 0.52100861f, -0.10398100f, 0.26520142f, 0.37971005f, 
    0.02670485f, 0.01180814f, -0.01332221f, 0.00912010f, -0.00845425f, -0.14180438f, 0.03858506f, 0.02128575f, 
    0.11393801f, 0.05006412f, 0.09673075f, 0.14865901f, 0.08030724f, -0.05501162f, 0.00940773f, 0.04404731f, 
    0.04528501f, 0.04364909f, 0.01984516f, -0.03377428f, -0.15020563f, -0.10818074f, -0.06269506f, -0.23060359f, 
    0.04951351f, -0.07703372f, -0.00588824f, 0.00988230f, 0.03095130f, -0.03259608f, -0.00537223f, -0.00725321f, 
    -0.26685131f, 0.07904366f, -0.02756938f, -0.17556977f, -0.08189952f, 0.05644869f, -0.05640993f, 0.02110231f, 
    0.00836643f, 0.08608001f, -0.12115408f, 0.00499389f, -0.16193865f, -0.24107443f, -0.06558045f, 0.07555991f, 
    0.00923539f, 0.05674268f, 0.00047825f, -0.02494960f, 0.02362606f, -0.06123032f, -0.29468459f, -0.02673553f, 
    -0.57999343f, 0.00246518f, 0.01525981f, -0.10610608f, 0.07815875f, -0.11698693f, -0.04779099f, -0.12321839f, 
    0.01038453f, -0.00840121f, 0.01968177f, 0.02658915f, 0.00291083f, 0.06349299f, -0.07957081f, 0.06803596f, 
    0.04223705f, 0.00075012f, 0.04183215f, 0.01800429f, -0.01789873f, 0.04242839f, -0.00040537f, -0.02130585f, 
    -0.74986571f, -0.52802867f, -0.01972402f, -0.11908671f, -0.12337845f, 0.00093942f, 0.10140978f, -0.10250655f, 
    0.04458842f, -0.03993157f, -0.02635225f, -0.04228679f, -0.02676002f, 0.00862453f, 0.04178587f, -0.18937582f, 
    0.01336077f, -0.07238337f, -0.10719807f, -0.13460423f, 0.06120222f, 0.23643804f, -0.09335838f, 0.20738260f, 
    0.31794217f, -0.00467303f, 0.22170782f, 0.38711259f, 0.16962610f, -0.01276601f, 0.04482505f, 0.14925802f, 
    0.04878088f, 0.02269634f, -0.01621477f, 0.04294480f, -0.11253096f, 0.53203875f, 0.34131166f, 0.35286266f, 
    -0.02349660f, -0.02415974f, 0.04029021f, 0.04510113f, 0.07394738f, -0.05298518f, -0.03625004f, -0.02254573f, 
    0.02617981f, -0.15321814f, -0.11933047f, 0.00998718f, -0.05134443f, -0.04568842f, 0.00237476f, 0.05230689f, 
    -0.00045758f, -0.08171079f, -0.01152443f, 0.05726198f, 0.00833512f, 0.07725456f, 0.07355811f, 0.08616260f, 
    -0.05943016f, 0.05779488f, -0.07133973f, -0.07616594f, -0.09966398f, 0.05396327f, -0.04470032f, 0.05606286f, 
    0.02443128f, -0.02592977f, -0.09488677f, 0.17778744f, -0.04090400f, -0.07838503f, -0.08824331f, 0.01548375f, 
    -0.02537481f, -0.06472012f, 0.00104343f, -0.03826457f, -0.12273870f, -0.01833853f, -0.07373302f, -0.17962262f, 
    0.06829175f, 0.05954914f, -0.20907983f, -0.14630221f, 0.00538654f, -0.01316077f, -0.11181397f, 0.03765192f, 
    -0.07669134f, 0.11323987f, 0.10717404f, 0.11382162f, 0.04791175f, 0.06723042f, 0.00553000f, 0.03043304f, 
    -0.07201339f, -0.04362718f, -0.01429789f, 0.04669074f, -0.77210528f, -0.36289635f, -0.27701089f, -0.30683696f, 
    0.10442907f, -0.01042154f, 0.08589031f, 0.05276512f, -0.06484188f, -0.03149315f, -0.00655892f, -0.00623986f, 
    -0.14866818f, -0.03313605f, 0.01334166f, 0.07556214f, -0.00462933f, 0.05056899f, 0.02664575f, 0.03758764f, 
    -0.12869616f, 0.03569463f, 0.07718626f, -0.05342561f, -0.16147517f, 0.37113133f, -0.00959862f, 0.20381732f, 
    -0.09335134f, 0.01584118f, 0.09739204f, -0.17896439f, -0.08810075f, 0.09940290f, -0.00906143f, 0.06532622f, 
    -0.21507506f, 0.13294548f, -0.10183278f, 0.13859379f, -0.02779687f, -0.09310543f, 0.02813991f, 0.12257668f, 
    0.00062558f, -0.02692837f, 0.03526791f, -0.05563742f, -0.19453323f, 0.14121500f, 0.08395965f, -0.07469643f, 
    0.01385601f, -0.03823203f, 0.07466457f, -0.10065646f, -0.04226576f, -0.09812377f, -0.03440812f, 0.04510031f, 
    -0.33734536f, -0.05694207f, 0.13817558f, 0.01958461f, -0.13855769f, -0.29073548f, 0.02835076f, 0.00990997f, 
    -0.16444087f, 0.00040895f, -0.00104565f, -0.14873193f, 0.08191783f, -0.19670875f, -0.09179195f, -0.06761797f, 
    0.02050577f, -0.02348286f, -0.11951040f, -0.12642322f, 0.06471562f, 0.13389330f, -0.04475962f, -0.18699688f, 
    -0.19909148f, -0.26008642f, -0.10822915f, -0.08294038f, 0.02048341f, -0.03263467f, 0.00545272f, -0.02738283f, 
    0.11981580f, 0.07274995f, 0.01643688f, -0.07448960f, -0.11260100f, 0.68826532f, -0.35249683f, -0.33385429f, 
    0.14575237f, -0.03379986f, -0.09399812f, -0.10527106f, -0.14440414f, 0.05373584f, -0.08978211f, -0.10122370f, 
    -0.01805676f, -0.07682984f, -0.15599273f, 0.33270487f, 0.10271782f, 0.11445695f, -0.10037810f, 0.07605179f, 
    -0.06514262f, -0.15583010f, 0.06520137f, 0.01303154f, -0.22313751f, 0.31058142f, -0.28631061f, -0.27774033f, 
    0.14198938f, -0.00155660f, -0.05858406f, -0.15146811f, -0.26184961f, -0.04825445f, -0.01932792f, -0.00259922f, 
    0.47997290f, 0.17629200f, 0.18529263f, -0.20608653f, -0.31517872f, -0.01485163f, -0.18088306f, -0.08152824f, 
    0.08726893f, 0.10949840f, 0.00646377f, -0.07994194f, -0.06813125f, -0.15182137f, -0.04857652f, 0.05660037f, 
    -0.01589411f, 0.13417354f, 0.05056816f, 0.06825373f, -0.10606602f, -0.01233882f, 0.00729902f, -0.05461388f, 
    -0.02867668f, 0.21177478f, -0.11447239f, -0.05158608f, -0.03356341f, -0.06059180f, -0.13464876f, 0.04304859f, 
    0.01198221f, -0.07077645f, 0.13393115f, -0.21919227f, 0.34289572f, -0.24319032f, 0.11121128f, 0.11827324f, 
    0.15253222f, 0.09294294f, 0.05888407f, -0.09470612f, -0.14102283f, 0.04782864f, 0.04406681f, 0.00469995f, 
    0.03904108f, -0.06056240f, 0.24596536f, 0.01127959f, -0.11765759f, 0.04345445f, -0.01534691f, -0.02177949f, 
    0.11339876f, 0.04447594f, 0.12829910f, 0.00766070f, 0.15369061f, -0.12927444f, 0.09561210f, 0.02780811f, 
    0.01128395f, 0.13391808f, 0.00515424f, 0.01766508f, 0.02296689f, 0.08554628f, 0.12187648f, -0.08697616f, 
    0.15193841f, -0.00926800f, -0.01118656f, 0.04045004f, -0.00451943f, -0.00503687f, -0.08867041f, -0.15113270f, 
    -0.12362780f, 0.09203755f, 0.01638153f, 0.16719599f, -0.28761482f, -0.03394897f, -0.08678614f, -0.32962286f, 
    0.18389329f, 0.08343776f, -0.12691219f, 0.24359472f, -0.01421813f, -0.11073273f, -0.04595218f, -0.04880039f, 
    0.38575071f, 0.17312390f, -0.53157592f, -0.62306809f, 0.19428308f, 0.13185450f, 0.03358399f, 0.13785234f, 
    -0.17694356f, -0.10947741f, 0.12488927f, -0.17299129f, -0.25794825f, -0.19966686f, 0.29400960f, -0.11604536f, 
    -0.08636170f, -0.07298867f, -0.11216593f, -0.10698883f, -0.15021901f, 0.11174733f, -0.17671286f, 0.02497595f, 
    -0.01440747f, -0.05886057f, -0.01652766f, 0.12592015f, 0.03461103f, 0.09558498f, -0.07989596f, 0.06196669f, 
    0.08582499f, 0.16015004f, -0.04858549f, -0.09767515f, -0.14782622f, 0.14620410f, -0.12286554f, 0.50738561f, 
    -0.05876745f, -0.26710859f, 0.25275579f, 0.19790050f, 0.08564150f, 0.15538706f, -0.05388830f, 0.16163759f, 
    0.49095899f, -0.14001831f, -0.14589415f, 0.12909600f, 0.03333791f, -0.08322600f, 0.03359717f, -0.20481086f, 
    -0.16284923f, -0.07308100f, 0.15061094f, 0.01697598f, -0.31398731f, 0.07508770f, -0.04204786f, -0.03042372f, 
    -0.00366381f, -0.03325682f, -0.05797991f, -0.00390653f, -0.14753462f, 0.19084355f, -0.15942062f, 0.19152299f, 
    -0.09013076f, 0.12771772f, 0.13513410f, 0.37465590f, -0.10726527f, -0.05319264f, -0.22852194f, -0.01120516f, 
    -0.03287922f, -0.01174220f, 0.06592356f, 0.05479660f, -0.29706410f, -0.03946799f, 0.36043710f, 0.51943237f, 
    -0.02479469f, -0.15017399f, 0.05072056f, -0.10803826f, 0.11242810f, 0.01482489f, -0.14202182f, 0.07119313f, 
    0.13974240f, 0.08543286f, 0.36116266f, 0.13871998f, 0.01280582f, 0.06870954f, -0.04612803f, 0.01681586f, 
    -0.03771788f, -0.08084955f, 0.21405222f, 0.02247950f, -0.17405494f, -0.08483443f, -0.21287435f, -0.06334911f, 
    0.17199107f, -0.09085528f, 0.15590560f, -0.04551886f, -0.01381628f, 0.06022335f, -0.18407524f, 0.13181131f, 
    -0.00388680f, 0.02808210f, -0.16697563f, 0.10694974f, -0.00036898f, -0.04780817f, -0.09700379f, 0.06951387f, 
    -0.03022570f, 0.05113539f, -0.00725652f, -0.05408783f, -0.15670834f, -0.08614839f, -0.13207208f, 0.22765172f, 
    -0.04517802f, 0.06304636f, 0.09717498f, -0.01875129f, -0.03222416f, 0.10073323f, -0.00312086f, 0.15536620f, 
    -0.56739235f, 0.53439951f, -0.06519359f, 0.20801502f, -0.12525269f, -0.08620382f, 0.22571903f, -0.16148329f, 
    -0.15801337f, 0.14730375f, -0.28736490f, -0.04035248f, 0.58117378f, -0.00846452f, 0.05117990f, -0.06127086f, 
    0.22380380f, 0.02481484f, -0.12880087f, -0.02929864f, -0.17532507f, 0.06667103f, -0.07529820f, -0.00647575f, 
    -0.02485747f, -0.15732561f, -0.37100342f, 0.02974034f, -0.06053655f, -0.18951669f, -0.04124356f, -0.09343998f, 
    0.02841016f, -0.06473193f, -0.18790250f, 0.05289701f, -0.16481450f, 0.20841879f, 0.09899677f, 0.17350806f, 
    0.01616216f, 0.13784109f, 0.05724917f, -0.04169681f, -0.14119352f, 0.04395277f, -0.04201851f, 0.07424620f, 
    -0.69584900f, -0.19999075f, -0.05109338f, 0.06690244f, -0.00256263f, 0.07490886f, 0.13873978f, -0.01863642f, 
    0.13811234f, 0.12060042f, 0.05002407f, 0.02540067f, -0.24092183f, -0.16002621f, 0.06818008f, 0.09981338f, 
    -0.04960163f, -0.11617830f, -0.14154091f, -0.13406251f, 0.18160594f, -0.07081309f, -0.00968582f, -0.04644644f, 
    -0.23017582f, -0.22998324f, 0.01631584f, 0.35116586f, 0.06379451f, -0.12644085f, -0.06020860f, -0.29010731f, 
    0.14174096f, -0.17989886f, -0.10084491f, -0.09407553f, 0.22611508f, -0.04990102f, 0.13827972f, -0.01350817f, 
    0.03268816f, -0.09517390f, -0.13273971f, 0.01102284f, 0.08451095f, -0.02455122f, -0.04620779f, -0.02621588f, 
    -0.04672201f, -0.08808321f, -0.02050341f, 0.20351368f, 0.06498744f, 0.04327689f, 0.21130773f, 0.08684696f, 
    0.00730758f, 0.04950241f, -0.00307806f, -0.04629944f, 0.65807456f, -0.32673478f, 0.02664647f, -0.80732471f, 
    -0.19309887f, -0.17678231f, -0.04654679f, 0.06773068f, 0.04390186f, 0.02772112f, -0.01178503f, -0.22243939f, 
    -0.31380194f, -0.01079253f, 0.07744735f, 0.00790340f, -0.02049776f, 0.08303952f, -0.13623793f, 0.05083266f, 
    -0.02723797f, -0.35768870f, -0.01561205f, -0.12116417f, -0.07248492f, -0.00082267f, 0.14939404f, 0.13640717f, 
    -0.00602197f, 0.06008558f, -0.13973801f, 0.11979344f, 0.00549090f, 0.01625406f, 0.13528398f, 0.04610540f, 
    -0.49930689f, 0.44765446f, -0.18129699f, -0.03928885f, 0.08999204f, 0.31657550f, -0.10509530f, 0.01384529f, 
    -0.12898500f, -0.18783551f, 0.08512954f, 0.10057069f, -0.03777484f, -0.08223815f, 0.54243261f, 0.25521994f, 
    -0.16055588f, -0.09347785f, -0.01985472f, 0.07078747f, 0.13699864f, 0.00683976f, -0.12922157f, 0.02457629f, 
    -0.32973760f, -0.01477190f, 0.14960024f, -0.30793595f, -0.04380290f, -0.07814144f, -0.05623926f, 0.01783417f, 
    -0.01512498f, 0.05737601f, 0.00884525f, 0.08773015f, -0.71498615f, 0.19879869f, -0.43486896f, -0.00989840f, 
    0.14276794f, 0.07493211f, -0.24767807f, -0.03597856f, -0.07315495f, -0.15678160f, 0.23415768f, -0.03355570f, 
    0.16569005f, -0.14006971f, -0.01187696f, 0.03095214f, -0.10481445f, 0.06573092f, 0.08170157f, -0.04125945f, 
    0.06663959f, -0.10683513f, -0.10798683f, -0.14493984f, 0.30374810f, -0.03519420f, 0.19885191f, 0.22924949f, 
    -0.00829458f, 0.02139801f, 0.11452416f, -0.08230925f, -0.06071388f, -0.09826773f, -0.02051245f, 0.10956215f, 
    0.09180370f, 0.38502523f, 0.03615781f, -0.14196417f, 0.18839704f, 0.05139465f, -0.05516607f, -0.04527522f, 
    -0.25800571f, 0.05500628f, -0.11073399f, -0.09846888f, 0.10223997f, 0.17634350f, 0.30346152f, 0.39243317f, 
    0.04056388f, -0.13035506f, 0.09778696f, -0.05161990f, -0.07451577f, 0.03319883f, -0.15596698f, -0.08541819f, 
    -0.28863066f, -0.29415816f, 0.03269369f, 0.10061290f, 0.09278289f, 0.07024620f, -0.43609801f, 0.08503985f, 
    -0.04188395f, -0.01557449f, -0.14784332f, -0.09289489f, 0.08661262f, 0.18205854f, 0.04753730f, -0.03650702f, 
    0.06819394f, -0.06864769f, 0.18164411f, -0.25907576f, -0.12134271f, 0.22775207f, 0.03882440f, 0.04358823f, 
    0.07093415f, -0.10410222f, 0.06722520f, -0.00941952f, 0.04754614f, 0.03148941f, -0.10075826f, 0.09891301f, 
    0.05764443f, -0.04915513f, 0.12675937f, 0.05685166f, -0.54968256f, -0.02185158f, -0.01314736f, -0.27917773f, 
    -0.03121560f, -0.13160545f, -0.12275315f, -0.04094738f, -0.04983861f, 0.05671015f, 0.03583677f, -0.08817603f, 
    -0.07806029f, -0.14584352f, -0.10862312f, 0.17029482f, 0.04221591f, 0.00002045f, -0.00595118f, 0.00418056f, 
    -0.04022482f, 0.06313010f, -0.18584798f, -0.06434248f, 0.07355992f, -0.15112337f, 0.34799439f, 0.14027593f, 
    -0.14625390f, -0.00849735f, -0.11584686f, 0.07173934f, 0.08207189f, 0.07379538f, -0.22869875f, -0.02528971f, 
    0.19885863f, -0.10360741f, 0.03866873f, 0.12645325f, 0.05767176f, -0.16058823f, -0.07905331f, -0.17368872f, 
    -0.06795597f, 0.04292846f, 0.06254531f, 0.15282986f, 0.16855353f, -0.20284089f, -0.03240587f, 0.15077060f, 
    0.22677757f, 0.05326074f, 0.04915488f, 0.10137504f, -0.06040436f, 0.08418997f, -0.09296482f, 0.02704054f, 
    -0.43412653f, -0.46777806f, -0.18175685f, -0.02594275f, 0.10813165f, -0.09681967f, -0.17453785f, -0.08448069f, 
    -0.06954521f, -0.01595125f, 0.05861107f, -0.04565324f, 0.06431492f, -0.12323955f, 0.05130370f, 0.17232771f, 
    0.00481150f, -0.04295496f, -0.05176001f, 0.12635255f, 0.05385595f, 0.05731447f, -0.11654914f, 0.02408181f, 
    0.33502045f, 0.25664210f, -0.27311283f, -0.12691522f, -0.07805985f, -0.04246071f, -0.10475279f, 0.10796692f, 
    0.00277389f, -0.00102132f, 0.16132739f, 0.05364539f, 0.11021063f, -0.02463919f, 0.18242966f, -0.00438485f, 
    -0.00707103f, -0.03471293f, -0.04540513f, 0.08493407f, -0.01772103f, 0.01883464f, 0.03837916f, 0.06582867f, 
    0.36457720f, -0.14747882f, -0.13945949f, 0.00854775f, 0.12028595f, 0.08466078f, -0.02619117f, -0.18558571f, 
    -0.12214757f, 0.02334920f, -0.01649748f, 0.00830829f, -0.00866488f, -0.10916940f, 0.02682547f, 0.10413667f, 
    0.03705326f, 0.03622337f, -0.03498013f, 0.07231716f, -0.05373847f, -0.07768786f, -0.06795641f, -0.05824260f, 
    -0.22802351f, 0.14864732f, -0.05915074f, -0.65899855f, 0.35266829f, -0.00496288f, -0.00200961f, -0.04736279f, 
    -0.12166948f, -0.11771458f, 0.05638211f, -0.02283102f, -0.05173810f, 0.03572395f, 0.01771893f, 0.22498439f, 
    -0.01571524f, -0.01189773f, 0.06047984f, 0.05466196f, -0.00014890f, 0.06782976f, 0.05439705f, -0.01588907f, 
    -0.18157740f, 0.29255992f, -0.10317288f, 0.17057477f, 0.05757380f, 0.02425970f, -0.05843616f, -0.05190957f, 
    -0.13901173f, -0.00970986f, 0.01606808f, 0.13163608f, 0.05188748f, -0.04488604f, 0.07206630f, 0.11550730f, 
    -0.05275771f, 0.01482102f, -0.05237074f, -0.03856209f, -0.04559316f, 0.05380254f, 0.01080767f, 0.07055327f, 
    0.14819191f, -0.05779396f, 0.10378966f, -0.19324297f, -0.18088882f, -0.03758885f, -0.16946004f, 0.12838201f, 
    -0.00517019f, 0.07417116f, -0.02731518f, -0.17663643f, 0.05052333f, -0.03431191f, 0.01276966f, -0.02950947f, 
    -0.03255842f, 0.07181249f, -0.06519304f, 0.03676872f, 0.09778782f, -0.06759701f, -0.05499281f, -0.10867376f, 
    -0.03468057f, 0.03165681f, -0.02038230f, -0.05398844f, 0.09275880f, 0.01488755f, -0.02305085f, 0.08304220f, 
    0.01521957f, 0.00434145f, -0.05004916f, -0.02689333f, -0.06161901f, -0.53824264f, 0.02138107f, -0.01595069f, 
    -0.19694468f, -0.02047851f, -0.30022782f, -0.11350166f, -0.05298031f, 0.03771453f, 0.00997654f, 0.05785763f, 
    0.00518254f, 0.19570275f, 0.32972145f, 0.13984573f, -0.04939204f, 0.05635633f, -0.07773488f, 0.11375891f, 
    -0.03450225f, -0.06575256f, -0.11135204f, -0.05311953f, -0.15484244f, -0.30300543f, -0.13757710f, -0.02049458f, 
    -0.16189836f, 0.04549876f, 0.09007986f, -0.20185758f, -0.24145398f, -0.01965767f, -0.06156654f, -0.04610417f, 
    -0.03670808f, -0.03112766f, -0.02826987f, 0.19167416f, -0.08793232f, 0.07909498f, 0.02821547f, -0.04819969f, 
    0.08081271f, -0.09511305f, -0.07192664f, -0.02286937f, -0.04885063f, 0.07151563f, 0.23398151f, 0.08362959f, 
    -0.03670213f, 0.01077418f, 0.09940132f, -0.00885652f, -0.01163104f, -0.08612136f, 0.06398650f, 0.04213813f, 
    0.12654853f, -0.18614991f, -0.16376896f, -0.13738889f, -0.16479576f, -0.00877804f, 0.00208340f, -0.09538779f, 
    -0.05399922f, -0.02439189f, -0.18487978f, 0.04346758f, -0.09793777f, 0.05103865f, 0.09540819f, 0.04275199f, 
    -0.10025865f, -0.04849731f, 0.06332383f, 0.09184358f, -0.00804756f, -0.07612853f, -0.06357958f, 0.16806500f, 
    0.08877814f, 0.06184718f, 0.02172149f, 0.08993163f, 0.08070390f, -0.01805624f, -0.03966544f, -0.10942987f, 
    0.02417119f, 0.00650437f, 0.03542356f, 0.06248248f, 0.17677276f, 0.04180462f, -0.27479348f, 0.07239423f, 
    0.02127557f, 0.01879193f, 0.03379906f, -0.06791327f, 0.33184996f, 0.16931711f, 0.03546490f, 0.44273052f, 
    0.04795195f, 0.05834722f, -0.08766396f, 0.11365907f, 0.06796974f, -0.07950810f, 0.03545476f, -0.21612257f, 
    -0.05128266f, -0.00468297f, -0.03313233f, -0.09315154f, 0.15096490f, 0.08350502f, -0.17563589f, -0.02200393f, 
    -0.09737545f, -0.06032964f, 0.09875682f, -0.08984823f, 0.07793241f, 0.00673439f, -0.06952428f, -0.01457858f, 
    -0.46557394f, -0.42583901f, 0.40715560f, -0.34377354f, 0.02007162f, 0.11249674f, -0.02621082f, 0.01434349f, 
    -0.02405558f, -0.13191895f, -0.07970370f, 0.11511864f, 0.04780065f, -0.09436789f, -0.29158136f, -0.26478088f, 
    0.07738254f, 0.04411313f, 0.05680313f, -0.07453476f, 0.01971424f, -0.08231165f, -0.00028130f, -0.08966079f, 
    0.11232176f, 0.05770937f, 0.19191757f, 0.16321249f, -0.08397821f, -0.10220828f, -0.00591872f, -0.17993081f, 
    0.04542876f, 0.01684291f, -0.00810235f, -0.02799737f, 0.16951334f, 0.12344529f, 0.29127756f, 0.12466733f, 
    -0.05761918f, 0.02369654f, 0.00618320f, 0.09539095f, 0.00394688f, -0.00055153f, 0.05666046f, -0.02542590f, 
    -0.09284887f, -0.27977851f, -0.09380058f, -0.02827695f, 0.09961432f, -0.14557838f, -0.12195612f, 0.04887644f, 
    0.06027620f, -0.04842745f, -0.29366308f, -0.17401791f, 0.00287626f, -0.05128489f, -0.00479484f, 0.10946427f, 
    -0.20079608f, -0.12371532f, 0.08566954f, -0.08403481f, -0.07207235f, -0.01873807f, -0.00993891f, -0.01616636f, 
    -0.31401581f, -0.07689115f, -0.12591833f, -0.03855343f, 0.04501672f, -0.05069275f, -0.26823229f, 0.08023921f, 
    -0.07666118f, -0.10817631f, -0.04217118f, -0.09911123f, 0.13399123f, 0.07736713f, 0.00970294f, -0.00011481f, 
    0.10624892f, 0.02024931f, 0.09366562f, 0.06485968f, -0.00052520f, 0.03646988f, 0.00718635f, -0.04060279f, 
    0.01285354f, 0.04416711f, -0.11077529f, 0.04283462f, 0.07815278f, 0.08910590f, 0.01180833f, -0.07414591f, 
    -0.01896901f, 0.05959890f, -0.10107028f, 0.10280679f, -0.00848451f, 0.21998882f, 0.06427360f, 0.12619153f, 
    -0.03585260f, -0.15687627f, -0.09311222f, -0.10683209f, -0.03064926f, -0.02095929f, -0.02614582f, 0.00552238f, 
    0.07876661f, 0.11808015f, 0.24174148f, 0.23187047f, -0.05652345f, 0.01069884f, 0.03033710f, -0.08390561f, 
    -0.07872729f, 0.00012636f, 0.11438867f, -0.09563980f, 0.08969148f, -0.01671589f, 0.07091864f, 0.08799330f, 
    0.00565315f, 0.07783251f, -0.05627998f, -0.10324764f, 0.13478513f, 0.06737389f, 0.02831604f, 0.02293782f, 
    0.03063788f, 0.06476210f, 0.07246076f, -0.08232533f, 0.08665453f, -0.06183412f, -0.05500552f, -0.00544949f, 
    0.04928454f, 0.04500165f, -0.03594938f, -0.03704125f, 0.06258122f, -0.07535259f, -0.13456258f, 0.14674048f, 
    -0.17459860f, -0.04456798f, 0.13139042f, -0.24614117f, -0.07075359f, -0.04046951f, 0.05617414f, -0.09993897f, 
    -0.02713833f, -0.18554971f, -0.10113788f, -0.39499947f, -0.01896010f, -0.02008606f, -0.04401629f, -0.06599013f, 
    -0.09963491f, -0.05008678f, 0.02431349f, -0.25981861f, -0.33090931f, -0.04713418f, -0.19833146f, -0.22632121f, 
    0.09897690f, -0.04997827f, 0.02121613f, 0.07317208f, -0.00905030f, 0.02766293f, 0.05172813f, -0.00207260f, 
    0.05223951f, 0.09873524f, -0.05101949f, -0.09559450f, 0.01513993f, -0.05394440f, 0.05202521f, -0.01846756f, 
    0.03124276f, 0.14664017f, -0.04543560f, 0.19144218f, 0.14299336f, -0.07735807f, 0.11934428f, 0.25246686f, 
    0.01605031f, 0.00484102f, 0.05758373f, 0.06267732f, 0.03298026f, 0.01583250f, -0.01913321f, 0.04302176f, 
    -0.04145635f, 0.14057058f, -0.11604907f, -0.04303935f, 0.06086056f, -0.05009757f, -0.01472675f, -0.03840045f, 
    -0.07386301f, -0.04546412f, 0.16826831f, -0.06617258f, -0.14013657f, -0.01398559f, -0.02176134f, -0.20972069f, 
    -0.03989928f, 0.00140809f, -0.03606957f, -0.03495855f, -0.10315151f, 0.00221257f, 0.04842456f, 0.13403907f, 
    0.01454221f, 0.19799927f, 0.25255489f, 0.06640586f, -0.03294407f, 0.02611005f, 0.03032827f, 0.06212485f, 
    0.02231096f, 0.01193973f, -0.00530925f, 0.00654915f, 0.03520766f, -0.13068600f, -0.18589039f, 0.04942866f, 
    -0.08443518f, -0.00428053f, -0.04403711f, 0.02558645f, 0.01237163f, -0.00217894f, 0.07161059f, 0.02230147f, 
    -0.00440444f, -0.02241996f, 0.01439021f, 0.07360003f, 0.07606477f, 0.10664345f, 0.16509144f, 0.01375503f, 
    0.03482479f, 0.08944396f, -0.01124950f, 0.02545820f, -0.15966602f, 0.01946138f, -0.17910923f, 0.11947133f, 
    0.10678984f, 0.00588925f, 0.03036662f, 0.02219767f, 0.02464690f, -0.01832504f, -0.01632645f, -0.06229660f, 
    0.07004357f, -0.21316408f, -0.01022803f, 0.14491454f, 0.09173616f, -0.32370558f, -0.03970478f, 0.04819692f, 
    -0.11656249f, 0.09997576f, -0.12240101f, 0.09489307f, 0.17122120f, 0.24759869f, -0.19210482f, 0.23165844f, 
    0.17487821f, 0.18609512f, 0.21560600f, -0.01495091f, 0.05237633f, 0.01777910f, 0.01143929f, -0.12604435f, 
    -0.09115974f, -0.12610842f, -0.18421844f, -0.10192186f, 0.03332877f, 0.08856568f, -0.08066389f, 0.05136576f, 
    0.01667323f, 0.06049998f, 0.00272602f, -0.01362637f, -0.15379834f, -0.11529274f, -0.14283770f, -0.08335725f, 
    0.03336253f, 0.01747526f, 0.06383409f, 0.05880988f, 0.10325377f, 0.07165492f, -0.09056708f, 0.11928800f, 
    -0.01098946f, 0.08387167f, 0.22445466f, 0.19083183f, 0.06974208f, -0.05649757f, -0.00823553f, 0.19308172f, 
    0.00573294f, -0.05508047f, 0.02486011f, -0.00642352f, -0.07225014f, 0.12359424f, -0.19232169f, -0.00172505f, 
    -0.11599538f, -0.13947341f, -0.03201791f, -0.15036400f, 0.16454209f, 0.05494799f, 0.02124932f, 0.25674641f, 
    -0.00587768f, -0.22322385f, -0.04894356f, 0.04565771f, -0.17471823f, -0.09621125f, -0.00236764f, -0.19809870f, 
    0.08912021f, -0.00127166f, -0.05148859f, 0.11620191f, -0.27553979f, 0.22020410f, -0.58517849f, -0.40081227f, 
    0.07882597f, 0.01916484f, -0.02599682f, 0.00852320f, 0.03442654f, -0.03255038f, 0.06341990f, -0.14204155f, 
    -0.12540682f, 0.03308155f, 0.02366061f, -0.13949881f, -0.12340555f, -0.17637843f, 0.10712531f, -0.08116441f, 
    -0.04487002f, -0.06279125f, 0.00222039f, -0.16899692f, 0.16339543f, -0.03800562f, 0.02552538f, 0.04453254f, 
    0.04212698f, 0.09218781f, -0.08203416f, 0.01360501f, -0.10573605f, -0.29804945f, -0.34879646f, -0.08264129f, 
    -0.06190212f, 0.07808508f, 0.21501863f, 0.24677095f, -0.13606170f, 0.09337025f, 0.03736963f, 0.07605394f, 
    -0.02080869f, -0.03735058f, -0.02842541f, -0.00106858f, -0.06410272f, -0.04775532f, -0.05039328f, -0.01783640f, 
    -0.16561779f, 0.05369772f, -0.07851930f, -0.06287463f, -0.19101146f, -0.01477543f, -0.24099070f, -0.02527832f, 
    -0.00773886f, 0.01785865f, 0.07794508f, 0.04145088f, -0.10488730f, -0.05707659f, 0.05409002f, 0.15628979f, 
    0.05332225f, -0.04282084f, 0.00516412f, 0.05420170f, 0.11298279f, 0.25499555f, -0.19553268f, 0.09738128f, 
    0.06825110f, -0.13861416f, 0.13997473f, -0.18824910f, 0.08022650f, -0.14943433f, 0.32464644f, 0.19414447f, 
    -0.00700951f, -0.13368784f, 0.02162442f, 0.15601610f, -0.14987773f, -0.15090857f, -0.04145802f, -0.01265477f, 
    0.03594121f, -0.02304745f, -0.00524542f, -0.02966355f, 0.14956711f, 0.09980815f, 0.16942331f, 0.22193795f, 
    -0.12250303f, -0.11041048f, -0.09894513f, -0.02737332f, -0.01490436f, -0.14108257f, -0.07784411f, -0.13315317f, 
    0.00287412f, 0.02202107f, -0.02979774f, -0.02973277f, 0.08131424f, 0.04224320f, 0.01367822f, 0.04402123f, 
    0.15373076f, 0.04260238f, -0.01844000f, 0.00974414f, 0.05161511f, 0.10272606f, 0.02602596f, 0.17860426f, 
    -0.06827343f, -0.18832703f, 0.10918985f, -0.12344024f, 0.05782919f, -0.04239369f, -0.01701598f, 0.00473193f, 
    -0.15238780f, -0.11240564f, 0.06247835f, 0.00688677f, -0.03122406f, 0.02862824f, -0.22984208f, 0.04495969f, 
    -0.06285652f, 0.06078127f, -0.08603603f, -0.01007026f, 0.10756473f, 0.15973704f, 0.09835269f, 0.19697475f, 
    0.09281339f, -0.12056705f, 0.12409746f, -0.17658260f, 0.05003165f, -0.05855817f, 0.16584097f, 0.14845076f, 
    0.03181083f, 0.14795546f, -0.15212266f, 0.07372419f, -0.03043589f, -0.05415328f, 0.03492688f, -0.01271437f, 
    -0.01522551f, -0.14924720f, -0.04834339f, 0.04849828f, -0.04384475f, 0.02376320f, 0.10631652f, 0.14208873f, 
    0.00759232f, -0.01734470f, 0.00879537f, 0.08260097f, -0.02158564f, -0.05469567f, 0.02792828f, 0.06707888f, 
    0.11751585f, -0.03422994f, -0.04286182f, 0.07205956f, -0.00419126f, 0.00594310f, -0.03866755f, 0.11918107f, 
    0.00844551f, -0.03033067f, -0.11553155f, -0.11161070f, 0.05374438f, 0.14618935f, 0.16135725f, 0.12963475f, 
    -0.06341326f, -0.10966317f, 0.01933878f, -0.05157131f, -0.00138510f, 0.03510279f, 0.06138468f, 0.03557048f, 
    0.00972580f, -0.25490794f, 0.20625827f, 0.11295263f, -0.06682722f, 0.09884330f, 0.06186362f, -0.01307169f, 
    0.01896999f, 0.03441269f, -0.07148982f, -0.00108921f, 0.09922345f, 0.10268360f, 0.12315250f, 0.18929929f, 
    0.01756091f, -0.00050786f, -0.17657222f, -0.06037671f, -0.00414990f, -0.08100784f, -0.03590906f, -0.07297483f, 
    0.22380982f, -0.05073937f, -0.18837464f, -0.01964959f, 0.22476159f, 0.03763008f, -0.11976187f, -0.08230506f, 
    0.03108086f, -0.06924073f, -0.08855156f, 0.04937043f, 0.03659751f, -0.05181861f, -0.10523702f, 0.07569774f, 
    -0.06545429f, 0.02048037f, 0.14981830f, 0.01229989f, 0.03531159f, 0.22078452f, 0.04433949f, 0.12408122f, 
    -0.15275826f, -0.14502881f, -0.09845091f, 0.10971928f, 0.06319541f, -0.08411882f, -0.08331329f, -0.02963290f, 
    -0.01247976f, -0.05071842f, -0.00291376f, 0.07945129f, 0.11157319f, 0.06552891f, -0.12790048f, -0.22220860f, 
    0.09017560f, -0.05391975f, 0.13058844f, 0.04213201f, -0.05680304f, -0.01293415f, 0.02965804f, -0.02463375f, 
    -0.02167603f, 0.16208437f, -0.05935992f, -0.19152306f, 0.19002955f, -0.12859206f, 0.19341043f, -0.27044019f, 
    0.03410128f, 0.00144421f, -0.00276245f, 0.06717241f, -0.41334477f, 0.18525229f, 0.14258189f, 0.10031364f, 
    -0.11284205f, -0.14019325f, -0.04934997f, 0.19467369f, 0.02844493f, -0.11508504f, -0.16517626f, 0.02069032f, 
    -0.10742018f, 0.02859123f, -0.07512701f, 0.11969327f, 0.09062525f, 0.14300835f, -0.15058868f, 0.07091141f, 
    -0.05539011f, -0.00020283f, 0.13156559f, -0.01418466f, 0.25482193f, 0.00928027f, 0.10040774f, 0.04229796f, 
    0.07387435f, -0.01383697f, -0.11620308f, -0.09698125f, 0.03215877f, 0.04823663f, 0.01982175f, -0.01462558f, 
    0.04399501f, -0.06646502f, -0.02419827f, 0.40716475f, 0.09402455f, -0.00915449f, -0.10915319f, 0.03358414f, 
    -0.05532995f, 0.02069316f, -0.16480221f, -0.15642320f, -0.38304296f, -0.30600736f, -0.25764641f, -0.18817051f, 
    -0.02280164f, -0.08913232f, -0.04339880f, 0.17022783f, -0.12264977f, -0.14752823f, -0.02697621f, -0.09941194f, 
    -0.00179272f, 0.10852121f, -0.16115694f, 0.20239986f, -0.07049567f, 0.06276252f, 0.03236111f, -0.02201011f, 
    -0.10175847f, 0.07411207f, -0.08573516f, -0.26039791f, -0.03734326f, -0.08549651f, -0.06165746f, -0.00959814f, 
    0.03709557f, -0.07825196f, 0.00852560f, 0.15419868f, -0.15252468f, -0.31575701f, -0.31828418f, -0.61687893f, 
    0.03258028f, -0.02002143f, 0.03041974f, -0.08461457f, -0.18112692f, 0.17957100f, 0.12379101f, 0.07447755f, 
    0.09445640f, 0.06789690f, 0.07694958f, -0.00215336f, -0.49978587f, -0.75046372f, 0.21502058f, 0.00947857f, 
    -0.11836120f, -0.07411106f, -0.03298536f, 0.03882409f, 0.17014895f, 0.01345634f, 0.03154291f, -0.02893421f, 
    -0.11546686f, 0.18248530f, -0.06399953f, -0.01160637f, -0.01222105f, -0.08479929f, -0.00911222f, -0.06207551f, 
    -0.02858518f, 0.07897694f, -0.03034568f, -0.12762573f, -0.05999798f, 0.08594781f, -0.10511687f, -0.25068054f, 
    -0.03735839f, 0.03056418f, -0.13141419f, 0.05512645f, 0.16059946f, -0.08750019f, 0.13459618f, 0.03524730f, 
    0.08309357f, -0.04530919f, 0.02002052f, -0.05118637f, 0.08064805f, 0.21831071f, 0.09446955f, 0.07216726f, 
    0.06759144f, -0.01264458f, 0.01674384f, 0.07404706f, -0.01950608f, -0.47439200f, -0.02381052f, 0.04666857f, 
    0.08600387f, 0.09452935f, -0.13237628f, 0.01034992f, 0.07960148f, -0.02062530f, -0.00533368f, -0.07565860f, 
    -0.34736100f, 0.80982804f, -0.41398451f, -0.25350812f, -0.13245413f, 0.03581832f, -0.05988446f, 0.12943310f, 
    0.04305134f, -0.01902798f, -0.02636803f, 0.03596291f, 0.06224453f, -0.08754932f, 0.10292862f, 0.06064565f, 
    0.07623434f, 0.05777834f, -0.10987571f, 0.17832793f, 0.01106427f, 0.01375614f, 0.00326916f, 0.04302214f, 
    0.21297102f, -0.02984836f, -0.29869473f, 0.10851923f, -0.01603303f, 0.01319936f, -0.10724884f, -0.05778222f, 
    0.22497742f, 0.11964483f, 0.00913504f, 0.14652462f, 0.03323820f, -0.09995506f, -0.31331643f, -0.15780351f, 
    0.05727731f, 0.12650910f, -0.04732263f, 0.05346262f, -0.02326021f, -0.06151175f, -0.04190324f, -0.02693079f, 
    -0.12497108f, 0.04457021f, -0.35942078f, -0.03526388f, -0.10569145f, 0.00414531f, 0.01253049f, 0.02775305f, 
    0.10470927f, 0.11196122f, -0.00786692f, 0.02138630f, 0.13920431f, -0.06329301f, 0.26709324f, -0.34246662f, 
    -0.08103356f, 0.19571765f, -0.02804308f, 0.08359202f, 0.14204662f, 0.02798336f, 0.13193896f, -0.02263024f, 
    0.20165242f, -0.02693465f, 0.20391080f, 0.05309149f, -0.13578016f, 0.06601762f, 0.03097771f, 0.20120333f, 
    -0.08377779f, -0.11306646f, -0.06770110f, -0.04869731f, 0.12631159f, -0.09855853f, 0.13474150f, -0.14993741f, 
    0.09242143f, -0.04061476f, -0.05412012f, 0.02552583f, -0.13528758f, -0.21902142f, 0.11373550f, -0.24292870f, 
    -0.00499019f, -0.17079407f, -0.10303760f, -0.07904650f, 0.09268972f, 0.05492811f, -0.22280425f, 0.12011521f, 
    -0.03877244f, -0.10081366f, 0.26541856f, -0.02673711f, -0.65518421f, -0.15265502f, 0.02881222f, -0.00220094f, 
    0.11427440f, -0.21179645f, 0.06104470f, 0.14421178f, 0.03782802f, -0.04606746f, 0.10254923f, 0.14439470f, 
    0.04615465f, -0.02965014f, 0.31962246f, -0.01221986f, 0.03574460f, 0.06932800f, 0.02987295f, 0.01917799f, 
    0.02758555f, -0.04345538f, 0.20885248f, 0.11801787f, 0.14536950f, 0.15776901f, -0.35197955f, -0.35391688f, 
    -0.05810310f, 0.05279020f, -0.05135772f, -0.00231773f, 0.07601563f, -0.27121750f, 0.00606587f, -0.17988685f, 
    0.08284737f, -0.13356560f, -0.19193141f, -0.00254711f, -0.01759063f, 0.10005431f, -0.02232778f, 0.07895564f, 
    0.11755889f, -0.45626271f, -0.23783039f, -0.34533188f, 0.23993494f, -0.32706901f, -0.08873444f, 0.11862312f, 
    -0.07154807f, 0.03115315f, 0.04441833f, 0.04403591f, 0.04214603f, -0.03264199f, -0.02984059f, -0.03038816f, 
    -0.08689559f, 0.02204984f, -0.28573033f, -0.10897227f, -0.05072062f, 0.13405913f, 0.00598899f, -0.01533735f, 
    0.11276448f, -0.16329917f, -0.03742112f, -0.14434618f, -0.07184348f, -0.01635770f, -0.01683646f, 0.07966610f, 
    -0.00591892f, 0.07765011f, 0.02117700f, -0.11531343f, 0.07344848f, -0.10686502f, 0.08232475f, 0.10332790f, 
    0.13672148f, 0.05158440f, 0.09218048f, -0.17109977f, 0.21495198f, 0.00639346f, -0.23358935f, -0.01890485f, 
    -0.00129321f, -0.01714276f, 0.03665344f, -0.01643049f, -0.34098142f, 0.33212951f, 0.05710643f, 0.16930953f, 
    0.10519055f, -0.12607627f, -0.02302994f, 0.18953401f, 0.00008337f, -0.07181676f, 0.05967766f, 0.01340164f, 
    -0.06240646f, -0.12797010f, -0.07787702f, 0.07924158f, -0.02648627f, -0.09047145f, 0.14943136f, 0.03662891f, 
    -0.17609803f, 0.16766033f, -0.03484394f, -0.12253777f, 0.10759288f, 0.12657654f, -0.25805372f, -0.29712787f, 
    0.07802912f, 0.08847040f, -0.05205109f, -0.01325606f, 0.04827989f, -0.03570352f, 0.03523052f, 0.03490509f, 
    0.07013402f, 0.16333699f, 0.12337629f, 0.09340142f, -0.09563640f, 0.11742130f, -0.07540919f, -0.01750258f, 
    0.30279568f, -0.03868520f, -0.12800691f, -0.18999253f, -0.07644144f, 0.10908837f, -0.17184329f, -0.09131150f, 
    0.05448382f, 0.03900296f, -0.17453234f, 0.13210608f, -0.07696611f, -0.00714930f, 0.00781527f, -0.03481426f, 
    0.13312718f, -0.10761072f, -0.10380223f, 0.12178291f, -0.00477266f, 0.05364771f, 0.04344902f, -0.02271803f, 
    0.06613814f, -0.09324321f, 0.07172654f, 0.00895246f, 0.12459599f, 0.01537636f, -0.06867111f, 0.03918450f, 
    0.05783894f, -0.06676262f, -0.01964257f, 0.16047686f, 0.11312091f, -0.00114223f, -0.12378031f, 0.07131290f, 
    0.14101557f, 0.07773776f, -0.01889547f, -0.02269328f, -0.08908888f, 0.06248406f, 0.07068882f, 0.19757631f, 
    0.07271051f, 0.03302144f, 0.06720477f, 0.11410129f, -0.44389960f, 0.03228417f, 0.15496528f, -0.08948220f, 
    0.02315025f, -0.03685701f, 0.15344501f, 0.14422344f, 0.04198660f, 0.02366539f, -0.18985778f, -0.28051934f, 
    0.06980585f, -0.15978204f, -0.01177596f, 0.05084118f, 0.03187494f, -0.04095504f, 0.07290963f, 0.00631109f, 
    0.10071814f, 0.05040042f, 0.04187995f, -0.12664290f, -0.22411329f, 0.01051074f, -0.37231979f, -0.20707610f, 
    -0.03094818f, 0.14220341f, -0.06747229f, 0.15109071f, -0.03868940f, -0.08736125f, 0.05535072f, -0.13656212f, 
    0.21398138f, -0.20564584f, -0.31998610f, 0.10310356f, 0.07838614f, 0.11127722f, -0.01071976f, 0.26002204f, 
    0.06476321f, -0.17208725f, 0.21764620f, 0.27119562f, 0.00472723f, -0.12189613f, 0.13571484f, -0.08498304f, 
    -0.14194524f, -0.16387182f, -0.07675664f, -0.03117251f, 0.16977888f, 0.01172436f, 0.35246748f, -0.00313757f, 
    0.15935449f, -0.03722328f, 0.26030561f, 0.03093508f, -0.01155399f, 0.08344369f, 0.06187591f, -0.25045234f, 
    0.02742107f, 0.00719550f, -0.02507731f, -0.01242510f, 0.17994528f, -0.35524967f, 0.13631111f, 0.11170450f, 
    0.10089134f, 0.03681725f, 0.13287495f, -0.01434592f, 0.01732857f, 0.10393876f, -0.04710781f, 0.04890945f, 
    -0.01668401f, 0.04528861f, 0.08378769f, -0.22664811f, 0.15829416f, 0.08804001f, 0.13740358f, 0.11281446f, 
    -0.01843665f, -0.01334296f, 0.03650375f, 0.05940325f, -0.01435220f, 0.02481096f, -0.29715392f, -0.00394936f, 
    0.02393804f, 0.09299219f, -0.03242727f, 0.12101910f, 0.05283653f, -0.14906579f, 0.05759143f, -0.43500262f, 
    -0.32807317f, 0.12228965f, 0.06711833f, -0.21332343f, 0.08263157f, -0.02714638f, 0.04465256f, 0.22146945f, 
    -0.06300189f, 0.01729892f, 0.06246862f, 0.01119428f, -0.39277643f, -0.22596675f, -0.07143166f, -0.26982123f, 
    0.08592322f, 0.01462130f, 0.01339172f, -0.14274767f, 0.15822683f, -0.16552611f, 0.26239726f, 0.05157335f, 
    -0.04895268f, -0.11989857f, -0.13884407f, 0.08012465f, 0.01269368f, -0.04326585f, -0.02126568f, -0.05051259f, 
    -0.02455196f, 0.02943879f, 0.02600773f, 0.03378775f, -0.09906923f, -0.09742612f, -0.13864401f, -0.10088803f, 
    -0.07343968f, 0.05930641f, 0.02480356f, 0.17601334f, 0.19439350f, -0.04314502f, -0.01885794f, -0.00392324f, 
    0.11146076f, -0.22234416f, 0.37102526f, 0.01622816f, 0.08556495f, 0.06109512f, 0.08058527f, 0.07056943f, 
    0.14221483f, -0.14136440f, -0.01830892f, 0.11265752f, -0.00989613f, 0.12615658f, 0.16816325f, 0.05055402f, 
    -0.03930743f, -0.03170472f, 0.01039247f, -0.09515784f, 0.01202029f, -0.07712478f, -0.01925691f, -0.00065498f, 
    -0.55830532f, -0.35791993f, 0.04999012f, -0.04385673f, -0.07149973f, -0.02472994f, 0.00236426f, 0.02925262f, 
    0.04069931f, 0.00476362f, 0.05645780f, 0.02249937f, 0.10855319f, 0.20377119f, 0.10748876f, -0.17222865f, 
    0.11376677f, -0.06581881f, 0.08472955f, -0.05850841f, 0.08045476f, -0.00802919f, 0.05655605f, 0.06539585f, 
    -0.03323069f, -0.09388644f, 0.15309140f, -0.08820413f, 0.00466648f, -0.02352211f, 0.00345167f, -0.03338363f, 
    0.12234323f, -0.13617963f, 0.02076067f, 0.05086683f, 0.18459177f, -0.10608881f, -0.06042755f, -0.12422184f, 
    0.00398508f, -0.06320728f, -0.04771800f, 0.15252466f, -0.00271421f, -0.20645364f, -0.03006553f, -0.14206125f, 
    -0.11550512f, 0.09765439f, 0.19414635f, -0.09398858f, -0.00123976f, -0.01430354f, -0.00122164f, -0.00154977f, 
    -0.06624638f, 0.05980935f, 0.03594407f, -0.02665672f, -0.06257104f, -0.11309686f, 0.05953974f, -0.13915806f, 
    -0.12224832f, 0.05119801f, -0.06616156f, 0.00718297f, 0.03982699f, 0.06938682f, -0.05840415f, 0.05134693f, 
    0.18623683f, 0.22222652f, -0.09509842f, -0.07018506f, -0.03222403f, 0.12766585f, 0.20200811f, -0.14431486f, 
    0.20736331f, 0.08228258f, 0.17403860f, -0.16340645f, 0.02718931f, -0.04001082f, 0.03078262f, -0.04767935f, 
    0.06012357f, 0.01888924f, 0.03684988f, -0.01806697f, -0.01702673f, -0.02162971f, -0.14145041f, -0.04046344f, 
    0.10444856f, 0.00032303f, -0.12107739f, -0.00750798f, 0.05632222f, -0.01452505f, 0.05125763f, -0.04990388f, 
    -0.02010710f, -0.04737828f, -0.05650764f, -0.07057186f, -0.36231837f, 0.10741290f, -0.01025384f, 0.03277535f, 
    -0.21301532f, 0.09794570f, -0.04988028f, -0.00605918f, 0.00206867f, 0.00110830f, 0.05243919f, 0.00102844f, 
    -0.67273366f, -0.55561346f, 0.13236929f, -0.09336031f, 0.02892224f, -0.09227635f, -0.09368947f, -0.22170532f, 
    0.00977213f, -0.04129282f, -0.02489743f, -0.01969807f, 0.06405246f, -0.34371778f, -0.16183077f, 0.02950019f, 
    -0.00345576f, 0.03935882f, 0.05499956f, 0.08629452f, -0.05752992f, 0.02194371f, 0.15648441f, 0.01989019f, 
    -0.03401484f, -0.10667390f, -0.27090532f, -0.09884883f, -0.12576731f, 0.21875262f, -0.03328522f, 0.04067549f, 
    -0.02681898f, 0.00843598f, -0.13511813f, 0.03948402f, -0.45714992f, -0.56790286f, -0.59773690f, -0.21056740f, 
    0.05421515f, 0.16407746f, -0.12083125f, -0.23773374f, 0.02761402f, -0.09010325f, 0.10004252f, -0.06686182f, 
    -0.22705294f, 0.02896148f, -0.05325323f, -0.03565077f, -0.08922409f, 0.05826296f, -0.06630172f, -0.09081171f, 
    -0.04205771f, -0.06085676f, 0.05643292f, 0.19266184f, -0.26307255f, 0.12418700f, 0.23113182f, 0.16351455f, 
    -0.11837102f, -0.02380143f, 0.04993870f, 0.02479507f, -0.01649380f, 0.10059853f, 0.06075924f, 0.07556617f, 
    0.11721107f, 0.05614305f, 0.02766817f, -0.19341987f, -0.04842601f, 0.05746269f, 0.08687674f, 0.02753658f, 
    0.07594886f, 0.06971882f, -0.04814121f, 0.13150129f, 0.08878720f, -0.10370019f, -0.06811899f, 0.04733738f, 
    -0.04042586f, 0.02298721f, 0.10795325f, 0.02114644f, 0.05785124f, 0.33672118f, 0.16417195f, 0.02175602f, 
    -0.08799379f, -0.13094063f, 0.02140346f, 0.10581398f, -0.01022695f, -0.07373323f, 0.03628410f, 0.04820216f, 
    -0.07071802f, -0.00970880f, -0.11228748f, -0.05325871f, -0.04695816f, -0.22143276f, 0.25274265f, 0.07594095f, 
    -0.05648687f, -0.00771127f, -0.06618333f, 0.22890556f, -0.01355159f, 0.12141998f, 0.15113403f, 0.11276281f, 
    -0.02673856f, -0.10716813f, 0.04791854f, -0.32902646f, -0.00245688f, 0.01203904f, 0.00057680f, -0.02648249f, 
    -0.03798836f, -0.02453035f, -0.02844160f, 0.14706910f, -0.14799032f, -0.02330604f, 0.02844474f, -0.28953186f, 
    0.09690618f, 0.05705755f, 0.05808875f, -0.05132653f, 0.04553941f, 0.00989500f, -0.05193829f, 0.01099734f, 
    -0.38031560f, -0.52455729f, -0.13512151f, -0.17941579f, -0.23225293f, -0.31797779f, -0.25997910f, -0.48299280f, 
    0.00233236f, -0.00766393f, 0.01654860f, -0.11245226f, -0.09066150f, -0.27795872f, -0.33081400f, -0.16230880f, 
    0.02892085f, 0.18508695f, 0.16212247f, -0.00859171f, -0.00786806f, -0.02976280f, -0.13176252f, 0.08925745f, 
    -0.40114474f, -0.13313673f, 0.16685621f, -0.14376684f, 0.00590290f, 0.08176611f, 0.13762599f, -0.07607406f, 
    0.08742133f, 0.07780874f, -0.01568582f, -0.00177540f, -0.46968731f, -0.47136405f, -0.19038157f, -0.07240041f, 
    -0.29034376f, -0.17890982f, 0.21967249f, -0.15365890f, -0.02365201f, -0.02476460f, -0.01016885f, 0.05052808f, 
    0.77187055f, 0.30934420f, -0.18135509f, 0.47766843f, -0.04813435f, -0.06702916f, 0.15527406f, 0.12531331f, 
    0.08043271f, 0.02417565f, 0.14005640f, -0.13012479f, -0.19709615f, -0.25854832f, -0.01971101f, -0.06282944f, 
    0.14816897f, 0.10720129f, 0.05522029f, -0.08059910f, -0.02495074f, 0.00688992f, -0.09603895f, 0.02532632f, 
    0.00172637f, -0.06934988f, 0.02695927f, 0.04719418f, 0.07473907f, 0.00165918f, 0.08920988f, -0.09482580f, 
    -0.08349407f, -0.08534136f, -0.00759490f, 0.06846200f, -0.47885621f, 0.15527168f, 0.15567981f, 0.26156703f, 
    -0.04074403f, -0.05450742f, -0.11564942f, 0.03096145f, 0.01953875f, -0.14155471f, 0.05132440f, 0.08900106f, 
    -0.37197551f, 0.18221861f, -0.11788091f, -0.33855873f, -0.22207214f, -0.03484299f, -0.03254990f, 0.16298544f, 
    0.03858507f, 0.01487977f, -0.06441741f, -0.00580517f, 0.12319209f, 0.04961539f, -0.13229512f, -0.08416899f, 
    -0.08620789f, -0.01083517f, 0.06773985f, 0.03680369f, 0.15013136f, 0.03875481f, -0.00176443f, -0.04948793f, 
    0.06946592f, 0.14465240f, -0.05176231f, 0.03113952f, -0.08598600f, 0.09710917f, 0.08728830f, -0.06552932f, 
    0.13957533f, 0.00398879f, 0.18442452f, -0.07848994f, -0.16016674f, -0.04960348f, 0.33189064f, 0.11509921f, 
    0.09601665f, -0.16604871f, 0.18461376f, -0.10074873f, 0.01062686f, 0.06232576f, -0.01361784f, -0.08181434f, 
    0.02422542f, 0.01997181f, 0.06184520f, -0.03103128f, 0.10094109f, -0.06338746f, -0.06880012f, 0.13876306f, 
    -0.01159621f, 0.07513310f, 0.01856040f, -0.06014408f, 0.01857551f, 0.09850071f, 0.08534306f, -0.17734870f, 
    -0.03191949f, 0.01502378f, 0.01977004f, 0.10092235f, 0.04842439f, 0.01924869f, 0.11951729f, -0.10184965f, 
    0.05232552f, 0.18707803f, -0.05688487f, 0.01359104f, -0.02457730f, -0.00937770f, 0.02590417f, -0.01553555f, 
    0.17149709f, 0.14379619f, 0.15982021f, 0.18411374f, -0.21838686f, -0.21855952f, -0.14748669f, 0.16460928f, 
    0.02131314f, 0.15023904f, 0.12143619f, 0.01921783f, -0.00113030f, -0.03339323f, -0.04040655f, 0.03687396f, 
    -0.04980281f, 0.16497995f, 0.11949210f, -0.00426974f, 0.14373873f, 0.04368382f, -0.06529564f, 0.03481807f, 
    -0.05454915f, 0.00082762f, -0.17386584f, 0.20494458f, 0.05682437f, 0.07397489f, 0.11754296f, -0.06459434f, 
    0.04430403f, -0.05048965f, 0.09545010f, 0.11544279f, -0.02621542f, -0.03278439f, 0.14811501f, 0.15993120f, 
    -0.47312179f, -0.42814696f, -0.38086170f, -0.10206076f, -0.06193825f, 0.01063847f, -0.16048694f, -0.34392199f, 
    -0.02537605f, -0.08674268f, -0.06929857f, 0.04964267f, 0.24253206f, -0.06941061f, -0.08398263f, 0.12878980f, 
    -0.02519567f, -0.02446566f, 0.05185156f, 0.08923065f, -0.04974767f, 0.00662199f, 0.11732384f, -0.25569332f, 
    0.24758692f, -0.01709855f, -0.07068772f, 0.02994194f, -0.10680830f, -0.10212179f, -0.01113202f, -0.05726412f, 
    -0.00578506f, -0.13653851f, -0.01254788f, -0.02718564f, -0.43065712f, -0.12112742f, 0.17064340f, -0.32517469f, 
    -0.00332878f, 0.05022769f, -0.03618874f, 0.02964094f, -0.00193176f, -0.00975000f, 0.00491683f, 0.03678896f, 
    -0.42826188f, -0.30996174f, 0.13933852f, 0.36445272f, 0.01574245f, 0.12090138f, 0.06187647f, -0.21566033f, 
    0.08064361f, -0.08783087f, 0.03587269f, 0.09415624f, 0.04769750f, -0.26969656f, 0.06798813f, -0.21378139f, 
    0.19348408f, 0.18388140f, 0.12633426f, -0.12408680f, 0.05000079f, -0.01563018f, 0.00685375f, 0.05457410f, 
    0.02467307f, 0.01372920f, -0.07906388f, -0.08177885f, -0.00776178f, 0.02448696f, 0.00314983f, 0.09889815f, 
    -0.03753139f, 0.02628097f, -0.00421627f, -0.11278683f, 0.11675590f, 0.07663529f, -0.19987376f, -0.07936512f, 
    -0.02043068f, -0.05366309f, 0.00205858f, 0.06642906f, 0.00619710f, -0.06748397f, 0.00018675f, 0.10609438f, 
    -0.46488494f, -0.40210018f, -0.25841594f, -0.02960620f, -0.04104031f, -0.20750161f, -0.16028287f, -0.28539798f, 
    -0.03076521f, -0.06747238f, 0.03494886f, -0.07198561f, 0.33805826f, -0.45773920f, -0.11551166f, -0.04511395f, 
    -0.05314537f, 0.10097337f, 0.06794243f, 0.03113646f, 0.06933019f, 0.01091870f, 0.04851812f, 0.17893566f, 
    -0.14887223f, -0.01976861f, -0.04556573f, 0.03870171f, -0.04586215f, 0.01701136f, -0.06361736f, -0.18052036f, 
    0.00693372f, 0.02833507f, -0.00422473f, 0.00702585f, -0.03939921f, -0.09839660f, 0.16775954f, -0.15295200f, 
    0.03627486f, 0.00783966f, 0.06750423f, -0.15338555f, 0.04843922f, 0.03721048f, -0.05988429f, 0.07129452f, 
    0.28412730f, 0.11977996f, 0.11604156f, -0.22734784f, 0.04556851f, -0.13870238f, 0.19847994f, 0.02338489f, 
    0.10321950f, -0.04222263f, 0.10133196f, 0.10596004f, -0.19033198f, -0.02850355f, -0.12197088f, 0.13127297f, 
    -0.00277005f, -0.03079034f, -0.14207780f, 0.00684782f, 0.00624044f, -0.02417176f, 0.14780530f, 0.04564673f, 
    -0.52214539f, -0.61553323f, -0.41259056f, 0.08844221f, 0.05172535f, 0.17650700f, -0.03689045f, -0.13080530f, 
    0.02649189f, -0.02611381f, 0.04301802f, 0.06677572f, -0.16477923f, -0.01837871f, -0.09098044f, 0.31358632f, 
    0.04115957f, 0.17730063f, -0.04803026f, 0.03242427f, 0.00183843f, -0.02380070f, -0.04115303f, 0.03192051f, 
    -0.35119653f, -0.50540668f, -0.30859593f, -0.24090885f, 0.03968675f, -0.13090023f, -0.06261712f, -0.34264097f, 
    -0.05771335f, -0.01467850f, -0.05118106f, -0.02391400f, 0.10277242f, -0.08632004f, 0.02322326f, -0.02554543f, 
    -0.00088937f, 0.02251351f, 0.14368479f, -0.05537464f, 0.08848584f, 0.11317500f, 0.14458971f, 0.15459920f, 
    -0.51552039f, -0.48521554f, 0.02094479f, 0.09096138f, -0.16706626f, -0.01196963f, 0.08137172f, -0.02211080f, 
    0.03819315f, 0.05590500f, 0.01033808f, -0.00233078f, -0.35467795f, 0.11043096f, 0.36397231f, 0.31414047f, 
    -0.03399847f, -0.07491318f, 0.06421491f, -0.13579433f, -0.04744362f, 0.22149017f, -0.12427868f, 0.09934206f, 
    0.01994847f, -0.03356259f, -0.07084659f, -0.03941953f, 0.02754068f, -0.00240263f, 0.07044434f, 0.05326798f, 
    0.00377238f, -0.05574263f, -0.06659493f, -0.32154995f, -0.01892046f, 0.10435291f, 0.02725449f, 0.02822564f, 
    -0.15298037f, -0.25923836f, -0.02138861f, 0.06192587f, 0.02426598f, -0.04419664f, 0.08005163f, -0.12195594f, 
    -0.12881853f, -0.20915827f, -0.18024157f, 0.14876279f, -0.06754024f, 0.00128716f, -0.04543653f, 0.13641655f, 
    -0.00999328f, -0.04606631f, -0.01025234f, 0.05694757f, -0.33134285f, -0.42438495f, -0.35645202f, -0.18148211f, 
    0.05984436f, 0.03062565f, 0.07314285f, -0.12610552f, -0.05847676f, 0.00532339f, 0.07930298f, -0.00555723f, 
    -0.09325061f, 0.01955565f, 0.15558554f, 0.23257788f, -0.02721842f, -0.03283478f, -0.02729773f, 0.05286979f, 
    0.01027665f, 0.09992152f, 0.13912474f, 0.01680127f, -0.21878868f, -0.33449915f, -0.45401543f, -0.04338436f, 
    -0.09435263f, -0.07329428f, -0.11248972f, -0.19844081f, -0.00966841f, -0.04554951f, 0.00721563f, 0.01955478f, 
    -0.14318520f, 0.04956437f, -0.01386413f, 0.00345949f, 0.04943071f, -0.01332658f, 0.00891471f, 0.10692830f, 
    0.17237331f, 0.04283784f, 0.03620206f, 0.02611912f, 0.50487030f, 0.47070006f, -0.31635830f, -0.07354773f, 
    -0.11404027f, 0.05632371f, -0.08946317f, 0.14996722f, 0.07970369f, 0.02781120f, 0.01874121f, -0.00540978f, 
    -0.32709309f, -0.44250557f, -0.21834944f, 0.53029501f, 0.11577059f, -0.06322201f, -0.05683552f, -0.24405652f, 
    -0.00212545f, 0.04694612f, -0.01833467f, 0.02088711f, -0.53842479f, -0.38276258f, -0.30724207f, -0.21206854f, 
    -0.00184519f, -0.15565470f, -0.14796081f, -0.05266602f, -0.03804439f, 0.01354530f, 0.02531625f, -0.03747021f, 
    0.12169807f, 0.01279407f, 0.03639154f, -0.06414041f, 0.07957693f, -0.00753580f, 0.03229123f, -0.06598478f, 
    -0.18545847f, 0.12246959f, -0.15137091f, 0.06949595f, -0.02318292f, 0.09321261f, -0.05780089f, -0.00741061f, 
    -0.09109730f, -0.16723771f, -0.05638364f, 0.02131937f, -0.00053328f, -0.01773190f, 0.00341702f, 0.01001738f, 
    0.04905671f, 0.02123177f, 0.03736205f, -0.03133785f, -0.03801288f, 0.02188951f, -0.02613462f, -0.01822761f, 
    0.01569114f, 0.01009260f, -0.01395546f, -0.02489991f, 0.52912605f, -0.27715430f, -0.04706863f, -0.38129279f, 
    -0.19854687f, 0.06993657f, 0.06305464f, -0.10170721f, 0.03097825f, 0.12335166f, 0.01737459f, -0.06104223f, 
    -0.44736630f, 0.28140813f, 0.02839182f, 0.02997755f, -0.02971879f, -0.15063062f, -0.09031136f, 0.03952118f, 
    -0.04915715f, 0.04481699f, 0.04361599f, -0.01030627f, 0.39562663f, -0.70310909f, -0.10561701f, -0.46965319f, 
    -0.02588201f, -0.14739963f, -0.11498750f, 0.07565042f, -0.00048109f, 0.10961214f, -0.10978225f, -0.07303087f, 
    -0.11672623f, 0.03142591f, -0.04164581f, 0.08639137f, -0.11344896f, -0.00036343f, -0.07087152f, -0.01444422f, 
    -0.08389461f, -0.08748600f, -0.03265555f, 0.02310281f, -0.31732076f, -0.25548768f, 0.12706950f, 0.40901625f, 
    0.01583579f, 0.15753600f, 0.12884735f, -0.04793678f, 0.03370341f, -0.01913786f, -0.02457283f, -0.07387347f, 
    0.05869251f, 0.31951100f, -0.29198554f, -0.09265676f, 0.01900355f, -0.00954933f, -0.11753614f, 0.02781715f, 
    -0.11213184f, 0.05824786f, -0.02522218f, 0.01197945f, 0.42851835f, -0.25062066f, -0.06973763f, -0.20359814f, 
    -0.04299239f, -0.10859533f, -0.10981295f, 0.04184375f, 0.14944111f, 0.01405580f, -0.01304204f, 0.03888500f, 
    -0.19826381f, 0.10152529f, -0.26066867f, 0.07712062f, -0.05724834f, -0.04051875f, 0.04161920f, 0.04506949f, 
    -0.01315372f, 0.03133371f, 0.04521689f, -0.12027139f, 0.01277569f, 0.03591202f, 0.18238051f, 0.00130388f, 
    0.01222827f, 0.05989378f, -0.02044410f, -0.01518861f, 0.00604908f, -0.01788687f, 0.03380610f, 0.21894649f, 
    0.06770861f, -0.04985447f, 0.09553864f, -0.00583692f, -0.20624875f, 0.08894739f, -0.15149809f, 0.11265253f, 
    -0.00235326f, -0.00836872f, -0.02781417f, -0.04397765f, 0.51880032f, -0.30460984f, -0.01541957f, -0.42550674f, 
    -0.06068445f, -0.00631024f, -0.18993966f, 0.01651867f, 0.03418553f, -0.04357066f, 0.01718102f, -0.12209355f, 
    0.15314007f, 0.10568324f, -0.24520004f, -0.11458418f, 0.05317971f, -0.00648919f, -0.00835530f, 0.03405572f, 
    0.03381754f, 0.07650915f, -0.27672383f, -0.02549334f, -0.03104310f, -0.03051334f, 0.10322161f, -0.27251643f, 
    0.01794285f, -0.09147939f, -0.03207498f, 0.00092284f, 0.04116949f, -0.04552934f, 0.08698118f, -0.13739380f, 
    -0.25442177f, -0.28260526f, -0.20244785f, 0.19353236f, -0.00437511f, -0.09026132f, -0.06894882f, 0.10259409f, 
    -0.02629901f, 0.02440698f, -0.02778331f, -0.02367985f, 0.07679944f, -0.06296376f, 0.07529066f, -0.09765456f, 
    -0.02762026f, -0.05825897f, -0.00475672f, 0.07996876f, 0.04941533f, -0.01490047f, 0.05257348f, -0.00792952f, 
    0.14722873f, 0.35299885f, -0.09677445f, 0.44883320f, -0.00408576f, -0.13989279f, 0.06627870f, -0.05751260f, 
    -0.08637959f, -0.02502380f, 0.02090021f, -0.07325279f, 0.19146411f, -0.33030918f, -0.10515811f, -0.05218013f, 
    0.00061362f, -0.33267015f, 0.06614604f, 0.15148428f, 0.02259404f, 0.02999095f, -0.04512872f, -0.05590148f, 
    -0.52545118f, -0.30329067f, -0.32082489f, 0.28264308f, -0.02398978f, -0.00735766f, 0.08684653f, 0.03953936f, 
    -0.07732407f, -0.00992806f, 0.00452986f, 0.01884689f, -0.04589985f, 0.11911163f, 0.09868439f, -0.08642751f, 
    -0.01977984f, -0.06292088f, -0.03492669f, 0.03982506f, 0.04903824f, -0.00452686f, 0.00930606f, -0.01228242f, 
    -0.03347533f, 0.11696307f, 0.06720610f, 0.10752218f, -0.01236040f, -0.06684113f, 0.03191516f, 0.04462419f, 
    -0.03063527f, 0.03835241f, 0.02956718f, 0.03338259f, -0.10670184f, -0.39284277f, 0.33194783f, -0.21913826f, 
    0.04634588f, 0.12594545f, -0.16009872f, 0.02724837f, 0.01805350f, 0.01870268f, 0.06593560f, -0.04366111f, 
    0.00438995f, -0.33080709f, -0.15957107f, 0.30057937f, -0.08159207f, 0.06726404f, -0.05774016f, -0.10971055f, 
    -0.04037822f, -0.01609381f, 0.02112642f, -0.07891246f, -0.28707752f, -0.25967547f, 0.04401403f, -0.11361822f, 
    0.00741465f, 0.11616714f, 0.02852307f, -0.03369580f, 0.09399221f, -0.00284242f, 0.04151304f, -0.05160166f, 
    -0.02892953f, 0.09150733f, 0.02379808f, 0.04363741f, 0.01019340f, -0.05202305f, 0.15289697f, -0.13595057f, 
    -0.11919324f, 0.06378482f, -0.02433269f, 0.04447598f, 0.25199968f, 0.00916078f, -0.13978386f, -0.10268527f, 
    -0.01949466f, 0.17704940f, -0.04759440f, 0.00939573f, 0.07088973f, 0.02406400f, 0.05170594f, -0.09933108f, 
    -0.10478552f, 0.04507271f, -0.04832981f, 0.02474678f, 0.03372688f, -0.08600620f, 0.01971183f, -0.07096542f, 
    0.06718939f, -0.05781173f, 0.02125330f, -0.07216183f, -0.20665589f, 0.08788758f, -0.06710596f, 0.31932208f, 
    0.01091578f, 0.10478352f, 0.08400971f, 0.00461770f, -0.06500212f, -0.04483650f, 0.07777478f, -0.01550503f, 
    0.05440943f, 0.06493941f, 0.17989519f, 0.09630006f, 0.03556240f, -0.05030603f, -0.01469281f, -0.02063775f, 
    0.03664704f, 0.07608986f, 0.10699326f, 0.05653746f, 0.01041543f, -0.04161423f, 0.00711966f, -0.14647466f, 
    0.01881594f, -0.10538816f, -0.06901706f, -0.03233518f, 0.04539425f, 0.05397407f, 0.01544100f, -0.03087672f, 
    -0.12227383f, 0.17310590f, 0.32505655f, 0.03115856f, -0.04196728f, 0.04634865f, 0.03862401f, 0.09926677f, 
    0.05167519f, -0.23179939f, 0.08854201f, 0.01374813f, -0.04655301f, -0.03569059f, -0.12093705f, 0.08192482f, 
    0.02447118f, -0.02384249f, 0.01494133f, -0.04211371f, 0.07384207f, 0.03713784f, -0.05191524f, -0.08212543f, 
    -0.23735370f, -0.23127198f, 0.00090529f, 0.24903551f, 0.14316480f, 0.03660356f, 0.16083837f, 0.13517429f, 
    -0.00748008f, -0.06229237f, -0.01195185f, -0.03424142f, 0.27874658f, -0.15499204f, 0.10259696f, -0.11922003f, 
    -0.01843850f, 0.01859336f, -0.12396258f, -0.07367585f, -0.11768474f, 0.01365137f, -0.14656912f, 0.06013482f, 
    -0.07651109f, -0.01821511f, -0.02646672f, 0.02482581f, 0.00616637f, -0.00968033f, -0.03152680f, 0.03018274f, 
    -0.04049108f, -0.00001062f, 0.04540372f, 0.01098684f, 0.15425746f, 0.29668790f, 0.01458205f, 0.15466207f, 
    0.09676278f, 0.01248215f, 0.05053923f, -0.02621170f, 0.01755832f, -0.04140077f, 0.07709838f, -0.03008720f, 
    -0.08941390f, 0.10627291f, 0.03985308f, -0.07905122f, -0.03087134f, 0.19337039f, 0.03791391f, 0.15168023f, 
    -0.10843483f, 0.12485167f, 0.03580382f, 0.06101120f, -0.16065943f, 0.20892182f, -0.03685440f, -0.05537891f, 
    -0.04728792f, -0.10011455f, 0.01678392f, 0.07483096f, -0.07059924f, 0.03778097f, 0.09104621f, 0.01243719f, 
    -0.05830188f, 0.00924864f, -0.00868217f, -0.09304829f, 0.01929203f, 0.00062497f, -0.01880365f, -0.00772265f, 
    0.02085280f, 0.04744463f, 0.01585801f, -0.08030824f, -0.04183327f, -0.11488924f, 0.11653558f, 0.02854394f, 
    0.01522888f, -0.03898882f, 0.07161270f, -0.08775911f, -0.02786016f, -0.10745682f, 0.07363397f, 0.13187793f, 
    -0.24871466f, -0.35549933f, 0.06241808f, 0.37868270f, 0.00948193f, 0.01891395f, -0.01187896f, 0.01709370f, 
    0.04237242f, 0.03177349f, 0.01124141f, -0.04108308f, -0.13674946f, -0.26792625f, -0.32747471f, 0.06135536f, 
    -0.05824944f, 0.04656617f, -0.10771435f, -0.01521935f, 0.03766615f, 0.10336065f, 0.00650308f, 0.01270929f, 
    0.18477131f, -0.04328882f, 0.01043083f, -0.14390336f, -0.10431409f, -0.00765639f, -0.26529479f, -0.02257332f, 
    0.06414424f, 0.01924888f, 0.06253958f, -0.09105349f, -0.08597480f, 0.22182392f, 0.08370120f, 0.12421647f, 
    -0.00369455f, -0.05401965f, 0.04427706f, -0.00018209f, -0.04624183f, -0.01937023f, 0.03278234f, 0.00263516f, 
    -0.14100626f, 0.21051398f, -0.09955616f, -0.10192376f, -0.04999970f, -0.06036123f, 0.01670870f, -0.04690129f, 
    -0.00788717f, 0.04713129f, -0.00469275f, -0.16755682f, 0.30064380f, -0.24156681f, 0.05654112f, -0.31350955f, 
    0.00738881f, -0.01574489f, 0.12216904f, 0.06441905f, -0.00077606f, -0.02665340f, 0.01974625f, -0.13273787f, 
    -0.47417995f, -0.22056690f, 0.18323508f, 0.12169481f, -0.05691571f, 0.09628879f, -0.02408591f, -0.01971940f, 
    0.04291927f, 0.02419841f, 0.01364151f, -0.09927958f, 0.13092457f, -0.20792300f, 0.02622786f, -0.09401837f, 
    -0.19388174f, 0.04424360f, -0.04892389f, -0.05649221f, -0.04455192f, 0.02373607f, 0.00762875f, -0.11045524f, 
    -0.20186222f, -0.27937064f, -0.03034563f, -0.14069706f, 0.18225189f, 0.04425878f, 0.03348567f, 0.12751096f, 
    0.01275040f, -0.05329216f, -0.02202463f, -0.04143426f, -0.03595283f, 0.11570454f, 0.00292734f, 0.10326862f, 
    -0.05697363f, 0.00313674f, 0.15393466f, 0.00220384f, -0.01673643f, 0.00357781f, 0.05129688f, -0.09499673f, 
    -0.06561372f, -0.29613766f, -0.22347187f, -0.16760446f, 0.05383215f, 0.07123066f, -0.04356926f, 0.11304785f, 
    0.04361757f, -0.02973344f, -0.02904113f, 0.01756956f, 0.28818777f, -0.44005352f, -0.47150198f, -0.53265756f, 
    -0.02743746f, 0.01526452f, -0.14337941f, 0.10184386f, 0.12642691f, 0.01080286f, 0.01908771f, 0.00813667f, 
    0.04789966f, 0.09046453f, -0.00166249f, -0.00451650f, -0.03279877f, -0.03782486f, 0.01020590f, 0.02254451f, 
    0.02933311f, -0.02016780f, -0.10740179f, -0.08036361f, 0.07580090f, -0.04650823f, -0.03688516f, -0.06119232f, 
    -0.18116111f, 0.02496473f, -0.05433613f, -0.06740637f, 0.05150773f, 0.05776126f, 0.06254366f, 0.05795472f, 
    0.32361013f, -0.22867863f, 0.02195387f, 0.02354776f, -0.03294429f, 0.10568013f, 0.02648993f, -0.23212005f, 
    -0.03517239f, 0.03239013f, 0.00173304f, -0.04231337f, -0.30359203f, 0.19449998f, -0.23519379f, 0.29147446f, 
    -0.01854766f, 0.02491407f, 0.04975089f, 0.04242608f, 0.02636181f, -0.08096087f, 0.01126362f, -0.04594133f, 
    0.34503180f, -0.08211426f, -0.06989894f, -0.23214982f, 0.01146585f, -0.01773575f, -0.05572085f, -0.02063718f, 
    0.09538232f, -0.05538129f, -0.08425647f, -0.14587353f, -0.16044635f, 0.02736007f, 0.04814733f, 0.24749623f, 
    0.14810470f, -0.14953390f, -0.03222213f, 0.09392936f, 0.01027564f, -0.11645337f, -0.06684370f, -0.01271918f, 
    0.06959049f, -0.04162169f, -0.03535276f, -0.10094154f, 0.02502896f, 0.06370716f, 0.00539761f, -0.00350757f, 
    0.06308574f, 0.05521408f, -0.11940655f, -0.16251844f, -0.54220611f, -0.38809150f, -0.22410595f, -0.01624359f, 
    -0.11416174f, -0.06473887f, 0.08182871f, -0.02228201f, -0.12125737f, 0.06318744f, 0.06014165f, -0.06604292f, 
    0.08956786f, -0.52055877f, 0.29075715f, -0.28883350f, -0.05054039f, -0.00638034f, -0.15689787f, 0.08728807f, 
    -0.03221217f, -0.00312002f, -0.00660222f, -0.04676109f, 0.05489881f, -0.34542021f, -0.09844962f, 0.19146830f, 
    -0.13009167f, 0.02184053f, -0.03850394f, -0.02821656f, -0.04247124f, -0.04913254f, -0.04083621f, 0.02686831f, 
    -0.06721638f, -0.07265207f, 0.01665882f, -0.05466856f, 0.08409083f, 0.16561554f, -0.01140490f, -0.07214297f, 
    0.22298980f, -0.10728236f, 0.05611065f, -0.06044090f, 0.00098438f, 0.08459319f, -0.03925885f, 0.00566270f, 
    0.09051528f, 0.00682493f, 0.01514978f, 0.08918787f, 0.03512375f, 0.08309359f, 0.04360669f, 0.10357499f, 
    -0.21097271f, 0.10964799f, 0.03759349f, -0.04263987f, -0.07677662f, -0.04834054f, -0.02582840f, 0.01448544f, 
    -0.07938597f, -0.02532665f, 0.07758363f, 0.04408539f, 0.12611747f, -0.03272653f, -0.46624458f, -0.34719029f, 
    -0.23429652f, 0.01457702f, 0.04854995f, -0.03147755f, 0.02319708f, -0.14861286f, -0.01783478f, 0.00295303f, 
    0.03470780f, 0.11810309f, -0.07107317f, 0.02180842f, -0.00666169f, -0.00112351f, 0.04153624f, -0.05906116f, 
    0.14248507f, 0.08438087f, 0.05063637f, 0.09733679f, 0.25867388f, 0.15261465f, -0.15368167f, -0.28983119f, 
    0.01909462f, 0.06742799f, 0.07869402f, 0.12388647f, 0.05808469f, 0.01133249f, 0.01138475f, 0.08059503f, 
    0.19880809f, 0.05605115f, 0.01874913f, 0.11014409f, -0.00425816f, -0.07404457f, 0.13988745f, 0.07503423f, 
    0.06757162f, 0.03735945f, 0.07475650f, 0.03238288f, 0.28084302f, -0.12601654f, -0.16402504f, -0.09120376f, 
    0.24891861f, -0.09026308f, -0.07402568f, 0.07047796f, 0.01339007f, 0.02992087f, 0.03767229f, -0.01186940f, 
    0.12178543f, -0.14367822f, -0.00949793f, -0.08262455f, -0.00145383f, 0.04211759f, 0.13128898f, 0.14183755f, 
    0.15274058f, -0.02262136f, 0.09598051f, 0.06135356f, -0.27511483f, -0.23669083f, -0.11752814f, -0.00616596f, 
    0.08711081f, 0.09520297f, 0.04270121f, 0.10222846f, -0.08658469f, -0.07258353f, -0.18566465f, -0.16938107f, 
    -0.19535080f, -0.03573080f, 0.01849115f, 0.10137001f, 0.05488790f, 0.06440429f, -0.06193928f, 0.10695562f, 
    -0.13136001f, 0.00173356f, -0.17603986f, -0.03537434f, -0.10779062f, 0.02340061f, 0.04965337f, 0.02331718f, 
    0.01881633f, -0.05197993f, 0.00958634f, 0.00140854f, -0.24905841f, 0.06762186f, -0.24535109f, -0.58398479f, 
    -0.00289545f, -0.02476141f, -0.11051296f, 0.01040978f, 0.04241153f, -0.11706912f, 0.07342795f, -0.01266399f, 
    0.04699711f, 0.01177315f, 0.15881024f, 0.13885488f, 0.04904254f, -0.04865007f, -0.23024128f, -0.24300809f, 
    0.04627884f, -0.02637206f, 0.00020441f, 0.01094352f, 0.00675605f, 0.08916160f, 0.08251574f, -0.00774196f, 
    0.24728510f, 0.01506110f, 0.03044821f, -0.31901595f, -0.05078411f, -0.10773319f, -0.03522955f, -0.05334913f, 
    -0.04318801f, -0.04724359f, 0.07925470f, 0.05472358f, -0.27478114f, 0.13217677f, -0.01633827f, 0.10248405f, 
    -0.04754917f, -0.04240306f, -0.02079620f, 0.02004641f, 0.08310554f, 0.04148403f, -0.06269260f, 0.07336113f, 
    0.00928986f, -0.23311964f, -0.27052042f, -0.10395180f, -0.10160115f, -0.01630219f, 0.01016993f, 0.08432336f, 
    -0.05727089f, 0.05997995f, 0.00162513f, 0.05160385f, -0.12766312f, 0.17502342f, 0.14713085f, 0.12595429f, 
    0.05938515f, -0.07728864f, -0.09822401f, -0.19879173f, 0.07919972f, -0.04199759f, -0.02598936f, -0.02182313f, 
    0.25581658f, -0.25314957f, -0.03850495f, -0.03783838f, -0.18158787f, 0.05365244f, 0.22706331f, 0.11730088f, 
    0.01262871f, 0.17045943f, 0.15587239f, -0.03887362f, -0.07492425f, -0.00384587f, -0.33594492f, -0.15205689f, 
    -0.03646944f, -0.02468342f, 0.10619060f, -0.04966105f, 0.05634061f, -0.06502073f, -0.01355718f, -0.00576831f, 
    -0.66280836f, 0.18797016f, 0.18218702f, 0.11830679f, 0.03338495f, 0.11806597f, -0.04482205f, -0.06564590f, 
    -0.21877807f, -0.03262586f, 0.18326887f, 0.09721412f, -0.24348547f, 0.08439865f, 0.08876570f, 0.08538531f, 
    -0.12232970f, -0.10487026f, 0.04763111f, -0.03880075f, -0.00188636f, -0.00934044f, -0.04163080f, 0.02463263f, 
    -0.19466682f, -0.11425149f, 0.08850890f, -0.06728424f, -0.07606671f, -0.07197966f, -0.07975852f, 0.03617944f, 
    -0.20469095f, -0.16088776f, -0.14281976f, -0.07830964f, 0.37658277f, -0.11593395f, -0.23406737f, -0.06652388f, 
    -0.02405996f, 0.09225622f, 0.06051514f, 0.01511900f, -0.01820931f, -0.03391136f, 0.11205845f, -0.04940090f, 
    0.24382454f, -0.51155972f, -0.28481293f, -0.31273016f, 0.26782173f, -0.00411845f, 0.20035286f, 0.08024045f, 
    0.02241971f, 0.05189393f, 0.03448536f, 0.04054783f, 0.26567161f, -0.12278394f, -0.11976212f, -0.10703098f, 
    -0.03032089f, 0.00093231f, 0.02723432f, 0.02100118f, -0.13381480f, -0.25928307f, -0.04738305f, -0.28414378f, 
    -0.26168939f, -0.07828308f, 0.09336121f, 0.03606515f, -0.07792493f, 0.17658389f, -0.04959736f, -0.08594014f, 
    -0.04767388f, -0.08500540f, -0.04759945f, 0.13185827f, -0.06830794f, 0.02714631f, -0.19894953f, 0.13874470f, 
    0.08317434f, -0.03952496f, 0.02796300f, 0.05202404f, 0.10983654f, 0.06010114f, -0.07436769f, 0.02066292f, 
    -0.04366137f, -0.00299322f, 0.01197147f, 0.00973829f, -0.06000400f, 0.04285415f, 0.05827310f, 0.00270792f, 
    -0.00419277f, 0.15425627f, -0.13559133f, 0.05676404f, -0.48699450f, -0.03754816f, 0.31652510f, 0.28620926f, 
    -0.12897541f, -0.02828711f, -0.10910704f, -0.11407345f, 0.08621809f, 0.09825009f, 0.00011887f, 0.08790378f, 
    -0.08863719f, -0.04233839f, 0.03773753f, 0.12896624f, -0.01855025f, -0.02900452f, -0.04708117f, -0.01642638f, 
    -0.13438821f, -0.05752816f, -0.17755915f, -0.12826762f, -0.14351663f, 0.11296399f, 0.10575358f, 0.05000545f, 
    -0.00198734f, -0.07877652f, -0.06073416f, -0.11121301f, -0.07016035f, -0.00696503f, -0.04454184f, 0.01339268f, 
    -0.26152056f, -0.17499897f, 0.14800175f, 0.10336713f, -0.06199645f, 0.03781002f, -0.08331591f, 0.06543703f, 
    -0.04840780f, 0.21545246f, -0.09985951f, 0.24797077f, -0.13120972f, -0.08159100f, 0.06069256f, -0.03761850f, 
    -0.02767921f, -0.01582540f, -0.00979137f, -0.01095087f, -0.04747830f, 0.06844000f, -0.04995005f, 0.00788091f, 
    -0.02283166f, -0.31134504f, -0.24658614f, 0.00312659f, -0.13336402f, 0.05888342f, -0.01833136f, -0.00065930f, 
    -0.05138326f, 0.02065326f, 0.00201676f, 0.02446331f, 0.42329183f, 0.20408289f, -0.02074133f, -0.29123688f, 
    0.02554832f, 0.00636802f, -0.01936051f, -0.17488913f, 0.02278922f, 0.01153202f, -0.01963573f, -0.15076512f, 
    -0.13579166f, -0.05092081f, 0.03085728f, -0.02676400f, -0.01675379f, 0.00837416f, 0.00691624f, 0.00241946f, 
    -0.01109962f, 0.01379187f, 0.11130974f, 0.04001210f, -0.70312363f, 0.02838974f, 0.21015868f, 0.02473311f, 
    -0.07444323f, -0.15189868f, -0.09248100f, -0.07015313f, 0.00895002f, 0.07144028f, -0.03046237f, 0.01203270f, 
    0.14331086f, 0.02870478f, -0.04368165f, -0.33407775f, -0.28449062f, -0.15649115f, 0.06561360f, -0.01904483f, 
    0.14840664f, 0.03724596f, -0.03007081f, 0.05120752f, -0.27347293f, 0.05220282f, 0.00490169f, 0.13490891f, 
    -0.03021177f, 0.11937624f, -0.00174500f, -0.08537956f, -0.01457333f, -0.06597381f, -0.10516068f, -0.04492358f, 
    -0.09144014f, 0.05407561f, 0.08181531f, -0.17357078f, 0.02947909f, -0.04365254f, -0.00454494f, -0.01215276f, 
    -0.08526250f, -0.08293311f, -0.10481638f, -0.05106115f, -0.17234132f, 0.07459053f, 0.19273543f, -0.05843209f, 
    -0.06870607f, -0.00827489f, -0.02142861f, -0.08076112f, -0.00685469f, 0.09248075f, -0.03439195f, 0.06891592f, 
    0.06648623f, 0.01252829f, -0.13055378f, -0.12029131f, 0.08790677f, 0.01420612f, -0.09457441f, -0.02605658f, 
    0.02033849f, -0.00051549f, 0.03912738f, 0.06166655f, -0.08915568f, -0.28423101f, -0.03031926f, -0.09212431f, 
    0.14961392f, 0.14835429f, 0.06983908f, 0.14162709f, -0.07053373f, -0.02225517f, -0.05472768f, -0.50709361f, 
    -0.04484506f, 0.03260275f, -0.09704848f, -0.06826246f, 0.09184190f, -0.03832391f, 0.02961144f, 0.10723165f, 
    0.04114038f, 0.04070562f, -0.00360181f, 0.10371419f, -0.59548444f, 0.00472797f, 0.16411173f, 0.21375509f, 
    -0.15029259f, -0.02984269f, -0.02401418f, -0.04969889f, -0.03318360f, -0.20795941f, -0.04454171f, -0.00677985f, 
    -0.29461038f, 0.04890157f, 0.15672059f, 0.16370063f, -0.02629010f, 0.00172679f, -0.01243131f, 0.09586480f, 
    -0.04161781f, -0.00494505f, 0.02223261f, 0.23308343f, -0.05179053f, -0.18722565f, -0.04905398f, -0.20203654f, 
    -0.01671121f, 0.02186832f, 0.02978891f, -0.04210656f, -0.01548676f, 0.07957824f, 0.19579560f, 0.24134266f, 
    0.54064173f, -0.11429092f, 0.16174269f, -0.17954807f, 0.20957471f, -0.11275962f, -0.07508370f, 0.10742701f, 
    -0.00724794f, 0.04961836f, -0.01315174f, -0.05846078f, 0.15916406f, 0.07064337f, -0.01491801f, 0.00978424f, 
    0.11950605f, -0.11042321f, 0.05575576f, 0.10221271f, 0.09389539f, -0.04504198f, 0.13475330f, 0.16840544f, 
    0.02126379f, -0.35106590f, -0.36481211f, -0.19182025f, -0.19118795f, -0.07673400f, -0.04770378f, -0.27513376f, 
    -0.06920790f, 0.00938111f, -0.00312926f, 0.01048373f, -0.33330426f, -0.07108416f, 0.07477190f, 0.12764581f, 
    0.01121703f, 0.10810241f, -0.07352147f, 0.01817475f, -0.25786039f, 0.10732019f, -0.14607142f, -0.28982699f, 
    0.03707044f, -0.24092989f, -0.34061047f, 0.15256365f, 0.11619209f, 0.25252292f, 0.13310686f, 0.13058820f, 
    0.00558556f, -0.08276425f, -0.01465804f, -0.09684987f, -0.22428335f, -0.33883187f, -0.37716904f, 0.32283324f, 
    0.07350074f, 0.08313544f, 0.11465488f, 0.04291039f, -0.02315773f, 0.11932569f, 0.08603255f, 0.05551254f, 
    -0.22819427f, 0.00868420f, -0.00526774f, -0.09313527f, -0.09045420f, -0.00203707f, 0.00227691f, -0.05040369f, 
    -0.02565333f, 0.01869410f, -0.01819772f, 0.11431988f, -0.24502212f, -0.27555886f, -0.17671746f, 0.00636316f, 
    0.15646152f, 0.04018391f, 0.10093437f, 0.06834026f, -0.01793997f, -0.02870660f, 0.04608390f, -0.00203074f, 
    0.37845692f, 0.08137224f, -0.05098635f, -0.10574524f, 0.08647305f, 0.00886781f, 0.11499153f, -0.15912379f, 
    0.07145187f, 0.07720294f, 0.08114558f, 0.09038171f, -0.05529359f, -0.19073626f, -0.44301128f, -0.25394681f, 
    0.04873899f, 0.04697943f, 0.04053419f, 0.04820447f, -0.05407093f, 0.12006290f, -0.00907029f, -0.20812626f, 
    -0.12198950f, -0.12325728f, -0.19436432f, -0.13326892f, -0.02189484f, 0.07330837f, 0.03549706f, 0.07994243f, 
    0.11241036f, 0.12511709f, 0.08906902f, -0.11381030f, 0.04409810f, -0.17276381f, -0.20122471f, -0.24098454f, 
    -0.30819568f, -0.25562185f, -0.22377761f, -0.26833567f, 0.05010680f, 0.03155074f, -0.01119253f, 0.02665826f, 
    -0.04360402f, -0.13467708f, -0.09943599f, -0.21197018f, -0.00426542f, -0.08033200f, 0.04690227f, -0.01859194f, 
    0.12055465f, 0.11856032f, 0.03189420f, 0.06793171f, -0.27464917f, -0.55823582f, -0.22619493f, -0.08071111f, 
    0.10487369f, 0.11016525f, 0.04969849f, 0.13671166f, -0.02912101f, -0.15956092f, -0.13080259f, -0.01515205f, 
    0.32259813f, 0.46791175f, 0.00081875f, -0.23404853f, 0.04947852f, -0.00376817f, -0.14460854f, -0.03447358f, 
    0.04034166f, -0.00772274f, -0.01075062f, 0.05300094f, -0.11997698f, -0.53345394f, -0.37588677f, -0.19987081f, 
    0.18362880f, 0.08094677f, 0.04900461f, 0.12817490f, 0.05238964f, 0.15407827f, 0.05829205f, 0.13284668f, 
    -0.23473045f, -0.22958308f, -0.08461622f, -0.13113381f, 0.11183834f, -0.16363241f, -0.00281377f, 0.11916628f, 
    -0.14854397f, -0.06128241f, 0.01292794f, -0.24158262f, -0.09332476f, 0.01750170f, -0.17649548f, 0.01815705f, 
    0.01202490f, 0.07618621f, 0.02314810f, 0.08842671f, 0.01564484f, -0.09985366f, -0.07725568f, -0.07313620f, 
    -0.14413199f, -0.11472616f, -0.22796303f, -0.00302714f, -0.08414519f, 0.20817135f, 0.10344236f, 0.14950252f, 
    0.08722346f, 0.04459746f, 0.05881311f, -0.06700583f, -0.30438787f, -0.16955328f, 0.17870781f, 0.14384271f, 
    0.11449544f, -0.00844020f, -0.23985124f, 0.16155635f, 0.06174554f, -0.14122987f, -0.04184565f, 0.09296849f, 
    0.14471368f, -0.11524979f, -0.02279840f, -0.08146478f, 0.16489342f, -0.03399231f, -0.28661418f, 0.25876686f, 
    -0.04399241f, -0.08514462f, -0.05162204f, -0.16596276f, -0.18888021f, -0.09054457f, 0.14755514f, 0.31986478f, 
    0.05131402f, 0.21046013f, -0.15828204f, -0.10140322f, 0.10037119f, -0.04531870f, 0.07329367f, -0.03716925f, 
    -0.29388070f, 0.00439280f, -0.50496316f, 0.24448745f, 0.13713180f, -0.14854042f, 0.14847399f, -0.06009769f, 
    -0.05191186f, -0.07648343f, -0.07890711f, -0.09792895f, 0.20257837f, -0.44298670f, -0.01860268f, -0.00838289f, 
    0.14253356f, -0.21864849f, -0.09137542f, 0.14307800f, 0.05667192f, 0.01252888f, -0.05939823f, 0.00546538f, 
    -0.12930079f, 0.13482441f, -0.10830722f, 0.06361444f, 0.02184324f, 0.00416295f, -0.03752473f, 0.05774043f, 
    -0.00573568f, -0.07782516f, 0.05888960f, 0.04236397f, 0.13776013f, 0.15485020f, 0.09221800f, 0.16778775f, 
    -0.09155126f, -0.14057405f, -0.13223660f, -0.19332714f, 0.06731939f, -0.04711182f, 0.04187408f, 0.19299316f, 
    -0.13376504f, 0.21007502f, -0.08295500f, -0.00402880f, 0.02227075f, -0.17175451f, 0.10925306f, 0.16538906f, 
    0.11455024f, 0.11944156f, -0.04584674f, 0.09962851f, -0.01481763f, -0.05946605f, -0.10818905f, 0.03749754f, 
    0.04343737f, 0.04298917f, -0.01193618f, -0.02940420f, 0.10931876f, 0.05670825f, 0.11795889f, 0.25264910f, 
    0.08963276f, -0.09551470f, 0.20358494f, -0.13327383f, -0.03175953f, 0.03081273f, -0.13308071f, -0.06190856f, 
    -0.05936353f, -0.03468437f, -0.02852402f, -0.00742852f, -0.19774929f, 0.07988553f, 0.38648984f, 0.28031865f, 
    -0.05442459f, -0.07691730f, -0.27848148f, -0.30052906f, 0.15038136f, -0.09009229f, -0.15449837f, 0.01518240f, 
    -0.15877582f, 0.07829818f, 0.03923897f, 0.48383489f, 0.08937487f, -0.08858194f, -0.02685214f, 0.09724184f, 
    0.01966615f, -0.09607963f, -0.00273370f, 0.15170570f, 0.07536453f, -0.35902414f, -0.28212216f, -0.00883958f, 
    -0.02012073f, -0.06508805f, 0.14706238f, 0.01272680f, -0.00073867f, -0.05752219f, -0.03319587f, -0.04536965f, 
    -0.38410208f, 0.02006265f, -0.05306936f, -0.12623735f, 0.03064081f, -0.01391511f, -0.08311575f, 0.14611198f, 
    0.01861148f, -0.10363192f, 0.03518106f, -0.10791641f, 0.02958363f, -0.47913611f, -0.13614039f, -0.04571768f, 
    0.24633285f, 0.10738634f, 0.04136062f, 0.05117033f, -0.07825562f, -0.12097402f, -0.04523654f, -0.07800461f, 
    -0.37467203f, 0.11511020f, 0.26945913f, -0.03867192f, 0.15955469f, 0.00199266f, -0.25020412f, -0.24156295f, 
    -0.04905270f, 0.04960772f, -0.00877780f, -0.02811445f, -0.44148260f, 0.11812853f, -0.14540774f, -0.12351387f, 
    -0.02506871f, -0.21915856f, 0.02722944f, 0.14292157f, 0.03124417f, 0.07050253f, 0.06349402f, 0.04692737f, 
    -0.47743294f, 0.39864486f, 0.25782818f, -0.86369640f, 0.12473576f, -0.13826717f, 0.18540445f, -0.24149811f, 
    -0.00755676f, 0.09555618f, 0.12354327f, -0.02611180f, 0.14998686f, -0.30571920f, -0.02311319f, 0.00740039f, 
    0.07922250f, 0.16355707f, 0.07822905f, 0.21400467f, 0.00354201f, -0.00247625f, -0.03114652f, -0.03575422f, 
    -0.13044025f, 0.01775421f, 0.08036926f, -0.25950199f, 0.11880866f, -0.11984591f, 0.02614377f, 0.16766968f, 
    0.12882943f, 0.11428510f, -0.10039703f, 0.00541698f, -0.00645631f, -0.18312104f, 0.34792840f, -0.28567186f, 
    -0.05711355f, -0.13100164f, -0.03082894f, -0.07549085f, -0.19175041f, 0.10986354f, -0.04614826f, 0.02067513f, 
    0.10712626f, 0.10809859f, 0.16201839f, 0.07626156f, 0.03589691f, -0.28635278f, -0.03329730f, 0.12258544f, 
    -0.05365765f, 0.06918044f, 0.06029241f, 0.00904352f, 0.11452167f, 0.07841322f, 0.38505152f, 0.03785913f, 
    -0.08928814f, -0.02758433f, -0.12498805f, -0.04714293f, 0.00416602f, 0.07967456f, 0.02850950f, 0.09350454f, 
    -0.15937781f, -0.29519907f, 0.03323092f, -0.52425826f, 0.18791135f, 0.03888700f, 0.01598421f, 0.07461346f, 
    0.00720774f, -0.06198493f, -0.17275916f, -0.06010469f, -0.33203781f, 0.15095550f, -0.32932362f, -0.14844580f, 
    -0.20154533f, 0.14932069f, -0.11885096f, 0.01976149f, 0.11955442f, 0.03562922f, -0.23721713f, 0.05407024f, 
    -0.22620988f, -0.04574927f, 0.06562135f, -0.10926455f, 0.09872144f, -0.02830482f, -0.00906313f, -0.16029565f, 
    0.12972371f, 0.00930458f, -0.03686088f, -0.06510850f, -0.04281591f, -0.01910383f, -0.09289294f, -0.11702973f, 
    0.03148168f, -0.08272703f, 0.06463911f, 0.03167389f, 0.01386545f, 0.14928924f, 0.05695528f, -0.12096049f, 
    0.07888734f, -0.09659926f, 0.15904395f, -0.20221612f, 0.04169360f, -0.01554137f, 0.02526141f, 0.05326934f, 
    -0.06369325f, 0.04466093f, 0.18815359f, 0.14114556f, 0.15320346f, -0.33682707f, -0.09718155f, -0.05497566f, 
    0.15913582f, 0.17633705f, 0.07424588f, 0.03403760f, -0.04029946f, -0.05337792f, -0.07216303f, -0.01733305f, 
    0.06754760f, 0.02323027f, 0.09217331f, -0.52107579f, 0.02176814f, -0.14299838f, 0.00241742f, 0.01163208f, 
    0.13635111f, 0.06744328f, -0.05651598f, 0.04696021f, -0.16218625f, 0.11831506f, -0.06500027f, 0.01763042f, 
    0.09557921f, -0.14749537f, 0.06624585f, -0.05885233f, 0.07244003f, 0.08451844f, 0.08340620f, 0.21542311f, 
    0.10988935f, 0.30405080f, 0.12290446f, -0.16350560f, -0.06241591f, -0.15979260f, 0.15394212f, 0.21970062f, 
    0.04099674f, 0.03879358f, 0.02539966f, -0.02367878f, -0.55949855f, -0.08960488f, -0.01292173f, 0.17791061f, 
    -0.01619927f, 0.11253657f, -0.06347535f, -0.29338884f, 0.17758921f, 0.00696366f, -0.09418549f, -0.00248812f, 
    0.17759129f, 0.34327170f, -0.03212777f, -0.18081701f, 0.06886313f, 0.02624183f, 0.04358095f, 0.05692747f, 
    0.26068538f, -0.05895626f, -0.04084903f, 0.01244870f, -0.14216998f, -0.05574590f, -0.06307317f, 0.06318461f, 
    0.00322207f, -0.09471768f, 0.07956918f, 0.06489096f, 0.01876843f, -0.04118615f, 0.00776993f, -0.08739424f, 
    0.04026049f, -0.27570611f, 0.23112842f, -0.25168628f, -0.05256080f, 0.16066352f, -0.34623230f, 0.02814816f, 
    -0.12157635f, 0.00726794f, -0.05015156f, -0.02158748f, -0.13138078f, 0.16796067f, -0.17350492f, -0.04045117f, 
    -0.08752897f, 0.00473198f, 0.04973656f, 0.16985585f, -0.05666879f, 0.04048463f, -0.06025631f, -0.05192843f, 
    0.01747593f, -0.11460053f, -0.05979703f, 0.05760926f, 0.15171492f, 0.06070368f, 0.06980911f, -0.07633963f, 
    0.07273535f, -0.05103545f, 0.03708145f, -0.01687862f, 0.11663494f, -0.32151198f, -0.00552321f, -0.29539999f, 
    0.10624313f, -0.01538722f, -0.00311163f, -0.15270723f, 0.03786348f, -0.09434181f, -0.12920515f, -0.11889076f, 
    -0.03898323f, -0.34032509f, -0.01530037f, -0.17855835f, 0.13617285f, -0.16159791f, -0.02990910f, 0.04082367f, 
    0.01149529f, -0.02483935f, -0.04830702f, 0.00270284f, -0.33220899f, 0.34311619f, -0.20695189f, -0.28752136f, 
    -0.21375032f, -0.00549626f, -0.06497709f, -0.09833705f, 0.05671790f, -0.00003389f, 0.05680878f, 0.07894534f, 
    0.07198812f, 0.05410177f, -0.00289277f, 0.11667741f, -0.07324591f, 0.07971571f, -0.09102725f, 0.03844108f, 
    0.16739358f, -0.14924657f, -0.00585393f, 0.18462412f, -0.01972404f, -0.03271149f, 0.01553283f, -0.19119799f, 
    0.07474306f, -0.03585927f, 0.07917161f, 0.12663171f, 0.00356364f, -0.00970445f, -0.18375854f, 0.03294764f, 
    -0.32869151f, 0.05806166f, -0.34249017f, -0.12377024f, 0.05377056f, -0.13942938f, 0.01555450f, 0.00194347f, 
    -0.06215044f, -0.18298718f, -0.07971546f, -0.08059317f, 0.20458736f, -0.07509787f, 0.28698176f, -0.01187737f, 
    0.11588572f, -0.15233997f, -0.04716375f, -0.04546673f, -0.07853691f, 0.01949359f, -0.06793795f, -0.00057613f, 
    0.32239565f, 0.07748399f, -0.47072870f, 0.04692391f, 0.06194666f, 0.03951639f, 0.08099508f, -0.01404982f, 
    0.00284052f, 0.06998007f, -0.04716032f, -0.04876725f, 0.06650456f, -0.28626248f, 0.28812912f, 0.00576194f, 
    0.00146385f, -0.19997191f, -0.19436911f, -0.05832580f, -0.03460695f, -0.09726503f, 0.02367454f, 0.01248959f, 
    -0.29980189f, 0.17256685f, 0.09586012f, -0.28520599f, -0.24021588f, -0.05964301f, -0.09257035f, 0.33349320f, 
    0.04263181f, 0.03985940f, 0.04753737f, 0.03131526f, -0.21201304f, 0.09486989f, -0.13258100f, -0.16629124f, 
    -0.00075618f, 0.06569111f, 0.21578656f, 0.13649592f, 0.11318585f, 0.00524064f, 0.06619913f, 0.29511449f, 
    -0.43196562f, 0.09821279f, -0.08297264f, -0.42697260f, -0.19522032f, 0.01259392f, -0.05193467f, -0.11975361f, 
    0.08773176f, 0.00184613f, 0.01811314f, 0.00963849f, 0.27573082f, 0.10556198f, 0.12826900f, -0.24056831f, 
    0.10561714f, -0.03872932f, -0.25161919f, -0.04323646f, 0.00507046f, -0.00383353f, 0.01199599f, 0.13958426f, 
    -0.11327615f, 0.03826905f, 0.05972475f, 0.06591153f, 0.09712922f, 0.10707287f, 0.03005828f, 0.00141607f, 
    0.14678763f, 0.11117354f, 0.06322675f, 0.07672209f, 0.15874068f, 0.09420992f, 0.11092496f, -0.24065486f, 
    0.00689734f, -0.17945829f, -0.10463701f, -0.04275314f, -0.06468032f, -0.01178587f, 0.07545884f, -0.03996396f, 
    -0.02088830f, -0.51758599f, 0.10688682f, 0.03839370f, 0.18462051f, -0.03371899f, 0.04117913f, -0.08533789f, 
    0.03019961f, -0.00419749f, -0.07397182f, -0.10423685f, -0.37657920f, 0.06803393f, -0.13225351f, 0.03487477f, 
    -0.06938899f, 0.05994209f, 0.05355528f, -0.00743116f, 0.15095897f, 0.11639453f, -0.02375357f, 0.04444034f, 
    0.20215645f, 0.13627034f, 0.34012893f, 0.21708080f, 0.10919868f, -0.14180194f, -0.11340194f, -0.18392222f, 
    -0.04957093f, 0.06461322f, 0.00562588f, 0.03420050f, -0.40684816f, -0.13280827f, 0.23086120f, -0.07303904f, 
    -0.03848717f, 0.00460844f, 0.06194210f, 0.15006958f, 0.04403654f, 0.06314315f, 0.09156665f, 0.00644222f, 
    0.12263311f, 0.09114932f, 0.27458811f, 0.24407983f, 0.01823050f, -0.06699307f, -0.02225032f, -0.10653994f, 
    -0.10262471f, 0.01312273f, -0.02523403f, -0.01063414f, -0.12339076f, 0.23609231f, 0.55291635f, -0.43672660f, 
    0.03535425f, -0.23772743f, -0.01923265f, -0.10361402f, -0.03295013f, 0.05074234f, 0.07670603f, 0.06919235f, 
    -0.13242453f, -0.52729011f, 0.08000612f, -0.05417200f, -0.09149376f, 0.12018491f, -0.12799081f, 0.19384782f, 
    0.09230050f, -0.00818926f, 0.03084886f, 0.00238529f, 0.07653456f, 0.11481452f, 0.14402738f, -0.08316156f, 
    -0.11005647f, -0.19338921f, -0.11545298f, 0.03302066f, 0.08755417f, 0.03942858f, 0.02675917f, -0.01777682f, 
    -0.14553447f, 0.34377986f, -0.10838411f, 0.14008772f, -0.20666079f, 0.09275632f, -0.14828037f, 0.04731107f, 
    -0.36268723f, 0.10961404f, 0.03564848f, -0.02274342f, -0.00797368f, 0.13251159f, 0.08575353f, -0.07034446f, 
    -0.11425231f, 0.07497770f, 0.06990706f, 0.09981476f, -0.04177294f, 0.18725479f, 0.12969434f, 0.08734024f, 
    0.07195472f, -0.20768058f, -0.07912921f, -0.22432253f, -0.13474162f, -0.08037283f, 0.01724306f, -0.04913025f, 
    0.04611833f, -0.01833095f, 0.10897131f, 0.00729541f, -0.74040717f, 0.34387410f, -0.20427094f, 0.17243153f, 
    -0.05891267f, 0.12608507f, -0.11580639f, 0.20415409f, -0.16561985f, 0.01683290f, 0.07017243f, 0.10798032f, 
    -0.03092795f, 0.12335593f, 0.25272623f, 0.09473833f, -0.00649381f, 0.13663237f, -0.03427721f, -0.09941874f, 
    0.00868180f, 0.12317672f, 0.06597514f, 0.07835995f, -0.20625508f, 0.07074192f, -0.07800946f, 0.16654652f, 
    0.08159919f, -0.00092179f, 0.02434098f, -0.03595091f, 0.01653354f, 0.12605923f, 0.07569433f, -0.01513217f, 
    0.13510710f, -0.26816973f, 0.10060068f, 0.09590366f, -0.04907718f, 0.07954626f, 0.09111922f, 0.01060756f, 
    -0.02579416f, 0.05029435f, -0.14716670f, 0.14650786f, -0.29678923f, 0.22337800f, -0.55308431f, -0.01371159f, 
    0.10790880f, -0.23578051f, -0.06493316f, 0.13847345f, -0.16374987f, 0.10321683f, 0.00791601f, 0.03576225f, 
    0.11701234f, 0.12757802f, 0.26528153f, 0.17593619f, -0.04752645f, 0.05272210f, -0.02232907f, 0.07758162f, 
    0.08744608f, 0.08166601f, 0.00434305f, 0.06323090f, -0.01363371f, 0.03171992f, -0.01764096f, -0.19742325f, 
    0.04232324f, -0.13903174f, -0.05697140f, 0.07177433f, -0.01860190f, 0.10743115f, -0.15118970f, -0.46918529f, 
    0.05699234f, -0.00185522f, 0.13597268f, -0.06453359f, 0.02019749f, -0.11414348f, 0.02791346f, -0.08038520f, 
    -0.14674251f, -0.05678074f, -0.28638938f, -0.20784321f, 0.07245801f, 0.06115258f, -0.09579162f, 0.01377012f, 
    0.02643103f, 0.00370943f, 0.06521266f, -0.07236343f, -0.04604606f, -0.15883569f, -0.14506468f, -0.31427872f, 
    0.00106914f, 0.05281753f, 0.07075761f, 0.00231977f, 0.00224065f, 0.09750491f, 0.20476472f, 0.13609338f, 
    0.00244383f, 0.06430473f, 0.07856555f, 0.14188130f, -0.30287018f, 0.29254889f, -0.15197961f, -0.36060405f, 
    0.01319808f, -0.10618770f, 0.17123103f, -0.03487470f, -0.13648951f, 0.16294289f, -0.08273308f, 0.07076301f, 
    -0.05313082f, 0.52334762f, 0.01968426f, -0.09853362f, -0.09211285f, 0.00020185f, 0.00477439f, -0.13542859f, 
    0.06297903f, 0.13635918f, -0.02753493f, 0.11265037f, -0.06333300f, 0.26962155f, 0.22282282f, 0.21142577f, 
    -0.04448031f, -0.07464659f, 0.06910215f, 0.03052418f, -0.04922678f, 0.05448523f, 0.08870836f, 0.12033646f, 
    -0.09372316f, 0.10948621f, -0.05645085f, 0.15041223f, -0.28079212f, 0.02858967f, 0.01594164f, 0.10280632f, 
    -0.01007121f, 0.02797802f, 0.11943278f, 0.16396861f, -0.36003447f, -0.28188771f, -0.15528859f, -0.02972530f, 
    -0.20056514f, 0.15597737f, -0.24587232f, 0.22720595f, -0.13986582f, 0.01726999f, 0.01570440f, -0.08052005f, 
    0.51946270f, -0.56592995f, 0.20135610f, 0.08867798f, -0.08997707f, 0.08912557f, 0.11991137f, 0.14371526f, 
    0.01210363f, -0.03038204f, -0.23732245f, 0.08573103f, -0.21467765f, 0.03208980f, 0.01965080f, 0.20896424f, 
    0.00651819f, 0.14431378f, -0.15576816f, -0.21632887f, 0.01470153f, 0.05154783f, 0.10607051f, -0.11506309f, 
    0.04758539f, -0.13053982f, 0.01450701f, -0.00493591f, -0.13368966f, -0.04559380f, 0.17337891f, 0.01232078f, 
    0.03594786f, -0.03673136f, 0.07761236f, -0.08659206f, -0.00677569f, -0.16990274f, -0.04709491f, 0.00277894f, 
    -0.18239452f, -0.05066829f, -0.10250892f, 0.07574151f, 0.07264502f, -0.04164134f, 0.00760454f, -0.03280967f, 
    -0.06949420f, -0.11329107f, 0.15144601f, -0.11328683f, -0.01388552f, -0.02843045f, 0.04779975f, 0.01332847f, 
    -0.00098214f, -0.16661172f, -0.21665597f, 0.05194395f, -0.42603818f, 0.29478285f, 0.08774331f, 0.06884615f, 
    -0.00560296f, 0.06876591f, 0.26465809f, -0.00622875f, -0.19436342f, 0.13194667f, 0.08489741f, -0.07063623f, 
    -0.37937930f, 0.20135531f, 0.10925039f, 0.21935551f, 0.04815258f, 0.03424717f, 0.12070332f, -0.03401611f, 
    -0.10105367f, -0.05780466f, -0.05697248f, 0.00069494f, -0.33695051f, 0.13046667f, -0.39877468f, -0.02353927f, 
    0.07266652f, -0.06302189f, 0.00814863f, 0.17662464f, -0.28785080f, -0.13854952f, -0.12879299f, -0.21301685f, 
    -0.06680082f, 0.31656244f, 0.20753652f, 0.12502655f, -0.03815064f, 0.04077578f, 0.00111410f, 0.22559124f, 
    -0.28974399f, -0.02815201f, 0.17764811f, -0.00578419f, 0.29669136f, -0.17044398f, 0.41550824f, -0.05551694f, 
    0.02060851f, -0.03452656f, 0.05276810f, 0.02479818f, -0.10246464f, -0.04221594f, 0.08810451f, 0.00343347f, 
    -0.08543333f, 0.19453363f, 0.23208848f, 0.00697748f, -0.03791381f, 0.03193882f, 0.01330340f, 0.07296778f, 
    -0.09806896f, -0.10738420f, 0.14007132f, 0.04404582f, -0.00596176f, -0.21886748f, -0.03741335f, 0.19881466f, 
    -0.06323434f, 0.01034171f, -0.08153576f, -0.00811520f, -0.06488273f, 0.02443773f, -0.22609510f, -0.00424598f, 
    -0.34558520f, 0.18514970f, -0.12003684f, 0.04756697f, 0.06542677f, -0.01593475f, -0.07685366f, 0.08061957f, 
    -0.16709222f, -0.21011345f, -0.17653514f, -0.29643410f, -0.17667472f, -0.16232841f, -0.27641660f, -0.00471029f, 
    -0.23106743f, -0.07517190f, -0.02935960f, -0.00738380f, 0.02145736f, 0.06050984f, -0.02231108f, 0.04619240f, 
    -0.07686441f, -0.01730159f, -0.03928874f, 0.23759715f, 0.03511976f, -0.22678012f, -0.04773155f, -0.03838944f, 
    -0.05798709f, 0.15188694f, 0.13202120f, 0.14202338f, 0.04396883f, 0.02494762f, -0.07199492f, -0.06211548f, 
    -0.08356742f, -0.02432085f, 0.04670822f, 0.09791545f, 0.02784537f, -0.20395778f, -0.10059138f, -0.11689071f, 
    -0.22674686f, -0.20127513f, -0.09330675f, 0.14409950f, 0.05855249f, -0.03185214f, -0.14154282f, 0.00235128f, 
    -0.01564823f, 0.12625834f, 0.00532176f, 0.02995647f, -0.07713933f, 0.02777248f, -0.14371549f, 0.03550907f, 
    -0.14123864f, 0.15276377f, -0.17834418f, -0.01196830f, -0.02281704f, -0.17614210f, -0.15851349f, -0.00069057f, 
    -0.11478165f, -0.05453173f, 0.05393351f, -0.02678413f, -0.05819524f, 0.07562065f, 0.11725206f, 0.00094351f, 
    -0.07377049f, 0.10161664f, 0.06822849f, 0.04139847f, 0.03354728f, -0.14916179f, -0.12631129f, 0.18709949f, 
    -0.03038820f, -0.01539382f, 0.05101087f, -0.08819766f, 0.07737070f, -0.02850649f, -0.25786301f, 0.16716920f, 
    0.02044887f, -0.22776613f, 0.08027628f, -0.05590421f, 0.04732328f, 0.07195342f, 0.01747034f, 0.00225999f, 
    0.06170230f, 0.01870931f, -0.09300403f, -0.08585381f, 0.06600071f, -0.24912803f, 0.20267788f, -0.03867188f, 
    0.03978736f, -0.06521060f, 0.00079426f, -0.07587473f, -0.12185823f, 0.03577796f, -0.00794347f, -0.21040507f, 
    -0.12888969f, 0.02439462f, -0.22447884f, -0.16330592f, -0.08604706f, 0.00605740f, -0.08173479f, -0.01418307f, 
    -0.02182844f, -0.05423691f, -0.00489631f, -0.05681183f, -0.41261062f, 0.39830548f, -0.08084342f, -0.01531716f, 
    -0.01165596f, -0.17792325f, -0.04899129f, -0.05580827f, -0.13299775f, 0.18810511f, -0.01690086f, 0.04741237f, 
    -0.14523819f, 0.08097676f, -0.12603061f, 0.30161753f, 0.09637974f, -0.00129513f, 0.08578900f, 0.08256997f, 
    0.05956263f, 0.07724754f, 0.11467768f, 0.14777148f, 0.32008177f, 0.09215472f, 0.05535912f, -0.11015132f, 
    -0.02713412f, -0.20609371f, 0.03789692f, 0.01060079f, -0.03071545f, -0.10010655f, -0.19773325f, -0.26829612f, 
    0.06476993f, 0.09771524f, -0.16071452f, 0.15595438f, 0.14565738f, -0.05707221f, 0.09437469f, 0.04500997f, 
    -0.22576301f, 0.08674934f, 0.08851678f, -0.06695515f, 0.03825025f, -0.03459824f, 0.04892242f, 0.07967590f, 
    0.03828268f, 0.02362512f, 0.02857484f, -0.00145610f, -0.13566515f, -0.11295282f, 0.04169345f, -0.01435415f, 
    -0.14629880f, 0.17394294f, 0.33388472f, 0.11819126f, 0.03284179f, 0.09681948f, 0.12197761f, -0.05252142f, 
    0.08889864f, 0.05050603f, 0.26944482f, 0.07100384f, -0.22370757f, 0.21046425f, -0.02132946f, -0.02601896f, 
    -0.14459860f, -0.07515453f, -0.04483948f, -0.00606154f, 0.06908433f, 0.14964661f, 0.20561339f, 0.08232700f, 
    -0.48570290f, 0.06766206f, -0.25016597f, -0.03687173f, 0.01720394f, 0.00342810f, 0.12128122f, -0.03073698f, 
    -0.02948838f, 0.14885566f, -0.06931667f, 0.01089277f, -0.30706236f, 0.17908108f, 0.04470553f, -0.04513931f, 
    0.06345576f, 0.14219423f, 0.06866409f, -0.05680480f, 0.08148431f, 0.04210982f, -0.07073116f, -0.06429213f, 
    -0.10923483f, -0.33830690f, -0.36001462f, 0.11931700f, -0.06309291f, -0.15808585f, -0.08075836f, 0.14817856f, 
    0.04926322f, 0.07813495f, -0.02933472f, 0.03227446f, 0.07048696f, 0.03928037f, 0.10413978f, -0.02605025f, 
    -0.03629201f, -0.12964691f, 0.04494431f, -0.04987054f, -0.34705341f, -0.13087456f, -0.14710520f, -0.35041505f, 
    0.12054824f, -0.31080338f, 0.10859991f, 0.07719871f, 0.02058265f, 0.05072651f, -0.01730162f, 0.01737789f, 
    -0.18721013f, 0.03009671f, 0.06315999f, -0.10314418f, 0.37982005f, 0.10927874f, 0.18481657f, 0.12072771f, 
    -0.06138599f, -0.10325541f, -0.08129659f, -0.01897329f, -0.12733160f, -0.10571904f, 0.01590611f, -0.19172862f, 
    -0.13524008f, -0.27812970f, -0.02175602f, -0.22038263f, -0.11940505f, -0.11091428f, 0.06967431f, -0.00629355f, 
    -0.06937314f, -0.14737196f, -0.04020328f, 0.01033424f, 0.10082711f, 0.08258613f, -0.06379029f, -0.00649897f, 
    -0.09432692f, 0.01622272f, 0.11891098f, -0.05268297f, -0.01057854f, 0.09978302f, 0.12263834f, 0.04356902f, 
    -0.40800688f, 0.15164679f, -0.17342027f, -0.07497910f, 0.01942276f, 0.17809524f, 0.10770317f, 0.03832730f, 
    -0.06048181f, 0.07427114f, -0.06652047f, 0.01525118f, 0.07100942f, -0.28640977f, 0.10798982f, 0.06232281f, 
    0.00625680f, 0.04054385f, 0.05485127f, -0.02180134f, 0.01906367f, -0.00665619f, -0.12584820f, -0.15018921f, 
    0.14849792f, 0.10360641f, -0.00324561f, -0.12797777f, -0.03632058f, -0.02799483f, 0.07809417f, -0.00116389f, 
    -0.00326503f, -0.04110537f, -0.04776839f, -0.00345322f, -0.02141182f, -0.44085026f, -0.34113401f, 0.03612838f, 
    0.02350407f, 0.02245794f, -0.02828579f, 0.08642181f, 0.05997348f, 0.06953999f, 0.01866676f, 0.01824655f, 
    -0.26153636f, 0.19111012f, -0.23350488f, 0.01259494f, -0.07787736f, 0.00479111f, 0.13140354f, -0.18066618f, 
    -0.02413253f, 0.05849088f, 0.11323252f, -0.08580339f, -0.27713779f, -0.00938139f, -0.05755183f, 0.04430814f, 
    0.00223968f, -0.10544953f, -0.15802769f, 0.03403161f, 0.00733663f, -0.07757697f, -0.03733797f, -0.02971456f, 
    -0.25286752f, -0.26797834f, -0.15493444f, 0.09680033f, -0.01415435f, 0.09736957f, -0.01813301f, -0.15424268f, 
    -0.01636978f, -0.10230792f, 0.00447038f, -0.02432354f, -0.12488253f, 0.20396601f, -0.28722799f, 0.03699525f, 
    -0.04266981f, 0.11400937f, -0.01063803f, 0.00093105f, -0.09321917f, 0.03801420f, -0.11452255f, 0.10832509f, 
    0.17099088f, -0.27234751f, 0.25893432f, 0.44702908f, -0.08403531f, -0.17430776f, 0.10016666f, 0.48421860f, 
    0.07494522f, 0.00313435f, -0.09641276f, 0.04740275f, 0.02183953f, -0.09238434f, 0.25542083f, 0.01672482f, 
    0.05177065f, -0.05394083f, 0.08723009f, -0.01450172f, -0.02518258f, -0.02195316f, 0.00048305f, -0.20620000f, 
    0.11076500f, 0.03699436f, 0.10514836f, -0.00460658f, -0.03580938f, -0.04898910f, 0.08450580f, 0.00244828f, 
    -0.08077260f, -0.05055214f, -0.03331302f, -0.19723290f, -0.50227100f, -0.02377623f, -0.07120888f, 0.47610572f, 
    0.31236860f, 0.09355452f, 0.16975188f, 0.12700811f, -0.08488533f, 0.19927911f, 0.00061314f, -0.01055488f, 
    0.11336213f, 0.05905044f, 0.12483227f, 0.05683590f, -0.07293236f, 0.07151262f, -0.13369504f, 0.01558214f, 
    0.01351879f, -0.02992308f, -0.00187844f, -0.11516441f, -0.65191793f, 0.19716020f, -0.32643750f, 0.24709764f, 
    0.13602737f, 0.06778346f, 0.18246786f, -0.12635602f, -0.08608358f, -0.01194916f, 0.19760402f, 0.19329388f, 
    0.33738077f, -0.12893569f, 0.33935800f, -0.23156492f, 0.10713833f, -0.06614631f, -0.18691485f, 0.26200706f, 
    -0.15816803f, 0.04836188f, 0.02277402f, -0.13842838f, -0.00301589f, -0.09681592f, 0.06441285f, 0.37416780f, 
    -0.28694689f, 0.10282190f, -0.07632579f, -0.07106952f, 0.05077097f, -0.04190344f, -0.02408468f, 0.09828272f, 
    -0.15914670f, -0.00458404f, 0.23049887f, 0.19849584f, 0.07345241f, 0.00694742f, 0.11883382f, -0.09604116f, 
    0.03848255f, -0.08206811f, -0.19202849f, 0.05371340f, 0.00604024f, 0.04339086f, -0.11575107f, -0.30684164f, 
    -0.04094353f, -0.02729837f, -0.01713688f, -0.01022760f, -0.02131854f, 0.05258527f, 0.04398041f, -0.02872428f, 
    0.26077059f, -0.23566271f, 0.23814148f, -0.14895564f, 0.06352130f, 0.10551699f, -0.06458564f, -0.05066099f, 
    -0.00426034f, 0.07582943f, 0.17149734f, 0.06159041f, 0.06834219f, 0.13170458f, -0.11450373f, 0.08481687f, 
    0.03183955f, 0.03223036f, 0.14160699f, 0.16043328f, -0.03538603f, 0.04919270f, 0.08615038f, 0.08503026f, 
    -0.28925854f, 0.15139414f, -0.35266989f, 0.07823256f, 0.20588471f, -0.15870295f, 0.04810767f, -0.06698961f, 
    -0.05508310f, -0.09136549f, -0.22191140f, -0.13768776f, -0.00076175f, 0.14778516f, -0.27906981f, 0.13243531f, 
    0.20576660f, 0.09685717f, 0.05728928f, -0.13953976f, 0.03668718f, -0.12292306f, 0.08220750f, -0.12384319f, 
    -0.14671426f, -0.25326419f, -0.19549489f, 0.04547731f, 0.04441991f, 0.02889119f, 0.05839962f, -0.05323432f, 
    0.09721937f, -0.13596299f, 0.03197362f, 0.08299488f, 0.06637374f, -0.08816413f, 0.27235699f, 0.35012785f, 
    -0.04993640f, 0.12924492f, -0.04641961f, 0.02531173f, -0.12198611f, -0.07405077f, -0.04341868f, -0.06149307f, 
    -0.00026214f, -0.27229762f, 0.15846641f, 0.21567751f, -0.09395222f, -0.07384279f, -0.04630354f, -0.21698524f, 
    -0.00501987f, -0.11929070f, -0.05703611f, -0.23726286f, 0.49484181f, 0.32870075f, 0.14274347f, -0.08377395f, 
    0.00757184f, -0.11698389f, 0.13166222f, 0.15455939f, -0.02137329f, 0.08149205f, 0.04905876f, 0.03143561f, 
    -0.17602642f, 0.12072949f, 0.11870099f, 0.07360769f, 0.06494974f, 0.21438339f, -0.08356654f, 0.06685989f, 
    -0.01330884f, 0.08825684f, 0.09975991f, 0.10091123f, -0.06838038f, -0.16666760f, 0.01694661f, -0.06988533f, 
    0.08365399f, -0.07535016f, -0.20265386f, 0.10395184f, -0.07598729f, 0.01979557f, -0.03719423f, 0.02870194f, 
    0.02062722f, -0.58176255f, 0.45667994f, -0.22480908f, 0.06989267f, 0.04952396f, 0.03024131f, 0.17117473f, 
    -0.05380083f, 0.00211032f, 0.12963331f, 0.07184564f, 0.28968304f, 0.22010723f, 0.09290007f, -0.13286370f, 
    -0.12215690f, 0.05598569f, -0.09211896f, 0.07316676f, -0.03743284f, 0.09549712f, 0.00382782f, -0.05353205f, 
    0.09136265f, 0.15697026f, 0.04809643f, -0.03903233f, -0.11750763f, 0.04964182f, -0.04760863f, -0.01922234f, 
    -0.02205535f, 0.03637158f, 0.04498601f, 0.01707938f, -0.19664417f, -0.22066236f, -0.18228900f, 0.25878152f, 
    -0.08858788f, -0.09944737f, 0.17091966f, -0.16985378f, 0.04532971f, 0.06343333f, -0.14193116f, -0.07683288f, 
    -0.17561355f, -0.52570182f, -0.10604534f, -0.08650687f, 0.04524601f, -0.03966282f, 0.07383355f, -0.01245972f, 
    0.04028305f, 0.09382280f, 0.09771708f, -0.00122334f, -0.14806166f, 0.03253205f, -0.23980285f, 0.07923730f, 
    0.14238834f, -0.10015380f, 0.01437112f, 0.04646629f, -0.03299935f, 0.12718736f, 0.04794430f, 0.14820208f, 
    -0.19622336f, 0.00662913f, -0.09899442f, 0.21448997f, -0.06034959f, 0.05771289f, 0.05690118f, 0.19904187f, 
    -0.12785284f, -0.03520162f, -0.08218221f, 0.02933218f, -0.10795742f, 0.03204229f, -0.08980334f, 0.06236350f, 
    0.13032722f, 0.04305843f, 0.17588946f, -0.10228692f, -0.04048704f, 0.06862496f, -0.07003459f, -0.15320057f, 
    0.17116624f, 0.14563204f, 0.15533607f, -0.10383939f, -0.13819365f, 0.27491921f, -0.23709315f, 0.06905839f, 
    -0.10759923f, 0.01876851f, 0.08722699f, 0.06923235f, -0.30126813f, -0.03023733f, -0.02550240f, 0.08099938f, 
    -0.12320201f, -0.13622625f, -0.04454425f, -0.00883926f, -0.14635971f, -0.01273388f, 0.16510382f, -0.02676854f, 
    -0.10865396f, -0.08204195f, 0.05239408f, 0.19678985f, 0.03296102f, -0.02981604f, 0.09856840f, 0.19442727f, 
    -0.07421365f, 0.13065313f, -0.00418572f, -0.02246896f, 0.38061166f, 0.22369692f, 0.28063148f, -0.17074756f, 
    -0.06103769f, -0.00890039f, -0.06289683f, 0.08130074f, -0.09095535f, -0.04574336f, 0.01065472f, -0.04577550f, 
    -0.06282391f, 0.13711651f, -0.02031771f, 0.00500201f, -0.15874825f, 0.13541473f, -0.03996457f, 0.11442550f, 
    -0.09769233f, 0.15583356f, 0.07110378f, -0.06706197f, 0.02861095f, -0.11634043f, 0.15703040f, -0.13548896f, 
    -0.05537611f, 0.12469395f, -0.05969882f, -0.02098402f, 0.04774382f, 0.01344052f, 0.07273564f, 0.00663998f, 
    -0.18068020f, -0.47441939f, 0.10887416f, -0.17779912f, -0.36290658f, -0.22213770f, -0.06176945f, -0.12170220f, 
    -0.00160758f, 0.07697012f, -0.06933064f, 0.00032544f, 0.11306909f, -0.11914068f, 0.02418169f, -0.12594973f, 
    -0.04426738f, -0.00319989f, 0.19342546f, 0.23642388f, -0.10233438f, 0.03979334f, 0.15100820f, -0.04794581f, 
    0.13909464f, 0.02007183f, 0.23887873f, 0.12345099f, 0.00055143f, -0.01238922f, -0.01731638f, -0.05086090f, 
    -0.04861270f, 0.13837409f, -0.09857139f, 0.07354891f, 0.09771286f, -0.09031370f, -0.03969408f, -0.11813221f, 
    -0.03289832f, 0.01604238f, 0.00318474f, -0.10250253f, -0.03721669f, 0.01426922f, 0.03170363f, -0.10002743f, 
    -0.51108599f, 0.16824701f, -0.12676366f, 0.18269464f, -0.03898454f, 0.02137770f, 0.16534410f, -0.20016801f, 
    -0.13212478f, 0.06718451f, -0.07460406f, 0.08717262f, 0.11711869f, -0.03385405f, 0.35760957f, 0.03212797f, 
    -0.19850047f, -0.00040132f, -0.21517880f, -0.00910751f, -0.05084941f, -0.00372809f, 0.03013385f, 0.06225661f, 
    0.31585196f, 0.03071898f, 0.14782745f, 0.14713295f, 0.00062585f, 0.08743184f, 0.00878137f, 0.04707501f, 
    -0.12167382f, 0.06883556f, 0.06761400f, 0.07194638f, 0.02765794f, 0.06115206f, -0.22373146f, 0.34928879f, 
    0.03218337f, 0.04385432f, 0.00292894f, 0.08321185f, -0.17961870f, 0.03160737f, 0.20214315f, -0.09185313f, 
    -0.06238388f, 0.04131695f, -0.13843720f, 0.01773077f, -0.29398340f, -0.09841278f, -0.24856776f, -0.11017604f, 
    -0.00092085f, -0.01137090f, -0.08177061f, -0.18391299f, -0.25438654f, 0.13307296f, -0.21246095f, -0.15659319f, 
    -0.15701155f, -0.10215145f, 0.18088679f, -0.10277648f, 0.17269415f, 0.07346503f, -0.11386416f, 0.07678721f, 
    -0.19982363f, -0.14615773f, 0.09660014f, 0.31155235f, 0.13936552f, 0.07093246f, 0.13713647f, -0.21018647f, 
    -0.04681739f, -0.06484756f, 0.01737539f, -0.09291708f, 0.04825595f, 0.06547532f, -0.00063230f, 0.01388869f, 
    -0.12799005f, 0.02090803f, -0.03357368f, 0.05990545f, -0.25323844f, 0.08340339f, 0.03154829f, 0.01833466f, 
    0.11937317f, -0.09339476f, 0.22198866f, -0.01786154f, 0.05802063f, 0.11299021f, -0.17125794f, 0.11864720f, 
    -0.02123870f, -0.03002278f, 0.02192064f, -0.15977313f, -0.28250244f, -0.02353428f, -0.33824089f, 0.20548023f, 
    0.12025952f, -0.00238069f, -0.07233124f, -0.04158349f, -0.09995421f, -0.10588150f, -0.18491915f, -0.08708315f, 
    0.21525651f, -0.18291570f, 0.32137936f, 0.00385473f, -0.00848386f, 0.02988082f, -0.03559613f, -0.14465657f, 
    -0.00883601f, 0.03653873f, 0.10134099f, 0.03390238f, 0.00738243f, 0.09049417f, -0.24223430f, 0.23272295f, 
    0.06761824f, 0.01340494f, 0.11689586f, 0.01367936f, 0.13154380f, 0.15575743f, -0.05490774f, 0.00988228f, 
    -0.19046743f, -0.22750995f, -0.11264010f, -0.01737224f, -0.14120555f, 0.04503001f, -0.04613566f, -0.14722028f, 
    0.02007170f, 0.01822034f, -0.05137673f, -0.18524879f, 0.13848682f, 0.09484601f, 0.01677492f, -0.06373148f, 
    -0.00299928f, 0.04680885f, -0.05522263f, -0.02888736f, 0.16654047f, 0.12861575f, 0.04841396f, 0.07145998f, 
    0.06944130f, 0.21591558f, -0.12107485f, -0.05955451f, -0.04072760f, -0.01793477f, 0.09092204f, 0.04839974f, 
    0.05117134f, -0.05933118f, -0.01835579f, -0.04988912f, -0.21393713f, -0.18390748f, 0.02284972f, -0.19396879f, 
    0.05866319f, -0.00349390f, -0.04936112f, -0.05431737f, -0.03569257f, -0.00989720f, 0.09853751f, -0.19190592f, 
    0.01384546f, 0.13853332f, -0.02690936f, -0.22372042f, -0.14425562f, 0.13348958f, -0.04000802f, 0.07120833f, 
    -0.12615620f, -0.00948571f, 0.12045084f, -0.18672507f, -0.08111423f, -0.03239430f, 0.17533316f, -0.00252704f, 
    -0.02688238f, -0.10729218f, 0.00395769f, 0.08629411f, -0.09916107f, -0.05146546f, -0.34374616f, -0.12423182f, 
    0.03434305f, 0.05885588f, -0.16650307f, 0.15998831f, -0.06860012f, -0.02517652f, -0.06760041f, -0.04306972f, 
    0.08660021f, 0.01705586f, 0.05659128f, -0.11854213f, -0.20109384f, -0.38651082f, 0.16647252f, -0.24738479f, 
    -0.07579134f, 0.04758742f, -0.17215583f, -0.09521901f, -0.04260425f, -0.03286522f, 0.06150053f, 0.12184824f, 
    -0.33700791f, -0.05994514f, -0.17599684f, -0.12679151f, 0.01006249f, -0.03471047f, -0.06118875f, 0.02573548f, 
    -0.11601854f, 0.09671056f, 0.06047395f, -0.03200842f, -0.25650239f, -0.39207518f, 0.05628674f, -0.03131522f, 
    -0.20570922f, -0.15642563f, -0.01264331f, -0.11486557f, -0.05802608f, 0.03299909f, -0.02778143f, -0.04273810f, 
    -0.26548243f, -0.23223050f, -0.18766950f, 0.11449502f, 0.09785414f, -0.08479186f, -0.00944187f, 0.09176253f, 
    0.04468093f, 0.04377143f, -0.00074845f, 0.09516851f, -0.39376020f, -0.44456783f, -0.03352140f, -0.21294495f, 
    -0.04088336f, 0.01031678f, 0.14261456f, 0.02235088f, -0.07370680f, 0.10106891f, 0.00969662f, -0.10889006f, 
    -0.26820129f, -0.01127234f, -0.19352931f, 0.10955426f, -0.04627151f, -0.17879191f, 0.17892256f, -0.22469607f, 
    -0.05966859f, 0.00282566f, 0.04121685f, 0.07864337f, -0.04739826f, -0.29370859f, 0.02308587f, 0.16884056f, 
    -0.09210602f, -0.26373374f, 0.10751134f, -0.03587366f, -0.01413119f, 0.04831651f, 0.04828970f, 0.04684292f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.15254089f, 0.06896697f, 0.04235042f, -0.11474817f, -0.04878813f, 0.02967960f, 0.03626938f, -0.11266022f, 
    0.03774562f, 0.02307416f, 0.03456996f, -0.00579815f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
