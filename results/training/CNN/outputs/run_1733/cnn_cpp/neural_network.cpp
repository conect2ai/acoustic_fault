#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.76661551f, -0.55168760f, -0.65327716f, -0.60918498f, -1.06968558f, -0.68339884f, -0.09674756f, -0.75404829f, 
    -0.15071768f, 1.03464103f, 0.93763959f, 0.94825816f, 0.49414352f, 0.40262258f, 1.06764150f, 0.30787870f, 
    -0.07507355f, -0.27999547f, -0.98287052f, -0.22188671f, -0.95273238f, 0.37627107f, 0.00940951f, 0.23487213f, 
    -0.57010299f, -0.94213778f, -0.52883565f, -0.41088071f, 0.17668387f, -0.44989207f, 0.67183405f, -0.29161528f, 
    0.46954349f, 0.04425987f, 0.12151331f, 1.05002522f, 0.02582424f, -0.30374348f, 0.67671221f, -1.07931221f, 
    -1.03231835f, -1.51807797f, 0.10791375f, -0.17073131f, 1.01387668f, -1.61546409f, -1.08446980f, -0.61352074f, 
    1.44167709f, 0.43288976f, -0.27336121f, -0.04403919f, -0.38981614f, -0.40311027f, -0.74139160f, 0.20826133f, 
    -0.07854777f, 0.02116355f, 0.42507887f, -1.16104007f, -0.32984388f, -0.72914881f, 0.25781000f, -0.65124846f, 
    -0.57055509f, -0.29552495f, -0.78741705f, -0.75087214f, -1.10139275f, 1.08181214f, 0.81477493f, 0.13190895f, 
    -0.04939275f, 0.91431886f, -0.75388718f, 0.19334558f, -0.93425971f, -0.50472862f, -0.77731323f, 0.21889579f, 
    0.09595510f, 1.50091887f, 1.38087034f, 0.66133773f, -0.44583637f, -1.11800981f, -0.65617937f, 0.03054683f, 
    0.06715922f, -0.00017402f, 0.22552048f, 0.02883850f, 0.03597251f, 1.10769081f, -0.20607308f, -0.37903476f, 
    0.89227623f, 0.73875070f, 0.42572099f, -1.03366053f, -0.63716060f, -1.30137086f, 0.42572108f, 0.47074836f, 
    0.35538393f, -0.34551749f, 1.36005807f, -0.42362967f, 0.11585968f, 0.77862251f, 0.31418198f, -0.11492441f, 
    -0.16278034f, -0.55504125f, -0.51187468f, 1.40949249f, -1.00148046f, 0.53222913f, -0.91655344f, -1.44264114f, 
    -0.91480654f, -0.49732658f, -0.47578984f, 0.38996640f, -0.64392889f, -0.24347870f, -1.67206669f, -1.29558957f, 
    -0.75681067f, -0.39015850f, 0.54354382f, -0.35732606f, 0.00421658f, -0.26470414f, 0.42080188f, 1.58324194f, 
    -1.15180123f, -1.12930310f, 1.17728448f, -0.44846597f, -0.35105732f, -0.02107495f, 0.09032002f, -0.36504135f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.53221178f, 0.40829787f, 0.51842481f, 0.53611922f, -0.05751272f, -0.18411161f, 0.66675329f, -0.00612721f, 
    0.77307498f, 0.67447674f, 0.72650284f, 0.80268377f, -0.01228930f, 0.30728543f, 0.62872893f, 0.55544394f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.07175228f, 0.03184166f, 0.40813619f, -0.08539528f, -0.04461373f, -0.15914254f, 0.19258475f, 0.07460507f, 
    0.08912113f, 0.12690558f, 0.11566771f, -0.06974412f, -0.06924360f, -0.13024771f, -0.08129730f, -0.04378963f, 
    0.14943670f, 0.12794800f, -0.23614132f, 0.12344691f, -0.01455146f, 0.02203977f, 0.09980982f, 0.05033987f, 
    -0.24259394f, -0.10844462f, 0.27106968f, -0.06553732f, -0.01569560f, -0.18542926f, -0.01799990f, -0.14761962f, 
    -0.17520003f, 0.01165974f, 0.06135517f, -0.01034241f, -0.03812632f, 0.00837442f, -0.04790665f, -0.15478270f, 
    -0.15253346f, -0.30664346f, 0.14668964f, -0.10423389f, -0.09711452f, -0.75166494f, -0.02132484f, -0.41114953f, 
    -0.17461631f, 0.09525258f, 0.05505742f, 0.00718902f, 0.10038511f, 0.04474003f, -0.12564716f, 0.07410880f, 
    0.36265075f, -0.16689540f, -0.13551797f, 0.12790000f, 0.23121713f, -0.05089762f, 0.11541777f, 0.00221878f, 
    -0.32130715f, -0.02260622f, -0.13659960f, 0.07215653f, -0.19725496f, 0.07454760f, 0.02786029f, 0.06831232f, 
    0.21348079f, 0.04379516f, 0.16449517f, 0.05844148f, -0.11608324f, 0.28991258f, 0.23302658f, 0.03167587f, 
    -0.03886275f, 0.75160664f, 0.09061430f, -0.28927034f, -0.03651304f, 0.14385149f, -0.16408049f, -0.04292428f, 
    -0.00085672f, 0.14219779f, -0.24368843f, -0.08679957f, 0.02035051f, -0.14882618f, 0.01710984f, 0.01104155f, 
    0.45566082f, 0.17093997f, 0.14950199f, 0.03904973f, 0.04119283f, 0.19463484f, -0.01704312f, 0.32470724f, 
    -0.09646591f, 0.09441226f, 0.16664819f, 0.06913289f, -0.18339805f, -0.18806672f, 0.32514545f, 0.01431878f, 
    0.25519601f, -0.29903516f, 0.13703954f, 0.10658980f, 0.45446634f, 0.33091709f, -0.16233619f, -0.08612160f, 
    0.03220848f, 0.13929302f, 0.00381289f, -0.04584739f, 0.15937026f, -0.01769071f, -0.08954599f, -0.30126968f, 
    -0.10262932f, 0.17367132f, 0.06575011f, 0.16981260f, -0.24611326f, -0.25111410f, -0.02512022f, -0.26541668f, 
    0.11741441f, 0.13137750f, 0.07955650f, -0.21138819f, 0.36846846f, -0.04887051f, 0.17457065f, -0.18375833f, 
    0.04737383f, 0.04388677f, -0.04713596f, 0.06565522f, -0.08644056f, 0.01066242f, 0.01154381f, 0.08772444f, 
    -0.00819465f, 0.08061112f, 0.00269395f, -0.00519848f, 0.00666034f, -0.03727340f, -0.01912225f, -0.06773958f, 
    0.01279188f, -0.02081885f, -0.01922361f, 0.03566580f, -0.06824886f, 0.01675917f, -0.05981665f, 0.05354387f, 
    0.03250814f, 0.03010235f, -0.01460514f, -0.00896285f, 0.03798381f, -0.02624437f, -0.01314663f, 0.07795898f, 
    -0.07698368f, -0.00430269f, -0.08499117f, -0.08536722f, -0.06241719f, 0.04046938f, 0.01476170f, -0.08358479f, 
    -0.00820120f, 0.02571910f, -0.03568645f, -0.04947770f, -0.07831283f, 0.06624804f, -0.01615604f, 0.03790601f, 
    -0.01579301f, 0.02060895f, -0.07875004f, 0.05139032f, -0.07552940f, 0.03679894f, -0.06774176f, 0.01650614f, 
    0.05669879f, 0.04648489f, -0.08395945f, 0.04023427f, -0.03763440f, 0.02743463f, 0.00957293f, 0.03527546f, 
    -0.06333996f, 0.06108140f, -0.01930388f, 0.03462442f, -0.03571890f, -0.04527009f, -0.06219891f, -0.07719348f, 
    0.06333961f, 0.01836605f, -0.07768612f, -0.04104745f, -0.00007287f, -0.04532623f, 0.04462989f, 0.06971572f, 
    -0.08281548f, -0.01004936f, 0.05830678f, 0.00828316f, 0.00015959f, -0.08168891f, -0.08301520f, -0.06629012f, 
    -0.04162469f, -0.07933995f, -0.02743323f, -0.06738488f, -0.08283182f, 0.01738168f, 0.02309616f, 0.05043567f, 
    0.04291596f, 0.00960307f, 0.03724431f, -0.05504549f, -0.05533600f, 0.02976205f, 0.03350033f, 0.05598811f, 
    -0.09276427f, 0.06269699f, -0.01937634f, 0.00532599f, 0.01948783f, 0.00184874f, -0.03712611f, 0.04591282f, 
    -0.07443471f, -0.05749349f, -0.01071361f, -0.01924975f, 0.03281403f, -0.06777165f, -0.02342553f, 0.06728167f, 
    -0.00184971f, -0.07041477f, -0.04315570f, -0.02828927f, 0.01044757f, -0.01802153f, -0.08317328f, -0.01370826f, 
    -0.07637026f, -0.04008543f, -0.00282288f, -0.05744885f, -0.04128529f, -0.05007127f, 0.06359081f, -0.00491529f, 
    -0.06891367f, -0.04657586f, -0.03963119f, -0.00082187f, 0.04301994f, 0.06538475f, 0.04199544f, -0.01439205f, 
    -0.35591209f, -0.56540227f, 0.08246121f, -0.11860128f, -0.36138994f, -0.12823482f, -0.09295794f, 0.07144100f, 
    -0.00482402f, -0.78598487f, 0.06569569f, 0.26743254f, -0.05019506f, -0.44825611f, -0.23599473f, 0.12829000f, 
    -0.05070060f, 0.12031320f, -0.21336599f, -0.29720816f, 0.05935003f, 0.04408607f, 0.03992569f, 0.10753216f, 
    0.13906825f, 0.05878430f, 0.13845468f, -0.29323211f, -0.01001364f, 0.27904052f, -0.03802910f, 0.22920279f, 
    0.05633456f, 0.07275943f, 0.13019593f, -0.13437606f, -0.65786964f, 0.24300615f, 0.22095414f, 0.00492821f, 
    -0.06488907f, -0.24301773f, -0.01308015f, 0.02872282f, 0.03226879f, -0.51659417f, -0.28063437f, 0.26424101f, 
    0.10294542f, 0.20100312f, -0.23511706f, -0.10635803f, -0.00829180f, 0.05409390f, 0.04230015f, 0.46976456f, 
    0.19946353f, -0.02816765f, -0.13972594f, -0.08070027f, 0.01546689f, 0.13342203f, -0.25801924f, -0.02499091f, 
    -0.33757123f, 0.23886511f, 0.01195278f, 0.03046582f, -0.03654337f, 0.12333665f, -0.06899153f, 0.02325908f, 
    -0.05352914f, 0.08760989f, -0.05333116f, -0.11960334f, 0.06615157f, -0.08534490f, 0.08595092f, -0.00900625f, 
    -0.15891726f, -1.23454559f, 0.32698029f, -0.11884250f, -0.13737614f, 0.21512234f, -0.19463076f, 0.08681820f, 
    -0.11108682f, -0.08391273f, -0.11974564f, -0.50181568f, 0.00267998f, -0.01514435f, -0.05348182f, -0.22068149f, 
    -0.00544960f, -0.14190637f, 0.07472726f, 0.09037156f, 0.49589938f, 0.48585469f, -0.00708590f, 0.14242160f, 
    0.17101584f, 0.11308409f, 0.05451635f, 0.20937955f, -0.01009333f, 0.95266616f, -0.02870570f, -0.17017041f, 
    -0.02844602f, -0.41547835f, -0.49053657f, 0.30723894f, 0.41166383f, 0.01679570f, -0.64665955f, 0.19816369f, 
    0.05718752f, -0.01172293f, -0.01031379f, 0.02802385f, -0.12488555f, 0.10849611f, 0.13744809f, 0.29803163f, 
    0.21242662f, 0.15221572f, -0.17844421f, 0.11889790f, 0.05089688f, 0.10560929f, -0.11844528f, 0.58399624f, 
    0.16803600f, 0.17961462f, -0.15049443f, -0.13786066f, 0.01736597f, -0.01414262f, 0.10389472f, -0.17567565f, 
    0.39095905f, 0.38024420f, 0.67193401f, 0.21417780f, 0.13601626f, 0.09436518f, -0.19220275f, -0.15381472f, 
    0.19235733f, 0.09347405f, 0.20117030f, -0.24055894f, 0.09039671f, -0.13582984f, -0.12600477f, -0.15184423f, 
    0.09211349f, 0.20386326f, 0.07404822f, -0.18809038f, -0.12145010f, -0.05661491f, -0.00624744f, 0.00035895f, 
    0.07760632f, 0.05845087f, 0.38416281f, -0.22973263f, -0.06675909f, -0.25338456f, 0.29682431f, -0.03240547f, 
    -0.05819531f, -0.15773429f, 0.10632870f, -0.48655909f, 0.36323321f, 0.33076596f, 0.40856335f, 0.01435747f, 
    -0.24188602f, -0.14259665f, -0.10219144f, -0.15596116f, -0.47559986f, 0.14430408f, -0.32292253f, -0.25235072f, 
    0.05990479f, 0.04622667f, 0.09436452f, 0.01122455f, -0.03909454f, 0.22462918f, 0.21254583f, 0.22333787f, 
    -0.16869427f, -0.19324461f, 0.02270728f, -0.08970093f, -0.07296301f, 0.10038614f, -0.02866773f, 0.61382324f, 
    0.41195202f, 0.11068068f, 0.13660893f, -0.07959263f, -0.40593299f, 0.04594072f, 0.10152274f, -0.41456997f, 
    0.03676224f, 0.49814239f, -0.08997996f, 0.05789251f, 0.13004558f, 0.22145881f, -0.03993614f, 0.00670775f, 
    0.11247626f, -0.08478542f, 0.23363753f, -0.11242888f, 0.17211150f, 0.08827189f, 0.04546142f, -0.13877252f, 
    -0.09223211f, -0.11090849f, 0.12252166f, -0.25842351f, 0.03777721f, -0.07381425f, -0.08642857f, -0.00707539f, 
    -0.27359465f, -0.21135272f, -0.44261065f, -0.05206281f, -0.27630034f, -0.12181128f, -0.16948462f, 0.29458070f, 
    0.07937399f, -0.01003987f, 0.06780060f, 0.16387993f, 0.07634109f, 0.18346623f, -0.02254673f, -0.12307612f, 
    0.21687756f, 0.25875828f, 0.41115040f, -0.17927830f, 0.44175979f, 0.08170415f, 0.14266685f, 0.33375105f, 
    0.25062880f, 0.05680938f, -0.09665239f, 0.05952957f, -0.06293123f, 0.02278185f, -0.05846177f, -0.21369112f, 
    0.01282391f, 0.01786898f, 0.00167187f, 0.04991993f, 0.01918972f, 0.07281072f, 0.15901832f, -0.01830881f, 
    0.43719730f, 0.37059659f, -0.12550627f, -0.10646438f, -0.03641617f, -0.14331004f, -0.14556842f, 0.01447590f, 
    -0.12530148f, -0.14542590f, -0.47885770f, -0.22720036f, -0.38565269f, -0.51332176f, 0.00787446f, 0.13535835f, 
    0.13948563f, 0.16289084f, 0.08408030f, 0.26639950f, 0.14121889f, -0.03367424f, -0.17390652f, 0.17705932f, 
    0.02655652f, -0.05514709f, 0.16326420f, 0.38632721f, 0.10070740f, -0.10388158f, -0.21501978f, -0.12645650f, 
    0.01489724f, 0.09833181f, 0.22591683f, -0.12036119f, -0.03895700f, 0.05899872f, 0.01917247f, -0.01963466f, 
    0.10593570f, 0.01132051f, 0.01598792f, -0.13590595f, -0.54739076f, -0.11888038f, -1.04897797f, -0.33779714f, 
    -0.10611297f, -0.13111934f, -0.12111285f, -0.24553974f, -0.06789560f, -0.34312642f, 0.26050922f, 0.13404708f, 
    0.12089425f, -0.25384372f, -0.37207428f, 0.07653822f, 0.09384351f, 0.10372828f, -0.39921835f, -0.21106391f, 
    -0.01990875f, 0.12564118f, 0.15390168f, 0.05186256f, 0.20009954f, 0.08635546f, 0.24149100f, -0.27223408f, 
    -0.40551171f, -0.12217827f, -0.19886056f, -0.17994559f, -0.12945756f, -0.04292299f, -0.25389752f, -0.35151395f, 
    -0.02159704f, -0.41811526f, -0.63761890f, 0.07361645f, 0.03018329f, 0.09612678f, 0.10016049f, -0.19725931f, 
    0.18167825f, 0.65005112f, -0.04405353f, 0.10406777f, 0.05420432f, 0.22349602f, 0.15665662f, 0.08257867f, 
    0.02716785f, -0.11641403f, -0.00526913f, -0.00847046f, -0.03130507f, 0.13569090f, 0.01311113f, -0.10688842f, 
    0.08304462f, -0.08065493f, -0.10432662f, -0.42393684f, 0.38897392f, 0.10656381f, 0.10797238f, 0.27052593f, 
    0.28598359f, 0.08150773f, 0.57970232f, 0.09982388f, 0.30121547f, -0.56326658f, 0.06623033f, 0.32800123f, 
    0.01979512f, 0.16465372f, 0.12154681f, -0.00056478f, 0.10056186f, -0.07716230f, -0.34967995f, -0.09580377f, 
    0.00149943f, -0.14980012f, -0.25922352f, 0.08528254f, -0.12850228f, 0.17881778f, -0.50497431f, 0.70188743f, 
    0.35692802f, 0.09577511f, -0.16478097f, -0.29814157f, 0.09852485f, -0.14573984f, -0.01359830f, 0.52252197f, 
    0.38275257f, -1.14940834f, 0.01606382f, -0.15313207f, 0.06128475f, 0.27498478f, 0.10065161f, 0.11229201f, 
    -0.55417490f, 0.26989290f, 0.10490494f, -0.18530872f, -0.24739906f, 0.01158580f, 0.06282368f, 0.10545024f, 
    0.19725381f, -0.27982986f, -0.01418206f, 0.13747831f, 0.08837822f, -0.05145202f, 0.10761530f, -0.04046920f, 
    -0.03307557f, -0.02311328f, 0.16732925f, 0.24305274f, 0.10283925f, -0.29467347f, -0.08244682f, 0.28437698f, 
    0.02493960f, 0.08481265f, -0.19268836f, -0.05526336f, 0.00866415f, -0.15833455f, -0.09310307f, 0.04411079f, 
    -0.26611748f, 0.04313304f, 0.25475898f, 0.08483399f, -0.01496853f, -1.03961337f, -0.08898143f, -0.09528539f, 
    0.15471606f, -0.48984164f, -0.02191290f, 0.03007908f, -0.09878311f, -0.29937553f, 0.35009900f, 0.07304689f, 
    -0.05692646f, -0.46030849f, 0.14182703f, -0.01425982f, -0.02910982f, 0.02078487f, -0.46088561f, 0.34950817f, 
    -0.36692446f, 0.19693756f, -0.00883088f, 0.02892158f, 0.04874203f, -0.11705974f, -0.05124173f, -0.00417722f, 
    -0.02062036f, 0.14318098f, -0.02186574f, -0.18900846f, 0.10514842f, 0.00776563f, 0.01166975f, 0.11917701f, 
    -0.01606347f, -0.40711984f, 0.03229186f, 0.24090593f, 0.38976365f, -0.08557497f, 0.27595708f, 0.00443198f, 
    0.05888304f, -0.35649586f, -0.23506832f, 0.04359954f, 0.32819134f, 0.07436769f, -0.06781696f, 0.08160192f, 
    -0.08327916f, 0.03061858f, 0.09505677f, -0.11042391f, -0.09264287f, 0.14518574f, -0.18314935f, 0.08378974f, 
    0.39219970f, 0.10784180f, 0.29701316f, 0.09312858f, 0.54730320f, -0.09480218f, -0.03367054f, 0.06997569f, 
    0.00345947f, 0.01661575f, 0.09357237f, 0.05477403f, -0.30678070f, -0.32176051f, -0.52531594f, 0.03357151f, 
    -0.26453468f, -0.08830854f, 0.09538651f, -0.11856220f, 0.14066310f, 0.17350900f, 0.66634446f, -0.09053231f, 
    -0.15771008f, 0.20088838f, 0.33207184f, 0.07703245f, -0.09653689f, -0.06433646f, -0.11619080f, 0.21855107f, 
    0.26065379f, 0.09047769f, -0.11124548f, 0.12512927f, -0.08065291f, -0.00959717f, 0.11304545f, -0.23533615f, 
    0.02842413f, -1.15460742f, -0.17401980f, 0.12354149f, 0.18430410f, 0.12098737f, 0.01418240f, -0.17564963f, 
    0.06331520f, 0.48934177f, 0.35537729f, 0.11415263f, 0.19281387f, 0.21162544f, 0.22606829f, 0.00136712f, 
    0.01526679f, -1.02878559f, -0.50933832f, -0.21015392f, -0.01203461f, -0.21599658f, -0.02439157f, 0.05630668f, 
    -0.06574005f, -0.01837164f, -0.08608148f, 0.24011549f, 0.12707312f, 0.05335383f, 0.05743412f, -0.02395129f, 
    0.10880267f, -0.54794878f, 0.01751204f, -0.22650108f, -0.00155375f, 0.48278731f, -0.03722891f, 0.16266838f, 
    -0.28483737f, -0.05911076f, 0.11821205f, 0.20589273f, -0.08252002f, 0.91460985f, 0.24146785f, 0.08654556f, 
    0.16106035f, -0.07399404f, -0.02674270f, 0.09082604f, 0.18042196f, -0.13680716f, -0.22296894f, 0.11236893f, 
    -0.11403114f, -0.21283272f, -0.30970702f, 0.17319033f, -0.28190950f, -0.14822575f, -0.32034078f, 0.42086995f, 
    0.01131022f, -0.13648736f, 0.03897882f, 0.08587939f, -0.10612893f, 0.17225757f, -0.09394881f, 0.32984200f, 
    0.20287661f, 0.39617875f, -0.22595321f, -0.12431791f, 0.09281897f, 0.24072646f, 0.15498695f, 0.01408770f, 
    0.13370451f, 0.02493925f, 0.23706251f, -0.07041986f, 0.31258199f, 0.08742995f, -0.05907513f, 0.22908010f, 
    0.12414189f, -0.23728178f, -1.11853576f, -0.61524546f, -0.05427400f, 0.03057161f, -0.10578577f, -0.00603208f, 
    0.06400913f, 0.19208978f, -0.02116521f, -0.31859499f, 0.20263433f, -0.01509080f, -0.10953512f, -0.07172154f, 
    0.16598244f, 0.29741898f, 0.38531539f, 0.35002452f, 0.59211594f, -0.23793413f, -0.10047912f, 0.02103782f, 
    0.03799674f, 0.14116760f, 0.14615586f, -0.03032527f, -0.39002067f, 0.30313680f, 0.74879301f, -0.24911569f, 
    0.28241611f, -0.08546609f, -0.12675448f, 0.40090466f, -0.37796053f, -0.04261631f, -0.03057245f, 0.08650877f, 
    -0.18585515f, 0.12640721f, 0.03837471f, 0.13361749f, -0.28871581f, -0.02803597f, 0.09420814f, 0.08724045f, 
    0.02955979f, -0.15880238f, -0.28259018f, 0.00601151f, -0.02033247f, 0.08946238f, -0.02891475f, -0.25596336f, 
    -0.56778765f, 0.03312505f, 0.24491107f, -0.12931956f, 0.22343786f, -0.09692438f, 0.03995396f, -0.21705097f, 
    -0.02040898f, 0.13859458f, -0.11499369f, -0.17691626f, -0.20839073f, -0.00991590f, -0.10884692f, -0.10018162f, 
    -0.16818453f, 0.10231264f, 0.22783525f, 0.03493986f, -0.11061734f, -0.25857887f, -0.09950500f, -0.14267316f, 
    -0.18544863f, -0.06429938f, -0.60558301f, -0.31168586f, -0.28672266f, -0.09660286f, -0.14092572f, 0.04261728f, 
    0.07882413f, 0.18191674f, 0.12921226f, 0.40795302f, 0.08932188f, -0.24975295f, -0.32053530f, 0.32914603f, 
    0.08121643f, 0.06071386f, 0.33417568f, 0.15187083f, -0.59856468f, -0.06753188f, 0.39579156f, 0.06683262f, 
    -0.30726010f, -0.18856357f, 0.09770280f, 0.01672350f, -0.14512990f, -0.15973395f, 0.16566922f, -0.03590386f, 
    -0.17820503f, -0.22272146f, 0.05749131f, 0.21490219f, -0.05197301f, -0.15584108f, -0.38043013f, 0.22822742f, 
    -0.09819324f, 0.02926564f, 0.27165887f, 0.22033136f, -0.02058605f, 0.28239477f, 0.00556961f, -0.66960174f, 
    -0.34248945f, 0.11735249f, 0.16098985f, -0.06496742f, 0.07985982f, -0.06396200f, -0.02040052f, 0.08475901f, 
    0.11216056f, 0.60382575f, -0.35292178f, 0.14124592f, 0.05825620f, 0.17316581f, 0.22545548f, 0.37489614f, 
    0.09709702f, -0.17497429f, -0.17822319f, -0.21134667f, 0.08919851f, -0.08257377f, -0.13002816f, 0.06486731f, 
    -0.12073687f, 0.12212473f, -0.02120440f, 0.05116281f, 0.00445173f, -0.31680325f, -0.19154899f, 0.07094485f, 
    -0.06216959f, 0.45170698f, 0.36553422f, -0.27762198f, 0.36363515f, -0.04004992f, 0.15552118f, 0.32687259f, 
    -0.10750841f, 0.15297982f, 0.17388900f, 0.02862295f, -0.05149353f, 0.43859068f, 0.20326939f, -0.00891871f, 
    -0.08554091f, -0.14143279f, -0.32458907f, 0.08041528f, 0.34837577f, -0.31766486f, -0.42635688f, -0.20815215f, 
    -0.00803689f, 0.06636112f, 0.07517193f, 0.07286253f, 0.00838703f, -0.17727463f, -0.21464291f, 0.24181893f, 
    -0.22089337f, -0.00000734f, -0.02975524f, 0.06378159f, 0.07990421f, -0.10820431f, -0.01784446f, 0.69258982f, 
    0.30299082f, -0.74780434f, -0.09624306f, 0.51408064f, -0.23686238f, 0.06490953f, 0.16349407f, 0.03604238f, 
    -0.07582312f, -0.07815050f, 0.02832155f, -0.00169957f, 0.01157423f, -0.01271572f, 0.01845469f, -0.02141048f, 
    -0.02346915f, -0.08430140f, 0.01268810f, -0.06180213f, 0.06291558f, -0.06470425f, -0.04698994f, -0.05889722f, 
    0.01435024f, 0.00035919f, 0.02291782f, -0.04141986f, 0.02508257f, 0.04612923f, -0.04147898f, 0.02095547f, 
    -0.00427750f, 0.04547780f, -0.00088741f, -0.01486291f, 0.02156388f, -0.04900505f, -0.06539980f, 0.07484610f, 
    0.06794546f, 0.03021096f, -0.06808872f, -0.02730331f, -0.02146702f, -0.05255637f, -0.05971792f, 0.04263022f, 
    -0.02785332f, -0.02580286f, -0.07145558f, 0.04190676f, -0.04743833f, 0.01621496f, 0.02929230f, -0.03975215f, 
    -0.02322192f, 0.00735566f, -0.05130265f, 0.04949387f, 0.01038825f, -0.07585223f, 0.03913270f, -0.03910279f, 
    0.07571428f, 0.06175612f, -0.01224096f, -0.05188322f, -0.00029524f, -0.06959333f, -0.05064300f, -0.00305885f, 
    0.06819233f, -0.04332216f, -0.05784515f, -0.06761925f, -0.02904737f, 0.06253673f, 0.00099116f, -0.02612236f, 
    -0.01278238f, 0.07022700f, -0.05286519f, 0.02824905f, -0.06313332f, -0.02279601f, 0.01639515f, 0.03943797f, 
    -0.07207504f, 0.01100189f, 0.00441487f, -0.02838453f, -0.00880389f, 0.07739326f, -0.02661287f, -0.05406006f, 
    0.02261181f, -0.03607157f, -0.02955433f, -0.02991727f, -0.08715303f, -0.00081196f, -0.07291459f, 0.04501835f, 
    0.02688015f, -0.02408447f, -0.00479246f, 0.06709571f, -0.02421823f, -0.05232026f, 0.01516555f, -0.08850358f, 
    -0.03789482f, 0.03947317f, -0.01252389f, 0.03369482f, -0.08344930f, -0.06424183f, -0.03036143f, 0.00518963f, 
    -0.05492233f, 0.03722212f, -0.03969606f, 0.02332617f, -0.07541657f, -0.06305641f, -0.02635680f, -0.03980784f, 
    -0.00756623f, 0.05197462f, 0.00257175f, -0.02842086f, -0.03069673f, 0.05173170f, -0.04422058f, -0.08285251f, 
    -0.08352888f, -0.03186902f, -0.05666026f, 0.04986104f, -0.06099506f, 0.01264614f, 0.00592406f, 0.06044890f, 
    0.04346678f, 0.05932926f, 0.01600463f, -0.01548327f, 0.07150753f, 0.01983734f, 0.02523046f, -0.02013050f, 
    0.42679134f, 0.54124773f, 0.38162374f, -0.43385434f, 0.23257069f, -0.18622808f, -0.16269422f, -0.14008529f, 
    0.02272012f, 0.12316073f, 0.06770793f, 0.11673378f, 0.14637181f, 0.06647889f, 0.14747013f, 0.34345186f, 
    0.14481692f, 0.26939932f, 0.01295058f, -0.08715024f, 0.23618501f, 0.15588288f, 0.18849829f, 0.08095197f, 
    -0.02480651f, 0.21062474f, 0.34550494f, -0.04790578f, -0.11276708f, -0.04944309f, 0.01248410f, -0.06088255f, 
    0.04532284f, -0.08456831f, -0.27511436f, -0.00556742f, -0.09471893f, 0.39982343f, -0.25706095f, 0.00931973f, 
    0.07251796f, -0.24808781f, -0.33335441f, -0.34076738f, -0.19724692f, 0.25766751f, -0.32420433f, 0.84710872f, 
    -0.19281241f, 0.23539585f, 0.09216306f, 0.05097259f, 0.28801459f, -0.00261014f, -0.06950603f, -0.20747086f, 
    -0.03178494f, 0.00685003f, 0.06469065f, -0.11781701f, 0.20371519f, 0.13676448f, 0.20402059f, 0.17380175f, 
    0.31486508f, 0.14571375f, 0.02477942f, -0.21548396f, 0.11565224f, 0.25169489f, 0.04221428f, -0.28653508f, 
    -0.34778163f, -0.50626212f, 0.05440333f, -0.13290910f, -0.24697252f, -0.16523817f, 0.04019985f, 0.01755181f, 
    -0.20370133f, -0.39716631f, -0.02847295f, -0.12202604f, 0.04528400f, -0.05589718f, -0.03332588f, 0.13376702f, 
    -0.05413459f, 0.01242882f, 0.00760493f, -0.19063117f, -0.08529065f, 0.28596839f, -0.07090101f, 0.04916381f, 
    -0.50968456f, -0.42828044f, -0.44452125f, 0.10426939f, -0.02125405f, 0.56352323f, 0.02030992f, -0.23466563f, 
    -0.09564539f, 0.33508879f, 0.00798780f, 0.16528340f, -0.27828181f, -0.73972487f, 0.45027718f, -0.18425718f, 
    -0.14941917f, -0.12752056f, -0.08188872f, 0.03415270f, -0.04875901f, 0.00066976f, 0.09376799f, 0.15228985f, 
    0.21604246f, 0.09960121f, -0.06089449f, -0.12096243f, -0.00348060f, 0.20392047f, 0.19976945f, -0.04648824f, 
    0.43884876f, -0.38677162f, 0.21132965f, -0.00601654f, 0.21936502f, -0.04097078f, 0.15267016f, -0.00060188f, 
    -0.21724837f, 0.65295988f, -0.12649630f, -0.13168164f, -0.04060636f, -0.06594082f, 0.10442058f, 0.11351550f, 
    0.21273229f, 0.32851788f, -0.24728259f, 0.06960382f, -0.11387198f, -0.18569657f, -0.17924297f, -0.16228643f, 
    -0.00632203f, -0.08909676f, 0.41369221f, 0.03491929f, -0.04398057f, 0.23869607f, 0.03436879f, 0.01181143f, 
    0.04169061f, -0.03300187f, 0.22465037f, -0.51134658f, 0.01790228f, 0.11252859f, -0.00618011f, 0.12123200f, 
    0.20524558f, 0.29313403f, 0.22188334f, -0.06320751f, -0.16097640f, -0.29899275f, 0.09426272f, 0.07694614f, 
    -0.09228598f, 0.12296664f, -0.29876816f, -0.15308303f, -0.15495856f, -0.27008340f, 0.27921858f, -0.01404123f, 
    -0.05094191f, -0.12464102f, -0.25662228f, -0.01001145f, -0.25376645f, 0.35030207f, -0.19940905f, -0.82232273f, 
    -0.04071378f, 0.18418229f, 0.29397988f, 0.00056819f, 0.03609513f, 0.14410433f, 0.02285378f, 0.08328132f, 
    0.23807187f, 0.33525503f, 0.08504601f, -0.24929242f, 0.33150640f, 0.12687548f, 0.25293970f, -0.20253429f, 
    -0.45108858f, -0.25277743f, -0.16454734f, 0.17722249f, -0.11831141f, -0.07871261f, 0.01671621f, -0.01508519f, 
    -0.29533175f, -0.22386821f, 0.47997218f, 0.24954076f, -0.08159274f, -0.04148177f, 0.11384991f, 0.15576871f, 
    0.22493111f, 0.15666530f, 0.22962072f, 0.12215562f, -0.24557815f, -0.00258799f, 0.05382535f, 0.02708199f, 
    0.13893922f, -0.16173805f, -0.22585529f, 0.08285902f, -0.06136612f, 0.12730080f, 0.03293236f, 0.08149751f, 
    0.03445819f, -0.01257061f, -0.17401266f, 0.45514271f, -0.36422691f, 0.05711976f, -0.10043929f, 0.01381265f, 
    0.02313926f, 0.10117137f, -0.08179112f, 0.03414784f, -0.15121886f, 0.27173010f, -0.09212073f, -0.08496245f, 
    -0.17982446f, -0.05059608f, 0.00132775f, 0.15043493f, -0.19771840f, 0.06555103f, -0.55992663f, -0.35171863f, 
    0.06451475f, -0.03517197f, -0.13436952f, -0.12335417f, 0.08835756f, 0.03738421f, 0.48953316f, -0.28920352f, 
    -0.49655995f, 0.13248023f, 0.10823786f, 0.24403252f, -0.01967134f, -0.14719453f, 0.01156610f, -0.37267309f, 
    -0.20827875f, 0.43109342f, 0.20709814f, 0.25769114f, 0.57174754f, 0.16202417f, 0.03735507f, 0.06414843f, 
    0.24660946f, 0.19941553f, 0.02305159f, -0.01688325f, -0.13936628f, 0.08123563f, 0.16344224f, 0.07309639f, 
    0.15634349f, -0.08666909f, 0.20155539f, 0.44362971f, -0.12239512f, -0.05199605f, -0.20596388f, 0.11378893f, 
    -0.09433971f, -0.03045233f, 0.26711416f, -0.27294856f, -0.11017083f, 0.18639781f, -0.03766435f, -0.12874161f, 
    0.03522393f, -0.09649276f, -0.29374525f, 0.08134972f, 0.15461019f, 0.00616075f, 0.03644785f, 0.12635310f, 
    -0.34780312f, 0.14408344f, 0.31926069f, 0.07915261f, -0.07218356f, 0.58345175f, 0.25760138f, -0.09165334f, 
    0.10327435f, 0.03648372f, 0.05213742f, -0.00225126f, 0.17547698f, 0.85466456f, -0.60089886f, -0.22580603f, 
    0.02489041f, -0.03871895f, -0.35112301f, 0.01374492f, -0.04572085f, -0.16192597f, -0.02370130f, 0.07628581f, 
    0.02590792f, -0.02915145f, 0.14560388f, -0.39393356f, 0.02586834f, 0.12565458f, -0.04126900f, 0.62619191f, 
    -0.07214180f, 0.36744165f, -0.12003691f, -0.01196956f, 0.21808606f, 0.07834424f, -0.15109809f, 0.26803473f, 
    -0.22205637f, 0.05580489f, 0.11279628f, -0.12269424f, 0.40779474f, 0.22451243f, -0.12798370f, 0.05024084f, 
    -0.06303933f, -0.50151384f, -0.26719949f, 0.07139725f, -0.17278001f, 0.02647632f, 0.01770927f, 0.07327070f, 
    0.17327404f, 0.11706788f, 0.14864315f, 0.03117158f, 0.09231175f, -0.05320847f, 0.05235422f, -0.06692102f, 
    0.61896783f, 0.20377399f, 0.16382053f, 0.30507469f, -0.43752882f, -0.68051642f, -0.03384966f, 0.18822312f, 
    -0.15023315f, 0.17162764f, -0.17559867f, 0.00440409f, -0.12595408f, 0.59696001f, 0.26290089f, -0.14012481f, 
    0.04153563f, -0.11576978f, 0.18602408f, -0.08269534f, 0.20130277f, -0.15022874f, -0.24272907f, -0.14340085f, 
    -0.07772908f, -0.15807396f, 0.32984394f, -0.01206055f, -0.03844384f, -0.10519069f, 0.48177978f, -0.34104162f, 
    -0.42634463f, -0.05413077f, -0.03786080f, -0.11911231f, 0.21944079f, 0.11171006f, -0.12591922f, -0.01561381f, 
    -0.42061460f, 0.16794352f, -0.22511469f, 0.20275019f, 0.33474267f, 0.01555042f, -0.07881182f, -0.21667987f, 
    0.58402890f, 0.01262824f, 0.02011905f, 0.11008664f, 0.01417707f, -0.05033982f, -0.15437563f, -0.07889745f, 
    -0.14552765f, -0.46191770f, -0.55983353f, -0.31548923f, 0.00708864f, -0.09117933f, -0.10894650f, -0.43321618f, 
    -0.16625369f, -0.10869440f, 0.25830573f, 0.21986197f, 0.02766508f, 0.07997206f, 0.20021622f, -0.00673410f, 
    -0.14026606f, -0.16069233f, -0.40948722f, -0.26418725f, -0.24897219f, -0.54696769f, 0.24767625f, 0.02692695f, 
    0.07941147f, 0.14641485f, 0.30095738f, 0.32867754f, 0.26086721f, 0.45618311f, 0.13414671f, -0.37891516f, 
    -0.07860208f, -0.09691501f, 0.12123561f, 0.33782190f, 0.18805069f, 0.60839218f, 0.19808082f, -0.12987904f, 
    0.25794220f, 0.13620101f, 0.03309160f, -0.14270128f, 0.12900457f, -0.10134637f, 0.23166792f, 0.24313198f, 
    -0.19677931f, 0.00345182f, -0.09713823f, 0.00662588f, 0.29133841f, 0.16464294f, -0.22053948f, 0.12745242f, 
    0.22999853f, 0.35380328f, -0.12639433f, -0.20497380f, 0.04811670f, 0.00115088f, -0.03286252f, 0.31762624f, 
    -0.14127474f, -0.05218455f, -0.14146270f, -0.30522180f, -0.10448778f, 0.13595967f, -0.01117598f, -0.18218039f, 
    0.29262811f, -1.12851346f, -0.39717844f, -0.36644539f, -0.32428625f, -0.50653374f, 0.07286528f, -0.05213759f, 
    0.09619761f, 0.24397950f, -0.04546153f, -0.30582356f, 0.24561603f, -0.10043124f, 0.07208708f, 0.06979610f, 
    0.07617487f, 0.27145743f, 0.18428555f, -0.15709294f, -0.33638549f, -0.26534921f, 0.20438857f, 0.19805585f, 
    0.27928340f, -0.11262707f, -0.05317057f, 0.24043684f, -0.01290850f, -0.24543707f, 0.31151807f, -0.26250255f, 
    0.13703647f, 0.03469669f, 0.09720092f, -0.10633743f, 0.23988721f, 0.16191907f, 0.15539068f, 0.12370382f, 
    0.01031933f, -0.00060576f, -0.31886840f, -0.02321193f, -0.05394987f, -0.22235169f, 0.60838252f, 0.03940700f, 
    -0.19223338f, 0.12519449f, 0.35426581f, 0.30210832f, 0.20984708f, 0.04221895f, -0.11581939f, 0.38285938f, 
    -0.11131807f, -0.24783710f, -0.13459156f, 0.23037672f, -0.03332978f, 0.13191940f, 0.16968590f, 0.20677124f, 
    0.17558213f, 0.28158635f, 0.03221215f, 0.04823424f, -0.06755450f, -0.12588347f, -0.04370731f, 0.00514343f, 
    -0.02018994f, 0.39937994f, 0.12739441f, 0.26927015f, -0.11521248f, -0.29930866f, -0.20539936f, -0.12774710f, 
    -0.04627964f, 0.01029932f, -0.40689826f, -0.25011984f, -0.74761343f, -0.04059717f, 0.06543166f, -0.16669218f, 
    -0.23868570f, -0.14444135f, -0.13277094f, 0.15728502f, -0.03643971f, 0.08856573f, 0.16285138f, 0.06992370f, 
    -0.08517674f, -0.12778209f, -0.21314046f, 0.07879975f, -0.34321809f, -0.27531227f, 0.66277570f, -0.03496000f, 
    -0.26523212f, -0.08616635f, -0.00120541f, 0.00712689f, 0.17568325f, -0.09461650f, -0.18183732f, -0.44904244f, 
    -0.21835180f, -0.04137371f, -0.40180391f, -0.15769146f, -0.07724337f, 0.01071110f, -0.17638567f, -0.24197641f, 
    0.24194634f, 0.00611804f, 0.15265046f, -0.05602603f, 0.26078555f, -0.12221485f, 0.00208990f, -0.45270145f, 
    -0.16791750f, 0.67091125f, 0.34646109f, -0.06822417f, 0.12892768f, 0.05511678f, 0.03089464f, -0.16607873f, 
    0.38124815f, 0.13448909f, 0.28010523f, -0.09357963f, -0.09860349f, 0.24617860f, 0.17699902f, -0.07444602f, 
    -0.09267706f, 0.81590784f, 0.45193720f, 0.12402662f, -0.10621681f, -0.20719928f, -0.20467828f, 0.08423182f, 
    0.09136937f, 0.06853778f, 0.11364786f, 0.03325484f, 0.13950416f, -0.00366916f, 0.10213172f, 0.03130902f, 
    0.01443604f, -0.05360634f, -0.08789194f, -0.12462022f, -0.58538222f, -0.69152397f, 0.16595380f, -0.02055016f, 
    -0.01459373f, -0.01689369f, -0.10810675f, 0.19090439f, 0.28440621f, -0.26329839f, 0.57716429f, -0.06638522f, 
    -0.18666360f, -0.22694045f, -0.07312360f, -0.03624036f, -0.09307272f, -0.25896624f, -0.30133155f, -0.41339475f, 
    -0.02220903f, -0.07951397f, 0.38927752f, 0.06331232f, 0.01762952f, -0.10206129f, 0.04578226f, -0.17025290f, 
    0.22819246f, -0.03149629f, -0.08331452f, -0.06589673f, 0.19087633f, 0.16981538f, 0.04454569f, 0.42507851f, 
    -0.57006806f, -0.07395248f, -0.28779474f, 0.24233377f, 0.34951499f, -0.12840991f, 0.36457551f, -0.01617569f, 
    -0.35810959f, -0.41675913f, -1.01387858f, -0.23325884f, -0.04604707f, -0.15611763f, -0.04975525f, -0.09500309f, 
    -0.09615183f, 0.01507480f, 0.06874059f, 0.10267056f, -0.13679305f, -0.11477479f, -0.30959421f, -0.01868452f, 
    0.02787869f, 0.13552961f, 0.17621207f, 0.15702280f, 0.11771993f, 0.08203339f, 0.03089326f, 0.11636908f, 
    -0.07485487f, -0.00956282f, -0.02542787f, -0.13941018f, 0.03122908f, 0.33052105f, 0.00614334f, 0.16966707f, 
    0.28799954f, -0.07030974f, -0.00725275f, 0.27562174f, -0.49475580f, -0.45782751f, -0.68071055f, -0.26353979f, 
    -0.18478405f, -0.12605059f, 0.06991726f, 0.05966166f, 0.13154542f, -0.56629527f, -0.58541685f, -0.01351553f, 
    0.02249421f, 0.09051382f, -0.11770993f, -0.10602397f, 0.00358949f, -0.00613630f, 0.33982587f, 0.26930657f, 
    0.51069075f, 0.30823183f, 0.39169437f, 0.14660673f, 0.24545093f, 0.19967704f, 0.19580415f, -0.60299671f, 
    0.16136871f, -0.21757960f, -0.52659541f, -0.04002123f, -0.25641790f, 0.07077566f, -0.03884847f, -0.04188541f, 
    -0.00031787f, 0.33471024f, 0.20694016f, 0.09251378f, 0.34326389f, 0.11260029f, 0.45095658f, 0.11730146f, 
    0.09762434f, -0.09485775f, -0.18068016f, 0.16916054f, -0.00782447f, -0.04962612f, 0.09239358f, -0.03497463f, 
    0.10338825f, 0.01800952f, -0.21218887f, -0.05354438f, -0.01895006f, 0.19149482f, 0.06919970f, -0.04153017f, 
    0.04370727f, 0.16048045f, 0.22530495f, -0.03049146f, 0.10888251f, 0.84435570f, 0.25973254f, 0.17322925f, 
    -0.34995455f, -0.08653103f, -0.14085262f, 0.13516498f, -0.09747311f, -0.05450555f, 0.25908309f, 0.13642634f, 
    -0.16861615f, -0.23971497f, -0.01572522f, -0.08950865f, -0.13535212f, -0.51582700f, -0.14274108f, -0.49441180f, 
    -0.09217495f, 0.20728852f, -0.04129694f, 0.04114205f, 0.18044963f, -0.03781411f, -0.31476384f, 0.07113925f, 
    0.32612893f, 0.19223526f, 0.05320179f, 0.11688562f, -0.04079689f, -0.08988874f, 0.00638820f, 0.06392099f, 
    0.32398719f, 0.46079910f, -0.08837000f, 0.20986070f, 0.26893941f, 0.07084810f, -0.14610733f, 0.21988110f, 
    -0.40918967f, -0.11928094f, 0.33685553f, -0.07873791f, -0.26550519f, -0.29138511f, -0.08052504f, 0.03768449f, 
    -0.05459534f, 0.04184126f, -0.14654705f, 0.28131142f, -0.16796640f, -0.13125725f, -0.11419061f, -0.03524937f, 
    0.22785518f, 0.23622373f, 0.28170070f, 0.49429119f, 0.18813173f, 0.28700164f, 0.10707273f, 0.08569465f, 
    0.10630764f, -0.08757264f, 0.21140195f, -0.23538639f, -0.08371390f, -0.16510394f, -0.03901699f, 0.11331435f, 
    0.05166154f, -0.16383652f, 0.23972856f, 0.18343331f, 0.00162141f, -0.27182174f, -0.42871097f, -0.35731304f, 
    -0.08063154f, -0.16236378f, -0.29131147f, -0.15312479f, 0.10409423f, -0.47260728f, 0.59101570f, 0.09721436f, 
    0.20741184f, 0.00369453f, -0.10521731f, 0.07549638f, -0.11233790f, 0.05769107f, 0.11976510f, 0.33147466f, 
    0.62736946f, 0.29091582f, -0.03539219f, -0.03645156f, 0.34634730f, 0.29684874f, 0.12830855f, -0.01122957f, 
    -0.21061583f, 0.06386854f, -0.26843658f, 0.18646915f, -0.13841894f, 0.14948715f, 0.06646822f, -0.33477670f, 
    0.33370936f, -0.12351913f, 0.77185476f, 0.19236341f, 0.07081626f, -0.03629591f, 0.05343803f, 0.13389136f, 
    0.02736368f, -0.08172387f, -0.27117595f, 0.39143023f, -0.35865593f, -0.10215788f, -0.13648945f, 0.15738279f, 
    0.08386552f, 0.13641183f, -0.28209051f, -0.05255048f, -0.04083833f, 0.11385747f, 0.00104479f, 0.11953351f, 
    0.13480519f, 0.23753874f, 0.11993721f, -0.34168258f, -0.25628331f, -0.00916680f, 0.06603193f, 0.04033707f, 
    0.10735716f, 0.10916250f, 0.04684095f, -0.04948022f, -0.02852127f, -0.65089613f, 0.23580784f, -0.25349164f, 
    -0.09036160f, -0.36414358f, 0.03695376f, -0.24790706f, 0.20171991f, -0.08723250f, -0.06135214f, 0.58683795f, 
    -0.27554435f, -0.12661146f, 0.32907435f, 0.14460567f, 0.08783154f, -0.01362361f, -0.28629088f, 0.06910900f, 
    0.53180468f, 0.13055851f, 0.18271783f, -0.11739984f, 0.13052808f, 0.14409482f, 0.05692901f, 0.32630616f, 
    0.46060821f, 0.46021128f, -0.16816323f, -0.09880918f, 0.20262338f, 0.39610550f, 0.26904079f, 0.12508027f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.02841586f, -0.00002176f, 0.12138397f, -0.16686974f, 0.42162678f, 0.41924283f, 0.06247052f, 0.42707589f, 
    -0.04161701f, -0.08607436f, 0.10635422f, 0.20946419f, -0.13308086f, 0.32336396f, 0.37004772f, 0.44076467f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.44614303f, 0.04928589f, -0.89682037f, 0.37059492f, -0.01309011f, -0.02341799f, 0.10119769f, -0.07153805f, 
    -0.14866513f, 0.25282392f, -0.25794208f, 0.44078705f, 0.68102872f, 0.07349253f, -0.29837275f, -0.75924772f, 
    -0.53172386f, 0.18349871f, -0.65042186f, -0.53489077f, 0.24030025f, -0.22669040f, 0.10018555f, 0.13806194f, 
    0.02735117f, -0.14869750f, -0.49873906f, 0.18241964f, 0.48423564f, 0.66278368f, -0.09069955f, 0.39214796f, 
    -0.34344646f, -0.16508953f, 1.00707996f, -0.34895265f, 0.28958806f, 0.29163548f, -0.70527428f, 0.26972702f, 
    -0.15378265f, 0.31871441f, -0.61108905f, -0.40652421f, -0.30761638f, 0.04020440f, 0.09725946f, 0.33600557f, 
    0.01047169f, 0.08403803f, 0.49323016f, 0.25699276f, -0.41929674f, 0.01946887f, -0.70693809f, -0.87669313f, 
    0.14926943f, -0.01491378f, 0.24295273f, 0.58902556f, 0.20696770f, -0.30440214f, -0.82569385f, 0.24820594f, 
    0.00485419f, -0.18140779f, -0.10413336f, 0.13346441f, 0.15058286f, -0.01448828f, 0.54729319f, -0.06000263f, 
    -0.07153124f, 0.41706854f, 0.04202154f, -0.07922804f, -0.17754929f, 0.08465950f, -0.71161479f, -0.28731993f, 
    0.47283638f, -0.18110745f, -0.25856072f, 0.15223122f, 0.02480866f, 0.08408987f, 0.29111078f, 0.25479466f, 
    -0.02426727f, -0.45154330f, -0.58452338f, 0.20915549f, 0.10355380f, 0.05595017f, -0.29293498f, 0.11230633f, 
    0.48032567f, 0.13212839f, -0.19990949f, -0.04384701f, 0.61249512f, -0.25863552f, -1.39803278f, 0.45586523f, 
    -0.23317206f, 0.02319179f, 0.23341639f, -0.89026850f, -0.66082054f, -0.86566776f, 0.31029436f, -0.11923075f, 
    -0.14409170f, -0.17816487f, -0.34745243f, -0.10168749f, -0.71227854f, -0.66223085f, -0.36822069f, 0.56863624f, 
    -0.15125363f, 0.01524956f, 0.46949354f, 0.44966090f, -0.19675416f, 0.31172895f, -0.40513542f, -0.08278035f, 
    0.34401366f, 0.04049047f, -0.40515187f, -0.81078273f, -0.54387218f, 0.18867970f, 0.15188171f, -0.07280744f, 
    -0.10614380f, -0.82124513f, 0.53801358f, 0.40820098f, -0.05542764f, 0.00820197f, 0.35507759f, -0.09045480f, 
    -0.04674422f, -0.23231576f, -1.09872317f, 0.36678126f, 0.13223711f, 0.77137226f, -0.23758686f, -0.27899382f, 
    0.23635620f, 0.14995305f, 0.43383846f, -0.41912550f, -0.77777123f, -0.31294969f, -0.20550597f, 0.14772238f, 
    -0.29038909f, -0.01540876f, 1.05850410f, -0.37420037f, 0.07811414f, -0.60399103f, 0.71153086f, 0.15536363f, 
    0.01947543f, -0.55118036f, -0.33424562f, 0.60228354f, -0.29551545f, -0.54229337f, 0.40151289f, -0.29148251f, 
    0.52175027f, 0.19188307f, -0.42380720f, -0.51624453f, -0.05992053f, -0.85607290f, -0.14445463f, -0.89337987f, 
    -0.08490442f, 0.07738791f, -0.02261068f, -0.39188087f, -0.50111818f, 0.46950886f, 0.40070078f, 0.46485725f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.39417765f, 0.47078928f, 0.17874782f, 0.00255417f, -0.02499582f, -0.02396704f, -0.21339761f, -0.61115295f, 
    0.01566423f, 0.41255245f, -0.21405977f, -0.10194969f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
