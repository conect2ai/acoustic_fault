#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.26334846f, -1.25067663f, -1.31925321f, 0.90271050f, -0.73941463f, -0.50427824f, -0.53939044f, 0.11293643f, 
    -0.41008702f, -0.86836386f, 1.64227128f, -1.12765944f, 0.36068493f, -0.72169709f, -0.98886371f, -0.31049073f, 
    -0.40263095f, -0.86610061f, 1.05496979f, 0.54299951f, -1.13430107f, 1.18807089f, -0.93554485f, 0.48123801f, 
    0.78604054f, 0.48114434f, 0.57282263f, 1.33349514f, 1.36268520f, 1.22449827f, -1.49472845f, -0.92213202f, 
    -0.30365703f, 0.41278976f, 0.48697260f, -0.27068675f, -0.52499193f, -0.26502064f, 1.03963137f, -1.47253597f, 
    -1.00437891f, -0.66850245f, 0.39952487f, 0.55047452f, -0.34242910f, -0.91801357f, -1.62265944f, 0.16127802f, 
    1.23800755f, -0.13193825f, 0.93162131f, 0.21697402f, -0.17982604f, -0.19623914f, 0.48416445f, 2.33440351f, 
    -0.00896236f, -0.60033965f, 1.15669227f, 0.06460423f, 0.13651605f, 0.27700740f, -0.32399380f, -0.98800105f, 
    1.02609801f, -0.01561427f, 0.73086673f, 1.15156662f, 1.15714467f, -0.12227751f, -0.65638167f, -0.40060008f, 
    -0.74934620f, -1.75877094f, -0.09608975f, -0.14322834f, 1.12489045f, 0.77463472f, -0.26870728f, -0.61874849f, 
    -0.48565453f, 0.50388253f, -0.61212838f, -0.59670442f, 1.35108340f, 1.51462746f, -0.83345914f, 0.06335820f, 
    -0.09237470f, -0.60735732f, -0.71930391f, -1.58734560f, -0.43479532f, -0.76820052f, 0.46892625f, 0.22530288f, 
    0.93173897f, 0.32671577f, 0.19755265f, -0.44979188f, -0.57168621f, -1.31620347f, -1.09583855f, 1.25370514f, 
    0.81578720f, -0.16644022f, -0.41071907f, -0.12037855f, 1.31730890f, 0.68867719f, 1.09661782f, 1.15940571f, 
    0.62307298f, 0.65051454f, -0.60565388f, 0.25422186f, -0.73442739f, -1.55535543f, 1.08444726f, 1.74584329f, 
    0.33433875f, 1.23923433f, -0.38795194f, -0.03033555f, 0.41161746f, 0.12459861f, -1.30393064f, -0.31600079f, 
    -1.02024460f, 0.51005429f, 1.36436594f, -0.14570889f, -0.15947805f, -0.22628222f, 0.41260785f, -0.27530330f, 
    -1.34372675f, -1.01412129f, -1.12417257f, -1.06772494f, -0.21017113f, 0.35684687f, 0.36899227f, -0.00318531f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.42857197f, -0.08937509f, 0.33002332f, 0.09220377f, 0.37647524f, 0.10042393f, 0.44363171f, 0.04598706f, 
    0.28594384f, 0.35637051f, 0.27046543f, 0.03114856f, 0.29662681f, 0.26234919f, 0.04398463f, 0.36543903f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.35042667f, -0.99719232f, 0.24531133f, 0.14527942f, -0.00359671f, 0.00562452f, -0.08001805f, 0.08586535f, 
    -0.03895029f, -0.15282343f, -0.36778173f, -0.00921489f, 0.05063840f, 0.07009819f, -0.08593878f, -0.08425378f, 
    0.07530256f, -0.03107671f, -0.04270935f, 0.02440659f, 0.38257048f, -0.04376569f, 0.42842650f, 0.02591502f, 
    0.20948076f, -0.10544232f, -0.24163695f, 0.15031351f, 0.04817705f, -0.05210846f, 0.10627356f, 0.09480114f, 
    -0.18789059f, -0.02090682f, -0.18920378f, -0.03112016f, 0.08285962f, 0.18836714f, -0.08702181f, -0.15873137f, 
    0.14635994f, -0.63174164f, -0.04417530f, -0.10623338f, 0.21957646f, -0.18887727f, 0.10330496f, 0.08700483f, 
    -0.02114938f, -0.11610277f, 0.07223536f, 0.01457235f, -0.01018470f, 0.07378851f, 0.16165918f, 0.09261100f, 
    -0.21189691f, 0.11935554f, -0.01047674f, 0.05073596f, 0.18266019f, 0.12966695f, -0.10940466f, -0.00260500f, 
    0.36736828f, -0.23850714f, -0.21493614f, -0.16577189f, 0.10774455f, 0.01238658f, 0.04297134f, -0.10333630f, 
    -0.03921983f, -0.12259085f, 0.02850620f, -0.00944545f, -0.03075323f, -0.05495099f, 0.08330996f, 0.12178113f, 
    -0.06279936f, -0.24248986f, -0.15268379f, 0.27214441f, -0.25760889f, -0.03326940f, -0.09208274f, -0.08739013f, 
    0.02240770f, 0.03083931f, -0.07191584f, 0.11815476f, 0.13825357f, -0.10084981f, -0.04811847f, 0.08425099f, 
    0.05641407f, -0.09164253f, -0.07304066f, -0.01587878f, -0.02162522f, -0.18168592f, 0.19385940f, -0.20468895f, 
    -0.41883940f, 0.12011170f, 0.27157569f, 0.12701645f, 0.02767077f, 0.05212089f, -0.01103147f, 0.04034989f, 
    0.04111804f, -0.03148150f, -0.09860703f, 0.07398643f, -0.03538284f, 0.01156093f, 0.11239340f, -0.02566549f, 
    0.02146618f, 0.11579871f, 0.00738683f, -0.53392756f, 0.66527456f, -0.14553972f, -0.10988326f, 0.03494529f, 
    0.06058371f, 0.03753502f, -0.13178538f, -0.12459284f, -0.07908031f, -0.20246953f, 0.17849316f, -0.30631143f, 
    -0.00888619f, 0.00358893f, -0.06635340f, -0.03871422f, 0.47169551f, 0.08369672f, 0.20823608f, -0.09679244f, 
    0.19174854f, 0.08141774f, 0.08795060f, 0.09572059f, -0.01579861f, -0.11913658f, -0.04295034f, -0.13577175f, 
    -0.14463398f, -0.11824709f, 0.18755327f, -0.02010131f, 0.17515893f, -0.32371768f, 0.09146626f, 0.06529362f, 
    -0.28833902f, 0.16238150f, 0.10594550f, -0.22395702f, -0.54533905f, 0.05370354f, 0.09737538f, -0.02920136f, 
    0.08656023f, -0.04292561f, 0.09044148f, -0.03813889f, -0.08738790f, -0.03719292f, -0.03290166f, 0.02564623f, 
    0.03492257f, -0.06623769f, 0.01689054f, 0.11692622f, -0.30407283f, 0.34619719f, 0.08879963f, -0.04518228f, 
    0.16936910f, -0.03810966f, -0.13725753f, -0.00003861f, 0.02934988f, -0.13944574f, 0.10317586f, 0.24399909f, 
    0.08021395f, 0.08488023f, -0.02178312f, 0.01373301f, 0.02108998f, 0.12792049f, -0.01651557f, 0.06062469f, 
    -0.52306622f, -0.18069527f, -0.41036838f, 0.19965483f, -0.23121414f, -0.10508902f, -0.29404229f, 0.07556412f, 
    0.02618332f, -0.05938648f, 0.06705448f, 0.13054524f, -0.12692876f, 0.04168788f, 0.14192478f, -0.09446859f, 
    -0.03536805f, -0.12765311f, -0.00964514f, 0.03992565f, -0.55124080f, 0.55574143f, 0.00643170f, -0.26935866f, 
    -0.16734843f, 0.07442005f, 0.04917923f, -0.10254040f, -0.02632162f, 0.02233149f, -0.01449847f, 0.10063548f, 
    0.02481110f, 0.14714751f, -0.04172828f, -0.13477957f, -0.01301401f, -0.07288636f, -0.06738666f, 0.01651248f, 
    0.19579579f, -0.03400960f, -0.07249518f, -0.01122667f, 0.05460054f, -0.17260897f, -0.23104361f, 0.02376504f, 
    0.03601669f, -0.10728000f, -0.02077957f, 0.06400748f, 0.03891385f, 0.09656161f, -0.04172512f, 0.06251667f, 
    -0.05450096f, -0.07779941f, -0.08873801f, 0.00826012f, -0.28314823f, 0.04460274f, 0.46983024f, 0.17038824f, 
    0.01039685f, 0.03139371f, -0.17241606f, 0.11451912f, -0.06113391f, -0.04159710f, 0.10729742f, 0.01906668f, 
    0.05173692f, 0.06104454f, -0.08647027f, -0.02540501f, -0.16801628f, 0.00902719f, -0.14514887f, -0.08838335f, 
    0.78111178f, 0.27581331f, 0.14399555f, -0.30696946f, -0.65924835f, 0.01698780f, 0.08881533f, -0.11813816f, 
    0.03097359f, -0.11304018f, 0.08021301f, 0.09967171f, -0.14394467f, 0.13369103f, 0.08739671f, 0.01866138f, 
    -0.02614048f, 0.06659801f, -0.02799130f, -0.02588863f, -0.27928942f, -1.08559549f, 0.00206837f, 0.17380024f, 
    -0.36526784f, -0.07647444f, -0.13506331f, 0.16288286f, 0.04690008f, 0.07359720f, 0.01278660f, -0.03390772f, 
    -0.08434384f, -0.18477938f, 0.08171690f, 0.04135205f, -0.08892704f, -0.03926720f, 0.14093441f, 0.02671649f, 
    0.27644491f, -0.39213532f, 0.16914392f, -0.46928290f, -0.10118419f, -0.11865853f, 0.27361491f, -0.08947033f, 
    -0.00953955f, 0.14588085f, 0.00529064f, -0.12870176f, 0.04108971f, -0.01697441f, -0.10439453f, -0.09396522f, 
    0.01182317f, -0.28792271f, 0.01061639f, -0.07322125f, -0.50028437f, -0.38222659f, -0.99760121f, -0.56914562f, 
    0.30134103f, 0.14120823f, -0.12380574f, 0.00059720f, -0.25931540f, 0.01437238f, 0.07780026f, -0.03932302f, 
    -0.01799439f, -0.28334591f, 0.16324139f, -0.04706280f, -0.15938416f, -0.15141021f, 0.02703473f, -0.14624207f, 
    -0.00614977f, -0.25393844f, 0.27253890f, -0.00799179f, 0.21587816f, -0.07029179f, -0.18588237f, -0.01955986f, 
    -0.02626357f, -0.13923055f, 0.14524241f, 0.06864794f, 0.01882715f, 0.00064476f, -0.12086229f, 0.00792427f, 
    0.13478947f, -0.15274017f, 0.04257173f, -0.10960479f, 0.08418777f, 0.09282912f, -0.12063341f, 0.24765177f, 
    0.00467104f, -0.03174128f, -0.05362889f, -0.03498715f, -0.00363823f, -0.03463419f, -0.06086395f, 0.04893683f, 
    -0.02829184f, 0.21016610f, -0.10884949f, 0.04621870f, -0.03311137f, -0.05424856f, -0.21063384f, -0.04172012f, 
    -0.63826996f, -0.21974511f, -0.17503993f, -0.03208123f, -0.43947673f, 0.03603316f, -0.01979478f, 0.01664420f, 
    -0.00245796f, -0.03509623f, -0.03900960f, 0.00195547f, -0.00588048f, 0.08092578f, -0.05622883f, -0.16027485f, 
    -0.01477413f, -0.18625724f, -0.15295427f, 0.01666061f, 0.06345578f, 0.23650713f, -0.14500338f, 0.15661784f, 
    -0.45993295f, 0.09114251f, -0.05136195f, -0.07551567f, -0.25471064f, 0.17186472f, 0.13432412f, 0.06714370f, 
    -0.01059278f, 0.10952644f, 0.10292035f, 0.06287749f, 0.20146435f, -0.10602030f, -0.02120248f, 0.00379659f, 
    0.34842381f, 0.23305418f, -0.00025696f, -0.10408778f, 0.27068666f, -0.22663642f, -0.01024513f, 0.02369130f, 
    0.01691542f, -0.04652632f, 0.16746508f, -0.09251456f, 0.07073094f, 0.20920426f, -0.01522526f, 0.05698263f, 
    -0.00180574f, 0.04929760f, -0.09934428f, 0.04865933f, -0.41884601f, 0.08240742f, 0.03758758f, 0.06071393f, 
    0.13316128f, -0.00489770f, -0.00318550f, -0.16199142f, -0.00358519f, -0.11695754f, 0.21905598f, 0.07949367f, 
    0.06070375f, -0.11825959f, 0.14037828f, 0.10921266f, -0.03863464f, 0.14836860f, 0.02342350f, 0.10667754f, 
    0.33553630f, -0.04805417f, -0.12437267f, -0.03400638f, -0.23013014f, -0.14846906f, 0.00444976f, 0.06951585f, 
    -0.05442716f, 0.04952862f, 0.16630395f, 0.12356635f, -0.13051209f, 0.02736504f, 0.02185136f, -0.01279600f, 
    0.02984449f, -0.01720365f, -0.11669754f, -0.10460716f, 0.42531931f, -0.72387600f, -0.14107859f, -0.04789130f, 
    0.00195298f, -0.00543724f, -0.00416442f, -0.01586082f, 0.10720449f, 0.00643532f, -0.10123610f, -0.09320112f, 
    -0.12471192f, -0.12237062f, 0.05639504f, 0.03491260f, 0.01897306f, -0.18169717f, 0.09154788f, 0.00936653f, 
    0.43390960f, -0.17497444f, -0.07564773f, 0.13554066f, -0.13011433f, -0.03382915f, 0.08105087f, 0.14267971f, 
    0.19234759f, 0.01121517f, -0.02195133f, -0.20244491f, 0.09078713f, 0.11278111f, -0.08628944f, 0.27303040f, 
    -0.01023275f, 0.01059126f, -0.04416404f, 0.02395862f, 0.47900814f, -0.39569202f, -0.17403680f, -0.09198225f, 
    -0.17740087f, -0.19245772f, 0.15295070f, -0.08511522f, 0.19805567f, 0.06062334f, 0.05824182f, -0.03517831f, 
    0.01612491f, -0.03813394f, 0.18024132f, 0.00116435f, -0.12440798f, 0.07481633f, -0.22015524f, 0.11763636f, 
    0.59635031f, 0.36259967f, 0.29058680f, 0.10445626f, 0.29969412f, -0.04926618f, -0.06646247f, -0.10563619f, 
    -0.13936059f, 0.12279461f, -0.15207909f, 0.02192767f, 0.04059666f, 0.12854947f, -0.13865350f, -0.05689448f, 
    0.09695122f, 0.08981224f, 0.07963033f, 0.16605823f, -0.83818620f, 0.24876218f, -0.01689679f, -0.16087218f, 
    0.23333265f, -0.26629212f, 0.09335169f, -0.02385521f, -0.10002150f, 0.21710302f, -0.01747335f, -0.01634297f, 
    0.08904742f, -0.19635549f, -0.18738896f, -0.01656998f, -0.06187603f, 0.19717576f, 0.08078730f, 0.05637695f, 
    -0.19841889f, 0.13287719f, -0.31811157f, 0.02066898f, -0.11783286f, 0.19103134f, 0.09440476f, 0.00020208f, 
    0.18086511f, 0.14945315f, -0.03217243f, 0.05110768f, 0.02098265f, -0.11103250f, 0.05999791f, 0.15875682f, 
    -0.00265199f, -0.08270747f, -0.03671090f, 0.03277603f, -0.11511394f, 0.01675872f, 0.00529613f, 0.09120888f, 
    -0.19142602f, 0.10257868f, 0.03201604f, 0.11401425f, 0.29079747f, 0.03397186f, -0.19422832f, -0.17017166f, 
    0.23387274f, 0.37717468f, 0.02321091f, 0.07466214f, -0.08210430f, -0.00492393f, -0.19374499f, -0.17937928f, 
    -0.50033945f, -0.56984270f, -0.06437927f, -0.03906755f, -0.27914897f, -0.04789774f, -0.06852721f, -0.14575198f, 
    0.09620737f, 0.24500197f, 0.06281073f, -0.01526446f, -0.06959490f, 0.08501409f, 0.06448619f, 0.14027007f, 
    -0.03923537f, -0.07528381f, -0.18116733f, -0.01667081f, -0.23130631f, -0.73404735f, -0.29334137f, -0.54947656f, 
    -0.36446920f, 0.02793388f, -0.04791096f, 0.24538681f, -0.12209737f, -0.02387382f, -0.26324692f, 0.01662382f, 
    -0.08594853f, 0.05891038f, -0.27672502f, -0.03603505f, -0.08318065f, 0.17784056f, -0.13637152f, -0.04888874f, 
    -0.04811845f, 0.16912869f, 0.12886256f, -0.18185996f, -0.17569955f, -0.00989442f, -0.23486304f, 0.10822597f, 
    -0.09111844f, 0.05103180f, -0.23524369f, 0.07891967f, 0.04720360f, -0.11746636f, -0.03548769f, 0.13716413f, 
    0.05601474f, 0.06706142f, 0.03470143f, -0.04487582f, -0.28405216f, 0.31033137f, -0.27551764f, -0.25131375f, 
    -0.06986494f, 0.08087553f, 0.27553749f, 0.11749163f, -0.00995402f, -0.26772809f, -0.00523450f, 0.05309710f, 
    -0.03664754f, -0.14049035f, -0.10751065f, -0.11329848f, 0.09329738f, -0.09492861f, -0.04800696f, -0.01608752f, 
    0.24532685f, 0.00674895f, -0.17982507f, -0.19148131f, -0.35138094f, -0.01723614f, 0.15676251f, -0.04891261f, 
    0.03326311f, -0.09271073f, -0.01278526f, -0.26641256f, 0.03695145f, -0.06088600f, -0.14132531f, 0.09067412f, 
    0.08011094f, -0.09893572f, 0.03814097f, -0.20888422f, -0.05069896f, 0.10316020f, 0.30748773f, 0.10817332f, 
    0.35256591f, -0.24938092f, -0.19043565f, -0.36166099f, 0.03483581f, -0.10874863f, 0.03459889f, -0.09864505f, 
    -0.08215378f, -0.18484479f, 0.10559397f, 0.01723885f, -0.03458421f, -0.03412701f, 0.12043444f, 0.09430936f, 
    0.38176918f, -0.07525799f, -0.01476218f, -0.23985219f, 0.03228492f, 0.09446138f, 0.01935403f, 0.14724204f, 
    -0.26991171f, -0.05704856f, -0.07166521f, -0.11234906f, 0.18742119f, -0.01561086f, 0.00985206f, -0.16005415f, 
    -0.03757975f, 0.15785328f, -0.15781324f, -0.07553507f, 0.29320115f, 0.30243987f, 0.02579168f, 0.09832888f, 
    0.18244685f, -0.01928150f, -0.14114228f, 0.04244904f, 0.09534505f, 0.32459357f, -0.09237789f, -0.03164042f, 
    -0.00406456f, 0.03420305f, 0.00090509f, -0.06428817f, -0.01749092f, -0.18954416f, -0.15571493f, -0.10971753f, 
    0.14780775f, -0.07463463f, 0.07669672f, 0.17281538f, 0.25596127f, -0.08441676f, -0.12768136f, 0.01538656f, 
    0.08522201f, 0.00654192f, 0.15307702f, 0.04439505f, -0.03796031f, 0.00816182f, -0.01280598f, 0.10245597f, 
    -0.18667698f, -0.07397080f, -0.06776379f, -0.16909154f, 0.18835799f, -0.50308174f, 0.41613796f, -0.10385630f, 
    0.14644703f, -0.01380108f, -0.11801934f, 0.00988484f, -0.00182067f, 0.09123771f, -0.01964497f, -0.08674636f, 
    0.01991335f, 0.04431573f, -0.07336848f, 0.10417467f, -0.20741895f, 0.00367783f, -0.01449265f, -0.03545363f, 
    0.72193331f, -0.29866457f, 0.16278470f, -0.01090509f, -0.06621899f, -0.36803901f, 0.12476786f, -0.08982269f, 
    -0.05224997f, 0.05982024f, 0.04899461f, -0.21993913f, 0.02885500f, 0.00405155f, -0.06827576f, 0.23165481f, 
    0.05118940f, 0.07533637f, 0.16322017f, 0.05153120f, 0.40559420f, 0.13534756f, -0.10750522f, 0.35784632f, 
    -0.09689555f, -0.10825585f, 0.07436116f, -0.02254321f, 0.04660650f, 0.16059169f, -0.02465798f, 0.02249947f, 
    0.05444399f, 0.14119062f, 0.11636332f, -0.06389695f, -0.14850828f, -0.05086183f, -0.13414811f, 0.03348237f, 
    -0.22798498f, -0.06508993f, 0.14506271f, -0.24774666f, 0.11380299f, 0.16972604f, -0.02621698f, 0.06075355f, 
    -0.02406320f, 0.05699948f, -0.05646515f, -0.03094298f, 0.05637332f, -0.08546446f, -0.08162695f, -0.06844290f, 
    -0.04788351f, -0.06578856f, -0.09533015f, -0.02350874f, 0.71939820f, -0.08686409f, -0.32900566f, -0.15759464f, 
    -0.14698552f, -0.18538560f, 0.05611049f, 0.08913343f, -0.02649940f, -0.12099811f, -0.03023368f, -0.01572851f, 
    0.03609207f, 0.04668952f, 0.07396775f, 0.04862456f, -0.24174045f, -0.09055360f, 0.05925360f, -0.12598050f, 
    0.49784291f, 0.07332933f, 0.20172617f, 0.03841218f, 0.35947189f, 0.04929773f, -0.21515007f, -0.50921732f, 
    0.11470341f, 0.11808039f, 0.17780709f, -0.03317184f, -0.05843621f, 0.10962379f, 0.03056656f, -0.09023763f, 
    -0.11901627f, 0.11684696f, 0.05159804f, 0.00023254f, 0.72402459f, -0.87621409f, -0.10256326f, -0.07058145f, 
    -0.63489896f, -0.10919241f, 0.17992701f, -0.24160846f, -0.14888775f, -0.01628778f, 0.09826676f, 0.14722896f, 
    0.10958475f, -0.15980861f, -0.09560946f, -0.02559710f, 0.02977348f, 0.13629074f, 0.09264252f, 0.02885802f, 
    0.10288253f, 0.30261737f, 0.06528717f, 0.27236715f, -0.06886391f, -0.11831658f, 0.17704687f, 0.04143222f, 
    -0.06983362f, 0.06408910f, 0.03052375f, 0.02645493f, -0.01314096f, 0.02561902f, 0.06181494f, 0.10691822f, 
    0.00466119f, 0.07804417f, -0.02037952f, 0.06296657f, 0.83476150f, 0.49013919f, -0.20049383f, 0.07932701f, 
    0.31196070f, 0.09305011f, 0.13011961f, 0.06755678f, 0.07956707f, 0.23744856f, -0.14855994f, -0.06524665f, 
    -0.12861001f, 0.04828193f, 0.06361566f, -0.06728387f, 0.13336484f, 0.04172897f, 0.15936600f, 0.13305202f, 
    0.32773361f, 0.21259542f, -0.44988555f, 0.13644767f, 0.07076005f, -0.14642382f, 0.05847615f, 0.07863399f, 
    0.15513016f, -0.15044428f, 0.03482850f, -0.02659645f, -0.19456124f, -0.09990328f, 0.01689796f, -0.11205846f, 
    0.01311225f, 0.09122567f, -0.18534529f, -0.06774694f, -0.40227467f, -0.27890572f, -0.41893050f, 0.34983382f, 
    0.52929693f, 0.13953945f, 0.23032874f, 0.14817007f, 0.03950135f, -0.15014875f, 0.14448471f, 0.05830447f, 
    -0.02996978f, -0.21378537f, -0.01913179f, -0.04519363f, 0.05513577f, 0.02097227f, 0.07080973f, -0.16122550f, 
    -0.45180085f, 0.57597762f, 0.12651992f, 0.37155363f, 0.21831082f, 0.14010327f, 0.11123621f, 0.07170764f, 
    -0.04402680f, 0.07948070f, -0.06418255f, 0.01370857f, 0.09821807f, -0.22813775f, -0.28750211f, 0.00751708f, 
    -0.01897211f, -0.01706970f, 0.18790679f, -0.22174934f, 0.33855885f, -0.00173977f, -0.01596205f, -0.15538402f, 
    -0.07459176f, -0.13163775f, -0.10297602f, -0.19844307f, 0.05477090f, -0.13819124f, -0.04306383f, -0.04211473f, 
    0.20647414f, -0.06026479f, -0.09841089f, -0.01982349f, 0.17862605f, 0.00912582f, -0.00516614f, -0.02915376f, 
    -0.12336009f, -0.00240627f, -0.25656846f, -0.20313101f, 0.21082458f, -0.23800966f, 0.02607311f, -0.12227131f, 
    0.20112734f, -0.01256591f, -0.02328876f, 0.17841040f, 0.08379360f, -0.04066664f, 0.01482695f, 0.03409865f, 
    0.07921923f, -0.16949105f, 0.23923886f, 0.00451308f, -0.94235647f, 0.17423140f, 0.12187161f, -0.17334014f, 
    -0.47564858f, -0.18677290f, -0.19114397f, 0.04640280f, 0.02715983f, -0.10590043f, 0.04075240f, -0.13927555f, 
    -0.01752535f, -0.11592728f, -0.10923050f, -0.11982792f, 0.02447627f, 0.04472198f, 0.07059775f, 0.10827366f, 
    0.09716446f, -0.33250201f, 0.12784290f, -0.01066274f, -0.17704052f, 0.00522855f, -0.29246533f, -0.00241248f, 
    0.00561977f, -0.00504962f, -0.05396092f, 0.01379110f, 0.11111773f, -0.05773788f, 0.06511340f, -0.02420553f, 
    -0.10138470f, 0.05883023f, 0.04907998f, 0.18320566f, 0.04471775f, -0.10216050f, -0.23393179f, 0.12907521f, 
    -0.10940108f, -0.16694020f, -0.10356125f, -0.07466673f, 0.05129153f, -0.11555706f, -0.22046691f, -0.07930515f, 
    0.12917309f, 0.22654396f, 0.01623306f, -0.10369122f, -0.04989637f, 0.10964965f, -0.05529760f, 0.02438439f, 
    0.00574500f, -0.07012706f, 0.07435188f, 0.09226546f, -0.09773372f, -0.01040170f, -0.25997022f, -0.25571436f, 
    -0.07034720f, 0.03333403f, 0.04105975f, -0.02260493f, 0.15202223f, -0.05300450f, 0.09136914f, 0.02184620f, 
    0.16250129f, -0.08090247f, 0.07105783f, -0.11503306f, -0.11578294f, -0.16272357f, -0.12293668f, 0.00116704f, 
    -0.14132389f, -0.18954109f, -0.18410306f, 0.18879132f, -0.09809184f, 0.02851954f, -0.11546905f, 0.09279604f, 
    -0.13095951f, 0.09868054f, -0.14712936f, 0.12226802f, -0.01495327f, 0.08216891f, 0.27733269f, -0.01036846f, 
    -0.80724448f, -0.87211192f, -0.48501131f, -0.05176200f, -0.25447091f, -0.21213214f, -0.22337204f, -0.04833683f, 
    0.01610991f, -0.17643332f, -0.21205387f, -0.11087134f, 0.13812889f, -0.07200652f, 0.01891037f, 0.10236291f, 
    -0.19130526f, 0.14121500f, -0.03864513f, 0.15256830f, -0.29238671f, 0.08769356f, 0.08330017f, -0.09279636f, 
    -0.03403153f, 0.08103216f, 0.02978224f, -0.22577474f, 0.19358034f, -0.10140826f, 0.15089831f, 0.01091521f, 
    -0.09876028f, 0.03318396f, -0.14534800f, -0.07052350f, -0.01113715f, -0.18095265f, 0.14766251f, -0.02681483f, 
    -0.19900492f, 0.30032396f, -0.28974313f, -0.13665415f, -0.09049600f, -0.06219370f, -0.11925116f, 0.09454530f, 
    0.03942064f, -0.11463457f, -0.10261274f, -0.15419380f, -0.07006759f, -0.00835998f, -0.02589832f, -0.04142573f, 
    -0.06013212f, 0.03939014f, 0.09201660f, -0.07885528f, 0.04467175f, 0.37039420f, 0.11354915f, 0.07437428f, 
    -0.11743028f, -0.13322747f, -0.05315078f, -0.09885657f, -0.09961338f, 0.04110975f, -0.04596894f, -0.03152463f, 
    -0.03092527f, -0.16172482f, -0.02533135f, 0.01286725f, 0.10184076f, 0.10664254f, 0.16723074f, 0.01232454f, 
    -0.26619405f, 0.44129336f, -0.25142619f, 0.28412119f, -0.35977945f, -0.08202238f, -0.05527322f, 0.13505462f, 
    -0.07413469f, -0.16389064f, 0.01903994f, -0.11984210f, -0.02077536f, 0.10326904f, 0.11891407f, -0.01531003f, 
    -0.03405559f, -0.01188203f, -0.15923554f, 0.14737552f, 0.47954848f, 0.07693452f, 0.05359586f, -0.08272842f, 
    -0.36360008f, -0.08617597f, 0.14617215f, -0.03681174f, -0.04104252f, -0.01462174f, 0.07068378f, -0.13128752f, 
    0.10476756f, 0.01530004f, -0.00095100f, -0.06170484f, 0.16154084f, 0.09767254f, 0.04008390f, 0.35018072f, 
    -0.18898278f, -0.04174320f, -0.44518107f, -0.03493140f, -0.26896283f, -0.10426836f, -0.08147385f, -0.04003378f, 
    -0.30293891f, 0.07647585f, -0.29707721f, -0.11681320f, 0.08922139f, -0.09344351f, 0.09387200f, -0.12434819f, 
    -0.06943210f, 0.02273167f, -0.06816173f, 0.00177923f, -0.36607841f, -0.75118661f, 0.30745286f, 0.33170739f, 
    -0.04492063f, -0.25046262f, -0.07077329f, 0.18036814f, -0.14743817f, 0.00739327f, 0.07062483f, 0.05579907f, 
    -0.01136640f, -0.12771808f, 0.01506230f, -0.00849030f, -0.17316015f, 0.08217694f, 0.00954990f, 0.04140892f, 
    -0.10651559f, -0.29219356f, 0.11613154f, 0.14706996f, -0.06662259f, -0.00283749f, 0.08701009f, -0.00511485f, 
    -0.15017530f, 0.02250673f, 0.10677963f, 0.10739630f, -0.20235068f, -0.01423559f, 0.07281734f, -0.14130746f, 
    -0.15455374f, 0.10111670f, 0.10169696f, -0.01612065f, -0.27880517f, 0.17289919f, -0.16087984f, 0.00035398f, 
    0.30033046f, 0.01376027f, -0.02387476f, -0.02049964f, 0.08675829f, 0.06660643f, 0.02937520f, -0.17708252f, 
    0.02408261f, -0.07693037f, -0.17473228f, 0.07831267f, -0.09942903f, -0.20092887f, 0.00946905f, 0.05247779f, 
    -0.33035004f, -0.03454861f, 0.22345319f, 0.07889475f, -0.02301460f, -0.01489601f, -0.05212203f, 0.20586433f, 
    -0.03342572f, 0.00985166f, 0.05584525f, 0.03791273f, -0.21970834f, -0.08290341f, -0.06486165f, 0.15055837f, 
    0.06909451f, 0.03082871f, -0.05813801f, -0.04415962f, 0.34746528f, -0.17829214f, -0.18355648f, 0.37202087f, 
    0.13456623f, 0.11249782f, -0.05084323f, 0.27712068f, 0.06938978f, -0.00295793f, -0.12277611f, -0.02832904f, 
    0.14808510f, 0.16317792f, -0.09295872f, -0.12463360f, 0.07221793f, -0.15127435f, -0.03520517f, -0.07658672f, 
    -1.05245316f, 0.02431493f, -0.04890167f, 0.09579273f, 0.20364472f, 0.09041318f, 0.06907934f, -0.15722933f, 
    0.07926916f, 0.04037654f, -0.14446867f, -0.10382328f, 0.15141198f, 0.17457345f, 0.06142785f, -0.04088376f, 
    0.40209755f, 0.07201140f, 0.14392699f, -0.14837380f, -0.43333834f, 0.13189922f, 0.24603112f, -0.03490872f, 
    -0.17636463f, -0.09006023f, -0.03876161f, -0.07482920f, -0.05750005f, -0.12764427f, -0.12823021f, 0.09599411f, 
    -0.01591701f, 0.08308175f, 0.09258758f, -0.17731670f, -0.02067417f, 0.14441431f, -0.11009675f, -0.05193147f, 
    -0.60932714f, 0.32427639f, -0.12656407f, -0.02857034f, 0.17080097f, 0.20919445f, 0.00079620f, -0.03978975f, 
    0.12832063f, -0.01499989f, -0.09299968f, 0.08653054f, -0.11491306f, -0.03778434f, -0.14484745f, -0.01230815f, 
    0.00813919f, 0.03234413f, 0.01291022f, -0.06698302f, -0.09204952f, -0.03929763f, 0.07709821f, 0.07888129f, 
    0.30735451f, 0.08055130f, -0.08082860f, -0.13212882f, -0.06523224f, 0.12191804f, 0.10746085f, -0.08584059f, 
    0.10405700f, 0.08688270f, -0.06958971f, -0.08377250f, 0.07963212f, 0.19911981f, 0.19699343f, -0.27262831f, 
    -0.15276085f, 0.06958955f, 0.07733087f, -0.27612048f, 0.07531573f, 0.09884893f, -0.04729896f, -0.02765222f, 
    0.14525771f, 0.16992693f, 0.21450083f, -0.03409661f, 0.02830575f, -0.07808004f, -0.16381034f, 0.16046622f, 
    0.08672173f, -0.02766807f, -0.03065318f, -0.01061496f, -0.07768180f, 0.83800858f, -0.32904947f, -0.36451572f, 
    -0.11564780f, -0.02807601f, -0.06697718f, 0.09093112f, 0.14060140f, -0.09513308f, -0.11930104f, 0.18165423f, 
    -0.04259139f, -0.06251480f, 0.04272924f, 0.15573426f, 0.14659975f, -0.25303739f, -0.04819302f, -0.07457116f, 
    -0.77633119f, -0.01453546f, -0.11613756f, -0.09353698f, 0.18521737f, 0.09163742f, -0.02546769f, 0.10363647f, 
    -0.20526025f, 0.06462023f, 0.10780069f, -0.02715035f, 0.10990259f, 0.02302432f, -0.05051660f, 0.15114270f, 
    -0.00191317f, 0.13741253f, 0.21198779f, -0.06081965f, -0.16592987f, 0.04804847f, -0.26505190f, 0.26502830f, 
    0.11784056f, 0.15917616f, 0.08888192f, 0.08538523f, 0.21446848f, -0.02076695f, 0.00947388f, 0.27084079f, 
    0.02938154f, -0.12047660f, -0.01867242f, -0.05884387f, 0.03883177f, 0.07454111f, 0.09061420f, -0.00955920f, 
    -0.17724079f, -0.31579515f, -0.33062509f, -0.13461447f, 0.10985774f, 0.12177434f, -0.01501408f, -0.05317629f, 
    0.07194680f, 0.21514039f, 0.10610028f, 0.16529402f, 0.13356543f, -0.13275108f, 0.00927997f, -0.16065508f, 
    -0.03658366f, -0.05080559f, 0.18427771f, -0.12438126f, -0.09072342f, 0.16845766f, 0.49178809f, 0.46855885f, 
    -0.30430645f, -0.09963274f, -0.07430089f, 0.08575713f, 0.21513264f, 0.07717869f, -0.24512634f, 0.18529300f, 
    0.06914439f, 0.00854116f, -0.13374700f, -0.16263239f, -0.06122179f, -0.27968410f, -0.08594989f, -0.09998199f, 
    0.09005632f, 0.27978224f, 0.15454456f, -0.11107353f, -0.22965975f, -0.01413616f, -0.03136021f, -0.04269641f, 
    0.03029515f, 0.22871132f, 0.00772546f, -0.07370343f, -0.07637451f, -0.15810193f, -0.09260824f, 0.07678153f, 
    -0.00474424f, -0.30153114f, 0.07950629f, 0.05336927f, 0.25138101f, 0.07403027f, 0.08116792f, 0.22976021f, 
    -0.00510528f, -0.29003617f, -0.02400427f, 0.05620086f, 0.14051141f, 0.13567521f, -0.14961234f, -0.10876341f, 
    0.17161283f, 0.15977551f, 0.22223473f, -0.10870196f, 0.04268811f, 0.05838822f, 0.03993391f, -0.05003174f, 
    0.26513565f, 0.03992101f, -0.01571139f, 0.11430722f, 0.34078813f, -0.10776313f, -0.13617367f, -0.01681230f, 
    0.19430071f, 0.06784344f, -0.07706413f, -0.08420903f, -0.01599445f, 0.24947745f, 0.39785761f, 0.03077977f, 
    0.08065316f, 0.03087919f, -0.38560158f, -0.08754490f, -0.59644532f, -0.12959503f, -0.15104979f, 0.08250165f, 
    -0.25314298f, 0.09534197f, 0.04885580f, 0.22809102f, 0.04746741f, -0.08467944f, 0.13720131f, 0.10963442f, 
    -0.06129339f, -0.13125907f, 0.00481787f, 0.14449660f, 0.06770196f, 0.06765670f, -0.07215159f, 0.05356908f, 
    0.04056340f, -0.15739302f, 0.06452525f, 0.25269723f, -0.06794406f, 0.01214745f, 0.09275991f, -0.20358978f, 
    -0.06625324f, 0.10467368f, 0.06678508f, -0.00192840f, 0.04055894f, 0.07391461f, 0.14604080f, 0.05251584f, 
    -0.12171497f, -0.05252917f, 0.16168651f, 0.21599160f, -0.00274681f, 0.47823766f, 0.21088848f, -0.01799878f, 
    -0.20158254f, 0.03928767f, -0.04751548f, 0.05744046f, -0.10303871f, -0.03248396f, 0.20278040f, -0.11734925f, 
    -0.06971349f, -0.03172326f, -0.11462761f, 0.04982492f, -0.08402546f, 0.26950791f, 0.13824141f, 0.05363389f, 
    -0.24122095f, 0.28719318f, -0.47556901f, -0.08889186f, -0.12311878f, 0.13927908f, 0.10068441f, 0.11475921f, 
    -0.18186161f, -0.14341332f, -0.12004066f, -0.10673415f, -0.19556817f, -0.10234037f, -0.02415168f, 0.04130976f, 
    -0.17883070f, 0.07918040f, 0.06486296f, 0.00649187f, 0.04488425f, 0.23515344f, -0.08581598f, -0.11909416f, 
    0.11336606f, 0.10171300f, -0.09927377f, 0.04181106f, 0.01222545f, -0.06956866f, 0.16723010f, -0.04922182f, 
    0.11186675f, -0.09028956f, 0.05754663f, -0.03315578f, 0.14592363f, -0.14445117f, 0.13131985f, 0.08086981f, 
    -0.75934410f, -0.29176366f, -0.24217267f, -0.23077129f, -0.05714262f, 0.12236843f, -0.10768986f, -0.06873482f, 
    0.08821763f, -0.22207473f, 0.03530402f, 0.04178715f, -0.02741411f, 0.04693004f, 0.01156770f, 0.04866207f, 
    -0.04231846f, -0.01539456f, -0.25945318f, -0.06218770f, -0.48032358f, -0.05289777f, -0.21517298f, -0.17234941f, 
    0.12093669f, 0.09339213f, -0.01955141f, -0.03269455f, -0.00017199f, -0.06240796f, 0.18723373f, 0.09000486f, 
    -0.24159351f, -0.07796208f, -0.16761203f, 0.00812859f, 0.03941955f, -0.03484964f, -0.04422385f, -0.02661865f, 
    0.07330747f, -0.06017572f, 0.24065147f, 0.23272805f, 0.04771669f, -0.03248545f, 0.05811304f, -0.00618347f, 
    -0.04573523f, -0.00436778f, -0.02456284f, 0.08004934f, -0.00437303f, 0.08640955f, 0.11935524f, 0.02120512f, 
    0.03200851f, 0.13594756f, 0.02121217f, -0.01224241f, -0.56706196f, -0.36871150f, 0.26002002f, 0.33149344f, 
    -0.59718162f, 0.04722695f, -0.04899995f, -0.04279554f, -0.00499076f, -0.13515857f, -0.08139946f, -0.01823500f, 
    -0.08917693f, -0.02984109f, -0.00607355f, -0.15489337f, 0.06498945f, 0.20864457f, 0.11739536f, -0.09541168f, 
    -0.98822457f, 0.02336280f, -0.18551740f, -0.38607109f, 0.00444763f, 0.00413866f, 0.06111037f, 0.17629412f, 
    -0.03041555f, -0.17970395f, 0.20923093f, -0.05022225f, 0.07068652f, -0.16637614f, 0.08999646f, 0.04578392f, 
    -0.02714143f, -0.19584490f, -0.05939715f, 0.12709197f, -0.47047323f, -0.24489960f, -0.01027099f, 0.01412252f, 
    0.25708732f, 0.13213088f, -0.07594747f, -0.20775302f, -0.17053871f, 0.05162499f, 0.04606063f, 0.08891878f, 
    -0.06974492f, 0.06649340f, -0.03996107f, -0.02880966f, 0.11214886f, -0.11162277f, -0.33688250f, 0.19875775f, 
    -0.13734311f, -0.28287178f, -0.15272084f, -0.45535555f, 0.36460790f, -0.20438381f, -0.07257630f, 0.15700570f, 
    0.02074664f, -0.19226457f, 0.08406261f, -0.17365727f, -0.23925428f, -0.03745532f, -0.10531253f, 0.03491521f, 
    0.02614805f, 0.23497495f, 0.07118119f, 0.28833315f, -0.05032055f, 0.05220354f, 0.18551295f, 0.08251094f, 
    0.06624684f, 0.10407542f, 0.06003973f, 0.01453862f, -0.10848492f, -0.00087518f, 0.14269547f, 0.05715159f, 
    0.03792431f, 0.05511807f, 0.12789586f, 0.06328882f, -0.07431696f, 0.30524984f, 0.09611108f, 0.07612666f, 
    0.09391404f, -0.10985962f, -0.11158960f, 0.51301891f, 0.15212868f, -0.09600677f, 0.27661830f, -0.08027775f, 
    -0.03347353f, 0.17701095f, -0.00149901f, 0.03900139f, -0.05078255f, 0.00513177f, -0.10876922f, -0.14762603f, 
    0.07529768f, 0.01835132f, -0.12625489f, -0.10186751f, -0.23464584f, 0.50004405f, 0.28019449f, 0.00216646f, 
    -0.45341650f, 0.06804354f, -0.02782978f, 0.00687958f, 0.01470436f, 0.06083220f, 0.01802285f, 0.05675201f, 
    -0.17022930f, 0.02121653f, -0.17401454f, 0.10652126f, 0.03449551f, -0.13769391f, 0.04320933f, 0.00285619f, 
    0.01139676f, 0.01578726f, -0.13267168f, -0.24327324f, -0.07135250f, 0.11093836f, 0.13334449f, 0.04751170f, 
    -0.18395987f, -0.10778368f, -0.01595530f, -0.00726457f, -0.10047167f, -0.15363638f, -0.10252210f, 0.08838154f, 
    -0.07702631f, 0.05880187f, 0.14007890f, -0.02636514f, -0.19665055f, -0.51204437f, -0.11473981f, -0.15776721f, 
    -0.02594754f, -0.02672120f, 0.14876209f, 0.13891934f, -0.06734849f, 0.02515190f, -0.16467588f, 0.15067115f, 
    -0.12043008f, 0.06523161f, 0.19061795f, -0.19356839f, -0.00436730f, -0.01215721f, -0.00211377f, 0.03913907f, 
    -0.73691684f, 0.41834018f, 0.06577470f, 0.31977379f, -0.38314357f, 0.30224806f, -0.01762109f, 0.18503998f, 
    0.06777570f, -0.19749855f, -0.01589765f, 0.07943511f, 0.03470267f, 0.03201314f, -0.17645617f, -0.07019097f, 
    -0.02534572f, 0.06480473f, -0.05046915f, -0.24426062f, 0.22353064f, -0.40225345f, -0.13821533f, 0.05247439f, 
    -0.21083887f, 0.02064798f, 0.00267484f, 0.02163576f, 0.00276777f, 0.04492535f, -0.07259649f, -0.07718882f, 
    0.09884793f, 0.07464079f, 0.09448685f, 0.05113268f, -0.11098456f, -0.09210477f, -0.09907359f, -0.06724419f, 
    0.34971350f, -0.56415623f, -0.04071777f, -0.40957081f, 0.01744559f, -0.05788808f, -0.07907311f, -0.12959577f, 
    0.02523813f, -0.16436821f, 0.02783081f, -0.01828678f, 0.21948804f, 0.05348955f, 0.06067928f, 0.08141705f, 
    -0.05173116f, -0.16161971f, -0.00822508f, 0.00220648f, 0.15887140f, -0.37411484f, -0.23099475f, -0.00544625f, 
    0.16806927f, 0.01914202f, 0.01009222f, -0.06866885f, 0.14719799f, -0.07229926f, 0.13516402f, 0.08416040f, 
    0.11335079f, 0.13076182f, 0.00852169f, 0.09978025f, -0.16444093f, 0.06571491f, -0.21543083f, 0.10392585f, 
    0.30445400f, 0.05645018f, -0.11887800f, -0.08893890f, -0.07294124f, -0.07251786f, 0.22272907f, 0.09463584f, 
    -0.06954151f, 0.00742838f, 0.17805168f, -0.16755491f, 0.12869443f, -0.10674051f, 0.09542856f, -0.11452076f, 
    0.12000456f, 0.13299283f, -0.01675734f, 0.01600490f, -0.43358225f, -0.26803935f, -0.03076967f, -0.11610839f, 
    0.30260843f, 0.11514319f, -0.00189083f, 0.26569575f, -0.05516190f, -0.26261112f, -0.15175349f, -0.12104260f, 
    0.23144509f, 0.19371064f, 0.00875710f, 0.22367935f, -0.08440902f, -0.13401432f, -0.00747853f, 0.27052766f, 
    -0.49964398f, 0.08495601f, -0.09579248f, 0.39439726f, -0.01256172f, -0.11591195f, -0.12756920f, 0.04807552f, 
    0.29268900f, 0.01625937f, -0.04612254f, -0.10362927f, -0.00821724f, -0.02319719f, 0.13638435f, -0.04331175f, 
    -0.07976314f, -0.26694405f, -0.15665880f, -0.09698729f, 0.72675943f, -0.65698713f, -0.05435546f, 0.20481373f, 
    0.15268166f, 0.06040074f, -0.06532907f, 0.10028096f, -0.03866014f, 0.00571567f, -0.02726245f, 0.12840731f, 
    -0.12277418f, -0.03632326f, 0.00481659f, -0.06392963f, 0.00576085f, 0.04593967f, -0.10959077f, -0.03634329f, 
    0.04646287f, -0.34925827f, -0.01243330f, 0.04041562f, 0.24078462f, -0.19952181f, 0.00305747f, -0.17307773f, 
    -0.18482362f, 0.05500469f, 0.02465592f, 0.10228402f, 0.00505329f, 0.18873818f, 0.07446504f, -0.05080749f, 
    -0.04087040f, 0.08781530f, -0.09168433f, 0.05659919f, -0.13997653f, 0.08397107f, -0.38998505f, -0.47659117f, 
    0.14512299f, -0.03668577f, -0.01563549f, 0.02082645f, -0.15467347f, 0.07346018f, 0.09413937f, -0.21976568f, 
    -0.11997224f, -0.15023595f, 0.08517552f, -0.10348849f, 0.01096138f, -0.01615382f, 0.13365032f, -0.17496634f, 
    -0.01849443f, 0.16409427f, 0.03221404f, 0.18867025f, 0.28549084f, -0.08490451f, 0.24438094f, -0.18014838f, 
    0.01668269f, -0.04041747f, -0.17136483f, 0.07236123f, -0.34015152f, -0.17159048f, -0.04669584f, -0.00456436f, 
    -0.00523019f, 0.15403290f, -0.17741629f, -0.02995609f, -0.26420185f, 0.30151299f, 0.09108993f, 0.19926345f, 
    0.45336401f, 0.09843112f, -0.29921204f, -0.25177345f, 0.09579290f, -0.01466022f, -0.09689263f, 0.07074643f, 
    0.14626627f, -0.03180376f, -0.25453168f, 0.12629943f, -0.22269624f, -0.04428647f, 0.02435824f, -0.22470036f, 
    -0.42108312f, 0.16872977f, -0.07475939f, -0.22202645f, -0.13269441f, 0.05006487f, -0.05783682f, -0.19371691f, 
    0.09305404f, 0.07532532f, -0.17548673f, -0.01081603f, -0.12871824f, -0.02360363f, 0.06126867f, -0.05708230f, 
    -0.22151032f, 0.19401149f, -0.08010811f, -0.09196231f, -0.16099977f, -0.36659122f, -0.49098897f, -0.21931742f, 
    0.08138441f, 0.00727035f, -0.19837269f, -0.11197756f, -0.12171419f, -0.09749353f, -0.15944518f, 0.04907962f, 
    0.09938100f, -0.09681690f, 0.00686140f, -0.13834977f, 0.17224613f, 0.00147593f, 0.02916251f, 0.11195330f, 
    0.08031376f, -0.32907665f, -0.08362286f, -0.05690591f, 0.35579464f, 0.09574382f, -0.13058445f, -0.08620738f, 
    -0.08711267f, 0.03281573f, -0.09006121f, -0.01165987f, -0.06330595f, -0.05988314f, -0.06992967f, -0.25083229f, 
    0.04956733f, 0.06167604f, -0.02344398f, 0.02825537f, -0.03573858f, 0.12818179f, 0.19065456f, 0.22701296f, 
    0.29527968f, 0.11324233f, 0.01777651f, -0.08833333f, 0.02175215f, -0.18873771f, -0.04162221f, 0.05390735f, 
    0.19292955f, -0.15342128f, -0.05968240f, -0.13733155f, -0.17614585f, -0.05248288f, 0.07007079f, -0.13570642f, 
    -0.44121665f, -0.16979657f, 0.19450605f, -0.12387241f, -0.40101212f, 0.11481692f, -0.08761691f, -0.13690165f, 
    -0.06654737f, -0.14313076f, -0.02914856f, -0.05117621f, -0.05887026f, -0.12008554f, -0.11732595f, -0.02992303f, 
    0.06262188f, -0.06147131f, -0.01430017f, -0.02633701f, 0.11027270f, -0.22882465f, -0.01864176f, -0.08341355f, 
    -0.32238510f, -0.04713828f, -0.24499603f, -0.08534322f, -0.23367858f, -0.08014172f, 0.00476503f, 0.03704453f, 
    0.10895959f, 0.10492711f, -0.23641850f, 0.02907159f, -0.08842316f, -0.00202692f, -0.07382758f, -0.05929212f, 
    0.24874257f, 0.18804128f, 0.32810634f, 0.08950828f, 0.23671122f, 0.05320240f, 0.12893568f, -0.10896151f, 
    0.06625079f, -0.02686787f, -0.00474850f, 0.10494337f, -0.05334470f, 0.03519775f, -0.16686313f, -0.05024292f, 
    0.04476898f, -0.05869291f, 0.03559280f, -0.13968760f, -0.53509969f, 0.44297758f, 0.16198991f, -0.10350768f, 
    -0.04350193f, -0.16288123f, 0.07219530f, -0.17678618f, -0.04044480f, -0.13593036f, 0.02462360f, 0.04802434f, 
    -0.10605651f, 0.08797054f, -0.25672913f, -0.08516937f, -0.03276885f, -0.05507893f, 0.02787991f, 0.04412080f, 
    0.28937557f, 0.03443947f, 0.35025066f, -0.00231606f, 0.17160606f, -0.16209629f, 0.11558381f, -0.09130748f, 
    -0.11603643f, 0.14529699f, -0.07269794f, 0.14724359f, -0.18400130f, 0.01207601f, -0.09275370f, -0.18163943f, 
    -0.11196151f, 0.04332067f, 0.24040151f, -0.22942682f, 0.43937260f, -0.00545585f, 0.42618766f, -0.12584451f, 
    0.25006431f, 0.06748994f, 0.16232149f, -0.00319183f, -0.05070694f, 0.03218748f, 0.01704288f, 0.05244808f, 
    -0.12868550f, 0.05680462f, -0.13933744f, -0.03985357f, -0.07524078f, -0.01487869f, 0.12545252f, -0.00980420f, 
    -0.08678412f, -0.41987365f, -0.02147879f, -0.26938570f, -0.18754722f, -0.23724048f, -0.11978509f, 0.00874079f, 
    -0.15469436f, -0.18274727f, 0.08342786f, -0.04479001f, -0.11773159f, -0.09789030f, -0.14823623f, 0.06344225f, 
    -0.14680083f, -0.14692391f, -0.04188082f, -0.07022049f, 0.49366444f, -0.28375039f, -0.03444077f, -0.04131084f, 
    -0.20320745f, 0.31510106f, -0.10839435f, 0.05566572f, -0.02665702f, 0.03018151f, -0.05029079f, 0.00599150f, 
    -0.10557589f, 0.00339069f, 0.01889552f, 0.16304249f, 0.24950056f, 0.04837209f, 0.06309688f, -0.02801469f, 
    -0.09403434f, 0.04812720f, 0.42777798f, 0.11078954f, 0.11492198f, 0.21229434f, 0.01824204f, 0.10702614f, 
    0.14282890f, -0.15057105f, -0.21186782f, 0.17874764f, 0.17744510f, 0.05369454f, -0.08940065f, 0.04263045f, 
    0.18445940f, 0.11181987f, 0.09761260f, -0.01508024f, 0.32493252f, 0.25918269f, 0.25407040f, 0.09719592f, 
    0.22371599f, -0.01647852f, 0.08030473f, -0.18569544f, -0.18790685f, -0.07136455f, -0.05515532f, -0.03250941f, 
    -0.18694113f, -0.13289970f, -0.14462037f, -0.06453703f, -0.08005044f, 0.06310675f, 0.02976562f, -0.08877061f, 
    -0.17844948f, 0.28017062f, 0.20126922f, -0.22978227f, -0.41501984f, -0.06716970f, -0.12836549f, -0.01942408f, 
    0.07387315f, -0.25528058f, 0.15406971f, 0.07310086f, 0.10869529f, 0.03477162f, 0.10892793f, -0.22634980f, 
    0.04452345f, -0.27954403f, 0.12768301f, -0.00871918f, -0.39333659f, -0.26657534f, -0.58510399f, -0.10564470f, 
    -0.39341950f, 0.14094076f, -0.09838662f, -0.76202697f, -0.04571057f, -0.21175811f, 0.20375535f, 0.03989605f, 
    0.09627037f, -0.10866622f, 0.30500427f, -0.25867566f, 0.06811481f, -0.23914042f, 0.06369381f, -0.32138184f, 
    -0.02921510f, 0.26962441f, -0.02469029f, 0.08756576f, -0.17534064f, -0.02157975f, 0.03754076f, -0.06568195f, 
    0.05440947f, 0.01884896f, 0.17035249f, 0.08144948f, 0.03068853f, 0.11674564f, -0.00989158f, -0.02211236f, 
    -0.00944263f, -0.14719668f, 0.10230851f, -0.06372552f, 0.03917032f, -0.25233522f, -0.14154886f, -0.23396958f, 
    0.12281730f, 0.24433376f, 0.03697175f, -0.11689132f, -0.08732752f, -0.08512228f, 0.08581384f, 0.13050163f, 
    0.04574895f, 0.16392538f, 0.02684894f, 0.10984629f, -0.03776402f, 0.14693435f, 0.06229214f, -0.07704820f, 
    -0.16531797f, -0.25957939f, -0.08711422f, -0.58290380f, -0.29012609f, -0.01606789f, -0.14339010f, -0.07374785f, 
    0.04710446f, -0.21358666f, 0.14447364f, 0.07356495f, -0.05949317f, 0.15271677f, -0.01123896f, 0.13601409f, 
    -0.07674047f, 0.01849428f, -0.57325423f, 0.08957507f, -0.34387031f, -0.03314939f, 0.28806299f, 0.03171725f, 
    0.22921759f, -0.26759756f, -0.13596748f, -0.02055143f, -0.15570594f, -0.06818898f, -0.18486370f, 0.01092251f, 
    -0.15390761f, 0.06397964f, -0.02085706f, -0.12002897f, 0.07595117f, 0.12516329f, -0.08857708f, 0.05009587f, 
    0.12087012f, 0.22292121f, -0.40590203f, 0.28939146f, 0.07866164f, 0.16944161f, 0.06116989f, -0.20204437f, 
    -0.18778549f, -0.04167902f, -0.16340539f, -0.00121622f, 0.03085995f, -0.03074193f, -0.11719166f, 0.15079254f, 
    -0.06454266f, -0.06702104f, 0.24010167f, -0.00074079f, 0.20297761f, 0.22204611f, -0.11164765f, 0.12938598f, 
    0.28499755f, -0.25636587f, -0.05321979f, -0.21817611f, -0.27739984f, 0.01994425f, -0.31589717f, -0.01021982f, 
    -0.05049698f, -0.17090452f, 0.09638368f, 0.07843956f, 0.04352182f, 0.14233486f, 0.09718614f, -0.02081500f, 
    -0.10798874f, -0.06547394f, 0.17071238f, 0.02010418f, 0.22799869f, -0.04786776f, -0.06907896f, 0.21831653f, 
    -0.10548443f, 0.16453174f, 0.08278874f, -0.13849513f, -0.16543527f, -0.11461280f, 0.08978347f, -0.04870107f, 
    0.03673111f, 0.07448454f, 0.07833309f, 0.08634718f, 0.43330619f, 0.03447221f, -0.08555971f, 0.09713861f, 
    -0.01638691f, -0.06986758f, -0.05023960f, -0.02967802f, -0.11483677f, 0.16322723f, -0.06364724f, -0.21805437f, 
    -0.00438228f, 0.07169392f, 0.09286306f, 0.23889174f, -0.03937307f, -0.04210670f, 0.16275740f, -0.12108746f, 
    -0.25405508f, -0.17888844f, 0.43399116f, -0.15059879f, -0.06678093f, 0.12367621f, 0.24145094f, -0.03357038f, 
    -0.21131521f, -0.16588558f, 0.07696397f, 0.03302839f, 0.13967276f, 0.14407481f, -0.06724113f, 0.01578265f, 
    0.00268502f, -0.00858216f, -0.27566004f, 0.05390714f, -0.16789503f, 0.20420937f, -0.01306410f, -0.14191137f, 
    -0.03812117f, -0.10596437f, -0.02822888f, 0.09033943f, -0.25060403f, 0.07359678f, -0.03264883f, -0.04866399f, 
    -0.22839335f, -0.06805867f, 0.03446708f, -0.04532343f, -0.21348782f, 0.01938909f, 0.04075550f, 0.02939543f, 
    0.33463508f, 0.37089363f, -0.00882198f, 0.19044842f, 0.23515472f, 0.05482079f, 0.04231119f, -0.12491778f, 
    -0.13231143f, -0.13085100f, 0.03204179f, 0.08079869f, -0.10919596f, -0.13826919f, 0.04880174f, -0.29001215f, 
    -0.03508570f, 0.15488501f, 0.15949096f, -0.15824774f, 0.22246234f, 0.05715502f, -0.21351452f, 0.14130270f, 
    0.14379561f, 0.03141401f, 0.05839959f, -0.14583874f, -0.02460530f, -0.02578550f, 0.07413609f, -0.10113952f, 
    -0.05134229f, -0.02282478f, 0.13112544f, 0.18837593f, 0.02102074f, -0.03863350f, 0.09866084f, 0.16893633f, 
    -0.14897826f, -0.29505703f, 0.18021920f, 0.09714308f, 0.17766674f, -0.19991951f, -0.14311595f, -0.03706142f, 
    -0.20991895f, 0.08384190f, -0.03010434f, -0.04346627f, -0.15045696f, -0.07840980f, -0.18053898f, 0.16523495f, 
    -0.09728537f, -0.04525678f, 0.10470629f, 0.00144017f, -0.42772251f, 0.19681589f, 0.24592488f, -0.51786739f, 
    -0.39232710f, -0.05287775f, -0.02651861f, -0.10186160f, 0.07908393f, -0.27625206f, 0.03770940f, -0.00417206f, 
    -0.05016532f, 0.21509778f, -0.03098880f, 0.02467639f, 0.27462262f, -0.24305058f, -0.42355448f, 0.06740125f, 
    -0.03608970f, 0.59286356f, 0.16150846f, 0.29260176f, -0.01878693f, 0.19221854f, 0.11286324f, -0.04859292f, 
    0.02499646f, 0.05162765f, -0.13121933f, -0.01832022f, 0.19356863f, -0.00326964f, 0.15892459f, 0.14114791f, 
    0.04277018f, 0.12011546f, -0.17293933f, -0.11786250f, -0.44387424f, -0.45367345f, 0.12131823f, -0.56443805f, 
    0.01955665f, -0.26061282f, 0.08576357f, -0.05838781f, 0.16398217f, 0.05828652f, -0.24755763f, -0.25419372f, 
    -0.08980393f, 0.08257242f, 0.02840565f, 0.09370016f, 0.11237720f, 0.13696282f, -0.04424630f, 0.15073192f, 
    -0.09627991f, 0.24212903f, 0.46063620f, -0.32991093f, -0.01451744f, -0.02378559f, 0.20513779f, 0.04872618f, 
    0.02147617f, -0.22461437f, -0.05228310f, 0.01615704f, 0.13951261f, 0.12830049f, 0.05251886f, -0.16044573f, 
    0.08105330f, -0.00814026f, -0.16839772f, -0.01880969f, -0.05554873f, -0.35221583f, 0.62740827f, -0.50515205f, 
    -0.65383679f, 0.07381105f, 0.07134452f, 0.07160974f, -0.17611615f, 0.07920944f, -0.04249147f, -0.07140262f, 
    0.00006531f, -0.14424267f, -0.06905455f, -0.07369375f, -0.04628013f, 0.02744517f, 0.08406806f, -0.17533323f, 
    0.04259899f, -0.07199975f, 0.11572762f, -0.31523478f, -0.02045603f, -0.19974366f, 0.09493620f, 0.09980332f, 
    -0.16444311f, 0.06226595f, 0.16487609f, 0.01383604f, 0.24445386f, -0.19736381f, -0.18336780f, 0.11270178f, 
    0.01066685f, 0.03767652f, 0.23864494f, 0.07024931f, 0.61474079f, -0.04088609f, -0.30950570f, -0.13317670f, 
    0.15499613f, 0.23219910f, -0.06728947f, -0.04613093f, 0.00126807f, 0.00920492f, 0.02362875f, -0.02865559f, 
    0.09936985f, 0.11608065f, 0.08208635f, -0.07263203f, -0.00218120f, 0.05126039f, 0.12506698f, -0.04620365f, 
    0.27372786f, -0.54220194f, 0.29757223f, -0.09807377f, -0.16682406f, 0.08177599f, 0.05995593f, -0.11096350f, 
    -0.03932845f, 0.02949153f, -0.11283091f, 0.00170917f, 0.01784167f, -0.16509786f, -0.02325608f, 0.01187158f, 
    -0.08317226f, 0.02927502f, -0.14497834f, 0.06185324f, -0.07559526f, -0.37336731f, -0.17324246f, -0.23781383f, 
    -0.04629679f, -0.04973857f, 0.14171286f, -0.04616677f, 0.06369045f, -0.07240648f, 0.07703172f, 0.06729166f, 
    -0.03277121f, -0.00226674f, -0.02495565f, -0.08694144f, 0.17974909f, -0.11287735f, -0.01107073f, -0.02529358f, 
    0.37156382f, 0.04706322f, -0.20955938f, 0.12361736f, -0.03126154f, 0.06011701f, -0.02963066f, -0.00825719f, 
    -0.03868654f, 0.13210349f, -0.08394607f, 0.00044641f, -0.06351079f, 0.00843845f, -0.02237208f, 0.09173033f, 
    -0.04582818f, -0.03276180f, 0.09340565f, 0.05370255f, -0.97348869f, 0.51041830f, -0.05117415f, 0.29968715f, 
    0.16808103f, 0.38318321f, 0.12712306f, -0.09534194f, -0.13550314f, 0.19008374f, 0.03136384f, 0.02791768f, 
    -0.02965971f, -0.09947491f, -0.06454745f, 0.15601207f, -0.05033686f, 0.16452500f, -0.05863529f, -0.13599756f, 
    -0.02994224f, -0.58117038f, -0.22243026f, 0.16669618f, 0.19585676f, -0.02153482f, 0.07586870f, -0.12183286f, 
    -0.13022174f, 0.10381921f, -0.04445266f, 0.15928489f, 0.01032195f, -0.14193794f, 0.01929172f, -0.13858581f, 
    -0.17042518f, -0.13602144f, 0.17323950f, -0.01387119f, -0.10572911f, -0.11544596f, -0.15233859f, 0.21141228f, 
    -0.36965930f, -0.04361247f, 0.06331528f, -0.09731270f, 0.06894727f, 0.11843105f, -0.20427296f, 0.00889221f, 
    0.00768758f, -0.12077104f, 0.04132275f, 0.01352569f, 0.10615387f, -0.13252106f, -0.00208457f, -0.09601147f, 
    -0.13829342f, 0.26752198f, -0.15044978f, 0.00432541f, -0.24156985f, 0.10776093f, 0.31036073f, -0.05557163f, 
    -0.01560247f, -0.41047859f, -0.06064959f, 0.09760156f, 0.04006890f, 0.01272481f, -0.00278770f, -0.01426258f, 
    0.03646536f, -0.07079230f, 0.16813548f, -0.07325050f, 0.11151496f, -0.45814499f, 0.28237215f, -0.27346614f, 
    0.25767446f, 0.02868047f, -0.01881182f, -0.04918221f, -0.00270048f, -0.05565153f, -0.05827111f, -0.18983710f, 
    0.03678805f, 0.28299749f, 0.09868788f, -0.05455199f, 0.02771370f, -0.22450687f, -0.13256210f, 0.04975804f, 
    0.25190517f, -0.65669656f, -0.04942034f, 0.32346854f, 0.00079267f, -0.00628045f, -0.07684805f, -0.02550828f, 
    0.06386231f, 0.08262993f, -0.10114893f, 0.05794085f, -0.18450311f, 0.11227729f, -0.12288073f, -0.25038549f, 
    -0.06302416f, -0.00512771f, -0.04647969f, 0.09161181f, -0.10846019f, -0.35110238f, -0.23472418f, 0.14884818f, 
    0.04637963f, -0.15091747f, 0.17275685f, 0.03623461f, -0.24900515f, -0.08416844f, 0.13174561f, 0.00444514f, 
    -0.14060080f, -0.05464314f, 0.08093362f, 0.06334601f, 0.04926986f, 0.02780453f, 0.12754895f, 0.16757320f, 
    -0.34572110f, -0.21426298f, -0.05509430f, 0.17586306f, 0.13920046f, 0.09998085f, 0.01713851f, 0.17852461f, 
    0.08758345f, 0.05499681f, 0.02791839f, -0.07841656f, 0.07021174f, -0.10877963f, 0.02216985f, -0.02976158f, 
    -0.15626498f, -0.17554262f, 0.14704570f, -0.01081966f, -0.64860916f, -0.13547449f, 0.04142660f, 0.17901266f, 
    -0.08741986f, 0.09138132f, -0.00239388f, 0.03141396f, 0.07793349f, -0.01498761f, 0.04260348f, 0.05283152f, 
    -0.09051830f, -0.04065026f, 0.14213598f, 0.10886303f, -0.20253253f, -0.43150648f, -0.17831123f, -0.11683592f, 
    -0.30218846f, -0.53713346f, -0.10625961f, 0.00324317f, 0.32158279f, 0.16614299f, 0.03766119f, 0.13976361f, 
    0.01374375f, -0.08085813f, 0.15832333f, 0.03221627f, -0.06482953f, 0.06746915f, 0.02480797f, 0.21144657f, 
    0.12331371f, 0.19005927f, 0.26573613f, 0.13345462f, -0.76124454f, -0.04357058f, -0.00422726f, -0.21852054f, 
    -0.28398666f, 0.37525859f, -0.01909521f, -0.03243969f, -0.00702987f, 0.10061781f, 0.02481324f, 0.03625298f, 
    -0.06910285f, 0.36126426f, 0.00041993f, 0.05828183f, 0.00149869f, 0.02347288f, -0.13787907f, 0.02055110f, 
    0.49250305f, 0.54167777f, 0.24764697f, -0.04083263f, -0.08217972f, 0.07832022f, -0.05321406f, 0.08738267f, 
    0.16596374f, 0.03857088f, 0.02799265f, 0.01242273f, 0.06172691f, 0.05489620f, -0.08229302f, 0.19188002f, 
    0.24748118f, -0.19249474f, -0.16644755f, 0.18199192f, 0.13505553f, 0.10264788f, 0.10395367f, 0.06269235f, 
    -0.10129626f, -0.19676276f, -0.03976167f, 0.03111175f, -0.02958474f, 0.13932769f, -0.04735773f, 0.04136587f, 
    -0.03765780f, -0.02950322f, -0.03162958f, -0.14635527f, 0.04901066f, 0.18202180f, -0.03449817f, -0.01464076f, 
    -0.82421505f, -0.40141580f, -0.51207292f, 0.01353107f, -0.19909552f, 0.13043584f, 0.01117693f, -0.05374210f, 
    -0.02027149f, 0.15027745f, 0.00257963f, 0.03144516f, -0.04839876f, 0.09089421f, 0.08445431f, -0.05748802f, 
    0.07835617f, 0.10414539f, 0.04627477f, 0.09808275f, 0.18331099f, -0.02236801f, -0.20435803f, -0.21401784f, 
    -0.00302743f, -0.01066713f, 0.07468948f, -0.32574400f, -0.00352976f, -0.02526064f, -0.00790633f, 0.03209611f, 
    -0.17848185f, 0.03416259f, 0.17181177f, -0.12211128f, 0.05515312f, 0.17059562f, -0.02318836f, 0.06664447f, 
    0.32024753f, -0.12188154f, -0.16147844f, 0.04168220f, 0.09753163f, -0.18886459f, -0.05247419f, -0.15000883f, 
    -0.14075926f, -0.07150718f, -0.01037962f, 0.01951198f, -0.12144914f, -0.03724474f, -0.04170778f, -0.13553645f, 
    -0.01291873f, -0.01767187f, -0.18366735f, 0.07831893f, 0.17752729f, 0.04865608f, -0.21972005f, 0.10317289f, 
    -0.27902845f, -0.06720570f, 0.02536198f, 0.11769181f, 0.08216928f, 0.00378593f, 0.20678832f, -0.05260441f, 
    0.08137561f, -0.16071512f, -0.06183490f, 0.05963740f, 0.10361711f, 0.13549826f, 0.12880504f, 0.08050607f, 
    0.05546603f, 0.09054042f, -0.00348352f, -0.16662532f, -0.28039598f, -0.07253572f, 0.05447581f, 0.01251412f, 
    0.09348666f, 0.08915126f, -0.23991974f, -0.05373830f, -0.06641050f, 0.09637190f, -0.05986211f, 0.16736612f, 
    0.13071920f, 0.08200820f, -0.09613828f, 0.18031923f, 0.24764453f, -0.29625088f, -0.04759499f, 0.20964955f, 
    0.15606877f, -0.08173542f, 0.08694129f, -0.00184169f, 0.04528185f, -0.13986884f, -0.00808680f, 0.20083462f, 
    -0.06714280f, -0.16352877f, -0.07415979f, -0.15537986f, -0.04890426f, -0.03283917f, -0.20619126f, -0.01627480f, 
    -0.64718115f, -0.50134671f, -0.13104504f, -0.18112779f, -0.32656634f, 0.09400229f, 0.17917860f, -0.13944204f, 
    -0.06980697f, 0.01945118f, -0.02765401f, -0.09034259f, 0.01120705f, -0.00319282f, 0.05581081f, -0.10135440f, 
    0.09810608f, 0.19665815f, 0.17261894f, 0.17439756f, -1.15789294f, 0.25800556f, -0.51955062f, -0.20876786f, 
    0.20135413f, 0.03780874f, 0.03845213f, -0.10052110f, 0.03453540f, 0.18709910f, 0.20804869f, 0.00071387f, 
    0.06131205f, -0.11608243f, 0.03453355f, -0.05831459f, -0.17726149f, 0.24797150f, 0.02436021f, 0.13716953f, 
    0.38260680f, 0.05134352f, -0.08150492f, 0.21128546f, -0.35539651f, -0.34743026f, -0.20389485f, -0.00472054f, 
    -0.07149949f, -0.14766216f, -0.10775103f, 0.01207704f, -0.05581819f, -0.13928546f, -0.05399350f, -0.01165254f, 
    0.01628475f, -0.00270405f, -0.10787595f, -0.17052414f, 0.39920786f, 0.00884662f, -0.05959853f, -0.14785326f, 
    0.04714497f, 0.06324962f, 0.04256978f, 0.08092345f, 0.08852617f, 0.04661240f, 0.05715147f, -0.12047511f, 
    0.01659783f, 0.11988790f, 0.05055158f, 0.16791640f, -0.01633599f, -0.27982435f, -0.32614207f, -0.04952343f, 
    0.22999595f, -0.09790895f, -0.11282694f, 0.10528357f, 0.08981057f, 0.07565834f, -0.25347659f, -0.16190930f, 
    -0.08388647f, -0.05103423f, -0.05507473f, 0.09446415f, 0.01473715f, -0.01335256f, 0.07242158f, -0.04481222f, 
    0.15358716f, -0.05013090f, 0.00023593f, 0.04875603f, 0.06352823f, -0.09746200f, -0.28610575f, 0.15338598f, 
    -0.22065563f, -0.03149085f, 0.08904429f, -0.07926055f, 0.00490195f, -0.20686466f, 0.09898508f, -0.07788873f, 
    0.06473243f, 0.16266264f, -0.07550005f, 0.22507574f, 0.20975046f, -0.02650934f, 0.15461330f, 0.11093517f, 
    0.11446244f, -0.21576138f, 0.08719607f, 0.14789981f, 0.12194602f, 0.37928307f, -0.13672896f, -0.04096118f, 
    0.12196489f, 0.10086224f, 0.10739684f, 0.12330510f, 0.06204491f, 0.15835270f, 0.02625787f, 0.03203107f, 
    -0.14243096f, 0.02818802f, -0.14491078f, -0.04578977f, 0.87963927f, 0.30735365f, -0.48416886f, -0.30889082f, 
    0.14919828f, 0.01116124f, 0.06361832f, -0.12562759f, 0.10066918f, -0.03439077f, 0.25694078f, 0.08910194f, 
    0.06454588f, -0.05877380f, 0.05203120f, 0.03033253f, -0.06832492f, -0.05950304f, 0.08966614f, 0.23400106f, 
    0.11190759f, 0.03098671f, -0.15224983f, 0.00963573f, 0.41178387f, -0.00704849f, -0.07963566f, -0.00965524f, 
    0.19659472f, -0.03008963f, 0.04712656f, -0.05426744f, -0.02357526f, 0.10164268f, 0.14308204f, 0.02501826f, 
    0.01150456f, -0.08047748f, 0.12047341f, -0.00120814f, -0.00436891f, -0.02052182f, 0.09087892f, -0.11190150f, 
    0.11945204f, -0.18253015f, 0.04265868f, 0.08159358f, 0.03051063f, -0.15964602f, -0.06624536f, -0.07702360f, 
    0.07039051f, 0.08620872f, -0.12879050f, -0.02004942f, -0.15839940f, 0.01566354f, -0.21126020f, -0.18390413f, 
    0.51672089f, -0.05923881f, -0.28184065f, 0.07424853f, -0.58273727f, -0.03181735f, 0.13579306f, 0.01843018f, 
    0.13026091f, 0.02721887f, 0.04043134f, 0.01794846f, -0.02383166f, 0.00961992f, 0.11276107f, 0.00734000f, 
    0.09907915f, -0.00115498f, -0.08936748f, -0.02575776f, -1.02699924f, -0.37241620f, -0.01136280f, -0.23053220f, 
    -0.18684980f, -0.02320303f, 0.09806911f, -0.04202252f, 0.09387676f, 0.09005678f, -0.23814842f, 0.20911784f, 
    0.04620760f, 0.02838883f, -0.05656867f, -0.20954069f, -0.03803148f, -0.09629230f, -0.20264985f, -0.12525736f, 
    -0.55275548f, 0.22980118f, 0.13051361f, 0.04064067f, 0.06018323f, 0.09862858f, -0.07453877f, 0.05264259f, 
    -0.04479583f, 0.06331809f, -0.02550820f, 0.05095369f, 0.05076327f, -0.10503732f, 0.00844615f, -0.15587726f, 
    -0.03929144f, -0.01373888f, -0.05573601f, 0.04892823f, 0.19540225f, -0.43100247f, 0.17837371f, 0.17704816f, 
    -0.24640809f, -0.02339440f, 0.20003480f, 0.12287832f, -0.24739365f, 0.18511374f, -0.19439563f, 0.05348260f, 
    -0.09725051f, -0.08117758f, -0.13643031f, -0.03169490f, -0.09265646f, -0.07162719f, -0.13148485f, -0.05185016f, 
    -0.52476871f, 0.46650589f, -0.11859402f, -0.01955747f, 0.14998752f, -0.01788978f, 0.05084975f, 0.22287789f, 
    -0.17993951f, 0.10702590f, -0.01520045f, -0.07709552f, -0.03542882f, -0.16033508f, 0.14122124f, -0.13105273f, 
    -0.10760595f, 0.06233345f, 0.08022807f, -0.09712360f, -0.24436358f, 0.30319336f, 0.16335283f, 0.12693079f, 
    -0.31058455f, 0.17383198f, -0.24490754f, -0.05407323f, -0.07564864f, -0.04604274f, 0.02937262f, -0.10683739f, 
    0.03705687f, -0.28583330f, 0.08412980f, -0.00900106f, 0.13603632f, -0.03150306f, 0.09830382f, 0.00069191f, 
    0.02421003f, -0.80469722f, -0.30597210f, -0.26297480f, -0.43197641f, 0.05660674f, 0.03859634f, 0.13665614f, 
    -0.08968868f, 0.19279303f, 0.07567754f, 0.02567446f, -0.10959339f, -0.11967114f, -0.08254737f, -0.00520956f, 
    -0.04813356f, -0.11929640f, -0.11193816f, -0.01032403f, 0.14266621f, 0.07595985f, -0.14854163f, 0.22460234f, 
    0.04293381f, -0.14304517f, 0.17257798f, -0.04219293f, -0.02685408f, 0.11227510f, -0.01432856f, -0.08820023f, 
    0.13704872f, 0.19413155f, -0.00797565f, 0.12432569f, -0.01124133f, -0.17041072f, -0.01928569f, 0.00345565f, 
    0.22383562f, -0.17618255f, 0.20178045f, -0.05508664f, -0.14022090f, 0.06946327f, 0.06901934f, 0.09250445f, 
    -0.19483815f, -0.01553057f, -0.32208613f, -0.24742186f, 0.17300922f, 0.08366013f, -0.09145861f, 0.00101736f, 
    0.04917815f, 0.04724181f, -0.28021714f, -0.12987363f, -0.18920073f, 0.24738912f, -0.31927666f, -0.59951556f, 
    0.10814454f, -0.10170418f, -0.32642365f, -0.02250315f, -0.20928647f, -0.10643780f, -0.02280300f, 0.13746311f, 
    0.04152237f, -0.00897064f, 0.10572938f, 0.10888379f, -0.07040139f, -0.08646367f, 0.26585820f, -0.05860292f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.17716828f, 0.08079153f, -0.05285466f, 0.04980524f, 0.01227923f, -0.01224174f, 0.04188138f, -0.09904628f, 
    -0.05537596f, -0.01921036f, 0.11530518f, 0.02150642f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
