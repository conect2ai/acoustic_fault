#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.02274070f, 0.87718761f, -0.48113301f, 0.21317607f, -0.46198913f, 0.61500102f, -0.34115300f, -0.81110406f, 
    -0.35927692f, -0.05924610f, 0.44355667f, -0.10977653f, 0.01461535f, -0.17318924f, -0.16311117f, -0.05190993f, 
    -0.49866045f, 0.09478906f, -0.11684691f, -0.28012294f, -0.11267940f, 0.16954358f, -0.16472597f, 0.16579100f, 
    -0.05434578f, -0.77969384f, -0.01058794f, 0.10555196f, -0.28796467f, -0.49482405f, 0.56604165f, 0.68095315f, 
    0.37565163f, 0.43220332f, 0.50147361f, -0.06907802f, 0.01870895f, 0.11884402f, -0.19626342f, -0.31402972f, 
    0.34861851f, -0.26700974f, -0.12902559f, -0.29347369f, 0.06053300f, -0.24524738f, -0.25620356f, 0.07702078f, 
    -0.09823001f, 0.05669929f, -1.02453732f, 0.21155013f, 0.67240316f, 0.69589728f, -0.49780399f, 0.15751998f, 
    0.10439240f, 0.06111127f, -0.20019071f, 0.37750757f, -0.35485622f, 0.03973091f, -0.35440114f, -0.03850725f, 
    -0.27145106f, -0.04598595f, 0.10812506f, -0.13014124f, -0.07590773f, -0.01309500f, -0.12735343f, -0.10060118f, 
    -0.25286618f, -0.00277941f, -0.56620020f, -0.23811488f, -0.08695543f, -0.35792664f, -0.50518447f, -0.35883263f, 
    0.44993609f, 0.25274166f, -0.43261638f, 0.51495129f, 0.44241768f, 0.45459282f, -0.34990579f, 0.04394174f, 
    -0.06879664f, -0.53765559f, -0.00597614f, -0.15630458f, 0.04586452f, 0.03134874f, -0.29348817f, -0.13547701f, 
    -0.00244758f, -0.19408175f, -0.04273458f, 0.37160361f, 0.08168067f, -0.90981144f, -0.62230974f, -0.41509295f, 
    -0.18333393f, 0.15664116f, 0.48993042f, 0.12546353f, 0.01212104f, 0.43618026f, -0.29206628f, 0.30269435f, 
    -0.08199502f, 0.12163997f, -0.06378838f, -0.12506174f, 0.26007125f, 0.42975172f, 0.08294705f, -0.11355624f, 
    0.00400390f, 0.01785479f, 0.04985895f, -0.07799054f, 0.20422164f, -0.68934768f, 0.45783257f, 0.35887194f, 
    -0.23586954f, 0.17997697f, 0.73278600f, -0.48062038f, -0.57978487f, -0.09127028f, -0.68412620f, -0.36089996f, 
    -0.17969260f, -0.34845084f, -0.09403812f, -0.61736488f, -0.15147078f, 0.00334145f, 0.08408844f, -0.29338816f, 
    -0.09676645f, 0.11138687f, 0.33521473f, 0.02278353f, -0.01428247f, -0.38103208f, 0.07011218f, 0.94657832f, 
    0.58095139f, 0.34735647f, -0.36187631f, -0.74493390f, 0.45653912f, -0.17622195f, 0.47137275f, -0.46891376f, 
    0.07280308f, -0.24523288f, 0.21640670f, -0.12308079f, 0.14115113f, 0.12299985f, 0.20409241f, 0.29893366f, 
    -0.03219532f, -0.17625909f, -0.15761289f, -0.34695911f, -0.00547670f, -0.15921593f, -0.10022165f, 0.34910032f, 
    -0.09001595f, -0.32016861f, 0.99609548f, -0.09818712f, -0.24538465f, 0.35913584f, 0.12478482f, -0.28118584f, 
    0.27232784f, 0.26786241f, -0.30299053f, -0.15952614f, 0.18131225f, 0.24099182f, 0.12426694f, -0.44272146f, 
    0.02240030f, 0.35169050f, 0.04202458f, 0.52029514f, -0.40584809f, 0.58363539f, 0.04600138f, 0.11202512f, 
    -0.56854534f, -0.43472680f, -0.37407386f, -0.09567741f, -0.36398190f, 0.04187221f, 0.17557032f, -0.44129321f, 
    -0.03474914f, -0.58659416f, -0.12888630f, 0.54872549f, -0.02906767f, 0.09099046f, 0.34637922f, -0.03744699f, 
    -0.26904961f, -0.29209244f, -0.26767167f, 0.06336750f, 0.06788252f, 0.31431368f, 0.46198663f, -0.07598129f, 
    0.10155931f, 0.33693472f, -0.45073199f, -0.30255324f, -0.54733604f, 0.13475895f, 0.66663396f, -0.50469428f, 
    0.58247375f, 0.72919905f, -0.09220934f, -0.48605075f, -0.13502011f, -0.12879652f, -0.19173595f, -0.42354441f, 
    -0.21302113f, -0.03212248f, 0.13807607f, 0.17980641f, -0.06381058f, -0.36469391f, -0.23131441f, -0.47362468f, 
    -0.12970839f, 0.20600104f, 0.71234536f, 0.53064799f, -0.92107165f, -0.68614662f, -0.61854649f, 0.65968698f, 
    0.15944915f, 0.04382848f, 0.53863549f, 0.22181220f, -0.30240080f, -0.16933495f, -0.37899145f, 0.02384847f, 
    0.01409537f, 0.22013138f, 0.09820938f, -0.25251096f, 0.13168062f, 0.36692938f, 0.17049895f, -0.03034529f, 
    -0.15509400f, 0.09661859f, -0.21871574f, 0.28656784f, 0.68734872f, 0.82390922f, -0.61694872f, -1.10045958f, 
    -0.13713694f, -0.39429495f, -0.01162699f, -0.14933608f, -0.10468110f, 0.41103169f, 0.31178296f, -0.20553705f, 
    0.01460427f, 0.34138945f, 0.18564074f, 0.21008721f, -0.26408890f, 0.08036318f, -0.11645222f, -0.01647659f, 
    0.13665195f, 0.11583520f, -0.01817108f, 0.09183430f, 0.99188995f, 0.32021201f, -0.75631195f, 0.47706681f, 
    -0.43310857f, 0.04590449f, 0.37654066f, 0.30520189f, 0.42563996f, 0.02560453f, 0.30041027f, -0.18136686f, 
    -0.02232627f, -0.51851362f, 0.29626995f, 0.01170481f, -0.28265134f, 0.06157443f, -0.19967318f, 0.26576722f, 
    -0.48386559f, -0.25043482f, 0.09288981f, -0.28627339f, -0.21738727f, -0.48026997f, -0.21157801f, -0.32907373f, 
    -0.33681789f, -0.15556647f, 0.57365775f, 0.54842740f, 0.11522150f, 0.16583805f, 0.46423346f, -0.22911139f, 
    -0.09307717f, 0.02574731f, 0.11224934f, -0.30729944f, -0.18527564f, 0.25436446f, 0.22099014f, -0.01648452f, 
    0.25172165f, -0.20022666f, -0.25642630f, 0.31426319f, -0.07484888f, 0.14677612f, 0.04472836f, 0.17625272f, 
    -0.61274135f, -0.59402996f, -0.49419236f, -0.48128426f, -0.29910085f, -0.08168891f, -0.26997557f, -0.35512179f, 
    0.50760388f, -0.12838750f, -0.06279102f, 0.15013163f, 0.20234112f, -0.01106852f, -0.04666229f, -0.39464080f, 
    -0.23164001f, 0.33978876f, -0.00535671f, 0.52517158f, 0.29470161f, -0.01749149f, 0.12939873f, 0.07196646f, 
    -0.64213961f, 0.11208394f, 0.22034504f, 0.46398371f, -0.92955166f, -0.50240815f, -0.59142321f, -0.70145363f, 
    -0.26635000f, 0.29411429f, 0.49918965f, 0.14159924f, 0.02711795f, -0.14654353f, -0.39540270f, 0.02285105f, 
    0.01113068f, 0.09969689f, -0.13737464f, -0.04843323f, -0.08500259f, -0.23344706f, -0.09391272f, -0.15835725f, 
    -0.74057412f, -0.66227806f, -0.60796577f, 0.04430986f, -0.50275218f, -0.32140726f, -0.22859710f, -0.40789232f, 
    0.43910661f, 0.38700381f, 0.33468270f, 0.04348059f, -0.21981566f, -0.04453209f, -0.04179526f, -0.09199664f, 
    0.19236624f, -0.03789418f, 0.00092296f, 0.33229828f, -0.18309246f, 0.18446420f, -0.09517965f, 0.02458893f, 
    0.03019398f, 0.36359394f, 0.04702719f, 0.27189130f, 0.16692899f, -0.07439760f, 0.71261466f, 0.14361970f, 
    0.20910859f, -0.47180423f, -0.23605070f, -0.26237866f, -0.33953190f, 0.25756484f, -0.16450582f, 0.32262692f, 
    -0.03142208f, 0.42681193f, -0.20337367f, 0.00141510f, -0.00412433f, -0.23274240f, -0.31180102f, -0.31261805f, 
    -0.37525126f, -0.31574115f, 1.12582338f, 0.57703888f, 0.43523920f, -0.52801573f, -0.48133510f, 0.09645093f, 
    0.16540246f, -0.46256956f, 0.05898062f, 0.04963187f, 0.33479106f, 0.21475191f, -0.28173316f, 0.12217727f, 
    0.12801850f, -0.06354399f, -0.22449359f, 0.27044854f, 0.02981886f, -0.01530443f, -0.12312978f, 0.03987468f, 
    -0.02623007f, 0.06785078f, 0.14035769f, -0.40354520f, -0.79100543f, -0.83343685f, -0.57942933f, -0.31923392f, 
    -0.13208300f, 0.24867079f, 0.45699733f, 0.12679306f, 0.44189492f, 0.02794202f, -0.27976966f, 0.15125002f, 
    0.09050314f, 0.20584051f, -0.07402004f, 0.25980955f, 0.15454298f, 0.24794470f, 0.16984157f, 0.07060611f, 
    -0.15167649f, -0.39429861f, 0.02268572f, 0.23559095f, -0.16825169f, -0.06059434f, 0.27596816f, 0.81578082f, 
    0.63455212f, 0.09237440f, 0.53330266f, 0.38083032f, 0.71440715f, 0.30316931f, -0.26908472f, -0.01543100f, 
    -0.45007810f, 0.05389681f, -0.19576873f, 0.17066647f, -0.00817997f, -0.07105614f, 0.16877210f, 0.05782646f, 
    0.15218106f, 0.32007682f, -0.08952323f, 0.22810704f, 0.30901754f, -0.44797263f, -1.30564570f, -0.18491818f, 
    0.88555783f, 0.40744179f, 0.52730370f, 0.74597377f, 0.42087552f, 0.17597497f, -0.05667565f, 0.04877376f, 
    0.26187509f, -0.16719408f, 0.25569642f, 0.17154501f, -0.05348336f, -0.15770240f, -0.18960784f, -0.16899954f, 
    -0.04209895f, -0.03901960f, 0.27779964f, -0.09877306f, 0.06726108f, -0.16104527f, -0.69776499f, 0.40504700f, 
    0.97999531f, -1.08829200f, -0.17081150f, 0.80155736f, 0.13401620f, -0.59684294f, -0.20585944f, -0.56442702f, 
    -0.04424810f, 0.42746124f, -0.19709797f, 0.30653530f, 0.09523787f, -0.07865439f, -0.08736876f, -0.09536660f, 
    -0.16529706f, -0.06629571f, 0.11072331f, -0.02130179f, 0.13505992f, 0.31911212f, 0.00904597f, 0.92491913f, 
    -0.34208727f, 0.22314222f, -0.09662472f, -0.24495776f, -0.14893526f, 0.41801304f, -0.43873754f, -0.37931773f, 
    0.23676801f, -0.18129653f, -0.03287801f, -0.09169963f, -0.12956065f, -0.23079418f, -0.07600123f, 0.28762916f, 
    -0.26250651f, -0.14584018f, -0.10881263f, 0.09607653f, -0.05809651f, 0.08738244f, -0.09432098f, 0.04765432f, 
    -0.58903712f, 0.10071455f, -0.60268235f, -0.83944523f, 0.33198619f, -0.17835447f, 0.19935735f, 0.48389617f, 
    0.37024084f, 0.42925525f, -0.36069420f, -0.25554085f, -0.19376281f, 0.16414163f, -0.24507453f, 0.56604499f, 
    -0.01585452f, 0.08163074f, -0.06853740f, -0.00084536f, -0.08806831f, -0.13949166f, 0.30073750f, 0.17917398f, 
    0.22753251f, -0.56145811f, -0.57713598f, 0.47590905f, 0.64535749f, 0.54451627f, -0.68034267f, 0.13106227f, 
    0.11993735f, -0.11698858f, 0.00224582f, -0.00686168f, -0.31628123f, 0.10871117f, 0.24569626f, 0.07849620f, 
    0.15791643f, 0.36253977f, 0.26783201f, -0.20495805f, 0.11578570f, -0.24666786f, -0.22958770f, -0.17510015f, 
    0.19880648f, 0.02426246f, 0.13951649f, 0.80316621f, 0.51802194f, 0.57671130f, 0.60780793f, 0.14978944f, 
    0.03134520f, -0.27930641f, -0.18202077f, -0.20461299f, 0.39487299f, 0.17329185f, 0.02935276f, 0.15043859f, 
    0.11796441f, 0.15677635f, 0.24375764f, 0.08373035f, -0.16744420f, 0.40350616f, 0.01783417f, -0.26975882f, 
    0.24032262f, -0.06395429f, 0.38745269f, -0.60280401f, -0.03599141f, -0.51038742f, -0.09462336f, -0.38777480f, 
    0.25669569f, 0.71287239f, -0.04423782f, -0.04154147f, -0.40207112f, 0.03752974f, 0.13575207f, -0.13555156f, 
    -0.30602881f, 0.31684557f, 0.10334150f, 0.14995368f, -0.16792448f, -0.28553602f, -0.14522602f, -0.22941852f, 
    -0.01086681f, 0.13455817f, 0.44656700f, -0.08027757f, -0.00871891f, 0.55048406f, 0.78090477f, -0.08285589f, 
    0.33416307f, 0.71153980f, -0.15520717f, 0.43609360f, 0.30751237f, -0.24310042f, 0.12756637f, -0.29925984f, 
    -0.23941781f, 0.05242347f, 0.06306143f, 0.09738805f, -0.01928165f, -0.09751086f, 0.04712930f, 0.28745288f, 
    -0.32102829f, 0.38207394f, 0.19489355f, -0.12372935f, 0.13440350f, -0.14706242f, -0.84808493f, -0.78419173f, 
    -0.17362583f, -0.34971622f, -0.78744477f, 0.85694695f, 0.53328472f, -0.02692112f, 0.55448425f, 0.07338225f, 
    -0.34884506f, -0.10961460f, -0.08428136f, 0.11762356f, -0.03180977f, -0.10541845f, -0.14100619f, -0.16282383f, 
    -0.12892736f, 0.26944092f, 0.26989296f, -0.10358069f, 0.30419010f, -0.02191808f, -1.04807484f, 0.07439373f, 
    -0.31840628f, -0.54564267f, -0.20865552f, 0.02783812f, -0.21536143f, 0.30443275f, 0.44367191f, 0.01317334f, 
    0.42251271f, 0.13319030f, -0.04492603f, -0.19860452f, 0.23021133f, 0.26734823f, 0.12267140f, 0.11708292f, 
    -0.09521793f, 0.01280543f, -0.07272415f, -0.23979416f, 0.25351825f, -0.27854472f, 0.10546834f, -0.55490404f, 
    -1.01434934f, 0.35999915f, -0.05967592f, -0.27057168f, 0.32194579f, -0.39496547f, 0.76330656f, 0.15729786f, 
    -0.43780428f, 0.15031365f, -0.46412557f, 0.01096349f, 0.23845866f, -0.31132969f, -0.04011869f, 0.34914851f, 
    -0.19043057f, -0.18750298f, -0.00058310f, 0.00624266f, 0.07506977f, 0.33380437f, 0.03244734f, -0.10130189f, 
    -0.49844572f, -0.41113544f, 0.64514178f, 0.13234963f, 0.42862216f, -0.15096846f, 0.13071255f, -0.46131852f, 
    -0.44046977f, 0.00727351f, 0.62370968f, -0.17457581f, 0.46114635f, 0.16935971f, -0.07774488f, 0.49193105f, 
    0.12703083f, 0.13407061f, 0.16213219f, 0.28576761f, -0.16128476f, -0.21674860f, -0.03692067f, -0.47993541f, 
    0.25784501f, -0.08509122f, 0.81466556f, 0.65141875f, 0.20649932f, 0.33840382f, -0.88459307f, 0.83354187f, 
    -0.19422512f, -0.56682783f, -0.17096904f, 0.05956000f, 0.00574389f, 0.31419030f, 0.28949681f, 0.00666863f, 
    -0.05450182f, -0.13126059f, -0.09768399f, -0.04305783f, -0.27392390f, -0.21322465f, 0.16269666f, 0.22489196f, 
    0.20076206f, -0.13644460f, 0.66091835f, 0.10374694f, 0.31866875f, 0.74156415f, 0.79018718f, -0.53574580f, 
    -0.06909326f, 0.39656445f, -0.55188733f, -0.19141433f, -0.09829751f, -0.37352917f, -0.48786807f, 0.29361010f, 
    -0.08558180f, -0.04515371f, 0.09759618f, 0.36352009f, 0.27025139f, -0.23782152f, 0.17476800f, -0.08954357f, 
    -0.27192780f, -0.19795501f, 0.16437805f, 1.01909721f, 0.52531886f, -0.62888211f, -0.35029617f, 0.27735856f, 
    -0.18860178f, -0.36730713f, 0.36783683f, 0.32333872f, 0.35327432f, -0.10187197f, -0.01637686f, 0.52861351f, 
    0.00276361f, 0.19835649f, -0.12618899f, -0.23485641f, -0.13742156f, -0.33697671f, 0.11367669f, -0.10801918f, 
    -0.00198309f, -0.12423302f, 0.09487493f, 0.11549859f, 0.29165736f, -0.51129192f, -0.48044139f, 0.33350834f, 
    -0.43917567f, 0.56544286f, 0.06656492f, 0.20301065f, 0.33136076f, 0.37199458f, -0.04365151f, 0.37610614f, 
    -0.02510346f, -0.09351977f, -0.26202548f, -0.15720057f, 0.09821174f, 0.10744137f, 0.00120171f, 0.31877035f, 
    0.03053829f, 0.30682451f, -0.10460896f, 0.60856104f, -0.23725951f, 0.66607171f, 0.63234323f, 0.44566408f, 
    0.55377048f, 0.80339074f, 0.33525783f, -0.01854108f, 0.22221166f, -0.34055540f, -0.40356058f, -0.40603107f, 
    -0.22818466f, -0.09390681f, 0.21537116f, 0.13123871f, 0.14401408f, 0.30329168f, 0.14150187f, -0.02759038f, 
    0.23529109f, 0.20000483f, -0.02914190f, 0.25762576f, 0.04671706f, -0.02086370f, -0.12627399f, -0.58815855f, 
    -0.66558027f, -0.01360239f, 0.39369550f, -0.23414637f, -0.14953540f, -0.35597661f, -0.01415499f, 0.41382128f, 
    0.14681591f, 0.18909454f, 0.13721980f, 0.10512980f, 0.41560379f, 0.25280887f, 0.32764813f, 0.08124036f, 
    0.23177743f, 0.49153233f, -0.06218066f, 0.10571297f, 0.19447136f, -0.32055637f, -0.38047114f, 0.53733569f, 
    0.42623481f, 0.45849708f, 0.27052397f, 0.80689794f, 0.11793626f, -0.35877705f, -0.14739493f, -0.29750332f, 
    -0.33979154f, 0.22490658f, 0.20766702f, -0.33862379f, 0.16642562f, -0.32801625f, -0.10671126f, 0.09914383f, 
    -0.23602034f, 0.36221531f, 0.00431883f, 0.26507846f, 0.08821259f, -0.05784557f, -0.00173802f, 0.43429840f, 
    1.09398258f, 0.35515237f, -0.31330329f, 0.78632969f, -0.09482125f, -0.38264805f, -0.47412223f, 0.38470614f, 
    0.11344092f, 0.29589859f, -0.25011161f, -0.17790045f, 0.13184801f, -0.18043587f, -0.04572318f, 0.12215569f, 
    -0.07662917f, 0.20777215f, -0.06369162f, 0.28626597f, 0.50126135f, -0.05856732f, 0.20182498f, 0.10436095f, 
    0.20319054f, -0.14495134f, -0.18595208f, 0.04916525f, 0.60862082f, 0.68162543f, 0.62615591f, 0.64541227f, 
    0.13965672f, 0.09016146f, 0.27314410f, -0.21550132f, -0.27186441f, -0.07405721f, 0.03244146f, -0.10162745f, 
    -0.25313538f, -0.30089241f, 0.10573744f, -0.30705056f, -0.42049456f, -0.25365525f, -0.08863200f, -0.05763362f, 
    -0.29872665f, 0.14157189f, -0.62010938f, -0.67677873f, -0.59827667f, -0.66327000f, -0.29620126f, -0.51791918f, 
    -0.41024229f, 0.15908834f, -0.13192058f, -0.23137619f, -0.24486266f, 0.09027103f, -0.01881446f, 0.00704833f, 
    -0.36026299f, -0.08018253f, -0.00065321f, 0.07016765f, 0.11804419f, -0.00646946f, -0.14276989f, -0.00192390f, 
    -0.35956094f, 0.17525035f, -0.07270233f, 0.58696222f, -0.28735170f, -0.01063687f, -0.64306170f, 0.35078537f, 
    0.51022679f, 0.00290460f, 0.61237341f, -0.10833483f, -0.09993860f, 0.20678137f, 0.35709614f, 0.15271769f, 
    -0.30869660f, -0.23572777f, -0.35480067f, -0.39533013f, 0.37372518f, 0.40269139f, -0.36763409f, 0.04677535f, 
    0.27610025f, 0.04724388f, -0.01488369f, -0.07843702f, 0.18620189f, 0.38082239f, 0.66281015f, 0.39865515f, 
    -0.91481960f, -0.83836430f, -0.63440579f, 0.08552314f, -0.18266042f, -0.03157532f, 0.34336203f, -0.00826865f, 
    -0.07880093f, 0.20076972f, -0.40953839f, -0.45227206f, -0.20018148f, 0.10003493f, 0.02834936f, -0.29991797f, 
    0.53740895f, -0.12591754f, -0.20001446f, 0.05799698f, 0.01971202f, -0.31012270f, 0.31205240f, 0.21323857f, 
    -0.12121779f, -0.18799947f, 0.72389442f, -0.07732100f, 0.00351914f, -0.77629131f, -0.26993033f, -0.04802378f, 
    -0.25441542f, 0.29862940f, 0.17003943f, -0.03365670f, -0.34770423f, 0.33263800f, -0.34436536f, -0.00013934f, 
    0.05917497f, -0.00931632f, -0.09757327f, 0.08776047f, -0.24979648f, -0.07768475f, 0.89305693f, 0.27214146f, 
    0.50076383f, 0.64808923f, 0.22574261f, 0.26607549f, -0.16933659f, 0.04522833f, -0.55203813f, 0.13475996f, 
    0.00825377f, 0.16101578f, 0.10626903f, 0.05618934f, 0.25305316f, -0.35569185f, -0.28723440f, 0.30006921f, 
    -0.13753375f, 0.05383386f, -0.26869288f, 0.27174231f, -0.38586429f, 0.20297994f, -0.05483247f, -0.99087960f, 
    0.92780757f, 0.62268293f, -0.48474079f, 0.22596507f, -0.88115203f, 0.65848315f, 0.28560349f, -0.35431510f, 
    -0.07623799f, -0.25924489f, 0.14952791f, 0.02178523f, -0.04189926f, -0.07972774f, 0.25544545f, -0.10271922f, 
    -0.08345918f, 0.12663046f, 0.03726588f, 0.04687815f, -0.08266176f, 0.04252766f, -0.01941311f, -0.04832544f, 
    -0.96808153f, -0.25156116f, -0.28149632f, 0.66222399f, 0.70291954f, 0.87422508f, 0.16113400f, -0.54999393f, 
    0.23752035f, -0.63332891f, -0.11616982f, 0.11177513f, -0.03211746f, 0.35859266f, -0.00309536f, -0.03824764f, 
    0.02202687f, -0.29103065f, -0.24110806f, 0.26766360f, 0.01090864f, 0.05417293f, 0.00907834f, -0.16682047f, 
    -0.14562526f, -0.10307367f, 0.71287429f, 0.66608626f, 0.33045080f, 0.43954343f, -0.27101690f, -0.32066643f, 
    0.28937912f, -0.13589896f, 0.14744490f, 0.10947130f, -0.09719144f, -0.19553754f, -0.24009453f, 0.26782551f, 
    -0.06124510f, -0.05498398f, 0.00544827f, -0.19499785f, 0.31497198f, 0.06707193f, 0.37489915f, 0.18918136f, 
    0.39216858f, 0.33991408f, 0.53303701f, 0.57133597f, 0.46351731f, 1.15800214f, 0.17784555f, -0.21190877f, 
    0.39342743f, -0.60838652f, 0.45996213f, 0.41892293f, 0.21234581f, -0.14090243f, 0.03049328f, 0.17759520f, 
    -0.68799323f, -0.32305631f, 0.09033738f, 0.33442453f, -0.20690663f, 0.07125541f, -0.02254123f, 0.38088980f, 
    -0.18889740f, -0.25509372f, -0.28551629f, -0.68244004f, 0.26305899f, 0.64507782f, -0.53790325f, 0.55574769f, 
    0.09464692f, -0.03321582f, 0.52641803f, -0.54809344f, 0.01935944f, -0.08599737f, -0.05810314f, 0.19458036f, 
    -0.47791064f, -0.20308104f, -0.46108389f, -0.38452750f, 0.03528615f, -0.48855785f, -0.34950072f, -0.11983423f, 
    0.19690074f, 0.01701454f, -0.05297321f, 0.25434646f, 0.00378913f, -0.91448194f, 0.19219202f, 0.36178169f, 
    -0.04532230f, -0.26689056f, 0.45648417f, 0.40749112f, -0.01854611f, -0.00032684f, 0.21842349f, 0.38358149f, 
    0.02173150f, -0.22687379f, 0.30862734f, -0.58427620f, -0.04279554f, -0.42095840f, -0.00641297f, 0.10505478f, 
    -0.13378257f, -0.13827352f, 0.09348228f, -0.24620882f, 0.26432312f, 1.08401799f, -1.09852731f, 0.25988278f, 
    -0.32265195f, 0.83728838f, 0.52071065f, 0.26097238f, 0.33261836f, 0.11374148f, 0.33555377f, -0.01150225f, 
    0.41256353f, -0.32920307f, 0.37726015f, 0.06533580f, 0.16413450f, -0.24892733f, 0.09078480f, 0.03733605f, 
    0.16065329f, 0.16603887f, -0.00697177f, -0.03060565f, 0.16243960f, -0.01483896f, -0.32929292f, 0.70217502f, 
    -0.48268056f, -0.41259569f, 0.77262861f, 0.25534913f, -0.64592439f, -0.23536575f, -0.70729339f, 0.10966981f, 
    0.21713156f, -0.36897016f, 0.36193529f, 0.05806188f, 0.25850353f, 0.35843268f, 0.34480745f, 0.08738133f, 
    0.20347118f, -0.05623262f, 0.10022849f, 0.00804214f, -0.06603649f, -0.12346648f, 0.31628251f, 0.64364702f, 
    0.25741738f, 0.18982406f, 0.64343220f, 0.33416414f, 0.08601943f, 0.42296714f, 0.16013418f, 0.35667297f, 
    0.57107949f, -0.25302005f, 0.16403544f, 0.33291250f, -0.01197752f, -0.11865422f, -0.47663742f, -0.23368230f, 
    0.00676502f, -0.29006651f, 0.06434594f, 0.29610792f, -0.15705004f, 0.45415708f, 0.12485244f, 0.00060889f, 
    -0.50583833f, 0.45471939f, -0.53475004f, 0.09769612f, -0.38958180f, -0.30586112f, -0.44676185f, -0.67988366f, 
    0.18234612f, -0.32806724f, 0.13253836f, 0.21219763f, 0.32571235f, 0.21055944f, -0.41809136f, -0.03727174f, 
    -0.17923714f, 0.49501327f, 0.23665789f, -0.04144990f, -0.07227800f, 0.16183718f, -0.45501825f, 0.17358124f, 
    0.51758492f, 0.54522228f, 0.77490622f, 0.62352943f, -0.25261161f, -0.00361127f, -0.45802891f, -0.44498149f, 
    0.02197868f, -0.33453855f, 0.31550983f, 0.31940711f, 0.54162019f, -0.27933866f, -0.09897257f, -0.02242857f, 
    0.11692557f, 0.09920853f, -0.23106694f, 0.05552195f, 0.39769715f, 0.33749399f, -0.05702778f, -0.18164624f, 
    -0.07656874f, -0.06187291f, -0.57424986f, 0.87777948f, -0.12902652f, -0.55157101f, 0.60099334f, -0.29393381f, 
    -0.21064834f, -0.11737771f, -0.86329311f, -0.69164163f, -0.13554741f, 0.26406169f, 0.27354804f, 0.32254598f, 
    0.15931347f, -0.21130647f, 0.24101654f, -0.05745298f, 0.10544643f, 0.49114749f, 0.13877882f, -0.00491687f, 
    0.08684354f, 0.24711786f, 0.06240699f, 0.81479007f, 0.74247736f, -0.02232940f, -0.44024903f, 0.59110463f, 
    0.54773861f, -0.14445065f, -0.09009593f, 0.17826299f, 0.60405570f, -0.35279071f, -0.02644729f, -0.25375444f, 
    -0.48541015f, -0.35114256f, -0.12509991f, -0.05206753f, -0.26034546f, -0.31354555f, -0.23406991f, 0.08637439f, 
    -0.18277158f, 0.02281871f, -0.30823138f, -0.07795613f, -0.34901309f, 0.90232444f, 0.65012163f, -0.01830337f, 
    0.58671373f, 0.37751502f, 0.54044950f, -0.46554780f, 0.00462780f, -0.19588956f, -0.10623131f, 0.01650647f, 
    0.10633951f, -0.16995361f, -0.10615364f, 0.27257469f, 0.37024173f, 0.09234877f, -0.27575943f, -0.21314231f, 
    0.02030164f, 0.37876755f, -0.10543095f, 0.23162414f, 0.08446825f, -0.88321757f, -0.11061186f, -0.25200996f, 
    -0.44197762f, -0.20435634f, 0.61419547f, 0.64074796f, -0.55091089f, 0.51308328f, 0.60573083f, -0.04035128f, 
    -0.29332721f, 0.19347884f, -0.39466769f, 0.17173138f, -0.30302814f, 0.09682012f, 0.10187624f, 0.11035542f, 
    -0.09427077f, -0.21659531f, -0.05239792f, -0.21055430f, -0.01572229f, -0.11604055f, -0.69376415f, -0.39918026f, 
    0.20230481f, 0.36537042f, 0.12206560f, -0.69105011f, -0.02840909f, -0.25452366f, -0.06328751f, -0.51141447f, 
    0.37781858f, 0.38738260f, -0.32602856f, -0.00818021f, 0.23941548f, -0.30881056f, 0.32015318f, 0.67737645f, 
    -0.27219212f, 0.14207269f, 0.19017911f, -0.01086283f, 0.36513790f, -0.25199863f, -0.18843895f, 0.73871702f, 
    0.51217568f, 0.11296426f, 0.22173615f, 0.33323997f, -0.73411024f, -0.92518431f, -0.16932032f, -0.39394006f, 
    -0.28010398f, 0.11688885f, 0.18537940f, 0.07076542f, -0.05364335f, 0.13085371f, 0.30832919f, -0.15800767f, 
    -0.05073124f, -0.18317650f, -0.09146091f, -0.22950387f, 0.08937700f, 0.21940766f, -0.08099171f, -0.05303233f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.10242013f, 0.01033479f, -0.12927812f, 0.18337454f, 0.26170269f, 0.20092922f, 0.03531832f, 0.01956605f, 
    0.26134112f, 0.01300751f, 0.21118926f, 0.10506683f, 0.11288133f, 0.18711331f, 0.33539593f, 0.17443031f, 
    0.26715586f, -0.12143397f, 0.21375692f, 0.15104982f, 0.08598522f, 0.21642549f, 0.27941990f, 0.19629312f, 
    -0.03945096f, 0.28770798f, 0.03486006f, 0.02293060f, 0.18474635f, -0.06088066f, 0.23236087f, 0.01073976f, 
    0.23228693f, 0.17513455f, -0.15173480f, 0.09894921f, 0.10018200f, 0.18816915f, 0.21447529f, 0.20552373f, 
    0.12848046f, 0.09374328f, 0.03931857f, 0.04430335f, 0.17657518f, -0.09351318f, -0.00967060f, 0.07753184f, 
    0.14642245f, 0.31128418f, 0.08105315f, -0.00442928f, 0.18903577f, 0.20099130f, 0.00802069f, 0.08904895f, 
    0.37573957f, 0.03018171f, 0.15704615f, 0.16269548f, -0.02036726f, -0.04670992f, 0.09216303f, 0.12944470f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.20503044f, 0.09867802f, 0.04903967f, -0.09783006f, -0.12424830f, 0.07786401f, 0.05026282f, 0.01337334f, 
    -0.00891044f, 0.07360537f, -0.04747146f, -0.03080479f, 0.33272672f, 0.19631623f, 0.08309115f, -0.13166451f, 
    0.01789234f, 0.07025702f, 0.01819677f, 0.07104865f, -0.04558392f, 0.05781785f, 0.00377198f, -0.04107948f, 
    -0.10436637f, 0.14742582f, 0.08333395f, 0.40045759f, -0.10079817f, 0.01656150f, 0.07571158f, 0.03284038f, 
    0.07756621f, -0.10854106f, -0.05083760f, -0.05080546f, 0.18242307f, 0.03579018f, -0.09629442f, -0.17612265f, 
    0.02130092f, 0.06982715f, 0.03337852f, 0.00244531f, 0.07288254f, 0.05038060f, -0.04136825f, -0.03168850f, 
    -0.00441730f, -0.04569250f, -0.04031432f, -0.24996157f, 0.00142063f, -0.02018071f, 0.03859872f, 0.01939994f, 
    -0.11209013f, 0.04510074f, -0.01020311f, 0.02766660f, -0.40776071f, -0.07223588f, 0.10448091f, -0.00995963f, 
    0.05731386f, -0.04489749f, -0.02137893f, -0.10797983f, -0.04632029f, 0.00756570f, -0.04787946f, 0.02686044f, 
    -0.04245960f, 0.17602731f, -0.19610538f, 0.04314809f, -0.27329209f, -0.07405257f, 0.02339456f, -0.05505520f, 
    -0.05977188f, 0.05712791f, 0.03409936f, -0.13638599f, 0.17990820f, 0.26919654f, -0.20413657f, 0.32454258f, 
    -0.12290176f, 0.03329984f, -0.00021008f, -0.03053091f, 0.02799780f, -0.06991242f, 0.10288933f, -0.10276221f, 
    -0.11932475f, -0.02941438f, 0.09549697f, -0.10679612f, 0.07295690f, 0.04665112f, 0.00493732f, -0.01049697f, 
    -0.07197301f, 0.05478379f, 0.10669074f, -0.11902540f, 0.35278052f, -0.00779486f, -0.00736318f, -0.11418784f, 
    0.13850325f, 0.08783802f, 0.00518822f, 0.03010431f, 0.05962307f, 0.02009846f, 0.01332975f, 0.05915044f, 
    0.12479800f, -0.00167916f, -0.00928849f, -0.26496002f, -0.03543895f, -0.05242210f, 0.02601676f, -0.03013029f, 
    -0.10465319f, 0.04421289f, 0.05276984f, 0.14143078f, -0.50572622f, 0.26402459f, -0.01690255f, 0.04047977f, 
    0.02539844f, 0.05392153f, 0.01059397f, -0.07268082f, 0.02113533f, 0.02187344f, 0.00841161f, 0.07146396f, 
    -0.15275614f, 0.08865846f, -0.12425416f, 0.12335614f, -0.26360390f, 0.02040421f, -0.00863307f, 0.01923377f, 
    0.07653055f, 0.05608758f, 0.04233909f, -0.11590886f, 0.13861395f, 0.08468948f, -0.00302226f, -0.14446233f, 
    0.13007069f, 0.06401804f, -0.07675905f, 0.08435787f, -0.05159120f, 0.03441915f, -0.07897555f, 0.04420527f, 
    -0.33350432f, -0.15288693f, -0.05104362f, 0.01298173f, -0.09922123f, 0.01954401f, 0.08710138f, -0.05740236f, 
    -0.04412667f, -0.06484091f, -0.01479840f, 0.00738646f, 0.00063115f, -0.25220197f, -0.01843018f, 0.03932401f, 
    -0.07948996f, -0.02846988f, 0.04365313f, -0.07639042f, -0.00287130f, 0.02844545f, -0.07757933f, -0.04289233f, 
    0.09250608f, -0.12568147f, -0.32493567f, 0.02989574f, -0.10530970f, -0.01122625f, 0.07265146f, -0.05718551f, 
    -0.03155532f, 0.01731221f, 0.00421849f, -0.06489274f, -0.09621995f, -0.03772026f, 0.08825815f, -0.03204752f, 
    -0.23086135f, 0.02119454f, 0.03500040f, 0.13102622f, -0.04703391f, 0.12644297f, 0.01227592f, -0.03141532f, 
    0.01222724f, 0.18738733f, 0.10123669f, -0.19881204f, -0.19406725f, -0.00063065f, -0.03822141f, 0.06923170f, 
    0.02425281f, -0.00555386f, -0.04138590f, -0.03637874f, -0.04342362f, 0.06615809f, -0.11364968f, -0.33277464f, 
    0.02900529f, -0.01465183f, -0.00053864f, 0.02887533f, 0.05157518f, -0.03928125f, -0.03855731f, 0.11806251f, 
    -0.14734094f, 0.07614237f, 0.02016481f, 0.19313523f, -0.03629547f, -0.00342172f, -0.01977308f, -0.04071259f, 
    -0.09664347f, -0.01790738f, -0.02385627f, 0.08442806f, -0.33499089f, 0.07558136f, -0.10353638f, 0.21848558f, 
    0.02529813f, 0.09720770f, 0.01040985f, -0.04362047f, 0.01240624f, -0.07735987f, 0.07110065f, -0.01124090f, 
    -0.45381239f, 0.13875970f, 0.27127400f, -0.16598591f, 0.01748750f, 0.04305467f, 0.04475758f, -0.03407835f, 
    -0.00715802f, 0.05157438f, 0.02932929f, -0.04940250f, 0.07058685f, 0.06154399f, 0.05251955f, 0.03846210f, 
    -0.12404390f, -0.16564319f, -0.04980992f, 0.01550565f, -0.16092461f, 0.08588415f, 0.03207222f, 0.05558467f, 
    0.07662134f, 0.23082191f, -0.03092119f, -0.27711862f, 0.10812364f, 0.03247381f, 0.02397339f, 0.05947875f, 
    0.01488863f, 0.09940857f, -0.01341433f, -0.02303082f, -0.04990318f, 0.00039099f, -0.27189571f, 0.24503559f, 
    -0.02613475f, -0.09239617f, 0.07200334f, 0.03624718f, -0.03873841f, -0.04941399f, -0.05340292f, -0.05526815f, 
    -0.07909670f, -0.03258023f, -0.00538781f, -0.11280467f, -0.07063148f, -0.14833638f, 0.12748291f, 0.05645090f, 
    0.07565919f, 0.00660005f, -0.03710635f, -0.00341694f, 0.27883980f, 0.15429300f, 0.20244321f, -0.25234881f, 
    0.16817485f, 0.12783760f, -0.09647440f, 0.00685325f, 0.01548359f, 0.05963712f, -0.05814321f, -0.02021041f, 
    -0.01004924f, -0.08473049f, 0.13993204f, 0.00958472f, -0.26880640f, -0.05276844f, -0.00667600f, 0.00148474f, 
    0.05527027f, -0.06477036f, 0.04306363f, -0.02786095f, -0.44161776f, 0.23680316f, -0.08410473f, -0.16114041f, 
    -0.00395337f, 0.05858118f, -0.03552970f, -0.08369900f, -0.00571685f, -0.06677301f, -0.00620378f, 0.09606325f, 
    0.24263529f, -0.01415951f, -0.13545285f, 0.02876662f, -0.06873564f, -0.03096373f, -0.01741229f, 0.02456859f, 
    -0.00332011f, 0.03098557f, -0.04695824f, -0.12056544f, -0.15930647f, -0.08081306f, -0.00648839f, 0.06176966f, 
    0.01466390f, 0.10898744f, 0.01136160f, -0.02057488f, 0.00481800f, 0.02251558f, -0.06631233f, -0.13338391f, 
    -0.13904408f, -0.16880044f, 0.06835394f, 0.08606858f, 0.02045951f, 0.00381825f, 0.03157500f, 0.08278698f, 
    0.06946982f, 0.00088149f, -0.01367733f, -0.05250995f, -0.03485746f, 0.04423572f, -0.00828031f, 0.05283350f, 
    -0.10711103f, -0.03382221f, -0.06371894f, -0.04675193f, -0.09334198f, -0.03812343f, 0.01765755f, -0.09251473f, 
    0.19366586f, 0.11574029f, -0.08815964f, 0.16249822f, -0.20854236f, 0.01191391f, 0.05902366f, 0.02011434f, 
    -0.00306316f, -0.04805354f, 0.02707832f, 0.03347905f, 0.04046085f, -0.07224679f, 0.01768088f, -0.37716329f, 
    -0.05021483f, -0.12249335f, -0.02889277f, 0.13288592f, 0.07076118f, 0.00369893f, 0.05124535f, 0.04342214f, 
    0.10194805f, -0.00536181f, -0.23112667f, 0.03440243f, 0.03896222f, 0.00382337f, 0.02619877f, -0.09205081f, 
    -0.14591885f, 0.03096390f, 0.02808661f, 0.03191157f, 0.08505958f, 0.07068332f, -0.00454361f, 0.04199900f, 
    -0.06680437f, -0.00651181f, -0.00029800f, 0.04921338f, 0.03091216f, -0.04018180f, -0.03717390f, -0.08609521f, 
    -0.09995937f, -0.07640631f, 0.15465300f, 0.07325269f, 0.01116243f, 0.08967549f, 0.04537975f, -0.05499811f, 
    -0.06449731f, -0.09288570f, 0.04665379f, 0.03831035f, 0.11682805f, -0.03802687f, 0.11629821f, -0.17564036f, 
    -0.15571472f, -0.04540804f, -0.05881469f, 0.02443683f, 0.02195689f, -0.06942851f, 0.10048328f, -0.00349603f, 
    0.21985672f, -0.15522778f, -0.09867118f, 0.20704940f, -0.07881345f, 0.03546771f, -0.13643372f, 0.06195994f, 
    -0.13630851f, 0.10862286f, 0.00357084f, -0.02839376f, -0.12297380f, 0.00561952f, 0.07268495f, 0.16888282f, 
    -0.09867416f, -0.05004833f, 0.01695867f, -0.14018871f, -0.05367972f, -0.00522231f, -0.10642642f, -0.03006781f, 
    -0.30858892f, -0.10633917f, -0.15451959f, -0.11072908f, -0.03566084f, -0.04635890f, 0.01506193f, 0.02604213f, 
    0.12257469f, 0.03965191f, -0.01589722f, -0.08526625f, 0.08890159f, -0.02139238f, 0.01609198f, -0.38593596f, 
    0.01730961f, 0.06098750f, 0.09094983f, -0.07595052f, 0.01337923f, 0.17365938f, -0.09906302f, 0.03056048f, 
    -0.11066184f, 0.09615550f, -0.13620827f, 0.13534069f, -0.09006330f, -0.04478442f, 0.00125811f, -0.24861109f, 
    -0.00811112f, 0.01300704f, -0.02370268f, 0.02159847f, -0.16629232f, 0.04623593f, 0.09413480f, -0.14533159f, 
    0.06962756f, 0.01957694f, -0.03452220f, 0.05321516f, -0.05393086f, -0.02294849f, 0.03969711f, 0.02302840f, 
    0.22359833f, 0.03921701f, -0.16111317f, 0.00325045f, -0.16497193f, -0.18128301f, -0.01686853f, 0.03073131f, 
    -0.03363705f, -0.03187478f, -0.14826146f, 0.01162461f, -0.20375261f, -0.06326734f, 0.21365188f, 0.10506579f, 
    -0.03974139f, -0.01996367f, 0.01788519f, -0.01731338f, 0.05136614f, -0.13800493f, -0.01238820f, 0.06630833f, 
    -0.33358440f, -0.05968993f, 0.09236143f, 0.14418243f, 0.18433692f, 0.01445639f, -0.08779143f, -0.11201458f, 
    0.00962253f, -0.06877594f, 0.01233732f, -0.00978484f, -0.07935976f, 0.08301101f, 0.07310496f, -0.01891129f, 
    -0.05965886f, -0.08636573f, 0.01181336f, -0.06412316f, 0.00423794f, -0.08271601f, -0.04276976f, 0.06335081f, 
    -0.02586132f, 0.10239869f, -0.20578843f, 0.36886171f, -0.11699054f, 0.02092049f, -0.03499452f, -0.05441672f, 
    0.04289934f, 0.13587913f, -0.10656523f, -0.02373350f, -0.26546505f, 0.10318957f, 0.17836085f, -0.17618853f, 
    0.01124603f, -0.11612818f, 0.01306455f, -0.05318195f, -0.00508079f, 0.02127715f, 0.02217486f, -0.01864857f, 
    -0.14552265f, 0.09868073f, -0.17874517f, 0.11638983f, 0.03100834f, 0.03136976f, 0.01241431f, -0.09339463f, 
    0.09262308f, -0.00758899f, 0.02568428f, 0.10680479f, 0.16653325f, -0.13957956f, -0.04941228f, -0.11196115f, 
    0.10062877f, -0.00630473f, -0.07725585f, 0.03063359f, -0.03017017f, 0.07826758f, 0.10178070f, -0.09708674f, 
    -0.09378082f, -0.12531373f, 0.31594875f, -0.06457099f, -0.02486882f, -0.05386702f, -0.03220052f, -0.05897408f, 
    0.15711521f, 0.15198007f, 0.08076808f, 0.02270579f, 0.05376607f, 0.00560705f, -0.17636159f, 0.20206904f, 
    -0.11449594f, -0.07477060f, -0.09049954f, 0.00435622f, -0.07685395f, 0.07505199f, 0.00285343f, -0.00198321f, 
    -0.10496186f, -0.13567470f, 0.04524966f, 0.02262299f, 0.01726909f, 0.00459626f, 0.02780367f, 0.01999511f, 
    0.08210622f, -0.05357030f, -0.06632172f, -0.02522063f, 0.02776744f, 0.09313734f, 0.10288392f, -0.12827805f, 
    -0.00319050f, 0.01097003f, 0.08111963f, 0.07364482f, 0.09712990f, -0.14447977f, 0.03070047f, 0.04176681f, 
    -0.35059029f, 0.15318286f, 0.09935074f, -0.13316043f, -0.01045456f, 0.12752242f, 0.03910515f, 0.00331426f, 
    0.06163971f, -0.18249996f, -0.17385748f, -0.05423724f, 0.09715883f, -0.22006416f, 0.21269472f, -0.12627755f, 
    -0.15422235f, 0.03490185f, 0.12340027f, 0.03402791f, -0.01236864f, 0.04582387f, 0.03313094f, -0.07562256f, 
    -0.12689511f, -0.08506427f, 0.16101943f, -0.02948971f, -0.03020011f, -0.09054742f, 0.15600795f, -0.03268588f, 
    -0.08279345f, 0.00280941f, -0.20449117f, 0.05590185f, 0.50358534f, 0.08554221f, 0.08580212f, -0.11023363f, 
    0.07709752f, 0.10693900f, -0.03208313f, 0.03571465f, -0.03619506f, 0.00017129f, -0.02702335f, 0.13558467f, 
    -0.08780314f, -0.08167817f, -0.22672194f, 0.11787912f, 0.01357460f, 0.00777209f, 0.07128829f, 0.05031164f, 
    0.01388725f, 0.07574762f, 0.00653015f, -0.06992199f, 0.21835487f, -0.00191202f, 0.13614646f, -0.01700509f, 
    -0.19181824f, -0.07577685f, -0.09552481f, 0.10140017f, -0.05012314f, 0.03671953f, -0.01346853f, -0.05291582f, 
    0.04677669f, -0.17100930f, -0.15739115f, -0.15247460f, -0.04433091f, -0.07314868f, 0.02330943f, -0.03437573f, 
    -0.01217207f, -0.03856261f, -0.02303046f, -0.02622904f, -0.29632553f, -0.12145841f, -0.07068001f, -0.06245406f, 
    -0.00570277f, -0.03228803f, 0.01202407f, -0.14897606f, 0.01883483f, 0.00520372f, -0.02561996f, 0.01292988f, 
    -0.16234593f, -0.10227543f, -0.25647095f, 0.11187157f, 0.08712059f, -0.04297711f, -0.02301141f, -0.39206019f, 
    -0.13467373f, -0.03380264f, -0.02228240f, -0.08135877f, -0.17376085f, -0.08157936f, 0.02616983f, -0.10254012f, 
    -0.01383885f, -0.07287139f, -0.01878427f, 0.10694520f, -0.04003318f, -0.03106605f, -0.15468222f, -0.06404968f, 
    0.25275657f, -0.15814266f, 0.01368839f, -0.12410881f, 0.02883792f, 0.09690116f, 0.05309323f, 0.03162049f, 
    0.03791787f, -0.11468673f, 0.07416638f, -0.05464140f, 0.01974911f, -0.16624902f, -0.20756418f, -0.06678389f, 
    -0.05563847f, -0.01176964f, 0.01245171f, 0.03341623f, -0.01446739f, -0.02725759f, 0.01078638f, -0.08068227f, 
    0.17796806f, -0.01576486f, -0.27033716f, -0.03177066f, 0.12206379f, 0.07893702f, 0.00633734f, 0.01777818f, 
    0.03684035f, -0.18290244f, -0.08724034f, 0.17579910f, 0.08740407f, -0.09823782f, -0.01686341f, 0.05861012f, 
    -0.19269116f, 0.08974890f, -0.05225347f, 0.00499893f, -0.02589341f, 0.08090988f, -0.04692908f, 0.17909713f, 
    -0.08750145f, -0.00749331f, -0.07492206f, -0.01611328f, -0.09320343f, -0.03287137f, -0.05935459f, 0.07170863f, 
    0.02182040f, -0.02129784f, -0.08480298f, 0.06518995f, -0.08540342f, -0.18621299f, 0.13018914f, -0.07958964f, 
    0.05395038f, 0.03147508f, -0.16113165f, -0.01563407f, -0.01082094f, 0.08399098f, 0.14062308f, -0.02574308f, 
    0.09086350f, -0.39272267f, 0.15092270f, -0.32474494f, 0.06340970f, -0.07324983f, 0.00261788f, 0.00909331f, 
    -0.04028406f, 0.06872139f, -0.06605002f, -0.13219228f, -0.18627714f, -0.00691164f, -0.23199843f, -0.12268800f, 
    -0.03741349f, -0.05664668f, -0.02253812f, 0.02496996f, 0.00831141f, 0.02189453f, 0.01974110f, -0.09044497f, 
    0.34799248f, -0.15237851f, 0.06455316f, 0.05644775f, 0.04475004f, -0.09811726f, 0.02363344f, 0.08096963f, 
    -0.05606562f, 0.01981365f, -0.15234886f, 0.14696844f, -0.08745723f, -0.03493207f, -0.08295462f, -0.04280707f, 
    -0.02866184f, -0.03604703f, -0.03614867f, -0.14163646f, 0.03909491f, -0.00931039f, 0.02992919f, 0.03789070f, 
    0.09125078f, -0.01975159f, -0.13344908f, -0.23644069f, 0.00450904f, 0.01833814f, 0.00522461f, 0.06209646f, 
    -0.01953871f, 0.03564613f, 0.02500525f, 0.04275141f, -0.25784597f, -0.22128633f, 0.01402287f, 0.07934716f, 
    -0.07278399f, -0.03774803f, -0.10358007f, 0.15113063f, 0.00658700f, -0.06772633f, 0.07707728f, -0.04203004f, 
    -0.02074122f, 0.04223663f, -0.06556999f, -0.01424329f, 0.10593263f, -0.01506528f, 0.06517634f, 0.05502031f, 
    0.04249254f, -0.04518779f, 0.00688831f, 0.13456810f, 0.11366250f, -0.02439536f, -0.00821406f, 0.04538020f, 
    0.06549121f, 0.17996557f, -0.08308878f, -0.11244553f, 0.06688582f, -0.01344851f, -0.08720453f, 0.01855778f, 
    0.19080122f, -0.08421227f, 0.03187299f, -0.06092682f, 0.01898728f, -0.09403925f, -0.00717411f, -0.00078179f, 
    -0.10090510f, -0.02948470f, 0.02331424f, 0.06146003f, 0.23841584f, -0.07075141f, 0.07528706f, -0.07731172f, 
    0.10103182f, 0.10362436f, 0.06631964f, -0.01925997f, 0.02807256f, 0.01450089f, 0.01150746f, -0.02911545f, 
    0.29009545f, 0.01115685f, 0.00129423f, 0.17105289f, -0.05203744f, 0.04879660f, -0.01353582f, 0.00925743f, 
    0.15542337f, 0.07169458f, -0.05535391f, -0.07043600f, 0.38225248f, 0.06852143f, -0.11731881f, 0.06386130f, 
    -0.05748754f, 0.11556365f, -0.01296903f, 0.03383886f, -0.00280508f, 0.09148790f, -0.02673091f, 0.08334700f, 
    -0.26846829f, -0.05847392f, -0.17637801f, -0.05749456f, -0.08864158f, 0.01160302f, 0.02197743f, 0.07050155f, 
    0.05548326f, -0.00985695f, -0.05466425f, 0.00011916f, 0.24416615f, -0.11663640f, -0.16284299f, -0.04548305f, 
    0.04040952f, 0.03900098f, 0.02030795f, -0.03525052f, 0.07034447f, -0.09306901f, 0.02922213f, -0.20645732f, 
    -0.13342722f, -0.13345328f, 0.02084421f, -0.30571017f, 0.08745205f, 0.00957180f, -0.12779009f, 0.16345945f, 
    0.14496382f, 0.01600250f, -0.06000632f, 0.03954739f, -0.12744261f, 0.03236273f, 0.00905047f, -0.04786379f, 
    -0.01721003f, 0.12585086f, -0.11970608f, -0.02440813f, -0.03478845f, 0.03242590f, 0.05622273f, -0.02172384f, 
    0.10427256f, 0.02516675f, 0.15870839f, 0.10854404f, -0.04560008f, 0.02707291f, -0.01131857f, -0.06721430f, 
    -0.03061014f, 0.06771195f, 0.06378467f, 0.01068842f, -0.12002566f, -0.00400594f, -0.13115682f, -0.01785293f, 
    -0.01330332f, -0.05548616f, -0.03273948f, -0.07291988f, -0.04575274f, -0.07438189f, 0.03074315f, 0.13603579f, 
    -0.02274455f, 0.17961667f, 0.08239140f, 0.04347151f, -0.07794973f, -0.05421057f, 0.03371829f, -0.04775637f, 
    -0.07970460f, 0.14299189f, 0.00592234f, 0.04054506f, 0.32719979f, -0.21107729f, -0.07933767f, -0.05434156f, 
    -0.04799483f, -0.11897598f, -0.03643144f, 0.01306023f, 0.10349442f, -0.01832099f, -0.11443854f, 0.08886207f, 
    -0.10140873f, 0.05836912f, -0.04713682f, -0.13509601f, 0.04254679f, -0.00012856f, -0.04246275f, 0.09390309f, 
    0.14150774f, 0.00450157f, 0.04937610f, 0.04077323f, -0.20181623f, 0.18222806f, -0.03262872f, 0.11410508f, 
    -0.10617474f, -0.07717722f, 0.06294177f, 0.01763633f, 0.15384124f, -0.04443697f, -0.10418563f, 0.07675070f, 
    -0.21213366f, 0.02607811f, -0.00149618f, 0.02293701f, 0.02564492f, -0.01786972f, 0.00623337f, -0.08174152f, 
    0.03904996f, 0.06141013f, -0.05801789f, 0.03063564f, -0.04021880f, 0.17594092f, 0.00049147f, -0.10793410f, 
    -0.03807715f, 0.03170097f, 0.07537477f, -0.01882040f, 0.07244387f, -0.04578041f, -0.00566503f, -0.01696533f, 
    -0.05735693f, -0.01815763f, 0.05819263f, 0.24124873f, 0.06241547f, 0.03133893f, -0.06136156f, -0.00141673f, 
    0.02339092f, 0.03033384f, -0.03263064f, -0.04460067f, 0.21936327f, -0.10289581f, 0.11797810f, -0.03555415f, 
    0.06606559f, -0.20982553f, -0.09894414f, 0.00796433f, -0.05710786f, -0.04940137f, -0.12049037f, -0.01063706f, 
    0.07475663f, -0.18885738f, -0.00878142f, 0.02679467f, 0.09224762f, -0.07515344f, -0.04953000f, -0.09558752f, 
    0.17468894f, -0.03788126f, 0.00821271f, 0.18186958f, 0.11429338f, 0.09042445f, -0.00270184f, 0.13696219f, 
    -0.10393110f, 0.02028659f, 0.01491431f, -0.00063803f, 0.02078873f, 0.04445316f, -0.10735092f, 0.10938500f, 
    0.18232834f, -0.00457556f, 0.00387746f, 0.00047389f, -0.06602085f, -0.07362466f, 0.08193636f, 0.02012213f, 
    -0.08149621f, 0.11733919f, 0.15902589f, 0.05250848f, 0.08870039f, -0.01416314f, 0.10888996f, 0.20315027f, 
    -0.03027090f, 0.03635472f, -0.03107914f, 0.02123098f, -0.10792921f, 0.13141973f, -0.12502837f, -0.02874358f, 
    0.19629607f, -0.09436926f, 0.05149063f, 0.20453979f, -0.18101245f, -0.07996766f, -0.00437408f, 0.04949426f, 
    0.03814933f, -0.03546111f, -0.08230186f, 0.12391169f, 0.11390351f, 0.01335087f, -0.00875647f, 0.04114738f, 
    0.08734016f, 0.14533624f, -0.01867248f, 0.06708414f, -0.09623293f, 0.18220219f, 0.04195017f, -0.07233717f, 
    0.14952303f, 0.01406876f, 0.17679296f, -0.03925722f, -0.01544935f, 0.00510573f, 0.06442674f, -0.01410123f, 
    -0.11237502f, 0.05357051f, 0.02279834f, 0.04280261f, 0.11574612f, -0.14897497f, 0.12139881f, -0.02703017f, 
    0.06864405f, 0.03572684f, -0.18057245f, 0.04777719f, 0.00231553f, -0.18425392f, 0.00590453f, 0.03235571f, 
    -0.26849216f, 0.04752691f, -0.19186069f, -0.10615270f, 0.05369765f, 0.10037319f, -0.03280738f, 0.12040968f, 
    -0.03891287f, -0.05104934f, 0.04315711f, -0.02385225f, 0.07186296f, 0.01862464f, -0.02942364f, -0.01190839f, 
    0.05685437f, -0.11261424f, 0.05378557f, -0.19212908f, -0.10566339f, 0.07423593f, -0.14545058f, -0.19138858f, 
    0.06522404f, 0.00513421f, 0.15324624f, 0.21687576f, -0.01814929f, 0.07191341f, 0.00051239f, -0.04069281f, 
    0.08580413f, 0.06708036f, 0.03006363f, 0.05956691f, -0.24968697f, 0.14607488f, -0.29170290f, -0.40417001f, 
    0.09714893f, 0.17276321f, -0.02501141f, -0.07532883f, -0.01657285f, 0.02602699f, 0.03664071f, -0.05167346f, 
    -0.03556298f, 0.07915375f, -0.31764641f, -0.04385974f, -0.05061534f, 0.01498678f, 0.02329647f, 0.01263114f, 
    -0.07996214f, 0.08829761f, 0.03704337f, -0.10051663f, 0.04641377f, 0.06617804f, 0.01040327f, 0.15507545f, 
    0.04942813f, 0.01061350f, 0.05865024f, -0.03374192f, -0.02808183f, 0.04952800f, 0.02554699f, 0.04340801f, 
    0.23658578f, -0.06053313f, 0.06558312f, 0.19990692f, -0.09958973f, -0.09063465f, 0.04517966f, 0.00392094f, 
    -0.04917312f, -0.13945967f, 0.09875447f, -0.20410655f, 0.08875491f, 0.03196818f, -0.13714996f, -0.09517516f, 
    -0.04097470f, 0.11548669f, 0.12256083f, 0.00690913f, 0.03121174f, -0.12412842f, -0.14911260f, -0.08781575f, 
    0.00428131f, -0.05513232f, 0.07445252f, 0.12519956f, -0.05260648f, -0.04545631f, -0.06074090f, 0.02704106f, 
    -0.17317027f, -0.04662309f, 0.00743794f, -0.15927319f, 0.36672491f, -0.23158756f, 0.15858276f, -0.06066938f, 
    0.04148875f, 0.05844177f, 0.00951098f, 0.02297107f, 0.01081170f, 0.03142758f, -0.12878558f, -0.02752542f, 
    0.19591431f, 0.00359544f, -0.05453919f, -0.21068777f, -0.04126928f, 0.08294387f, 0.00831606f, -0.04345784f, 
    0.00456275f, -0.01648857f, -0.01797572f, 0.12768835f, 0.17404538f, 0.06796986f, 0.11002452f, 0.18826105f, 
    -0.12358910f, 0.06013624f, 0.06681841f, 0.01590117f, -0.08647481f, -0.08690235f, -0.00875477f, 0.09485335f, 
    0.01137664f, -0.25300673f, -0.10275111f, -0.10619736f, -0.03095226f, 0.10962719f, 0.06187372f, 0.12833866f, 
    -0.07244880f, 0.12882437f, 0.04942099f, -0.05652491f, -0.08386428f, 0.01483411f, -0.00829245f, -0.04785058f, 
    -0.00751112f, -0.10300301f, -0.02972027f, -0.00627247f, -0.06951329f, 0.13565803f, 0.04073067f, -0.03470453f, 
    0.03047527f, 0.04553400f, -0.08316372f, -0.33399576f, 0.03980421f, -0.04672183f, 0.04804579f, -0.01067109f, 
    0.01834640f, 0.13699462f, 0.12518217f, -0.03692096f, 0.13766328f, 0.07642310f, 0.14638549f, -0.06578945f, 
    -0.01364386f, -0.07419161f, -0.05063257f, 0.07028780f, -0.05253386f, -0.14264616f, -0.12183483f, 0.00266250f, 
    0.09956501f, 0.10330494f, 0.00328482f, -0.08394138f, -0.19926634f, 0.15024394f, 0.03432069f, -0.09753127f, 
    0.06921930f, -0.06941689f, 0.18840896f, -0.03586797f, -0.18754838f, -0.04743920f, 0.00030449f, -0.08556928f, 
    0.08668836f, -0.15534130f, -0.05158151f, 0.01422382f, -0.00728886f, -0.00182334f, -0.05080114f, -0.01551442f, 
    -0.17265721f, -0.06679868f, -0.14544049f, 0.03860236f, 0.02252461f, -0.03856984f, -0.04981694f, 0.06884233f, 
    -0.00847015f, -0.19213811f, 0.14029248f, 0.15140769f, -0.05251143f, 0.01927659f, 0.00749259f, 0.05190508f, 
    -0.00683982f, -0.09539142f, 0.07814051f, 0.00953703f, 0.02268978f, 0.06321174f, -0.11686844f, 0.08611627f, 
    0.02671237f, -0.01605728f, 0.00263384f, -0.27480122f, 0.10224349f, -0.05351588f, 0.04672565f, -0.01091219f, 
    0.01527216f, -0.00124339f, -0.04633439f, -0.00527281f, 0.31545553f, 0.11658862f, 0.11059199f, 0.16600572f, 
    -0.06186891f, -0.11487503f, 0.00156120f, 0.16339642f, -0.04836218f, 0.05110394f, 0.00274714f, -0.14190759f, 
    0.28830889f, 0.00789580f, -0.27621254f, -0.17871445f, -0.10645673f, 0.05668120f, 0.01570590f, 0.12461603f, 
    -0.08147305f, 0.02482793f, 0.06324466f, -0.15126640f, 0.10781939f, -0.04940032f, 0.12806284f, 0.08910168f, 
    -0.02405059f, -0.12839736f, -0.01778366f, 0.01217985f, -0.02764654f, 0.04468789f, 0.07340256f, -0.05191423f, 
    0.11679219f, 0.00230015f, 0.06453197f, 0.15881218f, -0.06376945f, -0.10293552f, -0.00454884f, -0.03987333f, 
    -0.00422846f, -0.04666390f, -0.01592947f, 0.04233371f, -0.07247612f, -0.17144951f, -0.00784840f, -0.08506597f, 
    -0.08046386f, -0.00215162f, -0.02915344f, -0.17251518f, -0.05358559f, 0.07794312f, -0.09316988f, 0.03256766f, 
    0.00790168f, 0.11255062f, -0.21246870f, -0.05892808f, 0.05217328f, 0.05586734f, -0.01975616f, 0.00268277f, 
    -0.09104716f, -0.00311998f, -0.01653133f, -0.03613947f, 0.07515826f, -0.07112580f, -0.10961413f, -0.10307309f, 
    -0.04499935f, 0.04716781f, -0.01898916f, -0.04134082f, -0.10522357f, -0.03846249f, 0.07365242f, -0.08745202f, 
    0.13380165f, -0.08133041f, -0.02347451f, -0.23744941f, -0.11235174f, -0.08561584f, -0.03057478f, -0.03860780f, 
    -0.01539857f, -0.14529376f, 0.01076722f, -0.04121466f, -0.42172551f, 0.19374906f, -0.02223305f, 0.13457382f, 
    0.04278998f, -0.01825953f, -0.02781385f, 0.06111651f, -0.09339436f, 0.01252413f, -0.08476792f, -0.07789177f, 
    0.04293472f, -0.03706189f, -0.03185833f, 0.15520678f, 0.04798682f, -0.07806521f, 0.10060752f, 0.02497931f, 
    -0.05961042f, -0.11920536f, 0.12859063f, 0.00897123f, -0.32283467f, -0.04659490f, 0.00128503f, -0.26002902f, 
    -0.03838144f, 0.09762845f, 0.03105913f, 0.03400437f, -0.04831219f, -0.05150191f, -0.02795948f, -0.04079951f, 
    0.18103832f, -0.04520094f, -0.03169938f, 0.01979234f, -0.09160033f, -0.06028911f, 0.05740920f, 0.16557142f, 
    -0.01587222f, 0.01526275f, 0.02784899f, -0.01161078f, 0.23752354f, 0.10117798f, 0.13151228f, 0.16638769f, 
    -0.07472684f, -0.01909548f, 0.03611604f, 0.01976717f, -0.07670372f, 0.02826652f, -0.01056805f, 0.00141419f, 
    -0.30021507f, -0.07138952f, -0.07639779f, -0.09037209f, -0.09046862f, -0.02744336f, 0.03066351f, -0.03529879f, 
    -0.03479219f, -0.03941134f, 0.03584759f, 0.01627422f, 0.24189962f, -0.08351979f, -0.05756068f, -0.05784808f, 
    -0.02762824f, 0.02753184f, -0.01988501f, -0.02375939f, -0.04275537f, 0.07588665f, -0.02282473f, -0.14589818f, 
    0.06262884f, -0.20635106f, 0.17967322f, -0.02639144f, -0.05232587f, -0.07640670f, -0.05382858f, 0.03649642f, 
    -0.04164796f, -0.00977761f, 0.04222031f, 0.01552072f, -0.23878799f, 0.00012280f, 0.16449229f, -0.11837006f, 
    -0.01154471f, -0.01581251f, -0.04710995f, 0.11899363f, -0.00422701f, -0.14246783f, -0.01255060f, 0.07446127f, 
    -0.08996598f, -0.02180373f, 0.01841790f, -0.19286530f, 0.08869886f, 0.08217770f, 0.05233889f, 0.00208110f, 
    -0.01636924f, 0.03305613f, 0.05620579f, -0.04793665f, 0.22779755f, 0.06808378f, 0.07070363f, 0.28560454f, 
    -0.12157267f, -0.12010029f, 0.07131273f, -0.00923413f, -0.07469296f, -0.06802128f, 0.00107650f, 0.00136429f, 
    0.05064379f, -0.06402306f, -0.07975694f, 0.00692344f, -0.03349080f, 0.02122237f, 0.00299251f, -0.15410143f, 
    0.09898367f, 0.04398644f, 0.02514784f, 0.05179164f, 0.13432199f, -0.19166161f, 0.14882036f, 0.05611467f, 
    -0.07639217f, 0.05438224f, -0.09180928f, -0.04451856f, 0.12762469f, -0.07126204f, -0.00838664f, -0.08833504f, 
    0.17723531f, -0.00682744f, -0.14654270f, -0.11899171f, 0.00840064f, -0.01000845f, -0.01668149f, -0.02452361f, 
    -0.07755539f, 0.00271076f, -0.05791054f, -0.01726778f, -0.28903750f, -0.00738031f, 0.00335556f, -0.25724232f, 
    -0.00327364f, 0.02337387f, 0.06734581f, -0.00319415f, -0.00896298f, 0.01995207f, -0.02032291f, -0.06123162f, 
    0.08108207f, 0.05385241f, -0.10268755f, 0.22350642f, -0.09199551f, 0.01959665f, -0.06724045f, 0.00479743f, 
    -0.01247079f, -0.02091741f, -0.02296320f, 0.07944183f, 0.29882109f, -0.14143974f, -0.15573032f, 0.08164594f, 
    -0.10374270f, 0.01638539f, 0.00723267f, -0.10019146f, 0.01719211f, -0.04080726f, -0.04676651f, 0.02623780f, 
    0.16073747f, -0.03988347f, -0.10746617f, 0.13483441f, 0.07361742f, 0.04036168f, 0.03736681f, -0.12705414f, 
    -0.08951873f, -0.02840906f, -0.01700022f, 0.02600014f, 0.11942613f, 0.02945409f, 0.06615911f, -0.13533528f, 
    -0.11058456f, -0.06797477f, -0.10974254f, 0.06373330f, 0.06040750f, -0.08171470f, 0.08209254f, -0.12101439f, 
    0.03118821f, 0.09682397f, -0.00876839f, 0.07580624f, 0.05038702f, 0.00966104f, 0.04474777f, -0.05189312f, 
    -0.05770841f, 0.03230684f, -0.01998821f, 0.01285708f, 0.41249058f, -0.02861328f, 0.09003983f, 0.31837538f, 
    -0.14808495f, -0.04158047f, 0.08870702f, -0.03891004f, -0.05939687f, -0.00174535f, 0.09853419f, 0.08553346f, 
    0.04982707f, 0.02649495f, 0.03978144f, 0.13730906f, -0.09423790f, -0.11391973f, -0.03361917f, 0.06326626f, 
    -0.02595542f, 0.03665040f, -0.07504204f, -0.04619454f, -0.23073168f, -0.08922049f, -0.03163093f, 0.04922402f, 
    -0.02756813f, 0.00976203f, -0.12125562f, 0.06365636f, 0.11814820f, 0.00467552f, 0.00606893f, -0.11675747f, 
    0.29366690f, -0.08178275f, -0.02514451f, 0.14317863f, -0.01456418f, 0.00131762f, 0.09649230f, -0.03694866f, 
    -0.05837512f, -0.17315780f, -0.06054423f, -0.08286324f, 0.25234833f, 0.02615518f, -0.13043571f, -0.03607015f, 
    0.10456584f, 0.09596270f, -0.01055886f, -0.12751618f, -0.05720349f, 0.06432598f, -0.01759676f, -0.03144198f, 
    -0.14227326f, 0.09915608f, -0.04086882f, -0.05338515f, 0.15221915f, 0.01129256f, -0.01849690f, -0.00542930f, 
    -0.00028873f, 0.00622512f, -0.11846960f, 0.04335980f, -0.08260078f, -0.00403324f, -0.09827791f, -0.02663697f, 
    0.05467999f, -0.09675994f, 0.15402339f, 0.00140793f, -0.09745856f, -0.00793437f, 0.00284758f, -0.01431805f, 
    -0.06009585f, -0.00363957f, 0.18846707f, 0.02912554f, -0.09544391f, -0.02511489f, 0.01725398f, -0.03763337f, 
    -0.06202335f, -0.04042658f, -0.02519899f, -0.07394685f, -0.16368985f, -0.03111306f, 0.01344184f, 0.07229432f, 
    0.15673777f, -0.01979677f, -0.01043287f, -0.07706462f, 0.02472180f, -0.07943510f, -0.02365575f, -0.03957114f, 
    0.10921846f, -0.28946424f, 0.09491492f, -0.11532149f, 0.00146526f, 0.09660657f, -0.03698231f, 0.06021073f, 
    -0.04182893f, -0.14119984f, -0.03605710f, -0.05243965f, -0.08411167f, -0.00750619f, -0.00575975f, -0.06305730f, 
    0.12151356f, 0.00760550f, 0.00485078f, -0.01916193f, 0.05870873f, -0.02483987f, 0.08270755f, -0.08166008f, 
    0.00467021f, -0.02397158f, -0.05281228f, -0.02782234f, -0.00416250f, 0.00282941f, 0.06265137f, 0.05132089f, 
    -0.00667146f, -0.04247698f, 0.02512125f, -0.08012746f, 0.09434603f, -0.19237818f, 0.10024706f, -0.03368896f, 
    0.04390730f, 0.04934762f, -0.04558513f, 0.05454249f, 0.08242366f, 0.02922061f, 0.00169096f, 0.01124336f, 
    -0.08989203f, -0.15122609f, -0.26078123f, -0.01103816f, -0.07756390f, -0.09598400f, -0.07910085f, -0.07453272f, 
    0.02828066f, 0.06565511f, -0.00207523f, 0.00578259f, -0.26119649f, 0.09378443f, 0.13890289f, 0.09678941f, 
    0.08197425f, -0.03300333f, 0.05803386f, -0.10088233f, -0.10794228f, 0.00557597f, -0.07054906f, -0.02708736f, 
    -0.24085109f, -0.04391308f, -0.15412034f, -0.00848720f, -0.13395742f, 0.07422006f, 0.04199799f, -0.08033223f, 
    -0.01817565f, 0.06380085f, -0.05242238f, 0.07061475f, 0.03981014f, 0.11102700f, 0.05224213f, -0.25497609f, 
    0.04218091f, -0.03247932f, -0.04980583f, 0.03709580f, 0.04042175f, 0.03485778f, 0.03217739f, 0.09679680f, 
    -0.05870966f, 0.12120787f, 0.02890758f, -0.09461807f, 0.07592478f, 0.04238253f, -0.04987939f, 0.04744765f, 
    0.03360701f, 0.06692497f, -0.03391564f, -0.05412904f, 0.41285199f, 0.07307480f, -0.40837041f, -0.11300293f, 
    0.05888688f, 0.00534956f, 0.02253547f, 0.06571417f, -0.07861987f, -0.02489776f, 0.01554571f, -0.07005733f, 
    0.27015141f, -0.16415392f, 0.05905585f, 0.03487946f, 0.00387655f, 0.08386063f, -0.09437442f, -0.09081236f, 
    0.04698234f, -0.01596626f, -0.15872552f, 0.02915656f, 0.07834560f, 0.12424004f, -0.20035560f, 0.09639481f, 
    0.00488495f, 0.01670964f, 0.03007116f, -0.08839463f, -0.02930133f, -0.01910934f, 0.02174455f, 0.00972324f, 
    0.06031271f, -0.02191359f, 0.03970843f, -0.03913400f, 0.13790077f, 0.05036892f, 0.00265159f, -0.11908635f, 
    -0.01946415f, 0.07950127f, -0.07735503f, 0.05946868f, 0.26374662f, -0.08370263f, -0.02018335f, 0.01025243f, 
    -0.00313996f, 0.01528201f, -0.03842977f, -0.05658030f, 0.03266022f, 0.19312723f, -0.02603690f, 0.02912459f, 
    0.24965635f, 0.05833191f, -0.00748309f, 0.01519392f, -0.08526168f, -0.02561702f, -0.00738133f, -0.00103843f, 
    0.04393721f, -0.03871633f, 0.00268894f, -0.11201146f, -0.26454160f, 0.08389810f, 0.04669542f, -0.10192615f, 
    0.03990410f, 0.02886563f, -0.06433904f, 0.05058546f, 0.01347788f, -0.13213089f, 0.05625605f, -0.04159419f, 
    -0.11938506f, 0.05218214f, 0.07052147f, -0.00748014f, 0.05827162f, -0.09502397f, 0.01075540f, -0.12358854f, 
    -0.08173161f, 0.00151878f, -0.13340142f, -0.01461965f, 0.04337299f, 0.04279561f, -0.03067042f, -0.01675867f, 
    0.01312375f, 0.06714812f, -0.01887001f, -0.04181161f, -0.01578620f, 0.08251232f, 0.01615908f, 0.06446227f, 
    -0.20263006f, -0.05734504f, -0.25406238f, -0.19598864f, 0.05613036f, -0.12207441f, -0.01446473f, -0.05452050f, 
    -0.10109479f, 0.01551753f, -0.04303706f, -0.04178408f, -0.09957500f, 0.06598334f, 0.06362313f, -0.01944952f, 
    0.03729653f, -0.03756295f, 0.13671543f, -0.04639627f, -0.07491034f, -0.03543768f, -0.01314002f, -0.00300734f, 
    -0.16257842f, 0.06798045f, -0.11595940f, -0.24410431f, 0.06431776f, 0.01811182f, -0.01004282f, -0.04343691f, 
    -0.13898256f, -0.01310030f, -0.00498700f, -0.05870794f, 0.20069687f, -0.23336850f, -0.00252709f, -0.05877872f, 
    0.08456297f, 0.05876678f, 0.07099196f, 0.00736120f, -0.04949645f, 0.11330944f, 0.01314074f, 0.04539739f, 
    0.17559116f, -0.14126366f, -0.07134530f, 0.00751762f, -0.00390378f, -0.03105053f, -0.04331788f, -0.09346545f, 
    0.05213809f, 0.00675078f, -0.13180733f, 0.00279303f, 0.33199373f, -0.04419940f, 0.10206342f, -0.00884082f, 
    -0.04065258f, -0.01544571f, 0.03025478f, 0.04083837f, -0.01125914f, 0.04998133f, -0.03760487f, 0.01185609f, 
    0.23979616f, -0.08350860f, -0.13070430f, -0.01594368f, -0.04547122f, 0.02864696f, -0.00862336f, -0.04388699f, 
    -0.09159605f, -0.05695194f, -0.02630913f, 0.09318069f, 0.00871870f, 0.09007809f, -0.12427086f, -0.18271998f, 
    0.02656246f, 0.03848524f, 0.06188021f, -0.09043524f, -0.04897205f, 0.00639613f, 0.08090776f, -0.17351244f, 
    0.32429838f, 0.19964823f, -0.10526277f, 0.14914627f, 0.02291105f, 0.07179800f, -0.05686293f, 0.06906664f, 
    -0.04160095f, -0.03247390f, 0.04861679f, 0.03213436f, -0.14762938f, 0.00769373f, -0.04092911f, -0.23934731f, 
    0.03749591f, -0.06304564f, -0.04572795f, -0.04769949f, -0.04340547f, -0.03170163f, 0.01617391f, -0.01926832f, 
    -0.32115880f, 0.08992407f, 0.06763498f, -0.02499582f, 0.02982499f, 0.03371865f, 0.10666450f, 0.17097118f, 
    0.00448738f, 0.08866066f, 0.01478766f, 0.11841707f, 0.04176399f, 0.08336432f, -0.01902566f, -0.06317887f, 
    -0.01058776f, 0.04378209f, -0.04115723f, -0.01734100f, 0.04915839f, -0.08203304f, 0.02217537f, 0.06221114f, 
    0.04754372f, -0.06997716f, -0.00434600f, 0.00956643f, -0.00748704f, 0.00882843f, -0.04657359f, -0.03444007f, 
    -0.02373816f, 0.03355671f, -0.05245922f, 0.11488484f, 0.40794078f, 0.02514930f, -0.01737824f, 0.19988728f, 
    0.00951308f, -0.04777632f, -0.05186654f, 0.14266467f, -0.01153911f, 0.08508927f, -0.03742481f, 0.00887496f, 
    -0.21472470f, 0.27140486f, -0.21237916f, -0.05244452f, -0.03572293f, 0.04654731f, -0.03122725f, 0.10188140f, 
    -0.06993414f, -0.03778803f, 0.06369684f, -0.03218863f, -0.06854729f, -0.06641869f, 0.09810061f, -0.19946127f, 
    0.04545033f, -0.07880784f, -0.02211460f, 0.02762902f, -0.03064694f, -0.02815767f, 0.04926204f, -0.19568153f, 
    0.14778052f, 0.10665385f, 0.06956005f, -0.02141992f, -0.15167919f, 0.03944528f, -0.09029864f, 0.06197216f, 
    -0.01458584f, 0.01745318f, 0.04323158f, -0.04760241f, -0.12822539f, -0.01880345f, -0.00392334f, 0.01208778f, 
    -0.10635666f, -0.00831932f, -0.02857753f, 0.00997073f, 0.02166447f, 0.04130337f, 0.01441253f, 0.07003831f, 
    -0.00413316f, -0.07010067f, 0.04304513f, 0.02627313f, -0.10526726f, 0.06386501f, -0.01853773f, 0.01181989f, 
    -0.02521540f, 0.02982253f, -0.03430835f, -0.01612897f, -0.11065175f, -0.06209267f, 0.00285413f, 0.04140745f, 
    0.04721769f, -0.06698104f, 0.01097403f, 0.08962813f, 0.04216305f, 0.00836003f, -0.04490760f, -0.12777740f, 
    0.14269933f, -0.19453421f, 0.00310404f, -0.11560752f, -0.11960451f, 0.05830869f, 0.01584679f, 0.04601106f, 
    0.06589056f, 0.01948736f, 0.04046615f, -0.02029673f, -0.16468816f, 0.01549242f, -0.07925811f, -0.14316139f, 
    -0.05249400f, -0.09443908f, 0.02633562f, -0.01740813f, -0.02050179f, -0.06068143f, 0.04094922f, -0.02323068f, 
    0.17040075f, 0.05013308f, -0.04290491f, -0.08222806f, -0.05946619f, 0.00012077f, -0.04095178f, 0.04833014f, 
    0.06465942f, 0.07058852f, 0.02492585f, -0.07726427f, 0.07613806f, 0.19812353f, 0.14305244f, 0.21954115f, 
    0.08750570f, 0.15059811f, -0.04743709f, -0.07240254f, -0.03607538f, 0.11554417f, -0.02727660f, -0.05024984f, 
    0.07384983f, 0.03852856f, -0.05171824f, -0.13994959f, -0.07887618f, 0.04013558f, 0.00496093f, 0.04218025f, 
    0.03233445f, -0.04015410f, 0.12263726f, 0.03041392f, 0.03519607f, -0.17038158f, 0.01836274f, 0.18575732f, 
    -0.01667517f, 0.01381939f, 0.16959402f, 0.03560533f, 0.01040678f, -0.04321275f, -0.01307041f, 0.06891075f, 
    -0.16928855f, -0.01127695f, -0.14862187f, -0.07147022f, -0.07977854f, -0.00219636f, -0.05310979f, 0.09598666f, 
    -0.02896336f, 0.00628754f, 0.06770340f, -0.02506265f, 0.05987067f, -0.09778305f, -0.03457378f, -0.15065502f, 
    -0.09407108f, -0.05886097f, 0.04523418f, -0.09159841f, -0.07761059f, -0.01782736f, -0.07880332f, 0.03336382f, 
    -0.33451873f, 0.01454541f, -0.09273774f, -0.05427644f, -0.14238150f, -0.14400925f, 0.01519744f, -0.01492493f, 
    -0.09643532f, -0.05877548f, 0.05973661f, -0.03393538f, 0.06316961f, 0.06253911f, -0.06428526f, 0.03825857f, 
    -0.04686970f, -0.01767270f, 0.06342532f, -0.04751606f, -0.01325000f, -0.03978939f, 0.07456852f, -0.05326331f, 
    0.25541320f, 0.14648736f, 0.19875529f, 0.00374601f, 0.03797012f, 0.00666715f, -0.00162465f, 0.02530174f, 
    -0.07224046f, -0.04463680f, 0.01825392f, -0.04632007f, -0.14066929f, 0.03210811f, 0.03855682f, 0.06493157f, 
    0.03516341f, 0.06001377f, -0.00048021f, 0.00267022f, -0.00510847f, 0.02213819f, 0.02837855f, 0.06818458f, 
    -0.08381382f, 0.10884431f, 0.00718489f, -0.01983062f, -0.12508100f, -0.11863736f, 0.02726861f, 0.04038845f, 
    -0.06068904f, 0.01908615f, -0.02782129f, -0.02715109f, -0.18023221f, -0.01251300f, 0.19288288f, 0.20192277f, 
    -0.01329321f, -0.04954527f, 0.09407627f, 0.01383631f, -0.04452593f, -0.00171306f, -0.11244280f, 0.01981008f, 
    -0.09000018f, -0.14519811f, 0.04178476f, -0.01561400f, -0.11618928f, -0.04051558f, 0.03670976f, 0.06411448f, 
    -0.03829946f, -0.03764232f, -0.10241141f, -0.11566222f, 0.00850821f, 0.04929455f, 0.00193071f, -0.02783336f, 
    -0.08575892f, 0.05197068f, 0.07586975f, -0.02237807f, -0.06829026f, 0.05920911f, 0.05223192f, -0.03051134f, 
    -0.26309922f, -0.12819637f, -0.15159099f, 0.05147654f, -0.14326906f, -0.05770340f, -0.01550351f, 0.00967733f, 
    0.01275094f, -0.02861532f, 0.09675147f, -0.06841937f, 0.05879300f, -0.07357539f, -0.02053734f, 0.05487132f, 
    0.00782208f, 0.01792995f, 0.01987742f, -0.01891354f, -0.08674818f, -0.03700167f, -0.02043806f, 0.02931368f, 
    -0.07393210f, 0.03194498f, 0.01628961f, -0.11463721f, 0.03064916f, -0.00213085f, -0.03679078f, 0.05092632f, 
    0.12389801f, -0.03007477f, -0.00967464f, 0.02450564f, 0.20333615f, -0.16624689f, 0.09238008f, -0.07318264f, 
    0.02045554f, -0.03501337f, -0.11902942f, 0.11720909f, -0.08302151f, 0.04159642f, 0.08846454f, -0.04786352f, 
    -0.24776828f, -0.05666960f, 0.17266162f, 0.14671245f, 0.07776888f, 0.06041767f, 0.11984527f, -0.00869836f, 
    0.00032743f, 0.04461987f, -0.12545696f, -0.06423342f, -0.56780291f, -0.02255915f, 0.15426917f, 0.02059191f, 
    -0.02549716f, 0.07975171f, -0.01372908f, 0.03730096f, -0.09403128f, 0.05234363f, -0.08990230f, -0.05502674f, 
    -0.41521919f, -0.40850067f, 0.20613068f, 0.12093867f, -0.07521747f, 0.12668759f, 0.03338110f, -0.12075870f, 
    -0.04722081f, -0.17096710f, 0.12057500f, -0.04275953f, 0.09669106f, -0.05836886f, -0.07590884f, 0.02232886f, 
    -0.06983607f, -0.03116600f, -0.06911543f, -0.05892318f, 0.06182285f, 0.01805020f, 0.00273800f, -0.01917663f, 
    0.00100044f, 0.06619265f, -0.14320689f, -0.05121462f, -0.07439082f, -0.00162996f, 0.04264219f, 0.05890736f, 
    -0.04170695f, -0.04946505f, 0.01546284f, -0.07925124f, -0.27799711f, -0.41237557f, -0.00768902f, 0.07573051f, 
    -0.12395535f, 0.01399610f, 0.00436435f, -0.02885958f, 0.00581444f, -0.18738043f, 0.13279440f, -0.02256180f, 
    0.01035825f, 0.01624930f, -0.04256618f, -0.01417317f, -0.08813681f, 0.06299370f, 0.04336309f, 0.00040322f, 
    -0.10282939f, -0.06766306f, -0.04026594f, 0.03587427f, -0.06892975f, -0.31388286f, -0.10591362f, 0.12826049f, 
    -0.04893949f, -0.08165919f, 0.01112939f, -0.05966200f, -0.02429085f, 0.02631509f, 0.04014897f, -0.00960702f, 
    0.33237407f, -0.36783001f, -0.26397485f, -0.03451416f, -0.02701691f, 0.05597226f, -0.04929664f, -0.09039344f, 
    -0.06789479f, -0.00851624f, -0.02696324f, 0.00024885f, -0.18742052f, -0.11987248f, -0.09616734f, 0.02516277f, 
    0.01483723f, 0.01614359f, -0.01487059f, 0.07738209f, 0.14471577f, -0.03062619f, 0.02875997f, 0.02749971f, 
    0.04198879f, 0.01962408f, -0.02695517f, -0.00672782f, -0.13962123f, -0.09547982f, -0.02421767f, 0.06854212f, 
    -0.07716070f, 0.04065327f, -0.03777518f, 0.05552933f, -0.11552843f, -0.13073668f, 0.02460271f, 0.07723941f, 
    -0.07723651f, 0.03839990f, -0.01635005f, -0.02589506f, -0.03928667f, 0.03948269f, -0.06501941f, 0.14309996f, 
    -0.06891289f, -0.10378020f, -0.06979397f, 0.22659944f, -0.02154534f, 0.02998536f, 0.04291540f, -0.14832254f, 
    -0.04872509f, 0.04716063f, -0.01940124f, 0.13044618f, 0.26365241f, 0.04493969f, 0.04830782f, 0.09528769f, 
    0.05090972f, -0.01925536f, 0.00044567f, 0.11982004f, -0.01041877f, -0.13872921f, -0.07562090f, 0.05447225f, 
    0.00467717f, -0.31003866f, -0.09991145f, 0.11627715f, 0.00899595f, 0.05496237f, -0.04214307f, 0.03139748f, 
    -0.01775438f, -0.11589374f, 0.02804610f, -0.12860601f, -0.33967388f, 0.37506682f, 0.20035875f, 0.04585221f, 
    0.03854535f, 0.01375223f, 0.01738531f, 0.08168317f, 0.06263493f, -0.02165778f, -0.04996327f, 0.09128149f, 
    0.38778380f, -0.01940019f, -0.01479432f, 0.14148383f, 0.05388233f, -0.08303981f, 0.02879560f, 0.09771978f, 
    -0.04349376f, 0.05225913f, 0.02635042f, -0.15773195f, -0.39039487f, -0.19808604f, -0.09312273f, 0.06204462f, 
    0.05424334f, -0.02180708f, -0.07232770f, -0.03625126f, -0.08666837f, -0.07895750f, 0.01380978f, -0.04271527f, 
    -0.04010786f, -0.15230858f, -0.33543164f, 0.13984047f, -0.12052587f, 0.11134039f, 0.06461100f, -0.02262937f, 
    -0.04168563f, 0.01122696f, 0.03575149f, 0.03330866f, -0.05249514f, -0.15186320f, 0.15363359f, -0.13873686f, 
    0.14172840f, -0.06840291f, -0.04703657f, -0.06239974f, 0.11973175f, -0.02204897f, 0.05091735f, 0.07286201f, 
    0.05964093f, 0.11159322f, 0.08095568f, -0.11417918f, -0.11567172f, 0.04066224f, 0.04189544f, -0.02597959f, 
    -0.02633988f, 0.01218769f, 0.01472535f, 0.10542824f, -0.24112850f, -0.02250331f, -0.32829434f, 0.01726268f, 
    -0.01316606f, 0.10793348f, 0.04979695f, 0.03561140f, -0.07841200f, 0.06634678f, 0.05322938f, 0.03440887f, 
    0.25922576f, 0.21791323f, 0.03362586f, 0.02014500f, -0.09106897f, 0.07096586f, -0.03380561f, 0.01248503f, 
    0.13007632f, 0.00327227f, -0.06314109f, 0.00120991f, -0.30584139f, -0.30903184f, -0.23469353f, -0.17207907f, 
    -0.07385493f, -0.02965662f, -0.05508649f, -0.05014264f, 0.03748003f, 0.04061580f, -0.06246877f, 0.00869419f, 
    0.21789056f, 0.21357763f, -0.03154550f, 0.09393563f, -0.02065339f, 0.01781604f, 0.03013275f, 0.01891264f, 
    0.00497371f, -0.08440507f, -0.04107286f, -0.02859908f, -0.24973960f, -0.10481711f, -0.24271715f, 0.21317051f, 
    -0.02134423f, 0.06469276f, 0.07301918f, 0.03311004f, -0.09221248f, -0.01905718f, -0.01936000f, -0.01462752f, 
    0.29653069f, 0.08044174f, 0.13147750f, -0.08701886f, 0.08415230f, 0.05929480f, -0.02032984f, 0.08338014f, 
    0.04345459f, -0.08968782f, 0.00395752f, 0.01212230f, -0.09936488f, -0.00125944f, -0.33239239f, 0.01239613f, 
    -0.11805383f, -0.07299579f, 0.01160896f, -0.04413825f, -0.03425371f, 0.04096197f, -0.06159916f, -0.01117781f, 
    0.24995269f, -0.14316851f, -0.00418608f, -0.01013367f, -0.06324577f, -0.02063161f, -0.05690298f, 0.07692428f, 
    -0.03310218f, 0.04355944f, -0.06299358f, -0.01047107f, -0.20008028f, 0.14159787f, -0.00559832f, -0.09010430f, 
    -0.08794404f, 0.02596427f, -0.01554893f, 0.04590912f, 0.09299569f, -0.16609883f, -0.04839984f, 0.08657799f, 
    -0.11553618f, 0.13671571f, 0.08039121f, 0.12567960f, -0.04307334f, 0.05511710f, -0.03013436f, 0.00804886f, 
    0.02393544f, 0.05020489f, -0.00746478f, -0.04771737f, 0.29116052f, -0.32930404f, -0.01178557f, 0.12468794f, 
    0.07236587f, 0.12457009f, 0.00291559f, 0.01853021f, 0.00176148f, -0.04179882f, 0.00410703f, -0.20911685f, 
    -0.30570719f, 0.02364260f, 0.02630978f, -0.08207276f, -0.06279207f, 0.02138211f, -0.07668383f, -0.00883024f, 
    0.02228082f, -0.15005988f, 0.02585452f, 0.06664490f, -0.15590192f, 0.02193829f, -0.02577384f, 0.14926851f, 
    0.08006135f, 0.10193919f, -0.05644407f, 0.11105712f, 0.00906571f, 0.09708775f, 0.03338369f, 0.10473157f, 
    0.02635958f, 0.00285927f, -0.02359824f, -0.31382918f, -0.09533703f, 0.10434490f, 0.05085958f, 0.17997293f, 
    0.04386486f, 0.04691177f, -0.01798828f, 0.05401205f, -0.10844012f, 0.04760309f, 0.04651286f, 0.09449626f, 
    0.08799607f, 0.06043955f, -0.03545794f, 0.09337907f, -0.04116597f, 0.00082290f, 0.14637788f, -0.02167137f, 
    -0.43790814f, 0.23482689f, 0.10912844f, 0.17768623f, 0.05766220f, -0.04517711f, 0.03042192f, -0.02552981f, 
    0.00991075f, 0.05062946f, -0.11229987f, 0.00067941f, 0.21886690f, 0.26710489f, -0.00673045f, -0.11320792f, 
    0.05102457f, 0.10088103f, 0.02914908f, 0.10484675f, -0.05807542f, -0.01289976f, 0.08690871f, 0.13784690f, 
    -0.20157361f, -0.05547908f, 0.03239753f, -0.04535025f, 0.10753724f, 0.01757128f, 0.08872379f, -0.05715406f, 
    0.14708200f, 0.09515029f, -0.11174831f, -0.05748792f, -0.17364256f, 0.00592170f, -0.04976434f, -0.14464931f, 
    0.08465316f, 0.08440249f, 0.01526367f, -0.08380108f, -0.04656272f, -0.11796780f, 0.12407044f, -0.09524234f, 
    -0.16164240f, 0.06169255f, 0.00783806f, -0.12227432f, 0.09620253f, 0.00911683f, 0.04510999f, 0.12045687f, 
    -0.02763955f, -0.01973798f, -0.06714682f, 0.00839291f, -0.18166308f, -0.16294254f, -0.10830092f, 0.11392112f, 
    -0.14518906f, -0.14276552f, 0.06262720f, -0.12256474f, -0.06373616f, -0.03338314f, 0.05875548f, 0.04309756f, 
    -0.12086286f, -0.06462147f, -0.08628227f, 0.21110867f, -0.00357850f, 0.10451367f, 0.04658081f, -0.02340469f, 
    0.03999988f, -0.03412152f, 0.02833482f, 0.06176477f, 0.10770117f, -0.31143132f, 0.12927438f, -0.09687131f, 
    -0.14042784f, 0.02629553f, 0.06128836f, -0.12206250f, -0.02730524f, 0.01680994f, 0.06450227f, -0.01893024f, 
    0.06330285f, 0.11157913f, -0.00329330f, -0.07050433f, 0.03407134f, 0.10914548f, -0.04343313f, -0.03216963f, 
    -0.10318141f, -0.04647648f, 0.01098370f, 0.06979898f, -0.20089608f, -0.06017230f, 0.03851431f, 0.15350696f, 
    0.01607299f, -0.05085718f, -0.08475206f, 0.00449206f, -0.01790936f, 0.03819576f, 0.01345911f, -0.00320009f, 
    -0.01951612f, 0.03980407f, -0.08447749f, 0.04251869f, 0.05189010f, -0.05972783f, 0.09126819f, 0.02241201f, 
    0.00744010f, 0.01700941f, 0.02291557f, -0.04967697f, -0.22519729f, -0.24699414f, 0.17728505f, 0.06924225f, 
    0.06097065f, -0.03198410f, -0.06227876f, -0.05291755f, 0.04104605f, 0.02560585f, -0.01081866f, -0.00377579f, 
    0.11612263f, 0.03478339f, -0.02611308f, 0.12159706f, -0.00244299f, 0.14398332f, -0.05256674f, 0.17246018f, 
    0.02379825f, 0.00675893f, 0.05961421f, -0.00860038f, 0.06715222f, 0.18801989f, 0.01913015f, -0.10484974f, 
    0.14989589f, 0.04373503f, 0.02700705f, 0.03801350f, -0.01688856f, 0.13536148f, 0.08585761f, 0.04545401f, 
    -0.28754482f, -0.11250103f, 0.17415547f, -0.16766299f, -0.02059192f, 0.12513864f, -0.04646641f, 0.01311428f, 
    0.07550225f, -0.03738476f, 0.02370613f, -0.00334991f, -0.16596554f, -0.03268829f, 0.03448246f, 0.23572557f, 
    0.00642380f, -0.06683427f, -0.03550207f, 0.12425525f, 0.04136077f, -0.05451004f, 0.00480190f, 0.10996807f, 
    0.10550091f, 0.11867809f, -0.08551871f, 0.05464374f, -0.07489594f, 0.04220699f, 0.08970879f, 0.06916486f, 
    -0.08710302f, 0.00007161f, 0.06032721f, 0.06425972f, -0.61089426f, 0.12737989f, -0.08975061f, -0.11661892f, 
    -0.05468580f, 0.04606234f, 0.09482811f, 0.06231030f, 0.01809587f, 0.00753655f, 0.05735698f, 0.00298008f, 
    0.29890501f, 0.15516336f, -0.06320502f, -0.42393777f, -0.00952044f, -0.07526579f, -0.07122298f, -0.10360724f, 
    0.03230535f, -0.01974642f, -0.10016718f, -0.01598658f, -0.18867426f, 0.09348108f, 0.15197413f, -0.11074766f, 
    -0.02548642f, 0.01147381f, -0.00561620f, 0.05497685f, 0.06267653f, -0.00132494f, 0.05353904f, 0.00328663f, 
    0.11447429f, -0.08738475f, -0.09771039f, 0.20445488f, -0.02155432f, -0.05833135f, 0.01379832f, 0.05373874f, 
    0.04131777f, -0.01922167f, 0.07725108f, 0.05449667f, -0.14619258f, 0.07611864f, 0.03691623f, -0.01021047f, 
    0.01103864f, 0.01826319f, -0.00294642f, 0.12932521f, 0.01497296f, 0.02819734f, -0.05391059f, 0.00412884f, 
    -0.17852254f, 0.00919641f, 0.05358936f, -0.01267791f, -0.13406776f, 0.04746258f, 0.02992539f, 0.06030463f, 
    -0.10846306f, -0.04903781f, 0.04479484f, -0.18613558f, -0.23138145f, -0.18360603f, 0.03029742f, -0.06725493f, 
    0.13727213f, -0.03628827f, 0.06397024f, 0.04674017f, -0.01601987f, -0.06785924f, 0.01267385f, -0.01590244f, 
    0.22540060f, 0.16410959f, -0.07862417f, -0.16754043f, 0.05749390f, -0.03509747f, -0.10897768f, -0.00032518f, 
    0.04815887f, -0.11430629f, 0.05052842f, -0.06535710f, -0.42714682f, 0.06402829f, -0.03860090f, 0.10723580f, 
    0.02202708f, 0.05425094f, -0.02801674f, 0.11110228f, -0.02653745f, -0.14859332f, 0.02188129f, -0.01608414f, 
    0.20054181f, 0.16580854f, -0.06402295f, 0.02122379f, -0.01642238f, 0.01065130f, -0.02428669f, 0.06648338f, 
    -0.07286585f, -0.04637235f, 0.04312740f, -0.00622108f, -0.02543812f, 0.03455421f, -0.09705662f, -0.11597827f, 
    -0.02242181f, -0.01046779f, -0.08301557f, 0.01782189f, 0.00982294f, -0.04440568f, -0.03590155f, 0.07293788f, 
    -0.15188359f, 0.07473884f, -0.02004907f, -0.07019314f, 0.07978481f, -0.09877288f, 0.00966421f, -0.03337833f, 
    -0.04233348f, -0.00137054f, -0.01531332f, -0.07622724f, -0.43864813f, 0.07385296f, 0.18080625f, 0.12316800f, 
    -0.05343107f, -0.07222532f, -0.01297852f, 0.05432823f, 0.01757926f, -0.06274626f, -0.11992002f, -0.02026242f, 
    0.12149490f, 0.02600789f, -0.04560338f, -0.01040405f, 0.06422928f, -0.06918436f, 0.03798910f, 0.03260440f, 
    -0.03756841f, 0.03087185f, 0.08017914f, -0.00331095f, 0.26652989f, -0.41828057f, -0.13103926f, 0.03741204f, 
    -0.22039938f, -0.00497733f, 0.07213203f, -0.07400610f, -0.05462530f, 0.15226589f, -0.03075988f, -0.00323417f, 
    -0.20769796f, 0.08695243f, 0.02492350f, 0.09826302f, -0.03080647f, 0.14624557f, -0.08107950f, -0.03155363f, 
    -0.03999020f, -0.02593247f, -0.02396783f, -0.13089298f, 0.27565408f, 0.06550380f, 0.08006080f, -0.01805509f, 
    -0.02285264f, 0.04975698f, 0.01225843f, 0.04020442f, 0.02370577f, 0.04231422f, 0.03231490f, -0.06240510f, 
    0.06081080f, 0.00421339f, -0.08476000f, 0.26371288f, 0.02565331f, -0.00062200f, 0.13470086f, 0.02601045f, 
    0.21072763f, 0.00807872f, -0.03100291f, -0.10585085f, -0.06236546f, 0.02423739f, 0.02522177f, 0.02500007f, 
    -0.00670391f, -0.08346883f, 0.00357637f, -0.04441294f, 0.00542194f, -0.06117735f, 0.04886204f, -0.08963649f, 
    0.10602836f, -0.10196742f, 0.14631824f, 0.12330161f, -0.13197550f, -0.03236048f, 0.06886289f, -0.19072603f, 
    0.01932925f, 0.06409343f, -0.10927784f, -0.19566281f, -0.06716674f, 0.13985464f, -0.22198491f, 0.04863819f, 
    0.00146874f, 0.00984161f, 0.17696728f, 0.01881499f, -0.04497425f, -0.02714447f, 0.01934283f, 0.14264590f, 
    0.00754024f, 0.01587552f, 0.09609935f, 0.21680023f, 0.11314388f, -0.04874197f, 0.04332891f, 0.18321949f, 
    -0.00475029f, -0.02724256f, 0.08255473f, -0.01451823f, -0.05664952f, -0.03732830f, -0.15589134f, -0.15142235f, 
    -0.07571937f, -0.04295787f, 0.01388519f, -0.20640896f, -0.03238105f, -0.07331148f, -0.03910030f, -0.00127132f, 
    -0.18644039f, -0.35852224f, 0.14586379f, -0.00934738f, -0.00856052f, 0.00106214f, 0.02441883f, -0.01922087f, 
    0.05248327f, -0.02922977f, -0.03966270f, -0.02338052f, -0.12519658f, 0.03461248f, 0.06635112f, -0.03900529f, 
    0.10480978f, 0.01611737f, 0.05754422f, 0.04656970f, 0.00232970f, 0.01605846f, 0.01108513f, 0.16468629f, 
    -0.06965639f, 0.06305570f, 0.15558274f, -0.01774142f, 0.01917183f, -0.02507608f, -0.06568116f, 0.01598532f, 
    0.02681276f, -0.01179444f, 0.00795321f, -0.01826359f, -0.05683339f, 0.23047136f, 0.10828524f, 0.04564735f, 
    -0.10107497f, -0.15841521f, 0.12019819f, -0.12462405f, -0.05021489f, -0.06882562f, -0.05595938f, -0.02530057f, 
    -0.15071289f, 0.14527534f, -0.17751452f, -0.49354875f, -0.06520612f, 0.04711181f, 0.02414918f, 0.00752490f, 
    0.08186401f, -0.19434321f, -0.01328732f, 0.04180491f, 0.15382436f, 0.01434676f, 0.14252755f, 0.11776786f, 
    -0.11336592f, -0.11488146f, -0.05204685f, 0.00732413f, -0.00347016f, 0.02181833f, 0.03500654f, -0.14782049f, 
    -0.15059394f, 0.13054109f, -0.04131634f, 0.11509484f, -0.08996334f, 0.17158334f, 0.14881283f, 0.02602066f, 
    0.12227289f, -0.08632870f, -0.07192114f, -0.06768566f, 0.23924612f, 0.28749409f, -0.11848284f, -0.02141724f, 
    0.05528195f, -0.10240764f, -0.00586419f, -0.05472380f, -0.06045339f, 0.01767446f, 0.07272296f, 0.11122309f, 
    -0.48786938f, 0.17156482f, -0.07139030f, -0.08447827f, 0.07573536f, 0.07309828f, -0.02418752f, 0.05833901f, 
    -0.15125015f, 0.02488247f, -0.07515851f, 0.03321170f, -0.34095806f, 0.02111481f, -0.12857477f, -0.11244994f, 
    0.15245962f, -0.00721639f, 0.04805947f, -0.14188403f, 0.04814743f, -0.01168044f, -0.02063329f, -0.08034150f, 
    -0.04562839f, 0.07920200f, -0.04018860f, 0.22681537f, -0.07409940f, -0.04630094f, -0.05923744f, -0.01987093f, 
    0.01875405f, -0.07350074f, 0.04379826f, -0.10140952f, 0.00666066f, -0.00402891f, 0.09395204f, 0.13718382f, 
    -0.05165339f, -0.04153750f, -0.02973887f, 0.05806989f, -0.07732544f, -0.01646890f, -0.10851485f, 0.04842355f, 
    -0.00466507f, -0.00570946f, 0.06801713f, -0.07799268f, 0.07222939f, 0.04306352f, 0.01274616f, 0.08279832f, 
    0.16636761f, -0.08354169f, -0.08190134f, -0.02575286f, -0.29472625f, -0.37448800f, 0.02397397f, 0.06139163f, 
    -0.12696084f, -0.00129263f, 0.03235051f, -0.10439099f, 0.05424054f, -0.03995653f, 0.02918164f, -0.12620008f, 
    -0.11508587f, 0.07659058f, 0.08115827f, 0.07905663f, -0.06354622f, -0.04347094f, 0.06142127f, -0.05294552f, 
    -0.05416232f, -0.09359174f, 0.06689753f, -0.03703849f, -0.00167112f, -0.19060721f, -0.09596842f, 0.18767582f, 
    0.01760637f, 0.01883913f, 0.13854553f, 0.04697108f, -0.03864083f, -0.08199468f, 0.00135373f, 0.07150848f, 
    -0.01728593f, 0.27652809f, -0.11315963f, -0.07731760f, -0.00906970f, 0.04858440f, -0.04702906f, 0.07547831f, 
    0.08608424f, 0.03399014f, -0.11191682f, -0.01861170f, -0.27202085f, 0.10683540f, -0.04604387f, 0.11202765f, 
    0.06009029f, -0.00655837f, 0.08250732f, 0.04249138f, -0.03193482f, -0.00974198f, 0.10448255f, 0.03227946f, 
    -0.14884676f, -0.04626854f, 0.07744064f, -0.01643952f, 0.13374308f, -0.07141635f, -0.08404183f, -0.07774597f, 
    0.00241760f, -0.09666271f, -0.13330996f, 0.01549451f, -0.20759714f, -0.19407807f, 0.09699120f, 0.25262278f, 
    -0.14581159f, -0.00230859f, -0.01317913f, -0.09004705f, 0.04617010f, 0.03458491f, 0.02689433f, -0.06131941f, 
    -0.19218808f, -0.03431849f, 0.14810388f, 0.10073600f, -0.01113146f, 0.07959523f, -0.00638409f, 0.00097741f, 
    -0.04543131f, -0.10477308f, -0.05793907f, -0.25357750f, -0.07268025f, -0.00839311f, -0.05752980f, -0.02130215f, 
    0.03638528f, -0.11745162f, -0.02481647f, -0.15007818f, 0.01884929f, -0.04472563f, -0.05293259f, 0.05780183f, 
    -0.10075867f, 0.10001556f, -0.01700095f, -0.08995575f, 0.06793454f, -0.10911873f, -0.02339623f, 0.04741383f, 
    0.05348064f, -0.03485445f, -0.13911362f, -0.05272430f, 0.06551973f, -0.15373217f, -0.28134313f, -0.05059225f, 
    0.03805906f, 0.05264444f, -0.04828114f, -0.14522094f, -0.02482529f, -0.24918938f, -0.02980578f, -0.01097412f, 
    -0.17730469f, 0.00454108f, -0.26044741f, 0.01558568f, 0.02703881f, 0.06486048f, -0.01286633f, 0.03600312f, 
    0.06828501f, -0.04364230f, 0.02895086f, 0.01367369f, -0.06520760f, -0.13364063f, 0.24273443f, 0.20776883f, 
    0.11959159f, 0.05723076f, 0.09159748f, 0.05138445f, 0.05725730f, -0.05136736f, -0.01937932f, -0.13823114f, 
    0.01333681f, 0.05274489f, 0.08583184f, 0.17648737f, -0.13444248f, -0.00272259f, -0.08185066f, -0.05858874f, 
    0.04271746f, 0.07326695f, 0.11349420f, -0.00743170f, -0.03386794f, 0.05502514f, 0.12435549f, -0.08577838f, 
    0.23363777f, -0.13874212f, -0.14752746f, 0.10899291f, 0.12802632f, -0.12057260f, -0.16080834f, -0.10616190f, 
    -0.20026596f, -0.12553599f, -0.06938963f, 0.15880527f, 0.03647238f, 0.04914442f, 0.00808189f, 0.08948662f, 
    -0.00100963f, 0.07777584f, 0.01582745f, 0.01715080f, 0.14825924f, 0.08350742f, 0.10465164f, 0.01509724f, 
    0.02782716f, 0.15981786f, -0.07977048f, -0.15189704f, -0.00162944f, -0.17711340f, -0.01690606f, -0.05367920f, 
    0.25943601f, 0.01338099f, -0.13180916f, -0.14871448f, -0.02422348f, -0.03921230f, -0.15655430f, -0.07488488f, 
    0.07931245f, 0.07909001f, -0.12323997f, -0.08506533f, -0.11779542f, 0.17308182f, 0.02500608f, 0.04641451f, 
    -0.01224660f, -0.15069731f, 0.05010926f, 0.12602849f, -0.04055880f, 0.05472037f, -0.00190697f, 0.03736487f, 
    0.15080912f, 0.18686020f, -0.04038787f, -0.07834318f, 0.03045836f, -0.09321243f, -0.03082749f, -0.20760530f, 
    -0.23359570f, 0.04207878f, -0.10210828f, 0.02095781f, 0.08076405f, 0.09923214f, -0.02398921f, -0.06515141f, 
    0.03880314f, 0.02045871f, 0.06900127f, -0.01722914f, 0.04079828f, -0.12693894f, 0.06331798f, -0.08129686f, 
    -0.04671419f, -0.02267818f, 0.16676807f, 0.25671551f, 0.09081727f, -0.00949174f, 0.00313002f, 0.05589235f, 
    0.00070532f, 0.04742850f, -0.11076688f, 0.03206697f, 0.04106184f, 0.10773173f, 0.04130208f, -0.01902552f, 
    0.02576558f, -0.00434172f, 0.03358569f, -0.00598002f, -0.14430565f, 0.00550501f, 0.08220639f, 0.19830413f, 
    -0.40359265f, -0.07594537f, -0.13164705f, 0.14260657f, 0.01166255f, 0.03528403f, 0.00133874f, -0.09324397f, 
    0.01240736f, 0.06168223f, 0.00976022f, 0.01951470f, 0.01043650f, 0.16103388f, 0.02527133f, 0.13294695f, 
    0.15671623f, -0.04842687f, -0.14508292f, -0.12220611f, -0.07018376f, 0.05626491f, 0.00350042f, -0.14332591f, 
    -0.01493244f, -0.01290633f, -0.09657000f, 0.10305379f, 0.05796781f, -0.06308622f, 0.11560262f, -0.06444260f, 
    0.00275759f, -0.09437253f, -0.00585914f, -0.06885631f, -0.35221988f, -0.04723693f, -0.28457826f, -0.02693035f, 
    0.09328782f, 0.06244465f, -0.14983064f, -0.02165548f, -0.04533065f, 0.04285410f, 0.05604724f, 0.05766135f, 
    -0.11561289f, 0.09400254f, 0.17741543f, -0.16500063f, 0.12655012f, 0.04575444f, 0.01026492f, -0.00773179f, 
    0.11140358f, 0.11456215f, 0.06599596f, -0.10969681f, -0.71356314f, 0.20956299f, 0.00029345f, -0.29678971f, 
    0.14179465f, -0.00280522f, -0.03699717f, -0.04446160f, -0.00421438f, 0.04520546f, 0.04171731f, -0.05404612f, 
    -0.33181101f, -0.23379092f, 0.20484294f, 0.21428567f, -0.10902933f, -0.02711185f, -0.04526777f, 0.00444069f, 
    -0.06124411f, 0.04122905f, 0.02811807f, 0.01136301f, 0.09042885f, 0.02322736f, 0.00703474f, 0.04675465f, 
    -0.05820199f, 0.01565608f, -0.05023264f, 0.01267159f, -0.03061001f, -0.02268872f, -0.13163278f, 0.04678234f, 
    0.24388607f, 0.02494253f, 0.01983435f, -0.12060412f, -0.03705584f, 0.18612657f, 0.06350053f, -0.21691512f, 
    -0.06227379f, -0.08871374f, -0.02338849f, -0.08752519f, 0.05493785f, 0.08476669f, 0.00630493f, -0.15559720f, 
    0.09537871f, 0.04618071f, 0.02061624f, -0.04140779f, 0.05484339f, 0.04200269f, 0.13431290f, 0.04975870f, 
    0.05650358f, -0.03007134f, 0.10132904f, 0.10165745f, -0.01620460f, 0.10391606f, -0.00369712f, -0.01847267f, 
    0.04986250f, -0.00511780f, -0.07794567f, 0.22300775f, -0.34251109f, 0.08750740f, 0.05779811f, -0.01418513f, 
    -0.04508843f, 0.01584424f, 0.24564224f, 0.11924413f, 0.23156035f, 0.12334182f, -0.07694584f, -0.02665050f, 
    -0.00093376f, -0.00166450f, 0.12616476f, 0.13124809f, 0.02998164f, 0.02525235f, 0.17371956f, -0.01561725f, 
    0.02452645f, 0.02392698f, -0.07384576f, 0.03509937f, -0.47171772f, -0.11046306f, -0.22600210f, -0.18122137f, 
    0.13618283f, -0.00538391f, 0.06060093f, 0.08631639f, -0.00137949f, 0.13340573f, -0.06932433f, -0.16526832f, 
    -0.17853485f, -0.31354761f, 0.08843350f, -0.04354153f, 0.14447246f, -0.00874060f, -0.07123970f, -0.20417377f, 
    -0.00498381f, 0.11148393f, -0.06029687f, 0.19616142f, -0.25366277f, -0.47661933f, -0.23439209f, 0.05003458f, 
    0.08026494f, -0.01280521f, 0.17732421f, -0.11553252f, -0.06816677f, 0.06896175f, -0.03706765f, -0.02130493f, 
    0.01666883f, -0.06659888f, 0.03317868f, -0.04590227f, 0.03370815f, 0.01791856f, -0.10315430f, 0.00019245f, 
    -0.00347491f, -0.00353052f, 0.16236800f, 0.24150668f, 0.11660245f, -0.01288289f, -0.00200142f, 0.16983151f, 
    -0.05346730f, -0.07781891f, 0.06943072f, 0.07483900f, 0.01156954f, -0.06605976f, 0.05635963f, 0.05788715f, 
    0.08606340f, 0.02623139f, 0.02498950f, -0.17306826f, -0.11354121f, -0.03371365f, -0.16521353f, -0.04514886f, 
    0.00166662f, -0.08306863f, 0.04549787f, 0.04116118f, -0.08350585f, 0.16622683f, 0.02782058f, -0.16166687f, 
    -0.04338342f, -0.00142551f, -0.01929586f, -0.17674538f, -0.07608991f, -0.03156190f, 0.00083656f, -0.04852081f, 
    0.03147273f, 0.11730191f, -0.11204696f, -0.15164125f, -0.00032180f, -0.09817226f, 0.00938240f, 0.07210571f, 
    -0.04788002f, -0.00194489f, 0.08502354f, -0.20289376f, 0.08656774f, 0.06882747f, 0.10225205f, 0.09923878f, 
    -0.02888994f, -0.07692292f, 0.10384089f, -0.03942136f, 0.11291815f, 0.06749638f, 0.10298041f, 0.15541975f, 
    -0.25915042f, -0.13758835f, -0.05061761f, -0.11128289f, 0.07792747f, -0.08598819f, -0.10971358f, -0.01879489f, 
    -0.01260006f, 0.03778745f, -0.04443317f, 0.06444257f, 0.01530070f, 0.00278052f, 0.07166387f, 0.07857203f, 
    -0.01393285f, 0.02931676f, 0.02927630f, -0.02969617f, -0.02299157f, -0.02439071f, -0.14398147f, 0.16367620f, 
    0.09275819f, 0.05969175f, 0.02170439f, -0.26113862f, 0.06571102f, -0.01896221f, -0.01136492f, 0.11698405f, 
    0.04024220f, -0.01494919f, 0.01702110f, 0.06077147f, -0.03510985f, 0.09254202f, 0.16828755f, -0.12243497f, 
    -0.05005692f, -0.06295267f, 0.04997374f, -0.01769342f, 0.00295300f, -0.15848207f, -0.05305318f, -0.14997475f, 
    -0.04825404f, -0.18089183f, -0.22521536f, 0.08438313f, 0.12378497f, 0.17564270f, -0.04426390f, 0.01074280f, 
    -0.03383187f, 0.00077720f, 0.05300923f, 0.06135866f, 0.05875824f, -0.09146383f, 0.29606411f, 0.00206160f, 
    -0.00807488f, -0.14316891f, -0.02569856f, 0.16610059f, 0.22373493f, -0.14353009f, 0.13685964f, -0.08603284f, 
    0.14999983f, 0.08459791f, 0.06362325f, 0.11184645f, -0.12299001f, -0.13471217f, -0.03686423f, 0.15541613f, 
    -0.02789609f, -0.05166486f, 0.05941629f, -0.07076200f, -0.35567406f, -0.09349205f, 0.09416711f, 0.13944399f, 
    -0.07179066f, 0.05483153f, -0.05073555f, -0.11426800f, 0.04808282f, -0.05052995f, 0.06268425f, -0.16615987f, 
    0.08540973f, -0.00668803f, 0.03477963f, -0.02577203f, -0.04608405f, 0.14770681f, 0.01905514f, 0.00567680f, 
    -0.20244424f, 0.02605150f, 0.05102174f, -0.03127738f, 0.09008307f, -0.17924239f, -0.07102765f, 0.08546961f, 
    -0.13345860f, -0.02367957f, -0.06003863f, 0.06336170f, 0.08740682f, 0.14563213f, 0.06757060f, 0.06799755f, 
    -0.23474492f, -0.13136509f, 0.23199655f, -0.31402290f, -0.04720762f, 0.01289009f, 0.13783605f, 0.02100400f, 
    -0.02739374f, 0.13705711f, 0.04337865f, 0.07887582f, -0.04596843f, 0.01841204f, -0.08728817f, 0.07526433f, 
    -0.12090021f, 0.06144486f, 0.01324903f, 0.02664988f, 0.05901632f, 0.03700886f, 0.05198290f, 0.06935004f, 
    -0.12455732f, 0.00358288f, 0.15692095f, -0.15431885f, 0.10634007f, -0.25433806f, -0.09545953f, 0.10094784f, 
    0.06201221f, 0.04126517f, 0.04744632f, 0.13314283f, -0.14878938f, -0.23120345f, 0.14374012f, 0.16117461f, 
    -0.10520662f, -0.02555258f, 0.09406668f, 0.08128960f, -0.03254565f, -0.15373307f, -0.04754470f, -0.27032864f, 
    -0.12333782f, -0.09868699f, -0.05112494f, -0.10017308f, 0.04083577f, 0.08628502f, 0.05017328f, -0.03389269f, 
    -0.05273816f, -0.04876345f, -0.00650510f, 0.02955985f, -0.28642970f, 0.19061095f, 0.11025293f, -0.02166024f, 
    -0.12142181f, -0.03089373f, -0.06865256f, 0.00512558f, 0.11403608f, -0.05249153f, -0.13747194f, 0.09931359f, 
    -0.30545756f, 0.01183023f, 0.05861923f, 0.02023735f, 0.04475044f, 0.02092343f, 0.07925231f, 0.00113008f, 
    -0.06331755f, 0.09159165f, 0.07028215f, 0.11798806f, 0.06943862f, -0.01206527f, 0.03124195f, -0.25111073f, 
    -0.00657558f, -0.04841841f, 0.03067413f, 0.05394261f, 0.08693905f, -0.04602892f, 0.01827621f, -0.15171970f, 
    -0.09724218f, 0.16359277f, -0.01321250f, 0.11688542f, -0.10091475f, -0.00886429f, -0.03434375f, -0.11876620f, 
    -0.00605584f, -0.18800101f, 0.19317700f, 0.14470132f, 0.08638529f, 0.15017954f, -0.00004738f, 0.06084841f, 
    -0.08184229f, -0.07190895f, 0.00647994f, -0.01761336f, -0.06917743f, 0.06586371f, -0.10731404f, 0.13504957f, 
    -0.09931169f, -0.22588007f, 0.08109811f, 0.24800266f, -0.08289739f, -0.08091383f, 0.08223937f, 0.02218627f, 
    -0.06108648f, 0.06094601f, 0.15625146f, 0.12024166f, 0.16783223f, -0.15811551f, 0.08146350f, -0.01370949f, 
    0.06168781f, -0.10935431f, -0.10202763f, 0.00795556f, 0.09427157f, -0.05233942f, -0.12326627f, -0.16618036f, 
    -0.17582521f, 0.01091989f, 0.21888568f, 0.29522467f, 0.03858194f, -0.07563286f, -0.02544893f, 0.02579943f, 
    0.11909807f, 0.10743637f, -0.00124600f, 0.08026338f, -0.36173710f, -0.08717756f, -0.18394653f, -0.10768154f, 
    0.01912848f, 0.00306673f, -0.04567149f, -0.20897600f, 0.01090548f, -0.10357352f, 0.05165876f, -0.17779291f, 
    0.08987139f, -0.03445934f, 0.00380815f, -0.18372139f, 0.01286976f, 0.01509947f, -0.02569380f, 0.10496856f, 
    0.13904488f, 0.08105518f, 0.01139274f, -0.01685587f, 0.02858580f, 0.07681285f, 0.00687630f, 0.14182907f, 
    -0.01211982f, -0.09056395f, -0.00782338f, 0.05128729f, -0.07254609f, -0.21404809f, -0.03531637f, 0.16296387f, 
    0.17641671f, 0.02886151f, -0.04691897f, 0.28097650f, 0.02016787f, -0.02645016f, -0.05406761f, 0.06396817f, 
    -0.05575791f, 0.16253655f, 0.03903202f, 0.18665752f, 0.09771921f, -0.28821173f, -0.13425875f, 0.03930191f, 
    -0.06231086f, 0.08130238f, 0.09809922f, -0.01069481f, 0.02970217f, 0.03965307f, 0.00394552f, 0.15798651f, 
    0.32856092f, -0.14893518f, 0.09979790f, -0.08923278f, -0.08548969f, 0.02381820f, 0.03329689f, 0.10492408f, 
    0.08419172f, -0.01020187f, 0.27288318f, -0.04911454f, -0.04452954f, -0.03612818f, -0.20724836f, -0.03937812f, 
    -0.02823989f, 0.04649206f, -0.01311027f, -0.06738473f, -0.02292722f, 0.19005044f, 0.01564431f, 0.01111035f, 
    -0.09886930f, -0.08639242f, -0.07943606f, -0.17088765f, -0.00315878f, -0.03313563f, -0.04620103f, -0.11649532f, 
    -0.04061745f, 0.07840811f, -0.04217916f, 0.08128010f, 0.20347972f, -0.10938985f, -0.19489004f, -0.16195843f, 
    -0.01069157f, 0.05720385f, 0.01196268f, -0.02571414f, 0.09480787f, 0.01616032f, 0.08000264f, 0.15294190f, 
    0.02438812f, 0.13645545f, 0.30025774f, 0.02457129f, 0.06764033f, -0.15697503f, 0.08202652f, 0.04590206f, 
    0.03572569f, -0.04508494f, -0.09910139f, -0.03643351f, 0.25625831f, 0.04396993f, 0.21177067f, -0.21177495f, 
    -0.00317473f, -0.05163034f, 0.08419302f, 0.04053022f, 0.09746606f, 0.08107486f, 0.00711987f, 0.05710871f, 
    0.18891232f, -0.02136102f, -0.02612875f, -0.13915358f, -0.01020899f, -0.00427602f, -0.11742388f, -0.15926898f, 
    -0.09468138f, -0.06196802f, 0.06797758f, -0.09894443f, -0.18078528f, -0.09355439f, -0.16749364f, -0.07446607f, 
    -0.04860800f, -0.09657284f, 0.13029933f, -0.06415422f, 0.02407261f, 0.01493499f, -0.06796703f, 0.07005250f, 
    -0.24020194f, 0.01718996f, -0.18600740f, 0.22694524f, -0.05453381f, 0.07161962f, 0.07060877f, 0.03061386f, 
    0.01028797f, -0.03504256f, 0.13032086f, -0.06134720f, -0.22986779f, -0.12914729f, -0.08820046f, 0.33629441f, 
    0.00032649f, 0.12662829f, -0.00680279f, -0.01369597f, 0.05188574f, 0.00568679f, -0.01455644f, -0.11504245f, 
    -0.23109201f, -0.02640880f, -0.00155113f, 0.16069397f, 0.05214272f, 0.03091486f, -0.03643188f, 0.01904541f, 
    -0.00250982f, -0.04334302f, 0.04853582f, 0.03744395f, 0.00489643f, -0.15543441f, -0.13464692f, -0.06892899f, 
    -0.07751863f, 0.02900710f, 0.02425491f, 0.00231599f, 0.01057366f, 0.00065807f, -0.09046148f, 0.09029497f, 
    -0.16802840f, -0.03548389f, -0.33524823f, 0.03667169f, 0.04968040f, -0.08066925f, -0.05135917f, -0.00218264f, 
    0.06499273f, -0.08612725f, 0.06268022f, 0.01653110f, 0.26958084f, 0.08130219f, -0.07143661f, -0.14668271f, 
    -0.01527206f, 0.08125019f, 0.01011210f, -0.02602893f, 0.08905310f, -0.13806809f, -0.17165427f, 0.11284512f, 
    -0.18037194f, 0.07525508f, -0.07951216f, -0.13376451f, 0.02472182f, -0.01965630f, 0.01449667f, -0.07892966f, 
    -0.00900231f, 0.05530345f, 0.04814387f, 0.01972452f, -0.04022245f, -0.16324303f, -0.04119297f, 0.01343952f, 
    -0.12523213f, 0.01654365f, -0.03709773f, 0.06296842f, -0.04045769f, -0.10084348f, 0.00594197f, 0.00426321f, 
    -0.27485535f, 0.11959986f, -0.03909154f, 0.25089630f, 0.01175084f, -0.07371211f, -0.01451157f, 0.02656562f, 
    0.00663730f, 0.07669479f, -0.11418085f, -0.05960726f, -0.27382669f, -0.12826739f, -0.06586146f, -0.16134253f, 
    -0.01711039f, 0.03169242f, 0.01664494f, -0.03944822f, -0.00168686f, -0.06698417f, 0.02835513f, -0.06011204f, 
    0.01243977f, -0.11546153f, 0.07585565f, -0.21960628f, 0.01275255f, 0.06823221f, 0.01754311f, 0.04360783f, 
    -0.20437156f, -0.06414184f, -0.00006196f, 0.00888541f, 0.42042843f, -0.45082930f, 0.13513361f, -0.09568678f, 
    -0.05802469f, -0.02556407f, 0.03530393f, 0.00193064f, 0.04233781f, -0.07580450f, 0.01996796f, -0.05862132f, 
    0.21721657f, -0.20358485f, -0.25148356f, 0.19708207f, 0.04799515f, 0.05568170f, 0.03877929f, 0.01462696f, 
    -0.04679732f, 0.01871968f, -0.02030677f, 0.01675017f, 0.08499912f, -0.07300147f, -0.00757378f, -0.06472043f, 
    -0.02277764f, 0.03472566f, -0.15162784f, -0.03556949f, -0.04216566f, 0.01096806f, 0.09433820f, 0.02744968f, 
    -0.24101551f, -0.17381157f, 0.04859317f, -0.12340868f, -0.00835377f, -0.07860541f, -0.01753800f, -0.02114186f, 
    -0.04692680f, 0.02498647f, -0.02254237f, 0.01012066f, 0.17913036f, -0.06150371f, 0.13197805f, -0.11268856f, 
    -0.03517759f, 0.05486319f, 0.13302380f, 0.08851545f, 0.00286028f, 0.09558660f, -0.11681366f, -0.14330541f, 
    -0.00247007f, 0.16497409f, 0.11219601f, -0.15439126f, -0.09937153f, -0.11077423f, -0.00559656f, 0.00852319f, 
    0.13393497f, -0.06919272f, 0.04602998f, -0.20734543f, 0.25261751f, -0.02424809f, -0.10703386f, 0.16617356f, 
    0.00088250f, 0.03192557f, -0.14290360f, -0.11801703f, -0.11582437f, 0.02366467f, -0.00404148f, 0.04492079f, 
    -0.05769736f, 0.00863284f, -0.09302078f, 0.12527867f, -0.05565557f, -0.04281911f, -0.05173806f, 0.07783623f, 
    0.01637902f, -0.01130634f, 0.01365082f, -0.08381645f, -0.12746160f, -0.20974749f, 0.12279859f, -0.35430777f, 
    -0.02683090f, -0.03396636f, 0.08118892f, -0.18581097f, -0.14253868f, -0.12276235f, 0.12076003f, 0.05198846f, 
    -0.07967622f, -0.05807079f, -0.04019371f, 0.06999928f, -0.03105044f, 0.02490788f, -0.01984865f, -0.06627239f, 
    -0.11476949f, 0.04511036f, 0.01835853f, -0.07192423f, -0.18786477f, -0.10024936f, -0.07666779f, -0.10299584f, 
    -0.11535520f, 0.07248166f, 0.03968316f, -0.09075329f, -0.04111430f, -0.00627119f, -0.08826039f, 0.05108450f, 
    0.13718648f, 0.05820675f, -0.01135980f, -0.02080088f, -0.15997587f, 0.03305443f, 0.12131596f, 0.01130976f, 
    0.13790564f, 0.01846711f, 0.01474325f, -0.24863340f, 0.06090503f, 0.03345124f, 0.09615872f, -0.14761746f, 
    0.09518982f, -0.07254048f, 0.10673167f, 0.02060473f, 0.01657462f, 0.07129411f, -0.00197536f, 0.03114615f, 
    0.32426879f, 0.11127556f, 0.19160643f, -0.36262932f, 0.05897668f, 0.11158112f, 0.09729422f, 0.06271081f, 
    0.01116413f, 0.04005042f, -0.17340425f, 0.11499549f, -0.16226777f, 0.12291215f, 0.02210016f, 0.17355472f, 
    0.06135622f, 0.15912023f, -0.06042324f, 0.06546025f, 0.02698260f, -0.06179656f, 0.06976087f, 0.03870538f, 
    0.02857112f, -0.04644720f, 0.11942971f, -0.01013315f, -0.06307209f, 0.03408689f, 0.05773313f, 0.03707781f, 
    0.03028013f, -0.00160622f, 0.04985714f, 0.00660047f, -0.09257081f, 0.01346593f, 0.13813771f, -0.18773521f, 
    -0.04959793f, 0.03281507f, -0.08810177f, -0.00352871f, -0.02323167f, -0.02438316f, -0.01904585f, -0.12855197f, 
    -0.13890421f, 0.15671282f, 0.05415511f, -0.17605820f, -0.06530623f, 0.02496752f, 0.04535090f, 0.15538704f, 
    0.01835447f, -0.08135834f, -0.05406815f, -0.16130799f, 0.08114442f, 0.03351141f, -0.00371187f, -0.26416916f, 
    -0.07772318f, 0.03830646f, 0.04182154f, 0.08410202f, 0.03458748f, 0.02327468f, -0.01136590f, -0.05295440f, 
    -0.16669026f, 0.11857336f, 0.07314626f, -0.13723497f, 0.00556729f, 0.06115950f, -0.05067546f, 0.03556208f, 
    -0.07889792f, 0.03420139f, 0.10835262f, -0.05968244f, 0.00964546f, -0.26767921f, 0.02342172f, -0.01858540f, 
    -0.05306336f, 0.03614895f, 0.04345461f, 0.09624282f, 0.10813898f, 0.04492010f, 0.11830663f, 0.18717982f, 
    -0.28847322f, 0.01659766f, -0.16249110f, -0.24674846f, -0.13488457f, -0.04657663f, 0.06575328f, -0.08386480f, 
    0.08065703f, 0.01692201f, -0.00115400f, -0.05719785f, 0.17980613f, -0.07179941f, -0.23678720f, 0.16767439f, 
    0.04429286f, 0.03358271f, 0.13679630f, 0.04888130f, -0.11390021f, 0.06600582f, -0.04839190f, 0.03541230f, 
    -0.10904673f, -0.09549195f, 0.05914906f, -0.14099653f, 0.12589048f, -0.04124503f, 0.00485323f, 0.03653004f, 
    0.05021423f, 0.06315442f, -0.16465913f, 0.08078180f, 0.22664720f, -0.22769588f, 0.00668998f, 0.01138331f, 
    -0.04543576f, 0.00020881f, 0.04785575f, 0.00750619f, -0.02160504f, -0.08383286f, 0.00603545f, 0.10071964f, 
    0.07107513f, 0.15766145f, 0.08376834f, -0.14824590f, -0.05165528f, -0.18076064f, -0.01286034f, 0.03275682f, 
    0.03285543f, -0.05686924f, -0.09121899f, 0.05516229f, -0.07384298f, -0.31398892f, -0.01652406f, 0.06414744f, 
    0.07944374f, -0.01821728f, 0.08361533f, -0.06465824f, -0.14723483f, -0.03195216f, -0.05824162f, -0.09347156f, 
    0.17439838f, -0.20524433f, -0.02611439f, 0.20649470f, 0.02451264f, 0.01212562f, -0.05652677f, 0.00300605f, 
    0.04647013f, -0.12662841f, -0.10379031f, -0.01211771f, -0.00592902f, 0.06530722f, 0.06466988f, -0.13651344f, 
    -0.00083598f, -0.02667147f, 0.03540587f, 0.05395208f, -0.00166046f, -0.04484807f, -0.05684580f, -0.05896574f, 
    0.03777135f, 0.20432220f, 0.05625302f, -0.40962994f, -0.08559347f, 0.09106592f, 0.05524236f, -0.00182270f, 
    -0.12386072f, 0.11216158f, 0.06336217f, -0.06090534f, -0.09228627f, -0.05234954f, -0.01186856f, 0.29004082f, 
    0.04963607f, -0.07888845f, 0.00227433f, 0.01402763f, 0.00462376f, -0.00565777f, 0.03929317f, 0.19167310f, 
    0.39416894f, -0.17685013f, 0.14061125f, 0.03586707f, -0.05310474f, -0.05301505f, -0.04716594f, 0.05362485f, 
    0.12371854f, 0.07689074f, 0.05417946f, 0.02821119f, 0.18534286f, -0.06952883f, 0.27593964f, 0.15432602f, 
    -0.12298274f, -0.12011933f, -0.07683846f, 0.05465874f, -0.01358437f, -0.14164889f, -0.02159374f, 0.08516666f, 
    -0.02848018f, 0.14605644f, -0.07300679f, -0.09629020f, 0.02395542f, 0.04677579f, 0.13858205f, 0.00361242f, 
    -0.11493615f, -0.11494866f, -0.12812434f, -0.30397749f, -0.10279839f, 0.03541276f, 0.17374218f, -0.01388932f, 
    -0.04784469f, -0.12493352f, -0.16741799f, 0.02250724f, -0.08014029f, 0.01312875f, -0.00024396f, 0.19481769f, 
    0.06105619f, -0.07056466f, 0.14676267f, 0.15071836f, 0.05710044f, -0.00944443f, 0.01161319f, -0.04031480f, 
    0.04536748f, 0.06315467f, -0.20971350f, -0.01522986f, -0.15663411f, 0.19389352f, 0.00994768f, 0.05754957f, 
    0.05242782f, 0.09812865f, -0.04019118f, -0.00534663f, 0.03948787f, -0.12464438f, 0.01452855f, -0.09919294f, 
    -0.08481216f, -0.07575839f, 0.02194977f, 0.05566968f, -0.02126441f, 0.07696585f, -0.12188888f, 0.00720684f, 
    -0.00971701f, -0.11534852f, -0.01890348f, -0.05251357f, -0.59599364f, 0.21450777f, -0.04148579f, 0.11112404f, 
    -0.13113907f, 0.05075034f, 0.16187049f, 0.02859441f, 0.00772454f, 0.03451667f, 0.07671513f, 0.12568153f, 
    0.07653118f, 0.00359662f, -0.04152131f, -0.00803772f, 0.15814288f, -0.07949090f, 0.08947814f, 0.03949631f, 
    -0.22163510f, 0.07343832f, -0.10726288f, -0.19783472f, 0.08067635f, -0.07814006f, -0.13449280f, -0.09594800f, 
    -0.15144692f, 0.06950738f, -0.04234614f, -0.01590225f, -0.08329368f, 0.20955905f, -0.00686791f, 0.16673182f, 
    0.18986623f, 0.00599793f, -0.01066355f, -0.10262471f, 0.13998881f, 0.00715481f, 0.06317759f, -0.07378901f, 
    -0.18828934f, 0.09847136f, -0.24136434f, 0.06669943f, -0.00411517f, 0.13851002f, -0.00562505f, -0.21210691f, 
    0.00133401f, 0.04269093f, -0.02264642f, -0.01957196f, -0.01485341f, 0.03566739f, 0.00856718f, 0.10556064f, 
    -0.27831861f, -0.04055711f, 0.08460867f, 0.14555004f, -0.06963085f, -0.14377831f, 0.00078837f, 0.06382797f, 
    -0.07778832f, 0.07080706f, -0.02070315f, 0.05251076f, 0.05778370f, 0.12914196f, 0.02392625f, 0.09172117f, 
    0.08334051f, 0.02287291f, 0.09377621f, 0.00572364f, 0.06501665f, 0.01647678f, 0.00480635f, -0.02568320f, 
    0.15116715f, -0.02850024f, 0.01366317f, 0.08892022f, 0.20382662f, -0.00557788f, 0.01697548f, 0.00936328f, 
    0.04190565f, 0.05699847f, 0.05337781f, -0.08304046f, -0.11143750f, 0.20084462f, 0.04411663f, 0.12057221f, 
    0.05522627f, -0.00611570f, 0.00873872f, 0.01019254f, 0.06697594f, 0.00177822f, 0.02766296f, -0.07239180f, 
    0.06585201f, 0.08370113f, 0.15220352f, 0.06259082f, -0.01877584f, 0.08424503f, 0.05207287f, -0.03026400f, 
    -0.04533194f, 0.05572964f, -0.10926007f, -0.02788218f, 0.06806040f, 0.21425568f, 0.11191433f, 0.10085157f, 
    0.01242083f, 0.03211417f, 0.03136640f, -0.07625655f, -0.10209512f, -0.04421703f, 0.06160888f, -0.00706265f, 
    -0.11405627f, -0.34787548f, 0.08453700f, -0.13366883f, -0.01650632f, -0.05177979f, -0.03472295f, -0.03637534f, 
    -0.01125999f, 0.02779853f, -0.06371835f, 0.03607920f, 0.05494816f, 0.13354391f, -0.06701632f, -0.25615674f, 
    -0.05602918f, -0.00144694f, -0.04255559f, -0.16010299f, 0.02617201f, 0.05462877f, 0.00594266f, -0.17533463f, 
    0.11388340f, 0.06390858f, 0.14326049f, 0.07576104f, 0.01278418f, -0.01321839f, 0.04615245f, -0.01015851f, 
    -0.00834910f, -0.05243307f, -0.02855632f, 0.03515045f, 0.25295311f, 0.13662049f, -0.07360557f, -0.01648914f, 
    -0.01148672f, 0.00948516f, 0.04098876f, 0.01654093f, -0.02129111f, 0.00290176f, -0.04283556f, -0.02107164f, 
    0.06089795f, 0.20194206f, -0.11456037f, 0.05407072f, -0.03749637f, -0.03228654f, -0.02466580f, 0.02968703f, 
    -0.00174305f, 0.02106217f, -0.03402904f, -0.03110880f, 0.04006066f, -0.11854436f, -0.02679225f, 0.10198015f, 
    0.08953477f, 0.01115069f, -0.01880236f, -0.01134208f, -0.02373490f, -0.00687842f, -0.00779876f, -0.08002331f, 
    -0.14716507f, 0.07382311f, -0.06049238f, -0.07824340f, -0.12972413f, 0.01485771f, -0.00950560f, -0.05107091f, 
    0.01691858f, 0.00639881f, -0.02107015f, -0.06817072f, -0.10564930f, 0.09178468f, 0.04750813f, 0.04796267f, 
    0.06612170f, 0.04535433f, 0.02789675f, -0.01981816f, -0.01689347f, 0.07824809f, 0.03071017f, -0.03787246f, 
    0.02071100f, 0.08883327f, 0.11291914f, 0.15721259f, -0.03497591f, 0.01102422f, -0.04008236f, -0.01571291f, 
    -0.07712239f, -0.05262948f, -0.02719163f, -0.05496963f, 0.09937786f, -0.09975068f, 0.00916346f, 0.05753371f, 
    -0.09026048f, -0.03120253f, -0.00436340f, -0.06295673f, -0.03870710f, -0.00681601f, -0.06134424f, 0.01133671f, 
    0.00959027f, 0.14966053f, 0.08446557f, 0.10541056f, 0.13397048f, -0.03083507f, 0.01047732f, -0.07600904f, 
    -0.00812492f, -0.01255697f, 0.04893231f, -0.12159563f, -0.21283314f, 0.05072577f, -0.02816759f, 0.04394773f, 
    0.00351468f, 0.02763292f, 0.09494662f, -0.00924149f, -0.02703742f, -0.05115245f, -0.03929205f, -0.06541096f, 
    -0.18527901f, -0.09287375f, -0.16959131f, 0.01157636f, -0.07785717f, -0.05712580f, -0.02796915f, -0.00513445f, 
    -0.04343875f, -0.00936898f, -0.05432609f, -0.02392618f, 0.02775695f, 0.14324152f, 0.10113797f, 0.09149771f, 
    0.02244729f, 0.04431891f, 0.05079552f, -0.04677304f, -0.04900064f, 0.01010164f, -0.01135364f, -0.02862060f, 
    -0.15022191f, -0.03145621f, -0.04965343f, -0.10783792f, -0.06594115f, -0.00276952f, -0.05571697f, -0.05422433f, 
    0.04615862f, -0.07649004f, 0.07654013f, -0.03780195f, -0.00689256f, -0.23423038f, 0.07966278f, -0.09627659f, 
    0.01482197f, 0.00790017f, -0.02146334f, 0.09305063f, -0.00827203f, 0.07484885f, -0.08180067f, -0.06063459f, 
    0.21538463f, 0.06683028f, 0.03754294f, 0.18747966f, 0.01998169f, 0.00036465f, 0.06937489f, -0.02950582f, 
    -0.06764592f, -0.03799709f, 0.01186895f, -0.02083739f, -0.01142070f, -0.03120026f, -0.12719284f, 0.09653217f, 
    -0.07369481f, -0.01780229f, -0.02985897f, -0.04220483f, -0.00736735f, -0.02803088f, -0.03312524f, -0.02160243f, 
    -0.12372267f, 0.05740646f, 0.06830870f, 0.17282304f, 0.10111451f, 0.03654952f, 0.01841851f, -0.02907392f, 
    -0.03147842f, -0.05938630f, -0.02605182f, 0.02818968f, 0.08719125f, -0.24539217f, 0.01340217f, -0.07585616f, 
    -0.01544410f, 0.04218447f, -0.05876468f, -0.07429525f, -0.02611396f, -0.04194629f, -0.06631383f, -0.03837086f, 
    -0.33377478f, -0.00286063f, -0.03189674f, -0.11146598f, -0.03696440f, -0.04721825f, -0.00075003f, -0.03113738f, 
    -0.04452854f, -0.01466556f, 0.02552867f, -0.00319887f, 0.11395099f, 0.08427282f, 0.11699566f, 0.10069348f, 
    0.10961838f, 0.02805669f, 0.04865126f, 0.05923454f, 0.00378176f, 0.01340338f, 0.00367244f, -0.06850911f, 
    -0.07965997f, 0.00821263f, -0.05640066f, -0.13703552f, -0.01253505f, 0.00666905f, -0.03398878f, -0.06006245f, 
    -0.03205679f, 0.03508896f, -0.02880419f, -0.01580695f, 0.15818483f, 0.14094007f, 0.21507987f, 0.04534640f, 
    0.01856414f, 0.02935060f, -0.05191170f, -0.00121452f, -0.00679688f, 0.04262123f, 0.06859565f, -0.04817882f, 
    0.07813578f, 0.07121476f, 0.06476810f, 0.12077396f, 0.12540892f, -0.04165347f, 0.01196075f, -0.05255507f, 
    -0.03359729f, -0.05217496f, -0.01032936f, 0.00266129f, 0.00756815f, 0.09902200f, 0.12547100f, 0.14755391f, 
    0.15249199f, 0.01660163f, -0.02539064f, 0.00048933f, -0.08615492f, 0.04223797f, 0.01085993f, -0.06677639f, 
    0.18389226f, -0.16091885f, -0.01557428f, 0.02035118f, -0.12906262f, -0.08154665f, -0.03358047f, 0.03108166f, 
    -0.03348465f, 0.02391711f, 0.01134026f, -0.03193114f, 0.16158725f, -0.39305928f, 0.09092612f, 0.06981335f, 
    -0.02081679f, 0.00806670f, -0.04095025f, -0.03001277f, -0.02658947f, 0.04671198f, -0.00324072f, 0.02071779f, 
    0.19140308f, -0.10711426f, -0.11688050f, 0.04009188f, -0.09344558f, 0.03658457f, 0.02791553f, -0.08141837f, 
    0.01958194f, -0.01505407f, 0.03034209f, -0.04265521f, 0.00031529f, 0.06969234f, -0.08649562f, -0.01916724f, 
    0.04470661f, 0.14408797f, -0.00957873f, 0.06482406f, -0.08307066f, 0.00426812f, 0.04934854f, -0.05729896f, 
    0.08431336f, 0.01259813f, 0.02098832f, -0.02931820f, -0.08072631f, 0.02187186f, -0.00181696f, 0.02577005f, 
    -0.02224088f, 0.03526248f, -0.05078446f, -0.09597307f, -0.07427431f, 0.01159149f, -0.02670463f, -0.04141900f, 
    -0.02426245f, 0.01094606f, -0.01599010f, -0.04043765f, -0.00276863f, -0.05247596f, -0.00969170f, 0.05948045f, 
    -0.03031197f, -0.07174083f, 0.09947718f, -0.10240684f, -0.00558323f, 0.00402226f, -0.09779075f, -0.01847344f, 
    -0.02122984f, -0.01275640f, -0.06612640f, -0.05597071f, -0.23847082f, 0.00959268f, -0.17526518f, -0.04885451f, 
    0.01903690f, -0.06988140f, -0.02149499f, -0.04983131f, -0.09440079f, -0.05792326f, 0.02670396f, 0.00874443f, 
    -0.15655296f, 0.23051412f, -0.02338632f, -0.19610286f, 0.00345430f, -0.02127290f, -0.08017113f, -0.01691722f, 
    -0.11224930f, -0.01678121f, 0.03998621f, -0.04906404f, -0.17658974f, 0.01808837f, 0.02186729f, -0.13083485f, 
    -0.03904013f, 0.02072125f, -0.07597854f, -0.04659925f, 0.01765383f, -0.00882375f, -0.06426612f, -0.05221718f, 
    0.10512678f, 0.08832370f, 0.16880269f, 0.15873912f, 0.19870315f, 0.06342851f, 0.01265895f, -0.09690950f, 
    -0.04920928f, 0.06787036f, -0.06552570f, -0.09357886f, -0.06606206f, -0.18478811f, -0.08747676f, -0.00320312f, 
    -0.00726451f, -0.01718357f, 0.07321868f, -0.08974723f, -0.05065101f, 0.10363942f, 0.00944836f, -0.06111878f, 
    0.17749932f, -0.04141717f, -0.03379379f, 0.03995623f, 0.02754475f, -0.12005452f, 0.01737212f, -0.11987512f, 
    -0.05962162f, -0.05563090f, -0.02487511f, -0.05398422f, 0.02067788f, 0.01294819f, -0.05926540f, 0.26158187f, 
    -0.04718415f, -0.12198405f, -0.00821040f, 0.05655123f, -0.00468027f, 0.06691530f, -0.04144710f, -0.00493849f, 
    -0.24563520f, -0.03779004f, -0.16394533f, -0.13685027f, -0.05690772f, -0.11549561f, 0.06348703f, -0.08085681f, 
    -0.13194983f, -0.02375014f, -0.02736995f, -0.00006372f, 0.34298661f, -0.35786349f, 0.29072312f, 0.27495205f, 
    0.02679066f, -0.04091451f, -0.04357620f, 0.01322571f, -0.00570216f, -0.01327614f, -0.08016314f, 0.01103081f, 
    -0.26342002f, 0.16308671f, 0.12946095f, -0.16494012f, 0.07978621f, -0.03965871f, 0.00793492f, -0.03563064f, 
    -0.04064659f, -0.01729348f, -0.00735513f, -0.02249212f, -0.05534336f, -0.16601197f, -0.06505601f, -0.17768674f, 
    0.02231332f, -0.02095751f, -0.08211385f, -0.06582251f, -0.08099979f, 0.03479690f, -0.01236394f, 0.00576568f, 
    -0.26225880f, 0.02917072f, -0.13801982f, -0.15706611f, -0.05629550f, 0.05446325f, -0.02716383f, -0.04147619f, 
    -0.06492084f, -0.02462263f, -0.02451892f, -0.03019192f, 0.03494644f, -0.28451779f, 0.01220625f, 0.02226203f, 
    -0.03667215f, -0.06706454f, -0.03993827f, -0.02202941f, -0.12001621f, 0.03094454f, 0.02121493f, -0.10276147f, 
    0.18939644f, -0.09252249f, -0.03538310f, -0.02790615f, -0.03935378f, -0.04254939f, -0.04442420f, -0.02902236f, 
    -0.03222863f, 0.01693464f, -0.10916626f, 0.06328623f, -0.22351789f, -0.04800570f, -0.16626167f, -0.01742720f, 
    -0.09802750f, -0.02809095f, -0.05131126f, -0.10253222f, -0.03512833f, -0.02499509f, -0.07366387f, -0.06540634f, 
    -0.13673069f, 0.04114459f, -0.02160209f, 0.12771899f, 0.09483489f, -0.08333237f, -0.05902636f, 0.12057182f, 
    0.03835584f, -0.03320446f, -0.01578827f, 0.00349296f, -0.06470857f, 0.03261838f, -0.05325541f, -0.15917692f, 
    0.02255858f, 0.03049194f, -0.06079554f, -0.03743200f, -0.03227616f, -0.06868145f, -0.01070702f, -0.13089177f, 
    -0.06343545f, -0.01270574f, 0.01263847f, 0.00994984f, 0.05578874f, -0.14623952f, -0.03418670f, 0.00486782f, 
    -0.00234045f, 0.05787671f, -0.04624980f, 0.01307935f, -0.11815482f, -0.08273686f, -0.16195832f, -0.06249545f, 
    0.06500564f, -0.00428299f, 0.01132863f, 0.01265379f, -0.02202882f, 0.01031767f, -0.01689956f, -0.08083331f, 
    0.05900657f, 0.06166776f, -0.01748659f, 0.18332282f, -0.01413470f, -0.09108728f, -0.12315720f, -0.00357606f, 
    0.01008341f, -0.07634085f, -0.13764904f, -0.09230153f, 0.08680773f, 0.07358388f, -0.12471163f, -0.05029835f, 
    0.04672333f, 0.00063194f, -0.03064527f, -0.04954487f, -0.05611936f, 0.07652021f, 0.03793274f, -0.06191545f, 
    -0.22609901f, -0.02816024f, 0.03153511f, -0.00313606f, 0.12113310f, -0.03696693f, -0.03920377f, -0.02715865f, 
    -0.00936386f, 0.07078043f, 0.03837261f, 0.05805607f, -0.13292886f, 0.23208340f, 0.06207450f, 0.06860946f, 
    0.13058621f, 0.02810167f, 0.07470459f, 0.03650385f, 0.02602729f, 0.03800149f, 0.05636058f, -0.02322711f, 
    0.11680489f, -0.28628033f, 0.12986100f, -0.04874694f, -0.02901890f, -0.01388377f, -0.00563247f, -0.03923412f, 
    -0.06789120f, 0.04942702f, -0.01470156f, -0.09182618f, -0.18536533f, 0.01118768f, -0.06929756f, 0.04759940f, 
    -0.04267391f, 0.00810136f, -0.10211910f, 0.00521443f, -0.09609699f, 0.01403522f, 0.09294236f, -0.06116540f, 
    -0.02905802f, 0.05473581f, -0.20656306f, 0.01269221f, 0.08341361f, -0.03337535f, -0.06833114f, -0.01595357f, 
    0.01784521f, -0.04148022f, 0.05963745f, 0.06049807f, 0.04429249f, -0.01093287f, 0.12876472f, 0.13008699f, 
    -0.03615449f, -0.06410857f, 0.03349215f, -0.08745752f, -0.02602988f, -0.09826121f, 0.05475160f, 0.04651649f, 
    -0.02379932f, -0.14390370f, 0.10914528f, -0.05634593f, -0.04324102f, -0.22503744f, -0.02230026f, -0.12617293f, 
    -0.02830081f, -0.05414546f, -0.06670223f, 0.06470358f, -0.04341695f, 0.03148905f, 0.06272323f, 0.07920472f, 
    0.03578406f, 0.13510929f, -0.09208792f, -0.06962322f, -0.08226556f, -0.09328764f, 0.06700494f, 0.04699632f, 
    -0.08717879f, 0.11941509f, 0.05984649f, 0.01235245f, -0.13989809f, -0.00376446f, -0.01599428f, 0.03455479f, 
    0.07279698f, -0.02472118f, 0.03613422f, 0.05848107f, -0.08390665f, -0.03942164f, 0.00591605f, -0.15818898f, 
    -0.00426183f, -0.16371609f, -0.13027698f, 0.11911786f, 0.09194189f, -0.04730546f, -0.10952801f, -0.15566413f, 
    0.08940651f, -0.19175911f, -0.07465735f, 0.01394173f, -0.00753473f, 0.03820079f, -0.09378888f, -0.00008652f, 
    0.00627218f, 0.06465383f, 0.05464413f, 0.00790058f, 0.10855682f, -0.01184405f, -0.09826681f, 0.02645912f, 
    -0.01496067f, -0.02764076f, -0.01027451f, -0.03554451f, -0.18796909f, 0.02044726f, 0.05858600f, 0.06053692f, 
    -0.01762375f, -0.00816901f, -0.03891119f, -0.18487337f, 0.02220645f, -0.04477312f, 0.08310944f, 0.01710486f, 
    0.01924659f, 0.01657942f, -0.04799446f, 0.02988450f, -0.12925825f, 0.11576688f, -0.03186577f, 0.01197060f, 
    -0.09660318f, 0.05378363f, 0.03996302f, -0.04217399f, -0.05016601f, -0.01085513f, 0.05492019f, -0.06425220f, 
    -0.00909417f, 0.27121514f, -0.05148806f, 0.01923770f, -0.18535802f, -0.04335270f, -0.11417504f, 0.02328191f, 
    0.03165525f, -0.11172721f, -0.03205982f, 0.00702832f, 0.31569895f, 0.20120022f, -0.18297581f, -0.26322147f, 
    0.03708695f, -0.01005555f, 0.04816406f, 0.00404470f, 0.02200976f, -0.08966602f, -0.02816572f, 0.15632029f, 
    -0.00403006f, 0.03185151f, -0.07340512f, 0.01733692f, -0.00631797f, -0.07933507f, -0.04576112f, -0.09960572f, 
    0.02108264f, 0.09197213f, -0.13285315f, -0.04149994f, -0.02021726f, -0.01183763f, 0.13806441f, 0.04954619f, 
    -0.11092865f, -0.02084482f, -0.01849709f, -0.09574580f, 0.01416803f, -0.06029183f, 0.00627696f, -0.01887976f, 
    -0.07920568f, 0.17029837f, -0.07517274f, -0.24806045f, 0.08547164f, -0.04366897f, 0.03591323f, 0.03957252f, 
    0.06861861f, 0.04512702f, -0.01492872f, 0.07748439f, -0.14457026f, -0.06719605f, -0.22030562f, -0.24772152f, 
    -0.07266684f, -0.00659947f, 0.02573157f, -0.01747622f, -0.01200521f, 0.00031089f, 0.02230166f, 0.00111740f, 
    -0.07001875f, -0.06762052f, 0.17069446f, -0.05223026f, -0.03258036f, -0.05026292f, -0.12678021f, -0.01978862f, 
    -0.01383324f, 0.01000804f, -0.12989666f, 0.00950303f, 0.04977226f, 0.01658474f, -0.14128485f, -0.10137653f, 
    -0.00653031f, -0.08263044f, -0.07750255f, -0.02754765f, 0.09887626f, 0.10969552f, 0.01901483f, 0.02172092f, 
    0.21527846f, 0.10413020f, -0.20852108f, 0.01906903f, 0.04302474f, 0.04605254f, 0.04005028f, -0.06182113f, 
    -0.03985463f, -0.06039013f, -0.02460559f, 0.07585125f, -0.24855879f, 0.07823244f, 0.14368002f, 0.02578188f, 
    -0.06435935f, 0.06718729f, -0.08885333f, 0.04069640f, -0.03601107f, -0.02244089f, 0.04559620f, -0.13541940f, 
    0.22662514f, -0.05172227f, 0.04797143f, 0.08929645f, 0.06402759f, -0.09093480f, -0.05608713f, -0.01625893f, 
    0.07059879f, -0.06321498f, -0.07334404f, -0.00109561f, 0.01990770f, -0.05285383f, 0.18345791f, 0.14024290f, 
    -0.13648193f, -0.08467796f, 0.01247018f, 0.04616375f, 0.01109882f, 0.05434752f, -0.16844510f, -0.08290724f, 
    0.14597997f, 0.02163960f, -0.17808995f, -0.17508394f, -0.04571985f, -0.10379142f, 0.10765862f, 0.00306805f, 
    0.01223707f, 0.00844983f, -0.04849230f, 0.03750594f, 0.03121679f, -0.06109411f, -0.21297531f, -0.09225811f, 
    -0.06473900f, -0.01981249f, 0.04604623f, 0.03544811f, 0.08038489f, 0.03764326f, -0.00256988f, 0.02736590f, 
    -0.09871193f, 0.06268662f, 0.05814726f, 0.11289825f, -0.06972130f, 0.04189117f, 0.06994483f, -0.13968858f, 
    -0.03401853f, 0.00177268f, -0.02233573f, 0.05307303f, -0.04434322f, -0.11793144f, 0.04086028f, 0.06418482f, 
    -0.00796312f, -0.10892934f, -0.03648667f, -0.08967782f, -0.00883897f, 0.06592456f, 0.03757208f, 0.02285594f, 
    0.03131712f, -0.06292630f, 0.06436457f, 0.09464900f, 0.13714194f, 0.06534445f, -0.07642296f, -0.04373551f, 
    0.05798859f, 0.09795237f, -0.01562222f, 0.01578338f, -0.01211793f, -0.07106790f, -0.15777931f, -0.09069183f, 
    -0.15023670f, -0.03248436f, 0.01691465f, -0.10576932f, -0.00975287f, 0.01078937f, -0.13252400f, 0.02084018f, 
    0.09563518f, 0.14821590f, 0.00533314f, 0.07918736f, 0.04558820f, 0.05755563f, -0.14760491f, -0.00299059f, 
    0.04569030f, 0.04950054f, -0.06552508f, -0.06467105f, -0.13219120f, 0.12717360f, 0.12614658f, 0.01769993f, 
    0.00932190f, 0.05729915f, -0.02857070f, 0.13679136f, 0.03661766f, 0.00690078f, -0.10236983f, -0.25426474f, 
    -0.07682148f, -0.08829384f, 0.09652171f, -0.02487952f, 0.03348260f, 0.04190439f, -0.08864364f, -0.08474483f, 
    0.05433906f, 0.04955759f, -0.03548764f, 0.11172093f, -0.18741487f, -0.01865747f, 0.20922790f, -0.22017403f, 
    -0.02103272f, -0.08844202f, 0.09341667f, -0.11251333f, -0.07948922f, -0.05717828f, 0.08190718f, 0.11752553f, 
    0.07482588f, -0.19361505f, -0.07843740f, -0.11108848f, 0.03828306f, -0.07376549f, 0.01024536f, -0.11158729f, 
    -0.17041427f, 0.00990564f, 0.04823940f, 0.04332552f, -0.00767359f, -0.09811288f, -0.14197493f, 0.11356869f, 
    0.05928171f, 0.04960790f, 0.00042514f, -0.07908904f, 0.11817586f, 0.01728882f, 0.06698204f, -0.01503780f, 
    -0.08056653f, -0.09618974f, 0.02118284f, 0.20028347f, 0.03659823f, -0.00451634f, -0.08986657f, 0.03439483f, 
    0.00885579f, 0.04591615f, 0.10022306f, 0.08592215f, -0.13749552f, 0.08476982f, -0.19636403f, -0.08805560f, 
    0.02104649f, 0.00385935f, -0.14910419f, -0.02223702f, 0.09872574f, 0.05956682f, -0.02649545f, -0.03160614f, 
    0.03972032f, 0.04038496f, 0.05412583f, 0.00858931f, -0.11553843f, -0.06995738f, 0.08592795f, 0.09171256f, 
    0.06453948f, -0.01752131f, -0.00590261f, 0.03084222f, -0.04433104f, -0.10119589f, 0.05614891f, 0.20879443f, 
    0.04643312f, 0.01418279f, -0.02428383f, -0.03026614f, -0.01730486f, 0.12024782f, 0.06349136f, 0.01020366f, 
    -0.18532179f, 0.12177298f, -0.02775108f, -0.02867215f, -0.13784865f, -0.14422348f, -0.09078798f, 0.01789629f, 
    0.01166654f, 0.09003153f, 0.02473231f, 0.07019150f, -0.22130668f, -0.04513684f, -0.01719542f, 0.14608018f, 
    0.04621009f, 0.03915262f, -0.04159414f, 0.01412950f, -0.01649501f, -0.02261856f, 0.11002213f, 0.04820256f, 
    -0.03499693f, -0.17455931f, -0.12675846f, -0.01272079f, 0.07890669f, 0.00873929f, 0.01649431f, 0.01051057f, 
    0.10497782f, 0.01501017f, 0.06093115f, 0.04498623f, 0.18818311f, 0.05879795f, 0.07271306f, 0.06161348f, 
    0.07329216f, -0.06108671f, -0.02648958f, -0.05784464f, 0.07020900f, -0.10416388f, -0.00759652f, -0.13042338f, 
    -0.25175250f, -0.00855531f, 0.06391936f, -0.18573643f, 0.02733225f, -0.04435696f, -0.01905130f, -0.05462213f, 
    0.01808282f, -0.16388790f, 0.03209136f, 0.02592368f, 0.02732208f, 0.27979183f, -0.22914015f, 0.10520679f, 
    -0.01529513f, 0.02141585f, -0.08253743f, 0.00217726f, 0.09448976f, -0.02801123f, 0.06278383f, 0.03388237f, 
    0.10248364f, -0.14226347f, -0.08719627f, -0.17582279f, -0.01811363f, -0.08272417f, 0.02488455f, 0.06944515f, 
    0.03930796f, -0.01819902f, 0.14857264f, -0.06809241f, 0.11343081f, 0.14217506f, -0.15802728f, -0.20739396f, 
    -0.16931312f, -0.11889651f, -0.06175502f, 0.02994496f, 0.09412599f, -0.09753380f, 0.04453560f, -0.09173574f, 
    0.03764230f, 0.00469996f, -0.04427400f, 0.13751066f, 0.13903160f, 0.04609483f, -0.01307760f, -0.05441169f, 
    0.11900701f, 0.04951457f, 0.01773482f, -0.14753388f, 0.05424080f, 0.14334349f, -0.07994519f, 0.03773053f, 
    0.00499083f, -0.09372710f, -0.07327466f, -0.04690555f, -0.07960157f, 0.03548211f, -0.05773956f, -0.04250520f, 
    -0.03092904f, -0.18223564f, 0.15249038f, 0.06619834f, -0.02651878f, -0.04416889f, -0.04562650f, -0.07535217f, 
    0.05283237f, 0.00593665f, -0.01136896f, 0.06306988f, 0.04461145f, -0.06834183f, 0.06299591f, 0.04077730f, 
    0.09848038f, -0.00770393f, 0.01919192f, -0.03360821f, 0.02404336f, 0.06833781f, -0.13487971f, -0.01031480f, 
    0.16422035f, -0.12886505f, -0.01559226f, 0.16896766f, 0.12029587f, -0.02527403f, -0.12099975f, 0.00912771f, 
    0.12135575f, -0.14740339f, 0.13292487f, -0.15944046f, 0.12020395f, -0.01163282f, -0.04177138f, -0.02797687f, 
    0.13612680f, 0.02503569f, -0.13463397f, -0.05664346f, -0.05820205f, -0.06876692f, -0.09537292f, -0.17751662f, 
    0.00783293f, -0.13548982f, 0.07084482f, 0.01624196f, 0.07373422f, 0.03844472f, 0.05797581f, -0.03954432f, 
    -0.02288791f, 0.03612457f, 0.03717638f, 0.04065032f, 0.05309836f, 0.14560109f, 0.05644560f, 0.09673974f, 
    -0.13986033f, -0.03043890f, -0.04013511f, -0.12399194f, 0.04188228f, 0.00509650f, 0.00874970f, 0.03327227f, 
    -0.15586090f, 0.01956515f, -0.11406694f, -0.11963910f, -0.07512430f, -0.00329819f, -0.18022621f, 0.01741098f, 
    0.08924034f, 0.00955216f, 0.14889054f, -0.02547323f, 0.20412813f, -0.07342925f, 0.00383933f, 0.12155846f, 
    0.11825567f, -0.00503843f, 0.04445576f, -0.01055941f, 0.00989878f, 0.08402084f, 0.02934905f, -0.17806619f, 
    -0.04552741f, -0.05691442f, -0.15256250f, -0.15444008f, -0.00799508f, -0.03416887f, -0.12263187f, -0.02714284f, 
    -0.00154937f, -0.08343597f, 0.09421612f, 0.02920489f, 0.13684867f, 0.09620909f, -0.19732678f, -0.05366861f, 
    0.02976133f, 0.03188427f, -0.05496612f, 0.06793787f, 0.02860858f, 0.05457428f, -0.01472783f, 0.10518733f, 
    -0.06836976f, -0.00373944f, -0.13257311f, -0.16643061f, 0.00256916f, 0.00169309f, -0.14167115f, -0.03619360f, 
    0.02269868f, 0.09169417f, 0.02907350f, -0.02893041f, 0.09769866f, 0.02645149f, -0.06217170f, -0.02992584f, 
    0.06911653f, -0.05403167f, -0.10968833f, 0.01217803f, -0.00509602f, 0.11840360f, -0.06493101f, -0.04876165f, 
    0.05324461f, 0.04539164f, -0.11451942f, 0.06139121f, 0.03762389f, -0.02531501f, -0.06666224f, 0.03818947f, 
    0.13833067f, -0.08867761f, 0.01649337f, 0.09519532f, -0.08932287f, -0.03301546f, 0.02735787f, 0.07894375f, 
    -0.06575011f, -0.11164561f, -0.01176731f, 0.03476392f, 0.03130946f, 0.01266772f, -0.01171000f, -0.05690709f, 
    -0.19168976f, -0.17748569f, 0.03620727f, -0.15069740f, -0.11609271f, 0.00190597f, 0.09173480f, 0.03956382f, 
    0.07685666f, 0.05763906f, -0.03500658f, 0.12779488f, -0.13669555f, -0.14331721f, -0.19816087f, -0.14745213f, 
    0.11440912f, 0.06328756f, 0.03087044f, -0.04349295f, 0.10329439f, -0.00142981f, -0.05123298f, 0.00713806f, 
    -0.31489393f, 0.01546723f, 0.20044543f, -0.21531314f, -0.00685978f, 0.03204200f, 0.07789391f, -0.06213474f, 
    0.07584106f, 0.03348613f, 0.06443579f, -0.09136445f, 0.02698731f, -0.10984385f, 0.00306014f, -0.00409712f, 
    0.08498907f, 0.00010653f, -0.00256586f, 0.05744163f, 0.09512562f, 0.04831644f, 0.05344680f, -0.05669872f, 
    0.03057248f, 0.05085483f, 0.05440592f, 0.10848633f, -0.02227307f, 0.10181971f, -0.00913513f, -0.01685441f, 
    0.10045294f, -0.04787735f, -0.09055839f, 0.11736778f, -0.16612943f, -0.12409534f, 0.14287910f, -0.00206529f, 
    0.07592388f, -0.13312064f, 0.05440930f, 0.01289938f, 0.05690204f, 0.14902955f, 0.04385966f, 0.05231132f, 
    -0.03447194f, -0.10448744f, -0.03958239f, 0.05080454f, 0.02434122f, 0.03224725f, -0.06538518f, 0.04121916f, 
    -0.05348622f, -0.01211553f, -0.08134651f, -0.04496624f, -0.29897243f, -0.07106450f, -0.08559252f, -0.02369709f, 
    -0.07800359f, -0.07092684f, -0.04248815f, -0.04976604f, -0.08727892f, -0.06494942f, 0.04819122f, -0.01517316f, 
    0.08190230f, -0.11055748f, 0.11668231f, 0.10569583f, -0.13329716f, 0.05673687f, 0.02563777f, 0.08487462f, 
    -0.00790744f, -0.05319817f, 0.09636064f, -0.07613658f, -0.33272859f, 0.01452109f, -0.07869550f, 0.06313745f, 
    -0.00927292f, -0.05324246f, 0.06074677f, -0.06047997f, 0.01200474f, 0.11300927f, 0.00203829f, 0.06960079f, 
    -0.31393972f, -0.11472077f, -0.07365349f, 0.27020773f, -0.02412827f, 0.05505615f, 0.11394718f, -0.07345445f, 
    0.03950296f, -0.04436142f, 0.02784519f, -0.00992611f, 0.17042471f, 0.18051170f, 0.06262535f, 0.08204755f, 
    -0.02289268f, -0.08649912f, 0.01962564f, 0.15990424f, 0.06900896f, 0.01519805f, 0.01011626f, 0.10774853f, 
    -0.41363341f, 0.27613536f, 0.29094359f, 0.04327130f, 0.09899808f, -0.02497457f, 0.01284703f, 0.09583420f, 
    0.02853837f, -0.04367436f, 0.00894818f, 0.02099821f, 0.28420737f, -0.03978326f, 0.28080031f, -0.13655186f, 
    0.06536046f, -0.02532817f, -0.05112496f, 0.00575120f, -0.03334669f, -0.03617942f, 0.07491986f, -0.00841514f, 
    -0.29603004f, 0.19057216f, 0.10404889f, -0.08831100f, 0.01956533f, 0.03913327f, 0.06449746f, 0.10810634f, 
    0.16084884f, -0.05681171f, 0.13682365f, 0.01104420f, -0.07444408f, -0.15648867f, 0.11486468f, -0.07629059f, 
    0.06053111f, 0.05115332f, -0.04663344f, 0.02794353f, 0.08161890f, 0.07053714f, 0.02940493f, -0.05254453f, 
    -0.01991536f, -0.12096544f, 0.23579785f, 0.05801388f, -0.18282762f, 0.12971593f, -0.00860570f, -0.06318368f, 
    -0.06659442f, -0.00530131f, 0.04839476f, -0.03048985f, -0.16673370f, 0.01490580f, -0.16907234f, -0.10724257f, 
    -0.04287851f, -0.00265908f, 0.09500859f, 0.00110005f, 0.04558677f, 0.08495613f, 0.02066017f, 0.00756496f, 
    -0.19960998f, -0.34648207f, 0.00038891f, -0.03050065f, 0.04260913f, 0.01976182f, 0.03372709f, -0.08101690f, 
    -0.02967888f, 0.00298137f, 0.00209207f, -0.05715355f, 0.13555621f, 0.13215971f, -0.05183312f, -0.05826372f, 
    0.00761272f, -0.10338263f, 0.07530885f, 0.05858323f, 0.00272364f, -0.07678234f, -0.11159564f, 0.09197833f, 
    0.26062658f, 0.04255453f, 0.21501210f, 0.10370714f, -0.00315118f, 0.03121754f, -0.10611196f, 0.06060419f, 
    -0.05201273f, -0.00187802f, 0.03917620f, -0.00705516f, -0.03293822f, -0.08764683f, 0.06594858f, -0.04394656f, 
    0.03174702f, -0.03543716f, 0.09653910f, 0.02729713f, -0.07663473f, -0.02232486f, -0.04987343f, -0.04721403f, 
    -0.04232368f, -0.04309017f, 0.05095561f, 0.02868906f, 0.04978414f, -0.08035590f, -0.04467878f, -0.18527816f, 
    0.01535526f, -0.10361033f, -0.04583749f, 0.01811768f, 0.17084336f, 0.00659311f, -0.15639088f, 0.06684854f, 
    0.05429816f, 0.00994379f, -0.04158514f, 0.00321741f, 0.04427092f, -0.02401512f, -0.05326542f, 0.09131075f, 
    -0.19992337f, -0.04234231f, 0.06704166f, -0.20540862f, 0.16203980f, -0.09184863f, -0.02944393f, 0.02198121f, 
    0.02792849f, -0.05002448f, 0.14048681f, 0.05213695f, -0.12097807f, 0.06457904f, -0.09389500f, 0.15309933f, 
    0.06900369f, 0.06453488f, 0.01877961f, 0.10048528f, -0.09382466f, -0.02863145f, 0.08804838f, 0.01632911f, 
    0.04975819f, -0.32002386f, -0.08596118f, 0.04598467f, -0.06327500f, -0.04938368f, -0.05990882f, 0.06138324f, 
    -0.08827239f, -0.03811014f, 0.00403638f, 0.05794653f, 0.15488169f, -0.04287955f, 0.06502084f, -0.08659846f, 
    0.00870285f, -0.07146329f, -0.01599528f, -0.02186646f, 0.07977149f, -0.03676546f, 0.00553030f, 0.06007604f, 
    -0.07438469f, 0.11358321f, -0.15084977f, -0.23534064f, 0.14252724f, -0.00134253f, -0.10097668f, 0.05861886f, 
    0.00603899f, -0.09456917f, -0.03529808f, -0.19442409f, -0.03186464f, -0.02585076f, -0.04968853f, 0.21010961f, 
    -0.00468053f, 0.08291338f, 0.01733850f, 0.03059002f, -0.05848798f, -0.08871045f, 0.07250518f, 0.00381941f, 
    -0.04157791f, -0.11649875f, 0.03160972f, -0.13584362f, 0.07214617f, 0.04190636f, 0.00239373f, 0.00786211f, 
    0.02981455f, -0.03698543f, -0.05722520f, 0.04799367f, -0.12891825f, -0.00400412f, -0.00865376f, 0.04435042f, 
    -0.06858557f, 0.01720333f, -0.09415992f, -0.04766717f, -0.11271475f, 0.11672743f, -0.10342292f, 0.02920876f, 
    -0.09567859f, -0.28364706f, -0.10882988f, 0.17423666f, -0.02545990f, 0.00494665f, 0.10556747f, 0.10947289f, 
    0.02785109f, -0.08169387f, 0.01766920f, -0.14032662f, 0.70975631f, 0.03062551f, -0.10818201f, 0.11910950f, 
    0.09362243f, -0.07475364f, -0.08670107f, 0.16837804f, -0.05786667f, 0.05685556f, 0.13696754f, 0.00575899f, 
    -0.00166412f, 0.15059762f, -0.07708596f, -0.18037102f, 0.10084000f, -0.00537093f, -0.02113122f, 0.03340233f, 
    0.09079177f, 0.10157617f, -0.07601773f, -0.04582834f, 0.27347204f, -0.26044360f, -0.06793708f, -0.23368880f, 
    -0.03803699f, 0.04161534f, -0.12474232f, 0.08155326f, -0.08526559f, 0.10086143f, 0.03668910f, 0.04881766f, 
    -0.17946959f, 0.07349786f, -0.14305189f, -0.08690741f, -0.07294719f, -0.15130608f, 0.15483361f, -0.06901819f, 
    0.00037951f, 0.11178593f, 0.01799727f, -0.13883770f, -0.08239085f, 0.11789685f, 0.23858044f, 0.13829437f, 
    -0.04693580f, 0.02520742f, 0.03051428f, 0.01549570f, 0.13278863f, -0.08212470f, 0.07267203f, 0.05650157f, 
    -0.08149805f, 0.07347593f, -0.02890606f, -0.04549698f, 0.10787397f, 0.08085727f, -0.05265403f, 0.06984060f, 
    -0.06777086f, -0.03059956f, -0.08150201f, -0.00516686f, -0.08051504f, 0.11588408f, -0.26258019f, -0.08901569f, 
    0.05755174f, -0.00019248f, -0.04117347f, 0.11145890f, -0.15640996f, -0.04922756f, -0.15117669f, -0.09438644f, 
    -0.07569417f, -0.06519700f, 0.04008941f, 0.00195904f, 0.02040486f, 0.11625242f, -0.07119323f, -0.12449133f, 
    -0.02626232f, -0.11895308f, -0.02943533f, -0.04841051f, -0.16523357f, 0.18296970f, -0.07765733f, -0.22926232f, 
    0.08072863f, -0.02097702f, 0.01620648f, -0.01383829f, -0.07671756f, -0.04830289f, 0.00334076f, -0.04497065f, 
    -0.39870095f, 0.02705686f, 0.04732846f, 0.03351504f, 0.04994342f, -0.04691646f, 0.06944419f, -0.20079960f, 
    -0.09166727f, -0.10452350f, 0.08454107f, 0.06839552f, -0.05637740f, 0.17078039f, -0.12697032f, -0.13341540f, 
    0.06965528f, -0.03267346f, -0.09335356f, -0.07727031f, 0.04791680f, 0.09343850f, 0.00356774f, -0.02089070f, 
    0.05183243f, -0.26501939f, -0.12293039f, 0.08130623f, 0.05114144f, 0.00670115f, -0.09624033f, 0.02104595f, 
    -0.11057334f, 0.00582133f, -0.11055943f, 0.05935051f, 0.02112819f, 0.20640096f, -0.05413954f, 0.16607390f, 
    0.05753031f, 0.06623463f, 0.02991596f, -0.02774122f, -0.01868129f, 0.10576570f, -0.04412110f, -0.04707198f, 
    0.11493623f, 0.06050768f, 0.20591575f, -0.11616760f, 0.01829951f, 0.01554030f, 0.03526505f, -0.07128759f, 
    0.07915413f, 0.10012478f, -0.07727911f, -0.00362489f, 0.10336051f, 0.15534140f, -0.06251499f, -0.15205643f, 
    -0.03614892f, 0.06693136f, -0.17148462f, 0.15482871f, -0.00129331f, 0.01680528f, 0.01140443f, 0.03896400f, 
    -0.16081281f, 0.07544986f, -0.32913965f, -0.26322377f, 0.06021954f, 0.12410971f, 0.03708267f, 0.03742554f, 
    -0.12831844f, -0.02805705f, 0.03855043f, -0.12582164f, 0.41453707f, -0.62971735f, 0.15740685f, 0.03197088f, 
    0.00484278f, 0.04450107f, 0.06565459f, -0.00711120f, 0.02708171f, -0.09173673f, 0.06168639f, -0.01985352f, 
    -0.05896749f, 0.17334823f, -0.27945411f, 0.32855928f, -0.03045117f, -0.08906136f, -0.02878077f, 0.07973541f, 
    -0.03501726f, 0.03057111f, 0.01692951f, -0.03466066f, 0.06880898f, -0.19596690f, -0.01136857f, -0.18690000f, 
    0.09403673f, 0.08937018f, -0.12262555f, -0.07717581f, -0.09678186f, -0.16449864f, 0.01032790f, 0.02100662f, 
    -0.27928555f, 0.00240919f, 0.22508842f, -0.10813674f, -0.01185208f, 0.00746221f, -0.02713251f, 0.04345150f, 
    0.03920618f, 0.09014953f, -0.19188559f, 0.08056540f, 0.00586003f, -0.26931736f, -0.14120056f, -0.11365664f, 
    0.01971934f, 0.12676957f, -0.06756744f, 0.02324836f, -0.03606772f, 0.10117339f, 0.08224107f, 0.09337173f, 
    -0.02736599f, -0.09617937f, 0.07988393f, -0.00581993f, 0.10602058f, -0.03465636f, 0.13061798f, -0.06957388f, 
    0.05592450f, -0.00874685f, -0.00908994f, 0.05646334f, 0.30982304f, 0.26303259f, -0.41370833f, 0.10934930f, 
    -0.00512304f, -0.04545655f, 0.11493907f, 0.01422208f, -0.01322015f, 0.04650540f, 0.07471692f, -0.02042380f, 
    0.19963036f, -0.20406583f, -0.05933791f, -0.32660452f, -0.14639267f, 0.00894473f, 0.02254232f, 0.07644570f, 
    -0.11330513f, -0.08187702f, -0.08406476f, -0.00654748f, -0.22941941f, 0.11958425f, -0.07665282f, -0.10221815f, 
    0.10115486f, 0.05386323f, 0.08005678f, -0.04246782f, 0.07081664f, 0.02855461f, -0.03657290f, -0.04108562f, 
    -0.14825705f, -0.14336917f, 0.09731652f, 0.01419356f, -0.05436411f, -0.01565167f, 0.10029993f, -0.09981134f, 
    -0.15516548f, 0.07056646f, -0.10926388f, -0.02655221f, 0.12315448f, -0.14492595f, 0.24488974f, -0.05877329f, 
    0.00672813f, -0.03640741f, -0.03169227f, -0.14312321f, -0.03981357f, -0.03399853f, 0.00181725f, -0.14709726f, 
    0.35038877f, -0.32715991f, -0.25262508f, -0.17816469f, -0.06297333f, 0.04254024f, 0.02372549f, 0.09594090f, 
    0.00183097f, -0.02933411f, -0.08347761f, -0.00085910f, -0.05777273f, 0.28358990f, 0.00212560f, -0.08224141f, 
    -0.05952392f, 0.13714954f, -0.09407128f, -0.07780373f, 0.03962025f, 0.05435510f, 0.07091974f, -0.00919068f, 
    0.20369717f, -0.05612958f, 0.07897475f, -0.15875126f, 0.04765383f, 0.11032415f, -0.05523659f, -0.00520750f, 
    -0.05052395f, -0.17535630f, 0.03958160f, -0.02464034f, -0.20556687f, -0.42090878f, 0.08504216f, -0.09341635f, 
    0.06132212f, 0.02334646f, 0.05851839f, 0.04681711f, 0.06777984f, -0.01879322f, 0.00883482f, 0.07179473f, 
    0.04573555f, -0.00674305f, 0.03272000f, 0.14343028f, -0.21395540f, 0.06395901f, 0.08569063f, -0.06250551f, 
    0.08252832f, -0.03972235f, 0.03854584f, -0.26491261f, -0.16878632f, -0.07078556f, 0.02769723f, -0.21450439f, 
    0.02996267f, -0.00622790f, -0.01216739f, 0.00268499f, -0.00982182f, 0.04301634f, 0.03996567f, -0.04067761f, 
    -0.07983875f, -0.04511040f, -0.01702361f, 0.03845577f, 0.07823300f, 0.01483770f, 0.04153042f, -0.04919751f, 
    0.07702386f, -0.04288825f, -0.02658400f, -0.00580127f, 0.12666655f, 0.12505075f, -0.05033123f, -0.08068976f, 
    -0.20205869f, -0.01793415f, 0.00021433f, -0.00163130f, -0.03973522f, -0.08417875f, -0.01496156f, -0.00531113f, 
    -0.23421663f, 0.01324749f, -0.03448588f, 0.11091271f, -0.07155284f, -0.14423196f, -0.10515100f, -0.16088103f, 
    -0.04164336f, -0.16604242f, -0.09711795f, -0.06551438f, 0.13262476f, -0.02195683f, -0.05507319f, 0.00571850f, 
    -0.06441846f, 0.00412776f, 0.03974714f, 0.06807695f, 0.02969623f, -0.08891743f, -0.05311397f, -0.00852620f, 
    0.12415382f, 0.07387869f, -0.07478201f, -0.00828457f, -0.08823185f, 0.05267838f, 0.02081040f, 0.04057971f, 
    0.04951867f, -0.01175316f, 0.12828884f, -0.07835237f, -0.15355837f, 0.08760522f, 0.02163889f, -0.12866968f, 
    0.16978435f, -0.09551589f, 0.02496191f, 0.01203061f, -0.02554695f, -0.12712590f, -0.05705095f, -0.06861951f, 
    -0.46474299f, -0.33236963f, 0.12738559f, -0.06908756f, 0.06571946f, 0.00598085f, -0.07141766f, -0.04624056f, 
    0.04366274f, -0.08613465f, 0.03175373f, 0.07507022f, -0.02620089f, -0.16020919f, -0.04958659f, 0.11301255f, 
    -0.06390157f, 0.07119393f, 0.03883289f, 0.06809002f, 0.11999038f, 0.14755453f, -0.03935998f, 0.14765331f, 
    0.16491897f, -0.00273595f, -0.05335199f, 0.07122441f, 0.10834432f, -0.00360086f, 0.12277400f, -0.02834364f, 
    0.01124138f, 0.09817073f, 0.02410975f, 0.04512201f, -0.00698839f, 0.03149802f, 0.07057167f, -0.09802084f, 
    0.04656762f, 0.06051061f, -0.00363889f, 0.01467215f, 0.06829991f, -0.00228701f, -0.08227817f, -0.13718624f, 
    -0.23265943f, -0.20286681f, 0.02530431f, 0.00635700f, -0.03491708f, -0.04441364f, 0.04609714f, -0.04025913f, 
    0.01776343f, -0.02499070f, -0.05752848f, -0.07042640f, -0.21614566f, 0.08221181f, 0.10827772f, 0.06115251f, 
    0.09462858f, -0.06617954f, 0.02342397f, -0.03936860f, -0.06544083f, -0.01838758f, 0.00688497f, 0.17214221f, 
    -0.35460266f, -0.19439167f, -0.02614119f, -0.06942247f, 0.04115714f, 0.05236751f, 0.02856852f, -0.08320026f, 
    0.08768488f, -0.06867436f, -0.11598976f, -0.01417341f, 0.13262077f, 0.08595926f, -0.04472878f, 0.03975233f, 
    -0.10937271f, 0.06499878f, 0.03029456f, 0.07222356f, 0.02062310f, 0.07092948f, 0.03228629f, 0.04889032f, 
    0.09210484f, 0.00857376f, 0.15152018f, -0.02527548f, 0.07250472f, 0.11562794f, 0.00116012f, -0.02869819f, 
    0.05051874f, 0.12932463f, -0.07058425f, 0.07134414f, 0.28861299f, 0.21792570f, 0.03794292f, -0.10400074f, 
    0.03793321f, 0.00496063f, -0.01805136f, 0.16621405f, -0.07561117f, -0.04805625f, 0.00359953f, -0.07708413f, 
    0.11575563f, 0.06754243f, 0.12211011f, -0.02773145f, 0.11976211f, -0.09474349f, 0.02166322f, -0.05657403f, 
    0.03143635f, 0.01599115f, -0.06309239f, 0.07158291f, -0.18075062f, -0.11185679f, -0.06560627f, 0.00662337f, 
    0.04692743f, -0.11949418f, -0.15137184f, -0.19293819f, -0.04943746f, -0.06732835f, -0.00084260f, -0.09946717f, 
    -0.44966498f, -0.14950742f, 0.08155437f, 0.09248604f, 0.07157666f, 0.07525840f, 0.04514105f, -0.06100900f, 
    0.09666646f, 0.03662259f, -0.04697626f, 0.06758830f, 0.16825111f, 0.06526012f, 0.00984854f, -0.05932159f, 
    -0.06443520f, 0.06340678f, -0.00654780f, -0.02324692f, -0.04657570f, 0.01824364f, -0.02715443f, -0.06604062f, 
    0.02003418f, -0.14718610f, -0.12834895f, -0.10339499f, 0.06028083f, 0.01463306f, -0.05455553f, 0.07788120f, 
    0.01850542f, 0.12170766f, -0.07985316f, 0.00752697f, 0.28138131f, 0.00060329f, -0.06274040f, 0.04891796f, 
    -0.00651257f, -0.20235156f, -0.00702596f, 0.11278998f, -0.09047174f, 0.02935019f, -0.07409918f, 0.03285319f, 
    -0.20084625f, 0.04572933f, -0.04937926f, -0.00937202f, 0.01684501f, -0.00598105f, 0.05968452f, 0.00298412f, 
    0.06835978f, 0.07058470f, 0.07789820f, 0.01390612f, -0.22698367f, -0.19925001f, 0.10375509f, 0.08310831f, 
    0.06536648f, 0.02452190f, 0.02491577f, -0.08361699f, 0.10327608f, -0.05213415f, 0.01424758f, -0.05634503f, 
    0.08997668f, 0.03003449f, -0.00031600f, -0.05804622f, 0.00822011f, 0.03980961f, 0.03387491f, -0.06273557f, 
    -0.02421513f, 0.01229276f, 0.04621654f, -0.00230308f, -0.09987404f, 0.11058161f, -0.15070307f, 0.04784625f, 
    0.02135732f, 0.00590466f, -0.07829308f, 0.08712846f, -0.00651811f, 0.00832668f, 0.10934750f, 0.06685508f, 
    -0.29757890f, -0.10848112f, -0.22569627f, -0.15348893f, 0.04001500f, 0.02167819f, -0.05836857f, 0.03093022f, 
    0.11721885f, 0.15872261f, 0.03914321f, 0.07757825f, 0.09202865f, -0.03083491f, 0.05415684f, 0.07040212f, 
    -0.09768980f, -0.12950501f, -0.01034144f, -0.03892345f, 0.02891653f, -0.05315354f, -0.07373965f, 0.02401707f, 
    -0.27850857f, -0.12571554f, -0.02047519f, -0.24680132f, 0.09159283f, -0.00577676f, -0.00810295f, -0.00340247f, 
    -0.07183078f, 0.11862665f, -0.03456864f, 0.04335355f, 0.28115687f, -0.16134024f, -0.08374471f, -0.08462622f, 
    -0.04770690f, -0.00624501f, 0.02282801f, 0.04151075f, 0.04559519f, 0.08437686f, -0.01034045f, -0.02737724f, 
    0.09771866f, 0.08435600f, 0.11615010f, -0.05324642f, 0.00936923f, 0.01677967f, 0.10216213f, -0.06499884f, 
    -0.09893847f, -0.00002775f, -0.06021649f, 0.03594626f, 0.06638715f, 0.06176741f, 0.07369059f, -0.07783277f, 
    -0.05466306f, 0.07167729f, 0.06709681f, -0.02615853f, 0.03533465f, -0.03592514f, -0.01182760f, 0.03312419f, 
    0.09275763f, 0.17945215f, -0.05484126f, -0.01575287f, -0.05717579f, -0.04526157f, -0.02462513f, 0.07537952f, 
    0.01702020f, -0.06876950f, 0.10907834f, 0.12405139f, -0.23220094f, -0.01070818f, -0.18623085f, -0.12496202f, 
    0.04455777f, 0.04247296f, -0.02460465f, 0.00976067f, 0.03722392f, -0.11981723f, -0.01958768f, -0.03875388f, 
    -0.41662171f, -0.08099555f, -0.11403117f, -0.24422313f, -0.07577159f, -0.05195262f, -0.13316388f, 0.05958433f, 
    -0.07661533f, 0.08788564f, -0.00492698f, -0.05782001f, -0.41937330f, -0.29791301f, -0.01326968f, 0.06735978f, 
    0.02140972f, 0.11027122f, 0.05963232f, -0.01032920f, 0.03066201f, -0.12429529f, -0.03694589f, -0.04230573f, 
    -0.04502585f, -0.08306061f, -0.03905595f, 0.05238248f, -0.03813168f, -0.00807745f, -0.00851528f, -0.08767112f, 
    0.09578221f, -0.00903426f, 0.02605950f, 0.19214767f, -0.38929620f, -0.17680031f, -0.12507558f, -0.25800395f, 
    0.04067967f, -0.07154772f, -0.03645477f, 0.06001977f, 0.00483061f, 0.10536266f, -0.01438030f, -0.01250551f, 
    0.10841265f, 0.00574138f, 0.00714233f, -0.01353366f, 0.04064554f, -0.07595237f, 0.04451558f, -0.00823593f, 
    0.06045674f, 0.04282277f, 0.05561911f, 0.13437070f, -0.05506891f, 0.00504027f, 0.00349658f, -0.11611822f, 
    0.05606721f, 0.06350949f, -0.01401690f, 0.07449847f, 0.05261642f, 0.04608705f, -0.01705408f, 0.04676899f, 
    -0.53293103f, -0.27223238f, -0.03530742f, 0.02139496f, 0.05029276f, -0.03161222f, 0.06815224f, 0.10071195f, 
    0.10617529f, 0.09022199f, -0.01894492f, 0.18162619f, 0.13367262f, 0.07114905f, -0.14649419f, -0.00770184f, 
    0.01024096f, -0.09397787f, -0.09943989f, -0.02617297f, 0.00483331f, -0.09079800f, -0.08793890f, -0.17046806f, 
    0.16490170f, 0.07335865f, 0.05155544f, -0.13093834f, 0.07847399f, 0.04160652f, -0.04112063f, 0.02965848f, 
    -0.05616853f, -0.09681323f, 0.07860074f, -0.10684869f, -0.01900212f, -0.12427256f, 0.08855357f, -0.01749387f, 
    -0.07259794f, -0.01201647f, -0.03947690f, 0.13896091f, 0.09350262f, 0.00805366f, 0.05091006f, -0.09580926f, 
    0.04947915f, 0.23335825f, 0.12027395f, -0.03202122f, 0.01919504f, 0.05940813f, -0.02631145f, 0.05647626f, 
    -0.00823531f, -0.01518061f, 0.03173087f, -0.08799530f, -0.24335641f, 0.13960922f, -0.17554991f, 0.08989738f, 
    0.09692410f, -0.03791377f, 0.04218674f, -0.13595104f, 0.06110235f, 0.07577142f, -0.01079924f, -0.17208888f, 
    -0.38914794f, -0.21145213f, 0.03583153f, 0.04158145f, -0.01522232f, 0.00756144f, -0.01997781f, -0.05136047f, 
    0.09321848f, 0.14373870f, -0.04402839f, 0.05929181f, -0.38035899f, 0.01103144f, -0.21431142f, -0.18097304f, 
    -0.01756364f, 0.03987568f, -0.07293867f, -0.00357041f, 0.00739454f, -0.00326990f, 0.07026411f, 0.04537934f, 
    0.12872113f, 0.01818939f, -0.08727489f, 0.05334437f, -0.02678430f, -0.02987107f, 0.00974620f, 0.00954057f, 
    0.06580020f, -0.06541042f, 0.03338641f, 0.07272146f, -0.14876275f, 0.25861022f, -0.10430915f, -0.14683802f, 
    0.01939348f, 0.01341776f, 0.06309151f, 0.05509280f, 0.10416872f, 0.09230831f, 0.00569994f, 0.09992208f, 
    -0.29957071f, -0.39270660f, -0.01256551f, -0.27611592f, 0.11182077f, -0.18727072f, -0.09440253f, 0.00679105f, 
    -0.06969321f, -0.08477648f, 0.02225581f, 0.13268621f, -0.10660589f, 0.33361110f, -0.08302760f, -0.06051732f, 
    0.03139354f, 0.03078999f, -0.06128877f, 0.08021094f, 0.15612993f, -0.03825312f, -0.08288533f, -0.07833432f, 
    -0.02011797f, 0.02798593f, -0.04975136f, 0.04433892f, 0.04810465f, 0.06660619f, -0.08805102f, -0.01550044f, 
    0.05362437f, -0.00163409f, -0.04653736f, -0.00528452f, -0.09545092f, -0.09648804f, 0.23293413f, 0.04991499f, 
    -0.01217609f, -0.01446731f, 0.04473497f, 0.02739229f, 0.08505484f, -0.01185355f, 0.02412025f, 0.07271265f, 
    0.08484630f, 0.06079145f, -0.08729438f, -0.03890886f, 0.19354641f, -0.05298082f, 0.05595747f, 0.02006951f, 
    0.04610844f, 0.06593802f, 0.09329803f, 0.11706851f, -0.19662966f, -0.13982937f, -0.14124790f, -0.08297768f, 
    0.00676429f, -0.06229093f, 0.01610052f, -0.01857355f, 0.10621065f, 0.02631824f, 0.12930694f, -0.00555214f, 
    0.16979404f, 0.07724340f, 0.04867943f, 0.08277857f, 0.06517931f, 0.12523094f, -0.01707491f, 0.00637345f, 
    -0.02849356f, 0.08100396f, 0.06504559f, 0.07976790f, -0.11346249f, 0.01619064f, 0.02637144f, -0.07718173f, 
    0.06884021f, -0.03858589f, -0.10106723f, -0.00715694f, -0.00971924f, 0.04557906f, -0.01525709f, 0.11841722f, 
    0.16855539f, 0.06971119f, -0.12974368f, -0.05119538f, 0.05882938f, 0.08577863f, 0.03505701f, -0.01191163f, 
    0.04426461f, 0.18212207f, -0.06769931f, 0.02766104f, -0.49553484f, -0.29794094f, -0.05149583f, -0.05511452f, 
    0.00300333f, 0.04742574f, -0.07227956f, -0.06256907f, 0.00349799f, -0.15949430f, -0.16196673f, 0.07787248f, 
    -0.45751372f, -0.07778894f, -0.29837820f, -0.15794629f, 0.01260179f, -0.07485376f, -0.02345867f, -0.00752174f, 
    -0.03384737f, -0.11442527f, 0.07926662f, 0.09137771f, 0.13603847f, 0.10983978f, -0.15693848f, 0.16582365f, 
    0.01207361f, -0.14302836f, 0.02117470f, -0.03643004f, -0.02836241f, 0.04236492f, -0.04473163f, -0.17171410f, 
    0.13971347f, 0.19943613f, 0.00434393f, 0.00068360f, 0.08417762f, 0.02210052f, 0.14291519f, 0.06412917f, 
    -0.05250738f, 0.07039221f, 0.12965485f, 0.09698179f, -0.12117845f, 0.04807277f, 0.03569504f, -0.01997218f, 
    0.07340200f, -0.04154586f, 0.02363923f, 0.00046487f, 0.00648383f, -0.03965003f, 0.02557602f, 0.07237712f, 
    0.33868659f, -0.31634125f, -0.11036993f, 0.06713894f, 0.10246416f, -0.06204946f, -0.04152990f, -0.09678610f, 
    -0.02333914f, 0.11363056f, 0.06190316f, 0.07476394f, -0.33395547f, -0.03637591f, -0.01521642f, -0.02104525f, 
    0.00008003f, 0.10407571f, 0.01382409f, 0.04684906f, 0.02626650f, 0.04757399f, -0.04725092f, -0.13736713f, 
    -0.17180316f, 0.08199521f, 0.15066966f, -0.27541211f, -0.02124433f, 0.07628367f, -0.01459943f, -0.07601168f, 
    -0.05774369f, 0.06879704f, -0.04984567f, 0.06625420f, 0.13413623f, -0.20977880f, 0.06151928f, 0.01141439f, 
    -0.07392400f, -0.05097277f, 0.08033221f, -0.01667166f, -0.01247500f, 0.04184043f, 0.00207422f, 0.01642990f, 
    0.05134448f, -0.00830578f, -0.10449561f, 0.04775621f, -0.00531127f, -0.05194738f, 0.05622893f, -0.12088259f, 
    -0.01960433f, 0.04726192f, -0.01503537f, -0.07214191f, -0.11072061f, -0.04689730f, -0.02116431f, 0.13298625f, 
    -0.08186540f, 0.13123500f, -0.04131669f, -0.19250576f, -0.02320321f, 0.00980053f, -0.03150950f, -0.00946202f, 
    0.19149922f, -0.00710382f, -0.06505496f, -0.12722433f, -0.08467112f, -0.07891469f, -0.01693675f, -0.08850078f, 
    -0.13586555f, 0.06972637f, -0.06214070f, -0.00126195f, 0.00294124f, -0.10865983f, -0.00171809f, 0.16818674f, 
    0.08708995f, -0.04886924f, 0.03240729f, -0.07240631f, -0.15386395f, -0.04540244f, -0.06447900f, 0.00946961f, 
    0.01652035f, 0.03458564f, -0.03615857f, 0.03670644f, 0.00539188f, -0.01459299f, -0.06659400f, -0.06573393f, 
    0.05224653f, -0.05611803f, -0.00939894f, 0.02645121f, -0.03652419f, -0.22072633f, -0.06352133f, 0.01315588f, 
    0.00275710f, -0.03566067f, 0.00747412f, 0.13414352f, -0.03066031f, -0.01223583f, -0.02936129f, -0.02036903f, 
    0.02031162f, -0.00089172f, 0.00305620f, 0.01770091f, 0.05158720f, 0.02964468f, 0.02073686f, -0.12569493f, 
    -0.05948200f, 0.00830919f, 0.01331340f, 0.06695294f, 0.38705644f, -0.10180244f, -0.02220352f, -0.03141954f, 
    -0.11371027f, -0.00984852f, -0.06391898f, -0.08766934f, 0.07620403f, 0.00899958f, -0.01724404f, 0.05038465f, 
    -0.29550415f, -0.27654484f, 0.12402645f, -0.07547025f, 0.14799596f, -0.05354217f, 0.00327198f, 0.06386054f, 
    0.10521332f, 0.05059543f, 0.04604810f, -0.04599886f, 0.04916548f, -0.07908799f, -0.03706482f, 0.02064209f, 
    -0.03796617f, -0.02709099f, -0.01014647f, -0.01350592f, -0.09107990f, -0.02338397f, -0.06684642f, -0.06853973f, 
    0.05536005f, -0.00086360f, 0.04068256f, -0.04168617f, -0.00644688f, 0.02994945f, -0.11045942f, 0.00529473f, 
    -0.04095808f, -0.07042912f, 0.09970915f, -0.02911425f, -0.19940677f, 0.02311997f, -0.27108899f, 0.04702106f, 
    0.14710248f, -0.02742998f, 0.09562132f, 0.13549343f, 0.01971074f, 0.02038455f, -0.00045131f, -0.05161179f, 
    0.20152381f, 0.07666560f, -0.04393229f, -0.18753867f, -0.08240245f, -0.05545833f, 0.04844350f, 0.00956603f, 
    0.05335905f, -0.10582386f, -0.08400219f, -0.06038877f, -0.00701303f, -0.38401946f, 0.09049440f, -0.11190246f, 
    -0.15847063f, -0.00710556f, 0.03453256f, 0.02516491f, -0.01042106f, -0.06544763f, 0.06136791f, 0.01561481f, 
    0.38624206f, -0.02891143f, 0.02528595f, 0.04084295f, -0.01965205f, -0.03622803f, -0.09188870f, -0.04985058f, 
    0.13269038f, 0.05742525f, 0.03068348f, 0.01268630f, 0.05440739f, 0.05035166f, -0.00954425f, 0.06288019f, 
    -0.09822860f, -0.02925969f, 0.00986634f, -0.16139062f, 0.02745680f, -0.00130591f, 0.04385935f, -0.10401005f, 
    -0.27273077f, -0.09034614f, -0.04854056f, -0.31740895f, -0.08377802f, -0.01641537f, 0.06358667f, 0.06906736f, 
    -0.06341895f, -0.03740641f, -0.08506143f, -0.02078651f, -0.13606431f, -0.04058103f, 0.01775929f, -0.09179781f, 
    0.08300386f, -0.02130839f, 0.03195744f, -0.10837888f, -0.05627906f, -0.05271970f, 0.04072963f, 0.11414581f, 
    0.06312174f, -0.07287724f, -0.06435426f, 0.36695886f, -0.15495706f, 0.08519845f, -0.07443595f, -0.04493696f, 
    0.04707448f, 0.08423111f, 0.05528189f, 0.00767185f, 0.18008870f, 0.08417457f, -0.01021909f, 0.04476655f, 
    0.11800880f, -0.00227987f, 0.06287068f, -0.02694686f, -0.03890741f, 0.05031278f, 0.00690095f, 0.02185277f, 
    -0.14667188f, 0.14332372f, -0.08074726f, 0.09280889f, -0.00415813f, -0.13607439f, 0.05982111f, 0.03337042f, 
    -0.06939761f, 0.07864615f, 0.11416788f, -0.07931515f, -0.35746673f, 0.13950643f, -0.01518458f, -0.09805093f, 
    0.03357415f, -0.04744694f, -0.01213121f, -0.00099996f, -0.00475600f, -0.13416858f, -0.05639141f, 0.00544627f, 
    0.29323298f, -0.15569325f, -0.15198322f, 0.08709647f, 0.03193358f, -0.00493457f, -0.04689523f, -0.03010602f, 
    -0.07505249f, -0.01682973f, 0.08054578f, -0.00548887f, 0.01546083f, -0.13432242f, 0.02171420f, 0.05108702f, 
    0.02895400f, -0.03340578f, -0.05435024f, 0.03814483f, -0.13479908f, -0.04934998f, 0.09041443f, -0.11261500f, 
    0.04501572f, -0.41026244f, -0.08678047f, -0.06399452f, 0.06649947f, 0.05516714f, -0.02666421f, 0.08732802f, 
    -0.03787815f, -0.07748129f, 0.05484229f, -0.08424116f, -0.16331202f, 0.21115866f, 0.03624336f, 0.11665815f, 
    0.05003416f, -0.05079566f, -0.02245820f, -0.01346465f, 0.04133222f, -0.09691270f, 0.07264826f, -0.04483796f, 
    -0.05428975f, 0.08624828f, 0.06017980f, -0.06799350f, -0.09258591f, 0.10533995f, 0.11999664f, -0.07286648f, 
    -0.00750434f, -0.03450720f, 0.00472791f, -0.13455863f, -0.14246525f, 0.15710986f, 0.04505263f, -0.11663098f, 
    -0.03205845f, -0.00035836f, -0.11752427f, 0.00242475f, -0.03211922f, -0.04495366f, 0.05422594f, -0.11437558f, 
    -0.02380657f, 0.05358654f, 0.02945939f, 0.15580088f, -0.03622616f, 0.05595293f, 0.01803606f, 0.07724173f, 
    -0.10703941f, -0.09495991f, -0.04355264f, 0.02287191f, 0.17127362f, 0.09749480f, -0.21436128f, -0.00034087f, 
    0.00329810f, -0.02272604f, -0.07090562f, -0.00944982f, -0.06515154f, 0.05803559f, 0.01863928f, 0.03662147f, 
    -0.27902880f, -0.02827043f, -0.15042740f, -0.16172870f, 0.07855407f, -0.01540848f, 0.04547012f, 0.00718234f, 
    0.07203967f, -0.10199835f, -0.17544848f, 0.04570061f, -0.01404719f, 0.23364162f, -0.01716617f, 0.10980988f, 
    0.10288735f, -0.02285894f, 0.00215521f, 0.07874887f, 0.12139408f, 0.11152155f, 0.01941253f, 0.04238899f, 
    0.02655632f, -0.10999314f, 0.05406196f, -0.07993343f, 0.09387960f, -0.03988057f, -0.00649737f, 0.01740864f, 
    -0.01517325f, 0.05498362f, -0.05655658f, 0.03292053f, 0.13603987f, -0.11543161f, -0.00041170f, 0.00377658f, 
    0.00487842f, -0.03805513f, -0.03523412f, -0.04240810f, -0.00740916f, -0.02569119f, 0.00556113f, -0.08152909f, 
    0.17481972f, 0.07936833f, -0.03137695f, 0.00548492f, 0.03426068f, -0.12047460f, -0.03062140f, -0.08682128f, 
    0.00052241f, -0.06672854f, -0.02229297f, -0.09450360f, 0.17754787f, -0.07672366f, -0.09370323f, 0.12900884f, 
    0.04546235f, -0.00686507f, -0.04681020f, -0.02493902f, 0.05697088f, 0.03110334f, 0.03561101f, -0.08688719f, 
    -0.15192924f, 0.34240216f, -0.03898013f, 0.04107408f, 0.13300459f, 0.07459956f, -0.02047857f, 0.03196762f, 
    0.04724327f, -0.00048088f, -0.02211432f, -0.02779539f, -0.07737944f, -0.29829124f, -0.07067604f, -0.13363920f, 
    0.07614066f, -0.04828670f, 0.03296652f, -0.07610013f, -0.06123425f, 0.00992677f, 0.04370118f, 0.03513633f, 
    0.00515737f, 0.23004243f, -0.12547991f, -0.02973621f, -0.16929454f, -0.00868344f, -0.03814880f, -0.18790442f, 
    0.06396235f, -0.00906167f, -0.04571847f, -0.01829015f, -0.24082854f, 0.09061462f, -0.16695367f, 0.08577202f, 
    0.10130574f, -0.01965689f, 0.00622595f, -0.14284834f, -0.07746101f, 0.03892930f, -0.09372573f, -0.03866075f, 
    0.43357530f, 0.10914582f, -0.10936274f, -0.09649882f, 0.00241175f, 0.02862393f, -0.07486842f, 0.00205578f, 
    0.07807820f, 0.02548814f, 0.02376598f, 0.04837079f, -0.02342224f, -0.46191052f, -0.00107667f, -0.04635229f, 
    -0.14068435f, 0.09645264f, -0.05296551f, -0.03288533f, -0.03897918f, 0.07797882f, 0.04022732f, 0.06570973f, 
    0.17095867f, -0.14774598f, -0.05704773f, -0.07370260f, 0.02918723f, -0.11645462f, 0.09202826f, -0.05089444f, 
    0.13792208f, -0.10562699f, 0.00749299f, 0.04357272f, -0.31109318f, 0.19697216f, -0.11766998f, 0.13436288f, 
    -0.07669953f, -0.10096128f, -0.01205774f, 0.15313068f, 0.07654430f, -0.02148450f, 0.09999058f, 0.05540483f, 
    0.14798965f, -0.01382817f, 0.24068189f, 0.04676821f, -0.06383684f, -0.01783212f, 0.07688266f, -0.06789781f, 
    -0.02728507f, 0.00109230f, 0.08107450f, 0.09677663f, 0.16716954f, -0.06124937f, -0.04295025f, -0.00911468f, 
    -0.07434618f, 0.05968626f, 0.00723703f, 0.09827578f, -0.02215079f, -0.04179298f, -0.01765872f, -0.10027173f, 
    0.29423285f, -0.03924188f, -0.19037515f, -0.39103404f, 0.09252517f, 0.00054690f, 0.06877632f, 0.04854684f, 
    0.07795819f, -0.01450907f, 0.03622591f, 0.05260320f, -0.35826474f, -0.05903441f, 0.05883747f, 0.03526254f, 
    -0.16420917f, 0.03829699f, 0.06247566f, -0.02978667f, 0.03241378f, 0.10292724f, 0.13621263f, 0.01205796f, 
    -0.36293209f, 0.11322670f, 0.02905295f, -0.01776281f, 0.10772976f, -0.05144183f, -0.05603182f, 0.09415890f, 
    0.15148801f, -0.00094068f, 0.03968580f, -0.03753567f, -0.21852377f, -0.15071963f, -0.16124932f, 0.03726410f, 
    -0.03847104f, 0.04209820f, 0.11775105f, 0.00387131f, -0.14390890f, 0.06858433f, -0.09106635f, 0.00396275f, 
    -0.03371581f, -0.16069143f, -0.07692216f, 0.24819314f, 0.05175597f, 0.12254710f, -0.01467410f, 0.03968831f, 
    -0.00203120f, 0.02671974f, -0.00563104f, -0.11765738f, -0.10151408f, -0.08127124f, -0.08353264f, -0.18135203f, 
    0.12062043f, -0.01503859f, -0.11366047f, 0.09955761f, 0.08801665f, -0.12522547f, -0.05735212f, -0.03005607f, 
    0.04988731f, 0.02324480f, -0.09973861f, 0.01786171f, -0.06741501f, -0.02942343f, -0.00934699f, -0.04048803f, 
    0.08720153f, -0.00589483f, -0.05287545f, -0.03706650f, 0.44850782f, 0.10191344f, -0.18684153f, 0.06601953f, 
    0.02693287f, 0.09642715f, -0.04021751f, 0.11311822f, 0.14532645f, -0.00659429f, 0.05627870f, -0.15467064f, 
    -0.16521019f, 0.03417595f, 0.10019739f, 0.32055086f, 0.07928516f, -0.03872617f, 0.03680643f, 0.08962756f, 
    -0.03884062f, -0.16999878f, 0.03592956f, 0.03900348f, 0.15959804f, 0.14049062f, -0.16849823f, 0.07596403f, 
    0.13460158f, 0.02907736f, -0.01343352f, -0.00914253f, 0.10302755f, 0.05508045f, 0.12257138f, 0.03813072f, 
    -0.03490929f, -0.11608008f, -0.06301113f, 0.12240843f, -0.05412206f, -0.01970647f, 0.04327333f, 0.05063834f, 
    -0.05893952f, -0.06518592f, 0.07378668f, -0.07927023f, 0.15787719f, -0.23015496f, -0.02138386f, 0.06156252f, 
    -0.13133590f, 0.11106714f, -0.01748280f, 0.07800882f, -0.05065744f, -0.08756046f, -0.04084366f, -0.00802160f, 
    -0.20952274f, 0.21413834f, -0.02814392f, 0.03085811f, -0.11045344f, -0.06805787f, 0.00461909f, -0.00954308f, 
    0.02923571f, -0.05062130f, 0.01484849f, -0.10266484f, 0.16064203f, 0.23988365f, -0.17458539f, -0.06082771f, 
    0.00029656f, -0.00588731f, 0.00927320f, 0.05750802f, 0.08850493f, -0.01812584f, -0.03266595f, 0.01630221f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.08251013f, 0.02361494f, -0.06705210f, -0.00738543f, 0.02633540f, 0.02040128f, 0.01671828f, -0.07906004f, 
    -0.05396490f, 0.02947949f, 0.05167353f, -0.00722038f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
