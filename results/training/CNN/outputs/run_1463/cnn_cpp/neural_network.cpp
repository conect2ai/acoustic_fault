#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.08372760f, 0.32695481f, -0.24002209f, -0.24746795f, -0.43051809f, -0.46945009f, 0.14505152f, 0.41213742f, 
    0.31264856f, 0.49028316f, -0.00613805f, -0.14288305f, -0.11754600f, -0.30635366f, -0.43429145f, -0.06640670f, 
    0.00473453f, 0.04277014f, 0.17610548f, -0.13385479f, -0.21952939f, 0.01688766f, 0.01124890f, 0.13714570f, 
    0.01530909f, 0.33178911f, -0.06565628f, -0.25285086f, -0.03217547f, 0.14259708f, -0.00514317f, 0.10910500f, 
    0.17070416f, -0.10573427f, -0.26034656f, -0.16300249f, 0.87224704f, -0.57612014f, -0.20141912f, 0.21218583f, 
    -0.31511238f, 0.50613797f, 0.23807326f, 0.05912741f, -0.38849884f, 0.27902839f, -0.01914934f, 0.00913849f, 
    0.04867991f, -0.04234986f, 0.13304128f, -0.22131808f, 0.15201358f, 0.34117517f, 0.29165417f, -0.10537653f, 
    -0.03691191f, 0.24545546f, 0.08561633f, 0.32236719f, -0.01819611f, 0.25540465f, 0.14549914f, -0.43785709f, 
    -0.08821484f, 0.13776587f, 0.15336367f, 0.25069538f, -0.18140873f, 0.11511911f, -0.29441684f, -0.38245165f, 
    -0.34748855f, -0.18308559f, -0.23426311f, 1.09628665f, -0.21649681f, -0.28382638f, -0.34154820f, -0.32929936f, 
    0.26813927f, -0.47406647f, -0.60385513f, -0.75207764f, -0.93670249f, -0.07451487f, 0.14262401f, 0.25020379f, 
    -0.16618384f, -0.22440951f, 0.06796271f, 0.19382648f, 0.06469375f, -0.12833171f, -0.09367226f, -0.16438167f, 
    -0.17027014f, -0.09396841f, -0.03468785f, -0.30457062f, -0.34286872f, -0.13977006f, 0.28013152f, 0.28473642f, 
    0.24363007f, 0.00511096f, -0.10467653f, -0.44902727f, -0.29841048f, 0.20238429f, 0.13096929f, 0.27030131f, 
    0.19456828f, -0.03671391f, 0.33060485f, -0.50921476f, -0.05096738f, 0.20976940f, 0.23462506f, 0.27555963f, 
    0.38223287f, 0.35169142f, 0.58034152f, -0.38887855f, -0.46281877f, -1.44425547f, -0.49899086f, 0.38181686f, 
    0.90337729f, 0.29344761f, 0.24865343f, -0.71345866f, -0.27392808f, 0.49810910f, 0.04068456f, -0.18725364f, 
    0.03773368f, -0.29796612f, 0.59426272f, -0.23208827f, -0.09383082f, 0.20795679f, 0.22738835f, -0.29806444f, 
    -0.24415673f, 0.35463512f, -0.14267944f, 0.01139592f, 0.13445514f, 0.16753015f, -0.36534053f, 0.97763515f, 
    0.17886899f, 0.39729774f, -0.07730287f, -0.00074751f, -0.05191202f, -0.46234787f, -0.45153409f, -0.20502548f, 
    0.24255572f, 0.10539945f, 0.16201033f, -0.29369968f, -0.30576879f, -0.00112773f, 0.21553382f, 0.30960628f, 
    -0.04338235f, -0.12683842f, -0.17030469f, -0.16257216f, -0.29183441f, -0.11228164f, -0.41371071f, -0.97081703f, 
    -0.84218001f, -0.48148915f, -0.07895625f, 0.74062383f, 0.29121488f, 0.11709987f, 0.01021667f, -0.14440514f, 
    0.33371979f, -0.18157563f, -0.58069503f, -0.14017464f, -0.22838338f, -0.14283560f, 0.54379201f, -0.30496663f, 
    0.34505144f, 0.27740172f, -0.20969509f, -0.23994616f, -0.08678286f, -0.41601989f, -0.47645548f, -0.17271411f, 
    0.64382237f, -0.39186677f, -0.13459234f, 0.25739878f, 0.07452033f, 0.45021415f, 0.08268718f, -0.28071511f, 
    0.00959327f, -0.18073255f, 0.21537954f, 0.12542190f, -0.31558698f, 0.22877310f, 0.08816106f, 0.11709167f, 
    -0.06763407f, -0.17499635f, 0.20655774f, -0.32265967f, 0.07072107f, -0.10313220f, 0.22775480f, 0.21184851f, 
    -0.19121882f, -0.75486958f, -0.25247866f, -0.86120927f, -0.14548136f, 0.26707840f, 0.67698121f, -0.01376171f, 
    0.16830978f, 0.05585278f, 0.22028831f, 0.40504786f, -0.20767708f, 0.05690094f, -0.60172045f, 0.52880025f, 
    -0.54397213f, -0.39238238f, 0.45624730f, -0.09899913f, -0.22098173f, -0.23335287f, 0.02191850f, 0.42968097f, 
    0.09168574f, 0.47236907f, 0.62103647f, 0.62042737f, 0.33228466f, -0.14308883f, -0.82391292f, -0.66544163f, 
    -0.50230807f, -0.11446097f, -0.09368972f, -0.53543925f, -0.07245073f, -0.03961346f, 0.18642075f, 0.43293396f, 
    0.16124944f, 0.07524474f, 0.31495532f, 0.29128140f, 0.14735335f, -0.03454093f, -0.26529688f, -0.20789436f, 
    -0.09501981f, -0.04666066f, -0.20339969f, -1.00649393f, -0.55269617f, -0.09263822f, -0.70473492f, -1.27373385f, 
    0.82727420f, 0.34872326f, -0.12118933f, -0.12963040f, 0.47004813f, 0.07333132f, 0.78423065f, -0.34293655f, 
    -0.21661967f, -0.64324629f, -0.59276128f, -0.20815694f, -0.03015567f, 0.09225848f, 0.33076391f, 0.16188410f, 
    -0.11570603f, -0.08692044f, 0.10354559f, -0.13410498f, 0.13298683f, -1.25757861f, -0.60067791f, -0.96462935f, 
    -0.47674632f, 0.53839159f, 0.12684679f, 0.12350516f, -0.67842013f, 0.54309678f, -0.28116786f, -0.32358015f, 
    -0.01873774f, 0.18798928f, 0.36201978f, 0.17053300f, 0.20578679f, -0.08275481f, -0.12168711f, -0.25329098f, 
    0.06106698f, -0.28132603f, -0.25884813f, -0.00162706f, -0.03681713f, 0.70935667f, 0.32737374f, 0.28755987f, 
    -0.24633683f, -0.08371954f, 0.23863477f, 0.20305365f, -0.05487772f, 0.10750853f, -0.32762307f, 0.00577458f, 
    0.20495607f, -0.08157039f, -0.33217591f, 0.02099316f, -0.36572006f, -0.29289642f, -0.13048029f, 0.04438671f, 
    0.18072565f, -0.19125935f, 0.39063454f, 0.23986696f, -0.28087506f, -0.21258369f, 0.47496155f, -0.72708428f, 
    -0.38505000f, 0.43316042f, 0.07397131f, 0.73361379f, -0.52196878f, -0.63513279f, 0.13242964f, 0.49789992f, 
    0.34973866f, -0.09114741f, -0.45806834f, -0.01323083f, 0.10270862f, -0.45297202f, -0.09589192f, 0.17469655f, 
    -0.05256659f, -0.21028624f, 0.10064137f, -0.50846541f, -0.40227616f, 0.36386073f, -0.45925140f, -0.73690343f, 
    -0.55665517f, 0.09403540f, 0.12821758f, -0.39563888f, -0.81975240f, -0.67084718f, -0.62626022f, -0.61444950f, 
    -0.48273915f, 0.40703630f, -0.39096534f, -0.17636019f, -0.61221790f, -0.26657787f, -0.17854646f, 0.06464140f, 
    -0.48323208f, -0.45916444f, -0.44180691f, -0.05588026f, 0.22878729f, 0.08744066f, -0.10045307f, 0.26938647f, 
    -0.19958010f, 1.13470161f, 0.96401227f, -0.66649282f, 0.03693365f, -0.27743825f, -0.28396609f, 0.18046826f, 
    0.39176482f, -0.52434343f, -0.17009376f, -0.21089691f, -0.10069168f, 0.58329976f, -0.49097162f, 0.35246217f, 
    -0.01013317f, -0.24949531f, -0.03077914f, 0.11892540f, -0.08750506f, 0.16251878f, 0.20228536f, -0.25175446f, 
    -0.11667302f, -0.87543237f, -0.79206949f, -0.86388564f, -0.81939054f, -0.20435220f, -0.26787782f, -0.49863043f, 
    -0.45964620f, -0.50565404f, -0.21299660f, -0.66006446f, -0.57151264f, -0.23060824f, -0.17980810f, -0.33915505f, 
    -0.12383299f, -0.40913519f, -0.23592781f, 0.27652964f, -0.19522972f, -0.10431127f, -0.00029560f, -0.37588504f, 
    -0.00521508f, -0.15069191f, -0.49026093f, -0.24356534f, -0.42159960f, -0.12486553f, 0.19860893f, -0.18420729f, 
    -0.32177326f, -0.58289802f, -0.65472865f, -0.18593915f, 0.10920900f, -0.12902705f, -0.13746850f, -0.68333006f, 
    -0.14289753f, 0.27735260f, 0.27724078f, 0.26920792f, 0.37419543f, 0.36991507f, -0.00107133f, -0.22826451f, 
    0.12973511f, 0.00009395f, -0.11795475f, 0.27042598f, 0.15739995f, -0.40682235f, -0.75472623f, -0.73802918f, 
    0.07623706f, 0.13516301f, -0.01089068f, -0.04856324f, -0.47313845f, -0.16759354f, 0.08398203f, -0.13006806f, 
    -0.26774973f, -0.35437685f, -0.02678991f, -0.44600359f, -0.04861068f, -0.31317228f, -0.41537270f, 0.09080673f, 
    0.37752220f, 0.47513404f, 0.27052966f, 0.24957706f, 0.84140766f, 0.00451177f, 0.23382592f, 0.33412883f, 
    0.36203736f, -0.53963977f, 0.03525152f, -0.48656636f, -0.50811762f, -0.51609230f, 0.02576780f, 0.18998142f, 
    -0.03048686f, 0.12719320f, 0.13234204f, 0.13115573f, 0.12427076f, -0.06886907f, -0.27947646f, 0.34643671f, 
    -0.24208909f, -0.04893430f, 0.13568769f, 0.07560515f, -0.17877537f, -0.42552185f, -0.62934524f, -0.55870748f, 
    -0.66037571f, -0.62742776f, -0.19356611f, -0.43349841f, -0.74744725f, -1.16482961f, -0.84979713f, 0.13028838f, 
    0.07732178f, 0.30103177f, 0.65406752f, 0.05707133f, 0.22838877f, -0.10298418f, 0.06463329f, -0.00077359f, 
    -0.23322824f, -0.35317728f, 0.17334540f, 0.21098013f, 0.29152802f, 0.15988888f, -0.14671350f, 0.25214335f, 
    0.52755237f, 0.00909946f, -0.22773868f, -0.14173175f, 0.30577633f, -0.14929084f, -0.50887620f, -0.11546858f, 
    -0.25477585f, -0.12597123f, 0.07353693f, 0.10888162f, -0.26444265f, 0.47750235f, -0.08375440f, -0.08504725f, 
    0.18911688f, -0.09467657f, -0.02710882f, -0.06549374f, -0.11569236f, -0.01836513f, 0.58323175f, 0.29401857f, 
    -0.18789756f, -0.28647202f, -0.00108330f, -0.03322488f, -0.12148830f, 0.03755085f, 0.44888103f, -0.23882437f, 
    -0.20277174f, 0.05973521f, 0.43361717f, -0.42358723f, 0.11196321f, 0.12488607f, -0.11501795f, 0.06360017f, 
    -0.33203188f, -0.04238685f, 0.04229587f, 0.00938508f, -0.08059063f, 0.29078966f, 0.30775085f, 0.38229153f, 
    0.69314116f, 0.79627794f, 0.44652429f, 0.21817075f, -0.18819223f, -0.22807549f, -0.55172908f, -0.34950322f, 
    -0.17170756f, -0.44548956f, 0.17298406f, -0.29540899f, 0.03600463f, 0.30056742f, 0.22529671f, -0.33714235f, 
    -0.31038687f, 0.02660125f, -0.00039798f, -0.00968776f, 0.15516905f, -0.03709682f, -0.10955635f, 0.11792548f, 
    0.14077005f, -0.68397564f, -0.27661175f, 0.42045948f, 0.51421863f, 0.42861325f, 0.82895195f, 0.83799922f, 
    -0.46837240f, -0.38616428f, 0.12965238f, 0.18542278f, -0.03312749f, 0.07014757f, -0.16065502f, -0.26948324f, 
    -0.23771371f, -0.25622892f, -0.17172365f, 0.08488591f, 0.07949283f, 0.10429119f, -0.11486855f, -0.02890060f, 
    0.21303600f, -0.16576962f, -1.12900138f, -0.55347526f, 0.72825986f, -0.11153173f, -0.81787002f, 0.19189823f, 
    0.13673688f, 0.22384448f, -0.12427228f, -0.16370963f, -0.23482446f, 0.03154876f, -0.00628342f, 0.60202229f, 
    0.06625439f, -0.08737347f, 0.18378393f, 0.09389237f, -0.08648700f, 0.37800270f, 0.10392989f, 0.00215864f, 
    0.21943027f, -0.11030051f, -0.10116553f, 0.83407962f, -0.62402505f, -0.89107919f, -0.94486636f, -1.02238011f, 
    -0.10577232f, -0.14692998f, 0.34177139f, 0.18315566f, 0.10699973f, 0.35112080f, 0.27153543f, 0.25113133f, 
    0.08109411f, -0.06544195f, -0.02056954f, -0.29621306f, 0.04608648f, 0.00350777f, -0.28347650f, -0.25464329f, 
    -0.21073627f, -0.20298207f, -0.39527851f, -0.39975494f, -1.47603035f, -0.25438410f, -0.04333776f, -0.67810190f, 
    -0.13299710f, 0.91932786f, 0.21572769f, -0.02968380f, 0.44224864f, 1.00180781f, 0.23050177f, 0.02458640f, 
    -0.33124149f, -0.25187203f, -0.05872251f, 0.04235548f, -0.11523730f, 0.08833486f, 0.14419271f, -0.11786781f, 
    0.02432975f, 0.17237356f, 0.04491480f, -0.01610985f, -0.44400805f, -0.62742853f, 0.98511386f, 0.35334554f, 
    -0.70954692f, -0.47249714f, 0.14528888f, 0.57339180f, -0.18803290f, -0.33291715f, -0.06880536f, 0.05117293f, 
    0.21562542f, 0.21197465f, -0.57642174f, 0.26887390f, -0.14191540f, -0.05108431f, 0.03516723f, -0.34872404f, 
    -0.35038227f, -0.09654848f, -0.06919608f, -0.49451098f, -0.42716014f, -0.36535513f, -0.73925245f, -0.78201497f, 
    0.67763960f, 0.65445447f, 0.11686516f, 1.26925194f, 0.29574686f, -0.26793072f, -0.36159843f, -0.22968388f, 
    -0.19773118f, -0.23485407f, -0.31516799f, 0.01024624f, -0.07148778f, 0.03468776f, -0.10887773f, -0.14880550f, 
    -0.05472530f, 0.16882539f, -0.32293609f, 0.20850706f, 0.10306739f, -0.10944498f, -0.36237699f, -0.33750200f, 
    0.69592190f, 0.18335500f, 0.43513712f, -0.08696614f, -0.89404303f, -0.95789778f, -0.21918449f, 0.36146706f, 
    0.51710373f, -0.12544335f, -0.29911414f, -0.21755049f, -0.04375717f, -0.26453838f, 0.02078754f, 0.17124933f, 
    0.37412280f, 0.03865323f, 0.00614524f, -0.05103924f, -0.07835057f, -0.16628748f, -0.05104224f, -0.19637839f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.58198386f, 0.33968431f, 0.30945486f, -0.16598283f, 0.28819510f, 0.42478269f, -0.01384592f, -0.04980733f, 
    0.30207172f, 0.47528166f, 0.07992627f, 0.53551751f, 0.02604989f, 0.40521470f, 0.47093314f, 0.26374912f, 
    0.39088750f, -0.77585286f, 0.09141359f, 0.04334691f, 0.02095946f, -0.14378312f, 0.40065941f, 0.14239469f, 
    0.21256918f, 0.20583643f, 0.33144692f, 0.11574481f, 0.42385009f, 0.06596555f, 0.24236141f, 0.36475107f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.89683127f, -0.29327366f, -0.50303429f, -0.15816352f, -0.02366247f, 0.02553997f, 0.03383909f, 0.01888913f, 
    -0.08496223f, -0.08104715f, -0.04293174f, 0.00651845f, 0.01138263f, -0.14052480f, -0.18218914f, -0.00943811f, 
    -0.13835447f, -0.12047778f, -0.43545461f, -0.16236913f, -0.09393215f, 0.11390761f, -0.08489862f, -0.15665501f, 
    -0.02578383f, -0.00233231f, 0.02229145f, 0.06403518f, 0.02401813f, 0.05732602f, 0.05563402f, -0.00880154f, 
    -0.21288989f, -0.00033904f, 0.02820513f, 0.00651983f, 0.26957905f, -0.23522472f, -0.36357543f, 0.13622905f, 
    -0.02498730f, -0.05152383f, -0.05629847f, 0.07683256f, -0.17013492f, 0.10790734f, -0.09568358f, 0.13794647f, 
    0.01021214f, 0.01893471f, 0.09748554f, -0.00691764f, -0.30747122f, -0.12897289f, 0.02148809f, 0.02202647f, 
    -0.07214487f, -0.09513379f, -0.03000134f, -0.05058284f, 0.23854643f, 0.20459993f, 0.53596747f, -0.67100048f, 
    -0.10323923f, -0.23941959f, 0.08115815f, 0.11846220f, -0.03333830f, -0.06448496f, -0.27155024f, -0.40711373f, 
    -0.03188819f, 0.17908354f, -0.23964244f, 0.13309149f, 0.04289345f, -0.40412852f, -0.27021584f, -0.01986581f, 
    -0.08333216f, -0.10765473f, 0.02004358f, 0.14675194f, 0.33361757f, 0.21107848f, -0.06499342f, -0.10622533f, 
    0.00372590f, 0.22595440f, 0.26041919f, 0.03942941f, -0.03404767f, 0.06297625f, 0.01264695f, 0.00652237f, 
    -0.28489813f, -0.33600435f, 0.00109632f, 0.09704491f, 0.00293691f, -0.00648197f, -0.04721418f, -0.00229503f, 
    -0.04437207f, 0.04533324f, 0.03372310f, -0.01610112f, -0.08265889f, -0.08930184f, -0.24484161f, -0.08031844f, 
    0.06124420f, 0.10249636f, -0.03615095f, -0.23942827f, 0.01832497f, -0.32827389f, -0.33203971f, -0.17351878f, 
    0.15271015f, 0.08417306f, 0.11615878f, -0.03837430f, 0.02087018f, 0.14275245f, 0.07543609f, 0.07064509f, 
    0.20064844f, -0.00016919f, -0.03816183f, 0.04133749f, 0.31422114f, 0.08607227f, -0.13409342f, -0.18874906f, 
    -0.01417781f, 0.01988298f, 0.16129617f, 0.12320704f, -0.02137362f, -0.02938951f, 0.09427671f, -0.05068045f, 
    0.32509148f, 0.06268386f, -0.25242430f, -0.12856141f, 0.06538195f, 0.09508973f, -0.07423562f, -0.05537454f, 
    -0.07059222f, 0.05957445f, 0.06094347f, 0.10772051f, -0.24028687f, -0.72726047f, -0.67525965f, 0.06558818f, 
    0.01209702f, -0.10635323f, 0.05585101f, 0.11878495f, -0.02451025f, -0.03757689f, 0.05100943f, -0.08339404f, 
    -0.15865391f, -0.02070507f, -0.20953941f, -0.12932773f, -0.01400019f, -0.07313070f, -0.02179540f, -0.06620280f, 
    -0.12735896f, 0.01395018f, -0.13663748f, 0.29615915f, 0.36987174f, 0.22413297f, -0.03657138f, -0.43148008f, 
    0.18274726f, 0.01152684f, 0.06294951f, -0.00086022f, -0.05018409f, -0.06992735f, -0.18583235f, -0.20422144f, 
    -0.71929592f, -0.11210099f, -0.10186701f, 0.14027651f, 0.05311264f, 0.04866468f, -0.02705652f, 0.11229280f, 
    0.02242742f, 0.03513689f, -0.05465738f, -0.00102717f, 0.40728432f, 0.22382538f, 0.03915722f, -0.03468578f, 
    0.22655614f, 0.29777640f, 0.11676924f, 0.06023340f, -0.14719081f, -0.11908664f, -0.02778670f, -0.07524522f, 
    0.40680027f, 0.33288333f, -0.16754103f, -0.07898136f, 0.13440990f, 0.10719410f, 0.01375233f, -0.01253552f, 
    -0.00821546f, 0.00783592f, 0.04658660f, -0.02151912f, 0.06175297f, -0.28387830f, -0.36101350f, 0.02672644f, 
    0.12797272f, 0.18661429f, -0.22924162f, -0.14698541f, -0.05117181f, -0.13030452f, -0.03337710f, -0.05923681f, 
    0.02936669f, -0.08496589f, -0.07156754f, -0.05854026f, -0.15730698f, -0.25351751f, -0.12447499f, -0.19589718f, 
    -0.03400615f, 0.16169803f, 0.02642054f, 0.02566106f, 0.44168434f, 0.07272954f, -0.41778925f, -0.22710843f, 
    0.06435677f, -0.00635466f, -0.02999497f, -0.09786628f, -0.00612704f, 0.05567262f, 0.02406495f, -0.00012924f, 
    0.03142090f, -0.06445364f, -0.06845965f, 0.02885646f, -0.21100818f, -0.25840479f, -0.16755807f, 0.03464369f, 
    -0.00768367f, -0.04072142f, -0.02391625f, -0.00378270f, -0.01717735f, 0.10393299f, -0.07545292f, 0.07668579f, 
    -0.19573691f, -0.26900765f, -0.12552473f, -0.07111909f, -0.09767930f, 0.00206831f, -0.09739884f, -0.12232811f, 
    -0.06349429f, -0.27753693f, -0.03287141f, -0.18151344f, 0.06992364f, 0.06608240f, -0.16779786f, -0.02237789f, 
    -0.00378473f, 0.05223936f, 0.03023738f, 0.05247944f, 0.16770303f, -0.01205034f, 0.22528078f, -0.10810795f, 
    0.05857896f, -0.06453913f, 0.10104498f, 0.06451335f, -0.05837919f, -0.02039619f, 0.09265815f, 0.00270136f, 
    0.16760826f, -0.12946618f, -0.00778390f, -0.04941227f, -0.02715693f, 0.19150680f, -0.13541082f, 0.06755793f, 
    -0.05803518f, -0.06191204f, 0.01750189f, 0.05252782f, 0.22955282f, -0.01461456f, -0.01816819f, 0.13322073f, 
    0.14164308f, 0.04216613f, -0.02683496f, 0.02719341f, -0.11823069f, 0.04112004f, -0.14037955f, 0.10069467f, 
    -0.19959213f, 0.16435891f, 0.02568115f, -0.03315785f, -0.01589240f, 0.16411211f, 0.10907783f, 0.05860595f, 
    0.00376949f, 0.22265483f, -0.11137392f, -0.04358443f, -0.13317046f, -0.20380965f, -0.37758684f, -0.02562677f, 
    -0.06995785f, 0.03311056f, 0.08059750f, 0.08553497f, -0.00014126f, 0.10214754f, -0.03079529f, 0.05526306f, 
    0.95299149f, -0.29127878f, -0.47987354f, -0.58911633f, 0.03237031f, -0.11335424f, 0.16634886f, -0.03415275f, 
    -0.04639619f, 0.08756723f, -0.04748772f, -0.05351619f, -0.22061083f, 0.51909894f, 0.32548630f, -0.37221545f, 
    -0.19553639f, -0.12430882f, -0.07955915f, -0.16082205f, -0.00751478f, -0.14132310f, -0.08649586f, 0.03388638f, 
    0.54000568f, 0.17170173f, 0.65838754f, 0.10951323f, 0.03088572f, -0.07693664f, -0.01966579f, -0.06364950f, 
    -0.03950122f, -0.14640903f, 0.01380811f, 0.05881591f, 0.15803275f, 0.02268663f, -0.07455852f, -0.04557715f, 
    0.01563141f, 0.09716336f, 0.17362250f, 0.15052982f, 0.07800974f, 0.03815041f, -0.20994759f, -0.00127132f, 
    0.03074897f, 0.08898783f, 0.12446270f, 0.10603447f, 0.04949398f, -0.00477263f, -0.04160036f, -0.03325715f, 
    -0.01434557f, -0.25294703f, 0.01499244f, 0.07907630f, 0.36413217f, -0.09498189f, -0.41435811f, -0.36926588f, 
    -0.17250909f, -0.16684417f, -0.13211662f, -0.01159744f, 0.12966269f, -0.05135748f, 0.06197821f, 0.18788408f, 
    -0.02113691f, 0.11939257f, -0.03762202f, -0.03776794f, 0.13719407f, 0.13527343f, -0.03162792f, 0.26675999f, 
    -0.09160557f, -0.03720836f, -0.03763912f, 0.07609958f, -0.60867000f, 0.09548870f, -0.27849853f, -0.11126627f, 
    0.04017394f, 0.05529974f, 0.10452144f, 0.09849630f, 0.08439651f, -0.11015573f, 0.18162507f, 0.07109188f, 
    -0.13940859f, 0.02344322f, 0.05300653f, -0.19538638f, -0.02688454f, 0.12014184f, 0.02327332f, -0.03706986f, 
    0.04536755f, 0.00729062f, -0.02935908f, 0.07698701f, -0.27767155f, 0.01131445f, -0.21243937f, 0.35086763f, 
    0.11558945f, -0.12622581f, -0.09590777f, -0.18540858f, 0.13199446f, -0.07923018f, -0.26483378f, -0.18542403f, 
    0.38195321f, -0.01878890f, -0.06794094f, 0.16730057f, -0.06973490f, -0.05245126f, 0.08221437f, 0.00515195f, 
    0.01190445f, 0.08784326f, 0.15944102f, 0.01717904f, -0.40839657f, 0.25488392f, -0.23090206f, -0.27061194f, 
    -0.01954403f, 0.05364129f, 0.07940578f, 0.13524257f, 0.12671874f, 0.15794744f, -0.03428633f, -0.11862718f, 
    -0.03683045f, -0.09916005f, 0.04810234f, -0.29049402f, -0.03991733f, -0.30953172f, 0.01199083f, -0.22152783f, 
    -0.06162942f, 0.01847758f, -0.01445640f, 0.05695572f, 0.19421978f, -0.00282824f, -0.39144644f, -0.46018758f, 
    -0.09544375f, 0.06912991f, -0.19027048f, 0.02362065f, -0.00481827f, -0.06684701f, -0.11521824f, 0.01321213f, 
    0.29940695f, -0.32908031f, 0.14063063f, 0.11880117f, 0.32225105f, 0.05777029f, -0.28457007f, -0.33546868f, 
    0.03159155f, -0.03101511f, 0.12607192f, -0.25997382f, 0.73045188f, 0.13703482f, 0.16441274f, 0.12314845f, 
    -0.04168405f, -0.06608869f, -0.02357515f, -0.02845905f, -0.08549009f, 0.06974509f, 0.00491138f, -0.07138594f, 
    0.40433148f, 0.35038593f, -0.09084190f, -0.06278249f, -0.13795891f, -0.06479194f, 0.03084099f, -0.13002561f, 
    0.09346531f, -0.42101887f, -0.22130021f, -0.10609586f, -0.14365676f, -0.02641360f, -0.21266402f, -0.18513544f, 
    0.04340656f, 0.06354695f, 0.03680126f, 0.07758672f, 0.02965693f, 0.10265647f, 0.02678888f, 0.07513642f, 
    0.33786014f, -0.10354413f, 0.08026007f, -0.00883403f, -0.02687741f, -0.24931924f, -0.06273194f, 0.12537286f, 
    -0.07503593f, 0.00694212f, 0.00342131f, 0.01784194f, 0.21394150f, 0.32694262f, 0.36984974f, 0.45258307f, 
    -0.12282710f, 0.05635971f, -0.06301666f, -0.08255012f, -0.02646546f, 0.02892751f, -0.03418818f, -0.06246752f, 
    0.13054954f, 0.05937228f, -0.00619213f, -0.09218282f, -0.16651817f, -0.17468649f, -0.00038190f, -0.24198109f, 
    0.02876941f, -0.09656519f, -0.03422122f, -0.05995096f, 0.25557348f, 0.14067802f, 0.11344776f, -0.10459101f, 
    -0.20771892f, 0.07991003f, 0.22328477f, 0.17261285f, -0.06926835f, 0.01210508f, -0.11045482f, 0.01626085f, 
    0.09940967f, 0.20052265f, -0.30353588f, -0.18598762f, -0.22251412f, -0.08833109f, 0.06284770f, -0.29527989f, 
    -0.12004997f, 0.03589012f, 0.03462134f, 0.03368810f, 0.15733486f, -0.04204674f, 0.36006021f, 0.25622138f, 
    -0.01705625f, 0.09031121f, 0.10873431f, 0.03777400f, 0.01361936f, -0.02046561f, 0.03973140f, 0.01297403f, 
    0.14498192f, -0.09891032f, 0.10522345f, 0.03490991f, -0.01627683f, 0.06781217f, 0.02524234f, -0.26491374f, 
    0.04013469f, 0.02276725f, 0.02471400f, 0.01651330f, 0.16715096f, 0.05298141f, -0.02300336f, 0.01668569f, 
    0.12752040f, 0.15850785f, 0.18959299f, -0.09776725f, -0.04282492f, 0.07268879f, 0.01140031f, 0.03159554f, 
    0.23040858f, 0.18611750f, -0.27304393f, -0.10797460f, -0.14548711f, -0.11766485f, -0.04615866f, -0.10881791f, 
    0.01169819f, -0.05916590f, 0.08881006f, 0.00974907f, 0.44523519f, -0.06725383f, 0.14401409f, 0.30459037f, 
    -0.12155578f, -0.04481030f, -0.02959819f, -0.07718692f, 0.06152240f, 0.01635079f, 0.07215197f, 0.00471109f, 
    -0.43693227f, 0.07480226f, 0.15914252f, -0.11935109f, -0.00534361f, 0.00674494f, -0.01800027f, -0.07599308f, 
    -0.10204256f, -0.03127882f, 0.11105494f, 0.02294176f, 0.07515973f, -0.16219392f, -0.09119214f, -0.20833144f, 
    -0.06230625f, 0.11232509f, 0.00417320f, -0.13837609f, 0.11300374f, -0.14661382f, -0.16118705f, -0.11685777f, 
    0.30068767f, 0.31917956f, -0.25233859f, -0.20337652f, -0.07976332f, -0.03094512f, -0.16694143f, 0.18061309f, 
    -0.29958978f, -0.05694296f, 0.07182820f, 0.14290142f, -0.06004084f, -0.40237534f, 0.24327603f, -0.29292586f, 
    0.08420336f, 0.09157294f, -0.05307419f, 0.05179109f, -0.43068257f, -0.43247354f, -0.26597580f, -0.30254239f, 
    0.40909946f, -0.08212466f, 0.23888412f, 0.21423815f, -0.00237792f, -0.03128738f, -0.00306626f, 0.14485033f, 
    -0.01881882f, 0.01850358f, 0.22568290f, -0.08967115f, -1.08527601f, 0.15351065f, 0.18062115f, -0.39181349f, 
    0.08397802f, -0.05720697f, -0.27193472f, -0.06996935f, -0.03382836f, -0.03974176f, 0.01068426f, -0.01606214f, 
    -0.49184343f, 0.34778327f, 0.26488632f, -0.09291183f, -0.02410742f, -0.01592008f, -0.05181808f, 0.03849900f, 
    0.03251930f, -0.06536502f, 0.01713317f, -0.03521720f, -0.10808826f, -0.03308020f, 0.03174521f, 0.05548175f, 
    -0.15667631f, -0.07909572f, 0.01998386f, -0.01949307f, 0.10503799f, -0.01848971f, 0.04036660f, 0.06823724f, 
    -0.02377363f, -0.08987970f, -0.05332068f, 0.03203912f, 0.00651129f, 0.03841851f, -0.00275511f, -0.00008705f, 
    0.02215130f, 0.21789297f, 0.20451070f, 0.10368819f, -0.65155542f, -0.12727433f, -0.00567778f, -0.27412039f, 
    -0.14080071f, 0.12418386f, -0.09086994f, -0.46563208f, 0.10616047f, -0.04686443f, 0.06868701f, -0.11644968f, 
    0.02288917f, 0.01547934f, -0.09541600f, -0.01547973f, 0.17539401f, -0.11338221f, 0.07273076f, 0.03533864f, 
    0.03931503f, 0.01155602f, 0.06535548f, -0.10248091f, -0.02296358f, -0.17699310f, -0.38621542f, 0.28893229f, 
    -0.02212010f, 0.12265155f, -0.17067313f, 0.23202606f, -0.00431327f, -0.15529321f, 0.00668965f, 0.01938589f, 
    -0.01446412f, 0.02210664f, 0.04064981f, -0.24388024f, 0.06042574f, -0.11524997f, -0.35384414f, 0.02303273f, 
    0.08178252f, -0.10112942f, 0.04729973f, -0.09164954f, -0.08446886f, -0.33598331f, 0.39190212f, 0.28309613f, 
    0.19768082f, 0.03710918f, -0.15476105f, 0.09712525f, 0.08972315f, -0.00861066f, 0.10121856f, -0.16828193f, 
    -0.27338675f, 0.20435609f, -0.25851515f, 0.05962398f, -0.01466846f, -0.10984480f, -0.00014302f, 0.02094639f, 
    -0.03248335f, -0.10826250f, 0.13343048f, 0.05579953f, -0.29705647f, -0.11187113f, 0.25186518f, -0.05430955f, 
    0.09633753f, 0.06657752f, 0.02445849f, -0.06284323f, -0.34557122f, 0.00485617f, -0.13552879f, -0.04680987f, 
    -0.22798114f, -0.11678293f, 0.03374000f, -0.09860144f, 0.11537707f, -0.05493294f, -0.00851459f, -0.59004408f, 
    0.04882208f, -0.00092768f, 0.09065738f, -0.06823272f, 0.48813879f, 0.53571808f, 0.41026187f, 0.43682805f, 
    0.14069729f, -0.07289014f, -0.24990802f, 0.23943235f, 0.10382579f, 0.04906929f, 0.01966868f, -0.11294945f, 
    0.24414298f, -0.10597008f, 0.87892568f, 0.24849392f, -0.04964683f, 0.22089653f, -0.07222324f, 0.01505429f, 
    0.09609859f, 0.03794070f, -0.00803823f, 0.03087692f, -0.05373354f, 0.09811161f, 0.04606979f, -0.24848959f, 
    -0.00113275f, -0.04963071f, 0.01714426f, 0.03895558f, 0.04920843f, 0.05939883f, -0.04660555f, -0.02802836f, 
    -0.28158131f, 0.25529346f, -0.03074437f, -0.13339731f, -0.01639767f, -0.08428029f, -0.01162066f, 0.08210064f, 
    0.02796239f, 0.03208289f, 0.14428258f, 0.11445405f, -0.35913157f, -0.13995084f, -0.48689136f, -0.10540668f, 
    0.14420506f, 0.14132175f, -0.09469641f, 0.06591676f, -0.04214275f, -0.06881527f, -0.00908278f, 0.05169575f, 
    -0.00135516f, -0.54601073f, -0.00099359f, -0.36595151f, 0.00137866f, 0.03777773f, -0.00809646f, 0.03396772f, 
    -0.02607985f, -0.01642467f, 0.03964022f, 0.10866805f, -0.88021260f, -0.30121720f, 0.06680217f, 0.19220334f, 
    -0.13978471f, -0.14820632f, 0.04418022f, -0.00899736f, 0.02804345f, -0.08427543f, -0.02432339f, -0.10407501f, 
    -0.33497825f, -0.25639212f, 0.14745294f, -0.05370132f, -0.04207668f, -0.18486428f, 0.01367021f, 0.09261175f, 
    0.00957281f, 0.00965997f, 0.01664555f, -0.00975422f, -0.22047020f, -0.04155610f, 0.25542641f, -0.52312946f, 
    -0.07753903f, 0.08630915f, -0.01484766f, -0.07658830f, -0.04513782f, -0.14157878f, -0.14729819f, -0.06474964f, 
    -0.35244039f, 0.06942693f, -0.00480004f, -0.14198232f, -0.45757258f, -0.33363563f, -0.44111222f, -0.22080854f, 
    -0.03910417f, 0.02746810f, -0.12022271f, 0.11036953f, -0.92168403f, -0.61783159f, -0.07086150f, -0.41076595f, 
    -0.04059651f, -0.08889424f, 0.17498973f, -0.06646451f, 0.00987708f, -0.05930693f, -0.02269450f, -0.04479880f, 
    0.02052778f, 0.01532712f, 0.04841725f, 0.05269805f, -0.18146834f, -0.01952785f, -0.07041539f, 0.24164635f, 
    -0.05180953f, -0.01426245f, 0.02692018f, -0.05701552f, -0.01229102f, -0.01257181f, -0.11160188f, 0.02747556f, 
    -0.22923489f, -0.23832107f, 0.02168106f, -0.16078673f, -0.00967141f, 0.05870123f, -0.11378495f, -0.04931351f, 
    -1.14539003f, 0.09895062f, 0.24265473f, -0.63733131f, -0.05037607f, 0.10442916f, 0.03262822f, 0.03104466f, 
    0.00313591f, 0.04215303f, -0.06891764f, -0.04897542f, 0.02195056f, 0.04178159f, -0.38744733f, -0.31603104f, 
    0.02897644f, -0.13653499f, 0.02789844f, 0.14721197f, -0.12454451f, -0.01734686f, 0.07467947f, -0.18737160f, 
    0.40069848f, 0.09274229f, 0.18429887f, 0.17826246f, -0.07668705f, -0.00179648f, 0.21736392f, 0.07206220f, 
    -0.02487427f, 0.03875963f, 0.00753264f, -0.00762541f, -0.12502091f, 0.29739302f, 0.11100474f, 0.09619144f, 
    -0.07923628f, 0.03499960f, 0.17114230f, -0.17071733f, 0.00440749f, 0.00843953f, 0.04113347f, 0.19157924f, 
    0.26226705f, 0.00854268f, 0.24128331f, 0.33122239f, 0.08753923f, -0.02653144f, -0.01784000f, 0.06052584f, 
    0.11824102f, -0.01228629f, 0.02086845f, 0.08791356f, 0.29783732f, -0.16248958f, 0.10935485f, -0.03521449f, 
    0.11584175f, -0.03512106f, -0.08334756f, -0.00445768f, 0.00900317f, 0.31086028f, 0.11157258f, 0.11312702f, 
    -0.17431524f, 0.43118876f, -0.11753307f, 0.02612669f, 0.07023919f, -0.05210766f, -0.07873334f, 0.02571811f, 
    0.02294887f, 0.08510762f, -0.01384550f, 0.01239603f, -0.13438134f, -0.08478811f, -0.00857050f, 0.02990132f, 
    -0.03390503f, 0.15427683f, 0.07372873f, -0.01941542f, 0.00549356f, 0.05453373f, 0.01120850f, -0.00813310f, 
    -0.63129109f, 0.10041760f, -0.17312892f, -0.00026030f, -0.07950529f, -0.12347915f, -0.12825286f, -0.10889529f, 
    -0.14870800f, 0.02337399f, -0.00556753f, -0.05114891f, -0.12289710f, 0.08089574f, 0.00707192f, -0.10486571f, 
    -0.09310409f, -0.04543101f, -0.00790966f, -0.10686105f, -0.20110683f, -0.06393970f, -0.10578492f, -0.02291762f, 
    -0.14527984f, 0.11593588f, 0.00653451f, -0.15154840f, -0.06513412f, 0.14253584f, 0.12051358f, 0.02392120f, 
    0.23367180f, 0.28070810f, -0.22586341f, -0.14745966f, -0.44154236f, -0.10013983f, 0.07267744f, 0.41760409f, 
    0.02826117f, 0.11097700f, 0.36777890f, -0.05318778f, -0.08433450f, 0.20793442f, -0.13918771f, -0.09858233f, 
    -0.23391163f, -0.26333022f, -0.29316136f, -0.02785554f, 0.11042901f, 0.06739808f, -0.04410012f, -0.03520449f, 
    0.03143078f, -0.14625937f, -0.11416699f, 0.14767221f, 0.06337095f, 0.60637450f, -0.20582026f, -0.63967699f, 
    0.01752506f, -0.05940512f, -0.13711067f, 0.03244196f, -0.38738185f, 0.10600340f, -0.17579190f, 0.02335973f, 
    -0.09552811f, 0.30080578f, 0.27030420f, 0.07712249f, 0.03300582f, 0.10984428f, -0.07648753f, 0.03555052f, 
    0.00594991f, 0.11145829f, 0.00416161f, 0.26553643f, 0.01759432f, 0.34674665f, -0.35877183f, -0.03199859f, 
    0.18657303f, -0.10012718f, -0.04722761f, -0.10463296f, -0.18133138f, 0.04619159f, 0.11045925f, 0.10258480f, 
    -0.56551284f, -0.15353031f, -0.48981872f, 0.22234969f, -0.10523211f, -0.00069412f, 0.06624680f, -0.11742894f, 
    -0.17090929f, -0.01370781f, 0.21791443f, 0.16406734f, 0.17877445f, -0.07682217f, -0.18346758f, -0.21761586f, 
    0.26150164f, -0.17699598f, -0.18689565f, -0.15050168f, 0.18975291f, 0.09319761f, 0.09793049f, -0.12430510f, 
    0.08421319f, -0.32022813f, 0.17955533f, 0.01173405f, -0.09041555f, -0.02872704f, 0.06973806f, 0.04795179f, 
    0.17142943f, 0.10153157f, -0.13969751f, -0.00793359f, -0.08937023f, -0.19668438f, -0.03040777f, 0.21683562f, 
    0.18116054f, -0.07779930f, -0.00960634f, -0.14440811f, -0.04898968f, 0.09272513f, -0.00871303f, -0.01703353f, 
    -0.38089353f, -0.06614799f, -0.21835506f, 0.30539200f, 0.00659299f, -0.03536154f, 0.04739727f, -0.21227972f, 
    -0.09548558f, 0.01216363f, -0.08239959f, 0.10190758f, -0.65966922f, -0.03510536f, 0.31834313f, -0.14820957f, 
    -0.38594797f, -0.14079231f, -0.33608526f, -0.05864366f, -0.04193218f, 0.09775025f, -0.17647332f, -0.14633006f, 
    -0.58111739f, 0.04137753f, -0.07764533f, -0.22347330f, 0.02646996f, 0.05450532f, 0.00608840f, -0.22764213f, 
    -0.06628074f, 0.19223122f, -0.04069871f, 0.14765333f, 0.08143213f, -0.10122380f, 0.04011467f, 0.22693263f, 
    0.07038324f, -0.00932809f, 0.08678698f, 0.08602083f, -0.12231756f, 0.09903000f, -0.17973095f, -0.01387755f, 
    0.59531152f, -0.33423027f, 0.38203928f, -0.40615866f, -0.51415050f, 0.03920212f, -0.24850686f, 0.17087853f, 
    0.21240170f, 0.10097321f, 0.24783282f, -0.09758979f, -0.02405014f, -0.14118971f, -0.20198622f, 0.12054814f, 
    0.13055420f, -0.01581419f, 0.03410555f, -0.00313839f, -0.03859308f, 0.03852523f, 0.03152756f, -0.00212397f, 
    0.00428419f, -0.06984150f, -0.01727722f, 0.25631711f, -0.01959959f, 0.00315800f, 0.00918629f, 0.05874941f, 
    -0.01845880f, 0.01901831f, -0.11463332f, 0.09588315f, 0.13674213f, 0.04813234f, 0.14943703f, 0.44706187f, 
    0.03057304f, -0.15808275f, 0.00357185f, -0.02219410f, 0.03562433f, 0.15222582f, 0.18341130f, 0.01993678f, 
    -0.06810091f, -0.12494936f, 0.23853430f, 0.55121613f, 0.14722513f, -0.09203769f, 0.10811109f, 0.11053207f, 
    0.06582683f, 0.11025625f, -0.01419416f, 0.23716208f, -0.08024886f, -0.35884807f, -0.08197292f, 0.38898259f, 
    0.02340828f, 0.09924617f, -0.11456384f, 0.06789952f, 0.02911174f, 0.04894700f, -0.10613113f, -0.03171893f, 
    0.20459469f, 0.13970938f, 0.22994290f, 0.12860854f, -0.20743960f, 0.01014829f, -0.12222156f, -0.32854533f, 
    -0.20623669f, -0.24858688f, -0.02111538f, -0.01958883f, -0.24988693f, -0.04339621f, -0.18691498f, -0.07595351f, 
    0.04380514f, -0.09402356f, -0.06614365f, -0.26143283f, -0.00968866f, -0.03702734f, -0.06864510f, -0.11305173f, 
    -0.30095252f, -0.31240422f, 0.35682696f, 0.01347757f, -0.10793360f, -0.01608886f, -0.03726498f, -0.01749940f, 
    0.06525169f, -0.12494373f, 0.13840668f, 0.05098460f, -0.74643606f, 0.71014214f, -0.46233320f, -0.79554516f, 
    0.09812132f, 0.37680206f, -0.13529955f, -0.13860033f, -0.01786245f, -0.08710513f, 0.06575201f, 0.02660012f, 
    0.01708358f, 0.32246429f, 0.20426333f, 0.32727841f, 0.11687395f, -0.11203631f, -0.13710402f, -0.15401839f, 
    0.04127166f, 0.10096429f, -0.11044253f, -0.18630636f, -0.33293241f, -0.06499912f, -0.04776727f, 0.33096525f, 
    0.02532851f, 0.10118732f, -0.04338037f, 0.07129107f, 0.05950543f, 0.02004234f, 0.17391936f, 0.22581862f, 
    1.01369023f, -0.13076682f, -0.08122247f, -0.06060043f, 0.22047620f, 0.15967652f, 0.21914446f, -0.20609540f, 
    -0.20798932f, -0.16971557f, -0.02051678f, 0.01566467f, 0.42901999f, -0.11118693f, 0.03913857f, 0.19023825f, 
    0.05017126f, -0.21758881f, -0.07088102f, 0.00015837f, -0.05359625f, -0.01787391f, -0.08171608f, -0.05437186f, 
    -0.88091987f, 0.98479104f, 0.08799329f, -0.12425132f, 0.14950672f, 0.28385904f, -0.10406850f, 0.26751181f, 
    -0.24906473f, -0.17046645f, 0.07708512f, -0.11146408f, 0.26716954f, -0.00544958f, 0.02212777f, -0.13321403f, 
    -0.30191070f, -0.00148894f, -0.06459510f, -0.10066476f, 0.01154666f, 0.00534656f, -0.03640317f, -0.04443000f, 
    -0.43362063f, -0.44325808f, -0.74598312f, -0.33269575f, 0.05227168f, -0.01113806f, 0.04869419f, 0.12502179f, 
    0.05880545f, -0.01362474f, -0.10668614f, -0.06082210f, 0.13103023f, -0.02324775f, 0.06689858f, -0.05326959f, 
    -0.00016495f, -0.13704336f, 0.27116424f, -0.22161798f, -0.06117875f, -0.03617755f, -0.12598026f, -0.42177969f, 
    -0.00633030f, 0.00414645f, -0.08542069f, 0.02614290f, 0.02575654f, -0.02410875f, 0.06323719f, 0.08156687f, 
    0.00561299f, 0.03465998f, 0.03101783f, 0.11586142f, 0.33758113f, 0.34219041f, 0.22709492f, -0.07280727f, 
    0.26989195f, 0.11493520f, -0.00733015f, 0.05929593f, 0.11079878f, -0.18602476f, 0.15718570f, -0.08577815f, 
    0.00220067f, 0.09189668f, 0.04771903f, 0.04992568f, 0.12597533f, -0.04828333f, -0.10093300f, -0.20454428f, 
    -0.11313795f, -0.07954454f, -0.05755525f, 0.00753506f, 0.08062060f, -0.79718542f, -0.01356187f, 0.20390040f, 
    -0.16086599f, -0.02053555f, -0.04345138f, -0.38712502f, -0.07044920f, 0.04827547f, -0.16256517f, -0.07855812f, 
    0.44170782f, -0.06491289f, -0.04953448f, 0.40420818f, -0.11906994f, -0.21109553f, 0.18509251f, -0.05733172f, 
    0.15205322f, 0.00903290f, 0.04418205f, -0.05486671f, -0.17611125f, -0.21665743f, 0.10450339f, -0.02535544f, 
    -0.24797863f, 0.10207091f, -0.26535296f, -0.09480741f, -0.13037886f, -0.08650606f, 0.10048513f, 0.00161896f, 
    0.08576457f, -0.02362823f, 0.09235568f, -0.02912810f, 0.15282255f, 0.00009304f, 0.01824923f, 0.03980864f, 
    0.15966880f, -0.04832358f, -0.25230262f, 0.06047725f, 0.10581744f, -0.02032300f, -0.09615106f, 0.15367658f, 
    -0.12335464f, -0.11352494f, -0.14750232f, -0.15074623f, -0.12274787f, -0.26295784f, -0.23853570f, -0.13167432f, 
    0.12076250f, 0.28941503f, 0.06109633f, 0.27608424f, 0.06810003f, 0.13872589f, -0.21669206f, 0.10107615f, 
    -0.01878306f, -0.09928679f, 0.02417568f, -0.03410236f, 0.13323048f, 0.18800722f, 0.14284092f, 0.21004684f, 
    -0.11539555f, -0.10124856f, -0.04331725f, -0.08321882f, -0.08264719f, -0.06528620f, -0.06876536f, 0.02141411f, 
    -0.12962343f, 0.20674250f, 0.13777600f, 0.08177541f, -0.18597685f, 0.08138740f, -0.11595402f, -0.20863006f, 
    -0.01277763f, -0.00349455f, -0.00298330f, 0.09814770f, -0.26406008f, -0.48626214f, -0.49181113f, -0.21506177f, 
    0.13203217f, 0.06465285f, 0.07226329f, -0.19295858f, 0.04327872f, -0.04250863f, 0.05153128f, 0.06287322f, 
    0.05679639f, -0.32259652f, -0.27198738f, 0.03722917f, -0.06129336f, -0.04741841f, -0.11142746f, 0.10898399f, 
    -0.09600507f, -0.18661928f, -0.19447842f, -0.08119269f, 0.02011553f, 0.17332605f, 0.20370126f, 0.18062538f, 
    -0.03599840f, 0.16100655f, 0.10734647f, -0.06063643f, -0.04395939f, -0.09019688f, 0.04689494f, 0.04351870f, 
    0.22776437f, -0.09495120f, -0.13499145f, 0.18833892f, 0.07741716f, 0.05399539f, 0.06422502f, -0.11187365f, 
    0.09121097f, -0.09747265f, 0.04888527f, 0.02326793f, -0.18118326f, -0.07264522f, 0.00243859f, -0.02144284f, 
    -0.08215789f, 0.12619835f, -0.04423325f, 0.14752360f, -0.03896878f, 0.02790798f, -0.01251492f, 0.13999070f, 
    -0.14035361f, 0.04168599f, 0.17799297f, 0.14330903f, -0.06346929f, -0.10165798f, -0.17491411f, -0.02508613f, 
    -0.00194194f, 0.05445111f, -0.06414574f, -0.06441551f, -0.04516927f, 0.13502640f, -0.04357230f, 0.18010934f, 
    0.17284204f, -0.08904909f, -0.11713669f, -0.11369789f, -0.02534866f, -0.11075180f, -0.03067131f, -0.07626579f, 
    0.24866153f, 0.30050600f, 0.29221743f, 0.15229470f, -0.19340259f, 0.32297567f, 0.24075988f, 0.09641566f, 
    0.06268569f, 0.00050329f, 0.10191806f, 0.04189216f, 0.24773310f, 0.41638997f, 0.20202881f, 0.11921087f, 
    -0.09394320f, -0.06544359f, 0.06665877f, 0.34435606f, 0.00410027f, 0.01222841f, 0.03023971f, -0.03493601f, 
    -0.00673065f, -0.07844213f, -0.11113332f, 0.03569752f, 0.06412885f, -0.04337935f, -0.07377903f, 0.13359351f, 
    0.06795362f, -0.07197422f, -0.17862242f, -0.13847713f, 0.10472161f, -0.09928781f, 0.05181790f, -0.01502917f, 
    -0.07352117f, 0.01160828f, 0.07771669f, 0.12295452f, -0.16944613f, -0.12962292f, -0.01548443f, -0.07699215f, 
    -0.40885490f, 0.10768755f, 0.03921032f, 0.61100560f, -0.07502024f, -0.09927212f, 0.06582746f, 0.16093960f, 
    0.00155922f, 0.01761773f, -0.00174837f, -0.01445101f, 0.33931276f, -0.01423931f, 0.06989221f, 0.06901985f, 
    0.13572633f, 0.07818880f, -0.01724357f, -0.11306884f, -0.17417859f, 0.11794385f, -0.08643507f, 0.06710890f, 
    -0.02921249f, -0.10567151f, -0.10752517f, -0.16324857f, -0.39830691f, -0.30106238f, -0.04475361f, -0.31810492f, 
    0.03618321f, 0.01976170f, 0.00933861f, 0.05672443f, -0.11664017f, -0.01048677f, 0.16872673f, 0.07502993f, 
    0.00913453f, -0.04586502f, 0.02071478f, -0.17186339f, 0.23909135f, 0.09566969f, 0.06331959f, 0.07935148f, 
    -0.13438460f, 0.12426005f, -0.14121826f, 0.16251524f, -0.12525968f, -0.11548572f, 0.02552471f, -0.10323703f, 
    0.23594587f, -0.07324611f, -0.09109885f, -0.05379527f, 0.08653674f, -0.05951105f, -0.18904252f, 0.12242359f, 
    0.07691403f, -0.10372144f, 0.01770748f, -0.15213634f, 0.15308827f, 0.10754172f, 0.18989052f, 0.28834710f, 
    -0.02515136f, -0.96846455f, 0.03144931f, -0.11302298f, 0.02372489f, 0.01900629f, 0.05361992f, -0.21820934f, 
    -0.01248647f, 0.03301156f, -0.01157332f, 0.04101844f, 0.38525325f, -0.30352041f, -0.22056952f, 0.23339888f, 
    -0.13113068f, -0.05083508f, -0.03348959f, 0.01521748f, 0.09321889f, -0.05746726f, 0.04234247f, -0.00381464f, 
    0.60427731f, -0.11551245f, -0.64258939f, 0.23844618f, -0.01840536f, -0.00047432f, -0.07431152f, 0.00298207f, 
    0.17111151f, 0.04696826f, -0.05013228f, 0.07007150f, -0.00017726f, -0.08989496f, -0.04283954f, -0.07782953f, 
    0.11001422f, -0.00098478f, -0.14127500f, 0.09819723f, 0.01381992f, -0.11194364f, 0.36285642f, 0.27067035f, 
    -0.00190701f, -0.23695767f, -0.14587267f, 0.06924700f, 0.00585992f, -0.01994019f, -0.05415908f, 0.07616020f, 
    -0.09315943f, -0.21960907f, 0.10944453f, -0.07855058f, 0.04507218f, 0.19408886f, 0.11000212f, -0.26346090f, 
    -0.08722552f, -0.15279657f, -0.37931013f, -0.22524212f, -0.17818226f, -0.10141792f, -0.01424361f, -0.13222264f, 
    0.07230064f, -0.25287926f, 0.06746923f, 0.08730601f, -0.18273526f, -0.14432080f, 0.21064875f, 0.09804800f, 
    0.12943646f, 0.15491652f, 0.00518711f, -0.11374751f, 0.29173696f, -0.31779864f, 0.47539020f, 0.18541326f, 
    -0.17568034f, 0.10140181f, -0.07589334f, -0.08814805f, 0.14146015f, -0.06892819f, 0.10323843f, 0.06452928f, 
    -0.15951088f, -0.03015097f, 0.01235674f, -0.09125608f, 0.10957653f, -0.15933317f, -0.20805661f, 0.13419767f, 
    -0.08884294f, -0.15559795f, 0.00493200f, -0.30649036f, -0.16842394f, 0.11815958f, 0.35486868f, -0.44972816f, 
    -0.14460298f, -0.24747603f, 0.08052637f, 0.13589619f, -0.14558175f, -0.13046838f, -0.26545039f, 0.06720342f, 
    -0.22345604f, -0.06342535f, -0.01181578f, -0.13762200f, 0.06178010f, -0.07115638f, -0.09472749f, -0.00653663f, 
    -0.06197162f, 0.07021196f, -0.06517259f, -0.06786027f, -0.04510195f, -0.00661596f, -0.08420755f, -0.14442545f, 
    -0.27873570f, -0.00126924f, 0.06820115f, -0.03938167f, 0.17295323f, -0.01943821f, 0.09799617f, 0.16697930f, 
    0.07672644f, -0.00767258f, -0.24583443f, 0.12082136f, -0.06559429f, 0.10851718f, 0.04329406f, 0.17638986f, 
    0.00391728f, -0.02095165f, 0.16588765f, -0.09256207f, -0.29082775f, -0.11676942f, -0.02325441f, -0.10792940f, 
    0.05555275f, 0.16307843f, -0.07276971f, -0.06750831f, 0.03285954f, 0.10107972f, 0.18337750f, -0.08561533f, 
    0.06088363f, 0.14021486f, -0.08358063f, -0.35327101f, -0.00702685f, -0.15476930f, 0.05799349f, 0.26295406f, 
    0.03361620f, -0.09393404f, -0.20025153f, 0.05834425f, -0.21797407f, -0.00306540f, -0.64587194f, 0.23248594f, 
    0.11032628f, 0.03863831f, 0.06724712f, -0.02385829f, 0.12132165f, -0.13806397f, -0.02586671f, 0.05451592f, 
    -0.21126159f, -0.10404281f, 0.14729117f, -0.16123010f, 0.09365433f, 0.03434236f, 0.12906647f, 0.03639638f, 
    0.07116948f, 0.09226362f, 0.14625537f, -0.08016672f, 0.09108335f, 0.20415673f, 0.37031788f, 0.10421867f, 
    0.01283113f, 0.10528948f, 0.13366455f, 0.15710740f, 0.15993032f, -0.06184656f, 0.11852989f, 0.04931646f, 
    -0.71945888f, 0.12188179f, -0.11614364f, 0.35535094f, 0.06102675f, 0.12178711f, 0.24175142f, -0.09633522f, 
    0.00100965f, 0.06192936f, -0.09493134f, -0.06621889f, -0.06068058f, 0.07188642f, 0.11604735f, -0.26304707f, 
    0.14340165f, -0.29454839f, -0.19015823f, -0.16768581f, 0.05046963f, -0.02043671f, -0.02205452f, 0.13093188f, 
    -0.08171030f, 0.18881784f, 0.16836727f, -0.15634033f, 0.21026017f, 0.05827155f, 0.12543739f, 0.26197711f, 
    -0.05541853f, 0.08487349f, 0.16655098f, 0.12889946f, 0.14755313f, 0.10868555f, -0.23675433f, -0.30380860f, 
    0.21197695f, 0.13680166f, -0.15382279f, -0.11297852f, 0.24778379f, 0.10002454f, 0.11971216f, 0.08746180f, 
    -0.19818206f, -0.37769797f, 0.06498520f, 0.02942229f, 0.35379890f, 0.05804233f, -0.10388585f, -0.00716048f, 
    -0.00270511f, -0.17581062f, -0.02712941f, -0.21223503f, -0.08420301f, 0.24772751f, -0.02763065f, -0.28894436f, 
    0.31579563f, 0.13339312f, 0.02603328f, -0.23722538f, 0.02699804f, -0.04860551f, 0.03500160f, 0.05759051f, 
    -0.10725922f, 0.11132316f, -0.26444334f, 0.06946332f, 0.21095091f, -0.18817803f, -0.16380215f, 0.20936868f, 
    0.03430707f, 0.08669420f, 0.13944352f, 0.18371576f, -0.30783656f, -0.10458410f, 0.04835159f, 0.01533573f, 
    -0.06343653f, 0.03017168f, -0.18099542f, 0.02852310f, 0.04999865f, 0.07276955f, 0.01812149f, 0.13380259f, 
    0.28409901f, -0.32594424f, -0.24860375f, 0.11300001f, 0.28702614f, 0.13985088f, -0.02624082f, 0.07880315f, 
    -0.05682100f, 0.00593279f, -0.06522222f, 0.02538729f, -0.46080142f, 0.01952432f, -0.21156386f, 0.04983159f, 
    0.00154762f, -0.08826904f, -0.08277949f, 0.16767336f, 0.23998789f, -0.00949321f, -0.15328352f, -0.20620587f, 
    0.20967060f, -0.24788085f, -0.33381465f, 0.15021357f, 0.12637949f, 0.08281562f, 0.07615165f, 0.18785848f, 
    0.09516713f, 0.13732274f, -0.01922601f, -0.07338396f, 0.29615647f, -0.06891785f, -0.23317203f, -0.16805537f, 
    0.02081145f, -0.01979165f, -0.04858424f, 0.06476461f, -0.20281909f, -0.18069363f, 0.02776923f, -0.23419961f, 
    -1.22303462f, -0.43689069f, -0.11821026f, -0.22259302f, -0.00181704f, -0.02936892f, 0.02401101f, 0.02190755f, 
    0.09167861f, -0.05665182f, 0.05338927f, 0.02215021f, -0.32705253f, 0.50944877f, -0.48307103f, 0.15520346f, 
    0.02535527f, -0.05380732f, -0.00789918f, 0.03716149f, 0.30755204f, -0.14736526f, 0.00597921f, -0.08246343f, 
    -0.03238926f, -0.18013845f, -0.11764685f, 0.01868690f, -0.06874610f, -0.04312882f, -0.00936421f, 0.08226178f, 
    0.01398019f, -0.03244838f, -0.33006561f, -0.07999992f, 0.05988153f, 0.01696997f, 0.18510456f, 0.37660074f, 
    0.01261942f, -0.16760077f, -0.07857519f, 0.23702362f, -0.00985343f, 0.05938836f, -0.02285081f, -0.10060528f, 
    0.15362090f, -0.04533788f, -0.40524092f, 0.24711010f, -0.04832860f, 0.01807720f, 0.01839104f, -0.02499540f, 
    -0.01311034f, 0.13870397f, -0.00150930f, -0.20061877f, -0.02273343f, 0.03517506f, 0.06367936f, -0.08659432f, 
    0.19855754f, 0.04195090f, 0.02559601f, -0.29179263f, -0.06050528f, -0.13162278f, 0.03229372f, -0.06864430f, 
    0.03637023f, 0.06375316f, 0.01232985f, -0.02673825f, -0.01977118f, 0.02146087f, 0.07341665f, 0.13859583f, 
    -0.02773117f, 0.16259421f, 0.08897648f, 0.16389732f, -0.38451272f, -0.18764240f, 0.26880822f, -0.00676752f, 
    0.16471957f, 0.14352158f, 0.09066718f, -0.30358818f, 0.05188764f, 0.04981291f, -0.08742380f, 0.05873186f, 
    -0.17425050f, -0.20307939f, 0.01207658f, 0.23862803f, -0.07665082f, 0.25614119f, -0.18056987f, -0.02570097f, 
    0.08953207f, -0.08034609f, 0.00141357f, 0.20573914f, -0.30760932f, -0.34152877f, 0.07402758f, 0.22198595f, 
    -0.11505780f, -0.02965943f, -0.07918177f, -0.07949186f, 0.02168598f, 0.07145658f, 0.01003772f, -0.02931196f, 
    -0.14460416f, -0.32528034f, 0.03411522f, -0.14252070f, -0.04501967f, 0.33200249f, 0.11685944f, 0.03600296f, 
    0.07105604f, 0.21375689f, -0.06533447f, 0.03230925f, -0.12449665f, -0.18336907f, 0.37064317f, -0.28947631f, 
    -0.03761902f, -0.17539984f, 0.24426249f, 0.08995656f, 0.00475474f, 0.15154339f, 0.11428008f, 0.07598517f, 
    -0.05006536f, 0.04295612f, 0.07447881f, -0.00513009f, 0.15718433f, 0.16773415f, 0.03596181f, -0.02574502f, 
    0.02032662f, -0.02508073f, -0.11148450f, -0.23653883f, -0.39528987f, 0.13691907f, 0.58166903f, 0.29957274f, 
    -0.05207630f, -0.21117494f, -0.13455398f, 0.19610374f, -0.12751029f, 0.04527943f, 0.20228535f, 0.06645532f, 
    0.26467839f, -0.13641712f, -0.37098646f, -0.32400560f, -0.15111068f, 0.05825456f, 0.21858324f, 0.02158930f, 
    0.16755304f, -0.00698087f, -0.14160156f, 0.02776272f, -0.72350830f, 0.10207767f, 0.75410062f, 0.79625481f, 
    -0.07829604f, -0.07663114f, 0.18541451f, -0.24355567f, -0.13537897f, 0.13950025f, -0.10940981f, 0.11987744f, 
    -0.52448332f, 0.54941052f, -0.29820019f, -0.29653668f, 0.05510157f, -0.19633865f, 0.39689595f, 0.28232625f, 
    0.03193972f, 0.03712035f, 0.14159094f, 0.06529699f, 0.03498155f, 0.09958739f, 0.24463421f, -0.07034311f, 
    0.07061393f, 0.07890107f, 0.00385861f, -0.04266430f, -0.05401528f, -0.07996504f, 0.05348410f, 0.10178273f, 
    -0.21356370f, 0.05035304f, 0.03815537f, 0.19341180f, 0.17361514f, 0.13006566f, 0.09188874f, 0.17509556f, 
    0.17957729f, 0.07982600f, 0.20460750f, -0.01735481f, -1.03809392f, -1.03052115f, -0.38516989f, -0.53052020f, 
    -0.29942423f, -0.16687481f, -0.03015403f, -0.41965947f, -0.13519198f, -0.01278377f, -0.08975541f, -0.22435434f, 
    0.13072212f, 0.01136229f, -0.05089189f, -0.34378925f, 0.01203008f, 0.21335906f, -0.05982213f, -0.00567944f, 
    -0.13583390f, 0.01949636f, 0.06863371f, -0.03588610f, -0.41858178f, -0.61899436f, -0.72913188f, -0.09940168f, 
    -0.31102961f, 0.01582433f, -0.00596812f, -0.27564806f, -0.05544617f, 0.01707689f, -0.05913842f, 0.10733067f, 
    -0.59810698f, -0.58306175f, -0.22413062f, 0.50210971f, -0.09460738f, -0.00188407f, -0.12759525f, -0.11270506f, 
    0.01201420f, 0.00297882f, 0.01764748f, -0.00944967f, -0.49565646f, -0.38273051f, 0.25158966f, -0.50991970f, 
    0.13525702f, -0.50467283f, 0.01625132f, 0.09740995f, 0.00655074f, 0.06120611f, -0.06933664f, -0.15948732f, 
    -0.21266802f, -0.42442486f, -0.29859412f, 0.10731614f, -0.02782756f, 0.17150763f, 0.10544477f, -0.34437892f, 
    -0.00697482f, -0.16109791f, -0.01079843f, 0.13339737f, -1.08507276f, -0.91380793f, -0.42837024f, -0.25960988f, 
    -0.14057334f, -0.43041432f, -0.46513417f, -0.42317587f, -0.00384678f, 0.05953977f, -0.00387023f, -0.00920830f, 
    -0.04181292f, -0.13547429f, -0.22119668f, -0.07950869f, -0.05306760f, 0.00796961f, 0.14348260f, -0.17986442f, 
    -0.07197087f, -0.05140561f, -0.15086086f, 0.02059817f, -0.04845546f, -0.01025061f, 0.02872494f, 0.01018788f, 
    -0.15117031f, -0.29718506f, 0.01315553f, 0.19145927f, 0.04113261f, -0.11551647f, 0.04779742f, -0.19334559f, 
    0.39932856f, -0.50402838f, -0.13884464f, -0.17303856f, 0.09772824f, 0.10372488f, 0.23123208f, -0.04936597f, 
    -0.04610149f, -0.11107448f, -0.09003253f, 0.05717558f, -0.12762229f, -0.23621947f, -0.00184224f, 0.10773159f, 
    0.11901543f, 0.06914078f, -0.05453030f, -0.08649972f, 0.13387960f, -0.01071252f, 0.07957567f, 0.03153872f, 
    -0.44803512f, -0.41050065f, 0.08836331f, -0.01427987f, 0.03909784f, 0.03396480f, -0.19150387f, -0.36346495f, 
    -0.10294253f, -0.04180786f, 0.01407207f, -0.02006099f, 0.23764329f, 0.42740032f, -0.10080747f, -0.06736784f, 
    -0.05522761f, 0.00332332f, 0.00017069f, -0.04345905f, 0.15963036f, 0.12950398f, -0.03832395f, 0.13600622f, 
    -0.28770694f, -0.08520468f, 0.25712931f, 0.07151713f, 0.06871961f, 0.09570324f, -0.02632497f, 0.04474980f, 
    -0.05296265f, 0.08155013f, 0.11712102f, 0.00840724f, 0.24991493f, -0.32077748f, 0.38817543f, -0.06419706f, 
    0.02505399f, -0.02229471f, 0.10714227f, -0.05569882f, 0.17900823f, 0.20288061f, 0.13750251f, 0.24686298f, 
    -0.17008841f, -0.23339869f, -0.06670798f, 0.08107503f, 0.04318038f, 0.18340409f, -0.10815074f, -0.17840450f, 
    0.11057569f, 0.03084627f, 0.15265568f, -0.10431256f, -0.01979776f, -0.28886124f, -0.56845939f, 0.07337338f, 
    -0.16580340f, 0.25044471f, 0.09131085f, 0.10123732f, 0.08212525f, 0.04371042f, 0.04460794f, 0.08944125f, 
    -0.30533272f, -0.13615216f, 0.13245749f, -0.07507277f, 0.04684815f, 0.13970849f, 0.06860235f, -0.13757272f, 
    0.01522283f, 0.07009065f, 0.13750286f, -0.01186013f, 0.00078319f, 0.04628814f, 0.03754478f, -0.12900615f, 
    -0.00540931f, -0.17383584f, 0.00068102f, -0.02525129f, -0.05259238f, -0.01723147f, 0.10286508f, -0.13506064f, 
    0.14034358f, 0.05691158f, -0.00266185f, 0.00901012f, 0.00729201f, -0.08432659f, 0.01189458f, -0.12406889f, 
    -0.09635673f, -0.25327235f, -0.14345492f, -0.30727106f, -0.64759332f, 0.36809042f, 0.64748794f, -0.18122272f, 
    0.11761464f, 0.07643206f, 0.11226337f, 0.20585105f, -0.14072724f, -0.04533955f, -0.09893528f, -0.06862526f, 
    0.08537524f, -0.09402949f, 0.03529698f, -0.09974807f, -0.01632679f, 0.03515480f, 0.06497087f, 0.03162443f, 
    -0.05227501f, -0.01196367f, 0.12633333f, -0.07143367f, 0.54140562f, 0.02530295f, 0.25907609f, -0.26713413f, 
    -0.20224868f, 0.16952084f, -0.07621150f, 0.11698330f, -0.13195717f, 0.20059825f, -0.08758347f, -0.17612611f, 
    0.13220017f, 0.16084728f, -0.03709201f, -0.07895742f, -0.08246055f, -0.10673101f, 0.25376508f, 0.11808503f, 
    -0.08485398f, -0.05215726f, 0.16265351f, 0.05950387f, 0.72407526f, -0.34687856f, -0.16541658f, -0.50595522f, 
    0.13105823f, 0.01866204f, 0.08419441f, 0.19495584f, 0.03819956f, -0.21793869f, -0.07493816f, -0.09646488f, 
    -0.04684119f, 0.07521220f, 0.16496404f, -0.13607864f, 0.01353795f, -0.03190067f, -0.02307338f, 0.01436355f, 
    0.06480910f, -0.03427134f, -0.02974899f, -0.04145506f, 0.64534920f, -0.44046777f, -0.14908881f, -0.85464978f, 
    -0.13321705f, -0.02179244f, 0.04523570f, 0.05827358f, -0.07890685f, -0.10796518f, 0.01249566f, -0.12331062f, 
    -0.04078219f, 0.08556841f, -0.11447629f, 0.02720325f, -0.09765062f, 0.08666094f, -0.05963305f, 0.10940194f, 
    -0.11809269f, -0.03192345f, 0.05296304f, 0.01132613f, 0.00832064f, -0.77918702f, -0.60409391f, -0.54226649f, 
    -0.01131453f, -0.06735335f, -0.23915593f, 0.15672062f, 0.06433140f, -0.10028423f, 0.05593138f, 0.03304506f, 
    -0.78437597f, -0.67968982f, -0.53791618f, -0.79802340f, 0.01060955f, -0.18975309f, 0.23867197f, 0.08138075f, 
    0.01713750f, 0.14184120f, -0.05452604f, 0.05543105f, -0.19100663f, 0.20836312f, -0.06444079f, -0.07402550f, 
    -0.01381183f, -0.03156442f, -0.02039389f, -0.03460055f, 0.12805365f, -0.07372568f, -0.02665043f, -0.25165290f, 
    0.15732211f, -0.55659270f, 0.56363982f, -0.55074561f, -0.03412790f, 0.03897338f, -0.08903518f, -0.00998820f, 
    -0.05354909f, 0.08510219f, -0.17959628f, -0.06372609f, -0.36787024f, -0.69702548f, 0.35606360f, 1.00884521f, 
    -0.09127130f, -0.10153013f, -0.17325100f, -0.01094868f, 0.03266735f, -0.02428798f, -0.05808827f, -0.04260668f, 
    -0.05523210f, 0.20819306f, -0.08205803f, 0.10858683f, -0.06607077f, 0.07417725f, -0.06442221f, -0.11722034f, 
    0.00824199f, -0.01146709f, 0.00260317f, -0.00869981f, -0.32702628f, -0.22366861f, -0.15596785f, -0.05576234f, 
    0.12878428f, -0.10684165f, 0.03168515f, 0.23734714f, -0.04284253f, -0.07695962f, -0.08816641f, 0.01523060f, 
    -0.24680994f, -0.39095965f, -0.07329694f, -0.26724085f, 0.06637797f, -0.05165164f, -0.14202173f, 0.12928915f, 
    0.00041889f, 0.02006391f, -0.04417763f, -0.01181705f, -0.60349268f, 0.51785922f, -0.13552061f, 0.35351697f, 
    0.02534709f, -0.13150498f, 0.18179695f, -0.03665367f, 0.00094440f, -0.12087766f, 0.03745436f, 0.03362225f, 
    0.03269519f, 0.06119582f, 0.11489297f, -0.08613896f, -0.04013402f, -0.23597121f, 0.17112371f, 0.27576730f, 
    0.06024854f, 0.03581763f, 0.00405786f, -0.08020872f, -0.49500874f, -0.39651683f, 0.05541538f, 0.26010939f, 
    0.19184527f, 0.04569595f, -0.05188042f, -0.01536045f, 0.02126937f, 0.02498214f, -0.05632455f, 0.00238636f, 
    -0.09090601f, 0.13964027f, -0.08934215f, -0.05948927f, 0.09031709f, 0.01087132f, -0.09782591f, -0.04876554f, 
    -0.13185440f, 0.00257708f, -0.04786581f, -0.00330519f, -0.00806798f, 0.08940661f, -0.12642038f, 0.00224923f, 
    0.02059920f, 0.04801355f, 0.20744741f, -0.11840743f, -0.00030222f, -0.01100443f, 0.04574121f, -0.01644197f, 
    -0.39381623f, 0.31300312f, -0.01047557f, -0.12431623f, -0.06475012f, -0.01088024f, -0.17360717f, 0.09323718f, 
    0.09409400f, 0.02472452f, 0.07754564f, -0.11453094f, 0.07141054f, 0.30015898f, 0.07577794f, -0.13840103f, 
    -0.00546087f, 0.01276149f, -0.03323608f, 0.08997123f, -0.06840186f, 0.11485586f, -0.11839460f, -0.31812984f, 
    0.22486302f, -0.05583419f, -0.24840148f, -0.25373417f, 0.12269635f, -0.20088807f, -0.25368175f, -0.08052308f, 
    0.06153052f, 0.01169068f, 0.06598899f, 0.02595978f, -0.51891732f, -0.37804976f, -0.28285998f, -0.04358039f, 
    0.00395017f, 0.00235717f, 0.18146466f, 0.06570204f, 0.02173275f, 0.20682499f, 0.07919145f, 0.04463117f, 
    0.63880324f, -0.30764723f, 0.23023997f, -0.39121160f, -0.04652702f, -0.11722903f, -0.16032605f, -0.06126367f, 
    0.12139970f, -0.15828685f, -0.11950106f, -0.21144767f, 0.07307750f, 0.29898900f, 0.00550023f, 0.23965815f, 
    0.05131456f, 0.07826411f, 0.11474005f, -0.00660912f, 0.02003850f, 0.12925369f, 0.07937615f, -0.03492713f, 
    0.15080670f, -0.21582197f, -0.03890716f, -0.23128052f, 0.01015339f, -0.10597893f, -0.01324737f, -0.02593536f, 
    -0.00787520f, 0.17699622f, 0.03630282f, -0.23348865f, 0.33624381f, -0.43946719f, -0.01487419f, 0.06858927f, 
    0.04863868f, 0.05748534f, -0.10218693f, -0.13239935f, -0.01514488f, 0.07340854f, 0.01674425f, 0.06056479f, 
    -0.42163175f, 0.20406270f, 0.19056229f, 0.13382542f, -0.11863098f, -0.10561650f, -0.11791980f, -0.11120337f, 
    0.03974179f, -0.05049183f, -0.00603320f, 0.20230100f, -0.27012742f, 0.10813097f, 0.04705785f, 0.05286112f, 
    -0.07122629f, 0.15009864f, 0.01249658f, 0.06479400f, 0.11480185f, 0.04319512f, -0.06707615f, 0.21956655f, 
    -0.12894632f, -0.18947817f, -0.13834083f, -0.14327522f, -0.04666151f, -0.04329248f, -0.05530332f, -0.09984975f, 
    -0.08986985f, 0.01594354f, -0.12913780f, -0.24244323f, -0.37332642f, 0.01808192f, -0.25263256f, 0.24312027f, 
    0.10807556f, 0.32173225f, -0.04848236f, -0.23435220f, 0.08612955f, 0.05918215f, 0.09761814f, 0.04640858f, 
    0.06768947f, 0.07695536f, 0.06265521f, -0.08018077f, -0.12994266f, -0.08055061f, -0.09154792f, -0.13326931f, 
    -0.07860816f, 0.12556106f, 0.19316135f, 0.14375405f, 0.50452662f, 0.07086336f, -0.29945937f, -0.51487106f, 
    0.29274365f, -0.29935864f, 0.06163450f, 0.04182136f, 0.11610559f, 0.16288728f, 0.17827760f, 0.32466781f, 
    0.05799732f, 0.11023389f, -0.09415395f, -0.09484495f, 0.03005381f, 0.17011359f, -0.01374634f, -0.14726442f, 
    -0.23372489f, 0.01964525f, -0.31962425f, -0.05884212f, 0.36371145f, 0.12480571f, -0.56498235f, -0.14477208f, 
    0.02417632f, -0.05493012f, 0.21145457f, 0.11027797f, -0.02085390f, 0.06090891f, -0.22821979f, -0.42289004f, 
    -0.21135493f, 0.02387360f, 0.03332957f, -0.27194250f, -0.07192758f, -0.07131867f, -0.01429398f, -0.05543192f, 
    0.07787478f, 0.03265771f, -0.01503624f, 0.08597757f, 0.06856462f, -0.47809136f, -0.29308388f, -0.00698703f, 
    0.06110287f, -0.01697580f, 0.12886786f, 0.25308108f, 0.15300706f, 0.06028061f, 0.25763705f, 0.22930698f, 
    -0.42721021f, -0.09753583f, 0.02910653f, 0.13641746f, 0.13025589f, -0.01099373f, -0.10495365f, -0.07573597f, 
    0.06329682f, -0.15829574f, 0.03524870f, -0.11958791f, -0.01301321f, -0.29123873f, -0.34130713f, 0.75574994f, 
    0.01117958f, 0.22315624f, 0.34445646f, 0.23383924f, -0.02513757f, -0.06782612f, 0.12493344f, 0.04791723f, 
    0.25824937f, -0.94124609f, -0.70594949f, 0.13237332f, -0.01335058f, 0.18290508f, 0.08180746f, -0.15700184f, 
    -0.03706105f, -0.16296846f, -0.00081989f, -0.05207639f, -0.40508571f, 0.00188020f, 0.18128568f, 0.01808555f, 
    -0.08451980f, 0.03781144f, -0.09180754f, -0.05544086f, -0.07585500f, 0.15845694f, -0.08806373f, 0.17645754f, 
    0.37452769f, -0.00094357f, -0.17328112f, -0.18230450f, 0.14583416f, -0.19166613f, 0.18404791f, -0.02925384f, 
    0.01658650f, -0.14710261f, 0.08495030f, -0.14018999f, 0.04867286f, -0.67817545f, -0.37338209f, -0.72644687f, 
    -0.24578060f, -0.21306942f, -0.22174773f, -0.04699669f, 0.10262568f, 0.19316678f, 0.04186125f, 0.08432732f, 
    -0.14232112f, 0.19886385f, 0.20351085f, -0.08898059f, 0.10286551f, -0.12826408f, -0.11247996f, 0.05624487f, 
    -0.18370849f, -0.03324092f, 0.06085235f, 0.14198804f, 0.35417795f, -0.23783037f, -0.48751900f, -0.55742091f, 
    -0.19350237f, -0.20564698f, -0.00764021f, -0.07107426f, 0.04730185f, -0.06686774f, -0.00494661f, -0.05728794f, 
    0.21235558f, 0.00094654f, -0.17576063f, -0.07161047f, -0.04310469f, 0.27493167f, 0.06927542f, -0.08270703f, 
    0.02375305f, -0.04708078f, -0.07675222f, -0.11397468f, -0.87909889f, -0.50830221f, 0.14809729f, 0.26808810f, 
    0.02311525f, 0.18878059f, 0.06567748f, -0.01498848f, 0.01577816f, 0.19531135f, 0.19388260f, 0.30942687f, 
    -0.28431571f, -0.07459207f, 0.06456111f, -0.08389431f, -0.05096046f, -0.12543619f, -0.24820569f, -0.30039915f, 
    -0.00462169f, -0.05884274f, -0.02289171f, -0.08572476f, -0.76444489f, -0.77283412f, -0.09578779f, 0.14093570f, 
    -0.01132891f, -0.14224941f, 0.01493427f, 0.05818242f, -0.05901650f, -0.00465933f, -0.01762873f, 0.09853197f, 
    -0.17014414f, 0.05358889f, 0.24935840f, 0.15026446f, -0.00422234f, 0.02276931f, 0.03212957f, 0.00466011f, 
    0.12814246f, 0.20688538f, 0.15530530f, -0.02864429f, -0.17735246f, -0.06313425f, -0.05898814f, -0.05926352f, 
    -0.04673060f, 0.01341204f, 0.05006579f, 0.05799329f, 0.28020215f, 0.03798396f, 0.15005739f, 0.23153707f, 
    -0.50601244f, 0.04934728f, 0.20362881f, 0.05328858f, 0.08680985f, -0.12424353f, 0.02585241f, -0.13668640f, 
    -0.07476172f, 0.06258499f, 0.11663202f, 0.03147551f, 0.00316947f, -0.12399194f, -0.20244351f, -0.35893622f, 
    -0.24446301f, -0.14737573f, 0.04131607f, -0.02283083f, -0.01722990f, -0.00802150f, 0.06737135f, 0.14244901f, 
    0.03700083f, -0.02872537f, -0.18781607f, -0.00467692f, 0.02176347f, 0.04690858f, 0.29113328f, 0.40304223f, 
    0.10994329f, -0.15239304f, -0.02945926f, 0.13302436f, -0.16439414f, -0.24443153f, -0.03461751f, 0.04291978f, 
    0.20429559f, 0.10626658f, -0.05188748f, 0.11087956f, -0.25850734f, -0.24740483f, -0.30783099f, -0.35825795f, 
    -0.25699168f, -0.12414230f, -0.20213474f, -0.02778246f, -0.02510929f, 0.02528489f, 0.15174782f, 0.08116225f, 
    0.06157651f, 0.30276126f, -0.02019579f, -0.07153245f, -0.29642808f, -0.01360715f, 0.10731369f, 0.10794661f, 
    -0.04569596f, 0.01425883f, -0.01588361f, 0.02966063f, -0.24460508f, 0.13650221f, -0.17675401f, -0.54368585f, 
    0.05308153f, 0.32774356f, -0.04262237f, -0.30991492f, -0.15076284f, -0.27635649f, -0.11138423f, -0.12156682f, 
    -0.03004031f, 0.00287505f, -0.14993498f, 0.13495186f, 0.59296960f, 0.26297495f, 0.02353928f, -0.09316190f, 
    0.28786844f, 0.11428992f, 0.11144256f, -0.01469371f, -0.07631974f, -0.09191034f, -0.04347448f, -0.07152076f, 
    -0.12754981f, -0.14014338f, -0.11443143f, -0.39187104f, 0.03408905f, -0.00357221f, 0.19143555f, -0.08345699f, 
    -0.01821899f, 0.02558395f, 0.01088123f, 0.08011379f, 0.14266895f, -0.20025714f, -0.03018595f, -0.18550001f, 
    0.12447520f, -0.05743878f, -0.00032133f, 0.17800811f, 0.09220808f, 0.02159446f, -0.35489482f, -0.10784711f, 
    -0.03585136f, -0.07327838f, 0.17770858f, 0.18984422f, 0.04967336f, 0.14895041f, 0.10673483f, -0.06343598f, 
    0.29150695f, 0.12437108f, 0.02446776f, 0.00583630f, 0.26084015f, -0.11383427f, -0.14702974f, -0.18846819f, 
    -0.07276694f, -0.00315881f, 0.20946713f, 0.24444887f, -0.09130120f, 0.05844359f, -0.01615773f, -0.03790303f, 
    0.28933012f, -0.13935314f, 0.10657934f, -0.05299247f, 0.28644839f, 0.14508997f, -0.20568042f, -0.12879953f, 
    0.13051365f, -0.03265829f, -0.17809415f, -0.11348835f, -0.15435426f, -0.31477818f, -0.19940159f, 0.25805229f, 
    -0.04746892f, 0.12128183f, -0.06140503f, -0.04190786f, -0.10586262f, -0.08712929f, -0.10070805f, -0.03613422f, 
    -0.09740452f, -0.29486668f, -0.15221676f, 0.10184230f, 0.02975392f, 0.24504070f, -0.03074135f, 0.07562389f, 
    -0.12508661f, 0.04656371f, 0.00798917f, -0.01405915f, -0.05184603f, -0.11055115f, 0.03523052f, 0.55061412f, 
    0.06074054f, 0.02366721f, -0.13155080f, 0.06926359f, 0.20410296f, 0.05390049f, -0.02931823f, 0.15878962f, 
    0.19394927f, -0.30010903f, -0.02049034f, -0.08269545f, 0.11855200f, 0.08106814f, -0.06030153f, -0.00713842f, 
    0.00685755f, 0.01589384f, -0.02455388f, -0.13194609f, 0.39455456f, -0.10863730f, 0.53438604f, 0.01963757f, 
    0.31839740f, -0.19356102f, -0.22122672f, -0.13590913f, -0.26287273f, -0.08589467f, -0.15913153f, -0.00066456f, 
    0.07218818f, 0.54653841f, -0.31392196f, 0.03364399f, -0.04505085f, -0.16843814f, 0.04034578f, 0.28562009f, 
    -0.16872673f, 0.08184300f, 0.00285342f, -0.03952563f, -0.09612678f, 0.07074168f, 0.04431073f, -0.81793284f, 
    -0.00645922f, -0.14372154f, -0.04870734f, 0.00383303f, 0.07236551f, -0.03304228f, -0.03523509f, 0.13985088f, 
    0.07187665f, -0.35647842f, 0.02690216f, -0.00569324f, -0.35709020f, 0.11615466f, -0.21039641f, -0.09051772f, 
    0.04470559f, 0.03255680f, 0.06556199f, 0.10752400f, -0.00637553f, -0.24152446f, -0.12982377f, -0.02138451f, 
    0.05550298f, 0.12484241f, 0.01906870f, -0.00935913f, 0.12074945f, 0.07716739f, 0.15382560f, -0.03562416f, 
    0.29416996f, -0.66613525f, 0.28935349f, -0.04472179f, -0.11518662f, 0.02963786f, -0.13098603f, -0.25267944f, 
    -0.22967276f, 0.10287439f, 0.12085586f, 0.02543702f, -0.30396619f, -0.09954905f, -0.19601671f, -0.17014235f, 
    0.07244750f, -0.10250439f, -0.00615055f, 0.19009285f, 0.06321882f, 0.11026255f, 0.01886330f, -0.11834449f, 
    -0.61457288f, 0.16747269f, -0.99181962f, 0.24332587f, 0.14233664f, -0.15587808f, 0.15319064f, 0.07559038f, 
    0.10759426f, -0.05925385f, -0.05466235f, 0.06747402f, -0.18031773f, -0.10382633f, 0.31406152f, 0.05870152f, 
    -0.04581433f, 0.06607441f, 0.19777775f, 0.20889971f, 0.09355366f, 0.02433684f, 0.16474532f, -0.00524030f, 
    -0.05563627f, -0.24176677f, 0.16261926f, -0.38067061f, -0.26645660f, -0.09374732f, -0.12229531f, 0.09536772f, 
    0.03782417f, 0.03593302f, -0.01266903f, 0.01233282f, -0.19025862f, 0.12218247f, -0.03556100f, -0.58834571f, 
    -0.24202766f, -0.02899856f, 0.02617894f, 0.07677433f, 0.03378432f, 0.01933940f, -0.06040653f, -0.21927753f, 
    0.49891677f, -0.35605976f, -0.43392590f, -0.24541000f, 0.48220024f, 0.19476728f, 0.34960875f, 0.22795998f, 
    0.05162314f, -0.09709741f, 0.01507336f, -0.16987672f, -0.31518307f, 0.23106667f, 0.21035148f, -0.35496879f, 
    -0.45292202f, 0.06857723f, 0.10250958f, 0.41993076f, -0.04285598f, -0.01503863f, 0.08568878f, -0.03989365f, 
    -0.30617115f, -0.24626005f, -0.00527600f, -0.22329262f, 0.05813761f, 0.10623483f, 0.14367925f, 0.24736398f, 
    0.07839099f, -0.15183458f, -0.15268108f, -0.18979862f, -0.01179899f, -0.17410359f, -0.02237327f, -0.13080287f, 
    0.21947476f, -0.04809660f, -0.10406643f, 0.03605459f, -0.05052739f, -0.23707750f, -0.09728348f, -0.03595186f, 
    0.06800965f, 0.19151323f, -0.43461600f, 0.19762783f, 0.13273646f, 0.18071713f, 0.11404854f, -0.05242204f, 
    0.00062098f, -0.12095267f, -0.11202583f, -0.05803702f, -0.33833784f, -0.60652107f, 0.38911968f, 0.35444322f, 
    -0.12347770f, 0.29521191f, -0.33856848f, -0.00207747f, -0.22373918f, 0.01903808f, -0.07352785f, 0.02728770f, 
    -0.19965433f, 0.39886147f, -0.45336464f, -0.00731181f, -0.05547881f, 0.08488001f, -0.21711174f, 0.11816692f, 
    0.06364744f, -0.12512036f, -0.01552628f, 0.00589083f, -0.00531678f, 0.36914381f, 0.65435022f, -0.29157248f, 
    -0.03958705f, -0.28355846f, -0.03168955f, -0.07478536f, -0.15799272f, 0.13312745f, 0.10939248f, 0.10412103f, 
    0.09947374f, 0.01092807f, 0.38931674f, 0.38098314f, -0.13573161f, 0.02107764f, -0.21692319f, -0.39979944f, 
    0.28178161f, -0.11703987f, -0.10736132f, 0.02915127f, -0.29623839f, 0.41118357f, -0.31647509f, -0.00480543f, 
    -0.18078929f, 0.09134922f, -0.19090423f, -0.06279413f, 0.14343680f, 0.06457330f, -0.05863821f, 0.22844341f, 
    -0.48946676f, -0.11763307f, 0.20783409f, 0.01245300f, -0.08682708f, 0.15951927f, -0.24282309f, 0.22099242f, 
    0.18390714f, -0.17729208f, 0.14796571f, 0.11270975f, -0.33030781f, -0.25705171f, -0.74451178f, 0.09036019f, 
    0.10273270f, 0.06645866f, 0.13516119f, -0.20951964f, 0.05670428f, -0.05503126f, -0.01912895f, 0.08390579f, 
    -0.12676845f, 0.19996424f, -0.26978472f, -0.10496369f, -0.21810402f, -0.09220099f, -0.10261177f, 0.04158942f, 
    -0.06804187f, -0.13662273f, -0.06146697f, 0.03467513f, -0.29197133f, 0.20680918f, 0.38092282f, 0.20719555f, 
    0.01574641f, -0.08443397f, -0.09118494f, 0.11952851f, -0.17830813f, 0.03170396f, 0.24747141f, 0.05200516f, 
    -0.50585359f, 0.07807916f, 0.11939347f, -0.31508419f, -0.07471485f, -0.06172122f, -0.36632106f, 0.02042133f, 
    0.02514561f, -0.14098720f, -0.04639665f, -0.13368315f, -0.22033729f, -0.11863925f, -0.49055386f, 0.24106210f, 
    0.02171417f, 0.01354310f, -0.18037628f, 0.27762109f, 0.04739217f, -0.26489741f, -0.12627698f, -0.14391759f, 
    -0.58942282f, -0.17873083f, -0.05769173f, -0.03610354f, -0.07930399f, -0.13861001f, 0.04724136f, 0.09295385f, 
    -0.08639202f, 0.06785675f, 0.06287933f, 0.41013113f, -0.54653597f, 0.82662046f, -0.30691412f, 0.16087244f, 
    0.03248971f, 0.03648036f, 0.15316737f, 0.05653505f, -0.07453112f, -0.01245737f, 0.15886247f, 0.23150906f, 
    0.01099012f, -0.25966635f, -0.01911362f, 0.07133509f, -0.23889834f, 0.05298832f, 0.21147768f, 0.03077454f, 
    0.14253631f, -0.19712122f, -0.11272426f, -0.16471075f, -0.18425876f, -0.10578636f, -0.15841946f, -0.02098043f, 
    -0.03052607f, 0.11663295f, 0.22068988f, -0.07199400f, -0.16777422f, -0.01190353f, 0.01292930f, -0.28901231f, 
    -0.44976872f, 0.22073433f, -0.08937144f, -0.10374398f, 0.00394404f, 0.14122777f, -0.17270648f, 0.19199634f, 
    -0.15276648f, 0.09955131f, 0.13363621f, 0.05518412f, 0.14355043f, 0.44246215f, -0.03158461f, 0.52193451f, 
    -0.00784059f, -0.10550833f, 0.33984023f, 0.07074727f, -0.05581616f, 0.25553441f, 0.20617954f, 0.31869662f, 
    -0.30613190f, -0.32485282f, -0.03498160f, -0.03743316f, 0.08631718f, -0.05578196f, -0.04882815f, -0.06757132f, 
    -0.28439724f, -0.07528935f, -0.11411291f, -0.08258267f, 0.20396222f, -0.18358113f, 0.22579661f, 0.21256122f, 
    0.07687965f, 0.00926140f, -0.13674006f, 0.02015023f, -0.25841147f, -0.02151441f, 0.05700620f, -0.21137254f, 
    -0.39124396f, 0.27219182f, -0.01116237f, 0.31415677f, 0.02748421f, -0.07681967f, 0.19224122f, 0.27194008f, 
    -0.02126461f, 0.15419291f, 0.00842780f, -0.23255466f, 0.01469188f, 0.01940531f, 0.17323846f, 0.19697686f, 
    -0.07844152f, -0.22680724f, -0.00642424f, 0.10364109f, 0.02395744f, 0.00447830f, -0.08027589f, -0.15457952f, 
    -0.51502973f, 0.55244684f, -0.58456576f, 0.05877975f, 0.08287026f, 0.43840194f, 0.01302382f, 0.06862739f, 
    -0.15652104f, -0.10682950f, -0.53590888f, -0.32029659f, -0.29442719f, -0.32330352f, 0.10728015f, 0.09596147f, 
    -0.08260239f, 0.17058198f, -0.05865311f, -0.08279712f, 0.05230699f, 0.05910718f, 0.16119692f, 0.06082534f, 
    0.41026103f, 0.31735489f, -0.10229188f, -0.07740893f, -0.51913708f, -0.29461142f, -0.01252928f, 0.03623569f, 
    -0.16974540f, 0.22008529f, -0.41429800f, 0.00730705f, -0.14171605f, -0.24770585f, -0.66471285f, 0.01310455f, 
    -0.17727673f, 0.15326476f, -0.13660048f, -0.01776133f, 0.00847046f, 0.07006053f, -0.01015833f, -0.17005794f, 
    -0.22259945f, -0.29033640f, -0.27460358f, 0.08570226f, 0.14459921f, 0.29335624f, -0.22935268f, -0.13942465f, 
    -0.12182551f, -0.12234089f, 0.07162774f, -0.05822811f, 0.24463725f, -0.21404633f, 0.27578273f, 0.04143868f, 
    -0.27129877f, 0.06878233f, -0.11493707f, 0.03104660f, 0.12294959f, 0.09161696f, 0.09035961f, 0.30626735f, 
    -0.50214702f, -0.02220382f, 0.22259003f, 0.12246934f, 0.08708002f, -0.03529958f, -0.52791941f, 0.20851070f, 
    -0.36965197f, -0.00828682f, 0.08250875f, -0.19643436f, -0.21492901f, 0.11074486f, -0.13475800f, 0.14376441f, 
    -0.12490939f, 0.03659667f, 0.04554719f, -0.11172152f, 0.13326088f, 0.22423209f, 0.17108805f, 0.10845424f, 
    0.27494583f, -0.21607515f, 0.15062465f, -0.08969475f, -0.15079570f, 0.17425650f, 0.26668119f, 0.00327557f, 
    0.07658249f, 0.10178114f, 0.17179133f, 0.24584752f, -0.00212215f, -0.01618535f, 0.43138924f, -0.08602936f, 
    -0.08845802f, -0.07150718f, -0.36882958f, 0.09119572f, 0.23816478f, 0.06345268f, 0.43430126f, -0.00382388f, 
    -0.19061030f, -0.39526698f, -0.18059866f, 0.02724683f, -0.07882499f, -0.19804786f, 0.14440738f, -0.12820162f, 
    0.22964492f, 0.10100695f, -0.04465965f, -0.03456691f, -0.47062072f, -0.38071522f, 0.34374994f, -0.37444532f, 
    -0.02252021f, -0.15051487f, -0.09147208f, -0.07519072f, 0.04366741f, -0.01540240f, -0.25718412f, 0.02804173f, 
    0.34758571f, 0.36283812f, 0.17108317f, 0.13539039f, 0.04213016f, 0.02216434f, 0.07965106f, 0.34642923f, 
    -0.26340026f, 0.22161137f, 0.14757848f, 0.02300330f, -0.13117215f, -0.19651739f, -0.19675182f, 0.21360730f, 
    0.01920638f, -0.33265394f, -0.04564594f, 0.18127979f, -0.07077476f, -0.28579962f, -0.38319793f, -0.38058880f, 
    0.22565657f, 0.12684032f, 0.00689097f, -0.07099068f, 0.20175375f, -0.25217053f, 0.04749893f, 0.02588593f, 
    -0.21762514f, 0.12219254f, -0.03134530f, -0.01370157f, 0.81029069f, -0.40680480f, 0.58239090f, 0.08985532f, 
    -0.08430438f, -0.21236381f, 0.16221316f, 0.11178891f, -0.53296095f, -0.33592585f, -0.19030854f, -0.06785682f, 
    0.08737855f, -0.06180657f, -0.04645613f, 0.13573521f, -0.29131985f, -0.05932329f, 0.09806772f, -0.25059095f, 
    -0.16960831f, -0.02335930f, -0.14535068f, 0.06561584f, -0.15147072f, -0.00011847f, -0.23435132f, -0.21125068f, 
    -0.05318224f, -0.04720922f, 0.33018672f, -0.06242538f, 0.00792562f, 0.08139528f, -0.19137667f, -0.06501439f, 
    0.21392886f, -0.23297815f, 0.36800605f, 0.10610604f, -0.02477464f, 0.02067067f, -0.16174069f, 0.04159836f, 
    -0.35965541f, -0.06598088f, 0.10981873f, -0.00114769f, 0.00032505f, 0.16859825f, -0.19227017f, 0.38188788f, 
    -0.18997212f, 0.18363781f, 0.03950176f, -0.04548037f, -0.11142868f, 0.00549553f, 0.03773163f, -0.09465764f, 
    -0.08822152f, -0.04433032f, -0.17668201f, -0.08984210f, -0.00521215f, -0.05857697f, 0.02592358f, 0.03352033f, 
    0.12130559f, 0.19960290f, 0.09589357f, 0.01498551f, -0.39925644f, -0.17725310f, 0.25147116f, 0.17310737f, 
    -0.29664811f, -0.12919578f, 0.07166806f, 0.07052246f, -0.02091557f, 0.15141381f, 0.07487079f, 0.11320750f, 
    -0.10211034f, 0.38271922f, -0.22545989f, -0.01082845f, -0.29553404f, 0.02604542f, 0.14309113f, -0.27336946f, 
    -0.09247802f, -0.04847730f, -0.19766968f, -0.17218746f, -0.53511155f, -0.39519271f, -0.11758834f, 0.51673996f, 
    0.45831540f, -0.13352922f, 0.17826022f, 0.02451947f, -0.01970307f, 0.18162288f, 0.14475439f, -0.18280244f, 
    -0.08296353f, 0.16723813f, 0.04301607f, -0.12334551f, 0.00645664f, -0.04982761f, 0.08181738f, 0.03756034f, 
    0.02073214f, 0.12558341f, 0.07841615f, -0.08079491f, -0.01790196f, -0.03067901f, -0.26040667f, 0.13662152f, 
    0.11293287f, 0.12322494f, 0.00490569f, -0.02069139f, 0.00835109f, 0.15839697f, 0.40088320f, 0.23650138f, 
    -0.05571112f, 0.16332172f, -0.14006290f, 0.17679133f, -0.03200332f, -0.06616368f, 0.13036607f, 0.20764139f, 
    -0.30807337f, -0.06189784f, -0.01259818f, 0.09047787f, -0.67706174f, 0.00162413f, -0.38544556f, 0.12246606f, 
    0.06441105f, -0.01083916f, -0.10398018f, 0.15133761f, -0.20227195f, -0.03886799f, 0.06292104f, -0.23678714f, 
    0.25236714f, -0.28711316f, 0.33240581f, -0.01675749f, 0.13637526f, 0.00141732f, -0.22303793f, 0.07030617f, 
    0.03297955f, 0.00308010f, -0.00958277f, 0.07305168f, -0.07108909f, 0.20334779f, -0.41761532f, -0.26057747f, 
    0.04257455f, -0.14286458f, 0.12082779f, -0.06920784f, -0.02795854f, 0.12783916f, 0.00315378f, 0.00623101f, 
    -0.51322484f, 0.71182054f, 0.00884079f, -0.08580011f, -0.29046485f, -0.19850108f, 0.11240557f, 0.15557921f, 
    0.00277693f, -0.01081818f, -0.03681695f, 0.05563457f, 0.15382478f, 0.22074433f, 0.13510308f, 0.10309897f, 
    -0.09373895f, 0.11825701f, -0.05379238f, 0.01035382f, -0.04877033f, 0.04867796f, 0.18126419f, 0.07450689f, 
    -0.25392476f, -0.07264846f, -0.20669733f, 0.62200379f, 0.01715252f, -0.15757570f, 0.16118158f, 0.09980524f, 
    0.11545058f, 0.20515910f, 0.14088157f, 0.18706194f, -0.22756775f, -0.42586759f, -0.07375066f, 0.43127263f, 
    -0.27761972f, -0.21372215f, -0.13682011f, -0.41664028f, 0.10607326f, 0.06580779f, 0.05702359f, -0.02222612f, 
    0.46587065f, -0.43145546f, 0.66897249f, -0.16074868f, -0.03053047f, -0.00579616f, 0.08457526f, 0.07444645f, 
    -0.07309286f, -0.06732388f, -0.00752648f, -0.00928784f, 0.21060981f, -0.40189582f, 0.02715832f, -0.25173444f, 
    -0.09994954f, -0.10233789f, 0.14482038f, -0.06499168f, 0.02961827f, 0.03527851f, 0.02107878f, -0.11554728f, 
    0.05709285f, 0.01008802f, -0.25414097f, 0.18269911f, -0.27209103f, -0.12313414f, 0.10950945f, -0.21551862f, 
    0.01947001f, 0.00919970f, -0.12150279f, -0.09167945f, -0.26924488f, 0.01295888f, -0.20294988f, -0.47559592f, 
    -0.13770036f, 0.23877117f, -0.10984445f, 0.07240349f, -0.04695221f, 0.03496980f, -0.13130936f, -0.05363314f, 
    0.65036297f, 0.36974686f, 0.06789122f, 0.01275416f, -0.16898188f, 0.09294849f, -0.12518695f, 0.34201366f, 
    -0.04213800f, 0.03704789f, 0.00097575f, -0.04501963f, -0.14687212f, -0.11896818f, 0.08336201f, -0.14956254f, 
    -0.11121953f, -0.19538587f, -0.32337591f, -0.31852755f, 0.05982334f, -0.10168212f, -0.07263099f, -0.05093204f, 
    0.06631308f, 0.10501684f, 0.11513525f, -0.05424294f, -0.02068794f, -0.14305077f, 0.02120890f, -0.22147857f, 
    -0.05028747f, -0.03144479f, -0.00098413f, -0.14789984f, 0.04156518f, 0.01027315f, -0.02802637f, 0.05327424f, 
    0.11220090f, 0.10013923f, 0.02706746f, 0.33814251f, -0.27323368f, -0.20713231f, -0.28999364f, 0.01183713f, 
    0.55735284f, 0.23304924f, 0.59182483f, -0.14303336f, -0.04244117f, 0.14126028f, -0.20722501f, 0.02418323f, 
    -0.03714127f, 0.02059939f, 0.01913291f, 0.07334366f, -0.63628244f, 0.20976460f, -0.67760581f, 0.00957956f, 
    0.02156695f, -0.04507469f, 0.16260418f, -0.23100983f, -0.12865794f, 0.00405014f, -0.06181490f, 0.06238438f, 
    -0.18473573f, -0.05620568f, 0.27281967f, 0.20173101f, 0.14788209f, 0.15646984f, 0.24793324f, -0.21036702f, 
    -0.10214080f, -0.14319639f, -0.31523526f, 0.11151794f, -0.40706182f, -0.41244844f, -0.04021145f, -0.16642569f, 
    -0.06467544f, -0.01713955f, -0.08810282f, 0.14326224f, -0.06268824f, 0.15720186f, 0.04642384f, -0.04677517f, 
    -0.50654203f, 0.14679444f, -0.50657004f, 0.01224739f, -0.05763054f, -0.10050080f, 0.22304949f, -0.15800792f, 
    -0.10781148f, -0.09027851f, 0.15372412f, -0.14355069f, -0.36348534f, 0.26250696f, -0.15623879f, -0.21142517f, 
    -0.06434379f, 0.07196636f, -0.04713361f, 0.05291021f, 0.08430784f, 0.26152739f, 0.24206601f, -0.06743371f, 
    -0.66311729f, 0.11021070f, -0.15291138f, 0.20044236f, 0.14868438f, 0.03827670f, 0.22091399f, -0.24283175f, 
    0.03249111f, -0.10330113f, 0.17314278f, 0.17953256f, 0.66109329f, -0.36073148f, 0.09675217f, 0.05126352f, 
    0.14418761f, -0.24091505f, 0.07006197f, 0.22312492f, -0.03086739f, 0.04712621f, 0.00518854f, -0.04004522f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.20032069f, 0.07120711f, 0.13344419f, -0.14512654f, -0.16243196f, 0.04249457f, 0.11043584f, -0.22241363f, 
    0.06273842f, 0.00595275f, -0.00329150f, -0.01399320f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
