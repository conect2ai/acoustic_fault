#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.57492834f, 0.83258116f, -0.03370302f, 0.54051971f, -0.27909896f, -0.33669671f, -0.27211246f, -0.39618975f, 
    0.11816712f, 0.55267102f, 0.50422668f, 0.55704159f, 0.25634131f, -0.20861855f, 0.20199029f, 0.00257175f, 
    0.40363240f, -0.45288721f, -0.21361893f, -0.70249766f, -0.55107230f, 0.02328593f, 0.34518343f, 0.22671326f, 
    -0.15524486f, -0.06138737f, 0.43711600f, 0.55060089f, -0.68741339f, 0.46237162f, 0.55211484f, 0.29036745f, 
    0.23080045f, -0.21086347f, -0.28865489f, -0.20854497f, 0.63729888f, 0.40288413f, -0.23580880f, -0.05260560f, 
    0.07777630f, 0.14546850f, 0.05405124f, 0.73417097f, -0.31521362f, 0.46454698f, 0.73968345f, 0.57684463f, 
    -0.36341155f, 0.61792761f, -0.45172477f, 0.25284666f, 0.00103278f, 0.16023295f, -0.78694171f, 0.31159291f, 
    0.28219303f, -0.38223016f, 0.62269825f, 0.27840933f, 0.23114239f, -0.39389423f, 0.27820712f, 0.41353086f, 
    0.24287221f, 0.35534528f, -0.00031309f, -0.45774052f, 0.00464530f, 0.38245574f, 0.28393152f, 0.10394017f, 
    0.70640135f, 0.05968066f, 0.20024754f, -0.02764599f, -0.43550527f, -0.36154011f, -0.42021021f, -0.15160848f, 
    0.07176333f, -0.14228229f, -0.34629899f, -0.08859076f, 0.72005922f, 0.32178783f, 0.33206424f, 0.36451858f, 
    0.05517097f, 0.25545484f, 0.47561747f, 0.32422188f, 0.11899529f, 0.24560495f, 0.67783207f, 0.13272557f, 
    -0.10584277f, -0.34698635f, -0.03300646f, -0.81118751f, 0.74308252f, -0.40825698f, 0.09537480f, -0.27676219f, 
    -0.43330288f, 0.15326692f, -0.10080040f, -0.19853051f, -0.50180119f, -0.51652765f, -0.19841836f, 0.17520908f, 
    0.58055258f, 0.49385193f, -0.26874566f, -0.00297062f, -0.50730437f, 0.54627627f, 0.45855227f, 0.65445298f, 
    -0.63837898f, -0.03447365f, -0.35704130f, -0.16524801f, -0.16481577f, -0.09177716f, -0.24391638f, -0.39986190f, 
    -0.38406244f, 0.43758339f, 0.72766960f, -0.38876006f, 0.07064120f, -0.54411471f, -0.26441196f, -0.51694286f, 
    0.17871530f, -0.49797904f, 0.02240889f, 0.29546276f, 0.71110457f, 0.13952394f, 0.17807241f, 0.24919745f, 
    -0.59849483f, 0.10917062f, 0.64314312f, 0.83187288f, 0.79460466f, -0.52842712f, -0.07270471f, 0.09093974f, 
    -0.07225233f, -0.78796208f, -0.30420411f, 0.18709980f, 0.42077121f, -0.36961755f, -0.56347871f, 0.41345936f, 
    0.43476406f, -0.03663900f, 0.45443609f, 0.77292204f, -0.53460974f, 0.28381297f, 0.00361117f, 0.11602668f, 
    0.39401770f, -0.02660397f, 0.12153641f, -0.32737595f, 0.28821868f, -0.25267461f, 0.29095051f, -0.58358115f, 
    -0.42033404f, -0.03853185f, -0.04504746f, 0.64220357f, 0.24193433f, 0.51604730f, 0.33345100f, -0.39164615f, 
    -0.36402443f, 0.77936620f, 0.11914362f, -0.23016508f, -0.00830949f, -0.19965711f, 0.20731954f, 0.05179583f, 
    0.71329355f, -0.01360719f, 0.47045845f, -0.40476462f, -0.03359269f, -0.73573631f, 0.16553587f, 0.38332057f, 
    -0.25959295f, -0.77644461f, 0.04725077f, 0.03071586f, 0.39977473f, 0.10292208f, 0.51805514f, 0.32966584f, 
    -0.00011578f, 0.27859005f, 0.05981050f, 0.24553680f, 0.58910614f, -0.61820596f, -0.18825300f, 0.34524500f, 
    -0.29645842f, 0.14439596f, -0.44397825f, -0.17272925f, 0.61331332f, -0.50516540f, 0.13483550f, 0.18082450f, 
    -0.29632458f, -0.28010017f, 0.53904217f, -0.15256564f, -0.53319013f, 0.20072499f, 0.49969095f, 0.36681107f, 
    0.37799284f, -0.59068102f, 0.47671774f, 0.17867017f, 0.02528648f, 0.55569851f, -0.13235313f, 0.63628262f, 
    -0.33207667f, -0.07613926f, -0.14062217f, 0.63389373f, -0.43707097f, 0.28860560f, 0.18651456f, -0.70659584f, 
    0.18026254f, 0.07485697f, -0.23528336f, -0.00067764f, -0.37567654f, -0.52313650f, -0.35066646f, 0.37261665f, 
    0.24588147f, -0.43806571f, -0.18040755f, 0.25822318f, -0.48279783f, 0.10225388f, 0.58233613f, 0.46864027f, 
    -0.43489751f, -0.31245232f, -0.56988245f, -0.25410995f, -0.09181134f, -0.08354698f, 0.27347633f, -0.50613052f, 
    -0.63685656f, -0.20656534f, 0.69923860f, 0.69900519f, 0.15410081f, 0.13879891f, -0.21558328f, 0.69235855f, 
    -0.58348286f, -0.34523213f, -0.52756941f, -0.30971631f, -0.19466805f, -0.12400422f, -0.27035823f, 0.43949172f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.32846335f, 0.28290689f, 0.02831922f, 0.19432391f, -0.28052342f, -0.26735646f, -0.20779075f, 0.26376766f, 
    -0.09188806f, -0.05569499f, -0.36416119f, 0.16280332f, -0.17008249f, 0.09059227f, -0.21859376f, 0.23029907f, 
    0.19744694f, 0.09899168f, -0.40893072f, -0.21273397f, -0.14127299f, -0.06959212f, -0.07041761f, 0.26414505f, 
    0.21357535f, -0.19288580f, 0.13017032f, -0.02882373f, -0.11327147f, 0.06777141f, -0.36761403f, 0.10551163f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.00340214f, -0.03730290f, -0.04671357f, 0.00902941f, -0.02448303f, 0.02484800f, -0.03776463f, -0.00313436f, 
    -0.01855582f, -0.03295220f, 0.01845818f, 0.04723402f, -0.05294084f, -0.05384363f, -0.03876805f, 0.05038837f, 
    0.00834177f, -0.02877467f, 0.00998050f, -0.02764356f, 0.06326277f, 0.04161868f, -0.04743509f, 0.02480552f, 
    -0.00244197f, -0.02066126f, 0.01277149f, -0.00014182f, -0.02919966f, 0.01184214f, 0.02528661f, 0.00779792f, 
    -0.00056067f, 0.00749305f, -0.01537492f, -0.00065760f, 0.01658237f, -0.04561195f, 0.04606123f, -0.04249419f, 
    0.03551227f, 0.02957009f, -0.00368046f, -0.05286259f, -0.06333975f, -0.02745673f, 0.03673379f, 0.00230349f, 
    0.00652799f, -0.05323489f, 0.04773598f, 0.01777183f, 0.01057660f, -0.06330180f, -0.04093904f, 0.02433757f, 
    0.00042035f, -0.00821996f, -0.03014850f, 0.04269675f, 0.03539077f, 0.03375065f, 0.02102087f, 0.00049253f, 
    -0.02440273f, -0.05742082f, 0.00993858f, -0.01139672f, -0.04568759f, 0.04851245f, -0.04214871f, 0.02933866f, 
    0.01789019f, 0.01726688f, 0.02644490f, -0.00374791f, -0.02251397f, 0.02420841f, -0.02313737f, -0.02880035f, 
    -0.02390266f, -0.03669371f, -0.00772604f, -0.04509686f, -0.03401773f, -0.02047257f, -0.01860325f, -0.00473829f, 
    0.03957374f, -0.05760965f, 0.00482333f, 0.00973757f, 0.02559422f, 0.01209715f, -0.06361413f, 0.00428791f, 
    0.04013855f, -0.02473505f, 0.03369049f, 0.03947470f, -0.00077783f, 0.02610170f, -0.03467264f, 0.04935303f, 
    0.00125261f, 0.00289658f, -0.02756214f, -0.04250232f, -0.03224211f, -0.05672712f, 0.00410793f, -0.00747120f, 
    -0.03720330f, 0.03951779f, -0.05805928f, 0.02335050f, 0.00464163f, -0.03223293f, -0.03580800f, -0.05351254f, 
    -0.01056623f, -0.00385370f, -0.06389783f, 0.02078684f, 0.00095533f, -0.01499717f, 0.02852554f, -0.06382456f, 
    -0.04566994f, 0.01093564f, -0.02508979f, -0.01152974f, -0.03560304f, -0.06402032f, -0.05445820f, 0.01308276f, 
    0.01602691f, -0.00207458f, 0.03438542f, -0.00466506f, -0.06553677f, -0.00283420f, -0.02297498f, -0.01538352f, 
    -0.03414235f, 0.04043870f, 0.04771852f, 0.04382952f, -0.02078512f, 0.02611561f, -0.05779107f, 0.02589994f, 
    -0.04721241f, 0.01390687f, -0.01929170f, -0.05275128f, -0.00244595f, 0.01817858f, -0.00582009f, -0.05024366f, 
    0.04475593f, -0.05016434f, 0.00095676f, -0.02863690f, 0.00168735f, -0.02924483f, -0.05711272f, -0.00826950f, 
    0.03384775f, -0.05932878f, -0.02836236f, 0.04258161f, -0.00849688f, -0.05151122f, -0.03240078f, -0.02597386f, 
    -0.03842752f, -0.00864296f, -0.04155764f, -0.02352909f, -0.02508504f, -0.00294312f, -0.06015783f, 0.00658692f, 
    0.03363510f, 0.01997538f, 0.00415103f, 0.03627521f, 0.03232631f, 0.00757084f, 0.02209087f, 0.04110621f, 
    -0.06269435f, -0.05190980f, -0.05880791f, 0.00496030f, 0.03430549f, -0.00626995f, -0.00387202f, 0.01105478f, 
    0.05209723f, -0.04226798f, -0.05514650f, 0.00958037f, 0.04683238f, 0.00381767f, 0.02555295f, 0.04123348f, 
    0.01262624f, 0.01167053f, 0.00569021f, -0.05332818f, -0.06048264f, 0.01281769f, 0.00094543f, -0.01981598f, 
    -0.04078905f, -0.00455515f, -0.05436719f, -0.06671406f, -0.02396452f, -0.05889737f, -0.02809913f, -0.02831789f, 
    0.00849220f, 0.01591180f, -0.02480230f, 0.03703498f, -0.02279376f, 0.05092591f, 0.02789376f, -0.01115968f, 
    -0.00527033f, -0.03229310f, 0.00754659f, -0.00110427f, -0.01801658f, -0.03960984f, -0.04597793f, 0.01306005f, 
    -0.02227931f, -0.03356675f, 0.05108388f, -0.00216575f, -0.01481599f, -0.03005633f, -0.03096241f, -0.01126059f, 
    0.03200485f, 0.00959830f, 0.00644386f, -0.02603253f, -0.00871595f, -0.01141571f, -0.05270044f, -0.02737661f, 
    0.01683860f, 0.04145543f, 0.05006332f, -0.00255243f, 0.05040479f, -0.02484419f, 0.00653736f, 0.02777234f, 
    -0.03463458f, 0.01282708f, 0.02497734f, 0.01171307f, -0.02179085f, 0.05106141f, 0.04271265f, -0.05867242f, 
    -0.01859945f, 0.02896826f, -0.04899618f, -0.02221016f, 0.01633255f, -0.02429759f, -0.04342932f, 0.01028483f, 
    0.04699052f, -0.05754485f, 0.05184188f, 0.00029312f, -0.00558809f, -0.00504384f, -0.05640863f, 0.00522111f, 
    -0.21362101f, 0.08419987f, -0.03555590f, -0.05639865f, 0.09503835f, -0.15665646f, 0.03234174f, 0.20010184f, 
    -0.08312954f, 0.15411563f, 0.13869649f, 0.18397138f, -0.12917559f, -0.04798143f, 0.05506755f, 0.09202382f, 
    0.21488607f, 0.01021361f, 0.13099785f, -0.04134343f, -0.05939449f, 0.08804381f, 0.04146159f, 0.08699275f, 
    -0.16198984f, -0.15199684f, -0.19449629f, 0.55663657f, 0.00342970f, -0.10665563f, 0.03561252f, -0.11784270f, 
    0.10488651f, 0.02033301f, 0.08680522f, -0.09829883f, 0.16892435f, 0.15109304f, 0.06414965f, 0.10712422f, 
    -0.21161351f, -0.07867740f, -0.03380482f, -0.01100106f, 0.02630278f, 0.05634734f, -0.10769903f, 0.13195381f, 
    0.01075917f, -0.00210742f, -0.04017022f, 0.05143525f, 0.02667413f, -0.03832576f, 0.30060995f, -0.41381907f, 
    0.12073544f, -0.23152147f, -0.06051295f, -0.08956710f, -0.07655381f, 0.00897774f, -0.10975678f, 0.25812209f, 
    0.19316208f, -0.08724310f, -0.08153480f, -0.09663469f, 0.15654875f, -0.03128135f, 0.05056072f, -0.08891749f, 
    0.05095253f, 0.13233522f, -0.01204365f, -0.13659978f, -0.02991996f, -0.09706903f, 0.11593988f, 0.03851021f, 
    0.19299801f, 0.08644985f, -0.16433126f, -0.08529602f, 0.22958054f, 0.00600291f, -0.06235645f, -0.04993013f, 
    -0.20091355f, -0.27082583f, -0.34127352f, 0.00518243f, -0.20978805f, -0.11619660f, -0.04990038f, 0.10923117f, 
    0.02360562f, -0.04395958f, -0.04436594f, 0.06091733f, -0.07737093f, -0.02312442f, -0.09553724f, 0.01521388f, 
    0.16619839f, -0.04764910f, 0.07745207f, 0.05049339f, 0.21583353f, 0.00325306f, 0.02268756f, -0.08681574f, 
    0.01969460f, 0.01738215f, -0.09672003f, -0.00048296f, -0.02325653f, 0.03988137f, -0.10626031f, 0.15616411f, 
    -0.08346552f, 0.02489770f, -0.09684765f, 0.07955179f, -0.02727376f, 0.09532318f, -0.03950607f, -0.14441438f, 
    -0.10288271f, 0.17094415f, 0.07378060f, -0.03013589f, 0.14549792f, 0.07313927f, -0.19034065f, 0.32553986f, 
    -0.33432889f, -0.10095329f, 0.17903391f, 0.00702434f, 0.02476275f, -0.07894672f, 0.03742311f, 0.01808471f, 
    -0.08021148f, 0.09298255f, -0.02634866f, 0.12279284f, -0.04694154f, -0.17693253f, -0.03549687f, -0.00136634f, 
    0.03028301f, -0.22177087f, -0.00947078f, -0.02164212f, 0.17073266f, 0.06890117f, -0.03180662f, 0.04902439f, 
    0.03146154f, 0.11185423f, -0.11962392f, 0.17358194f, 0.10228275f, -0.21713598f, -0.01221636f, 0.04714958f, 
    -0.31817341f, -0.11236855f, -0.12754463f, -0.15957288f, -0.04521551f, 0.00220901f, 0.01332731f, 0.08775837f, 
    0.01893881f, 0.04816666f, 0.10193032f, 0.02220200f, -0.09128530f, -0.06106581f, 0.11536962f, -0.24583903f, 
    -0.02907654f, 0.09692425f, -0.07601363f, 0.18961087f, -0.05632848f, -0.01583020f, -0.07193547f, 0.02621363f, 
    -0.18183343f, -0.01475094f, 0.05037423f, 0.24712197f, 0.04328930f, 0.03044347f, -0.05157568f, -0.01650574f, 
    -0.23838648f, -0.03802579f, -0.18833067f, 0.13951875f, -0.14790642f, -0.08512200f, -0.06906546f, 0.11754019f, 
    -0.03256240f, -0.04377414f, -0.03373578f, 0.09778334f, -0.10250169f, 0.04799620f, 0.18060634f, -0.05577862f, 
    -0.22288024f, -0.13150014f, 0.03912880f, 0.10478187f, 0.17162268f, 0.06726029f, 0.03165905f, 0.00090647f, 
    -0.01808498f, 0.01154291f, -0.59308922f, 0.10101670f, -0.15564242f, 0.01403921f, -0.19859464f, 0.15866360f, 
    -0.00933844f, -0.12351106f, 0.11287687f, 0.11712458f, 0.13867609f, -0.04820817f, -0.11050943f, 0.17071658f, 
    0.00039902f, 0.08257937f, -0.01511099f, 0.31059051f, -0.08723610f, -0.02233399f, 0.05660296f, -0.07236929f, 
    0.16826996f, 0.03233130f, -0.02351464f, 0.08074573f, -0.53934717f, -0.01382152f, -0.03336244f, 0.17232268f, 
    0.07516018f, 0.11842708f, 0.14653525f, -0.07601414f, 0.03673815f, 0.15275469f, -0.00659658f, 0.15518160f, 
    -0.00829912f, -0.07631668f, -0.14878698f, 0.01532197f, 0.18666396f, 0.22102751f, -0.05999118f, -0.36073884f, 
    -0.02844570f, 0.20146978f, 0.03072746f, 0.12759204f, -0.27447221f, -0.10184447f, -0.07309305f, -0.18677156f, 
    0.04758835f, 0.14030699f, 0.16030389f, 0.01554026f, 0.08581942f, -0.00615458f, -0.03706227f, 0.07962772f, 
    0.23526074f, -0.21560910f, 0.12599687f, -0.05189238f, 0.10268706f, 0.03785669f, -0.10506256f, -0.03504463f, 
    0.00588769f, 0.22603992f, -0.03191175f, 0.06766792f, -0.04980917f, -0.12097958f, 0.00474964f, 0.05126766f, 
    -0.02055250f, 0.03241253f, 0.40395120f, 0.09613186f, 0.05660253f, 0.00498768f, -0.06371403f, -0.13920368f, 
    0.07026695f, 0.04911350f, 0.09522918f, -0.28291491f, -0.15802079f, -0.03857369f, 0.00948804f, 0.08162137f, 
    0.02517454f, 0.05068446f, 0.05380403f, -0.10765672f, 0.04747294f, -0.16647592f, 0.13815826f, 0.10626941f, 
    -0.05244632f, 0.16923450f, 0.08225738f, -0.03416286f, 0.04957542f, 0.43207306f, 0.15060256f, -0.04718102f, 
    -0.25322956f, 0.01564863f, 0.04310038f, 0.05944739f, 0.01242039f, -0.02737143f, 0.08597721f, 0.20631640f, 
    -0.12899894f, 0.00931366f, 0.20069896f, -0.06896541f, -0.05562552f, -0.15500177f, -0.12254727f, 0.07237916f, 
    0.11750323f, -0.02210659f, 0.14966455f, 0.14587501f, 0.04018759f, 0.04929561f, -0.01097191f, 0.12571459f, 
    -0.04552097f, 0.34903023f, 0.12246984f, 0.02011140f, -0.09208404f, 0.03118008f, -0.09292199f, -0.02074526f, 
    0.04413345f, -0.11405557f, 0.14672764f, 0.09233667f, -0.21985416f, -0.06563466f, -0.08387534f, -0.03336885f, 
    0.16429777f, -0.15593910f, -0.20407401f, -0.03971475f, 0.18089704f, -0.17586610f, -0.08633839f, -0.05666732f, 
    -0.07344246f, 0.20054355f, -0.00742321f, 0.08806214f, -0.35381129f, -0.36330050f, -0.03751090f, 0.06488184f, 
    0.12397122f, -0.10490847f, 0.00301940f, -0.07227942f, 0.22184899f, -0.29479530f, -0.13666996f, -0.10524610f, 
    -0.20229581f, 0.01184633f, 0.03092629f, 0.21605593f, 0.04283719f, 0.35718960f, 0.11648099f, -0.12858255f, 
    0.13951343f, -0.01323796f, -0.06115793f, 0.14405879f, -0.06841916f, -0.06018081f, -0.02257606f, -0.30519566f, 
    -0.13159242f, 0.14129007f, 0.06805842f, -0.00618608f, -0.10846528f, 0.01529535f, -0.05580112f, 0.00315786f, 
    0.12355023f, -0.10608102f, -0.01481119f, -0.09879781f, -0.02306872f, 0.01886278f, -0.03106697f, 0.11162932f, 
    -0.19494496f, -0.18211538f, 0.16752338f, 0.03376645f, 0.06899989f, 0.00071574f, -0.03350443f, 0.01439695f, 
    -0.00311840f, -0.07633246f, -0.04776591f, -0.03748977f, 0.03296013f, -0.05317665f, -0.07741962f, -0.09403445f, 
    -0.16550894f, 0.03791816f, 0.22788763f, -0.47105801f, -0.10675180f, -0.05665572f, -0.11514023f, -0.01137813f, 
    0.03698090f, 0.02133618f, 0.04634482f, 0.12867083f, 0.01781934f, -0.09476347f, -0.01193320f, 0.09766168f, 
    0.03167186f, -0.08425278f, -0.01106637f, 0.00385474f, 0.17498668f, 0.05114304f, -0.23855917f, 0.13506551f, 
    0.06581280f, -0.05684552f, -0.03787014f, 0.03180594f, 0.00417965f, -0.27072218f, -0.01690035f, -0.03721553f, 
    0.07282166f, 0.07404585f, -0.08652049f, 0.16642192f, 0.01482023f, -0.09886157f, 0.09208752f, -0.05665155f, 
    -0.13081944f, -0.05664750f, 0.00667782f, -0.13349989f, 0.00152311f, 0.01149896f, -0.01651325f, -0.03378345f, 
    -0.04134249f, 0.09848458f, 0.02968996f, -0.07013208f, -0.08884662f, -0.07469981f, -0.05344414f, 0.11300910f, 
    -0.03800935f, -0.18212029f, -0.18934807f, -0.09280019f, 0.14424698f, -0.00227886f, -0.02842439f, 0.05573433f, 
    0.06675304f, -0.04713892f, 0.11333513f, -0.10128723f, 0.09811883f, -0.21378754f, 0.07481797f, 0.03263605f, 
    0.17493577f, 0.16197677f, -0.17798182f, -0.06250844f, 0.04426896f, 0.07923999f, 0.00801672f, -0.04962038f, 
    -0.12774512f, -0.10637291f, 0.00162591f, -0.36778507f, 0.31636009f, -0.01297943f, 0.10374166f, 0.09933774f, 
    0.09441435f, -0.04519884f, -0.05430961f, -0.04073724f, 0.33036420f, -0.16503100f, -0.24202526f, 0.03355757f, 
    0.11880665f, -0.00986116f, -0.08755068f, -0.02182279f, -0.01505679f, 0.29090437f, -0.01035747f, -0.16881120f, 
    0.17369033f, -0.00851475f, 0.06362868f, 0.02035392f, -0.02394900f, 0.02733753f, 0.29514304f, -0.37040985f, 
    0.04782200f, -0.00356286f, 0.09887785f, 0.13709699f, 0.11167582f, -0.08643027f, 0.03126992f, -0.11281647f, 
    -0.22924829f, -0.08164757f, 0.11668436f, 0.23370495f, 0.19360253f, 0.18173523f, 0.09295532f, -0.05680435f, 
    0.42132521f, 0.07413892f, 0.08498351f, 0.17101824f, 0.16960731f, -0.12015481f, -0.06396426f, 0.16534530f, 
    0.05220606f, 0.30683851f, -0.03161819f, 0.12688205f, 0.04398102f, 0.05950994f, 0.16244017f, 0.13328698f, 
    0.05638699f, 0.07809266f, -0.03507242f, -0.09010428f, 0.11425414f, 0.09230894f, 0.19477968f, 0.11886563f, 
    0.03047070f, -0.04247260f, 0.07282545f, -0.00347783f, -0.12397759f, -0.16557544f, 0.01516565f, -0.00646740f, 
    0.04540061f, 0.16532432f, 0.05232685f, -0.01247207f, 0.24908304f, 0.05375335f, 0.18068628f, -0.13711722f, 
    -0.13524358f, 0.01083058f, 0.03330332f, -0.17102315f, -0.00174276f, 0.45006016f, 0.12233922f, -0.08394586f, 
    0.04822706f, -0.03061239f, -0.03882528f, -0.08502112f, -0.09099443f, -0.03627697f, -0.64916790f, -0.04676649f, 
    0.14166664f, -0.12856908f, 0.17135042f, -0.02692647f, -0.01944505f, 0.07726507f, -0.07521477f, 0.28546432f, 
    0.06304480f, -0.10200205f, 0.17354111f, 0.04647194f, -0.00586391f, 0.20228574f, 0.08279168f, 0.00623469f, 
    0.15729891f, 0.21193925f, -0.08670837f, -0.08069194f, 0.03319538f, -0.03171752f, 0.07822054f, 0.01062413f, 
    0.02488528f, -0.47334155f, -0.31748348f, 0.10622249f, 0.24076623f, 0.17371401f, 0.03810995f, -0.09781615f, 
    -0.09635714f, -0.09444357f, 0.08809655f, -0.08504458f, 0.16900492f, 0.07378643f, 0.14948454f, -0.00710222f, 
    -0.23451003f, -0.04790761f, 0.01506798f, -0.24013366f, 0.01639636f, 0.20364651f, 0.05165572f, -0.03444159f, 
    0.11770828f, 0.04380861f, 0.06753179f, 0.17851272f, -0.14261745f, -0.15801080f, -0.19379434f, 0.11734444f, 
    0.07131480f, 0.12537357f, -0.00823471f, -0.02417356f, -0.02084077f, 0.36874858f, 0.28401199f, 0.05942417f, 
    0.11022990f, 0.03763178f, -0.06717384f, 0.05694999f, 0.00140221f, 0.05434452f, -0.28848708f, -0.44366390f, 
    0.08728870f, 0.03151414f, -0.04083424f, 0.07518017f, -0.22693358f, 0.07164592f, 0.21538170f, -0.41410899f, 
    -0.05456183f, 0.19846332f, 0.01529587f, 0.19059879f, 0.01479862f, 0.13433544f, 0.02154299f, -0.04961268f, 
    -0.28361738f, -0.34299281f, -0.23945993f, 0.05729358f, 0.02717637f, -0.01180790f, -0.01035493f, -0.05038197f, 
    -0.00025570f, -0.10633925f, -0.01658083f, -0.20110273f, 0.09041587f, -0.04953615f, 0.08216358f, 0.08709888f, 
    -0.03604811f, 0.03953480f, 0.05869022f, -0.15501036f, 0.23400803f, 0.09831227f, -0.05563874f, -0.28176197f, 
    -0.07643496f, -0.08266620f, 0.02690416f, 0.07911976f, 0.01718821f, -0.13980746f, 0.23111850f, 0.05312522f, 
    -0.01817219f, 0.02893816f, -0.16240698f, -0.06544995f, 0.21471813f, -0.12138447f, -0.02528674f, -0.04802726f, 
    0.23113623f, -0.13031732f, -0.03258397f, -0.03362933f, 0.02450806f, -0.02933705f, -0.11076069f, 0.16742687f, 
    0.15651548f, 0.13656960f, 0.21682496f, -0.07562309f, -0.12644070f, 0.01312562f, -0.09524027f, 0.16009793f, 
    0.12154859f, 0.05372909f, 0.19685437f, 0.11010128f, 0.31502697f, 0.05872048f, -0.38527673f, 0.02564593f, 
    -0.05121456f, 0.19161947f, 0.11809825f, -0.00527101f, 0.10270943f, 0.23946859f, -0.15689617f, 0.05899314f, 
    -0.25270063f, -0.07386068f, 0.13761736f, 0.08016556f, 0.09725492f, 0.17974275f, -0.04326785f, 0.07867111f, 
    -0.01493111f, 0.14329313f, -0.04464028f, -0.03506181f, -0.11506332f, 0.01238047f, 0.09223591f, 0.08613041f, 
    0.05850505f, 0.04189084f, 0.03704206f, 0.02774226f, 0.06452813f, 0.15862127f, 0.02810952f, 0.07739186f, 
    0.14962229f, -0.08976305f, 0.15391806f, 0.02467215f, 0.02344236f, -0.14406402f, 0.01968303f, -0.12731837f, 
    0.08610181f, 0.11504219f, 0.04235318f, -0.02616077f, -0.09912389f, 0.16177852f, -0.02781677f, 0.08224259f, 
    -0.01034292f, 0.15937616f, 0.07110251f, -0.20519844f, -0.03680952f, 0.44335505f, 0.22702853f, -0.12153246f, 
    -0.03437965f, 0.10973608f, -0.10581060f, 0.09752711f, 0.01059826f, 0.05307232f, -0.15111224f, 0.00913774f, 
    0.06147543f, 0.09667020f, 0.15153231f, 0.16323042f, -0.01588468f, 0.07361718f, 0.01341323f, 0.00797487f, 
    0.32672051f, -0.22601342f, 0.26784083f, -0.02460146f, 0.03393688f, -0.01289564f, -0.01508970f, 0.00014007f, 
    -0.03468455f, 0.04272892f, -0.04872257f, -0.05816662f, 0.04134129f, 0.00113457f, 0.03971062f, 0.01314548f, 
    -0.04713646f, -0.00988406f, -0.05098750f, -0.04577766f, -0.05983691f, -0.08128031f, 0.03324832f, -0.00904902f, 
    0.03702530f, -0.06991092f, -0.01056380f, -0.04392854f, 0.01007111f, 0.05942887f, 0.00792151f, 0.02921069f, 
    -0.01288622f, -0.03296847f, 0.05131105f, -0.03170955f, 0.02800362f, -0.03197994f, -0.02940807f, -0.07883824f, 
    0.02865723f, 0.04223383f, -0.04724157f, 0.03885174f, -0.08197685f, 0.00347824f, -0.07646011f, 0.01557528f, 
    -0.01644481f, -0.01271860f, -0.01785608f, 0.04378055f, -0.06213104f, 0.03074039f, -0.01738493f, -0.07951143f, 
    -0.07997904f, -0.02480010f, -0.01931758f, -0.04094879f, 0.02529601f, -0.06427663f, -0.06632759f, -0.05517780f, 
    -0.00309027f, 0.02873914f, -0.02515736f, -0.05425366f, -0.02437561f, -0.03300233f, -0.03529261f, -0.03434024f, 
    -0.07109206f, -0.05014212f, -0.08250961f, 0.01392685f, -0.06995579f, -0.05009660f, -0.07317544f, -0.04002699f, 
    0.04701466f, 0.01023746f, -0.06145731f, -0.00690901f, -0.06819254f, -0.05419499f, -0.04208925f, 0.05443792f, 
    -0.05428397f, -0.02886532f, -0.02698936f, -0.06194059f, -0.00239464f, 0.00266203f, -0.05529916f, -0.06166616f, 
    0.02672781f, -0.04383845f, -0.03791672f, -0.04560325f, -0.01274074f, -0.02086343f, -0.01029021f, 0.03286839f, 
    -0.03756082f, 0.01899663f, -0.00957204f, -0.02802328f, 0.07119171f, 0.04331989f, -0.00643499f, -0.03715018f, 
    -0.04156423f, 0.04926895f, -0.04820031f, 0.00012861f, -0.10823152f, -0.00059062f, -0.08370417f, -0.02999423f, 
    0.02160268f, 0.00109116f, -0.08222704f, -0.07715817f, -0.06147879f, -0.03456623f, -0.04309286f, -0.02214654f, 
    -0.09501920f, -0.00735391f, -0.05565705f, 0.02960948f, 0.03788158f, -0.03323676f, 0.02076599f, -0.06898512f, 
    0.00819144f, 0.00938504f, 0.00947548f, 0.00060234f, 0.04421795f, 0.03185492f, 0.05297568f, -0.08854233f, 
    0.02799919f, 0.02616370f, 0.04919796f, 0.03539041f, -0.02310325f, -0.02637869f, 0.01187677f, 0.04451663f, 
    -0.01547746f, 0.01455380f, -0.00651287f, -0.02494865f, -0.01637793f, -0.06376955f, -0.04215308f, -0.04755281f, 
    0.02992938f, 0.01013250f, -0.03976687f, -0.07219866f, 0.01087265f, -0.01738228f, -0.01177091f, 0.02703395f, 
    -0.02846482f, -0.07151530f, -0.06360491f, -0.03191162f, -0.05285728f, -0.05870882f, -0.02647151f, 0.02767599f, 
    0.03535366f, 0.00904956f, -0.06440802f, -0.00837455f, -0.04059232f, 0.00587300f, 0.04419014f, 0.05291417f, 
    0.06228838f, -0.05111310f, 0.03785219f, 0.04351562f, 0.03466550f, 0.01042634f, -0.05650187f, -0.00022031f, 
    -0.05639027f, 0.03707249f, 0.00397373f, -0.01355023f, -0.04897923f, -0.05015016f, -0.05046890f, 0.01702653f, 
    -0.05977485f, 0.03098453f, -0.02497336f, -0.01752557f, -0.04179473f, 0.04055572f, -0.00976911f, -0.00351186f, 
    -0.07062186f, -0.02050533f, 0.01634679f, 0.00586739f, 0.01953072f, -0.04521261f, -0.06746557f, 0.04771836f, 
    -0.03445589f, 0.02601653f, -0.00077478f, -0.00152843f, -0.04144457f, -0.05748677f, -0.03204685f, 0.02821563f, 
    0.01450320f, 0.02491410f, 0.01847173f, -0.01678682f, 0.03842645f, 0.05702872f, -0.02856321f, 0.04694546f, 
    -0.02971256f, -0.09388225f, -0.01889171f, -0.06531897f, -0.01957728f, 0.04171637f, 0.02902985f, -0.03010418f, 
    0.03083443f, -0.05566540f, -0.00457309f, 0.03561885f, 0.00302387f, -0.03391721f, -0.01838494f, -0.04245310f, 
    -0.05196367f, 0.03523360f, -0.06290141f, -0.01141220f, 0.00182094f, 0.02869577f, -0.03696209f, 0.03012636f, 
    -0.06153928f, 0.04652197f, 0.00056936f, 0.00457822f, -0.03310332f, -0.03081343f, -0.05372640f, -0.04190347f, 
    0.01489882f, -0.02045906f, 0.03475864f, 0.00305625f, -0.00827032f, -0.00453638f, 0.01867668f, -0.06794941f, 
    0.00555571f, -0.04375180f, 0.00660282f, 0.01689386f, -0.04316945f, -0.03252381f, -0.04691783f, 0.00069005f, 
    -0.06621957f, 0.00246077f, 0.01569418f, 0.00438554f, 0.02404236f, -0.00631742f, 0.02633848f, -0.01851816f, 
    0.03027702f, -0.06911428f, -0.02208477f, 0.00539709f, -0.05021155f, -0.04907677f, 0.06153059f, 0.00307375f, 
    -0.02794384f, 0.01459478f, -0.04564182f, -0.03537016f, 0.01937940f, 0.00552202f, -0.03497037f, -0.04285018f, 
    0.01686375f, -0.07499090f, 0.00672949f, -0.04987695f, -0.03898251f, 0.01611170f, -0.02454693f, -0.06152803f, 
    0.02026963f, -0.04454867f, -0.02539926f, -0.05374724f, -0.08654361f, -0.07794292f, -0.02260861f, 0.02362348f, 
    0.01471022f, -0.03634640f, -0.07803401f, -0.01569327f, 0.03080223f, -0.01551094f, -0.04440265f, -0.08236286f, 
    -0.01223176f, -0.05829003f, 0.00887644f, -0.02700170f, 0.02992735f, -0.04156678f, -0.06306660f, -0.05106346f, 
    0.01171043f, 0.02793158f, 0.03822236f, -0.00129196f, -0.05950949f, -0.01427430f, 0.04057579f, -0.06486122f, 
    0.02242595f, -0.07029751f, 0.00936604f, 0.01589162f, -0.06409109f, 0.01385743f, -0.06196322f, -0.01904684f, 
    0.00587907f, -0.05845067f, -0.01158144f, 0.00670666f, -0.01716725f, -0.05219762f, -0.07696062f, -0.07734647f, 
    0.00660085f, -0.05375365f, -0.03830006f, -0.01236145f, -0.04761284f, 0.03116739f, -0.04851594f, -0.02349370f, 
    -0.07126801f, -0.02299013f, -0.01508055f, -0.05824389f, -0.05340291f, 0.00461436f, 0.02387717f, -0.03604249f, 
    0.02928454f, -0.00454125f, -0.01899060f, -0.05741669f, -0.01909855f, -0.05343021f, 0.01227365f, -0.05330699f, 
    -0.08440888f, 0.01341415f, -0.00386535f, -0.05484554f, -0.07506426f, -0.05759055f, 0.00254298f, -0.03438018f, 
    -0.00798163f, -0.00469580f, -0.04114683f, -0.01574255f, -0.00505477f, -0.08178043f, -0.06720813f, 0.02495620f, 
    -0.08085962f, -0.04282010f, 0.01837960f, -0.07931473f, -0.04608806f, -0.01474035f, -0.00465257f, 0.01460729f, 
    0.01098828f, -0.05233630f, 0.03235209f, 0.04057591f, -0.08167291f, 0.01352210f, 0.02127232f, 0.03338280f, 
    -0.01565952f, -0.04805949f, 0.01558312f, 0.00793248f, -0.01992939f, -0.04246495f, -0.03447226f, -0.05176125f, 
    0.00661521f, 0.02940824f, 0.00407286f, 0.04730474f, -0.00461495f, -0.01208658f, -0.04199513f, -0.07582794f, 
    -0.03822027f, -0.07158627f, -0.00349900f, 0.02100046f, -0.07168780f, -0.06341679f, -0.07744981f, -0.00644653f, 
    -0.06033960f, -0.03686552f, -0.05772601f, -0.03035801f, -0.01485944f, 0.01907831f, -0.04043480f, 0.02318725f, 
    -0.06303865f, -0.05665926f, 0.03204704f, 0.00755739f, -0.06414268f, -0.02075422f, -0.06012049f, -0.05357498f, 
    -0.02366891f, 0.02393885f, 0.01907465f, -0.07729971f, -0.05036354f, 0.03936208f, 0.01626003f, -0.02384168f, 
    0.00004947f, 0.02529823f, -0.06820642f, 0.00132051f, 0.01410135f, 0.01517183f, -0.02406516f, -0.03228103f, 
    -0.04264995f, -0.02211858f, -0.04651987f, -0.00073956f, -0.03288353f, 0.00057263f, -0.01360092f, -0.05308538f, 
    -0.04469935f, -0.07157464f, -0.04275443f, 0.02634648f, 0.02086833f, -0.05934910f, -0.03770249f, 0.01698803f, 
    -0.02139221f, -0.01883554f, -0.00908964f, -0.02000828f, -0.04558435f, -0.02691337f, -0.04566767f, 0.00258891f, 
    0.02360216f, -0.06205896f, -0.03073210f, -0.01370439f, -0.06727168f, -0.06685250f, -0.03529769f, -0.00475906f, 
    -0.00115672f, -0.00485035f, -0.01200264f, -0.01985689f, 0.01867435f, 0.00602457f, 0.00949727f, -0.00042450f, 
    -0.04325994f, 0.02355475f, -0.04806927f, 0.00789036f, -0.00203282f, -0.03113798f, 0.01127111f, -0.04739528f, 
    -0.01045098f, -0.01811864f, 0.02072431f, -0.00525092f, -0.03929080f, -0.04457960f, -0.02270603f, -0.02235927f, 
    -0.04817981f, -0.07695390f, -0.04991374f, -0.05637862f, 0.02047617f, -0.01775757f, 0.01238794f, -0.05388581f, 
    -0.04226826f, -0.01012193f, -0.01375596f, -0.03854532f, 0.01398016f, 0.01803490f, -0.00540699f, -0.03354100f, 
    0.00375912f, -0.04958639f, -0.05670071f, -0.04096072f, -0.01107510f, -0.01808999f, -0.06283367f, -0.01127433f, 
    -0.07362004f, -0.01121679f, -0.00282898f, -0.05011071f, -0.01960292f, -0.04134801f, -0.00217836f, -0.04698452f, 
    0.01768206f, -0.02633574f, 0.01793817f, 0.00969739f, -0.02956524f, -0.00344951f, -0.07036558f, 0.00337260f, 
    -0.06903505f, -0.00559536f, -0.00036218f, -0.02350761f, -0.04169271f, -0.00952827f, 0.01675011f, 0.00638154f, 
    -0.05072344f, 0.00239917f, -0.01746998f, 0.01729339f, -0.02066767f, 0.03340763f, -0.07457436f, -0.03852643f, 
    0.01426024f, 0.18292740f, -0.02586673f, -0.02537826f, -0.06576513f, 0.06236901f, 0.06791614f, -0.05821410f, 
    0.17611834f, 0.11130344f, 0.06487944f, 0.16297871f, -0.00453807f, -0.00617245f, 0.16730748f, 0.08350588f, 
    -0.08078969f, -0.15870394f, 0.23240224f, -0.15872343f, -0.00751954f, -0.15074416f, 0.05896806f, -0.03323532f, 
    0.11508451f, 0.14358075f, 0.03223204f, 0.07661932f, -0.03240461f, -0.03001435f, -0.04480033f, 0.04339634f, 
    -0.04044641f, 0.03717533f, 0.03475018f, 0.05118722f, -0.28199339f, 0.09480491f, 0.09125610f, -0.05611969f, 
    -0.03575653f, 0.17700900f, 0.14166981f, -0.19651029f, 0.10954081f, 0.05115648f, 0.02106094f, -0.06062309f, 
    -0.09919692f, 0.04944693f, 0.06926540f, 0.12960628f, 0.02560393f, -0.10101666f, 0.22360317f, 0.06201758f, 
    0.17978987f, 0.18688396f, 0.08013477f, -0.05645841f, -0.08078468f, 0.09466615f, 0.01893446f, 0.02651784f, 
    0.00134622f, 0.03524071f, -0.06694132f, 0.02421823f, -0.12898630f, -0.08967628f, -0.11126367f, -0.12295092f, 
    0.07683646f, 0.02772361f, -0.00417252f, 0.08298673f, -0.06892091f, -0.08553179f, -0.02915484f, -0.07116421f, 
    0.11097960f, 0.25417060f, 0.00519341f, 0.00597821f, 0.34443507f, -0.01340476f, 0.10622979f, 0.03566974f, 
    -0.01968544f, 0.06482004f, 0.13076310f, -0.07031968f, 0.05976781f, 0.00624981f, 0.07726305f, -0.06067041f, 
    -0.05076975f, 0.16464132f, -0.07767202f, -0.09481344f, -0.18621223f, -0.15306020f, -0.06924102f, 0.06501944f, 
    -0.06452751f, 0.04645175f, 0.14864498f, -0.06691880f, 0.15275386f, 0.23474157f, 0.24002497f, -0.00706555f, 
    0.05244343f, 0.00819739f, -0.06861150f, 0.01267507f, 0.01661465f, 0.07954093f, -0.04274719f, 0.05200804f, 
    -0.01966612f, -0.13608445f, 0.00956451f, 0.05500837f, 0.06404493f, 0.03435890f, -0.10048681f, 0.21763083f, 
    0.31058031f, 0.13244082f, -0.17177321f, -0.00852214f, -0.18567008f, 0.07067827f, 0.04683177f, 0.17211086f, 
    0.07265050f, -0.19150619f, 0.09958044f, -0.03780990f, -0.07251049f, 0.04022100f, 0.07814761f, 0.09659109f, 
    0.05383722f, 0.27753532f, -0.00579840f, 0.01886631f, -0.12532964f, -0.05915762f, 0.10822228f, 0.08384773f, 
    0.20129584f, -0.00926537f, -0.07841772f, 0.13761508f, -0.01024496f, 0.02384884f, 0.11316793f, 0.14018479f, 
    -0.10768244f, -0.09727725f, -0.27901813f, 0.02204110f, 0.05846177f, 0.15395348f, 0.16847737f, 0.07597997f, 
    0.05079240f, 0.01749474f, 0.03334108f, -0.25564444f, 0.05872696f, -0.02640825f, 0.09065759f, -0.18363190f, 
    -0.22856466f, -0.00473289f, -0.13202269f, -0.06199585f, 0.20905858f, -0.18472488f, 0.00499421f, -0.19347285f, 
    -0.12077714f, -0.20894039f, -0.00353471f, 0.21465564f, -0.07486713f, -0.00218767f, -0.03553399f, -0.04442906f, 
    0.04037191f, 0.21277840f, -0.08082908f, -0.04516942f, -0.01790320f, 0.09626938f, -0.31952858f, -0.11393075f, 
    -0.26332679f, 0.00290183f, 0.12115973f, 0.00085282f, 0.03570164f, 0.07901105f, -0.00484461f, 0.11469150f, 
    -0.24506721f, -0.04424869f, -0.13891485f, 0.07343785f, -0.01001228f, 0.06472734f, 0.11312157f, -0.10421114f, 
    -0.12350056f, 0.04393580f, -0.05407846f, -0.05504432f, -0.05969840f, 0.17569661f, 0.15188393f, -0.18376841f, 
    -0.04222415f, 0.00115083f, -0.00576158f, -0.09738056f, -0.11557887f, -0.06350224f, 0.03751948f, 0.06432223f, 
    0.02259098f, -0.02365036f, 0.20281504f, -0.27680561f, 0.20881806f, -0.01451701f, -0.05598889f, 0.00487576f, 
    -0.04289627f, 0.10933570f, 0.01326123f, -0.02804763f, -0.11650652f, 0.00267105f, 0.00198625f, -0.02845553f, 
    -0.21575701f, -0.03611306f, -0.09463317f, -0.14756581f, 0.00555715f, -0.03140497f, 0.22368617f, -0.13152683f, 
    -0.05879064f, 0.13825457f, -0.04561152f, 0.12427779f, -0.01297754f, -0.16542549f, 0.01743593f, 0.08683710f, 
    0.17285043f, -0.21246639f, -0.11274824f, -0.09789744f, 0.03137221f, 0.02683748f, 0.12075230f, -0.05848131f, 
    0.22175764f, -0.06864072f, -0.04135488f, -0.05634741f, 0.07427029f, 0.00113755f, 0.11640701f, -0.25617683f, 
    -0.05511801f, 0.02176538f, 0.04647511f, 0.20387213f, -0.16230559f, 0.07523297f, -0.12312563f, 0.02982115f, 
    0.20246480f, 0.19685322f, 0.20289913f, -0.10416428f, -0.10170675f, -0.08501310f, 0.08223307f, -0.11926088f, 
    -0.02383911f, 0.15874535f, 0.21294129f, 0.01554648f, -0.06746535f, -0.03734748f, -0.07743093f, -0.13388520f, 
    -0.11367146f, 0.03787272f, 0.05370201f, -0.04378975f, 0.24461694f, -0.04116657f, 0.15638256f, 0.05545621f, 
    -0.16451378f, 0.08025476f, 0.07075232f, 0.05086391f, -0.11659009f, -0.02287447f, -0.04469462f, 0.08685043f, 
    0.04199712f, -0.02318289f, -0.07875899f, 0.11608443f, -0.42211387f, 0.01492676f, 0.04240421f, -0.01352229f, 
    -0.02761132f, 0.08830043f, -0.07548855f, -0.09486938f, -0.08258790f, 0.02771225f, -0.03776475f, -0.07283957f, 
    0.02332248f, 0.00440334f, -0.09862802f, -0.28913921f, -0.03371321f, -0.05007659f, 0.18145084f, -0.04567723f, 
    0.02889662f, 0.05843151f, 0.00231198f, 0.06253325f, 0.04354272f, -0.08636582f, 0.05767383f, -0.08580283f, 
    0.05102490f, -0.31106412f, -0.12275664f, -0.04434123f, 0.00806152f, -0.17057183f, -0.06279495f, -0.14697534f, 
    0.08246323f, 0.10665163f, -0.13252224f, -0.01350120f, 0.01337304f, -0.23797432f, -0.08107928f, 0.01586857f, 
    0.01017802f, -0.00158216f, 0.02964328f, -0.01164512f, 0.14093156f, 0.15541640f, -0.05428758f, 0.09290237f, 
    0.02236738f, -0.06399693f, -0.17385578f, 0.05206684f, -0.02150529f, -0.16585943f, -0.08218075f, -0.00265706f, 
    -0.06006046f, 0.13789307f, 0.02382487f, -0.16800497f, -0.04174883f, -0.06331922f, -0.03087821f, 0.04749867f, 
    0.08932201f, 0.10459440f, 0.08986960f, 0.10412534f, 0.06306988f, 0.07290480f, 0.15062985f, 0.12845995f, 
    0.14054301f, 0.11501823f, 0.03980415f, 0.15289888f, 0.00706045f, 0.02185027f, -0.06742332f, -0.17492466f, 
    0.04111835f, -0.13857506f, 0.03715391f, -0.09987077f, -0.00140455f, 0.03720489f, -0.30264911f, 0.21620882f, 
    0.24895103f, 0.09447046f, 0.00440791f, -0.11815280f, 0.18071447f, 0.19953306f, 0.02441480f, -0.08187706f, 
    0.03037276f, -0.22845003f, 0.12523493f, -0.04462154f, 0.10249334f, 0.01029585f, -0.20364845f, -0.01672411f, 
    0.05240218f, 0.07585466f, -0.09457807f, 0.08552141f, -0.03978849f, -0.02880820f, -0.03541326f, 0.17778862f, 
    0.04365714f, 0.06059587f, -0.04016282f, 0.11698879f, 0.05572352f, -0.13374256f, 0.12466754f, 0.02249501f, 
    0.11315225f, -0.00686821f, -0.26444957f, 0.19324896f, 0.48185948f, -0.03764363f, 0.00734265f, 0.05354594f, 
    -0.08744092f, 0.09157453f, -0.04086921f, -0.16383639f, 0.18438007f, -0.00840228f, 0.08407760f, 0.09051752f, 
    0.06670026f, -0.05940285f, -0.06818076f, 0.25527632f, -0.01549145f, -0.03874466f, -0.38184515f, -0.03677093f, 
    -0.07421721f, -0.15693551f, -0.00445696f, 0.08068828f, 0.27139458f, 0.22342879f, 0.13531184f, -0.26419729f, 
    0.10116813f, 0.04900267f, 0.13719736f, 0.03589331f, -0.30239004f, -0.06651224f, 0.10739420f, -0.02507824f, 
    0.06395619f, -0.15036158f, -0.18332922f, -0.09235023f, -0.10483406f, -0.05491679f, -0.08691013f, 0.03821038f, 
    -0.27650094f, -0.07033289f, -0.04052575f, -0.03134726f, 0.10051619f, 0.12856728f, 0.09008000f, -0.03427537f, 
    -0.13589746f, 0.02179664f, 0.04545910f, 0.07288205f, 0.05108803f, -0.02755233f, -0.05704966f, 0.03375239f, 
    0.03874161f, -0.05584127f, -0.16108042f, -0.02062892f, -0.03234146f, -0.10314726f, -0.09603759f, -0.01949054f, 
    0.06194643f, 0.00098985f, 0.27306989f, -0.11075968f, 0.10549995f, 0.05547044f, 0.02725863f, 0.07904766f, 
    -0.06737377f, -0.09793824f, 0.03895818f, 0.03523510f, 0.00035462f, -0.24167754f, -0.08533272f, 0.13487962f, 
    0.08635525f, -0.13016056f, 0.14927466f, -0.16982448f, -0.20607463f, 0.00153685f, 0.33920434f, 0.01525074f, 
    0.05656786f, -0.07559974f, 0.24202000f, -0.08593913f, 0.03888689f, -0.08829451f, -0.10325950f, -0.18670925f, 
    0.04342848f, -0.25713450f, -0.12346852f, -0.08077943f, 0.02231649f, 0.00216849f, 0.02941561f, -0.09449898f, 
    -0.02583709f, -0.12710011f, 0.20460258f, -0.06544055f, 0.05995720f, 0.16041486f, 0.03318928f, 0.31611127f, 
    0.11552417f, 0.15468049f, -0.15335113f, -0.17689237f, -0.07403530f, -0.18522485f, -0.01644058f, -0.03927997f, 
    -0.03766842f, -0.05330571f, 0.00585777f, -0.05814113f, -0.03768707f, 0.00262068f, -0.04703826f, -0.02402223f, 
    -0.06113067f, -0.05052869f, 0.00885300f, 0.04602705f, -0.02800310f, -0.05507025f, -0.01876807f, 0.02029359f, 
    0.02933505f, -0.06524632f, -0.02106140f, -0.00869850f, 0.03948593f, -0.05478877f, -0.00142766f, 0.01509281f, 
    0.03424730f, -0.04854545f, -0.01278126f, 0.01526928f, -0.01983345f, 0.00209005f, -0.06518600f, 0.04641344f, 
    0.03464840f, -0.04313508f, 0.01166513f, -0.02089936f, 0.00720044f, -0.01352225f, -0.01130797f, 0.02454299f, 
    0.00735964f, 0.02337665f, 0.00134707f, 0.03547952f, -0.04166584f, 0.01139185f, 0.04179046f, 0.01274252f, 
    -0.06362486f, 0.02187821f, 0.00070804f, -0.02256397f, 0.02298195f, 0.04745730f, 0.04958425f, -0.02893873f, 
    -0.00728103f, 0.04751931f, -0.01987314f, 0.00442796f, -0.03892070f, 0.00701103f, -0.06175642f, -0.01299574f, 
    -0.04273485f, 0.02539153f, 0.00370156f, 0.04490769f, -0.05331463f, 0.03343767f, 0.00360396f, -0.04129249f, 
    -0.00455713f, -0.00352118f, -0.05419545f, 0.03872279f, -0.01683325f, 0.02517502f, -0.04678743f, -0.03975227f, 
    0.04549032f, 0.03954540f, 0.02323453f, 0.03159741f, 0.00088606f, -0.01429521f, -0.04668838f, 0.01244403f, 
    -0.05573519f, 0.00849690f, -0.03160502f, 0.03591526f, 0.03763285f, 0.04286575f, 0.00216828f, -0.05576906f, 
    -0.06042024f, 0.00404354f, 0.02339235f, -0.03909408f, -0.03916406f, -0.00155970f, 0.01038904f, 0.03677982f, 
    0.04320031f, -0.04092430f, -0.00506410f, 0.00588582f, -0.02501455f, 0.02968781f, -0.02774945f, -0.04242260f, 
    -0.01377405f, -0.00365958f, 0.05101771f, -0.04634852f, -0.05845384f, -0.03623555f, -0.04622905f, 0.00571366f, 
    -0.03211804f, -0.03035024f, 0.02480942f, 0.01257005f, -0.05351684f, -0.05833508f, -0.06673093f, 0.04187545f, 
    0.04972456f, 0.00253533f, -0.01983044f, 0.01124182f, 0.00698966f, 0.01310872f, -0.04239934f, 0.03397904f, 
    0.00029501f, 0.02265056f, 0.04522844f, -0.00517337f, -0.04812228f, 0.01070841f, 0.04286961f, -0.02376425f, 
    -0.04775414f, -0.04298884f, -0.01583752f, 0.02334666f, 0.02085226f, 0.00957379f, -0.02303391f, 0.02463936f, 
    0.00951310f, -0.03857780f, -0.01279360f, -0.01439710f, 0.00955441f, -0.05435801f, -0.03634369f, -0.02276241f, 
    -0.00252636f, -0.05994332f, -0.05079346f, 0.03111149f, 0.04237568f, 0.02589894f, -0.04664107f, 0.02572269f, 
    -0.05474764f, 0.03031372f, 0.03034018f, -0.02203949f, 0.01607502f, 0.04273980f, -0.03671749f, 0.00253239f, 
    0.02232489f, -0.02668647f, 0.02299006f, 0.04482047f, 0.02763582f, -0.01361734f, -0.02195816f, -0.03666668f, 
    0.04326836f, 0.02269505f, 0.00195736f, 0.00134407f, -0.05658578f, 0.02021162f, -0.01588450f, 0.04216746f, 
    -0.06820128f, 0.05039915f, -0.05170736f, -0.03085473f, -0.00200152f, -0.04827449f, 0.01140760f, 0.03612157f, 
    0.02129981f, -0.02051317f, -0.03793717f, -0.03063371f, 0.02530864f, -0.04447214f, -0.06652165f, -0.01745195f, 
    -0.03405556f, -0.02450030f, -0.04764810f, 0.03108377f, -0.05701606f, 0.00534974f, -0.03195886f, -0.01634349f, 
    -0.00574518f, -0.01406064f, -0.00401260f, -0.04330165f, -0.04958551f, 0.01540889f, 0.00003079f, -0.03212273f, 
    0.01811102f, -0.03575131f, -0.02894062f, -0.04440435f, 0.00044064f, -0.04247659f, 0.01125326f, -0.05208146f, 
    -0.05568786f, -0.04876131f, 0.03481437f, -0.00083027f, 0.03507632f, 0.04054611f, -0.04382865f, 0.03074376f, 
    -0.06278626f, 0.04753613f, 0.04753528f, 0.04509468f, -0.03073919f, 0.03257516f, -0.01167541f, 0.04295208f, 
    0.02021876f, -0.02837774f, 0.00875203f, -0.06532235f, 0.02280957f, 0.03479071f, 0.04376756f, -0.00768103f, 
    -0.01206366f, -0.01898344f, 0.00930813f, -0.05704152f, -0.00439268f, 0.03272770f, -0.02007362f, -0.02963565f, 
    -0.03767298f, 0.02409392f, -0.05911190f, -0.00983435f, -0.01456719f, 0.03585399f, -0.05041553f, 0.03747815f, 
    -0.03834519f, -0.04249394f, 0.05204417f, 0.02328311f, -0.00913991f, 0.00676229f, -0.03180071f, -0.05937452f, 
    -0.02611582f, 0.03458031f, -0.06266201f, 0.02924704f, 0.02381391f, 0.03683494f, -0.06547896f, -0.00426097f, 
    0.01856169f, -0.05200933f, -0.06327859f, -0.00412380f, -0.02650672f, -0.04381666f, -0.02735133f, -0.02814355f, 
    0.05061859f, -0.02878142f, -0.00169394f, -0.02979894f, 0.03022594f, -0.08035534f, -0.01329966f, 0.00649149f, 
    0.05574695f, 0.02583792f, 0.00829808f, -0.06811806f, 0.02577029f, 0.00946967f, -0.04407719f, -0.02951499f, 
    -0.03419549f, -0.02349239f, -0.05189114f, -0.01803632f, -0.04562800f, -0.02269659f, -0.06195613f, -0.05042292f, 
    -0.00463281f, 0.00275356f, -0.04857003f, 0.01404040f, 0.04986072f, 0.01702863f, 0.01496471f, -0.04431825f, 
    0.03831694f, -0.04730716f, -0.04935702f, -0.04172434f, 0.00560204f, -0.02775465f, -0.02385461f, -0.04838793f, 
    -0.02990225f, -0.00530173f, 0.00524070f, 0.05181388f, 0.04575248f, -0.05447733f, -0.08467660f, -0.04532138f, 
    0.02430084f, -0.05232698f, -0.03628904f, -0.01642195f, -0.01537894f, -0.05613087f, -0.05199183f, -0.04697650f, 
    -0.00356142f, -0.04991388f, 0.01301742f, 0.03346206f, -0.07312394f, 0.00529178f, -0.04539281f, -0.05215384f, 
    0.00986714f, 0.03492929f, -0.00011281f, -0.07752221f, 0.00969273f, 0.01068948f, -0.01826408f, -0.01053883f, 
    0.04361175f, 0.00919681f, -0.01664269f, 0.02237569f, 0.00141419f, 0.04570622f, -0.00005004f, 0.03038482f, 
    -0.01422153f, 0.02239995f, -0.02110125f, -0.01520264f, 0.02004690f, -0.03408448f, -0.06725791f, -0.00974087f, 
    -0.01172452f, 0.00329782f, 0.00991013f, 0.01006876f, -0.06236766f, -0.02478387f, 0.03217741f, -0.00670930f, 
    -0.03982912f, 0.03339653f, -0.05200581f, 0.03026708f, 0.01265347f, 0.03263678f, -0.05896042f, -0.02286009f, 
    0.01514333f, -0.04063480f, -0.02177127f, -0.01895475f, 0.02908673f, 0.03185361f, 0.03465398f, 0.03319630f, 
    0.01645026f, -0.03846301f, -0.00609269f, -0.01076974f, 0.03182973f, -0.04337977f, 0.00019089f, 0.00648404f, 
    -0.00494598f, -0.04634687f, -0.00636970f, 0.01623334f, -0.00254255f, 0.02118163f, 0.01529770f, -0.06620630f, 
    0.01192211f, 0.02989885f, -0.01154197f, -0.02875443f, 0.03178433f, -0.02775885f, -0.03501256f, -0.04956809f, 
    0.04685578f, -0.04259118f, 0.00459258f, -0.05943824f, 0.01621819f, -0.00394163f, -0.00139300f, 0.00320286f, 
    0.04316939f, 0.01529899f, 0.00526594f, -0.05482034f, -0.04545617f, -0.03145806f, -0.05391081f, -0.04716972f, 
    -0.01271956f, -0.03105213f, -0.00255555f, -0.03809034f, 0.01708971f, 0.00516964f, -0.04764955f, 0.03731608f, 
    0.00299930f, 0.00685298f, 0.03045348f, -0.02086103f, -0.03748850f, 0.04943299f, 0.07146752f, -0.02489416f, 
    0.02279476f, -0.01601285f, -0.06807632f, -0.03186997f, -0.02780535f, 0.01977300f, -0.04549633f, -0.03793506f, 
    -0.02257581f, 0.01119184f, -0.05359752f, -0.00338742f, -0.03056752f, 0.02225421f, -0.02453867f, 0.00940313f, 
    -0.01767062f, 0.04336872f, -0.04090943f, 0.02439288f, 0.01919121f, 0.04294410f, 0.00685543f, -0.06579717f, 
    -0.00573133f, 0.04350354f, -0.01316499f, 0.00994440f, -0.06321586f, -0.01859050f, 0.04093705f, -0.06953407f, 
    0.00556571f, -0.06398854f, -0.00091534f, 0.03892257f, -0.04369655f, 0.03161023f, 0.03050865f, 0.01297006f, 
    0.03554333f, -0.06196094f, 0.02886361f, -0.05850348f, 0.00934256f, 0.03144780f, -0.02012298f, -0.06404823f, 
    0.04714162f, -0.06861928f, 0.04074602f, 0.04669570f, -0.01491744f, -0.00906512f, -0.00776846f, -0.04316636f, 
    -0.01268288f, -0.05260339f, -0.03679480f, -0.05518440f, 0.01240750f, -0.03302588f, -0.07238912f, -0.00614086f, 
    0.04669039f, 0.01332557f, -0.05187161f, 0.04728565f, 0.03501136f, 0.00416528f, -0.05264113f, -0.03601945f, 
    -0.03121732f, 0.04732552f, 0.03340572f, -0.04141018f, -0.04323927f, -0.02352051f, -0.01504643f, 0.02196247f, 
    -0.03583492f, 0.01697613f, -0.01289556f, -0.05766747f, 0.01868510f, -0.00291314f, -0.01103240f, -0.02500972f, 
    -0.06474746f, -0.01341051f, 0.00553436f, -0.05922686f, -0.04289483f, -0.01859276f, -0.01356102f, -0.01901867f, 
    0.02072881f, -0.02439017f, 0.03860739f, -0.00791630f, 0.01388405f, -0.01085956f, -0.06558463f, 0.04804734f, 
    0.04811732f, 0.00175652f, 0.00071633f, -0.04377268f, -0.00131034f, -0.04326128f, 0.03718963f, -0.00589477f, 
    0.30291694f, -0.31274968f, -0.18772259f, -0.08103138f, -0.03980371f, 0.08129663f, 0.05729871f, 0.14023915f, 
    -0.01703523f, 0.01633198f, -0.43523192f, 0.06853344f, 0.13403557f, 0.04310738f, -0.01125658f, 0.11155501f, 
    -0.04187005f, 0.01598672f, 0.14951570f, 0.05549755f, -0.18124197f, 0.03454753f, -0.22442992f, -0.05904592f, 
    -0.06570742f, 0.10671060f, 0.08388773f, -0.29417002f, -0.08132143f, -0.09859658f, -0.16844733f, 0.10095053f, 
    0.06231942f, 0.09672926f, 0.06726909f, 0.07619307f, -0.08944862f, -0.24486890f, 0.10377659f, -0.00751032f, 
    0.00960864f, -0.01793277f, 0.28032410f, -0.00805552f, -0.16365513f, 0.17040320f, -0.13928398f, 0.32384035f, 
    -0.00170428f, -0.01477928f, -0.01750530f, -0.03770081f, -0.17658411f, -0.10919970f, -0.06844376f, -0.03003456f, 
    0.14080630f, -0.21471331f, -0.10750459f, 0.06720280f, 0.01783411f, 0.22982976f, 0.07801072f, 0.04683570f, 
    -0.31108725f, 0.01241591f, 0.19005591f, 0.08524171f, 0.04648549f, -0.04025649f, 0.04706334f, -0.07732029f, 
    0.03315553f, -0.21557738f, -0.05741005f, -0.17199278f, 0.11058725f, -0.11434887f, 0.09100770f, 0.16038741f, 
    -0.14103110f, 0.15346782f, 0.07364686f, -0.14321667f, -0.02936750f, 0.02001786f, 0.12625444f, -0.33017313f, 
    0.03391745f, 0.26575166f, -0.39204815f, -0.30628055f, -0.10979253f, 0.24423937f, -0.05299950f, 0.24314663f, 
    0.17941709f, 0.24271908f, -0.17803396f, 0.20251016f, -0.00491927f, -0.00928018f, -0.02827480f, -0.01356382f, 
    0.18271871f, 0.02929648f, 0.04272212f, -0.02094379f, -0.14917260f, 0.17668222f, -0.17421718f, -0.08650160f, 
    -0.08201965f, -0.05987176f, -0.12933899f, 0.00940858f, 0.07141442f, 0.21098705f, -0.09947771f, 0.17178510f, 
    0.09050372f, 0.11617362f, 0.00036345f, 0.04216651f, 0.06552357f, 0.14767937f, -0.18064560f, -0.12670325f, 
    0.08558841f, -0.09159785f, -0.08964958f, 0.18787389f, -0.06478696f, 0.18045154f, 0.08242057f, -0.06544756f, 
    0.05875472f, 0.17452906f, 0.08160149f, 0.10018264f, -0.29556760f, 0.04313817f, -0.01281593f, 0.15838213f, 
    0.08266225f, 0.07367509f, 0.02684320f, -0.06570897f, -0.11848073f, 0.01618929f, 0.16963847f, 0.13806011f, 
    0.01145821f, 0.06940541f, 0.23697285f, -0.05485231f, -0.04119776f, -0.05384710f, 0.00827069f, 0.07883834f, 
    0.02791128f, -0.07773090f, 0.11434028f, -0.14075562f, -0.00536903f, 0.19167632f, -0.11365531f, -0.02705282f, 
    0.11803693f, -0.07484854f, 0.13147771f, 0.32102108f, -0.07480453f, -0.05113563f, 0.02916948f, -0.03269641f, 
    -0.05641442f, 0.06129264f, -0.00455165f, -0.14667246f, -0.12937927f, -0.31483638f, -0.11796510f, 0.14276484f, 
    0.06058378f, -0.01124126f, 0.06649072f, -0.11173522f, -0.13751194f, 0.01060680f, 0.13814640f, -0.00170810f, 
    -0.08044214f, 0.01486290f, 0.05401707f, -0.19103259f, -0.13276501f, 0.23703839f, 0.00578450f, 0.02590771f, 
    0.01073170f, -0.07117069f, 0.09218454f, -0.11172755f, 0.07477439f, 0.20276667f, 0.20385925f, -0.24259192f, 
    -0.15380263f, -0.09441916f, -0.01216285f, 0.08707377f, 0.13363513f, 0.13417779f, 0.13954832f, -0.06270179f, 
    0.17766297f, 0.15376318f, 0.09053423f, 0.02127834f, -0.12966359f, -0.00698971f, -0.01145643f, 0.23703769f, 
    0.06564067f, -0.10658542f, -0.19907475f, -0.12097248f, -0.10283928f, 0.11588831f, 0.06592581f, -0.08585005f, 
    -0.04151414f, -0.18231949f, -0.29854175f, -0.07655932f, -0.07669616f, -0.06938794f, 0.07602497f, 0.05108478f, 
    -0.00480827f, 0.18971412f, -0.04545368f, 0.07615503f, -0.03985177f, -0.03034176f, 0.04139224f, -0.00595029f, 
    0.14766856f, 0.01252639f, 0.06381671f, -0.27599880f, -0.23130424f, 0.16274413f, -0.19091743f, 0.00784063f, 
    -0.13431053f, -0.08860394f, -0.25819770f, 0.09540488f, -0.06603960f, 0.17024498f, -0.26900357f, 0.06455937f, 
    0.16165650f, 0.05293377f, 0.08278348f, 0.10488077f, -0.00066597f, 0.01643653f, -0.31564936f, 0.03375322f, 
    -0.23038229f, -0.00640457f, 0.00589294f, -0.02802151f, -0.01502378f, 0.05850860f, -0.03410653f, 0.07566841f, 
    0.35323820f, -0.20074120f, -0.15094249f, -0.11595449f, -0.17874600f, 0.21562810f, 0.17106226f, -0.08563526f, 
    0.02461241f, 0.04334381f, -0.01692940f, 0.04457589f, 0.04345452f, 0.01849413f, 0.04702640f, -0.03706955f, 
    0.04582676f, 0.03736766f, -0.04646744f, 0.01890544f, -0.01239949f, -0.04468007f, -0.00347313f, -0.00104015f, 
    0.01779379f, 0.04192700f, -0.02829352f, 0.00555146f, -0.02400835f, 0.03809263f, 0.01237734f, -0.00053875f, 
    -0.06788433f, -0.04608527f, 0.01185197f, -0.01045385f, 0.03541620f, -0.00635635f, 0.04031477f, 0.02319500f, 
    0.01345809f, -0.04064542f, 0.01149761f, 0.02385917f, -0.04743642f, -0.04187769f, 0.02227054f, 0.03580946f, 
    0.02469104f, -0.06215583f, -0.04126738f, -0.00951641f, -0.05651817f, -0.05453880f, -0.05118336f, 0.00498817f, 
    0.02464059f, 0.00482665f, 0.03053532f, 0.01283663f, -0.02797044f, -0.03525170f, 0.04256634f, -0.01045381f, 
    -0.01637043f, -0.03426283f, 0.04080955f, 0.05432261f, 0.01723050f, 0.03361406f, 0.01084266f, 0.02886744f, 
    -0.04048306f, 0.04128520f, -0.03331925f, -0.02890479f, -0.00749839f, -0.00132860f, -0.04736265f, -0.05645145f, 
    0.00453863f, 0.02757058f, -0.04649540f, -0.03331359f, -0.05730608f, 0.04565833f, -0.05087302f, 0.03735621f, 
    -0.06605702f, -0.00859564f, 0.01971176f, -0.01989503f, -0.04367985f, -0.06917319f, 0.01515904f, -0.06116402f, 
    -0.01890188f, -0.05044163f, -0.01965573f, -0.02873147f, 0.04691977f, -0.01255059f, 0.02234668f, -0.05649005f, 
    -0.06871697f, 0.02168499f, -0.02517502f, -0.06052966f, -0.05131542f, 0.00968719f, -0.03271230f, -0.02427399f, 
    0.01585707f, 0.03621722f, -0.03621810f, -0.04431660f, -0.06681789f, -0.00957755f, -0.06098939f, 0.03464431f, 
    0.00462635f, 0.03404553f, 0.02852322f, -0.04510131f, 0.01879767f, -0.00646625f, -0.03594001f, -0.05051785f, 
    0.02504710f, 0.02105374f, -0.04067925f, -0.02985465f, 0.00729882f, 0.00301688f, -0.02606990f, 0.03760197f, 
    -0.05311647f, 0.04266109f, 0.03388610f, -0.03819416f, -0.04105815f, -0.00025428f, -0.06213851f, 0.00015451f, 
    -0.03825245f, -0.04790454f, 0.01865504f, 0.03604896f, 0.04556854f, -0.00983250f, -0.00126898f, 0.04415911f, 
    -0.06391813f, -0.05077599f, 0.01145391f, -0.00264148f, 0.01599994f, 0.00680109f, -0.06204626f, -0.00330411f, 
    -0.06540217f, 0.00371127f, 0.03713064f, -0.05390665f, 0.00451369f, -0.05420053f, -0.01901514f, 0.00748401f, 
    0.02776572f, 0.02175503f, -0.03683290f, -0.00157926f, -0.03424446f, 0.03781288f, 0.02739716f, -0.02714876f, 
    -0.00761346f, -0.05713260f, -0.00181710f, -0.00566531f, -0.02195106f, -0.02412869f, 0.04425704f, -0.06020686f, 
    0.05534631f, -0.06360089f, -0.03582817f, -0.02738291f, 0.00433180f, -0.03545919f, 0.04007842f, 0.03541490f, 
    0.03185204f, 0.05423951f, 0.00437562f, -0.04923419f, 0.01302698f, 0.04400746f, -0.05006061f, 0.01286135f, 
    -0.02253093f, -0.06803675f, 0.01334126f, 0.01975315f, -0.01212358f, -0.00922845f, -0.05513798f, -0.04455863f, 
    0.02986872f, -0.03534736f, -0.00015071f, 0.02219914f, 0.01249949f, 0.03264664f, 0.00309288f, -0.04117038f, 
    -0.06051156f, -0.01316366f, -0.04358526f, 0.01128706f, -0.02317391f, 0.00735132f, -0.03605716f, 0.01034845f, 
    -0.00792838f, 0.02267046f, 0.00324453f, 0.03927447f, -0.05238112f, -0.00585475f, -0.01792275f, 0.03248753f, 
    0.00940234f, 0.01096569f, -0.01143438f, -0.01759153f, -0.00344365f, -0.05570682f, -0.04238033f, 0.02089302f, 
    0.03304199f, 0.01164063f, -0.05692481f, 0.01817222f, 0.00616798f, 0.02560528f, -0.04787723f, -0.05355468f, 
    -0.06521667f, -0.05853065f, -0.00965464f, -0.05708147f, 0.02582005f, 0.01753784f, -0.03111394f, -0.00438687f, 
    -0.04561983f, 0.01129770f, 0.01514917f, 0.00005894f, 0.00844725f, 0.03812977f, 0.03218345f, 0.01648195f, 
    0.02115341f, -0.01467180f, 0.02504244f, -0.00180596f, -0.01668644f, 0.01474105f, -0.02251235f, -0.06730846f, 
    0.02705509f, -0.01191999f, -0.01112248f, 0.02494691f, -0.03170033f, 0.04455279f, -0.01339945f, -0.05633111f, 
    -0.04716924f, 0.02412213f, -0.04219633f, -0.01701792f, 0.04420071f, -0.01763568f, -0.00017628f, -0.02985223f, 
    0.02020321f, -0.06145880f, 0.04925142f, -0.01428307f, -0.05695204f, 0.03271228f, 0.00998098f, -0.02223071f, 
    0.16270633f, 0.27031875f, -0.03363889f, -0.06249230f, -0.01643494f, -0.02204808f, -0.03321434f, -0.18375260f, 
    -0.00794265f, -0.04376005f, -0.11778616f, 0.02293372f, -0.07008263f, 0.03273695f, 0.05470911f, 0.01025061f, 
    -0.03409917f, -0.10620712f, 0.12451340f, 0.01194392f, -0.17820820f, -0.00345716f, 0.06055006f, -0.04111145f, 
    0.14441213f, 0.07831079f, -0.04964304f, -0.11750269f, 0.05713053f, -0.13937669f, 0.02489903f, 0.03661810f, 
    -0.04347078f, 0.08939555f, -0.12689178f, 0.13201699f, -0.31866917f, -0.33658341f, -0.19437197f, -0.26546988f, 
    0.00017484f, -0.06440863f, -0.00680621f, -0.26728600f, -0.03698719f, -0.19157673f, 0.20317219f, 0.08703579f, 
    0.03445874f, -0.07243344f, -0.02386300f, -0.09576254f, 0.07254986f, -0.01759845f, -0.21886718f, 0.18411049f, 
    0.17534195f, 0.03063714f, 0.03238440f, -0.05491582f, -0.00441328f, -0.10332975f, 0.06254657f, 0.05868506f, 
    -0.14118502f, -0.15991507f, -0.09127632f, 0.03426347f, 0.01077147f, -0.04302241f, 0.02386239f, 0.00261317f, 
    0.05878860f, -0.38531238f, 0.08249107f, -0.13999127f, 0.00061872f, -0.05127303f, -0.06861176f, 0.02337929f, 
    0.05320983f, 0.21934563f, 0.05939474f, -0.15055716f, 0.07359137f, 0.14884065f, -0.06299772f, -0.03092045f, 
    0.01737141f, -0.01011593f, 0.05040161f, -0.14607584f, -0.12725358f, 0.06624711f, 0.04318217f, -0.08146608f, 
    0.09397394f, 0.01891695f, -0.10293798f, 0.31770822f, 0.00933599f, -0.02510472f, -0.03031071f, -0.11746788f, 
    -0.03860994f, -0.03554275f, -0.06821416f, -0.01640390f, 0.11595849f, 0.21884622f, -0.02662962f, 0.20472635f, 
    -0.08953206f, -0.00249737f, -0.04435266f, 0.06163413f, 0.11930018f, 0.09535056f, -0.01801532f, 0.05937560f, 
    -0.03226830f, 0.01404756f, -0.04753648f, -0.10133183f, -0.01737629f, -0.01208455f, 0.12757792f, 0.31269068f, 
    0.14131384f, -0.15513098f, 0.07331137f, -0.01738842f, 0.06485583f, -0.01224287f, -0.12174466f, 0.00190614f, 
    0.10810088f, -0.08682962f, 0.14100245f, 0.07683773f, -0.15262896f, -0.07952450f, 0.09615592f, 0.08055574f, 
    0.14769822f, 0.25029144f, 0.07611704f, -0.06341245f, 0.03008582f, 0.07938255f, 0.02860150f, 0.14423250f, 
    0.01255810f, -0.12882520f, 0.05902896f, 0.17550120f, -0.04035472f, -0.01294500f, 0.03481657f, -0.07901842f, 
    0.04164463f, 0.10477703f, -0.31016639f, 0.21036820f, 0.20412190f, -0.07587563f, -0.21043366f, -0.07195122f, 
    -0.18505719f, 0.06873843f, 0.03611220f, 0.12367246f, 0.13048755f, 0.02968020f, 0.15892959f, -0.17371817f, 
    0.00450284f, 0.00872021f, 0.08874842f, -0.08472337f, 0.14894620f, -0.10214934f, -0.00897270f, -0.12392797f, 
    -0.06528755f, 0.05806013f, -0.05816319f, -0.10636834f, -0.15246017f, 0.19727863f, 0.19109426f, -0.00720420f, 
    -0.13780284f, 0.10787723f, 0.05722098f, 0.14553092f, -0.09839446f, -0.08402194f, -0.26087674f, 0.04004347f, 
    -0.16022159f, -0.01372130f, -0.14355171f, -0.01977272f, -0.13215721f, 0.09503309f, 0.11557232f, -0.02918243f, 
    -0.16175634f, -0.18509196f, -0.06356233f, -0.00496592f, -0.09373730f, 0.05041105f, 0.02444307f, -0.04764189f, 
    0.12103244f, 0.24226987f, 0.16608304f, 0.02625640f, 0.01295388f, 0.03890093f, -0.19400683f, -0.05479763f, 
    -0.08339527f, -0.10567764f, -0.04034008f, -0.14869225f, 0.08436745f, -0.11988959f, 0.05616700f, 0.00097288f, 
    0.03204584f, -0.18518250f, -0.01492524f, -0.05987050f, 0.04857874f, -0.04453263f, 0.15453519f, -0.01433017f, 
    0.03848570f, -0.01127174f, 0.02873019f, -0.07833418f, -0.03138872f, -0.26109526f, -0.02351305f, 0.02560146f, 
    0.04079888f, -0.01299211f, -0.10046832f, -0.12142348f, -0.07625136f, 0.22078221f, 0.11926560f, -0.01950124f, 
    -0.00568933f, -0.19555242f, -0.02845944f, 0.03420455f, -0.00522229f, 0.13340034f, -0.04677372f, -0.06212245f, 
    0.08259749f, -0.13324031f, -0.12576981f, -0.09709577f, 0.02805912f, -0.01090044f, 0.15319623f, 0.02153818f, 
    -0.12104630f, 0.04761779f, -0.08040370f, -0.06760395f, 0.08756720f, 0.07359681f, 0.11707632f, 0.07688965f, 
    -0.04931555f, 0.12775826f, -0.02698270f, -0.03622670f, -0.07102139f, 0.12155183f, -0.03231676f, 0.00324006f, 
    0.13361871f, -0.27405900f, -0.17166279f, 0.06086941f, -0.10008758f, 0.05318373f, -0.11659105f, -0.00166489f, 
    -0.04569802f, -0.03697716f, -0.05216657f, -0.06288537f, 0.07594180f, 0.14374910f, 0.03635332f, 0.05120315f, 
    -0.06378394f, 0.12236261f, -0.07004191f, -0.13643648f, 0.10420704f, 0.01736881f, 0.01566041f, -0.00510299f, 
    0.09243338f, -0.22666004f, 0.16066085f, -0.29712045f, 0.01226757f, -0.10564619f, -0.04882669f, -0.04664614f, 
    0.21332103f, -0.05317195f, -0.09214445f, -0.15327950f, -0.28896379f, 0.11229088f, -0.19125280f, -0.01917014f, 
    0.00899940f, -0.07705636f, -0.01447667f, 0.00085219f, 0.12250215f, 0.03875803f, 0.03114182f, 0.16926982f, 
    0.00006379f, -0.14804511f, 0.05545664f, 0.16124927f, 0.01001712f, 0.10067870f, 0.06275022f, 0.02364574f, 
    -0.12144950f, -0.01767808f, -0.10929576f, 0.07498153f, 0.07314656f, -0.15069310f, -0.16417728f, 0.02581396f, 
    -0.17998575f, 0.03078560f, -0.00565191f, 0.07383911f, 0.07536015f, -0.00480504f, 0.00168564f, -0.07838887f, 
    0.09901321f, 0.00001674f, -0.12957072f, -0.03047274f, 0.08847277f, -0.05720147f, 0.06971891f, -0.00590720f, 
    0.12376253f, -0.08422299f, 0.08243255f, 0.10452773f, 0.01855461f, 0.16661321f, -0.01135994f, -0.06255299f, 
    -0.04060654f, 0.12111422f, -0.15217984f, -0.11067189f, 0.07932094f, 0.05052765f, 0.01419964f, 0.01371665f, 
    0.13742368f, 0.05778131f, 0.03549599f, 0.06012036f, -0.07260675f, 0.07609016f, 0.03226866f, -0.04084799f, 
    -0.06267040f, -0.05221612f, -0.02280678f, 0.05291258f, -0.04776222f, -0.10855023f, 0.18386838f, 0.05798532f, 
    -0.00678834f, 0.05061041f, -0.04294464f, -0.10562952f, -0.02897834f, 0.29995218f, 0.04107264f, -0.00170174f, 
    0.03473889f, -0.09587204f, 0.04234760f, 0.21989839f, 0.01392994f, 0.15604806f, -0.19004032f, -0.10362981f, 
    0.08377399f, 0.02396016f, 0.02398955f, -0.09008517f, -0.06280276f, 0.20717257f, 0.09271053f, 0.00603126f, 
    -0.09541509f, 0.11394138f, 0.07485434f, 0.07963645f, -0.11156336f, -0.01243070f, -0.12964031f, -0.10809886f, 
    0.14358358f, 0.03668981f, -0.02925602f, 0.07309660f, -0.06181142f, 0.09422344f, -0.01756057f, 0.05459599f, 
    0.02330836f, -0.01776730f, -0.05054433f, 0.11816825f, -0.12928140f, 0.09303148f, 0.08525893f, 0.06552416f, 
    -0.05151476f, -0.15016440f, -0.19131826f, -0.18182984f, -0.11485306f, 0.07007487f, -0.05401354f, 0.03106534f, 
    0.02144454f, -0.02282103f, 0.03504253f, -0.04793664f, -0.30547968f, 0.34384686f, 0.01315451f, -0.08171612f, 
    -0.06261040f, -0.11568259f, -0.14243424f, -0.10038359f, -0.07238685f, -0.12329619f, -0.08726228f, -0.07288487f, 
    0.11805094f, 0.04644639f, 0.07672714f, -0.03450434f, -0.10492738f, 0.04550066f, -0.05362258f, 0.09604802f, 
    0.04650223f, 0.18558031f, 0.21441185f, 0.03301318f, 0.03747035f, -0.02315433f, -0.15853409f, 0.05338736f, 
    -0.00467044f, 0.09330457f, 0.12909843f, -0.06798938f, 0.12442814f, -0.01651705f, -0.07813168f, -0.25955847f, 
    0.06454603f, -0.10565917f, -0.01746235f, 0.02248946f, 0.13019851f, 0.01734676f, -0.03155799f, 0.00421077f, 
    0.12298290f, 0.16265103f, 0.11765882f, 0.00743047f, -0.14025141f, -0.18138328f, -0.15223187f, 0.15854958f, 
    0.01170408f, -0.01913995f, -0.05667252f, -0.01776914f, 0.02720001f, 0.00035584f, 0.09432679f, 0.01720787f, 
    0.16404770f, -0.02831707f, -0.39746889f, -0.01822438f, 0.16543917f, 0.03643298f, 0.02737652f, 0.15383865f, 
    -0.01765289f, -0.13079621f, -0.18952808f, 0.20716348f, 0.03259911f, -0.07887927f, -0.18882142f, 0.02114822f, 
    0.10795154f, -0.14827242f, -0.00845436f, -0.08177524f, -0.24044989f, -0.06582157f, 0.15884483f, -0.09889231f, 
    -0.05697094f, -0.26194179f, -0.00885471f, -0.17780282f, -0.00081864f, 0.13935885f, -0.03629435f, 0.18137132f, 
    0.15878241f, -0.19524416f, 0.06623585f, 0.15550341f, -0.00706211f, 0.06121233f, 0.14771193f, -0.09668927f, 
    0.20897198f, -0.01384450f, -0.07029945f, 0.08347873f, -0.03233567f, -0.03064659f, -0.19021760f, 0.09401511f, 
    -0.02424506f, 0.04701610f, -0.17884502f, 0.01877059f, -0.08169242f, 0.16017136f, 0.10558651f, 0.06806451f, 
    0.08368496f, 0.00081080f, 0.05810304f, -0.03114696f, 0.01688267f, -0.06990562f, 0.05886906f, 0.04853196f, 
    0.00522504f, -0.03761252f, 0.21152599f, 0.13658014f, 0.06888858f, 0.11523045f, -0.05697210f, 0.06652753f, 
    0.02281251f, -0.00005804f, -0.04684270f, 0.15604317f, 0.20034331f, -0.09723937f, -0.15718871f, 0.08027967f, 
    -0.14410283f, 0.08036039f, -0.01825178f, -0.01698612f, 0.21441939f, 0.10400505f, 0.06091684f, -0.08634479f, 
    -0.00920349f, 0.06274077f, 0.02168742f, 0.13960813f, -0.00886758f, -0.11111174f, 0.01650961f, 0.04539518f, 
    0.22932927f, -0.18747345f, -0.02756937f, 0.17641072f, -0.32064781f, -0.05226386f, -0.25026616f, -0.33439079f, 
    0.03741718f, 0.05842547f, 0.00911348f, 0.00727025f, -0.08150133f, 0.13051304f, -0.30472958f, -0.13885488f, 
    0.27910322f, 0.08065917f, -0.15008484f, 0.07949107f, -0.02552505f, 0.07785523f, -0.05458493f, 0.02851776f, 
    0.19935754f, -0.10296912f, 0.07964675f, 0.09887419f, 0.01402244f, 0.01469210f, -0.09584877f, 0.02439800f, 
    -0.46237049f, -0.08494370f, 0.05470664f, 0.17167377f, -0.00846590f, 0.03633178f, 0.12612732f, 0.09530515f, 
    0.00221912f, 0.11355767f, 0.19019666f, 0.12170105f, -0.02147000f, -0.24522668f, 0.18232469f, -0.10908311f, 
    -0.02262278f, 0.17919013f, 0.14649476f, 0.08704340f, -0.51403010f, -0.04384437f, -0.09241839f, -0.05306489f, 
    0.21753234f, -0.02952267f, 0.04762742f, -0.16422555f, -0.00210703f, -0.02436469f, 0.17801721f, 0.06579214f, 
    -0.09516675f, 0.13453716f, 0.03525867f, 0.12346783f, 0.02894783f, 0.03320087f, 0.16547266f, 0.00654386f, 
    -0.02022942f, -0.02312250f, -0.11322819f, -0.11278384f, -0.21899730f, -0.30384311f, -0.01709081f, -0.13701694f, 
    0.08679739f, 0.11552580f, 0.18648107f, -0.05470240f, -0.00696354f, 0.09055025f, 0.21697527f, -0.32073495f, 
    -0.12219448f, -0.21083342f, -0.05694336f, 0.03118749f, 0.13191248f, -0.10665526f, -0.01828619f, -0.06846766f, 
    0.10452803f, 0.29527628f, -0.17485109f, 0.08283103f, 0.15930960f, -0.06588379f, 0.10812519f, 0.12114097f, 
    0.06930078f, -0.25774661f, -0.18855992f, -0.08114583f, -0.03240632f, 0.12361211f, 0.07679171f, 0.26095614f, 
    0.10286350f, -0.10103226f, -0.43042716f, 0.03672376f, -0.20350194f, 0.10080348f, 0.04154872f, 0.12414690f, 
    0.08290035f, 0.18621862f, -0.10945764f, 0.35766584f, -0.32349578f, -0.01867054f, 0.06075194f, -0.03425518f, 
    0.14024702f, -0.23975740f, 0.26881340f, -0.11930566f, 0.02888410f, -0.35552594f, 0.14643958f, -0.11662441f, 
    -0.08228724f, 0.13014512f, 0.07726883f, 0.11026748f, 0.14000963f, 0.00469518f, -0.09126734f, 0.13395478f, 
    -0.02079774f, -0.09091023f, 0.06021094f, -0.04503103f, 0.05670108f, 0.09484200f, 0.04564131f, -0.11645763f, 
    -0.01148671f, -0.01360543f, -0.02395049f, -0.05345798f, -0.04399572f, -0.03704033f, -0.02788354f, 0.12411477f, 
    -0.14383210f, 0.00268627f, 0.17630355f, 0.07143687f, 0.01670128f, -0.07070556f, 0.16699360f, 0.05088403f, 
    0.13984615f, -0.09613267f, 0.08799671f, -0.09837069f, -0.01793915f, 0.13337044f, 0.04876395f, 0.06016721f, 
    -0.18338320f, -0.02264927f, -0.17932051f, 0.06344678f, 0.01679760f, 0.15334298f, 0.08203048f, 0.09930825f, 
    -0.05466885f, 0.02177318f, -0.00649220f, -0.24891618f, -0.14657342f, 0.11816360f, -0.12284355f, 0.03732790f, 
    -0.12291837f, -0.05140956f, -0.02608706f, -0.07191903f, -0.05602592f, -0.01164007f, 0.01810957f, 0.12007993f, 
    0.05780991f, 0.13088179f, -0.02825757f, -0.32938412f, 0.08171587f, -0.04223400f, 0.05520665f, -0.03210796f, 
    0.05294056f, -0.10301293f, 0.10686756f, -0.04253124f, -0.01328795f, -0.00980345f, 0.20309448f, 0.05004157f, 
    -0.05701235f, 0.14826250f, 0.01229825f, -0.20221744f, -0.17597519f, -0.47479105f, -0.12949269f, -0.04538718f, 
    0.17439553f, 0.00878775f, 0.11285661f, -0.00826965f, -0.01781991f, 0.02080252f, -0.11438350f, 0.09085266f, 
    -0.11156673f, 0.05412028f, -0.06161463f, -0.23752947f, 0.06712414f, -0.14967205f, 0.10000476f, -0.23853309f, 
    0.03700547f, 0.04089632f, -0.05003000f, -0.09080631f, 0.14347273f, -0.00499814f, -0.01375420f, 0.00454527f, 
    0.07712181f, 0.04839898f, -0.02213516f, 0.07494395f, -0.06674632f, 0.18235916f, 0.06436392f, -0.03666670f, 
    0.02437494f, -0.10988912f, 0.03012900f, -0.04266505f, 0.07453154f, -0.00950749f, 0.20502093f, -0.06973620f, 
    0.00645003f, 0.01691591f, 0.04225719f, 0.16688143f, 0.11115791f, -0.03283665f, -0.05964072f, -0.05103464f, 
    -0.03585447f, -0.08443258f, 0.18857993f, -0.11560943f, 0.07146728f, -0.01607242f, -0.02863435f, 0.11132120f, 
    -0.15519078f, -0.09448756f, -0.01097167f, -0.00313593f, -0.01898360f, -0.32979169f, 0.10740999f, -0.10261451f, 
    0.02765127f, 0.18396823f, -0.09800923f, 0.02093348f, 0.16980958f, -0.30880690f, 0.26659209f, -0.18594019f, 
    0.28579950f, 0.07871546f, 0.02795991f, 0.12477478f, -0.17041020f, -0.22040069f, -0.09398157f, 0.17371626f, 
    -0.10122918f, -0.03386298f, -0.12400381f, 0.04707776f, 0.31059673f, -0.11155375f, -0.04328309f, -0.15794262f, 
    0.01737293f, 0.00186724f, -0.06234092f, 0.02469472f, 0.16176465f, 0.06300121f, 0.03219790f, -0.14062174f, 
    -0.07698963f, -0.27776951f, -0.00902957f, 0.05042891f, 0.02869050f, 0.12835181f, 0.18521932f, 0.02237127f, 
    -0.06497528f, 0.11975509f, 0.13991091f, 0.08481193f, 0.01897718f, -0.15934487f, -0.08538847f, 0.05513180f, 
    0.08578540f, -0.05279973f, -0.02754801f, 0.02920895f, 0.22841521f, -0.11926390f, -0.13305151f, -0.01340586f, 
    -0.04732349f, 0.09483547f, 0.18616740f, 0.30862370f, -0.16503552f, -0.09795474f, -0.09723468f, -0.01939603f, 
    -0.15361460f, 0.09036054f, -0.12992725f, 0.03644105f, 0.32294452f, 0.19879662f, 0.23793851f, 0.00980781f, 
    -0.01792070f, -0.04758729f, -0.04414442f, 0.04725061f, 0.14567631f, -0.04060404f, 0.04391101f, 0.07957941f, 
    0.10916997f, 0.14867663f, 0.01528836f, -0.01828673f, -0.05381623f, -0.04119904f, 0.24798487f, 0.18053015f, 
    0.28599155f, 0.00476017f, -0.10115004f, 0.09936573f, 0.06341675f, 0.11424550f, -0.12593873f, 0.02175165f, 
    0.00975612f, 0.06262277f, 0.03066416f, -0.14732121f, 0.09866526f, 0.03998827f, -0.19395806f, 0.13941227f, 
    0.04190786f, -0.06345654f, -0.09403709f, -0.03676144f, 0.01327442f, -0.20521641f, 0.03377172f, -0.13739227f, 
    0.02702744f, 0.04750768f, 0.04111236f, -0.01559376f, -0.21410726f, -0.02324223f, -0.18505998f, 0.07914838f, 
    -0.01707689f, -0.09726968f, -0.19305551f, -0.06605187f, 0.00539184f, 0.04103594f, -0.11990280f, 0.10806730f, 
    -0.08707288f, -0.07386908f, -0.11058702f, 0.04950083f, -0.10071123f, -0.09713273f, -0.36625722f, -0.08760124f, 
    0.04840162f, 0.22000259f, 0.03838297f, -0.07076322f, 0.05210915f, -0.03640892f, -0.40648130f, -0.16564466f, 
    0.06106169f, 0.07266407f, -0.22342743f, -0.17006722f, -0.00994833f, 0.21271342f, 0.07737850f, 0.17941228f, 
    0.11599216f, 0.01362438f, -0.03336273f, 0.03290882f, 0.02240078f, -0.04417262f, -0.06106661f, -0.00968891f, 
    0.08282709f, 0.17719509f, 0.10334268f, 0.08000931f, -0.17057288f, -0.03225381f, 0.03879214f, -0.16097240f, 
    0.12890491f, 0.09843845f, -0.02777722f, 0.06211647f, 0.00588277f, 0.00990511f, -0.01357994f, 0.00259929f, 
    0.07129646f, 0.09645800f, 0.02184315f, 0.03525065f, -0.00282320f, 0.07273969f, 0.10878847f, -0.07303373f, 
    0.00112436f, -0.17028919f, 0.10732769f, -0.19849923f, 0.01080452f, -0.05510123f, -0.00295610f, 0.04990550f, 
    -0.10757159f, -0.01291769f, -0.08087334f, 0.19779561f, -0.09056259f, 0.16234833f, 0.05768917f, 0.05746203f, 
    -0.16292101f, 0.00728229f, 0.11012422f, 0.04252847f, -0.21767192f, -0.24018973f, -0.08729488f, 0.13485491f, 
    0.03642673f, -0.06842615f, -0.04105027f, -0.06878895f, 0.03066549f, 0.01224738f, 0.06618356f, -0.06741035f, 
    -0.01509037f, 0.05830756f, 0.02383257f, -0.08506199f, -0.16540831f, -0.06865989f, -0.07342955f, 0.03228537f, 
    0.12958908f, 0.01079399f, 0.01928231f, -0.11343809f, 0.02149397f, -0.16814300f, -0.22045118f, 0.15809575f, 
    0.19175676f, -0.03077636f, -0.12075332f, 0.09358680f, 0.03137583f, -0.02327298f, 0.11344101f, 0.03764189f, 
    -0.13781314f, -0.07714873f, -0.00780947f, 0.04346764f, -0.04514220f, 0.01988255f, -0.11749704f, 0.00366658f, 
    -0.03646746f, 0.04823945f, -0.03927900f, -0.04560719f, -0.02842643f, -0.02681884f, 0.00628276f, 0.00104055f, 
    -0.04393357f, -0.04746098f, 0.03202130f, 0.02289518f, -0.01409929f, -0.02461890f, -0.05537349f, -0.04976700f, 
    -0.05119065f, -0.03525249f, 0.06201663f, 0.04176530f, 0.03983424f, -0.05587938f, 0.01668643f, -0.02862358f, 
    -0.02180243f, 0.00899139f, 0.02888387f, -0.05267477f, 0.02082458f, 0.01164736f, -0.04095647f, 0.00990480f, 
    -0.04649133f, -0.03788670f, 0.02529530f, 0.03242892f, -0.03428818f, -0.03578632f, -0.03150836f, 0.01029809f, 
    -0.04929719f, -0.02612673f, 0.04435788f, 0.04858600f, 0.03754207f, 0.01740157f, -0.04173199f, 0.05386882f, 
    -0.04556344f, -0.02568475f, 0.04884031f, -0.06322559f, 0.03660299f, 0.03298552f, -0.02885220f, 0.03826716f, 
    0.04373696f, 0.01549703f, 0.02010256f, -0.04751683f, -0.02340392f, 0.03670609f, 0.03069251f, -0.00620258f, 
    0.01277850f, 0.02697888f, -0.03300884f, 0.04048477f, 0.02801585f, -0.03100067f, 0.01664585f, 0.00188366f, 
    -0.00535430f, 0.04457519f, 0.04247521f, 0.00956005f, -0.02038022f, -0.05327416f, -0.01549430f, -0.05509933f, 
    0.00551783f, 0.00925862f, -0.00087602f, -0.05157731f, 0.04299581f, -0.01889312f, -0.04784970f, 0.01389538f, 
    -0.01309242f, -0.05598693f, -0.04474968f, -0.01076862f, 0.00721788f, 0.05688263f, -0.04057826f, 0.01857110f, 
    -0.00846725f, 0.01857868f, 0.01747565f, -0.02418097f, -0.04209794f, 0.00222086f, -0.04983024f, 0.05562208f, 
    -0.00854723f, -0.04478081f, 0.02686874f, -0.06106747f, 0.04609010f, -0.04437398f, 0.04912155f, -0.05429931f, 
    0.00825836f, 0.04737210f, 0.03850213f, 0.05017528f, 0.03089020f, -0.01081032f, -0.03228595f, -0.06019295f, 
    0.05223439f, -0.03655723f, 0.03895757f, 0.01602795f, 0.02060075f, 0.00441731f, -0.03919699f, 0.02098027f, 
    0.03207762f, 0.00534134f, -0.04116858f, -0.03549804f, 0.05683887f, 0.03191200f, -0.05471351f, 0.02500040f, 
    -0.05141837f, 0.03287761f, 0.04091998f, 0.03008075f, -0.00884367f, -0.00472983f, -0.01022691f, -0.04056687f, 
    0.00609035f, -0.02703317f, -0.03684905f, -0.00709149f, 0.01358317f, -0.05050777f, 0.01474339f, -0.00934451f, 
    -0.01323481f, 0.05531842f, 0.00839070f, 0.02028279f, -0.02245793f, 0.03294430f, 0.03965735f, -0.02586816f, 
    0.02434408f, -0.03999678f, 0.04413413f, -0.05550700f, -0.04069962f, 0.00087873f, -0.02313998f, -0.05082471f, 
    -0.03961874f, 0.00217894f, -0.03627611f, -0.03990468f, -0.03889120f, 0.00054371f, 0.05032662f, 0.01511147f, 
    -0.03433739f, -0.01976927f, -0.03406457f, 0.04294867f, 0.00494668f, -0.01941032f, 0.00883335f, 0.03103598f, 
    -0.00219894f, 0.03612129f, -0.03612498f, 0.05698749f, 0.03761831f, 0.01678965f, -0.00943149f, -0.00100352f, 
    -0.00366350f, -0.01176724f, 0.00281563f, -0.03457562f, -0.02880645f, -0.03754085f, 0.01176323f, -0.05019578f, 
    -0.04957381f, -0.04663067f, -0.04123573f, -0.03010261f, -0.02322938f, 0.00443087f, 0.01709569f, -0.03387742f, 
    -0.00849629f, -0.02550176f, 0.00219700f, 0.02427944f, -0.01612932f, -0.00707508f, 0.01491689f, -0.00938957f, 
    0.00409570f, 0.01363332f, -0.02412542f, -0.04707568f, 0.01042665f, 0.00827483f, -0.02375802f, 0.02151736f, 
    0.03494963f, -0.05616194f, -0.03953521f, -0.00448646f, -0.05728502f, -0.06309509f, -0.00652938f, -0.01784417f, 
    0.01964043f, 0.01497188f, 0.03601205f, 0.02268577f, -0.01325090f, -0.01194307f, -0.05132944f, 0.02605923f, 
    -0.03187061f, 0.00859546f, -0.05569234f, 0.01022759f, 0.03529870f, -0.02801352f, 0.02246906f, -0.00439975f, 
    -0.06224406f, -0.00311378f, -0.04092038f, -0.05040129f, 0.00760083f, -0.03979492f, -0.02299764f, -0.01946588f, 
    0.01950547f, 0.02165824f, -0.04304475f, -0.03479766f, -0.00310148f, -0.00304159f, -0.04312233f, -0.05258479f, 
    0.00710447f, 0.00699528f, -0.02602950f, -0.00669052f, -0.05369915f, 0.00964691f, 0.04626466f, -0.01586467f, 
    -0.02483316f, -0.05698422f, 0.02353673f, -0.00678282f, 0.01865421f, -0.06254042f, 0.00455000f, -0.06109186f, 
    -0.01742673f, 0.04712717f, 0.00873687f, -0.00715011f, 0.01263693f, -0.04563986f, -0.06076548f, 0.00590684f, 
    0.00725093f, -0.05252856f, 0.00777051f, -0.03455817f, 0.03291648f, -0.00726159f, -0.01033079f, 0.01650444f, 
    -0.00105709f, 0.02913467f, -0.03883525f, 0.02734370f, -0.01701922f, -0.01648735f, 0.04620101f, -0.01137148f, 
    -0.03490348f, 0.04782543f, -0.00950943f, 0.03971070f, -0.03786114f, 0.04097763f, -0.04808049f, -0.03437391f, 
    0.00922542f, -0.00736342f, -0.04615949f, 0.00062349f, 0.01990800f, 0.00019920f, -0.02274019f, 0.05246877f, 
    -0.05313046f, 0.04831065f, 0.01652758f, 0.00667192f, -0.06466851f, -0.00670608f, 0.00957187f, -0.00026625f, 
    -0.02176131f, -0.06032098f, 0.02540577f, -0.03088467f, 0.01270839f, -0.01404511f, -0.01636747f, 0.01669444f, 
    -0.06004111f, 0.05703707f, -0.04113616f, 0.04151656f, -0.03196992f, -0.00389470f, 0.00918255f, 0.05516558f, 
    -0.04547393f, -0.02906130f, -0.01413761f, 0.03648775f, 0.00955489f, 0.03827384f, -0.00451009f, -0.04796944f, 
    -0.02066350f, -0.05201573f, 0.00706073f, 0.03231541f, -0.02292179f, -0.03251631f, -0.01385624f, 0.00596696f, 
    0.03387742f, 0.05386914f, 0.01245559f, -0.03251246f, 0.01701453f, -0.01114011f, -0.03533714f, -0.06276520f, 
    0.01196275f, -0.01088243f, 0.04998857f, -0.01661245f, 0.01184689f, -0.00783240f, -0.05623234f, 0.02363536f, 
    0.00280389f, 0.03529083f, -0.02544285f, -0.02522809f, 0.01482995f, 0.04794290f, 0.05001391f, 0.05007272f, 
    -0.00266763f, 0.02593174f, -0.06627306f, 0.02407835f, 0.04998595f, -0.00888490f, -0.00234059f, 0.03109974f, 
    0.04437278f, 0.03906058f, 0.04422973f, -0.04200869f, 0.00253432f, -0.05418346f, -0.04559028f, 0.01018673f, 
    0.01682268f, -0.05547462f, -0.02368600f, -0.03546317f, 0.00605417f, 0.02266812f, -0.05516246f, -0.05692261f, 
    0.00796354f, -0.05191590f, -0.05172453f, -0.02867823f, -0.03101510f, -0.02853048f, -0.04211964f, 0.02597224f, 
    -0.04647522f, -0.04061147f, 0.02476875f, -0.05527438f, 0.02755952f, 0.04577947f, 0.04036973f, 0.04188761f, 
    -0.05290834f, -0.06289963f, -0.03609905f, 0.02366189f, -0.04476470f, -0.03347988f, -0.01328466f, 0.02855441f, 
    0.03076579f, 0.01301516f, 0.03348004f, -0.04402893f, -0.04190655f, -0.06379178f, -0.03818996f, -0.03596682f, 
    -0.05685558f, 0.04535559f, -0.02111518f, -0.04156548f, 0.00121575f, -0.00628118f, -0.05458181f, 0.00401706f, 
    -0.06068771f, -0.05675771f, -0.03036969f, -0.00981182f, -0.00910823f, -0.04551122f, -0.04729624f, -0.05662509f, 
    0.05255986f, 0.00769282f, 0.00376266f, -0.05920588f, -0.06128151f, 0.04848240f, -0.06131939f, 0.00020863f, 
    -0.01147922f, -0.02768260f, -0.06043333f, 0.04662961f, 0.00219350f, 0.01746941f, 0.04231396f, -0.04428457f, 
    -0.05593004f, -0.02291444f, -0.03130306f, -0.01190498f, 0.04994286f, 0.01895421f, 0.01900554f, 0.01645647f, 
    -0.01236720f, 0.01522562f, -0.03699151f, 0.04909347f, -0.02034817f, -0.04946174f, -0.00037170f, 0.04823142f, 
    -0.02856160f, -0.02168158f, -0.06277235f, -0.01633006f, 0.01264379f, 0.02153885f, 0.03565191f, 0.03742093f, 
    0.04369083f, -0.01070069f, 0.01345388f, -0.05164741f, -0.05706670f, -0.04367359f, -0.03007821f, 0.02773821f, 
    0.03455119f, -0.01989618f, -0.03603038f, 0.01673141f, -0.01417260f, 0.00649502f, 0.02245628f, 0.03498816f, 
    0.03337635f, -0.02371075f, 0.04931821f, -0.03651945f, -0.00029814f, 0.04605234f, -0.05124535f, 0.00565837f, 
    0.01086360f, -0.03472754f, 0.03076412f, -0.00753467f, -0.06400897f, 0.04473117f, 0.00022791f, 0.05343549f, 
    -0.02492978f, -0.02387852f, -0.02593834f, 0.00325790f, -0.05098551f, -0.00862713f, -0.05036475f, 0.02356605f, 
    0.03654783f, 0.03011049f, 0.00125561f, 0.00008652f, -0.03480588f, -0.02641410f, -0.02573212f, 0.00760560f, 
    -0.03451592f, -0.00188021f, 0.04427041f, -0.01907588f, -0.04981364f, -0.03129725f, 0.02971553f, 0.02318445f, 
    0.05407795f, -0.05598450f, 0.01687005f, 0.04412947f, -0.04966465f, -0.03241104f, -0.04713852f, -0.01939561f, 
    0.01209294f, 0.03882895f, -0.03203781f, -0.06184901f, -0.00481427f, -0.05105997f, -0.01247611f, 0.01234183f, 
    -0.03882087f, 0.01009752f, -0.01201848f, -0.00963214f, 0.00080389f, 0.03235021f, -0.05912522f, -0.01905358f, 
    0.05130470f, 0.01223445f, 0.00381016f, 0.03505635f, -0.05396817f, -0.01966708f, -0.01444874f, -0.00607591f, 
    -0.05741769f, -0.06236485f, -0.03039265f, 0.01779523f, -0.01657514f, -0.00996101f, -0.03650859f, -0.03416482f, 
    0.00489545f, -0.00978675f, -0.02587963f, -0.03777577f, 0.04325408f, -0.02710849f, -0.04178502f, -0.06587726f, 
    -0.02716465f, 0.01151374f, 0.05359118f, 0.03961438f, -0.00232687f, -0.03566279f, -0.06174818f, 0.03583579f, 
    0.00919819f, 0.02866906f, 0.03010650f, 0.03096835f, -0.02510255f, 0.05136140f, -0.05703478f, -0.02193973f, 
    -0.00457266f, -0.01695633f, 0.03585586f, 0.00294983f, -0.01142719f, 0.04431933f, 0.03863305f, 0.05895928f, 
    -0.00518947f, 0.02882925f, -0.01538450f, -0.05855967f, -0.03422290f, -0.05387624f, -0.03815455f, 0.04074725f, 
    -0.05197516f, -0.04225686f, -0.01165401f, -0.03137705f, -0.06029204f, -0.03370868f, -0.01701254f, -0.01967431f, 
    0.03114098f, -0.04099767f, -0.00377825f, 0.04139889f, -0.03308249f, 0.02942378f, -0.01130289f, 0.03941851f, 
    -0.00680944f, -0.05954109f, -0.02512834f, -0.02874982f, 0.02394938f, 0.03137621f, -0.02182028f, 0.03589999f, 
    0.02976679f, 0.03500424f, 0.00588828f, 0.01476375f, 0.04036272f, 0.01425830f, -0.00660920f, 0.01210042f, 
    -0.06418936f, -0.01621215f, -0.00722564f, 0.02851692f, -0.02763215f, -0.05292146f, 0.02353561f, -0.01044265f, 
    -0.03581475f, 0.03936950f, 0.03882474f, -0.05062623f, 0.01589612f, -0.04362369f, 0.04895479f, -0.03368234f, 
    0.04924328f, -0.05122001f, 0.04734426f, 0.02689737f, -0.04527694f, -0.00513701f, -0.04289597f, 0.00187877f, 
    0.04907551f, 0.00825526f, 0.01506452f, -0.04042263f, -0.04363311f, 0.01495264f, -0.04495330f, -0.05583823f, 
    -0.03672988f, -0.04444689f, -0.01427254f, 0.04507330f, -0.03258990f, 0.02878039f, 0.04905232f, -0.06007310f, 
    -0.04260963f, 0.03692459f, -0.05089902f, -0.05496483f, -0.03123491f, -0.05427773f, -0.00370001f, 0.02818085f, 
    0.01927521f, -0.00527888f, 0.02940953f, 0.02733009f, -0.04272538f, -0.01929861f, 0.00017736f, -0.04573944f, 
    -0.03062332f, 0.00671883f, -0.06154057f, 0.02261220f, -0.06411749f, -0.04171381f, 0.02077246f, 0.00479695f, 
    0.03449740f, -0.02053397f, 0.00999398f, -0.05947289f, -0.00037970f, 0.01884333f, 0.01820050f, 0.04337006f, 
    -0.02439526f, -0.05075051f, -0.02298576f, 0.01503429f, -0.00625448f, -0.05002987f, 0.01456787f, 0.00993820f, 
    0.02955062f, 0.01544169f, -0.03398188f, 0.00051387f, -0.02293827f, 0.02239946f, -0.04132178f, 0.00013089f, 
    0.00066443f, -0.03269530f, 0.02656524f, -0.03386621f, 0.01629722f, 0.02641728f, 0.04924189f, -0.03293715f, 
    -0.05428347f, -0.04316815f, -0.05258283f, -0.02033465f, 0.02386861f, 0.02050016f, 0.03559971f, -0.03235273f, 
    0.03157074f, 0.01475980f, -0.01101333f, -0.01547020f, 0.02275042f, 0.01695646f, -0.00930860f, -0.03501171f, 
    -0.06544863f, 0.02988125f, 0.01373080f, 0.02800362f, -0.04897977f, -0.04199604f, 0.00984238f, 0.03954523f, 
    0.02800746f, -0.06190876f, -0.05080135f, -0.05456796f, 0.04668304f, 0.04114508f, -0.00703949f, 0.04183088f, 
    0.02596700f, -0.04887352f, -0.06210617f, -0.04319123f, 0.03995923f, -0.04613701f, 0.00930865f, -0.05869795f, 
    0.01588533f, -0.05520173f, 0.03863003f, -0.00780476f, -0.00382854f, -0.02792295f, -0.02266671f, -0.01552258f, 
    -0.04432004f, 0.01131348f, -0.01088455f, -0.00650320f, 0.01519271f, -0.01171683f, 0.02234485f, -0.05687004f, 
    -0.06320518f, 0.04380592f, -0.01184522f, -0.04853979f, 0.04556815f, -0.03010929f, 0.04143743f, -0.02273277f, 
    -0.05285145f, -0.02166988f, -0.05123812f, 0.01124641f, -0.00055955f, 0.01617118f, -0.03539372f, -0.03213694f, 
    -0.02302453f, 0.00199956f, -0.04553184f, 0.03916849f, 0.01260835f, -0.04955582f, 0.02377243f, -0.03207970f, 
    -0.01798892f, -0.02722336f, 0.02751068f, -0.05981170f, -0.04932300f, -0.05530770f, 0.03467779f, -0.05233350f, 
    -0.03162354f, -0.03252536f, -0.05791676f, -0.01908002f, 0.00241471f, -0.02905874f, -0.01178311f, 0.02408622f, 
    -0.02151345f, -0.04831387f, 0.01953713f, -0.04450581f, 0.02266074f, -0.03862408f, -0.00238433f, 0.01322573f, 
    -0.22604387f, -0.13267173f, 0.05927746f, -0.26493111f, -0.01481307f, 0.07388765f, 0.17855652f, 0.07487866f, 
    -0.15514712f, -0.02679060f, 0.00453612f, 0.16633184f, 0.04748715f, 0.06807810f, 0.14314696f, 0.17066172f, 
    0.10339897f, -0.17583719f, 0.02829361f, -0.12926222f, 0.11569712f, 0.00352348f, 0.01168220f, 0.13541922f, 
    0.11350353f, -0.08922473f, 0.15501614f, -0.07013930f, 0.11956885f, -0.01749617f, 0.17780469f, 0.08524060f, 
    -0.14784481f, 0.02923531f, 0.01549229f, 0.02129114f, -0.17171197f, 0.07419536f, -0.01111713f, -0.08333753f, 
    -0.00416183f, 0.08704849f, 0.04207475f, 0.00740028f, 0.10228501f, -0.13908902f, 0.38051364f, 0.15643854f, 
    -0.16815783f, 0.12670419f, 0.04632787f, -0.13222754f, 0.05712662f, -0.30231985f, -0.10526445f, 0.20918466f, 
    -0.19528137f, -0.21610136f, -0.00177930f, 0.05220503f, -0.10691285f, 0.02515262f, 0.04093247f, -0.39384645f, 
    -0.00551966f, 0.21182521f, 0.11613623f, 0.09528588f, -0.00547634f, 0.01399664f, 0.06247904f, 0.05410935f, 
    -0.18225943f, 0.10867240f, 0.14338546f, 0.03755125f, 0.05080302f, 0.12597135f, -0.03111353f, 0.08793201f, 
    0.02134213f, 0.05862463f, 0.14775263f, -0.02446154f, -0.24908622f, -0.17735735f, -0.15342468f, 0.10918330f, 
    -0.02209884f, 0.11962354f, -0.12253793f, 0.11674471f, 0.04928960f, 0.03152505f, -0.04813577f, 0.09399896f, 
    0.14713843f, 0.07832761f, 0.22611620f, 0.52937615f, 0.01086092f, -0.32842734f, 0.00931739f, 0.12567662f, 
    0.03517029f, -0.08345330f, 0.12881675f, 0.13354483f, 0.13902715f, -0.17428613f, -0.07624471f, -0.34165788f, 
    -0.13841900f, 0.11521704f, -0.09429986f, 0.15723363f, 0.24065128f, 0.17564155f, 0.07422057f, 0.10269692f, 
    0.01403393f, 0.11317585f, 0.05706236f, -0.01735314f, -0.07444251f, -0.05825228f, 0.03508420f, -0.32429051f, 
    0.12225126f, 0.00809173f, -0.14662705f, 0.03964987f, 0.04751675f, 0.16855225f, -0.00149074f, 0.40383989f, 
    0.12337121f, -0.21215191f, 0.08044919f, 0.20231731f, 0.02855014f, -0.17088027f, -0.06409671f, -0.06838545f, 
    -0.19866937f, 0.03685654f, 0.19183743f, -0.00229756f, 0.01475326f, 0.02872142f, 0.31584737f, 0.04879185f, 
    -0.00081713f, 0.21470110f, -0.18970074f, -0.13107741f, -0.10451282f, -0.01118529f, -0.07941076f, 0.08270702f, 
    -0.07334341f, -0.05024514f, -0.25103217f, -0.30425823f, -0.15162398f, 0.02210283f, -0.10109808f, 0.04301133f, 
    -0.03726102f, -0.01686311f, -0.39344540f, -0.14729682f, -0.03026395f, -0.18909162f, -0.24351713f, 0.10066520f, 
    0.08146805f, 0.20319073f, -0.07075620f, 0.09075710f, -0.31033063f, -0.02855592f, -0.26839033f, 0.03345606f, 
    0.12292957f, 0.06238363f, 0.17306499f, 0.02519751f, -0.09724368f, 0.06191533f, -0.05360958f, 0.12081752f, 
    0.00812583f, -0.03909307f, 0.07652222f, 0.06851561f, -0.06362580f, -0.09965613f, 0.18750478f, -0.14921245f, 
    0.07238383f, 0.15776619f, -0.04810158f, 0.15080486f, -0.17198932f, -0.05492032f, -0.02910119f, -0.09738070f, 
    0.14180842f, 0.00932620f, 0.00624524f, 0.01543192f, 0.09107810f, 0.09533063f, 0.00238839f, 0.23010306f, 
    0.25680047f, 0.01939684f, 0.08914694f, 0.02590516f, 0.10503292f, 0.12843256f, 0.06099315f, -0.05475155f, 
    0.04681060f, -0.28269738f, 0.27661449f, -0.24738440f, 0.16892880f, 0.11942577f, 0.21658027f, -0.04426873f, 
    0.17104782f, 0.18713731f, 0.02330451f, 0.04450384f, -0.06165783f, -0.09023823f, 0.04586867f, -0.00380038f, 
    -0.17455256f, 0.05261491f, 0.02780425f, -0.56599909f, 0.08236255f, 0.00207036f, 0.08411154f, 0.23831207f, 
    -0.08883242f, -0.24093474f, 0.10346135f, 0.07742172f, 0.08218603f, -0.32745790f, 0.04480860f, -0.20775315f, 
    -0.30488768f, 0.37388280f, 0.09695881f, 0.04926807f, 0.07127681f, -0.17828652f, -0.07615144f, -0.02153903f, 
    0.00143539f, 0.11086061f, 0.09296529f, 0.00882518f, -0.06524351f, 0.00612302f, -0.29941234f, -0.04640320f, 
    0.06358584f, -0.05385469f, -0.00475103f, 0.00919884f, -0.04331091f, -0.13533923f, 0.23510012f, -0.12244777f, 
    -0.45034477f, 0.20726198f, 0.14899649f, 0.18528463f, 0.03410113f, -0.16720971f, -0.10476037f, 0.22257052f, 
    -0.21424809f, 0.02950211f, 0.03285351f, -0.16308036f, 0.11262041f, -0.19325377f, -0.13086124f, 0.06970521f, 
    -0.04525892f, 0.20198363f, 0.06231804f, 0.12215558f, 0.02369181f, -0.11757609f, -0.13728113f, -0.03762180f, 
    -0.05252396f, 0.16257967f, 0.09121083f, -0.03560017f, -0.19601744f, 0.01772837f, 0.13138413f, 0.03097056f, 
    0.06149488f, -0.01508852f, -0.05969269f, 0.42278019f, -0.06782012f, 0.12745044f, -0.10904840f, -0.12465852f, 
    -0.17327599f, 0.19125570f, 0.06818698f, 0.23089248f, 0.12674557f, 0.01957399f, 0.03128327f, -0.12610464f, 
    -0.32988518f, -0.03908414f, 0.19342022f, 0.06009604f, 0.15465461f, 0.00431958f, 0.00946238f, 0.01644759f, 
    -0.04211293f, -0.14030020f, 0.02120378f, -0.19005126f, 0.09143136f, 0.15528129f, -0.08522398f, 0.14192969f, 
    -0.06869011f, 0.09982765f, 0.06680983f, -0.11813964f, -0.07996863f, -0.09625018f, 0.04370964f, -0.00584362f, 
    0.12946792f, 0.13553698f, -0.05255445f, -0.01610941f, -0.10013860f, -0.07720934f, -0.04333364f, 0.14039582f, 
    0.01850220f, 0.08522676f, -0.06085051f, -0.07470306f, 0.16614485f, -0.00753783f, -0.17749405f, -0.13588974f, 
    0.07341020f, -0.00095090f, 0.05783417f, 0.02064889f, 0.04791659f, 0.14019547f, 0.06098964f, 0.06823751f, 
    0.05727910f, -0.04992483f, 0.07495417f, -0.01743431f, -0.03419798f, -0.11546693f, -0.05618962f, -0.16947539f, 
    0.12529998f, 0.05841179f, 0.11701924f, -0.09406517f, -0.15285987f, 0.00301254f, 0.08343250f, 0.14997707f, 
    0.17777070f, -0.01287850f, -0.13738048f, 0.02989692f, 0.09339235f, 0.18770917f, -0.09359293f, 0.08152353f, 
    -0.05870398f, -0.23141776f, 0.11449298f, -0.12667367f, 0.03829879f, -0.01804776f, 0.01943673f, -0.02608826f, 
    0.12999775f, -0.01866687f, 0.19359416f, -0.13448557f, 0.16363347f, 0.06148917f, 0.04854435f, -0.07308501f, 
    -0.01949827f, -0.06472179f, 0.08222463f, -0.02949770f, 0.28964159f, -0.04721090f, -0.08969931f, 0.12699926f, 
    0.16643636f, -0.13642035f, 0.15179136f, 0.04804560f, 0.08281675f, 0.07303731f, 0.04757648f, 0.19936971f, 
    -0.08531365f, 0.00530902f, 0.44475466f, 0.00131378f, 0.17244603f, -0.09202286f, 0.06146901f, -0.03331603f, 
    0.21761110f, -0.41357204f, 0.05719435f, 0.05048569f, 0.15719332f, 0.17025413f, 0.05924232f, 0.03073184f, 
    0.10085458f, 0.15441026f, -0.10233844f, 0.01128786f, -0.12466150f, -0.17171994f, 0.06178536f, -0.01749270f, 
    -0.06377445f, 0.02770757f, 0.13228248f, -0.16983628f, -0.04869020f, -0.23292263f, 0.29791221f, 0.17020576f, 
    0.25096151f, 0.17933254f, 0.01658784f, -0.09372199f, 0.12651433f, 0.08445150f, 0.03543641f, -0.01080261f, 
    -0.07910330f, 0.02324155f, -0.00631865f, 0.15953107f, 0.12121759f, -0.03510195f, 0.09652335f, 0.15194012f, 
    -0.04836961f, 0.09236199f, -0.19705291f, 0.21833824f, -0.00571381f, 0.03742077f, 0.01633044f, 0.06448491f, 
    0.03045574f, 0.04981402f, -0.17156605f, 0.07707787f, -0.10107382f, 0.00325573f, 0.20531127f, 0.12625150f, 
    0.00608792f, -0.01921346f, 0.01531410f, -0.19627884f, -0.18631802f, 0.09165850f, 0.07889809f, 0.22326739f, 
    -0.03415759f, -0.18574947f, 0.00663464f, 0.04054083f, 0.10627536f, 0.09963112f, 0.18243885f, -0.07500241f, 
    -0.11828163f, -0.03305371f, -0.06493042f, -0.03828880f, -0.19672176f, -0.19385991f, -0.05936666f, -0.00271527f, 
    0.24731661f, -0.00285615f, 0.18853217f, 0.13317305f, 0.09908523f, -0.02691850f, -0.04256983f, -0.10136124f, 
    -0.08856583f, -0.02598475f, 0.11172402f, 0.03654329f, -0.02927739f, 0.02486681f, 0.16598967f, 0.02743850f, 
    0.20091809f, -0.22250305f, -0.11731241f, 0.03131717f, 0.13689560f, -0.04387594f, -0.15089916f, 0.18557252f, 
    -0.07849853f, -0.04298841f, 0.03918155f, -0.01753295f, -0.07946754f, 0.07745143f, -0.05599180f, 0.04871976f, 
    0.08570842f, -0.02583573f, 0.20222706f, -0.03883684f, 0.18848541f, 0.06855807f, 0.05260693f, -0.12009533f, 
    -0.11347223f, -0.07339364f, -0.06277466f, 0.06923612f, 0.03085101f, 0.00277033f, -0.15772963f, -0.22812697f, 
    -0.20409177f, 0.08670346f, 0.30037704f, 0.23477626f, 0.09249262f, -0.22932605f, 0.00198808f, 0.09117394f, 
    -0.04382610f, 0.08895375f, -0.12295374f, -0.00274590f, -0.01541811f, -0.06761211f, -0.07368376f, -0.03214104f, 
    -0.08526610f, -0.17423651f, -0.13699169f, 0.01721323f, -0.04445783f, -0.01689179f, -0.00848889f, -0.00839847f, 
    0.01676930f, 0.08580728f, 0.14611627f, 0.07133929f, -0.14932543f, 0.12913522f, -0.01826800f, 0.05783200f, 
    0.04412401f, 0.15629736f, -0.01424921f, -0.20008242f, -0.12056700f, -0.05939967f, 0.13077460f, 0.04623544f, 
    -0.13158759f, 0.05249068f, -0.00621065f, 0.11702257f, -0.48459235f, -0.53208739f, -0.42863056f, -0.05221919f, 
    0.07411290f, -0.18564551f, 0.24819057f, -0.13035408f, -0.00621638f, -0.37914455f, -0.07292568f, -0.08971131f, 
    0.06752530f, -0.05535170f, 0.12160744f, 0.17706171f, -0.03656352f, -0.07108549f, -0.11901471f, 0.03654084f, 
    -0.01957849f, -0.03036067f, -0.15185876f, -0.00416489f, -0.02955426f, 0.09877811f, -0.08126128f, -0.09066260f, 
    -0.29493582f, -0.13442743f, 0.03970315f, -0.01150141f, 0.19828288f, 0.06164610f, -0.00536077f, 0.08802990f, 
    -0.24858321f, -0.01975487f, 0.13221300f, -0.10168544f, -0.04294496f, -0.00603596f, -0.03785249f, 0.06433439f, 
    0.12267730f, 0.27038816f, 0.18586333f, -0.00449935f, -0.07035442f, 0.05368885f, -0.03913826f, 0.34850368f, 
    0.15693128f, -0.01489353f, -0.07943664f, -0.11233113f, -0.23315009f, -0.01980076f, 0.09717629f, -0.15706939f, 
    0.03338033f, 0.00197385f, 0.04598249f, 0.38286686f, -0.05454663f, 0.11561950f, 0.11355452f, 0.05430249f, 
    -0.02626496f, -0.10177252f, -0.07183373f, -0.07088253f, 0.27185911f, 0.11728403f, -0.03694039f, 0.11862539f, 
    -0.03512275f, -0.01501254f, 0.02420344f, -0.08977313f, -0.05614641f, -0.16731481f, -0.12183820f, 0.26977536f, 
    0.08866178f, 0.06881103f, 0.00778805f, 0.04251089f, 0.01430823f, 0.08694414f, 0.22436656f, 0.02820307f, 
    -0.12751518f, 0.03220058f, -0.07071164f, 0.02346400f, -0.00505115f, 0.04837963f, -0.15671133f, 0.02794256f, 
    0.13829403f, 0.03081192f, 0.06743041f, 0.05433999f, 0.01750760f, 0.00047445f, 0.04476941f, 0.18014556f, 
    0.03801834f, 0.09682613f, -0.30790880f, 0.01168669f, -0.01987245f, 0.08731076f, -0.00490466f, 0.19373941f, 
    0.13072291f, 0.08862469f, -0.00204283f, -0.10603815f, 0.00876678f, -0.04679864f, -0.00899771f, 0.01342189f, 
    -0.06982531f, 0.11652198f, -0.30343154f, -0.20122473f, 0.03356924f, 0.00285138f, -0.08195960f, -0.11026242f, 
    0.00577544f, 0.04274973f, -0.14446230f, 0.38915166f, 0.01389773f, 0.07635868f, 0.03448347f, 0.04482223f, 
    -0.13366807f, 0.10227278f, 0.03333396f, -0.05897159f, -0.03723223f, -0.59434122f, 0.16203821f, 0.00908491f, 
    0.01972806f, 0.10017432f, -0.04952860f, -0.05571008f, 0.12096990f, 0.04814586f, -0.17278355f, 0.11032439f, 
    0.06514286f, 0.06841735f, 0.00922540f, -0.14535579f, -0.06397255f, 0.02046481f, -0.13074663f, -0.10156956f, 
    -0.08738651f, -0.02398233f, -0.00784513f, 0.17085643f, -0.13470890f, -0.07426273f, 0.12767808f, -0.14730592f, 
    -0.09996561f, 0.00275199f, -0.03819941f, 0.10895343f, -0.05600790f, 0.02213809f, 0.15049948f, 0.13480023f, 
    0.06356787f, 0.12169080f, 0.17561825f, 0.08566606f, -0.07367957f, 0.19589609f, 0.04360722f, 0.08011959f, 
    0.02438721f, 0.02302960f, 0.07935623f, 0.10031421f, -0.11813804f, -0.01839902f, -0.09251854f, 0.01018006f, 
    0.09954438f, -0.15587041f, -0.02012521f, -0.28204581f, 0.17969254f, 0.06076967f, 0.20684850f, 0.02642829f, 
    -0.07530102f, -0.13784245f, 0.09655550f, 0.15260862f, 0.02043602f, 0.01830814f, -0.02605018f, 0.10733685f, 
    -0.06780041f, -0.01098745f, 0.16426143f, 0.07703090f, 0.02455412f, 0.01274183f, -0.01330303f, -0.05449893f, 
    -0.12360305f, 0.20765932f, 0.12082365f, 0.04942407f, 0.05356055f, 0.01955940f, -0.12971419f, 0.02413382f, 
    0.02824233f, 0.08899842f, 0.10700361f, -0.02886820f, -0.06601529f, -0.02923946f, -0.03067099f, -0.17344195f, 
    -0.07234417f, -0.00990340f, -0.18270428f, -0.18005610f, -0.01743524f, -0.03376425f, 0.01432305f, 0.07691959f, 
    0.31975734f, 0.02701614f, 0.11415379f, 0.01028853f, 0.10111313f, -0.04365060f, 0.00751781f, 0.02343374f, 
    -0.04611254f, 0.03712155f, 0.01081137f, -0.03865465f, -0.06251585f, -0.02413975f, 0.00880301f, 0.00352142f, 
    0.04095314f, 0.00078757f, -0.03578171f, -0.04665188f, 0.04749659f, 0.01161990f, -0.05745681f, -0.02660285f, 
    -0.03811961f, 0.03836681f, -0.03645070f, -0.03629326f, 0.03118847f, -0.04026949f, -0.05247726f, -0.06512307f, 
    0.04290306f, -0.04857145f, 0.01012418f, -0.04917512f, -0.01525527f, -0.01047456f, 0.01135545f, -0.02664526f, 
    -0.02343891f, -0.00583277f, 0.03565520f, -0.06037287f, -0.00117812f, -0.04907444f, 0.01951152f, 0.03698635f, 
    0.04806301f, -0.06627279f, 0.03741144f, -0.05390002f, -0.05498930f, 0.02283747f, -0.05147645f, -0.02361063f, 
    -0.04222201f, -0.03190845f, -0.04720039f, 0.00806757f, -0.02780504f, -0.03061198f, 0.02684977f, -0.04697477f, 
    -0.05157688f, 0.02005662f, 0.00925900f, -0.00145044f, -0.02266107f, -0.01430619f, 0.04844779f, 0.03702205f, 
    0.00047913f, -0.02259933f, -0.01110002f, 0.03124613f, -0.04180898f, -0.03329581f, -0.02312247f, -0.06373567f, 
    -0.01844746f, -0.03982070f, -0.02973095f, 0.04869400f, -0.03966612f, -0.03398545f, 0.02943563f, -0.03512301f, 
    0.01849531f, -0.01845238f, -0.02284507f, -0.02446388f, 0.04833071f, 0.02088937f, -0.01789183f, 0.04124664f, 
    -0.00490301f, 0.00350706f, 0.02533484f, -0.01555443f, 0.02960549f, -0.01991803f, 0.03420888f, 0.04910900f, 
    -0.01155837f, 0.04749004f, -0.04960827f, -0.06168078f, -0.00171383f, 0.03107861f, -0.00817605f, -0.05755013f, 
    -0.02978800f, -0.04249512f, -0.01119184f, -0.02667932f, -0.02638324f, -0.04060228f, -0.06576789f, -0.02007398f, 
    0.03808450f, 0.04691618f, -0.01137386f, 0.01913271f, 0.01614088f, -0.02103657f, -0.05488445f, 0.03546079f, 
    -0.06530350f, -0.01963967f, -0.05240228f, -0.05019689f, -0.03706601f, -0.06108438f, -0.01349864f, -0.01249381f, 
    0.03752679f, -0.03662826f, 0.04815905f, -0.00989244f, -0.02884527f, -0.01337574f, 0.03229342f, -0.02597746f, 
    0.02862442f, -0.04043973f, -0.04781858f, 0.00354884f, 0.04317729f, -0.00321278f, 0.01404887f, 0.03522624f, 
    0.04760244f, 0.03475638f, -0.00109419f, -0.06041855f, 0.00587891f, 0.02003528f, -0.00485591f, -0.06494606f, 
    -0.03966743f, 0.04856934f, 0.03253303f, -0.00390296f, -0.04760294f, -0.06021417f, -0.02537086f, -0.05085483f, 
    -0.02630884f, 0.01367156f, 0.03703752f, -0.00264583f, 0.01525402f, -0.01865488f, 0.03398628f, -0.06091224f, 
    -0.00689309f, -0.03513216f, 0.02916745f, 0.02202681f, -0.04336268f, 0.02682832f, 0.02897578f, -0.04441212f, 
    -0.01321984f, 0.00751143f, 0.00009934f, 0.00070655f, 0.04629365f, -0.06391225f, 0.02922275f, 0.02694127f, 
    -0.03297077f, 0.03821214f, -0.04720263f, -0.05844581f, 0.02086122f, -0.05670780f, -0.05469679f, 0.03592547f, 
    -0.05512464f, -0.01782369f, -0.02296850f, -0.01725869f, -0.04044450f, -0.04446886f, -0.00801647f, 0.03769423f, 
    -0.01976514f, 0.00311681f, -0.04047609f, 0.01724996f, -0.01814808f, -0.04704235f, 0.00480571f, -0.00341956f, 
    -0.04487014f, -0.05780119f, 0.03349454f, -0.00315179f, -0.04695641f, 0.02892046f, 0.01026759f, 0.01264838f, 
    0.01371664f, -0.02786247f, -0.00871145f, 0.02454715f, -0.00985972f, -0.00617145f, -0.05640521f, 0.04551956f, 
    -0.02401292f, -0.00585388f, 0.02518703f, 0.01544039f, -0.03758148f, -0.05989995f, -0.00946204f, -0.01805184f, 
    0.04958570f, 0.02929326f, 0.00125868f, 0.00055368f, 0.02783327f, 0.00202722f, 0.02000510f, 0.04394538f, 
    -0.04650443f, 0.04629254f, -0.00551795f, 0.03089085f, -0.06516092f, -0.02417426f, 0.00004723f, 0.00795535f, 
    -0.03527103f, -0.05930347f, 0.03588667f, -0.01075738f, 0.02510001f, 0.01059205f, -0.01090512f, 0.00342857f, 
    0.00068662f, -0.01035390f, -0.06426293f, -0.04212317f, -0.02289494f, 0.03448943f, -0.05881925f, -0.02156563f, 
    -0.03240501f, -0.05218506f, -0.00070118f, 0.01244954f, -0.00588780f, 0.01574090f, -0.02685066f, -0.02003442f, 
    0.05361997f, -0.00492527f, -0.01291728f, -0.04898033f, 0.03104786f, 0.05066422f, -0.03000546f, -0.04330734f, 
    -0.03458036f, -0.01401279f, -0.02772434f, -0.05044274f, -0.03529429f, 0.04630580f, -0.01295129f, -0.03434514f, 
    -0.06826189f, 0.08579573f, 0.19205895f, -0.07785578f, 0.19485746f, 0.10473792f, 0.18803610f, 0.04823990f, 
    0.00983848f, 0.01899841f, 0.09716100f, 0.15708846f, -0.01545598f, -0.00728326f, 0.09167034f, 0.00503713f, 
    0.11271579f, -0.01287134f, -0.12427397f, -0.06336665f, -0.19000836f, -0.04112911f, 0.19315191f, -0.00671653f, 
    -0.02897265f, 0.03013027f, -0.03767126f, 0.13401453f, 0.02783457f, -0.01674678f, -0.11407003f, 0.08968719f, 
    -0.03408790f, 0.08964869f, -0.07472745f, 0.13698788f, 0.01166208f, 0.03914686f, -0.09636123f, -0.03237946f, 
    -0.00939942f, 0.05110684f, -0.18752970f, 0.04408943f, 0.06042831f, -0.03427441f, 0.20670237f, 0.17547105f, 
    0.14500684f, 0.07548196f, 0.21167564f, 0.01917569f, 0.11092962f, -0.07217251f, -0.28022933f, -0.15862431f, 
    -0.05723583f, 0.00202235f, 0.07265295f, -0.11010763f, -0.01624004f, 0.07316762f, -0.08950042f, -0.00379896f, 
    0.14738505f, 0.10675668f, -0.06605328f, -0.03603565f, -0.01448519f, -0.05793345f, 0.03819861f, 0.05201595f, 
    -0.12717518f, 0.05694023f, 0.10948813f, -0.17672417f, 0.11685870f, -0.00200567f, 0.14847989f, 0.07770224f, 
    0.06021445f, -0.11817338f, -0.04640900f, -0.21721171f, 0.03209570f, 0.02761187f, -0.03505775f, 0.09616851f, 
    -0.02510507f, -0.10723431f, -0.03605213f, 0.14855933f, -0.07947434f, 0.11955115f, 0.02839716f, -0.05310712f, 
    0.13152111f, 0.03309850f, -0.06855410f, -0.05948178f, -0.03508738f, 0.09355578f, 0.09259400f, 0.02885643f, 
    -0.12525649f, 0.00265131f, -0.16083387f, 0.01715460f, 0.25133255f, 0.24731646f, -0.60323071f, 0.09341829f, 
    0.09095312f, 0.15862405f, 0.10767160f, -0.08276062f, -0.04055670f, -0.02148253f, 0.12261581f, 0.16679692f, 
    -0.17578849f, 0.06632197f, 0.00340794f, -0.05743866f, -0.06696845f, 0.10948037f, 0.09428745f, -0.06472826f, 
    -0.42225894f, -0.03107549f, 0.19941674f, 0.01852892f, 0.04980719f, -0.09104974f, 0.00082247f, -0.18753923f, 
    0.01096265f, -0.10551000f, 0.01557848f, 0.04219964f, 0.09157454f, 0.19811842f, -0.00429425f, -0.13711174f, 
    -0.08966487f, -0.05756371f, 0.25901443f, 0.10057208f, -0.00318467f, 0.03827963f, -0.01338214f, 0.10963596f, 
    0.06024831f, -0.18511985f, -0.21920364f, -0.15818308f, 0.18704291f, -0.08708604f, -0.12059402f, -0.02633658f, 
    0.23605561f, 0.10852309f, -0.29131582f, 0.01541532f, -0.22616880f, 0.02248453f, -0.04667136f, 0.01253727f, 
    -0.14487502f, -0.18731722f, -0.06476818f, -0.18190591f, -0.17803103f, 0.06211885f, -0.01057504f, -0.01892085f, 
    -0.01515950f, 0.17317538f, 0.01562726f, 0.07371655f, -0.29818058f, -0.04845868f, 0.08852898f, -0.17197478f, 
    0.03220732f, -0.08108284f, -0.09094021f, 0.07873933f, -0.12863417f, 0.16487508f, 0.00927043f, 0.06034305f, 
    0.08231333f, -0.05028367f, -0.01907808f, 0.11425570f, 0.01032586f, -0.00517072f, 0.01266950f, 0.03415824f, 
    0.04830014f, -0.14697661f, -0.06510016f, -0.08835623f, 0.03317764f, -0.08551755f, 0.04331601f, 0.19432873f, 
    0.06758052f, -0.10458368f, 0.12653533f, 0.01679611f, -0.07336575f, 0.03020950f, -0.00817994f, 0.06421621f, 
    -0.30303580f, -0.04604905f, -0.05283654f, 0.15456870f, 0.09734938f, 0.12592643f, -0.08133924f, -0.10169772f, 
    -0.04227031f, -0.10154142f, -0.09428723f, -0.14864057f, -0.08740158f, -0.05025388f, -0.05978544f, 0.18033715f, 
    -0.01408392f, -0.07414152f, 0.15677685f, 0.08657914f, -0.04270915f, 0.11850178f, 0.19888075f, 0.12605707f, 
    0.04688512f, -0.04547789f, -0.15210702f, -0.28213358f, -0.11044359f, -0.13973410f, -0.09080263f, 0.07666945f, 
    0.04375967f, -0.02409875f, -0.09499625f, 0.05278203f, -0.25148422f, 0.05222395f, -0.46707022f, 0.16959484f, 
    0.00912330f, -0.02196687f, -0.16790690f, -0.19375630f, -0.05389539f, 0.07583561f, 0.19467488f, 0.27938372f, 
    -0.00662409f, 0.02588380f, 0.06474325f, 0.10904537f, 0.07777109f, 0.23825024f, -0.08951148f, -0.11841284f, 
    -0.37792465f, 0.20477214f, 0.13623521f, 0.05516670f, 0.09681869f, -0.12502553f, -0.01557707f, -0.12639527f, 
    -0.30940273f, -0.01433325f, -0.00022648f, -0.03131343f, -0.11897034f, -0.03396093f, 0.06578573f, 0.13605228f, 
    0.04580512f, -0.44814029f, 0.07142394f, 0.18434702f, 0.12045331f, 0.05715758f, -0.11627910f, -0.01488809f, 
    0.12543352f, -0.35200903f, 0.02232390f, -0.10823932f, -0.02482143f, 0.14320290f, 0.03466306f, 0.07546275f, 
    -0.03905341f, 0.08608016f, 0.24921504f, 0.17630383f, -0.01416164f, -0.23359486f, 0.05726400f, -0.05538901f, 
    0.00748905f, 0.21072504f, 0.03023244f, -0.25857475f, 0.30092788f, -0.02035772f, 0.10576831f, -0.09639598f, 
    -0.00532566f, 0.08966093f, -0.06140435f, -0.00780484f, -0.27639237f, -0.19848019f, 0.13184324f, 0.07468254f, 
    -0.04177497f, 0.10896768f, -0.00437130f, 0.06705858f, -0.31626895f, -0.17193063f, -0.18591239f, -0.10024486f, 
    -0.01391654f, 0.11025053f, 0.03261700f, -0.16687733f, 0.21243373f, -0.15571779f, 0.14259250f, 0.07538869f, 
    -0.15303451f, 0.08882760f, -0.07632722f, -0.07847633f, -0.08116038f, 0.00007459f, -0.17633756f, -0.16420886f, 
    0.01030654f, 0.08275846f, 0.01947709f, 0.10709292f, -0.04302787f, 0.03404328f, 0.08573665f, 0.06854096f, 
    -0.27778569f, -0.05866608f, 0.06060809f, 0.15437487f, 0.12131368f, 0.06389091f, -0.03823387f, 0.02739024f, 
    0.00676111f, 0.27346504f, 0.27597022f, 0.05698674f, -0.00721856f, -0.15279806f, -0.03296692f, 0.05637413f, 
    0.11444423f, 0.11323767f, -0.06029711f, -0.30745649f, -0.07194614f, -0.10143497f, -0.00521779f, 0.10697024f, 
    0.00800831f, -0.05368188f, -0.10744539f, -0.01961326f, -0.17642885f, -0.11522856f, 0.13591285f, 0.02344627f, 
    0.02930479f, -0.04996346f, -0.00706421f, -0.03084201f, 0.31032690f, 0.24642082f, 0.05341597f, 0.03321463f, 
    0.04287660f, -0.10155545f, 0.03669390f, 0.09966653f, -0.07588422f, -0.09879390f, 0.02562647f, -0.01974059f, 
    0.00649117f, 0.16043039f, -0.01046956f, -0.07473265f, 0.05264794f, -0.09980735f, 0.10474532f, 0.09353767f, 
    -0.10163758f, -0.21551427f, -0.03420392f, -0.04728441f, 0.03242595f, -0.03344242f, 0.02982943f, 0.01256665f, 
    0.05011584f, 0.02692576f, 0.02830965f, 0.00355670f, -0.01948152f, 0.01507327f, -0.11533685f, 0.18092784f, 
    0.21166714f, -0.07925753f, -0.16800022f, -0.05031371f, 0.06980836f, 0.09371601f, 0.15288517f, 0.01601665f, 
    0.04186931f, -0.14735760f, -0.08985558f, 0.03335670f, -0.16781935f, -0.08312251f, 0.03029036f, 0.13275927f, 
    -0.02071647f, -0.05580736f, -0.00320750f, -0.07223050f, 0.05369928f, -0.01199812f, -0.02344053f, 0.09203459f, 
    -0.09929304f, -0.02871243f, 0.07138241f, -0.17594957f, -0.05750370f, -0.20908615f, 0.03582851f, 0.07553649f, 
    -0.07338096f, 0.04886899f, 0.11861914f, 0.00837924f, -0.42358083f, 0.14945444f, -0.17130223f, 0.14808851f, 
    0.06544097f, 0.07180690f, -0.09117118f, -0.04702057f, -0.06429082f, 0.27711102f, 0.08097861f, -0.10278423f, 
    0.07975373f, 0.10917622f, 0.04283090f, 0.05608192f, 0.15976505f, -0.02849299f, 0.07037469f, 0.06295756f, 
    -0.12346130f, 0.01989264f, -0.05936394f, 0.17826113f, -0.08996046f, -0.06884938f, 0.17872259f, -0.02325409f, 
    -0.08081118f, -0.00203721f, -0.00479075f, -0.02095218f, 0.18606271f, 0.09630290f, -0.03518892f, 0.08195578f, 
    -0.04475326f, 0.01435247f, -0.22856887f, -0.16822548f, -0.10586195f, 0.03472344f, 0.10147649f, 0.01533398f, 
    0.12200365f, -0.10413574f, 0.03655256f, -0.14176710f, -0.04577264f, -0.05092753f, -0.13550283f, 0.07559621f, 
    -0.03506016f, -0.02025551f, -0.19264188f, 0.00033773f, -0.05326884f, 0.09581372f, -0.01274182f, 0.04175328f, 
    0.04401460f, 0.01256744f, 0.03032841f, -0.35926360f, 0.14581543f, 0.01601122f, 0.01639385f, -0.15754737f, 
    0.11419130f, -0.09222525f, 0.11683595f, -0.02269400f, -0.03844755f, -0.02461907f, 0.05071139f, -0.14944699f, 
    -0.11745860f, -0.13170961f, -0.14415587f, 0.09396308f, -0.14203769f, -0.05621299f, 0.05596463f, -0.11755031f, 
    -0.01131123f, -0.02137261f, -0.05601622f, -0.11512554f, 0.01635553f, -0.06905142f, 0.33026829f, -0.03956620f, 
    -0.02530283f, -0.04039741f, -0.03886259f, -0.18818092f, 0.03713314f, -0.09091931f, 0.08518681f, 0.23528400f, 
    0.01847047f, -0.03727852f, -0.16414016f, 0.04837890f, 0.10078143f, 0.04790787f, -0.08654741f, -0.09187869f, 
    0.14035571f, -0.13468854f, -0.22783001f, 0.27912110f, 0.15063192f, 0.15062755f, -0.09471225f, -0.02760316f, 
    -0.06554005f, 0.20826854f, -0.01982710f, -0.08869453f, 0.19507235f, 0.11374260f, -0.03534730f, -0.12953074f, 
    0.05768508f, 0.03630382f, -0.11894994f, -0.26465830f, 0.25159368f, -0.03704055f, 0.01721642f, 0.01366457f, 
    -0.06709248f, -0.02691495f, -0.02306925f, -0.15870042f, -0.02367378f, -0.28323472f, 0.03356234f, -0.07739832f, 
    0.12976849f, 0.05530733f, 0.01169309f, -0.06857118f, -0.02317144f, 0.23991109f, 0.11762314f, -0.03616242f, 
    0.18892060f, -0.21417692f, 0.07961453f, 0.14874837f, -0.11452641f, 0.28289270f, 0.14741604f, -0.16656648f, 
    0.10902916f, -0.03093706f, -0.13336581f, 0.17114551f, -0.04506873f, -0.05228670f, -0.01896547f, 0.11212912f, 
    -0.10582509f, -0.01535950f, -0.04989626f, 0.24711762f, -0.03504226f, 0.00366724f, -0.05453866f, 0.13916871f, 
    -0.01391535f, -0.00370817f, 0.18953411f, 0.00839597f, -0.09720647f, 0.02961520f, 0.10325726f, -0.23449205f, 
    0.11571176f, 0.24962227f, -0.14939426f, 0.12225584f, 0.10669313f, 0.01007133f, -0.08087194f, 0.01142296f, 
    -0.09862674f, 0.04974599f, 0.07172927f, 0.07435817f, -0.01441764f, 0.02651712f, 0.08192556f, -0.06806463f, 
    -0.25270453f, 0.04398482f, -0.25433588f, 0.05691972f, -0.19662318f, 0.05535672f, 0.04192070f, -0.04012811f, 
    0.10781841f, -0.24686593f, 0.06254334f, 0.12176511f, 0.05959989f, -0.15511368f, -0.06426932f, -0.02184304f, 
    0.14715047f, -0.05143815f, 0.12543300f, 0.14315249f, -0.04807084f, -0.07023920f, 0.09811305f, -0.09362084f, 
    -0.13549994f, 0.11998389f, 0.03906364f, 0.02025386f, 0.13413838f, 0.10989448f, 0.30075380f, -0.18597503f, 
    0.11608449f, 0.05723809f, 0.04939491f, -0.02768802f, -0.02495811f, -0.07051016f, 0.06590407f, -0.10473698f, 
    0.10031271f, 0.06412097f, -0.02978924f, -0.01654872f, -0.09229483f, 0.17853408f, 0.15296265f, -0.19439061f, 
    -0.03845922f, -0.01022596f, -0.19885594f, 0.01191197f, -0.01324378f, -0.07243445f, -0.02999828f, -0.08105382f, 
    0.18545903f, -0.08534056f, -0.12382545f, 0.09470131f, -0.07754186f, 0.02598433f, 0.08005416f, -0.11125249f, 
    -0.06396981f, 0.13188857f, -0.14101815f, 0.01490826f, -0.05614338f, 0.10921777f, 0.08516613f, -0.01181908f, 
    -0.03547478f, 0.08881750f, 0.10495203f, 0.15725778f, -0.08709338f, 0.09081047f, -0.06714663f, 0.12033943f, 
    -0.14147037f, -0.09352299f, -0.16664630f, 0.04545781f, 0.07706988f, 0.07235403f, 0.08140115f, -0.01413435f, 
    0.09230570f, 0.10462902f, -0.01400343f, 0.10452055f, 0.03702265f, 0.06774824f, -0.18215214f, 0.06403726f, 
    0.19429544f, 0.01442699f, -0.12857471f, -0.05548584f, -0.28734341f, -0.02489213f, -0.03376316f, 0.01329905f, 
    -0.00221742f, -0.01498547f, 0.07481347f, -0.05094214f, -0.14808840f, 0.15525229f, -0.03475741f, 0.15590192f, 
    -0.10086921f, 0.19629833f, -0.14222191f, -0.08030757f, -0.02835891f, 0.15891172f, -0.15649389f, -0.17552376f, 
    0.02231685f, -0.10131139f, 0.03900488f, 0.07506015f, 0.03211061f, -0.10195753f, -0.18905272f, -0.12026019f, 
    0.05303453f, 0.02328461f, 0.00507429f, 0.07076941f, -0.03958964f, -0.12791045f, -0.06622583f, 0.11860484f, 
    0.01423976f, 0.11260038f, 0.17457414f, -0.04330412f, -0.22846118f, 0.07764260f, 0.08094589f, -0.02170164f, 
    0.01646379f, 0.00321266f, -0.18447702f, -0.14927824f, -0.08765140f, -0.01423231f, 0.13827437f, 0.07240929f, 
    -0.17723091f, -0.12749735f, -0.02585967f, 0.05576719f, 0.26562893f, -0.12535565f, -0.06400367f, 0.05650132f, 
    0.09223369f, -0.07140863f, -0.01316185f, -0.19569871f, -0.10033779f, -0.08489124f, 0.22994213f, -0.01880582f, 
    -0.08868793f, -0.16581982f, -0.23511565f, 0.20140606f, 0.06561249f, 0.14843415f, 0.21964057f, -0.22974879f, 
    0.00655775f, 0.12311780f, -0.03385984f, -0.02508881f, 0.12038700f, 0.05246178f, -0.08790521f, 0.06696910f, 
    0.10701220f, -0.13823773f, 0.10581102f, 0.00812582f, -0.10370392f, -0.10577060f, -0.12929077f, 0.10885654f, 
    0.08296986f, 0.10255588f, -0.05174967f, 0.08786956f, -0.05824890f, 0.07395142f, 0.31573215f, 0.00721572f, 
    0.16314752f, -0.26822147f, 0.27871615f, -0.07262240f, 0.03824186f, -0.04861979f, 0.01888489f, -0.02523520f, 
    -0.10521977f, -0.07511557f, -0.10505079f, 0.14703831f, 0.02891404f, 0.01911316f, 0.09479913f, 0.12936924f, 
    0.02571738f, 0.05090243f, 0.12384056f, 0.07101671f, 0.15381081f, -0.22048502f, 0.06858362f, -0.04163761f, 
    -0.03236837f, 0.31321660f, -0.02696312f, -0.05163708f, 0.12117508f, 0.16481616f, 0.04658837f, -0.11297298f, 
    -0.14521369f, -0.13304353f, 0.01558426f, 0.05306835f, -0.14584391f, -0.06107191f, 0.07981190f, 0.02501085f, 
    -0.15267824f, 0.05403966f, 0.04544096f, -0.09155375f, -0.01388931f, -0.06857499f, -0.36341041f, 0.05518468f, 
    0.09012017f, -0.01898446f, 0.05412000f, -0.01564954f, -0.07754706f, -0.00044622f, -0.15428594f, 0.31580567f, 
    -0.21791154f, -0.07363432f, 0.17162336f, -0.14310512f, -0.06423100f, -0.00282165f, -0.16043304f, 0.09028590f, 
    -0.06413837f, 0.05660369f, 0.08550243f, 0.07660516f, 0.04092414f, 0.04150084f, -0.00698528f, 0.07694128f, 
    -0.15831475f, -0.00100314f, 0.19423646f, 0.12602884f, 0.00279033f, -0.09885275f, -0.07985856f, 0.09538829f, 
    -0.12656893f, -0.00326859f, 0.21293761f, 0.16505960f, -0.07069603f, -0.12033365f, -0.03789023f, 0.03444313f, 
    0.16922015f, 0.06965999f, -0.10313552f, -0.21084253f, 0.00399708f, 0.02306476f, -0.13935573f, -0.12747166f, 
    0.10521679f, 0.04473577f, 0.00575757f, -0.11518232f, -0.01948436f, -0.16587286f, -0.02903218f, 0.00053813f, 
    0.06732319f, -0.10304487f, -0.04240019f, 0.07280497f, -0.00408125f, 0.06829141f, 0.19015422f, -0.00489225f, 
    0.15464471f, -0.11729363f, -0.01960482f, -0.25027847f, 0.00509831f, -0.30317828f, -0.07457206f, 0.13467108f, 
    0.17872597f, 0.07413134f, -0.03908748f, -0.06406855f, -0.06123891f, -0.15256716f, -0.10372150f, 0.13465381f, 
    -0.13034114f, -0.09872424f, 0.01434112f, 0.14773373f, 0.03220261f, -0.13976216f, -0.05491611f, 0.14106521f, 
    0.20120448f, 0.21490453f, -0.09759839f, -0.12648535f, 0.11532072f, -0.09419964f, 0.05999591f, 0.04889421f, 
    -0.15412475f, 0.06526348f, -0.03712650f, -0.08267088f, -0.04611557f, 0.07060090f, 0.08823729f, 0.23853523f, 
    0.01206931f, -0.39363480f, 0.16496015f, -0.19239423f, -0.05342902f, -0.28460193f, -0.02126514f, 0.06792818f, 
    0.06974858f, 0.13404946f, 0.35337043f, -0.23571984f, 0.03762156f, -0.08125208f, -0.03885897f, -0.01989012f, 
    0.07515753f, 0.02738254f, 0.12007900f, -0.05170007f, 0.10384308f, -0.08641697f, -0.01288351f, -0.01922428f, 
    0.05386306f, -0.08272351f, 0.06067096f, -0.16524196f, -0.42297006f, 0.13030471f, -0.08369212f, 0.01831547f, 
    -0.08749655f, -0.01436650f, 0.09734711f, -0.10241227f, -0.02058571f, 0.06858425f, 0.17404249f, 0.03239293f, 
    0.08384373f, 0.00278263f, -0.08489686f, -0.02996006f, -0.05716775f, 0.02095745f, 0.05066263f, 0.02380137f, 
    -0.11922058f, 0.04407479f, -0.03122916f, -0.05410828f, -0.03747143f, -0.06893460f, 0.02644928f, 0.11176804f, 
    -0.09591149f, 0.08743623f, 0.11578508f, -0.13228968f, -0.06767288f, -0.03037540f, 0.17436500f, 0.13422173f, 
    -0.12541418f, -0.04925607f, -0.04604380f, -0.08109599f, -0.09526720f, 0.09887913f, 0.13373046f, 0.07368163f, 
    0.07565030f, 0.00456620f, 0.01733332f, 0.04936995f, -0.20656809f, -0.12011024f, -0.16753118f, -0.00774541f, 
    0.04155445f, 0.14248367f, 0.08731586f, -0.09376859f, 0.10147678f, -0.02687271f, -0.08993526f, -0.04392736f, 
    0.04955735f, -0.07394085f, -0.12392621f, -0.06038075f, 0.04411379f, 0.04336200f, -0.02398200f, 0.01069109f, 
    0.09209465f, 0.04508318f, -0.03881973f, 0.08315452f, -0.09541765f, 0.01652835f, 0.02298070f, -0.08290444f, 
    0.06028623f, -0.05509095f, 0.09507319f, -0.01215802f, -0.08596522f, -0.00384887f, -0.05507884f, 0.18130268f, 
    0.01277850f, 0.04029928f, -0.08726666f, -0.10484244f, 0.00008342f, -0.12047977f, 0.21579380f, -0.02544151f, 
    0.38468319f, 0.05164214f, -0.04105706f, -0.05176527f, -0.08776509f, -0.00135546f, -0.03128964f, 0.30286476f, 
    -0.07001567f, -0.09082086f, 0.05844707f, 0.12124904f, 0.04966495f, 0.04304652f, 0.00446203f, 0.04946953f, 
    0.04015819f, -0.00009239f, 0.04554860f, 0.02510982f, -0.03982642f, -0.00321126f, 0.02840757f, -0.05820445f, 
    0.03729231f, -0.05388541f, -0.02025726f, 0.04044508f, -0.04927484f, 0.00546604f, -0.03283579f, -0.04939980f, 
    0.02022597f, 0.00366488f, 0.02786316f, 0.02784208f, 0.05034672f, -0.04592592f, -0.00950208f, 0.03264846f, 
    0.02564560f, -0.05396858f, -0.04674644f, 0.00092930f, -0.00630333f, 0.04047776f, -0.02403442f, -0.00265387f, 
    0.03690812f, -0.05555411f, 0.01295261f, -0.03359500f, 0.02220014f, -0.06166156f, -0.01463210f, -0.01030974f, 
    0.04624220f, -0.02365385f, -0.03933692f, 0.02050801f, -0.01719570f, -0.03566599f, 0.03453252f, 0.04967196f, 
    0.01680737f, 0.00173825f, 0.00195251f, -0.03731713f, -0.02567939f, -0.00820922f, -0.02003956f, 0.04258233f, 
    0.03349899f, -0.00218246f, -0.04561319f, -0.04735120f, 0.04040960f, 0.04708740f, -0.02299814f, 0.01409920f, 
    0.01499436f, -0.01907888f, -0.01076761f, 0.05120433f, -0.02916409f, -0.03352946f, 0.04726323f, -0.03775504f, 
    -0.05520763f, 0.01048647f, 0.02415114f, 0.03771345f, 0.04647823f, 0.02640551f, -0.03029621f, -0.04630849f, 
    -0.00932832f, -0.01351325f, -0.01287872f, -0.06027339f, -0.05555899f, -0.05816353f, 0.04667804f, 0.00395458f, 
    -0.01714556f, -0.02047523f, -0.05671546f, 0.00530962f, 0.01424587f, 0.00455969f, -0.03825301f, -0.01965485f, 
    -0.03475443f, 0.05141930f, -0.04758078f, -0.04238569f, -0.05017895f, -0.03040284f, -0.01215669f, 0.00132251f, 
    0.04967216f, -0.00956826f, -0.04388684f, 0.01091487f, 0.05000580f, -0.00385277f, -0.03795594f, -0.03117025f, 
    -0.04144856f, 0.03428671f, 0.01103862f, 0.02027772f, -0.04583523f, 0.04826361f, -0.00791720f, -0.02016273f, 
    -0.02652279f, -0.02441887f, 0.02525266f, -0.05405482f, 0.03814818f, -0.02535957f, -0.01104000f, 0.04355903f, 
    -0.05374702f, -0.06009055f, 0.01626311f, 0.02167816f, 0.04579385f, 0.02600046f, -0.03258585f, -0.00620502f, 
    0.01820249f, 0.04525416f, -0.00605454f, 0.00651092f, -0.01759361f, 0.03317126f, -0.03462283f, 0.04797610f, 
    -0.04128480f, -0.04288569f, 0.04672039f, -0.02288114f, -0.01640126f, -0.02494472f, 0.03618106f, 0.01088634f, 
    0.00284696f, 0.01042664f, -0.03417980f, 0.04438368f, 0.04804743f, -0.06374007f, -0.02701105f, -0.01371076f, 
    -0.02161726f, -0.04698035f, 0.03756857f, 0.03250929f, -0.01428147f, -0.01097977f, -0.03863343f, 0.03269198f, 
    0.00760558f, 0.05131301f, 0.05291399f, 0.03757184f, -0.04002292f, -0.05523845f, -0.02043910f, -0.04099121f, 
    -0.00539417f, 0.02416863f, -0.01012858f, 0.03617379f, -0.00486875f, 0.01038245f, 0.04226141f, -0.02332253f, 
    -0.01580124f, 0.01722499f, -0.05303585f, 0.02803871f, 0.04304637f, 0.03331731f, -0.05253101f, 0.04101532f, 
    -0.00847383f, -0.04257455f, 0.01916926f, -0.00185842f, -0.04794615f, -0.05251241f, -0.03566238f, -0.04272858f, 
    0.00217651f, 0.01020801f, 0.04800666f, 0.02037536f, -0.00529483f, 0.01067409f, 0.04121199f, 0.04725077f, 
    -0.05666358f, -0.03965484f, 0.00980371f, -0.05728348f, 0.00125303f, -0.02284910f, -0.03418555f, -0.04596236f, 
    -0.02451305f, 0.03420810f, 0.03167988f, -0.06186767f, 0.00711549f, -0.04041948f, -0.01106315f, 0.03650820f, 
    -0.03128159f, -0.00377132f, -0.04713602f, -0.00918045f, -0.03748389f, -0.02935600f, -0.05683750f, 0.01431614f, 
    -0.03533093f, 0.02770825f, 0.03509025f, -0.02334160f, -0.04744460f, -0.05550910f, -0.01605711f, -0.04414377f, 
    -0.02226719f, 0.02294216f, -0.03405011f, 0.05454513f, 0.00682567f, -0.01427446f, 0.02859304f, 0.01417628f, 
    0.01654404f, -0.00431161f, -0.04787141f, 0.03473388f, -0.01744469f, 0.00271040f, 0.02941935f, -0.02115081f, 
    0.00953404f, 0.00426026f, 0.00955860f, 0.03987138f, 0.04301659f, 0.04468485f, 0.05583665f, 0.00703213f, 
    0.00002380f, 0.03399456f, -0.04847461f, -0.03573150f, -0.03752508f, -0.01629293f, -0.02596633f, -0.02747825f, 
    -0.02908272f, -0.00006004f, 0.00438789f, -0.06120016f, 0.00451978f, -0.03771546f, -0.05564941f, -0.00067752f, 
    0.01406293f, -0.06155309f, -0.02745702f, 0.01423864f, 0.03683671f, -0.04834820f, 0.05067534f, -0.00178370f, 
    -0.01227988f, 0.05689316f, 0.05741297f, 0.03679677f, 0.01792277f, -0.05644311f, -0.02748114f, 0.02074161f, 
    0.03336050f, -0.04148317f, -0.03185492f, -0.00973864f, -0.02543586f, 0.00772743f, -0.01068345f, 0.00375431f, 
    -0.01234246f, -0.01459587f, 0.01260980f, -0.03065966f, -0.02308830f, -0.05476309f, 0.01401323f, 0.02922947f, 
    -0.00843968f, -0.04382151f, 0.02278328f, -0.02421379f, 0.00038368f, -0.00578388f, -0.03775195f, 0.04396465f, 
    0.03325598f, -0.04200426f, -0.05650197f, 0.04138441f, -0.00527241f, -0.06964812f, 0.04927808f, 0.00881740f, 
    -0.06578695f, -0.05399475f, 0.03997143f, -0.03676914f, -0.06513262f, -0.07104086f, -0.02402129f, -0.00325212f, 
    -0.05400359f, -0.05468705f, 0.02791173f, 0.03039071f, -0.00596106f, 0.00388099f, 0.03803412f, -0.01259803f, 
    0.02100554f, -0.04059699f, 0.01188321f, -0.06576326f, -0.02848361f, -0.07218294f, 0.01036657f, 0.02632000f, 
    0.02628603f, 0.03793702f, 0.04369350f, 0.02514878f, -0.03723894f, -0.07113101f, -0.00117180f, -0.02549117f, 
    -0.01429510f, -0.02964937f, -0.00349446f, -0.06803769f, -0.07088855f, -0.07264038f, -0.02287074f, -0.02540502f, 
    -0.07220241f, 0.01796591f, -0.01273385f, 0.02789047f, -0.00781190f, -0.02711879f, -0.00380148f, 0.00255839f, 
    -0.04828119f, 0.04204507f, -0.03467185f, -0.06858754f, -0.04048690f, -0.02325928f, 0.04328342f, 0.02453725f, 
    -0.05041724f, -0.03418576f, -0.02316196f, -0.03685712f, -0.05536213f, -0.06339113f, -0.05821685f, -0.01874888f, 
    0.02301575f, 0.02771446f, 0.04074847f, 0.01711399f, -0.05573092f, -0.03691692f, -0.04739771f, -0.03242783f, 
    -0.05165402f, -0.06509078f, -0.01833792f, -0.00287245f, 0.00071752f, -0.01647493f, -0.02810348f, -0.05837598f, 
    -0.04537297f, -0.02750227f, -0.02421695f, -0.07138637f, -0.03789950f, 0.04392485f, -0.02010836f, 0.03541831f, 
    -0.03172084f, -0.00220058f, -0.02686964f, -0.03670920f, -0.06208035f, -0.01555731f, -0.06162365f, 0.01298790f, 
    -0.03321296f, 0.02126792f, 0.02967861f, -0.04544801f, -0.03521999f, -0.05253879f, 0.04366798f, -0.02887647f, 
    -0.02563373f, -0.04729636f, 0.03362521f, -0.05788424f, 0.00263193f, 0.02266192f, 0.04230192f, -0.02207104f, 
    -0.06322653f, 0.00984803f, -0.06488362f, -0.02106683f, 0.00583717f, -0.04853175f, 0.00793874f, -0.06423300f, 
    -0.05900237f, -0.06490303f, -0.05056130f, 0.03475547f, 0.01064054f, -0.06302470f, 0.01803912f, -0.05833843f, 
    -0.05956692f, 0.00437211f, 0.00823886f, 0.03933084f, -0.05784176f, -0.05219407f, -0.04625135f, -0.05452298f, 
    -0.03332614f, 0.01459389f, -0.04048157f, -0.03227897f, 0.00810767f, -0.03090758f, -0.04995686f, 0.01118395f, 
    -0.01577363f, -0.02531067f, -0.06177307f, -0.07285515f, 0.04226723f, -0.06059180f, -0.04845388f, -0.03790898f, 
    -0.02566518f, -0.03672641f, -0.02648517f, 0.03133526f, -0.06455769f, 0.02594172f, -0.01514319f, -0.00759092f, 
    -0.00088935f, -0.00366581f, -0.02142000f, 0.00472931f, -0.01395824f, -0.04861222f, -0.04042060f, 0.02720708f, 
    -0.01839576f, 0.04356348f, 0.04393844f, 0.00012912f, -0.01977774f, -0.04063841f, 0.04089480f, -0.05724142f, 
    -0.04269899f, 0.02033857f, 0.00948358f, -0.05808072f, -0.03369893f, 0.00528481f, -0.01034282f, 0.01284387f, 
    -0.04603978f, -0.00859809f, -0.00320215f, -0.06521354f, -0.00121589f, 0.00404046f, -0.03154220f, 0.04085595f, 
    0.01844032f, -0.02658184f, -0.02454351f, -0.03570757f, -0.02462109f, -0.06864700f, -0.02547196f, 0.02575386f, 
    -0.01959007f, -0.03548762f, -0.00897557f, -0.02345734f, -0.03045253f, -0.04704373f, 0.02449497f, 0.00768474f, 
    -0.05362662f, -0.06282108f, 0.01088334f, 0.03072153f, -0.00243441f, -0.04478531f, -0.00257448f, 0.01538902f, 
    -0.02212226f, -0.02875502f, 0.00185636f, 0.01538002f, 0.05273142f, -0.05528218f, -0.05132810f, -0.05768599f, 
    -0.01409949f, -0.06668521f, -0.05680158f, -0.02908213f, -0.00836539f, -0.03377941f, -0.03393833f, -0.05579826f, 
    -0.07153288f, -0.02496315f, -0.00230353f, -0.02205870f, -0.03429197f, -0.01603002f, 0.01803634f, -0.05331282f, 
    -0.02456827f, -0.01871787f, -0.02320335f, -0.05740080f, 0.03579282f, 0.03282418f, -0.02970666f, -0.00273871f, 
    -0.14221285f, 0.22489598f, -0.11122413f, 0.00671681f, -0.15043101f, -0.02906656f, -0.07171507f, 0.02319382f, 
    -0.09219877f, -0.27596122f, -0.10923604f, 0.12047023f, 0.13238446f, 0.01247799f, 0.03911319f, -0.03745835f, 
    0.05465525f, 0.03641984f, 0.10142975f, -0.21259803f, 0.05078700f, 0.00412373f, 0.00636659f, 0.08027826f, 
    0.01305693f, -0.11210240f, -0.13115615f, 0.09343868f, 0.04553735f, -0.09938552f, 0.02296126f, -0.02817463f, 
    0.08665970f, -0.01922430f, 0.06541961f, -0.15326202f, -0.29550001f, -0.02668209f, -0.20651706f, -0.00373724f, 
    -0.09300546f, -0.02992533f, 0.08259217f, 0.05480102f, -0.05081756f, -0.30024678f, 0.04994766f, 0.08878265f, 
    -0.22334231f, 0.06903604f, 0.03015311f, -0.01061643f, -0.19595334f, 0.05004693f, 0.11542796f, 0.22006845f, 
    -0.12580256f, -0.06347171f, -0.10415267f, 0.09558111f, 0.08820397f, 0.05814525f, 0.10224619f, -0.12789363f, 
    -0.23349875f, -0.10768533f, 0.06066952f, -0.08231841f, -0.01310677f, -0.01152028f, 0.10517205f, -0.06686866f, 
    -0.05395130f, 0.04419218f, -0.03086262f, 0.08213703f, -0.00682782f, -0.03908231f, 0.07051200f, -0.14529508f, 
    0.10595956f, 0.23467214f, -0.02059850f, -0.09131980f, -0.02235685f, 0.04740011f, -0.05107325f, -0.02610548f, 
    0.05251273f, -0.03673404f, -0.07489958f, 0.13558780f, -0.12322603f, -0.04459598f, -0.04769211f, 0.01674422f, 
    0.04483808f, 0.05736536f, -0.05472293f, 0.27741578f, 0.13033295f, 0.00124396f, 0.12291910f, 0.00662511f, 
    0.03934985f, -0.03703261f, 0.16577986f, 0.00599714f, 0.06660550f, -0.06456514f, 0.02930030f, -0.09048358f, 
    -0.03664792f, 0.05982390f, 0.01477249f, -0.08737544f, -0.02888998f, -0.21097346f, -0.02213155f, 0.02476754f, 
    0.06388123f, 0.14538227f, -0.00330597f, 0.13781157f, -0.13872072f, 0.09738008f, -0.03279933f, 0.21085081f, 
    -0.04954802f, 0.02087014f, -0.03274174f, 0.09238753f, -0.22272663f, 0.17250767f, 0.01101205f, -0.04347219f, 
    -0.02814315f, -0.00344083f, 0.08531062f, 0.04624711f, -0.00700539f, -0.10482730f, -0.12852719f, -0.01353619f, 
    0.22751845f, 0.11747925f, -0.07065277f, 0.07045776f, 0.06947358f, 0.15899462f, -0.01030561f, 0.03524508f, 
    -0.05148587f, 0.19052270f, 0.13722843f, -0.05940491f, 0.08445583f, -0.13974713f, -0.00709641f, -0.00223453f, 
    -0.01533572f, 0.06784295f, -0.31131989f, -0.10508219f, 0.08530726f, 0.09329705f, -0.01084940f, -0.05600294f, 
    -0.30741996f, 0.09642212f, -0.04566877f, 0.22928692f, 0.08170835f, 0.06627098f, 0.07201468f, -0.16231258f, 
    -0.00548642f, 0.18452941f, 0.07174235f, -0.04052689f, 0.00276913f, -0.21194176f, 0.08934056f, -0.21561167f, 
    0.02379974f, -0.00000537f, 0.31867716f, -0.06661855f, -0.26367262f, 0.03212192f, -0.03228030f, 0.07292109f, 
    0.01783233f, 0.07353501f, 0.20779255f, -0.02963511f, -0.12768836f, -0.11912911f, -0.04728706f, -0.07505567f, 
    -0.12460071f, -0.09205121f, 0.11168586f, -0.33219039f, -0.04679041f, -0.10747206f, 0.14289793f, 0.07453270f, 
    -0.03747239f, -0.02550225f, 0.01555272f, 0.13864639f, 0.08102535f, -0.08685247f, 0.10363929f, -0.12061268f, 
    0.21875297f, 0.13335466f, 0.05440909f, 0.06308847f, -0.03511541f, 0.05277666f, -0.13913220f, 0.07641076f, 
    0.12830424f, -0.08441940f, 0.13890859f, 0.01010324f, -0.10173836f, 0.19353801f, -0.11272391f, -0.09009369f, 
    0.12910517f, -0.07173593f, -0.13185777f, 0.01532057f, 0.14024527f, 0.03061160f, -0.08853052f, 0.04656122f, 
    -0.01595945f, 0.02277896f, -0.00065233f, 0.10418653f, 0.07384183f, 0.09737788f, 0.02507863f, 0.00511693f, 
    0.02873657f, -0.06330781f, 0.03727574f, -0.01472467f, -0.14318575f, -0.06484541f, 0.14953855f, 0.05857816f, 
    0.04282223f, -0.19365282f, -0.08299213f, -0.02920686f, 0.03767498f, -0.00560975f, -0.09846196f, 0.09687824f, 
    0.13301173f, 0.08844758f, -0.11411034f, -0.01232475f, -0.15240851f, 0.01656377f, -0.05279683f, -0.05652249f, 
    0.04525209f, -0.08881529f, -0.05301530f, 0.02650775f, -0.00170300f, 0.07307810f, -0.15892623f, -0.00159413f, 
    0.21699134f, 0.10903177f, 0.09070524f, 0.21784393f, -0.23187512f, 0.04307974f, 0.07365881f, 0.16194950f, 
    -0.04300740f, -0.00901944f, 0.00825449f, 0.04814767f, -0.05740615f, -0.02731203f, 0.02027779f, -0.06144066f, 
    -0.03288754f, -0.02912264f, 0.04683016f, 0.01684424f, 0.00372686f, -0.01424981f, 0.01763482f, -0.04094429f, 
    -0.06369618f, -0.03549262f, -0.02805312f, 0.02175794f, 0.00018966f, -0.04865965f, 0.03187821f, -0.00668223f, 
    -0.05045423f, -0.00849636f, 0.00759785f, 0.03469435f, -0.00178846f, 0.02712642f, 0.03010025f, 0.03056717f, 
    0.04893319f, -0.03405414f, -0.01649909f, -0.04742920f, -0.06327824f, 0.00958949f, 0.03693820f, -0.00855834f, 
    -0.03274468f, -0.00481278f, 0.01553226f, -0.03586931f, 0.02262585f, 0.03650495f, -0.03214468f, -0.01709569f, 
    0.03527503f, -0.04568459f, 0.03413856f, 0.04787701f, -0.01054998f, 0.01791352f, -0.05256944f, 0.05357834f, 
    0.03085610f, 0.04486860f, -0.05714341f, -0.00678724f, 0.02979574f, -0.01500809f, -0.03157574f, -0.03129633f, 
    -0.03104022f, -0.06285407f, -0.02047679f, -0.02932440f, -0.02015690f, 0.00587938f, -0.06753372f, -0.05645965f, 
    -0.04459054f, 0.03713820f, 0.01789626f, -0.01152514f, -0.01431805f, 0.04394513f, -0.05115787f, -0.05803832f, 
    -0.00552078f, -0.02106970f, -0.05616800f, -0.00979041f, -0.01483193f, -0.01970471f, 0.04240824f, -0.03266323f, 
    -0.00849707f, -0.05455239f, -0.00458004f, -0.04649941f, -0.06349348f, -0.04420025f, 0.03696905f, -0.05836082f, 
    0.02754055f, 0.00124537f, -0.04840734f, 0.03181031f, 0.03424206f, 0.03996117f, -0.00469410f, 0.04421259f, 
    -0.02748802f, 0.03579611f, 0.03505335f, 0.03766987f, -0.01970385f, 0.01840674f, -0.00539182f, 0.03144133f, 
    0.00719461f, -0.02261616f, -0.06544853f, 0.04360392f, -0.05091792f, 0.01598916f, 0.05173865f, -0.05295289f, 
    0.00000279f, 0.04082119f, -0.02276970f, 0.04851587f, 0.04101170f, -0.06199890f, -0.02980007f, -0.04154953f, 
    0.02605550f, -0.03713953f, -0.03864856f, -0.00384138f, 0.01225975f, -0.05548107f, -0.05342981f, -0.02143221f, 
    0.00447932f, 0.03507923f, -0.02727656f, -0.00521451f, 0.02692377f, 0.01804780f, -0.05058799f, -0.00509744f, 
    -0.06620503f, -0.04193896f, 0.04494036f, 0.03371734f, -0.04078428f, -0.04654334f, 0.01503694f, -0.03463712f, 
    -0.02064069f, -0.03811588f, 0.04186987f, -0.02158253f, -0.06205482f, -0.03734396f, 0.04831738f, -0.01757801f, 
    0.03830372f, -0.03113418f, -0.00642595f, 0.04087468f, 0.03554827f, -0.02014220f, -0.03559059f, 0.00665352f, 
    -0.02465746f, -0.03458592f, 0.03977361f, -0.02217993f, -0.03617435f, -0.04625458f, -0.01289888f, -0.06733166f, 
    -0.02580427f, -0.04683951f, -0.02504942f, 0.03218705f, 0.02548145f, -0.03262622f, -0.00387469f, 0.03909428f, 
    0.00112498f, -0.00513370f, -0.04480805f, 0.00665887f, -0.00901410f, 0.03785814f, 0.03746834f, -0.03599307f, 
    -0.05454592f, -0.04718005f, -0.02456200f, -0.03760581f, -0.06407258f, 0.04128068f, -0.01552134f, -0.06513103f, 
    0.03439161f, -0.01601383f, 0.04311993f, -0.01177380f, 0.02204956f, 0.04396991f, 0.02281037f, -0.00139095f, 
    -0.01816908f, -0.03186488f, 0.00681239f, 0.01402157f, -0.00110278f, -0.01119580f, -0.05153671f, 0.01355711f, 
    -0.04007735f, -0.02249308f, -0.00555235f, 0.00631377f, -0.01283092f, -0.03167466f, -0.03794385f, 0.04413833f, 
    0.01391528f, -0.05241463f, 0.00125152f, 0.00579266f, -0.00470533f, 0.03461064f, -0.04042152f, 0.04519351f, 
    -0.02452025f, 0.00965576f, -0.00751605f, -0.01877108f, -0.00379068f, -0.01958044f, 0.03982184f, -0.05068123f, 
    -0.02156487f, 0.04739080f, 0.02592175f, 0.02936784f, -0.06830680f, -0.01680748f, -0.05817211f, 0.00382721f, 
    -0.03637200f, 0.02564631f, -0.06035548f, 0.01213183f, -0.03282209f, -0.05148891f, -0.03486768f, -0.03170592f, 
    -0.02752271f, -0.04246021f, 0.03038387f, -0.04387735f, 0.03747377f, 0.04390829f, -0.05644031f, -0.02390820f, 
    0.03169065f, -0.04802366f, -0.05658977f, 0.04471147f, -0.05562771f, -0.05789984f, -0.03639143f, -0.03367189f, 
    -0.00307761f, 0.03857087f, 0.05378046f, -0.03357633f, -0.00006143f, -0.00304022f, -0.02643753f, -0.02450147f, 
    0.03998371f, -0.06344478f, -0.04788358f, 0.00250808f, 0.03455784f, -0.00752569f, 0.02140989f, -0.00964918f, 
    0.04345302f, 0.04825919f, 0.14341229f, 0.12564512f, 0.28643429f, -0.07016118f, 0.15057330f, 0.01673600f, 
    0.01560996f, -0.03450977f, 0.10176564f, 0.34932205f, -0.01270545f, -0.08692165f, 0.09242395f, 0.31563747f, 
    0.09389812f, -0.00383305f, -0.14124301f, -0.19421990f, -0.09635405f, 0.02585022f, 0.01274533f, 0.03694859f, 
    0.05121129f, 0.04398565f, -0.01094483f, 0.22249757f, 0.02970383f, -0.09548528f, -0.00301342f, 0.06736040f, 
    0.05349651f, 0.06406907f, 0.09362676f, 0.04803299f, 0.17805921f, -0.18636431f, 0.07152664f, -0.18016544f, 
    -0.08951154f, -0.11675448f, -0.16932395f, 0.05467154f, 0.00863225f, 0.18533540f, 0.24206799f, 0.12243800f, 
    -0.06417819f, 0.06055716f, 0.05791852f, -0.08798997f, -0.08885299f, -0.08728552f, -0.16083305f, -0.19446588f, 
    -0.17103179f, -0.10248946f, 0.16668688f, 0.02366708f, 0.10332777f, -0.07111844f, 0.00309932f, 0.04249933f, 
    0.26347765f, 0.14313656f, -0.01521371f, 0.10446962f, 0.10533967f, 0.18861790f, 0.06929767f, -0.01979005f, 
    0.08218943f, 0.08756842f, 0.03638510f, -0.17244270f, 0.04456162f, -0.08120970f, -0.08158541f, 0.09917550f, 
    0.10596210f, -0.23326229f, -0.24121051f, 0.02500854f, 0.09513941f, 0.01714765f, -0.13494164f, 0.14877000f, 
    -0.07745707f, -0.11328986f, -0.04592375f, 0.02712508f, 0.12594408f, -0.22800682f, 0.13668658f, -0.06685601f, 
    -0.18535121f, -0.02178638f, 0.02641460f, -0.06313111f, 0.15208305f, -0.00137124f, -0.05716445f, 0.02656096f, 
    0.09972254f, 0.08557901f, -0.04980869f, 0.16705137f, 0.12164234f, -0.37223908f, -0.25397179f, -0.01966704f, 
    -0.06137515f, 0.00930197f, -0.04092089f, 0.04113280f, 0.02588905f, 0.09444530f, 0.16482283f, 0.15136343f, 
    -0.05033512f, -0.00839999f, 0.00183958f, 0.04123457f, 0.03651906f, 0.04790455f, 0.02502928f, -0.43129602f, 
    -0.21658766f, -0.05270554f, -0.04490244f, 0.05583445f, 0.15769206f, -0.10535921f, -0.08699905f, -0.09909874f, 
    -0.12509140f, 0.09241627f, 0.07357919f, 0.03855693f, -0.01094273f, 0.10795617f, 0.00017490f, 0.11778210f, 
    -0.05682842f, -0.14443441f, -0.00351757f, 0.01314013f, 0.10587843f, -0.00477693f, 0.02320984f, -0.06592438f, 
    -0.01692042f, 0.08100411f, -0.21738565f, -0.26117730f, 0.08940617f, 0.02247096f, -0.08827475f, -0.09716874f, 
    0.11977002f, -0.10510503f, -0.30587265f, -0.36021861f, 0.30826080f, -0.17939159f, -0.23856324f, -0.20245938f, 
    -0.02791423f, -0.19829473f, 0.04911152f, 0.07885534f, -0.17848979f, -0.32923457f, 0.11391806f, 0.05832854f, 
    0.02822659f, 0.02803418f, -0.06597566f, 0.19119030f, -0.11792505f, 0.02510669f, 0.26704574f, -0.06546286f, 
    -0.11624535f, -0.09512090f, 0.02679407f, 0.03537362f, 0.07224514f, -0.14598802f, -0.02460762f, 0.24463423f, 
    -0.02820219f, -0.03788289f, 0.02569265f, 0.14551531f, -0.07596321f, -0.07822426f, 0.05997072f, 0.08087678f, 
    0.14353710f, -0.05360156f, -0.07592122f, -0.04922949f, -0.08768699f, -0.21581307f, 0.10512175f, 0.03352860f, 
    0.04293095f, 0.12050740f, 0.09841007f, -0.06421719f, 0.03181870f, -0.00775416f, -0.17005681f, 0.20789309f, 
    -0.23999660f, -0.33586672f, 0.09653537f, 0.05129765f, 0.30927989f, 0.13928790f, -0.10869750f, -0.07849330f, 
    -0.18967870f, -0.07813226f, -0.01484019f, 0.03997287f, -0.07478765f, -0.09128869f, -0.13236628f, -0.20624436f, 
    0.12826100f, 0.03985399f, -0.03974235f, 0.19101007f, 0.13983801f, 0.16321170f, 0.13258033f, 0.08734745f, 
    0.13100600f, -0.01337670f, 0.03325209f, -0.01108642f, 0.02571527f, -0.09903919f, -0.00703698f, 0.03653031f, 
    0.01790944f, -0.07801058f, 0.00462285f, 0.04197922f, -0.06136739f, -0.22897984f, -0.19059226f, -0.02907244f, 
    0.08545198f, -0.11247891f, 0.04850791f, 0.00767892f, -0.03224894f, 0.18151146f, 0.13376968f, 0.13647500f, 
    -0.01698583f, 0.02984682f, 0.12048732f, -0.03111663f, 0.09304567f, 0.12383174f, 0.18625705f, -0.08182301f, 
    -0.01484139f, -0.07886042f, -0.10437221f, 0.08411027f, -0.02779118f, 0.00600571f, -0.04397510f, -0.24096008f, 
    -0.03929226f, -0.25283837f, 0.04474251f, 0.11130127f, -0.00608027f, -0.07286946f, -0.02340170f, -0.06481595f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.03306771f, 0.20513947f, 0.04137792f, 0.21564966f, 0.01236629f, -0.08349258f, 0.01424756f, -0.11895079f, 
    -0.01428298f, 0.02024451f, 0.04388497f, -0.00555393f, -0.00173720f, 0.03693851f, 0.13851425f, -0.03379710f, 
    -0.01498372f, 0.05089479f, -0.03392245f, 0.10123759f, 0.12173586f, 0.10620240f, -0.05918930f, 0.08798192f, 
    0.02156412f, 0.02210847f, 0.05326341f, -0.04103820f, -0.04402297f, 0.05670282f, 0.03826574f, 0.12828839f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.11251821f, -0.00820340f, -0.14981844f, -0.14867765f, -0.09109721f, 0.12400915f, 0.14296244f, -0.10515672f, 
    0.15375800f, -0.00461693f, -0.17436296f, 0.00391414f, 0.07100488f, -0.01340226f, 0.08199395f, -0.01775935f, 
    -0.02163870f, 0.11605621f, -0.14542289f, -0.13854714f, 0.00730797f, -0.03484659f, -0.05999903f, 0.03524897f, 
    0.15355602f, 0.01279098f, -0.14866509f, 0.00738720f, 0.13956150f, -0.11224218f, 0.15662500f, -0.06008061f, 
    -0.03406947f, 0.63916492f, -0.38092175f, 0.20573980f, 0.11166021f, 0.09590370f, 0.16778576f, 0.46694219f, 
    -0.10052457f, 0.06463329f, -0.22970542f, -0.06049804f, -0.17378661f, -0.18575817f, 0.31030294f, -0.54777807f, 
    0.01193245f, -0.10005599f, -0.06912325f, 0.00324564f, 0.19934812f, -0.35162488f, -0.11656702f, 0.25672153f, 
    -0.10193272f, 0.17104051f, -0.17626271f, 0.14654183f, 0.03524771f, -0.00201756f, -0.13775465f, -0.01032703f, 
    0.17099606f, 0.00131197f, 0.06484522f, -0.16225737f, -0.16991906f, -0.01915482f, -0.12523049f, -0.09166712f, 
    0.01450161f, -0.00972541f, 0.12571637f, -0.03263677f, -0.08646514f, -0.01780133f, -0.04250594f, 0.13155155f, 
    -0.09276281f, -0.11481895f, 0.07638492f, -0.14645779f, 0.07053638f, -0.16210672f, 0.11897604f, 0.13362382f, 
    -0.16662295f, -0.11506199f, 0.03118544f, 0.14813615f, -0.07530192f, -0.14181477f, 0.08872805f, -0.06494564f, 
    -0.01355661f, -0.10063665f, -0.32888487f, -0.18264394f, 0.13690811f, -0.13580155f, 0.12091177f, -0.46411622f, 
    0.14334461f, 0.12168901f, -0.03777176f, -0.08163098f, 0.39877087f, -0.10428685f, 0.01539267f, -0.02989155f, 
    -0.04528978f, 0.14905369f, 0.11546986f, 0.42973167f, 0.02848213f, 0.18018162f, 0.16898960f, 0.25726867f, 
    -0.38534474f, 0.29070184f, 0.00366700f, -0.15041438f, 0.05752741f, 0.28764236f, -0.09677915f, 0.01326963f, 
    -0.10284557f, 0.02791394f, -0.52828872f, 0.20952013f, 0.03291408f, 0.08665390f, 0.25062713f, 0.49528754f, 
    0.07328730f, 0.12255799f, 0.20968160f, -0.12947431f, 0.32198182f, 0.19770946f, -0.04639035f, 0.04536949f, 
    0.05626655f, 0.10056507f, 0.00379886f, 0.10104705f, -0.24448094f, 0.18814515f, 0.16100261f, 0.32008487f, 
    -0.15088195f, 0.24827930f, -0.34473565f, 0.15575205f, 0.15690435f, 0.31103075f, 0.11697067f, 0.09783379f, 
    -0.16554734f, -0.13624649f, 0.09190602f, 0.37592706f, -0.02144705f, 0.05113257f, -0.22217563f, -0.50686789f, 
    -0.03810377f, 0.01045869f, 0.20251091f, -0.04718593f, -0.49573442f, 0.14380546f, 0.34857634f, -0.29754069f, 
    0.04718705f, 0.07467364f, -0.09183062f, -0.20109798f, 0.03567987f, 0.28546569f, 0.10580922f, -0.33116794f, 
    0.37552038f, -0.05035872f, 0.43712208f, -0.03028629f, 0.01387978f, 0.14163709f, -0.07869940f, -0.14527151f, 
    -0.09429070f, -0.02853027f, 0.41993448f, 0.08863797f, -0.03627411f, 0.12115694f, 0.15960254f, 0.51582319f, 
    0.03083470f, 0.04233212f, 0.42634565f, -0.06627318f, -0.09071988f, -0.01567580f, 0.02989020f, -0.01716177f, 
    -0.16947041f, 0.13810024f, 0.07011949f, -0.27944994f, 0.07849878f, 0.08475605f, -0.13179922f, -0.52830988f, 
    0.43819758f, 0.41206050f, 0.14754809f, 0.13122813f, -0.04711389f, 0.08672765f, -0.06644827f, -0.20155066f, 
    -0.13923594f, 0.28993961f, 0.15871440f, 0.30721495f, -0.07752953f, -0.12942642f, -0.19794606f, -0.30278260f, 
    0.14098114f, 0.01891823f, 0.01293987f, -0.09200973f, -0.23963362f, -0.28743759f, 0.13699199f, -0.37945339f, 
    -0.09246361f, -0.17979757f, 0.01873779f, 0.09117780f, 0.28536212f, -0.09972139f, -0.16354498f, -0.06209933f, 
    -0.11127225f, -0.03184666f, 0.28697792f, 0.00450969f, -0.13535699f, -0.21667252f, 0.10116211f, 0.40547505f, 
    0.00347802f, -0.18159816f, 0.15146622f, 0.36172485f, -0.03519625f, -0.01293751f, -0.13263716f, -0.24299677f, 
    0.16528845f, -0.07328285f, -0.12047324f, 0.11774958f, -0.49899149f, 0.13863885f, -0.15831320f, 0.02247912f, 
    -0.06397602f, -0.13960381f, -0.16878153f, -0.01146475f, -0.19247481f, -0.29417729f, -0.08042460f, 0.08866300f, 
    0.28856546f, 0.30335966f, 0.23801757f, -0.03613830f, 0.00405172f, 0.31491598f, 0.03143975f, 0.20473734f, 
    0.11459429f, 0.29448020f, -0.13073453f, 0.21699892f, -0.11599272f, 0.01367232f, -0.22216120f, -0.45225045f, 
    -0.08931380f, -0.15634401f, 0.07300196f, -0.09861211f, 0.18514295f, -0.44664890f, 0.32305872f, -0.31138891f, 
    0.17268592f, -0.17044176f, -0.13460961f, -0.18998818f, 0.37698364f, 0.38764358f, 0.04942317f, 0.09899035f, 
    -0.01712266f, -0.42252192f, 0.00924455f, 0.09788384f, 0.10554231f, -0.24987663f, -0.16565031f, 0.14393090f, 
    -0.01049766f, -0.08772936f, 0.62288982f, 0.19208165f, 0.11408313f, 0.12471028f, -0.31030530f, -0.47383639f, 
    0.13064346f, -0.03094998f, -0.29276049f, -0.04288527f, -0.46675670f, -0.31152442f, 0.19886900f, 0.28799248f, 
    -0.11763126f, 0.08737039f, -0.06137906f, 0.34338152f, -0.02340983f, 0.19749610f, -0.08666940f, -0.35320422f, 
    0.58806860f, -0.03039329f, 0.19045490f, -0.06084079f, -0.08335406f, -0.09989941f, -0.12164678f, 0.11412530f, 
    -0.01590835f, -0.17179888f, -0.10700201f, -0.04516915f, -0.00937893f, 0.01240363f, 0.05347678f, -0.03552937f, 
    -0.14935274f, -0.10800353f, -0.06934933f, 0.07534900f, 0.02302176f, 0.06779562f, 0.02469941f, -0.14651920f, 
    -0.02539860f, -0.03127066f, 0.10405675f, -0.05875286f, 0.00836196f, -0.19376831f, 0.02369426f, -0.04466780f, 
    0.06165913f, -0.01497564f, -0.16623239f, -0.07622911f, 0.06859203f, -0.03859235f, 0.00659672f, 0.05760611f, 
    0.11230814f, -0.04923534f, 0.06265809f, 0.05274689f, 0.05066496f, 0.12488849f, 0.02366150f, -0.23467813f, 
    0.02383544f, -0.11710533f, 0.20455484f, -0.16608027f, 0.54433018f, 0.35742402f, -0.48615476f, -0.12276725f, 
    0.08079848f, -0.06598011f, -0.02469836f, 0.07002329f, 0.18750200f, 0.32715532f, 0.03459953f, 0.52897298f, 
    -0.57195038f, -0.27097836f, -0.08870213f, 0.07577590f, 0.13439852f, 0.18803307f, 0.08232641f, 0.22368217f, 
    0.14310601f, 0.45297235f, 0.67208725f, -0.22218376f, -0.02462414f, 0.15137480f, 0.33037668f, -0.20600240f, 
    -0.07792130f, -0.14236461f, -0.27381882f, 0.13936767f, -0.40738869f, -0.20056745f, -0.25175473f, -0.03900360f, 
    -0.03706801f, 0.04427023f, -0.12869181f, 0.31135035f, 0.19340350f, -0.07167128f, -0.07261363f, -0.21774712f, 
    0.13848865f, -0.18840073f, -0.22614916f, 0.16986272f, -0.06320795f, 0.17907679f, 0.12109395f, -0.20450994f, 
    -0.03138948f, -0.21524227f, 0.30653954f, -0.17962499f, -0.15968944f, -0.09376107f, 0.08294546f, -0.35807103f, 
    -0.08894890f, -0.11129590f, -0.21277304f, -0.12858438f, 0.04023456f, -0.37874511f, 0.40845612f, 0.19100730f, 
    0.08480138f, -0.03156181f, 0.11634813f, -0.08423577f, 0.37153861f, 0.44461653f, -0.16146885f, 0.18322642f, 
    0.31972793f, -0.04858062f, 0.28732964f, 0.02491578f, 0.01402122f, -0.30545291f, 0.09929223f, -0.10962710f, 
    0.10524734f, 0.22910663f, -0.40861198f, -0.14790060f, 0.08117525f, 0.14087620f, 0.39430171f, 0.09384690f, 
    0.11082688f, 0.00503669f, 0.18138473f, -0.16887981f, 0.49756372f, 0.14210628f, 0.13945855f, -0.02688621f, 
    0.04812437f, 0.03878888f, 0.01187513f, 0.15519156f, 0.17364788f, 0.33701700f, 0.08694416f, -0.17374939f, 
    0.17948307f, 0.31638384f, -0.34971014f, -0.03336608f, -0.09796496f, 0.14152080f, 0.02805102f, -0.03523434f, 
    0.11998558f, -0.18388622f, 0.17906365f, 0.32951161f, -0.12373935f, 0.09211460f, -0.07212002f, 0.13941133f, 
    -0.06040234f, 0.06569914f, 0.29791135f, -0.15197094f, -0.23310360f, 0.25931296f, 0.14330564f, -0.22731328f, 
    -0.13078941f, 0.03468382f, 0.03202657f, -0.20093451f, -0.14938632f, -0.31160545f, 0.11439453f, -0.33662504f, 
    0.19632591f, 0.42307267f, 0.18006212f, -0.18643871f, 0.14393434f, 0.16349673f, -0.11083507f, 0.15995646f, 
    0.11294234f, 0.06820025f, -0.12736697f, -0.14573738f, 0.02499127f, -0.01827935f, 0.21602714f, 0.18444446f, 
    0.14491670f, -0.12887532f, 0.31481877f, -0.06536622f, -0.08053935f, 0.23684837f, 0.50695491f, 0.08771618f, 
    0.03366591f, -0.17803039f, -0.13035387f, 0.03630392f, -0.12048292f, -0.02139697f, -0.17738366f, -0.20056565f, 
    0.19238865f, 0.49363366f, 0.13017797f, -0.12272673f, 0.11720667f, 0.45714155f, -0.03387973f, -0.19753945f, 
    0.12487477f, 0.06608520f, -0.20026414f, -0.01099738f, -0.01660556f, -0.06939743f, 0.32487431f, 0.65643877f, 
    0.13299800f, 0.12571652f, 0.11164130f, -0.04811637f, 0.35790488f, 0.36376020f, -0.16198845f, 0.25984719f, 
    -0.05340377f, 0.14599362f, 0.17398424f, 0.27637240f, -0.17640094f, 0.27032292f, 0.14343126f, 0.01401468f, 
    -0.14296325f, 0.22705673f, -0.18963465f, -0.02330552f, -0.14432390f, 0.45474437f, 0.03182813f, -0.15066731f, 
    0.12071704f, 0.17888030f, -0.05371043f, 0.25016564f, -0.09818856f, -0.09706815f, 0.20825578f, -0.17382368f, 
    -0.14713120f, -0.15475929f, 0.27110344f, 0.00570412f, 0.03276271f, 0.37120128f, 0.27395108f, -0.35836414f, 
    0.16982944f, -0.00207181f, 0.00019062f, 0.15664917f, 0.14473584f, -0.47128659f, -0.06121463f, 0.03876756f, 
    -0.50654453f, 0.21610126f, 0.26205325f, -0.00577045f, -0.14914085f, -0.20704126f, -0.02938071f, -0.14116623f, 
    -0.04134148f, 0.24583295f, 0.36607495f, 0.35193595f, -0.09559914f, -0.15514193f, -0.13777329f, -0.37703401f, 
    -0.03017887f, 0.15294036f, 0.07797655f, 0.10266502f, -0.29310217f, 0.08910570f, -0.25073683f, -0.31412992f, 
    0.05412111f, -0.00768242f, 0.04552647f, 0.00464060f, 0.00033002f, -0.21326910f, -0.08910310f, -0.04991511f, 
    -0.13331407f, 0.16628349f, 0.24695128f, 0.11350751f, 0.03457113f, 0.04094069f, 0.06541666f, 0.36311439f, 
    -0.05395240f, -0.13391809f, 0.39831454f, -0.22994421f, 0.02850986f, 0.12753068f, 0.27054429f, 0.26973200f, 
    0.10238408f, 0.08726266f, -0.00669558f, 0.04344558f, 0.45553917f, 0.11149096f, -0.04441603f, 0.24034680f, 
    -0.01180065f, -0.09600210f, -0.05577782f, 0.21666403f, 0.20487870f, 0.35456076f, -0.04353938f, 0.02961463f, 
    0.20078787f, -0.16018499f, 0.14601168f, 0.06090733f, -0.11018737f, 0.04554715f, 0.00000392f, -0.27383068f, 
    -0.01777411f, -0.13110019f, -0.16356713f, -0.11082631f, -0.16321026f, 0.06132689f, 0.03818785f, -0.15409574f, 
    -0.14236765f, -0.02845424f, -0.10221561f, 0.04182341f, 0.00287260f, 0.07899415f, -0.04976215f, -0.08183911f, 
    -0.02565679f, 0.17668721f, -0.13072529f, -0.05227967f, -0.13654231f, -0.03745788f, 0.15609223f, -0.05324963f, 
    -0.14246450f, 0.06640209f, 0.12697600f, -0.00551473f, -0.08834323f, -0.05945700f, 0.02874154f, -0.01947604f, 
    -0.11380637f, -0.17104371f, 0.31483969f, 0.21936503f, 0.11093916f, 0.12157585f, -0.18163706f, -0.54550910f, 
    -0.14011589f, -0.13837089f, 0.25077251f, 0.00041906f, 0.19582260f, 0.10469427f, -0.51650006f, -0.01389440f, 
    -0.04869557f, 0.15722865f, 0.03869522f, 0.47664374f, -0.19034439f, 0.31277043f, -0.05317074f, 0.25120687f, 
    -0.32157665f, 0.04628821f, -0.21196303f, -0.14931750f, 0.01475106f, 0.41972911f, -0.10260274f, 0.31317052f, 
    0.08967660f, 0.59020209f, -0.19076656f, 0.14673313f, 0.04848962f, 0.07309770f, 0.16107890f, 0.37240848f, 
    -0.06259267f, 0.06890887f, -0.24236646f, -0.02548658f, -0.19899145f, -0.17799391f, 0.09333662f, -0.10488981f, 
    0.06253000f, 0.11757959f, 0.07490089f, -0.05285151f, 0.24977767f, -0.33141038f, -0.15127133f, 0.38081729f, 
    -0.18584611f, -0.24471945f, -0.23503792f, 0.04727306f, 0.08980954f, -0.09819411f, -0.01560711f, 0.33821464f, 
    0.08610000f, -0.24627411f, -0.24571346f, 0.02140838f, 0.16780756f, 0.06141071f, 0.00439860f, 0.45298249f, 
    -0.06048258f, 0.06073686f, 0.18039735f, -0.10513997f, 0.53031695f, 0.00343049f, 0.51045418f, 0.16717225f, 
    0.00331043f, -0.14725076f, -0.02409009f, 0.01245493f, 0.21578711f, 0.42129877f, 0.04457988f, -0.07946741f, 
    0.17009066f, -0.01267386f, 0.11763379f, -0.10047643f, -0.04788580f, 0.35232070f, -0.13063364f, 0.01900269f, 
    0.04864507f, 0.02351968f, 0.08121777f, -0.14955461f, -0.01755711f, 0.13188042f, -0.03269814f, -0.02600241f, 
    0.02733371f, 0.01321500f, -0.00707470f, -0.16114907f, 0.16359353f, -0.14643513f, -0.12113415f, -0.15822282f, 
    -0.07157656f, -0.12125637f, -0.08750885f, -0.14324938f, -0.02036939f, -0.07016492f, 0.10627747f, 0.14200473f, 
    0.09586775f, 0.08561156f, -0.02119430f, -0.07407353f, 0.01306192f, -0.09441794f, -0.08101907f, -0.01613605f, 
    -0.04166706f, 0.29946929f, 0.04343738f, -0.11185130f, 0.00179926f, 0.14612895f, 0.26567724f, 0.04681292f, 
    -0.07616494f, -0.08058016f, -0.47659677f, -0.17925707f, 0.05441190f, -0.17878486f, 0.26754904f, 0.14854781f, 
    -0.01152009f, 0.00840800f, -0.06535791f, 0.23677978f, 0.21363884f, 0.01440307f, -0.08506647f, 0.29436707f, 
    -0.02317567f, -0.35588229f, 0.02070769f, -0.10230276f, 0.12446442f, -0.05938703f, 0.06406802f, 0.07360350f, 
    -0.03564566f, 0.05884413f, -0.26576200f, 0.12787037f, 0.01470149f, 0.05330215f, -0.07225681f, 0.15414278f, 
    0.04868872f, -0.17226821f, -0.10591954f, 0.08577219f, 0.18489625f, -0.39050636f, 0.35449749f, -0.24818783f, 
    -0.13286605f, 0.17382200f, -0.04947553f, -0.13337713f, 0.31605199f, -0.02967130f, 0.12002606f, 0.28259319f, 
    -0.36850929f, -0.09109878f, 0.10582667f, -0.00953382f, 0.02042717f, -0.36490214f, 0.09479968f, 0.23785207f, 
    0.04790167f, 0.11874764f, 0.00651908f, -0.18519036f, -0.00960882f, -0.07551482f, -0.19150104f, -0.16685714f, 
    0.17776974f, -0.02410482f, -0.18320823f, 0.14770640f, 0.14316987f, -0.16309561f, 0.01706402f, -0.16692737f, 
    -0.02368638f, 0.16120178f, 0.06140412f, 0.10859246f, -0.16444907f, -0.03265833f, -0.07826971f, 0.05983271f, 
    -0.18695970f, -0.10385960f, 0.08919496f, 0.16837929f, 0.00391921f, -0.01967232f, 0.16479412f, -0.02289336f, 
    0.00768097f, -0.10632582f, 0.08878897f, 0.19214490f, 0.06377605f, -0.02230548f, 0.04448156f, 0.15073195f, 
    0.11163666f, 0.15267965f, 0.39711520f, -0.11255038f, 0.38171306f, 0.25157103f, -0.33263054f, 0.14222276f, 
    -0.13890280f, 0.06697576f, -0.14964198f, 0.19048908f, -0.24950060f, 0.48393238f, -0.12728332f, -0.12409880f, 
    -0.18928777f, 0.00315351f, 0.01941669f, 0.12520385f, 0.01405878f, 0.43450755f, -0.04804260f, 0.01264073f, 
    0.05027820f, 0.26672038f, 0.53757501f, 0.10116696f, -0.07559697f, -0.08005830f, 0.19405091f, -0.27993926f, 
    0.09518862f, 0.18081754f, -0.26626265f, -0.06006745f, -0.51751989f, -0.17542404f, 0.22564654f, -0.02376782f, 
    0.08013136f, -0.09105111f, -0.15543418f, 0.25342831f, 0.32718325f, -0.37255698f, 0.02445901f, -0.05028341f, 
    0.19653164f, 0.12358508f, 0.01599154f, -0.15718623f, -0.06628294f, -0.22618055f, 0.08095687f, 0.14685096f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.03231064f, 0.11129510f, -0.14934662f, 0.01904855f, 0.11933026f, 0.15162589f, 0.12571281f, 0.06169242f, 
    -0.00779582f, 0.05351915f, -0.03338145f, -0.19035602f, 0.11705485f, 0.16058910f, 0.02972664f, 0.28884584f, 
    -0.06888264f, 0.21169290f, 0.16893052f, 0.48544478f, 0.07388221f, 0.18154237f, 0.11683837f, 0.24202962f, 
    0.18194792f, 0.12235837f, -0.03975282f, 0.17164162f, 0.07211622f, 0.11366703f, -0.05851518f, 0.04154126f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.06220468f, 0.09922600f, 0.09722885f, -0.04965070f, -0.08624022f, 0.02698953f, 0.08972481f, -0.10437106f, 
    0.06126330f, -0.26743582f, -0.14703244f, -0.13580585f, 0.05533970f, -0.13976316f, 0.04849271f, -0.16979785f, 
    -0.15344039f, -0.02944222f, 0.08456229f, -0.05592004f, -0.10253435f, 0.14274399f, -0.14165640f, -0.13120727f, 
    0.04689033f, -0.09377287f, 0.09175415f, -0.13031925f, 0.05908109f, -0.15033691f, 0.05475130f, -0.13406195f, 
    0.07713851f, 0.09003979f, -0.13963270f, -0.14842090f, -0.07582387f, -0.03397647f, -0.01193072f, -0.03811657f, 
    0.04666827f, -0.17419906f, 0.02884145f, 0.05238444f, -0.00422082f, 0.02352043f, -0.10230532f, -0.16401961f, 
    -0.08376707f, 0.08203872f, 0.05822960f, -0.12597212f, -0.14893281f, -0.00926171f, -0.17578074f, -0.15986459f, 
    -0.07606284f, -0.07932577f, -0.12960604f, 0.04832985f, 0.08903258f, -0.01341839f, 0.00384365f, 0.06545271f, 
    -0.02629308f, 0.24009974f, -0.16598412f, -0.46980259f, 0.23770407f, 0.27096745f, 0.43367603f, 0.00505134f, 
    0.46994379f, -0.10473644f, -0.24391331f, -0.04056495f, -0.07109615f, -0.07293476f, -0.80277884f, -0.12024144f, 
    0.61605620f, 0.17541331f, 0.04713949f, 0.13728641f, 0.40747330f, -0.34066638f, -0.10064353f, 0.04326281f, 
    0.08837306f, -0.11357852f, 0.08401273f, -0.28331625f, -0.03043683f, 0.15047739f, 0.17470714f, -0.00046269f, 
    -0.11374240f, -0.12999779f, -0.08572678f, -0.13752335f, 0.11148388f, 0.06140173f, 0.08469275f, -0.15608871f, 
    0.08520193f, -0.18205076f, 0.14275698f, -0.04047849f, -0.19545002f, -0.12817492f, 0.15918079f, 0.13069454f, 
    -0.14149658f, -0.02580365f, -0.15250152f, 0.12722367f, 0.00632648f, -0.14095660f, -0.16021413f, 0.00510439f, 
    -0.15477227f, -0.03673469f, 0.17416097f, -0.13368168f, -0.09844881f, -0.11236324f, -0.09101430f, -0.17092837f, 
    -0.16887829f, 0.00050625f, 0.03610253f, 0.07645817f, 0.25296265f, 0.20737258f, 0.45847663f, -0.23827693f, 
    0.00306231f, -0.37412977f, -0.16492936f, -0.11796062f, -0.10075235f, 0.49851573f, -0.35621771f, 0.28103134f, 
    0.40693539f, 0.71591568f, 0.40655810f, 0.12929118f, -0.09792994f, 0.28630367f, 0.15660101f, -0.00605745f, 
    -0.26004112f, 0.20653260f, -0.06617627f, -0.18261182f, -0.44983456f, -0.05321830f, 0.35401955f, -0.09809434f, 
    0.13968140f, -0.12462641f, 0.10353586f, -0.06512971f, 0.15205413f, -0.01918093f, -0.18896089f, 0.05616783f, 
    -0.13517189f, -0.00203388f, 0.01334133f, 0.09057432f, -0.07479692f, 0.03566669f, 0.01372229f, -0.16697040f, 
    0.11743050f, -0.01690582f, 0.16005656f, -0.03919891f, 0.04902155f, 0.14283678f, 0.16876549f, -0.05184291f, 
    -0.12131655f, -0.15187618f, 0.01846694f, -0.07899956f, -0.06586646f, 0.15883557f, -0.04807829f, 0.06421937f, 
    0.00413216f, 0.09234063f, -0.11236779f, 0.11783700f, -0.10281708f, -0.15904751f, -0.04574642f, 0.05222271f, 
    -0.09124599f, 0.02736746f, -0.10912693f, -0.10694162f, 0.04099414f, 0.02686556f, 0.10761476f, 0.08129141f, 
    0.04134975f, -0.10068912f, -0.06636357f, -0.09752707f, -0.03074651f, -0.05354364f, 0.07382119f, 0.04457686f, 
    -0.12192365f, -0.04815588f, 0.11166397f, 0.07984150f, 0.01749436f, 0.14531185f, -0.15453407f, -0.08861040f, 
    0.11471204f, -0.02247767f, 0.00076983f, -0.18209526f, -0.00260464f, -0.03466383f, -0.09531748f, 0.03148277f, 
    -0.05684007f, -0.04193576f, 0.00089081f, -0.15018998f, -0.03831427f, 0.08110187f, 0.07700948f, -0.12001766f, 
    -0.16285855f, -0.13329943f, 0.02698720f, -0.12936306f, 0.07841039f, -0.10746267f, 0.17459927f, -0.08887879f, 
    -0.05148573f, 0.08060151f, 0.12910905f, -0.16291264f, -0.11196170f, 0.15812895f, -0.10272407f, -0.02439101f, 
    0.16794349f, 0.04795056f, -0.11233520f, -0.32242143f, 0.16389160f, -0.49943507f, 0.47744846f, -0.35300657f, 
    -0.42831534f, -0.33163422f, -0.24830168f, -0.16899270f, 0.03490515f, 0.26539814f, 0.19581209f, 0.04075465f, 
    -0.06089200f, -0.03769293f, 0.37674457f, -0.20004702f, -0.48304531f, 0.27005589f, -0.06346778f, -0.16817752f, 
    0.20612481f, 0.24129006f, 0.07007772f, 0.10699431f, -0.08319600f, -0.13509504f, 0.08003623f, -0.00808494f, 
    -0.13154621f, -0.26662949f, -0.09409383f, -0.36271375f, -0.18721126f, 0.62991446f, 0.33840370f, 0.02492529f, 
    0.15409960f, 0.24030340f, 0.22799504f, 0.09309158f, -0.28930327f, -0.21833502f, 0.62194794f, 0.14267941f, 
    0.13621363f, 0.29429346f, -0.14985877f, -0.12643474f, -0.12291931f, 0.33138841f, -0.05723951f, -0.04662656f, 
    -0.37475011f, 0.32822400f, -0.05235687f, -0.02703694f, -0.12554014f, 0.08275560f, 0.04171081f, 0.10434226f, 
    -0.12016711f, -0.25793585f, 0.11742790f, -0.04268766f, -0.17916977f, 0.84113097f, 0.42031190f, 0.30179110f, 
    0.20305848f, 0.48343623f, 0.51253605f, -0.08430374f, 0.10475571f, -0.01708107f, 0.25905934f, -0.19232537f, 
    0.56432784f, -0.25959188f, -0.23921838f, -0.03423903f, 0.38992733f, -0.09221919f, -0.07737617f, 0.24079071f, 
    -0.32508734f, 0.02750897f, -0.08623974f, -0.18199483f, 0.00827452f, 0.06153552f, 0.16897257f, 0.04914941f, 
    -0.11072453f, 0.08415321f, -0.00256259f, -0.51913321f, 0.24740697f, -0.34088734f, 0.35657927f, -0.57193530f, 
    -0.12845375f, -0.44383964f, -0.08385380f, 0.08389181f, 0.01151820f, -0.57050896f, -0.09968676f, 0.10880233f, 
    0.24143893f, 0.05085818f, 0.37157106f, -0.21427916f, -0.55961812f, 0.33016860f, 0.15800712f, -0.27237478f, 
    -0.07750588f, 0.08120266f, -0.02596668f, -0.08952914f, -0.13832115f, -0.01601910f, 0.31777394f, -0.25675222f, 
    0.12269801f, 0.61108255f, 0.01642271f, 0.29432654f, 0.22096288f, -0.08831092f, -0.34959924f, -0.04576461f, 
    0.20193833f, -0.06422983f, -0.40283641f, 0.07529746f, 0.12517639f, 0.31352499f, -0.54320234f, 0.16015454f, 
    0.00382707f, 0.17435157f, 0.14150348f, 0.45937964f, 0.11859708f, -0.23666821f, -0.11577848f, 0.07144345f, 
    0.38944662f, 0.00469051f, -0.18331701f, 0.28556153f, -0.01184122f, -0.06788266f, -0.13247521f, 0.20151809f, 
    0.00854902f, 0.02995591f, -0.17253813f, 0.00097094f, -0.10361677f, -0.40255770f, -0.09097946f, -0.05042526f, 
    -0.28847814f, 0.27081838f, 0.06291971f, -0.04960486f, 0.42291823f, 0.42586058f, 0.27874759f, -0.12314762f, 
    -0.83769453f, -0.53355575f, -0.00521101f, 0.06151804f, 0.01059132f, 0.55079663f, -0.04997602f, 0.18577471f, 
    0.19725725f, -0.10418501f, -0.09862785f, 0.29985231f, 0.13862558f, 0.07886115f, -0.11490191f, 0.08638021f, 
    -0.15241514f, -0.07469737f, 0.14729065f, 0.05542077f, 0.01143368f, -0.13049084f, 0.09452810f, -0.10264456f, 
    -0.10434626f, 0.12618178f, -0.12100355f, 0.01121243f, -0.01768384f, -0.09092572f, 0.01393195f, -0.12528609f, 
    0.13005911f, -0.10684434f, -0.06684843f, -0.13430515f, 0.00395598f, -0.02473831f, -0.16701812f, -0.07963083f, 
    -0.00537746f, 0.16115974f, -0.08558396f, -0.12385971f, -0.03636866f, -0.11533268f, 0.00484861f, -0.07803574f, 
    -0.16138563f, 0.00774289f, 0.06994242f, 0.40207496f, 0.28239629f, 0.21509872f, -0.12183721f, -0.14878984f, 
    0.30497801f, -0.02563757f, 0.25941876f, 0.06909498f, -0.30451417f, -0.59589320f, 0.14290415f, -0.00185594f, 
    0.06206414f, 0.28069687f, 0.12081512f, -0.19438708f, -0.14404759f, -0.18646652f, -0.00844005f, 0.22890449f, 
    -0.12770234f, 0.29822382f, -0.02006627f, 0.07970627f, 0.13065371f, 0.11193719f, 0.24095547f, -0.21037604f, 
    0.05955366f, -0.02033632f, -0.05633834f, 0.15866053f, -0.13001715f, 0.03564588f, -0.18936527f, -0.06386325f, 
    0.05564595f, 0.00215522f, -0.00064571f, 0.00574221f, -0.13164358f, -0.13671175f, -0.10149157f, -0.11799804f, 
    0.02644981f, -0.13744019f, -0.02959026f, 0.11242527f, -0.13890827f, -0.02006162f, -0.02341514f, 0.01178005f, 
    -0.03706731f, 0.04949594f, 0.16146748f, 0.06601376f, 0.02347689f, -0.04263172f, -0.08218969f, 0.00523380f, 
    0.09280360f, -0.38057131f, -0.12493584f, 0.10772799f, 0.14133181f, -0.05076699f, -0.15256751f, -0.13902284f, 
    0.47345456f, -0.16418415f, 0.52014416f, 0.06006126f, 0.31168672f, 0.51499742f, -0.09145615f, 0.13548307f, 
    0.19622411f, -0.25977057f, 0.13808988f, -0.03052523f, -0.00484719f, 0.46952832f, -0.10398723f, 0.44474334f, 
    -0.06306942f, 0.06734718f, -0.11841304f, 0.09921013f, -0.33363760f, 0.00398473f, 0.37170842f, 0.14983584f, 
    -0.15266481f, 0.23170379f, 0.16280261f, 0.54080540f, 0.24802572f, -0.36881414f, -0.10630123f, 0.12692431f, 
    -0.30556694f, 0.01122109f, -0.30729654f, 0.00541288f, 0.54162693f, -0.59527332f, -0.24270928f, 0.31363195f, 
    -0.26714697f, 0.06471708f, 0.20991383f, 0.10039977f, -0.10662043f, 0.06660096f, 0.00043243f, 0.37062025f, 
    0.01789310f, 0.26080790f, -0.17165224f, 0.04840091f, 0.29397085f, 0.06710967f, 0.18863943f, -0.16743794f, 
    0.00543587f, 0.25595328f, 0.10861896f, -0.00735655f, -0.22480887f, 0.07062912f, 0.38564283f, 0.02348826f, 
    -0.45881656f, 0.33939716f, -0.14251024f, 0.16726200f, -0.45045108f, 0.38688111f, 0.27781430f, 0.38219225f, 
    -0.06591333f, 0.17268224f, -0.09362282f, 0.19627729f, -0.04816978f, 0.30210200f, 0.04024632f, -0.38179445f, 
    0.15132828f, 0.15882832f, -0.02279008f, 0.17219128f, 0.19165121f, 0.02776641f, -0.21962923f, 0.25438470f, 
    0.06496383f, 0.39861992f, -0.10788961f, -0.13043718f, -0.13669930f, 0.29377207f, -0.06947137f, 0.35895261f, 
    -0.39320427f, 0.75910985f, 0.12216622f, -0.08016839f, 0.06352080f, 0.16874644f, 0.45191777f, 0.07065790f, 
    -0.41511548f, -0.19780892f, -0.29008335f, 0.06056216f, -0.03547410f, 0.07038528f, 0.13158296f, -0.17517194f, 
    0.34798488f, 0.06170598f, 0.07019466f, 0.20572166f, 0.66269344f, 0.07724965f, -0.07718921f, 0.01172344f, 
    0.05358666f, 0.01312838f, 0.15053663f, 0.29082930f, 0.05062187f, -0.37274328f, -0.47855482f, 0.04424203f, 
    -0.25779158f, 0.20047045f, -0.38523534f, 0.12073183f, 0.51493531f, -0.00564790f, -0.09967558f, 0.10380011f, 
    -0.38048890f, -0.30518565f, 0.09154130f, 0.25720084f, 0.01929208f, 0.19966668f, 0.10586702f, 0.21314104f, 
    0.12869920f, 0.11111680f, -0.08937404f, 0.21319383f, 0.42178491f, 0.02077828f, 0.23119746f, 0.12745441f, 
    -0.09838513f, 0.38729289f, 0.16432860f, 0.05757394f, 0.46899450f, -0.31856582f, 0.05406089f, -0.02362313f, 
    -0.28218400f, -0.05360392f, 0.04221780f, 0.11301539f, -0.00994544f, 0.65561980f, -0.17596781f, 0.31572735f, 
    -0.35355783f, 0.24616882f, 0.50696105f, -0.21308982f, -0.18093610f, 0.10354198f, -0.05233827f, 0.35738736f, 
    0.04715875f, 0.07815272f, 0.11916193f, 0.05648719f, -0.32026210f, 0.02533887f, 0.24790031f, 0.09215901f, 
    0.07703879f, -0.14675649f, 0.06525980f, 0.20270364f, -0.23720317f, 0.58824700f, 0.35740811f, 0.29112476f, 
    0.25632703f, -0.31886658f, 0.48712647f, 0.10677855f, -0.13685453f, 0.93180591f, -0.25952336f, -0.00345678f, 
    0.26470342f, 0.23758715f, -0.03311190f, 0.28824785f, 0.25753152f, -0.20577087f, -0.10394159f, 0.44809127f, 
    -0.38901681f, -0.14987247f, -0.08230270f, -0.26604775f, -0.48229510f, 0.09081041f, 0.33316979f, 0.29157788f, 
    -0.08501358f, 0.39180627f, 0.08240760f, -0.18333335f, 0.15101910f, -0.28261739f, -0.22871689f, 0.39460230f, 
    0.38692665f, 0.11286360f, -0.06820286f, -0.14219968f, -0.01358754f, 0.60316807f, -0.63873339f, 0.03585485f, 
    0.21374506f, -0.22161196f, 0.00169332f, 0.11184766f, 0.47632027f, -0.45419735f, -0.06703806f, 0.06200689f, 
    0.62515748f, -0.14998825f, -0.06057536f, 0.35291967f, 0.11028416f, 0.11278635f, -0.00358461f, 0.35925132f, 
    0.05652784f, -0.00700264f, 0.02812674f, -0.09447972f, -0.15582253f, -0.14009410f, -0.13068363f, 0.03781420f, 
    0.09965172f, -0.10427283f, 0.01123568f, -0.08754867f, 0.06619458f, 0.09588374f, 0.06965637f, 0.06065636f, 
    -0.10204755f, 0.15808384f, -0.16785462f, -0.14536089f, 0.05208940f, -0.12029515f, 0.14205736f, 0.04336468f, 
    0.02173889f, 0.07119512f, 0.17226669f, -0.05525205f, -0.00409180f, -0.10020483f, -0.10509288f, -0.09690340f, 
    0.13204253f, 0.26961538f, -0.00669857f, -0.24318050f, -0.33704451f, 0.06992546f, 0.36291298f, 0.19809008f, 
    0.01893398f, -0.16941747f, 0.31861135f, -0.01329451f, -0.66303301f, 0.03657969f, 0.60934460f, 0.01032002f, 
    0.43479782f, 0.41164121f, -0.15946096f, 0.39234310f, -0.10667431f, 0.23863037f, 0.08213867f, -0.54474252f, 
    -0.05435871f, 0.17035688f, 0.16114815f, 0.15936886f, 0.24682266f, -0.11395452f, -0.44445518f, 0.35353655f, 
    0.11647237f, 0.11576190f, -0.10445786f, -0.06344209f, -0.08915618f, -0.10785304f, 0.09092069f, -0.04072714f, 
    0.08376443f, 0.05564817f, 0.02382480f, -0.08195587f, 0.00809767f, -0.02126290f, -0.11896249f, -0.04090728f, 
    -0.15877181f, 0.08188929f, 0.11050892f, -0.16334030f, -0.12007979f, 0.01188723f, 0.17476313f, -0.09798031f, 
    0.08097905f, -0.18801740f, -0.04250257f, 0.10450358f, -0.13508002f, -0.05547535f, -0.24199317f, -0.20499018f, 
    -0.12415182f, 0.28736487f, 0.05339177f, -0.05237802f, 0.31753072f, -0.04874879f, -0.15050386f, 0.32859156f, 
    0.39591667f, 0.18450683f, -0.41944978f, 0.16239807f, 0.10048102f, -0.91164541f, -0.32345650f, 0.05170183f, 
    0.60269868f, -0.11572918f, -0.06936893f, 0.32005066f, 0.20809147f, -0.53241867f, 0.10110667f, 0.19817276f, 
    0.13796148f, -0.02810054f, 0.14865389f, -0.29527611f, 0.54734296f, 0.11098343f, 0.01676221f, 0.01861694f, 
    -0.06033692f, 0.45172316f, 0.14920068f, -0.48836997f, 0.07775347f, 0.47962761f, -0.10559418f, 0.44559604f, 
    0.19463782f, 0.67205489f, -0.02017067f, -0.07739282f, 0.12464668f, -0.42226815f, 0.02814974f, -0.14605580f, 
    0.01522961f, -0.13281487f, -0.18239741f, -0.02726076f, 0.22642921f, -0.29046431f, 0.05881571f, -0.16596419f, 
    0.56278193f, 0.19890429f, 0.00858194f, 0.26004243f, 0.49414951f, -0.19301993f, 0.01911886f, 0.18712895f, 
    0.01698794f, -0.19687776f, 0.06622003f, 0.26528615f, 0.36189279f, 0.21183950f, 0.06591851f, -0.32950673f, 
    -0.29289967f, 0.05173871f, -0.36530653f, -0.13272601f, 0.23311749f, -0.34611583f, 0.24403715f, 0.24758193f, 
    -0.13831435f, 0.42070392f, 0.43098018f, 0.10632368f, -0.27697888f, 0.57106608f, -0.06618897f, 0.01124367f, 
    -0.16016938f, 0.35800505f, 0.04394985f, 0.15158600f, -0.05208114f, -0.09713533f, 0.44155613f, -0.22752541f, 
    -0.08926956f, -0.00645941f, 0.08366714f, 0.13691038f, -0.07671183f, -0.10716278f, -0.15088303f, 0.12605718f, 
    0.23826948f, -0.21595824f, 0.71010000f, 0.04181201f, -0.35649446f, 0.63498145f, 0.32488787f, -0.04599285f, 
    -0.05111891f, -0.09882560f, 0.01683289f, -0.12307424f, -0.01235954f, 0.27729723f, -0.09735905f, 0.06673265f, 
    0.19072428f, 0.01192641f, -0.01119694f, 0.48337668f, -0.03925224f, -0.11327845f, -0.18777001f, 0.32911956f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.12647183f, -0.08777949f, 0.00225195f, -0.01934708f, 0.26697707f, -0.09328971f, 0.02841819f, 0.10798422f, 
    -0.30965501f, 0.08197128f, -0.00965961f, -0.19958527f, 0.48257586f, -0.21240140f, -0.12846588f, -0.02301185f, 
    0.11468626f, -0.08249349f, 0.26645094f, 0.13514495f, 0.29121917f, 0.06029346f, 0.36783251f, 0.28633752f, 
    0.19645359f, -0.14871866f, 0.12564984f, -0.13687119f, 0.19279620f, 0.30721620f, 0.28389668f, 0.02147901f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.07635543f, -0.15019202f, -0.77265722f, -0.09723820f, 0.08079792f, 0.07770227f, 0.03819227f, 0.13004290f, 
    0.29309592f, -0.19349690f, -0.76941347f, -0.81703460f, 0.10739237f, 0.30345535f, 0.12876728f, -0.54759383f, 
    0.00159278f, 0.08351903f, 0.19320704f, 0.36900061f, -0.02693831f, 0.37309510f, 0.25612345f, -0.13649788f, 
    -0.08016290f, -0.07715571f, -0.11275913f, 0.14347495f, -0.36209106f, -0.16656099f, 0.19174084f, -0.14815710f, 
    0.07819833f, 0.01552815f, -0.51855487f, 0.16774869f, -0.30554572f, 0.14049910f, 0.06610247f, -0.09964406f, 
    0.46950281f, -0.11098126f, 0.08990234f, 0.11404997f, -0.06098154f, 0.52868211f, 0.12764214f, -0.29717880f, 
    -0.04689422f, 0.10059448f, -0.39864570f, 0.02390580f, 0.23507205f, 0.15305689f, 0.06050744f, 0.20693058f, 
    -0.00206269f, -0.06793324f, -0.08943722f, 0.00239543f, -0.38160688f, 0.07300429f, -0.42270452f, 0.41018566f, 
    -0.07143740f, 0.11741155f, 0.18050994f, -0.05637263f, 0.09163287f, 0.08810673f, 0.09578089f, 0.05983033f, 
    -0.45316055f, -0.06385893f, 0.05915039f, -0.15212736f, -0.05275043f, -0.15773655f, -0.07018939f, 0.04389115f, 
    0.00470827f, 0.23883091f, -0.85690790f, 0.18502255f, -0.22370388f, -0.75407422f, 0.02464630f, 0.28471151f, 
    0.12610888f, 0.07975823f, 0.23450485f, 0.06957044f, -0.21546598f, -0.11424300f, -0.81922191f, 0.44586247f, 
    0.00023899f, -0.00256627f, -0.21834205f, 0.07964633f, 0.20770770f, -0.05668911f, 0.08932338f, 0.05535850f, 
    -0.13694365f, -0.01482766f, 0.17501643f, -0.28051528f, -0.31573436f, -0.30028215f, 0.03627194f, 0.25848663f, 
    -0.04927126f, 0.17468816f, 0.43229795f, -0.33152920f, -0.51182884f, 0.24032915f, 0.21942888f, 0.26028815f, 
    -0.92810643f, -0.02929896f, -0.69642788f, -0.12344322f, -0.18948445f, -0.83435941f, 0.16481170f, -0.28750309f, 
    0.06410160f, -0.11809945f, 0.02731446f, -0.10150068f, 0.18450704f, -0.16157107f, 0.13800494f, -0.06200679f, 
    -0.67112446f, -0.36921221f, -0.48623762f, -1.04945087f, 0.20660378f, -0.55025494f, -0.09700318f, 0.37249249f, 
    0.17025979f, 0.15098768f, 0.06336142f, -0.30117109f, -0.40058765f, -0.04264334f, 0.13847747f, 0.04294485f, 
    -0.07131184f, 0.06011825f, -0.29465592f, 0.06387293f, 0.08597014f, -0.06952596f, 0.33089408f, 0.03860763f, 
    0.12184662f, 0.05328375f, -0.90032369f, -0.09678606f, -0.89686227f, 0.13340199f, 0.06777812f, 0.11587150f, 
    -0.25332060f, -0.27080026f, -0.11859048f, -0.11706891f, 0.02536767f, 0.32640362f, 0.05916956f, -0.08361597f, 
    -0.01485241f, 0.02507349f, 0.24166748f, -0.04464575f, 0.26358050f, 0.35624698f, -0.06780756f, -0.50129467f, 
    -0.14339775f, 0.07557601f, 0.16090347f, -0.16715877f, 0.31515867f, 0.20523180f, -0.02168539f, -0.04307661f, 
    0.15052073f, 0.16378313f, 0.27146712f, 0.00679079f, -0.56234390f, 0.12871216f, 0.13287784f, -0.09458172f, 
    -0.46173280f, -0.18193741f, 0.33273977f, -0.07530388f, -0.06364063f, -0.24733768f, -0.04435301f, -0.10907117f, 
    -0.15936610f, 0.19342583f, 0.01166631f, -0.52019525f, -0.06554610f, 0.20592988f, -0.16569746f, 0.11494225f, 
    0.27919993f, -0.12429854f, -1.10488617f, 0.09169755f, 0.33162609f, 0.21834323f, -0.55106521f, -0.12993871f, 
    -0.04372859f, 0.07011500f, -0.05602375f, -0.03022355f, 0.13815440f, 0.00238174f, -0.05569028f, -0.10460157f, 
    0.65821660f, 0.20096816f, -0.37818387f, 0.78401309f, -0.54351425f, 0.06926042f, -0.04529532f, -0.03455015f, 
    -0.05411019f, 0.07757517f, 0.07455777f, -0.20732708f, -0.41216975f, -0.00718792f, 0.24450757f, -0.69810069f, 
    -0.23996255f, 0.10392977f, -0.02707324f, -0.12483749f, -0.59482872f, -0.24403000f, 0.27119833f, 0.34189668f, 
    0.12722023f, 0.08555809f, -0.17388758f, 0.02874904f, -0.32205373f, 0.06688237f, -0.05955866f, 0.03618025f, 
    -0.16746120f, 0.39013311f, 0.30685237f, 0.06616230f, -0.30572805f, 0.07788828f, -0.12605961f, -0.00900218f, 
    -0.15321849f, -0.54255468f, -0.50945908f, 0.47711200f, 0.24546054f, -0.14559227f, -0.99052221f, -0.08396798f, 
    -0.27007380f, -0.07784772f, 0.58407694f, -0.12146755f, -0.05856986f, 0.15815355f, -0.10942950f, -0.00107055f, 
    -0.11952439f, -0.10081962f, 0.30964962f, -0.09237086f, -0.03366836f, 0.10341074f, -0.05626166f, 0.08244773f, 
    -0.49333081f, -0.54917991f, -0.34356093f, -0.22008327f, 0.12610054f, -0.45735964f, 0.00610008f, -0.19904986f, 
    0.00053627f, -0.51765949f, 0.06565825f, 0.27207634f, 0.25739661f, 0.00359401f, 0.14407353f, -0.33299008f, 
    0.12534694f, -0.12471543f, -0.12691472f, 0.04436147f, 0.24651222f, 0.20590033f, -0.06333506f, -0.36108306f, 
    -0.07658925f, 0.14618777f, -0.72368294f, -0.14289866f, 0.10985471f, -0.05173134f, -0.11854889f, 0.10955096f, 
    -0.53910309f, 0.55088723f, 0.35603532f, -0.50625718f, -0.45641929f, -0.81254077f, -0.07334919f, 0.24252596f, 
    0.15272640f, 0.14358866f, -0.30672443f, 0.20395052f, 0.07342836f, -0.60196954f, 0.06146348f, 0.05338985f, 
    -0.73680687f, 0.07299577f, -0.11945678f, 0.07571303f, -0.74682856f, 0.04693935f, 0.24337675f, -0.12780477f, 
    0.16325226f, -0.12173212f, 0.62980223f, -0.01814030f, 0.31067920f, 0.05033114f, -0.13510683f, 0.03228592f, 
    -0.44116896f, -0.00718509f, 0.37596193f, -0.27403143f, -0.07432555f, 0.05935767f, -0.01405876f, -0.29327458f, 
    0.09239002f, 0.13904953f, -0.40454653f, -0.23608719f, -0.46850604f, -0.39185452f, -0.26065305f, 0.42072597f, 
    -0.21661200f, 0.17140752f, -0.34742787f, -0.10849304f, 0.20040698f, -0.04967361f, -0.03857669f, -0.65756649f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.22599731f, 0.11529424f, 0.07330289f, -0.10267713f, 0.03667593f, 0.06315409f, 0.01002586f, -0.26431695f, 
    -0.32868940f, 0.25297940f, 0.09620756f, 0.16062127f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
