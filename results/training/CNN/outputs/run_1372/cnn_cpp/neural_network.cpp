#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.08118251f, -0.02868682f, 0.18215141f, 0.46964267f, -0.51150465f, -0.23062861f, -0.37274432f, -0.25748292f, 
    -0.00418621f, -0.55823523f, 0.29997957f, 0.52044582f, 0.18359068f, -0.28765172f, 0.38503093f, -0.11766121f, 
    -0.52426630f, 0.22630759f, -0.81415468f, 0.10110833f, 0.50124538f, -0.43092936f, -0.57152933f, -0.73600078f, 
    -0.17766492f, -0.34874472f, -0.50477737f, -0.13489893f, 0.28351149f, -0.13866873f, -0.58277315f, 0.15671812f, 
    0.42456958f, 0.09085798f, 0.23905559f, 0.15460989f, 0.66898584f, -0.79508138f, 0.29390073f, -0.19849618f, 
    -0.00294689f, -0.18168978f, 0.33670178f, 0.01954538f, -0.10336126f, 0.35067528f, 0.61549467f, -0.05317877f, 
    -0.53635126f, 0.26790822f, -0.27863249f, 0.30515900f, 0.22698280f, -0.34888586f, 0.87092894f, -0.72534716f, 
    -0.54133868f, 0.09158044f, -0.52056026f, -0.27772707f, -0.56448746f, 0.51919311f, -0.22787862f, 0.18578692f, 
    0.26525918f, 0.22637740f, -0.08856462f, -0.31784761f, 0.41307017f, -0.19077013f, -0.50473291f, 0.10049818f, 
    -0.59185582f, -0.28008077f, -0.67821825f, 0.70266604f, 0.47157139f, 0.20806724f, -0.17170008f, -0.33187836f, 
    -0.28212714f, -0.66430569f, -0.51566994f, -0.64973378f, 0.19550228f, 0.31696779f, 0.54392904f, 0.40525064f, 
    0.22420484f, -0.05853228f, 0.86169761f, 0.07923163f, 0.04087803f, 0.31594062f, -0.18567634f, 0.16290532f, 
    -0.27434978f, -0.15185970f, -0.54497838f, -0.00075924f, -0.49885246f, -0.45184651f, 0.23360305f, 0.54767883f, 
    -0.53064227f, 0.20005949f, 0.15417823f, 0.30034241f, -1.05651402f, -1.05867636f, 0.03457355f, 0.71942264f, 
    0.72511309f, -0.28558815f, 0.01909551f, 0.00537234f, -0.14248370f, -0.30895865f, -0.58014041f, 0.49600282f, 
    0.22814147f, 0.76957351f, 0.26847172f, -0.52377069f, -0.52121252f, -0.18577611f, 0.44476455f, 0.79581118f, 
    -0.85963643f, -0.20980605f, -0.46465045f, -0.49666348f, -0.18869948f, -0.19096395f, 0.22452256f, 0.99898118f, 
    -0.59824294f, -0.56280279f, 0.21110556f, -0.00608670f, -0.78822565f, -0.41385370f, -0.28421110f, -0.10916194f, 
    0.12085792f, -0.54417747f, -0.20162550f, -0.15137015f, 0.36021844f, 0.29747525f, 0.13357221f, 0.27999032f, 
    -0.40299511f, 0.32678995f, 0.50416940f, 0.39091226f, -0.70636570f, -0.08755084f, -0.20311724f, -0.41391969f, 
    0.36420810f, 0.19273058f, -1.12329853f, 0.29875770f, 0.68409294f, -0.69735998f, 0.15665179f, 0.61894244f, 
    0.05483122f, 0.02249682f, -0.00551248f, 0.11545607f, -0.88255960f, 0.66398811f, 0.22785337f, -0.19872162f, 
    -0.28919381f, -0.41720214f, -0.22569662f, 0.69313508f, -0.21118890f, -0.91442239f, -0.86064559f, 0.02331900f, 
    0.00381997f, 0.03180381f, 0.35661352f, 0.06620471f, 0.34115162f, -0.26648352f, 0.88834429f, 0.48279044f, 
    -0.67231506f, -0.36416554f, -0.02831934f, 0.01008731f, 0.23647515f, 0.36841398f, -0.03361091f, 0.04833144f, 
    0.03558537f, 0.38769388f, 0.28262722f, -0.37905332f, -0.31035024f, 0.01049639f, 0.33587825f, 0.18572477f, 
    -0.74976921f, -0.13088085f, -0.57534188f, 0.63662660f, -0.44434977f, -0.25068206f, -0.15878054f, 0.21858941f, 
    -0.00608535f, 0.46684039f, 0.37698546f, 0.03662376f, 0.21765007f, -0.09607275f, -0.13258314f, 0.02150776f, 
    -0.26247451f, 0.10909014f, 0.28294098f, 0.03187556f, 0.35372591f, 0.37392083f, 0.15137807f, -0.14488947f, 
    0.25009361f, 0.11393648f, 0.87104410f, -1.03072798f, -0.00906413f, -0.04183273f, -0.16041106f, 0.27363965f, 
    -0.14588879f, -0.29404882f, 0.22157048f, -0.59369439f, -0.70031220f, 0.79378647f, -0.69247800f, -0.72138751f, 
    0.38528785f, 0.41449425f, 0.00407837f, -0.14601432f, 0.58914542f, -0.62350422f, -0.58733428f, 0.38189688f, 
    0.46363318f, -0.03555990f, -0.20275335f, -0.31719649f, 0.32546732f, -0.19819099f, -0.78167784f, -0.44553697f, 
    -0.80776995f, 0.02034337f, -0.09995387f, 0.49773738f, 0.44671398f, -0.32014933f, 0.34805644f, 0.43820000f, 
    -0.74194056f, -0.03401703f, 0.15974022f, -0.03470000f, -0.09818547f, 0.21907489f, 0.17377925f, -0.65669447f, 
    -0.39846849f, 0.36112833f, -0.39434993f, 0.02393441f, -0.15799367f, -0.25099805f, -0.63402140f, -0.64571768f, 
    -0.65939152f, 0.21387623f, 0.21381880f, -0.43985346f, -0.11208500f, 0.60231215f, -0.48684177f, 0.26980165f, 
    0.36870191f, -0.63655496f, 0.86128730f, -0.36509693f, -0.18040700f, 0.70139104f, -0.60043824f, 0.29360697f, 
    -0.02609493f, -0.13116437f, -1.10165668f, 0.38274267f, 0.64451671f, -0.14891490f, -0.22485752f, 0.26398322f, 
    -0.38486686f, -0.32998726f, -0.45021009f, 0.49718589f, 0.04553216f, 0.41830450f, -0.00700326f, 0.07569996f, 
    0.30712429f, -0.01080101f, 0.10733180f, -0.35433343f, 0.66710472f, -0.23246731f, 0.08430162f, 0.43833530f, 
    0.03762770f, -0.14966817f, -0.12831734f, 0.43244720f, -0.27907407f, -1.03013134f, 0.23001030f, -0.64305043f, 
    0.32170582f, -0.36012426f, 0.68658835f, 0.20521699f, -0.19049998f, 0.21541531f, 0.49608457f, 0.02056677f, 
    -0.18488890f, 0.04791135f, 0.42563397f, -0.32477039f, 0.14973131f, -0.32619601f, 0.03612731f, 0.40467018f, 
    0.90400666f, 0.09868365f, -0.70017880f, -0.71487874f, 0.29034045f, -0.12745205f, 0.23165864f, -0.10293555f, 
    -0.69071162f, -0.76290745f, -0.12470162f, -0.27189550f, -0.65371019f, -0.69759625f, 0.11208859f, 0.06207504f, 
    -0.07570314f, 0.34806708f, -0.24711369f, 0.50128883f, -0.52609885f, -0.21319625f, 0.14381130f, -0.14923114f, 
    -0.50608599f, 0.67783445f, 0.44790438f, 0.52124393f, -0.83096987f, -0.60716039f, 0.06383344f, 0.42887092f, 
    0.18694010f, 0.13969915f, -0.10809370f, 0.26958701f, 0.04601581f, -0.21179575f, -0.81045896f, 0.67113000f, 
    0.03949953f, 0.02961176f, -0.37841493f, 0.53876066f, 0.83511847f, -0.61482710f, 0.08840562f, 0.05914252f, 
    -0.02266477f, 0.20527138f, -0.03444432f, 0.19004852f, -0.57047093f, 0.48053780f, 0.57460284f, 0.53934985f, 
    -0.56959671f, -0.05192293f, -0.50245655f, -0.29424444f, 0.04094166f, -0.03943855f, -0.73695362f, -0.74115247f, 
    -0.11711075f, 0.52163243f, 0.00016624f, -0.36680359f, -0.49096352f, -0.31376576f, -0.61156940f, 0.35337022f, 
    -0.22438569f, -0.65156215f, 0.05095603f, -0.45641580f, -0.16960327f, 0.38948727f, -0.01238441f, 0.47694656f, 
    0.30470014f, 0.20339935f, -0.56354719f, -0.42548287f, -0.32081673f, -0.16629483f, -0.29815713f, -0.46716994f, 
    -0.44077379f, -0.14736776f, 0.06308195f, 0.40509823f, 0.29299971f, -0.73182207f, -0.02518645f, 0.23773624f, 
    0.03359950f, 0.22256215f, -0.82729948f, -0.68035805f, 0.25072816f, -0.63907695f, -0.95261133f, -0.75441790f, 
    0.05399906f, 0.31167543f, 0.24084538f, 0.21652302f, 0.51712036f, -0.03647996f, -0.83665287f, -0.81537896f, 
    -0.60566127f, -0.28878647f, -0.49504930f, -0.32617331f, 0.37743545f, -0.51766640f, 0.23372260f, -0.82295179f, 
    -0.83969456f, -1.03169179f, 0.35914683f, 0.47302094f, -0.33684754f, 0.05760866f, -0.41223323f, 0.48280895f, 
    0.56630963f, -0.20274286f, -0.30757922f, 0.51087761f, -0.41349089f, -0.41024461f, -0.06150431f, -0.37466022f, 
    -0.73819363f, -0.43916595f, -0.56143904f, -0.65862089f, -0.41969416f, -0.34095505f, -0.43436626f, 0.69119638f, 
    -0.54033524f, -0.19060901f, 0.08535862f, -0.28085491f, -0.31327879f, -0.11241078f, 0.41880983f, 0.38511899f, 
    0.85143149f, -0.60609657f, -0.10978860f, 0.47691426f, 0.29425237f, -0.51088715f, -0.26384673f, 0.07923386f, 
    0.11771590f, 0.71138602f, -0.62754732f, -0.90225410f, 0.54504043f, 0.53216892f, 0.10615881f, -0.33556622f, 
    0.15008943f, -0.00422855f, 0.16308114f, 0.33922887f, -0.89145923f, 0.09155943f, 0.60816979f, 0.51765132f, 
    -0.07873799f, -0.47442487f, -0.34617406f, -0.06248415f, -0.26625234f, -0.11701155f, 0.16679692f, -0.10295375f, 
    -0.24646138f, 0.23853301f, 0.48626322f, 0.22151436f, -0.81537336f, -0.62914062f, -0.04716844f, 0.52003586f, 
    -0.65530699f, 0.05090085f, -0.35507268f, -0.21486005f, 0.32715082f, -0.67225105f, 0.34765995f, 0.31317046f, 
    0.36608687f, 0.49422011f, -0.22405590f, -0.08247487f, 0.32442605f, -0.26979071f, 0.95148367f, -0.66635489f, 
    -0.64702904f, 0.43085474f, 0.13203634f, -0.41059798f, 0.08325465f, 0.12390088f, 0.08292479f, -0.88146698f, 
    -0.59327477f, -0.68208259f, 0.30417386f, -0.19337174f, -0.35452026f, -0.21071400f, -0.45448971f, -0.40137842f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.05934268f, 0.17499290f, 0.15297875f, 0.22808103f, 0.08474307f, 0.15037927f, 0.17712383f, 0.17652123f, 
    -0.12813114f, 0.10064375f, 0.04292785f, 0.18493639f, -0.12666737f, 0.11455970f, 0.16489744f, 0.11650752f, 
    0.12905005f, 0.19151720f, 0.17236294f, 0.05375587f, 0.18658936f, 0.21413755f, 0.31038150f, 0.07057484f, 
    0.05832460f, -0.10784877f, 0.20101508f, 0.29210374f, 0.20993350f, 0.22813523f, 0.26119885f, -0.17202000f, 
    0.25670984f, 0.12250833f, 0.08542415f, -0.16574338f, -0.07726876f, 0.20829859f, 0.28485018f, 0.25240511f, 
    -0.12842897f, -0.04975738f, 0.01397682f, -0.01796948f, 0.12573925f, 0.26885125f, -0.24821894f, 0.32603410f, 
    -0.05580428f, 0.07338719f, -0.16432653f, -0.05723535f, 0.08879440f, 0.23532774f, -0.32875732f, 0.20506433f, 
    0.28914014f, 0.20904726f, 0.13241743f, 0.11109485f, 0.16539195f, 0.41907424f, 0.32717076f, -0.17035818f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.07858753f, 0.19304226f, -0.13638029f, -0.05833124f, 0.00144294f, -0.16020912f, -0.10365588f, -0.10095160f, 
    0.00180208f, 0.01417060f, -0.02406065f, -0.04759413f, -0.00140550f, -0.00601646f, -0.01496993f, -0.08879296f, 
    -0.08273891f, -0.10559119f, -0.02107260f, 0.07552422f, -0.37250569f, -0.14478029f, 0.10088017f, -0.28507525f, 
    0.16535959f, 0.00067788f, -0.01983614f, -0.02359691f, 0.07331149f, 0.00862862f, 0.04293523f, 0.06765524f, 
    -0.02614470f, -0.01315105f, -0.01244358f, -0.06388071f, -0.04477480f, 0.00461301f, -0.02788645f, 0.03107662f, 
    0.14889243f, 0.19400850f, 0.01349788f, -0.24400838f, 0.03819065f, -0.06827309f, 0.05610981f, -0.08591348f, 
    0.02534261f, 0.00795228f, 0.03811005f, -0.02987009f, -0.04061871f, -0.00976450f, -0.00833882f, -0.05213886f, 
    -0.09149370f, 0.00188575f, -0.00008123f, 0.06916489f, -0.03682280f, -0.01688916f, 0.06743247f, 0.04588256f, 
    0.01188865f, -0.03907479f, -0.00599136f, 0.00293863f, 0.03619879f, -0.00808329f, -0.05526943f, 0.00900436f, 
    -0.07656417f, -0.00930318f, -0.02482074f, -0.03401527f, -0.06811738f, -0.01181564f, -0.02373786f, -0.05810222f, 
    -0.01837882f, 0.03078285f, -0.05165923f, -0.27328426f, 0.07966967f, -0.20562565f, -0.02894844f, -0.04647400f, 
    -0.09963728f, -0.00900395f, -0.07389013f, 0.05997118f, 0.06281878f, 0.06043094f, -0.04453271f, -0.02202028f, 
    -0.04918804f, -0.14037159f, -0.31185758f, 0.09982943f, -0.10339563f, -0.05253896f, -0.05891942f, 0.02103354f, 
    -0.03335998f, -0.00913682f, 0.04327697f, -0.05333718f, -0.03576590f, 0.05669837f, -0.03185915f, 0.01004236f, 
    0.03974055f, 0.00890303f, -0.00715605f, -0.02775039f, -0.04785761f, -0.18261881f, -0.09908442f, -0.00191988f, 
    0.01753925f, 0.11119078f, -0.09195243f, -0.14819045f, -0.09262707f, 0.01420025f, 0.03336236f, 0.00394480f, 
    -0.12700646f, 0.03575602f, -0.04276492f, -0.02158368f, 0.00917151f, -0.01491195f, -0.00627982f, -0.05446471f, 
    0.01601293f, -0.07997051f, 0.07366497f, 0.04888071f, -0.37232262f, 0.01672954f, 0.21236691f, 0.02398303f, 
    0.14438705f, 0.01343952f, -0.01509898f, -0.01682761f, 0.01395033f, 0.01776956f, 0.07481810f, -0.00485726f, 
    -0.01190328f, 0.00672275f, 0.01862469f, 0.00708749f, 0.03232476f, -0.07695444f, 0.02905992f, -0.11049441f, 
    0.36322683f, 0.08899149f, -0.48157007f, -0.07236251f, -0.03741541f, 0.04792192f, 0.08164261f, 0.08166503f, 
    -0.07529726f, 0.01311814f, -0.01793303f, 0.00867825f, 0.01306630f, -0.03747934f, 0.03142293f, 0.05346568f, 
    0.05461114f, 0.04947896f, -0.01019678f, 0.00009258f, 0.19873442f, 0.09984811f, -0.07327888f, 0.02999486f, 
    0.05839161f, 0.11399196f, 0.09227487f, 0.06448842f, -0.02286162f, -0.17249961f, -0.10206962f, -0.06428632f, 
    -0.07727309f, 0.05835099f, 0.06346869f, 0.02788359f, 0.01583445f, -0.00260743f, 0.00369273f, -0.00934752f, 
    -0.24755637f, 0.19530141f, -0.15529186f, 0.34759197f, 0.28155977f, 0.03953604f, -0.00198992f, -0.00956980f, 
    0.04623940f, 0.04984856f, 0.00111692f, 0.04768400f, 0.02313755f, 0.04833937f, 0.03967103f, 0.01480736f, 
    0.00393473f, 0.10727858f, 0.05109133f, -0.02446506f, 0.12079015f, 0.21335150f, -0.20227741f, 0.02200027f, 
    0.01867896f, 0.06624471f, 0.01380394f, 0.08023854f, -0.13133197f, -0.01502354f, 0.03772168f, -0.10507708f, 
    -0.06213039f, -0.01276971f, 0.01764201f, 0.00042065f, -0.00107701f, -0.08037500f, 0.01834838f, -0.00184510f, 
    0.51935506f, 0.18858746f, -0.42316255f, -0.17965397f, 0.01263300f, 0.11742760f, 0.09584635f, 0.17604135f, 
    -0.00679169f, 0.11265775f, -0.02576481f, 0.00543888f, -0.05343156f, 0.07341757f, 0.00539297f, 0.00818721f, 
    0.07396011f, 0.09274311f, 0.00431174f, 0.03104335f, 0.29824376f, -0.17306924f, 0.04231033f, -0.05279640f, 
    -0.19783360f, 0.00312837f, -0.04758611f, 0.06918841f, 0.06242751f, 0.07446954f, 0.02595566f, 0.07716414f, 
    0.05562469f, 0.13392079f, -0.04291200f, -0.13031028f, 0.02785514f, 0.03890574f, 0.03924146f, 0.05228344f, 
    -0.08917205f, 0.10113519f, -0.14821015f, -0.01184191f, -0.32159531f, 0.00734469f, -0.18720180f, 0.00318355f, 
    -0.09183539f, 0.02237082f, -0.06133268f, -0.06912962f, -0.03716869f, 0.05441704f, 0.06309778f, -0.03349473f, 
    0.02375736f, -0.00445828f, -0.05449439f, -0.10153428f, 0.07982311f, -0.02268292f, -0.00540742f, 0.05323479f, 
    -0.01714431f, 0.03416821f, -0.05091591f, 0.09756877f, -0.05083038f, -0.01467087f, -0.04351800f, -0.00999447f, 
    -0.03043917f, -0.00781770f, -0.07111997f, 0.05124287f, -0.04333524f, 0.10616545f, -0.02906419f, 0.13090946f, 
    0.12494510f, -0.03500485f, -0.12598005f, 0.04482181f, -0.01980972f, 0.08262709f, -0.02588288f, 0.00414507f, 
    0.01691995f, 0.03670022f, -0.05268930f, -0.03496203f, -0.11098611f, 0.04286348f, -0.09208178f, 0.02946266f, 
    -0.02862228f, 0.01284189f, -0.02469870f, 0.00136439f, -0.22843745f, -0.10500139f, 0.05473332f, 0.00403153f, 
    -0.17180754f, 0.02723086f, -0.01590400f, -0.15428561f, -0.01578374f, -0.02671476f, 0.02646405f, 0.04071225f, 
    -0.00104194f, -0.00254627f, 0.05419989f, -0.02401245f, 0.05578214f, -0.13985462f, -0.09092792f, -0.06480234f, 
    -0.47203457f, -0.18209206f, 0.31347832f, 0.03529038f, 0.07339635f, -0.14422813f, 0.01106248f, 0.11271609f, 
    0.10323865f, -0.13131551f, -0.12495310f, -0.07782833f, -0.11938934f, -0.00347399f, 0.02663350f, -0.09589040f, 
    0.00600410f, 0.00419627f, -0.04597409f, -0.04190796f, 0.27289134f, 0.12711217f, 0.04468321f, -0.17423214f, 
    0.03774514f, 0.01883077f, 0.07688030f, -0.09142532f, -0.13165206f, -0.15790372f, 0.01953093f, -0.07255846f, 
    -0.00290871f, 0.02265001f, -0.04312930f, -0.12714200f, 0.04241962f, -0.05116754f, 0.02427117f, -0.28010148f, 
    0.33708575f, 0.29166391f, -0.09527086f, -0.04879650f, 0.02446469f, 0.19833186f, 0.08884745f, 0.17023318f, 
    -0.07219339f, -0.15372641f, -0.04203559f, -0.03433095f, -0.04666257f, 0.02692753f, 0.07336608f, -0.00191152f, 
    -0.00819318f, -0.00018267f, 0.00649964f, 0.03589439f, -0.07155014f, -0.07342181f, 0.06383030f, 0.03871816f, 
    -0.04442227f, -0.17375824f, -0.17711391f, 0.07133272f, 0.01043413f, -0.01474778f, 0.05280765f, 0.01083762f, 
    0.01376924f, 0.03221454f, 0.00663376f, -0.05617229f, -0.00719604f, -0.00579342f, -0.10400066f, -0.10549564f, 
    0.01205002f, -0.14287499f, -0.15041433f, 0.01052841f, 0.01071380f, 0.02748978f, -0.05606678f, -0.05868074f, 
    0.04674878f, -0.02056316f, -0.10141960f, -0.08652559f, -0.00593729f, -0.02780256f, -0.03020662f, -0.10539824f, 
    -0.01596812f, -0.05123840f, 0.02313541f, -0.05487908f, 0.20794834f, 0.12935916f, 0.03328971f, -0.09706424f, 
    -0.11117865f, 0.10711838f, -0.04167706f, 0.12850909f, -0.22093949f, 0.02504071f, -0.03660138f, 0.05856935f, 
    -0.04829928f, -0.02572357f, -0.06289044f, -0.01875584f, -0.04968348f, -0.07088643f, -0.08350255f, -0.04151965f, 
    -0.11262683f, -0.10718151f, -0.12526819f, -0.07675325f, 0.00686812f, 0.04505264f, 0.01081206f, -0.00263979f, 
    0.03547550f, 0.02735104f, 0.00182232f, 0.02225779f, 0.01241740f, 0.05286536f, 0.02468327f, 0.04255582f, 
    0.04153268f, 0.03454652f, -0.03959588f, 0.00375073f, -0.00039412f, -0.05552657f, 0.00704659f, 0.04035857f, 
    0.04534231f, 0.00424623f, 0.04023776f, 0.01655913f, 0.02776059f, 0.05815262f, -0.23521161f, -0.22826391f, 
    -0.10006153f, -0.09578446f, -0.19005559f, -0.04689202f, -0.00000502f, 0.01667254f, 0.03350162f, 0.02132009f, 
    0.02075417f, -0.08519874f, 0.06182563f, -0.14115217f, -0.01031816f, -0.06029524f, -0.12647012f, 0.00270405f, 
    -0.08701519f, -0.12688056f, -0.05062225f, -0.01711506f, -0.05735618f, -0.09620073f, -0.03976954f, 0.02022963f, 
    0.10035633f, -0.03951586f, -0.01432187f, -0.08865963f, 0.15820113f, 0.16085993f, 0.29610589f, -0.36338362f, 
    0.01441814f, -0.00338178f, 0.05767124f, -0.00196425f, -0.02321612f, -0.09503526f, 0.03874378f, 0.00303123f, 
    -0.11416628f, -0.00168450f, -0.02850729f, 0.02720413f, 0.00029813f, -0.05230318f, -0.07111419f, -0.05914440f, 
    -0.03246230f, -0.07818962f, -0.21148270f, 0.09556870f, 0.00411480f, 0.07489231f, -0.01592740f, -0.03160619f, 
    -0.05602726f, -0.06534004f, 0.01414870f, -0.01502561f, -0.09718169f, 0.01298650f, -0.00734124f, -0.03747692f, 
    0.06909054f, -0.07927068f, -0.00806033f, -0.01971509f, 0.21692905f, 0.26646957f, -0.03019852f, -0.28270411f, 
    -0.11797423f, 0.11177380f, -0.11010716f, -0.03021447f, -0.05151711f, -0.09126521f, -0.03710905f, 0.01521508f, 
    -0.04744721f, 0.04170524f, 0.01977998f, 0.00404271f, -0.02047288f, -0.05714805f, -0.03988822f, 0.07059178f, 
    -0.07260941f, -0.05976937f, -0.12496405f, 0.06498222f, -0.03097240f, 0.03677348f, 0.01360403f, -0.02729628f, 
    0.00291547f, 0.00996481f, -0.06042872f, -0.07751158f, -0.09882443f, -0.02304711f, -0.00629207f, -0.03482686f, 
    0.02907798f, -0.03416486f, -0.06905583f, -0.07323497f, 0.28899521f, 0.12427545f, 0.18801856f, -0.26612425f, 
    0.02130629f, 0.02458645f, 0.11836006f, 0.04869903f, 0.01557419f, 0.00206539f, -0.01364037f, -0.00314190f, 
    -0.00810021f, -0.07174002f, -0.13956715f, -0.01946946f, -0.19931851f, -0.04449638f, 0.14862800f, 0.08896849f, 
    -0.20568067f, -0.02748883f, 0.21037513f, -0.00041504f, 0.03529583f, -0.10270402f, 0.00977186f, 0.06161257f, 
    0.05129065f, -0.06718879f, -0.10265939f, -0.08145239f, 0.02756569f, -0.06486754f, 0.00182685f, -0.04680585f, 
    -0.05331324f, -0.01859481f, -0.03567824f, -0.06645427f, -0.04496101f, 0.05330807f, 0.01907627f, 0.00835359f, 
    -0.11808868f, -0.12002538f, 0.08787809f, -0.08389352f, -0.07045463f, 0.03194506f, -0.09089496f, -0.03401115f, 
    -0.15906025f, -0.03808338f, -0.09652669f, -0.16344334f, 0.02263370f, -0.02805296f, -0.10334780f, -0.17216505f, 
    -0.07168080f, 0.12112503f, 0.25027758f, -0.12742126f, 0.20150656f, -0.14403623f, -0.07872155f, 0.00957485f, 
    0.04669442f, -0.00017399f, 0.00922364f, 0.01052401f, -0.05607151f, -0.02853553f, -0.00854269f, 0.08637378f, 
    0.04624057f, -0.03838383f, -0.05263106f, 0.10588950f, -0.05878021f, -0.02838827f, -0.14497873f, 0.03644140f, 
    0.01651553f, 0.03153918f, 0.05067149f, 0.05165444f, 0.01618076f, 0.04089259f, 0.00090440f, 0.05002110f, 
    0.06500790f, 0.06145339f, 0.05148229f, 0.05087841f, -0.16994534f, -0.00931176f, -0.01564678f, -0.03004123f, 
    -0.06063019f, -0.00579022f, -0.15798984f, 0.04161101f, 0.05167820f, 0.00973490f, 0.00512781f, 0.03842842f, 
    0.04115871f, 0.06146447f, -0.02942355f, 0.05609101f, 0.08277149f, -0.03575033f, 0.06870209f, -0.21806452f, 
    -0.08056130f, -0.16762590f, -0.04926872f, 0.05241690f, 0.06229103f, -0.05553767f, 0.13664864f, -0.12968376f, 
    0.07716009f, 0.06468932f, 0.13207674f, 0.09413879f, 0.01414066f, -0.09277482f, -0.09380893f, -0.03442064f, 
    -0.02029888f, -0.10959279f, 0.04154779f, 0.01413725f, 0.02551604f, 0.01125226f, -0.05514460f, -0.04649464f, 
    -0.25446403f, -0.32705382f, -0.12526944f, 0.08364060f, -0.05768795f, -0.05781623f, 0.00825170f, -0.00347038f, 
    -0.00352472f, 0.02697973f, -0.04098517f, -0.00145953f, -0.09817970f, -0.00684453f, -0.00325042f, -0.11885817f, 
    -0.11114024f, -0.05759776f, -0.06601734f, -0.00567819f, -0.41298285f, 0.22005385f, -0.02129198f, -0.14893457f, 
    -0.18243136f, 0.01115880f, -0.09883261f, -0.08061087f, -0.00439132f, -0.01145789f, 0.00309509f, 0.03860435f, 
    -0.02744531f, 0.04180878f, 0.02691786f, 0.02140394f, 0.02814198f, 0.00475958f, -0.02978353f, -0.07851641f, 
    0.29549465f, 0.23474863f, 0.03652137f, -0.29570517f, -0.07440039f, 0.09245212f, 0.11520635f, 0.09086397f, 
    -0.04650382f, 0.01108697f, 0.01425350f, 0.00230962f, -0.03169594f, 0.00439356f, -0.02585480f, 0.01504813f, 
    -0.03448921f, -0.08295813f, 0.00516121f, -0.01222093f, -0.31673804f, -0.08263111f, 0.37795293f, -0.27741814f, 
    -0.07132062f, 0.09081464f, -0.00227125f, -0.08618051f, -0.11654837f, -0.09945160f, 0.08925498f, 0.02549365f, 
    -0.00853620f, 0.04107526f, 0.00430251f, -0.00687045f, -0.00981041f, 0.07060633f, -0.06579885f, -0.26750350f, 
    -0.11244930f, 0.07476492f, -0.09821682f, 0.06486124f, -0.11188754f, -0.04190237f, -0.06698088f, -0.03671249f, 
    0.06299619f, 0.09426986f, -0.01578935f, -0.05177660f, -0.15031785f, 0.03776313f, 0.09214935f, -0.02307177f, 
    0.02190355f, -0.05190060f, -0.02475923f, -0.04969914f, -0.16630952f, 0.13090877f, 0.23044413f, 0.08933280f, 
    -0.12166043f, 0.09188840f, -0.35894862f, -0.10066491f, -0.07549861f, 0.10878967f, -0.12393872f, 0.13980778f, 
    -0.02536611f, -0.00467488f, -0.00573804f, -0.07678143f, -0.02634682f, -0.00617688f, -0.33101851f, -0.19342877f, 
    -0.22588810f, -0.40918982f, -0.12577344f, -0.09995840f, 0.26576015f, -0.02393859f, -0.02416902f, 0.04485598f, 
    -0.00365440f, 0.08485638f, -0.02361786f, 0.02058337f, -0.04731271f, -0.04925609f, 0.04326884f, -0.08106857f, 
    -0.11663610f, 0.10435545f, -0.09326836f, 0.09866269f, -0.36087531f, 0.07405879f, -0.10042012f, 0.02420277f, 
    -0.14480044f, 0.05028529f, -0.00206227f, -0.06409207f, 0.02095270f, 0.03070986f, 0.01828788f, -0.01899250f, 
    0.02525589f, 0.01910581f, -0.00109400f, 0.05332425f, 0.08320229f, -0.00119448f, -0.06957047f, -0.04756777f, 
    0.32194996f, 0.14879030f, 0.06717403f, -0.23057112f, -0.03994329f, 0.05222058f, 0.07363383f, 0.11628035f, 
    0.01506320f, 0.10107711f, -0.02812001f, 0.02894261f, -0.05703578f, -0.04723844f, 0.01467991f, -0.00856266f, 
    -0.09872276f, 0.08943359f, -0.05445169f, 0.10132001f, 0.16946203f, 0.16070083f, -0.11513864f, -0.06133772f, 
    -0.03782496f, -0.01403450f, -0.04930381f, -0.01701486f, 0.01246621f, -0.09421764f, -0.05758427f, 0.00751228f, 
    -0.02975393f, -0.01274226f, -0.00936534f, -0.03814611f, -0.06241570f, -0.00520801f, 0.01256850f, -0.03739916f, 
    0.06190858f, 0.16402444f, 0.22559904f, -0.16828260f, -0.21113321f, -0.02880620f, -0.01459627f, 0.03153601f, 
    -0.03106430f, 0.02652855f, -0.02663116f, -0.05037149f, -0.04977162f, 0.00320733f, -0.02271158f, 0.02537165f, 
    -0.00216540f, 0.08348919f, 0.09161826f, 0.05888877f, -0.02903121f, 0.00697226f, 0.12081856f, -0.06203218f, 
    0.01589897f, -0.04097352f, 0.03456851f, -0.00853236f, 0.00231255f, 0.00347180f, 0.06975599f, -0.00106488f, 
    -0.01482785f, -0.07255721f, -0.08491094f, -0.07510466f, -0.00844847f, -0.03951644f, -0.04030235f, -0.04166071f, 
    0.32520792f, 0.29857215f, 0.08163778f, -0.39836413f, -0.09405033f, 0.05235869f, 0.10687755f, 0.00907679f, 
    0.02750618f, 0.02712073f, 0.01779196f, -0.04999962f, -0.01107194f, -0.01014444f, -0.03512909f, 0.02245963f, 
    -0.05763038f, -0.00834491f, 0.04046311f, -0.11376959f, -0.04007476f, 0.24829730f, 0.16317755f, -0.17912973f, 
    -0.06416593f, -0.08519907f, 0.00503484f, -0.04632868f, -0.03122630f, -0.05098432f, -0.00871019f, -0.04930860f, 
    -0.00673638f, 0.01289225f, -0.00693121f, -0.03103769f, -0.01739236f, 0.06521450f, 0.02282849f, 0.10273992f, 
    0.17340170f, 0.28799155f, -0.05408575f, -0.34118950f, -0.13313651f, 0.00537895f, 0.07326166f, -0.12263956f, 
    0.02386753f, 0.16854163f, 0.01974042f, 0.00382969f, 0.02998597f, -0.00834398f, -0.02211745f, -0.03072776f, 
    -0.03532429f, 0.00656785f, -0.05290769f, 0.10464133f, 0.14690135f, -0.26381758f, 0.00681039f, -0.20528874f, 
    0.12233256f, -0.10210176f, -0.03751822f, -0.05078753f, 0.03423457f, 0.00762366f, -0.00371598f, -0.01818278f, 
    -0.00026845f, 0.06493554f, 0.00582540f, 0.01417834f, -0.09171360f, -0.00369971f, -0.06331754f, 0.06755376f, 
    0.21699050f, 0.17213470f, 0.13323586f, -0.18536671f, -0.12172847f, 0.14986508f, 0.16498508f, 0.16289243f, 
    -0.01615038f, 0.15008059f, -0.01884789f, -0.00139026f, -0.03101365f, -0.02316112f, -0.06193200f, -0.04541286f, 
    -0.12273306f, 0.06830549f, 0.18439770f, 0.10142395f, 0.09592376f, 0.05860547f, -0.07759134f, -0.01238741f, 
    -0.00284782f, -0.06411472f, 0.03701034f, -0.12408393f, -0.11944097f, -0.15741333f, 0.01163164f, 0.07724591f, 
    0.02205454f, -0.01385729f, -0.00085534f, -0.04591814f, -0.01363453f, -0.07413356f, -0.06119563f, 0.04364142f, 
    -0.10516828f, -0.07711390f, -0.08895960f, 0.12448037f, 0.00020136f, -0.02262647f, -0.03978333f, -0.01838667f, 
    -0.06647132f, -0.00578227f, -0.09770813f, -0.06713822f, -0.01241159f, -0.06257884f, -0.02329301f, -0.14729548f, 
    0.05975926f, -0.08577437f, -0.12970009f, 0.00502506f, -0.01103432f, -0.26749665f, -0.59071225f, 0.12107473f, 
    0.01240731f, 0.09864020f, -0.01427889f, -0.00837350f, -0.07697807f, 0.00276159f, -0.01793784f, -0.00691364f, 
    -0.08800073f, -0.14342776f, -0.03570279f, 0.00547717f, 0.08028123f, -0.05549391f, 0.00849429f, -0.01379811f, 
    0.01583726f, -0.31645799f, -0.23063344f, 0.12694524f, -0.10859264f, 0.02412796f, 0.06373053f, 0.00750356f, 
    0.01687777f, 0.01885264f, 0.04191991f, 0.02001293f, -0.13194962f, 0.11513398f, 0.01771834f, -0.01633063f, 
    0.09776124f, -0.02531918f, -0.03512297f, -0.09690216f, 0.10547567f, 0.07391503f, -0.03293346f, 0.03635490f, 
    -0.00254684f, 0.02389827f, 0.02152529f, -0.01502312f, 0.01906791f, 0.03376031f, 0.04752424f, 0.02684059f, 
    -0.03595833f, 0.00494858f, 0.03098210f, -0.01679990f, -0.03703585f, -0.00613114f, -0.00977145f, -0.01672165f, 
    0.26241094f, 0.15971571f, 0.07060717f, -0.22094700f, -0.01046033f, -0.05250032f, 0.07113700f, 0.01676450f, 
    -0.07438155f, 0.00769502f, -0.03954552f, -0.03680420f, -0.01209429f, -0.01964102f, 0.01487920f, 0.01415615f, 
    -0.02625554f, 0.01909584f, -0.08144831f, -0.07645681f, -0.11226552f, -0.12685756f, -0.05269694f, -0.00077376f, 
    -0.00743380f, -0.03626547f, -0.03391533f, 0.02290313f, 0.07038957f, 0.01057744f, -0.17615722f, -0.05147951f, 
    -0.09745917f, -0.09622195f, -0.18385784f, -0.03379307f, 0.02639558f, -0.01489172f, 0.00028205f, 0.02559241f, 
    0.05119591f, 0.06544753f, -0.30265087f, 0.13867579f, 0.01981573f, 0.02082589f, -0.03626116f, -0.04810724f, 
    -0.07162599f, -0.07033881f, -0.05808752f, 0.01402333f, -0.07006091f, -0.02535494f, -0.00049913f, -0.08074943f, 
    0.02303886f, -0.07409574f, -0.07984442f, 0.04523575f, 0.24489228f, 0.13713886f, 0.06985030f, -0.20771322f, 
    -0.06998195f, 0.09601926f, 0.15827416f, 0.14249855f, 0.04138257f, 0.02268260f, 0.01664069f, -0.01306776f, 
    -0.00632326f, -0.06194612f, 0.01259213f, 0.00764401f, -0.09362819f, -0.05720182f, -0.12156966f, -0.01353347f, 
    -0.06977651f, 0.13252559f, -0.16327086f, 0.06858668f, 0.01504552f, 0.06209904f, 0.02437957f, 0.01953125f, 
    0.03601078f, -0.02760418f, 0.03396956f, 0.04382084f, 0.02263803f, -0.03260363f, -0.01418575f, -0.01781799f, 
    -0.08926706f, -0.09163367f, -0.08288024f, 0.02197844f, -0.13913348f, -0.07691658f, 0.00005247f, -0.00094041f, 
    0.17975533f, -0.01859181f, -0.01968918f, -0.01701252f, -0.01747853f, -0.00619023f, 0.05656321f, 0.02328599f, 
    0.05487836f, -0.10460535f, 0.10007749f, 0.15498227f, 0.11981797f, 0.04366849f, -0.00261343f, 0.00691932f, 
    -0.10736743f, -0.01166997f, -0.21217079f, -0.04830059f, 0.08835983f, 0.20795572f, -0.10975985f, -0.02936459f, 
    0.07087731f, -0.07122350f, 0.04449600f, 0.03524114f, 0.07611636f, -0.04546689f, 0.07872742f, -0.14250730f, 
    -0.01798011f, 0.02655038f, -0.23655553f, -0.25228262f, -0.01070250f, -0.06851687f, 0.05417791f, -0.03556586f, 
    -0.01368049f, -0.03562801f, 0.03233746f, 0.00481764f, -0.00981191f, 0.04555241f, 0.14611611f, 0.04301389f, 
    0.02056968f, 0.04027165f, -0.01176325f, -0.08253714f, -0.02287563f, -0.03794004f, 0.04353960f, 0.02857142f, 
    -0.07591563f, 0.10362546f, -0.15709011f, -0.13126297f, 0.10619519f, -0.19092159f, 0.13321483f, -0.10356725f, 
    0.01139817f, 0.04730480f, -0.07625129f, -0.08631849f, -0.02433293f, 0.14975949f, 0.01770268f, 0.01974231f, 
    -0.08496092f, 0.08575252f, 0.06311352f, -0.08090145f, 0.06208896f, -0.00786256f, 0.12247007f, 0.01720670f, 
    -0.03893843f, -0.04735258f, -0.01600636f, -0.07806096f, 0.01436640f, 0.00279329f, 0.03448086f, -0.05788799f, 
    -0.04191970f, 0.03440047f, 0.03053910f, -0.02137708f, 0.08497284f, -0.06730781f, 0.06541930f, -0.02408659f, 
    0.33621433f, 0.19240165f, -0.33849600f, 0.02240544f, -0.21924157f, -0.03661023f, 0.01873560f, -0.08919793f, 
    -0.12750335f, 0.21801984f, 0.04143673f, 0.00640293f, -0.02121269f, -0.04562372f, 0.10147689f, -0.05357251f, 
    0.00660631f, -0.03733576f, 0.04209226f, 0.19098531f, 0.15122975f, 0.08006895f, 0.04887158f, 0.05750128f, 
    0.16366263f, -0.04466860f, -0.00988638f, 0.03003497f, -0.01236145f, -0.03912818f, -0.00086048f, 0.00709449f, 
    -0.04377895f, -0.01322286f, -0.00217104f, 0.10638758f, -0.00177385f, -0.01536185f, 0.08640748f, 0.07924702f, 
    0.03451064f, 0.05124643f, 0.25132668f, 0.01911216f, -0.26402560f, 0.00895899f, -0.06058136f, -0.03664866f, 
    0.01119643f, -0.19740692f, 0.14058514f, -0.07559881f, -0.11764094f, -0.24352811f, 0.01363159f, 0.03015144f, 
    -0.05786675f, -0.13732055f, 0.07549281f, 0.02181297f, -0.07141786f, -0.21517470f, -0.17898028f, -0.02425926f, 
    -0.07430453f, -0.03198090f, -0.02003193f, 0.03736243f, -0.06569277f, -0.09952158f, -0.09393973f, 0.05505703f, 
    -0.02017792f, -0.01448237f, -0.01112569f, -0.01220104f, 0.01313973f, -0.00538808f, -0.00828533f, 0.01202062f, 
    0.81258392f, 0.24601085f, -0.04598645f, 0.16546850f, 0.19634761f, -0.04178715f, -0.00959831f, -0.01033790f, 
    -0.02629495f, -0.00073405f, -0.00402146f, -0.01685381f, -0.02721997f, -0.00954897f, 0.05401167f, 0.04840327f, 
    -0.14647143f, 0.06501619f, 0.01303781f, -0.01488957f, 0.09318893f, -0.15245877f, -0.16880725f, -0.05082727f, 
    -0.03096678f, 0.01523493f, -0.00038062f, 0.07362305f, 0.01514323f, -0.14165476f, -0.06021396f, -0.08320606f, 
    0.02662249f, 0.01248201f, 0.00319569f, -0.00690363f, -0.02691736f, -0.00341562f, 0.03999556f, 0.01407264f, 
    0.41285381f, -0.09030647f, -0.04031326f, -0.01004072f, 0.07518272f, -0.02209015f, -0.04399008f, 0.02705319f, 
    0.08628814f, -0.12338158f, 0.16857533f, -0.07593741f, -0.01516077f, -0.12143712f, -0.19937012f, -0.01201988f, 
    -0.08471145f, -0.02337406f, 0.02431592f, -0.04512108f, -0.00541955f, -0.40791401f, 0.26326337f, 0.08417843f, 
    0.22178283f, -0.02776387f, 0.02359785f, 0.02734107f, -0.03323511f, -0.01392123f, 0.17401013f, 0.03742900f, 
    0.11347467f, -0.03949512f, -0.09069993f, 0.28360173f, 0.00083693f, -0.12451188f, 0.06646928f, -0.11813621f, 
    -0.21099463f, -0.11516381f, -0.10490983f, 0.03062959f, -0.40219337f, 0.05487204f, -0.14984427f, -0.17215465f, 
    -0.09226627f, 0.14707403f, -0.07985893f, 0.01118250f, 0.04277752f, 0.09400065f, -0.05070060f, 0.00419974f, 
    0.01880050f, -0.04737465f, -0.05444266f, -0.04615962f, 0.31195486f, 0.01017640f, -0.23515411f, 0.04074572f, 
    -0.38647243f, 0.12131561f, -0.06302997f, -0.11452657f, 0.01516530f, -0.03282136f, 0.02900919f, -0.01832082f, 
    0.06401183f, 0.07838562f, -0.00316221f, -0.03220276f, -0.10036297f, -0.18150695f, -0.00683582f, 0.02802678f, 
    0.06103457f, 0.03518106f, -0.06522670f, -0.05268767f, -0.10040705f, -0.12634724f, 0.05200877f, 0.04793132f, 
    -0.07688669f, 0.04194469f, 0.00029125f, -0.02759718f, -0.01969477f, 0.01626983f, -0.04729880f, -0.02033393f, 
    0.01297615f, -0.06346721f, 0.01116221f, 0.06159684f, 0.26635140f, 0.04517290f, -0.07531097f, -0.09976577f, 
    -0.06607043f, -0.04532170f, -0.03698589f, -0.17276391f, -0.10643914f, 0.04928706f, 0.00114179f, 0.01304441f, 
    0.02076594f, -0.00457606f, -0.02141027f, 0.02098530f, 0.19038856f, -0.24963127f, 0.03861225f, 0.06642747f, 
    -0.26427028f, -0.39626482f, 0.00657603f, 0.01049514f, 0.08648510f, 0.08305293f, -0.02874215f, 0.04343340f, 
    0.04809850f, 0.00289378f, -0.01472653f, 0.05744349f, 0.00290614f, -0.00998556f, -0.11757727f, 0.10632098f, 
    0.05284197f, 0.03369628f, 0.12113605f, 0.02072892f, -0.54959035f, 0.13631223f, -0.06822108f, 0.15938595f, 
    -0.01737011f, -0.00957973f, 0.01846863f, 0.23533200f, -0.09419690f, 0.00392883f, -0.02700650f, -0.02475037f, 
    0.07978237f, 0.03993378f, -0.13700616f, -0.00481893f, 0.10130049f, 0.05124216f, -0.16375543f, 0.04734539f, 
    -0.17301199f, -0.03536512f, -0.06780989f, 0.07959609f, -0.13727790f, 0.06255639f, 0.16003948f, 0.21917386f, 
    -0.15808989f, -0.04810051f, -0.00540116f, -0.01601879f, 0.05766930f, -0.00447287f, 0.01244153f, -0.01065243f, 
    0.00350382f, -0.01785701f, -0.06209968f, 0.02042804f, 0.00595753f, -0.08053320f, 0.03616695f, -0.04716871f, 
    0.01880295f, 0.07970881f, -0.03980063f, -0.15143827f, -0.00042221f, 0.05184593f, -0.03655585f, -0.04609686f, 
    0.02759223f, 0.06036182f, 0.02636593f, -0.06179951f, 0.04117894f, -0.15886383f, 0.08944978f, 0.04952004f, 
    0.03092744f, 0.00797121f, 0.07661787f, 0.04269002f, 0.09634259f, 0.02624665f, -0.00702540f, 0.03669904f, 
    0.03966647f, -0.01836252f, -0.04520318f, 0.02464569f, 0.03271073f, 0.01106986f, -0.08914104f, 0.12132605f, 
    0.08109079f, -0.00453376f, -0.04100683f, -0.05193861f, -0.04334173f, 0.06598078f, -0.07857313f, -0.06661624f, 
    0.11683162f, 0.01832086f, 0.05799605f, -0.03471180f, 0.10646260f, 0.15585168f, -0.01750567f, -0.06554994f, 
    0.05341513f, 0.00113088f, 0.02819101f, 0.02566864f, -0.02210681f, -0.10074058f, -0.10116667f, -0.17012607f, 
    0.15910122f, 0.03712618f, 0.02875943f, 0.07293319f, 0.09674881f, -0.01645325f, -0.00309489f, -0.01904017f, 
    -0.03592316f, -0.01711823f, 0.02204822f, 0.02430999f, -0.02614627f, 0.00589317f, 0.02323029f, -0.02025759f, 
    0.03912754f, -0.00766891f, 0.02000864f, -0.05412814f, 0.06853898f, 0.07164640f, 0.05522901f, 0.09940338f, 
    0.05928454f, 0.00229004f, -0.04548505f, -0.01164092f, -0.04909987f, -0.04592716f, 0.05266140f, 0.10158794f, 
    -0.00620078f, 0.01426765f, 0.07776682f, -0.07629602f, -0.05763018f, -0.12745467f, -0.01494622f, -0.03842016f, 
    0.28736928f, 0.23140767f, -0.18565981f, 0.21211325f, -0.13982770f, -0.18120016f, 0.20884490f, -0.04285277f, 
    -0.14217038f, 0.09535026f, -0.01141149f, -0.10266361f, 0.06146887f, 0.04718319f, -0.11489329f, -0.04683304f, 
    0.06498384f, -0.00616049f, -0.05210061f, -0.02037163f, -0.72875404f, 0.04814693f, -0.18572354f, -0.12560847f, 
    0.24281929f, 0.03060820f, 0.01533091f, 0.01883985f, 0.13657334f, 0.05862908f, -0.04443194f, 0.02636096f, 
    -0.00013336f, -0.02222790f, -0.08218541f, 0.02569074f, -0.01649098f, 0.03906040f, -0.01224028f, -0.02545443f, 
    0.65423483f, -0.18831514f, 0.19812986f, 0.02657951f, -0.09359668f, 0.02644396f, 0.06638506f, 0.05849531f, 
    0.02882958f, -0.17787094f, 0.11003160f, -0.17869952f, 0.11752367f, -0.13365968f, -0.05582765f, 0.04156230f, 
    0.03227580f, -0.08456043f, 0.00127332f, -0.00336929f, -0.30349031f, 0.05818546f, -0.13634782f, -0.03952455f, 
    0.10303961f, -0.02557435f, 0.13043682f, 0.02535561f, -0.09189793f, 0.04109331f, -0.04298456f, -0.03400132f, 
    0.00875041f, 0.01273152f, 0.01052576f, 0.03012868f, 0.00822384f, -0.01482820f, -0.02486588f, 0.06820811f, 
    0.01262081f, -0.08594308f, 0.01652501f, 0.02538021f, -0.04742675f, -0.02890327f, -0.01194715f, -0.03008032f, 
    0.05428677f, -0.01828707f, 0.09405618f, 0.08637059f, -0.00069344f, 0.05450808f, -0.01489651f, -0.06431100f, 
    0.02557785f, 0.01033211f, 0.04383149f, 0.02525453f, 0.08252339f, 0.03867113f, 0.03500782f, -0.14144647f, 
    0.23407625f, 0.10624814f, -0.07762245f, -0.02569557f, 0.01668463f, 0.04422244f, 0.06397740f, 0.02404481f, 
    0.05389059f, -0.03343535f, 0.03111096f, -0.06218954f, -0.16849522f, -0.05229102f, -0.00513279f, -0.12710977f, 
    -0.20484790f, -0.14051019f, 0.05722964f, -0.00986592f, 0.02061857f, -0.04424768f, 0.01736379f, 0.06735732f, 
    0.05699811f, 0.05603670f, 0.05995517f, 0.10378205f, -0.00857769f, 0.07708631f, 0.01552715f, -0.04346365f, 
    0.07941572f, 0.02576073f, -0.00020847f, 0.04187592f, -0.04231983f, -0.34883180f, -0.02702905f, -0.30362952f, 
    -0.11633301f, -0.04430189f, 0.16405815f, -0.15897912f, 0.07229923f, 0.12024315f, 0.07669626f, 0.03011013f, 
    -0.08241241f, 0.16297276f, -0.03098875f, 0.01353183f, 0.05433723f, -0.07614756f, 0.08643028f, -0.00751467f, 
    -0.63257432f, -0.36078197f, -0.06700506f, -0.22530688f, 0.01727486f, 0.06415705f, -0.06626025f, -0.00035913f, 
    -0.06977936f, -0.05617256f, 0.12371375f, 0.01547922f, 0.01997020f, -0.04740867f, 0.02111373f, 0.03550022f, 
    -0.11797272f, 0.01222601f, -0.06583145f, -0.29953614f, 0.19847293f, 0.11538134f, 0.09347695f, 0.09464778f, 
    0.15419915f, -0.05280821f, -0.04970934f, 0.00180585f, -0.03837302f, -0.00915943f, -0.01088196f, 0.00220501f, 
    0.00303841f, -0.00095111f, -0.00062457f, -0.08175148f, 0.05834160f, 0.01092785f, -0.04074440f, -0.07013071f, 
    0.27491453f, 0.07758154f, 0.02920185f, 0.02773739f, 0.06809224f, 0.01486513f, -0.03244427f, -0.01505949f, 
    -0.01548902f, -0.05865404f, -0.10996256f, 0.05556460f, -0.05706863f, 0.04232860f, 0.05726469f, -0.02120895f, 
    -0.05109270f, -0.00075252f, 0.00734593f, -0.04592605f, -0.76087499f, -0.13860154f, -0.18045366f, -0.16595909f, 
    -0.04900450f, 0.00336084f, 0.00670570f, 0.08684688f, -0.06928026f, -0.14285940f, -0.08673652f, 0.08851955f, 
    0.00708593f, 0.01795748f, -0.02198264f, 0.03418144f, 0.03180052f, 0.00696171f, -0.04931585f, -0.00533800f, 
    0.22747526f, 0.03394702f, 0.06173313f, 0.01307881f, 0.01300085f, -0.04498231f, -0.02625983f, -0.02092049f, 
    0.03571797f, -0.00751953f, -0.01102153f, 0.01376882f, 0.06591912f, -0.05487061f, -0.00352179f, 0.20880096f, 
    -0.10820159f, 0.05624481f, 0.07623996f, -0.00194139f, -0.01406885f, -0.18761693f, 0.29632109f, -0.13158530f, 
    -0.04942928f, 0.07067917f, -0.06454030f, -0.01333739f, -0.03939240f, -0.00346977f, -0.03950698f, -0.02888762f, 
    0.00274301f, 0.04365680f, -0.04120899f, -0.03146211f, 0.10777480f, -0.08222270f, 0.08736715f, 0.00988043f, 
    -0.00228602f, 0.17590351f, 0.00680779f, 0.28541905f, 0.20950904f, -0.08246259f, 0.02254264f, -0.06895152f, 
    0.02830551f, -0.09531527f, -0.03065646f, 0.01585326f, 0.02916435f, -0.04905409f, 0.06608230f, 0.01094004f, 
    0.01655565f, 0.09372722f, -0.19164748f, 0.01556660f, 0.04797721f, 0.30634791f, -0.14842041f, -0.07245303f, 
    0.08474835f, -0.13381866f, -0.04347186f, -0.00413013f, -0.36770806f, 0.07632933f, -0.05573340f, -0.00824022f, 
    -0.00396157f, 0.00139685f, -0.01490921f, 0.13753927f, 0.06294592f, 0.05861412f, 0.01299458f, 0.11283176f, 
    -0.24341172f, -0.07717733f, 0.18002085f, 0.02046359f, -0.18910851f, 0.04483699f, 0.09047397f, -0.03859332f, 
    -0.00320505f, -0.01144090f, -0.01800897f, -0.00496140f, -0.02855975f, 0.20628403f, -0.09000371f, -0.15555733f, 
    -0.05956432f, 0.00125326f, -0.06084739f, -0.00909969f, 0.12710108f, -0.11128929f, 0.00850344f, 0.04940999f, 
    -0.11304869f, -0.20739870f, 0.05719481f, 0.29329818f, 0.17060363f, 0.00575375f, -0.09531735f, 0.02789506f, 
    0.08092900f, -0.04399937f, 0.01539747f, 0.01468707f, -0.13571429f, -0.00919607f, -0.02307059f, -0.07527718f, 
    0.67604178f, 0.29869106f, -0.05944453f, 0.18753381f, 0.16516656f, -0.01225010f, -0.01765007f, -0.05694153f, 
    -0.05737369f, 0.02283151f, -0.05518444f, -0.05686504f, -0.09064457f, 0.00145834f, -0.00484668f, -0.05301286f, 
    0.03671345f, 0.05187882f, -0.09271835f, -0.04053159f, 0.41178128f, -0.02314851f, -0.04196474f, -0.16981876f, 
    -0.13361253f, -0.07365919f, -0.03902579f, -0.06710523f, -0.07578433f, -0.05536961f, -0.01322755f, -0.00047567f, 
    0.03875970f, 0.02873661f, 0.01720334f, -0.00831988f, 0.02588846f, -0.16682616f, 0.06546330f, 0.07231972f, 
    0.24943914f, 0.21596992f, 0.21830691f, 0.04595390f, 0.04497493f, 0.09032208f, -0.10912950f, -0.03726877f, 
    0.30710706f, 0.04871657f, 0.06487796f, -0.03638842f, 0.04160600f, -0.00289932f, -0.03080122f, 0.05545244f, 
    -0.08824998f, -0.23189695f, 0.08810624f, -0.05914179f, -0.12045202f, -0.05884096f, -0.15075761f, 0.00532420f, 
    -0.09157799f, 0.12295823f, 0.09349352f, 0.03755713f, 0.02031556f, -0.01271431f, 0.10248485f, -0.01683779f, 
    0.08702477f, 0.03430618f, 0.01439951f, -0.01588471f, -0.03790235f, -0.00829737f, -0.03328224f, 0.01898154f, 
    -0.06681433f, 0.14316016f, -0.04342835f, -0.08786947f, -0.25360432f, 0.02520220f, -0.01208590f, 0.01258634f, 
    -0.09598678f, 0.00760529f, -0.03442700f, 0.01096329f, 0.03408593f, -0.02168787f, 0.03240184f, -0.19327357f, 
    -0.11783274f, -0.03031726f, -0.14108036f, -0.25488091f, -0.09965856f, -0.00491297f, -0.01312230f, -0.08356598f, 
    0.07266062f, 0.01868084f, -0.04135017f, -0.02394218f, 0.01779769f, -0.03097954f, -0.04448546f, -0.02806183f, 
    0.08585566f, 0.09764788f, 0.01864653f, -0.11059145f, 0.00971455f, 0.04924326f, 0.02500402f, 0.03774041f, 
    -0.30053556f, 0.15205657f, -0.09903065f, 0.33190525f, 0.11625863f, -0.08314852f, 0.01874159f, -0.08163674f, 
    0.14964615f, -0.00140480f, -0.05427753f, 0.02100524f, 0.01934908f, 0.01731280f, 0.02748856f, -0.00438202f, 
    0.00529092f, 0.05702528f, -0.24589789f, 0.03098225f, -0.28374708f, -0.08222816f, -0.28562689f, -0.36274034f, 
    -0.36893666f, 0.01813881f, -0.12969908f, -0.15238799f, -0.02116271f, 0.02128691f, -0.02967635f, 0.02493163f, 
    0.01659816f, 0.00350870f, 0.03099677f, -0.01375425f, -0.10700849f, -0.08819593f, -0.12759826f, -0.20223175f, 
    -0.19337046f, 0.09784073f, -0.21798345f, -0.10129546f, -0.00002865f, -0.06671458f, -0.16476382f, -0.30927914f, 
    0.14270388f, -0.20142916f, -0.00330885f, -0.02290311f, -0.04611143f, 0.07826511f, 0.08541995f, 0.01121422f, 
    0.00415102f, 0.04081062f, 0.05949018f, -0.17935644f, 0.17354320f, 0.06199399f, -0.12926850f, 0.05328213f, 
    0.19950135f, -0.01907885f, -0.05287785f, -0.10418056f, 0.01809087f, 0.04204169f, 0.07206866f, 0.01897321f, 
    -0.04880699f, -0.08206156f, 0.13639161f, 0.02274059f, -0.02974761f, -0.07419835f, 0.09613833f, -0.14278932f, 
    0.04753844f, 0.19616614f, 0.04023871f, 0.16022934f, -0.17302674f, 0.08896883f, -0.12712453f, -0.14026321f, 
    -0.16689947f, -0.06900194f, 0.00249184f, -0.00111169f, 0.04952102f, 0.00239213f, 0.03863172f, -0.06262973f, 
    -0.01742914f, 0.07829251f, -0.27095070f, 0.02361566f, 0.02505685f, 0.01102378f, -0.17717715f, -0.06214821f, 
    -0.07099161f, 0.06643539f, 0.04126316f, -0.01389650f, -0.11267568f, 0.09679531f, 0.05786595f, 0.07899775f, 
    0.03577803f, 0.01575293f, 0.03490263f, -0.05700523f, 0.02931674f, 0.00489984f, 0.17159039f, 0.08257693f, 
    0.36851645f, 0.04018637f, -0.05299619f, -0.00096783f, -0.01712005f, 0.06019543f, 0.01311376f, -0.02161001f, 
    -0.02814289f, -0.00832629f, -0.11140829f, 0.14994588f, 0.12798646f, 0.12482699f, 0.00206043f, 0.11221401f, 
    0.04330504f, 0.01434300f, 0.07279593f, 0.04510490f, 0.90004426f, -0.18046021f, -0.11881519f, 0.02502691f, 
    -0.12971598f, -0.01111706f, 0.02864734f, -0.02733354f, 0.00459990f, -0.03420919f, 0.13762826f, -0.10315942f, 
    0.04347550f, -0.08611111f, -0.04426507f, 0.06879178f, -0.00155872f, -0.14355887f, 0.02451008f, 0.05366575f, 
    0.02488351f, -0.09383170f, 0.27188912f, 0.03202058f, -0.19227280f, -0.01922687f, -0.01261307f, 0.04386538f, 
    -0.03443618f, 0.02732325f, 0.00016456f, -0.10787386f, -0.05982787f, -0.01148240f, -0.06651632f, 0.15766597f, 
    -0.09286275f, -0.13331999f, -0.03904982f, -0.02142700f, -0.05585865f, -0.05739568f, -0.05092298f, -0.01962077f, 
    0.02024436f, -0.01858084f, 0.01935479f, 0.02161649f, 0.06217705f, -0.00258201f, -0.09138832f, 0.02543034f, 
    -0.01043247f, 0.01333943f, 0.01779806f, -0.06728188f, 0.02344337f, 0.04803969f, 0.00567926f, 0.03397425f, 
    -0.17947815f, 0.15500510f, -0.01884671f, 0.01309457f, 0.02771892f, -0.01900740f, 0.11892384f, 0.04323398f, 
    0.05184936f, -0.11532426f, -0.02170800f, 0.00469396f, 0.02776464f, -0.08080947f, -0.02947719f, 0.01976843f, 
    0.10881564f, 0.03782424f, -0.10241815f, 0.00577876f, 0.07942209f, -0.04670442f, 0.04553337f, 0.09871142f, 
    0.09972601f, -0.01959621f, 0.05216480f, -0.03836438f, 0.02706489f, -0.02104255f, 0.06015313f, -0.03865213f, 
    -0.05734934f, 0.02943811f, 0.14381976f, -0.03451579f, -0.06888182f, -0.05524895f, -0.01039063f, -0.04140002f, 
    0.33085179f, -0.02439415f, -0.19291753f, 0.04234133f, -0.14305712f, 0.03134662f, 0.03710838f, 0.02360914f, 
    -0.06572870f, 0.01952632f, 0.15852463f, 0.10075914f, 0.03432256f, 0.00671735f, 0.05941349f, 0.00163934f, 
    0.02403126f, 0.02113008f, 0.07114420f, 0.10115192f, 0.25003299f, 0.23695500f, 0.23521113f, 0.12637839f, 
    -0.00569510f, 0.06907948f, -0.08981423f, -0.00479169f, 0.11070584f, -0.05590132f, 0.00219516f, -0.00568734f, 
    -0.00636006f, -0.08498200f, -0.00713695f, 0.01210581f, 0.03365542f, -0.02237160f, -0.09261636f, -0.00804177f, 
    -0.10247099f, 0.15713182f, -0.13639258f, 0.01137465f, 0.05334708f, 0.05235009f, 0.00912320f, -0.02054785f, 
    0.01638353f, -0.07591756f, 0.03504150f, 0.06336023f, 0.02554599f, -0.05830076f, 0.03892444f, 0.06019570f, 
    0.09652331f, 0.18449570f, 0.11522877f, 0.01477474f, 0.14824717f, 0.06882164f, -0.26540393f, -0.10570720f, 
    0.13390738f, 0.03219744f, 0.00766526f, -0.01551799f, -0.00522605f, -0.03967338f, 0.00730400f, 0.04103217f, 
    0.02397497f, -0.03910444f, 0.01265847f, -0.01946537f, -0.00402857f, 0.07992637f, 0.00212264f, -0.02315848f, 
    0.05806066f, -0.00501394f, -0.07615672f, -0.04788905f, 0.00393675f, 0.01807693f, 0.00100211f, -0.03421636f, 
    0.06503923f, 0.02657103f, -0.04137043f, 0.02791468f, -0.00914767f, -0.00036927f, -0.03040932f, -0.02640034f, 
    0.03551534f, 0.06371399f, 0.04753472f, 0.05806442f, 0.00563108f, 0.05295186f, -0.00548421f, 0.04378950f, 
    0.06562035f, 0.02734707f, 0.03057749f, 0.02671108f, 0.00678067f, 0.02168456f, -0.03773255f, 0.00409391f, 
    -0.06243248f, 0.02062300f, 0.02368602f, 0.01295525f, -0.06802332f, -0.00726683f, -0.00335957f, -0.01867521f, 
    -0.19498993f, 0.16379304f, -0.14919670f, 0.09417296f, -0.06610725f, -0.09553245f, -0.03141429f, -0.29794610f, 
    -0.07866946f, -0.11685462f, 0.09585129f, -0.00626555f, -0.00006839f, 0.05235440f, 0.00857612f, 0.01633474f, 
    0.04972029f, -0.10375828f, -0.01485696f, 0.02356222f, -0.08922877f, -0.13969126f, 0.10744833f, -0.06952728f, 
    -0.07647797f, 0.01351114f, -0.00855305f, -0.05547269f, -0.01357452f, 0.05354289f, 0.06103756f, -0.01287542f, 
    -0.01434768f, 0.04898174f, -0.05894225f, 0.02131111f, -0.10021665f, -0.10049179f, 0.01119488f, -0.00773334f, 
    -0.30838600f, 0.29905498f, -0.00004238f, 0.08130751f, -0.41926894f, -0.08140884f, 0.13683946f, -0.12156483f, 
    -0.04619152f, 0.02397481f, 0.01671441f, 0.05983900f, -0.02960929f, 0.00045116f, -0.05095643f, -0.01037484f, 
    -0.01375263f, -0.00488241f, 0.01921985f, -0.01238244f, -0.11993692f, -0.08774963f, -0.11046222f, -0.08278737f, 
    -0.08315098f, -0.00641350f, -0.01599276f, 0.00775717f, -0.02147772f, 0.03129876f, 0.00876829f, -0.00824751f, 
    -0.01327804f, 0.00954256f, 0.00790597f, -0.02298007f, 0.01381796f, 0.09898427f, 0.04617424f, -0.07726132f, 
    -0.31399965f, -0.32032719f, 0.68829203f, 0.15103140f, 0.16780439f, -0.08837075f, -0.05139668f, 0.04711818f, 
    -0.10091676f, -0.10767572f, 0.06306662f, 0.02484486f, 0.00520862f, -0.14838763f, 0.04633462f, 0.04407620f, 
    0.05349006f, 0.02226595f, 0.05191994f, -0.05572768f, 0.03683567f, 0.13902944f, 0.23367867f, 0.05396152f, 
    0.19074245f, -0.03251000f, -0.01585250f, 0.00783581f, 0.03783016f, -0.07396699f, 0.03671798f, -0.02897634f, 
    -0.09731912f, 0.01163751f, 0.06741295f, 0.01820507f, -0.02135671f, -0.01676654f, -0.03611635f, -0.03816377f, 
    -0.41033804f, -0.25522780f, 0.01144780f, -0.20894280f, -0.49507236f, 0.00661664f, -0.00904945f, -0.03984455f, 
    0.03566099f, 0.05253002f, -0.03188347f, 0.02439405f, -0.00152550f, 0.01183581f, -0.00566035f, 0.12074418f, 
    -0.07090471f, 0.14022563f, 0.10516978f, -0.07266393f, 0.07043692f, -0.05024251f, 0.09882859f, -0.00479117f, 
    0.03432053f, 0.00669101f, -0.09166043f, 0.01036941f, 0.11920834f, -0.23384941f, -0.04617646f, -0.06871260f, 
    0.08924603f, -0.00459046f, 0.02638094f, -0.01237522f, -0.04411010f, -0.04739901f, 0.04433955f, -0.07096170f, 
    -0.02188925f, -0.47665206f, 0.67938352f, 0.19560367f, 0.29820400f, -0.08402962f, -0.14709295f, -0.03402701f, 
    0.26114085f, -0.17888480f, 0.00169108f, 0.02639168f, 0.02130760f, -0.09790368f, 0.02970703f, 0.02497431f, 
    -0.04381104f, -0.00451353f, 0.01985053f, -0.02937862f, -0.01450238f, -0.05685994f, 0.06733030f, -0.03551622f, 
    0.19390893f, -0.00866107f, 0.01040374f, -0.03428414f, 0.02809678f, -0.01810990f, -0.01365301f, -0.06846567f, 
    0.06756138f, -0.06398260f, 0.06358247f, 0.03562431f, 0.06727327f, 0.00547575f, -0.01908763f, -0.00959621f, 
    -0.06336828f, -0.20452829f, 0.37246761f, -0.15372160f, 0.05546951f, 0.05591157f, -0.03121518f, -0.08342733f, 
    0.04899802f, -0.10208807f, -0.02039946f, 0.01700821f, 0.02409858f, -0.00929047f, -0.00099991f, 0.07531221f, 
    -0.04049103f, -0.09690416f, 0.00942872f, 0.10223489f, -0.27384156f, 0.36358690f, 0.11169590f, 0.11023372f, 
    -0.45254758f, 0.00422208f, -0.03682228f, -0.04273589f, -0.10119179f, 0.08066660f, 0.01837490f, 0.00174839f, 
    0.00884981f, -0.08531807f, -0.01254214f, 0.08459792f, 0.08416576f, 0.13914950f, 0.08507615f, 0.15546383f, 
    0.03819469f, 0.04393933f, 0.19512549f, -0.05765079f, 0.18504612f, -0.00632443f, 0.01779718f, -0.00125263f, 
    0.00257419f, 0.06119576f, 0.05291805f, 0.09612639f, -0.06689752f, 0.01993641f, 0.10652146f, 0.03076207f, 
    0.00774294f, -0.01154071f, 0.04516530f, -0.00502614f, -0.22921827f, -0.07353234f, 0.20480910f, -0.20886733f, 
    0.06623677f, -0.05740536f, 0.05978331f, -0.06304511f, -0.02759767f, 0.05551909f, 0.03401325f, 0.00467130f, 
    0.00935772f, 0.03902563f, 0.02097736f, 0.06559939f, -0.12056889f, -0.02196878f, -0.03489374f, -0.03940796f, 
    0.47722954f, 0.11915160f, -0.21681279f, -0.04893479f, 0.12550548f, -0.06577809f, 0.08170885f, -0.06595872f, 
    -0.04872210f, 0.11055932f, -0.05879965f, -0.00894141f, -0.00771685f, 0.06473609f, -0.12220640f, 0.05935155f, 
    -0.01947366f, 0.02778885f, -0.01495409f, 0.03778077f, 0.31075856f, 0.27478048f, -0.16674027f, 0.10381092f, 
    0.15382877f, -0.08562435f, -0.05541139f, -0.07340540f, -0.15585110f, 0.01134751f, -0.00418389f, 0.03910617f, 
    0.07071580f, -0.12647425f, -0.03411613f, -0.04608069f, 0.02968410f, 0.05815489f, 0.03011580f, -0.06475254f, 
    0.08404564f, -0.01951360f, 0.19863527f, 0.15717168f, 0.12852705f, -0.05179785f, -0.15653609f, -0.03928602f, 
    0.04097379f, -0.12657109f, -0.02202874f, 0.05256195f, 0.04287057f, 0.01659749f, 0.03277654f, -0.03099901f, 
    -0.03246825f, -0.01377089f, -0.04456397f, -0.06488179f, -0.05793647f, -0.02114407f, 0.12237363f, -0.05705662f, 
    0.06682378f, -0.01434004f, -0.03440643f, -0.25908419f, -0.09002476f, 0.05187026f, 0.00736964f, -0.03382606f, 
    0.00396790f, -0.00929262f, -0.02309085f, 0.03476663f, -0.03529260f, -0.03283329f, -0.03245988f, 0.00050486f, 
    -0.00609519f, 0.08927416f, -0.01899265f, -0.04168318f, 0.07662222f, 0.03798630f, -0.04181384f, 0.02045930f, 
    0.05837481f, 0.04088479f, -0.02249430f, 0.02888857f, 0.12122721f, -0.06240341f, 0.09629781f, -0.01693044f, 
    -0.01760806f, -0.03700610f, 0.06356513f, -0.00557051f, 0.20880802f, -0.28434432f, 0.04603782f, -0.02920373f, 
    -0.08725192f, 0.01259909f, 0.08682561f, 0.05513142f, 0.04698994f, 0.02630224f, 0.02449120f, -0.03593139f, 
    0.00177892f, -0.07024855f, 0.05310160f, 0.01619032f, 0.02801884f, -0.08722027f, 0.13725555f, 0.04961351f, 
    -0.00853217f, 0.03444659f, 0.01172479f, -0.36084071f, 0.13618094f, 0.03924036f, -0.04590420f, -0.03827243f, 
    0.02090701f, 0.05635656f, 0.00306890f, 0.00030444f, 0.00676987f, 0.01874915f, -0.00042788f, 0.04929624f, 
    0.01004832f, -0.02754864f, 0.03784154f, -0.00177851f, -0.06371610f, -0.08082683f, -0.10858995f, -0.06796560f, 
    0.02176976f, -0.01241239f, -0.00263140f, 0.00757810f, 0.02278743f, 0.04130394f, -0.04301446f, -0.12051117f, 
    0.00547133f, 0.02160258f, 0.03027900f, 0.03466205f, 0.01615442f, -0.03671768f, 0.00191581f, 0.00979057f, 
    0.00300151f, 0.31674001f, 0.04135741f, 0.23121846f, 0.01763519f, -0.01250966f, -0.03385337f, 0.00267950f, 
    -0.08048435f, 0.13522446f, 0.03530763f, 0.02033247f, 0.04910553f, -0.05214681f, -0.04484990f, 0.05664390f, 
    0.01756132f, -0.04996724f, 0.00444472f, 0.02276414f, 0.30058613f, 0.18147488f, -0.48759380f, 0.08963758f, 
    0.06452618f, 0.07014623f, 0.04464210f, 0.00055872f, 0.10082205f, 0.11089113f, 0.00457726f, 0.00248632f, 
    0.06293079f, 0.02001900f, -0.02688442f, 0.03373174f, 0.03994953f, 0.03293296f, -0.17101018f, 0.09757718f, 
    -0.02779298f, 0.10683926f, 0.24337670f, -0.00305773f, 0.01536382f, -0.01768578f, -0.01769628f, 0.06272800f, 
    -0.02640259f, 0.02814934f, 0.00497502f, 0.02459903f, 0.04932649f, -0.11119965f, 0.01404557f, -0.00086536f, 
    0.02242758f, 0.04864897f, 0.05600112f, -0.09836528f, -0.01843870f, -0.08060109f, -0.04794694f, -0.06202391f, 
    0.07633100f, 0.03680794f, 0.03847624f, -0.10320543f, 0.06449317f, 0.05140079f, -0.00717454f, 0.08431206f, 
    -0.05399608f, 0.05718475f, 0.02039537f, 0.00204882f, -0.00799842f, -0.02660905f, 0.00348012f, 0.04670780f, 
    -0.02973699f, 0.00762541f, 0.01152932f, 0.00516274f, 0.05698644f, 0.01765903f, -0.04396290f, -0.02332688f, 
    -0.00121034f, -0.00618271f, -0.02257186f, -0.05612643f, 0.00333335f, 0.02463228f, 0.08895425f, -0.00852443f, 
    -0.03063119f, -0.02584575f, 0.04880396f, -0.02958502f, -0.13864474f, 0.02796938f, -0.03809320f, 0.22522120f, 
    0.23988158f, -0.08056054f, -0.00080330f, -0.03260599f, 0.06362325f, -0.01802021f, 0.02870942f, -0.02850178f, 
    -0.01505619f, -0.01585829f, -0.02828569f, 0.06196168f, 0.12569477f, 0.10294631f, -0.05307665f, 0.14348008f, 
    0.14786525f, 0.06827775f, -0.13739412f, 0.04339233f, 0.06511095f, -0.04233759f, 0.04048743f, 0.06634413f, 
    -0.03306736f, 0.03217617f, -0.05213880f, -0.01546961f, -0.02043003f, 0.04138040f, -0.00219651f, 0.01818406f, 
    -0.08142091f, 0.01897720f, -0.02608480f, -0.01619594f, 0.46242875f, -0.30254358f, -0.01665409f, -0.24191253f, 
    0.14980808f, 0.12021060f, -0.11529581f, -0.24261963f, -0.03093649f, -0.04530871f, -0.13496065f, 0.07839843f, 
    0.03497909f, 0.02058882f, -0.00246449f, 0.08218040f, -0.04670517f, -0.26522562f, 0.09814980f, 0.03262977f, 
    0.27889258f, 0.19116168f, -0.15865916f, 0.18184882f, 0.21642953f, 0.01253079f, 0.06918124f, -0.05136074f, 
    -0.00611849f, -0.01078676f, -0.03424643f, -0.02424229f, -0.00928503f, -0.02934561f, -0.03379910f, 0.04195521f, 
    0.13119787f, 0.11260656f, 0.08152212f, 0.04786694f, -0.19808264f, -0.26339218f, -0.17979828f, -0.10825629f, 
    -0.06339086f, -0.05908605f, -0.03261262f, -0.02901690f, 0.03230144f, 0.01827681f, 0.01313294f, -0.02373791f, 
    -0.06580836f, 0.04129454f, -0.05941861f, -0.02676068f, -0.05439660f, 0.14366037f, 0.02002536f, -0.00226321f, 
    -0.29600406f, -0.00728946f, -0.18216948f, -0.23318604f, -0.04304228f, -0.04868808f, -0.02569293f, -0.04688317f, 
    -0.00686159f, 0.05162574f, 0.01648430f, -0.05751149f, -0.06009354f, -0.00231520f, 0.02511033f, 0.10798493f, 
    -0.13626015f, 0.02011108f, 0.07748043f, -0.00152712f, -0.04881306f, 0.18140292f, -0.04771415f, 0.19153346f, 
    0.08045487f, 0.03177878f, -0.02338631f, 0.07160751f, -0.04673803f, -0.03421871f, -0.04208911f, -0.01125681f, 
    0.03505536f, 0.02896472f, 0.05706184f, -0.02068559f, 0.02470867f, 0.02418001f, 0.00156037f, 0.02209088f, 
    -0.13326278f, 0.01787011f, 0.01218998f, -0.10035007f, 0.02237979f, 0.01964290f, -0.02640936f, 0.00734622f, 
    0.02911005f, 0.07490014f, 0.00460027f, 0.01441775f, -0.05003282f, 0.04441552f, -0.00073493f, 0.08563875f, 
    -0.03227215f, -0.24778542f, 0.13380437f, 0.02358722f, -0.39401203f, -0.28367183f, 0.27192399f, -0.13045731f, 
    -0.04126640f, -0.07450878f, 0.08147483f, -0.02251304f, -0.02053532f, 0.10994593f, 0.00643430f, 0.03729744f, 
    0.01096455f, 0.06363595f, -0.01700156f, -0.04985143f, -0.04985603f, -0.04998957f, -0.05410789f, -0.07076173f, 
    -0.18024446f, -0.44925389f, -0.12653166f, 0.07686766f, -0.45244509f, -0.04951767f, 0.01024309f, -0.05211094f, 
    0.10787261f, -0.10000659f, -0.02197542f, 0.03340070f, -0.01699518f, -0.03102772f, -0.02747038f, -0.01319984f, 
    -0.00048609f, 0.00708596f, -0.12668408f, 0.02428550f, -0.41763070f, 0.02857449f, -0.28614628f, -0.04134441f, 
    -0.03205314f, -0.15900579f, -0.09057922f, 0.14201966f, -0.24855995f, -0.04899074f, -0.01754463f, 0.02568025f, 
    0.01310789f, -0.03067753f, -0.02730242f, 0.02668397f, -0.09749297f, 0.03641081f, -0.10466684f, 0.01968107f, 
    -0.16334744f, 0.08609568f, 0.05470704f, -0.00068640f, 0.01133110f, 0.02029892f, 0.02277399f, -0.10514496f, 
    -0.08016977f, -0.00943239f, 0.00653719f, -0.05929928f, -0.08734603f, 0.03432847f, 0.10391221f, 0.03775081f, 
    -0.05972497f, 0.04694174f, 0.01363586f, -0.14961311f, -0.09147093f, -0.08171259f, -0.16787204f, -0.04686847f, 
    -0.03789095f, 0.04696403f, 0.02485512f, -0.08188804f, -0.08010335f, -0.00526182f, -0.04282036f, -0.03712248f, 
    0.05250022f, -0.06872544f, 0.03303960f, 0.00528606f, 0.04427122f, -0.10076833f, 0.12402486f, -0.02367622f, 
    -0.23580314f, 0.08517446f, -0.21422492f, 0.00570287f, -0.22666328f, -0.05280509f, -0.03026706f, -0.06911847f, 
    -0.01948282f, 0.10401485f, 0.03907938f, 0.03344370f, -0.06503239f, 0.05779724f, -0.03196695f, 0.17223658f, 
    0.04002075f, 0.11622065f, 0.01510225f, -0.01964355f, -0.43173704f, -0.08490109f, 0.26779455f, -0.26271221f, 
    0.12192243f, -0.01188592f, -0.01172070f, -0.05493127f, 0.05766255f, 0.01134226f, -0.00086611f, -0.00780023f, 
    0.01894766f, 0.02094764f, 0.00686498f, 0.03484079f, -0.03301768f, -0.01149209f, -0.02569286f, -0.05472866f, 
    -0.27665049f, -0.20223723f, 0.43239895f, 0.34857965f, 0.09012447f, -0.07398116f, 0.00451076f, -0.06582605f, 
    0.03549098f, -0.17328595f, -0.00735520f, 0.01217362f, -0.03277078f, 0.00462696f, -0.06976156f, -0.02213499f, 
    -0.01774570f, 0.02599900f, -0.08965220f, -0.00044542f, -0.10658463f, 0.04076339f, -0.00610377f, 0.12408376f, 
    0.01355931f, 0.01317058f, -0.03274595f, -0.07702489f, -0.06315687f, -0.14755233f, 0.00161543f, 0.06466090f, 
    0.05843264f, 0.03505450f, 0.00835937f, -0.01422350f, -0.00066036f, 0.00048579f, 0.02123939f, -0.02599568f, 
    -0.13395549f, -0.17769124f, 0.18623884f, 0.17473249f, -0.34382442f, -0.04104595f, 0.01088207f, -0.00402507f, 
    -0.05872167f, 0.06236090f, 0.01337828f, -0.01671064f, 0.03052286f, -0.02879935f, -0.05125507f, -0.01184075f, 
    0.03836958f, 0.07047412f, 0.05220159f, 0.12063952f, -0.00176153f, 0.03273281f, -0.06280872f, -0.05044235f, 
    0.02387342f, 0.07047530f, -0.14044425f, -0.06647776f, 0.01494748f, 0.01596342f, 0.01233436f, -0.01095934f, 
    0.06130546f, 0.00007823f, -0.08127272f, 0.00772898f, -0.04162062f, 0.04754871f, 0.05230718f, -0.03622945f, 
    -0.13602182f, -0.67298770f, -0.61228114f, -0.08937038f, -0.45239872f, -0.06503914f, 0.06763382f, -0.02366670f, 
    -0.02031418f, -0.09066817f, -0.03337440f, 0.02724054f, -0.01047634f, -0.00122392f, -0.02211383f, -0.01330364f, 
    -0.02640120f, 0.02976324f, -0.17740181f, -0.03927841f, -0.37836194f, -0.38461167f, 0.28346136f, -0.09217684f, 
    -0.09008349f, -0.03609403f, -0.04787073f, -0.12692751f, -0.04213030f, -0.00123317f, 0.00394206f, -0.02122404f, 
    -0.00233284f, -0.01341914f, -0.03369119f, -0.07472581f, -0.06794418f, 0.02393715f, 0.04194920f, 0.15579793f, 
    -0.80687225f, -0.43416545f, -0.28544089f, -0.10316233f, -0.45714667f, 0.18136518f, 0.17173748f, -0.16199887f, 
    0.01494401f, -0.11626405f, 0.03762582f, 0.01776293f, 0.00412866f, 0.00476316f, -0.07958537f, 0.01404890f, 
    0.02294584f, 0.00322523f, -0.03006083f, 0.02799553f, -0.09646975f, 0.18988444f, -0.03212999f, -0.12583083f, 
    0.09674808f, 0.03299469f, 0.02745513f, 0.01134367f, 0.02619883f, -0.01962654f, -0.03350544f, -0.00999893f, 
    -0.03440617f, -0.03364354f, -0.03087052f, -0.04709531f, 0.11973812f, 0.08568568f, -0.06567458f, -0.03388020f, 
    -0.54670829f, -0.70185655f, -0.35592553f, -0.12798940f, -0.73464960f, -0.01174289f, -0.05064141f, 0.05964624f, 
    -0.00361144f, -0.08674727f, -0.03455792f, 0.01680584f, -0.01709450f, -0.05738225f, 0.01127356f, -0.07469661f, 
    -0.00825461f, -0.05256022f, 0.03198203f, 0.07604947f, -0.10638627f, 0.09800970f, -0.04245451f, 0.04938270f, 
    0.02094869f, -0.00777998f, -0.04589742f, -0.12676467f, -0.07044127f, -0.11950228f, 0.02780862f, -0.00320322f, 
    0.00817206f, 0.01812272f, -0.03582342f, 0.03172300f, -0.01518743f, -0.01652702f, 0.05182444f, -0.00298705f, 
    -0.08852703f, 0.15028523f, -0.05159593f, -0.05822669f, -0.04201602f, 0.02322922f, -0.06531811f, -0.04164957f, 
    0.00176425f, 0.01196580f, 0.03697404f, -0.04185898f, 0.00725551f, -0.01696466f, -0.01335321f, 0.02596618f, 
    -0.06315234f, 0.08393924f, 0.11765128f, -0.01452956f, -0.10541540f, 0.18395472f, 0.44388852f, -0.00366275f, 
    0.00557920f, -0.02821181f, -0.04604086f, 0.04624669f, -0.00855784f, 0.06851396f, 0.05168482f, -0.00143538f, 
    0.02366491f, 0.04995551f, 0.00485740f, 0.02598281f, -0.00926149f, 0.05993671f, 0.07307278f, -0.07501908f, 
    0.03414676f, 0.05625479f, 0.24391757f, -0.08153031f, 0.09902711f, 0.02626153f, -0.05956955f, -0.02324136f, 
    -0.01701515f, 0.07873717f, 0.04601266f, -0.03773499f, -0.00328452f, -0.04276456f, 0.03350261f, 0.06445561f, 
    0.03133706f, -0.04102623f, 0.04756776f, -0.00722990f, 0.00588458f, -0.05702405f, -0.02496240f, 0.01210482f, 
    0.04160549f, 0.00387093f, -0.07244390f, -0.00572097f, 0.04606579f, -0.04844078f, -0.06031192f, -0.05128298f, 
    -0.03832224f, 0.01317084f, 0.01058810f, 0.00547259f, -0.03716233f, -0.05968698f, 0.02786494f, -0.03503825f, 
    0.13910346f, -0.02516194f, 0.10245012f, 0.42863843f, 0.08618396f, 0.05115266f, 0.04319653f, -0.04335636f, 
    0.04028916f, 0.06812514f, 0.02003906f, 0.03420778f, -0.00872432f, 0.00891436f, -0.04844644f, 0.00241471f, 
    -0.00065350f, 0.03523393f, 0.01238771f, -0.00490904f, 0.11186081f, -0.06612033f, -0.09540998f, -0.01177087f, 
    0.11471163f, 0.02369184f, -0.03456865f, 0.01981384f, 0.04621983f, 0.02416032f, -0.13308305f, -0.00359657f, 
    -0.04677635f, -0.00966392f, -0.03113978f, 0.06726351f, 0.00997154f, -0.03946752f, 0.06031380f, -0.00631063f, 
    -0.08604942f, 0.12614520f, 0.04248430f, 0.00236534f, -0.05047669f, -0.00252206f, -0.06187169f, -0.09543216f, 
    -0.04028698f, -0.06870043f, 0.00933755f, 0.00559011f, 0.04320323f, -0.00589279f, -0.03838400f, 0.00923316f, 
    0.00076274f, -0.00213452f, 0.08073071f, -0.02437364f, -0.20699015f, -0.22769092f, 0.30424392f, 0.35762677f, 
    -0.00127019f, 0.03428962f, 0.08325826f, 0.01314406f, 0.06379709f, -0.04416461f, -0.01848711f, 0.01146836f, 
    0.01214306f, 0.02066338f, -0.02869432f, -0.02037719f, 0.02427126f, 0.00258770f, -0.06301472f, -0.01091312f, 
    -0.04406623f, 0.02703951f, 0.09208640f, -0.10119921f, 0.03216067f, -0.13165465f, 0.02793237f, -0.00957255f, 
    0.03252991f, 0.00206414f, -0.06064218f, 0.06497737f, -0.05966337f, -0.08000674f, 0.08826213f, -0.02592263f, 
    -0.10356496f, 0.15848733f, -0.07920389f, -0.05357173f, 0.46566609f, 0.26231924f, 0.42796996f, -0.41485444f, 
    -0.11972664f, -0.13176221f, 0.13841109f, -0.09863264f, 0.00966909f, -0.12271952f, -0.02108922f, 0.05311345f, 
    0.14167473f, -0.02639471f, -0.05726385f, 0.08029003f, -0.04284053f, -0.05501015f, -0.10899790f, -0.19943315f, 
    0.12317539f, 0.08497169f, 0.02067397f, -0.05618454f, 0.18430233f, -0.06752190f, 0.08932269f, 0.02286308f, 
    -0.02383563f, 0.06434156f, -0.05088063f, 0.02748411f, -0.03681545f, -0.04944735f, -0.08656324f, -0.06779697f, 
    -0.04914979f, 0.04148012f, -0.01594411f, -0.02678564f, 0.05915793f, -0.06429712f, -0.19352463f, -0.07037374f, 
    -0.23004235f, -0.05095777f, -0.10778949f, 0.01238900f, -0.14479259f, -0.05766592f, -0.06748914f, -0.02797619f, 
    -0.08315192f, -0.03554628f, 0.01303767f, -0.00845051f, -0.00977034f, -0.04658227f, -0.00290547f, 0.00440202f, 
    -0.44836646f, 0.09388099f, -0.10246899f, 0.25833270f, -0.22364648f, 0.11972363f, -0.05159999f, 0.01879997f, 
    -0.09092362f, -0.00770728f, -0.04357812f, 0.21551909f, -0.01946110f, -0.01038673f, -0.11035942f, 0.05194857f, 
    0.13096759f, 0.15452181f, 0.03491226f, -0.20631382f, -0.37573874f, 0.06948201f, 0.13265626f, 0.07592233f, 
    0.14823633f, -0.11993480f, -0.09649248f, -0.15253899f, 0.10315033f, -0.07672483f, 0.00344749f, 0.01911772f, 
    0.04931745f, -0.07296915f, 0.04822637f, -0.01997032f, 0.01269495f, -0.14530289f, 0.06290779f, 0.00409210f, 
    -0.18658283f, -0.13148437f, -0.05010109f, 0.15279812f, 0.19208857f, -0.12827341f, 0.00409689f, 0.14907625f, 
    -0.05610218f, 0.01243647f, 0.05183605f, 0.03060194f, 0.01126616f, -0.11197551f, -0.05088237f, -0.09488597f, 
    -0.07830211f, 0.11592042f, 0.01289099f, 0.02935678f, 0.07779757f, -0.24066645f, 0.10153232f, -0.15719594f, 
    -0.19217457f, -0.16631596f, -0.04017605f, -0.09319121f, 0.06715627f, -0.02648570f, 0.06559249f, 0.10954012f, 
    0.13021851f, -0.04723604f, -0.02850272f, 0.02339390f, -0.03722104f, 0.01668531f, -0.10906821f, -0.06466526f, 
    0.30309388f, 0.12653615f, -0.16400455f, -0.02299110f, 0.19410387f, 0.23294859f, 0.13427806f, 0.00090972f, 
    0.06162684f, 0.08890834f, -0.11069147f, 0.01409302f, 0.13629656f, 0.05946110f, 0.10104313f, -0.08454017f, 
    0.04020181f, -0.00383700f, 0.10595772f, 0.01797988f, -0.08145820f, -0.03767689f, -0.14726338f, -0.00166004f, 
    0.19326210f, 0.17373875f, -0.04637964f, -0.00440563f, -0.11129264f, -0.11979450f, -0.12311403f, 0.02895791f, 
    0.05952803f, -0.01854282f, 0.05020216f, -0.00782033f, -0.03643311f, -0.01562637f, 0.03492874f, 0.00951986f, 
    -0.59330332f, -0.37818447f, 0.21656482f, 0.12543222f, -0.28934139f, 0.06167685f, 0.03844142f, 0.05792213f, 
    0.09667455f, 0.00157220f, 0.08924038f, 0.09247465f, 0.16574940f, 0.01797142f, -0.01823732f, 0.01310653f, 
    0.03052210f, 0.04066201f, -0.07698546f, 0.07165783f, -0.25136387f, 0.14175062f, -0.21582732f, -0.06794945f, 
    0.25715891f, 0.13788839f, -0.01893333f, 0.08789480f, -0.07009273f, 0.08571212f, -0.00599070f, 0.04707743f, 
    0.00486295f, -0.01980398f, -0.09044969f, 0.01232956f, -0.01074389f, 0.03452042f, 0.08220329f, -0.05371134f, 
    -0.57098889f, 0.54555213f, -0.13516890f, -0.07051624f, 0.30758572f, 0.30485636f, 0.03046481f, -0.02443898f, 
    -0.09577034f, -0.06518912f, -0.24458835f, -0.03524975f, 0.01610431f, 0.03721614f, 0.12386193f, -0.06209341f, 
    -0.01802999f, -0.03738728f, 0.15111229f, 0.04147587f, -0.19089836f, 0.52190179f, -0.03174390f, -0.16143748f, 
    -0.31245553f, 0.17194043f, 0.04904424f, 0.03701814f, 0.10317010f, 0.09674337f, -0.06690679f, -0.13486348f, 
    0.07635595f, -0.08297902f, 0.00715566f, -0.03496160f, 0.05207951f, -0.12633796f, 0.04469764f, -0.06935041f, 
    -0.03210813f, -0.11458401f, 0.06996191f, 0.10397098f, 0.39317441f, -0.00953055f, 0.05925328f, -0.06443021f, 
    -0.00804469f, 0.02683717f, 0.04287506f, 0.02209064f, -0.13504249f, -0.10562696f, -0.03824958f, -0.06328861f, 
    -0.01135424f, 0.09104064f, 0.05012874f, -0.01685859f, -0.18562776f, 0.04448908f, -0.25795937f, 0.26596099f, 
    0.10393891f, -0.04968816f, -0.04201864f, -0.02133555f, -0.05013911f, 0.09289992f, -0.01290405f, 0.01409958f, 
    -0.04129533f, -0.05465885f, -0.03013916f, -0.05483390f, 0.00648856f, -0.12256504f, -0.00620057f, -0.06512682f, 
    -0.21256520f, 0.14115416f, -0.17093012f, -0.08873369f, 0.08032461f, 0.03921166f, -0.00970824f, 0.06725362f, 
    -0.08634838f, -0.03444727f, -0.12636557f, 0.06709152f, 0.05377483f, -0.03421498f, 0.00029671f, 0.00819927f, 
    0.02265495f, 0.05138026f, -0.03075188f, 0.02251238f, -0.00557616f, 0.02317029f, 0.37783766f, -0.16691758f, 
    0.15137932f, -0.29589263f, -0.14082718f, 0.04705922f, -0.04443936f, -0.05746009f, 0.03638370f, 0.01353604f, 
    -0.02287422f, 0.13508295f, 0.08669984f, -0.07373069f, -0.01753150f, -0.01699045f, -0.04494373f, 0.00523200f, 
    0.65146440f, 0.66628754f, -0.05504075f, -0.36990705f, -0.23992056f, 0.01599266f, -0.06348998f, -0.10924446f, 
    -0.18398504f, -0.13304059f, -0.06104056f, -0.02811050f, -0.01179360f, 0.04229121f, 0.06412878f, 0.00447814f, 
    0.01173902f, -0.17756012f, 0.07458022f, 0.04602803f, -0.48942095f, 0.24174894f, -0.09390946f, -0.03207302f, 
    -0.03974774f, 0.07654935f, -0.13210611f, 0.04916922f, -0.05408113f, 0.04549639f, -0.10205962f, -0.07953747f, 
    -0.14997187f, -0.28459513f, 0.16021042f, 0.09837750f, -0.02138400f, 0.14305481f, -0.19824177f, -0.14214782f, 
    -0.09461863f, 0.03031663f, -0.13398260f, 0.07669579f, 0.38162106f, 0.09765499f, -0.04098720f, -0.03380848f, 
    -0.04842686f, 0.01470546f, -0.04945344f, 0.06069828f, 0.06750144f, -0.01124316f, 0.08422292f, 0.09901111f, 
    -0.05948896f, 0.10460298f, -0.01340651f, 0.05559712f, 0.11329994f, 0.33232901f, 0.37814027f, -0.42509013f, 
    0.22897641f, -0.16098599f, -0.04706777f, -0.03671594f, -0.03838008f, -0.05776926f, 0.06442238f, 0.04237840f, 
    0.04673875f, -0.00524854f, 0.07340971f, -0.01416975f, -0.03855124f, -0.10326065f, -0.02898701f, -0.07549038f, 
    -0.23687840f, 0.06771328f, -0.04838470f, -0.15710054f, -0.35940787f, 0.11340057f, 0.03754665f, -0.01475882f, 
    -0.02088126f, 0.06078373f, -0.07174110f, -0.06538843f, -0.11136369f, -0.06255973f, 0.01424404f, -0.13267092f, 
    -0.12078143f, -0.00191197f, 0.01090783f, -0.16405416f, -0.19117646f, 0.19545284f, -0.08308735f, 0.05975638f, 
    0.06664787f, -0.01355076f, -0.07124731f, 0.00275949f, -0.01520435f, 0.00978472f, 0.03536062f, 0.06005215f, 
    -0.07966941f, -0.14130680f, -0.05480643f, 0.04218465f, 0.02361942f, 0.02440523f, 0.00703287f, -0.00882685f, 
    -0.35918552f, 0.03478556f, -0.05778512f, -0.13121122f, -0.33147573f, -0.05785485f, -0.09766476f, 0.04851462f, 
    0.01411226f, 0.06699540f, 0.01050747f, -0.11802858f, 0.07778500f, 0.04944826f, 0.03743641f, 0.02972389f, 
    -0.01674834f, -0.07312308f, 0.01830404f, -0.01019427f, -0.16371779f, -0.26411557f, -0.38357478f, -0.11550918f, 
    -0.25618544f, 0.21515037f, 0.08857414f, 0.01690172f, 0.01676413f, 0.03786472f, 0.01947170f, -0.05280912f, 
    -0.04519459f, -0.01431188f, -0.06298964f, 0.00672048f, 0.03413611f, -0.06703218f, -0.12054694f, -0.18471730f, 
    -0.50969118f, 0.26574841f, -0.08343934f, 0.11353892f, 0.14689641f, -0.00726110f, -0.02937073f, -0.09947148f, 
    -0.13027084f, -0.00991923f, -0.11401557f, 0.00622731f, -0.01618580f, 0.00689282f, 0.03658510f, 0.00605280f, 
    0.07135590f, 0.03599465f, -0.15264192f, -0.07828516f, 0.06041415f, 0.09142296f, -0.12966758f, -0.17700815f, 
    -0.00665873f, 0.05983240f, 0.03825505f, -0.14600502f, -0.01383312f, -0.08552112f, 0.01922626f, -0.02310406f, 
    -0.05119594f, -0.02877614f, -0.00126725f, 0.01288141f, -0.03256192f, 0.00774758f, -0.06375770f, -0.02287981f, 
    -0.23329656f, 0.44215357f, -0.16075829f, 0.05725324f, 0.13927676f, 0.19694650f, -0.00840160f, -0.02699393f, 
    -0.11009107f, 0.12134185f, -0.03612706f, -0.09488349f, -0.06751498f, -0.06388588f, 0.03073250f, 0.02859131f, 
    -0.10920320f, -0.01411586f, 0.05238420f, -0.07175338f, 0.03482180f, -0.00487553f, -0.16793509f, -0.07353660f, 
    0.14965047f, 0.02852018f, 0.08228923f, 0.03362958f, 0.02738934f, 0.09831288f, -0.02485454f, 0.04025819f, 
    0.07901673f, -0.04789888f, 0.07981782f, 0.00208556f, -0.02063379f, 0.02946542f, 0.06982168f, 0.11239086f, 
    -0.04824182f, 0.05755317f, 0.15357912f, 0.21319050f, 0.12338342f, 0.06717804f, -0.01006426f, -0.07653478f, 
    -0.13117184f, -0.03945012f, -0.02970643f, -0.07724138f, 0.02327714f, -0.04712313f, -0.08159897f, -0.00302657f, 
    0.01129965f, 0.15695840f, -0.04934243f, -0.15544038f, -0.00437153f, 0.11343140f, 0.00721659f, -0.12167706f, 
    0.02218588f, 0.00535840f, 0.09519827f, -0.08113708f, 0.03010123f, 0.11876301f, -0.07035941f, -0.02879720f, 
    0.05302695f, 0.00019615f, 0.01887419f, 0.04118468f, 0.00833683f, -0.02199693f, -0.01962313f, -0.06487934f, 
    0.22053684f, 0.19919550f, -0.25380120f, -0.17365016f, 0.00397254f, -0.04042853f, -0.11411247f, 0.05710657f, 
    -0.09666331f, -0.07363991f, -0.01489094f, -0.00179659f, -0.09258827f, 0.08000968f, 0.03967591f, 0.12197632f, 
    -0.04794215f, -0.01439521f, -0.04102932f, 0.03619814f, 0.37524235f, 0.04228402f, -0.24814622f, -0.21033709f, 
    0.04051723f, 0.11066137f, 0.05987438f, -0.04019971f, -0.15542743f, 0.06256771f, -0.20359091f, -0.21836144f, 
    0.11157776f, -0.10664938f, -0.07329192f, -0.10141963f, -0.06637938f, -0.10880733f, 0.16216968f, 0.02704356f, 
    0.42598641f, 0.31183666f, 0.08507026f, -0.33734185f, 0.03488328f, 0.02940929f, 0.03676343f, -0.01881580f, 
    0.02431108f, 0.08904634f, -0.10465675f, -0.04379413f, 0.03179576f, 0.12206936f, 0.04041111f, 0.03373330f, 
    -0.05657639f, -0.04443664f, 0.08019393f, 0.04543476f, -0.75420481f, -0.36679506f, 0.00642932f, -0.22580779f, 
    -0.20867454f, 0.14141475f, -0.01996027f, -0.00777801f, 0.00006502f, -0.02642846f, 0.01320882f, 0.08556972f, 
    0.05290747f, 0.02838641f, -0.11883949f, -0.05086497f, 0.03082543f, -0.00064586f, -0.07443790f, -0.11498749f, 
    -0.32656845f, -0.51524216f, 0.05228307f, 0.01682612f, -0.27484986f, -0.00671509f, 0.01817989f, -0.02169996f, 
    -0.13821323f, -0.01356649f, -0.05143318f, 0.07955202f, 0.08776689f, 0.18896653f, -0.19817577f, 0.05307480f, 
    -0.10204439f, 0.09213213f, -0.04684656f, -0.08642291f, 0.35251865f, -0.25648221f, -0.17767356f, -0.05943174f, 
    0.14393985f, 0.17698959f, -0.03926832f, -0.03306532f, -0.09377249f, -0.30053651f, -0.02040830f, 0.00682961f, 
    0.05557715f, 0.03834105f, 0.00454436f, -0.07291158f, 0.03326197f, 0.17690083f, -0.01167364f, -0.16061869f, 
    -0.45304078f, 0.13462849f, -0.36027113f, 0.06373790f, -0.21679245f, 0.09395545f, -0.16076054f, 0.04771824f, 
    0.01692487f, -0.02424794f, 0.02861997f, -0.11757618f, 0.06762797f, -0.14332061f, -0.04406393f, 0.00030151f, 
    0.08314516f, 0.06181942f, 0.11071255f, -0.06575208f, -0.14179474f, -0.18125682f, 0.54166764f, -0.11370660f, 
    0.25743958f, -0.08397456f, -0.02814764f, -0.05618092f, 0.03631123f, -0.10242480f, 0.09859955f, 0.03681904f, 
    -0.03679019f, -0.02028066f, 0.11213691f, -0.03044521f, -0.02476506f, 0.13210018f, -0.02049031f, -0.08250083f, 
    -0.12098618f, -0.06647290f, -0.20795819f, 0.06212084f, 0.13801758f, 0.02181588f, -0.01388894f, -0.00186820f, 
    0.05332910f, 0.03671090f, -0.01435703f, 0.01150977f, -0.05103684f, -0.03093409f, -0.02179605f, -0.03749289f, 
    -0.03188826f, 0.10997643f, -0.12923212f, 0.01080393f, -0.05145100f, 0.06546463f, -0.15541503f, 0.02251295f, 
    -0.12333698f, 0.07060590f, -0.12882209f, -0.20033032f, -0.00197648f, -0.03509174f, 0.22618867f, 0.17675689f, 
    0.16929178f, -0.09942848f, 0.09368882f, 0.06370241f, -0.01038341f, -0.13667576f, 0.00454778f, -0.18068886f, 
    0.21794902f, 0.24297455f, 0.06050560f, 0.44097736f, 0.22358106f, -0.01116788f, -0.14242956f, -0.00556679f, 
    -0.13630928f, -0.17194921f, -0.17789647f, 0.04211408f, 0.08211578f, -0.10146558f, 0.06057285f, 0.00278027f, 
    0.00932000f, 0.20880257f, -0.11759214f, 0.11070734f, -0.05833941f, 0.17337194f, -0.19922055f, -0.07706606f, 
    -0.41477382f, -0.03189991f, -0.24195264f, 0.07522713f, 0.09604990f, -0.00051405f, -0.02652446f, -0.00975257f, 
    0.05848825f, -0.26828858f, -0.10322276f, -0.09760745f, -0.07259680f, -0.10651537f, 0.33530101f, -0.01215802f, 
    -1.32410944f, 0.33953017f, 0.23460788f, -0.05426205f, -0.13741389f, 0.14509347f, 0.01704619f, 0.11708472f, 
    -0.18476506f, -0.15891393f, -0.05758352f, 0.12688430f, 0.05092839f, 0.10369811f, -0.23152244f, -0.00462201f, 
    0.01440878f, 0.12221948f, 0.00977476f, -0.04655688f, -0.14120767f, -0.25252283f, 0.41340283f, 0.01890805f, 
    0.09266207f, -0.25313318f, -0.08854594f, 0.07885972f, 0.06090292f, -0.06865627f, 0.05185826f, 0.01113831f, 
    -0.00109436f, 0.10069671f, 0.05211828f, -0.04806571f, 0.01415399f, -0.02342128f, 0.04406231f, -0.04018664f, 
    -0.15007985f, 0.14202401f, -0.13296019f, 0.03099235f, 0.19092096f, 0.05193238f, 0.03530201f, 0.02705955f, 
    0.03307501f, 0.06003175f, -0.11610486f, 0.12144131f, -0.03010543f, 0.04689464f, 0.16435505f, -0.05202751f, 
    0.02315700f, 0.15103483f, 0.06831455f, 0.07488384f, -0.06736467f, -0.08089188f, -0.13493228f, 0.07760056f, 
    0.14102808f, -0.02705659f, 0.00108643f, -0.01193166f, -0.07278727f, 0.04576374f, -0.02916178f, -0.03214831f, 
    -0.00873172f, 0.00556907f, -0.14460590f, 0.11556037f, -0.00776657f, 0.09859901f, -0.01341653f, -0.08241791f, 
    0.01793740f, -0.21067591f, -0.08037068f, 0.09400901f, 0.31419665f, -0.04822232f, 0.07630397f, -0.00607905f, 
    0.06652185f, 0.06268419f, 0.01690706f, -0.03024091f, -0.03802436f, -0.12837997f, -0.00866346f, -0.04806782f, 
    0.00651220f, -0.00992617f, 0.03983696f, 0.00894606f, -0.01193108f, 0.00816320f, 0.27614111f, -0.27246121f, 
    0.14441158f, -0.05205441f, 0.05666275f, 0.02355362f, 0.03939151f, -0.09251912f, 0.05706938f, 0.00190581f, 
    -0.12046812f, 0.02322039f, 0.07169150f, 0.06556515f, 0.00483846f, 0.13799448f, -0.10917369f, -0.22544824f, 
    0.00626581f, -0.01415418f, -0.20616001f, -0.01361075f, 0.20160306f, 0.13454817f, -0.05758148f, 0.01077972f, 
    0.09056294f, 0.08058731f, -0.03421142f, -0.02037601f, -0.14289078f, -0.00621717f, -0.05457748f, -0.02423759f, 
    -0.03686908f, 0.16669273f, -0.12937030f, 0.04193490f, 0.08272624f, -0.20763877f, 0.09434709f, -0.00661801f, 
    0.28060618f, -0.08927453f, 0.12136108f, 0.09168477f, 0.12112202f, 0.07943915f, 0.03193025f, 0.03269434f, 
    -0.00452138f, -0.04365592f, 0.01672897f, -0.08095473f, 0.01049255f, -0.02085853f, 0.01890177f, -0.02767663f, 
    0.01065523f, -0.08523957f, -0.12915155f, 0.07425243f, 0.22200041f, 0.05228684f, 0.13536416f, 0.13133049f, 
    0.10669427f, 0.12550893f, 0.07575466f, -0.03660380f, -0.03393606f, -0.01721432f, -0.00165641f, -0.07565231f, 
    -0.11505015f, 0.04113112f, -0.12739937f, 0.05098204f, -0.49585170f, 0.16640127f, 0.34116763f, -0.08171395f, 
    0.12961148f, -0.07083605f, 0.06506175f, 0.05951295f, -0.02630256f, -0.08483950f, -0.08102555f, 0.02942090f, 
    -0.02569556f, -0.03952663f, -0.04759059f, -0.00645721f, -0.00979102f, 0.01552747f, -0.04205341f, -0.08095588f, 
    -0.04589893f, -0.17378959f, -0.26614538f, 0.11466609f, 0.24983613f, -0.07943085f, -0.00782688f, -0.04052819f, 
    0.03306864f, 0.08357257f, -0.02416229f, 0.01095750f, -0.01220011f, -0.17949119f, -0.05502062f, 0.04507684f, 
    0.06760329f, -0.02770641f, -0.03138953f, -0.02935336f, -0.28789669f, -0.14022791f, -0.07562571f, 0.12225580f, 
    0.02163863f, 0.03069733f, -0.04247704f, 0.14494811f, 0.02121553f, 0.08811790f, -0.01835972f, 0.02290444f, 
    -0.04866514f, -0.03298808f, -0.09262836f, 0.00013840f, -0.08116668f, 0.15709339f, -0.01427517f, -0.16441317f, 
    -0.68807721f, 0.07776572f, -0.27391157f, 0.03196822f, -0.06363524f, 0.12261043f, -0.13747123f, 0.11855998f, 
    -0.10810629f, -0.04534332f, 0.04004254f, -0.05240935f, -0.07436357f, -0.04240599f, -0.02804790f, -0.04009970f, 
    -0.02923884f, -0.06061128f, -0.03985485f, -0.11132917f, 0.05680785f, 0.44778532f, -0.01680892f, 0.10766883f, 
    0.21979108f, 0.16570051f, 0.01508165f, -0.00926507f, -0.00157954f, 0.01442360f, -0.03821259f, -0.04705782f, 
    0.07365659f, 0.03052252f, 0.06348946f, 0.00463854f, -0.10325778f, -0.01179578f, 0.05611464f, -0.05863328f, 
    0.50553232f, 0.10372224f, -0.12061833f, 0.12496353f, -0.14620237f, 0.14411211f, 0.05516243f, 0.06746083f, 
    0.05135671f, 0.09274773f, -0.07328010f, -0.06083591f, 0.02829894f, -0.05253260f, -0.01708557f, -0.07944188f, 
    -0.10654030f, -0.08956925f, -0.02565121f, 0.00174166f, -0.22758840f, -0.19022484f, -0.26976314f, -0.06339890f, 
    0.08333782f, 0.06960782f, 0.04912516f, 0.07593203f, 0.08824010f, 0.03219885f, 0.01649396f, -0.00774791f, 
    -0.00125822f, -0.03587361f, -0.07605164f, 0.12937683f, -0.06059019f, 0.07380605f, 0.01801434f, 0.00486678f, 
    -0.17406707f, 0.04556468f, -0.14116187f, -0.12609279f, 0.20746779f, 0.07799357f, -0.02317935f, -0.09625328f, 
    0.01027762f, -0.12705168f, -0.13595445f, 0.08817543f, -0.06595334f, 0.11651320f, 0.09062834f, -0.14595614f, 
    0.00625743f, 0.13171534f, -0.02719897f, -0.13764167f, 0.33999771f, 0.73581421f, -0.27013388f, -0.10303723f, 
    -0.41540378f, 0.10156141f, -0.00307432f, -0.03110777f, -0.14099197f, -0.00041728f, -0.16939034f, -0.14759453f, 
    0.00742985f, -0.10865933f, 0.06413846f, -0.06408846f, -0.05262925f, -0.19565198f, 0.05456346f, 0.02640880f, 
    -0.33124882f, 0.05697666f, -0.07289036f, 0.12457594f, 0.26645359f, 0.04219063f, -0.13524103f, 0.01244130f, 
    -0.11200647f, 0.03023948f, 0.00456064f, 0.04679990f, 0.01485972f, 0.01470951f, -0.06268790f, 0.11925715f, 
    0.04184274f, 0.01946383f, -0.04817493f, -0.07819150f, -0.02262853f, -0.04528940f, -0.20619002f, -0.02390525f, 
    0.25118396f, 0.02725323f, 0.01393094f, -0.06007853f, -0.02767489f, 0.01035076f, -0.01537755f, 0.06437039f, 
    0.00361511f, 0.10441970f, 0.08290637f, -0.05949420f, -0.00667584f, 0.04991235f, 0.03166140f, 0.04474705f, 
    0.05595724f, -0.16321164f, 0.10224649f, -0.07718680f, -0.02701106f, -0.07143350f, -0.02505585f, 0.06250484f, 
    0.00309118f, -0.05319923f, 0.00927601f, -0.04732260f, -0.05273561f, 0.03692956f, -0.07543601f, -0.13052565f, 
    0.06714688f, 0.07555536f, 0.09504529f, 0.10042472f, 0.14595872f, -0.25814462f, -0.20553617f, 0.05606943f, 
    -0.30158108f, -0.01846451f, 0.02201696f, 0.03374564f, -0.04255814f, 0.04584276f, 0.02831840f, -0.04742046f, 
    0.00060469f, 0.01475470f, 0.06059825f, -0.09634858f, 0.00459080f, -0.01420657f, 0.03398338f, 0.05822019f, 
    -0.02217180f, -0.09351084f, -0.01173341f, 0.14940165f, -0.02410614f, 0.03847939f, -0.03025491f, 0.09725611f, 
    -0.11056995f, -0.06303380f, -0.01945117f, 0.00606234f, -0.04316337f, 0.00296636f, -0.00529567f, 0.06751778f, 
    0.13908969f, -0.01040381f, 0.05953605f, 0.18559560f, -0.00300029f, 0.01785612f, 0.04001818f, -0.05236525f, 
    -0.02172250f, 0.02273897f, 0.04156557f, -0.01373774f, 0.04359116f, -0.00838118f, 0.10430355f, -0.03210937f, 
    -0.01352763f, -0.07893330f, -0.01880345f, 0.03668659f, -0.05968761f, -0.05569826f, -0.09825006f, -0.02122121f, 
    0.13821253f, -0.12777358f, 0.21782593f, -0.10985617f, 0.05428733f, 0.11593198f, -0.05078338f, 0.04470493f, 
    0.02247329f, -0.22946988f, 0.06811241f, 0.04013357f, -0.12618767f, -0.07885262f, 0.01244164f, 0.02462023f, 
    -0.03558974f, -0.19611576f, -0.22502981f, -0.17178065f, -0.04000539f, -0.02878139f, -0.06233402f, -0.03080243f, 
    0.05517763f, 0.05905965f, 0.00532454f, 0.11654992f, -0.02819029f, 0.02558186f, 0.06054241f, -0.01177400f, 
    0.05473579f, 0.00061371f, 0.07909068f, -0.09863571f, 0.09313591f, 0.08437360f, -0.13023368f, -0.00352786f, 
    0.09475794f, 0.00670630f, 0.26008856f, -0.05587382f, 0.10768010f, 0.06904865f, -0.03957540f, 0.13134785f, 
    0.00302891f, 0.04007914f, -0.01914158f, -0.04767933f, -0.03541063f, 0.03028815f, -0.05226569f, 0.01720266f, 
    0.02239056f, -0.09610401f, -0.10373054f, 0.03179717f, 0.03885564f, -0.02004530f, -0.16890140f, 0.00304378f, 
    -0.13589038f, -0.01236887f, 0.04051594f, 0.01489497f, 0.04176458f, -0.00310683f, 0.04023860f, -0.02617453f, 
    -0.04163476f, -0.00694548f, 0.05027017f, 0.00115180f, 0.10445990f, 0.01535964f, -0.02880709f, 0.10603210f, 
    -0.20943947f, -0.27636698f, 0.28798932f, 0.16279233f, 0.01019001f, -0.04825342f, 0.02139873f, -0.06439373f, 
    0.01018011f, 0.19348520f, -0.00367230f, 0.02679646f, -0.06020734f, -0.00894546f, 0.01807506f, 0.00035001f, 
    0.02135110f, 0.00080292f, -0.04191386f, 0.02890687f, 0.11925778f, 0.01256467f, 0.10872973f, 0.01697566f, 
    0.08457607f, -0.07870534f, -0.01607137f, -0.02796395f, 0.03561376f, 0.10381665f, 0.11881511f, -0.00207130f, 
    -0.06480623f, -0.03884055f, 0.00911295f, 0.06921014f, 0.04509563f, 0.05881400f, -0.00521159f, -0.01581951f, 
    0.06979403f, 0.16195947f, -0.13195604f, -0.37593761f, 0.05892097f, 0.03919762f, 0.03782299f, -0.01155249f, 
    0.05628166f, 0.05765243f, 0.08604935f, 0.03744072f, 0.02219307f, 0.05057172f, -0.00851180f, 0.04188500f, 
    0.14345630f, 0.03021984f, 0.03071408f, 0.13050325f, 0.17431684f, -0.04722109f, 0.10738736f, 0.15126051f, 
    0.00768924f, -0.05165986f, -0.01699706f, -0.03613857f, 0.01648472f, 0.05885057f, 0.02438533f, -0.03692938f, 
    0.04343543f, 0.00178421f, 0.04798455f, 0.03988076f, -0.02598488f, 0.06022201f, -0.08711842f, -0.11198457f, 
    0.05386638f, -0.37867910f, 0.19230205f, 0.20939761f, 0.06594474f, -0.22775766f, -0.08712193f, -0.04145662f, 
    -0.23727566f, 0.18569529f, -0.03021255f, 0.04467554f, -0.02045816f, -0.10535045f, -0.00535008f, -0.00056953f, 
    0.06205894f, 0.09457713f, -0.08922536f, 0.00691930f, -0.31862280f, -0.24761444f, -0.02891124f, -0.26685742f, 
    -0.04073663f, 0.03395501f, 0.04022603f, 0.01025008f, -0.00129762f, 0.09905067f, -0.00123863f, -0.05299987f, 
    -0.06072973f, -0.14761126f, -0.04579937f, -0.22889967f, -0.03307532f, 0.03206906f, 0.02563528f, 0.10991583f, 
    -0.06926737f, 0.06941901f, 0.15973395f, 0.03813411f, 0.03556385f, -0.03027354f, 0.04590010f, -0.05631482f, 
    0.13805571f, 0.00668693f, 0.02012688f, -0.04001379f, 0.03705426f, -0.06296649f, -0.05053349f, -0.09224340f, 
    -0.05675407f, -0.04355188f, 0.01977105f, 0.06482375f, 0.04334171f, 0.01728353f, 0.26140875f, -0.23221885f, 
    0.12247580f, 0.00984646f, 0.16692172f, -0.04919845f, -0.05013742f, -0.12617436f, 0.02298440f, -0.02963440f, 
    -0.04192654f, 0.04871556f, -0.04880143f, -0.11282112f, 0.09357282f, -0.17280890f, 0.00325791f, -0.02927707f, 
    -0.14354819f, -0.09343394f, -0.02340914f, -0.06336011f, 0.03823864f, -0.05562861f, 0.01136849f, -0.01281666f, 
    -0.00677690f, -0.11825877f, 0.06825595f, -0.09673117f, -0.07127512f, -0.10531531f, 0.02733181f, 0.07389993f, 
    -0.00488067f, 0.00067318f, -0.02623051f, -0.02617517f, -0.00373960f, -0.07939662f, -0.12276555f, 0.10931358f, 
    0.21846987f, 0.00986353f, -0.03724752f, 0.02239183f, 0.04565328f, 0.07495070f, 0.04445664f, 0.00202578f, 
    -0.02962509f, -0.05061307f, 0.01106260f, -0.01744745f, -0.12492906f, 0.04470786f, -0.02368817f, -0.05011398f, 
    -0.05000913f, -0.47240871f, -0.05339596f, -0.03062733f, -0.13840598f, 0.02138947f, -0.06229081f, -0.02999347f, 
    -0.05071199f, 0.00968682f, 0.02414340f, -0.14639388f, 0.04923496f, 0.03397028f, -0.05362134f, 0.02744208f, 
    -0.21210577f, -0.06852590f, -0.15348679f, 0.00543331f, -0.04665383f, -0.08238779f, 0.00205769f, -0.27136433f, 
    0.10367000f, -0.10628656f, 0.00334500f, 0.02257211f, 0.10536721f, -0.06232847f, -0.07435688f, -0.08628848f, 
    -0.04243068f, 0.06333413f, -0.03533297f, -0.20426798f, -0.30300066f, -0.06616477f, -0.11216903f, -0.14040571f, 
    0.16152491f, -0.03598734f, 0.19136232f, 0.09255025f, 0.07447797f, -0.12939279f, -0.02974588f, -0.22911716f, 
    -0.08707787f, -0.04742279f, 0.09552829f, 0.00495034f, -0.00825767f, 0.05272051f, 0.01010153f, 0.05039711f, 
    0.00887946f, -0.00997730f, -0.00084968f, -0.10127762f, 0.00811400f, -0.00219695f, -0.11724120f, 0.15237750f, 
    0.11755481f, 0.02539813f, 0.12995769f, -0.10872078f, -0.02722235f, 0.05875278f, 0.06373058f, -0.05511157f, 
    -0.03990471f, -0.04592774f, 0.03007873f, -0.00698216f, -0.02307833f, -0.02120853f, -0.02928463f, -0.05251939f, 
    0.07578104f, -0.05550179f, -0.02470539f, -0.07798674f, -0.14036398f, -0.01056605f, -0.01967366f, -0.01087531f, 
    0.00436007f, 0.01957669f, -0.00731716f, 0.00390466f, 0.00203168f, -0.03499317f, -0.07409999f, 0.01955213f, 
    -0.07721031f, 0.00555504f, -0.08404954f, -0.07186093f, -0.04150177f, -0.04448187f, 0.05164040f, 0.13954623f, 
    0.14255162f, -0.11416462f, 0.08256691f, -0.02809412f, 0.00610655f, -0.15105863f, -0.01481317f, -0.00792578f, 
    -0.01085004f, 0.07306971f, 0.10704257f, -0.04585859f, 0.04048352f, 0.03222643f, -0.14135186f, -0.20778930f, 
    0.18763527f, -0.03025935f, -0.04946717f, 0.19691125f, 0.08364274f, 0.07302772f, 0.01200131f, 0.06410078f, 
    0.03201695f, 0.03466595f, 0.08286268f, 0.01105128f, 0.00748221f, -0.01150950f, 0.04351346f, -0.04058607f, 
    0.02122790f, 0.01000216f, -0.08287527f, 0.11477309f, 0.05008454f, 0.01516028f, 0.00963985f, -0.07084391f, 
    -0.00821861f, 0.08649727f, 0.02536759f, 0.01007670f, -0.00149339f, 0.07186376f, 0.06596051f, 0.02892831f, 
    0.06571896f, -0.00102934f, 0.08589659f, 0.08558180f, 0.02673296f, 0.01885704f, -0.02823805f, 0.05156488f, 
    0.03146566f, -0.17198220f, 0.03317399f, -0.29313931f, 0.03801381f, -0.03112828f, 0.10562924f, 0.07416487f, 
    0.07320375f, -0.19658355f, -0.04421136f, -0.05735252f, -0.08830583f, 0.07833090f, -0.02158169f, -0.22206984f, 
    -0.06493048f, -0.05936973f, -0.00981744f, -0.05324176f, 0.01176907f, -0.00282628f, 0.08245643f, 0.12120460f, 
    0.00163981f, -0.17338604f, -0.15018739f, -0.09192552f, -0.11775788f, -0.04357073f, -0.03300287f, -0.00068647f, 
    0.03705746f, 0.01307091f, -0.03545320f, 0.02093429f, -0.03201362f, -0.10509501f, -0.00794831f, -0.05384998f, 
    -0.13168342f, -0.31521130f, 0.02715928f, -0.09100389f, -0.01555139f, -0.07867283f, -0.02837984f, -0.11571307f, 
    -0.02671735f, -0.03110807f, -0.07941198f, -0.02649923f, 0.05755968f, 0.08628026f, 0.04190573f, -0.05588100f, 
    -0.02463966f, 0.06186795f, -0.05784745f, -0.11051998f, 0.11249190f, 0.03346562f, 0.20705985f, 0.15637785f, 
    0.17343096f, 0.02026475f, -0.07930177f, -0.04729202f, -0.09268537f, -0.04512548f, 0.07387093f, 0.01041973f, 
    0.00131015f, -0.02066115f, -0.00141497f, -0.02496539f, -0.04270976f, -0.02610350f, -0.04812678f, -0.08858614f, 
    -0.01718600f, -0.01448309f, -0.04938439f, -0.06064491f, -0.00940079f, 0.04485946f, -0.01057184f, 0.04451283f, 
    -0.06436017f, 0.01461973f, -0.04775869f, 0.02112316f, 0.19696149f, -0.09300076f, -0.04896025f, 0.06849841f, 
    -0.08800470f, -0.03146801f, -0.05962157f, -0.01541440f, -0.28498924f, -0.12876140f, -0.11480941f, -0.01767977f, 
    -0.04940618f, -0.10177802f, -0.04588486f, 0.06877125f, -0.23058708f, -0.03998417f, 0.01761006f, 0.02200419f, 
    -0.03478095f, 0.05377724f, 0.01229214f, 0.09762274f, 0.16900192f, 0.12103393f, -0.01046501f, 0.28572497f, 
    0.01926351f, -0.00709443f, 0.01916982f, -0.03870229f, -0.00144252f, 0.02853508f, -0.04655309f, -0.12061924f, 
    0.05207593f, -0.08305074f, 0.03083667f, -0.11649849f, 0.02134126f, -0.10471326f, 0.04532688f, -0.05361023f, 
    -0.20276776f, -0.03231595f, -0.10540827f, -0.04602121f, 0.13812041f, -0.13718128f, -0.09720664f, 0.23708303f, 
    -0.28425667f, 0.06237989f, -0.18386219f, 0.14430669f, 0.03297337f, 0.02926282f, 0.03085450f, -0.07088552f, 
    -0.04658175f, -0.03615586f, 0.07901747f, -0.02077089f, 0.03938740f, 0.03888832f, -0.33752862f, 0.05907087f, 
    0.09326763f, -0.43361360f, -0.28740507f, 0.22783002f, -0.28050742f, 0.03164962f, -0.03682398f, 0.03595680f, 
    -0.09398378f, -0.02323036f, 0.05012497f, -0.07453182f, 0.01580963f, 0.05958145f, -0.05088780f, -0.03873827f, 
    0.15012902f, 0.06240733f, 0.06992407f, 0.07337148f, 0.05310543f, 0.02616055f, 0.04805507f, -0.01434676f, 
    -0.01351198f, 0.04977323f, 0.00834038f, 0.03151276f, 0.05611471f, 0.03045488f, 0.10620628f, 0.06073335f, 
    0.00062671f, 0.01615321f, 0.08996087f, -0.00129520f, 0.03769029f, -0.19380820f, 0.01745490f, 0.13085495f, 
    0.05206130f, 0.01646476f, 0.02439318f, -0.03703818f, -0.03256812f, 0.06564499f, 0.05823385f, 0.08385436f, 
    -0.00098501f, 0.03191350f, 0.10371955f, 0.08199028f, -0.03325588f, -0.04427047f, 0.00769131f, 0.14297123f, 
    0.13597421f, -0.08021114f, -0.06682346f, 0.02046444f, 0.19756988f, 0.00096404f, 0.08133549f, 0.11224163f, 
    0.02182088f, -0.17661928f, -0.03889728f, -0.14562595f, 0.06853171f, 0.10285817f, 0.15462247f, 0.00858710f, 
    -0.12084819f, 0.02659025f, -0.02461739f, 0.02531766f, 0.02972615f, -0.03775954f, 0.01203685f, -0.01490116f, 
    0.01465182f, -0.03786001f, 0.02216703f, -0.08462754f, -0.14227132f, 0.05769713f, 0.01095201f, -0.01575540f, 
    0.04900857f, -0.00116881f, 0.07065517f, -0.00801104f, -0.06212148f, 0.09343427f, -0.05096823f, -0.14822631f, 
    -0.03331681f, -0.05308626f, -0.03525950f, -0.04117044f, 0.20964003f, 0.04821400f, -0.33404100f, 0.15451042f, 
    0.25330099f, -0.04068689f, -0.02141121f, 0.09917207f, 0.09390384f, -0.00929386f, 0.03145725f, -0.03045581f, 
    -0.01733587f, -0.02750463f, 0.06162277f, -0.06382076f, 0.05231236f, -0.00266163f, -0.07208931f, -0.08751198f, 
    0.04910069f, 0.02693428f, 0.17737594f, 0.14936954f, 0.10299819f, -0.14810315f, -0.01471753f, -0.10839263f, 
    -0.04642094f, 0.08519601f, 0.00461071f, -0.01588772f, 0.01585941f, 0.07564590f, 0.00566764f, 0.00316388f, 
    -0.00610959f, -0.10104249f, 0.01593436f, -0.01150487f, -0.36096114f, -0.17486453f, 0.04418978f, 0.04432927f, 
    0.26050505f, -0.29487836f, 0.23499013f, -0.05337084f, 0.15250552f, -0.02154735f, -0.05644525f, -0.09037355f, 
    -0.05370364f, -0.01949784f, 0.07436769f, -0.22336914f, -0.04991905f, -0.12545981f, 0.02339274f, -0.14615576f, 
    -0.20858705f, -0.16593029f, 0.05149608f, -0.17294282f, 0.02333601f, 0.04143962f, 0.06313796f, 0.15188521f, 
    -0.08164980f, -0.06213625f, 0.03506318f, -0.05058708f, 0.11079966f, -0.20658301f, -0.11125276f, 0.06951839f, 
    -0.09824001f, -0.01630614f, -0.14389317f, -0.04154899f, -0.00021018f, -0.10627072f, -0.05032874f, -0.07729319f, 
    -0.03107951f, 0.13508832f, 0.07775187f, 0.06076143f, -0.12888475f, -0.11524474f, 0.03896886f, -0.16333084f, 
    -0.10734219f, -0.04399497f, 0.21080248f, -0.12374253f, -0.18478681f, 0.02975732f, -0.07481015f, -0.19891270f, 
    -0.01124176f, -0.10889395f, -0.00503786f, -0.61449087f, -0.25686616f, 0.02107283f, -0.00184021f, 0.09135644f, 
    0.12585928f, -0.00474059f, 0.08864988f, 0.07752427f, -0.03077685f, -0.01007025f, 0.02559709f, 0.13161963f, 
    0.13837236f, -0.17729715f, 0.00468740f, 0.10491658f, 0.19742273f, 0.18413930f, -0.24119568f, 0.21499114f, 
    0.27354622f, 0.00798461f, 0.05351923f, 0.06655487f, 0.02497620f, 0.09717055f, 0.05994535f, 0.03196261f, 
    0.00235404f, -0.05007458f, 0.02708783f, 0.09989185f, 0.00538911f, 0.10710732f, -0.05997026f, -0.05407134f, 
    -0.14911675f, -0.16601054f, 0.04312162f, 0.10523873f, 0.08089799f, -0.07498499f, 0.02466240f, 0.02654624f, 
    -0.21288790f, -0.11111394f, 0.00291281f, 0.01789682f, 0.01672955f, -0.02880635f, -0.13894142f, -0.07743900f, 
    0.13152626f, 0.00976411f, -0.05949769f, 0.06520239f, 0.10623956f, 0.01207690f, 0.17940755f, -0.03839715f, 
    -0.00464771f, 0.03655902f, -0.04431311f, -0.15405612f, -0.03442343f, 0.05941948f, 0.09211405f, -0.01533946f, 
    0.05702895f, -0.02049024f, 0.02369386f, -0.05342713f, -0.04243908f, -0.08102930f, -0.03641908f, -0.09622360f, 
    -0.10369886f, 0.04916943f, 0.04727992f, -0.03943444f, 0.04047867f, -0.04394224f, 0.08840681f, 0.03488951f, 
    0.05802321f, 0.06593802f, 0.02686108f, 0.00932706f, 0.01583751f, 0.08243205f, -0.01978408f, 0.08804347f, 
    0.08974033f, 0.01391584f, 0.00550968f, 0.27516651f, -0.02249087f, 0.02464136f, -0.10413927f, 0.04997281f, 
    -0.04713386f, 0.05506226f, 0.01649904f, -0.00357113f, -0.01214848f, 0.05049311f, -0.07595930f, 0.03254817f, 
    0.00954515f, 0.00663821f, 0.06089702f, 0.04703024f, -0.14784479f, -0.11904762f, -0.01910356f, -0.01077211f, 
    0.01310274f, 0.10825806f, 0.24398574f, 0.25068167f, 0.14121489f, -0.11423361f, 0.04363693f, 0.03117168f, 
    0.00378067f, 0.20156685f, 0.01061067f, 0.00178971f, 0.04194778f, -0.00320208f, 0.04864416f, -0.03003328f, 
    -0.03107296f, -0.06532656f, -0.01475652f, -0.09769105f, 0.14447179f, 0.12264643f, 0.03463883f, 0.19935825f, 
    0.13627979f, 0.10935740f, 0.16286014f, 0.06446621f, 0.10855241f, 0.13170023f, 0.00078757f, -0.05326624f, 
    0.01795420f, -0.01162500f, -0.02548567f, 0.09882416f, 0.04524027f, -0.09991710f, 0.14700869f, 0.16170663f, 
    0.08167396f, 0.14356375f, 0.35165527f, 0.21869022f, 0.23398919f, -0.03565586f, 0.04729268f, 0.12467790f, 
    -0.01218469f, 0.09381399f, 0.01996233f, 0.00308157f, -0.01006662f, -0.05312504f, 0.02478543f, -0.00487218f, 
    -0.00623620f, -0.18332061f, -0.03228882f, -0.08402420f, 0.06521358f, -0.09379663f, -0.20965689f, -0.04540357f, 
    -0.41611910f, 0.09488963f, -0.05090720f, 0.04523669f, 0.00638935f, 0.01094343f, -0.05955654f, 0.02606524f, 
    -0.11808439f, -0.10542371f, -0.10126908f, -0.07552271f, -0.05895729f, -0.02420464f, -0.00362935f, 0.24946617f, 
    -0.05872253f, 0.08268771f, 0.21717788f, 0.03335344f, 0.13992876f, -0.09123962f, 0.09522042f, -0.12420974f, 
    0.06398774f, 0.17049706f, -0.00854050f, 0.00411127f, -0.00390415f, 0.07583063f, 0.02937003f, 0.07219671f, 
    0.04721408f, -0.15660487f, -0.02849335f, 0.17335968f, 0.14035212f, -0.02131615f, 0.13466607f, -0.13824996f, 
    0.05015726f, 0.12945716f, -0.05730747f, 0.06124496f, -0.01065627f, 0.02281800f, -0.02523668f, -0.05436699f, 
    -0.00083921f, 0.03263209f, -0.01069883f, 0.02640460f, -0.06334149f, -0.05924777f, -0.11736255f, -0.18656531f, 
    0.08608400f, -0.11692692f, 0.04909875f, -0.15089996f, -0.04549741f, 0.07185782f, 0.01424398f, 0.04978592f, 
    0.05562460f, 0.00632938f, 0.03841003f, -0.01772946f, -0.02524506f, 0.07044256f, -0.07111260f, -0.01924375f, 
    -0.17265089f, -0.04488172f, -0.12148327f, -0.17661370f, -0.32340235f, -0.19989957f, 0.10684627f, -0.07130475f, 
    -0.03858359f, -0.10613916f, 0.01539271f, -0.14148279f, 0.01073677f, -0.00118446f, 0.02465116f, -0.03632166f, 
    -0.02349307f, 0.11516514f, 0.03435626f, -0.02186202f, 0.04354472f, -0.00048770f, -0.06856426f, -0.06262941f, 
    -0.70866650f, 0.00023847f, -0.01723826f, -0.40231702f, -0.16028215f, 0.05128640f, 0.03687420f, -0.04623691f, 
    0.12076708f, 0.10048302f, -0.10498515f, 0.01802610f, 0.01538208f, -0.04733041f, -0.01258835f, -0.10801810f, 
    -0.03329705f, 0.11713906f, -0.06713688f, 0.12929825f, 0.13633470f, 0.09270381f, 0.06078777f, 0.02166011f, 
    -0.05287275f, 0.02460185f, -0.04083621f, 0.00485779f, -0.02282150f, 0.07667212f, 0.09486552f, -0.00348898f, 
    0.02646448f, 0.04608525f, 0.00713184f, 0.06752322f, -0.06226146f, -0.03406748f, -0.05342037f, -0.04373867f, 
    0.02888110f, -0.10907834f, 0.08183943f, 0.08886272f, -0.02841190f, -0.15451911f, -0.05025469f, 0.06180678f, 
    -0.05549336f, -0.12831758f, 0.00562261f, -0.04812710f, 0.00077097f, -0.01376105f, -0.03885831f, -0.06058114f, 
    -0.01817429f, -0.00282268f, 0.04855259f, -0.03175849f, 0.10744977f, -0.21317294f, 0.02347340f, -0.00552195f, 
    -0.05271409f, 0.04390735f, -0.08356934f, 0.00999403f, -0.06354033f, 0.04186445f, 0.04555247f, -0.04741960f, 
    -0.06533936f, -0.03110743f, -0.02187646f, 0.01007777f, -0.02068255f, 0.04102574f, -0.13967034f, 0.02399254f, 
    0.14302033f, -0.14346415f, 0.15964784f, -0.15756711f, -0.02829208f, 0.00833965f, -0.04783091f, 0.05142301f, 
    -0.03583508f, -0.09393215f, -0.00478552f, -0.07903261f, 0.00019627f, 0.06535080f, -0.02476239f, -0.01902150f, 
    -0.08268108f, -0.13342766f, -0.09701328f, -0.13374351f, -0.11020823f, -0.11391424f, 0.06117282f, 0.08668763f, 
    0.07154321f, -0.09678467f, -0.00424455f, -0.03741945f, -0.08120292f, -0.05634622f, -0.03952737f, 0.00726815f, 
    0.02111010f, 0.06789639f, 0.01452083f, 0.07511678f, 0.09225774f, -0.02478690f, 0.07253279f, 0.12717110f, 
    -0.02612088f, -0.07702032f, 0.15666057f, -0.08388042f, -0.02872446f, 0.05314831f, 0.04834869f, -0.06522722f, 
    -0.09305278f, 0.06599408f, -0.00144161f, -0.01190272f, -0.03242360f, 0.01184280f, -0.07475306f, 0.06424738f, 
    -0.00371321f, -0.11575297f, -0.04035933f, -0.10016201f, -0.22760388f, -0.04936951f, 0.07223231f, 0.17328183f, 
    -0.01622465f, 0.08054785f, -0.01973459f, -0.04747525f, 0.00433513f, 0.07747706f, -0.10262611f, -0.10299262f, 
    -0.10393717f, 0.06231706f, -0.05944089f, -0.06476177f, -0.08539660f, -0.02843254f, -0.03552528f, 0.03343714f, 
    -0.05881085f, -0.00661936f, 0.34980363f, 0.05651711f, -0.27113348f, -0.08698875f, 0.00955859f, 0.01575469f, 
    0.12081849f, 0.07440110f, -0.01326086f, 0.02267207f, 0.00540865f, 0.00444779f, 0.02306408f, 0.03568620f, 
    -0.06731632f, -0.06643317f, -0.05526302f, -0.11612071f, 0.02790017f, -0.03631141f, -0.12935881f, 0.09636790f, 
    0.04041861f, 0.02534178f, -0.11533493f, -0.04090545f, 0.02625348f, 0.04361887f, -0.10154352f, -0.02381298f, 
    0.02276385f, 0.00315527f, -0.07714264f, 0.06848956f, 0.06861672f, 0.04685126f, -0.05424856f, 0.04938722f, 
    0.25724450f, -0.13514464f, 0.16380963f, -0.02648403f, -0.15196763f, 0.13661087f, 0.01044095f, 0.21990216f, 
    -0.09044799f, 0.02150449f, -0.00879458f, -0.05410960f, 0.00403882f, -0.08235304f, -0.01608667f, -0.09999464f, 
    0.03261978f, 0.08775812f, 0.20014438f, 0.10608856f, 0.04042357f, 0.08574596f, -0.21421990f, 0.01923747f, 
    0.16132329f, 0.16503781f, -0.04826741f, -0.00380958f, -0.02917313f, -0.02566702f, -0.06236730f, 0.06711093f, 
    -0.01663514f, -0.02078467f, -0.03618712f, 0.08541834f, -0.13520828f, 0.15441424f, -0.04517817f, -0.05426928f, 
    -0.00179788f, 0.02099185f, 0.12486397f, -0.04563406f, 0.06863967f, 0.08392131f, 0.05048830f, -0.10206169f, 
    0.01622168f, -0.11450429f, 0.03838531f, -0.00553442f, 0.06976703f, 0.07760728f, -0.01827095f, 0.03219435f, 
    -0.01448483f, -0.09762260f, -0.05733136f, -0.18337460f, -0.00952385f, -0.07912605f, -0.05236341f, 0.04140236f, 
    0.04550657f, 0.05151168f, 0.01193294f, -0.06080956f, -0.06400647f, 0.09209660f, 0.02530872f, -0.04405721f, 
    0.05034119f, 0.04688669f, -0.00267847f, -0.11677758f, -0.14629249f, 0.07097115f, -0.07784063f, -0.05254260f, 
    -0.41711795f, 0.27177933f, -0.51794362f, -0.40644604f, -0.12842366f, -0.10324076f, -0.08392028f, 0.03181600f, 
    -0.14818688f, -0.03589567f, -0.11359455f, -0.02096667f, -0.11324752f, 0.10134885f, 0.02324733f, -0.11384545f, 
    -0.10887814f, 0.09230102f, -0.05818580f, -0.10250540f, -0.28346151f, 0.00999287f, -0.22051086f, -0.09385518f, 
    -0.08930423f, 0.04743290f, 0.02767200f, -0.02267573f, 0.03323795f, 0.03598312f, 0.12285859f, -0.07950895f, 
    0.05139698f, -0.06318683f, -0.07966406f, -0.06070922f, -0.00140312f, 0.05913090f, 0.00115512f, -0.00890778f, 
    -0.20888050f, -0.09350658f, 0.12827413f, -0.20806970f, 0.22991863f, 0.07617385f, 0.01993044f, -0.02452821f, 
    -0.01509539f, -0.02823540f, 0.01397498f, 0.02440440f, 0.05510475f, 0.00029370f, -0.00839105f, -0.21020021f, 
    0.01321846f, -0.10510679f, 0.19877028f, -0.06244845f, -0.08026823f, 0.02308930f, 0.09410319f, -0.21612540f, 
    -0.09243441f, -0.01525125f, 0.03568196f, -0.00876217f, 0.01300689f, 0.17140417f, 0.04253199f, 0.14547651f, 
    -0.08178481f, -0.00755480f, -0.03334561f, 0.01146108f, 0.05674753f, 0.01587317f, -0.02948155f, 0.07266343f, 
    -0.73956978f, -0.06475701f, -0.26054883f, -0.29620197f, -0.40531197f, -0.02370927f, 0.03458544f, 0.03620336f, 
    -0.07064034f, 0.01734411f, 0.04107559f, 0.06050843f, -0.06774089f, 0.00402860f, 0.10024913f, -0.02185453f, 
    -0.01610322f, -0.01202521f, 0.03184020f, 0.03961594f, 0.21010356f, 0.11400293f, -0.22798733f, -0.02745161f, 
    -0.06804964f, 0.00561496f, -0.09419434f, 0.00498003f, -0.09913481f, -0.07385654f, -0.23408575f, -0.01702466f, 
    -0.29192472f, 0.03011461f, 0.13781467f, -0.09927183f, -0.10442740f, 0.07677360f, -0.09540875f, -0.06868469f, 
    0.41284412f, 0.22115833f, -0.01468711f, -0.11337423f, 0.11392189f, -0.02153551f, 0.14534903f, 0.15840228f, 
    0.03131305f, 0.09248326f, 0.03312237f, 0.04427095f, -0.00362989f, -0.03563305f, -0.00244939f, 0.00653370f, 
    -0.00516293f, -0.06399143f, 0.01200068f, 0.09976154f, -0.00582452f, 0.18687932f, 0.13982341f, -0.16386664f, 
    0.13972211f, -0.01832158f, -0.00781872f, -0.09732454f, -0.00305555f, 0.16622463f, 0.01839978f, -0.00949009f, 
    -0.01540734f, -0.06015412f, 0.02702358f, -0.02689789f, -0.08647377f, -0.06940219f, 0.02766145f, -0.08083659f, 
    0.14737992f, -0.22443447f, -0.01332750f, 0.03617453f, -0.01413357f, 0.11616683f, -0.02249366f, -0.00219126f, 
    0.00968503f, -0.04018163f, 0.02474898f, -0.00174402f, 0.09956359f, 0.03907440f, 0.03463051f, -0.09093514f, 
    0.02264242f, 0.03709292f, -0.05267084f, -0.07635435f, -0.15366109f, -0.18309702f, -0.13215472f, 0.23267287f, 
    -0.01752088f, 0.06717149f, 0.03809734f, 0.06889902f, 0.06776973f, -0.05693278f, -0.00825106f, -0.02495834f, 
    -0.00141288f, 0.01190053f, -0.03259055f, 0.03309087f, -0.04897537f, 0.31343588f, -0.02796522f, -0.01257551f, 
    -0.32572418f, 0.10470303f, -0.10477505f, 0.22352162f, -0.14635344f, -0.01111406f, -0.21253130f, -0.08565534f, 
    0.04007452f, 0.12113869f, 0.11220782f, 0.03293652f, -0.10154068f, -0.04784021f, 0.12584025f, -0.04651403f, 
    0.07859300f, 0.08111446f, -0.08258417f, 0.02558311f, 0.26416531f, -0.21789689f, 0.17331383f, 0.01518607f, 
    -0.14542142f, -0.00353850f, -0.04559912f, -0.26836321f, 0.01995503f, 0.11352012f, 0.07630493f, 0.11111738f, 
    -0.06567956f, 0.00670778f, 0.07048218f, 0.11014508f, -0.01505032f, -0.07903679f, 0.15886769f, 0.36477605f, 
    -0.12110041f, -0.14028196f, -0.03422289f, -0.20938802f, -0.27416962f, -0.02169875f, 0.05323702f, -0.01515403f, 
    0.11378147f, 0.14812905f, 0.07089349f, 0.02860903f, -0.10233441f, -0.02054827f, -0.04795000f, -0.01670812f, 
    0.08679228f, 0.01247005f, 0.04218300f, 0.07506985f, -0.21257414f, -0.05436815f, -0.06863461f, 0.17512503f, 
    -0.08364294f, 0.00684872f, -0.07606902f, 0.12752783f, 0.07964875f, -0.00252301f, -0.01155825f, 0.01243697f, 
    -0.02178107f, -0.00446674f, 0.01851396f, 0.06763458f, -0.01026180f, 0.22536141f, -0.07286715f, 0.01010536f, 
    -0.06360745f, -0.07003669f, -0.14410067f, 0.00600323f, 0.00110574f, -0.09617836f, -0.01354970f, -0.04811475f, 
    -0.09304062f, 0.01585232f, 0.15866931f, 0.06107569f, -0.03005829f, -0.04970633f, 0.04209415f, -0.05002625f, 
    -0.07422403f, -0.04820291f, 0.10780380f, 0.18846788f, 0.18129915f, 0.02249159f, 0.17327091f, 0.00542926f, 
    -0.10288442f, 0.06869855f, -0.05041934f, -0.05551565f, -0.08772635f, 0.10071991f, 0.02973312f, 0.02225953f, 
    0.03036703f, 0.01902151f, -0.04125798f, 0.01168090f, 0.01614274f, 0.04262548f, 0.11516509f, 0.23381485f, 
    -0.25404945f, -0.00865849f, -0.07547405f, 0.09604524f, -0.04311284f, 0.08337718f, -0.01280868f, -0.06397954f, 
    -0.01327512f, -0.04223931f, 0.03687472f, -0.01877584f, -0.03157000f, 0.04931521f, -0.03912523f, -0.12323398f, 
    -0.09384145f, -0.01038995f, 0.03550828f, -0.01696003f, -0.02798828f, -0.05397247f, -0.13801821f, -0.00288183f, 
    0.01867077f, -0.00934388f, 0.03073517f, -0.00399745f, -0.02902045f, -0.01182770f, 0.12408290f, 0.00840332f, 
    -0.01227888f, 0.10813840f, 0.03450559f, -0.02413685f, 0.00848100f, 0.11186006f, 0.05217035f, 0.03442103f, 
    0.16584376f, -0.09542897f, 0.21238694f, -0.15635157f, -0.15009633f, 0.11848312f, -0.12652630f, -0.03215979f, 
    0.00732743f, 0.08476745f, 0.08191094f, 0.06715653f, -0.02100315f, -0.06558650f, 0.05674971f, 0.03742357f, 
    -0.19586240f, 0.01101568f, 0.01987663f, 0.15301536f, 0.22470815f, -0.11752750f, 0.14552940f, 0.22784731f, 
    -0.26379567f, -0.00973845f, 0.02837218f, 0.08026105f, -0.13392787f, 0.02164663f, 0.06248548f, -0.01102402f, 
    -0.01765550f, -0.01620335f, 0.12341117f, -0.08766028f, 0.00866221f, 0.02887263f, 0.04261564f, 0.06816702f, 
    -0.20856230f, 0.07129946f, -0.32723612f, -0.26955709f, 0.00885033f, -0.03984798f, -0.01869139f, -0.06047559f, 
    -0.09217747f, 0.19783215f, -0.07856325f, 0.20613857f, -0.08696213f, 0.01226852f, 0.01038840f, 0.00502863f, 
    -0.02988897f, 0.06037325f, 0.00571373f, 0.11873298f, 0.16335303f, -0.04997712f, 0.10339506f, 0.14215404f, 
    -0.11842257f, -0.06521423f, 0.06120409f, 0.03270306f, 0.06580595f, -0.01314645f, -0.03520591f, -0.00050422f, 
    -0.05477520f, -0.05363129f, 0.00554437f, -0.09921104f, 0.07667581f, 0.05642280f, -0.01325427f, -0.04640357f, 
    0.26442936f, 0.03803457f, -0.13394651f, -0.07879381f, 0.02362776f, -0.02813349f, 0.02016572f, 0.07214846f, 
    -0.07075060f, 0.02697820f, 0.03459886f, -0.11580376f, -0.13117801f, 0.00813061f, -0.05961491f, 0.10454914f, 
    0.04743492f, -0.01727506f, -0.07081882f, 0.03024141f, -0.00595802f, -0.00464338f, 0.17107287f, 0.16036315f, 
    -0.20140475f, -0.01201522f, -0.09597410f, 0.01441484f, -0.00573393f, -0.13214144f, -0.00217850f, 0.05148999f, 
    -0.00995888f, -0.02533802f, 0.05805003f, -0.01284943f, 0.05327976f, -0.13434273f, -0.36742556f, -0.37881559f, 
    -0.06028866f, -0.16903166f, -0.05173213f, 0.13835661f, -0.12750633f, 0.15207756f, -0.02639169f, -0.08787123f, 
    0.03875148f, 0.07757498f, -0.04580241f, 0.00530676f, -0.07787572f, 0.02948042f, -0.09647318f, 0.12904710f, 
    0.04906485f, 0.01963432f, 0.04220263f, 0.10833067f, -0.58191311f, 0.78241664f, 0.06362458f, -0.04190528f, 
    0.20143279f, 0.09994194f, -0.18883194f, 0.08424530f, 0.07032676f, -0.27545395f, 0.08440793f, -0.06859174f, 
    0.00306322f, -0.04559225f, 0.07815234f, 0.06450746f, -0.03713683f, 0.09322794f, 0.20044832f, -0.02915542f, 
    -0.31013346f, 0.16039546f, 0.21274881f, 0.09607034f, -0.20291854f, -0.00052840f, -0.00789110f, -0.01162346f, 
    0.13093141f, -0.00296030f, -0.08221793f, -0.00526507f, -0.04610120f, -0.03580362f, -0.02169460f, -0.13476796f, 
    -0.11622950f, 0.00918645f, -0.16157891f, -0.05582465f, -0.17290741f, -0.15337013f, -0.03033528f, 0.09480821f, 
    0.02220298f, 0.04541039f, 0.04205390f, -0.08007071f, 0.01447944f, 0.02918850f, 0.02107457f, -0.02389990f, 
    0.00951201f, -0.00471443f, 0.00002571f, -0.02752383f, -0.00948162f, 0.15934506f, 0.07573228f, -0.05596389f, 
    -0.21588698f, -0.07474176f, -0.14917417f, 0.01807557f, 0.07369324f, 0.02499622f, 0.05193543f, -0.05966325f, 
    -0.10483242f, -0.05079063f, 0.19147199f, -0.06855801f, 0.09686080f, -0.08230480f, 0.01025385f, -0.02448621f, 
    -0.05406114f, -0.03640863f, 0.10155179f, -0.01629198f, -0.43078554f, 0.23738518f, -0.15301803f, 0.00352163f, 
    -0.11942128f, 0.03606936f, -0.01937782f, -0.02722732f, 0.02097961f, 0.20506313f, 0.10517340f, -0.13960230f, 
    0.05715702f, -0.05726473f, -0.03481443f, -0.06485176f, -0.00974822f, 0.05615701f, 0.03266124f, 0.07809807f, 
    0.05406897f, 0.01042213f, -0.17765315f, -0.24417165f, 0.17084308f, 0.03975713f, 0.03944151f, 0.00674593f, 
    -0.09472942f, 0.02239451f, 0.05847938f, -0.05708585f, -0.05236473f, 0.07338998f, 0.03085245f, -0.07730387f, 
    0.14799298f, 0.02876946f, -0.11223897f, 0.02806501f, 0.17386970f, 0.00318453f, -0.21929763f, 0.17738581f, 
    -0.12345802f, 0.02020279f, -0.00008356f, -0.02677295f, 0.00334606f, 0.13153365f, -0.02247943f, 0.07334398f, 
    0.00260228f, -0.04275378f, -0.00871015f, 0.13396531f, -0.15724185f, 0.12483873f, -0.01089686f, 0.05352595f, 
    -0.01191179f, -0.05538967f, 0.20939967f, -0.08724229f, -0.18408471f, 0.19190341f, 0.05553363f, 0.15446608f, 
    -0.01167032f, -0.08381300f, 0.05355468f, -0.03066741f, 0.02604828f, 0.03011770f, -0.00115450f, -0.01815456f, 
    0.00924584f, -0.01301894f, 0.13656726f, 0.01487301f, 0.05593968f, -0.26957083f, -0.01285974f, 0.15916994f, 
    -0.13004035f, 0.11378242f, 0.00321844f, -0.05642436f, 0.15033284f, 0.15191692f, -0.00091795f, 0.03942806f, 
    0.03233133f, 0.06125856f, 0.02550275f, -0.02290849f, -0.03848323f, -0.02706108f, -0.25112757f, 0.22330067f, 
    0.64532888f, -0.04698974f, -0.38629836f, 0.01239731f, 0.22266075f, 0.00600847f, -0.27876627f, 0.02355380f, 
    -0.16505541f, 0.11376793f, 0.05610167f, -0.01219388f, -0.08397748f, -0.01682488f, -0.17412366f, 0.16084425f, 
    0.13945682f, -0.10223879f, 0.05468296f, -0.03866205f, 0.11861531f, -0.08473860f, -0.07877162f, -0.06374665f, 
    0.14690070f, -0.06788098f, -0.21216501f, -0.48638445f, -0.17977621f, 0.24860829f, 0.11090804f, -0.06777454f, 
    0.01980725f, 0.20673375f, -0.16879798f, 0.18893814f, 0.17080601f, 0.02112014f, 0.05996282f, 0.27166012f, 
    -0.03161216f, -0.36218929f, 0.15741500f, -0.09286091f, 0.18209726f, 0.05386487f, 0.00288516f, -0.10408574f, 
    -0.02499828f, -0.04081452f, 0.05971598f, -0.02406758f, 0.08223730f, -0.07531188f, 0.08294325f, -0.16371921f, 
    -0.14513224f, 0.00780585f, 0.30919021f, -0.17799580f, -0.26624611f, -0.07167254f, -0.14483620f, 0.18026464f, 
    -0.00892138f, 0.04594661f, 0.03203159f, 0.04934722f, 0.06529830f, 0.01402435f, -0.01766780f, -0.03650826f, 
    -0.01532213f, 0.00537923f, -0.00336423f, -0.08725466f, -0.04178143f, 0.14269546f, 0.05609069f, -0.00854535f, 
    -0.15089145f, -0.07038736f, 0.09657140f, -0.11274328f, -0.16918755f, -0.02512963f, -0.05072721f, -0.05317736f, 
    -0.15696980f, -0.13333037f, -0.00772932f, 0.01910292f, -0.00946003f, -0.01836729f, 0.02521677f, -0.01890845f, 
    -0.05483343f, -0.24089138f, -0.14480267f, -0.08288359f, 0.12980130f, -0.00139636f, 0.05252183f, -0.12158548f, 
    -0.05641011f, -0.08633421f, 0.08279606f, 0.05903555f, 0.00462082f, 0.06191893f, -0.14798406f, 0.10970157f, 
    -0.11028755f, -0.00130678f, 0.02491111f, 0.00678368f, 0.11304999f, -0.02933780f, 0.11876871f, 0.18229400f, 
    0.28120330f, 0.10333631f, 0.07382550f, 0.10226781f, 0.07658239f, 0.01847288f, -0.05293979f, -0.11034377f, 
    0.03003761f, -0.03937083f, 0.02713621f, 0.04567026f, 0.01757316f, 0.01948199f, 0.01066357f, -0.01816036f, 
    0.02338831f, -0.23210888f, -0.12850642f, -0.26069224f, 0.04590961f, -0.00709895f, 0.03801864f, 0.06665301f, 
    -0.06800490f, -0.07220502f, 0.03397856f, 0.04843337f, -0.08405567f, 0.05184411f, 0.07011115f, -0.01832043f, 
    0.00931200f, -0.12208510f, 0.01095832f, 0.10344411f, 0.03376037f, -0.06863111f, -0.01725528f, 0.00599065f, 
    0.07743563f, -0.16663770f, 0.31473771f, -0.12006600f, -0.30832151f, 0.14832345f, 0.03842052f, 0.01017448f, 
    -0.06229704f, -0.21525069f, 0.08683347f, 0.00891481f, 0.02093680f, -0.01515920f, 0.04050015f, -0.02810324f, 
    0.02694583f, 0.01445702f, 0.09215283f, 0.14082688f, 0.15473053f, 0.07271134f, 0.13614801f, 0.15496896f, 
    -0.11884779f, 0.06471135f, -0.04868941f, 0.05718189f, 0.04365390f, 0.10285018f, 0.06200339f, 0.04904307f, 
    0.00741524f, 0.00682311f, -0.03717703f, -0.04549871f, 0.04122797f, 0.10602197f, -0.24159698f, -0.12849835f, 
    0.14182840f, 0.03052967f, 0.28783539f, -0.07025914f, -0.15844953f, -0.01137282f, -0.00724836f, 0.08058333f, 
    -0.12047366f, 0.01566713f, -0.07822215f, -0.02740701f, -0.02144725f, 0.01140996f, -0.00865386f, -0.01828727f, 
    0.01168526f, 0.03951410f, 0.01286133f, 0.10727061f, 0.02853003f, 0.04525105f, -0.01052789f, -0.04559309f, 
    -0.09203684f, 0.01893261f, 0.08644538f, 0.08176474f, -0.05311989f, -0.09390503f, 0.04963925f, -0.05171250f, 
    0.09391010f, 0.18748884f, -0.02583644f, 0.09083123f, -0.01514283f, 0.04543341f, -0.02671317f, -0.07433026f, 
    0.01155894f, 0.05827121f, 0.20363936f, 0.02710263f, -0.07273252f, 0.09622633f, -0.05376235f, 0.08201993f, 
    0.11734351f, -0.03501131f, 0.06203827f, 0.02896244f, 0.01840223f, 0.04760733f, -0.01158833f, 0.04229133f, 
    0.04742641f, -0.24599220f, -0.04589295f, -0.27604830f, 0.06395550f, -0.02251744f, 0.11039768f, -0.01486478f, 
    0.03055572f, -0.09153721f, 0.01395096f, -0.00802090f, 0.05008213f, -0.07227354f, -0.00447096f, -0.12444320f, 
    -0.00391195f, -0.04765012f, -0.01547772f, 0.04992815f, 0.01024263f, -0.03168008f, 0.02639962f, 0.11263470f, 
    -0.11106067f, -0.01884455f, -0.04987912f, -0.12291881f, 0.06939282f, -0.16330642f, -0.00833870f, -0.04189334f, 
    -0.06263166f, 0.03883874f, 0.13265866f, -0.01190298f, -0.06559135f, -0.20512849f, -0.03735237f, -0.01283699f, 
    -0.06105695f, 0.03904000f, 0.05732184f, 0.05184837f, -0.42632914f, 0.06894229f, -0.22011112f, -0.32186812f, 
    0.00195811f, 0.01000653f, -0.04585392f, 0.02301940f, -0.08871694f, 0.00112458f, -0.08223295f, 0.11106502f, 
    -0.07113060f, -0.10547178f, -0.01791290f, 0.00135162f, -0.07911862f, 0.10328396f, -0.05007637f, 0.01582454f, 
    0.31715679f, 0.18671957f, -0.49229804f, -0.10211681f, 0.22521153f, -0.06109479f, -0.04235818f, -0.02946241f, 
    -0.05021873f, -0.05322898f, 0.12486315f, -0.00027313f, -0.00769194f, -0.00298492f, 0.07978991f, -0.14162631f, 
    0.04073823f, 0.14132300f, 0.00795128f, -0.12167723f, 0.07241298f, -0.00245211f, 0.02890399f, -0.04074945f, 
    -0.02277938f, 0.00089760f, 0.02850049f, -0.01333416f, -0.03802991f, -0.02256905f, 0.03667292f, -0.05857580f, 
    0.03972226f, 0.00128762f, -0.00412739f, 0.03388793f, 0.04859091f, -0.03396178f, -0.03134451f, 0.02278645f, 
    -0.11991885f, -0.03159059f, 0.14120351f, -0.01978559f, -0.12340812f, 0.16617809f, -0.04865498f, -0.09654411f, 
    -0.10183845f, 0.14926837f, 0.04278045f, 0.06798293f, -0.05311678f, 0.03074361f, 0.02206174f, 0.06799882f, 
    -0.07520636f, -0.05592865f, 0.03818750f, 0.13632643f, -0.25166231f, 0.09073713f, -0.14598347f, -0.09132046f, 
    -0.06387920f, 0.02677537f, -0.03228371f, -0.07756376f, 0.01474889f, -0.05394154f, 0.19715630f, 0.05666250f, 
    0.08130522f, 0.06739495f, -0.11801108f, 0.03118655f, 0.04843279f, 0.08102752f, 0.05591953f, 0.01222290f, 
    -0.08562320f, -0.01508745f, 0.09137056f, -0.24344333f, 0.00367882f, -0.02497766f, 0.07305641f, 0.02970064f, 
    -0.03019602f, 0.03434832f, -0.01997607f, -0.01255272f, -0.02431525f, -0.09164169f, -0.05362667f, 0.05302548f, 
    -0.02009077f, 0.06963205f, 0.01146787f, 0.02787633f, -0.21088371f, 0.02593324f, 0.04748227f, -0.05892842f, 
    -0.10073984f, 0.00952716f, 0.00948100f, 0.00614158f, -0.07550331f, 0.03530436f, 0.01490428f, -0.04661091f, 
    0.00971448f, 0.04171397f, 0.05337898f, 0.02493430f, -0.03653002f, -0.03172175f, 0.02648657f, -0.12044021f, 
    -0.02133808f, -0.12694010f, 0.01175027f, 0.08161114f, -0.01741235f, -0.05176308f, 0.07253121f, -0.00945081f, 
    0.02922469f, -0.01162113f, -0.00973906f, -0.03822849f, -0.02734399f, 0.04355646f, 0.02079333f, 0.05473391f, 
    0.03439299f, 0.10634890f, 0.02271563f, 0.08642112f, 0.02315564f, 0.17140509f, -0.04929843f, 0.04388615f, 
    0.07719571f, -0.03628554f, 0.06159960f, -0.01231954f, -0.04191371f, 0.03810877f, -0.05779950f, 0.01287063f, 
    -0.00089131f, 0.07532694f, -0.06961270f, 0.00721693f, -0.09486784f, -0.08344968f, 0.03447129f, -0.00783757f, 
    -0.23547651f, -0.30713511f, -0.44084710f, -0.04834544f, 0.15676351f, -0.05381732f, 0.05698858f, -0.02687093f, 
    -0.06568051f, -0.14392602f, -0.01202580f, -0.02065882f, 0.02588265f, 0.03308652f, 0.01954120f, 0.02353329f, 
    0.00981236f, 0.10316675f, 0.13851655f, 0.08107588f, 0.04864202f, 0.08428129f, 0.03313913f, -0.03062424f, 
    0.03071056f, -0.05640014f, 0.00211604f, 0.02082595f, 0.01874447f, 0.05435504f, 0.06296216f, 0.05722706f, 
    -0.00518128f, -0.04864020f, 0.02080370f, -0.05031504f, -0.06553115f, -0.03614142f, 0.00898854f, -0.08036122f, 
    0.05986580f, 0.09862199f, -0.08718064f, -0.14486079f, -0.02767296f, 0.03708950f, 0.12284312f, 0.07860967f, 
    0.03519309f, 0.13803452f, -0.01153858f, 0.05090018f, -0.01905156f, 0.01946204f, 0.04882646f, 0.03414617f, 
    -0.01794754f, 0.10328534f, 0.04155584f, 0.03091504f, 0.15490012f, -0.05785815f, -0.10316802f, -0.06423029f, 
    0.02576855f, 0.07879985f, -0.02518808f, 0.10962699f, 0.01064958f, 0.01460395f, 0.01822088f, 0.02480187f, 
    -0.05259228f, -0.10500604f, -0.00485645f, -0.06958839f, -0.06264635f, 0.06086646f, -0.02538766f, 0.01401866f, 
    -0.26935336f, -0.35311174f, -0.49901474f, -0.04102197f, -0.33680376f, 0.06159291f, 0.17523701f, 0.00106529f, 
    -0.01174942f, -0.29332319f, 0.03549635f, -0.03968610f, -0.04331306f, 0.04680942f, 0.06938378f, -0.02781394f, 
    -0.07582524f, 0.14184462f, -0.03344329f, 0.07513846f, -0.02004611f, 0.11295284f, -0.02091830f, -0.05959643f, 
    0.04440552f, -0.00353228f, 0.00219599f, -0.00085809f, 0.01670758f, 0.00245064f, -0.03200894f, -0.01162773f, 
    -0.02011505f, -0.01411778f, -0.00718261f, 0.02356204f, -0.03112602f, -0.12097849f, 0.01067436f, 0.00579612f, 
    -0.28714389f, -0.14625295f, 0.17325512f, -0.24026610f, 0.53468454f, -0.06794721f, -0.14097579f, -0.03805284f, 
    0.11640658f, 0.14217116f, 0.02825519f, 0.10810104f, 0.13804048f, 0.16147161f, -0.10423008f, 0.01423716f, 
    0.03393141f, 0.09072826f, 0.01375711f, 0.03437821f, -0.41850761f, 0.34186974f, 0.28562850f, -0.00643476f, 
    0.04766864f, -0.13526694f, -0.01495946f, -0.05055274f, -0.06967139f, 0.25211990f, -0.13489135f, -0.04918559f, 
    0.05796342f, -0.00867217f, 0.01269403f, -0.01952922f, 0.00054339f, -0.05564091f, -0.00459696f, -0.01504962f, 
    -0.30467269f, -0.03655168f, 0.13975100f, -0.27403173f, -0.25978792f, 0.03247230f, 0.01008406f, 0.03565412f, 
    -0.01188907f, -0.03221437f, 0.00379496f, -0.04888154f, 0.01061204f, -0.01961805f, -0.02845187f, 0.04275186f, 
    0.05460612f, -0.09085718f, -0.07332972f, 0.08289330f, -0.27443925f, 0.24536690f, 0.19500424f, 0.04757417f, 
    -0.00806932f, -0.05502738f, -0.10885787f, -0.08838543f, -0.04408337f, -0.09003745f, 0.00480993f, 0.05028864f, 
    -0.05266392f, 0.01586713f, 0.03730056f, 0.01877142f, -0.02522922f, -0.00376879f, -0.07912265f, -0.07132026f, 
    -0.46065375f, -0.09761776f, 0.44780001f, -0.05110832f, 0.15625837f, -0.16209155f, -0.19667344f, -0.05791706f, 
    -0.21278571f, 0.11312256f, -0.07783362f, 0.10105403f, 0.06219419f, 0.01590549f, -0.07655512f, 0.03384987f, 
    0.03134720f, -0.00722110f, -0.02608825f, 0.01843058f, -0.09626915f, 0.02330243f, 0.06620032f, -0.16775645f, 
    0.04336647f, -0.00085048f, 0.05765854f, -0.06520902f, -0.02331690f, 0.05171805f, -0.05927024f, 0.00846741f, 
    0.08611993f, 0.16457851f, -0.09711549f, 0.06338746f, 0.06823938f, 0.00776616f, 0.03219071f, 0.11619528f, 
    0.16848764f, -0.31516579f, -0.40846545f, -0.07496170f, -0.00919721f, -0.03908239f, 0.08315833f, 0.07499442f, 
    0.12591673f, -0.31524274f, 0.05383508f, -0.00511903f, -0.00775645f, 0.01057296f, 0.03716549f, 0.00032111f, 
    0.01620788f, 0.12647636f, -0.01066946f, -0.03604245f, -0.13244916f, -0.31546178f, -0.23479889f, 0.24855952f, 
    -0.46637130f, -0.03173114f, 0.06059453f, -0.02008558f, -0.01064038f, -0.30120796f, 0.04166593f, 0.00504627f, 
    -0.04458226f, 0.07043573f, 0.11739635f, 0.02619720f, -0.00776150f, 0.19344117f, -0.04634819f, 0.01293338f, 
    -0.21347909f, 0.21474721f, 0.18058105f, 0.06690996f, 0.09125210f, -0.06361252f, 0.03920120f, 0.01075899f, 
    -0.06501731f, 0.05440794f, 0.09615545f, -0.01637762f, 0.07746837f, -0.00684227f, -0.01241710f, 0.05483720f, 
    -0.00611380f, 0.00830789f, 0.04211048f, -0.05909376f, 0.09035800f, -0.31955436f, -0.32091123f, -0.12925173f, 
    0.15548475f, -0.09849891f, 0.06442784f, 0.17295589f, 0.02981308f, -0.01298380f, -0.02124185f, -0.01712000f, 
    -0.04344479f, 0.00633256f, 0.05352777f, -0.09462895f, 0.01773194f, 0.01562643f, 0.06549454f, 0.01543416f, 
    -0.17118695f, 0.04694649f, -0.09752873f, 0.00914098f, 0.20602579f, -0.12266097f, 0.04243360f, 0.03411879f, 
    -0.03235330f, 0.17880335f, -0.00678029f, 0.02273056f, 0.14934541f, -0.05523247f, 0.13201083f, -0.15841980f, 
    0.08135734f, -0.10723897f, 0.08953857f, -0.14554778f, -0.18455501f, -0.11475530f, -0.08902659f, 0.03128643f, 
    0.00649005f, 0.15300557f, 0.03805897f, -0.06022144f, 0.29244375f, 0.01897151f, 0.05580501f, 0.00693700f, 
    -0.10977201f, 0.11145528f, 0.01602975f, -0.02354166f, 0.02356760f, -0.04719140f, 0.18705942f, 0.12082587f, 
    -0.70949435f, 0.54460317f, 0.23109411f, -0.31168249f, -0.18040194f, -0.26955330f, -0.01678469f, -0.16627425f, 
    0.07775711f, -0.01742418f, -0.01886788f, -0.00635351f, -0.02328381f, 0.03001503f, 0.04901663f, 0.01094456f, 
    -0.02472557f, 0.03637438f, -0.02695880f, -0.05604171f, 0.06077312f, -0.30659807f, -0.34157062f, -0.10955338f, 
    0.22087257f, -0.06730014f, 0.13698894f, 0.18149458f, 0.05766813f, -0.05500729f, -0.00162955f, -0.00756967f, 
    -0.03777457f, -0.01187310f, 0.02521137f, -0.03373868f, 0.00093282f, 0.05167253f, 0.09299709f, -0.01394457f, 
    0.00394443f, -0.02441200f, 0.02525052f, -0.01129036f, -0.01584669f, 0.00957309f, -0.00397842f, 0.01904734f, 
    0.00103701f, -0.00159232f, 0.07316165f, -0.01204062f, -0.03722692f, 0.07842032f, -0.02625492f, 0.00779701f, 
    -0.01840729f, 0.01777526f, 0.00152378f, 0.04368922f, -0.31222218f, -0.37706870f, -0.34867525f, 0.20824209f, 
    -0.05519675f, -0.07811347f, 0.05695670f, -0.01015704f, -0.01745121f, -0.10255140f, 0.07461811f, -0.00124197f, 
    -0.05069708f, 0.01615561f, 0.00421226f, -0.02475177f, -0.01585640f, 0.05537133f, 0.04055708f, 0.01611485f, 
    -0.00014370f, 0.01533041f, 0.04259126f, -0.07937293f, -0.04174343f, -0.04460170f, 0.03119094f, -0.01132350f, 
    -0.05810579f, 0.00985069f, -0.02554253f, -0.03463750f, -0.03783766f, -0.00005630f, -0.06492928f, -0.03744455f, 
    -0.00619010f, -0.03600864f, 0.02324827f, 0.01520444f, -0.03782000f, -0.03584600f, 0.06034844f, -0.10470849f, 
    -0.05888316f, -0.01593214f, -0.02920012f, -0.02490802f, -0.04984612f, 0.01251829f, -0.17828779f, -0.02693626f, 
    -0.07384184f, -0.03955408f, 0.00352377f, -0.02678061f, -0.08900211f, -0.02061692f, -0.03967697f, -0.02805878f, 
    -0.21178983f, 0.31232402f, -0.00342685f, -0.08050174f, 0.12891465f, -0.14258386f, 0.00356664f, 0.09338849f, 
    0.17085408f, 0.11016040f, 0.04675126f, 0.02504167f, 0.03654777f, 0.00710955f, 0.08043738f, 0.08360583f, 
    0.03352102f, 0.11533994f, 0.09919229f, 0.10816266f, -0.27823666f, -0.23963034f, -0.18474580f, -0.00318681f, 
    0.15374421f, -0.11478049f, 0.02934734f, -0.07371673f, -0.02054207f, 0.07051742f, -0.02216170f, 0.01848234f, 
    0.04605074f, -0.03860980f, 0.04299237f, -0.00139780f, 0.03993741f, -0.04754071f, 0.19588697f, -0.06724118f, 
    -0.20985463f, 0.33865973f, -0.01638710f, 0.00803885f, 0.23920497f, 0.00916980f, -0.05647842f, -0.04206334f, 
    0.11370873f, 0.00878615f, 0.12797190f, 0.06567661f, 0.02068375f, 0.13402554f, 0.04138564f, 0.06312767f, 
    0.00833547f, -0.04618895f, -0.05093714f, 0.00782986f, -0.47502649f, -0.18180111f, 0.19027530f, 0.06877059f, 
    -0.14062995f, -0.25411263f, 0.09235585f, -0.06217763f, -0.10400651f, -0.11967009f, 0.06960794f, 0.03138228f, 
    0.00489930f, -0.04768624f, 0.01901259f, -0.01416699f, 0.00370379f, 0.04149064f, 0.11538403f, -0.09097787f, 
    0.11275782f, 0.08848823f, -0.01635382f, -0.01753647f, 0.04486870f, 0.01533473f, 0.00841733f, 0.00960288f, 
    0.03818390f, -0.03040214f, -0.07938861f, -0.00463913f, -0.02387391f, -0.03460239f, -0.00285258f, 0.02559777f, 
    -0.10153434f, -0.02367570f, -0.07928178f, -0.06177192f, 0.03141665f, -0.26324648f, -0.45575458f, -0.12989251f, 
    0.28788960f, -0.08478253f, -0.00000202f, -0.00641510f, -0.13197309f, -0.04742103f, -0.05537339f, -0.01214808f, 
    -0.00778451f, 0.01719869f, -0.01035385f, 0.02753140f, 0.08993914f, 0.00745772f, 0.16013028f, -0.01793822f, 
    -0.13652714f, 0.09895530f, -0.01547363f, -0.05581524f, 0.19553693f, -0.06039087f, 0.04002155f, 0.04397884f, 
    0.01366462f, 0.14232549f, 0.01410218f, 0.04754234f, 0.06737813f, 0.01838205f, 0.00660754f, -0.03237842f, 
    0.01196474f, -0.05704766f, 0.02728468f, -0.00945296f, -0.36465847f, -0.31190252f, 0.28642306f, 0.14270340f, 
    -0.02936141f, -0.13908963f, -0.18918639f, 0.17141159f, 0.20142448f, -0.14386867f, 0.03968370f, 0.12562102f, 
    -0.09397997f, 0.03497168f, 0.06384239f, 0.02797947f, 0.05186109f, 0.06280830f, -0.02324199f, -0.03712657f, 
    -0.03732619f, 0.06022536f, -0.22943841f, -0.00881373f, 0.10562283f, -0.02391354f, 0.05749873f, 0.02128753f, 
    -0.03084193f, 0.10326385f, -0.03591441f, 0.01246169f, 0.03721142f, 0.00533589f, -0.01728161f, 0.02799942f, 
    0.04219327f, -0.04404641f, 0.07470901f, -0.03016185f, 0.01474280f, 0.05459847f, -0.12576512f, -0.14660415f, 
    -0.09592579f, -0.00683522f, 0.02994333f, 0.04753245f, -0.03845935f, -0.01668759f, -0.05276122f, -0.09588262f, 
    -0.05682268f, -0.08466331f, -0.04203217f, -0.07596543f, -0.07669367f, -0.27577671f, -0.01959535f, 0.07539397f, 
    -0.03495384f, -0.09796084f, -0.03995378f, -0.08851422f, -0.17794375f, -0.01527622f, 0.08550100f, 0.07920171f, 
    -0.07038086f, -0.01063423f, -0.00225655f, -0.09934426f, 0.03753018f, -0.07807010f, -0.04635793f, 0.02889851f, 
    -0.12527186f, -0.01043329f, -0.10019086f, -0.00732357f, -0.35709429f, 0.36947495f, 0.22439127f, 0.07606187f, 
    0.18720691f, -0.11383941f, -0.08720161f, 0.00292341f, 0.03133864f, 0.25644374f, -0.06883872f, -0.00317931f, 
    0.06508899f, 0.04574257f, 0.09135342f, 0.01633873f, -0.00191717f, -0.02820662f, 0.01199740f, 0.00163667f, 
    0.03902035f, 0.05063109f, -0.02122911f, 0.07261954f, -0.02392838f, 0.05006542f, -0.05282873f, 0.03671556f, 
    0.00859173f, -0.03088842f, 0.02941454f, 0.01756508f, 0.01637896f, -0.03567887f, 0.02827454f, 0.06867712f, 
    0.08311846f, 0.00952880f, -0.13368683f, 0.04278943f, 0.20189685f, -0.15897115f, -0.39496937f, -0.32138282f, 
    0.11585735f, -0.01868635f, 0.06200059f, 0.15736315f, 0.07711980f, -0.04726579f, 0.00108483f, -0.03599368f, 
    0.01375359f, -0.02556043f, 0.00243948f, -0.02880498f, -0.05878773f, -0.06999595f, 0.13682342f, 0.05372574f, 
    -0.42784894f, -0.34586239f, -0.40859836f, -0.21602571f, -0.04775910f, -0.12265392f, -0.09728097f, -0.09313453f, 
    -0.10312431f, -0.22333620f, 0.00231701f, -0.01437546f, 0.00339987f, -0.02419169f, 0.01122649f, -0.02727813f, 
    0.01588703f, 0.06991888f, 0.11458289f, 0.02511277f, 0.20434383f, -0.12240727f, -0.35742626f, -0.05192832f, 
    0.20108226f, 0.00333065f, 0.15901847f, 0.10868034f, 0.18591252f, 0.08267649f, -0.03070333f, -0.06187531f, 
    -0.10767487f, -0.01266134f, 0.06389491f, 0.01919169f, 0.07908218f, -0.04106438f, 0.04490188f, 0.01437725f, 
    0.43346810f, 0.16857313f, -0.15534475f, -0.07578566f, -0.05187415f, -0.06149548f, 0.01424225f, 0.07836988f, 
    0.20842245f, -0.06569683f, 0.16172117f, -0.01480258f, 0.06176193f, -0.39052230f, -0.08123564f, 0.00408097f, 
    0.00595729f, -0.07964513f, 0.10870324f, 0.00597975f, 0.10396758f, 0.13759811f, -0.27293700f, -0.05718349f, 
    0.07329310f, -0.16792174f, 0.00324969f, -0.02967089f, -0.00378809f, 0.23248792f, 0.31214404f, 0.18897031f, 
    -0.11956247f, -0.02221452f, -0.10860823f, 0.02432812f, 0.09282392f, -0.01834648f, -0.01100365f, -0.04334756f, 
    -0.15276541f, 0.13782586f, -0.13872755f, -0.24074994f, -0.17177670f, 0.01217168f, 0.05646910f, 0.11546802f, 
    -0.00679558f, 0.03478213f, 0.05798896f, -0.07441971f, 0.05793478f, 0.00707488f, -0.01601422f, 0.06362718f, 
    0.11692245f, -0.09179880f, 0.10818666f, 0.07172090f, 0.02457699f, -0.34630075f, -0.19338773f, -0.05580256f, 
    0.10866740f, -0.03886205f, 0.06262496f, 0.12532885f, -0.02826448f, -0.08037360f, -0.04971582f, -0.04621750f, 
    -0.03436936f, 0.01535579f, 0.03053790f, -0.06701783f, 0.00186329f, 0.00089059f, -0.00895988f, 0.03044781f, 
    0.03864774f, -0.45882511f, -0.54255944f, -0.15115598f, 0.12874608f, -0.01689720f, -0.07026590f, -0.02999931f, 
    -0.07516938f, 0.00804947f, -0.04627279f, 0.04677298f, -0.02086209f, -0.09617852f, -0.21468742f, -0.03654246f, 
    0.00963660f, 0.11406184f, 0.02624293f, -0.02096916f, -0.01582240f, 0.22953549f, -0.01990960f, 0.02524396f, 
    -0.02048322f, -0.10515173f, -0.08232459f, -0.17410989f, 0.07574961f, -0.11711422f, 0.03343346f, -0.04454425f, 
    -0.07444106f, -0.03713510f, 0.05622442f, -0.02153618f, -0.02771478f, 0.04633611f, -0.00726901f, -0.03406788f, 
    -0.30753413f, -0.27385107f, -0.24262616f, -0.11886204f, -0.10606945f, -0.14759278f, 0.02298847f, -0.06431129f, 
    -0.00057046f, -0.14341348f, 0.02460755f, -0.05460485f, -0.00026280f, 0.01497316f, 0.05447233f, -0.01296765f, 
    0.02248077f, 0.06176355f, 0.16773134f, 0.02528074f, 0.01871019f, -0.08069275f, 0.03727163f, 0.05831693f, 
    0.12817627f, -0.06499103f, 0.10614137f, -0.03350987f, 0.03041136f, 0.03447437f, 0.06667690f, -0.03957486f, 
    0.04956113f, -0.07202414f, -0.00646049f, 0.00021937f, -0.02102869f, -0.01784953f, -0.01544333f, -0.02643744f, 
    -0.74549389f, -0.53426623f, -0.35172054f, -0.37885797f, 0.20684622f, -0.07043707f, -0.17508592f, -0.20531847f, 
    -0.16834553f, -0.27135798f, -0.02387196f, -0.05135706f, -0.00925265f, 0.00627723f, -0.02759250f, -0.02886762f, 
    -0.00345295f, 0.05363668f, 0.17791681f, 0.04457885f, -0.50173092f, -0.48736113f, -0.59371865f, -0.23500761f, 
    0.08478237f, -0.12045230f, 0.09881517f, 0.10345293f, 0.01797022f, -0.24213818f, 0.00610604f, -0.01657315f, 
    -0.03209519f, 0.01549631f, 0.03063720f, 0.00497477f, -0.02157446f, 0.10260440f, 0.11763772f, 0.00588851f, 
    -0.46638927f, -0.86470735f, -0.72574359f, -0.05380684f, 0.08172773f, 0.12765545f, 0.14526992f, -0.02831413f, 
    -0.15304711f, -0.49189028f, 0.03198821f, 0.05475972f, -0.05389452f, -0.04054596f, 0.06124378f, -0.01451665f, 
    0.00974948f, 0.10717911f, 0.19230036f, 0.05821776f, -0.00262012f, 0.13419345f, 0.14152372f, 0.02351260f, 
    -0.10038900f, 0.08519162f, 0.08476656f, -0.01476798f, -0.00924868f, 0.09156696f, -0.00756604f, 0.03277312f, 
    0.04175673f, 0.00991041f, -0.05337191f, 0.02074173f, 0.04853525f, 0.01510887f, 0.08965091f, 0.06774850f, 
    -0.24692805f, -0.27117825f, -0.51246804f, -0.08018709f, -0.28337178f, -0.13894241f, 0.02424019f, -0.19006445f, 
    -0.14000936f, -0.34175542f, 0.01401634f, -0.01459622f, -0.01695332f, 0.01937829f, 0.07469027f, -0.09203719f, 
    -0.05201670f, 0.15651548f, 0.05045120f, 0.04024714f, 0.03347390f, 0.14781401f, -0.11820292f, -0.00637926f, 
    0.02009852f, 0.00238159f, -0.02845147f, -0.00978451f, 0.03564204f, -0.14237802f, -0.01935769f, -0.05627121f, 
    -0.06891025f, -0.00999961f, 0.03521816f, -0.02724329f, -0.02299230f, 0.11688513f, -0.17812552f, -0.11636150f, 
    -0.00304977f, 0.11555249f, 0.02025197f, 0.08124076f, -0.00678338f, 0.04188055f, 0.04018877f, 0.05378061f, 
    0.06045429f, -0.06098759f, -0.00292964f, 0.03515065f, -0.00109843f, 0.04683852f, 0.11172347f, 0.08760874f, 
    -0.07528615f, 0.01164794f, -0.22882806f, -0.08630104f, -0.17445131f, 0.34710217f, 0.10060664f, 0.03985407f, 
    0.21721065f, 0.05184995f, 0.02489596f, -0.02535642f, 0.06112183f, -0.04425799f, 0.05904084f, 0.11129418f, 
    0.10309180f, 0.05984485f, 0.02655070f, 0.01134590f, -0.03149842f, -0.00464489f, -0.06464254f, 0.01987743f, 
    -0.14315389f, 0.05437405f, 0.00253646f, 0.01095833f, 0.21576160f, -0.00544706f, -0.03917281f, -0.04800714f, 
    0.12283820f, -0.00044031f, 0.10584414f, 0.10331614f, 0.07631610f, 0.01547251f, -0.05966211f, -0.02757226f, 
    0.02170477f, -0.00271234f, 0.06555181f, -0.01274364f, -0.11720300f, 0.09912391f, 0.14157124f, 0.02380110f, 
    -0.01019378f, -0.02849721f, -0.05929387f, -0.08691652f, -0.07674059f, -0.10192561f, -0.08707298f, -0.04321459f, 
    -0.05757511f, 0.02702736f, 0.05816086f, -0.02994909f, -0.06589362f, 0.00208443f, -0.07033323f, -0.02598684f, 
    -0.21050514f, -0.30453342f, 0.01157124f, 0.01793175f, -0.10925468f, 0.02747230f, -0.04722869f, 0.02604948f, 
    -0.06216049f, -0.01064087f, -0.04064435f, 0.02158190f, -0.00733574f, 0.07477165f, -0.05516762f, 0.00850645f, 
    -0.00476488f, 0.03543935f, 0.04313225f, 0.06309063f, -0.00254586f, -0.04713333f, 0.13962790f, 0.05099455f, 
    -0.03732594f, -0.01068940f, 0.00595079f, -0.01821943f, -0.03031101f, 0.04752535f, 0.07689184f, 0.03068610f, 
    0.04890449f, 0.00390568f, -0.05891056f, 0.02210685f, -0.01729917f, -0.02117256f, -0.00267383f, 0.04697384f, 
    -0.05731369f, 0.28297919f, -0.05023285f, 0.10820595f, 0.02370929f, 0.06130633f, 0.03932864f, -0.03203975f, 
    0.05720528f, -0.12094860f, -0.01414122f, 0.02088745f, -0.03440741f, 0.02743584f, 0.07281915f, 0.02965610f, 
    -0.04722207f, 0.09945662f, -0.14484645f, -0.06346808f, -0.21554615f, -0.38626122f, -0.48515266f, -0.26008296f, 
    0.01737656f, -0.07395634f, -0.15377320f, -0.10135477f, -0.09770200f, -0.02511876f, -0.00322064f, -0.01123073f, 
    -0.03908969f, -0.01917009f, -0.04903920f, -0.03770791f, -0.08756262f, 0.03137373f, 0.00303887f, -0.04706899f, 
    0.15049395f, 0.00752399f, 0.16984710f, -0.05550792f, 0.02444309f, 0.01708457f, -0.06252325f, -0.12848653f, 
    -0.02045730f, -0.00038111f, -0.01418521f, 0.01009815f, 0.00708567f, -0.01765022f, -0.04504320f, 0.03817449f, 
    0.06902421f, -0.00391783f, -0.00696252f, -0.00889330f, 0.04911603f, 0.11386061f, -0.04445709f, -0.00524242f, 
    -0.09837118f, 0.01500740f, 0.07447190f, -0.01088329f, -0.01993760f, -0.04094765f, -0.04005813f, 0.04262818f, 
    0.04274032f, -0.02034272f, -0.01779815f, -0.11977895f, -0.02376420f, 0.00978037f, -0.05708511f, -0.10950582f, 
    -0.07332546f, -0.17249870f, 0.08560222f, 0.33785444f, -0.13149150f, -0.00800860f, 0.03869491f, -0.09760485f, 
    0.05069732f, 0.09099412f, 0.00170282f, -0.04997933f, -0.04880818f, -0.02036027f, -0.00594076f, 0.04823650f, 
    0.07532606f, -0.04262540f, 0.04389910f, 0.03206589f, 0.03077850f, 0.05336821f, -0.13130702f, 0.00099402f, 
    -0.07860773f, 0.04235368f, -0.03145710f, 0.03139907f, -0.07132307f, -0.00298769f, -0.11923827f, -0.05882593f, 
    0.04129305f, 0.03388974f, -0.04961561f, 0.01092036f, -0.01954255f, 0.05357026f, -0.04244642f, -0.00070489f, 
    -0.11303030f, -0.25984004f, 0.06179491f, 0.01915915f, 0.16463941f, 0.06296139f, -0.08209967f, 0.04033626f, 
    0.00429750f, -0.00252372f, 0.09635578f, -0.00433880f, -0.01424565f, -0.01326089f, 0.04059173f, -0.04420277f, 
    0.02070260f, -0.07893730f, 0.06258789f, -0.04624220f, -0.05002598f, 0.07506387f, 0.01981551f, -0.01702156f, 
    -0.01991070f, -0.00059888f, 0.03830015f, 0.01002770f, -0.04482296f, -0.01016004f, 0.06554709f, 0.01810322f, 
    0.01000845f, 0.00075865f, -0.00497981f, -0.02504888f, -0.03106065f, 0.00708267f, -0.00209478f, 0.03071963f, 
    -0.58796573f, -0.57045662f, 0.45404062f, -0.24922110f, 0.24037090f, -0.11520958f, 0.01565801f, 0.16420442f, 
    -0.05586898f, 0.01657003f, -0.01334394f, 0.03120044f, -0.04568670f, -0.01264067f, -0.07689559f, 0.02730427f, 
    -0.03671338f, -0.01561662f, 0.01061119f, -0.07175159f, -0.01130474f, 0.04923818f, -0.00340672f, 0.05147022f, 
    -0.06206387f, 0.00472884f, 0.07010532f, -0.01400690f, -0.03236495f, -0.03996618f, 0.02459217f, -0.00488207f, 
    0.02945730f, 0.00740721f, 0.00640227f, -0.04032118f, 0.03390869f, -0.10342708f, -0.02147272f, -0.00812338f, 
    0.39619121f, -0.76168370f, -0.92346311f, -0.37980288f, -0.09656172f, 0.07922088f, -0.01501144f, 0.13692543f, 
    0.20976318f, 0.06239143f, 0.04275248f, 0.04898037f, 0.01627195f, 0.00863795f, -0.03111640f, -0.01444961f, 
    0.02440820f, -0.11135132f, 0.09238621f, 0.11398324f, 0.34702235f, 0.02324624f, -0.16990983f, -0.16497315f, 
    -0.15851185f, 0.01557487f, -0.03151005f, 0.03299222f, 0.00635017f, 0.02513233f, -0.00510244f, 0.01756006f, 
    0.09000101f, -0.00855859f, 0.01579900f, 0.01464282f, 0.00856633f, 0.02506102f, 0.04572039f, -0.00854602f, 
    0.00243055f, 0.04923861f, 0.05471491f, 0.07199872f, -0.04186264f, 0.02727756f, 0.04335379f, 0.03850512f, 
    -0.06121078f, -0.00291974f, 0.02184717f, -0.01567557f, 0.02805237f, 0.02580549f, 0.02269578f, 0.11772227f, 
    0.00257964f, -0.05740456f, -0.09616796f, -0.03739226f, -0.06240222f, -0.05038128f, 0.05857036f, -0.13488729f, 
    0.00226135f, 0.01185424f, 0.01574307f, 0.01510623f, 0.05232726f, -0.00658555f, 0.05793312f, -0.01591114f, 
    0.04525449f, 0.04912245f, 0.05663189f, 0.04132248f, 0.03435010f, 0.02704478f, 0.03033205f, 0.02411231f, 
    0.59535223f, -0.67533702f, -0.66654092f, -0.25682378f, -0.15770751f, -0.09254166f, 0.08152506f, -0.34962621f, 
    0.23856598f, -0.07687657f, 0.02443410f, 0.07334051f, 0.05683971f, 0.01960602f, 0.10769421f, -0.04964736f, 
    0.05016192f, -0.03571146f, 0.04928071f, 0.08768237f, 0.13925919f, -0.00672171f, -0.22803225f, 0.09411070f, 
    -0.20234832f, 0.02275699f, 0.03227713f, 0.00630056f, 0.03135068f, -0.01954758f, -0.05346338f, -0.00840675f, 
    -0.02543690f, 0.02308627f, -0.01766598f, -0.01327616f, -0.03874411f, -0.12295980f, -0.01026224f, 0.09150262f, 
    -0.36360639f, -0.09097631f, 0.19859679f, 0.07867657f, 0.12881280f, -0.01529799f, -0.02534497f, 0.02022653f, 
    0.00773143f, 0.00024810f, 0.05121936f, -0.01399308f, 0.02422921f, -0.02761526f, -0.05118943f, 0.02355880f, 
    -0.03426981f, -0.09809116f, -0.07019657f, -0.03840057f, -0.18075417f, -0.49228147f, 0.55617177f, -0.31831196f, 
    0.27986267f, 0.04434734f, -0.06598217f, 0.13783270f, -0.00901573f, 0.01370024f, -0.02521363f, 0.00966154f, 
    -0.04079460f, -0.05995071f, -0.12408522f, 0.13898776f, 0.00460869f, 0.07455207f, -0.01082890f, -0.11448973f, 
    0.09248854f, -0.02012203f, -0.13584104f, -0.09265847f, -0.11225934f, 0.02776413f, -0.08251926f, 0.01392796f, 
    -0.00612549f, 0.00875508f, -0.06768994f, -0.02608571f, -0.05266835f, -0.00973686f, 0.03685393f, 0.01732785f, 
    -0.00026489f, 0.01374559f, 0.03709266f, -0.01401270f, -0.08302449f, 0.16063914f, -0.05447170f, 0.05252365f, 
    -0.14935541f, 0.01703357f, -0.05702281f, -0.10058141f, -0.03611354f, -0.02700178f, 0.05819556f, 0.03152725f, 
    0.02395169f, 0.00970567f, -0.02834895f, -0.02438106f, -0.12926205f, -0.01781171f, -0.03518816f, 0.07429954f, 
    0.24058111f, 0.29852566f, -0.06743664f, 0.05669056f, -0.31413579f, 0.09348318f, 0.04590166f, 0.07536671f, 
    -0.07429977f, -0.11214396f, -0.08662476f, 0.02342140f, 0.05926425f, 0.01787289f, -0.11275506f, -0.09977598f, 
    -0.11435452f, 0.03872489f, -0.08646884f, -0.12598729f, 0.10539072f, -0.22858015f, 0.22133002f, -0.15903258f, 
    0.23729326f, -0.07774497f, 0.17872055f, -0.15719615f, 0.02304569f, -0.09643437f, 0.04203260f, 0.06403328f, 
    0.06959436f, -0.08157822f, -0.10990997f, 0.09475294f, -0.01738773f, 0.09309651f, -0.00829780f, -0.04742505f, 
    0.25740984f, -0.60949475f, -0.35203248f, -0.30198398f, -0.14512368f, -0.04355409f, -0.10733681f, 0.11186886f, 
    0.17963168f, -0.11401004f, -0.00019759f, 0.02692057f, 0.02774168f, 0.02068213f, 0.06506182f, -0.01184042f, 
    0.02969458f, 0.01891452f, 0.01626576f, -0.01079267f, -0.04406411f, 0.04601989f, -0.14530188f, 0.08025897f, 
    -0.20968422f, 0.00902577f, 0.04589221f, 0.12455513f, 0.00281800f, -0.06076304f, -0.00017460f, 0.05447902f, 
    0.01856697f, -0.02475175f, -0.02563504f, 0.02047346f, 0.01407306f, 0.06064769f, -0.01290007f, -0.01545606f, 
    0.04047556f, 0.10148654f, 0.01050464f, -0.03065827f, 0.02091949f, -0.01532437f, 0.04412834f, -0.04560131f, 
    -0.04155608f, -0.07110550f, -0.02477632f, -0.04197124f, 0.02163713f, -0.07028718f, -0.09301414f, -0.08937049f, 
    0.03332531f, -0.00826873f, -0.07267953f, -0.01154140f, -0.34720218f, -0.26046556f, 0.37152737f, -0.17799516f, 
    0.14643231f, 0.03814161f, -0.00876173f, 0.14826779f, 0.00624800f, -0.07731273f, 0.01657100f, 0.02022808f, 
    -0.03437124f, -0.07661270f, -0.07190245f, -0.01198396f, -0.03045343f, 0.06268734f, 0.04310749f, -0.00942134f, 
    0.04527260f, 0.07543607f, 0.00502017f, 0.04323952f, -0.11302518f, 0.03957091f, 0.02287061f, -0.00717212f, 
    -0.01256249f, -0.01665938f, 0.02023669f, 0.02292626f, 0.04528448f, -0.04335363f, 0.00008599f, -0.06229319f, 
    -0.12224238f, 0.07786011f, 0.02049103f, -0.04815110f, 0.03819364f, 0.11763687f, 0.04907808f, 0.02437664f, 
    -0.04605300f, -0.00364115f, 0.01025591f, 0.01152908f, -0.03394412f, -0.04244757f, -0.05089276f, -0.16690588f, 
    -0.08226895f, -0.16729224f, -0.15460905f, -0.02634476f, 0.01914066f, 0.05528472f, 0.03438910f, -0.01201137f, 
    -0.23603565f, -0.36764514f, 0.13436395f, 0.04085343f, 0.23769939f, 0.05031268f, -0.00592841f, 0.16808508f, 
    -0.16502975f, -0.04743529f, -0.03241272f, 0.05463394f, -0.03366407f, -0.02397137f, -0.05828077f, 0.05909024f, 
    -0.00170292f, -0.00594125f, -0.07321141f, -0.08198796f, 0.23089765f, -0.32462662f, -0.16471355f, 0.32990980f, 
    -0.04891188f, -0.11001663f, 0.00556902f, 0.02395640f, 0.03635336f, -0.04620245f, 0.02882087f, 0.05657875f, 
    -0.03912687f, -0.01506978f, -0.02115122f, -0.07843228f, 0.03118036f, 0.01444980f, -0.08253625f, -0.07343691f, 
    -0.14357682f, -0.06643261f, 0.07216600f, 0.02279344f, 0.04501862f, 0.00640717f, 0.03689455f, 0.07325514f, 
    0.00606764f, -0.01914552f, -0.02652410f, 0.07227422f, 0.02801461f, 0.01331665f, 0.04041546f, -0.03170861f, 
    -0.02303131f, -0.01869277f, -0.01486976f, 0.00864277f, 0.10611308f, -0.37453559f, -0.36322823f, -0.21077023f, 
    -0.03776667f, -0.02408602f, -0.09543151f, 0.04458694f, 0.02918615f, 0.06751857f, -0.01418712f, 0.03108977f, 
    0.09011745f, 0.02918588f, 0.04395430f, -0.04775381f, 0.02025774f, -0.00077329f, -0.03227182f, -0.06712214f, 
    -0.03489206f, 0.05138165f, 0.02932488f, 0.03742022f, -0.01397370f, -0.03136094f, -0.02323511f, 0.00792174f, 
    -0.02967574f, -0.03260883f, -0.02527315f, -0.06313110f, -0.03587465f, 0.01741992f, -0.04343546f, 0.02014037f, 
    -0.00626538f, -0.00877851f, -0.06639237f, -0.01278104f, 0.06625991f, -0.27392238f, -0.16574609f, 0.13169214f, 
    -0.12609617f, 0.04834392f, -0.00255120f, -0.14579456f, 0.04356586f, 0.07873003f, -0.01320874f, -0.00425644f, 
    -0.06525418f, -0.04205307f, -0.07258714f, -0.04553142f, 0.05580576f, -0.07872958f, 0.14496565f, 0.12227465f, 
    0.26678616f, 0.12501739f, -0.16873765f, -0.02929767f, -0.16167517f, 0.02028678f, 0.01030107f, 0.02584150f, 
    -0.10564338f, -0.05491794f, -0.01151736f, -0.11453915f, 0.08119766f, -0.02974404f, -0.09898855f, -0.00741193f, 
    -0.10200000f, 0.04712043f, -0.01151223f, -0.06578343f, 0.45933419f, 0.11552250f, -0.03009353f, 0.02941035f, 
    -0.10708150f, -0.03233606f, -0.06779797f, -0.01346702f, -0.02672776f, 0.02725768f, -0.06343047f, -0.11131372f, 
    0.07737742f, 0.01545443f, -0.02834570f, 0.05654239f, 0.03593964f, 0.01149848f, -0.09269126f, -0.06053493f, 
    0.18033232f, 0.11657657f, -0.13814275f, 0.13174355f, -0.22999805f, 0.02710506f, 0.12228039f, -0.09926468f, 
    0.00879977f, 0.01692109f, -0.05595763f, 0.03053434f, -0.01870411f, -0.00378918f, -0.02316505f, -0.02043937f, 
    0.02075805f, -0.10323669f, 0.04124424f, 0.05850016f, 0.04468804f, 0.05544123f, 0.03415367f, 0.03189820f, 
    -0.08038226f, 0.01072044f, 0.01667429f, -0.02342797f, -0.05066346f, -0.00356443f, 0.00737934f, 0.01749144f, 
    0.02061614f, -0.00824649f, 0.01643863f, -0.07310995f, -0.11151740f, -0.06914669f, 0.08561600f, 0.03325760f, 
    -0.01467459f, 0.08010329f, 0.16169710f, -0.02913208f, -0.00026886f, 0.02908534f, 0.00721251f, 0.00841016f, 
    0.00015112f, -0.01665715f, 0.04317646f, 0.00147298f, 0.05990914f, 0.00956430f, -0.01091221f, 0.00471637f, 
    0.04004611f, 0.02686172f, 0.04549240f, 0.01391739f, 0.69657111f, -0.24060735f, -0.20428537f, -0.29252508f, 
    -0.15327914f, -0.01430134f, -0.09250022f, -0.06146966f, -0.09430485f, -0.23901622f, 0.04971473f, -0.02239861f, 
    -0.02274569f, 0.00681354f, -0.04808608f, 0.01785361f, -0.01065274f, 0.04376613f, -0.00193895f, -0.03197302f, 
    -0.00128521f, 0.03598700f, 0.07156851f, 0.04353681f, -0.02296627f, -0.02881201f, -0.01021813f, 0.01030363f, 
    -0.01680251f, -0.02800318f, 0.03156475f, -0.03504909f, -0.02290849f, -0.01675461f, -0.01484514f, -0.09804232f, 
    -0.05781832f, -0.05724126f, 0.02938991f, 0.01013971f, -0.10648341f, 0.17178717f, -0.23484306f, 0.02044185f, 
    -0.12728631f, 0.01524911f, 0.01725197f, -0.07059497f, -0.10018626f, -0.06745738f, 0.06530669f, 0.01758356f, 
    0.04423470f, 0.01634549f, 0.02420769f, 0.02739235f, 0.01325983f, -0.01743216f, 0.01873349f, 0.02929742f, 
    0.13711649f, -0.19273932f, 0.14440092f, 0.01332053f, -0.03466818f, -0.09537383f, 0.12091230f, -0.06719447f, 
    0.16385518f, 0.13839434f, 0.02865074f, 0.00194812f, -0.01935834f, -0.05735734f, -0.01270303f, -0.03833689f, 
    -0.00765624f, -0.05323381f, 0.10694230f, -0.06823926f, 0.02592125f, -0.02208421f, -0.17783207f, 0.10659207f, 
    -0.11249839f, 0.06272832f, 0.06840383f, -0.01148336f, -0.14176066f, -0.05144793f, 0.05401711f, 0.01954811f, 
    -0.00102397f, 0.02492160f, -0.04317506f, 0.04769129f, 0.01414610f, 0.11419746f, -0.04056359f, -0.04208614f, 
    -0.03366436f, 0.09761841f, -0.10744542f, 0.00818978f, 0.03951043f, 0.07011452f, -0.02330845f, 0.00699044f, 
    -0.08338451f, -0.01522234f, 0.02931577f, 0.05721423f, 0.00817417f, 0.03182551f, 0.16929144f, 0.03496242f, 
    0.00030346f, 0.02763846f, -0.03650953f, 0.06974671f, -0.03847852f, 0.05119761f, -0.04658379f, 0.03041207f, 
    -0.05404399f, 0.13993442f, 0.04806309f, 0.04173462f, -0.08886161f, -0.12174036f, -0.17048100f, 0.07673405f, 
    0.04414447f, -0.00211777f, 0.02035688f, -0.10640957f, -0.04767335f, 0.10699117f, -0.12721673f, 0.04088114f, 
    0.04011217f, -0.07750456f, 0.03631433f, 0.02686368f, 0.01531485f, 0.01220430f, 0.02340970f, 0.09430346f, 
    -0.07913963f, -0.02132456f, 0.04160302f, -0.00960187f, 0.00067101f, 0.02772382f, -0.03649608f, 0.07269510f, 
    -0.01078416f, -0.22147849f, 0.02675837f, -0.00904794f, -0.05054210f, 0.08567546f, -0.03727123f, -0.01870626f, 
    -0.13618441f, -0.02916153f, -0.01351512f, -0.04303667f, -0.11264944f, 0.01153225f, 0.00709481f, -0.01192674f, 
    0.04171230f, -0.00616650f, -0.02637833f, -0.02981648f, -0.07105071f, -0.07132831f, -0.02770948f, 0.00529124f, 
    0.13741221f, -0.26031530f, -0.08016548f, -0.45512259f, -0.14821148f, 0.00470928f, 0.02012885f, -0.17475949f, 
    0.23874132f, 0.01434686f, 0.00052703f, -0.00674586f, -0.03780263f, 0.00727572f, 0.05338862f, -0.03593746f, 
    -0.01242802f, -0.04669651f, 0.09362473f, -0.00784783f, -0.28875899f, -0.24738905f, 0.11959991f, -0.05886375f, 
    0.11814553f, -0.02026887f, 0.05970669f, 0.04158900f, 0.00212933f, -0.00339138f, -0.00123914f, 0.03067801f, 
    -0.04587164f, -0.00452750f, -0.00317593f, 0.05768405f, -0.03024851f, 0.00129601f, -0.06498136f, -0.02343722f, 
    -0.21848629f, -0.05008876f, 0.04458481f, 0.08337053f, 0.11984408f, 0.11344056f, -0.00273197f, 0.07703751f, 
    0.01638391f, 0.04529675f, 0.01043395f, -0.02640134f, -0.06484482f, -0.01034440f, -0.00400974f, 0.07643607f, 
    0.12207922f, -0.00481288f, 0.02325620f, -0.01697636f, 0.00554423f, 0.00491783f, -0.01369520f, 0.00448164f, 
    -0.01770703f, -0.02813964f, 0.01099085f, -0.03863280f, 0.03376798f, -0.03193576f, 0.00070766f, 0.01289821f, 
    0.01793259f, -0.01100061f, -0.03580248f, -0.04090089f, 0.01209131f, -0.02577570f, 0.01657863f, 0.00949198f, 
    0.16737556f, -0.23712826f, 0.17160290f, 0.41776437f, 0.03847358f, -0.03162688f, 0.07706886f, 0.01108778f, 
    0.06995621f, 0.09665915f, 0.05338447f, -0.01704142f, -0.00465426f, -0.06158334f, -0.01950490f, 0.01632865f, 
    -0.03456577f, -0.05415477f, 0.08145662f, -0.04613975f, -0.26422051f, -0.12216163f, -0.06071861f, 0.24771872f, 
    -0.06600948f, 0.10658211f, 0.11929483f, -0.01981700f, -0.03289586f, 0.08185910f, 0.00919258f, -0.03710811f, 
    0.00916369f, 0.02835224f, -0.01424680f, 0.05275249f, 0.11805487f, -0.09363633f, 0.03492850f, -0.03699483f, 
    -0.69671333f, -0.56383890f, 0.12706414f, 0.30556428f, 0.16990349f, -0.06044566f, 0.08042442f, -0.00975951f, 
    -0.11652797f, 0.11714539f, 0.06104142f, -0.01932614f, -0.00183962f, -0.00806229f, -0.01291124f, -0.01690135f, 
    0.06427497f, -0.13304070f, -0.04574895f, -0.11647933f, 0.00765670f, -0.17312036f, 0.16487981f, -0.14481235f, 
    0.09020569f, -0.03952385f, 0.02240947f, -0.03732587f, 0.00531720f, -0.03245925f, 0.05698635f, 0.01801774f, 
    0.01471336f, -0.03516202f, -0.02720125f, -0.09725697f, -0.04270580f, -0.07776406f, 0.09373347f, -0.03569802f, 
    -0.34387848f, -0.25991938f, 0.09892204f, -0.14060508f, 0.08067014f, 0.04507465f, 0.10020622f, 0.04360589f, 
    0.07137832f, 0.15035114f, 0.00316927f, -0.03110909f, -0.06080519f, -0.04418668f, -0.01470691f, 0.02385951f, 
    0.03791513f, 0.08701790f, 0.08215914f, -0.07267619f, -0.25848761f, -0.16171747f, 0.16009149f, -0.04515734f, 
    0.09526781f, -0.05930911f, 0.00893159f, 0.06268193f, 0.03956623f, 0.06208880f, -0.07685083f, -0.00569934f, 
    -0.00204850f, 0.01104085f, 0.00975945f, 0.01678121f, -0.00564132f, -0.06776790f, -0.10192645f, -0.02658080f, 
    -0.06153710f, 0.04104115f, 0.16140410f, -0.02137854f, 0.07267424f, -0.05575748f, 0.01102571f, 0.05504797f, 
    -0.00245517f, -0.04708759f, 0.02878218f, -0.05471413f, -0.06639204f, -0.03705931f, -0.04929192f, -0.06195952f, 
    -0.01747577f, -0.05065148f, -0.02304859f, -0.01790824f, -0.18720712f, -0.14756684f, 0.16786788f, 0.03869510f, 
    0.03473570f, 0.00907843f, 0.03073234f, 0.06860654f, 0.02517355f, -0.03194486f, -0.08607299f, -0.00348177f, 
    0.04771715f, 0.03409258f, -0.02323887f, -0.03836741f, 0.01546102f, -0.02437116f, 0.04755494f, 0.04373879f, 
    -0.06892423f, 0.08642674f, -0.02262365f, 0.14548635f, -0.06667394f, -0.00535831f, 0.04204233f, 0.09171031f, 
    -0.05481032f, 0.00435682f, -0.09423789f, 0.03105043f, 0.01238038f, 0.00176604f, -0.03906509f, 0.00868138f, 
    -0.05445237f, -0.04450228f, 0.09642674f, 0.10425662f, -0.03408689f, 0.00261139f, -0.01003689f, -0.01462763f, 
    -0.01425051f, 0.05493882f, 0.02875203f, 0.00699069f, 0.01663532f, 0.01415405f, -0.02156966f, 0.01396601f, 
    0.05944509f, 0.02530436f, 0.02724124f, 0.00497478f, 0.02841804f, 0.01837344f, -0.01999537f, -0.00736934f, 
    0.32478040f, -0.27672568f, 0.19215076f, -0.32561859f, -0.10460473f, 0.03229159f, 0.08786846f, -0.15652658f, 
    0.16740537f, -0.08380073f, -0.00742851f, -0.03066799f, 0.01163834f, -0.03626509f, -0.01953152f, -0.03990094f, 
    -0.04965933f, -0.04784193f, 0.01387155f, -0.05993176f, 0.12229111f, 0.09633757f, 0.03496023f, -0.05069206f, 
    -0.06791107f, 0.01627115f, 0.00398687f, -0.00634348f, -0.02657256f, -0.08339948f, -0.07802486f, -0.16688488f, 
    -0.03175321f, -0.27412882f, -0.09447876f, -0.02654435f, -0.01540326f, 0.02344801f, 0.00265337f, -0.01980210f, 
    -0.23665120f, -0.17650071f, 0.24687999f, -0.16879277f, 0.19564216f, -0.09885347f, 0.04789498f, 0.07232235f, 
    0.03533610f, 0.03728195f, -0.05112953f, 0.03227430f, -0.00605988f, 0.03154080f, 0.01327856f, -0.02821634f, 
    -0.02198787f, -0.07215927f, -0.05537906f, -0.01859962f, 0.22370079f, -0.23616779f, -0.14529577f, -0.26863903f, 
    -0.19435659f, -0.02284326f, 0.01753471f, -0.10160392f, 0.15918897f, 0.07304259f, 0.00080717f, -0.00978518f, 
    -0.02861931f, -0.06232623f, -0.01837407f, -0.01561248f, 0.00742916f, -0.08565262f, 0.05032322f, -0.03020115f, 
    0.05285209f, 0.13309209f, 0.06430898f, 0.06256942f, -0.00903873f, 0.02502400f, -0.07823358f, 0.00268476f, 
    0.03394929f, 0.03628847f, 0.05150532f, 0.00008641f, -0.01714441f, -0.00244616f, 0.04664993f, -0.03628164f, 
    -0.12429366f, -0.07677768f, -0.10934055f, -0.15509413f, 0.13313952f, 0.16224416f, 0.01006368f, 0.01762547f, 
    -0.15825114f, -0.02315001f, -0.10547623f, -0.03826305f, 0.01784971f, -0.05075551f, -0.05982266f, 0.04604623f, 
    -0.01619376f, 0.04593041f, 0.03816037f, -0.01383245f, -0.02623271f, -0.07796420f, 0.02334758f, 0.03962709f, 
    0.17971173f, 0.06678822f, -0.01172938f, -0.15523411f, -0.09409721f, 0.03733803f, -0.16952588f, -0.09170032f, 
    -0.12537460f, -0.16205905f, 0.01641963f, 0.05654781f, 0.01694766f, 0.01156135f, -0.01940702f, 0.06376082f, 
    0.01707559f, -0.01782637f, -0.07676500f, -0.20839646f, 0.05925031f, 0.03246506f, -0.05900718f, -0.02033254f, 
    -0.06269737f, -0.06723382f, 0.09883709f, -0.00883894f, 0.02907406f, -0.02110415f, 0.08492567f, -0.01018249f, 
    0.00178599f, 0.06903728f, -0.02724488f, 0.01322535f, 0.06595973f, 0.06860505f, 0.11589901f, 0.03158623f, 
    0.42992505f, 0.02156706f, -0.07451925f, 0.08151361f, -0.01298224f, -0.00044573f, -0.08442879f, -0.08335102f, 
    -0.06645035f, 0.09673043f, 0.12344801f, 0.01144242f, 0.04380496f, -0.07899355f, 0.02029355f, -0.06861801f, 
    0.07737245f, 0.06407081f, -0.05725200f, 0.12591009f, -0.20423745f, 0.13858774f, 0.08534556f, 0.05844086f, 
    -0.05667565f, -0.03705133f, -0.02395609f, 0.00145234f, -0.01653769f, -0.08226918f, -0.07404573f, -0.02144014f, 
    0.01700236f, -0.04539548f, 0.04866605f, -0.06036699f, 0.03337752f, 0.15728299f, 0.10368329f, 0.05146388f, 
    0.34789869f, -0.48595750f, -0.17825463f, 0.00743137f, 0.15640016f, 0.10700042f, -0.01618825f, 0.03641513f, 
    0.02308467f, -0.01321890f, 0.02741672f, 0.03057181f, 0.04309157f, 0.01796971f, 0.06026925f, 0.05129821f, 
    0.06751344f, 0.03220500f, -0.01917666f, -0.00903921f, -0.21776506f, 0.13704973f, 0.12991114f, 0.07460789f, 
    -0.03944403f, 0.03855443f, -0.07861501f, -0.02775621f, -0.01141736f, -0.06300152f, -0.05054544f, -0.05327803f, 
    -0.01690854f, -0.01799574f, -0.01758919f, -0.02688419f, -0.05113334f, -0.11926859f, -0.03008890f, -0.05064153f, 
    0.01906547f, -0.24456921f, -0.53337371f, 0.02573231f, 0.18222107f, -0.20703550f, 0.01395747f, 0.06264804f, 
    0.08177924f, -0.00797370f, -0.02379878f, -0.00933350f, -0.02966462f, -0.04068920f, -0.04837330f, -0.00625096f, 
    -0.06473286f, -0.06552719f, -0.12428720f, -0.08337048f, -0.16207279f, -0.32764667f, -0.29191074f, -0.21588930f, 
    -0.00944632f, -0.07314803f, 0.08934797f, 0.09500867f, 0.10606769f, 0.12581399f, 0.04724467f, -0.02714578f, 
    -0.01968713f, -0.06770511f, -0.06968860f, -0.01678696f, 0.02766486f, 0.01980012f, 0.04198077f, -0.02369204f, 
    -0.74080455f, -0.01206125f, 0.22854730f, 0.08360912f, -0.13204013f, -0.00868154f, -0.08418034f, -0.05488431f, 
    -0.06169264f, -0.06675001f, -0.04826751f, -0.04235277f, -0.07652657f, -0.05560299f, -0.04052394f, -0.21068041f, 
    -0.24987000f, -0.09803308f, -0.22626397f, -0.02448206f, -0.13083959f, -0.20884608f, -0.19805463f, 0.06175942f, 
    -0.03030890f, -0.08084754f, 0.03666345f, 0.05111742f, 0.03806300f, 0.09585886f, 0.07467385f, 0.00177291f, 
    0.01178041f, -0.05794197f, -0.00578407f, -0.04274249f, 0.09662229f, 0.00406000f, 0.09176403f, 0.06070282f, 
    -0.17301096f, -0.15989822f, -0.85306072f, -0.36011401f, 0.02524681f, -0.14012645f, 0.08528715f, 0.26788989f, 
    0.19980444f, 0.03377145f, 0.02719113f, -0.07452494f, 0.00478926f, 0.05513298f, 0.02952489f, -0.00264882f, 
    0.00627728f, 0.00314142f, -0.08602896f, -0.04163685f, 0.13141745f, 0.13390730f, 0.15192100f, 0.00630141f, 
    -0.20346336f, -0.06639750f, -0.01921634f, -0.13101043f, 0.01838119f, -0.01713498f, 0.05032526f, 0.01800033f, 
    0.05066842f, -0.02859627f, 0.01621448f, -0.03228041f, -0.03218990f, 0.00504526f, -0.12824683f, -0.26202181f, 
    -0.36840278f, -0.09747081f, 0.04109561f, 0.15521188f, 0.01482210f, 0.09247918f, 0.02979199f, -0.00375148f, 
    -0.07045906f, -0.17176996f, 0.03113585f, 0.03521573f, 0.06425324f, -0.00899760f, 0.01478133f, 0.07961137f, 
    -0.02115145f, 0.05926063f, -0.06064305f, -0.13983127f, 0.18129785f, -0.51391506f, -0.15305755f, 0.11525155f, 
    0.23892283f, -0.01355788f, 0.14094339f, 0.07939015f, -0.03876966f, 0.07368077f, 0.04635931f, 0.00669400f, 
    0.00042212f, 0.05984223f, 0.04584322f, 0.03913585f, -0.11951410f, -0.10513484f, -0.14092059f, -0.17824152f, 
    -0.00078711f, -0.19649945f, -0.07907232f, -0.07352181f, 0.00217824f, -0.05040165f, 0.06754285f, 0.10523175f, 
    0.05179072f, 0.08313586f, 0.04369594f, -0.01633647f, -0.02976195f, 0.03953587f, -0.01410964f, -0.00465168f, 
    0.05283598f, 0.03231984f, 0.04172809f, -0.02737097f, -0.00335389f, 0.17327081f, 0.17032880f, 0.07774936f, 
    -0.22220610f, 0.05488688f, 0.04341834f, -0.06647907f, -0.00508668f, -0.06476162f, -0.00047082f, 0.04015670f, 
    -0.00959659f, 0.00277236f, -0.02394163f, -0.00367158f, 0.12122542f, 0.03973677f, 0.06939246f, -0.04437598f, 
    0.34840757f, 0.05316608f, -0.10782492f, -0.19795817f, -0.09210462f, -0.04448428f, 0.14428104f, -0.02079806f, 
    0.08709626f, -0.11845325f, 0.01802290f, 0.00957867f, 0.13786022f, 0.04558726f, 0.08894015f, 0.04194785f, 
    -0.01475997f, -0.04015533f, 0.11032512f, -0.03417559f, 0.72374964f, -0.13228443f, -0.09409174f, 0.08139937f, 
    -0.11673487f, 0.13483833f, -0.06168120f, 0.03972073f, -0.03518210f, 0.14129212f, 0.04464944f, 0.14665864f, 
    -0.07201113f, 0.00499603f, -0.00919630f, 0.06097395f, 0.00254471f, -0.02798757f, 0.00497356f, -0.04435514f, 
    -0.05348165f, -0.49124870f, -0.50863022f, -0.34015703f, 0.18662354f, 0.05852377f, -0.01311702f, 0.05638395f, 
    0.06954477f, 0.10724919f, 0.01294446f, -0.10065105f, -0.06097851f, -0.06719764f, -0.06609449f, -0.02152677f, 
    -0.00661825f, -0.01944852f, 0.03380355f, 0.01917700f, 0.24492139f, 0.13268460f, 0.00824749f, -0.00384848f, 
    -0.16248307f, -0.00272626f, -0.09487777f, -0.01846450f, 0.00473682f, -0.15364479f, -0.03767541f, 0.05654339f, 
    0.03083387f, 0.02738685f, 0.00208304f, 0.01310752f, 0.10044941f, 0.06897746f, 0.10180251f, 0.08170655f, 
    -0.05279649f, -0.03344867f, 0.01413283f, 0.05511457f, -0.12984975f, -0.05622146f, 0.02581198f, 0.08356591f, 
    0.02516413f, 0.00127442f, 0.01446582f, -0.02746116f, -0.04156928f, 0.05852480f, 0.09984604f, 0.07923154f, 
    0.05937179f, 0.02152433f, 0.02802845f, 0.04384971f, 0.39076859f, -0.38428554f, -0.26550546f, 0.05106137f, 
    0.07379263f, 0.00380504f, 0.13961127f, 0.02925464f, -0.06754974f, -0.09838489f, 0.02886698f, -0.04541965f, 
    -0.03803679f, 0.02779520f, 0.05824079f, 0.04091464f, 0.01322398f, -0.06626374f, -0.02358192f, 0.05566056f, 
    -0.14626126f, 0.14696924f, 0.09634808f, 0.01338501f, -0.19437765f, -0.06837346f, -0.05632710f, -0.06237530f, 
    -0.03033834f, -0.07305008f, -0.09638594f, -0.04509467f, 0.00826557f, -0.00127926f, -0.00772735f, -0.01364120f, 
    0.02435761f, -0.07156484f, -0.01591941f, -0.02514689f, -0.18381105f, -0.06915816f, 0.02872962f, -0.02980022f, 
    -0.14983194f, -0.07192235f, 0.00759544f, 0.01499575f, 0.03308182f, -0.00420720f, -0.00818554f, 0.06282663f, 
    0.06795156f, 0.03974595f, 0.08613622f, 0.01277595f, 0.07048886f, 0.04021057f, 0.04041709f, 0.04087109f, 
    0.38517219f, -0.20179422f, -0.04382359f, 0.10143090f, 0.29990563f, 0.14814581f, 0.15535136f, 0.01893235f, 
    -0.01470547f, 0.09011265f, 0.05190070f, 0.11411647f, 0.02343281f, 0.11173388f, -0.04822301f, -0.05011596f, 
    -0.06804964f, -0.02665244f, -0.09780990f, -0.02755438f, 0.26770702f, 0.06650976f, -0.26413533f, -0.24290802f, 
    0.05330263f, 0.08396739f, 0.05468777f, 0.01900125f, 0.08110891f, 0.03416504f, 0.00723543f, 0.02254185f, 
    0.15671451f, 0.04868191f, -0.01512358f, 0.01890265f, 0.03039619f, 0.01860887f, 0.12983161f, 0.03538023f, 
    -0.22198632f, -0.30487683f, 0.01543179f, 0.07641392f, 0.14422987f, -0.01023791f, 0.07126205f, 0.06796356f, 
    -0.02032387f, 0.04524259f, 0.02089505f, 0.04062157f, -0.14737536f, 0.09802242f, 0.01528352f, 0.01830964f, 
    -0.01150138f, 0.04499078f, -0.00808266f, -0.02167425f, 0.01179287f, -0.28516895f, -0.45345655f, -0.18527007f, 
    0.07863598f, -0.07819168f, 0.02386911f, 0.12746966f, 0.06530667f, 0.05908614f, -0.03615003f, -0.09247489f, 
    -0.03898164f, 0.03071720f, -0.00369655f, -0.02101275f, 0.03830471f, 0.03804436f, 0.04197985f, 0.04218796f, 
    -0.18418510f, -0.09265552f, 0.03230846f, 0.03888674f, -0.00633723f, -0.02061964f, 0.02892288f, -0.00858255f, 
    0.03406030f, -0.01549099f, 0.03743505f, 0.09176558f, 0.06720997f, 0.08561431f, -0.00666276f, -0.02582251f, 
    0.08184744f, 0.02057214f, 0.09287968f, 0.08957216f, 0.13433392f, 0.09725918f, -0.25569978f, -0.25316894f, 
    -0.09772643f, 0.10018039f, 0.04589517f, -0.04481591f, 0.18031043f, 0.10777370f, -0.00087455f, 0.00836289f, 
    -0.02761858f, 0.09255545f, 0.05669671f, -0.05356888f, -0.06769088f, -0.06774902f, -0.10208720f, -0.30898449f, 
    0.23403788f, -0.02143213f, -0.08878765f, -0.05199573f, -0.12809214f, 0.00440614f, 0.04598631f, 0.06654928f, 
    0.07027815f, 0.03088761f, 0.05286112f, -0.01815698f, -0.06096415f, -0.01142321f, 0.00662810f, 0.01204170f, 
    0.12140007f, 0.00787786f, 0.12089404f, 0.01085302f, 0.19882555f, -0.12331553f, -0.15581383f, -0.03627616f, 
    -0.02591407f, -0.15368722f, 0.10386999f, 0.18641977f, 0.08642333f, -0.10900092f, 0.04581080f, 0.18246740f, 
    0.19892921f, -0.05175470f, 0.08745590f, -0.09252546f, -0.06131051f, 0.03886288f, 0.04506922f, 0.01580603f, 
    0.46116999f, 0.24445388f, 0.05646489f, 0.00621516f, -0.08103342f, -0.00586106f, -0.00962543f, -0.03153155f, 
    0.04607931f, -0.06736337f, 0.05391751f, 0.02901802f, 0.01945493f, 0.03796099f, 0.01909960f, -0.11196553f, 
    -0.12544312f, -0.08802146f, -0.05139768f, -0.25358409f, -0.24307480f, 0.08688243f, 0.10548262f, -0.05409668f, 
    -0.17694512f, -0.03073949f, -0.07254406f, -0.03661993f, -0.02487048f, -0.04058987f, -0.05732258f, -0.03924601f, 
    -0.01333912f, -0.05500760f, -0.02276100f, 0.01325814f, 0.03498305f, 0.04853578f, -0.01605358f, -0.00645093f, 
    -0.17298886f, -0.07159007f, 0.06232624f, -0.01457239f, -0.11265963f, -0.02669238f, -0.02483847f, -0.06233855f, 
    -0.01073167f, 0.06056391f, -0.04884582f, -0.07332425f, -0.07280061f, 0.03026901f, 0.01887848f, 0.01015977f, 
    0.09834711f, 0.01530682f, -0.05126166f, 0.06720437f, 0.16304435f, -0.69193667f, -0.48841107f, -0.15612590f, 
    0.08032683f, 0.06516235f, 0.11427578f, 0.07806314f, 0.10833681f, 0.14373200f, 0.05067177f, 0.08132811f, 
    -0.05565270f, -0.03282696f, -0.06971284f, 0.03332232f, 0.02101051f, -0.07106640f, -0.07266135f, 0.01427746f, 
    -0.27877158f, -0.02769784f, 0.11921220f, 0.06517178f, 0.05623036f, -0.03790142f, 0.03776280f, -0.03777758f, 
    0.00637576f, 0.00592849f, -0.05985788f, 0.02613330f, 0.03051994f, -0.01152032f, 0.05061081f, -0.00045633f, 
    -0.07657452f, 0.02443044f, -0.01747519f, 0.01888086f, -0.10583150f, 0.25896478f, 0.14298283f, 0.11880185f, 
    -0.04256043f, 0.06442221f, -0.01892317f, -0.04978387f, 0.00592388f, -0.12635940f, -0.01120957f, -0.00450987f, 
    0.02632493f, 0.00467618f, -0.05002185f, -0.01626438f, -0.07249196f, -0.03400518f, -0.00369058f, -0.03117514f, 
    -0.13863844f, -0.26525873f, -0.49274167f, -0.20243278f, -0.08701969f, 0.00730935f, -0.19597574f, -0.01934361f, 
    -0.01027468f, -0.13130654f, -0.03367538f, 0.00739490f, -0.00742673f, 0.00814506f, 0.03879379f, 0.02621423f, 
    -0.00206726f, 0.05009872f, -0.00589531f, -0.00448746f, 0.29451346f, 0.06136953f, -0.06584036f, 0.11792833f, 
    -0.16462125f, 0.10814519f, -0.07523742f, 0.02951666f, -0.09698265f, -0.04586496f, -0.00579751f, 0.01900825f, 
    -0.01154300f, -0.02187322f, -0.06350435f, 0.01929416f, 0.03650503f, 0.10217381f, 0.01466762f, -0.00464511f, 
    -0.33157891f, -0.07216415f, 0.07947780f, -0.04182149f, 0.13770325f, -0.10309329f, 0.13591635f, -0.01390916f, 
    0.07090363f, -0.04914533f, 0.02698466f, -0.06474012f, 0.06707589f, 0.12261452f, -0.03854447f, -0.04030424f, 
    -0.01939686f, 0.06294581f, 0.08702361f, 0.00832547f, -0.25964314f, -0.04719855f, -0.15479821f, -0.05739058f, 
    -0.01327935f, -0.02295470f, 0.20733418f, -0.01562810f, 0.07973740f, 0.04368911f, 0.08562359f, -0.00249959f, 
    -0.07336958f, 0.12434853f, 0.05076001f, 0.05134723f, 0.09834089f, 0.00605847f, 0.04744850f, -0.07999080f, 
    0.03632661f, 0.04201373f, 0.10310029f, 0.04848656f, -0.13471064f, -0.06734129f, -0.06090868f, -0.08545689f, 
    -0.01762242f, 0.04609881f, 0.00590934f, -0.04031278f, -0.07072629f, 0.00043301f, -0.02571597f, -0.18554127f, 
    0.00010340f, -0.03860551f, -0.23157103f, -0.07130544f, -0.21627198f, 0.19442788f, 0.17350520f, 0.11846831f, 
    -0.16381072f, 0.04265135f, -0.02490636f, -0.11517286f, -0.02174637f, -0.06956057f, -0.02240522f, 0.02023649f, 
    -0.01234554f, -0.03873497f, -0.04826688f, -0.00356707f, -0.03878161f, -0.08312935f, -0.09890234f, -0.09431252f, 
    0.04626399f, 0.03166115f, -0.43446270f, -0.24312319f, 0.00922771f, -0.02093545f, -0.05565565f, 0.13892575f, 
    0.10400453f, 0.05827419f, 0.00089158f, -0.02646159f, -0.03673341f, 0.03536726f, 0.06386562f, 0.07241131f, 
    0.01248473f, 0.07921520f, -0.06954671f, -0.17174533f, -0.00761797f, -0.27343321f, -0.16721855f, 0.08761594f, 
    0.10370053f, 0.05372884f, -0.01274352f, -0.06834606f, 0.03800282f, 0.07550851f, 0.00338819f, -0.00378248f, 
    0.01301994f, -0.01570793f, -0.01746883f, 0.00805437f, 0.04971588f, 0.12141164f, -0.01687763f, 0.11441521f, 
    -0.03379391f, -0.18117104f, -0.08039475f, 0.03914928f, 0.05760454f, 0.13267788f, 0.01407179f, 0.01140899f, 
    -0.00641301f, -0.01942564f, 0.04911474f, -0.00857386f, -0.00462326f, -0.02577777f, -0.00651581f, 0.02802776f, 
    -0.10121877f, -0.01656128f, -0.11686236f, -0.17256555f, 0.08881526f, -0.03362672f, -0.02793983f, -0.04993624f, 
    -0.05351686f, -0.00532689f, -0.04562309f, -0.05120556f, -0.01988137f, -0.03561987f, -0.06523976f, 0.09405191f, 
    0.04568697f, -0.01106034f, 0.06647517f, 0.03499312f, 0.11260553f, 0.03841968f, 0.08704627f, 0.10648705f, 
    -0.04748722f, -0.36325860f, -0.48502207f, -0.17935766f, -0.18843308f, 0.09896501f, -0.07759107f, -0.10448021f, 
    -0.01159470f, -0.09767565f, -0.02066449f, -0.02116230f, 0.00048844f, 0.03346632f, 0.01274022f, 0.02489501f, 
    0.02762775f, 0.04377596f, 0.07997364f, 0.05827709f, 0.02223773f, 0.01931837f, 0.12623225f, 0.00438662f, 
    -0.07285611f, 0.07760856f, -0.18242466f, -0.11131921f, -0.13701063f, -0.28051910f, -0.00911698f, -0.02644191f, 
    -0.00399954f, -0.01738265f, -0.01468358f, 0.07719808f, 0.02568981f, -0.02019553f, -0.07338504f, -0.23004358f, 
    0.53118688f, -0.15096749f, -0.14292705f, -0.05132064f, -0.17668018f, -0.00082534f, -0.08857394f, -0.00711901f, 
    0.01758556f, -0.00991594f, -0.04726302f, 0.03114426f, 0.03470446f, 0.01084281f, 0.00926126f, -0.01812214f, 
    0.09541746f, 0.13334587f, 0.01418720f, 0.00991250f, 0.04818146f, 0.04294989f, 0.03246387f, 0.03271808f, 
    -0.05036684f, 0.03138520f, -0.07114921f, 0.00096840f, 0.09809863f, -0.11417374f, -0.03574118f, -0.00811182f, 
    0.00214683f, -0.02248110f, -0.00294751f, -0.17013802f, 0.07470416f, 0.00543298f, -0.05961736f, 0.01910742f, 
    -0.01500923f, -0.44924498f, -0.43985599f, -0.26073661f, -0.19843127f, -0.15794243f, -0.19101949f, 0.00066340f, 
    -0.15610355f, -0.33759069f, 0.01045305f, 0.00478602f, 0.00311275f, 0.00414216f, 0.04789142f, 0.05970381f, 
    0.03206896f, 0.16670182f, -0.03618990f, -0.31257385f, 0.13445799f, -0.19127226f, -0.07413068f, 0.10691011f, 
    -0.00548589f, 0.05024647f, -0.01620501f, -0.08384214f, -0.01057524f, 0.09130061f, 0.04798329f, 0.09621704f, 
    0.03236471f, 0.00193652f, 0.05421603f, -0.01516297f, 0.12264812f, 0.06518655f, 0.11793849f, 0.13185988f, 
    -0.07177810f, -0.16552062f, 0.04190499f, 0.05837491f, -0.01250129f, -0.03598238f, 0.01559711f, 0.00516741f, 
    -0.04020638f, 0.06723198f, 0.01584107f, -0.00377157f, 0.04765635f, 0.12855217f, 0.05484190f, 0.04652387f, 
    0.07473138f, 0.01146358f, 0.01183064f, 0.11361273f, -0.27607986f, -0.33302593f, 0.02965515f, 0.08200647f, 
    0.13518588f, -0.05082167f, 0.08521707f, 0.09017013f, 0.00084010f, 0.01606829f, 0.04345724f, 0.01167389f, 
    0.06380580f, 0.09955416f, -0.03795364f, -0.02421222f, -0.03420763f, -0.03121572f, 0.04644457f, -0.03508668f, 
    -0.10333630f, -0.15437245f, 0.21426305f, -0.06400004f, 0.12018418f, -0.07592790f, 0.02507726f, -0.10670178f, 
    0.00857901f, -0.05453926f, -0.03544771f, 0.00604059f, 0.01753808f, -0.11078590f, 0.02355915f, 0.00139259f, 
    -0.02054626f, -0.17838812f, -0.00101730f, -0.07399567f, -0.05360573f, -0.12049641f, -0.06405852f, 0.02278108f, 
    -0.04018146f, -0.09310308f, -0.01186388f, -0.01234163f, -0.00828811f, 0.02291974f, 0.03177164f, 0.02492346f, 
    -0.04433358f, -0.03178407f, 0.00713393f, -0.02001467f, 0.14566480f, 0.08646400f, 0.15174830f, 0.11028620f, 
    0.07863969f, -0.09952092f, -0.56988251f, -0.23864172f, -0.06007583f, 0.11529065f, -0.04212315f, 0.17606805f, 
    0.07750539f, 0.06063160f, 0.00017635f, 0.00885596f, -0.02420522f, 0.00749836f, -0.01843167f, 0.02848468f, 
    0.01043162f, -0.02165280f, 0.01866367f, 0.00793747f, -0.04312029f, -0.00564188f, 0.00178125f, -0.04000705f, 
    -0.14249389f, -0.07839600f, 0.02245568f, 0.06392481f, 0.03175676f, -0.05785151f, 0.04415914f, 0.12664516f, 
    0.02686295f, 0.05318964f, 0.06386647f, -0.03162241f, 0.01948159f, -0.01492359f, -0.01237214f, 0.06768110f, 
    -0.08938126f, -0.30039513f, -0.08296860f, 0.14631252f, 0.07602585f, -0.00589548f, 0.00592637f, -0.00338743f, 
    -0.02371916f, 0.12490130f, -0.00207115f, 0.01037998f, 0.00100555f, 0.01438517f, 0.01341064f, -0.02175358f, 
    0.10684254f, 0.06546430f, 0.00151342f, 0.06110064f, -0.06516813f, -0.20737386f, -0.48978925f, -0.32845974f, 
    -0.06283528f, -0.08698023f, -0.09211323f, 0.09467831f, -0.07880297f, -0.19135238f, -0.02396511f, -0.04497104f, 
    -0.06329244f, 0.02524860f, 0.06500421f, 0.01628337f, -0.03203412f, 0.06042016f, 0.00734682f, -0.01418921f, 
    -0.01665938f, -0.22832504f, -0.12908804f, 0.00925641f, -0.03365856f, -0.00152247f, 0.06156550f, 0.13087676f, 
    -0.01463568f, 0.13334401f, 0.05200144f, 0.00400059f, -0.00605160f, 0.01741042f, -0.03246352f, 0.01544705f, 
    0.03145667f, -0.03439725f, -0.00688906f, -0.00105565f, -0.16492744f, 0.01491260f, -0.19763842f, 0.11614501f, 
    -0.10112168f, 0.00865566f, 0.05173434f, 0.10094180f, -0.00723720f, 0.06973974f, 0.00480745f, -0.04851135f, 
    0.01551165f, 0.02316938f, -0.05958390f, -0.03122515f, 0.08288866f, 0.00603985f, 0.00325421f, 0.07110044f, 
    -0.21742830f, -0.09117458f, -0.27796307f, 0.05602046f, -0.23606150f, 0.00031068f, 0.01410797f, 0.00656898f, 
    -0.07099805f, 0.13023582f, 0.00537330f, 0.01134376f, 0.01476209f, 0.03056291f, -0.00212587f, -0.06973124f, 
    0.00213345f, 0.02537452f, 0.16776651f, 0.09481776f, -0.15381989f, 0.13503909f, 0.11553649f, 0.05327941f, 
    0.00817158f, 0.07741208f, 0.00191789f, -0.00553348f, -0.04317289f, -0.09265090f, 0.01032196f, 0.02778069f, 
    0.04884311f, 0.00702961f, 0.01985483f, 0.01352257f, -0.04948589f, -0.09701938f, 0.03550559f, -0.04441640f, 
    -0.02072148f, -0.24859577f, 0.19870047f, -0.12479676f, -0.06762823f, 0.06123821f, -0.09448589f, -0.08697294f, 
    0.07452250f, 0.13071269f, 0.07178395f, -0.11176928f, 0.06846465f, -0.05765859f, -0.13913532f, 0.13867348f, 
    0.01536443f, -0.21365359f, -0.08494014f, 0.00357066f, -0.05534611f, 0.04371816f, -0.26709622f, -0.15466972f, 
    0.16233934f, -0.12513912f, 0.14646402f, 0.14134817f, 0.09189378f, 0.07898970f, 0.05018599f, 0.04133948f, 
    -0.05484012f, -0.03348214f, -0.04010420f, 0.05983666f, 0.10749041f, -0.12705491f, -0.04583859f, -0.08214170f, 
    0.18602164f, -0.41202042f, 0.16521628f, -0.31829321f, -0.19833390f, -0.18397354f, -0.28705758f, -0.01893941f, 
    0.06144797f, 0.02981502f, -0.04622605f, 0.01897415f, -0.01100579f, -0.03337445f, -0.00166697f, 0.09324066f, 
    0.02565316f, 0.02240780f, -0.07688300f, -0.06894567f, -0.14633156f, -0.09243528f, -0.33631739f, 0.01026277f, 
    -0.00179088f, 0.02052906f, 0.02983952f, 0.14524782f, 0.01015192f, 0.00519076f, 0.03004648f, 0.01688314f, 
    0.02678292f, 0.04723665f, 0.00158664f, -0.07202398f, 0.13640451f, 0.02805885f, 0.02883358f, 0.13166460f, 
    0.13096875f, 0.19126317f, 0.11980363f, 0.45908248f, -0.36042646f, 0.00103525f, -0.03524590f, -0.32569560f, 
    0.02134844f, -0.13829701f, 0.00712823f, -0.09966830f, 0.11540243f, 0.04200002f, -0.00267529f, 0.07943405f, 
    0.06281899f, 0.05117455f, 0.03002126f, 0.11953747f, 0.16003422f, 0.07450625f, 0.38338941f, 0.33623916f, 
    -0.28720003f, 0.14419453f, -0.14784898f, -0.22561710f, -0.13864481f, -0.23639064f, 0.05042643f, 0.08244972f, 
    0.09259181f, 0.05404364f, 0.05236673f, 0.00339750f, -0.02370442f, -0.02877257f, -0.00456094f, -0.00423760f, 
    0.02158755f, -0.27011454f, -0.37941208f, -0.10862409f, 0.21246395f, -0.04065379f, -0.02625155f, 0.11869562f, 
    0.01179002f, -0.00436133f, -0.10407320f, -0.01899491f, 0.02320962f, -0.04188062f, -0.04170496f, 0.07037707f, 
    0.09624194f, 0.06062589f, -0.02201688f, 0.00170370f, 0.16568244f, 0.03946010f, 0.14962432f, -0.10328015f, 
    -0.11370742f, -0.11004706f, 0.06282100f, -0.23820285f, -0.03870971f, -0.04094260f, 0.01610525f, 0.03149053f, 
    0.00894282f, 0.06998345f, 0.00984448f, -0.05581445f, -0.02545624f, -0.05980536f, -0.07389478f, 0.06064692f, 
    -0.29008800f, 0.10776058f, -0.13595186f, 0.41365567f, -0.48849571f, -0.21400039f, 0.17644054f, -0.51978368f, 
    0.00522455f, -0.20913041f, 0.08988582f, -0.09895828f, 0.01980196f, 0.10632676f, 0.03796907f, 0.08756846f, 
    0.06043063f, -0.00300035f, 0.02979870f, 0.06398033f, -0.06034671f, 0.14135304f, -0.02395485f, 0.31305590f, 
    0.11965098f, 0.00243946f, -0.01100001f, -0.13228002f, 0.12365059f, -0.06240886f, 0.12227084f, -0.00214334f, 
    0.10573504f, -0.04149320f, -0.07625009f, 0.01591473f, 0.06204274f, -0.00393136f, 0.10046323f, 0.16217880f, 
    -0.00010371f, 0.39569372f, -0.25161085f, -0.00015885f, -0.10604565f, -0.03882532f, -0.05049507f, 0.02750783f, 
    -0.12524393f, 0.12814488f, 0.00539859f, 0.06289189f, -0.04740960f, -0.01464881f, 0.03511084f, -0.00362679f, 
    0.01356226f, 0.10661072f, -0.00210143f, -0.01582559f, 0.32957435f, -0.62601340f, -0.18163116f, -0.29532436f, 
    0.05796725f, -0.15675569f, -0.08661677f, 0.03144495f, 0.11309386f, 0.09681686f, -0.06019059f, 0.00922430f, 
    0.01712186f, -0.00824539f, 0.02331746f, -0.06000997f, 0.04916948f, 0.09152058f, -0.00940708f, 0.05665797f, 
    0.03829775f, 0.06201546f, 0.22444716f, 0.22129653f, -0.13636830f, 0.13242042f, -0.05206461f, -0.11680358f, 
    0.02473767f, -0.13392682f, -0.02694168f, 0.07063748f, 0.01090165f, 0.01079502f, 0.06370960f, 0.02584840f, 
    -0.05916791f, -0.01655069f, -0.00846358f, 0.03439282f, -0.13333978f, 0.17299800f, -0.43288761f, -0.03692596f, 
    -0.03416283f, 0.16779238f, 0.04350992f, 0.12347023f, -0.00822000f, 0.05138249f, 0.06836269f, -0.07384680f, 
    -0.01073724f, 0.02291112f, -0.02855825f, 0.05001432f, -0.09484436f, -0.03711522f, -0.02123721f, -0.01769369f, 
    -0.60497862f, 0.12258377f, -0.21368939f, 0.28780779f, -0.02253358f, 0.08411995f, -0.01611645f, -0.09183281f, 
    -0.06510095f, -0.12972631f, 0.08511288f, 0.04433915f, 0.00754169f, -0.14557493f, -0.00553660f, -0.00643220f, 
    -0.08397782f, -0.11731891f, 0.07881580f, 0.04166592f, -0.22490795f, -0.39012545f, -0.34308881f, 0.05465486f, 
    -0.21169221f, -0.13808125f, 0.22861648f, 0.04201249f, -0.09220076f, -0.06513239f, 0.06561847f, -0.08137019f, 
    -0.07821959f, -0.05764483f, 0.09352116f, -0.02094794f, 0.14571984f, -0.00464391f, -0.13693213f, -0.02274832f, 
    -0.07358263f, -0.10473318f, 0.40234971f, 0.12838589f, -0.47324678f, 0.01007371f, -0.14011163f, -0.24014162f, 
    0.04950076f, 0.01369547f, -0.00628325f, -0.00695668f, -0.00021859f, 0.03700743f, -0.00936551f, -0.02572072f, 
    -0.03994385f, -0.02596725f, -0.03672151f, -0.01168922f, -0.14094679f, 0.31294587f, -0.50563896f, 0.10949961f, 
    -0.15337144f, 0.05642229f, 0.04692003f, 0.16529402f, -0.02496798f, -0.00049341f, 0.03543179f, -0.03821317f, 
    -0.04652312f, -0.07014839f, -0.07401921f, 0.09497984f, -0.03719676f, -0.04884109f, 0.05457371f, -0.10100356f, 
    -0.04877459f, -0.06809482f, 0.05604536f, 0.03673330f, 0.12274881f, -0.08061300f, 0.08806775f, -0.03321214f, 
    -0.05841292f, -0.00872909f, 0.01692594f, 0.02433389f, -0.00131072f, 0.05672674f, 0.00165397f, 0.07202768f, 
    -0.04247782f, 0.01544191f, -0.12659232f, -0.04392828f, -0.31705523f, -0.00600948f, -0.08147463f, -0.26825044f, 
    -0.29039532f, 0.05941616f, -0.09256251f, -0.09675746f, 0.04210713f, 0.03576081f, 0.00729705f, 0.00541689f, 
    0.05059909f, 0.03256166f, -0.07053302f, -0.04771721f, 0.04321947f, -0.02457861f, -0.00842550f, 0.05634703f, 
    -0.15347309f, -0.08169548f, -0.21268044f, -0.03162757f, 0.12904121f, -0.01780736f, 0.10872108f, 0.13550870f, 
    -0.00227372f, 0.06724901f, -0.00362390f, 0.05052901f, 0.04239669f, 0.02088959f, -0.02025494f, 0.04972354f, 
    0.06520087f, 0.04866710f, 0.00927131f, 0.05908696f, -0.09637674f, -0.01521952f, 0.02249997f, -0.02000014f, 
    0.13626932f, 0.00105530f, -0.03772096f, 0.01100680f, 0.01150915f, -0.06527843f, 0.16821428f, 0.12903371f, 
    0.15542684f, 0.11057475f, -0.14345621f, 0.15437208f, 0.02757061f, 0.04560751f, 0.02238995f, 0.04509206f, 
    -0.14521353f, -0.43858439f, -0.12192492f, -0.22456942f, -0.30501866f, 0.09601463f, -0.20224002f, 0.02093156f, 
    -0.04105486f, -0.08772484f, -0.05126458f, 0.02843081f, 0.00119721f, 0.03955318f, 0.11515626f, -0.01062220f, 
    0.04694626f, 0.00371443f, 0.00086436f, 0.00731730f, -0.22547515f, 0.00107371f, 0.05485984f, 0.20882817f, 
    -0.26800171f, 0.08827979f, -0.15100037f, 0.01823140f, -0.04286256f, -0.09517855f, 0.01283199f, -0.03657127f, 
    0.04742575f, -0.00567453f, 0.01440997f, 0.02065896f, 0.02507309f, -0.07541316f, 0.01190316f, 0.01513547f, 
    0.13019745f, -0.08017211f, 0.07059057f, -0.08304001f, -0.20483676f, -0.06003749f, -0.06300009f, -0.06450656f, 
    0.00677684f, -0.06241989f, -0.02607093f, 0.05316743f, -0.03069748f, 0.06911492f, -0.01145232f, -0.00590529f, 
    0.02379815f, 0.01641852f, -0.02836240f, -0.01315017f, -0.32757714f, -0.03695426f, 0.30896330f, 0.14216292f, 
    -0.38069612f, 0.17934841f, -0.26562011f, 0.00280140f, -0.01482618f, 0.06637797f, -0.03991732f, -0.05400219f, 
    -0.00330340f, 0.00548906f, -0.08328403f, 0.01803409f, 0.04737199f, -0.03402051f, -0.02741178f, -0.02964609f, 
    -0.07922479f, 0.19408886f, 0.25441039f, -0.19296530f, -0.05165828f, 0.04970318f, -0.06135756f, -0.01346850f, 
    0.01124245f, 0.08048999f, 0.04581940f, 0.05829047f, 0.04599476f, 0.01504402f, 0.03495416f, -0.00635504f, 
    0.08935075f, -0.04249449f, 0.01037045f, -0.00379508f, -0.27321872f, 0.15954983f, 0.06456011f, 0.38139778f, 
    -0.52461892f, 0.10944846f, -0.02173230f, -0.09930243f, 0.07574174f, 0.02074053f, 0.07681441f, 0.00856781f, 
    0.06829354f, 0.01303253f, -0.02235893f, 0.01889088f, 0.04573019f, 0.04410134f, 0.15808287f, 0.18988656f, 
    -0.27301398f, 0.16000725f, -0.07469581f, 0.19864522f, -0.00958357f, -0.02786728f, -0.17267951f, -0.06791352f, 
    -0.05985110f, -0.02676192f, 0.01198386f, -0.02942383f, -0.03575084f, -0.05478817f, -0.05948753f, 0.00853750f, 
    -0.12270349f, -0.01205104f, 0.03759836f, -0.01097235f, -0.33888158f, -0.01349084f, -0.04879434f, -0.15169483f, 
    0.02896314f, -0.00734087f, 0.20631890f, -0.16309370f, -0.32067755f, 0.12975520f, 0.03144591f, -0.01085801f, 
    0.05940102f, -0.08521834f, -0.01237618f, 0.06184038f, -0.04592301f, -0.07518946f, -0.09635945f, -0.04649420f, 
    -0.42723021f, -0.01485374f, -0.39106855f, 0.20199683f, -0.14440337f, 0.03414013f, -0.02508125f, 0.05108171f, 
    -0.01318138f, 0.09566551f, 0.06160877f, -0.07915597f, 0.03388966f, 0.01660474f, -0.02937659f, -0.00779357f, 
    0.04535824f, 0.03323141f, 0.17448924f, 0.22644022f, -0.21142733f, -0.11858142f, -0.25773603f, -0.12441300f, 
    0.18480240f, -0.00221881f, 0.09817328f, 0.02005092f, 0.04234841f, -0.06537028f, 0.01353881f, 0.00568894f, 
    0.04289220f, -0.00986588f, -0.01053758f, 0.08563418f, 0.02297801f, -0.03170555f, 0.00842131f, 0.03483051f, 
    0.02491065f, -0.18748868f, -0.10098023f, -0.11889000f, 0.08707324f, 0.06597430f, -0.02878464f, -0.05068117f, 
    0.04370145f, 0.00742249f, -0.00322829f, 0.06661221f, 0.07312477f, 0.01708347f, -0.01437318f, 0.07306600f, 
    0.00901002f, 0.00133088f, -0.00628152f, 0.07575194f, 0.05982004f, 0.12112720f, 0.19136922f, 0.19319648f, 
    -0.40733492f, 0.00324545f, -0.08088721f, -0.25745180f, -0.19301766f, -0.16521548f, 0.17379311f, -0.02670274f, 
    0.05464802f, 0.05135954f, 0.03950481f, -0.00120241f, -0.03524900f, -0.01740414f, -0.05884296f, -0.00966992f, 
    0.10180207f, -0.12070047f, -0.00530995f, -0.26157248f, 0.09846537f, -0.02908481f, 0.03507053f, 0.11366691f, 
    -0.01056833f, 0.08629559f, 0.02344158f, 0.09302328f, -0.01239225f, 0.00036382f, -0.03553430f, 0.01335577f, 
    0.06877631f, 0.07929281f, -0.06278662f, 0.03540903f, -0.22299294f, 0.22964077f, -0.68106008f, 0.21095166f, 
    -0.00355473f, 0.08590041f, 0.06608171f, 0.21479478f, -0.07803489f, 0.05530480f, 0.05287031f, -0.03934823f, 
    0.00221170f, -0.03599185f, -0.08559274f, 0.08297963f, 0.15062715f, -0.12621608f, 0.01771721f, -0.03735596f, 
    -0.27844560f, -0.24841821f, 0.14271981f, 0.14420398f, -0.23267816f, -0.08669425f, -0.12372347f, 0.10470038f, 
    0.05408201f, 0.19007681f, 0.03530398f, 0.01868427f, 0.02984838f, -0.00376604f, -0.00073371f, -0.01068087f, 
    0.04856979f, 0.01509400f, 0.02733424f, -0.03070756f, -0.21426779f, 0.11227639f, -0.43748188f, -0.21027555f, 
    -0.16796702f, 0.11992534f, -0.07475567f, 0.10470141f, 0.07215669f, 0.01067474f, 0.06786571f, -0.01583490f, 
    -0.01241482f, -0.05054834f, -0.01171720f, -0.25652042f, -0.02325336f, -0.01937994f, 0.03699667f, 0.01503864f, 
    -0.50650483f, 0.13458523f, 0.19622040f, -0.18817472f, -0.10564438f, -0.04201445f, -0.06747722f, -0.01476821f, 
    -0.01575492f, 0.08813398f, -0.12092654f, 0.06540741f, -0.10426608f, -0.14300485f, 0.01028198f, 0.08005950f, 
    0.08817091f, -0.12501225f, 0.05223027f, 0.12123077f, -0.53804600f, 0.27468950f, -0.13079913f, -0.44735271f, 
    0.15579344f, 0.29883635f, -0.20711409f, 0.07986122f, -0.03336134f, -0.30129933f, -0.00191168f, 0.01476402f, 
    -0.12207370f, 0.07521690f, 0.08619446f, -0.07553861f, -0.14253452f, -0.04371484f, -0.11216704f, 0.00502118f, 
    -0.12320796f, -0.31689003f, -0.04028885f, -0.19484545f, 0.09706087f, -0.04138260f, -0.02178425f, -0.10577916f, 
    0.02737631f, -0.11915770f, -0.05347193f, 0.01919151f, 0.04202184f, -0.06711201f, 0.01504905f, 0.12402976f, 
    -0.04446600f, -0.11009105f, -0.09467221f, 0.00538960f, -0.02512164f, 0.09358921f, -0.34471044f, -0.00307839f, 
    0.04835290f, 0.12711813f, 0.08773560f, 0.16076416f, 0.02914641f, 0.16427961f, -0.00587203f, -0.01484146f, 
    -0.01097121f, 0.00833869f, -0.04768654f, -0.02045238f, -0.03746453f, 0.00107533f, 0.01507369f, -0.00432000f, 
    0.01152487f, -0.10003220f, -0.15847045f, 0.30044237f, -0.39436319f, -0.05340018f, 0.08178828f, -0.16158654f, 
    0.01713748f, 0.00409874f, 0.06241132f, -0.00223977f, 0.04810234f, 0.06013615f, 0.07265857f, 0.02706838f, 
    0.13469623f, 0.05031476f, 0.14219350f, 0.13053545f, 0.10548609f, 0.17610632f, 0.23709852f, -0.20044914f, 
    -0.21381386f, -0.00277367f, -0.04875417f, 0.03014309f, 0.04847059f, 0.04787707f, -0.06173542f, -0.00956582f, 
    0.03982906f, -0.03345172f, -0.00237550f, 0.00337606f, -0.06245450f, 0.07090043f, -0.11633354f, -0.14302966f, 
    0.18141958f, -0.35286465f, -0.19512250f, 0.03723015f, 0.01933088f, 0.00269841f, -0.13993931f, 0.10305039f, 
    0.03955546f, 0.05664923f, -0.01319958f, 0.07245575f, 0.00580681f, 0.01891798f, 0.06475548f, 0.05928632f, 
    0.08677088f, 0.17714864f, 0.00966283f, 0.18652426f, 0.09560008f, 0.02314746f, -0.10308818f, 0.03912500f, 
    -0.07876066f, 0.04566715f, 0.12882128f, 0.13945566f, 0.00025801f, -0.07838853f, -0.01065133f, 0.02252415f, 
    -0.14045528f, -0.03118244f, 0.03356984f, 0.07105400f, -0.05000273f, -0.06690747f, -0.03059710f, -0.10297579f, 
    -0.35021397f, -0.22516811f, -0.09327452f, 0.08288633f, -0.17637201f, -0.11819993f, -0.20538886f, 0.27212027f, 
    0.05688550f, 0.09434100f, 0.01731686f, -0.00111648f, -0.00458980f, -0.03752741f, -0.04724037f, 0.00664578f, 
    0.02013745f, 0.06133525f, 0.09118534f, -0.11343887f, 0.26628068f, 0.17894414f, -0.64614373f, 0.15204044f, 
    0.00603216f, 0.07224303f, -0.03851909f, 0.09342316f, -0.07878280f, 0.11055473f, -0.00529113f, 0.00830986f, 
    0.01338764f, 0.00465268f, 0.00719533f, -0.00603479f, 0.05465917f, 0.05495108f, 0.05857418f, 0.10754342f, 
    0.38877690f, -0.16220638f, -0.14403234f, -0.00757475f, -0.18400809f, -0.21196561f, -0.14320266f, 0.15659632f, 
    0.02569414f, 0.24196479f, -0.03917084f, -0.01849075f, -0.01392053f, -0.02430188f, -0.12750925f, 0.03028203f, 
    -0.01807909f, 0.00381043f, -0.03828505f, -0.04301785f, -0.00307709f, -0.34396499f, -0.03088693f, 0.12590158f, 
    0.03053586f, -0.16065253f, 0.10763936f, -0.12105779f, 0.01004615f, 0.01185292f, -0.02746367f, -0.14723501f, 
    0.02729258f, 0.02548442f, 0.04643960f, 0.06860795f, 0.05690607f, -0.04159791f, -0.09556431f, -0.03617836f, 
    -0.00060938f, -0.58977300f, 0.08469303f, 0.02762404f, 0.04125059f, -0.14594397f, -0.10673347f, -0.00112944f, 
    0.14701150f, 0.18213440f, 0.01064610f, 0.03511037f, 0.05181880f, 0.01575470f, 0.01878109f, -0.00331547f, 
    0.00397445f, 0.01907362f, 0.10008416f, 0.09823903f, 0.00903594f, 0.03153822f, 0.25373814f, -0.09432239f, 
    -0.11077058f, 0.00212533f, 0.00825101f, 0.07838991f, -0.05752466f, 0.06206897f, 0.01830624f, -0.01277890f, 
    0.01846983f, -0.04534271f, 0.02972923f, 0.00285040f, -0.04827072f, -0.04655841f, -0.17730764f, -0.11323376f, 
    0.04774773f, -0.20552838f, 0.14045399f, -0.16353989f, 0.01104565f, -0.00413388f, 0.02990256f, -0.05256256f, 
    -0.01259672f, -0.00455339f, 0.07597590f, -0.00960387f, -0.03440130f, 0.07909264f, 0.01438139f, -0.05254842f, 
    0.06376673f, -0.02260790f, -0.02482365f, 0.03814516f, 0.07884050f, -0.13519272f, 0.12251554f, -0.13361028f, 
    -0.12360497f, -0.10548248f, -0.12891845f, -0.08060252f, 0.11280932f, -0.14535233f, -0.09582058f, 0.05567572f, 
    0.01457896f, 0.07423392f, -0.00794280f, 0.04865371f, 0.02262696f, 0.01058661f, -0.02695617f, 0.09051932f, 
    0.11348502f, -0.01451327f, 0.01652838f, 0.03782928f, -0.05615396f, 0.01297462f, -0.06077579f, -0.01433378f, 
    -0.04627290f, -0.08758895f, -0.04323925f, 0.03668202f, -0.05123460f, -0.05082989f, 0.01566866f, 0.03735787f, 
    0.12976801f, 0.00953900f, 0.01901659f, 0.22821519f, 0.06127034f, 0.04117866f, 0.18083118f, 0.00848540f, 
    0.07776593f, 0.02765490f, 0.05506786f, -0.03226840f, -0.02295423f, -0.00390209f, 0.00618455f, 0.05396860f, 
    0.02259708f, -0.01746399f, 0.02214153f, -0.00432467f, -0.04840948f, -0.02476951f, -0.03276026f, -0.00183684f, 
    -0.05942777f, 0.04631003f, -0.31121483f, 0.00572023f, -0.15159974f, -0.21790124f, 0.04219683f, -0.01224407f, 
    0.06921190f, 0.11856372f, 0.08832100f, -0.07392810f, 0.00974719f, -0.03489623f, 0.02052067f, -0.02374919f, 
    0.04624096f, 0.03873950f, 0.01046875f, -0.05789170f, -0.20958725f, 0.04757997f, 0.07804872f, 0.08472384f, 
    0.19262382f, -0.12840049f, 0.11172941f, -0.13231719f, -0.05840170f, 0.00826030f, 0.04526780f, 0.04692680f, 
    0.06180485f, -0.03616305f, 0.02548119f, 0.13252233f, 0.08606182f, -0.03343604f, -0.02965753f, 0.03670968f, 
    0.06207624f, -0.02699699f, 0.30645400f, -0.23045467f, -0.20704165f, -0.10476179f, -0.01192456f, -0.04332137f, 
    0.03310442f, 0.06168685f, -0.01101097f, 0.00140295f, 0.00728762f, -0.00224129f, 0.01862837f, -0.01624282f, 
    0.06228708f, -0.04060252f, -0.09836525f, -0.01220150f, -0.01698731f, -0.08459918f, 0.13451289f, 0.25620821f, 
    -0.50745577f, -0.07586749f, 0.00977455f, -0.05994078f, 0.05004722f, 0.07772381f, 0.04661952f, 0.00148703f, 
    0.03203438f, 0.02337360f, 0.00411855f, -0.03752127f, 0.04578770f, 0.03570373f, 0.08507665f, -0.00884958f, 
    0.01477811f, -0.07599799f, -0.07897484f, 0.11334337f, 0.06814702f, -0.01351316f, 0.07943288f, 0.04478792f, 
    -0.09411934f, -0.00324921f, -0.02998118f, -0.03610227f, -0.03935862f, 0.02834552f, 0.04337162f, 0.00757221f, 
    -0.10388222f, -0.18974106f, 0.01449909f, 0.00609963f, 0.05973329f, -0.21871050f, 0.19573891f, 0.14503407f, 
    0.01551900f, -0.09537067f, -0.06798361f, 0.01968201f, -0.11130881f, -0.01503661f, 0.04367346f, -0.04762118f, 
    -0.13950430f, 0.05366353f, 0.05697013f, 0.03398424f, -0.14351515f, 0.05321289f, 0.00722820f, -0.02443098f, 
    -0.06023296f, 0.04460913f, -0.16149868f, 0.03698973f, 0.10865919f, 0.01330424f, 0.00099120f, 0.02738359f, 
    -0.05991037f, -0.06677565f, -0.02972910f, 0.04232873f, 0.00466640f, 0.00841509f, 0.00491342f, 0.12570235f, 
    -0.11189512f, -0.17769310f, -0.15296382f, -0.14522645f, -0.05620054f, -0.21113780f, 0.08247698f, -0.03272381f, 
    -0.08580942f, -0.01607807f, 0.06634627f, 0.02241341f, 0.04477646f, 0.01185527f, -0.01800001f, -0.01462659f, 
    0.01623701f, 0.03099350f, 0.01487997f, -0.01286497f, 0.10075567f, 0.06843591f, 0.07926148f, 0.06496403f, 
    -0.35764268f, 0.11831544f, -0.13391887f, 0.06558786f, -0.03471363f, 0.06952704f, 0.09950101f, 0.03308630f, 
    0.16605909f, 0.16835268f, -0.23583929f, 0.03428912f, 0.02563735f, -0.09296098f, -0.02611460f, 0.04555357f, 
    -0.04738877f, 0.04138675f, 0.17969628f, 0.17609540f, -0.00712048f, -0.18797463f, 0.08379496f, 0.03067968f, 
    -0.10151458f, 0.07344853f, -0.11032305f, 0.14177822f, 0.00201920f, -0.10361604f, -0.09255740f, 0.01181172f, 
    0.07244381f, 0.04529091f, 0.06549147f, 0.06466524f, 0.01951374f, 0.12752135f, -0.02941016f, 0.01515687f, 
    -0.37646642f, 0.10811269f, 0.01613030f, 0.16491942f, 0.06967881f, 0.08653603f, -0.09242274f, -0.07420827f, 
    0.13862370f, 0.06033091f, -0.04170471f, 0.03474807f, 0.02077421f, -0.01004620f, -0.03138077f, -0.10571670f, 
    0.03214177f, -0.34689736f, -0.15088232f, -0.03876263f, -0.02334082f, -0.09088972f, 0.03625460f, 0.02997211f, 
    -0.00693014f, -0.12885547f, -0.03768536f, -0.05164232f, -0.02264704f, -0.06804182f, -0.08088691f, -0.01759210f, 
    -0.12625329f, 0.01634259f, 0.01135837f, 0.07488198f, -0.10429162f, -0.00718842f, -0.05033337f, -0.02741522f, 
    0.12198634f, -0.09374170f, -0.24950406f, -0.00162264f, -0.02583589f, 0.09673331f, 0.02349825f, 0.04887601f, 
    -0.01452403f, 0.02951850f, -0.13783270f, 0.09427355f, -0.12758000f, -0.26549464f, -0.32500169f, 0.01673606f, 
    -0.15373175f, -0.02887192f, 0.02965800f, -0.13310072f, 0.01603662f, -0.07196942f, -0.01076197f, -0.01141857f, 
    -0.06400393f, -0.04585924f, 0.01893835f, -0.19253555f, 0.09981987f, -0.03763381f, -0.00299826f, 0.04169154f, 
    -0.03640347f, -0.04072257f, -0.08984126f, 0.01095784f, -0.02474838f, 0.00190383f, 0.04848272f, 0.05221343f, 
    -0.03070520f, -0.07612577f, -0.18887056f, 0.10483762f, -0.00467844f, -0.04101124f, -0.09233911f, -0.21528231f, 
    -0.06395005f, -0.07793148f, -0.10051129f, -0.00049553f, -0.08206466f, 0.02773211f, 0.00182742f, 0.00302961f, 
    -0.05453064f, -0.25985506f, -0.18872838f, 0.06492635f, -0.06450789f, 0.25395694f, 0.09179475f, 0.07235970f, 
    0.05083079f, 0.00458027f, 0.01973980f, -0.01052926f, -0.07685386f, 0.03138166f, -0.11910815f, 0.00738773f, 
    0.01313407f, 0.04968356f, 0.02168382f, 0.07063612f, -0.00036024f, 0.09468935f, 0.05251446f, 0.15582490f, 
    0.14271182f, 0.24038470f, 0.05317498f, -0.04369315f, -0.02763899f, 0.18063657f, -0.15869029f, -0.06011205f, 
    -0.05480013f, -0.05379611f, -0.19100252f, 0.13187920f, -0.09651150f, -0.13396360f, -0.06905784f, -0.06511391f, 
    -0.05269929f, -0.07541627f, 0.00543702f, -0.05136004f, 0.00414016f, -0.01617030f, 0.21183987f, -0.02837570f, 
    -0.06764071f, 0.01842780f, -0.01350599f, -0.00394465f, 0.08238997f, -0.02089661f, -0.01610958f, 0.09225551f, 
    -0.12596653f, -0.04319367f, -0.05152054f, -0.14652406f, -0.10245463f, 0.00355568f, -0.10611904f, -0.23415916f, 
    0.01179371f, -0.00900587f, -0.11495908f, 0.00578663f, -0.05477575f, 0.03416786f, 0.00348826f, 0.15466547f, 
    -0.10045304f, -0.10530424f, 0.03740709f, -0.01626091f, -0.01892955f, 0.04965971f, -0.03992341f, -0.04026300f, 
    -0.06796606f, 0.09567819f, -0.13212299f, -0.04293435f, -0.21319428f, 0.20370805f, -0.21922168f, 0.14490013f, 
    0.06056378f, 0.03447025f, -0.00564066f, 0.06544454f, 0.18071894f, 0.02523302f, 0.00287642f, -0.01914603f, 
    -0.08893311f, -0.00258646f, -0.02242491f, -0.07354777f, -0.01857800f, -0.32643580f, -0.12680416f, -0.15075044f, 
    -0.14700653f, 0.02844181f, 0.06292344f, 0.04363074f, -0.10187606f, 0.00712509f, -0.00419976f, -0.07487358f, 
    0.02131115f, 0.03071324f, 0.00975820f, -0.03583768f, 0.02417665f, -0.07632443f, -0.02033447f, 0.00329261f, 
    -0.07999934f, 0.00248699f, -0.01168249f, -0.01904553f, -0.18288453f, -0.33625430f, 0.07103118f, 0.03623939f, 
    0.11042351f, -0.06927807f, -0.04706437f, 0.08285277f, 0.03324567f, -0.07107420f, -0.17365158f, 0.08088142f, 
    0.01017001f, -0.02147804f, -0.05022126f, -0.02301808f, 0.05797434f, 0.02204148f, 0.07241600f, 0.00758401f, 
    0.26395288f, -0.14647570f, 0.16421045f, -0.24596043f, -0.05352901f, -0.13117246f, -0.02651185f, 0.07165409f, 
    0.03441879f, -0.03462255f, -0.03728266f, -0.00673141f, -0.03613918f, 0.02818806f, 0.04207311f, 0.01509095f, 
    0.06206238f, 0.09982211f, -0.00990350f, -0.08401439f, -0.35300028f, -0.09990685f, 0.13428634f, 0.08273557f, 
    0.10543298f, 0.01869884f, -0.16010739f, 0.01559576f, 0.29449040f, 0.12460992f, -0.03689112f, -0.01709954f, 
    0.08890735f, -0.01572297f, 0.08349158f, -0.07520669f, 0.12916835f, -0.04531808f, 0.15683517f, 0.08627486f, 
    -0.26267818f, 0.11484969f, -0.26803645f, 0.17106980f, 0.10244741f, -0.02241112f, 0.00448128f, -0.08795527f, 
    -0.02184821f, -0.04065300f, -0.01028868f, -0.03482567f, 0.02083247f, 0.01400695f, 0.02152358f, 0.07362561f, 
    0.00279489f, -0.12892984f, 0.07190457f, 0.10545301f, -0.21830714f, -0.43704447f, 0.10243250f, -0.07075591f, 
    -0.02271853f, -0.10724714f, -0.01770459f, 0.12766281f, -0.09451474f, -0.01383459f, -0.08664522f, 0.02294393f, 
    -0.00536666f, 0.04167083f, 0.05944603f, -0.00714531f, 0.03284718f, 0.09989679f, 0.08288953f, 0.04463334f, 
    0.06951605f, -0.05276712f, 0.07811882f, 0.01284612f, -0.08531419f, 0.05465023f, 0.01779838f, -0.04194605f, 
    0.01108839f, 0.03444966f, -0.07020691f, 0.03249913f, -0.00221843f, 0.03346829f, 0.01777749f, -0.01670798f, 
    0.10435151f, 0.03902146f, 0.02469572f, 0.01330556f, -0.33882257f, 0.15885583f, 0.20273642f, 0.18720305f, 
    0.14298651f, -0.00283103f, 0.13127163f, -0.15124726f, 0.14344205f, -0.06749512f, -0.04092338f, 0.03771029f, 
    0.01228262f, 0.00085994f, 0.01879030f, -0.01987018f, -0.01705377f, 0.07020929f, -0.04016129f, -0.05295007f, 
    0.09744282f, -0.21905290f, 0.07630920f, -0.08080359f, -0.11627829f, -0.15381016f, -0.12216005f, 0.01305695f, 
    -0.03909552f, -0.13859206f, 0.01989285f, 0.00542454f, -0.00816671f, 0.04815550f, 0.05792482f, 0.05450831f, 
    -0.02930636f, -0.02862949f, -0.05929770f, -0.12809849f, -0.03427442f, -0.18744631f, -0.14377031f, -0.07864621f, 
    -0.24273024f, 0.04680507f, -0.13763867f, -0.09437326f, -0.01280279f, -0.02578366f, -0.04491957f, 0.05278781f, 
    -0.03144906f, 0.04055494f, -0.06494103f, 0.03333380f, 0.05303650f, 0.08965800f, 0.07381056f, -0.14627042f, 
    -0.38811547f, 0.13257457f, -0.12623361f, 0.13296671f, 0.03298551f, -0.05931617f, 0.00078979f, -0.00785736f, 
    0.27111354f, 0.00092837f, 0.01007364f, -0.00049691f, -0.00969426f, -0.07389612f, 0.14391297f, 0.02681261f, 
    -0.08315843f, -0.13484570f, 0.14478180f, -0.05824366f, -0.18294109f, 0.03118290f, 0.10827141f, -0.16071461f, 
    0.06755689f, -0.02493444f, -0.01700122f, 0.10952328f, 0.06947234f, 0.09359644f, -0.07334624f, -0.00740928f, 
    -0.06722374f, 0.13758865f, 0.02378490f, 0.07599659f, -0.06189695f, 0.04556514f, -0.04226889f, -0.00459018f, 
    -0.10093993f, 0.12632273f, -0.11950472f, 0.12645540f, 0.01561116f, 0.06576968f, -0.06521673f, 0.03986515f, 
    0.09015431f, 0.03639512f, 0.00507006f, -0.04758378f, 0.06112910f, 0.00611777f, 0.07707336f, 0.00931033f, 
    -0.04580511f, -0.04208398f, 0.14169328f, 0.01927418f, -0.36975750f, -0.03319978f, 0.04306310f, 0.11949600f, 
    0.08305506f, -0.00954789f, 0.01637363f, -0.04198851f, 0.01028413f, -0.03428182f, 0.05716285f, -0.04620609f, 
    0.06001316f, -0.01649549f, 0.02643356f, 0.07300133f, 0.01220662f, -0.01023415f, -0.00343328f, 0.08060745f, 
    0.03112167f, -0.07372040f, 0.06256970f, 0.04685955f, -0.08561076f, -0.00904425f, 0.09111264f, 0.05540601f, 
    0.03749213f, 0.02589974f, 0.00894144f, -0.09737734f, -0.01195968f, 0.01898457f, 0.02331811f, -0.03910858f, 
    0.01981764f, 0.13179936f, 0.08402108f, 0.09952249f, -0.16802771f, 0.00830702f, -0.09752111f, 0.03457743f, 
    0.02511892f, 0.02061144f, 0.04142031f, 0.13643487f, 0.03620744f, -0.05078346f, -0.08679097f, -0.03498603f, 
    0.05525761f, -0.02944920f, -0.03643848f, -0.00775254f, -0.10530866f, -0.06168649f, -0.07567633f, -0.17024261f, 
    0.15659867f, -0.12769066f, 0.17075968f, -0.11883386f, 0.01907401f, -0.03162897f, 0.07410906f, -0.04223814f, 
    0.04218430f, 0.04078943f, -0.06850887f, 0.05357252f, -0.03372082f, -0.03533503f, -0.01389257f, 0.01700257f, 
    0.15310304f, 0.00726429f, 0.14772704f, -0.04593096f, 0.22561081f, -0.30521640f, 0.34785154f, 0.19839925f, 
    -0.00763283f, -0.03214975f, -0.04825759f, 0.25912383f, 0.07403356f, -0.15014629f, 0.11930306f, -0.00527143f, 
    -0.12907450f, 0.06880736f, -0.02944305f, 0.02645739f, 0.09954516f, 0.17366824f, -0.10981635f, 0.14379846f, 
    0.19373697f, -0.06159265f, 0.10680071f, 0.09777481f, 0.07189100f, -0.11916324f, 0.10026696f, 0.04914106f, 
    -0.00561878f, -0.08887562f, -0.01946704f, 0.01677322f, 0.00619179f, -0.04296733f, 0.05230515f, 0.03730260f, 
    -0.19742027f, -0.11536610f, -0.11095482f, -0.27312228f, -0.00188230f, -0.24086091f, -0.10123518f, -0.29117623f, 
    -0.29085585f, -0.01519614f, -0.13655466f, -0.01220640f, 0.02288007f, -0.10170176f, -0.12325943f, 0.04124486f, 
    0.09069911f, -0.07813498f, 0.03794236f, 0.14610755f, -0.03077494f, 0.02978292f, 0.06849279f, 0.00791250f, 
    -0.12209737f, -0.11319270f, 0.01439215f, 0.17015919f, -0.10580140f, -0.13727333f, -0.17855553f, -0.13826443f, 
    0.10138848f, 0.13685098f, -0.23065324f, 0.02199838f, 0.11136310f, -0.04398527f, -0.06810421f, -0.20422079f, 
    0.20016275f, 0.00006086f, 0.03861947f, 0.17474511f, 0.25722989f, -0.03862049f, 0.19485947f, 0.11177378f, 
    0.13385299f, -0.00337395f, 0.12197671f, 0.09123875f, 0.05262658f, 0.03763558f, -0.04819003f, 0.06642162f, 
    -0.08243081f, -0.12906851f, -0.08277376f, 0.00274668f, -0.12538807f, 0.04344720f, 0.08422954f, 0.11820718f, 
    0.06595960f, 0.02459210f, 0.18044865f, 0.19282027f, -0.08960314f, -0.04031879f, -0.07208998f, -0.09318853f, 
    0.03657496f, 0.01981331f, -0.05517343f, 0.02969632f, 0.02627635f, 0.02713523f, 0.07906251f, 0.01792833f, 
    0.03617120f, 0.04890031f, -0.00069992f, 0.01652424f, -0.22406219f, -0.22618550f, -0.08242310f, -0.11707749f, 
    0.04714112f, -0.00677623f, -0.10346090f, 0.11429515f, -0.03749965f, -0.14147420f, -0.19295220f, 0.06449400f, 
    0.03862005f, 0.02489164f, 0.01302405f, 0.06038938f, -0.07882982f, 0.05230387f, -0.03044604f, -0.03601768f, 
    -0.28109178f, 0.06417259f, -0.43126595f, -0.01800010f, 0.08999272f, -0.06147951f, -0.07566558f, -0.03700713f, 
    -0.05698429f, 0.06204428f, -0.03415487f, 0.06585886f, 0.01945627f, 0.02679907f, 0.00547440f, 0.03712518f, 
    -0.02781848f, -0.18059501f, 0.03710623f, -0.01910427f, -0.22199427f, -0.37384614f, 0.24283601f, 0.15150315f, 
    0.05132810f, -0.16077220f, -0.17108016f, -0.07882860f, 0.33604684f, -0.14122798f, -0.16064127f, 0.02244957f, 
    0.04706821f, 0.01547853f, -0.00073834f, 0.12390020f, 0.00011330f, -0.02491687f, 0.31186673f, 0.05539349f, 
    0.00258544f, -0.28869048f, 0.04534533f, 0.10346705f, -0.00861122f, 0.02335251f, 0.05580371f, 0.16027275f, 
    0.13156438f, -0.10767297f, -0.00647566f, -0.02058303f, 0.07533529f, 0.08007125f, 0.16173999f, -0.09006263f, 
    -0.11728748f, 0.11156601f, -0.08790454f, 0.08942579f, -0.23194124f, -0.20236523f, 0.23990914f, 0.19775625f, 
    0.20012955f, -0.07047708f, 0.25526106f, -0.12724516f, -0.01273322f, -0.27072012f, -0.07638367f, -0.01895860f, 
    0.01535679f, 0.09256027f, 0.11974607f, 0.00478516f, 0.17758092f, -0.02298633f, 0.07061563f, 0.11545742f, 
    -0.31981215f, 0.13020928f, 0.04465365f, 0.10839646f, -0.11759500f, 0.15947159f, -0.06784254f, -0.01956570f, 
    0.08803386f, 0.00257125f, -0.18865186f, 0.03023497f, 0.19202887f, -0.09967346f, 0.01012426f, -0.05815084f, 
    -0.08644657f, -0.11815059f, -0.04769636f, 0.09346970f, -0.04094740f, -0.24237786f, 0.06063668f, -0.02640709f, 
    0.05345375f, -0.13941626f, -0.04811057f, 0.03242607f, -0.03125650f, -0.14245699f, -0.06539273f, 0.04577074f, 
    -0.03697817f, -0.03078969f, -0.00983747f, 0.05535653f, -0.09855328f, -0.05245905f, 0.00519762f, -0.06459202f, 
    -0.19104129f, 0.06752197f, -0.44985163f, 0.09269709f, -0.01172432f, 0.08567899f, 0.00783179f, 0.05371255f, 
    -0.14050804f, -0.06903891f, -0.01569787f, 0.06314492f, 0.04465611f, -0.09117814f, -0.00114870f, -0.04802862f, 
    -0.01516418f, -0.13814360f, 0.01531185f, -0.09081253f, -0.05527726f, 0.01696329f, -0.15550366f, 0.21862422f, 
    0.12521125f, -0.01067310f, -0.01714691f, 0.05746844f, 0.11574174f, 0.01749511f, 0.01961292f, -0.10904115f, 
    0.07219636f, 0.06216856f, 0.02035782f, 0.09649269f, 0.00958552f, -0.13140981f, 0.15733269f, 0.16417783f, 
    -0.06184799f, 0.00529910f, -0.35179564f, 0.06306008f, 0.00469714f, -0.01735489f, 0.04282930f, 0.09697869f, 
    -0.13886231f, -0.04179452f, 0.01524087f, 0.04558970f, -0.03490478f, 0.06510133f, -0.02834732f, 0.00998586f, 
    -0.13660693f, -0.11174680f, -0.32832676f, -0.16492203f, -0.14434052f, -0.11550059f, -0.01988930f, 0.07081511f, 
    0.02013263f, -0.01982066f, 0.00974672f, 0.10534006f, -0.09367838f, 0.05508782f, -0.04405495f, -0.00958296f, 
    -0.04270675f, 0.04355941f, 0.06917706f, -0.01964588f, 0.00366525f, 0.09475115f, 0.07641253f, 0.17496650f, 
    -0.32709467f, 0.07870504f, -0.26773190f, -0.00598364f, 0.11782474f, -0.09861904f, 0.00047198f, -0.09474577f, 
    0.00947843f, 0.01785769f, -0.04304268f, 0.07167925f, -0.00465928f, 0.05268108f, -0.03567398f, 0.06020157f, 
    0.02232146f, -0.10642699f, 0.07172432f, -0.03824404f, -0.08760610f, -0.10019383f, -0.26755399f, -0.04025074f, 
    0.06601965f, -0.04972438f, -0.03511933f, 0.12399179f, -0.11249882f, -0.12984221f, 0.02765776f, 0.09539510f, 
    -0.01234085f, 0.03207458f, -0.03409017f, 0.12013609f, -0.16216862f, -0.08076704f, -0.15710860f, -0.16895320f, 
    -0.40063953f, -0.09218640f, -0.01437150f, -0.06256343f, 0.03328987f, 0.14628977f, -0.17477597f, 0.10703415f, 
    -0.04703663f, -0.03294435f, -0.05203617f, 0.15235817f, 0.12073709f, 0.00517019f, 0.01190965f, 0.12112077f, 
    0.02715409f, 0.03281417f, 0.00282825f, 0.11711574f, -0.04111210f, 0.02773692f, -0.13684706f, 0.11808408f, 
    0.08654997f, -0.02180071f, -0.03863385f, 0.03684888f, -0.02180547f, 0.09377763f, -0.07539128f, 0.00548800f, 
    -0.14592569f, -0.03066657f, 0.06989791f, -0.01700910f, -0.14194979f, -0.02345836f, -0.00369547f, 0.07451929f, 
    -0.18328285f, 0.04077499f, -0.67577064f, 0.06495246f, -0.03080884f, -0.00251397f, -0.06301358f, 0.08255289f, 
    -0.08850490f, -0.07165023f, 0.04087175f, 0.07206067f, -0.06061960f, 0.04104900f, 0.00817187f, 0.01127957f, 
    -0.05371169f, -0.09102396f, -0.08850259f, -0.21322316f, -0.27769989f, 0.04781224f, -0.13856702f, 0.06400060f, 
    0.02149006f, 0.04118464f, 0.00102979f, -0.02819438f, 0.14223270f, 0.09259237f, -0.05074021f, -0.03871904f, 
    0.04854241f, -0.00297153f, -0.02300013f, -0.00905788f, 0.06197112f, -0.09378087f, 0.12612410f, 0.15197825f, 
    -0.18990993f, 0.17616718f, -0.01591279f, 0.06235097f, -0.03287303f, -0.01611982f, -0.02786884f, -0.10934098f, 
    0.15103427f, 0.12198578f, -0.12350237f, -0.02521478f, 0.00971976f, -0.03185778f, 0.01556297f, -0.11402093f, 
    0.09640625f, -0.03579213f, 0.10280655f, 0.06847538f, -0.09019787f, 0.18515910f, -0.00123896f, 0.05000489f, 
    -0.00894647f, 0.08245265f, -0.04181900f, -0.00843239f, -0.02015670f, 0.10697372f, -0.05292571f, -0.00569848f, 
    -0.03672344f, 0.00147033f, -0.04440000f, -0.05771476f, -0.03503995f, -0.04625586f, 0.05003754f, -0.10715680f, 
    0.11623556f, -0.10638187f, 0.03296428f, 0.06823114f, -0.13055101f, -0.00054163f, -0.00449358f, 0.03541045f, 
    -0.08112927f, -0.07814629f, 0.11142977f, 0.05682617f, -0.13618584f, 0.06628456f, -0.08977445f, -0.05509782f, 
    -0.16745269f, 0.09122050f, -0.25527865f, -0.09283970f, -0.20560335f, -0.02526342f, -0.03040950f, -0.00394069f, 
    0.01858707f, 0.00494524f, 0.03647089f, 0.00585109f, -0.04677688f, 0.07703549f, 0.00010389f, 0.00009543f, 
    0.03297768f, -0.02479894f, -0.02161604f, 0.03101594f, 0.10992221f, 0.04437886f, 0.08570331f, 0.19858511f, 
    -0.01675797f, 0.09449156f, 0.04975856f, 0.07437513f, 0.21067947f, -0.05070611f, 0.02510969f, -0.01266047f, 
    -0.02133988f, 0.10452788f, -0.09902539f, 0.07634321f, 0.00269507f, -0.10079785f, -0.02317923f, 0.08169547f, 
    -0.01171925f, -0.13195005f, 0.05569533f, 0.02013864f, 0.26540157f, -0.14227144f, 0.23416111f, -0.00081295f, 
    -0.17765787f, 0.09586661f, -0.11585843f, 0.00248968f, 0.00304852f, -0.02191221f, 0.00120876f, 0.05694558f, 
    0.04192046f, -0.01516943f, 0.01489981f, -0.02930210f, -0.00530620f, 0.01304704f, 0.01889367f, -0.07401701f, 
    -0.09501717f, 0.20686060f, -0.15640198f, 0.10418600f, 0.11091306f, 0.01620386f, 0.00964862f, -0.00762245f, 
    0.14068608f, 0.14515603f, -0.09918657f, -0.11114533f, 0.06251634f, 0.02188588f, -0.00729539f, -0.02747723f, 
    0.00344937f, -0.14530309f, 0.13746005f, 0.08370402f, -0.20673782f, 0.05282663f, -0.43526801f, 0.03432990f, 
    0.03937145f, -0.04529535f, -0.05672125f, 0.02035773f, -0.05121200f, 0.05829191f, -0.03423410f, 0.10248155f, 
    -0.00282388f, -0.06873637f, -0.03394797f, 0.01384696f, -0.02222429f, -0.03428942f, -0.03925839f, -0.06714910f, 
    0.04424286f, -0.07814775f, 0.02843191f, 0.10338511f, -0.11668768f, 0.03627597f, -0.07047369f, 0.08597060f, 
    -0.01511347f, -0.01848330f, 0.01050484f, 0.03606210f, -0.00949088f, -0.04089945f, 0.00684114f, 0.05584075f, 
    0.09890030f, 0.04860570f, 0.14804293f, -0.07683084f, 0.04415809f, -0.22936806f, 0.09572803f, -0.16545539f, 
    0.05548064f, 0.11060516f, 0.06832052f, 0.06363452f, 0.07505697f, -0.05234477f, 0.12964834f, -0.01882638f, 
    0.09433094f, -0.03327110f, -0.00744693f, 0.02608765f, 0.07767554f, -0.13516210f, 0.02064455f, -0.04650608f, 
    -0.01174545f, -0.29107398f, -0.06446473f, -0.10041330f, 0.06918499f, -0.06815778f, -0.23002909f, 0.06669844f, 
    -0.05729097f, -0.03812917f, 0.02374583f, 0.05076275f, 0.01705976f, 0.00442287f, -0.01043679f, 0.04985453f, 
    -0.00129436f, -0.01528965f, -0.03062571f, 0.02018571f, 0.01520777f, -0.02469159f, 0.02145279f, -0.06156476f, 
    0.12115772f, 0.04287883f, 0.10145570f, -0.02112202f, 0.04184238f, -0.09216560f, -0.04517595f, 0.02280327f, 
    0.08243905f, 0.01310238f, 0.08353181f, -0.00363731f, 0.00054618f, -0.05041740f, -0.08932844f, 0.00369490f, 
    -0.28051373f, 0.13269986f, 0.04168431f, 0.34465781f, -0.11291148f, -0.00307558f, -0.03948154f, 0.04650241f, 
    0.06495955f, -0.14254390f, -0.01767148f, -0.03482886f, -0.00928735f, -0.09524486f, 0.01105292f, 0.08911411f, 
    -0.07692736f, -0.05237914f, 0.04812277f, -0.01751632f, 0.19155362f, 0.10282932f, 0.13678278f, 0.11863050f, 
    -0.01213819f, -0.10819225f, 0.05179622f, -0.09857446f, 0.00414463f, 0.07331758f, -0.07258616f, 0.00843828f, 
    0.02973811f, -0.01769460f, 0.00867231f, 0.05816547f, -0.00738685f, -0.12716684f, 0.01861289f, 0.03669048f, 
    -0.45959932f, -0.14874427f, -0.17463279f, 0.45013887f, -0.03329367f, -0.01015349f, -0.14790224f, -0.05012151f, 
    0.10676782f, -0.08269595f, 0.00825434f, 0.01121783f, -0.04720832f, 0.02624802f, 0.05753490f, 0.00574759f, 
    0.00105044f, 0.20698263f, 0.21396334f, -0.06670124f, 0.27515426f, -0.17908986f, 0.14389694f, -0.11728714f, 
    -0.02638599f, -0.01123979f, 0.00411096f, -0.08226459f, 0.00154474f, -0.07494131f, -0.01907421f, -0.00756553f, 
    0.01449104f, -0.08452726f, -0.02562454f, 0.05230446f, 0.06084370f, 0.02814789f, 0.00886520f, -0.07163290f, 
    -0.56923258f, 0.11091756f, -0.40073574f, -0.00397396f, -0.46384540f, 0.15972853f, 0.12729931f, 0.04241688f, 
    -0.11318783f, 0.08348184f, -0.12026427f, -0.17916431f, 0.14564277f, 0.10587263f, 0.02281322f, 0.00014252f, 
    0.01230749f, -0.06312317f, 0.02906513f, 0.12866396f, -0.26600713f, -0.08787171f, -0.10889885f, 0.04817029f, 
    -0.17080903f, 0.01356412f, 0.01129187f, -0.00809332f, -0.01365235f, 0.00527690f, -0.04756911f, -0.04070855f, 
    0.06967433f, -0.06210485f, -0.07059411f, -0.00861377f, -0.06500299f, -0.04591397f, -0.04877442f, -0.02543067f, 
    0.20399529f, -0.13870218f, -0.03436518f, 0.13147295f, -0.12256437f, -0.02392718f, -0.06647097f, -0.08807213f, 
    0.00565073f, -0.02423802f, -0.12191007f, -0.05040412f, -0.01904936f, -0.04614092f, -0.07541702f, 0.05636543f, 
    0.06017131f, 0.08120870f, -0.00773794f, -0.11617672f, -0.31388751f, -0.02773696f, -0.21504623f, 0.31458136f, 
    0.01231696f, -0.05911210f, 0.03026816f, -0.01930498f, 0.06676582f, 0.01969940f, -0.03114688f, -0.13192420f, 
    -0.11715989f, -0.07653765f, -0.01530840f, 0.02560896f, -0.09638406f, -0.06338684f, -0.08344944f, -0.05182506f, 
    -0.74430043f, 0.02355436f, -0.46521491f, 0.21062241f, -0.49066332f, 0.07578476f, 0.08083061f, 0.08851546f, 
    -0.18820819f, 0.10456489f, -0.07914636f, -0.08727162f, -0.01502094f, 0.11735445f, -0.03953888f, 0.03710655f, 
    -0.00827822f, 0.05905203f, 0.03823273f, -0.00173067f, -0.22982866f, -0.06349983f, -0.32924637f, 0.08134191f, 
    0.19234452f, 0.11825131f, 0.04683959f, 0.12264595f, -0.10643563f, -0.07948441f, 0.01449441f, -0.13276388f, 
    -0.01297767f, 0.16057087f, 0.08964207f, 0.01734553f, -0.01444937f, 0.08730953f, -0.00373456f, 0.02312920f, 
    0.26952723f, -0.35738164f, 0.31012303f, 0.01825307f, 0.08186997f, -0.05524442f, -0.08716451f, -0.13319126f, 
    0.10953943f, -0.00193514f, 0.05781597f, -0.01505600f, 0.00875353f, -0.00263247f, 0.01543989f, -0.00814357f, 
    0.10609484f, -0.02079326f, 0.21884331f, -0.05614054f, -0.60129702f, -0.29585445f, -0.09486589f, 0.12743831f, 
    0.06035295f, 0.01470060f, -0.03833731f, -0.00734917f, 0.05481737f, -0.07975435f, -0.08475087f, 0.04051312f, 
    0.02660013f, -0.00795114f, -0.00325891f, 0.16649817f, 0.01354775f, 0.20106599f, 0.11912585f, 0.05143920f, 
    -0.09472165f, 0.06905015f, -0.17743416f, 0.14339556f, -0.10711253f, 0.05091130f, 0.10677696f, -0.05106785f, 
    0.13115548f, 0.00752191f, -0.01418586f, 0.00933487f, 0.02683572f, 0.06773243f, -0.05068896f, 0.01770047f, 
    -0.06125322f, 0.09501299f, 0.00808036f, 0.05168271f, 0.35142589f, 0.12591477f, 0.27679616f, 0.03268302f, 
    -0.04453009f, 0.03926766f, 0.05904854f, -0.04061957f, 0.05385175f, -0.09919970f, -0.12891039f, 0.07938936f, 
    0.02864298f, 0.00523826f, -0.04502465f, -0.04519748f, -0.04889700f, 0.02443139f, 0.02852383f, 0.04587357f, 
    -0.02939803f, -0.09036257f, 0.18795247f, -0.19744909f, 0.27878183f, 0.15724018f, 0.20290467f, 0.05880973f, 
    0.03141370f, 0.05822152f, -0.05651383f, 0.04702816f, -0.02994261f, 0.02625637f, 0.03840654f, 0.04793479f, 
    0.10401829f, 0.02373014f, -0.07044005f, 0.01691042f, -0.24047174f, 0.09945541f, 0.11316405f, 0.24116549f, 
    -0.14135760f, 0.08651613f, -0.16920131f, 0.20722075f, -0.13944690f, -0.02972516f, -0.01449290f, 0.01397228f, 
    0.01860869f, 0.05789518f, 0.05968839f, 0.16564818f, -0.17811249f, -0.06625011f, 0.02325614f, -0.15426674f, 
    -0.05272884f, -0.28375232f, -0.19159566f, 0.21044996f, -0.33156854f, -0.13505073f, -0.18280886f, -0.06386209f, 
    -0.03529229f, 0.04604910f, -0.00277334f, 0.02620590f, -0.01647574f, -0.12028696f, -0.07948966f, -0.00075518f, 
    -0.03397488f, -0.00565378f, -0.04733077f, -0.09231949f, 0.38564220f, 0.12371661f, 0.34787270f, -0.18022166f, 
    -0.02449177f, 0.09583059f, 0.06589253f, -0.10787564f, 0.10206146f, -0.01876786f, -0.05295633f, 0.07308389f, 
    0.02058890f, 0.05746978f, -0.05715171f, -0.07790110f, 0.02321141f, -0.10001446f, -0.15211827f, 0.05152350f, 
    -0.07972021f, 0.03703436f, -0.01276954f, 0.02058839f, 0.01003321f, 0.04158792f, 0.06922345f, 0.03924268f, 
    -0.00398045f, 0.03860793f, -0.04445510f, -0.01033680f, -0.05636745f, 0.03884942f, -0.01275773f, -0.02301031f, 
    -0.03776976f, 0.02945020f, 0.05513696f, -0.17738999f, -0.13332769f, -0.00464759f, -0.29614630f, 0.20467193f, 
    -0.07352833f, -0.08981960f, -0.16585548f, -0.07783028f, 0.04475076f, -0.03216458f, -0.06355209f, 0.04053147f, 
    -0.02164452f, 0.01769496f, 0.02342056f, 0.09034220f, -0.03441681f, 0.12485280f, 0.12508555f, 0.12877563f, 
    0.10332158f, -0.07964453f, -0.00477397f, -0.12301926f, -0.00221866f, -0.00933084f, 0.04217009f, -0.01522237f, 
    -0.02711608f, 0.00937133f, -0.05591842f, 0.04257927f, -0.01067680f, -0.01627417f, -0.01165037f, 0.01621373f, 
    0.07612710f, 0.07301806f, -0.03646346f, -0.00633108f, -0.01420407f, -0.09913166f, -0.11121616f, -0.02573082f, 
    0.08549918f, -0.01948264f, 0.15205045f, -0.02835993f, 0.05005499f, 0.01011243f, -0.13811065f, 0.07800242f, 
    0.01823002f, 0.00935817f, -0.04453490f, -0.03123456f, 0.01303775f, -0.04609748f, -0.10760748f, -0.09004723f, 
    -0.15241145f, -0.27103907f, 0.05015725f, 0.20012984f, -0.28157246f, 0.04023001f, 0.03273318f, -0.10671125f, 
    0.05848515f, -0.22385609f, -0.09082804f, -0.01746885f, 0.03036311f, 0.03064456f, 0.07259405f, 0.15279435f, 
    0.00090597f, 0.05939751f, 0.02872458f, -0.01934054f, 0.20197633f, -0.35604075f, 0.21759628f, 0.15614410f, 
    0.17238274f, 0.01501834f, 0.02694397f, 0.08672035f, 0.04145757f, -0.09082474f, 0.03578925f, -0.06182978f, 
    0.02990274f, 0.05391970f, -0.02047940f, 0.04878278f, 0.03271222f, 0.09223381f, -0.04332139f, -0.07681967f, 
    -0.33763108f, 0.02527237f, -0.06694210f, 0.14817303f, -0.12866366f, -0.03615249f, 0.10896807f, -0.08580214f, 
    0.13430063f, 0.00859961f, -0.16502382f, -0.02897071f, -0.01372117f, -0.08931396f, -0.05032226f, 0.02577561f, 
    0.00852003f, -0.00423955f, -0.11180247f, 0.07369701f, 0.12206735f, -0.04388213f, -0.39198527f, 0.02709648f, 
    -0.04112344f, -0.04328189f, 0.01410199f, -0.02925253f, 0.01596542f, -0.06268381f, 0.03129197f, 0.06690685f, 
    -0.00816532f, -0.08470044f, 0.00476511f, 0.01064765f, -0.04607234f, 0.04992753f, 0.06447826f, -0.03151994f, 
    0.06468138f, -0.09474925f, 0.02723076f, 0.15832874f, 0.13777915f, -0.03496217f, 0.12746342f, -0.07136831f, 
    0.08216644f, 0.03973849f, -0.01767031f, 0.05707038f, -0.03411895f, 0.02825876f, 0.09540784f, -0.09181293f, 
    -0.01008664f, 0.00033034f, -0.03972661f, -0.09822451f, 0.02602954f, -0.41169727f, -0.30129647f, -0.03960876f, 
    0.06002771f, -0.05448452f, 0.07768937f, 0.10065367f, -0.06629556f, -0.00754886f, 0.03020741f, -0.01334974f, 
    0.06294157f, 0.06277330f, 0.00047999f, -0.02016299f, 0.02841587f, 0.09756768f, 0.03724305f, 0.01313221f, 
    0.10572576f, -0.09513368f, 0.18578781f, -0.13666558f, 0.14641790f, 0.11941787f, 0.16856852f, -0.11454681f, 
    0.03632521f, 0.00148073f, 0.04130974f, 0.07708041f, 0.11641378f, 0.01283463f, 0.06617990f, -0.04106667f, 
    0.05366679f, -0.03951199f, -0.21191935f, -0.00110604f, -0.43894991f, 0.11678889f, -0.37356871f, 0.34188789f, 
    0.36905935f, -0.04505036f, 0.18395391f, -0.14274187f, 0.07098337f, 0.33323392f, 0.00269938f, 0.14554836f, 
    0.02987230f, -0.13519050f, -0.10676922f, 0.16017596f, -0.04358860f, 0.04861747f, 0.04824188f, 0.08492299f, 
    -0.01135281f, -0.51801598f, 0.10532805f, -0.32963291f, 0.30179003f, 0.07710075f, 0.05335353f, 0.15774897f, 
    0.04266833f, -0.01333663f, 0.01086859f, 0.04752738f, -0.00790072f, 0.07701704f, 0.10673524f, 0.08228266f, 
    0.15431631f, 0.01190542f, -0.07264456f, 0.06485382f, 0.10635599f, -0.04584152f, 0.01734029f, 0.02225656f, 
    -0.15354262f, -0.03245650f, -0.01899040f, 0.02279002f, 0.08150670f, -0.03315223f, -0.10277200f, -0.08978041f, 
    0.04389971f, -0.09200203f, -0.08284504f, 0.09519692f, 0.04290714f, 0.04758452f, -0.09873941f, -0.02234541f, 
    -0.12367924f, 0.12371577f, -0.20183082f, 0.23405063f, -0.01812308f, -0.08991530f, 0.02824392f, 0.07368623f, 
    0.13018233f, 0.05853507f, -0.17123795f, -0.04966392f, -0.07001450f, 0.03858019f, -0.09120897f, 0.01831307f, 
    0.07394014f, 0.12127553f, -0.04213713f, -0.07231314f, -0.11908001f, -0.26500031f, 0.24025719f, -0.19593337f, 
    -0.11726342f, 0.01198658f, -0.09148527f, -0.16790569f, 0.09857518f, 0.05315131f, -0.09641452f, 0.00157176f, 
    -0.08413190f, -0.07838809f, 0.00059514f, -0.09259857f, -0.02514318f, -0.02101521f, 0.11177382f, -0.05193680f, 
    0.03391485f, 0.00944408f, -0.03618135f, 0.08447782f, -0.00053815f, 0.01231286f, 0.07660053f, -0.02607936f, 
    0.02136959f, 0.00842366f, -0.11918197f, 0.00666191f, -0.02406940f, -0.04802984f, -0.04960146f, 0.04622518f, 
    -0.04073049f, -0.00311564f, 0.01400240f, 0.03531200f, 0.52899921f, -0.10072601f, 0.37696743f, 0.07302891f, 
    -0.08373347f, -0.00461043f, 0.03259176f, -0.21101248f, 0.13269532f, -0.07453212f, -0.10677502f, 0.01853143f, 
    0.00212082f, 0.01903359f, -0.08187121f, -0.00306681f, 0.04060604f, 0.04308140f, -0.02065391f, 0.08918165f, 
    0.07030468f, -0.19278844f, -0.10134546f, 0.02602473f, -0.09496721f, -0.00854334f, -0.19397222f, -0.03181191f, 
    -0.19078439f, -0.01096165f, 0.02041421f, 0.05290475f, -0.01938516f, -0.05153177f, -0.03953400f, -0.00644803f, 
    -0.04337883f, 0.01198903f, -0.00879411f, -0.01095110f, 0.35165519f, 0.00899659f, 0.46229896f, -0.13310196f, 
    0.03813659f, 0.08970322f, -0.02310533f, 0.03569808f, 0.09423859f, -0.15508750f, -0.00862624f, -0.05305265f, 
    -0.00551217f, -0.04710379f, -0.01115824f, 0.05333301f, -0.01690378f, -0.07024035f, 0.13096353f, -0.12959160f, 
    0.21944247f, -0.27205944f, 0.00774902f, 0.23814577f, 0.13989367f, -0.08831411f, 0.25312695f, -0.11112531f, 
    0.22488952f, -0.11099231f, -0.19010420f, 0.01098507f, 0.04182276f, 0.09710701f, 0.20194629f, -0.07677960f, 
    -0.08339817f, 0.03919242f, 0.07159638f, -0.01935782f, 0.50087768f, -0.03266338f, 0.29715523f, 0.28100368f, 
    0.26624939f, 0.04245582f, 0.32957920f, -0.07818299f, 0.13608196f, -0.21674672f, -0.16365667f, -0.09558876f, 
    -0.01032423f, -0.08631491f, -0.03485383f, -0.01134298f, 0.06028221f, -0.07361376f, 0.05001667f, 0.15405767f, 
    -0.19914912f, -0.07702480f, -0.09436740f, 0.42183858f, -0.21330976f, 0.01816644f, 0.02803198f, 0.00961699f, 
    0.08597668f, -0.05008564f, -0.12425826f, -0.21577382f, -0.06191679f, 0.05863917f, -0.05749920f, 0.05431987f, 
    -0.00588381f, 0.19432199f, -0.03410562f, 0.00417998f, 0.29423904f, 0.08136519f, 0.20390141f, 0.03443868f, 
    -0.10888612f, 0.04074790f, -0.03954743f, -0.05454858f, 0.00041313f, -0.03221357f, -0.09290724f, 0.01289971f, 
    -0.00976453f, -0.04090035f, -0.04976736f, -0.02857415f, 0.04171151f, 0.05136017f, 0.04247824f, 0.10548306f, 
    -0.15656988f, -0.23680715f, -0.22291853f, 0.08910429f, -0.22623233f, -0.00308657f, 0.12059657f, 0.09998615f, 
    -0.14447534f, -0.02138331f, -0.03568549f, -0.05916998f, 0.11100670f, 0.14738445f, 0.03271552f, 0.07536672f, 
    0.04140536f, 0.09917272f, 0.03748620f, 0.04962832f, -0.07209636f, -0.28359753f, 0.08368301f, 0.17076991f, 
    0.04168992f, -0.15485600f, -0.15426040f, 0.04690816f, -0.07826781f, 0.01931932f, 0.01478873f, -0.03719863f, 
    -0.07379703f, -0.06655385f, -0.03308245f, -0.03003241f, 0.02007128f, 0.09571064f, -0.10470884f, -0.28045854f, 
    -0.05316781f, -0.45344004f, -0.11204285f, -0.06414235f, 0.09077395f, -0.07999325f, -0.12074307f, -0.00807556f, 
    0.01837581f, -0.10911698f, -0.02928195f, 0.00393168f, 0.07045277f, -0.03296005f, -0.04532656f, 0.09317103f, 
    -0.05409943f, -0.00891083f, 0.15146504f, 0.02282816f, 0.11263268f, 0.10742253f, 0.06142284f, 0.01410468f, 
    -0.08447888f, 0.01430256f, 0.00400138f, 0.03932063f, -0.08996739f, -0.06435387f, -0.03007770f, 0.04152179f, 
    -0.07341458f, 0.03348282f, -0.07582028f, -0.00149583f, -0.02968786f, -0.05082252f, -0.09633547f, -0.04385044f, 
    -0.01007104f, -0.29900786f, -0.16109434f, -0.04474018f, 0.02922762f, 0.08383065f, -0.26792145f, 0.03801430f, 
    -0.23210241f, -0.13719428f, -0.01865794f, 0.03244262f, -0.01021367f, -0.03570601f, -0.03199031f, -0.02962678f, 
    -0.04938798f, -0.01717575f, -0.08126240f, -0.06319786f, 0.42182449f, -0.19242613f, 0.19635352f, -0.08997933f, 
    0.14831625f, -0.09772229f, -0.22594550f, -0.18109068f, 0.04932380f, -0.21278767f, -0.01684496f, 0.02700043f, 
    0.00681657f, -0.00495034f, -0.03818568f, 0.01560407f, -0.04687269f, -0.10674656f, 0.13628529f, 0.02749840f, 
    -0.03941843f, -0.15320566f, -0.06999894f, 0.21376392f, 0.09198469f, -0.17973359f, -0.25641868f, 0.02460769f, 
    -0.08358991f, -0.21539439f, -0.02612799f, 0.01784625f, -0.00716245f, 0.01005113f, 0.07927985f, 0.01143350f, 
    -0.06978654f, 0.05637640f, 0.02247872f, -0.00395609f, -0.23292932f, 0.09125454f, 0.04680537f, 0.18311784f, 
    -0.21815619f, 0.01310921f, -0.09634964f, 0.12579541f, -0.19294083f, 0.03823667f, 0.04033650f, 0.01178621f, 
    0.08215311f, 0.09363741f, 0.01184610f, 0.06300555f, -0.02476793f, 0.14022557f, 0.01966131f, -0.07396554f, 
    -0.04473277f, -0.26568487f, -0.44088635f, -0.26753584f, -0.03100012f, -0.13630959f, -0.17570736f, 0.04756900f, 
    0.05949060f, -0.02880187f, -0.00342423f, 0.05199400f, 0.00574654f, -0.07232345f, -0.04856776f, 0.10783360f, 
    -0.06223946f, 0.01798506f, 0.07828292f, 0.03410280f, -0.05211402f, 0.02645370f, 0.00018303f, 0.25099194f, 
    -0.07891400f, -0.08483958f, -0.04291971f, -0.00976443f, 0.05048344f, -0.03351508f, -0.05848707f, -0.00578326f, 
    -0.07877900f, 0.01289851f, 0.01727693f, 0.03414156f, -0.05614613f, 0.05971669f, -0.02910059f, -0.20347798f, 
    -0.21178579f, 0.02944950f, -0.05537276f, 0.12498178f, -0.08723573f, -0.02954360f, 0.05470094f, 0.05184251f, 
    0.12240101f, -0.00597738f, -0.05296273f, -0.07881431f, -0.09144749f, -0.00607967f, -0.01388598f, 0.06439736f, 
    0.03711113f, 0.06332897f, -0.00759677f, -0.05664892f, -0.53260899f, 0.04417618f, -0.28228366f, 0.23323607f, 
    0.00968100f, 0.00403161f, 0.10731869f, -0.02138528f, 0.09289198f, 0.03609429f, -0.06597681f, -0.09037710f, 
    -0.10053376f, 0.03541999f, 0.02002388f, 0.04954975f, -0.01783675f, 0.02585149f, -0.11434174f, 0.10084210f, 
    -0.12969297f, 0.00795925f, -0.11218327f, 0.03389572f, -0.02535093f, -0.00160625f, 0.17067842f, -0.08284215f, 
    -0.02120546f, -0.06159620f, -0.24826172f, -0.00682834f, 0.08416343f, 0.10837023f, 0.02695056f, 0.03441619f, 
    -0.05338517f, 0.03151641f, 0.04325923f, 0.14519846f, -0.07465064f, -0.00681861f, -0.12071745f, 0.14472832f, 
    0.02033458f, -0.08162157f, -0.03971459f, 0.08010535f, -0.05356769f, -0.03753505f, 0.03898604f, 0.03363356f, 
    -0.09559111f, -0.07228903f, -0.02750842f, -0.03133061f, -0.12414408f, -0.06732351f, -0.19977163f, -0.23457330f, 
    0.08467921f, -0.08660778f, 0.09131140f, 0.07545797f, -0.12589613f, 0.05087557f, -0.11998029f, -0.00578869f, 
    -0.00864182f, -0.00466896f, 0.02405568f, -0.12460845f, 0.02345959f, -0.01067834f, 0.00089257f, 0.03718932f, 
    0.04395404f, -0.06157200f, 0.05032949f, -0.05598027f, -0.28899509f, -0.05092811f, -0.20138592f, -0.06620767f, 
    0.10422683f, -0.00864857f, 0.09161229f, 0.04564914f, -0.06262302f, 0.12599273f, -0.06716429f, 0.09767341f, 
    -0.00488548f, 0.07479139f, 0.06758259f, 0.04057558f, 0.01699494f, 0.06128861f, 0.02061981f, -0.07445213f, 
    -0.31572565f, -0.10833615f, -0.11380021f, 0.23187704f, -0.03737943f, -0.09058061f, 0.02981889f, 0.04085374f, 
    0.15046695f, -0.00804605f, -0.04716436f, -0.04368949f, -0.08643755f, -0.06448311f, 0.03707623f, 0.00016442f, 
    0.07164239f, 0.06535758f, -0.05701306f, -0.05830635f, -0.03029964f, -0.11683412f, -0.08968344f, -0.13950965f, 
    -0.17972410f, -0.03537805f, -0.03584344f, 0.05135632f, -0.04661879f, 0.00357170f, 0.00728697f, 0.03765720f, 
    0.08417584f, 0.03341931f, -0.01055970f, 0.02440597f, 0.04906366f, 0.01567466f, 0.01800527f, 0.07208180f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.13070373f, 0.08785956f, 0.04076174f, -0.03699401f, -0.05438847f, 0.00753140f, 0.00614901f, -0.06289016f, 
    0.03567958f, 0.00973899f, -0.00298291f, 0.00624215f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 5120);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
