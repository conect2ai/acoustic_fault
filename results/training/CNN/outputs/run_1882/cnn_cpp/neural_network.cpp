#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.29459006f, -0.41047511f, -0.59656954f, 0.01727051f, -0.26150435f, -0.30752221f, -0.25605461f, -0.30715084f, 
    -0.07823480f, -0.10953756f, 0.31199756f, 0.07895454f, -0.72584665f, -0.77508086f, -0.27990043f, -0.03056029f, 
    -0.21386279f, -0.38102829f, 0.36754870f, 0.11885897f, 0.66719639f, -0.25891885f, -0.55569446f, -0.48833883f, 
    0.53012156f, -0.07535800f, -0.07542764f, 0.10173883f, -0.42655891f, -0.31740800f, 0.47845969f, -0.08311421f, 
    0.12566511f, 0.12765212f, 0.75573099f, -0.75048530f, 0.51079243f, -0.33562315f, 0.22740267f, 0.52492732f, 
    -0.45890474f, -0.06599895f, 0.24250692f, 0.24601772f, 0.04862220f, -0.61484343f, 0.02968108f, -0.08823734f, 
    -0.42979905f, -0.47896340f, 0.55564904f, -0.04486780f, -0.16702503f, -0.10519016f, 0.12885073f, 0.34030411f, 
    0.02705132f, 0.43681571f, -0.73717237f, -0.59536457f, -0.29027301f, 0.30043393f, 0.25285617f, 0.82697278f, 
    -0.26171693f, -0.08931113f, -0.20698066f, 0.31275213f, -0.35478121f, 0.18706138f, 0.42348301f, -0.22307430f, 
    -0.78115731f, 0.12082127f, 0.65895432f, 0.06112979f, -0.03461625f, 0.01287695f, -0.26071832f, 0.29810584f, 
    -0.18933527f, 0.24371831f, 0.10601550f, 0.12101145f, 0.38329536f, 0.32361031f, 0.18577746f, 0.33320114f, 
    -0.15784495f, -0.32596308f, -0.41612890f, -0.38827500f, -0.62811249f, -0.07412215f, 0.81650591f, 0.10110794f, 
    0.22050893f, -0.38610622f, -0.35424623f, 0.27397779f, 0.28605059f, 0.27504566f, -0.29457262f, 0.67973787f, 
    -0.33385509f, -0.01905691f, -0.14900228f, -0.05505601f, -0.55698013f, -0.16713047f, -0.55732614f, 0.10716549f, 
    0.01760177f, -0.38375118f, 0.69221830f, 0.15253751f, -0.12072716f, 0.04812823f, -0.12841138f, 0.45964012f, 
    -0.15377726f, 0.04090902f, 0.47679901f, -0.46166596f, -0.22262824f, 0.21220566f, 0.31713694f, -0.89292091f, 
    -0.60487783f, -0.01381160f, 0.51999867f, 0.30452982f, -0.14611995f, 0.49781948f, 0.36002055f, -0.69027066f, 
    -0.34364122f, 0.59430474f, 0.02430531f, -0.12406591f, 0.43912718f, -0.26633701f, -0.23444368f, -0.41467330f, 
    -0.24205391f, 0.82685190f, -0.46011898f, 0.35554296f, 0.30761579f, 0.05729750f, 0.34473076f, -0.19772229f, 
    0.27314281f, -0.01227467f, 0.05224383f, -0.22548738f, -0.48991457f, -0.40335673f, -0.24282193f, 0.34052619f, 
    0.52515090f, 0.66921127f, 0.61401850f, -0.14935200f, -0.32985920f, 0.37255239f, 0.46815336f, -0.10604244f, 
    -0.54869777f, 0.09558640f, -0.29098427f, -0.05017410f, 0.19543807f, 0.14748979f, -0.32465228f, 0.46478933f, 
    -0.16408099f, 0.23845413f, -0.19590572f, 0.43846467f, -0.45522887f, -0.31251261f, -0.44846022f, 0.67572868f, 
    0.67569643f, 0.10137596f, -0.15008457f, -0.24805856f, -0.25758240f, -1.09814060f, -0.28590384f, -0.58059299f, 
    0.51232666f, 0.53065032f, 0.01054955f, 0.04793351f, -0.03749891f, 0.27923828f, -0.21382861f, -0.07722995f, 
    -0.59820306f, 0.38760313f, -0.19399133f, 0.05437864f, 0.36092931f, -0.15669695f, -0.02145028f, -0.61271709f, 
    0.34406203f, 0.31771943f, -0.68682015f, -0.22603048f, -0.05919163f, 0.13826407f, -0.41145149f, 0.40428683f, 
    0.19165921f, -0.32409525f, -0.02997937f, 0.73747170f, -0.71029449f, -0.37564862f, -0.16595723f, -0.50498331f, 
    0.55148697f, -0.43459234f, -0.03984117f, -0.43143070f, -0.30547270f, -0.17203571f, -0.48952907f, -0.05561229f, 
    -0.14571121f, 0.16657865f, -0.44078919f, -0.22033009f, 0.00717464f, 0.46208328f, 0.77966607f, -1.20483172f, 
    -0.04196497f, -0.13335037f, -0.12441932f, 0.40386739f, -0.28190517f, 0.01765881f, -0.74685103f, 0.81505024f, 
    -0.28651220f, -0.07684521f, -0.20106295f, 0.46948409f, -0.42495412f, 0.06103732f, -0.07871073f, -0.50016648f, 
    0.24780771f, -0.68595445f, 0.22099891f, 0.18332827f, 0.42168289f, -0.59361333f, 0.48522002f, -0.36865041f, 
    -0.25807080f, -0.41636762f, -0.30291790f, 0.00872291f, -0.43043295f, -0.47688481f, 0.65257949f, 0.89441133f, 
    -0.30394024f, -0.69799769f, -0.30931073f, 0.13003133f, -0.12395021f, 0.26454535f, 0.03784511f, -0.93321347f, 
    0.18095264f, 0.39845911f, 0.42302302f, 0.37025297f, 0.67342162f, 0.04922138f, 0.15202399f, 0.39433864f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.01337569f, -0.33977956f, -0.19895759f, 0.07224382f, 0.40288141f, -0.28291404f, 0.01302863f, 0.10842963f, 
    0.38653210f, 0.07500241f, -0.36814678f, -0.06887069f, -0.27098647f, -0.00449764f, -0.10215028f, -0.23147705f, 
    -0.26910731f, -0.01040255f, -0.15049495f, 0.07640079f, -0.05164383f, 0.23112348f, 0.23051567f, 0.04048028f, 
    0.03718470f, -0.44481742f, 0.10317829f, -0.21603516f, -0.04467747f, -0.33235630f, -0.00865908f, -0.15205622f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.04771092f, -0.02812772f, 0.02584329f, -0.01919454f, 0.01053779f, -0.05796485f, -0.02640455f, -0.03707287f, 
    -0.01946626f, 0.04020213f, 0.03855867f, 0.04497440f, 0.05064651f, -0.01691220f, -0.01304913f, 0.01272709f, 
    0.00833523f, -0.00925296f, 0.02574248f, -0.03409966f, -0.05241161f, -0.03454608f, -0.06203074f, -0.02302549f, 
    0.00493600f, -0.02441615f, -0.03453691f, 0.04080130f, 0.00674649f, 0.02179450f, -0.04087851f, -0.01160696f, 
    0.03255589f, -0.05156261f, -0.01982961f, -0.02847629f, -0.00370655f, -0.06355241f, 0.00115681f, 0.02877853f, 
    -0.06621090f, 0.04267012f, -0.00862158f, -0.01995399f, -0.05356610f, 0.00280142f, 0.01728472f, -0.03412848f, 
    -0.00409678f, -0.04593184f, 0.05384912f, -0.02187332f, -0.00270368f, -0.00696331f, -0.04101687f, -0.05446370f, 
    0.01183657f, -0.01432776f, -0.01994301f, -0.04624866f, -0.03535275f, -0.01929536f, 0.03304609f, -0.05847029f, 
    -0.02955848f, -0.05523707f, 0.01971610f, 0.02791964f, -0.03277064f, 0.00085613f, 0.04650076f, -0.00647605f, 
    -0.03598433f, 0.04858555f, -0.00782888f, -0.06208172f, 0.01276556f, -0.01511579f, 0.01960644f, 0.04284300f, 
    -0.04177609f, 0.00018370f, -0.01066016f, -0.05304931f, -0.01333707f, 0.04685495f, -0.04250567f, 0.05057999f, 
    0.02909848f, -0.04375165f, 0.01091402f, -0.05320088f, -0.05156815f, -0.02184010f, -0.04448308f, -0.02709139f, 
    -0.00121244f, -0.04229051f, -0.06235443f, -0.04808782f, 0.03283121f, -0.03366506f, -0.00020609f, 0.04099137f, 
    0.02073806f, -0.04453250f, -0.05899500f, 0.02432222f, 0.05352447f, -0.00101311f, 0.02485463f, 0.02103979f, 
    0.05414379f, -0.00775943f, -0.01860958f, 0.02505395f, 0.02004722f, 0.00301372f, -0.00301090f, -0.00669692f, 
    0.02824884f, 0.02450955f, 0.02949604f, -0.00123428f, 0.01987345f, -0.02543597f, -0.05719387f, 0.02760690f, 
    -0.02442990f, 0.04914100f, 0.01816620f, 0.02931960f, 0.00411308f, -0.00367162f, -0.02062813f, 0.01870207f, 
    0.03213292f, -0.04501591f, 0.03185615f, -0.06445271f, -0.05294730f, 0.01526767f, -0.03520745f, 0.00628035f, 
    0.01303657f, 0.02553079f, -0.01321258f, 0.04050008f, -0.03623046f, -0.06533053f, -0.01780222f, 0.01988962f, 
    -0.04208058f, -0.02960528f, -0.00618975f, 0.01922844f, -0.00973957f, 0.01894549f, 0.04229084f, -0.02168435f, 
    0.03918238f, -0.01518186f, 0.03609539f, 0.02369593f, -0.00475236f, -0.05812765f, 0.00532001f, -0.02154983f, 
    0.05916493f, -0.04022204f, 0.02349300f, -0.00414916f, -0.06764591f, -0.02317695f, 0.03699809f, 0.00000363f, 
    0.03006113f, 0.04537641f, 0.02853831f, 0.00360335f, -0.01267565f, 0.04712742f, -0.05956899f, -0.03238931f, 
    0.01197003f, -0.02284669f, 0.02358414f, -0.04427629f, 0.00661676f, -0.03055652f, 0.04837883f, 0.00745656f, 
    -0.03817593f, -0.05104623f, 0.01073319f, -0.05571869f, -0.05309372f, 0.05599931f, -0.00504153f, 0.04435976f, 
    0.02208592f, 0.01966086f, -0.02442915f, -0.00941975f, 0.04072396f, -0.03390948f, -0.03346498f, -0.01283529f, 
    0.05717677f, 0.00516662f, -0.04603285f, -0.01820339f, 0.03320494f, -0.00607099f, -0.05956982f, 0.04591709f, 
    0.02198895f, 0.01470813f, -0.04721149f, -0.04172509f, 0.04042628f, -0.02743341f, 0.05852846f, 0.02759606f, 
    -0.01961531f, 0.01427920f, 0.01270436f, -0.04198987f, -0.05170191f, 0.03306305f, -0.01596104f, 0.00982018f, 
    -0.01342431f, 0.04595685f, -0.01661550f, -0.04493312f, -0.01592386f, 0.02336755f, 0.05482352f, -0.03385282f, 
    0.01767706f, 0.02080863f, -0.06097810f, -0.01566140f, -0.02521270f, -0.05483105f, 0.04848719f, -0.02108560f, 
    -0.05999364f, -0.02964826f, 0.03055902f, -0.01320940f, -0.04520660f, 0.00253789f, -0.02961244f, 0.02049402f, 
    0.00307170f, -0.01744264f, -0.02021696f, 0.02127044f, 0.03725301f, -0.02015119f, 0.00667818f, -0.04612206f, 
    0.03532782f, -0.05424028f, -0.00632881f, 0.05306335f, -0.05023701f, 0.01435573f, 0.03302572f, 0.04826087f, 
    -0.04605515f, -0.00595398f, -0.01164193f, 0.03792528f, -0.02803024f, 0.02348241f, 0.01072787f, -0.00364070f, 
    -0.04221969f, 0.01928197f, 0.04588798f, -0.01212873f, -0.04385048f, -0.02407273f, 0.02316601f, -0.03549422f, 
    -0.02727200f, 0.02631273f, 0.01946566f, 0.03342567f, 0.05129107f, -0.03181789f, -0.00991839f, -0.05343186f, 
    -0.04579227f, 0.04072675f, 0.02922262f, 0.01693197f, 0.02206882f, -0.04919446f, 0.01724427f, -0.00876756f, 
    0.04669552f, -0.04406368f, -0.05295185f, -0.04662720f, 0.00111128f, -0.02483735f, -0.02942223f, -0.01406501f, 
    -0.03475643f, -0.04404634f, 0.03678210f, 0.04082558f, -0.00444577f, -0.05205317f, -0.06286752f, 0.02565264f, 
    -0.00877369f, -0.03482625f, -0.02813927f, 0.01091276f, -0.03489973f, 0.00958695f, 0.03817650f, -0.03440926f, 
    0.04043589f, 0.02709712f, 0.00592883f, 0.01721867f, -0.03458017f, -0.04002747f, -0.05874891f, -0.03168378f, 
    -0.00954725f, 0.04359206f, -0.03458811f, 0.04887398f, -0.06163460f, -0.02596710f, -0.01295494f, 0.03437726f, 
    0.00359847f, -0.03731716f, -0.05648521f, 0.00728801f, 0.03240788f, -0.00673167f, 0.01010823f, 0.00662988f, 
    0.00965069f, -0.01416763f, -0.04948610f, -0.04311332f, 0.01775971f, 0.02237559f, -0.03894024f, -0.03999580f, 
    0.01721976f, 0.05310937f, -0.03012465f, -0.05681119f, 0.02194772f, -0.02635349f, 0.03879319f, 0.03935076f, 
    -0.03020553f, 0.02512466f, 0.01146099f, -0.06246339f, 0.03119925f, 0.00001978f, -0.02295285f, -0.00025693f, 
    -0.05088691f, -0.02884337f, 0.01398778f, 0.00290870f, -0.03154811f, -0.01396892f, 0.05218617f, 0.01987022f, 
    -0.02582313f, 0.01153501f, -0.03371915f, 0.03267007f, -0.02790387f, -0.00579308f, -0.03323507f, -0.03510838f, 
    0.03573505f, 0.03793958f, 0.00023788f, -0.04331722f, 0.05161076f, -0.03298112f, -0.00378393f, 0.00145450f, 
    0.04001222f, -0.03878530f, 0.02375101f, 0.00268753f, -0.03888847f, -0.04710696f, -0.05891056f, 0.03844223f, 
    0.04932152f, -0.04863924f, 0.04245051f, 0.00011556f, -0.03079160f, 0.00475523f, -0.00569712f, -0.00622047f, 
    0.02317333f, -0.05770452f, 0.03227725f, 0.01149373f, -0.00864064f, -0.02649366f, -0.02679979f, 0.01803833f, 
    0.02934564f, 0.04101621f, 0.05163736f, -0.01970783f, 0.01278023f, 0.02138458f, -0.05727024f, -0.05452839f, 
    -0.03749740f, -0.05636564f, -0.00694471f, -0.00017062f, 0.01788501f, 0.03212522f, -0.00371504f, 0.05161938f, 
    0.02680558f, -0.04774942f, -0.04535682f, -0.00721334f, -0.02206195f, -0.02737687f, -0.01316455f, 0.03686802f, 
    -0.05812041f, 0.01675468f, -0.03013677f, 0.02383730f, -0.03496880f, -0.00806503f, 0.00813416f, 0.02522446f, 
    0.00898510f, -0.01561829f, -0.03869108f, -0.01540294f, 0.00195207f, -0.04821046f, -0.02246539f, -0.02978861f, 
    -0.05683559f, 0.03166128f, 0.03764775f, -0.03005187f, 0.01415616f, -0.06387672f, -0.05695279f, 0.00314347f, 
    -0.03973093f, -0.05063045f, 0.03799694f, 0.02042086f, 0.00261581f, -0.01958963f, -0.04607276f, 0.00961115f, 
    0.03442625f, -0.01363971f, 0.03047355f, -0.04714548f, -0.02256197f, -0.00766145f, 0.01500753f, 0.03547852f, 
    -0.06150489f, 0.03283383f, 0.01590110f, -0.03318691f, -0.02102624f, -0.01368907f, 0.00131742f, -0.04625249f, 
    0.01032387f, -0.03284378f, -0.04185423f, -0.01209293f, -0.04391940f, -0.05205195f, -0.01682150f, -0.02791696f, 
    0.01532365f, 0.00739143f, -0.04330826f, -0.05045300f, -0.01824636f, -0.02751922f, -0.02025147f, 0.02058575f, 
    -0.05155434f, -0.06013207f, -0.01550361f, -0.03898628f, 0.00367237f, -0.00918992f, 0.03766860f, 0.02178502f, 
    -0.03756692f, 0.02655445f, 0.05174986f, 0.01224199f, -0.02795305f, 0.04685314f, 0.03416469f, -0.02458610f, 
    -0.01369995f, -0.04021385f, -0.03581564f, 0.05115419f, -0.03026213f, -0.05811420f, 0.02723099f, 0.00938108f, 
    0.02422515f, 0.03030305f, 0.05157809f, -0.02616058f, -0.06312731f, -0.06355229f, 0.01713534f, -0.06359202f, 
    -0.04726251f, -0.04185864f, -0.05761492f, -0.00279304f, 0.00881261f, -0.00786684f, 0.00713599f, 0.01736042f, 
    0.00012775f, -0.01546168f, -0.00842918f, -0.04529596f, -0.03562175f, 0.01616066f, 0.00052806f, 0.03593639f, 
    0.04577406f, -0.03209233f, -0.02225028f, -0.05092365f, -0.04588096f, 0.03993849f, -0.00574674f, -0.01401245f, 
    -0.04342762f, 0.03576508f, -0.04132815f, -0.04536219f, -0.01860795f, -0.05930867f, 0.02575273f, -0.04098096f, 
    0.03978147f, 0.24550699f, 0.11079733f, 0.08902689f, -0.07022782f, -0.03221526f, 0.06972188f, 0.10917821f, 
    -0.05128483f, 0.00560141f, -0.14123805f, 0.10768962f, -0.07886000f, 0.04634972f, -0.05786714f, 0.13443172f, 
    0.04564192f, 0.03181254f, -0.11448940f, -0.27819023f, -0.46693274f, -0.08338954f, -0.00563264f, -0.13508216f, 
    -0.12472211f, -0.15517287f, 0.08326785f, 0.10935197f, -0.16350520f, 0.26622882f, 0.02558897f, -0.03851849f, 
    0.00818531f, 0.08111271f, -0.21510340f, 0.09183776f, 0.14820164f, -0.21803406f, 0.04226441f, -0.10010044f, 
    0.17359878f, -0.03029238f, 0.14820285f, -0.00201061f, 0.25750703f, -0.12921956f, -0.06026663f, 0.04683061f, 
    -0.01044641f, -0.04040708f, -0.04177888f, 0.24729414f, 0.03063229f, -0.07402867f, 0.20386730f, -0.06753933f, 
    0.23875865f, -0.15895757f, -0.02885858f, 0.07962025f, 0.05680245f, 0.11596656f, 0.05714571f, 0.03893561f, 
    -0.41002983f, 0.03480129f, 0.05412146f, -0.12844147f, 0.09408358f, 0.15343153f, -0.15417771f, 0.10439882f, 
    -0.23871146f, -0.13432178f, 0.28845274f, 0.03748611f, 0.04049252f, 0.08494398f, 0.09252735f, -0.00930326f, 
    0.09060733f, -0.03112392f, -0.19905178f, -0.09366957f, -0.04972742f, 0.03692451f, -0.00861746f, 0.04193322f, 
    0.01356592f, 0.06477787f, -0.40167490f, 0.07807991f, -0.25298157f, -0.00145566f, -0.01154856f, -0.05238392f, 
    0.02134405f, 0.02797665f, -0.01523801f, -0.12490288f, -0.36575550f, -0.28037694f, 0.01185743f, -0.13066703f, 
    -0.01801591f, -0.02907926f, -0.17135100f, -0.26337531f, -0.16112085f, -0.03066258f, 0.09276719f, 0.07042150f, 
    -0.03009895f, 0.03790333f, 0.10178423f, -0.00368899f, -0.10704378f, 0.13901851f, -0.59393257f, -0.11281782f, 
    0.00719516f, 0.06467579f, 0.05945312f, 0.06099484f, 0.10074976f, -0.10821044f, 0.13564710f, -0.60499668f, 
    0.04678384f, 0.15253899f, 0.02867198f, -0.16162056f, 0.05525085f, 0.07886222f, 0.11578193f, -0.22709282f, 
    -0.00670653f, -0.06554174f, -0.03749176f, 0.07736567f, -0.11424355f, 0.02096556f, 0.03980260f, -0.07608742f, 
    -0.42009819f, -0.42200065f, -0.48804894f, 0.13810121f, -0.16387579f, -0.08690866f, 0.02055396f, 0.01212154f, 
    -0.06989152f, 0.06791468f, 0.01488138f, 0.12106086f, -0.08257110f, -0.00167134f, 0.03526464f, 0.01932592f, 
    0.06221152f, -0.03286420f, -0.09002910f, -0.15096539f, -0.16608134f, 0.12155040f, -0.20673165f, -0.26634905f, 
    0.07619312f, -0.05718352f, -0.03319335f, -0.26778954f, -0.19839185f, -0.35048541f, 0.10665174f, -0.20730230f, 
    -0.08867293f, -0.11031529f, 0.04045383f, 0.02778323f, -0.55193686f, 0.28259593f, -0.08427664f, -0.05793018f, 
    -0.00680668f, -0.03704024f, 0.03952537f, 0.04225675f, -0.06125592f, -0.30085626f, 0.18097053f, 0.00884679f, 
    0.02475871f, 0.00129508f, 0.05097647f, 0.02114054f, -0.01605681f, 0.01026262f, -0.04593734f, 0.06857759f, 
    -0.03744797f, 0.00606526f, 0.09254582f, 0.11584913f, 0.00042249f, 0.00338113f, -0.13862081f, -0.07865945f, 
    -0.02890019f, 0.24964082f, 0.09306441f, 0.13793361f, 0.14154653f, 0.07440654f, -0.00833496f, 0.15912668f, 
    0.17916946f, 0.05312614f, 0.30455863f, -0.01157555f, 0.01274366f, -0.01009917f, -0.02608005f, -0.02343342f, 
    -0.08136735f, -0.17862536f, -0.05753839f, 0.19145344f, -0.11362791f, -0.02012425f, 0.04011980f, 0.02883358f, 
    -0.23106229f, -0.02378433f, -0.51011246f, -0.14422190f, 0.26566824f, 0.08636597f, -0.03371907f, 0.07565321f, 
    0.05125065f, 0.13770559f, 0.01911774f, -0.23698752f, -0.77797204f, -0.28666228f, 0.02436941f, 0.01847822f, 
    -0.12466867f, 0.00181851f, -0.17362463f, 0.05021498f, -0.12059170f, -0.20630993f, 0.28359023f, 0.05833453f, 
    0.06989346f, -0.03549685f, 0.00415729f, -0.02860087f, 0.09758180f, -0.12990479f, 0.05324870f, 0.12609246f, 
    -0.03374956f, -0.10671735f, 0.12529582f, 0.16723567f, 0.08326836f, 0.00791992f, 0.75195152f, -0.31297782f, 
    -0.84871006f, 0.02524312f, -0.10050911f, 0.13257921f, -0.01299967f, 0.02078543f, -0.03371758f, -0.62058592f, 
    -0.01935787f, -0.45215380f, -0.01855010f, -0.04060711f, -0.18920241f, 0.13916135f, 0.00474364f, 0.14092043f, 
    0.11973640f, 0.15972091f, 0.03974189f, 0.02731938f, 0.07322594f, 0.00989622f, 0.02988700f, 0.06093075f, 
    -0.10011045f, -0.21525788f, -0.09997457f, -0.10674027f, 0.14116976f, -0.07054863f, 0.04189908f, -0.07344314f, 
    -0.06655014f, -0.16972533f, -0.16857192f, -0.11508115f, -0.17055181f, -0.05275677f, -0.09120681f, 0.14006685f, 
    -0.20554496f, -0.00110263f, 0.21896516f, -0.01299137f, -0.08434924f, 0.00479937f, 0.04319708f, -0.00289457f, 
    -0.00048819f, 0.01807573f, 0.06647346f, 0.03263912f, -0.02284165f, -0.11715479f, -0.12549032f, 0.14461666f, 
    -0.08255900f, 0.04351840f, 0.08731930f, 0.17618908f, 0.13551079f, 0.02131003f, 0.08901573f, -0.11279856f, 
    0.09331033f, -0.15756689f, -0.06152156f, -0.10928423f, 0.06533532f, -0.14624809f, -0.31641036f, 0.01623739f, 
    0.07558877f, 0.02429536f, -0.00924321f, -0.04972316f, 0.02666216f, -0.10462472f, 0.00445935f, -0.12814754f, 
    -0.08318201f, 0.01570681f, 0.09728933f, 0.01608191f, -0.00243965f, -0.03194549f, 0.10956632f, 0.14421102f, 
    0.06156759f, 0.17984246f, 0.19442655f, 0.06262314f, -0.01113545f, 0.14169267f, 0.04235388f, 0.12368285f, 
    0.10730019f, -0.21612991f, -0.12097467f, -0.14256355f, -0.07632396f, 0.02214826f, -0.09814040f, 0.06815678f, 
    -0.09300102f, 0.10840525f, 0.21071003f, 0.13520645f, -0.00935514f, -0.17757973f, -0.11426859f, -0.06449152f, 
    -0.03502100f, -0.27512279f, 0.13390826f, -0.37602869f, -0.44559637f, -0.28621295f, -0.12031399f, -0.16316611f, 
    -0.04136359f, -0.06972743f, -0.10131347f, -0.00715279f, 0.01660646f, 0.00354436f, 0.03314472f, -0.07492884f, 
    0.01074549f, 0.10091561f, 0.00923978f, 0.25790736f, 0.09142333f, -0.07703817f, -0.34933206f, -0.17464179f, 
    0.04136881f, 0.15147050f, -0.23283128f, -0.01736971f, -0.05150233f, -0.07348616f, 0.22538242f, -0.16202654f, 
    -0.22295748f, 0.10847782f, 0.05415026f, -0.05103700f, 0.11208449f, -0.01009583f, 0.18131450f, 0.09234462f, 
    0.06698555f, -0.07157988f, 0.03347025f, -0.01325203f, -0.07292301f, -0.09098966f, -0.08661278f, -0.07169389f, 
    -0.17679366f, -0.09582163f, -0.41845414f, -0.15382221f, -0.10796249f, -0.03499999f, -0.08271403f, 0.11034098f, 
    -0.05395427f, -0.08118360f, -0.10832183f, 0.09757660f, -0.00829087f, -0.03398166f, 0.08971224f, 0.12683167f, 
    0.03544183f, 0.01839720f, -0.03638409f, -0.36763129f, -0.04664447f, 0.12976977f, 0.05733806f, -0.13960819f, 
    -0.18108220f, -0.41441879f, -0.12160105f, -0.07725683f, -0.08889404f, -0.15461065f, -0.05097064f, 0.00156300f, 
    0.07399310f, 0.01707259f, 0.17517282f, 0.13415971f, 0.09628413f, 0.14740747f, 0.04873274f, -0.01980305f, 
    -0.08924364f, -0.02687277f, -0.00391383f, -0.25947532f, 0.02547166f, 0.20823827f, 0.15518323f, 0.05586519f, 
    -0.01573948f, -0.11448810f, 0.10585809f, 0.07582197f, 0.02952959f, 0.05056085f, 0.09823718f, 0.15040225f, 
    0.00729308f, -0.03288626f, 0.00956402f, 0.11113662f, 0.06001735f, 0.09639914f, 0.02649776f, 0.23130195f, 
    0.01114039f, 0.07221899f, 0.10826016f, 0.13656373f, 0.02458638f, 0.03236816f, 0.05750452f, 0.05423157f, 
    0.13280730f, 0.03309660f, -0.20361765f, 0.01412928f, 0.08568530f, -0.05493125f, 0.18611200f, -0.13726044f, 
    0.00970130f, -0.06698262f, 0.14269078f, 0.18191889f, -0.08759972f, 0.06649347f, -0.01258935f, 0.04401629f, 
    0.06915619f, -0.17832585f, 0.27149639f, 0.38685402f, 0.04927147f, 0.08087737f, 0.07305310f, 0.07164802f, 
    0.12483139f, -0.00580925f, 0.07139079f, 0.10980661f, -0.06502733f, -0.17895812f, -0.26803234f, 0.03362580f, 
    0.07342000f, 0.08634625f, 0.01304031f, -0.05174797f, 0.07942291f, 0.00019764f, 0.16253585f, -0.04910159f, 
    -0.03417020f, 0.06016132f, 0.11521755f, 0.06763498f, -0.01230196f, -0.04354015f, 0.09652176f, 0.04589637f, 
    0.03849545f, 0.00572060f, 0.04958783f, -0.03173271f, -0.06692296f, -0.24768795f, -0.48636022f, -0.17559947f, 
    0.03360869f, -0.08429742f, -0.11094331f, 0.05925053f, 0.07013030f, -0.08226380f, 0.09801681f, -0.08400159f, 
    -0.21761449f, -0.34523857f, -0.02776565f, -0.05545069f, -0.12647429f, 0.00055624f, 0.07903875f, -0.09973250f, 
    -0.02142146f, 0.26331750f, 0.10642938f, 0.03081159f, -0.01111647f, 0.01573323f, 0.04317340f, -0.01984568f, 
    -0.02691268f, 0.08129299f, 0.23729990f, -0.18768707f, -0.00087585f, -0.03957918f, -0.06581715f, 0.00277542f, 
    -0.00350583f, 0.17323747f, -0.25815815f, -0.13198760f, -0.19535831f, -0.06644941f, -0.10675056f, 0.05021408f, 
    -0.10188524f, -0.02679173f, -0.09620503f, 0.09171160f, -0.05783232f, 0.21209870f, -0.02915198f, 0.04328204f, 
    -0.24555981f, 0.02338933f, -0.13208827f, 0.01818140f, -0.04015361f, -0.00167349f, -0.26718280f, 0.03691391f, 
    0.01107793f, 0.03442066f, -0.03641162f, 0.14233126f, -0.09151584f, -0.24324630f, 0.30481148f, 0.07445813f, 
    -0.06993032f, -0.03017971f, -0.23358509f, -0.02547130f, -0.02300914f, -0.05270028f, -0.12655574f, -0.27359581f, 
    -0.23174365f, 0.07603411f, -0.05290021f, 0.01749451f, -0.09734731f, 0.14436848f, 0.11285345f, -0.03625947f, 
    0.05231209f, 0.30144659f, -0.03017142f, -0.09564998f, -0.02964289f, -0.13009299f, -0.00701054f, 0.11527486f, 
    0.08042549f, 0.10485635f, 0.18066320f, 0.04919810f, 0.02769108f, 0.14093938f, 0.09771229f, 0.00986326f, 
    0.05888882f, 0.12764546f, -0.15343636f, 0.01599389f, -0.20453255f, -0.11738847f, -0.01280165f, 0.07344076f, 
    -0.01002289f, 0.02885869f, -0.39562708f, 0.05646772f, 0.34371874f, -0.09425738f, -0.14505585f, -0.07483377f, 
    0.08862407f, 0.16360541f, -0.06754559f, 0.02457002f, -0.31637034f, 0.37848520f, -0.34979054f, 0.02500921f, 
    -0.01949434f, 0.13784966f, 0.03349036f, -0.28058097f, 0.17379516f, 0.01048249f, -0.21271819f, 0.00348551f, 
    0.01451411f, 0.07054190f, -0.01613017f, 0.01632322f, -0.18613036f, -0.06106326f, -0.37188262f, -0.05316563f, 
    -0.07135006f, 0.04767882f, -0.12554048f, 0.01340066f, 0.04602219f, -0.05310343f, -0.09915196f, -0.06901740f, 
    0.04573442f, 0.00538510f, 0.01203269f, -0.15064758f, 0.03411385f, 0.07548782f, 0.11581267f, -0.18799597f, 
    0.02623094f, 0.21631232f, -0.05988206f, 0.12828702f, 0.02715802f, -0.02679511f, 0.04824457f, -0.05583363f, 
    0.22349231f, -0.15448372f, -0.19457643f, -0.21017234f, -0.08535991f, 0.24337061f, 0.01207104f, -0.01988289f, 
    0.09883234f, -0.30921906f, -0.00183100f, 0.02049146f, 0.09607874f, 0.08639560f, -0.08104431f, -0.04292601f, 
    -0.02267911f, 0.10684073f, 0.02711839f, -0.18727674f, 0.18573712f, 0.04074719f, 0.02828836f, -0.22587612f, 
    0.02514066f, -0.02332806f, -0.09932560f, -0.01345613f, -0.23231292f, 0.20608586f, -0.05720889f, 0.23758931f, 
    -0.07065280f, -0.00331542f, -0.18290265f, 0.11119321f, 0.04761388f, -0.14606503f, 0.31810036f, 0.14531954f, 
    -0.02650996f, -0.05495054f, 0.08368303f, 0.02785018f, -0.03993605f, 0.28052753f, -0.11601116f, 0.24162534f, 
    -0.07553162f, -0.03185667f, 0.09025203f, -0.03633279f, 0.08676884f, 0.06042682f, 0.14819077f, -0.02166044f, 
    -0.14222500f, 0.04730806f, 0.02072235f, 0.09445322f, 0.01785710f, 0.08618037f, 0.02225522f, -0.07316369f, 
    -0.05939841f, 0.28650579f, -0.15017436f, 0.03416736f, -0.21522887f, 0.11761589f, -0.07232497f, 0.10152496f, 
    -0.03312942f, -0.17070465f, 0.03268170f, -0.03783913f, -0.20662881f, 0.06993797f, 0.03683415f, -0.03943752f, 
    0.18054482f, 0.04878128f, 0.17571214f, 0.11269442f, -0.14603169f, -0.11040806f, -0.05618802f, 0.03887979f, 
    0.21372096f, -0.11546601f, 0.14094555f, -0.25580570f, 0.51490510f, 0.16548145f, 0.01153970f, -0.07935487f, 
    0.03550194f, 0.11291642f, -0.14123537f, -0.38119295f, -0.07223931f, 0.35811043f, -0.02219594f, 0.23536327f, 
    0.00044372f, -0.14583728f, -0.15379982f, 0.18457809f, -0.00362210f, -0.04276342f, 0.17081954f, 0.00236476f, 
    0.05404002f, -0.04664135f, 0.01263942f, 0.02770476f, 0.02921097f, 0.12940943f, 0.18908472f, -0.12326723f, 
    0.01737533f, -0.12135855f, 0.18646368f, 0.08698363f, -0.00105436f, -0.05480961f, -0.56723940f, -0.38971454f, 
    -0.08257568f, 0.07091193f, 0.05225208f, 0.00689686f, -0.09078258f, 0.02511890f, 0.05403150f, 0.48207888f, 
    -0.23799255f, -0.01459676f, -0.12700592f, -0.01970603f, 0.00842283f, -0.08380359f, 0.12123174f, 0.07881612f, 
    -0.03112052f, 0.01823991f, 0.05832778f, 0.04277672f, 0.04182923f, 0.04657762f, -0.00304348f, 0.04429058f, 
    -0.02614923f, 0.01413283f, 0.03485325f, -0.01764822f, -0.02733821f, 0.01918927f, -0.06578024f, -0.06375566f, 
    -0.02948951f, -0.04977176f, -0.04223751f, -0.03596283f, 0.01498706f, 0.04675243f, -0.01130617f, -0.01580672f, 
    -0.02045785f, -0.00389156f, -0.04312451f, -0.03623023f, -0.01946394f, -0.05969569f, -0.04330465f, -0.02574254f, 
    -0.06307299f, -0.05711932f, -0.01003820f, -0.05117834f, 0.03326123f, 0.04154452f, -0.03467560f, -0.03321898f, 
    -0.01222531f, 0.03028659f, 0.01012049f, 0.01486600f, 0.02779644f, -0.03747382f, 0.01630672f, -0.05578312f, 
    0.00424255f, 0.03131214f, 0.03615998f, -0.01611904f, 0.02430392f, -0.00318871f, 0.00067927f, 0.04433101f, 
    0.02607470f, -0.05722954f, -0.02511082f, -0.00142598f, -0.05508295f, -0.04627717f, -0.03619072f, 0.01290966f, 
    -0.03615052f, -0.05503736f, 0.03454573f, 0.04089903f, 0.00570598f, 0.03139044f, 0.00887130f, 0.04764291f, 
    0.01187883f, 0.04079268f, 0.03248916f, -0.02680558f, -0.02748044f, -0.00041975f, 0.03412880f, -0.01189144f, 
    -0.01248580f, 0.01328971f, 0.02448485f, -0.05930514f, -0.03333632f, -0.05300437f, 0.06062545f, -0.01466052f, 
    -0.00366247f, 0.04044195f, -0.00774897f, -0.02548104f, 0.03217798f, 0.03616129f, -0.06246220f, 0.00944379f, 
    -0.06255474f, -0.02133519f, 0.01281357f, -0.02580270f, -0.01141453f, -0.06867614f, 0.03066528f, -0.01054581f, 
    0.01420522f, -0.04664935f, -0.04317017f, 0.01947187f, -0.00369557f, 0.04878896f, 0.02970950f, -0.04040156f, 
    -0.05966096f, 0.00546347f, -0.01571880f, 0.00078555f, -0.06563643f, 0.01818009f, -0.00358397f, -0.01136923f, 
    -0.03097235f, -0.03087867f, 0.03895524f, 0.03935410f, -0.04579937f, -0.00717727f, -0.00864140f, -0.02441736f, 
    0.00909732f, 0.03794259f, -0.05229275f, -0.05926069f, 0.01967434f, -0.03139149f, 0.03583195f, 0.01326392f, 
    0.04907204f, -0.03802597f, -0.01932956f, -0.01876949f, 0.02852301f, -0.00960731f, 0.05059085f, 0.02397136f, 
    -0.01245099f, 0.02423760f, 0.00437958f, 0.03527067f, -0.04415791f, -0.00966606f, 0.03174316f, 0.02356260f, 
    0.04657140f, -0.03796754f, 0.01078017f, 0.04059459f, -0.03353798f, -0.05524618f, -0.01712804f, -0.03746730f, 
    0.05016747f, 0.03705293f, 0.01843099f, -0.06663267f, -0.00581344f, 0.00584745f, -0.05161362f, -0.04018351f, 
    0.03649238f, -0.06268668f, -0.01866667f, 0.00425218f, 0.03654112f, -0.04178861f, 0.00068195f, 0.00951377f, 
    -0.05723932f, 0.04555842f, -0.05323755f, 0.02968420f, -0.04512285f, 0.01409204f, 0.03910404f, -0.02982806f, 
    0.01763977f, 0.04107852f, 0.02553987f, -0.00516513f, -0.05868394f, -0.05379389f, -0.02938112f, 0.06050507f, 
    0.02419138f, -0.00319171f, -0.04197644f, -0.03615693f, 0.00936852f, 0.03737384f, -0.02194598f, -0.03164853f, 
    0.01077597f, -0.05059329f, -0.06660778f, 0.00155794f, -0.02223933f, -0.05456405f, 0.00761896f, -0.03940151f, 
    -0.01253100f, -0.00674204f, -0.06308026f, -0.05180526f, 0.02468335f, -0.01546837f, -0.03277071f, -0.03633923f, 
    -0.06425860f, -0.02931326f, -0.00617344f, 0.02302463f, -0.03670909f, -0.06482367f, -0.00664949f, -0.02458905f, 
    -0.04506604f, -0.01502567f, -0.00892024f, -0.01386036f, -0.03203152f, -0.03584936f, 0.03847167f, -0.04379963f, 
    0.00896798f, 0.01755523f, -0.04013088f, 0.04886988f, -0.03435090f, -0.05115462f, -0.00662790f, 0.01134483f, 
    -0.05093450f, 0.04902858f, 0.00309050f, -0.03905254f, -0.05350215f, -0.03807926f, -0.02660937f, 0.03525217f, 
    0.03493400f, 0.04809345f, -0.00933731f, -0.04867547f, 0.05386652f, 0.05771960f, -0.02926745f, 0.01499367f, 
    0.00194915f, -0.00337545f, 0.04686235f, 0.02921117f, 0.03647519f, 0.03920351f, -0.02808290f, -0.05743885f, 
    -0.00687500f, 0.03045791f, -0.03154701f, -0.06794745f, 0.01232743f, -0.02178774f, 0.05055824f, -0.05871468f, 
    -0.01000109f, 0.01577795f, -0.01893571f, -0.04029329f, -0.00913071f, -0.05537563f, 0.01620181f, -0.05495098f, 
    0.01495809f, -0.02927567f, -0.05603624f, 0.02673114f, -0.05125794f, -0.00083121f, -0.00330440f, 0.03050381f, 
    0.00446479f, 0.07898150f, -0.03524582f, -0.04847013f, 0.07383757f, 0.13922641f, 0.11587603f, 0.03840099f, 
    0.02411364f, -0.74271411f, -0.20999552f, 0.00834106f, -0.12211645f, -0.07402829f, -0.15788102f, 0.06205438f, 
    -0.07019598f, 0.00543143f, -0.03267465f, -0.39217114f, -0.10616675f, 0.01957837f, 0.13799106f, -0.19142871f, 
    0.00677470f, -0.15843713f, -0.08288672f, 0.04186821f, 0.12181001f, 0.30458814f, 0.03927369f, -0.11439308f, 
    0.02345227f, -0.01204900f, 0.06886049f, 0.17160214f, 0.03243420f, 0.26648679f, 0.15222250f, 0.07030526f, 
    0.01123613f, 0.16269884f, 0.09493802f, 0.08835493f, 0.04430014f, -0.18218051f, -0.12219980f, 0.03963098f, 
    -0.22925659f, -0.10391811f, -0.09982426f, -0.10764220f, -0.03377448f, -0.02398158f, 0.11555674f, -0.31793782f, 
    0.10727185f, 0.08224092f, -0.01249476f, -0.09475243f, 0.21198250f, -0.04769476f, -0.06400507f, -0.01225157f, 
    0.21327180f, -0.24622525f, 0.19438502f, 0.11038125f, 0.05309239f, -0.04122199f, -0.07341247f, -0.03340786f, 
    0.38672298f, 0.12059691f, 0.09642104f, 0.08618990f, 0.09293567f, 0.10128108f, 0.08326752f, 0.14727783f, 
    0.06996939f, 0.07256019f, 0.00228407f, -0.09074759f, -0.03364134f, -0.04424296f, -0.08629349f, 0.03999402f, 
    -0.01378666f, 0.11120891f, -0.17429899f, -0.18700029f, 0.26903090f, -0.23748885f, -0.09841950f, 0.01649654f, 
    -0.02595403f, -0.06654339f, 0.10063003f, -0.07816631f, -0.22967760f, 0.09966540f, 0.12529776f, -0.13324425f, 
    -0.10428302f, -0.13423385f, -0.04669333f, 0.01029163f, 0.01969400f, -0.05355322f, -0.03293460f, -0.03455487f, 
    0.03458694f, -0.16817793f, -0.04864759f, 0.05898236f, -0.09548901f, 0.09662863f, 0.06912241f, -0.07762211f, 
    -0.18154015f, -0.04328142f, 0.03080344f, 0.06680531f, 0.11240773f, 0.08972917f, 0.13755348f, 0.34815955f, 
    0.17741297f, -0.09754936f, -0.16257909f, 0.26296115f, 0.01308479f, -0.08078869f, 0.00499442f, 0.14703661f, 
    -0.14016148f, 0.01899376f, -0.09337844f, -0.06452711f, -0.01648982f, 0.06250789f, -0.02869500f, 0.09766494f, 
    0.07647134f, -0.27167067f, -0.28760952f, -0.36240318f, -0.22475596f, -0.11158600f, -0.10817718f, -0.06938789f, 
    -0.06179284f, -0.01220099f, -0.07203476f, -0.55510616f, -0.02451394f, -0.00080098f, -0.04926295f, 0.04093701f, 
    -0.03690948f, -0.09676360f, -0.36852720f, -0.02321041f, -0.06940958f, -0.13391533f, -0.14435856f, -0.12367469f, 
    0.06918781f, 0.00201307f, 0.06632952f, -0.01753604f, -0.19129689f, -0.13736215f, 0.01920266f, -0.04255405f, 
    0.10509656f, 0.06845672f, 0.02388535f, 0.03834378f, -0.07089649f, 0.04631582f, 0.39062366f, -0.25782278f, 
    -0.12422662f, 0.02102955f, -0.00407997f, 0.09487419f, 0.00821592f, -0.11371285f, 0.26160929f, 0.50490618f, 
    -0.08627436f, 0.09697431f, 0.05278960f, -0.02344471f, 0.07584936f, 0.05827047f, 0.01416997f, 0.20943956f, 
    0.32310212f, -0.07308854f, 0.08564197f, 0.05618366f, 0.15186286f, 0.06005285f, 0.08891118f, -0.00760347f, 
    -0.15502135f, -0.05977633f, -0.01450111f, 0.03508406f, -0.02910760f, -0.00448827f, -0.13903686f, 0.09383083f, 
    -0.14358908f, 0.15094715f, 0.10716005f, 0.00264064f, 0.01499458f, 0.02353965f, 0.03982173f, 0.02114229f, 
    0.13678707f, -0.38807353f, -0.44000721f, -0.59590095f, -0.18650541f, -0.39455980f, -0.09643612f, -0.12390365f, 
    -0.07589075f, -0.04149260f, -0.14915740f, -0.21727572f, 0.16157460f, 0.10512871f, -0.09861368f, 0.14845692f, 
    0.01679978f, -0.01210220f, 0.10692235f, -0.14316256f, -0.40766203f, -0.37438536f, -0.13710472f, -0.08253305f, 
    -0.00138986f, -0.01666375f, -0.05287042f, 0.03090064f, -0.16137663f, -0.01415923f, -0.21083628f, 0.12972465f, 
    -0.04900651f, -0.03384743f, 0.00486553f, 0.01660209f, -0.02865057f, -0.44015986f, -0.15203418f, -0.04721259f, 
    0.02004256f, -0.12180712f, -0.06129930f, 0.04337871f, 0.00878091f, 0.10852364f, 0.03336827f, -0.20712793f, 
    -0.26920423f, 0.00219737f, 0.08841283f, -0.03008204f, 0.02974324f, -0.02469906f, -0.07317121f, -0.12417065f, 
    -0.10641609f, -0.13445076f, -0.15662207f, -0.07366101f, -0.16955751f, -0.09047621f, -0.05964071f, 0.18231525f, 
    0.01595560f, 0.05689434f, -0.03774338f, -0.02256602f, 0.00108674f, -0.00946192f, 0.00771092f, 0.00638221f, 
    -0.01446599f, -0.00342323f, -0.00741796f, -0.04110334f, -0.00561161f, 0.01608451f, 0.00537610f, 0.04600575f, 
    -0.01419395f, -0.05916779f, -0.02416478f, -0.00907263f, -0.00057397f, -0.01087080f, 0.05675836f, -0.00769597f, 
    0.02390158f, 0.05007484f, 0.04013432f, 0.00920557f, -0.05158170f, -0.05412009f, -0.04915732f, -0.00675504f, 
    -0.04203943f, -0.01054488f, -0.03285272f, 0.00940267f, -0.00992636f, -0.02730674f, -0.03751838f, -0.03781655f, 
    0.00359690f, -0.02067077f, 0.03158110f, 0.01440387f, 0.01445037f, 0.00658493f, -0.04969828f, 0.02890973f, 
    -0.04904805f, 0.05163431f, -0.06235740f, -0.05207694f, 0.03700396f, -0.01509338f, -0.00867320f, -0.03117192f, 
    0.00304134f, 0.04691415f, 0.00816382f, -0.04054088f, -0.02059306f, -0.05186278f, 0.01611445f, 0.02991981f, 
    0.01592444f, -0.02733784f, -0.01914101f, 0.01680427f, -0.03757648f, -0.01382867f, -0.05060824f, 0.01807238f, 
    -0.01397276f, 0.05323990f, -0.04170104f, -0.03057768f, -0.02263330f, -0.03613736f, 0.00570905f, -0.01474150f, 
    0.04326600f, 0.03293604f, 0.04417499f, 0.01943227f, -0.03075860f, -0.01032429f, -0.00807838f, -0.04882515f, 
    -0.01013394f, -0.01376141f, -0.02687030f, 0.00271370f, -0.02878064f, -0.03741181f, -0.02747278f, -0.03391030f, 
    0.04947824f, 0.05084136f, -0.05596846f, -0.00373392f, -0.02596487f, 0.05230276f, 0.04417023f, -0.03320656f, 
    0.03756228f, -0.04423123f, -0.05681850f, -0.02416957f, -0.03849173f, -0.04386840f, 0.02909477f, -0.01131131f, 
    -0.03427343f, 0.04281676f, -0.00339168f, -0.03701144f, -0.04567498f, 0.01858929f, -0.01248915f, -0.00605469f, 
    0.02558597f, 0.02816129f, -0.04407248f, 0.05453161f, 0.02821627f, -0.01397885f, 0.04494493f, 0.00588053f, 
    -0.04268621f, -0.03019184f, 0.04192589f, -0.01248286f, 0.01434260f, 0.01790855f, -0.05233530f, -0.02626663f, 
    -0.06177067f, 0.02999280f, -0.05774449f, 0.01334998f, 0.03524587f, 0.04667683f, 0.01316312f, -0.05345859f, 
    -0.05996194f, -0.05711065f, -0.03541113f, 0.00459390f, 0.02849659f, -0.04609613f, 0.04655453f, 0.01480379f, 
    -0.01067348f, -0.00247855f, -0.01014976f, 0.04212810f, -0.03316360f, -0.02267340f, -0.03701921f, -0.03327145f, 
    -0.05185601f, -0.00108344f, 0.03616256f, -0.01552041f, -0.01023427f, -0.02960504f, 0.04237096f, 0.02162989f, 
    0.05063004f, 0.04737091f, -0.00793081f, -0.03571262f, -0.04832235f, 0.01688292f, 0.04500403f, -0.05238772f, 
    0.03781202f, 0.05172826f, 0.00936090f, -0.04853024f, -0.02870219f, 0.02088195f, 0.01110407f, 0.02346062f, 
    0.02934221f, -0.05859141f, -0.03702592f, -0.01134605f, 0.01361291f, -0.00158450f, 0.05086659f, -0.00143951f, 
    -0.02747521f, -0.02937660f, -0.05884138f, -0.03484767f, 0.04206190f, 0.01556716f, 0.02472581f, -0.00048307f, 
    0.04010534f, 0.02164795f, -0.00365209f, 0.05548942f, 0.00373235f, -0.03315358f, -0.05186186f, -0.03967201f, 
    -0.00943044f, 0.02292334f, -0.03374987f, 0.04961346f, -0.03526006f, -0.05071131f, -0.03128925f, -0.01171444f, 
    0.01367577f, 0.00881337f, 0.02350467f, 0.01788614f, -0.04778729f, -0.00434621f, 0.04041590f, -0.00032158f, 
    -0.02023250f, -0.05208838f, 0.03576688f, 0.04865923f, 0.00335642f, -0.04821641f, -0.04717302f, 0.00022853f, 
    -0.02563893f, -0.02462601f, -0.04485321f, -0.03619859f, -0.00243480f, -0.01118062f, -0.01717932f, 0.02824295f, 
    -0.00938380f, -0.04530269f, -0.02727097f, 0.03378822f, 0.03430926f, 0.00028781f, -0.03809233f, 0.01033755f, 
    0.00076137f, 0.02412147f, 0.01808422f, -0.04395696f, -0.03124626f, -0.01786971f, 0.02968998f, -0.05274011f, 
    0.02050210f, 0.03912874f, 0.04771218f, 0.05057445f, -0.00136978f, -0.02757686f, 0.02666601f, -0.02282527f, 
    0.04980874f, 0.01951440f, 0.01863327f, 0.00217163f, 0.03730822f, 0.03916675f, 0.03332432f, -0.04027025f, 
    -0.05318224f, -0.05477927f, 0.01082150f, -0.04485321f, -0.02153496f, 0.02294428f, 0.04877621f, -0.01958587f, 
    -0.04048358f, 0.02585836f, 0.02209786f, -0.00042244f, -0.01594162f, -0.05108253f, -0.06199162f, 0.00952070f, 
    -0.52327681f, -0.40486088f, -0.43565136f, 0.00158708f, -0.00012867f, -0.21600744f, -0.05288779f, 0.02325814f, 
    0.01170139f, -0.66025168f, -0.28382164f, -0.29028282f, -0.11251516f, 0.08884010f, -0.02059644f, -0.02581672f, 
    0.03153735f, 0.07808964f, 0.41293231f, -0.60717773f, -0.29077399f, 0.02604718f, 0.05651284f, -0.08343235f, 
    -0.04731664f, -0.05365207f, -0.07072931f, -0.10921688f, -0.04137931f, 0.02290033f, 0.11421099f, 0.20172814f, 
    0.09280331f, 0.02594166f, -0.03607144f, 0.17207202f, 0.05577975f, 0.14851469f, 0.03784135f, 0.10732886f, 
    0.17010297f, 0.17167044f, 0.11894482f, 0.07283072f, -0.02700371f, -0.43025348f, -0.41264886f, -0.47802237f, 
    -0.08906407f, -0.01140111f, 0.02269614f, -0.12645069f, -0.07968487f, 0.05360371f, -0.30990919f, 0.03327199f, 
    -0.10548051f, -0.06667543f, 0.07188478f, 0.00546652f, 0.11326780f, 0.06679861f, 0.07357571f, 0.20259650f, 
    0.13963051f, -0.06230485f, 0.19556375f, 0.04701013f, 0.06211685f, 0.02526274f, -0.05220994f, 0.04728626f, 
    0.32251251f, 0.15503539f, 0.12522544f, 0.06187746f, 0.15712437f, 0.16870368f, 0.26862624f, 0.12339068f, 
    0.20913680f, 0.01580499f, 0.14377798f, 0.08199266f, 0.10399498f, -0.08469941f, 0.07442512f, 0.00032359f, 
    -0.06198843f, 0.10345182f, -0.49157065f, -0.17314887f, -0.36406550f, -0.11884137f, 0.09861927f, -0.13382569f, 
    0.01292276f, -0.03621760f, 0.11423692f, 0.08776214f, 0.04334811f, -0.00398844f, -0.07392190f, -0.10472406f, 
    0.00174098f, -0.01380093f, -0.12509659f, 0.17157687f, -0.30142647f, -0.35060027f, 0.01735131f, -0.11110517f, 
    0.24853060f, 0.00684600f, 0.01205185f, -0.02627808f, 0.07876276f, 0.02167687f, 0.14416787f, -0.02842363f, 
    0.02006713f, 0.08794052f, 0.02249813f, 0.02097273f, 0.13286708f, 0.01160230f, -0.36211592f, 0.29922783f, 
    -0.29083493f, -0.16443704f, 0.10899295f, 0.01959046f, -0.09304646f, -0.07782510f, -0.08348292f, 0.21231224f, 
    -0.13055119f, -0.33430248f, 0.00237895f, -0.02286654f, -0.05459847f, 0.01426129f, -0.05031903f, 0.14194180f, 
    0.04570754f, -0.05223830f, -0.05652644f, -0.08919863f, -0.04466047f, 0.08014598f, 0.03912479f, -0.14012584f, 
    -0.05569836f, -0.13059178f, -0.17438078f, -0.22925559f, -0.11266648f, 0.05981358f, -0.03389851f, -0.06611885f, 
    -0.06113101f, -0.12393007f, -0.16816519f, 0.03288558f, 0.13135675f, -0.11225498f, -0.01235508f, -0.08571739f, 
    -0.06613752f, -0.03269833f, 0.06761450f, 0.05843325f, 0.03712411f, 0.09382050f, -0.07194450f, -0.04567195f, 
    0.14989905f, 0.00911718f, -0.04820093f, -0.12603907f, -0.17258948f, -0.02513340f, 0.08196739f, -0.13334599f, 
    -0.06101138f, -0.01231447f, -0.00984182f, 0.13087440f, 0.13193733f, -0.34865904f, 0.09917397f, 0.28088441f, 
    0.02792235f, 0.08955548f, 0.16090836f, -0.00962894f, 0.15486507f, -0.02025807f, -0.29224703f, -0.07233456f, 
    0.08246404f, 0.07855661f, 0.10815875f, 0.10330471f, 0.07760181f, 0.02752697f, 0.02259688f, -0.25059271f, 
    -0.52174711f, -0.46633330f, 0.02481422f, 0.09532059f, -0.11695173f, -0.00205772f, 0.04453495f, -0.01191824f, 
    -0.07193039f, 0.20259711f, 0.18242279f, -0.02914422f, 0.00098419f, -0.15941583f, 0.21078977f, 0.05779835f, 
    0.03151814f, -0.62025785f, -0.81929183f, -0.96355397f, 0.03093621f, -0.06101421f, -0.13417153f, -0.10256687f, 
    0.01582244f, -0.03203856f, 0.19291434f, -0.29776597f, -0.09470990f, 0.04341628f, 0.00664743f, 0.10099629f, 
    0.10740605f, 0.10345770f, 0.13785370f, 0.08426136f, 0.08141863f, -0.06295985f, -0.11026695f, -0.26406601f, 
    -0.09944960f, 0.55196989f, -0.02389756f, -0.21618421f, -0.69841534f, -0.15222813f, 0.04505085f, 0.12155288f, 
    0.04769820f, 0.02948295f, 0.05643953f, -0.07709955f, -0.10164813f, -0.00880359f, -0.25050637f, -0.86078751f, 
    -0.06212579f, 0.12259687f, -0.07342397f, -0.12996027f, 0.00037509f, 0.15881833f, 0.54361564f, -0.01580738f, 
    -0.20864521f, 0.02745592f, -0.11598569f, 0.03984525f, -0.03429833f, -0.05508406f, -0.04940078f, -0.03912466f, 
    0.04146405f, 0.01866585f, -0.11834100f, -0.01321285f, 0.07478349f, 0.08222823f, -0.03231869f, 0.07922050f, 
    -0.03491476f, 0.00616251f, 0.00868527f, -0.03187301f, -0.06209455f, -0.03142023f, -0.04767188f, 0.04213055f, 
    0.02582501f, -0.04293126f, -0.04978245f, 0.03147571f, -0.03873888f, 0.03190828f, 0.05322315f, 0.04031297f, 
    0.01386377f, 0.04135416f, -0.04606023f, -0.06430949f, -0.02799288f, 0.01537334f, -0.03820873f, -0.00047253f, 
    0.04040428f, -0.00953231f, -0.04779859f, 0.05083514f, 0.01186813f, 0.01338098f, -0.04257844f, 0.02827550f, 
    -0.03120069f, 0.00219328f, -0.03249267f, -0.04898931f, 0.03305486f, 0.00350787f, -0.00279154f, -0.01095463f, 
    0.01591548f, -0.04144215f, -0.06014153f, -0.02281981f, -0.06062413f, 0.02775112f, -0.04577991f, -0.04308558f, 
    0.02609872f, 0.01010589f, -0.03931867f, -0.05312336f, 0.02356212f, -0.00117526f, 0.01015908f, 0.00878911f, 
    -0.06155961f, 0.00970025f, 0.03484538f, -0.03538546f, 0.01742596f, -0.05444722f, 0.04288213f, -0.04905178f, 
    -0.05020061f, 0.01588912f, -0.06329378f, -0.04581985f, -0.01039523f, 0.04016762f, -0.05201609f, -0.05080098f, 
    -0.05736740f, -0.04227621f, 0.04664731f, -0.05210311f, -0.04144770f, 0.03852852f, 0.03751511f, 0.04213234f, 
    -0.02134367f, -0.03864118f, -0.02328535f, -0.02683628f, -0.06434655f, -0.02753090f, 0.01161288f, -0.03148403f, 
    0.00391860f, -0.04543514f, -0.05900542f, 0.05234325f, 0.04874654f, -0.04620914f, -0.03960977f, 0.05249894f, 
    0.00618034f, -0.04638342f, -0.04969526f, 0.01261186f, 0.00421782f, 0.02150533f, 0.00818914f, -0.04030273f, 
    -0.04907079f, -0.05030579f, -0.00475494f, -0.04306240f, -0.02322078f, 0.05007144f, 0.05154056f, 0.03475896f, 
    0.03445123f, -0.05381152f, -0.04794365f, 0.00037936f, -0.04975918f, -0.00752885f, -0.00667712f, 0.03007128f, 
    0.03706684f, 0.04198819f, 0.03115917f, 0.01087394f, -0.04990448f, -0.04796183f, -0.00878042f, 0.00144465f, 
    -0.02112989f, 0.02664895f, 0.04700170f, 0.02399402f, -0.03578599f, -0.05214741f, 0.02654278f, -0.03916393f, 
    0.02872914f, 0.04773855f, 0.02830835f, -0.03994399f, -0.06272639f, -0.03616194f, -0.01364103f, -0.01218050f, 
    -0.00964621f, 0.01366378f, -0.01346456f, -0.05554042f, -0.04122665f, -0.00251797f, 0.03746010f, -0.04188797f, 
    0.01261724f, 0.03655479f, -0.02268954f, 0.04818573f, 0.04779502f, 0.03207953f, -0.02049201f, -0.01111393f, 
    0.02455192f, 0.04263697f, -0.04202442f, 0.03710631f, -0.01505459f, 0.05237126f, 0.02124246f, 0.03825831f, 
    -0.04263141f, 0.03139304f, -0.04547480f, -0.04491335f, -0.00510681f, 0.01892994f, -0.03881852f, -0.05798325f, 
    0.01785810f, 0.03120455f, -0.01624260f, 0.04794725f, 0.02598812f, 0.00459974f, -0.05352074f, -0.05499455f, 
    0.00167232f, 0.05165794f, -0.01926373f, -0.05051197f, -0.00304119f, -0.01627754f, 0.01425524f, 0.02466089f, 
    0.01084177f, -0.05764178f, -0.04202939f, -0.03672386f, -0.01071901f, 0.03109118f, -0.05378021f, 0.00923229f, 
    0.00793421f, 0.02046023f, -0.06190869f, -0.01760908f, 0.01793209f, -0.04523720f, -0.01273776f, 0.00291053f, 
    -0.00262841f, -0.02478114f, 0.02802425f, 0.02914145f, -0.04199371f, -0.03255117f, 0.00610150f, 0.02855933f, 
    -0.04050955f, 0.00733571f, 0.02938545f, -0.01970960f, -0.01491003f, -0.04737455f, 0.01133158f, -0.05183385f, 
    0.01314386f, 0.03965465f, -0.01037190f, 0.02901560f, 0.00336850f, -0.01735212f, -0.04904322f, 0.04976853f, 
    -0.05422264f, -0.01597453f, -0.06064813f, 0.02417625f, -0.06131528f, -0.01726477f, 0.01926702f, -0.05862209f, 
    -0.04536011f, -0.03288490f, -0.02140027f, 0.00548128f, 0.03900023f, -0.04208750f, -0.05045627f, -0.05680121f, 
    0.04380146f, -0.01977199f, 0.00805451f, -0.01528293f, 0.01948110f, 0.00649475f, -0.05270866f, -0.01571774f, 
    -0.05993915f, -0.00189674f, -0.03403865f, 0.03940941f, -0.03303942f, 0.01382323f, 0.02082295f, -0.05053150f, 
    0.02353513f, 0.04532007f, -0.02181890f, -0.01355377f, -0.02243587f, -0.03823471f, 0.01955235f, -0.03664705f, 
    0.00931707f, -0.02793672f, 0.02505439f, 0.02049441f, -0.03642512f, -0.02164714f, 0.04762202f, 0.02343128f, 
    -0.05898361f, -0.01444778f, -0.04378776f, -0.04221727f, -0.05246886f, -0.02365119f, -0.00104436f, -0.04482863f, 
    -0.14705190f, -0.10865722f, 0.22058147f, -0.00720763f, 0.04122108f, -0.06578847f, -0.01314943f, 0.14810660f, 
    0.05929495f, 0.23027435f, 0.01337867f, 0.23219623f, -0.06292919f, -0.04832980f, 0.01136548f, 0.01694051f, 
    -0.03660319f, 0.08435902f, 0.06178736f, -0.01795377f, 0.00884882f, -0.17604062f, 0.00772688f, 0.14974914f, 
    -0.08793513f, 0.00713935f, -0.06195794f, -0.12119035f, 0.11835700f, 0.16890331f, 0.07078414f, 0.04953260f, 
    0.06040451f, 0.13465384f, -0.03702671f, 0.21963853f, -0.15753224f, -0.05702604f, 0.05212576f, -0.02677043f, 
    -0.04470566f, -0.03501709f, 0.02283032f, 0.02581515f, -0.10411863f, 0.26245785f, -0.12393977f, 0.14688750f, 
    0.08857048f, -0.09265782f, 0.04823279f, -0.00038080f, 0.01420391f, 0.11098084f, 0.02030919f, 0.08353687f, 
    0.15169355f, 0.04484393f, -0.01655787f, -0.14718771f, 0.01955640f, 0.16107750f, -0.02255533f, 0.04009058f, 
    0.03912729f, 0.08248666f, 0.02597213f, -0.01236202f, 0.09115224f, -0.03191889f, 0.00604667f, 0.01297892f, 
    0.17202501f, 0.25555724f, -0.13252948f, -0.06915402f, 0.12217943f, -0.14072032f, 0.02444354f, -0.03228922f, 
    -0.10312921f, -0.08013608f, -0.01217616f, -0.08704430f, 0.00691461f, -0.01775781f, -0.00570121f, 0.06591745f, 
    0.00539394f, -0.03406990f, -0.19127244f, -0.29455617f, -0.00656824f, -0.25535282f, 0.16283506f, 0.05419370f, 
    0.02954248f, 0.14158769f, 0.39930913f, -0.08462369f, 0.15183297f, -0.00075598f, -0.06313804f, -0.10552220f, 
    0.00983565f, -0.01123202f, 0.01222870f, 0.04056278f, -0.08858719f, -0.13419008f, 0.10944090f, -0.07226979f, 
    -0.00836811f, -0.05543072f, -0.01465660f, 0.03455220f, 0.03184838f, -0.05437294f, -0.01415574f, -0.18685517f, 
    -0.03705995f, 0.01050963f, -0.04959337f, 0.02962046f, -0.00332954f, -0.05139044f, -0.04725946f, 0.02420949f, 
    0.27685693f, -0.04249141f, -0.08639175f, -0.01127484f, -0.24584953f, -0.13082482f, -0.19973949f, 0.09834140f, 
    -0.00826882f, 0.03356758f, 0.01738327f, 0.00873593f, 0.16523974f, 0.01619815f, 0.13740626f, 0.08784303f, 
    -0.06233506f, -0.08542703f, 0.04986492f, -0.05084214f, 0.01466504f, 0.04494765f, 0.01905775f, 0.04330226f, 
    -0.07321829f, -0.18154903f, 0.11495699f, 0.05258695f, -0.01206577f, -0.00619383f, -0.19266605f, -0.04048244f, 
    -0.27077615f, -0.23113608f, -0.40273750f, 0.18577269f, 0.11047133f, 0.13520010f, -0.06927202f, 0.04495747f, 
    -0.05351819f, 0.11038965f, 0.08495475f, -0.06213109f, 0.01638478f, 0.10445561f, -0.00146547f, -0.05434482f, 
    -0.11155526f, -0.01808907f, -0.14549056f, 0.02740457f, -0.06387768f, -0.13318734f, -0.24777630f, -0.03245546f, 
    0.11385215f, 0.15004458f, -0.02254043f, 0.11035568f, 0.25575343f, 0.00750386f, -0.06674572f, 0.01695644f, 
    -0.06038278f, -0.01790901f, -0.05292753f, -0.04407524f, 0.00097604f, 0.13799053f, -0.07825675f, 0.03912139f, 
    0.12573718f, 0.00407460f, -0.01662861f, -0.01421500f, -0.00157239f, 0.20267721f, 0.12142015f, 0.16554654f, 
    0.15376669f, 0.11721302f, 0.00236558f, -0.01562681f, -0.03720367f, -0.07855280f, -0.10589357f, 0.09800964f, 
    -0.10439155f, 0.20746757f, 0.20117016f, -0.02314251f, 0.04727120f, 0.01253366f, 0.03026950f, 0.13843819f, 
    -0.01822253f, 0.02349615f, -0.11794665f, 0.06557307f, 0.13214324f, 0.06739389f, -0.03685609f, 0.04110400f, 
    -0.05684340f, 0.04693679f, -0.05591221f, 0.20150919f, -0.07225502f, 0.03656026f, -0.03201626f, -0.20612460f, 
    0.08537384f, 0.24188165f, 0.28362197f, -0.21250787f, 0.25459445f, 0.28901726f, 0.00269564f, -0.05596435f, 
    -0.17345670f, -0.03156605f, 0.01631404f, -0.04473232f, -0.05792443f, -0.00309440f, 0.09334057f, 0.01009799f, 
    0.11656654f, -0.10400607f, 0.03351274f, -0.11004061f, -0.06570041f, 0.11557019f, -0.02173440f, 0.14012025f, 
    -0.13304800f, 0.02978216f, 0.04556349f, -0.02938172f, 0.01523732f, 0.17274714f, -0.04341294f, 0.01035987f, 
    0.08297256f, -0.06141806f, 0.03247103f, 0.17045729f, -0.19978033f, 0.08397099f, -0.09245215f, 0.02117682f, 
    0.13143912f, -0.02165350f, 0.04198949f, 0.02720021f, -0.02409362f, 0.02079500f, -0.12147945f, -0.05318987f, 
    -0.07091793f, -0.11874501f, -0.28388587f, -0.09706981f, 0.05053480f, -0.04890522f, 0.09415433f, -0.07236832f, 
    0.04889913f, -0.11610703f, 0.20534353f, -0.05970114f, -0.31126201f, -0.22889166f, -0.20651950f, 0.06194097f, 
    0.08612569f, -0.05542038f, 0.21738882f, 0.33495998f, 0.03814869f, -0.14559855f, -0.03545391f, -0.23861420f, 
    -0.04174313f, 0.04212365f, -0.11980935f, 0.16080573f, -0.07492427f, 0.17296809f, 0.02131652f, 0.08676056f, 
    0.11779323f, 0.09719945f, 0.05884439f, 0.15553714f, 0.16955501f, 0.04198646f, 0.13188945f, -0.05279194f, 
    0.09260692f, 0.10550532f, 0.03809935f, 0.09905172f, -0.13390493f, 0.04676539f, 0.32312635f, -0.19040066f, 
    -0.21495311f, -0.20146269f, 0.00831840f, 0.02989446f, 0.18932153f, -0.08549279f, -0.02328033f, 0.26670101f, 
    0.26181206f, -0.02067528f, -0.21719474f, -0.06610804f, 0.02171095f, -0.05322685f, 0.05452976f, 0.33296946f, 
    -0.09019682f, 0.16952001f, 0.13075903f, 0.06812991f, 0.26037619f, -0.09525912f, 0.05997026f, -0.12680107f, 
    -0.20477293f, -0.02387734f, -0.11626213f, 0.11795091f, 0.25134620f, -0.13468508f, -0.01072714f, -0.01731520f, 
    0.00564587f, 0.27467102f, 0.18994807f, 0.17116410f, -0.02092723f, -0.01815979f, -0.07677519f, -0.04208676f, 
    0.12844951f, 0.12490068f, 0.04617958f, -0.31421676f, -0.05328646f, 0.13850720f, -0.04255528f, 0.10043877f, 
    -0.15133546f, 0.09785262f, 0.00084820f, 0.36018744f, 0.28035879f, 0.17547670f, -0.00737659f, -0.01961198f, 
    -0.09988722f, 0.09284855f, 0.07645999f, -0.04913029f, -0.13411683f, -0.05758728f, 0.15771419f, -0.06636123f, 
    0.02260670f, 0.08106188f, -0.03461578f, 0.05132093f, -0.16072905f, 0.02967308f, 0.22238585f, 0.13959330f, 
    0.05323548f, 0.02340676f, -0.01778267f, -0.04636857f, -0.01453402f, 0.04352468f, -0.20905605f, -0.11936729f, 
    0.01293426f, -0.03216638f, -0.12991220f, 0.12405695f, 0.03131342f, 0.04133351f, -0.23617835f, -0.23400484f, 
    0.24528396f, 0.02036632f, 0.05405902f, 0.14836803f, -0.09425008f, -0.07665351f, 0.13640335f, 0.18314937f, 
    -0.01303439f, 0.15162772f, -0.12399714f, 0.00752233f, -0.12817229f, 0.18243740f, 0.16705666f, -0.07099970f, 
    0.03156291f, -0.29701093f, -0.07453550f, -0.15143013f, 0.10148568f, -0.03081967f, -0.11676590f, 0.17025448f, 
    0.03309234f, -0.09742046f, 0.00518999f, -0.19067468f, 0.31568134f, -0.02356606f, -0.02975174f, -0.01663912f, 
    -0.02239570f, -0.08759604f, 0.21959886f, 0.05418282f, 0.14717996f, 0.11052877f, 0.03141212f, -0.07397744f, 
    -0.07418227f, 0.12981212f, -0.07884303f, 0.00905216f, -0.15596458f, -0.20155843f, -0.24016722f, 0.00916019f, 
    -0.00665426f, -0.04027900f, -0.13066624f, 0.00267542f, 0.22305544f, -0.22770213f, -0.08353709f, -0.01051182f, 
    -0.07630350f, -0.02547229f, -0.02622174f, -0.16186927f, 0.01849448f, -0.01023205f, 0.00068783f, 0.12488306f, 
    0.03603616f, -0.17143559f, 0.10660817f, 0.13089862f, 0.09036528f, 0.17377762f, -0.15681319f, -0.26560906f, 
    -0.09884386f, -0.11939746f, -0.14083405f, -0.04766255f, -0.02312656f, -0.02601846f, 0.02810009f, -0.02950259f, 
    -0.01318405f, 0.21924613f, 0.39616394f, -0.16051163f, 0.12570214f, 0.00454548f, 0.04121334f, -0.01745737f, 
    -0.07363811f, 0.05568936f, 0.18553194f, -0.11348230f, -0.23035292f, 0.02499476f, -0.10098191f, 0.00990375f, 
    0.03457696f, 0.02307322f, -0.11652879f, -0.25440255f, 0.28067505f, -0.12278162f, 0.05685130f, -0.23182350f, 
    -0.00914083f, 0.11580056f, 0.07500958f, 0.19868767f, 0.02018950f, 0.34812427f, -0.12124244f, -0.15691099f, 
    -0.06444629f, -0.04635329f, 0.06500573f, -0.20818035f, -0.43057543f, -0.03958996f, 0.28321207f, -0.02886522f, 
    -0.13158613f, -0.13180450f, 0.02647636f, 0.04567080f, -0.14831597f, -0.02811488f, 0.02696647f, -0.34098563f, 
    -0.26756942f, -0.20221327f, 0.14260510f, 0.13266852f, 0.04663316f, -0.02410757f, 0.43484819f, 0.15030792f, 
    0.10389844f, 0.04592390f, -0.06213672f, 0.04033051f, 0.02469748f, 0.07645424f, -0.04451909f, -0.09925678f, 
    0.09284061f, -0.14481094f, -0.02058129f, 0.00870930f, -0.05678453f, -0.12295270f, -0.04395624f, 0.08410998f, 
    0.22252984f, 0.10227083f, 0.09760119f, -0.03696549f, 0.00646588f, 0.04062934f, 0.09727666f, -0.09443247f, 
    -0.08655237f, -0.24945499f, 0.11159895f, 0.20722331f, -0.01868204f, -0.18459280f, -0.21765970f, -0.02043246f, 
    -0.06320591f, 0.03042623f, -0.28257090f, -0.07286859f, -0.07625540f, -0.27361557f, -0.04855271f, -0.11541969f, 
    -0.07700600f, 0.08041865f, 0.14159279f, -0.07010535f, -0.29803124f, -0.12860404f, 0.02124668f, 0.13468280f, 
    -0.03931623f, 0.04560145f, -0.02242822f, 0.11599158f, -0.04747341f, -0.07705611f, -0.03919364f, -0.02776997f, 
    0.07404045f, -0.13276964f, -0.02832624f, 0.02551088f, 0.11741286f, 0.21890116f, 0.12321183f, 0.26791587f, 
    -0.01245929f, 0.07545526f, -0.13747822f, 0.01406278f, 0.00029673f, -0.10969388f, -0.16261759f, 0.01419326f, 
    -0.14401616f, -0.17651662f, -0.17723888f, -0.09474017f, 0.06694609f, 0.04325079f, -0.00752841f, -0.24530213f, 
    0.12697756f, -0.11748799f, 0.01808472f, 0.12862876f, -0.07720653f, -0.15782332f, -0.02505404f, 0.07779853f, 
    0.03667163f, -0.00467716f, -0.00028916f, -0.08806212f, -0.08960988f, 0.09535939f, 0.10813161f, 0.09941477f, 
    0.05768503f, -0.02631590f, 0.06136031f, -0.09827732f, 0.11828541f, 0.00257601f, -0.21265477f, 0.05832641f, 
    0.00347300f, 0.06690631f, 0.36115053f, -0.13204566f, 0.01660676f, 0.18801105f, 0.04609809f, 0.09415828f, 
    0.01619090f, 0.07552271f, -0.05593105f, -0.21071534f, -0.34609017f, -0.16152354f, 0.15380098f, -0.14122893f, 
    -0.10688952f, -0.02999584f, -0.04402177f, 0.05367051f, 0.06299766f, 0.03630114f, -0.01790226f, 0.02647805f, 
    0.06248184f, 0.11346576f, -0.05483522f, -0.09219068f, 0.11290664f, -0.10222913f, -0.18861623f, -0.15239096f, 
    0.30455256f, -0.10628443f, -0.09345108f, 0.13291202f, 0.13336821f, -0.05111275f, -0.05936861f, 0.10232159f, 
    -0.41591892f, 0.04062090f, -0.04743415f, 0.05325150f, -0.08397216f, 0.07926452f, -0.02841553f, 0.34041464f, 
    0.02541815f, 0.17169492f, 0.01735038f, 0.00426195f, 0.01837826f, 0.11786716f, -0.02143692f, 0.07333456f, 
    0.11907988f, -0.13863018f, -0.31066838f, 0.11389526f, -0.20829865f, 0.02789936f, 0.09789643f, 0.02705575f, 
    -0.11410590f, 0.08757164f, 0.19144003f, 0.04399508f, -0.11523617f, -0.07814284f, -0.02756936f, -0.13008197f, 
    -0.05865872f, 0.04413275f, 0.32761556f, -0.19889513f, -0.17437027f, -0.07820097f, -0.01888415f, -0.14624253f, 
    -0.04134179f, 0.03800308f, 0.03135529f, 0.12774797f, -0.02667722f, 0.10301560f, -0.11019224f, -0.07333616f, 
    0.07981443f, 0.00860453f, 0.02164255f, -0.03982608f, 0.28272986f, -0.10995439f, -0.20506977f, 0.05035026f, 
    -0.01699341f, -0.08596689f, -0.03579856f, -0.00656547f, 0.04775718f, 0.10965969f, -0.04397474f, -0.18596138f, 
    0.09911550f, 0.05842628f, 0.00027742f, 0.01653683f, -0.03026250f, -0.05226283f, 0.01375653f, -0.10471956f, 
    -0.05902426f, 0.08020642f, 0.13452800f, 0.07478068f, -0.06074059f, -0.05179761f, 0.09984563f, 0.03204843f, 
    0.07530653f, 0.09050842f, -0.11885848f, -0.07855778f, -0.02324159f, 0.03721159f, 0.06826914f, 0.12914631f, 
    0.05246864f, 0.13157974f, -0.14876078f, 0.04086357f, 0.06313485f, -0.10468072f, 0.03055522f, 0.09605407f, 
    0.22873327f, 0.23546261f, 0.26526254f, 0.22338066f, 0.02134878f, 0.05110400f, 0.13742656f, 0.04498406f, 
    -0.04034677f, -0.04080371f, 0.29008108f, 0.12185847f, -0.10369088f, -0.10139260f, 0.00928878f, 0.07421596f, 
    0.09455118f, -0.04064691f, 0.00349990f, -0.13370286f, -0.00229163f, -0.06663383f, 0.08186058f, -0.34588638f, 
    0.20439483f, -0.12807716f, 0.27700335f, 0.06717154f, 0.00279107f, 0.12051995f, 0.09858438f, 0.00107468f, 
    -0.05723716f, 0.08409674f, -0.01627983f, -0.09644652f, -0.06088351f, 0.02744984f, 0.17728342f, 0.13641155f, 
    0.02438110f, 0.05405959f, 0.07367721f, 0.04174993f, -0.16869111f, -0.02883650f, -0.38001192f, -0.40629852f, 
    -0.32230255f, 0.06907959f, -0.27593085f, -0.18642507f, -0.00457451f, 0.18666212f, 0.02657191f, -0.03543612f, 
    -0.26102445f, -0.30442712f, -0.06825338f, 0.02352505f, 0.03654100f, 0.03879059f, -0.03519015f, 0.06522349f, 
    -0.18562835f, -0.27773616f, -0.27664492f, 0.02940168f, 0.12121829f, 0.20441663f, 0.03489688f, 0.01488533f, 
    -0.00916059f, -0.00290662f, -0.01107268f, 0.69086421f, 0.04979881f, -0.09985802f, -0.06781933f, 0.08125948f, 
    0.07373525f, 0.08077299f, -0.23119646f, 0.21240823f, 0.10003616f, 0.10389743f, -0.00710326f, -0.11030392f, 
    0.05793860f, 0.03601668f, 0.06877370f, 0.02659312f, 0.44296649f, -0.34805360f, 0.08422008f, 0.30994478f, 
    0.02360489f, -0.04572914f, 0.00912007f, -0.11968789f, -0.04319201f, 0.07303055f, -0.09303492f, 0.10680986f, 
    0.05026618f, -0.02732952f, 0.03850703f, 0.15188815f, -0.04998213f, 0.15369171f, 0.11241812f, -0.42470360f, 
    -0.14155999f, -0.04827702f, 0.14313862f, 0.06388953f, -0.05697834f, -0.02106376f, -0.11506024f, 0.33017978f, 
    -0.11774898f, -0.07728302f, -0.05018846f, 0.11448833f, 0.04605216f, 0.02835348f, 0.05069401f, -0.23364416f, 
    0.20542464f, 0.02946581f, -0.00113883f, 0.15943401f, -0.02215085f, 0.05303968f, 0.15055968f, 0.04970689f, 
    0.24735416f, 0.20380732f, 0.02460220f, 0.06834073f, 0.08619681f, 0.09052199f, 0.06991687f, 0.14810987f, 
    0.04757501f, 0.03085683f, 0.23258144f, 0.07002485f, -0.03303540f, -0.00873784f, -0.03765948f, 0.08787555f, 
    -0.10928993f, -0.02934158f, -0.19883882f, -0.30626354f, -0.55407131f, -0.23525707f, 0.02003922f, 0.05226684f, 
    -0.00806000f, 0.00910227f, -0.01046963f, -0.06929716f, 0.14264220f, 0.06665576f, -0.06740917f, -0.08335597f, 
    -0.11015730f, 0.00397116f, 0.04338068f, 0.03274595f, 0.02562813f, -0.04625231f, -0.32003853f, 0.07447816f, 
    0.02200492f, 0.09370749f, -0.08018535f, -0.08863583f, -0.11135881f, -0.01353999f, -0.07625122f, 0.13422896f, 
    0.07241137f, -0.02157944f, -0.22007787f, 0.05042060f, 0.10233022f, 0.04416141f, -0.20512880f, -0.41246548f, 
    -0.15137443f, -0.08220064f, 0.17055514f, 0.01802213f, 0.03243270f, 0.02133974f, -0.10766900f, -0.27882606f, 
    -0.27046677f, -0.39336145f, 0.04902565f, -0.13880056f, -0.00842809f, 0.17706397f, 0.01340503f, 0.09600235f, 
    0.13923526f, 0.11309164f, -0.25608391f, -0.16032305f, 0.12226906f, -0.10182208f, 0.03602786f, 0.14031160f, 
    -0.08683268f, -0.30617484f, 0.03034818f, 0.19582890f, -0.09301633f, -0.06228070f, 0.10756849f, 0.01015661f, 
    0.06308178f, 0.04335929f, -0.33730251f, 0.21619502f, 0.19863516f, -0.01114102f, 0.03313059f, -0.01866951f, 
    0.05596170f, 0.13185781f, 0.18272160f, 0.09954932f, 0.02610661f, -0.10268745f, -0.06073210f, 0.02614702f, 
    0.03163196f, -0.06053025f, 0.03080172f, 0.05898636f, -0.07571884f, -0.26970196f, -0.16030332f, -0.07626034f, 
    0.00345177f, 0.06981210f, 0.00313526f, -0.07096624f, 0.04332448f, 0.13329346f, -0.53982055f, -0.75385451f, 
    -0.17256910f, -0.02310068f, 0.00860982f, -0.05302636f, -0.08715442f, -0.00080516f, -0.16820619f, -0.27857384f, 
    -0.57536715f, 0.03298600f, 0.14448375f, 0.13237152f, 0.03385104f, -0.03064440f, -0.11365665f, 0.09067342f, 
    0.26854506f, 0.14459598f, -0.01619101f, 0.16481315f, 0.05851081f, -0.08383851f, 0.16097914f, 0.13702317f, 
    -0.24819778f, 0.57322431f, -0.38782579f, 0.12654762f, 0.09428111f, 0.03288917f, 0.16340956f, 0.18153772f, 
    -0.04368003f, 0.45282593f, -0.03448418f, -0.11819799f, -0.29596001f, -0.01719485f, 0.08187073f, 0.00284494f, 
    -0.07326416f, -0.03789681f, -0.31489474f, 0.32517937f, -0.35108662f, 0.03879663f, -0.04053304f, 0.22896071f, 
    0.12323672f, -0.09208355f, -0.24786361f, -0.05525083f, 0.33317277f, 0.00618162f, -0.15730572f, 0.19695783f, 
    -0.04387153f, 0.10072864f, 0.16278176f, -0.07294559f, -0.17692515f, -0.18017958f, -0.08206309f, -0.18312904f, 
    0.06634456f, -0.08014079f, -0.01602067f, 0.02858016f, -0.01163570f, 0.11580121f, -0.02671236f, 0.18475600f, 
    -0.01387377f, 0.02289256f, 0.17025538f, -0.00969421f, 0.03757164f, 0.00012526f, -0.07028342f, -0.05619449f, 
    -0.00666940f, -0.01021757f, 0.10297807f, -0.19684510f, 0.13102181f, 0.02571338f, 0.06050496f, 0.33052072f, 
    -0.06469508f, -0.22213301f, -0.12279636f, -0.07818995f, -0.07613528f, 0.04309800f, -0.12585679f, 0.11980044f, 
    -0.03462944f, 0.12891318f, 0.34094763f, -0.12668410f, 0.00141143f, -0.00836686f, 0.15596344f, 0.02214149f, 
    -0.28172737f, -0.14855437f, -0.02646079f, 0.12695931f, -0.00453387f, -0.00634017f, -0.05297062f, -0.01174854f, 
    -0.05857680f, -0.08769963f, -0.28524414f, 0.01658434f, 0.07828335f, 0.00348930f, -0.06264138f, -0.07269295f, 
    -0.03815086f, -0.15111393f, 0.04044213f, -0.07743444f, -0.21706815f, -0.00930922f, 0.20994252f, 0.12645049f, 
    -0.07870355f, -0.09941620f, -0.03670760f, 0.15289675f, -0.08704076f, -0.09114494f, -0.16421269f, -0.10590617f, 
    0.10212000f, 0.03033676f, -0.14902969f, -0.05060589f, 0.10474385f, 0.18258254f, -0.23507147f, -0.01804318f, 
    0.09434418f, -0.14432453f, -0.09992757f, -0.00053835f, 0.00519687f, -0.11989963f, 0.01998595f, -0.08948396f, 
    0.11449925f, -0.05136486f, 0.04648004f, 0.08591692f, -0.07352341f, 0.02515525f, -0.05548290f, -0.10582517f, 
    -0.06696138f, 0.01391725f, 0.04726396f, 0.06132699f, 0.02072248f, 0.13949843f, 0.02507925f, 0.04066784f, 
    0.01545711f, -0.06318959f, 0.09769619f, 0.06235691f, -0.09732039f, -0.03528269f, 0.09991649f, 0.12223788f, 
    0.08423787f, -0.06564096f, -0.17776078f, -0.00858783f, 0.03637627f, 0.05534527f, -0.04466304f, -0.13272077f, 
    0.09449887f, 0.16906105f, 0.05094519f, -0.03930821f, 0.18663549f, 0.13737187f, -0.11301406f, 0.00695518f, 
    0.06350446f, 0.10742657f, 0.00888250f, -0.10275052f, -0.14580566f, 0.08525327f, 0.01988237f, -0.08684956f, 
    -0.03287872f, 0.04458328f, 0.01979001f, 0.12828887f, 0.10738008f, 0.17856015f, 0.03701810f, 0.15303552f, 
    0.14635779f, 0.10429052f, 0.07762364f, 0.02282676f, 0.14955325f, -0.16085505f, -0.14173704f, -0.43172717f, 
    0.09661575f, 0.03966076f, -0.12314563f, 0.08666069f, 0.13584451f, 0.08896221f, -0.12659881f, -0.09015606f, 
    -0.02124023f, 0.08128886f, 0.02030402f, 0.04551509f, 0.09150953f, 0.07644983f, 0.02493519f, 0.01036422f, 
    0.02639950f, -0.01455242f, 0.15427966f, -0.01024463f, -0.16339143f, 0.16560626f, 0.08856566f, 0.01127462f, 
    -0.20399815f, -0.27647859f, -0.39914677f, 0.06807178f, 0.02156645f, 0.12403723f, -0.03503814f, 0.17804319f, 
    -0.01224726f, 0.19230728f, 0.23528211f, 0.12184939f, -0.01784038f, 0.00534939f, 0.14621930f, -0.04313228f, 
    -0.05204129f, -0.04703615f, 0.02178903f, -0.07363282f, -0.19249852f, 0.16923086f, 0.01939720f, 0.03292908f, 
    0.08673060f, 0.07294329f, 0.09196536f, 0.08904861f, -0.13152206f, -0.14406213f, 0.04821233f, 0.06082854f, 
    0.06967083f, 0.06269499f, 0.01699527f, 0.05772281f, 0.07890267f, -0.06014153f, -0.00158489f, 0.10949831f, 
    0.07530164f, -0.04957561f, 0.06052508f, -0.03923980f, -0.00581905f, -0.04401583f, -0.10392299f, 0.18910617f, 
    0.12606594f, 0.10514080f, 0.10395698f, 0.08521385f, 0.04370144f, 0.05913130f, -0.00114862f, 0.21525082f, 
    0.14791201f, 0.09102180f, 0.13074808f, 0.01587903f, 0.01244864f, 0.00390249f, -0.04264953f, 0.25042880f, 
    0.20403834f, 0.16033365f, -0.05576243f, 0.00723341f, 0.07114596f, -0.00023880f, 0.00483620f, -0.14796165f, 
    0.00692050f, 0.26750481f, 0.04124535f, -0.05350372f, 0.16626467f, -0.06249966f, -0.12675036f, 0.09134218f, 
    -0.15342820f, -0.09632508f, 0.05917756f, 0.28817749f, -0.09601278f, 0.07194396f, -0.12921533f, 0.16609664f, 
    0.07191929f, -0.05000339f, 0.17104876f, 0.07858656f, 0.11556084f, 0.00728698f, 0.01780417f, -0.07645552f, 
    0.01642797f, 0.04897714f, -0.12417948f, 0.10595928f, -0.13979405f, 0.05544261f, -0.17676899f, -0.19317655f, 
    0.14394008f, 0.02195997f, 0.10402364f, 0.02462963f, 0.15060893f, 0.23183562f, 0.23697414f, -0.11799522f, 
    0.08864450f, 0.00829738f, -0.07695258f, 0.09423768f, -0.05005471f, -0.01505535f, 0.08986040f, 0.10804188f, 
    -0.03380552f, -0.04426006f, 0.10225427f, 0.03605645f, -0.05294852f, -0.09115413f, -0.14043483f, -0.19859190f, 
    -0.15940058f, -0.15398203f, -0.07934859f, -0.17631061f, 0.18007281f, 0.07651187f, -0.06196515f, -0.16438670f, 
    -0.23961098f, -0.24743548f, 0.06431742f, 0.02255787f, -0.06469112f, -0.06764481f, 0.13778794f, 0.16908053f, 
    0.09911311f, 0.00529236f, -0.19046320f, 0.08641148f, -0.06385157f, 0.02346399f, -0.05023566f, 0.04879519f, 
    -0.03465943f, 0.28068900f, -0.03996717f, -0.20431598f, 0.14188427f, 0.05540164f, 0.04118505f, -0.13991621f, 
    -0.00506434f, -0.10028455f, -0.08515807f, 0.08810621f, 0.05765954f, -0.02980857f, 0.08946507f, -0.06962676f, 
    0.08108070f, 0.21689698f, 0.03310083f, -0.08238178f, -0.15922569f, -0.01256616f, 0.10762570f, -0.06864310f, 
    0.06126700f, 0.09784026f, -0.02224456f, 0.01548285f, -0.06732447f, -0.03143078f, 0.00546439f, -0.04237243f, 
    0.01645475f, -0.02240030f, 0.03001591f, 0.17346540f, 0.05323713f, 0.34223974f, 0.12625602f, -0.23942158f, 
    0.08833484f, 0.03323971f, 0.12326634f, 0.10131127f, 0.02700424f, -0.16168684f, -0.12715693f, -0.34179252f, 
    0.08672030f, 0.00966160f, 0.00379061f, 0.01131221f, 0.06680363f, 0.06176882f, -0.02570189f, -0.04775242f, 
    -0.11543040f, -0.00086392f, -0.03214426f, 0.05616528f, 0.06744861f, 0.08312152f, -0.01461338f, 0.08137862f, 
    0.35589242f, 0.07335953f, -0.12171794f, 0.18877052f, 0.04443967f, -0.12805718f, -0.01704992f, -0.02736783f, 
    -0.15121336f, -0.14221448f, -0.10968424f, 0.27518862f, 0.03052659f, -0.02017523f, 0.06592926f, -0.09226609f, 
    -0.08997997f, -0.13102306f, 0.02560987f, -0.01745944f, 0.13811342f, -0.07986244f, -0.13546668f, 0.00640149f, 
    0.01315040f, -0.10163702f, 0.09349235f, -0.40814874f, -0.04281901f, 0.06493913f, 0.00037716f, -0.05350444f, 
    0.02070331f, -0.11378061f, 0.04002014f, -0.11263417f, 0.16356619f, -0.08089641f, -0.20020427f, 0.00589920f, 
    -0.07710435f, -0.08367629f, -0.00307965f, 0.02514756f, 0.11423034f, -0.12634550f, 0.15960045f, -0.07956666f, 
    0.13466729f, 0.03005956f, -0.05179865f, 0.03796642f, -0.11936115f, -0.09617332f, 0.12644713f, -0.21714322f, 
    -0.05697705f, 0.06215083f, 0.03474135f, -0.05815499f, 0.02459531f, 0.03148989f, -0.03287730f, 0.17327602f, 
    0.19920073f, -0.14920449f, 0.06946851f, 0.17686997f, 0.07364143f, -0.08401058f, -0.11687917f, -0.37139714f, 
    -0.09748503f, 0.02367007f, 0.04310433f, 0.10072426f, -0.05629424f, 0.01951761f, 0.01207151f, -0.11255985f, 
    0.08321939f, 0.01960706f, -0.09973905f, -0.03626356f, -0.16766495f, 0.00678134f, -0.00810019f, 0.13657656f, 
    0.06314208f, 0.12343627f, -0.30891937f, -0.12776338f, 0.13554491f, 0.04508452f, 0.11864493f, 0.10204273f, 
    -0.02517872f, -0.14624701f, -0.30966866f, -0.12303936f, 0.01509397f, 0.08689331f, 0.05911658f, -0.01330359f, 
    -0.01116298f, 0.05143322f, 0.13524112f, 0.22157291f, -0.08162105f, -0.13131058f, 0.01745669f, 0.02434746f, 
    0.00510492f, 0.01543002f, -0.06723064f, -0.11369870f, -0.16841644f, 0.08789714f, -0.14620361f, -0.05490118f, 
    0.00047240f, 0.04479151f, -0.07935168f, 0.07474642f, -0.05560860f, 0.07253069f, -0.03749582f, -0.08383219f, 
    -0.20741615f, 0.03268128f, -0.07771157f, 0.03927583f, -0.05069777f, 0.02538630f, -0.04958417f, 0.34432995f, 
    0.11364148f, -0.18444362f, 0.03628618f, 0.15090983f, -0.00686172f, 0.08333600f, 0.12450399f, 0.01844096f, 
    0.03292045f, -0.08179673f, -0.30257481f, -0.01491586f, -0.03922313f, 0.07452476f, 0.07774072f, -0.05414722f, 
    -0.00341876f, 0.34553921f, 0.07108267f, -0.26838499f, -0.02908614f, 0.10635177f, 0.05124860f, 0.04290679f, 
    0.11774315f, -0.03141846f, 0.02364451f, -0.00989884f, -0.16060396f, -0.01136326f, -0.05520016f, 0.03848782f, 
    0.01015404f, 0.00228680f, 0.01150217f, -0.09841023f, -0.21798244f, 0.02139666f, 0.17107561f, -0.09432299f, 
    -0.15469944f, 0.15369324f, 0.03125404f, 0.04848461f, 0.29384127f, -0.08341707f, 0.07563767f, -0.17421231f, 
    -0.08249760f, 0.05196833f, 0.22364916f, 0.08019201f, 0.05626031f, 0.31150973f, 0.03701068f, -0.21214461f, 
    0.19203432f, 0.11365464f, 0.04988513f, -0.07985918f, 0.09045515f, -0.07627011f, -0.37161559f, -0.08785065f, 
    0.16748077f, -0.13065626f, 0.05219515f, -0.02199510f, 0.03200242f, 0.03079038f, 0.02171360f, 0.03187715f, 
    -0.06190711f, -0.03608777f, 0.03860622f, 0.11016761f, -0.01312139f, -0.00868349f, -0.02997072f, 0.03529469f, 
    0.26589960f, -0.16705130f, -0.04526057f, -0.06253720f, -0.12806454f, 0.11169625f, 0.00258575f, 0.15856342f, 
    0.01742971f, -0.27517506f, 0.20139460f, -0.66279000f, -0.04966478f, -0.18237095f, -0.04600994f, 0.05764795f, 
    0.10981117f, 0.16130920f, 0.15422325f, -0.23701581f, -0.42091808f, 0.01366751f, 0.04844932f, 0.11213239f, 
    -0.07651385f, -0.11434688f, -0.25700498f, 0.25084558f, 0.15796708f, 0.34482285f, 0.08189173f, 0.09311645f, 
    -0.10659925f, 0.05970481f, 0.15197824f, 0.03393809f, 0.26914230f, -0.10180072f, 0.17251073f, 0.06172770f, 
    0.17585357f, 0.20363174f, 0.18698457f, 0.08508784f, -0.04494699f, -0.69784397f, -0.07268531f, 0.19587049f, 
    -0.00503415f, -0.26539686f, -0.10385348f, 0.05677378f, 0.02488600f, 0.07205652f, 0.14694889f, -0.15158871f, 
    -0.19541137f, 0.05944061f, 0.18349274f, 0.13478974f, 0.07808509f, 0.01219289f, -0.15661561f, 0.14025065f, 
    -0.05159278f, 0.08618110f, -0.03096246f, 0.10850967f, 0.14699483f, 0.02361508f, 0.03552112f, -0.03920673f, 
    -0.40717217f, 0.16736726f, -0.00312084f, -0.11271265f, 0.21310216f, -0.10141966f, 0.12607010f, 0.11098761f, 
    -0.03705300f, 0.06552617f, -0.15993236f, 0.17615022f, -0.13697696f, 0.04194649f, -0.01675406f, -0.07165869f, 
    0.14562167f, 0.14531073f, 0.10933746f, -0.01947969f, 0.06012596f, 0.09188339f, -0.07442521f, -0.10187835f, 
    -0.02858049f, -0.12284496f, -0.07620283f, -0.13561302f, -0.21005335f, -0.06159377f, 0.11696209f, 0.12347832f, 
    0.06996564f, 0.03040497f, 0.02329428f, 0.08747850f, -0.40186638f, -0.39529201f, 0.29266506f, 0.14542247f, 
    -0.06939530f, -0.00255280f, 0.01030313f, -0.21386912f, -0.15217708f, -0.18013412f, 0.02048014f, -0.03281591f, 
    -0.05076077f, -0.03705342f, 0.10705046f, 0.09498180f, 0.03983112f, 0.13731048f, 0.08964224f, 0.01519201f, 
    0.25524831f, -0.07702736f, -0.17380048f, -0.14289920f, -0.05519737f, -0.00173607f, 0.02836228f, -0.31037107f, 
    0.31318900f, -0.12232838f, -0.12308414f, 0.00688127f, 0.00484340f, 0.02689058f, -0.12245546f, 0.23047374f, 
    -0.05623536f, 0.02016021f, 0.04844666f, -0.06126130f, 0.01868680f, 0.04813460f, 0.13559550f, 0.04657289f, 
    -0.04123016f, 0.06764584f, 0.15021870f, 0.02556842f, 0.03227300f, -0.15153483f, 0.02337487f, 0.01847901f, 
    -0.09163056f, -0.15394937f, 0.14076121f, -0.34662142f, -0.05541962f, -0.05449738f, -0.14807270f, 0.01263412f, 
    -0.01658792f, 0.09397276f, 0.14097156f, -0.05934810f, -0.01881312f, 0.04989351f, 0.05459821f, 0.18954498f, 
    -0.00299820f, 0.09205510f, 0.03637893f, -0.03785652f, 0.05535268f, -0.00544639f, -0.02367794f, -0.02247943f, 
    0.00012645f, -0.17988762f, 0.02228869f, -0.04934506f, 0.12081976f, -0.00149373f, 0.05981431f, 0.08915617f, 
    0.02750882f, 0.11681502f, -0.24022882f, 0.00572963f, -0.06313868f, 0.01311189f, 0.20150891f, 0.04189061f, 
    0.31437242f, 0.06528346f, 0.04902538f, -0.05904988f, 0.08744723f, 0.04296024f, 0.04331170f, -0.39601055f, 
    0.17209592f, -0.46907035f, -0.05033708f, -0.07025582f, -0.10049859f, -0.05229873f, -0.07173607f, 0.12251060f, 
    -0.06211435f, -0.44643626f, -0.04905680f, -0.10120718f, 0.06202446f, -0.09988807f, 0.09704003f, 0.08036765f, 
    0.00414681f, -0.40673557f, -0.43508083f, -0.07983825f, -0.19932073f, -0.25623187f, -0.22905427f, 0.07730046f, 
    0.02675164f, 0.14339079f, -0.41230297f, -0.42805150f, 0.05024574f, -0.42899969f, 0.18847002f, -0.27345207f, 
    0.18983766f, 0.10323174f, 0.02778485f, -0.42091006f, -0.27077222f, -0.28330797f, 0.14835075f, 0.11837345f, 
    0.09295092f, -0.03342434f, 0.00004128f, -0.20071748f, -0.32103747f, 0.01257792f, 0.07847325f, -0.23833315f, 
    0.01581088f, -0.05638425f, 0.03793392f, -0.11951129f, -0.06076584f, -0.26484030f, 0.00997283f, -0.08309504f, 
    -0.09029852f, -0.09390800f, -0.07571466f, 0.10785095f, 0.08414766f, 0.17415388f, -0.27425772f, 0.22927223f, 
    -0.36465186f, -0.00321359f, 0.10064559f, 0.10438924f, 0.02011632f, 0.00194879f, -0.13913482f, -0.16091825f, 
    0.12216392f, 0.12534541f, -0.00898573f, 0.04193357f, -0.10154036f, 0.11374863f, 0.01785079f, 0.06719244f, 
    -0.23270054f, -0.02533856f, 0.26611885f, 0.04354263f, 0.08622217f, 0.03457453f, -0.01928495f, -0.11519123f, 
    0.26189381f, 0.28058892f, 0.17982751f, 0.15096773f, 0.09324886f, 0.00533459f, 0.14006516f, 0.07331009f, 
    -0.12074842f, 0.13837028f, 0.12721083f, 0.24240568f, -0.14610434f, 0.07842365f, -0.09129280f, 0.02410328f, 
    -0.06815727f, -0.08902009f, 0.01346479f, 0.16241498f, 0.20990729f, -0.10350479f, -0.03119740f, 0.00183612f, 
    0.17068554f, 0.16085638f, -0.26139033f, 0.32607022f, -0.04071015f, 0.02657325f, -0.14051774f, -0.05478865f, 
    0.04295127f, 0.04885052f, 0.15807778f, 0.05071386f, -0.06743756f, 0.16426590f, -0.10674100f, 0.00056607f, 
    0.02635563f, -0.04149768f, 0.09302602f, -0.04677377f, -0.16731761f, 0.12591626f, 0.12986025f, 0.23874459f, 
    0.11411882f, 0.11740427f, 0.02299939f, -0.15392928f, 0.11773425f, -0.13935848f, 0.00504514f, -0.07147258f, 
    -0.05610539f, 0.06837940f, 0.00755212f, -0.05056049f, -0.01453942f, -0.01854436f, -0.06366908f, 0.00110142f, 
    0.15028998f, 0.06099402f, -0.16748169f, 0.08638027f, -0.05009747f, -0.05994749f, 0.09422816f, 0.14520507f, 
    -0.13956369f, -0.11850125f, 0.22853065f, -0.37877390f, 0.05160992f, -0.00105875f, 0.05244185f, 0.00828610f, 
    0.00137364f, -0.17807458f, 0.11157664f, -0.15508659f, -0.23383909f, -0.18031716f, 0.02052777f, 0.24471267f, 
    -0.11362204f, -0.18778010f, 0.13588062f, 0.29438344f, 0.25750268f, -0.24596208f, 0.03387395f, -0.13064770f, 
    0.06193849f, 0.03939293f, 0.02007569f, 0.12890886f, 0.17310190f, 0.07177593f, -0.11961676f, -0.05165336f, 
    0.02360082f, -0.07973296f, 0.06157616f, -0.06084423f, 0.01712610f, 0.20663366f, -0.25953728f, -0.10779191f, 
    0.10165519f, -0.00949652f, -0.03100583f, -0.03340602f, 0.08839905f, -0.16489308f, 0.08610830f, -0.02513836f, 
    0.03162966f, -0.13913241f, -0.00285843f, 0.14691168f, -0.05694308f, -0.17486326f, -0.24664396f, 0.02307457f, 
    -0.22305064f, -0.07299871f, 0.11607921f, -0.00965353f, 0.10354412f, 0.00009011f, 0.02085466f, -0.01986154f, 
    -0.15610129f, -0.31585175f, -0.21791264f, -0.10264266f, 0.13090837f, -0.04989189f, 0.13201156f, -0.26515937f, 
    -0.05656207f, -0.17871155f, 0.01149953f, -0.08590797f, 0.18594638f, 0.12299201f, 0.01026891f, -0.04579826f, 
    -0.05370781f, -0.42464256f, -0.39931554f, 0.10086559f, 0.06458879f, 0.10479570f, -0.10180980f, -0.03232640f, 
    0.14363155f, 0.15686838f, 0.02705930f, 0.01655604f, -0.10254987f, -0.10925578f, 0.03731282f, -0.02664622f, 
    -0.02009491f, 0.10933676f, -0.07767199f, -0.10107691f, -0.06383397f, -0.04411351f, -0.17733397f, -0.04163147f, 
    0.04981658f, 0.19454877f, -0.07183414f, -0.10570683f, 0.14697927f, 0.24111691f, -0.05220741f, -0.05454961f, 
    -0.04093210f, 0.01505654f, 0.11131390f, -0.13801591f, -0.05921425f, -0.05721100f, 0.11712370f, 0.12717463f, 
    0.07130127f, -0.00252153f, 0.08012495f, 0.04767079f, -0.06038991f, -0.01592938f, -0.03713781f, 0.09757143f, 
    0.11224428f, 0.03997136f, 0.18669303f, -0.14330293f, 0.07049404f, -0.06580318f, -0.10607665f, -0.00271363f, 
    0.15527152f, 0.13858968f, 0.05163734f, 0.08665691f, 0.24904694f, -0.06149557f, -0.00949737f, -0.01858146f, 
    -0.02427578f, 0.06520914f, -0.11069254f, -0.02770065f, 0.03849955f, -0.03126263f, -0.11177353f, 0.06567221f, 
    -0.13858263f, 0.19196208f, -0.13753085f, -0.05406550f, -0.07068469f, 0.01217768f, 0.10374887f, -0.00361313f, 
    0.08900715f, 0.04046095f, 0.11198219f, 0.17718311f, -0.03287900f, -0.01251225f, 0.13521622f, -0.17186888f, 
    -0.04640822f, -0.02811290f, -0.10264946f, -0.15394165f, 0.00937203f, 0.00736782f, 0.06361330f, 0.16762412f, 
    0.23651440f, -0.07207035f, 0.05718420f, 0.05303954f, -0.07733430f, 0.07173999f, -0.08806037f, 0.00242670f, 
    -0.17481239f, -0.07811730f, 0.12651341f, 0.15798791f, -0.00968269f, 0.19923934f, 0.29495981f, 0.23311915f, 
    -0.12718110f, 0.01875176f, -0.10219346f, -0.16934434f, -0.04462347f, -0.09145896f, -0.06447080f, 0.05911788f, 
    -0.08591070f, -0.25685897f, 0.11609453f, 0.11506371f, 0.04178092f, 0.10817895f, -0.29564390f, -0.31419283f, 
    0.00895161f, 0.12534566f, -0.11526220f, -0.08397955f, 0.07508254f, -0.07850001f, -0.07763655f, 0.02817391f, 
    -0.08597815f, -0.11566948f, -0.18075141f, -0.03923482f, -0.02150397f, 0.10439706f, 0.08782201f, -0.07584465f, 
    0.01011819f, -0.05699518f, -0.31445062f, -0.21755534f, 0.32752809f, -0.12016876f, 0.12777415f, 0.05695496f, 
    -0.04321660f, 0.12382866f, 0.23315120f, -0.03035281f, -0.05130817f, 0.08948142f, 0.02549357f, -0.02362704f, 
    -0.01620642f, -0.01020917f, -0.00850930f, 0.02555957f, -0.10329524f, 0.08026404f, 0.08630534f, 0.02721123f, 
    -0.09054630f, -0.06026631f, 0.09836958f, 0.08194380f, 0.16188551f, -0.09258677f, -0.09647589f, -0.23090607f, 
    0.03203251f, -0.11536189f, 0.03852532f, -0.04289731f, 0.06689020f, -0.06236206f, -0.46647435f, -0.26253986f, 
    0.22828630f, 0.03164437f, 0.10920885f, 0.13762043f, 0.06328516f, 0.00460034f, 0.20584270f, -0.05518426f, 
    -0.28306442f, 0.24912900f, 0.00851408f, -0.04155220f, 0.07392552f, 0.13396394f, 0.17177121f, 0.34571227f, 
    0.01033335f, 0.15444788f, 0.39032534f, 0.07867952f, 0.18949708f, 0.01340156f, 0.10541940f, 0.00734097f, 
    0.15192911f, -0.00571717f, -0.01869426f, 0.13826549f, 0.07792486f, 0.03193647f, -0.07834274f, -0.27407995f, 
    -0.19036356f, 0.01136784f, -0.02940845f, 0.04393107f, -0.11062143f, -0.16455214f, 0.02555706f, -0.13124971f, 
    -0.11698464f, -0.16217704f, -0.04477260f, -0.05771888f, -0.04805861f, 0.05749320f, -0.08625918f, 0.00545107f, 
    -0.07504401f, -0.03382781f, -0.09874136f, -0.04024842f, -0.05624970f, 0.27047181f, -0.03731142f, -0.22707632f, 
    0.11844998f, 0.15060516f, -0.03526159f, 0.15341035f, -0.14221838f, 0.03800286f, 0.10418035f, -0.00170639f, 
    0.01788284f, 0.03312301f, 0.01395710f, 0.07295869f, -0.13372283f, -0.05585139f, 0.11592084f, -0.04775442f, 
    -0.19195303f, -0.05832600f, -0.01482105f, 0.09777115f, 0.01721446f, 0.01682686f, -0.03186554f, -0.17753357f, 
    0.04364682f, -0.02691197f, -0.02816198f, 0.09797514f, -0.17195119f, -0.09455737f, -0.13816315f, -0.02576977f, 
    -0.03822757f, -0.02506297f, -0.01288388f, 0.09677938f, 0.13780598f, -0.01432171f, -0.08752193f, -0.14613274f, 
    -0.09746581f, -0.10861214f, -0.24813314f, 0.01650381f, 0.27037469f, 0.07919437f, 0.14858826f, 0.14822455f, 
    -0.07187577f, 0.22344919f, 0.00369522f, 0.03180378f, 0.06943069f, -0.05646150f, -0.00442825f, 0.06454903f, 
    -0.05829328f, -0.23303835f, -0.21341230f, 0.00589344f, 0.04350114f, 0.10561105f, 0.00199725f, 0.14924166f, 
    -0.07052033f, -0.14502589f, 0.04627400f, -0.02362188f, -0.05882724f, -0.07850393f, -0.04673854f, -0.09284637f, 
    -0.01709531f, -0.02757808f, 0.00178939f, -0.29670295f, -0.11184773f, 0.10113405f, 0.14319265f, -0.09239792f, 
    -0.14094841f, -0.04849640f, -0.08958731f, 0.01170152f, 0.02393636f, -0.00353795f, -0.03002461f, 0.14375408f, 
    -0.04957507f, -0.02950352f, 0.00455886f, 0.06721328f, -0.06397398f, 0.09662602f, -0.07687208f, -0.11552552f, 
    0.05846572f, 0.08547065f, 0.15433568f, -0.00878629f, -0.12452783f, 0.04671127f, 0.06346510f, -0.05852909f, 
    0.01533901f, 0.19397283f, 0.11741888f, 0.02929866f, 0.18079683f, 0.03678091f, 0.05728962f, -0.01731091f, 
    -0.10574256f, -0.20697218f, 0.06222662f, -0.21493517f, 0.01696145f, -0.02880912f, -0.07673043f, 0.10730349f, 
    0.07250178f, -0.40022096f, 0.08128071f, -0.11895856f, 0.15867808f, 0.00951421f, -0.01800031f, -0.00303094f, 
    0.01703216f, 0.21802805f, -0.17030679f, -0.03237373f, 0.09547035f, 0.10013264f, -0.12031258f, 0.18892798f, 
    -0.00232807f, -0.10580407f, -0.10709073f, -0.12464774f, 0.06568327f, -0.04162246f, 0.03746970f, 0.02040920f, 
    -0.02652835f, 0.07249535f, -0.03511365f, -0.02492339f, 0.02068047f, -0.24588978f, 0.05698377f, -0.18573166f, 
    -0.05712549f, -0.03118924f, 0.06332725f, 0.11779368f, -0.02597235f, -0.30784214f, -0.08548978f, -0.28135017f, 
    0.04025398f, 0.01277994f, -0.01917958f, 0.20168580f, 0.07801828f, -0.25053549f, 0.06273099f, -0.00466620f, 
    0.05435465f, -0.07580251f, 0.11122452f, -0.03336287f, 0.02574364f, 0.03920685f, 0.01839028f, -0.00910421f, 
    0.08972109f, -0.02710343f, -0.04298897f, 0.04167846f, 0.01526347f, 0.00878952f, 0.10088274f, -0.02533255f, 
    -0.01356059f, -0.48179579f, -0.12915441f, -0.18910000f, 0.02445476f, 0.10525435f, -0.01155739f, 0.18391585f, 
    0.04359905f, 0.01177598f, 0.12257016f, -0.32030922f, -0.38842610f, 0.00995727f, 0.05229881f, 0.02571790f, 
    0.06048205f, 0.12666668f, -0.08103886f, -0.00816397f, -0.06917796f, 0.21657293f, 0.02178761f, 0.17335857f, 
    -0.11063925f, -0.01615306f, -0.04458722f, 0.10212209f, 0.06324844f, 0.01482082f, -0.05572733f, -0.02199316f, 
    0.11327350f, 0.03711025f, 0.05688989f, 0.03163785f, 0.20300749f, -0.08282774f, -0.13237679f, 0.11865525f, 
    -0.07262859f, -0.05517850f, 0.06780697f, -0.02325386f, -0.06558474f, 0.01042112f, -0.10285287f, -0.10144364f, 
    -0.30886734f, 0.11810204f, 0.14103006f, -0.08588131f, 0.23054466f, -0.06386802f, 0.06993745f, 0.09488737f, 
    0.07648995f, 0.02802186f, 0.08463279f, 0.11797279f, -0.16696995f, -0.07130354f, 0.14261942f, -0.00945697f, 
    0.03558294f, 0.12769225f, 0.08821740f, -0.00319462f, 0.10309909f, -0.02257679f, 0.13330777f, 0.09775577f, 
    0.13537125f, -0.03420004f, -0.02327207f, -0.03000630f, -0.09706326f, 0.04463438f, -0.14005631f, 0.14690852f, 
    0.09240712f, 0.07877804f, -0.01806630f, 0.01539863f, 0.06789369f, -0.06252854f, 0.03025148f, 0.09424507f, 
    0.04888402f, -0.09006361f, 0.00962830f, -0.17336918f, -0.21352118f, -0.00527012f, 0.04727529f, -0.07847457f, 
    -0.02299675f, -0.09617089f, -0.07099393f, -0.11689471f, -0.45095116f, -0.09734409f, -0.04755402f, 0.02315167f, 
    0.06602409f, -0.14157064f, 0.03792182f, 0.09590421f, -0.02424383f, -0.03677910f, 0.01424016f, -0.02474089f, 
    -0.06463257f, -0.05815327f, 0.06843609f, 0.02084402f, 0.00982173f, 0.13615383f, -0.06847084f, 0.20546024f, 
    -0.00663477f, -0.07971688f, -0.04267684f, 0.05930864f, 0.09447021f, -0.09082994f, 0.08907183f, 0.06996530f, 
    0.01482250f, -0.08161453f, -0.07567417f, 0.00176152f, -0.03853773f, -0.25850520f, -0.04903404f, -0.07839074f, 
    -0.06043720f, -0.13749582f, -0.03619400f, -0.21251072f, -0.22183427f, 0.19119287f, -0.00617228f, 0.17362404f, 
    0.05073228f, 0.03326416f, -0.10212962f, -0.52293634f, -0.18668048f, -0.14254682f, -0.07617720f, 0.09349457f, 
    0.01123534f, -0.02801162f, -0.24338478f, -0.01469953f, 0.00904289f, -0.11439390f, -0.08376876f, 0.05705319f, 
    0.13456298f, 0.04144066f, -0.21738063f, -0.07566541f, -0.15455978f, -0.11234682f, -0.02754962f, -0.00263973f, 
    -0.01265590f, 0.07052944f, 0.16508803f, 0.12044001f, -0.01042902f, -0.00091109f, 0.05241646f, -0.14538310f, 
    0.04263574f, -0.00611446f, -0.03209954f, 0.05429447f, 0.08903634f, -0.19750728f, 0.14586018f, 0.20386015f, 
    0.03651939f, 0.06433043f, 0.08394027f, -0.05083100f, 0.01057019f, 0.06035375f, -0.02345148f, 0.14998175f, 
    0.13344008f, -0.01098445f, 0.00451787f, 0.06615382f, -0.02792495f, 0.02731119f, -0.02955301f, 0.04705353f, 
    -0.20070080f, 0.06334724f, -0.02221613f, 0.05581067f, 0.11709746f, 0.13774240f, 0.03956243f, 0.14034259f, 
    0.15429495f, -0.08788966f, -0.04505478f, -0.13287282f, -0.15887941f, -0.25610340f, 0.13611931f, -0.05773810f, 
    0.09543928f, -0.15826182f, -0.09086888f, -0.14661817f, -0.11928402f, -0.04482426f, -0.11092064f, -0.04623995f, 
    -0.09032473f, 0.05247415f, -0.16897266f, -0.09739769f, 0.29603031f, 0.06449240f, -0.10876928f, -0.06514183f, 
    0.10979854f, -0.07699257f, 0.11586774f, -0.17191644f, -0.33404511f, -0.22996381f, -0.01043038f, 0.05989670f, 
    -0.22431183f, 0.25863439f, 0.17152938f, 0.07415704f, -0.32108754f, 0.00936195f, -0.03707877f, -0.05022080f, 
    0.07295270f, -0.15276957f, 0.16149987f, 0.03008171f, 0.13740440f, -0.35350126f, 0.09861895f, 0.03381680f, 
    -0.00663023f, -0.01139346f, 0.04282491f, 0.01477489f, 0.06402897f, -0.00843985f, -0.00818061f, -0.00429021f, 
    -0.11578255f, 0.02650208f, -0.06222290f, 0.01595238f, -0.05234166f, 0.11532605f, 0.04181522f, -0.17912234f, 
    -0.02742761f, -0.05512082f, -0.13174415f, -0.00437836f, -0.07079005f, 0.06974851f, 0.06147435f, 0.15556626f, 
    0.01462564f, 0.12478446f, 0.16151308f, 0.10308180f, 0.04232758f, -0.13923086f, -0.07134911f, 0.01394830f, 
    0.02079441f, 0.15315373f, 0.16975193f, 0.22774766f, 0.23639037f, 0.00642287f, 0.02800587f, -0.00394230f, 
    0.06097160f, 0.00257648f, 0.10629722f, 0.02577834f, 0.03930545f, 0.07582767f, 0.10324056f, 0.02184266f, 
    0.02015239f, 0.00180148f, -0.00712188f, -0.14998877f, -0.11026394f, 0.04751230f, 0.15389112f, 0.10911064f, 
    -0.00538473f, -0.04546810f, -0.02770847f, 0.30550569f, -0.03273135f, 0.08618653f, -0.01225165f, -0.07147265f, 
    0.05671420f, 0.04680629f, -0.10547704f, -0.04128450f, -0.07637632f, 0.21501718f, -0.12053329f, -0.10399634f, 
    0.15457766f, 0.10714781f, 0.07720114f, -0.04684055f, 0.02808656f, 0.07961144f, 0.32503900f, 0.04262894f, 
    0.29906300f, -0.03498444f, -0.00095410f, -0.03891081f, 0.11196384f, -0.05903453f, -0.13058177f, -0.06006380f, 
    0.16184495f, -0.17383222f, 0.05284804f, -0.05059693f, 0.00309081f, 0.08125252f, -0.10091457f, -0.05424676f, 
    0.14920284f, 0.04756042f, -0.03265162f, 0.02445928f, -0.11073034f, 0.07311851f, 0.03873842f, 0.03792772f, 
    0.07559684f, 0.01754390f, -0.05194902f, 0.03395995f, 0.06921085f, 0.04754779f, -0.00390397f, -0.04771296f, 
    -0.07789350f, 0.01963835f, -0.14031824f, -0.15047355f, 0.11280309f, 0.08572643f, 0.12019960f, 0.06884833f, 
    0.06028081f, 0.13949415f, 0.21746783f, 0.26087844f, 0.09329386f, -0.00325186f, 0.01898552f, -0.04424248f, 
    -0.01887911f, 0.07855161f, -0.05348007f, 0.13403548f, -0.00397786f, -0.06190363f, -0.04478531f, 0.25614929f, 
    -0.02128102f, 0.08642885f, 0.01208973f, 0.07579645f, -0.22738162f, 0.00313723f, -0.05948382f, -0.21780865f, 
    0.01177394f, 0.03670996f, -0.08057325f, 0.04557895f, 0.08718988f, -0.08239539f, -0.31160071f, 0.04513934f, 
    0.13407928f, -0.00885702f, 0.08132617f, -0.13412994f, -0.08408366f, -0.13114741f, -0.14379731f, -0.04712337f, 
    0.00650835f, -0.19781905f, 0.03842260f, -0.06094849f, -0.11821038f, 0.06999357f, 0.12755354f, 0.20271122f, 
    -0.07305649f, -0.04153460f, -0.17660515f, 0.05887506f, 0.08098990f, -0.02178891f, -0.16215384f, 0.00433166f, 
    -0.33804753f, 0.06964047f, 0.13650772f, 0.04884308f, 0.10718753f, 0.03934506f, 0.08780155f, -0.17069054f, 
    -0.28739259f, -0.50029278f, -0.16465497f, 0.09433797f, 0.00728719f, 0.16508810f, -0.00455857f, 0.07337042f, 
    -0.08149134f, 0.16418636f, 0.11129785f, -0.03201932f, 0.01216293f, 0.00065563f, -0.00192005f, 0.06352159f, 
    0.01531341f, -0.09960359f, -0.06703486f, -0.28957656f, -0.30841458f, -0.27609462f, 0.02657864f, 0.00756178f, 
    0.19267036f, 0.15399742f, 0.10553617f, 0.08067155f, 0.17702833f, -0.31258997f, 0.00585590f, 0.07486399f, 
    0.19004621f, -0.00010364f, 0.06014964f, 0.08673568f, 0.02175354f, 0.03410885f, 0.03130301f, 0.08714017f, 
    0.04723695f, 0.13486093f, -0.02355260f, 0.04375463f, 0.07889425f, 0.03438358f, 0.11536500f, 0.08093881f, 
    0.12440481f, 0.18950067f, 0.03618615f, -0.07927155f, 0.01476087f, 0.00513742f, 0.07265373f, -0.10893235f, 
    0.28276375f, 0.04285312f, -0.08334602f, 0.10040922f, 0.06225105f, 0.14339975f, -0.02681891f, 0.06530967f, 
    -0.27632275f, 0.14851768f, 0.02532478f, 0.01403565f, 0.21253443f, 0.02665857f, -0.06124845f, 0.00028420f, 
    -0.02394042f, 0.00018317f, -0.10715487f, -0.10222979f, -0.15707697f, 0.03246566f, 0.13372225f, 0.13218872f, 
    0.03622767f, 0.01675235f, 0.01162502f, -0.27983582f, 0.31553456f, -0.16046456f, 0.15256019f, -0.12433607f, 
    0.07874935f, 0.16962306f, -0.10360701f, -0.09936494f, 0.02585744f, 0.05908122f, -0.11047658f, 0.14183718f, 
    0.07135496f, 0.09610828f, 0.04336198f, -0.03310398f, -0.21099709f, 0.09888087f, 0.07154957f, 0.14409740f, 
    0.10809330f, 0.02374807f, 0.05869235f, 0.01364577f, -0.10038649f, 0.14491688f, 0.05163769f, 0.15027367f, 
    -0.06505737f, 0.12133107f, -0.03721959f, -0.03365387f, 0.17141199f, -0.05671141f, -0.05400287f, -0.07745023f, 
    -0.05137430f, -0.04309119f, 0.02144163f, 0.08594665f, 0.03634921f, -0.12103255f, -0.02396820f, -0.04876939f, 
    0.20129737f, 0.03613939f, -0.01879086f, -0.17466989f, -0.09723005f, 0.00569310f, -0.09399719f, 0.04429712f, 
    0.01770220f, -0.20469107f, -0.20860460f, -0.24015602f, -0.12202436f, 0.01591614f, 0.08812072f, -0.10965312f, 
    -0.11525447f, -0.07224027f, -0.03166709f, -0.01065079f, -0.10912941f, -0.09041022f, 0.08632739f, 0.06263271f, 
    -0.07780357f, 0.10074321f, -0.05097058f, 0.04385383f, -0.08151272f, 0.05184399f, 0.04049215f, -0.04512228f, 
    -0.18301001f, -0.19265704f, -0.01769565f, -0.07318137f, 0.13963553f, 0.07179753f, 0.03561204f, 0.03765028f, 
    -0.06646588f, 0.13029397f, 0.04799881f, 0.11846993f, 0.01912007f, -0.28773835f, 0.03146747f, 0.14429748f, 
    0.09798667f, -0.06374280f, 0.09558010f, -0.01395871f, -0.19011286f, 0.03385374f, 0.02654869f, -0.07148318f, 
    0.12930086f, 0.04543729f, 0.05412136f, 0.10617594f, 0.12049421f, 0.18801293f, 0.01445682f, 0.16829352f, 
    0.03300747f, 0.02877790f, 0.04417237f, 0.08374693f, 0.07020800f, -0.06040670f, -0.02175470f, -0.05049279f, 
    0.03862936f, 0.11598051f, 0.35818034f, 0.01632567f, 0.06775881f, 0.19146957f, 0.09123883f, 0.25659811f, 
    0.06302662f, 0.10439752f, -0.08131240f, 0.07568554f, -0.08735571f, 0.09302864f, 0.03165634f, -0.11883986f, 
    0.02541265f, -0.00003062f, -0.04803208f, 0.12114204f, -0.04414842f, 0.07585366f, -0.05232183f, -0.13945806f, 
    -0.13515593f, -0.19757755f, -0.08013202f, 0.13394837f, -0.03962747f, 0.18319035f, 0.05749116f, 0.09865771f, 
    0.03221960f, -0.01564110f, -0.14051872f, 0.03676301f, -0.20733593f, 0.25183478f, -0.04598853f, -0.07249551f, 
    -0.11866526f, -0.06565344f, -0.14553784f, 0.22647810f, -0.14088313f, 0.03796006f, 0.09134734f, 0.09264956f, 
    0.06421893f, -0.01177130f, 0.10227956f, 0.02801583f, -0.14787577f, -0.00469333f, 0.13174857f, -0.04608015f, 
    0.01746365f, 0.08093096f, -0.14547373f, 0.13182722f, -0.02288149f, -0.20962618f, 0.11410034f, -0.08687494f, 
    -0.18035901f, 0.12152197f, 0.08731358f, 0.07908463f, 0.10326225f, -0.24809471f, -0.03866294f, -0.18451117f, 
    -0.02631089f, -0.02803390f, -0.01227137f, -0.03201567f, -0.07682008f, 0.00321919f, -0.11703885f, 0.04690538f, 
    -0.19111530f, 0.07143421f, 0.06842691f, -0.13940927f, -0.06341964f, 0.05703634f, 0.00426447f, 0.17291664f, 
    0.19287756f, 0.03841024f, 0.03924816f, -0.03805211f, -0.21332811f, -0.03827413f, -0.06839369f, 0.05999342f, 
    0.01402453f, -0.30557054f, -0.16587390f, 0.02661910f, 0.04661132f, 0.14156437f, -0.01911505f, 0.11897985f, 
    -0.04081268f, -0.02091692f, 0.02376618f, 0.20802695f, -0.06267304f, -0.06198435f, -0.39633504f, 0.02554478f, 
    0.06886457f, 0.02033911f, -0.18744099f, -0.20145573f, -0.01173664f, -0.22158663f, -0.03096572f, -0.07462729f, 
    0.12245355f, 0.05566778f, -0.03013180f, -0.00063576f, -0.08045785f, 0.04180815f, -0.02702897f, 0.15434773f, 
    -0.04991081f, -0.03496686f, 0.07845753f, 0.02609246f, -0.08144949f, 0.07239710f, -0.06709726f, -0.04152459f, 
    0.09349588f, 0.14475445f, 0.20232576f, 0.19857146f, 0.06843384f, 0.08410659f, -0.08307265f, 0.09375311f, 
    0.19267157f, -0.00158550f, 0.03506381f, -0.03563334f, -0.07202876f, -0.08403550f, 0.04926506f, 0.10082863f, 
    0.25143668f, -0.19617006f, 0.03556244f, -0.12561180f, -0.15936820f, -0.14376049f, 0.13777122f, 0.05540472f, 
    0.06836935f, -0.00856582f, 0.02840210f, -0.01883360f, 0.10528814f, 0.04586228f, 0.16245177f, -0.02497544f, 
    -0.07265043f, 0.06287044f, 0.01293704f, 0.12625474f, -0.05520907f, -0.03255251f, -0.05956199f, -0.16764520f, 
    0.14052317f, -0.16497545f, -0.25667119f, 0.04261887f, 0.07427063f, 0.16401878f, -0.05913927f, -0.10162331f, 
    -0.08944798f, -0.00512312f, 0.08350149f, 0.02932811f, 0.05413027f, -0.29444110f, -0.18329982f, -0.12944856f, 
    -0.05079082f, -0.01691091f, 0.04801264f, 0.03215391f, 0.03060889f, -0.20232762f, 0.11508700f, 0.00753398f, 
    0.23304929f, 0.07680465f, 0.09082017f, 0.10137030f, 0.01262137f, -0.14212829f, 0.14757921f, -0.06178801f, 
    -0.11391739f, 0.06883160f, 0.08418559f, -0.05871005f, -0.08829646f, -0.02436998f, -0.06936651f, 0.01129793f, 
    0.08623484f, -0.13485929f, 0.23900838f, 0.00989412f, 0.01687195f, -0.10114932f, 0.08936508f, 0.07043836f, 
    0.02560387f, -0.10938567f, -0.08897718f, 0.09916855f, -0.03298654f, 0.11208373f, 0.09311111f, -0.03378415f, 
    0.03907932f, 0.03661801f, -0.40649867f, -0.27542517f, 0.10948781f, -0.03022022f, 0.11885116f, -0.11767241f, 
    -0.07263917f, 0.01342864f, -0.03823695f, -0.07631879f, -0.05496440f, 0.40468875f, -0.14478418f, 0.07968131f, 
    0.08406114f, 0.11600199f, 0.19263415f, -0.11905883f, 0.12903933f, 0.00786376f, -0.04264955f, 0.05803782f, 
    0.05768761f, -0.01441962f, -0.02987828f, 0.15038566f, 0.09418520f, -0.04240078f, -0.17939524f, -0.24202374f, 
    -0.06622632f, -0.12859936f, 0.19056205f, 0.06694208f, -0.00966280f, 0.06234303f, 0.05438190f, 0.17128362f, 
    0.14745161f, -0.02785691f, 0.16118242f, -0.02128709f, -0.11601076f, 0.01935918f, 0.07229237f, 0.07266266f, 
    -0.13560674f, -0.06753347f, 0.01775132f, -0.00991405f, -0.06270154f, 0.10722486f, -0.03137444f, 0.16090536f, 
    0.32861772f, -0.13822348f, -0.32007742f, 0.04281288f, 0.11290392f, -0.09569331f, -0.01187540f, -0.09981453f, 
    0.16915815f, -0.08111324f, -0.03795095f, -0.06115302f, 0.01639421f, 0.09436494f, -0.06499147f, -0.06545142f, 
    0.05615213f, 0.02649709f, -0.04530082f, 0.07194006f, 0.20719454f, 0.04676691f, -0.10911401f, -0.06387026f, 
    -0.07157087f, -0.10878766f, -0.27267918f, -0.25498801f, -0.25023574f, -0.24197534f, -0.15395047f, 0.02307002f, 
    -0.02907661f, -0.09932490f, 0.01296976f, -0.04010736f, -0.12414117f, 0.01912330f, 0.35724303f, -0.09385985f, 
    0.05901456f, 0.28399029f, -0.05030346f, 0.03184770f, 0.17404769f, -0.14909887f, -0.10190501f, -0.22718151f, 
    -0.00573584f, -0.04560901f, -0.03278697f, 0.26526591f, -0.01351167f, 0.02781085f, -0.01293667f, 0.01781729f, 
    0.18489350f, -0.17367148f, 0.03946311f, -0.09959090f, -0.03055516f, -0.19122626f, -0.10957139f, 0.05188748f, 
    -0.06050621f, -0.11743384f, 0.02838562f, 0.01103513f, -0.02357823f, 0.18724719f, 0.06397878f, -0.01656156f, 
    -0.00345467f, 0.00025476f, -0.06778742f, -0.01628537f, 0.02931749f, -0.08576499f, 0.11753640f, 0.06388836f, 
    -0.23065709f, 0.23400843f, -0.07872389f, 0.13078348f, -0.01348705f, 0.09808765f, 0.02152175f, 0.03778918f, 
    0.08953831f, 0.05714077f, 0.25805989f, -0.07945868f, -0.00901849f, -0.05584914f, -0.05951789f, 0.03847881f, 
    0.15585786f, 0.22113113f, 0.06607348f, -0.06659021f, -0.01102441f, -0.28129351f, -0.06044317f, 0.09389745f, 
    -0.08735640f, 0.01153127f, 0.12941913f, 0.00071925f, 0.04890345f, -0.01924754f, 0.32904077f, 0.09453840f, 
    0.01529487f, 0.06713959f, 0.09476487f, -0.04727057f, -0.38038778f, -0.17149580f, 0.08021311f, 0.28896755f, 
    -0.05635890f, 0.05640850f, 0.05914622f, 0.14648128f, -0.04160395f, -0.07099951f, -0.03943830f, 0.17276005f, 
    0.42234606f, 0.03167649f, -0.07256189f, 0.14883754f, 0.09919909f, 0.14151040f, 0.08232147f, 0.08356105f, 
    0.05919505f, -0.08326735f, 0.04140995f, -0.08509523f, -0.10793468f, 0.12296174f, 0.09274754f, 0.01653086f, 
    0.05403997f, 0.03427488f, 0.19562319f, 0.06553638f, 0.22127967f, -0.07529471f, 0.02917486f, 0.19715445f, 
    -0.14481974f, -0.10039641f, -0.18435836f, 0.17222269f, -0.10483921f, -0.12986103f, -0.04021032f, 0.14018089f, 
    0.06560595f, 0.03742988f, 0.22557846f, 0.20506902f, 0.00469184f, 0.12441691f, 0.09728813f, 0.17853224f, 
    0.06553206f, 0.05377310f, 0.11679816f, 0.08373024f, -0.32744834f, -0.00759720f, -0.13357209f, 0.00559510f, 
    0.14601983f, -0.03898527f, -0.03558391f, -0.01673544f, 0.05866189f, 0.23249814f, 0.16399892f, 0.06224260f, 
    0.07638618f, 0.06779372f, -0.01649752f, 0.09159830f, 0.06265153f, 0.08840456f, -0.01262411f, -0.02683631f, 
    0.03636738f, -0.01594718f, -0.04111160f, -0.01401734f, -0.01097481f, 0.07180134f, -0.29932791f, 0.01828162f, 
    -0.18031713f, -0.01526823f, -0.03399635f, -0.02585240f, -0.07341047f, -0.10718980f, 0.05763242f, -0.04878773f, 
    0.07341460f, -0.08038912f, -0.14666227f, -0.03672248f, -0.14392942f, 0.10063697f, -0.02979576f, -0.07745104f, 
    0.01066806f, -0.11728265f, -0.11423606f, -0.03442243f, -0.00992715f, 0.04520461f, 0.15289009f, -0.04783939f, 
    0.02150219f, -0.27961355f, -0.35197380f, -0.34329349f, -0.17031960f, -0.16220981f, 0.11587600f, 0.08476094f, 
    0.05659276f, 0.14355752f, -0.14511722f, -0.03693452f, 0.01716005f, -0.16751754f, -0.00078232f, -0.09055639f, 
    -0.02204415f, -0.00111228f, 0.02930930f, 0.13850218f, -0.08282080f, 0.04962575f, -0.10575002f, -0.03296325f, 
    -0.01048090f, -0.18103641f, 0.09713934f, 0.17601794f, 0.22032981f, -0.04436219f, 0.16671681f, -0.07699815f, 
    0.13170856f, 0.08634946f, -0.09343676f, 0.07139115f, 0.10171238f, -0.14942673f, 0.14134939f, -0.24932213f, 
    0.05795060f, -0.04025067f, 0.00871414f, 0.08293524f, -0.03932907f, 0.14842004f, -0.09240693f, -0.08586777f, 
    0.03983348f, -0.05559291f, -0.03284313f, 0.06512473f, -0.02797817f, 0.32443887f, -0.01060586f, 0.22641940f, 
    -0.00674153f, 0.14011240f, 0.04959985f, 0.01320288f, 0.11438800f, -0.04953739f, 0.12009127f, 0.18018156f, 
    -0.30686665f, 0.04686356f, 0.15940295f, 0.17902906f, 0.21404649f, 0.05332459f, 0.03284652f, -0.02286524f, 
    0.12090293f, 0.08280949f, 0.07915737f, 0.13354860f, -0.06095865f, -0.01703358f, -0.00198084f, -0.01301539f, 
    -0.03005134f, -0.04041352f, -0.09912036f, -0.02264904f, 0.12917320f, -0.15904817f, -0.11307442f, -0.09291148f, 
    -0.09842705f, -0.03796031f, -0.01771540f, -0.08002147f, 0.05627158f, 0.11296362f, 0.08062258f, -0.07951546f, 
    -0.17355983f, -0.01480791f, -0.01089276f, -0.08170535f, -0.20414513f, -0.01027625f, 0.27265188f, -0.16138060f, 
    0.04299349f, 0.05985984f, -0.08479679f, 0.03836454f, 0.04020461f, -0.03776167f, 0.17630616f, -0.00137262f, 
    0.07316378f, -0.03075514f, -0.16555908f, 0.03234461f, 0.02719353f, -0.08072590f, -0.10449176f, -0.30395204f, 
    -0.00878026f, -0.16256802f, 0.00227496f, 0.02142576f, -0.05145696f, 0.00036063f, -0.07780163f, -0.14696124f, 
    0.31009579f, -0.06194796f, 0.10265166f, 0.04854756f, -0.06546155f, -0.01645351f, -0.17611447f, 0.07324255f, 
    -0.13549998f, 0.10550002f, 0.00030192f, 0.14254309f, -0.03688283f, 0.06346608f, -0.15039246f, 0.00366867f, 
    0.01417419f, 0.02876501f, -0.10159940f, -0.26545525f, 0.12547362f, 0.03187861f, 0.09775902f, 0.05521225f, 
    0.03666319f, 0.08397692f, 0.16857783f, -0.01855019f, 0.18112336f, -0.01880544f, -0.03447244f, -0.13453382f, 
    0.01467977f, -0.14903182f, -0.01765869f, 0.03714134f, 0.19741628f, -0.06757699f, 0.09485348f, -0.05271841f, 
    -0.05584810f, -0.08556146f, 0.00352063f, 0.09943124f, 0.00967288f, -0.08405077f, -0.13074976f, -0.03873289f, 
    -0.06702256f, -0.13277750f, -0.04447597f, -0.08999014f, -0.07719541f, -0.24696799f, -0.07113193f, -0.08995364f, 
    -0.05149971f, -0.07561228f, 0.04125931f, 0.09441082f, 0.05336904f, 0.00198012f, -0.08357626f, 0.04391148f, 
    0.16686895f, 0.06490817f, 0.03263221f, 0.14743346f, 0.07992926f, 0.02362000f, 0.04564286f, -0.24781537f, 
    0.03114852f, 0.02904941f, 0.14357948f, -0.04661662f, -0.12090293f, -0.02929798f, 0.13483775f, -0.03316058f, 
    0.24822831f, -0.04245344f, 0.37069225f, -0.20172925f, 0.08699245f, 0.33694237f, 0.17828485f, -0.07196820f, 
    -0.12252270f, -0.15093718f, -0.00741841f, 0.09063009f, -0.01653958f, -0.02289248f, -0.02529822f, 0.04377051f, 
    0.11408650f, -0.02709717f, 0.04068007f, 0.11914227f, 0.20513302f, 0.05451778f, -0.05670050f, 0.02905540f, 
    0.03246380f, 0.02246608f, 0.18368243f, 0.30627629f, 0.14411014f, -0.02558526f, -0.13489495f, 0.02980181f, 
    0.23050207f, 0.02648479f, 0.03339537f, -0.09876147f, -0.14571758f, 0.01209468f, -0.06734436f, 0.02872524f, 
    0.04742023f, -0.06125179f, 0.06337247f, 0.01134724f, 0.06557173f, -0.12319133f, -0.13560568f, -0.30816358f, 
    -0.05380562f, 0.08669257f, 0.09260181f, 0.14323518f, 0.13467225f, 0.00601908f, 0.18390718f, -0.21665393f, 
    0.00794830f, -0.02301126f, -0.02664006f, -0.03340649f, 0.03854864f, 0.03545613f, 0.05913738f, -0.11836971f, 
    0.04020166f, -0.06430925f, -0.03462164f, -0.06431154f, -0.11878789f, -0.05904669f, -0.03721324f, 0.05749900f, 
    0.00255639f, 0.20152682f, 0.00893251f, -0.10701334f, -0.00915323f, -0.15932165f, -0.04165498f, -0.06678118f, 
    0.04731458f, 0.30902508f, 0.11916837f, 0.05573127f, -0.04529893f, -0.06306144f, -0.04408015f, 0.01033562f, 
    0.08196946f, 0.14528112f, -0.17562616f, 0.09041438f, 0.33144990f, 0.03287666f, 0.07691262f, 0.10993110f, 
    0.07636784f, -0.01117329f, 0.08867579f, 0.04092150f, -0.27880648f, 0.18128741f, -0.03397820f, -0.02254040f, 
    -0.08966885f, 0.05496549f, 0.07878064f, -0.06648029f, -0.11148363f, -0.15850222f, 0.07001854f, -0.02136066f, 
    0.05057453f, 0.01056599f, 0.23297493f, 0.14155285f, 0.05748082f, 0.22913764f, 0.04708190f, -0.10577652f, 
    -0.02948701f, -0.08062133f, -0.21606812f, 0.03054731f, 0.08394057f, -0.15381575f, -0.14018959f, -0.07146233f, 
    0.07043390f, -0.10220087f, 0.09067103f, 0.10222561f, 0.06216933f, -0.16992338f, 0.01220439f, -0.06143144f, 
    -0.07127619f, 0.19209576f, -0.25101817f, -0.08799673f, 0.09125130f, 0.11377690f, 0.20035838f, 0.16778262f, 
    0.18508145f, 0.14587143f, -0.15337676f, 0.05033561f, 0.11235543f, -0.14063294f, 0.01868335f, 0.05663080f, 
    -0.08130135f, -0.02943340f, -0.02286836f, 0.11673797f, -0.19701895f, -0.02153436f, 0.02175197f, -0.07036398f, 
    -0.06370065f, -0.01103331f, 0.26119068f, -0.08411460f, 0.22463600f, -0.15235229f, -0.37079066f, -0.18397850f, 
    -0.11336877f, -0.01548237f, -0.12734622f, -0.11369926f, -0.10287364f, 0.00131474f, 0.08766029f, -0.00792662f, 
    0.05177062f, 0.05837079f, 0.00828319f, -0.13967875f, 0.48179033f, -0.09065868f, 0.12468486f, 0.04598666f, 
    -0.09087174f, 0.16006397f, 0.08441170f, 0.00368981f, -0.08339976f, -0.06652385f, 0.02549772f, -0.01802247f, 
    0.01151948f, -0.14949758f, -0.03064662f, 0.10119582f, -0.03384878f, 0.11160697f, 0.02051498f, -0.25099444f, 
    0.03216621f, 0.00820531f, 0.01803156f, -0.22195247f, 0.13785489f, -0.03478121f, 0.03503574f, 0.16536154f, 
    0.10106063f, -0.09571037f, -0.07027257f, 0.05657951f, -0.16100885f, 0.06746085f, 0.02167750f, 0.08449493f, 
    0.02857213f, 0.12739226f, 0.01112115f, -0.14364558f, -0.12632585f, -0.33338600f, 0.03402851f, 0.09518261f, 
    -0.05571038f, 0.21144117f, 0.12644003f, 0.22455686f, 0.13259958f, 0.04429895f, 0.07583177f, 0.12642385f, 
    0.05852380f, 0.07871288f, 0.07991713f, -0.07417692f, 0.09801333f, 0.03827062f, -0.16520704f, -0.01063472f, 
    0.03697175f, 0.08516371f, -0.16369113f, 0.05825599f, 0.11848098f, 0.02536374f, 0.03903338f, 0.15260942f, 
    0.06626302f, 0.12750679f, 0.05088985f, 0.15132049f, 0.14598282f, -0.05684737f, 0.21079490f, -0.08752304f, 
    -0.11427444f, -0.29414669f, -0.02581199f, -0.21257666f, -0.00518598f, 0.22881487f, -0.15651053f, 0.00972578f, 
    -0.02026546f, -0.02233633f, -0.11200427f, 0.02165850f, -0.00992427f, -0.02026929f, 0.16682981f, -0.24356171f, 
    -0.06101692f, 0.04605054f, -0.08072176f, 0.00746030f, -0.02823674f, 0.03565553f, 0.02904497f, 0.28746578f, 
    0.14320244f, 0.01638247f, 0.09881526f, 0.10668244f, -0.09387617f, -0.06081411f, -0.05229755f, 0.04515070f, 
    -0.10645916f, -0.03978365f, -0.12680925f, -0.06996470f, 0.21464713f, -0.22709611f, 0.04963102f, -0.06803960f, 
    -0.12585628f, 0.16128583f, 0.03487942f, 0.11572744f, -0.05759714f, -0.00511612f, -0.10294379f, 0.06656472f, 
    -0.06200532f, -0.10454271f, 0.15675654f, -0.31089613f, 0.09449294f, -0.29698116f, -0.02776764f, -0.19029324f, 
    0.06546133f, -0.03148944f, 0.02889827f, -0.12127845f, -0.11343775f, 0.07388786f, 0.14514743f, 0.07852450f, 
    0.12150582f, -0.26915851f, 0.05463115f, 0.10530239f, 0.43874127f, 0.10053519f, 0.16445613f, -0.00588957f, 
    0.06534632f, 0.06505503f, 0.03873704f, -0.09873938f, 0.01056109f, 0.25820041f, 0.00615735f, -0.04638305f, 
    -0.07688481f, -0.09424055f, -0.09166020f, -0.00095206f, 0.02189994f, -0.05412946f, -0.37969092f, -0.02393042f, 
    -0.04130824f, -0.00175137f, 0.04160458f, 0.02908816f, 0.04516871f, 0.03434282f, 0.06810247f, 0.15277024f, 
    0.14447558f, -0.07813710f, -0.23719481f, -0.15975568f, -0.19753583f, -0.01023784f, 0.01973110f, 0.01742797f, 
    -0.02904885f, 0.03336881f, 0.00794069f, 0.03205747f, -0.04700556f, 0.00742664f, -0.03453768f, 0.02523338f, 
    -0.05415333f, -0.04732227f, -0.06702136f, 0.01134340f, -0.03525727f, -0.05638364f, 0.01573028f, 0.04105518f, 
    -0.05946978f, 0.01406552f, -0.04855376f, -0.01481560f, -0.00960933f, 0.01773638f, -0.01945110f, -0.00511268f, 
    0.00336327f, -0.04376350f, 0.01068026f, -0.00466149f, 0.03733996f, -0.03590468f, 0.02421165f, 0.03573767f, 
    -0.05243262f, 0.01725231f, -0.03956593f, 0.03052718f, -0.01227819f, -0.04376497f, -0.03773290f, 0.00654133f, 
    0.04104362f, 0.04387246f, 0.00303158f, 0.00289585f, 0.01728262f, -0.03622368f, -0.03637327f, -0.00600865f, 
    0.05436039f, -0.04163411f, -0.05333566f, -0.03866526f, 0.04378597f, -0.06031327f, 0.01161222f, -0.04109543f, 
    -0.05562068f, 0.01416058f, -0.00413842f, -0.00811339f, -0.04573103f, -0.05012155f, -0.04518884f, -0.05776108f, 
    -0.02312238f, 0.02750706f, 0.01995842f, -0.03356880f, 0.01202275f, 0.02067311f, -0.04977393f, 0.00898053f, 
    -0.06320491f, -0.03351841f, 0.03926604f, 0.05051911f, -0.05688418f, -0.02267421f, -0.03893410f, 0.03879072f, 
    -0.05191528f, 0.04424582f, -0.02423023f, -0.00009695f, 0.02119004f, 0.03096198f, 0.02445768f, -0.00387653f, 
    0.01587481f, 0.03362332f, -0.00449418f, -0.03844533f, -0.04007670f, -0.04467179f, 0.00594715f, -0.03419713f, 
    0.02847438f, -0.03415542f, -0.04402521f, 0.03693427f, -0.03391865f, -0.03081116f, -0.04141850f, 0.00315052f, 
    0.00257738f, 0.01632397f, -0.04259465f, 0.03856728f, 0.01447736f, 0.02737032f, 0.01728509f, 0.02658856f, 
    -0.01571828f, 0.02187401f, 0.01286292f, 0.01746096f, -0.04458699f, 0.02293229f, -0.01646949f, 0.03964793f, 
    -0.02158495f, 0.03167190f, 0.03845528f, -0.00932109f, 0.03627902f, -0.01585314f, 0.02773695f, -0.05882642f, 
    -0.00674266f, 0.04754624f, -0.03293356f, -0.02998411f, -0.02305513f, -0.05836027f, -0.02945649f, -0.04975341f, 
    -0.03636111f, -0.03974909f, -0.03790769f, 0.01506630f, -0.01315034f, -0.04541370f, 0.05022086f, 0.04905165f, 
    -0.03611503f, 0.01720803f, -0.02560403f, -0.04773812f, -0.02855013f, 0.02006409f, -0.05055067f, -0.05732528f, 
    -0.04600481f, -0.01769847f, 0.01129117f, -0.04208942f, 0.02924740f, -0.05123015f, -0.02361211f, -0.02714751f, 
    -0.04886347f, -0.01589026f, 0.03504463f, 0.02988351f, -0.05949416f, -0.04606563f, 0.05321300f, -0.00200951f, 
    0.02731819f, -0.03125066f, 0.02629204f, -0.03168780f, -0.03948013f, -0.03675780f, 0.00771523f, -0.02919882f, 
    0.00888221f, 0.02662287f, -0.00879570f, -0.01493024f, 0.01901525f, -0.05254362f, -0.02963076f, -0.05556120f, 
    0.04004429f, -0.01774807f, -0.04621803f, 0.05410229f, -0.01209492f, -0.06263503f, -0.03864483f, -0.02205671f, 
    0.05244396f, -0.03212423f, 0.04027667f, -0.03486643f, -0.01386853f, -0.02665770f, -0.02940790f, 0.04242463f, 
    0.02613128f, 0.00762149f, -0.00397551f, 0.00547064f, -0.01763689f, 0.03670244f, 0.00945670f, -0.00259334f, 
    -0.06732971f, -0.02241997f, 0.03430171f, -0.03227322f, -0.00499860f, -0.04032221f, -0.03870615f, -0.05107230f, 
    -0.04473835f, -0.04623913f, 0.03956101f, 0.03499554f, -0.00257215f, -0.02024304f, 0.03009674f, 0.02134375f, 
    -0.05516260f, -0.01679312f, -0.03356455f, -0.03381853f, -0.02121179f, -0.04445375f, 0.04390838f, -0.00865611f, 
    -0.00265071f, 0.00396988f, 0.04335944f, -0.03547250f, 0.04465777f, -0.01307961f, -0.02203208f, 0.04382708f, 
    -0.05748402f, 0.04086281f, 0.03983434f, 0.04922142f, -0.01783769f, -0.03177167f, -0.03322738f, -0.01400874f, 
    -0.02418760f, 0.03371111f, 0.01763337f, 0.01134803f, -0.01198526f, -0.01129213f, 0.00909396f, -0.01127381f, 
    0.05032111f, -0.03367289f, 0.00967905f, 0.02395450f, 0.03110119f, 0.01099084f, -0.02501638f, 0.00739752f, 
    0.00967261f, -0.04861023f, -0.04228867f, -0.00988572f, 0.04012130f, 0.03744654f, -0.05936743f, 0.05316954f, 
    -0.02149772f, -0.05702064f, 0.00566442f, -0.05217971f, -0.00340964f, -0.02433648f, 0.04312359f, 0.00959168f, 
    -0.03136481f, -0.05484915f, -0.03296165f, -0.04383110f, -0.01035060f, -0.05222076f, -0.00004741f, -0.06712441f, 
    0.18720432f, -0.01953615f, 0.13535497f, 0.00307713f, 0.09641259f, 0.09931368f, 0.07568778f, -0.08383612f, 
    -0.02955921f, -0.05130511f, 0.23273161f, 0.26850918f, -0.16225843f, 0.01335750f, -0.21883795f, -0.01074415f, 
    -0.10230246f, 0.03365886f, 0.04715669f, -0.00720340f, -0.19952279f, -0.21418342f, 0.17285292f, -0.07382441f, 
    -0.04881572f, 0.06840775f, 0.04047117f, 0.20217779f, -0.21922491f, -0.21633908f, 0.03617414f, -0.03653178f, 
    -0.02997485f, -0.03014949f, 0.01133644f, -0.04315121f, 0.03850206f, -0.27643520f, -0.13964589f, -0.18119913f, 
    0.10812447f, 0.06934153f, 0.01369997f, 0.00225703f, 0.06190129f, -0.17055486f, 0.05256699f, 0.29873219f, 
    -0.01459042f, 0.09099898f, -0.00118605f, 0.07258261f, 0.01396937f, -0.03749518f, 0.08535589f, 0.04880939f, 
    -0.30111781f, -0.07618690f, -0.07899651f, -0.09285074f, 0.09248558f, 0.04166469f, 0.00193726f, -0.14674357f, 
    -0.03270854f, 0.01050801f, 0.04618856f, 0.02014568f, -0.11997006f, -0.03457560f, 0.07764377f, -0.10975283f, 
    -0.31914967f, -0.29859886f, 0.08179118f, -0.01157642f, -0.01120977f, 0.12948765f, 0.10032362f, 0.11066484f, 
    -0.08900910f, 0.24819760f, 0.03420637f, -0.18388493f, -0.06677788f, -0.22163668f, -0.15854073f, 0.05089151f, 
    0.13468941f, 0.11190680f, 0.30464154f, -0.29425922f, -0.05070121f, 0.04655211f, 0.03072956f, 0.03417071f, 
    0.06801812f, 0.05065026f, 0.03950936f, 0.22051826f, -0.09799257f, -0.01858545f, 0.06067502f, -0.13363303f, 
    -0.00556188f, 0.02118939f, 0.16733810f, -0.01022414f, 0.15408240f, 0.22988768f, -0.03378376f, -0.02163845f, 
    -0.01399359f, 0.13400397f, 0.00990433f, -0.00988989f, -0.05333105f, 0.02238527f, -0.24823436f, -0.02033137f, 
    0.13228399f, 0.00443431f, 0.03953574f, 0.15844010f, 0.03191739f, -0.02306753f, 0.28173259f, 0.11792322f, 
    -0.28142107f, -0.01869927f, -0.02932019f, 0.11881065f, -0.02967189f, 0.13297567f, -0.06819651f, 0.13667738f, 
    -0.09425798f, 0.15952188f, 0.01751805f, 0.15252025f, 0.05387902f, -0.03273992f, -0.11614674f, -0.04765788f, 
    -0.16147566f, 0.02849621f, -0.68392730f, -0.12211689f, -0.22893859f, 0.02012498f, 0.11228969f, 0.08649183f, 
    -0.08743224f, 0.33680186f, 0.32796842f, 0.21466565f, -0.10382071f, 0.01318165f, -0.13224182f, 0.01064400f, 
    0.06755394f, 0.03432718f, 0.12430381f, -0.29800537f, -0.22485875f, 0.06304275f, -0.17854206f, -0.15069206f, 
    0.03948715f, 0.01168552f, -0.06003346f, -0.10057097f, -0.00139712f, 0.22490746f, -0.16244844f, 0.11241852f, 
    -0.01674688f, 0.08786521f, 0.03792167f, -0.07832467f, 0.13913305f, -0.26801786f, -0.16437224f, 0.01596119f, 
    -0.09465603f, 0.00076245f, 0.07977417f, 0.03032848f, 0.14142893f, 0.18464255f, -0.02452327f, -0.16588627f, 
    -0.00305017f, -0.11081922f, 0.07091813f, 0.11921745f, 0.00220013f, -0.03431915f, 0.05927565f, 0.07752157f, 
    -0.07405166f, -0.02115987f, 0.06329976f, 0.09742074f, -0.03112339f, -0.04534880f, 0.01896367f, -0.07598151f, 
    0.12992738f, 0.22208543f, -0.01160482f, -0.04091828f, -0.03442094f, -0.05412552f, -0.00396496f, 0.15151176f, 
    0.14408980f, 0.05307837f, -0.08907808f, -0.03429816f, -0.09191425f, -0.11064460f, 0.09601894f, -0.03161708f, 
    0.02783048f, 0.25520098f, 0.24947029f, 0.23117778f, -0.00081406f, 0.00547694f, 0.21260901f, 0.09857088f, 
    0.09839632f, 0.08191882f, 0.08347419f, -0.03189156f, 0.04832080f, -0.08631246f, -0.02577551f, 0.15688334f, 
    0.05459579f, -0.12160341f, -0.01969454f, -0.49856615f, 0.00259689f, 0.16713502f, -0.21859963f, -0.08841627f, 
    -0.12487889f, -0.17606382f, 0.13966085f, -0.02606564f, 0.13986968f, 0.29218906f, 0.17942320f, -0.11383375f, 
    -0.07770954f, -0.09407740f, -0.01127435f, 0.06797898f, 0.05901064f, -0.15827280f, 0.15227453f, 0.15360859f, 
    -0.07968584f, -0.04855317f, 0.12652130f, 0.02760829f, -0.05297594f, -0.01697265f, -0.01836505f, -0.21666825f, 
    -0.54660666f, -0.07440530f, -0.00744376f, -0.13034283f, 0.07099697f, 0.06937820f, 0.04974559f, -0.20077069f, 
    -0.35285458f, -0.06271362f, -0.15507846f, 0.01966682f, 0.06221721f, 0.06105274f, 0.12691188f, 0.11762132f, 
    -0.34570655f, -0.31271008f, -0.39931652f, 0.05031888f, -0.01038988f, 0.00478644f, -0.00967139f, 0.02605251f, 
    -0.00279241f, -0.13186510f, 0.00884939f, 0.16001163f, -0.02300239f, 0.01602687f, -0.10580159f, 0.00571978f, 
    0.09415387f, 0.20488729f, -0.01156831f, 0.01320032f, 0.22028936f, 0.04429484f, 0.09607768f, 0.05115421f, 
    -0.06118029f, -0.06965162f, -0.00490226f, 0.24471962f, 0.00089692f, 0.03008338f, -0.06931067f, -0.32406780f, 
    0.01341753f, 0.14254072f, -0.03019357f, -0.00039520f, 0.07695545f, -0.02402851f, 0.08560479f, 0.00216091f, 
    -0.04502826f, 0.05072808f, 0.03174208f, 0.09978859f, 0.04762468f, 0.02903983f, -0.25374851f, -0.37419915f, 
    -0.08960301f, -0.04285215f, -0.10650089f, -0.08792383f, 0.01846991f, -0.23619431f, -0.21098755f, 0.06787306f, 
    -0.08533905f, 0.09930135f, 0.06381787f, 0.22859155f, -0.14576879f, -0.10251429f, 0.06730665f, 0.12499720f, 
    -0.02238881f, 0.04974282f, 0.07911596f, 0.04254113f, 0.15016140f, 0.16393244f, -0.05143901f, 0.14302199f, 
    -0.15421548f, 0.06880470f, 0.20340097f, 0.02130469f, -0.14239012f, -0.15726636f, 0.13844275f, -0.10324291f, 
    -0.04450936f, 0.20478147f, 0.08337324f, 0.07533550f, -0.13576138f, -0.06189086f, -0.10652982f, 0.01845642f, 
    0.03948136f, -0.01311034f, 0.11570543f, 0.18100804f, -0.12509809f, -0.05063821f, -0.01006684f, -0.13018757f, 
    -0.01120546f, -0.03966863f, -0.01538272f, 0.24289961f, -0.05211325f, 0.11818365f, 0.05858321f, 0.15767227f, 
    0.01770531f, 0.00476186f, -0.04209146f, 0.00694740f, 0.44939733f, -0.04814135f, -0.14647958f, -0.00341128f, 
    -0.00812191f, 0.00753508f, 0.06502115f, 0.00373840f, 0.10662665f, 0.07299807f, 0.08708758f, 0.04015801f, 
    -0.00479166f, -0.03152657f, -0.28198567f, -0.05048359f, 0.02528740f, 0.08341526f, 0.35018885f, 0.05055382f, 
    -0.25655726f, -0.11285232f, -0.02593639f, 0.09202360f, 0.08586328f, 0.06586304f, 0.06957757f, -0.25365564f, 
    -0.17233300f, -0.18668722f, -0.06711919f, 0.08787356f, -0.23286332f, -0.00446457f, 0.03586274f, 0.18059620f, 
    0.12736417f, 0.04811744f, 0.05378668f, -0.35431835f, -0.04256507f, -0.07236774f, 0.09791953f, 0.06003131f, 
    0.04639750f, -0.19453584f, 0.10347402f, -0.04457891f, 0.03038778f, 0.08074471f, 0.14052905f, 0.08149406f, 
    0.05690178f, 0.05773846f, 0.38231120f, 0.17310458f, 0.15208913f, 0.06361308f, 0.01050542f, -0.08474272f, 
    -0.25844210f, 0.05354913f, 0.11318580f, -0.00198262f, -0.00966286f, 0.13206312f, -0.11451553f, 0.11150561f, 
    0.07236615f, 0.09415869f, 0.07407032f, -0.05229474f, 0.28807354f, 0.12986742f, 0.02213263f, -0.18156503f, 
    -0.02338983f, -0.05838310f, 0.05516189f, -0.03403930f, -0.15403716f, 0.41583830f, 0.10677649f, -0.23214798f, 
    -0.09606812f, -0.02332108f, -0.00150521f, 0.02285460f, -0.04041601f, -0.11773030f, 0.13452867f, 0.00890238f, 
    -0.41936928f, -0.13196604f, 0.01606357f, 0.05977378f, -0.00026702f, -0.05277805f, 0.07271783f, -0.71041900f, 
    0.03296069f, 0.01745829f, -0.08308266f, 0.05553768f, -0.10313845f, -0.14787988f, 0.04573541f, -0.10217126f, 
    0.02974745f, -0.10998133f, -0.22988571f, -0.05797126f, -0.09176394f, -0.10527974f, -0.17681745f, -0.02474502f, 
    -0.06562501f, 0.07889988f, 0.26675755f, 0.04603878f, -0.09985684f, -0.10426997f, -0.16263720f, 0.04182932f, 
    0.00778722f, -0.07170717f, -0.05178255f, -0.36856982f, -0.23309816f, -0.02817534f, 0.00339661f, -0.02408994f, 
    -0.04544725f, -0.20420201f, -0.11965884f, -0.30472311f, 0.06259567f, 0.08228257f, 0.10639548f, 0.05920374f, 
    0.00954024f, 0.02448173f, 0.07729896f, -0.28362203f, -0.14642532f, 0.05935562f, -0.30355415f, 0.02743405f, 
    0.01086859f, 0.06774969f, -0.00881386f, 0.03816931f, -0.07145175f, -0.29169929f, -0.26745731f, -0.09561121f, 
    -0.06270736f, -0.03895915f, -0.07496088f, 0.14731529f, 0.05463249f, 0.08284452f, -0.11722073f, -0.19115183f, 
    -0.16519006f, 0.07476772f, 0.10448357f, 0.11725681f, 0.20234090f, 0.12578562f, -0.07317805f, 0.22420108f, 
    0.06154444f, 0.14629728f, -0.32521069f, -0.18812191f, -0.22512609f, 0.10573483f, 0.06529550f, -0.07308911f, 
    -0.03008136f, 0.10806918f, -0.22169241f, 0.03878595f, 0.06164483f, 0.02947562f, 0.01858477f, -0.12863775f, 
    0.14268044f, 0.24384546f, 0.12253683f, 0.29306078f, -0.09706153f, 0.04080639f, -0.10561501f, 0.12725055f, 
    -0.03516361f, 0.03671176f, 0.10318944f, -0.10541325f, 0.20520458f, 0.17408817f, -0.02669601f, -0.03856312f, 
    -0.09647012f, -0.07906367f, -0.05222367f, 0.17809066f, 0.33503050f, 0.03134635f, -0.00566569f, 0.01351568f, 
    0.01796841f, -0.10416010f, -0.04551828f, -0.03480721f, -0.23600882f, -0.26249939f, -0.21289952f, 0.02839960f, 
    0.00178298f, 0.20650277f, 0.06802547f, 0.00765431f, 0.02029893f, -0.04573158f, 0.19265780f, 0.02750293f, 
    -0.17397287f, -0.02442727f, -0.01114069f, 0.13204379f, 0.05626298f, -0.00860068f, -0.05222718f, -0.04364433f, 
    0.02498092f, -0.15340728f, -0.04990640f, 0.12919906f, 0.05351879f, -0.02545092f, 0.06051907f, -0.25279248f, 
    -0.00132196f, -0.37582096f, -0.14642718f, 0.01945429f, 0.12342444f, 0.03393224f, 0.15271628f, -0.06796665f, 
    -0.48507687f, -0.17044459f, -0.04851430f, -0.08993939f, 0.03389788f, 0.03394551f, -0.06438866f, 0.11366253f, 
    0.03855761f, -0.08237945f, 0.06951714f, -0.08041870f, -0.16483809f, -0.24126114f, -0.05109870f, 0.02338043f, 
    -0.01040793f, 0.08103526f, -0.32108304f, 0.26604819f, 0.12615903f, -0.14147732f, -0.37295619f, 0.00038153f, 
    0.02638449f, -0.00437119f, 0.02739946f, -0.20594460f, -0.18184450f, -0.36440301f, 0.04899270f, 0.18333988f, 
    -0.40033606f, -0.06187636f, -0.01977818f, -0.03086081f, 0.20405675f, 0.12246972f, 0.12931314f, -0.07784914f, 
    -0.13730240f, 0.01648027f, 0.18945183f, 0.10546090f, 0.02343776f, -0.20021489f, -0.13852656f, 0.05885196f, 
    -0.22342961f, 0.06909018f, 0.01509465f, -0.13139400f, -0.08965309f, 0.04919225f, -0.07662140f, 0.27615991f, 
    -0.11551895f, -0.09638302f, -0.10832909f, -0.06174180f, 0.05781548f, 0.09259934f, 0.09416976f, -0.22994421f, 
    -0.04959152f, -0.01564232f, -0.03587714f, 0.05261137f, -0.07231381f, -0.02408797f, -0.01301732f, 0.02646356f, 
    -0.04388462f, -0.17271996f, -0.24798518f, 0.10787205f, -0.00080616f, -0.14865613f, 0.17060921f, 0.13959606f, 
    0.14557962f, 0.21187216f, 0.28198975f, 0.00020018f, -0.08014031f, 0.04703109f, 0.02533277f, 0.06737736f, 
    0.10642520f, -0.12693773f, -0.67760599f, 0.04495346f, -0.33731982f, -0.10517740f, -0.12126841f, -0.08915157f, 
    0.10615633f, 0.00910277f, -0.05623430f, -0.03269938f, -0.11546095f, 0.03614389f, 0.07096682f, 0.11695276f, 
    -0.24122867f, -0.02276581f, 0.05902254f, 0.00035655f, -0.46697408f, 0.16034919f, 0.19482370f, -0.09927601f, 
    -0.17185850f, -0.01799816f, 0.03514956f, -0.07802182f, 0.09090838f, 0.02454182f, 0.18140081f, 0.20266627f, 
    -0.06281781f, -0.20243303f, -0.00341070f, 0.07935040f, -0.11577503f, 0.04736786f, 0.12371139f, 0.16200414f, 
    0.19728775f, -0.02015922f, -0.15859413f, 0.00480456f, -0.03926758f, 0.02011983f, 0.05948711f, 0.12176371f, 
    0.09348410f, 0.31414366f, 0.08832885f, 0.06706533f, -0.13418928f, -0.08925812f, -0.01702168f, 0.07367892f, 
    -0.08692967f, 0.37633464f, -0.01871236f, -0.12343728f, -0.09173187f, -0.00619110f, -0.01192260f, -0.08665533f, 
    0.02162265f, 0.12245651f, 0.22540513f, -0.03582695f, -0.06144912f, -0.08852199f, -0.13827652f, 0.10746858f, 
    -0.05394219f, -0.01005885f, -0.34742230f, -0.01626195f, 0.18396336f, -0.02953785f, -0.20220874f, -0.07925303f, 
    0.11705767f, 0.09861282f, -0.03535857f, -0.62085938f, 0.04097469f, -0.22488819f, 0.14844930f, -0.01235232f, 
    -0.20413274f, -0.14278300f, 0.00861315f, 0.04796844f, 0.16331585f, 0.16794413f, 0.06581495f, -0.01037182f, 
    -0.02808814f, -0.13349503f, -0.01981899f, 0.04731068f, 0.00448956f, 0.04773211f, -0.02143643f, 0.12400902f, 
    -0.04936766f, 0.03297503f, 0.08378160f, 0.14289212f, 0.01368580f, 0.12827082f, 0.23787861f, -0.67356449f, 
    -0.23715964f, 0.06304677f, 0.01079409f, -0.08116373f, -0.09263854f, 0.01897525f, -0.00909465f, 0.31857094f, 
    -0.14490820f, 0.20770128f, -0.24391766f, 0.05761079f, 0.14607969f, 0.16662686f, 0.01121603f, 0.07883575f, 
    -0.01253406f, -0.04657421f, 0.02447474f, -0.00436604f, -0.01196639f, -0.02410539f, 0.04290108f, 0.04310352f, 
    0.00818691f, 0.00678939f, 0.04938470f, -0.03917224f, 0.04495710f, -0.03114880f, -0.03395057f, 0.03816364f, 
    -0.03497492f, -0.02814272f, -0.03649174f, -0.04438442f, -0.06300584f, 0.04952629f, -0.02459448f, -0.02803398f, 
    -0.00846586f, -0.04920979f, -0.02457499f, -0.01454177f, -0.05399198f, -0.02706287f, 0.01597162f, -0.01036581f, 
    -0.00025585f, -0.00345895f, 0.02845185f, 0.04574512f, -0.02353449f, -0.00298077f, 0.03724002f, 0.01019150f, 
    0.03501636f, -0.05850071f, -0.01551821f, 0.01230196f, 0.01929484f, -0.07039009f, 0.01055828f, -0.00271032f, 
    -0.06152324f, -0.00140621f, -0.02722968f, 0.01813754f, 0.02064499f, -0.00387846f, -0.04130692f, 0.02608929f, 
    -0.05521002f, -0.00962567f, -0.01804676f, -0.06915303f, -0.05947799f, -0.03931154f, -0.02710027f, -0.05881321f, 
    0.02295521f, -0.05660414f, 0.02602301f, 0.03495736f, -0.05006057f, -0.01115021f, -0.05860797f, -0.05251600f, 
    -0.02422921f, -0.04985791f, -0.02380634f, 0.00274122f, -0.06502464f, -0.02325712f, -0.00836202f, 0.00130855f, 
    0.02421063f, 0.01355307f, 0.00903373f, 0.04214145f, 0.02012341f, 0.02679325f, 0.01466825f, -0.03331153f, 
    -0.04982837f, -0.04834366f, 0.01495978f, -0.03048988f, 0.02706888f, 0.04588460f, -0.01677824f, 0.04443228f, 
    -0.04933300f, -0.04556945f, -0.03170241f, -0.01626441f, -0.05277983f, -0.02880499f, -0.02199718f, -0.00777815f, 
    0.04027138f, -0.06061812f, 0.04270188f, -0.03747456f, -0.00690207f, -0.04787782f, 0.02540924f, 0.03703707f, 
    -0.01844932f, 0.01405264f, -0.05971807f, -0.03543860f, 0.00744989f, 0.02066105f, -0.01544561f, 0.00120044f, 
    -0.07382358f, -0.05217534f, -0.00503082f, 0.01330289f, -0.07144131f, -0.06462547f, 0.01009298f, -0.02001207f, 
    -0.00824447f, 0.03509109f, 0.04360159f, 0.03043002f, 0.03444288f, -0.04707061f, -0.03271496f, -0.03131720f, 
    -0.01484012f, -0.02982438f, -0.04748836f, 0.04938753f, -0.00864732f, -0.02498184f, 0.03989374f, -0.00274308f, 
    -0.00176142f, 0.03260399f, 0.01545665f, -0.04476581f, -0.02612286f, 0.00771811f, 0.02085162f, -0.02309600f, 
    -0.02553576f, 0.01060428f, -0.00833620f, 0.03974371f, 0.03985627f, -0.04374271f, 0.02636524f, 0.00750913f, 
    0.02493189f, -0.05230730f, 0.02001018f, -0.06326323f, 0.01356467f, 0.05271903f, 0.03404919f, -0.04980035f, 
    -0.02378883f, 0.01619006f, -0.03841799f, 0.01509279f, -0.05967614f, 0.02211056f, 0.01844624f, -0.05974000f, 
    -0.01331117f, 0.02718787f, -0.05393643f, 0.02353493f, -0.04906634f, -0.05545039f, 0.05024634f, -0.03262367f, 
    0.04214977f, -0.01818093f, 0.04659558f, 0.02510415f, 0.04140519f, -0.04717281f, 0.05907902f, -0.01706593f, 
    -0.03234748f, 0.00926001f, 0.00691528f, 0.00128139f, -0.02994437f, -0.03582046f, 0.00624018f, -0.00642316f, 
    0.03694801f, 0.04477133f, -0.02796927f, -0.00357787f, -0.01134590f, -0.04436794f, 0.03781243f, 0.02710225f, 
    -0.05357071f, -0.04576100f, -0.04602411f, 0.03722500f, -0.02328691f, -0.06074336f, 0.02568014f, 0.03789584f, 
    -0.04914809f, 0.03724201f, -0.03287983f, -0.05371040f, -0.06455110f, -0.00347296f, 0.04190544f, -0.03443442f, 
    -0.05883634f, 0.02085469f, -0.04281604f, -0.00697863f, 0.04119007f, 0.02192539f, 0.02650275f, 0.03280488f, 
    -0.01188792f, 0.03191513f, -0.04621632f, -0.01666295f, 0.01171972f, 0.05162226f, 0.02256089f, 0.02667815f, 
    0.00380125f, -0.03201676f, 0.05506546f, -0.05911799f, -0.01517945f, 0.01068385f, 0.00218639f, 0.02377030f, 
    0.01042514f, 0.04294840f, -0.07050192f, -0.04266736f, 0.00202741f, 0.02767949f, 0.00058902f, -0.04462258f, 
    -0.00777215f, -0.03807914f, 0.00488237f, 0.00659149f, 0.02492756f, -0.01618386f, -0.01718900f, 0.02370356f, 
    -0.02496936f, 0.05033957f, 0.05589030f, 0.04644071f, -0.02777966f, -0.01655380f, 0.02882377f, -0.03935079f, 
    0.00207475f, -0.01831467f, 0.02347670f, -0.04214433f, -0.01155559f, -0.05418646f, -0.04380606f, 0.03117974f, 
    -0.01740520f, -0.00213015f, -0.00057582f, 0.01732319f, -0.01023945f, 0.00696816f, -0.04346289f, 0.01670993f, 
    -0.06486274f, 0.06870097f, 0.11395760f, 0.02144789f, -0.04086135f, -0.03687572f, 0.05926502f, 0.00830553f, 
    -0.01314817f, -0.04083681f, -0.23850685f, 0.21770777f, -0.38090634f, -0.03323012f, -0.02801430f, 0.07741002f, 
    -0.04216078f, 0.07953444f, -0.08842223f, -0.19181901f, 0.22870150f, -0.31334350f, -0.00433345f, -0.33788252f, 
    0.11261413f, -0.05543934f, 0.09895471f, -0.14805035f, -0.04279309f, 0.27871925f, 0.01009970f, -0.02310532f, 
    0.13456108f, -0.03558160f, -0.01525119f, 0.24466762f, -0.06130016f, 0.00860673f, -0.08385533f, -0.01408912f, 
    0.11789814f, 0.03340431f, 0.06321331f, 0.09572775f, 0.09107801f, 0.13494401f, -0.11129472f, -0.10741957f, 
    -0.00594815f, -0.18855417f, 0.01080802f, -0.08349326f, 0.12880132f, 0.10624232f, -0.17341468f, 0.14159198f, 
    0.33197635f, -0.01799405f, 0.04144531f, -0.22387378f, 0.07232093f, -0.12593608f, -0.00081325f, 0.01061614f, 
    0.03447336f, -0.10449398f, -0.01321073f, 0.12224485f, 0.14093325f, 0.08805343f, -0.01098106f, 0.09503045f, 
    0.28006837f, 0.12864110f, -0.23150451f, 0.15448883f, 0.09946361f, -0.06278462f, -0.01044958f, -0.08754604f, 
    0.17506216f, -0.03849431f, 0.14387284f, 0.15148629f, 0.04354307f, -0.01185740f, -0.05036847f, 0.02054155f, 
    0.14603978f, 0.18991698f, -0.28595865f, 0.01599910f, 0.17359737f, 0.04854429f, 0.00767626f, -0.19839028f, 
    -0.13297054f, -0.04813156f, 0.01979156f, -0.04422170f, 0.00105588f, 0.10340991f, 0.04387020f, -0.10235125f, 
    -0.03173847f, -0.13861778f, -0.15716951f, -0.04079762f, -0.20557831f, -0.05807551f, 0.26814649f, 0.01300078f, 
    0.03218269f, 0.07166643f, -0.14879715f, 0.04402903f, -0.07473417f, 0.04546962f, -0.15457411f, -0.23018892f, 
    -0.02955383f, -0.02441975f, -0.14353134f, 0.00711380f, 0.11931574f, 0.12961856f, -0.37065572f, -0.33095720f, 
    0.30895543f, -0.12935157f, 0.04498871f, 0.10390668f, 0.05711752f, -0.07703339f, 0.00446789f, 0.19509102f, 
    0.17007993f, -0.28845176f, 0.05732345f, 0.03482670f, 0.05114765f, -0.04364677f, -0.04399275f, -0.12304521f, 
    0.11869463f, -0.01725347f, -0.15383449f, 0.04174101f, -0.07030139f, 0.01868089f, 0.01831974f, 0.00479703f, 
    0.07641537f, -0.04886985f, -0.11875370f, -0.06453617f, -0.04219725f, 0.03488463f, -0.01705793f, 0.11524602f, 
    0.19648148f, -0.04171710f, 0.05906522f, -0.14977573f, -0.05632987f, -0.07574412f, 0.04984270f, -0.11245548f, 
    0.01412554f, -0.13222192f, 0.05263167f, 0.04892107f, 0.04892958f, -0.13325302f, 0.06854760f, -0.05135095f, 
    -0.01260156f, 0.07915075f, 0.17483434f, 0.10861181f, -0.11037359f, -0.09204585f, -0.01273205f, 0.14846608f, 
    0.02854485f, -0.06269023f, -0.12505724f, -0.14248657f, 0.10792427f, -0.30296382f, -0.13845219f, 0.17356487f, 
    0.13534871f, 0.13492581f, 0.04360249f, 0.04088866f, -0.01133399f, 0.13669485f, -0.20016918f, -0.11953468f, 
    0.20253915f, 0.05707079f, 0.02160094f, -0.00771611f, -0.02075183f, 0.01219693f, -0.00664527f, 0.14724568f, 
    -0.07196210f, 0.12575027f, -0.00413882f, -0.07551974f, -0.04270645f, 0.07865161f, 0.06160483f, 0.09791008f, 
    -0.27827048f, 0.17633645f, 0.35991469f, -0.11757012f, 0.04935934f, -0.21983530f, 0.05343725f, 0.02201203f, 
    0.00866276f, -0.17677380f, -0.18467136f, 0.26037490f, 0.09820575f, -0.04091420f, -0.11748406f, -0.13714629f, 
    -0.00780411f, 0.03996655f, -0.26632866f, 0.25069219f, 0.20608322f, 0.10648540f, -0.03210624f, -0.30720344f, 
    0.13716322f, 0.06723057f, -0.02102248f, -0.29559055f, -0.31158447f, -0.01948756f, -0.21491334f, -0.02475925f, 
    0.22518894f, -0.21501686f, -0.07112338f, -0.12074643f, -0.04409458f, -0.18589103f, 0.13664192f, 0.09553570f, 
    0.14860702f, -0.04747125f, 0.04469409f, 0.02199980f, -0.07013147f, -0.02688158f, -0.08475138f, 0.02085099f, 
    -0.02239935f, -0.00382684f, 0.16159421f, -0.09773576f, 0.03078062f, -0.05056595f, 0.10886968f, -0.06075754f, 
    0.25402594f, -0.08553519f, -0.11215164f, -0.12247144f, -0.02793196f, 0.02441216f, -0.04213049f, 0.03249911f, 
    -0.05150659f, -0.17083655f, 0.06478696f, -0.03807181f, 0.01713204f, -0.02451402f, 0.06328727f, 0.15941706f, 
    -0.05299231f, -0.00079523f, -0.10975900f, 0.06316490f, -0.04186763f, -0.06853555f, 0.07984910f, -0.06718702f, 
    0.06496581f, -0.33143511f, -0.25802010f, -0.27613443f, 0.08806133f, 0.01121411f, 0.11900403f, -0.00344791f, 
    0.01276484f, -0.18312511f, -0.38661054f, 0.07386350f, -0.10677925f, 0.16823247f, -0.02988105f, 0.00257769f, 
    0.01372884f, 0.16849433f, 0.00774624f, -0.04305983f, 0.09892793f, -0.12803172f, 0.03747635f, 0.05170558f, 
    -0.03403634f, -0.02195968f, -0.11691216f, -0.19497287f, -0.02285817f, 0.00934406f, -0.07513515f, 0.04007858f, 
    -0.07140215f, -0.12538484f, 0.07729349f, 0.20168309f, 0.02134723f, -0.04156978f, -0.02605032f, 0.10279834f, 
    0.06043522f, -0.08014846f, 0.02402699f, -0.08110000f, 0.07148856f, -0.00392626f, -0.05280849f, 0.01585564f, 
    0.02592098f, 0.13286699f, -0.05122798f, -0.04414853f, 0.21044302f, 0.08447004f, -0.22505650f, 0.17340450f, 
    -0.06778745f, -0.05469131f, 0.03163564f, 0.01465312f, -0.07185609f, -0.02522314f, 0.11973580f, 0.17412098f, 
    -0.00737649f, -0.19843082f, 0.16869792f, 0.01128498f, -0.01341657f, 0.09829393f, -0.02222033f, -0.04415599f, 
    -0.05475540f, -0.06967514f, -0.13181739f, -0.15989184f, -0.04221983f, 0.14899202f, 0.01920280f, -0.10922545f, 
    0.08736307f, -0.08236041f, -0.03558782f, 0.08191084f, -0.05004707f, -0.05155971f, -0.12802379f, 0.06532776f, 
    0.03424098f, -0.19861317f, -0.29909027f, -0.07608660f, -0.29196280f, -0.14021857f, -0.06386328f, 0.06978799f, 
    -0.04804651f, 0.01285777f, -0.02324885f, -0.05318436f, -0.11702514f, 0.13867775f, 0.12377382f, -0.13875951f, 
    0.04394398f, -0.01511748f, 0.05240886f, 0.07980573f, 0.00847222f, 0.05963303f, -0.16197124f, 0.03185955f, 
    -0.06775343f, 0.01149223f, 0.05557621f, 0.02152992f, -0.07518105f, -0.11730406f, 0.10714822f, 0.07153741f, 
    0.02333897f, 0.18266100f, 0.11195310f, 0.15629408f, -0.06609251f, -0.07920393f, 0.14178596f, 0.07716568f, 
    -0.18098237f, 0.29548764f, 0.04142412f, -0.00840465f, 0.04745230f, -0.17685087f, -0.04924373f, -0.15700158f, 
    -0.11332801f, 0.10900219f, 0.10547946f, 0.18187293f, 0.03543914f, -0.14639741f, -0.02070622f, 0.14780013f, 
    0.12050692f, 0.01879027f, -0.04062035f, 0.10046746f, -0.00246974f, 0.04598598f, -0.14648965f, 0.09013332f, 
    0.21096338f, 0.16017963f, -0.13776681f, -0.02974023f, -0.26374835f, 0.03449288f, 0.14738314f, -0.04958289f, 
    -0.14891006f, -0.06929690f, -0.08773754f, -0.05738287f, -0.10482758f, 0.03021298f, -0.03131897f, 0.05608060f, 
    -0.01378619f, 0.13167690f, 0.18268245f, 0.23991218f, -0.15360589f, 0.08919783f, -0.08046106f, 0.08228537f, 
    0.01799483f, 0.16218476f, -0.14616826f, -0.11407289f, -0.16159351f, -0.04032518f, 0.18184914f, 0.04458337f, 
    0.08859315f, 0.05654644f, -0.03206131f, -0.03709596f, -0.01317476f, 0.04163844f, 0.06394836f, 0.14440769f, 
    0.02394178f, -0.14196149f, -0.16719739f, -0.02223286f, -0.10864443f, -0.00839049f, -0.11043918f, -0.03676097f, 
    -0.01800540f, 0.21795823f, 0.12544230f, 0.11935507f, 0.08063618f, 0.04802162f, -0.04323976f, 0.08938111f, 
    0.28155726f, 0.06501872f, -0.04684808f, 0.08809110f, -0.14774084f, -0.01122035f, -0.01765589f, -0.14992516f, 
    0.13439025f, -0.29253474f, -0.12215845f, -0.07262516f, -0.03571468f, 0.00323927f, 0.02288556f, 0.03178159f, 
    0.04592539f, -0.01554308f, 0.16839705f, 0.07436790f, 0.13570163f, 0.07853712f, 0.03455182f, 0.00448458f, 
    -0.12374697f, -0.01895687f, 0.00493587f, 0.23395136f, -0.01149250f, 0.03283094f, -0.06510438f, 0.22038557f, 
    0.08511356f, 0.23431228f, 0.22749472f, 0.12523350f, 0.06277026f, 0.01539090f, 0.08129316f, 0.04150812f, 
    0.03890920f, -0.16266765f, 0.17613004f, 0.18681404f, 0.29034311f, -0.28061804f, -0.02707196f, 0.00774279f, 
    0.14326699f, -0.02808542f, 0.15066396f, -0.14449534f, 0.01044165f, -0.41748410f, -0.09666554f, -0.20654680f, 
    0.20267811f, 0.07177250f, 0.04913762f, -0.00488740f, -0.04626636f, -0.01056439f, 0.01793347f, -0.12379923f, 
    -0.14618821f, -0.00349923f, 0.14154208f, 0.02818785f, -0.00910058f, 0.10453678f, -0.00316510f, 0.18699197f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.03693492f, 0.04621843f, 0.17716831f, 0.08294970f, 0.02704596f, -0.05975882f, 0.24141079f, -0.06005072f, 
    0.18958534f, 0.05003190f, 0.03201455f, 0.08615811f, -0.08600357f, 0.09688365f, 0.01708873f, 0.01062416f, 
    0.26535821f, 0.10603525f, 0.00856039f, 0.19873878f, 0.03181712f, 0.24619584f, 0.16055349f, 0.09533972f, 
    0.01264512f, -0.01117074f, -0.04031178f, -0.07089373f, 0.02623519f, -0.04004258f, 0.15824930f, 0.07802842f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.01293838f, 0.08573478f, 0.52350247f, 0.30999270f, -0.45966730f, 0.16664249f, -0.04669860f, 0.10637491f, 
    -0.44993255f, 0.08374324f, 0.13926397f, -0.38162535f, 0.24217799f, 0.00570097f, 0.25080603f, -0.04736932f, 
    0.15730153f, 0.13641505f, 0.01884373f, 0.03247797f, 0.25698912f, 0.16187188f, -0.06710518f, 0.00635084f, 
    0.05618808f, 0.03002295f, 0.03592202f, -0.24107552f, -0.12182903f, -0.11164924f, 0.04206486f, -0.20857616f, 
    -0.09353761f, 0.11794363f, -0.00353056f, -0.07765817f, -0.06828776f, 0.03532144f, 0.04545037f, -0.18164369f, 
    -0.16235755f, -0.04590546f, 0.02108886f, -0.23138261f, 0.00579240f, -0.19509451f, -0.18546176f, 0.00699104f, 
    -0.03281397f, 0.09244551f, -0.09981314f, -0.17895380f, -0.16947733f, -0.17006496f, -0.01307467f, 0.00528942f, 
    -0.22682409f, 0.15846211f, -0.04657457f, 0.04335676f, -0.13792516f, 0.00500066f, 0.13314739f, 0.11710823f, 
    -0.11128333f, -0.12723938f, -0.23771931f, -0.17426904f, 0.10321153f, 0.03539449f, -0.02911399f, 0.04695148f, 
    -0.30758411f, 0.07248569f, 0.19320355f, 0.10357042f, -0.15605529f, -0.48433870f, 0.03112642f, -0.23260856f, 
    0.37940603f, 0.33287108f, 0.08151047f, -0.18113665f, 0.26971662f, -0.13253687f, 0.28742599f, -0.09376732f, 
    -0.00667835f, 0.15666604f, -0.20772065f, -0.07284740f, 0.18662739f, 0.14513089f, 0.31644249f, -0.22712734f, 
    0.10694374f, 0.16022158f, -0.52895027f, 0.05959585f, 0.12785079f, -0.13646570f, -0.15450606f, -0.01199239f, 
    0.01488782f, -0.01318391f, -0.19150531f, -0.02696680f, 0.28354621f, 0.37364796f, 0.12606597f, -0.15347435f, 
    -0.14806235f, -0.02617778f, 0.02771505f, -0.21905839f, 0.18043484f, 0.03567405f, 0.02054915f, -0.26250070f, 
    0.21274941f, 0.10116232f, -0.16287200f, 0.12099027f, -0.05777013f, -0.12872189f, 0.09871171f, 0.12082902f, 
    0.01289058f, 0.15347821f, 0.21529078f, 0.22424445f, -0.12317983f, 0.14486952f, 0.21570073f, -0.03363344f, 
    0.09810835f, -0.08187895f, -0.10608909f, 0.02686350f, 0.32125911f, 0.33919472f, 0.05128780f, -0.05625089f, 
    -0.20449854f, -0.19184598f, 0.13581935f, -0.17444685f, -0.02178645f, 0.16256735f, -0.16399799f, 0.13689029f, 
    -0.10377789f, -0.12210100f, 0.44905967f, 0.07214314f, 0.00533558f, -0.00566929f, -0.30766988f, -0.03411517f, 
    -0.16691735f, 0.17375754f, 0.16699852f, -0.30465171f, -0.08469568f, -0.05151053f, -0.31911099f, -0.00215168f, 
    0.10497576f, -0.06601094f, 0.01666239f, 0.24094152f, 0.13071823f, 0.20805961f, 0.05386645f, 0.14805275f, 
    0.10327294f, -0.05428762f, 0.05651561f, -0.09105482f, -0.08038573f, 0.00220628f, -0.22941105f, 0.23817953f, 
    -0.03598123f, -0.16381526f, 0.19768257f, 0.09994535f, -0.29876986f, 0.02980170f, 0.07897270f, -0.14441429f, 
    0.06668016f, 0.07661283f, 0.05146293f, -0.21173425f, 0.05778714f, -0.09493274f, 0.69726890f, -0.05495067f, 
    0.00665884f, -0.09756489f, 0.04634818f, -0.13745329f, -0.05430882f, 0.08832053f, -0.01428082f, -0.32542926f, 
    0.03708455f, 0.14560397f, -0.34154987f, 0.19397397f, 0.36837226f, -0.45100978f, 0.00087308f, -0.01508552f, 
    -0.12122742f, 0.01649565f, -0.06191639f, -0.55121368f, 0.21326701f, 0.06598004f, 0.24204400f, -0.07040396f, 
    0.11446411f, -0.14695343f, -0.08568889f, -0.08328369f, -0.31905881f, -0.01633972f, -0.04020682f, 0.17234460f, 
    0.10188984f, -0.09806814f, 0.00803543f, -0.10612270f, -0.11101272f, -0.03527004f, -0.25357652f, 0.00369356f, 
    0.24444823f, -0.32232058f, -0.12501541f, -0.30835798f, -0.09020541f, 0.17528149f, -0.41838247f, -0.17969646f, 
    0.00874352f, 0.05043658f, -0.01046093f, 0.13092358f, -0.02086816f, 0.04563876f, 0.04382298f, -0.05275643f, 
    0.15426573f, -0.04431389f, 0.22299708f, 0.11990725f, 0.30675802f, 0.04466958f, 0.19539540f, 0.08274641f, 
    -0.14217471f, 0.15884762f, 0.13813654f, 0.09168372f, 0.11615048f, -0.08608451f, 0.02295501f, 0.04904681f, 
    0.01463003f, 0.17303011f, -0.55402255f, -0.53391039f, -0.05595101f, -0.34333205f, -0.29194149f, -0.03178875f, 
    0.29337823f, 0.10046525f, 0.22552966f, -0.02288802f, 0.52767742f, -0.08150144f, -0.20342129f, -0.06895820f, 
    -0.06567513f, -0.01577660f, 0.04693193f, -0.17386223f, -0.17262614f, -0.04465944f, 0.60662562f, 0.05053988f, 
    0.10356810f, -0.05021619f, 0.08135283f, 0.18270749f, -0.10761730f, -0.30675489f, 0.06727416f, -0.05251239f, 
    0.50045615f, 0.19288173f, -0.25223956f, 0.09159861f, 0.17180358f, -0.20711569f, -0.02330879f, -0.14635465f, 
    0.08835517f, 0.03829600f, 0.26291263f, -0.15545961f, 0.61771214f, 0.03434911f, -0.12666564f, -0.12928522f, 
    -0.17333686f, -0.16023311f, 0.13145974f, -0.18999842f, 0.12320912f, -0.05312998f, -0.04797801f, -0.06602032f, 
    -0.03453426f, 0.00953313f, 0.01070513f, -0.13183430f, 0.04604826f, 0.13258991f, 0.07318648f, -0.00743026f, 
    -0.04705149f, -0.10615046f, -0.11977701f, -0.02908439f, -0.04128320f, 0.01271349f, -0.09832428f, -0.18040743f, 
    -0.18621904f, 0.16234894f, -0.16679384f, 0.01196498f, 0.07396418f, 0.07528795f, -0.14968449f, 0.08688256f, 
    -0.05222997f, 0.03556591f, 0.09484270f, -0.11560863f, 0.10693125f, 0.18026638f, 0.13491283f, 0.13344312f, 
    -0.08510184f, -0.04760482f, -0.00639158f, -0.19122593f, -0.16010337f, 0.12755473f, -0.04942511f, 0.02354215f, 
    -0.02367999f, 0.13373284f, -0.07632320f, 0.02607026f, -0.19343877f, -0.11403703f, -0.17842330f, -0.19455445f, 
    -0.14640038f, 0.09423970f, 0.14843349f, 0.08916659f, -0.16436151f, 0.11524458f, -0.02764454f, -0.12394799f, 
    -0.11146629f, -0.09265917f, 0.16316240f, 0.35419300f, -0.03251715f, 0.16844165f, 0.03046664f, 0.09965195f, 
    -0.12310065f, 0.07436055f, 0.01630984f, -0.48200816f, 0.34305984f, 0.07152202f, 0.22204755f, 0.17860028f, 
    -0.01803105f, -0.24488193f, 0.05086199f, 0.04360343f, -0.05154821f, -0.09874576f, -0.07441664f, -0.12279945f, 
    0.15700908f, 0.11149276f, -0.13434799f, -0.08912195f, -0.36336079f, 0.05222246f, 0.16795503f, 0.06835746f, 
    -0.12135665f, -0.01911150f, 0.09742258f, -0.07768873f, -0.22809269f, 0.07747135f, -0.13949652f, 0.11015603f, 
    -0.29005280f, 0.10948143f, 0.15963830f, 0.24983434f, -0.22873951f, -0.18997125f, 0.10457052f, 0.20136301f, 
    0.03181862f, 0.20423360f, -0.16712026f, -0.05221802f, -0.00231114f, 0.09267829f, -0.07340385f, 0.13831578f, 
    -0.00067444f, 0.04033950f, -0.00920856f, -0.18712679f, -0.10458233f, 0.09770241f, 0.13355407f, 0.21966015f, 
    -0.13675539f, 0.07059908f, 0.02738942f, 0.03330059f, 0.50033629f, 0.00752675f, -0.31857058f, 0.18078908f, 
    0.43537015f, 0.08112227f, -0.25632888f, 0.15782461f, -0.05602062f, 0.44195274f, -0.03695561f, -0.10269035f, 
    -0.09223176f, -0.07609923f, 0.28148323f, 0.01285223f, -0.22590642f, 0.21226893f, 0.07563651f, 0.11168322f, 
    -0.08599988f, -0.07466605f, 0.24525246f, -0.21837609f, 0.10980903f, 0.09855195f, -0.00274357f, 0.13279766f, 
    0.04808158f, 0.14323704f, 0.18367513f, 0.08935072f, 0.12719055f, -0.16615747f, 0.03633337f, -0.16937703f, 
    0.12128989f, -0.04791610f, 0.04711124f, -0.04831774f, -0.21769153f, 0.14878979f, -0.00991112f, -0.27564821f, 
    -0.12411391f, 0.19456181f, -0.01168675f, 0.03769374f, -0.22736862f, 0.21692483f, 0.13390432f, 0.11897571f, 
    0.14695191f, 0.01830945f, -0.10029740f, -0.36544406f, 0.38988337f, -0.05641633f, 0.09971759f, 0.10994584f, 
    0.06647024f, -0.13487852f, 0.31656516f, 0.08330574f, 0.36340979f, 0.12360511f, 0.01602442f, 0.14164151f, 
    -0.32091847f, 0.07352048f, 0.19937883f, -0.18851025f, -0.27112392f, 0.30024311f, 0.23134245f, -0.15988044f, 
    -0.01780525f, 0.06798500f, 0.00357176f, 0.19015098f, 0.08970829f, -0.05048361f, -0.13235192f, -0.16156647f, 
    0.19885933f, -0.06344365f, -0.34969434f, -0.03701488f, 0.05824783f, -0.13749892f, 0.10026944f, -0.05556224f, 
    -0.06648248f, 0.02778944f, 0.12600631f, -0.12159935f, 0.05069786f, 0.03995291f, -0.07249428f, 0.08343133f, 
    0.07816174f, -0.06610632f, -0.07662021f, -0.12852734f, -0.08702149f, 0.04988997f, 0.03629484f, -0.01790531f, 
    0.12561674f, 0.04993438f, -0.12563799f, -0.15962949f, 0.01637871f, -0.07561787f, 0.01265767f, -0.10836286f, 
    -0.14470127f, -0.11803830f, 0.00092829f, -0.10440688f, -0.02928824f, 0.08412237f, -0.10331517f, -0.08896108f, 
    0.11652624f, -0.06263420f, 0.23533364f, -0.02342626f, 0.33256191f, 0.04909962f, 0.79197580f, -0.12661682f, 
    -0.08698023f, -0.05622480f, 0.18852390f, -0.10679361f, -0.04634877f, -0.38552511f, 0.24692956f, -0.28648636f, 
    0.19705857f, -0.18677780f, -0.08619139f, 0.18688899f, 0.34786835f, 0.15544362f, 0.03463503f, 0.03147019f, 
    -0.02398933f, -0.10202169f, 0.10229598f, 0.00774090f, 0.20869873f, -0.07306483f, -0.15286098f, -0.20103237f, 
    -0.01743691f, 0.16336215f, 0.45760745f, -0.07822252f, -0.11197412f, -0.10954262f, 0.22645153f, -0.02824523f, 
    -0.17117342f, -0.00033603f, 0.20790608f, -0.17418951f, 0.05744451f, -0.01861053f, -0.04337320f, -0.02150487f, 
    0.30011964f, 0.13988921f, -0.26510602f, 0.12516057f, 0.18298237f, -0.06390890f, -0.19623542f, 0.05204039f, 
    0.02664266f, -0.16571866f, 0.00841336f, 0.10738869f, 0.30245337f, 0.09148546f, -0.23007888f, 0.11857584f, 
    -0.13084467f, -0.09763684f, 0.12375747f, 0.01853872f, -0.07041147f, -0.11860818f, -0.15761459f, -0.03478312f, 
    0.08964145f, 0.12517647f, 0.10680265f, -0.11082481f, -0.10806777f, 0.15538132f, -0.01051087f, -0.13007051f, 
    -0.06005974f, 0.06477025f, -0.17101556f, -0.20705244f, -0.13663928f, -0.11392161f, -0.04455609f, -0.10319391f, 
    -0.11438728f, -0.02935694f, -0.03558283f, -0.18617947f, -0.12452410f, 0.11858246f, -0.05004016f, -0.16640827f, 
    0.16653052f, 0.13109276f, -0.00489458f, 0.31051528f, 0.31190556f, -0.02105546f, -0.29773352f, -0.11492752f, 
    -0.32062021f, 0.10945030f, -0.09207197f, -0.37721735f, 0.28060529f, -0.28953716f, 0.23234303f, 0.02247454f, 
    -0.01159360f, -0.28048545f, 0.22016324f, -0.16020148f, 0.04300361f, 0.13778286f, 0.02728342f, 0.05973883f, 
    0.25222397f, 0.09177956f, 0.21570352f, 0.06154130f, 0.23123996f, -0.12135128f, -0.26354104f, -0.04002073f, 
    -0.00328801f, -0.10036907f, 0.03289444f, -0.12541503f, 0.24176322f, -0.14780653f, 0.03271964f, -0.07392007f, 
    -0.15879397f, -0.01483777f, 0.14873199f, 0.19488972f, -0.29544294f, 0.20277473f, 0.08435770f, -0.44621119f, 
    0.43959767f, 0.42247143f, -0.24042872f, -0.09238679f, 0.18032573f, -0.39684087f, 0.02297805f, 0.09123564f, 
    -0.07515399f, 0.18005697f, -0.12656912f, -0.29800427f, 0.42786834f, 0.13882975f, 0.04435154f, -0.17923920f, 
    0.15663654f, 0.00165278f, -0.48693585f, 0.15379259f, 0.19977638f, 0.13563274f, 0.41448301f, 0.01562666f, 
    0.18136358f, -0.05919349f, 0.15278696f, 0.05084819f, -0.43849432f, -0.21144217f, -0.33618438f, -0.11223995f, 
    0.24656856f, 0.45459923f, 0.01961457f, 0.17306024f, 0.09323706f, 0.06389239f, 0.09348854f, 0.07644670f, 
    -0.12089980f, 0.01676855f, -0.32273167f, -0.13813156f, 0.13156489f, 0.02017822f, -0.05348068f, 0.16416845f, 
    -0.13256033f, 0.00242586f, 0.14740343f, -0.07269498f, 0.08220170f, 0.07329474f, -0.11230665f, -0.00841812f, 
    -0.05005215f, -0.02962324f, -0.01979880f, -0.16476813f, -0.04515111f, -0.05239177f, -0.10653674f, -0.08517995f, 
    -0.03326220f, 0.09271966f, -0.04558532f, -0.15890329f, -0.17321053f, -0.01026690f, -0.05522966f, 0.07598342f, 
    -0.18467557f, 0.04729318f, 0.05216369f, 0.07415652f, 0.06945985f, 0.12456953f, -0.13039792f, -0.10821190f, 
    0.14049372f, 0.00828919f, 0.11449954f, -0.05454529f, -0.00123573f, 0.13640925f, -0.08426487f, 0.04543421f, 
    -0.06565241f, 0.06330990f, -0.01109171f, -0.15002438f, -0.05472845f, 0.01959409f, -0.09867118f, 0.06105672f, 
    -0.15613778f, -0.01789252f, -0.14203984f, -0.12433957f, -0.04745884f, 0.16168763f, -0.14521606f, 0.03994704f, 
    -0.17572120f, -0.15042265f, -0.01021416f, -0.06172638f, 0.10816977f, 0.04121912f, 0.08372011f, 0.07478198f, 
    0.14724322f, -0.06781417f, -0.12908217f, -0.29108194f, -0.06422195f, 0.11940902f, -0.18330844f, 0.10994812f, 
    -0.32702398f, -0.17278732f, 0.08796650f, 0.11054713f, 0.00248623f, -0.07100244f, 0.13214098f, -0.01275993f, 
    0.29041001f, 0.33441499f, -0.23850755f, -0.18692195f, 0.03963086f, 0.04016502f, 0.03340179f, -0.01667240f, 
    0.24648635f, -0.04557117f, 0.06388962f, 0.08262075f, 0.23865235f, -0.07706618f, -0.02929399f, -0.06664269f, 
    0.02928798f, 0.05107737f, 0.57835859f, 0.09938359f, 0.14909634f, -0.13580385f, -0.25013009f, -0.10072793f, 
    0.21741275f, -0.02285198f, -0.14041990f, 0.08318813f, -0.08741720f, 0.33184358f, -0.06610938f, -0.03319973f, 
    -0.26566944f, 0.16444018f, 0.14346769f, -0.13278027f, -0.06425944f, 0.07405058f, -0.17568187f, 0.14571369f, 
    -0.01804844f, 0.12805270f, 0.28256223f, 0.04697628f, 0.50761056f, -0.04116552f, -0.14688545f, -0.01635262f, 
    -0.03779109f, -0.02668751f, -0.03395452f, -0.17458522f, -0.08726282f, -0.04736831f, 0.02687675f, 0.05952179f, 
    0.24643146f, -0.01354990f, -0.07329325f, -0.04476668f, 0.02342620f, 0.29636341f, -0.04301239f, -0.22834989f, 
    0.09049907f, 0.02124347f, 0.15585555f, -0.20724979f, 0.00848503f, 0.15853909f, -0.14995968f, -0.10021494f, 
    0.25160405f, -0.02457818f, -0.17790876f, 0.14457686f, 0.29079071f, 0.03485324f, -0.17454638f, -0.13546576f, 
    -0.00248755f, -0.02401736f, -0.11836371f, -0.12193556f, -0.20164771f, 0.08857712f, -0.27142137f, -0.16342834f, 
    0.22451180f, -0.14636344f, 0.01515097f, -0.11816277f, 0.09706721f, 0.31150562f, 0.09430862f, -0.05582669f, 
    -0.07456568f, 0.24053375f, -0.11670284f, 0.00856291f, -0.05368825f, -0.27921721f, 0.23765224f, -0.14555353f, 
    0.33749223f, -0.05319208f, -0.14832644f, 0.16172539f, -0.23694207f, 0.01530015f, 0.23249191f, -0.19994506f, 
    -0.16929810f, -0.00438538f, -0.22683892f, -0.06678390f, 0.12137466f, 0.00343549f, -0.06968042f, -0.02472562f, 
    0.16074215f, 0.09464891f, -0.13057782f, -0.00876982f, 0.07445517f, 0.18836404f, 0.09513638f, -0.12189184f, 
    -0.06015554f, -0.04673685f, -0.10606876f, -0.16608399f, -0.02789051f, -0.11707249f, 0.21332504f, -0.00214756f, 
    -0.25702581f, 0.15993226f, -0.10511759f, 0.10523126f, -0.09881019f, 0.17471448f, 0.13261811f, -0.14148869f, 
    -0.06883904f, 0.10416289f, 0.22042653f, 0.14175199f, -0.01262242f, -0.15895320f, -0.25556856f, 0.08521544f, 
    -0.00430413f, 0.03285770f, 0.04828595f, 0.00966926f, 0.28132334f, 0.30073464f, 0.23849687f, 0.14945589f, 
    -0.39838231f, -0.20797013f, 0.20570672f, -0.22268836f, -0.00475675f, 0.12611759f, 0.06076079f, 0.31202653f, 
    0.01929178f, -0.16967069f, 0.08801717f, -0.14944884f, -0.43273416f, -0.15206887f, 0.33729813f, -0.03207714f, 
    0.02302177f, 0.03614973f, -0.06899716f, 0.00883977f, 0.25047088f, 0.07852925f, 0.39408726f, -0.07880807f, 
    0.31597847f, 0.07374097f, -0.13355798f, 0.37336057f, 0.01550178f, -0.11241122f, 0.10096768f, 0.28010434f, 
    -0.26884067f, 0.20403120f, -0.27105942f, -0.53627837f, -0.05122362f, -0.30823386f, -0.11417744f, -0.24085699f, 
    0.04172944f, 0.13045678f, 0.26921928f, 0.02146079f, 0.05158415f, 0.16156714f, -0.52191383f, -0.28727907f, 
    -0.04034547f, 0.02935195f, -0.11828944f, 0.02796495f, -0.51656252f, 0.05666253f, -0.12612878f, -0.11413861f, 
    0.26835775f, 0.05072438f, 0.11090282f, 0.14078675f, -0.11229457f, -0.02509356f, 0.00801270f, 0.14550073f, 
    -0.04882277f, 0.28563887f, -0.00858919f, -0.11886541f, 0.14378145f, 0.01850215f, 0.30615172f, -0.19159012f, 
    -0.00224380f, 0.02549277f, -0.20404369f, -0.05723750f, -0.22067009f, -0.14304471f, 0.35958293f, -0.00445076f, 
    -0.00745004f, -0.12946540f, -0.08965760f, 0.26911283f, 0.07470750f, 0.00641262f, -0.06739470f, -0.16893078f, 
    0.29428044f, -0.02686996f, -0.17247787f, -0.03761059f, -0.01752652f, -0.05453994f, 0.10636850f, -0.15554793f, 
    -0.55338073f, -0.26484406f, 0.25980023f, -0.13978949f, 0.04904093f, 0.08927249f, 0.41190937f, 0.11947887f, 
    0.08369935f, -0.15315649f, -0.17467175f, -0.37142020f, -0.28476283f, -0.08350655f, 0.40742585f, 0.23919348f, 
    0.04298056f, 0.08869267f, -0.57463360f, 0.38869411f, -0.15110448f, 0.09609654f, 0.00410011f, 0.14507112f, 
    0.07850988f, -0.11788410f, -0.16552365f, -0.13645776f, 0.29439327f, 0.06466530f, 0.03782735f, 0.47036073f, 
    -0.26049709f, 0.17192313f, 0.15163006f, -0.01615740f, -0.10221452f, 0.09367166f, 0.14402144f, -0.14656222f, 
    0.19096272f, 0.15334402f, 0.16333731f, -0.27950740f, -0.33082426f, 0.02426253f, 0.05139486f, 0.18407701f, 
    0.03155957f, -0.14680183f, 0.20838936f, 0.33878985f, 0.01218583f, 0.13425471f, 0.21201953f, 0.10616093f, 
    0.28355798f, 0.06239485f, -0.15715136f, 0.19689958f, -0.32126355f, 0.12614501f, -0.24545011f, -0.13483681f, 
    0.03705063f, 0.04099918f, -0.04928441f, -0.32899177f, -0.18497717f, 0.23864339f, -0.16383828f, 0.13907802f, 
    -0.02214411f, 0.13466452f, -0.05856964f, -0.12955873f, -0.20805611f, -0.15511522f, -0.04638737f, -0.15890560f, 
    -0.01997188f, 0.11384987f, -0.29007450f, -0.18412741f, -0.32395485f, 0.17953320f, 0.09273040f, -0.17197102f, 
    -0.29645127f, -0.16417007f, 0.13269509f, 0.05054164f, 0.19134738f, 0.00833980f, 0.04667434f, 0.17310643f, 
    -0.21155174f, -0.14759092f, 0.14072436f, -0.09549336f, 0.26276600f, 0.20157574f, 0.00825813f, -0.14437741f, 
    0.23780015f, -0.03727579f, -0.12291921f, 0.06224709f, -0.02341477f, -0.00767557f, -0.01363228f, -0.06352371f, 
    -0.13102871f, 0.13441414f, -0.24305306f, 0.06704111f, 0.39542907f, 0.02774243f, 0.25432128f, -0.08366630f, 
    -0.12432566f, 0.08157298f, -0.20407857f, -0.24777608f, 0.09942595f, -0.42717561f, 0.14621997f, 0.15499134f, 
    0.00109290f, 0.09913206f, 0.13638639f, -0.15619998f, -0.16580009f, -0.02782327f, 0.05716963f, -0.09094752f, 
    0.27630156f, 0.04922438f, 0.38031143f, 0.08486629f, 0.24281093f, 0.08758656f, -0.17894848f, -0.05104454f, 
    -0.07500187f, -0.12313199f, -0.08660011f, 0.19025165f, 0.31630459f, 0.11500372f, -0.60211957f, -0.09346938f, 
    0.15007144f, -0.02407795f, -0.16400187f, 0.25222406f, -0.18738005f, -0.07256460f, 0.26636127f, 0.02405731f, 
    -0.01254380f, -0.20855416f, -0.06321558f, -0.18230841f, -0.19424370f, -0.00076477f, 0.31810084f, 0.18777432f, 
    0.23968109f, 0.12119508f, -0.18001488f, -0.01302656f, 0.09905428f, -0.10194261f, 0.35208008f, 0.03358839f, 
    0.08810589f, -0.11126507f, 0.18889849f, -0.07068355f, 0.30696476f, -0.01918449f, -0.15212965f, -0.14986138f, 
    0.00103825f, -0.10308887f, -0.01560036f, 0.03804366f, -0.18108797f, -0.14196843f, -0.15178260f, -0.18557163f, 
    -0.10949882f, -0.08774435f, -0.00052639f, -0.20194069f, -0.03091958f, 0.03717655f, -0.20758568f, 0.12350442f, 
    0.01130525f, 0.15403529f, 0.05893123f, -0.05807174f, 0.30945161f, -0.02654512f, 0.07304429f, 0.13215272f, 
    -0.06314608f, -0.13374668f, 0.43128631f, 0.15309161f, -0.06243792f, -0.14243519f, -0.27712086f, -0.05382003f, 
    -0.11150236f, -0.03095920f, -0.14305845f, 0.16749701f, -0.08840004f, 0.47886604f, 0.15151916f, -0.08256572f, 
    -0.17009076f, 0.09988990f, 0.15343414f, -0.03545328f, -0.18427175f, 0.17146461f, -0.00728206f, 0.08415139f, 
    0.15278605f, 0.14678834f, -0.14638573f, -0.06153219f, 0.34725046f, -0.15730922f, 0.13340145f, 0.14972632f, 
    0.09476024f, -0.04215260f, 0.46164715f, 0.06586909f, -0.15693121f, 0.04313232f, 0.25311711f, -0.14256862f, 
    -0.65398765f, 0.17140853f, 0.25662941f, -0.20710111f, 0.12451267f, 0.09317254f, 0.17427188f, -0.14807358f, 
    0.49532592f, 0.23740478f, -0.55932117f, -0.12237146f, 0.23008312f, 0.14653282f, -0.10157986f, -0.12334667f, 
    0.22687855f, -0.03989321f, 0.17091776f, -0.37463716f, 0.38292757f, -0.03785579f, 0.04960498f, -0.05406524f, 
    -0.07492489f, -0.03137314f, 0.09771319f, 0.08436257f, -0.26012075f, -0.11111327f, -0.44105703f, 0.17104183f, 
    0.44290489f, -0.14993149f, -0.13901231f, 0.31055146f, 0.26610813f, -0.12358923f, 0.07089515f, -0.18604082f, 
    -0.04032255f, 0.11713400f, 0.33191529f, -0.25770637f, 0.07094377f, 0.20518343f, 0.30293968f, 0.13361929f, 
    -0.27213714f, 0.01900753f, 0.14589135f, -0.15753525f, 0.02071892f, -0.10262997f, -0.07183935f, -0.08986015f, 
    -0.00719994f, -0.06586149f, 0.04472047f, -0.08062686f, 0.00954169f, -0.02467906f, -0.16097684f, 0.11624282f, 
    0.33178514f, 0.05865779f, -0.09139018f, 0.23377299f, 0.25300804f, 0.09836724f, 0.08056778f, -0.12784341f, 
    0.04594571f, -0.17647627f, -0.10228521f, 0.05249471f, 0.02187737f, 0.17542142f, 0.33203182f, 0.11958582f, 
    -0.35189280f, 0.13632762f, 0.19881611f, -0.09114385f, -0.92020327f, -0.02546022f, -0.03102472f, -0.29443389f, 
    0.16615637f, -0.00092083f, -0.12413836f, 0.35785878f, -0.26870117f, -0.07867847f, 0.22012955f, -0.16818009f, 
    -0.09116008f, -0.16504838f, -0.21642286f, -0.17525874f, 0.32410598f, 0.55280668f, 0.07393435f, 0.22129644f, 
    -0.22418417f, 0.04737429f, 0.13079880f, 0.08421874f, 0.19811802f, -0.00745378f, 0.00209166f, -0.20691672f, 
    0.16098648f, 0.13916887f, 0.04719602f, 0.06223710f, -0.33055237f, 0.15425481f, 0.07327705f, 0.06547917f, 
    -0.15868621f, -0.12339637f, -0.16697080f, -0.21665794f, 0.35873213f, 0.14189230f, 0.29780644f, 0.02357054f, 
    0.13976431f, -0.16997446f, 0.18972194f, 0.34384492f, -0.06883061f, -0.31669244f, -0.15354802f, 0.27546626f, 
    -0.37686536f, -0.00461819f, 0.12789518f, 0.17543301f, -0.09191220f, 0.04704111f, 0.14307548f, 0.19623220f, 
    0.01380655f, -0.15547837f, -0.03495659f, -0.33729687f, -0.44702277f, -0.07181507f, 0.31698385f, 0.14995782f, 
    -0.07066432f, 0.08464937f, 0.34783340f, -0.23969766f, -0.18362156f, 0.03865001f, 0.07771691f, -0.01407024f, 
    -0.34250289f, -0.09982597f, 0.15207656f, 0.14444672f, 0.12774505f, 0.02896264f, 0.20183189f, 0.01660543f, 
    0.38994479f, 0.23404773f, -0.24052288f, -0.08420849f, 0.10343266f, -0.15455192f, -0.16544394f, 0.07034156f, 
    0.28915250f, -0.16063370f, 0.20872721f, -0.16325508f, 0.47719756f, 0.03149921f, -0.14382757f, -0.18459389f, 
    0.03233068f, 0.04798678f, -0.22342585f, 0.17501570f, 0.07614668f, -0.07547277f, -0.39374837f, -0.16905895f, 
    -0.42961925f, -0.13107024f, 0.17531231f, -0.24962379f, 0.05398928f, -0.33088797f, 0.22972085f, 0.07514887f, 
    -0.12897485f, 0.04771705f, 0.16431373f, -0.15761919f, 0.13762823f, -0.07877830f, 0.21616705f, -0.21309395f, 
    0.26570481f, -0.11065686f, 0.18292965f, 0.09306881f, -0.16922188f, -0.03028564f, -0.00211050f, -0.15305361f, 
    -0.02688025f, 0.13185251f, -0.23911631f, -0.53620762f, -0.39733487f, -0.11703640f, -0.19264154f, -0.15245868f, 
    0.25938511f, -0.17595573f, 0.07057092f, 0.48227379f, -0.10701559f, 0.13611938f, 0.03458764f, -0.06570115f, 
    0.19571644f, 0.04862402f, -0.03259520f, -0.01713032f, 0.25644866f, 0.15654707f, -0.08294155f, 0.24537227f, 
    -0.19512238f, -0.11820771f, 0.25898835f, -0.09942110f, -0.16616814f, -0.03665806f, 0.17483665f, -0.09521198f, 
    -0.15048426f, -0.06282514f, -0.05958175f, -0.00045665f, 0.03451704f, 0.12056182f, -0.10278548f, -0.11453474f, 
    -0.17608468f, 0.05052204f, -0.05415933f, -0.18593237f, -0.15078984f, -0.13292161f, -0.00252526f, 0.01465717f, 
    -0.10233782f, -0.15353657f, 0.06010604f, -0.09565735f, -0.02695367f, -0.09580542f, -0.11131927f, -0.12083872f, 
    0.05359871f, -0.08526669f, -0.06952643f, -0.02341651f, -0.04736414f, -0.00315895f, -0.03047016f, -0.11472855f, 
    0.01201231f, 0.14682969f, -0.16182286f, -0.00524529f, 0.29159635f, -0.07078562f, 0.31672871f, 0.14337945f, 
    -0.06060001f, -0.12534060f, -0.08550577f, 0.18878925f, 0.41145238f, 0.46371892f, 0.14858952f, 0.15795319f, 
    -0.04507948f, 0.10699891f, -0.47862843f, -0.33509648f, 0.11746985f, -0.32670131f, -0.31041461f, -0.55543590f, 
    0.14670831f, -0.01074549f, 0.43890586f, -0.22818621f, 0.03130087f, -0.03442731f, -0.20687589f, -0.09920999f, 
    0.00490906f, 0.06175509f, 0.36452869f, -0.15709651f, -0.27571863f, -0.10981420f, 0.58302069f, -0.15962179f, 
    0.17270589f, -0.07278866f, 0.15537235f, -0.28571537f, 0.27417606f, 0.10891408f, 0.15013579f, -0.19598812f, 
    -0.12230717f, 0.06441469f, 0.04321595f, 0.12715755f, 0.28046790f, -0.04798383f, -0.14300995f, -0.20178531f, 
    0.08050212f, 0.07431903f, -0.08554924f, 0.15823033f, -0.01176324f, 0.03201079f, 0.14962150f, -0.02924446f, 
    0.00210849f, -0.17293711f, 0.20020686f, -0.14222263f, -0.24698378f, 0.04691994f, 0.60099024f, -0.03916160f, 
    -0.02732202f, 0.07999662f, 0.16985705f, -0.05016604f, -0.07997719f, -0.35409290f, -0.02086872f, -0.25664228f, 
    0.30889422f, 0.35531405f, -0.40011352f, 0.19678824f, 0.32433587f, -0.04367729f, 0.04873201f, -0.23281780f, 
    -0.13890596f, 0.12098842f, 0.29032817f, -0.06973451f, 0.36546144f, -0.06975428f, 0.00435305f, -0.03839653f, 
    0.15685867f, 0.00877615f, 0.03926532f, 0.33145106f, -0.09943075f, -0.08300824f, 0.28710696f, -0.04392409f, 
    0.23298550f, 0.03792915f, -0.00356456f, -0.03166735f, 0.27950373f, 0.20945023f, -0.07282797f, -0.15571819f, 
    -0.17606989f, -0.20055929f, 0.24520591f, 0.00012243f, -0.06803180f, 0.10137645f, 0.14830591f, -0.10973918f, 
    -0.15710786f, -0.05802730f, 0.37854320f, -0.01986240f, -0.11877877f, 0.13681138f, -0.19040343f, -0.03285813f, 
    0.04318473f, 0.07662369f, -0.23579840f, 0.03030717f, 0.04301750f, 0.02557149f, -0.36160919f, -0.06297056f, 
    0.00082632f, 0.15073831f, -0.10462904f, -0.00517390f, 0.34268230f, 0.37657869f, 0.11760980f, 0.04402737f, 
    -0.11178558f, 0.08162957f, 0.07557876f, 0.08716289f, 0.04066896f, -0.08395558f, 0.14140411f, 0.06558679f, 
    0.16139849f, -0.00375176f, 0.21953422f, -0.01860985f, 0.09296130f, 0.10676603f, -0.08835392f, -0.05780074f, 
    -0.13559608f, 0.10608298f, -0.18026242f, -0.19172026f, -0.33544067f, -0.01074214f, 0.34493873f, 0.09170447f, 
    0.38570151f, 0.00261799f, 0.11067770f, 0.28571501f, -0.01218738f, -0.21244265f, 0.06113021f, -0.00572174f, 
    0.25430316f, 0.26994690f, -0.07865126f, 0.12432968f, -0.00349143f, -0.04985971f, -0.08163113f, 0.09197702f, 
    -0.08617184f, -0.16038895f, 0.29603365f, 0.01588516f, 0.01338532f, 0.04784532f, -0.18038870f, -0.03581686f, 
    0.13265619f, -0.06613504f, -0.19061838f, 0.09013798f, 0.22721019f, -0.13327046f, 0.03139636f, -0.09251016f, 
    0.14517698f, -0.15020491f, -0.18603969f, -0.16492781f, 0.25528494f, 0.22558632f, 0.26242596f, -0.18234468f, 
    -0.04543312f, 0.05583482f, -0.04315552f, -0.13426623f, -0.00006433f, -0.04155000f, -0.02579553f, 0.12900993f, 
    0.33677992f, -0.14901668f, 0.02493538f, 0.23736638f, -0.05603710f, -0.09501596f, -0.04669386f, -0.19451742f, 
    -0.13296802f, 0.18071897f, -0.18271691f, 0.32210097f, 0.28762326f, 0.12207710f, 0.45071113f, 0.13230218f, 
    0.34765223f, 0.10592113f, -0.05895576f, -0.14667420f, -0.28006366f, -0.34037116f, -0.14137015f, -0.04673296f, 
    0.35590839f, -0.16471362f, 0.15857159f, 0.05292916f, 0.12773158f, 0.18064767f, 0.24133864f, -0.07439956f, 
    -0.01623954f, 0.12053088f, -0.18211827f, -0.05839262f, -0.04662592f, 0.04884101f, -0.05153283f, 0.18188825f, 
    -0.15448681f, 0.12646551f, -0.50865179f, 0.10377908f, 0.54794133f, -0.12981288f, 0.61051208f, -0.15621826f, 
    -0.22431087f, -0.12857406f, 0.04386953f, -0.33694413f, 0.14612362f, -0.59812421f, 0.16694777f, -0.00603529f, 
    -0.16183625f, -0.39369074f, 0.24120370f, -0.01216800f, 0.02943163f, -0.14072637f, 0.23785432f, 0.00422177f, 
    0.27638367f, -0.12519409f, 0.19466668f, -0.08306458f, -0.06738760f, -0.02303547f, 0.02018459f, -0.13255070f, 
    -0.02058781f, -0.09083042f, -0.22359388f, -0.50855350f, 0.00430426f, 0.07787368f, 0.07392924f, 0.15257774f, 
    0.02641531f, -0.13184603f, -0.03679467f, -0.20827480f, -0.26502827f, 0.26909611f, 0.18361178f, -0.14234650f, 
    -0.13327450f, 0.32238051f, 0.15145968f, 0.28421843f, 0.03706390f, 0.13060473f, 0.03731518f, -0.12004519f, 
    -0.10668945f, -0.08553264f, 0.01661432f, -0.01971124f, -0.07164863f, -0.11958909f, -0.13188873f, -0.10245694f, 
    -0.11200241f, -0.12065037f, -0.11673236f, 0.46497709f, 0.04620605f, 0.00051867f, -0.50299090f, -0.09494188f, 
    0.10401890f, 0.07589384f, -0.13446490f, 0.04089995f, 0.23648322f, -0.17084281f, 0.16914362f, 0.08545525f, 
    -0.30036524f, 0.07807042f, 0.01471879f, -0.14079192f, -0.12451575f, 0.37248334f, 0.34533662f, 0.13380647f, 
    -0.08547253f, -0.07906096f, -0.07792146f, -0.22365715f, 0.09071276f, 0.02614297f, 0.08182541f, -0.03567799f, 
    0.05920086f, 0.07614376f, -0.56625116f, -0.07219341f, 0.42748538f, -0.11516038f, -0.56932300f, -0.15481839f, 
    0.02329578f, -0.15457593f, 0.24337059f, 0.01383295f, 0.07553405f, 0.11149267f, 0.15277082f, 0.06240259f, 
    0.01250656f, 0.23964891f, 0.04061468f, -0.34675974f, -0.12533446f, -0.14200823f, 0.17723739f, 0.19879153f, 
    0.29569864f, -0.17524265f, 0.05151244f, -0.10784242f, 0.01640918f, -0.12226998f, 0.11401374f, -0.12078901f, 
    0.08201954f, 0.01203364f, -0.01715655f, 0.09344039f, 0.10364714f, 0.10165152f, -0.08978035f, 0.11267170f, 
    -0.15709859f, -0.06876875f, -0.17306957f, 0.07312848f, -0.15297973f, 0.09653290f, -0.03377737f, -0.13853353f, 
    -0.01994855f, -0.15848121f, -0.19858016f, 0.12851775f, -0.08804426f, 0.11408851f, -0.21490394f, -0.09673671f, 
    -0.15209310f, -0.00898105f, -0.03717099f, -0.06238653f, -0.03785390f, -0.03291311f, -0.01638761f, -0.12644693f, 
    -0.00953922f, 0.02708737f, 0.70395094f, -0.12594630f, 0.15420182f, -0.16428712f, -0.26294252f, 0.13305250f, 
    -0.20430142f, 0.02526733f, 0.20935990f, 0.27215412f, -0.33106181f, 0.02036213f, 0.02639964f, -0.25136948f, 
    -0.09422977f, 0.10715293f, -0.16790657f, -0.01349982f, -0.11862690f, 0.21005705f, 0.02907855f, 0.21416214f, 
    0.11534297f, 0.09325761f, 0.03970867f, 0.03472308f, 0.22708276f, 0.10595559f, -0.06730714f, 0.09402563f, 
    -0.09031037f, -0.15369989f, 0.23563571f, 0.09459981f, -0.09697788f, -0.14988343f, 0.15200125f, -0.00059627f, 
    0.08346876f, 0.06851517f, -0.06841237f, 0.34400490f, -0.09311233f, -0.02503124f, -0.04815195f, -0.25665411f, 
    0.10705140f, -0.15019323f, 0.14301705f, 0.01453954f, 0.13220446f, 0.24107893f, 0.09926070f, 0.18305442f, 
    -0.38520700f, -0.14769717f, -0.11552428f, -0.22076273f, -0.03173504f, -0.10154324f, 0.26960775f, 0.10368981f, 
    -0.00231520f, -0.06493462f, 0.01771136f, -0.11445951f, -0.05277523f, -0.14933711f, -0.05598601f, 0.08544188f, 
    -0.06114576f, -0.05477392f, -0.01494929f, -0.02668276f, -0.18505007f, 0.08154914f, -0.06014506f, -0.00959505f, 
    -0.10075003f, -0.14560612f, 0.12314001f, 0.08042254f, -0.08135847f, -0.03416578f, 0.08665562f, -0.13704191f, 
    -0.12071212f, 0.00896257f, -0.15828602f, -0.17259389f, 0.11263329f, -0.14399426f, -0.18565316f, -0.07964258f, 
    0.02179624f, -0.03101513f, -0.03882395f, -0.55708784f, -0.37703720f, -0.08494844f, -0.14989693f, -0.11225510f, 
    0.26086420f, 0.08437154f, 0.05552952f, 0.24473810f, -0.03399912f, 0.07782030f, -0.06378815f, -0.14505616f, 
    0.01854131f, 0.28395876f, -0.02823501f, 0.18986605f, 0.14895341f, 0.05210328f, -0.04454777f, 0.18842201f, 
    -0.12384535f, -0.16700117f, 0.30193296f, -0.03907995f, 0.36451325f, -0.09350374f, -0.18156642f, -0.17328224f, 
    0.15162122f, 0.11916260f, 0.30649465f, -0.21761289f, -0.02147666f, 0.00519339f, -0.25653166f, 0.03105977f, 
    0.07260248f, 0.16640961f, 0.22044241f, 0.12108280f, -0.05263643f, -0.07626983f, 0.18250391f, -0.26584587f, 
    0.19383532f, 0.00076759f, 0.11443887f, -0.16573012f, 0.03220905f, -0.16621824f, 0.24283184f, 0.06371577f, 
    -0.00980240f, 0.08605981f, -0.29912341f, -0.11751082f, 0.26212019f, -0.11368798f, 0.25329721f, 0.08847397f, 
    0.08254909f, 0.00272656f, 0.52662927f, 0.26973793f, -0.35991520f, 0.01895880f, -0.31233615f, -0.03443246f, 
    -0.18713802f, -0.05680315f, -0.02234602f, 0.10490257f, -0.20464882f, -0.10229316f, 0.09509113f, 0.04594111f, 
    -0.18150200f, 0.11064662f, 0.00445833f, -0.03307109f, -0.00275457f, -0.01773661f, 0.33607960f, -0.12024871f, 
    -0.10296056f, -0.15751803f, -0.19176196f, -0.04736970f, 0.20700423f, -0.08542405f, 0.46376383f, 0.19851802f, 
    0.10704757f, -0.04769361f, 0.05657748f, 0.04088355f, 0.03205105f, -0.02093523f, -0.01454260f, -0.17016225f, 
    -0.16379470f, -0.03758591f, -0.08834470f, 0.10568628f, -0.05478240f, -0.03499648f, -0.01505277f, 0.18897083f, 
    -0.03230553f, -0.33071724f, -0.09656905f, 0.14325804f, 0.06099467f, 0.08164968f, -0.09733874f, 0.03953287f, 
    0.07070928f, 0.05854560f, -0.07111132f, -0.11276215f, -0.11120976f, 0.09774443f, -0.07540410f, -0.16128486f, 
    -0.11572818f, -0.00627969f, -0.10578642f, 0.33956775f, -0.04599751f, 0.02149640f, 0.36783877f, -0.05537375f, 
    0.34160605f, 0.04038981f, -0.11028221f, -0.25027284f, 0.18114589f, 0.47896931f, 0.02489828f, 0.12090006f, 
    -0.21645312f, -0.02186940f, 0.26093027f, 0.22463526f, 0.07948408f, -0.08388467f, -0.00518564f, -0.25471768f, 
    0.20583153f, 0.13674526f, 0.16742378f, 0.14741416f, -0.13281327f, -0.16212830f, -0.06933813f, 0.04593583f, 
    -0.08303372f, 0.00813778f, 0.55794615f, -0.09515912f, -0.28225631f, -0.07220981f, 0.56478143f, 0.07780810f, 
    0.10520703f, -0.00401116f, 0.11997995f, 0.06827612f, -0.03004094f, -0.15700373f, 0.07558192f, 0.07880504f, 
    -0.12563211f, -0.14650853f, -0.05149201f, 0.14706390f, 0.12748839f, 0.15720902f, -0.01081938f, -0.09508725f, 
    -0.31160256f, 0.05305825f, 0.20626293f, 0.09675234f, 0.31987691f, 0.01316659f, -0.01421237f, -0.01717849f, 
    -0.07375742f, 0.12583938f, -0.15191855f, -0.17010261f, 0.29110321f, 0.10012671f, 0.45228934f, -0.06563687f, 
    0.22610368f, -0.05179999f, 0.14162296f, -0.19884056f, 0.09204609f, -0.27370501f, 0.24497701f, -0.06634762f, 
    0.18223615f, -0.07170665f, -0.06224560f, 0.09938736f, 0.28464130f, -0.12030438f, -0.03209157f, 0.16797586f, 
    -0.32607517f, 0.08325288f, -0.02456828f, -0.12177695f, 0.00020258f, 0.03049973f, -0.10031612f, -0.27982244f, 
    0.07532928f, -0.13567047f, 0.60025388f, 0.13661793f, 0.21572088f, -0.07011373f, -0.05301143f, 0.00357643f, 
    -0.34443375f, 0.00323599f, -0.12397243f, 0.20326890f, -0.01188376f, 0.29850772f, 0.20502505f, 0.00053739f, 
    0.16620325f, 0.05262953f, -0.08807608f, -0.01471638f, -0.06890073f, 0.24646239f, -0.14518699f, 0.20685191f, 
    0.28049240f, -0.00711334f, 0.16029595f, -0.06692854f, 0.25888008f, 0.03541278f, -0.06533407f, -0.11320379f, 
    0.01275177f, -0.06928404f, 0.19945705f, -0.05553725f, 0.07415263f, 0.10249259f, 0.10056607f, 0.02556809f, 
    -0.11443108f, -0.04566750f, -0.09929320f, -0.26382622f, 0.01059534f, 0.16296548f, -0.08964935f, -0.23825450f, 
    0.27260181f, 0.21019851f, 0.06093373f, -0.03509059f, 0.18774770f, -0.01486024f, 0.11239716f, 0.05498632f, 
    0.07921558f, -0.14135057f, 0.01921660f, 0.18152568f, 0.36348796f, 0.06407063f, -0.04249088f, -0.17121954f, 
    0.04150850f, 0.06370022f, 0.22468974f, 0.08999870f, 0.34128788f, 0.13883463f, -0.17315885f, -0.15177220f, 
    -0.18674755f, -0.15316346f, -0.15238425f, 0.12237273f, -0.17054170f, -0.10310069f, 0.20966473f, -0.14038882f, 
    -0.12635139f, 0.06663253f, 0.01811056f, -0.11771023f, 0.00047529f, 0.25147688f, 0.12318715f, 0.02315409f, 
    -0.03006763f, 0.03730480f, -0.02626262f, -0.15863682f, 0.27034190f, -0.07414030f, -0.11341322f, 0.26447976f, 
    0.16212219f, -0.10157414f, 0.41978434f, 0.05947793f, -0.25965908f, 0.13265952f, -0.16162860f, -0.11313311f, 
    -0.14885938f, -0.01672074f, 0.08518507f, 0.23741138f, 0.14330612f, -0.15636890f, 0.24569827f, -0.39927000f, 
    0.01619093f, 0.02136546f, -0.15396358f, -0.19861554f, 0.14489125f, -0.07595359f, -0.02113296f, 0.06937665f, 
    0.15124851f, -0.10765091f, 0.02321718f, 0.14012764f, 0.07974028f, 0.10873894f, 0.23642561f, -0.21295728f, 
    -0.17137557f, -0.10218006f, -0.07742393f, 0.04527233f, -0.13924727f, -0.08076708f, 0.10752820f, -0.08159824f, 
    -0.15100895f, -0.10724832f, 0.00637241f, -0.15761760f, 0.01712789f, 0.06895427f, 0.05245633f, -0.05117940f, 
    0.16085726f, -0.07907870f, -0.06796464f, -0.16405682f, -0.12309849f, -0.00687750f, -0.08754299f, 0.05881689f, 
    -0.01673925f, -0.04040281f, -0.13057283f, -0.16690212f, -0.03534660f, -0.04371564f, 0.15226895f, -0.16716607f, 
    0.07573291f, 0.05655848f, -0.10764504f, -0.55080622f, -0.28829655f, -0.04297706f, 0.03190238f, -0.00826877f, 
    0.39905357f, 0.10615940f, 0.02742206f, 0.12280250f, -0.14126490f, 0.33141699f, 0.06821838f, -0.32489431f, 
    0.33704856f, 0.10050210f, -0.08466615f, 0.18206209f, 0.12727375f, 0.15223728f, -0.03225693f, -0.04153635f, 
    -0.22865181f, 0.09691352f, 0.38303337f, -0.22909251f, -0.01796182f, -0.10606212f, 0.16463153f, -0.03146096f, 
    -0.07281715f, 0.04910298f, 0.63342071f, -0.21035190f, 0.16239382f, -0.04255354f, -0.30580071f, 0.14494044f, 
    -0.34306586f, 0.01719249f, -0.09247101f, 0.13300647f, -0.19068450f, -0.18277535f, 0.22566241f, -0.33692062f, 
    0.12252156f, 0.11709133f, -0.08206648f, -0.15561554f, 0.05324572f, 0.14150186f, 0.17137487f, 0.26765671f, 
    0.07079440f, 0.09774490f, -0.15962081f, -0.06866906f, 0.17921752f, 0.17620997f, 0.06327065f, 0.00341489f, 
    -0.08154772f, -0.04749570f, -0.02416852f, 0.05875932f, -0.03998895f, 0.17432801f, -0.09024161f, -0.14993036f, 
    0.06720934f, 0.05067318f, -0.14511740f, -0.10750381f, 0.02664457f, -0.16806544f, -0.18326241f, -0.10680962f, 
    -0.21152496f, -0.03804902f, 0.06799714f, 0.07072728f, -0.11593791f, 0.06484435f, -0.03757831f, 0.07203317f, 
    0.03398614f, -0.03300303f, -0.01026462f, -0.01417534f, -0.14518745f, 0.12809037f, 0.07567244f, -0.12847348f, 
    -0.15502843f, -0.10996313f, 0.26861894f, 0.12874401f, -0.06740262f, -0.00879486f, 0.55867064f, -0.14946592f, 
    0.10090696f, -0.10110942f, 0.19901963f, -0.23060201f, -0.01144956f, -0.29183739f, 0.05821446f, 0.04332559f, 
    0.14676131f, -0.10348452f, -0.22696386f, 0.35448837f, 0.20890456f, -0.01287617f, -0.02864603f, 0.15060984f, 
    -0.21691290f, -0.11342094f, 0.06349687f, 0.01269440f, -0.30209357f, 0.11785312f, -0.02084797f, -0.02471559f, 
    -0.08424108f, -0.08577292f, 0.15174924f, -0.15758386f, 0.46302950f, -0.14325194f, 0.22431804f, 0.04248379f, 
    -0.13974272f, -0.15890145f, -0.01562550f, 0.14224397f, -0.24197365f, -0.47051972f, -0.05531694f, -0.29258320f, 
    0.26294681f, -0.00315080f, 0.01440073f, 0.13894573f, 0.01168369f, 0.23756310f, -0.14183770f, 0.15222168f, 
    -0.09326902f, 0.12649831f, 0.09917165f, 0.07057247f, 0.28353241f, -0.06600589f, 0.03745852f, 0.01369099f, 
    0.08969425f, -0.03621835f, -0.06445272f, 0.01978199f, 0.46332887f, -0.12764943f, -0.17143731f, -0.03659120f, 
    -0.45681646f, -0.01148491f, -0.06630273f, -0.21767181f, 0.23410134f, -0.44993731f, 0.26389784f, -0.18581295f, 
    -0.13495210f, -0.19862346f, 0.17537142f, -0.23026289f, -0.15095514f, 0.01093452f, 0.11743625f, 0.03667916f, 
    0.19228224f, 0.10050380f, 0.05249820f, -0.10751206f, 0.28091291f, 0.04804907f, -0.09042677f, 0.16453277f, 
    -0.08629794f, 0.08580198f, -0.16916180f, -0.16008839f, 0.07771700f, 0.10588335f, -0.11100650f, 0.08358312f, 
    -0.06358154f, -0.00954864f, -0.07150007f, 0.01523921f, -0.09939891f, -0.18054804f, -0.10013136f, 0.12681045f, 
    -0.17147334f, 0.02131226f, -0.19587199f, -0.19600056f, 0.05233749f, -0.17696919f, 0.01251036f, 0.05422018f, 
    -0.08710150f, -0.11618190f, -0.11696015f, -0.04115732f, -0.11764309f, -0.00727448f, -0.09325126f, 0.12987435f, 
    -0.09326427f, -0.05853754f, 0.65642875f, 0.35510430f, 0.09406657f, -0.06477391f, -0.12947221f, 0.15307316f, 
    -0.09458783f, -0.02942235f, -0.09953591f, -0.33431140f, 0.02650254f, 0.28951010f, 0.16275436f, 0.26152650f, 
    -0.10386451f, -0.22678137f, 0.12060900f, 0.48302302f, -0.33490059f, 0.16566204f, 0.10033578f, 0.19495736f, 
    -0.21939813f, 0.14425232f, 0.02878004f, -0.25762531f, -0.05197626f, -0.02017810f, -0.18608294f, 0.27216479f, 
    -0.12519006f, -0.07386075f, 0.43296239f, 0.28493652f, -0.03941108f, 0.12177058f, 0.27964205f, -0.09177494f, 
    0.08094635f, -0.15645650f, 0.00318442f, 0.12921827f, -0.03614288f, 0.07456544f, -0.14754237f, -0.04062058f, 
    0.03173412f, 0.15454088f, -0.04357623f, 0.32051986f, -0.07108394f, 0.18801166f, 0.05286651f, -0.13302320f, 
    -0.28531882f, 0.02309739f, -0.21396296f, -0.20502336f, -0.14171761f, 0.12144606f, 0.03729026f, 0.31631383f, 
    0.17593518f, -0.13790838f, 0.35344696f, 0.01893943f, -0.26228511f, 0.16958067f, 0.24563244f, -0.13806273f, 
    -0.07530128f, -0.00702683f, 0.20784761f, -0.09547029f, -0.34161434f, -0.37881300f, 0.05826139f, -0.03487518f, 
    0.41809592f, 0.30225894f, -0.09655575f, 0.34126142f, 0.03237239f, 0.08435356f, 0.25213644f, -0.00138353f, 
    0.02454374f, 0.06465524f, -0.28875539f, -0.18821508f, 0.20439175f, 0.03788426f, 0.24395077f, 0.17514305f, 
    0.07517382f, 0.15581091f, 0.07699606f, -0.07808382f, -0.39563137f, -0.00010994f, 0.03773227f, -0.04194069f, 
    -0.24793710f, -0.06958933f, 0.18645386f, -0.07730839f, 0.12255952f, 0.41174781f, 0.09901398f, 0.11077277f, 
    -0.02633637f, 0.09444384f, -0.28099531f, -0.17711076f, 0.16391276f, 0.03765779f, 0.04189274f, -0.17571692f, 
    0.18468742f, -0.08885774f, 0.20422730f, -0.20864274f, 0.14239185f, 0.07010547f, -0.03475901f, 0.24924703f, 
    0.08964872f, -0.15000305f, 0.19084051f, 0.08453462f, 0.35291579f, -0.05964696f, -0.48568752f, -0.06473079f, 
    -0.09800033f, -0.14866087f, 0.09719667f, 0.09644777f, -0.16850129f, -0.05970639f, 0.07876438f, -0.10364521f, 
    -0.01002702f, -0.12038628f, 0.05785631f, 0.15883602f, -0.24612573f, 0.21031682f, 0.07469988f, 0.28128475f, 
    0.09804983f, 0.15581712f, -0.19018035f, -0.10309200f, 0.09369646f, -0.14876862f, 0.19273591f, 0.18373907f, 
    -0.11349536f, -0.08030661f, -0.34152606f, -0.18323177f, -0.03842162f, -0.08605180f, 0.45566279f, -0.16364142f, 
    0.23225138f, -0.05132804f, 0.08020554f, 0.36543411f, -0.11445811f, 0.23316915f, -0.19967815f, 0.00414698f, 
    -0.09310516f, 0.38305551f, 0.12646155f, 0.06085502f, 0.23920321f, -0.16992447f, 0.10596403f, -0.03262014f, 
    -0.28951576f, -0.16319740f, -0.19870076f, -0.33482251f, -0.00019550f, 0.02938424f, 0.23448823f, -0.17001510f, 
    -0.15692456f, 0.15935443f, -0.07531049f, -0.11099613f, 0.21344391f, 0.07885201f, 0.62528360f, -0.14299107f, 
    -0.02425242f, 0.14241824f, 0.33654207f, 0.23992182f, -0.02797904f, 0.14094695f, 0.13224652f, 0.03269693f, 
    -0.22066072f, 0.12547511f, -0.44918421f, -0.25957561f, 0.20255469f, -0.36105683f, 0.11956307f, -0.28243113f, 
    0.21361779f, 0.16092433f, -0.19228409f, -0.59764403f, -0.10421515f, 0.11538226f, 0.30549994f, -0.31830847f, 
    -0.09180973f, -0.09885743f, 0.26734498f, 0.20054318f, -0.41526476f, 0.06917593f, 0.28782442f, -0.10993171f, 
    0.32921782f, -0.17529148f, 0.01011902f, 0.11166643f, 0.07349227f, -0.16118151f, -0.05981802f, 0.01535325f, 
    -0.43209890f, 0.04444936f, -0.15967478f, 0.25611880f, -0.02475385f, 0.33746606f, 0.12747370f, 0.09765854f, 
    -0.20697860f, -0.04612615f, 0.10097531f, -0.41958061f, -0.23341198f, -0.15728752f, 0.29860279f, 0.28224590f, 
    0.14814541f, -0.01005657f, -0.41444620f, -0.11389688f, 0.13351864f, 0.06561457f, -0.20617914f, 0.09873431f, 
    -0.13032284f, -0.02610424f, 0.33243454f, 0.22043449f, -0.17929606f, -0.23524168f, -0.10287419f, 0.03816862f, 
    -0.09173903f, 0.10481974f, -0.30815151f, -0.00628447f, -0.09944537f, 0.09457073f, 0.33015192f, 0.10302083f, 
    0.32927987f, 0.12472534f, -0.35381263f, -0.44588539f, -0.33834702f, 0.12150005f, 0.42325673f, 0.10844406f, 
    -0.03477836f, -0.09468673f, -0.15019763f, -0.01193793f, -0.36442330f, -0.09144160f, -0.01078333f, 0.10719111f, 
    -0.17758358f, -0.08019852f, 0.02612397f, -0.13324702f, -0.09911329f, -0.13002190f, 0.22854532f, -0.10105103f, 
    0.32589263f, -0.04447723f, 0.25564757f, -0.03596023f, 0.11027898f, 0.07690989f, 0.06470454f, -0.11991503f, 
    0.20821737f, 0.09118021f, 0.07922390f, -0.07221660f, 0.06490014f, -0.16097061f, -0.19957195f, 0.04375587f, 
    -0.14402902f, 0.03007477f, 0.15201816f, 0.08175281f, -0.38608810f, 0.12820959f, 0.03330893f, 0.12244152f, 
    -0.06874499f, 0.05840137f, 0.11709668f, -0.12523653f, -0.17032216f, 0.33171269f, 0.11247484f, 0.07521732f, 
    -0.38683242f, 0.15227993f, -0.17520316f, -0.01548602f, 0.04484275f, -0.10691252f, 0.02625918f, -0.11821342f, 
    0.22900276f, -0.16978270f, -0.12855919f, -0.10249305f, -0.02270941f, -0.07594597f, 0.29113129f, 0.12914979f, 
    -0.14410159f, -0.08858526f, -0.26167059f, 0.22719823f, -0.01951268f, -0.11203545f, 0.30557007f, 0.11963858f, 
    -0.08535092f, 0.14502782f, -0.11207481f, -0.31512383f, 0.41754577f, 0.02382161f, 0.29913339f, -0.08212854f, 
    -0.18023066f, 0.20119806f, -0.04399130f, -0.18227811f, 0.29501560f, -0.14432925f, -0.04663896f, -0.03140335f, 
    -0.01326003f, -0.07106335f, 0.40400228f, 0.30324736f, -0.00072897f, -0.03989846f, 0.01365831f, -0.21829249f, 
    0.04681122f, 0.02934813f, -0.16883071f, 0.18714918f, -0.14181840f, -0.01708279f, -0.11546199f, 0.11372619f, 
    -0.03255183f, -0.14294632f, -0.16153914f, 0.11078010f, 0.02203903f, 0.14965193f, -0.32387164f, -0.14326373f, 
    -0.02971799f, -0.04357518f, 0.04536390f, -0.16424392f, -0.00431094f, 0.01241013f, -0.23096187f, 0.05244081f, 
    -0.14958809f, 0.01063538f, -0.11200668f, 0.01317402f, -0.26664364f, -0.18458846f, 0.16724978f, -0.33032313f, 
    -0.04369761f, 0.11043767f, -0.50461370f, -0.10097574f, -0.11054982f, -0.08048691f, 0.21385829f, 0.07361636f, 
    0.29592705f, 0.07645888f, 0.12101191f, 0.17105697f, -0.24981034f, 0.09390165f, -0.22911043f, 0.21770886f, 
    -0.14990237f, 0.05360600f, -0.01623834f, 0.11389989f, 0.03401240f, -0.02660431f, 0.05244844f, 0.09901734f, 
    -0.14096747f, -0.03303526f, -0.12828356f, -0.08867483f, -0.11548743f, -0.02666247f, 0.12178467f, 0.08805786f, 
    -0.04125097f, 0.04775194f, 0.09987608f, 0.05877695f, -0.14572228f, 0.03228605f, -0.06017363f, -0.05869518f, 
    -0.13377018f, 0.10212394f, 0.04112066f, -0.01314656f, -0.07899304f, 0.00244217f, -0.06655619f, -0.18228811f, 
    -0.00112506f, -0.18514292f, 0.09972483f, -0.03628699f, 0.00412224f, -0.18940330f, -0.11386927f, -0.02108155f, 
    -0.18747519f, -0.03092899f, 0.02235663f, 0.03419034f, 0.06800089f, -0.14660354f, -0.01640493f, -0.05501853f, 
    -0.11180878f, -0.17566608f, -0.37506983f, 0.30010724f, 0.01622734f, -0.02891338f, 0.12322673f, -0.17743082f, 
    0.04109533f, -0.02040061f, 0.07111192f, -0.42083132f, 0.12670240f, -0.02546763f, 0.00997314f, 0.25656652f, 
    0.09437352f, 0.06881276f, 0.14936541f, 0.14995196f, 0.10450039f, -0.06498760f, 0.16545285f, -0.26026294f, 
    0.27574202f, -0.13683003f, -0.23869678f, -0.05208835f, -0.38974148f, -0.18838187f, -0.19244787f, 0.21090202f, 
    -0.10444330f, -0.06088838f, -0.04410271f, -0.10958557f, 0.42049226f, -0.01994094f, 0.22401051f, -0.06889199f, 
    0.09681083f, -0.00643381f, 0.12860952f, -0.23346382f, 0.03255743f, -0.40835246f, 0.06003844f, -0.12477401f, 
    -0.10559987f, -0.21660493f, -0.06920456f, 0.13575926f, -0.05598005f, -0.10115796f, 0.06968895f, 0.12916183f, 
    -0.07624064f, -0.02430728f, -0.26974812f, 0.06716872f, -0.10285006f, 0.08429924f, 0.24487245f, 0.03875771f, 
    -0.05171387f, 0.17643526f, 0.05931043f, 0.02735594f, 0.05503811f, 0.04900257f, -0.06129798f, -0.11905378f, 
    0.18555513f, -0.13801940f, -0.06882524f, -0.02207370f, 0.06536140f, -0.09292594f, -0.16848783f, 0.07890563f, 
    -0.14684750f, -0.05500442f, -0.13395679f, -0.13663381f, -0.11789516f, -0.08240772f, 0.11516082f, 0.00590430f, 
    -0.03303884f, -0.17145737f, -0.14037399f, 0.00828241f, 0.09707028f, -0.00304239f, -0.15410815f, -0.18766569f, 
    -0.12263798f, -0.11002292f, -0.45643756f, 0.12381511f, 0.28568482f, -0.04303892f, -0.35488388f, 0.10475358f, 
    -0.18879670f, -0.11288908f, -0.14144333f, -0.27223238f, -0.20863983f, -0.10237502f, 0.07081957f, 0.19535835f, 
    0.51128531f, -0.09890842f, 0.09027896f, 0.15552494f, -0.01537240f, -0.16201277f, 0.27049240f, 0.19124493f, 
    0.19823129f, 0.04994808f, -0.11716752f, -0.20916197f, -0.10323980f, -0.15292427f, 0.10713017f, 0.05476769f, 
    -0.12858720f, -0.03705499f, -0.14626421f, 0.23576675f, 0.10777699f, -0.14913037f, -0.09319992f, 0.10761379f, 
    -0.19001694f, -0.02289758f, 0.09620345f, 0.13822563f, 0.30379680f, -0.07048915f, 0.14125018f, 0.21822833f, 
    0.00808206f, -0.16621570f, -0.22113916f, -0.11622710f, -0.07078400f, 0.07834357f, -0.10676902f, -0.07595397f, 
    -0.02557679f, 0.05815345f, -0.01051805f, -0.00752888f, -0.42112282f, -0.06233678f, 0.12560137f, 0.03678981f, 
    0.01005299f, -0.04969109f, 0.54691654f, 0.05142982f, -0.03544603f, -0.08649187f, 0.05363685f, 0.01422928f, 
    -0.24043298f, -0.04057131f, -0.19131942f, -0.12250461f, 0.36370173f, -0.04753219f, 0.12357315f, 0.27075022f, 
    0.01057016f, -0.12993585f, 0.19467808f, 0.00157584f, 0.03498651f, 0.01389004f, -0.06051710f, -0.06069309f, 
    0.08461682f, 0.01024055f, 0.23812526f, -0.25266656f, 0.22092083f, 0.04982051f, -0.25706407f, 0.10932902f, 
    0.02941578f, -0.05035337f, 0.40107822f, 0.06406901f, -0.42453867f, -0.15233940f, -0.41831064f, 0.10932774f, 
    -0.22182329f, -0.00530279f, 0.00034131f, 0.38205758f, 0.09103408f, 0.36456472f, 0.03089089f, 0.13011380f, 
    -0.06369986f, 0.25560674f, -0.13314289f, 0.04702501f, 0.10432547f, 0.24242187f, -0.12717810f, 0.06431755f, 
    -0.05707647f, -0.02202605f, -0.06107073f, -0.22938152f, 0.11493762f, -0.16312173f, 0.10557373f, 0.27416936f, 
    0.08199189f, -0.09472232f, 0.12529108f, -0.02016960f, -0.17892700f, -0.11569884f, 0.06647408f, 0.09154597f, 
    -0.01418016f, 0.00073702f, -0.09547618f, -0.07348771f, -0.05950392f, -0.02507939f, -0.00028926f, -0.17261094f, 
    0.06120769f, 0.01283165f, 0.12368038f, -0.09883205f, -0.05768897f, -0.05153767f, -0.05512113f, -0.02764288f, 
    -0.05848080f, -0.09225988f, 0.10895526f, -0.04948274f, 0.07161716f, 0.03239522f, -0.21442415f, -0.18820375f, 
    0.14709976f, 0.06822026f, 0.39319754f, 0.13785250f, -0.06954131f, 0.00546069f, -0.12509537f, 0.13024358f, 
    0.01501118f, -0.14421336f, -0.12776187f, 0.33478492f, -0.01489769f, -0.18926454f, 0.06599237f, -0.45472905f, 
    0.20131239f, 0.13301212f, 0.20661122f, -0.28595027f, 0.13956915f, 0.28788909f, -0.10909401f, 0.09418402f, 
    -0.06931113f, 0.14393274f, 0.11070658f, -0.12095848f, 0.28052777f, -0.16671045f, 0.04103257f, -0.16690533f, 
    0.15709712f, -0.12028456f, 0.49304321f, 0.00061640f, -0.34341893f, 0.04062925f, 0.22870483f, -0.00743787f, 
    0.08717172f, -0.00805306f, -0.14996476f, 0.17466295f, -0.03340688f, -0.00082494f, 0.01509734f, -0.14506562f, 
    -0.38422862f, 0.00281470f, -0.00292531f, 0.08606102f, 0.03016574f, 0.31978139f, -0.16986297f, 0.22726224f, 
    0.08656331f, 0.06763955f, 0.24152607f, -0.36926121f, 0.07767671f, 0.01510998f, 0.08678455f, 0.30311894f, 
    0.03301515f, 0.15276735f, 0.15451998f, -0.29246989f, 0.02406299f, 0.17431264f, -0.06882545f, 0.13618930f, 
    0.37898120f, 0.17042989f, 0.26097983f, 0.36098924f, -0.07176095f, 0.04750320f, 0.02698947f, -0.34997582f, 
    -0.00218889f, 0.43092924f, -0.20802729f, -0.06095973f, 0.02464165f, -0.39472294f, -0.02836738f, 0.15538347f, 
    0.03286429f, 0.12023830f, 0.06616558f, -0.04856821f, 0.21213764f, 0.06750357f, 0.03169807f, -0.30740058f, 
    0.04045029f, 0.05259515f, -0.09589007f, -0.03093733f, 0.31126392f, 0.00942713f, 0.08510234f, -0.15822138f, 
    0.26647538f, 0.09777418f, 0.13198678f, 0.04530837f, -0.38771212f, 0.01635495f, -0.12833570f, -0.13541384f, 
    -0.01256599f, 0.21031086f, 0.06688345f, 0.15521902f, 0.13091759f, -0.05340479f, -0.08791675f, 0.00497307f, 
    -0.02162405f, 0.03060434f, -0.18307817f, -0.05616100f, -0.12141968f, -0.10080872f, 0.17743665f, 0.06914341f, 
    0.15785049f, 0.09000599f, 0.04967623f, -0.05788816f, -0.01539055f, -0.05984890f, -0.16004309f, 0.09549281f, 
    -0.13329418f, 0.13363381f, -0.13476188f, -0.08692151f, -0.15771249f, 0.11764769f, 0.07792097f, 0.00742301f, 
    -0.04038750f, -0.13200571f, 0.03452922f, 0.09431408f, -0.05111437f, 0.01113669f, -0.12675980f, -0.13586913f, 
    -0.14933787f, 0.00164156f, 0.07834584f, -0.15631858f, 0.00858235f, 0.04725172f, -0.13234581f, -0.11823997f, 
    -0.02363704f, 0.02890884f, 0.02174607f, 0.06987007f, -0.01064077f, -0.00495163f, -0.09378470f, 0.05303828f, 
    -0.21116690f, -0.01886906f, -0.11370876f, 0.04013098f, -0.08283410f, -0.01965648f, 0.23837097f, -0.24418136f, 
    0.00876096f, -0.29145008f, -0.12251493f, 0.08017806f, -0.14937277f, 0.15565272f, 0.00169652f, -0.27594200f, 
    -0.09845593f, -0.12436090f, -0.29517782f, 0.14859787f, -0.06408235f, 0.11782739f, -0.13922834f, -0.01911398f, 
    0.03643363f, 0.12325123f, 0.51854730f, 0.01503593f, 0.07200743f, 0.03895315f, 0.32048371f, -0.11854137f, 
    -0.33354217f, 0.09601460f, -0.10193097f, -0.24034221f, 0.15037838f, -0.00070108f, 0.00186571f, -0.10419410f, 
    0.06085861f, -0.27808586f, -0.05102506f, 0.32504958f, 0.15991092f, 0.07078909f, -0.08740894f, 0.10585663f, 
    0.12642658f, 0.03134827f, 0.07287280f, -0.01498366f, -0.26232481f, 0.10419873f, -0.11764416f, 0.20747225f, 
    -0.04382861f, 0.10275830f, -0.15076946f, -0.21917267f, -0.00893185f, -0.13817528f, -0.40332067f, 0.06363620f, 
    -0.08071078f, -0.07735930f, 0.22829287f, 0.32103801f, -0.09569825f, 0.19622125f, -0.13155897f, -0.22171767f, 
    -0.22594579f, 0.30107170f, 0.04599690f, -0.18772671f, -0.00354878f, -0.08080996f, 0.02087451f, 0.14723064f, 
    0.13782242f, -0.17198765f, -0.11567465f, -0.08781462f, -0.23425500f, -0.07678248f, 0.24897176f, 0.13170484f, 
    -0.08642650f, -0.01687047f, 0.46490988f, 0.11765569f, 0.10762033f, 0.01744340f, -0.30817172f, -0.06108686f, 
    -0.12812741f, -0.05561144f, -0.09266107f, 0.14551024f, 0.34704766f, 0.28242970f, 0.29485089f, -0.07152387f, 
    -0.27323624f, -0.16602013f, 0.11701202f, -0.10169489f, -0.01714887f, 0.05739747f, 0.08444603f, 0.18505327f, 
    -0.06612404f, 0.07294860f, 0.21564603f, 0.06511128f, -0.16163574f, 0.01391383f, -0.09972541f, 0.08731730f, 
    0.03104820f, 0.01641691f, 0.17796786f, -0.04245611f, -0.28416240f, 0.02701646f, -0.22049583f, -0.00055139f, 
    -0.06283440f, -0.00865073f, 0.14424853f, 0.11104988f, 0.18502374f, 0.22619008f, 0.28460333f, -0.06350372f, 
    -0.40760806f, -0.12285561f, 0.23748192f, -0.25776953f, -0.16174705f, -0.12987220f, 0.25905326f, 0.13278335f, 
    0.26207310f, -0.11285131f, 0.01185028f, -0.04603714f, -0.10673781f, -0.12842375f, 0.36330742f, 0.09014367f, 
    0.11977177f, 0.10144380f, 0.07159720f, -0.06659715f, -0.05288878f, 0.02415084f, -0.11503780f, 0.07198039f, 
    0.16589886f, 0.10907295f, 0.08575389f, 0.13396953f, 0.11552549f, -0.00650721f, -0.03353077f, -0.05931250f, 
    0.08092060f, -0.15389563f, -0.19154851f, -0.06593880f, -0.01245515f, -0.06377629f, -0.08746082f, -0.26714227f, 
    -0.19074859f, 0.14865981f, 0.28197998f, -0.02106015f, -0.05785455f, -0.00128961f, -0.07940414f, -0.10201258f, 
    -0.05387001f, 0.04377447f, -0.14201486f, -0.17319568f, -0.28123161f, 0.00061573f, 0.38660163f, 0.04236782f, 
    -0.28434524f, 0.14800003f, 0.16321540f, -0.01781524f, -0.23210257f, 0.21374871f, 0.10534559f, -0.17712414f, 
    -0.27821293f, -0.08140082f, -0.08218976f, -0.16626613f, 0.26449311f, 0.30949068f, -0.09883379f, -0.12670864f, 
    -0.30203179f, -0.04112340f, 0.17711698f, 0.14834003f, -0.19014370f, 0.08713081f, 0.08363727f, 0.09977742f, 
    0.13206415f, 0.11898384f, 0.87277144f, 0.16414107f, -0.09913871f, 0.15156269f, -0.04514965f, 0.10950495f, 
    -0.27814922f, -0.02783555f, 0.11980001f, 0.02492149f, 0.10402903f, -0.20235223f, 0.38398120f, -0.35297459f, 
    -0.02475142f, 0.07419214f, -0.00841902f, -0.09241363f, 0.15971863f, 0.11241333f, -0.14907426f, -0.03890550f, 
    -0.19501454f, -0.05192580f, 0.15923296f, 0.09330609f, 0.23595306f, -0.16908145f, 0.24647535f, 0.04916692f, 
    0.12144886f, 0.16882472f, 0.03822370f, -0.20918356f, 0.02513971f, -0.08632576f, 0.46757290f, -0.02106202f, 
    0.23112579f, -0.10444535f, 0.12789732f, 0.16168718f, 0.08700803f, 0.37681210f, -0.05252723f, 0.08074436f, 
    -0.23435333f, 0.09088755f, -0.37627852f, -0.25797465f, 0.26945359f, -0.27801740f, 0.08619287f, -0.34714583f, 
    0.34779060f, -0.00492440f, -0.17813113f, -0.27737519f, 0.44383526f, 0.00209974f, 0.13122031f, 0.11786206f, 
    -0.13001236f, -0.11402181f, 0.21329780f, -0.01002313f, 0.24823102f, 0.08967652f, -0.11887802f, 0.00592300f, 
    -0.31413132f, -0.11172307f, 0.01748688f, -0.26656586f, 0.02834203f, 0.06082198f, 0.29127586f, -0.00831529f, 
    0.08050970f, -0.00608714f, -0.02170872f, -0.16978061f, 0.19902720f, 0.20059389f, 0.08008377f, -0.08484148f, 
    0.48051202f, -0.01093058f, 0.16051306f, 0.02881589f, 0.10825923f, 0.13080186f, -0.02382247f, -0.09259760f, 
    0.01712380f, 0.06723817f, 0.30688739f, -0.11480282f, -0.35052076f, 0.10995823f, 0.45510185f, -0.03863455f, 
    -0.22864370f, -0.10456130f, 0.14623120f, 0.23148556f, 0.18051495f, 0.05865892f, -0.00304182f, 0.15771218f, 
    0.33620691f, 0.44330439f, -0.24269712f, 0.01195311f, 0.23513769f, 0.04732263f, -0.20701391f, -0.17248152f, 
    0.15686454f, -0.11583606f, 0.05077244f, -0.38826248f, -0.00220490f, 0.01212385f, 0.24393004f, -0.11838850f, 
    0.07893215f, 0.12594210f, 0.66173524f, 0.08869264f, 0.06179488f, 0.12198152f, 0.00368854f, 0.08810250f, 
    -0.29996726f, -0.13381584f, 0.25502715f, 0.21576028f, -0.11580767f, -0.36676228f, 0.12865429f, -0.17445172f, 
    -0.05254772f, 0.02542755f, -0.15993415f, -0.02802244f, 0.13186304f, 0.14367989f, 0.00874441f, 0.03522495f, 
    -0.10279620f, -0.15408035f, -0.21103328f, 0.08178567f, 0.07680260f, -0.11414880f, 0.37549052f, -0.11118539f, 
    -0.12905444f, 0.16836220f, -0.47535652f, 0.29611477f, 0.36950645f, -0.06315378f, -0.24164495f, 0.04379357f, 
    -0.16073880f, -0.07443268f, -0.01693984f, 0.05670342f, 0.18893586f, 0.00149989f, 0.03989822f, 0.06373447f, 
    0.32343963f, -0.31139871f, -0.06253394f, 0.07131372f, -0.05568613f, 0.11040413f, 0.07274321f, 0.00668856f, 
    0.05584436f, -0.07535116f, -0.11994957f, -0.11692081f, -0.12130996f, 0.09340478f, -0.02192949f, 0.10988777f, 
    0.02850364f, 0.06401246f, -0.11151841f, -0.03398611f, -0.07081492f, -0.06176922f, 0.24662744f, -0.14829592f, 
    -0.04445710f, -0.01742380f, 0.29447129f, 0.27749786f, -0.04075044f, -0.07646557f, -0.16122080f, 0.13968791f, 
    -0.26673308f, 0.17854977f, -0.09175167f, 0.33626127f, 0.10881945f, 0.06773637f, 0.11578255f, 0.10855740f, 
    -0.04998019f, -0.01915423f, -0.34052739f, -0.40506053f, -0.34451020f, -0.07998400f, 0.11285391f, 0.18124259f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.03707869f, -0.13754414f, 0.14759797f, 0.08552843f, -0.15025997f, 0.13754484f, 0.23809256f, 0.02721895f, 
    -0.25518686f, 0.11831567f, -0.18608454f, -0.09143419f, 0.04285740f, 0.13237463f, 0.04438015f, -0.09911214f, 
    0.11717585f, 0.15304591f, 0.02457101f, 0.09041958f, -0.08587454f, 0.11048639f, 0.11424918f, 0.20498474f, 
    0.14619043f, 0.07985737f, -0.18978462f, -0.15846805f, -0.13231134f, -0.05556635f, -0.12816456f, 0.18986972f, 
    0.01339849f, 0.16901532f, 0.02190467f, -0.11895110f, 0.05610563f, -0.20412146f, -0.14717649f, 0.03175778f, 
    0.00168313f, 0.13280191f, 0.11199359f, -0.02389423f, 0.27900112f, -0.11809646f, -0.09720606f, -0.03302422f, 
    -0.11399597f, 0.14757459f, 0.13911220f, -0.28128371f, -0.13734931f, 0.19083288f, 0.21732169f, -0.12687175f, 
    0.09093198f, -0.12748396f, 0.26229331f, 0.11485660f, -0.02532409f, 0.35662657f, 0.01772716f, 0.07163089f, 
    0.00444345f, 0.31075177f, 0.15162763f, 0.20451093f, 0.05100507f, 0.13682961f, -0.13428825f, -0.06790291f, 
    -0.00680611f, -0.02191698f, -0.03121893f, 0.00610621f, 0.18622577f, 0.09533159f, -0.13008222f, 0.27006480f, 
    0.28003761f, 0.09843280f, 0.18045312f, -0.09167317f, -0.06570076f, -0.09646079f, 0.05119625f, 0.27806973f, 
    0.15951091f, 0.04326470f, 0.29411063f, 0.15389189f, 0.19977583f, 0.06495111f, 0.27269560f, 0.02124404f, 
    0.13652679f, -0.19584213f, -0.21673350f, 0.09253849f, 0.02752923f, 0.11845955f, -0.00654486f, 0.00996323f, 
    0.28557464f, 0.08684091f, -0.14551952f, 0.04636469f, 0.02028203f, 0.18143278f, -0.10348485f, 0.05185595f, 
    0.23954752f, -0.10071789f, -0.01610003f, 0.16025528f, -0.09507188f, -0.16779436f, -0.08000536f, 0.00729022f, 
    -0.15502763f, -0.01827238f, -0.17987975f, 0.29191759f, 0.23179656f, -0.04204258f, -0.12910813f, 0.12586810f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.05526360f, -0.07653695f, -0.24704215f, 0.08881921f, 0.12928063f, -0.19246806f, -0.25462472f, -0.06174638f, 
    0.21066995f, 0.05173731f, -0.02973271f, -0.08227423f, 0.02945161f, -0.06716304f, -0.04637685f, -0.27683830f, 
    -0.16718648f, -0.06960662f, 0.07387617f, 0.03021058f, -0.01917058f, 0.10526765f, -0.37597135f, 0.04698490f, 
    -0.10864765f, 0.03509752f, 0.06172291f, -0.08893467f, 0.03869935f, -0.13327165f, -0.08296372f, -0.00037853f, 
    0.56526142f, -0.23799194f, -0.24221167f, 0.27447253f, -0.12444114f, 0.05698778f, 0.28121164f, -0.18127199f, 
    -0.04013460f, -0.19793430f, 0.09586645f, -0.14472796f, -0.24610922f, 0.10611771f, -0.03763799f, 0.12861942f, 
    0.10595707f, -0.09178927f, 0.09102932f, 0.41707221f, 0.01364908f, -0.00281916f, 0.03900358f, 0.09890611f, 
    -0.10434598f, 0.08415814f, -0.12768637f, 0.17373084f, -0.00707335f, -0.02416382f, 0.11968029f, -0.05353047f, 
    -0.31872022f, -0.01944454f, 0.05591530f, -0.12040751f, -0.43223536f, -0.52729350f, -0.10716799f, 0.14016375f, 
    -0.06634447f, 0.03306859f, 0.03089201f, 0.03993484f, -0.03371286f, -0.00304554f, 0.04153644f, 0.03777954f, 
    -0.52690232f, -0.06339275f, -0.12746100f, 0.04535286f, 0.00751769f, -0.03177536f, -0.23595151f, -0.23634019f, 
    -0.52302796f, 0.04046238f, -0.29235619f, -0.07097706f, -0.01716468f, -0.27412537f, -0.38114068f, 0.04764838f, 
    -0.21417959f, 0.20458923f, 0.02259969f, -0.15169226f, 0.03808187f, 0.04958798f, -0.08239353f, -0.14098173f, 
    -0.14295176f, 0.10394170f, 0.17407727f, -0.30925882f, 0.01042172f, -0.19595350f, -0.10932358f, -0.26419064f, 
    -0.18982568f, -0.05618616f, -0.04212534f, 0.04003733f, -0.03696765f, 0.04581693f, -0.10871023f, 0.11498067f, 
    -0.07653717f, -0.02668165f, 0.03104612f, 0.14539781f, 0.07740023f, -0.28067020f, 0.03300661f, -0.19193918f, 
    0.06285382f, 0.05289032f, -0.14519526f, 0.06129845f, 0.12523846f, 0.11845886f, -0.63841516f, 0.04107407f, 
    -0.71089011f, -0.74372941f, -0.02572830f, -0.05291363f, 0.11764122f, -0.19598716f, 0.25100118f, -0.05717210f, 
    -0.12571162f, -0.07613783f, -0.03552334f, -0.10607151f, -0.07135624f, 0.19465336f, -0.28510582f, -0.22044571f, 
    -0.07204621f, 0.00508050f, -0.18294492f, 0.01443032f, -0.02876021f, -0.06642178f, 0.09125908f, 0.16476017f, 
    -0.13927612f, -0.06172148f, 0.17665803f, 0.06178600f, 0.26841694f, -0.11074345f, 0.17901367f, 0.13455048f, 
    -0.02078782f, 0.08269525f, -0.22723424f, 0.38582799f, 0.45473742f, 0.01927307f, -0.15133175f, -0.62732041f, 
    0.05727032f, 0.11969621f, -0.05053568f, -0.77932388f, -0.07333166f, -0.42588922f, 0.20649356f, 0.06431272f, 
    0.00829696f, 0.02812096f, 0.08376352f, 0.19245267f, 0.00405696f, 0.22787811f, -0.09512746f, 0.02338775f, 
    -0.00681656f, 0.05353501f, 0.03795709f, -0.00542096f, 0.00278686f, 0.05143321f, 0.02525588f, 0.10669463f, 
    -0.03227846f, 0.04646282f, 0.04592333f, -0.02171914f, 0.03415489f, -0.05141408f, 0.05543514f, 0.23100403f, 
    0.01225050f, 0.02403377f, -0.08297633f, -0.04997072f, 0.22298603f, -0.03533007f, 0.19088544f, -0.03867652f, 
    -0.16238026f, -0.22950698f, 0.03767793f, 0.03678987f, -0.50396091f, -0.04550223f, -0.40665856f, -0.02572994f, 
    -0.26453757f, 0.01924855f, 0.24979129f, -0.03921308f, 0.00249923f, 0.02940750f, -0.02528457f, 0.01539503f, 
    0.06636561f, 0.02608005f, 0.16749795f, -0.02256289f, 0.05873514f, 0.18946289f, -0.07092856f, 0.21114311f, 
    -0.06347383f, 0.02115192f, -0.11387706f, 0.04243173f, 0.02044211f, 0.17756721f, 0.07677566f, -0.14193788f, 
    -0.12313710f, 0.08664873f, -0.64863425f, 0.08947843f, -0.72172409f, -0.12736768f, 0.10704629f, -0.45446286f, 
    -0.08245070f, -0.05347644f, 0.06910370f, 0.00611408f, -0.01803864f, 0.10836297f, 0.39224815f, 0.31265610f, 
    -0.36664170f, -0.01140102f, -0.00682363f, -0.03570739f, -0.00964886f, -0.02502529f, -0.25279117f, 0.07002805f, 
    0.15754907f, -0.11150701f, 0.30903354f, 0.01036728f, 0.03357844f, -0.19236635f, -0.07084174f, 0.04476320f, 
    0.05645045f, -0.03676600f, -0.26772121f, -0.07629485f, 0.19093509f, -0.19005792f, -0.00592782f, -0.15419924f, 
    -0.10172369f, -0.05270182f, 0.21213059f, -0.15198982f, -0.15050252f, -0.01403019f, -0.08618012f, -0.11577176f, 
    -0.01316787f, -0.13326678f, 0.11084083f, -0.47360691f, -0.49461260f, -0.00848522f, 0.19545248f, -0.74213684f, 
    -0.52604663f, -0.45575806f, 0.01914858f, -0.03774457f, 0.18142444f, 0.10608824f, 0.03843729f, -0.33617809f, 
    -0.09001720f, -0.04497601f, 0.22094636f, 0.37800327f, -0.19708975f, -0.17181931f, -0.54718745f, -0.06369068f, 
    -0.10276476f, 0.04524700f, 0.06219547f, -0.35111001f, -0.02809971f, -0.04272761f, -0.11431874f, 0.13854077f, 
    0.17124014f, 0.13121973f, -0.22826849f, -0.00117821f, -0.06902379f, -0.09417260f, -0.04905431f, -0.47715196f, 
    -0.25358194f, 0.04478980f, 0.14155141f, 0.03075587f, -0.54522556f, -0.04070315f, -0.06754033f, 0.12187397f, 
    0.14212073f, -0.24379627f, -0.07190820f, 0.09812358f, 0.42854574f, 0.11317138f, 0.12115420f, -0.20251037f, 
    0.05107112f, -0.01006352f, 0.07082131f, -0.06067609f, 0.04415433f, 0.10079698f, 0.10842244f, -0.10878355f, 
    -0.03852953f, 0.00032342f, -0.84472883f, -0.59490162f, -0.07685952f, -0.23101248f, -0.05065066f, -0.25281864f, 
    0.04938911f, -0.02299258f, -0.17453340f, 0.05357258f, -0.20514286f, -0.22160853f, -0.25889087f, -0.11302970f, 
    0.05810548f, -0.01555994f, 0.27772248f, -0.04882883f, 0.05754354f, 0.15410881f, -0.01455920f, 0.11406942f, 
    0.21364392f, -0.11688527f, 0.31505603f, 0.19504367f, -0.25963905f, -0.85673833f, 0.07136200f, -0.27496493f, 
    -0.13872710f, -0.15680604f, 0.03229130f, -0.08903444f, 0.18115143f, -0.00637896f, -0.66109413f, -0.27912804f, 
    0.02942833f, 0.06749202f, -0.05635401f, -0.05695381f, -0.03203303f, 0.00588390f, -0.05742641f, -0.14328502f, 
    -0.02197701f, 0.03749382f, 0.06159208f, -0.52396137f, 0.07082572f, 0.41660222f, 0.03084865f, 0.12638052f, 
    -0.29930505f, 0.18114147f, 0.08240176f, 0.15424411f, -0.03258953f, 0.22569032f, -0.12251586f, 0.04671597f, 
    -0.24635333f, -0.09791915f, 0.11112921f, -0.00598943f, -0.20406775f, 0.14161524f, -0.08901195f, -0.09160824f, 
    0.16152140f, -0.47458354f, -0.02356433f, -0.02340355f, 0.13633135f, -0.00311294f, -0.17644183f, 0.02315058f, 
    -0.55080879f, -0.00146027f, -0.13247822f, 0.06157069f, -0.22558318f, 0.09634050f, 0.10614970f, -0.07175052f, 
    -0.36452425f, -0.18329541f, -0.08595019f, -0.37721568f, -0.01137872f, 0.13890864f, -0.23388456f, -0.03207146f, 
    -0.12244472f, 0.03437647f, -0.16419053f, -0.03709444f, -0.09273501f, 0.07310680f, 0.05555631f, -0.90769649f, 
    -0.14166015f, 0.03174096f, -0.09605423f, -0.52594823f, -0.07195485f, -0.05484257f, -0.26200533f, -0.15520273f, 
    0.00261141f, 0.08643465f, -0.20105673f, 0.02632304f, 0.22322677f, -0.13082466f, 0.17234084f, 0.07677909f, 
    0.19007397f, 0.07377531f, -0.06255390f, -0.37433204f, -0.04715722f, 0.17657600f, -0.04281294f, -0.12102816f, 
    0.11512042f, 0.16214368f, -0.14878842f, -0.13988853f, -0.07007603f, -0.37670344f, -0.45389214f, 0.00731536f, 
    -0.12141576f, 0.07111573f, -0.39054734f, -0.16976932f, 0.09444620f, -0.03171507f, 0.14148474f, -0.10734662f, 
    -0.42353565f, -0.03932020f, 0.08413404f, 0.09968173f, 0.02308447f, 0.08380250f, 0.03614081f, 0.15838021f, 
    -0.08449873f, 0.00012966f, 0.25378239f, -0.06182268f, -0.02496563f, 0.09348079f, -0.00501227f, 0.04507229f, 
    0.22429229f, 0.21191545f, 0.00868449f, -0.00605903f, -0.19143377f, 0.00532383f, -0.21967824f, 0.10677778f, 
    0.04125829f, 0.03272651f, 0.14279762f, 0.08006396f, -0.00983045f, 0.04118739f, 0.17075926f, -0.33319893f, 
    0.02187532f, -0.03439358f, 0.08799540f, 0.26140216f, 0.05412232f, -0.10754594f, -0.09260420f, -0.24370727f, 
    0.05271332f, -0.06495038f, -0.14696965f, -0.59959799f, -0.37113911f, 0.05824760f, 0.07697790f, 0.07915688f, 
    0.07911503f, 0.08863373f, 0.12070335f, -0.03794951f, -0.28024372f, -0.25207314f, -0.31905016f, 0.21639878f, 
    -0.05233183f, 0.07753336f, 0.01933933f, -0.04447854f, -0.00289604f, 0.11478025f, -0.17305684f, -0.01701379f, 
    0.13821153f, -0.00473228f, -0.08586115f, -0.02871509f, -0.24023440f, 0.02809328f, 0.01380976f, -0.00390218f, 
    0.23152089f, -0.35847551f, 0.04877632f, 0.13077979f, 0.06632452f, 0.07730048f, -0.05674277f, -0.12641764f, 
    0.11632925f, 0.01687526f, 0.06315441f, 0.16802138f, 0.11524323f, 0.10561620f, -0.03623183f, -0.23270233f, 
    0.22167628f, 0.00882649f, -0.19771886f, 0.13256864f, 0.08876242f, 0.07660893f, -0.29390737f, -0.33345631f, 
    0.10645770f, 0.01673227f, -0.02172655f, -0.50379139f, 0.03377260f, -0.33917442f, -0.18263668f, 0.04714957f, 
    -0.07115676f, 0.01188138f, 0.00003569f, -0.00306142f, 0.03549913f, -0.23259160f, -0.02615047f, -0.02542767f, 
    -0.08473389f, -0.19812715f, -0.03154945f, -0.25201800f, -0.04188706f, 0.02743557f, -0.08557847f, -0.00128619f, 
    -0.09935085f, 0.05596887f, 0.04240747f, -0.28607610f, -0.29187202f, 0.00127630f, 0.01809472f, -0.08070150f, 
    -0.10199587f, 0.13545717f, 0.19428258f, 0.10094529f, -0.15967429f, 0.15875721f, -0.10867610f, -0.60273629f, 
    0.16704537f, -0.06252109f, -0.58840138f, -0.05700605f, 0.13807331f, 0.06344183f, -0.32786313f, -0.07492709f, 
    0.03105766f, -0.25235447f, -0.04351292f, 0.05581173f, 0.08675513f, 0.14392348f, -0.13967529f, 0.00552592f, 
    0.09054990f, 0.05734686f, -0.00353737f, 0.17369525f, 0.03232713f, -0.04384105f, -0.35291398f, -0.18239333f, 
    0.06046190f, 0.00396838f, -0.09029613f, 0.11563941f, -0.06417729f, -0.34902909f, -0.37073907f, 0.14816262f, 
    -0.31069055f, -0.06179376f, -0.04166910f, -0.15504269f, -0.88478452f, 0.12284409f, -0.17734762f, -0.14049949f, 
    0.03347658f, 0.08102874f, 0.12318172f, -0.08579649f, -0.28971916f, 0.05422529f, -0.06899921f, 0.04488958f, 
    -0.27156433f, 0.14224166f, 0.03049439f, 0.10985529f, 0.13769539f, -0.07223242f, -0.01553153f, -0.03484504f, 
    -0.16542101f, -0.14725842f, -0.18698685f, -0.23728995f, 0.08127394f, 0.01287314f, -0.36976275f, -0.01046871f, 
    0.22140288f, 0.02172407f, 0.06689299f, -0.07826575f, -0.08656447f, 0.16998067f, 0.00393759f, -0.03286504f, 
    0.27767041f, -0.17774369f, 0.14634979f, -0.06270422f, 0.03818149f, 0.03685652f, 0.08830249f, -0.11577879f, 
    0.12044179f, -0.11993773f, 0.10235003f, -0.02104416f, -0.08270123f, -0.04379855f, 0.28347456f, 0.11522604f, 
    -0.00781480f, 0.17237723f, -0.03133091f, -0.29008803f, -0.24749465f, 0.18685690f, -0.16964947f, -0.09404466f, 
    0.19005826f, -0.09740192f, 0.03814364f, -0.12274730f, 0.04617727f, -0.10601926f, -0.04621244f, -0.11258824f, 
    -0.28459615f, 0.08943593f, 0.20023419f, 0.27130243f, 0.05514513f, -0.01071825f, 0.32579073f, -0.54063928f, 
    -0.03824487f, 0.07125330f, -0.12171324f, 0.20501749f, 0.06195217f, 0.17319037f, 0.03336470f, -0.01861676f, 
    0.43336040f, 0.17785363f, -0.13383582f, 0.05210005f, 0.05733973f, 0.18114254f, -0.10181244f, 0.04122267f, 
    -0.68951058f, -0.03066698f, -0.00614088f, -0.19875284f, 0.00456685f, -0.12277862f, 0.23240545f, -0.14313331f, 
    -0.13041985f, 0.31335270f, 0.04960382f, -0.06734192f, -0.46442759f, -0.09930039f, -0.08383055f, -0.02682690f, 
    -0.25499800f, -0.03535157f, 0.04121260f, -0.00112713f, 0.00885453f, -0.19613861f, 0.05909369f, 0.12346892f, 
    0.07024651f, -0.05453525f, -0.23840545f, -0.03922151f, -0.14085114f, -0.14826700f, -0.07379948f, -0.53691185f, 
    0.04587510f, 0.13929598f, -0.32543430f, -0.46149486f, -0.01339251f, -0.02295326f, -0.24518681f, -0.30575851f, 
    0.01836486f, -0.37211734f, -0.75684947f, 0.07154917f, 0.22179899f, -0.18494932f, 0.07297957f, -0.44184679f, 
    -0.37967682f, 0.13919908f, -0.08827522f, -0.09072060f, 0.16755231f, 0.30636686f, 0.05969292f, -0.20991927f, 
    0.24957474f, -0.29064870f, 0.14318308f, -0.32400507f, 0.24448311f, -0.54076374f, -0.32750162f, -0.07963815f, 
    -0.09259317f, 0.11956848f, 0.05874084f, 0.22550409f, -0.00877270f, -0.32431826f, -0.03958346f, -0.00824286f, 
    0.30461103f, 0.23227336f, -0.64979309f, -0.17756441f, -0.55073792f, -0.26239297f, 0.08528246f, 0.30982926f, 
    -0.50616002f, -0.07398193f, 0.23373966f, 0.05108671f, -0.24619916f, -0.06868996f, -0.34283650f, 0.14459656f, 
    0.12462346f, -0.26270452f, -0.16338101f, 0.19211707f, -0.07546113f, 0.14639615f, -0.21794809f, -0.14103492f, 
    -0.13610215f, -0.16408661f, -0.03418528f, 0.18916725f, 0.02282675f, -0.06987152f, 0.07050475f, -0.00069802f, 
    -0.31514639f, -0.03372183f, -0.16553102f, -0.25293911f, -0.06364596f, -0.30820906f, -0.15975578f, 0.15206592f, 
    0.12422998f, 0.01548467f, -0.06274185f, -0.07313460f, -0.04332529f, -0.14697658f, -0.63472652f, 0.30204910f, 
    -0.10022758f, -0.35683736f, -0.02725434f, -0.75573891f, 0.03762124f, -0.22931121f, -0.13899356f, 0.21701033f, 
    -0.25389957f, 0.02167251f, -0.23005320f, 0.13591491f, 0.14144316f, -0.07861490f, 0.09908712f, -0.02967099f, 
    -0.13210583f, -0.11287568f, 0.00108457f, -0.05972498f, -0.21372889f, -0.21506733f, 0.21744385f, 0.04737473f, 
    0.20013811f, -0.01339318f, -0.68842930f, -0.29320624f, -0.08304888f, -0.32950020f, 0.15432756f, -0.23479635f, 
    0.00274472f, 0.03402636f, -0.14312489f, 0.17798388f, -0.03539993f, 0.20422976f, -0.08736964f, 0.20335160f, 
    0.18637714f, 0.00731420f, -0.03476993f, -0.08357321f, -0.27074575f, -0.02959369f, -0.30293399f, -0.00142476f, 
    0.02242964f, 0.13769452f, -0.34503272f, -0.12400314f, -0.40169328f, 0.16093603f, 0.07334252f, -0.02557194f, 
    -0.06267568f, -0.00030888f, -0.09397633f, 0.25226694f, 0.12782462f, -0.49462959f, 0.13014790f, 0.17131415f, 
    -0.10116676f, 0.09397870f, -0.20621307f, -0.58053660f, 0.12460674f, -0.38245776f, 0.29182079f, 0.00623570f, 
    0.03337610f, -0.18180388f, -0.03807282f, 0.08152308f, 0.02136284f, -0.15548001f, -0.00063278f, 0.27302232f, 
    -0.12616521f, -0.30172980f, -0.00040178f, 0.08982258f, -0.27762893f, -0.11118607f, -0.01885366f, -0.06164718f, 
    -0.10890707f, -0.08236519f, -0.27032796f, -0.14637607f, -0.09991530f, -0.04434854f, -0.29374263f, -0.09249281f, 
    -0.52872223f, 0.19802070f, -0.10023288f, 0.11944900f, 0.30932188f, -0.39180276f, -0.20501862f, -0.26243392f, 
    0.23937269f, 0.07879259f, -0.27596146f, 0.04299771f, -0.07548315f, -0.25559989f, -0.05621623f, 0.05008952f, 
    -0.32689098f, -0.15502889f, -0.68220830f, 0.04154447f, 0.04198522f, -0.48386189f, -0.28199589f, 0.04950044f, 
    0.01723126f, -0.02084730f, -0.02306084f, -0.12335736f, 0.13703610f, 0.17315143f, 0.31866813f, -0.15743512f, 
    0.00368042f, -0.41652900f, 0.53516299f, -0.01266624f, -0.01975578f, -0.53079134f, -0.19336259f, -0.20788276f, 
    -0.35191515f, 0.04672595f, -0.44579697f, 0.05648243f, -0.14198603f, -0.10688023f, -0.25432816f, 0.16566274f, 
    -0.12975751f, -0.35299766f, 0.05523925f, 0.05423703f, 0.01905116f, 0.14356773f, 0.15213184f, 0.15764654f, 
    -0.08404580f, -0.05042433f, -0.89328945f, -0.04459105f, -0.02082611f, -0.36400771f, -0.35807511f, 0.16284923f, 
    -0.07306904f, -0.02787946f, -0.15881686f, -0.13998739f, -0.08111954f, -0.23966412f, -0.33924469f, -0.04549819f, 
    -0.35039392f, 0.16080821f, 0.28202915f, 0.63114560f, 0.12192719f, -0.16420925f, -0.23713601f, 0.08201446f, 
    -0.01689596f, 0.19803500f, -0.37042373f, 0.06003565f, -0.14560461f, 0.13228270f, 0.06657747f, -0.08298161f, 
    -0.38846964f, -0.06005910f, 0.01250146f, -0.19381410f, -0.20651260f, -0.41456923f, 0.05229476f, 0.02593368f, 
    -0.00685479f, -0.31602898f, 0.08027802f, -0.49720657f, -0.08143600f, 0.21686570f, 0.03077085f, -0.29009685f, 
    -0.08018016f, 0.02896656f, 0.05613739f, -0.13173175f, -0.03203382f, 0.26668727f, -0.11404644f, 0.11436146f, 
    -0.12371243f, -0.58508968f, -0.03378528f, -0.07186760f, 0.08812457f, -0.42383906f, -0.00195234f, 0.01360607f, 
    -0.30156890f, 0.06082553f, -0.15856536f, -0.17327046f, -0.34977147f, 0.01207773f, 0.19109450f, 0.23207282f, 
    0.10629857f, 0.22330816f, 0.06257515f, 0.02391940f, -0.45828426f, 0.28767377f, 0.20948218f, -0.26019454f, 
    0.21561301f, -0.34183171f, -0.19605251f, 0.19719601f, 0.01595105f, 0.19582589f, -0.11087815f, -0.01166644f, 
    0.17819780f, 0.01136651f, -0.20785889f, 0.33639681f, -0.05799070f, -0.12392036f, 0.21763271f, -0.20540518f, 
    0.07592926f, -0.09360486f, -0.09527555f, -0.25242180f, 0.08030868f, -0.08633415f, 0.02205508f, -0.16382502f, 
    -0.02232052f, -0.62986767f, 0.08273445f, -0.25435448f, -0.04109433f, -0.54626930f, 0.11531427f, 0.17364307f, 
    0.23043975f, 0.01436137f, 0.29124135f, -0.13144827f, -0.14498840f, 0.05266507f, 0.16335182f, -0.44169116f, 
    -0.18706107f, 0.22129451f, -0.00565736f, 0.01664275f, -0.04965178f, -0.05762844f, -0.26130590f, -0.03475278f, 
    0.04379363f, -0.10070352f, 0.02075311f, 0.26319626f, -0.02065252f, -0.18632549f, 0.26282442f, 0.15259387f, 
    -0.06406606f, 0.05795901f, 0.19780371f, -0.09863020f, 0.07608002f, 0.11794028f, -0.19770388f, -0.56034708f, 
    -0.09556413f, -0.03244560f, -0.63555354f, -0.37296915f, -0.30313396f, -0.24214929f, -0.33442268f, -0.13139558f, 
    -0.02831474f, -0.17000751f, 0.46063659f, -0.19161981f, -0.13203579f, -0.22719616f, -0.39992881f, 0.44139674f, 
    -0.50162047f, -0.05047562f, -0.06940558f, -0.33449307f, 0.04314414f, 0.23852015f, -0.32837474f, -0.15141873f, 
    0.06695271f, -0.07135569f, 0.10942038f, -0.44107887f, -0.09734095f, -0.34159654f, -0.16792384f, -0.06034191f, 
    0.05453333f, -0.04770378f, 0.06082000f, 0.03731646f, 0.08376975f, -0.15578382f, -0.01755409f, -0.19919778f, 
    -0.05121950f, -0.00866955f, 0.17162691f, 0.34801227f, -0.16029532f, 0.12656358f, 0.03561569f, 0.10111373f, 
    0.23979527f, 0.02423225f, 0.04088511f, 0.10729685f, -0.46701390f, 0.02926524f, 0.11541167f, 0.00441734f, 
    0.18153930f, 0.04748072f, -0.09372981f, -0.03131731f, -0.05880899f, -0.24089724f, -0.06308490f, 0.15847521f, 
    -0.11983267f, -0.22311708f, 0.11550599f, -0.13530631f, 0.04341453f, 0.03987361f, -0.06328006f, -0.02195389f, 
    0.35126990f, -0.26746333f, -0.09263107f, -0.03508539f, -0.05279652f, 0.33364204f, -0.21736512f, 0.09410472f, 
    0.04099625f, -0.08715507f, -0.22251306f, 0.01778441f, -0.00586764f, -0.40119362f, -0.51135325f, -0.32052696f, 
    -0.32011983f, -0.01487674f, -0.17395724f, 0.01809411f, 0.30288428f, -0.07900225f, 0.04584439f, -0.14296442f, 
    -0.55540276f, -0.01849941f, 0.06907228f, 0.02100736f, -0.48261368f, -0.79539800f, -0.18880241f, -0.15632871f, 
    -0.10449716f, -0.63540828f, -0.09142733f, -0.04792490f, 0.09155457f, 0.10641912f, 0.32545489f, 0.10312895f, 
    0.23901851f, -0.01057524f, 0.03917715f, -0.10992369f, 0.03380940f, 0.06162017f, 0.07277749f, -0.01571715f, 
    0.00996625f, 0.00429118f, 0.06345179f, -0.43099886f, -0.30696523f, -0.38199675f, 0.09912643f, 0.05588870f, 
    0.03276728f, -0.23972689f, 0.06760645f, -0.17623481f, -0.18909948f, -0.19839075f, 0.02903552f, 0.29869294f, 
    0.18561900f, 0.01663754f, -0.34629017f, -0.50951892f, 0.07730703f, -0.39896584f, 0.27484065f, -0.41088688f, 
    -0.13819100f, -0.49767464f, -0.02867082f, -0.29825747f, -0.29051152f, -0.55937111f, -0.36419538f, -0.04312269f, 
    -0.30085865f, -0.04252093f, 0.08528440f, 0.24055471f, 0.26193157f, 0.10600233f, 0.36940613f, 0.02076273f, 
    0.27845886f, -0.00357871f, 0.07171459f, -0.36699468f, 0.02800487f, -0.10606565f, 0.09839854f, -0.29767537f, 
    -0.47051460f, 0.13967294f, 0.13637398f, -0.25440314f, 0.20011991f, -0.28809738f, 0.05140484f, -0.17641173f, 
    0.26260346f, -0.12922116f, 0.02627699f, 0.32905105f, 0.26352370f, -0.08410891f, 0.23587565f, 0.07921638f, 
    0.01713849f, -0.27479890f, 0.33209175f, -0.37899634f, -0.09549893f, -0.16895358f, 0.33889481f, -0.30048954f, 
    -0.17842503f, -0.53385413f, -0.13007939f, -0.09349385f, -0.06115631f, 0.04029290f, 0.19203585f, -0.07316562f, 
    0.37645373f, 0.23200111f, -0.31411442f, -0.32229280f, 0.05243636f, -0.55411965f, -0.28404701f, -0.05630871f, 
    0.11349224f, -0.01099822f, -0.06118953f, 0.14758363f, -0.00220343f, 0.03749867f, -0.09098284f, -0.04883512f, 
    -0.08666249f, -0.19273810f, -0.41732252f, 0.11438542f, -0.60801560f, 0.09580261f, 0.23004732f, 0.08953807f, 
    -0.27642423f, -0.01792583f, 0.20594382f, -0.30700231f, -0.17057142f, 0.01204930f, -0.05374046f, -0.01137329f, 
    -0.27380025f, -0.10960308f, -0.13530521f, -0.05732953f, -0.31416172f, 0.24826300f, -0.11541475f, 0.04303347f, 
    -0.26961237f, 0.03033644f, -0.34380856f, -0.17215700f, -0.10500929f, -0.42100143f, 0.05083717f, -0.00097040f, 
    0.01427552f, 0.02028227f, 0.05668813f, -0.17466226f, -0.44632974f, -0.22002506f, -0.07082094f, 0.15703629f, 
    -0.01517696f, 0.08499918f, 0.10735694f, -0.24402921f, -0.07066201f, -0.21620224f, -0.14216262f, 0.11280043f, 
    0.02821766f, -0.09827346f, -0.13927178f, 0.18628177f, 0.06193274f, -0.60840601f, 0.39675280f, -0.11291400f, 
    -0.03851448f, 0.12657477f, -0.00385542f, -0.27226356f, -0.27979472f, -0.14698943f, -0.35177734f, -0.23782855f, 
    0.00038472f, -0.42378587f, -0.09722643f, -0.55153131f, -0.32170209f, 0.06598158f, 0.16592841f, -0.07906687f, 
    0.16913210f, 0.16908643f, 0.05775716f, 0.01932477f, 0.13958621f, 0.23911949f, 0.08138330f, -0.81761020f, 
    -0.08659828f, -0.25824314f, -0.13237165f, -0.60431498f, 0.00099772f, 0.15014423f, -0.07489915f, -0.03320490f, 
    0.25994837f, -0.02345333f, -0.12008483f, 0.10925273f, -0.43943140f, -0.07570911f, -0.61254865f, 0.04155883f, 
    0.10084671f, -0.18153849f, 0.12294828f, 0.22056659f, 0.15102969f, 0.16692199f, 0.30191135f, 0.04303002f, 
    -0.07352404f, -0.81123221f, 0.06514242f, -0.00332195f, 0.06044852f, -0.33779269f, -0.02551287f, -0.06876066f, 
    -0.02722275f, 0.05550716f, -0.49593905f, 0.20041664f, 0.04371794f, 0.17353220f, 0.12248565f, 0.23327403f, 
    -0.03786113f, 0.05009574f, 0.22116061f, -0.25496998f, 0.22633098f, -0.08397738f, 0.13603865f, -0.14714466f, 
    -0.35202652f, 0.01857106f, -0.15191604f, -0.24196857f, 0.13408068f, 0.26098984f, -0.08061278f, 0.26686665f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.14518310f, 0.12799986f, 0.04948292f, 0.08729987f, -0.01432451f, -0.01852161f, -0.07258445f, 0.02785354f, 
    -0.03447382f, 0.13334048f, -0.00942159f, 0.04131798f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
