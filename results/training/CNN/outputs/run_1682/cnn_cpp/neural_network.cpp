#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.25019741f, -0.42976356f, -0.32083237f, -0.10466834f, -0.31311432f, -0.54162043f, -0.51418179f, -0.59759283f, 
    -0.31439066f, -0.73110735f, 0.42364937f, 0.21554600f, 0.33838913f, -0.03613251f, 0.27082467f, 0.01849135f, 
    -0.07346456f, -0.00752095f, -0.01018423f, -0.01598093f, 0.06907518f, -0.14226730f, -0.08013020f, 0.25022030f, 
    0.29646790f, -0.13253182f, 0.71789640f, 0.42900640f, -0.13922366f, -0.18472140f, -0.16023760f, -0.41787416f, 
    -0.22099130f, 0.35261545f, 0.01272652f, 0.09927033f, -0.39781135f, -0.07510613f, -0.20825689f, -0.31095380f, 
    0.38670957f, 0.25466967f, -0.18467888f, -0.05477669f, -0.12769787f, 0.08839107f, -0.24756293f, -0.11713817f, 
    -0.12057096f, -0.16548106f, -0.58651149f, 0.15986125f, 0.50532538f, 0.58280045f, 0.10328132f, -0.46147695f, 
    -0.68007201f, -0.38764480f, 0.42083061f, 0.31317508f, -0.07286809f, 0.21656056f, -0.15905602f, 0.01310194f, 
    -0.09204016f, 0.21449722f, 0.26821640f, -0.14947735f, -0.26230940f, -0.05710340f, -0.04767842f, -0.15107940f, 
    0.03251014f, -0.06302593f, 0.02377165f, -0.72495067f, 0.12221632f, -0.42853430f, -0.26757443f, -0.28855401f, 
    -0.09386972f, -0.05730408f, -0.33126989f, -0.29500487f, 0.14484729f, 0.08699964f, -0.08239905f, -0.13526046f, 
    -0.37634999f, -0.11975278f, 0.20959769f, 0.00344762f, 0.16942978f, 0.38683856f, 0.22267896f, -0.09156300f, 
    -0.35993779f, -0.17878318f, -0.18650110f, -0.28683957f, -1.10502541f, -0.36317462f, 0.08227940f, -0.74584234f, 
    -0.58457530f, 0.79427928f, 0.29302782f, 0.08201531f, 0.20116955f, 0.43188336f, -0.14379179f, -0.23675749f, 
    -0.02522698f, 0.05579858f, -0.06601053f, 0.12486678f, -0.05853493f, -0.20271464f, 0.14065291f, 0.06465794f, 
    0.00701208f, 0.27148178f, 0.17362414f, 0.12957618f, -0.06213438f, 0.68647456f, -0.26409772f, -0.59353596f, 
    -0.76340258f, -0.80975926f, 0.66400433f, 0.23242940f, 0.08359344f, -0.10592341f, 0.29582646f, 0.06573062f, 
    0.04595917f, -0.17365468f, 0.10945243f, 0.19161102f, -0.12042385f, 0.15982477f, 0.04861920f, -0.18641706f, 
    -0.45982921f, -0.25176972f, 0.19883946f, 0.14677085f, 0.06717478f, 0.40196973f, 0.38773251f, -0.54860926f, 
    -0.54570580f, -0.16966917f, 0.33692467f, -0.40938658f, -0.38074294f, -0.48852628f, -0.22200741f, 0.36657500f, 
    -0.00923605f, 0.63591146f, 0.10624760f, -0.11457882f, 0.02619748f, 0.26217210f, -0.10693651f, -0.29279035f, 
    -0.24996318f, -0.25342000f, -0.12048915f, -0.06852408f, -0.02787383f, 0.00722271f, -0.04540686f, -0.69203037f, 
    -0.31867671f, -0.38249582f, 0.63056648f, 0.31233451f, -0.16555771f, 0.10529278f, 0.22077242f, -0.34889320f, 
    -0.37219474f, 0.39354822f, 0.31494030f, -0.11168317f, 0.09869774f, 0.14208142f, -0.06185176f, -0.08588722f, 
    0.05342340f, -0.03432639f, -0.05164659f, -0.04015294f, 0.33111230f, 0.06015654f, 0.12201295f, 0.12619466f, 
    0.07388736f, 0.78725648f, -0.02274890f, -0.92255294f, -0.60535693f, 0.07713187f, -0.34651774f, 0.27053815f, 
    -0.36226237f, 0.54290110f, -0.11874980f, 0.05551913f, 0.43734470f, -0.00346846f, -0.25295061f, -0.24271326f, 
    0.24377118f, 0.04249097f, 0.18035638f, -0.27415016f, 0.22924756f, 0.11629261f, -0.41252542f, -0.09642085f, 
    -0.16928124f, -0.19791719f, -0.30309269f, -0.52775121f, 0.01610628f, 0.65317261f, 0.57472086f, -0.61196977f, 
    -0.28311655f, -0.08539608f, 0.00285012f, 0.00205310f, -0.07164647f, -0.02484973f, -0.16741414f, -0.10483512f, 
    0.07650152f, -0.35594207f, 0.12081804f, 0.21068402f, 0.12650259f, -0.27143118f, 0.12413593f, 0.19251984f, 
    -0.07892296f, 0.33116251f, 0.38174662f, 0.69391102f, 0.40088284f, 0.16233934f, 0.42797706f, -0.28327262f, 
    -0.09777459f, 0.13061902f, 0.46968710f, 0.25327808f, 0.28372595f, -0.28190342f, 0.06110818f, 0.11756859f, 
    -0.13724050f, -0.07508621f, 0.05973189f, -0.15334247f, -0.14960770f, 0.12863228f, 0.08185713f, -0.03724499f, 
    -0.31195074f, 0.29497299f, 0.21809739f, -0.29407874f, -0.92229724f, -0.79472458f, 0.36106887f, 0.62533534f, 
    0.28327206f, 0.31709927f, -0.36904445f, -0.74808842f, -0.59690523f, -0.08732816f, -0.50736511f, -0.08280835f, 
    0.13747768f, -0.17285410f, -0.07533957f, -0.01245271f, 0.43993229f, -0.45820662f, -0.29228282f, -0.19868715f, 
    -0.02817602f, 0.13825139f, -0.14253898f, -0.04904214f, 0.19793355f, 0.34819239f, 0.06768625f, -0.33844745f, 
    -0.33164421f, -0.17534080f, -0.12032282f, 0.16734724f, 0.03778750f, -0.11958095f, 0.18544807f, 0.05185515f, 
    0.00883865f, -0.34075534f, 0.19441053f, 0.47573391f, -0.11036302f, -0.20643564f, -0.45361248f, 0.22824621f, 
    -0.17439824f, 0.26158354f, 0.19099259f, 0.09645712f, 0.28909838f, -0.05718226f, 0.04638969f, 0.07298668f, 
    0.12916277f, 0.30035535f, -0.10490988f, -0.30620804f, -0.02415406f, -0.09361366f, -0.13914433f, -0.34379542f, 
    -0.09779122f, 0.17480260f, -0.10785622f, -0.13192624f, 0.31632146f, -0.10699169f, 0.14594531f, -0.13341554f, 
    -0.00762493f, -0.20040096f, 0.31801146f, 0.11618073f, -0.01358790f, 0.39989060f, 0.07025050f, 0.31090862f, 
    0.23203264f, 0.01630968f, 0.05638343f, -0.14530650f, 0.33054215f, 0.11594594f, -0.16776679f, -0.12510167f, 
    0.45026487f, 0.00614963f, -0.19442385f, -0.58911467f, -0.30514455f, 0.19188611f, 0.15081644f, -0.04415894f, 
    0.14418274f, 0.06162346f, -0.06264472f, -0.24959235f, -0.21892588f, -0.12132309f, -0.21352719f, -0.15806775f, 
    -0.06520970f, 0.25329575f, 0.01349155f, 0.31286684f, -0.09113205f, 0.59119451f, -0.69018906f, -0.23628552f, 
    -0.24389882f, -0.26407719f, -0.31980586f, -0.13907620f, -0.42309788f, -0.11038270f, 0.20781311f, -0.21937712f, 
    0.19414690f, 0.24876553f, 0.23517421f, -0.00501852f, -0.16553946f, -0.05292199f, 0.13523474f, 0.04893564f, 
    -0.33375213f, -0.03988355f, 0.24762650f, -0.68381947f, -0.45752570f, -0.01030335f, -0.12093286f, -0.25351438f, 
    -0.13839860f, -0.24655584f, 0.58322597f, 0.62038147f, -0.18570362f, 0.05097588f, 0.17539766f, -0.04421837f, 
    0.26314190f, -0.17914714f, -0.09528469f, -0.30822834f, 0.05858707f, -0.00082011f, -0.25956520f, -0.10851611f, 
    -0.29368412f, -0.24974822f, 0.02373852f, 0.69241053f, -0.54447269f, -0.01384042f, -0.52985048f, -0.31007051f, 
    0.56084025f, -0.24136832f, 0.11482176f, 0.29534718f, -0.07948886f, -0.04769766f, 0.17628725f, 0.16633427f, 
    -0.00090569f, 0.01318913f, 0.22386715f, 0.23442665f, 0.31514156f, -0.03978658f, -0.03128859f, -0.16005468f, 
    -0.34198761f, -0.01379575f, 0.39822042f, 0.54567355f, 0.38092065f, -0.18048368f, -0.05149671f, -0.33453405f, 
    -0.22688571f, -0.39530277f, -0.28468943f, -0.05801630f, 0.27524874f, 0.23576535f, 0.17452745f, 0.18552205f, 
    0.12571158f, -0.26392815f, -0.09028140f, 0.10559755f, -0.12316279f, 0.03344588f, 0.03204603f, 0.04630532f, 
    0.04988815f, 0.00783814f, -0.01172451f, 0.20356001f, 0.09853372f, -0.13664772f, -0.14986789f, 0.01506587f, 
    -0.02161583f, 0.13245821f, 0.08497386f, -0.30108660f, 0.19582495f, -0.04323791f, 0.34311643f, -0.21638776f, 
    -0.00685518f, 0.21169424f, -0.41491595f, -0.04085481f, -0.31909445f, 0.19230095f, -0.02950861f, 0.33607835f, 
    -0.08353456f, -0.09345284f, 0.35800514f, 0.13001102f, -0.07319776f, 0.26588032f, -0.01424968f, 0.21621573f, 
    -0.13072339f, 0.01349489f, 0.25009000f, 0.05713858f, 0.25188008f, 0.01471503f, -0.07773367f, 0.09913307f, 
    -0.14567062f, -0.35874444f, -0.20682622f, -0.20791990f, 0.28151569f, -0.04280393f, 0.12298954f, -0.15905157f, 
    -0.21820812f, -0.28125522f, -0.13771980f, -0.48269954f, -0.31482074f, 0.79362416f, 0.33513698f, 0.27886316f, 
    0.02179956f, -0.13289744f, -0.35549322f, -0.34757850f, -0.29316095f, -0.22249244f, -0.32755601f, -0.08062252f, 
    0.29587662f, -0.06703303f, -0.15300988f, 0.29740587f, -0.10014001f, 0.17243186f, -0.28596646f, 0.23736656f, 
    0.05990325f, -0.03306524f, 0.01707504f, 0.02043577f, -0.30838063f, -0.14993103f, 0.55664134f, 0.56189066f, 
    -0.41803357f, -0.46153089f, 0.42490342f, -0.12022769f, -0.05397924f, 0.09345639f, -0.37846464f, -0.39866728f, 
    0.14955832f, -0.19981706f, 0.11697704f, 0.11171214f, 0.12079254f, -0.03093025f, 0.23261560f, 0.20628181f, 
    -0.00629274f, 0.01111378f, -0.31091499f, 0.04238677f, 0.16736633f, 0.25032195f, 0.02133211f, -0.58386576f, 
    -0.55123997f, -0.24075548f, -0.23004067f, -0.09860739f, -0.37904242f, -0.19184427f, 0.33361924f, 0.45759079f, 
    0.33059537f, -0.34549725f, -0.32830957f, 0.25791356f, -0.16287267f, 0.10497775f, 0.13667744f, -0.08637714f, 
    -0.29119575f, -0.14439546f, -0.22644553f, 0.10140260f, -0.39034337f, -0.22805633f, -0.22467139f, -0.39725947f, 
    -0.38082987f, -0.79954076f, -0.43902397f, -0.36316332f, 0.17056698f, 0.30820403f, 0.01974262f, -0.56631893f, 
    -0.17371967f, 0.49941346f, -0.19686531f, 0.02292410f, -0.52399772f, -0.17077884f, -0.25816864f, -0.09352273f, 
    -0.05413097f, -0.22977792f, 0.29605734f, -0.27238610f, -0.15123205f, -0.00905381f, -0.25498137f, -0.15909004f, 
    -0.08090948f, -0.00642648f, -0.05589418f, -0.67347670f, -0.27167943f, -0.13315120f, 0.16655961f, 0.44475755f, 
    0.20145164f, -0.34652361f, -0.37917796f, -0.08173035f, -0.18153000f, 0.29464772f, -0.03497982f, -0.26915017f, 
    -0.31271353f, -0.21248162f, 0.00449364f, -0.41069695f, -0.15612821f, 0.06915497f, 0.20293988f, -0.21788873f, 
    0.29900211f, 0.33089367f, 0.89390171f, -0.93327719f, -0.10974455f, 0.54160774f, -0.47983992f, 0.40988213f, 
    0.48677146f, 0.63416457f, -0.50099874f, -0.18284056f, 0.02734915f, 0.00353684f, -0.06259678f, 0.06990577f, 
    -0.30897364f, 0.19331601f, -0.01941389f, -0.08414743f, -0.08997147f, -0.01129110f, 0.03370121f, -0.13838209f, 
    -0.16886081f, 0.06146672f, 0.22631213f, 0.53896266f, 0.28263274f, -0.65382105f, -0.77975667f, -0.63126910f, 
    0.12966889f, 0.25043964f, 0.40401453f, 0.24132998f, -0.26874748f, 0.33434290f, 0.23812075f, 0.03201796f, 
    -0.03237155f, 0.06711047f, -0.15366618f, -0.40937981f, 0.06109295f, 0.35973945f, -0.32434964f, 0.25649527f, 
    0.02646183f, -0.06102555f, -0.27185178f, 0.05923629f, -0.94662863f, 0.40854144f, -0.08347683f, -0.46150270f, 
    0.32841897f, -0.11804843f, -0.21629432f, 0.24261557f, 0.88964647f, -0.06526405f, 0.19091304f, -0.52427125f, 
    0.26602134f, -0.50653815f, 0.05670591f, 0.25778061f, -0.12107792f, 0.17357390f, -0.27132544f, 0.32559282f, 
    -0.04571058f, -0.19209523f, -0.07944734f, 0.15087874f, 0.15119140f, 0.19304353f, -0.37895656f, 0.18228079f, 
    -0.16219482f, 0.05059021f, 0.06254491f, 0.34913963f, -0.38244262f, -0.11284874f, 0.71345681f, 0.07837965f, 
    -0.13645770f, -0.01500886f, 0.08279312f, 0.44112766f, -0.34792489f, 0.13599165f, 0.10989355f, -0.28540578f, 
    -0.37953466f, -0.08014429f, -0.01161894f, 0.39848238f, 0.16851427f, 0.01862303f, 0.00952524f, -0.20501570f, 
    -0.21474022f, -0.13435987f, -0.44368091f, -0.28481501f, -0.45393106f, -0.38520965f, -0.32868120f, -0.55778110f, 
    -0.06034374f, -0.02918448f, -0.11428553f, -0.34728295f, -0.30052456f, -0.08349271f, 0.05663656f, -0.11668050f, 
    -0.40393797f, -0.28081852f, -0.29313943f, 0.20167810f, -0.03149956f, -0.29149333f, 0.01880751f, -0.28577372f, 
    0.18256406f, 0.19700670f, 0.20417221f, -0.06578185f, -0.03048696f, 0.00115682f, 0.11199166f, 0.12987788f, 
    0.29743847f, -0.00286477f, 0.08451248f, 0.12624066f, -0.23777053f, 0.21667741f, 0.10148580f, 0.41005453f, 
    0.10533392f, 0.15144305f, -0.44588813f, 0.00671645f, 0.34884307f, -0.01018041f, -0.02194494f, -0.17044984f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.21854474f, 0.02630872f, 0.11372650f, -0.12923875f, -0.20640397f, 0.19000314f, 0.15780680f, 0.13843331f, 
    0.14105321f, 0.18916534f, 0.02019402f, -0.07255772f, 0.21538915f, -0.05150273f, 0.06297400f, -0.05678435f, 
    0.05786840f, 0.14320119f, 0.02630889f, 0.17547254f, 0.01868952f, 0.12204725f, 0.15081018f, 0.01571885f, 
    0.01904709f, 0.07705136f, 0.44495854f, 0.11786623f, 0.29458585f, 0.07208222f, 0.15329610f, -0.13908407f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.00799949f, -0.01464593f, 0.00234054f, 0.02065937f, -0.01064309f, -0.02601226f, -0.04848342f, -0.05291917f, 
    -0.01205011f, 0.03431580f, 0.04201706f, 0.03677581f, -0.00270362f, -0.04604593f, -0.03182217f, -0.03577491f, 
    -0.01679945f, 0.02267366f, -0.03607526f, -0.01684555f, 0.02397517f, 0.03906101f, -0.03474342f, -0.05471379f, 
    0.03484478f, 0.02915519f, -0.04998550f, 0.02098826f, 0.03018950f, 0.03308642f, -0.03056818f, -0.00640286f, 
    -0.01341966f, -0.00181766f, -0.01437643f, -0.03853799f, -0.00555292f, 0.04889196f, 0.03502182f, -0.00705021f, 
    -0.01081614f, -0.02186961f, 0.02150740f, 0.04354811f, -0.04781478f, -0.01555339f, -0.04044129f, -0.01785254f, 
    0.02834626f, 0.01680719f, 0.01066766f, -0.05022890f, -0.02965739f, -0.03306425f, 0.01599463f, 0.02870430f, 
    -0.03407950f, 0.03009259f, -0.00488200f, 0.03914991f, -0.02340729f, -0.01297555f, -0.00889552f, -0.01376213f, 
    0.00679814f, -0.04861950f, 0.02582946f, -0.02177039f, 0.02439009f, 0.01773573f, 0.02894126f, -0.00492078f, 
    -0.05235630f, -0.00210120f, -0.04956252f, 0.00536904f, 0.02233703f, -0.03818601f, -0.02960021f, 0.02038728f, 
    -0.01375324f, -0.04112934f, -0.04105505f, -0.04542640f, -0.04671802f, 0.04009034f, -0.04213325f, -0.05583651f, 
    -0.05016271f, -0.05141011f, 0.02827009f, -0.00575090f, -0.00040652f, -0.03948842f, 0.02654856f, -0.03910885f, 
    -0.05210942f, -0.01806257f, 0.01132260f, 0.01695370f, -0.04964110f, -0.01139925f, -0.01666018f, 0.03841565f, 
    -0.00462929f, 0.00553073f, -0.03010785f, -0.02578578f, 0.02103098f, -0.03727954f, -0.00385566f, 0.04343651f, 
    0.03002708f, -0.01539088f, -0.01900963f, 0.00713821f, -0.05284455f, 0.00347038f, -0.02620285f, -0.04265352f, 
    -0.00115996f, -0.02033508f, -0.04320964f, 0.02756995f, -0.01950455f, 0.00903300f, 0.02554213f, 0.04362805f, 
    -0.04689375f, -0.01263763f, -0.03717844f, -0.04447816f, 0.03375033f, -0.03357318f, 0.02492295f, 0.00396086f, 
    -0.03251914f, -0.04167771f, -0.04527679f, 0.02466321f, 0.02304482f, 0.02426932f, -0.03171289f, -0.02298402f, 
    -0.00198538f, 0.03511481f, -0.03116382f, -0.03975820f, -0.05121849f, 0.00333147f, -0.05206827f, -0.01298507f, 
    -0.04878482f, 0.04111456f, -0.03391910f, -0.01615903f, -0.04292397f, -0.00629587f, -0.05144172f, -0.05282810f, 
    0.04199292f, -0.03625976f, -0.01614838f, 0.00050401f, -0.01918185f, -0.03888486f, -0.00627912f, 0.01275546f, 
    0.00117693f, 0.02604314f, 0.02972343f, -0.04488576f, -0.03024563f, 0.00015736f, -0.00392910f, 0.02488637f, 
    -0.00745628f, -0.00232032f, -0.03151439f, -0.03602363f, -0.04969614f, 0.00109749f, -0.02841282f, -0.04441187f, 
    -0.03268767f, -0.01303697f, 0.01552692f, -0.00806709f, 0.02651306f, -0.00751643f, 0.04222749f, 0.03766675f, 
    0.02243914f, 0.02428112f, -0.02202247f, -0.01141906f, -0.04759093f, -0.01593098f, 0.00145682f, 0.00247935f, 
    -0.04253363f, 0.00825882f, -0.01478171f, 0.02041762f, -0.05040239f, 0.04166236f, -0.00194257f, 0.03291652f, 
    -0.01443446f, 0.02357680f, -0.04769685f, 0.03256864f, 0.03434870f, 0.02619315f, -0.03888135f, -0.05576433f, 
    -0.03100100f, 0.03850013f, -0.02038315f, 0.00798423f, -0.02268701f, 0.04743345f, -0.00175789f, 0.00579618f, 
    -0.01927822f, 0.03901448f, 0.03288468f, -0.02647005f, 0.00411716f, -0.00806970f, 0.00908795f, 0.01900898f, 
    0.03627615f, -0.03966529f, -0.05095312f, -0.00603354f, 0.03094734f, -0.03598567f, 0.01346351f, 0.04232031f, 
    -0.03220807f, -0.01072347f, 0.04474485f, -0.05212233f, -0.04649292f, -0.01981350f, -0.03675473f, -0.00409982f, 
    -0.02450741f, 0.01724608f, -0.04765343f, 0.02974483f, -0.03802830f, -0.04118766f, 0.02863125f, 0.03667856f, 
    -0.03548029f, 0.01707185f, -0.03865321f, -0.01805622f, 0.01260846f, -0.02484220f, 0.04059704f, -0.04629559f, 
    -0.05192931f, 0.03785037f, 0.00650973f, 0.04694696f, -0.01415018f, -0.01375237f, 0.00831401f, -0.04479720f, 
    -0.00043327f, -0.01963994f, -0.02508307f, 0.02647942f, 0.04586572f, 0.04854693f, 0.02419661f, -0.02166238f, 
    0.03278610f, 0.00073860f, -0.03228220f, -0.02547359f, -0.00925687f, 0.01595358f, -0.05005934f, 0.02884283f, 
    -0.01400096f, -0.02296808f, -0.00551624f, 0.02131354f, 0.01849834f, -0.02887211f, -0.02658175f, -0.01520845f, 
    -0.04679892f, -0.01253662f, 0.03348487f, -0.01093606f, 0.04693306f, -0.02794996f, -0.05301058f, 0.00590546f, 
    0.01025847f, 0.00226282f, -0.04175019f, 0.00578664f, -0.01043410f, -0.05718469f, 0.01467810f, -0.00202796f, 
    -0.04980358f, 0.02714922f, -0.00443434f, -0.00908854f, 0.04169573f, -0.05503174f, 0.00049457f, 0.03145671f, 
    -0.05281123f, 0.01347603f, -0.04986819f, -0.05188626f, -0.03339474f, 0.02302480f, 0.01767646f, 0.00282969f, 
    0.00960398f, -0.03681533f, -0.02148970f, 0.01479590f, -0.04889584f, -0.00601773f, 0.01524300f, 0.00125940f, 
    -0.01517381f, 0.04413131f, 0.04388584f, -0.05512588f, 0.04205529f, -0.00827619f, 0.02897619f, 0.00202656f, 
    0.01650249f, -0.01713408f, -0.01992047f, -0.03708340f, 0.00189626f, -0.04691987f, 0.03034956f, -0.02130893f, 
    0.00325264f, 0.01623961f, -0.04053630f, 0.01405802f, 0.03310555f, 0.00710999f, -0.01506565f, -0.05478562f, 
    0.04844129f, -0.04288362f, -0.01389566f, 0.04138924f, 0.04876507f, -0.01986760f, 0.03453578f, -0.05024387f, 
    -0.02435547f, 0.02469515f, -0.03518831f, 0.01626641f, -0.00077933f, 0.02476688f, 0.03551898f, -0.03870612f, 
    0.02209483f, -0.03415779f, -0.04712548f, 0.00213250f, 0.03035320f, 0.00903257f, -0.00015796f, 0.00654496f, 
    -0.01091666f, 0.08545638f, 0.02732118f, -0.16433620f, -0.05539341f, -0.06850871f, -0.05005196f, 0.00244953f, 
    0.10564353f, 0.07421821f, 0.00653286f, -0.01970004f, -0.14975449f, 0.01577939f, -0.40339893f, 0.23438297f, 
    0.08465998f, 0.00035072f, 0.12986469f, -0.04246474f, -0.01756685f, 0.00076471f, 0.03727568f, 0.02200090f, 
    -0.15543926f, -0.41109520f, -0.15048473f, 0.37156412f, 0.06051844f, 0.14384621f, 0.12467828f, 0.13311501f, 
    0.02977630f, -0.07979716f, 0.20755683f, -0.12669815f, -0.27753258f, -0.12267391f, 0.02629360f, -0.24733786f, 
    -0.00989002f, 0.08402856f, 0.06072315f, 0.16825807f, -0.02017202f, 0.08857022f, 0.15850985f, 0.02287004f, 
    -0.57145447f, -0.13962978f, -0.15261933f, -0.03452441f, -0.08044317f, -0.16448773f, 0.03902996f, -0.12364587f, 
    0.17421046f, -0.06895701f, -0.10757660f, 0.02547676f, 0.12454417f, 0.18318734f, 0.13479348f, -0.24708642f, 
    -0.01072736f, -0.10992047f, -0.08605471f, 0.05103957f, 0.16954035f, 0.01784500f, 0.00687899f, 0.07605599f, 
    0.14150505f, 0.05776460f, 0.32179388f, -0.18651989f, 0.11472939f, -0.07806689f, 0.06912272f, 0.02727830f, 
    -0.04355900f, -0.01695776f, 0.13806531f, 0.01484978f, -0.10049374f, -0.21091382f, 0.22420250f, 0.03226982f, 
    -0.01901312f, -0.02337651f, -0.02108232f, 0.09555097f, 0.02453742f, 0.08618884f, -0.09550786f, -0.02104792f, 
    0.14669199f, 0.17563432f, -0.03932739f, -0.01311458f, 0.07964658f, -0.05410685f, 0.16272736f, 0.18592098f, 
    0.21185903f, 0.13192622f, -0.23586769f, -0.03444074f, -0.02818755f, -0.21591528f, 0.09170803f, -0.00899811f, 
    0.11576793f, 0.06341092f, 0.30434984f, 0.06956167f, -0.00812956f, 0.10293846f, 0.03990493f, 0.02297848f, 
    -0.27710631f, -0.02605643f, -0.20897466f, 0.04100193f, 0.08636736f, 0.01957580f, 0.04545459f, -0.06378659f, 
    -0.02406996f, -0.07272443f, -0.03218472f, 0.02029437f, -0.08152940f, -0.17855380f, -0.02828372f, -0.12777643f, 
    -0.17110506f, 0.00812571f, -0.05666978f, 0.14359014f, -0.00445204f, 0.11499663f, 0.13513106f, -0.03082177f, 
    -0.07862365f, -0.04684980f, -0.00215638f, -0.11337830f, 0.02741702f, 0.01324335f, 0.06287013f, 0.09125975f, 
    0.08714015f, -0.00077121f, 0.10080479f, 0.09253678f, -0.18714602f, -0.06375901f, -0.17323896f, -0.01451691f, 
    0.11405195f, 0.20240645f, 0.20273168f, 0.16816594f, 0.09264401f, -0.05438897f, 0.04446156f, 0.02132275f, 
    -0.08952317f, -0.07567044f, -0.10952709f, -0.07868800f, 0.09208814f, 0.09053617f, -0.02122176f, 0.11462594f, 
    0.01039044f, 0.20819928f, 0.02243959f, -0.17251767f, -0.14099662f, -0.16884549f, 0.16956714f, -0.10614445f, 
    0.18777013f, 0.16237539f, 0.08882567f, 0.14750525f, 0.01442045f, 0.04170649f, 0.04421084f, 0.08913568f, 
    0.13193010f, 0.23377366f, 0.17304344f, -0.10743687f, -0.07737830f, -0.12268744f, 0.01093822f, -0.10814437f, 
    0.00076822f, -0.07026785f, 0.17371713f, -0.10621344f, -0.01769190f, -0.04389650f, 0.01058541f, 0.05555787f, 
    0.12442410f, -0.05382907f, 0.18979880f, 0.07724173f, -0.04463961f, 0.17840813f, 0.07173129f, 0.07880276f, 
    0.01923436f, -0.04978577f, -0.08813981f, -0.04426114f, -0.10014076f, 0.01198747f, 0.07187704f, -0.01366183f, 
    -0.06979499f, 0.08218434f, -0.03128779f, -0.09727834f, -0.01977228f, -0.16788973f, 0.21087883f, -0.18534674f, 
    -0.03013058f, 0.10670572f, -0.00250710f, 0.00996531f, 0.00004213f, -0.03079763f, 0.01440158f, -0.13537443f, 
    -0.04122746f, 0.09389132f, 0.12044176f, 0.08382016f, -0.01885609f, -0.06464078f, 0.11127383f, 0.00360768f, 
    0.20886475f, 0.07410540f, 0.11322170f, 0.07545093f, 0.16701521f, 0.06563524f, -0.07148922f, -0.01531211f, 
    0.17577440f, 0.09323538f, 0.19227080f, -0.00429085f, 0.05081313f, -0.03601747f, 0.08923049f, 0.00037246f, 
    -0.09793992f, -0.05369228f, -0.07352555f, -0.11472666f, 0.04112126f, 0.13266285f, 0.15470785f, 0.16022873f, 
    0.08305077f, -0.00904017f, -0.07299538f, 0.03187982f, -0.06649875f, 0.04516185f, 0.06270149f, 0.06623765f, 
    -0.06507573f, 0.02100240f, -0.00702134f, 0.10616612f, 0.08868756f, 0.01143084f, 0.05652411f, -0.00440731f, 
    -0.07896648f, -0.01239029f, 0.22712740f, -0.13341416f, -0.03031848f, 0.12417778f, -0.03952825f, 0.07330120f, 
    0.02026364f, 0.15548161f, -0.04696805f, 0.03880459f, -0.04048330f, -0.10755189f, 0.05497487f, -0.15586576f, 
    -0.12952864f, 0.10772913f, -0.04398842f, 0.07046106f, 0.04275831f, 0.04650743f, 0.07129723f, 0.04797296f, 
    -0.08438980f, -0.18580334f, 0.20317510f, 0.03098793f, -0.02222740f, -0.01628152f, -0.14773893f, 0.15758996f, 
    0.28231725f, 0.09056561f, 0.01815484f, 0.12039521f, 0.03253054f, 0.19913231f, 0.27796000f, -0.25877401f, 
    0.01135468f, -0.10358675f, 0.25814533f, -0.10174131f, 0.10272379f, 0.12956207f, -0.10384755f, 0.03112356f, 
    -0.30632395f, 0.29575312f, 0.05447859f, 0.36859608f, 0.05410966f, -0.06946518f, -0.01365894f, 0.01978505f, 
    0.03619318f, -0.06422555f, 0.21876827f, 0.26199928f, -0.01268390f, 0.14966577f, 0.05797657f, 0.07774016f, 
    0.03078491f, -0.05422799f, -0.12493221f, 0.01961867f, -0.14982148f, 0.17871426f, 0.03057051f, 0.12811996f, 
    -0.01423361f, -0.00318087f, -0.07003804f, -0.11584213f, 0.07672705f, -0.02956907f, 0.08666575f, -0.02040166f, 
    0.10647674f, 0.01712582f, 0.22503358f, -0.01920122f, -0.04892447f, -0.02289023f, -0.11696491f, 0.07080674f, 
    0.11621401f, -0.00099622f, -0.09724652f, 0.01220365f, 0.04183467f, -0.08165494f, 0.03954001f, -0.00530321f, 
    -0.02017735f, -0.02329241f, 0.01130236f, -0.01187223f, -0.04258173f, 0.03583026f, 0.01316121f, -0.05411398f, 
    -0.04067584f, 0.03507337f, 0.04025064f, -0.02260914f, -0.05250654f, 0.00407827f, 0.02966904f, -0.03607072f, 
    -0.03821525f, 0.03644687f, -0.02012313f, 0.01970027f, 0.01113981f, -0.04606422f, -0.01663929f, 0.01105953f, 
    0.04172067f, -0.00091841f, -0.04381424f, -0.00450700f, -0.05053171f, -0.02412149f, 0.00940462f, -0.01474365f, 
    -0.02593944f, 0.02093278f, 0.03330491f, -0.05271157f, -0.04851063f, -0.03195941f, 0.03921923f, -0.04321152f, 
    -0.02955684f, 0.01831776f, -0.00971428f, 0.01840243f, -0.05582301f, 0.02635180f, -0.02607322f, 0.04216143f, 
    0.00079878f, -0.01069667f, 0.01928185f, -0.05702223f, -0.03528225f, 0.00934066f, -0.04182608f, 0.02963405f, 
    -0.03219274f, -0.01499095f, -0.05119903f, -0.03469098f, -0.03600907f, -0.05232938f, 0.01892442f, 0.02068306f, 
    0.03376731f, 0.02316073f, 0.01820361f, 0.02411447f, -0.02077531f, -0.05242841f, 0.04105282f, -0.01236884f, 
    -0.04818008f, -0.01577875f, -0.04031825f, -0.05816363f, -0.01430642f, -0.03607971f, -0.03497323f, -0.04424509f, 
    -0.05383264f, -0.02124105f, 0.00449618f, -0.04156686f, 0.01192251f, -0.03640469f, 0.03788030f, -0.00724834f, 
    -0.03464109f, 0.03637288f, -0.04961127f, -0.03893388f, 0.00461985f, 0.03204370f, 0.01368659f, -0.01101953f, 
    -0.04315918f, -0.05484165f, 0.01306147f, -0.02068738f, -0.00335722f, -0.00704983f, 0.00720778f, -0.03878820f, 
    -0.00508200f, 0.03281550f, 0.01120566f, -0.02966314f, -0.02200358f, 0.00576625f, -0.03402011f, 0.00598619f, 
    -0.01901624f, -0.04605958f, -0.03926612f, 0.03405833f, -0.05527330f, 0.00755347f, -0.00025562f, -0.03204218f, 
    -0.01851695f, -0.00003553f, -0.00130066f, 0.00698561f, 0.02662982f, -0.01338281f, -0.05011024f, -0.02119900f, 
    0.04129180f, 0.04296442f, 0.02177116f, 0.03504144f, 0.05276235f, 0.01972835f, 0.03295299f, 0.00428705f, 
    -0.05683793f, -0.02396188f, -0.02965872f, -0.02826578f, -0.00255740f, -0.05375974f, 0.01616371f, 0.03415677f, 
    -0.02757824f, -0.03981540f, 0.02109971f, -0.04958060f, -0.01962741f, -0.04279402f, -0.04048967f, 0.03146359f, 
    0.02431819f, -0.00587903f, 0.00409321f, -0.02999468f, -0.03646142f, -0.00846632f, 0.03571679f, -0.05144932f, 
    -0.02895140f, 0.03280079f, 0.03328596f, -0.01434883f, -0.00859489f, -0.00175430f, 0.00413382f, -0.04650758f, 
    0.00459409f, 0.02799195f, -0.05015855f, -0.04319535f, -0.02919361f, -0.02702511f, -0.02757853f, 0.04266612f, 
    -0.00241121f, -0.04076349f, 0.01881624f, -0.05408622f, -0.04048006f, 0.03564337f, 0.00852975f, -0.05923335f, 
    -0.04765526f, -0.03845348f, 0.02423269f, 0.03347432f, -0.01911983f, -0.02041278f, 0.03438755f, -0.04016994f, 
    0.01731974f, -0.04394496f, 0.03060220f, 0.04133110f, -0.04062226f, -0.02686133f, 0.02274989f, 0.00523889f, 
    0.02145338f, 0.02896172f, -0.03673275f, 0.00792432f, -0.00413692f, 0.04343670f, -0.05628319f, 0.01273246f, 
    -0.01638213f, -0.01004047f, 0.03254200f, -0.05006367f, -0.02832493f, -0.05331769f, -0.00249324f, 0.00774383f, 
    0.03853101f, 0.00178554f, 0.00574166f, -0.01885566f, 0.02431644f, 0.01667867f, 0.01512250f, -0.00566495f, 
    0.02828901f, 0.01721061f, -0.02210508f, -0.00729328f, -0.02859031f, -0.03144715f, -0.01371070f, -0.02553616f, 
    -0.05534398f, 0.00121634f, 0.02593237f, 0.00319053f, 0.03586401f, 0.01664445f, 0.02640126f, 0.00921631f, 
    -0.02582624f, -0.04032587f, 0.02115803f, 0.01475926f, -0.00458556f, -0.05169130f, -0.04957607f, 0.01646385f, 
    0.01109720f, 0.00513835f, -0.01521091f, -0.05580242f, -0.01621544f, -0.00475735f, 0.01612813f, 0.01492665f, 
    0.02644813f, -0.04533464f, -0.02971668f, -0.04516340f, -0.02142087f, -0.01617921f, -0.02452106f, -0.03233640f, 
    -0.03728074f, 0.02953684f, -0.02679491f, 0.03635381f, -0.00276027f, 0.01871827f, 0.01607969f, 0.00976139f, 
    0.03289011f, -0.01188831f, 0.02313599f, -0.00074448f, 0.00239177f, 0.00582372f, -0.03431574f, -0.02003757f, 
    -0.02471682f, -0.02250567f, 0.03951979f, -0.02791455f, 0.04037390f, 0.02794944f, -0.03600112f, 0.00094298f, 
    -0.01360520f, -0.01231953f, -0.00312107f, -0.01821038f, 0.01136334f, -0.05066120f, -0.00805156f, 0.04103727f, 
    -0.04203302f, 0.02147077f, 0.03573684f, 0.02994339f, 0.01343456f, 0.01014399f, 0.00760849f, 0.02421465f, 
    -0.05108347f, 0.01070259f, -0.04393787f, -0.05029770f, -0.00903359f, 0.01724107f, 0.02659743f, 0.03356883f, 
    0.01438096f, 0.00599325f, 0.03880420f, 0.03731634f, -0.03736649f, -0.02589327f, 0.00736596f, -0.01383609f, 
    -0.05386369f, 0.03145780f, -0.01625051f, 0.03317201f, -0.01038752f, -0.02348151f, -0.03522776f, 0.03129406f, 
    0.02232481f, 0.01614450f, -0.03674589f, -0.03603762f, -0.01785710f, -0.04382466f, -0.05165908f, 0.01374263f, 
    -0.02410221f, -0.01946794f, 0.00579018f, 0.03113198f, -0.01334317f, -0.01786008f, 0.00239346f, 0.02260984f, 
    -0.03142716f, -0.03783832f, 0.00648279f, 0.02621961f, -0.03735081f, 0.03958410f, -0.02618171f, -0.01449237f, 
    0.00572530f, -0.02757657f, 0.00679024f, -0.00914465f, -0.01592616f, -0.02237726f, 0.00896773f, -0.02681002f, 
    0.00400139f, -0.02585271f, 0.04028757f, -0.03033950f, -0.02736965f, -0.03340141f, -0.01898979f, 0.02340494f, 
    -0.00906436f, -0.04444836f, 0.02592099f, -0.05848983f, -0.00553651f, -0.04797227f, -0.01340387f, -0.01897522f, 
    0.02090544f, -0.04533830f, 0.02486631f, -0.00819185f, -0.04207861f, 0.04297007f, 0.01934168f, -0.01490666f, 
    -0.02013171f, -0.00729505f, 0.04134895f, 0.00784420f, 0.04932208f, -0.00924007f, 0.03584843f, -0.00009146f, 
    0.00397959f, -0.02122457f, -0.05182041f, -0.05775900f, -0.05265470f, -0.02810292f, -0.01232253f, 0.00801890f, 
    0.01620498f, -0.02222604f, -0.02260517f, 0.00640243f, 0.01610694f, 0.01217494f, -0.02596929f, 0.04392795f, 
    0.03758969f, -0.02670720f, 0.01481110f, -0.02329212f, 0.00648485f, -0.02508244f, -0.03877079f, 0.00057775f, 
    0.01938954f, -0.03141331f, 0.01200758f, 0.01465064f, -0.03212412f, -0.00640602f, -0.02024231f, 0.02097934f, 
    -0.04761735f, -0.02184999f, -0.05003647f, -0.03424380f, 0.00569998f, -0.04923513f, 0.00868299f, -0.04101421f, 
    0.01698727f, -0.01938957f, -0.04224438f, -0.03120539f, -0.04151116f, -0.00113754f, 0.00397047f, 0.04500550f, 
    -0.00622541f, 0.01553323f, 0.02298583f, 0.01228262f, -0.04748359f, 0.01479954f, 0.01682973f, -0.04712226f, 
    -0.02278121f, -0.05991480f, -0.00890856f, -0.00715601f, 0.00202862f, -0.00534131f, -0.03809357f, 0.01761857f, 
    -0.00711330f, 0.04179443f, -0.02338970f, 0.00076507f, -0.04814580f, 0.00805856f, 0.03409166f, -0.03989223f, 
    -0.02132842f, 0.01207474f, -0.01230166f, -0.02085808f, -0.04380321f, -0.04719719f, 0.01017949f, -0.04178641f, 
    0.01507566f, -0.01143555f, 0.03191192f, 0.03147402f, -0.03623918f, 0.02099046f, -0.00765449f, 0.03909122f, 
    -0.03660309f, -0.03415363f, 0.02571107f, 0.02949927f, -0.03487669f, -0.01020985f, 0.04167020f, -0.02900106f, 
    0.03874040f, -0.02255847f, 0.03045512f, -0.04512026f, 0.03016095f, -0.03125347f, 0.01133995f, -0.01771987f, 
    0.00915344f, 0.01919601f, -0.02473930f, 0.03366609f, -0.02352199f, -0.00807128f, -0.02495395f, -0.05617036f, 
    0.00575508f, -0.04232981f, -0.00317387f, -0.05384171f, -0.03775329f, -0.04634254f, 0.02609185f, 0.03514835f, 
    -0.01215961f, 0.01326405f, 0.03533212f, 0.03774862f, -0.01020399f, 0.01950201f, 0.00368648f, 0.01978276f, 
    0.04293199f, 0.02829552f, -0.02074947f, -0.01660549f, -0.00120524f, 0.01508914f, -0.00973534f, -0.01059496f, 
    -0.04615967f, -0.05675323f, 0.03979024f, -0.02063872f, 0.04545959f, -0.03945214f, 0.05050966f, 0.03979854f, 
    0.01213105f, -0.02734415f, 0.01686670f, 0.01808660f, -0.01149973f, -0.02939420f, 0.01858018f, 0.02342880f, 
    -0.04692006f, -0.00351744f, 0.04496216f, -0.01048284f, -0.01570993f, -0.01932257f, -0.01180652f, -0.05029552f, 
    -0.00866831f, -0.03951829f, 0.02619464f, 0.02942917f, -0.01469173f, 0.02104325f, -0.00144330f, -0.00660890f, 
    -0.03864424f, 0.03331077f, 0.01231066f, 0.02413802f, 0.00964654f, 0.02063568f, 0.02708491f, 0.00875655f, 
    -0.04976162f, 0.03496734f, 0.03584268f, 0.05059685f, -0.04981838f, 0.03371939f, -0.01503335f, -0.02807650f, 
    0.04094571f, 0.02937126f, 0.00549905f, 0.01201884f, 0.04139879f, -0.04290922f, -0.04548962f, -0.01433801f, 
    -0.00285879f, -0.04685412f, -0.03577307f, -0.00710016f, 0.01789141f, -0.00140520f, -0.04305331f, 0.03237362f, 
    0.04737195f, -0.01016619f, -0.03687032f, -0.03521130f, 0.01156817f, -0.03106747f, -0.05489808f, -0.02083812f, 
    -0.05932235f, -0.01289118f, -0.02533055f, 0.02845647f, -0.00950230f, -0.03211752f, 0.00845117f, 0.00753458f, 
    0.03655314f, -0.05492836f, -0.00006066f, -0.05793164f, 0.02985722f, -0.00313132f, 0.00256836f, -0.05240397f, 
    0.00950269f, 0.03744251f, -0.02190669f, -0.01997427f, -0.05369649f, 0.01938694f, 0.02312154f, -0.00126143f, 
    -0.02415537f, 0.02122294f, -0.01436538f, -0.04011442f, 0.03278329f, 0.01865320f, 0.00749836f, 0.02058003f, 
    0.03593295f, -0.01884069f, 0.03412193f, -0.00765499f, 0.00046211f, 0.03465136f, -0.05171213f, -0.02558480f, 
    0.01733583f, -0.03183161f, -0.02113341f, -0.00390431f, -0.00755693f, 0.00135225f, 0.01055261f, 0.00102829f, 
    -0.03178903f, -0.03963905f, -0.04187386f, 0.00082560f, -0.03911460f, -0.05247707f, -0.00307236f, 0.02413141f, 
    -0.02986822f, 0.01335279f, 0.03621839f, -0.02080993f, -0.04027670f, -0.05292979f, 0.02459342f, -0.01266795f, 
    -0.04457230f, -0.02504368f, -0.05449425f, -0.00099357f, -0.00199638f, -0.02995124f, 0.01806949f, -0.00020823f, 
    -0.03739189f, -0.04963164f, 0.01650240f, -0.02922786f, -0.04700933f, 0.03425518f, -0.04629593f, -0.00366974f, 
    -0.02398114f, -0.00878890f, -0.00422502f, -0.04500889f, -0.01680428f, 0.02646995f, -0.03460762f, 0.02238142f, 
    -0.04317168f, -0.00675915f, -0.00394060f, 0.04255693f, -0.01133434f, 0.01540148f, -0.01843218f, -0.03440427f, 
    0.01881537f, 0.00603795f, 0.02488473f, 0.00595621f, 0.00457983f, -0.05720307f, -0.04058355f, 0.00304887f, 
    -0.02609731f, 0.02610153f, -0.01185511f, 0.04021936f, -0.05094272f, -0.00359140f, -0.04852559f, 0.01994934f, 
    0.01980978f, -0.05198167f, 0.03166334f, -0.02244583f, -0.05015140f, -0.02861897f, -0.01550146f, 0.02931473f, 
    -0.00387961f, -0.04308568f, 0.03446013f, 0.00400889f, 0.01371341f, 0.02027354f, -0.04838214f, 0.02914461f, 
    -0.03700934f, 0.04128098f, 0.02717099f, 0.03677587f, 0.02089331f, -0.03991833f, 0.02102289f, 0.02941644f, 
    0.00646358f, -0.05536221f, 0.01355487f, -0.01044776f, 0.02461794f, 0.01081609f, 0.02135937f, -0.05361664f, 
    0.01299674f, -0.00173846f, -0.03774142f, 0.02459584f, 0.04570836f, -0.01038525f, -0.01120964f, 0.03240969f, 
    -0.05589661f, -0.05361831f, 0.01025685f, -0.05820474f, 0.02884159f, -0.02588411f, -0.03698415f, -0.02461439f, 
    -0.02504061f, -0.02109755f, 0.04526102f, -0.05025576f, -0.02358894f, -0.04128660f, -0.03773981f, 0.03590117f, 
    0.31252968f, 0.11309157f, 0.03245240f, -0.19243190f, 0.22308704f, 0.04693625f, 0.13562237f, 0.10613979f, 
    -0.02365414f, -0.02255396f, -0.00807924f, -0.06675251f, -0.10446548f, 0.10636812f, 0.20624848f, 0.11776924f, 
    -0.05681798f, -0.03511153f, -0.00157744f, 0.13038005f, -0.02062545f, 0.03272643f, 0.05831169f, 0.05291662f, 
    0.03041469f, 0.13531245f, 0.46620172f, -0.00278189f, 0.14984825f, -0.08474680f, -0.00932505f, -0.00972379f, 
    0.03225024f, -0.06973875f, 0.02038779f, 0.00355655f, 0.16828442f, 0.20389169f, -0.00057044f, -0.10615098f, 
    0.11204946f, 0.11544020f, 0.18216351f, 0.07379109f, 0.07488281f, 0.03222393f, 0.16087569f, 0.13064009f, 
    -0.02396332f, -0.14656371f, -0.39545235f, -0.30682120f, -0.02049270f, 0.22623922f, 0.03488408f, -0.03626883f, 
    0.00739362f, -0.02386856f, -0.07502721f, 0.05823729f, -0.11574427f, -0.25336149f, -0.18089215f, -0.04810638f, 
    -0.08017132f, -0.01565780f, -0.14330424f, -0.01047567f, -0.17222944f, -0.17727917f, -0.08569860f, -0.14938240f, 
    0.04066287f, 0.08055621f, 0.08693312f, 0.00618400f, -0.01338970f, -0.00216883f, 0.00512025f, 0.00621345f, 
    -0.04039283f, 0.05996457f, 0.08529361f, 0.00656465f, 0.14026180f, 0.19669823f, -0.12778801f, -0.07908486f, 
    0.14750907f, 0.09306441f, 0.14268063f, -0.12280218f, 0.06438819f, -0.24833183f, -0.04281583f, -0.13056543f, 
    -0.31912002f, 0.09134583f, 0.09032209f, -0.05144536f, -0.06802244f, 0.02694931f, -0.01321438f, 0.02232621f, 
    0.04687357f, 0.01004219f, 0.02805977f, 0.04458032f, -0.01105224f, 0.20697862f, 0.00859673f, -0.16887404f, 
    0.05689290f, 0.17263019f, 0.04978424f, -0.04449096f, 0.01063264f, -0.06153063f, -0.05002117f, -0.09403604f, 
    0.17481832f, -0.08230688f, 0.11508128f, 0.10787114f, -0.00522072f, 0.03704625f, -0.13852546f, -0.04153859f, 
    -0.08366910f, -0.05965866f, -0.03744181f, -0.02560842f, 0.28725114f, 0.12988195f, -0.15754956f, -0.03627362f, 
    -0.02086193f, 0.03986124f, 0.10863099f, -0.01113055f, -0.04148795f, 0.04173325f, 0.01339772f, -0.00774197f, 
    -0.02952898f, -0.10861605f, -0.01613619f, -0.01279058f, 0.12773992f, 0.06435195f, -0.03082314f, -0.07429335f, 
    0.08135127f, -0.07445782f, -0.07813397f, -0.08353110f, -0.08257292f, 0.03531101f, 0.01354766f, -0.08821248f, 
    0.08489391f, -0.00714617f, -0.01767767f, -0.01099363f, 0.02175375f, -0.09217561f, -0.00025942f, -0.12701558f, 
    -0.18387493f, 0.03001115f, -0.09176039f, 0.15405244f, 0.06323405f, 0.06399991f, -0.02669000f, 0.00190813f, 
    0.12539229f, 0.18270145f, 0.01637854f, 0.13296555f, 0.11115444f, 0.25627372f, -0.06334981f, -0.05553566f, 
    0.04187856f, 0.02568634f, 0.11749967f, 0.14173771f, 0.05030101f, 0.07366215f, -0.01845748f, 0.06987461f, 
    0.04508789f, 0.17703138f, -0.14934400f, -0.11350412f, -0.06735493f, -0.03295301f, 0.06774976f, 0.01791417f, 
    0.05385531f, -0.01180087f, 0.05943641f, -0.03026227f, -0.04501798f, 0.14438716f, 0.13060574f, -0.13851386f, 
    0.20566274f, -0.07800628f, 0.01884336f, -0.12272049f, -0.03538002f, 0.03130944f, -0.07916125f, 0.08703788f, 
    0.07388073f, 0.29410380f, 0.07890251f, -0.04488127f, 0.01660447f, 0.04049135f, -0.00581981f, -0.10991629f, 
    -0.08270425f, -0.03503470f, -0.01825426f, 0.01180945f, -0.04671209f, 0.09266140f, -0.05475033f, 0.02325463f, 
    -0.10485178f, 0.06142937f, -0.04553488f, -0.13714428f, -0.02573928f, 0.03277884f, -0.18293646f, 0.05357553f, 
    -0.03319873f, -0.15788780f, -0.13711505f, 0.07420874f, 0.03393095f, -0.02023405f, 0.04260032f, 0.14471383f, 
    0.14153504f, 0.03200812f, 0.13873379f, 0.12448380f, 0.09598333f, 0.04974097f, 0.04631053f, 0.07154988f, 
    -0.01533217f, -0.04797979f, 0.03296212f, 0.21726118f, -0.06540248f, -0.02778594f, -0.03439243f, 0.06591070f, 
    0.20220980f, 0.07753811f, -0.03467911f, -0.07971808f, 0.14837506f, 0.07458844f, -0.08872383f, 0.05398748f, 
    -0.04038906f, 0.06046426f, -0.01203664f, -0.14425758f, 0.08296116f, -0.06946805f, 0.20063151f, -0.11029206f, 
    0.15405300f, 0.01047851f, -0.00862172f, -0.01568232f, 0.15130854f, 0.10990279f, 0.06434235f, 0.10000439f, 
    0.12209454f, 0.09757908f, -0.02402365f, -0.19149917f, 0.18619886f, 0.07417756f, 0.10992891f, -0.00670592f, 
    0.01282607f, 0.02150544f, 0.05657808f, 0.08848908f, 0.05545687f, 0.22571118f, -0.23066258f, 0.00867490f, 
    0.06793185f, 0.07298891f, -0.20418836f, 0.14172485f, 0.00763361f, -0.04270422f, 0.02158997f, -0.02428775f, 
    -0.39673826f, -0.03436534f, -0.29900187f, 0.24574058f, -0.05625311f, -0.09225935f, 0.07871924f, 0.23476969f, 
    -0.15094768f, 0.05996307f, -0.11601172f, -0.04176551f, 0.03723281f, -0.31786895f, -0.35135892f, 0.06340180f, 
    0.10996751f, 0.01658998f, -0.08312329f, 0.02831819f, -0.03295756f, -0.01581304f, 0.09292480f, 0.11529072f, 
    -0.11935420f, -0.27673978f, 0.18214498f, -0.24319699f, -0.06060689f, 0.16922560f, -0.04432102f, 0.07891148f, 
    0.06085331f, 0.00424050f, 0.10628528f, 0.00654858f, -0.00592214f, -0.02990617f, -0.10787897f, 0.14175265f, 
    0.03174962f, -0.00160007f, -0.00786850f, -0.18597327f, 0.12147362f, 0.23309967f, -0.11677631f, 0.07321212f, 
    0.20207608f, 0.06448247f, 0.05275686f, -0.02362291f, 0.02202712f, -0.01491317f, 0.06364246f, -0.00717434f, 
    -0.04527377f, -0.00043942f, 0.04834232f, 0.00157803f, -0.08373095f, 0.06537482f, -0.05781982f, -0.01183173f, 
    -0.05947176f, -0.01905843f, -0.04034760f, 0.03169510f, 0.11400999f, -0.05027490f, 0.19950098f, -0.10821485f, 
    -0.04087333f, -0.01091641f, 0.01854967f, -0.05485110f, 0.00167657f, 0.00747496f, 0.03472212f, 0.01791807f, 
    -0.01140236f, 0.02917421f, -0.01855375f, 0.01229656f, -0.01793154f, -0.00460928f, -0.02079556f, -0.03157544f, 
    -0.02299327f, -0.01558221f, -0.05375093f, 0.02890116f, -0.01412816f, -0.02504382f, -0.00029068f, 0.01672589f, 
    0.01789971f, 0.00571839f, -0.04798060f, 0.01197783f, -0.01829171f, -0.04529237f, 0.01468796f, 0.03458619f, 
    -0.03174287f, -0.00978751f, 0.00088545f, 0.00658924f, 0.01091282f, 0.01012465f, -0.05445932f, -0.01992262f, 
    -0.01890890f, 0.03989918f, 0.01337477f, -0.00579232f, 0.02002680f, -0.00984137f, -0.04639180f, -0.01046851f, 
    0.00784464f, 0.03426824f, 0.00215341f, -0.01914339f, 0.03677225f, 0.03526085f, -0.01718852f, 0.01196499f, 
    -0.01910190f, -0.05000444f, -0.04444877f, 0.01881439f, 0.02538595f, -0.01066838f, 0.01906279f, -0.03998458f, 
    0.01612575f, 0.02225388f, 0.01474798f, 0.04033978f, -0.00365896f, -0.03921748f, -0.02150987f, -0.04773842f, 
    0.03415835f, -0.00411836f, -0.03030420f, 0.04038685f, 0.02635542f, 0.04088819f, -0.03760627f, -0.05351527f, 
    -0.01534682f, -0.00629721f, -0.03884602f, 0.00718782f, -0.06049330f, 0.02077106f, 0.03004242f, 0.03228914f, 
    0.00892622f, 0.02149785f, 0.03273326f, 0.02016032f, 0.02455247f, -0.05553921f, 0.02273741f, -0.01503226f, 
    -0.01758531f, 0.04935035f, -0.02628784f, -0.02642177f, 0.04043667f, -0.00975730f, -0.02246985f, -0.04763662f, 
    -0.02421214f, -0.01635747f, -0.04095699f, -0.05883155f, -0.01116810f, 0.03093715f, -0.05244348f, 0.02684904f, 
    -0.04411171f, 0.03806851f, 0.01178826f, -0.01464892f, -0.05184898f, -0.01456680f, -0.00053278f, 0.00072935f, 
    -0.02092357f, -0.02730933f, 0.00542752f, 0.03496154f, -0.02567301f, 0.04570949f, -0.05547994f, -0.03277907f, 
    0.04392266f, 0.04075883f, -0.01443226f, 0.04315857f, 0.02096713f, -0.02166604f, -0.05607158f, -0.02965060f, 
    0.01768934f, -0.01389631f, -0.03146914f, 0.03049733f, 0.00904178f, -0.01470751f, 0.01609953f, -0.05429343f, 
    0.00835058f, -0.03269351f, -0.04080421f, -0.03281077f, 0.01442398f, -0.01473042f, -0.01456512f, 0.02117306f, 
    -0.03958430f, -0.01496156f, 0.04175675f, -0.03927846f, 0.03988480f, -0.05586843f, -0.00315319f, -0.05231719f, 
    0.00410648f, 0.02432266f, -0.03069343f, 0.02566795f, 0.00811999f, -0.04449027f, -0.03732973f, -0.02203392f, 
    -0.00104811f, -0.05920050f, 0.00155520f, 0.01366649f, 0.04277443f, -0.00965881f, -0.01139041f, -0.04149947f, 
    0.01986769f, -0.02177391f, 0.01900025f, -0.00070147f, 0.00435608f, -0.00398095f, 0.01938836f, 0.01370253f, 
    0.01479821f, -0.02041715f, -0.01435976f, 0.03377612f, 0.03473065f, -0.01622426f, 0.03345866f, -0.05056129f, 
    -0.01924829f, -0.01850469f, 0.03404837f, 0.04462369f, -0.02510088f, -0.01395086f, 0.04489271f, -0.02095639f, 
    0.01522195f, 0.01920700f, -0.04313188f, 0.02753196f, -0.00888530f, -0.01637851f, 0.03881783f, -0.05157423f, 
    0.00754585f, -0.04018485f, -0.04481512f, -0.03120351f, -0.02388165f, -0.03785695f, -0.01456428f, -0.02145341f, 
    0.00039980f, 0.00707341f, 0.03409760f, -0.02379634f, 0.03133783f, 0.02420492f, 0.01324268f, -0.04753419f, 
    0.01689997f, 0.03141833f, 0.03987918f, 0.01063691f, -0.00064228f, 0.04625271f, -0.04374561f, 0.02598868f, 
    -0.02649307f, -0.05107140f, 0.02344619f, 0.00734118f, 0.01661696f, -0.02431642f, 0.01941298f, 0.00850191f, 
    0.02658802f, -0.04770872f, 0.01672174f, -0.04631826f, 0.04150456f, 0.02124066f, 0.02803194f, -0.03381732f, 
    -0.01605517f, 0.03728629f, -0.02705646f, -0.02583474f, -0.05396479f, 0.04413293f, -0.03380244f, -0.04824819f, 
    -0.02252736f, -0.02753491f, -0.03965126f, -0.04298792f, 0.04308589f, 0.03424762f, 0.01377830f, -0.02205221f, 
    0.00216678f, -0.05414027f, -0.00136912f, 0.03168055f, -0.00964754f, 0.00682645f, 0.02124557f, -0.04775424f, 
    -0.05187441f, 0.04271218f, 0.01386307f, 0.01010124f, -0.00078413f, -0.01309320f, -0.05258550f, 0.00130300f, 
    -0.03176270f, -0.04628884f, -0.00456617f, -0.03632081f, -0.02459470f, -0.03872254f, -0.01201700f, -0.00093482f, 
    0.00373444f, -0.05742657f, 0.01156162f, -0.01011230f, -0.03126074f, 0.01093742f, -0.01486919f, 0.00283449f, 
    -0.00463589f, -0.05774883f, -0.04114341f, -0.01063219f, 0.00544061f, 0.02781442f, -0.00370727f, -0.01214914f, 
    0.02634738f, -0.05512629f, -0.01794008f, -0.03180112f, -0.01606611f, -0.00064559f, 0.01914340f, -0.04780512f, 
    0.00397447f, -0.04853346f, -0.04348204f, -0.03108665f, -0.02044192f, -0.05027485f, 0.03469133f, -0.04566120f, 
    -0.04913771f, -0.02759379f, 0.00395147f, 0.00976361f, 0.03336151f, 0.01440397f, -0.00453192f, 0.01167958f, 
    -0.00420705f, -0.03093405f, -0.04796285f, -0.04269205f, -0.00886206f, -0.02196319f, 0.02482942f, 0.01490285f, 
    -0.00836858f, -0.00011600f, 0.00407247f, 0.02335017f, -0.05290363f, -0.00081025f, 0.03795146f, -0.04018442f, 
    0.00897592f, 0.03668292f, -0.05967233f, -0.02650241f, -0.01470461f, 0.00040235f, -0.04446784f, 0.00283023f, 
    0.00337591f, -0.01307706f, -0.04454458f, -0.02605535f, -0.04906453f, 0.04395258f, -0.01778810f, -0.02854432f, 
    0.01105744f, 0.00498723f, 0.03117726f, -0.04215136f, -0.01307993f, -0.00261630f, -0.05012342f, 0.03486127f, 
    0.03567357f, 0.02866923f, 0.00838876f, -0.02231441f, -0.00824019f, -0.03346475f, -0.00970109f, 0.04312684f, 
    0.03651951f, 0.02594342f, 0.04471301f, 0.01310521f, -0.05068538f, 0.02617761f, -0.03611281f, -0.04359630f, 
    0.02125098f, -0.03027601f, -0.00649435f, -0.04999652f, 0.05580604f, 0.14412892f, 0.07192405f, 0.04320905f, 
    0.02941432f, -0.03006998f, -0.06441905f, -0.01832802f, -0.14279374f, 0.15004726f, 0.13891532f, 0.04215427f, 
    0.01523387f, -0.00249753f, -0.07200915f, 0.13290808f, 0.12453556f, -0.00861125f, -0.05247041f, 0.08600155f, 
    0.18527715f, -0.22038524f, 0.12704393f, 0.02528365f, -0.05963218f, -0.04734566f, -0.05107310f, 0.02281131f, 
    0.12616724f, 0.01122542f, 0.08850989f, -0.04158479f, -0.10713689f, 0.14142054f, 0.03327003f, 0.00724463f, 
    -0.01522431f, 0.03172427f, 0.00187785f, 0.17126910f, -0.08674546f, -0.08413132f, -0.00026056f, 0.15639274f, 
    -0.06365262f, -0.18884343f, 0.04096508f, 0.12341360f, -0.04125404f, -0.04813548f, -0.08874355f, 0.08812040f, 
    0.07589553f, -0.07487892f, 0.02582542f, 0.09933376f, 0.02540708f, 0.11287622f, 0.12926307f, -0.08411193f, 
    -0.01732901f, 0.09057363f, -0.03772013f, 0.06013294f, 0.16534884f, -0.08792935f, -0.07502256f, -0.00578022f, 
    0.10151213f, -0.21456003f, 0.12520891f, -0.08124518f, 0.06258373f, 0.10468248f, -0.01489674f, -0.06841870f, 
    0.13276654f, -0.04414919f, -0.01017480f, 0.03011304f, 0.36277291f, -0.06092500f, -0.08032016f, -0.04033646f, 
    0.10754275f, 0.00035330f, 0.08094053f, -0.02009816f, 0.00967606f, 0.03096415f, -0.24092731f, -0.05226903f, 
    -0.03670925f, -0.25081062f, -0.11662683f, 0.04676817f, -0.00739119f, 0.18650088f, -0.09296003f, 0.07851530f, 
    0.11294560f, 0.04311841f, 0.11494423f, -0.00054610f, 0.19175561f, -0.02220679f, 0.41530687f, -0.25718704f, 
    0.04436371f, 0.01591617f, 0.14175989f, 0.09372184f, 0.03959721f, 0.06124406f, -0.10997067f, -0.03948069f, 
    -0.15804984f, 0.09134939f, 0.15436408f, -0.14815617f, -0.02552206f, -0.19223399f, -0.09866436f, 0.03526970f, 
    -0.02725146f, -0.07508009f, -0.08771277f, 0.10847993f, 0.20902425f, -0.04638929f, 0.51572955f, -0.41374081f, 
    0.01041674f, -0.18147175f, 0.05783494f, -0.05107650f, 0.12445164f, -0.05605514f, -0.05373388f, 0.03780957f, 
    -0.34005398f, 0.22179960f, -0.25843170f, 0.08257712f, -0.03148541f, 0.09132247f, 0.02681540f, -0.03683932f, 
    -0.03183435f, -0.04642866f, -0.14196000f, -0.03851276f, 0.02083632f, 0.06232256f, -0.04155373f, -0.14410029f, 
    0.15151079f, -0.02670428f, 0.12580803f, 0.12333123f, -0.06994031f, -0.01046395f, -0.09509594f, -0.03960706f, 
    0.03937642f, 0.09391757f, 0.03728050f, -0.06069132f, 0.10120590f, -0.05857393f, 0.08864652f, 0.06755086f, 
    0.08087924f, -0.00150054f, 0.08561633f, 0.03787552f, 0.06187860f, 0.21300805f, -0.03545550f, -0.12903693f, 
    0.05322147f, -0.12482247f, -0.03772094f, 0.14375488f, -0.08570333f, 0.02981586f, 0.01166617f, -0.07824416f, 
    -0.03765333f, 0.02756685f, -0.13012874f, 0.11430605f, 0.09226793f, 0.05694397f, 0.00846349f, -0.04072697f, 
    0.19982989f, -0.01432936f, 0.12820244f, -0.02961829f, -0.14105318f, -0.01806209f, -0.38886377f, 0.15990536f, 
    0.04815729f, 0.05874392f, 0.03690685f, 0.07947459f, 0.07358073f, 0.05179263f, 0.17923622f, 0.11513874f, 
    -0.42584029f, -0.24174757f, -0.12890881f, -0.05429558f, 0.03888985f, -0.08682074f, -0.05133793f, 0.00194926f, 
    0.05972887f, 0.01833708f, 0.07835066f, -0.11973093f, -0.07636213f, -0.00360952f, -0.00244010f, 0.01813893f, 
    0.01640410f, -0.11855848f, 0.01978277f, 0.02839293f, -0.08477494f, 0.03062343f, -0.13814092f, -0.18301439f, 
    0.05283421f, 0.01399072f, 0.08383226f, -0.01942634f, -0.06185473f, -0.08542112f, 0.18668830f, 0.04092581f, 
    0.02121778f, -0.01322945f, 0.07589895f, 0.03035723f, -0.34970900f, 0.00062823f, -0.09331757f, -0.11988115f, 
    0.11219621f, -0.05314632f, 0.04910348f, -0.04767711f, 0.20060137f, 0.03626071f, 0.03244960f, -0.01368339f, 
    -0.37529916f, 0.26065034f, 0.10257901f, -0.11391311f, 0.04188475f, -0.06273761f, 0.07498849f, 0.03498948f, 
    0.07280482f, -0.05883391f, 0.11290979f, -0.08451131f, 0.23450890f, -0.04970271f, -0.10259855f, 0.20846722f, 
    -0.02178208f, 0.14681587f, 0.09779277f, 0.04664620f, 0.14029801f, -0.01806747f, 0.04345570f, 0.15880746f, 
    0.03042942f, -0.17119281f, 0.30333856f, -0.08821984f, -0.15246107f, -0.03231440f, -0.04101538f, 0.10161406f, 
    0.07030160f, -0.06117865f, 0.00383779f, 0.03932648f, 0.00874504f, 0.13478628f, 0.08430640f, -0.01443063f, 
    0.16988458f, 0.03114242f, 0.11324551f, -0.11742347f, -0.04668169f, 0.03868944f, -0.03881204f, -0.04481952f, 
    0.16164690f, 0.08950877f, 0.04000440f, -0.00645099f, -0.21079756f, 0.04661850f, 0.05386779f, -0.14768349f, 
    0.14140734f, 0.16109799f, 0.05823354f, 0.05944441f, -0.16660510f, 0.21599111f, -0.27825832f, -0.12006652f, 
    -0.08108468f, -0.03819577f, 0.03710898f, -0.03527834f, 0.15702116f, 0.05448695f, -0.03169162f, 0.01110895f, 
    0.15639929f, 0.19353203f, -0.24507912f, 0.03326939f, -0.09096757f, 0.19247179f, -0.09126659f, 0.01398598f, 
    -0.00287068f, -0.02508872f, -0.04068416f, 0.11811616f, 0.08459326f, -0.29205510f, 0.19419223f, -0.03873075f, 
    -0.11756790f, 0.14159158f, -0.17648309f, -0.02152263f, 0.06470449f, -0.09360690f, 0.10640974f, -0.09371137f, 
    0.05935791f, 0.08740345f, 0.14719748f, -0.06098821f, 0.04872385f, 0.07207642f, 0.07755103f, -0.01663507f, 
    0.02580862f, -0.07455981f, 0.04905814f, 0.05715284f, -0.02920548f, -0.11111563f, 0.07004027f, -0.06529447f, 
    -0.05491216f, -0.04935475f, -0.01169636f, -0.00950105f, -0.14194614f, -0.11967005f, 0.02450709f, 0.16925049f, 
    -0.11171946f, -0.14017297f, -0.03969828f, 0.15550418f, -0.03238834f, -0.12925944f, -0.11229023f, 0.09188077f, 
    -0.04479719f, -0.01576423f, -0.03785224f, -0.05309293f, 0.38989702f, -0.10093946f, 0.28079122f, -0.18561785f, 
    -0.04596797f, 0.03675781f, 0.01382239f, -0.01814339f, -0.01382175f, 0.01194055f, 0.02766651f, 0.02337956f, 
    0.21847427f, 0.29644114f, -0.14653699f, -0.05935178f, -0.10411349f, 0.01053318f, 0.07073525f, -0.09983864f, 
    -0.13167381f, 0.01795779f, -0.01285396f, 0.03373941f, 0.17583376f, -0.08633753f, -0.07306200f, 0.23918705f, 
    0.02852232f, 0.00271270f, -0.03267473f, -0.07519221f, 0.07414912f, -0.02440130f, -0.01283537f, 0.01311725f, 
    0.47270378f, 0.08347707f, 0.23088621f, 0.23170753f, 0.11860707f, -0.01715759f, 0.03768340f, 0.00119466f, 
    -0.09414191f, 0.02769018f, 0.04219502f, 0.04943473f, -0.20280066f, 0.09271057f, -0.09492568f, 0.42285210f, 
    -0.06135958f, -0.07085027f, 0.16233025f, 0.11864410f, -0.15706195f, 0.03959581f, 0.06594548f, 0.10924838f, 
    -0.16762322f, -0.03611911f, -0.14586508f, 0.24085355f, 0.14802623f, 0.10643315f, -0.02326167f, 0.10891484f, 
    0.01473289f, 0.20085937f, 0.11676722f, 0.07193470f, -0.06552894f, 0.09408116f, -0.15007463f, -0.01273835f, 
    -0.00557102f, 0.05140010f, -0.02737840f, 0.11228099f, -0.00644662f, 0.01703703f, 0.12758188f, -0.09783547f, 
    0.04085193f, -0.00587984f, 0.25019503f, 0.07624095f, 0.09151036f, 0.06971030f, 0.06570043f, -0.02570204f, 
    0.07934865f, -0.02552392f, 0.15618633f, 0.15292054f, -0.02594279f, 0.08611241f, -0.01746466f, 0.22891863f, 
    -0.03759775f, 0.01020973f, -0.17192452f, 0.11187044f, -0.11867831f, -0.03734257f, 0.02905011f, -0.06674230f, 
    0.26250142f, 0.00456913f, 0.07347343f, -0.14766885f, -0.15402788f, -0.02801814f, -0.03361567f, -0.02105686f, 
    -0.06380089f, -0.05912739f, -0.01318008f, -0.18343031f, -0.18351556f, 0.08468623f, -0.06786837f, 0.24921630f, 
    0.06686905f, 0.11950956f, -0.08279289f, -0.09085330f, -0.01126768f, 0.11430559f, 0.10848350f, 0.02256070f, 
    0.18253917f, -0.08470668f, 0.07614984f, -0.03274115f, -0.02679523f, 0.04406517f, 0.00773490f, 0.00269690f, 
    -0.04526396f, 0.10502906f, 0.04944653f, -0.04979880f, 0.08957218f, 0.03953579f, 0.02739691f, -0.02508397f, 
    -0.05748387f, 0.05159370f, -0.00429686f, -0.00908283f, -0.07358198f, -0.02587056f, -0.08782192f, -0.04822879f, 
    0.08416336f, 0.10820385f, 0.11556192f, -0.04055857f, -0.10946790f, -0.00594730f, -0.00484932f, 0.00048721f, 
    0.07887799f, -0.08433320f, -0.01408475f, 0.08843329f, 0.07083325f, -0.02497671f, -0.01113424f, 0.32835430f, 
    -0.02088302f, 0.07327099f, 0.02726655f, -0.03998891f, -0.06972796f, -0.03573157f, 0.00207790f, 0.01291273f, 
    -0.08751778f, -0.27987528f, 0.00437163f, 0.26715863f, 0.07775358f, 0.09103874f, 0.15001565f, -0.02379831f, 
    0.04770035f, 0.02767211f, 0.00329996f, 0.14676206f, 0.11043125f, -0.09224587f, 0.08936180f, -0.16243008f, 
    -0.03927283f, 0.15114473f, 0.06669860f, 0.04440917f, 0.15306014f, -0.07687062f, -0.12323210f, -0.03314324f, 
    0.10806897f, -0.06258197f, 0.17858601f, -0.02600597f, 0.04032446f, 0.07353109f, -0.02834363f, -0.07685793f, 
    0.01261857f, 0.01885762f, -0.04759897f, 0.07775645f, 0.12854280f, 0.11123086f, -0.12879425f, 0.12101707f, 
    0.05193759f, -0.12437181f, 0.06112120f, 0.01361241f, -0.05675301f, -0.00662008f, -0.01193255f, 0.06201784f, 
    0.04357172f, 0.06419274f, 0.02464703f, -0.03269380f, 0.02848511f, -0.04138420f, -0.02061089f, 0.00137977f, 
    0.05012209f, 0.18099089f, 0.02719251f, 0.05373542f, 0.08846314f, 0.00040800f, 0.07566255f, 0.10905629f, 
    -0.11437033f, 0.05938003f, -0.02000957f, 0.02074660f, 0.05850361f, -0.02728005f, 0.03067206f, 0.17498474f, 
    0.20887931f, 0.03701618f, 0.11143602f, 0.04593169f, -0.02168559f, 0.00136475f, -0.13612346f, 0.09061953f, 
    -0.06120754f, 0.12021957f, 0.02335566f, -0.07404188f, 0.06865858f, 0.03701255f, -0.08133383f, -0.08034562f, 
    0.03863784f, 0.05110080f, 0.06207234f, -0.05609423f, -0.08075586f, 0.09470254f, 0.06594433f, 0.13713418f, 
    -0.03185756f, 0.10134018f, -0.32115230f, 0.23330683f, 0.20339383f, 0.17236002f, 0.04105541f, -0.04569402f, 
    0.03642636f, 0.10859559f, 0.23110493f, 0.06336673f, -0.00283957f, 0.02521634f, 0.12263954f, 0.15345798f, 
    0.02212399f, -0.08296757f, 0.10357869f, 0.10546525f, -0.02122156f, 0.04756023f, 0.00943050f, -0.01694293f, 
    -0.17658482f, 0.07344013f, 0.05019144f, -0.00573342f, 0.07083189f, -0.05342780f, 0.08394928f, -0.06179156f, 
    -0.04846686f, -0.07064417f, 0.05227163f, 0.09042592f, 0.11683979f, -0.08787666f, 0.13936359f, 0.37027633f, 
    -0.12632795f, 0.04176300f, -0.07519075f, 0.17867015f, -0.03194328f, 0.01543029f, 0.09406985f, 0.01145518f, 
    0.38476202f, -0.31483862f, 0.07505401f, -0.14077835f, 0.11032663f, 0.03982110f, 0.05388269f, 0.01724601f, 
    0.01560691f, 0.10913683f, 0.04354880f, -0.12355876f, -0.00600988f, 0.11619649f, -0.20177568f, 0.03034300f, 
    0.03711607f, -0.08555648f, 0.09981628f, 0.01257971f, -0.01720233f, 0.03551298f, -0.01774298f, 0.18210743f, 
    -0.13146481f, -0.19880065f, -0.00348952f, 0.14573683f, -0.01140789f, -0.04204852f, -0.12856749f, -0.07507113f, 
    0.03273247f, 0.07193807f, -0.00576353f, 0.00602570f, 0.01853340f, 0.00436825f, -0.06997988f, -0.11794543f, 
    -0.06900565f, -0.01022688f, 0.02929853f, -0.10400258f, 0.07785381f, 0.01598318f, -0.05140958f, -0.11372502f, 
    0.17263280f, 0.25372565f, 0.32079828f, 0.26041281f, 0.05803908f, 0.11404349f, 0.05627345f, 0.09271163f, 
    0.02162797f, 0.10193828f, -0.05734423f, -0.07664949f, 0.34039506f, -0.12654534f, -0.24781008f, 0.00935586f, 
    -0.09655116f, -0.08154967f, -0.04254061f, -0.13813256f, 0.08115936f, -0.15021288f, -0.04022389f, -0.04237880f, 
    -0.21768104f, -0.29698351f, 0.20034906f, 0.33205605f, -0.25743431f, 0.05366965f, -0.04490366f, 0.00890417f, 
    -0.00392098f, -0.04161420f, 0.00995082f, -0.10486615f, 0.03774037f, 0.11000068f, 0.16369809f, 0.19208911f, 
    0.01010792f, -0.09636356f, 0.02203999f, 0.08123584f, -0.18255663f, -0.04678725f, -0.03509750f, -0.03034125f, 
    -0.14763869f, 0.15149431f, -0.11115672f, 0.10795353f, 0.10463303f, -0.13524495f, 0.21697153f, -0.12099303f, 
    0.08597108f, 0.09994375f, -0.07180694f, -0.03980117f, 0.05099155f, 0.10914322f, 0.00580511f, -0.02991437f, 
    0.00911056f, -0.04342071f, 0.01170004f, 0.05637598f, 0.12821846f, -0.19480114f, 0.09666268f, -0.01293536f, 
    -0.01201125f, 0.24297546f, 0.36321807f, 0.09291347f, 0.08580750f, 0.06596406f, 0.05780346f, 0.01279372f, 
    -0.06581042f, -0.08329086f, -0.17064899f, -0.00961979f, 0.09162617f, 0.06611721f, 0.17888401f, 0.06444751f, 
    0.11622405f, 0.08667866f, 0.12196127f, 0.17202155f, 0.18852791f, -0.00693624f, -0.00304824f, -0.07154572f, 
    0.12650768f, 0.13932039f, 0.22121748f, 0.17886727f, 0.04519306f, -0.09012290f, 0.02258697f, -0.03552591f, 
    0.05302182f, -0.00364552f, -0.00713135f, -0.10881064f, -0.08826108f, 0.04600421f, 0.09500804f, 0.03887936f, 
    -0.04535048f, 0.25331375f, 0.09875876f, 0.03064446f, 0.06373892f, 0.09111606f, -0.02505344f, 0.04767945f, 
    -0.31748897f, -0.38520864f, -0.23015732f, -0.13757631f, -0.12289190f, -0.06704208f, -0.07364757f, -0.03570831f, 
    0.05145261f, -0.01556512f, -0.03496275f, -0.01086969f, -0.21723594f, 0.22868067f, -0.08616348f, 0.06654482f, 
    -0.14246246f, 0.10855437f, -0.09044414f, 0.19859114f, -0.00907414f, -0.04774246f, -0.05612078f, -0.01074704f, 
    -0.05971399f, 0.05196328f, 0.03715065f, -0.03122649f, 0.03189490f, -0.02169512f, 0.05929178f, 0.09164721f, 
    0.13944869f, -0.01064479f, 0.04282474f, 0.12570763f, 0.01832985f, -0.02867745f, -0.02853875f, -0.02585519f, 
    0.04758127f, 0.18102151f, 0.08023420f, 0.13888034f, 0.03707948f, -0.06365761f, 0.07487597f, 0.02770364f, 
    0.02553988f, -0.07467303f, -0.22704595f, -0.03588677f, 0.07046273f, -0.18637806f, -0.02067187f, -0.01280465f, 
    0.11193091f, 0.05232204f, -0.02982131f, -0.00230656f, 0.06445581f, 0.15146567f, 0.40106010f, 0.03857453f, 
    -0.02809498f, 0.03352459f, -0.08307512f, 0.10277926f, 0.00879385f, -0.01720952f, -0.02805595f, -0.07982056f, 
    0.21942483f, 0.25566867f, 0.14035617f, 0.27936292f, 0.07256469f, -0.21868192f, 0.23269027f, -0.01118622f, 
    -0.07926267f, -0.12254110f, 0.09376635f, -0.02101070f, 0.01409761f, -0.00193586f, 0.05614012f, 0.13119586f, 
    0.07119641f, -0.15050009f, -0.03232219f, 0.05384995f, -0.13624541f, 0.04183479f, 0.04003344f, 0.05833367f, 
    -0.18193904f, 0.01023791f, 0.00734734f, -0.02714098f, -0.07796699f, -0.04066671f, 0.11678278f, -0.07807510f, 
    -0.03155685f, -0.01823232f, 0.10871759f, -0.11566248f, -0.13370234f, -0.06215262f, 0.17679460f, -0.09689795f, 
    -0.09616145f, 0.02504971f, -0.13490433f, 0.07326579f, 0.06618197f, 0.06865796f, 0.04261034f, -0.13762847f, 
    0.07670353f, -0.18106170f, -0.18293332f, -0.16679952f, 0.06622092f, -0.01675812f, 0.06736332f, -0.03354598f, 
    0.04837715f, -0.25347033f, 0.01025320f, -0.21038173f, 0.02207951f, 0.21924286f, 0.18659152f, 0.33279252f, 
    0.04386250f, 0.01157045f, 0.06600102f, 0.11445270f, 0.00194144f, 0.06470949f, 0.08319401f, -0.17252102f, 
    0.07897960f, 0.01339250f, -0.05607473f, 0.05586156f, 0.02880296f, 0.15189524f, -0.04659270f, 0.20403068f, 
    0.04354124f, -0.13958380f, 0.10869810f, 0.01304118f, -0.00902142f, 0.00416710f, 0.24273489f, 0.01288017f, 
    0.05202140f, -0.08831012f, -0.09684420f, 0.08580312f, -0.01193528f, -0.20726652f, -0.17314354f, -0.07003362f, 
    -0.24148771f, 0.10161022f, 0.12520657f, -0.05858263f, -0.00290014f, 0.01919407f, -0.02477869f, 0.01095670f, 
    -0.00755610f, 0.00810053f, -0.02060543f, 0.03913823f, 0.07767295f, 0.19102749f, 0.05795165f, 0.15995285f, 
    -0.14873490f, 0.02882321f, -0.04197108f, 0.02171719f, 0.07991023f, -0.02926220f, 0.07324158f, 0.00314836f, 
    -0.22153530f, -0.20189644f, -0.05137752f, -0.04693903f, 0.08869092f, -0.03691966f, -0.08011726f, 0.13782452f, 
    -0.07698926f, 0.08399076f, -0.03170845f, -0.06943991f, -0.01648010f, -0.12976263f, 0.04138269f, 0.12695256f, 
    -0.02693088f, -0.01216961f, 0.14071512f, 0.00103043f, 0.04620526f, 0.00895191f, 0.11782225f, -0.06512947f, 
    -0.02242239f, 0.03789496f, 0.08747628f, 0.08293387f, 0.05648443f, 0.10962418f, -0.04796973f, -0.03187767f, 
    -0.07124918f, -0.14175276f, -0.02315099f, 0.32450920f, -0.27170178f, 0.15877318f, -0.08322210f, -0.03623630f, 
    0.01243045f, -0.04536490f, -0.04703281f, -0.01257114f, -0.04855796f, 0.04126438f, -0.04073445f, 0.09219507f, 
    0.13221239f, 0.14159094f, 0.20704553f, 0.13266784f, 0.05359224f, 0.05574679f, 0.10630873f, 0.09245034f, 
    0.11548629f, -0.04099418f, 0.03926396f, 0.06689560f, -0.10636508f, -0.18205881f, -0.08026144f, -0.03977825f, 
    0.10469136f, 0.02215032f, -0.11516723f, 0.08362745f, 0.12305038f, 0.05758430f, 0.34435520f, 0.09554911f, 
    0.12104648f, 0.22265328f, 0.13398467f, 0.09070312f, -0.08765665f, -0.09225666f, -0.10914943f, -0.00256077f, 
    0.05454784f, -0.04589588f, 0.05975596f, 0.00189332f, -0.37409326f, 0.03365539f, -0.01892070f, 0.01096949f, 
    -0.03317488f, -0.04365225f, -0.06169183f, -0.05503253f, -0.04650987f, 0.04890352f, -0.03976402f, 0.05598259f, 
    -0.37579736f, 0.26033697f, -0.17658675f, -0.21615398f, 0.08443592f, -0.01198249f, 0.06840142f, -0.01141904f, 
    -0.02236224f, -0.00131010f, 0.06390715f, -0.02808598f, 0.23574328f, 0.20507503f, 0.04761506f, 0.11204662f, 
    0.04112393f, 0.08200161f, 0.01292175f, 0.00021961f, -0.05943294f, -0.04064569f, 0.00571370f, -0.03399992f, 
    0.49344224f, 0.29702908f, 0.03948355f, -0.09103394f, 0.02254880f, 0.14796284f, 0.11003751f, 0.10042730f, 
    -0.12777777f, 0.04430294f, 0.01897469f, -0.05706569f, 0.32799569f, -0.10695536f, -0.22732653f, 0.11663809f, 
    0.03974424f, -0.08446987f, 0.04266662f, -0.03790539f, -0.07445927f, 0.08343869f, 0.01296521f, -0.01814740f, 
    0.00538688f, 0.23605259f, 0.08718127f, 0.09203533f, 0.03522288f, 0.00080851f, 0.03734269f, 0.10402647f, 
    0.00971282f, 0.05582458f, 0.03677171f, -0.04070454f, -0.06626773f, 0.12038504f, 0.09842852f, -0.05711767f, 
    -0.12503903f, 0.00188158f, -0.01366073f, -0.04961964f, -0.08677575f, 0.08725792f, 0.12675799f, 0.00275381f, 
    -0.02193007f, -0.05124360f, 0.05340207f, 0.08911780f, -0.06792907f, -0.02326377f, 0.02861552f, -0.11000061f, 
    0.03552844f, -0.04682687f, -0.06719674f, 0.15664931f, 0.08182137f, 0.14951713f, -0.18103138f, 0.11342788f, 
    -0.03116544f, -0.05028573f, -0.06624968f, 0.01434079f, 0.00424821f, -0.05003385f, -0.00227164f, -0.05568325f, 
    -0.20899491f, -0.29153952f, -0.49055341f, -0.04270955f, -0.07777535f, 0.00158545f, 0.04229643f, -0.20471589f, 
    0.01779674f, -0.05290322f, 0.02275340f, -0.01835862f, 0.25439057f, -0.01880131f, -0.00787032f, 0.16656674f, 
    0.11463132f, 0.05932232f, 0.12642838f, 0.09977936f, 0.03857463f, 0.05558523f, 0.01386691f, 0.11234882f, 
    0.09399608f, -0.18972896f, 0.08482723f, -0.06086138f, -0.10049096f, -0.09386580f, 0.08932998f, -0.17546229f, 
    -0.06383125f, -0.00407146f, 0.04092159f, 0.05583265f, -0.18693836f, -0.05513069f, -0.16704276f, -0.01393032f, 
    -0.14029709f, 0.03049850f, 0.01453097f, -0.13602684f, -0.05606323f, 0.09849265f, -0.00022741f, -0.04872659f, 
    -0.05629741f, -0.06566408f, 0.05676424f, 0.03496681f, -0.10806809f, -0.01118589f, 0.01507618f, 0.03619511f, 
    -0.13883618f, -0.08885337f, 0.11273628f, -0.06537701f, 0.10224154f, -0.08025604f, 0.06150859f, -0.08484944f, 
    0.12688091f, 0.06694750f, 0.05107349f, -0.16453943f, 0.01898059f, -0.00169034f, -0.01228424f, 0.03159031f, 
    0.11076714f, -0.11020406f, 0.13840048f, -0.01597681f, -0.00680686f, 0.09619415f, 0.09324870f, 0.17323548f, 
    -0.20038971f, 0.05888401f, -0.00869551f, -0.04577589f, -0.09329082f, 0.03948882f, 0.08493256f, -0.14507198f, 
    -0.10171369f, 0.00002654f, 0.15872248f, -0.00806036f, -0.03790746f, -0.04356165f, 0.03684975f, -0.05451271f, 
    0.13716987f, -0.03774067f, -0.23789181f, -0.05825240f, -0.06425796f, 0.07455602f, 0.04999313f, -0.00716556f, 
    0.04878521f, 0.01755715f, -0.06347442f, 0.09018128f, 0.03782140f, -0.02931325f, -0.00361036f, -0.09277155f, 
    0.04833002f, 0.04253981f, -0.03463654f, 0.02747365f, -0.01498570f, -0.03633826f, 0.04935541f, 0.04605218f, 
    -0.19812593f, 0.06905217f, 0.10423137f, -0.06817594f, -0.01943199f, 0.06027952f, -0.14490360f, -0.00048892f, 
    -0.14853597f, 0.10524359f, -0.06801767f, 0.05125612f, 0.16378067f, -0.02993883f, -0.21843833f, -0.17561010f, 
    -0.11578038f, -0.05929316f, 0.17444368f, 0.13531393f, -0.06671808f, 0.06964847f, 0.06037321f, -0.07133488f, 
    0.06660329f, -0.07069048f, -0.31505695f, 0.07202979f, -0.05858579f, -0.00819128f, 0.11695294f, 0.02654720f, 
    0.00749341f, 0.12566480f, 0.01776322f, 0.09976856f, 0.10474925f, 0.13868535f, 0.05182146f, -0.00319107f, 
    0.00290332f, 0.06125950f, -0.04558323f, -0.03720181f, -0.05556490f, 0.08743165f, -0.05202851f, -0.09788007f, 
    0.23838215f, 0.21923426f, -0.10085043f, 0.20916127f, 0.06171763f, 0.06683410f, 0.00911643f, -0.11468951f, 
    -0.01952981f, -0.06925977f, -0.03144855f, -0.11922619f, 0.24345241f, -0.00788290f, 0.13122848f, 0.10778888f, 
    0.04916006f, 0.01322004f, 0.03191037f, 0.08669129f, 0.00068160f, 0.00452419f, -0.02005685f, 0.10272249f, 
    0.15809181f, -0.26906890f, -0.23639990f, 0.11437952f, -0.06189877f, -0.03395389f, -0.00259862f, -0.00789847f, 
    -0.05316653f, -0.04670610f, -0.00253398f, 0.00410055f, 0.27827254f, -0.32983449f, -0.04550276f, 0.13559508f, 
    -0.00634316f, -0.06763370f, 0.06142192f, 0.07570269f, -0.06381639f, 0.03865687f, -0.14103208f, 0.06993458f, 
    -0.16408089f, 0.05424398f, 0.13222063f, -0.03536508f, -0.08000340f, -0.02325764f, 0.01572790f, -0.21377897f, 
    -0.01992720f, 0.11628578f, 0.10041721f, -0.04287814f, 0.06567926f, 0.05213469f, -0.01515633f, -0.11859860f, 
    -0.08218777f, 0.00472350f, 0.02848739f, -0.04434393f, -0.12770130f, 0.01419518f, 0.12714082f, 0.02232678f, 
    0.15042245f, 0.07637195f, -0.06011494f, 0.08669442f, -0.00156341f, -0.00795462f, -0.04945764f, 0.10102500f, 
    -0.08553366f, 0.04040114f, -0.04128389f, 0.11683925f, -0.00337464f, -0.10334850f, 0.08689645f, -0.09495126f, 
    -0.06574362f, -0.02383676f, -0.00921418f, -0.14334507f, -0.01048297f, 0.12167218f, -0.07099967f, -0.04991792f, 
    -0.05574518f, 0.01476855f, 0.03797321f, 0.00833052f, -0.03925577f, -0.01227728f, 0.02935519f, -0.01851714f, 
    0.00542939f, -0.00418817f, -0.03385559f, 0.04250757f, 0.02359570f, -0.01050946f, -0.03063504f, 0.01673480f, 
    0.04157632f, 0.00910526f, -0.02679758f, 0.01029566f, -0.01458842f, -0.05491136f, 0.01377707f, -0.01447617f, 
    -0.02210329f, 0.01634755f, 0.04095466f, 0.04444338f, -0.02780705f, -0.00205592f, -0.01967208f, -0.00219927f, 
    -0.01489837f, 0.03179886f, 0.02660481f, -0.03992533f, 0.02810087f, 0.01236128f, -0.05028612f, -0.01426816f, 
    0.00650943f, -0.02934955f, 0.02620856f, 0.00055411f, 0.00986838f, -0.02045874f, -0.05328701f, -0.02665827f, 
    0.02999887f, -0.04687109f, -0.04655464f, -0.00825455f, -0.02135541f, -0.04249315f, 0.01887552f, -0.00546653f, 
    0.01257138f, -0.02050584f, 0.01396589f, 0.03398959f, 0.00586210f, 0.02843636f, -0.05642198f, -0.05499090f, 
    -0.00981780f, 0.01727407f, -0.03201765f, 0.02863299f, -0.03946754f, -0.02073544f, 0.03740341f, 0.00391640f, 
    -0.03535405f, 0.03833698f, 0.02479552f, -0.00927885f, -0.01807257f, -0.03957895f, -0.02255166f, -0.02323973f, 
    -0.03890702f, 0.01933813f, -0.02945005f, 0.01258794f, -0.04610628f, -0.03049305f, 0.03774027f, 0.00491417f, 
    0.02984257f, -0.02293646f, -0.03445838f, -0.00721791f, 0.00720602f, -0.05557561f, 0.03027124f, -0.01515104f, 
    0.00613456f, -0.01722437f, -0.05495611f, -0.03251635f, -0.04213657f, 0.03072734f, -0.00119308f, 0.02639468f, 
    -0.04713595f, -0.00645710f, -0.01592155f, -0.03781999f, 0.04160424f, -0.00752309f, 0.02753815f, -0.04197597f, 
    -0.01435509f, -0.05324667f, -0.04150404f, 0.02822431f, 0.03364948f, -0.00807430f, 0.02731304f, 0.02066897f, 
    0.03268420f, 0.00190545f, -0.01053065f, -0.00375209f, 0.00411341f, -0.01713023f, -0.04041884f, -0.00957201f, 
    -0.05240134f, -0.02702574f, 0.02307404f, -0.02122655f, 0.05084984f, -0.05503810f, 0.02725491f, 0.02966164f, 
    -0.02596295f, 0.03517157f, 0.01641163f, -0.04210867f, -0.05492126f, -0.03448788f, 0.01154656f, -0.04459513f, 
    -0.02382472f, -0.04308675f, 0.01343213f, 0.03501460f, 0.00439459f, 0.04302682f, -0.05524210f, -0.04259716f, 
    -0.04754831f, 0.02038373f, 0.02574819f, 0.01021978f, -0.05598910f, 0.03690158f, -0.01166736f, 0.03935249f, 
    0.02561362f, -0.00185249f, 0.02996343f, 0.03421926f, 0.00349783f, -0.05661277f, -0.00208225f, -0.00304470f, 
    0.04018036f, -0.05155837f, 0.04343097f, -0.03849182f, 0.03423807f, -0.02017599f, 0.03105732f, -0.05649952f, 
    -0.03784229f, 0.01262748f, 0.00272380f, 0.01228125f, -0.02266671f, 0.04487735f, 0.01881642f, -0.04354085f, 
    -0.01608051f, 0.01624944f, -0.05498128f, -0.04761812f, 0.02615832f, -0.01028602f, 0.01924119f, 0.02027989f, 
    0.04024660f, -0.03546903f, -0.02992608f, 0.02343467f, 0.01513639f, -0.04645984f, 0.00043079f, 0.01824822f, 
    -0.01675870f, -0.05547931f, 0.01371079f, -0.03826424f, -0.05568532f, 0.00648428f, -0.05632808f, 0.01264000f, 
    -0.01896790f, 0.00930455f, -0.04918875f, -0.01630587f, -0.00681993f, -0.02704117f, 0.03027776f, -0.03789390f, 
    -0.01929657f, 0.04302950f, 0.02616305f, 0.04457708f, -0.01924190f, -0.05302185f, 0.03106668f, -0.03923952f, 
    0.03939837f, -0.05581537f, 0.00442308f, 0.00403724f, 0.04031093f, 0.02444880f, -0.03827661f, -0.02055305f, 
    -0.04327004f, -0.03255116f, 0.01971943f, -0.02097231f, -0.00745617f, -0.02504104f, 0.00259373f, 0.02543636f, 
    -0.01607298f, -0.02710554f, 0.02500402f, 0.03443280f, -0.00803970f, -0.03732135f, -0.01690994f, 0.01321050f, 
    -0.02647914f, -0.05280913f, -0.02705611f, 0.02615709f, 0.02813341f, -0.00630723f, 0.02499554f, -0.01521364f, 
    -0.00764719f, 0.01106134f, -0.02696416f, -0.02059080f, -0.03104685f, 0.01436029f, -0.00988892f, -0.00173522f, 
    -0.04767844f, 0.02577694f, -0.01669446f, 0.03295238f, -0.03626165f, -0.04715303f, -0.05287538f, 0.01439204f, 
    -0.02900741f, 0.01654132f, -0.00023909f, -0.00227882f, 0.00368080f, -0.03349678f, 0.04080020f, -0.03494893f, 
    0.03178249f, -0.01886254f, -0.00152109f, 0.01682325f, -0.03148868f, -0.01076285f, -0.01371977f, -0.02537417f, 
    -0.05380363f, -0.04629458f, -0.03502917f, -0.04718924f, -0.03711828f, -0.02875804f, -0.03532766f, 0.03203524f, 
    -0.04592687f, 0.01608134f, -0.05658215f, 0.03594569f, 0.02414544f, -0.00245861f, -0.00782208f, -0.00496879f, 
    -0.05390729f, 0.02123724f, -0.04307395f, 0.02328552f, 0.00443490f, 0.03433583f, 0.02612557f, 0.00440489f, 
    0.03805250f, -0.05055570f, 0.01033444f, -0.01872780f, -0.03922659f, 0.01527600f, -0.03462899f, 0.03354178f, 
    -0.01784554f, 0.04266642f, 0.01895453f, -0.04014428f, -0.03665384f, -0.04094141f, -0.00999468f, -0.01702411f, 
    -0.00906226f, -0.03266251f, -0.05103173f, 0.00204863f, 0.01787602f, 0.01957025f, 0.00859674f, 0.01015307f, 
    -0.03455050f, -0.04714792f, -0.02254857f, -0.00193460f, -0.03962610f, -0.00241371f, -0.05487693f, 0.00720294f, 
    0.03829801f, -0.05318183f, 0.02176779f, -0.03175075f, -0.02527759f, -0.03930726f, -0.02630255f, -0.04104686f, 
    0.02890511f, -0.03398521f, 0.02110995f, -0.00335707f, 0.00732488f, 0.01146997f, 0.04397061f, 0.01812513f, 
    0.01119645f, -0.05282917f, -0.01913147f, -0.03582269f, 0.03493804f, -0.03515892f, 0.01425272f, 0.03300414f, 
    -0.03442695f, 0.00384483f, -0.03128915f, -0.05515788f, 0.03622482f, -0.04506269f, -0.00193999f, 0.01243731f, 
    -0.01905689f, 0.04038420f, 0.02127348f, -0.05159748f, 0.03865395f, -0.03873009f, -0.04838029f, -0.02633632f, 
    -0.04245392f, -0.02292971f, -0.00404273f, -0.00731385f, 0.00734986f, 0.00245240f, 0.03073627f, 0.02997676f, 
    0.01700654f, -0.05470501f, 0.04177465f, -0.01870777f, -0.02441705f, 0.03902437f, 0.03803503f, -0.03866036f, 
    -0.04069668f, -0.03644923f, -0.02136713f, -0.02223754f, -0.05078253f, -0.05581909f, 0.03837912f, 0.04412870f, 
    -0.00745059f, -0.01341464f, 0.00529165f, 0.01445189f, -0.00240188f, 0.03633251f, 0.00103290f, -0.02578191f, 
    0.00777299f, 0.00034600f, 0.01216737f, -0.00947623f, 0.01510323f, 0.03273145f, 0.03112586f, 0.04161312f, 
    -0.04586997f, -0.01156600f, 0.02677514f, -0.03945433f, 0.04365861f, 0.02157474f, -0.03061054f, -0.02838501f, 
    0.00972940f, -0.04008721f, 0.03835875f, -0.02781935f, -0.05581019f, -0.01972981f, -0.05312396f, -0.05628695f, 
    -0.03505463f, -0.03306226f, -0.00423574f, -0.03076670f, -0.02171704f, -0.03717033f, -0.03716135f, -0.03706925f, 
    -0.04142745f, 0.00959362f, -0.03922845f, 0.00272257f, 0.00204761f, 0.02121698f, -0.02474124f, 0.01424536f, 
    -0.02036080f, -0.02291574f, 0.03274522f, 0.02817555f, 0.03954859f, -0.04811044f, 0.03667307f, 0.03093590f, 
    -0.04867268f, 0.01875028f, 0.02916750f, -0.02880079f, 0.00915082f, -0.01050780f, -0.05561274f, 0.04019486f, 
    -0.00063788f, -0.01386053f, -0.03235846f, 0.04253265f, 0.01644823f, -0.02081479f, 0.00887385f, -0.04559161f, 
    0.02812871f, 0.00186030f, -0.04572859f, 0.01786619f, -0.05474469f, 0.02328720f, 0.03251641f, 0.01824803f, 
    -0.01920617f, -0.01453882f, 0.02866059f, 0.03553995f, 0.02098194f, -0.00530458f, -0.03356883f, -0.00068540f, 
    0.04270557f, 0.04216543f, 0.03357959f, -0.02336092f, 0.03296864f, -0.04732044f, -0.05044007f, 0.00861430f, 
    0.03575778f, -0.02676972f, -0.04641753f, 0.02026562f, -0.00173054f, -0.04297755f, 0.03613922f, 0.03938771f, 
    -0.01992251f, -0.04104077f, 0.04136822f, -0.01420630f, -0.05234483f, -0.01556383f, -0.01499719f, 0.03686866f, 
    -0.03635049f, -0.03173230f, -0.00461324f, -0.01769139f, 0.02995937f, -0.01398352f, 0.00768436f, -0.00591954f, 
    -0.03906734f, 0.01004507f, 0.01663633f, -0.00116887f, -0.01883704f, 0.01360641f, -0.00026002f, -0.01948061f, 
    -0.02967734f, -0.00880186f, -0.01684450f, 0.02518294f, 0.00057509f, -0.03930826f, 0.02936522f, 0.01700870f, 
    0.02362909f, -0.02084957f, -0.02063387f, 0.00761268f, -0.02756292f, -0.03368899f, 0.04162779f, 0.03548087f, 
    -0.01640841f, -0.02779668f, -0.01139063f, 0.01873949f, -0.03140770f, 0.03695047f, -0.01579030f, -0.04338511f, 
    0.03770698f, 0.00118218f, 0.01348885f, -0.04349615f, -0.02997502f, -0.02124958f, -0.03130743f, -0.02682672f, 
    0.00355470f, 0.01605133f, -0.05365621f, 0.02914667f, 0.01576866f, -0.04888228f, -0.00396643f, 0.01781451f, 
    -0.04653953f, -0.04317421f, 0.01377087f, -0.01647561f, -0.05322495f, -0.03570928f, -0.01228230f, 0.02303144f, 
    -0.05516588f, -0.03788572f, -0.04117990f, -0.03529384f, 0.04104204f, -0.03741724f, -0.00326573f, -0.02328582f, 
    0.00344348f, 0.00730474f, -0.03593571f, -0.00641683f, -0.04132010f, -0.03942047f, -0.01645349f, -0.00926525f, 
    0.00916037f, 0.02994039f, -0.04015050f, -0.01892688f, -0.05682534f, -0.04039579f, -0.05312610f, -0.00675017f, 
    -0.03681403f, -0.03716500f, -0.00016473f, -0.00284718f, -0.02519587f, 0.01142572f, -0.04713412f, -0.02342236f, 
    -0.00598880f, 0.01294489f, -0.02932716f, 0.01766704f, 0.00937671f, -0.01834873f, -0.04234959f, 0.03625446f, 
    0.00025027f, -0.04691833f, -0.02324496f, -0.04079978f, -0.04833179f, -0.05560079f, 0.03894159f, 0.00566766f, 
    -0.05041912f, -0.02263920f, -0.01185525f, -0.04672462f, -0.01236648f, 0.01165502f, 0.03494694f, 0.02173560f, 
    -0.03862054f, -0.02145689f, -0.02204340f, -0.00413212f, -0.00568013f, -0.05683131f, -0.03901215f, -0.02761082f, 
    -0.01192620f, 0.02410900f, -0.04587097f, -0.02334616f, 0.02436883f, -0.03585385f, 0.03786372f, 0.01842965f, 
    -0.05507396f, -0.00737932f, -0.01390038f, 0.00021215f, -0.01900464f, 0.03192582f, 0.02279534f, 0.04477090f, 
    -0.04706989f, -0.05053005f, 0.00268128f, -0.00131636f, -0.04910425f, 0.03088892f, -0.05323156f, -0.03046895f, 
    -0.04739191f, 0.02506499f, -0.04595849f, -0.01905940f, 0.00319731f, -0.01178051f, 0.02428175f, 0.03681319f, 
    -0.04370698f, -0.03219110f, 0.00506002f, -0.04559753f, 0.00037387f, 0.04487300f, 0.04210189f, 0.03745965f, 
    0.01602893f, 0.03036964f, 0.04138539f, -0.05692889f, -0.01204863f, 0.00145781f, -0.01486883f, 0.00172253f, 
    -0.00554739f, -0.00739391f, 0.00874751f, 0.01797727f, -0.02302883f, 0.01908291f, 0.01646342f, -0.04365936f, 
    -0.00858179f, 0.00306194f, -0.03998462f, -0.00422365f, 0.02571909f, 0.00632500f, -0.04891779f, 0.00031386f, 
    0.00204788f, 0.01854440f, 0.01858868f, -0.00916548f, -0.00053747f, -0.01136904f, 0.00400754f, -0.04881594f, 
    0.00798806f, 0.01784375f, -0.00198030f, -0.03996032f, -0.04100204f, -0.00552879f, 0.00611344f, 0.03543803f, 
    -0.01627250f, -0.00604514f, -0.03693612f, -0.02489071f, -0.03914913f, -0.04331405f, 0.00563568f, -0.04957754f, 
    0.00434660f, -0.01767286f, -0.03232153f, 0.04358327f, 0.01179563f, -0.04402020f, 0.04068675f, 0.02207651f, 
    -0.01403245f, 0.01059172f, -0.02483346f, -0.02813067f, 0.01183784f, -0.01884392f, 0.01500975f, 0.02358697f, 
    0.03496628f, -0.01686883f, 0.03585222f, -0.02071371f, -0.03800337f, 0.02090548f, 0.00149286f, -0.04468644f, 
    -0.04064589f, -0.00442265f, -0.03950701f, 0.03948108f, 0.02346605f, -0.03265067f, 0.04486690f, -0.00308360f, 
    0.02428947f, 0.15050834f, 0.10237503f, 0.01711006f, 0.04594640f, 0.13640338f, -0.05484440f, -0.25318283f, 
    0.01154016f, 0.00912310f, -0.06532664f, 0.05104427f, 0.16962563f, -0.03660297f, 0.14368179f, -0.01106405f, 
    -0.00652148f, -0.03432814f, -0.00394725f, 0.05578008f, 0.05898518f, -0.00769388f, 0.08540178f, 0.05953217f, 
    -0.42403117f, -0.08767121f, 0.22580154f, -0.00184250f, 0.03572366f, 0.13974771f, -0.05975125f, 0.17632657f, 
    0.00801784f, 0.03783854f, 0.04222455f, 0.03932125f, -0.05932554f, 0.26606289f, 0.08242811f, 0.09464858f, 
    -0.05299021f, -0.06847694f, -0.02444984f, 0.03226925f, -0.01044112f, 0.05704588f, 0.05885775f, 0.07057902f, 
    -0.46510527f, 0.13991100f, 0.15428674f, -0.11596236f, 0.06994075f, -0.25030014f, -0.00506759f, -0.24707784f, 
    -0.10613269f, -0.07944825f, -0.08957875f, -0.09453893f, 0.36388344f, 0.12293956f, -0.17267531f, -0.17759980f, 
    0.01794140f, 0.02066789f, 0.05215500f, 0.19425185f, 0.20836540f, -0.16720212f, 0.02230517f, -0.12472219f, 
    -0.09976488f, 0.15015173f, -0.09336739f, 0.13516162f, 0.02241195f, 0.05790509f, 0.04316048f, 0.15304784f, 
    0.14459994f, 0.06002863f, -0.15359373f, 0.16208279f, -0.12711720f, -0.03600458f, 0.04124560f, 0.04562967f, 
    -0.04204273f, 0.02498138f, 0.22025397f, -0.09214643f, -0.01677892f, -0.01007416f, -0.02815899f, -0.04570495f, 
    0.24384226f, -0.41780484f, 0.27364901f, -0.32180023f, 0.17096724f, 0.20796061f, -0.19610254f, 0.17075056f, 
    0.02129884f, 0.03954962f, -0.00832974f, 0.00946929f, -0.07837378f, 0.13182214f, 0.06340617f, 0.31578675f, 
    0.00730029f, 0.19600978f, 0.01457422f, -0.03195424f, 0.01463262f, -0.06119821f, 0.00364476f, 0.05418260f, 
    0.13222311f, 0.11205138f, 0.15861124f, 0.09720243f, 0.02467513f, -0.05235523f, -0.03870608f, 0.00755259f, 
    -0.06021455f, -0.04972518f, -0.05406325f, 0.00412397f, 0.01335204f, -0.04952198f, 0.49478596f, -0.11883848f, 
    0.05693274f, -0.03972317f, 0.21473135f, -0.11351173f, 0.05977844f, 0.01100154f, 0.10371944f, -0.04849646f, 
    0.22860728f, 0.01351189f, 0.06500778f, -0.05580796f, 0.01115508f, 0.00446689f, -0.08691946f, 0.06361404f, 
    -0.00549223f, -0.07314179f, -0.04456098f, -0.07846005f, -0.03968810f, -0.01874176f, -0.00787805f, -0.03365786f, 
    -0.07406908f, 0.06363054f, -0.04068762f, 0.04202351f, -0.03491616f, -0.03293957f, -0.05856545f, 0.03781163f, 
    0.11124568f, -0.07678130f, -0.08394745f, 0.05495151f, 0.00744571f, -0.12978218f, -0.00580001f, -0.00322318f, 
    0.12712875f, -0.16572571f, 0.18323830f, 0.12334467f, 0.03832963f, -0.06006007f, -0.27019536f, -0.02410650f, 
    -0.03294794f, -0.09713181f, -0.09036669f, -0.08828242f, 0.05922850f, 0.11531305f, -0.00414172f, 0.00448454f, 
    0.01374866f, -0.08065136f, 0.03628366f, -0.09299090f, -0.01114158f, 0.04211917f, -0.09541107f, -0.07002019f, 
    0.03536942f, 0.06147927f, 0.03325636f, 0.14785805f, -0.02997532f, -0.11000693f, 0.00631100f, 0.05948393f, 
    0.01949712f, -0.05010113f, -0.01279540f, 0.08097275f, -0.10851010f, -0.05106279f, -0.02515502f, 0.00967139f, 
    0.09455317f, -0.07654256f, -0.02964090f, 0.01345643f, 0.04927408f, -0.02312303f, -0.05534573f, -0.01755879f, 
    -0.08864073f, -0.02042153f, -0.08672720f, -0.00406211f, 0.15800105f, -0.00590737f, -0.04631045f, 0.16807598f, 
    0.04657414f, 0.01608671f, 0.02500612f, 0.12507381f, 0.01758489f, -0.02891549f, -0.06293465f, -0.00016037f, 
    0.00766866f, -0.10922046f, -0.04270787f, -0.06988554f, 0.04068200f, 0.03938851f, 0.07690386f, 0.05468520f, 
    -0.13737196f, -0.20426132f, 0.08666987f, 0.06701278f, 0.20097025f, 0.00104846f, -0.03099418f, -0.10363530f, 
    0.04341312f, -0.02492615f, 0.00185157f, -0.02611162f, -0.02146101f, -0.00484425f, 0.03429469f, -0.02303248f, 
    0.23288298f, -0.01538221f, -0.00452329f, -0.15087929f, 0.08488057f, 0.16022053f, -0.08017358f, 0.05544732f, 
    -0.14712116f, 0.05959671f, 0.05021698f, 0.05572625f, -0.20267832f, -0.03563117f, 0.05575063f, -0.09240141f, 
    -0.03291230f, 0.07306936f, -0.00071710f, 0.08342233f, 0.00347654f, 0.01561241f, 0.15944982f, -0.05898108f, 
    0.03811636f, 0.20050843f, -0.00334280f, -0.00501828f, -0.10716335f, 0.01637767f, 0.02071171f, 0.13780847f, 
    -0.00756958f, -0.02061956f, 0.07220871f, 0.11854967f, 0.01615502f, -0.03881386f, 0.03727131f, -0.10661636f, 
    -0.00610341f, -0.02281140f, 0.04426217f, 0.05293570f, 0.02292326f, 0.05843147f, -0.00325113f, -0.11652415f, 
    0.61220598f, -0.06237097f, 0.06443993f, -0.08460622f, -0.07960597f, -0.04772230f, 0.09999201f, -0.04291950f, 
    0.16171877f, 0.06655450f, 0.06225707f, -0.01444437f, 0.37479031f, -0.31532302f, -0.49059117f, -0.34000549f, 
    -0.09298944f, 0.11082436f, -0.03912273f, -0.05209786f, 0.19464900f, 0.08714338f, 0.00310525f, -0.05172038f, 
    -0.56716961f, 0.09434792f, 0.11255888f, 0.17888583f, -0.05267610f, 0.19533551f, 0.05507890f, 0.15394153f, 
    0.01516248f, -0.02267448f, 0.03544150f, 0.10113975f, 0.03810549f, 0.19747247f, -0.06753342f, 0.05670330f, 
    -0.06159901f, 0.01732508f, 0.05642425f, 0.12445950f, 0.00034876f, -0.03699918f, 0.09337426f, -0.20521313f, 
    0.15783808f, 0.14623158f, 0.16807792f, -0.02546530f, 0.10678900f, 0.07744135f, 0.00659323f, -0.07265919f, 
    0.02035389f, -0.04103162f, 0.12307300f, 0.04057458f, 0.00841770f, -0.01214751f, 0.05794689f, -0.00476715f, 
    0.01904780f, -0.09384879f, -0.02574230f, 0.07813999f, -0.12030657f, -0.04527251f, -0.04694763f, 0.00317603f, 
    -0.07774533f, -0.02329396f, 0.01590805f, -0.09298852f, 0.01607673f, 0.20533270f, 0.12270623f, -0.24430421f, 
    0.09069996f, 0.05433066f, 0.05969867f, 0.06607273f, -0.17882486f, -0.04738782f, -0.06067667f, 0.21024783f, 
    0.09756058f, 0.05254597f, 0.03540728f, -0.03719128f, -0.05318899f, 0.12443487f, -0.00128391f, -0.13030033f, 
    -0.02711184f, -0.35239077f, 0.07172688f, 0.00053331f, 0.14171317f, 0.11658720f, -0.00949687f, 0.23802461f, 
    0.05109714f, 0.01800922f, -0.00522258f, -0.11315385f, -0.30572426f, 0.04527830f, 0.17456442f, -0.23623969f, 
    -0.08446786f, 0.07089511f, 0.16760625f, 0.07792792f, 0.07325592f, 0.06029062f, 0.11261091f, -0.06619021f, 
    -0.73696291f, -0.10304796f, -0.30221692f, -0.22265141f, 0.01997510f, 0.03136223f, -0.06091009f, -0.10699974f, 
    0.07311157f, 0.00846371f, 0.04728728f, -0.03052622f, 0.29045936f, 0.02211367f, 0.11919913f, -0.26061240f, 
    0.09239477f, 0.01219718f, 0.05415021f, 0.14492637f, 0.40216568f, -0.00869400f, 0.09686341f, -0.04904998f, 
    0.14079139f, 0.00635883f, 0.07282266f, -0.23499294f, 0.07573570f, -0.16257679f, 0.18668780f, 0.05757251f, 
    0.20563152f, -0.06771985f, -0.04688859f, 0.09373007f, -0.13218270f, -0.18674675f, 0.01877356f, 0.02581317f, 
    0.04347926f, -0.03426142f, 0.14378589f, 0.02517487f, 0.07006376f, 0.07816755f, -0.04326899f, 0.02954744f, 
    0.33171162f, -0.02248304f, -0.20647575f, -0.15241382f, 0.11460131f, 0.02367813f, 0.01097791f, 0.14161828f, 
    0.03239775f, 0.05795059f, -0.20012185f, 0.04632835f, 0.03721472f, -0.04737480f, -0.06105932f, -0.04818417f, 
    0.06174932f, -0.00486470f, 0.12803783f, -0.09446014f, 0.10668303f, 0.15450852f, 0.01571246f, 0.15476038f, 
    -0.13534170f, 0.07978372f, -0.09238980f, 0.07475365f, 0.01648480f, -0.11026967f, -0.02651690f, -0.08724616f, 
    -0.09253167f, -0.00485480f, 0.02201472f, -0.02787567f, -0.08244302f, 0.03203927f, -0.01640893f, -0.04288905f, 
    -0.08089186f, -0.01098491f, 0.03506106f, -0.03979265f, 0.15036012f, 0.18224192f, -0.01135188f, 0.09424028f, 
    -0.01496571f, -0.01076428f, -0.02018358f, -0.04202510f, 0.06245268f, -0.14899234f, 0.01469517f, 0.05180640f, 
    0.00234503f, -0.03355782f, 0.18631141f, 0.03087693f, -0.09309516f, -0.04042297f, -0.08200446f, 0.00001402f, 
    0.08939572f, 0.14164598f, -0.00552607f, 0.00081811f, 0.00025196f, -0.02367788f, 0.02563623f, 0.02631937f, 
    0.03707615f, -0.10513958f, -0.03138471f, -0.03168575f, 0.05371739f, 0.02643915f, -0.09791838f, 0.11972669f, 
    -0.15526244f, -0.00077861f, -0.00838992f, -0.28089130f, -0.11190456f, 0.01402863f, -0.02629003f, -0.07149174f, 
    0.09101480f, 0.00340263f, 0.05145185f, -0.03548847f, 0.01313443f, 0.03649026f, 0.03672596f, 0.04245713f, 
    0.01804472f, 0.12541486f, 0.09488221f, -0.35073391f, -0.07495841f, 0.01089755f, -0.09017633f, 0.06839352f, 
    0.01366635f, -0.00519448f, 0.12450488f, -0.13083772f, -0.10114294f, -0.11157314f, -0.11911353f, 0.05118988f, 
    -0.09823979f, -0.06383409f, 0.12934770f, 0.20880741f, -0.12493734f, 0.05364201f, -0.00436620f, 0.08245776f, 
    0.14654770f, -0.02589274f, -0.18951789f, -0.03306030f, -0.15512490f, -0.04667742f, -0.02038385f, 0.02084825f, 
    0.05176958f, -0.05474540f, -0.10496864f, 0.04139955f, -0.09493475f, -0.13210993f, 0.04918832f, 0.00128920f, 
    0.06178905f, -0.07763965f, 0.05244530f, -0.01544061f, 0.04169539f, 0.00380374f, 0.13963501f, 0.06268637f, 
    0.02854931f, -0.00012697f, 0.05637297f, 0.13893880f, -0.00638604f, 0.01575270f, 0.04181862f, 0.02619086f, 
    -0.11589304f, 0.02179181f, -0.09696253f, 0.01629547f, 0.18636020f, -0.19977488f, -0.15637536f, 0.05105849f, 
    0.07122766f, 0.15949312f, 0.14342745f, 0.04177416f, -0.07979837f, -0.15274940f, -0.00922363f, -0.07538166f, 
    -0.04218761f, -0.11404591f, -0.15326449f, -0.13480948f, 0.12894140f, 0.09084556f, 0.14809808f, -0.04170525f, 
    -0.02901063f, -0.05942571f, -0.09841826f, 0.10241084f, -0.14920925f, 0.03006931f, 0.04251924f, 0.02399107f, 
    0.14519893f, 0.10594746f, 0.03308712f, 0.15871389f, 0.15511701f, 0.01525883f, -0.02994752f, -0.04586659f, 
    -0.02508003f, -0.10910936f, 0.12893510f, -0.16519421f, -0.04969374f, -0.14790539f, 0.06044411f, 0.06272048f, 
    0.18663087f, 0.16887495f, 0.07479353f, 0.13917364f, -0.08311716f, -0.04146169f, -0.07723896f, -0.16350141f, 
    -0.03793795f, 0.01193554f, 0.23839426f, 0.17111419f, 0.10989062f, 0.11138944f, 0.02163025f, 0.17108633f, 
    0.28546679f, -0.04151184f, 0.00733072f, -0.05667137f, -0.04255655f, -0.06174485f, -0.02316503f, -0.11895470f, 
    0.14354677f, 0.06254389f, 0.12378977f, 0.04525580f, 0.15536267f, 0.26662451f, -0.02925076f, -0.32480386f, 
    0.02073905f, 0.03291317f, -0.05440342f, -0.08793709f, 0.09866756f, 0.09807924f, -0.02267019f, 0.02550049f, 
    -0.33171713f, 0.22233917f, 0.05303158f, 0.39607573f, -0.00615171f, -0.04621695f, 0.02198644f, 0.10293094f, 
    0.08291867f, 0.04910921f, 0.08107946f, 0.19709209f, 0.07579885f, -0.02353698f, 0.11747766f, 0.02366554f, 
    -0.06537070f, -0.02420652f, -0.13895856f, 0.10206026f, 0.09826230f, 0.11196265f, 0.10101044f, 0.06428857f, 
    0.05353939f, 0.04817953f, 0.02807410f, -0.12636974f, 0.06957711f, 0.09217276f, 0.18562239f, -0.04866242f, 
    0.06736024f, 0.15338384f, 0.17997488f, 0.05697446f, 0.02955554f, -0.06368144f, 0.01477460f, -0.00294819f, 
    -0.00104122f, -0.11746845f, -0.10987695f, 0.05924447f, -0.06932077f, 0.05412368f, 0.00192223f, -0.01742821f, 
    0.21640943f, 0.24432522f, 0.23291320f, 0.14982224f, 0.05149578f, 0.02145832f, -0.11118645f, -0.00232603f, 
    0.02934481f, -0.09114889f, -0.04087524f, 0.08457690f, -0.25202110f, 0.01702920f, -0.33521119f, -0.05578366f, 
    -0.00922320f, -0.06882041f, -0.12160052f, 0.00556238f, -0.01771261f, -0.17139040f, -0.07244216f, 0.01930564f, 
    -0.29610172f, -0.27656913f, -0.16800296f, -0.12478153f, 0.07640126f, 0.01365013f, -0.00906515f, -0.03578166f, 
    -0.02299422f, -0.06502191f, 0.04222247f, -0.00981447f, 0.05606078f, 0.23445533f, 0.12101554f, 0.18185686f, 
    0.08978787f, 0.08216180f, -0.05273218f, 0.13821532f, -0.01436268f, -0.03490685f, -0.12050496f, -0.03754607f, 
    -0.00854596f, 0.23245092f, 0.05055370f, -0.04048068f, -0.04868992f, -0.01758974f, 0.13594502f, -0.18678352f, 
    -0.01645044f, -0.02324519f, -0.09554423f, -0.04879627f, 0.36481681f, 0.03298363f, -0.06760781f, -0.04340375f, 
    -0.07563089f, -0.06387053f, -0.03956905f, 0.02721645f, 0.00552882f, -0.11602620f, 0.01398475f, -0.01339049f, 
    0.12023223f, 0.15064068f, 0.19940405f, 0.10014628f, 0.01570095f, 0.05460282f, -0.11704382f, -0.00529881f, 
    0.00909394f, -0.09797925f, -0.14823727f, -0.04242518f, 0.06840693f, -0.01064757f, 0.23277293f, 0.06160101f, 
    -0.09724049f, 0.06259786f, 0.02522444f, -0.09001774f, 0.00957716f, 0.08143958f, 0.05070974f, 0.05499933f, 
    -0.05212014f, -0.23653287f, 0.21474770f, -0.02658917f, 0.06242105f, 0.08963464f, -0.05379159f, 0.03280311f, 
    0.02194629f, -0.03070848f, -0.10362186f, -0.03523478f, 0.07172373f, 0.07106826f, 0.13567083f, 0.28758276f, 
    0.05445841f, 0.13344392f, 0.09659527f, -0.08101296f, -0.05993646f, -0.03319942f, 0.01021724f, -0.02564090f, 
    -0.28796434f, -0.34320411f, -0.32230622f, -0.22052447f, -0.03784401f, 0.02868159f, -0.01484998f, 0.02591451f, 
    0.00467618f, 0.01829561f, -0.00666151f, 0.14262761f, 0.22379704f, 0.09415183f, 0.48482934f, 0.00155483f, 
    0.02237686f, 0.09963354f, 0.11669014f, -0.02881625f, -0.01925293f, -0.10833729f, -0.03158291f, -0.06392299f, 
    -0.08226617f, -0.07417960f, -0.00049865f, 0.00589238f, 0.01458567f, 0.02694902f, -0.02854639f, 0.00681445f, 
    -0.01280381f, 0.05754292f, -0.05174491f, -0.02516277f, -0.02180454f, -0.05652839f, -0.08926849f, -0.08259201f, 
    0.00031249f, 0.06305990f, 0.17139071f, 0.00819640f, 0.05953198f, 0.07503475f, -0.07808552f, 0.06417948f, 
    -0.07699131f, -0.06119891f, -0.11177236f, -0.01889579f, 0.01043488f, -0.15104675f, -0.00348663f, -0.07157516f, 
    -0.21792693f, -0.22603808f, -0.01693784f, -0.04929738f, 0.18797210f, 0.01196577f, 0.02142093f, -0.04145580f, 
    0.06923454f, -0.01880044f, -0.06009757f, -0.10847913f, 0.06913476f, 0.01306604f, -0.06584799f, 0.04548275f, 
    0.09166010f, 0.07523081f, 0.15445346f, 0.03169436f, -0.00965123f, -0.03592928f, 0.11848649f, 0.01641105f, 
    -0.06830643f, -0.00435259f, -0.03960975f, -0.06915916f, -0.19821909f, -0.06241425f, 0.01129230f, 0.01689162f, 
    -0.02274680f, -0.08456565f, 0.10553441f, -0.00361646f, -0.10347123f, -0.03541981f, 0.01841675f, -0.06534484f, 
    -0.05610065f, -0.05387466f, -0.19288278f, -0.06966788f, -0.02032315f, 0.01323875f, 0.06352374f, 0.02811900f, 
    -0.00107788f, 0.08194850f, 0.06357545f, -0.01009096f, -0.02608548f, -0.08761528f, -0.01017935f, -0.18143329f, 
    -0.00815660f, 0.10900140f, -0.14999953f, 0.12442760f, 0.04045294f, 0.02844462f, 0.13743190f, -0.20166346f, 
    -0.16133769f, 0.02060417f, -0.06035608f, -0.14735678f, -0.05774340f, -0.04110664f, -0.04599184f, -0.04971441f, 
    -0.05869376f, -0.06105845f, 0.09697911f, -0.00425614f, 0.04941670f, 0.15733260f, -0.14184915f, -0.26022556f, 
    0.16559935f, -0.09555478f, 0.01648347f, 0.10469547f, -0.11789470f, -0.00842306f, 0.09660731f, -0.18390869f, 
    -0.04796809f, 0.18280424f, -0.17862879f, -0.11559191f, 0.15420118f, 0.07238880f, 0.07084939f, 0.14145276f, 
    -0.08660034f, -0.02014905f, 0.03193882f, 0.06036730f, -0.01379773f, 0.13004905f, 0.14481299f, -0.00300875f, 
    -0.00943406f, 0.04827746f, 0.00114034f, 0.08712950f, 0.06864920f, -0.03438395f, -0.01838190f, -0.12697127f, 
    0.20065129f, 0.23384972f, 0.10812512f, 0.08266428f, -0.01646147f, 0.08099209f, -0.04036164f, -0.10429397f, 
    0.05684791f, -0.02306110f, -0.12907986f, -0.11113682f, 0.17374632f, 0.08625732f, 0.19882631f, 0.13019915f, 
    0.02524763f, 0.10372977f, -0.06817183f, 0.02599606f, 0.03925380f, -0.12014952f, -0.04819027f, -0.16496654f, 
    0.51182193f, -0.41630942f, -0.13461787f, -0.03256266f, -0.23098187f, 0.08321323f, -0.04193556f, 0.04931153f, 
    0.07955968f, 0.04690648f, -0.04982061f, -0.00136251f, 0.07609925f, -0.11882292f, 0.03831600f, -0.12829922f, 
    -0.01655672f, -0.01966112f, 0.06556034f, 0.01839210f, -0.03038008f, -0.07420094f, -0.24519655f, -0.10001556f, 
    -0.54855621f, 0.19108751f, 0.01946042f, 0.00758982f, -0.16439879f, 0.08685932f, -0.06256521f, -0.06231164f, 
    -0.02165768f, 0.00139955f, 0.01434587f, -0.05510266f, -0.19061078f, 0.13877720f, -0.07242117f, 0.01294552f, 
    -0.10173638f, -0.04468573f, -0.05710423f, 0.03020252f, -0.07133009f, -0.03028093f, 0.05379218f, -0.01679656f, 
    0.22817260f, 0.21586756f, 0.21330249f, 0.10433123f, 0.00258513f, 0.03376287f, -0.02196232f, 0.04988136f, 
    0.00115972f, -0.04435345f, 0.01696936f, -0.00463579f, -0.12814431f, -0.09154242f, -0.05859580f, -0.02832637f, 
    0.02443488f, -0.02186376f, 0.02096682f, -0.04436606f, -0.01397339f, 0.10425235f, 0.08916865f, -0.00098955f, 
    0.02353513f, -0.03719135f, 0.02443977f, 0.01587453f, -0.02277625f, -0.04548831f, 0.04504967f, 0.03969239f, 
    0.00237601f, 0.03918013f, 0.02581449f, -0.05206278f, -0.00431964f, 0.00208553f, 0.00368759f, 0.02756281f, 
    -0.05810547f, 0.02480374f, -0.00785079f, 0.02798036f, 0.02402183f, -0.00994177f, 0.01469000f, 0.02735225f, 
    0.01382297f, 0.03020114f, -0.02384703f, -0.04788871f, -0.02189699f, -0.05420392f, 0.01876756f, -0.04406323f, 
    -0.00135091f, -0.02029319f, -0.05551006f, -0.01954519f, 0.00603509f, -0.04141837f, -0.00793450f, -0.03439499f, 
    0.02532996f, -0.02743849f, -0.00938750f, -0.02521549f, -0.03679677f, -0.00670257f, 0.00120518f, 0.01941560f, 
    -0.04995618f, -0.02450849f, -0.01764552f, 0.03317198f, 0.00146133f, 0.01868436f, -0.04391439f, 0.01873816f, 
    -0.00389171f, -0.02952170f, 0.02052132f, -0.00303619f, 0.04168760f, 0.01255945f, -0.00817158f, 0.01834375f, 
    -0.02949176f, -0.04608180f, -0.01427735f, 0.03283023f, -0.01911918f, -0.02115723f, 0.00525029f, -0.05198963f, 
    -0.05810713f, 0.01027411f, 0.04048611f, -0.01643815f, -0.00619025f, -0.01772893f, -0.03541787f, 0.03290011f, 
    -0.03277721f, -0.01014589f, 0.03960380f, -0.00711227f, -0.01250459f, 0.03618653f, 0.01189847f, -0.02005992f, 
    -0.03670810f, -0.02346316f, -0.01561677f, 0.00713761f, 0.00045652f, 0.01926241f, -0.00154924f, -0.04282109f, 
    -0.01330672f, -0.03860602f, 0.02434894f, -0.05238257f, -0.05196907f, -0.03992570f, 0.01578047f, 0.02919444f, 
    0.04189796f, -0.01288737f, -0.00206590f, 0.03623081f, -0.01779868f, -0.05168561f, 0.02007397f, 0.03819831f, 
    -0.01703245f, -0.03078066f, -0.02132767f, -0.03320768f, -0.05389211f, 0.00819365f, -0.04997032f, -0.03820171f, 
    0.01716927f, -0.04086781f, 0.01071266f, 0.00082042f, 0.00037724f, -0.01981075f, 0.02834467f, -0.05508513f, 
    0.00699499f, -0.00503943f, 0.02327709f, -0.01392558f, -0.00496675f, -0.04436643f, -0.01978016f, -0.05609720f, 
    0.00267093f, -0.00393792f, 0.03680020f, 0.02071132f, -0.03200552f, -0.02591100f, -0.05316371f, -0.04461193f, 
    0.00612543f, 0.03829919f, 0.02161225f, -0.02002582f, 0.00211148f, 0.02989329f, -0.01548502f, -0.02764884f, 
    0.02097887f, 0.01814733f, -0.04025296f, 0.02921572f, -0.05366981f, 0.03823675f, 0.02473950f, -0.02971739f, 
    -0.00883662f, 0.01775515f, 0.03565310f, -0.01041364f, 0.02705254f, -0.00380627f, 0.03098843f, -0.00106052f, 
    -0.01551073f, -0.03279960f, -0.04655302f, 0.00093499f, -0.01875987f, -0.05126221f, -0.00242898f, -0.01571724f, 
    -0.02970319f, -0.03394542f, 0.00601072f, -0.02173933f, 0.01997422f, 0.02951748f, -0.05316857f, 0.03044612f, 
    -0.01362418f, -0.03058615f, 0.05089032f, 0.04102004f, 0.03444628f, -0.03707992f, -0.03700136f, -0.04468310f, 
    -0.04006501f, 0.00731286f, 0.00596302f, 0.03895038f, -0.01228519f, -0.02143916f, -0.01552636f, -0.00317643f, 
    0.03779807f, -0.02046514f, -0.01844710f, 0.00428496f, -0.00876355f, 0.03091651f, -0.05368167f, 0.03527562f, 
    -0.01663071f, 0.01805052f, -0.01265028f, -0.01468215f, -0.01788346f, 0.00849209f, -0.04353202f, -0.03494013f, 
    0.01381158f, -0.02903360f, -0.00797261f, -0.01334628f, 0.00671772f, -0.03369484f, -0.04117792f, 0.01321371f, 
    0.00753638f, -0.00902708f, -0.01481041f, -0.00579058f, 0.01315040f, 0.01541293f, 0.01195581f, 0.01469037f, 
    0.02072087f, 0.02750453f, -0.02128304f, -0.04906521f, -0.00239199f, 0.02714581f, -0.03874023f, -0.04735515f, 
    0.03584908f, 0.03233865f, -0.00637889f, 0.02224599f, -0.04344214f, 0.00315297f, 0.00830217f, -0.04429485f, 
    0.02307446f, 0.02242189f, -0.02275318f, 0.00547505f, 0.03093240f, -0.05307459f, 0.00387645f, -0.03885304f, 
    -0.05985751f, -0.00619407f, -0.05029606f, 0.01641165f, -0.00658049f, 0.00144140f, -0.01140215f, -0.00023027f, 
    -0.01624798f, -0.03134869f, -0.01615928f, -0.03178561f, -0.04259713f, -0.01523359f, -0.04679410f, -0.01228578f, 
    -0.02768278f, 0.03516966f, 0.02250308f, -0.02408781f, 0.00611360f, 0.00301988f, -0.00835686f, -0.00264487f, 
    -0.00439707f, 0.02131669f, 0.02984340f, -0.03220422f, -0.02994104f, 0.02527224f, -0.03443510f, -0.05870572f, 
    0.03968459f, -0.03102933f, 0.01871509f, 0.02799693f, -0.04116065f, -0.03314389f, -0.03004334f, -0.03632911f, 
    -0.04147255f, -0.00275550f, -0.05128431f, 0.00145031f, -0.04760154f, 0.03496217f, -0.01206385f, 0.01173296f, 
    -0.05179457f, -0.05976665f, -0.02703092f, -0.04452470f, 0.03181328f, -0.04305685f, -0.03024186f, -0.00903375f, 
    -0.04286291f, -0.01320099f, -0.04398485f, -0.01800560f, -0.01407192f, 0.03709507f, 0.03186343f, -0.05635677f, 
    -0.01375060f, -0.02204596f, 0.03189185f, 0.01377624f, -0.00534181f, -0.05050812f, 0.03216848f, -0.04550853f, 
    -0.02567386f, 0.00734489f, 0.00259354f, -0.01071902f, 0.02016578f, 0.01531768f, -0.02019460f, 0.01508942f, 
    0.00711935f, -0.02732517f, -0.04828002f, 0.02180061f, -0.03564946f, -0.05153183f, 0.01922899f, -0.01813645f, 
    -0.00346690f, -0.03480644f, -0.03379004f, 0.03131084f, 0.03656007f, 0.01112630f, -0.02838162f, 0.01374945f, 
    -0.04911210f, -0.02796965f, -0.04938923f, -0.02870966f, 0.00125470f, 0.03554854f, -0.03279774f, -0.02223513f, 
    -0.01036116f, -0.03728722f, 0.01808857f, -0.00139449f, 0.02985492f, 0.01658694f, -0.03806600f, -0.00952071f, 
    -0.03921395f, -0.02513571f, -0.04543377f, 0.03588300f, 0.02793903f, -0.00636524f, 0.01150524f, 0.00476316f, 
    0.01776873f, 0.04301893f, 0.01962942f, -0.02931044f, -0.05640473f, 0.03484119f, -0.00319499f, 0.01311237f, 
    0.28454110f, 0.18586294f, 0.15929157f, 0.02094157f, 0.10545610f, 0.03121971f, 0.13244660f, 0.18686394f, 
    0.03144150f, 0.12528709f, -0.13869078f, -0.12326380f, 0.13740742f, 0.10891677f, -0.14554788f, 0.36807480f, 
    -0.01171183f, -0.03265160f, 0.06237114f, -0.12129780f, 0.08931714f, -0.08371803f, 0.08381772f, 0.09997723f, 
    0.22915497f, -0.03015795f, 0.39436126f, 0.28365222f, 0.00941449f, 0.03415443f, -0.03859959f, -0.11686765f, 
    -0.03616122f, -0.09958870f, 0.10008591f, -0.11518537f, 0.19465601f, 0.14430222f, -0.01034927f, -0.00101409f, 
    0.09103111f, 0.00409077f, 0.01442126f, 0.19805686f, 0.21035230f, 0.18698882f, 0.09217850f, 0.09468375f, 
    0.05080730f, 0.02402624f, -0.18549882f, -0.02773582f, -0.03922820f, 0.04884074f, -0.06585538f, -0.09084621f, 
    0.07070137f, -0.06534725f, -0.12248039f, 0.09324025f, -0.03948328f, -0.23152046f, -0.00266300f, 0.03765051f, 
    -0.10850397f, -0.09012932f, -0.11628129f, -0.11195304f, -0.04143593f, -0.09390409f, -0.07133077f, 0.03503189f, 
    0.19737396f, 0.10045488f, 0.31726277f, -0.08124799f, -0.11355709f, 0.01481966f, 0.01390742f, -0.07451654f, 
    0.06852220f, 0.04950746f, 0.05595218f, 0.07552338f, 0.35899913f, -0.07297479f, 0.10243017f, -0.13000092f, 
    0.09540365f, -0.04060741f, 0.13490720f, -0.07939767f, -0.03725583f, -0.17716940f, -0.06685612f, -0.23292390f, 
    -0.16666496f, 0.23832071f, -0.15342584f, 0.14374343f, -0.02195140f, -0.07799304f, -0.01929613f, -0.19235000f, 
    0.20674592f, 0.08365153f, -0.03489925f, 0.02612112f, -0.06732003f, 0.04346198f, 0.19898881f, -0.37418917f, 
    -0.00891459f, 0.12464358f, -0.00147448f, 0.00106768f, -0.05003878f, -0.09677134f, -0.14687355f, -0.19594637f, 
    0.08878466f, -0.14747380f, 0.15181199f, 0.12488024f, 0.00608227f, 0.16415244f, -0.10470286f, -0.27153179f, 
    -0.18411571f, -0.09949780f, -0.10751400f, -0.00802932f, 0.17562498f, 0.11840741f, -0.02472952f, -0.12064423f, 
    0.06040050f, 0.10181540f, 0.03929911f, 0.17418867f, -0.02594174f, -0.01431396f, -0.00018232f, 0.08388745f, 
    -0.31015998f, -0.00839219f, -0.24004668f, 0.04286735f, 0.22508487f, 0.10264472f, -0.00822672f, 0.11044177f, 
    -0.14763917f, -0.28070483f, -0.14158221f, -0.27580908f, -0.17353661f, -0.14687692f, 0.14788705f, -0.07973855f, 
    0.21081373f, 0.13478070f, -0.10080408f, 0.02528122f, -0.21200347f, -0.28781280f, -0.15738481f, -0.47971842f, 
    -0.01412546f, 0.03073934f, -0.23185554f, 0.15423737f, 0.01153513f, 0.01751379f, 0.09732860f, 0.25140584f, 
    0.23389451f, 0.26213714f, 0.15505607f, 0.16715072f, 0.04714912f, 0.23860154f, 0.10633021f, -0.07124551f, 
    0.18447183f, 0.03803017f, 0.05150563f, 0.21646972f, -0.03969183f, 0.01649425f, -0.20069064f, -0.04824057f, 
    0.11245445f, 0.27395567f, 0.00011773f, 0.19871800f, -0.01226177f, -0.06625152f, 0.02950857f, 0.05045111f, 
    0.16898781f, 0.04614588f, 0.15250123f, 0.13095412f, -0.32203558f, 0.21721770f, 0.04849713f, 0.07979011f, 
    0.18998113f, 0.00913865f, -0.09366594f, -0.09205192f, 0.10707899f, -0.04204807f, 0.02361766f, -0.04025878f, 
    -0.17656952f, 0.22077665f, 0.00288221f, 0.30415493f, 0.06249472f, 0.08230684f, 0.05044637f, -0.07613678f, 
    -0.11895560f, -0.01322226f, 0.01430115f, -0.13783851f, -0.10697088f, 0.01590526f, -0.02076013f, 0.00921468f, 
    -0.15983513f, -0.04486481f, 0.03918582f, -0.36266848f, -0.27538046f, 0.08078676f, -0.27313495f, -0.25213853f, 
    0.20573680f, -0.13191789f, -0.17495506f, 0.15308130f, 0.00861093f, -0.06064285f, 0.04097384f, 0.00904548f, 
    0.26023072f, 0.17247976f, 0.17394263f, 0.18331595f, -0.01595252f, 0.49787483f, 0.11429999f, 0.35123372f, 
    0.06382558f, 0.01865814f, 0.03925306f, 0.09555832f, 0.02238272f, -0.02681819f, 0.00200977f, -0.03021750f, 
    -0.06660413f, 0.34169665f, -0.18297073f, 0.19709475f, 0.12197075f, 0.01737514f, -0.09057514f, 0.06468404f, 
    -0.13152353f, -0.10805158f, -0.03500013f, -0.38599461f, 0.05502615f, -0.02041427f, 0.15486664f, 0.01008327f, 
    0.04176738f, -0.02197647f, -0.05590520f, -0.03292597f, 0.14690247f, 0.10525880f, 0.07030470f, 0.17267972f, 
    0.01043604f, 0.06198559f, 0.05756792f, -0.14928660f, -0.05070716f, 0.03545283f, -0.04376169f, -0.05933523f, 
    0.01389397f, 0.07699565f, -0.02128027f, 0.12296763f, 0.21252695f, 0.12627536f, -0.12840463f, 0.12195916f, 
    0.03513009f, 0.04029898f, -0.16573673f, 0.11682134f, -0.07349624f, -0.19102687f, -0.10078043f, -0.21350916f, 
    -0.39083681f, -0.12373772f, -0.18263672f, 0.16774476f, 0.07674765f, -0.26018447f, -0.10744853f, 0.30216610f, 
    -0.04735821f, 0.04755507f, -0.11241085f, -0.02883521f, -0.02762171f, -0.03166588f, -0.04610868f, 0.10859298f, 
    0.04932956f, -0.00915046f, -0.07887980f, -0.12490015f, 0.17426926f, 0.00236432f, 0.08120143f, 0.10922448f, 
    0.02012649f, -0.12173583f, 0.08789946f, -0.22817986f, -0.01055490f, -0.00899378f, -0.10570642f, -0.15194668f, 
    -0.02883025f, -0.04057550f, 0.09117947f, -0.08910041f, -0.08040651f, -0.06822419f, -0.05650461f, 0.24289294f, 
    -0.01021717f, -0.03890678f, 0.02768104f, -0.39066038f, 0.00097597f, -0.03293586f, -0.17151527f, -0.04905720f, 
    0.21011807f, 0.14325275f, 0.13019630f, 0.13346374f, 0.07498340f, 0.07590269f, 0.06383393f, 0.16895373f, 
    -0.00124876f, -0.00937371f, 0.11399290f, -0.02533523f, 0.07562160f, -0.07209907f, -0.10016893f, 0.01277666f, 
    0.05363641f, 0.01896350f, 0.01920461f, -0.11567426f, 0.31554356f, 0.02332199f, 0.15079589f, -0.02961771f, 
    -0.10240566f, -0.12295073f, -0.17416120f, -0.05331330f, 0.12536754f, 0.09911142f, -0.02896507f, -0.09587602f, 
    0.00935378f, -0.04738313f, 0.04611219f, 0.05105402f, 0.01835652f, -0.07553977f, 0.36927837f, -0.11303887f, 
    -0.06527113f, -0.02740763f, -0.02448919f, 0.04814887f, -0.09139984f, 0.00963611f, -0.02868477f, -0.04806316f, 
    0.17788231f, 0.27819133f, 0.42632845f, -0.16001235f, 0.06481536f, -0.07437465f, 0.03511290f, -0.07514811f, 
    0.01075625f, 0.01642592f, -0.00150279f, 0.00619598f, 0.10407353f, -0.01735446f, -0.10372166f, -0.07897327f, 
    0.07169540f, 0.12602401f, 0.22048496f, 0.04951217f, -0.07320429f, -0.05519442f, -0.00668157f, -0.04798009f, 
    -0.07280497f, -0.17910923f, -0.02287268f, 0.07714416f, 0.15333374f, 0.09620333f, 0.11183404f, 0.03952987f, 
    -0.05259512f, 0.08555573f, -0.00469298f, 0.02222815f, -0.26574102f, 0.10521179f, -0.07524038f, 0.29261446f, 
    -0.02488582f, 0.15579271f, -0.10655522f, -0.04795956f, 0.13549589f, 0.09381270f, -0.03018490f, 0.04255353f, 
    -0.06626898f, 0.05525826f, -0.23064414f, 0.09649719f, 0.00645465f, 0.08651688f, 0.08969771f, 0.05947806f, 
    -0.08118831f, -0.03840514f, 0.05625440f, 0.05033345f, -0.10930444f, 0.04556569f, -0.22681253f, -0.10058293f, 
    -0.04279403f, 0.07092562f, 0.18795063f, 0.06928127f, 0.04748802f, -0.08972800f, 0.06227650f, 0.04720045f, 
    0.22763707f, -0.20482266f, 0.11062783f, 0.31640196f, 0.03236999f, 0.05094646f, 0.04181020f, 0.31214496f, 
    -0.13387041f, 0.12007284f, 0.15357824f, 0.03473269f, 0.03217933f, 0.27490550f, -0.20567276f, 0.14967653f, 
    0.09348844f, 0.10833294f, 0.08890802f, 0.06371675f, 0.03003616f, 0.03004855f, 0.07228237f, 0.07164975f, 
    0.11479816f, -0.02320459f, 0.11848810f, -0.17248608f, -0.07168125f, -0.19090515f, -0.14857720f, -0.01831033f, 
    -0.07222582f, -0.07659859f, -0.00732349f, -0.04411995f, 0.06889015f, 0.26708177f, -0.17386647f, 0.12257783f, 
    -0.00518427f, -0.03301151f, 0.12395144f, -0.11571766f, -0.04521073f, 0.02890973f, 0.02756455f, 0.08075310f, 
    0.04394796f, -0.07862934f, 0.04650803f, -0.06693373f, 0.05331724f, -0.00375034f, -0.03512895f, -0.04639516f, 
    0.10542802f, 0.15472855f, 0.08664316f, 0.11212642f, 0.08621877f, 0.01222632f, -0.11781102f, 0.01513769f, 
    -0.03065585f, 0.02710044f, 0.00351910f, -0.11584228f, 0.00196749f, 0.04756040f, 0.13419135f, 0.11500949f, 
    -0.09034803f, -0.05353658f, -0.05434016f, -0.07081541f, 0.01631478f, -0.11175757f, -0.19670483f, -0.12935939f, 
    0.00144282f, 0.03904852f, -0.03697522f, -0.10280564f, 0.14777406f, 0.26058063f, 0.02018494f, 0.24240904f, 
    -0.17572160f, 0.02864961f, -0.01914002f, -0.03921255f, 0.05221799f, 0.00823561f, 0.03965038f, -0.05468565f, 
    0.00506428f, -0.12199204f, -0.04714052f, -0.07479156f, 0.02661176f, -0.01189772f, 0.02417449f, 0.04095590f, 
    0.13027430f, -0.10408869f, -0.02608376f, 0.03490898f, 0.08412062f, -0.18987773f, 0.12009849f, -0.11059838f, 
    0.08892859f, -0.01778525f, 0.19415848f, 0.21622302f, -0.04605822f, 0.09933310f, -0.03718225f, 0.03891730f, 
    0.04219558f, -0.04697729f, 0.05664093f, -0.22435252f, -0.07174522f, -0.03657195f, -0.13707995f, -0.11313282f, 
    -0.18111768f, -0.07000346f, -0.00770348f, 0.06074966f, -0.08158495f, 0.09589490f, -0.04623105f, 0.00513188f, 
    -0.11889880f, -0.01435065f, -0.06784139f, 0.05445063f, -0.03067164f, -0.02336775f, 0.15801269f, 0.17030738f, 
    -0.01804787f, -0.08500057f, -0.12028444f, -0.10627772f, -0.03762369f, 0.00448002f, 0.04419783f, 0.03068923f, 
    -0.09135447f, 0.01852409f, -0.10894956f, -0.00758353f, -0.24343173f, -0.30667517f, 0.11785447f, 0.14620559f, 
    -0.00252656f, 0.11925045f, -0.05901476f, -0.04122046f, -0.13847139f, -0.00113816f, -0.08103117f, -0.01627428f, 
    -0.05341405f, -0.33522394f, 0.05660504f, 0.07599300f, -0.01071968f, 0.07307233f, -0.07345869f, 0.00981492f, 
    0.08944781f, -0.02409130f, 0.02863907f, 0.04070740f, 0.00865574f, -0.03373857f, 0.05332645f, -0.08017752f, 
    0.14100356f, 0.08488867f, 0.05835210f, 0.10226267f, -0.03188568f, -0.06304926f, -0.00279478f, -0.01650453f, 
    0.04739881f, 0.14779429f, -0.01024420f, -0.05391636f, 0.15821280f, -0.04111079f, 0.10932425f, 0.12344758f, 
    0.00002739f, 0.02326182f, 0.06492431f, 0.03066537f, 0.03645002f, 0.12120152f, -0.07266930f, 0.03400087f, 
    0.08760505f, 0.15750220f, 0.04564109f, -0.02402762f, 0.02196697f, 0.12979937f, 0.06414722f, 0.14166804f, 
    -0.31848347f, 0.25220764f, 0.11577905f, 0.01734337f, -0.05249681f, -0.03900772f, 0.11296866f, -0.00296416f, 
    0.10616744f, 0.13128683f, 0.01833885f, 0.05916327f, 0.10347790f, -0.08749558f, -0.11993094f, 0.39084822f, 
    -0.00458622f, 0.08804861f, -0.05925496f, 0.19238098f, 0.01099567f, 0.07769154f, 0.22152562f, -0.00583255f, 
    0.37406087f, -0.11429551f, -0.06457184f, -0.07988957f, 0.16930316f, 0.03065385f, 0.07459769f, 0.12180112f, 
    0.07303542f, 0.00064581f, 0.08214864f, 0.20002191f, -0.19232853f, -0.08248267f, -0.10969102f, 0.04693069f, 
    -0.07893596f, 0.05139303f, 0.04950428f, 0.04924730f, 0.21216926f, 0.16018783f, 0.00826575f, 0.19566582f, 
    0.05322467f, -0.07760974f, -0.02904085f, -0.00138094f, 0.01445983f, 0.11111644f, 0.01610993f, -0.15795556f, 
    0.07382650f, 0.02763789f, -0.04740189f, 0.05356043f, -0.24176042f, -0.12855379f, -0.06399217f, -0.13972235f, 
    -0.11324246f, -0.04821709f, -0.06745140f, -0.04540345f, -0.14112394f, 0.05069312f, 0.06381994f, 0.08878515f, 
    0.19011186f, 0.12709948f, -0.07460719f, -0.06779060f, -0.06502698f, -0.14371935f, 0.03642996f, 0.10155059f, 
    -0.07744827f, -0.01043619f, -0.03479397f, -0.05949179f, 0.08626543f, -0.04998999f, 0.13632905f, -0.03388036f, 
    -0.17279676f, -0.05610149f, 0.03023785f, 0.00246086f, -0.00705407f, 0.12166738f, 0.11204024f, -0.00433647f, 
    -0.12307186f, 0.43328983f, -0.02715502f, -0.02743599f, 0.06142320f, -0.03788566f, 0.11391967f, -0.02295623f, 
    -0.08231504f, -0.01184101f, 0.01275404f, 0.02800190f, 0.35351571f, 0.10731230f, 0.09949253f, 0.08415002f, 
    0.07932952f, 0.01556171f, 0.03869143f, -0.04578051f, 0.06776384f, -0.02019718f, 0.09239934f, 0.08661912f, 
    0.28290582f, 0.21552128f, 0.13436475f, -0.04722332f, 0.03191268f, 0.17664042f, 0.03317334f, -0.06471837f, 
    -0.17335403f, -0.05160569f, 0.02324025f, 0.01452257f, 0.09523830f, -0.08731113f, -0.06614008f, 0.16845538f, 
    -0.03034747f, -0.10765669f, -0.02132824f, -0.03251867f, -0.19489665f, -0.03037211f, 0.05069827f, -0.08840869f, 
    -0.01332469f, 0.12238130f, -0.11244415f, 0.08757272f, -0.04925079f, 0.02004324f, 0.02054997f, 0.10678139f, 
    -0.03878166f, 0.16899198f, 0.08034075f, 0.05007010f, -0.16812153f, 0.09562961f, -0.04428605f, -0.02789622f, 
    0.04455244f, 0.02637115f, 0.01476943f, 0.04006075f, -0.07330458f, -0.02039001f, 0.03608013f, -0.10674226f, 
    -0.08529709f, 0.11812268f, 0.23444355f, -0.21577184f, -0.02169498f, 0.01260248f, 0.10057935f, -0.12978509f, 
    0.11867482f, 0.02641582f, 0.01346503f, 0.16397682f, -0.08689708f, 0.12433667f, -0.23312020f, 0.07108705f, 
    0.01586553f, 0.03404357f, -0.16267790f, -0.02707500f, -0.07118518f, -0.12719575f, 0.01696051f, -0.12101066f, 
    0.23061717f, 0.03048352f, -0.04887580f, 0.14023070f, -0.04195190f, 0.06020198f, -0.03153876f, -0.09090470f, 
    -0.02728495f, 0.00225042f, 0.03273918f, -0.09067580f, 0.20470525f, -0.03784705f, -0.15001464f, 0.17943797f, 
    0.12245644f, 0.03738976f, 0.00543426f, -0.09530445f, -0.05788111f, 0.07586023f, 0.09413438f, 0.02651722f, 
    0.12713011f, -0.18406719f, 0.09453150f, -0.06679862f, 0.09874795f, 0.08232433f, 0.05652739f, -0.06261373f, 
    -0.03020039f, -0.04354475f, 0.01247379f, -0.11832616f, -0.06371247f, 0.01313646f, 0.01669721f, 0.04648560f, 
    -0.03941334f, 0.06116482f, -0.12909594f, -0.10804428f, -0.08042951f, -0.04956429f, -0.04262645f, -0.14789332f, 
    -0.06755356f, -0.06366623f, 0.04841802f, 0.02162951f, -0.11200472f, -0.03465094f, 0.04443640f, -0.01773326f, 
    0.08337576f, -0.03426613f, 0.11888122f, 0.10386581f, 0.08763906f, 0.00184085f, -0.13179852f, -0.03019966f, 
    0.03925603f, 0.12460423f, 0.05993705f, -0.09773967f, -0.05901743f, -0.09605660f, -0.08228061f, -0.04121857f, 
    0.05655063f, -0.12570974f, -0.04891668f, -0.04939154f, 0.04135288f, 0.09259915f, -0.00660289f, 0.13205013f, 
    -0.05433716f, 0.14229529f, -0.11868258f, 0.05407166f, -0.07935020f, 0.02062054f, 0.16539894f, -0.20162325f, 
    0.04251112f, 0.15117246f, 0.06284700f, -0.03838939f, 0.07933827f, -0.11137607f, -0.02662370f, -0.13634604f, 
    0.18837707f, 0.15653135f, 0.06180657f, -0.07895528f, 0.04631421f, 0.19132195f, 0.04191510f, -0.07633970f, 
    -0.05392985f, -0.00774422f, -0.06794386f, 0.15182805f, 0.14625333f, 0.14830998f, 0.02073961f, 0.08978121f, 
    0.06917941f, 0.00940984f, 0.05651662f, -0.02299615f, -0.06577156f, -0.08592896f, -0.07067718f, 0.16439648f, 
    -0.07456411f, 0.03531574f, -0.07039861f, 0.01162148f, 0.03055441f, -0.01568545f, -0.03954013f, 0.02484110f, 
    0.00138755f, 0.06626145f, 0.06409045f, 0.13672490f, 0.17535529f, 0.00110907f, 0.00141738f, 0.09936280f, 
    -0.10820746f, 0.01078695f, -0.04332295f, 0.04873933f, -0.09683772f, -0.00553896f, 0.07295021f, 0.14128520f, 
    0.26984406f, -0.02570827f, -0.08329672f, -0.00742748f, 0.02671615f, 0.09134018f, -0.02903868f, 0.08709937f, 
    -0.03920377f, 0.10541034f, -0.11417994f, -0.09192546f, -0.02689494f, 0.14041489f, 0.09102633f, -0.09989914f, 
    0.08815853f, 0.02720647f, -0.04783368f, -0.08888557f, -0.11452523f, 0.13259615f, 0.03133943f, 0.06837057f, 
    0.13423343f, 0.16972324f, -0.24542923f, 0.09786694f, 0.12301628f, 0.08101604f, 0.06713498f, -0.11355615f, 
    -0.02844925f, 0.03267734f, 0.10081872f, -0.03504489f, 0.17333023f, -0.01328287f, -0.02327704f, 0.08496074f, 
    0.04938028f, -0.09436303f, -0.11895665f, 0.06805640f, -0.00219811f, 0.02458214f, -0.11596689f, -0.02009832f, 
    -0.01237584f, 0.00478261f, -0.07323953f, 0.17843838f, -0.03569362f, -0.06739105f, 0.07973584f, 0.06008701f, 
    -0.07667478f, -0.04606828f, 0.02385313f, 0.01239831f, 0.24534252f, -0.21943566f, 0.06928943f, -0.00624120f, 
    -0.04531170f, -0.02218249f, -0.02573780f, 0.09735101f, -0.00424740f, 0.03703666f, -0.02649697f, 0.03417319f, 
    -0.16997345f, -0.17243573f, 0.22502947f, -0.20295328f, 0.12221017f, 0.00250386f, 0.05438956f, -0.03330349f, 
    0.03710129f, 0.12792569f, 0.06723002f, -0.12211093f, 0.10329973f, 0.19891068f, -0.15057053f, 0.09643105f, 
    -0.01796146f, -0.08469710f, 0.10613154f, -0.04404041f, 0.02080863f, 0.13447383f, 0.00932578f, 0.10370673f, 
    0.04253949f, -0.02461614f, -0.11394645f, 0.01719394f, -0.07652386f, -0.07326429f, -0.05995994f, 0.06425878f, 
    -0.09150171f, 0.09920613f, -0.10784395f, -0.04474930f, -0.02187599f, 0.09264706f, -0.06272773f, 0.02419608f, 
    0.01159479f, 0.01342545f, 0.03211399f, -0.01694432f, 0.17974854f, 0.10809030f, -0.08196498f, -0.05466954f, 
    -0.05103841f, -0.03453301f, -0.05647697f, 0.02107238f, -0.00790950f, 0.03946578f, 0.03823155f, -0.01138168f, 
    0.02422297f, -0.03830428f, 0.00616182f, 0.02994113f, 0.03854996f, -0.02606759f, 0.00893552f, -0.04829089f, 
    0.02159658f, -0.05503503f, -0.04541484f, 0.01517656f, 0.03945570f, -0.05264029f, -0.05675043f, 0.03045416f, 
    0.01359942f, -0.02852647f, 0.00360625f, 0.01098031f, 0.03660977f, -0.04571133f, 0.01305554f, 0.03689972f, 
    0.04140794f, -0.01612607f, 0.02456884f, -0.00391059f, -0.03418544f, 0.02753107f, -0.04362069f, -0.01847704f, 
    -0.01318314f, -0.01540629f, 0.01669697f, -0.04202073f, -0.03833009f, -0.01623008f, -0.01255653f, -0.03890060f, 
    0.02119691f, -0.02778136f, -0.02106323f, -0.00036486f, -0.03428047f, -0.02824222f, 0.01957008f, -0.05229386f, 
    -0.03289559f, -0.04430231f, 0.04298208f, -0.04177270f, -0.00724394f, 0.01478059f, -0.00527131f, 0.03451468f, 
    0.04355995f, -0.00849337f, -0.05076455f, 0.04147974f, -0.05525553f, -0.03278426f, -0.05543136f, 0.02220765f, 
    -0.03901156f, -0.02949184f, -0.04528247f, 0.01065944f, 0.00473885f, -0.00751529f, -0.00620072f, -0.00922322f, 
    -0.04177720f, 0.01325955f, -0.05439802f, -0.02190701f, -0.03374514f, 0.02001390f, 0.03289511f, 0.01137637f, 
    -0.00317257f, -0.00937653f, 0.02818669f, 0.01267088f, 0.01863183f, 0.00978893f, -0.02979078f, 0.00000878f, 
    0.01440982f, -0.05689278f, 0.02869410f, -0.00043190f, 0.03254086f, 0.05082183f, 0.04151779f, -0.02969685f, 
    0.02204748f, -0.01143225f, 0.03397887f, -0.00549653f, -0.02680430f, -0.01606236f, 0.04951328f, 0.04167904f, 
    -0.03334752f, -0.05197604f, 0.04395768f, -0.05330268f, -0.00123508f, -0.05595621f, -0.02976094f, 0.02541813f, 
    -0.02968629f, -0.04728919f, 0.02157883f, -0.00583602f, 0.04425836f, -0.00547739f, -0.04779585f, -0.00562439f, 
    -0.01806150f, 0.01330024f, 0.02789801f, -0.05193437f, -0.01023707f, 0.02688902f, -0.02993099f, -0.04422136f, 
    -0.00864450f, 0.03633426f, 0.03302122f, -0.02592842f, -0.00191460f, -0.04799621f, 0.04184074f, 0.01460432f, 
    -0.04692984f, -0.00276498f, 0.01300983f, 0.02506126f, 0.04821685f, -0.04709344f, 0.02706912f, -0.05339903f, 
    -0.01973293f, 0.02629155f, 0.00659262f, -0.00431699f, -0.03210348f, -0.04552716f, -0.02520255f, -0.04892474f, 
    -0.04723645f, -0.02404275f, -0.02032481f, -0.04283576f, -0.04865712f, 0.01028565f, 0.04074863f, -0.02223519f, 
    0.00077597f, 0.03898020f, 0.01555271f, -0.04399386f, -0.00686204f, -0.01707295f, -0.05231832f, -0.00609886f, 
    0.03585781f, -0.04405711f, 0.01558227f, -0.00397906f, 0.02403041f, 0.00844745f, 0.00857579f, 0.02847736f, 
    -0.01219167f, 0.04485083f, -0.00344991f, 0.01832961f, 0.02030836f, -0.02663551f, 0.02597469f, -0.03750836f, 
    0.04836192f, -0.04493568f, 0.01769722f, 0.00242033f, 0.02095263f, 0.03095578f, 0.02196490f, -0.02679205f, 
    -0.04195091f, -0.00406386f, -0.01352898f, -0.04093117f, -0.00420712f, -0.03015363f, -0.00921086f, 0.03330863f, 
    0.03351275f, -0.04842562f, -0.05011331f, 0.03445455f, -0.01416526f, 0.00102500f, 0.01132966f, -0.04237925f, 
    -0.02934993f, -0.03967905f, -0.03608357f, -0.02391192f, 0.03744366f, -0.03500676f, -0.03665854f, -0.04610569f, 
    0.03184417f, 0.00123325f, 0.02064353f, 0.03204453f, -0.05579939f, 0.04029349f, -0.03121907f, -0.00991541f, 
    0.00527995f, -0.00988308f, -0.03009810f, -0.01430166f, -0.03310702f, 0.03965868f, 0.03036476f, 0.02493709f, 
    0.01855318f, -0.04510747f, 0.01211734f, -0.00226001f, -0.04246772f, -0.05170198f, 0.02709064f, 0.03969020f, 
    -0.05111743f, 0.03002824f, -0.02862513f, 0.02358308f, -0.03329562f, 0.03578113f, -0.04079432f, -0.02550282f, 
    -0.03199414f, -0.04536816f, 0.01887146f, 0.04029978f, -0.01922248f, -0.02988020f, -0.02844449f, -0.05235290f, 
    -0.03151067f, 0.02772753f, -0.00828157f, 0.00064042f, 0.03426399f, 0.02506378f, -0.01181882f, 0.01253707f, 
    0.03705901f, -0.02965697f, 0.01269153f, -0.02752959f, -0.01468856f, -0.02893233f, 0.02617252f, 0.00018693f, 
    0.04099556f, -0.04478430f, -0.01207787f, -0.02659065f, -0.01571458f, -0.00379631f, -0.01867814f, 0.00508936f, 
    -0.03491759f, 0.02722401f, 0.00528007f, -0.00542135f, -0.02698892f, -0.03020662f, 0.03672362f, -0.04283029f, 
    -0.04252603f, -0.03248806f, 0.03710767f, -0.00768516f, -0.01877463f, -0.04065678f, -0.00013607f, 0.01246765f, 
    0.00594788f, -0.02486032f, -0.05464949f, -0.03879693f, -0.02656747f, -0.01889749f, 0.01035254f, -0.04245948f, 
    -0.03241909f, -0.04486258f, 0.02571850f, -0.05466444f, -0.02189435f, -0.03474218f, -0.02070244f, -0.04779942f, 
    0.00805174f, 0.00004233f, 0.01400230f, -0.01585977f, -0.03556027f, -0.00482984f, -0.04824222f, 0.03530159f, 
    -0.05194597f, -0.04397029f, -0.04952267f, 0.04283895f, -0.03810109f, 0.01598769f, -0.05342695f, 0.01422782f, 
    0.03230775f, -0.02525408f, -0.01089502f, 0.00749888f, -0.02724703f, 0.03562870f, -0.00294106f, -0.03271993f, 
    -0.05579840f, -0.02438765f, -0.00272339f, -0.02654940f, -0.03673361f, 0.00855268f, -0.00429426f, 0.03113981f, 
    -0.02261372f, -0.00655231f, 0.03045869f, -0.00861170f, -0.04046499f, 0.00797275f, -0.03992035f, 0.00507630f, 
    -0.00305914f, -0.04955857f, -0.03266246f, 0.03753414f, -0.01856832f, 0.02622910f, 0.02412513f, -0.04953037f, 
    -0.02666762f, 0.03913372f, 0.03613341f, -0.02041193f, 0.04552070f, -0.04303041f, -0.03430040f, -0.01449933f, 
    0.01080014f, 0.00364026f, -0.01050112f, 0.01983994f, 0.04608648f, -0.02259136f, 0.04632830f, 0.04995093f, 
    -0.02700647f, -0.03595765f, -0.05771271f, -0.02026935f, 0.03993941f, -0.03045458f, 0.03862999f, -0.00898225f, 
    0.02986418f, 0.02544377f, 0.02566797f, -0.01651835f, 0.00993690f, -0.02119602f, 0.02403852f, 0.01967902f, 
    -0.00571527f, 0.00359080f, 0.02795125f, -0.05744965f, 0.01449143f, 0.02020010f, -0.04068820f, -0.04982578f, 
    0.03226940f, -0.03264014f, -0.01934248f, -0.02647291f, 0.02954707f, -0.01282327f, -0.00721106f, 0.02207814f, 
    -0.02044757f, -0.03000092f, 0.02104995f, -0.02054130f, 0.00567547f, 0.03811555f, 0.00311618f, 0.01819828f, 
    -0.02035215f, -0.01417457f, 0.00232102f, -0.02905721f, -0.02703200f, -0.00661769f, -0.04218599f, 0.00484655f, 
    -0.00486726f, -0.05979515f, -0.02190975f, -0.03190931f, -0.02723681f, -0.01108719f, 0.01607885f, -0.01078149f, 
    0.02102196f, -0.02260718f, -0.02503412f, 0.03388341f, 0.03074703f, 0.01031723f, 0.03638530f, 0.00648923f, 
    0.01099613f, 0.03242069f, -0.05625929f, -0.04024696f, 0.04044088f, -0.01205396f, 0.04067059f, -0.04133896f, 
    -0.02431035f, 0.00290466f, -0.02150672f, -0.01267599f, -0.05606676f, 0.02619134f, -0.01506733f, -0.05188008f, 
    -0.05119605f, -0.05030710f, -0.01360131f, 0.02714650f, -0.02496205f, -0.02395789f, 0.00910904f, 0.01211708f, 
    -0.03499144f, -0.04610062f, -0.04333324f, -0.03933487f, -0.03561454f, 0.01720922f, -0.05924018f, -0.03930027f, 
    0.02255220f, -0.00355739f, -0.04749649f, -0.02094017f, -0.02540980f, 0.03409574f, -0.00187953f, 0.02753417f, 
    0.02792407f, 0.00041771f, -0.05184412f, 0.03435798f, 0.04168263f, 0.02680028f, 0.01948555f, 0.00888759f, 
    -0.03511641f, 0.03959733f, 0.01178363f, 0.00483492f, 0.01045859f, -0.01383609f, 0.01402041f, 0.03203040f, 
    0.01160472f, -0.01540426f, -0.02925416f, -0.05044245f, -0.04238125f, -0.06218605f, -0.05109784f, -0.05715621f, 
    0.02506274f, -0.05609871f, 0.02217568f, -0.04440981f, 0.02096721f, 0.00132747f, -0.00936903f, 0.02656403f, 
    0.00760991f, -0.00636631f, 0.00411138f, -0.01742292f, 0.00767241f, -0.05837145f, 0.01433745f, 0.02295269f, 
    -0.01422403f, 0.00692599f, 0.02430180f, 0.04245289f, -0.04181012f, -0.03249998f, -0.04036117f, -0.02283963f, 
    -0.02256249f, -0.05783344f, 0.03200103f, -0.01257916f, 0.03138189f, -0.00404201f, -0.05421036f, -0.00537404f, 
    0.04253647f, -0.00923499f, -0.04038673f, -0.01901881f, -0.03032866f, -0.04724256f, -0.05808526f, -0.02569739f, 
    -0.04865269f, -0.00519035f, 0.01341714f, 0.02772260f, 0.02228549f, 0.03354747f, -0.01329193f, -0.03831444f, 
    -0.02929552f, 0.03385935f, 0.02360640f, -0.05225768f, -0.03868749f, -0.02756811f, -0.03973679f, -0.03928168f, 
    -0.02982558f, -0.04418392f, -0.04665783f, -0.00423032f, -0.01173568f, -0.01329562f, -0.05851461f, -0.00130222f, 
    0.01473891f, 0.00698291f, 0.00558933f, 0.04045465f, -0.01488050f, 0.04007383f, 0.00056686f, -0.04188095f, 
    -0.01894359f, 0.02431409f, 0.02909181f, -0.01867398f, 0.00839620f, 0.01320641f, -0.00257040f, 0.00917157f, 
    -0.00951187f, 0.01132661f, 0.02848256f, -0.00872960f, -0.05491877f, 0.00610510f, 0.04062828f, -0.03066882f, 
    -0.00624951f, -0.03538169f, -0.02643602f, -0.03693268f, -0.00756393f, 0.03668745f, -0.05430555f, 0.03577860f, 
    -0.03441661f, -0.05465274f, -0.00956054f, 0.04351650f, -0.02228842f, -0.00368085f, -0.04851247f, -0.02608148f, 
    0.01943243f, 0.02533887f, 0.03569018f, 0.03212691f, -0.02222593f, 0.03626600f, 0.00097098f, -0.00180991f, 
    0.00699824f, 0.02520642f, -0.00948727f, -0.05342208f, 0.01128243f, -0.03452718f, -0.03240514f, -0.04302452f, 
    0.01395131f, -0.02118842f, 0.03819861f, -0.01339204f, 0.00197364f, 0.03714307f, 0.03083891f, 0.01139612f, 
    -0.02726453f, 0.02119654f, 0.02811673f, -0.01562202f, -0.04626546f, 0.01359897f, 0.03823076f, 0.00704104f, 
    0.01307728f, -0.03853675f, -0.04764478f, -0.05965004f, -0.03976362f, 0.01503495f, -0.05144101f, 0.00270354f, 
    -0.03121628f, -0.01194998f, 0.01663049f, 0.00648910f, -0.01773891f, -0.05485630f, -0.02233406f, -0.02834783f, 
    -0.04084615f, -0.00442781f, -0.05894699f, -0.03374188f, -0.00876489f, -0.04921303f, -0.06040277f, 0.00476484f, 
    -0.05262281f, 0.01828008f, -0.00781835f, 0.02901512f, -0.05083188f, -0.04119133f, -0.04250569f, -0.03252415f, 
    0.02888769f, 0.03565520f, 0.03838728f, -0.04657545f, -0.05832834f, -0.00491526f, -0.05280373f, -0.02250832f, 
    0.02072487f, 0.03585020f, -0.04919837f, -0.04528658f, -0.04726968f, -0.02667136f, -0.05389221f, 0.02874108f, 
    0.01785290f, 0.02977660f, 0.02008361f, 0.00976444f, 0.03325674f, -0.04646704f, 0.00608712f, 0.00389009f, 
    -0.04510133f, 0.01789069f, -0.00853714f, -0.01273290f, -0.02674488f, -0.03264871f, 0.00244001f, -0.03819159f, 
    -0.05312416f, 0.01911270f, -0.00819951f, 0.03312184f, -0.00320130f, 0.03263555f, -0.04978672f, -0.02567245f, 
    -0.00494055f, 0.03838807f, -0.05124627f, -0.00409490f, -0.00345256f, -0.00643193f, 0.02824863f, -0.02692659f, 
    -0.00146753f, 0.04129155f, 0.01629430f, -0.04645802f, 0.01468072f, 0.03831992f, 0.02070712f, -0.02954084f, 
    0.02092960f, 0.01179179f, -0.02394144f, 0.01179988f, 0.03676978f, -0.01633197f, 0.03859897f, 0.02454300f, 
    0.02890970f, 0.01186673f, 0.02562750f, -0.03147547f, -0.02471461f, -0.02204104f, -0.04820991f, -0.02039000f, 
    -0.00727528f, -0.00578502f, 0.03302741f, 0.03315233f, -0.04042460f, 0.01038813f, -0.02764199f, 0.02897559f, 
    0.00914161f, -0.03401560f, 0.03662529f, -0.02590021f, -0.03046222f, -0.05093072f, -0.04489193f, 0.00525543f, 
    0.19182774f, 0.12793598f, 0.01632590f, 0.11931924f, 0.00128629f, -0.06899362f, 0.13896976f, 0.15647599f, 
    -0.03147901f, 0.09783745f, -0.01504675f, -0.20858632f, 0.23093848f, 0.07118192f, 0.00983163f, 0.23031518f, 
    -0.14733003f, 0.03587348f, 0.05643808f, -0.01507927f, 0.12619685f, 0.03776001f, 0.27954656f, 0.06764297f, 
    0.24985307f, 0.09511228f, 0.14624928f, 0.19958264f, -0.03091479f, 0.07624794f, 0.06590122f, -0.14368953f, 
    -0.16115314f, -0.08808048f, 0.10117446f, 0.03928915f, 0.25812152f, 0.08601106f, -0.00629210f, 0.09246420f, 
    0.06121934f, -0.02359967f, 0.08075485f, 0.13008690f, 0.14409907f, 0.23220588f, 0.21800314f, 0.13614227f, 
    0.03927487f, -0.00620789f, -0.04249435f, 0.03469262f, 0.02060268f, 0.07786524f, -0.03631693f, -0.15002422f, 
    -0.10302205f, -0.07693247f, -0.02077079f, 0.13631274f, -0.18031847f, -0.10611003f, -0.11876353f, 0.25177735f, 
    0.04200066f, -0.06969276f, -0.05762232f, -0.17725286f, -0.10799498f, -0.03144374f, 0.05850201f, 0.01002304f, 
    0.20212971f, 0.07622821f, 0.07829650f, 0.05866701f, -0.03839061f, -0.01036423f, -0.04060895f, -0.08049095f, 
    -0.06227747f, 0.17538190f, 0.11379650f, 0.07530033f, 0.08600765f, -0.18351552f, -0.05262332f, -0.16033420f, 
    -0.02470420f, -0.03850390f, -0.04494848f, -0.04656240f, -0.20040688f, 0.02371308f, -0.11119624f, -0.25106084f, 
    -0.01419881f, 0.07147127f, -0.09444468f, 0.11977652f, 0.07636960f, 0.05768898f, -0.09751286f, -0.21627846f, 
    0.13864082f, 0.02799395f, 0.10939252f, 0.07786927f, 0.06172756f, -0.12572114f, 0.03132621f, -0.24312356f, 
    0.01515588f, -0.02515819f, -0.12772062f, 0.06699596f, -0.14014477f, -0.15571804f, 0.00035703f, -0.23404106f, 
    0.08183573f, -0.28825328f, -0.11929753f, 0.25446871f, -0.16719525f, 0.17560908f, -0.13451691f, -0.23545225f, 
    -0.17732076f, -0.24811438f, -0.14306523f, -0.20702206f, 0.18659559f, -0.00959510f, -0.03686481f, -0.03557760f, 
    0.09524029f, 0.12826139f, 0.05335512f, 0.11409958f, 0.02086977f, 0.05040869f, 0.11397070f, 0.21551178f, 
    -0.09301602f, -0.25392061f, -0.13001570f, 0.00377079f, 0.14530905f, 0.15949862f, -0.09483239f, -0.01226739f, 
    -0.19765417f, -0.31325465f, -0.14258312f, -0.36220923f, 0.01966245f, -0.06877868f, 0.20332937f, -0.16608141f, 
    0.10675761f, 0.06710564f, -0.21615896f, 0.12174231f, -0.32805571f, -0.25812835f, -0.28050104f, -0.49623135f, 
    0.03809194f, 0.10737479f, -0.07314080f, 0.15311337f, -0.18805678f, 0.00325375f, 0.10754801f, 0.13569346f, 
    0.26191005f, 0.13192977f, 0.13704842f, 0.08299097f, 0.14746742f, 0.14514200f, -0.03799641f, -0.01325419f, 
    0.19494683f, 0.08763110f, 0.08174977f, 0.14820664f, -0.11038718f, -0.08673221f, -0.18754795f, -0.12647048f, 
    0.10771495f, 0.05954535f, 0.02558692f, 0.15893957f, -0.00285762f, 0.06307985f, -0.00420016f, -0.05523146f, 
    0.09796756f, 0.07504844f, 0.11430447f, 0.20299998f, -0.20205681f, 0.04700672f, -0.00677201f, -0.07276864f, 
    0.05386990f, 0.15734731f, -0.16783015f, -0.09794070f, 0.22804081f, -0.04693193f, 0.06638848f, -0.06713844f, 
    -0.19666131f, 0.06114200f, -0.28431073f, 0.30660942f, 0.10667771f, 0.09923737f, -0.11815663f, -0.19588195f, 
    -0.02409884f, 0.00038206f, 0.00239363f, -0.17457463f, -0.07647032f, 0.03236094f, -0.22758229f, 0.11054881f, 
    -0.00975927f, -0.19025561f, 0.07775921f, -0.34658134f, -0.36735663f, -0.03782043f, -0.22343738f, -0.20832829f, 
    -0.09876828f, 0.02360423f, -0.13285644f, 0.16359809f, -0.00695308f, -0.06364620f, -0.05105802f, -0.03292725f, 
    0.28834584f, 0.15054275f, 0.23514442f, 0.25749886f, -0.00247062f, 0.32974809f, 0.17192313f, 0.32068494f, 
    -0.07606763f, 0.06763800f, 0.09688722f, -0.00625865f, 0.14388677f, -0.08582602f, 0.10735144f, 0.09376998f, 
    0.06358062f, 0.28307068f, -0.31347698f, 0.07541336f, -0.03846811f, -0.07464807f, -0.11168323f, 0.04775744f, 
    0.02497923f, -0.00641802f, -0.02523057f, -0.51151848f, 0.05168620f, 0.17874715f, 0.05394350f, 0.16610305f, 
    -0.14051765f, -0.00445736f, -0.00595368f, -0.09717564f, 0.06619836f, 0.09081320f, 0.07027616f, 0.41316122f, 
    0.03037576f, 0.06299615f, -0.02523109f, 0.15359432f, -0.08899699f, 0.01371295f, -0.00698259f, -0.01672427f, 
    -0.06664859f, -0.00972911f, 0.09768090f, 0.18194826f, 0.09682620f, -0.02984812f, -0.14766283f, 0.11344399f, 
    0.10032672f, 0.02168979f, 0.05118064f, 0.04903989f, -0.08987863f, -0.07945864f, -0.02131106f, -0.17389373f, 
    -0.45556945f, -0.31123623f, -0.19532707f, 0.06869925f, 0.00438256f, -0.04498200f, -0.04375222f, -0.09497076f, 
    -0.04829109f, -0.13482940f, -0.09362507f, 0.04234013f, -0.09322739f, -0.12784170f, -0.02878373f, 0.20466322f, 
    0.01181947f, 0.03739152f, 0.05058041f, -0.07994909f, 0.15668368f, 0.04232758f, 0.19406219f, -0.01913214f, 
    0.01245513f, -0.24516380f, 0.08760814f, -0.20267072f, 0.00514452f, -0.10508244f, -0.10654952f, -0.09206747f, 
    -0.03891401f, -0.04879859f, 0.13656099f, -0.09786853f, -0.21335039f, -0.03369284f, -0.26550129f, 0.23460302f, 
    0.01547999f, -0.15779760f, -0.07087436f, -0.27900332f, -0.12961018f, -0.15467873f, -0.08550309f, 0.07406362f, 
    0.09052359f, 0.06595278f, 0.16045603f, 0.13155568f, 0.00513445f, 0.10183734f, 0.07217881f, 0.20995811f, 
    -0.15554374f, -0.01687811f, 0.06722856f, 0.04823811f, -0.05893677f, -0.26975289f, -0.15356328f, -0.14737904f, 
    -0.08074742f, -0.12384116f, -0.03883251f, -0.35556516f, 0.09832080f, 0.01403023f, -0.10897861f, -0.03956760f, 
    -0.27629361f, -0.14206012f, -0.10975897f, -0.03642390f, -0.12838683f, 0.03266056f, 0.00427968f, -0.17201585f, 
    -0.13767016f, -0.04013012f, 0.00044696f, -0.01441603f, 0.27351916f, -0.08709390f, 0.11889669f, -0.10396814f, 
    -0.09521881f, -0.06601109f, -0.00573287f, -0.06125482f, 0.00844082f, 0.06751235f, 0.12738338f, 0.02407110f, 
    -0.20532525f, 0.29655170f, -0.22142947f, -0.09676288f, -0.04235407f, 0.20980527f, 0.05586167f, -0.03693663f, 
    -0.04268502f, -0.02969880f, -0.00475960f, 0.08306289f, 0.03202912f, -0.16437487f, 0.06893942f, 0.11503573f, 
    -0.06507705f, -0.04676002f, -0.09441116f, -0.15734650f, -0.02498502f, 0.02169578f, -0.02937886f, -0.06615815f, 
    -0.08328251f, 0.25550884f, 0.33300415f, 0.21795972f, 0.07875746f, 0.02573983f, -0.00681951f, -0.01986766f, 
    -0.25162572f, -0.10704354f, 0.02194419f, -0.11977088f, 0.19047557f, 0.18988267f, 0.06552397f, 0.18911447f, 
    0.14263727f, -0.03033109f, 0.02587517f, -0.00565726f, 0.06617755f, 0.06957812f, 0.02910260f, 0.02688240f, 
    -0.06408379f, -0.02625342f, -0.41732287f, 0.18844666f, 0.08268530f, 0.06678900f, 0.03910204f, 0.11376324f, 
    0.11124168f, 0.11645180f, -0.04009144f, 0.01419595f, -0.26370242f, -0.08640136f, -0.04221066f, 0.01315898f, 
    -0.00765361f, -0.00389794f, 0.03797280f, 0.15448733f, -0.07946818f, 0.05869087f, 0.09392243f, 0.00851971f, 
    0.39532161f, -0.15490487f, 0.19519354f, -0.19824018f, 0.26287425f, 0.06231297f, -0.05401542f, -0.02015009f, 
    -0.00858185f, 0.01387763f, 0.07014655f, 0.11117668f, -0.06449641f, 0.08720264f, -0.22559205f, 0.34241423f, 
    0.07741069f, -0.08859678f, -0.07908700f, 0.10636780f, -0.16568923f, -0.02155448f, 0.06859682f, 0.01322739f, 
    0.12512490f, 0.13958763f, 0.02974278f, 0.11993131f, -0.03641764f, 0.03875383f, 0.02670443f, 0.08846553f, 
    0.02109525f, 0.00948527f, 0.02695917f, -0.01154179f, -0.17821373f, -0.14572184f, 0.05810773f, 0.20917358f, 
    0.15530242f, 0.10103544f, 0.05099063f, -0.15631409f, -0.06928414f, 0.03264973f, 0.06004061f, -0.01515109f, 
    0.28092572f, -0.21375428f, 0.16112615f, -0.00646989f, 0.03338589f, -0.02762205f, -0.03664592f, -0.04592130f, 
    -0.08009540f, 0.10285201f, -0.02335678f, -0.03680861f, -0.01663488f, -0.02378081f, 0.03984883f, 0.07298702f, 
    -0.10289596f, 0.18461613f, -0.05965400f, -0.05410990f, -0.14165002f, 0.05981724f, -0.06402779f, -0.01335219f, 
    0.13801880f, -0.10660570f, 0.07703205f, -0.08591399f, -0.05597250f, 0.03800930f, 0.05790350f, -0.01276832f, 
    0.26797307f, -0.04914327f, 0.05821660f, 0.05031484f, -0.09605313f, -0.18490547f, -0.16212247f, 0.12545277f, 
    -0.09172183f, 0.05471731f, 0.05324727f, -0.12360931f, -0.04229237f, -0.04825858f, -0.05820132f, -0.12043858f, 
    -0.03982740f, -0.37025791f, 0.03708528f, -0.06605234f, 0.03184408f, 0.14179073f, -0.12944736f, 0.02035663f, 
    0.03007713f, 0.21051574f, -0.12128693f, 0.18171328f, 0.08091917f, -0.10868124f, 0.02471490f, -0.10742357f, 
    -0.04435896f, 0.24618007f, -0.04022573f, 0.09619488f, 0.04396276f, -0.12781674f, -0.03923361f, -0.14743328f, 
    0.19353659f, 0.02168385f, 0.06538063f, -0.01065217f, 0.09002442f, -0.00632552f, -0.10941026f, -0.00680064f, 
    -0.01395504f, -0.04322007f, -0.04718815f, 0.12194505f, 0.15853718f, 0.06713815f, -0.03565084f, 0.15026617f, 
    0.06472575f, -0.06718792f, 0.03889335f, 0.07870065f, -0.04502911f, -0.13706109f, 0.05692621f, 0.19073962f, 
    -0.04543852f, -0.03579376f, -0.02314297f, -0.10096200f, -0.07773868f, -0.05198172f, -0.08713323f, -0.05628334f, 
    -0.08975460f, 0.06083669f, 0.03074666f, 0.11526420f, 0.11244496f, -0.14830801f, 0.02007735f, -0.07049932f, 
    -0.08782136f, 0.09529263f, -0.12281176f, -0.23531219f, 0.04544955f, -0.04942427f, -0.00652310f, 0.10591198f, 
    0.20668116f, -0.11193796f, 0.07163766f, 0.05962180f, -0.00856206f, -0.05964718f, 0.12687650f, 0.00349232f, 
    -0.10039320f, 0.07904837f, -0.03094345f, 0.07369083f, -0.18243282f, 0.26133570f, -0.06191789f, 0.07884592f, 
    -0.14192928f, -0.00896622f, 0.05908414f, -0.01725929f, -0.08920455f, 0.12078300f, 0.13270433f, 0.05022513f, 
    -0.03156158f, 0.09206482f, -0.24335323f, 0.31322113f, 0.03093716f, 0.10053803f, 0.04388836f, 0.05342554f, 
    -0.02152116f, 0.05307420f, 0.10286243f, 0.08647678f, -0.03314269f, -0.16578683f, 0.12709685f, 0.09852427f, 
    -0.01908884f, -0.00747321f, 0.06852849f, -0.07656933f, 0.03843051f, 0.07314118f, -0.05574541f, -0.15231843f, 
    0.38042292f, 0.01125664f, 0.21407017f, -0.11406232f, 0.02864496f, 0.00695503f, 0.03575100f, -0.15920804f, 
    0.22015190f, 0.01101623f, 0.22991452f, 0.09032985f, 0.30895725f, 0.12562928f, 0.33681431f, -0.11230583f, 
    -0.10517404f, 0.01452539f, -0.12212323f, 0.04258906f, 0.05607288f, 0.15823874f, -0.01066983f, -0.17565137f, 
    -0.13805915f, 0.01594471f, 0.06205354f, 0.18902993f, 0.15082225f, -0.02547745f, 0.12860537f, -0.09592345f, 
    0.00692230f, 0.17476706f, 0.06337442f, 0.06884646f, -0.04917029f, 0.13622072f, -0.04239216f, 0.03134679f, 
    0.03229296f, -0.00140563f, 0.02210158f, 0.14244419f, -0.03460260f, -0.10260481f, 0.15238360f, -0.01238586f, 
    -0.17640240f, -0.08075733f, -0.11577329f, -0.09189484f, 0.01261857f, 0.10591184f, -0.02788233f, -0.06801534f, 
    -0.02186712f, 0.00342833f, -0.11155911f, 0.01954344f, -0.04312022f, 0.00601717f, 0.02939548f, 0.07194129f, 
    -0.00990242f, 0.05348307f, 0.05693307f, 0.04133342f, -0.05327037f, -0.03143701f, -0.12329855f, -0.01285694f, 
    0.11103594f, 0.13230257f, 0.16670248f, 0.14348255f, 0.01963410f, 0.08565820f, -0.02711772f, 0.03453348f, 
    0.00947376f, -0.00788354f, 0.00835725f, 0.04317356f, 0.21238101f, 0.14294502f, 0.03498248f, 0.16318253f, 
    0.01082530f, -0.05997293f, -0.06988354f, 0.02814801f, 0.01610148f, -0.12930557f, 0.00154794f, 0.07304171f, 
    0.29627785f, 0.04452909f, 0.21329987f, 0.13200003f, 0.26266491f, -0.03282641f, -0.01745740f, -0.01704529f, 
    -0.03201055f, -0.02459652f, 0.09503327f, -0.03905435f, -0.04892100f, 0.10557037f, -0.10102874f, 0.02073408f, 
    -0.07550025f, 0.03803203f, -0.09934566f, 0.06323266f, 0.03962791f, -0.07182310f, -0.03272591f, -0.04116423f, 
    -0.48689044f, -0.14961234f, -0.22473715f, -0.15272731f, -0.04767491f, -0.04831336f, 0.07678825f, -0.15048613f, 
    -0.06878431f, -0.10690565f, -0.00377959f, -0.04388755f, -0.07697016f, -0.14608124f, -0.05534469f, -0.14737207f, 
    -0.07357790f, 0.01233058f, 0.09049848f, 0.14457437f, -0.05301379f, 0.02501938f, -0.10341446f, 0.07045890f, 
    0.05481170f, -0.07227452f, 0.08085147f, 0.05246240f, 0.03795921f, 0.03253713f, -0.00264675f, 0.05233433f, 
    0.12047020f, 0.07195558f, -0.00327739f, 0.00970378f, -0.06710847f, -0.11605152f, -0.05563359f, -0.02198578f, 
    0.11575394f, 0.05300833f, 0.04115618f, -0.02774167f, -0.00890315f, 0.02020535f, -0.01224860f, -0.02443370f, 
    -0.31620321f, -0.24105339f, 0.24128719f, -0.22704616f, 0.13501136f, 0.04498461f, 0.03323831f, 0.15873384f, 
    -0.12262315f, 0.00685421f, 0.11460878f, -0.04294991f, 0.12990022f, -0.10165495f, 0.16326354f, 0.04226202f, 
    0.03377490f, 0.11551352f, 0.14025737f, -0.04461745f, -0.00414034f, 0.04435824f, 0.02575254f, 0.01667185f, 
    0.38225463f, 0.27312517f, 0.24726179f, 0.01322138f, 0.02324570f, -0.02415461f, -0.08984707f, -0.04914969f, 
    -0.02425606f, -0.02216060f, -0.04934167f, -0.04673369f, -0.06789320f, -0.01292544f, 0.31898564f, -0.15634064f, 
    0.09827170f, 0.09632888f, 0.13632450f, 0.06333353f, 0.06582788f, 0.00079890f, 0.04727473f, -0.07226183f, 
    -0.05763412f, -0.00128898f, -0.00285833f, -0.04082903f, 0.18162097f, 0.21592872f, -0.03421343f, -0.02174086f, 
    0.02655878f, 0.07355899f, 0.04498949f, 0.00616055f, 0.03022256f, -0.05462917f, 0.02925442f, -0.01574886f, 
    0.10723123f, 0.00867990f, -0.05440659f, -0.09170494f, -0.03244097f, 0.07127693f, -0.08231779f, 0.00980294f, 
    -0.05770143f, 0.05372149f, -0.01817667f, -0.00334213f, -0.02943362f, 0.01821974f, -0.01553146f, 0.08236499f, 
    0.00689596f, -0.12511180f, 0.00335370f, 0.02150794f, 0.03572107f, -0.09722182f, 0.05676644f, 0.01254731f, 
    0.05871249f, -0.03418617f, -0.02714767f, 0.03596053f, 0.07640703f, 0.06937410f, -0.04482049f, -0.02985651f, 
    -0.35975054f, 0.06556094f, -0.12432497f, 0.09110345f, -0.07317515f, 0.10824594f, 0.06489140f, 0.09358572f, 
    -0.19405784f, -0.03754754f, -0.04265713f, -0.02816744f, -0.07803097f, -0.00349449f, 0.04016355f, -0.10195844f, 
    0.06924237f, 0.00843030f, 0.08615987f, 0.13794692f, -0.03565310f, -0.06647308f, -0.09717865f, -0.06209921f, 
    0.11984254f, 0.07521954f, 0.12170693f, -0.04965119f, 0.03428067f, -0.10057633f, -0.11713684f, -0.11732349f, 
    -0.08409323f, -0.04260370f, -0.00961216f, 0.04208583f, 0.22942105f, -0.02811462f, 0.01711393f, -0.06875701f, 
    0.01946222f, 0.01941191f, 0.01280409f, 0.06439682f, 0.08450583f, 0.06436704f, 0.11643817f, -0.06708702f, 
    -0.09258607f, -0.08678730f, -0.03516534f, 0.01352800f, -0.05848587f, -0.05907136f, -0.01255885f, -0.01475397f, 
    0.04993706f, -0.04134537f, 0.00098054f, 0.00780262f, 0.13710040f, 0.24502873f, 0.09803990f, 0.06244601f, 
    0.16161695f, 0.00240148f, -0.15151779f, 0.10363580f, -0.10946404f, -0.02411179f, -0.01051719f, -0.01928871f, 
    0.22040710f, 0.12931703f, -0.01409472f, -0.11398470f, 0.13484997f, 0.24394405f, 0.03694635f, 0.23267600f, 
    -0.08609389f, 0.11321564f, 0.00007694f, 0.03959611f, -0.15382971f, -0.25832391f, -0.10458641f, -0.12016369f, 
    0.13657601f, -0.07671906f, 0.06885100f, 0.08052783f, 0.13695954f, 0.06103636f, 0.13477544f, -0.21551982f, 
    0.10074670f, 0.00640213f, -0.07338046f, -0.04832398f, -0.05094322f, 0.03464689f, -0.06018312f, -0.05189855f, 
    0.05758209f, 0.02823245f, 0.06765345f, 0.06884766f, -0.04115146f, -0.05367622f, 0.00675275f, -0.01337413f, 
    -0.03601629f, 0.17191543f, -0.00863183f, 0.10789010f, 0.08929145f, 0.07253340f, 0.01999483f, 0.02248866f, 
    0.31859362f, -0.20289914f, 0.08791981f, 0.06867161f, -0.08349809f, 0.07863135f, 0.01682094f, 0.04269818f, 
    0.19062661f, 0.09214584f, 0.10260538f, 0.15150218f, -0.24200734f, -0.44647124f, -0.01230409f, -0.26647818f, 
    -0.00969375f, 0.04869749f, 0.06100060f, 0.13754648f, 0.01211610f, 0.05304160f, -0.05861711f, 0.01090131f, 
    -0.31584999f, -0.12824553f, 0.09108011f, -0.19444120f, 0.07145642f, 0.07203263f, 0.09092609f, -0.08320529f, 
    0.19782935f, 0.01010992f, 0.08793301f, 0.03758973f, -0.09582964f, 0.20360021f, -0.06277297f, 0.04372013f, 
    0.01233777f, -0.04858148f, 0.01272201f, 0.00656584f, 0.05239303f, 0.01116944f, 0.09891739f, 0.06094408f, 
    0.07017639f, 0.12964734f, 0.14724740f, 0.02528276f, 0.04200901f, -0.04172084f, -0.06835450f, -0.04138510f, 
    0.05915664f, -0.00697093f, 0.03466640f, 0.12178469f, -0.05451095f, -0.02954941f, -0.01483067f, -0.11239413f, 
    0.08498754f, 0.01116174f, 0.04498149f, 0.02424752f, 0.07664841f, 0.11726839f, 0.03049171f, 0.05196212f, 
    0.04697113f, 0.04688939f, -0.05236838f, 0.01081487f, 0.16983373f, 0.16856365f, 0.00120849f, 0.02465875f, 
    0.01605664f, -0.01928504f, 0.01961868f, -0.04580996f, -0.11492581f, 0.29307884f, 0.35994875f, 0.17232721f, 
    -0.02960902f, -0.06430097f, -0.00816721f, 0.00471982f, -0.14324021f, -0.14131440f, -0.24994718f, -0.03244261f, 
    0.31068993f, 0.15507090f, 0.52432221f, -0.16909797f, 0.10267377f, -0.08620770f, 0.01521572f, -0.08850340f, 
    -0.01516358f, -0.12928158f, -0.03939115f, -0.05573124f, 0.08497720f, 0.10394467f, -0.08757546f, -0.06255564f, 
    0.08641687f, 0.07582410f, 0.13879029f, 0.12888551f, -0.10938188f, -0.06875194f, 0.00160896f, -0.09890672f, 
    0.12946245f, -0.26321036f, -0.46041739f, -0.24547890f, 0.03410461f, 0.12510288f, -0.00615656f, 0.23915099f, 
    0.06133638f, 0.13207462f, -0.03124297f, -0.06513102f, -0.20514643f, -0.29695052f, -0.17059089f, 0.09220571f, 
    -0.03003980f, 0.02522677f, -0.01065424f, -0.00993463f, 0.15373915f, 0.08982708f, -0.03272302f, -0.00195999f, 
    -0.00732618f, 0.04734209f, 0.06459763f, -0.00959865f, 0.06636480f, 0.04671237f, 0.06107580f, 0.04892028f, 
    0.07355309f, -0.07008844f, 0.08095866f, 0.00631142f, 0.12499486f, 0.08855325f, -0.20393500f, -0.14972211f, 
    0.05986393f, 0.06906369f, 0.15255764f, -0.01483468f, 0.08859608f, 0.03207399f, 0.15582550f, 0.13653056f, 
    -0.27377167f, -0.13230877f, -0.08474937f, 0.27724686f, -0.05213269f, 0.00620857f, 0.05290413f, 0.13443971f, 
    -0.08961405f, 0.04831855f, 0.11137964f, -0.07567273f, -0.01633284f, 0.28499830f, -0.10615087f, -0.17893992f, 
    0.08678012f, 0.20199162f, 0.16582038f, -0.00247580f, 0.05991645f, 0.05875881f, 0.10608656f, -0.01809582f, 
    0.16603960f, 0.17469849f, 0.18132615f, 0.01117180f, -0.07203527f, -0.14095229f, -0.16021103f, -0.18517566f, 
    -0.05995487f, -0.03429580f, 0.00370977f, 0.02375565f, 0.29019967f, 0.15958425f, -0.12907799f, -0.03566216f, 
    0.10112216f, 0.00136629f, 0.07937253f, 0.06508215f, -0.02289733f, 0.01779017f, -0.01987906f, 0.08734649f, 
    -0.10565197f, 0.03786555f, -0.07259064f, 0.08573081f, 0.05345304f, 0.12854540f, 0.07564860f, -0.06443210f, 
    0.11684511f, 0.11487588f, 0.08662449f, 0.18246028f, 0.02020390f, -0.01436668f, -0.07021555f, -0.03321630f, 
    0.11032604f, 0.00517035f, 0.11808199f, -0.11099604f, 0.02783981f, 0.13009341f, 0.15597375f, 0.11486231f, 
    -0.09064019f, 0.08745790f, 0.09108408f, 0.09402931f, -0.02285093f, -0.04127539f, -0.18203221f, -0.09374274f, 
    -0.19628939f, -0.00442955f, -0.17959288f, -0.03361619f, 0.18539208f, 0.27962849f, 0.10343721f, -0.08569092f, 
    0.11104160f, 0.05402809f, 0.01676858f, -0.00050567f, -0.00943676f, 0.01271744f, 0.03644536f, 0.01680485f, 
    0.00883182f, -0.10778552f, -0.11420753f, 0.03742702f, 0.10383909f, 0.05635691f, 0.04259764f, 0.22056651f, 
    -0.03374040f, -0.10174923f, -0.02111930f, -0.07329659f, -0.09663840f, -0.12837265f, 0.05095953f, -0.20423661f, 
    0.08140181f, -0.07387328f, 0.21438837f, 0.10042748f, -0.01070680f, 0.10189079f, -0.02588879f, 0.02217776f, 
    -0.11798813f, 0.06570899f, 0.13026035f, -0.13643527f, -0.08588843f, -0.19048110f, -0.06499872f, -0.08044086f, 
    -0.00305270f, 0.03437424f, 0.01284532f, 0.00629018f, -0.08326571f, 0.24179128f, 0.06780350f, -0.02883158f, 
    -0.11711036f, 0.01322418f, -0.03121322f, -0.01992864f, 0.04677913f, 0.09159634f, 0.10520037f, 0.10707066f, 
    0.03577842f, 0.04939582f, -0.00684988f, -0.01548371f, -0.07109334f, -0.01840566f, -0.05862764f, 0.01669961f, 
    -0.11518599f, -0.03913251f, -0.14740711f, -0.22033443f, -0.15994178f, -0.08665774f, 0.09502488f, -0.03602082f, 
    0.09734162f, -0.04161657f, 0.00502327f, 0.19983225f, -0.19525056f, -0.02405190f, -0.09610721f, -0.17155415f, 
    -0.17595078f, 0.05413250f, -0.06323229f, 0.05194746f, 0.09562072f, 0.02984299f, 0.05687181f, 0.08462641f, 
    0.09694272f, 0.12716831f, -0.00086442f, 0.01944695f, 0.10943093f, -0.09507960f, 0.11866127f, -0.13881487f, 
    0.25873834f, 0.06671237f, -0.07888032f, 0.03777958f, 0.00136498f, -0.12310513f, 0.00992072f, -0.15404314f, 
    0.12565807f, 0.05333352f, 0.07487375f, -0.13399525f, 0.09716614f, 0.00804634f, 0.12101713f, 0.00103074f, 
    0.04470318f, 0.02359374f, -0.07716703f, -0.10806633f, 0.09975098f, 0.02434471f, -0.09177593f, 0.03784779f, 
    0.13704824f, 0.15328033f, 0.14574790f, 0.15975930f, 0.11474325f, 0.01259563f, 0.04540762f, 0.22556785f, 
    0.11344390f, 0.14136449f, -0.10967799f, 0.23674814f, -0.07857346f, 0.02743828f, 0.08636303f, 0.01674745f, 
    0.01958248f, 0.14204179f, -0.09344413f, -0.01392209f, -0.02049227f, -0.25837445f, -0.27834982f, 0.15644133f, 
    -0.06827857f, -0.02654458f, 0.01232174f, 0.05217195f, -0.05768852f, 0.01872468f, 0.01217953f, 0.10250598f, 
    0.28365242f, -0.06389253f, -0.05031776f, -0.27865148f, -0.09112968f, 0.19606733f, -0.01561287f, 0.01306007f, 
    0.16533870f, -0.09317421f, 0.04076004f, 0.18598765f, -0.12810771f, -0.04410366f, 0.20047899f, -0.05879871f, 
    -0.09680820f, 0.03181699f, -0.09268790f, -0.15278237f, 0.18304305f, 0.07341143f, 0.09049267f, 0.12630032f, 
    0.14072472f, 0.05124162f, -0.03763942f, 0.11122194f, 0.06396095f, 0.06796849f, 0.03124521f, 0.03561863f, 
    -0.03898747f, 0.02540301f, -0.04734116f, -0.02818291f, -0.11121728f, -0.04646225f, 0.02023469f, -0.13447385f, 
    -0.03727207f, -0.04857550f, -0.02003600f, -0.16049886f, -0.00468107f, 0.04146137f, 0.13086697f, 0.10107476f, 
    0.09136449f, 0.03018553f, 0.13630140f, -0.07570593f, -0.02339523f, -0.05799473f, -0.05217606f, -0.14134549f, 
    0.02087688f, -0.01649384f, -0.09853493f, -0.02684735f, 0.21708077f, -0.23032071f, -0.05876321f, -0.11172229f, 
    -0.04753858f, -0.04470320f, -0.04107402f, 0.08718986f, -0.02826378f, -0.01017546f, 0.05853178f, 0.01139901f, 
    0.00592476f, -0.24305089f, -0.01727496f, 0.15305346f, 0.03471319f, 0.07699204f, 0.07086478f, 0.03243483f, 
    0.06409158f, -0.00780816f, -0.01962789f, -0.03492621f, -0.18203866f, 0.03147380f, -0.02276067f, 0.05485970f, 
    -0.03260913f, -0.05137888f, 0.08969446f, 0.13810328f, 0.04973097f, 0.06372102f, 0.06660853f, 0.08618745f, 
    -0.54475570f, -0.07374597f, 0.06384900f, 0.13977735f, 0.03428204f, -0.06034612f, 0.17038739f, -0.28590307f, 
    0.09694993f, -0.09496833f, -0.08503313f, 0.01355142f, -0.15412933f, 0.29304957f, 0.02707137f, 0.01082982f, 
    -0.07360880f, 0.04522762f, -0.03637741f, 0.05404432f, -0.00147342f, -0.13036363f, -0.05383320f, 0.02623404f, 
    0.08231281f, 0.12068779f, -0.01322906f, 0.14103410f, 0.01505750f, 0.01586647f, -0.06695396f, 0.02562327f, 
    -0.10560074f, 0.02561646f, 0.04768817f, 0.00348426f, -0.05093103f, 0.04569408f, 0.11446559f, 0.07728539f, 
    -0.01916868f, -0.00809763f, 0.05496961f, -0.06885143f, 0.15775450f, -0.06129023f, -0.11019720f, -0.11029222f, 
    0.24499476f, -0.06729097f, 0.21829386f, -0.23093344f, 0.04923819f, 0.11869972f, -0.02916331f, 0.20152612f, 
    0.16689700f, 0.10624071f, 0.06400257f, -0.14397848f, -0.00071137f, -0.07913232f, 0.19790334f, 0.07790282f, 
    0.06552323f, 0.04854949f, 0.04369013f, 0.03291276f, 0.04944080f, -0.05435529f, 0.01751640f, -0.04561492f, 
    0.07827532f, -0.12272839f, 0.07520577f, -0.09890887f, 0.02766250f, -0.02294671f, -0.07433418f, 0.11769349f, 
    -0.08942733f, -0.09594961f, -0.08527280f, -0.01953813f, -0.17449716f, -0.00096039f, 0.16547689f, -0.15690495f, 
    -0.12817721f, -0.06417843f, -0.00652687f, -0.11336594f, -0.01764653f, -0.01097359f, 0.00293383f, -0.06002678f, 
    0.02077877f, 0.02174687f, 0.05029559f, -0.12458871f, 0.03609312f, 0.09670272f, -0.05359368f, 0.15530130f, 
    0.03263904f, -0.03087906f, -0.08053727f, -0.00328580f, -0.04058799f, 0.03653646f, -0.03612597f, -0.03864997f, 
    0.05169820f, 0.01320679f, 0.06891713f, 0.12970316f, -0.00431503f, -0.08947253f, -0.08306074f, -0.06426292f, 
    0.06514216f, -0.01918278f, -0.12778962f, -0.09674256f, 0.08376738f, -0.06188821f, -0.03937286f, 0.01890069f, 
    0.08169734f, 0.02034413f, 0.10464872f, 0.08189233f, -0.08348661f, 0.09126618f, -0.03295261f, 0.24141608f, 
    -0.00249540f, -0.03731360f, -0.08297852f, -0.02022351f, -0.05585912f, -0.01922607f, -0.01727801f, 0.05698725f, 
    0.02141017f, 0.13603155f, 0.04714226f, -0.02709029f, -0.16066471f, -0.10926325f, 0.02381222f, -0.34344050f, 
    0.25486502f, -0.06552912f, 0.10559160f, 0.05109463f, 0.05396302f, -0.09539306f, -0.04091067f, 0.10361256f, 
    0.12330699f, -0.04374431f, -0.05819788f, -0.02459708f, 0.15622598f, 0.04565637f, -0.04279216f, 0.06792253f, 
    0.10135473f, -0.00993514f, 0.05589331f, -0.00278178f, 0.04724151f, 0.07949880f, 0.11333996f, -0.00643786f, 
    -0.10495608f, 0.01357193f, 0.03351169f, -0.07935018f, 0.08082490f, -0.10116176f, -0.14327671f, 0.06358328f, 
    0.00859966f, 0.07498060f, 0.03885123f, 0.08891996f, -0.09023340f, 0.05662211f, -0.09845730f, -0.11967040f, 
    -0.01915689f, -0.02642061f, -0.22162306f, -0.03226718f, 0.07419941f, 0.02261369f, 0.17560479f, -0.00382424f, 
    0.21343079f, 0.06275100f, 0.21532798f, 0.24806339f, 0.13945763f, -0.00722556f, 0.07269976f, 0.13398702f, 
    0.05626509f, 0.12731850f, 0.15536992f, -0.04392134f, 0.04065104f, -0.03617676f, 0.01251249f, 0.09402320f, 
    0.18239678f, -0.06315608f, 0.00694186f, -0.10000030f, -0.00814559f, 0.17318353f, -0.10322735f, 0.20106034f, 
    -0.00303101f, -0.05560443f, 0.00763815f, -0.10065719f, -0.09557500f, 0.08259666f, 0.05638031f, -0.01090279f, 
    -0.09931284f, -0.00711183f, 0.07540356f, 0.08876478f, 0.09848252f, -0.00326983f, 0.21584837f, 0.13747934f, 
    -0.18029051f, 0.08579930f, 0.16075648f, -0.07936204f, 0.02804500f, 0.02989770f, -0.02062799f, 0.03352878f, 
    -0.04958311f, -0.01104210f, 0.17949358f, 0.20228162f, -0.05580913f, 0.10620478f, -0.07873036f, -0.10746191f, 
    -0.00637634f, -0.01354981f, -0.12626785f, -0.11136729f, -0.07956898f, 0.01455341f, 0.05603908f, -0.19904333f, 
    -0.35261980f, -0.02353531f, 0.07853538f, -0.07256759f, 0.01760689f, -0.03971466f, 0.01561280f, 0.10267047f, 
    0.03172249f, -0.01138222f, 0.07939006f, 0.06217130f, 0.04257051f, 0.14168072f, -0.00191887f, -0.11563150f, 
    -0.09709819f, 0.10831417f, -0.00084019f, 0.00449272f, 0.07980561f, 0.06748489f, 0.18653141f, -0.03653296f, 
    -0.08777685f, -0.12502922f, 0.06925146f, 0.13279572f, 0.06799718f, 0.09957419f, -0.10863583f, 0.28770375f, 
    0.06567670f, -0.07619962f, 0.20695928f, 0.05642535f, -0.07211440f, 0.13153495f, -0.15540022f, 0.27000490f, 
    0.12701190f, -0.03096206f, 0.02200030f, 0.04667914f, 0.12859149f, 0.09588774f, -0.04680617f, 0.02136223f, 
    0.00620201f, 0.02495542f, 0.15509367f, -0.16908616f, 0.00427784f, 0.03532032f, 0.02915754f, -0.19198233f, 
    0.08693765f, -0.01898881f, 0.07003164f, 0.05506926f, -0.03542551f, -0.02176295f, -0.09672245f, -0.03665135f, 
    0.03510471f, -0.04800785f, 0.05942560f, 0.05226184f, 0.09173115f, 0.04633518f, 0.14903538f, -0.02760613f, 
    -0.05441842f, -0.02057117f, 0.16944762f, 0.17090791f, 0.08210561f, 0.05036494f, 0.05215772f, 0.11155001f, 
    -0.04357786f, 0.01048628f, -0.19097579f, -0.06600083f, 0.23120701f, -0.17622752f, 0.09570142f, 0.03850702f, 
    0.03842382f, -0.00558932f, -0.04041416f, 0.05867269f, 0.13364393f, -0.00421101f, 0.08858350f, 0.12345952f, 
    0.00205979f, -0.26503611f, 0.12929715f, 0.43114656f, -0.23247427f, -0.02755397f, -0.13432258f, -0.06128150f, 
    0.13141169f, 0.05177037f, 0.03851301f, -0.08827972f, -0.17766415f, -0.10603835f, 0.10146123f, 0.06384025f, 
    0.06979614f, -0.12502542f, 0.14614816f, 0.15188456f, -0.03987877f, -0.00471548f, 0.13477652f, 0.17491439f, 
    -0.18929152f, -0.09482168f, 0.06661009f, 0.13670710f, -0.03190595f, -0.15010044f, -0.08338600f, -0.02515187f, 
    0.07997862f, -0.17923453f, -0.03697432f, 0.10096467f, -0.13086124f, 0.21196339f, 0.21121562f, -0.20269158f, 
    -0.07442114f, -0.03108064f, -0.05724237f, -0.01790673f, -0.04103746f, -0.14340296f, -0.01208678f, 0.02225981f, 
    -0.16997990f, -0.02496357f, 0.18067540f, 0.05213308f, 0.05438720f, 0.00702762f, 0.04525631f, -0.03885037f, 
    0.01216463f, 0.06601416f, -0.05152645f, 0.04963775f, 0.16521972f, 0.07426155f, 0.06158320f, 0.06044737f, 
    0.27101788f, 0.02166801f, 0.04108300f, 0.01750018f, 0.18355916f, -0.23273918f, -0.15119952f, -0.19506449f, 
    0.03484619f, 0.32972467f, 0.04772641f, 0.06487400f, 0.02121181f, 0.08037738f, 0.04155573f, 0.04487080f, 
    0.11765668f, 0.18835860f, 0.05162600f, -0.02076213f, -0.13202548f, -0.03241750f, 0.37823489f, -0.12495697f, 
    0.10809060f, 0.12003545f, 0.00981593f, 0.05911657f, 0.02248606f, -0.07559953f, -0.07269545f, -0.01772428f, 
    -0.09109942f, -0.31598061f, 0.12809455f, -0.19401096f, 0.01325272f, -0.12816261f, -0.16364387f, 0.01371566f, 
    -0.05050441f, -0.01335390f, -0.09778558f, -0.06394651f, -0.16440029f, 0.18508713f, 0.05828069f, 0.02330384f, 
    -0.15326162f, -0.01571835f, -0.09140814f, 0.04516348f, 0.03916262f, 0.03079885f, -0.01686222f, 0.01605083f, 
    -0.17392042f, 0.17202891f, -0.20924352f, -0.06206386f, 0.06508011f, 0.11621854f, -0.00638373f, 0.13929488f, 
    0.05264174f, -0.05211491f, -0.10309787f, -0.13533141f, -0.07051434f, -0.07991092f, 0.03116689f, -0.06358790f, 
    0.20373796f, 0.01862312f, -0.01392360f, 0.16506109f, -0.07421871f, -0.26944858f, -0.03217439f, -0.14122394f, 
    0.02259708f, 0.02176761f, -0.18050845f, -0.03985839f, 0.05122386f, -0.03587883f, 0.04322952f, 0.09996137f, 
    0.33519769f, 0.13227692f, 0.02285097f, 0.14344251f, -0.16791436f, 0.15357894f, 0.21282087f, 0.18345207f, 
    -0.15437703f, -0.01240652f, 0.01347362f, 0.22434872f, -0.01585289f, 0.08584777f, -0.05582155f, -0.00061466f, 
    0.04856878f, 0.32738468f, -0.03586411f, 0.17983696f, 0.00501411f, -0.05890857f, 0.08351091f, -0.06167538f, 
    0.32095227f, 0.03861288f, 0.10894448f, 0.06967772f, 0.14565668f, 0.07835244f, -0.08779621f, 0.19071381f, 
    0.19865136f, 0.08520249f, 0.00563660f, -0.06161027f, -0.04159913f, 0.00222170f, -0.03925359f, 0.19520658f, 
    -0.27506888f, -0.10844989f, 0.08451232f, 0.02579294f, 0.09377591f, -0.03642891f, -0.07697211f, 0.01721764f, 
    -0.17856547f, -0.15489317f, -0.03966234f, -0.16766100f, -0.06106474f, 0.06426466f, 0.00330718f, -0.06276963f, 
    -0.08658998f, -0.12429164f, -0.00293546f, -0.14464998f, -0.14632256f, 0.00233104f, -0.20737806f, -0.09203479f, 
    0.23199084f, -0.17204526f, -0.21626413f, -0.05884283f, 0.06654530f, -0.02971629f, 0.16338678f, 0.00563576f, 
    0.27802262f, 0.00820402f, 0.06408759f, 0.09366252f, -0.02936706f, 0.06883177f, 0.07310117f, 0.29408213f, 
    0.13165610f, 0.04296916f, 0.11819728f, 0.05086518f, 0.13726768f, -0.05338231f, -0.04957994f, 0.13560431f, 
    0.06220299f, -0.04221126f, 0.21719177f, -0.11279351f, -0.01518284f, 0.08608545f, -0.15920509f, 0.01627094f, 
    -0.00715222f, -0.22648390f, 0.02493178f, -0.08152789f, 0.11292481f, 0.00409016f, 0.13728100f, 0.04730946f, 
    0.12009511f, -0.07763454f, 0.03795407f, 0.08329151f, 0.13233840f, -0.00338625f, 0.10907229f, 0.11927296f, 
    -0.28180689f, -0.03069150f, 0.24405268f, -0.01392779f, -0.02262429f, 0.03260859f, -0.04964377f, 0.20629053f, 
    0.03179128f, 0.04880218f, 0.13929470f, 0.19861335f, -0.05422796f, 0.29160422f, 0.01668188f, 0.03694620f, 
    0.02247224f, -0.09888540f, -0.09993690f, -0.10887928f, -0.08224067f, -0.07205072f, 0.02629368f, -0.06778011f, 
    -0.46308184f, 0.24793462f, -0.13486740f, -0.02342740f, 0.18037099f, -0.15197058f, 0.05455482f, 0.10441118f, 
    -0.06445020f, 0.07327931f, 0.00575401f, -0.01085985f, -0.03297901f, 0.30962870f, -0.11658529f, 0.10812742f, 
    0.06683224f, -0.02320691f, 0.03760902f, -0.05205297f, 0.17997828f, 0.05691142f, 0.28364173f, 0.03016094f, 
    0.26933292f, -0.04734715f, 0.03633418f, 0.08363304f, -0.01430282f, 0.12916368f, -0.12710686f, 0.14428948f, 
    -0.11164980f, -0.07724435f, -0.01634012f, 0.04751218f, 0.07835728f, -0.19716299f, -0.06766797f, -0.05282478f, 
    0.04878655f, 0.00862384f, -0.05037080f, -0.02945827f, 0.01361322f, 0.03728000f, -0.09166341f, -0.00570589f, 
    -0.03370310f, 0.01154816f, 0.17979103f, 0.22122172f, 0.02036452f, -0.07214769f, 0.07230972f, -0.00093985f, 
    0.12035640f, -0.07577565f, 0.03871953f, -0.08765128f, 0.00428142f, -0.18361647f, -0.16005191f, -0.09198183f, 
    0.00165533f, 0.13436754f, -0.03017515f, 0.15991983f, 0.06939900f, -0.08066827f, 0.21799961f, 0.02330713f, 
    0.15989657f, 0.10482009f, -0.02716432f, -0.12860221f, 0.11598019f, 0.01831456f, 0.13225339f, 0.11847757f, 
    0.01527539f, 0.08252332f, -0.00878139f, -0.03181322f, -0.16013531f, -0.08155456f, -0.42202437f, 0.23621604f, 
    -0.09260402f, -0.06031530f, 0.09294374f, -0.11230858f, 0.09464136f, 0.02895154f, 0.02189783f, -0.02970124f, 
    -0.26442659f, -0.17751090f, -0.12424435f, 0.16350715f, -0.17576012f, 0.07935178f, -0.04152394f, 0.05352572f, 
    -0.00000663f, 0.01692390f, -0.04359132f, -0.07004898f, -0.02299834f, -0.07068403f, 0.05842772f, -0.03071529f, 
    0.12844217f, 0.03849232f, 0.13557529f, 0.05762959f, -0.06896373f, 0.02758888f, 0.04821155f, -0.02605798f, 
    0.02688151f, 0.10222279f, 0.01444128f, 0.07853766f, -0.16350698f, -0.16392384f, 0.00887145f, -0.04559069f, 
    0.00349387f, -0.06904780f, -0.19733275f, -0.00380301f, 0.30382004f, 0.24449840f, 0.14152543f, 0.10408600f, 
    0.03444264f, -0.02490373f, 0.02011063f, -0.02411522f, -0.02149848f, -0.12731394f, 0.03185889f, 0.01496684f, 
    0.26845148f, 0.19824870f, 0.13299140f, -0.27600867f, 0.02382603f, 0.06729551f, 0.01946013f, 0.01278351f, 
    -0.01533110f, -0.03988298f, -0.12028789f, 0.04103062f, 0.04004827f, -0.12540199f, 0.16994444f, -0.04636450f, 
    0.07357342f, -0.04037511f, 0.04620891f, 0.09044237f, -0.02812739f, -0.03751557f, -0.07089648f, -0.06554470f, 
    0.14226122f, 0.49666396f, -0.24271315f, 0.19258919f, -0.03704987f, -0.06105564f, 0.08187240f, -0.06499270f, 
    0.03290834f, 0.08895545f, -0.23512036f, 0.09784398f, -0.07967300f, -0.01446280f, -0.02807239f, 0.09901825f, 
    0.03546082f, 0.02405639f, 0.02695563f, -0.00894121f, 0.08937187f, -0.00035317f, -0.07369825f, 0.11752145f, 
    -0.32276869f, -0.13717674f, -0.35803193f, 0.12826230f, -0.10883036f, 0.03746152f, 0.05257650f, -0.04616843f, 
    -0.01417673f, -0.06098219f, 0.00269312f, 0.13832127f, 0.12842168f, 0.01892848f, -0.38043013f, -0.04492128f, 
    -0.04752317f, 0.08107261f, -0.10831452f, 0.09973603f, 0.03719062f, -0.05429219f, -0.02708515f, 0.12907784f, 
    -0.13207632f, -0.02258219f, -0.08851088f, -0.01366472f, 0.07365516f, -0.09105624f, 0.03206045f, 0.16225192f, 
    0.01209122f, -0.15160269f, -0.03103503f, -0.03499828f, -0.19787776f, -0.12959407f, -0.04257412f, 0.11263552f, 
    0.03878141f, 0.10424179f, 0.06391087f, 0.12020650f, 0.00149641f, -0.13729368f, 0.01363109f, 0.01738229f, 
    -0.11980372f, -0.19888715f, -0.16016735f, 0.03030840f, 0.06415255f, 0.05711512f, -0.00179854f, 0.02148256f, 
    0.12981978f, 0.19438118f, 0.02598557f, -0.00817918f, -0.07521708f, 0.01963345f, 0.24465892f, -0.04553107f, 
    -0.04390445f, 0.09415968f, 0.02385178f, 0.09978453f, 0.06485314f, -0.01661896f, -0.05622082f, 0.08589853f, 
    0.33547285f, 0.09232306f, 0.10464859f, -0.09511951f, 0.06165484f, -0.08048242f, -0.00838547f, 0.05913863f, 
    0.06319287f, 0.11223949f, 0.08255916f, 0.04917754f, -0.04146572f, 0.07029757f, -0.02716107f, 0.13742904f, 
    0.17125390f, 0.05926782f, 0.11883138f, -0.05162093f, -0.02147406f, 0.08684878f, 0.03870920f, 0.07477485f, 
    -0.34070432f, -0.16681360f, -0.21509312f, 0.04644469f, 0.12965603f, 0.18821132f, 0.16166669f, -0.04830760f, 
    -0.02607822f, -0.03392160f, 0.07521439f, -0.12644337f, -0.12535679f, 0.03039047f, 0.19371997f, -0.06165250f, 
    -0.09106084f, 0.01719204f, -0.14210691f, -0.04513462f, -0.02263255f, -0.03354651f, 0.03480381f, -0.07478568f, 
    0.08725271f, -0.11541940f, -0.01949725f, 0.06641793f, 0.00107716f, 0.07939166f, 0.05407783f, 0.03365586f, 
    0.22992112f, 0.05758171f, 0.10639907f, 0.05809204f, -0.17203772f, -0.14153442f, -0.04215307f, 0.16579300f, 
    0.09391817f, 0.18070197f, 0.16215152f, 0.03759248f, 0.03322261f, -0.02993638f, -0.03482185f, -0.06903487f, 
    -0.33867183f, -0.27041119f, -0.23452432f, 0.05418088f, 0.06913301f, 0.06965045f, 0.05802943f, -0.16397890f, 
    -0.01319390f, -0.19959734f, 0.00732115f, -0.04197560f, 0.03756474f, 0.21110958f, 0.27879190f, 0.16824092f, 
    -0.05098891f, 0.04333378f, -0.03297522f, 0.10440593f, 0.05025987f, -0.04356150f, -0.06638313f, 0.04316263f, 
    -0.09921061f, -0.03955514f, 0.22549561f, -0.11714160f, 0.10098410f, 0.06303901f, -0.01864621f, -0.08395113f, 
    0.00180367f, 0.06361382f, 0.00178103f, 0.01339876f, 0.21199341f, 0.03828740f, -0.16625664f, 0.08545113f, 
    0.01839706f, 0.02723626f, 0.00859593f, -0.01672124f, 0.03662509f, -0.18009838f, 0.01274420f, 0.05264042f, 
    -0.10541370f, 0.11313684f, 0.06755809f, -0.03747058f, 0.06047011f, -0.09417734f, -0.22051038f, 0.15541300f, 
    0.01907283f, -0.00230638f, -0.03997000f, -0.03217793f, 0.15815541f, 0.27885276f, 0.27719641f, 0.09021778f, 
    0.00316115f, -0.20621295f, 0.15582016f, -0.00205023f, 0.12126327f, -0.04274156f, -0.04729524f, -0.01348385f, 
    0.09397202f, 0.28684655f, -0.00349347f, 0.38647193f, -0.04081035f, 0.05077957f, -0.01942452f, -0.01040884f, 
    0.06230271f, -0.01803581f, 0.05024671f, 0.17524584f, 0.13845609f, 0.14125609f, 0.05433300f, -0.03299031f, 
    -0.01508873f, -0.04930786f, 0.03005156f, -0.07795455f, -0.03663797f, 0.14776523f, -0.07924989f, 0.01919178f, 
    0.07764257f, 0.04231507f, -0.01166300f, -0.12322158f, 0.09285820f, 0.03362837f, 0.11412660f, 0.17156556f, 
    -0.00006419f, -0.03524824f, 0.01479620f, 0.02550618f, -0.02766173f, -0.11868663f, -0.17477746f, 0.11119191f, 
    -0.11538993f, -0.01463867f, -0.11410195f, -0.00199875f, 0.12162250f, -0.04289024f, 0.06461819f, 0.09447778f, 
    -0.14459190f, -0.04794066f, 0.08307086f, 0.04033930f, -0.12630241f, -0.08084154f, -0.02703103f, -0.00432566f, 
    -0.00929142f, 0.03934504f, 0.02070474f, -0.06573099f, 0.22925745f, -0.17113324f, -0.22055538f, -0.05918601f, 
    -0.00007163f, -0.08329632f, -0.02128873f, -0.14256246f, 0.00452465f, 0.03320828f, 0.08567442f, 0.00600926f, 
    -0.26059219f, -0.02823299f, -0.35070780f, 0.22996855f, -0.14721705f, 0.12265783f, 0.06831377f, -0.03217215f, 
    -0.02983577f, -0.03398701f, -0.01681687f, -0.02111729f, -0.12961844f, -0.18405493f, 0.02091270f, 0.06304797f, 
    0.01534746f, -0.03702716f, 0.10434295f, 0.01952798f, 0.05661613f, -0.00063126f, 0.07052980f, -0.02480772f, 
    -0.06755953f, 0.16049680f, 0.17050146f, 0.28376964f, 0.04637636f, -0.11497931f, 0.10728335f, -0.17169325f, 
    0.04694548f, -0.04809682f, 0.03920907f, -0.05034800f, 0.14007984f, 0.37871832f, 0.18085845f, 0.06882714f, 
    -0.03743618f, -0.14736976f, 0.10630354f, 0.02310673f, -0.07851472f, -0.01357162f, -0.01426030f, -0.02564625f, 
    -0.12138330f, 0.12803070f, 0.05933839f, 0.01874916f, 0.01647865f, 0.01283846f, 0.00609058f, 0.05768809f, 
    -0.01846821f, 0.06576884f, 0.00684465f, 0.05616269f, -0.21032383f, -0.02853322f, 0.10291462f, 0.04314125f, 
    0.12262465f, 0.08497353f, 0.01539317f, 0.14872792f, -0.04070046f, -0.05750455f, -0.00459789f, -0.03656359f, 
    0.30971232f, 0.34683940f, 0.13573653f, -0.10799174f, 0.07817841f, -0.15791918f, 0.13199508f, -0.10180179f, 
    0.14510421f, 0.14392877f, -0.02314774f, 0.00299110f, -0.10666954f, -0.10166319f, -0.00216388f, 0.18987986f, 
    0.11817724f, 0.00776333f, -0.06702234f, 0.10785237f, -0.01625849f, -0.09548174f, 0.04908334f, -0.00959341f, 
    -0.11408560f, -0.20263627f, -0.20226130f, -0.03329800f, -0.02574853f, 0.07948175f, 0.04242479f, 0.02392963f, 
    -0.03771171f, 0.02500079f, -0.06850006f, -0.12708864f, -0.32382289f, -0.03839516f, -0.22186947f, 0.25619590f, 
    -0.14205371f, 0.17236246f, -0.13215593f, 0.03381871f, -0.08283551f, 0.04235449f, 0.02697217f, 0.03959558f, 
    0.12858176f, -0.04625515f, 0.07718596f, -0.06907520f, 0.06739173f, 0.00720173f, 0.06643063f, 0.14417309f, 
    0.07066821f, 0.01151534f, -0.02503681f, -0.02258373f, -0.10077146f, -0.08680454f, -0.07392829f, 0.02986157f, 
    0.07870755f, 0.19152392f, 0.05179308f, 0.12250273f, -0.08083966f, -0.10358244f, -0.07462396f, -0.04198346f, 
    0.01657568f, -0.16443999f, -0.11469461f, -0.03839197f, -0.06125688f, -0.04376579f, 0.00930044f, 0.03048377f, 
    0.25711787f, 0.13426554f, 0.10437312f, 0.03849272f, -0.21743824f, -0.18986730f, 0.14252590f, 0.19608666f, 
    -0.11605704f, 0.21290876f, 0.06596380f, 0.03426899f, -0.06783550f, -0.03359052f, -0.04516801f, -0.03115926f, 
    0.12564495f, 0.03591656f, 0.14354272f, 0.04419676f, -0.04309441f, -0.15423943f, 0.04687699f, -0.10066350f, 
    0.08128793f, 0.03493487f, 0.02641695f, 0.12740548f, 0.03652681f, -0.05640489f, 0.07360490f, 0.00220235f, 
    0.09058578f, 0.15020689f, 0.05031169f, -0.01440878f, -0.00321879f, -0.04453652f, -0.00980548f, 0.00974020f, 
    0.02944667f, -0.14123750f, 0.00575157f, 0.03392703f, 0.13653991f, 0.14749797f, 0.14188232f, -0.06747818f, 
    -0.04552692f, -0.03531982f, -0.04405700f, -0.00445364f, 0.17174992f, 0.00124613f, 0.04155065f, 0.05265762f, 
    -0.03604693f, 0.02772343f, 0.01899731f, -0.00873759f, -0.01791048f, -0.06865957f, -0.05172019f, -0.00774191f, 
    0.06657913f, -0.01445858f, -0.00799102f, -0.03090775f, 0.01996520f, 0.00767241f, 0.01972911f, -0.02921780f, 
    0.30876830f, 0.09575769f, 0.16221452f, 0.20247374f, 0.11028751f, -0.08367417f, -0.00998795f, 0.11820234f, 
    -0.03408258f, 0.19939266f, 0.11573900f, -0.04085064f, 0.09756908f, -0.05481670f, -0.00924157f, 0.11269782f, 
    0.19820984f, -0.20667632f, 0.03333053f, 0.01411145f, -0.01359715f, 0.16924804f, -0.00899604f, 0.06335695f, 
    -0.07882463f, -0.07143323f, -0.04220024f, -0.04865128f, -0.04076005f, 0.20359518f, 0.13664806f, -0.02000872f, 
    -0.10851304f, -0.06325672f, 0.01340401f, -0.00498293f, -0.00946940f, 0.06502920f, 0.10470228f, 0.14104106f, 
    -0.21745159f, -0.02043532f, -0.05345134f, 0.18104921f, 0.10984983f, 0.14294796f, 0.02324972f, 0.01389563f, 
    0.01906666f, 0.09846339f, 0.21203724f, 0.12188504f, -0.01425444f, 0.03735338f, 0.06295098f, 0.08494764f, 
    -0.07729522f, -0.03207924f, -0.10629852f, -0.04009623f, -0.03146977f, -0.03932395f, -0.00171227f, -0.06246131f, 
    -0.45980465f, 0.09841888f, 0.20076388f, -0.00986354f, 0.10067404f, -0.10697001f, -0.11234815f, 0.07583333f, 
    0.05929140f, -0.03983403f, 0.10790308f, 0.04912349f, 0.28463665f, 0.24806520f, 0.45014054f, 0.06060959f, 
    0.02381164f, -0.10239182f, 0.01143498f, -0.00505093f, 0.08313777f, 0.05681548f, 0.19281118f, 0.03030676f, 
    0.09057862f, -0.02932342f, 0.16713050f, 0.32747391f, 0.04529501f, -0.06692880f, -0.06581107f, -0.02713026f, 
    -0.00382192f, -0.04344493f, 0.17439505f, 0.08358884f, 0.05260013f, 0.24839792f, -0.13506293f, 0.00776762f, 
    0.04473332f, -0.07180681f, 0.07442828f, -0.01243465f, -0.12941884f, 0.08568133f, 0.03345869f, 0.09922249f, 
    -0.13325667f, -0.10278087f, -0.00506461f, 0.03054863f, 0.03703511f, 0.02578712f, 0.01505794f, 0.02611134f, 
    0.05260444f, 0.03778414f, -0.01547581f, -0.05047439f, -0.02423167f, -0.00452171f, -0.06381939f, 0.01804905f, 
    0.03433394f, 0.05719182f, 0.00007947f, 0.07619318f, 0.28608158f, 0.11152535f, 0.13585286f, 0.05743958f, 
    0.00087841f, 0.03417438f, -0.13400312f, -0.14975047f, 0.01626533f, 0.03800291f, 0.09964935f, 0.06438985f, 
    0.07351627f, -0.02200538f, 0.07902479f, -0.03371345f, -0.36222875f, 0.17378572f, 0.03973203f, 0.13886715f, 
    -0.08143093f, -0.13834432f, -0.09729083f, -0.08559003f, -0.06774385f, 0.04614552f, -0.06208195f, 0.02018975f, 
    -0.35146356f, 0.32350057f, -0.13591713f, -0.07300360f, 0.06958515f, -0.02892084f, -0.03119004f, 0.16616644f, 
    -0.17815639f, 0.00452364f, -0.07446405f, 0.04360283f, 0.17012554f, 0.06255294f, 0.03130452f, -0.14405894f, 
    0.10510372f, 0.06342995f, -0.14177810f, -0.02835874f, 0.00163642f, -0.00412429f, 0.07241567f, 0.00004233f, 
    0.34904203f, 0.22074434f, 0.24686041f, 0.15216319f, -0.02368921f, 0.12176562f, -0.07600135f, 0.18488839f, 
    -0.21907280f, 0.03171523f, -0.05826671f, -0.07688992f, 0.25544691f, 0.10257337f, -0.01211222f, 0.00099403f, 
    0.09836445f, 0.09469715f, -0.07704830f, -0.04027207f, -0.06015363f, 0.03133813f, 0.01232597f, 0.01541111f, 
    -0.05481589f, 0.14769863f, -0.09885705f, 0.02102572f, 0.05788814f, 0.07196273f, -0.05145230f, 0.06191348f, 
    0.06324322f, 0.05348586f, -0.00726279f, 0.13852145f, -0.14389409f, -0.02012086f, -0.00857254f, -0.08507913f, 
    0.01499703f, -0.01238237f, -0.05580266f, 0.13359812f, -0.12858240f, 0.26845446f, 0.00624168f, 0.00518605f, 
    0.05491050f, 0.03826016f, -0.06345981f, 0.11382808f, -0.04281021f, 0.05804023f, 0.07085890f, -0.11681229f, 
    0.11344331f, -0.07917698f, 0.06985127f, 0.26379281f, -0.10329311f, 0.13930856f, -0.48328292f, 0.16171648f, 
    0.06466606f, 0.08636355f, 0.11704021f, 0.06737891f, 0.01188392f, -0.01871001f, 0.00699294f, -0.02164502f, 
    -0.08661538f, 0.12848732f, -0.13015795f, 0.21107091f, -0.15484677f, -0.05962206f, 0.06503481f, -0.08964062f, 
    0.05859262f, -0.00684192f, 0.03264109f, 0.11593605f, 0.18820766f, -0.17701612f, 0.06333084f, -0.00065816f, 
    0.18073808f, -0.03346478f, 0.09790011f, 0.06039073f, 0.07575285f, 0.07013259f, 0.05713212f, 0.01865986f, 
    0.15795624f, -0.13698339f, 0.04632475f, 0.01566763f, 0.01356361f, 0.05309921f, 0.01915011f, -0.08024042f, 
    -0.05365192f, 0.03699445f, -0.01424073f, 0.17760782f, -0.05656342f, 0.06758142f, -0.16902430f, 0.08419574f, 
    -0.14470014f, 0.11051728f, 0.09260090f, 0.03042487f, -0.02671622f, 0.13019574f, -0.01128514f, -0.00648432f, 
    -0.02425962f, -0.10471669f, 0.13384731f, 0.03076770f, -0.09769382f, -0.07834212f, -0.05637934f, -0.12367582f, 
    -0.11267178f, -0.05057066f, 0.06651161f, 0.03736920f, 0.08932392f, -0.14927645f, -0.04798611f, -0.31075531f, 
    0.08876448f, 0.12156577f, 0.11803716f, 0.02774922f, -0.01769591f, -0.07335284f, 0.08367515f, -0.09020720f, 
    0.14632782f, -0.25313875f, 0.05017981f, -0.16658872f, 0.01937522f, 0.05780169f, 0.00028782f, 0.19704542f, 
    -0.05709368f, 0.20533377f, -0.04488399f, 0.12299491f, -0.13334015f, 0.08348268f, 0.04502780f, -0.21402165f, 
    0.00577138f, 0.03385708f, 0.12763129f, 0.04221971f, 0.15231541f, 0.14096372f, 0.09222849f, -0.06465971f, 
    -0.17387578f, -0.04907652f, -0.07595562f, -0.00781911f, 0.01701143f, -0.12459444f, -0.03248769f, -0.06167728f, 
    0.11623355f, 0.06044145f, -0.06111733f, -0.02977331f, 0.06376665f, 0.01232053f, 0.09793454f, -0.01716203f, 
    0.12821735f, 0.11608305f, -0.13957672f, 0.06048297f, 0.07157167f, -0.12895009f, 0.06260949f, 0.10902093f, 
    -0.07948811f, 0.14812513f, 0.23285143f, 0.00089709f, -0.03908809f, 0.00713686f, -0.20305409f, -0.09274555f, 
    -0.08726552f, 0.02686022f, 0.07266594f, 0.07208344f, -0.20636339f, -0.03050575f, 0.03907739f, -0.23046225f, 
    -0.02747738f, -0.15788105f, -0.09383021f, -0.02634961f, -0.07579499f, 0.04113546f, -0.10591859f, -0.06275871f, 
    -0.07343934f, -0.16776873f, -0.09002823f, 0.11880649f, 0.04909142f, -0.12263858f, 0.08186339f, -0.09660876f, 
    -0.11590059f, 0.09943359f, -0.05146321f, 0.10431864f, -0.00956846f, 0.17253737f, 0.11656089f, 0.22025037f, 
    -0.08933172f, 0.08997070f, -0.06555770f, 0.01164202f, -0.09102416f, 0.09100261f, -0.00147640f, -0.02771889f, 
    0.20234635f, 0.12893218f, 0.06731867f, 0.18769288f, 0.07745226f, 0.00660608f, 0.03056189f, -0.02233614f, 
    0.05541483f, -0.04516149f, -0.13296205f, -0.12596716f, 0.22878197f, -0.16605085f, 0.08027521f, 0.04078521f, 
    0.10655945f, 0.05740917f, 0.17372265f, 0.07420192f, -0.00213526f, -0.12616178f, -0.04150011f, -0.01093872f, 
    0.52105063f, -0.04656061f, 0.06068547f, 0.12509745f, -0.06019001f, -0.00549536f, -0.17910039f, -0.08600447f, 
    0.10099976f, 0.02307560f, 0.09939829f, 0.05412893f, 0.14440013f, -0.01694705f, 0.10274556f, -0.05351593f, 
    -0.05259722f, -0.15364555f, 0.06757601f, -0.03070314f, 0.05963130f, 0.05346736f, -0.24277943f, -0.02131918f, 
    -0.34858170f, 0.22889017f, -0.03712959f, 0.10075817f, -0.00745861f, 0.02467919f, 0.04852955f, -0.18432739f, 
    0.02041760f, 0.22322807f, -0.04383456f, 0.11822746f, -0.01023735f, 0.11656254f, 0.19487084f, 0.04883919f, 
    -0.09939064f, 0.01710472f, -0.07179888f, -0.14924288f, -0.08328584f, 0.01252930f, 0.09138668f, 0.03394050f, 
    0.04260006f, 0.04334929f, -0.24150136f, -0.16109441f, -0.00633466f, 0.12316364f, -0.00204257f, 0.10756084f, 
    -0.01008875f, 0.05403636f, -0.00067425f, 0.06923490f, -0.02166880f, -0.11866783f, 0.10637889f, 0.18037376f, 
    -0.06454958f, -0.05068404f, 0.01094016f, -0.13834737f, 0.05712606f, 0.02136870f, -0.11299417f, -0.02418812f, 
    -0.08229235f, -0.04496918f, 0.13201468f, 0.14902565f, 0.06954166f, 0.01225684f, 0.14318979f, 0.02650652f, 
    -0.02808725f, -0.01660722f, -0.03284421f, -0.07326169f, 0.24978614f, -0.14997464f, -0.08436569f, -0.05481626f, 
    0.08574223f, 0.02180643f, 0.02532136f, -0.04662945f, 0.10163996f, 0.09343062f, 0.09236585f, -0.08480944f, 
    0.03169138f, -0.25104812f, -0.04450655f, 0.30803764f, -0.16763721f, 0.06558289f, -0.04288505f, -0.10973244f, 
    0.12897572f, 0.01780593f, 0.02213815f, -0.02786537f, -0.17578144f, -0.14216065f, 0.09490157f, 0.06243012f, 
    -0.02794183f, -0.09112501f, 0.08584198f, 0.04034649f, 0.00757028f, -0.04886737f, 0.08326857f, 0.07568642f, 
    -0.13347246f, -0.04093852f, -0.08120298f, 0.01902497f, 0.04727256f, -0.02685319f, -0.02010508f, -0.06274474f, 
    0.07690226f, -0.06531750f, 0.03856004f, 0.05876530f, 0.03837014f, 0.08673438f, 0.26320028f, -0.16478518f, 
    -0.01736101f, -0.05105098f, 0.02948380f, -0.01329729f, 0.09268223f, -0.06491566f, 0.09544314f, -0.05365830f, 
    -0.00710416f, -0.03504527f, 0.16647391f, 0.01117026f, -0.03284674f, -0.04464942f, 0.07584887f, -0.01104776f, 
    0.10832012f, 0.02253452f, -0.05201970f, -0.04121435f, 0.04043564f, -0.00027452f, -0.02011190f, 0.03440886f, 
    0.25477189f, -0.02254083f, 0.00366526f, 0.02500198f, 0.06656911f, -0.15794687f, -0.08371381f, -0.09538398f, 
    0.05327155f, 0.31726581f, -0.03491057f, -0.12762593f, 0.05961294f, 0.04701509f, 0.07349569f, 0.05624491f, 
    0.01298523f, 0.18859123f, -0.04463742f, -0.10141349f, -0.02869274f, -0.10582680f, 0.32400423f, -0.12961239f, 
    0.07357488f, 0.05685973f, 0.01545309f, -0.00344345f, 0.06859942f, -0.04774869f, -0.05559869f, 0.04895540f, 
    -0.16017759f, -0.24403337f, -0.02904402f, -0.08712390f, 0.03291196f, -0.08901911f, -0.03690482f, -0.01416855f, 
    0.06020322f, -0.01783116f, -0.03546622f, -0.01743922f, -0.26449478f, 0.19703394f, -0.01690201f, 0.07499751f, 
    -0.07575373f, 0.04493203f, -0.12717439f, 0.09518801f, 0.03637207f, -0.06036640f, 0.03628081f, -0.04026285f, 
    -0.08671717f, 0.17993343f, -0.07947308f, -0.02453242f, 0.14469759f, -0.01587404f, 0.03814644f, 0.14682229f, 
    0.05797513f, -0.02803993f, -0.04569846f, -0.13009626f, -0.05643238f, -0.07883199f, 0.04569432f, 0.01662473f, 
    0.18888225f, -0.03341107f, -0.07833561f, 0.12128948f, 0.00170150f, -0.12667526f, -0.01914201f, -0.08051062f, 
    0.06351116f, 0.02843590f, -0.08193184f, -0.03649092f, 0.03374869f, 0.08913957f, 0.01872133f, 0.09374983f, 
    0.19750123f, 0.24855171f, -0.05747447f, -0.01799444f, -0.23118863f, -0.00707373f, 0.08997120f, 0.12339117f, 
    -0.13550131f, 0.00921497f, 0.07105368f, 0.15588112f, 0.05377408f, 0.07349242f, 0.02838814f, -0.03845841f, 
    -0.09812813f, 0.18237332f, 0.02917718f, 0.12484917f, 0.03642364f, 0.01931866f, 0.01188892f, -0.10281987f, 
    0.18144472f, 0.07398759f, 0.09058855f, -0.03079734f, 0.05118499f, 0.04590463f, -0.13846889f, 0.03686599f, 
    0.00938402f, 0.13693681f, -0.07870438f, -0.07798389f, -0.01785536f, -0.01602913f, -0.09719766f, 0.12925930f, 
    0.02018341f, 0.01294595f, 0.00264854f, -0.06167635f, 0.12410856f, 0.03395105f, 0.01797696f, -0.02417548f, 
    -0.05529649f, -0.14451012f, -0.11620498f, -0.05842330f, 0.02060072f, 0.01473825f, 0.00041832f, 0.04001627f, 
    -0.10847878f, -0.08035166f, -0.00676939f, -0.02764907f, -0.06156860f, 0.05720557f, -0.07763079f, -0.02331575f, 
    0.22599746f, -0.15630779f, -0.12573741f, 0.01294376f, 0.01216266f, 0.00041354f, 0.08950347f, 0.02610219f, 
    0.14863390f, -0.01331392f, -0.00772564f, -0.02858729f, 0.08073275f, -0.09398993f, -0.02946626f, 0.14885783f, 
    0.08309940f, 0.19441108f, 0.11676675f, -0.04058111f, 0.17119481f, -0.03842288f, 0.02644701f, 0.09345543f, 
    -0.00192374f, -0.14366576f, 0.11879768f, -0.18931092f, 0.03578806f, 0.07113665f, -0.12501761f, -0.01969911f, 
    0.04486335f, -0.20963176f, -0.05242045f, -0.07966185f, 0.10612243f, -0.01058286f, -0.04944453f, 0.06246282f, 
    0.02616033f, -0.10262247f, -0.00311540f, 0.08395083f, 0.04081624f, 0.00022803f, 0.03801077f, 0.15765578f, 
    -0.17064069f, -0.12674440f, 0.10322889f, -0.05182563f, -0.05911273f, 0.02362945f, -0.01369099f, 0.15421420f, 
    0.03334062f, 0.06277525f, 0.14015096f, 0.22322327f, -0.05729893f, 0.21751967f, 0.05000401f, 0.03118973f, 
    0.02120632f, -0.08019426f, -0.07748020f, -0.05243872f, -0.01872331f, 0.03013101f, -0.01569920f, 0.07437502f, 
    -0.39288566f, 0.21186207f, -0.02382834f, -0.09732790f, 0.17534740f, -0.09776167f, -0.06058563f, -0.02313853f, 
    -0.07557481f, 0.16661733f, 0.00691890f, 0.03397387f, 0.02289100f, 0.39734688f, 0.09493410f, -0.05475811f, 
    0.06069140f, -0.02741869f, -0.03908077f, -0.01272722f, 0.02443331f, 0.09768741f, 0.30158931f, 0.05423407f, 
    0.29908359f, -0.13671009f, -0.13957930f, 0.13519381f, 0.08262382f, -0.09058179f, -0.12508351f, 0.06640807f, 
    -0.05170998f, -0.03184099f, -0.06041624f, 0.08431480f, 0.16067922f, -0.20302883f, -0.09756998f, -0.10119599f, 
    0.08058496f, -0.08170825f, -0.08869062f, -0.00566225f, 0.07063747f, -0.00544136f, -0.07277232f, -0.01237889f, 
    -0.08741815f, -0.00717634f, 0.11901000f, 0.14695230f, -0.00274620f, 0.01218079f, 0.14761849f, 0.09295934f, 
    0.12365430f, -0.02759152f, 0.07150619f, -0.05822304f, 0.11226314f, -0.00914111f, -0.16398123f, -0.01000992f, 
    0.12422967f, 0.03884818f, -0.00938000f, 0.04473155f, 0.14823160f, -0.01387111f, 0.22445256f, 0.07706044f, 
    -0.42485687f, -0.20587374f, -0.15742156f, 0.13529715f, -0.14382283f, -0.01156101f, -0.09095470f, -0.01958008f, 
    -0.00975547f, -0.04399472f, 0.04238355f, -0.01849874f, 0.29371783f, 0.09750883f, 0.32889679f, -0.08801144f, 
    0.00875538f, -0.05156989f, -0.07965992f, -0.13158445f, -0.14676611f, 0.01412488f, -0.11327573f, 0.01439226f, 
    0.25102633f, 0.31443423f, -0.31874928f, -0.03506969f, 0.04310073f, 0.00608653f, 0.04280823f, -0.07270459f, 
    -0.03946308f, 0.00556054f, -0.10419910f, 0.03303545f, -0.12817262f, -0.32095265f, -0.12364694f, -0.09228373f, 
    -0.07672560f, 0.07770444f, 0.05390236f, -0.00089517f, 0.04905216f, -0.05963308f, -0.07908277f, -0.11878536f, 
    0.04528133f, -0.07034341f, 0.19389522f, 0.24964710f, 0.03549143f, -0.04365405f, -0.01278441f, 0.10909310f, 
    -0.14369848f, -0.05935750f, -0.01592205f, -0.09514081f, -0.04923992f, 0.16306797f, 0.19288610f, 0.22760841f, 
    0.02451203f, -0.02722248f, 0.12378671f, 0.12889008f, -0.02102057f, 0.15659307f, 0.02494356f, 0.16454040f, 
    -0.22065224f, -0.21192646f, -0.17217918f, 0.23954000f, 0.18254229f, 0.16542007f, 0.09380588f, 0.20797063f, 
    0.11693909f, 0.19104855f, 0.08024756f, 0.07072313f, -0.21515281f, -0.05945080f, -0.10933437f, 0.02026785f, 
    -0.02144185f, 0.08160123f, -0.06851275f, 0.25301111f, -0.11204868f, 0.12437387f, 0.10228461f, 0.03408511f, 
    0.17159984f, -0.17567509f, 0.28598812f, 0.16250063f, 0.12572780f, 0.07220476f, 0.21431215f, 0.23363203f, 
    0.01999347f, 0.04659565f, 0.16895799f, 0.14853364f, -0.06165618f, -0.04376379f, -0.21767856f, 0.20680085f, 
    0.06822892f, -0.02349199f, 0.06184084f, 0.27480343f, -0.06743816f, 0.02773829f, 0.06762087f, -0.04972638f, 
    0.19480035f, 0.16704105f, 0.04748228f, -0.23361431f, -0.12879515f, -0.10537893f, -0.08014344f, -0.06768227f, 
    -0.07878035f, 0.01194096f, -0.02747823f, -0.14729498f, -0.34746721f, -0.02095808f, 0.00713543f, 0.31641242f, 
    0.11415279f, 0.15384395f, 0.05030718f, 0.08143900f, 0.09954701f, 0.14954951f, 0.08686097f, 0.05706893f, 
    0.02779759f, -0.01568416f, 0.12671071f, -0.05221166f, 0.02385831f, 0.10010244f, 0.03860171f, 0.05871287f, 
    -0.09132036f, 0.16075891f, 0.13544212f, 0.06503635f, -0.04282837f, -0.00537610f, -0.02533554f, -0.02259063f, 
    -0.02470792f, 0.11521588f, 0.01752212f, -0.04844707f, -0.10682274f, 0.06290328f, 0.00444671f, 0.03731365f, 
    0.07040824f, 0.02261958f, 0.08349933f, -0.12455287f, -0.14316572f, -0.00653449f, -0.03152931f, -0.03554742f, 
    -0.01850548f, -0.11401013f, -0.12492894f, 0.05368080f, -0.08765118f, -0.20681226f, 0.11855634f, 0.06369542f, 
    0.04597305f, 0.14602408f, 0.11719501f, -0.12961768f, 0.02300372f, -0.05991937f, 0.04761387f, -0.05966077f, 
    -0.16730003f, -0.33844119f, 0.05641426f, 0.09892522f, 0.06884719f, 0.08042619f, 0.15202792f, 0.09483567f, 
    0.02443380f, 0.12623522f, -0.14353077f, 0.07672261f, -0.00282875f, -0.18661386f, -0.07960772f, -0.17677112f, 
    -0.05137958f, 0.14929204f, 0.23321706f, 0.24491887f, 0.10305890f, 0.02406247f, -0.07557651f, -0.14129576f, 
    0.02953706f, -0.15568799f, 0.06366640f, -0.06730247f, -0.05295596f, -0.10903566f, -0.09401535f, -0.07013186f, 
    -0.02871381f, 0.00780140f, 0.00042325f, 0.12462409f, 0.22799066f, -0.02129143f, 0.10053933f, -0.07764506f, 
    0.07700309f, -0.07276861f, 0.06567047f, 0.06284037f, 0.14187035f, 0.05965700f, 0.07129610f, 0.19081223f, 
    -0.01648392f, 0.17989850f, 0.20247974f, -0.10424255f, -0.12377660f, -0.01187098f, -0.11974730f, -0.12853161f, 
    0.07572047f, 0.19870122f, 0.00383828f, 0.13990964f, -0.05600664f, -0.02191876f, 0.03271289f, -0.06017855f, 
    0.05492780f, -0.03788585f, -0.18889382f, 0.01595008f, -0.00563403f, -0.06217528f, 0.00046325f, 0.02620284f, 
    -0.02796515f, -0.11103551f, 0.14870161f, 0.04328379f, -0.05939058f, -0.01121214f, 0.09825424f, 0.04981709f, 
    -0.07697573f, 0.10338221f, -0.07317810f, 0.08015945f, 0.06604349f, 0.03293436f, -0.09082341f, 0.17406185f, 
    0.04939201f, 0.05087925f, 0.09972425f, 0.07819366f, 0.06262691f, 0.17584877f, 0.12194251f, -0.04414418f, 
    -0.05075258f, 0.03673998f, -0.14183825f, 0.32566738f, 0.10841917f, 0.12995058f, 0.02431499f, 0.16304404f, 
    0.12925281f, 0.07717191f, 0.11390427f, -0.03455903f, -0.06764255f, -0.21263829f, 0.31649417f, 0.06687706f, 
    0.01143461f, 0.06085511f, 0.26316744f, 0.11103970f, 0.02695153f, 0.10080537f, -0.01375761f, 0.03120974f, 
    0.24897012f, 0.09897387f, 0.35543305f, 0.08722775f, -0.06636506f, 0.00665763f, -0.02507320f, -0.15153421f, 
    0.18141514f, 0.03290614f, 0.26532066f, 0.21719749f, 0.06897200f, 0.15492426f, 0.50374579f, 0.13864864f, 
    -0.09659909f, 0.01716398f, 0.10461814f, 0.10029158f, -0.04080769f, 0.15021567f, 0.04360867f, 0.06857213f, 
    0.25743830f, 0.00696973f, -0.02835529f, 0.03063376f, 0.19142489f, -0.06348868f, 0.16907606f, -0.11507115f, 
    0.14232491f, 0.15322572f, 0.08470284f, 0.05452288f, -0.04874132f, 0.08960222f, 0.00911139f, -0.16279215f, 
    -0.10722223f, 0.02549167f, 0.00856302f, 0.00100775f, 0.00056977f, 0.03048687f, 0.22935553f, 0.27306485f, 
    -0.21778715f, -0.17420372f, -0.08867747f, 0.05311693f, 0.02155580f, 0.14623994f, -0.06253720f, 0.00360283f, 
    0.00141297f, 0.10073666f, -0.05531356f, 0.07229980f, -0.06850779f, -0.07219095f, 0.02177204f, -0.18804440f, 
    -0.09839422f, 0.07373070f, 0.03776861f, -0.15051305f, -0.03738743f, 0.06414305f, -0.06495556f, 0.06816769f, 
    -0.00640705f, 0.01498590f, -0.00711374f, -0.00631155f, -0.03081625f, -0.02815005f, -0.04051062f, -0.03302585f, 
    0.01966042f, -0.02144671f, -0.00168627f, -0.00060608f, -0.03182195f, -0.04613685f, -0.02740228f, -0.02909788f, 
    0.02897355f, 0.00260120f, -0.04439735f, -0.03021251f, -0.02585698f, 0.02032979f, -0.05261018f, -0.01555550f, 
    -0.02957769f, 0.00922088f, 0.03860321f, -0.05676845f, -0.05008706f, -0.04075617f, -0.04730384f, -0.05083568f, 
    0.00571011f, -0.04540498f, 0.02940155f, 0.02776337f, -0.00190702f, 0.01160038f, -0.02411892f, 0.03834718f, 
    -0.03805658f, 0.02261369f, -0.03838340f, -0.02608307f, 0.02879543f, -0.02662935f, -0.05591068f, -0.01473194f, 
    0.02650934f, 0.01995428f, 0.03468731f, 0.04317380f, -0.03161907f, 0.03626720f, 0.03382621f, 0.02475152f, 
    0.01804208f, 0.01326853f, -0.00995508f, -0.00938173f, 0.01428836f, -0.03626756f, 0.02042908f, 0.00083384f, 
    -0.03636057f, -0.03206201f, 0.04011216f, 0.02069715f, -0.03525161f, -0.02445080f, -0.04526247f, -0.00833004f, 
    -0.05216761f, -0.04681685f, 0.01035480f, -0.03282288f, 0.03131502f, 0.03288802f, 0.04069202f, 0.01557506f, 
    0.01197278f, -0.03396016f, -0.00143814f, -0.02799699f, 0.03230670f, -0.03307072f, -0.02581848f, -0.00548026f, 
    -0.04865243f, -0.02447480f, -0.04079797f, 0.01399116f, 0.00988455f, -0.01735702f, 0.02022609f, -0.04945135f, 
    0.00812798f, -0.04435311f, -0.00615784f, 0.01360759f, -0.05298274f, 0.02540303f, -0.05142195f, 0.03318638f, 
    -0.01995969f, -0.05181568f, 0.02293935f, -0.04780163f, -0.04250232f, -0.00538573f, 0.01539643f, 0.00822576f, 
    -0.01556470f, -0.01148108f, -0.03528550f, -0.03521493f, -0.04768120f, 0.03019549f, -0.02685099f, 0.03386594f, 
    0.00184506f, 0.02073083f, 0.00855809f, 0.01578165f, 0.00941945f, -0.01651293f, -0.04160881f, -0.03995244f, 
    0.02469808f, -0.00826128f, -0.03533769f, -0.00592083f, 0.01597414f, 0.00820602f, -0.05066139f, -0.03189587f, 
    -0.00075867f, 0.02015090f, -0.02319933f, -0.02375663f, -0.03062862f, -0.05822146f, -0.01433748f, -0.02752795f, 
    0.00737114f, 0.02437969f, 0.03397373f, 0.03846868f, -0.04936646f, -0.04049496f, 0.00325896f, -0.04956224f, 
    -0.03826287f, 0.01300659f, -0.01416711f, -0.00702233f, -0.04962671f, -0.05036622f, -0.02792012f, -0.05133005f, 
    0.01423211f, -0.04428738f, -0.05123580f, -0.03643003f, -0.00842511f, -0.00002654f, 0.03114249f, -0.04503963f, 
    -0.02161171f, -0.02547626f, -0.05445290f, -0.04859798f, -0.00553854f, 0.03131124f, -0.04411433f, -0.03650081f, 
    -0.04019197f, -0.03446290f, 0.03317882f, 0.02572292f, -0.01560745f, 0.01920529f, 0.04080154f, -0.05178907f, 
    0.01774798f, 0.04027391f, 0.02386490f, 0.03199420f, -0.04906494f, 0.02697807f, -0.04769415f, -0.04910755f, 
    -0.04061630f, -0.01446633f, 0.00641107f, -0.03045362f, 0.01764059f, -0.02448204f, -0.04341704f, -0.00413237f, 
    0.04966044f, 0.03591920f, -0.03360598f, 0.01040877f, -0.01328602f, 0.02036462f, 0.02787387f, 0.01151318f, 
    -0.00796405f, 0.04235403f, -0.04810005f, 0.02231946f, -0.00508792f, 0.00989798f, -0.04883034f, 0.00843556f, 
    0.00715863f, -0.04732271f, -0.03853251f, -0.01922770f, 0.04302438f, -0.02266689f, 0.01332475f, 0.00622009f, 
    0.01988184f, -0.03134495f, 0.01631732f, 0.01432875f, -0.05523394f, 0.01677771f, -0.05170923f, -0.01065465f, 
    -0.05417052f, -0.03062948f, 0.03269926f, 0.02225092f, 0.03207103f, -0.04840909f, -0.05122120f, 0.00423449f, 
    -0.03602880f, -0.01764376f, -0.05043721f, -0.00482407f, -0.00861762f, 0.04335876f, -0.03609629f, -0.01269957f, 
    0.00252344f, 0.02327504f, -0.03227595f, -0.00420024f, 0.01931444f, -0.00628489f, 0.04095325f, -0.02161203f, 
    -0.05107025f, -0.05766448f, -0.05516674f, -0.02858236f, 0.02036311f, -0.03448810f, 0.04143105f, -0.05369503f, 
    0.04156484f, 0.02759987f, -0.03464429f, 0.01296106f, -0.04859621f, -0.03450425f, 0.02236025f, -0.03098461f, 
    -0.01180819f, 0.02392656f, 0.00706887f, 0.01404462f, -0.02827590f, -0.01040184f, -0.01526351f, 0.01166189f, 
    -0.05477720f, 0.03317831f, -0.05561867f, -0.01204073f, -0.00814731f, 0.01022540f, 0.01290125f, 0.02506846f, 
    -0.01215349f, 0.03548964f, -0.01446672f, -0.02497870f, -0.01637599f, 0.01830715f, -0.00826943f, 0.02979749f, 
    0.04333763f, 0.03537022f, 0.00094905f, 0.02148793f, -0.02472534f, -0.00965408f, 0.02627376f, -0.04104451f, 
    -0.01223474f, -0.00121288f, -0.03997548f, -0.00628275f, -0.01351901f, -0.00840934f, -0.02402455f, 0.01612876f, 
    0.00022732f, -0.02847088f, -0.02873821f, 0.00155246f, 0.00549084f, 0.02207433f, -0.02837152f, -0.00262719f, 
    -0.00353903f, -0.04141284f, 0.03942119f, 0.01172380f, 0.03125662f, -0.02650406f, -0.04458724f, -0.01268500f, 
    0.03978374f, -0.01096030f, 0.01177605f, -0.04046069f, 0.01146479f, 0.03491602f, -0.00941319f, -0.02809115f, 
    0.01029395f, -0.02296525f, -0.05366478f, 0.04304574f, -0.00655188f, 0.00406573f, 0.00988855f, 0.03402492f, 
    -0.03384597f, -0.05126582f, -0.01930018f, 0.02534532f, 0.04107555f, -0.03946232f, -0.01851789f, 0.00089510f, 
    0.02732729f, -0.02870028f, -0.01810633f, 0.04113003f, -0.00420465f, -0.04633995f, 0.02742139f, -0.02905254f, 
    0.03266452f, -0.01006819f, -0.01949384f, -0.02055020f, -0.00563386f, -0.03750952f, -0.01508031f, -0.01738023f, 
    -0.00161199f, -0.04667614f, 0.03171642f, -0.05707028f, 0.00189439f, -0.02394979f, 0.01872271f, 0.03590406f, 
    0.00410213f, -0.05013019f, -0.00403124f, 0.02723705f, -0.04903373f, -0.03153946f, 0.00696981f, 0.01959208f, 
    0.05822838f, 0.03336632f, 0.05099513f, 0.26440707f, 0.12475921f, 0.11955697f, 0.13431129f, 0.14527847f, 
    0.03170794f, -0.04045767f, 0.03304752f, 0.02342131f, 0.14672390f, -0.04555665f, 0.38137656f, -0.15223610f, 
    -0.06134529f, -0.11283411f, -0.05580871f, 0.07787853f, 0.09262609f, -0.12197004f, 0.08412106f, 0.01683225f, 
    0.34389099f, 0.35537392f, 0.26145741f, -0.13606127f, 0.10616815f, -0.09408995f, -0.00133616f, -0.15390030f, 
    -0.04287601f, 0.00524721f, 0.00478846f, 0.05578119f, 0.13892223f, 0.01203429f, -0.03318541f, 0.26728329f, 
    0.14194362f, -0.04312767f, -0.04378307f, -0.07859059f, -0.01550714f, 0.02288594f, -0.01324369f, -0.06382975f, 
    0.28403285f, 0.07769927f, 0.30514359f, 0.37308571f, 0.07359961f, 0.07871233f, 0.17133027f, 0.22363761f, 
    -0.09153357f, 0.00096392f, -0.04953817f, -0.07515775f, -0.57138854f, -0.09705625f, 0.00908437f, 0.48439810f, 
    -0.02044369f, 0.14489341f, -0.11090054f, -0.04537387f, 0.02685198f, 0.12566575f, -0.15664279f, 0.12725469f, 
    0.27015767f, -0.17448060f, -0.19103155f, 0.30001333f, 0.03730971f, 0.16410387f, -0.09563538f, -0.02204966f, 
    0.01757837f, 0.06207275f, 0.07079269f, 0.02117895f, 0.06068121f, 0.01250132f, -0.15673450f, -0.02669455f, 
    0.07512974f, 0.08077000f, -0.05123009f, 0.12464907f, 0.03281129f, 0.04334101f, 0.02448226f, 0.07125503f, 
    -0.12856722f, -0.32507080f, 0.15027705f, 0.28812259f, 0.09739379f, 0.20073654f, -0.15503362f, -0.06000943f, 
    -0.15632565f, -0.14554878f, 0.20107922f, 0.08910059f, 0.12704854f, 0.24589477f, -0.11228170f, 0.02795469f, 
    -0.04121606f, 0.04159537f, -0.16423804f, -0.02430820f, -0.05362562f, 0.07744357f, 0.05837344f, -0.03236996f, 
    0.15464905f, 0.08031510f, 0.28172752f, -0.09740055f, -0.04302283f, -0.07047612f, -0.07485802f, 0.10268865f, 
    0.07845028f, -0.03711880f, 0.02409013f, 0.08318025f, 0.02221604f, 0.22631651f, 0.10514108f, -0.03647260f, 
    0.02995583f, 0.01620566f, 0.05179549f, -0.00026195f, 0.00545248f, -0.03538377f, 0.12612768f, 0.10143316f, 
    0.00419832f, -0.07540255f, 0.06316408f, 0.02656564f, 0.10508979f, 0.16459154f, -0.14607181f, -0.10009949f, 
    -0.03746888f, 0.11871319f, 0.00579278f, 0.08914044f, 0.19873592f, 0.04731572f, 0.08613769f, 0.01490292f, 
    0.02200733f, -0.02157225f, -0.08202240f, -0.16106749f, -0.03172673f, 0.13219225f, -0.01885903f, 0.02609250f, 
    -0.02994395f, -0.01889803f, -0.04479902f, -0.11269339f, -0.04626626f, 0.02265836f, 0.01409317f, -0.07281565f, 
    0.01626656f, -0.10360479f, -0.07590208f, 0.00704044f, 0.17982426f, 0.34321174f, -0.00095670f, 0.15092696f, 
    -0.13438934f, -0.08089051f, -0.12787102f, 0.03359149f, -0.00505566f, -0.00641581f, -0.04323227f, -0.10463671f, 
    -0.05296905f, -0.12149850f, -0.07154877f, 0.30696264f, 0.04624218f, 0.14815903f, 0.11113501f, 0.17436005f, 
    -0.05299134f, 0.05309304f, -0.18061432f, 0.07333230f, 0.00208103f, -0.03624302f, 0.08913320f, -0.01282643f, 
    0.02116590f, 0.14929333f, -0.07133509f, 0.09201677f, 0.13389117f, -0.01992146f, -0.02085130f, -0.10545797f, 
    -0.03821972f, 0.10952660f, 0.26025960f, -0.07019415f, 0.04023562f, -0.12266702f, -0.29236013f, -0.03182838f, 
    -0.01103365f, -0.03047773f, 0.09206817f, 0.05641345f, -0.04636331f, 0.00775049f, -0.20893027f, 0.00614862f, 
    -0.09180255f, -0.01008067f, -0.02833419f, -0.02330364f, -0.03969864f, 0.01159525f, 0.11984605f, 0.07421372f, 
    -0.05022031f, -0.10551966f, -0.14320104f, -0.10793559f, -0.04978560f, 0.01854246f, 0.04883762f, 0.02977148f, 
    -0.12970629f, -0.09330812f, -0.07059263f, -0.00915012f, -0.28664544f, 0.16149504f, 0.42376462f, 0.15559593f, 
    -0.05569008f, 0.00426684f, -0.28127655f, -0.17280905f, -0.11131157f, 0.03193123f, -0.11362795f, 0.04527839f, 
    0.02138953f, 0.04562384f, 0.10238483f, 0.14830327f, -0.02621313f, 0.05786945f, -0.03436482f, 0.06533618f, 
    0.07937267f, 0.09992508f, 0.07065355f, 0.02062089f, 0.04726873f, -0.16845572f, -0.08597542f, 0.16440299f, 
    0.12696563f, 0.13117509f, 0.15031305f, 0.05956708f, -0.01361902f, -0.01035060f, 0.05343080f, -0.09830332f, 
    0.04315372f, 0.17632957f, -0.05926943f, 0.08655105f, 0.01637101f, -0.04887765f, 0.06191720f, -0.07879732f, 
    0.01808421f, -0.01808031f, -0.04324339f, 0.09406076f, 0.14689988f, 0.02035295f, 0.02613708f, 0.22647676f, 
    0.10822626f, 0.12958904f, 0.04883347f, 0.02608782f, 0.07733019f, 0.00956371f, 0.11546636f, 0.00549719f, 
    -0.12044409f, -0.05707587f, 0.02645211f, -0.14679980f, -0.01178710f, 0.03252205f, 0.02599086f, -0.02492838f, 
    -0.01587126f, -0.00296021f, 0.08145811f, 0.11545750f, -0.30260563f, -0.21823268f, 0.05760406f, 0.23971669f, 
    -0.01926523f, 0.24299325f, -0.02300312f, 0.09637442f, 0.04762197f, 0.02280271f, 0.06701171f, -0.18464798f, 
    0.28599483f, -0.19837475f, -0.37031072f, -0.38981906f, 0.14993985f, -0.03272926f, 0.05277048f, 0.02072622f, 
    0.05128289f, 0.12567344f, -0.02570619f, 0.05709659f, -0.33628201f, -0.15708040f, -0.12440541f, 0.13485277f, 
    -0.00850679f, -0.00757100f, 0.01107387f, -0.01174595f, 0.07810584f, 0.02625803f, -0.03925826f, 0.19555584f, 
    0.03710515f, -0.02783362f, 0.11830349f, 0.08896371f, 0.00451240f, 0.05284422f, -0.08558550f, 0.01084706f, 
    -0.02379476f, 0.07720916f, 0.10541190f, 0.12160607f, -0.16027810f, -0.03185655f, 0.04759216f, 0.00269028f, 
    0.06802730f, 0.07655147f, 0.08712819f, -0.04895492f, -0.00244849f, 0.13334766f, -0.04091264f, 0.13452497f, 
    0.03205727f, -0.03983835f, 0.08394720f, 0.01740900f, 0.03726643f, 0.11017013f, -0.03130519f, -0.04641928f, 
    0.07978981f, 0.07131923f, 0.00873928f, 0.09381504f, 0.02726994f, 0.07363157f, -0.39666617f, 0.12169120f, 
    -0.04377497f, -0.04774473f, -0.07870711f, -0.02622317f, -0.04179047f, -0.09474961f, -0.05509238f, -0.04175633f, 
    0.18029243f, -0.23480383f, 0.11974490f, 0.06530477f, -0.07823569f, 0.09295897f, 0.00300671f, 0.06059004f, 
    -0.06967627f, 0.00166959f, -0.01406959f, -0.18733419f, -0.16507953f, 0.02532169f, -0.10029415f, -0.03082266f, 
    0.09616556f, 0.06775364f, 0.14548947f, 0.20616451f, -0.03177837f, -0.00762496f, -0.05783416f, -0.11399557f, 
    -0.28514558f, -0.12205362f, -0.07203977f, 0.00323834f, -0.08325392f, -0.27376926f, 0.12176771f, -0.08725749f, 
    -0.07391230f, 0.06212562f, -0.17666240f, -0.08103464f, 0.09867064f, 0.16913088f, -0.04079701f, 0.19793400f, 
    0.00537234f, 0.03475735f, 0.10468958f, 0.09866334f, 0.11293753f, -0.02717547f, -0.04487037f, 0.10158767f, 
    0.24354693f, 0.03565051f, 0.13368198f, -0.14454956f, 0.13355532f, 0.04819276f, -0.01230486f, 0.05155792f, 
    -0.05151075f, -0.15790032f, -0.01510498f, -0.09808873f, 0.00391010f, -0.18760492f, 0.15162797f, -0.05165190f, 
    -0.13673818f, 0.04876515f, 0.09382252f, 0.02850806f, 0.03180530f, 0.04902107f, -0.00446957f, -0.01095849f, 
    0.02323767f, -0.13826598f, -0.04741544f, 0.25309813f, 0.07722752f, -0.07892270f, 0.05293781f, 0.18018481f, 
    -0.07768334f, 0.04143498f, -0.17713198f, -0.05868114f, 0.13207999f, -0.06179849f, 0.09895216f, 0.16996951f, 
    0.01407774f, 0.09375964f, 0.26041839f, -0.00745796f, 0.07356079f, 0.12264557f, 0.07423413f, 0.06952262f, 
    -0.19605206f, 0.11106351f, -0.14591806f, -0.16870220f, -0.15699619f, -0.04628735f, 0.01041026f, -0.08044744f, 
    0.02956272f, -0.01946411f, 0.11882208f, 0.07045448f, -0.00031944f, 0.07810458f, -0.06875937f, -0.15018767f, 
    -0.08555302f, 0.02962553f, -0.06974692f, 0.04863763f, 0.11031576f, -0.05221043f, -0.02867977f, 0.10721372f, 
    -0.18512720f, 0.05367962f, 0.03619401f, -0.01954600f, 0.06463532f, -0.04205967f, -0.01218806f, 0.14000984f, 
    0.03527929f, 0.00958203f, 0.02657671f, 0.02941591f, -0.07551736f, -0.07802406f, -0.02274189f, 0.01914473f, 
    0.06702697f, 0.07124497f, 0.08767352f, -0.00377390f, 0.09695400f, -0.03430594f, 0.07794263f, 0.07553204f, 
    -0.11813782f, -0.15161721f, -0.23101866f, -0.04540001f, 0.09800267f, -0.17919309f, -0.04733051f, -0.04455751f, 
    -0.09069767f, 0.09215364f, -0.00860464f, -0.14986330f, 0.01177903f, 0.04392341f, 0.17537665f, 0.12448045f, 
    0.12475853f, 0.04276203f, -0.13077256f, 0.01889250f, 0.01720502f, -0.02980898f, 0.04200650f, 0.05153336f, 
    0.09210078f, -0.06846763f, 0.17804937f, 0.01068430f, 0.02775385f, -0.09732106f, 0.09580328f, 0.00925786f, 
    0.04694398f, -0.16460034f, 0.11654602f, -0.05872941f, -0.15778123f, -0.24841462f, -0.02947970f, 0.19957361f, 
    0.10863321f, -0.03292013f, 0.21154107f, 0.23844475f, -0.10931732f, 0.11870924f, 0.00680754f, 0.01827041f, 
    -0.29113767f, -0.29303917f, -0.19813521f, 0.06942241f, -0.02993195f, -0.09793907f, 0.04676826f, -0.15536806f, 
    -0.16600274f, -0.03228548f, 0.09337305f, -0.16764839f, -0.05412163f, 0.00895277f, 0.25317061f, -0.06722995f, 
    -0.05790308f, 0.12203504f, -0.05257517f, 0.08319570f, 0.06930333f, 0.09414954f, 0.27252501f, -0.11336160f, 
    -0.06633139f, -0.01402697f, 0.00408343f, -0.10493565f, -0.01284056f, 0.02903495f, 0.05447422f, -0.02694862f, 
    0.09106881f, 0.03733106f, 0.04898515f, -0.02172958f, -0.21343550f, -0.09177718f, -0.00831524f, 0.09687287f, 
    0.17905414f, 0.12901822f, 0.07565254f, -0.00865603f, -0.07058569f, -0.00680227f, -0.02810126f, -0.16113180f, 
    -0.31803086f, 0.05620825f, -0.04864459f, -0.00573322f, 0.17076291f, 0.14135341f, 0.02584926f, 0.00452424f, 
    -0.02511540f, -0.15084673f, 0.09802035f, 0.11245279f, 0.00371546f, -0.00331166f, 0.03725062f, -0.03672647f, 
    0.02629538f, -0.00767830f, 0.05355009f, 0.16355941f, 0.05433973f, -0.14284526f, -0.08165640f, -0.10286196f, 
    -0.07341985f, -0.01547655f, 0.14835888f, -0.15523629f, 0.00245287f, 0.00532448f, 0.04147542f, 0.04025479f, 
    -0.03897873f, -0.02027131f, -0.12290064f, -0.09348378f, -0.00201333f, -0.04751961f, 0.02975115f, 0.02024275f, 
    0.01360160f, 0.07452136f, 0.03841547f, -0.03333384f, 0.12275211f, -0.03371004f, 0.15146831f, 0.12663369f, 
    0.05899629f, -0.03670262f, 0.27730468f, -0.08608361f, -0.08728109f, 0.03552353f, -0.07331613f, 0.13496719f, 
    0.21967286f, 0.03797132f, 0.00040720f, 0.08846739f, -0.10370190f, -0.06313968f, 0.01367476f, 0.05605941f, 
    -0.10020487f, 0.03412439f, 0.24970065f, 0.03826990f, 0.12753154f, -0.06026258f, -0.14950570f, -0.02062756f, 
    0.09043685f, 0.25597352f, -0.00428389f, 0.33840138f, -0.07705590f, 0.10737077f, 0.01536638f, 0.01817749f, 
    0.11892305f, -0.13402116f, 0.08390824f, 0.23494443f, -0.04708295f, 0.20470485f, 0.00507978f, -0.05429560f, 
    -0.07160061f, 0.07454585f, -0.07875685f, 0.17424889f, 0.01970633f, 0.03482281f, 0.09870311f, 0.03954993f, 
    0.12649503f, 0.06695073f, 0.07104008f, -0.06972793f, 0.08545572f, 0.09752932f, 0.03233417f, -0.06413869f, 
    0.08535000f, 0.02875535f, 0.12561139f, 0.07260693f, -0.14528975f, -0.11910050f, -0.10263505f, -0.09106778f, 
    -0.06310162f, -0.13780081f, -0.21289180f, -0.02268762f, -0.00462938f, -0.07098474f, 0.15482855f, 0.18255898f, 
    -0.00782160f, 0.00032414f, -0.02132191f, 0.04099032f, 0.01652061f, -0.01254311f, -0.04270457f, -0.00809706f, 
    0.00977511f, 0.03148562f, 0.02287288f, -0.00600457f, 0.03153406f, 0.03534323f, -0.04005075f, -0.03647533f, 
    -0.05322643f, -0.01363074f, -0.03767024f, 0.02189599f, 0.04167735f, -0.00918180f, -0.02365593f, -0.04687747f, 
    -0.01418890f, 0.01148482f, 0.00752300f, -0.03025766f, -0.01570372f, -0.03121003f, -0.04162060f, -0.02796560f, 
    -0.04356698f, -0.01692544f, -0.00701063f, 0.01895574f, 0.02968900f, 0.01660437f, -0.03885131f, -0.00820387f, 
    0.00298422f, -0.04590502f, -0.01357932f, -0.03685403f, -0.03680470f, 0.01549872f, 0.01500449f, -0.04721336f, 
    0.03284317f, -0.02831846f, -0.02342922f, 0.04397549f, -0.01085128f, 0.04553983f, 0.00793484f, 0.03554335f, 
    -0.04585172f, -0.00515232f, -0.03505597f, 0.00918685f, 0.00645192f, 0.03363344f, -0.04298580f, 0.02789994f, 
    0.01801048f, -0.01199561f, 0.02266375f, -0.01852448f, 0.02141415f, -0.04591190f, -0.04873460f, -0.03541136f, 
    -0.04889464f, -0.01641944f, -0.01200304f, -0.00592513f, -0.02481222f, 0.04401173f, 0.04018770f, -0.01154380f, 
    -0.01538910f, 0.02919392f, 0.01188235f, 0.03035091f, -0.00406787f, -0.04487251f, -0.01488250f, -0.04188497f, 
    -0.00046435f, 0.04488629f, 0.02281058f, 0.00396088f, -0.05380728f, 0.03539346f, 0.02604018f, -0.04746681f, 
    -0.02395343f, -0.01254739f, -0.03475869f, 0.03520716f, 0.00680119f, 0.00904520f, -0.02642439f, 0.01242983f, 
    -0.00053616f, -0.03746569f, 0.01600676f, 0.01721080f, -0.02093933f, -0.05208402f, -0.05268523f, -0.04093214f, 
    -0.04810155f, -0.02924805f, -0.03538552f, 0.00713907f, -0.04509200f, -0.00948686f, 0.02858661f, -0.04617300f, 
    0.00353125f, -0.00475823f, -0.00350971f, -0.02827040f, -0.03110984f, -0.05596724f, 0.03361810f, 0.03028640f, 
    0.01226571f, -0.01327119f, 0.03017056f, -0.00407433f, -0.02557422f, 0.03603408f, 0.04349873f, 0.00605373f, 
    -0.00959838f, -0.01799686f, 0.00469543f, -0.02506391f, -0.03926784f, -0.04483180f, -0.00818136f, -0.02648407f, 
    -0.00705185f, 0.02764495f, -0.04697143f, -0.03608251f, -0.03603075f, -0.04013490f, -0.04139704f, -0.05636426f, 
    -0.03976520f, -0.02299090f, -0.02320411f, -0.02730733f, 0.03059386f, 0.01798097f, -0.03104305f, -0.04874253f, 
    -0.03977285f, -0.01771595f, 0.03810655f, -0.00720893f, -0.04639002f, -0.02040504f, 0.04275777f, -0.05102756f, 
    -0.02425452f, 0.02574038f, 0.01273757f, -0.03997759f, 0.02010872f, 0.02678587f, -0.05363061f, 0.00739346f, 
    0.00437647f, 0.00099666f, 0.04999020f, 0.02866172f, -0.01205342f, 0.03738092f, -0.00067011f, 0.01314206f, 
    -0.01096208f, -0.03570725f, -0.01327778f, 0.01947593f, -0.03939786f, 0.01259220f, 0.02762993f, 0.04491152f, 
    0.02227560f, -0.00181050f, 0.01094043f, -0.02657773f, 0.03031186f, 0.01788105f, -0.03541167f, -0.04978715f, 
    -0.04440339f, 0.03193697f, 0.03839047f, -0.02722008f, 0.03994626f, 0.00462336f, 0.03984281f, -0.00110957f, 
    -0.02002186f, -0.03007211f, -0.03842223f, 0.00732694f, -0.02246199f, 0.01325956f, 0.00874065f, 0.00071305f, 
    -0.05269341f, 0.02138424f, 0.03947511f, -0.02153585f, 0.02196495f, -0.00206977f, 0.00573044f, 0.01027256f, 
    -0.04569821f, 0.01295033f, -0.00625490f, -0.03742805f, -0.04057481f, -0.00463543f, -0.03014019f, 0.02441812f, 
    0.03970165f, -0.04176335f, -0.01995513f, -0.05251240f, 0.02501601f, 0.02344302f, 0.02896417f, 0.01444050f, 
    -0.01274746f, -0.05107261f, -0.01989904f, -0.02656520f, -0.01079678f, -0.05471639f, 0.02060715f, 0.03895675f, 
    -0.01436781f, 0.01531607f, -0.01331340f, 0.02470024f, -0.04731373f, -0.00071233f, -0.02813452f, 0.01375406f, 
    0.02509933f, 0.00105688f, -0.02687091f, -0.03947574f, -0.00321068f, -0.01359337f, -0.04244099f, 0.01407642f, 
    -0.02180449f, 0.02908899f, -0.02952638f, 0.00607516f, -0.01907279f, 0.00246632f, -0.00941897f, -0.05401723f, 
    -0.04143715f, -0.04023124f, -0.02891661f, 0.01409166f, -0.03474400f, 0.03691269f, -0.04952492f, 0.01860770f, 
    0.04396399f, -0.04491841f, -0.03403682f, 0.00272949f, 0.01063636f, -0.01203696f, -0.01140660f, 0.04218433f, 
    0.01565776f, -0.04672444f, -0.04354299f, 0.04216904f, 0.00638948f, 0.04371985f, 0.02086359f, -0.01728363f, 
    -0.00591394f, -0.01413826f, -0.04644258f, -0.00242971f, -0.00616916f, 0.02730557f, -0.05686043f, -0.00720313f, 
    0.02560389f, -0.02913807f, 0.03382823f, -0.02757297f, 0.03415548f, 0.02896481f, 0.01270272f, -0.00472197f, 
    -0.01022971f, -0.02356618f, -0.05701367f, 0.00882736f, -0.02116484f, 0.00254019f, -0.05535104f, -0.05585372f, 
    0.02876618f, 0.03561296f, 0.04912253f, 0.02715211f, -0.00754244f, 0.00941311f, -0.01131570f, 0.01014384f, 
    -0.04106417f, 0.03517090f, -0.03529170f, 0.02783442f, -0.00556856f, 0.00807036f, -0.02131595f, -0.00570859f, 
    -0.04099359f, -0.01475191f, 0.04264751f, -0.04543620f, 0.02444766f, 0.04320356f, 0.02958955f, 0.04597429f, 
    0.04116973f, 0.01071429f, -0.04132348f, -0.05375626f, -0.05575585f, 0.02331302f, -0.02226654f, 0.04267358f, 
    0.04462472f, 0.00015492f, 0.00978667f, 0.00027661f, -0.01385726f, 0.02468120f, 0.01439356f, -0.05550167f, 
    -0.02386830f, -0.05175890f, -0.03874930f, 0.00198667f, -0.03974808f, -0.04599676f, -0.01352715f, -0.00051210f, 
    0.01693983f, -0.04421191f, -0.02854468f, 0.00094128f, 0.00708211f, 0.01340805f, 0.03284276f, 0.00544205f, 
    0.02898394f, 0.03386526f, -0.00287998f, -0.02784205f, -0.01880064f, 0.03532520f, 0.03270014f, -0.02427624f, 
    -0.05453772f, 0.02888908f, 0.14409490f, 0.09754447f, -0.07768784f, -0.09964319f, -0.03647804f, -0.03817432f, 
    0.01440323f, -0.03861444f, -0.01011501f, 0.02696687f, 0.45640960f, -0.07890988f, -0.08732285f, -0.17131166f, 
    -0.09254736f, 0.01499767f, 0.12950021f, -0.08917467f, 0.05684676f, 0.09045935f, 0.15134344f, 0.09933768f, 
    -0.07118583f, -0.09406020f, -0.33960366f, 0.11667290f, -0.29817137f, 0.11334722f, 0.04288726f, 0.01482231f, 
    -0.02327796f, 0.03422808f, -0.03219933f, 0.02008928f, -0.14345127f, -0.10330301f, 0.04939275f, 0.18698063f, 
    -0.13167056f, -0.11165726f, -0.09789652f, -0.02737697f, 0.02514079f, -0.02297175f, 0.00800577f, 0.06293220f, 
    -0.24932383f, 0.07102288f, -0.03431191f, -0.07290882f, -0.01431068f, -0.28027695f, 0.03189316f, -0.10631038f, 
    0.05944259f, 0.02082925f, 0.07472211f, 0.09642268f, 0.28040746f, 0.17891897f, -0.02663506f, -0.09633721f, 
    0.04236502f, -0.15190645f, 0.24574414f, 0.20047663f, 0.00659603f, 0.18529251f, 0.19826116f, -0.04836657f, 
    -0.05064104f, 0.02755154f, 0.03886225f, 0.11114929f, 0.10630836f, 0.01055436f, -0.05260563f, 0.10626008f, 
    0.06171323f, 0.13894492f, 0.17350328f, 0.02927111f, -0.11123449f, -0.10519283f, 0.04121902f, -0.05906925f, 
    0.10436426f, 0.00209610f, -0.09739488f, 0.01088880f, 0.00871304f, 0.00545613f, -0.04927942f, -0.00917558f, 
    0.18641929f, 0.02337024f, 0.10862945f, -0.35574833f, 0.14212188f, 0.01468392f, -0.12021749f, -0.01139576f, 
    0.06246430f, 0.01906066f, -0.01218083f, -0.05732722f, -0.14058620f, -0.21920678f, 0.02589444f, 0.02528446f, 
    0.03367215f, 0.01580114f, -0.14438808f, 0.18134530f, -0.11307185f, -0.07221154f, -0.07776189f, 0.04531481f, 
    0.23903261f, 0.06815644f, 0.07787751f, 0.13440327f, 0.01438842f, 0.01470965f, -0.05525732f, -0.00252227f, 
    0.03735912f, -0.02970471f, -0.08825849f, -0.07423289f, -0.27734149f, -0.02759117f, 0.22194988f, 0.04880303f, 
    0.03664327f, 0.03560747f, -0.07374819f, -0.03440122f, -0.14234379f, 0.06297960f, 0.02086211f, -0.02733889f, 
    0.14561918f, -0.03818962f, 0.00223615f, 0.04087465f, 0.03495282f, -0.00800352f, 0.12289196f, 0.10451761f, 
    0.00511433f, 0.00028533f, -0.06928948f, -0.15643147f, -0.00264193f, -0.09183995f, 0.02739428f, 0.06007211f, 
    -0.06920818f, 0.03734696f, 0.05964027f, 0.05517799f, -0.03243088f, -0.10503572f, -0.10864244f, -0.04549548f, 
    0.14223146f, -0.04791445f, 0.03513142f, 0.06112779f, 0.02728064f, -0.03779289f, 0.06353667f, 0.17487118f, 
    0.03535982f, 0.10019201f, 0.20260467f, 0.13264586f, -0.24703513f, -0.18084522f, -0.09382538f, 0.22725740f, 
    0.06802470f, 0.10961425f, 0.13807622f, -0.00078592f, -0.02150956f, 0.01176199f, 0.04966854f, 0.04336952f, 
    -0.09671593f, -0.09273521f, 0.08105508f, 0.02540404f, -0.06039875f, 0.07103609f, -0.04954204f, -0.14511181f, 
    0.15104662f, 0.17925350f, 0.21954627f, 0.10815102f, 0.01114511f, -0.04101469f, -0.04312062f, -0.01070839f, 
    -0.14163961f, 0.17319810f, -0.04389861f, -0.08982621f, 0.11268628f, -0.12957795f, -0.09033597f, 0.04434124f, 
    0.17084701f, -0.07918558f, -0.00353596f, 0.07645729f, 0.14437032f, 0.17611878f, -0.00910193f, 0.01558725f, 
    0.08152284f, -0.02776321f, -0.05117116f, -0.00145372f, 0.32742640f, -0.02990369f, -0.01916832f, 0.18635078f, 
    0.07897401f, -0.09526551f, 0.05720535f, -0.03382872f, 0.05025244f, 0.02035833f, -0.20338748f, -0.11397538f, 
    0.15952611f, 0.04659182f, 0.08126322f, 0.08895824f, 0.05126627f, 0.05657206f, -0.02682517f, -0.00246352f, 
    0.11338983f, 0.06260701f, 0.11027379f, 0.15495697f, 0.27537474f, -0.01275756f, -0.04177852f, 0.06992430f, 
    0.05793847f, 0.14027120f, 0.15078446f, 0.02488738f, 0.15021679f, -0.04597602f, 0.05520491f, 0.10436327f, 
    0.26189393f, 0.05618887f, -0.02325460f, -0.10174105f, 0.01178726f, 0.03295536f, -0.13380787f, 0.07381626f, 
    -0.06259122f, -0.03094618f, -0.05913360f, -0.01198398f, -0.04861862f, 0.10062024f, -0.10521909f, 0.02275016f, 
    -0.15180966f, -0.04704700f, 0.02474934f, -0.07752331f, 0.06146400f, 0.15116616f, 0.06347049f, 0.15661199f, 
    -0.10364597f, -0.06447427f, -0.10754599f, 0.18329822f, -0.10240350f, 0.07210151f, -0.11362951f, 0.03722274f, 
    -0.06969775f, 0.07107729f, 0.24515930f, 0.12606837f, -0.02654202f, 0.04424721f, 0.18036027f, 0.08524368f, 
    0.02853120f, -0.09077222f, 0.02446796f, 0.07655378f, -0.07157540f, 0.00715308f, 0.01941882f, -0.07512175f, 
    0.19786814f, -0.05169224f, 0.25547159f, -0.08176136f, 0.05200408f, -0.03779596f, -0.02376125f, -0.10540652f, 
    0.05384244f, 0.07115582f, 0.08193990f, -0.05158056f, 0.25876287f, 0.15060739f, -0.02125940f, -0.32128531f, 
    -0.04811896f, -0.04695745f, -0.01143021f, -0.09484638f, 0.08872890f, 0.08367626f, 0.11050852f, 0.02382719f, 
    -0.24252315f, -0.22621530f, 0.11561053f, 0.07231607f, 0.01757621f, -0.03392948f, 0.00593361f, 0.05331624f, 
    -0.03105876f, -0.01585960f, 0.07321090f, -0.14239325f, 0.27207035f, 0.11872501f, -0.09178472f, 0.09257126f, 
    0.00107230f, -0.07161144f, 0.06509078f, 0.06319644f, -0.03862598f, -0.09449297f, 0.07515586f, -0.10529360f, 
    -0.02645970f, 0.00966436f, 0.19186334f, 0.04171355f, 0.04006247f, 0.04314901f, -0.04967896f, -0.00231283f, 
    0.02704194f, -0.00548000f, -0.01635369f, 0.00238749f, 0.14108366f, 0.09748348f, -0.10099276f, -0.03503830f, 
    -0.04073393f, 0.01206829f, -0.03847898f, 0.00810739f, 0.07351253f, 0.05662958f, -0.01288461f, -0.09272987f, 
    -0.02180773f, -0.06732845f, -0.15414904f, -0.01789620f, 0.09375575f, 0.16990176f, 0.07313064f, -0.01895936f, 
    -0.02566500f, -0.03649772f, -0.00039638f, -0.01906982f, -0.15153772f, -0.00123221f, 0.46339867f, -0.07751103f, 
    0.01138907f, 0.07963066f, -0.19075118f, 0.06502699f, -0.04992765f, -0.02809872f, 0.06004718f, -0.01465629f, 
    0.20874840f, 0.34127581f, 0.44825202f, -0.06582566f, 0.31186840f, -0.08138577f, -0.15843455f, 0.04614978f, 
    -0.03103460f, 0.05607140f, 0.03647669f, 0.05133437f, 0.26703057f, 0.29794309f, 0.02609821f, -0.07247555f, 
    -0.00828163f, 0.01955328f, 0.16658576f, 0.04269040f, 0.06243984f, -0.00463254f, -0.01682127f, -0.02874619f, 
    0.35443345f, 0.09520810f, 0.21396567f, 0.00625774f, 0.16323622f, 0.29979774f, -0.01872787f, 0.15623310f, 
    -0.14070837f, -0.01868158f, 0.01680904f, -0.07671224f, -0.20674992f, -0.14625135f, -0.03712536f, 0.12461509f, 
    -0.01191124f, 0.26486281f, 0.08207926f, 0.07456121f, 0.08197607f, -0.12201911f, -0.10893600f, -0.06330382f, 
    -0.08008981f, -0.09426822f, -0.26978233f, 0.11845095f, -0.00746654f, 0.07763582f, 0.11327430f, -0.01934116f, 
    0.07952857f, 0.01333063f, -0.15166824f, -0.02803905f, -0.02030817f, 0.22736934f, -0.15910092f, 0.02089001f, 
    0.04145329f, 0.10905427f, 0.24982032f, -0.17354238f, -0.11133684f, -0.00742937f, 0.01605847f, 0.06659284f, 
    -0.09235299f, -0.19782090f, -0.01830859f, -0.06000492f, 0.07681271f, 0.21617538f, 0.00727695f, 0.19985364f, 
    -0.10111574f, 0.03695936f, 0.11823791f, 0.17322180f, 0.11637904f, 0.25734288f, 0.11295594f, 0.03179663f, 
    -0.00328551f, 0.04954053f, -0.03136185f, -0.04362090f, -0.00277732f, -0.01150434f, -0.00062628f, -0.07856187f, 
    0.04150141f, 0.03954650f, 0.25196409f, 0.00696068f, -0.00952084f, -0.01477297f, -0.06405128f, 0.06019183f, 
    -0.03811157f, -0.03272818f, 0.07783985f, 0.04888708f, 0.21517082f, 0.09722810f, 0.16942802f, -0.10360705f, 
    0.05973031f, -0.05728307f, 0.18672712f, -0.07533398f, 0.09321080f, -0.12861930f, -0.05534007f, -0.07249331f, 
    -0.00294660f, 0.03848897f, 0.06138946f, -0.01167402f, 0.04928459f, 0.18584387f, -0.10473599f, -0.12487907f, 
    -0.10660274f, 0.04906857f, -0.04268476f, 0.05861379f, 0.07304791f, 0.08064353f, 0.06941617f, -0.00670783f, 
    0.00507454f, -0.17314287f, -0.10310648f, -0.10911305f, -0.05000065f, 0.09913918f, 0.02280782f, 0.00401209f, 
    -0.04915834f, 0.08937220f, 0.08411966f, -0.04077302f, -0.05697094f, 0.04723724f, -0.03720561f, -0.14683025f, 
    0.11389536f, -0.19062594f, 0.04542257f, 0.13600947f, 0.27721739f, 0.29951349f, -0.27848306f, -0.03774807f, 
    -0.15096289f, -0.18010946f, -0.06098677f, -0.06229610f, 0.01754160f, 0.04721216f, -0.04917479f, -0.06007645f, 
    -0.05874816f, -0.04777031f, -0.19474632f, 0.01970698f, 0.06402750f, 0.17904224f, -0.00698491f, 0.24188089f, 
    0.08370145f, 0.02737848f, -0.22947887f, 0.15900943f, 0.07462367f, 0.07139903f, 0.02608906f, -0.03963071f, 
    0.08198292f, -0.02478107f, -0.08827101f, 0.22324933f, -0.03361477f, 0.00845444f, -0.00880023f, 0.07315915f, 
    -0.00464404f, 0.07834818f, 0.07426514f, -0.03233009f, -0.02919766f, -0.07855163f, -0.00131703f, 0.03394097f, 
    -0.05890370f, -0.07788827f, 0.05616828f, 0.03262782f, 0.03120883f, 0.07756297f, -0.20384437f, 0.11725034f, 
    -0.07006270f, 0.01918682f, 0.06118564f, -0.00563763f, -0.04025985f, -0.00418737f, 0.03253080f, 0.20621940f, 
    -0.13966557f, -0.04281443f, -0.06907298f, 0.00905627f, -0.02493479f, 0.04077628f, -0.07787209f, 0.03729207f, 
    -0.20454679f, -0.07190037f, -0.06074029f, -0.00114111f, -0.20377834f, 0.00933830f, 0.00785956f, -0.06771030f, 
    -0.07299814f, -0.07071672f, -0.14266957f, 0.07833627f, 0.00832895f, -0.01035316f, 0.00737023f, 0.06016371f, 
    -0.02157829f, 0.06923816f, 0.08861838f, -0.03399446f, 0.07974707f, -0.05538892f, 0.09552500f, -0.03761578f, 
    0.01621892f, 0.03654724f, 0.03564621f, 0.01879481f, 0.09703042f, -0.23981616f, -0.05560927f, -0.03454562f, 
    0.15604876f, 0.05244663f, 0.01933757f, -0.00068616f, -0.02788716f, 0.03073044f, 0.11066006f, -0.04541089f, 
    0.19841471f, 0.11583052f, -0.00653191f, -0.02693638f, 0.01200001f, -0.08150935f, 0.12305748f, 0.08057424f, 
    0.05365322f, -0.05447208f, 0.03040347f, 0.03630611f, -0.06532560f, 0.10454134f, -0.04846526f, 0.03291907f, 
    0.11941478f, 0.04272163f, 0.05608284f, -0.06400486f, -0.01804763f, -0.01579782f, -0.07200309f, -0.02715764f, 
    0.15665400f, 0.16676481f, -0.21963567f, 0.05724931f, -0.08182167f, -0.00404775f, 0.20665583f, -0.09854016f, 
    -0.09794362f, 0.04519868f, -0.04811944f, 0.03631546f, -0.05818437f, -0.16277498f, -0.41484389f, 0.19242476f, 
    0.02978844f, 0.17311706f, -0.10215726f, 0.09392713f, 0.03276161f, 0.12160446f, -0.00740795f, 0.00494171f, 
    0.24605398f, -0.01454625f, 0.01766999f, -0.12398268f, 0.07148988f, 0.16382734f, -0.01346103f, -0.04111570f, 
    -0.11286476f, 0.12907852f, -0.11011836f, 0.04810304f, -0.16468339f, -0.11788435f, 0.04972314f, -0.02392757f, 
    -0.05467649f, 0.08702269f, -0.02690788f, 0.05717570f, 0.21574754f, -0.00158745f, 0.02768074f, -0.19138999f, 
    0.06712704f, 0.05828372f, -0.01941193f, 0.05369510f, 0.01799072f, -0.00405359f, 0.00678279f, -0.06638776f, 
    -0.06798149f, -0.02420706f, -0.10555439f, -0.01333076f, -0.06422159f, 0.03994925f, 0.11466729f, 0.01545203f, 
    0.00364135f, -0.00688056f, 0.05310889f, 0.09673041f, -0.21500117f, -0.10039008f, 0.01830542f, 0.08910751f, 
    0.10328091f, 0.12876959f, 0.02050195f, -0.00669485f, -0.14223658f, -0.06572775f, 0.05798664f, -0.01997099f, 
    -0.01329542f, -0.07410669f, -0.02084377f, -0.01531727f, -0.29950154f, 0.15930600f, -0.38305026f, 0.02121532f, 
    0.00932025f, 0.02000072f, -0.00229993f, 0.05617369f, 0.10478485f, -0.02932052f, -0.10230506f, 0.16642839f, 
    -0.34729797f, -0.01126672f, -0.25743783f, -0.11116976f, -0.08708018f, 0.14288402f, 0.04298688f, 0.12898575f, 
    0.02155372f, -0.08770784f, -0.06288842f, 0.09484138f, 0.05203838f, 0.16503680f, 0.12581356f, -0.05704248f, 
    0.02456659f, 0.04559394f, -0.18011707f, 0.01125387f, 0.04150657f, -0.00528032f, -0.05775562f, 0.06665420f, 
    0.18550657f, 0.26661035f, 0.28847191f, 0.01299486f, -0.10080764f, -0.07894737f, -0.09907681f, 0.09049741f, 
    0.01192973f, -0.03068945f, -0.04613887f, -0.01719038f, 0.45465013f, 0.11567933f, 0.12204514f, -0.13472393f, 
    0.06160625f, -0.04529188f, 0.02972586f, 0.00332406f, -0.11033148f, 0.11721626f, 0.02863182f, 0.01537312f, 
    0.12292649f, 0.03257431f, 0.09976043f, -0.16120309f, -0.06774741f, 0.04993842f, -0.06236677f, -0.03239540f, 
    0.05591677f, 0.01659761f, -0.05751537f, 0.03395280f, 0.04505760f, -0.04126017f, 0.22324769f, 0.12894261f, 
    -0.05738090f, 0.00964390f, -0.16237816f, -0.11546963f, -0.06171021f, -0.01458567f, -0.07885898f, 0.05447410f, 
    -0.02943430f, 0.14361508f, -0.13440183f, -0.10956035f, 0.14832149f, -0.09497116f, -0.11635514f, -0.14169762f, 
    -0.02264991f, 0.04717206f, -0.03831875f, 0.02685591f, -0.00488197f, -0.07719430f, 0.11688039f, 0.09635945f, 
    -0.00590059f, -0.09431177f, 0.11367624f, 0.08240025f, -0.03799104f, -0.04501109f, -0.02246852f, 0.01248119f, 
    -0.13101053f, 0.11799427f, -0.06530778f, 0.14226042f, 0.08757256f, 0.15241024f, 0.17017236f, 0.03018519f, 
    0.15598477f, 0.06963862f, 0.02140738f, 0.12215073f, 0.13667105f, -0.27176777f, 0.31624383f, -0.24922751f, 
    0.10753253f, -0.02889689f, 0.08982378f, 0.02306944f, -0.05034924f, -0.09584656f, -0.01252304f, -0.02797137f, 
    0.02044579f, 0.04547990f, 0.00655700f, 0.10559469f, -0.03267166f, 0.05247331f, 0.11560509f, 0.05964648f, 
    -0.00866905f, 0.03902779f, -0.08511559f, -0.02973218f, -0.03033401f, -0.05035776f, 0.02757422f, 0.06320253f, 
    -0.05863782f, 0.06591202f, 0.21704288f, 0.11079496f, -0.04976371f, -0.04521266f, -0.02658648f, 0.04255170f, 
    0.00598232f, -0.11141752f, 0.01789271f, 0.09872226f, 0.08783655f, 0.04470994f, 0.20192643f, 0.06273454f, 
    0.06093486f, -0.06320621f, 0.06852727f, 0.21113732f, 0.08116978f, -0.12984318f, -0.12293842f, -0.28412503f, 
    0.09658859f, -0.01868633f, 0.02481202f, 0.10249665f, -0.02672218f, -0.00848639f, 0.06484288f, 0.00676299f, 
    0.19516630f, 0.01255856f, 0.04750609f, -0.04138378f, 0.00047669f, 0.03908064f, -0.11035735f, 0.00663639f, 
    -0.01063465f, 0.12748174f, -0.04575672f, 0.08200049f, -0.02493224f, 0.09242840f, -0.01276369f, 0.12925166f, 
    -0.02933900f, -0.00026028f, -0.07588772f, -0.09178490f, 0.02419364f, 0.06726854f, 0.16938318f, 0.06832369f, 
    -0.07957014f, -0.04062276f, -0.09076065f, 0.12943801f, 0.00670748f, 0.00843804f, 0.02321655f, 0.10569973f, 
    0.09074551f, 0.09985150f, 0.05173285f, -0.05343131f, 0.01660754f, 0.00767304f, 0.07012099f, 0.06306094f, 
    0.17999074f, 0.15181607f, -0.05651316f, 0.09648200f, 0.02727593f, -0.03210778f, 0.01863544f, -0.09744554f, 
    -0.13864496f, -0.01515133f, 0.18462740f, 0.14907852f, 0.05519334f, 0.10602999f, -0.04985279f, -0.01441440f, 
    0.02454357f, 0.07386008f, 0.12621257f, 0.18192023f, 0.05002186f, 0.10709783f, -0.10408384f, -0.36490661f, 
    0.03320899f, 0.00260225f, 0.15817642f, 0.03500195f, 0.08299123f, 0.02369857f, 0.07521277f, -0.00810542f, 
    -0.02098583f, 0.16154149f, -0.02281672f, -0.04265685f, -0.02441149f, -0.10436280f, 0.25776538f, -0.09513034f, 
    -0.06773663f, 0.10731820f, 0.07344767f, -0.02901049f, -0.02471260f, 0.14352258f, -0.02158169f, 0.24182843f, 
    -0.13680330f, 0.03971929f, -0.06743687f, -0.00660183f, 0.02680893f, -0.07050917f, 0.05422663f, 0.14499722f, 
    0.17141111f, -0.07945162f, 0.09218685f, -0.00421984f, -0.16160753f, 0.00831044f, -0.01945595f, 0.02869023f, 
    -0.07495820f, -0.11846323f, -0.13873547f, -0.08556202f, 0.10717363f, -0.11154043f, 0.03564478f, -0.10607620f, 
    0.05144836f, 0.05806276f, -0.02251798f, -0.08679546f, -0.09645353f, -0.17862010f, -0.01494479f, -0.18337725f, 
    0.57672507f, -0.18132757f, 0.04404534f, 0.08280268f, -0.09237570f, 0.18105140f, -0.08950645f, 0.06223896f, 
    0.11477960f, -0.04027570f, 0.09353052f, 0.00565396f, 0.05734372f, 0.05519022f, 0.09421904f, -0.27979985f, 
    0.08028870f, -0.10063358f, -0.04287217f, -0.06104568f, 0.13810299f, -0.01563463f, -0.27833340f, -0.00191346f, 
    -0.44752380f, 0.33262092f, 0.15612450f, 0.17630401f, -0.13687147f, 0.09173296f, 0.17606342f, 0.02909954f, 
    0.06121325f, 0.07666163f, 0.00859273f, -0.20039922f, 0.20124780f, -0.04435185f, 0.20421852f, 0.04798914f, 
    -0.02643664f, 0.08460045f, -0.02006021f, 0.03345319f, -0.15694176f, -0.01261002f, 0.07721810f, -0.16232723f, 
    0.10288578f, 0.15252660f, -0.07786248f, -0.11491838f, -0.01670482f, 0.06662100f, -0.02892918f, 0.11552624f, 
    -0.03403191f, -0.06719776f, -0.09170380f, -0.00813940f, 0.07777921f, 0.01981049f, 0.11678761f, 0.17429997f, 
    0.01914314f, 0.07797036f, 0.11165751f, -0.08352181f, -0.07139993f, -0.04955197f, -0.18282971f, -0.03296174f, 
    -0.03318093f, -0.02885961f, 0.00429518f, -0.04238703f, 0.08821040f, 0.12536567f, 0.08255430f, -0.05828257f, 
    0.00767230f, -0.01205589f, 0.00493617f, 0.04521913f, -0.16861558f, 0.18114001f, -0.03150558f, 0.11371337f, 
    -0.02292459f, -0.06707501f, 0.05249123f, 0.01555083f, -0.12475599f, -0.03588242f, -0.00744963f, -0.13955234f, 
    0.42810503f, -0.28882164f, 0.23650171f, 0.12736864f, 0.09433585f, -0.00668989f, -0.04885931f, 0.01890840f, 
    0.09216966f, -0.04203960f, 0.06302869f, -0.09170934f, -0.23744984f, -0.05693123f, -0.00130696f, -0.23664917f, 
    0.01339287f, 0.01104097f, 0.13086343f, 0.12606102f, -0.07876418f, -0.08097898f, 0.04668150f, -0.05782566f, 
    -0.58344442f, -0.33575472f, -0.41113222f, -0.22372100f, -0.05685025f, 0.09327540f, 0.06718214f, 0.08999959f, 
    0.12982562f, 0.00786222f, 0.02346634f, -0.00042190f, -0.18360059f, -0.10535190f, 0.11395108f, -0.21888480f, 
    0.01801777f, 0.06283636f, -0.03317469f, 0.05562381f, 0.23250794f, 0.16848047f, -0.01453956f, -0.06320623f, 
    0.17334841f, -0.08125570f, 0.12715721f, -0.12674889f, 0.05903800f, -0.05879070f, 0.10719747f, 0.04269823f, 
    0.01780810f, -0.14622433f, 0.06934376f, -0.08089307f, 0.07920732f, -0.12360192f, -0.02734484f, -0.02639990f, 
    0.15999411f, 0.08676697f, 0.10917006f, -0.05211856f, 0.04099000f, -0.07482164f, 0.00260873f, 0.08046252f, 
    -0.04702986f, 0.07088348f, -0.29955581f, 0.04060121f, 0.05025964f, 0.06827990f, 0.02451475f, 0.23697627f, 
    -0.10813531f, 0.15516666f, -0.08342984f, -0.17381920f, 0.08584947f, -0.06420846f, 0.23831569f, -0.20927073f, 
    0.12879185f, 0.04082469f, 0.12192351f, -0.02044790f, 0.12621880f, 0.02564437f, 0.05267859f, 0.07503828f, 
    -0.18295351f, -0.00065079f, 0.02563796f, -0.04914894f, 0.02646856f, -0.11846339f, -0.02153851f, -0.05718341f, 
    -0.03129806f, -0.01082397f, 0.10901868f, 0.05937908f, -0.01428253f, 0.09101195f, -0.08837383f, -0.18311128f, 
    -0.08780210f, -0.05468957f, -0.01118523f, 0.02919634f, 0.03335857f, -0.10044601f, 0.02701560f, 0.12992129f, 
    -0.17390460f, 0.12940058f, -0.11089495f, 0.03213805f, 0.11090782f, 0.00463507f, -0.06429613f, 0.08306149f, 
    0.00589584f, -0.01455227f, 0.04115751f, 0.01062709f, -0.00399109f, -0.06242926f, -0.06202929f, -0.07047612f, 
    0.29604542f, -0.02280923f, 0.08237547f, -0.03500045f, 0.06369155f, 0.01171737f, 0.06194979f, 0.07274248f, 
    -0.16852649f, -0.03523277f, -0.18757342f, -0.14387901f, 0.05751970f, 0.09235422f, -0.09330227f, 0.04890576f, 
    -0.09008466f, 0.24649420f, -0.04662780f, -0.16912192f, -0.05383909f, 0.17567426f, 0.13004661f, -0.01540204f, 
    0.01680519f, -0.04918955f, 0.01898336f, 0.20991409f, 0.00136232f, 0.06605614f, -0.00556311f, -0.01631592f, 
    -0.11881848f, 0.23578742f, -0.04111192f, -0.04166837f, -0.06355248f, -0.00770599f, -0.02944404f, 0.05125966f, 
    -0.06536435f, -0.00956444f, 0.02858863f, -0.20703392f, -0.00227862f, -0.01621195f, -0.20222118f, -0.00901647f, 
    0.14181677f, -0.01545448f, 0.07610101f, 0.04423975f, -0.01300801f, 0.12671113f, 0.00572166f, 0.05245508f, 
    0.00248641f, 0.05107606f, -0.14584146f, -0.07941727f, 0.02208799f, -0.05696090f, -0.03480662f, 0.00198726f, 
    -0.07679361f, -0.02761998f, -0.06058182f, 0.00805030f, -0.09200794f, -0.03226959f, 0.04689381f, -0.19514933f, 
    -0.07817880f, -0.05921430f, 0.03808360f, -0.02129558f, 0.01012849f, 0.06468267f, 0.09103315f, 0.14185517f, 
    0.03768849f, -0.06469101f, -0.09777749f, 0.00034384f, -0.07816906f, -0.03641198f, 0.02633970f, 0.02941524f, 
    0.01653679f, -0.00383153f, -0.03203999f, -0.09629609f, -0.00144625f, -0.11311036f, -0.05509698f, 0.12114071f, 
    0.13449678f, 0.17330486f, 0.10170927f, 0.01210612f, -0.03833913f, -0.02625549f, -0.09268812f, -0.06648923f, 
    -0.26823676f, -0.07611987f, -0.04448817f, -0.19413596f, 0.11182807f, 0.13577773f, 0.05198474f, 0.07190604f, 
    0.12762783f, -0.08315787f, -0.02511868f, 0.05388607f, 0.01564832f, -0.08076507f, 0.01328007f, 0.05294187f, 
    0.19899279f, 0.03824375f, 0.05134085f, 0.04572982f, 0.22629680f, -0.06478398f, 0.00980464f, -0.10203744f, 
    0.01777107f, -0.13416630f, 0.15585795f, -0.27898967f, -0.11503983f, -0.04442137f, 0.03640037f, 0.05153717f, 
    -0.02225998f, -0.03115926f, 0.08998922f, 0.02827312f, -0.16395815f, 0.16772957f, -0.12267630f, -0.12885576f, 
    0.05586066f, 0.04856949f, 0.06643864f, -0.00029185f, -0.01582181f, 0.19442336f, 0.11029366f, 0.19304270f, 
    -0.22734724f, 0.16667236f, -0.05448147f, -0.09034681f, -0.06823081f, -0.01470367f, -0.03239327f, -0.00800776f, 
    0.06834805f, 0.23220615f, 0.03406090f, 0.04082900f, -0.18545137f, 0.31675404f, -0.16514611f, -0.03376200f, 
    0.01218986f, -0.01777972f, 0.08628123f, -0.00529515f, -0.02395208f, 0.07794715f, 0.10157390f, 0.06970885f, 
    0.22955820f, 0.05544253f, -0.12377337f, 0.14491594f, 0.06252141f, -0.00661575f, -0.03465321f, 0.08885327f, 
    0.12508416f, -0.07249168f, 0.04923057f, 0.16051459f, 0.18729599f, -0.27017584f, 0.08743791f, -0.06342112f, 
    -0.07030215f, 0.05575624f, -0.10850929f, 0.02248663f, 0.21419550f, 0.13032146f, 0.02488743f, 0.13246788f, 
    -0.01684723f, 0.00499464f, 0.07594099f, -0.02303351f, 0.03007589f, -0.04188679f, 0.10621187f, -0.05805004f, 
    -0.00512354f, 0.08507219f, 0.12414715f, 0.01244985f, -0.01362181f, -0.04425283f, -0.04215169f, -0.05422801f, 
    0.00881560f, -0.00243133f, -0.05350636f, 0.15670697f, 0.06089342f, 0.11731246f, 0.13666916f, 0.14469916f, 
    -0.02022685f, 0.15415287f, 0.23709740f, 0.23134542f, 0.14636008f, 0.27507624f, -0.03982284f, -0.03011121f, 
    0.04575571f, 0.09410422f, 0.04757855f, 0.03363007f, 0.11727943f, 0.19220223f, 0.11028572f, 0.20241342f, 
    0.06301466f, 0.00752914f, -0.10240620f, -0.00942529f, 0.07149009f, 0.12443582f, 0.17462046f, 0.03959922f, 
    -0.13168027f, -0.28533393f, 0.39285618f, 0.20994288f, 0.03883373f, -0.02347520f, -0.21027581f, 0.12131374f, 
    0.02628724f, 0.09192058f, 0.08216795f, -0.03634971f, -0.05858365f, 0.23947233f, 0.00429676f, -0.00119817f, 
    0.00498641f, -0.05065091f, 0.03821013f, 0.07365363f, -0.04686194f, -0.11754738f, -0.05415579f, -0.05911695f, 
    0.02247395f, -0.11216464f, -0.34886375f, -0.36677125f, 0.04195870f, -0.18004669f, -0.07359817f, 0.02528524f, 
    -0.04464010f, -0.02133274f, -0.12804799f, -0.09692095f, 0.28653535f, -0.14952278f, -0.18317065f, -0.25307593f, 
    -0.10552822f, 0.11528970f, 0.14633010f, 0.18641147f, 0.29947975f, -0.07567666f, -0.06944204f, -0.10080172f, 
    -0.23627922f, 0.06832100f, 0.24120598f, -0.03319334f, -0.02224832f, 0.06312103f, 0.21351303f, -0.04797810f, 
    0.10999374f, -0.15611637f, -0.07983580f, -0.02753638f, 0.06094652f, 0.09217218f, 0.01392630f, 0.00054523f, 
    -0.01335581f, -0.02879390f, 0.26092991f, 0.04399571f, -0.00113676f, 0.11145055f, 0.07303420f, -0.03237623f, 
    -0.11951836f, -0.22883911f, -0.12254274f, 0.06542625f, -0.07983311f, 0.10976838f, 0.17954291f, 0.13718465f, 
    -0.06130477f, -0.00287053f, -0.11797124f, -0.05580283f, 0.01422129f, 0.02168616f, 0.10808081f, -0.04728127f, 
    -0.07190345f, 0.28337342f, 0.11322037f, -0.17273779f, 0.06012296f, -0.04302055f, 0.00147048f, 0.09768252f, 
    0.05608863f, 0.16411495f, 0.15318288f, 0.04953751f, -0.02916159f, -0.03120014f, -0.04995364f, -0.06737091f, 
    0.07964487f, 0.02486570f, 0.07185569f, 0.08165104f, 0.02630498f, 0.26207799f, 0.05903457f, -0.04558038f, 
    0.02196502f, 0.09609225f, 0.06154741f, 0.11368876f, 0.08874092f, 0.09638540f, -0.03742804f, 0.08434720f, 
    -0.02678870f, 0.14240120f, -0.02989029f, 0.02510042f, -0.08203837f, 0.00533135f, 0.00104597f, -0.09496620f, 
    -0.05078495f, 0.01270566f, -0.02820264f, 0.07904546f, -0.02386963f, 0.01797783f, 0.03311800f, 0.00087959f, 
    0.03416463f, -0.13327610f, -0.09116292f, -0.16751739f, -0.05564078f, 0.05217658f, 0.01814294f, 0.06742679f, 
    0.13396774f, 0.24957819f, 0.02508475f, 0.10486595f, -0.01849976f, -0.09531923f, -0.14095105f, -0.05376727f, 
    -0.09555192f, 0.05508368f, 0.14791453f, -0.00550356f, 0.01111618f, 0.07505817f, 0.21990202f, -0.10294022f, 
    -0.10790475f, -0.17339322f, -0.17941730f, -0.15402271f, -0.04083449f, 0.03412288f, -0.02101956f, 0.02339131f, 
    -0.10789939f, -0.03538501f, -0.07792680f, -0.01950997f, 0.13319136f, 0.01230776f, 0.19280885f, 0.15101135f, 
    -0.06026036f, -0.09298366f, 0.16380475f, -0.11842793f, -0.07458857f, 0.02101102f, 0.00983312f, 0.02760187f, 
    0.05437766f, -0.19926663f, 0.12998854f, 0.13922589f, -0.19846815f, -0.02016127f, -0.02119280f, 0.04401421f, 
    -0.04384511f, -0.01875640f, -0.01292173f, 0.03332097f, 0.03690706f, 0.13016310f, 0.17403679f, -0.01420456f, 
    -0.07530437f, 0.01423477f, 0.02225062f, -0.00513965f, 0.10660014f, 0.09616457f, 0.25804272f, 0.05357572f, 
    -0.01664311f, 0.05004967f, -0.02403436f, -0.01169580f, -0.03079389f, 0.00151317f, 0.11054392f, -0.02767434f, 
    0.09547567f, 0.09063108f, 0.08065939f, -0.06388298f, 0.03604216f, -0.02846150f, -0.00910637f, -0.00366249f, 
    -0.16402395f, -0.31564605f, -0.09914783f, -0.30208141f, -0.06966161f, 0.02946719f, -0.07031997f, 0.12582414f, 
    0.13966753f, -0.20324250f, 0.02908554f, 0.30590346f, -0.03140408f, 0.08860515f, 0.02546939f, -0.14271569f, 
    -0.06311052f, 0.06981170f, -0.01947623f, -0.01675240f, 0.05061338f, 0.04641410f, -0.22841398f, 0.01825651f, 
    0.03893647f, -0.07006783f, 0.09011415f, 0.06322496f, 0.06333534f, -0.26796275f, 0.10888416f, -0.18856791f, 
    0.06959444f, -0.07019401f, -0.10489188f, 0.04438645f, 0.16926765f, -0.01624376f, -0.11387435f, -0.26970205f, 
    -0.09333908f, 0.06067973f, 0.10362388f, -0.16795161f, 0.00932478f, -0.19984366f, -0.04856110f, 0.10004176f, 
    -0.00921513f, -0.04217199f, -0.02835046f, -0.05451633f, 0.02351175f, 0.07972714f, 0.02783315f, 0.03253245f, 
    -0.00520122f, 0.07193694f, 0.11584509f, 0.01364922f, 0.02186914f, -0.05659014f, -0.02001566f, 0.14911410f, 
    0.44357571f, 0.14190577f, -0.05546767f, 0.05884674f, -0.03456824f, 0.04073467f, 0.09172060f, -0.06058465f, 
    -0.05325958f, 0.06717881f, -0.09154398f, -0.07148886f, 0.12884890f, -0.13024063f, -0.62555099f, -0.02904931f, 
    0.00480345f, 0.07428714f, 0.15242901f, 0.02307132f, 0.04399878f, 0.00290624f, 0.03338727f, 0.02906881f, 
    0.01361868f, 0.09804344f, 0.11728133f, 0.07489567f, -0.17945331f, 0.21881425f, -0.05653475f, 0.02915879f, 
    -0.11872789f, -0.15398690f, -0.19376816f, 0.34891734f, 0.06548573f, 0.20394985f, 0.20848583f, -0.10757846f, 
    -0.07701501f, 0.04969291f, -0.07186369f, 0.05931440f, 0.01684806f, -0.08706574f, -0.06673223f, -0.23013672f, 
    0.13508345f, 0.07614906f, 0.05236755f, 0.20579259f, 0.14015286f, 0.07508563f, 0.10049087f, 0.13401410f, 
    0.01922186f, 0.01496580f, 0.12011704f, 0.06956392f, 0.04803918f, 0.04749675f, 0.06788349f, -0.06950899f, 
    0.03764331f, -0.08673025f, -0.05557999f, 0.07332972f, -0.11108088f, -0.10511050f, 0.08384776f, -0.03505032f, 
    0.24085674f, 0.13294178f, 0.05726474f, -0.08381014f, 0.17258921f, 0.06462848f, 0.16187479f, 0.17086758f, 
    -0.00898614f, 0.05284172f, -0.00050347f, -0.07916578f, -0.12211791f, -0.02689119f, -0.16513479f, 0.16062553f, 
    -0.00694996f, -0.08883651f, 0.09284281f, -0.12234955f, 0.07340904f, 0.03572873f, 0.02331860f, -0.06377265f, 
    0.02843540f, -0.03303611f, 0.17284532f, 0.15564957f, 0.01442016f, -0.05679081f, -0.05881365f, -0.14129372f, 
    0.12710205f, -0.06999119f, 0.06270777f, -0.03982049f, -0.02533699f, 0.01669961f, 0.07114407f, -0.13725613f, 
    0.01692195f, -0.05255542f, 0.10857575f, 0.01509434f, 0.03868358f, 0.00988100f, 0.09574879f, -0.01080942f, 
    -0.26989651f, -0.09761578f, -0.38262901f, -0.24054785f, 0.03187117f, 0.19404186f, 0.06825735f, -0.03421798f, 
    0.03127415f, 0.00500246f, 0.00416705f, 0.01545329f, -0.04330049f, -0.17880397f, 0.04033359f, -0.21244171f, 
    0.00911193f, -0.05530154f, -0.06061473f, -0.01650404f, -0.08836924f, 0.01686322f, 0.05084234f, -0.06262412f, 
    0.06176121f, 0.15813176f, 0.16404572f, -0.11817310f, -0.02719550f, -0.05318877f, 0.08863413f, -0.01807081f, 
    -0.01437819f, -0.00242706f, -0.00032665f, 0.10224495f, 0.12765880f, 0.08715317f, 0.02769606f, -0.05319889f, 
    0.13366413f, 0.03710747f, 0.09054070f, 0.01498948f, 0.05836160f, -0.18706578f, -0.05149206f, -0.04618916f, 
    -0.26697579f, 0.50890887f, -0.01446712f, -0.10376112f, -0.13534147f, -0.15855823f, 0.09367853f, 0.02319372f, 
    -0.02701914f, 0.08508415f, -0.03179615f, -0.10201933f, -0.04379611f, -0.03544302f, 0.00253197f, -0.24956793f, 
    0.09325538f, 0.14187598f, 0.05551158f, -0.02700842f, 0.06607610f, 0.00365262f, -0.03767340f, 0.06243476f, 
    -0.15941367f, -0.21880150f, -0.16102956f, 0.16563980f, 0.05618620f, -0.05647475f, 0.01365741f, -0.13637625f, 
    -0.02253050f, 0.01876500f, 0.01658784f, 0.03300827f, 0.15309274f, 0.16323581f, -0.36277863f, 0.12462861f, 
    -0.02785293f, 0.04484818f, -0.00262678f, 0.17211093f, -0.07208025f, -0.06352469f, 0.02074137f, -0.01845325f, 
    -0.05661393f, -0.00381975f, -0.15289240f, -0.05284793f, 0.15951678f, -0.07962988f, 0.01873674f, -0.01054932f, 
    0.10711750f, -0.09673595f, -0.00305240f, -0.01605194f, -0.05228402f, -0.07835407f, 0.02267661f, 0.03390021f, 
    0.10212970f, -0.08161684f, -0.06373818f, 0.01528484f, 0.07933207f, -0.06521287f, -0.00978225f, -0.10385118f, 
    -0.20158184f, -0.07449053f, -0.16007297f, 0.07767926f, -0.00646319f, 0.10797216f, 0.02573888f, -0.06747662f, 
    0.15049118f, 0.22761895f, -0.07393142f, -0.07421733f, -0.04600965f, 0.10840033f, 0.12360168f, -0.10498689f, 
    -0.17644785f, 0.08016337f, 0.13816601f, 0.15658516f, 0.02710250f, 0.09311981f, -0.00556595f, 0.04707522f, 
    0.10229217f, 0.26715478f, -0.01439548f, -0.12371318f, -0.02822702f, -0.05273369f, 0.04863341f, 0.07758940f, 
    -0.00035042f, 0.02659748f, 0.02985614f, -0.01187314f, 0.01664238f, 0.09847300f, 0.07103252f, -0.02541834f, 
    0.05800119f, 0.03037168f, -0.04423520f, -0.10601517f, -0.05906056f, 0.06653906f, -0.07807986f, 0.03536782f, 
    0.13128383f, 0.22476293f, -0.03616922f, -0.09833681f, 0.07146104f, 0.10301217f, 0.04954033f, -0.03684610f, 
    -0.05960813f, -0.02814778f, 0.00786938f, -0.01412773f, -0.08808224f, 0.08237801f, 0.03609926f, -0.10587992f, 
    -0.12060590f, 0.06144101f, -0.01617372f, -0.04380666f, -0.01395866f, 0.10844123f, -0.06672817f, 0.02276472f, 
    0.03565823f, -0.16285026f, -0.08618696f, 0.11760966f, 0.08372431f, 0.08541556f, 0.05938608f, 0.04203830f, 
    0.15221448f, 0.03567060f, 0.01297074f, -0.01244597f, 0.11081602f, 0.00499196f, -0.00817499f, 0.19679172f, 
    -0.05906423f, 0.11980545f, 0.04381744f, 0.02751392f, -0.03754644f, -0.00279391f, 0.00036196f, 0.04214314f, 
    0.03056093f, -0.22611469f, -0.18265502f, -0.10819888f, 0.05130788f, 0.03392879f, -0.06234282f, 0.00214408f, 
    0.06613418f, -0.04291774f, -0.01713831f, -0.05590577f, -0.05433598f, 0.02020875f, 0.18239734f, -0.04374225f, 
    0.18757533f, -0.05192458f, -0.11626766f, 0.01454763f, -0.02540692f, 0.00660624f, -0.01221244f, 0.01991754f, 
    -0.02429732f, -0.02898089f, 0.08430878f, -0.13449495f, 0.12266971f, 0.03958054f, 0.04565300f, 0.04020137f, 
    0.05770276f, 0.06788790f, 0.06811787f, 0.11090466f, 0.04143568f, 0.21045026f, -0.19193131f, -0.01731382f, 
    -0.03556921f, 0.03611318f, -0.13144854f, 0.12950870f, -0.00011867f, 0.03663037f, 0.10209248f, 0.06788217f, 
    -0.47718784f, -0.00837601f, -0.11828147f, 0.15978532f, 0.08792811f, -0.11109728f, -0.10870878f, 0.16530147f, 
    -0.04807035f, 0.03762680f, -0.19534005f, -0.03916863f, -0.08168903f, 0.03652351f, 0.13697301f, -0.01074164f, 
    0.09751820f, -0.02913509f, -0.01418577f, 0.06392273f, -0.07684215f, 0.00729199f, 0.11277460f, 0.13199487f, 
    -0.09003931f, -0.03104025f, 0.13084120f, 0.02146703f, 0.04114081f, -0.00191822f, -0.09738699f, -0.02147373f, 
    -0.01255786f, -0.13719645f, -0.00063335f, 0.10095401f, -0.01960026f, 0.01918386f, -0.03311212f, -0.00226713f, 
    0.05058511f, -0.11146421f, -0.03871687f, -0.12097012f, 0.03481951f, 0.13301533f, -0.09989299f, 0.11317337f, 
    0.10773208f, 0.04362125f, 0.09953975f, 0.06850137f, 0.01650358f, 0.02182593f, 0.13657156f, 0.15845834f, 
    0.09228800f, 0.09825152f, 0.02607124f, -0.06793185f, -0.06131308f, 0.02834605f, -0.21999009f, -0.01753470f, 
    -0.00570488f, 0.00272485f, -0.00931249f, 0.16477130f, 0.22551310f, 0.07807157f, 0.18793248f, 0.05887984f, 
    0.02517782f, 0.01977232f, 0.04618112f, -0.05757837f, 0.10471774f, 0.20313314f, -0.05969224f, -0.16430821f, 
    0.07693074f, -0.06369668f, 0.07996804f, 0.11198147f, -0.14988588f, 0.09999344f, 0.07932699f, 0.03778221f, 
    -0.05121149f, -0.01696453f, -0.01147576f, 0.02701434f, -0.10294553f, -0.01399717f, -0.19524783f, -0.03491856f, 
    -0.22052152f, 0.18219469f, 0.11431393f, -0.18123420f, 0.09732795f, -0.03321833f, -0.00340202f, 0.20196998f, 
    -0.01103752f, -0.08234116f, -0.06374475f, -0.05850951f, -0.09374030f, 0.11507645f, 0.02157077f, -0.04955139f, 
    -0.03187789f, 0.15220006f, 0.10357725f, 0.02853089f, -0.05964855f, 0.02587710f, -0.07961173f, -0.13765123f, 
    -0.21920665f, -0.13372819f, -0.08931466f, -0.14181018f, 0.05522408f, -0.00178675f, 0.00206362f, 0.03082904f, 
    -0.08322524f, 0.01953724f, -0.09701672f, -0.09096502f, 0.22680484f, -0.00853031f, -0.14877680f, -0.06861906f, 
    -0.06262448f, -0.00496831f, -0.05868948f, 0.07344613f, 0.11726046f, 0.10146105f, 0.05143289f, 0.00869792f, 
    -0.03969674f, 0.13681415f, -0.07515104f, 0.08625416f, 0.10130181f, 0.03053496f, 0.05240535f, 0.09639305f, 
    0.06858557f, -0.11037674f, 0.04722666f, 0.03547560f, -0.16544339f, -0.08948726f, 0.01989855f, -0.02890064f, 
    -0.06464202f, 0.14031003f, 0.11820589f, 0.07367107f, 0.03823569f, 0.03331034f, 0.02481777f, 0.02876183f, 
    -0.04025139f, -0.38311687f, 0.11148321f, -0.00126839f, 0.00903164f, 0.00729810f, 0.03155517f, 0.29218417f, 
    -0.18605040f, -0.03373954f, 0.09352165f, 0.00313892f, -0.01934184f, 0.12557329f, -0.24986523f, 0.28845012f, 
    0.17966402f, 0.19193596f, 0.29162380f, 0.10479405f, 0.01050021f, 0.01625906f, 0.02808326f, 0.10748417f, 
    0.10001492f, 0.20243873f, 0.07354641f, 0.07281102f, -0.09758431f, -0.08675236f, -0.07543607f, -0.06369267f, 
    0.03897899f, -0.00846989f, 0.02157547f, 0.07213853f, 0.16789341f, 0.07995778f, 0.12148716f, -0.05576482f, 
    0.16225679f, 0.02267675f, 0.22804788f, -0.03031901f, 0.03957456f, -0.08403417f, 0.02381965f, 0.01732677f, 
    0.15695037f, -0.06203622f, -0.01009619f, -0.05805524f, -0.02187137f, -0.04848897f, 0.11292160f, 0.01894864f, 
    0.09701826f, 0.09494314f, 0.06230031f, 0.17680383f, 0.00108354f, -0.00197679f, -0.23575722f, -0.05093239f, 
    -0.03869509f, 0.05106399f, 0.17735836f, -0.07449155f, 0.10077737f, 0.13052931f, 0.06382080f, 0.10415597f, 
    -0.07086798f, -0.12153641f, 0.01094501f, 0.01350377f, -0.06405097f, -0.11600214f, -0.16820590f, -0.12017752f, 
    -0.20278606f, -0.20423706f, 0.00768333f, -0.09782963f, 0.09022816f, -0.00291185f, -0.03431598f, -0.06980154f, 
    0.08859508f, 0.06353509f, 0.12581070f, -0.01035602f, 0.03686082f, -0.00631518f, 0.03417568f, -0.00943263f, 
    -0.09349271f, -0.10432703f, 0.07107458f, -0.16024430f, -0.11226027f, -0.02152020f, -0.03925034f, 0.15351197f, 
    -0.10718096f, -0.04278635f, -0.01023363f, -0.09636198f, -0.08545974f, -0.22761153f, -0.07359329f, -0.13904229f, 
    0.03671413f, -0.18169734f, 0.24602248f, 0.17627937f, 0.00812750f, 0.12286222f, 0.04730897f, -0.06901307f, 
    0.14347528f, -0.06703296f, -0.10354325f, -0.13369524f, -0.10643160f, -0.17371580f, -0.06942774f, -0.05530080f, 
    -0.00097000f, -0.01675495f, -0.00825811f, 0.01960402f, 0.06274231f, -0.00772836f, 0.08220771f, -0.04116182f, 
    0.02239974f, 0.16548494f, -0.06954858f, 0.08351976f, 0.21408838f, -0.05330009f, 0.22680065f, 0.14582939f, 
    -0.11319736f, 0.00976486f, 0.08238624f, -0.02092062f, -0.13126968f, -0.06235531f, -0.13074461f, -0.12574804f, 
    -0.30020076f, -0.20775987f, -0.09132610f, -0.10324141f, 0.05385151f, -0.23098081f, -0.08640718f, -0.15328325f, 
    0.02127511f, -0.08973067f, -0.09060903f, -0.00951438f, -0.14221303f, -0.03134758f, -0.09645867f, -0.13464148f, 
    0.03648974f, -0.11751847f, -0.12501940f, -0.12460034f, 0.06617341f, 0.07908005f, 0.14470723f, 0.02678635f, 
    -0.07418942f, 0.11965237f, -0.06002360f, 0.18145226f, -0.07026289f, 0.02481476f, 0.11136420f, -0.03334877f, 
    0.09724955f, -0.03121080f, -0.12788829f, 0.09745238f, -0.01464729f, -0.06604771f, 0.03090499f, -0.22183220f, 
    0.09901908f, 0.16283092f, 0.01135787f, 0.01225453f, 0.05222922f, 0.02412080f, -0.00837809f, 0.09551913f, 
    0.00566045f, -0.06196628f, -0.20445319f, -0.15916426f, -0.02315067f, -0.12780102f, 0.07088712f, -0.04246951f, 
    0.02673531f, 0.13593897f, 0.10840131f, 0.08341805f, 0.02461679f, -0.04063095f, 0.06814421f, 0.06663323f, 
    0.66060132f, -0.01863523f, 0.06912679f, 0.06431328f, -0.08056395f, 0.03453137f, -0.03251935f, -0.01990322f, 
    0.21588987f, 0.11197476f, 0.18040866f, 0.04507192f, 0.20076030f, -0.25939658f, -0.15122312f, -0.18666838f, 
    -0.03064168f, 0.07839907f, -0.02321752f, 0.08511160f, -0.00209532f, 0.12151571f, -0.13595966f, 0.10078377f, 
    -0.40254551f, 0.18504734f, 0.00558929f, 0.12133475f, 0.06422539f, 0.04021499f, 0.10268223f, 0.05353151f, 
    0.10051230f, 0.02280456f, 0.05265376f, 0.16775011f, 0.00139962f, 0.09599692f, 0.06797902f, -0.03782384f, 
    -0.15572701f, 0.08037362f, -0.08761514f, 0.07666739f, 0.16863924f, 0.10925507f, 0.11444942f, 0.06572444f, 
    0.09306117f, 0.13137886f, -0.01245892f, -0.01763117f, 0.04607465f, 0.05923404f, 0.03358084f, -0.10639599f, 
    0.02366619f, 0.01582986f, 0.00255588f, 0.08015166f, -0.15829435f, -0.08464026f, 0.05594668f, 0.01455122f, 
    -0.06247254f, -0.03176264f, -0.00089975f, -0.08776971f, -0.10073975f, 0.05180946f, 0.02219892f, 0.08121803f, 
    -0.05020498f, -0.04495605f, -0.04525871f, -0.02363859f, 0.00077837f, -0.03490347f, -0.03663759f, -0.05255505f, 
    0.04133521f, 0.01565639f, -0.00658561f, -0.01323098f, -0.03392451f, -0.00571964f, -0.03934262f, -0.00597880f, 
    -0.05299095f, 0.03359031f, 0.03484482f, -0.05415659f, 0.03585510f, -0.05903054f, 0.02407413f, -0.00069678f, 
    -0.02392865f, 0.04235433f, -0.01597651f, 0.00348982f, -0.01053590f, 0.03829509f, 0.02243818f, 0.00764376f, 
    0.01756886f, 0.03445195f, -0.00701478f, 0.00924483f, 0.01564496f, -0.02468625f, -0.02851405f, -0.05390621f, 
    -0.02511199f, -0.05620659f, -0.00816801f, -0.01939999f, -0.02038511f, -0.02823671f, 0.00176086f, 0.00105647f, 
    -0.03033984f, 0.04269486f, -0.01131883f, -0.03898380f, -0.01715225f, 0.03768329f, 0.02574313f, 0.04508643f, 
    -0.01945285f, -0.01978154f, -0.03145115f, -0.01596248f, 0.01669698f, -0.05169121f, -0.03091431f, 0.00396172f, 
    0.03949215f, -0.04016198f, -0.02351013f, 0.01248056f, -0.03824120f, 0.04112072f, -0.01906747f, -0.04715637f, 
    -0.04694027f, 0.02318615f, -0.03278504f, 0.01968345f, -0.04142104f, -0.01865126f, -0.01078622f, -0.00632676f, 
    -0.00043435f, 0.01851300f, -0.02977680f, -0.04993151f, -0.02922733f, 0.03335019f, -0.02439518f, -0.01086160f, 
    -0.04777987f, -0.00316970f, -0.03032713f, -0.00167606f, -0.02450464f, 0.00615442f, 0.03418227f, -0.05273297f, 
    0.04286896f, -0.01345135f, 0.02058828f, 0.00748342f, -0.02187840f, -0.05273351f, 0.02264323f, -0.04914676f, 
    0.03097785f, -0.03831760f, -0.05055566f, 0.02510853f, 0.00883494f, -0.02516350f, 0.00501589f, 0.04236030f, 
    -0.04590857f, -0.03339510f, -0.05566446f, -0.02574996f, 0.00878783f, 0.01401450f, -0.00846615f, -0.04307561f, 
    0.01088579f, 0.03573788f, -0.01250205f, -0.05467038f, 0.03205192f, 0.01838403f, -0.03254993f, -0.00076673f, 
    -0.05690766f, -0.05472193f, -0.00147079f, -0.00630420f, 0.01096256f, -0.00213136f, -0.03761662f, -0.00343369f, 
    -0.05529552f, -0.04489228f, -0.02126257f, -0.01024292f, 0.01156649f, -0.02541962f, 0.02158637f, 0.02070193f, 
    0.01513909f, -0.02336532f, -0.01415697f, 0.00041745f, -0.02068453f, -0.04245259f, 0.02552733f, 0.01694218f, 
    0.03983738f, -0.01427318f, -0.00515445f, -0.00435929f, 0.04097803f, -0.03881917f, -0.04566934f, 0.03782453f, 
    -0.02013462f, -0.01462335f, 0.00325526f, -0.03444638f, -0.00480776f, 0.03290031f, 0.03968715f, 0.03300107f, 
    -0.05422230f, -0.02178558f, 0.03999515f, -0.04995486f, -0.05688940f, 0.03823416f, 0.00474341f, 0.02713505f, 
    0.00292700f, 0.01939678f, -0.02559212f, -0.05230794f, 0.03364796f, -0.05289260f, -0.05256892f, 0.00830024f, 
    -0.04899367f, -0.02875214f, -0.04173581f, -0.01304406f, -0.05193714f, -0.00578821f, -0.00326762f, 0.01033807f, 
    0.02900279f, 0.00318095f, -0.00351394f, 0.03289916f, -0.02983693f, -0.02576632f, -0.03893434f, -0.02293740f, 
    0.02453994f, -0.03038754f, -0.02971455f, -0.04974709f, -0.05252747f, -0.01520160f, -0.05525317f, 0.00754083f, 
    -0.00957733f, 0.00727781f, -0.04411306f, -0.01437790f, -0.00525611f, -0.04428893f, 0.03520665f, -0.03601715f, 
    0.00864631f, 0.03222460f, -0.04194712f, 0.01787464f, -0.04134208f, -0.03666906f, 0.03516077f, 0.04210484f, 
    0.02796859f, -0.05726557f, -0.03086411f, 0.01308137f, 0.03795808f, -0.02233555f, -0.03092564f, -0.00845031f, 
    -0.04691373f, -0.03717845f, 0.02671027f, -0.02095053f, 0.03457858f, -0.01967215f, 0.00745030f, -0.01111594f, 
    0.03423889f, -0.01160186f, 0.01298860f, -0.00249123f, 0.01156788f, -0.00913210f, -0.02123618f, 0.03299030f, 
    -0.03814830f, 0.01554743f, -0.02216676f, -0.00755151f, 0.02446235f, -0.01759104f, -0.02217281f, -0.03556605f, 
    0.01029079f, -0.03646436f, -0.02053919f, -0.04595546f, -0.04848467f, 0.03630897f, 0.02928970f, -0.01063454f, 
    -0.00722139f, -0.02298072f, -0.00576924f, 0.03338415f, -0.01736228f, -0.00375711f, 0.01349778f, 0.01591231f, 
    0.01127067f, -0.00762101f, -0.02686534f, -0.00438709f, -0.05337120f, 0.02521961f, -0.05311247f, -0.05477310f, 
    0.00561726f, 0.04122787f, 0.02895121f, -0.00540196f, 0.00727114f, 0.01686046f, 0.03913844f, -0.04399291f, 
    -0.04151411f, -0.04381730f, -0.03761569f, -0.02738496f, 0.01123931f, -0.02498939f, 0.01230181f, -0.00930047f, 
    0.02328393f, 0.03365756f, 0.01677032f, -0.05999562f, -0.02585684f, -0.01958176f, 0.03284031f, -0.02590054f, 
    -0.03689535f, -0.01473593f, 0.03300281f, -0.05591057f, 0.02838432f, 0.04123481f, -0.01763541f, 0.03447235f, 
    -0.05078725f, -0.01643104f, -0.00948643f, -0.03029070f, 0.00093428f, -0.03067824f, -0.05148186f, -0.04806436f, 
    0.01423463f, -0.02596185f, -0.00460095f, -0.04154076f, -0.04116226f, 0.03697976f, 0.02863534f, 0.02173924f, 
    -0.00911576f, 0.01333797f, 0.03662723f, -0.00147165f, -0.03983836f, 0.01667315f, -0.02730631f, 0.01282139f, 
    0.02274498f, 0.01374785f, 0.01892205f, 0.00949530f, 0.00189574f, 0.03476069f, 0.01581307f, -0.04258427f, 
    0.03515590f, 0.00153335f, -0.05462491f, -0.00592663f, 0.01157871f, 0.00103114f, -0.01738782f, -0.04829937f, 
    0.04205054f, -0.00507150f, -0.01466144f, -0.05777398f, -0.01332450f, -0.05731175f, -0.00236147f, 0.01213150f, 
    0.01975118f, 0.00844951f, -0.02437473f, -0.03450407f, -0.02617722f, 0.02963636f, 0.03124440f, 0.01348259f, 
    -0.03740385f, -0.05822047f, 0.03097299f, -0.03957501f, 0.02616028f, 0.03985563f, -0.05472458f, -0.03377814f, 
    0.01386278f, 0.00189540f, -0.01495420f, 0.02485411f, -0.03323991f, -0.04291597f, -0.03201985f, -0.00705556f, 
    -0.02379158f, -0.01201132f, 0.01369135f, -0.02006695f, 0.01870998f, -0.04924046f, -0.04640009f, -0.01534773f, 
    0.00475611f, -0.04437323f, -0.00427973f, -0.02857540f, -0.02896998f, 0.01292778f, 0.01864316f, -0.04312296f, 
    -0.02190689f, 0.04316450f, -0.04600188f, 0.04478181f, -0.02757561f, 0.02285895f, 0.00030834f, -0.03239660f, 
    -0.03613607f, -0.01198468f, -0.00220680f, -0.04380670f, 0.03938056f, -0.03925249f, 0.02429611f, 0.01277534f, 
    -0.04230998f, -0.00922301f, -0.03552113f, -0.01885265f, -0.05516559f, -0.03305262f, -0.05537183f, -0.03111411f, 
    0.01625213f, 0.01598949f, -0.02986534f, -0.03556502f, 0.01432805f, 0.02515960f, -0.03989515f, 0.01391790f, 
    0.01205758f, -0.03459498f, -0.02871668f, 0.01423332f, 0.03421789f, 0.00825836f, 0.03504860f, 0.02245083f, 
    -0.03997530f, -0.01254023f, 0.01139029f, -0.05202757f, 0.02876548f, -0.00441685f, 0.04041322f, -0.02597171f, 
    0.02525673f, 0.03566371f, -0.03155731f, 0.01173305f, -0.03553108f, 0.02197870f, 0.01594700f, 0.03184666f, 
    -0.05115009f, -0.01943544f, 0.01726539f, 0.00504763f, -0.05585777f, 0.03761464f, -0.02455591f, 0.02400958f, 
    0.01716785f, 0.02606722f, 0.01630239f, 0.00864849f, -0.03744717f, -0.02023177f, 0.01421381f, -0.04375734f, 
    -0.00984882f, 0.04021506f, -0.03115807f, 0.00972527f, -0.05072536f, 0.01015033f, -0.04183319f, -0.04178261f, 
    0.00845505f, 0.01300731f, 0.01241772f, -0.02524848f, -0.01030546f, -0.02220859f, -0.01462270f, -0.05046602f, 
    -0.02588155f, 0.03520404f, -0.02592832f, 0.01827780f, -0.05048877f, 0.00224790f, -0.01015607f, 0.00397363f, 
    0.04161562f, 0.03346943f, -0.02336980f, -0.03720233f, -0.04553662f, 0.01558866f, -0.01112624f, 0.03128795f, 
    0.03344871f, -0.03105340f, 0.01280040f, 0.02818598f, 0.00288806f, 0.04495407f, 0.02979340f, -0.03714903f, 
    -0.05091137f, -0.03709314f, 0.04121719f, 0.00179424f, -0.03309407f, -0.01031744f, -0.00127724f, -0.05285861f, 
    0.01228143f, 0.00132201f, -0.04704818f, -0.01811833f, -0.05432287f, -0.02885454f, 0.04226787f, 0.02443243f, 
    -0.00688785f, -0.01964831f, -0.03810841f, -0.02557856f, -0.05571449f, 0.01314701f, 0.00930202f, 0.04023845f, 
    -0.01791852f, -0.01940037f, -0.05095646f, 0.01389675f, 0.00752563f, -0.04531861f, -0.02822785f, 0.00642682f, 
    -0.04442901f, -0.00221878f, -0.05216074f, 0.02219605f, -0.00205321f, 0.03572112f, 0.03548536f, -0.02144775f, 
    0.01880789f, -0.02293428f, -0.04639763f, -0.00099069f, 0.00658337f, -0.00427101f, -0.01820404f, 0.01411749f, 
    0.01891144f, -0.03175292f, -0.00556795f, -0.01749623f, 0.04573823f, 0.02824615f, -0.00898090f, 0.03640641f, 
    0.04145827f, 0.01676152f, -0.05696459f, -0.02100301f, 0.03285168f, -0.00584543f, -0.01467515f, -0.02646086f, 
    -0.05680335f, -0.01230376f, -0.03067199f, -0.05410794f, 0.03470248f, 0.05051753f, -0.03881093f, -0.01789987f, 
    0.01450002f, 0.02566620f, -0.02965178f, 0.01923438f, 0.01646188f, -0.01143879f, 0.01815230f, -0.03416396f, 
    -0.04444603f, 0.04810740f, 0.00496075f, -0.03322189f, -0.01063022f, 0.01619453f, 0.02192280f, 0.02364062f, 
    -0.02749960f, 0.00558746f, -0.00701152f, -0.04783023f, -0.05446730f, -0.03209094f, -0.02112865f, -0.00677739f, 
    -0.02361243f, 0.04090073f, -0.02937405f, 0.03337102f, -0.03964217f, -0.05474404f, 0.04027436f, 0.00422714f, 
    -0.02150882f, -0.04449930f, 0.01399605f, -0.04750379f, 0.01144231f, -0.00565267f, -0.05311505f, -0.04839111f, 
    0.01146595f, 0.02840486f, -0.01720185f, 0.00132675f, 0.03315293f, -0.00941710f, -0.01415388f, -0.00849651f, 
    -0.00014284f, -0.01886616f, -0.05519010f, 0.01949317f, 0.01386346f, 0.03791542f, -0.02460293f, -0.03486095f, 
    -0.01183051f, 0.03506586f, 0.04021031f, 0.03381252f, 0.01018426f, -0.00394918f, 0.00720085f, -0.03594937f, 
    -0.00194764f, 0.02743871f, 0.04239539f, -0.03730083f, 0.01047646f, -0.01851422f, -0.02451094f, -0.04557707f, 
    -0.00889795f, -0.05604167f, -0.00603718f, 0.02903924f, -0.04424455f, -0.05131185f, 0.02005980f, -0.01291872f, 
    -0.01486495f, -0.04266439f, -0.00605891f, -0.01637620f, -0.02625733f, -0.01231158f, 0.01138870f, 0.02297770f, 
    -0.02695623f, -0.04432354f, -0.05382834f, -0.02653515f, -0.00877535f, 0.03452126f, 0.02765780f, -0.05676853f, 
    -0.01218307f, -0.03130732f, -0.04497416f, -0.04274149f, -0.01978226f, 0.00711427f, 0.01919425f, -0.05270183f, 
    0.00781121f, 0.00162392f, 0.00145641f, -0.05262098f, -0.01364633f, -0.04498158f, 0.00332259f, -0.05030914f, 
    0.04292037f, -0.01217296f, -0.03289483f, -0.01657464f, -0.03866730f, -0.02202583f, -0.05051173f, -0.04406423f, 
    -0.05131262f, -0.01917856f, -0.04405892f, 0.03610907f, -0.05162740f, 0.03017844f, -0.04033995f, 0.01606719f, 
    0.00455559f, 0.00965806f, -0.00256335f, 0.00925690f, -0.03321601f, 0.01180804f, -0.05361298f, -0.04140271f, 
    -0.01763451f, -0.00313951f, -0.04990352f, -0.00102295f, 0.01901749f, -0.04157516f, 0.04641706f, 0.02542366f, 
    -0.00064215f, 0.03757655f, -0.01417537f, -0.01587044f, 0.01847085f, -0.00852220f, 0.01927969f, 0.01409843f, 
    0.02046823f, 0.03258322f, 0.03675870f, 0.01684064f, -0.03925930f, -0.03400497f, 0.00012118f, -0.00985558f, 
    -0.00176998f, -0.02662986f, -0.01793634f, -0.05265000f, 0.00884398f, 0.01097398f, 0.02755783f, -0.03162125f, 
    0.02160829f, 0.03996001f, 0.03617035f, 0.02097402f, 0.01781673f, -0.03476708f, -0.00063305f, -0.04327146f, 
    0.00020898f, -0.00611774f, -0.03179327f, 0.01625460f, -0.05109263f, 0.02040061f, 0.04765947f, -0.01887610f, 
    0.24500635f, 0.21491101f, 0.05799228f, -0.07436469f, 0.14600278f, 0.04859027f, 0.13114472f, -0.00470102f, 
    -0.04551898f, -0.05807607f, 0.03534370f, -0.00561683f, -0.62082553f, -0.05463090f, -0.20928758f, 0.06931052f, 
    0.06598846f, -0.13605750f, -0.05601081f, 0.06852913f, -0.03581927f, -0.08124285f, -0.07888956f, 0.08416587f, 
    -0.51127619f, -0.14250557f, 0.16780499f, 0.01196772f, 0.07830580f, -0.08052658f, -0.09110352f, 0.08305168f, 
    0.13496031f, -0.10772800f, -0.00477321f, 0.06614182f, -0.08043415f, 0.21880415f, 0.17643470f, -0.16711587f, 
    0.07669291f, 0.00633006f, 0.01617023f, 0.14008321f, 0.08020539f, -0.03629965f, -0.00950127f, -0.05051704f, 
    -0.18014787f, 0.11098126f, -0.16015488f, -0.15801512f, -0.04074674f, 0.12843195f, 0.09697079f, 0.04791760f, 
    0.07212733f, -0.07883191f, -0.08987871f, 0.05629577f, 0.34708267f, -0.13652439f, 0.06718972f, -0.43480065f, 
    -0.03710800f, 0.01468810f, -0.00423016f, -0.03097855f, -0.00565627f, 0.02128933f, 0.01854194f, -0.14225307f, 
    0.10726697f, 0.15065645f, 0.16921334f, 0.01800999f, 0.01079953f, -0.07393534f, -0.07086963f, -0.06373703f, 
    0.05663755f, -0.09600199f, -0.03111984f, 0.08209341f, 0.10350935f, 0.10275570f, 0.09983360f, -0.03143797f, 
    0.15529774f, 0.03113821f, 0.02046080f, -0.02081188f, 0.06494117f, 0.00231344f, -0.00666523f, 0.06367640f, 
    -0.10151734f, 0.19006871f, -0.04804613f, -0.15620364f, -0.02475973f, -0.08650349f, -0.03802135f, 0.11911005f, 
    0.00515196f, -0.00690438f, 0.03690724f, 0.01474504f, -0.16999534f, 0.09653873f, -0.01559171f, -0.17208371f, 
    0.09289542f, 0.19305962f, 0.35006467f, -0.04193996f, 0.12434420f, 0.02316416f, -0.02726306f, 0.12534401f, 
    -0.37903571f, -0.29022330f, -0.17679696f, 0.18004639f, -0.05003287f, -0.00508674f, -0.06786302f, -0.03982520f, 
    0.04342131f, 0.03510477f, -0.09982648f, 0.11750419f, 0.28403977f, 0.02278099f, 0.24787365f, -0.12538515f, 
    0.11057973f, -0.05604482f, 0.11759594f, 0.08435488f, 0.05489621f, -0.08479413f, -0.07225794f, -0.06009716f, 
    -0.03979300f, 0.00947372f, -0.21180527f, -0.01417709f, 0.07963388f, 0.03949443f, 0.10188208f, -0.01111445f, 
    0.21024612f, 0.00792013f, -0.04681595f, 0.11710128f, -0.25427121f, -0.15853186f, -0.20549710f, -0.06171007f, 
    0.03889078f, 0.05239606f, 0.18612275f, 0.06492208f, 0.10492499f, -0.03016618f, -0.02669790f, 0.02486039f, 
    -0.22223955f, -0.13067621f, -0.09728805f, 0.03997542f, 0.05060419f, 0.07028827f, -0.01666777f, -0.06781825f, 
    -0.05207571f, -0.02047567f, 0.04907885f, 0.06664558f, 0.06371636f, 0.00297820f, -0.07834396f, -0.33924586f, 
    0.02992145f, 0.01361596f, 0.15253906f, 0.07220490f, 0.06057112f, 0.05268674f, 0.01783089f, 0.11647508f, 
    0.02710067f, 0.19874562f, -0.05679971f, -0.16887891f, -0.16600123f, -0.11075521f, -0.04944435f, 0.06859364f, 
    -0.09500768f, 0.01252606f, 0.00473182f, 0.02644156f, -0.09403181f, 0.14566952f, -0.14336611f, -0.06032088f, 
    0.07771017f, -0.12351730f, 0.07727998f, 0.06730343f, 0.01327125f, 0.20991451f, 0.08798914f, 0.11701563f, 
    -0.00579691f, 0.06588349f, -0.17418155f, -0.06961183f, 0.03145378f, 0.05428186f, 0.00909898f, 0.09831014f, 
    0.04944450f, 0.01548290f, -0.04189489f, -0.01707045f, -0.08437346f, -0.06746794f, 0.07312468f, -0.12234442f, 
    0.06815883f, 0.19114645f, -0.06224398f, 0.12004133f, 0.14112319f, 0.04670830f, 0.00903051f, -0.01203438f, 
    -0.07048317f, -0.19834501f, -0.11341164f, 0.00111980f, 0.00270155f, -0.00914322f, 0.02998987f, -0.06122372f, 
    -0.03510138f, -0.13740899f, 0.06903960f, 0.05924113f, 0.10270468f, -0.11022897f, -0.15969937f, -0.22716932f, 
    -0.09133676f, -0.06309137f, 0.07431240f, 0.11161283f, -0.00709947f, 0.05768646f, -0.02732653f, -0.06386670f, 
    -0.01237774f, -0.15975879f, -0.36757761f, -0.19879833f, 0.03163721f, -0.02151967f, 0.10510952f, -0.00149857f, 
    -0.00819050f, 0.04521022f, 0.02544299f, 0.06252942f, 0.02578412f, 0.10125071f, 0.28739899f, 0.13541721f, 
    0.05791562f, 0.00345970f, -0.12112846f, -0.00839057f, 0.03672516f, -0.02675689f, -0.00608883f, 0.02921145f, 
    0.23199928f, 0.10741246f, 0.25419536f, -0.09429037f, 0.02706087f, 0.02296563f, -0.01074809f, 0.01553587f, 
    0.05477007f, -0.06678153f, -0.04495677f, -0.03296743f, 0.21794841f, 0.12310324f, -0.08121362f, -0.00851982f, 
    -0.07791908f, 0.04957655f, 0.02687486f, 0.08536026f, 0.00461092f, -0.05603011f, 0.01179347f, -0.03450881f, 
    0.23357217f, -0.15637870f, -0.20892696f, 0.15285592f, -0.03485980f, 0.07353768f, -0.10814475f, 0.08163067f, 
    0.01130398f, 0.07205527f, 0.06270394f, 0.02608987f, 0.03400309f, -0.06179100f, -0.07671940f, -0.31160918f, 
    0.03880317f, -0.12674743f, 0.01687915f, 0.04239242f, -0.00016798f, -0.00274043f, -0.08539544f, 0.06166574f, 
    -0.56135434f, 0.26396349f, 0.14361522f, 0.05270100f, 0.06059228f, 0.09457245f, 0.01324530f, 0.03188264f, 
    0.10688629f, 0.05948405f, 0.02440233f, 0.29593632f, 0.08445524f, -0.18759970f, 0.19775240f, 0.03580755f, 
    -0.01874802f, 0.01823291f, -0.06860067f, -0.15930633f, 0.09549413f, 0.12302456f, 0.07654252f, -0.06023641f, 
    0.18465568f, 0.19490913f, 0.05488086f, -0.01211661f, 0.08296981f, 0.08397306f, 0.11953697f, 0.16797438f, 
    0.01930938f, 0.02551902f, 0.04124613f, 0.01954614f, -0.10020045f, -0.11167264f, -0.08599649f, 0.10409216f, 
    0.06463218f, 0.00688787f, 0.02330693f, 0.02642736f, 0.01711167f, 0.13860779f, 0.19236244f, 0.14806946f, 
    0.23682900f, -0.00034577f, -0.03908689f, -0.02944137f, 0.13889557f, -0.03796824f, -0.05318658f, -0.06940310f, 
    0.00168232f, -0.00435561f, -0.02198027f, -0.03272511f, -0.01837504f, -0.07730930f, 0.04756155f, 0.10336103f, 
    -0.09824266f, 0.01391939f, 0.00060725f, 0.00958976f, -0.06787419f, 0.07553848f, 0.08967098f, -0.07024935f, 
    0.19751981f, 0.10772481f, 0.30175966f, -0.03127984f, -0.03404702f, -0.02390187f, 0.02370368f, -0.04994726f, 
    0.02899739f, 0.01690352f, 0.01138933f, -0.12513886f, 0.14732604f, 0.07182445f, -0.13305065f, -0.10152690f, 
    0.08249143f, 0.11504743f, 0.31494957f, 0.13530505f, 0.00430878f, 0.04591728f, 0.06853879f, -0.07364820f, 
    -0.21528216f, -0.20209113f, -0.28631967f, -0.18411510f, 0.12701277f, 0.18737164f, 0.15388493f, -0.01703299f, 
    -0.15087065f, 0.10139938f, -0.08895373f, -0.00448424f, -0.12010396f, -0.05003081f, -0.29688910f, 0.36199561f, 
    0.03334363f, 0.01663084f, -0.02602724f, -0.08172721f, 0.06652743f, -0.07811059f, 0.02093676f, -0.02710196f, 
    0.12342001f, 0.32335493f, 0.00236990f, -0.11528059f, 0.01727033f, 0.05661288f, 0.17575279f, 0.03862648f, 
    -0.07094467f, 0.00963124f, -0.01431988f, 0.03213786f, -0.00870070f, 0.04441072f, -0.04085461f, -0.06608946f, 
    -0.15997882f, 0.03674571f, 0.11318123f, -0.07696813f, 0.04546284f, -0.16459672f, 0.03114762f, -0.06055279f, 
    0.03446500f, 0.02091202f, -0.01148387f, 0.25816339f, 0.00731417f, -0.08119475f, 0.10061865f, 0.18739039f, 
    -0.09090388f, 0.11826731f, -0.07204504f, -0.08386252f, 0.05666994f, 0.14599009f, -0.04878649f, 0.08595237f, 
    0.05555433f, 0.08982687f, -0.09783004f, 0.00345970f, 0.03382459f, -0.04182889f, 0.03288181f, 0.04020823f, 
    -0.00330490f, -0.05263144f, -0.19822761f, -0.00889263f, -0.01583297f, 0.01441809f, 0.02839647f, -0.07061592f, 
    -0.03903824f, -0.02102182f, -0.00306920f, -0.07873459f, 0.18780741f, 0.16103344f, -0.50124294f, 0.09311080f, 
    -0.16388761f, 0.05949747f, -0.07899538f, -0.04062945f, -0.01903253f, 0.09222784f, 0.00598786f, 0.23292276f, 
    0.02080257f, -0.13533582f, 0.00248442f, 0.02186180f, 0.09826086f, -0.13209802f, 0.00763487f, 0.00086090f, 
    0.01950784f, -0.02367079f, 0.06435634f, -0.05183440f, 0.00386634f, 0.02037972f, 0.00247350f, 0.07696312f, 
    0.19584876f, -0.00592559f, -0.06585316f, -0.08261374f, 0.00711985f, -0.02193090f, 0.05210465f, 0.01054107f, 
    -0.13495938f, -0.11229832f, -0.12646011f, -0.02603418f, -0.00662728f, -0.07305905f, -0.09789024f, 0.00033406f, 
    0.04231424f, 0.23550329f, -0.06586512f, -0.16917439f, 0.11748838f, 0.30350864f, 0.21732770f, 0.38922110f, 
    0.03100139f, 0.13846578f, -0.07753224f, -0.03080086f, -0.03785370f, 0.02363108f, -0.04941145f, 0.06158855f, 
    0.21508136f, 0.09222196f, 0.07929515f, -0.01741303f, 0.07572850f, -0.03021110f, -0.00581813f, 0.04740414f, 
    0.13462242f, -0.17796588f, 0.05461173f, -0.10103278f, -0.04878575f, -0.11960724f, 0.14378028f, 0.01386783f, 
    0.14813830f, 0.00793853f, 0.13400824f, 0.10574608f, -0.03894436f, -0.01965796f, -0.03164389f, -0.01654453f, 
    0.07852221f, 0.00164887f, -0.03156074f, 0.01726569f, -0.01848812f, 0.14601210f, 0.10045845f, -0.06894509f, 
    -0.12378526f, -0.00628317f, -0.04832580f, -0.00020007f, -0.15054975f, 0.09012926f, 0.10844012f, -0.03642453f, 
    -0.11709195f, 0.00288472f, -0.04313760f, -0.04372708f, -0.13523392f, 0.05423227f, 0.08828487f, -0.02783571f, 
    -0.02231757f, -0.07197709f, -0.07500041f, -0.01307992f, -0.00369952f, 0.00695445f, 0.01536424f, 0.03553254f, 
    0.09026538f, 0.10329302f, 0.02002493f, -0.01893088f, 0.03257617f, -0.15971427f, 0.01975988f, 0.39444014f, 
    0.00688164f, 0.27217615f, 0.25543952f, 0.00681166f, -0.11689056f, 0.00822963f, -0.00624150f, -0.00928375f, 
    -0.01669387f, -0.17337634f, 0.01641912f, 0.10751477f, 0.20531125f, 0.17758068f, -0.09543747f, 0.04598445f, 
    0.01819836f, -0.03849766f, 0.04492626f, 0.00143782f, 0.04840565f, 0.04202951f, 0.13484579f, -0.27108347f, 
    0.12144905f, 0.04232381f, 0.09255033f, 0.05402073f, -0.02460880f, -0.01186561f, 0.00626777f, 0.03249953f, 
    0.00294633f, 0.06583827f, -0.08211000f, -0.18560247f, 0.22163484f, 0.00508332f, 0.12626442f, -0.06717256f, 
    -0.02585372f, 0.03684482f, 0.10137317f, -0.05139841f, 0.01234476f, 0.09681885f, -0.25062707f, 0.04986116f, 
    -0.01004853f, 0.03200435f, -0.11192829f, -0.02715176f, 0.08010033f, 0.04040864f, 0.07962482f, 0.17591044f, 
    -0.44460759f, 0.12686487f, -0.00670606f, 0.04352471f, 0.03996436f, -0.03037115f, 0.06586459f, 0.04052086f, 
    -0.01033710f, 0.03968604f, -0.06342547f, -0.00141166f, 0.19881240f, -0.23834530f, -0.15352677f, 0.27101669f, 
    0.05830463f, -0.01462758f, 0.06711601f, 0.13453048f, -0.00282364f, -0.00262932f, 0.17269930f, -0.02270008f, 
    0.29032603f, -0.01281418f, 0.17559028f, 0.05087457f, -0.01139513f, 0.00440789f, -0.00070784f, 0.15632871f, 
    0.02405139f, -0.06812508f, 0.24153788f, 0.05510913f, 0.02036335f, 0.11235360f, -0.16099387f, 0.05900912f, 
    -0.04394440f, -0.06817446f, 0.00281927f, 0.03145901f, 0.18364601f, 0.19190228f, 0.01474352f, 0.23419000f, 
    0.14836432f, -0.09843426f, -0.01803057f, -0.08900481f, 0.01396825f, 0.06590429f, 0.10095901f, -0.04529157f, 
    0.01060490f, 0.10034708f, 0.05500039f, 0.04492757f, -0.07288037f, -0.04346111f, -0.03931555f, -0.07172241f, 
    -0.12245838f, -0.06188282f, -0.09831189f, 0.04988416f, -0.00387731f, 0.07714236f, 0.11418745f, 0.01919603f, 
    -0.04692327f, 0.01786667f, 0.00043574f, -0.01092758f, -0.01053950f, -0.04178859f, -0.01113165f, 0.03746251f, 
    -0.02583655f, 0.04261656f, 0.01073974f, 0.00512876f, 0.04340532f, 0.01417820f, -0.01935093f, 0.00140352f, 
    -0.02374169f, 0.03899838f, -0.00340042f, 0.03660673f, -0.05526071f, -0.05658664f, -0.05090996f, -0.02193035f, 
    -0.02583049f, 0.02712579f, 0.02007393f, -0.02502508f, -0.02377322f, 0.00375633f, 0.01898678f, -0.03930088f, 
    -0.03279050f, 0.00212741f, 0.01231830f, -0.04228500f, 0.02004032f, 0.03194125f, -0.04924084f, 0.02889683f, 
    0.01880479f, 0.00494029f, -0.01215191f, 0.02536132f, 0.01793204f, 0.02909109f, -0.02315127f, 0.02420247f, 
    -0.00999374f, 0.00837932f, 0.00646007f, -0.00671603f, -0.01486293f, 0.01580654f, 0.03307524f, -0.04998235f, 
    -0.05587376f, 0.03603531f, 0.02313405f, -0.05469735f, -0.00915252f, -0.00731132f, 0.02810211f, 0.01449292f, 
    -0.00304599f, -0.02418263f, -0.00561877f, 0.01264346f, 0.00813758f, -0.01122733f, -0.04971885f, 0.01579180f, 
    0.03439218f, -0.05448983f, -0.01566107f, -0.05589015f, -0.04386873f, -0.00918763f, -0.03451219f, 0.00605399f, 
    0.03861773f, 0.02744770f, 0.01544788f, 0.03138094f, 0.04000821f, 0.01053819f, -0.01670812f, -0.03997866f, 
    -0.00877117f, -0.01132889f, 0.03608821f, 0.04203299f, 0.01938978f, 0.03313397f, 0.00675456f, -0.04093438f, 
    0.04488803f, -0.02581093f, -0.01198722f, -0.05173346f, -0.00641041f, -0.02118604f, 0.04405162f, -0.02474786f, 
    -0.03113412f, -0.00224422f, 0.00058997f, -0.02573817f, -0.01123864f, -0.03956550f, 0.03185799f, 0.03984122f, 
    -0.00162313f, 0.02326892f, -0.00285962f, -0.01894489f, 0.01695845f, -0.00594877f, -0.01140220f, -0.00561872f, 
    -0.03065329f, 0.02460286f, -0.02457787f, 0.00196818f, 0.02439464f, -0.05434572f, 0.01934909f, 0.00686132f, 
    0.04372681f, 0.03677934f, -0.02529242f, -0.03833239f, -0.04006658f, -0.05632206f, -0.01624439f, 0.01635446f, 
    -0.02677629f, 0.02179258f, -0.04656376f, 0.03433343f, -0.02459664f, -0.01211702f, 0.00538303f, -0.05202062f, 
    -0.04164256f, 0.03082322f, 0.02427998f, -0.04722673f, 0.00134996f, -0.00886820f, -0.01412211f, 0.01859668f, 
    0.02250238f, 0.04379012f, 0.04540039f, 0.01211264f, 0.03415884f, 0.00511763f, -0.02706246f, -0.00548896f, 
    0.02559251f, -0.04826343f, -0.03418617f, -0.03836003f, -0.04224989f, -0.03837330f, -0.03594951f, 0.04386702f, 
    -0.03404826f, 0.01789974f, 0.01315503f, 0.01843239f, -0.05177063f, -0.00638178f, 0.02897429f, -0.04836018f, 
    -0.03564209f, -0.03699484f, -0.00595177f, 0.01648398f, -0.03723638f, 0.01058670f, -0.00278482f, -0.02755122f, 
    -0.03614072f, 0.02242191f, -0.03544699f, -0.03813215f, -0.00523934f, -0.02367563f, -0.03403937f, -0.01534805f, 
    0.01061085f, -0.02626707f, -0.05169269f, 0.01496180f, -0.01256241f, -0.01604445f, 0.01259921f, 0.01799522f, 
    0.01209357f, 0.02389876f, -0.03066895f, -0.03977774f, -0.02262175f, -0.00943692f, -0.01243571f, -0.02329972f, 
    -0.03344042f, -0.02904189f, -0.04532335f, -0.04649625f, -0.02340497f, -0.04062725f, -0.04421842f, -0.00135237f, 
    -0.02307819f, -0.02679672f, -0.01633206f, 0.01985910f, 0.00399179f, 0.02172686f, 0.02763281f, -0.04511595f, 
    -0.03161034f, -0.03713094f, -0.01141361f, -0.01359896f, -0.01959337f, -0.05532077f, 0.01183941f, 0.03630288f, 
    0.02402099f, 0.04436404f, -0.01618475f, -0.05018121f, -0.04283688f, 0.03216731f, -0.03233147f, -0.01641646f, 
    -0.00852454f, -0.02469025f, 0.03426800f, -0.02118122f, 0.02135252f, 0.00567226f, -0.05432611f, -0.00177846f, 
    -0.02195305f, 0.01332048f, -0.04822695f, 0.02712318f, -0.02745706f, -0.01327109f, -0.01058892f, -0.01710792f, 
    -0.05348533f, -0.03567676f, 0.00415870f, -0.03261495f, 0.00721827f, -0.02709251f, 0.03752797f, 0.04341532f, 
    -0.00102850f, 0.01377801f, -0.02349378f, -0.02895911f, 0.03364887f, -0.05149579f, 0.02240524f, 0.02008513f, 
    -0.03027736f, -0.00802774f, 0.01634788f, -0.02932123f, 0.03589654f, -0.00335980f, -0.02893923f, 0.00985172f, 
    -0.01375654f, -0.04328210f, -0.01321025f, -0.04767741f, -0.03025622f, -0.03990987f, -0.04109137f, -0.04799955f, 
    -0.04929271f, -0.00733013f, -0.02445426f, 0.00757469f, 0.01780844f, 0.03175259f, -0.03487141f, -0.02096343f, 
    -0.05194338f, 0.03450180f, -0.01346517f, -0.02754552f, 0.03257382f, -0.02312993f, -0.02250176f, 0.04290467f, 
    -0.00021040f, 0.03324408f, -0.03246218f, 0.03869361f, 0.03032203f, -0.01347504f, -0.01009593f, -0.02968159f, 
    0.01886109f, 0.03273846f, 0.02518375f, -0.03659919f, 0.02041797f, -0.04211856f, -0.01162589f, 0.04469361f, 
    -0.00490695f, 0.01443830f, 0.04334765f, -0.01380411f, 0.01229817f, -0.02689786f, 0.01253937f, -0.00148038f, 
    -0.04762881f, 0.00182081f, -0.01417975f, 0.00916369f, -0.04202225f, -0.03100924f, 0.00941124f, -0.04088141f, 
    -0.03881653f, -0.03734814f, -0.00075913f, 0.01321114f, 0.00744772f, -0.02985697f, -0.04985523f, -0.05162993f, 
    -0.04852109f, -0.02764296f, 0.01406326f, -0.01472530f, 0.02496204f, 0.03286088f, 0.04190050f, 0.00300981f, 
    -0.02623907f, -0.04284638f, 0.01480728f, 0.00387847f, -0.03163054f, -0.00795213f, -0.05109444f, -0.00067108f, 
    0.02165858f, 0.03403248f, 0.03270912f, 0.01757239f, -0.01403951f, 0.01821669f, -0.04208682f, -0.02943444f, 
    0.00462814f, -0.05061354f, 0.04390969f, -0.04537610f, 0.03942834f, 0.04147176f, -0.00118757f, 0.00063425f, 
    -0.04093190f, -0.01098061f, -0.03738910f, 0.02572555f, -0.03727739f, -0.03273692f, 0.03795780f, -0.03007565f, 
    -0.22673813f, -0.21660820f, -0.15696682f, -0.21425325f, 0.03138966f, -0.16455160f, -0.06983870f, 0.17606373f, 
    -0.08068223f, -0.08373449f, -0.11017964f, -0.13401648f, 0.01201663f, 0.16225998f, 0.13954973f, 0.03828870f, 
    -0.03600824f, 0.04522162f, 0.10733337f, 0.10931620f, -0.03692859f, 0.09427542f, -0.16028374f, 0.10472464f, 
    0.16053241f, -0.00389390f, -0.11477434f, 0.09749556f, -0.01055341f, 0.05338538f, 0.10877106f, 0.05225870f, 
    -0.00764993f, -0.03238112f, -0.02388585f, -0.09234791f, -0.10587804f, -0.09395204f, 0.01295624f, -0.06624346f, 
    -0.11746626f, 0.04287112f, 0.07215305f, 0.05325690f, -0.04395154f, -0.07809427f, 0.04287808f, 0.16193712f, 
    0.25088128f, -0.19346356f, -0.21024048f, -0.16510102f, -0.07988877f, 0.16287693f, -0.11965965f, 0.20228484f, 
    0.01759167f, -0.19705439f, -0.03763752f, -0.10271587f, -0.00776045f, -0.18955249f, 0.15931036f, -0.16978243f, 
    -0.09452900f, -0.07072941f, -0.03797181f, 0.03510952f, -0.05508877f, -0.09861024f, -0.02752867f, -0.09832228f, 
    -0.32769373f, -0.08704376f, 0.23095211f, 0.17813663f, 0.02420332f, -0.05261460f, 0.02185240f, 0.23766603f, 
    0.07071353f, 0.11647706f, 0.11532147f, 0.02160711f, -0.02165047f, 0.14599164f, -0.13961829f, -0.00952241f, 
    0.28443933f, 0.03293771f, -0.16295059f, -0.01995753f, 0.02925157f, -0.05124482f, -0.07679169f, -0.25079727f, 
    -0.27537352f, 0.03234584f, -0.05611008f, -0.11999636f, 0.01304964f, 0.01019377f, 0.25010827f, -0.03332142f, 
    0.23690374f, 0.15362005f, 0.09935130f, 0.17363751f, -0.06814405f, -0.22243683f, 0.18427803f, -0.18252468f, 
    0.11158806f, 0.02399101f, -0.01140201f, 0.17255357f, -0.15393679f, -0.03522542f, 0.01085396f, -0.14884776f, 
    0.06958736f, 0.09613705f, 0.06790302f, -0.08452754f, -0.04005485f, -0.05750315f, -0.01501294f, -0.08462404f, 
    0.01139701f, -0.01996575f, -0.03448380f, -0.11176224f, -0.09270967f, -0.26361960f, 0.04483723f, 0.11503767f, 
    0.07466585f, -0.00222377f, 0.04380883f, 0.18823141f, -0.07105899f, 0.15472353f, 0.07270896f, -0.11143132f, 
    0.03794158f, 0.16694410f, -0.00009323f, 0.06492560f, -0.04775277f, 0.09547611f, 0.14334129f, -0.01687184f, 
    -0.07086555f, -0.08918817f, 0.00973608f, -0.19877702f, -0.00977214f, -0.01059028f, -0.07261501f, -0.11160530f, 
    0.06385120f, -0.08093365f, -0.12633342f, -0.12876147f, -0.15949263f, -0.08051312f, -0.12588680f, -0.11571106f, 
    -0.04985860f, 0.04110903f, 0.15408495f, 0.03811339f, 0.01882716f, 0.06061867f, 0.13168171f, 0.13590418f, 
    0.03361756f, 0.13060276f, 0.08175440f, 0.07686590f, -0.11601371f, -0.20454505f, 0.04731479f, 0.02478703f, 
    0.22156239f, -0.06246219f, 0.12073501f, 0.18483086f, -0.15543100f, -0.03727701f, 0.02039567f, 0.03727128f, 
    -0.26566321f, -0.14229974f, -0.07870352f, 0.08603586f, 0.16973399f, 0.07483466f, 0.15201367f, 0.04496160f, 
    0.03828047f, 0.17074202f, 0.13356522f, -0.08134443f, -0.03972524f, 0.02021861f, -0.11754622f, -0.15026872f, 
    0.06721634f, 0.14971964f, 0.29064867f, -0.09855361f, 0.02823967f, -0.03658672f, 0.05961306f, 0.03955994f, 
    0.08012279f, -0.03041784f, 0.09144977f, -0.04204658f, -0.06235711f, -0.04527600f, -0.02737386f, 0.06151195f, 
    -0.07884542f, -0.12464809f, -0.11687589f, -0.03660055f, 0.05570115f, 0.04365211f, 0.05728275f, 0.04332988f, 
    0.11015882f, -0.13213214f, 0.08563235f, -0.10134868f, 0.04047004f, 0.07587184f, -0.09020946f, -0.04410227f, 
    0.06906024f, 0.06265151f, 0.16071013f, 0.01518311f, -0.04935583f, -0.01520496f, 0.01683345f, 0.04168212f, 
    0.23086551f, 0.18492585f, 0.20385608f, 0.01577133f, 0.12689412f, -0.02994682f, -0.10838383f, -0.06668692f, 
    -0.00726125f, -0.06065060f, 0.20573124f, 0.08784701f, 0.00839340f, -0.01400357f, -0.03349725f, 0.17474033f, 
    0.17030583f, 0.10369895f, 0.15130295f, 0.01985786f, 0.15160152f, -0.13557534f, 0.03184627f, 0.20701535f, 
    -0.03685476f, -0.00757381f, -0.08592574f, -0.04899252f, 0.27584812f, -0.21148714f, -0.21818416f, 0.05244784f, 
    -0.07660690f, -0.02238010f, 0.05034464f, 0.07608742f, -0.02270738f, 0.01993479f, 0.09738021f, 0.24816729f, 
    -0.00739008f, -0.33428907f, -0.02911245f, 0.14735201f, 0.04752382f, 0.04408647f, 0.15477607f, 0.26390421f, 
    0.06474351f, 0.07433033f, 0.30201262f, 0.01363874f, -0.30756050f, -0.05733624f, 0.16608468f, -0.13896404f, 
    0.12916073f, -0.20892346f, 0.13379361f, 0.06270556f, -0.05785267f, 0.18860783f, -0.15575433f, 0.05954785f, 
    0.02772797f, 0.17605187f, 0.01328981f, 0.11352886f, -0.03406002f, -0.06332435f, 0.14014450f, 0.03212119f, 
    0.02083562f, 0.19202468f, 0.18290375f, 0.02330791f, 0.05718999f, 0.12664050f, -0.12966312f, -0.08047228f, 
    -0.00370651f, -0.22385807f, 0.08433390f, 0.02741182f, 0.07527642f, 0.19776791f, -0.00757162f, 0.12313101f, 
    0.14463444f, -0.02364405f, 0.17865822f, -0.08804620f, -0.05796906f, 0.04383779f, -0.01872555f, 0.03214648f, 
    -0.10335421f, 0.02767598f, 0.04660581f, -0.18294170f, 0.15762980f, -0.14499263f, 0.19608477f, -0.01775956f, 
    -0.09872027f, 0.03884359f, -0.03550060f, -0.15056945f, 0.09281133f, 0.06019292f, 0.04098646f, -0.05700582f, 
    -0.23242237f, -0.21333106f, -0.13875261f, 0.16220725f, 0.07513714f, 0.00393689f, 0.10271493f, 0.09706930f, 
    0.05727665f, 0.07627381f, 0.00587539f, 0.01915030f, 0.11212301f, -0.00965179f, -0.02586791f, -0.12926497f, 
    -0.08394238f, 0.09188580f, 0.14907466f, -0.00736582f, -0.00935226f, -0.09686077f, -0.04073975f, -0.18243037f, 
    0.26788768f, 0.19987921f, 0.22111753f, 0.02242550f, 0.07774842f, 0.16599691f, 0.21940465f, 0.10386764f, 
    -0.01255935f, -0.00723222f, -0.04427452f, -0.02476523f, -0.09354894f, -0.11745879f, -0.00253280f, -0.06093122f, 
    0.01495618f, -0.06619733f, -0.01094954f, 0.10536705f, 0.02102278f, -0.04421071f, 0.05955117f, -0.00615958f, 
    -0.00642898f, 0.03598425f, 0.23951577f, 0.24103864f, 0.01374570f, -0.09644250f, -0.06616497f, 0.08905558f, 
    0.01061575f, -0.03462059f, -0.07295184f, 0.03979503f, 0.00009938f, 0.13134664f, 0.26781979f, 0.14811999f, 
    0.05930676f, -0.16777472f, -0.05693028f, -0.06150787f, -0.05220119f, -0.01324706f, -0.03427136f, -0.00921748f, 
    -0.07903662f, 0.25353211f, 0.17185755f, 0.32476956f, 0.09325658f, -0.06692227f, 0.21206011f, 0.02935850f, 
    0.00192585f, -0.03623874f, -0.02862026f, -0.00201758f, -0.18174905f, 0.10530196f, 0.18539765f, -0.20640846f, 
    -0.05157055f, 0.14511554f, -0.09052460f, -0.09127168f, 0.12327074f, 0.01760216f, -0.00777733f, -0.03323749f, 
    0.41517395f, -0.03049220f, 0.17989558f, 0.18703011f, 0.01673304f, 0.08983298f, -0.03255717f, -0.00533713f, 
    0.07704284f, 0.06062295f, -0.00901242f, 0.10290527f, 0.15366124f, 0.06315114f, -0.00493591f, 0.01320699f, 
    0.14646120f, -0.06669162f, 0.10064252f, 0.15687579f, 0.00684360f, 0.04626847f, -0.03878063f, -0.02664490f, 
    0.03967770f, 0.07386433f, 0.04296129f, -0.09677942f, 0.14342868f, 0.14856476f, -0.24003105f, 0.01738568f, 
    -0.02465815f, -0.04047412f, 0.09499817f, 0.03068020f, 0.02739026f, 0.13276443f, 0.03691093f, -0.08776782f, 
    0.04346600f, 0.18349122f, 0.12175294f, 0.05090775f, 0.01797770f, 0.01015557f, -0.07382074f, 0.00748997f, 
    -0.24343660f, -0.28007090f, -0.04960034f, 0.09024877f, -0.00861740f, -0.08524814f, -0.02963312f, 0.01455986f, 
    0.00917638f, -0.08523837f, -0.06901117f, 0.11312203f, 0.07555112f, 0.30349505f, 0.39786538f, -0.14697242f, 
    -0.01428014f, -0.07431592f, 0.09896465f, 0.09476729f, -0.00061386f, -0.06442731f, 0.00168534f, -0.04169966f, 
    -0.10713080f, -0.03256066f, -0.06933007f, -0.12814640f, 0.15370201f, 0.00304415f, -0.09527462f, -0.05140470f, 
    0.06306954f, 0.06436671f, -0.09557544f, 0.07313332f, 0.04731880f, 0.02194101f, -0.09992238f, 0.00124053f, 
    -0.13022438f, -0.04087708f, -0.02541420f, 0.11175111f, -0.00337878f, -0.03110912f, -0.00770097f, -0.04524860f, 
    -0.04420117f, -0.05902237f, -0.10175282f, -0.04711724f, -0.04565126f, 0.01146425f, -0.06933049f, -0.08679214f, 
    0.17524876f, 0.03976890f, -0.00843159f, 0.04364375f, 0.02715084f, 0.17153038f, -0.11007832f, -0.16472699f, 
    -0.19383113f, -0.05177233f, 0.07776789f, 0.10985231f, 0.01249691f, 0.09234398f, -0.01506480f, -0.05633037f, 
    0.12544550f, 0.17920840f, -0.04236437f, -0.01494310f, -0.07562278f, -0.02163652f, 0.05881272f, -0.02309286f, 
    0.01979057f, 0.13945737f, -0.06588120f, 0.13120802f, 0.01609284f, 0.04121315f, -0.06060648f, 0.03566596f, 
    0.15151218f, -0.04569716f, -0.22059062f, -0.00910373f, -0.08065411f, 0.04743409f, 0.04604318f, -0.03123902f, 
    -0.17045446f, 0.03113321f, 0.01421755f, -0.08237111f, 0.00640745f, -0.07181371f, -0.10294650f, -0.03187734f, 
    0.00015177f, -0.07627711f, 0.03207937f, 0.02379439f, -0.15684442f, -0.13414943f, -0.13890417f, -0.06177856f, 
    -0.01969162f, 0.01755764f, -0.01932061f, 0.04105359f, -0.04761501f, -0.05949043f, -0.04360869f, 0.07952251f, 
    -0.03890536f, -0.14011213f, -0.13939793f, 0.00044252f, -0.00043787f, 0.02398203f, 0.05032507f, -0.05517619f, 
    0.01225680f, -0.22417980f, 0.02271689f, 0.02759765f, -0.15118805f, 0.07529038f, 0.15813091f, -0.00751707f, 
    0.03341396f, 0.00682346f, -0.22153758f, -0.07246474f, -0.01177174f, 0.01915240f, -0.04234501f, 0.01284049f, 
    -0.06216392f, -0.11887858f, -0.05413324f, -0.13273223f, -0.10222238f, 0.02677667f, 0.01658622f, -0.01608881f, 
    -0.03980673f, -0.06604860f, -0.02670071f, 0.03837983f, -0.01541503f, 0.08800489f, 0.27187455f, 0.31599376f, 
    0.09322412f, -0.00607479f, -0.02066061f, 0.04453211f, 0.08987758f, 0.02844752f, 0.06798707f, 0.03788415f, 
    -0.00139472f, 0.14405064f, 0.36194977f, 0.02558110f, -0.01454017f, -0.03737688f, 0.02807046f, 0.01237847f, 
    -0.00523480f, -0.07504818f, -0.02687627f, 0.12877566f, 0.20540449f, 0.11884633f, 0.03699422f, 0.02660421f, 
    0.06917946f, 0.14963609f, 0.10432231f, 0.06780088f, 0.02311152f, 0.02088598f, 0.10159784f, -0.08914917f, 
    -0.04064997f, -0.15646656f, -0.02658564f, -0.04975203f, 0.03685242f, -0.04464097f, -0.11010417f, -0.01671971f, 
    -0.10206208f, 0.06123057f, 0.11108339f, 0.15837717f, -0.29127342f, 0.10722882f, 0.11508502f, -0.15276401f, 
    0.01137416f, 0.09159137f, -0.03162737f, -0.07616280f, -0.05007878f, 0.08516067f, 0.17378026f, -0.11711482f, 
    -0.15561029f, -0.01341426f, -0.20645322f, 0.02093582f, 0.14264771f, -0.04893573f, -0.02400359f, 0.01383560f, 
    0.03560198f, 0.08125097f, -0.12485529f, 0.28968310f, -0.30512568f, -0.15712003f, -0.00332898f, 0.09167492f, 
    -0.02108945f, -0.03999449f, -0.04836141f, -0.06411033f, -0.00727697f, -0.01092642f, 0.03003355f, -0.08267003f, 
    0.11849451f, 0.31550488f, 0.20108791f, 0.02268869f, 0.03431144f, 0.15314181f, 0.11336868f, 0.16730984f, 
    0.02335597f, -0.00324524f, 0.09784078f, 0.05855418f, -0.13457505f, -0.07792505f, -0.04309874f, 0.03767729f, 
    0.07342513f, -0.01603789f, -0.04475912f, -0.00255324f, 0.03216045f, 0.06481749f, 0.04669804f, -0.02073025f, 
    -0.01447404f, 0.02232138f, -0.02717838f, -0.03046797f, 0.01466295f, 0.02196896f, 0.02988503f, -0.04581369f, 
    -0.00670905f, -0.01993420f, -0.03981832f, -0.01421036f, -0.01518207f, -0.02608563f, -0.05225274f, -0.01226123f, 
    -0.00345739f, -0.04387838f, 0.02002177f, 0.04267236f, 0.00421625f, -0.05413228f, 0.00756245f, -0.00902530f, 
    0.01678200f, -0.04924505f, -0.01980233f, -0.01424825f, -0.03557004f, -0.00684990f, -0.04037729f, -0.01928400f, 
    0.03101187f, 0.00224128f, -0.01155620f, 0.01707115f, 0.00480297f, -0.05168331f, -0.03515546f, -0.01692240f, 
    0.02227009f, 0.01266489f, -0.03401643f, -0.00920439f, 0.02667379f, 0.00437785f, -0.04432521f, 0.00562978f, 
    0.02885638f, 0.00608915f, 0.04784596f, -0.03607306f, -0.03264596f, 0.01136582f, 0.01270579f, 0.02243813f, 
    -0.03195435f, -0.00216985f, 0.01458240f, 0.03178757f, 0.04060519f, -0.05891828f, 0.04452975f, 0.00782103f, 
    -0.04816036f, 0.01249087f, -0.05677633f, 0.04385968f, 0.04682279f, 0.00079488f, -0.01929001f, 0.04396599f, 
    -0.03203926f, -0.01350571f, -0.03013049f, -0.04204885f, 0.02563000f, 0.00320108f, 0.02826530f, -0.05669281f, 
    -0.01644768f, 0.03171470f, 0.01785357f, -0.04254230f, 0.04160076f, 0.04100171f, 0.00677441f, -0.02975385f, 
    -0.01431959f, -0.02586649f, -0.01846472f, 0.03908234f, 0.03501232f, 0.03572414f, -0.01368871f, -0.01704947f, 
    -0.02880022f, -0.00208455f, -0.00875926f, 0.01105880f, -0.03872430f, -0.03674398f, 0.01094986f, -0.01232813f, 
    -0.02194220f, 0.03008065f, -0.03243693f, -0.00506750f, -0.02841150f, -0.03904750f, 0.02046410f, -0.03655245f, 
    -0.05975747f, 0.02920060f, -0.04915578f, 0.02202433f, -0.03840326f, -0.03854197f, -0.01937940f, -0.03742012f, 
    -0.02450603f, -0.03799981f, -0.03931542f, -0.05327857f, -0.01318668f, 0.02466763f, -0.02179244f, -0.04543012f, 
    0.00495063f, -0.01812604f, -0.04915471f, -0.01813475f, -0.04006639f, 0.01137979f, 0.01944352f, -0.02620973f, 
    -0.05501688f, 0.03074087f, -0.05555263f, 0.04015209f, -0.01285224f, 0.02691217f, -0.05800527f, -0.00641830f, 
    -0.02311280f, -0.04192465f, 0.00759370f, 0.03313030f, 0.04467728f, 0.01226347f, -0.04158888f, -0.04848462f, 
    -0.00544589f, 0.04393680f, -0.02710034f, -0.04003345f, -0.00179174f, -0.01501653f, 0.03762896f, -0.02514780f, 
    0.03459627f, -0.03762417f, 0.04164278f, 0.02564929f, 0.02817034f, -0.03105372f, -0.04146349f, 0.02092666f, 
    0.04036893f, -0.02197313f, -0.00328543f, 0.01701882f, 0.03508168f, -0.03931680f, -0.05354561f, -0.04911495f, 
    0.01949874f, 0.00470593f, 0.01472225f, 0.03016407f, -0.04318098f, 0.01776371f, -0.00112125f, 0.00155225f, 
    0.04258883f, -0.02289053f, -0.00172608f, -0.05758834f, 0.02297369f, -0.01216672f, 0.02718187f, -0.03495324f, 
    -0.05292998f, -0.01057658f, 0.01593039f, -0.05214055f, -0.05658014f, -0.01224876f, -0.04237024f, 0.02781594f, 
    -0.03104645f, -0.01502065f, -0.04855410f, 0.03784092f, 0.03846267f, -0.04119769f, -0.02142077f, 0.00813350f, 
    0.00679687f, 0.02721480f, 0.01825744f, -0.01924628f, -0.04514352f, 0.01847819f, 0.00716940f, -0.03038329f, 
    -0.04843039f, 0.02119542f, 0.02883811f, -0.01384874f, 0.03330798f, 0.03003940f, -0.02666880f, 0.04419601f, 
    0.01212125f, 0.02430051f, -0.01336252f, 0.00778200f, -0.01405588f, -0.01406553f, -0.03035873f, 0.02097279f, 
    -0.01000940f, -0.02624919f, -0.02947363f, -0.02782930f, 0.01978394f, -0.01465482f, 0.01274711f, -0.03689504f, 
    -0.05151307f, -0.05924052f, 0.01864315f, 0.00896366f, -0.02151641f, 0.00528155f, 0.04424288f, -0.02605769f, 
    -0.03689897f, 0.03681646f, -0.01711309f, 0.03259142f, 0.02137032f, -0.03171545f, -0.00225226f, 0.02384423f, 
    0.02875963f, -0.04944137f, -0.05944740f, 0.00590393f, 0.03805117f, 0.01191384f, 0.00722205f, 0.03117521f, 
    -0.00614731f, -0.00259465f, -0.03631219f, -0.02709730f, 0.04234064f, 0.01834151f, -0.05290425f, -0.05402609f, 
    0.00763737f, -0.00705312f, -0.05216267f, 0.02213517f, -0.04605193f, -0.02454744f, -0.04432692f, 0.00986494f, 
    0.01007850f, 0.01993546f, -0.04597724f, -0.04655253f, 0.02474393f, -0.00014407f, 0.00116724f, -0.04773194f, 
    0.02839798f, 0.04418703f, -0.03144998f, -0.04830468f, 0.02292943f, -0.05418097f, -0.00424356f, -0.04192460f, 
    -0.00063820f, 0.01778353f, -0.01271613f, -0.00137949f, -0.05966559f, -0.01557156f, 0.03376155f, 0.04024016f, 
    -0.01392126f, -0.01199512f, -0.04550976f, -0.00288095f, -0.03722546f, -0.01542437f, -0.03583094f, -0.04808651f, 
    -0.02669906f, 0.00446163f, 0.01488934f, 0.00684768f, -0.01215980f, 0.01445956f, 0.03626724f, 0.04807188f, 
    0.02610379f, -0.00648060f, 0.01141752f, -0.01589186f, -0.00416593f, -0.02801498f, -0.02081455f, 0.01855274f, 
    -0.02900207f, 0.01944784f, 0.01648556f, -0.04666381f, 0.00330997f, 0.00745229f, -0.00763099f, 0.01537354f, 
    0.03383053f, -0.00791092f, -0.00702053f, 0.01242033f, -0.02885361f, -0.03015020f, -0.01842751f, 0.00192436f, 
    -0.01833396f, 0.00195113f, 0.01051353f, -0.00839749f, -0.00461938f, -0.05494796f, -0.04529431f, -0.01171198f, 
    0.01475280f, -0.00234344f, 0.04006369f, -0.03285025f, 0.02756014f, 0.03017715f, 0.01362675f, 0.03003068f, 
    0.00014697f, -0.00460102f, 0.02413159f, 0.02401307f, -0.02725603f, -0.03763163f, -0.01012552f, -0.02534823f, 
    -0.02790858f, -0.00807578f, -0.04170299f, -0.02490828f, 0.03619916f, 0.01413665f, 0.02398087f, -0.04836648f, 
    -0.05045781f, 0.03947117f, -0.00896580f, 0.01829306f, -0.02794215f, -0.04676766f, -0.00932909f, 0.02772584f, 
    0.05447174f, 0.17196193f, 0.30168045f, 0.35423613f, -0.10962775f, -0.03038621f, -0.03985183f, 0.15585235f, 
    -0.03113193f, 0.08533569f, 0.00268666f, 0.00960110f, 0.03512800f, -0.10177611f, -0.44446507f, 0.10156075f, 
    0.00995649f, -0.07902180f, -0.01253154f, -0.13360043f, 0.10091437f, -0.19052115f, -0.02692396f, 0.05472209f, 
    -0.48431271f, -0.10370491f, -0.36269996f, 0.21676882f, -0.06212079f, 0.15219817f, 0.01631588f, -0.10030793f, 
    -0.09928730f, -0.04346518f, 0.00713788f, 0.04451578f, 0.06624670f, -0.09805639f, 0.13777708f, 0.22082271f, 
    -0.05670652f, -0.19265768f, -0.20169841f, -0.03978178f, 0.02957795f, -0.03477494f, -0.01600705f, -0.07037052f, 
    0.30575022f, 0.26567903f, 0.13353491f, 0.07768643f, -0.00819678f, -0.14410874f, 0.12142672f, 0.17595018f, 
    -0.00845075f, -0.04503460f, -0.01951875f, -0.01366474f, 0.29720885f, 0.00042252f, 0.09772334f, 0.06290382f, 
    0.03878194f, -0.00919399f, 0.23855263f, 0.05680995f, -0.16813517f, 0.05354172f, 0.06371557f, 0.05817691f, 
    -0.00523900f, 0.04711211f, 0.23694658f, 0.10416611f, -0.05604491f, 0.08723267f, -0.05568500f, -0.03052053f, 
    0.01356036f, 0.00459668f, -0.00344154f, 0.00213434f, 0.06694905f, -0.01749253f, 0.20975019f, 0.07486060f, 
    0.03089467f, 0.04009429f, -0.14384426f, 0.21062474f, 0.05313318f, 0.02640235f, 0.07502537f, 0.09520951f, 
    0.05323924f, 0.43957999f, 0.10838374f, 0.14979878f, 0.06335077f, -0.20847224f, 0.11461311f, -0.26584736f, 
    -0.02577296f, -0.04162572f, 0.02468509f, 0.04012199f, -0.00604854f, -0.17831294f, -0.05037272f, 0.13322450f, 
    -0.12897560f, 0.03189672f, -0.01437809f, 0.01842398f, -0.00511082f, 0.02858289f, 0.02190712f, 0.10231514f, 
    -0.58498430f, -0.33217207f, -0.45026171f, -0.11313806f, -0.06331453f, 0.05600853f, 0.00271770f, -0.07523593f, 
    0.12088168f, -0.08290900f, -0.04587753f, 0.00050642f, -0.22950013f, 0.00071554f, -0.07019523f, 0.11710486f, 
    0.06162347f, 0.08740527f, -0.10275842f, 0.20539586f, 0.13672364f, 0.09451015f, -0.01586120f, 0.05273799f, 
    -0.11990996f, -0.06241154f, 0.00463616f, -0.04499009f, 0.06779750f, -0.00026433f, 0.07208061f, 0.05440008f, 
    -0.02495577f, 0.06573641f, 0.09025021f, 0.08751949f, -0.08944830f, -0.22265173f, 0.00294206f, 0.04905918f, 
    -0.02293680f, 0.06255706f, 0.08510515f, 0.06691674f, 0.08831642f, -0.06511791f, 0.08299351f, -0.03879352f, 
    -0.00163383f, -0.12768111f, 0.04870853f, -0.00926167f, 0.01363579f, 0.05527712f, 0.03466660f, -0.03692058f, 
    -0.02049546f, -0.08533379f, -0.02050477f, -0.01736854f, -0.08601321f, -0.19295065f, 0.34625146f, 0.02539756f, 
    0.04082338f, 0.13937631f, 0.15646109f, -0.04698311f, 0.08383877f, -0.03485757f, -0.03846829f, -0.02857555f, 
    0.19784662f, 0.13597187f, 0.20400511f, 0.20571117f, 0.05654874f, -0.14123732f, 0.15965866f, 0.14210939f, 
    -0.09035618f, 0.01170254f, 0.00937485f, -0.02484350f, -0.08361883f, 0.08693746f, 0.12063480f, 0.03993885f, 
    -0.12023590f, -0.04355846f, 0.04321270f, -0.09865651f, -0.01441846f, -0.01719557f, 0.06350030f, 0.01103330f, 
    -0.11397409f, -0.06671182f, -0.05581475f, 0.05817412f, -0.02500627f, -0.04041103f, 0.14033069f, -0.01949846f, 
    0.01339420f, -0.04808736f, -0.03749615f, 0.04817481f, -0.04278954f, -0.08193960f, 0.14683406f, -0.14885293f, 
    0.00531345f, -0.00649759f, -0.06720932f, -0.02398570f, 0.00247096f, -0.00838694f, 0.07974324f, -0.07579452f, 
    0.12354127f, 0.02809725f, 0.16470557f, -0.13056611f, 0.05637362f, -0.03427588f, -0.13953963f, -0.04866003f, 
    -0.01448216f, -0.02013873f, -0.00628385f, -0.14545029f, 0.06367674f, 0.18487443f, 0.00057193f, -0.06587924f, 
    0.07980959f, -0.07394861f, 0.12851655f, 0.16869943f, -0.00930091f, 0.07201873f, 0.01552709f, -0.15609381f, 
    -0.00572278f, 0.00562550f, -0.11062232f, 0.17340398f, -0.13622260f, -0.01068590f, 0.13211851f, 0.05697619f, 
    0.00039833f, 0.03138635f, 0.05598663f, 0.07447279f, -0.03630147f, 0.22238784f, 0.12497961f, 0.08158921f, 
    -0.01078078f, -0.01203431f, -0.07538610f, 0.05201651f, -0.03452027f, 0.08871637f, -0.11772091f, -0.05316267f, 
    -0.14011997f, 0.03968963f, 0.01084657f, 0.17428370f, -0.02638143f, 0.11943050f, 0.00924974f, -0.07277469f, 
    0.01717926f, 0.09328163f, -0.02953124f, -0.09220988f, 0.16298059f, -0.01591689f, 0.21809943f, 0.21195130f, 
    -0.04199457f, 0.10540258f, 0.10464212f, 0.09836331f, 0.01519423f, -0.10547633f, 0.08424933f, -0.04592284f, 
    0.01929965f, -0.24271050f, 0.03443770f, 0.01026317f, 0.05931417f, 0.01729002f, -0.19621454f, -0.03182194f, 
    -0.01686571f, -0.08790325f, 0.01864050f, 0.05205998f, -0.01135879f, 0.03355826f, 0.34728616f, 0.07677349f, 
    0.03844792f, -0.09089011f, 0.10953008f, 0.00595682f, -0.00814654f, -0.04276882f, 0.03426166f, 0.02243646f, 
    -0.14269403f, 0.12410282f, -0.03078802f, 0.06802277f, -0.02767241f, -0.05468531f, 0.06518976f, -0.10246709f, 
    -0.05339980f, 0.01636446f, -0.07015356f, 0.10292674f, -0.15239534f, 0.22014217f, 0.00979326f, -0.21848093f, 
    -0.06065466f, -0.05645728f, 0.01343996f, 0.04736708f, -0.30037853f, -0.15559061f, 0.00801148f, -0.01611333f, 
    0.02681315f, 0.00086843f, 0.06124639f, 0.17094697f, 0.05398264f, 0.00512669f, 0.02429911f, 0.15764162f, 
    0.08004444f, 0.07900305f, -0.03513841f, 0.00689444f, 0.01942801f, -0.10246135f, -0.04655361f, -0.11879289f, 
    0.08835144f, 0.01484622f, 0.07299223f, -0.15555774f, 0.12237489f, 0.00211788f, 0.04351771f, 0.12814353f, 
    -0.04218645f, -0.00483230f, -0.00321734f, -0.01660079f, -0.03100595f, -0.03362756f, -0.00213293f, 0.03566586f, 
    -0.03194545f, 0.04000483f, -0.03074952f, -0.02960493f, 0.01922144f, -0.04247771f, -0.00950294f, -0.01685330f, 
    -0.03526673f, -0.03543629f, -0.03107856f, -0.04918735f, 0.01847674f, -0.01583361f, -0.04063419f, -0.00204189f, 
    -0.00928367f, 0.02140329f, 0.01702001f, -0.05112625f, 0.03212359f, -0.02256538f, -0.03186150f, 0.00623206f, 
    -0.04023462f, -0.02080907f, -0.01960556f, -0.00397468f, -0.00553269f, 0.01264653f, 0.04224921f, 0.03110848f, 
    -0.00755598f, 0.02769824f, -0.03822313f, -0.03094044f, -0.03530841f, -0.03303877f, -0.04738892f, -0.00153861f, 
    0.01994988f, 0.04340696f, -0.02693371f, 0.04112753f, 0.02915123f, -0.04132859f, -0.01440012f, -0.02077882f, 
    -0.03034828f, -0.04271058f, 0.01985328f, -0.04372198f, 0.01558696f, 0.03982290f, 0.03616620f, -0.04030519f, 
    0.03812128f, 0.01794081f, -0.02896397f, -0.03730460f, -0.05122920f, 0.00992878f, 0.01119782f, -0.04594086f, 
    -0.01966089f, 0.01448137f, 0.04450801f, 0.03480241f, 0.02326755f, -0.02751881f, -0.01549694f, -0.02401282f, 
    -0.02466408f, -0.05240382f, 0.00158543f, -0.02821058f, -0.03001132f, 0.01698183f, -0.01660078f, -0.04266771f, 
    0.03270933f, 0.01638814f, 0.02708104f, -0.01675694f, -0.04277061f, -0.05204795f, -0.02346822f, 0.01677531f, 
    0.04130983f, 0.02584103f, -0.00634274f, 0.03925305f, 0.00524091f, -0.01116794f, -0.02024166f, 0.04261360f, 
    -0.02996371f, -0.03700823f, -0.00712525f, -0.05371634f, -0.03247218f, -0.03195312f, 0.00749921f, 0.00975341f, 
    -0.01090680f, -0.04464211f, 0.02518605f, -0.00247462f, -0.00990052f, 0.02668251f, 0.04189258f, -0.04084667f, 
    -0.00496034f, 0.01763325f, 0.01713935f, -0.05226542f, -0.02807599f, -0.00071065f, -0.04588532f, -0.00556373f, 
    -0.03953152f, 0.02381599f, 0.00153891f, -0.03100190f, -0.04360939f, 0.02037205f, 0.03352144f, -0.02269614f, 
    -0.03655633f, 0.01741353f, 0.04117139f, 0.04017529f, 0.03507891f, 0.04411299f, 0.01454340f, -0.02156658f, 
    0.00613664f, -0.00675536f, -0.05415133f, -0.03204077f, -0.01277688f, -0.00923442f, 0.01717391f, 0.01295825f, 
    -0.05311543f, -0.05271507f, 0.02807936f, -0.05501507f, 0.03548419f, 0.01970219f, -0.00810384f, -0.03342559f, 
    0.03742963f, 0.02145895f, -0.01856557f, -0.05542409f, 0.00750084f, 0.02643572f, -0.00879044f, -0.01230953f, 
    -0.04781008f, -0.04747193f, 0.00449536f, -0.04689087f, 0.04299981f, 0.01208280f, -0.03908348f, -0.05252876f, 
    -0.04078688f, -0.01249703f, 0.03878243f, -0.01007452f, -0.00485951f, -0.02513884f, 0.04239970f, 0.00315500f, 
    0.01644288f, -0.00414647f, 0.03902235f, -0.01975186f, -0.02639197f, -0.01942001f, -0.02531985f, 0.02923985f, 
    -0.01107503f, 0.02954919f, 0.01364701f, -0.01460491f, -0.02894144f, 0.00840048f, -0.03285374f, 0.00357253f, 
    -0.02801616f, 0.01584053f, -0.03591122f, 0.01328034f, -0.05145613f, -0.04996543f, 0.01865187f, 0.00964245f, 
    -0.03211732f, 0.02364555f, -0.01354224f, -0.03538273f, -0.03904683f, 0.00130875f, 0.03504379f, -0.05103900f, 
    0.00610748f, -0.01652347f, 0.00230569f, 0.03768159f, -0.05608458f, -0.02304754f, -0.00433926f, -0.05013197f, 
    -0.05496812f, 0.03587674f, 0.00134055f, 0.04319490f, -0.04633244f, 0.01393857f, 0.04464930f, -0.02401401f, 
    -0.01522628f, 0.03895514f, -0.00361124f, 0.00419834f, 0.02780683f, 0.03128288f, -0.01834011f, -0.02867130f, 
    -0.03843964f, 0.04418662f, 0.04225855f, -0.05503846f, 0.00766641f, 0.02594491f, 0.03203637f, 0.04087293f, 
    0.02859703f, -0.04622651f, -0.04808610f, 0.04215318f, -0.01386628f, 0.00251791f, 0.03428108f, -0.01155020f, 
    -0.05475927f, -0.00952628f, 0.00136759f, -0.03992363f, -0.03764124f, 0.02859340f, -0.04917756f, -0.04864816f, 
    -0.02213922f, -0.00122396f, -0.02007377f, -0.00120763f, 0.00125849f, -0.04370278f, 0.02860543f, -0.01611220f, 
    -0.05009239f, -0.00158532f, 0.02735537f, 0.00688564f, -0.04746669f, 0.02004713f, -0.05017306f, 0.00720203f, 
    -0.02398083f, -0.05094331f, -0.04742679f, -0.00702448f, -0.02732156f, -0.03167665f, 0.00611698f, -0.05405422f, 
    -0.03191556f, 0.01651606f, -0.01197589f, -0.01338753f, -0.00559826f, -0.02106527f, -0.01738544f, -0.00373424f, 
    -0.00456088f, 0.02043328f, -0.03029227f, -0.04426815f, -0.05376754f, -0.02309415f, -0.05305469f, -0.05609511f, 
    -0.02636884f, -0.02107889f, 0.03943304f, -0.00882429f, 0.04239659f, 0.03733554f, -0.03290209f, 0.00021846f, 
    -0.05544991f, 0.02840328f, 0.01408616f, 0.03233266f, 0.02185684f, -0.00492158f, 0.03420636f, -0.01392182f, 
    -0.00232499f, -0.01080662f, 0.03486142f, -0.04870142f, -0.02775216f, -0.01815310f, -0.01475165f, 0.00865276f, 
    -0.05306897f, 0.02193992f, 0.02856842f, 0.02935492f, 0.01191699f, -0.05076216f, -0.03528474f, -0.02243859f, 
    -0.05526618f, -0.05313037f, 0.02957496f, 0.00478185f, -0.03261155f, 0.01897355f, -0.00278649f, -0.03142288f, 
    0.03901199f, -0.02448867f, -0.04149886f, -0.00031500f, -0.01346461f, -0.00494370f, -0.01674841f, -0.05019378f, 
    0.04156952f, 0.03040421f, 0.01196167f, 0.01309500f, 0.03360001f, 0.04306471f, -0.05187334f, -0.02009298f, 
    -0.01385756f, 0.03881251f, 0.02940705f, -0.02185060f, 0.03782102f, -0.03723678f, 0.04017868f, 0.01880143f, 
    -0.01942132f, 0.00448733f, 0.01756601f, -0.01223623f, -0.01949887f, -0.02747018f, 0.00663118f, -0.02430061f, 
    0.00834466f, 0.03085643f, -0.04494185f, -0.04788077f, -0.05239667f, -0.01572699f, -0.03020559f, 0.04116019f, 
    0.13273647f, 0.03041933f, -0.09216790f, 0.10039469f, 0.05286968f, 0.11652911f, 0.15100007f, 0.22404860f, 
    -0.02269926f, 0.03994510f, 0.03179266f, 0.03649491f, -0.11381155f, -0.00340112f, 0.39574686f, -0.10173066f, 
    -0.03643111f, -0.02123607f, -0.11189480f, 0.08729846f, 0.04859368f, -0.08415662f, 0.03666559f, 0.05845713f, 
    0.29903436f, 0.20721072f, 0.14363711f, 0.01612744f, -0.00665788f, -0.05869658f, -0.08911891f, -0.01524488f, 
    -0.04470465f, -0.06248816f, -0.06634829f, 0.14984636f, 0.24425915f, 0.06044095f, 0.12705357f, 0.16076544f, 
    0.11314379f, 0.01218881f, -0.09217769f, -0.06887376f, 0.02992303f, 0.05915170f, 0.01670228f, 0.00985614f, 
    0.47221637f, 0.07247936f, 0.43340209f, 0.36592093f, -0.02684537f, 0.06361554f, 0.02572675f, 0.34817779f, 
    -0.08339559f, -0.06048148f, 0.12650017f, 0.20731848f, -0.32066971f, 0.02721983f, 0.15830250f, 0.33630222f, 
    0.04278367f, 0.13263990f, -0.16617280f, -0.05991378f, 0.03222508f, -0.00988857f, -0.04541277f, 0.15589416f, 
    0.33761775f, -0.10988764f, -0.09306403f, 0.08306840f, 0.05635111f, 0.12830779f, -0.07689667f, -0.05357873f, 
    0.00532276f, 0.12260289f, 0.02474627f, 0.09527573f, 0.25538307f, 0.08109705f, -0.22491220f, -0.14299965f, 
    0.07973573f, -0.09794855f, -0.09085863f, 0.10652979f, 0.00553771f, 0.09623102f, -0.10950775f, -0.00882919f, 
    -0.07176343f, -0.07751010f, -0.03255884f, 0.20695233f, 0.05163005f, 0.20324309f, -0.09679845f, -0.10214755f, 
    0.05871492f, -0.09508412f, 0.11261745f, 0.23807739f, 0.02949796f, 0.11828773f, -0.07513528f, -0.10900091f, 
    0.02603468f, -0.10516491f, -0.14374337f, 0.05033717f, -0.08981091f, 0.08757459f, -0.01652335f, -0.08673161f, 
    -0.20920481f, -0.08261983f, 0.15852314f, -0.06631171f, -0.10257698f, -0.09512383f, -0.15174936f, 0.09455264f, 
    -0.03071507f, -0.08806620f, -0.02200689f, -0.00285654f, 0.19481099f, -0.03793481f, 0.16427705f, -0.21599114f, 
    0.11113317f, -0.10978056f, -0.02084506f, -0.04078510f, 0.00131902f, -0.02456595f, 0.05139242f, -0.10377640f, 
    -0.13065587f, -0.12231188f, -0.06076609f, 0.11005316f, 0.12527122f, 0.13825735f, -0.09322695f, -0.18733603f, 
    -0.01937393f, -0.00090036f, -0.16916925f, 0.04252431f, 0.06859762f, 0.02481799f, 0.07081884f, -0.08464193f, 
    -0.01562442f, -0.06091817f, -0.04300631f, 0.04430782f, -0.00248387f, 0.08404069f, -0.12215760f, -0.12580188f, 
    0.01534291f, 0.10171513f, 0.15251033f, -0.01689832f, -0.02678617f, 0.04413497f, -0.07948978f, -0.05414038f, 
    0.19374840f, -0.02076001f, 0.11981411f, 0.15256917f, 0.14942557f, 0.24259061f, -0.11022151f, -0.09362289f, 
    0.00573142f, -0.08709651f, -0.04387147f, 0.20839803f, 0.04640865f, 0.03946421f, 0.05316730f, -0.16329898f, 
    0.09483621f, -0.14022613f, -0.15054008f, 0.18113911f, 0.12615186f, 0.13892952f, 0.08131410f, 0.16805175f, 
    0.16804762f, 0.18467334f, -0.09049844f, 0.22654560f, 0.07722111f, 0.06160017f, -0.17702629f, 0.04251098f, 
    0.02948076f, 0.22736989f, -0.11446447f, 0.04946567f, 0.10767090f, -0.04234188f, 0.07095300f, -0.05601043f, 
    -0.45967147f, 0.01762514f, 0.18715215f, -0.11371870f, 0.11867567f, -0.01679394f, -0.13924611f, -0.04597830f, 
    0.05254901f, 0.02422744f, -0.01784750f, -0.05034705f, -0.14301886f, 0.07477042f, -0.24995801f, 0.14556020f, 
    -0.04314299f, -0.13749753f, 0.06149110f, -0.04805181f, -0.06661091f, -0.08780900f, -0.17159098f, 0.12188287f, 
    0.03246556f, 0.06571390f, 0.00432343f, 0.04339873f, 0.03818057f, 0.02967146f, 0.05387286f, -0.07550925f, 
    0.04916326f, 0.05503324f, 0.04853721f, 0.15300663f, -0.57283151f, 0.07210656f, 0.29387882f, 0.00062173f, 
    0.06769197f, 0.14288859f, -0.16510943f, -0.18205452f, 0.10423113f, 0.02012138f, -0.05231813f, 0.06146495f, 
    -0.34569749f, -0.02813870f, 0.14090557f, 0.09032056f, 0.05112417f, -0.08195194f, 0.14125602f, -0.14385660f, 
    0.04422787f, -0.04739486f, 0.00179715f, -0.15278426f, 0.14561130f, 0.04251282f, -0.09039052f, 0.34185687f, 
    -0.02499518f, 0.16699107f, 0.10882296f, 0.00482791f, -0.15494870f, -0.01293068f, 0.05027888f, 0.09155726f, 
    0.10458057f, 0.03465714f, 0.04912294f, 0.13785724f, 0.03366726f, -0.02973597f, -0.01515272f, -0.11610526f, 
    -0.04545903f, -0.00673973f, -0.11334611f, 0.08463714f, 0.22235057f, 0.12190533f, 0.09870446f, 0.13514084f, 
    0.16949199f, 0.04187820f, 0.15164430f, 0.02063836f, 0.02427640f, 0.05162015f, 0.09478724f, -0.12447909f, 
    -0.06594022f, 0.12797692f, 0.00279685f, -0.16849555f, -0.06251289f, -0.03616435f, 0.01450992f, -0.10303034f, 
    -0.02703631f, 0.00839884f, 0.07038660f, 0.07751963f, -0.34170085f, 0.13968264f, -0.00991908f, 0.22994545f, 
    -0.08798406f, 0.07003565f, -0.09674928f, -0.07358093f, 0.16110185f, -0.04959478f, -0.01376019f, -0.01973446f, 
    0.34096879f, -0.05757843f, -0.44856796f, -0.31057024f, 0.12703095f, -0.06890353f, -0.02643534f, 0.04681408f, 
    -0.10218953f, 0.12458031f, -0.10684650f, 0.01372584f, -0.11682327f, -0.29385170f, 0.02752095f, 0.16611676f, 
    -0.07463496f, 0.00315317f, -0.07113151f, -0.19694082f, 0.04523127f, -0.17786089f, 0.03418636f, -0.01719121f, 
    -0.06759658f, 0.03226930f, -0.03688613f, -0.03640100f, -0.02914476f, 0.04706155f, -0.09908320f, 0.05425372f, 
    0.01843967f, -0.04100613f, -0.00528257f, 0.04492344f, -0.11278474f, -0.15457293f, 0.03420221f, -0.04162382f, 
    -0.03522983f, -0.08041187f, -0.02240792f, -0.22574970f, -0.15328027f, -0.05064782f, -0.13925086f, -0.18172137f, 
    -0.04410580f, -0.01616852f, -0.03704345f, 0.02427764f, 0.04141485f, 0.02683139f, 0.01948263f, 0.01905227f, 
    0.00793916f, 0.00111643f, -0.04792187f, 0.00518666f, -0.00149346f, -0.01084130f, -0.00442089f, -0.01353940f, 
    -0.02775089f, 0.01793924f, 0.03579085f, -0.05692200f, 0.02983026f, 0.03137384f, 0.04173051f, -0.03332476f, 
    -0.05620234f, 0.00424943f, -0.03654780f, -0.03343996f, 0.03400552f, -0.00823233f, -0.05408473f, -0.01164393f, 
    0.03007231f, -0.03975392f, -0.01616965f, -0.00039716f, 0.01570063f, 0.01883569f, -0.03898743f, -0.02457303f, 
    0.03836148f, -0.02606041f, 0.04237580f, -0.02184970f, 0.03354683f, 0.02818738f, 0.01007157f, 0.01975098f, 
    -0.00592548f, 0.02439828f, -0.01069521f, 0.03252162f, -0.00099553f, -0.04820798f, 0.04423406f, -0.02026739f, 
    0.02597641f, -0.03868958f, -0.00997308f, -0.00226606f, 0.02943413f, -0.01040515f, 0.02046351f, -0.05795402f, 
    -0.00725521f, -0.00117708f, 0.03362026f, 0.02891099f, -0.02354510f, 0.00925929f, 0.03986918f, 0.01058912f, 
    -0.02358525f, -0.03524273f, -0.03617424f, -0.02688795f, -0.03531827f, -0.03070697f, 0.00715467f, 0.03998750f, 
    -0.03700864f, -0.03030767f, 0.00422117f, -0.00498785f, 0.00755183f, -0.00881657f, 0.03491465f, 0.01570614f, 
    0.04937671f, -0.04877184f, 0.01791919f, -0.01069492f, -0.02347583f, 0.00757616f, 0.02016584f, -0.03038304f, 
    -0.02073374f, -0.00075551f, 0.00742377f, 0.03945479f, 0.00367700f, 0.03379816f, 0.03846660f, 0.00036454f, 
    -0.04733308f, -0.00939230f, -0.03777722f, 0.03849622f, 0.02330668f, 0.03849621f, -0.05895146f, -0.01479571f, 
    -0.02034269f, 0.00410127f, -0.05308520f, 0.04403412f, 0.03296923f, -0.02750866f, -0.04216372f, -0.05706458f, 
    0.00698569f, 0.01546235f, -0.05041391f, -0.05600118f, 0.00030593f, 0.01167946f, -0.04660405f, -0.05962934f, 
    -0.02224643f, 0.03990274f, 0.03549919f, 0.03959239f, -0.00238471f, -0.04772334f, 0.02481419f, -0.03804605f, 
    -0.04928877f, -0.04876059f, -0.00031593f, 0.00354358f, -0.02244974f, -0.03535894f, 0.00856058f, 0.00335513f, 
    -0.01194208f, 0.01562991f, -0.01575469f, 0.01209400f, -0.02951002f, -0.04734031f, 0.03947911f, -0.03868254f, 
    -0.03543698f, 0.03333386f, -0.05258412f, 0.02716392f, 0.00594201f, 0.02906456f, 0.03350830f, -0.00712931f, 
    0.01324404f, 0.03664049f, -0.03828532f, -0.01188817f, -0.04297317f, -0.04408208f, 0.01006737f, 0.02687062f, 
    0.03487505f, -0.01104725f, 0.04083887f, -0.01311832f, 0.02288200f, -0.04330938f, 0.00234106f, -0.04822809f, 
    -0.03791988f, 0.02064692f, -0.01315226f, -0.03779620f, 0.00199437f, 0.01534986f, 0.01310258f, -0.01384897f, 
    -0.02187492f, -0.03074449f, 0.03555714f, 0.04552272f, -0.05183473f, 0.01883625f, -0.01426403f, -0.03122297f, 
    0.02774408f, 0.02996582f, -0.05905866f, 0.03785196f, 0.03678494f, -0.04758405f, 0.02967736f, -0.00516194f, 
    0.00273106f, 0.04046945f, -0.02836971f, -0.05829368f, -0.04471524f, -0.01935634f, 0.03711713f, -0.00798838f, 
    0.01053723f, -0.00551179f, 0.01558428f, 0.03167250f, -0.01777429f, -0.00246025f, -0.03225040f, -0.02377214f, 
    0.01909893f, -0.02191729f, 0.00563882f, -0.00543553f, -0.03954219f, -0.04458747f, -0.03193688f, -0.00332987f, 
    0.01420578f, -0.03681420f, -0.02730124f, -0.04370179f, 0.00122013f, -0.02810137f, 0.02840213f, -0.05693600f, 
    0.03807491f, -0.01411523f, 0.01716474f, 0.00789616f, -0.03474760f, 0.01328536f, -0.04770498f, -0.05302281f, 
    -0.04500329f, 0.01438900f, 0.02822918f, -0.03722734f, 0.01867357f, -0.04832335f, 0.01624383f, -0.01042820f, 
    -0.02510648f, -0.04923282f, -0.03604919f, -0.02876419f, 0.01469852f, -0.01047301f, -0.04575622f, 0.02796460f, 
    0.03402774f, 0.00576013f, -0.04261998f, 0.00403171f, -0.00604119f, -0.00785310f, -0.02180836f, 0.03418198f, 
    0.01782671f, -0.00534346f, -0.00423396f, 0.00085319f, -0.01257676f, -0.02375930f, -0.04904293f, -0.03000760f, 
    -0.02074173f, -0.04627173f, 0.04089722f, 0.01223414f, -0.01162059f, -0.04252030f, 0.01539708f, -0.00189055f, 
    -0.05809344f, -0.03489479f, -0.02542523f, 0.02536254f, 0.03325014f, -0.02861610f, 0.02753579f, 0.01809981f, 
    -0.00924245f, -0.00669475f, 0.02383211f, -0.00288213f, -0.00582742f, -0.00711985f, -0.00324683f, -0.04470927f, 
    -0.04068129f, 0.02380764f, -0.04571987f, 0.00261174f, 0.01011945f, -0.00934317f, 0.00339262f, -0.04624087f, 
    -0.05273339f, -0.05605480f, 0.00652689f, -0.03771059f, -0.01525719f, -0.05474047f, -0.01001758f, -0.05131121f, 
    0.01911583f, 0.01868901f, 0.01227951f, -0.03682477f, 0.02659496f, 0.03015218f, -0.01273650f, -0.01946010f, 
    0.03046079f, -0.02642699f, -0.04260918f, -0.05272285f, -0.02555132f, -0.04413996f, -0.03398829f, -0.05907809f, 
    -0.03427466f, -0.04216794f, 0.02769669f, 0.01903215f, -0.01151833f, -0.01735296f, 0.02860527f, -0.03386835f, 
    0.03964986f, -0.00385483f, -0.01709815f, 0.01813417f, -0.04066522f, -0.01226474f, 0.02699411f, -0.03212840f, 
    -0.00295263f, -0.01280421f, -0.05279719f, -0.05438089f, -0.04917233f, -0.02393001f, -0.00976275f, -0.03719288f, 
    0.03662554f, 0.02070654f, -0.03504554f, 0.00908039f, -0.04963170f, 0.04200768f, 0.01996517f, -0.04443438f, 
    0.00496891f, -0.03389915f, 0.02171917f, 0.01295129f, -0.04905105f, -0.02417941f, 0.01387529f, 0.00150444f, 
    -0.03625939f, -0.04355408f, 0.00513066f, -0.05132756f, -0.02878243f, 0.02883844f, -0.01304980f, 0.03620142f, 
    0.02449278f, -0.06154951f, 0.03397356f, -0.03874623f, 0.00002873f, -0.02020382f, -0.02297444f, 0.00488898f, 
    -0.18335414f, -0.11926723f, -0.13848130f, -0.02833571f, -0.10890339f, -0.16426054f, 0.13332328f, 0.08295832f, 
    -0.06848384f, -0.10733672f, -0.05134240f, -0.16188911f, 0.04518443f, -0.07982372f, 0.21843311f, -0.04458512f, 
    -0.08341857f, 0.15230866f, 0.00099652f, 0.09029607f, 0.14395563f, 0.25540587f, 0.21737346f, 0.11276396f, 
    0.04825699f, -0.00017677f, -0.17807069f, 0.18024525f, -0.09386204f, 0.12459852f, 0.09683822f, 0.06261133f, 
    0.02014044f, 0.07191563f, -0.01352636f, -0.06113858f, 0.06243535f, -0.25494567f, -0.01381012f, 0.00303441f, 
    0.14970025f, 0.01370056f, 0.02711846f, 0.00066645f, 0.09406322f, 0.05033062f, 0.03846509f, 0.09972237f, 
    0.34149036f, -0.00315579f, 0.52624255f, 0.31178880f, -0.10479212f, 0.04553112f, -0.14731582f, 0.14649764f, 
    -0.08030000f, -0.27526063f, -0.01840786f, -0.02092331f, 0.00631048f, 0.30123916f, 0.20341888f, 0.11003827f, 
    -0.08648431f, -0.00518053f, 0.07032169f, -0.05589462f, -0.10160722f, -0.05915530f, -0.09746152f, -0.00701125f, 
    -0.05317300f, -0.07506979f, -0.01887782f, 0.11995243f, 0.02101573f, -0.01023836f, 0.02212477f, 0.02314528f, 
    0.08496779f, 0.17000933f, 0.03721717f, 0.01600074f, -0.06965171f, 0.02366342f, -0.16878626f, -0.04195764f, 
    -0.01435329f, -0.12905292f, -0.10414898f, 0.05763895f, -0.07312157f, -0.05397842f, -0.18851061f, -0.21024601f, 
    0.35725555f, 0.23120777f, -0.09380852f, 0.02005227f, 0.14321841f, 0.26662332f, 0.10359431f, -0.04021420f, 
    0.19102703f, 0.08385851f, 0.12099911f, 0.23606858f, -0.02313214f, -0.06051279f, 0.08662578f, -0.06867617f, 
    0.09486285f, -0.18736650f, -0.12493454f, 0.21446876f, -0.10001759f, -0.13963762f, -0.06398775f, -0.25278470f, 
    -0.06377110f, -0.12815309f, 0.05078703f, -0.04891855f, 0.01422684f, 0.08231287f, 0.02353976f, 0.03535195f, 
    -0.15607604f, -0.17377445f, -0.13251098f, -0.23956554f, -0.12786373f, -0.23151001f, 0.05049705f, 0.05090942f, 
    0.12979528f, 0.05637955f, 0.05272213f, 0.14577629f, 0.01366573f, 0.15471794f, 0.00925783f, 0.03888480f, 
    -0.01562999f, -0.08782483f, -0.05263637f, 0.07231763f, 0.03639209f, 0.11163587f, 0.02256415f, -0.01570232f, 
    -0.25101247f, -0.26695007f, -0.25626528f, -0.22695552f, -0.11817236f, 0.02037949f, 0.04517258f, -0.06556498f, 
    0.11726238f, 0.00448142f, -0.18215999f, 0.04162800f, -0.32349098f, -0.18606958f, -0.32941988f, -0.37649164f, 
    0.08143555f, 0.06738739f, 0.15225689f, -0.03572512f, -0.03046303f, 0.15705094f, 0.21026587f, 0.10219068f, 
    0.24752288f, 0.07623346f, 0.11378929f, 0.32277143f, -0.06561424f, -0.04637258f, 0.00282367f, 0.00037077f, 
    0.11859854f, 0.03974383f, 0.03430871f, 0.02851191f, -0.18574516f, -0.06993717f, -0.04446274f, -0.09849285f, 
    0.15489717f, -0.05563919f, -0.05636121f, 0.11672816f, 0.05176838f, 0.05199748f, 0.00633453f, 0.03179635f, 
    0.20471627f, 0.25844672f, 0.04718912f, 0.13734446f, 0.11718103f, 0.14197055f, -0.30169117f, -0.05266906f, 
    0.01288308f, 0.33132261f, 0.00706615f, -0.10463165f, 0.09330448f, -0.00713006f, 0.07548504f, 0.01730519f, 
    -0.06892043f, -0.17950068f, 0.15186018f, 0.11511575f, 0.09790880f, 0.13065168f, 0.00296402f, 0.09358779f, 
    -0.00843768f, -0.17617112f, -0.20454028f, -0.13949972f, 0.07966120f, 0.01592294f, -0.07067037f, 0.19704248f, 
    0.14009732f, -0.17074902f, 0.03774226f, -0.22326592f, -0.24378417f, -0.14782104f, -0.13734262f, -0.07123958f, 
    0.05940071f, 0.04296040f, 0.02214561f, 0.03239432f, 0.05103833f, 0.01879188f, 0.03436415f, 0.03530490f, 
    0.32428974f, 0.30676016f, 0.23997913f, 0.38021502f, -0.04188943f, -0.04518946f, 0.03514606f, 0.11907052f, 
    0.10186333f, 0.20497577f, 0.15597034f, -0.05300582f, 0.16157596f, -0.03827159f, -0.08310081f, 0.24016689f, 
    0.02486522f, -0.01888628f, 0.23744673f, 0.11497743f, 0.05053054f, -0.03140955f, 0.07213511f, -0.03731931f, 
    -0.07120516f, -0.21632281f, -0.14611764f, -0.25280842f, 0.24121699f, 0.23075400f, -0.09597240f, 0.28576839f, 
    -0.17967099f, 0.07306962f, 0.15807408f, -0.02175511f, 0.09158928f, 0.18096340f, 0.21521659f, 0.32258990f, 
    -0.01382943f, -0.12291221f, 0.02490079f, 0.31606692f, 0.01668383f, 0.04935210f, 0.11056916f, 0.12620440f, 
    0.11982770f, 0.10368107f, 0.22958896f, 0.14558715f, -0.10767683f, -0.04185742f, 0.12948745f, 0.04811274f, 
    0.04188643f, -0.07818284f, 0.01124057f, -0.08707649f, -0.13219535f, 0.03952891f, -0.09152260f, -0.15759246f, 
    -0.12752759f, 0.24942353f, 0.12900056f, -0.04318210f, -0.04609831f, -0.06967099f, 0.01943981f, -0.23764627f, 
    0.01120979f, -0.03015838f, 0.14548838f, 0.12729608f, 0.12867168f, 0.56906545f, 0.10356177f, 0.16670547f, 
    -0.07946560f, -0.10596710f, 0.01573195f, -0.01062097f, 0.13080625f, 0.04624711f, 0.06072469f, 0.06172330f, 
    0.37082833f, 0.07782073f, 0.02319600f, 0.06813036f, 0.12163518f, -0.07289489f, 0.00469600f, 0.08407211f, 
    -0.01223531f, 0.18861772f, 0.08279163f, -0.24633087f, 0.20308036f, -0.25871035f, 0.03976401f, 0.00533937f, 
    -0.08104351f, -0.07121187f, -0.13758050f, -0.01724916f, -0.05627184f, 0.00374134f, 0.01390660f, -0.02756941f, 
    -0.22846819f, -0.10153289f, -0.02611499f, -0.07550337f, -0.06464677f, 0.11484972f, 0.05975382f, 0.11683496f, 
    0.00998772f, -0.01195569f, -0.04011797f, 0.01984561f, 0.04479200f, -0.15720543f, -0.05341579f, -0.06440169f, 
    -0.08973727f, 0.03659960f, 0.08896647f, -0.09424606f, -0.14227378f, -0.22902291f, -0.32012531f, -0.16269991f, 
    0.37621439f, 0.31259078f, 0.25599825f, 0.14175645f, 0.02046127f, -0.08205115f, -0.04739316f, -0.02768032f, 
    0.05099383f, -0.09235426f, 0.01595691f, 0.06121738f, -0.58051473f, -0.20263399f, 0.06144820f, -0.28220704f, 
    -0.05507689f, 0.02989776f, -0.16519025f, 0.08259957f, 0.04900910f, 0.01423487f, 0.11955111f, -0.06541079f, 
    -0.21925929f, -0.00064567f, -0.00230803f, -0.40652782f, -0.03514323f, -0.14813383f, -0.11388452f, 0.06833135f, 
    0.05225869f, 0.03541902f, 0.01558612f, 0.01368925f, 0.25742161f, 0.41830301f, 0.23944877f, 0.27963129f, 
    0.11577600f, 0.04585743f, -0.03928841f, -0.06250398f, 0.01950973f, -0.02618076f, -0.05452598f, 0.02915440f, 
    0.36301598f, 0.33646134f, 0.07796418f, -0.10085513f, 0.24535124f, 0.38208026f, 0.25346598f, 0.06808431f, 
    -0.03271612f, 0.05620195f, 0.08194476f, 0.09568080f, 0.28525639f, -0.28792804f, -0.06516168f, -0.00028704f, 
    0.13636880f, 0.03743201f, 0.01894983f, -0.02225025f, -0.01114302f, 0.05151304f, 0.15113878f, -0.01030649f, 
    0.19762006f, 0.13007891f, 0.07071344f, 0.11806469f, 0.00197423f, -0.03117621f, 0.01047840f, 0.04721108f, 
    -0.04505794f, 0.06701040f, -0.05096575f, -0.01610561f, 0.13365357f, 0.13325273f, 0.01088371f, -0.00605719f, 
    -0.01018477f, 0.06317626f, 0.03785720f, -0.23688310f, 0.08770335f, -0.00055865f, -0.04225783f, 0.04228077f, 
    -0.11412244f, -0.10904768f, 0.00873327f, -0.04672377f, 0.00650642f, 0.11955042f, -0.19452037f, 0.01571441f, 
    -0.02908176f, -0.00719269f, 0.00093829f, 0.09857536f, 0.15103100f, 0.15814281f, 0.15031023f, 0.03053539f, 
    -0.11745477f, -0.04002422f, -0.12860300f, -0.02278487f, -0.00853201f, -0.02204917f, -0.12634176f, -0.00573011f, 
    -0.51359570f, -0.43097684f, -0.35074052f, -0.23058239f, 0.01241462f, -0.05234910f, -0.01161369f, -0.04968256f, 
    0.07274026f, 0.03833101f, 0.08423893f, 0.04243236f, 0.39679670f, 0.00898142f, 0.30914503f, 0.04124000f, 
    0.10651416f, -0.02206486f, 0.21642955f, -0.16077334f, -0.01562004f, -0.01024021f, -0.06439023f, 0.08386663f, 
    -0.00339234f, -0.10327026f, -0.06295791f, 0.08960634f, -0.06871355f, -0.08299699f, -0.17147443f, -0.13602088f, 
    0.01621593f, -0.01664125f, -0.01685620f, -0.04063173f, 0.00659940f, 0.02971495f, 0.02229271f, -0.05331990f, 
    -0.13763700f, -0.19080718f, -0.07470369f, -0.02773216f, 0.11387675f, 0.01528501f, -0.02009976f, -0.04846993f, 
    -0.18903337f, -0.07833257f, -0.08307032f, -0.03228784f, 0.00432837f, -0.03543283f, 0.02497093f, 0.02757112f, 
    -0.17122021f, -0.11142711f, 0.10692006f, 0.03702597f, 0.21479279f, 0.17818606f, -0.08332752f, 0.07449982f, 
    0.11144686f, -0.19819635f, 0.00741024f, -0.01521675f, -0.01173998f, 0.01750349f, -0.07921764f, 0.03690067f, 
    0.06361481f, 0.09831974f, 0.03475286f, 0.03360276f, -0.03732340f, 0.12591994f, 0.01267695f, 0.17226617f, 
    -0.07466158f, -0.03232368f, -0.02042122f, -0.08334320f, -0.04073456f, 0.08420487f, -0.07170594f, -0.00483972f, 
    0.00198385f, -0.01239349f, -0.07097054f, -0.13027053f, 0.00438288f, -0.09264512f, -0.03020506f, -0.07878895f, 
    -0.04477336f, -0.04157443f, -0.27330613f, -0.10691562f, 0.04176774f, 0.10499592f, 0.12177774f, 0.06255946f, 
    0.09170248f, 0.05097216f, 0.00475919f, 0.08492362f, -0.18589650f, -0.19792205f, -0.33783787f, 0.05229837f, 
    0.08417130f, -0.11476777f, 0.01900568f, -0.03127961f, -0.07863249f, 0.01593304f, -0.05074733f, 0.11702811f, 
    -0.17463417f, -0.10359286f, -0.18093310f, -0.00688804f, -0.02138121f, 0.01015193f, -0.02951093f, 0.01547653f, 
    -0.23858015f, -0.01560381f, -0.07348578f, 0.01382977f, 0.05480321f, -0.16672386f, -0.19573897f, -0.08228697f, 
    -0.10582584f, 0.05623230f, 0.13958855f, 0.03920838f, 0.00063380f, -0.00404422f, -0.00941843f, 0.02469451f, 
    -0.03068642f, 0.03976744f, -0.22354579f, -0.22706445f, -0.01380776f, 0.08171406f, -0.04933046f, -0.00557992f, 
    0.04478902f, 0.06850401f, 0.00936907f, -0.02203848f, 0.11594118f, 0.03173552f, 0.03396792f, 0.09699513f, 
    0.05658196f, 0.14285657f, -0.00112471f, -0.01854080f, -0.08574603f, 0.05215318f, -0.01051731f, 0.02926682f, 
    0.36591640f, 0.10449102f, -0.06951346f, 0.04522556f, 0.04452471f, 0.03257908f, 0.10036838f, -0.07294495f, 
    -0.00962274f, -0.10736781f, 0.04599139f, 0.06272309f, 0.21080375f, 0.25365818f, 0.08725536f, 0.09480658f, 
    0.07358459f, -0.00250155f, 0.00648849f, 0.01024539f, -0.00331249f, 0.00573230f, -0.00886471f, 0.02373775f, 
    0.11272521f, -0.22082247f, -0.53345025f, -0.06739680f, -0.05065065f, -0.00244978f, 0.08857039f, -0.14886190f, 
    -0.19373474f, 0.11922626f, 0.04237385f, 0.02227130f, 0.04430505f, -0.04092894f, -0.15578838f, 0.10722359f, 
    0.02367651f, 0.07573653f, -0.11405966f, 0.04118518f, -0.09496820f, 0.06828084f, -0.02697895f, -0.00576132f, 
    -0.23283690f, -0.15398726f, -0.03584778f, -0.25523046f, -0.03568279f, 0.01000822f, 0.03875158f, 0.19731410f, 
    0.07695816f, 0.08094218f, 0.02099304f, -0.12064067f, 0.08289719f, -0.34252650f, -0.01753327f, -0.00916048f, 
    0.06376249f, -0.04219831f, -0.05002858f, -0.04078702f, 0.11068659f, -0.01688356f, 0.06819577f, -0.05143325f, 
    0.23367363f, 0.18512326f, 0.12690215f, 0.09600598f, -0.03904158f, 0.02967134f, -0.03645450f, 0.08285800f, 
    -0.05476532f, 0.02463784f, -0.02232117f, 0.09555097f, -0.13555193f, -0.12854771f, -0.04344260f, 0.02241243f, 
    0.05151243f, -0.00485267f, -0.03794358f, -0.04661357f, 0.03123046f, 0.18383148f, -0.12893982f, -0.01461643f, 
    0.17957795f, 0.25297955f, 0.10107794f, -0.08408385f, 0.03652064f, 0.00107171f, 0.02113955f, 0.10804037f, 
    -0.06644622f, -0.14342043f, -0.04105232f, -0.03467068f, 0.01377899f, 0.26510406f, -0.17350286f, 0.32729045f, 
    -0.03340130f, 0.00741884f, -0.02318716f, -0.03962575f, 0.12385795f, 0.04833069f, 0.12263062f, 0.11830636f, 
    -0.05531478f, 0.10974751f, -0.00476475f, 0.10657994f, 0.25904402f, 0.06444074f, -0.00769130f, 0.02418882f, 
    -0.05231265f, -0.00614398f, 0.13413711f, 0.04832707f, -0.00633578f, 0.27536267f, 0.15028173f, 0.07149412f, 
    -0.13025163f, -0.00839906f, -0.21540910f, -0.02500794f, 0.01381329f, -0.00385934f, 0.03665437f, 0.03081840f, 
    -0.39946535f, 0.17660025f, -0.18320511f, -0.15774485f, -0.04685214f, 0.03674231f, -0.01294356f, -0.10860597f, 
    -0.05041481f, -0.13014996f, -0.13389698f, -0.05303842f, 0.37927046f, -0.13677700f, 0.03952489f, -0.26463726f, 
    0.01888471f, -0.10507326f, -0.14446236f, 0.12252942f, 0.06556912f, 0.01252299f, 0.11003816f, -0.07814279f, 
    0.18321852f, 0.03084392f, 0.18736690f, -0.08002813f, -0.02941605f, -0.01752977f, -0.02094479f, 0.08027196f, 
    0.15663597f, 0.01785467f, -0.03317881f, 0.08759574f, -0.03697237f, -0.16717751f, 0.06770439f, 0.01993871f, 
    0.10055672f, 0.00751927f, -0.01570988f, -0.04646952f, -0.07187803f, -0.06169271f, -0.08258329f, -0.06275790f, 
    -0.29287878f, -0.01669748f, 0.00794231f, -0.37294033f, 0.03339691f, 0.12762479f, -0.04340064f, 0.05556054f, 
    0.06659897f, -0.04459238f, -0.01910055f, 0.08772144f, -0.03133502f, -0.19371577f, 0.05399395f, -0.04988324f, 
    -0.02407985f, 0.06681886f, 0.11201384f, -0.12158466f, -0.00690394f, -0.02498816f, -0.08426666f, -0.02336097f, 
    0.20307533f, 0.26287222f, 0.10652734f, 0.31634375f, 0.01822760f, -0.05728313f, -0.01503658f, 0.00854945f, 
    0.01083133f, -0.06624304f, -0.05808250f, 0.05763183f, 0.25540480f, -0.25603455f, 0.35621426f, -0.17701788f, 
    0.05018352f, 0.04773819f, 0.10039687f, 0.03594834f, 0.05943634f, -0.00927067f, 0.01966668f, -0.02449165f, 
    -0.01166947f, -0.00037116f, -0.09244514f, -0.03197739f, 0.09219214f, 0.10645168f, -0.08423513f, -0.05092392f, 
    0.03790891f, -0.08474351f, -0.02537178f, -0.08188041f, -0.14624114f, -0.05402432f, -0.05175988f, -0.02387947f, 
    -0.05561720f, 0.09831522f, -0.10102855f, -0.08657797f, -0.01721782f, -0.03033319f, -0.15869749f, -0.06384013f, 
    -0.05488280f, 0.03801904f, -0.01344076f, 0.10657898f, -0.08245236f, -0.01354407f, 0.12481961f, 0.12655221f, 
    0.07249269f, 0.10987495f, 0.10631837f, 0.12265794f, -0.02165842f, -0.26300997f, -0.23054442f, -0.33946669f, 
    0.15533075f, 0.02537229f, 0.12798037f, 0.10522638f, 0.04846283f, 0.01750089f, -0.13825172f, -0.05298607f, 
    -0.10902575f, 0.14403228f, 0.00683193f, -0.05262000f, -0.06031532f, 0.07676086f, -0.05822796f, 0.13857628f, 
    -0.11843306f, 0.13012922f, -0.01755860f, -0.00336460f, -0.16978432f, 0.13102145f, -0.02975860f, 0.00355806f, 
    0.03697874f, 0.00295603f, -0.05683255f, 0.07492587f, -0.01402559f, -0.08516351f, 0.06367207f, -0.13085432f, 
    0.16652513f, 0.14839737f, -0.06930700f, 0.03133366f, 0.04873683f, 0.01660822f, -0.00959561f, 0.07685388f, 
    0.03018350f, 0.00396794f, -0.08954120f, 0.01577668f, 0.14924796f, 0.02745836f, 0.06302603f, -0.02358565f, 
    0.06901395f, 0.04295382f, -0.02574267f, 0.05156463f, -0.00519645f, -0.08242244f, -0.06691635f, -0.05997987f, 
    -0.04240318f, -0.03841749f, 0.07716449f, 0.13615578f, -0.14524291f, 0.02068029f, -0.05906944f, 0.06995016f, 
    -0.03427542f, -0.06459732f, 0.03836433f, 0.06540254f, 0.31814918f, 0.23265930f, -0.15885112f, -0.08284900f, 
    0.13562167f, 0.05495783f, 0.10954959f, 0.04569096f, -0.02907981f, -0.10353324f, 0.05144834f, 0.03491584f, 
    0.19676168f, 0.10952052f, -0.21165471f, -0.15601020f, 0.18802889f, 0.03203555f, 0.14968280f, 0.04416426f, 
    -0.13528292f, 0.04841361f, -0.07017427f, -0.01158016f, -0.22159806f, -0.01450357f, 0.03093277f, -0.00648987f, 
    -0.00132335f, -0.00630413f, -0.03325591f, -0.06731149f, 0.00636657f, 0.08000899f, 0.09746942f, -0.01433477f, 
    0.17303169f, -0.03153820f, 0.06470998f, -0.01441182f, -0.03835377f, 0.04655882f, -0.02929299f, 0.00276049f, 
    0.04997151f, 0.06031601f, -0.01794236f, 0.00410721f, 0.08896053f, -0.02272696f, -0.03656140f, -0.05270649f, 
    0.03077547f, 0.06161693f, -0.02577600f, 0.15842156f, -0.08837371f, -0.00030368f, -0.08637143f, -0.03060997f, 
    0.67451876f, -0.18354133f, 0.11552047f, 0.19628736f, -0.08467943f, -0.03061900f, 0.02327511f, 0.08305757f, 
    0.14137813f, 0.12402371f, 0.01951135f, 0.02421819f, 0.02846720f, -0.15987800f, -0.00802829f, -0.58758926f, 
    -0.04330686f, -0.06525557f, 0.07370632f, -0.05602150f, 0.10909626f, 0.11234520f, -0.16905698f, -0.00795215f, 
    -0.79590261f, 0.22668226f, 0.09445897f, 0.08842130f, 0.04660562f, 0.00230983f, -0.00301785f, 0.02138132f, 
    0.03838912f, 0.07109255f, 0.01402000f, -0.05101679f, 0.23935002f, 0.17567195f, 0.07683363f, 0.08294326f, 
    -0.10658295f, -0.02363111f, -0.02602191f, -0.08399978f, -0.01544408f, -0.00625706f, 0.05830449f, -0.10025866f, 
    0.22009586f, 0.21363588f, 0.03230416f, -0.10092463f, 0.05423433f, -0.10504018f, 0.05901667f, 0.07568827f, 
    -0.02571947f, 0.01755113f, 0.18148287f, 0.11940815f, 0.03104789f, 0.09134068f, -0.01091851f, 0.09576406f, 
    0.06620733f, 0.02243526f, -0.04738708f, 0.04140268f, 0.05036427f, 0.00175763f, -0.14523362f, -0.03192144f, 
    0.01446253f, 0.05593184f, 0.28475246f, 0.00339514f, -0.03292600f, -0.05534473f, 0.01412958f, 0.09512253f, 
    -0.01909751f, 0.05646646f, 0.00718155f, -0.03713074f, 0.28484190f, 0.12934503f, -0.25045666f, 0.19086234f, 
    0.06254697f, -0.07703264f, 0.07273700f, 0.03034692f, -0.03883137f, -0.04019387f, 0.04071010f, 0.00960140f, 
    0.25101230f, -0.24059285f, -0.14746290f, 0.34931096f, 0.08326894f, -0.04906597f, 0.05413402f, -0.00138884f, 
    -0.03281628f, 0.01963812f, 0.20392573f, 0.00776993f, -0.27672791f, -0.11610916f, -0.09059074f, 0.04853671f, 
    -0.06793613f, -0.09468867f, -0.02479393f, 0.12386670f, -0.01465080f, -0.04021204f, -0.09367375f, 0.05256642f, 
    -0.37159073f, -0.22271450f, -0.39867997f, -0.16390796f, -0.16640683f, -0.23306477f, 0.15208952f, -0.03005370f, 
    0.15095294f, -0.11760054f, -0.03463746f, -0.00846072f, -0.06957599f, -0.00118030f, 0.08246238f, -0.26218775f, 
    -0.15358347f, -0.04027666f, 0.10453811f, 0.19010058f, -0.11496540f, 0.12218630f, -0.04335906f, 0.07084313f, 
    0.08492141f, -0.14683470f, 0.33628196f, -0.00415509f, 0.04527108f, -0.03497688f, 0.05553731f, -0.00016611f, 
    0.10371295f, 0.00389757f, 0.23462369f, 0.04377255f, 0.14448324f, -0.08633284f, -0.02656395f, -0.02451309f, 
    0.14066684f, -0.03276818f, -0.09844807f, 0.20924653f, 0.16408285f, 0.08342736f, 0.01691843f, 0.01149770f, 
    -0.24095379f, 0.12844901f, 0.05427635f, -0.19300024f, -0.07512873f, -0.04771654f, 0.13068707f, 0.15756930f, 
    -0.00401461f, -0.03981659f, 0.13679001f, -0.03481841f, -0.01651932f, -0.28250021f, 0.12652729f, -0.15968724f, 
    0.03216937f, 0.12446593f, 0.18337573f, -0.04618287f, -0.04475008f, -0.02892578f, -0.00450639f, -0.00293656f, 
    0.34318575f, 0.20355031f, 0.17943510f, 0.07105684f, 0.08292961f, -0.04503947f, -0.10388546f, 0.00322338f, 
    0.04139525f, 0.04481198f, -0.01038370f, -0.01234991f, -0.23715495f, -0.06067336f, 0.25559455f, -0.06551848f, 
    -0.06752539f, 0.06341093f, -0.09735781f, 0.17882985f, 0.00174732f, 0.05528467f, -0.00648197f, 0.04174230f, 
    -0.17124031f, 0.12300157f, 0.00214512f, 0.03203354f, 0.13794196f, 0.13209575f, 0.05519159f, 0.09247158f, 
    0.01311164f, -0.02105238f, 0.09686445f, 0.01391674f, -0.04774754f, -0.08805228f, -0.06896396f, -0.04695412f, 
    0.24735138f, 0.07262465f, 0.09056356f, -0.12181010f, 0.12867074f, -0.02392676f, -0.09458838f, 0.00026270f, 
    0.04729726f, 0.19475074f, 0.04952235f, 0.03376228f, -0.07075810f, 0.07465249f, 0.00473005f, 0.11355593f, 
    -0.08107603f, 0.20044042f, 0.16087261f, -0.07131788f, -0.22728388f, -0.29003495f, 0.16016573f, -0.00327680f, 
    0.08842588f, 0.03492453f, 0.07824296f, 0.13285305f, -0.03044911f, -0.01000955f, -0.05212153f, -0.03745101f, 
    -0.31166658f, 0.11830691f, -0.00651666f, 0.07320721f, -0.14029613f, -0.09554631f, 0.18063661f, -0.06359861f, 
    -0.04340937f, -0.02509890f, 0.15171322f, -0.17499860f, -0.07132249f, 0.06276591f, -0.07042486f, -0.05226896f, 
    -0.01204198f, -0.04291653f, 0.05905233f, 0.01673038f, 0.04108733f, -0.05216331f, -0.00488728f, -0.01280126f, 
    0.10360415f, 0.09642011f, 0.12097240f, 0.01987826f, 0.17386667f, 0.15163378f, 0.06413860f, 0.01317564f, 
    0.04388245f, 0.02670728f, -0.02006447f, -0.03381385f, 0.28585419f, -0.06549471f, 0.19743726f, -0.07086080f, 
    0.09385712f, 0.12896401f, -0.05038287f, 0.05145988f, 0.03828579f, 0.05789765f, -0.03997165f, -0.13951235f, 
    0.19513346f, 0.09261238f, -0.01584640f, 0.03665236f, -0.06156658f, -0.03988368f, 0.02496725f, -0.10188373f, 
    0.15194604f, 0.03858822f, 0.08235607f, -0.01207534f, 0.19119352f, 0.20294175f, 0.05136991f, 0.10744614f, 
    0.23787652f, 0.03510715f, 0.00521313f, 0.10575430f, 0.08199286f, 0.06686635f, 0.05079570f, -0.02821333f, 
    0.14859259f, 0.15521504f, 0.03057446f, -0.08744303f, 0.10854817f, 0.24544799f, -0.01529137f, 0.29587570f, 
    0.12479334f, -0.00826139f, 0.01336914f, -0.00902447f, -0.11110925f, -0.12483904f, 0.01741151f, -0.05915972f, 
    -0.01264809f, -0.16630751f, 0.02555951f, 0.07709585f, 0.22485995f, 0.11052442f, 0.05915772f, -0.05632790f, 
    -0.12382516f, -0.09214328f, 0.05096006f, -0.05202544f, -0.02218821f, 0.04292746f, -0.12076113f, -0.04473313f, 
    -0.00380372f, 0.02263588f, 0.04490880f, 0.07261670f, -0.07895646f, -0.02880252f, 0.09294263f, 0.02979911f, 
    -0.07453460f, 0.19161771f, -0.06004115f, 0.05287211f, -0.02186666f, 0.03609297f, 0.05437034f, 0.05765160f, 
    -0.05126148f, -0.03412068f, 0.26839459f, 0.15879147f, 0.03705370f, 0.07230718f, -0.07018951f, 0.06618372f, 
    0.14084180f, 0.02650906f, -0.01078980f, 0.17175718f, -0.32266974f, 0.07362390f, 0.19366403f, -0.23741777f, 
    -0.06547810f, 0.03442706f, 0.26971188f, 0.07331061f, -0.06204103f, -0.04812441f, 0.07091510f, 0.07058088f, 
    -0.09555520f, -0.01722101f, 0.00016484f, -0.01169420f, 0.11405663f, -0.01973066f, 0.02336801f, 0.05446754f, 
    0.13200961f, -0.08094067f, 0.11329680f, 0.04312976f, 0.09734103f, 0.18427347f, 0.02811574f, 0.04523027f, 
    0.12032475f, 0.02346312f, 0.00773430f, -0.07692494f, -0.09039781f, 0.14661473f, -0.01263027f, 0.18904682f, 
    0.00513989f, 0.06885356f, 0.15551741f, 0.10498899f, 0.00985695f, -0.14185223f, -0.01476228f, 0.07999531f, 
    0.03986286f, 0.06495735f, 0.17308185f, 0.08086643f, 0.12874331f, 0.10613599f, -0.04741486f, -0.10655078f, 
    0.12116908f, 0.04410311f, 0.06237815f, -0.01605530f, 0.33940896f, 0.18477750f, 0.17158915f, 0.12748456f, 
    -0.23076443f, -0.27678475f, -0.19573373f, 0.08577939f, 0.13266325f, 0.17052035f, 0.09571446f, 0.01678205f, 
    -0.05236550f, 0.04820548f, 0.02482757f, -0.00514161f, 0.13829793f, 0.01641561f, 0.24572085f, 0.00516235f, 
    -0.03465315f, 0.08402529f, -0.02574860f, -0.09928688f, -0.03281944f, 0.10098191f, 0.00889297f, -0.02634538f, 
    0.25716814f, -0.00072405f, -0.00131698f, -0.01960891f, -0.01270441f, 0.03872759f, -0.12354796f, 0.00650820f, 
    -0.06740984f, 0.03228895f, -0.02713553f, -0.00637869f, -0.06074619f, -0.17915654f, -0.07764775f, -0.03940818f, 
    0.08427804f, 0.08421138f, 0.14397380f, 0.00747633f, -0.05834885f, -0.04881347f, 0.01268123f, -0.06463167f, 
    0.36280158f, -0.24053925f, -0.05975708f, 0.04009839f, 0.06857503f, 0.06921311f, -0.07929002f, 0.27464172f, 
    -0.02427750f, 0.08412079f, 0.11011588f, 0.02156979f, -0.03461390f, 0.10357035f, 0.13769475f, 0.15934579f, 
    -0.03196520f, 0.06292251f, 0.23157951f, 0.00228238f, 0.28643927f, 0.11798241f, 0.16835438f, 0.12430819f, 
    -0.21526714f, -0.06890119f, -0.15352331f, 0.02101733f, 0.13827178f, -0.02874912f, 0.15712367f, 0.06342907f, 
    0.01867078f, -0.10838315f, 0.09880517f, -0.00631268f, 0.04703579f, 0.03519156f, -0.17128041f, -0.11117276f, 
    0.07638106f, -0.00960155f, -0.01096109f, 0.15360296f, -0.06563865f, 0.05312712f, 0.13635892f, 0.06307466f, 
    0.14679028f, -0.00482813f, -0.32494500f, 0.27287209f, -0.04977131f, 0.08215573f, 0.24511066f, 0.15668304f, 
    0.11042725f, 0.15117222f, 0.02154010f, 0.11377069f, -0.08757395f, -0.07625269f, -0.17492807f, -0.12645109f, 
    0.01844176f, -0.03203269f, 0.03320221f, 0.12761533f, -0.01727626f, 0.05074827f, 0.04507763f, 0.04572381f, 
    -0.06214693f, 0.04092837f, 0.04727178f, -0.00829481f, -0.08302284f, -0.10468071f, -0.02481996f, -0.11148068f, 
    0.00026078f, 0.05526583f, 0.06422608f, -0.05208059f, -0.08940375f, 0.21912131f, -0.29247400f, 0.19099870f, 
    0.05267800f, 0.03876704f, 0.02778130f, 0.03968490f, 0.03010844f, -0.00836553f, -0.02538159f, 0.11310806f, 
    -0.04147279f, 0.00349717f, 0.01065806f, 0.06189116f, -0.08326779f, -0.04152945f, 0.09100918f, 0.02427779f, 
    -0.02434942f, 0.07014675f, 0.09901602f, 0.06944007f, -0.01105163f, -0.02777742f, -0.11088234f, -0.07555959f, 
    0.10688429f, -0.01322427f, -0.07857304f, 0.03560260f, -0.03345212f, 0.02916633f, 0.04647385f, 0.01609196f, 
    0.02373699f, 0.15143327f, 0.19478187f, 0.00864086f, -0.01016244f, 0.00806446f, -0.05811643f, -0.08744335f, 
    0.05071073f, 0.13419749f, -0.05442396f, -0.03432519f, -0.11188579f, 0.14054802f, 0.18185484f, 0.15874383f, 
    0.03967068f, 0.01187416f, 0.05295741f, -0.01350119f, 0.00861450f, -0.07495886f, 0.04664714f, -0.03178739f, 
    -0.03363244f, -0.25710189f, 0.01589281f, 0.05836900f, 0.13361646f, 0.03542404f, 0.11413231f, 0.13340524f, 
    0.07447144f, -0.00564740f, 0.14716321f, 0.07452040f, 0.02567944f, -0.11269618f, -0.17516924f, -0.07145415f, 
    0.12964913f, 0.04174533f, 0.12896179f, 0.12259465f, -0.06833250f, 0.06034376f, -0.03244901f, 0.00045976f, 
    -0.12196513f, -0.14573659f, 0.00629983f, 0.02813914f, 0.04468330f, -0.00665013f, 0.13649206f, 0.06902936f, 
    0.08763453f, -0.06027124f, 0.00093149f, 0.07077707f, -0.02124968f, 0.15817374f, 0.01813273f, 0.00501300f, 
    -0.02339030f, -0.10515680f, 0.11562081f, -0.06597446f, 0.08436869f, 0.02409779f, 0.02056913f, 0.23176813f, 
    0.08633846f, 0.20231900f, 0.17057197f, -0.01270653f, -0.04905919f, -0.00526809f, -0.01481841f, -0.02262225f, 
    0.00311807f, 0.04288834f, -0.10051263f, -0.13767964f, -0.17281884f, -0.21413982f, 0.05556948f, 0.22089888f, 
    0.02970911f, 0.15124094f, 0.04152333f, 0.04334495f, 0.07732005f, 0.02380126f, 0.00327271f, 0.00667682f, 
    -0.29130834f, -0.05510799f, 0.01455468f, 0.14310355f, -0.04185834f, -0.16154091f, 0.13844131f, -0.12424510f, 
    0.10942262f, -0.07946724f, 0.06715940f, 0.04146773f, 0.23724863f, -0.05115444f, -0.05479185f, 0.04652477f, 
    -0.01690907f, -0.02036124f, -0.07408532f, 0.06656797f, -0.03656648f, -0.05292949f, -0.10645513f, -0.00387667f, 
    -0.08294284f, -0.07976897f, 0.01543014f, 0.07998879f, 0.06258038f, 0.00724646f, 0.08458658f, 0.06656377f, 
    0.05947277f, 0.02773515f, 0.02705305f, 0.02917578f, -0.03871751f, 0.15057082f, 0.04302062f, 0.15812233f, 
    0.06959371f, 0.04137890f, 0.27648759f, -0.00997817f, 0.09289399f, 0.12714589f, 0.04767475f, 0.27712896f, 
    -0.13818748f, 0.41556755f, 0.06006832f, -0.05810939f, 0.12077525f, -0.07291699f, -0.01242481f, -0.14356349f, 
    -0.06505430f, 0.05505507f, 0.04394818f, -0.03667932f, 0.13510604f, 0.37873903f, -0.08227271f, 0.30258825f, 
    -0.07289629f, 0.02960127f, 0.12032579f, 0.00369854f, 0.03532698f, 0.08580179f, 0.16780612f, 0.16061881f, 
    0.63732678f, -0.01470242f, -0.20276035f, 0.12085449f, 0.09495552f, -0.02637557f, -0.03086555f, -0.04993547f, 
    -0.20816377f, 0.05125506f, -0.01858477f, 0.12107329f, 0.14252055f, -0.10496046f, 0.17634465f, -0.15187363f, 
    -0.08109724f, 0.08001983f, -0.08367428f, 0.04534842f, 0.13809793f, 0.05247474f, 0.06887209f, 0.07567599f, 
    -0.07158525f, -0.18169655f, -0.05956029f, 0.10959785f, 0.02938670f, 0.11221317f, 0.04654627f, 0.03481952f, 
    0.03296810f, 0.03879412f, -0.01559244f, -0.04361816f, 0.06527678f, -0.04623750f, 0.06548207f, -0.07752459f, 
    -0.01154500f, 0.04193247f, -0.10836309f, -0.05043096f, -0.14484607f, -0.07054251f, 0.13788626f, 0.04910257f, 
    -0.15509079f, 0.07948317f, -0.02332411f, -0.04429545f, 0.13403687f, 0.22941782f, 0.14325233f, 0.12358794f, 
    -0.05565871f, -0.05535934f, -0.00183344f, -0.00286207f, -0.17819086f, 0.18494450f, 0.18359715f, 0.07556461f, 
    0.08531483f, -0.09635934f, -0.00937886f, 0.04439261f, 0.03495097f, -0.00525665f, -0.13642590f, 0.06991461f, 
    -0.25415033f, 0.13517216f, -0.00109876f, 0.08289739f, -0.09594723f, -0.03258053f, -0.06959661f, 0.09314280f, 
    -0.00577358f, -0.00202906f, -0.09479377f, 0.05579116f, -0.01952363f, 0.11190896f, 0.12896542f, -0.07803923f, 
    -0.01705784f, -0.10271398f, -0.18149662f, -0.04335289f, -0.00942325f, -0.03820288f, -0.00746653f, 0.09572551f, 
    0.36618772f, 0.16449589f, 0.18699969f, 0.03809128f, 0.06113051f, 0.13711368f, -0.20179304f, 0.18847904f, 
    0.04139673f, -0.07536689f, 0.01342233f, 0.02057759f, 0.29624948f, 0.04334376f, 0.14377598f, -0.40077898f, 
    -0.01126876f, 0.01167261f, -0.08146343f, 0.04353120f, 0.14415969f, -0.04528210f, 0.01619827f, -0.06547260f, 
    -0.14420514f, -0.13732815f, 0.05125061f, 0.02216513f, -0.01508700f, 0.07558337f, 0.03443170f, -0.01184143f, 
    0.14722216f, 0.03955255f, 0.04540956f, 0.09329456f, 0.09593888f, 0.09413277f, -0.06586476f, -0.07991744f, 
    0.28416961f, 0.01077269f, 0.05649158f, 0.12367204f, -0.04126118f, 0.05329148f, -0.11287821f, 0.05549973f, 
    -0.11782273f, 0.02614714f, 0.02366095f, -0.03213368f, -0.04476757f, 0.09502848f, -0.05391905f, -0.10242344f, 
    0.06047176f, -0.04985081f, 0.12457537f, 0.07955860f, -0.15079777f, 0.07931263f, -0.18297961f, -0.17764719f, 
    0.06123083f, 0.18841279f, 0.22308089f, 0.03364350f, 0.03954398f, -0.02625650f, -0.11445384f, -0.09221981f, 
    -0.08529256f, 0.02873448f, 0.12944666f, 0.12586422f, -0.05992385f, -0.14355497f, -0.03327937f, -0.03546656f, 
    0.03804261f, 0.05373495f, -0.04386690f, 0.08693493f, 0.20899864f, -0.01797549f, 0.31713524f, -0.11793926f, 
    0.37992468f, -0.04928752f, 0.13550286f, 0.07325947f, 0.14381981f, 0.01196691f, -0.02166131f, -0.06942241f, 
    0.06886490f, 0.12625901f, -0.17718600f, 0.04099388f, 0.00084019f, 0.06865028f, 0.06728638f, -0.14734335f, 
    0.01369269f, -0.01999657f, -0.10661323f, 0.14621685f, -0.03622573f, 0.01476393f, -0.18381804f, -0.04369073f, 
    -0.01640653f, 0.14569816f, 0.06347954f, -0.00334272f, -0.06950620f, 0.07877283f, -0.02601980f, -0.07210133f, 
    0.10398102f, 0.00178913f, 0.08673443f, 0.09834000f, 0.02798273f, -0.07578730f, 0.01455694f, -0.02101302f, 
    0.00550947f, -0.04433402f, 0.08660484f, 0.18195654f, -0.00177423f, -0.08485879f, -0.11487426f, -0.48744041f, 
    0.08854038f, -0.01174491f, 0.17626128f, 0.08238155f, 0.03538643f, 0.01201299f, 0.07538375f, -0.07580542f, 
    -0.13371120f, -0.02272949f, -0.13504599f, -0.10830196f, 0.02906316f, 0.05509651f, 0.08505077f, 0.13828467f, 
    0.06894999f, 0.21855108f, 0.01548729f, 0.03210488f, -0.08142328f, 0.05576910f, -0.19946550f, -0.17792414f, 
    -0.03881694f, 0.00726618f, 0.07139077f, -0.02510049f, 0.10088392f, 0.12986951f, 0.07238796f, -0.07581868f, 
    -0.16215838f, 0.00109035f, 0.04524923f, -0.07741334f, -0.02532707f, -0.17719957f, -0.10131864f, -0.00531685f, 
    0.16734897f, -0.07397871f, -0.10464342f, -0.02994459f, 0.00669538f, -0.03608147f, -0.01269846f, -0.02619185f, 
    0.09239057f, -0.05109590f, -0.04734350f, -0.01450149f, 0.08536423f, -0.09107471f, -0.08806094f, 0.07552006f, 
    0.12723741f, 0.02839414f, 0.13889597f, 0.05270468f, -0.02893900f, -0.01526477f, -0.06072165f, -0.13430481f, 
    -0.06740865f, -0.14655837f, -0.02674819f, 0.01866015f, -0.10481565f, -0.03487150f, -0.10832500f, -0.29140565f, 
    -0.03626933f, -0.26007256f, -0.12867582f, 0.04004247f, 0.04503936f, 0.01862913f, -0.09276555f, 0.02454681f, 
    -0.05016058f, -0.06525984f, -0.06750546f, -0.04556158f, 0.07588849f, -0.22817926f, 0.10250402f, -0.08118967f, 
    0.00046731f, 0.05829379f, -0.04236333f, -0.00264689f, 0.11492741f, -0.08287921f, 0.06428677f, 0.26659766f, 
    -0.05259598f, -0.02476996f, -0.10733637f, -0.13569376f, 0.01815116f, 0.06732570f, 0.00144541f, -0.01862814f, 
    0.08672830f, -0.10026369f, 0.26342690f, 0.11462508f, 0.00316232f, -0.00574389f, -0.03974435f, 0.09988815f, 
    0.14294280f, -0.14020525f, -0.05449962f, 0.00372326f, 0.15579897f, 0.11314454f, 0.10156209f, -0.05331813f, 
    0.11642832f, 0.13890211f, 0.13887621f, 0.08657182f, 0.01819247f, -0.03527833f, -0.02360813f, -0.11535572f, 
    0.57413059f, -0.01623696f, 0.04848997f, 0.12477534f, -0.06127601f, -0.01536818f, -0.05231048f, -0.09307496f, 
    0.05159188f, 0.14815342f, 0.08623555f, 0.02721652f, 0.00937835f, 0.25948524f, -0.09980880f, -0.38266930f, 
    -0.09095241f, -0.16782235f, -0.05857701f, -0.14744000f, -0.00304211f, 0.07893457f, -0.05674479f, 0.01438475f, 
    -0.17538482f, 0.13666901f, -0.23653640f, 0.04812654f, 0.03774029f, 0.03454357f, -0.06393571f, -0.24558993f, 
    -0.02068232f, 0.13669619f, -0.18636385f, 0.21967761f, 0.10141411f, -0.20796365f, 0.21819445f, -0.16399015f, 
    -0.07107760f, -0.01638995f, -0.15302452f, -0.21440150f, 0.02517716f, -0.07667632f, 0.05018406f, -0.16457787f, 
    -0.05859954f, 0.14349140f, 0.00310012f, 0.06015917f, 0.05246616f, 0.11636413f, -0.01060373f, 0.22824185f, 
    -0.03209754f, 0.04079900f, -0.04983215f, 0.00352034f, 0.05422446f, -0.07264079f, 0.13343866f, 0.11306784f, 
    0.05438170f, -0.01231560f, -0.05106690f, -0.11074259f, -0.07183480f, -0.02096000f, 0.04263726f, 0.01482379f, 
    0.02928259f, 0.00846781f, 0.04580266f, 0.01978105f, 0.00288858f, 0.04395748f, -0.01999384f, 0.01186621f, 
    0.01416448f, 0.00131874f, -0.00896037f, -0.05791204f, -0.01455878f, 0.01437454f, 0.02176528f, 0.02299325f, 
    -0.04946278f, 0.03592229f, -0.02680549f, 0.02878782f, -0.00564687f, -0.01679887f, -0.02648732f, -0.02051863f, 
    -0.05943610f, -0.00012032f, -0.02579399f, -0.00284395f, -0.00628485f, 0.03599033f, 0.00041162f, 0.00703388f, 
    -0.04000812f, -0.05230504f, -0.02169727f, 0.00074491f, -0.01897267f, 0.01906688f, -0.01121391f, -0.01029096f, 
    -0.03185295f, 0.01913719f, 0.00111610f, -0.01245051f, -0.00345346f, -0.04805118f, -0.00650363f, 0.02673150f, 
    0.01375841f, 0.02854773f, -0.03730379f, 0.03945618f, 0.03314378f, 0.01854462f, 0.04548330f, -0.03998306f, 
    -0.03113277f, 0.00528775f, 0.00686333f, -0.02524115f, 0.04176914f, -0.03238299f, -0.01891092f, 0.01178951f, 
    -0.01618909f, -0.02351735f, -0.03665300f, -0.03238436f, 0.04534342f, 0.01828624f, 0.04133181f, -0.03821441f, 
    -0.04453662f, 0.03358696f, -0.00485348f, -0.02964880f, 0.00046321f, -0.04366980f, -0.01392539f, 0.00332228f, 
    -0.04877850f, -0.03018790f, -0.02224852f, -0.04046457f, 0.02246457f, -0.03866369f, -0.01955108f, 0.01614717f, 
    0.04760307f, -0.03536023f, 0.02044242f, -0.02511735f, 0.01910684f, 0.02626277f, -0.00430667f, 0.01943035f, 
    -0.01560805f, -0.05138140f, -0.00042391f, -0.03425531f, -0.02716233f, 0.03853697f, 0.03902453f, -0.02807838f, 
    -0.01336790f, -0.02426759f, 0.02369036f, -0.05152129f, 0.01544604f, -0.04603879f, 0.00420185f, -0.04407131f, 
    0.04462188f, 0.04883716f, 0.00531763f, 0.00136846f, 0.03935530f, -0.00416338f, -0.00614898f, 0.03898690f, 
    0.03188613f, -0.03310417f, -0.03008028f, 0.03720897f, 0.02904063f, -0.05588121f, -0.01245352f, -0.03771754f, 
    -0.05087416f, -0.01805793f, 0.03299217f, -0.00741109f, -0.04131040f, -0.01989762f, -0.03063289f, -0.04913742f, 
    0.00548509f, -0.04789742f, 0.03074916f, -0.02813691f, -0.01448056f, 0.00199305f, 0.03549326f, -0.00863632f, 
    0.01580005f, 0.03654920f, -0.03829112f, 0.02136204f, -0.03151461f, -0.01738828f, -0.04774150f, 0.01798854f, 
    -0.05978249f, -0.00267056f, -0.00545225f, -0.04253158f, 0.03875883f, -0.01074034f, -0.05883262f, 0.02102504f, 
    0.00465091f, -0.02701467f, 0.02561986f, 0.00160890f, 0.02305190f, -0.02351791f, -0.03140914f, 0.03831907f, 
    0.03102226f, 0.01848229f, 0.01357691f, -0.04881821f, 0.04001889f, -0.04007884f, -0.02166714f, 0.01601507f, 
    -0.02098821f, -0.02413670f, -0.05115036f, -0.04160429f, -0.01048770f, 0.00746624f, 0.00826877f, -0.04039395f, 
    -0.03163368f, 0.01185547f, 0.01792527f, -0.05855636f, -0.02150216f, 0.02713425f, -0.03641811f, -0.04446121f, 
    -0.01082323f, 0.03944146f, 0.00719895f, -0.03953427f, -0.01507740f, -0.02592126f, -0.03919712f, -0.00394233f, 
    -0.05605589f, -0.01675287f, -0.03896874f, -0.00247766f, -0.04659783f, 0.03768817f, -0.05313803f, -0.00375410f, 
    0.02306048f, 0.01836328f, 0.03345203f, 0.00603717f, -0.04489522f, -0.01093323f, 0.04283960f, -0.04107670f, 
    -0.05953057f, 0.02269158f, 0.00317585f, -0.04186404f, -0.03075822f, 0.02954880f, -0.01228012f, 0.01069105f, 
    0.03046197f, 0.01231486f, -0.05756686f, -0.02658366f, -0.00304395f, 0.02624902f, -0.03865974f, -0.03744961f, 
    -0.05373413f, 0.03780201f, -0.00823033f, -0.04780940f, -0.00027346f, -0.00181771f, -0.00541602f, 0.04013952f, 
    0.02275459f, 0.00372167f, -0.02721861f, 0.03305399f, 0.02939222f, 0.02083908f, 0.00158909f, -0.02937563f, 
    -0.00424594f, 0.04377933f, 0.01483454f, 0.04034245f, 0.01987204f, 0.02794965f, 0.03714338f, -0.00282287f, 
    0.03265551f, -0.03199923f, -0.01311940f, 0.02756524f, -0.00116268f, -0.04280336f, -0.04559632f, 0.01559638f, 
    0.03781013f, -0.01701308f, 0.00939793f, -0.05494173f, 0.02718289f, -0.00395433f, -0.03437734f, 0.03181534f, 
    -0.03056793f, -0.00068322f, -0.04234361f, 0.04382163f, -0.03039137f, -0.02388140f, 0.01520931f, -0.04036617f, 
    -0.04197099f, -0.00476926f, -0.03955885f, -0.01025993f, 0.00615282f, 0.03774207f, -0.03679161f, 0.02910230f, 
    0.02667373f, -0.02910340f, 0.02957452f, 0.03151942f, 0.01041123f, 0.01796119f, -0.01295481f, 0.01781070f, 
    -0.02495498f, -0.03763715f, 0.01119206f, 0.04117036f, 0.04069254f, 0.00423090f, 0.01767575f, -0.05379273f, 
    -0.05273439f, 0.02189405f, -0.01971799f, -0.00590435f, -0.02218118f, -0.04112452f, 0.00057744f, -0.00276148f, 
    -0.05493747f, 0.02565120f, -0.01499747f, 0.00180553f, -0.00665549f, 0.01870416f, -0.01319049f, -0.03210236f, 
    -0.00494972f, -0.02443773f, -0.04262632f, -0.00086075f, -0.00140347f, 0.02974726f, -0.03936776f, 0.04887608f, 
    0.03108702f, -0.04924106f, -0.00945393f, 0.00767555f, 0.02048988f, -0.03650291f, -0.03764857f, -0.01269224f, 
    -0.05379274f, 0.02179707f, 0.04038491f, 0.02181331f, 0.00383736f, -0.04568163f, 0.00247096f, -0.00910487f, 
    -0.00534326f, 0.03725333f, 0.04017997f, 0.03082406f, -0.02711886f, -0.02581273f, -0.00664680f, 0.02747420f, 
    -0.04812247f, 0.01865534f, -0.02569315f, -0.04961482f, 0.02891865f, 0.03471635f, -0.04118389f, -0.00264413f, 
    0.03739716f, 0.01993524f, 0.01238477f, -0.03665513f, -0.01188299f, -0.01774916f, -0.05953426f, 0.00655546f, 
    0.00085737f, 0.03921820f, -0.06016498f, -0.02793728f, -0.00070832f, 0.03035564f, -0.02493770f, 0.00700270f, 
    -0.00464761f, -0.02792653f, -0.01186449f, -0.04783849f, -0.04536693f, -0.04919133f, -0.03217850f, -0.01278450f, 
    -0.01645631f, 0.02556336f, 0.05341663f, 0.04162692f, -0.05753844f, 0.06751180f, 0.07417187f, 0.12352839f, 
    -0.01280371f, -0.05265291f, -0.01219573f, -0.00825834f, 0.04746157f, -0.01005391f, 0.15008692f, 0.05376130f, 
    0.00924935f, -0.05283714f, -0.04903167f, -0.00171793f, -0.08472432f, -0.12236453f, -0.01043372f, 0.01447108f, 
    0.07562254f, 0.39069405f, 0.04794494f, 0.01853899f, 0.25131443f, 0.00331935f, -0.02435277f, -0.04744286f, 
    -0.07155099f, -0.02120992f, 0.04437191f, 0.19051111f, 0.07918444f, -0.00250517f, 0.12957214f, -0.06326099f, 
    -0.11028945f, -0.10161140f, -0.19859324f, -0.18202204f, 0.05463472f, 0.05144119f, 0.01447921f, -0.08123414f, 
    -0.24627320f, 0.12201430f, 0.07900847f, 0.14146695f, -0.04856195f, 0.07985137f, 0.01684954f, 0.01149785f, 
    -0.15812588f, -0.16618478f, -0.02368576f, -0.09792343f, -0.10101908f, -0.06611258f, 0.17195253f, -0.14360011f, 
    -0.01451768f, 0.02729622f, -0.01758350f, 0.03727507f, -0.10648581f, 0.01723560f, -0.06342577f, 0.05551790f, 
    0.10549166f, -0.24463521f, -0.14194471f, 0.23135528f, -0.03010185f, 0.08125601f, 0.00216513f, 0.08571554f, 
    0.16906387f, 0.23053910f, -0.02047708f, 0.08744800f, -0.12772526f, -0.00254217f, -0.07584084f, 0.02105227f, 
    0.13885546f, 0.08781656f, 0.01860917f, 0.20410492f, -0.03944894f, 0.02895163f, -0.01668641f, -0.02604688f, 
    -0.15413350f, 0.07002775f, 0.37643144f, -0.26089394f, 0.09694245f, 0.08270934f, -0.04492983f, 0.08553465f, 
    -0.09553123f, -0.05243475f, 0.14337330f, 0.16402696f, -0.03147973f, 0.01954725f, -0.31072310f, 0.00143412f, 
    0.05830874f, 0.10671082f, 0.07108121f, 0.04040421f, -0.02499270f, 0.10404918f, 0.03322108f, -0.01320855f, 
    0.18974911f, 0.08195245f, 0.13229935f, 0.09850328f, -0.00707484f, -0.04561979f, -0.06947823f, 0.02860531f, 
    -0.06284398f, -0.04935673f, 0.03035589f, -0.01653955f, -0.14043704f, 0.04960723f, 0.15856338f, 0.23946533f, 
    0.13379364f, 0.16105673f, 0.07668480f, 0.06525071f, 0.12291343f, 0.01820220f, 0.06735859f, -0.06444198f, 
    -0.06990701f, -0.02865324f, 0.11085657f, -0.07140734f, 0.16585894f, 0.10104972f, -0.13226914f, -0.05513085f, 
    0.01159195f, 0.09828249f, -0.01625713f, 0.12615295f, -0.05124335f, -0.02254223f, 0.03552987f, -0.01822590f, 
    -0.06421741f, 0.12619202f, -0.05383920f, -0.09422823f, -0.00635785f, 0.02644396f, -0.04228863f, -0.02549378f, 
    -0.06391551f, 0.00688703f, 0.04051451f, -0.03351357f, -0.12359536f, 0.01995950f, -0.00651084f, -0.05081815f, 
    0.02412050f, -0.04962005f, -0.04617172f, 0.14481886f, -0.04377966f, -0.14715250f, -0.12642458f, -0.27278948f, 
    -0.10084428f, 0.07029296f, 0.20458224f, -0.01176217f, 0.03843598f, 0.04475606f, -0.01551827f, -0.04517512f, 
    -0.17583047f, 0.04163588f, -0.06653494f, 0.00792533f, -0.18617031f, 0.07260194f, -0.01095477f, 0.21419518f, 
    -0.15791708f, 0.10586751f, -0.30720806f, 0.18737841f, -0.09887844f, 0.01432608f, 0.03644012f, -0.14598624f, 
    0.00086167f, 0.07188612f, -0.04230947f, 0.10051382f, -0.00415852f, -0.07796397f, -0.01602159f, -0.17945985f, 
    0.12734579f, 0.16438742f, 0.09338063f, -0.08983602f, -0.05112843f, -0.12410558f, -0.19036478f, -0.02665732f, 
    -0.01192446f, 0.00087628f, -0.04194105f, 0.15818910f, 0.12693736f, -0.00233058f, -0.05632706f, -0.07291357f, 
    0.01056671f, 0.04597905f, 0.02823832f, 0.00626989f, 0.08701072f, 0.03419999f, 0.08173965f, 0.18788514f, 
    -0.01417437f, -0.04754356f, -0.02064938f, -0.01560849f, -0.07531226f, -0.00015539f, -0.09052387f, -0.06503306f, 
    -0.07638035f, -0.00318970f, -0.12710683f, 0.00735857f, -0.02249300f, 0.19165801f, 0.19045517f, 0.00137677f, 
    0.00962738f, 0.01209992f, -0.30792114f, -0.02756161f, -0.16707528f, -0.06122377f, -0.07375748f, 0.10565002f, 
    0.11619364f, -0.09008238f, 0.03653156f, -0.06273892f, 0.06472420f, 0.07854924f, 0.06636555f, 0.13281326f, 
    -0.09290672f, 0.15473901f, 0.00118271f, 0.04906539f, -0.29497474f, -0.03999925f, 0.15552799f, 0.17899981f, 
    0.12576832f, -0.00457026f, -0.02239208f, -0.03384070f, -0.06447496f, 0.08462342f, 0.11130659f, -0.13623650f, 
    0.15051614f, 0.23392864f, -0.09498660f, 0.26151270f, 0.08381502f, 0.00031382f, 0.01200010f, -0.06061656f, 
    0.11068421f, 0.11997904f, -0.03914016f, -0.03031758f, 0.00690794f, -0.16834003f, 0.08081932f, 0.09189007f, 
    -0.07473974f, 0.13611010f, 0.05544082f, 0.21847895f, 0.09861251f, 0.05222576f, -0.00151200f, -0.04331003f, 
    0.21031418f, -0.01426603f, 0.17137586f, 0.19863756f, 0.00149271f, 0.03895477f, 0.00167965f, 0.05362279f, 
    0.09680524f, 0.00169177f, 0.12253810f, 0.17664360f, -0.25847533f, -0.10346662f, 0.48353603f, -0.19707845f, 
    -0.04467660f, 0.12932096f, -0.00246667f, 0.12418514f, -0.14399555f, 0.08305792f, -0.07805833f, -0.00702439f, 
    -0.31423363f, -0.00584751f, -0.04442039f, -0.12025790f, 0.15982586f, -0.05402876f, 0.10396105f, -0.15420836f, 
    0.18940525f, 0.15325265f, -0.08436535f, 0.18192528f, -0.17488755f, 0.10447125f, -0.00189670f, -0.00335319f, 
    -0.05244430f, -0.01907439f, -0.01721338f, -0.09208171f, -0.04309073f, -0.02972019f, 0.04853866f, 0.16547769f, 
    -0.07103585f, 0.13278987f, -0.07396360f, 0.01892409f, -0.04711355f, 0.03232452f, -0.11369969f, 0.03408469f, 
    0.04852899f, 0.13741069f, 0.01129336f, 0.10469754f, -0.07316173f, 0.06545601f, -0.06185588f, -0.04486693f, 
    0.00901362f, -0.01323467f, 0.07621004f, 0.03563459f, 0.08399834f, 0.02524222f, -0.01425007f, 0.04147104f, 
    0.13882644f, 0.19201113f, -0.01154309f, -0.07664235f, 0.03344966f, 0.05014081f, 0.08409801f, 0.05973934f, 
    -0.01863456f, -0.08302145f, 0.02864062f, 0.04596051f, -0.33659363f, 0.39517820f, 0.09756526f, 0.27883196f, 
    0.01103099f, -0.02414738f, -0.03415210f, 0.02907011f, 0.00090397f, 0.06709752f, -0.08218963f, 0.02292400f, 
    0.09433092f, 0.22916023f, 0.22744772f, -0.10409106f, 0.19009601f, -0.05259059f, -0.02822704f, 0.06448377f, 
    0.05894531f, -0.11858549f, 0.01886739f, 0.03209069f, 0.04483435f, 0.19428755f, 0.07073256f, -0.13490030f, 
    0.01826374f, 0.12509266f, -0.03081481f, -0.01942075f, -0.03859084f, -0.05891317f, -0.02294742f, -0.03815296f, 
    -0.10850546f, -0.05721245f, -0.31213689f, -0.33026305f, 0.01976814f, 0.17877139f, -0.04289775f, 0.14775890f, 
    -0.04979096f, -0.04206489f, 0.00098054f, -0.05383551f, 0.30194795f, -0.23762985f, -0.02467376f, -0.22738975f, 
    0.03256806f, -0.03006459f, -0.10223164f, 0.06258680f, 0.06885899f, 0.07240289f, 0.02469460f, -0.05697468f, 
    0.09995236f, 0.04923413f, 0.08805664f, -0.11994240f, 0.05111339f, -0.01465137f, 0.09357959f, 0.11526354f, 
    0.22908975f, 0.00505270f, -0.00307756f, 0.08642227f, 0.07139201f, -0.06146088f, -0.09031059f, -0.10422142f, 
    0.07449058f, 0.01692458f, 0.01841050f, 0.01720763f, -0.02508535f, 0.00570645f, -0.04710804f, 0.01220705f, 
    -0.25112289f, 0.00143917f, -0.15987000f, -0.15725070f, -0.05270719f, 0.07835416f, -0.00712451f, 0.12061346f, 
    -0.11607435f, -0.00006570f, -0.02920668f, 0.05585609f, 0.02717771f, 0.02065585f, -0.15445517f, -0.14353895f, 
    0.07378464f, 0.04798367f, 0.19917510f, -0.04033686f, -0.01411941f, 0.01027802f, 0.00761258f, 0.05055525f, 
    0.04730735f, 0.29177266f, 0.07707878f, 0.21451688f, 0.04734690f, -0.09383823f, 0.01330260f, -0.11395933f, 
    0.06598270f, -0.04805101f, -0.01628897f, 0.01095451f, 0.37148848f, -0.05245754f, 0.05092978f, -0.17623004f, 
    0.22166732f, 0.02824549f, 0.17135450f, 0.08150112f, 0.09150973f, -0.01249659f, 0.02208853f, 0.14209561f, 
    -0.01162621f, 0.00703577f, -0.10670618f, 0.03834718f, 0.04657842f, 0.07759856f, 0.01453259f, -0.10160466f, 
    0.00890049f, -0.02667512f, -0.02823540f, 0.08673704f, -0.12872951f, -0.03946316f, -0.13098012f, -0.01087690f, 
    0.06752694f, 0.01068893f, -0.03271727f, -0.12607041f, -0.04919570f, 0.05477106f, 0.00762254f, 0.00477046f, 
    -0.11122765f, 0.03461813f, 0.06032618f, 0.16960813f, -0.06368592f, 0.00044076f, -0.00787397f, -0.10816578f, 
    -0.13517921f, 0.11906497f, 0.00192948f, -0.01599810f, 0.17684780f, 0.03438996f, -0.11279546f, -0.36712509f, 
    0.13945423f, -0.04682695f, 0.14219789f, 0.13225676f, -0.02970362f, 0.03529328f, -0.05802357f, 0.01069790f, 
    -0.04733526f, -0.00012347f, -0.01661252f, -0.19791369f, -0.01159910f, 0.11245570f, -0.06429729f, 0.29643592f, 
    -0.15897398f, 0.15607326f, 0.01010975f, -0.03460817f, -0.15725495f, 0.07727462f, -0.13122797f, -0.10487560f, 
    -0.00946585f, -0.00396404f, 0.03499094f, 0.07946222f, -0.07568419f, -0.01283552f, 0.04662400f, -0.15383181f, 
    0.10843404f, 0.16772693f, -0.08525793f, 0.01860387f, -0.04813693f, -0.07284395f, -0.05250211f, 0.05377018f, 
    0.02964757f, -0.05218093f, -0.08818602f, 0.04029963f, 0.00853160f, 0.00714888f, 0.06816807f, -0.09212586f, 
    0.08030181f, 0.03786894f, -0.02809082f, -0.04905033f, 0.04265326f, 0.01192949f, 0.05590929f, 0.07673384f, 
    -0.00759232f, 0.02128501f, 0.08457154f, 0.09320273f, -0.13463086f, -0.04852838f, -0.11716919f, 0.03273347f, 
    -0.14812177f, -0.06059854f, -0.00193269f, -0.07311914f, 0.01913548f, 0.00377583f, -0.06659026f, -0.03148005f, 
    0.08389146f, -0.01338757f, -0.02961536f, 0.12604353f, -0.06634231f, 0.02894921f, -0.04334683f, -0.05453218f, 
    -0.01344817f, 0.02775973f, -0.12174015f, -0.07019857f, 0.12249087f, -0.06111514f, 0.23562464f, -0.01091631f, 
    0.01289179f, 0.07920190f, -0.04341076f, -0.02218972f, -0.05751871f, -0.06062101f, 0.07855164f, 0.11033347f, 
    0.09605904f, 0.09787394f, -0.04187166f, 0.01950347f, 0.03631383f, 0.01628958f, 0.05316130f, -0.16637297f, 
    0.30598244f, 0.00810795f, 0.07639448f, -0.15216210f, -0.00124066f, 0.03765365f, 0.11512154f, -0.00337052f, 
    0.10457195f, 0.03098421f, -0.04578022f, -0.05672467f, 0.09444448f, -0.06177521f, -0.09913708f, -0.01191556f, 
    0.05482294f, 0.07392974f, 0.12005137f, 0.14108741f, 0.04461572f, 0.00809860f, -0.02725351f, 0.17629682f, 
    0.65281785f, 0.00704866f, 0.03669700f, 0.16892838f, -0.09068900f, -0.01064502f, -0.02227009f, -0.02348766f, 
    0.17480820f, 0.15205730f, -0.03209665f, 0.03337143f, 0.01424001f, -0.12924081f, -0.11813315f, -0.38810050f, 
    0.08253198f, -0.07578110f, 0.01049146f, -0.01887968f, -0.05005765f, 0.11551107f, -0.18916056f, 0.03807179f, 
    -0.47179705f, 0.15540683f, 0.01423910f, -0.03004125f, 0.00085828f, -0.00324405f, 0.08560917f, -0.02328890f, 
    0.09154863f, 0.08043363f, -0.09054270f, 0.12658575f, 0.12993744f, -0.02887861f, 0.17306630f, -0.01413546f, 
    -0.03541339f, 0.04602151f, -0.10714555f, -0.12052926f, 0.10234728f, 0.06040214f, 0.08515538f, -0.00218969f, 
    0.13487752f, 0.10488901f, -0.02563232f, -0.00959492f, 0.03446418f, 0.04463183f, 0.04364102f, 0.14049637f, 
    -0.10262053f, 0.06266421f, 0.06263098f, 0.15267937f, 0.06277718f, 0.02325353f, 0.02935588f, 0.07740933f, 
    0.02376731f, -0.00215717f, -0.08156823f, -0.01882558f, 0.05069748f, 0.04804801f, -0.10554828f, 0.08129287f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.02105744f, 0.14323196f, 0.02880232f, -0.01818797f, 0.02890498f, -0.00563746f, 0.10152232f, -0.03302362f, 
    0.05411592f, -0.01865008f, -0.04485277f, -0.04157337f, 0.16114956f, 0.17649858f, -0.06346592f, 0.01392212f, 
    -0.05345643f, 0.06738182f, -0.06156890f, -0.00432144f, -0.01468872f, -0.08369907f, 0.10223156f, 0.13667853f, 
    0.06626926f, 0.09655087f, 0.00025930f, 0.10076898f, 0.08104430f, 0.04462376f, 0.00670715f, 0.10792474f, 
    0.01493413f, -0.03364072f, 0.15086704f, -0.05183937f, 0.05185420f, -0.03294438f, 0.07161465f, 0.11295047f, 
    0.00210680f, -0.00547995f, 0.16266426f, -0.00981959f, -0.00986797f, 0.07439351f, -0.04001687f, -0.05124873f, 
    0.03172631f, 0.13832952f, 0.02078827f, 0.02448082f, 0.00447922f, -0.00215713f, -0.01678362f, 0.05150710f, 
    -0.07347726f, 0.06845196f, 0.14616598f, 0.04225221f, 0.13702431f, -0.01170233f, 0.14765956f, 0.09160312f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.06710587f, -0.15208896f, 0.02143343f, 0.09886354f, 0.33684048f, -0.11183625f, -0.04692531f, -0.18376794f, 
    -0.19554386f, 0.21639808f, 0.05414185f, -0.01981537f, 0.07369582f, -0.14952423f, 0.15864044f, -0.00663714f, 
    0.21750879f, 0.02715256f, 0.26875633f, 0.04059092f, 0.11131646f, 0.24112105f, -0.21679018f, -0.23612733f, 
    0.13179630f, -0.05167029f, -0.25909778f, 0.11738161f, -0.21199712f, 0.22043177f, -0.37332961f, -0.33162913f, 
    -0.05521346f, 0.08768206f, -0.03493956f, 0.10139573f, -0.37184724f, 0.19282340f, 0.18131174f, -0.22587955f, 
    -0.10201592f, 0.08800530f, 0.05955616f, 0.08945443f, -0.04170536f, 0.17927127f, 0.22373292f, 0.01488685f, 
    -0.19737306f, 0.05170565f, -0.05677569f, -0.22878692f, -0.01607412f, 0.10990389f, -0.05840027f, -0.05671879f, 
    0.24572590f, 0.22609623f, -0.44758797f, -0.36809981f, -0.07509709f, -0.02356754f, -0.19444260f, 0.33234778f, 
    0.11371863f, -0.14542450f, -0.10350727f, -0.08340044f, -0.21070394f, 0.07965432f, -0.04413899f, -0.09788094f, 
    -0.19115971f, 0.25826126f, -0.11623074f, 0.02826593f, 0.31507164f, 0.05762193f, 0.28441703f, -0.02144572f, 
    -0.46167195f, -0.05745681f, 0.05330585f, 0.00575612f, 0.03671047f, -0.44952771f, 0.23630968f, 0.18905686f, 
    0.00311843f, -0.26058608f, -0.46036562f, -0.24289575f, -0.19133846f, 0.29108328f, -0.25260770f, 0.12399972f, 
    -0.08450998f, -0.00162677f, -0.13338912f, -0.04475648f, 0.01593794f, 0.10558765f, 0.05096745f, -0.28403047f, 
    0.07961421f, -0.39188236f, 0.32883203f, -0.10445064f, -0.08634926f, 0.11346177f, -0.36950561f, -0.09436693f, 
    0.04593266f, 0.09254222f, 0.03332708f, 0.03833448f, 0.09520707f, 0.00321787f, -0.10284282f, -0.17552705f, 
    0.25213102f, 0.42502496f, -0.12543584f, -0.12933527f, 0.28135806f, -0.04631333f, 0.20259738f, 0.35320783f, 
    0.00053807f, 0.13155127f, -0.11160278f, -0.04041833f, -0.37595877f, 0.08006297f, 0.30712631f, -0.14478168f, 
    -0.07355086f, -0.47991645f, -0.05222148f, -0.11229664f, -0.03768157f, -0.02157714f, -0.32430592f, 0.00238185f, 
    -0.25377962f, 0.09595708f, -0.27709287f, 0.04783862f, 0.02310764f, -0.38952199f, 0.25827333f, -0.20947398f, 
    -0.32349718f, 0.15310046f, 0.24727656f, 0.11310215f, 0.07852781f, 0.31347597f, 0.01365553f, 0.09090300f, 
    -0.05144420f, 0.08498880f, 0.00821128f, -0.01198019f, -0.07472523f, 0.01918476f, 0.16647097f, -0.15219706f, 
    -0.38436151f, -0.23592891f, -0.07664399f, -0.09138297f, 0.09724037f, -0.02691076f, -0.33114073f, 0.10767785f, 
    -0.19862013f, 0.24618027f, -0.02190618f, -0.02965703f, -0.05664629f, 0.31363347f, -0.01633474f, 0.34067675f, 
    -0.53212303f, -0.36560816f, -0.10127734f, 0.01774797f, 0.31577143f, -0.02158646f, 0.14923438f, -0.21512364f, 
    0.06971166f, -0.47046846f, 0.07227377f, -0.09846609f, 0.08513612f, 0.01557022f, -0.21210825f, 0.25242677f, 
    -0.02425015f, -0.00383326f, 0.04068942f, -0.09172957f, -0.28910586f, -0.23092584f, -0.19963245f, -0.04192485f, 
    0.12307212f, 0.26466715f, 0.14867878f, -0.07910165f, -0.04339268f, 0.15388878f, 0.12551875f, -0.36619523f, 
    0.03956275f, -0.16808255f, 0.13882415f, 0.03777377f, 0.08073119f, -0.11767646f, 0.19433890f, -0.00594454f, 
    -0.11669882f, 0.22410621f, -0.18647100f, 0.04060344f, 0.00987884f, 0.14178532f, -0.52126622f, -0.10396843f, 
    -0.10852121f, 0.17574643f, -0.30895627f, -0.03726103f, -0.11008473f, -0.23293059f, 0.20063907f, -0.10069733f, 
    -0.18394589f, 0.07348140f, 0.08373127f, 0.00127162f, -0.00321257f, 0.23339993f, -0.03208221f, 0.14774768f, 
    0.08200955f, -0.65057725f, -0.30840269f, 0.40749255f, -0.11894839f, -0.06440494f, -0.06856463f, -0.24800111f, 
    0.06041557f, 0.03763963f, -0.08020137f, 0.04723902f, -0.08820330f, 0.10036474f, 0.04274449f, -0.01630299f, 
    0.16386490f, -0.06009102f, 0.01853766f, 0.04927962f, 0.08596643f, -0.10285363f, 0.14699680f, 0.07299851f, 
    0.30469808f, -0.29702568f, -0.08594086f, -0.07461716f, 0.05443381f, 0.33501223f, -0.07794990f, 0.12110206f, 
    -0.30451837f, 0.19557919f, 0.12341808f, 0.09409979f, 0.08851293f, -0.17340752f, 0.09789412f, -0.14286767f, 
    0.06609815f, 0.04752640f, 0.10454728f, 0.06897382f, 0.25288776f, -0.19681814f, 0.06981930f, -0.30579400f, 
    0.01020872f, -0.04422205f, -0.31832337f, 0.08018270f, 0.06796908f, -0.09944730f, -0.06070605f, 0.05327845f, 
    -0.69751650f, 0.12007726f, 0.03156637f, 0.15542716f, -0.10203089f, 0.09510573f, 0.02155990f, 0.07513615f, 
    0.07187274f, 0.09928435f, 0.12215093f, -0.28648970f, -0.17763406f, -0.00231391f, -0.13883534f, -0.26989344f, 
    -0.12085414f, 0.13425188f, 0.07535366f, -0.06526362f, 0.11712229f, -0.09928131f, 0.08181412f, -0.37949717f, 
    0.17782409f, -0.11977793f, 0.01147843f, -0.06047208f, 0.20630389f, 0.22225517f, 0.15866536f, 0.01310271f, 
    -0.00097260f, 0.11617246f, -0.30952558f, 0.08392101f, -0.03674414f, -0.39644763f, -0.36822760f, 0.06441560f, 
    0.11689623f, 0.11820614f, 0.14861487f, 0.08149564f, -0.08086212f, -0.17357546f, 0.11764832f, -0.18588153f, 
    0.09438723f, -0.07714911f, 0.23595004f, -0.12879251f, -0.07156739f, 0.01217357f, -0.11632524f, 0.30548909f, 
    0.24237715f, 0.22286788f, 0.17398587f, 0.06146372f, -0.05954991f, 0.19465394f, 0.06640718f, -0.00086706f, 
    -0.41615644f, 0.14549343f, 0.10431851f, -0.10262408f, 0.04607837f, -0.23357773f, 0.06290603f, -0.58030838f, 
    0.03321047f, 0.07112848f, 0.00032631f, -0.03339937f, -0.02364422f, 0.01108013f, -0.11351407f, 0.13736118f, 
    0.03490253f, 0.19095901f, -0.12285177f, -0.09869970f, -0.56501716f, 0.08221313f, 0.01622629f, 0.05732458f, 
    -0.57746512f, -0.34058976f, -0.08962269f, 0.00200316f, 0.14942507f, 0.30323562f, -0.16048138f, -0.06905964f, 
    -0.61028963f, 0.07157007f, -0.09395864f, -0.06201531f, 0.09160987f, -0.24583495f, 0.35316974f, -0.17612772f, 
    -0.72846574f, 0.26762047f, 0.07347406f, 0.08353689f, 0.27528390f, -0.18561123f, 0.19270952f, 0.17381237f, 
    -0.03985235f, -0.58274782f, 0.16811217f, 0.01935045f, 0.33123717f, -0.21490774f, 0.03780134f, 0.03272879f, 
    -0.18719271f, -0.33464307f, 0.02522085f, -0.08812210f, 0.00737829f, -0.49035394f, 0.13904065f, 0.01127481f, 
    0.05659869f, -0.47871625f, -0.03754117f, -0.37122235f, -0.03584189f, -0.58000112f, -0.04117812f, 0.36520818f, 
    -0.22862804f, -0.14017817f, -0.06578956f, 0.20197959f, -0.34184650f, 0.00160951f, -0.39219338f, -0.31446192f, 
    -0.01469698f, -0.17589206f, -0.00640136f, -0.02429968f, -0.01266061f, -0.10534470f, 0.44497740f, 0.06543050f, 
    -0.27156943f, -0.20161690f, -0.09705564f, 0.02292355f, -0.20895618f, -0.31963634f, -0.09680481f, -0.01730178f, 
    0.06565908f, -0.08759411f, -0.36220959f, -0.11701819f, 0.06864167f, -0.04322289f, -0.32713810f, 0.01954301f, 
    0.25706071f, -0.31120324f, 0.24662960f, -0.40110093f, -0.31494966f, -0.29237175f, 0.09990820f, 0.11487743f, 
    0.05349304f, -0.10937633f, -0.08526496f, 0.05935131f, 0.04466904f, 0.08820429f, -0.01317676f, 0.03058700f, 
    0.20854968f, -0.34890676f, -0.17472747f, 0.08954865f, -0.05768383f, -0.30051810f, -0.25827822f, 0.07201161f, 
    0.29110324f, -0.50188947f, -0.10538627f, -0.31536978f, -0.11990986f, 0.19678602f, 0.09054983f, 0.19155294f, 
    -0.27470344f, -0.18838105f, 0.12277246f, 0.30230936f, 0.21349019f, -0.11152540f, -0.28518561f, 0.01606862f, 
    0.01296925f, 0.06976882f, 0.03361959f, 0.05541189f, -0.27773869f, -0.05633631f, 0.12613647f, -0.05970655f, 
    -0.42905867f, -0.38137662f, -0.02563459f, -0.04954147f, -0.50877804f, 0.15717468f, -0.14590418f, -0.04282326f, 
    -0.49132326f, 0.28992641f, -0.43756247f, -0.03137102f, -0.02323975f, -0.20548262f, -0.04275844f, 0.18353412f, 
    0.32257101f, -0.23225363f, -0.49759525f, -0.10880349f, -0.35427812f, -0.12110660f, -0.13518585f, 0.21119855f, 
    -0.02171512f, 0.35054985f, 0.42770502f, -0.08578449f, -0.42540538f, 0.07775013f, -0.26561633f, 0.41036019f, 
    -0.10513566f, -0.19221698f, 0.07905044f, -0.01102763f, 0.08177992f, -0.63087219f, 0.19346593f, 0.03259028f, 
    -0.18939255f, -0.01891115f, 0.05016124f, -0.09246833f, -0.02080774f, 0.29189494f, -0.06819979f, -0.35161909f, 
    -0.32028973f, -0.17768940f, 0.09290834f, 0.11566314f, -0.44193360f, -0.11917932f, 0.23982485f, 0.16890766f, 
    -0.03979042f, 0.28566688f, 0.03324382f, 0.01440748f, -0.01467849f, 0.10140777f, -0.13848734f, -0.28907856f, 
    -0.11563233f, 0.07760627f, -0.09000438f, 0.00777540f, -0.44906655f, 0.14600289f, -0.26790094f, -0.03676008f, 
    0.12207444f, -0.60819143f, 0.11389682f, -0.04859559f, -0.08758650f, 0.02589554f, -0.10198583f, -0.01420518f, 
    -0.49255237f, -0.18931738f, 0.08035289f, 0.19835204f, 0.19608934f, 0.01569860f, 0.20548770f, 0.01480420f, 
    -0.12653874f, -0.49264485f, -0.26874995f, -0.12852480f, 0.04181457f, -0.53045809f, 0.11320180f, 0.08201739f, 
    -0.30325702f, 0.54332447f, -0.34688818f, 0.11401282f, -0.01618468f, 0.33283231f, -0.22316012f, 0.00050074f, 
    0.06896625f, 0.02708893f, -0.11685221f, 0.26139420f, -0.07843348f, -0.39048502f, 0.07189652f, 0.15530518f, 
    -0.13044773f, 0.37111002f, 0.16847038f, -0.13813145f, 0.11205665f, -0.05543130f, 0.20670921f, 0.26160631f, 
    0.05679277f, 0.15610790f, -0.05875421f, -0.01887639f, -0.27155268f, 0.08623276f, -0.60209221f, 0.09782470f, 
    0.19864354f, 0.28022519f, 0.10459369f, 0.09173941f, -0.15260506f, -0.04481489f, 0.11641263f, -0.09544666f, 
    -0.10082747f, 0.16361864f, 0.10371106f, -0.07987505f, -0.03272798f, -0.35493425f, 0.09696473f, -0.11383239f, 
    0.11049338f, -0.38219452f, -0.18068361f, 0.23938976f, 0.22698055f, 0.34820753f, -0.21639583f, 0.24410751f, 
    -0.06778092f, -0.12407269f, 0.30561417f, -0.01823453f, -0.21034023f, -0.38888171f, -0.19025297f, -0.35937178f, 
    0.22495286f, -0.05097836f, 0.18755776f, -0.08252724f, -0.06772973f, -0.18323086f, 0.19911961f, -0.12883005f, 
    -0.20720506f, -0.15214512f, 0.01787937f, 0.34607002f, -0.10982261f, -0.37604034f, -0.07286268f, -0.27768546f, 
    -0.47009587f, -0.51896852f, -0.11037701f, 0.22824001f, -0.15637696f, -0.04649458f, 0.02153440f, -0.12713610f, 
    -0.00897568f, -0.00234594f, -0.05778063f, -0.05465844f, 0.25766003f, 0.02229377f, -0.39382493f, 0.30265632f, 
    -0.05316136f, -0.06155591f, -0.10566127f, 0.06656419f, 0.14764076f, -0.17723571f, -0.21103464f, -0.07494342f, 
    -0.07409090f, 0.21740264f, 0.35131297f, -0.09542882f, -0.02955713f, 0.04312931f, 0.12662470f, 0.25569227f, 
    -0.07948978f, 0.38174334f, 0.15244742f, -0.56683344f, 0.16248722f, -0.50162137f, 0.06775278f, 0.15834050f, 
    -0.06728593f, 0.06323268f, -0.44198182f, -0.08551602f, 0.15127052f, 0.06603762f, -0.44457594f, -0.16144671f, 
    -0.16293842f, 0.14149421f, -0.06552654f, 0.06390516f, 0.02130627f, -0.27764419f, 0.06941229f, -0.03724010f, 
    0.04334874f, -0.03296249f, 0.08665645f, -0.34445152f, -0.00651536f, -0.39541611f, 0.03821979f, -0.07199275f, 
    -0.25260925f, -0.06892749f, 0.17686470f, -0.28104791f, -0.44449610f, -0.08926427f, 0.30417982f, -0.32000947f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.08915129f, -0.04982017f, 0.08871923f, -0.13462733f, -0.12239306f, -0.07557376f, 0.13469815f, 0.05927484f, 
    0.16579378f, -0.03184329f, 0.12376782f, 0.14059702f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
