#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.92915726f, -0.24758151f, 1.13031125f, -1.19616044f, 0.26068324f, -0.56299782f, 0.48843244f, 0.60112214f, 
    0.34962451f, -0.21571016f, -0.56913263f, -0.64041817f, 0.95172042f, -0.99014550f, 0.07569405f, -0.83792371f, 
    -0.62507826f, 0.86920387f, 1.03956389f, 0.96229202f, -0.59098196f, -1.14290035f, 0.58374172f, -0.87477875f, 
    -0.21951735f, 0.35487741f, 0.25710672f, 0.98512489f, -0.98673373f, -1.02949643f, -0.52836323f, -0.91348112f, 
    -0.43294403f, 0.48946813f, 0.09280035f, 0.17385365f, -1.23608971f, 1.18216693f, -0.84404534f, -0.71104491f, 
    0.10526796f, -0.83625937f, -0.29484347f, -0.33771852f, -0.06586916f, -0.49953404f, -0.36286178f, -0.99639893f, 
    -0.55440086f, 0.80151308f, 1.26176977f, 0.50550425f, -0.57766390f, 0.85147125f, 1.05891860f, 0.50430506f, 
    -0.27950558f, 0.75024062f, 0.53945893f, 0.49246722f, 0.02830895f, -0.59638792f, 0.47823164f, -0.95850104f, 
    -0.26590207f, -0.29538691f, 0.26333210f, 1.13967562f, -0.22006363f, -0.48496389f, -1.08660901f, -0.51654345f, 
    -0.24612273f, -0.67351192f, -0.96165460f, 0.73098999f, 0.99994737f, 0.49624774f, -0.04932025f, -0.60015130f, 
    -0.22928557f, 0.50044584f, -0.38495830f, 1.02641010f, -1.22361004f, -1.14346433f, -0.54680008f, 0.13021912f, 
    0.26019129f, -0.06376691f, 1.01189923f, 0.88002932f, 0.61817694f, -0.15284444f, -1.16504836f, -0.86222196f, 
    0.92191130f, 0.74448943f, 0.32125565f, 0.93877220f, 0.73517716f, 1.00488317f, 0.89783770f, 0.49299359f, 
    -0.26134685f, 0.36677331f, 0.78163940f, 0.25230214f, 1.00488532f, 0.91071171f, 1.16868496f, 0.37123457f, 
    0.16382582f, 0.59849930f, -0.63356268f, 0.02095961f, -0.34415206f, 1.01389956f, 1.01319396f, 0.83328485f, 
    -0.18173818f, 0.40033153f, -0.32171467f, 0.75582367f, 0.31571713f, -0.30273038f, -0.40513936f, -0.98105067f, 
    -0.94722444f, -0.41764209f, -0.84341639f, -0.41763458f, -0.56839484f, -0.21580739f, 0.08002327f, 0.77041113f, 
    1.26700675f, 0.75215638f, -0.67668205f, -0.58710289f, 0.13051410f, -0.45976469f, -0.04139644f, -0.09051418f, 
    1.39673686f, 0.77081060f, 0.39157459f, 0.90382063f, 0.46835455f, 0.25322160f, -0.01378306f, 0.06065856f, 
    -0.39716470f, 1.16404021f, -0.69885266f, -1.03187346f, -0.30595252f, -0.47503376f, -0.65760875f, -0.76178718f, 
    -0.35372752f, 0.17566724f, 0.58396351f, 0.70860630f, -0.20049721f, -1.29156220f, 0.63150668f, 1.06837821f, 
    -0.65138286f, 0.44621399f, 0.45954478f, 0.78949565f, 0.56806445f, 0.93732202f, 0.27558044f, 0.21282977f, 
    0.70129377f, -0.03764347f, -0.45477766f, 0.14195317f, -0.26319677f, 0.07535729f, -0.80731690f, 0.01239137f, 
    1.21010244f, -0.90110433f, 0.60591829f, -0.38634175f, -0.16363822f, 1.35531032f, -0.54202628f, -1.05894089f, 
    0.27338099f, 0.30850860f, 0.41015962f, 0.35744980f, 0.39115667f, 0.41459811f, -1.43071985f, -0.74678713f, 
    0.83421278f, -0.08343156f, 0.51907170f, 0.88081574f, -0.38774624f, 0.06036212f, -0.12982546f, -1.58279061f, 
    -0.65990812f, -0.38443318f, 0.86667979f, 1.07653785f, 0.60719222f, -0.02655475f, 0.23098053f, 0.09775975f, 
    -0.37679183f, -1.68240952f, -0.74189544f, -1.13985085f, 0.36144328f, -0.19373119f, 0.33948037f, 0.34101626f, 
    0.31983694f, 0.84642208f, -1.09039962f, 0.64009428f, 0.96488404f, -1.26552606f, 0.80099177f, 0.10537159f, 
    0.21858075f, -0.61137962f, -0.60671717f, -0.02841151f, -1.18013346f, -0.55137974f, -0.80065936f, 0.44899294f, 
    -0.06978852f, 0.53339499f, -0.77428079f, 0.73745286f, 0.06547588f, -0.21041161f, -0.10034978f, -1.22735667f, 
    0.73899025f, -0.98877144f, -0.67877960f, -0.25369260f, -0.66600490f, 1.27776074f, 0.62359333f, -0.24669762f, 
    -0.24942952f, -1.23926914f, -0.43563879f, -0.20962675f, 0.36392787f, -0.67466974f, -1.13718212f, -1.04405296f, 
    0.88875991f, -0.40882882f, 0.56056774f, -0.71363658f, 0.06808202f, 0.11162485f, 0.02695725f, -0.00624291f, 
    0.83498508f, 1.22474170f, 0.97499073f, -0.88571531f, -0.40336666f, 0.52693874f, -0.31197211f, 0.15578903f, 
    1.14451492f, -0.61466473f, 1.47186911f, -0.34196156f, -0.84683383f, 0.04738899f, -0.00799221f, -0.30533141f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.06086192f, -0.24018626f, -0.26708269f, -0.08743627f, 0.24215984f, 0.25833806f, 0.12311521f, 0.04395029f, 
    -0.08501899f, 0.42816558f, 0.06000238f, -0.19446343f, 0.56214726f, 0.44067684f, 0.20109819f, 0.36318147f, 
    0.06482810f, 0.36474454f, 0.04101993f, 0.54616261f, 0.26364633f, -0.24323435f, 0.04483963f, -0.13511640f, 
    0.17081775f, 0.02610302f, 0.10517559f, 0.24389762f, 0.28228852f, -0.16515850f, 0.07037848f, -0.17811207f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.30583358f, -0.13954471f, 0.07338196f, 0.24006248f, 0.16093789f, 0.06578053f, -0.11753004f, -0.02717077f, 
    0.02934766f, 0.22092628f, 0.04158674f, -0.14241411f, -0.05163755f, -0.00972077f, 0.08533251f, 0.27711460f, 
    0.18349041f, -0.14471485f, 0.08297694f, 0.25249651f, 0.00466974f, 0.14774270f, 0.15323445f, 0.08277136f, 
    -0.10195485f, 0.01054018f, -0.05482529f, -0.05892715f, -0.09996422f, -0.35089874f, 0.02657553f, 0.07812543f, 
    -0.04318042f, -0.06795266f, 0.04054365f, 0.07402865f, -0.05701200f, -0.30125871f, -0.04519691f, -0.13184634f, 
    0.24556789f, 0.02831827f, -0.04838726f, 0.22620389f, -0.09522519f, 0.05153385f, -0.27093062f, 0.18380898f, 
    0.17401765f, -0.09488764f, 0.11261186f, 0.00128650f, -0.03112305f, -0.09581856f, -0.59691602f, -0.05691569f, 
    0.18868200f, -0.14256738f, 0.03121892f, -0.00443314f, 0.07462270f, 0.01299825f, 0.19797428f, 0.16991128f, 
    -0.40897229f, 0.03984261f, 0.06800795f, -0.09164230f, -0.03623804f, -0.13535635f, -0.06168629f, -0.13492644f, 
    0.09713423f, -0.24791940f, -0.12563536f, 0.05152313f, -0.12269010f, 0.16298343f, -0.00183140f, -0.08426210f, 
    0.06607766f, 0.09124380f, 0.03736021f, 0.17918159f, 0.07158924f, -0.03671521f, -0.03579727f, -0.10475741f, 
    0.01417932f, -0.16829123f, -0.06162124f, 0.18812989f, -0.01297867f, -0.06056666f, -0.07189889f, 0.05685453f, 
    0.04540367f, 0.34852925f, 0.00698302f, -0.37944871f, 0.13334373f, -0.01568257f, -0.33544499f, -0.16339599f, 
    0.08447161f, -0.19948147f, -0.00217621f, -0.14170347f, -0.20108329f, 0.21764344f, -0.00936884f, 0.03183075f, 
    0.05658554f, -0.10367958f, 0.01029940f, -0.00503325f, -0.07855283f, 0.09337665f, 0.36172071f, 0.19473989f, 
    -0.03015704f, -0.15193371f, 0.01708164f, 0.12862703f, 0.15060398f, -0.00290307f, -0.43017411f, -0.06019771f, 
    -0.31257164f, -0.12995693f, -0.13433890f, 0.03333183f, -0.21000780f, 0.04316620f, -0.05754750f, 0.02608370f, 
    0.31612670f, 0.05048664f, 0.10300894f, -0.05991513f, -0.06770059f, -0.10538597f, 0.03810129f, -0.02797634f, 
    -0.40016884f, 0.13940221f, -0.02566058f, -0.17124607f, 0.02604045f, 0.14786510f, 0.03518419f, -0.03035311f, 
    -0.11789471f, -0.26046386f, -0.07719156f, -0.41507399f, -0.03660681f, 0.21101746f, 0.03600246f, -0.07415225f, 
    -0.15461759f, -0.14394665f, -0.54851449f, 0.19062091f, 0.05033446f, -0.03589661f, -0.34538174f, 0.11622789f, 
    -0.01257341f, -0.03067359f, 0.13829564f, -0.14362189f, 0.27956009f, 0.13719997f, 0.04148185f, 0.17926493f, 
    -0.00355491f, 0.01013070f, 0.19483706f, -0.11984955f, 0.17765133f, -0.18690456f, -0.26276666f, 0.14124429f, 
    0.15386355f, 0.00350095f, -0.17369017f, 0.17497240f, 0.16702776f, -0.32628635f, -0.47911721f, 0.17818950f, 
    -0.07803801f, 0.10593969f, 0.01859839f, -0.04222676f, -0.04767524f, 0.04300757f, -0.22720957f, -0.54735285f, 
    -0.25740460f, -0.07191797f, -0.06563541f, -0.02601395f, -0.13131569f, -0.11181141f, 0.06466033f, 0.46321461f, 
    -0.23837562f, -0.22892480f, -0.12847474f, 0.01442079f, 0.07184179f, 0.10608838f, 0.04698108f, -0.07430706f, 
    0.44877288f, 0.06687048f, 0.16910623f, -0.02274022f, 0.23858894f, 0.26004812f, 0.19919361f, 0.10072449f, 
    -0.10635631f, -0.10223628f, 0.39140373f, 0.10138962f, -0.04965189f, 0.03404050f, 0.17129655f, -0.16708851f, 
    -0.05364545f, 0.04067847f, -0.42094842f, -0.03804111f, 0.11203109f, 0.04934480f, -0.08052491f, 0.03762134f, 
    0.02548012f, -0.09351228f, 0.01022386f, -0.30778566f, 0.25054038f, -0.15322965f, -0.05454680f, 0.02418407f, 
    0.19633469f, -0.04754384f, -0.20089413f, 0.11331855f, 0.38484722f, 0.01682480f, -0.09431688f, 0.05141006f, 
    0.14123261f, 0.00165672f, -0.04330470f, 0.10783070f, -0.03123489f, -0.16869368f, 0.05266229f, -0.14077665f, 
    -0.18222830f, -0.06579602f, 0.09338269f, 0.07425964f, -0.10233568f, 0.18115278f, 0.36447015f, -0.69163752f, 
    0.05729195f, 0.16759728f, 0.08299386f, 0.21320952f, -0.04980179f, 0.03894563f, 0.04820590f, 0.33868909f, 
    -0.41405880f, -0.23897041f, -0.07474393f, 0.16260298f, -0.16530931f, 0.13864133f, 0.05374734f, 0.04600576f, 
    -0.12009314f, 0.29629809f, -0.04907179f, 0.05531092f, -0.25610712f, -0.07679826f, -0.15735093f, 0.01294781f, 
    0.25659749f, 0.28820676f, 0.12277952f, -0.01428109f, -0.04235978f, 0.06865803f, 0.33890072f, 0.22713602f, 
    0.25116834f, -0.03603380f, -0.50843298f, -0.42326361f, 0.24072261f, 0.02492633f, -0.00291391f, -0.03160169f, 
    -0.04330846f, -0.08283501f, 0.32163408f, 0.18548414f, 0.14399688f, -0.16601367f, -0.28038824f, -0.19409220f, 
    0.11706954f, 0.13088448f, -0.05054093f, 0.07017843f, 0.12128852f, -0.41035575f, -0.19747256f, 0.07965866f, 
    0.03090569f, 0.17455547f, 0.03417850f, -0.04340800f, -0.07438808f, 0.18460706f, -0.17986462f, 0.00287688f, 
    0.16629770f, -0.10639194f, 0.01781917f, 0.14556204f, 0.24300225f, 0.04416697f, -0.10832881f, -0.06095758f, 
    -0.21929978f, 0.06104595f, 0.05292140f, -0.22299187f, -0.22599603f, 0.08241970f, -0.36661804f, 0.13618505f, 
    0.20580794f, -0.17568511f, 0.04677610f, 0.04331513f, -0.04712364f, 0.07917830f, 0.09480026f, -0.11305620f, 
    0.15839674f, 0.00821957f, -0.12744474f, -0.04309194f, 0.00090775f, 0.14688244f, -0.07918462f, 0.16388763f, 
    -0.24677615f, 0.14551993f, 0.14102690f, 0.04737586f, 0.07233025f, -0.06127542f, 0.12376525f, 0.08089382f, 
    0.13719465f, -0.10943674f, -0.10196804f, -0.30087289f, -0.11041195f, -0.17593928f, -0.05180745f, 0.05607267f, 
    -0.12756981f, -0.02667004f, 0.29740131f, -0.78745550f, -0.16465910f, 0.06412584f, 0.03797787f, 0.12140733f, 
    0.03291520f, 0.07560009f, 0.19612248f, 0.21728276f, -0.28214964f, -0.25610122f, -0.06440258f, 0.13287130f, 
    0.14442196f, 0.13048793f, 0.13192105f, 0.00410703f, 0.01874124f, -0.81157303f, -0.59962797f, 0.05775923f, 
    0.12001923f, -0.04388632f, 0.05868796f, 0.07384443f, 0.09767360f, 0.14701660f, 0.04102604f, 0.39685646f, 
    0.17179607f, 0.07208545f, 0.04719707f, 0.12526390f, 0.14353009f, 0.06557006f, 0.06867584f, -0.63350141f, 
    -0.34582797f, -0.06599305f, 0.19308141f, -0.08930039f, -0.01842325f, 0.02887616f, 0.05819786f, 0.00529493f, 
    -0.42382509f, 0.21567833f, 0.07681663f, 0.17413177f, 0.18098187f, -0.07835463f, 0.07775412f, -0.04123184f, 
    -0.12895732f, -0.04627940f, 0.22941680f, 0.13892056f, 0.09495091f, -0.03876789f, 0.08569854f, 0.15112184f, 
    0.00209914f, 0.20042638f, -0.49552584f, -0.30079126f, -0.06569919f, 0.06866343f, 0.00951632f, -0.03836712f, 
    0.24627276f, 0.08051767f, -0.11357821f, -0.48898366f, -0.17440373f, 0.00353852f, 0.03086020f, 0.00503155f, 
    0.00089132f, 0.11498504f, 0.13023664f, -0.21723954f, 0.14602831f, 0.03176828f, -0.19944084f, 0.23837431f, 
    -0.00237016f, 0.17925683f, -0.08749079f, 0.07101809f, 0.30727112f, -0.07191470f, -0.08743128f, -0.05933153f, 
    -0.08777162f, -0.15117453f, -0.01627916f, -0.09148940f, 0.12493600f, 0.12191471f, -0.12551086f, 0.07565351f, 
    0.06517963f, -0.07121127f, -0.17392294f, -0.04080622f, -0.05844798f, 0.13378635f, -0.13990676f, 0.08825224f, 
    0.33347741f, 0.01701441f, -0.14943925f, 0.09951773f, -0.14409760f, -0.08205931f, -0.05902354f, -0.06381574f, 
    -0.11877289f, 0.14859979f, 0.00432908f, -0.14210437f, -0.00717169f, 0.02685227f, -0.07505361f, -0.09955956f, 
    0.15401521f, 0.02368966f, -0.29952267f, 0.11134774f, 0.27966446f, 0.04571224f, -0.05097580f, 0.11266936f, 
    0.12378407f, 0.04038265f, 0.01043273f, 0.03969293f, 0.03070779f, -0.20827553f, -0.01585528f, 0.10924172f, 
    -0.07723692f, -0.13983941f, 0.10855178f, 0.01573362f, -0.30039704f, 0.11403748f, -0.04415142f, 0.30913875f, 
    -0.08536223f, 0.22519325f, 0.07373332f, -0.12656853f, -0.07494064f, -0.35309073f, -0.11114584f, 0.06379674f, 
    -0.08657574f, 0.08161538f, -0.14027898f, -0.09960569f, 0.16653100f, 0.22092888f, 0.34853798f, -0.01390088f, 
    -0.01864779f, -0.02324788f, 0.14593580f, -0.12193085f, 0.36372432f, -0.03450184f, 0.00168982f, -0.20952858f, 
    -0.29104820f, 0.13815926f, 0.10593370f, -0.03745269f, -0.08274884f, 0.22442511f, 0.19262692f, 0.24344240f, 
    -0.01006236f, -0.54451376f, -0.01632164f, -0.23395087f, -0.11528365f, 0.00739893f, 0.23917323f, 0.05378949f, 
    0.12784545f, -0.05015174f, -0.42298663f, -0.17802431f, 0.07140207f, -0.12180082f, 0.08584654f, 0.12078422f, 
    -0.05985095f, 0.60084736f, -0.20656160f, 0.03609186f, 0.23655939f, 0.05580773f, 0.03240855f, -0.00290939f, 
    -0.05531281f, -0.11858115f, 0.09771848f, 0.30652648f, 0.12411885f, -0.12889346f, -0.05838400f, 0.00372988f, 
    0.02333399f, 0.09170125f, 0.20680650f, 0.13883458f, -0.19152506f, 0.00043212f, -0.20140406f, -0.21809585f, 
    -0.25030196f, 0.20297994f, -0.05130216f, -0.04357252f, -0.47580335f, 0.11291429f, 0.15701620f, -0.10684238f, 
    -0.13152535f, -0.01195553f, 0.00148094f, -0.00102607f, 0.03404076f, 0.00574588f, 0.09193321f, 0.06315962f, 
    0.06749821f, 0.12314127f, 0.06376395f, 0.16020983f, -0.24859715f, -0.07196252f, -0.07052948f, -0.30281597f, 
    -0.00436592f, 0.24643546f, 0.13489348f, 0.12848529f, 0.17948985f, -0.28901160f, -0.12047331f, -0.09349214f, 
    0.10773617f, 0.22649457f, -0.08742016f, 0.08103429f, 0.09248380f, -0.05716037f, 0.11313916f, 0.11767446f, 
    0.01006905f, 0.09918797f, 0.19516206f, 0.16425677f, 0.10324817f, -0.11082669f, -0.15682226f, 0.03773823f, 
    0.16821858f, 0.08387833f, -0.14783132f, -0.41179350f, -0.11980057f, 0.01673811f, 0.01116442f, 0.04797712f, 
    0.11480593f, -0.07802334f, -0.06767692f, 0.08683173f, -0.03456058f, -0.14142102f, -0.12514368f, -0.24340953f, 
    0.01899865f, 0.11894514f, -0.10300028f, 0.36750787f, -0.33920264f, -0.30086115f, 0.16853888f, 0.12744649f, 
    0.04098757f, 0.13362157f, 0.09796899f, -0.00085144f, 0.12986967f, -0.05783672f, -0.40104359f, -0.11202453f, 
    -0.03478559f, 0.02748781f, 0.17062984f, 0.02409587f, 0.01930677f, 0.39326423f, -0.04095027f, -0.12862848f, 
    -0.10783163f, -0.06938644f, -0.00865214f, -0.05386330f, 0.28585103f, 0.15934364f, 0.35178125f, -0.00089459f, 
    0.14474858f, -0.00324280f, -0.15306716f, -0.08099106f, 0.25596380f, 0.10669094f, -0.10432706f, 0.30352083f, 
    0.15795381f, -0.26517975f, -0.05551049f, -0.24535874f, 0.01380028f, 0.00618309f, 0.11780685f, -0.05026200f, 
    0.12251269f, -0.21653351f, -0.11285928f, 0.14404118f, 0.12391573f, 0.15938888f, 0.25261667f, 0.07753056f, 
    0.09518976f, 0.38873148f, -0.00211160f, 0.11628933f, -0.30343047f, -0.01471782f, 0.07003239f, 0.19462578f, 
    0.24403939f, -0.02617751f, -0.18356468f, 0.09293663f, -0.30516571f, -0.08755510f, 0.13452245f, 0.09423210f, 
    0.14036614f, -0.09281332f, -0.04122639f, 0.02665638f, -0.07078914f, -0.31862399f, 0.04979687f, -0.20313822f, 
    0.06274641f, 0.08773468f, -0.01006305f, -0.29454544f, 0.15901481f, 0.00493601f, -0.06606825f, 0.11152238f, 
    -0.11716579f, -0.06622303f, -0.14357944f, -0.02898809f, -0.12751465f, -0.14539188f, 0.05562603f, -0.11203181f, 
    -0.02483889f, 0.22947019f, -0.09590753f, 0.02522763f, -0.07110676f, -0.22971700f, -0.30994079f, 0.18706244f, 
    -0.22672361f, 0.19259760f, -0.00400214f, -0.13655207f, -0.06869133f, 0.31761932f, 0.20658351f, -0.07919104f, 
    -0.07596318f, 0.15935074f, 0.32687798f, 0.13015309f, 0.19703203f, -0.15004084f, 0.22852178f, 0.30472219f, 
    -0.09051225f, -0.13616528f, 0.22391492f, -0.02114297f, -0.09289244f, -0.04656018f, 0.02960516f, -0.30343410f, 
    0.19014816f, -0.08755972f, -0.05050292f, -0.31384116f, -0.11101896f, 0.02914800f, -0.00180550f, 0.02498854f, 
    -0.19007596f, -0.16905804f, 0.15658319f, 0.03593839f, -0.04118389f, -0.16834427f, 0.19117565f, 0.04638589f, 
    0.00274839f, -0.27714223f, -0.07879872f, 0.02287306f, 0.08987895f, -0.15076581f, -0.18850635f, -0.00802090f, 
    0.23276080f, 0.08920951f, 0.17225029f, -0.16980572f, -0.22377810f, -0.03042165f, -0.06631587f, 0.04377711f, 
    -0.30178261f, -0.14273487f, -0.11126526f, 0.18129680f, -0.13192704f, 0.51043028f, -0.06560066f, 0.27725911f, 
    0.31369472f, 0.06313912f, -0.03531835f, 0.10789977f, -0.06621298f, 0.26388347f, -0.00639210f, 0.06071334f, 
    -0.10747571f, 0.02649125f, -0.04461844f, 0.02184078f, -0.01301725f, 0.02205097f, 0.23279849f, -0.16877827f, 
    -0.00682419f, 0.10672402f, 0.12066454f, -0.15155511f, -0.01669490f, -0.21925791f, -0.05304977f, -0.10692682f, 
    0.10293645f, 0.03257034f, 0.18428230f, -0.10956423f, -0.16804355f, -0.04143725f, 0.08676329f, -0.14625260f, 
    -0.17694904f, -0.21944275f, 0.09114198f, 0.02134626f, 0.02904054f, -0.25995949f, -0.08839017f, -0.24414484f, 
    -0.21382745f, 0.19400641f, -0.00971330f, 0.17446640f, 0.13412181f, 0.12259795f, -0.10297537f, -0.25774318f, 
    -0.06553429f, 0.02419174f, -0.03628061f, 0.21841611f, -0.04935167f, -0.05742290f, -0.12138257f, -0.01744593f, 
    -0.25150681f, 0.04486128f, 0.30707455f, 0.00888709f, 0.39892617f, 0.18605419f, -0.05049422f, -0.02052081f, 
    0.09639504f, -0.10206749f, 0.09420834f, 0.09120793f, 0.09034236f, 0.26832917f, -0.28247064f, 0.09061814f, 
    0.11390583f, -0.02507439f, -0.07977045f, 0.00537850f, -0.07269555f, -0.07830568f, -0.02898672f, -0.13778014f, 
    0.01880409f, 0.00636272f, -0.06894822f, 0.19689567f, -0.14939393f, -0.08905463f, -0.16919377f, 0.12472642f, 
    -0.28171957f, -0.37365064f, -0.04569884f, -0.19967446f, 0.14134705f, 0.13928747f, 0.02466778f, 0.36627826f, 
    -0.03854642f, -0.31752923f, -0.19350576f, 0.04305336f, 0.00021474f, 0.28014612f, -0.14472218f, 0.03145561f, 
    0.07322787f, 0.23003814f, 0.04684405f, 0.34252471f, 0.15426709f, 0.05103014f, -0.13408533f, 0.29037353f, 
    -0.01656347f, -0.00960038f, -0.15551470f, 0.02367936f, 0.01056805f, 0.08732565f, 0.12998693f, -0.22212449f, 
    -0.05796559f, -0.02255198f, 0.04347083f, -0.47728407f, -0.23598340f, -0.12155293f, 0.00589526f, -0.08892974f, 
    0.07043899f, -0.00814420f, -0.03239102f, 0.04710064f, -0.54623944f, 0.27640471f, 0.17952101f, 0.15472451f, 
    0.07325995f, 0.13976216f, 0.11598961f, 0.08539278f, 0.00456531f, -0.45224217f, 0.16641797f, 0.21088398f, 
    0.06832773f, 0.12459870f, -0.04076482f, 0.07391604f, -0.13951229f, 0.05457423f, 0.07728909f, 0.08859904f, 
    0.23373623f, -0.18082346f, -0.06756712f, 0.04556061f, 0.15555103f, -0.18264176f, 0.03523993f, -0.40175071f, 
    0.04124180f, 0.26667595f, 0.13699256f, 0.29763955f, -0.17131855f, -0.05426028f, -0.05385626f, -0.18156210f, 
    -0.59227568f, 0.26890936f, -0.01806688f, -0.06847097f, 0.08271329f, 0.26322809f, -0.03568913f, -0.24379982f, 
    -0.05579526f, 0.42511293f, 0.17259935f, 0.12606648f, -0.05520973f, 0.11765455f, -0.18053001f, 0.05152267f, 
    0.06612375f, 0.09957550f, -0.28099513f, -0.00622564f, -0.27724808f, -0.10107110f, 0.05433155f, -0.09858759f, 
    0.20124863f, -0.04279543f, -0.08863230f, -0.09278940f, 0.06474094f, 0.22074386f, 0.03724552f, -0.05459533f, 
    0.03663400f, 0.09556419f, 0.08577661f, 0.03340747f, -0.21946725f, -0.14581475f, 0.08410461f, 0.32821187f, 
    -0.10390274f, -0.02533539f, -0.20721118f, 0.06243239f, 0.27701667f, 0.38579050f, -0.13435259f, -0.06964961f, 
    0.01890881f, 0.04803583f, -0.14320412f, -0.03058773f, 0.02921283f, 0.02444260f, 0.13118637f, -0.48142999f, 
    -0.16760008f, -0.18115981f, 0.10720756f, -0.04839747f, 0.04000235f, -0.01977057f, -0.07531975f, 0.07383849f, 
    0.04622033f, -0.22612244f, 0.04764253f, 0.06418245f, -0.04119585f, 0.05381615f, -0.01703561f, -0.01378427f, 
    0.02922597f, -0.03932183f, 0.14880659f, -0.21692282f, -0.28125763f, -0.10176821f, 0.00545715f, -0.03783377f, 
    -0.00609198f, 0.23584875f, -0.02152246f, -0.05562091f, 0.16613732f, 0.07377723f, 0.03066119f, -0.09813369f, 
    -0.11507975f, -0.03822362f, 0.02193848f, -0.08450558f, 0.02587184f, -0.07943772f, 0.23818558f, 0.08842681f, 
    0.04284049f, 0.05508698f, -0.07721352f, -0.35938576f, 0.00518476f, 0.00533780f, -0.04859368f, 0.11242175f, 
    -0.12417143f, 0.11413395f, -0.04175807f, -0.14327094f, 0.45993245f, 0.08405938f, 0.34245899f, 0.25589612f, 
    0.13624464f, -0.33868352f, 0.01546486f, -0.00719243f, -0.01916929f, -0.27006423f, -0.25095308f, 0.03784983f, 
    -0.01089166f, -0.04639759f, 0.05375427f, -0.03601565f, -0.17250682f, 0.05173153f, 0.16193096f, -0.13088651f, 
    0.09942390f, 0.20309344f, -0.11499012f, -0.04108504f, 0.23300055f, 0.31108886f, 0.02141566f, 0.35450760f, 
    0.05519822f, -0.12227002f, 0.13141692f, 0.01299772f, -0.12205496f, 0.01392111f, 0.04941695f, -0.08940485f, 
    -0.07691672f, -0.48111469f, 0.10034702f, 0.10456305f, 0.07724949f, -0.26196674f, 0.04312795f, 0.06505057f, 
    0.07286239f, -0.69570673f, 0.16840677f, 0.03838808f, 0.27623212f, 0.19209290f, -0.47548649f, 0.04487649f, 
    0.18116052f, 0.23609895f, 0.27248362f, 0.08891955f, 0.12437753f, 0.00763792f, -0.10090869f, 0.31700456f, 
    -0.24997789f, -0.25959963f, 0.04546088f, -0.33516759f, 0.13524158f, 0.06893831f, 0.07043298f, 0.03186182f, 
    -0.21319439f, 0.06075028f, 0.02981547f, -0.07208009f, 0.18078068f, -0.60270405f, 0.19634388f, 0.15720649f, 
    -0.20830929f, -0.11899877f, 0.14355560f, -0.13350913f, -0.00386187f, -0.27731979f, 0.12565126f, -0.15505895f, 
    0.05394732f, 0.03152404f, 0.08446884f, 0.03531687f, -0.03598901f, -0.02744815f, -0.51507914f, 0.18275282f, 
    -0.07811029f, 0.04685122f, 0.19617020f, -0.19139042f, -0.13074939f, -0.05372588f, 0.17660131f, 0.48980409f, 
    -0.19494097f, -0.05544149f, 0.39198381f, 0.17315201f, -0.32567888f, -0.01375351f, -0.04054646f, -0.24841666f, 
    0.25576395f, 0.14920552f, -0.53228492f, 0.30909121f, -0.18548068f, -0.37803027f, -0.03874308f, -0.02131701f, 
    -0.06246814f, 0.37978277f, 0.16429254f, 0.00285065f, -0.03369194f, 0.17371896f, 0.29261324f, -0.12664017f, 
    0.06915440f, 0.09269358f, 0.43886936f, 0.20717825f, -0.11025146f, -0.11754858f, 0.00039440f, 0.29275426f, 
    -0.15460309f, 0.10989571f, 0.07150345f, 0.28545728f, 0.33082303f, 0.00814836f, 0.18289988f, 0.18074372f, 
    -0.05071228f, 0.13555214f, 0.07404001f, 0.02754753f, 0.12856156f, 0.06524456f, 0.28914982f, -0.08398177f, 
    -0.03203598f, -0.22162768f, -0.11189951f, 0.02990604f, -0.00407554f, 0.25822732f, 0.15084568f, 0.02221223f, 
    -0.15927003f, -0.05696140f, 0.10178782f, 0.01608785f, -0.01114573f, 0.01495998f, -0.71196121f, 0.05349730f, 
    -0.23017925f, 0.00745813f, 0.02574168f, 0.09944222f, -0.10896061f, 0.16938430f, -0.02010441f, 0.35429090f, 
    0.01154272f, 0.02951497f, -0.10725067f, 0.18621206f, -0.06723821f, -0.08307885f, 0.16274114f, -0.08440701f, 
    0.27574864f, 0.17099845f, 0.08215761f, -0.15202877f, 0.15844700f, -0.15977415f, -0.00292033f, 0.17066507f, 
    -0.07363810f, -0.60083729f, 0.11839463f, -0.06083937f, -0.02453875f, -0.07244087f, 0.12959412f, -0.23944189f, 
    -0.10137606f, -0.07348169f, -0.12943070f, -0.37537494f, -0.32167238f, -0.15584219f, -0.03071649f, 0.07198788f, 
    0.17980534f, 0.43326804f, 0.17047709f, -0.02031082f, 0.08393338f, 0.17207563f, 0.04106515f, 0.04833622f, 
    0.11752518f, 0.09771094f, 0.07957307f, -0.07325293f, 0.21066104f, -0.19247483f, 0.09335879f, 0.17546654f, 
    -0.00968491f, -0.08850077f, 0.31149328f, -0.02711302f, -0.10819144f, -0.28276119f, -0.43696070f, 0.19243629f, 
    -0.10173579f, -0.03095204f, -0.16408543f, -0.04211687f, 0.20015062f, 0.13413742f, 0.04863404f, 0.17917666f, 
    0.23413654f, -0.05931389f, -0.01007703f, 0.03280724f, 0.14255595f, 0.19245447f, 0.00883092f, 0.21480463f, 
    -0.05028637f, -0.06819984f, 0.12142521f, 0.05299750f, -0.14205568f, 0.02930529f, -0.03622713f, -0.08745357f, 
    -0.27744943f, 0.33053452f, -0.58846909f, 0.16417256f, 0.10453603f, 0.17877465f, 0.06978164f, 0.01042701f, 
    -0.11341652f, 0.66141683f, 0.21368761f, -0.02055025f, -0.08588642f, 0.06349231f, 0.29669356f, 0.02574245f, 
    0.08011338f, 0.00736153f, -0.62154979f, 0.17229146f, -0.13098776f, 0.11289556f, -0.29563111f, -0.02088800f, 
    -0.06580590f, -0.05030495f, -0.16865616f, 0.20912181f, 0.14239870f, -0.05364013f, 0.10711744f, 0.04637056f, 
    0.15116763f, -0.12230305f, 0.18256602f, -0.03546983f, 0.41068846f, -0.09126797f, -0.09840392f, 0.06773061f, 
    -0.19492078f, 0.01007770f, -0.13244152f, 0.30190194f, 0.13133241f, -0.29570094f, 0.05758766f, -0.51271057f, 
    0.23283611f, 0.09696582f, -0.11201621f, -0.08137699f, 0.01845945f, 0.24992825f, -0.17116563f, -0.03673078f, 
    0.02338628f, 0.08603324f, -0.17111506f, 0.17197460f, 0.07081818f, -0.17856044f, 0.04454726f, -0.63865352f, 
    0.08635431f, 0.11047236f, 0.00126923f, -0.11416879f, 0.13239029f, 0.17378742f, 0.03442336f, 0.07302459f, 
    0.45822096f, -0.12718537f, -0.56160033f, 0.06426542f, -0.03768952f, 0.09218271f, -0.12903140f, -0.02307838f, 
    -0.13336498f, -0.68086678f, 0.12212935f, -0.03181434f, 0.08761089f, 0.04118098f, -0.04179811f, -0.11226001f, 
    0.12632897f, 0.01298089f, 0.56644630f, 0.11335552f, -0.11758719f, -0.11273568f, 0.16864341f, -0.00759312f, 
    -0.33458421f, -0.18220553f, -0.32955372f, -0.18341877f, -0.19163972f, -0.09407870f, 0.01055319f, 0.05754640f, 
    0.16938306f, -0.03673473f, 0.05148024f, -0.15701029f, -0.05417901f, -0.31261158f, -1.06473231f, 0.04738250f, 
    0.23471631f, 0.07594725f, -0.22671269f, 0.05087103f, -0.02520400f, 0.65044248f, 0.21814984f, -0.02842504f, 
    0.12383351f, -0.09935479f, -0.16948968f, 0.21359150f, -0.11844366f, 0.18699898f, 0.08030016f, -0.03839266f, 
    0.27479905f, 0.16706371f, -0.24363345f, 0.08745743f, 0.10229494f, 0.13853003f, 0.14741504f, 0.19724888f, 
    -0.04550355f, -0.14794579f, 0.09633366f, -0.07530721f, 0.01550134f, 0.10903018f, -0.00929770f, 0.02680092f, 
    0.13514102f, 0.03552806f, 0.24686076f, -0.06907918f, 0.13965607f, 0.01778306f, 0.07537355f, -0.16405579f, 
    0.02941570f, -0.17669350f, -0.06772627f, -0.41310003f, 0.13645712f, 0.04813778f, -0.00892005f, -0.06088476f, 
    0.07961939f, 0.07464600f, -0.38358614f, -0.00850984f, 0.05661526f, -0.02882740f, -0.03137700f, -0.01097139f, 
    0.02217170f, 0.08156036f, 0.12255497f, -0.11785039f, 0.05385498f, 0.12910722f, -0.04831426f, 0.16065632f, 
    -0.10215559f, 0.11087597f, 0.09110314f, 0.20421167f, -0.14263937f, 0.08841927f, -0.12105462f, -0.08493298f, 
    -0.12416054f, -0.04715896f, -0.04810215f, 0.24586855f, 0.18363415f, 0.00180867f, 0.07100938f, 0.09964406f, 
    0.04542180f, 0.03504848f, 0.04282344f, -0.01248240f, 0.09301544f, 0.01804033f, -0.34327197f, -0.52764791f, 
    -0.15355910f, 0.06047209f, 0.18522935f, 0.04055444f, 0.08237725f, 0.18288672f, 0.18504433f, -0.37922946f, 
    -0.09611262f, -0.02623392f, 0.21178618f, 0.06181119f, 0.13729092f, -0.11214828f, -0.05786002f, -0.16384737f, 
    0.32922831f, 0.04442010f, -0.12730081f, -0.00223846f, -0.03601442f, 0.10908136f, -0.10490257f, 0.06725841f, 
    0.14289677f, -0.64719748f, -0.54160172f, -0.02028793f, 0.02145442f, 0.15318055f, 0.11868811f, -0.05577291f, 
    0.01225237f, -0.09626980f, 0.42997059f, 0.30158970f, -0.08872122f, -0.02094111f, -0.01046285f, -0.01185252f, 
    -0.10993329f, 0.13965160f, 0.28801966f, -0.18798158f, 0.28090784f, -0.11548621f, 0.08408435f, -0.05360658f, 
    0.05361773f, -0.06702551f, -0.00107054f, 0.13041143f, 0.19266783f, -0.11789814f, 0.03909416f, 0.11676082f, 
    -0.01700877f, -0.06764140f, 0.00314612f, -0.05843659f, 0.05304416f, -0.00634096f, -0.02751654f, -0.05591756f, 
    -0.20412838f, -0.19887349f, -0.01249557f, -0.01146928f, -0.18611431f, -0.14582783f, 0.12181959f, 0.20566794f, 
    -0.24009649f, -0.02145195f, -0.02481003f, 0.02339974f, -0.02549720f, -0.10752732f, 0.08364064f, 0.58887428f, 
    0.15479337f, 0.09616455f, -0.03523208f, -0.10921296f, 0.09046154f, -0.17117050f, -0.00454231f, -0.07022749f, 
    0.82384360f, -0.36452517f, 0.16232188f, -0.13853119f, 0.03919482f, -0.01328637f, 0.06388802f, 0.04857676f, 
    -0.05477298f, -0.76166207f, 0.35614270f, -0.09010615f, 0.18976913f, 0.04457930f, 0.01022571f, 0.23363540f, 
    0.20906493f, 0.02632511f, -0.07377056f, -0.60553837f, -0.17650504f, 0.12892851f, -0.12169177f, -0.08173477f, 
    -0.05095808f, 0.12096159f, 0.15403239f, -0.20319223f, -0.12933907f, -0.03936935f, 0.21143179f, -0.00836421f, 
    0.00521127f, -0.18605742f, 0.04450120f, 0.24401231f, -0.11511153f, -0.09667417f, -0.46218276f, -0.01352433f, 
    0.02786396f, -0.18461239f, -0.17341076f, -0.01653169f, 0.15991563f, -0.01238317f, 0.23109673f, 0.32837251f, 
    0.17323565f, -0.14426465f, -0.14314325f, -0.04895826f, -0.00397905f, 0.01482512f, 0.24225640f, -0.25965011f, 
    0.01377084f, -0.06733673f, 0.15945782f, -0.08397239f, 0.05322136f, 0.09436835f, 0.16261663f, -0.01559204f, 
    -0.42852414f, -0.15125997f, -0.05723287f, 0.02435028f, 0.03842455f, -0.15360256f, 0.03863939f, 0.04451697f, 
    -0.05418744f, -0.06788369f, -0.01323959f, -0.06561282f, -0.01870161f, -0.04751919f, 0.03869678f, -0.04026408f, 
    -0.02971976f, 0.01055722f, -0.05650416f, 0.01099860f, 0.01227950f, 0.02053211f, -0.03413865f, -0.06363001f, 
    -0.01245601f, -0.01581565f, -0.01738933f, 0.04942732f, -0.00836522f, -0.02982256f, 0.02699919f, -0.01485153f, 
    -0.03104659f, -0.04964789f, -0.04435679f, 0.02959060f, -0.04337465f, 0.02767456f, -0.03717679f, -0.02990402f, 
    -0.03788002f, -0.02341894f, -0.03941907f, 0.00001410f, -0.00152771f, 0.00165868f, 0.03473943f, -0.06867156f, 
    0.02534967f, -0.02727085f, 0.04780407f, -0.02516979f, 0.00753173f, -0.00240486f, 0.00545485f, 0.02077692f, 
    0.03363299f, -0.02983300f, 0.03199030f, -0.03441717f, 0.04083853f, 0.02335301f, -0.02867902f, -0.05322935f, 
    -0.04645123f, 0.02569765f, 0.01591671f, -0.00362506f, 0.04639771f, -0.05114127f, -0.02985932f, 0.02490157f, 
    -0.05158202f, -0.03433344f, 0.04610982f, 0.00397125f, -0.01697299f, -0.05879834f, -0.01937970f, 0.01386122f, 
    0.04275013f, -0.06343684f, 0.00821654f, -0.03787152f, 0.01338122f, 0.01164985f, -0.01626313f, -0.05158674f, 
    0.03706669f, 0.02142799f, 0.03465085f, 0.02696713f, 0.01560079f, 0.01935719f, -0.05357524f, 0.04475804f, 
    -0.05137608f, -0.04568450f, 0.00026960f, 0.04848190f, 0.00154517f, 0.01495880f, 0.05200566f, -0.05326592f, 
    -0.02678340f, -0.03094612f, -0.00130919f, -0.04347225f, -0.01694450f, 0.00751933f, -0.00381168f, 0.00615097f, 
    -0.02858898f, 0.00719622f, 0.02862426f, 0.00969633f, 0.03340451f, -0.03151137f, -0.01803254f, -0.04551378f, 
    0.01744522f, 0.00975190f, 0.00608729f, -0.02222974f, 0.02898539f, 0.04108377f, 0.03601953f, -0.06321239f, 
    0.01724255f, -0.02071919f, -0.05169270f, -0.03353654f, -0.06955890f, -0.05039482f, -0.06166855f, -0.05051354f, 
    -0.03523361f, 0.02148950f, 0.04219138f, -0.01550567f, -0.02531750f, -0.01525117f, 0.03106383f, -0.01382327f, 
    0.02784845f, -0.03801243f, -0.04103864f, -0.01027027f, 0.02383714f, -0.02768399f, 0.04074064f, -0.00554739f, 
    0.03051788f, -0.05285076f, 0.03643618f, -0.00172071f, -0.02446458f, -0.01180087f, -0.03627567f, 0.00348807f, 
    -0.03557429f, -0.06004126f, -0.04390817f, -0.04004392f, 0.01594732f, 0.05113370f, -0.04993315f, -0.06103747f, 
    -0.02060551f, -0.00001619f, -0.04580715f, -0.01058512f, -0.00863695f, 0.03105473f, -0.04129837f, -0.04454865f, 
    -0.01856603f, -0.05276624f, -0.04361318f, 0.04879842f, 0.03287438f, -0.05149659f, -0.06182299f, 0.02602453f, 
    0.01370369f, -0.06846396f, 0.04451592f, -0.02360317f, -0.01118872f, 0.01294346f, 0.01630693f, -0.04352140f, 
    -0.03295078f, -0.03793991f, -0.01170437f, 0.02145392f, -0.02474673f, -0.00740742f, 0.02409486f, -0.00293711f, 
    0.03688041f, -0.01537402f, -0.04647190f, -0.00352354f, 0.03524728f, -0.07026129f, 0.02812197f, -0.03865540f, 
    -0.03803720f, 0.03104968f, -0.05078856f, 0.03085427f, -0.02425157f, -0.04903802f, 0.00850495f, -0.00261494f, 
    -0.05385671f, -0.00358059f, 0.03823320f, 0.01794364f, -0.00050826f, -0.03576440f, -0.02131839f, -0.00290454f, 
    0.01158799f, -0.01977425f, 0.03111025f, -0.02890099f, -0.04050113f, -0.02541886f, -0.04070110f, 0.04359461f, 
    0.03860514f, -0.00622904f, 0.05088703f, 0.02283817f, 0.03435239f, 0.05084500f, 0.03415807f, 0.03597827f, 
    -0.01389609f, 0.04850045f, 0.00467554f, 0.01665008f, 0.05327827f, -0.04311558f, -0.03409890f, -0.04444700f, 
    -0.04054377f, -0.05470403f, -0.00914239f, -0.02237165f, -0.04531715f, 0.05018251f, -0.00837555f, 0.00592708f, 
    -0.02757949f, -0.04581046f, -0.05630152f, -0.01765788f, 0.01400681f, 0.02200637f, 0.00619672f, 0.00055819f, 
    -0.02194923f, -0.01327119f, -0.01672098f, 0.02838495f, 0.01257853f, 0.00416249f, -0.05506991f, 0.04972688f, 
    -0.05359733f, -0.01934448f, -0.01975394f, -0.04879693f, -0.02528660f, -0.01727030f, 0.03773198f, -0.06119524f, 
    0.01202335f, -0.03592296f, 0.04080694f, -0.01118902f, 0.01851315f, 0.01364896f, -0.06276769f, 0.04084212f, 
    0.03126079f, 0.03248568f, -0.04122410f, 0.00243857f, -0.00698671f, 0.01125959f, 0.04855278f, -0.02061744f, 
    0.35100317f, -0.38789761f, -0.05797063f, -0.07187680f, -0.12899725f, 0.04689158f, -0.20406742f, 0.07151925f, 
    0.05374857f, 0.30638143f, 0.21366011f, 0.15365946f, -0.15617831f, 0.06003944f, -0.07518081f, -0.16595739f, 
    -0.19920394f, 0.18250783f, 0.23866554f, 0.09991949f, 0.01162824f, 0.09192026f, -0.32935545f, 0.06023640f, 
    0.04703142f, 0.08938792f, 0.01216630f, 0.36941504f, 0.05805001f, 0.01194187f, -0.14880499f, -0.00183938f, 
    -0.17193639f, -0.20243812f, -0.08099168f, -0.14270398f, -0.61675191f, -0.30413878f, 0.08464958f, 0.06702416f, 
    0.06282900f, 0.19074056f, -0.23792380f, 0.11982893f, -0.04120396f, 0.15361026f, -0.35590136f, 0.32839471f, 
    -0.06508779f, 0.24036247f, -0.10136175f, -0.14813663f, 0.17018445f, -0.24178244f, -0.02546101f, 0.08191134f, 
    0.25708601f, 0.15728223f, -0.03697654f, -0.00796242f, 0.05221517f, -0.22287406f, 0.08491024f, -0.09096795f, 
    0.26500210f, 0.36597884f, -0.02905018f, 0.08378783f, 0.07566549f, -0.25735506f, 0.01901490f, -0.04754687f, 
    -0.15163381f, 0.22169842f, 0.23304588f, 0.16165631f, 0.23258618f, -0.25669861f, 0.03526968f, 0.09995315f, 
    0.06802934f, 0.40113166f, -0.14001067f, -0.28809482f, -0.34338865f, -0.16552044f, -0.12042625f, -0.08567727f, 
    0.02380802f, 0.05312446f, -0.31916615f, 0.11425535f, -0.44241428f, -0.03170828f, -0.06870087f, -0.04925297f, 
    0.05381026f, -0.04011101f, -0.03764152f, -0.13302679f, 0.13770254f, 0.12676032f, 0.08396588f, -0.08439984f, 
    0.03659420f, 0.03999202f, 0.05904029f, 0.00950323f, 0.29327354f, -0.02708943f, 0.02802033f, -0.14598611f, 
    -0.06137128f, -0.20050253f, -0.03236848f, -0.05845242f, -0.06579093f, -0.21037905f, -0.22312851f, 0.10546811f, 
    -0.13937117f, 0.06755081f, -0.12458034f, -0.04760126f, 0.00430040f, -0.01430073f, -0.12803152f, 0.04715016f, 
    0.14875764f, 0.02772778f, -0.12493234f, 0.02488115f, 0.07793725f, -0.02903638f, -0.11404066f, -0.21493399f, 
    0.05760922f, 0.00729640f, -0.25789255f, 0.01570143f, -0.11419949f, -0.23008920f, 0.04676700f, 0.01174296f, 
    0.02091186f, 0.02503140f, 0.34856766f, 0.02932858f, -0.01036122f, -0.06454735f, 0.11754587f, -0.05692876f, 
    0.15247999f, 0.25311238f, -0.03844289f, -0.08879179f, 0.01705157f, -0.12335595f, -0.00188452f, -0.29829603f, 
    0.12199737f, -0.21040547f, 0.15418294f, -0.03672284f, -0.06482738f, -0.18152371f, -0.17517924f, 0.01088689f, 
    -0.26161757f, 0.20864868f, -0.01910485f, 0.06458935f, -0.01587154f, 0.03421930f, -0.08509862f, -0.07157508f, 
    -0.15473400f, -0.07365090f, -0.14710826f, 0.07973812f, -0.41135466f, -0.01270812f, 0.20478465f, -0.04358198f, 
    -0.02428339f, -0.08719566f, -0.10896336f, 0.00293203f, -0.34950969f, 0.18174607f, -0.07146799f, 0.25924513f, 
    -0.09859381f, 0.05244494f, -0.03731035f, -0.19826236f, 0.30863082f, -0.24634358f, 0.01930312f, -0.26661310f, 
    -0.04131429f, 0.04938895f, 0.23151697f, 0.04760932f, -0.25633386f, 0.07809268f, 0.14208302f, -0.01071091f, 
    0.03230733f, 0.45386246f, 0.18003726f, 0.36095828f, 0.09318326f, 0.06128983f, 0.17140557f, 0.08229384f, 
    0.50978863f, 0.19295855f, 0.49218252f, 0.02460924f, 0.10292360f, -0.29843542f, 0.02527102f, -0.02198519f, 
    -0.23522453f, 0.32818362f, -0.04813832f, -0.25268060f, -0.07979447f, -0.08491918f, -0.14561661f, -0.15154625f, 
    -0.06548741f, -0.06408391f, -0.08389367f, 0.15994264f, 0.23199041f, 0.28329900f, -0.19361295f, -0.23448087f, 
    0.24367352f, -0.01273958f, -0.07766679f, 0.32858312f, 0.02078838f, -0.05571089f, -0.12436007f, -0.08693936f, 
    0.14383291f, -0.40729749f, -0.11198094f, 0.12919419f, -0.22742940f, -0.20397875f, -0.23025849f, -0.17795350f, 
    0.10925879f, 0.16965340f, -0.08393467f, 0.06244227f, 0.01679388f, 0.14166296f, 0.10641716f, 0.45971963f, 
    0.00542289f, 0.35363010f, 0.06526735f, 0.27598000f, 0.13629425f, 0.02729658f, -0.31031278f, 0.00995530f, 
    -0.01769629f, 0.03372301f, -0.13016975f, 0.06141626f, 0.04904696f, 0.05125225f, -0.13763991f, 0.02992702f, 
    0.31791750f, -0.12419523f, 0.08930154f, -0.13583864f, -0.25335297f, -0.10200968f, 0.05094275f, 0.14974432f, 
    0.06266299f, 0.02196163f, -0.44058147f, 0.07889501f, 0.05889928f, -0.04671798f, 0.09238099f, -0.01703973f, 
    0.01864230f, -0.08085951f, -0.14864142f, -0.19840086f, -0.14922033f, 0.06746873f, -0.08147981f, -0.03076969f, 
    0.31160608f, 0.09977542f, -0.12591615f, -0.04675920f, 0.03469937f, -0.01828377f, -0.40924582f, 0.20179446f, 
    -0.23336782f, -0.04736840f, -0.01224541f, -0.04287336f, -0.24627051f, -0.39944389f, 0.18645269f, 0.14335027f, 
    -0.02418458f, 0.06241149f, -0.03859039f, 0.07506492f, -0.21879889f, 0.07124642f, -0.08237099f, 0.12009807f, 
    0.04515037f, 0.03079785f, 0.04304701f, 0.04337889f, 0.17975025f, -0.02250361f, -0.18901558f, -0.15889733f, 
    0.10989842f, 0.04320081f, 0.01246794f, 0.29110622f, -0.15047628f, 0.06186616f, 0.48830134f, 0.26746157f, 
    0.10634429f, 0.04280930f, 0.03721137f, -0.14935942f, -0.16608070f, 0.09823678f, -0.03969976f, -0.14138195f, 
    0.06760138f, -0.17791413f, -0.20472685f, 0.07839188f, -0.02562929f, 0.09743614f, 0.18114157f, -0.09966096f, 
    -0.10255056f, -0.19890395f, -0.07293027f, 0.17781864f, -0.04559087f, -0.02137855f, 0.04839879f, -0.07060592f, 
    -0.08605032f, -0.04315005f, 0.33859885f, 0.09215025f, -0.13654289f, 0.07944445f, 0.15832111f, 0.10639341f, 
    -0.09284317f, 0.36213806f, 0.01787482f, 0.27195579f, 0.23467100f, -0.41501552f, 0.01329694f, -0.05459224f, 
    0.32755113f, 0.04843196f, 0.23753689f, -0.18444090f, 0.05922078f, 0.42253512f, -0.00187150f, 0.05760785f, 
    -0.14355996f, 0.12465649f, -0.14615873f, -0.09470514f, 0.07830389f, 0.26183698f, 0.19122446f, 0.31258801f, 
    0.15429242f, 0.09947808f, -0.04228322f, 0.31131047f, 0.11455406f, -0.14812082f, 0.18271817f, 0.47752890f, 
    -0.03649583f, 0.15020820f, 0.01580963f, 0.07004587f, -0.06748094f, -0.10851513f, 0.09721598f, 0.06073502f, 
    -0.02658457f, 0.29614434f, 0.29456657f, -0.07310263f, 0.09613949f, 0.10368412f, -0.09097988f, -0.18432146f, 
    0.11420155f, 0.34711251f, -0.00438721f, 0.04438844f, 0.10085384f, -0.19252869f, -0.01972559f, 0.14482854f, 
    -0.22969873f, 0.16297580f, 0.13811207f, -0.07485408f, 0.07786716f, 0.06571781f, 0.05732716f, 0.09427136f, 
    -0.22623508f, 0.07132110f, -0.27143738f, -0.27966130f, 0.15641315f, -0.09871812f, -0.06482634f, 0.02958923f, 
    0.02975315f, 0.13474032f, 0.01506907f, 0.25760931f, 0.10525045f, -0.09308209f, -0.15517244f, 0.06017131f, 
    -0.09609818f, -0.07823555f, 0.00678441f, 0.31950140f, 0.25748882f, 0.24005042f, 0.33104986f, 0.31864762f, 
    -0.09902845f, -0.01361760f, 0.05930206f, 0.06039048f, -0.99221218f, -0.22053704f, 0.23779313f, 0.01622965f, 
    0.02726942f, 0.23018351f, 0.18071833f, -0.14373456f, 0.05058023f, -0.35001993f, -0.21924008f, -0.37483844f, 
    -0.24135017f, -0.01158683f, -0.22878426f, -0.14650077f, -0.00042435f, -0.02302131f, 0.49191731f, -0.18475880f, 
    -0.77826536f, -0.03230685f, -0.02735195f, -0.19411725f, -0.13923556f, -0.02336528f, -0.04544229f, -0.50865692f, 
    -0.22299230f, -0.64950979f, 0.26441425f, 0.17022873f, 0.03725199f, 0.09281243f, -0.36599004f, -0.09313162f, 
    -0.62778258f, 0.06549453f, -0.28311780f, 0.36167225f, -0.05814032f, 0.21626598f, 0.00223794f, -0.24698590f, 
    0.17859247f, -0.56766170f, -0.05564188f, -0.50356305f, -0.09599012f, 0.09068379f, 0.32604471f, 0.19121176f, 
    0.06706139f, -0.28683239f, -0.35027260f, -0.00574131f, -0.40713391f, 0.01923699f, 0.38380316f, 0.19987616f, 
    0.27199110f, 0.13877609f, -0.05685556f, -0.15107363f, 0.31726173f, 0.12921801f, -0.11409654f, 0.04339393f, 
    0.22887048f, 0.11890129f, 0.08585250f, 0.18375809f, 0.20609622f, 0.29509732f, 0.19206217f, -0.12443487f, 
    0.09097256f, 0.08286563f, -0.10235445f, 0.24475476f, 0.29444024f, -0.40108940f, 0.01529889f, 0.18174368f, 
    0.21802548f, 0.26404876f, -0.39966395f, -0.18486010f, -0.01873034f, 0.06050816f, 0.02653124f, -0.23674478f, 
    0.07960865f, -0.04039428f, -0.04687220f, -0.21691827f, 0.10001501f, 0.17417289f, 0.01612849f, -0.44590139f, 
    -0.15356319f, 0.11553766f, 0.16054463f, 0.17039865f, -0.08654080f, 0.11695486f, -0.16398810f, -0.02269143f, 
    -0.06037995f, -0.04112616f, -0.04991889f, -0.02721603f, 0.03777594f, -0.04295456f, 0.03473083f, 0.00311618f, 
    0.02984578f, -0.04940329f, 0.01649568f, 0.03719189f, 0.04200977f, -0.00498339f, 0.03291144f, -0.01785469f, 
    0.00387630f, 0.00701664f, -0.05133071f, 0.04222957f, 0.05709013f, 0.02457683f, -0.05530830f, -0.03529767f, 
    -0.02852270f, -0.03978815f, -0.05016501f, -0.00573827f, 0.03644633f, -0.02732307f, 0.01585094f, 0.06870188f, 
    -0.00609745f, -0.05934980f, -0.03263249f, 0.02130842f, -0.01342728f, 0.03706936f, -0.02500829f, -0.03508999f, 
    -0.03886662f, -0.06088694f, -0.05110637f, 0.05141381f, -0.00605008f, 0.04577575f, 0.00474056f, 0.03835355f, 
    -0.02457409f, -0.06389971f, -0.03606085f, -0.00327840f, 0.00068405f, -0.03011311f, 0.04905916f, -0.04418484f, 
    -0.04207056f, -0.00016352f, -0.01483006f, -0.02807886f, -0.05300585f, -0.05054432f, 0.02501449f, 0.03818513f, 
    0.02192715f, 0.03076303f, 0.04017936f, -0.02434934f, -0.05996389f, -0.05375580f, -0.05697950f, -0.03186802f, 
    -0.03009314f, -0.05437951f, 0.05169624f, -0.02928650f, 0.01019735f, -0.00832544f, -0.06181127f, -0.03396557f, 
    -0.03855431f, 0.00071603f, 0.04215006f, 0.00871876f, -0.00698268f, 0.02078270f, 0.02474459f, -0.04946784f, 
    -0.05417097f, -0.02888062f, -0.01554603f, 0.04158042f, -0.03809367f, 0.02811078f, -0.04433168f, 0.03823391f, 
    0.02855769f, -0.00436709f, -0.06359643f, -0.02764822f, -0.06702826f, -0.03603881f, 0.01311748f, -0.06042477f, 
    -0.06598911f, -0.01821806f, 0.03295774f, 0.01867910f, -0.04144035f, -0.03870837f, 0.02298072f, 0.03599915f, 
    0.03239696f, 0.03877515f, -0.02298768f, -0.03149636f, 0.00315260f, 0.00684387f, -0.03892959f, 0.04446949f, 
    0.04016359f, 0.03394365f, 0.03858298f, 0.04870826f, -0.00814888f, -0.04990206f, -0.02008818f, 0.05838903f, 
    -0.03688641f, 0.00504175f, -0.04688879f, 0.01156281f, 0.02899437f, -0.05382744f, 0.00503640f, 0.04848083f, 
    -0.02561985f, -0.02736655f, 0.02842791f, -0.05571431f, -0.00456649f, -0.03911587f, 0.00016593f, 0.02741587f, 
    -0.00654449f, 0.02337907f, 0.00003563f, -0.05120406f, -0.05821038f, -0.01068525f, -0.02258592f, -0.05227740f, 
    -0.02207520f, -0.06391296f, 0.01006405f, -0.02662828f, -0.02211327f, -0.05669739f, -0.00029385f, -0.00458257f, 
    0.04377257f, -0.05277568f, -0.00679298f, 0.03470667f, 0.04174692f, 0.01995279f, 0.03148926f, -0.03277932f, 
    -0.03027844f, -0.03600100f, -0.01824911f, -0.03112077f, -0.02641750f, -0.02892439f, 0.01337641f, -0.05342452f, 
    -0.03117212f, -0.03628356f, 0.04792987f, -0.04276551f, 0.00711322f, 0.00060938f, -0.00329090f, -0.02398588f, 
    -0.03348109f, 0.01590145f, 0.03308048f, 0.03202885f, -0.03507305f, 0.03826723f, -0.05103225f, -0.03006055f, 
    0.00211274f, 0.02158075f, -0.03676475f, -0.05691517f, 0.02536691f, 0.00996433f, 0.03030157f, -0.05571825f, 
    0.00726733f, -0.00209961f, -0.05920107f, 0.01608798f, -0.03333499f, -0.02725062f, -0.00483615f, 0.05216243f, 
    0.00319732f, -0.02861131f, -0.04288420f, -0.04302161f, -0.05532418f, 0.04312139f, -0.05162867f, 0.02846668f, 
    0.04215259f, -0.04279633f, 0.04285542f, -0.02495689f, 0.02512247f, 0.03464029f, 0.01544316f, 0.05361297f, 
    -0.02308445f, 0.01367152f, -0.01902721f, 0.02721493f, -0.06253483f, -0.00160119f, 0.03788845f, 0.02473919f, 
    -0.05030908f, -0.05758926f, -0.00504010f, -0.01339850f, 0.02714755f, 0.02453142f, 0.01890003f, -0.05126900f, 
    0.00051450f, 0.03175361f, -0.03645843f, -0.04360345f, -0.05790856f, 0.03851766f, -0.05686736f, 0.00342451f, 
    -0.00548459f, -0.00824769f, -0.03338818f, -0.04325689f, 0.03231667f, -0.04608625f, -0.05568459f, 0.02945546f, 
    -0.00741418f, 0.02497363f, -0.04310013f, 0.05200031f, -0.01842337f, 0.00082347f, -0.02114014f, -0.03657683f, 
    -0.01918107f, -0.05809277f, -0.05873741f, 0.04502652f, -0.02264042f, -0.00107651f, 0.01448351f, -0.05132685f, 
    0.03446829f, -0.02552512f, -0.04674543f, 0.00483182f, -0.00827183f, 0.02186607f, 0.04108137f, -0.02725919f, 
    -0.01430563f, -0.02237732f, -0.01072182f, 0.03804929f, 0.04044123f, 0.00409866f, -0.01616339f, 0.01441328f, 
    -0.06866123f, -0.04266736f, 0.00780758f, 0.00127960f, 0.00013284f, -0.06515484f, 0.02637679f, 0.03231649f, 
    -0.00239191f, 0.02653220f, -0.04913917f, -0.06524548f, -0.04789960f, 0.02798244f, 0.02384563f, -0.06701242f, 
    0.00964194f, -0.01072831f, -0.00556555f, -0.01364432f, -0.00545454f, -0.06044275f, 0.00004785f, -0.01296135f, 
    0.02652239f, -0.04397156f, -0.05420610f, 0.02220821f, 0.02499004f, -0.02917067f, 0.00409763f, 0.00435709f, 
    -0.03887138f, -0.02438550f, 0.01587314f, 0.04309231f, -0.04498374f, 0.03165822f, -0.06345530f, -0.03849917f, 
    0.00398466f, -0.05676445f, -0.03929840f, -0.03046471f, 0.00770103f, -0.05079345f, 0.02486120f, 0.02011350f, 
    -0.05870608f, -0.02671323f, 0.00026604f, 0.02211509f, -0.03273953f, -0.04689581f, -0.04678945f, -0.00997413f, 
    0.00045786f, -0.00946533f, -0.00953741f, 0.03248762f, -0.03088565f, -0.00411840f, -0.05155263f, 0.04575741f, 
    -0.05783383f, 0.01612700f, 0.02825287f, -0.01283249f, 0.01085465f, -0.01445154f, -0.00618836f, 0.03579780f, 
    0.04662789f, -0.04399142f, -0.04904297f, -0.02570811f, -0.03709318f, -0.00648109f, -0.04769741f, 0.02837766f, 
    -0.00401053f, -0.00429453f, 0.01185119f, -0.00393049f, -0.06590156f, 0.03981616f, -0.05517297f, 0.01599895f, 
    0.02208109f, -0.00986360f, -0.03229513f, -0.05791143f, -0.04981702f, -0.06289437f, 0.00354778f, -0.01786160f, 
    -0.05066134f, -0.00479147f, -0.04318849f, -0.02398817f, 0.04910854f, -0.02888804f, 0.04375388f, 0.02246262f, 
    -0.05032254f, 0.02560849f, -0.05493636f, -0.03689890f, -0.06244872f, 0.01965859f, 0.02233727f, 0.01802960f, 
    -0.06224097f, -0.03292232f, -0.05388036f, -0.01545998f, -0.05514975f, -0.00366953f, 0.02474272f, -0.05643373f, 
    0.02120999f, 0.03188723f, -0.04976247f, -0.03803689f, -0.06628492f, 0.00332914f, -0.00838103f, -0.03489968f, 
    -0.03619310f, -0.00684506f, 0.01061110f, -0.00062894f, -0.02417840f, -0.05559643f, -0.00779731f, -0.01851145f, 
    0.00409057f, -0.06101247f, 0.03534023f, 0.03101137f, -0.01576442f, -0.00336293f, -0.06391319f, -0.02017191f, 
    0.02095909f, -0.01605745f, -0.04603288f, -0.03451618f, 0.00576343f, -0.02783643f, -0.04024921f, -0.05848407f, 
    -0.02572072f, -0.04801535f, 0.03220931f, -0.01832800f, -0.00206054f, -0.03491436f, -0.03531340f, 0.00970137f, 
    0.03576080f, 0.00095151f, -0.02139437f, 0.02369509f, -0.01194292f, -0.03691452f, 0.00940300f, 0.00600011f, 
    -0.02974325f, 0.02138000f, -0.04424706f, 0.04919102f, 0.04046801f, 0.04321824f, 0.03893552f, -0.00115042f, 
    -0.04295566f, 0.04061043f, 0.01036884f, 0.03660402f, 0.00237702f, 0.02048000f, -0.02828426f, 0.02543667f, 
    -0.05196599f, 0.00496142f, 0.02919297f, 0.00364209f, -0.05862967f, -0.05544154f, -0.02078592f, -0.02673742f, 
    0.01114945f, -0.05100474f, -0.04415248f, 0.00727126f, -0.05375326f, -0.02952868f, -0.05540908f, -0.01143781f, 
    0.04304558f, 0.03930993f, -0.03263424f, -0.02102542f, -0.01091516f, -0.06176723f, -0.00486296f, -0.02097966f, 
    -0.01759048f, 0.04624600f, 0.01498918f, -0.01001211f, 0.04491574f, 0.01343916f, -0.02596983f, 0.00565003f, 
    -0.01906005f, -0.06506100f, -0.04137716f, -0.01986231f, 0.02283183f, 0.03674971f, -0.03588824f, -0.01929039f, 
    -0.06683563f, -0.01249429f, -0.03269923f, -0.01491774f, -0.07335474f, 0.02486978f, -0.05067297f, -0.04180743f, 
    0.04280059f, 0.00038236f, -0.01259825f, -0.01613845f, -0.00417995f, 0.04815254f, 0.01914608f, 0.01375379f, 
    -0.06539354f, -0.02140732f, 0.01853025f, -0.05272128f, -0.00169099f, 0.03932053f, -0.01853747f, 0.01197802f, 
    0.00535343f, 0.04178777f, -0.02172411f, 0.00331243f, 0.02506366f, 0.03694098f, 0.02554439f, 0.03072357f, 
    -0.02601148f, -0.05082013f, 0.03168912f, -0.00599755f, -0.01549334f, 0.01663735f, -0.06274644f, -0.02627785f, 
    -0.01440851f, -0.02085407f, -0.03668782f, 0.01175574f, -0.01311019f, -0.04955228f, 0.03599584f, -0.02116655f, 
    0.00155792f, 0.00123470f, 0.00591175f, 0.01618752f, 0.02692476f, -0.00742710f, -0.02565044f, 0.00437235f, 
    -0.04777715f, 0.02471315f, -0.02631776f, -0.01772800f, 0.03824464f, 0.04072364f, -0.06482509f, -0.06914271f, 
    0.02090525f, -0.04537246f, -0.02532546f, -0.03698677f, 0.00627834f, 0.05386181f, -0.02812504f, 0.04888654f, 
    0.01352628f, -0.04951850f, -0.03776096f, -0.01394234f, -0.02595015f, 0.01808005f, 0.01901580f, 0.06021918f, 
    0.00690054f, -0.02765685f, 0.02075161f, -0.03146200f, -0.05897285f, 0.03246490f, 0.03636326f, 0.03468049f, 
    0.02196558f, -0.03886912f, -0.05344919f, -0.04995601f, -0.04127514f, -0.04859415f, 0.00543862f, -0.04383494f, 
    -0.00983364f, -0.02633731f, -0.03295960f, 0.05143015f, -0.03863901f, -0.02849169f, 0.00638821f, -0.02210312f, 
    -0.03062730f, -0.05657541f, -0.04579786f, -0.00066557f, -0.00135712f, 0.01470296f, -0.01561806f, 0.01018741f, 
    -0.03194112f, 0.02258329f, 0.04814059f, -0.05918620f, 0.03218927f, -0.05308804f, -0.01581540f, -0.03089200f, 
    0.03795813f, -0.00714072f, -0.03859332f, 0.01487469f, -0.03140587f, 0.00994599f, -0.02179205f, 0.03002649f, 
    -0.00212654f, -0.06125066f, -0.02228796f, -0.01580767f, -0.01117206f, -0.01415693f, 0.03196885f, -0.02198278f, 
    -0.03643167f, -0.02242824f, -0.04205227f, -0.01214267f, -0.00051217f, 0.01389035f, 0.00948220f, 0.04403419f, 
    0.02296712f, -0.03505357f, 0.00875383f, -0.03814837f, 0.00549021f, -0.04223369f, 0.04077235f, -0.06053558f, 
    -0.01542662f, 0.03164054f, -0.05942731f, -0.05355691f, -0.02573502f, 0.01640210f, -0.05287556f, 0.04905830f, 
    -0.00653242f, -0.00808744f, 0.03736136f, -0.03338319f, 0.04193424f, 0.03439826f, 0.03397363f, 0.02656353f, 
    -0.04356379f, 0.05182357f, 0.01923946f, -0.03875615f, 0.01066241f, -0.03331930f, 0.04202751f, 0.00110129f, 
    -0.01520257f, 0.04644613f, -0.04357793f, 0.02590939f, -0.05282976f, -0.06192260f, -0.05713942f, 0.00787078f, 
    0.05759753f, 0.01218659f, -0.00049286f, -0.03434825f, 0.03486225f, 0.03966076f, 0.05272979f, -0.04362109f, 
    0.02275371f, -0.03372574f, 0.05081729f, -0.05955685f, 0.01420362f, 0.04067111f, 0.01965109f, -0.03072283f, 
    -0.01708233f, -0.00556005f, 0.00559501f, 0.05247600f, -0.03464785f, -0.01155500f, -0.01367558f, -0.02565698f, 
    0.00804127f, 0.04493616f, -0.05808106f, 0.02029098f, -0.02657849f, -0.00262836f, 0.00316045f, 0.03638228f, 
    0.02346211f, -0.04706664f, 0.02303299f, -0.01950363f, 0.03588761f, 0.03807513f, -0.00514723f, 0.01046847f, 
    0.03218504f, 0.03176307f, -0.06361042f, 0.02156287f, 0.01693691f, -0.03021182f, -0.03543271f, -0.00717307f, 
    -0.03248817f, -0.06517906f, -0.02705300f, -0.04426821f, -0.01904950f, -0.00811174f, 0.04893310f, -0.03656567f, 
    -0.00032447f, 0.00644991f, -0.04566704f, 0.02630002f, -0.06113647f, -0.00646955f, -0.00768264f, 0.00212584f, 
    0.03242232f, -0.06223235f, 0.05027289f, 0.02194582f, -0.00192197f, 0.02638254f, -0.02416932f, -0.05183399f, 
    0.01296484f, 0.04042129f, -0.02997802f, 0.05019326f, -0.00983686f, -0.01055642f, -0.06006020f, 0.02233905f, 
    0.01892216f, -0.00691761f, 0.04253681f, 0.04946614f, -0.01476002f, 0.03569027f, -0.01629458f, -0.05610035f, 
    -0.00828898f, 0.02475948f, -0.00222598f, -0.01470252f, -0.02658573f, -0.04251094f, 0.04183593f, -0.03199815f, 
    0.04641963f, 0.00861480f, 0.03135737f, -0.00262772f, -0.02075719f, 0.01172472f, -0.04873995f, -0.03936063f, 
    -0.00806118f, 0.01124889f, -0.00623766f, -0.03046826f, -0.01656711f, -0.02480765f, -0.03317004f, 0.00193186f, 
    0.05025729f, 0.03380346f, -0.04269845f, 0.02291561f, 0.02137910f, -0.00890039f, -0.02293454f, 0.04892209f, 
    0.05311791f, 0.02485041f, -0.06039087f, 0.03177516f, -0.01213877f, 0.03536641f, -0.05571310f, -0.02000399f, 
    -0.01557548f, -0.02988222f, -0.01010018f, -0.02393260f, 0.05689220f, 0.02220788f, 0.00000777f, -0.06046489f, 
    -0.05527453f, -0.04096910f, -0.01343253f, 0.01893550f, 0.00874315f, 0.04839050f, 0.01050203f, -0.01713439f, 
    -0.03368493f, 0.00234959f, -0.03161853f, 0.06281216f, 0.00468086f, -0.01832494f, -0.00271527f, 0.00712554f, 
    0.01496507f, -0.02302622f, -0.04848234f, -0.05928610f, -0.04036305f, 0.02388419f, 0.00042785f, 0.04209096f, 
    0.03798916f, -0.05128731f, -0.01113102f, -0.00924965f, 0.04228632f, -0.00011437f, -0.04783208f, -0.02206629f, 
    -0.87014163f, -0.26869270f, -0.20607203f, -0.00662061f, -0.02127577f, -0.16812117f, 0.06176305f, 0.06704575f, 
    0.18100147f, -0.25145629f, -0.08977602f, -0.17952162f, -0.07273150f, 0.05462914f, -0.19146691f, 0.00191778f, 
    -0.08005003f, -0.00503882f, 0.28080261f, -0.39184964f, -0.41849378f, 0.03878264f, -0.05239314f, 0.01347932f, 
    0.16241223f, 0.00494526f, 0.03280452f, -0.66729903f, -0.27694368f, 0.49142060f, -0.12456493f, 0.37677670f, 
    0.00299759f, 0.01040053f, 0.05769990f, -0.03363468f, 0.26928404f, -0.12733440f, -0.47804341f, 0.12986675f, 
    0.17045890f, 0.17483902f, 0.17557514f, 0.07771734f, -0.05629871f, 0.78530884f, 0.04405460f, -0.35031226f, 
    0.16403976f, 0.04784820f, -0.04701854f, 0.10308501f, 0.02378803f, -0.08381359f, 0.04753149f, -0.14471996f, 
    0.21628505f, -0.11965009f, 0.34169921f, 0.12442538f, -0.05167881f, 0.05246352f, 0.32939419f, 0.28734958f, 
    0.12130637f, 0.18764101f, -0.20033973f, 0.12076919f, -0.05968764f, 0.17802694f, 0.14531426f, -0.19621815f, 
    0.44845891f, -0.09240230f, -0.16085115f, 0.06293054f, 0.01155716f, 0.01129114f, 0.13168053f, 0.17029867f, 
    -0.04278037f, 0.04919234f, -0.21719018f, -0.13029231f, -0.07880881f, -0.08322097f, -0.04640918f, 0.07441950f, 
    0.22289312f, 0.18938740f, -0.36936292f, -0.15498126f, 0.12885407f, -0.24025866f, -0.12852213f, 0.08527811f, 
    0.15189132f, -0.06389631f, 0.27333906f, -0.54388553f, 0.09116887f, 0.38380390f, 0.10074919f, 0.08439066f, 
    -0.11958577f, 0.18915628f, -0.23271488f, -0.18362772f, 0.11714309f, 0.27689624f, 0.04277003f, 0.00610540f, 
    0.05132265f, 0.05103022f, 0.02291399f, -0.03141145f, -0.10381110f, 0.00475728f, 0.05350978f, 0.14816797f, 
    -0.17557544f, -0.05783990f, 0.04531620f, -0.06460065f, 0.07521610f, 0.08886665f, -0.30783251f, -0.06396510f, 
    0.17255895f, -0.05242318f, 0.09721076f, 0.12419321f, -0.17396902f, -0.04854438f, 0.10964936f, 0.25504166f, 
    0.02784318f, -0.12939912f, -0.17491952f, -0.10903271f, 0.08485217f, 0.09872438f, -0.04328860f, -0.07786611f, 
    0.04692603f, -0.14530768f, -0.06311154f, 0.00295074f, 0.12893857f, 0.05174059f, -0.05623710f, -0.06678244f, 
    -0.04065011f, -0.12932086f, -0.43693024f, 0.22677864f, 0.08257498f, 0.29236820f, -0.10806894f, -0.22253820f, 
    0.21861243f, 0.27208805f, -0.32676098f, 0.08579454f, -0.51668113f, -0.23288818f, -0.18998422f, -0.15490952f, 
    -0.07821348f, 0.06591009f, 0.27250180f, -0.11409976f, 0.17280445f, -0.05865569f, -0.06546219f, 0.04059090f, 
    0.08619218f, 0.20850772f, 0.02016778f, 0.12701686f, 0.66552943f, -0.41980311f, -0.08319065f, -0.05523078f, 
    0.20149218f, 0.02649383f, -0.11841347f, 0.21723126f, -0.13037239f, -0.32437918f, -0.63406682f, 0.15136723f, 
    -0.12050816f, 0.08251090f, -0.10641240f, 0.13584696f, -0.27909622f, -0.01900107f, -0.47822791f, 0.49014661f, 
    0.11132086f, 0.26221412f, -0.13265784f, -0.12772025f, -0.07083321f, -0.12575276f, 0.09805764f, 0.42725137f, 
    0.33328372f, -0.16243978f, 0.07409233f, 0.00117587f, -0.04919727f, 0.25015825f, 0.04794596f, 0.10830975f, 
    -0.35935050f, -0.56000262f, 0.42642587f, -0.02155363f, 0.44156119f, 0.18112218f, 0.14921255f, 0.03027526f, 
    -0.15898515f, 0.27582851f, 0.13487962f, 0.21905902f, -0.00475187f, 0.31849581f, 0.06272062f, -0.00994045f, 
    0.04263298f, -0.10951420f, -0.03862619f, 0.04070278f, -0.27426440f, 0.10341112f, -0.12206309f, 0.29109249f, 
    0.02138442f, 0.02270032f, 0.13138685f, -0.15289932f, -0.11437876f, -0.00002388f, -0.09066544f, -0.01566916f, 
    0.06254240f, 0.06805130f, 0.05162336f, 0.08558902f, -0.04570447f, -0.05640897f, -0.17303871f, -0.30622739f, 
    -0.00424063f, -0.02761629f, 0.10106613f, 0.02578108f, 0.07258233f, 0.40283865f, 0.04430081f, -0.22337641f, 
    0.20974244f, -0.09787092f, -0.03664184f, 0.14589232f, -0.07770749f, 0.05349408f, 0.10560099f, 0.11705206f, 
    0.43451649f, -0.05744672f, 0.03731318f, 0.04933470f, 0.04356893f, 0.24699786f, 0.14366911f, -0.09777436f, 
    -1.03202820f, -0.18063109f, -0.38019693f, -0.08664078f, -0.06343135f, -0.25448164f, 0.08482289f, -0.13599998f, 
    -0.24427161f, 0.08489804f, -0.27771229f, 0.20358929f, 0.01672120f, -0.06805895f, -0.11035173f, -0.16386959f, 
    -0.05254268f, -0.09498349f, 0.11437745f, 0.07749966f, 0.02815726f, -0.03153234f, 0.10446874f, 0.06780384f, 
    -0.12929398f, -0.13746895f, 0.09323142f, -0.04942033f, -0.31538185f, -0.04725745f, -0.21745291f, -0.03189984f, 
    0.07098229f, 0.04662937f, 0.15408963f, 0.05502513f, 0.23384854f, 0.15031728f, 0.23242490f, -0.07128031f, 
    -0.16040772f, 0.03730520f, 0.01888272f, -0.20845142f, -0.54992205f, 0.02104191f, -0.31786484f, 0.20418809f, 
    -0.08285340f, -0.03177026f, -0.05782376f, 0.19588704f, -0.00451354f, 0.02975668f, -0.19855915f, 0.25977203f, 
    -0.18252333f, -0.00410350f, 0.24846931f, -0.21708843f, 0.03885847f, -0.17336576f, -0.05498285f, 0.25296223f, 
    0.02400480f, 0.12251654f, 0.19235925f, -0.06115839f, -0.02561308f, -0.12505277f, -0.01289992f, -0.40406886f, 
    -0.33588341f, 0.04478755f, -0.08062583f, -0.06156140f, 0.05691358f, 0.01985310f, 0.09874738f, 0.36954653f, 
    0.03951775f, 0.05935751f, 0.29898667f, 0.04524006f, 0.12062465f, 0.17286357f, -0.07381774f, 0.15660882f, 
    0.09408057f, -0.07055144f, -0.02617661f, -0.44300142f, 0.36363506f, 0.07617283f, -0.19040610f, 0.25798580f, 
    0.04218886f, 0.05760582f, 0.25706887f, 0.21024792f, -0.39262316f, 0.05712960f, 0.11404446f, -0.09187690f, 
    0.04684041f, 0.06297566f, -0.35421565f, 0.32505777f, 0.10941333f, -0.49377000f, 0.08691999f, -0.05466519f, 
    -0.06733108f, -0.07172564f, -0.05426780f, 0.03094662f, -0.00045850f, 0.27607143f, 0.18303347f, -0.01848940f, 
    0.14306910f, -0.21826543f, -0.12026476f, 0.04715285f, -0.08773784f, -0.00057959f, 0.26089311f, -0.00266036f, 
    -0.09439690f, -0.14703795f, -0.07100746f, -0.03331903f, -0.07891617f, -0.05604256f, -0.12463313f, 0.13249706f, 
    0.30376992f, 0.17665756f, 0.03998458f, 0.06846183f, -0.10021380f, -0.11267485f, 0.04645934f, -0.34288120f, 
    0.23648077f, -0.13461523f, 0.11063257f, -0.07021493f, -0.09352177f, -0.01354181f, -0.07701940f, -0.13667770f, 
    0.26305559f, 0.05333477f, 0.20060790f, -0.07776976f, 0.12042014f, -0.07156747f, -0.16893260f, -0.01064555f, 
    0.24675687f, 0.54520798f, 0.04486986f, -0.00115568f, -0.16161785f, 0.02862498f, -0.02002311f, -0.08497497f, 
    -0.05016972f, 0.11852049f, -0.05124085f, -0.17133619f, 0.18006839f, -0.13448691f, -0.06384729f, 0.09215139f, 
    0.20004587f, 0.11997664f, -0.08168773f, -0.05428911f, 0.15859714f, 0.13181742f, 0.24473222f, -0.00197268f, 
    -0.05939893f, -0.00750952f, -0.06904748f, -0.07424591f, -0.15815850f, -0.15597285f, 0.09438830f, 0.10509225f, 
    -0.04870184f, -0.04646556f, 0.12899463f, 0.09601304f, 0.08697463f, 0.23258844f, 0.00634975f, 0.28177580f, 
    -0.08892792f, 0.12429974f, 0.06108399f, 0.01663244f, -0.00525690f, -0.02479568f, 0.03270661f, 0.16183013f, 
    0.19531520f, -0.00343799f, 0.00423091f, -0.28414762f, -0.11580960f, 0.01121731f, 0.08156444f, 0.00996124f, 
    -0.33692002f, 0.42335483f, -0.04995922f, -0.08690979f, -0.13772185f, -0.15756147f, -0.04257936f, 0.06191576f, 
    -0.12654637f, 0.25141439f, 0.11599071f, 0.11989179f, 0.05953326f, -0.15159948f, -0.18582429f, 0.01649920f, 
    0.13925669f, 0.43227005f, -0.36077777f, -0.20141278f, -0.11889393f, 0.32802969f, 0.04756540f, -0.03711302f, 
    0.12724999f, -0.12124273f, -0.46635053f, -0.03541657f, 0.10333040f, 0.19894800f, -0.13957630f, 0.14004667f, 
    0.22393812f, -0.02218905f, 0.07108795f, 0.13496709f, -0.05469808f, 0.16633384f, -0.06162001f, 0.02942182f, 
    0.18582535f, 0.12628685f, 0.11976544f, 0.17807664f, -0.44042638f, 0.16155641f, -0.71806979f, 0.19050132f, 
    0.02795378f, 0.02454168f, -0.04392426f, 0.16453840f, 0.19950052f, -0.18921667f, 0.03682958f, 0.40900433f, 
    0.03297275f, -0.12941596f, 0.16259705f, -0.27428254f, -0.06680926f, 0.03960367f, 0.13966654f, -0.01152793f, 
    -0.43532115f, -0.37609351f, -0.19207042f, 0.14378546f, 0.02385923f, 0.06975310f, -0.03201106f, -0.18855134f, 
    0.38466325f, -0.67852408f, -0.26624614f, -0.15931086f, 0.00494814f, 0.04231995f, -0.01745776f, 0.10830203f, 
    0.03269938f, -0.04761410f, -0.06357965f, -0.04102932f, -0.05794751f, 0.00297811f, -0.01544317f, 0.05206867f, 
    -0.05884813f, 0.02461863f, -0.05931205f, 0.01906637f, 0.01059376f, -0.00458154f, 0.00592288f, 0.04681733f, 
    -0.01180850f, -0.03389859f, 0.04214139f, -0.01875516f, -0.03974002f, 0.01074244f, 0.04360771f, 0.03238859f, 
    0.02492573f, -0.02872457f, -0.01783995f, -0.04085110f, -0.02489603f, 0.01176866f, -0.00970354f, 0.00576244f, 
    0.02809347f, -0.05266087f, -0.02930330f, -0.05094896f, -0.03237838f, -0.02092728f, -0.00242332f, 0.01948984f, 
    0.00500116f, 0.03885239f, 0.00997129f, -0.02812867f, -0.05958305f, 0.00947407f, 0.03187315f, 0.04839950f, 
    0.00640802f, -0.06389396f, -0.00531604f, -0.03406936f, -0.03448796f, -0.04264719f, -0.04567371f, 0.01392198f, 
    -0.06393757f, -0.04902202f, 0.00119032f, -0.02762190f, -0.05794677f, 0.02918164f, -0.05965283f, -0.05218257f, 
    -0.01250346f, 0.01070689f, 0.04899259f, 0.01182725f, -0.05126867f, 0.02359231f, 0.01468868f, 0.00580437f, 
    -0.02846511f, 0.01577838f, -0.02862994f, -0.05904528f, -0.00037361f, -0.05603091f, -0.05664586f, -0.04511219f, 
    -0.04317398f, 0.02789756f, -0.02272133f, -0.04185724f, -0.03633564f, 0.04952304f, -0.05105275f, 0.03565055f, 
    0.01902966f, -0.01722031f, -0.02774012f, -0.04184632f, -0.02144559f, -0.03557210f, -0.03520149f, -0.05175240f, 
    0.01500086f, -0.06034976f, 0.00680436f, 0.00581047f, -0.01509397f, -0.02077293f, 0.00037181f, -0.05359907f, 
    0.02101590f, -0.02488609f, -0.00732947f, 0.03452067f, 0.02690275f, 0.01562153f, -0.03655532f, 0.00402039f, 
    0.02421440f, 0.02667939f, -0.02777529f, 0.03544683f, -0.00598665f, -0.03098405f, -0.05636410f, -0.06372638f, 
    -0.00395696f, -0.01042661f, -0.02360750f, -0.04212735f, -0.00883769f, 0.05138621f, -0.00294262f, -0.06444101f, 
    -0.01266120f, -0.04492364f, -0.03752492f, -0.01516568f, -0.02268132f, -0.01537316f, -0.04697315f, -0.01090937f, 
    0.04290479f, 0.03876390f, 0.01027992f, 0.02106086f, 0.04596141f, -0.05079724f, 0.02763886f, 0.02196265f, 
    0.02354145f, -0.03392091f, -0.05047834f, 0.04376055f, -0.05636282f, -0.01394827f, -0.01532706f, -0.02885540f, 
    -0.05270357f, -0.03993196f, 0.04897569f, 0.03355940f, 0.05224431f, 0.00471249f, 0.05149022f, -0.03516229f, 
    -0.02108873f, -0.01401185f, 0.03244879f, 0.00570742f, 0.04571834f, 0.02163227f, -0.03802348f, 0.00931457f, 
    0.05264987f, -0.04007277f, -0.01629094f, 0.01789655f, -0.03051104f, -0.02409844f, 0.03052763f, 0.01052856f, 
    -0.01388902f, -0.00630100f, 0.04836861f, 0.00281148f, 0.04562339f, -0.00009056f, 0.02707629f, -0.02104450f, 
    -0.04336984f, -0.00589661f, -0.03863738f, 0.05178185f, 0.00286296f, -0.02482216f, 0.05224876f, -0.01514332f, 
    -0.02377577f, -0.04366551f, 0.02043384f, -0.00514430f, 0.01028102f, 0.04198328f, 0.01884279f, 0.03398905f, 
    -0.05889253f, -0.01161305f, -0.00814870f, -0.01491209f, 0.02680605f, -0.02808021f, -0.01683301f, -0.06047912f, 
    0.00472301f, -0.02692720f, -0.05828957f, -0.03273782f, -0.00769019f, -0.05841904f, 0.01385537f, -0.03927492f, 
    -0.05655818f, 0.01100540f, -0.00882344f, -0.04976655f, 0.00522406f, -0.04659888f, -0.00881433f, -0.02067766f, 
    0.04647784f, -0.06001010f, -0.01071209f, -0.03822623f, 0.00639581f, 0.03208623f, -0.05724173f, -0.06086395f, 
    0.00947700f, -0.01734114f, -0.00134007f, -0.05529495f, -0.04564815f, 0.01435927f, -0.02597649f, -0.02554251f, 
    0.04627212f, 0.04364578f, 0.00254583f, 0.04021021f, 0.04796701f, 0.01600060f, 0.01812222f, -0.03205913f, 
    -0.06130443f, -0.00211918f, 0.00836220f, -0.02704427f, 0.03426974f, -0.03746819f, -0.04787633f, -0.01924107f, 
    0.04986925f, -0.01971052f, -0.05662606f, 0.03558958f, 0.02312667f, -0.04860691f, -0.02119427f, -0.02093558f, 
    -0.00428022f, -0.06418182f, -0.04462619f, -0.01504287f, 0.00710619f, 0.03816817f, 0.02612592f, 0.03101636f, 
    0.04272315f, -0.02118445f, -0.01537095f, 0.04402312f, -0.01351575f, -0.00839150f, -0.03879043f, 0.02228404f, 
    -0.00121265f, -0.01594407f, -0.05591970f, -0.03182130f, -0.05013947f, 0.01878450f, -0.01058737f, -0.02174909f, 
    0.02992092f, -0.06509727f, 0.02559662f, -0.04035312f, -0.03150498f, 0.03345708f, 0.00004625f, -0.00464822f, 
    -0.04821909f, -0.05672853f, 0.01234273f, -0.04059786f, -0.01386364f, -0.05065037f, 0.01513576f, -0.02401895f, 
    -0.06553336f, 0.00353557f, 0.04329648f, -0.03156816f, 0.01559765f, -0.05267891f, 0.02558920f, -0.06741385f, 
    -0.02678910f, -0.04808235f, -0.03343598f, 0.02559424f, 0.02075532f, 0.04225146f, -0.04870161f, -0.02422265f, 
    -0.01467004f, -0.04082275f, 0.02698617f, 0.01529504f, 0.04029968f, 0.04742104f, 0.03264765f, 0.03275014f, 
    -0.05417062f, -0.03970885f, 0.04390778f, 0.00919439f, -0.04413146f, -0.02949573f, -0.01698154f, -0.04808237f, 
    -0.05047712f, -0.03006827f, 0.01748745f, -0.00063035f, -0.06122700f, -0.01819343f, -0.00367304f, 0.04677533f, 
    -0.02157841f, 0.01058160f, -0.03198669f, -0.00901868f, 0.00870275f, 0.01106202f, -0.06168411f, 0.04959393f, 
    0.00420702f, 0.00484634f, 0.01906238f, -0.05989205f, -0.05433632f, -0.01184469f, 0.02670007f, -0.03697327f, 
    -0.06377225f, -0.03418599f, 0.03195631f, -0.02340051f, -0.01851633f, 0.02353997f, -0.00928487f, -0.00608063f, 
    0.02242667f, -0.03599995f, -0.00378107f, -0.06669266f, -0.06093011f, 0.03536037f, -0.04466242f, 0.00677258f, 
    -0.01871425f, 0.00011211f, -0.02675265f, -0.04947342f, -0.04195777f, 0.00423124f, -0.04080091f, 0.02238050f, 
    0.02999193f, 0.04825220f, 0.02481209f, -0.06124737f, -0.02118579f, -0.01116811f, 0.03867548f, 0.04924034f, 
    -0.03452133f, -0.03964283f, -0.02157117f, 0.04517179f, 0.03894124f, -0.05249129f, -0.03813055f, -0.02462644f, 
    -0.01095081f, -0.02370176f, 0.00149422f, -0.05892518f, -0.05841101f, 0.00323143f, -0.00505731f, 0.00104033f, 
    0.00094254f, -0.02193717f, 0.01897490f, 0.01821916f, -0.02357105f, 0.03471029f, -0.01764905f, -0.02109005f, 
    -0.00813643f, 0.02540041f, -0.05645483f, -0.04523382f, 0.00045594f, -0.06097933f, 0.03985970f, -0.00103609f, 
    0.01189418f, -0.02667894f, -0.04152049f, -0.01583707f, 0.01161896f, 0.04118801f, 0.04988307f, -0.03479679f, 
    -0.05215485f, 0.00458139f, -0.00038559f, 0.00483541f, -0.03490877f, -0.01950189f, 0.00825255f, 0.00821527f, 
    -0.02870069f, -0.05206084f, 0.01510435f, 0.01859261f, -0.00981354f, 0.00032539f, -0.02897749f, 0.02760916f, 
    0.04587264f, -0.03353724f, -0.04308772f, 0.03753886f, 0.02999021f, 0.02719344f, -0.01620535f, -0.04601704f, 
    -0.04779882f, 0.02587679f, 0.01101458f, -0.02044789f, -0.04863827f, 0.03770090f, -0.03633736f, -0.05733755f, 
    0.05127922f, 0.04773461f, 0.00906345f, 0.00493193f, 0.02772138f, -0.02786927f, -0.02396152f, 0.04012907f, 
    0.04366085f, 0.04876580f, -0.04595980f, 0.02012782f, 0.02216249f, -0.06643578f, 0.00818913f, 0.03640046f, 
    0.04380554f, 0.03443708f, -0.06211376f, 0.03873525f, -0.04688577f, -0.00867128f, -0.02679468f, 0.01145457f, 
    -0.05136887f, 0.01204712f, -0.04695440f, -0.05136512f, 0.03684349f, -0.01411326f, 0.04167464f, -0.06281867f, 
    -0.02554715f, -0.03471605f, -0.01472737f, -0.06426093f, 0.03449167f, 0.02708013f, 0.01575710f, -0.03186713f, 
    -0.05451850f, 0.04739342f, 0.01161750f, -0.01033671f, -0.02371854f, 0.00538587f, 0.02504484f, 0.01667178f, 
    0.03334790f, 0.00637310f, -0.06236991f, -0.00693800f, -0.01560006f, -0.01681759f, -0.05406605f, -0.00319477f, 
    -0.02781789f, -0.04990368f, -0.03720938f, -0.04203236f, -0.04295208f, -0.04437574f, -0.00941953f, 0.01595978f, 
    -0.00301302f, -0.02662584f, 0.03480309f, 0.00430121f, -0.02566653f, -0.06291554f, -0.05975026f, 0.03686443f, 
    0.00484286f, -0.01673208f, -0.05952404f, -0.01121332f, -0.04446927f, -0.02339093f, -0.05250613f, -0.05692550f, 
    -0.01894552f, -0.02642074f, -0.03854035f, -0.04197394f, 0.01855212f, -0.02808211f, 0.02280695f, 0.02641713f, 
    0.00605655f, -0.01972512f, -0.04799039f, -0.02197727f, 0.01656761f, 0.02725175f, 0.04912722f, 0.04064652f, 
    0.02637865f, -0.04493718f, -0.02277029f, -0.02989661f, -0.05148758f, -0.02907951f, 0.00657941f, -0.03935820f, 
    0.01273044f, 0.03200218f, -0.03369118f, -0.01814589f, 0.00621685f, -0.05723897f, 0.04521349f, -0.06818629f, 
    -0.02110723f, 0.04356969f, -0.06930164f, -0.06478177f, -0.03181426f, 0.01792262f, -0.02636029f, -0.05105789f, 
    -0.01518573f, 0.00854240f, -0.07025224f, -0.04047736f, -0.01340054f, -0.05567176f, -0.05151042f, -0.00698409f, 
    -0.01081394f, -0.03518113f, -0.03226980f, -0.05134031f, 0.04551145f, -0.03117246f, -0.03358848f, -0.01389925f, 
    -0.01437374f, 0.02137328f, -0.03757008f, 0.00902006f, 0.03638953f, 0.02117057f, -0.05505593f, -0.06428080f, 
    -0.05590783f, -0.04957229f, 0.04498618f, -0.06871440f, 0.03785618f, -0.03623535f, 0.01934015f, -0.04343076f, 
    0.01260197f, 0.00491230f, 0.00142378f, -0.00452132f, 0.05518593f, 0.03408466f, 0.01559829f, -0.06474075f, 
    -0.05756330f, -0.02946805f, -0.02758268f, -0.05665303f, -0.04322383f, -0.04216713f, -0.07062062f, -0.03031207f, 
    0.01030948f, 0.01021005f, -0.03500807f, -0.02632642f, -0.04460552f, -0.04190643f, 0.01495499f, 0.00858953f, 
    -0.01602338f, 0.00830470f, -0.05659812f, 0.01925473f, 0.02566444f, 0.01660573f, -0.04395601f, 0.00461080f, 
    -0.01615916f, 0.03724879f, -0.00896201f, 0.04337393f, 0.01644950f, -0.04351857f, -0.06173814f, -0.04819046f, 
    0.01503571f, -0.01474352f, -0.03816770f, -0.05999288f, -0.03268379f, 0.03143544f, -0.02939922f, -0.04796708f, 
    -0.07017286f, 0.02833270f, -0.03361287f, 0.03454142f, -0.01822330f, -0.02450336f, -0.01391531f, -0.04844691f, 
    -0.07081499f, -0.05617107f, -0.02749801f, 0.02298700f, -0.01840900f, 0.00963736f, 0.03120537f, -0.04013516f, 
    -0.02018046f, -0.04239146f, 0.02026401f, 0.03414125f, 0.03041743f, 0.00887340f, 0.04591000f, -0.05786961f, 
    -0.00383452f, 0.00844054f, -0.00225776f, -0.00063620f, -0.02386108f, 0.01885726f, -0.06897141f, 0.03047419f, 
    -0.02991827f, -0.05428226f, -0.02998837f, -0.00549052f, 0.03726912f, -0.03042120f, -0.01078570f, -0.03842896f, 
    0.00815844f, -0.02695717f, -0.06287859f, -0.00027900f, -0.06679700f, -0.02914683f, 0.03957373f, 0.03584707f, 
    -0.01103475f, -0.03875025f, -0.01425784f, -0.05862150f, -0.05740402f, -0.03194205f, -0.05696704f, -0.00755869f, 
    -0.06277496f, -0.01321964f, -0.04569482f, 0.02018185f, -0.01447493f, -0.02533660f, -0.06723912f, 0.00410237f, 
    -0.03299895f, -0.04614354f, 0.04466314f, -0.05150683f, -0.03312876f, 0.02081879f, -0.01809637f, -0.05751800f, 
    -0.06900236f, -0.01919554f, -0.03716022f, 0.00180218f, 0.00764075f, 0.00898167f, 0.03126278f, -0.00288313f, 
    0.02149278f, -0.05306780f, -0.03594401f, 0.02201154f, -0.05311282f, 0.03677392f, 0.00262128f, 0.02836594f, 
    0.02112761f, 0.04010108f, -0.02609624f, -0.01499898f, 0.02799732f, -0.04706326f, -0.02975355f, 0.03006879f, 
    -0.03906548f, -0.00637669f, -0.03743880f, -0.06539737f, -0.01226377f, -0.03171864f, -0.02730914f, -0.01543038f, 
    -0.06103624f, -0.00795539f, -0.01194258f, -0.01078976f, 0.02694466f, 0.02930682f, -0.04102482f, 0.03248955f, 
    -0.06454980f, 0.00731451f, -0.01193774f, -0.00342152f, -0.05437218f, 0.00226169f, -0.01936765f, -0.00833473f, 
    -0.02485920f, 0.00565647f, 0.04712854f, -0.03874407f, 0.01517380f, -0.00567235f, 0.01613444f, -0.01283709f, 
    0.05250642f, -0.04727588f, -0.03165871f, 0.04524862f, 0.03664306f, -0.01863096f, -0.06178983f, -0.05709876f, 
    0.00089046f, 0.02460204f, -0.01171853f, 0.03473180f, -0.01724638f, -0.01541198f, -0.00508663f, -0.00363250f, 
    0.02745861f, -0.06020584f, 0.04473729f, 0.00381983f, -0.04195891f, -0.06094437f, 0.03155709f, -0.02356902f, 
    0.00621178f, -0.03483870f, -0.06654761f, -0.03901377f, 0.03968468f, -0.05660667f, 0.00083743f, 0.00637584f, 
    -0.06314972f, -0.05292241f, 0.03658636f, 0.01154071f, -0.05625761f, 0.00221849f, 0.00406583f, 0.01682480f, 
    -0.06818133f, -0.05246588f, -0.03611276f, -0.05215922f, -0.06340604f, 0.00105820f, 0.01531463f, -0.01195377f, 
    -0.03866889f, -0.01943494f, 0.01044398f, -0.00964273f, -0.04358413f, -0.05169414f, 0.02172744f, -0.06285897f, 
    -0.00781118f, -0.01538961f, 0.01677276f, -0.02549446f, -0.06720200f, -0.06088030f, -0.03134530f, 0.02256007f, 
    -0.02662921f, -0.04315388f, -0.03157055f, 0.01926864f, -0.01298440f, -0.01827562f, 0.02823230f, -0.00118341f, 
    -0.06023808f, 0.11278229f, -0.18319663f, -0.14354612f, -0.18513694f, 0.23454274f, -0.25161308f, -0.12001839f, 
    0.05987855f, 0.25246570f, -0.04372280f, 0.00766720f, 0.12526898f, 0.29384381f, 0.11039173f, 0.28241190f, 
    0.06051496f, 0.13441391f, 0.34759834f, -0.05900054f, -0.37398455f, 0.05334682f, 0.12031154f, 0.22207409f, 
    0.12109350f, -0.29711089f, 0.07653324f, 0.23234876f, 0.30682018f, -0.43061158f, 0.01342261f, -0.27076921f, 
    0.20558639f, 0.04044608f, 0.03551232f, -0.21515194f, -0.38725656f, -0.13208234f, -0.09155765f, -0.11830017f, 
    0.07087252f, 0.17650953f, -0.07645807f, -0.06966493f, 0.00093975f, -0.14575279f, 0.10605092f, -0.00464408f, 
    -0.05444332f, 0.16556993f, 0.05241101f, -0.03816329f, -0.09462588f, -0.15221594f, -0.12849940f, 0.05831128f, 
    -0.06500971f, 0.01278790f, 0.24820507f, 0.00351674f, 0.01943434f, 0.06554032f, 0.07446464f, -0.36681223f, 
    0.21025965f, -0.00246978f, -0.00523073f, 0.10710119f, -0.18130907f, -0.39263552f, 0.09693430f, -0.25592929f, 
    -0.09602074f, -0.22917019f, -0.32386488f, 0.01968770f, 0.07481346f, -0.34000459f, -0.05135338f, 0.04774946f, 
    -0.13381939f, -0.07218220f, 0.03854666f, 0.02945701f, 0.01739396f, -0.09278648f, 0.34726858f, 0.10374231f, 
    -0.05324391f, -0.15725505f, 0.40546629f, -0.22936264f, 0.30504048f, 0.25069237f, -0.09616771f, 0.20422207f, 
    0.00604626f, 0.17873320f, -0.01495863f, 0.56150723f, -0.03323946f, 0.11685760f, -0.04339270f, -0.16016786f, 
    -0.01858142f, 0.17700076f, -0.11514231f, 0.22903019f, 0.11770611f, -0.13803688f, -0.09833008f, -0.00869962f, 
    0.11149922f, 0.01441226f, -0.00520271f, 0.07621583f, 0.02481841f, 0.56075668f, -0.25321767f, -0.03315369f, 
    0.13290507f, 0.01076988f, -0.02608802f, -0.01832070f, -0.04043185f, 0.21961150f, 0.25542024f, 0.25353283f, 
    -0.30992857f, -0.23985645f, 0.05493908f, 0.03745884f, -0.07121842f, 0.12010297f, 0.05843228f, 0.52689832f, 
    -0.06520876f, -0.09257199f, 0.20033334f, -0.12719229f, 0.11975539f, -0.07633571f, -0.07029656f, 0.15049346f, 
    -0.41267341f, -0.59539324f, -0.08346482f, -0.06106364f, 0.08699091f, -0.15178072f, -0.00373796f, 0.20169596f, 
    0.20464204f, 0.16667575f, 0.24306358f, -0.22089158f, 0.05562341f, -0.14811713f, 0.00935935f, -0.07579585f, 
    -0.00276585f, -0.00881099f, -0.34068823f, -0.01442843f, 0.10622214f, 0.06232882f, -0.00535663f, -0.28844383f, 
    0.06731366f, -0.17102587f, -0.01723460f, 0.02978615f, 0.01916133f, 0.02768655f, 0.05506247f, 0.06969216f, 
    -0.03983120f, -0.08802252f, 0.15119569f, -0.01335256f, 0.10393436f, -0.14236484f, -0.09641446f, 0.08463816f, 
    0.08200062f, -0.16305239f, -0.18729120f, -0.03132709f, -0.11159499f, -0.13202168f, -0.00267389f, 0.27671006f, 
    0.23480257f, -0.11853544f, 0.03679540f, 0.00921481f, 0.07807826f, 0.10627547f, -0.31678179f, 0.34552214f, 
    -0.19033976f, -0.02991102f, -0.17596270f, -0.11420457f, -0.03291764f, 0.15787074f, 0.15702318f, -0.27416244f, 
    0.18459721f, 0.09904526f, -0.08896932f, 0.10771006f, -0.13398536f, -0.04911248f, 0.16060367f, 0.21570455f, 
    -0.18319502f, 0.39889443f, -0.29798055f, -0.13292088f, -0.03927093f, -0.07402763f, -0.09741326f, -0.00623729f, 
    -0.33085054f, -0.25834230f, -0.04058285f, -0.22587185f, 0.18266726f, 0.17968547f, -0.03921419f, -0.11520278f, 
    0.20442143f, -0.03002786f, 0.15446177f, 0.20049073f, -0.37937054f, 0.13123541f, -0.11369096f, -0.15751584f, 
    0.12378495f, 0.12346113f, 0.15282166f, 0.13485385f, 0.03369736f, 0.05192475f, -0.06607679f, -0.11842693f, 
    0.32481033f, -0.10995125f, -0.26403430f, 0.03943218f, -0.03927191f, -0.46425590f, 0.05707569f, 0.10403462f, 
    0.18775846f, -0.03636764f, 0.13974546f, -0.22657236f, 0.09801714f, 0.60909194f, 0.15884575f, 0.13156632f, 
    0.03208991f, 0.44236085f, -0.01743978f, 0.11241911f, -0.09459365f, 0.13722000f, -0.03556809f, -0.07335888f, 
    -0.23448078f, -0.20784380f, 0.04019374f, 0.06451857f, 0.01820712f, -0.11631729f, -0.09807063f, 0.21124047f, 
    -0.37225816f, -0.00154213f, -0.03209116f, 0.16293460f, -0.01597988f, 0.02422843f, 0.12503827f, 0.11660306f, 
    -0.03723206f, -0.05626078f, -0.03757244f, 0.01795130f, 0.03373277f, -0.00263848f, -0.05600522f, 0.04496726f, 
    0.01633229f, 0.01808377f, 0.01053234f, 0.04081334f, 0.01578965f, -0.06694141f, -0.02330486f, 0.03567709f, 
    -0.00279342f, 0.01820565f, 0.04438335f, -0.02947686f, 0.02995331f, 0.01441478f, -0.04904399f, -0.02145654f, 
    -0.05592749f, 0.03636375f, -0.03730018f, 0.02501936f, 0.02081696f, -0.02382561f, -0.02531930f, 0.04426228f, 
    -0.04691660f, -0.02963277f, -0.00542027f, -0.03911949f, 0.05764682f, -0.03431159f, -0.06056880f, -0.03917907f, 
    -0.06143516f, 0.04140732f, 0.03291050f, 0.02515847f, 0.02875347f, -0.04626297f, 0.03416087f, -0.05060504f, 
    0.03354631f, -0.00907176f, -0.02357308f, -0.01311607f, -0.00276810f, -0.06356715f, -0.00247347f, 0.00761635f, 
    -0.00728627f, -0.00883703f, -0.04609184f, 0.01812973f, 0.00611399f, 0.04090796f, -0.00326593f, 0.04289711f, 
    0.02176199f, -0.04187386f, -0.02291285f, -0.02073242f, 0.02396758f, 0.00873683f, 0.00264963f, -0.02603326f, 
    0.01584123f, 0.04402058f, -0.04737076f, -0.02119712f, -0.04435346f, -0.05723596f, -0.00129355f, 0.02722454f, 
    -0.06220565f, -0.01635533f, 0.01793507f, -0.05806465f, -0.02385407f, 0.03024163f, -0.04994446f, 0.01392513f, 
    -0.02171547f, 0.01938692f, 0.04373049f, -0.06063644f, -0.05291802f, -0.02063106f, 0.02953925f, 0.05488976f, 
    0.00419563f, -0.02777444f, -0.04207643f, 0.05595614f, 0.01797527f, -0.01441730f, -0.04814444f, 0.01552291f, 
    -0.01345051f, 0.00806620f, -0.00809016f, -0.02464240f, -0.01304807f, 0.05350649f, -0.02894112f, -0.02624739f, 
    -0.00377492f, 0.00321143f, -0.04089184f, -0.02371927f, -0.04712717f, 0.05427825f, 0.00356833f, -0.02112019f, 
    -0.06080355f, -0.02100779f, -0.04607491f, 0.01157369f, 0.01580719f, 0.03265056f, 0.04039302f, -0.06287370f, 
    -0.05190719f, 0.05831646f, -0.00217060f, 0.01058150f, 0.02083798f, -0.02648525f, -0.03595239f, -0.03664427f, 
    0.04278694f, 0.05101851f, 0.03324549f, 0.01975007f, 0.04680010f, -0.03656365f, -0.02572680f, 0.00350749f, 
    -0.04663009f, 0.04189349f, 0.04846837f, -0.05915032f, 0.04134942f, -0.04269234f, -0.05068128f, 0.00900319f, 
    -0.00562965f, 0.04420523f, -0.00191217f, 0.02245158f, -0.00306698f, -0.00781112f, 0.01054269f, 0.00681665f, 
    -0.02775181f, 0.01339376f, -0.04478600f, -0.03108114f, -0.02080491f, -0.02992571f, 0.03656152f, 0.00345784f, 
    0.03655155f, -0.06146520f, 0.05461874f, 0.01896275f, -0.03706689f, -0.00987433f, -0.00564193f, 0.02135275f, 
    -0.04062463f, 0.00136331f, -0.04069234f, 0.04881146f, -0.01102756f, -0.04695841f, 0.01066013f, 0.02699696f, 
    0.03163199f, -0.00255161f, -0.02809952f, 0.02640231f, 0.02105539f, 0.02600153f, -0.05387891f, -0.03345959f, 
    0.03421856f, -0.03292624f, -0.01210310f, -0.04065849f, 0.05290271f, 0.05394461f, -0.03904754f, -0.06597222f, 
    -0.00954140f, 0.02221079f, -0.04738443f, -0.00435333f, 0.02626770f, 0.02188045f, -0.00036019f, -0.03575633f, 
    -0.00009225f, -0.03133177f, -0.05287939f, -0.00431002f, 0.06154609f, -0.01381670f, -0.02812614f, -0.02854467f, 
    0.03405042f, 0.04569029f, 0.02516464f, -0.05956944f, 0.00378018f, 0.03850972f, -0.05307455f, 0.00010144f, 
    -0.03532794f, -0.00455848f, -0.04836427f, -0.02109078f, 0.00345289f, -0.03583216f, -0.00068262f, 0.04724715f, 
    0.00316686f, 0.00988356f, -0.04327329f, 0.04787255f, 0.01739328f, -0.05503821f, 0.03411178f, -0.04974082f, 
    -0.05664469f, 0.01798011f, -0.03888649f, 0.04195059f, -0.06039630f, 0.04307716f, -0.05292131f, 0.01557360f, 
    0.00967539f, -0.05057040f, 0.04410837f, 0.02055677f, -0.04447647f, -0.03506409f, -0.02267502f, -0.05852858f, 
    0.01340992f, 0.04584820f, -0.03443927f, 0.01650197f, -0.05830861f, 0.03761972f, -0.02289522f, 0.04503410f, 
    0.04433864f, -0.02606133f, -0.04264433f, -0.05971498f, -0.02562320f, 0.03740660f, -0.03917388f, -0.05093066f, 
    0.02720362f, 0.03516590f, -0.06592459f, -0.00284433f, 0.00051270f, -0.04612592f, 0.04163088f, -0.04015152f, 
    -0.02140564f, 0.02786713f, 0.01561619f, -0.03391555f, -0.04155900f, -0.00241361f, 0.02312581f, -0.06273553f, 
    0.07485098f, 0.12635456f, -0.29073316f, -0.09039549f, -0.20868139f, 0.15748107f, 0.13717209f, 0.12744482f, 
    -0.04733283f, 0.08163818f, -0.25635979f, 0.00245823f, 0.45434979f, -0.04004697f, 0.23778920f, 0.19005857f, 
    -0.19314462f, 0.19703588f, -0.57083845f, 0.08038998f, -0.09548561f, -0.05102236f, 0.12739480f, -0.39048162f, 
    -0.19819669f, 0.10178427f, 0.17689645f, -0.01724964f, 0.32972783f, -0.05121835f, -0.09140195f, -0.18611456f, 
    -0.12788428f, 0.12654869f, 0.06800758f, 0.08692323f, -0.50282866f, 0.36473620f, 0.22427459f, -0.05267137f, 
    0.20966053f, -0.12084683f, 0.04116720f, -0.02409422f, 0.05810170f, 0.01916085f, 0.05393780f, 0.28594762f, 
    -0.06827942f, 0.15662831f, 0.03456806f, 0.02120971f, 0.16011177f, 0.16323063f, 0.24281994f, 0.02813959f, 
    -0.22398467f, -0.19537950f, -0.05168474f, 0.05381726f, -0.05032885f, 0.01529434f, 0.02917300f, 0.14922175f, 
    -0.15593116f, 0.06605726f, -0.18094744f, -0.09239832f, 0.13992801f, 0.01878259f, 0.20714365f, -0.09551033f, 
    0.07730172f, -0.11370210f, 0.33169073f, -0.12110261f, -0.06939881f, -0.14106368f, -0.28517354f, -0.04236648f, 
    -0.05690968f, -0.19539936f, 0.13847373f, -0.27595693f, 0.17336057f, 0.04996207f, -0.06459748f, 0.03306867f, 
    -0.06852786f, 0.07196281f, 0.19479170f, 0.02492481f, -0.28888708f, -0.03014836f, 0.02459034f, -0.04388824f, 
    -0.02500541f, 0.08519989f, -0.22286965f, 0.27388182f, -0.15572277f, 0.10528385f, 0.23906036f, 0.02026526f, 
    0.09257794f, 0.04842791f, 0.20188725f, 0.05888037f, 0.21167138f, 0.22527137f, -0.15070368f, 0.47341347f, 
    0.24732713f, -0.02728416f, 0.09214374f, 0.14786154f, -0.08576982f, 0.16286249f, -0.10167900f, -0.02931436f, 
    0.32019985f, 0.14029138f, -0.04874110f, 0.05536953f, 0.17540859f, -0.11932626f, 0.13689886f, 0.14073551f, 
    0.26829588f, 0.28320083f, -0.09859495f, -0.27075741f, -0.12322034f, -0.04114835f, 0.03351406f, -0.16660041f, 
    0.05548949f, -0.12242226f, 0.13384131f, 0.21738772f, 0.03510516f, -0.24325959f, -0.04547399f, 0.11759344f, 
    0.45283589f, 0.02008842f, 0.09604957f, 0.13065258f, 0.12138227f, 0.00512348f, 0.22732933f, 0.20984817f, 
    -0.23677988f, -0.12827978f, 0.19553570f, 0.05400902f, -0.09509351f, -0.16625296f, 0.08275052f, 0.03984067f, 
    0.00239506f, -0.03836589f, -0.22551855f, 0.21026292f, -0.10281307f, 0.12184716f, 0.09701388f, 0.33967659f, 
    -0.16876720f, -0.20620809f, 0.13809705f, 0.12793131f, 0.22751120f, -0.11659127f, 0.20430528f, 0.00286791f, 
    -0.22537285f, 0.01640868f, -0.04016488f, -0.05480350f, 0.15367205f, 0.15850052f, -0.11497996f, 0.06031463f, 
    0.00729847f, 0.09406165f, -0.06793765f, 0.22117776f, -0.10476857f, -0.02995986f, 0.26935157f, 0.00385153f, 
    -0.08151307f, 0.25071228f, 0.12955092f, 0.15280402f, 0.14173627f, 0.17762829f, 0.05464740f, 0.12772070f, 
    0.09586956f, 0.18360418f, -0.08719137f, -0.00034325f, -0.08938975f, 0.10581230f, 0.12339627f, -0.46525058f, 
    -0.35305145f, 0.26318374f, -0.22052576f, 0.00488213f, -0.10882566f, -0.28737962f, 0.05965082f, -0.08006153f, 
    0.00932218f, 0.20216432f, 0.16024269f, -0.09396829f, 0.06120975f, -0.08339351f, -0.20141697f, -0.07401422f, 
    -0.06085309f, -0.18591015f, 0.02910100f, -0.27544597f, -0.00495172f, 0.12418612f, 0.01673458f, 0.06573021f, 
    0.16627128f, -0.02197573f, 0.06713844f, 0.19912159f, -0.21411768f, 0.22173174f, -0.02495576f, -0.10326822f, 
    0.00316168f, 0.00055361f, -0.44908920f, -0.06931853f, 0.04028077f, -0.30988228f, 0.19003953f, 0.00423695f, 
    0.12409431f, -0.06918076f, 0.20927010f, 0.08607985f, -0.46999574f, -0.05901862f, -0.34696096f, 0.12205264f, 
    -0.09068530f, 0.13614713f, 0.21943000f, -0.09547836f, 0.04313546f, -0.15276568f, -0.28949636f, 0.06380849f, 
    0.46338615f, 0.11028168f, -0.35658455f, -0.28207934f, -0.03816509f, 0.04865824f, 0.34707597f, -0.24459565f, 
    -0.19691332f, 0.00670412f, -0.40328410f, 0.10486190f, 0.24837959f, 0.08602265f, 0.20417152f, 0.28213841f, 
    -0.08934215f, -0.33801258f, 0.27532959f, -0.03896483f, -0.20250005f, 0.08649627f, -0.35056585f, 0.15334630f, 
    0.27835491f, 0.41419145f, -0.14060022f, -0.21601991f, 0.00033321f, 0.03196316f, 0.03200321f, 0.05980930f, 
    0.09550923f, -0.21734510f, -0.12953144f, 0.06428059f, 0.04974196f, 0.00616359f, 0.02459905f, 0.34142250f, 
    -0.02076884f, -0.02118179f, -0.09158652f, 0.08652007f, 0.35239753f, 0.23247850f, -0.01723179f, 0.33082715f, 
    -0.09988251f, -0.10472416f, -0.00339586f, 0.27707705f, -0.12577899f, 0.05807037f, 0.01293526f, 0.10588323f, 
    0.04236479f, -0.21919946f, 0.03823630f, -0.16484591f, -0.20694064f, -0.07404985f, -0.05194568f, 0.28834254f, 
    0.22384149f, 0.12604359f, 0.09126040f, -0.27306116f, -0.02478138f, 0.26775378f, 0.13181771f, 0.02909731f, 
    -0.16498484f, 0.25104016f, -0.14049676f, -0.24358067f, 0.09923341f, 0.20014527f, -0.25722271f, -0.27223417f, 
    0.02669658f, 0.11597518f, 0.03754414f, -0.07668411f, 0.03877196f, -0.03072502f, 0.26703700f, -0.06762752f, 
    -0.36399680f, -0.00446687f, 0.08880533f, 0.22360311f, -0.13430522f, 0.15605572f, -0.09834669f, -0.15574951f, 
    0.33998299f, 0.01524343f, -0.09502950f, -0.04194288f, 0.05784561f, -0.05619621f, -0.05864627f, -0.16989459f, 
    -0.16590337f, 0.61418790f, 0.48544824f, 0.28353444f, 0.03694930f, -0.00274160f, 0.05041545f, 0.04001797f, 
    0.03036898f, 0.33006081f, 0.22794451f, -0.12410266f, 0.22361721f, 0.06377058f, -0.01106170f, 0.10959072f, 
    -0.03058992f, 0.17336676f, -0.00166328f, -0.64576876f, -0.34991121f, -0.31615272f, 0.00760292f, 0.17015073f, 
    -0.17391397f, 0.26639548f, -0.15074651f, 0.18617456f, -0.64551198f, -0.62609619f, -0.23700051f, 0.06787930f, 
    0.23359017f, -0.07613289f, -0.07750063f, -0.21089695f, 0.07541154f, -0.43806341f, -0.25004271f, 0.01265570f, 
    0.17857067f, 0.05210115f, 0.02261202f, 0.02440900f, 0.13374060f, 0.05113281f, -0.06701924f, -0.11283516f, 
    0.15240423f, -0.08354572f, 0.07579866f, 0.09440389f, -0.17886305f, 0.00303817f, -0.00013018f, 0.08022263f, 
    -0.19715180f, 0.09141803f, 0.23243229f, 0.01566586f, 0.14864999f, 0.06140548f, -0.09671491f, -0.11212274f, 
    -0.53823799f, -0.83654904f, -0.37339365f, -0.00970788f, 0.27550921f, -0.11872803f, 0.10381537f, 0.12038603f, 
    0.07505561f, -0.01047982f, 0.03018868f, 0.31999177f, -0.03115364f, 0.10771804f, 0.24502765f, -0.08973748f, 
    -0.28188270f, -0.20975903f, -0.10370455f, -0.18381044f, -0.28430581f, 0.07593919f, -0.16939703f, 0.09686134f, 
    0.03286058f, -0.22103728f, 0.42231920f, -0.51095575f, -0.50550097f, 0.00141433f, 0.16327469f, 0.00816033f, 
    -0.00978175f, 0.04304520f, 0.05874497f, 0.06541894f, 0.07154120f, -0.08248999f, -0.04538895f, 0.22207950f, 
    -0.00649043f, 0.30449072f, 0.29152849f, -0.04069041f, -0.00280132f, 0.08488998f, -0.30186769f, 0.00409329f, 
    -0.21864408f, -0.06291429f, 0.00773606f, -0.00733424f, 0.13771236f, 0.10492650f, 0.26808691f, 0.08624633f, 
    0.01039625f, -0.16294609f, -0.02488358f, -0.12674558f, -0.02832524f, 0.09055963f, -0.02963747f, 0.44922659f, 
    0.21112159f, 0.10306398f, -0.27560925f, -0.21819878f, -0.01728429f, 0.03439011f, 0.15631968f, -0.09585487f, 
    0.02190805f, -0.24213563f, -0.11019816f, 0.03620471f, 0.12190762f, -0.08397509f, 0.05867553f, 0.14690724f, 
    -0.24703860f, -0.64696628f, 0.17435960f, -0.00590552f, 0.21125224f, 0.19754018f, 0.08975173f, -0.06548839f, 
    -0.00234337f, 0.39828044f, -0.13251065f, -0.12810667f, 0.17586291f, 0.16421622f, -0.00773539f, -0.01102790f, 
    -0.07074072f, 0.12970522f, -0.13173096f, -0.25899836f, -0.35198840f, 0.02177147f, 0.22460034f, -0.02764679f, 
    0.23111267f, -0.46159059f, -0.10656662f, -0.07229337f, 0.27422234f, 0.12581678f, -0.09928078f, -0.03488715f, 
    0.19853635f, -0.16420101f, -0.09031726f, 0.03854103f, -0.13234740f, 0.17853947f, 0.19709241f, 0.01312903f, 
    -0.16007017f, -0.21586327f, -0.01191788f, -0.18264498f, 0.07829863f, 0.03969645f, -0.13938285f, -0.01227255f, 
    -0.35102987f, -0.03040065f, 0.07108232f, 0.14788988f, 0.25079605f, 0.26395339f, -0.11364194f, -0.03685162f, 
    -0.35391879f, -0.01733697f, -0.15212592f, 0.00866835f, 0.00752457f, 0.26442519f, -0.10419930f, -0.34855750f, 
    0.15174033f, 0.03672631f, -0.08340670f, -0.01700902f, 0.02324032f, -0.00984465f, -0.20510593f, 0.06373811f, 
    0.22630249f, 0.04829335f, 0.13059485f, 0.12810995f, 0.02526360f, 0.04354021f, 0.00169832f, 0.01469595f, 
    0.09525409f, 0.13613789f, -0.11940852f, -0.04973780f, 0.13201889f, 0.01445279f, -0.11825140f, -0.08118235f, 
    0.13665278f, -0.07471351f, -0.05968377f, 0.18830700f, -0.01822245f, -0.00285014f, -0.16210946f, -0.14231205f, 
    -0.06825866f, 0.09274552f, 0.12507457f, 0.06310882f, -0.04776065f, 0.16362682f, -0.26449889f, -0.04280044f, 
    0.16693418f, -0.25356406f, -0.04930194f, -0.22861993f, 0.23110488f, -0.16927023f, -0.09245081f, 0.21579027f, 
    -0.06111332f, -0.09644543f, 0.01572639f, -0.04683098f, 0.12172291f, 0.07460868f, 0.07182273f, 0.24990353f, 
    0.03887155f, -0.14585765f, 0.04915993f, 0.02364679f, -0.11412123f, -0.14038259f, -0.17112388f, 0.00221687f, 
    0.13649748f, 0.26590276f, 0.04262770f, 0.09488481f, 0.14048174f, 0.10870674f, 0.06296580f, 0.16588780f, 
    -0.18456638f, 0.09656104f, 0.51058882f, -0.19136648f, 0.31759253f, 0.22188540f, 0.07464369f, 0.12415817f, 
    0.02273593f, 0.18935207f, 0.13247648f, -0.09555134f, -0.12476216f, 0.13204299f, -0.14854567f, -0.10447926f, 
    -0.16751014f, -0.13256148f, -0.29172552f, 0.09787409f, -0.06786321f, 0.13386898f, -0.11399697f, -0.07588632f, 
    -0.12520796f, 0.26230252f, -0.18478312f, -0.01823027f, 0.06656010f, 0.04315285f, 0.21254782f, 0.00940173f, 
    0.27118784f, 0.04062693f, 0.07296778f, -0.17772269f, -0.16188356f, -0.14340343f, -0.22620974f, -0.08501932f, 
    0.06339091f, 0.19609016f, 0.11953673f, 0.03728482f, -0.33713984f, -0.43842578f, 0.06711125f, 0.19616868f, 
    0.02542613f, -0.03889230f, 0.12972833f, -0.09205623f, -0.04658967f, -0.17372696f, 0.03162540f, -0.13422638f, 
    0.14022551f, 0.16639677f, 0.10240121f, -0.09944049f, -0.14437234f, -0.12291889f, 0.14234851f, -0.37714422f, 
    -0.09560118f, -0.11383232f, -0.03544169f, -0.00659149f, 0.03404367f, 0.06141206f, -0.08134478f, -0.31154460f, 
    0.07475775f, 0.10061677f, -0.09948409f, -0.09652260f, -0.16127799f, 0.23445491f, -0.03757064f, -0.18988277f, 
    -0.22043052f, 0.16150126f, -0.02486938f, 0.32787126f, 0.11853752f, 0.13360985f, -0.04596170f, -0.03160093f, 
    -0.11373794f, 0.08710236f, -0.12198526f, 0.01177629f, 0.11018845f, -0.06170387f, 0.17375392f, -0.05552035f, 
    0.03887435f, 0.02867411f, 0.06732181f, 0.01540001f, -0.03524024f, -0.16760449f, -0.12823327f, -0.12950392f, 
    0.07349120f, -0.06648185f, -0.02107063f, -0.19283901f, -0.13203451f, 0.43222910f, 0.29172575f, -0.09514453f, 
    -0.13185778f, -0.12658922f, 0.06030006f, -0.02566694f, 0.16208543f, 0.23945846f, 0.31371042f, 0.10858615f, 
    -0.42208433f, 0.01661264f, 0.04085630f, 0.01055166f, 0.18590954f, 0.15924007f, 0.37378284f, -0.36156559f, 
    0.17471711f, 0.12374499f, -0.15785085f, 0.07944095f, 0.03095206f, -0.00830224f, -0.19689630f, 0.22010942f, 
    -0.09882665f, 0.37897068f, 0.01889534f, -0.05236331f, -0.02042104f, 0.13100767f, 0.10032143f, 0.05484268f, 
    -0.13676335f, -0.37187344f, 0.32315451f, 0.02693212f, 0.19357729f, -0.18546344f, -0.17387655f, -0.12767707f, 
    -0.08074305f, 0.06706384f, 0.13713448f, -0.16711214f, -0.19954270f, 0.17517433f, -0.03405476f, -0.00753195f, 
    -0.23696104f, -0.09516443f, -0.18907596f, -0.16704896f, 0.00249105f, -0.23515679f, 0.04094470f, 0.04909807f, 
    -0.30739966f, -0.14431955f, 0.16369382f, 0.02546210f, 0.22011863f, -0.09416115f, -0.10356341f, 0.30788407f, 
    -0.13544993f, 0.11063364f, -0.15738101f, -0.24383529f, 0.12135996f, 0.05699804f, -0.31126463f, 0.04857174f, 
    -0.15133375f, -0.06284378f, -0.07515591f, 0.03610095f, -0.15130660f, 0.06861139f, -0.25520074f, 0.45931637f, 
    -0.03443163f, 0.19756100f, -0.01057965f, -0.04068789f, 0.02994039f, -0.05683979f, 0.10241766f, -0.13535114f, 
    -0.35763454f, 0.30229715f, -0.01121013f, 0.24704225f, 0.08165361f, -0.05200129f, -0.02045063f, 0.19264537f, 
    0.12642796f, 0.13023013f, -0.16463289f, -0.13499998f, 0.22290716f, -0.08624771f, -0.00498941f, 0.17094128f, 
    0.52693427f, -0.20909733f, 0.05285136f, 0.03966384f, -0.22062968f, -0.06707765f, -0.09501445f, 0.10644021f, 
    0.01752225f, 0.13386305f, 0.29133129f, 0.07412484f, 0.08115806f, -0.13333598f, 0.05759905f, -0.37384066f, 
    0.19568160f, -0.07140294f, -0.47834945f, 0.30077666f, 0.16723217f, 0.15983751f, 0.11120098f, 0.00025873f, 
    -0.09082843f, -0.01577864f, -0.09205212f, -0.18565351f, -0.12962557f, -0.33066058f, 0.03273663f, -0.06108101f, 
    -0.13084188f, -0.11798099f, 0.20249730f, -0.03340846f, -0.02527480f, -0.24518621f, 0.25103045f, -0.02307133f, 
    0.07345833f, -0.02922531f, 0.07075908f, -0.08805269f, -0.09469449f, -0.14482254f, 0.06012547f, -0.09992015f, 
    0.06400395f, 0.13849142f, -0.08431078f, 0.27831322f, -0.06648970f, 0.07129530f, -0.11634467f, 0.03804571f, 
    -0.23264731f, -0.04791426f, -0.24054284f, 0.08999641f, -0.12805703f, -0.08750710f, 0.07484567f, 0.12400912f, 
    0.50892889f, 0.23532632f, 0.10117338f, -0.02769153f, 0.25300625f, -0.08696708f, 0.23308460f, 0.18602276f, 
    0.00902074f, 0.40698239f, 0.22025965f, -0.09234431f, 0.11419356f, 0.39558122f, 0.06557831f, 0.10339317f, 
    0.33515957f, 0.07747282f, -0.20850541f, -0.02014993f, 0.00656318f, 0.09568055f, -0.32304975f, 0.04567820f, 
    -0.12651619f, -0.07144059f, -0.54447532f, 0.22113630f, -0.01256050f, 0.00427815f, -0.18985942f, -0.37326533f, 
    0.07650251f, 0.03077432f, 0.06171206f, -0.11950053f, -0.02021307f, 0.02074008f, 0.01971432f, -0.02406493f, 
    0.09170816f, 0.09678370f, 0.00666647f, -0.00454167f, 0.01347709f, 0.12843968f, -0.34964126f, -0.04809248f, 
    0.05941232f, 0.11112283f, 0.02118503f, -0.09610598f, -0.24244653f, -0.19842181f, 0.28200471f, -0.01748946f, 
    -0.08890704f, -0.05455033f, 0.10387587f, -0.00923945f, 0.00006578f, -0.03391549f, -0.06430630f, 0.16150549f, 
    0.12109677f, 0.26749912f, 0.11099305f, -0.18933457f, 0.14245634f, 0.09373228f, 0.09417507f, -0.25370303f, 
    0.32257211f, 0.04937355f, -0.09282318f, 0.13246498f, -0.11867137f, 0.11194716f, 0.15106845f, 0.07137332f, 
    0.10763788f, 0.11539671f, -0.14102632f, 0.03374964f, -0.04634276f, 0.19033164f, 0.21437825f, -0.11654916f, 
    -0.18792613f, -0.02772255f, -0.17631736f, 0.04467811f, -0.03929356f, 0.02612860f, 0.00602956f, 0.13650261f, 
    0.31849596f, 0.21074045f, -0.25047216f, 0.00428455f, -0.08132853f, 0.00271590f, 0.08512335f, 0.04578274f, 
    -0.16344407f, 0.04946456f, -0.29702416f, -0.04251701f, 0.08029616f, -0.41653106f, -0.02901666f, 0.07110245f, 
    -0.02337428f, 0.02369628f, -0.14755884f, -0.04325881f, 0.01119778f, 0.49192733f, 0.19851223f, -0.01436655f, 
    0.13304643f, 0.18575853f, -0.04778191f, 0.05268321f, 0.08332458f, 0.04193943f, 0.08768262f, -0.47948077f, 
    -0.26022583f, 0.09022871f, -0.07364897f, -0.15004516f, 0.20088059f, 0.01308392f, -0.00880269f, -0.06903588f, 
    0.05487038f, -0.09888540f, -0.04493099f, 0.09684851f, -0.15943807f, -0.03743563f, 0.00586036f, 0.11596679f, 
    0.35745981f, 0.16226195f, -0.07833263f, 0.00115577f, 0.12626584f, 0.08190679f, 0.00687367f, -0.00910503f, 
    -0.11643403f, 0.15649834f, -0.14955662f, 0.11684626f, 0.08932675f, 0.08086102f, 0.06030914f, -0.12212932f, 
    -0.31346828f, -0.09163034f, -0.01237750f, -0.12363803f, -0.05069110f, -0.00070688f, -0.03562076f, 0.04025275f, 
    -0.28123143f, -0.11146560f, 0.07008932f, -0.06688722f, 0.14652851f, -0.04530350f, 0.01008087f, 0.05978268f, 
    -0.21039024f, -0.10700802f, -0.16828363f, 0.16001812f, 0.02303686f, -0.05131447f, 0.23012491f, 0.09864537f, 
    -0.00824240f, 0.10089345f, -0.04890147f, -0.11987502f, -0.22385788f, 0.14591837f, 0.18389887f, 0.02793283f, 
    -0.06071340f, -0.25908655f, -0.08054753f, -0.14652918f, 0.08885214f, 0.13336881f, 0.35111085f, 0.33791831f, 
    0.03486493f, -0.26176164f, 0.08459318f, 0.11583523f, -0.15292121f, -0.02320234f, -0.19428959f, 0.10815402f, 
    -0.11485867f, 0.26270586f, -0.09971217f, 0.11079413f, 0.18693817f, 0.10497725f, -0.22962455f, 0.22763467f, 
    0.43060368f, 0.04633527f, -0.29867548f, -0.03141397f, 0.25028345f, 0.05216431f, 0.09178775f, 0.00221973f, 
    0.02647067f, 0.03241970f, -0.05995699f, -0.05804187f, -0.06684316f, -0.06271916f, 0.03036555f, 0.00569788f, 
    -0.04089636f, -0.02822184f, -0.02783003f, 0.00840886f, -0.06239126f, -0.00760019f, -0.05743396f, 0.04051926f, 
    -0.01814122f, -0.05452972f, -0.03208416f, -0.02618404f, -0.01796183f, -0.06062484f, 0.03160251f, 0.01591888f, 
    -0.06220601f, 0.03339355f, -0.06143614f, 0.00842621f, 0.05430511f, 0.01218939f, 0.04836366f, 0.04259285f, 
    -0.05078572f, -0.01803164f, 0.03454156f, 0.00915641f, -0.00176521f, -0.00076976f, -0.06199867f, 0.00880299f, 
    0.02027950f, -0.05160065f, -0.05794265f, 0.04227753f, -0.05224425f, 0.02946492f, -0.03763077f, -0.03775319f, 
    -0.06418859f, -0.02181603f, -0.00972810f, -0.00291205f, 0.00832401f, -0.04376293f, 0.05189807f, 0.00709394f, 
    -0.05492094f, 0.02284237f, -0.02866304f, 0.02405555f, 0.04084925f, -0.01615462f, -0.00059709f, 0.03033691f, 
    -0.02295671f, -0.01375613f, -0.05173691f, -0.05486945f, 0.02482207f, -0.00480314f, -0.03393662f, 0.03405505f, 
    -0.04841139f, -0.01373922f, 0.05101452f, 0.04650604f, -0.06631787f, 0.04627471f, -0.01030486f, -0.00385146f, 
    0.04787005f, 0.02225009f, -0.00377998f, -0.06327394f, -0.05593017f, -0.01200991f, -0.00242611f, 0.04338651f, 
    -0.01298785f, -0.06432593f, 0.00460086f, 0.01140057f, -0.04534243f, 0.05027911f, 0.01056538f, 0.02910186f, 
    0.02413833f, 0.00312575f, -0.06070786f, 0.00076960f, 0.02076026f, -0.04170284f, -0.00099569f, 0.05226751f, 
    -0.06573682f, 0.01735817f, 0.02831154f, 0.01274308f, -0.04316485f, 0.02571335f, 0.04420774f, -0.04559380f, 
    -0.03084912f, -0.03118716f, 0.00622488f, 0.04197475f, -0.03611912f, -0.00419088f, -0.01643467f, -0.04848392f, 
    0.04780032f, -0.06415358f, 0.04165458f, -0.03538299f, 0.03200335f, -0.01392785f, 0.00096528f, 0.00180853f, 
    0.02805535f, -0.06284878f, 0.03537652f, -0.04087089f, -0.04001111f, -0.02256447f, 0.01823793f, -0.06130088f, 
    0.01555425f, -0.02543044f, -0.00285744f, -0.04496394f, -0.01703554f, 0.03236439f, 0.01973060f, -0.01135243f, 
    -0.06497434f, -0.04586411f, -0.01430861f, 0.03879651f, 0.01765737f, 0.01989155f, -0.05655450f, -0.00610084f, 
    0.03732678f, -0.04557009f, 0.02270153f, 0.02379632f, -0.00222311f, -0.03847784f, 0.04035407f, -0.03485594f, 
    -0.02938979f, 0.02072701f, 0.05095714f, 0.04992371f, -0.02005263f, -0.00795461f, -0.01840117f, 0.00973195f, 
    0.04041397f, -0.01194198f, -0.01217697f, 0.03856659f, -0.02438082f, 0.00734321f, -0.05546207f, -0.01227108f, 
    0.00321743f, 0.00335593f, 0.02168242f, -0.06008519f, -0.02696262f, 0.02785983f, -0.04099546f, -0.02709751f, 
    0.00244353f, -0.05018977f, 0.03041177f, 0.02908670f, 0.04302784f, 0.00198375f, -0.01084447f, 0.01771704f, 
    -0.06624795f, 0.02896468f, 0.02095287f, -0.04822634f, -0.00872961f, 0.04687836f, 0.02927697f, 0.02609858f, 
    0.02423553f, 0.05253340f, -0.02833236f, -0.04508846f, -0.00629102f, 0.01750728f, 0.01032856f, 0.04560610f, 
    0.04242473f, 0.04627385f, 0.01798084f, 0.00180367f, 0.02891076f, -0.01208824f, -0.05408787f, 0.04895366f, 
    -0.00685604f, 0.00359619f, -0.03901552f, -0.00744042f, 0.01096541f, -0.03873869f, 0.00536999f, 0.03865571f, 
    0.00835484f, -0.02579746f, -0.01773090f, -0.03078548f, -0.02011855f, -0.05198724f, 0.01991849f, -0.01563301f, 
    -0.01655636f, -0.05396634f, -0.03551183f, 0.02830455f, 0.02130139f, 0.04558509f, -0.00021749f, 0.02859324f, 
    0.04580091f, 0.04196982f, -0.02141470f, -0.01929313f, -0.05794547f, -0.06375767f, 0.01860981f, 0.04469854f, 
    0.03110696f, -0.04012108f, -0.06003011f, -0.01975831f, 0.04648916f, -0.06098203f, -0.06278265f, -0.04283773f, 
    -0.02990846f, 0.02135086f, -0.04891569f, -0.03373419f, 0.01967588f, 0.02051178f, 0.00999026f, -0.01642689f, 
    -0.04593677f, 0.01303608f, 0.03398732f, 0.03154354f, -0.05971301f, -0.05362520f, 0.02584934f, 0.00825416f, 
    -0.00385783f, -0.05638191f, -0.01632987f, -0.02224179f, -0.04724736f, 0.03061998f, -0.02496958f, -0.01639800f, 
    -0.06552134f, -0.00226838f, 0.03251342f, 0.00861985f, 0.01001820f, -0.00300993f, -0.01833143f, 0.03033771f, 
    -0.04235044f, 0.00994502f, -0.02990209f, 0.05227496f, -0.04885279f, 0.03541594f, -0.04234199f, 0.02237644f, 
    -0.05280325f, 0.01809380f, 0.04893350f, -0.03821792f, 0.01981327f, -0.02582881f, -0.01233492f, 0.00752790f, 
    -0.02250414f, 0.04217488f, -0.03565935f, -0.01243518f, -0.04143566f, -0.07015864f, 0.00379539f, 0.01887204f, 
    -0.01278151f, 0.03000432f, 0.03140728f, 0.03630818f, -0.02249891f, 0.03198025f, 0.01048842f, 0.00562670f, 
    -0.01881839f, -0.03693532f, -0.01001151f, 0.04227863f, -0.06745307f, -0.00987957f, 0.03668385f, -0.03226938f, 
    -0.00650429f, 0.06298574f, -0.02863542f, 0.00200017f, -0.02476049f, -0.03544653f, 0.03771169f, -0.03864971f, 
    -0.04072848f, 0.03302320f, -0.05285071f, -0.03171081f, -0.02972177f, -0.05311461f, -0.01523231f, -0.02159817f, 
    -0.04400504f, -0.02049803f, 0.04558722f, 0.03828553f, -0.03004074f, -0.00233121f, 0.00635334f, -0.04402695f, 
    -0.03730118f, 0.04855580f, -0.05418624f, 0.05471189f, -0.00642777f, 0.05671063f, -0.04379262f, 0.04619135f, 
    0.01951275f, -0.03515356f, -0.03394131f, -0.03747744f, -0.04915111f, -0.03517338f, 0.00386006f, 0.00615524f, 
    0.01309500f, -0.00006648f, -0.05337993f, -0.03189692f, -0.04435586f, -0.05892045f, 0.02151953f, 0.01362277f, 
    -0.02975183f, 0.01958607f, -0.03929727f, 0.03163239f, -0.00257381f, -0.04850363f, 0.02699151f, 0.01190682f, 
    -0.01361009f, -0.05342194f, 0.00004999f, 0.03939963f, -0.04856164f, -0.04788265f, 0.04209035f, 0.03100330f, 
    -0.02130329f, -0.05638302f, 0.00748041f, 0.02998145f, -0.02854722f, -0.01767440f, -0.02181410f, -0.02779465f, 
    -0.02620967f, -0.02479632f, -0.02102214f, -0.02970356f, 0.04038871f, -0.05102235f, -0.06896512f, 0.03857411f, 
    -0.03556031f, -0.03775491f, 0.00569499f, -0.04637237f, 0.04633619f, -0.01540877f, 0.00761108f, 0.01420215f, 
    0.01402294f, 0.03828749f, 0.00529027f, 0.04301189f, 0.01844174f, 0.01784403f, -0.06188389f, -0.00742010f, 
    0.02385281f, 0.00333232f, -0.04618203f, 0.03038416f, -0.03215000f, -0.02784014f, -0.05010466f, -0.06746659f, 
    0.00073773f, -0.04008532f, 0.01880328f, -0.03191992f, 0.04082744f, 0.00935361f, -0.02298161f, 0.04443342f, 
    0.04578719f, -0.06003086f, 0.00663210f, -0.01223885f, -0.03786973f, 0.04890276f, -0.01471553f, -0.01192111f, 
    -0.03758483f, 0.00557811f, -0.01315226f, 0.00799404f, -0.05270366f, -0.02195193f, 0.04227829f, 0.01265439f, 
    0.01914144f, 0.03555581f, -0.02255259f, 0.02157920f, 0.02165885f, -0.00153697f, 0.01287629f, 0.02801856f, 
    -0.02635606f, -0.06972635f, 0.01127275f, 0.03558045f, -0.00156106f, 0.04887540f, -0.05550426f, -0.04339772f, 
    -0.03569821f, 0.03811552f, 0.00847790f, -0.00230473f, 0.04224113f, -0.01443467f, -0.06822233f, -0.01119442f, 
    0.01071642f, -0.03960069f, -0.05457237f, -0.03698490f, -0.01465512f, -0.02652939f, -0.04149132f, -0.06798091f, 
    -0.04625715f, 0.01935375f, 0.02897251f, -0.01084578f, 0.00456692f, -0.06039985f, 0.03817449f, 0.03487550f, 
    -0.01007091f, 0.01677295f, -0.06173045f, 0.04418240f, -0.06165072f, -0.02709823f, -0.04207103f, -0.04139225f, 
    -0.02085646f, 0.03472286f, -0.03274514f, -0.05815435f, -0.02353084f, 0.02451335f, 0.03753415f, -0.04930930f, 
    -0.04981980f, -0.03722104f, -0.01297392f, -0.03969501f, -0.01852263f, -0.04491674f, 0.03704168f, 0.01413951f, 
    0.03246599f, -0.02112383f, -0.04460346f, -0.01045392f, 0.02848856f, 0.04171151f, 0.00827657f, -0.03549301f, 
    0.00845410f, -0.05162254f, -0.00707340f, -0.03139852f, -0.00034452f, -0.01011868f, 0.03816434f, -0.04048593f, 
    0.01196157f, -0.03263034f, 0.03616459f, -0.03916290f, -0.01120487f, -0.04874324f, -0.03063444f, 0.01519436f, 
    0.01569447f, -0.04914175f, -0.00380749f, -0.02460776f, 0.02903737f, 0.01489289f, -0.04565145f, 0.02540138f, 
    -0.07300850f, 0.03484014f, -0.02695164f, 0.01863743f, -0.06298216f, 0.03019170f, -0.02128564f, -0.04566904f, 
    0.04710723f, 0.02131210f, -0.03317944f, 0.04254803f, 0.01171102f, 0.02974474f, 0.02731820f, -0.01581272f, 
    -0.04165725f, 0.02300251f, 0.04305247f, -0.04326788f, -0.04610990f, 0.01065636f, -0.01534525f, -0.05115625f, 
    0.00318105f, 0.01748936f, -0.02498243f, -0.06597571f, -0.03023682f, -0.06928682f, -0.05411780f, -0.02763795f, 
    0.00229698f, -0.06033340f, -0.00313620f, 0.02773602f, 0.01183370f, -0.05559286f, 0.02821708f, -0.05405489f, 
    -0.04399639f, -0.00520652f, -0.04028599f, -0.01019480f, 0.02362355f, -0.04425738f, 0.05370548f, -0.01667289f, 
    0.02136171f, -0.03172504f, -0.05985874f, -0.07265950f, -0.03207504f, -0.01943370f, -0.01819667f, 0.02745848f, 
    -0.02377702f, -0.02729867f, -0.06469025f, 0.01610743f, -0.00388935f, 0.04250377f, -0.04820496f, 0.00187936f, 
    -0.06068821f, -0.05192224f, -0.05673088f, 0.04423649f, -0.02472761f, 0.01451251f, -0.02152338f, 0.03199787f, 
    0.04708488f, 0.04727581f, -0.00076701f, -0.03403806f, 0.03026027f, 0.00539926f, -0.06322742f, 0.00199748f, 
    -0.04301845f, 0.03750622f, -0.05044315f, 0.03947523f, 0.02327196f, 0.03255158f, -0.05600797f, -0.01555792f, 
    -0.04682000f, 0.04103174f, 0.04383405f, -0.03280334f, -0.00180330f, -0.04260151f, 0.02839646f, -0.03436288f, 
    0.03649251f, -0.04638829f, 0.00766331f, 0.03661921f, 0.03745405f, 0.02778364f, -0.02212995f, 0.03080265f, 
    0.00409858f, -0.07174798f, 0.00699191f, 0.04724678f, -0.01692212f, 0.02028313f, 0.03310811f, 0.00883719f, 
    -0.03201074f, 0.02907107f, -0.03635016f, -0.01827277f, 0.00254784f, -0.01938638f, -0.05375894f, 0.04507162f, 
    0.00410298f, -0.02638347f, -0.01478010f, 0.03823122f, -0.04208323f, 0.04141834f, 0.03686545f, 0.03426380f, 
    -0.04809423f, 0.04501845f, -0.04220935f, 0.03889414f, 0.01100137f, 0.03562674f, -0.04414094f, -0.06633937f, 
    0.03617366f, -0.02619377f, 0.00163743f, 0.01877304f, -0.05058680f, 0.02939197f, 0.04042151f, -0.04807132f, 
    0.04317081f, -0.05590094f, -0.06517237f, -0.04028728f, -0.04768998f, 0.03548388f, 0.03113461f, -0.01748299f, 
    0.03249124f, 0.01384125f, -0.00997168f, -0.06039539f, 0.01146554f, -0.02886102f, 0.04614403f, -0.03579729f, 
    0.01217105f, -0.02183475f, 0.03461633f, -0.04030163f, 0.03129455f, -0.03208585f, 0.04303453f, 0.04400797f, 
    -0.03221754f, 0.01208285f, -0.03147937f, -0.04592453f, -0.06089329f, 0.03746377f, 0.03003901f, 0.03318225f, 
    -0.01142618f, -0.07770204f, -0.05625204f, -0.00016983f, -0.06582606f, -0.07358079f, -0.04275808f, -0.00491498f, 
    0.01003633f, 0.02951746f, -0.04830169f, -0.05942415f, -0.03730274f, -0.00760296f, -0.06045681f, -0.04566570f, 
    0.03713128f, -0.02359688f, 0.00370602f, -0.04169680f, 0.02601382f, -0.05343965f, -0.00913855f, 0.04135821f, 
    0.01586878f, -0.05934416f, 0.05104557f, 0.00956364f, 0.00328863f, -0.01483446f, 0.04279298f, -0.05478187f, 
    0.03448667f, -0.01438962f, -0.01605080f, -0.04449198f, 0.05895304f, -0.01009520f, 0.04522094f, 0.00833780f, 
    -0.04401882f, -0.03283192f, -0.01584139f, -0.06532181f, -0.06645808f, -0.02501658f, -0.05015764f, -0.03103974f, 
    0.01121591f, 0.02738766f, -0.00809558f, -0.00329368f, -0.01301452f, -0.01541419f, -0.00124496f, -0.06838030f, 
    -0.07303584f, -0.01870504f, -0.07219987f, 0.05176993f, 0.00948323f, -0.04005980f, -0.03319877f, -0.05447245f, 
    0.00149636f, -0.05465642f, -0.01386746f, 0.02459305f, -0.06456187f, 0.04377050f, -0.03084514f, -0.06128258f, 
    -0.03643552f, -0.00617277f, 0.01946236f, 0.02524642f, 0.00545886f, -0.06284165f, -0.03855025f, -0.06256485f, 
    -0.04555736f, 0.02445571f, 0.00233191f, -0.01763372f, 0.03125803f, -0.04052312f, -0.04147491f, -0.01338961f, 
    0.05306627f, -0.01695758f, 0.02480828f, -0.06291787f, 0.04359293f, 0.01180716f, -0.01302753f, -0.03395243f, 
    -0.07728814f, -0.03460655f, 0.02113473f, -0.05549861f, -0.03950980f, -0.04628376f, -0.02785313f, -0.01276136f, 
    -0.05194066f, -0.03175145f, -0.07111371f, -0.06277026f, -0.00853297f, 0.02335721f, 0.01866322f, 0.00678539f, 
    0.00585164f, -0.04442335f, -0.00901986f, -0.04994453f, -0.06180121f, 0.04884611f, -0.02471356f, 0.00997522f, 
    -0.00364560f, -0.00966408f, -0.00891102f, 0.00721968f, -0.05913718f, 0.02370845f, 0.04663349f, 0.02271650f, 
    -0.02426896f, 0.03568827f, -0.06553468f, -0.02164709f, 0.00133419f, 0.06155000f, -0.05170358f, -0.04548837f, 
    -0.01330644f, -0.03527520f, 0.05521169f, 0.00520793f, -0.01854455f, -0.04029511f, 0.00036381f, -0.05868917f, 
    -0.00103506f, 0.00553437f, -0.04683415f, -0.04172562f, -0.05445773f, 0.01465361f, -0.03115933f, 0.03399508f, 
    0.03962630f, -0.01301960f, 0.01050770f, 0.01335763f, 0.02345414f, -0.02484067f, 0.02380666f, -0.04083605f, 
    -0.06689018f, 0.04119729f, 0.02921707f, 0.02591085f, 0.02323072f, 0.00986822f, 0.00418931f, -0.04215696f, 
    -0.05062227f, -0.01465442f, -0.00576016f, 0.02273397f, -0.06102083f, -0.02069169f, -0.01110699f, 0.02303830f, 
    -0.04082714f, -0.05544352f, 0.04476807f, 0.03559338f, -0.01644792f, -0.00949076f, 0.00217139f, 0.02300890f, 
    0.04187802f, -0.06305269f, 0.02254095f, 0.03738227f, -0.03072271f, 0.04875993f, -0.05675493f, -0.04156215f, 
    -0.06527831f, -0.04452480f, 0.01631149f, -0.01825085f, 0.03635542f, -0.04301305f, -0.01886071f, -0.06285314f, 
    0.04181484f, -0.01640707f, 0.03774667f, -0.02364458f, -0.00932194f, -0.00828287f, -0.05128326f, 0.02344087f, 
    0.01243798f, 0.02640977f, -0.05663758f, -0.01716135f, -0.05096213f, 0.04645642f, 0.04164296f, -0.00470964f, 
    -0.04378852f, 0.02205971f, 0.04593580f, 0.00626283f, -0.02481281f, 0.01200210f, -0.02364518f, 0.03674785f, 
    -0.01714554f, 0.01762700f, -0.04319042f, 0.01062099f, 0.00870851f, 0.04543930f, 0.04190889f, 0.04487948f, 
    0.00867694f, -0.02252270f, -0.04692005f, 0.03044237f, -0.02997318f, -0.01758528f, -0.05509428f, 0.03582580f, 
    0.01722197f, 0.02040216f, -0.00285784f, -0.06264468f, -0.02494383f, 0.04120699f, 0.04684870f, -0.03958895f, 
    -0.04046214f, -0.03136626f, 0.00006465f, -0.05708474f, -0.05180081f, 0.04931803f, 0.02913399f, 0.02919937f, 
    -0.01839057f, -0.02356145f, 0.04456624f, -0.05692521f, 0.00783331f, 0.00839496f, -0.01036740f, -0.02895677f, 
    0.01558375f, -0.02042811f, 0.00735768f, -0.03669050f, 0.04279626f, 0.03889169f, 0.01854361f, -0.03787097f, 
    -0.01656730f, -0.05297408f, 0.03050527f, 0.01411969f, -0.04845838f, -0.04509446f, -0.02655442f, -0.04053379f, 
    -0.03026352f, -0.02618189f, -0.04105826f, 0.00533388f, 0.01371399f, 0.00637011f, 0.04025806f, 0.01350986f, 
    0.04950086f, -0.00299703f, 0.04702032f, -0.01302499f, -0.05549663f, 0.03251920f, -0.02301227f, -0.06664796f, 
    0.04180069f, -0.06627619f, 0.00207786f, -0.06030887f, -0.06184647f, 0.02059490f, 0.01543960f, 0.03842865f, 
    -0.04363184f, -0.04377067f, 0.01916653f, 0.01448158f, 0.00036915f, -0.02734488f, -0.05667585f, 0.01617814f, 
    0.04346464f, -0.01473215f, -0.03454526f, -0.03382591f, 0.01539322f, 0.00906902f, -0.06266056f, 0.04894374f, 
    0.03367834f, -0.06505997f, -0.02010690f, 0.02471115f, -0.01507477f, -0.06261905f, -0.05240849f, 0.02332389f, 
    0.00262775f, 0.04773915f, -0.01894705f, -0.06307430f, 0.05196768f, 0.01905586f, -0.02125099f, -0.01529028f, 
    0.02151791f, 0.04069828f, 0.02872183f, -0.05770018f, 0.05170736f, 0.05171180f, -0.00050183f, -0.02743155f, 
    -0.04415668f, 0.00939386f, -0.05717987f, -0.05513674f, -0.04104166f, 0.01318307f, -0.01293498f, -0.02779661f, 
    0.04562877f, -0.02698580f, 0.04847863f, -0.03507920f, 0.03364648f, 0.04121345f, -0.02083415f, -0.05380559f, 
    -0.05785470f, -0.00140810f, -0.01237687f, 0.01668513f, -0.03139432f, 0.01400920f, 0.01789112f, 0.05534459f, 
    0.00537197f, 0.02327846f, -0.06093198f, -0.05479523f, -0.01321867f, 0.02059917f, -0.01364779f, 0.03057023f, 
    -0.05928110f, 0.02769926f, 0.01710395f, -0.05255640f, -0.01432388f, 0.04973311f, 0.00886177f, -0.04186892f, 
    0.02664310f, 0.00340598f, -0.06881406f, -0.00686472f, -0.05168810f, -0.01844706f, -0.02900546f, 0.00227176f, 
    0.02295685f, -0.00817096f, 0.00544514f, -0.00575389f, -0.03884079f, -0.03370748f, -0.04515593f, 0.02841044f, 
    0.03285574f, 0.04421485f, -0.02936261f, 0.01432149f, -0.01355168f, 0.04738811f, -0.02141540f, 0.02273774f, 
    0.02138833f, -0.00700276f, 0.03152013f, 0.03374020f, -0.01222316f, -0.00944355f, -0.01096026f, 0.04630818f, 
    -0.03595538f, 0.02586550f, -0.02828113f, -0.03182280f, 0.03205002f, 0.01862927f, -0.02405801f, -0.02072691f, 
    -0.66329622f, -0.51311821f, -0.43853876f, 0.19660284f, 0.05209989f, -0.19765688f, 0.01705286f, -0.14056820f, 
    0.11581601f, -0.26345703f, -0.25082919f, -0.11983456f, -0.14362238f, -0.03366801f, 0.09372786f, -0.01738941f, 
    0.09976880f, -0.34504107f, -0.07111469f, -0.38035408f, -0.05654347f, 0.01925046f, -0.04552818f, -0.07248057f, 
    -0.20724727f, 0.03755518f, -0.16976655f, 0.38448197f, -0.04795720f, 0.10555008f, 0.03479619f, -0.01292468f, 
    -0.01947334f, 0.11707903f, 0.15419950f, -0.00415212f, 0.14425448f, -0.50177127f, -0.20803641f, 0.09188665f, 
    0.14107630f, -0.02297285f, -0.14679672f, 0.10181224f, -0.05808571f, 0.10616463f, 0.28801522f, -0.12157527f, 
    0.08100508f, 0.01833727f, 0.06547257f, -0.02903421f, 0.02232942f, -0.07823754f, 0.39759126f, -0.14604034f, 
    -0.02364353f, 0.16982065f, -0.04239852f, -0.07980495f, -0.02254887f, 0.04149856f, 0.18157269f, 0.24341950f, 
    0.19047807f, -0.28556907f, 0.03264080f, 0.05536228f, -0.17311886f, -0.00690701f, 0.09026716f, -0.01414789f, 
    -0.19814521f, 0.14301597f, 0.20284677f, 0.07500090f, 0.30370536f, 0.17385982f, -0.11360454f, 0.04078972f, 
    -0.07086477f, -0.26090860f, -0.52932858f, -0.11679526f, 0.27094477f, -0.16159901f, -0.02853492f, -0.09093890f, 
    -0.10548710f, -0.09900184f, -0.09324528f, -0.35380957f, 0.37743217f, 0.06149824f, 0.01572721f, -0.19347705f, 
    0.06155051f, 0.05493094f, 0.35139212f, -0.21712956f, -0.04119609f, 0.32479566f, 0.04303464f, 0.04314853f, 
    -0.12327996f, -0.07244266f, -0.02088764f, -0.09307095f, 0.37229964f, 0.29495189f, 0.23575413f, 0.02505437f, 
    -0.13814172f, -0.06276177f, 0.20550184f, 0.20784427f, 0.09755110f, -0.01317748f, 0.13327324f, 0.37743512f, 
    0.17018153f, -0.11087064f, 0.00488459f, 0.00442225f, -0.07346005f, 0.09020875f, 0.12365083f, 0.38640928f, 
    0.23574401f, 0.16104379f, -0.06636211f, 0.08311313f, 0.02559227f, 0.07070374f, -0.07908913f, -0.11253098f, 
    0.14721215f, 0.26250607f, 0.02279418f, -0.18461186f, 0.05426767f, 0.06806165f, -0.15704200f, -0.11888390f, 
    0.28441307f, 0.09876942f, 0.18399291f, 0.07435060f, -0.22934437f, -0.00634507f, 0.01388478f, -0.00417798f, 
    -0.05117326f, 0.47072491f, -0.08952407f, 0.10186560f, 0.11712274f, -0.08432008f, -0.09217551f, -0.18113062f, 
    -0.15030205f, -0.06165279f, -0.15331890f, -0.27583560f, -0.23112795f, -0.14120601f, -0.21962880f, -0.17584665f, 
    -0.03765815f, -0.31468740f, -0.02944482f, 0.53313005f, 0.21756552f, 0.20560643f, 0.08730905f, -0.33040860f, 
    -0.12607187f, 0.03629099f, 0.20723778f, 0.07804120f, 0.17578462f, 0.06696768f, -0.16868556f, 0.09734797f, 
    0.06073026f, 0.16825087f, -0.10446066f, -0.02085352f, 0.15178066f, 0.45416740f, -0.53119230f, -0.25766072f, 
    -0.10799399f, -0.03662976f, 0.06818535f, -0.06116144f, 0.03207945f, 0.11208744f, -0.35958472f, 0.58212906f, 
    -0.17071126f, 0.06371562f, -0.10746033f, -0.10031175f, 0.00513273f, 0.09589731f, 0.10162104f, -0.09536628f, 
    0.53582704f, 0.13148101f, 0.22644521f, 0.09560452f, 0.29992983f, 0.09847777f, -0.02208034f, -0.02126954f, 
    0.35245657f, 0.65524262f, 0.23564923f, 0.10530504f, 0.09416120f, 0.26218992f, 0.14801160f, 0.03246648f, 
    0.00096292f, -0.09779538f, -0.02782414f, -0.36326629f, -0.09321742f, 0.03708196f, -0.01146722f, 0.00249122f, 
    -0.02858231f, 0.14905789f, 0.05955902f, 0.22908252f, -0.20542312f, -0.22797143f, -0.15324806f, 0.22034259f, 
    0.06586906f, -0.20498766f, 0.34475020f, 0.02193827f, -0.09481160f, -0.28348333f, 0.08654879f, -0.10778360f, 
    0.15380459f, 0.12117942f, -0.09812456f, 0.10172404f, -0.32571968f, -0.19239190f, 0.10540949f, -0.01875066f, 
    0.10701783f, 0.03000904f, -0.01861517f, -0.09883582f, -0.07464955f, -0.16695379f, 0.41368297f, 0.17526878f, 
    -0.04616341f, 0.17121440f, 0.11231168f, 0.23594670f, -0.01369771f, -0.43582007f, -0.14819391f, -0.00118900f, 
    -0.13044153f, -0.46673161f, 0.10602167f, -0.00010310f, -0.15272649f, 0.00081535f, -0.06202882f, -0.34493700f, 
    -0.41124713f, -0.17217210f, -0.17727380f, -0.23367472f, -0.11771810f, 0.04457214f, 0.08925626f, 0.01601411f, 
    -0.00332080f, -0.03779055f, -0.04389031f, -0.00439041f, -0.03231357f, -0.00428546f, 0.00267110f, -0.05110983f, 
    -0.02514945f, -0.00522885f, -0.02469945f, -0.05033843f, 0.03505795f, 0.01102149f, -0.02530419f, 0.03748221f, 
    0.04217140f, -0.00731013f, 0.01011336f, 0.01935611f, -0.04054108f, -0.00708882f, 0.00325055f, -0.01800228f, 
    0.02442807f, -0.01328381f, -0.04425773f, 0.04915364f, -0.05510270f, 0.03899239f, 0.04673331f, 0.04515545f, 
    0.00182847f, 0.00865575f, -0.02466388f, -0.04762258f, -0.06074952f, -0.01898850f, -0.00980650f, 0.04265252f, 
    0.01074274f, -0.03328598f, 0.00631905f, 0.03396714f, -0.05004509f, -0.04113930f, 0.04693493f, 0.01970069f, 
    -0.02243790f, -0.03093197f, -0.05442895f, 0.03910278f, -0.04128613f, -0.03383425f, -0.05155389f, -0.02749897f, 
    0.00445343f, -0.05185434f, -0.02281793f, -0.03893146f, -0.00853387f, -0.03956613f, -0.04427408f, 0.03817928f, 
    -0.05290494f, -0.02550261f, 0.00047405f, 0.04063126f, -0.03510594f, 0.04903993f, 0.02546556f, -0.04970885f, 
    -0.00969421f, 0.03338065f, -0.04234189f, 0.00907010f, 0.00953030f, 0.04601718f, 0.04675493f, 0.04312471f, 
    -0.00751352f, -0.05695399f, 0.02221594f, 0.04899526f, 0.04578818f, -0.01132797f, -0.04161287f, -0.06045621f, 
    0.03818309f, -0.05369350f, 0.03362142f, -0.00043632f, -0.01168166f, -0.00049463f, 0.05060690f, -0.00599411f, 
    0.04772933f, 0.00299233f, -0.05654156f, 0.01191515f, -0.04531060f, -0.05661264f, 0.01819643f, -0.02677010f, 
    -0.03190519f, -0.02260390f, -0.03123422f, 0.03237462f, 0.04192771f, -0.00915009f, -0.00443096f, -0.00214683f, 
    -0.00481640f, -0.04583129f, -0.03618611f, 0.02466808f, 0.00454798f, -0.03312714f, 0.03695605f, 0.00553190f, 
    -0.05247650f, 0.03235501f, -0.01408041f, -0.03903009f, -0.00565783f, -0.04820225f, -0.00739407f, -0.01100141f, 
    -0.05136112f, -0.02891665f, 0.02180352f, 0.01203419f, -0.02715752f, -0.05241396f, -0.05887324f, -0.02660090f, 
    0.01822138f, -0.06144651f, 0.01542497f, -0.05314652f, -0.01506647f, -0.06461968f, -0.05189030f, 0.00034806f, 
    -0.00807395f, -0.05679072f, -0.04042701f, -0.01155993f, -0.01799540f, 0.00002921f, 0.01216707f, -0.00507627f, 
    -0.00802725f, -0.06175356f, 0.02443926f, -0.02719155f, 0.01455063f, -0.05330382f, 0.02429442f, -0.04803662f, 
    0.04980772f, -0.03673821f, -0.01174857f, 0.03108313f, -0.01683705f, -0.05043883f, -0.02647784f, -0.06385379f, 
    0.03691243f, -0.02858489f, -0.03819810f, -0.04413282f, -0.00230478f, 0.02736444f, -0.03477950f, 0.00545241f, 
    0.03242180f, -0.05345456f, -0.00078437f, -0.02223183f, -0.03479660f, 0.04380455f, -0.05200529f, -0.03368661f, 
    0.00755990f, 0.01658680f, -0.05971460f, -0.05686551f, 0.01747892f, -0.05520509f, -0.05517429f, 0.00835606f, 
    0.00392575f, -0.04831850f, 0.02388196f, -0.05511699f, 0.04785501f, -0.04928681f, -0.04794502f, -0.06091289f, 
    -0.06137859f, -0.04357334f, -0.02369574f, -0.04907141f, 0.02843002f, -0.02795303f, -0.01513932f, -0.05879202f, 
    -0.06440169f, 0.00438079f, 0.01082026f, 0.04251853f, -0.00516593f, 0.01988624f, 0.03771443f, -0.04953337f, 
    -0.05223994f, -0.01126725f, -0.05270978f, -0.06389956f, 0.05155223f, 0.02443657f, 0.03855872f, -0.00853661f, 
    0.02791743f, 0.02927825f, -0.03270676f, 0.03294539f, -0.02633992f, 0.01769614f, -0.01492950f, -0.01652091f, 
    -0.03118836f, -0.05678521f, 0.03011988f, -0.03476388f, 0.03429423f, -0.05440817f, -0.02621698f, -0.00729825f, 
    0.05203453f, 0.01841020f, -0.02372930f, -0.02017917f, 0.01527365f, -0.03099434f, -0.01417222f, 0.03307950f, 
    0.01553072f, 0.03193691f, -0.04527549f, -0.01186602f, -0.04344218f, -0.05347187f, -0.04534488f, -0.03014502f, 
    -0.01762477f, -0.05197452f, 0.01700609f, -0.04226568f, 0.03405363f, 0.01832462f, 0.04674629f, -0.02051777f, 
    0.01950363f, -0.00779767f, -0.06351191f, -0.00904313f, -0.02448900f, 0.04369363f, 0.04745888f, 0.01851438f, 
    0.05007570f, 0.04222111f, -0.04677045f, -0.03392123f, -0.02370244f, 0.05100701f, -0.02445843f, 0.00721208f, 
    0.05069059f, 0.01901515f, -0.05437759f, 0.03690137f, 0.00128588f, 0.01210340f, -0.00602757f, -0.04983189f, 
    0.03373769f, -0.03439140f, -0.01116641f, -0.01305543f, 0.02047935f, -0.00957908f, 0.03397936f, -0.01383331f, 
    0.00664112f, -0.02001056f, -0.02315384f, 0.05785117f, -0.00751836f, 0.03297433f, 0.04395652f, -0.03017032f, 
    0.02011939f, 0.04626842f, -0.03394573f, 0.02427841f, 0.03917142f, 0.04220468f, -0.00724174f, 0.04910534f, 
    -0.02560037f, -0.01509184f, 0.04613060f, 0.00881483f, 0.02555027f, -0.02293395f, -0.04045510f, -0.03459171f, 
    -0.03485961f, -0.03746226f, 0.00496682f, -0.04663592f, 0.04015412f, 0.02838443f, -0.00666976f, 0.03973942f, 
    0.01034240f, 0.05791724f, -0.03349669f, 0.04252028f, -0.00625796f, 0.03892997f, -0.00809829f, -0.04690136f, 
    0.02449163f, 0.02733636f, -0.05732365f, -0.06153510f, 0.02751134f, -0.02856501f, -0.01465146f, -0.00108088f, 
    -0.03819683f, 0.02237550f, 0.01560807f, -0.02934039f, -0.02365214f, -0.04666976f, -0.05755852f, -0.03636130f, 
    -0.03060535f, 0.05256022f, 0.00996221f, 0.03228514f, -0.04568070f, -0.00969834f, 0.02890183f, 0.00641511f, 
    -0.03224007f, 0.03592899f, -0.00560277f, 0.00425850f, -0.05028626f, 0.01051376f, -0.02188674f, -0.02225342f, 
    0.02696011f, 0.03626680f, -0.05890401f, -0.03261661f, 0.03153834f, 0.03481922f, 0.06489860f, -0.03735371f, 
    0.04352282f, -0.00298069f, -0.03926792f, 0.00799670f, -0.00698170f, -0.03072276f, -0.00566305f, 0.03520155f, 
    -0.04928438f, -0.00636368f, -0.01299359f, -0.01305548f, -0.03963938f, -0.05526043f, -0.03510701f, -0.05031431f, 
    -0.01396154f, -0.03685201f, -0.05435315f, -0.05309206f, 0.01352733f, -0.00899263f, -0.06413760f, 0.00144861f, 
    0.01454817f, -0.05084572f, 0.00474823f, 0.03671607f, 0.00222745f, -0.02493932f, 0.04025810f, -0.05211930f, 
    -0.00800055f, -0.02569461f, 0.04096458f, -0.06947706f, -0.06364640f, 0.01217340f, 0.02387633f, 0.00338742f, 
    0.02746711f, -0.03602793f, -0.00120386f, -0.01618569f, -0.03218411f, -0.01645068f, 0.02569487f, 0.03254059f, 
    0.04681294f, -0.05120751f, -0.00782519f, -0.05514424f, -0.04970126f, 0.03413540f, -0.04701284f, -0.06301896f, 
    -0.05958890f, 0.02073629f, 0.01618096f, 0.01505647f, 0.01055397f, 0.02164325f, 0.03408979f, -0.05805166f, 
    0.01039466f, -0.03326138f, -0.02245077f, -0.00966615f, -0.04739462f, 0.03697189f, 0.03060293f, 0.03554757f, 
    -0.05291448f, -0.01948255f, -0.04307323f, -0.02432453f, -0.05700026f, -0.00704103f, 0.04495328f, -0.01346395f, 
    -0.02816990f, -0.04551074f, -0.03545747f, -0.03412229f, -0.05125486f, -0.00450261f, 0.00345345f, -0.01278866f, 
    0.03425623f, -0.02748056f, -0.05783466f, -0.06477018f, -0.00654978f, 0.03868944f, -0.04898908f, -0.05094798f, 
    -0.02101687f, -0.01345332f, -0.01307323f, 0.01740365f, 0.03500141f, 0.02001425f, -0.00866415f, -0.06240460f, 
    -0.01282924f, 0.01160899f, 0.04432760f, 0.03271005f, 0.04573258f, -0.04517015f, -0.02466022f, 0.04147583f, 
    0.02707876f, -0.06804039f, -0.03078621f, 0.01923116f, -0.02817386f, -0.04466553f, 0.05161628f, -0.05276654f, 
    -0.03569697f, -0.04502383f, -0.06896400f, 0.02856928f, -0.01756966f, 0.03711491f, 0.03318524f, -0.05245800f, 
    -0.05915990f, -0.05472770f, -0.02730414f, -0.04607385f, -0.00709803f, 0.00207196f, 0.00199681f, 0.06892373f, 
    0.01650356f, 0.04548382f, 0.04532850f, 0.03771134f, -0.05816501f, 0.03986031f, 0.04279086f, 0.03632107f, 
    -0.04834599f, 0.05053791f, -0.02568687f, 0.01235049f, -0.02104045f, -0.00244045f, -0.03989152f, 0.00354707f, 
    0.01512821f, 0.00347352f, -0.03478700f, -0.04202904f, 0.02679579f, -0.00096227f, 0.01377319f, 0.04065108f, 
    -0.00532225f, -0.04689671f, -0.04556882f, -0.03538490f, -0.00302322f, 0.00383674f, 0.00825974f, 0.03476172f, 
    -0.04115742f, -0.04436797f, -0.01124634f, 0.04585388f, 0.01404356f, -0.03003623f, 0.04630108f, -0.02123278f, 
    -0.04989650f, -0.06035126f, 0.03803251f, -0.05800784f, -0.04798045f, 0.03318290f, -0.06390492f, 0.02160713f, 
    0.03362081f, -0.04819195f, 0.00051429f, 0.04598456f, 0.00254871f, -0.00526000f, -0.01617826f, -0.04909710f, 
    0.00895003f, 0.03534612f, -0.06611511f, 0.00663266f, -0.03488476f, -0.01721569f, 0.05436505f, -0.02647500f, 
    -0.46542460f, 0.03558912f, 0.06478614f, 0.00148124f, -0.00128645f, 0.07931162f, -0.10252579f, -0.28582948f, 
    0.06400730f, 0.20046966f, 0.21980999f, 0.02786000f, -0.08286476f, 0.01372275f, 0.01178537f, 0.08219497f, 
    0.06403667f, -0.35477820f, -0.13897826f, -0.31043115f, -0.36903679f, -0.27024618f, 0.16070212f, -0.01881733f, 
    -0.25994456f, -0.23510876f, -0.22895752f, 0.46193570f, 0.32420439f, -0.08700217f, -0.24608774f, -0.05108404f, 
    -0.01704334f, -0.28313699f, 0.05553190f, 0.04898077f, 0.41130710f, 0.15365641f, 0.11288381f, -0.10635575f, 
    0.04164765f, 0.05186630f, -0.08940888f, -0.26029074f, -0.21691722f, 0.11846169f, 0.06203272f, -0.25832930f, 
    -0.11997560f, -0.05533868f, -0.05827876f, 0.08775036f, 0.00818926f, 0.11752068f, 0.11067325f, 0.17490539f, 
    -0.09301173f, -0.01960121f, 0.13284025f, -0.10348768f, 0.16567996f, 0.18855157f, 0.08228648f, -0.28767961f, 
    0.22462139f, 0.24856296f, 0.24004897f, -0.07706492f, 0.14846516f, 0.02016611f, -0.13557692f, -0.08934330f, 
    0.16831015f, 0.05610207f, -0.22261447f, 0.24675964f, 0.08935945f, -0.03489623f, 0.29399899f, 0.22473185f, 
    0.06807370f, 0.15579256f, 0.18825619f, 0.17211916f, -0.14092074f, 0.06285345f, -0.07949375f, -0.13319416f, 
    -0.08124385f, 0.02100336f, 0.11980931f, -0.19549973f, -0.00650864f, 0.07725751f, -0.08797797f, 0.14903800f, 
    -0.37766546f, 0.02862988f, -0.18923318f, -0.71906722f, 0.20446555f, -0.05228821f, 0.03933131f, -0.23392327f, 
    0.04450204f, 0.08930981f, 0.20323449f, 0.08064912f, -0.03733641f, -0.25229409f, 0.04543717f, -0.08200456f, 
    -0.12952839f, 0.15570977f, -0.08081287f, 0.07700107f, 0.09390620f, -0.54435444f, -0.38199317f, 0.23270544f, 
    -0.15590987f, 0.00434853f, -0.17233397f, -0.09110114f, 0.05546715f, 0.04173215f, 0.05149874f, 0.10937249f, 
    -0.01332901f, -0.21857385f, -0.17825045f, -0.09536600f, 0.01486508f, -0.01266706f, 0.06187212f, -0.23809822f, 
    -0.62072921f, 0.09196441f, -0.11756702f, 0.10494815f, 0.05342905f, -0.18250597f, -0.05605942f, 0.11943527f, 
    -0.24151455f, 0.05338211f, -0.26309428f, -0.17349935f, -0.36504814f, -0.07725497f, -0.02065401f, 0.25529477f, 
    0.05153916f, 0.16407038f, 0.23492336f, 0.19614425f, 0.02790058f, -0.11359843f, -0.01166588f, -0.21522656f, 
    -0.07994161f, -0.02287202f, 0.08859272f, -0.21091127f, -0.17241454f, 0.04239446f, 0.05423015f, 0.10450539f, 
    -0.07025545f, 0.15193817f, 0.03068414f, -0.37344345f, 0.15448059f, -0.12632820f, 0.00339978f, 0.08098371f, 
    -0.02354380f, 0.22640875f, 0.13954577f, 0.17934644f, -0.07700729f, 0.08940417f, 0.27247471f, 0.03404332f, 
    -0.06083199f, -0.11113286f, -0.01050458f, -0.11153194f, -0.19045308f, 0.54107261f, -0.03527594f, -0.13097566f, 
    0.01578691f, -0.01826031f, 0.03113676f, -0.01314565f, 0.31602323f, 0.19895132f, 0.02241730f, -0.00071740f, 
    -0.02508799f, -0.13435540f, -0.23033948f, 0.02837838f, -0.10426184f, 0.20399950f, 0.12610598f, -0.03751686f, 
    0.23101263f, 0.21106976f, 0.23261601f, 0.08538367f, 0.06174329f, 0.11884118f, 0.26246455f, 0.00739991f, 
    -0.05906753f, 0.08531880f, 0.38546410f, 0.25362813f, -0.20565195f, -0.12757798f, 0.17141502f, 0.04875016f, 
    -0.11721905f, 0.22193584f, -0.17430812f, -0.33314335f, -0.18213367f, 0.05445537f, -0.07868884f, -0.28232485f, 
    -0.19433884f, 0.04088655f, -0.37681767f, 0.04604924f, 0.14998825f, -0.10825253f, 0.01413563f, 0.32872045f, 
    -0.33251753f, 0.23040690f, -0.14356641f, 0.20153324f, -0.23476066f, 0.02124772f, 0.05516651f, -0.01015331f, 
    0.02381316f, 0.04471047f, -0.06522667f, -0.05304111f, 0.42413560f, -0.03160235f, 0.06146742f, 0.12055615f, 
    0.05750130f, 0.03227790f, -0.14051898f, 0.01539394f, -0.03887996f, 0.26080486f, 0.10496494f, 0.03057207f, 
    0.01963397f, 0.20216307f, 0.35307008f, 0.10516812f, 0.21063873f, -0.12899372f, 0.30667409f, -0.12197245f, 
    -0.12637885f, -0.08053457f, -0.02982697f, 0.05053230f, -0.06450082f, 0.14150015f, -0.02042475f, 0.64215559f, 
    0.00007964f, -0.07207728f, 0.07817748f, -0.07112628f, 0.05558175f, -0.14323434f, 0.11091697f, -0.39545068f, 
    0.02297661f, 0.05203931f, -0.03935614f, 0.01903832f, 0.04788711f, 0.02681001f, -0.04825399f, 0.03511898f, 
    0.01363296f, 0.02819442f, -0.01795609f, -0.01528710f, 0.05148932f, 0.00260077f, 0.02285641f, -0.02740656f, 
    -0.06318177f, -0.02803421f, -0.01506579f, 0.04272573f, 0.04049226f, -0.00799343f, -0.04153915f, -0.03119860f, 
    0.00271432f, 0.01433691f, -0.04204140f, 0.00705035f, -0.05916592f, 0.03681204f, -0.04795750f, -0.03431212f, 
    -0.02138520f, 0.01750408f, -0.00541577f, -0.06104198f, 0.01760090f, -0.02769021f, -0.02138956f, -0.02906246f, 
    -0.01170342f, -0.05974138f, 0.03154812f, -0.05649063f, -0.04292344f, 0.04844546f, -0.01305524f, -0.03791020f, 
    -0.03780908f, -0.06030732f, -0.06618124f, -0.01752640f, -0.00767069f, 0.01030499f, 0.01026104f, -0.05642059f, 
    0.00019552f, -0.03083665f, -0.00914374f, -0.06292672f, 0.02163143f, -0.01092269f, 0.00236524f, -0.00777591f, 
    -0.06007089f, 0.01557579f, 0.04093779f, 0.00187574f, -0.01950649f, 0.02946339f, -0.05995979f, -0.00898055f, 
    0.01969228f, -0.02035368f, 0.02719591f, -0.05569590f, -0.06384113f, -0.04822386f, 0.01934822f, 0.04982757f, 
    0.01924112f, 0.00051710f, 0.00609716f, 0.02941645f, 0.04587157f, -0.05682553f, -0.03368228f, -0.00845660f, 
    -0.05385832f, 0.00676486f, 0.01260596f, -0.06308070f, -0.01942383f, 0.00549728f, -0.02374693f, 0.03253392f, 
    0.04575501f, 0.00504240f, -0.02117852f, -0.04923644f, -0.04772047f, -0.02335443f, 0.02853640f, 0.02039410f, 
    -0.05115137f, -0.00650067f, -0.01660587f, 0.01459224f, 0.01958091f, 0.03076072f, 0.00854679f, -0.06393354f, 
    -0.04516197f, -0.03574306f, -0.00942315f, 0.02113534f, 0.02863158f, 0.03270237f, 0.02486662f, -0.04085695f, 
    -0.04318452f, -0.05014480f, 0.03057910f, -0.01099485f, 0.00351797f, 0.01546001f, -0.04872764f, -0.03835089f, 
    -0.00631192f, -0.01462330f, 0.02041467f, 0.00008047f, -0.04210629f, 0.03630117f, -0.00927436f, -0.03375356f, 
    -0.04113832f, 0.01405453f, 0.00460475f, -0.02089019f, 0.01288977f, -0.06661473f, -0.00086737f, 0.02568918f, 
    -0.00957167f, -0.05365717f, 0.00253424f, 0.04041121f, -0.04808157f, 0.04503867f, 0.04826054f, -0.02325280f, 
    -0.00688215f, 0.00819149f, -0.00852145f, -0.02591385f, 0.01476283f, -0.04575842f, -0.01107288f, -0.03192024f, 
    -0.02443975f, -0.02785225f, -0.03855276f, 0.03611971f, -0.00148788f, -0.04891108f, -0.07253353f, -0.04599603f, 
    0.02710548f, -0.05359953f, -0.01014188f, -0.05276016f, 0.03644095f, -0.01438379f, 0.02709848f, -0.05274604f, 
    0.04489737f, 0.04942559f, -0.03103120f, -0.06624144f, 0.03835369f, -0.05928196f, -0.03625378f, -0.04737543f, 
    -0.04455734f, -0.04327020f, 0.03793463f, 0.02440524f, -0.05088731f, 0.03903815f, -0.03515014f, -0.05074129f, 
    0.02600426f, -0.00467818f, -0.03253312f, -0.03260292f, -0.05415289f, -0.03985934f, -0.02635080f, 0.03039933f, 
    0.02393011f, 0.00697991f, -0.03116008f, 0.04758163f, -0.06088744f, -0.01341909f, 0.03436699f, 0.02654808f, 
    -0.05175738f, -0.02859139f, -0.03446615f, -0.05816375f, -0.04390331f, -0.03064940f, -0.02975395f, -0.06105959f, 
    0.02285953f, 0.02915506f, 0.04758037f, 0.01241854f, 0.05117069f, -0.04394575f, -0.06667215f, 0.02207486f, 
    -0.01287791f, 0.01862205f, -0.04376267f, 0.00966738f, 0.03782952f, 0.01352731f, 0.00921106f, -0.05652829f, 
    -0.06286814f, -0.04212755f, 0.05843449f, -0.00838211f, 0.01392977f, -0.00431939f, 0.01243141f, 0.04348736f, 
    0.04975168f, 0.00136519f, 0.01381284f, 0.02459915f, -0.05475588f, -0.05199519f, 0.03921124f, -0.00785462f, 
    -0.01907700f, -0.04015944f, -0.04474283f, 0.02289063f, -0.01643502f, -0.01081625f, 0.03194392f, 0.02425857f, 
    0.00938702f, 0.01553308f, -0.02096413f, 0.02985282f, 0.00475391f, 0.05356086f, -0.04922042f, 0.04425480f, 
    0.02347201f, 0.03964702f, 0.04876480f, 0.00895127f, 0.04288090f, -0.05273016f, -0.02332161f, -0.05731905f, 
    0.03490832f, -0.01890277f, 0.00689724f, -0.00778266f, -0.01349097f, 0.01462977f, -0.02166258f, 0.03135165f, 
    -0.05930288f, 0.00562607f, 0.03207579f, 0.04774683f, -0.05564876f, 0.01221057f, -0.00187579f, 0.00711679f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.01459202f, 0.18211372f, 0.09448785f, 0.07698421f, 0.04584525f, 0.03195943f, 0.02693864f, -0.22730608f, 
    0.31429622f, -0.00820505f, -0.00322893f, -0.00310646f, 0.22349264f, -0.02474050f, -0.03792448f, -0.02094913f, 
    -0.05691365f, -0.04980034f, -0.03897787f, 0.15592283f, 0.16179250f, -0.08552253f, 0.00526959f, -0.03394765f, 
    -0.02480243f, -0.02173866f, 0.01750810f, 0.15607345f, 0.05164645f, -0.03942544f, 0.03273528f, -0.02053887f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.71107632f, 0.24787301f, 0.09064572f, -0.17770238f, 0.39248633f, -0.07499591f, -0.12087051f, -1.07652211f, 
    -0.40216354f, -0.14396514f, 0.12140626f, -0.06177521f, 0.56905150f, -0.34348911f, -0.04882203f, 0.07147052f, 
    -0.01826515f, -0.64820516f, -0.06054683f, -0.38476554f, -0.35495180f, 0.36823159f, 0.39185998f, 0.15068670f, 
    -0.15684661f, -0.03615381f, -0.05153940f, 0.30756959f, -0.13347772f, -0.13476577f, 0.00582631f, -0.06438561f, 
    0.29780394f, -0.65942460f, -0.22267419f, -0.17234387f, 0.06511981f, 0.23650499f, -0.08733815f, 0.36609754f, 
    0.07033043f, -0.00579733f, 0.06484635f, -0.10205571f, 0.74456763f, 0.25725132f, -0.10903149f, -0.04328893f, 
    -0.01067672f, -0.05378405f, -0.11503701f, -0.36383513f, 0.14235897f, -0.40074170f, -0.53749162f, 0.00420661f, 
    -0.05145743f, 0.15167251f, 0.11013364f, 0.31456971f, -0.14067778f, -0.15536229f, 0.26325783f, -0.15389283f, 
    0.09982324f, -0.80448878f, -0.30662075f, -0.19213814f, -0.03917024f, 1.07947397f, 0.15355314f, -0.16970356f, 
    -0.25619352f, -0.10893308f, 0.10031942f, 0.08586331f, -0.37240010f, 0.52599353f, 0.09846578f, -0.04262664f, 
    -0.00617406f, -0.19918510f, 0.10385803f, -0.08455735f, 0.51804924f, -0.13771801f, 0.28870326f, 0.04440397f, 
    -0.09247621f, 0.02470791f, 0.02225590f, -0.20713907f, 0.04493147f, 0.11613125f, -0.68020624f, -0.11365423f, 
    -0.07236042f, 0.31658188f, -0.43924168f, 0.53638500f, -0.35413787f, -0.17425342f, 0.01177756f, -0.82244956f, 
    -0.31663084f, -0.00663480f, -0.16311027f, -0.04777783f, -0.04562987f, 0.07633947f, 0.11074965f, 0.16200113f, 
    -0.05490408f, 0.26719409f, -0.11716264f, -0.21740720f, 0.21359335f, 0.53956419f, -0.18279965f, 0.10113820f, 
    -0.15799862f, -0.08154680f, 0.01457177f, -0.54941875f, 0.15629740f, 0.09135649f, 0.68842691f, -0.13775630f, 
    -0.65654767f, 0.05393201f, 0.13137662f, 0.46761006f, -0.61551160f, -0.13113360f, 0.11180869f, -0.62369752f, 
    0.38353589f, 0.10749418f, -0.08899122f, 0.08836960f, -0.14958368f, -0.13799579f, 0.14748511f, -0.06180776f, 
    0.13930610f, -0.62440020f, -0.12791815f, 0.27378273f, -0.32647800f, 0.33977056f, 0.37923792f, -0.06488047f, 
    0.16563401f, 0.03421821f, -0.03768275f, 0.31529465f, -0.08047395f, 0.05858169f, -0.18076320f, 0.16535519f, 
    -0.64850813f, -0.21218513f, -0.14812826f, -0.50736165f, 0.27924392f, -0.10163900f, -0.02674274f, 0.10060658f, 
    0.70537460f, 0.10350727f, 0.17170829f, -0.10954183f, -0.06287810f, -1.09005618f, -0.15117709f, -0.07887267f, 
    0.06352661f, 0.09735171f, 0.09158750f, 0.07512873f, -0.25221190f, -0.63846147f, 0.17593695f, -0.08848322f, 
    0.05017766f, 0.08036149f, 0.10676948f, -0.14158028f, 0.15804729f, 0.10066038f, 0.34810281f, 0.17051783f, 
    1.14669979f, -0.05237198f, -0.25307468f, 0.45019355f, 0.24575274f, -0.65650588f, -0.07032267f, -0.45310077f, 
    0.13704652f, 0.10816705f, -0.07544928f, -0.06264846f, -0.42429450f, -0.24497545f, 0.14335218f, -0.04672722f, 
    -0.02898815f, -0.22719613f, 0.03950216f, 0.00397820f, -0.24478349f, -0.33380923f, 0.14748198f, 0.15548196f, 
    0.02361849f, 0.15466353f, -0.12616256f, 0.22207445f, 0.04410071f, -0.03427064f, -0.40329441f, 0.00212466f, 
    -0.28603581f, 0.19167504f, 0.13674736f, -0.17373994f, -0.15975311f, 0.09916517f, -0.01177021f, 0.96035641f, 
    -0.29764861f, -0.09758059f, 0.07556266f, 0.01583353f, -0.46574041f, 0.03914459f, -0.14991985f, 0.09005839f, 
    -0.08076752f, 0.08282880f, 0.03861260f, -0.40347344f, -0.50843221f, 0.49651071f, 0.32841757f, 0.11974877f, 
    0.00385162f, 0.07819934f, 0.08636671f, -0.25671634f, -0.17826575f, -0.13992324f, 0.08670247f, 0.11612313f, 
    -0.22497670f, 0.01163671f, -0.34838611f, -1.06039178f, 0.21469496f, -0.23333621f, 0.12130547f, -0.38694325f, 
    0.07063576f, -0.16208686f, -0.05656979f, -0.01750786f, -0.50011218f, 0.55457950f, 0.13344869f, -0.04998208f, 
    0.14678597f, 0.40732709f, 0.05190951f, 0.38267723f, -0.27440074f, -0.35855797f, -0.74969399f, -0.10279746f, 
    -0.09896380f, -0.04091232f, -0.03725570f, 0.80590272f, -0.05754042f, 0.00902271f, -0.17729513f, -0.15276699f, 
    -0.21382967f, -0.09836252f, 0.35974041f, -0.03309367f, 0.35632995f, -0.51402998f, 0.15328345f, 0.40368432f, 
    0.09845743f, 0.08062027f, 0.15221335f, 0.01731829f, -0.20984036f, 0.93547475f, -0.02561373f, -0.02431800f, 
    0.00663554f, -0.54445857f, -0.08858728f, 0.15305531f, -0.26857612f, -0.15686034f, -0.03353412f, 0.07037254f, 
    0.13978012f, 0.12014046f, 0.03053483f, -0.56677437f, 0.04492385f, -0.12526658f, -0.30196470f, -0.16785850f, 
    0.20512848f, 0.52863961f, -0.24772777f, -0.15410404f, 0.06123021f, 0.37125593f, -0.08496168f, -0.41101462f, 
    -0.70937520f, 0.02523270f, 0.06039324f, 0.00878880f, -0.37533936f, -0.56979418f, -0.17750974f, 0.06984787f, 
    0.02586141f, -0.10676769f, -0.02247005f, 0.18722111f, 0.82986403f, 0.03765339f, 0.01280654f, -0.00800702f, 
    -0.00978736f, 0.10720740f, 0.05130860f, -0.33825722f, -0.12887973f, -0.01577706f, -0.38901857f, 0.13581258f, 
    -0.10818736f, -0.28276008f, 0.78308725f, 0.07719000f, -0.28681669f, -0.11333852f, 0.06282544f, 0.20462686f, 
    -0.11257436f, 0.08547106f, -0.14711563f, 0.09263239f, -0.11427123f, -0.30058920f, -0.02536720f, -0.15838972f, 
    -0.04904043f, 0.89313817f, -0.12905258f, 0.14850117f, 0.18428934f, -0.31513807f, -0.15431003f, 0.03894585f, 
    -0.12993741f, -0.09900999f, -0.11804984f, -0.03941799f, 0.12426134f, -0.16015399f, -0.80451304f, 0.16928209f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.09515548f, -0.03719144f, -0.26272801f, -0.33402941f, 0.04729926f, 0.18073539f, 0.06574100f, -0.31144091f, 
    -0.40314972f, 0.20964703f, 0.15582120f, 0.12603155f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
