#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.83932048f, 0.42228946f, 0.83982646f, -0.02069947f, 0.29567084f, -0.31323770f, 0.18782163f, 0.48662135f, 
    0.20494576f, 0.09905997f, -0.34770742f, 0.19271080f, 0.62397522f, 0.60787266f, -0.78640658f, 0.45505655f, 
    0.11231916f, -0.26313984f, -0.94693261f, 0.94976223f, -0.13885781f, -0.17113073f, -0.07758670f, -0.01170604f, 
    -0.08885925f, 0.20997693f, -0.02391143f, -0.57829672f, -0.47130960f, -0.65919924f, 0.45557463f, 0.70982051f, 
    -0.20237850f, -0.07847361f, -0.11472022f, -0.20968175f, -0.58220369f, -0.56720579f, -0.60459626f, 0.32890034f, 
    -0.15087378f, 0.59871763f, 0.38056326f, 0.12651768f, 0.34627703f, -0.90626270f, -0.72105819f, -0.49306807f, 
    -0.20105462f, -0.54568350f, -0.36361244f, -0.08704834f, 0.08619177f, -0.10488738f, -0.10190009f, -0.20595939f, 
    -0.00299800f, -0.61355966f, 0.66780102f, -0.39746001f, -0.19665703f, -0.12221620f, 0.13103953f, 0.73771811f, 
    0.19101417f, 0.39254674f, 0.15587559f, -0.72957391f, 0.30545998f, 0.43758395f, -0.22013476f, -0.03193535f, 
    0.58479077f, 1.07130837f, -0.26237911f, -0.20921177f, -0.31614891f, -0.16825736f, 0.09654737f, -0.09247869f, 
    0.16752623f, 0.10540021f, 0.23542851f, -0.02198134f, -0.37554884f, 0.01329611f, 0.83808696f, -0.26715851f, 
    -0.05478052f, 0.49595770f, 0.68241245f, 0.07474720f, 0.75124723f, 0.25163439f, 0.44670820f, 0.63343966f, 
    -0.03647299f, -0.23792298f, -0.26665565f, -0.12696266f, -0.60566604f, -0.06678724f, 0.36029017f, -0.76048547f, 
    0.39356181f, -0.18169583f, -0.23640279f, 0.14157848f, -0.20653281f, -0.30462399f, -0.35377455f, -0.38837004f, 
    0.37147632f, 0.79041821f, -0.40681922f, 0.14689848f, -0.27917731f, 0.18467222f, 0.39943320f, 0.74157166f, 
    -0.72766519f, -0.20405163f, -0.29617426f, -0.08425543f, -0.16225158f, -0.39745694f, 0.21557395f, -0.34930462f, 
    -0.27008677f, -0.49041399f, -0.84714013f, -0.75704908f, -0.00994590f, 0.13641284f, 0.28222206f, -0.84411108f, 
    -0.11260503f, 0.25734305f, 0.41767037f, 0.54651117f, 0.49152595f, -0.10106622f, -0.47728693f, -0.13717447f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.35952798f, -0.05954871f, 0.06677859f, 0.08382920f, -0.05378899f, -0.14432357f, 0.04279914f, 0.19906881f, 
    -0.10225070f, 0.16139765f, -0.07264684f, -0.12194653f, -0.26090640f, 0.03243428f, 0.23488775f, -0.07612995f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.01009604f, -0.03468279f, -0.03570497f, -0.02104406f, -0.08760126f, -0.03684319f, -0.02540233f, 0.00361300f, 
    -0.00779215f, 0.03147930f, -0.01960301f, 0.01409884f, -0.02744572f, 0.07296547f, 0.01167343f, -0.07016712f, 
    -0.00256582f, -0.07614878f, 0.00848362f, 0.02499442f, -0.06013542f, 0.00051498f, -0.04169491f, -0.08312117f, 
    0.04764798f, 0.00243655f, -0.01274534f, 0.03727913f, -0.03377242f, -0.06046175f, -0.08754438f, 0.03524813f, 
    0.05901626f, -0.06870820f, -0.01583694f, 0.07456458f, -0.01851057f, -0.06185870f, -0.06518105f, 0.04867697f, 
    -0.06927958f, 0.07582910f, -0.02863785f, -0.06468974f, -0.00829305f, -0.07597866f, -0.03039483f, -0.08242131f, 
    -0.04099241f, -0.01812010f, -0.05059223f, 0.07309677f, -0.06918570f, 0.02383578f, 0.04984298f, -0.01609246f, 
    -0.04231950f, 0.04618723f, -0.07086352f, -0.06981275f, -0.08070172f, -0.08629251f, 0.03056186f, -0.03972312f, 
    0.06832361f, 0.05678549f, -0.01835658f, -0.04896334f, -0.01676951f, -0.05900343f, 0.00163566f, 0.02540924f, 
    -0.03456280f, -0.06069930f, 0.03815034f, -0.03649320f, 0.03127390f, -0.06381179f, 0.02055917f, 0.01085829f, 
    -0.01765281f, 0.03123485f, -0.00864026f, 0.02535405f, -0.04796292f, 0.00902798f, -0.02089953f, -0.06015380f, 
    -0.05264254f, 0.03900717f, -0.03325027f, 0.01975395f, 0.04836882f, -0.02589778f, 0.06557739f, -0.07855352f, 
    -0.07197107f, 0.02469560f, -0.05781640f, -0.06754305f, 0.04321604f, 0.04022793f, 0.00602253f, 0.02165227f, 
    0.06463748f, -0.08262488f, -0.06511659f, -0.02292056f, 0.01698819f, -0.02848739f, 0.07295176f, -0.05252787f, 
    -0.05393054f, -0.06797242f, -0.07018360f, 0.04582715f, -0.01617353f, 0.07137136f, -0.05053633f, -0.08539484f, 
    -0.02440066f, -0.01255388f, 0.00452726f, -0.06843328f, -0.06787582f, 0.02590911f, -0.01341503f, -0.08083879f, 
    -0.08514946f, 0.06129014f, -0.05827666f, -0.04356679f, -0.04167685f, -0.08093705f, -0.01849227f, 0.03548215f, 
    -0.01537657f, 0.05593453f, -0.00220508f, 0.07336933f, -0.03400020f, 0.05570703f, -0.06900363f, 0.00637636f, 
    0.11921866f, 0.05933508f, -0.13120662f, 0.09264524f, 0.06594361f, 0.02635439f, 0.07691359f, 0.07323071f, 
    -0.07919475f, 0.11741864f, -0.41610938f, -0.36957377f, -0.12675248f, -0.17391992f, -0.10405953f, 0.01064015f, 
    0.14582726f, 0.14628540f, -0.91781294f, -0.24666406f, -0.03233604f, 0.10996339f, 0.05926923f, -0.01859034f, 
    0.02572350f, 0.07157157f, 0.05229677f, -0.05751093f, -0.31140789f, 0.06276841f, 0.14229119f, -0.09261274f, 
    0.02800280f, -0.04975692f, -0.07369927f, -0.05823670f, -0.31828281f, 0.00112502f, 0.19906262f, -0.04651697f, 
    -0.01408276f, -0.11154193f, -0.14865772f, -0.02190056f, 0.04948011f, -0.08358778f, -0.13392352f, 0.72437787f, 
    0.15019962f, -0.04955358f, -0.09459558f, 0.07428281f, -0.03185158f, -0.00681740f, -0.29281211f, 0.09310697f, 
    -0.35156468f, 0.04137913f, 0.16639461f, 0.19007547f, 0.05863747f, -0.11150318f, 0.14997016f, -0.17621021f, 
    0.11489612f, 0.05868414f, -0.06199988f, 0.17170946f, 0.11278693f, -0.03340773f, 0.02941548f, -0.08476529f, 
    -0.03914111f, 0.26256123f, -0.29352629f, 0.02739536f, -0.08437422f, -0.19628845f, -0.14167887f, -0.05273922f, 
    0.03058078f, 0.23166019f, -0.06641290f, 0.23684195f, 0.03721321f, 0.09510033f, 0.11672376f, 0.09564661f, 
    0.06139847f, 0.03331618f, -0.03131841f, 0.22154890f, 0.10957415f, 0.10099938f, 0.08882803f, -0.12223103f, 
    0.10188765f, -0.14440976f, 0.02206874f, -0.11544215f, -0.14626554f, -0.01456758f, -0.12609094f, 0.00995140f, 
    0.03025636f, -0.04411316f, 0.06241335f, 0.10524414f, -0.12257195f, -0.08438338f, -0.01252291f, -0.15168180f, 
    -0.01097108f, -0.12036759f, -0.02528265f, -0.05642020f, -0.11667232f, -0.50975275f, 0.29929817f, -0.28362390f, 
    0.21804808f, 0.06779966f, 0.03327261f, 0.08739799f, 0.13178697f, 0.05790489f, -0.03026233f, 0.09772452f, 
    -0.32350606f, 0.01245506f, -0.00919020f, 0.11663837f, 0.15535970f, 0.04564823f, 0.05384384f, -0.00174063f, 
    0.19399533f, 0.19829285f, -0.03216213f, -0.20219950f, -0.10956580f, 0.01479741f, 0.07220389f, 0.20798455f, 
    0.10204458f, -0.13101070f, 0.14142416f, -0.02553639f, -0.04496691f, 0.01772471f, -0.13572769f, -0.10155991f, 
    0.12486369f, 0.24177825f, -0.18616313f, -0.10028100f, 0.12837504f, -0.04215144f, -0.09392335f, -0.04277108f, 
    0.03295273f, 0.01936137f, -0.01671802f, -0.16030331f, 0.14682938f, -0.15537968f, -0.07084429f, -0.06665628f, 
    0.00804727f, -0.05803289f, 0.02182351f, 0.35592651f, 0.11294802f, 0.23510545f, 0.09207772f, -0.00438551f, 
    0.04037506f, 0.03704152f, 0.03662482f, 0.07522126f, 0.17078288f, 0.24466054f, 0.06748240f, 0.02492090f, 
    0.09826288f, -0.13634449f, 0.14441313f, -0.10127957f, -0.02628471f, 0.41418934f, 0.32712063f, 0.17631453f, 
    -0.06468687f, -0.09735028f, 0.12372173f, -0.02105951f, 0.04093247f, -0.02073769f, -0.17724842f, 0.05760918f, 
    -0.15974092f, -0.06579838f, -0.00376658f, 0.07079241f, -0.08630164f, 0.03891501f, -0.05654282f, 0.06692130f, 
    -0.26474530f, -0.38327092f, -0.03006168f, -0.26353937f, -0.10136370f, 0.08556259f, 0.07626767f, -0.06121757f, 
    0.11479031f, -0.24523953f, 0.00747920f, -0.29232380f, 0.03765605f, -0.01081885f, 0.11434343f, 0.07635390f, 
    -0.08076375f, -0.08421121f, 0.07342448f, -0.30990335f, 0.02851564f, 0.07555760f, -0.12038735f, 0.03753062f, 
    -0.12637983f, -0.03902245f, 0.44413936f, -0.05364643f, -0.01148304f, 0.14911282f, 0.11926270f, -0.07992879f, 
    -0.00529655f, 0.03731226f, -0.04574443f, 0.29577544f, 0.07744326f, -0.03726001f, 0.23013985f, 0.14822204f, 
    -0.00209288f, -0.05786667f, -0.07946067f, -0.19828743f, -0.31651258f, 0.17332342f, 0.21122901f, 0.29066411f, 
    -0.02714884f, 0.04356347f, 0.03481497f, 0.05858948f, -0.02453675f, -0.39247376f, -0.00721557f, -0.04046160f, 
    -0.02925924f, 0.08737352f, 0.01408651f, -0.16996787f, 0.02074214f, -0.03601971f, -0.18428811f, -0.54009223f, 
    -0.09679727f, -0.17639814f, -0.13292828f, -0.11604404f, -0.01287230f, 0.00891039f, -0.02784463f, 0.29846716f, 
    0.22072338f, 0.38159877f, 0.14350383f, 0.07062364f, -0.03478932f, -0.20037302f, 0.02963297f, 0.08313460f, 
    -0.05389123f, -0.02306017f, -0.01861564f, 0.01914333f, 0.03508187f, -0.07639819f, -0.03837722f, -0.07459573f, 
    -0.07802712f, 0.01229771f, 0.00412707f, 0.06031121f, -0.04825510f, 0.00894998f, -0.05226333f, -0.01831107f, 
    0.00543041f, 0.01643725f, -0.06303200f, -0.08439228f, 0.02114802f, -0.00698124f, -0.02910704f, -0.03904570f, 
    0.05773346f, 0.00086290f, -0.05282586f, -0.08579347f, -0.00243978f, 0.01361189f, 0.02621910f, 0.02423113f, 
    -0.01215035f, -0.07295208f, -0.02053903f, -0.01489892f, -0.01227590f, -0.02045066f, -0.06811406f, 0.01865079f, 
    -0.05283824f, -0.05532763f, -0.06848570f, -0.02662915f, 0.06081707f, -0.04056728f, -0.07338340f, 0.00619162f, 
    -0.06776132f, 0.03113766f, -0.01097824f, 0.01654050f, -0.00320672f, -0.08014856f, -0.03607219f, 0.00284709f, 
    -0.06123567f, -0.01414315f, 0.06857485f, 0.07372321f, 0.03823778f, 0.01889318f, -0.07035435f, -0.03911808f, 
    0.03312489f, -0.00635873f, 0.00000397f, 0.00812921f, -0.02506773f, -0.08945214f, -0.08755689f, 0.05174658f, 
    0.03069361f, -0.03102259f, 0.00865960f, 0.05597151f, 0.04948385f, -0.00905052f, -0.04879225f, -0.03166222f, 
    -0.06237351f, -0.06376995f, -0.04142298f, 0.02266374f, 0.06430964f, -0.06418519f, -0.02249307f, 0.03490336f, 
    0.04989739f, 0.01620084f, -0.08274285f, 0.03307053f, 0.05894103f, -0.08946653f, -0.09235246f, 0.03777186f, 
    0.06777819f, 0.07473587f, -0.08321161f, -0.08194683f, -0.03041505f, 0.05174236f, 0.04602099f, 0.06999655f, 
    -0.08566087f, -0.07115216f, 0.02342501f, -0.09222596f, -0.03430665f, 0.04351367f, -0.02278614f, -0.00948025f, 
    -0.04185976f, -0.06307837f, 0.05050419f, 0.03367164f, 0.05655726f, -0.01957260f, 0.06799054f, 0.03154610f, 
    -0.02942245f, -0.03159393f, -0.01478203f, -0.06821842f, -0.02184493f, -0.02133822f, -0.01170020f, 0.03510728f, 
    -0.07042132f, -0.07167113f, 0.03380774f, 0.04176331f, -0.00348317f, -0.02723859f, 0.00409939f, -0.02106522f, 
    0.00889658f, -0.05828445f, 0.05251778f, -0.05184661f, -0.00071571f, 0.01992475f, -0.06399259f, -0.03983358f, 
    0.19260575f, -0.04418474f, 0.15674958f, -0.12872291f, 0.03539164f, -0.02177525f, 0.07108520f, 0.17491692f, 
    0.13526556f, 0.00846086f, -0.02291565f, -0.03100366f, 0.01377437f, 0.06070428f, 0.01817410f, 0.10373683f, 
    -0.04306272f, 0.01463109f, -0.35592118f, -0.09581443f, -0.02166496f, 0.02844129f, -0.06870552f, -0.09140691f, 
    0.02626853f, 0.08448445f, -0.11116999f, 0.03696548f, -0.00420652f, -0.32085356f, -0.06130096f, -0.01705751f, 
    -0.05711242f, 0.04965859f, -0.12860930f, -0.30243197f, -0.01410377f, 0.35353833f, 0.09741309f, -0.11108470f, 
    0.12873778f, -0.03616131f, 0.20688194f, -0.21841611f, 0.02725822f, 0.16933160f, 0.03017113f, -0.58567894f, 
    0.06196235f, 0.05494501f, 0.10215811f, -0.09821770f, 0.30924764f, -0.16282076f, -0.13353936f, -0.27686879f, 
    -0.17555760f, 0.08760919f, 0.06058183f, -0.08689503f, 0.05785658f, -0.20198409f, -0.01983469f, 0.25150925f, 
    -0.05236933f, 0.27218884f, 0.00911430f, -0.06165001f, 0.24231191f, 0.03477599f, 0.13509065f, 0.20931655f, 
    0.12779908f, -0.09309861f, -0.13166240f, 0.24038449f, -0.11016026f, -0.04862330f, -0.01707113f, -0.04909875f, 
    -0.02234897f, -0.08894067f, 0.23910448f, -0.04594094f, 0.10639141f, -0.15751833f, -0.08915174f, 0.07055344f, 
    0.05585830f, 0.19006029f, 0.15639041f, -0.20345075f, -0.03925496f, 0.05750747f, -0.05264184f, -0.11943541f, 
    -0.07540150f, 0.26125801f, -0.07631978f, -0.11750495f, 0.14373171f, 0.17470109f, 0.05851123f, 0.10955346f, 
    -0.02190107f, -0.00845247f, 0.11749002f, -0.04511181f, -0.00891400f, -0.03219265f, 0.00262403f, 0.15112966f, 
    -0.20199451f, -0.08382592f, -0.12463196f, 0.02346306f, 0.02632548f, 0.00635459f, -0.00120344f, -0.02718590f, 
    0.06943743f, -0.00743431f, 0.25927606f, -0.30335450f, -0.04843163f, -0.06353294f, 0.08467220f, 0.07245141f, 
    -0.03391694f, 0.08253488f, 0.18659906f, 0.25473967f, -0.05183554f, -0.03646107f, -0.20943066f, -0.30259886f, 
    0.13572977f, -0.14640142f, 0.04516984f, -0.02607601f, -0.32646123f, -0.03365626f, 0.07451132f, 0.10855918f, 
    -0.67056072f, -0.16648313f, -0.05210295f, 0.29128820f, 0.07598808f, 0.09566753f, 0.00046592f, 0.00527123f, 
    0.09894755f, 0.03922559f, -0.04905364f, -0.23779432f, 0.08876227f, -0.01982814f, 0.11738008f, 0.22044063f, 
    -0.10935146f, 0.12775773f, 0.02216993f, 0.05210385f, -0.38974303f, -0.27773175f, 0.07742415f, 0.05253246f, 
    0.15676208f, 0.05286762f, -0.02309487f, 0.28657576f, 0.08162352f, 0.21276031f, -0.08819143f, 0.05230799f, 
    0.10391739f, 0.20971410f, 0.09531666f, 0.12117638f, 0.25040573f, 0.25677437f, 0.04059023f, 0.03326742f, 
    0.11678592f, 0.01831392f, -0.01091768f, 0.11530089f, 0.02789348f, 0.14033286f, 0.04364911f, -0.04183067f, 
    -0.01167592f, -0.10332623f, 0.04760164f, 0.01921853f, -0.08431301f, 0.13104357f, 0.11053033f, 0.01365829f, 
    0.05692906f, 0.08337829f, -0.09484009f, 0.29529306f, 0.24535933f, -0.03668413f, -0.00784537f, -0.42783645f, 
    -0.06920733f, -0.10724821f, 0.12035367f, 0.09801953f, -0.06735107f, -0.05888159f, 0.06965819f, -0.01086508f, 
    -0.47124168f, 0.02531700f, 0.03981174f, 0.09592132f, -0.02746971f, -0.14241132f, -0.12696271f, 0.10228405f, 
    0.06217524f, -0.41844112f, -0.29782876f, -0.17279176f, 0.14929689f, 0.05467951f, 0.02832189f, 0.19226015f, 
    -0.13707158f, -0.05255782f, -0.42685273f, -0.00606958f, -0.00676156f, -0.00699130f, 0.04314714f, -0.04727563f, 
    -0.02137919f, -0.13942702f, -0.17671937f, -0.01489330f, 0.04470997f, 0.10218013f, 0.12393348f, 0.07376390f, 
    -0.02160126f, 0.06306501f, -0.06142519f, -0.20777275f, 0.15404682f, -0.12601973f, 0.06998082f, -0.12002206f, 
    0.09329034f, -0.26642856f, -0.29965943f, 0.06347559f, 0.00759669f, -0.38587025f, 0.09832613f, 0.02877962f, 
    0.11134285f, 0.10962090f, -0.07086895f, -0.11364692f, -0.30137375f, -0.08571453f, 0.20783734f, 0.11156099f, 
    0.13494712f, -0.05909814f, 0.08833939f, -0.10153431f, -0.03489718f, 0.14714187f, 0.07120569f, 0.28876963f, 
    -0.03776801f, -0.15868828f, 0.12345333f, -0.02503434f, -0.02027374f, 0.16791511f, -0.03167626f, -0.05883867f, 
    -0.16692369f, 0.06889861f, 0.21671063f, -0.06188881f, 0.05470673f, 0.05591674f, -0.20029157f, -0.05441058f, 
    0.09418532f, -0.19759071f, 0.00667008f, -0.33232728f, -0.00333638f, -0.11243292f, -0.03008836f, 0.15795852f, 
    0.13877589f, 0.01573826f, -0.06093540f, -0.00991182f, 0.19663645f, -0.01939893f, 0.09095223f, -0.11679820f, 
    0.07155926f, -0.13793239f, 0.12226604f, 0.08998100f, -0.13048887f, -0.07777335f, 0.22811435f, 0.05623138f, 
    -0.03133311f, -0.10537944f, -0.13626429f, 0.11416581f, 0.01548213f, -0.22885203f, -0.04308462f, 0.23882464f, 
    0.16888914f, -0.03774163f, -0.07184045f, -0.00255160f, -0.12401333f, -0.14761652f, 0.05988041f, 0.08128054f, 
    0.10960109f, 0.05172660f, -0.02037338f, 0.24215288f, -0.24732190f, 0.05632879f, -0.04802621f, -0.15202472f, 
    0.06439426f, -0.06507488f, 0.09108909f, 0.00783675f, 0.07851485f, -0.16491410f, 0.06023958f, -0.03083097f, 
    -0.10310831f, 0.19140927f, -0.01410783f, 0.15831204f, -0.00796115f, 0.07831993f, 0.25115889f, -0.01117592f, 
    -0.18041438f, 0.26204640f, 0.09381490f, 0.04212680f, -0.16106749f, 0.02224182f, 0.04336349f, 0.12597813f, 
    -0.09477634f, -0.19774099f, -0.13746791f, -0.08712734f, -0.13730283f, -0.14248690f, -0.01980726f, 0.12973362f, 
    0.02210538f, -0.14218713f, -0.50065047f, 0.09197841f, 0.17839441f, 0.26848698f, 0.29893360f, 0.34447742f, 
    0.10923157f, -0.06815582f, 0.02697013f, -0.35337919f, -0.39665717f, -0.12922232f, -0.03160201f, -0.05595320f, 
    0.12589991f, -0.00127045f, -0.32266700f, -0.04508034f, -0.08723445f, -0.05664553f, -0.04782197f, 0.01272121f, 
    0.05517152f, 0.10744102f, -0.04376691f, -0.09166401f, 0.15380335f, 0.20614278f, 0.14455797f, 0.29588205f, 
    -0.02089012f, -0.01075602f, -0.15148970f, 0.28253284f, -0.21027566f, 0.05195565f, 0.01867896f, -0.14534377f, 
    0.30576214f, 0.07249945f, 0.03018213f, -0.04407759f, 0.15968046f, -0.11606248f, 0.17540567f, 0.21141344f, 
    -0.09938496f, -0.10959270f, 0.04212451f, -0.00938205f, 0.05173480f, -0.07049743f, 0.00727502f, 0.19681410f, 
    0.11033777f, 0.01153339f, -0.26744834f, 0.10418850f, -0.02330543f, 0.03529809f, -0.03823329f, -0.02528151f, 
    -0.04439528f, 0.19600147f, -0.06541310f, -0.00023772f, 0.17458509f, -0.12347136f, -0.11407094f, -0.17674397f, 
    0.14719720f, -0.06176103f, 0.22573270f, 0.29855964f, 0.06517972f, -0.23330806f, 0.03425529f, -0.06391696f, 
    0.11681514f, 0.02994109f, -0.05472714f, -0.21582900f, 0.06212213f, 0.32936752f, -0.11883806f, -0.08066472f, 
    0.06553210f, -0.19170228f, 0.00974087f, 0.31768215f, 0.06512549f, 0.07555139f, 0.15055491f, 0.22032380f, 
    0.09982350f, 0.11387178f, 0.06769316f, -0.24607173f, 0.01818113f, -0.11726932f, -0.17375070f, 0.04639360f, 
    0.01430851f, 0.10271566f, -0.11197907f, 0.00519441f, 0.12346484f, 0.02344629f, -0.05287573f, -0.10034821f, 
    0.29090333f, -0.19716854f, 0.01401143f, 0.12886320f, -0.08558273f, 0.13690512f, 0.23015353f, -0.10444824f, 
    0.11892986f, -0.18969408f, -0.20752797f, 0.16855833f, 0.04759054f, -0.04173132f, -0.00875369f, -0.07572719f, 
    0.22943473f, -0.02230919f, -0.11615087f, 0.16792217f, 0.23859546f, -0.00587292f, -0.02267855f, -0.05905165f, 
    -0.19757202f, -0.00355353f, 0.03720716f, -0.01469408f, 0.03596488f, 0.17778455f, 0.11796942f, 0.13730586f, 
    0.00854439f, -0.39657944f, -0.11961868f, 0.00767646f, -0.41178271f, 0.07526982f, 0.03825931f, 0.27296764f, 
    0.06409779f, -0.13818279f, -0.15631038f, 0.30184004f, 0.13700266f, 0.01743965f, -0.01642244f, -0.08928700f, 
    0.24950455f, 0.02294236f, -0.02320445f, 0.06242946f, -0.19863825f, 0.05066391f, 0.35802841f, -0.17456715f, 
    -0.01620907f, 0.04738126f, 0.06830155f, -0.10295785f, 0.08100230f, 0.04343807f, 0.05744834f, -0.14118652f, 
    0.12232009f, -0.04956712f, -0.04221621f, 0.16203620f, -0.02801378f, 0.22676802f, 0.14963259f, 0.05593423f, 
    -0.09704076f, 0.02213803f, -0.01695429f, -0.23391035f, 0.16250055f, 0.08867291f, -0.08685371f, 0.00025739f, 
    -0.08507859f, -0.09748010f, 0.04782422f, -0.11237807f, 0.05109856f, 0.03269861f, -0.10540242f, -0.10027728f, 
    -0.08396521f, -0.00153634f, -0.04272832f, -0.00433161f, 0.06641944f, -0.05826056f, -0.01950458f, -0.04676901f, 
    -0.07011218f, -0.00672837f, -0.08313377f, -0.08199468f, -0.09659883f, -0.02481474f, -0.02351386f, -0.09585455f, 
    -0.05237227f, 0.02568465f, 0.00641724f, -0.02397919f, -0.07146391f, -0.07144580f, -0.02574664f, -0.05292894f, 
    -0.06690777f, -0.00598317f, -0.00879677f, -0.07772405f, 0.01335476f, -0.02817113f, -0.07791059f, -0.05883466f, 
    -0.08138888f, -0.11250834f, -0.09238257f, 0.04791752f, -0.11097616f, -0.08707127f, -0.03599305f, 0.04186701f, 
    -0.05823975f, -0.09770526f, -0.04044018f, -0.03360648f, -0.00378838f, -0.07179379f, -0.02589714f, 0.05448929f, 
    0.01415460f, 0.00606750f, 0.02773303f, 0.02269713f, -0.05778388f, -0.06024758f, -0.09205350f, -0.06373072f, 
    0.00390374f, -0.04279841f, -0.09742525f, -0.05738126f, -0.11446436f, -0.08602852f, -0.04498971f, -0.10350605f, 
    0.00024070f, 0.04933201f, -0.10218411f, -0.07532705f, -0.00860953f, -0.05379337f, -0.03651637f, 0.00540517f, 
    -0.00150340f, 0.02637691f, 0.00215870f, 0.06835946f, -0.01045020f, -0.06553011f, 0.00834790f, 0.01031826f, 
    0.00984064f, -0.01230246f, 0.02677957f, -0.09981585f, -0.10525952f, -0.03576510f, 0.03774676f, -0.02428735f, 
    0.02002496f, -0.06681162f, -0.08718426f, 0.01989503f, -0.04169292f, -0.08436486f, -0.03962232f, -0.04252966f, 
    0.02388315f, -0.08126774f, 0.03994917f, -0.10012909f, 0.03790181f, -0.06205370f, -0.08712999f, 0.00914508f, 
    0.03424289f, -0.06344245f, -0.08929011f, -0.00561903f, -0.05248618f, 0.03240132f, -0.10044456f, 0.01250475f, 
    0.05453066f, -0.11617425f, -0.09854026f, -0.10175585f, -0.00624225f, -0.00001110f, -0.11569932f, -0.09581952f, 
    0.02308043f, 0.04659129f, 0.00679953f, -0.04765377f, 0.03596764f, -0.01006298f, -0.04376537f, -0.08736689f, 
    0.04416536f, -0.00138236f, 0.00021953f, -0.10590377f, -0.09836664f, 0.01734365f, -0.03673742f, -0.09408238f, 
    -0.06546851f, -0.08388272f, -0.09303395f, -0.00706355f, -0.07283428f, -0.06283611f, -0.00235317f, -0.06428921f, 
    0.10595333f, 0.09396450f, -0.01441380f, 0.14373682f, 0.16421524f, 0.23466262f, -0.09089974f, -0.04009074f, 
    -0.05447431f, -0.15475702f, 0.04346202f, -0.01223233f, -0.01948620f, -0.08950260f, -0.24396490f, 0.05197728f, 
    -0.07309709f, 0.19219616f, -0.03594503f, -0.06585591f, -0.34752944f, 0.00290559f, 0.00528793f, -0.14338003f, 
    -0.13608129f, 0.03006060f, -0.09162990f, 0.08171540f, 0.03731116f, -0.02911795f, -0.36999732f, -0.00670200f, 
    -0.06059238f, -0.11463030f, -0.11005482f, -0.13640067f, -0.14341410f, 0.27613106f, 0.30816549f, -0.13956249f, 
    -0.38937870f, -0.18701488f, 0.11532570f, 0.10185603f, -0.04110039f, -0.30673414f, -0.09125223f, -0.05075490f, 
    -0.12110953f, -0.18102787f, 0.04758292f, 0.06637503f, -0.03771422f, -0.01522021f, -0.20506509f, -0.16445708f, 
    -0.14430116f, -0.07482867f, 0.03875287f, -0.00318100f, 0.07233790f, -0.08253057f, -0.12182659f, 0.10649618f, 
    -0.01673968f, 0.01894137f, 0.14129874f, 0.07596428f, -0.06742731f, 0.07956856f, 0.13002110f, 0.08412908f, 
    0.24527900f, -0.15624620f, -0.44684884f, 0.22057234f, 0.07283366f, 0.07576275f, 0.02196094f, -0.08417156f, 
    0.02797160f, 0.04695836f, 0.13568582f, 0.28112403f, 0.09246039f, 0.07917534f, 0.24333343f, 0.12376466f, 
    -0.05385805f, 0.30629849f, -0.10842810f, 0.20410371f, -0.04637650f, 0.16495238f, 0.04307464f, 0.11912011f, 
    0.11516309f, 0.12970468f, 0.05035667f, -0.11391012f, 0.08714291f, 0.05009053f, -0.02024669f, -0.35155165f, 
    -0.10004912f, -0.08397374f, 0.21745303f, -0.06279290f, 0.29365173f, 0.06371104f, 0.43826890f, -0.09324528f, 
    0.32726309f, 0.06390562f, -0.01627104f, 0.04809102f, -0.01401947f, 0.09525640f, -0.15722191f, 0.00720932f, 
    0.19841745f, 0.05962047f, 0.21525104f, -0.00112275f, -0.18598355f, -0.07623213f, 0.13426290f, 0.14546001f, 
    -0.40134841f, 0.06569774f, 0.00668561f, 0.06217780f, 0.12912923f, 0.05901074f, -0.17050454f, 0.24134652f, 
    0.11597074f, 0.11060015f, -0.25902221f, -0.22989634f, -0.01517788f, -0.07812194f, 0.06626587f, 0.12537566f, 
    -0.33842617f, -0.54047638f, 0.06793640f, -0.15825590f, 0.04306281f, 0.17947194f, 0.01610799f, -0.00114268f, 
    -0.09271342f, -0.07763586f, 0.00114875f, -0.13853331f, -0.13857403f, 0.00009157f, -0.15707362f, -0.08493281f, 
    0.18136919f, 0.05555270f, 0.42460656f, 0.13286692f, -0.11665460f, 0.15562011f, -0.15372112f, -0.16066541f, 
    -0.08960281f, -0.16133197f, -0.12586921f, 0.05596552f, 0.24156818f, -0.13462171f, 0.03606078f, 0.19009787f, 
    0.08813588f, 0.02639276f, 0.14192730f, -0.01208127f, 0.17178544f, 0.11636517f, 0.00075700f, -0.09354255f, 
    -0.03398314f, -0.16499282f, -0.11128484f, 0.04261486f, 0.12314557f, -0.26245648f, 0.22908480f, -0.07737206f, 
    -0.17773634f, -0.21746330f, 0.02606564f, -0.16310787f, -0.06937037f, 0.12866834f, -0.12329469f, 0.12912847f, 
    0.33982420f, -0.07404261f, -0.02618676f, 0.06633838f, 0.02785243f, -0.16788489f, -0.03301453f, -0.00060768f, 
    -0.42412946f, 0.01815794f, 0.14638636f, -0.03670534f, 0.09706846f, 0.05452193f, 0.18648060f, -0.00940325f, 
    0.19295408f, -0.54451448f, -0.14764252f, 0.06532831f, -0.10139421f, -0.14923352f, -0.19891573f, -0.11409716f, 
    -0.02087959f, -0.03512586f, -0.45269346f, -0.02028157f, -0.07584180f, -0.01181421f, 0.06152004f, 0.03373309f, 
    0.14070983f, -0.01004562f, -0.29235893f, -0.25523138f, -0.03666379f, -0.00442912f, 0.04447205f, -0.05625671f, 
    0.14829886f, 0.07510778f, 0.09812291f, 0.33289167f, 0.11634258f, -0.15664639f, 0.06134460f, 0.10053999f, 
    -0.01743852f, 0.10680432f, 0.21449713f, -0.11754207f, -0.00977390f, 0.15828405f, 0.01662298f, 0.05690447f, 
    0.07230316f, 0.02540023f, -0.01803981f, 0.10782550f, 0.12855940f, 0.04897178f, -0.13430625f, 0.01383621f, 
    0.22752169f, 0.10454349f, 0.19398828f, -0.02076410f, -0.09582332f, 0.06929544f, 0.44031489f, 0.15492386f, 
    0.04145231f, -0.03279920f, -0.00842756f, -0.13188532f, 0.20756525f, -0.12420578f, 0.17954352f, -0.03739262f, 
    0.15137632f, 0.10650364f, -0.06391675f, 0.01276067f, -0.08371133f, 0.05620246f, 0.11428873f, 0.19553599f, 
    0.28263360f, 0.36428320f, 0.30362919f, -0.01823654f, -0.10669811f, 0.16601291f, -0.11841586f, 0.03259028f, 
    0.07763594f, 0.09195440f, -0.30256751f, -0.32321250f, 0.07691803f, -0.03680426f, -0.04784912f, 0.03694446f, 
    0.04065306f, 0.10989730f, -0.22483139f, -0.23064871f, 0.00617777f, -0.08134459f, -0.11461026f, -0.04899134f, 
    -0.09758327f, 0.01528880f, -0.02355132f, -0.45103583f, -0.43666667f, -0.16243222f, -0.00454079f, 0.02732806f, 
    0.02851218f, 0.12177711f, -0.01716544f, -0.22929126f, -0.37846473f, 0.07572419f, -0.42078066f, 0.14760859f, 
    0.03224198f, 0.01722161f, -0.06574054f, -0.17538099f, -0.07354843f, 0.01218383f, -0.14630367f, -0.23965271f, 
    0.20062050f, -0.01085677f, 0.00683044f, -0.02148862f, 0.14299844f, -0.02066084f, 0.16357082f, 0.11261602f, 
    -0.18053520f, 0.08241376f, 0.23958170f, 0.17239456f, -0.12729871f, -0.05152605f, 0.00841808f, -0.05715154f, 
    0.24041012f, 0.01234073f, 0.17976154f, 0.03960463f, 0.12127832f, 0.27537355f, 0.04789147f, -0.01894176f, 
    0.10151891f, -0.00005717f, 0.14771679f, 0.01468938f, 0.00765551f, -0.20881325f, -0.08173485f, 0.02699724f, 
    0.11883134f, -0.19164278f, 0.07176484f, 0.35498670f, 0.13189340f, -0.04199602f, 0.12289698f, -0.09075785f, 
    -0.21320127f, -0.04262988f, 0.29946935f, 0.15721771f, 0.05440854f, 0.24395208f, 0.12352008f, -0.05511130f, 
    -0.02362030f, 0.05313786f, 0.00472537f, -0.30167556f, -0.03875806f, -0.36574498f, -0.13164070f, -0.09102403f, 
    -0.00160578f, 0.02078180f, -0.18324348f, 0.14968985f, 0.04414708f, 0.07314308f, -0.07656065f, -0.00258537f, 
    0.11493602f, -0.01528367f, -0.16790029f, 0.19090615f, -0.03091824f, 0.14050682f, 0.20003468f, 0.17855053f, 
    -0.05058191f, 0.10263304f, 0.06950564f, 0.11160044f, -0.03693144f, 0.04065422f, 0.13290213f, 0.07382573f, 
    -0.52968621f, -0.05323406f, 0.20696907f, -0.01952231f, -0.07137072f, 0.04805852f, 0.17436849f, -0.17955974f, 
    -0.28125784f, -0.35531923f, 0.03312255f, -0.04478075f, 0.19170685f, 0.07041334f, -0.04202826f, 0.09685680f, 
    -0.15266405f, -0.04081214f, -0.21798557f, 0.14425680f, -0.08900906f, -0.21752600f, -0.02500769f, -0.02747389f, 
    0.25126603f, 0.01734636f, 0.32918519f, 0.20238990f, -0.11702040f, -0.08706982f, -0.06488117f, 0.14157020f, 
    0.05278838f, 0.16211069f, -0.04306528f, -0.23566863f, 0.03231002f, -0.08321416f, -0.14873271f, -0.05677825f, 
    -0.17098126f, 0.15000972f, -0.08708602f, 0.11319729f, 0.27276233f, 0.16782665f, -0.03055814f, -0.06423533f, 
    -0.04445520f, 0.01809278f, 0.12533721f, -0.12121614f, -0.07202336f, 0.01386949f, 0.23494732f, 0.03437807f, 
    -0.00071719f, 0.08169010f, 0.09282063f, 0.05735300f, 0.21413408f, 0.22382301f, 0.05103281f, 0.19719222f, 
    0.09366175f, -0.14802730f, 0.09971514f, -0.03710796f, -0.01415639f, 0.09797158f, 0.07145162f, 0.09879821f, 
    0.20380457f, 0.09654323f, 0.01789075f, 0.15327922f, -0.24929267f, -0.04625540f, -0.11316685f, 0.02281483f, 
    -0.05088693f, -0.20309043f, -0.09747766f, 0.08701602f, -0.14714068f, 0.15093085f, -0.00659249f, 0.06029294f, 
    -0.50650102f, 0.08254132f, 0.17401248f, -0.04822989f, -0.16845302f, 0.22488372f, 0.02846942f, -0.12132266f, 
    0.10312539f, 0.00725953f, -0.00403095f, -0.09429837f, -0.19095305f, 0.00804943f, -0.17133528f, -0.16437988f, 
    0.09500987f, 0.18593214f, 0.06480776f, -0.06269393f, 0.20745414f, -0.18027397f, 0.00834061f, -0.23743558f, 
    -0.06461392f, 0.18448019f, -0.04707130f, 0.18858708f, 0.26196298f, 0.12336142f, 0.04579376f, 0.05899500f, 
    -0.12442408f, -0.10326515f, 0.24805413f, 0.03572310f, 0.25036001f, -0.16681853f, 0.04475489f, 0.48934534f, 
    -0.02061041f, -0.09188429f, 0.29664961f, 0.04638397f, -0.02895506f, -0.05331491f, -0.09082792f, -0.24262908f, 
    -0.02865129f, 0.06188967f, 0.07169753f, -0.27528015f, 0.07460051f, -0.05125534f, 0.30818647f, 0.17856008f, 
    -0.17393927f, -0.22146410f, 0.06372007f, 0.00796275f, -0.14101684f, 0.09258723f, -0.07094137f, 0.04848058f, 
    -0.02973792f, -0.15438235f, -0.12885979f, -0.05784742f, 0.02881471f, 0.03663101f, 0.00007671f, 0.00922159f, 
    0.03596357f, 0.12809286f, 0.14303263f, -0.10395388f, 0.07324445f, -0.09195352f, -0.09646415f, -0.07494424f, 
    0.12711610f, -0.05959801f, -0.73241031f, 0.08028609f, 0.09713197f, 0.01358737f, -0.02655043f, -0.08339285f, 
    0.07596537f, -0.02685721f, -0.09922522f, -0.12096250f, -0.59966981f, 0.18739565f, 0.16722402f, 0.20466408f, 
    -0.09446277f, 0.10023035f, 0.06774089f, 0.31692973f, -0.01122287f, -0.18372932f, 0.01919177f, 0.03964288f, 
    -0.01550104f, 0.12404265f, 0.10234753f, 0.01438039f, 0.27124411f, 0.34039423f, -0.09464051f, 0.16863160f, 
    -0.01156495f, 0.01361276f, -0.06040428f, -0.01767113f, -0.02418551f, -0.31058100f, -0.16402063f, 0.15328272f, 
    0.08161557f, 0.00755450f, 0.11786073f, 0.03740563f, -0.06975908f, 0.10478747f, 0.21609847f, -0.26103631f, 
    -0.17966165f, 0.11713570f, 0.08463471f, 0.25436333f, -0.02944792f, -0.00122863f, 0.02886388f, -0.29774332f, 
    0.15304825f, 0.10698453f, 0.09655953f, -0.10174153f, 0.08868948f, 0.00227606f, -0.04355769f, 0.07279094f, 
    -0.06796120f, -0.28547490f, -0.11383028f, -0.13067594f, 0.04079040f, -0.05861576f, -0.09577110f, -0.09320617f, 
    0.03199480f, -0.07284250f, 0.07088847f, -0.31279644f, -0.04878427f, -0.18975686f, 0.07354841f, -0.12633459f, 
    -0.07068130f, 0.07563186f, -0.20065406f, 0.12122593f, 0.03553500f, 0.09049565f, -0.01166803f, -0.04967838f, 
    -0.07232822f, -0.00261725f, -0.05020851f, -0.44445038f, 0.25145414f, -0.11091891f, -0.04061306f, -0.03377398f, 
    -0.01518023f, -0.06937934f, 0.04079808f, -0.12783651f, -0.24488746f, 0.01996189f, -0.06200884f, -0.03361326f, 
    -0.17154689f, -0.04843647f, 0.09557505f, -0.01650276f, 0.09511652f, -0.14660417f, 0.15036672f, -0.23232028f, 
    0.13848269f, -0.04878236f, 0.04206935f, 0.08214048f, 0.15711327f, -0.00701671f, -0.41249770f, -0.11324038f, 
    -0.16125362f, 0.00877396f, 0.10440307f, -0.02833314f, 0.00643700f, 0.07991152f, 0.18760833f, 0.10488231f, 
    0.39191481f, -0.14904606f, 0.03439875f, -0.00400373f, -0.07823350f, 0.12188511f, 0.06666095f, -0.10473042f, 
    0.16568384f, 0.18730479f, 0.00096946f, -0.18173085f, -0.01733704f, -0.10221775f, 0.18565814f, 0.08943980f, 
    0.04174928f, -0.26409516f, -0.08603095f, 0.02076129f, 0.08659308f, 0.13567412f, 0.05787250f, 0.05090141f, 
    0.10030192f, 0.09305530f, 0.04463745f, -0.30701411f, -0.12718065f, 0.12923409f, -0.01916033f, -0.16479723f, 
    -0.04719249f, 0.01399362f, -0.16200243f, 0.27299646f, -0.20295969f, -0.38344330f, 0.06416417f, -0.04873059f, 
    0.04115972f, -0.01744564f, -0.15578428f, -0.00267960f, 0.13952030f, -0.24123475f, -0.21753007f, 0.22224839f, 
    0.03006292f, 0.11647528f, -0.00173658f, -0.08930394f, -0.19063272f, -0.75957018f, 0.01972562f, 0.00307405f, 
    -0.13568093f, 0.05491167f, -0.14772874f, 0.24064803f, 0.03110576f, -0.06410540f, -0.24124940f, -0.05591038f, 
    -0.10990777f, 0.13342763f, -0.08328660f, 0.11816306f, -0.02208603f, -0.02805795f, -0.22008467f, 0.10366549f, 
    0.19906452f, 0.06065773f, -0.03710792f, -0.15103407f, 0.09672758f, 0.00124188f, 0.00694192f, 0.06519645f, 
    0.08384464f, 0.32184777f, 0.12767163f, -0.39155596f, 0.10784470f, -0.16086137f, -0.14094917f, 0.11997459f, 
    -0.10963463f, -0.14034931f, -0.04863622f, -0.10705107f, 0.00051206f, -0.01247388f, -0.08592190f, 0.06987594f, 
    0.11294111f, 0.01865677f, 0.54863286f, -0.18877602f, -0.08348957f, -0.19083679f, -0.08182266f, -0.15187101f, 
    0.25761980f, 0.01098931f, 0.00874299f, 0.24126355f, 0.02697185f, -0.28179780f, 0.08536330f, 0.17898361f, 
    0.01158523f, 0.04366919f, -0.02842284f, -0.04423964f, -0.14797147f, -0.21563356f, -0.39547580f, -0.03370706f, 
    -0.03812633f, -0.13098885f, -0.11835778f, 0.11746247f, 0.09104275f, 0.19335791f, -0.23621029f, 0.18723588f, 
    -0.13733405f, -0.02657835f, 0.14517567f, 0.08286192f, 0.22766905f, 0.06358238f, -0.32479328f, 0.02793993f, 
    0.15119424f, 0.03823164f, 0.19134019f, 0.13547903f, -0.09127340f, 0.10305488f, 0.12758839f, 0.26595226f, 
    0.18378162f, 0.23313047f, -0.14763582f, -0.05922440f, 0.01118045f, 0.04972126f, -0.02604250f, 0.02146084f, 
    0.61751002f, 0.04380759f, -0.15935779f, -0.13248882f, -0.18104135f, -0.07259153f, 0.03253814f, 0.05086759f, 
    -0.10974281f, -0.31090471f, 0.04201336f, -0.17650750f, 0.13489252f, -0.07265043f, 0.09328718f, -0.15014908f, 
    -0.05612618f, 0.14307943f, -0.16557160f, -0.09530236f, -0.28226650f, -0.18169229f, 0.17488469f, 0.07095422f, 
    -0.10124154f, -0.20890954f, -0.12121299f, -0.26197657f, -0.12377951f, 0.24585558f, -0.08488266f, -0.01143294f, 
    0.00220652f, -0.05744209f, 0.07256664f, 0.11674648f, 0.04067476f, 0.10366683f, 0.00248522f, -0.07049318f, 
    0.12822008f, 0.00242852f, -0.02326095f, 0.13004810f, -0.09507515f, 0.32258707f, 0.17263621f, 0.11960185f, 
    -0.09520259f, -0.34068531f, 0.12913480f, -0.11155403f, -0.03108702f, 0.06496277f, -0.09910361f, 0.11116192f, 
    -0.15713114f, 0.12173509f, -0.04348347f, 0.12429586f, -0.01386049f, -0.01761519f, 0.00442100f, 0.35570058f, 
    0.10736651f, 0.16061537f, 0.19759122f, 0.04304106f, -0.06878667f, -0.03137814f, 0.10010312f, -0.09452757f, 
    0.48416695f, 0.03465359f, -0.03341082f, 0.04825013f, 0.04756756f, 0.05295606f, 0.04685991f, 0.24383019f, 
    -0.19301862f, -0.28105026f, 0.02572921f, 0.18862335f, 0.11739247f, 0.08909318f, -0.13482702f, -0.13650583f, 
    -0.10110026f, -0.08640160f, -0.04421641f, -0.22923301f, 0.09821695f, 0.09232325f, -0.04875624f, 0.14623009f, 
    -0.01995775f, 0.09799173f, -0.06021998f, 0.07145280f, 0.08249608f, -0.21260345f, 0.15037295f, 0.10164360f, 
    0.12175307f, -0.07166731f, 0.03071244f, 0.04030673f, -0.66126269f, -0.03721942f, 0.01289395f, -0.02052526f, 
    -0.03784520f, 0.13762552f, -0.06402187f, -0.14761658f, -0.00983416f, 0.30638739f, 0.11497191f, -0.10334093f, 
    0.10761252f, -0.00346022f, -0.28088844f, 0.09776749f, -0.03677736f, -0.00450889f, 0.01074435f, 0.08605313f, 
    -0.31927076f, 0.21593083f, 0.08043935f, -0.07944243f, 0.05212513f, 0.05329220f, 0.05060767f, -0.28960893f, 
    -0.20483516f, -0.01341362f, 0.01839112f, 0.03334465f, 0.02558240f, -0.23731104f, 0.16300152f, 0.16323453f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.02891547f, 0.35156894f, -0.14772342f, -0.00418479f, 0.00600500f, 0.14459179f, 0.06951133f, 0.08163416f, 
    -0.07233739f, -0.01036226f, 0.08443301f, 0.08824052f, -0.01373740f, 0.11834028f, 0.23773551f, -0.01445954f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.05489141f, 0.39093766f, -0.53224975f, 0.20378308f, 0.37105727f, -0.08228324f, -0.13596430f, 0.04636847f, 
    0.17329508f, -0.02083546f, 0.42350444f, 0.01725905f, -0.06243772f, 0.21462065f, -0.13516495f, -0.05614969f, 
    -0.14437588f, -0.23088132f, -0.23098083f, 0.06359149f, -0.02342551f, 0.20684816f, 0.51113063f, -0.11900679f, 
    -0.04798502f, -0.15090238f, -0.01170267f, 0.24591623f, 0.17311908f, 0.01548177f, -0.01507999f, -0.25079063f, 
    0.15874627f, -0.99374890f, 0.07192054f, 0.07341722f, -0.35345489f, 0.39211339f, 0.06809518f, -0.13852642f, 
    -0.08267070f, -0.21969832f, 0.41778713f, -0.29004556f, 0.40017441f, 0.18172146f, 0.34453854f, -0.49225321f, 
    -0.07299274f, -0.33613470f, -0.41437212f, 0.13752107f, 0.41902554f, 0.55920976f, -0.47482985f, -0.04346865f, 
    -0.24788676f, -0.06041642f, 0.13374688f, 0.06023683f, 0.13517815f, 0.05669727f, 0.19167505f, -0.37632662f, 
    0.13061641f, -0.33661011f, 0.19910187f, 0.01629575f, -0.18244040f, -0.16066165f, 0.45457664f, 0.08753087f, 
    0.23807591f, -0.36103877f, -0.34311521f, 0.28980860f, 0.26378444f, 0.25911400f, 0.17843448f, 0.12006404f, 
    -0.07219583f, -0.31232023f, -0.39394546f, 0.15887071f, 0.05134698f, 0.38078710f, -0.16606067f, -0.04700321f, 
    0.14064746f, 0.47807553f, 0.15449443f, -0.26938465f, -0.06507109f, 0.10178552f, 0.16882513f, 0.55859780f, 
    -0.23290426f, -0.30421922f, 0.42573354f, 0.04612883f, -0.03587205f, 0.06239896f, -0.12497584f, -0.20816918f, 
    -0.06713449f, 0.21448591f, 0.37347004f, -0.09900757f, 0.62479079f, -0.21919602f, 0.19538309f, -0.48510319f, 
    0.04527262f, 0.09118666f, 0.67994088f, 0.23734365f, -0.20318043f, -0.01236078f, -0.22931494f, 0.32081106f, 
    -0.03726857f, -0.38093445f, 0.21269302f, -0.27113843f, 0.25540441f, -0.26114264f, 0.47334543f, -0.05373031f, 
    -0.03881434f, -0.01767024f, 0.59457272f, 0.07948513f, -0.56553304f, 0.10087917f, 0.15165663f, -0.09612608f, 
    -0.16890812f, -0.14220591f, 0.12269860f, -0.07360770f, 0.23714016f, 0.06407036f, -0.37677830f, 0.26046154f, 
    0.11324582f, -0.09740273f, 0.16123815f, 0.11910523f, -0.49117604f, 0.27203190f, 0.35187745f, 0.17195958f, 
    -0.05907057f, -0.10475410f, -0.03484353f, -0.56769443f, 0.33846548f, 0.17232300f, 0.15920025f, -0.23971388f, 
    0.15115610f, -0.01249885f, 0.06290406f, -0.14011183f, -0.19457693f, 0.00639454f, -0.17057166f, 0.05247291f, 
    -0.16272235f, -0.22097908f, -0.14325973f, 0.03631473f, -0.09097091f, 0.05242988f, -0.17416617f, 0.15508135f, 
    -0.18842976f, -0.28472117f, -0.26479724f, 0.09980447f, 0.18540440f, 0.28745547f, 0.07051631f, -0.05291405f, 
    0.10212287f, -0.39359412f, -0.09366486f, 0.28956807f, 0.07152262f, 0.11477637f, 0.34993801f, -0.51876104f, 
    -0.03074054f, 0.18514811f, -0.20880215f, 0.15786310f, -0.23927577f, 0.10036892f, 0.23150437f, 0.00324738f, 
    0.08398072f, -0.27040851f, -0.02323049f, 0.12573709f, -0.04274297f, 0.08990505f, 0.19740525f, 0.09876883f, 
    0.08774285f, -0.44206670f, -0.35779002f, 0.18439408f, -0.27760828f, 0.13276829f, 0.35193470f, 0.50207597f, 
    -0.12119511f, 0.19430585f, 0.09603974f, 0.00389803f, -0.25156605f, -0.18827261f, -0.30205178f, 0.12250402f, 
    -0.13185170f, 0.02122593f, -0.39589238f, -0.09826122f, -0.20062137f, -0.21319015f, 0.51034182f, 0.34629458f, 
    0.12170439f, -0.08761287f, 0.37172920f, -0.10349692f, -0.30251294f, 0.27441493f, -0.13066240f, 0.22846836f, 
    0.18841390f, 0.78092885f, 0.12824452f, -0.01812177f, -0.17464979f, 0.45456794f, -0.09378073f, 0.05903475f, 
    -0.17104809f, -0.07684182f, 0.12325145f, 0.01875036f, 0.35534021f, -0.58301246f, -0.23270787f, -0.39466417f, 
    0.16024348f, -0.45000139f, -0.41951501f, 0.09495711f, -0.11000001f, -0.29483438f, 0.52577394f, 0.39749858f, 
    0.25065252f, 0.12892582f, -0.43271428f, 0.06008952f, -0.23523079f, 0.25164968f, 0.11795777f, -0.03905810f, 
    -0.16325545f, -0.09557870f, 0.82194281f, 0.24607486f, 0.00014289f, -0.03363588f, -0.16991650f, -0.08251943f, 
    0.18805905f, -0.03234024f, 0.39329082f, 0.24732223f, 0.31922817f, -0.36570945f, -0.11768053f, -0.22593911f, 
    0.04794636f, -0.36944568f, 0.07190144f, -0.07329106f, 0.26692927f, 0.06327241f, -0.26290941f, 0.23640564f, 
    0.20870544f, 0.45242983f, -0.32329616f, -0.09594847f, 0.06661139f, -0.14138418f, -0.14221808f, 0.27344337f, 
    -0.22652468f, 0.56447130f, -0.06548873f, -0.07748879f, 0.14887153f, -0.21748258f, 0.24787363f, -0.11030851f, 
    -0.06364328f, 0.06972065f, 0.45057890f, 0.12126675f, -0.11155589f, -0.52168518f, -0.47301015f, -0.29567888f, 
    -0.05867803f, 1.02221751f, 0.35078260f, 0.02445381f, -0.33008465f, -0.17979415f, 0.06812747f, -0.02236710f, 
    -0.06540507f, 0.07664599f, 0.37023234f, 0.08062892f, 0.15221822f, -0.70255363f, -0.31350252f, 0.25452489f, 
    -0.08458325f, 0.45611748f, 0.04278668f, -0.15455793f, -0.21279316f, 0.23225383f, 0.20347144f, 0.12287848f, 
    0.13166988f, -0.25248960f, 0.22378489f, 0.03332248f, 0.44353828f, -0.02549239f, -0.66062140f, -0.37972090f, 
    -0.04655113f, 0.14942048f, 0.14385915f, -0.05755178f, -0.11464743f, 0.20561905f, 0.02842633f, -0.05749676f, 
    0.11073449f, 0.46778959f, 0.23528124f, -0.40251222f, 0.21174382f, 0.52821696f, -0.19153635f, 0.08602621f, 
    0.16290784f, 0.56782860f, 0.01122269f, -0.04553345f, -0.08557747f, -0.34147230f, 0.15191434f, 0.32745892f, 
    0.14224528f, -0.20110759f, 0.50883406f, 0.05113432f, -0.26273113f, -0.17100243f, 0.07244536f, 0.22247219f, 
    0.07510656f, -0.39726302f, 0.13286778f, 0.13243076f, -0.38823208f, -0.16617256f, 0.14417991f, 0.49485150f, 
    -0.02997052f, 0.08170513f, 0.21727166f, 0.16884203f, -0.42400175f, 0.03422391f, -0.29522058f, 0.39880779f, 
    -0.13668445f, -0.10752028f, 0.05664841f, 0.15065086f, -0.24068418f, 0.02847043f, 0.01261006f, -0.20404208f, 
    0.08955401f, -0.23399390f, -0.05536990f, 0.01633959f, 0.03193513f, 0.21547316f, -0.19390616f, -0.13986729f, 
    -0.20483688f, -0.28681034f, -0.01117546f, 0.24044491f, -0.26071802f, -0.14865686f, 0.40596461f, 0.14267470f, 
    -0.10504872f, -0.33592919f, 0.14673965f, 0.19524214f, -0.18069609f, -0.10097026f, 0.38471690f, 0.31462067f, 
    0.11706629f, 0.11959171f, -0.27928868f, 0.13154964f, -0.02395435f, -0.17608239f, -0.11503931f, -0.16361625f, 
    -0.09034663f, -0.20802960f, 0.13091415f, -0.13265251f, 0.12710425f, -0.09883070f, 0.04091660f, -0.21713726f, 
    -0.00042939f, -0.14998093f, 0.20748121f, -0.22241586f, 0.09590018f, -0.02251648f, 0.22205728f, -0.07746933f, 
    -0.18485323f, -0.13320513f, -0.02384828f, 0.52320802f, -0.16791764f, 0.10387772f, -0.02041908f, 0.13598257f, 
    -0.11752272f, -0.33795810f, -0.02928214f, 0.11136731f, -0.07682747f, -0.29295096f, 0.15107673f, 0.23869482f, 
    -0.22492930f, 0.24662727f, 0.31994480f, 0.24538349f, -0.07829473f, 0.11833584f, -0.48757145f, -0.43183002f, 
    -0.08474854f, -0.10690187f, 0.05335262f, 0.00170795f, 0.37715480f, 0.35860863f, 0.07474571f, -0.28917524f, 
    -0.08222774f, 0.07125349f, -0.22263341f, 0.05344881f, -0.18071921f, 0.26088771f, -0.04795385f, 0.48058668f, 
    -0.04363826f, 0.10322386f, 0.01005149f, 0.20808154f, -0.10297871f, -0.06023392f, -0.24174330f, -0.23037946f, 
    -0.05014712f, -0.15451512f, -0.19514564f, -0.03112286f, -0.06417522f, -0.17350009f, 0.14652723f, -0.13648388f, 
    0.24042594f, -0.19180290f, 0.01469713f, 0.23575251f, 0.12277868f, 0.07548816f, -0.09727470f, -0.23937778f, 
    -0.23270217f, 0.29833183f, -0.31775793f, -0.15472634f, 0.52439392f, 0.42003840f, -0.00407555f, 0.21986476f, 
    -0.16390917f, -0.71964931f, 0.13205998f, -0.14339629f, -0.16396627f, -0.23297462f, 0.34301749f, 0.04447971f, 
    0.21961622f, -0.02891834f, -0.19168743f, 0.08146617f, 0.54014498f, 0.39828205f, 0.29997250f, -0.29172081f, 
    0.05805119f, -0.49187073f, -0.30973479f, -0.06323835f, 0.08834822f, 0.26984787f, 0.31048554f, 0.42398995f, 
    0.09837653f, -0.22348067f, 0.07697269f, -0.24050966f, -0.19183666f, -0.27429718f, 0.42729938f, -0.08341705f, 
    0.14918691f, -0.28254378f, -0.15220250f, 0.07851389f, 0.06230297f, -0.13872673f, -0.03277084f, -0.01352292f, 
    0.18090671f, 0.11550124f, -0.12821327f, -0.03211168f, -0.24626014f, -0.16030429f, -0.15958126f, -0.26781398f, 
    0.08317101f, -0.68579477f, 0.28947586f, -0.14054804f, -0.03356933f, -0.09274669f, 0.37606984f, -0.08628753f, 
    -0.02337264f, -0.05142638f, -0.22788191f, -0.02930536f, 0.24033368f, 0.42379460f, 0.35400543f, -0.26074350f, 
    -0.15334275f, 0.06140501f, 0.19659950f, 0.18009308f, -0.54552895f, 0.46518791f, 0.31827626f, 0.00502592f, 
    0.23904498f, -0.35267338f, 0.04483533f, 0.00635853f, 0.07513799f, -0.03364856f, -0.36977971f, -0.17451848f, 
    0.07868104f, -0.05518137f, -0.09633980f, 0.11564469f, 0.28940985f, 0.35360512f, 0.18601014f, -0.50567025f, 
    -0.26279318f, -0.19233024f, -0.14012177f, 0.29177132f, 0.10471971f, 0.24532190f, 0.18625455f, -0.11184797f, 
    -0.19093367f, 0.17755663f, -0.07503942f, 0.00602032f, -0.29842296f, 0.46367225f, 0.01412253f, -0.17925499f, 
    0.18296675f, -0.14131375f, -0.46090665f, 0.21394055f, 0.50047833f, 0.40089753f, 0.33969280f, 0.03167966f, 
    -0.18942353f, 0.05895038f, -0.01219965f, -0.05790067f, -0.16973542f, -0.04057120f, -0.09389042f, 0.06903589f, 
    -0.22195151f, -0.22726427f, -0.09690000f, 0.02707966f, 0.02112749f, 0.00296943f, -0.09256284f, -0.18908024f, 
    -0.20689744f, -0.32467040f, -0.04946792f, 0.20671330f, -0.12649448f, 0.15200946f, 0.23073687f, -0.23219053f, 
    0.19929485f, 0.33447802f, 0.42783606f, -0.44131783f, -0.01504931f, 0.42681020f, -0.02842768f, 0.33855301f, 
    0.02771437f, -0.03956478f, -0.15588544f, -0.12750250f, 0.25850469f, 0.27405733f, -0.35481566f, -0.17099160f, 
    -0.02931394f, 0.51730222f, 0.24923544f, -0.26231974f, 0.24192238f, 0.53943634f, -0.14327964f, 0.13719064f, 
    -0.03699669f, -0.54275250f, -0.12883867f, 0.16438006f, 0.01412691f, -0.15875027f, 0.22826971f, -0.14952078f, 
    -0.19059779f, -0.15632075f, -0.00087597f, 0.00706224f, 0.19644549f, 0.53810054f, 0.53488278f, -0.07068127f, 
    0.13700524f, 0.22529629f, -0.09241886f, 0.02115067f, 0.06729969f, 0.47966594f, -0.28728256f, 0.03197711f, 
    0.19052880f, 0.47740769f, -0.40951654f, -0.12004527f, -0.00487197f, 0.57703519f, -0.18307443f, -0.05647669f, 
    0.15789507f, -0.23444949f, -0.53020149f, -0.13930525f, 0.12267393f, 0.29932901f, 0.37303534f, 0.23889436f, 
    -0.19424269f, -0.08873418f, 0.11231027f, -0.25921217f, -0.32112408f, -0.38381228f, 0.02998454f, 0.44948548f, 
    -0.07127756f, 0.06124720f, 0.07557121f, -0.15716076f, 0.00758261f, 0.08478265f, 0.42257532f, 0.40375304f, 
    -0.11362864f, -0.39665526f, 0.18799481f, 0.30648413f, -0.25214332f, -0.45342675f, 0.18066950f, -0.17661598f, 
    0.03632757f, -0.22216399f, -0.09106711f, -0.19264942f, -0.17740814f, 0.48416430f, -0.12893213f, 0.42379138f, 
    0.09738390f, 0.43155521f, 0.13988881f, -0.24441886f, -0.34507066f, 0.49921355f, -0.17714508f, 0.37269613f, 
    -0.20363395f, 0.68412024f, -0.22743165f, 0.24160783f, 0.23908594f, 0.13074009f, -0.15489340f, -0.29770768f, 
    -0.12278944f, 0.12025068f, 0.04060814f, 0.33231509f, 0.24061295f, -0.56837189f, 0.02605549f, -0.31571904f, 
    -0.04862434f, -0.17442927f, -0.21275878f, 0.00948739f, 0.00967348f, -0.07065752f, -0.03429881f, 0.15062720f, 
    -0.18660390f, -0.18842670f, -0.23631749f, -0.16167486f, -0.21860686f, 0.03779823f, -0.19994110f, 0.11828887f, 
    -0.13322385f, 0.17189471f, -0.46693155f, -0.11521101f, 0.39333212f, 0.24036767f, -0.25702882f, -0.29411650f, 
    -0.10930733f, 0.26867315f, 0.18330091f, 0.22642344f, 0.04976163f, -0.49051344f, 0.14355032f, 0.15270416f, 
    -0.21234417f, 0.39423257f, 0.17270364f, 0.03297126f, -0.45451763f, 0.25847167f, 0.24771591f, 0.14172584f, 
    0.16894539f, -0.08967909f, 0.04085061f, -0.12783822f, 0.22967713f, -0.25537091f, -0.43594757f, -0.25151911f, 
    0.01463251f, 0.01305342f, -0.15899441f, -0.14833087f, 0.27691728f, 0.20434842f, -0.02470758f, -0.34784257f, 
    -0.06233059f, -0.40779367f, -0.20251291f, 0.53951782f, 0.31417590f, 0.24951553f, 0.20616879f, 0.26730227f, 
    -0.17089808f, 0.15287258f, -0.65832794f, -0.20193486f, 0.22418745f, 0.07678007f, -0.19648594f, 0.23225152f, 
    0.14528115f, 0.03117858f, 0.55620110f, -0.44239768f, 0.17824398f, 0.20581527f, -0.70978898f, 0.66873252f, 
    0.18751936f, 0.32034338f, 0.28615788f, 0.11395478f, 0.04808500f, -0.36162761f, 0.11613724f, 0.41042003f, 
    0.01956518f, 0.23862492f, -0.43694922f, -0.26774037f, -0.22989959f, 0.40977460f, 0.19822441f, 0.44743416f, 
    0.13312779f, 0.57372230f, 0.43481991f, 0.18170591f, -0.04908377f, -0.25422102f, -0.09106345f, -0.25744152f, 
    -0.03591692f, 0.24317025f, 0.06808496f, -0.14457330f, 0.60421664f, -0.06357167f, 0.27780312f, -0.42009273f, 
    0.10734074f, 0.72269291f, 0.40695816f, 0.13496232f, -0.19207086f, -0.45882261f, 0.04009516f, 0.21263054f, 
    -0.19878453f, 0.19990286f, -0.21652830f, -0.19460253f, -0.07856592f, 0.13120547f, 0.31742078f, -0.09774126f, 
    0.22721058f, -0.09349410f, -0.10610227f, 0.24575566f, 0.61369425f, -0.22072554f, -0.14108343f, -0.50060672f, 
    0.04360285f, 0.12092922f, 0.22946437f, 0.40657514f, 0.13201071f, 0.51314735f, 0.19204365f, -0.34082991f, 
    0.06329066f, -0.00908759f, 0.28762844f, -0.07402153f, -0.07914932f, 0.43668458f, -0.04507298f, 0.04286386f, 
    0.18145584f, 0.11545177f, 0.21611080f, -0.10353448f, 0.35963345f, -0.22039475f, -0.47319666f, -0.61312634f, 
    -0.07469770f, 0.06706709f, -0.44863230f, 0.16905114f, 0.08399425f, 0.16313335f, -0.13969547f, 0.01202234f, 
    0.23312907f, 0.33628157f, 0.37161928f, 0.01814477f, 0.11536647f, -0.44971216f, -0.13320535f, 0.00881991f, 
    -0.03059830f, 0.27901718f, 0.20721732f, -0.04301741f, 0.05286448f, -0.07145444f, 0.09433267f, -0.06511396f, 
    -0.02641479f, 0.20405152f, 0.27993461f, -0.59646034f, 0.13569447f, 0.11323880f, -0.39195362f, 0.15026866f, 
    0.03954831f, 0.01593893f, 0.34307736f, 0.05294067f, 0.11739808f, -0.05168412f, 0.41928837f, -0.00640067f, 
    0.03640132f, -0.12176442f, 0.39485484f, 0.24507101f, -0.10371810f, -0.17476872f, -0.42419621f, -0.11207484f, 
    0.06145706f, 0.02553219f, -0.14032005f, -0.02148083f, 0.10391832f, -0.40735057f, 0.42104095f, -0.42244828f, 
    0.05132801f, -0.10104251f, 0.14710309f, 0.07491480f, 0.21289045f, 0.16505972f, -0.06518418f, 0.40949401f, 
    -0.21224892f, 0.29561734f, 0.17179650f, 0.02430674f, -0.11185873f, 0.18578441f, -0.12714273f, 0.15489748f, 
    -0.00482316f, -0.09912877f, -0.00389025f, -0.29248455f, 0.45621234f, 0.34692988f, 0.09801229f, -0.06319643f, 
    0.04798809f, 0.30571598f, 0.14058886f, 0.08491201f, -0.07928415f, 0.02093257f, -0.27696475f, -0.18271603f, 
    0.16282859f, 0.02198179f, -0.16164412f, -0.08233172f, -0.20794846f, -0.35238886f, 0.17394984f, -0.12278432f, 
    0.00121899f, 0.46076477f, -0.47520140f, -0.05596408f, -0.33892027f, 0.49925399f, 0.01234943f, -0.02292234f, 
    0.10735935f, 0.23880525f, 0.24944641f, -0.13642548f, 0.41246006f, 0.20720582f, -0.16089781f, -0.23314087f, 
    0.03897431f, 0.52760679f, -0.47114369f, -0.02309260f, 0.04456472f, -0.35312906f, 0.03593272f, 0.64104319f, 
    -0.08901502f, 0.23599622f, -0.35721749f, -0.07275099f, -0.16919467f, 0.18712512f, -0.09601266f, 0.00542783f, 
    0.14654684f, -0.21586977f, -0.22059403f, 0.12069252f, 0.32260203f, 0.18798831f, 0.33434421f, 0.07961006f, 
    -0.18361083f, -0.10837200f, 0.03409168f, 0.34233737f, 0.02689089f, -0.42997706f, -0.36716521f, -0.36951718f, 
    0.03135664f, -0.36478138f, 0.11567900f, 0.12170258f, 0.23281720f, -0.30955455f, 0.25167561f, -0.06663151f, 
    -0.03157651f, 0.04650316f, 0.04702996f, -0.25507754f, 0.15485738f, -0.03363218f, 0.33650982f, 0.07791009f, 
    -0.09861866f, 0.06370912f, -0.48580396f, 0.18181302f, -0.32424113f, 0.39066336f, -0.03110219f, 0.30371231f, 
    0.07025994f, -0.02673358f, 0.17643827f, -0.19962204f, 0.33881637f, -0.00164765f, -0.33492842f, 0.07313646f, 
    0.03928697f, 0.39631179f, -0.27268678f, 0.20325024f, 0.47317135f, 0.01215802f, -0.21373621f, -0.25497261f, 
    0.12076001f, 0.01852657f, 0.15689585f, 0.43571368f, -0.03893086f, 0.20605755f, 0.02095675f, 0.32843545f, 
    -0.16508697f, 0.39866486f, 0.06455623f, 0.09517815f, 0.35707605f, -0.30408859f, 0.09602164f, -0.25575295f, 
    -0.19660859f, -0.11437126f, 0.04663921f, 0.01440459f, 0.02845197f, 0.16477372f, -0.06106830f, 0.50382429f, 
    -0.19333193f, -0.05438497f, 0.48031896f, 0.13550641f, 0.36098748f, 0.27143627f, -0.05201206f, -0.01569272f, 
    -0.20731470f, 0.26672277f, 0.27755302f, -0.29723594f, -0.26679516f, -0.17786504f, -0.53314078f, 0.31115308f, 
    -0.06343889f, -0.40785512f, 0.10039794f, -0.10100956f, -0.30571216f, 0.16778089f, 0.00806772f, 0.11596321f, 
    -0.19210440f, 0.25492194f, -0.02451950f, -0.06621107f, -0.26650527f, 0.36724925f, -0.09764403f, -0.00805977f, 
    0.04242253f, -0.07159312f, -0.01533667f, -0.12877946f, 0.43396404f, 0.06684934f, -0.17082793f, -0.11023371f, 
    0.19252825f, 0.28912404f, 0.54489636f, -0.24379715f, -0.06592142f, 0.48280212f, 0.07965497f, 0.22467414f, 
    0.15080267f, -0.16511360f, 0.22372875f, 0.09015600f, -0.29303297f, 0.37973285f, 0.29464746f, 0.13407455f, 
    0.02144711f, 0.35067388f, 0.08446278f, -0.46740854f, 0.06761293f, -0.21133246f, -0.56804234f, 0.05365542f, 
    -0.13924450f, 0.05877849f, -0.06607319f, 0.05612112f, -0.36143509f, 0.21194513f, 0.10732347f, 0.26967919f, 
    0.06766223f, -0.03191164f, -0.04807336f, 0.12143496f, -0.02684264f, -0.34473351f, 0.28084013f, -0.35573328f, 
    0.22152480f, 0.07514061f, 0.24100713f, 0.05376659f, 0.48135054f, -0.42333269f, -0.06275091f, -0.30464739f, 
    0.12580149f, 0.11197209f, 0.35769621f, 0.09867569f, 0.36991012f, -0.04699629f, 0.03550829f, -0.34404895f, 
    0.02165876f, 0.25940391f, 0.19359545f, 0.03300438f, 0.20275371f, 0.13137725f, -0.01257626f, 0.14630370f, 
    -0.19180101f, -0.14765526f, -0.33755338f, 0.33135182f, -0.19752356f, 0.19397186f, 0.00531709f, 0.55924499f, 
    -0.20148727f, 0.11994565f, -0.24292609f, -0.13962273f, 0.29690760f, 0.19306970f, -0.24121457f, -0.13263172f, 
    0.01084638f, 0.32764879f, 0.00594504f, 0.22908814f, -0.41268131f, 0.59857529f, 0.01112676f, 0.15716816f, 
    0.11271477f, 0.11796670f, -0.04915521f, -0.16642118f, -0.12878175f, 0.10750061f, 0.01488472f, -0.21594511f, 
    0.02605078f, -0.10940928f, -0.11233649f, 0.12546249f, -0.24393390f, 0.12522694f, -0.25362980f, -0.21410625f, 
    0.08333350f, 0.21087974f, -0.36857742f, -0.17376120f, 0.10731173f, 0.09194319f, -0.20532492f, 0.34645233f, 
    -0.09036839f, 0.38492888f, 0.10137304f, 0.12937464f, -0.07988531f, -0.20112261f, -0.28732553f, 0.01496767f, 
    -0.15297385f, -0.04523430f, -0.01242547f, -0.02091013f, 0.46180293f, -0.53812170f, 0.33429590f, -0.19413024f, 
    -0.04509334f, 0.13277711f, -0.18068486f, 0.26829222f, 0.06687291f, -0.27832478f, -0.26578930f, -0.00258447f, 
    -0.09345914f, -0.47931936f, -0.12473632f, -0.07956585f, 0.07590493f, -0.17708401f, 0.12451658f, 0.00812742f, 
    0.24231143f, 0.02238242f, -0.54619539f, 0.28007901f, 0.23098940f, 0.24667583f, 0.02145660f, -0.06489491f, 
    -0.18903174f, -0.20930423f, 0.25314322f, -0.22595504f, 0.18152913f, -0.06290481f, 0.17339872f, 0.06250162f, 
    -0.21680851f, -0.25895792f, 0.35738781f, -0.16680746f, -0.36567324f, 0.19525138f, -0.11739597f, 0.20606579f, 
    -0.00746900f, 0.49373868f, 0.49771154f, 0.02528515f, 0.24937268f, -0.39169654f, 0.48229176f, 0.04608160f, 
    0.10696200f, -0.41393346f, 0.44827920f, 0.15995359f, -0.28155652f, -0.38416779f, 0.19225124f, 0.14377916f, 
    0.22240399f, 0.07712875f, -0.32906100f, 0.02038729f, -0.03189512f, 0.32432699f, 0.07425568f, 0.26777092f, 
    -0.07303549f, -0.06412824f, 0.01096444f, 0.25661096f, 0.04009039f, -0.39051241f, -0.39397773f, 0.23432916f, 
    -0.24206746f, -0.09418129f, 0.02543498f, 0.22193462f, -0.26405579f, -0.07909343f, 0.11079878f, 0.35174462f, 
    0.18473130f, 0.20166039f, 0.33555272f, 0.44947875f, -0.25935230f, -0.40768820f, -0.49372640f, -0.12046226f, 
    -0.16737713f, -0.32002959f, -0.01291028f, 0.17137164f, -0.03071544f, -0.00646495f, -0.14398701f, -0.23322517f, 
    0.10825720f, 0.18356930f, -0.03129601f, -0.16551425f, 0.08034419f, 0.56251436f, 0.29745999f, 0.17397712f, 
    -0.09692651f, 0.04659264f, 0.14719583f, -0.17884856f, 0.41999450f, -0.41632566f, -0.20429435f, 0.05160741f, 
    -0.02461474f, 0.16412064f, 0.41709539f, -0.30523679f, 0.16384254f, 0.24796252f, 0.22891022f, -0.02348022f, 
    0.11054885f, -0.51211047f, -0.55719805f, -0.10975955f, 0.18884152f, -0.15650158f, 0.39246786f, -0.33491218f, 
    -0.12057151f, 0.06291505f, 0.19187188f, 0.33574197f, 0.23082566f, 0.13693026f, -0.17978020f, 0.29710677f, 
    -0.24008337f, -0.10271257f, -0.27719668f, -0.07505020f, 0.24268502f, 0.39174563f, -0.41062355f, -0.37474027f, 
    0.24619371f, 0.28819641f, 0.07314763f, 0.06491264f, -0.02640647f, 0.38983071f, 0.21273090f, 0.40921372f, 
    0.15010303f, 0.70898241f, -1.12531209f, 0.22082329f, -0.19565843f, -0.30797645f, 0.18312523f, 0.46331319f, 
    0.24130675f, -0.00509520f, -0.12939906f, -0.15192325f, -0.29061452f, 0.06902708f, 0.27753317f, 0.05596222f, 
    -0.14015259f, -0.57624406f, 0.11769138f, 0.09897212f, 0.10369618f, 0.14863054f, -0.00747395f, 0.12386269f, 
    -0.06319323f, -0.03485413f, -0.29371181f, -0.08597397f, 0.20051686f, 0.60763353f, 0.04907999f, 0.21115997f, 
    -0.22538720f, -0.13959527f, -0.35265189f, -0.21718229f, 0.35450190f, -0.16328412f, -0.08425565f, 0.24731502f, 
    -0.01147594f, 0.02045941f, 0.55849737f, -0.26838276f, 0.04427901f, -0.08709331f, -0.53554595f, 0.16947064f, 
    0.16997205f, 0.39390686f, -0.21302111f, 0.05334484f, 0.15150602f, -0.18305482f, -0.36335933f, 0.23965339f, 
    0.00121616f, 0.13700375f, 0.26605889f, -0.39585674f, -0.19785361f, 0.25298700f, 0.36816818f, 0.35629445f, 
    0.03284734f, -0.02015281f, 0.03140953f, 0.17455974f, -0.14608704f, -0.16226327f, -0.11341833f, -0.18452418f, 
    -0.09099370f, -0.15419765f, 0.20890470f, -0.07584392f, -0.05289334f, 0.01710770f, -0.12735283f, 0.06354949f, 
    0.13873044f, -0.42578077f, 0.10357468f, -0.25213301f, -0.22668336f, 0.23202729f, 0.44887117f, -0.40969500f, 
    -0.19996588f, -0.52579397f, -0.06275304f, 0.39101332f, 0.12587571f, 0.43056533f, 0.23838723f, 0.01383842f, 
    -0.24883905f, -0.11837420f, 0.54854971f, -0.10409647f, 0.15811647f, -0.03195307f, 0.33519119f, 0.33682224f, 
    0.06621347f, -0.39935553f, 0.00304182f, 0.23621373f, -0.02863291f, -0.28850853f, -0.08308277f, 0.08801730f, 
    0.15256158f, -0.00980938f, -0.16099420f, 0.03937149f, -0.01021942f, -0.26755983f, -0.23923093f, -0.02249821f, 
    -0.06458640f, -0.12371117f, -0.23883621f, 0.17350237f, 0.09033263f, -0.11371168f, -0.24961521f, -0.26624817f, 
    -0.21418680f, 0.32769373f, -0.05498787f, -0.02854683f, 0.22611201f, 0.13471101f, -0.12144534f, -0.05330435f, 
    -0.16194054f, 0.13426928f, -0.29565051f, -0.09081107f, 0.20968105f, -0.27426001f, -0.06178568f, 0.48454225f, 
    -0.03407497f, 0.35042340f, 0.48401594f, 0.14278395f, -0.20498000f, -0.32546657f, 0.17993778f, 0.42883632f, 
    0.19076239f, -0.23084351f, 0.26655403f, -0.43481502f, 0.18178368f, -0.37005275f, 0.15923104f, 0.34121275f, 
    0.00207308f, 0.30260393f, -0.28142825f, 0.22430374f, 0.33429459f, -0.16466592f, -0.07994327f, 0.18291540f, 
    -0.11184820f, 0.02790608f, 0.37980866f, -0.05444146f, 0.15806386f, -0.51669300f, 0.05136653f, 0.19211562f, 
    0.19101462f, 0.67295617f, 0.26049766f, -0.23358431f, 0.02511032f, -0.67982745f, -0.11340199f, 0.25128582f, 
    -0.21046543f, 0.21272607f, -0.09236445f, -0.08714275f, 0.11969592f, -0.08237986f, 0.41390952f, -0.19745521f, 
    0.11774075f, 0.22482973f, -0.13854262f, 0.16995108f, 0.03105504f, 0.05430742f, -0.20298028f, -0.07893273f, 
    -0.04453215f, -0.14006475f, -0.19009459f, -0.18829113f, -0.17967175f, -0.06624496f, -0.00411579f, -0.24411304f, 
    0.23528494f, 0.62721944f, -0.63382626f, -0.05503923f, 0.15454972f, -0.03988631f, -0.35552040f, 0.15090074f, 
    0.21478757f, 0.48829317f, -0.39331275f, 0.11595394f, 0.34976670f, 0.06887767f, -0.37047884f, 0.10709772f, 
    0.01036752f, -0.37877569f, 0.49804682f, -0.01226701f, -0.05786807f, -0.03928644f, 0.31899258f, 0.33339173f, 
    -0.12062705f, -0.27024689f, -0.31287608f, -0.46113834f, 0.41819930f, -0.17304188f, 0.07469179f, -0.16961123f, 
    0.18856224f, -0.43362826f, -0.05956227f, 0.24011958f, -0.06687216f, -0.08523235f, -0.12606347f, -0.09516338f, 
    -0.06998527f, 0.53377444f, -0.28607085f, 0.22447747f, -0.09169572f, 0.52217484f, 0.39350268f, -0.37315571f, 
    0.19362423f, -0.23093759f, 0.19388513f, -0.02891566f, -0.17894207f, -0.25663817f, 0.19227880f, 0.50692987f, 
    0.00046601f, -0.08854874f, 0.44645530f, 0.05001266f, -0.25107393f, -0.23235373f, -0.15912564f, 0.29625279f, 
    0.04833367f, 0.17400359f, -1.28638971f, -0.19387771f, 0.19527146f, -0.31052837f, 0.13715412f, 0.24731022f, 
    -0.24105278f, -0.33741951f, -0.10828481f, 0.47502905f, -0.24303524f, -0.22978756f, 0.15321381f, 0.39947438f, 
    0.06098434f, 0.49722788f, -0.07735894f, 0.04781443f, -0.22940755f, 0.06599492f, 0.09276295f, 0.00506670f, 
    -0.21451592f, -0.32704246f, 0.16211049f, -0.44108811f, 0.46354476f, -0.14852966f, 0.48749498f, -0.12767629f, 
    -0.03025284f, -0.40719658f, 0.53653872f, -0.23771782f, -0.13912489f, 0.16982271f, 0.25382441f, 0.03325717f, 
    -0.21235561f, -0.07854599f, 0.28961036f, -0.10689396f, 0.38035873f, 0.02060944f, -0.11172499f, -0.55258387f, 
    -0.11618254f, 0.53888011f, 0.23043236f, -0.06935998f, 0.56831056f, -0.17583089f, -0.16611639f, 0.01010629f, 
    -0.06099601f, 0.31851143f, -0.12855959f, -0.45665172f, 0.43188378f, -0.42904350f, -0.43606260f, 0.40611324f, 
    -0.02470636f, 0.42818290f, 0.38789043f, -0.08880839f, 0.38163769f, 0.08363974f, -0.13164707f, 0.03158393f, 
    0.19300881f, 0.43039274f, 0.36071792f, -0.85832185f, -0.32169056f, -0.18660073f, -0.34873155f, 0.22479536f, 
    0.04221397f, 0.14598274f, 0.11815253f, 0.14191532f, 0.42225820f, 0.13571915f, 0.07564713f, -0.53956389f, 
    0.13836464f, 0.18228835f, -0.14615427f, -0.03400188f, 0.27688721f, 0.31232324f, 0.05282089f, -0.07808393f, 
    -0.21634679f, -0.59000933f, -0.46085647f, 0.22971138f, 0.16351023f, 0.44075000f, 0.04467184f, 0.19064407f, 
    0.21335205f, 0.38350981f, 0.19337615f, -0.34714150f, -0.27686509f, -0.02172315f, -0.23315032f, 0.21097624f, 
    -0.01492578f, -0.24287461f, -0.20232090f, 0.21825506f, -0.22263348f, 0.16182894f, 0.31262106f, 0.00997647f, 
    0.11043292f, -0.13964264f, -0.14001094f, 0.37160805f, -0.20873089f, 0.23099346f, -0.06567075f, 0.50949764f, 
    -0.02204173f, 0.34941345f, -0.36125746f, 0.03739223f, 0.27773535f, 0.31197634f, -0.31341735f, 0.28800380f, 
    0.04082386f, 0.03934681f, -0.18709834f, 0.22863652f, -0.22923951f, 0.03925575f, -0.06467516f, 0.31517518f, 
    0.02143797f, -0.09516421f, -0.24483228f, 0.02108892f, -0.44822761f, -0.12623985f, 0.40674046f, 0.45253745f, 
    -0.13787447f, -0.01178580f, 0.13031723f, 0.21928035f, -0.34099844f, -0.31132072f, -0.17168476f, 0.30652234f, 
    0.16848895f, -0.05706109f, 0.26047108f, 0.13950261f, 0.32111847f, 0.04128259f, -0.22203173f, -0.00450728f, 
    0.18696712f, 0.15998825f, -0.06424459f, -0.21933666f, 0.29536444f, 0.47486752f, 0.02787887f, 0.03515166f, 
    0.18713215f, -0.63579506f, -0.38472536f, -0.12306137f, -0.09497558f, 0.29429695f, -0.12305383f, 0.33769494f, 
    -0.03186879f, 0.07989780f, 0.28234133f, 0.29453623f, -0.58405942f, 0.05440597f, -0.30658641f, 0.49423710f, 
    0.11822952f, -0.37726668f, -0.27415717f, 0.17089593f, 0.17413636f, 0.45351675f, -0.02889685f, -0.14465632f, 
    0.10147838f, 0.26186591f, -0.41669506f, -0.14824894f, 0.11535959f, 0.31709766f, 0.24346147f, 0.09789512f, 
    -0.13200164f, -0.46573091f, 0.32342666f, 0.17814484f, -0.06060018f, -0.17612204f, -0.25780523f, 0.32168663f, 
    0.10458670f, 0.18479909f, 0.44247249f, -0.93245441f, 0.39986259f, 0.04378251f, -0.66147083f, 0.32661894f, 
    -0.00193787f, -0.26474845f, -0.31172642f, 0.24369580f, 0.13370387f, 0.11081595f, 0.18899691f, 0.11002325f, 
    0.15525287f, -0.11810090f, -0.14829183f, 0.23392579f, -0.10201903f, -0.08023721f, -0.16685089f, -0.10084869f, 
    0.14578617f, -0.61893183f, -0.15734059f, 0.02115952f, 0.21742065f, -0.27930200f, 0.33748007f, -0.04922414f, 
    0.13109972f, -0.23924297f, -0.09482783f, 0.12814216f, 0.31669262f, 0.05595781f, 0.37405297f, -0.36786732f, 
    0.21335071f, -0.31971818f, -0.35041675f, -0.08442891f, -0.24203755f, 0.26486772f, 0.39570946f, 0.24249016f, 
    0.11804398f, 0.06201996f, 0.08805576f, -0.01088816f, -0.38738027f, 0.27869952f, -0.13441131f, 0.39414966f, 
    -0.11726767f, -0.54491687f, -0.50742018f, -0.23937006f, 0.12734449f, 0.33173716f, 0.13408126f, 0.25997156f, 
    0.06581671f, 0.41401321f, 0.38503996f, -0.35536620f, -0.27942339f, 0.14866108f, -0.21222766f, 0.07169598f, 
    0.21014300f, 0.49523792f, -0.18383631f, 0.15494671f, 0.49991426f, 0.02843155f, -0.14674705f, -0.04294600f, 
    0.01169150f, -0.10864895f, 0.36665469f, 0.45097217f, 0.43144521f, -0.14415103f, -0.11167330f, -0.34509522f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.32881084f, 0.50304884f, 0.10208721f, -0.25394255f, 0.43902883f, -0.25912556f, 0.15064773f, -0.33285964f, 
    -0.51619411f, 0.45889652f, -0.13478054f, 0.44608560f, -0.06405474f, 0.32918844f, 0.34310740f, 0.25454831f, 
    0.36013293f, -0.49312058f, 0.19002248f, -0.45492050f, -0.36088976f, -0.11504384f, -0.14668623f, -0.22283290f, 
    -0.23212367f, -0.15317340f, 0.25019807f, 0.07232741f, 0.28513348f, 0.21452592f, -0.10242033f, -0.08551398f, 
    0.21504997f, -0.08486685f, 0.46496132f, -0.12346382f, 0.28443792f, 0.13530454f, 0.17986873f, 0.13227427f, 
    0.12685043f, 0.23992299f, -0.32157338f, 0.22651875f, 0.26159331f, 0.24471551f, -0.05629934f, 0.00317239f, 
    0.27440622f, -0.17994198f, 0.04348584f, 0.22610353f, -0.01791070f, 0.27803919f, 0.07324695f, 0.14620602f, 
    0.29838759f, -0.05046268f, -0.20173366f, -0.39183310f, -0.03318708f, -0.03582888f, -0.00022303f, -0.16185340f, 
    0.16128179f, 0.08014260f, 0.34938711f, 0.15413575f, 0.30351502f, 0.00037826f, 0.06434038f, 0.27836284f, 
    -0.12851667f, 0.47577348f, -0.14137314f, -0.04233440f, 0.41768360f, 0.13009797f, 0.15289295f, -0.12990505f, 
    -0.06581719f, 0.20313354f, 0.43121642f, 0.00816383f, 0.41211194f, 0.27694455f, 0.06936733f, 0.00619771f, 
    0.25811160f, 0.17326351f, 0.08892217f, -0.10055090f, 0.25327092f, 0.29916590f, 0.22569361f, 0.57546836f, 
    -0.19041939f, 0.03075030f, -0.38700905f, -0.25134417f, 0.16618299f, 0.12958287f, -0.07465298f, 0.08448381f, 
    0.11496554f, 0.67012912f, -0.03506283f, -0.21866067f, 0.18934782f, 0.18945757f, 0.26910913f, -0.23025772f, 
    -0.08660558f, 0.19251426f, 0.02821649f, 0.38798335f, 0.02857469f, 0.13972026f, 0.13959138f, -0.34114543f, 
    0.12312940f, 0.52677256f, -0.42219105f, -0.16652122f, 0.35743779f, 0.44415361f, -0.08741640f, 0.24550916f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.02234426f, 0.11721620f, 0.27361140f, 0.04656351f, 0.14975752f, 0.05438524f, 0.17507805f, 0.39131272f, 
    0.06436393f, 0.42378065f, 0.01776511f, 0.04995150f, 0.00228279f, 0.06397966f, 0.14178084f, -0.33231443f, 
    0.16870677f, -0.61542690f, 0.03478787f, 0.18208557f, -0.39138192f, -0.26480043f, 0.07038231f, -0.27637282f, 
    -0.10250337f, 0.02841519f, 0.12737425f, 0.01260187f, -0.28600645f, 0.05231573f, -0.07531492f, 0.03829538f, 
    0.19656530f, 0.30521378f, 0.24110053f, -0.07178701f, 0.36380666f, -0.20143303f, 0.06762661f, 0.13157517f, 
    -0.00461097f, 0.25427076f, 0.02224396f, 0.28861547f, -0.06643517f, 0.03394400f, -0.04905456f, -0.19982545f, 
    -0.10731197f, 0.00914559f, -0.12108542f, -0.51975787f, -0.07877978f, -0.30439755f, 0.10856366f, 0.24601920f, 
    0.27335027f, -0.16165026f, -0.62649024f, 0.05233089f, -0.39673829f, -0.21784173f, 0.42010266f, 0.06326839f, 
    0.04305121f, -0.01186110f, -0.30068010f, -0.13697277f, 0.27706060f, 0.10357413f, -0.34740663f, -0.05639149f, 
    -0.41368207f, 0.09477840f, -0.05660567f, -0.27831313f, 0.12429436f, 0.01853104f, -0.29348981f, -0.48612919f, 
    0.00107561f, -0.39233249f, 0.27854067f, 0.08046626f, 0.18369719f, -0.03133403f, -0.26000550f, -0.25160050f, 
    0.10226814f, 0.23332214f, 0.24340560f, -0.22497912f, -0.14852145f, 0.09987723f, -0.22615325f, 0.08049179f, 
    0.05133119f, 0.14629866f, -0.16301581f, -0.06747980f, -0.10359591f, 0.22677149f, -0.06552614f, 0.22129329f, 
    0.01187380f, -0.13413894f, 0.44100395f, -0.02287029f, -0.01502312f, -0.96447277f, 0.47997490f, -0.01991761f, 
    -0.84765577f, 0.11972342f, 0.04321488f, 0.04082543f, -0.16847476f, -0.54022998f, -0.07619215f, 0.03152359f, 
    -0.52135056f, 0.12060662f, -0.59523064f, -0.04332049f, 0.19570935f, -0.03823555f, 0.01522596f, -0.37959322f, 
    0.24041323f, 0.07286832f, 0.10438590f, 0.30824617f, 0.12476702f, -0.20076008f, -0.10212763f, -0.19536084f, 
    0.28926432f, -0.03863609f, -0.02320940f, 0.20437783f, 0.06937195f, -0.42867538f, 0.08975964f, -0.14124708f, 
    0.21954162f, 0.07732516f, -0.22253758f, -0.37606910f, 0.08790354f, -0.17019975f, 0.08017487f, -0.08003619f, 
    -0.33778059f, 0.06282280f, -0.01395192f, 0.06740930f, 0.14637582f, -0.28972447f, 0.12413494f, 0.04385663f, 
    0.26763132f, 0.19871303f, -0.26250073f, -0.04825552f, 0.27856037f, -0.00223280f, 0.27481711f, 0.16230112f, 
    -0.08947667f, 0.13588007f, 0.22099192f, 0.20830321f, -0.00787448f, -0.11311325f, -0.19979388f, -0.19345233f, 
    -0.11872543f, -0.01210931f, -0.04541815f, 0.17489304f, 0.34547362f, -0.30152345f, 0.05539315f, -0.03401794f, 
    -0.06075079f, 0.30187917f, -0.21753015f, -0.34274411f, 0.35613245f, -0.14670718f, 0.23774441f, 0.13427912f, 
    -0.08462945f, 0.01423029f, -0.25339806f, -0.23589128f, 0.09269901f, -0.20871909f, 0.12898372f, 0.21551925f, 
    0.08870919f, 0.03911784f, 0.19183446f, -0.02388192f, -0.44106814f, 0.04987050f, 0.13594452f, 0.06667329f, 
    -0.02043605f, -0.56119746f, -0.17304841f, 0.06951702f, -0.01834759f, -0.01593182f, -0.63918602f, -0.62886941f, 
    0.15857235f, -0.01285027f, 0.15403454f, 0.13667636f, -0.08506991f, 0.12524997f, -0.57904595f, 0.05655581f, 
    -0.03289254f, 0.50621307f, -0.10917100f, 0.01119424f, -0.05302942f, -0.09549650f, -0.34512663f, -0.25235859f, 
    -0.07801463f, -0.03602625f, -0.09169672f, 0.14752188f, -0.32832536f, -0.27470294f, -0.14760378f, -0.13265051f, 
    0.40882930f, 0.71181291f, 0.22325580f, -0.38300401f, 0.14421663f, -0.03143781f, -0.23963477f, 0.17543645f, 
    -0.55568498f, 0.08715108f, 0.52167332f, -0.15550388f, 0.03598688f, 0.05528570f, -0.29190674f, -0.10450506f, 
    -0.26509789f, -0.25616995f, -0.54837179f, -0.66975158f, 0.00758028f, 0.31381994f, -0.22598107f, -0.61300826f, 
    -0.12075185f, 0.12500674f, -0.05591178f, -0.65724498f, -0.11631621f, 0.24435587f, -0.29728669f, -0.64399827f, 
    0.10328432f, -0.93641478f, 0.31218660f, 0.35368159f, -0.31593359f, -0.69863355f, 0.11976608f, -0.57813412f, 
    0.30368340f, 0.01559094f, -0.07566203f, 0.00396813f, -0.06325398f, 0.05329265f, 0.09544431f, 0.06735642f, 
    0.30231109f, -0.00314476f, -0.10500962f, 0.05911651f, 0.06136759f, 0.05875747f, -0.10179328f, 0.19404650f, 
    -0.03529151f, 0.06225213f, 0.27224967f, -0.01644764f, 0.47754925f, -0.01870012f, -0.37069488f, 0.53294152f, 
    -0.29914913f, -0.04489625f, -0.02663919f, -0.78245199f, 0.02307355f, 0.31651333f, 0.25412020f, -0.19146186f, 
    -0.06304979f, -0.30251727f, -0.86766714f, -0.06902549f, -0.69948202f, -0.52731758f, -0.76505792f, 0.10361308f, 
    -0.18393663f, 0.08274887f, 0.14648631f, -0.23172939f, -0.08785428f, 0.25160336f, -0.10037514f, -0.35882875f, 
    -0.66418290f, 0.42297113f, 0.04448390f, -0.50864542f, -0.04255985f, -0.51420790f, 0.14878662f, 0.29700807f, 
    0.04067457f, 0.14182939f, -0.37794977f, 0.11227409f, -0.09949297f, -1.01370382f, 0.33889791f, 0.19501390f, 
    0.25180429f, -0.04978714f, -0.17036948f, 0.26724055f, -0.32528594f, 0.33126512f, -0.09837238f, 0.08932903f, 
    -0.06635315f, -0.84332830f, -0.44032818f, 0.06502287f, 0.04729818f, -0.38210982f, -0.38807139f, -0.18528037f, 
    -0.04586105f, 0.17872792f, -0.33913928f, 0.46351445f, -0.14081359f, -0.43806124f, -0.23827177f, -0.79909688f, 
    -0.77111167f, -1.46123004f, -0.06059153f, 0.29143637f, 0.21403462f, 0.16463353f, 0.02442633f, 0.11928735f, 
    0.58060211f, 0.25359389f, -0.00911009f, 0.12515907f, -0.30593053f, 0.17965643f, 0.18830444f, -0.58694226f, 
    0.45606515f, -0.05521855f, -0.00502431f, -0.08885788f, -0.54447955f, 0.07273490f, 0.01040193f, -0.20678672f, 
    -0.18669227f, 0.01113456f, 0.02435170f, -0.14125019f, -0.03301870f, 0.18854196f, 0.40353131f, -0.06689179f, 
    -0.95365030f, -0.04219989f, -0.25109619f, 0.46153286f, 0.14369503f, 0.18075714f, 0.04862012f, 0.37251484f, 
    0.12238092f, 0.01600689f, -0.12970157f, -0.07649041f, -0.31961325f, 0.40216616f, -0.31544977f, 0.02543827f, 
    -0.93825865f, -0.46378118f, -0.04410345f, 0.06701096f, -0.66456515f, 0.13311920f, -0.35548681f, -0.61479169f, 
    -0.02466379f, 0.17335834f, 0.05276546f, -0.20687222f, -0.57859105f, -0.03925647f, 0.03198907f, 0.11005062f, 
    0.05473143f, -0.00242130f, 0.08152109f, 0.06563095f, -0.38858289f, 0.29760721f, -0.65504903f, -0.17996530f, 
    0.01786363f, 0.47130027f, 0.07177474f, 0.21698612f, 0.24920830f, 0.18456388f, 0.18076132f, -0.04691719f, 
    0.04350454f, 0.15563926f, -1.39679384f, 0.04951150f, -0.15848315f, 0.11382981f, 0.01190583f, -0.39263353f, 
    -0.04926345f, 0.07723338f, 0.32792193f, 0.10358232f, 0.00620910f, 0.11639042f, -0.68776041f, -0.12990834f, 
    -0.10337005f, 0.09576230f, 0.06254091f, -0.09896841f, 0.07655739f, 0.10798961f, -0.02191231f, 0.19396381f, 
    0.26913619f, 0.21698074f, 0.26727560f, -0.04167541f, -1.22200596f, -0.28354847f, 0.43187341f, 0.20997810f, 
    0.01713367f, -0.93731570f, -0.07427584f, -0.00042500f, -0.49267808f, -0.04708928f, 0.16631410f, 0.12896082f, 
    -0.07130266f, -0.92903835f, -0.50364280f, 0.26761863f, 0.17166778f, -0.95120275f, -0.07677492f, 0.04686458f, 
    -0.78205431f, -0.07643181f, -0.33127335f, 0.14082368f, -0.22376634f, -0.23254822f, 0.01876195f, -0.16248994f, 
    0.19453850f, -0.32207862f, 0.22850566f, 0.09785902f, -0.11583160f, 0.07484118f, 0.22970617f, 0.11421934f, 
    -0.27792454f, 0.09214494f, -0.12976937f, -0.96390790f, 0.07921980f, -0.10412197f, -0.35388249f, -0.17804046f, 
    0.21043655f, 0.31243375f, -0.07020916f, 0.01699644f, 0.04966722f, 0.31634295f, 0.33915219f, 0.26492196f, 
    0.23168030f, -0.20099814f, -0.03443927f, 0.19778259f, 0.08767347f, 0.37193161f, 0.01256125f, 0.04168647f, 
    0.22047955f, 0.00931462f, 0.13404863f, 0.03987470f, 0.03266371f, 0.22002354f, 0.03455222f, 0.01042102f, 
    -0.09889551f, -0.05819032f, 0.13507000f, -0.03530804f, 0.03029257f, 0.34609583f, -0.05797312f, -0.05988647f, 
    0.00477051f, 0.06059710f, -0.42019078f, -0.15373698f, -0.06164993f, 0.25477183f, 0.11515260f, 0.16598587f, 
    -0.13267495f, -0.04035322f, -0.40903014f, 0.54110092f, -0.29114333f, -0.55004430f, 0.09287656f, -0.13095964f, 
    0.11945404f, -0.19678472f, -0.13567561f, -0.28250203f, -0.12842241f, 0.25856066f, -0.11150938f, 0.02555995f, 
    -0.15805942f, 0.06855717f, 0.05557598f, 0.04158970f, -0.04081074f, 0.16022380f, -0.22603539f, -0.28574952f, 
    -0.11547314f, 0.21634732f, -0.31892231f, 0.04477843f, 0.13433322f, -0.08162585f, -0.02173636f, 0.06378309f, 
    0.04066094f, 0.00334009f, -0.09945542f, -0.19424307f, 0.33083773f, 0.19289814f, 0.09354376f, 0.21800229f, 
    0.16140890f, -0.18283911f, -0.05457020f, -0.09440202f, 0.11257809f, 0.05650630f, -0.71611315f, -0.05010079f, 
    0.04258725f, 0.04092998f, 0.04964404f, 0.03162428f, -0.18264589f, 0.18059948f, -0.15080282f, 0.02526142f, 
    0.06689232f, 0.04242543f, 0.24083894f, 0.04557547f, 0.11043501f, -0.56023157f, 0.13669547f, -0.05310190f, 
    -0.38735837f, -0.95750785f, -0.26611418f, -0.01144637f, 0.06024199f, -0.01435461f, 0.16187312f, -0.16017368f, 
    0.03364515f, -0.04357672f, -1.25033867f, -0.35864785f, -0.12928247f, 0.20183517f, -0.06306958f, -0.35191596f, 
    -0.06260195f, 0.24871810f, 0.44491425f, -0.32425082f, 0.19324350f, -0.74050528f, 0.22080520f, 0.16462396f, 
    -0.13588689f, 0.05813633f, -0.07421578f, 0.43006247f, 0.02588853f, -0.17471935f, -0.36857623f, -0.12884592f, 
    -0.17758226f, 0.09661635f, 0.07795773f, -0.58543664f, -0.62769020f, -0.14372000f, -0.42995963f, -0.15533687f, 
    -0.46361589f, 0.04885647f, 0.10886043f, 0.02857365f, 0.24397062f, -0.04063448f, -0.05344566f, -0.06787029f, 
    -0.06160401f, 0.15319581f, 0.18460305f, 0.03271933f, 0.22146249f, 0.28052825f, 0.24224865f, 0.11280341f, 
    -0.01549716f, -0.38931796f, -0.28152063f, 0.02975395f, 0.01097282f, -0.41132641f, 0.10398598f, -0.52149493f, 
    0.18363146f, 0.00768027f, -0.09748223f, -0.00555475f, 0.20511384f, -0.53995246f, -0.18049847f, 0.06779220f, 
    -0.24368970f, 0.29326200f, -0.00911721f, -0.39717731f, 0.23578583f, 0.04602632f, 0.07466239f, -0.24884751f, 
    -0.09857883f, -0.19137757f, 0.09075446f, 0.22765762f, 0.08018300f, -0.21084042f, 0.02370148f, 0.21428780f, 
    -0.18698929f, 0.02720546f, -0.27767164f, 0.16889794f, 0.23691130f, 0.29113168f, -0.00469786f, 0.04424430f, 
    -0.05127233f, -0.02604396f, 0.36075953f, 0.03922062f, 0.20977956f, 0.15056439f, -0.17305605f, -0.23974948f, 
    -0.36002070f, 0.09437292f, -0.03553389f, -0.34196484f, 0.06048176f, 0.03802801f, 0.01916357f, -0.08702799f, 
    0.03947274f, 0.20795058f, 0.09535541f, -0.01897989f, -0.08943700f, -0.22106491f, -0.14394914f, -0.01770367f, 
    0.00489338f, 0.66211617f, 0.11636537f, -0.36641943f, -0.15846422f, 0.63525736f, -0.10097401f, 0.39955568f, 
    0.35751224f, 0.64867687f, 0.08229307f, -0.18374708f, 0.00292022f, -0.10559631f, -0.15747169f, -0.15682015f, 
    -0.47380045f, -0.00993828f, 0.16261500f, -0.10917994f, 0.23934408f, -0.15674080f, -0.31914714f, 0.19925235f, 
    -0.04743164f, 0.21473189f, -0.45694610f, 0.56162238f, 0.21021885f, -0.18601963f, -0.52696216f, -0.13362953f, 
    -0.16937339f, -0.95139414f, -0.06183551f, 0.12519202f, 0.10307862f, 0.20037384f, 0.12676631f, 0.15425043f, 
    0.34071282f, -0.19700563f, -0.20388453f, 0.43001413f, 0.21177633f, -0.07508007f, -0.49935168f, 0.08769770f, 
    0.15014428f, 0.01582967f, 0.29238549f, -0.08879583f, 0.21439654f, -0.03124286f, 0.13007309f, -0.07276417f, 
    -0.21135151f, 0.10395311f, 0.22952434f, 0.04901037f, 0.02809064f, -0.43885511f, 0.11693181f, 0.03508547f, 
    0.05747673f, -0.26296705f, -0.32485217f, 0.03876049f, -0.58833075f, 0.21953693f, 0.26248044f, -0.36897928f, 
    0.06261902f, 0.06278683f, 0.07483207f, -0.45264995f, 0.23417872f, -0.04746799f, -0.17006339f, -0.54677463f, 
    -0.57873952f, -0.21584141f, -0.37870333f, 0.18701334f, 0.13292633f, 0.19039023f, 0.09727709f, -0.34284168f, 
    -0.14065902f, -0.14502846f, -0.45596305f, 0.26130810f, -0.12100607f, -0.17437144f, 0.07675263f, -0.00083641f, 
    -0.51883191f, -0.20625761f, -0.46563023f, -0.43210965f, 0.19663018f, -0.28406140f, 0.17068061f, -0.22759908f, 
    0.08658203f, -0.10786258f, 0.19551003f, 0.13405550f, -0.15419468f, 0.22096860f, 0.42259282f, 0.14758708f, 
    -0.43457705f, -0.90039492f, 0.21988927f, -0.14177056f, -0.37915981f, -0.08371004f, 0.05484366f, -0.40920690f, 
    -0.09192571f, 0.17828719f, 0.30134284f, -0.03345187f, 0.07914612f, -0.13895769f, 0.15615781f, -0.72071642f, 
    0.05151885f, -0.52267945f, -0.77073443f, -0.30854154f, 0.04852065f, 0.45744392f, -0.21047410f, -0.55410838f, 
    0.25221518f, 0.72329980f, -0.10262620f, 0.08815663f, 0.29644093f, 0.11047579f, 0.19151171f, -0.54576635f, 
    0.18468539f, 0.02462605f, -1.15890396f, 0.14687169f, 0.10525469f, 0.21255167f, -0.09698266f, 0.15118127f, 
    -0.77963543f, -0.16814692f, 0.08390758f, 0.12800680f, -0.10629395f, -0.21626489f, 0.19631593f, 0.19459051f, 
    0.21875678f, -0.04223984f, -0.09407045f, -0.15279005f, -0.21069746f, -0.19682331f, -0.63947225f, 0.15094158f, 
    0.03129391f, 0.29218400f, 0.10989969f, -0.33805680f, 0.15012661f, 0.18088619f, 0.15972567f, -0.13481846f, 
    -0.13022634f, -0.08668660f, -0.30394247f, -0.04302889f, -0.18442452f, 0.14728303f, -0.19272517f, 0.03413589f, 
    0.00532050f, 0.28384027f, -0.20468378f, -0.09716674f, -0.01852400f, -0.14349814f, -0.31954572f, 0.02043838f, 
    -0.05881052f, -0.26679918f, 0.07646073f, -0.39148328f, 0.13489996f, -0.10531396f, -0.01823004f, -0.29546088f, 
    -0.05491108f, 0.06231957f, -0.32106593f, 0.11830788f, -0.60544908f, 0.24929498f, 0.03099041f, 0.24462236f, 
    0.13435481f, -0.02128545f, 0.18619321f, 0.07643095f, 0.08302683f, 0.08527064f, -0.14787459f, 0.15176642f, 
    -0.12261638f, 0.16626683f, -0.91936964f, -0.02653700f, -0.16620965f, 0.19742221f, -0.28130266f, -0.44634178f, 
    -0.04870880f, -0.27456450f, -0.12491547f, 0.10848097f, -0.11548395f, 0.20288464f, -0.03844689f, 0.34451893f, 
    -0.10506477f, -0.25599849f, -0.04637945f, 0.19333975f, -0.45175853f, -0.10087420f, -0.06550127f, 0.07930102f, 
    -0.39375356f, -0.03343806f, -0.48155159f, -0.31370738f, -0.70566458f, -0.09021144f, 0.02296655f, -0.85537219f, 
    -0.04392974f, -0.80766934f, 0.19531989f, -0.03761516f, -0.12767695f, 0.03911821f, 0.06304520f, 0.39781308f, 
    0.02448029f, -0.71347857f, 0.26004490f, 0.74626768f, -0.05389969f, -0.90734762f, 0.06375049f, 0.25479078f, 
    -0.01956173f, -0.44782060f, -0.06411344f, -0.58397150f, -0.45390776f, -0.33972573f, -0.40892577f, 0.20105988f, 
    -0.27872846f, -0.40991944f, 0.44808570f, -0.60162729f, 0.11234474f, -0.67773610f, -0.06509452f, 0.18018760f, 
    0.15355781f, -0.43483305f, -0.24343856f, -0.17581409f, -0.31934717f, 0.03756626f, 0.12534018f, 0.02081125f, 
    -0.13744685f, -0.57263279f, -0.02691390f, -0.44753575f, -0.03889865f, -0.72898734f, -0.82749957f, -0.11276265f, 
    -0.90707672f, 0.11228847f, 0.06651253f, 0.24663562f, 0.38131201f, -0.45721650f, 0.09522741f, 0.17103066f, 
    -0.43458772f, -0.02999856f, -0.26669532f, 0.06323957f, -0.18166168f, -0.22699949f, 0.09653459f, -0.01878114f, 
    0.07783947f, -0.14949888f, -1.03010702f, -0.06891086f, -0.24944483f, -0.66386718f, 0.07087345f, -0.10512788f, 
    0.00488844f, -0.21226048f, 0.22828485f, -0.13967931f, -0.01754097f, -1.07874715f, -0.21837944f, -0.12993300f, 
    0.20728838f, 0.04255403f, 0.18211207f, -0.70712733f, 0.11841679f, 0.25560373f, 0.12491713f, 0.28478378f, 
    0.19658458f, 0.24689549f, -0.25447968f, 0.14526542f, -0.25014693f, -0.13572478f, -0.03673550f, 0.01770447f, 
    0.12777470f, -0.08509397f, -0.40656245f, -0.21539663f, -0.04352860f, -0.24081667f, 0.22816657f, 0.16342370f, 
    -0.09739750f, -0.25898880f, 0.17655572f, -0.52448094f, -0.26227596f, 0.24337567f, 0.06873009f, 0.06705040f, 
    -0.08133086f, 0.07775030f, -0.01043644f, -0.16392308f, -0.53449786f, 0.13297738f, -0.23453701f, 0.09179560f, 
    0.05792901f, 0.33736098f, -0.45328888f, 0.21973288f, -0.00195120f, -0.17835730f, 0.00756643f, 0.17951991f, 
    -0.03501788f, -0.00240369f, -0.01693636f, 0.07983260f, 0.15194435f, 0.02008592f, 0.23126343f, 0.32459617f, 
    0.00177559f, 0.29569572f, -0.20275642f, -0.17968175f, -0.29090458f, -0.50723839f, -0.08287995f, 0.12840907f, 
    0.44852075f, 0.11270355f, 0.16763294f, -0.44947794f, -0.30224642f, 0.14847441f, -0.42794394f, 0.14678699f, 
    -0.17036091f, -0.13028714f, 0.53236544f, -0.28338191f, -0.11739266f, -0.54720747f, -0.66631645f, 0.13893718f, 
    -0.15496714f, -0.03722862f, -0.07679445f, 0.16515122f, 0.08601847f, -0.15750745f, 0.04687340f, 0.24656191f, 
    0.14931846f, -0.01175492f, 0.00009781f, -0.07730141f, 0.07266009f, -0.03901231f, -0.13182887f, 0.37151951f, 
    0.14323367f, 0.50449210f, -0.17284067f, -0.44941023f, 0.44179353f, 0.02175287f, -0.22749756f, 0.18672842f, 
    0.19157717f, 0.01970337f, 0.06483851f, -0.03026648f, 0.00966647f, -0.23545124f, -0.23724368f, 0.04031604f, 
    -0.19732681f, -0.21340662f, -0.09564783f, 0.01036665f, -0.21817805f, 0.03139575f, -0.15569092f, 0.15929672f, 
    -0.02666132f, -0.33966210f, -0.44919652f, -0.20663851f, -0.38752949f, -0.07875343f, 0.05480767f, -0.18068084f, 
    0.22180553f, -0.04720408f, 0.06537710f, 0.01649123f, -0.00845662f, -1.64395940f, 0.11463346f, 0.16759053f, 
    0.34488299f, -0.90397310f, 0.19609918f, 0.12167836f, -0.37890202f, -0.01262153f, -0.22743531f, 0.17761105f, 
    -0.09538356f, 0.05950667f, 0.31752995f, -0.17904527f, -0.11293097f, -0.17911467f, 0.04142470f, 0.07778463f, 
    -0.24390517f, -0.06961367f, -0.69416070f, -0.24606383f, 0.18228284f, -0.12390263f, 0.15147783f, -0.45218933f, 
    -0.02677649f, 0.07400765f, -0.10686754f, -0.08803082f, -0.21475761f, 0.25963753f, 0.06142391f, 0.15403934f, 
    -0.29355949f, -0.28333667f, -0.30165276f, -0.34238598f, 0.69361645f, -0.24923775f, -1.18362117f, 0.14096409f, 
    -0.08230971f, -0.15379362f, 0.17536820f, -0.02765700f, 0.10392818f, 0.24594614f, 0.08485066f, 0.31193051f, 
    -0.04701649f, 0.05051977f, -0.08434136f, -0.91639566f, 0.09161009f, 0.43724561f, 0.39206910f, 0.16911009f, 
    -0.11225045f, -1.03905177f, -0.14051913f, -0.15744162f, 0.02014732f, 0.10478846f, 0.12024612f, -0.12416614f, 
    -0.06893318f, -0.07285239f, -0.19486481f, 0.16501179f, -0.35146135f, -0.01585268f, -0.11567713f, 0.04127334f, 
    0.05017772f, 0.06633832f, -0.06683414f, 0.39080209f, -0.40473324f, 0.29064381f, 0.13140602f, -0.64189398f, 
    -0.79901785f, 0.02602825f, 0.02092083f, 0.06194511f, -0.13110976f, -0.03449799f, -0.49227780f, 0.18082996f, 
    -0.75825357f, -0.38754335f, 0.15191831f, 0.02635531f, -0.21896566f, 0.06143700f, 0.16719452f, -0.70810193f, 
    -0.54320806f, -0.04498133f, -0.58728206f, -0.00178620f, -0.31855860f, -0.12216984f, 0.08036902f, 0.08567490f, 
    0.27798915f, -0.44538268f, -0.04895718f, 0.05069834f, -0.42495510f, -0.23731400f, 0.19573091f, 0.13651779f, 
    -0.08934712f, 0.13869591f, 0.33153361f, -0.38054895f, 0.42493349f, 0.03068285f, -0.27016771f, 0.04751949f, 
    0.22090961f, -0.08171131f, 0.26152688f, 0.06799631f, 0.00698547f, 0.23703222f, -0.59473240f, 0.02735922f, 
    -0.84324431f, 0.05669247f, 0.04832345f, 0.25773397f, 0.01594216f, -0.08613780f, -0.57308549f, -0.01819681f, 
    -0.05503998f, 0.34842879f, -1.91034925f, 0.11304749f, -0.22301260f, 0.19352090f, 0.09580120f, -0.16949932f, 
    0.12763146f, 0.07287983f, 0.15051174f, 0.13550830f, -0.01932814f, 0.00775135f, -0.14447649f, 0.19105323f, 
    -0.06791221f, 0.24774471f, -0.69460934f, -0.24513088f, -0.40609682f, -0.50167382f, 0.09556878f, -0.11205931f, 
    0.14177009f, 0.00510525f, -0.00654310f, 0.35423785f, -1.82159519f, 0.00036991f, 0.13048691f, -0.06967147f, 
    0.03133845f, -0.84083527f, -0.38307479f, 0.05067720f, 0.17453600f, -0.32995230f, 0.04414643f, -1.02810788f, 
    -0.04572361f, 0.24884672f, 0.07727430f, -0.07368140f, -0.29651111f, -0.68964636f, -0.00079528f, -0.13168213f, 
    0.14743589f, 0.16074973f, 0.23880388f, 0.35583249f, -0.14359999f, 0.09588132f, -0.41368216f, 0.11737981f, 
    0.06533850f, 0.27960622f, -0.33272943f, -0.11040064f, -0.44594750f, -0.03549114f, 0.21686906f, 0.27501410f, 
    -0.02564309f, -0.35333008f, -1.12772202f, -0.41956607f, -0.16207026f, 0.28355736f, -0.41921088f, -0.21781081f, 
    -0.03613657f, -0.46692002f, -0.01145659f, -0.45977768f, -0.22007446f, 0.17880894f, 0.06401753f, -0.58380157f, 
    0.00022700f, -0.23061766f, 0.25045979f, -0.72725880f, -0.14642896f, -0.17924638f, -0.07087424f, 0.13354658f, 
    0.31198657f, -0.04827611f, 0.06917093f, 0.00546146f, 0.00512225f, -0.01621223f, 0.07988800f, -0.08142475f, 
    -0.16549948f, -0.36516932f, 0.14457171f, -0.06429313f, -0.14215037f, 0.09361131f, -0.22033484f, -0.69978011f, 
    -0.03172225f, 0.15652159f, 0.00439995f, -0.07400232f, -0.43775553f, 0.25745109f, -0.05945514f, 0.25247172f, 
    -0.49303240f, 0.03611321f, 0.04118252f, -0.47052017f, -0.19598027f, 0.48863256f, 0.13076887f, -0.39153382f, 
    -0.24974802f, -0.32634798f, -0.46939448f, 0.02804407f, -0.17889863f, 0.06999909f, -0.06709347f, -0.46545801f, 
    -0.04709465f, -0.61952281f, -0.50330901f, -0.08918104f, 0.12956430f, -0.22082166f, 0.04126691f, 0.18063994f, 
    0.45605272f, 0.02114351f, 0.25275892f, 0.11658745f, -0.36248526f, -0.04063148f, 0.06051499f, -0.03124192f, 
    0.03488186f, 0.07312347f, 0.08235479f, -0.21931915f, 0.29806411f, 0.22240269f, 0.01500797f, 0.13074023f, 
    -0.07348461f, 0.12196870f, 0.08427020f, 0.07915594f, -0.58058822f, 0.00346976f, 0.37479225f, 0.18112795f, 
    -0.09567241f, -0.19388135f, 0.21336553f, 0.07517827f, 0.08566283f, 0.17700395f, 0.14355786f, -0.26830122f, 
    -0.04268631f, -0.36733818f, -0.23969580f, -0.21270519f, 0.24125274f, -0.06056695f, -0.76450104f, -0.28514516f, 
    0.21677233f, 0.18363759f, -0.10182186f, 0.26013112f, -0.01930550f, 0.08388050f, 0.06177101f, -0.02201371f, 
    0.29061159f, -0.08549266f, -0.04465565f, -0.16613366f, -0.13237622f, 0.10064977f, 0.20096208f, -0.35333803f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.05866865f, -0.12941989f, -0.09813083f, -0.18148965f, 0.12607054f, 0.30101359f, -0.01305928f, -0.57873750f, 
    -0.02959945f, 0.04065250f, 0.04337109f, -0.02601090f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
