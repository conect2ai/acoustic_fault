#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.04324158f, -0.28395674f, 0.91413778f, 0.21435863f, 0.26414385f, -0.37537125f, -0.14233334f, -0.46231094f, 
    -0.16721983f, -0.47236809f, -0.40024588f, -0.84968579f, 0.84437025f, 0.33590284f, -0.58406085f, -0.53027600f, 
    -0.52281958f, -0.15973699f, 0.58552492f, 0.40783659f, 0.20777306f, 0.27362162f, -0.64497143f, -0.50552279f, 
    -0.15800354f, 0.02632758f, -0.09697964f, 0.98824972f, -0.71240187f, 0.17929468f, -0.92816055f, 0.81075996f, 
    -0.45725617f, -0.10385927f, -0.02799883f, 0.16979674f, -0.56056643f, 0.38456988f, 0.16560449f, 1.03010464f, 
    -0.09549458f, -0.61249375f, -0.02333382f, 0.34865072f, 0.09314044f, 0.19292296f, -0.22896667f, 0.12214331f, 
    0.20966358f, 0.42535570f, -0.24417743f, 0.15594357f, 0.47230855f, -0.58112240f, -0.71035868f, 0.82843357f, 
    -0.14592344f, -0.37919098f, -0.33355319f, 0.17684947f, 0.35949910f, -0.07153755f, 0.55662566f, -1.15153396f, 
    -0.84286773f, 0.97900677f, -0.04088996f, -0.68446183f, 0.60243797f, 0.05172181f, 0.09596269f, -0.14212461f, 
    -0.67386454f, -0.40826675f, -0.37561366f, -0.41043255f, -0.82055783f, -0.44476879f, -0.38210553f, 0.35062176f, 
    0.54317176f, 0.09797117f, 0.32554299f, 0.35803184f, -0.45025006f, -0.77665991f, -0.44662961f, 0.35531655f, 
    0.41478422f, 0.76671857f, -0.63668448f, -0.85363746f, -0.80121464f, 0.86469913f, 0.54181880f, -0.04187227f, 
    0.80219096f, 0.20797305f, 0.62463897f, 0.46501896f, 0.50864929f, 0.22632937f, 0.38332316f, -0.24152859f, 
    0.03487076f, 0.41446632f, -0.26050395f, -0.39028689f, -0.81746000f, 0.28079754f, 0.37952021f, -0.27814791f, 
    0.36302757f, -0.53738868f, -0.41443849f, -0.41794527f, -0.73288447f, 0.44802707f, -0.39353669f, -0.30028120f, 
    -0.03176342f, -0.06197609f, -0.58047873f, -0.39912513f, -0.03146251f, -0.05531653f, 0.53369784f, 0.50057292f, 
    0.32759380f, 0.12648594f, 0.38575569f, 0.49482244f, 0.04482898f, 0.78198934f, 0.10169628f, -0.36686990f, 
    -0.56336606f, -0.31977817f, 0.84839422f, 0.33251628f, 0.76993787f, -0.00195145f, -0.57658833f, -0.39404142f, 
    -0.46474931f, 0.20676938f, 0.51367182f, -0.70396221f, 0.09970126f, 0.15793966f, 0.58745784f, 0.32607895f, 
    0.11146715f, 0.40714484f, 0.22534297f, 0.00296373f, -0.33455801f, 0.99397844f, -1.04139423f, -0.15641841f, 
    0.27586007f, 0.02655685f, -0.39761811f, 0.34087372f, 0.42622218f, -0.32617265f, -0.66726774f, 0.83985859f, 
    0.42094481f, 0.00026968f, -0.25236893f, 0.85062903f, 0.05750129f, -0.57875800f, -0.06782819f, 0.38501444f, 
    -0.33089656f, -0.46350890f, 0.44858342f, 0.08825321f, -0.63060111f, -0.19850264f, 0.61484307f, -0.53532159f, 
    -0.16829626f, -0.76635396f, 0.15395102f, 0.94355440f, -0.17706843f, 1.16405737f, -0.92040372f, -0.85514539f, 
    0.37816614f, 0.16360347f, 0.61216611f, -0.05110899f, -0.05933259f, -0.32686058f, 0.28731072f, -0.99122804f, 
    -1.05353892f, -0.47395334f, -0.06215982f, 0.40866187f, 0.43316877f, 0.06602704f, 0.17066960f, -0.03876647f, 
    0.44438893f, -0.26685786f, -0.52585292f, 0.12712459f, 0.08032004f, 0.50751954f, 0.42779240f, 0.53966498f, 
    0.61261022f, 0.63774127f, -1.15860105f, -0.36005300f, -0.70537001f, -0.27512094f, -0.13443626f, 0.25080112f, 
    -0.16679382f, 0.05364362f, 0.63127118f, 0.52956581f, 0.52931166f, 0.49797979f, 0.73257095f, 0.24017385f, 
    -0.45470104f, -0.00043980f, 1.13144934f, -0.82374460f, 0.34266368f, 0.06424333f, 0.40068635f, -0.40117061f, 
    -0.14910889f, -0.18377976f, -0.28766528f, 0.16975473f, -0.58341020f, 0.95774209f, 0.41269284f, -0.22573346f, 
    0.56539482f, -0.20129207f, 0.27229840f, 0.44182718f, -1.03211212f, 1.17656267f, 0.01768832f, -0.74342167f, 
    -0.43510017f, -0.21373165f, 0.00999479f, -0.06931163f, 0.17134735f, 1.37433136f, -1.04713380f, -0.32994986f, 
    0.26894090f, -0.24333493f, -0.28376639f, 0.33417061f, 0.19076303f, 0.06727791f, -0.22294430f, -0.24838147f, 
    0.06645481f, -0.43941179f, -0.26983681f, -0.52371234f, -0.50882232f, -0.67578804f, -0.38696223f, 1.11519897f, 
    0.40290204f, 0.59305662f, -0.04610609f, -0.21995132f, -0.11031741f, 0.29895440f, 0.12215294f, -0.06298828f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.16345629f, -0.17423458f, 0.36089993f, -0.16462800f, 0.24359100f, 0.50375217f, -0.16777623f, -0.08221339f, 
    -0.39578801f, 0.02979224f, 0.37028572f, -0.00434906f, 0.01911992f, 0.49217653f, -0.02655005f, 0.21142823f, 
    -0.37772924f, -0.03649324f, 0.22919466f, 0.42117596f, 0.24737583f, 0.04667141f, 0.39817163f, -0.03546556f, 
    0.26348713f, 0.14455518f, -0.14534461f, 0.32447270f, 0.33728617f, -0.15230086f, 0.04726282f, 0.12553409f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.00903224f, 0.04957579f, 0.03056790f, -0.06381045f, -0.00693363f, -0.05990047f, -0.06208831f, -0.01906416f, 
    -0.02190956f, 0.00571656f, -0.06102465f, -0.05385005f, -0.06056340f, -0.04992128f, 0.02134548f, 0.02643222f, 
    0.02339099f, -0.03388537f, -0.04549897f, -0.01305604f, 0.00206664f, 0.03643610f, -0.00279703f, -0.02273314f, 
    0.01607943f, 0.00343793f, -0.00285938f, -0.05871286f, 0.00659787f, 0.03367633f, -0.01243387f, 0.04484368f, 
    -0.06293476f, 0.01922051f, -0.05053762f, 0.03926777f, 0.03362431f, 0.02216040f, -0.00532431f, -0.02845546f, 
    -0.02207777f, 0.03079874f, 0.02641810f, -0.02738408f, -0.00098034f, 0.04195035f, 0.03447108f, -0.03262186f, 
    0.02186611f, -0.05748513f, -0.04921092f, 0.03735107f, -0.00111914f, -0.06365314f, 0.01479716f, 0.03152827f, 
    0.00063726f, 0.04242450f, -0.00936915f, 0.03663243f, -0.03571667f, 0.04498454f, -0.05865436f, 0.05243756f, 
    -0.00045785f, 0.01953607f, -0.01664598f, -0.03262151f, 0.04898274f, 0.01864813f, -0.00297039f, 0.00819238f, 
    -0.03316309f, -0.03589934f, -0.04425323f, -0.01129324f, -0.03788451f, 0.03965686f, 0.03417017f, 0.02972203f, 
    -0.06451546f, -0.06613632f, 0.01421484f, -0.02177619f, 0.03074157f, -0.01793019f, -0.05190850f, 0.03992398f, 
    0.02614058f, 0.00383331f, -0.02195107f, 0.00743548f, 0.02672433f, -0.04021897f, -0.05227070f, -0.04682225f, 
    -0.00663926f, -0.04709249f, -0.01892242f, -0.02176160f, 0.00136977f, -0.04266254f, 0.00142848f, -0.03025914f, 
    0.02261668f, -0.04693967f, -0.03164166f, 0.05011983f, -0.05097068f, -0.03591387f, -0.00961276f, -0.01492044f, 
    -0.01440557f, -0.02407292f, -0.05457862f, 0.04254895f, -0.03079388f, 0.01135574f, -0.00052385f, 0.00933546f, 
    -0.00767433f, -0.03417785f, 0.04526984f, 0.01236693f, -0.00589750f, 0.00236015f, -0.03296126f, 0.00705546f, 
    -0.06455555f, -0.00267956f, -0.02513421f, -0.03054967f, -0.05547272f, -0.03575582f, 0.01558001f, -0.04534356f, 
    0.02959590f, 0.01462551f, -0.02232580f, 0.00398065f, -0.03013550f, 0.02331608f, 0.03449976f, -0.04220067f, 
    0.02677594f, -0.03854927f, -0.02935161f, -0.02367776f, 0.01555833f, 0.01923687f, 0.01612096f, -0.01695264f, 
    -0.02435708f, -0.05547344f, 0.03200966f, 0.02041037f, -0.03474269f, 0.03855231f, -0.03196675f, -0.05993535f, 
    -0.00355987f, -0.00152682f, 0.00323764f, 0.03866517f, -0.04904987f, -0.05330317f, -0.01350298f, -0.02153900f, 
    -0.01704656f, -0.05951242f, -0.01732865f, 0.00891650f, -0.03973860f, -0.04702329f, -0.01791552f, -0.03164205f, 
    -0.03716101f, -0.01121813f, 0.02836456f, 0.03437952f, 0.00131925f, -0.05253103f, -0.03469242f, -0.01270728f, 
    -0.02630263f, 0.00539412f, 0.00417574f, 0.00889063f, -0.05607593f, -0.06735912f, 0.01853131f, -0.03914937f, 
    -0.04984539f, -0.03704610f, -0.00018368f, 0.03123518f, -0.03196234f, -0.04574492f, -0.04826612f, 0.04352145f, 
    0.03257653f, -0.05260501f, -0.04883793f, -0.02493599f, -0.04399259f, -0.00516038f, -0.04961526f, 0.02618995f, 
    0.03782592f, -0.04385363f, -0.00829830f, 0.03636150f, 0.01041505f, -0.05828821f, -0.00993242f, -0.04607286f, 
    -0.00184035f, 0.01654316f, -0.05514212f, 0.01598955f, -0.02491320f, -0.00856448f, -0.03136063f, -0.06740596f, 
    0.04472657f, 0.02865547f, 0.00524315f, -0.00560474f, -0.05365790f, 0.00068671f, 0.04051626f, -0.01694883f, 
    -0.03388137f, -0.01150622f, -0.03241583f, 0.00755552f, -0.05485515f, 0.00808833f, 0.04490780f, 0.00722416f, 
    0.01524212f, -0.05373862f, -0.04701050f, 0.00857090f, 0.04355483f, -0.06721082f, -0.03497107f, 0.04947681f, 
    0.03372710f, -0.06053702f, -0.01328255f, 0.00280571f, -0.02101846f, -0.00567840f, 0.00448289f, 0.03223741f, 
    -0.06294686f, -0.05135431f, -0.02555332f, -0.00218361f, 0.03118782f, -0.02434528f, -0.02374716f, -0.05863623f, 
    0.02006798f, 0.03737148f, -0.02391096f, -0.05372854f, -0.00924170f, 0.01119470f, 0.00188357f, 0.01158918f, 
    -0.06138468f, 0.02867721f, -0.05872741f, -0.03440618f, -0.06468347f, 0.03815968f, 0.01338181f, 0.01105007f, 
    -0.02605234f, 0.02138150f, 0.00417347f, -0.04563721f, -0.04607536f, -0.03671961f, 0.00726082f, 0.03661077f, 
    -0.28026715f, 0.07409597f, -0.06310391f, 0.03174093f, 0.18461783f, -0.13263103f, 0.13921694f, 0.25509986f, 
    0.16806079f, 0.09041680f, -0.00903855f, -0.06319941f, 0.07430254f, -0.04705851f, -0.06060926f, -0.16023442f, 
    -0.14993492f, 0.06968339f, 0.05686670f, 0.16916075f, 0.16548221f, -0.09143601f, -0.00898531f, -0.12164784f, 
    0.01230526f, 0.27657497f, -0.00436235f, -0.08772882f, -0.42929977f, 0.25608754f, -0.25286686f, 0.19959144f, 
    0.39219770f, -0.05041987f, -0.05856007f, 0.26626760f, 0.06111377f, -0.01980162f, 0.11225560f, 0.20137875f, 
    -0.08786336f, -0.14425938f, -0.06199813f, 0.16530702f, 0.11067170f, 0.31363171f, -0.08080213f, 0.14336886f, 
    0.03306757f, 0.09895061f, 0.32301798f, 0.07564184f, 0.19165695f, 0.26607230f, -0.32336223f, -0.10127621f, 
    -0.29794014f, 0.33449283f, -0.06938670f, 0.20578015f, -0.14848603f, -0.13807313f, -0.16264620f, 0.16939870f, 
    0.25141683f, 0.13676746f, -0.09437588f, 0.16799241f, -0.06983864f, 0.06567837f, 0.20729430f, -0.13818184f, 
    0.26954764f, -0.04070110f, -0.47301200f, -0.29631832f, -0.08082941f, -0.15744731f, -0.05010279f, -0.01855267f, 
    -0.28791511f, 0.10582718f, -0.11504120f, -0.06522954f, 0.22475810f, 0.02891050f, -0.13430645f, -0.30984655f, 
    -0.28094199f, -0.32460260f, -0.24995144f, 0.18447985f, -0.03668302f, -0.30055687f, -0.02233663f, -0.01303689f, 
    0.00285322f, -0.16476603f, -0.21110362f, -0.02155800f, 0.11819675f, 0.15501301f, -0.08631630f, 0.06314823f, 
    0.09176012f, -0.02947456f, 0.20069784f, 0.12050536f, -0.27417758f, 0.13813891f, -0.25556844f, 0.18381394f, 
    0.24757683f, 0.10052045f, 0.17287031f, 0.10184667f, 0.15377432f, -0.17820159f, -0.04677628f, -0.00381370f, 
    0.16055672f, 0.11885293f, 0.18857454f, -0.00930448f, 0.16166084f, -0.03524081f, 0.18659855f, -0.11989196f, 
    0.04241266f, 0.00877531f, -0.13027082f, -0.02428012f, 0.04081215f, -0.03143922f, -0.16383550f, 0.18344416f, 
    0.24155502f, 0.01095188f, -0.20216393f, -0.00835944f, 0.02116979f, 0.09625398f, 0.07122292f, 0.13225816f, 
    -0.02521584f, -0.20891775f, -0.03110890f, -0.08277562f, 0.08793618f, -0.02216065f, -0.26017055f, -0.27289826f, 
    -0.45208487f, 0.27837691f, -0.32991078f, 0.28222045f, -0.00192251f, 0.00432203f, 0.19820109f, -0.02981988f, 
    -0.12420896f, 0.01446849f, 0.47619170f, 0.13955948f, 0.15592086f, -0.05315070f, 0.07415845f, 0.09776837f, 
    -0.01214970f, 0.21558699f, 0.03846522f, 0.14848685f, -0.17091276f, 0.38283011f, 0.29584211f, 0.23049922f, 
    0.37287346f, -0.12455700f, 0.02482687f, 0.09630116f, -0.04618822f, -0.30095062f, 0.15239805f, -0.04884795f, 
    -0.06696925f, -0.18930532f, 0.07505383f, -0.21383776f, -0.15206258f, -0.01863514f, -0.02976412f, 0.01742861f, 
    -0.08644575f, 0.05499361f, 0.25087705f, -0.14525646f, 0.17079003f, 0.39598158f, 0.12969469f, 0.28881991f, 
    0.15417129f, -0.20522986f, 0.14516440f, -0.05086076f, -0.00073291f, 0.14421484f, -0.12628773f, 0.02801355f, 
    -0.06616220f, -0.11427215f, 0.20717674f, 0.06693646f, -0.03379492f, -0.16395505f, -0.26635268f, -0.21845719f, 
    -0.01707899f, -0.08099621f, -0.07080924f, 0.22974102f, -0.15068506f, 0.03220399f, -0.14376301f, 0.23390675f, 
    0.17173252f, 0.00134614f, 0.03658601f, 0.05493341f, -0.01907308f, 0.03421323f, -0.06760800f, 0.05557734f, 
    0.15775155f, -0.09221254f, -0.42130512f, -0.29347205f, -0.17781472f, -0.09164897f, -0.02682849f, 0.08805670f, 
    -0.04303118f, 0.08572277f, 0.11196427f, 0.12903976f, 0.18555425f, -0.17388044f, 0.10820749f, 0.12402148f, 
    -0.06239896f, 0.07327306f, 0.24265897f, -0.23162863f, -0.43556780f, -0.28707132f, -0.46478584f, 0.17461535f, 
    -0.24672417f, 0.05642654f, 0.07342125f, -0.07291849f, -0.00702281f, -0.16555609f, 0.24903531f, -0.03221350f, 
    0.00272207f, 0.29627800f, 0.46960253f, -0.09165748f, 0.58444679f, 0.04777953f, -0.06898635f, 0.07297865f, 
    -0.22225174f, 0.05522391f, 0.13942271f, -0.10887078f, -0.02194337f, 0.02462347f, -0.02032128f, 0.11455873f, 
    0.05554546f, 0.11090925f, 0.03786959f, 0.04623310f, 0.00032751f, -0.00074475f, -0.04055028f, -0.07462478f, 
    0.04683495f, -0.30251053f, -0.07772547f, -0.00218253f, -0.03832212f, 0.17812215f, 0.09312144f, -0.06123319f, 
    -0.27815369f, 0.27251750f, 0.19594720f, 0.17198184f, 0.13586424f, -0.08071390f, -0.06138044f, -0.03358643f, 
    0.08161557f, 0.16640078f, -0.55863500f, -0.14626111f, -0.12026416f, -0.01688235f, 0.02274190f, -0.11707383f, 
    -0.16347355f, -0.02525647f, -0.06281727f, -0.18386300f, -0.24333321f, 0.33663660f, 0.01077727f, -0.06985808f, 
    0.34011725f, -0.08522066f, 0.12186597f, 0.21158439f, 0.20952433f, -0.13234133f, 0.11935006f, -0.01113521f, 
    0.03269542f, -0.07865825f, -0.16530882f, 0.19974577f, 0.16175348f, -0.08169307f, -0.35209557f, 0.25465527f, 
    -0.00693579f, 0.11720285f, 0.01272753f, 0.22910163f, -0.04385685f, 0.01927009f, 0.10175858f, 0.24443768f, 
    0.19648339f, -0.11550276f, 0.16851200f, 0.15684669f, 0.19712798f, 0.10372854f, 0.05252646f, 0.46183783f, 
    0.10827532f, 0.24175291f, -0.13676593f, -0.02714220f, -0.07425024f, 0.14610825f, 0.20101953f, 0.18810897f, 
    0.22457485f, 0.39800766f, 0.38903952f, 0.01037172f, -0.00595365f, 0.20773555f, 0.04948360f, 0.08419083f, 
    0.01487731f, -0.05476555f, 0.04055881f, 0.22725235f, -0.18315217f, 0.09211209f, 0.01712078f, -0.17019686f, 
    0.24782328f, 0.32736272f, -0.03816260f, -0.13350442f, -0.13249406f, 0.10939660f, 0.05629224f, -0.02729264f, 
    -0.07690916f, -0.00705355f, 0.04429018f, -0.48250970f, -0.16555333f, -0.16079225f, 0.17195861f, -0.06281115f, 
    -0.00592117f, -0.04587140f, -0.02838584f, 0.00320614f, 0.14191285f, -0.14166364f, 0.03099478f, -0.04069719f, 
    0.04876531f, -0.02472644f, 0.00711148f, -0.13066478f, -0.15422875f, -0.05783869f, 0.04225421f, -0.00173827f, 
    0.03283280f, -0.06524134f, 0.16805871f, 0.08422092f, 0.06579444f, -0.07077113f, -0.01146391f, -0.18569572f, 
    -0.13951886f, 0.07225502f, -0.06451429f, 0.01440196f, -0.03786253f, -0.02288527f, 0.13827685f, 0.11835161f, 
    0.06827243f, 0.21262534f, 0.03144572f, 0.09491637f, 0.00044071f, -0.11754759f, 0.11270682f, -0.01487118f, 
    0.27205437f, -0.14406446f, -0.01859310f, 0.09831832f, 0.00491813f, 0.07972253f, 0.01895337f, -0.32967189f, 
    0.13261531f, -0.38468578f, -0.35217568f, 0.07109197f, -0.02143506f, -0.12217052f, 0.06643771f, 0.00287684f, 
    0.09895923f, 0.10243934f, -0.15447433f, 0.05810042f, 0.01818954f, -0.06399723f, 0.03821786f, -0.09211449f, 
    0.03911259f, 0.05131805f, 0.16156225f, -0.36669606f, -0.19597673f, -0.18507975f, 0.21539818f, -0.18184407f, 
    0.05174654f, 0.17168976f, 0.16958956f, 0.09038493f, 0.35922495f, 0.15563405f, 0.37582749f, -0.12521197f, 
    0.03919615f, 0.14682713f, -0.00938307f, 0.13627589f, 0.22386567f, 0.10308033f, -0.09649234f, 0.11529960f, 
    0.11443053f, 0.05724221f, -0.12062981f, -0.03221026f, -0.07216170f, -0.23401576f, 0.20478675f, -0.04040952f, 
    0.14742038f, 0.06256088f, 0.04071100f, -0.11199037f, -0.03078314f, 0.09348644f, 0.03762487f, 0.10299098f, 
    -0.02982252f, -0.04143122f, 0.08608014f, -0.04106259f, 0.16073631f, 0.05552677f, -0.16878521f, 0.16278313f, 
    -0.15308551f, 0.22177708f, 0.24085855f, 0.16426118f, 0.04584030f, 0.01306637f, -0.13146971f, -0.02320276f, 
    -0.03852385f, -0.08386166f, -0.05709767f, -0.12287748f, 0.17083532f, -0.10261804f, 0.05226214f, 0.07021370f, 
    0.05471588f, 0.16799386f, -0.33907747f, -0.45438251f, -0.02885340f, -0.07483540f, 0.04945797f, 0.03487361f, 
    0.10730032f, -0.11281524f, -0.10578372f, -0.17895316f, -0.11406339f, -0.09440065f, -0.13871014f, 0.12065097f, 
    -0.02278072f, 0.19266365f, 0.15785740f, -0.03552752f, 0.10045508f, 0.27466238f, 0.31068519f, -0.16837838f, 
    0.06063665f, -0.02266834f, -0.04152953f, -0.09783846f, 0.08393789f, 0.00242214f, -0.04562002f, -0.11118282f, 
    0.06037593f, 0.27133098f, 0.03610375f, -0.02689324f, -0.01315119f, -0.06487678f, 0.23442349f, 0.08195978f, 
    -0.07373006f, 0.01527082f, 0.09832005f, 0.02694507f, -0.03314199f, -0.15102187f, -0.15647207f, -0.39142880f, 
    -0.15431073f, -0.02476506f, 0.10741418f, -0.05551462f, -0.01168561f, 0.03422026f, -0.09488598f, 0.09149229f, 
    0.03698932f, -0.02834596f, -0.00614357f, -0.00576986f, 0.03953438f, -0.04828775f, -0.04767228f, -0.06756409f, 
    -0.05357869f, 0.02766956f, 0.00745931f, -0.04104640f, -0.00702127f, -0.01448937f, -0.06876913f, 0.01645859f, 
    0.03561116f, 0.02898404f, 0.04815563f, 0.02908639f, 0.00743778f, -0.05840085f, -0.00239286f, -0.03716459f, 
    -0.05242970f, 0.04456625f, 0.02565079f, -0.05545653f, -0.03947169f, 0.01638954f, -0.01773240f, 0.05939316f, 
    0.04492437f, -0.05104481f, -0.00881102f, -0.06293811f, 0.04496978f, 0.00136858f, -0.01676016f, -0.04958409f, 
    -0.01375131f, -0.02161900f, -0.00026332f, 0.02927918f, 0.03781659f, -0.05605492f, -0.00601378f, -0.06911942f, 
    0.04344466f, -0.00745657f, 0.00717412f, -0.04196288f, -0.05686255f, -0.00703572f, 0.00491880f, -0.03588127f, 
    -0.05818128f, -0.01253045f, 0.02040038f, 0.04955371f, -0.01492857f, 0.01057475f, 0.00195689f, 0.03978740f, 
    -0.06015337f, 0.01976346f, 0.03136252f, 0.01990320f, -0.03571284f, -0.05610731f, 0.03389905f, 0.00025314f, 
    0.01418866f, 0.03811609f, -0.01815899f, 0.00020288f, 0.03124386f, -0.00696422f, 0.04945002f, -0.02591942f, 
    -0.00406696f, -0.04749372f, 0.02758589f, 0.00006365f, -0.01514159f, 0.05373576f, 0.03666310f, 0.03374851f, 
    0.05207697f, -0.01253395f, -0.04670361f, -0.01769414f, 0.03709517f, -0.02988997f, 0.00399905f, -0.03531817f, 
    0.01247183f, 0.01120807f, 0.02626543f, -0.01430238f, -0.02628100f, -0.01872057f, 0.05005068f, 0.00751131f, 
    -0.01885120f, -0.01566005f, 0.04449095f, -0.04200537f, -0.05346680f, -0.03279119f, 0.00096127f, 0.04617431f, 
    -0.04203731f, 0.04295869f, -0.03723687f, 0.03880386f, -0.07175954f, -0.00254547f, -0.05103054f, -0.05621045f, 
    -0.05412700f, 0.02520436f, -0.03931824f, 0.03419404f, 0.02323394f, -0.00873553f, 0.04054892f, -0.04721760f, 
    -0.02316686f, -0.01761613f, -0.00952040f, -0.02264798f, -0.03174226f, -0.01698158f, -0.03511499f, 0.03734109f, 
    0.00026440f, 0.03556825f, 0.01730561f, 0.01458642f, 0.01870055f, -0.05374998f, 0.00349032f, -0.06416146f, 
    -0.03909367f, -0.00287139f, -0.05524486f, 0.01933237f, -0.05472356f, 0.04491514f, -0.05434222f, -0.01985284f, 
    0.04868618f, 0.04890304f, -0.04342996f, -0.05512151f, 0.01622018f, -0.03943028f, 0.01948943f, -0.02041996f, 
    -0.01836411f, -0.02061052f, -0.06005936f, -0.01738415f, 0.02301630f, -0.02903501f, -0.02585969f, -0.04593042f, 
    -0.00359690f, -0.06684552f, -0.01998204f, 0.00660827f, -0.02389436f, -0.03543068f, -0.06289761f, 0.04790962f, 
    0.04217702f, -0.05583062f, -0.02808384f, 0.01393545f, -0.06271983f, -0.04481352f, 0.03162361f, 0.04364722f, 
    -0.05979773f, 0.01488353f, 0.01599767f, 0.04574260f, -0.05587641f, -0.01830461f, -0.05999798f, 0.00264946f, 
    -0.01813752f, -0.04197159f, -0.00853815f, 0.03041179f, -0.03433373f, 0.03105601f, -0.05863168f, -0.00862701f, 
    0.01484883f, -0.00217622f, 0.00717987f, -0.03597897f, 0.04283486f, 0.02113075f, -0.02171135f, -0.00470927f, 
    -0.01562952f, 0.02561911f, 0.01002356f, 0.00283142f, 0.02268597f, 0.02096223f, 0.03955889f, -0.03330033f, 
    0.02051028f, -0.01669320f, -0.04232307f, 0.02015416f, -0.00934294f, 0.03408492f, 0.01539424f, 0.01820025f, 
    -0.02258831f, -0.01929425f, -0.02596403f, -0.04136546f, 0.00078127f, 0.00556109f, -0.00962015f, -0.03847663f, 
    -0.03561315f, -0.04533795f, 0.02231388f, 0.01910440f, -0.04519901f, 0.00416929f, 0.01177757f, -0.01070089f, 
    0.00636575f, 0.02079953f, 0.05654276f, -0.04547997f, 0.01136902f, -0.03861731f, 0.04221731f, -0.05945538f, 
    -0.03356731f, -0.05710605f, 0.01274029f, -0.04395066f, 0.02510148f, 0.01348949f, 0.03122486f, -0.01279721f, 
    0.00187175f, 0.00420109f, -0.05923598f, -0.02485460f, 0.01970378f, -0.01354665f, 0.04466339f, -0.03454348f, 
    0.00910511f, -0.00303648f, 0.00181043f, -0.03896864f, -0.04213927f, 0.04757714f, 0.02194711f, -0.01048029f, 
    -0.03074970f, -0.02991512f, -0.05157199f, -0.05107827f, -0.03004136f, 0.03708352f, -0.01636019f, -0.04365645f, 
    0.00246816f, 0.01285526f, 0.02399075f, 0.04768108f, 0.01886904f, -0.00974607f, -0.00748018f, -0.04286866f, 
    0.01557191f, 0.30862710f, 0.10824793f, -0.01853332f, 0.02835178f, -0.00806588f, -0.01734283f, -0.07687251f, 
    -0.06097748f, -0.03391187f, -0.15377654f, -0.26245564f, -0.08402606f, 0.03229131f, 0.03780862f, 0.11327984f, 
    0.01093099f, 0.17564712f, -0.02152139f, -0.05020930f, 0.10315242f, 0.09713540f, 0.00659335f, -0.02197465f, 
    -0.06479550f, 0.06317963f, 0.21909104f, -0.15760317f, -0.35707214f, 0.58986491f, -0.00150082f, 0.16749613f, 
    0.05935851f, -0.19511282f, 0.25048563f, 0.13061695f, 0.09885134f, 0.07126160f, -0.01314325f, -0.18459228f, 
    -0.01557274f, 0.02460428f, 0.18012102f, 0.09573696f, -0.06529433f, 0.03327354f, -0.08963961f, 0.10622533f, 
    0.08987647f, 0.14967088f, -0.09130263f, -0.17999373f, 0.08845849f, -0.12582757f, 0.12866718f, 0.49053395f, 
    -0.01456996f, 0.30391827f, -0.10893754f, 0.03380251f, -0.05550924f, -0.02557359f, -0.22062084f, -0.22126156f, 
    0.59522259f, -0.09537261f, -0.01671206f, -0.07359534f, -0.08370282f, -0.07399741f, 0.15742207f, -0.08718658f, 
    -0.18582496f, -0.26920769f, 0.22148171f, 0.01440111f, 0.09037482f, -0.10000265f, -0.00087761f, -0.22549286f, 
    0.25573543f, 0.06029058f, 0.15182443f, -0.06181210f, 0.00305043f, 0.12467960f, 0.11174689f, -0.04784822f, 
    -0.08074256f, 0.06341076f, 0.09381200f, -0.11689495f, -0.02615102f, 0.01635396f, -0.06417193f, 0.06639134f, 
    0.04635908f, 0.01695881f, -0.00415043f, 0.04033330f, 0.05287214f, 0.05633901f, 0.05992943f, -0.06981393f, 
    -0.06251866f, -0.10419215f, 0.10474838f, -0.00756877f, -0.00414779f, 0.05078183f, -0.16202828f, -0.02178358f, 
    -0.02553176f, 0.03012051f, -0.15163361f, -0.03913775f, -0.04890463f, -0.03420594f, -0.07979675f, 0.07502344f, 
    -0.02619440f, -0.06432538f, 0.03211388f, 0.17666973f, -0.20879148f, -0.05505240f, 0.10323567f, -0.02491529f, 
    0.09292913f, 0.09151644f, -0.13222823f, -0.15155236f, -0.05854367f, 0.04342883f, -0.01361719f, 0.08487803f, 
    -0.05218295f, -0.07226443f, -0.13745943f, -0.20846578f, -0.07015921f, -0.04792519f, -0.03658547f, 0.05073641f, 
    0.23044631f, 0.05080738f, 0.00346095f, -0.01641482f, 0.02837767f, -0.11719315f, -0.03668152f, 0.01473840f, 
    -0.15337673f, 0.12967142f, -0.10444606f, -0.10176296f, 0.12180664f, -0.03364401f, 0.07213119f, 0.05218815f, 
    0.15480398f, -0.15979828f, -0.06951969f, 0.12201315f, 0.03047393f, 0.04615758f, 0.07450233f, 0.11087010f, 
    -0.03183108f, -0.02230752f, -0.32147267f, 0.03995662f, -0.18615870f, 0.17935906f, 0.14452270f, -0.02001666f, 
    0.06222344f, 0.03099952f, 0.21399544f, -0.00155366f, -0.33863175f, -0.10381849f, -0.20016101f, 0.07323310f, 
    0.19890852f, 0.02970715f, -0.11067060f, -0.03600381f, -0.06279352f, 0.20925690f, -0.29277042f, 0.25692379f, 
    0.05098429f, -0.24192949f, 0.05896315f, -0.02458550f, -0.10148088f, 0.04933346f, -0.21341580f, -0.22713502f, 
    -0.07519305f, -0.04274220f, -0.08122009f, 0.11168624f, -0.06623501f, -0.02865683f, -0.13526396f, 0.13148747f, 
    0.20334005f, -0.00539630f, 0.02947160f, 0.06627023f, 0.03448267f, 0.01213910f, -0.05901793f, -0.01170889f, 
    -0.14582320f, -0.10526226f, 0.14621685f, -0.03854674f, 0.06294025f, -0.00582186f, 0.01179467f, 0.08887925f, 
    -0.18482631f, 0.03712776f, 0.09420071f, 0.09405117f, 0.14152990f, -0.25222394f, -0.13570689f, -0.18108413f, 
    0.14838216f, -0.02023917f, 0.06014851f, -0.06424139f, 0.46928161f, 0.30177605f, -0.01633916f, -0.06450867f, 
    -0.12021382f, -0.01517429f, -0.07513697f, 0.00397027f, 0.24118713f, 0.12383179f, -0.10356191f, 0.13446048f, 
    0.00621105f, -0.07738307f, 0.19662811f, -0.04992214f, -0.24088365f, 0.32806200f, -0.11236579f, 0.02848569f, 
    -0.04192409f, 0.05202137f, 0.08935207f, 0.10917467f, -0.06376453f, -0.20357904f, -0.16498215f, 0.62919128f, 
    0.00156097f, -0.09817931f, 0.15185033f, -0.11219055f, -0.21475604f, 0.22981940f, 0.14724097f, 0.00358607f, 
    -0.11324189f, 0.02841301f, 0.02060562f, 0.01913089f, -0.01187954f, -0.01032866f, 0.30505010f, 0.13286661f, 
    0.04807523f, 0.18774942f, 0.14121683f, 0.03232405f, -0.02854807f, -0.01597497f, -0.04459528f, -0.00130282f, 
    -0.32750788f, 0.01420401f, -0.00993997f, -0.00821892f, 0.14582655f, 0.22491288f, -0.12735337f, -0.10601099f, 
    -0.37154067f, -0.02559062f, 0.04503244f, -0.10163622f, -0.03648388f, -0.03987562f, -0.17763406f, -0.02837113f, 
    -0.02231895f, -0.20147273f, -0.47757652f, -0.31980735f, 0.13796912f, 0.09309770f, 0.02859454f, 0.09853260f, 
    -0.05535112f, -0.03833631f, -0.12008571f, -0.09617866f, 0.26237848f, -0.02031512f, 0.12404253f, 0.15221862f, 
    0.07479816f, 0.11817466f, 0.08917902f, 0.12075341f, 0.00712898f, 0.03475269f, 0.12992686f, 0.18947412f, 
    0.15670726f, -0.12083022f, 0.02260891f, 0.16802338f, -0.03303260f, -0.09628161f, 0.02926089f, -0.09776925f, 
    -0.07933955f, 0.15551017f, -0.06672597f, -0.14264214f, 0.06876884f, -0.20356284f, -0.03996386f, 0.38002875f, 
    0.02260598f, 0.27438357f, 0.05421533f, -0.06978904f, 0.01991528f, 0.36250716f, 0.20860693f, 0.39676952f, 
    0.36756769f, -0.42549506f, 0.09246307f, -0.14451061f, 0.15343951f, 0.25992128f, -0.03150479f, -0.00853928f, 
    -0.02710064f, -0.17425328f, 0.19955225f, 0.15082866f, 0.12905508f, 0.06446981f, 0.19994412f, 0.06847841f, 
    0.00805463f, -0.06304478f, 0.04612105f, -0.15005060f, 0.01290540f, 0.17390206f, 0.04862557f, 0.17207004f, 
    0.14416699f, 0.05736767f, 0.04500123f, 0.03090608f, 0.22013563f, 0.21132834f, 0.09236266f, -0.13884732f, 
    -0.00733506f, 0.11240727f, 0.08656310f, -0.39724869f, -0.14732604f, 0.15679081f, 0.13652062f, 0.02543729f, 
    0.00306870f, -0.04169833f, 0.04709009f, -0.10477502f, 0.06237902f, 0.24434066f, -0.12381001f, 0.16251691f, 
    0.11305151f, 0.12777646f, -0.13766424f, 0.00165606f, -0.28329986f, 0.03185669f, 0.04038577f, -0.02979597f, 
    -0.05634893f, 0.07150549f, 0.02517805f, 0.00585527f, -0.01218475f, 0.01406885f, -0.12456897f, -0.08652014f, 
    -0.05505243f, 0.05442400f, 0.08445212f, 0.09702510f, 0.04211137f, 0.08108772f, 0.05463765f, -0.09398935f, 
    0.12945969f, -0.00715923f, 0.12932283f, -0.15002063f, -0.04518545f, -0.23844507f, -0.32343853f, -0.26940852f, 
    0.17269953f, 0.13280019f, -0.03537102f, -0.02194067f, -0.05412643f, 0.12786111f, 0.24304539f, 0.20593576f, 
    0.13111427f, -0.11773565f, 0.32014596f, -0.28981140f, 0.01110177f, -0.13357536f, 0.10645375f, 0.17125815f, 
    0.15612499f, -0.06540509f, -0.20435373f, 0.13621484f, -0.21195003f, 0.07736907f, -0.06741774f, -0.04925575f, 
    -0.13684450f, 0.18275841f, 0.02494083f, -0.18155271f, 0.13888837f, -0.13522494f, -0.05643662f, -0.02967076f, 
    0.09804095f, 0.00065979f, -0.07320891f, 0.10544147f, 0.17547901f, 0.26029974f, -0.03747129f, -0.03934034f, 
    0.11465117f, -0.03121116f, 0.06926348f, 0.14284508f, -0.02770254f, 0.08571780f, -0.47253737f, -0.08927833f, 
    0.08931078f, 0.06758668f, 0.22494085f, -0.03263461f, -0.12682720f, -0.07473583f, 0.22098540f, -0.32616344f, 
    0.37882283f, -0.05199381f, 0.00042970f, 0.15484728f, -0.00565640f, 0.08218577f, 0.03818852f, -0.04721958f, 
    0.10259570f, 0.00767808f, 0.04589759f, 0.00528558f, 0.03731982f, 0.11453893f, 0.21904303f, 0.28421560f, 
    -0.39243275f, 0.05332263f, -0.27598724f, -0.08738700f, 0.14450650f, 0.26558831f, -0.02109967f, 0.21743867f, 
    -0.20651264f, -0.29418969f, -0.01897217f, 0.07419381f, -0.00233169f, 0.07242440f, 0.10896067f, 0.04272916f, 
    -0.14318503f, -0.03808977f, -0.17319106f, -0.14941378f, 0.03195408f, 0.11352018f, 0.08572210f, 0.28493828f, 
    -0.13731742f, 0.06600977f, -0.20407966f, -0.06289070f, 0.01620118f, 0.00460431f, -0.23430496f, 0.21995538f, 
    0.11494496f, -0.05305602f, 0.06276286f, 0.10547532f, 0.15833490f, 0.27141079f, 0.20082314f, 0.28363854f, 
    0.13984957f, 0.12832426f, 0.02917052f, 0.12801278f, -0.11552810f, -0.20788340f, -0.38332283f, 0.22975385f, 
    0.18831873f, 0.00984534f, 0.19074692f, -0.04590941f, 0.12486783f, 0.15987304f, 0.08728162f, -0.02250360f, 
    0.05656651f, 0.05336012f, 0.08941203f, 0.06990470f, 0.07030484f, 0.13135508f, -0.15439673f, -0.45832393f, 
    -0.10728206f, 0.05215476f, 0.10799804f, 0.03732462f, 0.09095122f, -0.00357266f, 0.13797334f, 0.06391095f, 
    0.17249446f, -0.15693586f, -0.20337272f, -0.04272051f, 0.03337680f, -0.15495911f, 0.15474425f, 0.06886958f, 
    0.05971292f, -0.03201878f, -0.26924661f, 0.12157470f, 0.24664544f, 0.12170179f, 0.23274668f, 0.01059937f, 
    0.18870062f, 0.23398352f, 0.40979606f, 0.34958845f, 0.09202822f, 0.01517878f, -0.12726299f, 0.01342075f, 
    -0.05120202f, 0.05147246f, 0.00945387f, -0.02006575f, 0.33157218f, -0.03100485f, 0.16388677f, 0.10055333f, 
    -0.09708165f, 0.26714194f, -0.11428046f, 0.16313039f, 0.02749679f, -0.24023554f, -0.10655030f, 0.11344070f, 
    -0.01816222f, 0.31385466f, -0.05480042f, 0.01876366f, -0.24320847f, -0.03442559f, 0.02250197f, -0.04580411f, 
    0.04718109f, 0.14773802f, 0.03285800f, -0.10148364f, 0.06905609f, 0.35296023f, -0.06706941f, -0.09905491f, 
    -0.33550110f, 0.02464816f, 0.00013130f, 0.01080129f, 0.12725180f, 0.16812152f, 0.01603314f, 0.24752490f, 
    0.15717602f, 0.23662555f, 0.24333736f, -0.03759941f, 0.06241517f, 0.25026909f, 0.09003701f, 0.20224290f, 
    -0.06802510f, -0.12390214f, 0.04054954f, 0.25720465f, 0.10281857f, 0.12542053f, -0.08891082f, 0.03235193f, 
    -0.09726308f, -0.02533962f, 0.04714212f, -0.15902102f, 0.11828540f, -0.00797088f, -0.00801210f, -0.21968359f, 
    -0.04017407f, -0.27307546f, -0.13708891f, -0.34636039f, -0.20991796f, 0.06085566f, 0.10117349f, 0.16106932f, 
    -0.18728469f, -0.18421882f, -0.06606717f, 0.25796339f, 0.27809599f, 0.08894581f, 0.05138888f, -0.16231254f, 
    -0.01713244f, -0.01422460f, -0.03396314f, 0.05565941f, 0.12770240f, 0.07215834f, 0.08664738f, 0.10524573f, 
    0.09701627f, 0.11078101f, 0.10312160f, 0.00437410f, 0.23466238f, 0.21879020f, 0.10281175f, 0.42912009f, 
    0.21160017f, 0.08469222f, 0.00112962f, 0.04775978f, 0.09971084f, 0.11269604f, -0.01035833f, 0.01090737f, 
    -0.03363798f, -0.04836954f, -0.06865904f, 0.16165689f, -0.01898664f, -0.10655608f, -0.02097835f, -0.25179899f, 
    -0.24624237f, -0.23635246f, 0.17266037f, 0.42298344f, 0.23975024f, 0.19693632f, 0.16927800f, 0.16845596f, 
    -0.12129642f, -0.34273061f, -0.13933934f, -0.11167367f, 0.03458336f, 0.08479802f, -0.00478350f, 0.01704455f, 
    -0.21215315f, 0.35720304f, 0.16587740f, 0.03917259f, -0.04374114f, 0.01977493f, -0.05868312f, -0.04689006f, 
    -0.13208827f, 0.19853939f, 0.31963080f, 0.14330582f, -0.20098758f, -0.12103289f, 0.37240985f, 0.09196939f, 
    0.03275339f, 0.20696370f, 0.34533718f, -0.09277773f, 0.22117172f, 0.17514661f, 0.27819777f, 0.13468230f, 
    0.07599121f, 0.04529918f, 0.10287860f, 0.09291814f, 0.04447184f, -0.19578160f, -0.14338577f, 0.14565723f, 
    0.16391122f, 0.02184054f, -0.04626493f, 0.21103027f, 0.14640671f, -0.57445788f, 0.09489214f, 0.31849930f, 
    0.15451473f, 0.10841645f, 0.29047382f, 0.03403396f, 0.26205343f, 0.06573952f, -0.07134581f, -0.11361487f, 
    0.10735030f, 0.18636288f, 0.05956860f, -0.03626119f, 0.02878239f, 0.12035527f, -0.08833349f, -0.16690217f, 
    -0.19554068f, -0.15641856f, -0.17001611f, -0.16343224f, -0.11256588f, -0.16480730f, -0.17477378f, -0.40369990f, 
    0.00262461f, 0.24589397f, 0.21696801f, 0.15721782f, 0.19723879f, -0.12916887f, -0.00414145f, 0.00593340f, 
    0.09163949f, -0.00723487f, -0.06134742f, -0.07605098f, 0.12631118f, 0.21998827f, 0.02292956f, 0.10161177f, 
    0.04243452f, -0.10008734f, -0.07656725f, 0.01163763f, 0.03749085f, 0.02364301f, -0.12424881f, -0.00495809f, 
    0.19964875f, 0.05733120f, 0.27399504f, 0.16036998f, -0.00608400f, 0.00856303f, -0.07119296f, 0.02406836f, 
    0.04125892f, -0.15610637f, 0.02715623f, -0.20607673f, 0.13033341f, 0.13978469f, -0.01516531f, 0.14765705f, 
    0.04977813f, -0.11202275f, 0.05264973f, 0.12371547f, 0.17442736f, -0.10675672f, 0.12810344f, 0.14396326f, 
    0.02717723f, -0.16580430f, 0.14392352f, 0.02292862f, 0.19490062f, -0.11623923f, -0.03063858f, 0.15594245f, 
    0.35861337f, 0.14523056f, 0.00447976f, 0.00785778f, 0.01936113f, -0.05487265f, 0.10846212f, 0.31497225f, 
    0.34081104f, -0.01246599f, -0.09025188f, -0.30046663f, -0.11984532f, -0.05511413f, -0.08149308f, 0.05232532f, 
    0.34781525f, -0.38879764f, -0.41656074f, 0.02173648f, 0.04811599f, -0.02541113f, 0.24841069f, -0.08526289f, 
    0.02742108f, -0.01484438f, -0.20862304f, 0.23743527f, 0.03731596f, 0.08563303f, -0.16565004f, -0.11416729f, 
    0.12468820f, 0.13362010f, 0.09045313f, 0.09112029f, 0.09602619f, -0.10846227f, 0.00858090f, 0.07185642f, 
    0.02769465f, 0.00783244f, -0.08678547f, -0.74424887f, 0.40525651f, -0.07839894f, 0.20065762f, -0.35503817f, 
    0.16127782f, 0.06626175f, 0.00575220f, -0.12314492f, -0.06692219f, -0.15298465f, -0.05731557f, -0.04651530f, 
    0.09317697f, 0.02057375f, -0.04117282f, -0.05815688f, -0.43447655f, -0.07189095f, -0.05090112f, -0.13077895f, 
    -0.08842576f, -0.04114513f, -0.09894418f, -0.16168800f, -0.16144542f, 0.17431942f, 0.03426795f, 0.25291917f, 
    -0.17400415f, 0.00718686f, -0.09420806f, 0.04815481f, -0.17496864f, -0.01290771f, -0.26452199f, -0.06476929f, 
    0.29812723f, -0.01774446f, 0.24866125f, 0.06340016f, -0.25011858f, 0.03204023f, -0.10675136f, 0.13770437f, 
    0.09177056f, 0.27029783f, 0.50326014f, 0.11115219f, 0.05251523f, 0.03678287f, -0.09808388f, -0.15418969f, 
    -0.09813868f, 0.17847936f, 0.05544842f, -0.02499127f, -0.05503288f, -0.05858542f, 0.17714666f, -0.20635335f, 
    -0.14692527f, -0.48326173f, 0.19625421f, -0.11426080f, 0.07157470f, 0.09210104f, -0.01271984f, -0.06506626f, 
    0.03636504f, -0.08097699f, 0.17156568f, 0.12407254f, 0.03612546f, -0.04115195f, 0.13335606f, -0.00743269f, 
    0.04494489f, 0.11491732f, 0.06461874f, 0.00522671f, 0.03585985f, 0.12375485f, 0.19494830f, -0.36411569f, 
    -0.12802602f, 0.09326702f, 0.11304720f, 0.02495980f, 0.12868246f, -0.00723554f, 0.21149527f, 0.24022140f, 
    -0.04985230f, 0.04570134f, -0.15076379f, -0.15000144f, 0.11634178f, -0.01208697f, 0.04244196f, -0.04353058f, 
    -0.07437050f, 0.03681430f, 0.13101617f, 0.18098438f, -0.07909450f, 0.03451548f, -0.05045870f, -0.00891869f, 
    0.08907410f, -0.01594776f, -0.05045507f, 0.12616698f, 0.07626972f, 0.07267644f, 0.00878881f, 0.26381171f, 
    0.04527435f, 0.03818707f, 0.05937423f, 0.12299007f, 0.02245516f, -0.09278059f, -0.17425120f, 0.04564355f, 
    -0.36167574f, -0.17839187f, -0.02485779f, 0.04203736f, -0.02573101f, -0.10923092f, 0.22450152f, -0.11570641f, 
    -0.03894339f, -0.08363134f, 0.01971882f, 0.08448618f, -0.33233270f, 0.08335391f, 0.07617901f, -0.03870750f, 
    -0.12486734f, 0.01506266f, 0.14267132f, -0.32174349f, 0.10303980f, -0.07053148f, -0.03625908f, 0.14653151f, 
    0.05427450f, 0.04287315f, 0.23621969f, -0.20632404f, 0.02420007f, -0.14116162f, 0.11824561f, 0.04525314f, 
    0.10340700f, -0.12694442f, -0.17532405f, -0.00700925f, 0.00107751f, -0.49791297f, 0.13875490f, -0.26032719f, 
    -0.08350027f, 0.10667088f, -0.02116235f, 0.12322895f, 0.07279618f, 0.11711536f, 0.02275090f, 0.09016065f, 
    0.16047385f, -0.08308663f, 0.12346222f, -0.02226522f, 0.04125329f, 0.03298381f, -0.01001863f, 0.07027937f, 
    0.06276115f, -0.03239719f, -0.03214012f, 0.02692052f, 0.06391655f, -0.16870628f, -0.30529356f, -0.48624474f, 
    0.08124047f, 0.24937537f, 0.01624771f, 0.06216179f, 0.03433724f, -0.26506397f, 0.03036802f, -0.02511355f, 
    -0.08169602f, 0.24226180f, 0.19398287f, -0.03231905f, 0.16322699f, 0.13908927f, 0.05033322f, 0.06657317f, 
    0.05876304f, 0.05591976f, -0.45080659f, 0.28602648f, -0.31019777f, 0.17813362f, -0.06349346f, 0.06605097f, 
    0.27436650f, 0.10687941f, 0.20492116f, 0.03790200f, -0.09496772f, -0.19542529f, -0.00109157f, 0.09177595f, 
    -0.04691129f, -0.10443676f, -0.32016063f, -0.30933145f, 0.10869551f, 0.47412747f, 0.02234556f, -0.19524196f, 
    -0.09311862f, 0.09616018f, -0.05666431f, -0.02055376f, 0.05275597f, 0.03658578f, 0.38537255f, 0.12223542f, 
    -0.03231232f, 0.01501035f, 0.04627730f, 0.00440585f, 0.01109997f, -0.10814274f, -0.12068675f, 0.04663416f, 
    0.31310806f, 0.00680481f, 0.08155656f, 0.04114085f, -0.07952180f, -0.00722597f, 0.07612747f, 0.11847100f, 
    0.00853767f, -0.23569861f, 0.03023702f, -0.10841431f, 0.02089680f, 0.02042251f, 0.02053576f, -0.10451106f, 
    0.02899782f, -0.00940727f, 0.02574478f, -0.03588322f, 0.04484434f, -0.02355846f, 0.03600284f, -0.01411577f, 
    -0.02773943f, 0.03347837f, -0.02619588f, -0.03105558f, 0.03382352f, 0.00442038f, 0.03288504f, -0.04677991f, 
    -0.00745991f, -0.00430598f, 0.01617200f, 0.00769372f, -0.02014674f, -0.00966993f, 0.03364836f, 0.04038758f, 
    -0.02910512f, -0.06199233f, -0.00563904f, -0.02314168f, 0.04873832f, 0.04432194f, -0.00945265f, -0.05358475f, 
    -0.04133687f, 0.00927959f, -0.04816105f, -0.01257183f, -0.00184100f, -0.02014757f, 0.04356945f, -0.04209207f, 
    -0.04522075f, -0.06120344f, -0.03096851f, -0.04893844f, -0.00747108f, -0.02963948f, 0.04149265f, -0.03181778f, 
    -0.06181806f, 0.05277790f, -0.04646610f, 0.04691025f, -0.03329104f, -0.05221650f, -0.03918604f, 0.01643746f, 
    -0.01373301f, 0.01637345f, 0.04346395f, -0.02642078f, 0.03527818f, -0.04738323f, -0.04433528f, -0.02756592f, 
    -0.01233667f, 0.02930329f, -0.04151935f, 0.03879558f, -0.01081679f, -0.05364950f, 0.04753965f, -0.06090481f, 
    0.01771736f, 0.00239097f, -0.02246604f, -0.00017065f, 0.04515836f, -0.01886188f, 0.02294761f, 0.04754446f, 
    -0.05204849f, 0.00933584f, -0.02643538f, -0.00283594f, -0.05356337f, -0.03559796f, -0.01447054f, 0.04010160f, 
    0.01499632f, 0.03983468f, -0.05977263f, -0.06610537f, 0.00172757f, -0.02664099f, -0.03255119f, 0.02756326f, 
    -0.03254240f, -0.06763684f, -0.00408650f, 0.02949104f, -0.05863063f, 0.03962263f, -0.04583945f, -0.05147494f, 
    -0.01986343f, -0.00462475f, -0.05464106f, -0.00254202f, 0.03732197f, -0.04687207f, 0.01737882f, -0.02981362f, 
    -0.05048375f, 0.02742900f, 0.04052011f, -0.01504721f, -0.06344714f, -0.05684672f, -0.05906322f, -0.01388891f, 
    -0.01135997f, -0.02492809f, -0.01833046f, -0.01353495f, 0.04478066f, -0.02672462f, -0.04685066f, 0.01083951f, 
    0.01315399f, -0.04423307f, -0.04646932f, 0.02582150f, 0.04186238f, 0.00574959f, 0.03074981f, 0.00791254f, 
    0.02172881f, -0.02417962f, -0.05582352f, 0.01535046f, 0.03169036f, -0.03372648f, -0.01717952f, 0.00893530f, 
    0.00290927f, -0.05260991f, -0.05306229f, 0.03902162f, -0.03033149f, 0.01695596f, -0.00083429f, -0.01013750f, 
    -0.03606628f, 0.03701045f, 0.01679200f, 0.02066545f, -0.06842808f, 0.00508943f, 0.05239048f, 0.01561313f, 
    -0.02966250f, -0.05574521f, -0.01570004f, 0.00450255f, 0.02129359f, -0.05785559f, -0.01500604f, -0.04545797f, 
    -0.02764723f, 0.03632499f, -0.03903983f, 0.02772812f, 0.00435673f, 0.02748720f, -0.02072330f, -0.05910231f, 
    -0.06409222f, -0.05390631f, -0.05593536f, 0.03870279f, -0.05139333f, 0.04575018f, -0.00121568f, 0.00773267f, 
    -0.00279081f, 0.04317269f, -0.03461179f, 0.01245613f, 0.02212415f, 0.04262328f, -0.06272759f, 0.03733425f, 
    -0.02977425f, 0.02260247f, -0.01666932f, -0.03058412f, 0.00149698f, 0.04488345f, -0.00563556f, -0.05393432f, 
    0.01587069f, 0.01903277f, 0.05106724f, 0.01531954f, -0.03360293f, -0.06753007f, -0.03591694f, -0.02860865f, 
    0.00272317f, -0.04641913f, 0.01927978f, -0.01792528f, 0.00667316f, 0.00543894f, 0.02174378f, -0.00302745f, 
    -0.06581748f, -0.03671848f, 0.00209138f, 0.00806783f, 0.02689218f, -0.01940795f, 0.00944345f, -0.01948546f, 
    0.03157507f, 0.03795438f, 0.02401592f, -0.06169707f, 0.01954834f, -0.01290682f, -0.03587590f, 0.01728059f, 
    -0.01921235f, -0.03786300f, -0.06875181f, -0.03460642f, -0.06307168f, -0.03317122f, 0.02108781f, 0.05442292f, 
    -0.05005819f, 0.05163108f, -0.01596434f, -0.03949708f, -0.04986170f, 0.01322479f, 0.01032033f, -0.01553678f, 
    -0.05542352f, -0.00729035f, 0.01258461f, -0.03207722f, 0.02073636f, -0.01443345f, 0.02018389f, 0.04565590f, 
    -0.03332434f, 0.01379732f, -0.01145418f, 0.02471028f, 0.04650377f, 0.00960725f, 0.02215681f, 0.00402136f, 
    -0.02445561f, -0.01000946f, 0.03206917f, -0.01094713f, -0.01549175f, -0.06533192f, -0.03741430f, -0.00582652f, 
    0.04674050f, -0.01503796f, -0.01992612f, 0.00617241f, 0.04169914f, 0.03648718f, -0.03406548f, 0.05161067f, 
    0.00662429f, 0.00073110f, -0.01354238f, -0.04880844f, 0.03448664f, -0.01048623f, -0.01312095f, -0.01301688f, 
    0.02828678f, -0.01101375f, -0.03750951f, -0.05048044f, -0.05876104f, 0.04498139f, 0.01928996f, -0.02108725f, 
    0.02755623f, -0.05261851f, -0.06511033f, -0.04032226f, -0.05177262f, -0.05986341f, -0.03624472f, -0.06396507f, 
    -0.02478318f, -0.01433182f, -0.05724451f, 0.03079577f, 0.02321750f, 0.00299813f, -0.00175161f, -0.01440343f, 
    0.03963150f, -0.02711617f, 0.03154019f, 0.00884511f, 0.01255864f, -0.05985164f, 0.04174414f, 0.02581058f, 
    -0.04816838f, 0.03749678f, 0.01891726f, -0.02544792f, 0.02928748f, 0.04066627f, 0.00324622f, -0.06027596f, 
    0.03422197f, 0.01211437f, -0.04260252f, -0.03545579f, 0.04565882f, 0.03227895f, -0.02379414f, -0.02268733f, 
    -0.00177898f, 0.04310536f, -0.05167101f, -0.04941210f, -0.01767978f, 0.03027984f, -0.04271242f, -0.00295011f, 
    -0.01091026f, -0.01247874f, 0.00989970f, -0.02542942f, 0.01441422f, -0.04899422f, -0.02656066f, -0.02845837f, 
    0.01811484f, 0.04069960f, 0.02890370f, -0.05699060f, -0.00302369f, -0.00659676f, -0.04672692f, 0.01109666f, 
    0.03735247f, -0.01561832f, 0.03028211f, 0.04288301f, -0.05968546f, -0.04725718f, -0.04231978f, -0.02619533f, 
    0.04300021f, 0.00258050f, 0.00310800f, -0.02785793f, -0.05473561f, 0.02970339f, 0.01264535f, 0.04417692f, 
    0.04905610f, -0.03741149f, 0.04452826f, -0.01137999f, 0.03906183f, -0.03055672f, -0.06894755f, 0.04395336f, 
    -0.02746510f, -0.06378228f, -0.04461499f, -0.02312844f, 0.01087645f, 0.01163707f, 0.02946323f, -0.04239058f, 
    0.04234067f, -0.02194225f, -0.00404446f, -0.03753424f, -0.05709495f, 0.00324636f, -0.00969651f, 0.01877804f, 
    -0.05085796f, -0.05747328f, -0.03718537f, -0.03115436f, -0.05809874f, 0.01690275f, 0.00847237f, 0.04625661f, 
    -0.06647328f, -0.00629720f, 0.01855448f, 0.04000616f, -0.01943067f, -0.03467840f, -0.03490832f, -0.05789927f, 
    -0.04429680f, -0.01928797f, -0.03259820f, -0.02166278f, -0.04222047f, -0.06198486f, -0.02210931f, -0.03508652f, 
    0.03942522f, -0.01090749f, 0.01409704f, 0.01628909f, 0.03877429f, -0.03971655f, 0.02581003f, -0.04549846f, 
    0.01740858f, -0.01475913f, 0.04108365f, -0.06655887f, 0.03491328f, 0.02394900f, 0.00175419f, 0.05742591f, 
    -0.06031991f, -0.02668932f, 0.00798405f, -0.05381102f, -0.00036992f, -0.03654797f, -0.00005332f, 0.02824582f, 
    -0.06293916f, -0.05775681f, 0.00211536f, 0.03331808f, 0.00239778f, -0.00920242f, 0.02644665f, 0.00102573f, 
    0.02109932f, -0.06122954f, -0.05965427f, 0.03036715f, -0.01191348f, -0.04164986f, -0.07017005f, -0.02391504f, 
    0.04195365f, -0.03003069f, -0.00470590f, 0.00391622f, 0.01650265f, 0.00452945f, -0.06959566f, 0.04375833f, 
    -0.04991313f, -0.02407218f, -0.03286114f, -0.00719313f, 0.02371216f, -0.03963548f, -0.01361000f, -0.05022775f, 
    0.04617130f, 0.00886440f, -0.05994189f, 0.04151929f, -0.00421598f, -0.05367126f, 0.02907860f, -0.07011479f, 
    0.04529984f, -0.02775714f, 0.02940416f, -0.02072818f, -0.02373195f, -0.01031489f, -0.04971530f, -0.06726708f, 
    -0.03140035f, 0.03394148f, -0.00028393f, 0.02077515f, -0.03565097f, -0.04144384f, -0.03548823f, 0.05610335f, 
    0.00283389f, -0.00624879f, 0.04283807f, 0.03474789f, -0.00419418f, -0.02768831f, 0.01732570f, -0.01024122f, 
    0.02721642f, 0.02245992f, -0.02761253f, 0.00216135f, 0.01178511f, 0.03130988f, -0.00033889f, 0.00320815f, 
    0.04273275f, -0.00580159f, -0.06180623f, -0.00331698f, -0.01077752f, -0.03793030f, 0.01480985f, 0.01747488f, 
    -0.04154072f, -0.02894988f, -0.01737196f, -0.03753918f, -0.06235251f, -0.04010671f, 0.02432154f, 0.04223696f, 
    -0.05593034f, 0.03922121f, 0.03847132f, -0.05420695f, -0.02300869f, -0.07088821f, -0.04171593f, 0.04344656f, 
    0.02987684f, 0.00856975f, 0.00533163f, -0.05027560f, 0.01852023f, 0.01449463f, 0.03053788f, -0.05106410f, 
    -0.00584329f, -0.01872363f, 0.00247964f, 0.04395974f, 0.01292406f, -0.05698874f, -0.05447422f, 0.05025525f, 
    -0.03844274f, 0.01790921f, 0.02335508f, 0.02970338f, 0.03279875f, -0.04620363f, -0.03419818f, 0.03961439f, 
    0.04348040f, -0.02089608f, 0.04371602f, -0.01648038f, -0.05386345f, 0.03738501f, -0.05391659f, -0.02386819f, 
    0.11165065f, -0.10054774f, -0.00158297f, 0.06214483f, -0.02025158f, 0.00777708f, 0.18846430f, -0.10865912f, 
    -0.00165390f, -0.05729302f, 0.21474665f, 0.18814479f, 0.22264241f, 0.08705544f, 0.06512456f, 0.11893255f, 
    0.01329939f, -0.03910993f, -0.02162982f, -0.01008803f, -0.23275474f, 0.09134814f, -0.04638950f, 0.12227806f, 
    0.08609241f, -0.02758656f, 0.11592976f, -0.14701606f, 0.22875361f, -0.07905987f, -0.26295361f, -0.24661316f, 
    0.05616465f, -0.14297828f, -0.06286182f, 0.09178193f, -0.37860158f, -0.18315695f, 0.32068923f, -0.07449316f, 
    0.13077910f, 0.11063163f, -0.20108545f, 0.14214234f, 0.22263885f, 0.06119402f, 0.02237018f, 0.16947213f, 
    -0.00436881f, 0.28943580f, -0.16316058f, 0.06418690f, 0.15841334f, 0.09565698f, -0.15461484f, 0.38726264f, 
    -0.02436149f, -0.01733210f, -0.02466541f, -0.02258333f, -0.29481268f, -0.22801781f, -0.14009629f, -0.22069402f, 
    -0.03538417f, 0.03775224f, 0.04228436f, -0.00007984f, -0.07224204f, 0.23582253f, 0.15777940f, -0.13740657f, 
    -0.04016631f, 0.05117776f, 0.24419641f, 0.00245147f, 0.05614978f, -0.08993456f, 0.05647760f, -0.06888404f, 
    0.06445508f, -0.02933782f, -0.00179811f, -0.14145018f, -0.11984333f, -0.18835479f, -0.09589735f, -0.25180009f, 
    -0.29440916f, 0.03502220f, -0.20594914f, -0.07433812f, 0.07137704f, 0.16087133f, 0.07458231f, 0.17505628f, 
    0.02317616f, -0.11456614f, 0.09089690f, -0.16544391f, -0.14694473f, -0.08181280f, 0.21067052f, 0.15576772f, 
    -0.00595112f, -0.14041674f, -0.16069067f, 0.09286696f, -0.10444383f, -0.03918694f, 0.36489382f, 0.18210329f, 
    -0.20059147f, 0.04440019f, 0.08465696f, -0.11007790f, 0.00542533f, 0.08762285f, 0.19159788f, 0.05657733f, 
    0.19102661f, 0.12358527f, 0.19862808f, 0.02112740f, 0.19883597f, -0.14816709f, -0.19769189f, -0.32914329f, 
    -0.23406997f, -0.05303000f, 0.07030316f, -0.04921411f, 0.16224335f, -0.05973672f, 0.05793307f, -0.13846564f, 
    0.12642021f, -0.20758672f, 0.21111436f, 0.09032782f, -0.16403468f, 0.20408042f, 0.24819668f, 0.05287222f, 
    0.43475288f, 0.27462789f, 0.12730128f, 0.06386797f, -0.07912618f, -0.27815813f, -0.11298560f, -0.07084642f, 
    -0.41946048f, -0.29977211f, 0.10976136f, 0.07839981f, -0.20931658f, 0.02081976f, 0.26988018f, -0.05034422f, 
    -0.11287492f, -0.01035421f, -0.46932152f, -0.15888999f, 0.00016209f, -0.18246600f, -0.09603334f, -0.05022342f, 
    0.16135652f, -0.15924756f, -0.02076330f, 0.26982442f, 0.28903073f, 0.01365677f, -0.07451126f, 0.02143458f, 
    0.26113048f, 0.06133526f, 0.11753754f, 0.08666826f, -0.01047224f, 0.05844723f, 0.22529823f, -0.08097094f, 
    -0.04026603f, 0.06994810f, 0.03941634f, -0.14938506f, -0.10958863f, 0.65844196f, 0.36706585f, -0.38260165f, 
    0.08690914f, -0.04908279f, -0.31718436f, 0.20025964f, 0.06044772f, 0.09752719f, -0.11053284f, 0.18928900f, 
    -0.15965976f, 0.08995425f, 0.07194089f, 0.05714961f, 0.22949962f, 0.20214909f, -0.28449163f, 0.10752589f, 
    0.05361478f, -0.22214557f, -0.06992082f, 0.05383289f, 0.12320372f, -0.12320696f, -0.42369446f, -0.08016508f, 
    0.21175623f, 0.19045140f, -0.16570325f, 0.05507173f, 0.01604492f, -0.04246810f, 0.15531538f, 0.08795744f, 
    -0.07901936f, -0.17824867f, -0.37796804f, -0.20207824f, -0.10585346f, -0.40342000f, -0.10366537f, -0.04753516f, 
    0.00787072f, 0.17652000f, 0.48009861f, 0.17483421f, -0.25558692f, -0.06165211f, 0.43248791f, -0.14237688f, 
    0.01923960f, 0.03574166f, 0.17230481f, -0.29160061f, -0.20450883f, -0.43051976f, 0.05824341f, 0.05485201f, 
    0.10243271f, 0.12647319f, 0.15041579f, -0.03613570f, -0.13950543f, 0.12567744f, 0.16005945f, 0.11526313f, 
    -0.22171280f, 0.01989976f, -0.08187566f, 0.08640086f, 0.06594005f, 0.42909190f, 0.39606246f, -0.55636472f, 
    0.08830180f, 0.15132391f, 0.17633894f, -0.15598939f, -0.15018153f, 0.17084184f, -0.01548900f, 0.00816429f, 
    0.07622916f, 0.10089899f, -0.06448495f, 0.17035553f, 0.14313345f, -0.10983419f, -0.05093423f, -0.26526907f, 
    -0.53386253f, -0.15774404f, 0.06011107f, 0.17092392f, 0.00094620f, -0.05885184f, -0.14992498f, 0.21947543f, 
    -0.00713992f, -0.09636974f, -0.02281262f, 0.04506307f, 0.04413528f, -0.08914585f, -0.11510120f, -0.07734127f, 
    0.06985618f, -0.02358532f, -0.08344687f, 0.01623328f, 0.13455351f, 0.00173460f, -0.17706953f, -0.03357283f, 
    -0.03943390f, 0.08706798f, 0.16227934f, -0.37933218f, -0.05374310f, -0.00988673f, 0.26579410f, 0.12288570f, 
    0.09728543f, -0.13453950f, 0.02197008f, 0.28179106f, 0.06993685f, -0.52452505f, 0.04799020f, -0.02319038f, 
    0.23088606f, 0.14998190f, 0.07296120f, -0.09583693f, -0.20815463f, 0.03538647f, -0.04863542f, -0.05181646f, 
    0.12832810f, -0.13602190f, 0.27211151f, 0.16944247f, -0.07430860f, -0.05260603f, 0.02030176f, 0.04975101f, 
    0.05648097f, 0.16091993f, 0.05727857f, -0.06322088f, 0.03168206f, 0.14728171f, -0.11222051f, -0.07066710f, 
    -0.03180830f, -0.22570065f, 0.13617004f, 0.04658862f, 0.02257668f, -0.01886987f, -0.10440743f, -0.56936902f, 
    -0.34387887f, 0.14535694f, -0.05043120f, 0.08138270f, 0.19444847f, 0.09310906f, -0.15477999f, 0.14349003f, 
    -0.43444711f, 0.04267971f, -0.11210889f, 0.04486343f, 0.06124336f, -0.19852324f, 0.04937943f, -0.18775900f, 
    -0.07461403f, 0.22626872f, -0.05384574f, 0.06606958f, -0.03885976f, 0.17024009f, -0.00195626f, 0.16557121f, 
    -0.00637831f, 0.17435144f, -0.33386299f, 0.24843629f, 0.11755466f, -0.06614812f, 0.08718266f, 0.04647962f, 
    0.04786327f, 0.08410538f, -0.04633065f, -0.00448349f, -0.05912004f, -0.04713516f, 0.07560629f, 0.12650882f, 
    -0.04037781f, -0.02121723f, -0.14709955f, 0.22320780f, 0.09812167f, -0.22566111f, 0.06196610f, 0.07641573f, 
    -0.04816642f, -0.05262673f, -0.18026866f, 0.00505609f, 0.18011619f, 0.00095148f, -0.07903878f, 0.07941709f, 
    0.09385243f, 0.03008193f, -0.00737086f, 0.01635185f, 0.07078700f, 0.09234345f, 0.08347674f, 0.03221486f, 
    -0.11036312f, -0.01320110f, 0.06295983f, -0.07627790f, -0.17478007f, 0.13153517f, -0.08417838f, -0.18582708f, 
    0.14567687f, 0.08562995f, 0.20836279f, 0.01486725f, 0.12595904f, 0.07593524f, 0.04237206f, 0.33233553f, 
    -0.01113478f, 0.01617475f, 0.08572144f, -0.23486768f, -0.10118510f, 0.15655987f, 0.02084535f, 0.12123334f, 
    0.01567981f, 0.04346209f, -0.40033919f, 0.19966920f, 0.20641473f, 0.24478504f, -0.18115516f, -0.04380437f, 
    0.10985976f, 0.01593759f, 0.06435178f, -0.02454346f, 0.08293354f, 0.20451936f, 0.07747483f, 0.15084802f, 
    0.03704978f, -0.01363967f, 0.03058918f, 0.13912910f, 0.13641562f, 0.10679846f, -0.05537295f, -0.01232459f, 
    0.00293811f, 0.09380865f, 0.24852027f, -0.01905488f, -0.75977528f, -0.27074009f, 0.13019744f, -0.01659898f, 
    0.22096570f, -0.07632771f, 0.19430289f, 0.13758765f, -0.04238283f, -0.24732459f, 0.34047905f, -0.08226333f, 
    0.14769220f, 0.07514882f, 0.08486157f, 0.07914051f, -0.10964514f, 0.27665141f, -0.33272457f, 0.53718615f, 
    0.05589196f, -0.06469762f, 0.09589370f, -0.02838547f, -0.05550876f, 0.09666583f, -0.16722687f, 0.24027631f, 
    0.02490184f, -0.11318757f, 0.00471373f, -0.12055000f, 0.10580576f, -0.03576917f, 0.16679186f, -0.12483939f, 
    0.32545060f, 0.04563665f, -0.54017270f, -0.03007251f, -0.00439633f, 0.01771182f, 0.18063726f, -0.08346406f, 
    -0.06805382f, 0.01286568f, 0.11964618f, -0.03769314f, -0.08585702f, -0.01130925f, -0.25568700f, -0.03367921f, 
    0.04676529f, 0.13739060f, -0.09294058f, -0.27855349f, -0.12816489f, 0.14041142f, 0.08703066f, -0.01582665f, 
    0.07887192f, -0.33356684f, -0.00679729f, -0.01814591f, 0.04480187f, -0.18246536f, 0.06171105f, 0.17841472f, 
    0.10752809f, 0.11652174f, 0.02519902f, -0.08564234f, -0.85534936f, -0.72337025f, -0.56758755f, -0.04944850f, 
    -0.00068762f, -0.11690845f, 0.19855222f, 0.02678904f, 0.12189392f, 0.31072667f, 0.44845122f, -0.18900777f, 
    -0.02460193f, -0.03137654f, 0.33818841f, -0.21245326f, 0.11180829f, -0.29742098f, 0.34936950f, -0.17418754f, 
    -0.22462882f, 0.18573815f, -0.05518059f, 0.02507868f, -0.07730004f, -0.20485413f, 0.11392573f, 0.26333427f, 
    -0.27656877f, -0.03383494f, 0.11702877f, 0.15193541f, -0.00673563f, -0.09466024f, -0.05773547f, 0.10962812f, 
    0.09000955f, -0.13105497f, 0.03300842f, 0.00093819f, 0.06494330f, -0.16163395f, -0.02605700f, -0.04053296f, 
    0.02741518f, -0.17901638f, 0.32065091f, 0.26964757f, -0.20116889f, -0.10279032f, -0.07467455f, -0.03520347f, 
    -0.27133745f, -0.19236729f, -0.34468606f, -0.14711517f, 0.03026350f, 0.03973927f, 0.01042570f, 0.04487920f, 
    0.08888759f, -0.03314728f, 0.04459694f, 0.08538056f, -0.25836816f, 0.50520450f, 0.04581245f, 0.06427953f, 
    -0.01828318f, -0.05092566f, 0.00541136f, 0.09057338f, 0.18061754f, 0.19157645f, 0.42410016f, 0.00667978f, 
    -0.15625332f, -0.00652823f, -0.06397931f, 0.12632085f, 0.04241282f, 0.13974382f, 0.13060836f, 0.35956189f, 
    0.11825974f, 0.03224504f, -0.10480405f, -0.27736965f, 0.00975571f, 0.02701152f, 0.32749495f, -0.00560604f, 
    0.08470848f, 0.09874099f, 0.08132806f, 0.10269341f, 0.10727748f, 0.09196997f, 0.02608030f, 0.18550974f, 
    0.34773591f, -0.04890221f, 0.12086039f, 0.12820353f, -0.11163116f, -0.04828323f, 0.13858247f, -0.16941296f, 
    0.17380431f, 0.19254653f, -0.00457890f, 0.00072969f, 0.10841696f, -0.05112451f, 0.12297386f, 0.05615865f, 
    0.26568896f, -0.24058160f, -0.19117644f, 0.13861135f, 0.03592752f, 0.08036143f, 0.20213355f, 0.05498576f, 
    0.00241752f, 0.31600523f, -0.04862026f, 0.04052095f, -0.09146500f, -0.20413595f, 0.27818528f, -0.10069540f, 
    0.05615610f, 0.16553359f, 0.03448135f, -0.02747497f, 0.19350646f, 0.22064754f, -0.03465262f, -0.06218010f, 
    -0.14435276f, -0.08622307f, 0.03685591f, -0.18768539f, -0.15284029f, -0.29366928f, 0.02576808f, -0.03852228f, 
    -0.14195494f, -0.05855945f, -0.08672779f, -0.28978160f, -0.12359710f, 0.04736784f, 0.00573608f, 0.00775805f, 
    0.21181490f, 0.13080169f, -0.05710424f, 0.09753653f, -0.02304896f, -0.01636198f, 0.18044880f, 0.31742540f, 
    0.26644379f, -0.14491457f, -0.35772049f, 0.00289442f, -0.33162582f, -0.32163200f, 0.10973266f, -0.30286917f, 
    0.03244354f, -0.29872495f, -0.11545005f, -0.05000267f, -0.29453135f, -0.08633756f, -0.20841707f, -0.19636945f, 
    0.30363825f, -0.08518817f, 0.25873828f, -0.06908778f, -0.03527159f, -0.23094158f, -0.18040659f, -0.06789768f, 
    0.35102201f, -0.20536922f, -0.09358504f, 0.39587572f, 0.14868441f, -0.04619798f, -0.09257179f, 0.15527289f, 
    -0.07461657f, 0.14603131f, 0.16004352f, 0.09514272f, 0.38625783f, 0.09713572f, -0.06955455f, -0.15219843f, 
    -0.24452364f, 0.07839706f, 0.12773615f, 0.00535121f, -0.11665202f, 0.27795526f, 0.10086432f, -0.02381630f, 
    0.14638844f, 0.11503034f, -0.09357944f, 0.21701770f, -0.03646281f, -0.28334135f, 0.08306179f, 0.19144613f, 
    0.01923794f, -0.04857261f, 0.13954766f, -0.03199137f, 0.19669637f, 0.21410093f, 0.16021061f, -0.20539764f, 
    0.14788920f, 0.15835953f, 0.02629695f, -0.31476051f, -0.09686316f, -0.03629655f, 0.03064741f, -0.07341452f, 
    -0.45947593f, -0.15135650f, 0.04816800f, 0.03785418f, 0.00123298f, 0.00887837f, 0.18438505f, 0.03189097f, 
    -0.10311951f, 0.02120061f, 0.10432561f, 0.02785305f, -0.02279738f, 0.10784642f, -0.01541176f, 0.21660830f, 
    -0.21451496f, -0.21285208f, -0.20223410f, 0.00414793f, -0.00840391f, 0.24710751f, 0.05097742f, 0.07839477f, 
    0.03233277f, 0.02810390f, 0.10804904f, 0.14149506f, -0.10029722f, -0.16880591f, -0.16015363f, -0.23334828f, 
    -0.43064907f, -0.17896089f, 0.12995751f, -0.06733778f, 0.04202439f, 0.02918365f, 0.17527206f, 0.02979750f, 
    -0.19268641f, -0.04092092f, -0.00960907f, 0.15519148f, 0.22686374f, 0.11406131f, 0.03353244f, 0.11631335f, 
    0.06098770f, -0.07046116f, 0.02427826f, -0.01861830f, -0.22026125f, -0.31222749f, 0.25050223f, 0.07372683f, 
    0.00422336f, 0.26815483f, 0.15546852f, 0.08525322f, 0.04715284f, 0.24357069f, -0.30898929f, -0.16213866f, 
    0.11746736f, 0.13626304f, 0.04635127f, -0.01089096f, 0.02175874f, 0.45471665f, 0.08555083f, -0.13181114f, 
    -0.27158526f, -0.05863509f, -0.06976908f, -0.09404885f, 0.12680227f, 0.07581992f, -0.11411671f, 0.02888709f, 
    0.12550439f, 0.17224789f, -0.05408495f, -0.02313145f, 0.02358151f, -0.04077775f, 0.12513734f, 0.11542439f, 
    -0.04857385f, -0.06166572f, 0.11748131f, -0.03224709f, -0.37270051f, -0.01366580f, 0.01704877f, -0.14995037f, 
    -0.05268555f, -0.27578485f, 0.16156271f, -0.33700350f, -0.11161785f, -0.11275645f, 0.12375210f, -0.00767640f, 
    0.05461461f, -0.00903821f, 0.03125311f, -0.23606943f, -0.15507735f, 0.05240696f, 0.09969608f, 0.00292054f, 
    0.17566900f, 0.05511681f, 0.00400178f, 0.69846940f, -0.52787596f, -0.19294801f, -0.01965215f, 0.00809667f, 
    -0.41521192f, -0.16740009f, 0.16118346f, -0.02627757f, -0.53374749f, -0.42809343f, -0.01693782f, -0.10200649f, 
    0.13920039f, -0.12033180f, 0.33848935f, 0.20385660f, -0.01743052f, -0.16451591f, -0.02843643f, 0.23957285f, 
    0.13102126f, 0.13566634f, -0.06554647f, 0.18924721f, 0.11551391f, 0.26330909f, 0.54366744f, -0.18582386f, 
    -0.47884864f, -0.16760865f, -0.09611379f, 0.08320613f, 0.09975686f, -0.20114647f, -0.34195015f, 0.01923615f, 
    -0.50209934f, -0.20970692f, 0.08436612f, -0.20584017f, -0.09177503f, -0.06087057f, -0.06813178f, -0.08031876f, 
    0.12495766f, -0.13998853f, 0.25933442f, 0.04910026f, -0.37136051f, -0.29965660f, -0.07183396f, -0.09529721f, 
    -0.05307631f, 0.21183068f, 0.13152850f, -0.11453664f, 0.03459452f, 0.05110133f, -0.12072899f, 0.09954727f, 
    0.00658718f, 0.06957993f, -0.26312622f, -0.16365440f, -0.07676408f, 0.21668553f, 0.13130541f, -0.14434083f, 
    0.06944278f, -0.03202258f, -0.03805467f, -0.26301298f, 0.42025006f, 0.03371058f, 0.04164861f, 0.02411916f, 
    -0.12851565f, -0.04831966f, -0.04682169f, 0.23641960f, -0.15684876f, 0.34285778f, 0.37006199f, -0.19798498f, 
    -0.14842847f, -0.09627713f, 0.13332684f, 0.15836245f, 0.11484355f, 0.28596592f, 0.25300834f, 0.11212194f, 
    0.14043440f, 0.06715344f, 0.13399248f, 0.03232292f, 0.09397417f, 0.09441641f, -0.07480287f, 0.24268039f, 
    0.20909357f, -0.19825768f, 0.04611772f, -0.22138141f, 0.04161651f, 0.11450057f, 0.20295900f, -0.21583356f, 
    -0.09379255f, -0.42324507f, 0.09842079f, 0.05140342f, -0.11473538f, -0.04130204f, -0.01913257f, 0.10267571f, 
    0.27765524f, 0.18452193f, -0.32426590f, -0.10111975f, -0.28511834f, -0.09270066f, 0.31568912f, -0.17031191f, 
    0.15346394f, -0.66362673f, -0.47550255f, 0.22530250f, -0.11832258f, -0.01023910f, -0.43173704f, 0.14543624f, 
    0.01663854f, 0.06456421f, 0.31211513f, -0.11652349f, -0.17347285f, 0.01039993f, -0.08690283f, 0.03002884f, 
    0.16275541f, 0.03189256f, -0.09489682f, -0.06270427f, 0.08965628f, 0.09186548f, -0.02837777f, 0.12553932f, 
    0.03223662f, -0.01491357f, -0.05711984f, 0.15065856f, 0.32441482f, -0.22217508f, 0.37515745f, 0.06332928f, 
    0.11851963f, -0.22016196f, 0.06631675f, -0.00260286f, 0.20883073f, -0.19873728f, -0.22845152f, 0.07508955f, 
    0.00593536f, 0.07746359f, -0.13213363f, 0.07016940f, 0.14913586f, 0.07091089f, 0.08836360f, -0.39017954f, 
    -0.13490428f, 0.03984332f, -0.04861848f, 0.12259964f, -0.13043541f, -0.17697002f, -0.08079658f, 0.07451106f, 
    0.12197036f, -0.13730933f, -0.14225423f, 0.03474366f, -0.00488623f, 0.15143675f, 0.19745550f, 0.04065169f, 
    0.31595781f, -0.24945168f, 0.02915121f, -0.08029199f, 0.00828191f, 0.33267790f, 0.32336774f, 0.07365754f, 
    0.15833409f, -0.19185013f, 0.19145592f, 0.23568879f, -0.07009501f, -0.07590763f, -0.19779204f, 0.04198266f, 
    0.00848407f, -0.04212382f, 0.57164317f, 0.17074698f, -0.07293950f, -0.19559805f, -0.05882036f, -0.15262981f, 
    -0.16640963f, -0.18260756f, -0.10238206f, 0.14675665f, -0.29184431f, -0.07377447f, -0.04528572f, 0.03615479f, 
    0.01133359f, 0.13395149f, 0.12000136f, -0.09104011f, 0.34619260f, 0.03910081f, 0.15479656f, -0.11320505f, 
    -0.05260523f, 0.07988615f, 0.18231988f, 0.02038961f, 0.03776136f, -0.00495076f, -0.49945977f, -0.58037579f, 
    0.02492561f, -0.03801303f, -0.04633519f, 0.12438632f, -0.07806119f, -0.16724530f, 0.24878061f, 0.12626381f, 
    0.35420263f, -0.01513764f, -0.18356410f, -0.02585034f, 0.21772644f, 0.28364524f, 0.08221933f, -0.03799016f, 
    0.30250525f, -0.03312168f, -0.02603132f, 0.22149144f, 0.08702007f, 0.03961726f, -0.04335288f, 0.04821136f, 
    -0.03235305f, 0.00670091f, 0.00601650f, -0.06112416f, -0.01467238f, -0.07066217f, 0.02560505f, -0.08999021f, 
    -0.05765483f, -0.01776440f, 0.04235827f, 0.03366074f, 0.04898730f, -0.02706148f, -0.05905910f, -0.03524582f, 
    -0.03539520f, 0.05346399f, 0.00862517f, -0.06804337f, -0.08466536f, -0.08457141f, -0.01980861f, -0.06334753f, 
    -0.01562169f, -0.03911297f, -0.09356020f, -0.01952026f, -0.00486550f, -0.04587463f, -0.05280973f, -0.06353232f, 
    -0.00047743f, -0.07321440f, -0.00921319f, -0.03443261f, 0.01593002f, -0.02194634f, -0.09221662f, -0.04890713f, 
    -0.07650527f, -0.02272015f, 0.01719536f, -0.05251755f, -0.09197529f, -0.09287731f, -0.08601814f, -0.07437078f, 
    0.00547527f, -0.08268162f, -0.08409119f, -0.07935848f, -0.07986016f, -0.05561097f, -0.07703912f, -0.09471750f, 
    -0.09161408f, -0.07821116f, -0.07534928f, 0.02252353f, 0.01861634f, -0.07788244f, -0.05764210f, -0.02944178f, 
    -0.03073977f, 0.01150672f, -0.06592056f, 0.03933831f, -0.03346471f, -0.06292002f, -0.05072393f, -0.03561613f, 
    -0.01758463f, -0.08993685f, -0.02773787f, -0.00697675f, 0.02494952f, -0.03252050f, -0.04894132f, -0.05264882f, 
    -0.02674265f, -0.03248388f, -0.00638814f, -0.03935168f, -0.02969720f, -0.06078508f, -0.03381380f, -0.01395369f, 
    -0.06274619f, -0.03776325f, -0.06008523f, -0.05404039f, -0.04358255f, -0.01966871f, 0.00086419f, -0.00347149f, 
    -0.03360871f, -0.03656444f, -0.06204577f, -0.05714590f, 0.00072701f, -0.03433036f, -0.04826079f, 0.00043406f, 
    0.01218232f, -0.01478141f, -0.02569882f, -0.04871370f, -0.05528491f, -0.00510779f, 0.02115254f, -0.03877042f, 
    -0.05566573f, -0.00684500f, 0.04831524f, 0.01873374f, -0.00417159f, -0.06373572f, -0.03807011f, 0.00972126f, 
    0.02269171f, -0.06634931f, 0.00423547f, -0.05349647f, 0.02832913f, 0.02863134f, 0.00479305f, -0.05334121f, 
    -0.04890856f, -0.07508785f, 0.01303951f, -0.01248911f, 0.00335486f, -0.03112745f, 0.01708821f, -0.00445386f, 
    -0.05628791f, -0.04271638f, -0.04346423f, 0.01100436f, -0.04095803f, 0.01519731f, -0.00586608f, 0.00517957f, 
    -0.02053809f, -0.04701683f, -0.07224124f, -0.09730302f, -0.07503560f, -0.06208210f, 0.02298959f, 0.00176898f, 
    -0.08582637f, -0.01063235f, -0.07054071f, -0.07066222f, 0.01998047f, 0.01027269f, -0.00987265f, -0.06588548f, 
    -0.04400297f, 0.01051360f, -0.09083880f, 0.00418623f, 0.01194734f, -0.01907287f, -0.05113533f, -0.09828655f, 
    -0.03185445f, -0.03137529f, -0.00677539f, -0.00667666f, -0.02554337f, -0.05870605f, -0.03326359f, -0.03905798f, 
    0.00086824f, -0.09001911f, 0.01527945f, -0.03722177f, -0.08918126f, -0.01379298f, -0.03359325f, 0.00515513f, 
    -0.01744077f, -0.00275032f, 0.02128182f, -0.06684022f, -0.03308099f, -0.02141912f, -0.05492327f, -0.00422682f, 
    -0.04232953f, -0.04409427f, -0.09546602f, -0.07813345f, -0.01859543f, -0.09032888f, 0.00812246f, -0.08840951f, 
    0.01305167f, -0.00611879f, -0.06569625f, -0.05888625f, -0.02443462f, 0.04346448f, -0.01834804f, -0.03277135f, 
    -0.01508243f, -0.04876795f, -0.03399485f, -0.05337876f, -0.00051023f, -0.04694392f, 0.00805600f, -0.04399568f, 
    -0.06743781f, -0.02866086f, -0.03157207f, 0.02847200f, 0.00347844f, -0.04255882f, 0.00290915f, 0.00474889f, 
    0.04395004f, -0.08292148f, -0.05768555f, -0.09099273f, -0.02342734f, -0.00760729f, 0.01717088f, -0.01671037f, 
    -0.00939554f, -0.04772611f, -0.06479860f, -0.06778624f, 0.04220641f, -0.06579272f, 0.00632902f, -0.08024139f, 
    -0.06653284f, -0.01299031f, -0.03965024f, -0.00878137f, -0.01982694f, -0.02464129f, -0.02944121f, -0.00519654f, 
    0.00780998f, -0.00882276f, -0.04529238f, -0.02569176f, 0.02361132f, 0.01380144f, -0.03074304f, -0.04007285f, 
    0.02957683f, -0.00038288f, -0.02433471f, -0.03103887f, -0.00256128f, -0.02678482f, 0.01797562f, -0.00180448f, 
    -0.02826947f, -0.07645957f, -0.08199584f, -0.06608900f, -0.09221134f, 0.01703669f, -0.02039040f, -0.02543185f, 
    -0.03123694f, 0.00131815f, 0.02706065f, -0.04937202f, 0.01417194f, -0.06197994f, 0.04364702f, -0.01276016f, 
    -0.05965200f, -0.09330984f, 0.01279577f, 0.01137304f, -0.05605932f, -0.00451071f, -0.08744431f, -0.05338052f, 
    0.21739815f, 0.08766352f, 0.24777025f, 0.03591061f, 0.04465544f, -0.05236143f, 0.13424088f, -0.05791961f, 
    0.14010391f, -0.09619092f, 0.00659547f, -0.23547232f, -0.18187699f, -0.13661627f, -0.29685163f, -0.08246783f, 
    -0.26346320f, -0.12589929f, 0.33513337f, 0.17683993f, 0.20121044f, 0.14194797f, 0.07097258f, 0.06587903f, 
    -0.05308385f, 0.13476337f, -0.07960356f, -0.82726407f, -0.16561453f, -0.41580620f, 0.11867686f, 0.04737559f, 
    0.01971762f, -0.10213249f, -0.12321572f, -0.01945904f, 0.17371453f, 0.02782679f, 0.06747457f, 0.00275089f, 
    0.07701573f, 0.08657260f, -0.00186842f, -0.01911361f, -0.03859061f, 0.38108656f, -0.02792413f, 0.00942382f, 
    0.06112001f, 0.14932948f, -0.05528845f, 0.01501300f, -0.10658592f, -0.16795602f, -0.26263314f, 0.07418329f, 
    -0.14156155f, 0.11058836f, 0.05336661f, 0.01575660f, 0.06105690f, 0.04407296f, -0.08545043f, -0.80741340f, 
    -0.35991627f, -0.14728355f, -0.12483953f, -0.09295432f, 0.21630663f, 0.02147417f, -0.02932888f, -0.28901052f, 
    0.16137888f, 0.61693865f, -0.13230957f, -0.06164384f, -0.01727539f, 0.07469800f, 0.02601903f, 0.06512637f, 
    -0.05834075f, -0.06058892f, 0.15835905f, -0.05110160f, 0.03279968f, 0.13788104f, 0.18421787f, 0.16652460f, 
    0.10294419f, 0.05789052f, 0.31145075f, -0.10188407f, -0.00873279f, 0.06134758f, 0.11429575f, -0.02649961f, 
    0.06731609f, 0.01537250f, -0.03882883f, 0.17838965f, 0.05768869f, 0.08678953f, 0.05798054f, 0.05897212f, 
    0.11436275f, 0.07748634f, 0.11674760f, 0.04269668f, -0.19374329f, -0.04347561f, -0.14300358f, -0.03752026f, 
    -0.02963576f, -0.10472709f, 0.03264415f, 0.10803013f, -0.12937272f, -0.09822646f, -0.00595619f, -0.81331104f, 
    -0.09074011f, -0.07766833f, -0.16709305f, -0.01336205f, 0.07439846f, 0.08224731f, 0.06594725f, 0.14822690f, 
    0.27510443f, 0.11559827f, -0.01396604f, -0.14297423f, 0.03524259f, 0.00012400f, -0.04852146f, 0.17852509f, 
    0.00405095f, 0.20128290f, 0.01514165f, -0.11458496f, -0.11671458f, -0.25070155f, -0.24577503f, -0.25312299f, 
    -0.05378485f, -0.00015835f, 0.11053018f, 0.05909403f, -0.20353943f, -0.01740668f, 0.08811098f, 0.01166522f, 
    -0.08621079f, 0.25082690f, -0.13342685f, -0.01555274f, 0.11127948f, 0.04725447f, -0.10700804f, -0.10518260f, 
    -0.00029971f, -0.28143203f, -0.23046786f, 0.04888787f, 0.07190523f, 0.01171654f, -0.09512682f, 0.13314883f, 
    0.14933449f, -0.03235444f, 0.01283286f, 0.06134679f, -0.03125789f, -0.14969100f, 0.00581306f, 0.06125045f, 
    -0.10570976f, 0.07296723f, -0.02936270f, -0.21585254f, 0.38273332f, 0.24425596f, -0.30834892f, -0.00241695f, 
    0.00043584f, -0.00157303f, -0.03633723f, -0.09267549f, -0.12429149f, 0.72476321f, -0.07947221f, -0.13351382f, 
    -0.03205760f, -0.37301821f, -0.05145381f, 0.05196379f, -0.16057536f, -0.32028341f, -0.33346468f, -0.45584807f, 
    0.17571981f, 0.21126774f, 0.04476788f, 0.02782509f, 0.06830943f, -0.03695192f, -0.02173996f, -0.08054874f, 
    0.05017304f, 0.17671230f, 0.15734929f, 0.03718746f, -0.02665901f, 0.17269723f, 0.02022239f, 0.00484962f, 
    -0.80911142f, 0.20520306f, -0.83026803f, -0.02652174f, -0.12075076f, -0.06759776f, -0.07942797f, 0.01732363f, 
    0.08742601f, 0.11943501f, 0.16218026f, 0.30532503f, 0.04972200f, 0.07418299f, 0.06538895f, 0.00672822f, 
    0.04791727f, -0.07919134f, 0.37203035f, 0.16135299f, 0.06500694f, -0.01131198f, -0.12068373f, -0.07205652f, 
    -0.07307500f, 0.19323105f, -0.08373617f, 0.12800695f, 0.16883565f, 0.23254767f, 0.03404701f, -0.05092529f, 
    0.07654981f, -0.09201600f, -0.17588413f, -0.02177470f, -0.19625220f, 0.14215107f, -0.13008712f, -0.00398173f, 
    -0.02537439f, 0.13231386f, -0.00442457f, 0.06510977f, -0.10976589f, 0.15946424f, -0.13037664f, 0.06340802f, 
    -0.16677272f, -0.21815236f, 0.11713575f, 0.33662221f, -0.10990750f, 0.07605255f, -0.46320671f, -0.46771440f, 
    -1.21940958f, -0.12057562f, -0.06378418f, -0.13085501f, -0.13079131f, 0.11161657f, 0.09717312f, 0.17214371f, 
    0.22640574f, 0.12357765f, 0.10109995f, -0.02396565f, 0.08719045f, 0.05691908f, -0.04243314f, 0.11669137f, 
    -0.41678002f, -0.38299033f, 0.05282142f, 0.07141721f, -0.20428245f, 0.09427553f, -0.01045893f, 0.08516482f, 
    0.12750313f, 0.06092868f, 0.11175171f, 0.01518977f, -0.18230754f, -0.12488876f, -0.31733650f, 0.13924477f, 
    0.16824679f, -0.05544950f, 0.12193742f, -0.27752393f, -0.09878522f, 0.26799709f, 0.10425659f, 0.06896274f, 
    0.06873073f, 0.12645407f, 0.13306715f, -0.27080807f, -0.59984589f, -0.90902108f, 0.26066491f, -0.04935717f, 
    -0.16799991f, 0.15924254f, -0.17790559f, 0.01861024f, -0.26360559f, -0.30664927f, -0.12653002f, -0.01849379f, 
    0.17194681f, 0.03181313f, 0.28545365f, 0.17283495f, 0.14274907f, 0.14255302f, -0.10049346f, 0.21593165f, 
    -0.03589739f, 0.23456468f, 0.02988473f, 0.03052396f, 0.33842793f, 0.17008740f, -0.45855042f, -0.04250759f, 
    -0.37802124f, -0.14606777f, -0.27813515f, 0.08286390f, 0.13890292f, -0.10310944f, 0.13212058f, -0.33151343f, 
    -0.69229293f, -0.52094722f, -0.10326843f, -0.40112862f, 0.10090480f, 0.08828445f, -0.11821569f, 0.09961989f, 
    -0.55502403f, -0.23698911f, -0.06464980f, 0.01250007f, -0.31855267f, -0.22612251f, -0.05066816f, 0.10478642f, 
    0.11499323f, 0.13543986f, -0.10868850f, -0.41574001f, -0.18328740f, -0.21932451f, 0.18453711f, -0.05834065f, 
    -0.01992699f, 0.02637511f, 0.09760608f, 0.15448047f, 0.55654138f, -0.06252458f, 0.09174118f, -0.19618517f, 
    -0.10800248f, 0.14620207f, 0.22171645f, -0.05594710f, -0.28274065f, -0.29689544f, 0.00285138f, 0.11545320f, 
    0.13457391f, -0.02393574f, 0.06896231f, 0.11043557f, -0.38656664f, -0.14235069f, 0.19728367f, -0.14847487f, 
    0.00748432f, 0.07094066f, 0.05325586f, 0.04275655f, 0.22210798f, 0.13226317f, -0.09659566f, -0.17988443f, 
    0.32646415f, 0.18965638f, 0.28643304f, 0.04045599f, 0.02931552f, 0.08546592f, -0.09038893f, -0.03559297f, 
    0.10835437f, 0.04778924f, -0.00653254f, 0.09960436f, 0.04939680f, -0.03538467f, -0.11516646f, 0.20381591f, 
    0.09051954f, 0.42628759f, -0.03599560f, -0.18285984f, -0.14617074f, 0.25661722f, 0.00725298f, 0.03742891f, 
    -0.17531060f, -0.18165550f, -0.06584138f, -0.06224630f, -0.09575055f, 0.14548941f, 0.09750998f, -0.16657948f, 
    0.14133051f, -0.53547281f, -0.63407046f, 0.08936089f, 0.06061487f, 0.29141000f, 0.05687575f, -0.05418329f, 
    0.05053421f, 0.01214079f, -0.29896471f, -0.04323403f, -0.19527294f, 0.07976165f, 0.09296381f, 0.15149803f, 
    0.12518123f, 0.19579910f, 0.20950419f, 0.16453764f, 0.13822819f, -0.13672774f, 0.16352513f, 0.07662418f, 
    -0.03916238f, -0.00144528f, 0.05325392f, 0.08302250f, 0.00657932f, -0.12775829f, -0.14243655f, 0.11439442f, 
    0.05512759f, -0.04879421f, -0.03121110f, -0.20616648f, 0.18695483f, 0.65070784f, -0.28675449f, 0.05076519f, 
    -0.13864927f, -0.25408792f, -0.05760900f, -0.01127592f, -0.04833407f, -0.08484408f, -0.00313939f, 0.28186509f, 
    0.49474010f, -0.02857422f, 0.05184930f, 0.23090354f, -0.07777230f, -0.00903155f, 0.04917540f, -0.12589227f, 
    0.07629481f, -0.08770367f, 0.03877899f, -0.02776591f, 0.10037366f, 0.04667172f, 0.03420385f, 0.17505231f, 
    0.30803746f, 0.34078619f, -0.63308287f, 0.16744627f, -0.10423003f, 0.10409053f, 0.09671087f, 0.02928652f, 
    -0.07075982f, -0.23041794f, -0.00610450f, 0.17205247f, -0.11351204f, -0.07315535f, 0.10187545f, 0.06332052f, 
    -0.01902227f, 0.02908719f, -0.46285650f, -0.70608974f, -0.45661369f, 0.11504617f, -0.11907573f, -0.12446841f, 
    -0.03138254f, 0.02040069f, 0.08314740f, 0.14189994f, -0.07629602f, -0.03042850f, 0.08763044f, 0.13502139f, 
    0.15397231f, 0.00761822f, -0.22617950f, -0.00694732f, -0.49979952f, -0.00285622f, -0.88271952f, 0.05162904f, 
    0.03203340f, -0.09358664f, 0.17105730f, 0.08662372f, 0.08824190f, 0.50519264f, 0.14445162f, -0.21638446f, 
    -0.04351285f, -0.14346576f, -0.22111471f, -0.03623634f, -0.20261525f, -0.02250991f, 0.10964587f, 0.06168696f, 
    -0.11096910f, 0.04457736f, -0.00066555f, 0.03319221f, 0.02006684f, 0.16805211f, 0.17097574f, 0.12210698f, 
    -0.15690948f, -0.32710710f, 0.05559495f, 0.08387545f, 0.11073282f, 0.10693143f, 0.13229412f, 0.06719621f, 
    -0.02925508f, -0.00313113f, -0.03482903f, -0.05612474f, 0.01535512f, -0.00925227f, -0.00783159f, 0.04701504f, 
    0.03581741f, -0.05347126f, 0.00230073f, 0.04646017f, -0.00715218f, -0.03904397f, -0.03073372f, -0.03637135f, 
    -0.02793073f, -0.02109344f, 0.00609395f, -0.02499486f, 0.02989511f, 0.03070022f, 0.00598859f, -0.04624744f, 
    0.00251403f, -0.04608849f, -0.01550938f, -0.01760464f, 0.00765022f, -0.00118285f, 0.01745014f, -0.00525035f, 
    0.00566420f, -0.01002224f, -0.00046571f, -0.00915330f, -0.00640457f, -0.01811266f, 0.04274698f, -0.02150175f, 
    0.03743847f, 0.03809441f, 0.03347080f, 0.01205519f, 0.04474838f, -0.04907627f, 0.02124282f, -0.02533204f, 
    0.04858046f, 0.04387205f, 0.04349898f, -0.06486960f, 0.00006730f, -0.03010596f, 0.02256051f, -0.00532145f, 
    -0.05488242f, -0.06040507f, -0.05847534f, -0.02655230f, 0.02042311f, -0.01499159f, -0.04602615f, 0.01259045f, 
    -0.00101943f, -0.03760190f, 0.02734512f, 0.01804008f, 0.01149023f, 0.04852464f, -0.00267089f, -0.00564004f, 
    0.05369375f, 0.02365119f, -0.03092641f, -0.01267044f, -0.03110816f, -0.04237474f, 0.03911559f, -0.00021235f, 
    -0.01950715f, -0.01511265f, -0.01856867f, -0.01385506f, 0.03223068f, -0.01754354f, 0.02609572f, -0.02579767f, 
    -0.03537989f, -0.04513324f, -0.05670868f, 0.00422261f, -0.05696983f, 0.01509108f, -0.01626156f, 0.00789726f, 
    -0.00786782f, -0.05902296f, 0.04922498f, -0.01885902f, -0.02768333f, 0.00187198f, 0.03963048f, -0.01330592f, 
    0.00115790f, 0.00703372f, 0.04079605f, 0.03002441f, -0.06155395f, 0.04060292f, -0.04506744f, 0.01847165f, 
    -0.04972234f, -0.05853601f, -0.04750066f, -0.05349632f, -0.00544124f, 0.03991096f, -0.03540273f, -0.04698792f, 
    -0.03519411f, -0.00188760f, 0.00614485f, -0.00072125f, 0.04356040f, -0.06177930f, 0.04075400f, -0.05741772f, 
    0.00300186f, 0.00372854f, -0.00167891f, -0.03657831f, 0.02844246f, -0.04195033f, 0.04143631f, -0.01632293f, 
    -0.03528159f, 0.00032237f, 0.05102812f, -0.05132359f, -0.02036789f, 0.03475325f, -0.03342033f, -0.01057494f, 
    0.01760306f, 0.05469966f, 0.03908823f, 0.02816248f, 0.00523169f, -0.01504651f, 0.00849731f, 0.01189557f, 
    -0.02313115f, -0.02318667f, -0.05914329f, -0.03120309f, -0.02988574f, -0.02996646f, -0.06248565f, -0.01047447f, 
    -0.03143745f, -0.02297895f, -0.04022639f, -0.04859819f, -0.04517568f, 0.03319324f, 0.00082245f, 0.00152728f, 
    -0.01749669f, 0.00091016f, -0.00652302f, -0.01870412f, -0.02824085f, 0.03551808f, 0.04715582f, -0.05928989f, 
    -0.01864247f, -0.04758707f, -0.06102875f, -0.00984607f, -0.03538327f, 0.04438164f, 0.03110299f, 0.00012717f, 
    0.04051336f, 0.01837661f, -0.04713587f, 0.04780501f, -0.00295082f, -0.03993671f, 0.03303820f, -0.03934385f, 
    0.05105734f, -0.01440734f, -0.02684131f, -0.01359038f, 0.00996637f, -0.00808410f, -0.04214457f, -0.05778804f, 
    0.02712733f, -0.05481665f, -0.03693725f, -0.03950982f, -0.05906498f, -0.00092314f, 0.01746665f, -0.03641197f, 
    -0.00425748f, -0.02981737f, -0.01781776f, -0.01046022f, -0.02280903f, 0.02477901f, -0.02731949f, -0.03597803f, 
    0.02454240f, -0.05018287f, 0.03652140f, 0.00532426f, -0.01313040f, -0.02118186f, 0.01199752f, -0.01003697f, 
    -0.00171660f, 0.00587188f, 0.04393980f, 0.00865145f, 0.02130340f, 0.02675326f, -0.03075365f, -0.05245415f, 
    -0.00397621f, -0.01086091f, 0.02844393f, -0.01790472f, -0.03028714f, 0.04586196f, 0.04602766f, 0.04458333f, 
    -0.00095074f, 0.05628170f, 0.01531128f, -0.03694809f, 0.03373871f, -0.01782432f, 0.03796480f, -0.00628576f, 
    -0.02029096f, -0.03855659f, -0.06169894f, 0.03934520f, -0.04468412f, 0.00323296f, -0.05104995f, -0.03657648f, 
    0.03453393f, 0.00869020f, 0.02378624f, -0.05241901f, -0.05986607f, 0.05785247f, -0.05004841f, 0.00960054f, 
    0.02456203f, -0.04628593f, 0.03199965f, -0.02110975f, 0.04530620f, 0.02453654f, 0.04607824f, 0.00654455f, 
    0.04670605f, 0.01492473f, -0.01206397f, 0.01825168f, 0.02670655f, 0.04774314f, -0.04694692f, -0.05797374f, 
    0.03799846f, -0.02766303f, -0.06377880f, -0.01765230f, -0.01188698f, 0.02042034f, -0.04520283f, 0.05117783f, 
    0.07755461f, -0.05423407f, -0.07383033f, -0.25962028f, -0.18941598f, 0.02350385f, 0.16796453f, 0.04169732f, 
    0.22024739f, -0.18844292f, -0.13327816f, 0.07307358f, 0.06287764f, -0.09490375f, -0.01380652f, 0.01424902f, 
    0.05465646f, 0.10709575f, 0.12833968f, 0.25674489f, 0.12528031f, -0.09331025f, 0.01361752f, -0.05345361f, 
    0.08786524f, 0.05925442f, -0.07254863f, 0.75470245f, -0.07542816f, 0.19284755f, 0.02619760f, -0.31182909f, 
    0.21376646f, -0.28961080f, 0.24114862f, -0.18923067f, 0.01651682f, -0.09904749f, -0.00777451f, 0.08674191f, 
    0.16188321f, -0.15925467f, 0.13658306f, 0.21424280f, -0.12782522f, -0.05420713f, -0.04430865f, -0.00986053f, 
    0.15921116f, 0.21883217f, 0.09217841f, -0.03887869f, -0.11477739f, 0.27080962f, -0.23880377f, -0.14494334f, 
    -0.35693958f, -0.11415556f, -0.06249495f, -0.01435960f, 0.21511900f, 0.05046524f, 0.17000997f, 0.15783712f, 
    -0.20278306f, -0.00789503f, 0.10268575f, 0.05006614f, 0.04408967f, -0.05201290f, -0.08433634f, 0.02347665f, 
    0.08984370f, -0.04703733f, 0.19334064f, -0.08848089f, -0.12733053f, -0.10013321f, 0.00105194f, -0.09451608f, 
    -0.14497146f, -0.12370311f, 0.29555118f, 0.01394397f, -0.05597426f, -0.01084134f, -0.18276887f, 0.11920787f, 
    -0.08917610f, 0.11970901f, -0.23206328f, -0.03521204f, 0.21063727f, 0.14600873f, -0.04790579f, -0.02205762f, 
    -0.06010275f, -0.06035226f, -0.03985208f, 0.01786161f, 0.25310725f, 0.05297936f, -0.36887780f, 0.07371166f, 
    0.08206706f, -0.03097370f, 0.00709956f, 0.08418737f, 0.05900364f, 0.17427693f, 0.37281883f, -0.03066966f, 
    0.06190149f, 0.04297868f, 0.08810008f, -0.07872036f, 0.26883832f, 0.17276113f, 0.19890618f, 0.33624443f, 
    -0.15308556f, -0.01586390f, 0.01865473f, -0.05300574f, 0.09899256f, -0.05620857f, 0.07115138f, 0.16946904f, 
    -0.01841731f, -0.05482865f, 0.06085402f, 0.10772147f, 0.16207245f, 0.12857203f, 0.01855420f, -0.04837229f, 
    0.06844483f, -0.06675366f, -0.03559878f, 0.10089446f, 0.18728374f, -0.09807641f, -0.04633151f, 0.26748350f, 
    -0.17151445f, -0.07363430f, -0.18134943f, -0.03971996f, -0.03476682f, 0.01194710f, 0.39717382f, -0.00937587f, 
    0.11895380f, 0.27478614f, -0.02249666f, 0.29116714f, -0.07108894f, -0.07430526f, -0.02812927f, -0.23527789f, 
    0.08678585f, 0.00657202f, 0.27884945f, -0.01338230f, -0.36398733f, -0.15429863f, 0.22802654f, 0.23511699f, 
    0.17154539f, 0.07112368f, 0.06397478f, 0.23921458f, 0.25004798f, 0.34125015f, 0.05909211f, -0.00571286f, 
    0.08167725f, -0.18498214f, 0.08710107f, 0.06780415f, 0.11624051f, -0.04367297f, 0.23218040f, -0.05447163f, 
    -0.00681183f, -0.07818817f, 0.13196760f, -0.07033782f, 0.12906499f, -0.28242534f, 0.28891903f, 0.29708743f, 
    0.03468180f, -0.08818477f, 0.43794045f, -0.18025793f, 0.14218998f, 0.24233200f, -0.10674123f, 0.00522161f, 
    0.50634241f, -0.07407907f, -0.00741338f, -0.02399065f, -0.12960501f, 0.03596822f, 0.02927557f, -0.16177985f, 
    0.02895067f, -0.04139545f, -0.21758395f, -0.22209282f, -0.09899189f, 0.17208470f, 0.18526962f, 0.16287686f, 
    0.42836311f, 0.03898020f, 0.47334644f, 0.00509117f, 0.16223718f, 0.03526034f, 0.00402183f, -0.06373157f, 
    0.07489797f, 0.03845971f, 0.00237035f, -0.06567241f, -0.06660021f, -0.01502504f, 0.02851907f, 0.35217598f, 
    0.05033394f, -0.08778889f, 0.13603668f, -0.04974131f, 0.02167932f, -0.14327124f, -0.31710479f, 0.02193364f, 
    -0.07105313f, -0.18454492f, -0.01855421f, 0.18212113f, 0.05595490f, -0.08540501f, -0.08093312f, 0.13956469f, 
    -0.08734771f, 0.10441607f, 0.10576565f, -0.15859619f, 0.21094149f, 0.13979359f, -0.10111061f, 0.05745868f, 
    0.03198739f, 0.02103436f, 0.11721555f, -0.07679605f, 0.04004442f, -0.06798771f, -0.04183200f, 0.28921175f, 
    0.00031620f, -0.22618000f, 0.07245024f, -0.02543133f, -0.03934478f, -0.13825360f, -0.08534470f, 0.03992534f, 
    0.43340519f, -0.02310427f, 0.01430136f, -0.08332663f, 0.19631162f, 0.00325280f, 0.03914965f, 0.06839881f, 
    0.29091814f, 0.11610790f, -0.20431401f, -0.00770153f, 0.07171286f, -0.13782983f, -0.11734966f, -0.02953047f, 
    -0.01671397f, 0.26661381f, 0.35542205f, -0.06907939f, -0.00376060f, -0.11131390f, 0.09446074f, 0.10561758f, 
    -0.06788798f, -0.38993552f, 0.15968210f, -0.05269082f, -0.14371410f, 0.07372583f, -0.16074567f, -0.02027653f, 
    -0.40251985f, -0.16547288f, 0.04644915f, -0.20108914f, -0.07045660f, 0.18073018f, -0.00378290f, 0.10026620f, 
    -0.07316759f, -0.00734962f, -0.01940105f, 0.02521051f, -0.00079789f, 0.43756101f, 0.00647306f, 0.09447925f, 
    0.25140315f, 0.04650765f, 0.03862149f, 0.14157772f, -0.07633916f, 0.16692761f, -0.13333756f, 0.30114785f, 
    0.14179401f, 0.09217389f, 0.21751513f, 0.14273617f, 0.11119282f, 0.05933577f, 0.20247439f, 0.17026177f, 
    0.19973533f, 0.29547414f, 0.00666723f, -0.04916606f, 0.08144961f, 0.24717429f, -0.00379576f, 0.19796850f, 
    0.14702563f, -0.14323927f, 0.15081753f, 0.12161394f, -0.04706717f, 0.13321328f, 0.08726639f, -0.38531414f, 
    0.15135404f, 0.31424633f, 0.01702460f, -0.08699210f, 0.05929005f, -0.03586330f, 0.05929790f, 0.09455121f, 
    -0.19991980f, -0.13317579f, 0.04605519f, -0.07748224f, -0.19275860f, -0.02775016f, 0.18521468f, 0.07223649f, 
    0.00759315f, -0.00185718f, -0.00725237f, -0.19141564f, -0.06661446f, 0.12125508f, 0.02338893f, -0.04283186f, 
    0.16898887f, 0.22491695f, -0.00578012f, 0.11229831f, 0.13871248f, 0.08301356f, 0.05136353f, 0.08786046f, 
    -0.06893686f, 0.07118003f, -0.13881679f, -0.09396794f, -0.15550159f, -0.08547214f, 0.00414063f, -0.05706774f, 
    -0.07389028f, -0.10582237f, -0.03124205f, -0.06659399f, -0.13455088f, -0.11921059f, 0.26808193f, -0.08214226f, 
    -0.05313499f, -0.06369296f, -0.10470770f, -0.12732419f, -0.23869784f, 0.05614953f, 0.09429502f, 0.10623223f, 
    0.09654386f, -0.04760827f, 0.19775052f, -0.02336412f, 0.02785486f, 0.02448234f, -0.19031273f, -0.37028539f, 
    -0.26558375f, 0.06748682f, 0.07210910f, -0.03682903f, 0.04103694f, -0.03095390f, 0.03710714f, -0.38614491f, 
    -0.08425541f, -0.15908937f, 0.09027806f, 0.04244626f, -0.04853809f, -0.34923780f, -0.19360293f, -0.18911389f, 
    -0.00759033f, -0.15811560f, -0.08631180f, -0.09241281f, 0.04553116f, 0.05998962f, -0.05635305f, 0.28344446f, 
    0.09376298f, -0.14817205f, -0.00714722f, 0.00521277f, 0.11871645f, -0.01915603f, 0.05057259f, -0.06745590f, 
    0.23547584f, 0.35815540f, -0.26152587f, -0.07937912f, -0.01028285f, -0.12466503f, 0.16282399f, 0.13300326f, 
    0.08431353f, 0.01249590f, 0.17487924f, 0.09946728f, 0.11424066f, 0.23762578f, 0.01317853f, 0.09377487f, 
    0.30027586f, 0.00710422f, 0.16847144f, 0.26357302f, 0.08573002f, 0.15207450f, 0.17814510f, -0.09012355f, 
    0.03142225f, -0.13555095f, 0.09884508f, 0.25538853f, 0.15412113f, -0.08429451f, 0.09008420f, -0.07265977f, 
    0.17649426f, 0.21783343f, 0.16375810f, -0.22098795f, -0.07794864f, -0.14358155f, 0.07741896f, 0.10293462f, 
    0.36116245f, -0.10377780f, -0.07641795f, 0.08959311f, 0.07100309f, 0.00773858f, -0.05117296f, -0.00084244f, 
    -0.02382221f, 0.00996356f, -0.01262520f, 0.13485304f, 0.13097546f, 0.18227457f, 0.26412544f, -0.06261046f, 
    0.15183294f, 0.29881364f, -0.09775712f, 0.09778826f, 0.28055280f, 0.10926284f, 0.07905004f, 0.25888833f, 
    0.07447758f, -0.34709626f, -0.35806227f, -0.13672192f, 0.02325551f, -0.12032502f, -0.10638428f, 0.17502725f, 
    0.14412268f, -0.03703997f, 0.13396420f, 0.15571356f, 0.39749354f, -0.13133538f, -0.06240217f, -0.02562896f, 
    -0.18002358f, -0.14794298f, 0.05718784f, -0.15560883f, -0.06908069f, 0.08864843f, 0.02820555f, 0.15759535f, 
    0.04455618f, 0.16115820f, -0.00397659f, 0.24631298f, 0.16897424f, 0.14222962f, 0.39693326f, -0.00799379f, 
    0.23542760f, 0.06956130f, 0.00579426f, 0.07121897f, -0.08085641f, -0.12454043f, -0.26276731f, 0.31799394f, 
    0.22947064f, 0.02683721f, 0.19526809f, 0.11700893f, -0.09588910f, 0.07562605f, -0.05529778f, -0.10762464f, 
    0.02793241f, 0.03023952f, -0.01463131f, 0.04961497f, -0.06270961f, -0.11308604f, -0.14070012f, -0.14745811f, 
    -0.18140410f, -0.08131623f, 0.01335525f, 0.10984851f, 0.11874028f, -0.12997597f, -0.08267398f, 0.10774904f, 
    0.04812861f, -0.02625452f, 0.01293017f, -0.01188122f, -0.04608855f, -0.04310031f, -0.06132602f, -0.04964089f, 
    0.01109467f, -0.01852903f, -0.05123349f, -0.03407753f, -0.03264536f, 0.05198394f, 0.00246396f, -0.04675331f, 
    -0.05616594f, 0.01620401f, -0.02823495f, 0.00891908f, 0.02340350f, -0.00068245f, 0.04873789f, -0.02752523f, 
    -0.04357675f, -0.04171208f, 0.02294354f, 0.05037658f, -0.00762605f, -0.02070292f, -0.05007358f, 0.02965333f, 
    0.02866002f, 0.00478082f, 0.00869969f, -0.00137857f, 0.04162874f, -0.00595763f, -0.05425268f, 0.02401586f, 
    0.02414389f, -0.03113079f, 0.05294788f, 0.05345242f, -0.04211767f, 0.05174643f, 0.04973485f, 0.03109240f, 
    -0.02436331f, -0.03400802f, 0.05630367f, -0.00016914f, -0.04617236f, 0.04598470f, 0.03888642f, 0.02267414f, 
    -0.00480113f, 0.00670166f, 0.01708888f, -0.00884738f, 0.04260842f, 0.05797125f, 0.03957331f, -0.02412381f, 
    -0.05823449f, 0.00905791f, -0.05500765f, 0.01276166f, 0.03632388f, 0.00102806f, -0.04327472f, -0.00172309f, 
    0.05867025f, -0.03750850f, -0.04119107f, -0.01261270f, -0.05460027f, -0.05612471f, 0.04306725f, 0.05184549f, 
    0.01035209f, -0.03875187f, 0.00331116f, 0.00978283f, -0.02778317f, -0.03577755f, -0.02682690f, -0.00782954f, 
    0.00845758f, -0.03683731f, -0.00325436f, -0.06061634f, -0.01333350f, 0.01873429f, -0.00572735f, -0.04455779f, 
    -0.01044173f, -0.05420682f, -0.05958503f, -0.06417111f, -0.00871595f, 0.01292505f, -0.00593952f, -0.03978536f, 
    0.03343782f, -0.04519230f, -0.00245733f, 0.02769599f, 0.04265760f, 0.01871938f, 0.01402088f, 0.04691197f, 
    -0.03702187f, -0.06143201f, -0.00618177f, -0.04704218f, -0.02313119f, 0.05442036f, 0.03120051f, -0.02067911f, 
    0.00859257f, 0.00160164f, -0.02014647f, -0.03395968f, 0.02301706f, 0.00866550f, -0.01880737f, 0.03028861f, 
    0.03852072f, 0.04610255f, -0.00284399f, 0.03874942f, 0.04217352f, 0.03945969f, -0.05393635f, -0.01270423f, 
    0.01660769f, -0.03833048f, -0.00343562f, 0.03517796f, 0.02811965f, -0.02055926f, 0.01127793f, 0.01700561f, 
    -0.04931414f, 0.03530754f, 0.04076209f, -0.02169063f, -0.03273879f, -0.03669159f, 0.00594365f, -0.01674444f, 
    -0.06534868f, -0.03484296f, -0.05264767f, 0.03234926f, 0.00471696f, 0.00509322f, -0.00925435f, 0.03253074f, 
    -0.05737449f, 0.03209345f, 0.03298226f, -0.01455710f, -0.02131982f, -0.05830202f, -0.04775566f, -0.05153119f, 
    0.04402347f, 0.02061823f, 0.01991111f, -0.04224146f, 0.01397716f, 0.00382137f, -0.04824803f, 0.03172092f, 
    0.00613094f, -0.03626798f, 0.01522673f, -0.00125079f, 0.04593256f, 0.04188102f, 0.04227232f, 0.02315030f, 
    0.05725989f, -0.05548863f, -0.02186219f, -0.02848240f, -0.05438812f, 0.03127081f, 0.01466135f, 0.01730205f, 
    0.04205484f, -0.05648758f, 0.04315423f, 0.04916879f, 0.00704417f, -0.01347633f, -0.03473034f, 0.00105118f, 
    -0.01706597f, 0.02005781f, -0.03890519f, 0.03036232f, 0.02491215f, 0.04028269f, -0.05960333f, -0.01658253f, 
    -0.00460063f, -0.05031406f, -0.03284407f, -0.02094672f, 0.02047964f, 0.04058339f, 0.00266690f, -0.05619643f, 
    -0.04252861f, -0.04669143f, 0.00825353f, -0.03724666f, -0.01869718f, -0.06168384f, -0.04745401f, -0.01799184f, 
    0.00470047f, -0.02552891f, 0.00039939f, -0.01055180f, 0.04528916f, 0.03011802f, -0.03079759f, -0.00761153f, 
    -0.02465460f, 0.03229124f, -0.02897124f, 0.01865540f, -0.00599106f, -0.06020731f, -0.02495278f, -0.04618159f, 
    0.02677326f, -0.03957309f, -0.03298698f, -0.03122094f, -0.02165931f, 0.01652055f, -0.06714869f, -0.01193774f, 
    0.02020059f, -0.04307966f, 0.02340615f, -0.03085823f, -0.03114937f, -0.01037293f, 0.04612647f, -0.01340037f, 
    -0.04145500f, 0.03284893f, 0.03923446f, -0.02301890f, 0.04323866f, -0.02342439f, -0.05511204f, -0.01393792f, 
    -0.02168763f, -0.04265492f, 0.03504467f, 0.00116511f, 0.02904811f, -0.00982546f, 0.02242579f, -0.02529839f, 
    0.03225634f, -0.05630551f, 0.00066159f, 0.01993079f, -0.03580824f, -0.02298887f, 0.05339100f, 0.04206950f, 
    0.01781571f, -0.04709255f, -0.00494062f, -0.02906726f, 0.01939991f, -0.04899102f, -0.03140517f, -0.03762091f, 
    0.00475307f, -0.03707728f, 0.03127804f, 0.01787839f, 0.05088403f, 0.03094241f, 0.03486529f, -0.01302781f, 
    0.00391418f, -0.04903655f, 0.00184156f, -0.01183129f, 0.03038444f, 0.01159550f, -0.00829552f, 0.04671579f, 
    0.01029814f, -0.06239716f, -0.01445567f, -0.02117125f, 0.03903793f, -0.00074657f, -0.04531070f, -0.04692991f, 
    -0.04341435f, -0.02819945f, -0.02341138f, 0.04063918f, -0.02299224f, -0.04284165f, -0.06645755f, -0.04992560f, 
    0.03606414f, -0.02863094f, -0.02121144f, -0.05061370f, -0.05457383f, -0.04411820f, 0.04950031f, 0.03048073f, 
    -0.00130182f, -0.00170438f, 0.06365085f, 0.05078690f, 0.02537532f, -0.04479003f, -0.01298636f, -0.03280957f, 
    -0.04797128f, -0.01471222f, 0.04310867f, -0.01095316f, 0.00721279f, 0.02866653f, -0.06249984f, 0.03574559f, 
    -0.01558793f, 0.01661529f, -0.03204761f, -0.02549688f, -0.04107244f, 0.00195338f, -0.04507554f, -0.05460624f, 
    0.04803067f, 0.04680822f, -0.02216516f, -0.01702908f, -0.05553544f, -0.06005591f, -0.03314116f, -0.03039705f, 
    0.02342327f, 0.03852646f, 0.04799996f, -0.05919983f, -0.04116457f, -0.06875986f, -0.06454083f, 0.03524830f, 
    0.04994071f, 0.02062074f, 0.05285892f, -0.05510044f, -0.04986679f, 0.03485583f, -0.05730022f, 0.03804785f, 
    0.03639812f, 0.03562827f, -0.02636379f, 0.02537187f, -0.01153777f, -0.05482859f, -0.02362970f, 0.03789813f, 
    0.00167776f, -0.04853115f, 0.00772421f, 0.00818579f, 0.03382457f, -0.02604380f, 0.05178489f, 0.02796103f, 
    0.00856990f, 0.01974205f, -0.02158983f, 0.01705614f, -0.00489542f, 0.04249335f, -0.04990314f, -0.06401989f, 
    -0.03865393f, -0.05005403f, -0.02552794f, -0.05565704f, -0.02923286f, -0.00115162f, -0.03197805f, 0.00062491f, 
    0.01358086f, 0.04473858f, -0.00025040f, 0.03437388f, -0.04347307f, 0.02124260f, -0.06108427f, 0.01168635f, 
    0.02251154f, -0.05476629f, -0.01252041f, -0.01213918f, 0.00546694f, -0.02941165f, 0.02680492f, -0.01420757f, 
    0.04758083f, 0.04842661f, -0.01152285f, 0.04713465f, -0.01101803f, -0.06885551f, 0.04153044f, 0.01965306f, 
    0.03994940f, -0.02019435f, -0.06639645f, -0.03009746f, -0.02010941f, 0.01655811f, 0.01288318f, -0.03602512f, 
    -0.00973054f, 0.04561538f, 0.01629918f, -0.01037215f, 0.02541075f, -0.01090478f, -0.03782383f, 0.01620278f, 
    0.02728023f, 0.02124760f, 0.04507127f, -0.04529884f, -0.00185047f, -0.04835749f, -0.00895045f, 0.04288388f, 
    -0.00762646f, -0.05236296f, 0.03123572f, 0.02263497f, 0.00163820f, 0.02536581f, -0.04982926f, -0.05366890f, 
    -0.01085579f, -0.01042288f, 0.02552994f, 0.03194987f, -0.01047462f, -0.03664698f, 0.00394180f, -0.06572647f, 
    -0.04707664f, -0.02277096f, -0.01935979f, -0.05801863f, -0.04433410f, -0.05223203f, -0.07035872f, -0.04826944f, 
    -0.00745514f, -0.05839020f, -0.06599842f, 0.02358283f, -0.06230682f, -0.05813780f, -0.00317325f, -0.01738451f, 
    -0.05265109f, 0.02182918f, 0.04131893f, 0.02307963f, 0.03191919f, -0.00480784f, 0.04318769f, -0.03480140f, 
    -0.01488886f, -0.04825140f, -0.04075297f, 0.04404126f, -0.05228600f, 0.02452070f, -0.03219973f, -0.03619112f, 
    -0.02191056f, 0.03670402f, -0.00022631f, 0.01888733f, 0.02568652f, -0.03366723f, -0.00508033f, -0.02407227f, 
    -0.02535001f, -0.02772703f, -0.01862152f, -0.00596834f, -0.02517888f, -0.02347355f, -0.00838107f, -0.03176541f, 
    0.04304164f, -0.01422849f, 0.01888420f, -0.02458561f, 0.01885166f, 0.04360967f, 0.03173944f, -0.01046071f, 
    0.02343118f, 0.02446706f, -0.06315087f, 0.03861525f, 0.03492903f, -0.05732631f, 0.03521767f, -0.04435372f, 
    0.01947542f, -0.01755016f, -0.05291544f, 0.01470833f, -0.02517050f, 0.02014537f, -0.06122677f, -0.01270400f, 
    0.02432238f, 0.01573519f, 0.02192562f, 0.00061625f, -0.02573380f, -0.04560744f, 0.00606965f, -0.04573327f, 
    -0.00283896f, -0.05050317f, -0.03380997f, -0.05021863f, 0.04752253f, -0.00468611f, -0.02655342f, -0.04360748f, 
    0.04614268f, -0.01196971f, 0.00481128f, 0.00847350f, 0.03544993f, 0.05039474f, -0.03081112f, -0.03998749f, 
    0.00175626f, -0.04207563f, 0.00807449f, 0.00337800f, -0.06096662f, 0.04974928f, -0.03202269f, -0.05197565f, 
    0.05654225f, 0.11717916f, -0.00196815f, -0.01579464f, 0.04677508f, 0.10266917f, -0.16126321f, -0.07490433f, 
    0.17890234f, -0.16844307f, -1.14323103f, -0.27099711f, -0.04405207f, 0.05122386f, -0.11122779f, -0.09867007f, 
    -0.01209671f, 0.13016321f, 0.10295688f, -0.14973709f, -0.03207266f, -0.20346291f, 0.10513360f, 0.05477684f, 
    0.11394503f, -0.03015599f, 0.09779767f, 0.50145549f, 0.33694753f, -0.11306532f, -0.00880152f, -0.14820036f, 
    0.02487828f, 0.29084000f, -0.17702566f, -0.25928679f, -0.20882523f, -0.11406073f, 0.07640315f, -0.02622583f, 
    0.05642560f, 0.12427162f, 0.13759725f, 0.01704707f, -0.07326502f, 0.01711317f, 0.17348939f, 0.07833439f, 
    0.28512698f, 0.11533085f, 0.13264152f, 0.01854618f, 0.06642382f, 0.18684651f, -0.22402464f, -0.16779944f, 
    -0.12470255f, -0.22377223f, 0.22168255f, -0.17142297f, -0.00358229f, -0.27098998f, -0.06574780f, -0.07291120f, 
    -0.49514368f, -1.15289474f, -0.00651051f, -0.19835094f, 0.16732037f, -0.01682500f, -0.02880546f, -0.10737950f, 
    -0.15506232f, -0.41800976f, -0.20577763f, 0.03929371f, -0.10255612f, -0.26409480f, -0.12721983f, -0.11627278f, 
    -0.01751248f, 0.10675327f, -0.28155872f, -0.18128105f, -0.12817848f, -0.06979632f, -0.15799578f, -0.12651154f, 
    -0.14878665f, -0.14926724f, -0.46267757f, -0.01076293f, 0.14259459f, 0.01112244f, 0.10943207f, 0.07596713f, 
    0.06445072f, -0.02858455f, 0.05034859f, 0.02760762f, 0.05880911f, 0.10519749f, 0.04223739f, 0.02232170f, 
    -0.11214703f, 0.04631585f, 0.03733668f, 0.15456361f, 0.11832692f, 0.19257864f, -0.31601974f, -0.01526995f, 
    0.01657222f, -0.03173264f, -0.03271868f, 0.08772326f, 0.23036169f, -0.00974541f, 0.04900412f, -0.03658380f, 
    0.14869140f, 0.12539592f, 0.05106242f, 0.06960671f, 0.07060755f, 0.22486798f, 0.03081579f, 0.22687635f, 
    0.10438118f, -0.18753457f, -0.24048519f, 0.09903158f, -0.04432768f, -0.05167611f, 0.10877735f, -0.42503309f, 
    -0.00582439f, -0.15306781f, 0.06851017f, -0.04599495f, 0.03931201f, -0.05684232f, 0.12366747f, 0.09297465f, 
    -0.17716645f, -0.09176611f, -0.03486420f, -0.31463394f, -0.18500137f, 0.02014825f, -0.07680822f, 0.00245933f, 
    0.05390156f, -0.19309136f, 0.01898644f, 0.08482501f, 0.14495167f, -0.00405991f, 0.09907162f, 0.17876357f, 
    0.17870830f, -0.11048393f, 0.12041980f, 0.16781943f, 0.03202397f, 0.03007251f, 0.17173685f, 0.09061107f, 
    -0.15331247f, 0.00408410f, 0.09703790f, -0.11091033f, 0.35377786f, 0.17822316f, 0.08414742f, -0.04903382f, 
    0.10619964f, 0.10383733f, 0.16068062f, 0.26376265f, -0.20529626f, -0.03885105f, 0.17830934f, 0.07163905f, 
    -0.09643979f, 0.01463152f, -0.00848259f, 0.06967757f, -0.22559901f, -0.23233221f, 0.28543532f, -0.11287284f, 
    -0.07384376f, 0.12707251f, -0.29832762f, 0.06489602f, 0.13914436f, 0.25231105f, -0.44972032f, 0.27599090f, 
    -0.36556277f, -0.15038224f, 0.27882826f, 0.01028221f, 0.02968431f, -0.10271430f, 0.00371495f, 0.09574020f, 
    -0.02964277f, -0.13943399f, -0.09368099f, -0.02230401f, 0.06196869f, -0.02748328f, -0.06026016f, -0.05460659f, 
    0.50916690f, 0.15913463f, -0.41796166f, 0.09044265f, 0.06478745f, -0.00370024f, 0.08373355f, -0.05740352f, 
    0.03537926f, 0.08098248f, 0.41400775f, 0.10320874f, -0.12026095f, -0.06030156f, -0.00604830f, -0.00825301f, 
    -0.02135472f, 0.19573554f, -0.20267780f, -0.12366868f, -0.07593337f, 0.04005630f, 0.00458589f, 0.00454028f, 
    0.13387281f, -0.08358154f, 0.03763662f, 0.04277687f, 0.18012109f, -0.04734442f, -0.09519085f, 0.02350559f, 
    0.20564140f, 0.11530058f, 0.02970363f, -0.06316815f, -0.55531633f, -0.31413594f, -0.51239431f, -0.08699551f, 
    0.23656720f, -0.11692021f, 0.11826510f, 0.10996782f, 0.03566187f, 0.40621480f, 0.29398537f, -0.71022773f, 
    -0.01206141f, 0.04024645f, -0.05193478f, 0.18685301f, 0.06216470f, -0.21986473f, 0.14424515f, -0.03172762f, 
    -0.92592871f, 0.01671547f, 0.03984421f, -0.03215468f, -0.02024262f, -0.01769862f, 0.14018387f, 0.31780145f, 
    -0.11912534f, 0.00503158f, -0.08142954f, 0.06279240f, 0.07297836f, -0.02220688f, 0.06108996f, -0.09501106f, 
    -0.01695866f, -0.03404297f, -0.05287721f, 0.05124714f, -0.05099400f, 0.01662952f, -0.05506961f, -0.06223224f, 
    -0.02954133f, -0.00296392f, 0.02858877f, -0.01417346f, -0.06020815f, 0.01958991f, -0.01145575f, 0.01782617f, 
    0.00299355f, -0.03470213f, 0.02398773f, -0.05109361f, -0.06335107f, -0.02499248f, 0.05199651f, 0.02884748f, 
    -0.01631865f, 0.01959451f, 0.03251131f, 0.04978871f, -0.02902325f, 0.02043019f, 0.03942242f, -0.02527373f, 
    0.05067657f, -0.05467613f, 0.00290055f, 0.03303733f, 0.02662307f, -0.04202846f, -0.01720694f, -0.02745377f, 
    0.03109883f, -0.06972434f, 0.03284312f, -0.06444534f, -0.04258126f, -0.06617378f, 0.04366257f, 0.04941545f, 
    0.00220982f, -0.06788711f, -0.03226002f, -0.04081042f, -0.06222852f, 0.03446781f, 0.04590358f, 0.02326729f, 
    0.03860998f, 0.00130811f, 0.03132993f, -0.02380904f, 0.03052926f, 0.04633870f, 0.02789482f, 0.01753635f, 
    0.00112804f, -0.04575644f, -0.01446771f, 0.02594029f, -0.02101866f, 0.02823478f, -0.02354472f, -0.03633273f, 
    -0.03817448f, 0.03250589f, 0.01427180f, 0.02993150f, 0.01956216f, 0.04953076f, 0.03627276f, -0.05110822f, 
    -0.04551096f, 0.03035132f, 0.05171323f, 0.02068398f, -0.05863091f, 0.03265664f, -0.02080425f, -0.00224300f, 
    0.04003615f, 0.01242655f, 0.05847549f, -0.03549285f, -0.02954769f, -0.02017373f, 0.04222950f, -0.01734330f, 
    -0.05558497f, -0.04838936f, -0.01664976f, 0.02938217f, 0.01224973f, -0.01782005f, -0.03487986f, -0.03114320f, 
    -0.01892025f, 0.03897640f, 0.03823309f, 0.00904037f, -0.00281631f, -0.05630170f, 0.01673273f, -0.04176149f, 
    0.06165531f, 0.00940214f, -0.02678870f, 0.00509648f, 0.05145156f, 0.01650295f, -0.05121217f, -0.01071765f, 
    0.01905730f, 0.00822009f, 0.04482555f, 0.00798262f, 0.05004746f, -0.04349459f, 0.00149681f, -0.03540664f, 
    -0.00710489f, -0.02469272f, 0.00117900f, -0.05152678f, -0.06426195f, -0.01517770f, -0.00928725f, -0.06471492f, 
    0.00380979f, -0.05576197f, -0.05878352f, 0.03379335f, -0.06429249f, -0.02312642f, 0.04266295f, -0.03178081f, 
    0.01051506f, 0.01142928f, -0.02141604f, -0.02193938f, -0.05671920f, 0.00374240f, 0.04751072f, -0.00388271f, 
    0.01563869f, 0.04465162f, -0.01134726f, 0.04366254f, -0.03806788f, 0.03062295f, 0.00709639f, 0.02141561f, 
    -0.00064838f, -0.00574896f, -0.01873308f, -0.01964881f, 0.01886470f, -0.04327380f, -0.04002180f, 0.01812214f, 
    0.04336166f, -0.05275480f, -0.04916089f, 0.03568649f, -0.01336473f, -0.06188138f, -0.05738224f, 0.02559017f, 
    -0.03259155f, -0.04530738f, 0.03857625f, -0.04297719f, 0.01655953f, -0.05030096f, -0.04567683f, -0.03564694f, 
    0.00217007f, -0.05828710f, 0.01268360f, 0.02207650f, -0.06181255f, -0.00274407f, 0.01561587f, 0.03464457f, 
    0.04189149f, -0.00212176f, 0.01987964f, 0.00662531f, 0.02250461f, -0.03501666f, 0.01328224f, 0.02434117f, 
    -0.05345083f, -0.00431364f, -0.02267931f, 0.03171577f, -0.02394435f, -0.05915713f, -0.05939692f, 0.01236231f, 
    0.00074783f, 0.03972004f, 0.04583090f, -0.02387539f, 0.05223614f, 0.00026042f, 0.04323338f, -0.03932267f, 
    0.04831480f, -0.02911014f, 0.01114251f, -0.00741859f, 0.01286167f, -0.05954573f, -0.05855701f, -0.00687254f, 
    0.00251454f, 0.00971366f, 0.00668918f, 0.00258118f, -0.06170366f, -0.00926687f, 0.02116431f, 0.01620844f, 
    0.03126447f, 0.03890675f, 0.02570237f, 0.00561191f, -0.03174099f, -0.00731338f, -0.02679462f, -0.05056813f, 
    -0.01680963f, -0.04011298f, -0.00419663f, -0.01242668f, 0.01172629f, -0.03236500f, -0.02402681f, 0.02781520f, 
    -0.01683914f, -0.01643378f, 0.02255884f, -0.04259904f, -0.02898991f, -0.00503561f, -0.00519885f, 0.02691182f, 
    -0.01200408f, 0.02353630f, -0.01053345f, -0.00827012f, 0.01426911f, 0.05122958f, -0.00134105f, 0.03279428f, 
    -0.00294236f, -0.03728027f, -0.01635358f, 0.02032091f, -0.02041259f, 0.04322216f, -0.00705437f, 0.01952881f, 
    0.03092259f, 0.03200576f, 0.06221670f, -0.02325174f, -0.00817887f, -0.00406947f, 0.00785868f, -0.05490221f, 
    -0.03629597f, -0.04320368f, -0.02083077f, 0.04921497f, 0.01383817f, 0.03043936f, -0.06225538f, 0.01912895f, 
    0.09635497f, -0.01098915f, -0.01961289f, -0.07350341f, 0.11870456f, 0.04353292f, 0.12004659f, 0.06103696f, 
    0.12144355f, 0.07327694f, -0.02348609f, 0.24780622f, -0.03365629f, -0.08186115f, 0.13389228f, 0.03032517f, 
    0.23661749f, 0.06552181f, -0.08925051f, -0.04585719f, -0.03297624f, 0.02265965f, 0.07050795f, 0.06475454f, 
    -0.03011988f, -0.19726445f, -0.04122693f, -0.33982664f, -0.55815852f, 0.54987174f, -0.13686560f, 0.06546596f, 
    0.03777994f, 0.08762211f, 0.11792450f, 0.03954057f, 0.23965736f, 0.12915389f, 0.06195566f, -0.30872738f, 
    -0.02172804f, -0.13869305f, 0.09975557f, 0.00434833f, 0.08949723f, 0.00260254f, -0.10804464f, 0.17289692f, 
    0.03455960f, 0.10674589f, -0.17643641f, 0.10033349f, -0.14828563f, 0.06756287f, 0.34580973f, 0.06141454f, 
    -0.11992234f, 0.07506653f, -0.03373211f, 0.01462516f, -0.07164575f, 0.01208116f, -0.00975875f, 1.55900359f, 
    -0.41627440f, -0.35379356f, -0.11081222f, 0.07079392f, -0.29808730f, 0.18141881f, 0.04475959f, -0.03539144f, 
    0.47453758f, -0.17721310f, 0.44370738f, -0.16017763f, -0.03607380f, -0.14712678f, -0.12307942f, -0.21694985f, 
    -0.10615673f, -0.42872441f, -0.22157051f, 0.29864615f, 0.14207438f, 0.00568143f, -0.04724988f, -0.06291528f, 
    -0.10233468f, 0.09148906f, 0.56067771f, 0.18093334f, -0.08938376f, -0.25381842f, -0.06957529f, 0.08614689f, 
    0.25545049f, 0.04552303f, -0.07996263f, 0.01357154f, 0.02865531f, 0.12346067f, 0.02213770f, 0.00386827f, 
    -0.08357684f, -0.02508997f, -0.08712184f, -0.00994479f, -0.27230737f, -0.30864218f, -0.26223099f, -0.08772930f, 
    -0.05704191f, -0.11639409f, 0.01252801f, 0.11885399f, 0.17904991f, -0.17910631f, -0.43965158f, 0.09466211f, 
    -0.00002621f, -0.00983102f, -0.10509367f, 0.01824370f, 0.05282151f, -0.00743292f, 0.03891540f, 0.10389968f, 
    0.04761498f, -0.01012795f, -0.13787697f, -0.09693659f, 0.13776208f, 0.13482451f, 0.04437237f, 0.30131459f, 
    0.06561712f, -0.09695271f, -0.01385382f, 0.18897626f, 0.13903001f, 0.24592306f, 0.14638823f, -0.05526846f, 
    0.23754142f, 0.10829694f, -0.20675513f, 0.03094649f, -0.32355228f, 0.09066577f, 0.08238813f, -0.10917664f, 
    -0.04603418f, -0.21889985f, -0.07400619f, 0.33970341f, -0.01147281f, 0.10962032f, 0.03793920f, -0.00535043f, 
    -0.21904762f, -0.07213260f, -0.13120843f, -0.04744831f, 0.12548251f, 0.07439952f, 0.15736152f, 0.05400487f, 
    0.05647998f, -0.04571026f, -0.11090148f, 0.00848113f, -0.05322523f, 0.27613762f, -0.15281147f, -0.19811842f, 
    -0.11966961f, -0.03513464f, 0.16163398f, 0.04356590f, -0.14596722f, -0.42391178f, 0.07017469f, 0.11882004f, 
    0.11784983f, -0.09290893f, 0.07633338f, -0.13111009f, -0.12015221f, 0.43315935f, 0.16288188f, -0.07434789f, 
    0.21239197f, -0.26791859f, 0.14325675f, -0.05592600f, 0.00597209f, 0.16360871f, 0.50797230f, 0.17503418f, 
    -0.79217255f, -0.04302397f, -0.15115584f, 0.28879815f, -0.06963310f, -0.07203107f, -0.22307792f, 0.06432194f, 
    -0.01706204f, -0.07319894f, -0.00593324f, -0.06633088f, -0.02969527f, 0.02465510f, -0.03665355f, -0.00311315f, 
    -0.34350368f, 0.02446298f, -0.33244357f, -0.04059980f, -0.04938054f, 0.07024397f, 0.04484082f, -0.13414691f, 
    -0.07676614f, 0.15405144f, 0.04899665f, 0.00720377f, -0.31026158f, -0.06516065f, 0.01161348f, 0.16359547f, 
    -0.01143605f, 0.06662004f, -0.00723460f, -0.25547436f, 0.19069794f, 0.05680350f, 0.21420863f, -0.11078313f, 
    0.11064187f, -0.15119319f, 0.09959143f, 0.15556896f, 0.03836991f, -0.00695874f, -0.13697344f, -0.18692040f, 
    -0.07370460f, 0.07928983f, 0.19235016f, 0.05952315f, -0.12446231f, -0.21239269f, -0.55578077f, 0.02817579f, 
    -0.09045286f, -0.14078441f, -0.06926795f, -0.02013125f, 0.06006713f, 0.22930822f, -0.21150956f, 0.13027935f, 
    -0.04688080f, 0.07871678f, 0.18463790f, 0.11341716f, -0.09865862f, 0.25128353f, -0.06476157f, -0.22864844f, 
    -0.46726373f, -0.13029668f, -0.11177273f, -0.23806782f, 0.05190286f, 0.05920229f, -0.02604649f, -0.09473718f, 
    -0.10983910f, 0.08151039f, 0.11824042f, 0.04316581f, -0.03052557f, -0.05345257f, 0.00913034f, -0.06479017f, 
    -0.01904372f, -0.69148165f, -0.80693835f, -0.11341365f, -0.34259781f, -0.09734228f, 0.08344345f, -0.12284876f, 
    -0.07432066f, 0.13850319f, 0.06257857f, 0.41338176f, -0.07535802f, -0.00220438f, 0.04262554f, 0.26338804f, 
    -0.04699509f, 0.22423258f, 0.12391538f, -0.01667451f, -0.31981543f, 0.01742271f, 0.10793498f, -0.00786881f, 
    -0.22218013f, -0.11858330f, -0.01253086f, -0.36125612f, -0.25383449f, -0.54673320f, -0.14834529f, -0.11739744f, 
    -0.36285588f, -0.10940836f, -0.04431961f, -0.08839006f, -0.57226694f, -0.22108363f, 0.00296589f, -0.08838825f, 
    -0.18106523f, 0.03247315f, -0.00575551f, 0.18402798f, -0.05672567f, 0.10332005f, -0.47493741f, 0.05655472f, 
    -0.12186795f, 0.04193787f, -0.09659404f, -0.04878227f, 0.01588328f, -0.14713481f, -0.26858449f, -0.07434355f, 
    -0.13996580f, -0.05772406f, -0.06185950f, -0.14427088f, 0.13327177f, 0.20160095f, 0.10626357f, 0.21152914f, 
    -0.13649385f, 0.06422768f, -0.31735104f, -0.11368321f, 0.36730137f, -0.05215475f, 0.11196298f, 0.03458340f, 
    0.14997555f, 0.43338433f, 0.42597911f, -0.20343682f, 0.14894465f, 0.10420231f, -0.10853212f, 0.01590277f, 
    0.18052174f, 0.01103076f, -0.09110299f, 0.06621445f, -0.17118642f, 0.15754582f, -0.24740876f, 0.00328233f, 
    0.14324458f, 0.21569684f, 0.46785825f, -0.05002268f, -0.19869763f, -0.13189301f, 0.11315691f, 0.14246193f, 
    -0.01138879f, -0.02791053f, -0.05155335f, -0.09351978f, -0.33667305f, 0.12034720f, -0.02301510f, -0.06627063f, 
    0.11427598f, -0.11648636f, -0.04891869f, -0.21106201f, -0.08978084f, -0.29276842f, 0.07697067f, -0.06074486f, 
    -0.17196259f, -0.08728030f, 0.21976243f, 0.07847798f, -0.12355359f, 0.06813695f, -0.01141094f, 0.16905740f, 
    0.14883855f, 0.07782917f, -0.08491495f, 0.11406094f, -0.03636656f, 0.04459998f, -0.13693699f, -0.73194087f, 
    -0.79426688f, 0.13659939f, -0.16385268f, 0.08060529f, 0.25607708f, 0.14104547f, -0.05986571f, 0.07156944f, 
    -0.64400083f, 0.20240660f, -0.28606439f, 0.15527223f, 0.26328209f, 0.17178613f, 0.06000343f, 0.01838290f, 
    -0.31351313f, 0.09642703f, -0.00322459f, -0.16455136f, 0.19231613f, -0.13778500f, 0.05870663f, 0.04002272f, 
    0.05885146f, -0.06955339f, -0.80239379f, -0.23020621f, 0.28308347f, -0.00421700f, -0.20581022f, 0.06216396f, 
    0.11549951f, -0.10470887f, -0.56561995f, -0.65251529f, 0.41304040f, -0.15605870f, 0.00794096f, -0.15130143f, 
    0.01155096f, -0.00652189f, 0.02105020f, 0.04854797f, -0.39207238f, -0.31625825f, 0.25488603f, -0.02680640f, 
    -0.19510464f, 0.01019084f, 0.10790064f, -0.02347218f, 0.05407169f, 0.30483803f, 0.40033367f, -0.18264627f, 
    -0.00417233f, -0.08774162f, -0.13559060f, 0.13232082f, -0.06313170f, 0.62905741f, -0.75107998f, -0.36701295f, 
    -0.13507581f, -0.04604075f, 0.05937887f, 0.03509433f, -0.26207146f, -0.14600439f, 0.16590734f, 0.00584608f, 
    0.14184110f, 0.05302149f, 0.09534010f, 0.06465377f, 0.14729507f, 0.07201321f, 0.02144260f, 0.19351046f, 
    -0.02464159f, -0.07431422f, 0.05878428f, 0.07536774f, -0.06707690f, 0.27964580f, 0.02843680f, 0.04340484f, 
    -0.23033531f, 0.08944999f, 0.01182169f, -0.08889498f, 0.09804527f, 0.07188943f, -0.00630574f, 0.06533658f, 
    0.05362140f, 0.17412372f, -0.13981657f, -1.07996905f, -0.44968283f, -0.21780019f, 0.03635876f, -0.02955953f, 
    -0.04577972f, 0.02866662f, 0.65693527f, -0.91983259f, -0.80526054f, -0.25673303f, -0.09912853f, -0.12381081f, 
    -0.12243180f, -0.02317273f, 0.04387773f, -0.31577379f, -0.20616975f, -0.87100840f, 0.06310072f, -0.02280182f, 
    0.44585323f, 0.29516000f, 0.13831696f, 0.07187886f, 0.03702680f, -0.07167801f, -0.08142176f, 0.02099037f, 
    -0.05735085f, 0.03807827f, 0.13155490f, 0.06234618f, 0.00440919f, 0.34495237f, -0.44131956f, -0.52063406f, 
    -0.13536359f, -0.07522635f, 0.01963477f, 0.20911400f, 0.22754945f, 0.08780427f, 0.18633893f, 0.07963438f, 
    0.09537127f, -0.01866780f, 0.09637655f, 0.01823305f, 0.12387113f, 0.11376939f, -0.13118547f, -0.00506425f, 
    -0.14244635f, 0.31685999f, 0.06864773f, 0.25290227f, 0.10979565f, 0.02466013f, 0.12723306f, 0.13069862f, 
    -0.00959770f, 0.10683174f, -0.30570263f, 0.12866190f, 0.10657714f, -0.04366558f, 0.06145095f, -0.09079591f, 
    -0.01061034f, -0.02395603f, -0.10132667f, -0.12064736f, -0.07557224f, 0.19757418f, -0.11335468f, 0.15435909f, 
    0.06680760f, 0.21193601f, 0.00675685f, -0.23103078f, 0.13448392f, 0.12635018f, 0.00154908f, -0.11386207f, 
    -0.06549367f, -0.02567112f, 0.11515694f, -0.00932175f, -0.02254915f, 0.54527497f, -0.33102983f, -0.13771869f, 
    0.13569959f, 0.17672887f, 0.20704944f, 0.03346186f, 0.01680197f, 0.20349340f, -0.17938916f, 0.06380565f, 
    -0.07831564f, -0.15778472f, -0.02015380f, 0.09832802f, -0.10611028f, 0.18708888f, 0.01749079f, 0.02497087f, 
    -0.04615710f, 0.01432937f, -0.03557033f, -0.04256444f, -0.00580798f, -0.00429013f, -0.07822883f, -0.09890711f, 
    0.20123033f, 0.15083869f, 0.07115694f, -0.01179539f, -0.06242889f, -0.32912931f, 0.08018739f, -0.34347895f, 
    0.44772983f, -0.33943379f, 0.09184960f, -0.06369066f, 0.23628907f, -0.12745209f, -0.14999299f, 0.02228567f, 
    -0.12734239f, -0.44546565f, 0.00553741f, 0.10886166f, 0.00367585f, -0.03589828f, 0.00013394f, -0.28737369f, 
    -0.09303279f, -0.04865127f, -0.04136914f, -0.13957959f, 0.27670190f, 0.07519548f, -0.24881132f, -0.23063546f, 
    -0.15540507f, 0.05405247f, 0.13616754f, 0.15299754f, -0.07375355f, 0.09647311f, -0.15116854f, -0.14722046f, 
    -0.10054571f, -0.05593192f, -0.14910588f, -0.23972562f, -0.25789025f, 0.04312817f, -0.07897905f, -0.05077172f, 
    -0.05727973f, 0.07618539f, -0.02969719f, -0.07629815f, 0.11712394f, 0.19997858f, -0.23232532f, 0.08348949f, 
    0.24201460f, 0.13736585f, 0.23088795f, -0.01585944f, 0.11402165f, 0.02780637f, -0.00481676f, 0.26823762f, 
    -0.16203831f, -0.02350788f, -0.03110634f, 0.07039516f, -0.01731299f, -0.02399630f, 0.10640064f, -0.14965110f, 
    0.07389127f, -0.01285296f, -0.00008369f, 0.10424567f, 0.05472811f, -0.26488513f, -0.08323278f, 0.22691351f, 
    0.18960109f, 0.04630177f, -0.21822163f, 0.04753011f, 0.10898288f, 0.02988570f, -0.02393847f, 0.11244317f, 
    0.13189207f, 0.00289148f, 0.13471796f, 0.02626395f, -0.04681602f, 0.17452444f, -0.26791379f, -0.23502374f, 
    0.13791078f, 0.29339731f, -0.13704570f, -0.04223227f, 0.02134435f, -0.06571221f, -0.15147437f, 0.20331739f, 
    0.25265479f, 0.04157651f, 0.21213216f, 0.00019489f, 0.00842951f, 0.04094961f, 0.12639877f, 0.21468133f, 
    -0.00404603f, -0.12472782f, 0.01046361f, 0.05470186f, -0.15655890f, 0.34860155f, 0.17893814f, 0.02518042f, 
    0.07787305f, 0.08732349f, 0.07423472f, -0.08143896f, -0.18245447f, 0.02187091f, -0.19650973f, -0.03614797f, 
    0.00190747f, -0.01098427f, -0.07880832f, -0.00950873f, 0.01870151f, 0.01508806f, -0.15289792f, 0.57991546f, 
    -0.17550184f, 0.04064779f, 0.27088231f, 0.10158394f, 0.09400463f, 0.18842611f, 0.11985223f, -0.21731956f, 
    0.28181982f, 0.12546065f, -0.05215525f, -0.06543796f, 0.02925639f, 0.08533403f, -0.00737264f, 0.03877734f, 
    0.02540395f, 0.04864984f, -0.07213015f, 0.01209622f, 0.06813293f, -0.08046874f, -0.20763730f, -0.09960473f, 
    0.05381051f, -0.33037248f, 0.44369557f, 0.06037826f, 0.00616842f, -0.06003776f, -0.07264814f, 0.13078552f, 
    0.09982397f, 0.02266048f, -0.06854968f, -0.06222035f, 0.14112172f, -0.02582090f, 0.04573645f, -0.07346724f, 
    -0.14230463f, -0.16746567f, -0.21073116f, -0.01426184f, 0.28792205f, -0.05125042f, 0.08965203f, 0.08539238f, 
    0.03592727f, 0.19843289f, -0.12328503f, 0.02099389f, 0.22202823f, 0.05174208f, 0.00434524f, 0.04561659f, 
    0.20928086f, -0.00936136f, -0.03076410f, -0.37842625f, -0.05190121f, -0.01379336f, 0.07137051f, -0.10803323f, 
    -0.01481048f, -0.08541757f, 0.01507852f, -0.20417099f, 0.04261086f, 0.02196780f, -0.07396144f, 0.53132910f, 
    -0.05229888f, -0.09261030f, 0.05364608f, -0.16220053f, -0.11663600f, -0.13017634f, -0.10835560f, -0.05126012f, 
    0.10307097f, 0.20366806f, 0.19104832f, 0.09984309f, 0.11106624f, -0.02598228f, 0.06882983f, -0.03117193f, 
    -0.16291061f, 0.02335067f, -0.06643134f, 0.10116048f, -0.04772275f, 0.07740943f, -0.02569259f, 0.01177958f, 
    0.02068963f, -0.06094332f, 0.03922323f, -0.02372970f, 0.01283043f, -0.00395406f, 0.02713716f, -0.00046622f, 
    -0.05690622f, -0.06665872f, -0.00375025f, 0.00832959f, 0.00745036f, -0.01957916f, -0.06039554f, 0.03186052f, 
    0.01543285f, 0.00980997f, 0.00168039f, 0.04892180f, -0.04071096f, -0.03068469f, -0.01619156f, 0.02861269f, 
    0.02466898f, -0.00268821f, -0.01640051f, 0.04422713f, 0.02073929f, 0.00414444f, -0.00832565f, -0.03811939f, 
    -0.00081731f, 0.01436159f, 0.02495071f, -0.00712293f, 0.05232027f, -0.02589521f, -0.03107882f, -0.00562340f, 
    0.00543626f, 0.00144062f, -0.00995398f, 0.04196713f, 0.04222749f, -0.03741938f, 0.01468711f, -0.02074913f, 
    -0.02339166f, -0.03848701f, 0.04046956f, -0.05175052f, -0.01814714f, 0.02207777f, -0.02797563f, 0.02197483f, 
    -0.00071861f, -0.06325831f, 0.02193547f, 0.03595573f, -0.05919632f, -0.03928686f, 0.02322823f, -0.02991291f, 
    0.02002969f, -0.06208164f, 0.03624424f, 0.00539866f, 0.00108422f, -0.06991142f, -0.05598129f, 0.02645794f, 
    0.00171154f, 0.02405298f, -0.00926568f, 0.03889924f, -0.06187397f, -0.03005030f, 0.00390322f, 0.04861303f, 
    -0.03623930f, -0.02460647f, -0.00316819f, -0.05395218f, 0.03279088f, -0.04188495f, -0.06028294f, -0.03816677f, 
    -0.00412226f, -0.01999338f, -0.06338322f, -0.05210087f, -0.06396292f, 0.04175396f, -0.01707070f, -0.00363066f, 
    -0.06037557f, -0.04081158f, -0.03703636f, 0.03991207f, 0.01955944f, -0.02745190f, -0.00477453f, 0.01241711f, 
    0.01790669f, 0.03784025f, -0.03215960f, -0.06813274f, -0.02424906f, -0.06420005f, 0.03640071f, 0.03507742f, 
    0.02040681f, 0.01680114f, -0.00861942f, -0.02845565f, 0.02945237f, 0.04340524f, -0.01077203f, 0.01326612f, 
    0.04935412f, 0.02574380f, -0.04238346f, 0.04653613f, -0.02397876f, -0.01668688f, 0.03484918f, -0.05516165f, 
    -0.02868488f, -0.03752704f, 0.02113413f, -0.03135530f, -0.01096186f, -0.06456856f, 0.03325191f, 0.01880208f, 
    0.02171652f, -0.05640627f, -0.06367440f, 0.01701316f, -0.00999435f, 0.04785947f, 0.03727096f, 0.02778827f, 
    -0.06224641f, 0.01467699f, -0.04182609f, -0.05968324f, 0.04674528f, -0.05799668f, -0.04005636f, 0.04402908f, 
    -0.05971991f, 0.01794636f, 0.02162566f, -0.04711326f, -0.06114423f, 0.02874428f, -0.01833464f, -0.00678035f, 
    -0.04413722f, -0.00818752f, 0.03591799f, 0.00926361f, 0.01102348f, -0.00929109f, -0.04533374f, -0.04657533f, 
    -0.06158096f, -0.06032837f, 0.01546010f, -0.04133558f, -0.01653617f, -0.03720312f, 0.03392626f, -0.03241730f, 
    -0.00665869f, -0.04866513f, -0.03196752f, -0.06121737f, 0.04669235f, 0.01288577f, -0.04081335f, -0.02479027f, 
    -0.01362495f, 0.04560890f, -0.01225670f, 0.02239225f, -0.06594606f, 0.04277064f, -0.02749846f, -0.03036112f, 
    0.03844547f, -0.03367212f, -0.03603644f, 0.04468798f, -0.01181974f, -0.04864458f, -0.01052505f, 0.03275914f, 
    -0.05195113f, -0.03963701f, 0.00132065f, 0.00794401f, -0.03730343f, -0.03860023f, -0.01608610f, -0.00178062f, 
    -0.04991394f, -0.01592887f, -0.06359222f, 0.02929295f, -0.02904110f, -0.00199391f, -0.04346419f, -0.04219347f, 
    -0.03866270f, -0.04708213f, -0.05910917f, -0.05788547f, 0.00009393f, -0.02240700f, 0.01989453f, -0.04712515f, 
    -0.05513854f, -0.05310459f, -0.04155037f, -0.05730204f, 0.03771533f, -0.03858029f, -0.05078887f, -0.02029448f, 
    -0.03103617f, -0.00041142f, -0.04768928f, -0.06204122f, -0.00383237f, -0.03445860f, -0.00422383f, 0.00249056f, 
    -0.02660825f, 0.04286720f, 0.04827872f, -0.00674833f, -0.03691736f, -0.05903106f, -0.05568829f, 0.03712057f, 
    -0.01535489f, 0.00840572f, 0.00179660f, -0.01578091f, 0.04033605f, 0.02908502f, -0.02205801f, 0.01395947f, 
    -0.05552831f, -0.00276940f, 0.04388302f, 0.02759225f, 0.01255173f, -0.04013206f, -0.05538958f, 0.00001159f, 
    0.00710041f, -0.00336492f, 0.04675968f, 0.04628447f, -0.05678569f, -0.04865189f, -0.00827434f, 0.00904774f, 
    0.04820722f, 0.02998334f, 0.03764375f, -0.00738517f, 0.00584700f, 0.04536005f, 0.03679315f, -0.01701868f, 
    -0.00348768f, -0.06322974f, -0.00992541f, 0.01265616f, 0.04462140f, 0.03522967f, -0.04332438f, -0.03856177f, 
    -0.00824667f, -0.20564938f, -0.04140103f, 0.01272274f, -0.11559449f, -0.03717824f, 0.14226526f, -0.10460255f, 
    0.14833257f, 0.26660627f, 0.04276429f, -0.33937380f, 0.06765575f, 0.03540853f, 0.27458569f, 0.01624188f, 
    0.15777278f, -0.04998598f, -0.59380847f, 0.23369214f, -0.06248949f, -0.08208157f, -0.16947080f, -0.24699038f, 
    -0.00634180f, -0.05343426f, 0.10032408f, -0.44778249f, 0.07629451f, 0.38313413f, 0.09563500f, -0.20370111f, 
    0.14607881f, -0.06741981f, 0.29089472f, 0.00175897f, 0.33776301f, 0.06351917f, -0.41531327f, -0.09100440f, 
    -0.00048325f, -0.16070917f, -0.12967472f, -0.04096378f, -0.00978005f, -0.05333914f, -0.59953552f, -0.13175453f, 
    -0.03324374f, -0.16345698f, -0.09981838f, 0.04658349f, -0.16863914f, 0.04969900f, 0.15248391f, 0.05993639f, 
    0.37248814f, -0.06839453f, -0.07747102f, 0.12173254f, 0.03716470f, 0.18490140f, -0.12600516f, 0.57854205f, 
    0.33588192f, 0.36606070f, 0.27287138f, -0.06452770f, 0.11911488f, 0.05806582f, -0.05412069f, -0.19284339f, 
    0.31795603f, 0.23648587f, -0.08643369f, 0.10917219f, -0.02302018f, 0.06535273f, 0.10022058f, -0.11316296f, 
    0.11894653f, 0.16346720f, 0.16944790f, 0.09079681f, -0.08111119f, 0.08179159f, -0.18737973f, 0.07765940f, 
    0.03725737f, 0.14832716f, -0.00804884f, 0.06990810f, -0.49351585f, 0.00397390f, -0.11426583f, 0.00799959f, 
    0.09222413f, 0.13142014f, -0.01026199f, -0.16153763f, -0.34286609f, 0.07145146f, -0.04852907f, 0.04143092f, 
    -0.01952606f, 0.09439685f, 0.07466317f, -0.04089276f, 0.23108315f, 0.24983898f, -0.01532204f, -0.02906312f, 
    0.18404949f, 0.00568343f, 0.00050840f, -0.05267325f, 0.11382111f, -0.04126288f, -0.07951216f, -0.18298075f, 
    -0.00580370f, -0.12982714f, 0.06935874f, 0.04324635f, -0.03535223f, -0.16240099f, 0.07004418f, 0.12749138f, 
    -0.06504247f, 0.08497787f, 0.02586593f, -0.30123174f, -0.23461565f, 0.10346682f, -0.07003650f, 0.43492472f, 
    -0.40832233f, -0.08793294f, -0.21533044f, -0.00363583f, 0.05283790f, -0.02242116f, -0.09619953f, -0.17509769f, 
    -0.07208096f, 0.13168608f, 0.55301738f, 0.09828617f, 0.36454967f, -0.16434079f, 0.05224054f, 0.21934326f, 
    -0.12386966f, -0.06972612f, -0.53257984f, 0.15477234f, 0.01665160f, -0.21201877f, 0.30587128f, -0.10951603f, 
    0.07315135f, 0.03712378f, -0.18918893f, -0.17719121f, 0.44022501f, -0.15178174f, -0.09133650f, -0.12502593f, 
    -0.05931002f, 0.01357235f, -0.09614753f, -0.12257721f, -0.02292656f, -0.29761553f, 0.01464194f, -0.05887881f, 
    -0.04596934f, -0.01934259f, 0.04164411f, -0.16212361f, 0.20124538f, 0.27600956f, -0.12240000f, -0.19485678f, 
    -0.08270220f, -0.15612891f, 0.01735538f, 0.04254442f, 0.04929370f, 0.35958403f, -0.19171992f, -0.59827101f, 
    0.00585394f, -0.06512661f, -0.11710095f, 0.11220012f, -0.01256748f, -0.03583181f, 0.29151753f, 0.18533869f, 
    -0.24196599f, 0.04396606f, 0.02782714f, 0.01457092f, -0.00555782f, 0.12795728f, -0.02186684f, -0.08934907f, 
    0.05157223f, -0.02681991f, -0.01302799f, 0.15006378f, -0.01908644f, 0.08587933f, 0.05163606f, -0.16946483f, 
    0.09369276f, 0.06849915f, -0.26058063f, 0.02542506f, -0.34792450f, -0.06560352f, -0.01486869f, -0.06029058f, 
    0.10656647f, 0.27911845f, 0.23415397f, 0.04330980f, -0.12826279f, -0.18339483f, -0.15509664f, 0.25313959f, 
    -0.11358969f, -0.06370335f, -0.24399191f, -0.66964692f, -0.26246861f, 0.12875675f, -0.26841512f, 0.25694939f, 
    0.17522934f, 0.07556797f, 0.15882030f, 0.18506141f, 0.03791232f, -0.10817827f, 0.00712424f, 0.04183987f, 
    -0.24832322f, -0.04707306f, -0.30006185f, -0.10631295f, -0.10495096f, 0.29042846f, 0.02432865f, -0.32258591f, 
    -0.09680893f, -0.08182611f, 0.03198831f, 0.07299429f, -0.10760470f, -0.04606794f, 0.16954286f, -0.07774213f, 
    0.00600202f, 0.21653146f, 0.08837373f, 0.15884182f, 0.23063585f, 0.05069871f, 0.19889008f, 0.09256864f, 
    0.04921610f, -0.02812896f, 0.16653897f, 0.04917404f, -0.04740696f, -0.21565725f, -0.07013030f, -0.03322271f, 
    0.08478300f, 0.13051011f, -0.07643979f, 0.08846902f, -0.09300655f, 0.08974236f, 0.03427611f, -0.01939468f, 
    -0.08447427f, 0.02821278f, 0.07892383f, -0.05516136f, -0.10422905f, 0.09319797f, -0.13248475f, 0.01126032f, 
    -0.00856108f, -0.17394219f, -0.43647185f, 0.35329342f, -0.18972877f, -0.11984721f, -0.14620942f, -0.13907175f, 
    -0.18918785f, -0.04114549f, -0.46704781f, -0.14155890f, 0.16425538f, 0.10297016f, 0.17005685f, 0.12638435f, 
    0.13441938f, 0.13417067f, 0.01362183f, -0.20676620f, -0.34497803f, -0.12795299f, -0.16930626f, -0.06641757f, 
    -0.11744381f, -0.01894279f, -0.02320116f, -0.15556696f, 0.13176480f, -0.27267495f, 0.03494803f, 0.13267471f, 
    -0.05450734f, 0.12237244f, 0.16204235f, 0.14465910f, -0.17646807f, 0.11800003f, 0.13297161f, 0.16528055f, 
    0.10558221f, 0.04558740f, 0.14535388f, -0.02315562f, 0.19750638f, 0.09583315f, 0.21720675f, -0.41513744f, 
    -0.85845125f, 0.02274653f, -0.13985208f, -0.07575212f, -0.11752308f, -0.14163432f, 0.30274445f, 0.47879577f, 
    -0.29401842f, -0.78401083f, -0.08758035f, 0.06075184f, 0.00590266f, -0.35156006f, -0.00773864f, 0.03333412f, 
    -0.37374556f, -0.40792835f, -0.61078471f, -0.04703066f, -0.14350587f, -0.28683090f, -0.14595686f, 0.05748650f, 
    -0.12384503f, -0.44774055f, -0.38049096f, -0.26208135f, -0.04001839f, -0.00779930f, -0.22041793f, 0.17541230f, 
    0.04825350f, 0.06259485f, -0.34062788f, -0.10320974f, 0.53594649f, 0.03428843f, -0.08927228f, 0.13055733f, 
    -0.00753506f, -0.00888529f, -0.03666654f, 0.06594364f, -0.09517490f, 0.06537504f, -0.03396441f, 0.09090746f, 
    -0.19640920f, 0.09623349f, 0.07240665f, 0.06055287f, 0.05285507f, 0.16895211f, -0.04563290f, 0.05182072f, 
    -0.02161834f, 0.05187155f, -0.09134892f, -0.08356771f, 0.22790033f, 0.19733779f, 0.17795068f, 0.16708392f, 
    0.10748046f, 0.00888614f, 0.04345048f, 0.19288948f, 0.11469782f, 0.06304350f, -0.09562050f, 0.10970524f, 
    -0.09864758f, -0.26309350f, -0.26412162f, -0.11865813f, -0.17553090f, -0.05647939f, 0.01556924f, -0.04717362f, 
    -0.22978216f, 0.39620677f, 0.03628976f, 0.20020457f, 0.20417418f, 0.07610698f, -0.03410394f, 0.10452653f, 
    -0.38762361f, -0.22992992f, -0.58583456f, -0.26868165f, 0.07144921f, 0.08576438f, -0.13235529f, 0.12511685f, 
    -0.13966540f, -0.21939953f, -0.49623689f, 0.36442775f, 0.14891142f, 0.10666943f, -0.13593800f, -0.03705357f, 
    0.07198815f, 0.13424264f, 0.06563696f, 0.16922636f, -0.25086719f, 0.11960595f, 0.16636521f, 0.11330512f, 
    -0.17747006f, 0.04086646f, 0.16880123f, -0.17880681f, 0.20267768f, 0.17738014f, 0.24520616f, 0.12445669f, 
    -0.04019751f, 0.03403719f, 0.12633711f, 0.20487024f, 0.20404296f, 0.04591951f, -0.29142916f, 0.09781241f, 
    0.19411798f, -0.03336820f, 0.22032458f, 0.11714453f, -0.11048733f, 0.05490147f, 0.49890795f, 0.40693364f, 
    0.15798458f, -0.09218863f, 0.25151113f, -0.07231749f, 0.03596183f, -0.02776772f, 0.06317737f, -0.05953829f, 
    0.10004812f, 0.13997224f, 0.13523869f, 0.24928346f, -0.05571224f, 0.08242160f, 0.04899152f, -0.15875585f, 
    -0.40806836f, -0.33024767f, -0.30234951f, 0.05412408f, -0.00201424f, -0.01828415f, -0.03447077f, -0.04065118f, 
    -0.05052042f, -0.07655007f, 0.07659519f, 0.10257930f, 0.09430697f, 0.08293115f, -0.09748043f, 0.17917031f, 
    0.06295992f, 0.04587824f, -0.08135803f, -0.10489877f, 0.20499866f, -0.05218462f, -0.08761279f, 0.00274709f, 
    0.00617143f, 0.22361174f, -0.64234108f, -0.12462862f, -0.15765174f, -0.21075591f, -0.45428804f, -0.05589961f, 
    0.00625814f, -0.30511373f, -0.06314622f, 0.48208341f, -0.11968428f, -0.33576530f, -0.09753270f, -0.01378928f, 
    0.32344499f, 0.17032875f, -0.01691051f, 0.12243901f, 0.25244981f, -0.17898405f, -0.12265769f, 0.17240860f, 
    0.05543754f, -0.19607489f, 0.05339757f, -0.06923634f, 0.05259768f, -0.34194076f, 0.37779832f, -0.63588107f, 
    -0.00887235f, -0.25056040f, -0.17891981f, 0.05885434f, -0.02576216f, -0.11995426f, -0.10304971f, -0.22247061f, 
    -0.38338560f, -0.02154298f, -0.14911211f, -0.07115798f, 0.10056030f, 0.05805144f, 0.08450422f, -0.22768706f, 
    0.07951000f, 0.01745849f, -0.17569534f, 0.09109423f, -0.06836562f, 0.13281618f, -0.05413192f, -0.00870374f, 
    0.02026698f, 0.00829667f, 0.00883073f, 0.00826919f, -0.03776989f, -0.01270368f, -0.00219940f, 0.01864525f, 
    -0.02132065f, -0.01626986f, 0.02087714f, 0.04448915f, 0.04853404f, -0.00995229f, 0.04253611f, -0.04237999f, 
    -0.03375708f, -0.03422225f, -0.01641656f, 0.03791811f, -0.02015512f, -0.05841541f, -0.02895599f, -0.00318350f, 
    0.00615957f, 0.00560089f, -0.06565773f, 0.02356262f, 0.00001826f, -0.03166820f, 0.03379880f, -0.05587874f, 
    0.04347485f, 0.01449959f, -0.06324022f, -0.05849989f, 0.03364216f, 0.00738760f, -0.00921142f, -0.02017711f, 
    -0.04228640f, -0.04326265f, -0.04806279f, -0.00695401f, 0.03320374f, 0.00371208f, 0.02994059f, 0.00918320f, 
    -0.00426292f, 0.02296969f, -0.04364996f, 0.00461169f, -0.05880712f, -0.03436543f, 0.00235162f, -0.01544388f, 
    0.03268253f, 0.00075337f, 0.03172350f, 0.00583715f, -0.01434238f, -0.02040858f, -0.05874173f, 0.02005286f, 
    0.00236987f, -0.02952997f, -0.05791148f, -0.00891269f, 0.03665698f, 0.00424642f, -0.02735331f, 0.00859695f, 
    -0.00303973f, -0.04071764f, -0.02284501f, -0.00380786f, 0.01907116f, -0.03925238f, 0.04458808f, 0.03953346f, 
    -0.00082647f, -0.02087017f, 0.03342296f, -0.03819070f, -0.06942512f, -0.00662870f, -0.00955326f, -0.00112152f, 
    -0.00660844f, -0.03415206f, -0.00324225f, -0.05894575f, 0.02872063f, -0.01038896f, 0.04968161f, -0.05849914f, 
    -0.01678812f, 0.01774389f, 0.01193084f, -0.00093589f, 0.04329270f, -0.00788550f, -0.01038474f, 0.02091799f, 
    0.01706837f, -0.05318241f, 0.04723203f, -0.00619526f, 0.03402648f, -0.04178113f, -0.00972946f, 0.00868529f, 
    -0.03481254f, 0.04859209f, 0.01476536f, -0.04316026f, 0.01980649f, 0.04868622f, 0.04702993f, -0.01791417f, 
    -0.00626157f, 0.02982615f, -0.00758259f, -0.06830187f, 0.00961551f, 0.04737008f, 0.00143560f, 0.00337617f, 
    -0.01471812f, 0.01655933f, -0.06195479f, -0.00683615f, -0.05150489f, 0.02293095f, -0.03851400f, -0.02503344f, 
    -0.04811594f, -0.05450516f, 0.01182187f, -0.02509869f, -0.00323040f, 0.03223363f, -0.01802243f, -0.04235997f, 
    0.00295124f, -0.03964205f, -0.05911184f, 0.02285091f, -0.02138267f, 0.04626845f, -0.02897239f, 0.01247732f, 
    -0.06303987f, 0.04099680f, 0.00977837f, -0.03674386f, 0.00799237f, 0.00920324f, 0.00322398f, -0.05599756f, 
    0.00784074f, -0.03072768f, -0.01836382f, -0.04762029f, -0.05085344f, -0.01821164f, 0.01675692f, -0.04863356f, 
    0.04789834f, 0.00558603f, -0.05711868f, 0.00443461f, 0.02444185f, 0.02584221f, 0.01154642f, 0.00456385f, 
    -0.02890819f, -0.06036217f, -0.00201384f, -0.01236925f, -0.01721307f, -0.02553942f, -0.00368458f, 0.04807575f, 
    0.00022887f, -0.05122008f, -0.05248079f, -0.01102111f, 0.00383115f, -0.00721922f, 0.01340438f, 0.04210182f, 
    -0.05574905f, -0.05883399f, -0.00932594f, 0.00656833f, 0.01561182f, -0.06154269f, 0.00444726f, 0.05051970f, 
    0.04176610f, -0.00721597f, 0.03576173f, -0.00268678f, 0.01454510f, -0.05595015f, -0.01382413f, 0.03977840f, 
    0.01322707f, 0.00941702f, -0.00004446f, -0.00068656f, 0.03259839f, -0.04279962f, -0.03955119f, 0.01919490f, 
    -0.06472858f, -0.05812443f, 0.04747969f, 0.02472845f, 0.04796335f, -0.02908814f, 0.04343378f, -0.02149023f, 
    -0.01188407f, -0.00136667f, -0.00698307f, 0.03943633f, 0.00034986f, 0.00481165f, -0.01750523f, 0.04316887f, 
    -0.02815748f, -0.02765173f, 0.04969617f, -0.04935548f, -0.03793971f, -0.00615445f, -0.05222128f, -0.02619684f, 
    0.00521536f, -0.00741206f, 0.03503262f, 0.02316634f, -0.05728637f, 0.00237286f, -0.00162530f, -0.00075409f, 
    -0.00503830f, -0.03247209f, -0.06472618f, -0.04402685f, -0.04620757f, 0.04432605f, -0.01331968f, 0.01040413f, 
    0.01169224f, -0.01551246f, 0.02770811f, -0.00334432f, 0.04017958f, 0.03310439f, 0.04722603f, 0.04007815f, 
    0.03121853f, 0.04944960f, -0.03882514f, -0.00670829f, -0.01963312f, -0.05302185f, -0.00936575f, -0.05922817f, 
    0.02201049f, -0.03263175f, -0.05403047f, -0.05637265f, -0.01883353f, -0.05595386f, 0.03874841f, -0.05811014f, 
    0.02509176f, -0.01057075f, -0.01592161f, -0.05278329f, -0.02622626f, -0.03686926f, 0.02581589f, -0.03986099f, 
    -0.26683366f, -0.08218056f, 0.04540895f, -0.02598400f, -0.11112152f, -0.06856696f, 0.02111105f, -0.01261448f, 
    -0.05622926f, -0.15502796f, 0.05755616f, -0.44599065f, -0.32103011f, 0.03240098f, -0.06244441f, 0.00973783f, 
    -0.08538921f, 0.07922997f, 0.14179228f, 0.02995832f, 0.24294458f, -0.04924861f, -0.07679923f, -0.12845522f, 
    0.15623859f, 0.06795151f, 0.06624409f, 0.88509035f, -0.62401021f, 0.12481586f, -0.04043349f, -0.06071435f, 
    0.13199872f, 0.12625903f, 0.02753408f, -0.17593950f, -0.55332077f, 0.05103538f, 0.12564133f, -0.07650524f, 
    0.12214690f, -0.01709153f, 0.20361708f, 0.39307019f, -0.32011595f, 0.11784941f, -0.09119062f, 0.37463376f, 
    0.12070850f, 0.10030305f, 0.01160066f, -0.10989158f, 0.18473025f, 0.04610437f, 0.18712941f, 0.02477672f, 
    -0.20456544f, 0.09796256f, -0.19112965f, 0.07492057f, 0.03054739f, -0.09802774f, -0.17340665f, -0.38938853f, 
    -0.11718065f, 0.11414967f, -0.09626842f, 0.02421924f, 0.07843520f, -0.03821130f, 0.05960623f, 0.04920454f, 
    -0.06621861f, 0.20450006f, 0.14420247f, -0.36693957f, -0.12288119f, -0.19672117f, 0.15485737f, -0.10175481f, 
    0.00806551f, 0.17821713f, 0.01372177f, -0.01345828f, 0.03487303f, 0.03895076f, -0.10383772f, 0.10455536f, 
    0.16641264f, 0.20023789f, -0.19210179f, -0.23137958f, -0.19613928f, 0.03157606f, 0.16994275f, 0.03468221f, 
    0.06272200f, -0.00819080f, -0.10723072f, -0.10885830f, 0.25504872f, 0.24016365f, 0.01314160f, -0.09515870f, 
    -0.21920887f, -0.05224964f, 0.09925751f, -0.03655843f, -0.13101162f, -0.07845934f, 0.07414925f, 0.06106044f, 
    -0.08127972f, -0.01020827f, 0.02191756f, 0.10936120f, 0.06401561f, 0.21050321f, -0.16409153f, 0.18273889f, 
    0.16422126f, 0.18549372f, 0.21537070f, 0.15558599f, -0.09802394f, 0.13026159f, 0.12414714f, 0.18289796f, 
    0.08838870f, 0.00649517f, 0.01978763f, -0.00651496f, -0.11973597f, 0.03481717f, -0.02654917f, -0.14311047f, 
    -0.08705469f, -0.32326588f, -0.10634153f, -0.09587308f, -0.08548368f, -0.06753716f, -0.18424426f, 0.12535615f, 
    0.15394028f, -0.10717201f, -0.22480313f, 0.10085239f, -0.00563291f, -0.03402520f, -0.24635796f, 0.15676939f, 
    0.15631746f, 0.26579437f, -0.29625025f, 0.26930219f, 0.07690553f, -0.11144282f, -0.23665968f, 0.18210439f, 
    0.15330139f, -0.16891326f, 0.13176915f, 0.14239557f, 0.20926206f, 0.04968873f, -0.05939766f, 0.09281649f, 
    -0.19528066f, -0.05833982f, 0.05464743f, 0.23381035f, -0.21581015f, 0.25314021f, 0.04158533f, 0.21810740f, 
    0.32886481f, 0.14443885f, 0.05078399f, -0.04494540f, -0.08474286f, -0.30593148f, 0.36425894f, 0.06756553f, 
    -0.02143514f, -0.15787737f, 0.04821805f, 0.02189660f, 0.10313498f, -0.10379457f, -0.74095839f, -0.18845962f, 
    -0.24291068f, 0.01883266f, 0.25011951f, 0.03559113f, -0.05360352f, 0.11706920f, -0.19043130f, -0.07324211f, 
    -0.33834952f, -0.07406805f, 0.02748297f, 0.06606565f, 0.07687861f, -0.08123568f, -0.05590858f, 0.16439512f, 
    0.06397387f, -0.24040678f, 0.14216991f, 0.14095715f, 0.07650491f, 0.16218041f, 0.26128709f, 0.03773853f, 
    -0.11350199f, -0.36215973f, -0.01550199f, -0.08834583f, 0.02112938f, 0.17981292f, 0.14295669f, 0.08185110f, 
    -0.06607047f, -0.03989917f, 0.20230396f, 0.04797976f, -0.03733711f, -0.21958728f, -0.08586545f, -0.01898210f, 
    -0.01813619f, -0.13900007f, 0.57066083f, -0.33497405f, 0.04008338f, -0.19912295f, -0.03412937f, 0.02314176f, 
    0.03506141f, -0.16769166f, -0.01872125f, 0.04900441f, 0.12459578f, -0.04897663f, -0.04984464f, 0.07419551f, 
    0.02143043f, 0.06761957f, -0.04859099f, 0.00411466f, 0.11702952f, -0.21800710f, 0.00920400f, 0.06293445f, 
    -0.18065819f, 0.25488570f, 0.20438787f, 0.09756204f, 0.14161083f, 0.30205068f, -0.35068670f, 0.21201417f, 
    -0.21974753f, 0.25028235f, 0.26507288f, 0.03029471f, -0.09793401f, -0.08959140f, 0.04054295f, 0.03402363f, 
    -0.02107981f, -0.18396619f, 0.00113385f, 0.24981594f, 0.19516088f, 0.02079801f, 0.06908090f, 0.51176119f, 
    0.27599335f, 0.12885466f, -0.12962997f, -0.08336146f, -0.18729512f, -0.01117845f, 0.17432608f, -0.00268944f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.04752055f, 0.07889210f, 0.09584920f, -0.06744331f, -0.06089160f, -0.02650738f, 0.05011065f, -0.16523914f, 
    0.01020018f, -0.05081406f, 0.14529213f, 0.04868267f, 0.08996462f, 0.19338146f, -0.05087107f, 0.22336733f, 
    0.34789494f, 0.00585826f, 0.12712298f, 0.15277959f, 0.00996579f, -0.02343290f, 0.18682179f, 0.03599799f, 
    -0.00673834f, 0.05407347f, -0.00913624f, -0.00331319f, -0.16542868f, 0.24843004f, 0.02689885f, 0.25055683f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.07757214f, 0.18441713f, -0.08037005f, -0.01224274f, -0.20123510f, -0.04522783f, 0.21887785f, 0.06883234f, 
    -0.13277006f, 0.16444495f, -0.19572830f, -0.09517211f, -0.26947516f, -0.16013888f, 0.03736587f, 0.23114932f, 
    0.27443412f, -0.07894697f, 0.31384391f, -0.10816691f, -0.03975169f, 0.03198236f, 0.02992776f, -0.01902001f, 
    -0.21270746f, -0.60093242f, 0.18290482f, 0.00761028f, 0.05948495f, 0.21364759f, -0.06651998f, -0.24758913f, 
    -0.07280098f, 0.07538325f, 0.03423194f, -0.13088301f, 0.10066713f, -0.26783615f, 0.11513440f, -0.16971046f, 
    0.05489803f, -0.10808767f, 0.33289886f, 0.26224333f, 0.08288233f, 0.12835622f, -0.02682674f, -0.05726079f, 
    -0.21985789f, 0.13701242f, 0.12251179f, 0.06798109f, -0.14230788f, -0.12775579f, 0.11597665f, 0.07688083f, 
    0.03710815f, 0.60529941f, 0.12422356f, 0.17253250f, -1.01118731f, -0.84435117f, 0.10718580f, 0.42867735f, 
    0.15428038f, -0.05328614f, 0.34059948f, -0.15064462f, 0.00620297f, 0.20835944f, 0.12805291f, 0.07302758f, 
    -0.09460077f, 0.16154760f, 0.21304844f, -0.13666879f, -0.11879093f, -0.01874646f, 0.12490866f, 0.18932906f, 
    0.23435169f, 0.02208206f, -0.15427943f, 0.10115039f, -0.02196839f, 0.02311968f, -0.24384448f, 0.08823013f, 
    -0.11307320f, -0.20379096f, -0.15649830f, 0.05949797f, 0.84119803f, -0.38247353f, 0.03808837f, -0.06903791f, 
    -0.04442828f, -0.09860678f, -0.11189925f, 0.06435255f, -0.17327435f, 0.16208175f, -0.10605042f, -0.49268150f, 
    -0.08511890f, 0.13460109f, 0.21739708f, -0.13082798f, 0.20420150f, 0.40456170f, 0.00210734f, -0.01892988f, 
    0.20743479f, 0.10057323f, 0.06983762f, 0.18889217f, 0.06682063f, -0.13597822f, 0.38562039f, -0.13337909f, 
    -0.17598124f, -0.10895444f, -0.17388633f, -0.10056859f, -0.38293430f, 0.84984303f, 0.14698350f, 0.07833449f, 
    0.07469295f, -0.31337723f, 0.07700904f, -0.15741847f, 0.10979894f, -0.02033605f, -0.14762196f, 0.29791337f, 
    -0.00741226f, -0.13462703f, 0.40695372f, -0.26223981f, 0.08917355f, 0.44090268f, 0.17156769f, -0.20875165f, 
    -0.23894456f, 0.08746716f, 0.16439506f, 0.26000941f, 0.15999539f, 0.00961107f, -0.54095453f, -0.03351592f, 
    0.13595137f, 0.06358901f, -0.36062422f, -0.07564493f, 0.79618067f, 0.46085486f, -0.03549378f, 0.14503728f, 
    -0.15280555f, -0.16755973f, 0.13030304f, -0.15307291f, -0.16097981f, 0.01992625f, 0.05513044f, 0.18994975f, 
    -0.02094319f, -0.02148054f, 0.45446834f, 0.10989198f, 0.32823429f, -0.07173171f, 0.02574693f, 0.01143364f, 
    -0.17340641f, 0.06923814f, -0.12716977f, 0.03907702f, 0.08099476f, -0.15659358f, 0.07971340f, 0.11029710f, 
    0.33575925f, 0.21913745f, -0.18121670f, 0.08685807f, 0.74513805f, 0.47659770f, 0.08754972f, -0.17434348f, 
    0.01224591f, -0.06949242f, -0.21445346f, 0.05861628f, -0.22792989f, 0.18186034f, 0.12978758f, 0.21685302f, 
    -0.11862990f, 0.12073974f, 0.15765625f, -0.19807881f, 0.03388461f, 0.62089658f, 0.20510353f, 0.10306793f, 
    -0.09499869f, -0.04163323f, 0.17912331f, -0.13044390f, -0.16029660f, 0.15369146f, -0.34727108f, 0.16675088f, 
    0.09725761f, -0.44171530f, -0.12904097f, -0.01684270f, -0.04370533f, 0.45389426f, -0.00352575f, 0.13287529f, 
    0.06440746f, 0.50902843f, 0.07096292f, -0.00359903f, -0.13540894f, -0.36409709f, 0.34792289f, 0.09737921f, 
    -0.12266549f, 0.00217727f, 0.26981497f, 0.12888446f, -0.00436429f, -0.28559917f, -0.05514069f, -0.08585662f, 
    0.05269213f, 0.11999440f, -0.01289209f, -0.00275257f, 0.00646114f, 0.09448589f, 0.25111723f, 0.17416868f, 
    0.20864215f, -0.25229806f, -0.06823056f, -0.14630459f, -0.28012562f, 0.14841397f, -0.15933071f, -0.35841131f, 
    0.07378320f, 0.09055172f, -0.11993843f, 0.06753577f, -0.06486048f, -0.16538318f, 0.05798410f, -0.00628995f, 
    0.02943639f, -0.04022893f, 0.12181189f, -0.12508658f, -0.10825034f, 0.03536717f, 0.15834196f, -0.01273652f, 
    -0.15196887f, -0.00037397f, -0.02990243f, -0.14693955f, -0.12893328f, 0.07346497f, -0.13360639f, 0.17063646f, 
    -0.15646674f, 0.08221450f, -0.01192153f, -0.10918516f, -0.01244266f, 0.06554537f, -0.08219234f, -0.16171223f, 
    0.12450632f, 0.01011659f, 0.02844652f, 0.09084055f, -0.01481707f, -0.19596891f, 0.13861167f, 0.16617116f, 
    0.13080148f, 0.13429657f, -0.25601026f, -0.34777665f, -0.06031007f, 0.35686460f, 0.12622514f, 0.23744032f, 
    -0.36027089f, 0.12557991f, -0.14443472f, 0.03458612f, 0.06200590f, -0.02039894f, 0.22784345f, -0.02846719f, 
    0.24786355f, 0.13314661f, -0.12685885f, -0.17075540f, 0.15271235f, 0.26353559f, 0.06050640f, 0.18012118f, 
    -0.10310979f, 0.19730423f, 0.51865953f, 0.09037150f, -0.00878364f, 0.11868904f, 0.30249926f, -0.10214856f, 
    -0.00755195f, -0.07381386f, 0.37705898f, -0.39895487f, -0.44157061f, -0.07938255f, 0.06247878f, 0.38999948f, 
    0.06931403f, -0.08669799f, 0.26036873f, 0.01126617f, 0.06581338f, 0.03980897f, -0.67052114f, 0.07705911f, 
    -0.07225608f, 0.19546859f, -0.05667445f, 0.16826248f, 0.16921109f, -0.43823323f, -0.04988022f, -0.42498997f, 
    -0.06419829f, -0.11444625f, -0.02477758f, -0.00390948f, -0.11011376f, -0.08855005f, -0.03082256f, 0.07170441f, 
    0.10507569f, 0.10547765f, -0.11744265f, -0.07315732f, 0.14626835f, -0.13465919f, -0.06219088f, -0.09402405f, 
    -0.16668335f, 0.04815086f, -0.01090746f, -0.09654707f, 0.05374939f, -0.01803615f, -0.16582330f, -0.12648313f, 
    -0.11859360f, 0.08640304f, -0.01250996f, 0.08475434f, -0.01751113f, -0.02415261f, -0.05167094f, 0.14536671f, 
    -0.17609416f, -0.26964900f, -0.16077897f, -0.04172279f, 0.34511805f, -0.01965161f, 0.19593921f, 0.18323149f, 
    -0.03768226f, 0.00454556f, 0.06316023f, 0.11950782f, -0.38269648f, 0.03443941f, 0.10409928f, -0.44590598f, 
    -0.08022112f, 0.02821909f, 0.07975780f, 0.21941833f, 0.09589583f, -0.03973931f, -0.23792860f, 0.10757802f, 
    -0.25152344f, 0.23232423f, 0.57678914f, 0.01148139f, -1.04350019f, -0.53088450f, -0.02858565f, 0.32375973f, 
    -0.06026129f, 0.32922125f, -0.38358194f, -0.05512628f, -0.37746453f, 0.15552557f, 0.32619381f, -0.03777443f, 
    -0.12377564f, -0.04226765f, -0.33809814f, 0.19391714f, -0.03843662f, 0.37720132f, 0.01039711f, -0.44868839f, 
    -0.06250875f, -0.13389307f, 0.36824211f, 0.02620852f, 0.01819220f, 0.04904647f, -0.21045876f, 0.00784860f, 
    -0.44149122f, -0.92968303f, 0.03550990f, 0.06560775f, 0.33377540f, 0.82104260f, -0.13279195f, -0.05625763f, 
    0.14417432f, 0.09118067f, 0.14568387f, 0.00703859f, 0.02410552f, 0.11454201f, -0.21636793f, -0.26825655f, 
    -0.12118527f, 0.13001536f, 0.40857708f, -0.28149930f, 0.19308773f, 0.21162613f, -0.13838288f, 0.15255344f, 
    -0.22768429f, -0.12946145f, -0.00470541f, 0.33936426f, -0.06824929f, 0.10419559f, -0.27159208f, -0.10708761f, 
    -0.28034857f, 0.20333439f, 0.19178070f, -0.00831188f, -0.65632808f, -0.23536099f, 0.00911433f, 0.30542567f, 
    -0.05716459f, -0.21052025f, -0.11594403f, -0.09964196f, 0.00793449f, 0.11952779f, 0.25277987f, 0.10730266f, 
    0.12486534f, -0.13372993f, 0.23516138f, -0.02981519f, -0.33664367f, 0.01882938f, 0.18702997f, 0.01849658f, 
    0.42493942f, -0.10749067f, 0.13914464f, 0.29976708f, -0.05538319f, 0.15831837f, -0.42632487f, 0.16884492f, 
    -0.36261559f, 0.37802708f, -0.31615552f, -0.10813123f, -0.82925874f, 0.07097663f, -0.16303183f, -0.15023129f, 
    -0.09747257f, 0.15454626f, 0.16345081f, 0.03134443f, -0.16634628f, -0.17624161f, -0.05341712f, -0.17454109f, 
    0.09461963f, 0.06824431f, -0.09539021f, -0.16305839f, -0.16878769f, -0.07114261f, 0.01173633f, -0.10813896f, 
    -0.07532763f, -0.04257070f, -0.09315929f, -0.03263935f, -0.00333261f, 0.09528774f, -0.12870921f, -0.10573897f, 
    0.14439666f, 0.06216864f, -0.09902904f, 0.14307652f, 0.14933793f, 0.07766696f, 0.03189000f, 0.00802714f, 
    -0.08191603f, 0.15791668f, 0.03341553f, -0.07880216f, 0.13615285f, 0.03782121f, 0.31498441f, 0.34397870f, 
    0.15419963f, 0.00504905f, -0.42322579f, -0.40626585f, -0.53646362f, 0.34971872f, -0.16529790f, 0.29204527f, 
    -0.03496435f, 0.07160094f, 0.27480009f, 0.03683140f, -0.03654994f, -0.08396825f, -0.60409772f, -0.14972830f, 
    -0.63881552f, -0.18841197f, 0.29571757f, -0.16555232f, 0.88711625f, 0.02869511f, -0.08703204f, 0.10043378f, 
    -0.03823126f, -0.09818238f, 0.09985591f, 0.11000304f, 0.09369531f, -0.08291300f, -0.08225019f, 0.10373945f, 
    -0.12287186f, -0.12078791f, -0.17893846f, -0.06679317f, 0.01017792f, -0.09136599f, 0.06074516f, 0.02565402f, 
    -0.20564535f, 0.16608758f, -0.00165090f, -0.09159589f, 0.13528842f, -0.16197328f, 0.09304577f, 0.09439528f, 
    -0.16425502f, -0.17111294f, 0.07788803f, -0.02068508f, -0.13576861f, -0.17548722f, 0.03500907f, -0.09145474f, 
    0.10470394f, 0.20611066f, -0.34079248f, -0.12655835f, 0.03269208f, 0.00598758f, 0.15045717f, 0.00532469f, 
    0.05005678f, -0.03983288f, 0.00392007f, -0.07301788f, -0.10368038f, 0.40588713f, -0.09901589f, 0.19459000f, 
    -0.19916312f, 0.05821986f, 0.10903509f, -0.07069478f, -0.12035313f, -0.08326333f, 0.04780482f, -0.17660105f, 
    -0.11561549f, -0.28728268f, -0.21546276f, 0.03699319f, -0.11813010f, -0.16949411f, 0.16984630f, 0.35120070f, 
    0.12948371f, -0.12214454f, 0.25430802f, 0.01963856f, 0.40865612f, 0.37039149f, -0.02315584f, -0.16526856f, 
    -0.01934807f, 0.00951338f, -0.42563421f, -0.07058114f, -0.21377647f, 0.41772303f, -0.13297236f, -0.31126505f, 
    -0.41468135f, -0.01700389f, 0.30584711f, 0.18280128f, -0.00179157f, -0.14298646f, -0.17111455f, -0.01776777f, 
    -0.01375106f, -0.45651838f, 0.31701458f, -0.13414703f, -0.48997602f, -0.00815994f, -0.11635553f, 0.05105727f, 
    0.14234655f, -0.02650974f, 0.54484749f, 0.17036046f, -0.32242057f, 0.25704435f, -0.09700069f, -0.21704921f, 
    0.00039220f, 0.06416631f, 0.11767557f, -0.13221267f, 0.32019001f, 0.27830157f, 0.15779881f, -0.21557033f, 
    0.02582560f, -0.11550314f, -0.00348030f, 0.08171993f, 0.00510025f, -0.01726806f, 0.28425437f, -0.04933546f, 
    -0.17580587f, 0.52545631f, -0.62212229f, 0.10372822f, 0.72556412f, -0.57227415f, -0.13288423f, 0.14587705f, 
    0.15135185f, 0.34810615f, 0.18245037f, -0.17766432f, -0.22368644f, -0.27975747f, 0.42695445f, 0.51854730f, 
    -0.07517982f, -0.12561600f, 0.05801822f, 0.03427336f, -0.42011058f, -0.00338327f, -0.14268774f, -0.51411545f, 
    -0.28837976f, 0.04931115f, 0.03715764f, -0.38298795f, -0.14730592f, -0.08446334f, 0.26975074f, 0.13176702f, 
    0.65038419f, 0.67761308f, 0.23102942f, 0.07428993f, 0.00776173f, 0.14210157f, -0.05813539f, -0.01390775f, 
    0.02556771f, -0.20799409f, 0.21126556f, -0.01183956f, -0.21685229f, 0.40440038f, -0.04294763f, -0.21685739f, 
    -0.12768152f, 0.09263069f, 0.31783712f, -0.60642195f, 0.10032383f, 0.40177375f, 0.01200124f, -0.04651020f, 
    -0.31272629f, -0.06683393f, 0.11724380f, 0.43757907f, 0.02757274f, -0.09209925f, -0.34035009f, -0.13627446f, 
    0.08971010f, -0.60837168f, -0.24361922f, -0.01560536f, -0.19391294f, 0.90955251f, -0.14792851f, -0.38953575f, 
    0.09479206f, 0.05389575f, -0.38720652f, 0.01908776f, -0.47585207f, -0.17369050f, 0.07914072f, -0.22834687f, 
    0.09759600f, -0.10770860f, 0.26021305f, 0.61001712f, 0.09985302f, 0.51142454f, -0.15816686f, -0.29490477f, 
    0.40250865f, -0.10196882f, 0.10648525f, 0.16825856f, -0.04081000f, -0.05596162f, 0.50218999f, -0.11812543f, 
    -0.26692954f, 0.11005086f, -0.07809142f, 0.03238123f, -0.20137091f, 0.26600626f, -0.03376012f, 0.33515576f, 
    -0.00864529f, -0.10876127f, -0.12376523f, -0.01676401f, -0.15455295f, -0.08078763f, -0.13812287f, -0.14063638f, 
    -0.17355904f, -0.14624493f, 0.16452140f, -0.12356459f, -0.05945257f, -0.13990374f, 0.00164598f, -0.06622560f, 
    -0.03190818f, 0.16782868f, 0.10047042f, -0.02058720f, -0.16113341f, 0.12467314f, -0.08189815f, -0.05336221f, 
    -0.15347551f, 0.02251594f, 0.07831205f, -0.02909633f, -0.17391045f, -0.10718007f, 0.03162158f, 0.00366779f, 
    0.07849942f, 0.14578845f, 0.33811918f, -0.16774411f, 0.04225464f, -0.22709052f, 0.21004885f, 0.26290685f, 
    0.06422941f, -0.04166594f, 0.24301004f, 0.19041771f, -0.21979509f, -0.12399844f, 0.03821459f, 0.10286521f, 
    0.12140302f, -0.07582216f, -0.06446031f, -0.16370332f, -0.14139883f, 0.08286057f, -0.01916396f, 0.14888097f, 
    0.18870255f, 0.88937777f, -0.16276199f, -0.13249722f, 0.48625636f, -0.74097693f, 0.08644133f, 0.11917235f, 
    0.18274170f, 0.26723340f, -0.07848126f, -0.06433310f, -0.26309150f, -0.28584760f, 0.10658150f, 0.22999099f, 
    0.15152618f, 0.03991387f, 0.03096619f, 0.12841532f, -0.26531768f, 0.47463092f, 0.03860277f, 0.07860260f, 
    0.44025129f, -0.14684017f, 0.34309128f, 0.22264078f, 0.13077986f, 0.09290995f, -0.16161291f, -0.07148750f, 
    -0.09447455f, -0.03538403f, -0.24019742f, 0.13548788f, -0.51337451f, 0.51398957f, 0.03513496f, -0.41467813f, 
    0.07964486f, -0.06470873f, -0.00327036f, 0.15502325f, 0.04856963f, 0.04146965f, -0.05349583f, 0.29847285f, 
    0.15267974f, -0.00646282f, 0.11007325f, -0.14570934f, -0.14982027f, -0.65269589f, -0.11961852f, 0.20042454f, 
    0.16791244f, 0.16889796f, 0.03311848f, 0.08813342f, -0.06453843f, 0.09040421f, -0.08143222f, -0.04789545f, 
    0.07780506f, 0.17412859f, -0.09176040f, 0.02264453f, -0.08780190f, -0.73137540f, 0.15179588f, 0.13481525f, 
    -0.17160964f, -0.09854189f, 0.10379589f, -0.10415877f, -0.12579897f, 0.12287485f, -0.09838674f, -0.18760477f, 
    -0.05866489f, 0.12529506f, 0.07916075f, -0.09814931f, -0.18453820f, 0.02284565f, -0.10610726f, -0.12666754f, 
    -0.15170127f, -0.05274286f, -0.16350441f, 0.01248273f, -0.16170755f, -0.14349663f, -0.05990417f, -0.08675903f, 
    -0.01788799f, -0.09181605f, -0.18549974f, -0.16781224f, 0.01668731f, -0.00407205f, -0.08945677f, 0.00479487f, 
    -0.15557805f, 0.21529132f, 0.20923711f, 0.13111210f, 0.04294156f, 0.21234439f, -0.27057111f, -0.62043619f, 
    0.05568663f, -0.07350649f, 0.13747802f, -0.18436083f, 0.11407989f, 0.11735670f, 0.02771097f, -0.29696235f, 
    -0.31376836f, -0.15308759f, -0.06002375f, 0.36977684f, -0.08384932f, -0.05736054f, 0.26122513f, -0.03392598f, 
    -0.37018088f, 0.23854765f, 0.18005656f, -0.14256260f, -0.93623233f, -0.06841086f, -0.13220306f, 0.33205181f, 
    -0.12678516f, -0.22820495f, 0.02958937f, -0.12301081f, 0.01390501f, 0.05186874f, -0.14373381f, -0.23816107f, 
    0.14410812f, 0.07866557f, 0.05720107f, -0.21546686f, -0.17121081f, -0.01459461f, -0.16151017f, -0.00489091f, 
    -0.07189563f, 0.08165667f, -0.10702141f, 0.05776050f, -0.16855137f, -0.03881010f, -0.01991012f, 0.13331537f, 
    0.02623450f, -0.19579579f, -0.05567884f, 0.14109565f, -0.14721017f, 0.10682146f, -0.11052712f, 0.03087095f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.23652396f, 0.04067006f, 0.14861912f, 0.32752407f, 0.04318358f, -0.08992532f, -0.29029927f, 0.28007722f, 
    -0.15079291f, 0.33916998f, 0.29578215f, -0.05144280f, -0.09364237f, 0.09237928f, 0.20545328f, 0.13949841f, 
    0.06982997f, 0.02703681f, 0.03746502f, 0.05423003f, -0.22826266f, 0.06414033f, 0.01632838f, 0.19247697f, 
    0.26815569f, -0.04227068f, -0.10246548f, 0.03969597f, -0.54370981f, -0.08567759f, 0.34434932f, -0.18223894f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.21957950f, -0.38501930f, 0.22358909f, -0.33533126f, 0.16609557f, 0.26722264f, -0.39415282f, -0.15924160f, 
    0.01218817f, -0.02843178f, 0.21290618f, -0.11061636f, -0.73108798f, -0.31027848f, -0.16368791f, -0.37027121f, 
    -0.14932208f, 0.28222507f, 0.15774395f, -0.35070759f, -0.60388976f, 0.41361666f, 0.24022877f, -0.22382861f, 
    -0.54044527f, 0.00369824f, 0.19778405f, -0.84259987f, 0.07594211f, -0.11270990f, -0.46278477f, 0.08531764f, 
    -0.16090100f, 0.19459832f, 0.07288524f, 0.17079701f, -0.00637304f, 0.07958748f, -0.24399054f, 0.18815020f, 
    -0.09079485f, 0.33015192f, 0.03695020f, 0.02592942f, -0.11688653f, -0.90443236f, 0.24439792f, 0.09876995f, 
    0.02483038f, -0.89918768f, -0.07859550f, 0.05628997f, -0.43127689f, 0.47073406f, -0.31286219f, -0.00184205f, 
    0.14830391f, -0.10391095f, -0.06072879f, -0.11142911f, -0.11859570f, -0.00550564f, 0.34896490f, -0.12304752f, 
    0.19987018f, -0.37146908f, -0.03844408f, 0.19747882f, 0.10078231f, 0.26221001f, 0.11073025f, 0.33817112f, 
    0.02721529f, -0.19335462f, 0.05868702f, -0.07069841f, -0.48820692f, 0.28122589f, -0.21918316f, 0.16237152f, 
    -0.09984045f, -0.28420126f, 0.04352651f, -0.39380845f, -0.33317181f, -1.51838458f, 0.10653677f, 0.48096174f, 
    0.03533646f, 0.01838363f, -0.32073629f, 0.39908531f, 0.20394054f, 0.10877764f, -0.20015040f, 0.00655276f, 
    0.40180421f, -0.43489352f, 0.25134262f, -0.47140932f, 0.01883953f, -0.07251780f, 0.38138196f, 0.27239400f, 
    -0.01838779f, -0.25708854f, 0.36934835f, -0.12136038f, -0.50128645f, 0.22824301f, -0.11446280f, -0.08751864f, 
    0.11247715f, 0.37471244f, 0.05258283f, -0.06097556f, 0.16191436f, -0.13767383f, -0.08900194f, 0.29158738f, 
    -0.84902936f, -0.03183225f, -0.17067419f, 0.03503786f, -0.25196683f, 0.03794794f, -0.53125674f, 0.11509738f, 
    -0.40972543f, 0.18356855f, -0.05902042f, -0.53847319f, -0.05523574f, -0.02708521f, -0.04779606f, -0.17648976f, 
    -0.12961224f, 0.17284873f, 0.18275784f, -0.02321402f, 0.54511619f, -1.02384079f, 0.06524662f, 0.27882013f, 
    -0.03036810f, 0.14538233f, -0.10394108f, -0.04414836f, 0.16135797f, -0.28952023f, 0.30858096f, -0.14552754f, 
    -0.54771096f, -0.08419794f, 0.18176240f, -0.13359743f, 0.20696095f, -0.01001144f, -0.24447554f, 0.07439470f, 
    -0.27203134f, 0.13399713f, 0.06458866f, -0.11301015f, 0.38854453f, 0.08900885f, 0.33677435f, -0.43381977f, 
    0.06822435f, -0.93044776f, -0.00163922f, -0.16900235f, -0.06801322f, -0.08792830f, 0.23524420f, 0.18981102f, 
    0.15193337f, 0.07050881f, -0.05245215f, 0.10858043f, -0.12767342f, -0.07961010f, -0.53884310f, 0.22118454f, 
    0.16518590f, -0.11874814f, -0.07695835f, 0.15276015f, 0.02029012f, -0.12915838f, -0.24822538f, -0.09081735f, 
    0.28560707f, -0.00772054f, -0.21913961f, -0.12737511f, -0.83227080f, -0.09901101f, -0.31150618f, 0.48583323f, 
    -0.15113668f, -0.60923350f, -1.11024070f, -0.14188123f, 0.18067786f, 0.36436006f, -0.94334960f, -0.23945296f, 
    -0.02128782f, -0.57802337f, 0.05091926f, -0.34675452f, -0.10649922f, -0.33640161f, 0.45512968f, -0.77397060f, 
    0.44899702f, 0.15191640f, 0.05441777f, 0.37550104f, 0.17126465f, 0.08268059f, -0.25080538f, -0.15804493f, 
    -0.44929814f, 0.28308952f, -0.35159454f, -0.26718751f, 0.43618840f, 0.19831735f, 0.13696985f, 0.17453493f, 
    -0.14830096f, 0.06271183f, -0.38234088f, 0.04638918f, 0.23899901f, -0.15941061f, -0.14759490f, -0.92133021f, 
    0.03729981f, -0.62024140f, -0.01618141f, 0.05748796f, 0.39119884f, -0.29887927f, 0.77029985f, -0.26638940f, 
    -0.24494301f, -0.00645936f, 0.01479702f, -0.45138451f, 0.01800488f, -0.06312571f, -0.09084386f, 0.04795156f, 
    -0.20294787f, -0.27264062f, -0.04640915f, 0.47716498f, 0.15669197f, -0.10549051f, 0.47950393f, -0.63522559f, 
    0.10188859f, 0.18804121f, -1.00678611f, 0.05341394f, -0.32638600f, 0.36734819f, -0.07560708f, -0.25443783f, 
    -0.07793037f, -0.05093895f, 0.00059684f, 0.25008386f, 0.32368603f, 0.30423731f, -0.40257400f, 0.25984895f, 
    0.29864699f, -0.05325003f, -0.72363305f, -0.32397160f, -0.07238720f, 0.13233313f, 0.19591381f, 0.00964219f, 
    0.52800095f, -0.04697692f, 0.17550594f, -0.11750913f, -0.57357520f, -0.73347235f, -0.11210953f, 0.00782187f, 
    -0.11025217f, 0.26559272f, 0.26699236f, -0.04213224f, 0.12280755f, 0.06952053f, -0.56455725f, 0.42007008f, 
    -0.16154173f, 0.47818139f, 0.01399952f, 0.06315457f, -0.16511767f, -0.78358078f, -0.02793312f, -0.93897468f, 
    0.05132876f, -0.09013006f, 0.09251013f, 0.31545204f, -0.08671020f, -0.17104152f, -0.52289730f, -0.00748775f, 
    -0.26191282f, -0.16455512f, 0.13022055f, 0.04998849f, 0.09955096f, -0.21741262f, -0.23105434f, -0.36744735f, 
    -0.04530312f, -0.68049306f, 0.01046083f, 0.03145293f, 0.47923371f, -0.02762184f, 0.33201182f, 0.13688464f, 
    -0.09616610f, 0.08325358f, -0.06719655f, -1.08761537f, 0.65245271f, -0.51009762f, -1.18196726f, 0.37871829f, 
    -0.42208624f, -0.11829448f, -0.92281479f, -0.46247336f, -0.29938647f, -0.10065688f, 0.41630104f, -0.12682548f, 
    0.16882077f, 0.14231387f, -0.41799247f, -0.23172778f, -0.52044863f, -0.83933932f, -0.07836654f, -0.16359805f, 
    0.16044940f, -0.33857411f, -0.03493468f, -0.09402998f, 0.31007171f, 0.34612244f, 0.44367138f, -0.59297198f, 
    0.00750320f, 0.40908426f, -0.14801759f, 0.17346548f, 0.23310031f, -0.60706925f, -0.08849160f, -0.48765847f, 
    -0.00051587f, -0.06049263f, -0.36390650f, -0.00393396f, 0.20156592f, 0.02818704f, 0.49535108f, -0.03839293f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.02613894f, 0.48959696f, 0.12602995f, -0.00214461f, -0.21710664f, -0.13666527f, -0.09492147f, -0.07190185f, 
    -0.26700029f, 0.04412482f, 0.12483195f, -0.24271698f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
