#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.10629556f, -1.01989305f, -0.64699984f, 0.08833336f, 0.46675199f, -0.67917949f, -1.31558275f, -0.82509506f, 
    -0.47240579f, -0.79686528f, 0.87078196f, 0.13986495f, 0.15281995f, 0.33682564f, -0.42509162f, -0.10992871f, 
    -0.23095989f, -0.33399731f, -0.95965105f, -0.93002635f, -0.35271212f, 0.11880440f, 0.22019581f, -0.11522999f, 
    0.25103706f, 0.79363173f, 0.36094531f, -0.42480561f, 0.36307073f, -0.01726851f, -0.18025531f, 0.38893011f, 
    0.28884968f, 0.28513658f, 0.49805638f, -0.20959464f, 0.14677030f, -0.37351212f, -0.81570059f, -0.41521284f, 
    -0.13390373f, 0.15025344f, -0.05578747f, 0.11573763f, -0.24756134f, 0.01383589f, -0.08768912f, 0.38427219f, 
    -0.15455963f, -0.51504165f, -1.31469953f, -0.98528498f, -0.52721721f, 0.10847451f, -0.54814380f, -0.63234460f, 
    -1.02867103f, 0.69256085f, 0.72548968f, 0.36490038f, -0.16395056f, -0.56165779f, -0.17762563f, -0.46642408f, 
    -0.63377422f, -0.10996491f, -0.37339595f, -0.26357672f, 0.02285719f, 0.07857061f, -0.06394470f, -0.06963480f, 
    0.25973013f, -0.49941018f, 0.90472907f, -0.34442213f, -0.07212749f, -0.05433916f, 0.25636405f, 0.81929117f, 
    -0.11729062f, -0.29020181f, 0.50768352f, 0.21517046f, 0.67322594f, 0.07725690f, 0.40155932f, 0.19905713f, 
    -0.43487728f, -0.28732541f, -0.18542953f, -0.00443189f, 0.02297583f, -0.14757921f, -0.12653342f, -0.43109879f, 
    -0.41990417f, 0.00967394f, 0.28206372f, 0.14015777f, 0.13493906f, -1.31072259f, -1.34402633f, -0.79369044f, 
    -0.48013276f, -0.38539064f, -0.15943936f, 0.25922555f, -0.08466589f, -0.99041623f, 0.74197495f, 0.61408508f, 
    0.81639367f, -0.03107192f, 0.51293355f, 0.03450570f, -0.23380879f, -0.37745449f, -0.17203578f, -0.04750479f, 
    -0.01473916f, -0.22363777f, -0.14625502f, 0.23693588f, -0.34358940f, -1.73401725f, -0.44003737f, -0.85260385f, 
    -1.00101578f, -0.38684845f, 0.51508439f, 0.74249160f, 0.74857038f, 0.60714406f, 0.56246293f, 0.26853153f, 
    0.18693163f, -0.04646715f, -0.25703302f, 0.11697219f, -0.23165822f, 0.03212568f, -0.28454140f, -0.03797425f, 
    -0.38089216f, -0.37871465f, -0.26402938f, -0.28518236f, -0.38843074f, -0.28571299f, -0.76813936f, -1.31171036f, 
    -0.18324858f, 1.23428452f, 0.75544816f, -0.38671529f, 0.06451432f, -0.97671360f, -0.20096555f, -0.90943229f, 
    -0.49544024f, -0.01129137f, -0.13554026f, 1.01882541f, -0.39563581f, 0.20202737f, -0.23849881f, -0.29584321f, 
    0.34171873f, 0.30309600f, 0.16201705f, -0.22827595f, -0.25443575f, -0.08402803f, 0.06842437f, 0.00794007f, 
    -1.25322735f, -0.23466723f, 0.70842969f, 0.93845075f, 0.51072526f, -0.17574997f, -1.17234182f, -0.33374479f, 
    0.62291414f, -0.10337804f, -0.09845788f, -0.13699003f, 0.06124628f, 0.18530983f, -0.72736430f, -0.24406937f, 
    0.48218849f, 0.23565991f, -0.64084727f, 0.37803188f, -0.42733368f, -0.33362800f, 0.08011022f, 0.18882534f, 
    -0.88102657f, 0.62019932f, 1.00338459f, -0.23148730f, -0.66685635f, -0.59614557f, -0.15274042f, -0.07850230f, 
    0.74744833f, 0.10545345f, -0.84645617f, -0.07539414f, 0.01514370f, -0.40545750f, -0.12907495f, 0.24245968f, 
    0.01560187f, 0.07386620f, 0.11045676f, 0.18517557f, 0.01703578f, -0.28018239f, 0.09844755f, 0.07793763f, 
    0.14634159f, 1.24276114f, 0.56850529f, 0.24021062f, -0.09564929f, -1.11547744f, 0.62565118f, -0.13309976f, 
    0.10194311f, -0.59028059f, -0.32492805f, 0.40510112f, -0.53794539f, 0.68423873f, -0.67203456f, -0.23725528f, 
    0.10898837f, -0.34591007f, -0.16942193f, 0.25539768f, 0.13774504f, -0.48655912f, 0.10217933f, 0.11053690f, 
    0.05313800f, 0.51868504f, -0.54134005f, -0.35358003f, -0.93908197f, -0.74582517f, -0.55910867f, -0.13672829f, 
    -0.22011968f, -0.01468773f, -0.51649326f, -0.76729971f, -0.51334172f, 0.00817836f, 0.18796691f, -0.20196705f, 
    -0.14750838f, -0.08443191f, -0.37964803f, 0.05874647f, -0.22899297f, -0.21484701f, 0.25570700f, 0.53701198f, 
    0.66726500f, 0.36182365f, 0.53610200f, -1.12743843f, -0.45871058f, 0.57711816f, 0.51749152f, 0.33831450f, 
    -0.65172738f, -0.14588119f, 0.03166369f, -0.35493168f, 0.06536402f, 0.28568166f, -0.19681674f, 0.15646166f, 
    -0.24118489f, 0.23054394f, 0.30727088f, 0.18628778f, 0.10540007f, -0.23443125f, -0.53646779f, 0.37525561f, 
    0.44867244f, -0.26012436f, 0.04485190f, 0.30129722f, -0.27410296f, 0.71549219f, 0.15137485f, -0.39851031f, 
    0.08689680f, 0.02812068f, -0.06097889f, -0.14293833f, 0.01515157f, 0.70874709f, 0.35085583f, 0.29293382f, 
    0.07793278f, 0.10429177f, -0.34414673f, 0.20402102f, -0.21626928f, 0.73554236f, 0.04673038f, -0.29479530f, 
    -0.03146651f, 0.62141615f, 0.09981844f, -0.53624183f, 0.34952927f, 0.57450306f, 1.53228319f, 0.88166714f, 
    -0.55394101f, 0.34131628f, -0.99692285f, -0.76299882f, -0.42036018f, -0.33736029f, -0.88872188f, 0.01181858f, 
    -0.17735913f, 0.17943844f, 0.40248016f, 0.13898405f, 0.14086199f, 0.09468073f, 0.40046120f, -0.08789980f, 
    0.06803609f, 0.00404006f, 0.19391057f, -0.26845405f, 0.20338230f, -0.06432702f, -1.28167522f, -0.61826152f, 
    -1.10795534f, -1.15009427f, -0.34877756f, 0.90334398f, 0.91063929f, -0.55872953f, -0.69834280f, 0.86834377f, 
    -0.11119793f, -0.51858401f, -0.67652661f, -0.61868769f, 0.36472586f, 0.08140919f, 0.34775382f, 0.19335854f, 
    0.31402990f, 0.05570291f, 0.12337111f, -0.22041294f, -0.08750232f, 0.02670453f, -0.13468872f, 0.50445354f, 
    -0.91555369f, -0.61541826f, -0.04580461f, -1.27751744f, -0.26327568f, -0.42448804f, -0.22608846f, -0.45418274f, 
    -0.02730720f, -0.84285212f, -0.68851161f, -0.52362436f, 0.71708649f, -0.09670700f, 0.08513148f, -0.26377577f, 
    -0.17984818f, -0.01776387f, -0.19797376f, -0.40378478f, -0.49532124f, -0.41834855f, -0.49821886f, -0.82792777f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.49458888f, 0.50301200f, -0.46709794f, 0.79510587f, 0.67124432f, 0.36603850f, 0.45100245f, 0.65202588f, 
    0.67537278f, 0.68807232f, -0.47428593f, 0.40223557f, 0.69478959f, 0.36569104f, -0.13699894f, -0.27417108f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.41077211f, 0.42439604f, -0.07896612f, -0.39377481f, -0.06620093f, 0.07887079f, -0.01858255f, -0.11297407f, 
    -0.10739948f, -0.09222071f, -0.21233048f, -0.19908389f, -0.70627964f, -0.12940402f, -0.49788100f, 0.07283928f, 
    -0.00296245f, 0.09202208f, 0.09184568f, 0.09629681f, -0.01433072f, -0.11997527f, 0.01396875f, 0.16298723f, 
    0.49621129f, 0.33005369f, 0.62971687f, -0.29119760f, 0.14665145f, 0.27325052f, 0.17764941f, 0.09418873f, 
    -0.00491878f, -0.08190189f, -0.02529079f, -0.28708532f, -0.74127233f, -0.09247456f, -0.10504036f, 0.07680065f, 
    0.08350309f, 0.04492184f, 0.11465164f, 0.06893729f, -0.18441802f, -0.38352573f, -0.00409442f, 0.02659782f, 
    0.56800658f, 0.27821344f, -0.51232862f, -0.29068711f, 0.08764051f, -0.12863487f, -0.04093373f, -0.08558064f, 
    -0.22404331f, -0.02455320f, -0.00254522f, 0.02684428f, -0.09629561f, -0.17134444f, -0.05186442f, 0.08697179f, 
    0.15962031f, 0.33038947f, 0.13533235f, -0.02444476f, -0.00096624f, 0.04329100f, 0.01963184f, 0.04681139f, 
    0.76074332f, -0.27508521f, -0.11199570f, -0.75156850f, -0.01349674f, -0.23876114f, 0.15765129f, -0.17744914f, 
    -0.09883272f, -0.06473936f, -0.15518039f, -0.11783069f, -0.01671716f, 0.22363047f, -0.02610600f, -0.24553216f, 
    -0.21331376f, -0.03884024f, 0.07289624f, -0.53618866f, 0.04563751f, -0.22204122f, -0.06178007f, 0.08440875f, 
    -0.50262827f, 0.24739487f, 0.02741040f, -0.33852145f, -0.12833351f, -0.26903975f, -0.19564687f, -0.04970171f, 
    0.07016281f, -0.13466610f, -0.01148121f, -0.05891698f, -0.27146727f, -0.53100622f, -0.75023252f, -0.07747413f, 
    -0.01011793f, -0.00162244f, -0.02563600f, 0.02781268f, -0.16392694f, 0.07011992f, -0.12589073f, 0.03260658f, 
    0.27227297f, 0.06102443f, -0.30994135f, -0.23747815f, 0.26108822f, 0.20155852f, 0.23223832f, -0.09275116f, 
    -0.00086601f, -0.11738802f, -0.03935171f, 0.02885695f, 0.14437190f, 0.14233424f, 0.24464180f, -0.31865051f, 
    -0.36028725f, -0.16525556f, -0.14671744f, -0.11381379f, -0.00143901f, -0.08189857f, -0.08502213f, -0.13555156f, 
    -0.09179930f, -0.04857598f, 0.03092860f, 0.03144844f, -0.29389173f, -0.12090026f, 0.03063973f, -0.22574210f, 
    -0.18376748f, -0.30202603f, -0.08925225f, -0.15829922f, -0.01479731f, 0.15437433f, 0.02554671f, 0.03592680f, 
    -0.05895643f, -0.07150000f, -0.26768634f, -0.06384995f, 0.08372111f, -0.05877699f, 0.02330449f, 0.06036965f, 
    0.39286643f, 0.25934774f, -0.25475940f, -0.28741089f, 0.02100113f, 0.17279162f, 0.05383325f, 0.13146521f, 
    0.02365983f, 0.07215306f, 0.11357728f, 0.01437107f, 0.46380174f, 0.10833913f, 0.10754453f, -0.07818022f, 
    0.17081220f, 0.12818894f, 0.07121892f, 0.09943612f, -0.23241770f, -0.19857949f, 0.01395687f, 0.28370684f, 
    -0.69488978f, 0.05235837f, -0.34892577f, 0.05679649f, -0.08274263f, -0.04479073f, 0.20764433f, 0.26443484f, 
    0.05823865f, 0.07551305f, -0.04484777f, 0.24970931f, 0.43167713f, 0.27521822f, 0.60724807f, 0.19864383f, 
    -0.01168074f, 0.01292469f, 0.01970165f, 0.00782170f, -0.05320888f, -0.07369301f, -0.00075023f, -0.01075031f, 
    -0.27270204f, 0.72332203f, -0.32890663f, -0.30955532f, -0.10611176f, 0.27093178f, 0.18008837f, -0.31917891f, 
    -0.02658364f, 0.08737519f, -0.06016890f, -0.08613912f, 0.01522254f, 0.14611067f, 0.21067864f, 0.25184894f, 
    -0.02912259f, 0.04510275f, -0.00722013f, -0.10506004f, 0.04941082f, 0.03279329f, 0.02032296f, 0.27462772f, 
    -0.03915080f, -0.06489371f, -0.04067716f, 0.02453893f, 0.00321239f, 0.28952533f, -0.00225525f, -0.23568001f, 
    0.16946898f, 0.10628927f, 0.10495028f, -0.00784440f, -0.03711569f, -0.10052599f, -0.35875607f, -0.28535226f, 
    0.03286613f, 0.01875734f, -0.14669116f, -0.07671323f, -0.11262094f, -0.03687528f, -0.29493943f, -0.19224265f, 
    -0.74061722f, -0.28967050f, -0.10589318f, -0.19901630f, -0.12765829f, -0.27756381f, 0.19597541f, -0.05072405f, 
    0.19565593f, -0.19555412f, 0.26465145f, -0.03800809f, 0.12600712f, 0.22418435f, -0.18102604f, -0.05738875f, 
    -0.24143460f, 0.16747913f, -0.08056826f, -0.06242813f, 0.14393477f, -0.03340027f, -0.08863791f, -0.08380955f, 
    -0.33721533f, 0.17192540f, 0.28503567f, -0.50685340f, 0.10537008f, 0.13321665f, 0.05813124f, -0.15552175f, 
    0.06607746f, 0.14927389f, 0.02258807f, -0.06653600f, 0.70000982f, 0.05152840f, 0.09196745f, -0.20058401f, 
    -0.25484571f, -0.16498232f, -0.01755545f, -0.14006387f, 0.02901173f, 0.02989251f, 0.02873913f, -0.03534049f, 
    0.07856219f, 0.37902752f, 0.37808079f, 0.22102596f, -0.23563671f, 0.08217383f, 0.02718627f, -0.06814282f, 
    -0.15094085f, -0.01475248f, 0.02362207f, -0.01846612f, -0.50164574f, -0.18986557f, 0.07182395f, -0.01186051f, 
    -0.13315722f, 0.12312644f, 0.13929750f, 0.12608227f, -0.05784566f, 0.01845605f, 0.06793584f, 0.04879087f, 
    0.08182701f, -0.04351517f, 0.27249426f, -0.04815044f, 0.16613039f, 0.19127007f, -0.16421980f, 0.03027676f, 
    -0.13467692f, 0.02138875f, -0.02918120f, 0.10765037f, 0.17552283f, -0.06906332f, -0.21076600f, -0.14432849f, 
    0.04398339f, -0.39849761f, -0.09040575f, -0.06854808f, -0.05520122f, -0.03171475f, -0.02521417f, 0.10471353f, 
    0.79059196f, 0.08716574f, 0.31993937f, -0.36038524f, -0.04065094f, -0.12391561f, -0.03280289f, -0.23379771f, 
    0.04266777f, -0.01801800f, -0.09528023f, -0.10796919f, 0.39309886f, 0.20031740f, 0.17349812f, 0.23793896f, 
    0.01209288f, -0.12957889f, -0.27318224f, -0.15415740f, 0.06481019f, -0.17483400f, 0.03817468f, -0.45575994f, 
    -0.40040037f, -0.19358103f, -0.27157587f, -0.22352333f, 0.25047785f, -0.00828533f, 0.03835018f, 0.01421133f, 
    0.02662843f, -0.09954009f, 0.01789004f, 0.02146008f, -0.26187965f, -0.49103224f, 0.23816563f, 0.18825491f, 
    0.03333187f, -0.07587350f, 0.03200136f, 0.06977792f, 0.12204320f, -0.09453348f, -0.06534982f, 0.06127053f, 
    -0.54183674f, 0.61510050f, -0.67715704f, 0.14549622f, -0.04317733f, 0.02200314f, -0.22924908f, -0.34389269f, 
    -0.02316484f, -0.15298067f, -0.03858070f, -0.10578047f, -0.11567499f, -0.18084583f, -0.12237874f, 0.22170235f, 
    0.01150733f, -0.02241005f, 0.07634485f, -0.02282608f, -0.03574969f, 0.05954391f, 0.00110334f, 0.03608964f, 
    -0.26424891f, 0.04270653f, 0.51107502f, -0.05544109f, -0.28491324f, 0.01470149f, 0.34724888f, 0.07919731f, 
    0.02419082f, 0.04077233f, -0.03776279f, 0.05009510f, 0.26797429f, 0.64997524f, 0.56021243f, 0.31143859f, 
    -0.04380794f, 0.04432436f, 0.14282860f, -0.01409859f, 0.04187076f, 0.13186651f, -0.06158932f, 0.16054985f, 
    -0.24280210f, 0.08009218f, -0.56794262f, 0.15704088f, -0.10160196f, -0.09955152f, 0.04814865f, 0.37167948f, 
    -0.08745522f, 0.06869098f, 0.13209605f, -0.04500476f, -0.17757256f, 0.16015291f, -0.03946089f, -0.04152330f, 
    0.07751309f, 0.11900686f, 0.02189190f, 0.35868147f, -0.00460184f, -0.07538468f, 0.12056469f, -0.27341893f, 
    0.52204621f, 0.12867646f, 0.32934138f, -0.02908849f, -0.04581010f, 0.08384889f, 0.00275922f, 0.29782701f, 
    -0.19616580f, 0.15267552f, -0.08000882f, -0.10997777f, -0.71376628f, 0.20840801f, -0.06002742f, -0.86446905f, 
    0.03270140f, 0.02621274f, -0.12230976f, -0.00653400f, 0.06484193f, -0.04668305f, 0.14330781f, -0.02563917f, 
    -0.62547553f, -0.41139060f, 0.03852727f, -0.70085382f, -0.28714955f, 0.17356746f, 0.41411179f, -0.17838714f, 
    0.01621618f, -0.15620708f, -0.02005572f, -0.13644628f, 0.04253365f, -0.03121262f, -0.22851948f, 0.33021951f, 
    0.20035152f, -0.05008142f, -0.23043877f, -0.12594242f, -0.09914174f, -0.14381878f, -0.03479828f, -0.01120463f, 
    0.08642422f, -0.09028754f, 0.15735789f, 0.04283154f, 0.16292784f, 0.18742192f, -0.09596165f, 0.10567492f, 
    0.00561385f, -0.24100122f, 0.27563280f, 0.03431705f, -0.56874263f, -0.42730382f, 0.17176202f, -0.39079747f, 
    -0.00803867f, -0.33150646f, -0.54241759f, -0.04999289f, -0.02989911f, 0.01428014f, -0.05436672f, -0.11583722f, 
    -0.19010033f, -0.21430637f, 1.00218189f, 0.49861267f, 0.14584118f, -0.08070487f, -0.18473722f, 0.24783373f, 
    0.00564441f, 0.07505286f, 0.05015759f, -0.03080517f, -0.95227385f, -0.16905694f, 0.28303054f, -0.52907550f, 
    0.12068742f, 0.01797933f, 0.07899725f, -0.21567954f, 0.03683534f, -0.08468908f, 0.06501985f, -0.14358941f, 
    0.11169969f, -0.09532683f, -0.17905727f, 0.24878408f, 0.21960071f, 0.06343722f, -0.06038711f, 0.14540216f, 
    -0.12734185f, 0.05426163f, -0.00261291f, -0.09070298f, -0.31402874f, -0.04650903f, -0.37062833f, 0.15259971f, 
    -0.08360402f, 0.22445393f, -0.25824934f, 0.21535528f, -0.15101697f, 0.29600126f, -0.06848582f, 0.01396100f, 
    0.07434557f, -0.21963087f, -0.29350266f, -0.16451932f, 0.25163507f, -0.03316472f, -0.01879756f, -0.04378764f, 
    -0.09982479f, 0.20457265f, 0.10789800f, -0.02258525f, -0.18632998f, 0.00752713f, -0.44465926f, -0.71355319f, 
    0.05775670f, -0.18978718f, 0.05067004f, -0.03337669f, -0.04321661f, 0.21668693f, -0.39271680f, -0.03688251f, 
    -0.29378992f, -0.24402913f, -0.26595616f, 0.33839408f, 0.16264437f, -0.00975358f, 0.18935259f, 0.18549559f, 
    -0.04989655f, 0.08396211f, 0.14587325f, -0.06112283f, 0.75269949f, -0.22364342f, -0.08782911f, 0.30373496f, 
    0.37633371f, 0.15111166f, 0.06433139f, -0.15847152f, -0.20151433f, 0.12407199f, -0.04039054f, 0.10335935f, 
    -0.28012872f, 0.61761248f, -0.46433347f, 0.19913395f, 0.09944095f, -0.20847338f, -0.00379621f, 0.01926985f, 
    -0.25194272f, -0.23182261f, 0.23878695f, -0.11448044f, -0.28585872f, 0.67012769f, -0.21236262f, 0.16147439f, 
    0.20712520f, -0.29050690f, -0.01690669f, -0.46242726f, -0.27809414f, 0.02505429f, -0.32721400f, -0.01574431f, 
    0.87723202f, -0.01724035f, 0.09371942f, -0.39758846f, -0.28668851f, -0.28976679f, -0.05323552f, -0.26619476f, 
    -0.24136190f, 0.02665382f, 0.02331919f, 0.12252712f, -0.93636024f, 0.28369403f, 0.13235742f, 0.31080171f, 
    0.09880402f, 0.09354554f, -0.67672688f, -0.15478669f, -0.10715920f, 0.04356616f, 0.09186028f, -0.13002728f, 
    0.14701119f, -0.02088746f, -0.01947027f, 0.47220039f, -0.03165222f, -0.07790560f, -0.04518380f, 0.16760887f, 
    -0.02676688f, 0.19560149f, 0.04477797f, -0.12145383f, 0.33750722f, 0.43794209f, -0.01767575f, -0.28448060f, 
    -0.03518661f, -0.38378203f, -0.11600467f, 0.07302653f, 0.10873441f, 0.06090049f, -0.01426781f, 0.19056275f, 
    0.01121077f, -0.08552845f, -0.54761875f, 0.11573523f, -0.26237303f, 0.19166665f, -0.32972804f, -0.30782622f, 
    -0.09371977f, -0.08503877f, -0.01360835f, -0.32111308f, -0.03943679f, -0.52399027f, 0.85576975f, 0.22280625f, 
    -0.32108861f, 0.30735382f, -0.05063457f, 0.30184731f, 0.14224786f, -0.00456446f, 0.00764525f, -0.34556565f, 
    0.30340081f, -0.23556082f, -0.33240798f, 0.27441415f, 0.27102381f, -0.04201026f, 0.05392263f, -0.08924554f, 
    -0.10695451f, -0.05714039f, 0.19199193f, 0.11982905f, -0.40263820f, -0.26118630f, -0.03265183f, 0.34651428f, 
    -0.07829498f, -0.05228587f, -0.05256578f, 0.10220932f, 0.01714911f, 0.03379841f, 0.03841865f, 0.01961543f, 
    0.28272769f, 0.09782495f, 0.46355149f, 0.23828043f, -0.08960471f, -0.10583547f, -0.24500579f, -0.04855212f, 
    -0.04074864f, -0.30293709f, 0.13319832f, -0.18788043f, -0.53521818f, -0.12653010f, -0.68470913f, -0.46048594f, 
    0.17820966f, -0.06091689f, 0.12128543f, 0.17978004f, 0.19535710f, -0.04041190f, 0.07395411f, 0.00136752f, 
    -0.23527212f, 0.09200395f, 0.04928952f, 0.00092233f, -0.41621655f, -0.10723317f, 0.02815672f, 0.06922934f, 
    0.09273459f, -0.13240039f, -0.03952251f, -0.12506135f, -0.30019853f, 0.01532962f, -0.22495212f, -0.16557211f, 
    0.03992784f, -0.00322147f, 0.01265746f, 0.09307804f, -0.14887516f, -0.06449752f, -0.12010742f, -0.13441208f, 
    0.29170340f, -0.07865312f, 0.32473838f, 0.20714085f, -0.09411985f, -0.10792903f, -0.08611606f, 0.01276133f, 
    0.13528982f, 0.06451946f, -0.06484247f, 0.11439832f, -0.02528074f, 0.00205671f, -0.04357424f, -0.02426155f, 
    -0.15139276f, -0.07341971f, -0.03279524f, 0.04736345f, 0.07753922f, -0.07366882f, 0.04431941f, 0.21577999f, 
    0.04115647f, -0.46332890f, 0.63562393f, -0.06223877f, -0.36905161f, 0.31602496f, -0.47803739f, 0.14469127f, 
    -0.23945443f, 0.22156148f, -0.22975209f, 0.04703292f, 0.04550003f, -0.51430595f, 0.10150076f, -0.01060634f, 
    0.01706597f, 0.11286113f, -0.00236662f, -0.18589485f, -0.19090982f, -0.17182456f, -0.03215374f, -0.18735279f, 
    -0.19687596f, -0.41799152f, -0.55681568f, 0.07121218f, -0.09538696f, -0.22585525f, 0.14326574f, -0.07371826f, 
    0.02440905f, -0.08157949f, 0.11793745f, -0.01164537f, -0.09351840f, 0.06546367f, -0.26881713f, 0.02770194f, 
    0.05140481f, 0.05580371f, -0.00546101f, 0.09134378f, -0.08856369f, -0.05021368f, -0.02704447f, -0.29186118f, 
    0.19400346f, 0.07085186f, 0.16076177f, 0.23269327f, 0.09790643f, -0.04461209f, 0.07291076f, -0.05082150f, 
    0.05376758f, 0.00149626f, -0.03257321f, -0.06431139f, 0.12426341f, -0.09945300f, 0.22325520f, 0.01527614f, 
    -0.11547205f, -0.12983535f, -0.02594161f, -0.35846835f, -0.05255310f, 0.03761355f, -0.03613473f, -0.11641915f, 
    0.16568442f, 0.09919933f, -0.02767326f, 0.02530659f, -0.00330227f, 0.11602983f, -0.01382153f, -0.19308518f, 
    0.05217734f, -0.32095957f, -0.25324300f, -0.23237474f, 0.12589321f, 0.66514736f, -0.04969146f, 0.45642093f, 
    -0.02489289f, 0.41099802f, -0.01902271f, 0.12008889f, 0.16896464f, -0.07362397f, -0.06803175f, -0.12624893f, 
    -0.50004429f, -0.07294015f, 0.07841461f, 0.25055212f, -0.12936080f, -0.07832599f, -0.20595098f, -0.15833098f, 
    0.02702317f, 0.14734584f, 0.00409127f, 0.10983120f, -0.10359325f, 0.23840465f, 0.10195482f, -0.10904930f, 
    0.01651777f, 0.29488605f, 0.02473182f, -0.02928602f, 0.14529197f, 0.16318093f, -0.09765951f, 0.52739596f, 
    0.13911992f, 0.15006500f, 0.16403328f, -0.16827494f, -0.08453746f, 0.21401228f, 0.08632772f, -0.40173480f, 
    0.08557332f, -0.15417965f, -0.05173745f, 0.00994220f, 0.53846145f, -0.17029962f, -0.48996180f, 0.09130653f, 
    -0.00261944f, -0.11212523f, -0.05682427f, 0.02041452f, -0.07457218f, -0.06976934f, 0.06170690f, -0.04276193f, 
    -0.15362448f, -0.56011599f, 0.16919284f, 0.28138030f, -0.03148712f, 0.09055684f, -0.20462942f, 0.09202244f, 
    -0.03421051f, 0.06577018f, -0.05928858f, 0.36773005f, 0.12574910f, -0.34883511f, 0.09082074f, 0.26948881f, 
    -0.03860450f, -0.03791616f, -0.08814597f, 0.07935716f, -0.07332803f, -0.16725409f, 0.08747055f, -0.11279872f, 
    0.18860535f, 0.10832818f, -0.00161682f, -0.20064303f, 0.13851537f, 0.03241752f, -0.00130170f, -0.12751441f, 
    -0.13147157f, -0.13058767f, -0.08563285f, 0.00205558f, -0.70107871f, 0.04860086f, -0.44515854f, -0.24881767f, 
    -0.03938057f, -0.16028078f, 0.04709744f, 0.18018557f, 0.28337151f, -0.33677840f, 0.05506999f, -0.17379513f, 
    0.15850650f, 0.30027050f, 0.29000124f, 0.10594779f, -0.04552881f, -0.14415915f, 0.01159120f, -0.08772333f, 
    -0.01383498f, 0.14280488f, -0.14155038f, 0.03933810f, 0.17857443f, -0.26397595f, 0.50269920f, -0.48203799f, 
    -0.09810187f, -0.12969218f, 0.12878011f, 0.15872732f, 0.13237135f, 0.16141139f, -0.01675783f, 0.19665155f, 
    -0.24862702f, -0.15653390f, -0.02151449f, 0.54491377f, 0.16861027f, 0.01575924f, -0.13358957f, -0.03773901f, 
    -0.07776616f, -0.11492055f, -0.04694438f, 0.03616389f, 0.36448258f, -0.17669308f, -0.85349649f, 0.04708267f, 
    0.36059028f, 0.02136017f, 0.07200217f, 0.06607182f, 0.21079305f, -0.09171576f, -0.14998892f, 0.30058143f, 
    -0.01459080f, 0.14614202f, -0.05480686f, -0.25017279f, 0.21005286f, 0.12357771f, 0.15256564f, -0.07352567f, 
    0.25667939f, 0.12742940f, 0.02623701f, 0.13700536f, 0.32814196f, -0.05949377f, -0.01114012f, 0.00355396f, 
    0.08100553f, 0.05919758f, 0.06284578f, 0.33661276f, 0.07986629f, -0.11465506f, 0.01965824f, 0.20718805f, 
    -0.26151401f, -0.07503273f, -0.33280450f, 0.03253175f, -0.10749860f, -0.49342373f, 0.23656552f, 0.42266849f, 
    0.10602640f, 0.17676660f, 0.00533606f, 0.21414004f, -0.36694130f, -0.07890104f, -0.28848326f, 0.05100439f, 
    -0.00178341f, 0.00760149f, -0.10489730f, -0.29877532f, -0.07354262f, 0.04155962f, 0.01342886f, -0.00555765f, 
    -0.55599648f, 0.28508005f, -0.20458882f, -0.49151111f, -0.00996042f, 0.01377284f, 0.02207016f, 0.17305985f, 
    0.02990696f, -0.07437326f, -0.03487562f, 0.00575084f, 0.23636922f, 0.07212240f, 0.18260790f, -0.00495207f, 
    0.05747733f, -0.20148778f, -0.01039684f, 0.12779038f, -0.01720740f, -0.02860233f, -0.10355665f, -0.28231591f, 
    -0.91414630f, -0.34478825f, -0.24431093f, -0.40838236f, 0.08622876f, -0.14458238f, -0.21483104f, 0.00640278f, 
    0.06681103f, 0.17225820f, -0.06431240f, -0.03062262f, -0.09989448f, -0.11863755f, -0.29338092f, -0.09495244f, 
    -0.05333260f, -0.05826858f, -0.07147519f, -0.12249595f, -0.16176519f, 0.21439810f, -0.05247978f, -0.18803626f, 
    0.16118781f, -1.39470410f, -0.72656262f, 0.87260181f, -0.27097324f, -0.26600078f, 0.23918638f, -0.14132449f, 
    -0.12793002f, -0.02885050f, 0.07936118f, -0.08703194f, -0.00897670f, 0.09799878f, 0.03256183f, 0.00506867f, 
    0.02788324f, 0.00594253f, -0.05098638f, 0.30845019f, -0.00945234f, 0.37999186f, 0.16044395f, 0.24394839f, 
    -0.82126611f, 1.39006829f, -0.33954084f, -0.53377050f, -0.44173929f, 0.01033312f, -0.27802560f, -0.08859347f, 
    0.03556303f, 0.02010269f, 0.05174963f, -0.03219157f, -0.67365003f, 0.75408536f, 0.68616527f, 0.08226373f, 
    -0.11272565f, -0.02103375f, -0.00101991f, 0.11558410f, -0.06697734f, 0.25516197f, 0.33358786f, 0.06159674f, 
    -0.46774650f, -0.61052161f, -0.05597100f, 0.90740985f, 0.28128585f, 0.13846608f, -0.00574465f, -0.24427046f, 
    0.02066400f, 0.08936688f, 0.04423312f, 0.08713810f, -0.38084003f, -0.43474784f, -0.27720356f, 0.57321477f, 
    0.15649237f, 0.17387933f, 0.19191049f, 0.41254264f, 0.18174489f, 0.35789749f, 0.00765587f, 0.14455456f, 
    0.00531613f, -0.10142703f, -0.19575751f, 0.06490386f, -0.09483831f, 0.29703793f, 0.19063036f, -0.10386514f, 
    -0.00877894f, 0.02390376f, -0.08805151f, -0.00437336f, 0.54912388f, -0.07388604f, 0.15033062f, -0.31079814f, 
    0.15375121f, -0.07724684f, 0.13894069f, 0.06974081f, -0.03359265f, 0.11447252f, -0.14686781f, -0.08761153f, 
    -0.61901337f, -0.72632414f, -0.19647543f, -0.43206283f, -0.17057914f, -0.77331269f, -0.50981277f, -0.19431010f, 
    -0.07104866f, -0.03446986f, -0.07548267f, -0.02883247f, -0.13944316f, -0.39113325f, 0.04907305f, -0.15249306f, 
    -0.30601168f, -0.10033971f, 0.06053128f, -0.59371209f, -0.15923283f, 0.01056053f, -0.13668753f, -0.02221345f, 
    0.01141009f, -0.33187425f, -0.12845391f, 0.05918572f, 0.01709605f, 0.02304015f, 0.07305103f, 0.17135470f, 
    0.16163802f, 0.06406716f, -0.17216305f, -0.12843226f, 0.17607549f, -0.86904907f, -0.58503264f, -0.33529255f, 
    0.14726748f, 0.33821452f, 0.32545370f, -0.08136056f, -0.03107614f, 0.06457222f, 0.02028719f, 0.21165764f, 
    -1.06223238f, -0.08525919f, 0.11128888f, 0.38225433f, -0.21774210f, 0.23749520f, 0.08482677f, 0.09426116f, 
    -0.01321342f, -0.01313375f, 0.06855433f, -0.04016409f, -0.62368661f, -0.48030844f, -0.73468131f, -0.03827871f, 
    -0.25353050f, 0.05450631f, 0.24218836f, -0.29815483f, -0.01652935f, 0.11237223f, -0.03337117f, 0.23531166f, 
    -0.62934977f, -0.44041881f, 0.74565089f, 0.47129443f, -0.08078103f, -0.07244957f, -0.00601699f, -0.09643787f, 
    -0.03654196f, -0.38609794f, 0.10665623f, 0.05469176f, 0.01659964f, 0.09435806f, 0.31316036f, -0.25292572f, 
    0.08276519f, 0.04490264f, -0.04217656f, -0.04868894f, 0.16047983f, 0.01738952f, 0.00975475f, -0.09411272f, 
    0.97236377f, -0.12631139f, -0.49806160f, 0.15137519f, 0.05984806f, 0.20567200f, -0.29733160f, 0.16916429f, 
    0.03635289f, -0.02074610f, -0.06943788f, 0.02401629f, 0.23121648f, 0.19360460f, 0.02658995f, -0.27943587f, 
    0.10133105f, -0.05306279f, -0.08135960f, -0.20181116f, -0.07821789f, -0.32172772f, -0.17983188f, -0.56036597f, 
    -1.04654062f, -0.52462077f, -0.80498898f, -0.21371156f, 0.32901779f, -0.24584319f, 0.29302093f, 0.08360425f, 
    -0.07041136f, 0.10639679f, 0.08343792f, 0.07198054f, 1.18159592f, -0.97598612f, -0.21594870f, -0.31624737f, 
    0.00333275f, -0.13648297f, -0.03284942f, -0.12622309f, 0.15356158f, 0.06577110f, 0.04627072f, -0.07716559f, 
    0.09455413f, -0.37686223f, 0.26954532f, -0.65887541f, -0.11275285f, -0.06423896f, 0.04654214f, 0.03510080f, 
    -0.20392384f, 0.18843564f, -0.29365879f, -0.01735897f, 0.11040721f, -0.95383930f, 0.62301368f, -0.87812430f, 
    0.20011696f, -0.07718012f, 0.05030099f, 0.09216456f, 0.02086388f, 0.13342190f, -0.08169199f, -0.09357153f, 
    0.01460815f, 0.31448901f, -0.50389332f, 0.06376057f, 0.12066414f, 0.32646605f, -0.18411268f, -0.08991551f, 
    -0.01321704f, -0.07419267f, 0.03986452f, 0.05845999f, -0.52213657f, 0.27933750f, -0.03859594f, -0.09390657f, 
    0.03762620f, 0.14670256f, -0.02834143f, -0.01095575f, -0.04245067f, 0.00626426f, 0.02241273f, -0.11275250f, 
    -1.00594771f, -0.40392843f, -0.31462479f, 0.09808614f, 0.24476634f, -0.07557110f, 0.17643729f, 0.18713818f, 
    0.08904698f, 0.00631591f, 0.05509945f, -0.00938473f, 0.39039984f, -0.03449845f, 0.02885202f, 0.26551983f, 
    -0.15513958f, -0.13878112f, -0.00992276f, -0.28246343f, 0.04703559f, 0.09168557f, -0.10081144f, -0.00339904f, 
    0.10279657f, 0.07694436f, 0.09101137f, -0.16767688f, 0.00199226f, -0.01781009f, -0.02190105f, -0.07110132f, 
    0.03411059f, -0.15185457f, 0.05521920f, 0.07949278f, -0.54081291f, 0.42931005f, -0.24580257f, 0.21845134f, 
    -0.21344838f, -0.13477673f, 0.11726761f, 0.10761886f, 0.06762267f, -0.04227028f, 0.06900293f, 0.05170541f, 
    0.35871026f, -0.96329123f, -0.37972817f, -0.04488655f, -0.07143471f, 0.13926990f, 0.02549502f, 0.17462057f, 
    0.03391117f, 0.10081063f, -0.09227900f, -0.02194505f, -0.24567139f, -0.00882530f, -0.30336952f, -0.14479950f, 
    0.15337744f, 0.06319078f, 0.35231209f, 0.17632146f, -0.20862873f, 0.02172540f, -0.25550756f, 0.05662348f, 
    0.61311609f, -1.14704239f, -0.37175035f, -0.30646518f, 0.02195515f, -0.00121536f, 0.03734807f, -0.01321310f, 
    0.12937319f, 0.26916310f, 0.08720997f, 0.10701988f, -0.58738750f, 0.39873129f, 0.17414179f, -0.28026208f, 
    -0.19133784f, -0.12628059f, -0.13285074f, -0.16534582f, -0.20201632f, -0.00558490f, -0.39433262f, 0.06777640f, 
    -0.13673894f, -0.51552242f, -1.01690376f, 0.04011856f, 0.14691700f, -0.37345856f, 0.08696066f, 0.30794862f, 
    -0.01067694f, -0.07227105f, 0.14766677f, 0.25448272f, 0.43525073f, -0.17243965f, -0.50211418f, -0.41851124f, 
    -0.18265596f, -0.17314318f, -0.04354961f, -0.13514151f, 0.27965549f, -0.22452505f, 0.20522161f, 0.18248844f, 
    0.06021015f, -0.54097617f, -0.61056131f, 0.27477485f, -0.15102057f, 0.19861956f, -0.04609900f, 0.01243343f, 
    -0.05041489f, -0.26128471f, -0.09809870f, -0.09379698f, -0.41083777f, -0.35737038f, -0.07817404f, -0.00590552f, 
    -0.06683402f, 0.16716082f, 0.07223129f, 0.06898634f, -0.13426954f, 0.15758844f, -0.16633584f, -0.42485178f, 
    1.10843790f, 0.18076782f, -0.12784190f, 0.07102581f, -0.07362162f, 0.23516652f, 0.25904953f, -0.34035450f, 
    0.16120356f, -0.12851244f, 0.11260754f, 0.02508302f, 0.55921191f, 0.09218207f, -0.48981678f, -0.42677155f, 
    0.08380308f, -0.12874021f, -0.03892968f, -0.10389955f, -0.00491394f, -0.06857222f, 0.32467997f, 0.19432786f, 
    0.33230320f, 0.38940731f, -0.02880703f, 0.30554447f, 0.24989323f, 0.07414408f, -0.12965262f, 0.25474671f, 
    0.14217526f, -0.05664384f, 0.14521624f, -0.00008572f, -0.55489326f, 0.06270985f, -0.00008526f, 0.31593347f, 
    -0.09973788f, 0.06052766f, -0.04418499f, -0.11405747f, -0.01750346f, 0.05461510f, 0.12235741f, 0.02025419f, 
    -0.60170865f, -0.60359055f, -0.33878943f, 0.06098527f, 0.04152324f, -0.01519406f, -0.14626153f, 0.09653747f, 
    -0.03396828f, 0.08088034f, 0.05384727f, 0.20673624f, 0.27021140f, 0.11342287f, -0.21046422f, -0.40045100f, 
    0.16600205f, -0.30467945f, -0.45989212f, 0.15799236f, -0.01672813f, 0.21409531f, 0.00084228f, 0.09833515f, 
    -0.06958897f, -0.04456847f, -0.14461261f, -0.07382872f, 0.03142254f, -0.04578748f, 0.03872696f, 0.11565590f, 
    -0.03670322f, 0.28378314f, 0.18191712f, 0.02412732f, -0.32940853f, 0.30570057f, 0.42915392f, 0.18364140f, 
    0.04206956f, -0.33789849f, 0.12453911f, 0.20539886f, 0.06890014f, -0.04845298f, 0.09272030f, -0.00532912f, 
    0.24337144f, -0.43031436f, -0.66667837f, 0.39996931f, 0.11773332f, 0.23092224f, 0.33159295f, -0.02359391f, 
    -0.06492352f, -0.04055129f, 0.05561107f, 0.04805877f, -0.24494857f, -0.35672963f, -0.20642599f, -0.01911225f, 
    0.06294387f, 0.09931859f, 0.12786245f, -0.35896432f, -0.09793755f, -0.23489836f, -0.05459671f, -0.65744686f, 
    0.17818257f, -0.00377150f, 0.14430155f, -0.03166860f, -0.05969076f, -0.25503007f, 0.01131886f, 0.34979108f, 
    -0.00611209f, 0.20252375f, -0.00827513f, -0.15410928f, 0.00459416f, -0.50488394f, 0.00700313f, -0.11761009f, 
    0.08262186f, 0.23000826f, 0.09735956f, 0.01392031f, 0.11004380f, 0.00888729f, 0.20490286f, 0.08303497f, 
    -0.22937644f, 0.18902673f, 0.52544439f, -0.00371228f, -0.06922725f, -0.40413687f, -0.01312386f, -0.08926975f, 
    0.12643786f, -0.02041246f, 0.03019758f, -0.02136594f, 0.00050264f, -0.39072475f, 0.26438597f, 0.39250731f, 
    0.12760347f, 0.08279471f, 0.08577526f, -0.08131620f, 0.08142690f, 0.13077994f, 0.11945846f, -0.16447254f, 
    -0.15130801f, 0.25946221f, 0.61562502f, -0.55296803f, 0.22049204f, -0.27655202f, 0.06161136f, 0.15884410f, 
    -0.21849543f, 0.05493670f, 0.02144696f, -0.03019233f, 0.19131771f, 0.17300773f, 0.63523179f, 0.40118065f, 
    -0.04460666f, -0.30676785f, -0.20062290f, -0.38484213f, -0.10316724f, 0.03941209f, 0.15467595f, 0.05700093f, 
    -0.94505250f, -0.64325160f, -0.28687537f, -0.13132031f, -0.04668313f, -0.12320372f, 0.11892228f, 0.24157150f, 
    0.07511078f, 0.04928640f, 0.03191262f, -0.01803827f, 0.21585453f, -1.78014588f, 0.56291384f, 0.03229469f, 
    0.19464691f, 0.03861806f, 0.01105487f, -0.25946930f, -0.32090020f, 0.19180365f, 0.17429301f, -0.07713994f, 
    -1.14778376f, -0.14731212f, -1.21926117f, 0.10683633f, -0.07273053f, -0.17998560f, 0.23339315f, 0.04123812f, 
    0.10611994f, -0.20173439f, 0.07785896f, 0.10359932f, -0.11703668f, -0.37707210f, -0.29262096f, -0.19446176f, 
    -0.00382213f, 0.10042392f, 0.26542825f, 0.29695418f, -0.13769738f, -0.03586558f, -0.08954976f, -0.14014484f, 
    -0.13101406f, 0.07712635f, 0.19141598f, -0.48066115f, -0.10451858f, -0.04803806f, -0.43445933f, 0.26104850f, 
    -0.03842506f, -0.03898479f, 0.08663765f, -0.05923894f, -0.25986114f, -0.12724961f, -0.37524346f, 0.16309805f, 
    0.33546188f, 0.30405745f, -0.21894395f, 0.02615987f, 0.10141881f, -0.03952609f, -0.24779998f, -0.35659653f, 
    -0.30253696f, 0.36100075f, -0.05290471f, 0.22705695f, -0.00078213f, 0.07190069f, 0.05957502f, -0.50876492f, 
    0.41383842f, 0.21826085f, -0.34350723f, -0.03847686f, -0.28138158f, 0.82244700f, -1.12886286f, 0.12579072f, 
    0.05274111f, 0.08435060f, 0.39371783f, 0.05683048f, -0.14492619f, -0.10303941f, -0.14840963f, -0.09666876f, 
    0.40494639f, -0.85870081f, 0.21146742f, -0.42069274f, -0.14527053f, 0.04428329f, -0.03098548f, -0.00377384f, 
    0.16683070f, -0.16493051f, 0.07010271f, 0.04007859f, 0.10470712f, 0.05486789f, -0.19419263f, -0.09222404f, 
    0.06431825f, 0.00093712f, -0.01416988f, 0.25928873f, -0.02625075f, 0.24403349f, 0.13547632f, 0.14590342f, 
    -0.50298887f, 0.16121258f, -0.66951835f, 0.33191958f, -0.00202538f, 0.03018717f, 0.11964024f, -0.04988895f, 
    0.00694396f, 0.28418589f, 0.05021081f, 0.10329892f, -0.45991951f, 0.55592978f, -0.17994750f, -0.47319567f, 
    -0.32744661f, -0.22103433f, -0.18608595f, -0.11857389f, -0.09756070f, 0.07505190f, -0.05797189f, -0.01418584f, 
    -0.68619096f, -0.02939395f, 0.13012969f, -0.01491811f, -0.14267260f, 0.13264619f, 0.23721966f, 0.36742181f, 
    -0.21308024f, -0.08723016f, -0.03771025f, -0.01991131f, -0.68537283f, 0.33305708f, 0.21748410f, -0.27192622f, 
    -0.27974814f, -0.00382802f, -0.13776319f, -0.15775061f, 0.28712118f, -0.30942655f, -0.00616127f, 0.00810824f, 
    -0.61520487f, 0.11776650f, -0.11151544f, 0.55153471f, -0.02070371f, 0.19659622f, -0.41440377f, 0.16197778f, 
    0.03770220f, -0.00288325f, 0.05045130f, -0.09504947f, 0.51233715f, -0.08629072f, 0.04464863f, -0.27259037f, 
    0.14561348f, -0.14538170f, -0.31469518f, 0.11263257f, -0.20328753f, 0.14401595f, -0.26542479f, -0.35654697f, 
    -0.74349332f, 0.90528905f, -0.05795351f, 0.26262882f, -0.34800294f, 0.38999870f, -0.57869816f, -0.05444515f, 
    0.14292859f, -0.07803874f, -0.08292527f, -0.02287081f, -0.69665468f, 0.43368250f, -0.77644920f, 0.38161683f, 
    -0.15074474f, 0.26785532f, -0.09796139f, 0.10855313f, 0.22141790f, -0.17677386f, -0.08326171f, -0.10406689f, 
    0.49081239f, -0.13038632f, 0.43398422f, 0.34697372f, -0.19483559f, 0.17787689f, -0.04056079f, 0.18382193f, 
    0.09668929f, 0.11924555f, 0.11453577f, 0.01378278f, 0.03041518f, -0.61004442f, 0.65893912f, 0.73697031f, 
    -0.09929637f, -0.17239663f, -0.28258967f, -0.02000658f, 0.02657738f, 0.10839046f, 0.19767500f, 0.22976449f, 
    0.11192871f, -0.34940982f, 0.11471710f, 0.17334162f, -0.35639980f, -0.10620119f, -0.26643923f, 0.36257121f, 
    0.21219930f, 0.05156407f, 0.18082070f, 0.30350399f, -0.17002052f, -0.34454265f, 0.43884027f, 0.22561602f, 
    -0.14185527f, 0.10243762f, 0.29149786f, -0.05579459f, -0.00656192f, -0.10408564f, 0.31660500f, 0.29096076f, 
    -0.16237408f, 0.22825170f, -0.51673299f, -0.00884516f, -0.13108940f, -0.20502730f, 0.37701315f, 0.02076508f, 
    -0.16346738f, 0.18200284f, 0.11663038f, 0.30829746f, -0.33380377f, -0.61728340f, -0.33982500f, -0.13653584f, 
    -0.22148472f, 0.19117188f, 0.28678256f, -0.26697227f, -0.13360578f, 0.13695003f, 0.03159021f, 0.09278312f, 
    -0.47985655f, 0.14915611f, 0.02603432f, 0.44914109f, 0.17156482f, -0.27543813f, -0.12658601f, 0.02405049f, 
    -0.16848487f, 0.19627856f, 0.13567699f, -0.35667309f, -0.20737161f, -0.02731424f, -0.31883454f, -0.19270472f, 
    0.02486912f, 0.12301841f, -0.16970646f, -0.26377922f, 0.09227309f, 0.05000775f, -0.52937281f, -0.38294378f, 
    -0.32945126f, -0.65252185f, 0.19695969f, 0.44982585f, -0.13469616f, 0.06988511f, -0.18522012f, -0.10006125f, 
    0.08230338f, 0.12531328f, 0.16056484f, 0.01902124f, -0.07038753f, -0.12128314f, -0.43124127f, 0.43308672f, 
    -0.07793696f, 0.08733857f, 0.10262755f, 0.02865548f, -0.18122849f, -0.03534779f, 0.24946105f, 0.07635649f, 
    0.33871707f, -0.49178806f, 0.12882647f, -0.51729524f, 0.34710670f, -0.40930614f, 0.05098092f, 0.00150818f, 
    -0.01023334f, 0.18490072f, 0.40835360f, 0.07801597f, -0.01967336f, -0.06728425f, -0.18935940f, 0.00547101f, 
    0.00976360f, 0.18646996f, -0.10418617f, -0.12399046f, 0.02919651f, 0.29878026f, -0.02710323f, -0.27030313f, 
    -0.10787829f, -0.55396187f, 0.66271722f, -0.19186975f, -0.26142067f, -0.27576175f, 0.09538145f, -0.10788082f, 
    -0.17241344f, 0.01751076f, -0.01857805f, -0.07126828f, -0.51958150f, -0.02303524f, -0.36308467f, -0.41609386f, 
    0.03536477f, -0.12742551f, -0.06264295f, -0.15976591f, -0.02466675f, -0.01906635f, 0.05313124f, -0.03602087f, 
    0.09557083f, -0.46776572f, 0.13381167f, 0.33738449f, 0.22123410f, -0.09709035f, -0.06342089f, -0.06688625f, 
    0.28624940f, 0.08017550f, 0.06212455f, 0.23000821f, -0.64181310f, 0.37928915f, -0.94826156f, 0.54013723f, 
    0.01632272f, -0.21368732f, 0.03557570f, -0.05651323f, -0.03914425f, 0.06664007f, 0.15351570f, -0.00823517f, 
    0.37355798f, -0.36627012f, 0.51571280f, -0.12182252f, 0.17731030f, -0.31319270f, 0.24286444f, -0.04596578f, 
    -0.18282497f, 0.05553672f, -0.14501154f, 0.01389663f, -0.10394429f, 0.15333955f, 0.97923386f, -0.22184207f, 
    -0.04413905f, 0.23459551f, -0.01721655f, -0.08649101f, -0.24761111f, 0.11853646f, 0.05510052f, 0.04050625f, 
    -0.20911451f, 0.01653753f, 0.23491675f, -0.23874038f, -0.32439536f, -0.05966102f, -0.09601396f, -0.08177886f, 
    -0.00401905f, -0.08612433f, -0.19562645f, -0.49530423f, -0.14596620f, 0.38369283f, -0.34357905f, 0.03316078f, 
    -0.14396243f, 0.18833348f, 0.19141428f, -0.15120633f, 0.02140193f, -0.14550142f, 0.26440826f, -0.46213385f, 
    -0.01922579f, 0.08610308f, 0.32825011f, -0.26394042f, -0.27810615f, 0.18532352f, 0.03765658f, 0.06080917f, 
    -0.00617510f, -0.13075119f, 0.00123794f, -0.43845254f, 1.02854800f, -0.12510653f, 0.84894198f, -0.79061639f, 
    0.16002767f, -0.10177840f, -0.27489471f, 0.22590078f, -0.11919829f, 0.05963408f, -0.12507686f, 0.01675711f, 
    -0.20105886f, 0.70573074f, -0.73079735f, 0.19741029f, -0.10390739f, -0.05598148f, 0.42874652f, -0.12810096f, 
    0.11524454f, 0.08419690f, 0.05762083f, 0.02947813f, -0.07783884f, -0.08673778f, -0.24158767f, -0.28572556f, 
    -0.17908125f, -0.52383876f, -0.06319310f, 0.25416028f, 0.24573767f, 0.16415767f, 0.21667333f, -0.02148908f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.38229996f, 0.15315890f, 0.14976326f, -0.14412545f, -0.21980086f, 0.14963940f, 0.11132145f, -0.18329568f, 
    0.04237607f, -0.01054499f, 0.05075721f, -0.13736106f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
