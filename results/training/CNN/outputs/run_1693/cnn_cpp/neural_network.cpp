#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.00882498f, 0.47062045f, 0.53350985f, -0.79430306f, -0.33100107f, -0.08011580f, -0.26682198f, 0.52887857f, 
    0.13392222f, -0.08023684f, -0.74735183f, 0.65601999f, 0.58840078f, -0.39033198f, -0.03433943f, -0.48416930f, 
    -0.51304871f, 0.52520937f, -1.00909400f, -0.66802180f, 0.15650600f, 0.18524753f, -0.17325857f, 0.47602719f, 
    -0.09948223f, -0.06793452f, 0.45990339f, 0.01168691f, 0.17877838f, -0.07652567f, 0.36606455f, 0.30367693f, 
    -0.62909311f, 0.18380833f, 0.25842419f, -0.13923351f, -0.94200683f, -0.50131375f, 0.73060101f, 0.46224990f, 
    0.10572062f, -0.65169138f, 0.04576987f, -0.39005336f, -0.53037602f, -0.35476756f, -0.43195227f, -0.37864786f, 
    0.31446859f, 0.51938379f, 0.24452879f, -0.46619532f, -0.28594512f, -0.43661681f, 0.38954902f, 0.18724559f, 
    0.33181629f, -0.42439961f, -0.73128855f, -0.93457645f, 0.02609304f, -0.57575816f, -0.37548849f, 0.37611014f, 
    -0.00179010f, 0.55584198f, -0.30141816f, -0.20878938f, -0.34504253f, 0.26617283f, 0.12305737f, 0.19530343f, 
    -0.53711325f, 0.76184052f, -0.33688676f, -0.49229202f, 0.97514117f, 0.23509212f, -0.34440765f, -0.43014085f, 
    -0.25946161f, 0.13829412f, -0.66761869f, 0.57995051f, 0.81113881f, -0.45343605f, -0.55266041f, 0.13670379f, 
    0.08290402f, 0.05351085f, -0.02198234f, -0.47732309f, -0.70795351f, 0.79618245f, 0.38391316f, -0.02637004f, 
    -0.33410507f, -0.18803848f, 0.03273881f, -0.96777266f, -0.89383006f, 0.46563324f, -0.03728861f, -0.39104599f, 
    0.01605831f, 0.43746290f, -0.35240620f, -0.21832386f, -0.31034845f, -0.20422414f, 0.58929384f, 0.53631347f, 
    -0.79207057f, -0.26390129f, 0.34140193f, -0.42665100f, 0.06237200f, 1.01770306f, -0.62354934f, -0.57969862f, 
    0.82347554f, -0.74961412f, 0.42873055f, -0.34439036f, 0.40391845f, -0.28128284f, -1.42429304f, 0.96733028f, 
    0.33969921f, -0.26520461f, -0.57057303f, 0.16872847f, -0.40852320f, 0.11747793f, -0.28493327f, 0.18543184f, 
    -0.54612035f, -0.07880124f, -0.35325718f, 0.01662116f, -0.17348433f, 0.03509110f, 0.24944806f, 0.52231669f, 
    0.22112517f, -0.68631148f, -0.72851598f, 0.25567108f, 0.57860130f, 0.54638708f, 0.08345334f, -0.13751239f, 
    -0.29229051f, -0.22168793f, -0.53838706f, 1.11813700f, -0.55847257f, -0.40208614f, 0.11426172f, 0.21443023f, 
    0.16238654f, 0.01675004f, -0.35551894f, 0.45361501f, 0.12323231f, 0.00486632f, 0.12372863f, 0.36694318f, 
    0.29800677f, 0.03193313f, -0.15841705f, 0.44943446f, -0.12536378f, 0.00327464f, 0.27210921f, -0.07384802f, 
    -0.43645978f, 0.38040027f, -0.40624830f, 0.31202206f, -0.81484520f, 0.31393558f, 0.55180752f, -0.14778420f, 
    -0.02668967f, -0.30815849f, -0.05215035f, -0.51442611f, -0.48466897f, 0.32180476f, 0.28864512f, -0.51286680f, 
    -0.06517184f, -0.46855319f, -0.12548634f, 0.34229046f, -0.11548055f, 0.28951457f, -0.58632737f, 1.11788833f, 
    -0.03591225f, -0.76718611f, 0.52471989f, -0.50359714f, -0.25632909f, 0.37455213f, -0.18202831f, -0.79991543f, 
    -0.21169637f, 0.25607789f, -0.70603836f, -0.24674278f, -0.23048399f, 0.10640833f, -0.58022964f, -0.67790192f, 
    0.80865079f, 0.20118910f, -0.70047575f, 0.15513717f, 0.26344249f, 0.20748857f, -0.35298032f, 0.14311206f, 
    -0.28200853f, 0.37880862f, 0.43477532f, 0.23282124f, -0.43347642f, 0.19901094f, 0.11964239f, 0.23019357f, 
    -0.29997563f, 0.11843622f, -0.83206910f, -0.27074125f, -0.61382270f, 0.16189630f, 0.04995865f, 0.41332409f, 
    0.09606889f, 0.11574403f, 0.39261103f, -0.51407874f, 0.32727957f, 0.45542285f, 0.12565473f, -0.12520219f, 
    0.01095712f, 0.27609494f, -0.44298515f, 0.15173848f, 0.37299693f, 0.27054715f, -0.47333941f, -0.04021770f, 
    -0.35236114f, -0.62342137f, -0.41617084f, -0.40776145f, -0.72414708f, 0.49708423f, 0.53119504f, 0.07713405f, 
    -0.56034774f, 0.05770097f, 0.07020811f, -0.23663868f, 0.31823578f, -0.00310320f, -0.88461798f, -0.75598079f, 
    -0.06819858f, 0.52320904f, -0.52567619f, -0.74213862f, -0.25474718f, -0.37240133f, -0.47180808f, 0.57247663f, 
    0.13244608f, -0.84952676f, -0.43191293f, -0.04363523f, 0.03901223f, 0.39078784f, 0.39109981f, -0.20987582f, 
    -1.33686543f, 0.82524043f, 0.02146964f, 0.23088400f, 0.32036558f, 0.47260553f, 0.00259316f, -0.36742461f, 
    -0.19054951f, 0.16539675f, 0.21186236f, -0.42402646f, -0.45697683f, 0.28470662f, 0.16792282f, -0.02845703f, 
    0.31039491f, 0.12252623f, 0.10912076f, -0.10900575f, -0.02262012f, -0.51521933f, 0.08227667f, 0.59812838f, 
    -0.13096356f, -0.18274881f, 0.40105495f, 0.58295667f, -0.12076943f, 0.19355257f, -0.30714345f, -0.26440728f, 
    0.55923158f, -0.59262961f, -0.31909603f, 0.39789468f, -0.50492126f, -0.10989209f, 0.44221503f, 0.15903145f, 
    0.48661739f, -0.12242190f, -0.50104457f, -0.21664979f, 0.54219407f, -0.45711300f, -0.41257262f, 0.08256578f, 
    -0.19279823f, -0.86734432f, -0.64836454f, 0.18311045f, 0.16481853f, 0.32306296f, -0.12472655f, 0.13399598f, 
    -0.62166548f, -0.13459501f, -0.47350630f, -0.53234351f, -0.07410305f, 0.42234820f, 0.10813431f, 0.10869939f, 
    -1.08977950f, -1.02692354f, 0.59542817f, 0.75648183f, 0.42977008f, 0.15421543f, -0.02156940f, -0.17963563f, 
    0.54088223f, -0.40206614f, 0.26142475f, -0.36282405f, -0.33770835f, -0.36487564f, 0.06544148f, 0.23077179f, 
    0.35881782f, 0.58754575f, 0.32109013f, -0.71001506f, -0.65267897f, 0.29210937f, 0.52221274f, -0.38259962f, 
    -0.66712767f, -0.50716656f, -0.12622155f, -0.38034502f, -0.20227246f, -0.13050124f, -0.63637549f, -0.27606949f, 
    -0.21154206f, 0.26451302f, 0.34446043f, -0.28309289f, -0.90606123f, -0.04242802f, -0.92502737f, -0.71488786f, 
    -0.33911383f, 0.09944449f, -0.30581582f, 0.24512464f, -0.59062624f, -0.11912765f, -0.04848720f, 0.34535879f, 
    -0.43938559f, -0.03430787f, -0.10244197f, 0.11350778f, 0.49353829f, -0.72549188f, -0.59798962f, 0.02884867f, 
    0.20785031f, -0.20156506f, -0.41696045f, -0.33425888f, -0.27744350f, -0.38631350f, -0.72557378f, -0.31105244f, 
    0.26760894f, 0.26019830f, -0.15268435f, -0.37301409f, 0.10341112f, 0.42318761f, -0.00865577f, 0.38550046f, 
    0.13232185f, -0.19190371f, -0.06174714f, 0.47017643f, -0.32291269f, 0.51129270f, -0.33567959f, -0.35065353f, 
    0.48824865f, -0.76141655f, -0.38112357f, -1.06999946f, -0.56202745f, -0.29044276f, 0.27211595f, -0.14074329f, 
    0.35429290f, -0.59687543f, -0.11919056f, -0.53392076f, -0.07863760f, -0.38911501f, -0.55539805f, -0.14709793f, 
    -0.30481476f, 0.31578127f, 0.24732897f, 0.53379381f, -0.68818098f, -0.12317295f, -0.01366450f, 0.24578443f, 
    -0.04095931f, 0.02370038f, -0.01410500f, 0.04296755f, 0.27306905f, -0.15868481f, 0.52893335f, 0.39675573f, 
    0.09669829f, 0.21444713f, -0.26502329f, 0.09520201f, -0.55071378f, -0.05440099f, -0.26162806f, 0.17813645f, 
    -0.28822407f, 0.20190819f, 0.09592243f, -0.08436036f, -0.39563584f, 0.48060378f, 0.39825261f, -0.47301376f, 
    0.00950055f, 0.41513517f, -0.48696965f, -0.32917801f, 0.33679286f, -0.05868394f, -0.59526992f, -0.19384503f, 
    -0.74434727f, 0.17520873f, -0.24460527f, -0.50383711f, -0.09091126f, 0.65854448f, -0.36694363f, -0.61351764f, 
    0.09684713f, -0.42394432f, 0.35266134f, -0.10831209f, 0.31900159f, 0.25935557f, 0.00481584f, 0.14039077f, 
    0.07538393f, -0.09648993f, 0.32545897f, -0.07161441f, 0.36774454f, 0.26418638f, -0.14538610f, 0.35417315f, 
    0.00075335f, 0.15003368f, 0.01988011f, -0.92503476f, -0.03674120f, 0.77402830f, -0.33980846f, -0.31258178f, 
    0.23705743f, -0.17402318f, -0.07221840f, -0.45786747f, -0.35133278f, 0.54785222f, -0.35638890f, 0.30268320f, 
    0.28345540f, -0.10180931f, 0.44319040f, 0.74838388f, -0.32712308f, -0.47596556f, 0.30713680f, 0.14512876f, 
    -0.34885696f, 0.14372586f, 0.15016828f, -0.11591336f, -0.49961764f, 0.55181044f, -0.41411465f, 0.56475937f, 
    0.13238530f, -0.22097363f, -0.14799429f, 0.27310297f, -0.40321779f, 0.21405494f, -0.12627341f, 0.14412582f, 
    0.15728332f, -0.06217574f, -0.31680822f, -0.04012286f, 0.33196631f, 0.32507324f, -0.99318886f, -0.25638252f, 
    0.72758818f, -0.20022769f, 0.19878113f, 0.18352793f, -0.40066189f, 0.01583932f, 0.32538715f, 0.10297195f, 
    0.40176269f, -0.16664369f, 0.00750399f, 0.39147270f, 0.20544931f, -0.41297850f, 0.43461698f, 0.09581291f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.08008078f, -0.13411498f, -0.08473229f, 0.06527320f, -0.10261863f, 0.03247042f, 0.04618936f, 0.04968504f, 
    -0.07195359f, 0.12145694f, 0.06367874f, 0.14724587f, 0.04082347f, 0.13944542f, 0.14360498f, 0.03653586f, 
    0.02604190f, 0.02356035f, -0.15759397f, 0.13065252f, -0.03156632f, 0.11898528f, 0.06676165f, 0.03521093f, 
    0.25826743f, -0.03982510f, 0.05590640f, 0.27051669f, 0.12345304f, 0.14076969f, -0.32463908f, 0.00377370f, 
    0.09538943f, 0.06482212f, 0.15953234f, 0.13891879f, -0.00271302f, 0.00525175f, -0.01720218f, 0.06375717f, 
    0.07458972f, -0.13795489f, 0.14747773f, -0.25572720f, 0.19875398f, -0.08436588f, 0.20779441f, 0.16910750f, 
    0.00958846f, -0.21807973f, 0.17512727f, -0.20434856f, 0.05959599f, 0.26780710f, -0.17959276f, 0.02997160f, 
    0.16007638f, 0.05255427f, -0.06975797f, 0.34536916f, -0.04351101f, -0.18105985f, 0.18417442f, -0.13390183f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.05448386f, -0.00116698f, 0.03007616f, -0.12268053f, -0.09771054f, -0.04574080f, 0.03788574f, -0.13660067f, 
    0.05536308f, -0.09402227f, 0.05460228f, 0.05015439f, -0.01266859f, 0.01056461f, 0.00833389f, 0.00797749f, 
    -0.00198966f, -0.01509684f, -0.05198398f, -0.03038752f, 0.45418841f, 0.07284694f, -0.05063531f, -0.30737761f, 
    0.05198574f, -0.10777314f, -0.05624176f, 0.01438159f, 0.05993993f, -0.00045501f, 0.07054153f, 0.07539490f, 
    0.04905099f, -0.02481648f, -0.06691118f, -0.18248968f, 0.09877433f, 0.04636592f, 0.02787459f, -0.13784745f, 
    0.23033053f, 0.20112598f, 0.22929689f, -0.17910236f, 0.09322564f, 0.03946314f, 0.11444387f, 0.11635795f, 
    -0.04509828f, -0.13983972f, -0.05016611f, -0.11893045f, -0.01575021f, -0.00144382f, 0.01787028f, -0.02074331f, 
    0.03108677f, 0.03123038f, -0.00590486f, 0.00616367f, 0.04336840f, 0.02523141f, -0.03055383f, 0.07258887f, 
    0.01996687f, -0.01166009f, 0.00598025f, -0.00796121f, 0.01113075f, 0.04543842f, -0.11599213f, -0.12263557f, 
    -0.07690376f, -0.03755966f, -0.15849036f, -0.11318511f, -0.07984708f, -0.05306987f, -0.02749169f, -0.01931661f, 
    0.32569981f, 0.17708325f, -0.09886090f, -0.30681652f, -0.02602542f, -0.00218669f, 0.04355706f, 0.03581732f, 
    0.08148424f, 0.04761444f, 0.00963550f, 0.02091371f, -0.04240640f, -0.07150331f, -0.06681997f, 0.03184904f, 
    -0.05576415f, 0.05101648f, -0.05624377f, 0.07847429f, 0.15812764f, -0.00998652f, -0.15643618f, -0.03301220f, 
    -0.14747161f, 0.01603909f, -0.03597952f, 0.06798906f, 0.01256646f, -0.01302186f, -0.00029789f, 0.00942758f, 
    -0.02626817f, 0.04930336f, -0.02861676f, 0.05596470f, 0.02158345f, 0.04138082f, 0.03323288f, 0.04571510f, 
    0.00544956f, 0.19701201f, 0.03438945f, -0.22396599f, -0.02857685f, -0.10408347f, -0.00201711f, -0.09000770f, 
    -0.09476385f, -0.01054287f, -0.00273263f, -0.03684268f, 0.02039155f, 0.01953411f, 0.01810274f, 0.01219419f, 
    0.00337798f, 0.07344705f, -0.00031995f, 0.04832020f, -0.01273284f, -0.03556149f, -0.01245755f, -0.09727706f, 
    -0.02529452f, -0.22752005f, -0.08216052f, -0.01960066f, 0.03797808f, 0.00458139f, 0.02281055f, 0.02550189f, 
    0.06763797f, 0.02356618f, -0.05237013f, -0.01600342f, -0.00415402f, -0.11491431f, -0.08225013f, -0.08337447f, 
    -0.17748332f, -0.18778518f, 0.42066291f, 0.16643715f, 0.00608803f, -0.01864732f, 0.03051960f, -0.03158227f, 
    0.02183046f, 0.05284387f, 0.08977609f, 0.05917794f, 0.09798338f, -0.01010607f, 0.00843982f, -0.14708039f, 
    0.03313719f, -0.02547278f, -0.09539301f, -0.08763351f, 0.13529161f, 0.04543372f, -0.13486035f, -0.09926068f, 
    0.09640138f, -0.22817400f, 0.07597875f, -0.02822364f, -0.18627074f, -0.01776960f, 0.04786897f, -0.04917398f, 
    -0.00446184f, -0.05359941f, 0.00925183f, -0.05074205f, 0.06381399f, -0.09601685f, -0.10754193f, -0.05312701f, 
    0.18725660f, -0.00217475f, -0.35931900f, 0.00029210f, -0.07749756f, 0.06419872f, 0.04852423f, -0.02900235f, 
    -0.21955708f, 0.00131823f, -0.01909003f, 0.01829163f, -0.04647257f, 0.02294276f, 0.07919067f, 0.01841438f, 
    0.06025905f, -0.01248308f, -0.00376611f, 0.00263743f, 0.30700356f, 0.13987753f, 0.19516578f, -0.32733560f, 
    -0.00481503f, 0.09335750f, 0.18176135f, 0.09859029f, 0.08347457f, -0.01729182f, 0.03842084f, -0.00313971f, 
    -0.04601843f, 0.01890997f, 0.03228557f, 0.02071023f, -0.02023219f, 0.01836899f, -0.07435856f, -0.01942686f, 
    0.15150794f, 0.14836940f, -0.09876709f, -0.39736101f, 0.05954937f, -0.08431914f, -0.04532839f, -0.13723186f, 
    0.06574506f, -0.00950879f, 0.02827070f, -0.08323751f, 0.02518868f, 0.03083273f, -0.01341308f, -0.05623730f, 
    0.02443299f, -0.04477655f, 0.05348733f, 0.07783317f, -0.09256176f, -0.10092318f, -0.33959788f, -0.00859946f, 
    0.05478805f, -0.12178595f, -0.03084330f, -0.12795614f, -0.12914269f, -0.02681031f, -0.09950536f, 0.06052760f, 
    0.06910674f, -0.12763664f, -0.01091871f, -0.04176275f, -0.07644138f, -0.12362237f, -0.02614563f, -0.03362764f, 
    -0.36826143f, 0.22768852f, 0.15144780f, 0.01034877f, -0.12331931f, -0.29668802f, -0.01966207f, 0.00482555f, 
    0.01257964f, -0.12684162f, 0.01959680f, -0.00615995f, -0.07047745f, -0.01803558f, -0.02277993f, -0.12952697f, 
    -0.00126458f, -0.03362336f, -0.18711953f, 0.13021982f, 0.12743583f, 0.19261762f, 0.03706593f, -0.07183534f, 
    0.00620428f, -0.00533201f, 0.02101309f, 0.11050574f, -0.06467711f, -0.06990211f, -0.03008973f, 0.00580102f, 
    -0.02213258f, 0.02282910f, 0.03372008f, -0.02625371f, -0.01334306f, -0.00629440f, 0.00266293f, -0.07866955f, 
    0.34590346f, -0.33624011f, -0.40701964f, 0.08328361f, -0.02712349f, 0.08974311f, 0.00949558f, 0.04550452f, 
    -0.08843045f, -0.06041675f, -0.00930188f, -0.00400730f, -0.19444425f, -0.01829434f, 0.03844646f, 0.05842491f, 
    0.04083328f, 0.03383454f, 0.03972692f, -0.00555402f, 0.00722253f, 0.12644055f, 0.34370819f, -0.27811745f, 
    0.06271753f, -0.18461071f, 0.15290318f, 0.09741426f, -0.05735878f, -0.05839045f, 0.13956359f, -0.02503013f, 
    -0.04476504f, 0.02176322f, -0.06982824f, 0.02420058f, 0.04323638f, -0.08459942f, -0.07641634f, -0.20528090f, 
    0.00234438f, 0.01908444f, 0.02319004f, 0.02173674f, 0.03799735f, 0.00723047f, 0.01823180f, 0.08116307f, 
    0.05311910f, 0.05100045f, -0.11359888f, -0.06220848f, -0.04913800f, 0.07746003f, -0.02360469f, -0.00658920f, 
    -0.00020355f, 0.02751081f, -0.07704131f, 0.03542779f, -0.01312455f, -0.04471225f, -0.11238632f, -0.01014004f, 
    0.00815468f, -0.11367077f, -0.00557438f, 0.01261754f, 0.00757470f, 0.01656192f, -0.05599657f, 0.03590040f, 
    0.00487816f, -0.02649732f, -0.08624543f, -0.09472010f, -0.07243468f, -0.13758178f, -0.13563043f, -0.11526385f, 
    0.01809543f, 0.11989294f, 0.01673186f, -0.16303490f, 0.04614431f, -0.23921621f, -0.12353346f, -0.03343409f, 
    -0.01021679f, 0.01290282f, 0.01083588f, -0.01478828f, -0.01371483f, 0.00031676f, 0.03193758f, 0.07470382f, 
    -0.04579829f, -0.14135140f, 0.05224149f, 0.05632281f, 0.12218170f, 0.05238423f, -0.09484327f, -0.05361176f, 
    -0.07293519f, -0.05936921f, -0.04530279f, -0.04828989f, 0.02311928f, -0.00388412f, -0.01618426f, -0.01366511f, 
    -0.05127901f, -0.02870889f, -0.01922358f, -0.06891978f, -0.02989376f, 0.00897645f, -0.08071610f, -0.23163287f, 
    -0.29372188f, -0.01906868f, -0.05118057f, 0.07843851f, -0.36690161f, -0.08277303f, -0.06791969f, -0.00918083f, 
    0.02160503f, 0.07508064f, 0.03924759f, 0.02651318f, -0.03325761f, -0.00941805f, -0.01457700f, -0.25511768f, 
    0.05261204f, -0.03414505f, -0.18715596f, -0.09004854f, 0.21909527f, 0.14319876f, 0.17704336f, -0.23676682f, 
    0.00472318f, 0.00934891f, 0.14653033f, 0.02679677f, 0.03498923f, 0.00156268f, 0.00374784f, -0.03525222f, 
    -0.03470658f, -0.12753892f, -0.09949785f, -0.01771567f, -0.14092238f, -0.08685514f, 0.05180641f, 0.04310698f, 
    -0.46207872f, -0.33402887f, -0.44103113f, 0.20519552f, -0.18036853f, -0.00518652f, 0.01592149f, -0.01650978f, 
    0.01576045f, 0.04502718f, 0.00603711f, -0.05052412f, -0.13987079f, -0.05030911f, -0.02471170f, -0.02516605f, 
    0.03766965f, 0.00539129f, 0.04804377f, 0.01282558f, -0.10250700f, -0.05346361f, -0.03366897f, 0.00933701f, 
    -0.02075223f, 0.01537766f, 0.00054445f, 0.01803400f, -0.00551088f, 0.01585712f, 0.00314825f, 0.03456334f, 
    -0.00792102f, 0.05021001f, 0.07096345f, 0.04455575f, 0.00429020f, -0.10363055f, -0.03286362f, -0.02538724f, 
    0.21348719f, 0.19826472f, 0.05446913f, -0.02646423f, 0.04328582f, 0.10513903f, 0.12875429f, 0.07600112f, 
    -0.04011592f, -0.18191886f, -0.01293902f, -0.08596210f, 0.02635734f, 0.04096823f, 0.04924259f, -0.02194809f, 
    -0.00294768f, 0.00783925f, 0.03114237f, -0.01268962f, -0.32498187f, -0.19547457f, -0.01457392f, -0.09264291f, 
    -0.01360515f, -0.05140041f, -0.07706366f, 0.02163312f, 0.04410960f, -0.04647144f, -0.02280378f, -0.00942947f, 
    -0.09006001f, -0.02793987f, 0.01375467f, -0.11540378f, -0.12524995f, 0.01678154f, -0.03259430f, 0.00024598f, 
    -0.00244269f, 0.12191565f, 0.03753810f, -0.10783273f, -0.21266185f, -0.11433327f, -0.11923009f, -0.14851075f, 
    -0.09556090f, -0.03331425f, -0.01038734f, -0.06553940f, -0.03529692f, 0.01373195f, 0.04202934f, -0.01890882f, 
    -0.00992468f, 0.10551848f, 0.03294551f, 0.05444249f, -0.12437329f, -0.07696664f, -0.08093091f, -0.01474680f, 
    -0.02327352f, 0.00897505f, -0.01271954f, -0.03241409f, 0.00607464f, 0.01232191f, -0.00696532f, 0.01220823f, 
    -0.02544348f, 0.03755021f, 0.03112182f, 0.01465755f, 0.00802470f, -0.14656718f, -0.04455273f, -0.02520022f, 
    0.35844958f, 0.24442753f, 0.01439113f, -0.33061159f, -0.01595495f, 0.06824996f, 0.11855014f, 0.07903296f, 
    0.00860129f, 0.11954382f, 0.02574440f, -0.01478047f, 0.01043801f, -0.07587206f, -0.06507562f, -0.04271344f, 
    -0.09795593f, -0.03222873f, -0.09084208f, 0.12818250f, 0.15175566f, 0.13660353f, -0.25100279f, -0.07102680f, 
    -0.08550636f, -0.01336286f, -0.10519476f, -0.16439894f, 0.14581735f, -0.02426353f, -0.00955473f, 0.03606120f, 
    -0.04128051f, 0.04149609f, 0.00005723f, -0.04199603f, -0.05799568f, 0.00115572f, 0.01772982f, 0.05159233f, 
    -0.33706191f, -0.24517936f, 0.25044745f, -0.08991484f, 0.05147116f, -0.04961008f, -0.01490582f, 0.08791513f, 
    0.08184209f, 0.00270417f, -0.05223695f, 0.03994439f, -0.00949087f, 0.00354978f, 0.05390371f, 0.04020628f, 
    0.03167192f, 0.06343693f, -0.05394201f, -0.04438785f, -0.01456032f, -0.01730633f, 0.01909471f, 0.01847778f, 
    -0.02812356f, -0.03480478f, -0.02695559f, -0.02427735f, 0.03271169f, 0.04503471f, -0.03280608f, -0.00317873f, 
    -0.04588653f, -0.01198886f, 0.04743278f, -0.02253006f, -0.07185792f, -0.03094586f, -0.07299462f, -0.06467999f, 
    -0.20866044f, -0.04978534f, 0.09102951f, 0.02669690f, 0.05948464f, -0.04037614f, -0.08606175f, -0.06364207f, 
    0.01230942f, -0.03464839f, -0.10499317f, -0.11796949f, -0.07300137f, -0.02876836f, 0.01047040f, 0.09678130f, 
    -0.05615349f, 0.01363984f, -0.05391729f, -0.15543433f, -0.59902430f, -0.10024072f, 0.23274447f, -0.09409669f, 
    -0.07110674f, -0.00465601f, -0.02704415f, -0.04615066f, 0.00354633f, -0.01241948f, 0.08515508f, -0.02074150f, 
    -0.02250392f, 0.03834904f, -0.01081959f, 0.05989382f, 0.06935748f, -0.04710087f, 0.01602739f, -0.18286084f, 
    -0.09163707f, -0.08204488f, -0.03098720f, -0.07157499f, 0.07189642f, -0.04009568f, -0.06470239f, -0.01206798f, 
    0.03453196f, 0.00156621f, 0.02521603f, 0.04086064f, -0.02640145f, -0.05347249f, -0.03183239f, -0.07407727f, 
    -0.01116652f, 0.01292732f, 0.00605001f, -0.02761563f, 0.28586584f, 0.28991523f, 0.04239227f, -0.33483487f, 
    -0.11112391f, 0.02181417f, 0.06094341f, 0.00585310f, 0.11934062f, 0.10348668f, 0.05808272f, -0.03286739f, 
    0.02296669f, 0.01698302f, 0.01623094f, -0.00962392f, -0.05382948f, 0.02366897f, -0.01853556f, 0.04333613f, 
    0.20625599f, 0.14388113f, -0.13554808f, -0.13604279f, -0.19735666f, 0.09065176f, 0.05507154f, 0.06829062f, 
    0.00358138f, 0.02061979f, 0.01644601f, -0.00090982f, 0.06409688f, 0.01470094f, 0.03437812f, 0.01621756f, 
    -0.01794270f, -0.03916081f, 0.03714747f, 0.00386000f, 0.34583849f, -0.18194957f, -0.62289488f, 0.07705460f, 
    0.01227328f, 0.17397420f, 0.10159230f, 0.11070585f, -0.21494938f, 0.07905977f, -0.01002672f, 0.00494418f, 
    -0.11600575f, 0.01884766f, 0.02746269f, 0.02402730f, 0.09682457f, 0.05450537f, -0.00767217f, 0.03515457f, 
    0.08045878f, 0.14036383f, 0.03928196f, -0.10615915f, -0.03861915f, -0.12286250f, 0.01666544f, -0.13822629f, 
    -0.06280218f, -0.01153228f, 0.04678639f, 0.02123861f, 0.03221110f, 0.00796880f, -0.04441757f, -0.05569810f, 
    -0.00134924f, -0.06258353f, -0.19581272f, -0.04329456f, 0.10346073f, 0.08112642f, 0.38008612f, 0.05493446f, 
    -0.31116694f, 0.02300955f, 0.00222208f, -0.04792658f, 0.03856643f, 0.05033724f, 0.06653336f, 0.01259045f, 
    -0.03848823f, 0.01575405f, 0.04810418f, -0.04507159f, 0.01362833f, 0.00532842f, 0.05535125f, -0.01513476f, 
    0.14969453f, 0.17513973f, -0.05810428f, -0.17044836f, -0.09551812f, 0.01684015f, 0.00219974f, 0.03419328f, 
    -0.05571489f, -0.01812552f, 0.03917851f, -0.04005571f, 0.05623246f, 0.00740833f, 0.00809925f, -0.01799982f, 
    -0.02834915f, -0.00187946f, 0.04862541f, -0.05045951f, 0.25878224f, 0.31232071f, 0.17962645f, -0.36632875f, 
    -0.01891153f, 0.10609786f, 0.13521439f, 0.13769837f, -0.04320985f, 0.02525074f, -0.02598337f, -0.01469669f, 
    -0.00553265f, 0.01411086f, -0.01923904f, -0.00091551f, -0.04652003f, -0.02888281f, 0.07389192f, -0.11164471f, 
    0.18756121f, 0.14803821f, 0.03656483f, -0.09726988f, -0.00694972f, -0.06127593f, 0.07374492f, 0.00873532f, 
    -0.05753561f, -0.11668253f, -0.03563753f, -0.14575784f, 0.00644120f, -0.04818848f, -0.00458431f, -0.03143553f, 
    -0.03430288f, -0.02844073f, -0.02482971f, 0.00748725f, 0.26589897f, 0.16628729f, 0.02738325f, -0.22395702f, 
    -0.03368812f, 0.07304088f, 0.07820241f, 0.10443850f, 0.02109345f, 0.07006829f, -0.02209641f, -0.03871973f, 
    0.01398200f, -0.08821986f, -0.02828498f, 0.00304288f, -0.12189598f, -0.04738517f, -0.03874726f, 0.02624545f, 
    0.23878050f, 0.20364189f, 0.06041997f, -0.14619963f, 0.01983460f, -0.06998935f, 0.05457643f, 0.07136180f, 
    -0.06205574f, -0.08391731f, 0.00655790f, -0.12156855f, -0.01951538f, -0.01546508f, -0.01392929f, 0.01018928f, 
    -0.01672318f, 0.00641498f, -0.04056221f, -0.01955160f, -0.16710533f, -0.43427747f, -0.16710992f, 0.09638799f, 
    -0.27118221f, -0.07689082f, 0.03003265f, -0.01591239f, -0.01942605f, 0.05125344f, -0.05062788f, 0.05341946f, 
    0.02237922f, 0.04568781f, 0.03358040f, -0.18389235f, -0.21663940f, -0.03058835f, -0.06805655f, 0.10427551f, 
    0.17809136f, 0.26940325f, 0.06636523f, -0.35399449f, -0.15947054f, 0.02992798f, 0.02719663f, 0.00359844f, 
    -0.01312445f, 0.03879450f, 0.00604687f, -0.00355476f, 0.01839978f, 0.00531423f, -0.02078613f, -0.02567836f, 
    -0.04460188f, 0.03478079f, 0.06210981f, 0.00018977f, 0.23907258f, 0.19344802f, 0.01764924f, -0.13281609f, 
    -0.02874723f, 0.04847269f, 0.12399834f, 0.07890611f, -0.01757660f, 0.00741575f, -0.00180851f, -0.03451788f, 
    -0.00675066f, 0.01674845f, -0.00731028f, 0.00085150f, -0.04721925f, -0.01008440f, 0.00237486f, -0.05616271f, 
    -0.45871165f, -0.23973358f, -0.25083777f, 0.06267437f, -0.06501648f, -0.02837702f, -0.00332842f, -0.03281613f, 
    -0.01497912f, 0.01068249f, -0.00015408f, -0.12241449f, -0.14408351f, -0.02347157f, 0.01311327f, 0.01990870f, 
    -0.01336602f, -0.08248504f, -0.03307108f, -0.09995358f, -0.02684375f, -0.02192708f, -0.03792860f, 0.01886141f, 
    0.01015585f, -0.01570494f, -0.00622716f, -0.00544636f, 0.01444513f, 0.05127916f, -0.00568071f, -0.11420045f, 
    -0.19188955f, 0.05257212f, 0.04464782f, -0.01157781f, 0.05541207f, 0.01688004f, 0.04692475f, -0.00801263f, 
    0.17322589f, 0.13198715f, 0.10710563f, -0.17667672f, -0.00840798f, 0.02095483f, 0.12084367f, 0.01639388f, 
    -0.03666373f, 0.06281983f, -0.00109466f, 0.00609858f, -0.03380727f, -0.02792246f, -0.00910481f, -0.04661384f, 
    -0.05046019f, -0.01420718f, -0.17383078f, 0.03901102f, -0.40270743f, -0.34536925f, -0.30019602f, 0.08629086f, 
    -0.20161706f, 0.05757780f, -0.01232170f, -0.04988910f, -0.02926151f, 0.03491512f, -0.07329533f, -0.02581407f, 
    -0.03142919f, -0.09970023f, -0.01317366f, -0.22667500f, -0.00076950f, -0.05603121f, -0.07281472f, 0.00517236f, 
    0.28522715f, 0.15673655f, -0.06380122f, -0.16749918f, -0.08715434f, 0.14627999f, 0.12242985f, 0.11146632f, 
    -0.06929356f, 0.00918802f, -0.03119425f, 0.00761270f, 0.05117946f, -0.01838047f, 0.03816193f, -0.01333443f, 
    -0.02711875f, -0.09764191f, -0.01769001f, 0.06882966f, 0.06580081f, -0.01020868f, 0.02924256f, 0.02322215f, 
    0.09961540f, 0.05880809f, 0.03653051f, 0.04084137f, 0.00851256f, 0.03698063f, -0.02548239f, -0.08489211f, 
    -0.06350660f, -0.01727251f, 0.05350174f, -0.03300036f, 0.00398875f, -0.00875461f, -0.00323439f, -0.02303953f, 
    -0.03827316f, -0.05714817f, 0.03965835f, 0.01563461f, 0.02596544f, -0.04493454f, 0.00625215f, 0.02968775f, 
    0.00748052f, 0.01963580f, -0.09803911f, -0.14559814f, -0.08449487f, -0.17003629f, -0.18964881f, -0.03083947f, 
    -0.04434764f, -0.05878320f, -0.05985688f, -0.03106675f, 0.11886382f, 0.02048843f, -0.20297098f, 0.00978786f, 
    -0.15617579f, 0.15429187f, 0.03411648f, 0.07243924f, -0.07834212f, 0.05192516f, 0.02790030f, -0.01890117f, 
    -0.04214936f, 0.00297384f, -0.02074486f, -0.02907923f, 0.04619472f, -0.04985408f, -0.06853723f, 0.03001391f, 
    0.13902059f, 0.09311248f, -0.00131627f, -0.04085368f, 0.07589643f, 0.04065748f, 0.08449695f, 0.06459305f, 
    0.02755994f, -0.06702846f, -0.02290710f, 0.04134968f, -0.02093502f, -0.01737828f, 0.01342944f, -0.00755816f, 
    0.02123144f, -0.01239721f, 0.01286745f, -0.02844164f, -0.04033949f, -0.04027588f, -0.24210015f, 0.09997632f, 
    -0.00669963f, 0.01495498f, -0.04702109f, -0.02551557f, 0.00004169f, -0.01645584f, -0.11223493f, -0.05184128f, 
    -0.16842479f, -0.09735192f, -0.08047257f, -0.09932258f, 0.01962155f, -0.05188422f, -0.06265682f, 0.02359112f, 
    -0.17777215f, 0.20067061f, -0.26526105f, -0.11878362f, 0.07200372f, -0.13208234f, 0.03770664f, 0.02459432f, 
    0.01215930f, 0.06056302f, -0.07804076f, 0.05684379f, -0.07858626f, -0.05997888f, 0.01320535f, -0.07425669f, 
    0.14127859f, -0.01739989f, -0.14041887f, -0.00752475f, 0.02350596f, -0.01402078f, 0.02178520f, 0.04413516f, 
    -0.01472742f, 0.02893871f, 0.05937536f, -0.00589751f, 0.05902201f, 0.04624296f, 0.01844100f, -0.07225861f, 
    -0.00137383f, -0.03034174f, 0.00004429f, -0.04688553f, -0.04182785f, -0.11906704f, -0.00929812f, -0.01402367f, 
    -0.03778535f, 0.00636014f, 0.10453567f, -0.13632418f, 0.05849523f, -0.15178673f, -0.01949807f, 0.07478025f, 
    0.03155463f, -0.14783092f, -0.14069636f, -0.12132259f, -0.09247790f, -0.11311950f, -0.08701774f, -0.06526122f, 
    -0.00463995f, 0.02776230f, 0.02648652f, -0.01819051f, -0.04134042f, -0.05740454f, 0.00656237f, 0.06459913f, 
    0.01769972f, 0.01992729f, 0.01821377f, 0.03375636f, 0.01478958f, 0.05176464f, -0.07986582f, -0.10464333f, 
    -0.07252851f, -0.19896820f, -0.17287655f, -0.00103189f, -0.00637738f, 0.01168800f, -0.01032127f, -0.02897726f, 
    0.03753602f, -0.00059714f, -0.00869745f, -0.07016254f, 0.05402254f, 0.05531072f, -0.07560116f, -0.24684513f, 
    0.00497988f, 0.03974694f, -0.00095528f, -0.02466180f, 0.05308442f, 0.05741188f, 0.01410463f, 0.02585028f, 
    0.12008587f, -0.08910427f, 0.05396420f, 0.04750746f, -0.78020656f, -0.09672181f, 0.03874008f, 0.05266108f, 
    0.04651561f, 0.01824059f, 0.03103085f, 0.00453774f, 0.06527796f, -0.14774162f, -0.03566092f, -0.02440989f, 
    0.05534777f, -0.10875233f, -0.28027603f, 0.16734263f, 0.12230778f, 0.03210071f, -0.17552413f, 0.03934324f, 
    -0.49267286f, -0.09969648f, -0.04321168f, -0.04895692f, -0.05441209f, 0.00425731f, 0.10555704f, 0.21325111f, 
    0.00965466f, -0.19017552f, -0.04218382f, -0.01287467f, 0.01658266f, -0.00830233f, -0.01840616f, 0.01066087f, 
    0.01507200f, -0.00432888f, -0.06268206f, 0.01418775f, 0.05912086f, 0.04198553f, 0.00263138f, 0.05433980f, 
    -0.02794016f, -0.00700690f, -0.05098042f, 0.00089140f, -0.00726522f, -0.01837244f, -0.03742588f, 0.02409478f, 
    -0.00534248f, 0.02576403f, 0.07298799f, -0.06364571f, -0.03549345f, 0.03849134f, 0.01661668f, -0.07642440f, 
    0.22691546f, -0.05938391f, -0.04030018f, -0.08070118f, 0.14522025f, 0.14342536f, -0.11211208f, -0.05911798f, 
    0.14076494f, -0.03028368f, 0.10290734f, -0.01475935f, 0.05739579f, -0.02739594f, 0.07888217f, -0.12144072f, 
    -0.11191867f, -0.10356060f, -0.02124241f, -0.21896139f, 0.08167341f, -0.06061639f, 0.12761612f, -0.03965063f, 
    -0.15307522f, -0.00968810f, -0.00579791f, 0.02604571f, 0.02666978f, -0.02680097f, 0.11657126f, -0.06089679f, 
    -0.02220179f, -0.10820881f, -0.08343667f, 0.13696839f, -0.02180065f, -0.13264978f, 0.02674247f, 0.02758530f, 
    -0.00311325f, 0.01005749f, -0.30924115f, -0.26838598f, -0.20798014f, -0.04271955f, -0.24491815f, -0.14462133f, 
    0.07152761f, 0.00614565f, -0.01831423f, 0.02951246f, 0.01450539f, 0.02873152f, 0.01380694f, 0.06676554f, 
    -0.07780959f, -0.22266957f, -0.06939407f, -0.12889847f, 0.07276128f, 0.04520451f, 0.01196570f, -0.00948145f, 
    0.06072849f, -0.02651126f, -0.00463509f, -0.15337868f, 0.02858207f, -0.00778369f, -0.00723681f, -0.02350842f, 
    0.02333709f, 0.08606319f, 0.03032723f, -0.02285063f, -0.06626008f, 0.02663517f, 0.06893486f, -0.05272093f, 
    -0.70053607f, -0.85248190f, 0.27773896f, -0.14264487f, 0.16333994f, -0.02795739f, -0.03552729f, -0.01374332f, 
    -0.10147289f, 0.02280227f, -0.06330808f, 0.07651729f, -0.00870398f, 0.05265114f, -0.00014401f, 0.14789082f, 
    -0.11565912f, -0.22377197f, -0.07650400f, 0.21735202f, -0.00554970f, 0.01484118f, -0.07324530f, -0.19401243f, 
    0.06818230f, 0.16982903f, -0.13729955f, 0.13254616f, 0.07651056f, -0.10146350f, 0.02592470f, 0.04069732f, 
    0.04130885f, 0.02132357f, -0.01514373f, -0.04306830f, -0.01537729f, 0.05366823f, -0.03081979f, 0.03412490f, 
    0.44434103f, -0.08280974f, 0.10238798f, 0.07385445f, -0.13827932f, 0.06367590f, -0.03500065f, 0.04827871f, 
    0.20897716f, -0.14949729f, 0.15760089f, -0.13265687f, 0.00737486f, -0.14726216f, -0.07212730f, 0.10534567f, 
    -0.02329859f, -0.10371739f, 0.06501009f, 0.00984414f, -0.16192152f, 0.07729269f, -0.20368461f, -0.09606229f, 
    0.14714620f, 0.02035770f, 0.03236097f, 0.00946642f, 0.07131670f, -0.02842775f, 0.00891961f, -0.00416250f, 
    0.03887320f, -0.04532243f, -0.02842042f, 0.09883541f, 0.05344459f, 0.02690273f, -0.09818969f, -0.00982970f, 
    -0.36379930f, 0.05120330f, -0.25852337f, -0.11526157f, 0.10054616f, 0.04811372f, -0.05373067f, -0.07697967f, 
    0.10450308f, -0.05501038f, -0.01213958f, 0.08008644f, 0.07008979f, 0.03169724f, 0.05882797f, -0.08690849f, 
    0.06089580f, 0.08227842f, 0.03325191f, -0.04327575f, 1.11825359f, 0.49483809f, -0.38333392f, -0.13479368f, 
    -0.16737410f, -0.12833224f, 0.06549530f, -0.14815699f, 0.10717603f, -0.00283364f, -0.03110060f, 0.08012240f, 
    -0.05821021f, -0.02477782f, -0.02818886f, -0.07222778f, 0.14501989f, 0.06221230f, -0.00735386f, 0.13907386f, 
    -0.73847342f, -0.27147284f, -0.20200333f, -0.02872602f, -0.16954108f, 0.10551869f, 0.01094911f, -0.08973386f, 
    0.01326042f, -0.10206184f, 0.04012468f, 0.00944055f, 0.04219866f, 0.00590804f, 0.01228889f, -0.17302424f, 
    0.03817344f, 0.02963899f, -0.07409091f, -0.16355941f, -0.14815989f, -0.05080961f, -0.10703494f, -0.00462052f, 
    -0.00377796f, 0.03138551f, 0.21846151f, 0.15186548f, -0.12112649f, -0.01148269f, 0.08429263f, 0.01561176f, 
    0.04510023f, 0.01774123f, 0.02866351f, -0.03764349f, -0.02073831f, 0.01060175f, 0.02612491f, 0.02185087f, 
    0.46513599f, -0.05397870f, 0.08716714f, 0.05531572f, -0.20834701f, -0.01830464f, -0.00550296f, -0.00288792f, 
    -0.07963470f, 0.04640747f, 0.12189614f, -0.18330973f, -0.06002600f, -0.05405710f, -0.04071048f, -0.01221170f, 
    0.00569455f, -0.09727653f, -0.03706125f, -0.03622466f, -0.30014458f, 0.08175096f, -0.09417602f, -0.19265459f, 
    0.24020879f, -0.04078528f, 0.03840740f, -0.03935705f, 0.11663403f, 0.14965354f, -0.05687642f, -0.04905044f, 
    0.06333251f, 0.06590433f, -0.03112885f, -0.01620426f, -0.02903924f, 0.03281972f, -0.01990065f, 0.02954297f, 
    0.09673531f, 0.01956796f, 0.07795972f, 0.04275090f, 0.03837844f, -0.06099499f, -0.03239320f, -0.03099032f, 
    -0.02885437f, -0.05372190f, -0.01299924f, -0.01730169f, 0.00478822f, -0.01303718f, -0.05102978f, -0.05225673f, 
    -0.06024184f, -0.06056010f, -0.00561352f, -0.01680938f, -0.03677274f, 0.10735419f, -0.10090831f, -0.02951177f, 
    0.04898100f, -0.06977195f, -0.02674982f, -0.06881756f, 0.06444012f, -0.09970273f, -0.03774948f, 0.05064722f, 
    0.11223491f, 0.05574387f, 0.03432606f, 0.02572363f, 0.04135515f, 0.03376896f, 0.09490370f, -0.01393359f, 
    -0.11170302f, -0.26933417f, -0.15012150f, -0.32219395f, 0.13014026f, 0.18529984f, -0.07557335f, -0.08995596f, 
    -0.04338498f, -0.04594722f, 0.09270304f, 0.05308669f, 0.00255734f, -0.01123739f, 0.03437259f, 0.05184361f, 
    -0.21346077f, 0.01100966f, -0.13588353f, -0.25481227f, -0.26156658f, -0.05009296f, -0.02667749f, -0.02784652f, 
    -0.14441153f, 0.20392635f, -0.05734807f, 0.04528227f, 0.03065147f, 0.02496682f, -0.00983481f, 0.03038443f, 
    0.05733929f, 0.15077965f, 0.03788877f, 0.03477951f, -0.02924572f, -0.06322724f, 0.05028209f, 0.07873031f, 
    0.09659579f, -0.42078206f, 0.01519966f, -0.42136809f, -0.28646529f, -0.17429021f, 0.22381334f, -0.47075477f, 
    -0.01173463f, 0.01968715f, 0.01805843f, -0.03247907f, 0.03750321f, 0.02588635f, -0.03777364f, -0.20242985f, 
    0.02249854f, -0.27291840f, 0.02972719f, -0.03703653f, -0.02303896f, 0.03194221f, 0.00091277f, -0.14470074f, 
    0.22394888f, 0.16188413f, -0.00745586f, -0.09499260f, -0.00845536f, 0.01898311f, 0.01030509f, 0.04873742f, 
    0.03335867f, -0.04126431f, 0.08081104f, 0.03907672f, -0.03556719f, 0.19480439f, -0.12634479f, -0.19595270f, 
    0.66364050f, 0.16273059f, 0.15025374f, 0.10772534f, -0.04310410f, -0.04357068f, -0.00378847f, 0.01952339f, 
    -0.01901968f, -0.04360214f, -0.04717159f, 0.06230720f, -0.02456991f, -0.02418535f, -0.00103573f, 0.00094349f, 
    -0.05999786f, 0.02741927f, 0.16187899f, 0.02212106f, 0.20944120f, 0.09787679f, 0.12305266f, 0.04806723f, 
    0.07814178f, -0.04364907f, -0.05403439f, 0.03077486f, -0.03580869f, -0.03186659f, -0.06116931f, -0.00075033f, 
    0.01862099f, 0.02690330f, 0.00593378f, 0.01515892f, 0.00051888f, -0.05028953f, 0.02869168f, -0.01991508f, 
    -0.27989155f, -0.15957659f, -0.10698906f, -0.01899623f, -0.09172835f, 0.00002542f, 0.08186110f, 0.08328340f, 
    0.01147118f, -0.18677649f, -0.05972247f, 0.03397442f, 0.00312782f, 0.01147082f, -0.02352381f, 0.00653557f, 
    -0.00939780f, 0.01084613f, -0.00527649f, 0.03912349f, -0.01648096f, 0.05873423f, -0.04279670f, 0.07370449f, 
    0.15644261f, -0.07882430f, -0.02209657f, -0.01458041f, -0.00793954f, -0.03371572f, 0.02683106f, 0.10765119f, 
    0.02772749f, -0.01230080f, 0.11787611f, 0.05398852f, 0.05480677f, 0.12567820f, 0.03905514f, 0.05764917f, 
    0.05140142f, 0.05739695f, -0.16173598f, -0.02205533f, -0.32329580f, 0.09016031f, 0.01708928f, -0.03639771f, 
    -0.00652233f, -0.01908417f, -0.00489676f, 0.03745906f, -0.00584499f, 0.01744328f, 0.05935697f, -0.16813409f, 
    -0.13973686f, -0.21740122f, -0.11256170f, -0.03811537f, 0.13999943f, 0.07779618f, 0.07655297f, -0.00014317f, 
    0.08279912f, 0.01879201f, -0.02508702f, -0.00838371f, -0.00899398f, -0.00063301f, -0.01470318f, -0.04036126f, 
    -0.00297969f, 0.03983834f, 0.00308156f, -0.04424706f, 0.13886510f, -0.10574879f, 0.07281578f, 0.01488633f, 
    0.27545443f, 0.25549543f, 0.11615361f, 0.18206385f, 0.04971798f, 0.06525216f, -0.09150349f, -0.06705884f, 
    0.14335868f, -0.11576004f, 0.03997893f, -0.00561257f, 0.03515979f, -0.05798106f, 0.03167685f, -0.05162985f, 
    -0.03721493f, -0.04786719f, -0.02299565f, 0.03829831f, -0.13361254f, -0.15415876f, 0.00778106f, -0.06551781f, 
    -0.24723455f, 0.07468480f, 0.13113181f, 0.03983668f, 0.00249848f, -0.15108220f, 0.15135226f, -0.01799794f, 
    -0.07026889f, 0.11566438f, 0.06634273f, 0.03173461f, -0.01507484f, -0.01533779f, 0.00892742f, 0.11651746f, 
    -0.21446776f, -0.17492753f, 0.08964018f, 0.08096482f, 0.04265098f, 0.03136474f, -0.04481303f, 0.06892364f, 
    -0.09673437f, -0.01403261f, -0.05814712f, 0.01073838f, -0.08108716f, -0.01728344f, 0.19454287f, 0.18587768f, 
    -0.02529304f, -0.07715397f, 0.05451066f, -0.07147487f, -0.07072992f, -0.05422210f, 0.01819487f, -0.01865703f, 
    -0.04100334f, -0.04919329f, 0.02965182f, 0.01727366f, 0.02131674f, -0.02551856f, 0.13636179f, 0.07631376f, 
    -0.05062402f, 0.07075686f, 0.01430236f, -0.07586470f, 0.00857605f, 0.02070502f, 0.04571959f, 0.06769404f, 
    -0.03054301f, -0.00662793f, 0.09554605f, 0.05994736f, -0.02822164f, -0.09606966f, 0.01457514f, 0.05661932f, 
    -0.01565694f, 0.03435040f, 0.06584775f, -0.00895995f, 0.03031448f, 0.01744975f, 0.02549286f, -0.07837135f, 
    -0.01552433f, 0.09171303f, 0.06067976f, 0.02803730f, 0.42210338f, 0.23891723f, 0.09281202f, 0.11139910f, 
    0.17571968f, -0.02845046f, -0.00920469f, -0.00374341f, -0.08276620f, 0.00323308f, -0.05783004f, 0.00080595f, 
    -0.03120728f, 0.02189463f, 0.00920159f, 0.09717440f, 0.10199577f, -0.13176441f, 0.02839216f, 0.07252233f, 
    0.00955464f, -0.05552843f, 0.18866003f, 0.08965294f, 0.12219223f, -0.01168463f, 0.04236212f, 0.05855855f, 
    -0.04268095f, -0.08767920f, 0.11867882f, -0.11223686f, 0.04807191f, -0.05204721f, -0.04501960f, 0.14638416f, 
    0.02302404f, -0.02624023f, -0.06114984f, -0.09585198f, -0.27009010f, 0.15364602f, -0.07922388f, 0.24342924f, 
    0.06043385f, 0.08822458f, 0.04133011f, -0.02659912f, 0.08383678f, -0.09016453f, -0.05126301f, -0.04726556f, 
    0.00809989f, 0.01143095f, 0.01760581f, -0.03431819f, 0.03925088f, 0.04462744f, -0.07999917f, 0.07060163f, 
    -0.12279622f, 0.00966013f, -0.07975660f, 0.20010072f, -0.08269592f, -0.01384310f, 0.04991854f, -0.25522548f, 
    0.06270924f, 0.05509397f, -0.00907204f, -0.00142161f, -0.01810799f, 0.02783356f, 0.00672682f, -0.00536214f, 
    -0.00904700f, 0.00232445f, -0.04277820f, 0.00471282f, 0.58598423f, -0.26397324f, -0.08839925f, 0.04444982f, 
    -0.20453335f, -0.08166230f, -0.05530328f, 0.02655747f, -0.13748185f, 0.01158675f, 0.11464356f, -0.19020405f, 
    -0.02656425f, -0.09837056f, -0.02356166f, -0.00411080f, -0.02546762f, -0.07040047f, -0.04754995f, -0.01096741f, 
    -0.18084079f, -0.00659433f, -0.14551403f, -0.03476468f, -0.03647810f, -0.05715320f, 0.05000489f, -0.09871052f, 
    -0.10565733f, 0.16389795f, -0.06348611f, -0.03008579f, 0.08759984f, 0.13317050f, 0.06360986f, 0.03760850f, 
    0.01536856f, -0.01615660f, 0.16794994f, -0.04226813f, 0.18584345f, 0.25187808f, 0.23193023f, 0.18435313f, 
    -0.37734261f, 0.03339713f, -0.03789816f, 0.04303741f, -0.07494427f, 0.00414919f, -0.09739483f, 0.03115895f, 
    -0.02861632f, -0.02826589f, 0.02679346f, -0.01370401f, -0.30655968f, 0.02029774f, -0.11368091f, -0.25922337f, 
    -0.18235885f, 0.05030550f, -0.08675752f, 0.14989586f, 0.00907016f, 0.02051959f, 0.05923586f, -0.08069097f, 
    0.03198565f, -0.02017730f, -0.04809869f, -0.01942546f, 0.00007979f, -0.00060712f, 0.01542096f, -0.02459502f, 
    0.00096687f, 0.01436052f, -0.01507435f, 0.03656500f, -0.26773682f, 0.26331288f, -0.00770063f, 0.16447580f, 
    0.13273242f, -0.25984073f, -0.04367194f, 0.04713995f, -0.11027901f, -0.09938779f, -0.03412257f, -0.02048970f, 
    0.01923819f, 0.01394274f, 0.02442243f, 0.00599897f, 0.02380083f, 0.07025499f, -0.26176140f, 0.00253980f, 
    -0.35766038f, 0.04840387f, -0.11949565f, 0.02302896f, -0.05106658f, 0.13333137f, 0.15137635f, 0.15907048f, 
    0.05423946f, -0.01415501f, -0.13568951f, -0.05330801f, 0.09056979f, 0.00343217f, -0.00177583f, -0.01747186f, 
    0.05984348f, 0.02272034f, -0.00636848f, 0.00658328f, 0.15154241f, 0.13448945f, 0.09683602f, 0.13035552f, 
    0.03797847f, 0.07704430f, -0.00916408f, -0.04863270f, 0.14783403f, -0.00077307f, 0.06136947f, -0.01947597f, 
    0.04034126f, -0.01984219f, -0.03668399f, -0.06376090f, -0.03192608f, -0.07375827f, -0.03302551f, 0.02409954f, 
    -0.15120225f, 0.03064303f, -0.04675345f, 0.02634308f, 0.10712808f, 0.05358666f, 0.05957381f, 0.15300991f, 
    0.20749289f, 0.01381349f, -0.00249150f, -0.00397621f, 0.00300872f, 0.01505667f, 0.02219064f, -0.03310074f, 
    0.05995811f, 0.04370724f, 0.05205158f, -0.03771961f, 0.26649007f, 0.18058236f, 0.11777003f, -0.02493210f, 
    -0.01102065f, -0.02780904f, -0.05412377f, 0.01104077f, -0.02882073f, 0.01206255f, 0.03099822f, -0.00542667f, 
    0.04491422f, -0.03320291f, 0.02782701f, 0.15727513f, 0.00222191f, 0.10822362f, 0.10075280f, 0.00268512f, 
    -0.33435932f, 0.13144732f, -0.08043332f, 0.09608883f, -0.00183087f, -0.11624697f, -0.03181789f, 0.09489880f, 
    -0.20709147f, 0.10545751f, 0.03025246f, -0.03414121f, 0.04898107f, -0.00703414f, 0.00260950f, 0.01142901f, 
    -0.00303078f, 0.02438868f, -0.15208612f, -0.08949359f, 0.01333613f, 0.16549547f, 0.05966152f, 0.26677376f, 
    -0.06203536f, 0.01027386f, -0.01152162f, -0.04985816f, -0.16544949f, -0.10459691f, -0.00571453f, -0.00364937f, 
    -0.00004449f, -0.01996608f, 0.02733175f, -0.02997125f, 0.05980473f, -0.00832065f, -0.15630339f, -0.03706549f, 
    -0.05497199f, 0.00221590f, 0.24996185f, 0.05446810f, -0.02129301f, 0.00941738f, -0.02033379f, 0.05417016f, 
    -0.02765251f, -0.01357225f, -0.08863021f, 0.06697933f, 0.02615864f, 0.07627341f, -0.13603540f, -0.10055278f, 
    -0.01929049f, 0.04235312f, 0.01602153f, -0.00758461f, 0.08507860f, 0.05468188f, 0.12315151f, 0.08897238f, 
    0.02127166f, -0.08825850f, -0.02431364f, -0.05379955f, -0.00254971f, -0.10221566f, -0.00848172f, -0.01901722f, 
    0.10593048f, -0.04122039f, 0.01328298f, -0.02958180f, -0.09976131f, -0.15410300f, -0.05583094f, -0.02358876f, 
    -0.07072676f, 0.08168828f, -0.04817453f, -0.04586847f, -0.11511810f, 0.10206675f, -0.04314504f, 0.02377039f, 
    0.01112102f, 0.00171751f, -0.01499730f, -0.00959281f, 0.01160348f, -0.01970330f, 0.02014393f, 0.06397599f, 
    0.01647337f, -0.01208374f, -0.09548713f, -0.02732065f, 0.17928921f, 0.06366477f, -0.00456601f, 0.03720892f, 
    -0.00580751f, 0.00739922f, -0.05982839f, -0.02692708f, 0.03806350f, -0.05531937f, -0.01852078f, 0.08142755f, 
    0.01827624f, 0.03544072f, -0.01645601f, 0.00974626f, 0.12977304f, -0.01474218f, 0.17149714f, 0.04564418f, 
    -0.07400558f, 0.16002075f, -0.10141826f, 0.30422598f, 0.00051855f, -0.26277173f, 0.01369666f, -0.26997632f, 
    0.24956140f, -0.09481795f, 0.00807821f, -0.02189356f, -0.05261298f, 0.01041816f, 0.03170278f, -0.04246796f, 
    0.00919976f, -0.05097193f, -0.00848885f, 0.07430292f, -0.09995443f, -0.07204724f, -0.12641402f, -0.08434150f, 
    -0.04178609f, -0.04867297f, 0.01488049f, 0.01450265f, -0.00390695f, -0.06536726f, -0.09049223f, 0.08055373f, 
    0.00916693f, 0.07118905f, -0.04657961f, -0.05142196f, -0.01429242f, -0.00799205f, -0.01182554f, -0.00680615f, 
    0.10630051f, 0.00210713f, 0.13547583f, 0.09221464f, 0.06356317f, -0.02698443f, -0.01059653f, -0.00245295f, 
    -0.03572391f, 0.00929703f, 0.13734978f, 0.01539653f, 0.01316351f, -0.04085924f, 0.06612664f, -0.11713352f, 
    -0.00924513f, -0.03002986f, -0.04370195f, 0.01268224f, 0.14847305f, -0.19728680f, -0.21679628f, -0.09101678f, 
    -0.17956531f, -0.10326905f, -0.01826391f, -0.18850692f, 0.04382017f, 0.01024225f, 0.04193721f, -0.00759444f, 
    -0.04241373f, -0.05554175f, -0.04984443f, 0.00068822f, 0.00498757f, -0.14031273f, 0.08766370f, 0.08837899f, 
    -0.03104375f, -0.14246559f, -0.20535624f, -0.13525650f, -0.11113714f, -0.04385582f, -0.00075717f, 0.01675704f, 
    0.00306783f, -0.06021174f, -0.01620727f, 0.01495848f, 0.03405140f, -0.00331698f, -0.03453036f, -0.03270310f, 
    -0.02463339f, -0.02231656f, -0.02988184f, -0.00142934f, 0.28597519f, 0.02934495f, -0.05981462f, 0.04080680f, 
    -0.08560398f, -0.02019806f, -0.02405296f, -0.02651853f, 0.02741103f, -0.02284617f, 0.10240673f, 0.14267473f, 
    0.07288644f, 0.03419280f, 0.10195661f, 0.01918403f, -0.00512458f, 0.05573431f, 0.11527693f, 0.04567482f, 
    -0.45133677f, 0.19393611f, -0.17759193f, -0.20631993f, -0.17632309f, -0.07907744f, -0.01246896f, -0.13117506f, 
    0.15521069f, -0.11603446f, 0.06960637f, -0.08451163f, -0.04042897f, -0.00791836f, 0.01858710f, -0.02061309f, 
    -0.07433639f, -0.16122486f, 0.01652027f, 0.03205877f, 0.03250620f, -0.00343658f, -0.04215645f, -0.04618088f, 
    0.00743935f, 0.02686642f, -0.08057877f, -0.03199920f, -0.00869834f, -0.02474892f, 0.06591940f, 0.05381145f, 
    0.03747208f, -0.01265053f, -0.02066651f, -0.09796627f, 0.00096086f, 0.03871560f, 0.03086371f, -0.06608151f, 
    -0.29499009f, -0.16144454f, 0.12163897f, 0.07194400f, -0.03682660f, 0.05124858f, 0.11159390f, 0.13430050f, 
    0.03603490f, 0.01539175f, 0.11127473f, 0.07323045f, 0.08049749f, 0.09263916f, -0.02942051f, 0.08245830f, 
    0.04365391f, 0.03323095f, -0.00901248f, -0.08200762f, 0.09742785f, 0.07863151f, 0.08574038f, 0.08012471f, 
    0.07260215f, -0.05336089f, -0.05070154f, -0.01157505f, -0.05823629f, -0.02284199f, 0.12265208f, 0.00818220f, 
    -0.00734319f, -0.04224194f, -0.01194764f, -0.13669713f, -0.04213008f, -0.13575707f, -0.00204882f, 0.02088450f, 
    -0.15954214f, -0.09841435f, 0.02937169f, -0.14764577f, 0.02965184f, -0.06459457f, 0.02052642f, -0.10536131f, 
    -0.05122204f, 0.09205165f, 0.01727860f, -0.02924637f, -0.03814857f, 0.02720374f, -0.01742091f, 0.03243450f, 
    -0.03818012f, 0.02583429f, -0.09630067f, -0.04337388f, 0.21849108f, 0.45770112f, -0.32969990f, 0.16262899f, 
    0.19439596f, 0.06411118f, 0.00282397f, -0.03916898f, -0.00355302f, -0.16280887f, 0.03178229f, 0.05682125f, 
    0.02658511f, -0.32032099f, 0.13321856f, -0.07297449f, 0.00147285f, 0.03638352f, -0.03202256f, -0.14471385f, 
    0.20524000f, -0.02630240f, 0.02020477f, 0.36204931f, 0.19107941f, -0.10380420f, -0.03421486f, 0.05426119f, 
    -0.04599663f, 0.04928093f, 0.03030668f, 0.06853104f, 0.09119433f, 0.00916227f, -0.02847837f, 0.00063888f, 
    -0.02436622f, 0.00926467f, -0.06746393f, 0.02292640f, 0.01528563f, -0.08895067f, 0.02139880f, -0.08389492f, 
    0.05413222f, 0.04840160f, -0.11753869f, -0.00066529f, 0.08822541f, 0.07651788f, -0.04040039f, -0.08695158f, 
    0.12880342f, -0.05005259f, -0.07791750f, 0.07461850f, -0.07886914f, -0.10940921f, 0.04575323f, 0.00499614f, 
    0.20042472f, 0.06497846f, 0.26131231f, 0.39722487f, 0.23467235f, -0.01364874f, -0.11135564f, -0.12073359f, 
    0.09228567f, -0.05382294f, -0.03365443f, -0.00476115f, -0.03862550f, -0.09618340f, 0.05344004f, 0.00488188f, 
    0.14080499f, -0.00516216f, -0.11918975f, -0.01985781f, -0.09906429f, -0.06075376f, 0.44695547f, 0.07421464f, 
    0.16932966f, 0.01456900f, -0.05008059f, -0.05084394f, -0.04744503f, 0.03172708f, 0.02025671f, -0.00228560f, 
    0.03892182f, -0.04634782f, 0.05174573f, -0.00591813f, 0.04843891f, 0.00568011f, 0.03684295f, -0.04578084f, 
    -0.68691516f, -0.14641002f, 0.22364089f, -0.27087206f, -0.18728840f, -0.06093097f, -0.11097942f, -0.08375071f, 
    -0.05886134f, -0.09033737f, 0.03252447f, -0.01930806f, 0.00322442f, 0.00167060f, -0.04324878f, -0.12350636f, 
    -0.10171217f, 0.17150250f, 0.03445298f, 0.10214510f, -0.20355067f, -0.05474850f, 0.10486630f, -0.11166344f, 
    -0.00322874f, -0.08051756f, -0.11193492f, -0.28399456f, -0.03786524f, 0.10324052f, 0.02718859f, -0.01768391f, 
    0.07739101f, 0.00960932f, -0.06451805f, 0.03955715f, -0.01403975f, -0.02227383f, -0.08402449f, -0.00939463f, 
    0.17906712f, -0.37952933f, -0.22243668f, -0.24451086f, 0.01321360f, -0.00149809f, -0.02776884f, 0.02415104f, 
    -0.04966993f, -0.01510959f, 0.01879961f, -0.12318006f, -0.01352723f, 0.02184264f, -0.02358671f, 0.02992676f, 
    0.03467947f, -0.17740422f, 0.18655770f, -0.01963181f, 0.03966780f, 0.17575471f, -0.08586418f, -0.13954893f, 
    0.00227078f, 0.17194903f, -0.34249744f, -0.17748748f, 0.16946109f, 0.12079250f, -0.10051889f, 0.01462810f, 
    0.18839355f, -0.06644055f, -0.08793514f, -0.11812560f, 0.03055870f, -0.07183685f, 0.10444780f, -0.07728195f, 
    -0.15947028f, -0.09501065f, 0.59161478f, 0.12241936f, 0.09434981f, -0.05646638f, -0.05578911f, 0.10774045f, 
    -0.00354669f, -0.07134666f, 0.05373307f, 0.01392704f, 0.07145913f, -0.08311250f, -0.00450247f, -0.00974362f, 
    0.00646360f, 0.03163457f, 0.06410919f, -0.03392653f, 0.21319488f, 0.09583645f, 0.14008626f, 0.25413427f, 
    0.29697362f, -0.01910818f, 0.11277201f, -0.08802003f, 0.15482242f, 0.09857037f, 0.01100749f, -0.03536532f, 
    0.01384818f, 0.01590382f, -0.05054514f, -0.02828473f, 0.05603766f, 0.03493239f, -0.16999343f, 0.02219910f, 
    0.12546858f, 0.15531597f, -0.27669027f, -0.10787562f, -0.00693123f, 0.10243329f, -0.08324767f, -0.03028245f, 
    0.03158111f, -0.03772055f, -0.00172285f, 0.01600982f, 0.04594897f, -0.04218800f, -0.05753817f, -0.11571437f, 
    -0.00240607f, 0.04535951f, -0.06353533f, -0.05653457f, -0.65348792f, 0.52718794f, -0.06853091f, 0.05258978f, 
    -0.41814414f, 0.00161625f, -0.03805291f, -0.10205875f, -0.04015198f, 0.07241381f, -0.01167782f, 0.14733160f, 
    -0.08595291f, -0.03166574f, 0.08732389f, 0.11686170f, -0.05207751f, -0.03840930f, 0.09542643f, -0.04034532f, 
    0.34925255f, 0.13751468f, -0.12815344f, 0.09095494f, 0.14466901f, 0.04854662f, 0.01987871f, -0.09075411f, 
    -0.03753695f, 0.02704241f, -0.09946998f, 0.00383774f, -0.01390789f, 0.00938997f, 0.00440258f, 0.05550753f, 
    0.03875678f, -0.01176222f, 0.12116839f, 0.10493260f, 0.07497848f, -0.10779299f, -0.10654149f, 0.07482755f, 
    0.02850750f, -0.12252650f, -0.08897193f, -0.12693796f, -0.07712195f, -0.14934345f, 0.00378636f, -0.02064464f, 
    0.06730486f, -0.01301666f, 0.00333339f, 0.02581696f, -0.03415414f, -0.00323820f, 0.01687478f, -0.07953094f, 
    -0.10058618f, 0.19587260f, 0.50466675f, 0.00619555f, 0.24457191f, -0.07210650f, -0.00748019f, 0.08828394f, 
    -0.09436774f, 0.12580483f, 0.06414633f, 0.02697633f, -0.02957045f, -0.07092203f, 0.01330958f, 0.00820289f, 
    0.00949634f, 0.03142088f, 0.02977879f, -0.00824428f, 0.29630291f, 0.02263861f, -0.09720100f, -0.00924287f, 
    0.03330805f, -0.02614976f, -0.13403705f, -0.27419567f, -0.05325558f, 0.19809258f, -0.03146076f, -0.07757721f, 
    0.07065703f, -0.05229511f, -0.07765591f, 0.01086273f, 0.01707898f, 0.00140222f, -0.21317557f, -0.05409060f, 
    -0.05872308f, -0.07641226f, -0.02774399f, 0.00398179f, 0.07728730f, -0.00029171f, 0.04438058f, 0.01480462f, 
    0.01867835f, 0.02598797f, -0.12044191f, -0.10773964f, 0.03060587f, 0.05750215f, -0.01771837f, 0.05934909f, 
    0.02782316f, -0.01994467f, 0.01019569f, 0.01101202f, -0.15365779f, 0.06288448f, 0.01771224f, -0.10599563f, 
    -0.02843702f, -0.01134163f, -0.10474069f, -0.10013973f, -0.04750091f, 0.03121618f, 0.05364743f, 0.03926324f, 
    0.02594825f, 0.00690393f, -0.06124341f, 0.03185431f, -0.01700462f, -0.12392806f, 0.04072283f, 0.04742851f, 
    0.05083511f, 0.15691330f, 0.03425119f, 0.07766388f, 0.18060903f, 0.00714727f, 0.02731697f, -0.01519716f, 
    -0.02087231f, 0.02995813f, -0.01787166f, -0.00585894f, 0.01549776f, 0.01430472f, -0.05101347f, 0.07020853f, 
    0.16666609f, 0.06138602f, 0.00760567f, 0.10142741f, -0.15113570f, -0.01344095f, 0.07565723f, 0.04347641f, 
    -0.04338201f, 0.06969075f, 0.06018913f, -0.05040053f, -0.08421894f, -0.09403881f, 0.03432775f, -0.01225954f, 
    0.00374709f, 0.04215986f, -0.00821700f, 0.02169528f, -0.00509351f, -0.06964842f, -0.06124338f, -0.01329838f, 
    0.48078537f, -0.43317506f, 0.19509986f, -0.43258467f, 0.16619515f, 0.10114988f, -0.15109457f, -0.15164298f, 
    -0.09048822f, 0.01503201f, -0.04360361f, -0.06053717f, 0.02344627f, 0.04957159f, 0.00067545f, 0.12598190f, 
    -0.11527710f, -0.21996225f, 0.12277289f, 0.02480227f, -0.07186612f, -0.13393004f, -0.17429398f, 0.00243565f, 
    0.04488081f, -0.04789856f, 0.03093612f, 0.02795942f, 0.02795022f, 0.01650299f, -0.00917890f, -0.03750626f, 
    0.00240253f, 0.05372789f, -0.02162810f, -0.00904414f, -0.00106882f, 0.03943781f, -0.04127232f, 0.12321511f, 
    -0.27179089f, 0.19413200f, 0.10378364f, -0.10792417f, -0.11289265f, -0.00634953f, -0.07763097f, 0.00712533f, 
    0.00109357f, 0.12933958f, 0.01853040f, 0.00143793f, -0.14527015f, 0.06594589f, 0.04639788f, -0.02364799f, 
    -0.00596044f, -0.03812253f, 0.13355684f, -0.03586077f, -0.20634019f, -0.16113034f, -0.04803666f, -0.06226047f, 
    -0.02484556f, 0.03515337f, -0.00376478f, 0.00149452f, -0.02821986f, 0.06704187f, 0.00279035f, 0.00717699f, 
    -0.04437994f, 0.05369454f, -0.01416907f, -0.09926025f, -0.10233049f, -0.06264172f, 0.05531841f, -0.00068450f, 
    -0.00208655f, 0.13762806f, 0.12697870f, 0.25608152f, 0.13785900f, -0.05444879f, -0.08113140f, 0.09055908f, 
    0.01072534f, -0.05376723f, -0.01160956f, 0.05278986f, 0.02002317f, 0.02764864f, 0.04208449f, 0.01339952f, 
    -0.00993178f, 0.03641839f, -0.02736318f, -0.03866222f, 0.10595371f, 0.03859679f, -0.08229840f, -0.10646939f, 
    0.08924334f, 0.05793000f, 0.00658641f, -0.00572646f, -0.01716058f, 0.07181513f, 0.02535577f, 0.01692659f, 
    0.04442355f, 0.05486162f, -0.03499107f, -0.00072596f, 0.06006544f, 0.00918888f, 0.01520917f, 0.00776160f, 
    -0.07398504f, -0.11063416f, 0.17901391f, -0.03565980f, -0.22128592f, 0.01572880f, 0.00349219f, 0.04863958f, 
    0.01918160f, -0.00592579f, 0.02289882f, -0.01830645f, 0.00844729f, -0.03093848f, -0.00954624f, 0.11216707f, 
    0.12882602f, 0.16232623f, 0.16575167f, 0.13970882f, -0.21220845f, -0.21534866f, 0.08215319f, -0.18691173f, 
    -0.00865555f, -0.03462938f, 0.01191862f, -0.05312413f, -0.00441836f, 0.04333660f, 0.00448707f, -0.01747498f, 
    -0.02102681f, 0.05000390f, -0.01381757f, -0.03434142f, -0.19031706f, -0.00910162f, 0.00978432f, -0.01034350f, 
    -0.19591576f, -0.43071052f, 0.15235999f, 0.31996655f, -0.24208459f, 0.01145901f, -0.03133125f, -0.13612668f, 
    0.12593727f, -0.05575735f, -0.06172751f, -0.02222437f, -0.05030305f, 0.01988105f, -0.04233841f, -0.05514045f, 
    0.04493491f, 0.05872275f, -0.07336722f, -0.01307333f, -0.23091689f, 0.08769789f, 0.03661332f, 0.01569739f, 
    -0.01933872f, -0.02118403f, 0.01057238f, -0.13033623f, -0.13512145f, -0.07000080f, 0.02361685f, 0.01048562f, 
    -0.08612429f, 0.06605493f, 0.01249285f, 0.03868084f, 0.05851014f, 0.00359740f, 0.00121375f, 0.01435636f, 
    -0.06138280f, -0.14471698f, -0.10824231f, 0.05772042f, 0.18948850f, -0.00662052f, -0.01649236f, -0.03744657f, 
    -0.04110781f, -0.01204208f, -0.03474257f, 0.01126464f, -0.01366952f, 0.09387026f, 0.01817395f, 0.07034419f, 
    0.01952361f, 0.06122825f, -0.00230490f, 0.06413526f, -0.03343801f, -0.01676152f, -0.00864455f, -0.00488549f, 
    0.09252822f, -0.04671133f, 0.01138708f, -0.00998939f, -0.00773035f, 0.00739585f, -0.04264900f, -0.01924308f, 
    -0.01604391f, 0.03525150f, 0.03003542f, 0.03420083f, -0.08292970f, -0.00041328f, 0.02152863f, -0.10332513f, 
    -0.00649260f, 0.06881946f, -0.11963972f, 0.02545322f, 0.04516333f, -0.06501314f, 0.08105918f, 0.07511269f, 
    -0.04058960f, 0.00376849f, -0.01205553f, 0.04367654f, 0.06451699f, -0.02523512f, 0.01709895f, -0.02747231f, 
    -0.00016434f, 0.07315376f, -0.00375819f, 0.01671018f, -0.25316378f, -0.03091698f, -0.21427895f, -0.00700156f, 
    -0.01137461f, -0.02871426f, 0.05391387f, 0.03100403f, -0.04292344f, 0.06329980f, -0.00865640f, 0.02055549f, 
    0.03054268f, -0.04540079f, -0.06571554f, -0.04728192f, -0.03827444f, -0.01033999f, -0.07035569f, -0.03803700f, 
    0.10796096f, 0.02346689f, -0.06497692f, -0.01608739f, 0.06826590f, 0.02088485f, -0.00272966f, 0.01171196f, 
    -0.02219704f, -0.05770324f, -0.16360973f, 0.06838871f, 0.12821154f, -0.00074017f, 0.06502741f, -0.01376495f, 
    0.04319945f, 0.01046442f, 0.05310223f, -0.06106743f, -0.17510542f, -0.35294574f, -0.27803767f, 0.10581467f, 
    -0.30067569f, 0.05188683f, 0.02673829f, -0.08675233f, -0.07870652f, -0.05667000f, 0.03145017f, 0.02943518f, 
    -0.00802615f, 0.00230560f, -0.03970078f, -0.02206979f, -0.00554400f, 0.02972118f, -0.13743021f, -0.08971733f, 
    -0.03154429f, -0.43418682f, -0.20274098f, 0.06103116f, -0.29774001f, 0.10121371f, 0.00589003f, 0.03754969f, 
    -0.03465350f, -0.24214317f, -0.01151597f, 0.05319084f, -0.00479517f, 0.01528207f, -0.04164691f, -0.00247543f, 
    0.00125467f, -0.01245728f, 0.00006151f, -0.00862063f, -0.10986895f, 0.16177367f, 0.61306071f, 0.03615031f, 
    0.23456046f, -0.08294895f, -0.04630710f, 0.07910485f, 0.15613958f, -0.11971190f, 0.06798846f, -0.00073944f, 
    -0.02605534f, -0.19521675f, 0.11748298f, -0.00344901f, 0.00579785f, 0.03316589f, 0.01641174f, -0.01325430f, 
    -0.27688047f, -0.03334816f, -0.01597446f, 0.01466307f, -0.02691399f, -0.01086284f, 0.10432223f, -0.12150495f, 
    -0.19523263f, 0.00642833f, 0.07379258f, -0.03857917f, 0.00582457f, 0.03496491f, -0.06943598f, 0.02857601f, 
    -0.01762513f, 0.00824156f, -0.16917452f, -0.13328899f, -0.02844387f, -0.29278147f, 0.07492296f, 0.07665691f, 
    -0.41481483f, 0.01004553f, 0.00923878f, 0.00840489f, -0.02140472f, 0.09121970f, -0.02281368f, -0.02642445f, 
    -0.05974902f, -0.00315844f, -0.06960312f, 0.15685259f, 0.05406715f, 0.07087654f, 0.00842503f, 0.02999562f, 
    -0.00019386f, -0.15958911f, -0.18177691f, 0.13202393f, -0.05506247f, -0.01252987f, 0.06520450f, 0.01156999f, 
    -0.07436009f, -0.08336687f, 0.05367116f, 0.05448319f, 0.04356794f, 0.00457391f, -0.02661829f, 0.00624239f, 
    -0.02182818f, 0.00673987f, -0.06442407f, -0.03176406f, -0.51814771f, -0.65466541f, -0.84540838f, -0.05717931f, 
    -0.55121815f, -0.06493030f, -0.00020702f, -0.01013342f, -0.08273341f, -0.02383292f, -0.03062993f, -0.01091948f, 
    0.03086308f, -0.00476507f, -0.05609505f, -0.01741345f, -0.03806474f, -0.02882822f, -0.20932391f, 0.05436008f, 
    0.12139893f, -0.02352962f, -0.04156164f, 0.27482581f, 0.07361609f, 0.06707854f, -0.09248872f, -0.00239805f, 
    0.00626110f, -0.08043878f, 0.02153256f, 0.14619453f, 0.05342656f, 0.03092520f, -0.01126310f, 0.00379645f, 
    -0.05327672f, 0.04117790f, 0.02961640f, -0.00515425f, -0.07977822f, -0.13575813f, 0.22939718f, 0.31159067f, 
    0.02159714f, -0.03522511f, 0.02227241f, -0.06616120f, 0.06475703f, -0.01826853f, 0.00479630f, 0.01074375f, 
    -0.03527139f, 0.04498732f, -0.01721468f, -0.00069106f, 0.07011532f, -0.00245964f, -0.03995667f, 0.03010863f, 
    0.24545608f, 0.00404848f, 0.04151710f, 0.17176995f, 0.07473408f, 0.03986395f, -0.12776200f, -0.13751714f, 
    0.08695979f, -0.00418894f, 0.02347623f, 0.05750231f, -0.03564346f, 0.03187946f, -0.05214067f, 0.00863301f, 
    0.00167351f, -0.06486606f, 0.02304498f, -0.00928265f, -0.03276031f, -0.13223001f, -0.13537170f, -0.27904576f, 
    0.12192664f, 0.08196000f, -0.03526445f, -0.00898900f, -0.03531015f, 0.04868554f, -0.00482118f, 0.05458905f, 
    -0.05640126f, 0.03700382f, -0.00744161f, 0.17233491f, 0.06330892f, -0.20258105f, 0.15040277f, -0.01465358f, 
    -0.62087709f, -0.33517367f, -0.56521380f, 0.03728129f, -0.48605448f, 0.19048767f, 0.16529155f, 0.05657008f, 
    -0.25557208f, -0.06747963f, -0.01667472f, -0.01739562f, 0.05058223f, 0.02020233f, -0.05828660f, 0.00593665f, 
    -0.00306839f, -0.04284471f, -0.04578310f, 0.09420162f, -0.15979847f, -0.41961822f, -0.11224952f, 0.18392016f, 
    -0.30750477f, 0.02032561f, -0.07315216f, -0.01361574f, -0.03311580f, 0.00535494f, 0.00003277f, -0.02119406f, 
    0.01267444f, -0.01353847f, -0.01978877f, -0.02257542f, -0.01563793f, -0.00292874f, -0.08368053f, 0.01064292f, 
    0.01273193f, 0.05188898f, 0.10010698f, 0.01197449f, -0.03816452f, 0.02179503f, -0.09332611f, -0.02863293f, 
    -0.03841252f, 0.08609658f, -0.04406518f, -0.01663513f, -0.00126344f, 0.03366501f, 0.15063660f, -0.00107719f, 
    0.02356178f, 0.05613063f, 0.09983125f, -0.07074562f, -0.06103247f, -0.22506662f, -0.03093805f, -0.05053563f, 
    0.04552059f, -0.01367938f, 0.00021611f, 0.02843936f, 0.04706119f, -0.00077364f, -0.06338411f, -0.06106976f, 
    -0.05015855f, -0.08118748f, -0.02940110f, 0.04050001f, 0.02845363f, -0.01362753f, 0.01311543f, -0.01031306f, 
    -0.04064894f, 0.10838979f, 0.09941517f, 0.29499933f, 0.09079383f, 0.01314722f, -0.01853075f, 0.08094797f, 
    0.06939890f, 0.03381981f, -0.05565549f, -0.00310211f, 0.03619691f, 0.01037808f, -0.00628968f, 0.00260228f, 
    -0.03440823f, -0.00981423f, -0.00710954f, 0.05295583f, -0.01000589f, -0.13306624f, 0.00898370f, -0.27473080f, 
    -0.01427818f, 0.04137241f, -0.01744382f, -0.01589103f, 0.02460453f, 0.01268761f, 0.03451631f, -0.04304968f, 
    -0.01315623f, -0.02804869f, 0.04540244f, 0.06131727f, -0.08073542f, -0.12389070f, 0.05577106f, 0.02231124f, 
    0.05936466f, -0.58140647f, -0.00514492f, 0.20603994f, -0.48965159f, 0.00301062f, -0.22284833f, -0.05370515f, 
    0.14430244f, -0.25865763f, 0.00601392f, 0.01694168f, -0.05897766f, 0.04263325f, 0.00426674f, 0.01904930f, 
    -0.04313993f, 0.00130139f, 0.11866236f, -0.07923640f, -0.00302383f, 0.05416131f, 0.09045406f, 0.08835159f, 
    0.09724919f, 0.02115069f, -0.02309955f, 0.07055517f, 0.07836912f, -0.20009883f, -0.10635788f, 0.00377371f, 
    0.00176963f, 0.05780090f, 0.04513785f, 0.02372030f, -0.02376610f, 0.01792729f, -0.01446277f, -0.00232118f, 
    0.09387971f, -0.01167277f, -0.08383849f, -0.06446820f, 0.06978557f, -0.01653621f, -0.03340427f, 0.03251297f, 
    0.04332599f, 0.08118821f, 0.02327844f, 0.10676103f, -0.03893553f, 0.04761780f, 0.00919898f, 0.03938470f, 
    -0.04765161f, 0.02341975f, 0.03150233f, 0.01345260f, 0.20207801f, -0.06894552f, 0.39126506f, -0.11687911f, 
    0.01570979f, 0.00325254f, -0.14885771f, 0.00568110f, 0.03258501f, -0.01588826f, 0.06311428f, -0.05334927f, 
    0.04237357f, -0.06985638f, 0.13335709f, -0.00449007f, -0.02296597f, -0.13022889f, 0.13080056f, -0.11121578f, 
    -0.00403942f, -0.02692526f, 0.00865529f, 0.14761642f, 0.04729063f, 0.00617212f, -0.03837639f, 0.07909890f, 
    0.08490657f, -0.46768120f, -0.03691145f, 0.01533040f, 0.05450419f, -0.00886533f, 0.02340129f, -0.02679124f, 
    -0.03085511f, 0.06624159f, 0.01015419f, -0.00083484f, -0.10039888f, 0.08984682f, 0.01371802f, -0.04763462f, 
    -0.03090781f, 0.01383456f, -0.03197430f, -0.08493455f, -0.02382588f, -0.02532785f, 0.01699499f, -0.08528510f, 
    0.06651675f, -0.03951393f, -0.01203350f, 0.06680674f, -0.05740733f, -0.08549489f, 0.09383190f, -0.05930107f, 
    0.38728648f, -0.41996947f, 0.17073539f, 0.12678608f, -0.01563773f, 0.05219797f, -0.12912768f, -0.07668210f, 
    -0.05279842f, -0.04037952f, -0.11331452f, 0.01637427f, -0.07323208f, -0.00221552f, 0.05947951f, 0.08247557f, 
    -0.00079066f, -0.08109348f, 0.07015745f, 0.01508799f, -0.08209547f, 0.00345181f, -0.00032805f, -0.02056598f, 
    0.02811465f, -0.00708455f, -0.05156548f, -0.00066914f, -0.00904518f, 0.04417196f, 0.03516542f, -0.12507167f, 
    -0.02906297f, -0.00136913f, -0.03571235f, 0.01660566f, -0.04955012f, -0.06035744f, -0.00747862f, -0.02986545f, 
    0.45988971f, 0.03672627f, -0.00741066f, 0.16875657f, 0.12220174f, -0.06062571f, 0.06904664f, -0.03032048f, 
    -0.07390776f, 0.06152262f, -0.04911977f, 0.00869089f, 0.03705998f, 0.06724133f, -0.05132372f, 0.04780841f, 
    -0.04068723f, 0.01148308f, -0.00903233f, 0.02822236f, 0.01408404f, -0.09243325f, -0.08420871f, -0.04750150f, 
    0.01930481f, -0.00893386f, -0.04220265f, 0.00029084f, 0.04167785f, 0.01040910f, 0.03303286f, -0.09641657f, 
    -0.07395560f, 0.10279169f, 0.08742356f, 0.05743517f, 0.04115622f, 0.00308328f, 0.03507670f, -0.03786273f, 
    0.17709303f, 0.11571001f, 0.24042366f, -0.27312195f, 0.13494746f, -0.19995116f, -0.06654816f, 0.02658806f, 
    -0.00860127f, -0.00317679f, 0.11579183f, 0.00262948f, -0.02487671f, -0.02631078f, 0.11801366f, -0.03662538f, 
    -0.07803268f, 0.00220474f, -0.11493856f, 0.04297981f, -0.68886399f, 0.50414258f, 0.10993955f, -0.25793514f, 
    -0.00772036f, 0.02951968f, -0.03572329f, 0.00816419f, -0.09453290f, -0.04087293f, -0.15012352f, -0.05850219f, 
    -0.04900931f, -0.13776852f, 0.22770527f, 0.09602693f, 0.05552002f, 0.03975086f, -0.19383126f, -0.28580457f, 
    -0.17697769f, 0.14024951f, -0.16545995f, -0.15219824f, 0.26821241f, 0.20667508f, 0.00274463f, -0.15587118f, 
    -0.00131755f, -0.35167333f, -0.13702971f, 0.06313252f, 0.02690616f, 0.09359802f, 0.06371427f, -0.01233168f, 
    0.09439819f, 0.00237707f, 0.04542589f, -0.12452609f, -0.18612115f, 0.07762028f, -0.16482872f, -0.03130126f, 
    -0.22543976f, 0.00594619f, 0.09545922f, -0.05392699f, -0.04655420f, 0.01484849f, -0.04979066f, -0.13301061f, 
    0.01267999f, -0.04659269f, -0.13399334f, -0.03108924f, -0.13914470f, 0.03877191f, 0.07495378f, -0.11949337f, 
    -0.07409777f, 0.27784389f, 0.12266317f, -0.10129765f, 0.18775105f, 0.02668283f, 0.01773872f, -0.07037682f, 
    -0.05693389f, -0.00259847f, -0.09014504f, 0.03276281f, -0.00136270f, -0.07179582f, 0.08012311f, -0.04183562f, 
    0.02390546f, 0.03656695f, 0.08312583f, 0.00787795f, 0.01247521f, 0.07168305f, -0.14514957f, -0.02362855f, 
    0.09105889f, 0.11115503f, 0.05446710f, 0.01608720f, 0.07627506f, 0.07290386f, -0.10394318f, 0.04898708f, 
    0.02168310f, 0.00778450f, 0.06270823f, -0.09988708f, 0.09270653f, -0.07254108f, 0.04169810f, 0.00081791f, 
    -0.07319760f, -0.18560569f, 0.15448557f, 0.05307224f, 0.22399554f, -0.10191766f, 0.11401252f, 0.12720980f, 
    0.02655300f, 0.07413179f, 0.08841461f, 0.00334362f, -0.00240327f, -0.05394160f, 0.10777140f, -0.07669919f, 
    -0.01251415f, 0.02641651f, -0.05935929f, 0.00744509f, -0.11139034f, -0.24018908f, 0.19819263f, 0.18310083f, 
    0.10298578f, 0.05789553f, 0.03227315f, 0.09173850f, 0.02647855f, -0.03402326f, 0.13970263f, 0.11563613f, 
    -0.07192310f, 0.02142557f, 0.05795617f, -0.06477674f, 0.06384754f, -0.00234420f, -0.11240913f, -0.07727120f, 
    0.65477782f, 0.02125745f, -0.10113309f, -0.18051419f, -0.35972852f, 0.09657033f, 0.08195949f, 0.01125422f, 
    0.13666190f, 0.14052188f, -0.12903723f, -0.07588033f, 0.13757667f, 0.11245133f, 0.07802185f, -0.06776022f, 
    0.06157540f, -0.11396702f, 0.05038777f, 0.12540865f, -0.61686403f, 0.32456735f, 0.17433850f, 0.10681018f, 
    0.23038159f, 0.03788580f, 0.05569951f, 0.02020581f, 0.02376421f, -0.12880757f, -0.18432432f, -0.04535024f, 
    -0.18381645f, -0.00863814f, -0.07766094f, -0.08628112f, -0.21119887f, 0.16301979f, -0.15784530f, -0.17187381f, 
    0.02638954f, 0.13397399f, -0.14327268f, 0.01988437f, 0.18145876f, 0.12956031f, 0.11106721f, -0.06214712f, 
    0.00660402f, 0.04344326f, -0.05895059f, 0.03321023f, 0.03877378f, -0.01603925f, 0.08134945f, -0.02254397f, 
    -0.00949706f, -0.06375715f, 0.13676426f, 0.00845263f, -0.12096064f, 0.07373738f, -0.06876895f, -0.16671970f, 
    0.16842805f, 0.07200921f, -0.01288459f, -0.15207963f, 0.02822989f, -0.12775467f, -0.03752298f, 0.10091447f, 
    -0.00856766f, 0.03144998f, 0.00555909f, -0.04020494f, 0.05026967f, -0.02127380f, -0.02573089f, 0.01091325f, 
    -0.07895423f, 0.05731102f, 0.39725286f, -0.07724401f, 0.24583240f, -0.17458512f, 0.05053726f, -0.03191897f, 
    -0.03272176f, -0.17812477f, 0.04035179f, 0.01167169f, -0.09883509f, -0.05350919f, 0.00292011f, -0.08009631f, 
    -0.04886013f, 0.06284358f, -0.11810669f, -0.12527825f, -0.37905931f, -0.20010191f, 0.19102836f, -0.11381313f, 
    0.19797830f, 0.01914489f, 0.01430106f, 0.07677811f, -0.07072597f, -0.10188597f, 0.02848885f, -0.08527561f, 
    -0.04954387f, 0.10911975f, -0.05726787f, -0.03419469f, 0.05155794f, 0.17670998f, 0.00186281f, -0.05496921f, 
    0.45851898f, 0.28446212f, 0.06747948f, -0.47693530f, 0.25751591f, -0.06007499f, 0.02244018f, 0.05552509f, 
    -0.05967660f, -0.08587570f, -0.09050260f, 0.00959030f, -0.08081627f, 0.08643018f, -0.08768594f, -0.00492930f, 
    -0.03803340f, 0.08148374f, 0.02473538f, 0.06198222f, -0.11701497f, 0.02901026f, -0.20709096f, 0.09999950f, 
    0.06128465f, 0.10021412f, -0.02439245f, 0.13131163f, 0.16832148f, 0.11370575f, 0.05114087f, 0.06452465f, 
    0.03934974f, -0.15459277f, -0.04871465f, 0.12504648f, -0.07758153f, 0.12121259f, 0.02746407f, 0.00852217f, 
    -0.14323567f, 0.54860407f, -0.07001226f, -0.04795969f, 0.18494214f, 0.19232427f, 0.00473538f, -0.03360106f, 
    -0.00812482f, -0.04338522f, -0.09107180f, -0.00870435f, 0.05414130f, 0.03990556f, 0.05963694f, -0.05988303f, 
    -0.00011309f, -0.02846380f, 0.05221133f, -0.00479384f, 0.34196278f, 0.26833087f, -0.17826617f, -0.04261160f, 
    0.28429410f, 0.00116442f, 0.06790625f, -0.15805119f, -0.06548548f, -0.06989521f, 0.12543082f, -0.05273016f, 
    -0.16240102f, -0.07077156f, 0.01247828f, 0.24654934f, 0.03363385f, 0.05833476f, -0.31521335f, -0.01413461f, 
    -0.01513750f, -0.22678439f, -0.19487756f, 0.10198184f, -0.31709576f, 0.13566998f, -0.11172592f, -0.00576382f, 
    0.06299794f, -0.09960873f, -0.10101273f, -0.01882818f, -0.04094914f, -0.13861828f, -0.06892955f, 0.02992844f, 
    -0.05494068f, -0.04250419f, 0.00621590f, 0.03790475f, -0.19312051f, -0.11820980f, 0.07050526f, 0.00732349f, 
    -0.08554253f, -0.00721162f, 0.03883438f, 0.00623692f, -0.07899097f, -0.02710096f, 0.03732185f, -0.04092855f, 
    0.02852488f, -0.02620915f, -0.07143242f, -0.00796306f, 0.10992628f, 0.12759061f, 0.03303835f, -0.17914408f, 
    0.28126085f, 0.17831378f, 0.20293044f, -0.19969705f, 0.19690348f, 0.00501867f, 0.18559246f, 0.01908525f, 
    -0.05116611f, 0.08316588f, -0.01464051f, 0.01984772f, 0.07797516f, -0.01038024f, 0.03014872f, 0.01281212f, 
    -0.07272774f, -0.04142962f, 0.07782080f, 0.03179953f, -0.07984282f, -0.00994535f, -0.04684703f, -0.00169746f, 
    0.22080363f, -0.09720315f, 0.09800851f, -0.02398660f, -0.04862373f, 0.06106677f, -0.00929161f, -0.01599195f, 
    -0.06332184f, 0.00898271f, -0.01280860f, -0.01308739f, 0.02714917f, 0.07644944f, -0.05772420f, -0.12087691f, 
    0.15508714f, 0.25378203f, 0.30079871f, -0.48592389f, 0.27149028f, -0.13679843f, -0.00811684f, -0.06798121f, 
    -0.11011767f, -0.00184757f, -0.11823110f, -0.14381045f, 0.03952194f, 0.09288569f, 0.11324835f, -0.10239127f, 
    0.08702749f, -0.27491328f, -0.02031022f, 0.06799164f, 0.09258211f, 0.01736187f, -0.07731949f, -0.16222604f, 
    0.09677511f, -0.02683266f, 0.06180301f, -0.02243784f, 0.05132726f, 0.03471884f, -0.03667692f, -0.04354270f, 
    0.00762726f, -0.04852765f, -0.02470940f, -0.06291495f, 0.00563532f, -0.02720394f, 0.00679591f, -0.03083740f, 
    0.03572237f, 0.04214112f, 0.24079511f, 0.38564736f, -0.03512507f, 0.07041848f, -0.00791897f, 0.00701121f, 
    0.05107990f, -0.23471367f, -0.03323136f, -0.01952169f, 0.04527232f, -0.02731622f, -0.13095728f, -0.01754455f, 
    -0.02418135f, 0.05915625f, -0.01670827f, -0.09977561f, -0.65366733f, -0.25552189f, -0.15397128f, -0.06024474f, 
    -0.35516316f, -0.00750899f, -0.14762633f, -0.16036430f, 0.12109293f, -0.14906822f, 0.03427007f, 0.02382920f, 
    0.14160070f, -0.09662938f, -0.07514388f, -0.06291751f, -0.02626288f, -0.02681962f, 0.00190859f, -0.12729384f, 
    -0.03429317f, -0.14769867f, -0.18253256f, -0.01932820f, 0.29165056f, 0.13761847f, 0.00896602f, -0.02343207f, 
    -0.05363424f, -0.06576161f, -0.06396077f, 0.05957358f, 0.06755728f, 0.07360821f, 0.04953172f, 0.07053138f, 
    -0.01362758f, 0.09195975f, 0.14324741f, -0.00611489f, 0.23471700f, 0.15273526f, 0.55515242f, -0.49491897f, 
    -0.02919328f, -0.13718051f, 0.06088839f, -0.09382112f, -0.10358796f, -0.21277696f, 0.08937144f, -0.02443774f, 
    0.11687279f, -0.08618934f, -0.10904013f, 0.02933664f, -0.04690062f, -0.10247948f, 0.00551985f, -0.09572446f, 
    -0.04948050f, -0.14355463f, -0.07616181f, 0.09018280f, 0.15003668f, -0.11762584f, 0.07733218f, 0.00963670f, 
    0.09269091f, 0.05263446f, -0.01115286f, 0.02144177f, -0.00826097f, -0.03370988f, 0.02889844f, -0.00245495f, 
    0.01743402f, -0.10967240f, 0.00533340f, 0.01502412f, -0.65794915f, -0.18689789f, 0.60720646f, -0.12671123f, 
    -0.05726112f, -0.08475123f, -0.16955794f, -0.06986918f, -0.02492711f, -0.22290385f, -0.02769961f, 0.02352939f, 
    0.04454292f, -0.00215203f, 0.06551635f, -0.03220483f, -0.01126773f, -0.07848631f, -0.01650755f, -0.12856628f, 
    -0.19674516f, 0.07154095f, -0.13720486f, -0.01845122f, 0.20724858f, 0.02104588f, 0.01380548f, 0.02200003f, 
    0.03737902f, 0.07028465f, -0.12775740f, 0.09512205f, -0.09586929f, -0.01000000f, -0.02674380f, -0.05616596f, 
    -0.01956434f, 0.12778962f, 0.00547754f, 0.02930708f, -0.10325750f, 0.15882467f, -0.01575636f, 0.30452263f, 
    0.24061109f, -0.03964432f, 0.01373135f, -0.02017492f, -0.02666700f, 0.01830667f, 0.00420599f, 0.10224906f, 
    0.08486180f, -0.17766105f, -0.00075994f, 0.02380086f, -0.01032886f, 0.02012848f, -0.07763012f, 0.11089940f, 
    0.89044768f, 0.19538370f, -0.12400132f, -0.09763912f, -0.16709268f, 0.19791685f, 0.13031547f, 0.06074801f, 
    -0.01616918f, -0.05175057f, -0.17064260f, -0.10840057f, 0.10492563f, -0.07950661f, -0.09090284f, -0.08005516f, 
    0.00453960f, -0.11125907f, 0.04659551f, 0.00519058f, -0.06973707f, 0.08868583f, -0.14981386f, 0.14374246f, 
    -0.07063507f, 0.03790486f, -0.06362186f, 0.01456217f, -0.05502599f, 0.01755517f, -0.09394499f, 0.00608386f, 
    0.02063946f, -0.12898646f, 0.01113855f, 0.02835710f, -0.03890963f, -0.01796840f, 0.01528613f, -0.00556664f, 
    0.13261677f, 0.03431926f, -0.20756191f, -0.24159458f, -0.23638728f, 0.02349058f, -0.16202460f, -0.14349194f, 
    0.01372185f, -0.20509227f, -0.03242785f, -0.00489291f, -0.06383539f, -0.12577389f, 0.02470216f, 0.00507783f, 
    -0.14799124f, -0.09703036f, -0.01481817f, -0.03536913f, -0.42175797f, 0.02068208f, -0.20715450f, -0.15443777f, 
    -0.20676549f, -0.12497268f, -0.02722393f, -0.11315604f, 0.08052445f, -0.12639789f, 0.10887517f, 0.07751693f, 
    -0.00757816f, -0.06843681f, 0.10256942f, -0.04179941f, -0.03659168f, -0.03483308f, 0.01298806f, -0.08085408f, 
    -0.04056737f, 0.35218480f, 0.01108154f, -0.13720457f, -0.39531374f, 0.17839678f, 0.00304768f, -0.06897021f, 
    -0.04151415f, 0.06382649f, -0.08498308f, -0.07806055f, 0.02846343f, -0.06592686f, 0.05179101f, -0.02273913f, 
    0.01548109f, -0.11953287f, -0.09464242f, -0.20921043f, 0.03980773f, -0.13066672f, -0.25422475f, -0.04465843f, 
    0.16995257f, 0.14205262f, -0.01317474f, -0.00773229f, 0.06159068f, 0.04505254f, 0.04579355f, -0.07138817f, 
    -0.12467144f, 0.00687504f, -0.04485480f, -0.02869569f, -0.02265380f, 0.09430661f, -0.08347616f, 0.02569156f, 
    0.00784294f, -0.10989347f, -0.10629161f, -0.05249097f, 0.24733227f, 0.08659007f, 0.01867685f, -0.01011812f, 
    0.02049638f, 0.05098574f, 0.12496874f, -0.05486004f, 0.02389048f, -0.03481605f, -0.05294686f, -0.05713236f, 
    -0.06852913f, 0.08039033f, -0.07919689f, 0.06542147f, -0.23954824f, 0.62368119f, -0.05498487f, 0.03787572f, 
    0.26715660f, 0.23119611f, -0.01278874f, -0.02917110f, -0.05424660f, 0.02015176f, -0.15324870f, 0.00301363f, 
    0.11198536f, 0.04923925f, 0.11879127f, 0.01364398f, -0.00106593f, -0.04147658f, 0.06945471f, 0.03222404f, 
    -0.16682813f, -0.07905641f, -0.09796834f, 0.15408249f, 0.08189154f, 0.06798630f, -0.01634748f, 0.15838063f, 
    0.11416189f, 0.00781578f, 0.09447190f, 0.04132780f, -0.08359394f, -0.03350395f, 0.03470822f, -0.01404034f, 
    -0.05534278f, 0.08870846f, -0.04056612f, -0.20898384f, 0.18505028f, -0.03096803f, -0.03196543f, 0.07903752f, 
    0.00611077f, -0.12891679f, -0.00718623f, 0.08033554f, 0.14282674f, 0.02524502f, -0.04423678f, 0.02820835f, 
    -0.00072930f, -0.00926853f, 0.00450827f, -0.14886604f, -0.03547425f, -0.01649443f, 0.03628008f, 0.07409389f, 
    -0.03287155f, -0.07767072f, -0.18993786f, -0.06627233f, 0.11222462f, 0.00306958f, -0.04935020f, 0.03596409f, 
    0.07070766f, 0.07675561f, 0.04765760f, -0.05956303f, -0.05127897f, -0.04148153f, -0.02509117f, -0.06061554f, 
    -0.09559717f, 0.08873685f, -0.13197409f, -0.01108962f, -0.00606295f, -0.05091050f, -0.23515846f, 0.04822546f, 
    0.12591137f, 0.01612400f, -0.06186968f, -0.04323508f, 0.09646325f, 0.03168967f, -0.05369412f, -0.02033041f, 
    -0.03505977f, -0.04308160f, -0.03825000f, -0.03467387f, 0.03989805f, 0.03210871f, -0.20001990f, -0.00184080f, 
    -0.12727644f, -0.02762160f, -0.24843210f, -0.12235125f, 0.15479787f, 0.07828926f, -0.01330508f, -0.05156482f, 
    0.02138797f, -0.07224154f, 0.02402545f, 0.02480278f, -0.09593176f, 0.05819932f, -0.01161074f, -0.08722922f, 
    -0.06545749f, 0.15242152f, 0.09283688f, -0.12030680f, -0.11259586f, 0.05506082f, -0.09338591f, -0.05027919f, 
    0.15092719f, 0.00852601f, 0.01588649f, -0.04916710f, -0.03736040f, 0.05930687f, -0.12469894f, 0.04192296f, 
    -0.06767736f, -0.00401416f, 0.02595443f, -0.05894893f, -0.01929549f, 0.12431426f, -0.03508815f, -0.02675259f, 
    -0.10983039f, 0.16597089f, -0.28287911f, -0.09769245f, 0.11319067f, 0.09646683f, -0.01868393f, -0.08477680f, 
    0.01894492f, -0.03883504f, -0.05624230f, 0.02333034f, -0.11449918f, 0.00642618f, -0.05046212f, -0.02619021f, 
    -0.07014234f, 0.05723795f, 0.01232875f, 0.05479123f, -0.51618391f, 0.19741225f, -0.32737333f, 0.09981587f, 
    -0.23924850f, -0.04354592f, -0.14664321f, -0.00027397f, 0.00773442f, 0.06711781f, 0.01655822f, 0.01713250f, 
    0.06768437f, -0.07034823f, -0.16189077f, -0.15554808f, 0.06996834f, -0.02624406f, 0.21154289f, 0.06576479f, 
    -0.06965441f, -0.03588125f, -0.23599163f, 0.15153277f, 0.18239783f, 0.04801605f, -0.02475102f, 0.08956546f, 
    0.03512742f, 0.06941771f, -0.02590274f, 0.01404059f, 0.06086192f, -0.09620638f, -0.00342849f, -0.03025752f, 
    -0.03187849f, -0.06528255f, -0.07970313f, -0.04158678f, 0.02028175f, -0.16201265f, -0.25688824f, -0.04417872f, 
    0.11739671f, 0.03199058f, 0.01951966f, -0.01104310f, -0.02573599f, 0.02641190f, -0.04888757f, 0.00703139f, 
    -0.08651593f, 0.07769345f, -0.05160698f, -0.04591382f, 0.02888197f, 0.05726156f, 0.03809805f, -0.01080725f, 
    0.09659752f, -0.05268278f, 0.08629158f, 0.20904560f, 0.03330180f, -0.01353705f, -0.01284225f, -0.05639831f, 
    -0.10283336f, -0.24779908f, -0.04370303f, -0.01845709f, -0.01092134f, -0.03059544f, -0.10993266f, 0.02250898f, 
    -0.06633634f, 0.17434974f, -0.08190227f, -0.13112694f, -0.15431505f, -0.05842941f, -0.36320812f, 0.02722228f, 
    -0.30428010f, 0.34731072f, 0.27138281f, 0.11217050f, 0.15603015f, 0.11225570f, -0.03574253f, -0.06450827f, 
    0.05390552f, -0.30780396f, -0.08348963f, -0.09874904f, -0.04918439f, -0.02671961f, -0.06514952f, 0.00182970f, 
    0.06670473f, -0.12049001f, -0.08728977f, -0.08920776f, 0.10896726f, 0.07537854f, -0.05504144f, 0.00606529f, 
    0.02074761f, -0.13843004f, 0.03074438f, -0.02251473f, 0.06294417f, -0.02682292f, 0.01246885f, -0.01231725f, 
    0.03110031f, 0.07401346f, -0.00501723f, 0.05793451f, -0.26946551f, 0.22992411f, 0.24881954f, 0.13411824f, 
    -0.10345596f, -0.06152996f, -0.07877599f, -0.12520455f, -0.02977176f, -0.07225718f, -0.04095572f, -0.07069989f, 
    -0.05435358f, 0.03383923f, 0.03071500f, -0.02003387f, -0.03851319f, -0.03674522f, -0.06398769f, -0.12166373f, 
    0.01109824f, -0.25708157f, -0.34989169f, -0.04321755f, 0.27088159f, 0.12870529f, -0.07155011f, 0.05224985f, 
    0.00412735f, 0.01474557f, 0.02812489f, 0.08798849f, 0.08456880f, 0.05135581f, -0.01135568f, 0.11848652f, 
    0.05292645f, 0.12331903f, 0.00238067f, 0.15667136f, 0.09446144f, -0.30105326f, -0.16144396f, -0.05292646f, 
    0.23926343f, 0.16244267f, 0.08348732f, 0.02559020f, -0.03206833f, -0.12462710f, -0.05965802f, 0.04611741f, 
    0.05155670f, 0.00168249f, -0.01123273f, -0.00606330f, 0.02304206f, 0.08925178f, 0.09109369f, -0.05713991f, 
    -0.18891177f, -0.08433077f, -0.07979342f, -0.22912569f, -0.29526725f, 0.01161567f, -0.15252335f, -0.01076369f, 
    -0.09577377f, -0.07000317f, -0.08848097f, -0.12554821f, 0.01672796f, -0.05143417f, -0.11533583f, 0.04368955f, 
    -0.00123740f, -0.01530839f, 0.01342495f, -0.08018067f, 0.16999890f, 0.05081909f, -0.20497680f, 0.14833723f, 
    0.14476992f, -0.01810422f, -0.05222703f, -0.00136656f, -0.03473160f, -0.08730668f, -0.05520642f, 0.05023869f, 
    0.08522969f, -0.03594941f, 0.07063725f, 0.05613262f, -0.04640970f, 0.01642685f, 0.07686628f, -0.07724143f, 
    -0.23999469f, 0.10504420f, -0.01777876f, -0.11715104f, 0.39784202f, 0.16303597f, 0.07247979f, -0.04534842f, 
    -0.00034209f, -0.01437855f, -0.08678084f, 0.03817447f, 0.02678583f, 0.00449210f, 0.03737850f, 0.02135477f, 
    0.05909410f, 0.22004244f, 0.14139087f, -0.14520791f, -0.54321307f, 0.09044390f, -0.08184929f, 0.13920321f, 
    0.12023925f, -0.02802468f, -0.14974864f, -0.04062247f, -0.11241779f, 0.03136312f, -0.00974113f, 0.01924859f, 
    0.04087197f, -0.03513285f, -0.06943591f, 0.09964031f, 0.01260369f, -0.02921588f, -0.02923474f, -0.09581526f, 
    0.26398319f, 0.05789376f, -0.37001187f, 0.16486514f, -0.13984314f, 0.15405399f, 0.10345036f, 0.00479080f, 
    -0.10248913f, 0.12024262f, -0.09926865f, -0.16749673f, 0.04123653f, -0.12599941f, 0.03753914f, -0.05435662f, 
    -0.06552260f, -0.07092278f, 0.21683878f, 0.02239573f, 0.01742179f, -0.31534541f, -0.05468373f, 0.03821326f, 
    -0.03830124f, 0.04504700f, 0.08072682f, 0.13793620f, 0.10620175f, 0.01058242f, -0.05656227f, 0.00821014f, 
    -0.20254834f, -0.07657332f, 0.02329106f, 0.10665960f, -0.13925421f, 0.13288055f, -0.04897982f, -0.20407203f, 
    0.08040071f, 0.31283140f, -0.02505001f, -0.15717775f, 0.07223161f, 0.08067293f, -0.12968636f, -0.18010843f, 
    -0.08127458f, -0.07456058f, -0.11612001f, -0.02428403f, -0.06540652f, 0.01459722f, 0.04045870f, 0.01586150f, 
    0.08127274f, -0.12886536f, -0.04572560f, 0.01563056f, -0.12074015f, -0.23245132f, -0.14092103f, -0.05508012f, 
    -0.22451055f, 0.18153726f, 0.02561343f, 0.00539608f, -0.01730332f, 0.00804687f, -0.06561905f, 0.03912764f, 
    0.02709339f, 0.07553010f, -0.06542643f, 0.04708308f, 0.00520594f, 0.00397409f, -0.24751431f, -0.07988475f, 
    -0.07007032f, -0.01148746f, 0.01929690f, 0.25227088f, 0.16254194f, 0.00120932f, -0.07059471f, 0.01234972f, 
    -0.05391218f, 0.14406633f, 0.05446652f, -0.03117412f, -0.04560873f, -0.09868251f, -0.01437178f, -0.05079520f, 
    -0.10182888f, -0.04382295f, 0.01306440f, -0.18200831f, -0.01271259f, -0.56560481f, -0.08568311f, -0.35667533f, 
    -0.13422650f, -0.20082195f, 0.01554045f, 0.10534266f, -0.06455151f, 0.02084413f, -0.05886322f, -0.07558092f, 
    -0.01937678f, 0.05408174f, -0.14986086f, -0.49357074f, -0.22848226f, -0.03242309f, 0.14562926f, 0.07335331f, 
    0.12563847f, -0.12028256f, -0.00414910f, 0.05751370f, 0.02672397f, -0.26290137f, -0.13935533f, 0.09081418f, 
    0.02788644f, 0.08936411f, 0.02610746f, -0.07916936f, -0.04997298f, 0.00610601f, 0.04622754f, -0.03130951f, 
    -0.04425435f, 0.00314183f, 0.02863960f, -0.03066278f, 0.03574122f, 0.00639068f, -0.02923726f, -0.04666675f, 
    -0.03138450f, 0.09433883f, 0.01189884f, 0.08653267f, -0.01020423f, 0.04436061f, -0.04765813f, -0.02979886f, 
    0.01700428f, -0.02680135f, 0.05067388f, 0.05485393f, 0.04615865f, -0.03083353f, -0.09220316f, -0.01703362f, 
    -0.12548041f, -0.20706341f, -0.08964143f, 0.10875588f, -0.09355270f, 0.00330474f, -0.03454945f, 0.08280700f, 
    -0.26441070f, -0.03169419f, -0.06057579f, -0.00954192f, -0.01398284f, -0.06053314f, -0.20964225f, 0.03461066f, 
    0.05519429f, 0.01615393f, -0.06670866f, 0.20562978f, -0.21545507f, -0.05497604f, 0.11149999f, -0.06500563f, 
    0.07882775f, -0.00805491f, 0.11929746f, -0.08350475f, -0.05092637f, 0.08246073f, -0.00814245f, -0.00336632f, 
    -0.02332777f, -0.06913195f, -0.00007267f, -0.09932555f, 0.00766042f, -0.05468137f, -0.04690909f, 0.04581086f, 
    0.13268572f, 0.15266220f, 0.06326032f, 0.18952985f, 0.12532286f, 0.20725003f, 0.11896632f, 0.01611566f, 
    0.11971228f, 0.16982108f, -0.02182748f, -0.01479420f, -0.00531965f, -0.00946017f, -0.01849980f, 0.01478825f, 
    0.10333618f, -0.13487974f, 0.11021652f, 0.16349298f, -0.01284716f, 0.01219042f, 0.01622668f, 0.12043431f, 
    0.13790479f, 0.05696315f, 0.15901719f, -0.04636820f, 0.00126905f, 0.07700814f, 0.04494461f, 0.08092862f, 
    -0.01983380f, -0.02622510f, -0.01241105f, 0.06901533f, -0.05119250f, -0.14904700f, -0.06735856f, 0.00106987f, 
    -0.14260627f, 0.10162946f, -0.13738927f, -0.09676652f, -0.20242058f, 0.16662346f, -0.04797405f, 0.00380555f, 
    0.08576616f, 0.06590854f, 0.00775180f, 0.07405480f, -0.00508143f, -0.09115898f, 0.04034353f, -0.02015015f, 
    0.03215699f, 0.26148069f, -0.19396840f, 0.13551086f, 0.13805795f, 0.00527726f, -0.03216533f, -0.07362978f, 
    -0.09505150f, 0.13977239f, -0.04494427f, 0.07076801f, -0.08410678f, -0.12658927f, -0.09952490f, -0.04900178f, 
    -0.10448851f, -0.04547400f, -0.05062665f, 0.07470026f, -0.13109472f, -0.04972249f, -0.11284317f, -0.13076426f, 
    -0.05982237f, -0.07770693f, 0.18031318f, 0.06759837f, -0.03961494f, -0.21350370f, -0.03710842f, -0.13208526f, 
    -0.13948873f, 0.06039567f, -0.06079030f, -0.00289141f, 0.03266760f, 0.02694152f, -0.00249805f, -0.04245095f, 
    0.00879353f, -0.05479040f, -0.06534173f, -0.04168789f, 0.01328175f, -0.01135414f, -0.02947755f, 0.19527157f, 
    -0.06137790f, -0.15460041f, -0.08334472f, -0.03330524f, -0.17557056f, -0.07271278f, -0.07780992f, 0.04303496f, 
    -0.05365919f, 0.02632695f, -0.02132171f, 0.02334692f, -0.04390642f, -0.08027200f, 0.03717109f, 0.12564145f, 
    -0.02065641f, -0.04970904f, -0.19328663f, 0.13992132f, -0.20358163f, 0.07576582f, -0.03138153f, -0.03757627f, 
    -0.02679586f, -0.03365926f, -0.11780608f, -0.02355335f, -0.07302324f, -0.01673023f, -0.10703849f, 0.02435268f, 
    -0.11662900f, -0.15242569f, -0.00226932f, 0.03997032f, 0.06202950f, -0.05808929f, 0.16519041f, 0.10396165f, 
    -0.23341992f, -0.02496671f, 0.05697455f, 0.02932143f, -0.08757333f, -0.09575605f, 0.04683746f, -0.12402836f, 
    -0.08213945f, 0.05971157f, 0.04220764f, -0.12763821f, 0.02856816f, -0.00072196f, -0.21173294f, -0.00781225f, 
    0.31127843f, -0.32039914f, -0.09774421f, 0.39157727f, -0.05449477f, 0.07649990f, -0.09648112f, 0.02309953f, 
    -0.03514890f, -0.02737098f, 0.04128746f, -0.10745974f, 0.02820515f, 0.00967110f, -0.00403651f, 0.01419744f, 
    0.03655686f, -0.00406318f, -0.00761638f, -0.23348214f, 0.10352186f, 0.02279484f, 0.16449049f, 0.00210372f, 
    0.05761065f, 0.11292156f, -0.05962703f, -0.06408881f, -0.03471774f, 0.08054118f, -0.09325343f, 0.03803194f, 
    -0.01479338f, 0.04015516f, 0.04959260f, -0.00535283f, -0.03721391f, -0.02779077f, -0.08115437f, -0.09777474f, 
    -0.36255860f, -0.23215233f, 0.09366921f, -0.12319402f, -0.02827447f, -0.19727653f, -0.00440743f, -0.04705089f, 
    0.03972863f, 0.08331105f, -0.01062386f, -0.03100226f, -0.07077236f, 0.03892110f, -0.06660473f, 0.05518459f, 
    0.02837268f, 0.05544163f, -0.00771287f, -0.03532190f, -0.26948035f, 0.00201001f, 0.06191767f, 0.29216418f, 
    -0.03008762f, -0.14905825f, -0.01981333f, -0.14661382f, -0.09737309f, 0.04321383f, -0.12435728f, -0.01693685f, 
    0.04971675f, -0.03037115f, 0.01739201f, -0.02371058f, -0.06364170f, -0.07382662f, -0.15429832f, 0.04741022f, 
    0.06895638f, 0.03393378f, -0.00863357f, -0.03106684f, 0.02096085f, 0.04572263f, 0.06896606f, 0.02469272f, 
    0.03708119f, 0.05995190f, 0.03127890f, -0.12695321f, 0.04329475f, 0.00419410f, -0.03870983f, 0.07665916f, 
    0.01854447f, -0.00603576f, -0.02513143f, 0.02207188f, 0.06555980f, -0.01397599f, -0.01619568f, 0.04057753f, 
    -0.00681951f, 0.15878744f, 0.06628076f, 0.00826802f, 0.01865250f, 0.05987994f, 0.00367731f, 0.02956251f, 
    -0.09504963f, -0.06656548f, -0.01191447f, -0.03992402f, -0.07164778f, -0.17470910f, -0.17255242f, -0.07236367f, 
    0.04005395f, -0.14072277f, -0.20069368f, 0.24598715f, -0.25065061f, -0.00783288f, -0.03881537f, 0.06698032f, 
    -0.10548926f, -0.06126801f, -0.00401647f, -0.02269138f, -0.04379462f, 0.02161915f, -0.05634145f, 0.00470856f, 
    0.17061062f, 0.04578744f, -0.01750180f, 0.22881585f, -0.01774142f, 0.01066927f, 0.14635457f, -0.06072547f, 
    0.00061904f, -0.01812310f, -0.03584125f, -0.16087128f, -0.01483539f, 0.09188087f, 0.02652092f, -0.01228588f, 
    0.05412740f, -0.08705463f, -0.03921122f, -0.05338620f, -0.02944459f, -0.09863710f, 0.00453628f, -0.11990364f, 
    0.31595400f, 0.04915068f, -0.26057559f, 0.46501395f, 0.04558069f, 0.16674265f, -0.02928672f, 0.15210782f, 
    -0.04778118f, 0.09504852f, 0.07723525f, -0.03988708f, -0.01316092f, -0.07117356f, 0.05089465f, 0.05390521f, 
    -0.08994783f, 0.15473393f, -0.17346792f, 0.03095151f, -0.16515616f, -0.04047229f, 0.01477624f, 0.14865969f, 
    -0.02563713f, -0.06025525f, -0.05299265f, 0.03134058f, -0.15934879f, 0.01590418f, 0.02096453f, 0.01613634f, 
    -0.03727738f, 0.12333100f, -0.00490542f, 0.10686330f, 0.13944790f, -0.04788975f, 0.01210849f, 0.21027306f, 
    -0.47336414f, 0.11409251f, -0.19091082f, -0.39512399f, -0.12574160f, 0.08364078f, 0.02618867f, 0.01316470f, 
    -0.00086586f, 0.07121500f, 0.02703134f, 0.03291702f, 0.11436450f, 0.06831851f, 0.03413473f, 0.01703027f, 
    0.10575976f, -0.03457056f, -0.18179260f, 0.02693872f, 0.01545379f, -0.00608091f, 0.00232673f, 0.03678592f, 
    0.06394772f, 0.02055633f, 0.04256600f, 0.01436117f, 0.06925774f, 0.00210393f, 0.12002763f, 0.00724808f, 
    0.01816121f, -0.00489221f, 0.07528999f, -0.01305156f, -0.06474143f, 0.05787295f, -0.02644634f, -0.01756170f, 
    0.09967965f, 0.01345038f, 0.09193616f, 0.04627381f, 0.02898891f, -0.16216795f, -0.05024606f, -0.10801150f, 
    0.12050869f, 0.03433895f, 0.09215844f, -0.05129872f, -0.00767018f, 0.01300368f, 0.04849437f, 0.06863572f, 
    0.01689253f, 0.04374815f, -0.02496940f, -0.04205753f, 0.02752872f, -0.07633408f, -0.27385947f, 0.19347943f, 
    -0.17255208f, 0.06401870f, 0.04339759f, -0.04603583f, -0.08140443f, -0.02345091f, 0.06331985f, -0.06215679f, 
    -0.08552351f, 0.07122000f, -0.02241257f, -0.02220699f, 0.01245615f, 0.01556223f, -0.06669284f, -0.06576226f, 
    -0.03870981f, 0.16388722f, 0.06428863f, -0.03920579f, 0.03705783f, -0.00602227f, 0.00239968f, 0.04750832f, 
    0.03065787f, 0.08109848f, 0.02382306f, -0.00448762f, 0.00646465f, 0.02478308f, -0.04462423f, 0.05209373f, 
    0.08332262f, 0.08900412f, 0.12168661f, 0.28880566f, 0.02351984f, 0.01195178f, -0.16418460f, 0.02737427f, 
    0.12021711f, 0.08190517f, 0.01052526f, 0.03436208f, 0.01701560f, -0.01843630f, 0.10499546f, 0.04610999f, 
    0.01630026f, -0.03643122f, 0.05591575f, -0.02205101f, -0.09861956f, 0.05809134f, -0.08428191f, 0.02806955f, 
    -0.04783672f, -0.16244654f, 0.13565837f, 0.07489211f, 0.01909867f, -0.09941954f, 0.07455895f, 0.08858985f, 
    -0.15158431f, -0.09183379f, -0.00731938f, -0.01279329f, 0.01920308f, 0.06114829f, 0.01477608f, 0.07008874f, 
    0.11027656f, -0.06344508f, -0.04541261f, 0.04250208f, -0.04624364f, -0.09086526f, 0.17807452f, -0.14366065f, 
    0.01766581f, 0.00963582f, -0.04601964f, 0.16785055f, -0.22451255f, -0.02609593f, -0.02323883f, -0.15168163f, 
    0.14466099f, -0.05991630f, -0.05542592f, 0.02807892f, -0.03756718f, -0.00328538f, -0.08188511f, -0.17774683f, 
    0.17061058f, -0.60143113f, -0.13058077f, -0.19559631f, -0.16371278f, 0.08651502f, -0.06706057f, -0.00640593f, 
    0.07693025f, 0.09097286f, 0.03254651f, -0.00306929f, 0.02663342f, 0.05357099f, -0.06556983f, -0.00328143f, 
    0.01390153f, 0.02098837f, -0.07265823f, 0.12027509f, 0.01032409f, -0.00570188f, -0.01682454f, -0.00661633f, 
    -0.01355611f, 0.09571245f, -0.00284160f, 0.08941150f, -0.07648496f, -0.04197976f, 0.00834074f, -0.04263869f, 
    0.07307952f, -0.08902855f, -0.02841682f, 0.03526339f, -0.07545111f, -0.03185158f, -0.12302134f, -0.08326292f, 
    -0.08531979f, -0.02528216f, 0.00950990f, -0.13529468f, -0.06287628f, 0.01099174f, 0.05980700f, -0.01321792f, 
    0.07649764f, -0.01169944f, -0.09317613f, -0.13950598f, -0.08834200f, -0.06890587f, -0.00176311f, -0.00690254f, 
    -0.06449848f, -0.06206290f, -0.06165528f, -0.01847997f, -0.16102774f, -0.19548194f, -0.02579699f, -0.14850639f, 
    0.04503593f, -0.01622319f, 0.03049412f, 0.01428123f, 0.10884260f, -0.00444358f, -0.00635659f, -0.01743062f, 
    0.02880108f, -0.01634276f, 0.05131961f, -0.13056891f, 0.04579386f, 0.05390417f, -0.11489679f, -0.00568856f, 
    0.15324178f, -0.17799833f, -0.09580459f, -0.11158145f, -0.11963781f, 0.01075915f, 0.02045295f, 0.03739128f, 
    -0.00373193f, 0.02249341f, -0.05471000f, -0.05352775f, -0.04715520f, -0.05057983f, -0.00364093f, -0.10252178f, 
    -0.04948696f, 0.04087247f, -0.00988999f, -0.11412936f, 0.05399586f, 0.17805420f, 0.19284643f, 0.14959869f, 
    0.14562804f, -0.13631813f, -0.01735142f, 0.05757086f, -0.01667744f, 0.14162154f, -0.00828368f, 0.02595008f, 
    0.03081084f, 0.05186646f, 0.03341868f, -0.01372477f, -0.03043953f, -0.07661789f, -0.01271374f, -0.22903185f, 
    0.10478730f, 0.22377759f, 0.24984600f, 0.14454630f, 0.10922977f, -0.08335482f, -0.06946167f, 0.04446457f, 
    -0.00486650f, 0.17902124f, 0.04271514f, 0.04849297f, 0.04507879f, -0.00344026f, -0.00581684f, 0.01033308f, 
    -0.03272568f, -0.03620338f, 0.01054515f, -0.15777892f, -0.21022393f, -0.21331538f, 0.20506763f, -0.02013581f, 
    0.00643136f, -0.13285136f, 0.02883199f, -0.07287054f, -0.02430023f, 0.02851913f, 0.06954432f, 0.02385395f, 
    -0.10728220f, 0.02655194f, -0.07158523f, 0.03673662f, 0.06299818f, 0.05501927f, -0.03094100f, -0.02217545f, 
    0.02309725f, 0.01182581f, 0.16203278f, 0.02299889f, 0.18947461f, -0.03728002f, -0.03239026f, -0.00372860f, 
    -0.02271456f, 0.07781643f, -0.04167762f, 0.05853645f, -0.01359895f, -0.04193939f, 0.01513675f, 0.02482302f, 
    -0.04082145f, -0.10328630f, -0.18950741f, -0.23045491f, -0.56135249f, 0.13163517f, -0.29683802f, -0.38790396f, 
    -0.10712125f, 0.05116254f, 0.03542104f, -0.04903707f, 0.06774097f, 0.00546748f, 0.03388104f, 0.00333475f, 
    0.03043940f, 0.05840543f, -0.03127030f, 0.21281023f, 0.09715149f, 0.15152699f, -0.02608397f, 0.19442876f, 
    0.09110312f, 0.08684501f, 0.21771388f, 0.09654789f, 0.10202876f, -0.05629554f, -0.05236435f, 0.06303593f, 
    0.09793835f, 0.10663985f, -0.01234222f, -0.02178055f, -0.02490367f, 0.00824493f, 0.01945274f, -0.01028194f, 
    -0.05108806f, -0.03369651f, -0.02582556f, -0.08426581f, 0.04981292f, 0.09738547f, 0.23363610f, 0.17824765f, 
    0.15319403f, -0.17165641f, 0.10280345f, -0.00028260f, 0.08566716f, 0.13443121f, 0.07205702f, 0.01881801f, 
    0.01008184f, 0.08208252f, 0.09607952f, -0.03344305f, -0.01086834f, -0.11050660f, 0.02169921f, -0.00380186f, 
    -0.00884242f, 0.09608757f, 0.02501609f, -0.03799136f, -0.12096169f, -0.05382784f, -0.13836826f, 0.03019045f, 
    0.04656312f, -0.06554150f, 0.07831145f, -0.00199657f, -0.00100874f, 0.00697964f, 0.04249781f, 0.01886888f, 
    -0.11571516f, -0.04238724f, -0.03865449f, -0.08388008f, -0.10759363f, -0.14270091f, 0.05712525f, 0.06679367f, 
    0.04917084f, -0.09586774f, 0.05926782f, 0.02951294f, -0.12095031f, -0.07516418f, -0.01703660f, -0.00803756f, 
    0.00705432f, 0.02433923f, -0.00192734f, 0.02972545f, 0.12126262f, -0.03951892f, -0.01028040f, 0.05392307f, 
    0.00435294f, 0.01681137f, 0.07928858f, 0.05292177f, -0.09852416f, -0.00826332f, -0.07835295f, -0.06474907f, 
    -0.18069872f, 0.02984183f, -0.10237112f, -0.00813007f, 0.01521468f, 0.02376309f, 0.02422951f, 0.01116676f, 
    -0.06686243f, 0.01448419f, -0.11140916f, -0.04520573f, 0.02196196f, 0.07820430f, 0.02851037f, -0.21336922f, 
    -0.26775646f, 0.10710888f, -0.09775395f, 0.00962130f, 0.08917493f, 0.02465019f, 0.02065654f, 0.05778072f, 
    -0.05552772f, 0.02245811f, -0.03975342f, -0.07447097f, 0.06593871f, -0.06239512f, -0.14107206f, -0.04188158f, 
    0.14868587f, 0.03949690f, 0.38197729f, 0.12579899f, 0.25824121f, -0.13001488f, 0.10346700f, 0.03095075f, 
    0.01182918f, 0.06521879f, 0.07450574f, -0.01488980f, -0.02318995f, -0.00128796f, 0.05410522f, 0.00285594f, 
    -0.00411919f, -0.07590040f, 0.06822009f, -0.18320043f, 0.05994942f, 0.06136019f, 0.12791710f, 0.08388755f, 
    0.08652009f, -0.14601785f, -0.00766284f, 0.01803439f, 0.12481014f, 0.06966560f, 0.02644337f, 0.01455925f, 
    -0.00659644f, 0.02507568f, 0.02888042f, 0.01431277f, -0.02351595f, -0.03524267f, 0.01481906f, -0.00207313f, 
    -0.14301944f, -0.04830393f, -0.08834834f, -0.16474973f, -0.06702821f, 0.04453376f, -0.03481091f, -0.05209718f, 
    0.06276297f, 0.02966005f, -0.03159423f, -0.06642664f, 0.10608327f, -0.13266367f, -0.04206542f, -0.01895879f, 
    -0.02238245f, -0.04706594f, -0.08162128f, 0.03921207f, 0.15635824f, 0.16318657f, 0.12322375f, -0.06914209f, 
    -0.07081496f, 0.06581054f, 0.04905682f, -0.00336225f, 0.05501888f, 0.09471945f, -0.05471005f, -0.02031170f, 
    0.04702753f, 0.08954426f, -0.04249996f, 0.04350877f, 0.02498492f, 0.04339359f, -0.01286469f, -0.01476561f, 
    -0.02880997f, -0.10212024f, 0.00652945f, 0.10775438f, 0.02735312f, -0.09909026f, -0.02375636f, -0.02960333f, 
    -0.01740992f, -0.08365389f, -0.01084804f, 0.03887257f, -0.13813439f, 0.04367648f, -0.03943558f, 0.02395655f, 
    0.04461120f, 0.02414239f, 0.04256466f, 0.04008194f, 0.01457878f, 0.01577170f, -0.22735299f, -0.09935196f, 
    -0.06610384f, 0.11951454f, -0.00792150f, 0.04251361f, -0.00495878f, 0.02862456f, 0.00266372f, 0.06493633f, 
    0.04804371f, -0.01800923f, -0.01883039f, 0.11680336f, -0.14547886f, -0.00503945f, -0.13156560f, -0.05231428f, 
    0.16075684f, 0.20651799f, 0.28698641f, 0.20311645f, 0.07527692f, -0.13136111f, -0.05928038f, -0.14825660f, 
    0.03738517f, 0.15434793f, 0.03450799f, 0.00413905f, 0.04986616f, 0.04943172f, 0.04446280f, 0.03124319f, 
    -0.07025469f, 0.03136357f, 0.03201694f, -0.05706010f, 0.09631350f, 0.06024959f, 0.09803157f, 0.09558094f, 
    0.01868267f, -0.03864324f, -0.04123898f, -0.06200653f, 0.04350204f, 0.06281233f, 0.17900240f, -0.00380744f, 
    -0.15036337f, 0.00603563f, 0.03629075f, 0.09399688f, 0.02665033f, -0.02837673f, -0.04124200f, -0.04465038f, 
    0.02104638f, 0.01279453f, -0.08311789f, -0.02914719f, -0.07550115f, 0.05280181f, -0.01406765f, 0.02470327f, 
    0.02831483f, 0.00449819f, 0.02001189f, -0.02387852f, -0.04998422f, -0.05762662f, -0.00940002f, 0.02841576f, 
    -0.04442005f, -0.00665137f, -0.00492729f, 0.01382221f, -0.24618265f, -0.04594878f, 0.10657623f, 0.09678324f, 
    0.13554691f, -0.08077915f, 0.04102892f, -0.10941404f, -0.15645537f, 0.04589440f, -0.09672018f, -0.01686817f, 
    0.02914962f, -0.04925020f, -0.04601547f, -0.12704562f, -0.02682449f, 0.05508672f, -0.08673128f, -0.06233170f, 
    0.21407260f, 0.07076067f, 0.13093491f, 0.10136645f, -0.04074685f, -0.00356427f, -0.03744324f, -0.02522829f, 
    -0.02373517f, 0.03807954f, 0.15392461f, -0.07211857f, -0.04288138f, 0.02542143f, 0.00729570f, 0.08190562f, 
    0.04488374f, -0.01302253f, -0.06260991f, -0.04235455f, 0.09904566f, -0.11161185f, 0.02674717f, -0.08172746f, 
    -0.04354741f, 0.04974626f, 0.03367832f, 0.08801534f, -0.05650510f, -0.06065169f, 0.01145437f, -0.09272851f, 
    -0.04915166f, 0.08438621f, -0.10632943f, 0.01660455f, -0.02272283f, -0.10138334f, -0.12785466f, -0.12642708f, 
    0.34686559f, -0.56901991f, -0.07565235f, 0.06017527f, -0.27896821f, 0.03196844f, -0.10155300f, 0.00496388f, 
    0.10242544f, 0.01354352f, -0.03362182f, 0.02131121f, -0.11048634f, -0.02636042f, -0.06008454f, -0.04871461f, 
    -0.03364888f, 0.05447958f, -0.23982184f, 0.02276989f, 0.04670484f, 0.05574796f, 0.04286442f, 0.00764819f, 
    0.07617758f, 0.11166070f, 0.06389758f, 0.04759492f, 0.04220185f, 0.08947610f, 0.02523529f, 0.03618279f, 
    0.05964299f, 0.02741770f, -0.02719144f, 0.05866528f, -0.06889997f, -0.01731681f, -0.02147972f, -0.06104555f, 
    -0.09299515f, -0.25252038f, -0.11082050f, -0.04692568f, -0.11236862f, -0.11373643f, -0.11791589f, 0.01076790f, 
    -0.07694567f, -0.03609859f, -0.03360011f, -0.07772721f, 0.01188935f, -0.03884736f, 0.04728011f, -0.10280801f, 
    -0.16320950f, 0.02885791f, -0.06296726f, -0.02232138f, 0.11934327f, 0.06825277f, -0.03424627f, -0.00651149f, 
    -0.02045931f, 0.08321638f, 0.01731796f, 0.03087744f, 0.01043466f, 0.03260884f, -0.00085374f, -0.02464185f, 
    0.04081706f, -0.22274348f, 0.04218517f, 0.06472304f, -0.03319156f, -0.01709506f, -0.05933565f, -0.02410769f, 
    -0.09602229f, -0.13590693f, -0.04354883f, 0.21769252f, -0.14193349f, 0.00337458f, 0.02389645f, 0.01383774f, 
    0.03212409f, -0.01538803f, -0.05730778f, 0.07104013f, -0.01461409f, -0.00624906f, 0.01350802f, 0.04706912f, 
    -0.01623712f, 0.12299822f, -0.11075717f, 0.03172041f, 0.41384947f, -0.36506042f, 0.17492919f, 0.07144290f, 
    -0.10313365f, -0.01971417f, -0.08904786f, -0.20510879f, -0.08599463f, 0.20205407f, 0.02222751f, 0.00519818f, 
    -0.11073213f, 0.06046949f, 0.16229630f, 0.15167078f, -0.10548633f, -0.04900051f, 0.09092976f, 0.19957504f, 
    -0.36558032f, -0.21291699f, -0.13334580f, -0.00446340f, -0.20533183f, 0.13807981f, -0.10790357f, -0.20571311f, 
    0.09011149f, 0.21029110f, 0.09221853f, 0.04975234f, -0.04543732f, -0.03414703f, -0.11114958f, 0.00405574f, 
    0.01124054f, 0.05806815f, 0.04294403f, 0.07503019f, -0.07237901f, -0.00342197f, -0.06191787f, -0.03342227f, 
    0.06896131f, 0.00915949f, -0.02982118f, -0.03786197f, -0.03242929f, -0.03643422f, 0.24594361f, 0.11552694f, 
    0.03156466f, -0.08396300f, -0.01639954f, 0.05743593f, 0.04647776f, -0.02719464f, 0.06601812f, 0.07090029f, 
    -0.26548401f, -0.07215729f, 0.20510577f, -0.05423801f, -0.28752664f, -0.02938211f, -0.00508542f, 0.14536367f, 
    -0.00118085f, -0.09440049f, -0.01875349f, -0.01082723f, -0.05427707f, -0.01746022f, -0.05738304f, -0.00299461f, 
    -0.06450802f, -0.06969897f, -0.04380638f, -0.11785848f, -0.06904026f, 0.10757972f, -0.15042770f, -0.10436225f, 
    -0.06792530f, -0.06049336f, -0.08465786f, 0.03216873f, -0.10845337f, -0.06052994f, -0.08774459f, -0.03335148f, 
    -0.13147905f, -0.03684809f, 0.04574770f, -0.15489626f, -0.10310518f, 0.08275715f, -0.08684008f, -0.15829761f, 
    0.01000960f, 0.10070401f, 0.12921774f, 0.01178376f, -0.10482791f, 0.05975665f, 0.05221414f, 0.02342878f, 
    0.07609852f, 0.02894809f, 0.04029874f, 0.03796821f, -0.00312994f, -0.01323114f, -0.02059716f, -0.06368114f, 
    -0.01681654f, 0.07298115f, -0.16395073f, -0.12662373f, -0.09794190f, -0.03540765f, -0.07461733f, -0.05408665f, 
    -0.02405819f, 0.05231205f, -0.09500184f, 0.11936998f, -0.05814824f, -0.02684300f, -0.04752083f, -0.03653020f, 
    0.01717305f, -0.03442811f, 0.03556365f, -0.02710929f, 0.07399460f, 0.11319811f, -0.03243421f, 0.01865793f, 
    0.08723488f, 0.74715757f, -0.41906554f, 0.12944663f, 0.03056682f, -0.00428921f, -0.04080104f, -0.04897808f, 
    -0.00910879f, -0.01739235f, 0.06569443f, -0.09933035f, -0.03662356f, 0.01072449f, -0.06217001f, -0.09570937f, 
    -0.15610999f, 0.14535952f, 0.03569978f, -0.27637768f, 0.06453808f, 0.05244431f, 0.09481773f, -0.04594736f, 
    -0.13292946f, -0.25247541f, 0.17504279f, -0.11802250f, -0.13348602f, 0.14744608f, 0.18298779f, -0.06780106f, 
    0.06556071f, 0.09531296f, -0.00290328f, 0.12433146f, 0.08271813f, 0.00266640f, 0.21086457f, 0.01978919f, 
    -0.38586456f, 0.13699284f, -0.23632199f, -0.35525313f, -0.17270814f, -0.05573264f, -0.02562339f, 0.00992191f, 
    -0.13740316f, 0.08288227f, -0.07491070f, 0.08346897f, -0.11442760f, 0.00468729f, 0.05587409f, -0.03576577f, 
    -0.10083201f, 0.04030249f, -0.09339596f, -0.00378980f, 0.01093081f, -0.07239173f, 0.15288676f, 0.09489048f, 
    -0.24340242f, 0.08378428f, 0.02178169f, 0.13558082f, -0.08182490f, -0.00222740f, 0.07708062f, -0.02587612f, 
    -0.00490942f, -0.03179090f, 0.03155504f, -0.09252118f, -0.00645769f, 0.02646238f, 0.10399161f, -0.05796871f, 
    0.13124844f, -0.05214613f, 0.22968215f, -0.03722610f, -0.23373669f, -0.00786021f, 0.00223884f, 0.08936612f, 
    -0.04443602f, 0.18364607f, 0.06996433f, -0.08467763f, -0.00311531f, 0.00384109f, 0.01152537f, 0.10675325f, 
    -0.02411325f, 0.03637688f, -0.00757509f, -0.01070802f, -0.42715329f, -0.09546532f, 0.16832298f, -0.21737713f, 
    0.23925421f, 0.05967982f, 0.04280521f, -0.04681157f, -0.02840077f, -0.02726657f, 0.08049198f, -0.10013396f, 
    0.14419401f, -0.12632787f, -0.00973074f, 0.05400791f, -0.18587346f, -0.35400084f, 0.26281726f, -0.10139178f, 
    -0.34125546f, 0.18748467f, 0.37615973f, 0.12094375f, -0.20683677f, -0.09841678f, -0.01720650f, -0.07238264f, 
    0.10738156f, 0.17121899f, -0.07849820f, 0.04331868f, -0.07103916f, -0.05936084f, -0.05647394f, 0.08049686f, 
    -0.12167444f, -0.11313067f, -0.04810046f, 0.14724104f, 0.15156609f, -0.08287848f, 0.11821064f, -0.03319550f, 
    -0.07361674f, -0.06608541f, -0.03889266f, -0.02013059f, 0.09740239f, 0.07744031f, 0.02371377f, -0.00830639f, 
    -0.03666759f, -0.02426398f, -0.05846322f, -0.00951719f, 0.03572368f, -0.01423962f, -0.00096900f, 0.18513161f, 
    -0.22295222f, -0.35546675f, -0.34332865f, -0.15713389f, -0.01723165f, 0.04104490f, 0.00736875f, -0.04254498f, 
    -0.05189420f, -0.09122686f, -0.11382045f, 0.06651019f, 0.07877497f, 0.03847664f, 0.11397704f, -0.09042615f, 
    0.00153588f, 0.09678553f, 0.00877542f, 0.00920539f, 0.07552445f, -0.25579450f, 0.16555542f, 0.26683268f, 
    -0.57083279f, 0.16439524f, -0.00168095f, 0.10467490f, 0.09430921f, 0.00097847f, -0.00002936f, 0.05641921f, 
    -0.08422411f, 0.00218888f, 0.17208850f, -0.13398914f, 0.04237541f, 0.08022990f, 0.17533427f, 0.09350074f, 
    -0.10414284f, 0.02254765f, -0.09120947f, 0.07428838f, 0.00236584f, 0.07224055f, -0.03409258f, -0.13830209f, 
    0.00988241f, 0.05987501f, 0.08376513f, 0.04098557f, -0.05054811f, 0.07513391f, 0.00713721f, -0.02236149f, 
    0.08911520f, 0.10368561f, 0.01922218f, -0.02794940f, 0.02997970f, -0.07332698f, 0.02758553f, -0.09340561f, 
    0.04995464f, -0.03078837f, 0.11330108f, 0.04729374f, -0.17609021f, 0.00768153f, 0.00911245f, -0.10779744f, 
    -0.12667082f, 0.05942760f, 0.03321502f, 0.02811860f, 0.03141039f, -0.01663453f, -0.01215557f, 0.18877326f, 
    -0.31347787f, 0.11435173f, 0.20312312f, 0.12177287f, -0.13994417f, 0.06934793f, -0.02186153f, -0.06794065f, 
    0.16006120f, -0.05229659f, -0.04196005f, 0.02937918f, 0.00307404f, -0.03194840f, -0.00706860f, -0.09038863f, 
    -0.01718972f, 0.07023880f, -0.11482694f, -0.17107563f, 0.22671890f, 0.08043225f, -0.04216242f, -0.14511032f, 
    0.03460089f, -0.09968597f, 0.11308489f, 0.01480198f, -0.06334814f, 0.07917977f, -0.09056132f, -0.03614395f, 
    -0.02543260f, -0.04695271f, 0.03372832f, 0.05485642f, 0.09220909f, 0.01548425f, 0.08548710f, 0.17017357f, 
    -0.62122804f, 0.36777198f, 0.03032679f, 0.33913663f, 0.02373019f, 0.10908363f, -0.36875725f, 0.13335679f, 
    0.14353612f, -0.17327251f, -0.08610646f, 0.06214292f, -0.04431391f, 0.00352763f, -0.00984546f, 0.23638453f, 
    -0.08938019f, 0.29804468f, 0.06272315f, -0.02039521f, -0.05120626f, 0.01490434f, 0.21369280f, 0.21371764f, 
    -0.16468741f, -0.09309175f, 0.03445926f, 0.10595984f, 0.15150191f, -0.04717393f, 0.03392927f, 0.00405906f, 
    0.04143934f, -0.08626188f, 0.02536022f, -0.09096586f, -0.04458513f, -0.11795849f, -0.18205367f, -0.19928208f, 
    0.05912816f, -0.12484908f, -0.23025358f, -0.19336745f, 0.21984680f, -0.04106536f, 0.02251870f, 0.01333310f, 
    -0.02290387f, 0.02696921f, 0.15136513f, -0.04629717f, -0.02292156f, -0.12327195f, -0.03490102f, -0.05557400f, 
    -0.06284489f, -0.02561940f, -0.00562252f, -0.10834244f, -0.07624079f, -0.19512019f, -0.14870095f, -0.00775168f, 
    0.08737548f, 0.05762302f, -0.01312432f, -0.03930084f, -0.04619328f, 0.07020157f, 0.01193134f, -0.01813455f, 
    0.00445476f, 0.08601912f, 0.02408094f, -0.00978973f, 0.07067022f, 0.09974056f, -0.04950442f, -0.00638991f, 
    -0.21527253f, -0.00413692f, -0.15834476f, -0.11120620f, -0.14230314f, 0.03175944f, -0.03324142f, 0.00657725f, 
    0.01168272f, 0.22705010f, 0.02935098f, -0.04251416f, -0.02281931f, -0.03111590f, -0.10636478f, -0.02647107f, 
    0.04542028f, 0.02944340f, -0.01973472f, 0.01897806f, -0.16522025f, -0.07143264f, 0.06289978f, 0.05769643f, 
    -0.05730192f, 0.13467450f, -0.11296030f, -0.00871507f, 0.03646142f, 0.08637625f, -0.03200032f, -0.13645336f, 
    0.00145118f, 0.00026006f, -0.04760915f, 0.06236150f, 0.03520489f, -0.04959740f, 0.00385917f, 0.01565808f, 
    0.18971887f, 0.13578357f, 0.09843633f, -0.01596661f, 0.23730290f, 0.04659666f, 0.06781501f, -0.04977926f, 
    0.04093347f, -0.07048822f, 0.01768140f, 0.05630024f, 0.03053272f, 0.01215917f, -0.04092862f, -0.13002747f, 
    -0.09184443f, -0.27527180f, -0.16983046f, -0.38569200f, 0.06577582f, -0.20484751f, -0.31161880f, 0.09896163f, 
    -0.00045680f, 0.05827788f, 0.06091473f, 0.00829863f, -0.03074956f, 0.04178194f, 0.03251005f, -0.03817214f, 
    0.00724928f, -0.05072379f, -0.05419329f, 0.08784497f, -0.07510526f, 0.16857716f, -0.07277559f, -0.07759888f, 
    -0.22518396f, -0.12018236f, 0.17702954f, -0.09169209f, -0.13382488f, 0.04154512f, 0.04257609f, 0.00900249f, 
    -0.06593335f, 0.02353299f, 0.03386496f, -0.00150092f, 0.01504308f, 0.08151217f, 0.03135554f, 0.05638400f, 
    -0.03356335f, -0.10438786f, -0.04962397f, -0.12882926f, 0.27333301f, 0.08758476f, -0.11802910f, -0.12023772f, 
    -0.00323262f, 0.00764497f, -0.08078548f, -0.00228944f, -0.06133302f, 0.20084873f, -0.02930844f, 0.05419739f, 
    -0.08836372f, -0.00155348f, -0.06212384f, -0.03675707f, 0.06150452f, -0.00291506f, 0.08550563f, -0.00129567f, 
    -0.40911564f, 0.55736089f, -0.16828315f, -0.01458920f, -0.01099031f, -0.06648020f, -0.03112982f, -0.06812663f, 
    0.07199261f, 0.02678838f, 0.12931836f, -0.06670259f, -0.12216841f, -0.05951598f, -0.14166249f, -0.17475140f, 
    -0.02543399f, 0.12877598f, 0.04482462f, -0.05581581f, 0.13966346f, -0.01054216f, -0.12671782f, 0.03407903f, 
    0.04077830f, 0.07375834f, -0.05728569f, -0.03018355f, -0.04206406f, 0.03340474f, -0.08721211f, -0.07601578f, 
    -0.03596938f, -0.04526664f, -0.09322175f, 0.13366462f, 0.09856983f, 0.01292426f, -0.04953559f, 0.02054396f, 
    0.13003376f, -0.35023552f, -0.06208737f, -0.02343250f, 0.08082354f, 0.11399967f, -0.15232857f, -0.09173086f, 
    -0.00072485f, 0.17013583f, 0.04463200f, 0.13015524f, 0.04088781f, 0.06760404f, -0.05356414f, 0.04854829f, 
    0.16055170f, -0.04450593f, -0.01334400f, 0.18138829f, -0.02337017f, -0.32264301f, 0.01115599f, 0.08303469f, 
    -0.06266066f, 0.09405933f, 0.02334614f, -0.00925621f, -0.02080388f, 0.14019100f, 0.01199553f, 0.06983048f, 
    0.04701416f, -0.01199330f, 0.02190739f, -0.16630232f, -0.13666598f, 0.14371158f, -0.02690048f, 0.14174320f, 
    -0.08782773f, -0.18899576f, -0.07111134f, 0.05774745f, 0.05655456f, 0.00354273f, -0.17493165f, -0.14745829f, 
    0.00786947f, -0.01423559f, 0.05169096f, 0.09072523f, -0.06033054f, -0.01336143f, -0.03503691f, -0.04874428f, 
    -0.04199496f, 0.03550491f, 0.14177911f, 0.27515447f, 0.11294712f, -0.10336016f, 0.24867932f, -0.09561275f, 
    -0.18624720f, -0.00137072f, 0.08450200f, 0.03937680f, -0.12747841f, -0.05272958f, 0.03645806f, 0.04663887f, 
    0.01736691f, 0.00814956f, 0.03094815f, 0.00897446f, 0.07440522f, -0.04673674f, 0.09861140f, 0.11828253f, 
    0.14633662f, 0.07679728f, 0.18719777f, -0.08484738f, 0.08085839f, 0.09833589f, 0.03757910f, 0.13503820f, 
    -0.14872909f, -0.10215364f, -0.00898743f, -0.01411610f, 0.00128392f, 0.02488848f, 0.01957669f, 0.01125831f, 
    0.01453338f, -0.03213844f, 0.05766456f, 0.13695590f, -0.28646141f, -0.21314870f, -0.39755234f, -0.37542534f, 
    -0.10132951f, 0.06129678f, 0.06755101f, -0.00684524f, -0.06424575f, -0.02853960f, -0.06017393f, 0.07343291f, 
    -0.03666335f, -0.02416882f, -0.00855061f, -0.07086367f, -0.04176829f, 0.05309389f, -0.00092391f, 0.02007505f, 
    0.08113363f, -0.08343103f, 0.06418430f, -0.07993998f, -0.07954508f, 0.07819035f, 0.04355696f, 0.09877867f, 
    0.12088505f, -0.11532087f, -0.00859555f, -0.03551325f, 0.01106344f, -0.04116520f, -0.02513599f, -0.00333966f, 
    0.06956358f, 0.04475705f, -0.00957613f, 0.24535896f, 0.39471647f, -0.10675558f, -0.22979939f, -0.21038431f, 
    0.19360960f, 0.06108886f, -0.04247892f, -0.03990823f, -0.02481181f, 0.00361296f, 0.04669156f, 0.01676321f, 
    0.06341406f, -0.01495665f, 0.00383125f, -0.30021417f, -0.03223531f, -0.12727395f, 0.11654894f, -0.08822261f, 
    0.15240876f, 0.02894783f, 0.20867252f, -0.02741859f, -0.04420741f, 0.03700619f, -0.00077983f, -0.04661176f, 
    -0.02340246f, -0.01539375f, 0.07518405f, 0.02428379f, 0.00664722f, -0.01527212f, 0.02463678f, 0.03320089f, 
    0.02152328f, -0.02216566f, 0.06025537f, 0.14371483f, 0.24311496f, -0.17116791f, 0.22380880f, 0.07269962f, 
    -0.26490223f, 0.35058132f, 0.19334203f, -0.00582298f, -0.04206230f, -0.01158182f, 0.06649300f, 0.02690344f, 
    -0.01474636f, 0.05866332f, 0.02617421f, -0.03497297f, 0.06339111f, -0.02018947f, 0.03897708f, 0.03019922f, 
    0.02994394f, -0.01302015f, 0.15661025f, -0.00787222f, -0.04990937f, -0.05296718f, -0.03467939f, -0.14394696f, 
    0.00722767f, 0.13146795f, 0.12865326f, 0.11907291f, -0.04068118f, -0.05052331f, -0.01642911f, 0.03700801f, 
    0.03521199f, -0.04661858f, 0.04059914f, 0.11067162f, -0.13372028f, -0.05588629f, 0.12569125f, -0.03622053f, 
    -0.12612486f, 0.01336969f, -0.00954107f, 0.03898748f, -0.02426231f, -0.01894697f, 0.00396273f, 0.04540484f, 
    -0.01809270f, 0.00591480f, 0.03224242f, -0.00080660f, -0.03896223f, -0.04082503f, -0.10250166f, -0.13570094f, 
    0.01416137f, -0.09894707f, 0.13279188f, -0.14786121f, -0.21991506f, -0.00877779f, 0.05493871f, -0.01186606f, 
    -0.02598245f, -0.00915791f, 0.10858755f, -0.01564561f, -0.00318983f, -0.07143851f, 0.04317338f, 0.03250919f, 
    0.02774440f, -0.01599170f, 0.03218790f, 0.05980548f, 0.07986334f, -0.09170116f, -0.29335597f, -0.14581870f, 
    0.19663490f, 0.08024488f, 0.09222340f, -0.01720354f, -0.06238093f, -0.10971323f, 0.01138939f, -0.05753681f, 
    -0.10022421f, 0.02937094f, 0.09180063f, -0.03154222f, -0.07137333f, -0.02692829f, -0.12294389f, -0.09369744f, 
    0.28099415f, -0.08598788f, 0.13521457f, 0.02072359f, -0.28401494f, 0.15304565f, 0.09749521f, -0.25687632f, 
    0.01014472f, 0.07083476f, 0.00430972f, 0.02528842f, -0.03762102f, 0.02873681f, -0.01507846f, -0.02320673f, 
    0.05044875f, -0.03893721f, 0.02801241f, 0.19586743f, -0.05653946f, 0.04158186f, 0.18935828f, -0.11839765f, 
    0.00000819f, 0.12175230f, 0.01481418f, 0.00723531f, 0.14721806f, 0.00400304f, 0.00401687f, 0.01175426f, 
    0.01605937f, 0.04871562f, -0.00040196f, 0.04020044f, 0.01530445f, -0.03257386f, 0.02664573f, 0.07134716f, 
    0.46508560f, 0.04835523f, -0.37044841f, -0.13295661f, 0.07201404f, -0.04531917f, 0.01981027f, -0.02650189f, 
    -0.13197079f, 0.07954061f, 0.10233582f, -0.02814510f, -0.05321268f, -0.04156417f, 0.02080813f, 0.05400055f, 
    0.09598632f, -0.08579407f, 0.03656835f, 0.06247841f, -0.02455800f, -0.03848965f, -0.12680081f, -0.07649517f, 
    0.06000811f, 0.00707355f, -0.01610487f, -0.04295562f, -0.10118902f, 0.01893707f, 0.19445319f, 0.05478965f, 
    -0.22180672f, 0.02692241f, 0.07078405f, -0.04970904f, 0.04147032f, 0.13220808f, 0.10264879f, 0.05884152f, 
    -0.14196062f, 0.11935743f, 0.04136802f, 0.01086984f, 0.04224783f, -0.14841884f, 0.06949416f, 0.04363349f, 
    -0.09801608f, -0.01154749f, 0.06758120f, -0.01856716f, 0.03857987f, 0.04325701f, -0.01825508f, -0.05415271f, 
    -0.10778827f, -0.07153568f, 0.00378094f, -0.01638154f, 0.21219072f, -0.00958928f, -0.26046059f, -0.01997046f, 
    0.16664492f, -0.10250311f, 0.04716028f, 0.03404065f, -0.09743176f, -0.01881332f, 0.16014941f, -0.13771164f, 
    0.01616577f, -0.03098460f, 0.00451398f, 0.04656367f, -0.06651499f, 0.03091587f, -0.00913976f, -0.07911244f, 
    -0.23437724f, 0.04724002f, 0.05448569f, -0.29632351f, -0.05345575f, 0.11149634f, 0.01749080f, 0.26920116f, 
    -0.34193200f, -0.16912703f, 0.04966902f, -0.01214397f, 0.04547042f, -0.02748696f, 0.01264490f, 0.04915827f, 
    0.02020430f, -0.01440860f, 0.00456306f, 0.02219770f, -0.19688487f, 0.15233983f, -0.14517212f, -0.04921154f, 
    -0.09320148f, 0.01079718f, -0.02671292f, 0.04104821f, -0.01411458f, 0.16957158f, 0.09814332f, -0.10665511f, 
    0.04692470f, -0.07081473f, -0.06358733f, -0.00914025f, 0.01335465f, 0.07812450f, 0.00239283f, 0.03060178f, 
    -0.07587279f, -0.19665934f, -0.20910484f, -0.01024319f, 0.02359111f, 0.03851551f, 0.02421952f, -0.05870244f, 
    0.02865664f, -0.00829643f, -0.07253183f, 0.00854476f, 0.06273034f, 0.12899883f, 0.06849166f, -0.02203626f, 
    0.04732523f, 0.14439906f, 0.06203404f, -0.06302965f, -0.03321986f, 0.34884042f, 0.03490753f, -0.19629960f, 
    -0.11198002f, 0.07250327f, -0.10920258f, 0.17986242f, -0.03753596f, 0.03943266f, 0.04630402f, -0.04500340f, 
    -0.07107265f, 0.02296315f, -0.00998946f, 0.04336933f, -0.06336837f, 0.15744494f, -0.06802264f, -0.05183679f, 
    -0.02999005f, -0.03431438f, -0.01162748f, -0.05131001f, -0.13681456f, 0.02198751f, 0.00041170f, -0.02519276f, 
    0.00417197f, 0.11019392f, -0.00662217f, 0.02622092f, -0.01577652f, -0.02313721f, -0.02838758f, 0.01004562f, 
    0.02037742f, 0.01833813f, 0.04873401f, 0.06839469f, -0.12550746f, -0.00916614f, -0.01199003f, -0.25123265f, 
    0.10874598f, 0.05665288f, 0.05613802f, -0.02143976f, -0.07370353f, -0.05272725f, 0.02759846f, -0.05756059f, 
    -0.00922125f, -0.07256772f, -0.04687136f, -0.00578406f, 0.01659601f, 0.08705202f, 0.02833721f, 0.05089904f, 
    -0.40571529f, 0.37498844f, 0.02365953f, -0.46887547f, 0.01981410f, 0.06278511f, -0.07514691f, 0.04935214f, 
    -0.10106437f, -0.00842222f, 0.09419852f, 0.00070001f, -0.02664874f, 0.11892730f, -0.08511314f, -0.05495372f, 
    -0.18866239f, 0.07493785f, 0.08886141f, -0.10385270f, 0.05512628f, 0.02157118f, -0.03405729f, 0.04231201f, 
    0.04525552f, -0.09211421f, 0.06595384f, -0.04274695f, -0.02411443f, -0.01111454f, -0.01814049f, -0.12846068f, 
    0.08025875f, -0.07221043f, 0.02305809f, 0.03170156f, 0.04068105f, -0.02383527f, -0.05088176f, 0.07549621f, 
    -0.18476462f, -0.17417105f, 0.08045936f, 0.08061973f, -0.19749236f, 0.07337379f, -0.16397914f, -0.12771074f, 
    0.16468142f, 0.05935274f, 0.01521517f, 0.02049905f, -0.09463772f, -0.04294835f, 0.05765726f, 0.04141624f, 
    0.02112084f, 0.03797774f, 0.05461030f, 0.14274310f, -0.01638640f, -0.08344124f, -0.21349864f, 0.02205796f, 
    0.01956670f, 0.02003289f, 0.05573788f, -0.03360080f, -0.06078862f, -0.01514668f, -0.01215895f, -0.06272930f, 
    0.01825536f, 0.09614585f, -0.05424540f, 0.09234751f, 0.03111661f, 0.14804906f, 0.02296971f, -0.00520506f, 
    0.01001331f, -0.32565281f, -0.51748151f, -0.25248161f, 0.17235018f, -0.00373234f, 0.06306028f, 0.24789123f, 
    0.14760055f, 0.00290706f, -0.04285504f, -0.00376142f, -0.01980815f, -0.02578389f, 0.03208573f, -0.04765811f, 
    0.04544803f, -0.06235202f, 0.20643686f, 0.01931612f, -0.03331679f, 0.08221179f, 0.01731448f, 0.04234879f, 
    0.05219783f, -0.07461088f, 0.08767506f, -0.12222759f, 0.12273583f, 0.09359501f, -0.01702476f, 0.09412465f, 
    -0.05240658f, 0.14007746f, -0.04533921f, 0.04758489f, 0.04966065f, -0.04546757f, 0.16058557f, 0.18106370f, 
    -0.30127376f, 0.31706500f, 0.32801917f, -0.10527661f, -0.04139660f, -0.03231191f, -0.01681098f, -0.00865356f, 
    -0.09857658f, 0.22480881f, -0.17372991f, 0.09286539f, 0.00100182f, 0.11184404f, 0.03062840f, 0.03530821f, 
    -0.01007590f, -0.09018460f, 0.06710427f, 0.02564567f, -0.00491287f, -0.13549875f, 0.08139591f, 0.01410914f, 
    -0.06958427f, 0.03711135f, -0.00726710f, 0.02133191f, -0.02334485f, -0.03964737f, -0.01257058f, 0.00494183f, 
    -0.05864439f, 0.02094737f, -0.01200971f, 0.02494153f, -0.01577215f, 0.01957577f, -0.11246577f, -0.08359113f, 
    0.04273359f, -0.16203660f, -0.12854217f, 0.01395428f, -0.02454296f, 0.03728776f, 0.07114885f, -0.08182507f, 
    -0.13294777f, 0.02188599f, -0.10613975f, 0.00333169f, 0.02744132f, 0.06746985f, -0.10296310f, 0.01165733f, 
    0.05051356f, -0.01548476f, 0.04231683f, -0.00562561f, 0.00978710f, -0.07216830f, 0.14347662f, -0.02789224f, 
    0.26051727f, -0.01692196f, 0.03576250f, 0.02374437f, 0.07881743f, 0.08783448f, 0.00363750f, 0.10768857f, 
    0.08713586f, 0.02171553f, -0.11360911f, -0.01027441f, 0.04835163f, 0.05714925f, 0.07000618f, 0.03793234f, 
    -0.29276097f, -0.72349304f, -0.54446507f, -0.06571151f, 0.09462704f, -0.00248060f, 0.11663295f, 0.11035949f, 
    -0.10725519f, -0.34275910f, -0.01814751f, 0.01966201f, 0.02535437f, 0.01052095f, 0.06384308f, 0.03874439f, 
    0.05335809f, 0.15296309f, 0.11090420f, 0.02166520f, 0.15432633f, -0.20198439f, -0.20545951f, -0.05302045f, 
    0.09192435f, 0.00112422f, 0.11775458f, 0.09148893f, 0.09230832f, -0.00165066f, -0.05121406f, -0.00044690f, 
    -0.08854736f, -0.06551596f, 0.01491124f, 0.00250941f, 0.03772376f, -0.00815092f, 0.01429865f, -0.03418302f, 
    -0.34743005f, -0.17082725f, 0.33830544f, -0.36587894f, 0.09510168f, -0.10769792f, 0.04373427f, -0.00779744f, 
    0.02916601f, 0.07532233f, 0.07515586f, 0.03603715f, 0.07889760f, 0.00684333f, -0.04632549f, -0.02333311f, 
    0.09559023f, 0.03415620f, 0.02154273f, -0.04084376f, -0.19951090f, -0.25090644f, 0.07553448f, 0.08304451f, 
    -0.04025386f, 0.09111875f, 0.18172653f, -0.07881588f, 0.10712830f, 0.00832150f, 0.14959589f, 0.03663035f, 
    0.01254234f, 0.00683423f, 0.01455550f, 0.04496461f, -0.02391649f, 0.00581235f, 0.06805993f, -0.07164693f, 
    -0.12413613f, 0.11719867f, 0.15349582f, -0.02956205f, 0.28848761f, 0.03593879f, -0.11267076f, 0.02575412f, 
    -0.00952901f, 0.04357011f, 0.06317410f, 0.09390647f, 0.02393011f, 0.12704001f, -0.04322997f, 0.01941253f, 
    0.07231700f, 0.05705688f, -0.02166273f, 0.06914052f, -0.34038162f, -0.43606913f, 0.16330683f, -0.00066002f, 
    -0.09685349f, -0.10375825f, -0.10070419f, 0.00826403f, -0.18955649f, -0.01580063f, -0.07066224f, -0.01434608f, 
    0.03954613f, -0.09522428f, 0.02397672f, 0.00970510f, 0.01322907f, -0.07033526f, 0.10794899f, -0.08975152f, 
    -0.29000223f, -0.10550620f, 0.10136424f, 0.20592998f, 0.14732751f, 0.05948580f, 0.15832806f, -0.10162501f, 
    -0.00548895f, -0.02688237f, 0.01026548f, 0.02900711f, 0.04025701f, 0.01416989f, 0.00334448f, 0.08250187f, 
    0.02949928f, 0.03370960f, 0.05667276f, 0.07611934f, -0.12671351f, 0.17848246f, 0.10677451f, -0.04649172f, 
    -0.03291893f, -0.00632606f, 0.06469119f, 0.14373407f, 0.02623234f, -0.05673135f, 0.00579634f, -0.02594198f, 
    0.10728088f, 0.05035094f, 0.15860040f, -0.00407255f, 0.01531227f, 0.14246778f, -0.04656534f, 0.01912656f, 
    -0.40145093f, -0.12766317f, -0.54975510f, -0.03229297f, 0.34965333f, 0.01015164f, 0.10659567f, -0.00974755f, 
    -0.08173458f, 0.06018301f, 0.11691441f, -0.01017423f, 0.04117424f, -0.03423268f, 0.09688704f, -0.02146619f, 
    -0.00624442f, 0.00170799f, 0.14103228f, 0.00893555f, -0.21139964f, 0.21201073f, -0.14130214f, -0.05873535f, 
    -0.03615299f, -0.16191871f, -0.17997588f, -0.23412034f, 0.03411099f, -0.09924367f, -0.09313878f, -0.01136594f, 
    -0.08997345f, 0.02608670f, -0.00760274f, -0.02501585f, -0.04668202f, 0.06330769f, 0.00695599f, -0.09723134f, 
    -0.25055510f, 0.29683134f, 0.13283782f, 0.02778258f, 0.23535535f, -0.02604033f, -0.02889139f, -0.07292192f, 
    0.08211100f, 0.04478569f, 0.09493513f, 0.06917387f, 0.04235940f, -0.08018553f, -0.06345408f, 0.04999259f, 
    0.03066995f, -0.02324576f, 0.07627567f, 0.01053308f, -0.10802039f, -0.26473722f, -0.24785750f, -0.19175097f, 
    0.28397658f, -0.07398172f, 0.09180181f, -0.11081398f, -0.01758662f, 0.02916339f, -0.07476593f, 0.04201650f, 
    0.02919740f, -0.04869407f, 0.04565752f, -0.02271233f, 0.04516339f, -0.15896137f, 0.27713057f, -0.11234627f, 
    -0.08179477f, -0.03853764f, 0.01938889f, -0.00877891f, -0.06210264f, -0.03559112f, -0.03806515f, -0.01240598f, 
    -0.04686807f, 0.05124872f, 0.08633889f, 0.05408911f, 0.09064993f, -0.02735546f, 0.01416593f, -0.04539193f, 
    -0.01279578f, -0.10431476f, -0.02032209f, -0.02534645f, 0.11119694f, -0.02642952f, 0.00588358f, -0.01493030f, 
    0.07404938f, 0.08108600f, -0.02302287f, 0.10719781f, 0.06646529f, -0.02031617f, 0.00604346f, 0.10415347f, 
    -0.11356982f, 0.00876244f, 0.05810178f, -0.03499087f, 0.03414383f, -0.03964494f, -0.10149428f, -0.08513789f, 
    -0.09197761f, -0.05286827f, -0.13698104f, 0.00060378f, 0.12769207f, -0.00827012f, 0.08274546f, 0.01778691f, 
    -0.01719203f, 0.03940162f, -0.04084411f, -0.04507031f, 0.04619500f, 0.04486052f, 0.03986884f, -0.02318351f, 
    0.04210791f, 0.01029297f, 0.11574371f, 0.00193177f, 0.22329104f, 0.11433524f, -0.11934928f, -0.03196120f, 
    0.10108682f, -0.08654562f, -0.03631659f, 0.02761174f, 0.07262656f, -0.15365876f, 0.07405379f, 0.04029406f, 
    -0.05157999f, -0.02828824f, 0.06831825f, 0.02390337f, 0.01419732f, 0.02230965f, -0.10410926f, -0.02354239f, 
    -0.39986074f, -0.39595851f, 0.06375045f, -0.01202322f, 0.20489334f, -0.07030377f, 0.20083196f, 0.15125449f, 
    0.11497940f, -0.10764464f, 0.05691827f, 0.04370361f, 0.02874102f, -0.05812552f, 0.04391121f, -0.00779253f, 
    0.05403104f, 0.12986888f, 0.06961101f, -0.03573951f, -0.38526803f, -0.18777901f, -0.50655872f, -0.06456137f, 
    0.22754963f, -0.15972331f, -0.06904709f, -0.01411575f, -0.13660972f, -0.13342489f, 0.01190612f, -0.02251028f, 
    0.03762877f, 0.03544071f, 0.04017140f, -0.01156464f, 0.00928360f, -0.03045957f, 0.12185680f, -0.01542751f, 
    0.08517421f, 0.09201551f, -0.01513763f, -0.15949984f, 0.10452893f, 0.03127382f, 0.03409194f, -0.01334026f, 
    -0.00446562f, -0.11143661f, -0.09394770f, -0.03245724f, 0.01759670f, -0.04237530f, -0.00760075f, -0.02207605f, 
    -0.02406806f, -0.06886994f, -0.23635529f, 0.02032212f, 0.06954949f, -0.04886060f, -0.18391857f, -0.06992140f, 
    -0.01660986f, -0.00099734f, -0.04398194f, 0.07975712f, -0.02282805f, 0.06071585f, -0.04078393f, -0.00379856f, 
    -0.07393780f, -0.11099691f, -0.00287046f, -0.03923445f, -0.04725365f, -0.16241474f, -0.00862412f, 0.03207798f, 
    -0.49006954f, 0.45723215f, 0.26255295f, -0.13746633f, -0.00069592f, -0.08898041f, -0.01089967f, -0.02936086f, 
    -0.13267602f, 0.22641362f, -0.13227046f, 0.08488623f, -0.03017617f, 0.04261383f, 0.04672823f, 0.00681124f, 
    -0.06192089f, -0.03234487f, -0.02353594f, 0.00583367f, -0.03953815f, 0.02138029f, -0.03493326f, 0.03598172f, 
    0.03460412f, -0.05680897f, 0.05234911f, -0.07765058f, -0.00885012f, 0.08977869f, 0.02218568f, 0.02768612f, 
    0.02521320f, 0.04590793f, -0.02155785f, -0.08742125f, -0.04930396f, -0.04669138f, 0.02866590f, 0.00058283f, 
    -0.21849735f, -0.25700274f, -0.14457898f, -0.01136145f, -0.25002044f, 0.02288164f, 0.10734362f, 0.04419828f, 
    0.04742344f, -0.10180207f, -0.02164402f, -0.02592015f, 0.05281524f, 0.05295904f, 0.05718260f, 0.00513640f, 
    0.05739787f, 0.14752643f, 0.07638777f, -0.00824092f, 0.10991692f, -0.12759922f, -0.19622973f, -0.19860727f, 
    0.00450707f, -0.00690026f, 0.01218294f, 0.15145299f, -0.01534368f, 0.04223093f, -0.04024277f, -0.01643079f, 
    -0.04748935f, -0.07656249f, -0.00113728f, -0.03552765f, -0.07867547f, -0.07616268f, 0.02935553f, 0.04052714f, 
    -0.35440984f, -0.37913999f, -0.64960772f, 0.00098654f, -0.24528645f, -0.06523544f, -0.18254627f, -0.10990117f, 
    -0.16448013f, -0.05595141f, -0.04679981f, 0.00641550f, 0.03552030f, -0.06963719f, -0.10725047f, 0.03792599f, 
    -0.01787321f, 0.12476588f, 0.03223618f, -0.00468316f, 0.33783540f, 0.22332200f, -0.11983693f, -0.07374634f, 
    -0.11470784f, -0.04794410f, 0.18803678f, -0.03897471f, 0.07593357f, -0.10289095f, 0.12626438f, -0.08393219f, 
    -0.03702691f, -0.12560403f, 0.03107878f, -0.02348948f, -0.01490094f, 0.04887832f, 0.10557297f, -0.18149981f, 
    -0.09129279f, 0.07792912f, 0.14081457f, 0.08619747f, 0.07021100f, -0.03257065f, -0.09084783f, -0.04661901f, 
    -0.03045477f, 0.15215336f, -0.00425119f, 0.06899495f, 0.13081916f, 0.06367530f, 0.08606977f, -0.02737451f, 
    0.06267664f, -0.04048492f, 0.02860663f, -0.01451228f, 0.07215846f, 0.09447213f, 0.02378060f, -0.03728341f, 
    0.03393666f, -0.08793126f, -0.02558627f, -0.01536062f, 0.03946547f, 0.05160234f, 0.06590213f, 0.07297624f, 
    -0.04255540f, 0.00465354f, -0.02436792f, -0.04280070f, -0.06170624f, -0.05600539f, -0.00961083f, -0.08923550f, 
    0.03695810f, 0.13852642f, -0.13170607f, -0.01511231f, 0.08781490f, -0.09287791f, -0.03567488f, 0.01828685f, 
    0.09912154f, 0.20321345f, 0.09185884f, 0.09956022f, 0.01580511f, -0.04965800f, -0.05604961f, 0.03904530f, 
    0.03976456f, -0.11813007f, 0.07796936f, -0.07958768f, -0.07075350f, 0.09742409f, -0.04037812f, -0.19899070f, 
    0.02910827f, -0.10882134f, -0.00675915f, 0.09096400f, 0.06206285f, 0.06291580f, -0.02516236f, -0.02793233f, 
    -0.04933862f, -0.03503518f, 0.00505009f, 0.04949338f, 0.01386076f, -0.08142123f, -0.00298908f, 0.07256474f, 
    -0.06107614f, 0.01718008f, 0.01157713f, -0.12645507f, 0.01495869f, -0.01772891f, 0.02957811f, 0.02383000f, 
    -0.00407885f, 0.07207220f, -0.01559970f, 0.04858214f, -0.08286221f, 0.18183669f, -0.03531771f, 0.04306059f, 
    -0.01160567f, -0.03512385f, 0.00978201f, 0.12930554f, -0.68723696f, -0.59513062f, -0.28359860f, -0.02930598f, 
    0.01088354f, -0.12546553f, -0.07925071f, -0.24446329f, -0.08763696f, -0.31848767f, -0.01200319f, -0.03414649f, 
    -0.02449792f, 0.02530515f, 0.01977579f, 0.00245575f, -0.01701931f, 0.03707599f, 0.02189473f, 0.02799160f, 
    -0.51260358f, -0.40815443f, -0.41254872f, -0.21610922f, -0.16748537f, -0.09113433f, 0.03688712f, -0.24047314f, 
    0.03903763f, -0.20387532f, 0.01001518f, -0.03411902f, -0.03089921f, -0.00287498f, 0.02885429f, -0.00278329f, 
    -0.00785299f, 0.07636248f, 0.00899126f, -0.08528501f, -0.52819222f, 0.45471919f, 0.31706741f, 0.07594185f, 
    0.34826800f, -0.11783341f, -0.03939984f, -0.04777879f, -0.05443188f, 0.16500650f, 0.04121331f, 0.06668901f, 
    0.07488370f, 0.00325560f, 0.00404275f, -0.00093810f, 0.02001781f, -0.00703316f, 0.02595614f, -0.00134810f, 
    0.14509997f, -0.08211077f, -0.27382842f, -0.06997945f, 0.15463935f, -0.06552098f, 0.05376369f, 0.07130617f, 
    0.03064868f, -0.12137543f, 0.03670024f, 0.00383317f, -0.13339432f, -0.03558736f, 0.07093515f, -0.01050325f, 
    -0.02954318f, 0.07589082f, -0.00084623f, -0.07734153f, -0.52896959f, 0.02042896f, -0.03576587f, -0.27696562f, 
    -0.00693445f, -0.05374531f, 0.00657568f, -0.00440168f, 0.05245300f, -0.03885719f, 0.11579107f, -0.00614086f, 
    0.07100214f, -0.02592482f, -0.06179841f, 0.01472829f, 0.21781756f, 0.00480608f, 0.14563899f, 0.02226099f, 
    -0.47103408f, -0.11074960f, -0.37599096f, -0.12442932f, -0.02508834f, -0.09085502f, -0.02620597f, -0.11716998f, 
    -0.04808774f, -0.20108736f, -0.01858357f, -0.03934196f, -0.05968903f, 0.00393868f, 0.03125753f, -0.00482247f, 
    -0.01182577f, 0.07090739f, 0.02145379f, -0.02972935f, -0.74772394f, -0.63543373f, -0.51248366f, -0.40001088f, 
    0.16038103f, -0.20796423f, -0.04732760f, -0.11300896f, -0.15294354f, -0.30853206f, -0.02977013f, -0.03411433f, 
    -0.02653032f, -0.00753736f, -0.00567889f, -0.00646044f, -0.01584484f, 0.03698386f, 0.16482638f, 0.04623990f, 
    -0.37646347f, 0.23860627f, 0.18419051f, 0.14479885f, -0.02753039f, -0.04776194f, -0.11390236f, -0.09103274f, 
    -0.09325067f, -0.06019192f, 0.00375118f, 0.01973098f, -0.03225434f, 0.06863688f, -0.03137078f, -0.01168677f, 
    0.00590096f, 0.02891265f, -0.04865557f, 0.04014606f, -0.15326872f, -0.41009814f, -0.52847242f, -0.08333661f, 
    -0.02942905f, -0.03415032f, -0.14638989f, -0.00088980f, -0.17870343f, -0.00677917f, -0.02044444f, 0.02368663f, 
    -0.00521878f, -0.05937768f, -0.10029685f, -0.01331962f, -0.02047225f, 0.07007176f, 0.06136193f, 0.02062824f, 
    -0.38678193f, -0.11150440f, 0.31173491f, 0.20556140f, -0.16776043f, -0.12193845f, -0.05883316f, -0.10318625f, 
    -0.09671354f, -0.06775790f, -0.03037078f, 0.06529091f, 0.02603516f, 0.02279210f, 0.01055301f, 0.00251533f, 
    -0.02879605f, 0.00095218f, -0.05646009f, 0.03728499f, 0.04701937f, 0.02774383f, -0.05442006f, -0.05662308f, 
    -0.20550084f, 0.09063880f, -0.01136473f, 0.03873686f, 0.07358177f, -0.05407713f, -0.06234587f, 0.01669330f, 
    -0.00703463f, -0.06607997f, 0.01927687f, -0.01042366f, 0.06019055f, 0.05342800f, -0.17453326f, 0.10230159f, 
    -0.35102579f, -0.36226916f, -0.83580244f, -0.38857073f, -0.02166707f, -0.28032091f, -0.00423703f, -0.17037708f, 
    -0.03734650f, -0.19399780f, 0.06231605f, -0.04369003f, -0.07368756f, -0.03048064f, 0.00492355f, -0.03476296f, 
    -0.00418698f, 0.12355994f, -0.06395940f, 0.00064766f, -0.33503315f, -0.35682198f, -0.26209223f, -0.19348226f, 
    -0.16776235f, -0.04563949f, 0.00531647f, -0.03275259f, -0.04063316f, -0.16277303f, 0.01433877f, 0.03000136f, 
    -0.02694774f, 0.05473317f, 0.01912081f, -0.01544227f, -0.02933231f, 0.04395196f, 0.02163407f, 0.01568172f, 
    0.16238616f, 0.08823610f, -0.04274725f, -0.12671386f, 0.09291761f, -0.04730473f, -0.01403510f, -0.01378380f, 
    0.10608779f, -0.09233363f, 0.03212308f, -0.04773346f, 0.04319052f, -0.06932037f, -0.01012375f, 0.00924236f, 
    -0.03646441f, -0.05521526f, -0.05232084f, 0.02370431f, -0.09869900f, 0.01010989f, 0.06498437f, -0.08705059f, 
    0.08035985f, -0.03203968f, -0.07527570f, -0.00207232f, -0.07935776f, -0.03207459f, -0.03910851f, -0.05454004f, 
    0.03995327f, 0.11445922f, 0.02430179f, -0.01052888f, -0.01786032f, 0.01298831f, -0.10914376f, -0.00057533f, 
    -0.20219967f, -0.25292301f, -0.10034748f, 0.12456522f, 0.18107176f, -0.13706377f, -0.11838521f, -0.01791743f, 
    -0.04557353f, 0.02941990f, -0.00808869f, -0.02767603f, 0.02722281f, -0.12240878f, -0.03248708f, 0.01106772f, 
    0.04282455f, -0.00987718f, 0.10576278f, -0.08836605f, 0.05819566f, -0.00589329f, 0.07006767f, 0.07529804f, 
    -0.13178639f, 0.02838568f, 0.03754839f, 0.04366559f, 0.00022852f, -0.15365855f, -0.03613821f, 0.04327364f, 
    0.02433229f, -0.00128070f, 0.04553597f, 0.00175361f, 0.00468937f, 0.12728211f, -0.17735532f, -0.01022383f, 
    -0.99370617f, -0.70113188f, 0.09606872f, 0.54960996f, -0.29825696f, 0.11907338f, 0.03184497f, -0.12532479f, 
    -0.05088663f, -0.09520058f, -0.02758883f, 0.03439828f, -0.00174908f, -0.02800065f, 0.04043384f, -0.01491882f, 
    -0.03037104f, 0.08396950f, -0.05430152f, -0.12097773f, -0.28492987f, 0.18548404f, 0.26696539f, -0.02143131f, 
    0.04288206f, -0.08841453f, -0.02458956f, -0.03333450f, -0.06481663f, 0.09277272f, -0.05644020f, -0.05146330f, 
    0.02548711f, 0.01224532f, 0.08877553f, -0.00054644f, -0.01668287f, -0.07756977f, -0.02648484f, -0.00277550f, 
    -0.00803004f, -0.01395424f, 0.01765491f, -0.01719864f, -0.02523834f, -0.02638070f, 0.04267556f, 0.01520901f, 
    -0.04253303f, 0.06977375f, -0.03468292f, 0.00970102f, 0.04918123f, 0.04611299f, -0.00866603f, -0.00167376f, 
    0.00970617f, -0.08925974f, -0.01584894f, -0.00042151f, -0.33316296f, 0.17790914f, 0.23542543f, 0.30054003f, 
    0.30913499f, 0.06355712f, 0.17791937f, -0.10126445f, 0.12229970f, -0.18476628f, 0.05641374f, 0.12039559f, 
    -0.00741196f, 0.02005524f, 0.01723267f, 0.06076887f, -0.06192225f, -0.03264378f, 0.01051458f, -0.00282106f, 
    -0.37904021f, 0.44208306f, 0.21587135f, -0.04186523f, 0.02358070f, -0.03934545f, -0.08107366f, -0.08584930f, 
    0.02844838f, 0.07009370f, -0.03788456f, -0.09609484f, -0.01415455f, 0.08156499f, 0.08587483f, -0.00591013f, 
    0.00661741f, -0.05605001f, -0.04118280f, 0.01073028f, 0.05444494f, 0.11775178f, 0.01575509f, -0.01396684f, 
    -0.02833308f, 0.05460846f, -0.01373506f, 0.00124309f, -0.09094507f, -0.05485500f, -0.05289960f, -0.01457785f, 
    -0.01526066f, 0.06175812f, 0.09184264f, 0.08496657f, -0.00015712f, 0.05287110f, -0.18430299f, -0.03663636f, 
    -0.18965426f, -0.08101936f, 0.22372885f, 0.23593085f, -0.05186787f, 0.12902717f, -0.04247594f, -0.03434155f, 
    0.04718461f, 0.08651080f, 0.04850325f, 0.07425454f, 0.02810648f, 0.08268598f, -0.07562641f, 0.07088417f, 
    0.06999261f, 0.15875968f, -0.12046257f, -0.01746571f, 0.00078083f, -0.04555233f, -0.05000559f, -0.02846716f, 
    0.02143889f, -0.02958113f, -0.07730700f, -0.07033006f, -0.02601724f, -0.03624089f, -0.09871461f, -0.22627629f, 
    -0.13683783f, 0.04210217f, 0.02616100f, -0.01836814f, -0.05358597f, -0.07804134f, -0.05585609f, -0.10321738f, 
    -0.13807511f, -0.06317162f, 0.16334192f, -0.07198707f, 0.06980715f, 0.03841603f, 0.10190745f, 0.03787075f, 
    -0.02297376f, 0.13008024f, -0.03654747f, 0.07474407f, -0.00166543f, 0.05734468f, -0.05931845f, -0.04857973f, 
    0.01773032f, -0.04831781f, 0.05460642f, 0.03728644f, -0.01128844f, -0.01220927f, 0.09713478f, -0.11931893f, 
    -0.00411250f, 0.03406656f, -0.02410404f, -0.04071984f, -0.03998189f, 0.04409781f, -0.18749622f, 0.04914313f, 
    0.00479906f, 0.02236030f, 0.00570189f, -0.00280370f, -0.02671915f, -0.04099693f, -0.10834037f, -0.01776828f, 
    -0.21296854f, -0.00102520f, -0.17631945f, 0.11706133f, -0.19497254f, -0.04678889f, -0.10776710f, 0.01515928f, 
    0.00155463f, 0.01620992f, 0.02070588f, 0.04318807f, 0.07045124f, 0.02422235f, -0.04959708f, 0.00197015f, 
    -0.06976574f, 0.00302102f, -0.10911201f, 0.06928810f, 0.27499387f, -0.07432014f, 0.09575578f, -0.13769449f, 
    0.11508437f, 0.10811277f, 0.07458974f, -0.01654263f, -0.00904110f, 0.05233562f, 0.04372913f, 0.03613071f, 
    0.05742244f, 0.02768254f, -0.11612405f, 0.03222772f, 0.02858760f, 0.06289414f, -0.03686392f, -0.00400126f, 
    0.55762643f, -0.03450870f, -0.06824554f, -0.22066173f, -0.11845696f, 0.06454419f, -0.01995713f, -0.28007007f, 
    -0.01797610f, -0.24502073f, 0.10325232f, -0.01718436f, 0.06731060f, -0.02739845f, -0.00698869f, -0.02583286f, 
    -0.03437242f, -0.02145883f, 0.00578872f, -0.02420132f, -0.01727320f, 0.06164530f, 0.07491270f, -0.04649615f, 
    0.02974103f, 0.00318033f, 0.04953649f, 0.00097675f, 0.00893139f, -0.02900187f, -0.01774521f, -0.05868373f, 
    -0.02563128f, -0.05733532f, -0.02200077f, 0.00540016f, -0.02594272f, 0.00426392f, -0.02416238f, 0.00981651f, 
    0.23534574f, -0.47477219f, -0.02619686f, -0.07817520f, -0.04034296f, -0.14082776f, 0.06268824f, -0.09543139f, 
    0.15406327f, 0.07129352f, 0.01493097f, 0.04282785f, -0.08703420f, -0.06039595f, 0.01585787f, 0.01337784f, 
    0.06322242f, -0.01066663f, 0.09229080f, 0.06526235f, 0.01504473f, -0.38267437f, -0.31574923f, -0.06752770f, 
    -0.18501207f, 0.02158202f, -0.05040001f, 0.07490472f, 0.08577608f, 0.00803289f, 0.02175085f, 0.01805473f, 
    -0.03316577f, 0.05151012f, 0.07723680f, -0.08983928f, -0.01653094f, -0.03038120f, 0.04903596f, 0.10918758f, 
    -0.30472797f, -0.22259121f, 0.16627899f, 0.17465381f, 0.00583707f, 0.01491187f, 0.05241467f, -0.07188556f, 
    -0.03919031f, 0.11001763f, 0.03814292f, -0.01563855f, 0.01841581f, 0.02244835f, 0.00661569f, 0.04521401f, 
    0.10012221f, -0.00527930f, -0.00219844f, -0.11281361f, -0.04838711f, -0.03775850f, 0.04828353f, 0.07828442f, 
    -0.03913958f, 0.00843877f, -0.02001414f, 0.01761655f, 0.02004375f, 0.00344021f, 0.05007834f, 0.03978767f, 
    0.02836544f, 0.02288143f, -0.05671032f, 0.01388482f, 0.00251705f, -0.06418457f, 0.00895008f, 0.00774193f, 
    -0.04623021f, 0.28939185f, -0.32261887f, 0.15136217f, -0.43939120f, 0.05106422f, 0.03907825f, 0.09580894f, 
    -0.07303549f, -0.00390153f, -0.08647583f, -0.03668722f, -0.12323593f, 0.00558698f, 0.11703304f, -0.11220142f, 
    -0.12859485f, 0.13212536f, -0.01807355f, 0.09442243f, -0.12245793f, -0.15560028f, 0.23755521f, -0.19711234f, 
    0.19198649f, -0.11172737f, 0.13878477f, -0.11179730f, 0.10034844f, -0.06075143f, 0.03627869f, 0.05351894f, 
    -0.05767256f, 0.00251617f, 0.04445956f, -0.00928178f, -0.01085004f, 0.00612995f, -0.02044933f, -0.09757421f, 
    0.02619878f, -0.51761872f, -0.09804820f, -0.17808770f, 0.07855244f, -0.00510217f, 0.02107272f, 0.04559304f, 
    0.19192219f, 0.01432927f, 0.01705874f, 0.02931869f, -0.02086677f, -0.02778790f, 0.01300551f, -0.04045738f, 
    -0.01152873f, -0.13483544f, 0.04924502f, 0.07428140f, 0.33262271f, -0.53246886f, -0.28974277f, -0.03296012f, 
    -0.03692450f, -0.05307771f, 0.04315769f, -0.08905155f, 0.16049123f, 0.02409471f, 0.02469193f, 0.02368923f, 
    -0.06355895f, -0.05542646f, 0.04419718f, -0.08793480f, -0.00238874f, -0.05290511f, 0.02707014f, -0.07501912f, 
    0.00841318f, -0.21492374f, 0.15763804f, -0.02966158f, -0.00607177f, -0.22435451f, 0.10506533f, -0.16748574f, 
    0.10545265f, 0.00253959f, 0.03027799f, 0.03418672f, 0.04754075f, 0.03212255f, -0.04256051f, -0.05597131f, 
    0.02742318f, -0.04627625f, -0.03306246f, -0.03905500f, -0.35319293f, -0.33852515f, 0.39563674f, -0.37718031f, 
    0.25115943f, 0.03647424f, -0.06316111f, 0.20181182f, -0.01186368f, 0.02508310f, -0.03751545f, -0.06485412f, 
    -0.01830827f, 0.02127860f, -0.11279807f, 0.02123390f, -0.09117615f, -0.00039225f, -0.05095533f, -0.06406098f, 
    0.24687947f, -0.00338152f, -0.14729448f, 0.38483542f, -0.36225897f, 0.04671321f, 0.04592746f, -0.00107693f, 
    -0.04615038f, 0.03575636f, -0.05184500f, -0.00317077f, 0.01939473f, -0.02139293f, 0.01262705f, 0.01072714f, 
    0.02929922f, 0.12828675f, -0.03004285f, -0.02457557f, -0.13850695f, -0.24320088f, -0.06982291f, 0.03054162f, 
    -0.03214260f, 0.04831916f, 0.00367746f, 0.06447212f, 0.08579161f, -0.09027532f, 0.00682398f, 0.02384255f, 
    0.01095721f, 0.04254656f, 0.00152060f, 0.04403016f, -0.02917243f, 0.03738765f, -0.08387391f, -0.01274477f, 
    0.07294311f, -0.05184261f, -0.28799728f, -0.07491167f, -0.12873597f, 0.05597922f, -0.06488445f, 0.10061377f, 
    0.00627718f, 0.01378785f, -0.07184647f, 0.06560433f, 0.02275990f, 0.00378141f, -0.06616868f, 0.00825393f, 
    -0.01628338f, 0.02071655f, 0.05528322f, 0.06217660f, -0.03775160f, -0.09887902f, -0.12174603f, 0.26735854f, 
    -0.00849061f, 0.06969352f, -0.05556723f, 0.12383197f, -0.05991168f, -0.19468856f, 0.09595044f, 0.09027351f, 
    -0.00634758f, 0.03173994f, -0.05293177f, -0.03835241f, -0.04722481f, 0.03281195f, -0.10571581f, -0.00021675f, 
    0.13006131f, 0.13266356f, 0.00477409f, -0.06765512f, -0.13140118f, 0.01463820f, 0.03401760f, 0.03444489f, 
    0.00568095f, -0.03301990f, -0.09632144f, -0.18759906f, -0.16843317f, -0.14141990f, -0.10447690f, 0.01774546f, 
    0.00461296f, 0.01493246f, -0.01261311f, 0.00731581f, -0.02489362f, -0.03520085f, 0.12815617f, -0.10207355f, 
    0.04775776f, -0.02412467f, -0.01977489f, -0.06131125f, 0.02329879f, 0.00511969f, 0.02201284f, -0.02573466f, 
    0.02725136f, 0.03083742f, -0.06136122f, 0.00767516f, -0.04957477f, -0.07039072f, 0.05857242f, 0.00100756f, 
    0.04575921f, -0.00380904f, 0.02174822f, 0.25331870f, -0.16925009f, -0.18850392f, -0.00128204f, -0.13240875f, 
    0.02831173f, 0.01427342f, -0.09147352f, 0.00944469f, 0.01225860f, -0.01775241f, -0.05547244f, -0.06412140f, 
    0.05501943f, -0.10314671f, -0.01298511f, 0.06674597f, -0.22728938f, -0.17654309f, 0.08746083f, 0.09999167f, 
    0.04683664f, 0.04741325f, 0.02754627f, -0.11352237f, 0.00686410f, 0.00215319f, 0.02425662f, -0.10340248f, 
    -0.02662012f, 0.00963110f, -0.00794152f, 0.03046735f, 0.00187313f, -0.05365629f, -0.05272617f, 0.01008132f, 
    0.10642558f, 0.04962873f, -0.49758545f, 0.17306657f, -0.35109940f, -0.06654292f, -0.10856153f, 0.07328273f, 
    -0.18247935f, 0.03257928f, -0.06561726f, 0.00966735f, 0.03870457f, 0.00588132f, -0.01020884f, 0.00605078f, 
    -0.09977137f, 0.17119871f, -0.14368826f, -0.04398806f, 0.06302366f, -0.41858456f, -0.07550799f, 0.34058648f, 
    -0.12047260f, 0.06319745f, -0.00109635f, -0.00816795f, 0.07603834f, 0.11280435f, 0.01453983f, -0.02300468f, 
    -0.14004967f, -0.05571808f, -0.03887822f, -0.03416038f, 0.09804910f, -0.08564461f, 0.08824198f, 0.07742176f, 
    -0.18953767f, 0.01079094f, 0.01815503f, 0.11380067f, 0.01574927f, 0.06076387f, 0.00879131f, 0.09516773f, 
    -0.05259040f, -0.04408554f, 0.06883667f, -0.00210602f, 0.05912635f, 0.07995223f, 0.02686764f, 0.02104249f, 
    -0.01392073f, -0.10392399f, -0.11669407f, 0.08376118f, 0.01550689f, 0.07824069f, 0.03377761f, -0.01042282f, 
    -0.12006248f, -0.03822753f, 0.02335843f, -0.04436487f, -0.01435428f, -0.04203418f, 0.02476251f, 0.01979875f, 
    0.03252791f, -0.00819369f, 0.02857703f, -0.09133410f, -0.09234151f, 0.05534720f, 0.03239625f, 0.01427432f, 
    0.52896774f, -0.31462890f, -0.14227206f, -0.14964239f, -0.12426218f, 0.02572981f, -0.05400841f, -0.04354532f, 
    -0.03094666f, -0.07449604f, 0.05350608f, -0.04459233f, 0.03558884f, -0.01435657f, -0.00230412f, 0.01932489f, 
    -0.01649455f, -0.01028767f, 0.04308683f, -0.00126927f, 0.02959315f, 0.04884573f, 0.01315463f, -0.02675187f, 
    -0.09557157f, -0.05363493f, 0.05118539f, -0.01882655f, 0.01858872f, -0.01629825f, -0.07953309f, 0.03905266f, 
    -0.00635412f, -0.08322375f, -0.11351516f, -0.12664606f, -0.08484481f, 0.00584404f, -0.02232026f, -0.09544640f, 
    -0.20772210f, -0.08044602f, 0.12138289f, 0.02302710f, 0.07134709f, -0.03393374f, -0.08227256f, -0.02068006f, 
    -0.00800934f, -0.06525011f, -0.02770783f, -0.06341131f, 0.03638123f, 0.02100378f, -0.02670141f, 0.03899081f, 
    0.06260852f, 0.07422383f, -0.02893489f, -0.03636262f, -0.04121852f, 0.10700390f, 0.00929854f, -0.01986289f, 
    -0.10021746f, -0.01211309f, -0.05490240f, -0.02421922f, -0.03779753f, -0.05007824f, 0.02731335f, 0.05940006f, 
    0.00453147f, 0.02154880f, -0.01283428f, -0.06413235f, -0.20895477f, 0.02281219f, -0.00050542f, 0.04725252f, 
    0.11095116f, -0.41801628f, 0.25451818f, -0.31157374f, -0.02013713f, -0.03198358f, 0.08992522f, -0.17181215f, 
    0.26174986f, 0.10517356f, 0.02041270f, 0.03346815f, -0.06218792f, -0.08830094f, 0.01647346f, 0.01618025f, 
    0.04095186f, -0.04945534f, 0.13006678f, -0.06779058f, -0.22301550f, -0.10640492f, -0.12513916f, -0.00721565f, 
    0.18688424f, 0.11576211f, -0.08658843f, 0.01852653f, -0.05027499f, 0.09406997f, -0.10178452f, 0.11901128f, 
    0.09659113f, 0.02284443f, -0.00858817f, 0.02716847f, -0.01290727f, 0.00018286f, -0.09751974f, -0.09146523f, 
    0.23061591f, 0.16521685f, -0.07413067f, -0.03826428f, -0.24047536f, -0.01118108f, 0.02118380f, 0.03709742f, 
    0.02282173f, -0.01191044f, -0.07318170f, -0.14258458f, -0.03825938f, -0.06814061f, -0.17128973f, -0.01632042f, 
    -0.01238628f, -0.02901741f, -0.01906103f, 0.00597679f, -0.02252802f, 0.01766815f, -0.08454259f, 0.01338178f, 
    -0.02279807f, 0.00950733f, -0.02136827f, 0.03101019f, 0.00436841f, -0.01158693f, -0.10146274f, -0.00127451f, 
    0.08713046f, 0.00605414f, -0.07566820f, 0.01947749f, -0.03471869f, 0.00893715f, -0.06664909f, 0.01957639f, 
    0.07672714f, 0.12550519f, -0.20745169f, 0.05136386f, -0.10407709f, 0.06078970f, 0.05300205f, 0.03542672f, 
    -0.05182042f, -0.06575754f, -0.20732225f, -0.03887839f, 0.01116336f, -0.01223446f, -0.09502722f, -0.04500719f, 
    -0.05272954f, 0.07937597f, -0.05785576f, 0.01723240f, -0.05168430f, -0.00937180f, -0.19877654f, 0.10224918f, 
    -0.08977091f, 0.07040220f, 0.03949452f, 0.05820299f, -0.08025998f, -0.04655914f, 0.05004132f, 0.00738109f, 
    0.03066257f, -0.00952533f, -0.02094767f, -0.12779583f, -0.02327766f, 0.13021713f, -0.07189949f, 0.08126104f, 
    0.12784326f, 0.15777552f, -0.17334719f, -0.01625706f, -0.05577120f, 0.04318446f, 0.07813194f, 0.03307784f, 
    -0.04331749f, 0.04585611f, -0.04305139f, -0.02035690f, 0.09971990f, -0.00285788f, -0.05631202f, -0.07057356f, 
    0.00790300f, 0.00585169f, -0.05888990f, 0.02782449f, 0.01917094f, -0.38958898f, 0.28830248f, 0.16885112f, 
    -0.00624370f, -0.03922804f, 0.07143319f, -0.04253659f, 0.04592501f, 0.05067580f, 0.00897186f, -0.01104068f, 
    0.00020171f, -0.02622691f, 0.00453005f, 0.00026402f, -0.01584060f, -0.06833008f, 0.03417883f, -0.01002477f, 
    -0.30520499f, -0.30589178f, 0.09027257f, -0.02365901f, -0.02169716f, -0.11631382f, 0.08253616f, 0.07747400f, 
    0.01393200f, 0.05972640f, 0.01426481f, -0.02236800f, 0.00883784f, -0.02667549f, -0.03494727f, 0.01208113f, 
    -0.02714484f, -0.05371919f, -0.06703218f, -0.01737182f, 0.23896775f, -0.42353329f, -0.48424986f, -0.12507465f, 
    -0.16300762f, 0.01302730f, -0.11972099f, 0.10877892f, 0.14649305f, -0.06193488f, -0.06170900f, 0.04014756f, 
    0.07315983f, 0.10282808f, 0.04041368f, 0.01311198f, 0.00237385f, 0.03682038f, 0.04715049f, 0.04172181f, 
    -0.24398869f, -0.19151387f, 0.08702008f, 0.12317368f, -0.00206661f, -0.00073735f, -0.06928545f, -0.02818841f, 
    -0.11928026f, 0.05883334f, 0.09562115f, 0.01292348f, -0.01263325f, -0.01612870f, -0.03513642f, 0.04113377f, 
    0.00723365f, -0.07516465f, -0.09003020f, 0.01484747f, -0.29131976f, 0.35914123f, 0.12764306f, 0.22153221f, 
    0.13865934f, 0.03409684f, 0.09424786f, 0.11285128f, -0.08423520f, 0.05362818f, -0.01230948f, 0.01379443f, 
    0.01954587f, 0.01700608f, 0.05028445f, 0.10842781f, 0.10739683f, -0.02954846f, -0.06386067f, 0.09439821f, 
    -0.23768476f, -0.31453079f, 0.15100864f, 0.03631076f, -0.03620964f, -0.08808128f, 0.05539978f, 0.01956436f, 
    -0.02333737f, 0.01054174f, -0.00131563f, -0.00356287f, 0.00420437f, 0.00024442f, -0.03878339f, 0.00771371f, 
    0.00031471f, -0.03153222f, -0.04516933f, 0.01692832f, -0.16267993f, -0.52772027f, -0.27003783f, 0.30763987f, 
    0.03599748f, 0.14742753f, 0.06670760f, 0.01710247f, 0.10769695f, 0.13703252f, 0.00591308f, 0.01142524f, 
    -0.03932656f, -0.00841746f, -0.03357828f, -0.01260121f, -0.00591743f, -0.03006095f, 0.11459244f, 0.00183284f, 
    0.42152941f, -0.40487060f, 0.06833594f, -0.24038172f, -0.05236358f, -0.09750903f, 0.09217631f, -0.03447920f, 
    -0.06586543f, -0.19775054f, 0.06525245f, -0.06257863f, 0.03723684f, 0.00802972f, -0.02401226f, -0.00362673f, 
    0.00903411f, -0.01436757f, -0.04471087f, -0.03144438f, 0.10763720f, -0.31764504f, 0.09086850f, -0.32222557f, 
    -0.00485345f, 0.02576347f, 0.07784792f, -0.09968321f, 0.13114253f, 0.07467213f, -0.01116609f, -0.00494566f, 
    -0.05184874f, -0.03755919f, 0.01613475f, 0.02309227f, 0.03269596f, -0.00560728f, 0.07859588f, -0.04249220f, 
    0.32607001f, -0.42598003f, -0.04836274f, -0.15455182f, -0.08325468f, 0.05732436f, 0.14339080f, -0.05000415f, 
    0.02253119f, -0.05376012f, 0.06943420f, 0.03299611f, 0.10500956f, -0.03347536f, 0.05386349f, -0.02507407f, 
    0.02959001f, -0.03797872f, 0.00181917f, -0.02044021f, -0.07076519f, 0.00531231f, 0.06436298f, -0.03907147f, 
    0.02284651f, -0.07787486f, 0.06312395f, 0.01715554f, 0.02511023f, -0.04667934f, 0.05979482f, 0.04000451f, 
    0.01872377f, -0.00100838f, -0.01205356f, -0.03599112f, -0.04407591f, -0.09979105f, 0.04891698f, -0.02518959f, 
    -0.85030937f, -0.54985303f, -0.32137898f, 0.32261729f, 0.23673354f, 0.03420765f, 0.02603889f, 0.08871579f, 
    0.01639584f, -0.02422974f, 0.01746661f, 0.04629465f, -0.02037759f, 0.02001403f, -0.01936156f, 0.03684375f, 
    0.02211862f, 0.03138635f, -0.02159675f, -0.03714802f, 0.12742770f, -0.25348166f, -0.03911563f, -0.13732068f, 
    -0.10589011f, -0.00328475f, 0.10990504f, -0.00685496f, 0.08257390f, 0.05866853f, -0.02370449f, -0.00956829f, 
    0.00497768f, -0.05986021f, -0.03532284f, -0.03311281f, -0.05855811f, -0.04983309f, 0.02507142f, 0.03646044f, 
    -0.01837571f, 0.11991628f, -0.02715356f, 0.02166631f, -0.01544004f, 0.00357413f, -0.01478306f, 0.02829581f, 
    -0.04230655f, -0.02909040f, 0.04472120f, -0.02340285f, -0.00204864f, -0.06569222f, 0.05651719f, 0.00851392f, 
    -0.08087128f, -0.03957927f, -0.09414861f, 0.01351397f, 0.04439965f, 0.10693572f, -0.01616506f, -0.03409255f, 
    -0.05376093f, -0.00269207f, 0.02844006f, 0.00488662f, 0.00204065f, 0.00210522f, -0.02492340f, -0.12401213f, 
    -0.16871847f, -0.17870608f, -0.01779698f, 0.02295618f, -0.00413273f, 0.02191388f, 0.00491880f, 0.03675769f, 
    0.21601404f, -0.34617242f, -0.25153089f, -0.16710065f, -0.17688957f, 0.03340346f, 0.04141084f, -0.10798303f, 
    0.08029488f, 0.05091306f, -0.01187808f, -0.01563728f, -0.02186608f, -0.03197452f, 0.01934941f, -0.08288044f, 
    -0.03151405f, -0.04885015f, -0.01040854f, -0.08567128f, -0.08611339f, 0.10761426f, 0.10691790f, -0.00528805f, 
    0.03777260f, -0.00442655f, -0.03762994f, 0.00830373f, -0.00698764f, -0.02923804f, 0.04538217f, -0.01899881f, 
    0.07174179f, -0.02513037f, -0.01138212f, -0.12001412f, -0.15074261f, -0.04817918f, -0.11710238f, 0.03580306f, 
    0.27346927f, -0.66822761f, -0.12104863f, -0.48724118f, -0.11221252f, 0.02037408f, 0.21269691f, -0.06536920f, 
    0.09353673f, 0.16094671f, 0.01095364f, -0.03462717f, 0.02285817f, -0.00883280f, -0.00965603f, -0.03588826f, 
    0.00529580f, -0.08745856f, -0.07959097f, -0.06155341f, 0.30036548f, -0.01155933f, -0.14574683f, -0.04303661f, 
    -0.00176135f, 0.04010951f, 0.02465690f, 0.03530939f, -0.02736542f, -0.01718651f, 0.04925277f, -0.01922573f, 
    0.06259614f, 0.05284365f, 0.01771115f, -0.00253460f, -0.00016522f, -0.00370771f, 0.05296210f, -0.04068018f, 
    0.02736269f, 0.11497413f, 0.04581669f, 0.01964944f, -0.09523853f, -0.00613049f, 0.00179117f, -0.00802992f, 
    -0.03446478f, -0.09267066f, -0.08869679f, -0.00919766f, -0.12015482f, -0.14256626f, -0.18363468f, 0.00846650f, 
    -0.05350061f, -0.02859214f, 0.00916123f, 0.01528429f, -0.43271822f, -0.47894093f, 0.32738736f, -0.09076393f, 
    0.03717502f, 0.01819145f, -0.09374944f, 0.06037645f, 0.01712396f, -0.02303392f, -0.04542637f, 0.03712722f, 
    -0.00101510f, 0.02269602f, -0.06154094f, -0.07864412f, -0.01175316f, 0.06647663f, -0.04905622f, -0.00111718f, 
    0.11101271f, -0.22746010f, -0.05882700f, -0.07794451f, 0.06220511f, 0.07649469f, 0.09522454f, 0.03671374f, 
    0.03381920f, 0.01785067f, 0.02600420f, -0.00169188f, 0.07436816f, 0.04055201f, 0.05200232f, -0.01992157f, 
    0.00772484f, 0.01466930f, 0.00780881f, 0.00537222f, -0.07712058f, -0.00336049f, 0.11603781f, -0.06459043f, 
    0.09375665f, -0.01939410f, 0.02952386f, 0.00810397f, -0.02396290f, 0.03146604f, -0.07580610f, -0.03271946f, 
    -0.03907145f, 0.06486630f, -0.01337470f, -0.00936904f, -0.01595095f, -0.01994614f, -0.03159638f, -0.05467525f, 
    0.50838399f, -0.22594015f, 0.20278282f, -0.15938105f, 0.20927127f, -0.00288006f, 0.03121674f, 0.13126299f, 
    0.12423522f, -0.09321596f, 0.07074479f, -0.11820144f, 0.08844731f, -0.15941490f, -0.09530216f, -0.15272158f, 
    -0.02511110f, -0.03432078f, 0.00464203f, 0.00931800f, -0.06562988f, 0.02982407f, 0.03284735f, -0.02581599f, 
    -0.03112805f, -0.01233763f, 0.03913937f, 0.02744586f, 0.03353941f, 0.01373474f, -0.02572439f, -0.02575412f, 
    -0.00356718f, 0.03488583f, -0.00100991f, 0.04400504f, 0.00287045f, 0.00160798f, 0.04686226f, 0.05373916f, 
    0.37959862f, 0.19319011f, -0.32978007f, -0.10479025f, -0.14806545f, -0.03353526f, 0.01538406f, -0.02898824f, 
    -0.10872164f, -0.06801161f, 0.04955812f, 0.00884607f, 0.08243999f, -0.05415887f, -0.08144034f, -0.04960005f, 
    -0.09755008f, 0.00365656f, -0.07969707f, -0.04606825f, 0.03986018f, 0.12072030f, -0.00762574f, 0.05497850f, 
    -0.10066815f, -0.01187696f, -0.01067396f, 0.00904238f, 0.01611991f, -0.02288000f, 0.02830258f, -0.13386980f, 
    0.00689413f, -0.02104607f, -0.13109806f, -0.06174428f, 0.02301948f, 0.04634129f, -0.01676352f, 0.02807282f, 
    0.18416670f, 0.22654702f, 0.08692215f, 0.02068169f, -0.27629074f, 0.02185285f, -0.00591987f, -0.10938472f, 
    0.01030321f, -0.23266968f, -0.01416246f, -0.01390625f, 0.03549700f, -0.02785135f, 0.03749053f, -0.05896508f, 
    0.11520538f, 0.03294347f, 0.09446878f, -0.00290541f, 0.46887606f, 0.14046742f, -0.13131034f, 0.00588065f, 
    -0.06333533f, 0.18113549f, -0.11451558f, -0.00906447f, 0.03001091f, 0.03315892f, 0.00815051f, 0.04907915f, 
    -0.06488273f, 0.14459202f, -0.02070616f, 0.02739366f, -0.09975339f, -0.07371048f, -0.13045940f, -0.02564776f, 
    0.01873630f, -0.48824441f, -0.54132897f, -0.29090625f, -0.12509304f, -0.00680325f, 0.05051721f, 0.19105607f, 
    0.03638392f, 0.13516252f, 0.03630879f, -0.01924050f, -0.10487212f, -0.03109140f, -0.03126163f, -0.00455011f, 
    -0.01367604f, -0.00250224f, 0.03252801f, 0.01723243f, -0.12018338f, -0.05452949f, -0.01835555f, 0.01820177f, 
    -0.04704802f, -0.08450945f, -0.02829249f, -0.00591796f, 0.00170861f, -0.01634729f, -0.03816999f, 0.01661531f, 
    -0.01212225f, 0.02678150f, 0.07144288f, -0.08392203f, 0.07577500f, 0.05611670f, 0.06549922f, 0.09823628f, 
    -0.01840951f, 0.16606493f, -0.24880591f, -0.24287955f, -0.10976729f, 0.09230959f, -0.04706096f, 0.01774814f, 
    0.11858875f, 0.04951441f, 0.02268113f, -0.00322980f, -0.01106619f, 0.12259851f, 0.07716237f, -0.05288071f, 
    -0.03528928f, 0.12565961f, -0.13163866f, -0.14279181f, 0.09050325f, -0.01721017f, -0.06713378f, 0.07442323f, 
    0.17699596f, -0.09161489f, 0.05965735f, 0.00165820f, 0.05099225f, 0.00132037f, -0.01542366f, -0.03912518f, 
    0.03160368f, -0.03966496f, -0.01379070f, 0.06070912f, 0.00474310f, 0.02116371f, -0.12185745f, -0.15823230f, 
    0.00060329f, 0.04806310f, 0.18887576f, -0.00561987f, -0.13826498f, 0.12953402f, -0.20783888f, -0.02016294f, 
    -0.08181253f, -0.24160688f, -0.04708236f, 0.02217006f, -0.00981836f, -0.06816748f, 0.00264035f, 0.06506532f, 
    0.07377562f, -0.03818368f, -0.11313224f, -0.37455514f, 0.12547144f, 0.05453465f, 0.01334838f, 0.04900592f, 
    -0.13494515f, 0.03683344f, -0.03948086f, -0.13070834f, -0.10571495f, -0.07838365f, -0.03222918f, 0.04976873f, 
    0.03615241f, 0.00250594f, 0.07232752f, -0.04493250f, 0.08090068f, 0.09100193f, 0.06152193f, 0.08575575f, 
    0.14853051f, 0.08794757f, 0.13920783f, -0.07205325f, -0.15992792f, -0.09751577f, 0.03786565f, -0.13289005f, 
    0.09277894f, -0.06631456f, 0.00917085f, -0.00257011f, 0.13347788f, -0.11293066f, 0.07803820f, 0.04337868f, 
    -0.16651434f, -0.30875486f, 0.03415368f, -0.26147839f, 0.35419673f, -0.15814060f, -0.09354897f, -0.11839528f, 
    -0.01004751f, -0.00532081f, -0.11465741f, -0.08614933f, 0.01499313f, 0.03579862f, 0.03824661f, 0.03905712f, 
    0.14952096f, -0.07225250f, 0.14717883f, 0.06935314f, 0.13735466f, 0.01219012f, 0.02276000f, 0.12550765f, 
    -0.05341078f, -0.22094746f, -0.25461137f, 0.09587456f, 0.27179882f, -0.03803612f, 0.10176325f, 0.11617212f, 
    0.04482270f, 0.04267617f, -0.00596893f, -0.10336111f, -0.05694146f, 0.00968055f, -0.01930809f, 0.01164511f, 
    -0.02715739f, 0.03341081f, -0.04586340f, -0.05993852f, -0.08519810f, -0.09865187f, -0.60449600f, -0.39214671f, 
    -0.12919030f, 0.05541563f, -0.02134037f, 0.07133468f, 0.05445751f, 0.02288970f, 0.00811869f, -0.03627788f, 
    0.05408173f, 0.04799840f, 0.02715694f, 0.03326455f, 0.00548866f, 0.03047669f, 0.04636195f, 0.06960770f, 
    0.23669945f, 0.12605488f, -0.02128760f, -0.07378135f, 0.01628897f, 0.19027904f, -0.08212062f, 0.10194127f, 
    0.03557398f, 0.00653904f, -0.02148942f, 0.11437275f, 0.07069814f, 0.01827710f, 0.07665116f, 0.08578001f, 
    0.10201342f, -0.10031907f, 0.04413605f, 0.06328474f, -0.25341776f, -0.48719689f, -0.14069004f, 0.11190496f, 
    0.19386810f, 0.10602278f, -0.06353161f, 0.11409297f, -0.04818261f, 0.14865072f, 0.05807717f, 0.01457139f, 
    0.04602717f, 0.06774977f, 0.13065308f, -0.01474494f, 0.10907444f, -0.09943630f, -0.28684166f, 0.08687646f, 
    0.66956758f, 0.12431744f, 0.01590198f, -0.16529202f, -0.00789759f, 0.13899042f, 0.00241658f, 0.00418592f, 
    -0.02735448f, -0.15314525f, 0.09640678f, 0.01924329f, 0.08340643f, 0.03809758f, 0.01844813f, 0.05736402f, 
    -0.01977207f, -0.10981597f, -0.01857310f, -0.01645608f, 0.18646263f, -0.22969031f, -0.14699443f, -0.02277165f, 
    -0.07705678f, -0.09626654f, -0.04858711f, -0.05653995f, -0.05774260f, -0.00467101f, -0.05735156f, -0.03548278f, 
    -0.05050641f, -0.07206353f, 0.00380554f, -0.02841861f, 0.04860388f, 0.04364731f, 0.15077512f, 0.01987092f, 
    -0.16005866f, -0.44212410f, 0.03670947f, -0.11794841f, 0.10419905f, -0.07484163f, 0.06361663f, 0.08047844f, 
    0.03770111f, 0.01008799f, 0.03702894f, 0.00680954f, -0.01496887f, -0.06134097f, -0.07854930f, -0.03581509f, 
    -0.01023038f, -0.05247594f, -0.00800941f, -0.06279992f, 0.58631361f, 0.18942061f, -0.08634887f, -0.06487467f, 
    -0.26877227f, -0.01727478f, -0.26169285f, -0.24249248f, -0.12566394f, -0.26916045f, 0.06482580f, 0.08448981f, 
    0.16958849f, -0.05074244f, 0.02565821f, -0.13605344f, 0.05759525f, -0.04026742f, 0.21622860f, -0.03412251f, 
    -0.01548095f, -0.07490878f, -0.06273007f, -0.10781112f, -0.06729954f, -0.08400463f, 0.00871670f, -0.02124090f, 
    -0.03870767f, -0.09737803f, -0.01073139f, 0.02325952f, 0.08665784f, 0.04154223f, 0.11113241f, 0.00822082f, 
    0.03499663f, -0.03118029f, 0.07574782f, 0.05841085f, -0.00884319f, -0.06039736f, -0.02041292f, 0.08472039f, 
    -0.01073917f, 0.04035664f, -0.04695275f, -0.09356839f, -0.01266809f, -0.00917843f, -0.00347635f, 0.01574729f, 
    0.05192053f, -0.01680749f, 0.07719494f, 0.00530044f, 0.03766834f, 0.13478869f, 0.03877197f, 0.13057925f, 
    0.20481707f, 0.21672964f, 0.03358581f, -0.03177719f, -0.13427661f, 0.06040036f, -0.05613230f, -0.03498542f, 
    0.01067244f, -0.06237948f, 0.00724414f, 0.07350689f, -0.01719810f, 0.02560486f, 0.00928108f, -0.13514575f, 
    -0.09424362f, -0.16872720f, 0.00575822f, -0.21958278f, -0.10341284f, -0.11803025f, -0.03347893f, 0.09874008f, 
    0.06519110f, 0.09819458f, -0.02713665f, 0.02189464f, 0.02708155f, -0.08523650f, -0.04351708f, 0.05411952f, 
    0.07434916f, -0.03262892f, -0.00786947f, -0.05004681f, 0.01765156f, 0.05560392f, -0.02135357f, 0.16873801f, 
    0.49449754f, 0.23244764f, 0.07051922f, 0.03529412f, -0.20101130f, 0.03114738f, 0.26672968f, 0.00740030f, 
    0.09999260f, -0.29259068f, 0.02537146f, 0.05027964f, -0.01097099f, -0.03410457f, -0.00108319f, 0.02715335f, 
    0.13992026f, -0.12256366f, 0.01387142f, -0.07826881f, 0.07720383f, 0.07875067f, -0.28049305f, -0.23833759f, 
    -0.12479089f, -0.05860642f, -0.01108675f, -0.07641165f, -0.05840375f, -0.10157316f, 0.04478885f, 0.02041457f, 
    0.02570383f, 0.13418256f, 0.00741621f, 0.02518882f, 0.05932013f, 0.04394615f, -0.10432921f, -0.19397427f, 
    -0.55628192f, -0.18895458f, 0.28641993f, 0.06792221f, 0.07417046f, -0.11385543f, 0.02633413f, -0.07859468f, 
    -0.04878037f, -0.01026474f, -0.04378579f, 0.01614853f, 0.05438477f, 0.06592125f, 0.02292624f, -0.04608181f, 
    0.00185276f, -0.04164236f, 0.05399983f, -0.02754428f, -0.21398623f, 0.11862189f, 0.06023411f, 0.03177300f, 
    -0.07888292f, -0.01660323f, 0.04126182f, -0.04583817f, 0.01759041f, -0.05345605f, -0.07254631f, -0.05432940f, 
    0.01075539f, -0.03825672f, -0.00386328f, 0.04419303f, 0.01365016f, 0.01456714f, 0.01923589f, 0.03116211f, 
    -0.03596934f, -0.37549469f, -0.38096380f, -0.20839539f, -0.07282043f, -0.04381915f, 0.02947562f, 0.07670832f, 
    0.06180428f, 0.14338280f, 0.07206698f, -0.05255845f, -0.11791874f, -0.06457102f, -0.08038246f, 0.03447610f, 
    0.03857245f, -0.01042766f, 0.04031054f, -0.03151038f, 0.14804356f, 0.10047457f, -0.02351571f, -0.04163094f, 
    -0.05953764f, 0.04180739f, -0.02146382f, 0.02317892f, 0.00785998f, -0.02956372f, -0.06770671f, 0.02431780f, 
    0.05399721f, 0.02558500f, 0.02822478f, -0.02922518f, 0.02078974f, -0.00023601f, 0.03250255f, 0.07893872f, 
    -0.13450401f, -0.08104724f, 0.11874836f, 0.08386636f, 0.03188443f, 0.07802306f, 0.00259781f, 0.05064929f, 
    -0.04482549f, -0.06345379f, 0.00951521f, -0.00721713f, -0.01003618f, -0.02106484f, -0.00606470f, -0.05255240f, 
    -0.09444328f, -0.02505545f, -0.05917633f, -0.35404792f, -0.31289855f, 0.08490100f, 0.17152023f, 0.02725770f, 
    -0.12659506f, -0.04586119f, 0.02308820f, -0.02792772f, 0.02666760f, 0.02227704f, -0.06491041f, -0.06881762f, 
    0.00919950f, 0.00885803f, 0.00630219f, 0.00371559f, 0.06110789f, 0.03281603f, 0.01248782f, 0.03188758f, 
    -0.14190058f, -0.07033342f, -0.43841758f, -0.32739997f, -0.15387124f, -0.04115759f, -0.26918247f, 0.08067487f, 
    -0.06497236f, -0.15933390f, 0.00812016f, 0.01808649f, -0.01354223f, 0.03888594f, 0.04339539f, 0.04747574f, 
    -0.00691039f, 0.08390507f, -0.11295257f, -0.24269007f, -0.26603031f, -0.24811283f, -0.06449620f, 0.01729262f, 
    0.27066463f, -0.06241130f, -0.02955670f, -0.00942457f, 0.06118232f, -0.01882589f, -0.02106503f, -0.13395526f, 
    0.04881192f, 0.01684199f, -0.07444704f, -0.04933537f, 0.02553704f, 0.06746521f, 0.06005341f, 0.07786261f, 
    0.12975161f, -0.05248589f, -0.03719947f, -0.11986163f, -0.20419824f, -0.09213668f, 0.02543140f, -0.03182410f, 
    0.02808969f, -0.04613886f, 0.09694945f, 0.11963949f, 0.02009818f, 0.03883921f, 0.01712318f, -0.00265512f, 
    -0.02106565f, -0.08933063f, -0.04742034f, 0.03354308f, -0.11270625f, -0.04585226f, 0.01869798f, -0.00644174f, 
    -0.00392694f, -0.09806558f, 0.02344432f, -0.01438965f, 0.00881411f, -0.00379936f, 0.02091923f, -0.03863514f, 
    0.00618631f, 0.01435294f, -0.04238998f, -0.02762144f, 0.07969972f, 0.07198559f, 0.14912243f, 0.03709802f, 
    -0.01186031f, 0.04194757f, -0.05270905f, -0.00785834f, -0.03503767f, -0.01548684f, 0.08880666f, 0.08271251f, 
    0.01993870f, 0.01627871f, 0.03887336f, -0.01693425f, 0.01298265f, 0.05851862f, 0.01626411f, 0.04865330f, 
    -0.01620852f, 0.04520841f, 0.14226252f, -0.04484854f, -0.11486492f, -0.00372661f, 0.06581943f, 0.11828069f, 
    0.00822834f, 0.11580891f, -0.03532271f, 0.00462525f, -0.07907886f, 0.01967660f, -0.05586446f, -0.05535269f, 
    0.06101646f, 0.00972020f, -0.06019599f, -0.03760691f, -0.11388168f, 0.03518102f, 0.00620855f, -0.07259729f, 
    -0.02684838f, 0.11509296f, -0.04581894f, -0.00337169f, -0.22537787f, -0.05366803f, 0.02363077f, 0.06973186f, 
    0.06425108f, -0.00312828f, 0.07306851f, -0.05222868f, -0.04857735f, 0.07758544f, 0.06092472f, 0.05476423f, 
    0.08659117f, -0.00530393f, -0.02263950f, 0.03405717f, 0.08171974f, -0.29816252f, -0.23506720f, -0.17802241f, 
    -0.11583715f, 0.01038680f, -0.03496055f, 0.01341453f, 0.09242342f, 0.01454387f, -0.02518659f, 0.04686652f, 
    0.00873683f, 0.00155701f, -0.00538370f, -0.00152504f, 0.04791472f, 0.10041576f, 0.04632429f, 0.09735562f, 
    -0.08798765f, -0.26812220f, -0.25144482f, -0.06765061f, -0.05411376f, -0.04860321f, -0.03205229f, -0.04590322f, 
    0.11729123f, -0.02277678f, -0.03016990f, 0.04316900f, 0.00550428f, -0.01734201f, 0.05278827f, 0.01217421f, 
    0.09217612f, 0.07287706f, 0.05629399f, 0.06352744f, -0.16417123f, -0.54830605f, -0.18848304f, -0.10764097f, 
    0.12848714f, -0.13253424f, 0.06785377f, 0.13484646f, 0.10581418f, 0.07696040f, 0.08357564f, -0.11102887f, 
    -0.05340576f, -0.00160798f, -0.06921671f, -0.05854708f, -0.02865556f, -0.03818690f, -0.00110026f, -0.06352293f, 
    0.41930807f, -0.07935677f, -0.06051754f, 0.06662047f, -0.17091966f, 0.04081565f, -0.04856507f, -0.19104362f, 
    -0.11025015f, -0.02040281f, 0.05315397f, 0.07685308f, 0.10134001f, -0.00832262f, 0.03366510f, -0.03084256f, 
    0.06638602f, 0.06509314f, 0.08803942f, 0.11152130f, -0.24893582f, -0.34020045f, 0.33505842f, 0.04433748f, 
    0.31567925f, -0.07667115f, 0.00196543f, -0.09724932f, -0.01632361f, -0.02667377f, 0.05122061f, -0.04687852f, 
    0.01956307f, -0.10601043f, -0.00785488f, -0.16082889f, -0.14026202f, -0.23883078f, -0.20456901f, -0.20781215f, 
    0.13895102f, -0.28415084f, -0.20517685f, -0.04390201f, -0.02674220f, 0.02726793f, 0.03685252f, 0.02863581f, 
    0.07028961f, -0.00791422f, -0.04626643f, 0.04369522f, -0.01174559f, -0.01416679f, 0.01390079f, 0.03552171f, 
    0.05390275f, 0.05827077f, 0.12118381f, 0.04521801f, 0.15108471f, -0.50472701f, -0.52031833f, -0.14459746f, 
    -0.19878466f, -0.11937078f, -0.26196635f, -0.03388445f, -0.04735307f, -0.10588543f, -0.03799868f, -0.00758088f, 
    -0.03923142f, -0.01000298f, 0.02992282f, 0.01956819f, -0.00242467f, 0.04099795f, 0.02308729f, 0.10424238f, 
    0.11549563f, -0.24607323f, -0.20489669f, -0.08596832f, -0.06083244f, -0.02234888f, 0.01788916f, 0.02527479f, 
    -0.02952225f, 0.18207169f, 0.00938657f, 0.03154320f, -0.03004832f, -0.00272430f, -0.03960870f, -0.00380189f, 
    0.06758740f, 0.06305137f, 0.03789945f, 0.05263822f, 0.01558297f, 0.06496903f, -0.32751554f, -0.23573047f, 
    -0.04000361f, -0.00405911f, -0.10614280f, 0.03425382f, -0.04343408f, -0.07235574f, 0.01889637f, -0.01345442f, 
    -0.01333160f, 0.07386953f, 0.02987465f, 0.03891858f, -0.02100474f, 0.03817317f, -0.07861714f, -0.24374343f, 
    0.07388253f, -0.05763701f, -0.26994616f, -0.10276615f, -0.00219101f, -0.01569874f, 0.03233889f, -0.00097772f, 
    0.01685601f, 0.09324123f, 0.08226553f, -0.05651193f, -0.04490152f, -0.03016711f, 0.01252558f, 0.00967599f, 
    0.03073673f, 0.00184348f, 0.08386176f, 0.03842720f, -0.22211604f, 0.04491520f, 0.19057232f, 0.03753096f, 
    0.09484085f, -0.02987966f, 0.01229690f, -0.03569197f, 0.00590961f, -0.02297566f, -0.08888017f, -0.05816121f, 
    0.06571580f, -0.03617483f, 0.03622073f, -0.08483698f, -0.02391633f, 0.06435379f, -0.04227640f, 0.00100173f, 
    0.43352532f, -0.39111593f, -0.40185323f, -0.11295117f, 0.06942226f, 0.07585122f, -0.01434231f, -0.01867265f, 
    -0.06613580f, -0.06344538f, -0.04236715f, 0.00763310f, 0.00357417f, -0.04360588f, -0.01581428f, 0.00464252f, 
    0.01496873f, 0.08703132f, 0.04996569f, 0.15932292f, -0.10408634f, -0.20164302f, -0.37198442f, -0.22602192f, 
    0.01023419f, -0.04397750f, -0.05968302f, 0.01180019f, 0.04044213f, -0.12915853f, -0.02389063f, -0.03277576f, 
    -0.03584817f, -0.00119612f, 0.03011748f, 0.00983615f, 0.01599019f, 0.06501795f, 0.06407058f, 0.05052518f, 
    -0.27644822f, -0.07892306f, 0.16001080f, 0.03299132f, 0.07846348f, -0.03922045f, 0.08421467f, -0.03198062f, 
    0.02971509f, -0.03708435f, 0.02560002f, 0.03722366f, 0.05437646f, 0.10218694f, 0.08451115f, 0.03680047f, 
    0.06869493f, 0.00383209f, 0.05415406f, 0.01862835f, -0.16164286f, -0.13675857f, -0.00966234f, -0.08318529f, 
    -0.10785057f, -0.09702937f, -0.02102042f, -0.02405496f, -0.01537984f, -0.05720378f, 0.06992881f, 0.08329231f, 
    0.05969562f, 0.03091742f, 0.07024564f, -0.01881225f, 0.00883947f, -0.03270423f, 0.00874510f, 0.04646006f, 
    0.05701032f, -0.09790193f, -0.46069315f, -0.18899421f, 0.03623945f, 0.07802498f, 0.03213739f, 0.04552158f, 
    0.07697239f, -0.03350806f, 0.01954812f, 0.00199055f, -0.02599651f, 0.08755975f, 0.06010775f, 0.05502431f, 
    0.02791633f, 0.00988873f, -0.10592742f, 0.02491092f, -0.42203730f, -0.07158626f, 0.14306410f, 0.09523907f, 
    -0.03149649f, -0.04515576f, 0.02717788f, -0.00748675f, 0.02837359f, 0.03798686f, -0.06576894f, 0.03263204f, 
    0.00373344f, 0.01122380f, 0.02816064f, 0.02413211f, 0.05586781f, 0.02276163f, 0.07177180f, 0.04252395f, 
    -0.04592019f, -0.40392625f, -0.57790518f, -0.27849984f, -0.03587226f, 0.02672858f, 0.03814664f, 0.10686384f, 
    -0.00437262f, -0.07084201f, -0.13333961f, -0.01801214f, -0.03963194f, -0.06493796f, 0.00048953f, -0.01272146f, 
    0.08447988f, 0.07478762f, 0.10113880f, 0.03117220f, -0.06601695f, -0.25606340f, -0.19274671f, -0.14554630f, 
    -0.04730022f, -0.04075608f, 0.03405768f, 0.04817260f, 0.06734893f, 0.10541186f, 0.09527708f, 0.06354365f, 
    -0.05944942f, -0.05868808f, -0.05698184f, 0.03187272f, 0.04839629f, 0.01345898f, 0.00887596f, 0.04894542f, 
    -0.04402222f, 0.09018153f, 0.01789009f, -0.04294304f, -0.13935602f, -0.05220501f, 0.01412402f, -0.00823823f, 
    0.01606556f, 0.00711435f, 0.03075908f, 0.01192660f, 0.03931274f, 0.06948179f, 0.11732837f, -0.01411485f, 
    0.07159989f, -0.01746575f, 0.06100025f, 0.00701830f, 0.00008738f, -0.53033310f, -0.18469594f, -0.04576636f, 
    0.16259833f, 0.00144483f, 0.17652543f, 0.08063077f, 0.03879962f, -0.05231840f, -0.00379166f, 0.00535543f, 
    0.05023322f, 0.07277989f, 0.10230172f, 0.02393117f, 0.06244673f, -0.12728606f, 0.05299658f, -0.01931065f, 
    -0.09363386f, -0.17445920f, -0.19546895f, -0.11361943f, 0.00226473f, 0.04615073f, -0.02912964f, 0.02338502f, 
    0.03769333f, 0.11502902f, 0.05403211f, 0.09149104f, -0.20582332f, -0.04539813f, -0.04498587f, -0.02027848f, 
    0.03875066f, 0.02736779f, -0.00190983f, 0.03843778f, -0.14053422f, -0.14287853f, 0.00815006f, 0.06210141f, 
    0.03219390f, -0.00299713f, -0.00186525f, 0.00071836f, -0.01197416f, 0.02408583f, 0.01783106f, 0.02947492f, 
    -0.02426797f, 0.01401287f, 0.03336325f, -0.04646050f, 0.04780866f, 0.05822198f, 0.07295997f, 0.07964355f, 
    0.08914966f, -0.02799380f, -0.06843103f, 0.19230580f, 0.07363342f, 0.01058743f, -0.03483658f, 0.09575054f, 
    -0.04502409f, -0.03826614f, -0.00730562f, 0.12179474f, -0.02477425f, -0.10669779f, 0.01584572f, -0.05064437f, 
    0.01023863f, -0.02264062f, -0.11403523f, -0.02098198f, -0.04758957f, -0.08594335f, -0.05984373f, 0.02151093f, 
    -0.16683221f, -0.10839944f, -0.07839356f, -0.08969384f, -0.06096398f, -0.04520154f, 0.07316782f, 0.09358887f, 
    -0.01679699f, 0.01656237f, 0.01012761f, 0.01378986f, 0.12237480f, 0.08506207f, 0.11482731f, 0.09681832f, 
    0.13107663f, 0.10099696f, -0.23379964f, -0.11247925f, -0.15231779f, 0.00351662f, 0.11461604f, 0.11236624f, 
    0.12133887f, 0.05804154f, 0.10032021f, -0.00301522f, -0.03875338f, -0.02565352f, 0.03650897f, 0.00876063f, 
    0.06756006f, -0.01675867f, 0.08634253f, 0.01031882f, -0.18450496f, -0.08853139f, 0.05995621f, -0.04282922f, 
    -0.17210442f, -0.04975955f, -0.00268863f, -0.03213978f, 0.00085305f, -0.03721128f, -0.01695425f, 0.01091207f, 
    0.03969900f, 0.05486375f, 0.09515921f, 0.00408883f, 0.06675386f, -0.02615767f, 0.05471621f, 0.04737966f, 
    -0.15117277f, 0.23550929f, -0.52430028f, -0.00908985f, -0.16721882f, 0.14723080f, 0.06651712f, 0.16956273f, 
    -0.05152958f, 0.02147212f, 0.11823556f, -0.08350426f, -0.05987835f, -0.07685687f, -0.10588125f, 0.09880847f, 
    -0.08454216f, -0.02113722f, 0.02800465f, -0.06655213f, -0.11801044f, -0.14238536f, -0.24117161f, 0.01321379f, 
    -0.05218357f, -0.12580875f, 0.12892324f, 0.01906199f, -0.01275036f, -0.00052608f, 0.14496046f, -0.06179778f, 
    0.00897887f, 0.07172651f, -0.06914843f, -0.02792474f, 0.17136316f, -0.00582707f, -0.19123806f, -0.04420218f, 
    -0.23990959f, 0.22940388f, -0.17589812f, 0.42786175f, -0.24377732f, -0.13510299f, -0.00871234f, -0.22653390f, 
    -0.08852439f, -0.10642771f, 0.11287810f, -0.05058196f, 0.04536707f, 0.02673262f, 0.07567777f, 0.00484500f, 
    0.02900308f, 0.02446619f, 0.03299183f, -0.03921266f, 0.06639673f, -0.09003888f, 0.02914494f, 0.05175985f, 
    0.12118497f, -0.02258073f, 0.11615524f, -0.06806120f, 0.02130433f, -0.01552800f, -0.03558145f, 0.05789413f, 
    0.02909913f, 0.02476302f, 0.03893401f, 0.00322846f, 0.07698634f, -0.03496263f, -0.08015071f, 0.01810923f, 
    -0.50352681f, -0.14462596f, -0.05616555f, 0.29033718f, -0.17093243f, -0.12526809f, 0.12883580f, -0.19116801f, 
    0.07996459f, 0.05907234f, 0.09342416f, -0.09812734f, 0.04829679f, 0.04131992f, 0.05528111f, -0.00736210f, 
    0.02709615f, -0.02962185f, 0.06441242f, 0.05288943f, 0.08727818f, 0.10909538f, 0.06741823f, 0.27910724f, 
    -0.07515017f, 0.01283630f, -0.00181076f, -0.04169052f, 0.06332423f, -0.03125084f, 0.04977487f, -0.01222958f, 
    0.06594955f, 0.03036766f, 0.07239651f, 0.06916491f, 0.07866088f, 0.00704655f, 0.06562871f, 0.14282094f, 
    0.28002441f, -0.27759799f, -0.55796385f, 0.14495249f, 0.06870057f, 0.02938588f, 0.08371037f, 0.11977497f, 
    0.07979827f, 0.19266634f, -0.01116266f, 0.01603033f, -0.05068419f, -0.01697592f, -0.03785519f, -0.03203016f, 
    0.08339418f, 0.05685448f, 0.02963489f, 0.07478750f, 0.10079606f, 0.05295941f, -0.24459499f, 0.09551319f, 
    0.00428486f, 0.11373399f, 0.12778136f, 0.20689365f, 0.02242605f, -0.01053539f, 0.03800627f, -0.05076595f, 
    -0.07502420f, -0.08794103f, -0.10072328f, 0.07595850f, -0.03392649f, -0.08893280f, -0.07970188f, -0.01116034f, 
    -0.13514535f, 0.12274478f, -0.17016703f, 0.08802247f, 0.05332868f, 0.09066179f, -0.14243217f, 0.01873923f, 
    -0.06768774f, 0.00670041f, -0.04744741f, -0.04615091f, -0.04411386f, 0.02075405f, 0.00530224f, 0.08774277f, 
    0.10809292f, 0.01909230f, 0.09536605f, 0.12907183f, 0.16619995f, -0.59578878f, 0.10280460f, 0.02729703f, 
    -0.08236291f, -0.12401073f, 0.15319403f, -0.12708385f, -0.09582579f, -0.13036130f, -0.07196267f, -0.04376671f, 
    -0.02389172f, -0.07745697f, 0.03975562f, 0.06528496f, -0.00816523f, -0.13623615f, -0.31030956f, 0.00770009f, 
    0.08565333f, -0.00293312f, 0.01220028f, 0.06666840f, -0.23601712f, -0.17663448f, 0.00777884f, -0.17081799f, 
    0.10003152f, -0.07810443f, -0.01020912f, -0.00054399f, 0.05778901f, 0.08361849f, 0.00507977f, 0.06236868f, 
    0.05270098f, 0.08120572f, -0.00734515f, 0.05023282f, -0.33279020f, -0.00629036f, 0.16599838f, 0.30615675f, 
    -0.49964833f, 0.15689932f, -0.17401205f, -0.08730365f, 0.06474623f, 0.03491671f, 0.04279295f, -0.04506358f, 
    0.08000994f, 0.07056249f, 0.05824297f, 0.03800122f, 0.01440135f, -0.06663139f, 0.04317281f, 0.05652949f, 
    0.14344707f, -0.56819701f, -0.18283488f, 0.02513724f, -0.21497667f, -0.13503253f, 0.07600597f, 0.03686073f, 
    0.00201215f, 0.03673424f, -0.00292339f, -0.07677100f, -0.03448351f, 0.01091455f, -0.01634123f, 0.00262342f, 
    0.06356163f, -0.10305737f, 0.00709888f, -0.03088593f, 0.11928714f, -0.67580867f, -0.12338443f, -0.32652253f, 
    -0.19548689f, 0.09801972f, -0.19914000f, 0.04738298f, 0.01461286f, 0.04533422f, -0.03233729f, -0.07074244f, 
    -0.03877093f, -0.03766080f, -0.09509998f, 0.07426166f, -0.08855654f, 0.02478451f, -0.08500156f, 0.05774986f, 
    -0.75033146f, -0.08946007f, -0.66573536f, -0.02280851f, -0.22927053f, 0.01352089f, -0.12547861f, 0.10435455f, 
    -0.25579625f, 0.06665428f, 0.05854807f, -0.02142454f, -0.02428684f, -0.05666710f, -0.10768609f, 0.11585201f, 
    -0.01238062f, -0.00413652f, 0.11401284f, 0.03005540f, -0.17675808f, 0.10219203f, 0.34108344f, 0.05981762f, 
    -0.08936182f, -0.02722011f, -0.01191069f, 0.04781018f, -0.09979009f, -0.04464589f, -0.00347676f, 0.00773789f, 
    0.06994174f, -0.01830047f, -0.01960333f, -0.03627790f, -0.02958262f, -0.05892250f, -0.10223653f, -0.05627433f, 
    0.14260899f, 0.03773286f, 0.22956824f, 0.29684913f, -0.29090080f, 0.10776304f, -0.07798097f, -0.10089565f, 
    0.02759798f, -0.21340995f, -0.05945568f, 0.02682496f, 0.04409516f, -0.01002255f, 0.01089908f, 0.08092319f, 
    0.00625868f, -0.03659271f, 0.01007821f, 0.12615858f, -0.02181322f, -0.00373710f, -0.46195090f, 0.14466242f, 
    -0.33812991f, 0.03126408f, 0.04465259f, -0.04456658f, 0.00675501f, -0.22559617f, 0.02865200f, -0.07202818f, 
    -0.06237138f, -0.05892555f, -0.12228426f, 0.00154459f, -0.03565464f, -0.18085453f, -0.11160079f, -0.10787997f, 
    -0.25865844f, -0.02344601f, -0.05659848f, 0.19594814f, 0.15697487f, 0.02890253f, 0.04342004f, 0.04679852f, 
    -0.08211332f, -0.11535329f, 0.09744307f, 0.14796650f, 0.03175152f, -0.14446004f, 0.02933148f, -0.02939132f, 
    0.06094001f, -0.06948821f, 0.00091472f, 0.04392248f, 0.11131801f, -0.10563201f, -0.04298287f, -0.01266662f, 
    -0.06377456f, -0.00407914f, 0.03754247f, 0.08212630f, 0.02716857f, -0.01034393f, 0.01561817f, -0.05034444f, 
    -0.02942275f, -0.09885479f, 0.00119659f, 0.04040683f, -0.06930365f, 0.08144306f, -0.05599992f, -0.00222353f, 
    -0.43515012f, -0.17822486f, -0.34611988f, 0.12082133f, -0.12891561f, 0.05098395f, 0.08953767f, 0.04992560f, 
    -0.00837314f, 0.05888926f, -0.00156104f, -0.03975431f, 0.00913867f, 0.01840416f, -0.03226374f, -0.01700694f, 
    -0.01488292f, -0.00336293f, 0.14114794f, 0.10364325f, 0.04239820f, 0.21763125f, -0.00055051f, -0.08171829f, 
    -0.13627507f, -0.00356188f, -0.02531505f, 0.05998280f, -0.03646739f, 0.04593029f, -0.00864777f, 0.02435291f, 
    -0.04128280f, -0.07779810f, 0.01612521f, 0.02736861f, -0.06889030f, 0.04435641f, -0.00335837f, -0.15457422f, 
    -0.92858851f, 0.25075343f, -0.61703706f, -0.42812449f, -0.03158972f, 0.01055628f, -0.03382779f, 0.03013702f, 
    -0.10031436f, 0.14886776f, -0.00452620f, -0.05757158f, -0.05176920f, 0.07114612f, -0.04460729f, 0.14355712f, 
    0.04063405f, -0.03329455f, 0.01804298f, -0.02936979f, -0.21574666f, 0.11623303f, 0.08673284f, 0.26682723f, 
    -0.32767281f, 0.12335254f, -0.16697378f, -0.09745916f, 0.02149159f, 0.09999153f, 0.01545402f, 0.02606028f, 
    0.08502496f, 0.04253290f, 0.02108290f, 0.00532462f, 0.04461101f, 0.02512228f, 0.18204322f, 0.15827727f, 
    -0.05033577f, -0.20046768f, -0.01335062f, -0.52971345f, -0.03014204f, -0.01300936f, -0.11710166f, 0.11829779f, 
    0.09501950f, 0.01166559f, -0.00904514f, 0.05219825f, 0.00941075f, -0.07396188f, 0.05425647f, 0.14457947f, 
    0.08034796f, 0.02852901f, -0.03038485f, 0.10675691f, -0.26074946f, -0.05612941f, -0.24285060f, -0.13114731f, 
    0.08929488f, 0.01565830f, 0.10162877f, 0.17786008f, 0.03390269f, -0.03720806f, 0.05823760f, 0.03393793f, 
    0.00683196f, -0.02326219f, 0.00483887f, 0.00980590f, 0.03128409f, 0.02290110f, 0.04879307f, 0.02097628f, 
    0.02141264f, 0.02213555f, 0.21622479f, 0.24740207f, -0.25871289f, 0.04031028f, -0.08761775f, -0.33787614f, 
    -0.13076618f, -0.10205364f, 0.03051915f, -0.02722223f, 0.06840111f, 0.06945487f, 0.03378880f, -0.02529252f, 
    -0.03111480f, 0.01748324f, -0.02170896f, -0.00827923f, -0.17379041f, -0.11311217f, -0.13925821f, 0.08276901f, 
    -0.02461866f, -0.00819455f, 0.08961507f, 0.07965825f, -0.07077391f, -0.02349333f, -0.05442647f, -0.01843164f, 
    -0.03407630f, -0.10959920f, -0.02026517f, -0.02778663f, 0.05496351f, -0.00988885f, -0.01578720f, -0.02650647f, 
    0.13965514f, -0.38622630f, -0.25408393f, -0.02800402f, 0.18619786f, -0.00932779f, -0.01317368f, 0.09484544f, 
    0.08466215f, 0.12961580f, -0.01620741f, 0.03641522f, 0.03774243f, -0.02403408f, 0.00233041f, 0.02350624f, 
    0.10538816f, 0.10415718f, 0.04457830f, 0.14649692f, -0.27286744f, 0.05089036f, -0.33255294f, -0.16395289f, 
    0.04784836f, 0.14345330f, 0.09992873f, 0.15251559f, 0.10349701f, 0.02543220f, 0.13107568f, -0.05474688f, 
    -0.02023993f, 0.01404435f, -0.00954147f, 0.09625390f, 0.03420161f, -0.07130977f, -0.00958243f, -0.02780899f, 
    -0.07512335f, -0.32843417f, -0.09852171f, 0.11285138f, -0.32519811f, -0.12655897f, 0.07992086f, -0.02045745f, 
    0.03592400f, 0.08250961f, 0.10036585f, 0.00685949f, 0.06247094f, 0.01786228f, 0.03399287f, -0.06381678f, 
    0.09874484f, -0.08013185f, 0.12985346f, 0.04097658f, -0.20315412f, 0.09369221f, 0.53325403f, -0.35378063f, 
    -0.29174900f, 0.00524300f, -0.22665109f, -0.03154913f, 0.06406879f, 0.16210629f, -0.13403843f, -0.02196429f, 
    -0.00243156f, -0.12313946f, -0.09694529f, 0.04877612f, 0.14119056f, -0.15206861f, -0.11679677f, -0.13617994f, 
    -0.27588663f, 0.15538973f, 0.02708632f, 0.38116324f, 0.14399299f, 0.04499064f, -0.02656276f, -0.05819038f, 
    -0.22529894f, -0.07223288f, 0.13680641f, -0.09685435f, 0.03348155f, -0.11124596f, -0.09503701f, 0.06711073f, 
    0.04520687f, -0.00476770f, 0.01393202f, 0.08415271f, -0.10406399f, 0.19853768f, 0.27261591f, -0.13656141f, 
    -0.03540201f, 0.11327215f, -0.05571380f, -0.01151106f, -0.00774232f, -0.02677524f, 0.00542134f, -0.02783616f, 
    0.06361135f, 0.01999466f, 0.06123510f, 0.01121356f, -0.01990006f, -0.11164431f, 0.02045583f, -0.03460401f, 
    -0.20675755f, 0.10628732f, 0.01881274f, 0.08253688f, -0.06471078f, 0.11219137f, -0.19250837f, -0.01900885f, 
    -0.12830700f, -0.33441076f, -0.02403183f, 0.06613696f, 0.00524541f, 0.01397259f, 0.01678391f, -0.02904711f, 
    -0.11883079f, -0.02933563f, -0.02620121f, 0.04747578f, -0.24557789f, -0.02204899f, -0.48235244f, -0.09453391f, 
    -0.12569417f, 0.14204752f, -0.20472799f, 0.13908111f, -0.04711177f, -0.09553219f, 0.02797638f, 0.01093775f, 
    -0.05781934f, 0.06333821f, 0.03498458f, -0.08539747f, 0.07665888f, 0.01445337f, 0.02925899f, 0.07552588f, 
    -0.22155708f, 0.05327358f, 0.09772832f, 0.27869025f, 0.12764442f, -0.09389335f, 0.08516043f, -0.15445167f, 
    0.10310762f, -0.04157617f, 0.03354971f, 0.02035104f, 0.01338903f, -0.00613463f, -0.05733451f, 0.06129508f, 
    0.02949497f, 0.01223025f, -0.15176895f, -0.07564370f, 0.09380268f, -0.11904180f, 0.06074200f, 0.10236061f, 
    -0.16443841f, -0.13028336f, 0.00044560f, 0.23163931f, 0.07583427f, 0.15633550f, -0.04769501f, 0.00177646f, 
    -0.01819246f, -0.00636627f, -0.01394653f, 0.02465003f, -0.01908892f, 0.03475047f, 0.07375196f, -0.22555369f, 
    -0.14060341f, 0.05340836f, 0.24893832f, -0.11842967f, -0.04678499f, -0.11155116f, -0.09789837f, 0.05750029f, 
    0.07187616f, 0.20451309f, -0.08925056f, 0.02547433f, 0.04632916f, -0.02921612f, -0.05198114f, 0.00368821f, 
    0.02661211f, 0.00947554f, -0.08385095f, -0.03662573f, 0.20431133f, 0.05079753f, 0.31186575f, 0.39588612f, 
    -0.44077694f, 0.09384679f, -0.10726312f, -0.22953957f, 0.08335282f, -0.19309600f, -0.00176264f, 0.06080415f, 
    0.03257395f, 0.09275513f, -0.00125205f, 0.08367477f, 0.02820385f, -0.01081076f, 0.03899683f, 0.07894076f, 
    0.12245857f, 0.13177490f, 0.08616989f, -0.05583263f, -0.11813495f, 0.10345551f, 0.01908679f, 0.12115260f, 
    -0.02460449f, 0.00660305f, 0.03224233f, -0.10869063f, -0.04414432f, -0.09650750f, -0.07972750f, 0.01962706f, 
    -0.04066686f, -0.10628141f, -0.14372796f, -0.05998252f, -0.03775319f, -0.33369634f, -0.47327393f, -0.21606247f, 
    0.11458255f, 0.05902819f, -0.15447648f, 0.12387837f, 0.00847062f, 0.01786145f, -0.04791093f, 0.04327517f, 
    -0.04163996f, -0.00758352f, 0.04625829f, 0.06078219f, 0.08057559f, 0.04075316f, -0.03185752f, 0.18323728f, 
    -0.04843444f, 0.02567686f, 0.18538553f, 0.03204021f, -0.10724873f, -0.09422357f, -0.06405879f, 0.09982341f, 
    0.01038819f, 0.09433065f, -0.07891965f, 0.01954623f, -0.00814340f, -0.02323359f, -0.02070889f, 0.02324443f, 
    0.00329517f, 0.05613381f, -0.07245877f, -0.13369435f, -0.13082740f, -0.25773859f, 0.09603956f, 0.15028012f, 
    -0.29232207f, 0.11946097f, -0.40383095f, 0.14117163f, 0.04302033f, 0.22786529f, 0.02895529f, 0.03040181f, 
    0.03197089f, -0.00840594f, -0.04140851f, -0.01416090f, 0.02019485f, 0.05029719f, 0.06098242f, -0.00874618f, 
    0.03406000f, -0.00958319f, -0.01799945f, 0.01742439f, -0.04974580f, -0.18182927f, 0.01399235f, -0.03464149f, 
    -0.05027259f, 0.03605398f, 0.00841374f, -0.04814795f, 0.00846151f, -0.01237413f, 0.04399822f, 0.01085881f, 
    -0.02161027f, -0.02301135f, -0.03644567f, -0.11650271f, -0.05221377f, -0.01225641f, -0.04083270f, 0.12820047f, 
    -0.27981517f, -0.05722367f, 0.03158071f, -0.04434417f, 0.03997088f, 0.08016872f, 0.07339601f, -0.00558988f, 
    0.04971972f, -0.00324503f, 0.03226222f, -0.02104963f, 0.05979886f, 0.06027001f, 0.08889627f, 0.06765232f, 
    -0.12745884f, -0.09264455f, 0.01741834f, 0.03254922f, 0.02868432f, -0.06170636f, 0.08204927f, -0.09607089f, 
    -0.03276646f, -0.02255972f, -0.00215657f, -0.03110404f, 0.04598982f, -0.00966452f, 0.02972769f, 0.07103538f, 
    0.01713729f, 0.00330164f, 0.00398667f, -0.06013702f, 0.05745732f, -0.37541106f, -0.06946193f, -0.20152216f, 
    0.14269240f, -0.15682374f, 0.09769596f, 0.11564328f, 0.01733785f, 0.04816983f, 0.00049364f, 0.06528652f, 
    0.01302751f, -0.11877213f, -0.04556586f, 0.05013924f, 0.10028439f, -0.07113378f, -0.05438001f, -0.05587728f, 
    0.05249919f, 0.14083143f, 0.24564563f, -0.12623589f, -0.21752937f, 0.10318573f, -0.31877545f, 0.13732895f, 
    0.05518130f, 0.03933037f, -0.05572950f, 0.01986608f, 0.00461656f, -0.02931668f, -0.00960439f, 0.00485314f, 
    0.04240455f, -0.02637460f, -0.01168117f, -0.13657917f, -0.20818897f, -0.11632980f, 0.02939515f, -0.00759065f, 
    -0.17970087f, -0.15963231f, 0.03881601f, -0.02785371f, 0.06390962f, 0.13833618f, 0.02537361f, -0.00019694f, 
    -0.02031997f, -0.01497104f, 0.00065428f, -0.06023426f, -0.01035888f, 0.10107144f, 0.02926971f, -0.08219226f, 
    -0.21752369f, 0.06366100f, 0.00070615f, -0.07863236f, -0.09878331f, 0.00869640f, -0.08992086f, 0.02656781f, 
    -0.04777464f, -0.01101201f, 0.02256108f, 0.03114748f, -0.03070762f, 0.00200637f, 0.01185173f, 0.02101152f, 
    0.09094903f, -0.06838600f, 0.01471058f, 0.08908656f, 0.08725336f, 0.02165250f, 0.09301980f, 0.14905757f, 
    0.05557980f, -0.03187203f, -0.05688739f, 0.01230765f, 0.02068207f, -0.03302503f, 0.11181174f, 0.07931238f, 
    0.05847937f, -0.01888129f, -0.06980485f, 0.13964738f, 0.07348081f, 0.01342239f, -0.04617761f, -0.00318313f, 
    -0.05268573f, -0.03025656f, 0.23106521f, 0.16991191f, -0.37475607f, 0.15572634f, -0.03331929f, -0.05331074f, 
    -0.03128473f, 0.09735735f, 0.10120641f, -0.00949933f, 0.01570811f, 0.02280395f, 0.04913302f, -0.02152805f, 
    0.05656849f, 0.01479105f, 0.04501263f, 0.11360148f, -0.04838407f, -0.01888993f, -0.04848740f, -0.33779013f, 
    0.06575683f, 0.04294553f, 0.00353714f, 0.05618908f, 0.02815607f, 0.12368584f, 0.01198998f, -0.00862554f, 
    -0.10876501f, 0.03733926f, 0.03695255f, -0.03327741f, 0.07649086f, 0.00836396f, -0.04679045f, 0.03173982f, 
    -0.31922442f, -0.51522160f, 0.15463646f, -0.61257249f, -0.12334310f, -0.06049275f, -0.13093607f, -0.03391131f, 
    0.05870791f, 0.17606246f, -0.00000209f, 0.03306677f, 0.00296085f, -0.02511992f, -0.03310087f, 0.00771518f, 
    0.02919388f, 0.01010072f, -0.06233077f, 0.02884780f, 0.11294466f, 0.08300222f, 0.29975340f, 0.19218422f, 
    -0.10683834f, 0.08354603f, -0.05225753f, -0.17604253f, -0.14091833f, -0.13835658f, 0.05874108f, 0.02496880f, 
    0.15088582f, 0.07840458f, 0.06878236f, 0.03694962f, -0.06786205f, -0.10253472f, -0.02911154f, -0.06548204f, 
    -0.13226058f, 0.01469983f, -0.01254886f, 0.02991370f, 0.12885091f, 0.04437267f, 0.09552898f, -0.04814349f, 
    0.03333578f, -0.15378685f, 0.09989186f, 0.07590232f, -0.01192466f, 0.02073692f, -0.06659347f, 0.13339932f, 
    -0.07152580f, -0.04982759f, -0.04076546f, -0.04008304f, 0.05786429f, -0.22869416f, -0.00668125f, -0.64528805f, 
    -0.44568402f, -0.20379290f, -0.18791440f, -0.12772545f, 0.09623539f, 0.08102704f, -0.10261281f, 0.05756200f, 
    -0.01717058f, 0.07450733f, -0.04693552f, 0.02800841f, 0.09236329f, 0.08125613f, -0.00329497f, 0.04107519f, 
    0.29410461f, 0.01902019f, 0.27162063f, -0.08503251f, -0.19637786f, 0.06229308f, -0.06804190f, -0.29372808f, 
    -0.15620565f, -0.16053517f, -0.05866197f, -0.03218994f, 0.08866183f, 0.04818365f, 0.04417844f, 0.02441991f, 
    -0.09808519f, 0.01136362f, -0.04706833f, -0.00425122f, 0.09446438f, -0.02915978f, 0.23966275f, -0.14208230f, 
    0.01761803f, -0.03195539f, -0.01123679f, -0.03286494f, 0.06817983f, 0.11020715f, 0.00256581f, 0.03505291f, 
    0.01951941f, 0.04189216f, -0.01572818f, 0.00307605f, 0.03816302f, -0.01028484f, -0.09350955f, 0.02703568f, 
    -0.03965402f, -0.12684548f, -0.00869832f, -0.21357411f, 0.19811566f, -0.19779500f, 0.19962148f, -0.02645157f, 
    -0.21612982f, -0.02542476f, 0.08478923f, 0.05839830f, 0.01202486f, -0.01852013f, 0.02246233f, 0.16651706f, 
    0.18693577f, -0.02726231f, 0.00632932f, 0.08722417f, 0.07047477f, -0.02012873f, 0.13096400f, 0.02960094f, 
    -0.03312055f, 0.05032274f, 0.12605648f, 0.07818308f, -0.03849720f, -0.02006089f, 0.03806584f, 0.03614075f, 
    0.00737963f, 0.02171550f, 0.04322106f, 0.07833625f, -0.03408950f, -0.07528558f, -0.09078257f, 0.03762110f, 
    -0.47162664f, 0.12850633f, -0.21604097f, 0.37831119f, 0.02115724f, -0.04123392f, 0.05953396f, -0.12704894f, 
    0.09997157f, -0.04829377f, 0.02944090f, -0.06644480f, -0.02851041f, -0.05015251f, 0.03022621f, 0.04623618f, 
    -0.00625047f, 0.00158768f, -0.01901311f, -0.00113407f, -0.22105271f, 0.07828384f, 0.00106394f, -0.07936043f, 
    0.07369990f, -0.02808460f, -0.10146815f, 0.02205090f, 0.03152197f, -0.05491113f, 0.12690137f, 0.03745542f, 
    0.03801773f, 0.13557719f, -0.11062788f, 0.12368595f, -0.04019238f, -0.02904918f, 0.03862219f, 0.06332193f, 
    -0.34665248f, -0.37076297f, 0.08815705f, 0.00728606f, 0.09240686f, 0.01720555f, -0.02888899f, 0.08519379f, 
    -0.02452871f, -0.10012800f, -0.07834730f, 0.00777159f, 0.05779679f, 0.02731331f, 0.02040221f, 0.01925990f, 
    0.04170782f, 0.04614718f, 0.07231830f, 0.03737387f, -0.20916274f, -0.22657362f, 0.16767146f, 0.20862512f, 
    0.19771142f, -0.05155946f, -0.11144867f, 0.02964657f, 0.18452621f, 0.10163901f, -0.06528111f, -0.11464828f, 
    0.06661986f, -0.04384249f, 0.14120241f, -0.13486773f, -0.04626489f, -0.06079237f, 0.11421862f, -0.01846839f, 
    0.18887435f, 0.08348415f, 0.21966299f, -0.03471946f, 0.06663369f, -0.02862954f, -0.05277086f, -0.16502482f, 
    0.03218811f, 0.09315911f, -0.04564560f, 0.07873561f, -0.03587066f, -0.06215949f, -0.10675432f, 0.05977713f, 
    0.02664905f, -0.00665897f, 0.05280420f, 0.03565577f, -0.02232957f, -0.12018034f, 0.10286078f, -0.01078501f, 
    -0.13717827f, -0.04526171f, -0.07491595f, 0.04686060f, -0.06148967f, -0.06483930f, 0.01846862f, 0.02045267f, 
    0.01956031f, 0.04326990f, 0.01879715f, -0.03514244f, 0.05407624f, 0.03173947f, -0.01250288f, 0.16270685f, 
    0.02813453f, 0.04735636f, -0.14433187f, -0.04402402f, 0.07149423f, 0.13290669f, -0.10257925f, 0.03308997f, 
    -0.04769168f, -0.00275401f, -0.01991279f, -0.00741957f, -0.01074211f, 0.02469325f, 0.06406508f, -0.01928994f, 
    -0.09103221f, -0.05606820f, -0.06234681f, 0.00546819f, -0.04643426f, 0.03435862f, -0.02342607f, -0.02220354f, 
    -0.06294072f, 0.03687792f, -0.02421021f, -0.04446993f, 0.02955874f, -0.02285240f, -0.01379996f, 0.06399376f, 
    -0.07150875f, -0.04614188f, -0.11458749f, 0.00314942f, -0.08380079f, -0.01457042f, -0.10908620f, -0.15738328f, 
    -0.03265855f, -0.12951997f, -0.24178480f, -0.00886161f, -0.00010283f, -0.00410210f, -0.13162394f, -0.00045419f, 
    -0.22725263f, -0.04362208f, 0.01792086f, 0.08772998f, -0.03211668f, 0.00697084f, -0.00956459f, 0.09617759f, 
    -0.19083963f, -0.19934645f, -0.13554445f, -0.03987122f, -0.30999082f, -0.32759684f, -0.16779099f, -0.10850401f, 
    -0.11174933f, -0.06936841f, -0.02351768f, 0.15498647f, 0.07501408f, 0.04320401f, -0.05048164f, 0.02429603f, 
    -0.03032043f, 0.05578226f, -0.08243598f, 0.07587043f, -0.02705203f, 0.11593324f, 0.15889303f, 0.17254043f, 
    0.17550048f, -0.29642388f, 0.26911238f, 0.09423979f, 0.03981632f, -0.12201691f, 0.05340044f, 0.07059745f, 
    0.00773972f, -0.13061258f, 0.01088535f, 0.01919329f, -0.15392156f, 0.06315511f, -0.03395788f, -0.08775738f, 
    0.04658614f, 0.09521271f, -0.32928371f, -0.24586605f, -0.40668923f, 0.22697459f, -0.51666868f, 0.17528051f, 
    0.08411519f, 0.02487642f, -0.03620228f, 0.15655495f, 0.00945671f, 0.16942820f, -0.19413957f, -0.00199732f, 
    -0.13014622f, -0.04338845f, 0.07180061f, -0.11514720f, 0.07457891f, -0.03158309f, 0.04150776f, 0.21199684f, 
    0.01859382f, 0.07564376f, -0.11905915f, 0.03680540f, 0.07310414f, 0.13038063f, 0.01126040f, 0.06526400f, 
    -0.04373831f, 0.02165482f, -0.12370618f, 0.02935801f, -0.12936677f, -0.07356693f, -0.15578860f, 0.04025370f, 
    0.00596789f, -0.05650597f, 0.02206601f, -0.06701178f, -0.12111928f, 0.13409938f, -0.08710137f, -0.05194936f, 
    0.15715875f, -0.07702812f, -0.07613607f, 0.05064271f, -0.06130921f, 0.07961870f, -0.12307176f, -0.02427786f, 
    -0.11436093f, 0.05255371f, 0.03205227f, 0.00886922f, -0.05987053f, 0.00000806f, -0.02137382f, 0.02291195f, 
    -0.11411924f, -0.04129981f, -0.11299790f, 0.20902209f, 0.15493642f, 0.02247933f, -0.02962511f, 0.10502169f, 
    -0.18972006f, 0.09900090f, -0.08272138f, -0.02420243f, -0.20472874f, 0.07975230f, 0.10685313f, -0.02330729f, 
    -0.10234240f, -0.07844913f, 0.04616470f, 0.08700556f, -0.44562992f, 0.23131579f, -0.04894924f, 0.35195348f, 
    0.24320835f, 0.05350256f, -0.08198057f, -0.00100263f, 0.07586295f, 0.09742866f, -0.09268223f, 0.04011583f, 
    0.09830725f, -0.04394495f, -0.06596958f, -0.09337104f, 0.05905556f, -0.24345754f, 0.02949276f, 0.11022885f, 
    0.23772350f, -0.02326843f, 0.15872976f, -0.02613307f, 0.17193323f, -0.22196914f, 0.16877082f, 0.12366352f, 
    0.14067909f, 0.02689862f, -0.05577090f, 0.10688555f, -0.01700152f, -0.08506218f, 0.05109470f, 0.02817867f, 
    -0.08435562f, -0.06507555f, -0.05915543f, -0.24387680f, -0.40563467f, -0.02573045f, 0.05629465f, 0.03319111f, 
    0.00624848f, 0.00568142f, 0.08765087f, -0.09899084f, 0.13456269f, 0.03839386f, -0.01225439f, -0.11276356f, 
    -0.00503162f, 0.03007351f, 0.00816142f, 0.02413134f, 0.12400336f, -0.08057490f, 0.09802186f, 0.17289725f, 
    -0.09413575f, 0.10162031f, 0.02264822f, 0.07292727f, -0.07315385f, 0.01510314f, -0.05860079f, -0.07056829f, 
    -0.02686884f, -0.00210055f, 0.00560520f, 0.01262245f, -0.02663657f, -0.05471570f, -0.02331319f, -0.07537334f, 
    -0.10594618f, -0.01236626f, -0.06004638f, -0.06652413f, -0.61188573f, -0.35068676f, 0.15910818f, -0.34377882f, 
    -0.04721589f, -0.07541203f, -0.05263666f, 0.18873216f, 0.14124155f, 0.08552030f, 0.02308653f, -0.08360736f, 
    -0.13137446f, 0.11461922f, -0.00748524f, 0.04646735f, -0.09504860f, 0.21340585f, 0.10365216f, 0.12325896f, 
    0.08919885f, -0.33249065f, 0.00071976f, -0.11268597f, -0.14279519f, -0.14712620f, -0.02353380f, 0.05861410f, 
    -0.06698903f, -0.05567205f, 0.14587720f, -0.03341092f, -0.11446036f, 0.02082822f, 0.11158177f, -0.01745651f, 
    -0.02665260f, 0.05321256f, -0.02112814f, 0.05004365f, -0.00153078f, 0.04247769f, -0.06368756f, 0.23675293f, 
    0.00858612f, -0.09134685f, -0.02209285f, -0.01000028f, 0.11285502f, 0.02591303f, -0.06046188f, -0.00025552f, 
    0.03969993f, 0.03350837f, 0.03442214f, 0.06191416f, 0.00960566f, -0.01507557f, 0.09595502f, 0.12586415f, 
    0.08970235f, -0.10739072f, 0.00524886f, -0.12231490f, 0.08187609f, 0.07565927f, 0.00872017f, -0.00470285f, 
    0.03702201f, -0.12320261f, 0.00626992f, 0.00035138f, 0.00655617f, 0.03196900f, -0.01830518f, 0.06113872f, 
    -0.16840024f, -0.04034535f, -0.19483848f, -0.19095978f, -0.01267844f, -0.07345437f, -0.13801247f, 0.22152369f, 
    0.02612303f, -0.09759756f, -0.07634334f, 0.20050935f, -0.02236516f, -0.03096344f, 0.01505593f, -0.03469837f, 
    0.02724888f, 0.09851687f, 0.06331525f, 0.06784914f, -0.01854796f, 0.03024681f, 0.02870910f, 0.13374256f, 
    -0.02475872f, -0.32524070f, 0.37170756f, 0.18472780f, 0.05972672f, -0.02670492f, 0.08989865f, 0.21223097f, 
    0.11134984f, -0.10098374f, 0.00467116f, 0.05135150f, 0.08004631f, -0.08155049f, -0.02009069f, -0.05739266f, 
    0.00039926f, 0.17389472f, 0.02211983f, -0.02584462f, -0.16129464f, -0.03139070f, -0.22963904f, -0.09879423f, 
    0.02771460f, 0.05276557f, -0.00111837f, -0.02728957f, -0.00669593f, 0.02215057f, -0.04492866f, 0.02674629f, 
    -0.02315739f, 0.04266264f, 0.00021022f, 0.07428534f, -0.09970071f, -0.07414980f, -0.09534827f, -0.15493752f, 
    -0.06579466f, 0.08175514f, 0.06097820f, 0.02564174f, -0.23324172f, 0.07506043f, 0.00907359f, 0.00634297f, 
    -0.07130123f, -0.02970349f, 0.03590066f, 0.10109234f, -0.01128432f, 0.07520688f, -0.04276988f, -0.07854086f, 
    -0.03570344f, 0.03308409f, -0.07614455f, -0.06130188f, -0.09531616f, -0.25315303f, -0.11902591f, 0.04649820f, 
    -0.15153138f, -0.15428047f, -0.09495753f, 0.03861931f, -0.05519109f, -0.08975144f, -0.12489854f, 0.03179531f, 
    -0.04158504f, 0.03315443f, -0.00628358f, 0.13348933f, 0.03812402f, 0.03740812f, -0.00643288f, 0.00655947f, 
    0.09557861f, -0.05132391f, 0.10888264f, -0.16336860f, -0.04258297f, 0.00886209f, 0.02724420f, -0.08020884f, 
    0.06690983f, 0.03746562f, -0.02221217f, 0.08361163f, -0.07697611f, -0.09129921f, -0.10767297f, 0.01632169f, 
    0.04091563f, -0.00644032f, 0.10492938f, 0.07220271f, 0.08743027f, -0.17720221f, 0.13749374f, 0.05004625f, 
    0.01990826f, -0.09265984f, -0.07596519f, 0.00215539f, -0.04202195f, 0.00440097f, -0.01477181f, 0.01047062f, 
    -0.19292429f, 0.09421726f, 0.05950458f, -0.08423001f, -0.05129649f, 0.07104798f, -0.01815325f, 0.10437859f, 
    -0.00658000f, -0.02819572f, -0.11382324f, 0.02592628f, -0.03565269f, 0.01964735f, -0.02656204f, 0.02964711f, 
    -0.22739828f, -0.03636054f, 0.06239355f, -0.00222916f, -0.02516816f, 0.00318482f, -0.04073307f, 0.01275981f, 
    -0.13240615f, -0.26584640f, -0.34014842f, -0.07026470f, -0.20797589f, -0.24785402f, 0.14815272f, -0.05519234f, 
    -0.06772546f, -0.05807318f, -0.10138966f, -0.02205474f, 0.03503101f, -0.09900342f, -0.17269278f, 0.01943673f, 
    0.04140293f, -0.07104786f, 0.02253807f, -0.00592679f, 0.03226292f, 0.05203823f, 0.00670731f, -0.09548356f, 
    -0.18767762f, 0.05863885f, -0.63838279f, 0.04512648f, 0.12744607f, 0.03450232f, -0.07691316f, 0.04109898f, 
    -0.16398475f, 0.02719703f, 0.00757341f, 0.08914944f, -0.03919424f, -0.02404417f, 0.04741776f, 0.00986581f, 
    -0.03134552f, -0.09644590f, -0.00487564f, -0.06528952f, 0.01224181f, -0.06242560f, 0.12460219f, 0.18859690f, 
    -0.06801483f, 0.01845197f, 0.02236014f, 0.00805462f, 0.04112727f, -0.08644624f, -0.07265154f, -0.07102288f, 
    0.09544576f, 0.03880530f, 0.09183715f, 0.07226181f, -0.07723693f, 0.10164911f, 0.01527059f, 0.12273688f, 
    0.43975490f, -0.26621047f, 0.19303317f, -0.04674347f, -0.07846676f, -0.00424705f, -0.06872541f, 0.07575269f, 
    0.07795370f, -0.00495957f, -0.01272531f, 0.08790118f, -0.09522530f, -0.04406072f, -0.11660825f, -0.04609504f, 
    -0.06737154f, 0.04505493f, -0.00653580f, -0.09515356f, -0.14952467f, -0.17016138f, 0.07680707f, 0.02463670f, 
    -0.10393956f, -0.03941522f, 0.11018142f, -0.04550976f, 0.01528207f, -0.01541996f, -0.06331559f, -0.12819572f, 
    0.01821325f, -0.00722715f, 0.03703373f, -0.02882696f, 0.09769469f, 0.07543356f, 0.07243168f, 0.09369551f, 
    -0.18358287f, -0.21273513f, 0.15454115f, -0.10912681f, -0.08995412f, 0.03263431f, -0.00229680f, -0.13176574f, 
    0.00283965f, -0.08209906f, -0.00616840f, -0.15163493f, 0.05258063f, 0.05043564f, 0.12746616f, 0.03142932f, 
    0.02199128f, 0.06336346f, 0.04800662f, -0.05672219f, -0.25840172f, -0.13142088f, 0.09902775f, 0.10287897f, 
    -0.02935677f, -0.12872252f, -0.08987390f, -0.15988304f, 0.14775133f, -0.10774386f, -0.12888782f, -0.05487763f, 
    0.01670717f, 0.00872983f, 0.01745674f, 0.19150071f, -0.13321532f, -0.01113888f, 0.15601251f, -0.13531528f, 
    0.20769544f, -0.29579076f, 0.17403619f, -0.14906393f, -0.13877472f, -0.02033966f, -0.09604528f, -0.05715596f, 
    0.01307236f, -0.00047967f, -0.15099108f, 0.12248959f, -0.00373014f, -0.00811817f, -0.05956458f, -0.05429523f, 
    -0.01473519f, 0.05312083f, -0.02699104f, -0.08420463f, -0.29976168f, 0.03876807f, -0.09460271f, -0.12069502f, 
    0.06360582f, 0.01584986f, 0.02038976f, -0.02561711f, -0.08320564f, 0.02667321f, -0.00805915f, 0.08334222f, 
    0.00126981f, 0.02565863f, -0.00670604f, 0.06531773f, 0.00575620f, -0.07769886f, 0.09723455f, 0.07038677f, 
    -0.13102700f, -0.02265282f, -0.03304787f, -0.13738614f, 0.03399511f, 0.02839307f, 0.02419297f, 0.08780849f, 
    0.01870301f, -0.10104395f, 0.02369064f, -0.05943113f, 0.04948963f, 0.03314579f, -0.05204624f, 0.02084483f, 
    0.01749129f, -0.01688676f, -0.03675305f, -0.00776051f, -0.09358078f, 0.24037193f, -0.03065813f, -0.00783757f, 
    0.01073979f, 0.06471440f, -0.09547671f, -0.10176632f, 0.00045371f, 0.00057913f, -0.07200384f, 0.06396186f, 
    -0.06053939f, -0.05368159f, -0.06141129f, -0.04898368f, -0.05513374f, -0.02104967f, -0.04489668f, -0.08726962f, 
    -0.48658469f, -0.13592564f, -0.11497641f, 0.01868282f, -0.05662025f, 0.02253759f, -0.00119130f, 0.09316687f, 
    0.18700860f, 0.04392957f, -0.15231825f, -0.01232723f, 0.00578395f, 0.01788704f, -0.04094484f, 0.10244861f, 
    -0.00300443f, -0.00481089f, 0.25845355f, 0.23248489f, -0.12815525f, -0.05237311f, -0.18369317f, 0.05149993f, 
    -0.07573409f, -0.05890401f, 0.08327067f, 0.01569023f, -0.14648360f, -0.10655157f, 0.05481507f, 0.09129281f, 
    -0.07647157f, 0.06688344f, 0.05299034f, 0.01856911f, -0.19986285f, -0.09862483f, -0.61929858f, -0.21036683f, 
    -0.25184467f, 0.00855042f, -0.04331571f, -0.02636737f, 0.07190105f, 0.02177949f, 0.03250075f, -0.05216881f, 
    -0.06428697f, -0.04806723f, 0.01472917f, -0.01664231f, -0.01080424f, 0.03244267f, -0.03121413f, 0.02355626f, 
    0.03267844f, -0.09522363f, 0.07333936f, 0.03940351f, -0.48995265f, -0.06990428f, -0.10338414f, -0.10175955f, 
    0.08117911f, -0.09339620f, -0.08823811f, -0.28241485f, 0.08449610f, 0.00647546f, -0.02157214f, 0.08521891f, 
    0.04096675f, 0.03343252f, 0.00689667f, 0.04301708f, 0.01147097f, -0.12970892f, 0.04325028f, -0.06439982f, 
    0.05324724f, 0.02837445f, 0.06881200f, 0.02417821f, 0.14106520f, 0.08365986f, 0.06899930f, 0.11937046f, 
    -0.00895947f, 0.05543196f, -0.12975645f, 0.02238623f, 0.05406037f, -0.00032493f, -0.01096925f, 0.11152650f, 
    0.09487882f, -0.10601898f, 0.11972518f, 0.10857647f, -0.14003739f, 0.08582497f, -0.35588360f, 0.04216095f, 
    0.06356531f, -0.00542048f, -0.02964187f, 0.02289117f, -0.04175439f, 0.02993682f, -0.03882486f, 0.03357491f, 
    0.03144648f, -0.02387787f, 0.04899440f, 0.04131384f, 0.01179224f, -0.09885813f, -0.03303496f, -0.07126926f, 
    0.06711436f, 0.12027065f, 0.00059020f, -0.08415785f, 0.11750879f, -0.00729348f, -0.01560022f, 0.07785565f, 
    -0.00506464f, -0.01662564f, -0.12031489f, 0.08783955f, -0.02721423f, -0.00351723f, 0.09113317f, 0.00591981f, 
    0.09153853f, -0.01968028f, 0.02931346f, 0.07945207f, 0.12726234f, -0.02502763f, 0.24064182f, 0.30271387f, 
    -0.05264292f, -0.04181568f, -0.14668719f, -0.02395231f, -0.05971954f, 0.03545365f, -0.05047061f, 0.03569566f, 
    -0.14687568f, 0.05230788f, 0.04128512f, -0.02195893f, 0.00154616f, 0.05741902f, -0.16321494f, 0.09366928f, 
    -0.44111750f, -0.01647665f, -0.12137289f, 0.16977133f, 0.02545557f, -0.01745814f, -0.02523308f, -0.23107420f, 
    0.20556735f, -0.11482608f, -0.07745092f, 0.06758973f, 0.06264815f, 0.08150708f, 0.03933819f, 0.03445429f, 
    0.01634024f, -0.13701208f, -0.01547641f, 0.03370864f, -0.19365786f, -0.05871309f, -0.06914753f, -0.05036029f, 
    0.14098026f, -0.03908245f, -0.03577964f, -0.01196293f, -0.05595212f, -0.00649627f, 0.03691673f, 0.05541489f, 
    -0.00273493f, -0.04290154f, 0.02919429f, 0.03174235f, -0.04450005f, -0.08542849f, -0.04294934f, -0.03859542f, 
    0.09963456f, -0.02902893f, 0.02776537f, 0.10572436f, -0.08453681f, 0.01494326f, 0.07539552f, 0.18334509f, 
    -0.04519559f, -0.03534364f, 0.04369622f, 0.03117472f, 0.04193345f, 0.05225499f, 0.00134505f, -0.05348523f, 
    -0.05675665f, 0.10638096f, -0.05887421f, 0.08040673f, 0.05244354f, -0.25003001f, -0.14100608f, 0.07051516f, 
    -0.16448683f, 0.01794599f, -0.04310195f, 0.04354533f, -0.18203284f, -0.04503730f, -0.14268918f, 0.01441285f, 
    -0.14315239f, 0.10124070f, -0.04214562f, -0.01866541f, 0.03812970f, 0.08391852f, -0.02833428f, -0.01834395f, 
    -0.04358324f, 0.05332587f, -0.01778849f, 0.03165210f, 0.08263432f, -0.07042377f, -0.00691519f, -0.00209686f, 
    0.03343164f, 0.03483069f, -0.02026593f, 0.01470894f, -0.06500063f, -0.10610968f, -0.04407318f, 0.00475204f, 
    -0.00629423f, 0.01551520f, 0.00541892f, -0.00698943f, 0.04253556f, 0.05264702f, 0.24183278f, 0.09705497f, 
    -0.15966602f, 0.02175680f, 0.00745712f, 0.00659083f, -0.05939239f, -0.04105445f, -0.03996253f, -0.08260715f, 
    0.02542059f, 0.00326456f, -0.05960266f, -0.03781267f, 0.10137345f, 0.11163612f, 0.01417585f, -0.00809524f, 
    -0.19220687f, -0.05403002f, 0.13689300f, -0.13726938f, 0.06584144f, -0.11801523f, 0.01270453f, 0.08345139f, 
    0.16604108f, -0.16761962f, -0.04567283f, 0.00351566f, 0.13257375f, -0.02117744f, -0.08140907f, -0.01742037f, 
    0.04141247f, 0.02285735f, 0.06011738f, -0.02706810f, 0.18285279f, -0.15013382f, 0.10472497f, 0.11130844f, 
    0.00823879f, -0.02959553f, 0.04990688f, 0.08135778f, 0.03467413f, -0.01224907f, -0.08272535f, 0.05617629f, 
    -0.08220948f, -0.04841035f, -0.10718891f, 0.00307056f, -0.00319808f, 0.07427158f, 0.12636788f, 0.07082742f, 
    -0.04648456f, -0.20356822f, 0.13773993f, -0.14959614f, -0.15920597f, 0.01430867f, -0.09684424f, 0.05932477f, 
    0.07373498f, -0.06373291f, 0.03206442f, -0.04194493f, -0.04060237f, 0.02609570f, -0.02930916f, -0.03162918f, 
    0.01207843f, 0.03966469f, 0.05372761f, -0.01477972f, 0.10179548f, 0.10170498f, 0.22011127f, 0.16205899f, 
    -0.02208537f, 0.11386479f, -0.02183164f, 0.08391413f, 0.00653620f, -0.01202042f, 0.02696213f, 0.00297633f, 
    -0.06441335f, 0.00652396f, -0.11963280f, 0.02331037f, 0.03355050f, 0.16352321f, -0.11727956f, -0.09394093f, 
    -0.15157270f, 0.02591013f, -0.00977222f, 0.25523436f, 0.12958792f, 0.01835885f, 0.01669716f, -0.06667005f, 
    -0.08086760f, 0.05989118f, -0.16091879f, -0.09807096f, 0.01171117f, -0.03214835f, 0.04261192f, 0.06153341f, 
    0.01554815f, -0.11055860f, 0.10763515f, 0.16037928f, -0.03390899f, 0.11304753f, -0.04076942f, 0.09817713f, 
    0.00369251f, -0.05535538f, -0.01154963f, -0.05464816f, 0.08028556f, 0.05359218f, -0.08321717f, -0.05326931f, 
    -0.01040393f, 0.00678357f, 0.00578817f, -0.00105443f, 0.01982398f, 0.00102571f, 0.09314661f, 0.06349035f, 
    0.34992203f, -0.16661465f, 0.27327806f, 0.17432356f, -0.04519457f, 0.04122163f, 0.07372306f, 0.13761771f, 
    0.05005800f, -0.03408862f, -0.02075851f, 0.06085008f, 0.08743205f, 0.02423153f, -0.07944153f, -0.07907373f, 
    0.05460771f, -0.06615843f, 0.04593037f, -0.06778888f, -0.26226810f, -0.21026573f, -0.13955003f, -0.07105380f, 
    -0.11632986f, 0.01251363f, -0.04466140f, -0.03889640f, 0.05407332f, -0.00798286f, -0.11414436f, -0.03322127f, 
    0.03472888f, -0.00688028f, -0.02947935f, -0.06433019f, 0.10853815f, 0.03820894f, 0.12564039f, 0.13691249f, 
    0.26355630f, 0.02698052f, 0.19134429f, -0.02353588f, 0.10095509f, -0.04712764f, -0.01805427f, 0.01636936f, 
    0.00196926f, 0.01456473f, -0.04345693f, 0.06466590f, 0.00810372f, 0.01180359f, 0.00581607f, -0.03903576f, 
    0.05403395f, -0.00138659f, -0.00050312f, -0.05917912f, -0.15633906f, -0.21948847f, 0.07743570f, -0.21982189f, 
    -0.19048393f, 0.00359917f, -0.02556358f, -0.01576656f, -0.01675484f, 0.05160484f, -0.03122328f, -0.03526226f, 
    -0.09262578f, 0.00164488f, -0.09618554f, 0.04781198f, 0.05417378f, 0.07414968f, 0.06194939f, -0.08112415f, 
    0.46849042f, 0.14884034f, 0.33210817f, 0.07891858f, 0.02343874f, 0.02363295f, 0.04685559f, -0.03535008f, 
    -0.01511894f, -0.05170292f, -0.09124937f, 0.08365937f, -0.04059844f, 0.08812455f, 0.00462335f, -0.02443379f, 
    -0.13475627f, 0.02207695f, -0.11778253f, 0.09379110f, -0.28339139f, 0.04399904f, -0.04956213f, 0.22298042f, 
    -0.15283899f, 0.12089562f, -0.04559141f, 0.33609214f, -0.11973666f, -0.13119161f, 0.07249218f, -0.01117050f, 
    0.12977344f, -0.00215150f, 0.12558362f, 0.05928514f, -0.09658586f, 0.03304121f, 0.09308016f, -0.14290743f, 
    -0.16323623f, -0.24919841f, 0.11304732f, -0.06652242f, -0.13791563f, 0.05941917f, 0.05070959f, -0.12790762f, 
    -0.04184480f, 0.02882338f, -0.03362364f, -0.14197633f, 0.06011384f, -0.03691474f, -0.00229011f, -0.01248268f, 
    0.01697607f, -0.08080199f, -0.00657652f, -0.05196343f, -0.07306210f, 0.08921310f, -0.10308221f, 0.11802908f, 
    0.00340710f, -0.09673084f, 0.06740572f, 0.03370988f, -0.04697932f, 0.07702215f, -0.08685966f, 0.01367299f, 
    -0.01497685f, 0.03873163f, 0.02033390f, 0.03017731f, -0.07003462f, 0.04839105f, -0.09564010f, -0.10619489f, 
    -0.24104987f, -0.15671101f, -0.24357712f, 0.16996624f, -0.05369937f, -0.04113617f, 0.06169975f, 0.13867584f, 
    -0.21297489f, 0.04211433f, 0.03783286f, 0.03278325f, 0.15513062f, 0.13089348f, 0.11117112f, 0.03063918f, 
    0.04037660f, 0.07176863f, 0.04666365f, 0.00741869f, -0.17606796f, 0.06294074f, -0.19797553f, 0.00358673f, 
    -0.12086158f, 0.08578666f, 0.05693927f, 0.00685097f, -0.09180547f, -0.00476252f, -0.01494700f, -0.06483060f, 
    0.06152912f, 0.14151368f, 0.07363185f, -0.03528380f, -0.00894858f, 0.01821657f, -0.02048637f, 0.13333371f, 
    0.40978074f, 0.01987101f, 0.32673264f, 0.04648937f, -0.01872670f, -0.13540821f, -0.20836902f, -0.03030892f, 
    -0.19330217f, -0.19548215f, -0.01604675f, -0.02157773f, 0.06094996f, -0.01313924f, -0.02530826f, 0.06616627f, 
    -0.00962823f, -0.00429139f, 0.11087542f, 0.03797128f, 0.19504717f, 0.25377098f, 0.28496042f, 0.03264494f, 
    -0.20393838f, -0.04795769f, -0.04880789f, 0.04267142f, -0.08800506f, -0.04782930f, -0.10510283f, -0.01102410f, 
    0.04769880f, 0.02274089f, 0.00254369f, -0.00811521f, -0.08667839f, -0.05452470f, -0.07839685f, 0.03604412f, 
    0.08877404f, -0.09527925f, -0.45449492f, 0.27421108f, 0.33687812f, 0.02238883f, 0.10413595f, -0.03421650f, 
    -0.06419744f, -0.14920443f, -0.01813410f, 0.09405328f, -0.04993685f, -0.01750740f, -0.02867381f, -0.05776897f, 
    0.07445790f, 0.01742307f, 0.15679333f, 0.02503398f, -0.42092347f, 0.27496609f, -0.05642375f, 0.37892020f, 
    -0.32468596f, -0.00812808f, -0.19567479f, 0.30930734f, -0.11191863f, -0.01858909f, -0.10119887f, 0.00241820f, 
    -0.05510723f, 0.01559637f, -0.06228533f, -0.01859403f, -0.04068144f, 0.08264355f, 0.09410574f, -0.09250003f, 
    -0.46504518f, 0.20210998f, -0.17337126f, 0.16239852f, -0.24018401f, 0.05225451f, 0.01948634f, 0.04410710f, 
    -0.06175474f, 0.06064324f, -0.06281414f, -0.12648401f, 0.06158615f, 0.01916515f, 0.03931961f, 0.00786544f, 
    0.00769630f, -0.00970161f, -0.01460549f, 0.09770996f, 0.07374515f, -0.20807210f, -0.01771551f, 0.10226340f, 
    0.00882978f, -0.04763285f, -0.04163781f, -0.02744078f, -0.05422327f, 0.03575576f, 0.03105819f, -0.00371551f, 
    0.08785965f, 0.03005523f, -0.09718170f, 0.01714530f, 0.02809695f, 0.08175300f, 0.05159981f, -0.06376984f, 
    -0.00616845f, -0.02690746f, 0.14598325f, 0.10481899f, -0.10401156f, -0.00274761f, -0.10725269f, 0.15698247f, 
    -0.12671031f, 0.02301424f, 0.02999294f, 0.04500347f, 0.01104918f, 0.02047230f, 0.01998880f, 0.00830238f, 
    0.00739170f, 0.04543464f, 0.09314945f, -0.02091094f, -0.44706583f, -0.30655232f, 0.00809054f, 0.43081731f, 
    -0.29802606f, 0.06047461f, -0.04458833f, -0.07126224f, 0.08569203f, 0.03333052f, -0.15035920f, 0.04100918f, 
    -0.18789141f, 0.02562958f, -0.05319880f, 0.09350786f, 0.03586273f, 0.24372956f, 0.12594576f, -0.13799968f, 
    -0.24525677f, -0.48905754f, 0.18500549f, -0.49337709f, 0.21722381f, 0.04806069f, 0.00402695f, 0.01109568f, 
    0.16492346f, 0.00712794f, -0.08976359f, 0.07441914f, -0.00703077f, 0.18880749f, 0.02294440f, 0.09911355f, 
    0.14277871f, 0.05017669f, -0.15735675f, 0.06597871f, -0.14249639f, -0.13527760f, -0.02453171f, 0.08056608f, 
    0.03360559f, 0.04562698f, -0.04389677f, -0.00670077f, -0.08831105f, -0.08306196f, 0.00452674f, 0.03953836f, 
    -0.03918373f, -0.05100626f, 0.02225554f, -0.02653430f, -0.10837528f, 0.01825172f, -0.11614007f, -0.14227304f, 
    -0.44450596f, 0.07195717f, -0.15491754f, 0.09535000f, -0.27706292f, 0.01516364f, 0.06935898f, -0.05407934f, 
    0.08196660f, -0.00678210f, -0.15910821f, -0.04065633f, 0.11005363f, 0.10405512f, -0.09913650f, -0.00321854f, 
    -0.00070439f, -0.00080227f, -0.02918616f, 0.14867632f, -0.03395880f, 0.25550115f, 0.25021586f, -0.03994501f, 
    0.07828209f, 0.06587433f, -0.04699413f, 0.20723191f, -0.01519289f, -0.03020382f, -0.05228192f, -0.00405023f, 
    -0.00295770f, 0.03164243f, 0.00613959f, 0.18045834f, -0.05290064f, -0.06988473f, -0.16131134f, -0.02055005f, 
    -0.09055775f, -0.01343157f, 0.01145041f, -0.10273940f, 0.02192686f, -0.04267132f, 0.04768451f, 0.01819821f, 
    0.08873356f, 0.05939616f, -0.00352125f, 0.09700529f, 0.02998666f, -0.00406181f, 0.04959702f, 0.06417748f, 
    0.01803354f, 0.01704759f, -0.06697793f, -0.02898528f, -0.00048515f, 0.03415714f, 0.15525696f, 0.10318396f, 
    -0.17026028f, -0.10406647f, -0.00087983f, 0.00568224f, -0.03702808f, 0.03884841f, -0.02219850f, -0.04909911f, 
    0.05172226f, -0.00747656f, -0.04099913f, -0.02779590f, -0.03782816f, 0.06727207f, 0.00540809f, -0.11181099f, 
    -0.07999975f, -0.13163179f, -0.05258706f, -0.13410741f, 0.07221244f, -0.09487058f, 0.01700336f, 0.20092553f, 
    0.00072114f, 0.03393187f, 0.04769525f, 0.07462949f, 0.00785267f, -0.07905409f, 0.09476414f, 0.02999847f, 
    0.11160449f, 0.09571364f, -0.00700071f, -0.00979268f, 0.12189104f, -0.20048183f, 0.20210761f, 0.07663742f, 
    0.02417212f, -0.14495888f, -0.01838437f, -0.06380717f, 0.08858664f, -0.06437623f, 0.01533075f, -0.03505960f, 
    0.00622672f, 0.04090760f, -0.00823883f, -0.14061686f, 0.03019246f, 0.12464304f, 0.07567517f, -0.07851023f, 
    0.37022626f, -0.16634752f, -0.18022868f, 0.13351642f, 0.28328460f, 0.03147195f, 0.06824455f, -0.06437073f, 
    -0.07447488f, 0.10422742f, 0.01818432f, 0.16264266f, 0.00987991f, 0.07605864f, -0.06226594f, 0.01019106f, 
    0.04972798f, -0.02499656f, -0.05390168f, 0.17996241f, 0.09752136f, -0.28899944f, -0.20951350f, -0.07654282f, 
    0.10545007f, -0.08209710f, -0.06822615f, 0.05804962f, -0.03227318f, -0.03822071f, 0.00538300f, -0.00349698f, 
    0.06677137f, -0.00915278f, 0.00642319f, 0.01126536f, -0.00278956f, -0.02184125f, 0.06339907f, -0.04759289f, 
    0.08328195f, -0.13104860f, -0.28397402f, 0.36718512f, 0.15338427f, -0.05797583f, 0.11196498f, -0.04970279f, 
    0.16254017f, -0.01170819f, -0.24064025f, -0.05101357f, 0.04234350f, 0.06292349f, 0.04294334f, 0.06130651f, 
    0.02434918f, 0.09198692f, 0.02681613f, -0.04750628f, 0.25661114f, 0.04833755f, 0.20433879f, -0.02877505f, 
    -0.08436767f, -0.01810973f, 0.04488026f, -0.12586577f, 0.02592687f, -0.02644694f, -0.07838672f, -0.07335362f, 
    -0.05272878f, -0.10965659f, -0.02616542f, 0.03168897f, 0.05780695f, -0.03076541f, 0.00441875f, 0.02016926f, 
    -0.13509454f, -0.15876389f, -0.01334294f, 0.02214697f, -0.12257940f, 0.03946794f, -0.03729427f, -0.04676522f, 
    -0.09381057f, 0.01168384f, -0.01573353f, -0.01315162f, -0.03863602f, -0.15995277f, -0.05585804f, -0.02888324f, 
    -0.08255747f, -0.09142486f, -0.08230943f, -0.03057456f, -0.02679923f, -0.02436505f, 0.04432717f, -0.12263408f, 
    0.00413369f, 0.06488742f, 0.09674037f, 0.04125575f, 0.07946636f, 0.02803407f, 0.02070423f, 0.02347212f, 
    0.03305981f, -0.02263957f, -0.00112607f, 0.02154052f, 0.06915747f, -0.07975397f, 0.00973812f, -0.06580204f, 
    -0.10275789f, -0.13360462f, 0.00782665f, 0.04945908f, 0.07197821f, 0.00966478f, -0.02626853f, -0.00070973f, 
    0.01039659f, 0.03144529f, 0.00322527f, 0.03228283f, 0.05482643f, -0.03046660f, 0.05175894f, 0.09361184f, 
    0.02414742f, 0.03515207f, 0.11314487f, -0.01639301f, 0.37669072f, 0.12133016f, 0.22795875f, 0.15042336f, 
    -0.04198044f, -0.06053158f, 0.06849930f, -0.14834028f, 0.11938228f, 0.02587203f, -0.16955641f, 0.08820678f, 
    0.00602800f, 0.00629507f, -0.05784217f, 0.01118159f, -0.00712047f, -0.00661298f, -0.05390613f, 0.07497995f, 
    -0.07417860f, -0.24103402f, -0.21743032f, 0.21876451f, -0.13967746f, -0.06661111f, -0.08312847f, 0.02941662f, 
    -0.11686236f, 0.01019058f, -0.02144432f, 0.00885928f, 0.09350827f, 0.00296236f, -0.03512707f, 0.03120581f, 
    -0.01588819f, 0.07174192f, -0.01387122f, 0.04430484f, 0.09800153f, -0.30868697f, -0.25817817f, 0.38533634f, 
    0.18841873f, -0.10234417f, 0.07445192f, 0.01223155f, 0.13911395f, -0.16736957f, -0.04741691f, -0.01355914f, 
    -0.04923808f, 0.03865853f, 0.14105473f, -0.14602242f, -0.11788639f, 0.10177434f, 0.02274468f, -0.03977718f, 
    -0.27648467f, -0.27601880f, -0.14347094f, -0.29372966f, 0.15201657f, 0.08497424f, 0.17193362f, -0.01799259f, 
    0.02858048f, 0.04297640f, -0.06392574f, 0.07561950f, 0.03905272f, 0.07324838f, 0.11487986f, -0.04686620f, 
    0.05602382f, 0.00632522f, 0.06039924f, 0.01241059f, 0.10816737f, -0.02495467f, -0.06099204f, 0.10841116f, 
    0.11064197f, -0.03679946f, 0.11965626f, -0.04108359f, 0.00746682f, -0.07608692f, -0.06074091f, 0.07920960f, 
    0.09940156f, -0.02566448f, 0.14283900f, -0.03204961f, -0.10574468f, -0.00291747f, -0.07827152f, -0.01502140f, 
    0.21527138f, -0.01664531f, 0.19715507f, -0.11132102f, 0.07321379f, 0.07063811f, 0.21295330f, -0.06895169f, 
    0.08971581f, -0.14591993f, 0.01654090f, -0.04359277f, 0.08394969f, -0.00316893f, 0.11278980f, 0.04026239f, 
    0.04440239f, 0.00136763f, -0.14156751f, 0.00883336f, 0.40216094f, -0.12672685f, 0.23995818f, -0.13399193f, 
    -0.00427185f, -0.01335767f, 0.09308099f, -0.12223222f, 0.08151657f, -0.15034683f, -0.07493831f, -0.00326380f, 
    -0.06535675f, -0.04901239f, -0.03301270f, 0.12624046f, 0.09587099f, -0.00559214f, 0.01853137f, -0.11884411f, 
    -0.20212692f, 0.00356158f, -0.16677366f, -0.03140207f, 0.10298833f, 0.10272358f, 0.05037344f, 0.05300697f, 
    -0.05051048f, 0.03104244f, 0.04465615f, 0.01669068f, -0.03855154f, 0.00069734f, 0.07278758f, -0.00498869f, 
    -0.08452687f, -0.05933085f, 0.04469247f, -0.06180929f, -0.00221481f, -0.22886755f, -0.08284877f, -0.00287873f, 
    -0.05300639f, -0.03166728f, -0.22933640f, 0.00608817f, -0.19957194f, -0.04760533f, 0.04284118f, -0.00140619f, 
    -0.05354683f, -0.00858403f, -0.05954452f, 0.03421332f, -0.01526231f, 0.01282095f, -0.11202876f, -0.12322607f, 
    -0.17421843f, -0.08593247f, -0.07183685f, 0.07555836f, 0.06657118f, 0.01739294f, -0.17749581f, 0.03118936f, 
    -0.13192281f, -0.11080511f, 0.06236639f, 0.00779248f, -0.10135093f, 0.02177460f, -0.02446937f, 0.03313769f, 
    -0.06546552f, 0.05338961f, 0.01476011f, -0.04500699f, -0.79184765f, 0.01189181f, -0.43313038f, 0.13976116f, 
    -0.43666589f, 0.02949808f, 0.06116759f, -0.05401561f, 0.11334687f, 0.07052013f, -0.10451491f, -0.08758359f, 
    0.04181304f, 0.07257513f, -0.08805088f, -0.01168959f, 0.04478336f, -0.01713938f, -0.08101774f, 0.10938857f, 
    0.15128522f, 0.22573829f, 0.15216602f, 0.12562913f, -0.13522655f, -0.08977749f, -0.12639847f, 0.02025205f, 
    0.01501938f, -0.14793323f, -0.07426724f, 0.05049239f, -0.00985294f, 0.01647149f, 0.08533679f, 0.01561200f, 
    -0.15130135f, -0.01783638f, 0.02198463f, -0.12727103f, 0.08021012f, -0.35234070f, -0.10425659f, 0.22458887f, 
    0.17411020f, 0.01095720f, 0.15667604f, -0.11063833f, 0.07653645f, -0.21480764f, -0.08982363f, -0.02322100f, 
    -0.03550232f, -0.03641440f, 0.03175473f, 0.11676371f, -0.09305524f, 0.06473843f, 0.08540218f, 0.01585158f, 
    -0.00847790f, -0.13002054f, 0.08515292f, 0.01199807f, -0.06442365f, 0.03378420f, -0.10470296f, -0.01688706f, 
    -0.09653788f, -0.05381318f, 0.02979682f, 0.02522538f, -0.02529304f, 0.02127716f, -0.02022994f, 0.05820032f, 
    -0.06308681f, 0.01814666f, -0.07629856f, -0.07731882f, 0.00705252f, -0.34888318f, -0.15393075f, -0.25196058f, 
    -0.11292151f, -0.03182554f, -0.25396547f, -0.13775189f, -0.11037324f, -0.18515748f, -0.04087413f, 0.00263120f, 
    0.02688644f, -0.03579214f, -0.06857536f, 0.04142638f, 0.01550766f, 0.02140762f, 0.06737768f, -0.04988953f, 
    -0.02964051f, -0.14044446f, 0.00294147f, 0.14448042f, 0.07288243f, 0.00250474f, -0.10237999f, 0.00297505f, 
    -0.01636335f, 0.00069313f, 0.05779541f, -0.12315578f, -0.09530787f, -0.07823784f, -0.03866510f, -0.06404891f, 
    -0.06424856f, -0.08042907f, -0.06222879f, -0.13319160f, -0.03506705f, -0.20450602f, -0.09395852f, 0.05934213f, 
    -0.12982219f, -0.03409972f, -0.07449980f, 0.02994688f, -0.05483768f, -0.03651087f, -0.04769989f, 0.02083453f, 
    0.07419351f, 0.05677783f, -0.01515152f, 0.00275576f, -0.00835060f, 0.07267268f, -0.00069913f, 0.05824199f, 
    -0.15589097f, -0.05971724f, -0.25319415f, 0.25314480f, 0.03916452f, 0.07030337f, -0.12266703f, 0.03250857f, 
    -0.13256156f, 0.01897770f, -0.01988222f, 0.02095562f, -0.08545629f, 0.00000590f, -0.12015129f, 0.02174389f, 
    -0.11032172f, -0.04655696f, -0.01499394f, -0.01850488f, -0.15041299f, 0.10437552f, -0.11204334f, 0.25654146f, 
    -0.04515548f, -0.10839921f, 0.07797442f, -0.03999389f, -0.04865704f, 0.06227614f, 0.04302577f, -0.13682574f, 
    0.06815814f, -0.06094950f, 0.00309035f, 0.16296116f, -0.03162427f, 0.04419673f, 0.07093225f, -0.02670044f, 
    -0.15572520f, -0.37050375f, 0.02086466f, -0.25820526f, -0.04054740f, -0.20281143f, -0.30766174f, -0.00719892f, 
    0.04261930f, -0.28855088f, -0.00963298f, -0.04028628f, 0.01514595f, -0.02968020f, 0.03199796f, -0.00541777f, 
    -0.00246176f, 0.05738690f, 0.24123912f, -0.04172622f, 0.03034852f, -0.05596014f, -0.06493107f, -0.16421562f, 
    -0.11218905f, 0.03692909f, -0.17752852f, -0.06166205f, -0.09924351f, 0.01737883f, 0.03688286f, -0.00331834f, 
    0.03334855f, -0.06009502f, -0.07291818f, 0.05194463f, -0.01716116f, 0.00483757f, -0.01532717f, -0.00207027f, 
    0.10800833f, -0.22397594f, 0.06069143f, 0.14386575f, 0.08902888f, 0.07546142f, 0.10702381f, -0.10015135f, 
    0.22391917f, -0.00408756f, -0.09658039f, 0.01821324f, -0.01504502f, 0.07398096f, 0.04451536f, -0.04964186f, 
    -0.01573074f, 0.04845104f, 0.08813419f, -0.03509140f, -0.33993420f, -0.12126520f, -0.10827804f, -0.06239922f, 
    -0.05353246f, 0.04717887f, 0.06266567f, -0.00941515f, 0.05441259f, -0.01371957f, -0.12585902f, 0.06091642f, 
    0.11099710f, 0.02227710f, -0.01234886f, 0.07378691f, -0.03458158f, 0.01033223f, -0.04001313f, -0.09544717f, 
    0.03967097f, -0.10811299f, 0.09725500f, -0.13548554f, -0.08156940f, 0.02041772f, -0.09253889f, -0.06886512f, 
    -0.06376661f, 0.05874685f, -0.02616587f, 0.04022637f, 0.10447585f, 0.06869096f, -0.00003663f, 0.04838330f, 
    0.04974063f, 0.01522705f, 0.16596904f, 0.01095148f, 0.17714657f, 0.00570463f, -0.02888254f, 0.15816252f, 
    0.21232954f, -0.00065502f, 0.11462797f, -0.06757218f, 0.08818638f, 0.07865580f, -0.01420849f, 0.00748096f, 
    -0.07208604f, 0.04445497f, 0.05230859f, 0.11794948f, 0.01701026f, 0.02581433f, 0.02260120f, -0.04228707f, 
    -0.07583486f, 0.16596030f, -0.37759465f, 0.00170199f, -0.14864579f, -0.09431940f, -0.14900884f, -0.20672537f, 
    -0.28779835f, 0.01537664f, 0.05059637f, 0.10122240f, -0.08667201f, -0.01291084f, -0.01279417f, 0.06648809f, 
    -0.06094418f, 0.04614622f, -0.00894817f, -0.07052728f, -0.19313100f, -0.21491216f, -0.02755474f, 0.07079092f, 
    -0.06748510f, 0.04851460f, -0.06092171f, -0.04363739f, 0.00277590f, 0.07056328f, -0.10775080f, 0.01279125f, 
    -0.08734354f, -0.11434869f, -0.05527226f, -0.04507761f, -0.10671997f, -0.10469761f, 0.00533734f, -0.09112285f, 
    -0.08010738f, 0.04401193f, -0.06612589f, -0.03581847f, 0.02071887f, -0.01093989f, 0.07096344f, 0.05616881f, 
    0.03771468f, -0.01042357f, -0.01146127f, 0.04759885f, 0.04410582f, 0.02101933f, 0.04119444f, 0.05395078f, 
    -0.00125133f, -0.03019201f, -0.11708882f, -0.03253030f, -0.35875446f, 0.19910127f, -0.32142898f, 0.30702430f, 
    0.23516203f, -0.02618416f, 0.14022446f, -0.05703451f, -0.03463586f, -0.01940833f, 0.00332361f, -0.04356629f, 
    -0.04802189f, 0.06874878f, 0.05862597f, 0.06753028f, 0.00379433f, -0.01792519f, 0.01044963f, 0.20373930f, 
    -0.09719513f, -0.28074312f, 0.03505837f, 0.16318314f, -0.16474809f, -0.07976814f, -0.12379945f, 0.06959231f, 
    0.00816813f, 0.14055450f, 0.01148056f, -0.06647506f, -0.09139389f, -0.13245495f, 0.00297505f, -0.01763932f, 
    -0.05460127f, -0.04013420f, -0.01892522f, -0.25321069f, -0.19277266f, -0.05196103f, -0.13458975f, 0.23881102f, 
    0.00850903f, -0.05554793f, 0.09439200f, 0.05833608f, 0.12239443f, 0.05383687f, -0.07171460f, 0.03057197f, 
    -0.00667878f, -0.01466673f, 0.02802107f, -0.04034931f, -0.00246271f, 0.03162915f, -0.11169732f, -0.06605980f, 
    -0.69452560f, 0.14051270f, -0.21766844f, 0.13543174f, 0.41145855f, 0.01622569f, 0.12882686f, -0.09542020f, 
    -0.15000102f, 0.20018925f, -0.11340410f, 0.01581064f, 0.01618202f, 0.14517742f, 0.16503087f, 0.10861498f, 
    -0.01466541f, 0.00842592f, 0.11096666f, -0.01193740f, 0.01343004f, 0.09678761f, 0.01170944f, 0.09424093f, 
    -0.10781039f, -0.16563816f, -0.00197300f, 0.02266498f, -0.03784352f, -0.05997014f, -0.04548781f, 0.05876857f, 
    -0.03428582f, 0.04846853f, 0.05265273f, -0.03824522f, -0.15782291f, -0.01783478f, -0.11431931f, -0.19156565f, 
    -0.15734263f, -0.21051070f, -0.07465038f, -0.06077837f, 0.20444256f, 0.11328784f, 0.16516812f, 0.08050109f, 
    -0.12865716f, 0.04537900f, 0.00789953f, -0.02545024f, 0.04207098f, 0.05311955f, 0.08112363f, -0.05673741f, 
    0.02100864f, -0.04820506f, -0.05177651f, 0.04324301f, 0.03933937f, -0.04981675f, -0.11248571f, 0.01173035f, 
    0.14278463f, -0.04450810f, 0.08557500f, -0.06104256f, 0.04349723f, 0.03323993f, -0.10050257f, 0.08177469f, 
    0.06150886f, 0.00316193f, 0.06817564f, -0.03335994f, -0.06132228f, -0.02678254f, -0.10248730f, -0.04931684f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.15222920f, 0.13124506f, 0.02690596f, -0.10193212f, -0.02894298f, -0.00348597f, 0.00106104f, -0.06909905f, 
    0.02330434f, 0.01013297f, 0.01938967f, -0.02539660f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 5120);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
