#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.08641639f, 0.92964959f, -1.41532767f, -1.47568417f, -0.33008093f, 0.91341746f, -1.27829421f, 0.24233432f, 
    0.57402289f, -0.26964283f, -0.54452294f, -0.39814374f, -0.77482796f, -0.01966736f, -0.36124474f, 0.01665539f, 
    0.00779179f, -0.39939249f, 0.19539796f, 0.32347310f, 0.06740651f, -0.00087041f, -0.31878152f, -0.02525632f, 
    0.11315303f, 0.26440263f, -0.36706054f, -0.98448169f, 1.34554839f, 0.08489587f, -1.51139235f, -0.94038576f, 
    -0.72719556f, -0.32124537f, 0.36434522f, 0.29354054f, 0.31126377f, 0.18189295f, 0.09800393f, -0.37462440f, 
    0.24817289f, 0.14947720f, 0.01834468f, -0.31394792f, 0.12505895f, -0.16957097f, -0.23810585f, -0.08936968f, 
    0.24695079f, 0.04693986f, 1.24431920f, 1.01710260f, -0.25118846f, 0.10524360f, 0.90060431f, 0.21939173f, 
    0.12910324f, 0.21907169f, 0.96063739f, 0.85813367f, -0.54302746f, 0.27544680f, -0.01567337f, -0.70050436f, 
    0.12854807f, -0.40445796f, -0.15094317f, -0.50960600f, -0.22177626f, -0.10719318f, -0.15104115f, -0.51059085f, 
    0.45438161f, 0.04427699f, -0.15834560f, -0.86353511f, 0.55817294f, 1.53115809f, 0.79661661f, 0.19882584f, 
    -0.17715806f, 0.34042251f, 0.88554060f, -0.14086667f, 0.48267788f, -0.28368071f, 0.30852956f, 0.70939106f, 
    0.35871607f, -0.22211158f, 0.33516389f, 0.33015239f, 0.43967310f, 0.54684734f, -0.41507137f, 0.08011311f, 
    -0.34267417f, -0.24964832f, 0.46383935f, -0.13486528f, -0.94785893f, -1.06624925f, -1.08238924f, -0.60144019f, 
    -0.61410332f, -0.26792517f, -0.62956440f, -0.81687552f, -0.82110602f, 0.35414585f, 0.79966050f, 0.07656020f, 
    -0.04760307f, 0.59162033f, 0.43573412f, 0.19977459f, -0.08282351f, -0.09794997f, 0.18796824f, 0.54082495f, 
    -0.00103597f, 0.32575577f, -0.30741549f, -0.34730864f, 0.13325934f, -0.87546045f, -0.55031371f, 0.25117269f, 
    0.69197088f, 0.89773691f, 1.16974986f, 0.30671662f, 0.44510198f, 0.08299439f, -0.54671282f, 0.44155437f, 
    -0.21839575f, -0.02979756f, 0.08939771f, 0.20666064f, 0.71923858f, 0.38159493f, -0.57618231f, 0.07220745f, 
    0.43999356f, 0.09364645f, -0.22501327f, 0.21746629f, 0.25142869f, 0.34267548f, -0.62682074f, -1.50878084f, 
    -1.32009578f, -0.82470542f, -0.32478788f, 0.46160150f, 0.62692010f, 0.63630527f, 0.89660656f, 0.53533274f, 
    -0.33084020f, -0.08860706f, 0.04235008f, 0.09876502f, -0.14525084f, -0.19183482f, -0.00188989f, -0.00498984f, 
    0.03281884f, 0.15003929f, 0.16962385f, -0.14828628f, 0.39900115f, 0.02611702f, 0.41290233f, 1.02654791f, 
    1.44804096f, 0.71789014f, 1.15064609f, 0.29318169f, 0.69220728f, -0.28964868f, 0.08308357f, -0.94790828f, 
    0.23175468f, -0.32193655f, 0.47108540f, 0.38276079f, 0.57705677f, -0.28568661f, -0.36455041f, 0.11531904f, 
    0.54715121f, 0.21953484f, 0.08089655f, -0.33841592f, -0.11190566f, -0.24947800f, -0.38808802f, -0.11885336f, 
    0.45781428f, 1.46829903f, 1.12616694f, 0.25309533f, -0.11239532f, -1.25080669f, 1.29578674f, -0.78989255f, 
    -0.12657422f, 0.64944053f, 0.33584648f, 0.74582368f, 0.33718997f, 0.39362830f, 0.61777848f, 0.22407947f, 
    0.02602513f, 0.49169460f, 0.36451498f, -0.00347038f, 0.01785232f, 0.20944534f, 0.30524388f, 0.20531994f, 
    -0.07006885f, 0.62332302f, 0.57073301f, 0.76595795f, 1.76721406f, 0.60333478f, -0.07038574f, 0.04350238f, 
    -0.45670453f, 0.19998084f, 0.14492410f, -0.74779439f, -0.67716849f, -0.57104969f, -0.26594383f, -0.24999095f, 
    -0.00845011f, 0.23998526f, -0.38382784f, -0.45889235f, 0.34240609f, 0.15273708f, 0.50837749f, -0.09041049f, 
    0.25126186f, 0.47633216f, 0.12304246f, -1.77765191f, -0.66497737f, 0.74278194f, -0.12356085f, -1.21783459f, 
    1.55556035f, 0.86271381f, -1.07421029f, 0.14530908f, 0.51143193f, 0.26614502f, -0.17011830f, -0.04916260f, 
    -0.01296864f, -0.52879041f, -0.14876601f, -0.26940131f, -0.17920473f, -0.37789267f, 0.17515121f, -0.05381737f, 
    0.07793230f, 0.07449827f, -0.01323009f, 1.61639273f, -0.19948062f, -0.66779286f, 1.57999504f, 1.22669709f, 
    1.04953563f, 0.56082499f, -0.29288876f, 0.62810540f, 0.10957582f, -0.05632450f, 0.58976078f, -0.32749650f, 
    0.56236637f, -0.23827522f, -0.11724596f, -0.47476006f, -0.06236933f, 0.03360124f, -0.56562847f, 0.18255104f, 
    0.17628367f, 0.20238233f, 0.07787096f, 0.12331543f, 0.82110131f, 0.24703592f, 0.21580251f, 0.55725986f, 
    0.75254619f, -1.27755749f, -1.42020619f, -0.52289754f, -0.93663055f, -0.31400439f, 0.08525716f, 0.43093815f, 
    -0.08651398f, 0.24368469f, -0.26573002f, -0.38547072f, -0.21977064f, -0.18347093f, -0.11248995f, -0.46915832f, 
    0.03492996f, 0.47000906f, -0.04665599f, -0.30041939f, 0.07079899f, 1.22738647f, 0.84285587f, -0.94806767f, 
    -0.95849770f, -0.88719273f, 1.04797471f, 0.80763829f, -0.14633633f, 0.01992270f, 0.68450254f, 0.02282401f, 
    -0.23670396f, -0.64575738f, -0.21525732f, -0.51406449f, -0.10762989f, -0.02119632f, 0.02141869f, 0.31375730f, 
    0.02226017f, -0.19008951f, -0.15809569f, -0.40524477f, -0.09715720f, -0.08056741f, 1.92225754f, 0.69409567f, 
    0.51999074f, -0.40252918f, -0.99216342f, -0.58425188f, -0.46747488f, 0.43765470f, -0.06645678f, 0.06610218f, 
    0.22328463f, 0.00521157f, -0.14697422f, -0.08583241f, -0.37510380f, -0.14204307f, 0.21066821f, -0.03362464f, 
    -0.25007775f, 0.38992819f, 0.10290661f, 0.66349095f, -0.06850437f, -0.11274917f, -0.11774583f, -0.90298373f, 
    0.65870750f, 0.85233307f, -0.51448554f, 0.41148308f, 0.72085565f, 0.86212671f, 0.99027234f, 0.78755111f, 
    1.10870194f, -0.18373099f, -0.24416023f, -0.06865937f, 0.18454842f, -0.09261446f, 0.02639851f, 0.18514642f, 
    -0.14869796f, 0.08863217f, -0.15406254f, -0.15704232f, 0.28885570f, -0.46084714f, -0.01940123f, 0.45869762f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.24271663f, 0.54993397f, 0.15974058f, 0.35207614f, 0.50241494f, 0.42207691f, 0.34380326f, 0.26153824f, 
    0.22067952f, 0.36723131f, 0.26184991f, 0.26300532f, 0.16814184f, 0.24814802f, 0.27589715f, 0.03530487f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.62090820f, -0.48643854f, 0.14563625f, -0.56042612f, -0.02678564f, -0.22217129f, 0.13613889f, -0.16653258f, 
    0.02207993f, -0.01439589f, -0.06526842f, -0.00028986f, 0.05285543f, -0.57040220f, 0.08591255f, 0.54357165f, 
    -0.34524053f, -0.11659375f, 0.03260361f, 0.02289245f, 0.03153327f, 0.07878597f, 0.01520397f, -0.04854753f, 
    0.14773303f, -0.11757615f, 0.12479941f, 0.00771223f, -0.11535599f, 0.12406613f, 0.08469217f, 0.10081436f, 
    -0.06986327f, 0.08559772f, 0.11615849f, 0.04417916f, -0.88443750f, 0.14683266f, -0.26102987f, 0.31368253f, 
    0.01595650f, 0.05965272f, 0.17049022f, 0.00539246f, -0.01770611f, -0.17796113f, 0.02627696f, 0.05780432f, 
    -0.69479084f, -0.71523941f, -0.05677349f, 0.33017227f, -0.11542980f, -0.09394712f, 0.05028750f, -0.02804335f, 
    -0.07921953f, -0.06928978f, -0.10210711f, 0.10642958f, -0.41855508f, -0.19415283f, 0.04392054f, 0.13658755f, 
    -0.00155095f, 0.09568714f, -0.26538846f, -0.02136268f, 0.02452766f, 0.11523726f, 0.04063092f, -0.29922229f, 
    0.15170401f, 0.37703577f, -0.22634274f, -0.73807704f, 0.08607127f, -0.03981791f, 0.07869340f, 0.20272744f, 
    0.02394719f, -0.15898779f, 0.00312910f, 0.20223427f, 0.25475740f, 0.23365408f, -0.24538466f, -0.14979966f, 
    -0.43652350f, 0.06989990f, 0.05696460f, 0.10927832f, 0.22868182f, 0.13641505f, -0.29273197f, 0.22290458f, 
    -0.27078360f, -0.17386593f, -0.24006897f, 0.03639899f, -0.09137774f, -0.11906616f, -0.12937346f, -0.01594129f, 
    -0.06255165f, 0.25258628f, -0.06335004f, -0.15674938f, 0.16727020f, 0.12241452f, -0.09883688f, 0.59413970f, 
    -0.02845208f, -0.05971058f, -0.09198543f, 0.01324486f, -0.07301556f, 0.07872964f, -0.25275469f, -0.19294132f, 
    -0.66510439f, 0.10640083f, -0.15366636f, 0.28376696f, 0.00519125f, -0.06375686f, -0.24147600f, -0.05031318f, 
    0.04394556f, 0.09023672f, -0.14852139f, -0.02743936f, 0.40027171f, 0.09979097f, -0.06492533f, 0.52300495f, 
    -0.16043827f, 0.07566714f, -0.15621366f, 0.12559983f, -0.22038291f, 0.27111748f, 0.14457856f, -0.16486831f, 
    0.35582298f, -0.04037368f, 0.15353876f, 0.06293076f, -0.24650612f, 0.04647394f, -0.18619394f, 0.17951491f, 
    -0.17524880f, 0.07165959f, -0.01746781f, -0.09998969f, 0.17045806f, 0.10916072f, 0.07132991f, -0.62809598f, 
    0.11990137f, 0.09221777f, -0.00763886f, -0.04264169f, -0.15362929f, 0.15341052f, 0.11447915f, 0.05578643f, 
    0.23830423f, 0.04616945f, 0.08841680f, -0.11631383f, -0.02063760f, -0.34907433f, -0.32045451f, 0.11292444f, 
    -0.23615699f, -0.14430763f, -0.06826298f, -0.04743315f, 0.33316335f, 0.15792271f, 0.29631928f, 0.01135685f, 
    0.11477675f, 0.12271576f, -0.04094715f, -0.34561098f, 0.02091845f, -0.04510701f, -0.04711351f, 0.14124590f, 
    -0.75584221f, -0.57815880f, 0.09648445f, -0.83131891f, -0.05717918f, -0.22855259f, 0.00722027f, -0.01800869f, 
    0.02956279f, 0.17167707f, 0.05017410f, -0.14142430f, 0.05234403f, -0.54934603f, -0.32207635f, -0.13029718f, 
    0.13453430f, -0.08456083f, -0.15538773f, 0.21742274f, 0.01824805f, -0.07884008f, 0.03929059f, 0.01645881f, 
    0.41115826f, 0.11788750f, 0.30107605f, 0.24366918f, -0.12295652f, -0.03314804f, 0.06138497f, 0.11405018f, 
    -0.06919588f, 0.08554059f, -0.29155749f, -0.05309760f, 0.01715702f, 0.24573047f, -0.16197129f, 0.23993857f, 
    -0.01487578f, 0.00575360f, -0.27572110f, -0.25091529f, -0.16128097f, 0.15097949f, 0.10992968f, 0.08710414f, 
    0.29019481f, 0.46179676f, -0.15510547f, 0.04408886f, -0.08164246f, -0.10598643f, 0.11117273f, 0.06519712f, 
    -0.10376289f, 0.16992654f, -0.05416802f, 0.05412538f, 0.17316709f, 0.34883395f, -0.06830015f, -0.16942088f, 
    -0.02257660f, 0.25040430f, 0.02739126f, -0.13063361f, 0.01390442f, 0.13767894f, -0.18198785f, 0.24696830f, 
    0.36075062f, -0.37139311f, -0.10052736f, -0.17133772f, 0.10544684f, -0.03006450f, 0.00219572f, 0.14029957f, 
    0.11109810f, 0.00015221f, -0.03678133f, 0.02714380f, 0.24699146f, -0.01278493f, 0.10670711f, 0.27780142f, 
    0.04372974f, -0.22679371f, 0.01261844f, -0.10781810f, -0.12337993f, -0.11079219f, 0.08200361f, -0.25536403f, 
    0.10480927f, 0.40220731f, -0.18899575f, -0.11732581f, -0.22166753f, -0.06290084f, 0.06446345f, -0.02869932f, 
    0.37641159f, -0.02255645f, 0.08670666f, 0.19106247f, 0.32988986f, -0.09916385f, 0.08574767f, 0.22238773f, 
    -0.25318310f, 0.16994944f, 0.21120380f, 0.04603168f, 0.04391941f, -0.11389973f, 0.36797053f, -0.22768769f, 
    0.11920456f, -0.41083577f, -0.15969588f, 0.22475250f, -0.21374215f, 0.04783915f, -0.14029169f, 0.01423008f, 
    0.05584963f, -0.20797698f, -0.06258427f, -0.02457201f, 0.44989234f, -0.50856638f, 0.19153367f, 0.17742735f, 
    -0.20643727f, 0.00750919f, -0.32151455f, 0.12553087f, 0.10384204f, -0.04478272f, -0.26449516f, 0.13647267f, 
    -0.28783631f, -0.13397387f, 0.16035260f, 0.06283318f, 0.04267308f, 0.03863385f, -0.03736117f, 0.10046003f, 
    0.18248665f, 0.06595588f, -0.02345247f, -0.01460582f, 0.42799273f, -0.47494143f, 0.22048080f, -0.43255642f, 
    0.05533158f, -0.21374473f, -0.17259718f, -0.18247475f, -0.27388677f, -0.19485325f, -0.12364043f, -0.01725781f, 
    0.38354015f, -0.18938392f, -0.20172825f, 0.07138041f, -0.23730855f, -0.20592466f, 0.01788301f, 0.00897174f, 
    -0.03354345f, -0.06264931f, -0.02357518f, -0.05089364f, -0.38977912f, 0.18642867f, -0.08306731f, -0.07365926f, 
    -0.04189164f, -0.13971218f, 0.02430844f, 0.13649277f, 0.05405010f, 0.22466889f, 0.06688463f, -0.08273514f, 
    -0.65185946f, -0.15197058f, -0.30258477f, 0.15855625f, 0.06707940f, -0.01577833f, -0.04443509f, -0.02070105f, 
    -0.26184618f, -0.12261581f, -0.02969021f, 0.02437400f, 0.44427815f, -0.33662337f, -0.16470525f, -0.29510587f, 
    0.08873551f, 0.17644440f, -0.10252851f, -0.03220782f, -0.17667320f, 0.14006606f, 0.03025270f, -0.41659889f, 
    0.38363901f, -0.05166987f, 0.07415268f, -0.01060634f, 0.09473470f, 0.10765087f, 0.21506453f, 0.09451196f, 
    -0.11898167f, -0.04849469f, 0.12121477f, -0.13225609f, 0.48053199f, -0.07677026f, -0.42058980f, 0.24132933f, 
    -0.28505901f, 0.09503978f, 0.20808245f, -0.03651846f, -0.18521570f, 0.01443491f, 0.04760741f, -0.15246005f, 
    -0.09404887f, -0.20561627f, 0.11936889f, -0.40004686f, -0.11792138f, -0.03434645f, -0.21739410f, -0.14159326f, 
    -0.04008649f, -0.21183757f, -0.11490390f, -0.17572026f, 0.12994930f, -0.30725357f, 0.02570383f, 0.17176469f, 
    -0.09897153f, 0.06148873f, -0.16502874f, -0.27589893f, -0.02932652f, -0.14730957f, -0.05346243f, -0.22896086f, 
    0.11094399f, 0.27799556f, 0.19252831f, 0.58362967f, -0.30335256f, -0.38779816f, 0.01062142f, 0.16092713f, 
    0.10015743f, 0.03045849f, 0.09947050f, 0.19644819f, -0.25930834f, 0.04070558f, 0.12879683f, -0.24877028f, 
    0.12413338f, 0.09428766f, 0.04349560f, -0.02705530f, 0.03161461f, 0.23303257f, -0.19488521f, 0.01051364f, 
    0.30732554f, 0.21644318f, -0.05498491f, -0.37060550f, -0.05934624f, 0.19014306f, -0.08177543f, -0.15095323f, 
    -0.09698673f, -0.31106910f, -0.06396294f, -0.32139853f, -0.17421985f, -0.13139288f, -0.12686776f, 0.23996654f, 
    -0.02952138f, 0.09562417f, -0.10120585f, -0.07065020f, 0.10852760f, 0.16634591f, 0.14342465f, -0.02985746f, 
    1.37074077f, -0.12090895f, -0.07587946f, -0.16572195f, -0.17120457f, 0.04830692f, 0.05398106f, -0.16072085f, 
    0.01588548f, 0.02153776f, 0.04386159f, -0.14388712f, 0.06702682f, -0.37453780f, 0.14727776f, -0.16142985f, 
    0.12000460f, 0.01143153f, -0.04153296f, 0.04611526f, -0.04390479f, 0.02418559f, 0.02313042f, -0.01574500f, 
    -0.25620291f, 0.26468617f, -0.14793101f, -0.29940209f, 0.06424348f, -0.02216174f, 0.17990831f, -0.19127943f, 
    0.03913689f, -0.03041703f, -0.02376021f, -0.22006428f, 0.21592902f, -0.14495017f, 0.13154985f, -0.09410929f, 
    0.12867013f, -0.18239401f, 0.08405237f, -0.08048159f, -0.01215775f, -0.10892883f, 0.23003191f, -0.03485055f, 
    -0.73511630f, 0.16295853f, -0.03581054f, -0.28610441f, -0.22818424f, -0.16605289f, 0.25383833f, 0.14983183f, 
    -0.10012101f, -0.20775579f, -0.09351330f, -0.01591725f, 0.34740236f, 0.12502253f, 0.01775413f, 0.20975673f, 
    -0.05102576f, -0.11131617f, 0.17296061f, -0.01836174f, 0.05976529f, 0.09498407f, -0.26438004f, 0.17821856f, 
    0.13574603f, 0.10071959f, 0.10370720f, 0.09150262f, -0.16821758f, 0.17887491f, 0.14577442f, 0.21640219f, 
    -0.07570171f, 0.01371401f, -0.01417461f, 0.05965890f, 0.55019116f, 0.19611314f, 0.02428637f, 0.26326916f, 
    0.20076540f, -0.02103253f, 0.08807442f, 0.08854417f, 0.02783041f, -0.07309628f, -0.09626687f, -0.14646961f, 
    -0.06147704f, -0.26309645f, -0.59100974f, -0.23013903f, 0.07844949f, 0.08801349f, 0.01546971f, -0.14952496f, 
    -0.14102469f, 0.12257779f, -0.00458024f, 0.17992765f, -0.69793451f, -0.19858411f, -0.05824671f, -0.02993992f, 
    -0.09392165f, 0.04041297f, 0.19920442f, 0.15085873f, -0.08361511f, 0.08390213f, -0.24846968f, 0.16090165f, 
    0.06147790f, 0.12117355f, -0.19143839f, -0.25415564f, -0.38134873f, -0.00442573f, -0.21351254f, 0.07891454f, 
    0.07196560f, -0.11387528f, 0.06254550f, 0.00254950f, -0.25097185f, -0.09373358f, 0.19583938f, 0.29867589f, 
    0.02228007f, -0.26617151f, 0.00483974f, 0.00417258f, -0.04436670f, 0.11081017f, 0.05183890f, -0.14409764f, 
    0.06364396f, -0.05487338f, -0.28801709f, -0.09049291f, -0.36998388f, -0.15772110f, 0.10267702f, -0.14348729f, 
    -0.31987175f, -0.03105788f, 0.08988628f, 0.02602049f, 0.50042117f, -0.97070515f, -0.33938521f, 0.61695445f, 
    -0.16015044f, 0.08763795f, 0.22243075f, 0.09632390f, 0.06495279f, -0.08272839f, -0.06688908f, 0.30885893f, 
    -1.67778254f, 0.08393244f, 0.02566523f, 0.15886375f, -0.19313982f, 0.09033728f, -0.09072272f, 0.00836989f, 
    -0.12351973f, -0.16524659f, -0.05430055f, 0.02141361f, -0.75095707f, -0.85815614f, -0.59846938f, 0.21873470f, 
    -0.11127275f, -0.28193730f, 0.03640995f, -0.06405251f, -0.06686159f, 0.00475992f, -0.00862328f, -0.13926597f, 
    -0.01158978f, 0.23752305f, 0.41475737f, 0.10628682f, 0.17095183f, 0.06832574f, 0.12282856f, 0.05652997f, 
    -0.06726707f, 0.23730420f, -0.10541409f, -0.03339178f, 0.22040106f, 0.02530723f, -0.22837791f, -0.02344822f, 
    0.15214920f, 0.15868014f, -0.07998487f, -0.10081208f, 0.24935360f, 0.00174868f, 0.20267910f, 0.10264549f, 
    0.19347399f, -0.04026710f, 0.04707197f, 0.34762183f, 0.05939092f, 0.21321796f, -0.09313026f, -0.05667873f, 
    0.11214019f, -0.05309723f, 0.07748474f, -0.21563421f, -0.36099628f, 0.12109164f, 0.04867199f, 0.17949274f, 
    -0.12344517f, 0.01859937f, -0.03618197f, 0.10702433f, -0.08677932f, 0.10300323f, 0.08410744f, 0.11515576f, 
    0.32262489f, -0.49035746f, -0.31618738f, -0.10111068f, -0.01992011f, 0.25135857f, -0.09167042f, 0.33575264f, 
    0.04695199f, 0.30478749f, -0.05905596f, 0.22731535f, -0.77097815f, -0.00396098f, -0.33425993f, -0.65442848f, 
    -0.05514239f, -0.03254056f, -0.19860822f, -0.00903914f, -0.09768761f, -0.00773666f, -0.15656662f, -0.08573709f, 
    0.59527665f, -0.15141626f, -0.37016827f, 0.43535823f, 0.14293261f, 0.03498508f, 0.07962461f, 0.04573204f, 
    -0.02250089f, -0.05322904f, 0.17702895f, 0.05694877f, -0.35309735f, -0.17206898f, 0.05006786f, 0.19851968f, 
    -0.09325106f, 0.19112556f, 0.16414194f, -0.14919776f, 0.03824427f, 0.04042521f, -0.02350803f, -0.09446475f, 
    0.08687738f, -0.43974286f, -0.03011053f, 0.26199365f, -0.00644649f, -0.05116380f, 0.01519057f, -0.01985447f, 
    -0.15038981f, 0.04909448f, -0.03699096f, -0.16763131f, 0.12688197f, -0.03396926f, -0.18418841f, -0.06919292f, 
    0.01135427f, -0.23507436f, 0.04989042f, 0.32604602f, 0.01985432f, 0.00059097f, -0.27492297f, -0.28958237f, 
    0.23136882f, 0.12927471f, 0.14426309f, 0.04162735f, 0.11405949f, 0.01654648f, 0.12419621f, 0.23906180f, 
    0.07313169f, -0.13698275f, 0.20564574f, -0.14959739f, -0.17473754f, 0.15920830f, -0.25920883f, -0.39954334f, 
    0.05390103f, -0.03486700f, 0.02748927f, 0.15609786f, 0.04517274f, -0.26769161f, 0.34301275f, -0.22445996f, 
    -0.53592288f, 0.08982188f, -0.03007763f, 0.32157937f, 0.16723877f, -0.18157385f, 0.03901478f, -0.08494624f, 
    0.00766181f, -0.08875747f, 0.14452222f, -0.07753076f, -0.11333340f, -0.07036782f, 0.03689606f, 0.00767910f, 
    0.12148897f, 0.06351640f, 0.11331081f, 0.12448116f, -0.06711558f, -0.07501794f, 0.16440740f, 0.11534302f, 
    -0.94374067f, -0.15111339f, 0.37443888f, 0.11220905f, 0.01436969f, 0.01488633f, -0.05113558f, -0.02223323f, 
    0.13234921f, 0.01988946f, -0.16195570f, -0.10500015f, 0.33435434f, 0.36622676f, 0.05693644f, 0.08061438f, 
    -0.10651422f, 0.25870195f, -0.14663592f, 0.05635346f, -0.00927961f, -0.01504223f, 0.09084311f, 0.13831346f, 
    -1.01907218f, 0.13895394f, 0.01642669f, -0.11833419f, 0.08007295f, -0.03314513f, 0.09262720f, -0.02283252f, 
    -0.10387129f, -0.04042669f, -0.11455975f, 0.09571491f, 0.14518447f, 0.11182101f, -0.22951519f, -0.09140358f, 
    -0.13578068f, -0.06665784f, 0.18906589f, -0.14403608f, -0.09959326f, -0.11355899f, -0.03920549f, -0.03565723f, 
    -0.52044123f, -0.45211333f, 0.28363043f, 0.30921391f, -0.18705471f, -0.09633008f, -0.24082115f, -0.23302457f, 
    -0.04983237f, -0.14207877f, -0.02522613f, 0.14115751f, -0.74101895f, -0.24888889f, -0.01862154f, 0.39633092f, 
    0.07090502f, -0.00431175f, 0.06771002f, 0.12654530f, 0.07424167f, 0.00033620f, -0.00038805f, 0.05779713f, 
    0.10253058f, -0.37822184f, 0.31912553f, -0.21353291f, -0.23493364f, 0.09950855f, 0.09836248f, -0.21736215f, 
    0.12384235f, 0.24967948f, 0.00018945f, 0.01566566f, 0.42599970f, -0.11235014f, -0.24184342f, 0.13020507f, 
    -0.01774393f, -0.16072102f, 0.08127504f, 0.06001392f, -0.13463843f, 0.03821208f, 0.06965005f, -0.00105452f, 
    0.10959446f, -0.00668239f, 0.19918033f, 0.23121656f, 0.15920290f, 0.17684256f, -0.27148759f, 0.02278278f, 
    -0.00397887f, 0.08682531f, -0.12528384f, -0.11822684f, 0.05272533f, -0.07664989f, 0.28358561f, -0.17662989f, 
    -0.20405610f, -0.01818627f, -0.12672794f, -0.04773849f, 0.06468163f, -0.04275866f, 0.06874379f, 0.15639767f, 
    0.18567717f, -0.11454289f, 0.15387835f, -0.63158244f, 0.01802449f, -0.01138782f, -0.07000329f, -0.31861961f, 
    0.05054570f, -0.20644855f, -0.17956175f, -0.26759800f, 0.12912048f, 0.03988645f, 0.30858326f, -0.18481506f, 
    0.01053656f, 0.04337184f, 0.03496940f, 0.20684518f, 0.04857603f, -0.30404443f, 0.03026466f, 0.09677323f, 
    -0.49123222f, -0.36623508f, -0.25536361f, 0.32865012f, 0.12196147f, -0.10870560f, -0.15747605f, -0.04962036f, 
    -0.08744653f, 0.26295617f, 0.32201722f, 0.23572299f, -0.36530682f, 0.12724388f, 0.20574121f, -0.03981484f, 
    -0.03243226f, 0.03378802f, 0.20318457f, 0.02588447f, 0.14497134f, 0.10542639f, -0.06135394f, 0.18524630f, 
    -0.62834460f, -0.40818176f, -0.62241191f, -0.19878478f, 0.07107574f, 0.30698204f, 0.03824107f, -0.07297098f, 
    0.07635006f, 0.10168266f, -0.15915109f, -0.02633411f, -0.09659533f, 0.14185201f, 0.27505749f, 0.12791890f, 
    0.06704770f, 0.27080539f, 0.23208053f, -0.05070019f, -0.26516166f, 0.00372831f, 0.14855808f, 0.16319337f, 
    0.08056690f, -0.14160946f, 0.12745276f, -0.29203755f, -0.08030006f, 0.07513534f, 0.06875910f, 0.00024386f, 
    0.11253145f, -0.07263568f, 0.22200328f, 0.30446184f, 0.00548019f, 0.08131674f, 0.32104540f, -0.13978052f, 
    -0.17243508f, -0.04228079f, 0.00726944f, 0.03105208f, 0.14759113f, 0.12471048f, -0.25531277f, 0.21311365f, 
    -0.86303395f, -0.00521322f, -0.04466215f, -0.37442958f, 0.05415030f, -0.08138987f, -0.04885734f, 0.12150766f, 
    -0.00587230f, -0.19703276f, -0.10302496f, -0.16134565f, -0.54538167f, -0.06023876f, 0.23662260f, -0.24905922f, 
    -0.08477610f, -0.20720933f, 0.08987807f, -0.06071037f, 0.19031490f, -0.08079128f, 0.09533498f, 0.05277038f, 
    0.05900156f, 0.00838072f, -0.01003401f, 0.37004039f, -0.12633204f, -0.22704761f, -0.03932044f, 0.10155746f, 
    -0.00747231f, -0.36407635f, 0.22392814f, 0.08451033f, 0.58741891f, 0.03822630f, -0.42083371f, -0.03073951f, 
    0.02995089f, -0.08622593f, -0.28776708f, 0.03662162f, 0.06957772f, -0.19381553f, 0.02243424f, -0.14489049f, 
    0.11684921f, 0.20347236f, 0.07879647f, 0.09049062f, 0.04853051f, -0.02608803f, -0.04121901f, 0.08560853f, 
    -0.03511442f, -0.01023730f, 0.12222320f, -0.15384226f, 0.06081077f, 0.19339213f, 0.38692844f, -0.03712435f, 
    0.04455325f, 0.05323550f, -0.26388204f, -0.18026175f, 0.15230647f, -0.28767931f, -0.08345234f, -0.04173080f, 
    -0.45061460f, -0.17790371f, -0.04794235f, 0.15834597f, -0.23359455f, -0.04024802f, 0.04356691f, -0.02588359f, 
    0.07710671f, -0.02742568f, 0.11340508f, -0.03779093f, 0.03593326f, 0.39268866f, -0.30536646f, 0.06375098f, 
    0.07602151f, 0.12583040f, -0.07982711f, -0.07091566f, -0.05211405f, 0.04615983f, -0.20484120f, -0.11455543f, 
    -1.14262962f, 0.37798959f, 0.06854316f, 0.23248239f, -0.07040333f, -0.11136627f, -0.11872835f, 0.07155428f, 
    -0.01722979f, 0.23752238f, 0.26909140f, 0.31900194f, 0.30530974f, -0.10632777f, 0.21612419f, -0.06944994f, 
    0.04737622f, -0.26188079f, 0.11037287f, -0.00704931f, 0.12216681f, 0.29776517f, -0.18687078f, -0.28798988f, 
    -0.65077764f, 0.23412985f, 0.09903175f, -0.26708245f, -0.02897023f, -0.02261749f, 0.10072594f, -0.02388077f, 
    -0.00515926f, -0.06575750f, -0.28724796f, -0.35179377f, 0.37010938f, -0.25864723f, -0.13723202f, 0.05786178f, 
    -0.16506803f, 0.11158349f, 0.23860990f, -0.04958876f, -0.05128980f, -0.04669899f, -0.08595999f, -0.15847591f, 
    -0.45022008f, -0.22290742f, -0.19705068f, -0.40121573f, -0.09531470f, -0.07944241f, 0.08681610f, -0.06646397f, 
    -0.17230113f, -0.00491485f, 0.04082859f, 0.07400041f, 0.36899942f, 0.30832657f, 0.18751077f, -0.04762765f, 
    -0.32683513f, -0.08850866f, -0.07396112f, -0.07360848f, 0.18382530f, 0.03046160f, -0.06491462f, -0.19877397f, 
    -0.07211468f, 0.13738662f, 0.32928959f, 0.22369759f, 0.08355287f, -0.00825652f, 0.09859480f, 0.10813180f, 
    -0.14802445f, -0.02746999f, -0.25599483f, -0.20608677f, 0.14056695f, 0.20511073f, 0.10909110f, -0.57154554f, 
    0.08422710f, -0.01891094f, 0.14475332f, 0.06855161f, -0.21610659f, -0.04663393f, 0.08928083f, -0.16558737f, 
    0.81943494f, -0.24378373f, -0.00548753f, -0.26316607f, 0.08670101f, -0.01798333f, 0.07212082f, -0.06318028f, 
    0.01359415f, -0.04723809f, 0.31942129f, 0.01292250f, -0.09158268f, -0.32086328f, 0.11616721f, -0.26084942f, 
    -0.11649583f, -0.02467531f, 0.08463326f, 0.14294401f, -0.04316968f, -0.04363067f, -0.02171655f, -0.11479644f, 
    0.32144260f, 0.22000699f, -0.12683576f, -0.67182040f, 0.13400580f, 0.19863737f, -0.03792934f, 0.01849376f, 
    -0.04512018f, 0.13776217f, -0.07540833f, 0.17465608f, -0.21902448f, -0.01984296f, -0.41600692f, 0.39981624f, 
    0.10453109f, 0.12656933f, 0.13453534f, 0.08692208f, 0.07205719f, 0.13154383f, 0.00447178f, -0.02059937f, 
    -0.61954385f, 0.09909023f, -0.25521016f, 0.45403549f, -0.02436065f, 0.09850740f, 0.00344702f, 0.07498744f, 
    -0.16431075f, -0.02461183f, 0.12121201f, -0.11748386f, -0.15888339f, -0.27388951f, -0.07778414f, 0.16687672f, 
    -0.13879940f, 0.01528468f, 0.19757068f, 0.06660889f, -0.17836037f, 0.02529203f, 0.15685312f, 0.08681007f, 
    0.58438098f, 0.46366987f, -0.19423065f, 0.63205487f, 0.13189150f, 0.05560787f, -0.01799609f, 0.27157947f, 
    0.04546878f, 0.00300837f, -0.02262341f, 0.00457391f, 0.21688771f, 0.25220039f, -0.13166830f, -0.29628980f, 
    -0.19294374f, -0.05869425f, -0.17498679f, -0.13225396f, -0.02640824f, 0.07288872f, -0.04680021f, -0.26717418f, 
    -0.25876892f, 0.23720622f, -0.01087099f, -0.19287668f, 0.14729436f, 0.08909258f, -0.35412797f, -0.03490644f, 
    0.02175018f, -0.08173432f, -0.01860718f, -0.13686650f, 0.18688813f, -0.50378931f, 0.07120599f, -0.27908188f, 
    0.22841950f, -0.04654633f, -0.15149222f, -0.18444903f, 0.06306093f, 0.11758197f, 0.09382377f, -0.01674861f, 
    0.06408999f, 0.13248990f, 0.24004802f, 0.28828549f, 0.06286094f, -0.06644333f, -0.04972858f, -0.19614962f, 
    -0.00484991f, -0.32540852f, 0.01375506f, -0.17461549f, -0.37559927f, -0.15697616f, 0.08628273f, -0.25122270f, 
    -0.01649941f, -0.13949208f, -0.04777444f, -0.07299721f, 0.01194640f, 0.15303761f, 0.12514578f, -0.11421602f, 
    0.13027979f, 0.45890221f, 0.30644831f, 0.52580428f, 0.23247802f, 0.37342742f, 0.20723206f, -0.04404067f, 
    -0.01176932f, 0.03705558f, 0.05430376f, -0.10732342f, -0.48940584f, 0.19680250f, 0.00050351f, -0.44771865f, 
    0.02463600f, -0.02548208f, 0.15176651f, -0.10879151f, -0.14102356f, 0.02963116f, 0.21486484f, -0.21093571f, 
    0.51706731f, -0.27870104f, -0.09595942f, -0.20125255f, 0.22706027f, 0.05868573f, -0.08127352f, 0.12557012f, 
    -0.12388819f, -0.15183949f, -0.01983885f, -0.20560238f, -0.32507297f, 0.09581122f, 0.13014384f, -0.27812871f, 
    -0.08939964f, -0.05806855f, -0.07577745f, -0.16074578f, 0.16712976f, 0.00055804f, 0.01756747f, 0.25921434f, 
    0.76349699f, -0.06824972f, 0.46858105f, -0.14305775f, -0.12307756f, 0.03704689f, -0.05108673f, -0.09235437f, 
    0.02574458f, 0.18169859f, -0.26445171f, 0.04773337f, -0.91101891f, 0.40021449f, -0.14901967f, -0.11255398f, 
    -0.38321838f, -0.00580239f, -0.01978404f, -0.29435277f, -0.25135377f, -0.09370000f, -0.14182469f, -0.19717965f, 
    -0.03933664f, -0.18802656f, -0.39808038f, 0.45314968f, -0.01474039f, -0.16968633f, -0.07246283f, -0.18477568f, 
    -0.34755611f, -0.05057288f, 0.03315532f, -0.04094217f, -0.47735155f, 0.46827313f, -0.08267374f, -0.04751595f, 
    -0.15834652f, -0.13277122f, -0.05372894f, -0.16359206f, 0.07267433f, 0.01151601f, -0.08558746f, -0.03480664f, 
    -0.25492284f, -0.17758219f, -0.47913244f, -0.21989004f, -0.13150521f, -0.06631362f, -0.12810919f, -0.11035933f, 
    -0.14926361f, -0.12632623f, -0.04110529f, -0.04690741f, -0.05628124f, 0.28447413f, -0.06260399f, -0.04348337f, 
    -0.02114059f, -0.16541643f, -0.06954301f, -0.05671946f, -0.00704816f, -0.03796179f, -0.05417947f, 0.03270026f, 
    -0.36052909f, 0.40920112f, -0.25867528f, -0.52736557f, -0.11353695f, 0.00579774f, -0.33870548f, 0.15147722f, 
    0.00833114f, -0.24749586f, -0.20799665f, -0.16870134f, -0.30243248f, 0.28693032f, -0.39482129f, -0.39575717f, 
    0.15900336f, -0.00204409f, -0.10518784f, 0.07326034f, 0.00410428f, 0.05671359f, 0.09998770f, -0.01664603f, 
    0.25495359f, -0.05030402f, -0.23220353f, 0.16630456f, -0.04257989f, -0.09079043f, -0.14248650f, -0.15221106f, 
    -0.35140905f, -0.08405671f, -0.33300629f, 0.01853145f, 0.27194816f, -0.19224133f, 0.21188350f, -0.14057288f, 
    -0.05731340f, 0.00191355f, 0.07071163f, -0.09797464f, -0.02108683f, -0.04188614f, 0.19552465f, 0.06245071f, 
    -0.24906555f, -0.02947690f, 0.30113292f, -0.46924812f, 0.00729849f, -0.14188488f, -0.33001664f, -0.08586741f, 
    0.02621245f, 0.15718827f, 0.08170019f, 0.16715872f, 0.03681985f, -0.17156546f, 0.09482788f, 0.23446229f, 
    -0.27084348f, -0.05557868f, 0.07127606f, -0.17363921f, 0.07297520f, -0.02989575f, -0.17076415f, 0.23454925f, 
    -0.59896570f, 0.00301576f, 0.50699288f, 0.20644060f, -0.26527193f, 0.21625958f, -0.06381492f, 0.08563636f, 
    -0.07337161f, -0.05942874f, 0.01450776f, -0.00506327f, 0.01195860f, -0.17923459f, -0.25326240f, 0.32051006f, 
    0.00745740f, -0.18794516f, -0.18954629f, 0.04259143f, -0.04882981f, -0.07236626f, 0.30702561f, -0.25138444f, 
    0.41937396f, 0.19311476f, -0.49970257f, 0.24186726f, 0.04650130f, 0.04331573f, 0.08321398f, -0.16209863f, 
    0.02171805f, 0.18416458f, 0.30458587f, 0.10951706f, -0.09841655f, -0.13882147f, 0.03760396f, 0.46874639f, 
    0.32240596f, -0.23121843f, -0.07357508f, 0.01350777f, 0.29086071f, 0.20871577f, -0.20032743f, 0.02111182f, 
    -0.05686833f, -0.07127549f, -0.25585800f, -0.42845875f, 0.04488784f, 0.07077157f, 0.04338032f, 0.04683722f, 
    0.02710385f, 0.02716200f, 0.06401672f, 0.21208845f, 0.14543025f, -0.08692776f, 0.01181506f, 0.33182338f, 
    0.03425968f, -0.03363534f, -0.02115874f, 0.07189944f, 0.11845764f, -0.13706508f, 0.02619154f, -0.19772165f, 
    -0.61339766f, -0.34937409f, -0.38959900f, -0.28722754f, 0.01322267f, 0.07584645f, -0.14048058f, 0.13061532f, 
    0.23183832f, -0.08305126f, -0.00139694f, -0.10760194f, 0.18488957f, 0.43306485f, -0.40594429f, 0.15501809f, 
    -0.17881986f, 0.22039942f, -0.43906564f, -0.25204173f, -0.12516758f, -0.15969925f, 0.10240180f, -0.01940603f, 
    0.10908554f, -0.12655477f, -0.18341184f, -0.25228095f, 0.10195878f, 0.12377935f, -0.11766043f, 0.01153785f, 
    0.33812457f, 0.05213508f, -0.11373333f, -0.06377196f, 0.55474859f, 0.18168096f, 0.02429087f, 0.19014730f, 
    -0.35168609f, -0.02064482f, -0.23019744f, -0.09898011f, 0.02376189f, -0.12413477f, 0.03627907f, -0.20897987f, 
    -0.45980942f, 0.19166850f, 0.35439202f, -0.25153789f, -0.09250827f, 0.01160346f, 0.07716421f, 0.26332247f, 
    -0.01641062f, -0.01733498f, -0.02765192f, 0.14574526f, -0.66079295f, 0.16980685f, 0.29083014f, -0.11632511f, 
    -0.10882449f, -0.11835005f, 0.12213275f, 0.00654297f, -0.01662533f, -0.15010144f, -0.17437235f, 0.00542758f, 
    -0.14720106f, 0.48761144f, -0.07695035f, -0.03687272f, -0.10345946f, -0.05496756f, -0.12118156f, -0.13407646f, 
    0.20002763f, -0.00989427f, 0.19574314f, 0.08402950f, 0.24545974f, -0.02186554f, 0.19790731f, 0.01188192f, 
    0.20890754f, 0.00188621f, 0.07496826f, -0.02751649f, -0.25253025f, -0.24544902f, -0.22184032f, 0.07427615f, 
    -0.04980709f, -0.58292645f, 0.18086681f, -0.14924550f, 0.14135236f, 0.33159634f, -0.10322037f, -0.11668942f, 
    0.14225689f, -0.23399176f, -0.02289468f, -0.10690635f, 0.46648020f, 0.27251187f, -0.62939870f, 0.17575374f, 
    0.19231375f, -0.24701425f, -0.09041774f, 0.08952069f, -0.06979351f, 0.17624769f, 0.12453004f, -0.20005354f, 
    0.13526954f, -0.24261625f, -0.03551758f, 0.07103048f, 0.44712046f, -0.08803139f, -0.18862496f, 0.09294289f, 
    0.11118237f, 0.02584385f, 0.12714894f, 0.01688821f, -0.46437505f, 0.08313429f, -0.27204329f, -0.41242319f, 
    0.09540232f, 0.11775410f, -0.07698087f, 0.25628850f, -0.09418335f, 0.17024158f, -0.15975608f, -0.14743809f, 
    0.04020531f, -0.14122415f, 0.35898882f, -0.13556755f, 0.08843381f, -0.04951127f, -0.07026019f, 0.17371444f, 
    -0.11957596f, -0.21803078f, -0.10570129f, -0.32061270f, -0.29814988f, -0.05420737f, -0.09575984f, -0.36048150f, 
    0.17187423f, -0.07307620f, -0.15739271f, -0.11366145f, -0.12016226f, -0.28405544f, 0.12914549f, -0.08439387f, 
    -0.27617094f, -0.34173778f, -0.20469861f, 0.31722668f, -0.02608420f, -0.00122917f, -0.03764186f, 0.01093633f, 
    -0.16050921f, 0.22824067f, 0.13887274f, 0.07227829f, -0.71295643f, 0.98284143f, -0.62506473f, -0.39580768f, 
    0.30484024f, 0.03246025f, 0.09089489f, -0.06410261f, -0.04503540f, -0.01732295f, 0.17475383f, -0.08341107f, 
    -0.11333132f, 0.14699562f, -0.08520507f, -0.84853584f, -0.03543245f, 0.01953446f, 0.22327282f, -0.09704349f, 
    0.13922769f, 0.19200271f, -0.01644049f, -0.05765190f, -0.45388249f, 0.01836511f, 0.43843383f, 0.10788915f, 
    -0.19226976f, 0.01465770f, -0.03424112f, 0.13233595f, 0.06988808f, 0.14101587f, -0.01766321f, 0.17724350f, 
    0.37334654f, 0.23536047f, 0.30808327f, 0.07204246f, 0.13654438f, 0.11766814f, 0.17562649f, -0.29567704f, 
    -0.21576135f, -0.15772328f, -0.21132748f, 0.18400446f, -0.01769281f, -0.43707505f, 0.15873466f, -0.11350469f, 
    0.09211203f, 0.07722573f, 0.17330496f, -0.10294954f, -0.08607746f, -0.03716461f, 0.21898767f, 0.10081461f, 
    -0.40465748f, -0.44354406f, 0.14011739f, -0.25124502f, 0.02045965f, -0.00780767f, 0.04581018f, -0.07316823f, 
    0.05695008f, 0.13259134f, -0.46452025f, -0.39649090f, 0.43464226f, 0.03512382f, 0.11494141f, 0.20291059f, 
    0.30384794f, 0.07190094f, 0.16673447f, 0.08515916f, -0.05922690f, 0.00948366f, 0.08324239f, 0.20956405f, 
    -0.88910496f, -0.65886223f, -0.19661018f, 0.10257316f, -0.14524534f, 0.25599694f, 0.02290381f, -0.08761056f, 
    0.03717571f, -0.14125200f, -0.14398240f, -0.06749832f, -0.93227160f, 0.07132108f, -0.23412487f, -0.31501564f, 
    0.04261728f, 0.26077762f, -0.23839752f, -0.05358551f, 0.00318549f, -0.09277503f, 0.42749009f, 0.19678025f, 
    0.44936052f, 0.16862907f, -0.04366075f, 0.04475446f, 0.13734965f, 0.06077370f, 0.10532194f, 0.11768071f, 
    -0.04239700f, 0.24066220f, 0.00827488f, 0.26673517f, 0.30778861f, 0.14117213f, -0.14352323f, -0.05790497f, 
    0.08208253f, 0.03326961f, 0.10636987f, 0.17524919f, 0.13231473f, -0.11738153f, 0.15554857f, 0.25261152f, 
    0.57605684f, -0.01822126f, 0.24531268f, -0.17769364f, -0.44709128f, -0.06409343f, 0.04200180f, -0.16018778f, 
    0.17255686f, 0.11579844f, -0.02966505f, -0.06284653f, -1.40077424f, -0.61829466f, -0.31403148f, -0.46432501f, 
    0.14676021f, -0.02870794f, -0.23794672f, -0.19896586f, 0.10337178f, -0.25505072f, 0.12723845f, -0.08302597f, 
    -0.40377927f, -0.28818241f, -0.24948667f, -0.05198959f, 0.10718260f, 0.11423729f, -0.08895239f, 0.05506976f, 
    -0.02359634f, 0.24735437f, 0.13131826f, 0.27752960f, -0.62781727f, -0.35870379f, -0.00726543f, -0.72677660f, 
    0.13612518f, -0.03127671f, -0.01227343f, 0.24851216f, 0.10300955f, -0.02877039f, -0.00632005f, 0.22495353f, 
    0.33917838f, -0.09668271f, -0.30275622f, 0.05867026f, -0.03671977f, 0.23389781f, 0.02613390f, 0.11858167f, 
    0.02349398f, -0.19170500f, -0.02856673f, 0.08167779f, -0.25267953f, -0.31010464f, -0.11416198f, -0.12923431f, 
    0.02923892f, -0.06253660f, -0.01560167f, 0.09267777f, 0.11037885f, -0.03017230f, 0.12020568f, 0.12739749f, 
    0.25857460f, 0.27375498f, 0.23352638f, -0.26676658f, 0.20573328f, 0.12108579f, -0.04907649f, 0.25639302f, 
    -0.07971467f, 0.05381183f, 0.03868291f, -0.00723298f, -0.49473888f, -0.18059736f, -0.32822451f, -0.00649331f, 
    -0.03686739f, -0.03000080f, 0.11148740f, -0.08932503f, 0.04689671f, -0.40846464f, -0.15278265f, -0.22560889f, 
    -1.40031588f, -0.10154090f, 0.54766768f, 0.27799499f, 0.35114145f, 0.11885875f, -0.06571323f, -0.32064059f, 
    0.09705479f, -0.17341390f, -0.01014002f, 0.26009786f, -0.02910455f, 0.26782930f, 0.02149831f, -0.15015097f, 
    0.15155883f, 0.20010130f, -0.07361300f, 0.13399805f, 0.10816203f, 0.14782298f, -0.03232175f, 0.12221940f, 
    0.29679713f, 0.00821243f, -0.08670725f, 0.45126423f, 0.15173191f, 0.17468376f, -0.20126286f, -0.25663692f, 
    -0.16266386f, -0.03374361f, 0.12060523f, 0.14141032f, -0.38775969f, 0.22635378f, -0.24364325f, -0.34849402f, 
    0.39476365f, -0.06460547f, 0.16942695f, -0.01674281f, -0.06096729f, 0.20618072f, 0.02261153f, 0.09924925f, 
    -0.27835438f, 0.13337967f, -0.38987783f, -0.04822595f, 0.18657309f, 0.03572891f, 0.07464269f, 0.33030817f, 
    0.15986070f, -0.15268950f, 0.03216760f, 0.11326572f, -0.43287912f, 0.05804534f, 0.07406574f, -0.31878114f, 
    -0.37794337f, 0.10414354f, -0.06419639f, 0.11995102f, 0.13764632f, 0.15852690f, -0.01234292f, -0.11290433f, 
    0.43597820f, 0.04941156f, -0.41498867f, -0.17434533f, -0.40125814f, 0.07822622f, -0.07419343f, -0.07799190f, 
    -0.01459880f, -0.22992791f, -0.17187680f, -0.35695565f, 0.23378217f, -0.29458898f, 0.44319922f, -0.18162011f, 
    0.09070034f, -0.13472328f, -0.18784027f, 0.16615376f, -0.28565881f, -0.09079211f, 0.07952037f, 0.16790006f, 
    -0.08799724f, -0.04998698f, 0.11936593f, 0.05801148f, -0.18352187f, -0.13939200f, -0.21503384f, -0.06628522f, 
    -0.17140424f, -0.11792963f, 0.10014687f, -0.22057186f, 0.16229843f, -0.31736073f, 0.00238165f, -0.22488721f, 
    -0.09860220f, -0.10811625f, 0.01184802f, -0.04687556f, 0.02392463f, -0.03502947f, 0.04207397f, 0.00118623f, 
    0.91767335f, -0.00590100f, -0.30941665f, 0.10793516f, 0.08899733f, -0.14985108f, 0.05533275f, 0.16087134f, 
    -0.29309595f, 0.07232119f, 0.00577003f, 0.06067932f, 0.23747596f, -0.06318086f, -0.11624492f, -0.34099719f, 
    0.08327592f, -0.03146096f, 0.02719502f, 0.15554048f, -0.02768642f, 0.03519920f, -0.16474712f, 0.00863808f, 
    -0.60035497f, 0.44068030f, -0.20275246f, 0.23814286f, 0.24390262f, -0.05446434f, 0.26557103f, -0.17901988f, 
    -0.12471350f, -0.10138594f, 0.13192727f, 0.01049102f, -0.01757423f, -0.40022394f, 0.07182031f, -0.12654869f, 
    0.12761591f, 0.08806295f, 0.10335629f, -0.19946748f, 0.16674095f, 0.18173990f, -0.23485748f, 0.09497958f, 
    0.33247694f, 0.28721508f, -0.40388915f, 0.25251809f, 0.05631078f, -0.32718024f, 0.16747501f, -0.10893029f, 
    0.12927110f, 0.08549644f, -0.17877382f, -0.09243592f, -0.10301571f, -0.42970634f, -0.11224969f, 0.08917180f, 
    -0.05140905f, 0.09350213f, 0.15505974f, 0.02040240f, 0.07933072f, 0.16500059f, -0.21059375f, -0.03796121f, 
    0.47902128f, 0.39425820f, -0.07386403f, -0.18035340f, 0.07376862f, 0.11136593f, -0.02147686f, 0.01135415f, 
    -0.05661531f, 0.04302734f, 0.01023248f, -0.07441271f, -0.82348138f, -0.56609690f, -0.18737826f, -0.26716587f, 
    -0.09143864f, 0.16716608f, 0.14839588f, 0.38700461f, 0.02393033f, 0.09413774f, -0.21687448f, -0.18477027f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.22641878f, 0.02209849f, -0.12364326f, 0.07152925f, 0.14284824f, 0.06927719f, 0.02043796f, -0.09574354f, 
    -0.11449066f, 0.07754043f, 0.15262811f, 0.05356544f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
