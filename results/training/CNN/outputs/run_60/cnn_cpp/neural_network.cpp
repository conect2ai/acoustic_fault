#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.58572972f, 0.41845301f, 0.94331396f, 0.30356377f, -0.37286010f, -0.10666405f, -0.26530558f, -0.56248969f, 
    -0.18157364f, 0.58740813f, 0.23496501f, 0.22387929f, -0.06742103f, -0.59993446f, 0.08820961f, -0.47154221f, 
    -0.76369947f, -0.38220063f, -0.47915670f, -0.30607894f, 0.27388033f, 0.45465577f, -0.01044757f, 0.07229074f, 
    -0.27755919f, 1.35005474f, 0.09316806f, 0.34774068f, 1.23553455f, 0.53899443f, 0.41329971f, 0.03554630f, 
    -0.38516778f, -0.10669097f, -0.26420626f, -0.41028547f, 0.26049107f, -0.12906690f, 0.33254510f, -0.34680420f, 
    0.23558185f, 0.37184569f, -0.10221971f, -0.03102033f, 0.05437209f, 0.02801451f, 0.20551930f, -0.24294877f, 
    -0.18050584f, 0.07279044f, -0.33010280f, -0.48864111f, -0.39934808f, -0.06223539f, -0.00077044f, -0.81756145f, 
    -0.87366229f, -0.45875627f, -0.51437259f, -0.45822749f, -0.13716877f, 0.48340118f, 0.17693171f, 0.12499467f, 
    0.53746879f, 0.14672332f, 0.04245569f, -0.00877920f, 0.28048596f, 0.08768070f, 0.36752921f, 0.16404915f, 
    0.50031513f, 0.07534607f, 0.09720293f, -0.46440712f, 1.15317929f, 0.18754879f, -0.19369096f, 0.24953672f, 
    -1.10861945f, 0.04445349f, 0.00268314f, 0.06120439f, -0.53019965f, -0.40095177f, -0.29559025f, -0.13784122f, 
    -0.25137571f, 0.20307508f, -0.33476725f, 0.11374356f, 0.29099539f, -0.06655686f, 0.02912958f, 0.26382494f, 
    -0.05690462f, -0.36478066f, -0.28468534f, 0.11564625f, -1.29013467f, 0.24812728f, -0.53363389f, -0.34973747f, 
    -0.22697222f, 0.17525585f, 1.30901670f, 0.40925908f, 0.53063709f, 0.69444042f, -0.11395922f, -0.38549060f, 
    0.35054615f, -0.58642256f, 0.13748780f, 0.01520280f, -0.18740922f, -0.00642512f, -0.19368622f, -0.36621007f, 
    0.01625470f, -0.21781218f, 0.16824321f, -0.12050802f, -0.01736120f, -0.25668773f, -1.02155125f, -0.12783176f, 
    0.00766638f, 0.20979042f, 0.78059953f, -0.28888187f, -0.51599592f, 0.56129229f, -0.29905027f, 0.49042165f, 
    0.11103413f, -0.07253165f, 0.38183209f, 0.09665239f, 0.25790304f, 0.02862811f, -0.28264064f, 0.34376317f, 
    0.50005186f, -0.39233965f, -0.27975121f, 0.44392669f, -0.37224507f, -0.11651571f, -0.76033819f, -0.30402324f, 
    -0.14478461f, -0.31541830f, -0.72627068f, 0.48509264f, 0.87103319f, -0.56202447f, 0.20523708f, 0.88120168f, 
    -0.20330538f, -0.01363206f, -0.07206737f, -0.34251320f, -0.27031788f, -0.12730440f, 0.35215974f, 0.06881162f, 
    -0.03549748f, 0.10303544f, -0.10377295f, 0.06371437f, -0.35647660f, -0.04024922f, 0.04607648f, -1.32521534f, 
    0.50909382f, 0.84948194f, -0.25348505f, -0.36305237f, 0.19088030f, 0.57252264f, -0.18574469f, 0.38770053f, 
    -0.08983808f, 0.43139526f, -0.06014774f, -0.47806397f, -0.15807642f, -0.15283689f, 0.37024099f, 0.08131781f, 
    -0.29698780f, -0.04581941f, -0.26233134f, 0.20892292f, 0.36629680f, 0.37029430f, 0.51470023f, 0.31402302f, 
    -1.12184656f, -0.72927040f, 0.09355409f, 0.24903965f, 0.57555723f, 0.60775971f, 0.18636680f, 0.82101715f, 
    -0.48945379f, -0.71390051f, 0.14561568f, 0.17278719f, 0.18009803f, 0.55696988f, 0.51339805f, -0.06747726f, 
    0.40436378f, -0.32458323f, -0.05369487f, 0.31731123f, 0.22352254f, -0.14458831f, -0.03277267f, -0.23779719f, 
    -0.32597536f, -0.95894659f, 1.31213582f, -0.25402233f, -0.68309820f, -0.21482651f, 0.88400227f, -0.75149077f, 
    -0.62920111f, -0.51340848f, -0.34829578f, -0.04620154f, -0.01975599f, 0.34736675f, 0.42582682f, -0.24183275f, 
    -0.23914936f, 0.02503058f, 0.14943093f, -0.21146454f, -0.20120844f, 0.03655687f, -0.13276348f, 0.04205002f, 
    -0.08266071f, -0.06003401f, 1.13143289f, 0.80887300f, 0.84127307f, 0.78934908f, 0.33178878f, -0.17533240f, 
    0.22117035f, -0.49554336f, 0.39311340f, -0.18130164f, 0.22866578f, 0.40653715f, 0.16885093f, -0.28302443f, 
    -0.20922452f, -0.12226461f, -0.17257167f, 0.29892683f, 0.03296172f, 0.07642207f, -0.26759735f, 0.55840325f, 
    0.07172267f, 0.06466218f, 0.33007750f, 0.95144290f, 0.55013490f, -0.10690217f, 0.22734278f, -0.10076082f, 
    -0.14868532f, 0.50672358f, -0.71711028f, -0.00308001f, 0.67601711f, 0.44024014f, 0.28349438f, 0.32497880f, 
    -0.15157272f, -0.36176038f, -0.01841712f, -0.07139876f, 0.29905879f, 0.16424210f, -0.01123576f, 0.21243317f, 
    0.20178317f, 0.01635555f, 0.44902319f, 0.25977087f, -0.14602977f, -0.66227174f, -0.80560267f, -0.72465867f, 
    0.78739917f, 0.54384220f, -0.34032607f, -0.99646926f, -0.47648549f, -0.51247287f, -0.03805685f, 0.31526354f, 
    0.56514430f, -0.02505864f, 0.15571120f, 0.19839036f, 0.58183342f, 0.27793512f, 0.26263127f, -0.21289733f, 
    -0.05912069f, -0.34074384f, -0.27122110f, -0.06618261f, -0.10095274f, 0.09154941f, 0.61225730f, -0.62687868f, 
    -0.85333574f, 0.11168544f, -0.01703032f, 0.32258442f, -0.51211697f, 0.60746270f, -0.71852982f, -0.27917960f, 
    -0.24956234f, -0.65732372f, 0.17298450f, 0.05915982f, -0.20747469f, 0.03522961f, -0.23889014f, -0.00537851f, 
    0.30761471f, 0.22544856f, -0.25815633f, -0.18243776f, -0.21736716f, -0.17715321f, -0.31143978f, -1.07427657f, 
    -0.21721296f, 0.14791723f, -0.08558352f, -0.82588840f, 0.82941246f, 0.45450670f, -0.18760265f, -0.13099693f, 
    -0.51469386f, -0.13428172f, -0.49414438f, 0.09968359f, -0.38694307f, -0.04629699f, -0.28501374f, -0.45083705f, 
    -0.36092323f, 0.15316267f, -0.31369996f, -0.09582257f, 0.15303780f, -0.08463537f, 0.00507736f, -1.22904384f, 
    0.47559530f, -0.17752174f, -0.61297661f, -0.19955660f, 0.47297761f, -0.52498972f, -0.33365902f, 0.68596607f, 
    0.07425741f, -0.42384526f, -0.45593458f, -0.08004646f, 0.34679675f, 0.19089903f, -0.34290034f, 0.08286107f, 
    -0.43640879f, -0.10721356f, -0.28862792f, -0.29527280f, 0.08578289f, 0.14914557f, 0.18187250f, -0.14181668f, 
    -0.37083724f, -0.80481422f, -0.28782758f, 0.31093195f, 0.11253287f, 0.06706695f, 1.16530645f, -0.89606375f, 
    0.63061827f, -0.01719457f, 0.59530044f, -0.02098184f, -0.09854761f, 0.08870829f, -0.15593731f, -0.77525824f, 
    -0.28307739f, -0.45654523f, -0.26009572f, -0.32954729f, -0.13999122f, 0.24918252f, 0.06721696f, -0.06470183f, 
    -0.04604537f, 1.16991484f, -0.38904744f, -0.42234290f, 0.47119844f, 0.29967856f, 0.63688922f, 0.60397357f, 
    0.16666168f, 0.20200059f, 0.66886890f, -0.51913679f, 0.19421275f, -0.26651379f, -0.39246753f, -0.10118558f, 
    -0.08987734f, -0.36675096f, -0.37087837f, 0.33389363f, 0.17473957f, 0.27934715f, -0.14479068f, 0.50055367f, 
    -0.02287041f, -0.14166778f, -1.09905732f, -0.63374001f, -0.28590241f, 0.02212715f, 0.17235361f, -1.34433150f, 
    0.22229195f, -0.27586693f, -0.67271990f, 0.13590875f, 0.31926131f, 0.17893012f, 0.29539433f, -0.01691580f, 
    0.28671372f, -0.26424867f, 0.00698268f, 0.49065855f, 0.14877613f, -0.08744126f, 0.01653065f, -0.13708220f, 
    -0.41084781f, 0.03994205f, -0.04890568f, -0.07528351f, 1.11455941f, -0.19534925f, -0.06571591f, 0.36939684f, 
    0.23722728f, 0.82284713f, 0.35041848f, -0.39706787f, 0.41937587f, -0.07634512f, 0.24296412f, 0.28834444f, 
    -0.70243955f, 0.10889015f, -0.06507468f, -0.25683662f, -0.19911881f, 0.07947118f, -0.36569053f, -0.03482091f, 
    0.25866312f, 0.12865137f, 0.13251284f, 0.26894912f, 0.46157831f, 0.62563485f, 0.43163541f, 0.91386926f, 
    0.22703722f, 0.41706505f, 0.54415089f, 0.58990020f, 0.43309057f, 0.50114000f, -0.34728435f, -0.02919109f, 
    -0.10842410f, 0.21045884f, -0.26800030f, 0.00840766f, 0.14050472f, 0.21283737f, -0.01060632f, -0.23176642f, 
    -0.06155586f, -0.38152963f, -0.39233080f, -0.18687323f, 0.04736622f, -0.52031690f, -0.84369403f, -1.11270905f, 
    -0.60537064f, -0.30457771f, 0.43271109f, -0.11459161f, 0.19361767f, 0.28165644f, 0.41339812f, -0.57786852f, 
    -0.21295564f, 0.41227093f, -0.17168744f, -0.41983739f, -0.12541060f, 0.29502490f, 0.25112143f, 0.15354843f, 
    -0.23922923f, -0.17783205f, 0.09733514f, -0.36417732f, 0.37916595f, 0.21208511f, -0.50512731f, 0.68439054f, 
    0.47570989f, 0.03890062f, 0.51033956f, -1.25587308f, -0.11715488f, -0.46943080f, -1.10140789f, 0.12083446f, 
    -0.17260720f, 0.31637773f, 0.23490278f, 0.24724929f, -0.12452055f, -0.03083123f, -0.48573387f, 0.12538627f, 
    -0.27519172f, -0.61290032f, -0.09233081f, 0.12869363f, 0.26000568f, 0.20228538f, -0.10013327f, 0.09022377f, 
    1.05551887f, 0.49326229f, -1.00682318f, -0.18521643f, -0.25271663f, -0.31228656f, -0.61502612f, -1.06587374f, 
    -0.46010646f, 0.34093067f, 0.39553460f, 0.07300900f, -0.06058230f, 0.07668220f, 0.13836132f, 0.09150565f, 
    -0.21815288f, 0.04900457f, 0.31627569f, 0.35865945f, -0.15945575f, 0.12062746f, -0.35718471f, -0.03477572f, 
    0.99576509f, 1.09214795f, -0.02360190f, -0.08805481f, -0.51945257f, -0.16234078f, 0.29993683f, -0.09144326f, 
    0.59667677f, 0.69281060f, 0.20387782f, 0.21779700f, -0.39798862f, -0.18795080f, 0.36100829f, -0.02604655f, 
    -0.32242709f, -0.28113875f, 0.13879281f, 0.26300815f, -0.39733103f, 0.11952121f, -0.07744774f, -0.05838850f, 
    0.14841402f, -0.42469639f, 0.24499838f, 0.75829059f, 0.94798458f, 0.40225583f, 0.38371545f, -0.05749706f, 
    0.13807125f, -0.09042055f, 0.07107869f, -0.42639852f, -0.28906363f, -0.08537798f, -0.15015419f, -0.38540801f, 
    -0.51975471f, -0.15124974f, 0.10265364f, -0.36223298f, -0.50056225f, -0.24153416f, -0.20232840f, 0.08064167f, 
    0.18127362f, -0.25859642f, 0.75454968f, 0.48455611f, -1.12212026f, -1.40001142f, -0.61508095f, 0.29215622f, 
    -0.08194651f, 0.17933014f, 0.14254504f, 0.26770416f, -0.21655537f, 0.27982983f, 0.20538108f, -0.09295983f, 
    -0.46393460f, 0.13539624f, 0.07752395f, 0.34580433f, -0.08009020f, 0.12666264f, -0.21611731f, 0.02996189f, 
    -0.29223350f, -0.09739734f, 0.29925689f, -0.24970984f, 0.12012185f, 0.09084368f, -0.99125528f, -0.49808261f, 
    0.53672242f, -0.49922979f, -0.01485374f, -0.34140277f, -0.06279410f, 0.51665092f, 0.39860505f, 0.08145099f, 
    0.39436442f, -0.19754428f, -0.36399654f, 0.32646164f, -0.28011420f, -0.00085640f, 0.44570082f, 0.18370707f, 
    0.46535891f, 0.33234781f, 0.42600089f, 0.12605222f, 0.76718980f, 0.95657194f, 1.04207933f, 0.85562152f, 
    0.16856325f, -0.14266664f, -0.49839970f, -0.70334572f, -0.31801996f, 0.12379558f, 0.45983833f, 0.09130111f, 
    -0.00337972f, 0.57063371f, -0.26873729f, 0.53501582f, 0.02822326f, 0.38686252f, -0.19736050f, -0.30152118f, 
    0.12353200f, -0.03888428f, 0.13514037f, -0.03864432f, 0.02870487f, -0.79656500f, -1.02141809f, 0.57898933f, 
    0.95971060f, 0.41225278f, 0.68698955f, 0.82104313f, 0.39783600f, -0.38345191f, 0.23350087f, -0.33615795f, 
    -0.23695152f, 0.24418139f, 0.65972340f, 0.07256067f, 0.12449337f, -0.20282464f, 0.00472222f, -0.00932138f, 
    -0.18797107f, 0.03599272f, 0.25807267f, 0.02511930f, 0.29003116f, -0.25091255f, 0.00509694f, -0.07993504f, 
    0.07535081f, 0.59286010f, 0.24454522f, -0.24308883f, 0.50412923f, 0.94917881f, 0.69530326f, 0.28981006f, 
    -0.18569754f, -0.49756122f, -0.63966173f, -0.48331365f, -0.46310085f, -0.20935142f, -0.00377121f, -0.34851515f, 
    0.32075816f, -0.24822916f, 0.02073121f, 0.31162256f, -0.42375150f, 0.05842071f, 0.14926043f, -0.07470225f, 
    -0.77660620f, -0.54946339f, -0.16714859f, -0.10680094f, -0.48977926f, 0.76120085f, 0.98242283f, -0.58293343f, 
    -0.11713902f, 0.31387833f, 0.03290921f, -0.31856570f, -0.52665561f, -0.60349220f, -0.37781793f, 0.33903939f, 
    0.15543979f, 0.10090774f, -0.42072237f, -0.18801624f, 0.16458321f, 0.03475304f, -0.32487100f, -0.15744495f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.24648502f, 0.12520230f, 0.39633542f, 0.24074934f, -0.16223912f, 0.35610387f, 0.12297782f, 0.22267728f, 
    0.25761631f, 0.08017807f, 0.27381811f, 0.19381438f, 0.34956309f, 0.06525631f, 0.32162368f, 0.07506306f, 
    0.18742704f, 0.08005121f, 0.29727882f, 0.09254411f, 0.00698336f, -0.04957787f, 0.44409856f, 0.26094243f, 
    0.19353706f, 0.13730003f, 0.22554414f, 0.10544094f, 0.33826724f, 0.28064746f, 0.13950208f, 0.00359711f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.00795766f, 0.00441877f, -0.03050573f, -0.01331549f, -0.04446115f, 0.02890227f, 0.01890011f, 0.00473255f, 
    0.04080429f, 0.03988143f, -0.03800037f, -0.03963625f, -0.01968458f, -0.01611192f, -0.04130084f, -0.00460724f, 
    -0.02481127f, -0.00095276f, 0.03510610f, -0.01722732f, -0.04408392f, -0.00585300f, -0.04550363f, -0.01004642f, 
    -0.00465836f, 0.00774721f, -0.05047540f, -0.03113934f, 0.00177998f, 0.00662248f, 0.01885465f, -0.04960828f, 
    0.02057738f, -0.03577321f, 0.00244942f, 0.03160455f, -0.03796795f, -0.01780035f, -0.00943988f, -0.00233117f, 
    0.00303021f, -0.00404340f, -0.05056546f, -0.05338908f, 0.04010734f, -0.02682833f, 0.02655653f, 0.00855597f, 
    -0.04463302f, -0.03097461f, -0.01685385f, -0.03941270f, 0.04437974f, 0.01150768f, 0.02399859f, 0.02740569f, 
    -0.01566457f, -0.04970573f, 0.01169375f, -0.04383601f, 0.00558497f, 0.00720660f, -0.04679488f, -0.02146360f, 
    0.01242391f, 0.03175610f, -0.04606419f, 0.04238852f, 0.04178287f, -0.05032298f, 0.03693973f, 0.02223202f, 
    -0.03735789f, 0.04397598f, -0.03739932f, 0.02973033f, -0.02421517f, 0.03036012f, -0.02950167f, -0.03401146f, 
    0.04013419f, -0.05523242f, -0.03038026f, 0.02540493f, -0.04952755f, -0.03102034f, 0.01731645f, -0.01690891f, 
    -0.00980302f, -0.01932747f, 0.00540919f, 0.03132910f, -0.04185230f, 0.01868892f, -0.03919355f, 0.02210359f, 
    -0.00295516f, 0.03561088f, -0.01469516f, -0.03524588f, 0.00338807f, 0.01578255f, -0.03229538f, -0.03948742f, 
    -0.03490525f, 0.03701377f, 0.00075584f, -0.00663059f, 0.03543619f, -0.00683785f, -0.05569652f, -0.00982197f, 
    -0.00294287f, -0.03906430f, -0.01822555f, 0.02905559f, -0.05003213f, -0.02387186f, -0.03396713f, -0.01749861f, 
    0.01085915f, 0.03171620f, -0.00081235f, -0.05248804f, 0.01504206f, 0.03880817f, 0.01874417f, 0.01034855f, 
    -0.04663488f, -0.03321706f, 0.00477060f, 0.01993257f, -0.05266337f, 0.02644595f, -0.00769618f, -0.05391417f, 
    -0.03566572f, -0.05503422f, 0.03583528f, -0.02000167f, -0.02218998f, -0.02534811f, 0.00444483f, -0.05495219f, 
    -0.00569847f, -0.03087520f, -0.04964592f, 0.04319123f, 0.02511179f, -0.00215996f, -0.00320392f, -0.02051072f, 
    0.04543634f, -0.04169165f, 0.00532209f, 0.04116969f, 0.04320578f, -0.00951830f, 0.02499965f, 0.03145033f, 
    -0.02549588f, 0.01710329f, 0.00135088f, -0.05592664f, -0.01096469f, 0.01381138f, -0.02193202f, 0.01199530f, 
    0.01066145f, 0.00947894f, -0.02865842f, -0.00420090f, 0.00419422f, -0.05616335f, 0.01546264f, 0.00113304f, 
    -0.00585565f, 0.02197002f, 0.01225124f, 0.02543452f, 0.00350420f, 0.00229655f, -0.05460686f, -0.00706700f, 
    -0.03335759f, 0.00804206f, 0.03840917f, -0.00362133f, -0.02063038f, -0.01038217f, -0.02045118f, 0.00717856f, 
    0.02103760f, -0.05508661f, -0.05477511f, -0.03799396f, 0.03631993f, 0.01418867f, -0.00756403f, -0.00561069f, 
    -0.01483763f, 0.04129268f, -0.03945268f, 0.02362737f, -0.04137244f, -0.04953897f, -0.04950658f, 0.00125369f, 
    -0.05049327f, -0.03266779f, -0.00980224f, -0.00308582f, -0.04310255f, -0.05578932f, -0.05252533f, -0.03708674f, 
    -0.04865714f, 0.01795288f, -0.02796993f, -0.01144832f, -0.00071528f, -0.04108883f, -0.00932205f, 0.03592338f, 
    -0.03624072f, 0.02833037f, 0.00163426f, 0.02274061f, -0.04600962f, -0.01378600f, 0.01264556f, 0.03479528f, 
    -0.04426830f, 0.02220162f, 0.03335159f, -0.00562721f, 0.04110806f, 0.01008383f, -0.03575785f, 0.00354088f, 
    -0.03349321f, -0.00167130f, -0.01560197f, 0.04050267f, -0.03751653f, -0.00911512f, 0.03052448f, 0.02242460f, 
    0.02399986f, 0.00998942f, 0.03311773f, -0.04162836f, -0.01257044f, -0.02103386f, -0.05178956f, -0.03998090f, 
    0.01312014f, 0.00533051f, -0.03220156f, -0.02260829f, 0.04208341f, 0.02912382f, 0.01308729f, 0.02044864f, 
    -0.03478391f, -0.01228791f, -0.04206192f, -0.04344789f, -0.00301556f, -0.03241416f, -0.00733650f, -0.05255974f, 
    0.02370796f, 0.02223836f, -0.05422302f, 0.00841169f, -0.02279515f, 0.00259305f, -0.02911880f, -0.05073030f, 
    -0.02520402f, -0.03214587f, -0.05206057f, -0.03385273f, -0.01464897f, -0.05095220f, 0.01198295f, -0.03688048f, 
    -0.04824353f, -0.00300951f, 0.01286532f, -0.02601764f, 0.01257290f, 0.04505405f, -0.00687982f, 0.02048615f, 
    0.03174375f, -0.02686424f, -0.01231436f, -0.05589283f, -0.02831174f, -0.03152382f, -0.04881531f, -0.03432921f, 
    -0.00320639f, -0.04169714f, 0.03734426f, -0.01509524f, 0.02351242f, -0.05125421f, 0.04168239f, 0.00370602f, 
    -0.00474845f, 0.02944885f, -0.05297676f, 0.00874386f, -0.02195917f, -0.02110583f, 0.02745154f, -0.02392327f, 
    -0.04017317f, -0.03092454f, -0.02866509f, 0.01606133f, -0.04589131f, -0.01923058f, -0.00667754f, 0.03320433f, 
    0.01847526f, 0.03550469f, 0.03637518f, -0.03077859f, -0.03669053f, -0.03899260f, -0.05064603f, -0.02067160f, 
    0.02102739f, -0.05340459f, 0.03233748f, -0.00887463f, 0.03611231f, 0.03777257f, 0.02575554f, -0.01806036f, 
    -0.04109240f, -0.04408658f, -0.01555822f, -0.04982169f, -0.04654977f, -0.02219416f, -0.00229992f, -0.02134344f, 
    0.03058032f, 0.03616426f, 0.04250991f, 0.04483686f, 0.02212860f, 0.00269041f, 0.02987348f, 0.02589860f, 
    -0.03580982f, -0.00143840f, -0.02869929f, -0.03317646f, 0.04115738f, -0.04271292f, 0.04207392f, -0.03329599f, 
    0.01470745f, -0.04378489f, 0.00220352f, -0.00887441f, 0.03744743f, 0.03233583f, -0.04265929f, -0.04063175f, 
    -0.00550974f, -0.00447780f, -0.01494628f, -0.05047362f, -0.00394101f, -0.01959787f, 0.01521521f, 0.03525818f, 
    0.33059216f, -0.11977842f, -0.31368414f, -0.08133452f, -0.14683622f, -0.09764235f, -0.02036434f, 0.07071228f, 
    -0.04240081f, -0.06439082f, 0.01839397f, -0.05256329f, -0.19755411f, 0.46239436f, 0.10356854f, -0.56162763f, 
    0.12939237f, -0.05731143f, 0.01072021f, -0.04891990f, 0.02290423f, 0.11629926f, -0.06435601f, -0.11848491f, 
    0.03778515f, -0.03947553f, -0.08104473f, 0.01044906f, -0.12444834f, 0.05656548f, 0.00940685f, -0.13893096f, 
    -0.06470092f, 0.05608286f, 0.10519861f, 0.03735147f, 0.23835811f, -0.39859939f, 0.09831975f, 0.21595821f, 
    0.08037270f, -0.17238502f, 0.02527473f, 0.00007926f, 0.07195976f, -0.03036879f, -0.03188366f, -0.15659022f, 
    -0.26834980f, -0.50204200f, -0.16842368f, 0.03821405f, 0.16372719f, 0.06185880f, 0.06656272f, 0.09114048f, 
    0.04467983f, -0.01906167f, 0.08575800f, 0.09855174f, -0.13912734f, 0.25886935f, -0.07804241f, -0.10818464f, 
    0.08856957f, 0.06392166f, 0.15678553f, -0.13882710f, 0.05966677f, 0.09834993f, -0.01140105f, 0.14989744f, 
    -0.02978792f, 0.00249500f, -0.22939332f, 0.01577258f, 0.12889224f, 0.09129019f, 0.08810065f, -0.17588241f, 
    0.03030549f, 0.15104413f, 0.09801490f, 0.07028771f, 0.23008651f, -0.40647542f, -0.06631545f, 0.37409866f, 
    0.01565184f, -0.10154115f, 0.07663896f, -0.08195814f, -0.04916200f, 0.03802297f, 0.02178770f, -0.00801492f, 
    0.23101580f, -0.22714475f, -0.23054175f, 0.10080879f, 0.02593908f, 0.03540832f, 0.08525833f, 0.13061365f, 
    0.13563590f, 0.16403796f, -0.13590942f, 0.13606173f, -0.53265876f, -0.34210539f, 0.30043483f, 0.56445283f, 
    0.10197997f, -0.03063108f, 0.15414613f, 0.05341019f, -0.18227059f, 0.06361081f, 0.04003166f, 0.10715352f, 
    -0.30846962f, 0.30314115f, 0.19345655f, -0.26213306f, 0.00730403f, 0.06473307f, 0.11069500f, -0.08415142f, 
    -0.07330228f, 0.05862742f, 0.20238911f, 0.07394277f, -0.19634381f, 0.39960545f, 0.30416584f, -0.15868470f, 
    0.06362384f, -0.01849573f, 0.06465994f, -0.09140993f, 0.12937580f, 0.03602005f, -0.05594588f, 0.00203314f, 
    -0.02063449f, 0.23644969f, -0.29215184f, 0.01194684f, 0.06411715f, 0.01194725f, -0.10043657f, -0.07226417f, 
    0.07938617f, 0.07295153f, -0.01858792f, 0.09488302f, -0.09712314f, -0.07559180f, -0.16854769f, 0.57222146f, 
    0.04346957f, -0.03412672f, -0.13298295f, -0.02107583f, 0.06737785f, 0.06721950f, 0.07714621f, -0.04680666f, 
    0.55188262f, 0.00810129f, -0.12368272f, -0.18422350f, 0.18082517f, 0.21148223f, 0.04512746f, 0.00648190f, 
    -0.04517991f, -0.03337707f, 0.03887912f, 0.03584978f, -0.29770043f, -0.03905693f, 0.12641898f, 0.28878736f, 
    0.11711048f, 0.15883979f, 0.09684616f, -0.06051817f, -0.20881520f, 0.07946006f, -0.00543980f, -0.03075965f, 
    -0.15602222f, -0.04858587f, 0.18038289f, -0.23650128f, -0.12018503f, -0.05226281f, 0.06715184f, -0.13515154f, 
    -0.04565930f, -0.06323213f, 0.06007817f, -0.12432458f, -0.14552851f, 0.13983120f, 0.33565685f, -0.26891148f, 
    0.00945699f, -0.06781571f, -0.05487992f, 0.08109740f, 0.25283095f, -0.04561462f, -0.07305601f, 0.14475504f, 
    0.56595081f, -0.14937970f, -0.00058278f, -0.00299581f, 0.10528854f, 0.15104887f, 0.15420605f, 0.05227483f, 
    -0.08396733f, 0.02721731f, 0.04233067f, -0.04966437f, 0.01269735f, -0.10565362f, 0.13980775f, 0.19941515f, 
    -0.06239678f, 0.09724744f, 0.11321681f, -0.10770874f, 0.13785201f, 0.16886918f, 0.08627187f, 0.13011310f, 
    0.02612038f, 0.38260144f, 0.38401088f, -0.16844840f, 0.12346826f, 0.07375999f, -0.00080537f, -0.13801354f, 
    0.07077456f, -0.05097704f, 0.00069481f, 0.05772672f, 0.02212399f, 0.14557530f, 0.10532334f, 0.03615588f, 
    0.20336199f, 0.31017110f, -0.00938428f, -0.08259568f, 0.01028345f, 0.15648925f, 0.07082634f, 0.03814986f, 
    0.45384532f, -0.14539973f, -0.09074683f, -0.16275421f, -0.03227318f, -0.01818787f, 0.07801925f, 0.17299514f, 
    -0.14559756f, 0.03435608f, -0.02863878f, 0.10149125f, -0.00640819f, -0.32483089f, -0.15669779f, 0.19747119f, 
    0.08544341f, 0.01752109f, -0.09333204f, 0.08682134f, -0.22520216f, 0.00943771f, -0.00891925f, 0.13265081f, 
    -0.09022206f, 0.28865352f, 0.23838866f, 0.37934127f, 0.19920808f, 0.00045030f, 0.13066745f, -0.09654666f, 
    -0.04666409f, -0.07785986f, 0.07946641f, -0.13210434f, 0.16151027f, 0.05570738f, 0.13682503f, -0.23802355f, 
    0.05529084f, 0.14173196f, -0.02801457f, -0.10984891f, -0.13697523f, -0.04094733f, 0.01527431f, -0.00079337f, 
    0.35269371f, 0.09177590f, -0.19140795f, 0.34789810f, 0.18684065f, 0.01625580f, -0.02554326f, -0.05460196f, 
    0.09949701f, -0.13871627f, 0.01868922f, -0.13573474f, -0.18821871f, 0.00124149f, -0.15054029f, 0.32700861f, 
    0.09612480f, 0.09030764f, -0.08456179f, -0.00784068f, 0.07888470f, -0.04693577f, -0.18541819f, -0.04705022f, 
    -0.01077781f, 0.54372191f, 0.16064546f, -0.50399292f, 0.10934327f, 0.01215417f, 0.01646160f, -0.04380689f, 
    -0.04269777f, 0.15100230f, 0.02113344f, 0.05416271f, 0.37649044f, -0.36988875f, -0.11068855f, -0.15088858f, 
    -0.00589708f, 0.05446742f, 0.04043766f, -0.13094090f, 0.06816541f, 0.06340413f, 0.08687751f, 0.08833534f, 
    0.24232896f, -0.17241076f, 0.11617220f, -0.22420838f, 0.12602925f, 0.05215403f, -0.08134053f, -0.04140112f, 
    0.21091720f, -0.08268033f, -0.02078850f, 0.05385256f, 0.52039862f, -0.03672758f, -0.10689485f, 0.21413741f, 
    0.04192605f, -0.03577598f, -0.06618824f, 0.00918986f, 0.07317480f, -0.10742271f, 0.13627002f, -0.09860283f, 
    -0.00421296f, -0.03471191f, 0.01115860f, -0.01553016f, -0.03473313f, -0.04120712f, -0.00510633f, -0.01931557f, 
    -0.00686823f, 0.01839204f, 0.01608641f, -0.05689767f, -0.04104033f, -0.04426787f, 0.01699710f, 0.02330771f, 
    -0.04548560f, 0.00215912f, 0.00595186f, -0.00268255f, 0.02047694f, -0.04384509f, -0.01051644f, -0.01745076f, 
    -0.03289929f, 0.04346735f, -0.01252734f, -0.04726024f, 0.01652743f, -0.05311214f, -0.00885772f, -0.02167541f, 
    0.02392449f, 0.03570783f, 0.00875113f, 0.01231899f, -0.03446337f, -0.01868493f, 0.01446234f, -0.02139809f, 
    0.03974572f, 0.01736023f, -0.05352450f, -0.04115041f, -0.03103710f, -0.02415184f, -0.03873946f, -0.03113053f, 
    0.03643015f, -0.00700444f, -0.03538337f, -0.03240857f, -0.02571634f, 0.03947699f, 0.04410195f, 0.01631032f, 
    -0.01451115f, 0.03804244f, -0.01452968f, 0.00512148f, -0.05436092f, -0.02086220f, 0.00861819f, 0.04217397f, 
    0.00881965f, -0.04439269f, 0.02979488f, -0.02549053f, 0.03743785f, -0.01683811f, -0.02714666f, -0.01222543f, 
    -0.01943301f, -0.05585235f, -0.00223104f, 0.04021213f, -0.00806028f, 0.04414908f, 0.01320137f, -0.04618416f, 
    -0.01934096f, 0.02571765f, -0.03170766f, -0.02258352f, -0.01472914f, 0.00366619f, 0.00477954f, 0.03721562f, 
    0.02417382f, -0.03116790f, -0.05204291f, 0.00088973f, -0.02347883f, -0.00137259f, 0.04108104f, -0.02943801f, 
    -0.04243932f, -0.01607127f, -0.03557268f, -0.03200829f, 0.00680166f, -0.02845415f, 0.00329507f, -0.03414636f, 
    0.02439185f, -0.02434592f, 0.03991227f, -0.01827753f, -0.05397207f, -0.01316463f, 0.00041431f, -0.05045380f, 
    0.00085138f, -0.03084735f, -0.00683638f, -0.03999344f, -0.05589084f, 0.01351082f, -0.00077337f, -0.05568507f, 
    -0.02157543f, -0.02091780f, 0.03090129f, 0.02319011f, -0.03248163f, -0.01900357f, 0.01823382f, -0.02970058f, 
    -0.02064017f, -0.04509819f, -0.04317379f, -0.02925931f, -0.01951484f, -0.04915439f, -0.03224811f, -0.02944214f, 
    -0.02071357f, -0.04660033f, 0.03553338f, 0.01193531f, -0.03347320f, 0.04355584f, 0.00606010f, 0.03387858f, 
    -0.01627509f, -0.00950734f, 0.01239281f, -0.03150471f, -0.05392407f, -0.01397012f, -0.03437688f, -0.00091940f, 
    -0.05376502f, -0.01038397f, -0.05389145f, 0.04066257f, 0.04464273f, 0.04446045f, 0.00889716f, 0.03615778f, 
    0.03384895f, -0.03044766f, 0.02072820f, -0.03805719f, 0.03880541f, -0.05367974f, -0.05220763f, -0.02740254f, 
    0.04071843f, -0.01890263f, 0.00901335f, 0.02733509f, 0.00517752f, 0.00212955f, -0.04008376f, -0.03552076f, 
    -0.01165856f, 0.03764800f, -0.00155213f, 0.03861454f, -0.04749434f, -0.01150969f, 0.02714501f, 0.03652727f, 
    0.01610974f, 0.02546621f, -0.05618788f, -0.02184660f, 0.03070499f, -0.01481036f, -0.03596464f, 0.03645117f, 
    0.00466855f, -0.04451394f, -0.02119720f, -0.04049484f, -0.00539478f, -0.01135303f, -0.01840465f, -0.05682471f, 
    0.02424555f, -0.01880987f, -0.02361138f, 0.01665777f, -0.01345656f, 0.00079760f, 0.04332633f, 0.02351183f, 
    -0.04715543f, 0.00740848f, 0.01104925f, -0.04350989f, -0.03311040f, -0.00422288f, -0.01951175f, 0.02282222f, 
    -0.04574320f, 0.04046157f, 0.03584492f, -0.05400911f, 0.03449368f, -0.02369656f, -0.05306939f, -0.05450758f, 
    0.02228478f, 0.01684958f, -0.03257551f, -0.01494154f, 0.03117228f, -0.00361782f, 0.01628553f, -0.01379786f, 
    0.01729678f, -0.01496611f, -0.00794753f, -0.05522916f, 0.02985046f, 0.02742883f, 0.03902724f, -0.00292824f, 
    0.01717765f, -0.04892643f, -0.01628280f, 0.02708940f, 0.02124969f, -0.00774554f, -0.00071900f, -0.05049747f, 
    -0.02335231f, 0.03733836f, 0.04320933f, 0.00225390f, -0.03545740f, -0.02066839f, -0.01272436f, 0.04198580f, 
    0.02868128f, -0.03309948f, 0.04401900f, -0.01878935f, -0.01300235f, -0.03953747f, -0.02054886f, -0.04367035f, 
    0.03984462f, -0.02057679f, 0.00701428f, 0.02300390f, -0.02273412f, 0.03284517f, -0.01788473f, 0.02852047f, 
    -0.02242711f, 0.00235055f, -0.03791765f, -0.00746849f, -0.00222380f, -0.00954822f, -0.00855818f, 0.03648664f, 
    -0.04920024f, -0.02143816f, -0.03171512f, 0.03080872f, 0.03618206f, 0.02140219f, 0.00099990f, 0.02780490f, 
    -0.02383812f, 0.02222992f, -0.03933087f, -0.04804515f, -0.04652912f, -0.04835338f, -0.04274337f, -0.02354997f, 
    -0.03745390f, -0.03015309f, 0.00105398f, 0.01118585f, 0.01574494f, 0.02544662f, -0.05123204f, 0.02876689f, 
    -0.03337697f, -0.02344312f, 0.04501970f, 0.03274233f, -0.03814775f, 0.01763832f, 0.01832168f, -0.02273765f, 
    0.03982989f, -0.04297553f, -0.00170207f, -0.04103016f, -0.01016906f, -0.05630043f, -0.03036518f, 0.02587867f, 
    -0.02804291f, -0.02576598f, -0.04927636f, 0.00415725f, 0.02714814f, -0.02474134f, 0.03783645f, 0.00610792f, 
    0.03933724f, 0.02145154f, 0.03827972f, -0.00876585f, -0.02103938f, -0.01641129f, 0.03441847f, -0.04236902f, 
    -0.04586006f, 0.02982866f, -0.05463600f, 0.01342802f, -0.02356138f, 0.01580987f, -0.05577638f, -0.01558469f, 
    -0.01737888f, 0.01528662f, 0.03438965f, -0.00572427f, -0.03408355f, -0.02947302f, -0.02101422f, -0.00313448f, 
    0.02869166f, -0.01541995f, -0.03753136f, -0.04611078f, -0.04225504f, -0.00408573f, -0.04501712f, 0.01958167f, 
    -0.03302383f, -0.03690276f, -0.05539215f, -0.02564284f, -0.03679829f, -0.01905422f, -0.01827629f, 0.01014118f, 
    0.02934236f, -0.00267511f, 0.03461508f, -0.02570317f, -0.04750219f, 0.02727082f, 0.00721670f, 0.03629594f, 
    -0.02148721f, -0.03368965f, -0.05303934f, -0.02125232f, 0.01073778f, 0.00744412f, -0.01993411f, -0.03407556f, 
    -0.04011909f, -0.02386307f, 0.01613626f, -0.04207878f, -0.03502450f, -0.03970302f, -0.01327224f, 0.03121428f, 
    -0.05211413f, -0.01358720f, -0.00532828f, -0.00760187f, 0.02277665f, 0.04716224f, -0.03762294f, -0.04539094f, 
    -0.03516716f, 0.03889630f, 0.02152124f, 0.01390227f, 0.02206406f, -0.00444349f, -0.01861611f, 0.03814782f, 
    -0.05286400f, 0.03721024f, -0.04628263f, -0.01352588f, 0.01662373f, 0.00487210f, -0.03602337f, -0.04331352f, 
    0.03762192f, 0.03206714f, -0.02132858f, -0.02866586f, 0.03466529f, 0.00102354f, 0.03951843f, 0.02598105f, 
    0.03316739f, -0.00978583f, -0.01799553f, 0.01438278f, 0.02678381f, 0.03625960f, 0.03791870f, -0.00622576f, 
    -0.00619173f, 0.01472726f, 0.01291981f, 0.00517165f, 0.03317939f, -0.01011167f, 0.02082942f, -0.03862920f, 
    -0.00747375f, 0.03828070f, -0.02331466f, 0.03017670f, -0.02134225f, -0.01808472f, 0.02066574f, -0.03205953f, 
    -0.03703069f, 0.03178916f, -0.03092809f, -0.03826012f, 0.00298152f, 0.01410586f, -0.05394320f, 0.04662368f, 
    0.02183911f, -0.00030502f, -0.04158087f, 0.02936497f, -0.02899749f, 0.00684302f, 0.03758969f, -0.01007641f, 
    0.04779932f, -0.03058606f, 0.01640067f, 0.04432459f, -0.00459677f, -0.00984004f, 0.01917589f, 0.00397404f, 
    -0.00535939f, -0.01457849f, -0.00052405f, -0.01146427f, -0.05042339f, -0.00222785f, 0.01921750f, -0.01208664f, 
    -0.04757604f, -0.01538061f, 0.04044189f, -0.04326062f, 0.03060382f, -0.03903441f, -0.00863960f, 0.04444982f, 
    0.01140759f, 0.01487554f, -0.01309573f, -0.04851344f, -0.03488597f, -0.01353613f, -0.02571829f, -0.04925450f, 
    0.00579320f, -0.01079532f, -0.02265063f, 0.04833581f, 0.02633738f, -0.00501276f, 0.00054288f, -0.03394739f, 
    -0.01163093f, -0.01823094f, -0.01214147f, 0.03318888f, 0.02454411f, 0.03911491f, -0.05121526f, 0.00821553f, 
    0.03764329f, -0.01516007f, -0.05434960f, 0.01844675f, -0.02880697f, 0.02131307f, -0.03664936f, 0.03787808f, 
    -0.04689798f, -0.04152004f, 0.00240086f, -0.03442722f, -0.00650139f, -0.03733115f, 0.03324387f, 0.02016002f, 
    0.02649686f, -0.02757717f, 0.00617942f, 0.00519061f, -0.05218133f, 0.05009157f, 0.02086303f, -0.00398785f, 
    0.01780513f, 0.02841119f, 0.01752926f, -0.03807878f, -0.02908138f, -0.01077037f, 0.04347539f, 0.00937110f, 
    0.00380592f, -0.04501942f, 0.04560609f, -0.01443583f, -0.05089856f, -0.04199643f, -0.04079765f, -0.02685353f, 
    0.02422475f, 0.03648409f, -0.02274333f, 0.01261565f, -0.02716274f, -0.00496682f, -0.04277095f, -0.00216923f, 
    -0.03161896f, -0.00015151f, -0.01901485f, -0.02321763f, -0.02879076f, -0.00314374f, 0.00637726f, -0.00662620f, 
    0.00107320f, -0.01003810f, 0.03248354f, 0.01102701f, -0.02925296f, 0.02931147f, 0.01958881f, -0.00634040f, 
    -0.03957015f, -0.04106240f, -0.01201483f, 0.02733354f, 0.00665009f, -0.02367876f, -0.04857940f, -0.03803907f, 
    -0.03331126f, 0.00606195f, -0.00119241f, 0.00223215f, 0.03270797f, 0.03887670f, 0.01450007f, -0.01890050f, 
    -0.04259981f, -0.04625115f, 0.04214547f, -0.01814654f, -0.03203940f, 0.04313582f, 0.03171670f, -0.03686682f, 
    -0.03056877f, 0.00525791f, 0.01430443f, 0.03802615f, -0.00450661f, -0.01581248f, 0.03493895f, -0.03131584f, 
    -0.03695338f, -0.05451407f, 0.02093900f, 0.03158987f, 0.04100438f, 0.03271501f, -0.04584231f, 0.03690403f, 
    -0.03676315f, -0.02960168f, -0.02706126f, -0.02541990f, -0.04561892f, -0.00898308f, 0.05355692f, 0.04340428f, 
    -0.04430119f, -0.02268275f, 0.01248612f, -0.03546024f, 0.01493133f, -0.03726216f, 0.03288894f, 0.02571941f, 
    -0.04132577f, 0.05015305f, 0.01705956f, -0.04196229f, 0.01091291f, 0.03294475f, -0.03136319f, -0.00921004f, 
    -0.00807889f, -0.01366919f, -0.03987291f, -0.04355092f, 0.03037307f, -0.01036675f, -0.01073095f, -0.00391454f, 
    -0.03380041f, -0.01191555f, 0.00502019f, -0.01585255f, 0.01027884f, 0.00876127f, -0.02522440f, 0.03806407f, 
    -0.03636751f, 0.00381859f, -0.05419986f, 0.04565603f, 0.01732405f, 0.03404512f, -0.02785222f, -0.04912057f, 
    -0.02951040f, -0.04974600f, 0.03105835f, 0.02459968f, -0.05057498f, -0.03444963f, -0.02671264f, -0.02916007f, 
    -0.02560667f, -0.03167754f, 0.04577454f, -0.04756073f, 0.04363199f, -0.01544822f, -0.00950848f, 0.04534727f, 
    -0.01025604f, 0.00226999f, -0.04887306f, 0.02067502f, -0.03568602f, -0.00553462f, -0.04355637f, -0.05325717f, 
    0.01283520f, 0.04733665f, -0.01460771f, 0.02063761f, 0.01721088f, 0.01188648f, 0.00394766f, -0.02907430f, 
    -0.05246978f, 0.04682084f, -0.00134370f, -0.03983520f, -0.02302252f, 0.01744837f, -0.01506780f, 0.03136609f, 
    0.03545344f, -0.04070818f, -0.01051366f, -0.03194550f, 0.00672566f, 0.03267435f, -0.03548513f, -0.04664206f, 
    0.03869054f, -0.01728069f, -0.03541677f, 0.03018429f, -0.03826232f, 0.00886966f, -0.03134857f, -0.05018822f, 
    0.03910022f, -0.03820581f, -0.04774446f, -0.02714659f, -0.05125829f, -0.01518135f, -0.03753213f, -0.00210585f, 
    -0.04444928f, 0.04812382f, 0.02694035f, -0.04159450f, 0.03497836f, -0.02463898f, -0.03367284f, -0.05488684f, 
    0.02877631f, -0.01270128f, 0.02662656f, 0.03277489f, -0.04588021f, 0.04584175f, -0.00950872f, 0.03130201f, 
    -0.02704536f, 0.02843047f, 0.03325338f, -0.02348870f, 0.02570064f, 0.02896648f, -0.02684465f, -0.04347238f, 
    0.00771674f, 0.00890421f, 0.02497699f, -0.02734292f, -0.02647530f, 0.00186289f, -0.01670249f, -0.05226484f, 
    -0.02634117f, 0.03383368f, -0.04206083f, -0.03289728f, -0.03985183f, 0.01345538f, 0.00306607f, -0.03742662f, 
    -0.31100866f, 0.28332603f, 0.00322068f, -0.11015065f, 0.14108117f, 0.16387819f, 0.12088495f, -0.04103946f, 
    -0.10848963f, -0.09438086f, 0.04149512f, -0.08150156f, -0.08406466f, 0.03470607f, 0.23299363f, 0.12174430f, 
    -0.17413740f, 0.02532258f, -0.14482582f, -0.03013463f, 0.04098375f, -0.15470538f, 0.12372145f, -0.11981027f, 
    0.18968861f, 0.07038762f, 0.03684924f, -0.16334000f, 0.00693824f, 0.15227924f, 0.05655861f, -0.06974128f, 
    0.00308550f, 0.12213732f, 0.15174556f, 0.09174541f, -0.17101964f, -0.21458510f, -0.09667612f, -0.18931600f, 
    0.22439151f, 0.11580786f, 0.12457405f, 0.07004417f, -0.03741174f, -0.01337400f, -0.00150440f, 0.13241434f, 
    0.51648015f, -0.07572915f, -0.03255789f, 0.05849131f, 0.09863988f, 0.03284764f, -0.02723160f, 0.06401774f, 
    0.03095098f, -0.00747043f, -0.02018425f, 0.09023624f, -0.08366238f, 0.19669171f, 0.00813766f, -0.07210749f, 
    0.13217498f, -0.10629386f, 0.04826407f, -0.04600874f, -0.21064135f, 0.16788690f, 0.14136566f, 0.12559471f, 
    -0.21148655f, -0.12821023f, 0.01369499f, -0.05859746f, 0.08733293f, -0.16624604f, 0.06228998f, 0.03372019f, 
    0.18851942f, 0.20027520f, 0.16973431f, 0.07503995f, -0.04467392f, 0.07963587f, -0.12448967f, -0.06705780f, 
    0.01393303f, -0.02405500f, -0.04565622f, -0.00036993f, -0.00379599f, -0.17949355f, -0.01559382f, -0.01700209f, 
    0.60957730f, 0.12442404f, -0.21044451f, 0.24663220f, -0.01836199f, -0.05841591f, -0.06123415f, 0.04962426f, 
    -0.04059480f, -0.16710839f, -0.09173214f, -0.20891981f, 0.34013033f, 0.15684322f, -0.10738928f, -0.28855455f, 
    0.10588891f, -0.12882216f, 0.11681466f, 0.00874075f, -0.11794263f, 0.04391879f, 0.01479810f, -0.13653767f, 
    -0.18834470f, -0.10857604f, 0.31665432f, 0.24351336f, -0.20925143f, 0.13827656f, 0.08802922f, -0.01316657f, 
    -0.11186027f, 0.00697587f, 0.09360129f, 0.05115352f, 0.04434246f, 0.00286024f, 0.12481481f, -0.00150891f, 
    -0.12380790f, -0.04205596f, 0.01205114f, 0.06504331f, -0.03665242f, 0.16636308f, 0.10380495f, 0.00764670f, 
    0.08725458f, 0.31166464f, -0.07053123f, -0.28914535f, -0.01483877f, -0.03574775f, 0.06658877f, -0.09739009f, 
    0.16122989f, -0.12943956f, -0.04501979f, -0.06990536f, -0.28472292f, -0.16120736f, -0.11336947f, -0.16045626f, 
    0.09406001f, 0.03299587f, 0.16557004f, 0.10220867f, -0.05008783f, -0.06762347f, 0.03386138f, -0.08258687f, 
    0.65157425f, -0.28241369f, 0.04429200f, -0.11939803f, -0.13652112f, -0.01189075f, 0.03316474f, -0.07388125f, 
    -0.27193698f, -0.02395801f, -0.02245778f, 0.02490728f, -0.50758052f, 0.39456648f, 0.02809348f, -0.09595986f, 
    -0.00383253f, -0.15082860f, -0.06301187f, -0.12525272f, 0.03571375f, 0.08893130f, -0.00600138f, -0.04679077f, 
    0.37676036f, -0.30634448f, -0.12799060f, 0.13600403f, -0.00468406f, -0.01185170f, -0.18500030f, -0.00616622f, 
    0.05807813f, 0.00725560f, -0.03390094f, 0.05169977f, 0.32280567f, -0.01253098f, 0.19294697f, 0.08483575f, 
    -0.20227039f, 0.05003803f, 0.08766679f, 0.02694781f, 0.01467291f, 0.10975064f, 0.03218067f, 0.16730484f, 
    0.44703725f, -0.09593619f, 0.24221109f, 0.11581559f, -0.03511138f, 0.08137960f, 0.02428448f, 0.05432409f, 
    -0.08582270f, -0.04274926f, 0.10484844f, 0.09606401f, 0.34605709f, 0.47356734f, 0.11529984f, 0.04854422f, 
    -0.07861263f, -0.02650982f, 0.05313462f, -0.00898198f, 0.06312858f, 0.06644870f, 0.20905881f, 0.14497975f, 
    0.29029849f, 0.18452489f, 0.12874068f, 0.29098383f, -0.01571419f, -0.07150432f, -0.15220223f, -0.01213374f, 
    -0.02308768f, -0.06065394f, 0.11503366f, -0.01730373f, -0.16877750f, 0.19623226f, 0.35506159f, -0.10348774f, 
    0.03157717f, -0.23852368f, 0.08022957f, 0.21445592f, -0.11621132f, -0.05257146f, 0.15960385f, 0.13848917f, 
    -0.22736798f, 0.02098708f, -0.05289729f, -0.44642681f, 0.13971406f, 0.39667684f, 0.05942291f, -0.04860293f, 
    0.08932183f, 0.12725225f, -0.09746437f, -0.02875822f, -0.13501842f, 0.14981525f, -0.04293345f, -0.33598953f, 
    0.12051889f, 0.05644355f, -0.08862322f, -0.02763773f, 0.00013451f, 0.17823164f, 0.00469198f, -0.07483193f, 
    -0.21698235f, -0.11771719f, -0.06274227f, 0.09363099f, -0.02675036f, -0.23557563f, 0.09430298f, -0.02185683f, 
    -0.01064810f, 0.06576446f, -0.12690297f, 0.14828521f, -0.01594569f, 0.11152318f, 0.04246545f, 0.27451491f, 
    -0.10500842f, 0.12964286f, -0.09647044f, 0.10195076f, -0.07102851f, -0.07249869f, 0.12369763f, 0.00536064f, 
    -0.08268490f, -0.07573631f, 0.26437026f, -0.17083554f, -0.01845348f, 0.01346905f, 0.04931251f, 0.26971111f, 
    -0.00119686f, -0.06553385f, 0.25732699f, -0.00688430f, -0.03219027f, 0.36119387f, 0.04676655f, -0.00973610f, 
    -0.04226492f, 0.00269194f, 0.04546648f, 0.07539684f, 0.07641169f, 0.08274826f, 0.20374560f, -0.01114697f, 
    -0.50339109f, 0.04896626f, 0.30157343f, 0.21381241f, 0.16918184f, -0.04971042f, 0.01643425f, -0.00503806f, 
    -0.03716781f, 0.03403695f, 0.10718945f, -0.09089204f, 0.75492936f, -0.12220116f, -0.13605514f, 0.11885805f, 
    -0.14231542f, -0.04116415f, -0.10788526f, -0.01320959f, -0.00640257f, 0.10641883f, -0.12110163f, -0.04167867f, 
    0.19938973f, -0.06553250f, 0.04801477f, 0.30391586f, 0.03840226f, -0.07653601f, -0.00016609f, 0.06727207f, 
    0.16703968f, 0.07792372f, -0.02800669f, 0.02026715f, 0.76162040f, -0.14122498f, 0.17304614f, 0.05957816f, 
    -0.07552599f, -0.06340374f, -0.10848750f, 0.23489130f, 0.04466473f, -0.09190039f, 0.05872508f, 0.09115518f, 
    0.29556349f, -0.04649156f, 0.02285786f, -0.09119353f, -0.01099573f, 0.07625099f, -0.07824271f, 0.16773871f, 
    0.15674131f, 0.17373490f, 0.11025335f, 0.30098042f, 0.10974418f, 0.09309160f, 0.08822465f, -0.14218475f, 
    0.04836698f, 0.11876083f, 0.05105528f, 0.13449934f, -0.00263209f, 0.05944066f, -0.06120810f, -0.09746156f, 
    0.08296022f, -0.02610081f, -0.03016881f, 0.06082620f, -0.05402412f, -0.08352788f, -0.17787695f, 0.02225848f, 
    0.03723426f, -0.18836620f, -0.03425600f, -0.07510987f, 0.06559966f, 0.27039331f, 0.05776855f, 0.22125085f, 
    0.05721888f, -0.01998298f, 0.18000078f, -0.10871890f, -0.03337696f, 0.09670752f, -0.18187018f, 0.09190835f, 
    -0.30171102f, 0.04177959f, -0.02858822f, 0.05834962f, -0.07773331f, 0.04093489f, 0.10272998f, 0.12392076f, 
    -0.03568343f, 0.01252707f, 0.08732896f, 0.05343062f, 0.10961401f, -0.08479858f, -0.19312812f, -0.06213648f, 
    -0.04729141f, 0.06741635f, 0.02465337f, 0.18122143f, 0.10583688f, -0.17705692f, -0.11123475f, -0.24736856f, 
    0.32852215f, -0.06266441f, 0.12404224f, -0.04882113f, -0.05848187f, 0.19607988f, 0.03496152f, 0.09201209f, 
    -0.00947789f, 0.04743477f, 0.08590344f, 0.08504006f, 0.61296970f, 0.02276446f, 0.03058156f, 0.02768199f, 
    -0.03546945f, 0.02412283f, -0.01065642f, 0.08880932f, -0.09038039f, 0.16590422f, 0.06888831f, -0.11697835f, 
    -0.07489664f, -0.12340209f, 0.10520516f, -0.08280266f, -0.06053787f, 0.07720416f, 0.08535543f, -0.00735626f, 
    0.13570179f, -0.08892170f, -0.00708853f, 0.09047084f, 0.46297070f, 0.39218956f, 0.06785810f, 0.24452630f, 
    -0.08269370f, 0.08005730f, 0.11048193f, 0.12976508f, -0.02435722f, 0.05504516f, -0.19000830f, 0.16870569f, 
    -0.04149992f, 0.41027093f, 0.03639390f, -0.09605546f, 0.04843821f, -0.01403412f, 0.04345711f, 0.08046927f, 
    0.22796179f, 0.08713917f, -0.08933884f, -0.07265000f, -0.24022634f, 0.16413672f, 0.24192978f, -0.00696281f, 
    0.07748766f, 0.15212958f, -0.10337697f, -0.02556015f, 0.05109824f, 0.07405762f, -0.10775590f, -0.00302028f, 
    -0.04158631f, -0.44178432f, 0.06991675f, 0.11514167f, 0.03193507f, 0.07805369f, -0.08919798f, 0.03496255f, 
    -0.08827916f, -0.00377992f, -0.04757678f, -0.01438716f, 0.22970821f, 0.02799592f, -0.11337440f, 0.34234685f, 
    -0.00803948f, 0.02197288f, 0.07843703f, -0.17147192f, 0.13182633f, 0.03365888f, 0.12379099f, 0.23089863f, 
    -0.10713964f, -0.00316675f, -0.16193967f, 0.04399750f, 0.04351880f, 0.03018439f, -0.05353389f, 0.14625256f, 
    0.11623988f, 0.16313571f, 0.36526513f, 0.14469744f, 0.77205831f, 0.02605062f, -0.23588078f, 0.07388900f, 
    -0.06625240f, 0.25170758f, -0.10136485f, 0.17302880f, -0.13843280f, 0.21912737f, 0.18974042f, 0.09465238f, 
    0.13943708f, 0.30487242f, 0.12853272f, -0.11473032f, -0.03279503f, 0.01669380f, 0.15711212f, 0.03852572f, 
    -0.01409847f, 0.09035619f, 0.31101277f, 0.16693668f, -0.25515756f, -0.03860826f, 0.01279946f, -0.21920872f, 
    0.18997562f, 0.09589840f, -0.11932075f, 0.07203493f, 0.07460281f, -0.15231483f, 0.12920071f, -0.07564508f, 
    -0.06870061f, 0.05413891f, -0.29859033f, 0.04040298f, 0.06414285f, -0.02404541f, 0.07821345f, -0.03671300f, 
    0.10892544f, -0.00258273f, -0.30756047f, 0.10695446f, -0.31201443f, -0.33514279f, 0.03150471f, -0.03326906f, 
    0.05603154f, -0.13893117f, 0.17194399f, 0.11175296f, 0.03746095f, -0.00916404f, -0.09265126f, 0.13288674f, 
    -0.32146353f, -0.06461203f, 0.14182505f, -0.15884589f, -0.02364485f, 0.10370496f, 0.26852056f, 0.16096051f, 
    -0.01283205f, 0.20718393f, -0.08221322f, 0.07799049f, 0.14320743f, -0.29358107f, -0.30383208f, 0.12346555f, 
    -0.16833694f, -0.09202939f, -0.18301451f, -0.03120090f, 0.01930992f, 0.24144915f, -0.15648195f, 0.09537188f, 
    -0.10364343f, -0.03101963f, 0.08836673f, 0.24133313f, 0.00050858f, -0.07567430f, -0.08606113f, -0.05616160f, 
    -0.15515755f, -0.05555889f, -0.02959509f, 0.09585666f, -0.09918767f, -0.22426890f, 0.04060422f, 0.29666123f, 
    0.06057752f, 0.17545451f, 0.17863141f, -0.00521539f, -0.07654114f, -0.29681462f, -0.01602477f, 0.01023206f, 
    -0.30170071f, 0.07585403f, 0.30610237f, 0.08405712f, 0.00334127f, 0.27514413f, 0.14521459f, 0.13288999f, 
    0.07433467f, -0.07913769f, 0.25325671f, -0.28608742f, 0.21847276f, -0.10664836f, -0.01510241f, -0.18399696f, 
    0.01427639f, 0.10176211f, 0.02158221f, 0.17251916f, 0.08791446f, 0.29735658f, -0.16187538f, 0.30720392f, 
    -0.14017826f, -0.30579478f, -0.08944190f, 0.61619085f, -0.02465237f, -0.15733236f, 0.28450763f, -0.11905187f, 
    -0.02474752f, 0.12904991f, -0.22702086f, -0.09718990f, 0.11437731f, -0.11250252f, -0.01340604f, -0.07186460f, 
    -0.03415249f, 0.10730775f, -0.15351008f, -0.03428834f, -0.22649308f, -0.11893217f, -0.29459494f, -0.04085945f, 
    0.23390992f, 0.19786298f, -0.12252215f, 0.07546096f, -0.12754421f, 0.17443651f, 0.00064666f, 0.02959131f, 
    0.04270658f, 0.08130144f, -0.12898484f, 0.11418305f, -0.23294349f, -0.24981733f, 0.16697744f, -0.12161859f, 
    0.03647863f, 0.05238969f, 0.00344350f, 0.11896193f, 0.15943477f, -0.11000744f, -0.04733519f, 0.13009322f, 
    -0.22092895f, 0.03925567f, 0.11048867f, -0.29918435f, 0.04461649f, 0.11883157f, 0.30214944f, -0.07779447f, 
    -0.19025612f, 0.01634609f, 0.28141290f, 0.14804441f, -0.36383596f, -0.07545020f, 0.21022217f, 0.08103566f, 
    0.06333166f, 0.22660971f, 0.07887381f, -0.04083257f, -0.01400262f, 0.40781659f, 0.19922253f, 0.17667063f, 
    0.14566965f, 0.05289739f, 0.17492832f, -0.22709841f, 0.03920916f, 0.04561405f, -0.03710919f, -0.09626684f, 
    0.11363975f, -0.00307588f, 0.02039471f, 0.09163073f, -0.62935293f, 0.23613158f, -0.24609195f, -0.37485835f, 
    0.35465300f, 0.11600266f, 0.19721386f, -0.02026034f, -0.01559718f, -0.07798898f, 0.04411804f, -0.04320204f, 
    0.34933433f, 0.01081142f, 0.02114962f, 0.13188380f, 0.08587456f, 0.09822018f, 0.13313676f, -0.11105612f, 
    0.21297877f, -0.17937082f, -0.11336755f, -0.06075725f, 0.30061966f, -0.36839595f, 0.13137156f, 0.03805891f, 
    -0.14128929f, 0.05694584f, -0.08231961f, 0.10673609f, -0.06228363f, 0.17547226f, 0.06959487f, -0.03902968f, 
    0.03721122f, 0.04315179f, 0.13560800f, 0.19037570f, 0.03604566f, -0.06221189f, 0.08251412f, 0.09381156f, 
    0.05703031f, 0.06192116f, 0.00349196f, -0.15923192f, 0.35793301f, 0.18879648f, -0.07665431f, 0.19629952f, 
    0.19000530f, -0.09535606f, 0.04454320f, 0.16473483f, 0.21520084f, -0.00806179f, 0.14101572f, 0.03881629f, 
    -0.37848485f, 0.04091670f, 0.16598590f, 0.13750972f, 0.03836142f, 0.03041123f, 0.00275851f, 0.08712669f, 
    -0.03896233f, 0.06069545f, -0.06359016f, 0.08037416f, 0.09990976f, 0.18118472f, 0.08478154f, -0.18401203f, 
    0.19543745f, 0.01856847f, 0.03392534f, -0.03504254f, -0.16407423f, 0.10441464f, 0.10390162f, 0.05460205f, 
    0.62938803f, 0.10440829f, -0.31878650f, -0.07054008f, 0.02609507f, -0.08656980f, 0.10751117f, 0.13016264f, 
    0.04722588f, -0.01604521f, 0.09742566f, 0.01952020f, -0.00507295f, 0.08372761f, -0.22598152f, -0.33330148f, 
    0.18123314f, 0.17970367f, -0.11708079f, 0.13243100f, 0.00551397f, -0.01030411f, -0.02574400f, 0.05360436f, 
    -0.49259654f, -0.05747702f, -0.11799408f, -0.47306949f, 0.09516872f, 0.06139404f, -0.02088841f, -0.13174605f, 
    -0.03961211f, -0.05003516f, -0.00769062f, -0.02808722f, -0.47124672f, 0.01267411f, -0.09922449f, -0.14559102f, 
    0.06166141f, 0.13790067f, -0.02959192f, -0.04235615f, 0.02561248f, 0.10702516f, -0.15989299f, 0.06592122f, 
    0.08485330f, 0.20079957f, -0.27937374f, 0.37012646f, 0.01330716f, 0.01584055f, 0.01745041f, -0.02887419f, 
    0.03295597f, -0.01702599f, -0.06092130f, -0.05783456f, 0.02416571f, 0.37942544f, 0.09918921f, 0.04709800f, 
    0.12799245f, 0.00167093f, 0.01621582f, 0.06647029f, 0.09176320f, 0.01290486f, 0.12441210f, 0.05951923f, 
    -0.02211346f, 0.12185631f, 0.27965263f, 0.24628055f, -0.05876814f, -0.03815836f, -0.01637998f, 0.06909806f, 
    -0.08768996f, 0.01903930f, -0.04299349f, 0.20074835f, -0.17104730f, 0.01498207f, -0.07776739f, 0.05374998f, 
    0.04069915f, -0.11974159f, -0.03435459f, 0.09138943f, 0.07350085f, -0.21030216f, 0.03181675f, 0.13347575f, 
    -0.40718114f, 0.14418454f, 0.01190754f, 0.09648184f, 0.06480560f, -0.10951740f, -0.00811857f, 0.17227265f, 
    0.04260035f, 0.10024770f, -0.09801546f, 0.10999209f, -0.68411160f, 0.52600193f, -0.39427930f, 0.23540631f, 
    0.15004089f, 0.21178687f, 0.10004750f, -0.07959499f, -0.10830840f, 0.00230858f, 0.28852728f, -0.14149560f, 
    0.14935756f, -0.06187308f, 0.18814342f, -0.11496479f, 0.04606244f, 0.14441620f, 0.05290281f, -0.12587269f, 
    0.02955419f, 0.08075203f, 0.03838241f, -0.26219377f, 0.37391460f, -0.26266223f, -0.05835664f, -0.00198475f, 
    0.10455299f, -0.13750838f, -0.05190181f, 0.04912373f, 0.00244728f, 0.11225373f, 0.00639256f, 0.04578079f, 
    -0.35746709f, -0.07346986f, -0.32199579f, -0.12186699f, 0.02188971f, -0.02603974f, 0.03050648f, -0.14388664f, 
    -0.02760174f, -0.10738633f, 0.05353704f, 0.18718296f, -0.27044860f, -0.00023090f, 0.21407187f, 0.35828254f, 
    -0.03875018f, -0.17461474f, 0.04448758f, 0.03908550f, -0.19321290f, -0.02506253f, 0.00026129f, -0.05855184f, 
    0.19007668f, -0.24965914f, 0.29667985f, 0.06857342f, -0.04822569f, 0.05188467f, 0.07511456f, 0.01694603f, 
    0.08160879f, 0.00358878f, 0.12559676f, 0.04853323f, 0.33025366f, -0.10682353f, 0.09600392f, -0.15348506f, 
    -0.00527361f, -0.04619461f, -0.14608645f, 0.06638703f, 0.01871237f, -0.01053106f, -0.03873285f, -0.05055831f, 
    -0.21018705f, -0.07845972f, 0.23212701f, 0.03645805f, -0.02243946f, 0.03872047f, 0.08568592f, -0.08573870f, 
    0.19547363f, -0.07322687f, 0.03424783f, -0.07371010f, -0.10809507f, 0.14826544f, -0.08995283f, -0.22788189f, 
    0.00293463f, -0.13623686f, -0.15687598f, 0.05390689f, 0.09024766f, 0.05034777f, 0.13146406f, 0.13467684f, 
    -0.31867972f, 0.21718609f, 0.31998914f, 0.36221978f, -0.08895867f, 0.11271596f, 0.10873239f, 0.22611181f, 
    0.01376731f, 0.21744435f, 0.00282074f, 0.18068911f, 0.26715040f, 0.21331798f, 0.12859656f, 0.00829272f, 
    0.19520094f, -0.18965779f, -0.19547042f, -0.00183943f, 0.09467685f, 0.00030573f, 0.01594054f, 0.16343027f, 
    -0.51617110f, -0.20769595f, 0.14915258f, -0.34778023f, 0.09563421f, 0.17449099f, -0.15228550f, -0.10110760f, 
    -0.13685939f, -0.00403514f, -0.02700087f, -0.11123861f, 0.35097605f, 0.28036913f, -0.11581867f, -0.24760917f, 
    0.04649387f, -0.05155425f, -0.15389171f, 0.11550976f, 0.02928681f, 0.04796166f, -0.17001767f, 0.13377070f, 
    -0.04722728f, -0.09447974f, -0.24985187f, 0.11478383f, -0.11900643f, -0.13164553f, -0.02802267f, -0.02896524f, 
    -0.14739598f, 0.07507223f, 0.08748123f, -0.10246219f, 0.06881940f, -0.02545653f, 0.14888585f, 0.25721839f, 
    -0.00662179f, 0.12638098f, 0.03078094f, -0.01073351f, -0.06306345f, 0.10037015f, 0.14709181f, -0.13656032f, 
    0.21128125f, -0.10621760f, 0.00148448f, -0.00713333f, 0.13353756f, 0.16521275f, 0.00183427f, -0.14971599f, 
    0.02996147f, 0.23426956f, 0.08728285f, 0.04338259f, -0.26606825f, -0.39143163f, 0.00946157f, 0.12659378f, 
    -0.06580226f, -0.00954615f, -0.05111825f, 0.02213180f, -0.03951068f, 0.06622140f, -0.11099938f, 0.03211981f, 
    0.46450889f, 0.17189422f, -0.05109895f, -0.27742419f, 0.08806970f, -0.03691479f, -0.02503292f, 0.01937364f, 
    0.10649448f, -0.02930868f, 0.01422266f, -0.15274574f, -0.28461003f, 0.32783565f, -0.01543383f, -0.15137050f, 
    0.11058423f, 0.14901803f, -0.11264850f, -0.06058684f, -0.01921349f, -0.02746682f, -0.06667551f, 0.19912887f, 
    0.43038240f, 0.50610620f, 0.17260811f, 0.29657149f, -0.08717973f, -0.05638143f, 0.00446938f, 0.13062081f, 
    -0.14886974f, 0.06567781f, 0.11050367f, -0.11027877f, 0.13995512f, -0.09181634f, 0.23829140f, 0.00772598f, 
    -0.14249143f, -0.10583769f, -0.12895192f, 0.20523866f, -0.05636779f, -0.08773517f, -0.20951037f, -0.18714254f, 
    0.62619698f, 0.26907238f, 0.43569151f, 0.23763019f, -0.19143417f, 0.02273488f, 0.04664729f, 0.11006087f, 
    -0.02434403f, -0.13158286f, -0.03593219f, 0.01814177f, 0.51122385f, 0.20577219f, -0.01132484f, -0.21649583f, 
    0.00633804f, 0.33256766f, -0.06486727f, 0.01337762f, 0.02844643f, -0.07203320f, 0.06087596f, 0.14781965f, 
    0.02140790f, -0.09838802f, 0.40585384f, -0.03733458f, -0.14984727f, -0.10080296f, 0.01801586f, -0.01550214f, 
    0.08387055f, -0.18748133f, -0.04578418f, 0.04499315f, -0.00209650f, 0.60002381f, -0.46148494f, -0.04954788f, 
    0.16914403f, -0.05411736f, 0.08989519f, 0.03585218f, 0.14334533f, 0.12756643f, 0.03980649f, -0.11134700f, 
    0.07762560f, 0.03955766f, -0.26440492f, -0.03667508f, 0.07188790f, 0.16172844f, -0.14174940f, -0.02127964f, 
    0.04478376f, 0.05529213f, -0.06016505f, -0.04404259f, 0.12934360f, -0.00549260f, -0.05077371f, 0.16846292f, 
    0.13110040f, 0.03015983f, 0.05566659f, 0.07939357f, -0.05656823f, 0.09722516f, 0.15254052f, 0.02228001f, 
    -0.09761370f, -0.33664277f, 0.07980219f, -0.06741772f, -0.11473631f, 0.01954307f, 0.02489798f, -0.03398832f, 
    -0.09384715f, -0.14568697f, -0.14448158f, -0.10016490f, -0.00495760f, 0.00945312f, -0.28506273f, -0.13188732f, 
    0.12616877f, 0.09552354f, 0.07818697f, -0.06664652f, 0.03048528f, -0.07722686f, -0.09601203f, 0.13210158f, 
    0.25936329f, -0.02351771f, 0.20817240f, -0.14424860f, -0.05031572f, -0.08905678f, 0.02899225f, 0.07675291f, 
    0.13462709f, 0.05054842f, 0.02116114f, 0.01763532f, 0.44958556f, 0.41818556f, -0.23733918f, 0.07534727f, 
    0.25909668f, 0.21666437f, -0.05313532f, -0.04764795f, -0.05680655f, 0.19830674f, -0.00099708f, 0.02395380f, 
    0.50818443f, 0.09900121f, 0.21614394f, 0.03355221f, 0.02765107f, 0.09609230f, -0.04676972f, -0.01691633f, 
    0.17852850f, -0.09955821f, 0.09979033f, 0.19374670f, -0.02655349f, -0.29091313f, -0.14369550f, -0.01436658f, 
    -0.03511430f, 0.10506583f, 0.09332181f, 0.05802105f, 0.02314227f, 0.06624869f, -0.02528057f, -0.09569503f, 
    0.31807664f, 0.21735878f, -0.04486045f, -0.04620356f, 0.01822316f, -0.04628249f, -0.03284044f, -0.03750237f, 
    -0.18413977f, 0.08994789f, -0.15411884f, 0.08743467f, 0.01396470f, 0.09750555f, 0.04248223f, -0.05113089f, 
    0.16872928f, -0.16952716f, -0.12468115f, -0.00007926f, -0.05883468f, -0.12332994f, -0.01338047f, 0.06337472f, 
    0.12250193f, -0.19245255f, -0.15160064f, -0.17118803f, -0.09077260f, 0.05520904f, -0.03242840f, 0.03091549f, 
    -0.07347199f, 0.06552064f, -0.11551978f, -0.10503245f, 0.30361935f, 0.39281556f, 0.26603258f, 0.47413728f, 
    -0.24470423f, -0.14938492f, 0.10270447f, 0.09663080f, 0.06300531f, -0.07844108f, -0.04945017f, -0.01685357f, 
    -0.02611453f, 0.08326049f, -0.17845389f, 0.16721015f, 0.14323866f, -0.00692261f, 0.01544976f, 0.05216367f, 
    0.12283303f, 0.03736272f, 0.05840772f, -0.12520641f, 0.39336285f, 0.13343513f, -0.16559787f, 0.04082197f, 
    0.00781891f, 0.05019453f, 0.17904380f, 0.05749543f, 0.14112270f, -0.12995178f, -0.07829721f, -0.17175950f, 
    -0.21080373f, -0.08295485f, -0.22082652f, 0.02731654f, 0.01887137f, 0.08254865f, 0.09869768f, 0.12657173f, 
    0.06925175f, -0.00321319f, 0.07594832f, 0.07506940f, 0.05556261f, 0.03120146f, -0.16954687f, -0.14619155f, 
    0.07644176f, -0.03488315f, -0.03236841f, -0.06803868f, 0.08334883f, 0.06031112f, 0.01059402f, 0.01112881f, 
    -0.17880061f, 0.27786106f, -0.24139310f, 0.19663197f, -0.00396156f, -0.15052295f, -0.03348612f, -0.19559562f, 
    -0.00359280f, -0.00863582f, 0.06181651f, -0.03897720f, 0.22529685f, 0.45235136f, 0.10551890f, 0.08209604f, 
    -0.03140222f, 0.12249297f, 0.10049020f, -0.16501881f, 0.03067889f, 0.04527620f, 0.04042739f, -0.02780849f, 
    0.04723548f, -0.20476195f, -0.34841031f, 0.07212466f, -0.05117167f, 0.03749845f, 0.08564196f, -0.05320855f, 
    -0.01710647f, 0.07565637f, 0.03930242f, -0.01347998f, -0.00440920f, -0.23810734f, 0.20894016f, 0.17038146f, 
    -0.08124866f, -0.03658861f, 0.00503139f, -0.04522657f, 0.14244631f, -0.04121997f, 0.07234113f, 0.01792463f, 
    -0.10983147f, 0.06121109f, -0.19032833f, -0.12221978f, -0.10319545f, 0.06828924f, 0.10362349f, 0.03407628f, 
    -0.07033111f, 0.08361737f, 0.05212848f, -0.06646802f, 0.21601172f, 0.16842683f, 0.48709843f, -0.03561739f, 
    -0.08413425f, 0.07539774f, 0.36235476f, -0.12974676f, -0.06368245f, 0.15172519f, -0.06450699f, -0.06128241f, 
    -0.05712251f, -0.05716085f, -0.03445593f, -0.00338886f, -0.01720444f, -0.00628547f, 0.01945959f, 0.01366967f, 
    0.01414321f, -0.04288588f, -0.03936273f, 0.03998370f, 0.02343215f, -0.02996760f, -0.05525787f, -0.02308042f, 
    0.00164958f, -0.00407498f, 0.01651455f, -0.03482460f, 0.02809706f, 0.01847648f, -0.04959749f, 0.00672438f, 
    -0.01592544f, 0.00721527f, 0.02055530f, -0.02646960f, -0.01504656f, -0.00420398f, -0.03507278f, -0.00016113f, 
    0.01113061f, -0.02674001f, -0.00446054f, 0.00190408f, -0.03375930f, -0.03104099f, -0.02401852f, -0.03880741f, 
    -0.01472564f, -0.05686875f, 0.00526380f, -0.05748039f, -0.04559985f, -0.01809904f, -0.01559834f, -0.04097584f, 
    0.01290312f, 0.02831698f, -0.04120540f, 0.02280650f, -0.02603603f, -0.02144258f, 0.03950008f, -0.04398484f, 
    -0.03315898f, -0.03008433f, 0.03563010f, 0.02656567f, 0.03091839f, 0.02577052f, -0.03917498f, 0.03986428f, 
    0.02986012f, -0.01602672f, 0.00247583f, -0.00836015f, -0.00151267f, 0.03078629f, 0.02894068f, -0.02208083f, 
    -0.01574781f, 0.03416436f, 0.01475221f, -0.03710461f, 0.00573227f, -0.00251535f, 0.02039861f, -0.04437999f, 
    -0.04590258f, -0.04731819f, -0.01984599f, -0.00275876f, -0.00040378f, 0.02571123f, -0.04543145f, 0.01479341f, 
    0.02128898f, 0.00495125f, 0.01208507f, -0.03302485f, 0.01190630f, -0.05804754f, -0.01257367f, -0.01509959f, 
    -0.01107243f, -0.04552947f, 0.00273033f, 0.03622844f, -0.01787107f, -0.03317746f, 0.01737314f, -0.05848394f, 
    -0.03064631f, 0.00287023f, -0.06171814f, -0.00796889f, -0.04980043f, 0.02564265f, 0.02014253f, -0.04833004f, 
    0.02496154f, -0.05358326f, -0.01242061f, 0.01553396f, -0.02205926f, -0.02842874f, -0.00681731f, -0.00557963f, 
    0.03779651f, 0.00195359f, -0.02513443f, -0.01763351f, -0.03346700f, 0.03024253f, 0.01593733f, -0.05630789f, 
    0.02799306f, -0.02990233f, -0.00149726f, -0.05447056f, -0.00791045f, -0.04279469f, 0.02296961f, 0.03614128f, 
    -0.05152327f, 0.03317708f, -0.02587491f, -0.00276912f, 0.02689425f, -0.01883512f, 0.01071395f, -0.01678936f, 
    -0.03103044f, -0.01551462f, 0.01881150f, -0.04878269f, -0.03897326f, -0.02814921f, 0.01293752f, 0.00709989f, 
    0.01893777f, -0.02900702f, -0.02031922f, -0.01258190f, 0.02952439f, -0.03860496f, 0.00847539f, 0.01304035f, 
    -0.04373694f, 0.02861273f, 0.03022090f, -0.03788223f, -0.05661952f, 0.03043282f, -0.05240513f, 0.04518474f, 
    0.02901322f, 0.00852362f, -0.03051229f, -0.04454707f, 0.03532533f, -0.03536493f, -0.06081753f, 0.00411189f, 
    -0.04056457f, 0.00090224f, -0.05121415f, -0.00301102f, 0.02833539f, -0.01021523f, 0.00619578f, 0.00861385f, 
    0.02453944f, -0.02211371f, -0.01236705f, 0.04838015f, 0.00637141f, -0.05349718f, -0.03394373f, 0.00921349f, 
    0.02706899f, 0.02983564f, 0.01040433f, 0.00415764f, 0.00615489f, 0.03013608f, -0.05309724f, -0.03313214f, 
    -0.01422924f, 0.03404175f, 0.03317906f, 0.01616990f, -0.00521251f, -0.02956224f, 0.01354826f, -0.00514587f, 
    0.03436394f, -0.02190395f, -0.06073499f, -0.00382354f, -0.01708728f, 0.03474116f, -0.03034914f, -0.00097903f, 
    -0.02204474f, 0.00875698f, -0.01425233f, 0.00102792f, -0.01718262f, -0.04523983f, -0.00021871f, -0.00389944f, 
    -0.02719387f, 0.01877298f, -0.03606154f, -0.06188885f, 0.00954627f, -0.02258320f, 0.03785470f, -0.01411128f, 
    -0.02966696f, 0.01498578f, -0.02769007f, -0.02909252f, -0.04948890f, 0.02733025f, -0.03279932f, -0.00015878f, 
    -0.01585900f, 0.03491713f, 0.00017866f, 0.03038574f, -0.06178828f, 0.00555446f, -0.01454027f, -0.02307481f, 
    -0.05999839f, -0.01264928f, -0.00443635f, 0.01245738f, -0.04631357f, 0.02525979f, 0.00930583f, 0.02049999f, 
    0.00946318f, -0.04932386f, -0.05511406f, -0.02751748f, 0.01428460f, -0.04696157f, -0.02660701f, -0.01028132f, 
    0.00975734f, 0.01602560f, -0.02293029f, 0.01593476f, -0.05335063f, -0.04353211f, -0.01134465f, 0.01924053f, 
    0.03673212f, 0.03651116f, -0.01703808f, 0.01958445f, 0.01955147f, -0.04656298f, -0.05859429f, -0.05384674f, 
    0.02613869f, 0.03849598f, -0.05508304f, -0.01322177f, 0.01672661f, -0.03370352f, -0.05478878f, 0.03804489f, 
    0.02076448f, 0.00815792f, 0.00719008f, 0.01739372f, 0.01394817f, -0.04638321f, -0.03160808f, -0.05840866f, 
    -0.04665305f, -0.02412564f, 0.01469036f, 0.01160879f, 0.02736667f, -0.01959954f, -0.04367204f, -0.03700942f, 
    0.01782033f, -0.05197121f, -0.02027779f, 0.02122617f, -0.02195142f, -0.04821691f, 0.03360809f, 0.00993815f, 
    0.01912495f, -0.02314828f, -0.00253098f, 0.02510756f, -0.01351300f, -0.05793607f, 0.00622945f, -0.01559384f, 
    -0.03756029f, 0.00826706f, 0.00237047f, 0.03413834f, -0.05418524f, -0.01924181f, 0.03452639f, 0.02065574f, 
    -0.00362135f, -0.00756493f, 0.03562807f, -0.01921598f, -0.06068228f, 0.00324041f, -0.01913460f, 0.03991896f, 
    -0.01904365f, -0.00886653f, -0.05085027f, 0.01571885f, 0.03297193f, 0.03827988f, 0.01762814f, -0.03591032f, 
    -0.05546321f, 0.02777051f, 0.02408357f, 0.00536549f, 0.02998803f, -0.06186474f, 0.00396960f, 0.01824308f, 
    0.03974053f, -0.01010732f, -0.02417983f, -0.01854881f, -0.06281664f, 0.02662008f, -0.04306315f, 0.03170649f, 
    -0.00869791f, -0.02763001f, -0.00520764f, -0.00993141f, 0.03184064f, -0.05668825f, 0.02567800f, -0.04366952f, 
    -0.04937040f, 0.04807531f, -0.04724870f, -0.05064539f, 0.00585918f, -0.03822458f, 0.03374530f, -0.02456690f, 
    -0.05268078f, 0.02506188f, -0.01271805f, 0.04126811f, -0.01363780f, 0.01797125f, 0.03201490f, -0.04342824f, 
    -0.19745964f, -0.11796703f, 0.07861606f, 0.26756164f, 0.10228454f, -0.07019153f, -0.11485138f, 0.34627381f, 
    0.08152276f, 0.00069610f, -0.16247524f, -0.13165572f, -0.03833561f, -0.25862187f, 0.25379863f, 0.27709404f, 
    -0.00155682f, 0.02150686f, 0.07295080f, -0.04045206f, 0.15413782f, 0.04926175f, 0.04191040f, 0.29305205f, 
    0.14345579f, 0.08063341f, -0.08077977f, 0.21616000f, 0.06362550f, -0.00028264f, -0.19388780f, 0.14018975f, 
    0.00167435f, 0.12889485f, 0.13605216f, 0.18749480f, -0.03432406f, 0.30418119f, 0.24650690f, 0.29040602f, 
    0.20819879f, 0.07858346f, -0.02297972f, 0.00530048f, 0.26485604f, 0.01037048f, 0.10185413f, -0.11766403f, 
    -0.89782554f, -0.05902663f, -0.09555658f, -0.04449866f, -0.18115976f, -0.13934107f, 0.08553752f, -0.26790059f, 
    -0.01873328f, -0.05844999f, -0.08989149f, 0.00324981f, -0.28755179f, 0.07772629f, -0.00097103f, -0.02680911f, 
    -0.02117787f, 0.09222623f, 0.09629133f, -0.01095053f, 0.18513104f, 0.03234209f, 0.01867678f, 0.29954785f, 
    -0.53892612f, 0.26055852f, -0.16059992f, 0.24645881f, -0.06801421f, -0.01872008f, -0.02727939f, -0.02894164f, 
    -0.01460515f, -0.23564312f, 0.02328051f, -0.15238564f, -0.33364433f, 0.32464314f, -0.01509253f, -0.04963223f, 
    0.09275901f, -0.08558552f, 0.21395411f, -0.03655913f, 0.01071249f, 0.14381298f, -0.19807643f, 0.24695940f, 
    -0.36749181f, -0.07628617f, 0.22203602f, -0.25137109f, -0.02982464f, -0.13961056f, 0.18712644f, 0.05470864f, 
    -0.03827845f, 0.24096332f, 0.05290119f, 0.06955419f, 0.27963653f, -0.02414595f, -0.05668333f, 0.53635556f, 
    0.06493569f, 0.02791925f, -0.14458811f, 0.04911038f, 0.08168001f, 0.04376964f, 0.11695103f, -0.08721503f, 
    -0.14490911f, -0.31801459f, -0.00297071f, 0.11709151f, 0.19041747f, 0.10226980f, 0.11502278f, 0.01534385f, 
    0.20214397f, 0.03280764f, 0.24189377f, 0.02865030f, -0.07270124f, -0.38327134f, -0.09492505f, 0.20648596f, 
    0.12574893f, 0.09697787f, 0.11962956f, -0.13025595f, 0.20345862f, -0.18657245f, 0.18222110f, 0.24263275f, 
    0.14409496f, 0.37391657f, -0.26334065f, 0.00616646f, 0.00477522f, -0.09014593f, 0.09859937f, 0.19735186f, 
    0.01811300f, 0.04471844f, 0.20281218f, 0.13580531f, 0.58281285f, -0.28960231f, 0.17389078f, 0.19100848f, 
    0.13704841f, -0.06375111f, -0.06213788f, -0.13987571f, 0.04306334f, 0.14742874f, 0.01730253f, -0.04321375f, 
    -0.10892247f, 0.11817987f, 0.05688671f, -0.14270619f, 0.26623890f, -0.10657897f, 0.14596249f, -0.06548880f, 
    0.10983060f, -0.05333359f, -0.15774333f, -0.05525284f, 0.13909477f, -0.09721582f, 0.16731799f, 0.05582212f, 
    0.06825526f, -0.00733635f, 0.05238182f, 0.05645154f, -0.00618305f, 0.10056041f, 0.00843851f, -0.09904017f, 
    0.02387270f, 0.23136604f, -0.03431280f, -0.06489484f, -0.10306940f, 0.04231905f, 0.08848514f, 0.09263999f, 
    -0.02602976f, -0.25336602f, 0.18549834f, -0.22237428f, 0.25111023f, -0.24074164f, -0.03491195f, -0.08714462f, 
    0.02577323f, -0.12974921f, -0.10742477f, -0.08702417f, 0.16891053f, -0.04848296f, -0.09617081f, 0.06972647f, 
    -0.25240597f, 0.40740496f, 0.12516625f, -0.14850070f, 0.10202603f, 0.01790530f, -0.09575117f, 0.10503311f, 
    0.00753488f, 0.10364201f, 0.16815774f, 0.10156846f, -0.46963629f, 0.11384774f, -0.11648144f, 0.10171404f, 
    -0.06552631f, 0.21271527f, -0.17676750f, 0.17666477f, 0.14530601f, -0.11588595f, -0.06009327f, -0.02227498f, 
    0.15884586f, 0.09602058f, 0.11525887f, -0.11530817f, 0.08937409f, -0.16304705f, -0.20055914f, 0.11967354f, 
    -0.04119644f, -0.19665362f, 0.13419816f, 0.01286231f, -0.14967646f, 0.08356603f, -0.08110611f, 0.18650275f, 
    -0.11890069f, 0.23790008f, -0.07818463f, -0.18850981f, 0.06087228f, -0.13231505f, 0.32409722f, -0.20376499f, 
    0.08399045f, 0.21323672f, 0.11451457f, 0.34609947f, 0.00618682f, -0.05694927f, 0.23595077f, -0.00618139f, 
    0.12849198f, -0.01433963f, 0.09878144f, 0.18764490f, 0.19677481f, -0.07250832f, 0.05185211f, 0.22635305f, 
    0.06327298f, -0.17002532f, 0.19581617f, -0.04608597f, -0.06825737f, 0.24302472f, 0.02187191f, 0.11212951f, 
    -0.03961584f, 0.00370379f, -0.23676378f, 0.09431986f, 0.11623628f, 0.01289038f, -0.14797418f, -0.07560392f, 
    -0.04433881f, 0.07653252f, -0.12329879f, 0.12032862f, 0.07675008f, -0.11873918f, 0.27002653f, 0.00882573f, 
    0.16387138f, -0.15461487f, 0.05360994f, 0.10050736f, 0.12936199f, 0.02237983f, 0.00105228f, -0.14342156f, 
    -0.08984534f, 0.00613293f, -0.39493179f, 0.26336816f, -0.07239179f, 0.11313710f, -0.20084634f, -0.01471600f, 
    0.23130178f, -0.04157576f, 0.14529818f, -0.02117327f, 0.25878036f, -0.03346192f, -0.13524869f, 0.26440394f, 
    -0.01028869f, -0.16099195f, 0.16599815f, 0.04350607f, 0.04954967f, 0.11923541f, -0.08513154f, 0.12148561f, 
    0.00732525f, -0.23794609f, -0.01859847f, 0.31286660f, 0.19589129f, 0.04087551f, 0.04909420f, 0.03863381f, 
    0.20639426f, -0.16260254f, 0.31168285f, 0.21173736f, -0.40528199f, 0.03464663f, 0.10589071f, -0.08047234f, 
    0.05664598f, -0.24162839f, 0.08279400f, 0.18091811f, 0.01428847f, -0.04475090f, 0.08197494f, -0.11063778f, 
    0.11642735f, -0.04425595f, 0.14067592f, -0.24054103f, -0.13480738f, 0.01774256f, -0.24418227f, 0.00255242f, 
    0.04332458f, 0.00131724f, -0.10128331f, -0.08487877f, -0.23331083f, -0.07039601f, 0.09282868f, -0.29650694f, 
    0.11757796f, -0.07309199f, -0.15260766f, -0.17221475f, 0.08913827f, -0.13544565f, -0.19877352f, 0.05700371f, 
    -0.03419166f, -0.02985167f, -0.03483725f, 0.00136260f, 0.01579564f, -0.00459466f, 0.01004304f, -0.05601067f, 
    -0.00360030f, 0.04392956f, 0.03697608f, 0.04338462f, -0.01303369f, -0.05554129f, -0.03440527f, 0.02412665f, 
    0.01457447f, -0.01053849f, -0.03214463f, -0.04283839f, -0.02867641f, -0.05640944f, 0.00951539f, 0.02420839f, 
    0.03120463f, -0.05687592f, 0.02450692f, -0.03912573f, -0.01284708f, 0.00147971f, 0.01898725f, -0.03891434f, 
    -0.02747742f, -0.00961719f, 0.01044032f, -0.04433390f, 0.00884491f, -0.05676282f, -0.02181625f, 0.00138138f, 
    0.04232759f, 0.01038837f, 0.01078547f, -0.02148397f, 0.04435573f, 0.00106399f, 0.01463493f, 0.03368632f, 
    0.01021667f, -0.02617063f, -0.05179390f, -0.04731468f, -0.02519458f, -0.04933308f, -0.03066422f, 0.00078130f, 
    -0.02714389f, -0.03879717f, 0.02631541f, -0.02304804f, -0.02377647f, 0.00394137f, 0.04421231f, -0.00165621f, 
    -0.02047304f, -0.05049408f, -0.03635572f, -0.04219118f, -0.04574972f, -0.04262570f, -0.05240919f, -0.00183249f, 
    -0.04026945f, -0.03075610f, -0.02251781f, -0.05218863f, 0.01711595f, -0.05064873f, 0.00052440f, 0.00110376f, 
    0.00857250f, -0.00176167f, 0.03111364f, 0.00929371f, -0.03752685f, 0.00882989f, 0.02724295f, 0.00177215f, 
    -0.05450151f, 0.03854802f, 0.00044770f, -0.04380649f, -0.01074419f, 0.03635692f, -0.05512933f, 0.03956691f, 
    0.01153333f, 0.01151376f, -0.02935692f, -0.00887315f, 0.02250695f, -0.03934682f, -0.02113091f, 0.00453061f, 
    0.04169061f, 0.03724678f, 0.03134686f, -0.00699082f, -0.02736688f, 0.00962321f, 0.01868110f, -0.05197164f, 
    0.04017970f, -0.03447704f, -0.02496849f, -0.04193953f, 0.01159470f, -0.01982782f, -0.04539711f, -0.05580218f, 
    0.00826023f, -0.04132243f, -0.04909186f, 0.00090334f, -0.04240534f, -0.00906252f, -0.03162290f, -0.00455069f, 
    0.01285034f, -0.00808168f, -0.01215247f, -0.03856501f, 0.00030468f, -0.03916669f, 0.04230687f, -0.05332962f, 
    0.00093675f, 0.01411002f, -0.00428380f, 0.01431865f, -0.00615916f, 0.01457286f, 0.00494491f, 0.02922332f, 
    -0.05444239f, -0.02647186f, 0.00940745f, -0.01715202f, -0.00248839f, -0.00291137f, 0.02404361f, -0.04158963f, 
    0.00476410f, 0.03049755f, 0.02335321f, 0.04243615f, -0.05206789f, 0.01441778f, 0.02727200f, 0.01004018f, 
    -0.02527193f, 0.04203528f, -0.01575875f, -0.02513221f, -0.00782790f, -0.00170186f, -0.04107336f, 0.01781889f, 
    -0.00268570f, -0.04687031f, -0.02247305f, 0.02490877f, -0.03938321f, 0.02474139f, -0.04562460f, -0.00813049f, 
    0.00923135f, -0.00510370f, -0.04482690f, 0.00566283f, -0.00248358f, -0.02961361f, 0.03791569f, 0.00357701f, 
    0.02674151f, -0.00505773f, -0.01847907f, -0.01424989f, 0.00926112f, -0.03673790f, -0.05602597f, 0.03048924f, 
    -0.05451548f, 0.04022037f, -0.03759673f, 0.00550159f, -0.03650614f, -0.04243019f, -0.04015895f, 0.02122130f, 
    -0.01551110f, 0.02141940f, -0.01761160f, -0.03380108f, 0.00310671f, -0.01699616f, 0.02069920f, -0.03178269f, 
    0.02230475f, -0.01981450f, 0.03719492f, 0.02498581f, -0.05627949f, -0.01124886f, -0.03426501f, 0.01614843f, 
    0.02593807f, 0.03921954f, -0.01172493f, -0.03616826f, 0.00918296f, -0.02189961f, 0.02033255f, 0.01608589f, 
    -0.02930783f, -0.05169587f, -0.02630355f, -0.01401283f, -0.01764544f, 0.03432917f, -0.04181659f, -0.03540697f, 
    -0.04824640f, 0.01506909f, 0.03182578f, -0.01748666f, 0.03737048f, 0.00020589f, -0.05004708f, -0.02803621f, 
    -0.04279825f, 0.03329917f, 0.03940001f, 0.00444205f, 0.01138252f, 0.03291234f, -0.02915251f, -0.02305817f, 
    0.01187558f, -0.01901082f, 0.01720209f, -0.02755633f, 0.02267496f, 0.02266756f, -0.03459644f, -0.04352633f, 
    -0.04737687f, 0.02115108f, -0.01634918f, 0.03432804f, 0.04198210f, 0.02792018f, -0.02146785f, 0.04191858f, 
    -0.00443840f, -0.03940515f, -0.01796080f, 0.01496558f, -0.02519636f, -0.04563269f, 0.02381284f, -0.02238432f, 
    -0.03508330f, -0.04497637f, 0.03931452f, 0.04230587f, 0.01136781f, -0.03514438f, -0.04067206f, -0.03256501f, 
    -0.00570531f, -0.02285885f, -0.03218903f, 0.00557141f, -0.00351208f, 0.01835356f, 0.03891987f, -0.05115108f, 
    -0.02761772f, 0.00988417f, -0.04701423f, -0.04149788f, 0.00586909f, -0.03384570f, 0.00547658f, -0.02099443f, 
    -0.03311370f, 0.02867420f, -0.04110328f, -0.03799436f, 0.01867776f, -0.02757140f, 0.01376410f, 0.03068132f, 
    0.00105470f, 0.04361795f, -0.01510119f, 0.02829820f, 0.00678787f, 0.03633726f, 0.01264642f, 0.00579173f, 
    0.03007592f, -0.03146207f, 0.04134335f, -0.04956596f, 0.00380586f, 0.02886227f, -0.03609380f, 0.02340855f, 
    -0.01397704f, -0.01584166f, -0.00886434f, -0.02320353f, 0.04012872f, 0.02935098f, -0.01361127f, -0.02908852f, 
    0.01656787f, -0.04532349f, 0.02576442f, 0.03370384f, 0.02363399f, 0.03321857f, -0.03459852f, 0.03001027f, 
    -0.00703369f, 0.03744493f, -0.02763498f, -0.00250600f, 0.00207389f, -0.02212641f, 0.00679161f, -0.03223805f, 
    0.01835488f, 0.00541095f, 0.03588493f, 0.02324592f, 0.00708280f, -0.02436384f, -0.02756845f, -0.04396924f, 
    -0.01219355f, 0.01198418f, 0.03714586f, 0.04352723f, 0.01130461f, 0.00109201f, 0.01088460f, -0.04559138f, 
    -0.04713216f, -0.03633341f, 0.02684567f, -0.02745133f, 0.00353593f, -0.04205996f, -0.04083369f, -0.03297107f, 
    0.00136036f, -0.01460983f, 0.02640240f, 0.00158434f, -0.02650288f, 0.00720071f, -0.03575357f, 0.03420386f, 
    -0.01773187f, -0.04205653f, 0.02889908f, -0.04081579f, -0.02050171f, 0.03680266f, 0.00760755f, 0.02603575f, 
    -0.20903204f, 0.20328861f, 0.19687599f, 0.22281851f, 0.12339991f, 0.11266001f, -0.04995315f, -0.06911147f, 
    -0.00277033f, -0.03041964f, 0.11713575f, 0.23308869f, 0.52981013f, 0.14487623f, -0.03450271f, -0.05017340f, 
    -0.16519733f, 0.04475767f, 0.04548007f, 0.00293658f, -0.02007991f, -0.10859188f, 0.05005307f, -0.04126200f, 
    0.01582139f, 0.02319197f, 0.29475632f, 0.43255779f, 0.11428910f, 0.00533939f, 0.05795158f, 0.10648726f, 
    -0.03901342f, -0.06010551f, -0.07999091f, -0.02275453f, 0.22254714f, 0.33808762f, 0.11819219f, 0.06672487f, 
    -0.05161507f, 0.06496468f, 0.14879315f, -0.06000121f, -0.11747129f, -0.13562661f, -0.21419474f, 0.08489668f, 
    -0.38602731f, 0.19019663f, -0.08415591f, -0.24142909f, 0.26390424f, 0.31394106f, 0.05156231f, -0.00885522f, 
    0.07279141f, 0.06549791f, -0.01057381f, 0.02457449f, 0.12655054f, 0.25701860f, -0.23604986f, -0.00393993f, 
    0.23579721f, 0.14595263f, 0.02783790f, 0.09489729f, 0.09285015f, -0.06623971f, -0.01859090f, -0.11805273f, 
    -0.29699066f, 0.18574797f, -0.07424132f, 0.03043689f, 0.08792803f, 0.18094662f, -0.06166220f, 0.14230263f, 
    0.01589876f, -0.00991130f, -0.01081616f, 0.06034120f, -0.20132671f, 0.47723743f, 0.08257947f, -0.04091775f, 
    0.07448034f, 0.00934229f, 0.00041830f, 0.18081841f, -0.05912508f, 0.19041254f, 0.06411657f, -0.26288214f, 
    -0.11103810f, 0.27383995f, -0.14090919f, 0.02458665f, 0.08145117f, 0.21294460f, 0.00672289f, -0.09061052f, 
    -0.08542509f, -0.06037971f, 0.14615098f, 0.02832929f, 0.73485827f, 0.14968282f, 0.13743256f, 0.17291389f, 
    -0.17950630f, 0.09954628f, 0.13380179f, 0.14105564f, -0.12990537f, 0.10279252f, -0.12386224f, 0.15037808f, 
    -0.03810517f, 0.18261316f, 0.09056566f, 0.03743843f, -0.24846128f, -0.25537905f, -0.00534612f, 0.08759269f, 
    0.11260002f, 0.02463768f, -0.19529355f, -0.04613920f, -0.10215295f, -0.21957085f, -0.01549913f, 0.01708347f, 
    -0.26597443f, 0.02019078f, -0.16647905f, -0.00673071f, -0.08335403f, 0.17730430f, -0.24886732f, -0.09931774f, 
    0.22640447f, 0.06794085f, 0.27779734f, 0.24876425f, 0.25206849f, 0.03063744f, 0.11690675f, 0.13058816f, 
    -0.04693203f, -0.06923592f, -0.02646193f, -0.12076651f, 0.20443676f, 0.40107754f, 0.22012724f, 0.16212165f, 
    0.08479045f, -0.06526241f, 0.16507201f, -0.02835824f, -0.01340438f, -0.15699695f, 0.05301195f, 0.28425819f, 
    -0.14252149f, 0.06027210f, 0.18189086f, 0.23076858f, 0.15711085f, 0.05527180f, -0.04784788f, 0.17464222f, 
    -0.11701445f, 0.03022796f, 0.20158713f, -0.02872119f, 0.58733565f, 0.25967842f, -0.03534497f, 0.07757597f, 
    -0.10479747f, 0.01145483f, -0.07940865f, 0.14168015f, 0.10879470f, -0.07150303f, 0.02373651f, 0.10067802f, 
    -0.15409131f, 0.44355348f, -0.09209255f, 0.12201861f, -0.01250992f, 0.08657891f, 0.21184939f, 0.17661944f, 
    -0.07631709f, 0.19547190f, 0.10214541f, 0.14200577f, -0.14564413f, 0.21687360f, 0.01383113f, 0.01685981f, 
    0.03870098f, 0.18632926f, -0.07966433f, -0.11282315f, -0.01991131f, 0.02454077f, 0.11693754f, -0.05547297f, 
    -0.54595166f, 0.24009016f, 0.10515641f, 0.19191737f, 0.04538090f, -0.00810935f, -0.03978178f, -0.03171484f, 
    0.27736643f, -0.11085121f, -0.06463810f, 0.04449019f, -0.55668730f, -0.00355390f, 0.02143891f, -0.14649354f, 
    0.04298928f, 0.02800871f, 0.12100767f, 0.14460744f, 0.08619659f, -0.08376583f, -0.15489154f, 0.01274937f, 
    -0.57215422f, 0.12371979f, -0.01299384f, -0.03746463f, -0.25036380f, -0.05377534f, 0.18415512f, 0.19046955f, 
    0.11329839f, 0.18877161f, 0.05560107f, 0.06986126f, 0.30511782f, -0.05938514f, -0.20679928f, -0.06804120f, 
    0.22156002f, -0.05003554f, 0.12695709f, -0.02169249f, -0.02254426f, 0.29238483f, -0.06360602f, 0.11731105f, 
    -0.42224458f, -0.16273607f, 0.57464695f, 0.26214617f, -0.00844656f, 0.02226114f, -0.03743807f, -0.07381151f, 
    -0.02585235f, 0.13581893f, -0.06856363f, -0.00044679f, -0.15799683f, -0.24923919f, 0.32525915f, 0.32104698f, 
    -0.07267361f, 0.22183704f, 0.00131738f, 0.02781483f, 0.02466021f, -0.17645139f, 0.12208237f, -0.00936508f, 
    -0.43832156f, -0.04257100f, 0.17805287f, -0.23969579f, -0.02395047f, 0.11426473f, -0.10775963f, 0.08264104f, 
    0.14935510f, -0.14098254f, 0.18875308f, 0.04797662f, 0.13219765f, 0.17559178f, -0.09641699f, 0.03177672f, 
    -0.12367278f, -0.09766242f, 0.07538696f, 0.25636339f, 0.04920450f, 0.11426941f, -0.05276053f, 0.24186389f, 
    0.28064057f, -0.46838853f, 0.20096707f, 0.15773638f, 0.09316225f, -0.05260387f, 0.37800005f, 0.07434854f, 
    -0.07018895f, 0.35617092f, -0.16209124f, -0.06789244f, 0.02574786f, -0.37665242f, -0.06920733f, 0.01061842f, 
    0.13944259f, 0.17469797f, -0.16017175f, 0.10007377f, -0.20358776f, 0.08039954f, -0.14574273f, -0.11764878f, 
    -0.05771813f, -0.09851994f, 0.02623868f, -0.05536680f, -0.20232666f, -0.06822938f, 0.03953516f, -0.00350628f, 
    0.07776939f, 0.19514343f, -0.08953790f, -0.05335817f, -0.43206361f, 0.19487934f, -0.11892635f, -0.10058854f, 
    0.16704734f, 0.14454520f, 0.01884864f, 0.23433594f, -0.00860711f, 0.03249092f, -0.07344074f, 0.14813773f, 
    -0.21085492f, -0.00514998f, 0.25064012f, -0.17266113f, -0.03121286f, 0.06249317f, 0.23768976f, -0.06322259f, 
    -0.06532680f, 0.00910376f, 0.40666431f, 0.06024242f, -0.00518884f, 0.02561638f, 0.20582467f, -0.03167873f, 
    0.10062755f, 0.31237742f, 0.03180476f, -0.02834756f, -0.09924533f, 0.25141203f, 0.10057922f, 0.16087021f, 
    -0.00921987f, -0.03779711f, 0.01511243f, 0.02917047f, 0.01325664f, -0.00964737f, -0.04717286f, -0.01755193f, 
    0.01058824f, -0.00477556f, 0.04446859f, -0.05300456f, -0.03648049f, -0.03726166f, 0.00594796f, 0.01163715f, 
    -0.01118460f, 0.03574757f, 0.03099491f, 0.02024223f, 0.01778041f, -0.00489989f, 0.01260263f, -0.04176079f, 
    -0.03526977f, -0.00122541f, -0.00194150f, -0.01799935f, -0.02542647f, 0.04346192f, -0.00587750f, -0.01869935f, 
    -0.02875018f, 0.02372666f, -0.05731466f, -0.03766535f, 0.02820786f, -0.02533724f, -0.04268620f, 0.01057565f, 
    -0.03938421f, -0.04579367f, -0.01987915f, -0.02121246f, 0.01604840f, -0.03937795f, 0.02092916f, -0.04412416f, 
    -0.02953498f, 0.04108017f, 0.01376753f, 0.01592333f, 0.00250659f, 0.02955938f, -0.03656301f, -0.03495468f, 
    -0.02824042f, -0.03453157f, -0.04158070f, -0.04499565f, 0.02517194f, 0.01045036f, -0.02857314f, 0.01347286f, 
    -0.05667559f, -0.04650850f, -0.04028545f, 0.02899914f, 0.03899761f, -0.04628836f, -0.00534720f, 0.00404484f, 
    -0.04905316f, -0.02057912f, -0.01354321f, -0.04613772f, -0.02327856f, 0.01621702f, 0.01637462f, 0.01338949f, 
    -0.04583371f, -0.01848808f, -0.00702478f, -0.04536739f, 0.02533075f, -0.03822873f, -0.00155476f, -0.02441526f, 
    0.01115962f, -0.02972406f, -0.04789374f, -0.02099259f, -0.02075319f, 0.02383307f, 0.00967855f, 0.04230614f, 
    -0.00026429f, 0.02524376f, 0.00980741f, -0.01597766f, -0.04413255f, 0.00035637f, -0.00754075f, -0.03385495f, 
    -0.04836693f, 0.00601231f, 0.01321572f, -0.01099823f, 0.03491688f, 0.04338079f, 0.04388140f, -0.01415893f, 
    0.02763202f, -0.03765177f, 0.01790242f, 0.02976644f, -0.03767536f, 0.01104836f, 0.02178684f, 0.02221390f, 
    -0.01975441f, -0.03661621f, 0.03434492f, -0.04803358f, 0.01026835f, -0.03812847f, 0.03009177f, -0.02828411f, 
    0.01060290f, -0.02506355f, 0.03433883f, -0.04621684f, 0.02403384f, 0.01433105f, -0.01731540f, -0.03666997f, 
    0.01353662f, 0.01050480f, 0.00554180f, 0.01531532f, -0.02205598f, 0.03483875f, 0.00708707f, -0.00016637f, 
    0.01860091f, 0.02757326f, 0.01890078f, 0.01857155f, 0.00231910f, -0.03025731f, 0.02712331f, 0.02188965f, 
    -0.02769424f, 0.01048119f, -0.04328983f, 0.04216979f, -0.00224162f, 0.01983664f, -0.05573922f, 0.01494537f, 
    0.00809972f, 0.01211794f, -0.01173920f, -0.03976150f, 0.03453481f, -0.01388650f, -0.03272143f, -0.03340512f, 
    0.02868053f, -0.04030799f, 0.04082006f, -0.03409264f, -0.02216543f, 0.01701888f, -0.00029571f, -0.02375839f, 
    -0.04853290f, -0.03425526f, 0.02402191f, 0.04141490f, -0.02423611f, 0.00587356f, 0.00844485f, -0.00976438f, 
    -0.03770152f, 0.04563136f, 0.03500244f, -0.01393282f, 0.00651265f, 0.02558043f, 0.02725045f, -0.01450063f, 
    -0.00820252f, -0.02628907f, -0.01297054f, 0.03160882f, -0.04107795f, -0.00899047f, -0.01510252f, 0.01010189f, 
    0.03515201f, -0.00809879f, -0.05126173f, -0.02037791f, 0.04218755f, -0.02790106f, 0.03931100f, -0.01411263f, 
    0.02559736f, -0.05565641f, 0.00755161f, -0.02167156f, 0.00259302f, -0.02014902f, -0.05074720f, 0.00615614f, 
    -0.03303266f, -0.01185938f, 0.02292027f, -0.03042247f, 0.03334548f, -0.01386344f, 0.02278744f, -0.03724651f, 
    -0.03867313f, -0.00663563f, -0.01224343f, -0.01260274f, 0.03095059f, -0.02609234f, 0.00538311f, 0.03599225f, 
    0.02899539f, -0.03417988f, 0.00977045f, -0.02527142f, 0.00141954f, 0.04315317f, 0.00101406f, -0.01461395f, 
    0.01311689f, -0.01589177f, -0.00241923f, 0.01245981f, -0.05410467f, 0.02304564f, 0.01321025f, 0.03052889f, 
    -0.05254363f, 0.03230724f, -0.02825700f, 0.02221630f, 0.01810195f, 0.03887442f, -0.04982376f, -0.00678089f, 
    -0.03915215f, 0.04129849f, 0.03226578f, -0.04896136f, 0.03146162f, -0.00540697f, -0.04924349f, 0.02773664f, 
    0.04354586f, -0.02041326f, -0.04923330f, -0.05144016f, 0.03178346f, -0.05703722f, 0.03052781f, -0.01117490f, 
    -0.05526109f, -0.03372569f, -0.02710714f, -0.00498006f, -0.01859987f, -0.05463869f, 0.04051862f, -0.04635717f, 
    -0.04210879f, -0.03094084f, 0.02732520f, 0.03451854f, -0.04739738f, -0.05495964f, 0.04115687f, 0.02620919f, 
    -0.01022819f, -0.01374396f, -0.02900168f, 0.04117321f, 0.03097858f, -0.03699513f, -0.00733350f, -0.05144772f, 
    0.02490592f, 0.00083731f, -0.00942823f, 0.00878005f, 0.04026651f, 0.04764704f, -0.01212177f, -0.02968983f, 
    -0.02864957f, 0.01809587f, 0.02091467f, -0.00621244f, -0.01194079f, 0.01917424f, -0.05443548f, 0.01041028f, 
    0.01480408f, -0.01385844f, -0.02297925f, 0.00357207f, 0.01210524f, -0.01614501f, 0.00378820f, 0.00767264f, 
    0.03726944f, 0.00610963f, 0.02311340f, -0.01151889f, 0.03510790f, 0.02674366f, -0.04750631f, 0.00918336f, 
    0.04203223f, 0.04096487f, 0.04006916f, 0.03235937f, 0.03547901f, 0.02376119f, -0.04283831f, -0.02288299f, 
    0.00352645f, 0.00707324f, 0.04779627f, 0.00289187f, -0.03483089f, 0.03513331f, -0.01775409f, 0.03593267f, 
    0.00175289f, -0.01111094f, -0.04732379f, -0.02427149f, -0.03970675f, 0.03940618f, 0.03459083f, 0.00096024f, 
    0.03348742f, 0.00005447f, 0.01481296f, 0.01350582f, -0.02102766f, 0.03071257f, -0.03327446f, -0.02112087f, 
    -0.01014091f, 0.04176853f, -0.01280889f, -0.00126318f, -0.00204666f, -0.05414050f, 0.04339546f, -0.05006870f, 
    -0.03291891f, -0.03768716f, 0.02628732f, -0.05092493f, -0.01151748f, -0.04769854f, -0.01054932f, -0.00820289f, 
    -0.04263858f, 0.02797341f, 0.04952569f, -0.02028451f, 0.00945650f, -0.02231086f, -0.01421246f, -0.04061668f, 
    0.03965468f, 0.02935940f, -0.03689768f, -0.03641088f, -0.03494851f, 0.01465624f, -0.02504398f, 0.03273435f, 
    -0.03068381f, -0.01825709f, -0.04197841f, 0.02519182f, -0.03340864f, 0.03328118f, -0.00246786f, 0.00352327f, 
    -0.03405239f, 0.00991582f, 0.04315722f, -0.04446543f, -0.05397215f, -0.03358578f, -0.01542678f, 0.02199617f, 
    0.02806788f, -0.03966890f, -0.01370738f, 0.00297603f, -0.03391249f, -0.01208462f, 0.03675627f, 0.03956418f, 
    -0.00446076f, -0.04680774f, -0.04216425f, -0.00834748f, 0.02668046f, -0.02020746f, -0.01284033f, 0.02581984f, 
    0.01172188f, -0.02062905f, 0.04174946f, -0.05341598f, 0.00067085f, -0.03615292f, -0.00458482f, -0.00348372f, 
    0.00976634f, -0.02924602f, 0.00213561f, 0.03432418f, -0.01451156f, 0.02660619f, -0.01517674f, -0.01372113f, 
    0.00934799f, 0.02180427f, 0.01318440f, -0.05101529f, -0.00344053f, 0.03860400f, -0.01494706f, -0.01821093f, 
    0.03754903f, 0.02898515f, -0.03119831f, -0.00305471f, -0.02004929f, -0.05578329f, 0.02531350f, 0.00852558f, 
    0.03558011f, -0.03461230f, 0.00419880f, -0.05149506f, 0.01484993f, 0.00055807f, 0.03420273f, -0.05446921f, 
    -0.00644097f, -0.01298202f, -0.01486266f, 0.03421628f, -0.02166250f, -0.01387161f, -0.01322334f, -0.02156661f, 
    0.00384977f, -0.00127294f, 0.00909618f, -0.00712297f, 0.02181757f, 0.01139296f, -0.04365433f, -0.04699124f, 
    0.02178284f, 0.02855985f, -0.03995517f, 0.00685047f, 0.02095584f, -0.03998351f, 0.01098221f, 0.01135054f, 
    -0.02521882f, -0.03111751f, 0.00757452f, -0.02530124f, 0.03722790f, -0.03528552f, -0.03525945f, 0.03418241f, 
    -0.04823142f, -0.01021689f, -0.05498299f, 0.04275797f, -0.04621483f, 0.00789635f, -0.02232422f, 0.04271195f, 
    0.00481902f, 0.02681594f, -0.00668386f, -0.00727174f, 0.00732184f, -0.03603828f, 0.03601202f, -0.00584447f, 
    -0.02715550f, 0.01761035f, -0.02784088f, -0.05553516f, 0.00626289f, 0.00569085f, 0.01817565f, -0.05350184f, 
    -0.04459921f, -0.02184608f, -0.01800874f, -0.02705852f, -0.01404397f, -0.00171828f, 0.02670322f, -0.01959941f, 
    -0.04854731f, 0.03460081f, -0.05682982f, -0.05222960f, -0.04368773f, 0.03848344f, -0.01833600f, 0.01744349f, 
    -0.04849333f, 0.02549591f, 0.00761184f, 0.00922384f, 0.01462679f, -0.02750426f, -0.04680166f, -0.05798822f, 
    -0.01958130f, -0.03469102f, 0.00308260f, 0.00439353f, -0.00290366f, 0.03334189f, 0.03991069f, -0.01165374f, 
    0.00857321f, -0.02302705f, 0.00681239f, -0.01091217f, -0.03275172f, -0.05525595f, 0.01083142f, -0.02734907f, 
    -0.02799881f, -0.01366808f, -0.01222226f, 0.02856824f, -0.01679705f, -0.02255997f, -0.02709014f, 0.02600146f, 
    -0.00007346f, 0.00091325f, -0.03240551f, 0.01670121f, -0.02710608f, 0.01213969f, 0.00681582f, -0.00238663f, 
    0.03902055f, 0.00348695f, 0.01011598f, 0.00077072f, -0.00985142f, 0.03670459f, -0.03456102f, -0.03200149f, 
    0.04224753f, 0.02646801f, 0.03184046f, -0.01432459f, -0.05287938f, -0.05853423f, -0.03946756f, 0.02737418f, 
    0.01947490f, 0.01624431f, -0.05759173f, -0.02969408f, 0.02835663f, 0.01641487f, 0.02718693f, 0.01649036f, 
    -0.01882967f, 0.03639313f, 0.00257409f, 0.01480432f, 0.04129270f, -0.05218224f, -0.03255594f, -0.00657764f, 
    0.03067023f, 0.03065197f, -0.01512582f, -0.01721596f, -0.04216687f, -0.03327575f, 0.00688964f, -0.04121819f, 
    -0.02068257f, -0.00001698f, -0.00263265f, -0.03043422f, 0.01952494f, 0.00062793f, 0.03858880f, 0.03266811f, 
    -0.04137042f, -0.05774013f, 0.03621315f, 0.02587680f, -0.05308748f, -0.01471151f, 0.02787988f, 0.00328123f, 
    -0.05214976f, 0.03205487f, -0.04884628f, -0.01199122f, -0.02605886f, 0.01354185f, 0.02553044f, -0.03519075f, 
    0.03346027f, -0.04244509f, -0.02656532f, -0.03541055f, -0.03201285f, -0.05243626f, -0.00488394f, -0.01620082f, 
    -0.02298680f, 0.01382896f, -0.02955227f, -0.03450436f, 0.02320727f, 0.03829217f, -0.04064332f, -0.03858786f, 
    -0.04613268f, -0.01345375f, 0.03103947f, 0.01855301f, -0.02868984f, -0.02610736f, -0.03697839f, 0.00651663f, 
    -0.02401162f, 0.01154719f, -0.04518566f, 0.01356623f, 0.02952597f, -0.03816249f, -0.03511132f, -0.05485831f, 
    0.01968748f, -0.04620725f, 0.02886968f, -0.02205926f, 0.01671825f, -0.01987043f, 0.02167029f, -0.01696645f, 
    -0.05094172f, -0.01699854f, -0.02927106f, -0.02506100f, -0.05342328f, -0.05754994f, 0.00804468f, 0.03344096f, 
    0.00149491f, -0.04143359f, -0.00147524f, -0.00805714f, 0.02310769f, 0.00937412f, 0.00885505f, -0.01931351f, 
    -0.00666034f, 0.02015839f, 0.02896600f, 0.03922472f, -0.01730087f, -0.02443190f, -0.02992730f, 0.02809125f, 
    0.01505351f, -0.03290224f, -0.03801743f, 0.01483521f, 0.00357481f, 0.03719151f, 0.02253127f, 0.03057572f, 
    -0.04331578f, 0.00195504f, -0.02110812f, -0.00061277f, -0.05450607f, 0.04231311f, 0.03033218f, 0.02462194f, 
    -0.03138517f, 0.03237534f, -0.04845450f, -0.02378995f, -0.03130986f, -0.04191994f, -0.00052912f, -0.05531974f, 
    -0.03044807f, -0.00905779f, -0.02801560f, 0.01584809f, -0.01014247f, -0.04641906f, -0.04161696f, -0.02250669f, 
    0.01630657f, -0.02686175f, -0.05583524f, 0.01411382f, -0.02923603f, -0.00474187f, -0.03202648f, 0.00527253f, 
    -0.03335196f, -0.04378622f, -0.01176159f, -0.02497215f, 0.03400031f, -0.01687931f, -0.01839462f, 0.00761954f, 
    -0.04775970f, -0.02440132f, -0.04947719f, -0.02593880f, -0.00886967f, -0.05396354f, 0.03222835f, 0.03759364f, 
    -0.05566851f, 0.02028493f, 0.04444214f, -0.02444470f, -0.01052014f, 0.02362623f, 0.03052366f, -0.01993447f, 
    -0.00881261f, 0.03015411f, 0.00918028f, -0.05074786f, -0.01564856f, -0.03432582f, 0.00772815f, 0.02501976f, 
    -0.05610551f, -0.02971422f, 0.00091636f, -0.01913362f, 0.00787346f, -0.04591702f, -0.04957259f, 0.01020296f, 
    0.00897451f, -0.00648965f, -0.04788143f, 0.04291209f, -0.03435756f, 0.00738283f, 0.00784727f, -0.02333793f, 
    -0.05172956f, -0.00478327f, -0.04241155f, 0.01046385f, -0.05687710f, -0.04323835f, -0.02452346f, -0.01931954f, 
    0.03924950f, -0.03149547f, -0.02312515f, 0.01196964f, 0.02946302f, -0.05256351f, 0.02071640f, -0.00873046f, 
    0.02646548f, -0.03931483f, -0.06586691f, 0.04191544f, -0.00653616f, -0.03076535f, -0.04021647f, -0.02311509f, 
    -0.01675345f, 0.00382203f, -0.05065567f, 0.01974676f, -0.01147410f, -0.02703191f, -0.05737451f, 0.04083171f, 
    -0.00106612f, -0.04111538f, 0.00483973f, 0.03161708f, 0.04016079f, -0.02404144f, -0.00839084f, -0.03048236f, 
    -0.00257186f, -0.01289253f, -0.02783090f, -0.01891791f, 0.00184242f, -0.03607546f, -0.01957700f, -0.01296543f, 
    0.03408720f, 0.02843761f, 0.01802049f, 0.01141148f, -0.02607420f, -0.01054109f, -0.00154868f, 0.03459960f, 
    -0.00551392f, 0.02630104f, -0.02464886f, -0.00078692f, 0.04093099f, 0.03191090f, -0.02043847f, -0.03148978f, 
    0.00125942f, 0.03150650f, 0.03079543f, 0.01979939f, 0.01395569f, 0.00854146f, 0.02633055f, 0.03812804f, 
    0.02480016f, -0.04418638f, -0.06470301f, -0.02334568f, -0.03430726f, -0.02241323f, -0.01699071f, -0.04027441f, 
    0.02448026f, -0.01272173f, -0.00892630f, -0.06125350f, -0.05665854f, 0.01226997f, -0.04161646f, 0.03134990f, 
    0.01529622f, -0.03612169f, -0.04610175f, 0.00434900f, -0.00436975f, 0.02117594f, -0.02091800f, -0.00665261f, 
    -0.06018176f, -0.04396696f, -0.03001181f, -0.02577420f, 0.01075704f, 0.03069696f, -0.01517443f, 0.02500271f, 
    -0.02296663f, -0.00865316f, -0.03956788f, -0.04052735f, -0.04505559f, -0.06175258f, -0.03257000f, -0.00032323f, 
    0.02673708f, 0.01420514f, 0.00183264f, 0.03582939f, -0.06005295f, -0.04351249f, -0.06595415f, -0.03374431f, 
    -0.00468110f, -0.01327336f, -0.01058156f, 0.02374975f, 0.01094778f, -0.02258583f, -0.05355853f, -0.00840967f, 
    0.01644799f, -0.00702315f, -0.02229466f, -0.01172895f, 0.02673872f, -0.05256605f, 0.03593097f, -0.01703520f, 
    0.04159201f, -0.04400983f, -0.03489399f, 0.03651456f, -0.00140768f, 0.01414774f, 0.00534060f, 0.03772378f, 
    0.03784917f, 0.02440225f, 0.03176789f, -0.04127657f, -0.04187425f, -0.02394576f, 0.00985018f, 0.00618488f, 
    0.03658912f, 0.00493284f, 0.03871245f, -0.02340700f, -0.02130815f, 0.01787833f, 0.02301364f, -0.04928530f, 
    0.00653286f, -0.02003216f, -0.01346538f, 0.03592892f, -0.03633974f, 0.03848210f, 0.02245471f, 0.00659023f, 
    0.03708426f, -0.03103102f, -0.05807084f, -0.02610775f, 0.02237371f, 0.00459358f, -0.05047487f, 0.01881739f, 
    0.00499734f, 0.03241526f, -0.06182588f, 0.04016232f, -0.04753245f, -0.04907981f, 0.01008399f, 0.02341466f, 
    -0.00387618f, -0.05260904f, 0.02806904f, -0.00403670f, 0.01943932f, -0.04788538f, -0.06393265f, 0.03602309f, 
    -0.04606733f, -0.03464665f, 0.02592640f, -0.04910810f, -0.03313513f, 0.00582437f, -0.06557047f, -0.00920295f, 
    0.00409950f, -0.03383417f, -0.04077581f, -0.05031911f, -0.04438207f, 0.00300644f, 0.00355122f, 0.02740219f, 
    0.02154790f, -0.00423500f, -0.05360913f, 0.00311270f, -0.02787665f, -0.01762416f, 0.00646775f, -0.03623506f, 
    0.03025410f, 0.03758010f, 0.02177263f, -0.03312363f, -0.02880521f, 0.05286254f, -0.02599549f, -0.01978633f, 
    -0.04950600f, -0.03207721f, -0.04622569f, -0.07188894f, 0.04317874f, 0.01597274f, -0.02639190f, -0.02979247f, 
    0.00499319f, -0.04487632f, -0.03141659f, -0.04348452f, 0.00620390f, 0.01333984f, 0.03991231f, 0.03040314f, 
    0.00231989f, -0.04072962f, 0.03857750f, 0.03463250f, 0.03746410f, -0.01194147f, -0.00680820f, 0.01136409f, 
    0.01914772f, 0.00712030f, -0.00699436f, -0.05031040f, -0.01068577f, 0.01728069f, 0.01152621f, 0.00374492f, 
    0.01764773f, -0.04935904f, -0.00850217f, 0.01541091f, -0.02983517f, 0.03625868f, 0.01971195f, 0.00639724f, 
    -0.06784382f, -0.03816473f, -0.04196209f, -0.04462175f, -0.03719082f, 0.03501766f, -0.01158028f, 0.00705276f, 
    -0.00304000f, -0.02234316f, -0.03287116f, -0.02662838f, 0.03415647f, -0.03196092f, 0.00906895f, -0.05950334f, 
    -0.04319366f, -0.00375899f, -0.01402310f, -0.00584261f, -0.00977782f, 0.04224909f, -0.04858820f, -0.06182785f, 
    0.01202329f, -0.03875713f, 0.00646060f, 0.00803204f, 0.02180080f, -0.03172787f, -0.01793757f, -0.04255310f, 
    0.02465570f, 0.01666162f, -0.01953006f, -0.05765242f, -0.02151194f, 0.03483699f, -0.02739197f, -0.03962834f, 
    -0.04169136f, -0.01351611f, -0.04041323f, -0.04871567f, -0.01706334f, -0.03700554f, -0.02842539f, -0.01111819f, 
    0.00958651f, -0.01700831f, 0.00475358f, 0.01571277f, 0.03016090f, 0.00143181f, -0.04151792f, -0.00138906f, 
    0.02218088f, 0.03448093f, 0.02724826f, 0.02628854f, -0.00515279f, -0.02115408f, -0.03921626f, 0.03415425f, 
    0.01665227f, -0.05758293f, 0.01270231f, 0.02387242f, 0.00879480f, 0.01874361f, 0.02874249f, 0.03582373f, 
    -0.04011652f, 0.01579303f, -0.01876484f, 0.01185236f, 0.03451305f, 0.03289087f, -0.04030693f, 0.01275700f, 
    -0.01150400f, -0.01065700f, -0.02551574f, -0.03896200f, -0.04648100f, -0.00596949f, 0.04867161f, -0.04561486f, 
    -0.06367280f, 0.02870101f, 0.02834219f, 0.00041926f, 0.02733287f, -0.05624714f, -0.04131279f, -0.04202349f, 
    0.10446269f, -0.22670406f, 0.03312135f, -0.18670438f, -0.10583404f, 0.06233849f, 0.10905459f, 0.05669248f, 
    -0.02839095f, -0.11929476f, -0.10907222f, -0.05945897f, 0.40054142f, 0.43801293f, 0.21139269f, 0.25563160f, 
    0.21042822f, 0.06840058f, 0.05534627f, 0.00845620f, 0.12906295f, 0.11104867f, -0.05585702f, 0.05139576f, 
    -0.42686909f, -0.13598697f, 0.04137002f, 0.04821105f, 0.05818306f, -0.01923776f, 0.11640319f, 0.15107766f, 
    -0.02460666f, -0.02401111f, -0.04800070f, 0.03458328f, 0.12353024f, -0.17273499f, -0.28569505f, -0.03165775f, 
    0.03287730f, 0.11765325f, -0.01130766f, -0.01634886f, 0.14819428f, -0.15209067f, 0.00388974f, -0.01016911f, 
    -0.27403933f, -0.12795423f, 0.12249117f, 0.15857722f, 0.11570455f, 0.06936250f, 0.08177305f, 0.15903227f, 
    0.01902071f, -0.03009247f, 0.05842074f, -0.08957406f, 0.11836627f, 0.02136157f, 0.16897415f, 0.14895324f, 
    0.16965726f, 0.07965492f, -0.01854514f, -0.00901225f, -0.10376475f, -0.03944402f, -0.01089845f, 0.16328022f, 
    -0.21914062f, -0.21774317f, 0.18610297f, 0.24722792f, 0.23474373f, -0.15010218f, 0.07417260f, -0.00324366f, 
    -0.03173330f, -0.05920481f, -0.06329463f, -0.20303240f, -0.23494323f, 0.01325401f, -0.30832988f, -0.12187413f, 
    -0.16285834f, 0.01235213f, -0.06213643f, -0.03186976f, -0.00711491f, 0.02168803f, -0.07411334f, -0.15516008f, 
    -0.24501836f, 0.26756522f, -0.19300954f, -0.14186056f, 0.07327047f, -0.04790368f, 0.00037738f, 0.15758303f, 
    -0.11622010f, 0.14103790f, 0.11312301f, -0.04957154f, -0.51420063f, -0.51053911f, -0.07110609f, -0.49472067f, 
    -0.16243157f, 0.17337571f, 0.00971477f, -0.19251280f, 0.05738986f, -0.10905586f, 0.20388412f, 0.07307407f, 
    0.67628300f, -0.00493355f, 0.20576866f, 0.31490675f, 0.01557131f, -0.08802110f, 0.07435124f, -0.12077166f, 
    0.01695024f, -0.09809843f, 0.10364217f, -0.01063512f, 0.53858292f, 0.03661000f, -0.05216356f, -0.19765912f, 
    -0.10575899f, -0.23290126f, 0.13096809f, -0.01035938f, -0.04227918f, -0.13836682f, -0.04500123f, 0.00673507f, 
    -0.03485075f, 0.12694368f, 0.15694934f, 0.17272273f, 0.03761696f, 0.00031367f, 0.07131864f, 0.08745575f, 
    0.07732483f, -0.00681614f, 0.16345964f, 0.01828712f, 0.03393120f, -0.05571155f, -0.05405118f, -0.10191608f, 
    -0.03141958f, -0.21224879f, -0.02574929f, 0.05224921f, 0.04254727f, 0.09264223f, 0.02732263f, 0.02851216f, 
    -0.50899214f, 0.22615293f, 0.00600043f, 0.09037302f, 0.05779203f, -0.05868398f, -0.02551017f, 0.00087640f, 
    -0.03898240f, 0.02138226f, -0.16411585f, 0.03823148f, -0.18812604f, -0.12166732f, -0.08753924f, 0.08625204f, 
    -0.06583553f, -0.00345917f, 0.11834878f, -0.05582216f, 0.14815825f, -0.17281151f, -0.10487991f, 0.05460624f, 
    -0.40229964f, -0.27684048f, -0.09001046f, -0.27633125f, 0.15579183f, 0.17296565f, 0.04630347f, 0.10895416f, 
    0.00213396f, -0.03708732f, -0.16456366f, -0.08353699f, 0.38187027f, 0.22916324f, 0.07037579f, 0.35267067f, 
    0.12676130f, 0.01950708f, 0.13434024f, -0.03436989f, -0.12056145f, 0.04285061f, -0.23259604f, 0.16503429f, 
    0.10803113f, -0.04222911f, 0.15474622f, 0.02699438f, 0.04242807f, -0.04642440f, 0.00803408f, 0.15295178f, 
    0.08979648f, -0.00789991f, 0.32893407f, -0.06909883f, 0.40585819f, 0.17199443f, 0.07435619f, 0.12568438f, 
    0.06811751f, 0.18918367f, 0.04318507f, -0.01631320f, -0.11824261f, 0.08340135f, 0.25413707f, -0.12213290f, 
    0.36129358f, 0.06042574f, 0.03204599f, 0.20095287f, 0.19016352f, 0.05781058f, -0.07051997f, 0.01240409f, 
    0.06307760f, 0.04056325f, 0.07617037f, 0.03419754f, -0.08521448f, -0.06488090f, 0.30017036f, 0.49910459f, 
    0.27301848f, -0.03288624f, -0.06506938f, 0.13152033f, 0.07407307f, -0.06624917f, 0.09920455f, -0.15361550f, 
    -0.02256444f, -0.22445130f, -0.06762883f, 0.03444624f, -0.13286060f, -0.12743413f, 0.17225194f, -0.00771661f, 
    0.06182219f, -0.01012644f, 0.11609104f, 0.00466673f, -0.05715648f, -0.02495092f, -0.04268437f, -0.02922206f, 
    -0.17419977f, -0.10309953f, -0.06299680f, -0.22317824f, 0.14879113f, 0.30166677f, 0.03120217f, 0.01730882f, 
    0.90593427f, 0.13147855f, 0.16712885f, -0.11256117f, -0.13984132f, -0.22151481f, -0.09292487f, -0.10581021f, 
    -0.12563139f, 0.07005297f, -0.07444933f, 0.20390828f, 0.12723893f, 0.33281565f, 0.08154264f, 0.14013435f, 
    -0.03446375f, 0.13991325f, -0.02704926f, -0.01914531f, -0.09034899f, 0.03714947f, 0.12902738f, -0.05288564f, 
    0.28170851f, 0.13119379f, 0.21990390f, -0.19065662f, -0.01465280f, -0.03235072f, 0.04017181f, 0.04679788f, 
    -0.09491997f, 0.00954033f, 0.07841695f, 0.07403304f, 0.08144078f, -0.17754623f, 0.16373624f, -0.08621476f, 
    0.12518099f, -0.10620323f, -0.07617643f, 0.04732280f, -0.05660722f, 0.03591229f, 0.03582869f, -0.06220957f, 
    0.25452435f, 0.03697374f, 0.34003821f, 0.00882760f, 0.13281482f, -0.07829244f, -0.11055133f, -0.00830527f, 
    0.04303383f, -0.01701136f, -0.00652045f, 0.01635293f, -0.33384481f, 0.37084022f, -0.18759587f, 0.04890183f, 
    0.04128528f, 0.11648081f, -0.01924415f, 0.06475020f, -0.03874848f, 0.11924817f, 0.02263413f, 0.16303173f, 
    0.25621876f, 0.17743643f, 0.02778119f, 0.48503646f, 0.05940008f, 0.07852698f, -0.12065824f, 0.35402653f, 
    0.04701725f, 0.06683405f, -0.13025236f, -0.01469159f, -0.17535365f, 0.20282517f, -0.22909832f, 0.09278366f, 
    0.00503490f, -0.07046140f, -0.09087385f, -0.06685497f, 0.00889251f, -0.13421263f, 0.05540213f, -0.03137658f, 
    -0.03428927f, -0.01197001f, -0.03275932f, -0.04710521f, -0.00791963f, 0.02148368f, -0.04624976f, -0.03767139f, 
    0.03721787f, 0.00136286f, -0.02639106f, -0.02890769f, 0.00480573f, 0.00366166f, 0.01069366f, 0.04873781f, 
    -0.05608037f, 0.00218274f, 0.01404809f, -0.05353470f, 0.03653197f, 0.00425415f, 0.02809177f, -0.00785731f, 
    0.00659315f, -0.00144098f, 0.04134132f, -0.05184042f, -0.04217874f, 0.01860693f, 0.02301912f, -0.00127700f, 
    0.03375699f, -0.04805311f, -0.04890736f, 0.03133843f, -0.00881575f, -0.03961247f, -0.01955359f, 0.01937152f, 
    -0.05469141f, -0.04654263f, 0.03864042f, -0.03838686f, -0.04900670f, 0.04647207f, 0.01981056f, 0.01892478f, 
    -0.03347529f, -0.00029271f, 0.03093796f, 0.04113731f, -0.01841556f, -0.00478977f, 0.04553977f, 0.01971535f, 
    -0.02316840f, 0.01021971f, 0.01819131f, 0.04188218f, -0.03013394f, -0.02450028f, 0.00368851f, -0.02063171f, 
    0.04407264f, -0.02280066f, -0.00615679f, 0.01423678f, 0.03745127f, 0.01135243f, -0.05133427f, 0.02860702f, 
    -0.04390037f, 0.00245749f, -0.03579323f, -0.00867467f, 0.03700806f, -0.03498070f, 0.03068748f, 0.00842253f, 
    -0.04787363f, -0.04853607f, -0.02374818f, -0.05743182f, -0.03138603f, -0.03291523f, -0.00007439f, 0.02983453f, 
    0.02675925f, -0.00075961f, 0.01434922f, -0.01983796f, -0.05032096f, 0.03651760f, 0.02801797f, -0.02410869f, 
    0.04163006f, -0.02239273f, -0.04223061f, -0.04147056f, 0.02623277f, -0.04138286f, -0.02049104f, -0.01142467f, 
    -0.00152894f, 0.01416960f, -0.01631780f, 0.04355310f, -0.04240357f, 0.00831879f, -0.00571347f, 0.03335412f, 
    0.01368691f, 0.02843740f, -0.05497095f, 0.04316423f, -0.01043714f, 0.01176581f, 0.00019668f, -0.02092374f, 
    0.04319358f, 0.00588043f, -0.01190624f, -0.00727621f, -0.04527519f, 0.02889028f, 0.00214985f, -0.05015046f, 
    -0.04002266f, -0.04066082f, -0.05013536f, -0.03001654f, 0.01446614f, -0.01643009f, -0.00193242f, -0.00374774f, 
    0.01689827f, -0.02600273f, 0.04200778f, 0.02782597f, -0.00094173f, -0.01423952f, -0.01889248f, 0.04136293f, 
    -0.00727766f, 0.02459952f, -0.00898249f, 0.00518077f, 0.00317634f, -0.04494309f, -0.02429393f, 0.01179403f, 
    0.00303250f, 0.03479619f, -0.03158661f, 0.03147857f, 0.00669402f, 0.03628200f, -0.02298169f, 0.00792595f, 
    -0.02662709f, 0.02975918f, -0.04429629f, -0.05462176f, 0.00221730f, 0.04160338f, 0.02941033f, 0.01060393f, 
    -0.00469349f, -0.03262155f, -0.05225390f, -0.03109863f, 0.02281083f, -0.00910950f, 0.04478274f, -0.02605089f, 
    -0.03585493f, 0.04001318f, -0.01839051f, 0.03867959f, -0.04602576f, 0.03329775f, -0.04640018f, 0.03575009f, 
    0.03993027f, -0.03752597f, -0.02713442f, -0.03233932f, 0.03143540f, -0.04809810f, -0.01336230f, -0.02681228f, 
    -0.01306187f, -0.00566188f, -0.03495823f, -0.04195528f, 0.02723843f, 0.02833580f, 0.03318560f, -0.03214370f, 
    -0.02169088f, 0.03332337f, 0.02558195f, -0.03920524f, -0.05400982f, 0.01078735f, -0.01473930f, 0.03316491f, 
    0.01364064f, -0.05137595f, -0.04615469f, -0.01983724f, -0.02998729f, 0.00081228f, 0.04362914f, 0.02842371f, 
    -0.05294173f, -0.05753807f, 0.00986366f, -0.00473765f, -0.05696208f, -0.01620381f, -0.03725088f, 0.01398920f, 
    -0.00708672f, 0.04749371f, -0.01721470f, 0.04179809f, 0.00088429f, 0.02938599f, 0.01562759f, -0.02197522f, 
    0.03805375f, 0.03704229f, 0.01526134f, -0.04152514f, -0.01975098f, -0.03049756f, -0.00813744f, 0.01144299f, 
    -0.00320876f, -0.02938480f, 0.00124515f, 0.04646318f, 0.02306283f, 0.03258984f, -0.00121452f, 0.04810978f, 
    0.00117641f, -0.04694185f, -0.00059312f, 0.04117068f, -0.01353634f, 0.01749047f, 0.01750213f, -0.01649315f, 
    -0.03092041f, -0.02484630f, 0.00771696f, -0.03240718f, 0.03699797f, -0.04882846f, -0.04791565f, -0.02539800f, 
    0.02763193f, -0.03203596f, -0.02503487f, 0.01744818f, 0.03239240f, -0.04356679f, -0.01481765f, -0.02490075f, 
    0.00915705f, -0.03935599f, -0.01540193f, 0.00254082f, -0.05158766f, 0.04465707f, -0.04031768f, 0.02261416f, 
    -0.00690874f, 0.00205065f, 0.00245659f, -0.00114198f, -0.04075190f, 0.03173777f, 0.02263789f, -0.04287527f, 
    0.03767214f, -0.04858291f, -0.00042245f, -0.01123345f, -0.04359628f, -0.05484138f, -0.04869689f, 0.03056415f, 
    -0.04121790f, -0.03406394f, -0.00226371f, -0.02011671f, -0.00050745f, 0.04014049f, -0.03927760f, 0.03557758f, 
    0.01107474f, -0.01982200f, -0.03094189f, -0.03117837f, -0.00821010f, 0.02844539f, -0.02549910f, -0.00618822f, 
    -0.04365762f, 0.01274775f, 0.01479521f, 0.00319167f, 0.03668637f, -0.00262184f, -0.00807673f, -0.00227037f, 
    -0.00675588f, 0.02716579f, -0.04269612f, -0.02117989f, -0.02692021f, -0.03609583f, -0.04627282f, 0.04508456f, 
    -0.00890789f, 0.00299360f, -0.00108324f, 0.04291481f, 0.02542129f, 0.01052587f, -0.03055244f, -0.00663179f, 
    0.01158836f, 0.02004610f, -0.05054450f, 0.03032528f, -0.04849178f, 0.00065338f, -0.03846264f, 0.04388815f, 
    0.03538231f, -0.01669260f, 0.02936255f, 0.01574815f, -0.03626097f, 0.04733275f, 0.03090746f, 0.02717186f, 
    -0.02752694f, -0.01704078f, -0.05222242f, -0.02327152f, 0.04037901f, 0.00998493f, -0.01203565f, 0.04217462f, 
    -0.03588912f, -0.03003378f, 0.02648227f, 0.03924848f, -0.00300388f, -0.02684479f, -0.02251079f, -0.04261338f, 
    0.02662776f, 0.04076432f, -0.01198437f, -0.00401545f, -0.01390983f, 0.03808517f, -0.02079426f, 0.00818364f, 
    0.00813648f, -0.03102329f, 0.01397472f, 0.01918218f, -0.02357144f, 0.02338166f, -0.05836898f, 0.02209899f, 
    -0.03951386f, -0.00467802f, 0.03511047f, -0.03466523f, 0.03340984f, -0.03455335f, -0.00044662f, -0.00041712f, 
    -0.04367077f, -0.00496347f, -0.02323630f, -0.03827239f, 0.02362155f, 0.00875448f, -0.02706910f, -0.01722960f, 
    0.02514355f, -0.05022855f, -0.02055994f, -0.00396236f, 0.03518670f, 0.01974068f, 0.03405711f, -0.01329950f, 
    -0.05194166f, 0.02744683f, 0.00779463f, 0.03289681f, -0.04022508f, -0.01608109f, -0.00050241f, -0.01115937f, 
    -0.03683841f, -0.05209944f, -0.00940952f, -0.02458891f, 0.03321884f, -0.04717669f, -0.03208778f, 0.00575413f, 
    0.00788189f, -0.05584166f, 0.00003374f, 0.04727669f, -0.03021152f, -0.01237015f, -0.03396415f, 0.02561775f, 
    -0.04084258f, 0.02485861f, 0.00625152f, 0.01586805f, -0.04728055f, 0.01554462f, -0.00688444f, -0.01080298f, 
    0.00021753f, 0.00508608f, 0.02701488f, 0.02287359f, -0.03965438f, -0.00703964f, 0.00819068f, -0.00675492f, 
    0.02349528f, -0.02808580f, -0.03115697f, -0.00926186f, -0.00477790f, 0.00926238f, 0.01003150f, 0.01736906f, 
    -0.01314507f, -0.00242293f, 0.02014228f, -0.00512383f, 0.03227239f, -0.01511999f, -0.00296378f, -0.01854024f, 
    -0.00982914f, -0.03635341f, 0.00539539f, 0.02056843f, -0.00090879f, 0.04228418f, -0.04652372f, 0.01228831f, 
    -0.05627032f, 0.03370221f, 0.00504655f, 0.04186814f, -0.00640034f, -0.01984767f, 0.04305857f, 0.02724778f, 
    -0.02561052f, -0.02823664f, 0.00734953f, -0.02083780f, -0.04421895f, 0.03607168f, -0.04238379f, 0.03390658f, 
    0.02082615f, -0.02752654f, 0.03421666f, 0.04016645f, 0.00177444f, -0.03807938f, -0.04634050f, -0.03164671f, 
    -0.05165882f, -0.00681611f, -0.02733424f, 0.01071354f, 0.04489145f, 0.00695438f, -0.00732536f, 0.02623582f, 
    0.01717491f, -0.03704873f, -0.04084842f, -0.04953786f, 0.00238551f, -0.04653598f, 0.02087943f, -0.04525258f, 
    -0.00226518f, -0.05417556f, -0.03942955f, 0.02616887f, -0.01765264f, -0.04042558f, -0.04864518f, -0.03580233f, 
    -0.01872224f, -0.04543092f, 0.02314720f, 0.01921573f, 0.03931052f, -0.00693559f, 0.02494556f, -0.02390699f, 
    0.04122386f, -0.02970959f, 0.03213766f, -0.05095515f, 0.02578092f, -0.03394092f, -0.04904350f, -0.01020129f, 
    -0.03376963f, 0.02617058f, -0.05389922f, 0.00050858f, -0.03892387f, -0.04948994f, -0.03314335f, -0.00820962f, 
    0.02659584f, -0.03024306f, 0.00349038f, -0.00666787f, 0.02376077f, -0.03517487f, -0.01682423f, -0.03514804f, 
    0.01419446f, -0.04235424f, -0.04482376f, -0.03703487f, -0.02560477f, 0.04230546f, -0.04151172f, 0.00031957f, 
    -0.01119925f, -0.00699428f, -0.00166464f, -0.05449605f, 0.03556788f, 0.02562596f, -0.00945412f, -0.05206012f, 
    -0.04148501f, -0.05651704f, 0.04463669f, -0.03622482f, -0.00854534f, -0.03031628f, -0.01622716f, -0.00819274f, 
    0.01742753f, -0.03640671f, -0.00930066f, 0.02852465f, 0.02780031f, 0.04471521f, -0.02845750f, -0.01651040f, 
    -0.05323100f, -0.05037163f, 0.00167848f, -0.01773885f, -0.05136767f, 0.00123508f, -0.01229683f, -0.05523000f, 
    0.04225927f, 0.01920051f, -0.04507795f, 0.00299452f, -0.01615369f, -0.03982743f, 0.04243875f, 0.04060108f, 
    0.02867612f, -0.01610760f, 0.03812445f, -0.01004956f, 0.02695594f, -0.01651558f, 0.01774076f, 0.03978238f, 
    -0.04851945f, -0.03121055f, -0.02800501f, 0.01058487f, -0.01574901f, 0.03193155f, 0.01413623f, 0.00940128f, 
    -0.03707192f, 0.03065882f, -0.01257599f, -0.03702157f, -0.04147432f, -0.00447765f, 0.02900083f, 0.01211735f, 
    -0.02272885f, 0.03028194f, -0.04477833f, -0.01125317f, 0.00969148f, -0.04804015f, -0.01978696f, -0.00863631f, 
    -0.02029231f, -0.05160835f, -0.04429476f, -0.03476413f, -0.03791540f, -0.05405601f, 0.04156353f, 0.01895474f, 
    -0.05183656f, 0.03091537f, -0.03766305f, -0.03373694f, -0.02764978f, 0.02288571f, -0.05363777f, -0.05003173f, 
    0.03746440f, -0.04462327f, 0.01398563f, -0.01136919f, -0.02484031f, -0.03463839f, 0.02508832f, -0.02555934f, 
    0.01394291f, -0.01915227f, 0.00998977f, 0.00176594f, -0.05149683f, 0.03190936f, 0.02364370f, 0.00483641f, 
    0.03665845f, 0.03465667f, 0.04284961f, 0.03046080f, -0.04682724f, -0.02780905f, -0.01130835f, 0.02555051f, 
    0.03609309f, -0.03732815f, -0.05252689f, 0.03850566f, -0.04877141f, -0.05044094f, -0.00485563f, -0.00724981f, 
    -0.04761634f, -0.03691369f, 0.03393168f, 0.02674028f, 0.02027781f, -0.05414371f, -0.01992377f, -0.01343743f, 
    -0.01632331f, 0.01471754f, -0.02086275f, 0.03774074f, -0.03865784f, 0.01091269f, 0.03764312f, 0.03673918f, 
    -0.04612384f, 0.02297117f, 0.01997158f, 0.01856550f, -0.00615896f, -0.04909995f, -0.00476432f, 0.02009415f, 
    -0.03157996f, -0.05189619f, 0.02004052f, -0.00437614f, 0.03957071f, 0.02620576f, -0.03327766f, -0.03772716f, 
    0.04146729f, 0.03516480f, 0.00085038f, -0.05664365f, 0.00345013f, -0.04436765f, -0.02494072f, -0.03923517f, 
    -0.03313762f, 0.02344151f, 0.00415660f, 0.03566287f, 0.04470543f, 0.00194730f, 0.03207639f, -0.04325844f, 
    -0.03415243f, -0.00684121f, -0.04624010f, -0.04337481f, 0.02639359f, -0.00634888f, -0.03126349f, -0.03992055f, 
    -0.03130594f, -0.00448552f, -0.04125469f, -0.03197954f, 0.00124281f, -0.00958401f, 0.01177184f, 0.00925321f, 
    0.03910280f, 0.03304387f, 0.00968416f, 0.03579120f, -0.01558764f, -0.02792126f, -0.03473891f, 0.02253390f, 
    0.02104241f, -0.01823014f, 0.00997619f, -0.02567016f, -0.03277111f, 0.00882482f, -0.00086907f, 0.04454703f, 
    -0.02771109f, 0.01538336f, -0.02609910f, 0.02170800f, 0.01434554f, 0.00107364f, -0.00552828f, -0.01494923f, 
    0.33180228f, 0.15222512f, 0.12875882f, 0.00703698f, -0.08622801f, 0.12081647f, 0.21586163f, 0.08011334f, 
    0.11011169f, -0.02415846f, 0.10924547f, 0.00498171f, -0.23040518f, -0.39105490f, 0.00038072f, -0.33145869f, 
    0.03781071f, -0.10518752f, -0.06607735f, 0.01329121f, 0.28028417f, -0.00755748f, -0.00222584f, 0.04242774f, 
    0.02333584f, 0.20753004f, -0.17952931f, -0.27833080f, 0.16373824f, 0.25100136f, 0.12889501f, -0.09989957f, 
    -0.10257058f, 0.10010576f, 0.02398358f, 0.02740658f, -0.04242907f, 0.27403080f, -0.25130558f, -0.10825992f, 
    0.14421922f, 0.11166599f, 0.01664996f, 0.13164684f, 0.00930049f, -0.00249523f, 0.22687876f, -0.05423568f, 
    0.26361942f, -0.25013298f, -0.11032579f, -0.09021426f, -0.17391382f, -0.01862923f, -0.14508213f, 0.13398156f, 
    -0.11597488f, 0.07688489f, 0.01094172f, -0.04973768f, 0.59612226f, -0.25219560f, 0.15597093f, 0.11725177f, 
    0.17268112f, -0.14369163f, 0.05678125f, 0.19072640f, -0.12182166f, 0.04398659f, 0.12978916f, 0.04588503f, 
    0.20858474f, -0.26356742f, -0.25874156f, -0.20929450f, -0.16327304f, 0.03544402f, 0.17100926f, -0.01273877f, 
    -0.02188075f, 0.13212825f, -0.04978160f, -0.07068264f, -0.34898931f, -0.36378795f, 0.03566464f, 0.07030330f, 
    -0.07980965f, 0.09174026f, -0.12661128f, 0.07623326f, -0.02314696f, 0.03470832f, 0.19816761f, 0.10155332f, 
    0.32389694f, 0.30184656f, 0.06762853f, 0.25409335f, -0.09335532f, 0.12433284f, -0.12291325f, 0.09290329f, 
    -0.00266658f, 0.00181822f, 0.08541401f, 0.02998926f, -0.17218080f, -0.49416569f, -0.13570476f, -0.01182777f, 
    0.13902465f, 0.03383142f, -0.02578923f, -0.02760203f, 0.06936151f, -0.02492067f, 0.14289734f, -0.03064486f, 
    0.33620405f, -0.07827540f, -0.04019865f, -0.10943127f, 0.07907014f, 0.16353430f, 0.04380403f, -0.01214054f, 
    0.04792659f, 0.09102760f, 0.23948143f, 0.16626249f, 0.62990159f, 0.12890519f, 0.00350674f, 0.11863270f, 
    0.22847323f, -0.05483944f, 0.16251811f, 0.11515971f, 0.05791389f, 0.15365775f, 0.20395109f, 0.15811808f, 
    0.64892274f, 0.01466371f, -0.20386107f, 0.04128949f, 0.02203313f, 0.03569678f, 0.06074702f, 0.01509852f, 
    -0.11124064f, 0.03959009f, 0.06038180f, 0.00156892f, -0.21986772f, -0.35064033f, 0.14280814f, 0.15665911f, 
    -0.02893073f, 0.18694814f, 0.12034757f, 0.15545410f, 0.01853706f, 0.15877518f, 0.08052743f, -0.10225300f, 
    0.20179506f, 0.06952420f, -0.16852985f, -0.03241087f, -0.05176405f, -0.10584253f, 0.01287062f, 0.00565101f, 
    0.20711425f, -0.02532656f, 0.02926503f, 0.02042810f, -0.67745990f, -0.06193875f, 0.00471796f, -0.13911422f, 
    -0.15780307f, 0.07957006f, 0.00597545f, 0.01954921f, 0.03020370f, -0.00296319f, -0.08141015f, -0.14680274f, 
    0.61131763f, -0.45549411f, -0.08711261f, 0.14380465f, 0.15513590f, -0.05305142f, 0.00926419f, 0.08999005f, 
    0.24237108f, -0.06737462f, 0.02022379f, -0.06493071f, 0.06655576f, -0.33446199f, 0.03331452f, 0.09107822f, 
    -0.06452186f, -0.04150543f, 0.21192223f, 0.17206138f, 0.08873280f, -0.04045108f, -0.02188565f, 0.18818466f, 
    0.26911145f, 0.22164939f, -0.12744282f, -0.06074993f, -0.13215235f, 0.11391275f, 0.09268051f, 0.12384135f, 
    -0.15078172f, 0.05279890f, 0.10146035f, 0.01872316f, 0.25606397f, -0.07888931f, -0.06077489f, 0.05877580f, 
    -0.03207734f, 0.22175558f, -0.07915339f, -0.12576166f, -0.02295165f, 0.19691917f, 0.24052770f, -0.04021568f, 
    -0.02386370f, -0.22662790f, -0.07592194f, -0.12634383f, 0.00817012f, -0.00613740f, -0.17128006f, -0.03896469f, 
    0.08280947f, -0.02655293f, 0.02442609f, -0.03059623f, 0.03820856f, 0.00928530f, -0.11580241f, -0.43090752f, 
    -0.13479623f, -0.06363790f, 0.01173128f, 0.07587492f, 0.11356677f, -0.05151162f, 0.07119699f, -0.01328348f, 
    0.35464919f, 0.45360988f, -0.48779434f, -0.44237497f, 0.16525622f, 0.23472100f, 0.09782474f, 0.25340348f, 
    0.06370973f, 0.07701515f, 0.00701632f, 0.03584470f, 0.36959440f, 0.19240287f, -0.23548515f, -0.07816015f, 
    0.05757165f, 0.08561680f, -0.02072385f, 0.16766433f, 0.20509519f, 0.19322801f, -0.01922152f, 0.03055779f, 
    0.53291982f, 0.03088170f, -0.00790318f, 0.23472406f, 0.00177684f, -0.05358862f, 0.02707166f, 0.13985838f, 
    0.04771373f, 0.08423237f, -0.11190541f, 0.13682096f, -0.16602583f, -0.12432073f, 0.01616841f, -0.07176543f, 
    0.05974397f, 0.08463209f, -0.05228158f, -0.10427444f, 0.00675514f, -0.03381062f, 0.17259233f, -0.03298960f, 
    0.01303534f, -0.09536894f, 0.04411207f, -0.28241304f, -0.00657180f, 0.20795870f, 0.02538764f, -0.06676628f, 
    0.01086874f, -0.03170311f, 0.19393861f, 0.00686999f, -0.18101202f, -0.02964483f, -0.02470693f, -0.09436312f, 
    -0.10549057f, 0.05702285f, -0.02952870f, 0.11971766f, 0.15548605f, 0.16509870f, 0.25872204f, -0.04563544f, 
    0.53257966f, 0.06214975f, 0.10062889f, -0.21599875f, 0.11893893f, -0.02542443f, 0.05947391f, 0.01911189f, 
    0.09375330f, -0.03711456f, 0.11675899f, 0.04898497f, 0.67007565f, 0.00179837f, -0.02117327f, 0.35752946f, 
    -0.08140128f, 0.07180010f, -0.00562451f, -0.15537736f, -0.00595828f, 0.11972675f, 0.22235194f, 0.10757503f, 
    -0.31336114f, -0.19155210f, -0.19036317f, 0.17958747f, 0.20072213f, -0.09947482f, -0.13397509f, 0.17205717f, 
    0.15429983f, 0.08403978f, -0.26151264f, 0.05797044f, 0.08215037f, 0.03238847f, -0.36070231f, 0.16756299f, 
    -0.15135181f, -0.18009278f, 0.06772469f, 0.12543492f, 0.06659258f, -0.19400634f, -0.06477885f, -0.17071675f, 
    -0.05101973f, -0.03167726f, 0.04309525f, 0.01036046f, -0.03953295f, -0.02538135f, 0.04606684f, -0.01618911f, 
    -0.04341256f, -0.05994981f, -0.05008200f, 0.02700852f, -0.02631698f, -0.05026831f, -0.04738751f, -0.00581498f, 
    -0.03376281f, 0.05146836f, -0.04179579f, -0.00497077f, -0.01383731f, 0.01135272f, -0.00490547f, -0.03331602f, 
    -0.02587410f, -0.05409943f, -0.03648732f, 0.03695520f, 0.01613828f, 0.04028241f, -0.05073372f, 0.03566086f, 
    -0.04731741f, 0.02970799f, 0.05015492f, -0.05006362f, -0.05905982f, 0.03180330f, -0.03471491f, -0.03996759f, 
    0.01946528f, -0.01749304f, 0.03253260f, -0.02955036f, -0.00963950f, 0.02697904f, 0.02207545f, -0.01577931f, 
    -0.03823361f, -0.01883266f, -0.05349300f, -0.03071751f, -0.02576703f, -0.02162891f, -0.04012739f, -0.00013450f, 
    0.00953450f, -0.02760376f, 0.03007219f, -0.01187444f, 0.01175310f, 0.00480762f, -0.00335598f, -0.01804561f, 
    -0.04110438f, 0.03216128f, 0.01012996f, 0.01465228f, -0.02595587f, -0.03267809f, -0.05044556f, 0.04938032f, 
    -0.03202688f, -0.00555563f, -0.05600382f, -0.00776729f, 0.02085687f, 0.00460093f, 0.02426533f, 0.04313391f, 
    0.03545246f, 0.03756694f, -0.03600577f, 0.01292591f, -0.01451863f, -0.03691858f, -0.04075881f, -0.05248374f, 
    0.02929753f, -0.00730516f, 0.01629365f, 0.02659916f, 0.02673944f, 0.00417585f, 0.00364100f, -0.00291922f, 
    -0.00590267f, 0.01766727f, -0.02537669f, -0.00452474f, 0.02494784f, 0.01890981f, -0.00781996f, 0.02188154f, 
    0.00587249f, -0.03652481f, -0.03991165f, -0.01900882f, -0.01920597f, -0.00777782f, 0.04143207f, -0.00020993f, 
    0.00991620f, -0.00776813f, 0.03117970f, -0.04202821f, 0.02148359f, -0.02433738f, -0.03856167f, 0.01663588f, 
    -0.02053491f, -0.00509630f, -0.02676772f, -0.03582408f, -0.03562944f, -0.02240637f, 0.01528139f, -0.00442376f, 
    0.02325925f, 0.03786539f, -0.04814628f, -0.05106563f, 0.03023469f, -0.02337114f, -0.02672978f, 0.03279513f, 
    0.03563830f, 0.00701752f, -0.03421980f, 0.03603728f, -0.03331285f, 0.03639831f, 0.01272779f, -0.05395869f, 
    -0.01932015f, -0.03808811f, -0.01748950f, -0.00882509f, -0.00340420f, 0.00424017f, 0.02743691f, -0.03063815f, 
    -0.04089413f, -0.00837841f, 0.01360728f, 0.01403689f, 0.01605765f, 0.00595135f, 0.03190699f, -0.05981462f, 
    0.02621548f, 0.00315496f, 0.02375474f, -0.00565781f, 0.00831082f, -0.04899888f, -0.01952562f, 0.00874080f, 
    0.00515582f, 0.02543654f, -0.01606889f, 0.04229702f, 0.01624296f, 0.01150862f, -0.00081757f, -0.02297536f, 
    -0.01855034f, -0.04013053f, -0.00934077f, 0.00601060f, -0.04593263f, -0.00767000f, -0.01069728f, -0.03308421f, 
    -0.05405391f, -0.01840725f, 0.00413357f, 0.01495004f, -0.02050965f, -0.05898839f, -0.03177533f, 0.02492456f, 
    -0.02285386f, 0.01034662f, -0.02942300f, 0.01556002f, 0.00243923f, -0.00722692f, 0.02524905f, -0.01760882f, 
    -0.01949808f, -0.03671394f, -0.04675546f, -0.01935443f, -0.01869682f, 0.00946427f, -0.01402133f, -0.02540503f, 
    0.04174548f, -0.04400975f, 0.01893054f, -0.01276514f, -0.00797896f, 0.00456891f, -0.04091316f, -0.05556349f, 
    -0.05392991f, 0.02787152f, 0.04126559f, -0.01595795f, -0.04432043f, 0.02795295f, -0.01302646f, 0.03925033f, 
    -0.02573345f, -0.02609509f, -0.00841272f, -0.03410462f, -0.05018706f, -0.04805787f, -0.00837098f, -0.00904264f, 
    0.02560371f, -0.02762854f, -0.02381201f, -0.00333738f, 0.03056226f, -0.04353181f, -0.02125799f, -0.02174132f, 
    0.00092345f, -0.02618782f, 0.01324725f, -0.02311923f, -0.04575086f, -0.00482653f, 0.01088157f, 0.04575930f, 
    0.02501301f, -0.04847404f, 0.01638534f, 0.01647839f, -0.03253192f, -0.02546112f, -0.03258196f, 0.00973562f, 
    -0.05499294f, 0.00600101f, 0.02845180f, 0.00973976f, 0.02323551f, -0.01767818f, -0.05341993f, 0.03981163f, 
    -0.00844986f, -0.00605194f, -0.05501194f, -0.04548752f, 0.00046172f, -0.02502270f, 0.00633315f, 0.01277849f, 
    -0.03593560f, 0.00349631f, 0.02214651f, -0.03909558f, 0.00330751f, -0.00360474f, -0.04842798f, -0.01005638f, 
    0.03264127f, 0.00478128f, -0.01072698f, 0.03997450f, -0.01309122f, -0.04569721f, -0.04909085f, -0.00601285f, 
    -0.00058683f, 0.02020660f, 0.00458585f, 0.02407964f, 0.02613342f, 0.02069158f, -0.05087589f, -0.04982073f, 
    0.04650869f, 0.01218728f, 0.02059515f, 0.05144918f, 0.02933346f, -0.03527701f, -0.01230835f, 0.04143385f, 
    -0.03380126f, -0.02172225f, -0.04336330f, 0.00907748f, 0.03210088f, 0.02904901f, -0.03584339f, 0.04682022f, 
    0.04335980f, -0.01074795f, 0.02516981f, 0.01605673f, 0.03582629f, -0.00107410f, 0.00045088f, 0.01179817f, 
    -0.02410938f, 0.05146036f, -0.00714271f, 0.03026170f, 0.02618244f, -0.03339317f, 0.01757077f, -0.05167138f, 
    -0.01069123f, 0.01124613f, 0.01717042f, 0.03238754f, 0.05822925f, -0.03840288f, 0.01532871f, -0.00306701f, 
    -0.00338824f, -0.03092841f, -0.03565690f, -0.03281270f, -0.01087591f, 0.01437929f, -0.04075013f, 0.04448064f, 
    -0.04219647f, 0.03460466f, -0.02941029f, -0.05142953f, -0.03228017f, 0.02712157f, 0.02402810f, -0.01907784f, 
    -0.05290566f, 0.00863553f, -0.05161405f, -0.01511190f, 0.02736750f, 0.03331377f, -0.01209168f, 0.00507227f, 
    0.01138338f, -0.04750945f, 0.01884931f, -0.02793794f, 0.04196532f, -0.03076775f, 0.03601137f, 0.00897080f, 
    -0.00210823f, -0.01042661f, -0.05391460f, -0.04342467f, -0.01096975f, 0.00597282f, 0.03351439f, -0.00390097f, 
    0.01994856f, -0.01576549f, 0.00910408f, -0.01520322f, 0.03976689f, 0.02072473f, 0.03993063f, -0.01592210f, 
    -0.17927852f, 0.03235221f, 0.09260672f, -0.05415647f, 0.06021697f, -0.21913050f, 0.00182214f, -0.01816006f, 
    0.02390561f, 0.07565326f, 0.12775430f, 0.13340357f, 0.59463358f, 0.55696774f, 0.02529825f, 0.37891343f, 
    -0.11849408f, 0.05938281f, -0.08728814f, 0.19741328f, 0.03055138f, -0.01235445f, 0.22576681f, -0.01342881f, 
    -0.32263649f, -0.18367282f, 0.00646897f, -0.08273917f, -0.13579521f, -0.01619167f, 0.20445579f, 0.13973601f, 
    0.13521522f, -0.07255659f, -0.08097928f, -0.05795316f, 0.01867393f, -0.07143008f, 0.04892716f, 0.01753913f, 
    -0.10278276f, -0.03207809f, 0.08236796f, -0.09383153f, -0.07702681f, 0.08644806f, 0.09761419f, 0.03952200f, 
    0.47109607f, -0.09644581f, 0.05049269f, 0.00933430f, 0.09532339f, 0.19969425f, 0.02003111f, -0.02520136f, 
    0.07937840f, 0.09884056f, 0.06554230f, 0.19448110f, -0.25451997f, -0.07720231f, 0.06990331f, -0.05612471f, 
    -0.12604620f, 0.12219491f, 0.07751418f, -0.04125712f, -0.09378806f, 0.04531606f, 0.01090130f, -0.03123575f, 
    0.17049411f, -0.27849212f, 0.17794661f, -0.14754708f, 0.08407586f, 0.07903428f, -0.12245733f, 0.09372824f, 
    0.07590995f, 0.08884463f, 0.02634859f, 0.24460562f, 0.47735646f, -0.09653064f, 0.07433943f, 0.05883475f, 
    0.08039790f, -0.11205462f, 0.17243107f, -0.00066128f, 0.07079030f, -0.06413372f, -0.08053488f, -0.04579607f, 
    -0.28186429f, -0.16697249f, -0.03857819f, -0.01684275f, 0.14450614f, 0.09663705f, -0.05756668f, -0.09246586f, 
    0.03415412f, -0.04305661f, -0.01538982f, -0.01221525f, 0.22284989f, 0.16973808f, 0.23476528f, -0.32745370f, 
    -0.24671057f, -0.03623575f, 0.00978349f, -0.00692239f, 0.12888247f, -0.01630238f, 0.00996461f, 0.10782481f, 
    0.27226129f, 0.30301985f, 0.31798658f, 0.27184761f, -0.00687800f, -0.02244782f, -0.06619945f, 0.10064551f, 
    -0.00886858f, 0.03295892f, -0.13842757f, -0.07787034f, 0.05200113f, 0.30595848f, 0.15795352f, 0.09033745f, 
    -0.09771284f, 0.10443260f, -0.07232676f, 0.07941021f, -0.04033329f, -0.02598942f, 0.14909801f, -0.05010140f, 
    -0.52954161f, -0.21086028f, 0.18801519f, -0.23625915f, -0.04624145f, 0.13864878f, 0.09401852f, -0.14762048f, 
    0.29305083f, 0.16448866f, -0.00808367f, 0.19734810f, -0.11645570f, 0.20377973f, 0.11236351f, -0.19464295f, 
    -0.09882913f, 0.11406245f, -0.10470094f, -0.01298175f, -0.01633007f, -0.05945994f, 0.17659312f, 0.08060793f, 
    -0.40861169f, -0.07206611f, 0.04059943f, -0.01076044f, -0.07237782f, 0.04503595f, 0.08541851f, -0.10059898f, 
    -0.01214604f, 0.04356578f, 0.25173375f, 0.10581981f, 0.33119088f, -0.30964696f, 0.08787560f, -0.08392673f, 
    -0.02529937f, -0.06881769f, -0.00417969f, 0.04789678f, -0.01072956f, 0.15650930f, 0.03326274f, 0.13321561f, 
    -0.23525546f, -0.05584716f, 0.05673367f, 0.04955151f, 0.11676224f, -0.02079919f, -0.02446303f, 0.09207013f, 
    -0.12648584f, 0.27537265f, 0.12284083f, 0.21663965f, 0.18139289f, 0.34932584f, 0.01325987f, 0.15494527f, 
    -0.04236956f, 0.03323356f, -0.10813919f, 0.15231277f, -0.16726060f, 0.03084760f, 0.08061141f, 0.07102998f, 
    -0.41248348f, -0.34658954f, 0.12303112f, 0.11982378f, 0.05923928f, -0.08543114f, 0.13773453f, -0.05832416f, 
    0.23154269f, 0.01038432f, -0.05310549f, 0.09939734f, 0.35688359f, 0.22678003f, -0.10732508f, 0.04169656f, 
    0.11787888f, -0.07766195f, 0.15145059f, 0.05403879f, -0.07893968f, -0.02772350f, -0.01263399f, 0.10956225f, 
    0.19060880f, -0.02169001f, 0.17310731f, 0.34629813f, 0.01782140f, -0.00945786f, 0.10885603f, 0.06121903f, 
    0.04719668f, 0.23638521f, 0.12122907f, 0.07162351f, -0.29290217f, -0.28108716f, -0.05519837f, -0.29510245f, 
    0.20280324f, 0.06189432f, 0.03574398f, 0.09223314f, 0.13515352f, 0.03022218f, -0.10803640f, 0.32486901f, 
    -0.36443368f, -0.02158247f, 0.01413079f, -0.04205425f, -0.07653164f, 0.03411717f, -0.06193653f, -0.04957077f, 
    -0.06650742f, -0.01048163f, -0.06874831f, -0.10608056f, -0.34103742f, 0.25284588f, 0.19202463f, -0.23540071f, 
    0.00665669f, 0.14406745f, 0.09069963f, 0.04061503f, 0.15118016f, 0.00210016f, 0.03683770f, 0.14670371f, 
    0.01639536f, 0.30736408f, -0.00028197f, 0.18188792f, -0.05349374f, 0.07967686f, -0.05788375f, 0.00447781f, 
    0.06671452f, 0.01420476f, 0.11410458f, 0.01912244f, 0.17591053f, 0.20333761f, 0.08681533f, 0.26257604f, 
    -0.00424029f, -0.00471424f, 0.12210380f, 0.06915450f, 0.02364905f, 0.08887190f, -0.09113417f, 0.15218234f, 
    -0.05964533f, 0.12383739f, 0.05601301f, -0.03524619f, 0.09358842f, 0.01042781f, 0.06283335f, 0.08858850f, 
    0.09214131f, 0.01958226f, -0.07336932f, 0.16333516f, 0.10101320f, -0.02549182f, -0.00109793f, -0.28885251f, 
    -0.00140780f, 0.21147138f, 0.19912116f, 0.06268697f, -0.14342879f, -0.19646560f, 0.06972414f, 0.08538242f, 
    0.01784433f, 0.37465233f, 0.15669437f, 0.23763438f, -0.04588168f, 0.01007603f, -0.10422927f, 0.14669384f, 
    0.09492110f, 0.14884500f, -0.13611741f, -0.04035167f, 0.01794012f, -0.06856963f, 0.09632166f, -0.12237114f, 
    0.05519215f, 0.09361485f, 0.01864722f, -0.02217675f, 0.05668191f, -0.07696187f, -0.09547016f, 0.00423046f, 
    0.19205296f, 0.24493349f, 0.17053667f, 0.12995230f, 0.03637719f, 0.07070065f, 0.15292537f, -0.07082538f, 
    -0.11065654f, -0.10623921f, 0.21105725f, 0.18368894f, -0.54705602f, -0.03317737f, -0.12972845f, -0.10561907f, 
    0.09341624f, 0.06748316f, 0.03458541f, 0.27330476f, 0.09468709f, 0.02109407f, 0.24400064f, 0.31432161f, 
    0.00902845f, -0.00710909f, 0.00185133f, -0.05236701f, -0.00239401f, 0.02401032f, -0.01506079f, 0.03957988f, 
    -0.01102215f, 0.01066556f, 0.01210927f, -0.02707927f, -0.02844492f, -0.00262026f, -0.00936536f, 0.04563306f, 
    0.03026241f, -0.04425759f, -0.00944036f, 0.02807211f, -0.01314039f, 0.00655791f, -0.02049622f, 0.00505646f, 
    -0.03152128f, -0.00039127f, -0.04191641f, -0.02365626f, 0.03939433f, -0.04368395f, -0.01221958f, 0.03350376f, 
    0.01801288f, 0.01265036f, -0.01338109f, -0.04563344f, 0.03011065f, 0.00895015f, -0.02128000f, 0.00901015f, 
    -0.03570861f, -0.03648985f, -0.01512943f, -0.04712402f, 0.02838917f, -0.04082910f, -0.03787478f, 0.02872316f, 
    -0.03864294f, 0.01156800f, 0.00188722f, 0.00906929f, -0.00426660f, -0.02853274f, 0.01470654f, 0.01275686f, 
    0.03902429f, 0.00777972f, 0.02317921f, 0.02078916f, -0.04006383f, -0.05125409f, -0.02660764f, 0.02503620f, 
    -0.04957718f, -0.00818465f, 0.01160991f, 0.01554410f, -0.01326929f, -0.02884388f, 0.01377571f, -0.00564945f, 
    0.01319491f, -0.00504202f, 0.02149301f, 0.00905432f, -0.00742933f, -0.04564387f, 0.04091531f, 0.01213250f, 
    -0.01083950f, 0.02189409f, -0.04315146f, 0.00115204f, -0.01713473f, 0.00670145f, 0.04772370f, -0.01355081f, 
    0.04187055f, -0.04280859f, -0.05355225f, -0.01724563f, -0.03454407f, 0.00724410f, 0.01293133f, -0.05178408f, 
    -0.01376203f, -0.00671276f, 0.00778904f, 0.03059233f, 0.02790117f, 0.03402596f, 0.03058566f, -0.03148630f, 
    0.02273766f, -0.03753233f, 0.03974474f, 0.03915589f, -0.00146493f, -0.02726296f, 0.02390825f, 0.03549277f, 
    -0.00276245f, -0.04816718f, 0.03787100f, 0.01649317f, -0.00746467f, 0.02698197f, 0.01690953f, 0.03935844f, 
    -0.01186240f, -0.01370233f, -0.05728872f, 0.02265219f, 0.04551370f, 0.02803590f, -0.01265208f, -0.01699293f, 
    0.02574700f, 0.00797071f, -0.01876744f, 0.01951020f, -0.05266688f, -0.04327857f, 0.03032308f, -0.02944618f, 
    -0.00381937f, -0.05865703f, -0.01446972f, -0.02005779f, -0.04544275f, 0.03957596f, 0.01753846f, -0.02052770f, 
    -0.00927458f, -0.02997291f, -0.02246069f, -0.03312344f, -0.03716283f, -0.02542347f, -0.01857804f, 0.00704387f, 
    0.01041176f, 0.01254876f, -0.05283371f, 0.02621338f, -0.04303629f, -0.02098260f, 0.00898718f, -0.03084432f, 
    -0.04390759f, 0.04371522f, -0.04651628f, 0.04155498f, -0.05268512f, -0.02244627f, -0.00725221f, 0.00002946f, 
    -0.01306128f, -0.01176127f, 0.05109568f, 0.02723425f, -0.01864346f, -0.00952077f, 0.01747899f, 0.01221793f, 
    0.01506483f, -0.02429566f, -0.00756914f, 0.01683635f, -0.00105775f, -0.04417882f, 0.03988580f, 0.00881744f, 
    -0.00419344f, -0.03390782f, -0.00640168f, -0.02262385f, -0.04067382f, 0.02925856f, 0.00174505f, -0.01626277f, 
    -0.00772971f, -0.05202359f, 0.00059976f, -0.04082315f, -0.02810882f, -0.04852393f, -0.05597986f, 0.02421366f, 
    0.00627866f, -0.02345693f, -0.00500614f, -0.00021739f, 0.03930005f, -0.05434462f, -0.05845624f, 0.03842167f, 
    0.04198918f, 0.02399104f, -0.03946019f, -0.01912261f, 0.01703279f, -0.04037429f, -0.03169088f, 0.02160539f, 
    0.03958036f, 0.02050801f, -0.02070075f, 0.02760164f, 0.00260977f, -0.00571290f, -0.01636878f, -0.03033040f, 
    -0.02839121f, 0.00306896f, 0.03104384f, -0.03633409f, 0.03808780f, 0.02414509f, 0.02632456f, 0.01812651f, 
    -0.04795422f, -0.04537913f, 0.03684981f, 0.01123594f, 0.02240065f, -0.02646111f, -0.04037140f, -0.04439442f, 
    -0.02066165f, -0.02953600f, 0.03630846f, 0.00361712f, -0.02733169f, -0.00576558f, 0.01492871f, 0.02967188f, 
    -0.02826718f, -0.05507312f, 0.04707960f, 0.02634988f, -0.01963461f, -0.04240143f, 0.00078865f, -0.04393545f, 
    -0.02481128f, 0.01381434f, -0.01734962f, 0.03361117f, 0.02229227f, -0.05125142f, -0.02347057f, -0.04565364f, 
    -0.04075187f, 0.03717624f, -0.04992474f, 0.03054983f, -0.04046767f, -0.01269663f, -0.04216216f, -0.00168279f, 
    0.01357377f, -0.03894417f, -0.01708020f, -0.00155457f, -0.00183551f, -0.04936991f, -0.04439113f, 0.03242218f, 
    -0.03542120f, 0.00968985f, -0.01370884f, 0.02176196f, -0.04077462f, 0.02602861f, -0.01490861f, -0.00886852f, 
    -0.04420793f, -0.00090577f, 0.02858679f, 0.01315513f, 0.03731818f, 0.03354925f, 0.00267952f, 0.01553189f, 
    0.03245565f, -0.00744329f, -0.00788530f, 0.00350120f, -0.01968042f, 0.02848155f, -0.04554415f, 0.03394133f, 
    0.02283464f, 0.03012133f, 0.01202825f, -0.04840795f, 0.03148389f, -0.01261262f, -0.02770316f, -0.04515313f, 
    0.00510241f, 0.00054815f, -0.03640075f, -0.00505988f, -0.03154747f, 0.00311901f, -0.05354100f, -0.02453883f, 
    0.00542233f, -0.02118254f, 0.00143504f, -0.03101729f, -0.00361450f, -0.01513179f, 0.03961699f, -0.04828345f, 
    0.04725877f, -0.00713405f, 0.02994078f, 0.03119876f, -0.03126858f, -0.02562833f, -0.05155499f, 0.01307614f, 
    0.04121931f, 0.04079885f, 0.03406930f, -0.04849468f, 0.00269238f, -0.02749670f, -0.01012374f, 0.01570282f, 
    -0.00429995f, 0.02785901f, 0.02792164f, 0.00127553f, -0.03109031f, -0.00390444f, 0.00850685f, -0.02109401f, 
    0.03770809f, 0.03000539f, 0.03914604f, -0.00709323f, 0.00379652f, 0.04456087f, -0.02374716f, 0.00923271f, 
    -0.02977968f, -0.02699090f, 0.03000602f, -0.03905630f, -0.04056411f, -0.00268131f, 0.03582305f, 0.01982139f, 
    -0.01060878f, -0.03953362f, 0.00370894f, 0.01736805f, 0.04050961f, 0.03736503f, -0.00385969f, 0.01979519f, 
    0.02152477f, -0.00510266f, -0.02294623f, -0.02152283f, -0.00160124f, 0.01543715f, 0.03000655f, 0.04056847f, 
    0.01421478f, 0.03658583f, 0.00620243f, -0.03712645f, 0.00227308f, -0.00553125f, 0.02287939f, -0.00728644f, 
    0.02428475f, 0.01000234f, -0.01330847f, -0.01800062f, 0.03019182f, 0.02866174f, 0.00620346f, 0.03010635f, 
    -0.04139984f, -0.01718528f, -0.00385594f, 0.00193849f, -0.03128000f, -0.03680812f, -0.05102796f, 0.01778919f, 
    0.02269408f, 0.01579960f, -0.04988940f, -0.00601758f, 0.01804974f, 0.02323600f, -0.02575169f, -0.05114243f, 
    -0.02805922f, -0.03031442f, -0.00270063f, -0.00732720f, 0.02329699f, -0.05030263f, -0.03667546f, 0.02515544f, 
    -0.03519072f, 0.02542854f, -0.01787727f, -0.01722228f, -0.02845210f, -0.04735500f, -0.01232887f, 0.01198146f, 
    -0.01869337f, -0.00613114f, -0.01617035f, -0.02016363f, -0.00885544f, -0.00793594f, -0.03601146f, -0.02768592f, 
    -0.01220482f, 0.01985266f, -0.02473842f, -0.01303759f, 0.03368546f, 0.02089727f, 0.02086841f, -0.05332858f, 
    -0.05153108f, -0.01566202f, -0.00880457f, -0.05039436f, 0.02124320f, -0.00895237f, -0.01580829f, -0.03723686f, 
    -0.05725904f, -0.00938869f, -0.04603327f, -0.04752212f, 0.00663465f, 0.00714585f, -0.05329322f, -0.05294570f, 
    0.01799279f, 0.03901479f, -0.04428647f, -0.02436839f, -0.04706484f, -0.00063401f, 0.01237379f, -0.00067771f, 
    -0.03745802f, -0.02171917f, 0.04244556f, -0.00045657f, -0.03810292f, -0.01395455f, -0.04803710f, -0.05723392f, 
    -0.00603246f, 0.04330128f, -0.02480726f, 0.03421500f, -0.01584092f, -0.03936331f, 0.00113651f, 0.00337716f, 
    -0.02669197f, 0.00316389f, -0.02907378f, -0.05368260f, -0.00412986f, -0.05170516f, -0.00741468f, 0.03725335f, 
    -0.02840826f, 0.02771063f, -0.05289165f, -0.01765737f, 0.02834110f, 0.01961815f, -0.01061916f, 0.03888102f, 
    -0.01239648f, 0.01030108f, -0.01515289f, -0.05620676f, 0.01674753f, 0.01623289f, -0.02906056f, -0.03228039f, 
    0.02393919f, 0.04287773f, 0.04272920f, -0.03811151f, -0.04036806f, 0.01854213f, 0.02429859f, 0.00279536f, 
    0.01287055f, -0.05431407f, -0.00619097f, -0.02019587f, -0.04656553f, 0.01934046f, 0.01814757f, -0.00508122f, 
    -0.03921135f, 0.03072355f, 0.02804480f, 0.01086627f, -0.05090825f, -0.04810775f, -0.01412258f, 0.04902295f, 
    -0.05739312f, 0.04014192f, -0.00408982f, -0.02913231f, -0.01786699f, -0.00433485f, -0.03283338f, 0.01073666f, 
    0.01468297f, 0.03667492f, 0.01606687f, -0.04444775f, 0.02494239f, 0.02115998f, -0.03467495f, 0.00468416f, 
    -0.00726055f, -0.04153908f, -0.01865225f, -0.02059934f, -0.03156329f, -0.05748417f, 0.01888357f, -0.04521632f, 
    0.03360128f, -0.05480398f, -0.00790960f, 0.00217630f, 0.00710562f, -0.04613493f, -0.04932440f, -0.05754053f, 
    -0.02993427f, 0.02815616f, -0.03821976f, -0.02505226f, 0.04411475f, -0.05030461f, 0.02188503f, -0.00947032f, 
    0.02660138f, 0.00354348f, -0.02436288f, -0.04618336f, 0.02040413f, 0.02962565f, 0.00215157f, -0.00688445f, 
    -0.00184489f, 0.03697632f, 0.02335522f, 0.00454198f, -0.03407176f, 0.00652872f, 0.04032176f, 0.01880464f, 
    -0.03623515f, -0.02827036f, -0.03692050f, -0.00350127f, -0.04899320f, -0.04371758f, -0.05715817f, -0.01738639f, 
    -0.04990751f, 0.01778485f, 0.02831384f, 0.00402993f, -0.00470454f, -0.03444677f, -0.04644314f, 0.02792403f, 
    0.00553155f, 0.03315490f, 0.01358892f, -0.03714135f, -0.00162839f, 0.00845510f, 0.01484538f, -0.02294968f, 
    -0.04900216f, 0.01451110f, -0.00797039f, -0.03898302f, -0.01885893f, -0.03738707f, 0.00704035f, 0.02594450f, 
    0.03143190f, 0.03568595f, -0.02830419f, 0.03842305f, -0.04487134f, -0.01777576f, 0.03409165f, 0.02727750f, 
    0.01948785f, -0.00668131f, 0.02851861f, 0.02430660f, -0.04278106f, -0.03603656f, 0.02344446f, -0.02971343f, 
    -0.05410476f, 0.01669223f, -0.02781595f, -0.05729360f, 0.02398925f, -0.05228579f, 0.03325456f, 0.01685885f, 
    0.01611368f, 0.01094056f, -0.01380684f, 0.03005731f, -0.03083683f, -0.05362989f, -0.02831534f, -0.05438165f, 
    -0.03751912f, 0.03263245f, 0.00216082f, -0.04448220f, 0.03386649f, -0.02005924f, -0.05411472f, -0.01544787f, 
    -0.01075062f, -0.02638028f, 0.02134661f, 0.00357576f, -0.00492050f, -0.04215110f, -0.00751531f, -0.00326075f, 
    -0.01431191f, -0.03945785f, 0.02506550f, 0.03917350f, 0.02026757f, -0.00720696f, -0.02651825f, -0.04880822f, 
    -0.00331791f, 0.04235876f, -0.01842621f, -0.01214720f, -0.01278867f, -0.05210350f, 0.01215516f, -0.00534869f, 
    -0.05528288f, 0.04150702f, -0.04315289f, 0.03118237f, 0.03885497f, -0.05064439f, -0.03977232f, 0.01356254f, 
    0.01457535f, -0.01317897f, 0.02454077f, 0.01581440f, 0.00796634f, 0.01458450f, -0.05304165f, 0.02458791f, 
    -0.05666307f, 0.03124944f, -0.04969383f, -0.01979597f, -0.03689203f, 0.00943637f, -0.01888675f, -0.02845108f, 
    -0.01673354f, 0.01168584f, -0.05081465f, -0.01691148f, -0.02746431f, -0.01157300f, -0.03862906f, -0.02720217f, 
    0.01650655f, -0.04784533f, 0.02454353f, -0.02641420f, -0.05540493f, -0.05212933f, 0.02575713f, -0.04693812f, 
    -0.05147804f, -0.02272683f, 0.02450765f, -0.04954793f, 0.00177091f, 0.02050058f, -0.05467331f, -0.05654111f, 
    -0.03243176f, 0.02820224f, -0.04143580f, 0.04400177f, -0.02011005f, -0.04132434f, 0.04339291f, -0.04426959f, 
    -0.00578170f, 0.03739735f, 0.03190140f, -0.05414981f, -0.04177841f, 0.03238650f, 0.02170530f, 0.03225656f, 
    -0.01112421f, -0.03894354f, 0.05082396f, 0.04812882f, -0.00885910f, -0.01363950f, -0.05733971f, -0.03729259f, 
    -0.03119054f, -0.02027353f, -0.00096131f, 0.02102244f, 0.00245952f, -0.01609608f, -0.04575488f, 0.00359987f, 
    -0.02343385f, -0.00201088f, -0.02713884f, -0.04192948f, 0.01495894f, -0.04078033f, -0.03582546f, -0.05540926f, 
    -0.01446061f, -0.02762022f, 0.00146628f, -0.01483635f, 0.02691095f, -0.03959541f, -0.02529641f, -0.04348980f, 
    -0.01720034f, 0.01315706f, -0.01487798f, -0.03463637f, 0.04345706f, 0.01735716f, 0.01077269f, -0.03452942f, 
    -0.00682264f, -0.01138838f, 0.00512424f, -0.02704299f, -0.03227363f, -0.02198500f, 0.01099338f, 0.01553451f, 
    -0.03697907f, -0.02999175f, -0.04920314f, -0.02539134f, 0.02205675f, -0.01413547f, 0.03864634f, -0.01954155f, 
    -0.02868593f, -0.04040016f, -0.03657790f, -0.03527314f, -0.04104085f, -0.03343798f, -0.00614051f, -0.04590260f, 
    0.00626874f, 0.01861197f, -0.02480733f, 0.02267431f, 0.01149311f, -0.05390731f, -0.03727177f, -0.05495484f, 
    0.00481151f, 0.00766280f, 0.00753850f, -0.05449421f, 0.02146545f, -0.01623331f, 0.03324838f, -0.02508423f, 
    0.03756018f, 0.02053431f, -0.04785423f, 0.01598793f, 0.03343495f, -0.04857556f, -0.00999737f, 0.02343659f, 
    -0.04887195f, -0.02535948f, -0.04603737f, -0.01917152f, -0.05555371f, 0.03733911f, 0.02883947f, -0.01496049f, 
    -0.04292773f, -0.00658970f, 0.04254561f, 0.03207691f, -0.04165193f, -0.05625690f, 0.02365979f, -0.02327788f, 
    -0.02199403f, -0.02701600f, 0.03986268f, -0.00743180f, -0.04034161f, -0.01260712f, 0.01614069f, -0.02328129f, 
    -0.05611331f, -0.04060232f, 0.01935347f, 0.02554074f, 0.04260093f, -0.03573421f, -0.02590054f, 0.00955212f, 
    0.02281021f, 0.04035109f, -0.00147277f, 0.04543995f, -0.02354459f, -0.02416986f, -0.03453221f, -0.04233903f, 
    -0.00790653f, -0.02523553f, -0.00127622f, 0.00357522f, 0.03963690f, -0.02266051f, 0.00043364f, -0.03097542f, 
    -0.02219989f, -0.00931627f, -0.02378727f, -0.03965266f, 0.03922597f, -0.03555050f, 0.02642113f, 0.01823155f, 
    0.03877160f, -0.00899975f, 0.01063149f, -0.03026334f, -0.04461800f, -0.05252060f, -0.01201498f, 0.00244990f, 
    -0.04377348f, -0.03694111f, 0.00454123f, -0.01015862f, -0.00435039f, -0.00240503f, 0.00735779f, -0.04671772f, 
    -0.01936618f, -0.01616144f, -0.01026603f, 0.02110984f, 0.02672658f, -0.02037070f, 0.04359537f, -0.04687287f, 
    -0.01170097f, 0.01422029f, -0.05493099f, -0.05608763f, -0.01722300f, -0.01477402f, 0.00338890f, -0.04699874f, 
    -0.00219008f, -0.02948819f, 0.03334711f, -0.05547410f, 0.02000428f, 0.02265849f, -0.02922532f, -0.04250138f, 
    -0.01298659f, 0.01428206f, 0.00717812f, -0.01346000f, 0.02666479f, 0.02629790f, -0.00219245f, -0.04379681f, 
    0.00243604f, 0.00764295f, 0.02090700f, -0.03603547f, -0.04484068f, -0.02043567f, 0.00485582f, 0.01589491f, 
    -0.03579745f, 0.04183631f, 0.00417139f, -0.03766932f, 0.01286933f, 0.03424699f, -0.03544359f, -0.04391196f, 
    -0.04881680f, -0.02109536f, 0.02067786f, 0.01547527f, 0.03007374f, -0.03038590f, 0.02590375f, -0.02734915f, 
    0.00634841f, -0.01407961f, 0.01188391f, -0.00209328f, 0.04005966f, 0.02986265f, -0.01227483f, -0.05182426f, 
    -0.00467493f, -0.03600848f, -0.00236897f, -0.04688272f, 0.00545854f, 0.04005342f, 0.04002253f, -0.01417494f, 
    0.00735962f, -0.05131569f, -0.03011465f, -0.04317754f, 0.01017887f, -0.01843644f, 0.02392726f, -0.03415717f, 
    0.03099827f, -0.00317338f, -0.04260508f, -0.03629799f, 0.00100847f, 0.02530696f, -0.01550246f, 0.04228344f, 
    0.00529639f, -0.02891149f, -0.04062423f, -0.01711871f, -0.02936080f, -0.01243462f, -0.01570838f, 0.02964110f, 
    -0.01866738f, 0.03113385f, -0.00989116f, 0.04076199f, 0.03438839f, -0.03226520f, -0.00712707f, -0.02210401f, 
    -0.04873260f, -0.03453112f, 0.02536864f, -0.01701761f, 0.03451503f, 0.02479965f, -0.05041632f, -0.03657741f, 
    -0.02704915f, -0.02842863f, 0.01770930f, 0.01063156f, 0.02684311f, -0.04738523f, 0.00971267f, 0.04280309f, 
    -0.01879751f, -0.01048503f, 0.00893166f, 0.02135697f, 0.00945589f, -0.03355545f, -0.03396510f, 0.02585063f, 
    -0.02098952f, -0.00225817f, 0.00713338f, 0.00050333f, -0.04190140f, -0.03506331f, -0.03842830f, -0.02493462f, 
    -0.01311956f, 0.03800836f, -0.05570557f, -0.04751012f, 0.04445290f, 0.04826162f, -0.00000812f, 0.02541419f, 
    0.01086826f, -0.00055024f, -0.04650630f, -0.04829694f, 0.02722267f, -0.04932760f, 0.00762924f, -0.03637926f, 
    -0.03415043f, 0.01041843f, -0.02406375f, -0.05045819f, -0.05303568f, -0.03237199f, -0.03114643f, -0.03920257f, 
    0.03239885f, 0.04079026f, -0.03050398f, 0.00150250f, 0.01420305f, 0.01325055f, 0.01997489f, 0.04173597f, 
    -0.02813704f, -0.01480808f, 0.01369968f, 0.00016910f, -0.05021637f, 0.02486777f, -0.00023428f, 0.03365608f, 
    0.04006880f, -0.00799613f, 0.04021368f, 0.03901928f, 0.03395122f, 0.02753180f, -0.02254910f, 0.02174127f, 
    -0.05384166f, 0.01447670f, 0.03959297f, 0.00105294f, 0.04224541f, 0.01670660f, -0.00732612f, -0.03224796f, 
    -0.00008049f, 0.03189379f, -0.05266340f, 0.04151211f, -0.02508457f, 0.02962064f, 0.01448905f, 0.04260444f, 
    -0.01978714f, 0.04375498f, 0.04397322f, -0.04090708f, 0.01328267f, -0.02585814f, -0.02525075f, 0.01311606f, 
    -0.02062932f, -0.05505124f, -0.03428220f, -0.04530918f, -0.01223910f, 0.03571925f, -0.01756208f, 0.02398228f, 
    0.00820407f, 0.01643016f, 0.01028242f, -0.02879569f, -0.03092699f, -0.00014598f, 0.00733298f, -0.02444975f, 
    0.00329278f, -0.05635832f, -0.00398871f, -0.04218286f, -0.00753882f, 0.02119504f, -0.01493800f, 0.00744260f, 
    0.00996742f, -0.02078219f, -0.04820855f, 0.03160838f, -0.03720269f, -0.04971513f, 0.02162859f, -0.01192101f, 
    -0.01658162f, -0.03705541f, 0.02290884f, -0.03766164f, -0.02559449f, -0.03518479f, -0.01638073f, 0.01105961f, 
    0.00307975f, 0.00180756f, -0.01320737f, 0.02207361f, -0.02990914f, -0.03765201f, 0.04572538f, -0.02313131f, 
    0.04360804f, -0.00536768f, 0.00401746f, 0.03036193f, -0.04695236f, 0.02998563f, -0.03902811f, -0.02364482f, 
    -0.01166669f, 0.01842123f, -0.00888744f, 0.00106967f, 0.02032266f, 0.03740191f, 0.03380556f, -0.01146556f, 
    -0.02708428f, -0.02919897f, -0.02733357f, -0.02068878f, -0.03283542f, -0.04190790f, -0.03461761f, -0.03748865f, 
    0.02095676f, -0.03568026f, 0.02258513f, -0.02699384f, 0.00183117f, 0.01907688f, -0.03211303f, -0.01085308f, 
    0.00427682f, -0.03138263f, 0.00114531f, -0.01999566f, -0.04626921f, -0.00697762f, -0.03546100f, -0.00162307f, 
    0.02322027f, -0.00829209f, 0.00415500f, 0.00191231f, 0.02268944f, -0.03402759f, 0.01959627f, -0.00223658f, 
    -0.03578427f, -0.03154562f, 0.00826885f, 0.04333447f, 0.03793474f, -0.02476326f, -0.02547224f, 0.02431137f, 
    -0.01911402f, -0.01164856f, -0.02766098f, -0.00694492f, -0.01039866f, -0.01664490f, 0.04106218f, 0.01223861f, 
    -0.02815320f, 0.01954845f, -0.00529307f, 0.00554754f, -0.03169263f, -0.03209023f, -0.04154448f, -0.03015949f, 
    -0.00614506f, 0.03249038f, 0.02851713f, 0.02577748f, 0.02686170f, -0.04925494f, -0.02239458f, 0.01431432f, 
    0.04495267f, -0.03195394f, 0.04260311f, -0.01309430f, -0.00454637f, -0.03020741f, -0.03366751f, 0.02411379f, 
    -0.03449189f, -0.00593963f, -0.00631658f, -0.03363408f, -0.01507884f, 0.04487902f, 0.02067361f, 0.04441898f, 
    -0.00296658f, -0.03832781f, -0.03415917f, -0.01686227f, -0.01767481f, 0.01971986f, 0.01965054f, -0.02950284f, 
    0.02342482f, -0.04435640f, 0.03275408f, -0.02190110f, -0.00232419f, -0.05278873f, 0.04445461f, -0.05407677f, 
    -0.01167008f, 0.03228941f, -0.03931546f, -0.01396117f, 0.02022806f, 0.01167927f, -0.03028069f, -0.05025145f, 
    -0.03646594f, 0.04395789f, 0.00138856f, -0.00317937f, 0.02643402f, 0.02397816f, -0.00429844f, -0.05275835f, 
    0.01454300f, -0.02658603f, 0.04175415f, -0.03647564f, -0.02346715f, -0.02433279f, -0.04352539f, 0.00069397f, 
    0.02238175f, -0.04072248f, -0.04090710f, -0.05552722f, -0.03374007f, -0.05257407f, 0.03405253f, 0.02631545f, 
    -0.01635448f, -0.01789237f, 0.02556234f, 0.02576296f, 0.00065357f, 0.01377574f, 0.03284398f, -0.00860469f, 
    -0.04877421f, -0.00175864f, -0.02406086f, -0.04613543f, 0.03729920f, 0.02251202f, -0.04180674f, -0.04983224f, 
    -0.01607231f, -0.03933193f, -0.02509953f, 0.02058179f, -0.02888751f, 0.00972331f, -0.04746406f, -0.01993858f, 
    0.01930648f, 0.02044832f, -0.00770938f, -0.03141697f, -0.01213626f, -0.05051283f, -0.01802133f, 0.02319402f, 
    -0.04309330f, -0.05301397f, -0.05032539f, 0.00668618f, -0.00372102f, -0.01252823f, -0.02746937f, 0.01635130f, 
    -0.03213030f, -0.01113058f, 0.01732012f, -0.05513386f, 0.00333563f, -0.05374656f, 0.00135487f, -0.03406456f, 
    0.03653033f, -0.00414509f, 0.00128142f, 0.03437472f, 0.01631106f, -0.00554731f, 0.02771068f, -0.00808333f, 
    0.01782296f, -0.00795133f, 0.03797674f, -0.00093439f, -0.01511564f, 0.00497880f, -0.00576128f, -0.03808331f, 
    0.02626072f, -0.05111819f, -0.04582452f, 0.01249622f, -0.03271773f, -0.05461974f, -0.01825099f, -0.04341386f, 
    -0.03342564f, -0.00371841f, 0.03149242f, -0.04707599f, -0.00054880f, 0.03725658f, 0.04413370f, -0.04896631f, 
    -0.01688031f, -0.03976006f, -0.02885842f, 0.03612160f, -0.00887967f, -0.00196157f, -0.02698902f, 0.02294105f, 
    -0.02731582f, -0.00795315f, -0.01091667f, 0.04460167f, 0.00026102f, 0.01562210f, 0.02620862f, 0.02875748f, 
    -0.02240840f, 0.03677329f, -0.02562559f, -0.05533643f, -0.02697234f, -0.02730400f, 0.00319982f, 0.01767172f, 
    -0.05589924f, 0.00851938f, 0.01481616f, -0.01522417f, -0.02838187f, 0.00268762f, -0.02995816f, -0.02814163f, 
    0.03816937f, -0.01280546f, -0.04390294f, -0.02712539f, 0.02400422f, -0.02203216f, -0.05516754f, -0.03190926f, 
    0.04267573f, 0.02503838f, 0.03286351f, -0.04690516f, -0.00280402f, 0.03148713f, 0.04376820f, 0.01403596f, 
    0.03134807f, -0.00317461f, -0.02365445f, -0.01785706f, 0.04468096f, 0.02351111f, -0.02156049f, -0.04725302f, 
    -0.03773556f, -0.02862915f, 0.02932159f, -0.03135069f, -0.05163090f, 0.02989667f, 0.00367114f, 0.03801747f, 
    -0.00338409f, 0.02455068f, 0.00093291f, 0.03155078f, -0.03380309f, -0.04216611f, 0.03632816f, 0.02514201f, 
    -0.02105350f, 0.02477486f, -0.04164750f, -0.03100511f, -0.03545652f, 0.03417479f, -0.01059091f, 0.02280244f, 
    -0.02733978f, -0.01641312f, 0.01230069f, -0.01761175f, 0.03389473f, -0.03898589f, 0.00696465f, 0.00511404f, 
    -0.03106533f, -0.04109083f, -0.04750307f, -0.00332251f, -0.00556203f, -0.04247000f, 0.02403193f, 0.00546792f, 
    0.03079076f, 0.03541578f, -0.00261308f, -0.05152491f, -0.02711852f, 0.02891182f, -0.00966042f, 0.00836175f, 
    -0.03592033f, -0.00041589f, -0.01444117f, -0.01859684f, -0.01541778f, -0.01400261f, 0.02170949f, 0.02341367f, 
    -0.00003067f, -0.02310586f, 0.03114121f, -0.03275358f, -0.02668194f, -0.04076703f, -0.03307750f, -0.00971718f, 
    -0.02907953f, -0.05052322f, 0.01716968f, -0.04442982f, -0.04027674f, -0.04463464f, -0.01765278f, 0.01121708f, 
    0.04193159f, -0.02633482f, 0.01111424f, -0.01784609f, -0.00088836f, 0.02905715f, 0.01613409f, -0.03396737f, 
    0.03635158f, -0.01671638f, -0.03159520f, 0.00797608f, -0.02476346f, -0.00745472f, 0.01008515f, -0.04293099f, 
    -0.28855720f, 0.22291921f, -0.09165825f, 0.33727765f, -0.19804026f, -0.15313567f, -0.00649533f, 0.01526068f, 
    -0.02236353f, 0.03228102f, -0.04659412f, -0.14069001f, -0.01902301f, -0.07055694f, -0.11033958f, 0.42374656f, 
    0.00377526f, -0.08833339f, 0.06580058f, -0.06694376f, -0.06858405f, 0.10575013f, 0.05066240f, 0.30096593f, 
    0.17354460f, -0.01087633f, 0.13358057f, 0.30293512f, 0.04628041f, -0.00272121f, -0.02472633f, 0.17767346f, 
    -0.00486695f, 0.17293067f, 0.00364690f, 0.19045377f, -0.06831050f, -0.01737742f, 0.08112013f, 0.09209453f, 
    -0.29352647f, -0.12905496f, -0.06662818f, 0.26309773f, -0.09512673f, 0.14094336f, 0.14539023f, 0.09112003f, 
    0.50645751f, 0.29805291f, -0.13469906f, -0.35792074f, -0.00659345f, 0.00645869f, 0.02614625f, -0.08079515f, 
    0.06402121f, -0.07070646f, 0.06344243f, 0.01468051f, -0.31825063f, -0.14677194f, -0.03406163f, 0.06207791f, 
    -0.04908890f, 0.11279090f, -0.09513681f, -0.15766019f, 0.21459089f, 0.08063682f, 0.17632748f, 0.07651300f, 
    0.30992165f, 0.37102944f, -0.08049113f, 0.05657501f, 0.09759346f, -0.04004821f, -0.02499630f, -0.02073754f, 
    0.05717325f, -0.02271398f, 0.08636850f, -0.11180960f, -0.21422355f, 0.08600525f, 0.13757904f, 0.18397965f, 
    -0.00521206f, 0.00612408f, 0.07883269f, -0.01430490f, 0.32536054f, 0.00805973f, -0.00295338f, 0.27893251f, 
    -0.58003390f, 0.13765699f, 0.01329065f, -0.12626851f, 0.21657056f, 0.02266350f, 0.09100328f, 0.18894051f, 
    0.13177422f, 0.10061651f, 0.03706308f, 0.01268581f, -0.63544446f, -0.00313682f, 0.26472101f, -0.00819616f, 
    0.14272945f, -0.05546020f, 0.11846807f, -0.02694069f, -0.02684263f, 0.05545976f, 0.15359536f, -0.24178116f, 
    -0.08677489f, -0.08017529f, -0.05026954f, 0.23752815f, -0.11587998f, 0.01205328f, -0.02157193f, 0.07433992f, 
    -0.13418676f, -0.05113394f, -0.05221528f, 0.07243509f, -0.20467645f, -0.09995372f, 0.29396030f, 0.02482205f, 
    -0.03023632f, 0.03180646f, 0.14969699f, -0.02765827f, 0.29723382f, -0.07162957f, 0.17096402f, -0.02164246f, 
    -0.27889046f, -0.12090924f, 0.26349968f, -0.20010476f, 0.11600590f, -0.06903013f, 0.06719428f, 0.03048166f, 
    0.14273660f, 0.20150891f, 0.28755212f, 0.15122880f, 0.10383096f, -0.13892180f, 0.29947957f, -0.43824804f, 
    -0.07098101f, 0.08807178f, -0.11028535f, 0.14956445f, 0.00663920f, 0.08236816f, -0.20983005f, -0.22713616f, 
    -0.02425746f, 0.15483594f, -0.23342188f, 0.25217152f, -0.00079611f, 0.12573257f, 0.10847654f, 0.02020980f, 
    0.02934883f, 0.22083625f, -0.07517194f, -0.05389207f, 0.18196911f, -0.35854313f, 0.01720276f, 0.13154633f, 
    0.20281760f, -0.02015905f, 0.26312467f, -0.07760623f, -0.02351340f, -0.15329210f, -0.00318319f, -0.18431705f, 
    -0.26721856f, 0.08303145f, -0.11332107f, -0.02918478f, 0.07889847f, -0.01513323f, -0.04955857f, 0.09669091f, 
    -0.10331479f, 0.09892750f, -0.19865194f, -0.14679854f, 0.24594116f, -0.05070372f, 0.03371526f, -0.10342299f, 
    -0.06880984f, -0.17000744f, 0.07062620f, 0.10148052f, -0.05770754f, 0.02525977f, -0.09960719f, 0.00159615f, 
    0.14953525f, -0.17481372f, -0.27827775f, 0.18741798f, 0.25362623f, -0.09420763f, -0.05165952f, 0.10075032f, 
    -0.08196623f, 0.18053029f, 0.12698159f, 0.01149080f, 0.23005886f, 0.08315296f, 0.22897145f, -0.31337070f, 
    -0.10440058f, 0.04658088f, -0.01867831f, -0.08634710f, 0.19434361f, 0.03259085f, 0.04197920f, -0.04196508f, 
    0.30240661f, 0.09577080f, -0.07723509f, 0.16665828f, 0.21545582f, 0.18643965f, -0.15148079f, -0.21325211f, 
    -0.03138956f, -0.04116375f, -0.05722647f, 0.02556710f, 0.06792133f, 0.08775286f, -0.09410716f, 0.08196128f, 
    0.26094705f, 0.29972163f, 0.03576931f, -0.01727795f, 0.06815297f, -0.04039870f, 0.08667780f, -0.18650585f, 
    0.38900676f, 0.24801390f, 0.15977250f, 0.32095632f, -0.17275195f, -0.05933723f, -0.06531353f, 0.05746870f, 
    -0.17441511f, -0.08436958f, 0.09491913f, 0.07760711f, -0.53122032f, 0.29147708f, 0.31563160f, -0.10872339f, 
    0.15295103f, -0.20052055f, 0.15529019f, -0.03075580f, -0.19805047f, 0.07687798f, 0.10580963f, 0.28156680f, 
    0.22302826f, -0.41728863f, -0.03816427f, -0.38517123f, 0.05113335f, -0.07161533f, 0.22623099f, -0.18542491f, 
    -0.10713056f, 0.06751364f, -0.00366523f, 0.14683118f, -0.25808555f, 0.20777583f, 0.05043508f, 0.31998298f, 
    0.14108063f, 0.03318110f, -0.00241989f, -0.14960167f, -0.05016668f, -0.20912547f, -0.04176096f, -0.13457267f, 
    -0.02904022f, -0.04658515f, 0.15964003f, -0.61622095f, 0.12715723f, 0.07039221f, -0.15619992f, 0.00562155f, 
    -0.03770292f, -0.15621215f, 0.02453624f, 0.08017938f, -0.52246284f, 0.03317988f, 0.18108648f, 0.02272708f, 
    0.14506879f, -0.00466050f, 0.39703026f, -0.03298614f, 0.26424837f, 0.10030383f, 0.20509197f, 0.19810046f, 
    -0.12456975f, 0.07295590f, 0.03529214f, 0.10347123f, -0.05674041f, -0.04679909f, 0.07727878f, 0.06039062f, 
    -0.10407125f, -0.04717857f, 0.06440430f, 0.06289426f, -0.44378370f, 0.64018726f, -0.09471215f, 0.07973167f, 
    0.05650245f, -0.04266908f, 0.13263549f, -0.01267276f, 0.07552686f, -0.08704472f, 0.18428297f, -0.27624631f, 
    0.28966734f, 0.32163894f, -0.16757211f, 0.08553942f, 0.00228605f, 0.13715388f, -0.18542761f, -0.00301912f, 
    0.11737958f, 0.10657440f, -0.12576537f, -0.01505849f, -0.08957909f, 0.28740138f, -0.01300096f, -0.22011402f, 
    -0.04350701f, -0.05196603f, -0.13007843f, 0.08881270f, 0.08383605f, -0.09450490f, -0.11608710f, -0.10363199f, 
    -0.02564160f, -0.04872606f, 0.04586620f, -0.01178193f, -0.02693581f, 0.00995225f, -0.04936270f, 0.00668225f, 
    -0.03877886f, -0.01142562f, 0.00015667f, -0.01806124f, -0.05614756f, 0.04650652f, 0.00405333f, -0.04181683f, 
    0.01960123f, -0.00857962f, -0.05230819f, -0.04906874f, 0.02851502f, 0.00000494f, -0.02133609f, -0.02141582f, 
    0.01788029f, -0.03252495f, -0.00063917f, -0.01314253f, -0.01232821f, -0.00506283f, 0.02672578f, 0.02265930f, 
    0.01856851f, 0.00002682f, 0.02408345f, -0.01897700f, 0.02615523f, 0.02143001f, -0.03922661f, 0.03793371f, 
    -0.02987631f, -0.05123576f, -0.00443739f, -0.01079865f, -0.00841601f, -0.00566944f, -0.00368416f, -0.03253665f, 
    -0.02631993f, -0.04762125f, 0.01354017f, 0.03094204f, -0.04857979f, 0.00842712f, 0.03038803f, 0.03492778f, 
    0.02848636f, 0.00344547f, -0.02027300f, -0.01316111f, -0.04125159f, 0.00722983f, 0.02839939f, 0.03135852f, 
    0.00823935f, -0.02742414f, -0.02190227f, 0.03257934f, 0.01669486f, -0.04251065f, 0.02254645f, -0.03320125f, 
    0.02488241f, -0.05050845f, 0.01581560f, -0.05524388f, 0.00067315f, -0.03859312f, 0.00028252f, -0.04557771f, 
    -0.03689198f, -0.04094226f, -0.00605092f, 0.03280635f, -0.04924997f, 0.00792667f, 0.01833110f, 0.04581361f, 
    0.03978334f, 0.04407892f, 0.00995663f, -0.01552693f, 0.03891150f, 0.01245936f, 0.02304729f, -0.02982298f, 
    0.00432973f, -0.04846830f, -0.01860244f, 0.03629015f, 0.01612164f, -0.02921691f, 0.02000691f, -0.00361214f, 
    -0.00073153f, -0.02424994f, -0.03736683f, -0.00160532f, -0.03461980f, 0.03199000f, -0.01709637f, 0.03603609f, 
    0.01150532f, -0.01781551f, -0.03734083f, -0.05580441f, 0.00194376f, 0.02531833f, -0.02641755f, 0.02137468f, 
    0.02918470f, -0.05028825f, 0.03812508f, -0.03563740f, -0.01625665f, -0.01830003f, 0.03079785f, -0.03210798f, 
    -0.05565769f, 0.01270047f, 0.04277721f, 0.01933397f, 0.00221444f, -0.04551059f, -0.04176385f, -0.02142975f, 
    0.01663687f, -0.04830072f, -0.02773249f, -0.01278435f, 0.01556239f, -0.02565889f, -0.00415475f, 0.02997258f, 
    0.02336734f, -0.00440967f, -0.03963314f, -0.01297106f, 0.04470422f, -0.00776198f, -0.05959458f, -0.02784571f, 
    0.01594058f, 0.04724400f, -0.00394010f, -0.03161644f, -0.01289515f, 0.04491936f, 0.01836059f, 0.04388371f, 
    -0.01598781f, -0.05343134f, 0.03874785f, 0.01145897f, 0.04220838f, 0.04712290f, 0.00192897f, 0.00100897f, 
    -0.02347035f, 0.02107722f, -0.05469526f, 0.04449403f, -0.01621151f, -0.01416619f, -0.03246818f, -0.00369024f, 
    -0.00595746f, 0.02111913f, 0.00616388f, 0.00480006f, 0.00215359f, -0.05178663f, 0.01542695f, 0.01718740f, 
    -0.04297058f, 0.04307787f, -0.00561706f, 0.02836253f, 0.02433020f, 0.02197493f, -0.02305182f, -0.00694000f, 
    0.01521367f, 0.01116029f, -0.00220259f, -0.05863515f, -0.03447114f, -0.03691589f, 0.02134682f, -0.00961718f, 
    0.02739222f, -0.01564537f, 0.02650210f, -0.02009473f, 0.02537265f, 0.03058170f, 0.03303984f, -0.00291769f, 
    0.00975459f, 0.00672827f, -0.05189949f, -0.01150970f, -0.04347923f, 0.03171176f, -0.02273627f, 0.02463738f, 
    -0.04462780f, 0.03150723f, 0.02125799f, -0.01899660f, 0.01556476f, -0.01574687f, 0.03608856f, -0.02502157f, 
    -0.03220948f, 0.04261919f, -0.00484207f, 0.01029774f, -0.01097435f, -0.03426249f, -0.05009877f, -0.04041271f, 
    0.02353239f, -0.04411354f, -0.03877318f, -0.02556302f, 0.00429527f, -0.00431450f, 0.02414842f, -0.00016806f, 
    -0.03715171f, 0.03100841f, -0.04940109f, 0.03681128f, -0.04020401f, -0.00757077f, 0.04092713f, 0.00772359f, 
    -0.02243750f, 0.01145312f, 0.00260431f, 0.02594145f, 0.02216419f, -0.00121831f, 0.01706761f, -0.00201932f, 
    -0.05000682f, -0.04202659f, 0.01355911f, 0.01196103f, -0.05992802f, -0.01814562f, 0.01467343f, 0.00152525f, 
    0.02963608f, 0.01157612f, 0.00016291f, -0.00360374f, -0.02768368f, -0.03561551f, -0.01785384f, 0.02745241f, 
    -0.03809074f, -0.02648752f, -0.00888448f, 0.02121838f, 0.01068512f, -0.02749086f, 0.04239785f, 0.02293325f, 
    0.02462786f, -0.01890391f, -0.01394960f, -0.04542472f, -0.04233164f, -0.04686384f, 0.02380279f, 0.00691400f, 
    -0.02669824f, 0.01903794f, 0.01016716f, -0.04728912f, 0.02368684f, -0.03523119f, -0.05027802f, 0.03620948f, 
    -0.01596312f, -0.00138747f, 0.04518706f, -0.00736334f, 0.02955603f, -0.03479729f, -0.03903022f, 0.00385864f, 
    0.01406241f, 0.00576605f, -0.00576604f, 0.01521418f, 0.00427177f, -0.02430340f, 0.02226232f, -0.00971526f, 
    -0.03750392f, -0.04551588f, 0.01810732f, 0.04049187f, 0.02394983f, -0.02688457f, -0.04740915f, -0.01124261f, 
    0.01961233f, -0.02271052f, 0.00328454f, -0.01047002f, -0.03293874f, 0.03916712f, 0.02706225f, 0.00368527f, 
    0.02970882f, -0.05068817f, -0.02228098f, -0.03355741f, 0.04965234f, 0.03217119f, -0.00925606f, 0.00701607f, 
    -0.02924155f, 0.03628161f, 0.03003503f, -0.02782778f, -0.04235981f, -0.04031930f, -0.05298327f, -0.00224771f, 
    -0.02160636f, -0.04868303f, -0.05129702f, -0.02287078f, -0.00089939f, 0.04361629f, 0.02805711f, -0.05304741f, 
    0.02901409f, -0.02199819f, -0.05115385f, 0.00770305f, -0.02571844f, -0.01190875f, -0.02382569f, -0.03100464f, 
    -0.04209939f, -0.01966214f, -0.03273343f, -0.03821584f, 0.02012832f, -0.02523055f, 0.01467534f, 0.00793392f, 
    0.04201693f, -0.00423222f, 0.00192712f, 0.03522755f, -0.01276892f, -0.04722203f, -0.01793732f, -0.05354692f, 
    0.00108753f, -0.01675984f, -0.01311063f, -0.01448224f, -0.04147428f, -0.01274184f, -0.01057990f, 0.04020992f, 
    -0.04400487f, 0.03693230f, -0.05145413f, -0.01352447f, -0.05468092f, 0.03274952f, 0.00205100f, -0.01781758f, 
    -0.02778902f, -0.04561993f, -0.03673140f, -0.00452787f, -0.03552816f, -0.05509186f, -0.01074237f, 0.02282906f, 
    0.01457520f, -0.03229621f, -0.00463723f, -0.02574590f, -0.05424911f, -0.00229989f, 0.02703446f, 0.01498621f, 
    -0.03739921f, 0.03892079f, 0.01876652f, 0.00057060f, -0.02493307f, -0.00709401f, 0.00288035f, -0.00502076f, 
    0.04031187f, -0.01870189f, 0.01389073f, -0.05472422f, 0.01946571f, 0.04282893f, -0.03862520f, -0.04613372f, 
    -0.05667478f, 0.02636060f, -0.04790191f, 0.03189802f, -0.05908825f, -0.04447345f, 0.01780853f, 0.02079946f, 
    0.02608087f, -0.03764985f, -0.03164473f, -0.04189833f, -0.05822180f, -0.04306500f, -0.00788802f, 0.00302857f, 
    0.03388185f, 0.03818570f, 0.03789093f, -0.01048791f, 0.03676901f, 0.04181798f, 0.03626769f, -0.05049912f, 
    -0.01777835f, -0.01913713f, -0.02242024f, 0.00932863f, -0.01881909f, -0.04679290f, -0.02784638f, 0.00707104f, 
    0.02671798f, 0.03045631f, -0.01321003f, 0.02713843f, 0.01608829f, -0.00343183f, 0.00930978f, 0.02031965f, 
    0.02395018f, 0.01929990f, -0.04329976f, 0.04804992f, -0.02396056f, -0.03634456f, -0.04599636f, -0.02739217f, 
    -0.00337900f, -0.04996106f, -0.01152882f, -0.01250322f, 0.02464435f, -0.03624063f, 0.03489785f, 0.04063936f, 
    -0.00342587f, -0.03715647f, 0.02441921f, 0.01702142f, -0.01704782f, 0.00649006f, -0.03160321f, 0.03488224f, 
    -0.02485962f, 0.00531983f, 0.03482820f, 0.00437453f, 0.01798663f, 0.02011302f, 0.04149769f, -0.03665743f, 
    -0.00539111f, -0.05161625f, -0.00785297f, -0.04509881f, 0.00862833f, -0.05186790f, -0.03663524f, 0.00072307f, 
    -0.04447741f, -0.04841681f, -0.03617261f, 0.01790433f, 0.01654922f, 0.03273162f, -0.02050713f, 0.02310481f, 
    0.03783482f, 0.04249371f, 0.00858817f, -0.02437441f, -0.02746532f, -0.04668254f, -0.02785827f, -0.03405196f, 
    -0.02581183f, 0.04314662f, 0.03522119f, -0.03813589f, -0.02655652f, -0.02462228f, -0.01917790f, 0.03619293f, 
    -0.00376616f, -0.02942530f, -0.04690639f, -0.01229573f, -0.05343010f, -0.01023275f, -0.04022906f, -0.03866878f, 
    0.03920835f, -0.00174377f, 0.00316101f, -0.00272264f, -0.04908503f, -0.04360829f, -0.03501341f, -0.00980361f, 
    -0.02475515f, 0.02721794f, 0.00187794f, -0.03085259f, -0.01639172f, 0.00596609f, 0.03190407f, -0.01416560f, 
    -0.01500627f, -0.03243025f, 0.00464235f, -0.00229769f, 0.04769680f, -0.02007392f, 0.02979643f, 0.00556139f, 
    -0.03240709f, -0.04085958f, -0.01810408f, 0.00616659f, 0.01250700f, 0.03333506f, 0.03766576f, 0.02283630f, 
    -0.01694781f, 0.02727650f, 0.01333251f, -0.00622072f, -0.02959463f, 0.04325906f, 0.00394201f, 0.02925147f, 
    -0.03951202f, -0.03438050f, -0.01286306f, 0.01540425f, 0.01129629f, -0.02886475f, -0.01819441f, -0.03424520f, 
    -0.02060854f, 0.04075521f, -0.04530198f, -0.03286512f, -0.04965542f, -0.05083102f, 0.01531874f, -0.01585568f, 
    -0.03378360f, 0.01225362f, -0.04478892f, -0.05142813f, -0.04190606f, -0.01673544f, -0.04606462f, -0.05552831f, 
    0.01647295f, -0.02545889f, -0.03510258f, 0.02283706f, -0.03036478f, -0.05514481f, 0.01252219f, -0.02890705f, 
    -0.00907976f, -0.03151641f, -0.04859127f, 0.03591128f, -0.05713047f, 0.02235579f, -0.04681042f, -0.04988641f, 
    -0.01216856f, 0.00906749f, -0.02265825f, 0.02557521f, -0.04195539f, -0.03542766f, -0.02399846f, -0.03999179f, 
    0.01194979f, -0.05412464f, -0.04348824f, -0.01506131f, -0.05442229f, 0.02764888f, 0.00219905f, -0.01691973f, 
    0.00274342f, -0.05604300f, 0.03935481f, -0.02543242f, 0.03182394f, -0.02496671f, -0.00877603f, -0.00623133f, 
    -0.01124779f, -0.05079954f, -0.04667202f, -0.05620425f, -0.05180365f, 0.03340333f, 0.02274787f, 0.00053000f, 
    0.04009322f, 0.02196795f, 0.03944738f, 0.00987688f, 0.01114933f, -0.04608825f, -0.04258511f, -0.01141153f, 
    -0.02420276f, 0.00228164f, -0.04441588f, -0.02292267f, -0.01466726f, 0.04158660f, -0.02366246f, 0.00742619f, 
    -0.02791016f, -0.03398494f, -0.03209889f, 0.04199504f, -0.03267340f, -0.01563117f, 0.03291783f, 0.02310440f, 
    -0.05746774f, -0.00971174f, -0.01178475f, -0.03827705f, 0.03006142f, 0.03801621f, 0.02309174f, -0.01524815f, 
    -0.00647476f, 0.00402153f, -0.02004120f, -0.02674890f, 0.01663171f, 0.00602418f, -0.03422794f, -0.00929213f, 
    0.03315885f, -0.01693368f, 0.03567813f, 0.02241028f, -0.04311616f, -0.00465521f, -0.01700776f, 0.04298804f, 
    -0.03587946f, -0.00857051f, 0.02015923f, -0.04152776f, 0.01292845f, -0.00754714f, -0.03446324f, -0.03323328f, 
    0.01860926f, 0.03255619f, -0.03751968f, 0.01172752f, -0.00198506f, -0.01546308f, -0.03803730f, -0.03187743f, 
    0.01696727f, -0.02481890f, 0.03706142f, 0.03820297f, 0.00651239f, -0.01613958f, -0.03635596f, 0.03124265f, 
    0.00577516f, 0.00228410f, -0.02901619f, 0.04088281f, -0.02282625f, 0.00151839f, 0.03206472f, 0.03605803f, 
    0.02062907f, -0.05031168f, 0.00100118f, -0.03728190f, -0.04246084f, -0.01286512f, -0.00023618f, -0.03368645f, 
    0.02513493f, 0.00530232f, -0.00402714f, -0.00631505f, 0.01210922f, 0.01012490f, 0.00345333f, -0.03981836f, 
    0.04040745f, -0.01422170f, -0.03720647f, 0.01909211f, -0.04498153f, 0.02677840f, 0.04233149f, 0.01572398f, 
    0.00950125f, -0.04382510f, 0.01236303f, 0.02951484f, -0.04535463f, -0.05324378f, 0.04183332f, 0.00404209f, 
    0.03163663f, -0.01104541f, -0.00143976f, -0.03788004f, -0.03397333f, 0.03006070f, -0.02552131f, 0.01840544f, 
    -0.01483252f, 0.01782770f, 0.04537278f, 0.00958376f, 0.00092050f, 0.00178944f, 0.01500028f, -0.01131652f, 
    -0.01091865f, 0.03953097f, -0.04546017f, -0.02208987f, 0.01893754f, -0.00054770f, -0.00442340f, -0.01517885f, 
    0.00115740f, 0.03186570f, 0.02576454f, 0.04283430f, -0.04812184f, -0.01332508f, -0.04672235f, 0.01137607f, 
    -0.05302843f, -0.04755152f, -0.04321428f, -0.02675951f, -0.04845002f, -0.05385851f, -0.02412654f, 0.03985054f, 
    -0.04720966f, 0.02095179f, -0.03269058f, 0.01266196f, 0.02143794f, -0.02412940f, -0.04045297f, 0.03981539f, 
    0.04188627f, 0.05146362f, -0.05039160f, -0.00311497f, 0.02497418f, -0.00761722f, 0.03655915f, 0.01906081f, 
    0.01175956f, 0.04005516f, 0.00936525f, 0.01386368f, 0.02522882f, -0.02122232f, 0.00601338f, 0.03943595f, 
    -0.05274942f, 0.00556863f, 0.02295386f, -0.03646097f, -0.04427180f, -0.01283074f, -0.01341003f, -0.02737232f, 
    -0.03646626f, -0.01629546f, -0.02161605f, -0.01500622f, -0.04558375f, 0.03465029f, -0.04948143f, -0.04392609f, 
    0.01898925f, 0.00982100f, 0.01569901f, -0.04700404f, -0.02090742f, -0.04455880f, 0.02896320f, -0.03064851f, 
    -0.02492244f, 0.04667901f, 0.01113931f, 0.02870596f, -0.03529924f, 0.03141682f, 0.02154465f, -0.01168598f, 
    -0.03459314f, 0.03009878f, -0.00981740f, 0.02370911f, -0.02937471f, -0.03627327f, 0.01396611f, 0.01300092f, 
    0.03661798f, -0.01780882f, -0.04395320f, 0.01642360f, -0.02164684f, -0.01823041f, 0.00532168f, -0.00862330f, 
    0.01260641f, 0.01107198f, -0.02209753f, -0.01592958f, -0.01595461f, -0.03116810f, 0.01397920f, 0.00557942f, 
    0.01527231f, 0.02009104f, 0.04187787f, -0.00774328f, -0.05316029f, 0.04094687f, -0.01799262f, -0.02440674f, 
    -0.04151865f, -0.04338485f, -0.03140818f, -0.03409517f, -0.01139980f, -0.05027011f, -0.00661213f, 0.00596873f, 
    -0.04332834f, -0.01896115f, 0.00187100f, 0.02675567f, 0.03787465f, 0.03234956f, -0.03376171f, -0.03398683f, 
    -0.05144317f, 0.01329691f, -0.05274681f, -0.05012029f, 0.01826162f, -0.02774651f, -0.01015431f, -0.01189979f, 
    -0.04259963f, -0.00235859f, 0.02772688f, -0.04230194f, 0.03154631f, 0.03039921f, -0.03782944f, -0.04030378f, 
    0.02529302f, 0.00331668f, 0.00238376f, 0.00240583f, 0.01114694f, -0.02400578f, 0.00126677f, -0.03630727f, 
    -0.01120741f, 0.04679003f, 0.02788675f, 0.04317762f, -0.01560576f, 0.04197816f, 0.04564483f, 0.01656640f, 
    -0.03261945f, -0.01015787f, 0.02246675f, 0.02872760f, 0.01475652f, -0.03791954f, 0.02561977f, 0.03800087f, 
    -0.03710910f, -0.01009776f, -0.04906135f, 0.03384368f, -0.05260331f, 0.02125981f, 0.04316380f, -0.01713779f, 
    -0.03960161f, -0.02367680f, 0.04004480f, -0.02834327f, -0.04988441f, 0.01581611f, 0.02467642f, 0.02116213f, 
    0.00276669f, -0.02603471f, -0.02139119f, -0.04188942f, 0.03041964f, -0.03539190f, 0.04298591f, 0.01799329f, 
    -0.00223413f, -0.01426549f, 0.02678143f, 0.01758087f, -0.03873896f, 0.04056422f, -0.03444953f, 0.03038939f, 
    -0.03844827f, 0.03132019f, -0.03641305f, -0.03805854f, 0.01630371f, 0.03858754f, 0.02881267f, -0.03427229f, 
    0.00011406f, 0.01064305f, -0.04451923f, -0.01669179f, -0.02136602f, 0.00988881f, -0.05449103f, -0.03869944f, 
    0.03080512f, 0.02087198f, 0.03708025f, -0.03026104f, 0.03976388f, 0.00160972f, 0.01706756f, 0.02217180f, 
    -0.04089829f, -0.00058410f, -0.04698161f, 0.04335525f, -0.04741135f, 0.03185396f, 0.00740684f, -0.03490116f, 
    -0.03993422f, -0.03702363f, 0.03937217f, 0.01060463f, 0.01243513f, -0.04544381f, -0.04121771f, 0.01912611f, 
    0.00382196f, -0.05823950f, 0.02406637f, 0.01616082f, -0.04342850f, -0.04834545f, 0.00643897f, -0.00187078f, 
    -0.00256306f, 0.03100138f, 0.03247331f, 0.01053069f, -0.03119708f, 0.02505255f, -0.00797770f, -0.00730302f, 
    -0.03714477f, 0.00242336f, -0.03374275f, -0.02194824f, -0.02277715f, 0.00697868f, -0.03088263f, -0.04835168f, 
    -0.02229463f, -0.03017313f, -0.00239166f, -0.02170394f, 0.01523887f, -0.04091863f, 0.02864626f, 0.02120728f, 
    0.04294853f, -0.03476689f, -0.02941283f, -0.00869649f, 0.02368413f, 0.00074206f, 0.01167786f, -0.04047489f, 
    -0.02705312f, 0.00716077f, 0.02037887f, -0.00950491f, -0.00079912f, 0.01444332f, -0.04124413f, 0.00770935f, 
    -0.02941793f, 0.02259402f, 0.03468929f, -0.00275910f, -0.04981280f, 0.00905615f, -0.04956807f, -0.02688975f, 
    0.04040961f, -0.04787085f, 0.02900397f, -0.05470858f, 0.00321370f, -0.02396480f, 0.02046886f, 0.04007726f, 
    -0.03594310f, 0.03140518f, -0.03316008f, -0.03121231f, -0.00550700f, 0.01085043f, -0.04029827f, 0.03144473f, 
    -0.01368723f, -0.03472382f, -0.00094646f, 0.03347941f, -0.04725145f, 0.02254030f, 0.03225943f, -0.03322846f, 
    -0.00940987f, 0.00870488f, 0.01100612f, -0.02165593f, 0.01550865f, -0.01392332f, -0.02553197f, -0.04621812f, 
    0.01271317f, 0.04743492f, 0.01848480f, 0.03304046f, -0.01117839f, -0.00729748f, 0.00921757f, -0.01224966f, 
    -0.03799325f, 0.02320917f, -0.04490503f, 0.01858127f, 0.01333913f, -0.01438247f, -0.01336400f, -0.03656064f, 
    -0.02891542f, -0.02886801f, 0.04427345f, -0.00373416f, -0.01715261f, 0.00874029f, 0.00188216f, -0.01674546f, 
    0.02146963f, -0.01418331f, 0.03668362f, 0.01925800f, 0.00534125f, -0.05360223f, 0.00041498f, -0.02217634f, 
    0.04608881f, -0.00722704f, -0.04685632f, 0.00519526f, -0.02088923f, 0.00747391f, -0.02058442f, 0.02241386f, 
    0.01762691f, 0.04429539f, -0.00514974f, -0.03636567f, -0.00174508f, -0.01667024f, -0.04227491f, -0.04106476f, 
    0.02796328f, 0.00592362f, 0.03177213f, -0.03462441f, -0.05456904f, -0.01606179f, -0.00182150f, 0.00872992f, 
    0.00967230f, 0.03061781f, -0.00823682f, -0.00762509f, 0.02471662f, 0.04133962f, 0.03565200f, -0.00606698f, 
    0.00084523f, 0.01533891f, 0.03975133f, 0.00019327f, -0.03815236f, 0.03148992f, 0.04347794f, -0.00808516f, 
    -0.00456941f, -0.00257319f, -0.04012044f, -0.01083586f, 0.01393856f, 0.00606801f, 0.00693614f, 0.00046238f, 
    -0.02941981f, -0.01650255f, -0.01683163f, 0.01093202f, 0.04082624f, -0.00132723f, -0.04478270f, -0.00632587f, 
    0.00165614f, -0.03671570f, -0.04268169f, -0.03216957f, 0.02918443f, 0.03570328f, -0.02786832f, 0.00026836f, 
    0.03269252f, -0.02096307f, -0.04502253f, 0.00806472f, -0.00288430f, -0.05585831f, -0.03906440f, 0.01347380f, 
    -0.01275256f, -0.03557593f, 0.00520303f, 0.03852008f, -0.04223422f, -0.00439633f, 0.04268097f, -0.00562407f, 
    0.03907301f, 0.00347223f, -0.04598256f, 0.03430841f, -0.00163323f, 0.01486082f, -0.02392014f, -0.03018841f, 
    -0.01950328f, 0.03129871f, 0.03506549f, 0.01437912f, 0.01534543f, -0.04339819f, 0.02796673f, -0.00274746f, 
    -0.04752367f, -0.02499762f, -0.01760407f, 0.01726040f, -0.02126854f, -0.05681506f, -0.01296569f, 0.00490641f, 
    -0.01006467f, 0.00133660f, -0.02782630f, -0.03437370f, 0.00165318f, 0.02597415f, -0.03750389f, -0.04095152f, 
    0.04626453f, -0.00097257f, 0.01047071f, 0.00875803f, -0.00183898f, -0.03411438f, -0.03284322f, -0.02693533f, 
    -0.02240876f, -0.00259072f, 0.05304940f, 0.02706288f, 0.04045102f, -0.03544265f, -0.01226516f, -0.02253111f, 
    -0.00402259f, 0.03699387f, 0.02698778f, 0.03937308f, 0.03272426f, 0.00873078f, 0.03382674f, -0.04064278f, 
    -0.00568874f, 0.01245883f, 0.00923858f, 0.03481705f, -0.01036960f, -0.01281574f, 0.03049872f, 0.02228627f, 
    -0.02701084f, -0.05180941f, 0.03937100f, 0.01548342f, -0.03118923f, -0.05418647f, -0.03532133f, -0.00808707f, 
    -0.00341126f, 0.00137540f, -0.05360062f, -0.04666129f, -0.02190539f, -0.04621142f, 0.02040348f, -0.02311903f, 
    -0.04914778f, -0.06068180f, -0.04486842f, 0.03695497f, 0.00452837f, 0.01245230f, -0.00743964f, -0.03776351f, 
    0.01670358f, -0.01932710f, 0.00342850f, 0.01217307f, -0.02619830f, -0.05400852f, 0.00256754f, 0.02891210f, 
    -0.03045202f, 0.02278319f, 0.02986173f, -0.05162076f, 0.01715213f, -0.00025011f, -0.01591140f, -0.01206851f, 
    0.00837463f, 0.01285889f, 0.03389443f, -0.04482534f, -0.00918083f, -0.03025730f, 0.02346303f, -0.04585696f, 
    0.01282749f, 0.00106422f, 0.03163147f, 0.02126293f, -0.03916883f, 0.00423745f, -0.03943125f, 0.02801816f, 
    -0.03578078f, -0.00417245f, -0.01431257f, -0.00709237f, -0.04314443f, 0.01894249f, -0.05489016f, -0.01667967f, 
    -0.03289705f, 0.02036150f, 0.00539420f, 0.00125895f, 0.01432535f, 0.03840461f, -0.03290241f, -0.00947007f, 
    -0.00252131f, 0.00858211f, 0.03347188f, -0.02357469f, 0.02514886f, -0.04629074f, 0.03406162f, 0.00106730f, 
    -0.04709593f, 0.00272350f, 0.00034067f, -0.03178891f, -0.00632362f, -0.00745315f, -0.04228287f, 0.02014296f, 
    -0.03092662f, -0.05024329f, -0.02857857f, 0.02734119f, -0.03250677f, -0.02148878f, -0.02223861f, -0.00870138f, 
    -0.00382247f, 0.02344190f, 0.00362560f, 0.01113938f, 0.02655958f, -0.03977775f, -0.03756339f, 0.04850367f, 
    -0.03967509f, 0.01679960f, 0.04777357f, 0.02640927f, -0.03352655f, 0.00264073f, 0.01386519f, -0.02915042f, 
    0.02287582f, 0.03682671f, 0.02061120f, -0.02011858f, -0.01433238f, 0.03310892f, -0.04650236f, -0.01619467f, 
    0.01347965f, -0.00699029f, -0.02550605f, 0.02891425f, -0.05759643f, -0.01143423f, 0.05578333f, -0.03937908f, 
    -0.01921916f, 0.01394275f, 0.02509557f, -0.04736288f, -0.01076932f, -0.02996726f, 0.02801327f, 0.01448029f, 
    0.01489408f, 0.02176560f, -0.05377946f, 0.03932965f, 0.02167100f, -0.05600585f, -0.02397851f, -0.04014270f, 
    -0.01133517f, -0.01434838f, 0.00895376f, -0.05326732f, -0.05079670f, 0.01935010f, 0.03507581f, 0.00312238f, 
    -0.04291945f, 0.04228476f, 0.00671147f, -0.03625750f, 0.00611913f, -0.03380207f, 0.02654729f, -0.01349629f, 
    0.03778933f, 0.02769357f, -0.05456672f, 0.01235463f, -0.01827692f, -0.04921155f, 0.02724080f, -0.01937833f, 
    -0.00207277f, -0.04811985f, -0.00539211f, 0.00012527f, -0.01990919f, -0.01235186f, -0.03484937f, -0.02168963f, 
    0.02071499f, -0.03617166f, -0.00659165f, -0.03146657f, 0.02814105f, -0.04831494f, 0.03912489f, -0.00714712f, 
    0.00565291f, 0.03015981f, -0.01325798f, -0.02326118f, -0.02100203f, -0.00086542f, 0.04750245f, 0.02452799f, 
    -0.01514326f, -0.04262227f, -0.02269942f, 0.01621260f, -0.03931477f, 0.00849605f, -0.03550222f, -0.01687277f, 
    -0.04101719f, -0.03749873f, 0.00014341f, 0.03927103f, 0.00304215f, 0.00639356f, 0.03868002f, -0.05217841f, 
    -0.02211733f, -0.02776080f, -0.02146483f, -0.03123374f, -0.00824392f, -0.02746411f, 0.03320072f, -0.04104732f, 
    -0.02067579f, -0.03475591f, 0.00643870f, -0.01161159f, 0.04405699f, -0.02245760f, -0.02046488f, -0.04519934f, 
    0.01938394f, -0.03263488f, 0.01317981f, 0.00508334f, -0.04573525f, 0.02291918f, -0.03297675f, -0.02685061f, 
    0.04041819f, -0.05209824f, -0.01949815f, 0.00191850f, -0.02355316f, 0.01896983f, -0.02204036f, -0.02009513f, 
    0.02112060f, -0.02876474f, -0.04411343f, 0.01446322f, -0.03377377f, 0.00996323f, -0.02382808f, 0.04477274f, 
    -0.00921218f, -0.03444272f, -0.00595125f, 0.02192393f, -0.03510674f, 0.00283693f, -0.04155167f, -0.05441477f, 
    0.00521144f, -0.04358007f, 0.02920751f, -0.05474771f, -0.04483905f, -0.03681527f, 0.03505071f, -0.04319233f, 
    0.03884088f, 0.00838341f, 0.01445359f, 0.03722563f, -0.03077880f, 0.00416185f, 0.04165021f, -0.04779898f, 
    -0.01787187f, -0.05260132f, 0.03439737f, -0.01451582f, 0.02854925f, -0.03774171f, -0.02865828f, 0.01414294f, 
    -0.01467974f, -0.05314444f, -0.05245218f, 0.00454030f, -0.01893922f, 0.04461308f, -0.00052753f, 0.00263972f, 
    -0.03812130f, -0.01585158f, 0.02151675f, 0.01264764f, -0.00202898f, 0.03719547f, 0.04550910f, 0.00882799f, 
    0.00938243f, -0.00021919f, -0.05122663f, 0.01922902f, 0.01053690f, -0.01073082f, 0.00986987f, 0.00963678f, 
    -0.00920403f, -0.00632845f, -0.02956817f, 0.02574217f, -0.04127277f, -0.05286951f, 0.00803002f, -0.05140106f, 
    -0.03721318f, 0.03050806f, 0.00287857f, -0.02217854f, -0.02446120f, -0.04653796f, -0.04774847f, 0.02538413f, 
    -0.00036678f, -0.03164904f, 0.00834717f, -0.04973248f, -0.00583541f, -0.05538481f, -0.01410522f, 0.03735465f, 
    -0.04998821f, 0.00772031f, -0.02466648f, 0.03311988f, 0.03719970f, 0.03954780f, 0.03042378f, 0.01972933f, 
    0.02761596f, -0.03984421f, 0.00497621f, -0.05835392f, -0.03891285f, 0.03419722f, 0.04297585f, -0.04846229f, 
    0.02988157f, 0.01215906f, -0.00489768f, -0.01219507f, 0.01269598f, 0.02071119f, 0.02233989f, -0.00028033f, 
    -0.04612980f, -0.04927939f, -0.05040450f, 0.00325977f, 0.02949340f, -0.04952504f, -0.03470698f, -0.03862871f, 
    -0.00562209f, -0.02588079f, 0.03570066f, -0.03495641f, 0.04806949f, -0.03856706f, 0.03535362f, 0.00410506f, 
    -0.01334206f, -0.03268734f, -0.02922190f, -0.03828287f, 0.00218546f, 0.03201448f, -0.00975745f, -0.01601263f, 
    -0.02570010f, -0.04110537f, 0.01335509f, -0.00369829f, -0.01551341f, 0.01882808f, -0.02317375f, -0.03981021f, 
    0.03606834f, -0.04020479f, -0.02505057f, -0.00950552f, 0.01721403f, -0.01611161f, 0.00114484f, -0.04568503f, 
    -0.03116943f, 0.00486205f, -0.02947369f, 0.00368683f, -0.02259395f, -0.00733342f, -0.02934125f, 0.04109883f, 
    0.03723298f, 0.02877745f, 0.04014081f, 0.01459844f, 0.03577702f, -0.01651610f, -0.02630473f, 0.00877510f, 
    0.03632292f, -0.01243232f, 0.02094819f, -0.02295528f, 0.00217641f, -0.01495362f, -0.00370169f, 0.03454893f, 
    -0.04564892f, 0.01888235f, -0.02557988f, 0.03216530f, 0.01284646f, -0.05249593f, -0.02726030f, 0.00624833f, 
    0.01479659f, 0.04485136f, -0.05432381f, -0.05596685f, 0.04457628f, 0.03899052f, 0.04184039f, 0.03869647f, 
    0.03488836f, -0.02459429f, 0.01985916f, -0.02645810f, -0.02175623f, -0.03503885f, 0.04317458f, -0.00743218f, 
    -0.03381453f, 0.02895313f, -0.03153466f, -0.01296405f, -0.01713646f, -0.04491627f, 0.00756443f, -0.00823397f, 
    -0.02703617f, 0.00737414f, 0.03918520f, 0.04007296f, -0.01004686f, 0.02797458f, 0.03050565f, -0.00982634f, 
    -0.02006058f, -0.04690928f, -0.00441775f, -0.00804088f, 0.03311630f, 0.02945110f, 0.00476394f, -0.02866876f, 
    0.04480429f, -0.02976215f, -0.03244234f, -0.04550951f, 0.02734730f, -0.04677176f, -0.00908484f, -0.05228014f, 
    0.01827462f, -0.04904597f, -0.04714831f, -0.01859839f, -0.04057011f, -0.02630844f, -0.01508525f, -0.01271133f, 
    -0.02043028f, -0.02749151f, -0.03696951f, 0.03976123f, 0.03934306f, -0.03165588f, -0.05289017f, -0.02530740f, 
    -0.04148995f, -0.01522614f, -0.03058169f, -0.03984175f, 0.01518184f, -0.01433563f, -0.01641601f, -0.04189338f, 
    0.01932723f, 0.00792666f, -0.03367032f, 0.02037076f, 0.01802712f, 0.00894704f, -0.01860025f, 0.02082464f, 
    0.03603286f, -0.00758432f, -0.02536047f, 0.02591015f, -0.04270448f, -0.00072942f, -0.05090174f, 0.01052829f, 
    0.02129538f, 0.04385026f, -0.03176893f, 0.03725181f, 0.03098739f, 0.02598915f, 0.02894929f, -0.02722447f, 
    0.03912642f, -0.03783829f, 0.00975334f, -0.04036681f, -0.04753063f, -0.02847173f, 0.00824285f, 0.01145840f, 
    -0.05592050f, 0.00000475f, 0.02739283f, -0.05236515f, -0.03465921f, -0.00428693f, -0.00109411f, -0.00417205f, 
    -0.03045737f, -0.03581782f, 0.01886936f, -0.00339204f, -0.04764167f, -0.03417684f, -0.00954031f, -0.05437575f, 
    -0.02776166f, -0.03472366f, 0.04340070f, -0.03641046f, 0.01857770f, -0.01128364f, 0.01471177f, -0.03755951f, 
    -0.05135710f, -0.02680797f, -0.00867759f, 0.00245704f, -0.02632920f, -0.04936469f, 0.03399707f, 0.01539550f, 
    0.00862156f, -0.05048247f, -0.00314340f, 0.03768933f, -0.00982796f, 0.04182096f, -0.04683387f, -0.04724623f, 
    -0.03844829f, 0.03597704f, -0.04706076f, 0.04536992f, 0.03865483f, 0.04708507f, -0.03112403f, 0.01014312f, 
    -0.01178840f, -0.05260236f, 0.01247109f, 0.04300408f, 0.03244816f, 0.01054392f, -0.03645589f, 0.03715102f, 
    -0.03524699f, -0.00465036f, 0.02887779f, 0.04449701f, -0.03044923f, -0.03405685f, -0.00154736f, 0.03218528f, 
    0.00109407f, -0.04834179f, -0.00094044f, -0.02407433f, -0.00926613f, 0.03823454f, -0.02385230f, 0.00872998f, 
    0.00304549f, -0.04174590f, 0.02266495f, 0.00049397f, -0.04161713f, 0.02232808f, -0.04951719f, 0.03797282f, 
    0.01633716f, -0.01892616f, 0.03778883f, 0.02503714f, -0.02048796f, 0.01150577f, -0.00505723f, -0.04359426f, 
    -0.04282944f, -0.02682075f, -0.03067989f, 0.03260673f, -0.02527517f, 0.04273752f, -0.00052899f, -0.04424109f, 
    -0.00108911f, 0.04317767f, 0.03717677f, -0.04117223f, -0.04802368f, 0.03405154f, 0.01974661f, -0.04202770f, 
    0.02705757f, 0.02805129f, 0.01961250f, -0.00409780f, -0.02111860f, 0.04772355f, -0.01341253f, -0.03175056f, 
    -0.00262098f, -0.04647502f, -0.02526017f, 0.00958279f, -0.02112389f, 0.03833896f, -0.01768036f, 0.00491146f, 
    -0.02167388f, -0.00189234f, -0.00933769f, 0.01824666f, 0.01071716f, -0.02788623f, 0.03655890f, -0.03121660f, 
    0.01505276f, 0.04148294f, 0.02810653f, 0.01828963f, -0.04594726f, -0.02412377f, 0.03014959f, -0.04102655f, 
    0.00048489f, 0.00963736f, 0.03124204f, -0.01583250f, 0.01247618f, 0.02958539f, 0.04756533f, -0.01460073f, 
    -0.01047937f, -0.03566585f, 0.02956823f, -0.01288830f, -0.03298247f, -0.03833581f, -0.00415112f, -0.02830460f, 
    -0.01951968f, -0.01633148f, 0.03059470f, -0.05070785f, -0.02391083f, -0.04405313f, -0.02584828f, -0.05044462f, 
    0.02796262f, -0.04267151f, 0.02178288f, -0.04930910f, -0.01326846f, -0.02899487f, 0.01522687f, -0.02672073f, 
    -0.05484112f, -0.00646730f, 0.00464275f, -0.03548447f, -0.01750295f, -0.04871280f, 0.01071085f, 0.03671152f, 
    0.00415544f, 0.01128517f, -0.00399115f, -0.04366042f, -0.05119492f, -0.04009964f, -0.01362049f, 0.03519645f, 
    -0.04657971f, 0.01538271f, -0.03497307f, 0.02136366f, -0.03451639f, -0.01492966f, -0.02034876f, -0.03377498f, 
    -0.04864197f, 0.02422133f, 0.01199770f, 0.02865378f, -0.00541088f, -0.02603830f, 0.03043318f, 0.02666551f, 
    -0.00279560f, -0.04364461f, -0.02307170f, -0.06068857f, 0.03411456f, -0.01456163f, -0.03367994f, -0.03292479f, 
    -0.03664724f, -0.01098404f, 0.01063132f, -0.04808759f, -0.01676641f, -0.03625279f, 0.00948271f, 0.01452575f, 
    -0.00510865f, -0.03278998f, 0.04448676f, 0.03218172f, -0.02290773f, 0.03701356f, -0.03006719f, -0.03958672f, 
    -0.00848498f, 0.01951433f, 0.02666897f, -0.03338312f, -0.05288686f, 0.01379429f, 0.03763074f, 0.02932967f, 
    0.03917950f, -0.01781745f, 0.03312384f, -0.03447738f, 0.03423395f, 0.00415700f, -0.02277409f, -0.04665818f, 
    0.00410240f, 0.03946279f, -0.04397168f, 0.03822185f, -0.00064352f, -0.01946661f, 0.04004960f, -0.04141311f, 
    -0.03593048f, 0.03995097f, -0.03683582f, -0.02184485f, -0.03604108f, -0.02292227f, -0.02394229f, -0.02382823f, 
    -0.01435584f, -0.04785284f, 0.00461215f, 0.03859311f, -0.00764625f, -0.05745614f, -0.05922120f, 0.02828450f, 
    -0.04134552f, -0.03274725f, -0.00414581f, -0.05135655f, -0.03984157f, 0.03926131f, -0.04868020f, 0.03988632f, 
    -0.01498385f, 0.04330796f, 0.00038226f, -0.04537347f, 0.02034369f, 0.00990487f, -0.01827695f, 0.02699516f, 
    -0.03836662f, -0.02642580f, -0.01288818f, -0.02887752f, 0.03376874f, 0.00959908f, 0.02350424f, 0.00346739f, 
    -0.01356785f, -0.00530336f, 0.03405232f, 0.01063559f, -0.00843581f, -0.00263726f, -0.00824294f, 0.04444485f, 
    0.02737956f, -0.02376489f, 0.02660910f, -0.01307950f, -0.00596067f, -0.05008171f, 0.03085201f, -0.05021976f, 
    0.02316612f, -0.00678459f, 0.03331093f, -0.02252259f, -0.04701256f, -0.04799131f, -0.00289840f, -0.04712336f, 
    0.01557837f, -0.00108772f, -0.02217090f, -0.00667488f, -0.01609325f, 0.01593314f, -0.02600689f, 0.02837703f, 
    -0.05369714f, 0.00028321f, 0.03541297f, 0.00790960f, 0.00893235f, -0.00479343f, -0.01091945f, 0.00523322f, 
    -0.01888458f, 0.03273797f, -0.02542315f, 0.03316503f, -0.05358538f, 0.02663033f, -0.00437474f, 0.02528481f, 
    -0.02858397f, 0.02027031f, -0.01781367f, -0.05773175f, -0.01996471f, -0.02598496f, -0.02045807f, -0.01991934f, 
    -0.05537652f, 0.03345380f, -0.05263950f, 0.03259283f, -0.02295319f, 0.03485993f, -0.03371444f, -0.04923360f, 
    -0.03134272f, -0.01672940f, -0.01780460f, 0.01019579f, -0.00370002f, -0.01124850f, -0.02201334f, 0.00874028f, 
    0.03463630f, 0.02771124f, -0.02986548f, 0.00438704f, -0.00119927f, 0.00937300f, 0.02982382f, 0.01585946f, 
    0.01482750f, -0.04723641f, 0.02920464f, 0.01545964f, -0.01548466f, -0.04583302f, -0.04394201f, -0.03211714f, 
    -0.03543312f, 0.02530825f, 0.02291847f, 0.01019871f, 0.03452204f, -0.01507235f, 0.02746969f, -0.00002250f, 
    0.02835617f, 0.02887520f, 0.01617158f, 0.03580994f, -0.00315650f, -0.03773730f, -0.01298448f, 0.02744721f, 
    0.00741952f, 0.01191174f, -0.05801076f, 0.02005319f, -0.00401369f, -0.04682681f, 0.01630631f, -0.01429179f, 
    0.01109653f, 0.03512914f, -0.06074665f, -0.04099550f, -0.05155529f, -0.02297319f, -0.00347291f, -0.01782498f, 
    -0.02924227f, -0.05448732f, -0.05184090f, 0.04073230f, -0.04233473f, -0.01043884f, 0.01153066f, -0.02972651f, 
    -0.02698072f, 0.02793458f, -0.00215449f, -0.02951034f, -0.02770267f, 0.03894673f, -0.00580922f, -0.00812343f, 
    -0.04404389f, -0.03111752f, 0.00961568f, 0.00255157f, -0.04331572f, -0.02052306f, -0.02620668f, 0.01809215f, 
    0.04381172f, -0.03708825f, -0.03210306f, -0.01332812f, -0.04959080f, 0.00869940f, -0.05377146f, -0.05313205f, 
    -0.03754935f, -0.00790887f, 0.02249746f, 0.00449203f, -0.05946362f, -0.00981639f, 0.03513259f, 0.02854696f, 
    -0.03539573f, 0.04663046f, -0.02221453f, 0.04138126f, -0.01964971f, 0.02813425f, -0.02987741f, -0.04256366f, 
    0.04722942f, 0.04269629f, 0.04195094f, -0.01900184f, 0.03053450f, 0.02021506f, 0.00493794f, -0.01208747f, 
    0.01007035f, -0.04069254f, -0.03222372f, 0.01007490f, -0.00678556f, -0.03324743f, 0.04176253f, -0.00428591f, 
    -0.02312863f, 0.01317331f, -0.00722741f, -0.05599633f, 0.00195712f, -0.05263052f, 0.00082434f, -0.04516194f, 
    -0.05677149f, -0.04640384f, 0.01512412f, 0.01288216f, -0.02724779f, -0.00357086f, -0.00009783f, 0.03732439f, 
    -0.03012761f, 0.02788088f, -0.00899915f, -0.02714177f, -0.03902957f, 0.00909167f, 0.01983966f, 0.03160980f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.00740475f, 0.04796098f, 0.03023961f, 0.02747992f, 0.02883338f, 0.00753521f, 0.07048432f, -0.11148284f, 
    0.01027550f, 0.10182427f, -0.05068733f, 0.02157507f, -0.01284839f, -0.03916283f, -0.02890788f, 0.02173787f, 
    0.02518480f, -0.01531820f, 0.18394592f, -0.00053643f, -0.09110978f, -0.02229294f, 0.03439570f, 0.03798595f, 
    -0.03691730f, 0.02616180f, -0.03121133f, -0.05105313f, -0.01461781f, 0.01924975f, -0.04424167f, 0.02550692f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.17801110f, -0.46118286f, -0.11993419f, 0.06468090f, -0.25345531f, -0.00323987f, -0.61225563f, 0.14372952f, 
    -0.10618541f, -0.56483001f, 0.01684417f, 0.04457653f, -0.13543269f, 0.07372094f, 0.09797987f, -0.11522559f, 
    0.17293534f, 0.11467161f, -0.16207129f, 0.11925869f, 0.33548597f, -0.04763547f, -0.13415821f, -0.12866870f, 
    -0.03843378f, 0.61507320f, 0.07105625f, -0.14847872f, -0.13827467f, -0.02308547f, 0.01703336f, -0.15920913f, 
    0.11883032f, -0.05916204f, 0.14479993f, 0.08073196f, 0.45406860f, -0.48024985f, -0.66503686f, -0.37654734f, 
    -0.16425021f, -0.18158641f, 0.10629229f, -0.09102822f, -0.00762696f, 0.01272493f, -0.15674135f, 0.42151636f, 
    0.01770589f, -0.12870967f, 0.31918457f, -0.04531871f, -0.05374178f, 0.00839455f, 0.12851666f, 0.12857735f, 
    0.13409899f, 0.08860171f, -0.14476177f, -0.12669778f, 0.14212924f, 0.07399607f, -0.05610384f, -0.10293640f, 
    0.15417457f, 0.09693260f, -0.02932457f, -0.00116373f, 0.16408110f, 0.26253492f, -0.09152232f, 0.44828075f, 
    0.17302626f, -0.91004813f, -0.12900972f, -0.60784656f, -0.00569635f, 0.17193308f, 0.13760448f, -0.02150990f, 
    0.14222762f, -0.08181228f, 0.16738278f, 0.12582605f, 0.00342971f, -0.17328148f, -0.01299547f, -0.08397620f, 
    0.12296611f, 0.02104855f, 0.08539435f, -0.14507911f, -0.11011644f, 0.12336735f, 0.12314662f, 0.07737621f, 
    0.01164100f, -0.96193272f, 0.11931951f, -0.14226642f, 0.04471640f, 0.23821299f, 0.11001436f, 0.20961787f, 
    -0.01483972f, 0.28885913f, -0.09616328f, 0.33072782f, 0.02040345f, 0.13798805f, -0.03337447f, -0.80298615f, 
    0.13273445f, -0.05187865f, -0.22522274f, 0.14012620f, -0.14358185f, -0.17085288f, -0.00867475f, -0.02513579f, 
    0.11064711f, -0.29489845f, -0.11766394f, -0.14770417f, 0.14880887f, -0.04954054f, 0.13533208f, 0.03111596f, 
    -0.13164200f, -0.18479031f, -0.14933485f, 0.09821803f, -0.32330298f, 0.23011969f, 0.17507277f, -0.22958097f, 
    0.13417840f, 0.09489267f, -0.11188360f, 0.21919791f, 0.07922304f, 0.05603215f, 0.11365863f, 0.24522114f, 
    -0.00660185f, 0.13021615f, -0.60148221f, 0.04272307f, 0.14181250f, 0.06365667f, -0.03013985f, -0.14999034f, 
    0.04715426f, -0.14988422f, 0.14822608f, 0.03188520f, 0.09565388f, 0.06075669f, -0.10202681f, 0.03863266f, 
    -0.12894304f, 0.42815718f, 0.11152843f, -0.10041726f, -0.47901848f, -0.01177067f, -0.56123978f, -0.56102479f, 
    -0.01522794f, 0.49864611f, 0.01798781f, -0.17053567f, 0.13217159f, 0.08070527f, 0.08674958f, 0.11517961f, 
    -0.01532997f, -0.07356621f, -0.14454609f, -0.06052217f, -0.02659602f, -0.06256771f, 0.15351914f, 0.09792570f, 
    -0.00097479f, 0.49902496f, 0.04097215f, 0.06574403f, 0.07672127f, -0.10514030f, 0.06282146f, 0.14358506f, 
    -0.00436385f, 0.52023667f, 0.03297726f, 0.05725285f, 0.06505979f, 0.30590287f, -0.57843143f, -0.18230659f, 
    -0.04885533f, -0.12619402f, 0.07329232f, -0.00229647f, 0.16602443f, 0.15512855f, 0.02242806f, -0.43769887f, 
    0.15392022f, -0.11666307f, 0.06556898f, -0.04544659f, 0.19035384f, -0.12368982f, -0.02931292f, -0.05912063f, 
    -0.05390092f, -0.75471091f, 0.05343463f, 0.08551779f, 0.16377340f, -0.02413599f, 0.08329427f, 0.10676715f, 
    0.01830934f, 0.57833374f, 0.03732821f, -0.17801780f, 0.13664865f, -0.10957470f, 0.27306589f, 0.48388648f, 
    0.02838264f, -0.10800243f, 0.01967930f, 0.05061158f, -0.06756248f, -0.03517862f, 0.10633872f, -0.27663010f, 
    -0.04420572f, 0.10966181f, -0.75039619f, -0.07143585f, -0.47757304f, 0.01598266f, 0.15022969f, 0.05625175f, 
    0.13587518f, -0.22250727f, 0.10099830f, 0.09880630f, -0.11444306f, 0.10046586f, 0.06608053f, -0.09223273f, 
    -0.10273222f, -0.36112258f, -0.17721029f, 0.12668219f, 0.26956090f, -0.67825991f, -0.07487111f, 0.24825110f, 
    0.11210629f, 0.38908419f, 0.10372014f, -0.79443139f, -0.09970443f, 0.10150789f, -0.04624436f, 0.33862123f, 
    0.15681419f, 0.12184807f, 0.10616576f, -0.07929614f, 0.23459013f, 0.04090960f, 0.00933493f, -0.06502758f, 
    0.00857650f, -0.17976344f, -0.01492441f, -0.12061545f, -0.05376821f, -0.00256196f, -0.17821017f, -0.15380885f, 
    -0.16090743f, 0.27540520f, 0.13274224f, 0.13990469f, 0.02359747f, -0.11590378f, 0.71622163f, -0.55362117f, 
    0.10046051f, -0.80750626f, -0.04489411f, -0.04522773f, -0.03870480f, -0.16866016f, -0.08531545f, 0.12593333f, 
    -0.04207541f, -0.02000682f, 0.13175364f, 0.12431082f, 0.11713750f, -0.02984028f, 0.06410179f, 0.09095009f, 
    -0.14907263f, -0.29393336f, 0.06384617f, 0.11818751f, -0.05349894f, 0.09084178f, 0.11371539f, -0.09292586f, 
    0.05461198f, 0.07595760f, 0.12955055f, 0.14878584f, 0.12469304f, -0.26602054f, 0.35594407f, 0.16532463f, 
    0.03975453f, 0.31785408f, 0.16969422f, -0.27444893f, -0.07994519f, -0.15150575f, 0.06182274f, -0.65471900f, 
    -0.01225898f, -0.01678433f, 0.38139573f, -0.15013167f, -0.61849630f, 0.07373920f, 0.09946591f, -0.12972054f, 
    0.13237336f, 0.22971378f, -0.03900151f, 0.04730194f, 0.13775055f, -0.14163010f, -0.09530804f, -0.17063814f, 
    -0.14974007f, -0.11955209f, -0.08508202f, -0.16066357f, -1.02094221f, 0.22396405f, -0.13957459f, 0.27533072f, 
    -0.04212048f, 0.07246777f, -0.15021639f, 0.02365362f, -0.09310658f, -0.04116596f, -0.07870447f, 0.28202328f, 
    0.13714251f, -0.09080193f, 0.41043445f, 0.12625478f, -0.22952542f, 0.01945612f, -0.13106686f, -0.17732912f, 
    -0.02950811f, -0.55236536f, -0.08288274f, 0.00748876f, -0.16604462f, -0.09758247f, 0.04605974f, 0.01863460f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.00328868f, 0.01634892f, -0.01946145f, 0.03131288f, -0.15003212f, 0.12695152f, -0.11472240f, -0.29687208f, 
    -0.08415524f, 0.17002596f, 0.12646776f, -0.07210174f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
