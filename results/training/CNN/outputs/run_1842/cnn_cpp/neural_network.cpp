#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.53838855f, 0.67993009f, -0.33237219f, 0.58567446f, 1.04617989f, 0.40043834f, -0.31629655f, -0.16085532f, 
    0.06570601f, -1.28473818f, 0.81517798f, 0.12087607f, -0.50629526f, 0.42396912f, 0.00425985f, 0.35423189f, 
    0.16310540f, 0.11997422f, 0.27950653f, -0.84224743f, 0.64097899f, -0.85582668f, -0.72163427f, -0.29934794f, 
    -0.16174705f, 0.42921016f, -0.50382954f, -0.32521445f, 0.25601536f, 0.03052243f, -0.43973681f, -0.19704239f, 
    -0.94610506f, 0.95734006f, 0.39359096f, 0.60143203f, -0.13024259f, -0.70060337f, -0.44866961f, -0.62053055f, 
    -0.26901871f, -0.30567566f, 0.05476226f, -0.58013707f, -0.04648539f, 0.43863922f, -0.07695779f, -0.05649405f, 
    0.11904030f, 0.24118748f, 0.50371701f, -0.11732443f, 0.45678186f, 0.52586967f, 0.69475675f, 1.23325872f, 
    -0.97591120f, -0.36347157f, -0.19891228f, 0.03603540f, -0.20362054f, 0.38177958f, -0.14771140f, -0.98396307f, 
    1.12437284f, -1.10426509f, 0.47111103f, -0.02594746f, 0.39740729f, 0.12021203f, 0.15685011f, 0.16896565f, 
    0.51419461f, 0.39238530f, 0.65044457f, -0.03280260f, 0.88794708f, 0.49388331f, 0.07129436f, 0.06371580f, 
    0.59038794f, -0.15839583f, -0.35248512f, 0.45291880f, 1.28193390f, -0.94567740f, -0.79053897f, -0.15479593f, 
    -0.38884100f, 0.55935502f, -1.20516646f, -0.64140821f, -0.07614579f, 0.06289776f, 0.36997309f, -0.81329376f, 
    0.00500033f, 0.14195588f, -0.30693451f, -0.64067239f, -0.11921931f, 0.04707730f, 0.38390821f, -0.42518789f, 
    -0.43900874f, -0.66017634f, -0.46949601f, -0.32044792f, 0.09062473f, 0.42224273f, 1.24088776f, -0.74660689f, 
    0.40157434f, 0.00081813f, 0.19655852f, -0.39740425f, -0.39257473f, 0.96561927f, 0.30617985f, 0.65373206f, 
    0.07106500f, -0.65168339f, 0.98392969f, 0.00431892f, 0.22321486f, -0.17481662f, 1.21926403f, -1.29563105f, 
    -0.76540732f, 0.52237380f, 0.16822438f, -0.19222702f, -0.34194726f, -0.30218789f, -0.44907323f, 0.93979669f, 
    0.56803232f, -0.27342758f, -0.64311188f, 0.30842030f, -0.55023503f, 0.13985385f, 0.31133419f, 0.30384725f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.29530367f, 0.07041334f, 0.64549208f, 0.05488296f, 0.61446524f, 0.82019138f, 0.07758978f, -0.05997819f, 
    -0.22846539f, 0.47924915f, -0.30105287f, -0.16220334f, 0.31367174f, 0.68783492f, 0.49915266f, 0.62096310f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.06400632f, 0.03342609f, -0.05229733f, 0.13431178f, 0.16595393f, -0.05266648f, -0.02129874f, 0.05127196f, 
    0.06721400f, -0.31465915f, 0.37620443f, -0.12602115f, -0.08073699f, -0.27840775f, 0.22875597f, 0.11949740f, 
    -0.01474060f, -0.27522251f, -0.41703272f, 0.33704519f, -0.16353437f, -0.25187129f, 0.13575587f, 0.05042356f, 
    -0.13304913f, -0.14078099f, -0.06790225f, -0.10436992f, -0.05247575f, -0.17761411f, 0.13579749f, 0.02175094f, 
    -0.21392918f, -0.24104673f, -0.51322526f, -0.23335017f, 0.02358176f, -0.02655303f, 0.19559775f, 0.08962520f, 
    -0.14993382f, -0.27714133f, 0.11513685f, -0.01680021f, 0.13209748f, 0.02029772f, -0.13704351f, -0.10036708f, 
    -0.17357698f, -0.02671433f, 0.05333961f, -0.00894243f, -0.26866457f, -0.48973703f, 0.05110367f, 0.30591214f, 
    0.44288558f, 0.13330582f, -0.09635689f, -0.01650498f, 0.10299062f, 0.09972020f, 0.04022545f, 0.02618967f, 
    0.55595815f, 0.83587182f, 0.07458762f, 0.01216881f, 0.10780630f, 0.23970668f, 0.19931614f, 0.14274096f, 
    0.31383705f, -0.07159831f, 0.05267433f, 0.14046462f, 0.14274192f, 0.11566667f, 0.14318909f, -0.07092967f, 
    -0.38439515f, 0.10539967f, 0.28722259f, -0.00037677f, -0.14010808f, 0.11371516f, 0.27020952f, 0.01916411f, 
    0.10527407f, -0.11257265f, -0.26040733f, 0.38864574f, -0.80592763f, 0.19799903f, 0.05556130f, 0.12118071f, 
    0.26607546f, -0.01343309f, 0.26177898f, 0.20452689f, 0.26248628f, 0.19699281f, 0.11372817f, -0.01187200f, 
    0.26433656f, 0.04186637f, 0.07980713f, 0.29632315f, 0.00570262f, 0.63536108f, 0.03908807f, 0.00532583f, 
    0.00422974f, -0.03945998f, 0.08829799f, -0.18404371f, -0.11463278f, 0.11989088f, 0.32205290f, 0.12013602f, 
    -0.00608909f, -0.24631816f, 0.04469036f, 0.01411393f, -0.04511220f, -0.21276215f, 0.16172531f, -0.10208930f, 
    0.47947896f, -0.07942653f, -0.17493625f, 0.44157070f, 0.18364905f, 0.01575765f, 0.28947324f, 0.22086996f, 
    0.33771861f, 0.39077657f, -0.12033753f, 0.05428635f, -0.12974446f, -0.13758932f, 0.09572483f, 0.01535910f, 
    0.07202621f, 0.06321633f, 0.01445755f, -0.08023015f, 0.01062277f, -0.02175588f, -0.03882958f, 0.04681727f, 
    0.00999167f, 0.07392307f, 0.05597734f, -0.03542003f, 0.01023875f, -0.03526371f, -0.08627526f, -0.05409206f, 
    -0.01556787f, 0.01957496f, -0.04858955f, 0.06365479f, -0.06194714f, -0.08586442f, -0.05850615f, -0.01384261f, 
    0.04625662f, -0.01788813f, -0.01816113f, 0.04389534f, 0.00863020f, -0.07438333f, -0.05385784f, 0.00858334f, 
    -0.02139020f, 0.02825938f, -0.08915114f, -0.00969654f, -0.04010042f, 0.04781268f, 0.00075561f, -0.04129408f, 
    -0.01017043f, -0.06775416f, -0.08192986f, -0.03858411f, -0.05843042f, -0.08723370f, -0.01535137f, 0.05685148f, 
    -0.05764745f, 0.01731885f, 0.05788506f, 0.02593908f, -0.04289422f, 0.05135082f, 0.03424286f, -0.07434397f, 
    -0.06295759f, 0.05738349f, -0.07819219f, -0.06678908f, -0.05421278f, -0.07155725f, -0.07890940f, 0.01596524f, 
    -0.05271919f, 0.06963286f, -0.01521297f, -0.01975565f, -0.00092367f, -0.08239746f, -0.03631994f, 0.05848217f, 
    -0.05313584f, -0.03971049f, -0.03791719f, -0.04350813f, 0.01110969f, 0.00316711f, 0.03136269f, -0.07849334f, 
    0.01384386f, -0.00208656f, -0.09072454f, -0.07662740f, -0.07728509f, 0.03283530f, 0.06399434f, -0.07913146f, 
    -0.04861981f, -0.05100199f, 0.02694784f, -0.06239067f, 0.07123008f, -0.06943264f, -0.06672835f, 0.03591205f, 
    -0.06586557f, 0.03709688f, 0.06776091f, 0.07564726f, 0.03243708f, -0.03036918f, -0.04503354f, 0.05018301f, 
    -0.06958254f, 0.04355721f, -0.08139743f, -0.06957086f, 0.00239746f, 0.05098958f, 0.01806339f, -0.08696014f, 
    0.01857691f, -0.04749383f, -0.00400792f, -0.02957886f, 0.04536658f, -0.03947169f, 0.01926734f, 0.03957018f, 
    0.00194994f, -0.02410845f, 0.00405977f, -0.01656505f, 0.00461962f, -0.08428929f, 0.01939164f, 0.04100544f, 
    -0.00879097f, -0.05578897f, -0.04542218f, 0.00762408f, 0.05543073f, 0.00101509f, -0.09217302f, -0.06703290f, 
    -0.03606867f, -0.06468916f, 0.02939347f, -0.08028756f, -0.08181008f, 0.05549981f, -0.02652605f, 0.04455178f, 
    -0.39062721f, -0.31433699f, -0.23781337f, -0.17652082f, -0.04107000f, 0.01260860f, -0.10233224f, -0.12088249f, 
    0.07742108f, 0.18832666f, -0.37068108f, -0.68693119f, -0.08225694f, 0.11706851f, -0.12332330f, -0.05893790f, 
    0.09416611f, 0.10634085f, -0.22125970f, 0.23686416f, 0.45018312f, -0.19137721f, 0.34915745f, -0.06813072f, 
    0.00105026f, 0.26438853f, 0.06873766f, -0.39055011f, -0.35669568f, 0.00327619f, -0.04545345f, 0.08850083f, 
    -0.24252899f, 0.22974753f, 0.02536339f, 0.24824204f, 0.06368627f, 0.03621418f, 0.44537190f, 0.05309808f, 
    -0.20994125f, 0.02517952f, 0.24441464f, -0.02149121f, -0.07953078f, 0.18195345f, 0.03877296f, -0.05275518f, 
    -0.09174575f, -0.00169524f, 0.30844361f, 0.16254491f, 0.16955696f, 0.33517590f, -0.60905939f, -0.11440612f, 
    0.24410066f, 0.12894161f, -0.11365511f, 0.00435797f, -0.10207331f, -0.10809154f, 0.07773969f, -0.88174641f, 
    0.25037903f, 0.39012641f, -0.01028565f, 0.34972051f, 0.16610748f, -0.14015092f, 0.19673237f, -0.05021327f, 
    -0.11586957f, -0.05628148f, -0.19365034f, -0.09807884f, -0.22371234f, -0.12245557f, 0.21829015f, 0.22868422f, 
    -0.03641650f, -0.07432196f, 0.53489417f, 0.52024668f, -0.02299877f, -0.00771483f, -0.13948040f, 0.12454893f, 
    0.47034064f, 0.28375092f, -0.05188932f, -0.19234227f, 0.37172860f, -0.19909517f, -0.23836949f, -0.49134749f, 
    0.18522343f, 0.03704339f, 0.05919338f, 0.00737097f, -0.01299020f, 0.36549127f, -0.07032883f, 0.01903724f, 
    -0.31312692f, 0.30049726f, 0.01017605f, 0.19132458f, -0.68003398f, 0.24773587f, -0.16287775f, 0.10624789f, 
    0.06473640f, -0.17526546f, 0.03629259f, 0.28299418f, 0.10883323f, -0.72568566f, 0.04741380f, -0.16008687f, 
    -0.00993040f, 0.01761065f, -0.07779025f, 0.02921751f, 0.27368432f, 0.01903163f, 0.59080172f, -0.14631242f, 
    0.40545079f, -0.12383401f, -0.14708841f, 0.24497204f, 0.07240464f, 0.19884913f, 0.02920816f, -0.45851162f, 
    0.01320766f, 0.48334539f, 0.05396797f, 0.18402912f, 0.15583795f, 0.00209223f, -0.01062088f, 0.15212844f, 
    0.15582179f, 0.11986185f, -0.10797039f, 0.07556432f, -0.23667927f, -0.12905471f, -0.16150260f, -0.23512347f, 
    -0.00268458f, 0.08235420f, 0.08475662f, -0.10379481f, 0.10188703f, -0.17587650f, 0.14266053f, -0.11444245f, 
    0.04338171f, 0.00049136f, -0.18731241f, -0.16471389f, 0.17666985f, 0.01433477f, 0.08480323f, -0.02299097f, 
    -0.06113347f, -0.08062645f, -0.10784965f, 0.08454397f, 0.03376020f, 0.19182093f, 0.21229781f, -0.00580911f, 
    0.04947461f, 0.21105136f, -0.03506162f, 0.27858543f, -0.17070323f, -0.12789991f, -0.36897182f, -0.20803112f, 
    -0.01246622f, 0.15384883f, 0.11493496f, -0.03379767f, -0.06752208f, 0.17364009f, 0.04177734f, 0.05569465f, 
    0.08271399f, 0.11283546f, 0.15740207f, -0.15892202f, 0.01902786f, -0.23519672f, -0.10609307f, -0.00849386f, 
    0.52585989f, 0.07149149f, -0.23177928f, 0.17242867f, -0.05333383f, -0.01071135f, 0.29873595f, 0.21969718f, 
    -0.19827789f, -1.24404347f, -0.04066385f, -0.13366351f, 0.22302176f, 0.11298177f, 0.02129793f, -0.25093132f, 
    0.23534018f, 0.27389681f, 0.03226199f, -0.01813187f, 0.07168736f, 0.01611842f, -0.20068231f, 0.10524800f, 
    -0.05414811f, -0.16462888f, 0.15412287f, 0.53375089f, -0.19245990f, 0.15455818f, -0.20544735f, -0.10433614f, 
    0.07679237f, -0.25990283f, 0.74910641f, 0.26732904f, 0.04202954f, 0.06522526f, -0.01927518f, 0.00906580f, 
    0.11123926f, 0.02889229f, 0.01777301f, 0.08424030f, -0.09782107f, 0.34985957f, 0.08702946f, 0.18687515f, 
    0.00269709f, -0.25769028f, -0.23743583f, 0.08568084f, 0.03093570f, -0.02464043f, 0.24313384f, -0.11155029f, 
    0.00365561f, -0.19593860f, -0.05754175f, 0.13978425f, 0.00580572f, 0.25366628f, 0.06452639f, 0.14046763f, 
    0.01427657f, -0.07953099f, -0.01801701f, 0.09152284f, 0.10147699f, 0.01014556f, -0.09795816f, -0.68450534f, 
    0.08301836f, -0.00339956f, 0.07843249f, 0.36094603f, -0.11182578f, -0.30947611f, -0.16614163f, 0.32723764f, 
    0.16370077f, 0.08100850f, 0.02713137f, -0.00716064f, 0.14775796f, -0.06295162f, 0.02089502f, 0.04912637f, 
    -0.11492543f, -0.07434896f, 0.03747100f, -0.03483676f, -0.11646419f, -0.12150717f, -0.03584534f, -0.03947082f, 
    0.02924223f, -0.07325015f, -0.02654660f, -0.10179546f, 0.03124591f, -0.00685828f, 0.01395159f, -0.04676464f, 
    -0.07871751f, -0.07451241f, -0.01523652f, -0.09453080f, 0.02120467f, -0.05946443f, 0.04441624f, -0.00547966f, 
    -0.09435640f, 0.00290474f, 0.00503097f, -0.11289324f, -0.07341665f, -0.00269864f, -0.03062777f, -0.04251637f, 
    0.05174442f, -0.01010847f, -0.01721745f, 0.02444272f, -0.03491003f, -0.03375237f, -0.06853182f, -0.05845207f, 
    -0.10425521f, 0.03505921f, -0.04658551f, -0.11029258f, -0.03670545f, -0.07459860f, -0.00398614f, -0.12298172f, 
    0.04395605f, -0.02691856f, -0.02811019f, -0.09199316f, -0.02700080f, -0.08061898f, -0.08513770f, -0.03035721f, 
    -0.10342048f, -0.00743296f, 0.06783057f, -0.02604408f, -0.10191800f, -0.01512689f, -0.07373935f, -0.02471855f, 
    -0.11084715f, -0.11968096f, 0.06411482f, 0.05735480f, -0.03186945f, 0.04130369f, 0.05019477f, -0.07179949f, 
    0.07841624f, 0.00031596f, -0.04770451f, -0.06927340f, -0.03324866f, 0.00379151f, 0.05760761f, 0.06555797f, 
    -0.03344177f, -0.10145824f, -0.11663298f, -0.03388071f, -0.08272520f, 0.02164670f, -0.00749041f, -0.05659107f, 
    0.03123455f, -0.00707076f, -0.03395377f, -0.00940286f, -0.03222483f, -0.04577244f, -0.01863695f, -0.05919801f, 
    -0.00365559f, -0.07738933f, 0.00224004f, 0.01001974f, -0.09163218f, 0.05489025f, 0.00186532f, 0.01197379f, 
    -0.01867146f, -0.02791445f, -0.01693841f, -0.00100878f, -0.02236693f, -0.06697986f, -0.03400054f, -0.05082071f, 
    -0.08854657f, -0.07055632f, -0.09677105f, 0.04246422f, -0.07312673f, -0.00373849f, -0.02945993f, 0.00015053f, 
    -0.00965488f, -0.10571356f, -0.08692379f, -0.06027268f, 0.01455584f, 0.01459489f, -0.02713097f, -0.10854698f, 
    0.02264007f, -0.10774095f, -0.07322643f, 0.01661419f, -0.09731005f, -0.09850729f, 0.03306373f, -0.02283029f, 
    0.03510493f, -0.09317130f, 0.02814380f, -0.00734756f, -0.03820569f, -0.02010982f, -0.05281466f, 0.04291561f, 
    -0.03434706f, -0.37534773f, 0.07251896f, -0.10521001f, -0.25452915f, -0.01051150f, -0.00740686f, 0.03000172f, 
    -0.01602927f, -0.85232055f, -0.41736165f, 0.16670027f, 0.00753330f, 0.07514053f, 0.01703712f, -0.06111947f, 
    0.18988611f, 0.06265650f, -0.08912870f, 0.21936786f, -0.02839042f, -0.20659313f, 0.04673957f, -0.06742272f, 
    -0.11175740f, 0.11460011f, -0.10560851f, 0.21234685f, 0.27602389f, 0.45562100f, -0.01915856f, 0.16602662f, 
    0.06360798f, 0.11647333f, 0.13186093f, 0.12318803f, 0.12718080f, 0.12101997f, 0.22788753f, 0.02885735f, 
    0.09512684f, 0.14549334f, 0.03655021f, -0.11766172f, 0.14430982f, 0.51794964f, -0.29628673f, -0.10043493f, 
    0.08724488f, 0.13803039f, -0.01794512f, 0.06910847f, 0.09200019f, -0.00997470f, -0.46679160f, -0.64327615f, 
    -0.63210541f, 0.14932303f, -0.08594751f, -0.05045607f, -0.12503915f, -0.06101019f, -0.11502507f, -0.62159544f, 
    -0.10457952f, -0.24731144f, -0.10446705f, -0.18148775f, 0.35683912f, -0.10252990f, 0.01907619f, -0.13730127f, 
    -0.05027787f, -1.08966672f, -0.94485199f, -0.13335897f, 0.07748163f, 0.07893272f, 0.07071318f, -0.15465884f, 
    0.13455589f, 0.00715202f, 0.02741936f, -0.15140271f, -0.05264238f, -0.10364420f, -0.01044073f, -0.06200685f, 
    0.09876111f, 0.14687456f, 0.64195240f, 0.22935800f, 0.33122221f, -0.18515754f, -0.11022563f, 0.05596038f, 
    0.06964033f, 0.09062010f, -0.11902405f, -0.13217023f, 0.18743521f, -0.04472383f, -0.04374040f, -0.00218575f, 
    -0.00299707f, 0.19924162f, 0.02394159f, 0.05285255f, 0.32984349f, -0.09665932f, -0.43189928f, 0.06868991f, 
    -0.02657154f, -0.31451494f, 0.02296787f, -0.03540273f, -0.04248992f, 0.04601502f, -0.37495986f, 0.27150166f, 
    -0.08779064f, 0.05568522f, 0.24850374f, -0.08630918f, -0.01388686f, 0.09084959f, 0.47156030f, -0.13078499f, 
    0.06197879f, 0.06522340f, -0.05964107f, 0.12499227f, 0.03969369f, -0.06600577f, -0.08348712f, -0.24859308f, 
    -0.72686511f, -0.52163506f, -0.03764684f, -0.12452830f, -0.35777864f, 0.03200777f, 0.22763762f, 0.21786979f, 
    0.13144217f, 0.14907745f, -0.01403539f, 0.20450258f, 0.01223802f, 0.13750200f, -0.17742601f, -0.17763458f, 
    -0.47163081f, 0.13296793f, 0.07052330f, 0.39910889f, 0.11018679f, 0.18987897f, -0.13603838f, 0.27593917f, 
    0.29391956f, 0.24018683f, 0.27607116f, 0.12074950f, -0.08723668f, 0.05134945f, 0.08714896f, 0.16919892f, 
    -0.00606813f, -0.13789560f, 0.01977737f, -0.15141885f, 0.15411633f, -0.23637736f, -0.37476668f, 0.06559813f, 
    0.05959867f, -0.06329697f, 0.38455364f, 0.51402599f, 0.01363972f, 0.05616078f, -0.07248465f, -0.19210795f, 
    0.05861114f, -0.15897322f, 0.18649921f, 0.02211058f, 0.23670170f, 0.13204224f, 0.08944304f, 0.24245945f, 
    0.23256636f, -0.01163217f, 0.01296449f, -0.00776505f, 0.11531752f, 0.16119313f, 0.06630320f, -0.10851090f, 
    0.14181723f, -0.00076139f, 0.25741330f, -0.05373494f, -0.10834369f, 0.00741947f, -0.04175192f, -0.46496236f, 
    0.24870381f, 0.03391008f, 0.27184168f, 0.12440716f, 0.08281616f, -0.08309116f, 0.29648480f, -0.13375561f, 
    -0.09383485f, 0.19273241f, 0.30167800f, -0.13506830f, -0.08365446f, -0.20680845f, 0.02755907f, -0.22552733f, 
    0.18755391f, 0.17429917f, -0.03700307f, -0.26762301f, 0.11348338f, 0.06646550f, -0.01065730f, 0.08129997f, 
    0.00745588f, 0.24004391f, -0.45137161f, 0.08496699f, 0.46260217f, 0.08602311f, -0.22504653f, -0.02846591f, 
    0.03435903f, 0.13379821f, 0.08638487f, -0.05686964f, -0.21804738f, -0.19677837f, -0.11157019f, 0.05133576f, 
    -0.22841683f, 0.11232009f, -0.17885382f, -0.29757512f, -0.09094620f, -0.08465485f, 0.29258919f, -0.03187144f, 
    -0.14949380f, 0.10543222f, -0.10293900f, 0.04667340f, -0.03063931f, -0.07627483f, 0.16627555f, 0.16765691f, 
    -0.12451009f, -0.10930359f, 0.03638557f, -0.34930584f, -0.14983054f, 0.09663051f, 0.22966349f, -0.30084917f, 
    -0.17733854f, 0.07970242f, 0.21798365f, -0.13735671f, -0.23956744f, -0.18447129f, -0.31759965f, 0.03285263f, 
    -0.04039381f, 0.22724250f, -0.12984850f, -0.02682929f, 0.02230136f, 0.09190537f, -0.10927119f, 0.28919068f, 
    0.10774241f, -0.68582463f, -0.12608691f, 0.13337959f, 0.12506728f, 0.09853910f, 0.00883780f, -0.01133716f, 
    0.07643000f, 0.01654049f, -0.05556575f, 0.66538000f, 0.02373764f, -0.22678629f, 0.25603735f, -0.06886455f, 
    0.11671259f, 0.12471920f, -0.38043964f, 0.16202751f, -0.06559943f, 0.01509515f, -0.04984769f, 0.04938835f, 
    0.13213418f, -0.08624908f, 0.16582759f, 0.27504015f, 0.22392933f, 0.08251690f, -0.24885057f, -0.05512576f, 
    -0.18352605f, -0.22581454f, 0.11247686f, 0.03704271f, 0.07793081f, 0.01348164f, 0.07412989f, -0.03782341f, 
    0.11200049f, 0.10908894f, 0.12726822f, -0.00821228f, -0.04044345f, 0.05207102f, 0.21616635f, -0.51325148f, 
    0.12652621f, 0.03465216f, -0.12888502f, -0.07975538f, 0.29537222f, -0.18819839f, -0.02276300f, 0.13388871f, 
    -0.28482351f, -0.06830022f, -0.07086542f, -0.01366069f, 0.14276239f, 0.06164701f, -0.14261267f, -0.71483952f, 
    -0.46446508f, -0.61369175f, -0.19551925f, 0.09604095f, -0.03127610f, 0.13796911f, 0.09119060f, 0.01804898f, 
    -0.00235202f, -0.53955936f, -0.12005374f, 0.09984338f, -0.34360018f, 0.03907203f, -0.01620531f, 0.07304323f, 
    0.06288970f, -0.00976091f, 0.50794464f, -0.41683686f, -0.02264966f, 0.01496914f, -0.10568839f, -0.13222909f, 
    0.05490913f, 0.18555570f, 0.46966195f, 0.15820847f, -0.14541250f, 0.17044114f, -0.01899438f, 0.46346843f, 
    -0.03213346f, -0.11558317f, -0.03401235f, 0.32314229f, 0.24534667f, -0.06005914f, -0.03589797f, 0.19098525f, 
    0.22782995f, -0.08442174f, 0.00134136f, -0.31612724f, -0.04500867f, -0.35827559f, 0.12595642f, 0.08631903f, 
    0.04522094f, -0.28520912f, -0.02580001f, -0.11568204f, 0.08020791f, 0.14409754f, 0.04395321f, -0.12266558f, 
    0.00645086f, 0.01155615f, -0.32935953f, 0.11882694f, 0.21096070f, 0.21599096f, 0.15800627f, 0.09006230f, 
    -0.09967434f, -0.00289404f, -0.06831295f, -0.00819303f, 0.11950635f, -0.02109075f, -0.07000837f, -0.27522248f, 
    -0.05451028f, -0.12108817f, 0.06345598f, -0.15213142f, 0.14062642f, -0.10260174f, 0.16331255f, -0.10858534f, 
    -0.27023977f, -0.21527924f, -0.32197958f, -0.11603772f, 0.12763964f, -0.06090686f, 0.11818438f, -0.24178241f, 
    0.14131601f, 0.10089325f, -0.71433198f, -0.65024900f, 0.03928669f, 0.10572310f, -0.10147668f, 0.14471729f, 
    -0.06951545f, -0.02299253f, 0.42639700f, -0.06684624f, 0.16389470f, -0.21104066f, -0.07471432f, 0.03073313f, 
    0.25819686f, -0.02689788f, 0.01929428f, -0.44556767f, -0.02517310f, 0.18960436f, 0.00855491f, -0.07379513f, 
    -0.08703195f, -0.04309674f, 0.21264277f, -0.18402173f, 0.18171005f, -0.59725535f, -0.30133861f, -0.17626067f, 
    0.01674401f, 0.05509221f, 0.17301592f, 0.08603385f, 0.08986692f, 0.13516285f, 0.16595836f, 0.09573996f, 
    0.07945612f, 0.22895171f, 0.17092711f, 0.16405451f, 0.18648027f, -0.06611041f, -0.01945342f, -0.14403164f, 
    0.05257594f, -0.11488953f, 0.13546486f, -0.33328184f, -0.04395138f, 0.07202186f, 0.00971965f, -0.66828728f, 
    -0.98089832f, -0.93628043f, 0.05927001f, 0.31135029f, -0.08135429f, 0.11540473f, -0.13597779f, -0.25074768f, 
    0.29223263f, 0.04818870f, 0.05053593f, -0.30700338f, 0.01404144f, -0.08693807f, -0.08328681f, -0.06811310f, 
    0.01185350f, -0.33141392f, 0.35311785f, -0.37864906f, 0.00112963f, 0.05962209f, 0.30080262f, 0.22155510f, 
    0.12316317f, 0.00494364f, 0.33283749f, -0.46621004f, -0.68687505f, -0.01200319f, 0.12008376f, -0.03255827f, 
    -0.01024347f, -0.12911145f, -0.10197634f, 0.24738276f, 0.33637622f, -0.44576842f, -0.05582500f, -0.13893048f, 
    0.04412329f, 0.09370566f, 0.02956045f, 0.15856738f, 0.43068641f, 0.25524548f, -0.00833513f, 0.00786885f, 
    -0.04478655f, -0.05309802f, 0.00062465f, 0.05454794f, 0.19327414f, 0.32263684f, 0.25307384f, 0.19093302f, 
    -0.08964455f, 0.08841705f, -0.11428525f, -0.00890543f, 0.02698340f, -0.05292450f, -0.56505680f, -0.07002752f, 
    -0.36821607f, -0.15878828f, 0.29774407f, -0.08274121f, -0.03542155f, -0.11615800f, 0.18385008f, 0.23522931f, 
    0.30364317f, 0.03117723f, -0.11563683f, 0.04616321f, -0.06750184f, 0.04147380f, 0.12560023f, -0.07011072f, 
    -0.17629975f, -0.06603810f, -0.02442607f, 0.03227516f, 0.19441757f, -0.28737456f, -0.00170455f, 0.07569927f, 
    0.03280846f, 0.24369515f, -0.27834785f, 0.32612920f, 0.22588879f, 0.05201672f, 0.02071164f, -0.15069108f, 
    0.13539459f, 0.13213529f, -0.00849967f, 0.29406211f, 0.25795597f, 0.02786422f, 0.17405263f, 0.16745540f, 
    -0.15524837f, 0.10522594f, -0.34641686f, 0.03624405f, 0.08575185f, 0.21876299f, -0.13861410f, 0.10808216f, 
    -0.07261580f, -0.14301223f, 0.07543219f, -0.20290303f, 0.04122293f, 0.06348487f, 0.35041311f, 0.07445434f, 
    -0.10873390f, 0.08842416f, 0.05933558f, -0.02529848f, -0.07789978f, -0.12088706f, -0.11062102f, 0.05516154f, 
    -0.05591325f, 0.02618148f, 0.11428943f, 0.11872830f, 0.02899795f, 0.27784842f, 0.48356199f, -0.40331435f, 
    -0.14997615f, 0.00667332f, 0.29735872f, 0.14977744f, 0.16078940f, 0.06074077f, 0.08851831f, -0.21382226f, 
    0.29986393f, 0.59903198f, 0.11668848f, 0.24080265f, -0.13577677f, 0.00078934f, 0.07645711f, 0.26033074f, 
    0.08167318f, -0.42509654f, -0.31043622f, 0.27444896f, 0.15464374f, 0.11421017f, -0.00296435f, 0.06842395f, 
    -0.01047664f, 0.01824808f, 0.34533870f, 0.34704882f, -0.08981574f, 0.25503975f, -0.18746743f, 0.04667657f, 
    -0.05292426f, -0.03960476f, -0.64946306f, -0.06234734f, 0.18830808f, -0.07589967f, -0.16628315f, -0.09365014f, 
    0.03230860f, -0.05409602f, 0.07685718f, -0.14930072f, -0.09874839f, 0.31494400f, 0.27804548f, 0.16366164f, 
    0.23582433f, 0.01847005f, -0.02577895f, -0.21680464f, -0.18552750f, -0.14293835f, -0.11747036f, 0.05842765f, 
    0.01586937f, -0.07732870f, 0.13801478f, -0.13803372f, -0.10455161f, -0.50304276f, -0.38631356f, -0.57599866f, 
    0.03522308f, 0.00231808f, -0.00127721f, 0.02591109f, -0.20176218f, -0.19478971f, 0.17937569f, 0.13566467f, 
    0.20901330f, 0.15184988f, -0.12580058f, -0.03922200f, -0.27635852f, 0.10927973f, 0.06093368f, -0.09069586f, 
    -0.26877394f, -0.18937165f, 0.08798417f, -0.07157471f, 0.16272816f, -0.00526238f, -0.01371165f, 0.29223514f, 
    -0.12789510f, 0.13092811f, -0.22285268f, 0.28857574f, 0.10754893f, 0.28061119f, -0.06418450f, 0.02467462f, 
    -0.10774350f, -0.11249730f, 0.14156230f, 0.14086105f, -0.11711992f, -0.14553730f, -0.27378845f, 0.17546423f, 
    0.24848740f, 0.10722013f, 0.15868266f, -0.23118430f, 0.14510904f, -0.01036865f, 0.34433708f, 0.01436746f, 
    -0.04058531f, -0.06475133f, 0.15717296f, -0.32158968f, -0.26835403f, -0.45943302f, -0.06560495f, -0.14908071f, 
    -0.38785595f, 0.17979844f, 0.03708486f, 0.26446486f, 0.02740495f, 0.01616896f, 0.12112425f, -0.02266665f, 
    0.11531379f, -0.14948033f, -0.28018546f, 0.25858957f, 0.12411662f, -0.02944624f, -0.00528869f, 0.06616863f, 
    0.00554316f, 0.09768383f, 0.08680533f, -0.05224759f, 0.00995283f, 0.22817543f, 0.21374613f, 0.13157406f, 
    0.19054754f, -0.02484227f, 0.09953304f, -0.06201722f, -0.16084485f, 0.35184953f, -0.22158186f, 0.12136704f, 
    0.46882513f, 0.36177540f, 0.24743937f, 0.00430440f, -0.17889632f, -0.14800645f, 0.23620872f, 0.18199384f, 
    -0.12826006f, 0.00593156f, -0.09880957f, -0.00319243f, -0.04518759f, 0.04166779f, 0.12723108f, 0.27310872f, 
    -0.03787140f, -0.15058313f, 0.23112839f, -0.08598405f, 0.04245209f, -0.18840413f, 0.00137758f, 0.29729632f, 
    0.16597952f, 0.14605738f, -0.23381372f, -0.23804456f, 0.18698925f, -0.13038783f, 0.21438521f, -0.03140799f, 
    -0.07079824f, -0.17510036f, 0.00768484f, -0.14125122f, 0.10092978f, 0.07011279f, -0.03424468f, 0.00925891f, 
    -0.06246940f, -0.03522087f, 0.06882126f, -0.14109305f, -0.14149740f, 0.04505889f, -0.07493870f, -0.11236665f, 
    0.05070312f, 0.02508518f, 0.02813177f, 0.08390056f, -0.13972393f, -0.11186749f, -0.09097660f, 0.13470447f, 
    -0.19535786f, 0.23197047f, -0.05453080f, -0.13668017f, -0.18293531f, 0.08414274f, -0.16166158f, 0.28926423f, 
    0.47234085f, -0.01723918f, -0.06299166f, 0.17269143f, -0.20294011f, 0.18778042f, 0.00301817f, 0.12690109f, 
    -0.01676301f, 0.13540006f, -0.05860284f, 0.03655297f, -0.09065494f, -0.10936463f, 0.18463102f, 0.07754848f, 
    -0.02397876f, -0.03262110f, 0.03706106f, -0.02241925f, -0.04769470f, 0.06681632f, -0.06106716f, 0.04052865f, 
    -0.06593290f, 0.02433655f, -0.03082223f, 0.02525373f, 0.06610613f, -0.07309420f, 0.06221655f, 0.06085946f, 
    0.01945924f, -0.04500540f, 0.02578278f, -0.03968362f, 0.06050666f, 0.06814937f, -0.00993053f, -0.07808017f, 
    -0.05724204f, -0.03560792f, -0.03065428f, -0.08673436f, -0.04664305f, -0.08521651f, 0.00622493f, -0.07608800f, 
    -0.02102029f, -0.07887381f, -0.07455241f, -0.04737461f, -0.07364358f, -0.07752854f, -0.05056885f, 0.06970842f, 
    -0.03418639f, -0.02331206f, 0.02973105f, 0.02742287f, 0.05778116f, -0.06357262f, -0.01696809f, -0.01772486f, 
    0.02759285f, -0.01097166f, 0.00145423f, 0.05023922f, 0.02867326f, -0.01676994f, -0.01984489f, 0.05286270f, 
    0.05410583f, -0.02350817f, 0.06975672f, -0.09072737f, -0.00160623f, -0.08155264f, 0.00057255f, -0.05867847f, 
    0.05308236f, -0.07766727f, -0.05978798f, -0.09010933f, 0.02319943f, 0.02201775f, 0.06713802f, 0.03807203f, 
    -0.08698079f, 0.04163378f, 0.04901146f, 0.04766005f, -0.07493997f, -0.03289521f, 0.07228232f, -0.04787537f, 
    -0.07652891f, -0.04842592f, 0.03834724f, -0.04510681f, -0.05441716f, -0.08247627f, -0.06942929f, 0.04236779f, 
    -0.06495908f, -0.08548363f, 0.02604754f, -0.03544515f, 0.06959054f, -0.08858509f, -0.01081958f, 0.07647657f, 
    0.07268125f, -0.07067910f, 0.03709050f, 0.02783410f, -0.01435031f, 0.03121005f, 0.02604155f, 0.04571708f, 
    -0.01752822f, 0.07098734f, 0.00749395f, 0.01844413f, -0.05863098f, -0.05812176f, -0.01776649f, -0.04859250f, 
    0.02601933f, 0.03730260f, 0.05158749f, 0.06843946f, 0.05429975f, -0.00701022f, -0.03922713f, -0.04077520f, 
    0.00300952f, 0.05689759f, -0.07405411f, -0.02399042f, -0.00376853f, -0.04318102f, 0.06277471f, -0.05003785f, 
    -0.01475738f, -0.03670867f, 0.03503931f, -0.07822695f, -0.00107881f, -0.07548334f, 0.02363799f, 0.02304891f, 
    0.05282906f, 0.01918443f, 0.00863935f, 0.03799240f, -0.03784757f, -0.06030725f, -0.08568292f, -0.05259615f, 
    -0.37036845f, -0.10084704f, 0.00791335f, -0.04318672f, -0.14721419f, -0.05408646f, 0.04564010f, 0.03691129f, 
    0.16324419f, -0.98332936f, -0.40479401f, 0.05558504f, 0.03318759f, -0.17242038f, -0.26199719f, 0.11220299f, 
    0.00912901f, -0.03272995f, -0.10920999f, -0.36952272f, -0.62075627f, 0.00432620f, 0.00244228f, 0.09895434f, 
    0.12768139f, -0.08498436f, 0.07233515f, -0.08919627f, -0.11195170f, -0.13682139f, -0.00763038f, -0.05722317f, 
    -0.16166449f, -0.03719303f, 0.05483198f, -0.14073354f, -0.07285744f, -0.12604538f, -0.20723745f, 0.20789987f, 
    0.25724488f, 0.02643414f, 0.10987867f, 0.20278807f, 0.00475835f, 0.29423812f, 0.23632595f, -0.04194093f, 
    0.18804149f, 0.26481998f, 0.27109155f, 0.16735758f, 0.32435566f, 0.07698731f, 0.53704602f, -0.76505113f, 
    -0.42455024f, -0.04563624f, -0.25238663f, 0.23072031f, -0.13317169f, 0.06676579f, 0.17323484f, -0.72527057f, 
    0.12926871f, -0.47291553f, 0.06078662f, -0.39486444f, -0.09360883f, -0.01124771f, 0.07830313f, -0.05797353f, 
    0.21070635f, -0.06967339f, -0.10750833f, -0.13968942f, -0.26033768f, -0.12656699f, -0.00069304f, 0.10808253f, 
    -0.06745171f, -0.32412106f, -0.35782048f, 0.35614109f, -0.11089467f, -0.07116713f, 0.06899062f, 0.29058525f, 
    -0.00201401f, 0.01911177f, -0.19406408f, -0.02207547f, 0.43242431f, 0.00363017f, -0.07412396f, 0.14967671f, 
    -0.10333999f, 0.01854966f, -0.02115653f, -0.06842667f, 0.07328308f, -0.08532012f, -0.04923562f, -0.01397168f, 
    0.08625224f, -0.14619912f, 0.25014305f, -0.13315189f, 0.05100069f, -0.13991015f, -0.34075007f, -0.12292022f, 
    0.00409998f, -0.10666688f, 0.08511940f, 0.04293024f, 0.08063303f, 0.31042799f, -0.26954094f, 0.33518443f, 
    0.00762419f, 0.20289311f, 0.25256687f, 0.13762727f, -0.05940826f, 0.04531353f, 0.27965853f, 0.11017822f, 
    -0.30013028f, 0.08049665f, 0.16778061f, -0.01012828f, 0.12632348f, -0.13071151f, 0.00304601f, 0.37682775f, 
    -0.11601673f, -0.20711622f, 0.17238027f, 0.15343915f, 0.07954353f, 0.16310927f, 0.10455985f, 0.09884788f, 
    0.37568820f, 0.40070161f, 0.19616742f, -0.44824871f, -0.13018054f, -0.10899914f, 0.06366806f, 0.03561725f, 
    0.11068106f, 0.03009151f, 0.35469490f, 0.19273901f, -0.06971592f, -0.12088981f, -0.04760455f, 0.13859987f, 
    0.11991043f, 0.00226786f, 0.29627204f, 0.51787823f, 0.25026318f, 0.01152964f, 0.34797689f, 0.15134618f, 
    0.09505774f, -0.11004521f, -0.17556117f, 0.40597808f, 0.08210122f, 0.13622943f, -0.05777087f, -0.01697209f, 
    -0.13422063f, 0.10023905f, 0.04932787f, 0.17280707f, 0.10206369f, 0.29683205f, 0.33550370f, -0.01528570f, 
    -0.13933200f, 0.35940078f, 0.16385977f, 0.00555936f, -0.06410804f, -0.12885368f, -0.08997255f, 0.10171466f, 
    0.12100899f, 0.01142478f, -0.04411434f, 0.20651600f, 0.12803786f, 0.23319112f, 0.26528227f, -0.52300948f, 
    -0.76914561f, -0.33760351f, -0.03354312f, 0.04310703f, 0.03873723f, 0.02175712f, 0.06811297f, -0.31486687f, 
    -0.09331604f, -0.01040632f, -0.20615274f, 0.10130086f, -0.04242359f, -0.03346315f, 0.18903688f, -0.19536929f, 
    -0.00345606f, 0.16216469f, 0.29287824f, 0.19426318f, -0.15524019f, 0.02530132f, 0.12534611f, -0.12064423f, 
    0.16099408f, -0.75697434f, -0.09152469f, 0.01551430f, 0.03317703f, -0.08088835f, -0.29299080f, 0.00396870f, 
    -0.10363762f, -0.01490522f, -0.45164320f, 0.18598785f, 0.25936040f, -0.04763508f, -0.41365287f, -0.08674251f, 
    -0.05130398f, 0.06334037f, -0.01000581f, -0.04508906f, -0.01515325f, -0.02805044f, -0.18610634f, -0.29931927f, 
    0.21914890f, 0.23735818f, 0.03045463f, 0.13447413f, -0.53482270f, -0.40366036f, -0.06998222f, 0.30134904f, 
    0.08522332f, 0.01493466f, 0.00527647f, 0.16012079f, -0.01218530f, -0.38377252f, -0.58532202f, 0.03055770f, 
    -0.09405747f, -0.04301690f, -0.02538251f, 0.08796297f, -0.20150495f, -0.13489377f, -0.34273189f, -0.51896858f, 
    -0.41505882f, -0.05294147f, 0.08454549f, 0.28680253f, 0.17429020f, 0.06670751f, -0.23123051f, 0.18136129f, 
    -0.04063438f, -0.29377863f, 0.09161665f, 0.00058195f, 0.14620547f, 0.11305423f, -0.06497051f, 0.04406311f, 
    0.15987347f, -0.05606429f, 0.12994312f, -0.00889825f, -0.14137545f, -0.11064094f, -0.15433219f, -0.16584657f, 
    -0.24170448f, 0.68174756f, 0.19315717f, 0.42453042f, -0.17875920f, -0.08819401f, 0.16031678f, -0.00809877f, 
    0.13247110f, 0.08463871f, 0.03642697f, 0.03179026f, 0.15991405f, 0.08599028f, -0.00746520f, 0.10691636f, 
    0.01578459f, 0.08920466f, 0.17704321f, 0.21329063f, 0.26380965f, 0.27088192f, -0.00163524f, -0.04948574f, 
    -0.01154305f, 0.18551728f, 0.25073877f, 0.14930020f, -0.10424923f, 0.02028917f, -0.30988038f, -0.02239029f, 
    0.06946819f, 0.01460289f, -0.08632047f, -0.07414804f, -0.15188415f, -0.14787561f, -0.17120066f, -0.02536355f, 
    -0.15792501f, -0.22414577f, -0.29386681f, 0.04908172f, 0.20656848f, -0.04178777f, -0.48857167f, -0.01811389f, 
    0.25161535f, 0.05936962f, 0.15833902f, 0.12981002f, -0.09614385f, -0.06038293f, 0.26513028f, 0.34976429f, 
    -0.41094124f, 0.23840898f, -0.06022269f, 0.07141158f, 0.36376360f, 0.07063854f, -0.15350977f, 0.12448314f, 
    0.09115571f, -0.01658656f, 0.17502421f, 0.17098339f, -0.02408827f, -0.22104129f, 0.03436434f, 0.08076081f, 
    0.01019209f, 0.19137250f, -0.29903111f, -0.10995404f, -0.12692733f, -0.14172532f, -0.06324059f, 0.19100975f, 
    0.01168154f, 0.19478303f, 0.92807353f, 0.27851459f, -0.59737742f, -0.03894032f, 0.24895650f, 0.03155217f, 
    -0.04289281f, 0.04035164f, 0.08229337f, 0.34207833f, -0.07377782f, -0.26825982f, 0.15920968f, 0.15309285f, 
    -0.24211311f, -0.20669462f, 0.00917258f, -0.18530297f, -0.21957348f, -0.04502977f, 0.22743204f, 0.02462470f, 
    0.00853390f, 0.00739862f, -0.14088039f, 0.06377937f, -0.20667593f, -0.41046491f, -0.23939486f, 0.07109897f, 
    0.18563654f, -0.00309946f, 0.02024679f, 0.11405602f, 0.01233876f, 0.15633141f, 0.11762217f, 0.12999672f, 
    -0.20353484f, 0.00881244f, 0.01975502f, 0.05814626f, 0.07569403f, -0.25043067f, -0.18494985f, -0.48354790f, 
    -0.19482864f, 0.08027749f, -0.09676744f, 0.11200511f, -0.00426676f, -0.03186879f, 0.33978957f, 0.11669625f, 
    -0.37189978f, -0.22444089f, -0.13388622f, 0.04464453f, 0.15682761f, 0.29080763f, 0.00974050f, 0.19517712f, 
    0.25000557f, 0.32616860f, 0.00536163f, -0.06144587f, 0.10943937f, 0.17239787f, -0.06401487f, -0.28313005f, 
    -0.16023982f, -0.26285455f, 0.11271661f, 0.14265694f, -0.08030542f, 0.14428283f, 0.22550304f, 0.07880357f, 
    0.10839606f, 0.02950065f, -0.00395612f, 0.37105179f, 0.01149835f, 0.14945409f, 0.05893670f, 0.10840277f, 
    0.06351066f, 0.00437476f, -0.51814860f, -0.47011781f, 0.10512643f, 0.30151674f, 0.22307287f, 0.30006939f, 
    0.07545771f, -0.07558473f, 0.24509640f, -0.08366486f, -0.05179769f, -0.23165160f, 0.20682614f, -0.13827287f, 
    0.11725020f, 0.09762148f, 0.11173886f, -0.00453143f, 0.06989180f, -0.37921503f, 0.16567653f, 0.27274355f, 
    -0.32203168f, 0.21421163f, -0.22530793f, -0.08286610f, 0.27272359f, 0.05835603f, 0.30116355f, -0.15553407f, 
    -0.10223284f, -0.55503225f, 0.07500412f, -0.01125448f, 0.26691774f, 0.16452686f, -0.06369498f, 0.14764285f, 
    -0.04256138f, -0.06248587f, -0.19742955f, -0.02676033f, 0.03008596f, 0.24026576f, -0.08948074f, -0.16116901f, 
    -0.34000692f, 0.53111559f, -0.27105919f, 0.28388944f, 0.13137572f, 0.02127382f, 0.11146092f, 0.05547546f, 
    0.11693124f, -0.16473162f, -0.31385201f, -0.24883214f, 0.39987528f, 0.14561312f, 0.04620529f, -0.02985226f, 
    0.11347426f, -0.32397315f, 0.19255587f, 0.26081899f, 0.12800013f, 0.22040784f, 0.01871421f, 0.10675190f, 
    0.02702347f, 0.15650082f, 0.10786510f, 0.00792549f, 0.52217495f, -0.14414455f, -0.19825712f, 0.10010581f, 
    0.09826145f, 0.20954558f, 0.12365834f, 0.04373911f, 0.14962615f, 0.30814433f, 0.13703257f, -0.74353504f, 
    -0.00492329f, -0.01527976f, -0.14774857f, 0.14165626f, 0.16196652f, 0.18684547f, -0.05898846f, 0.58501470f, 
    0.16026546f, -0.09923503f, -0.01576229f, -0.03057923f, 0.09652452f, 0.22712249f, 0.15983965f, 0.01150088f, 
    0.09684233f, 0.20558475f, 0.07514025f, -0.08176492f, 0.14222388f, -0.25525963f, -0.06975294f, -0.03679408f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.09068121f, -0.00433829f, 0.45853466f, -0.03780986f, -0.02113400f, 0.04272285f, 0.10669857f, 0.04355086f, 
    0.14515883f, 0.22140294f, 0.12589855f, 0.01227453f, 0.36932993f, 0.04171342f, -0.28708678f, 0.20427373f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.06084217f, 0.11065876f, -0.19144899f, 0.40147835f, 0.13476321f, -0.39602330f, 0.21270612f, 0.25775087f, 
    0.27075320f, -0.08520100f, -0.46799436f, -0.15274748f, 0.00259419f, 0.17740254f, -0.28279904f, 0.08882171f, 
    -0.20901984f, 0.04210254f, 0.06994540f, -0.53971952f, 0.01159129f, -0.15950678f, 0.26672629f, 0.76158494f, 
    -0.59301168f, 0.15910837f, 0.27806836f, 0.13469392f, 0.14208320f, -0.05530136f, 0.25536656f, 0.31658873f, 
    0.25313628f, -0.01699074f, 0.50320500f, -0.30340582f, -0.01947784f, 0.07910150f, -0.14226046f, 0.24830547f, 
    -0.90062875f, -0.28492782f, -0.09570569f, -0.21241991f, 0.27244997f, 0.20082316f, -0.12392423f, 0.18168771f, 
    -0.01936983f, -0.13293840f, -0.04705150f, 0.42731604f, -0.16632740f, 0.21821167f, -0.81051970f, 0.42431429f, 
    0.07039116f, -0.16484086f, -0.13214549f, 0.12946321f, -0.55867785f, -0.36456820f, 0.16361655f, 0.38396096f, 
    0.47179762f, 0.08236667f, -0.20562048f, 0.09580685f, -0.13155919f, 0.77124363f, -0.27594587f, -0.19410396f, 
    -0.00656079f, 0.34728029f, -0.05438665f, -0.15166377f, 0.64047724f, 0.10383324f, -0.02345928f, -0.02802696f, 
    -0.00015856f, 0.15971527f, 0.26250583f, 0.04160570f, -0.21593285f, 0.07545256f, -0.11060311f, -0.28613356f, 
    0.39478084f, 0.59206569f, 0.09115012f, -0.19335021f, 0.62907141f, -0.25711384f, -0.59794617f, -0.05436219f, 
    0.39432383f, 0.08533137f, 0.32268509f, 0.15023229f, 0.22606865f, -0.51438785f, 0.00563802f, -0.54289991f, 
    -0.52361399f, 0.12976202f, -0.00839341f, -0.20617662f, -0.04074244f, 0.35994229f, -0.13600685f, -0.04105297f, 
    -0.06607868f, -0.23734911f, 0.51879185f, 0.00791694f, -0.16272511f, -0.43440562f, 0.06851948f, 0.05099647f, 
    0.48436871f, -0.21384807f, -0.06603743f, -0.03166737f, -0.27822721f, -0.00287535f, 0.30076936f, -0.07478406f, 
    -0.27839419f, 0.03080711f, 0.17403129f, -0.08347999f, -0.16181308f, 0.10746247f, -0.26088777f, -0.11979648f, 
    -0.18267657f, -0.12426741f, -0.02620078f, -0.03661636f, -0.14095740f, 0.14496465f, 0.19596384f, -0.23890299f, 
    0.20648767f, 0.19591874f, 0.13793199f, -0.02200264f, -0.01241105f, -0.25452369f, -0.66698366f, -0.14625284f, 
    0.01049180f, -0.15147193f, -0.16045110f, -0.13547057f, -0.45921773f, 0.46060488f, -0.33702648f, 0.54896724f, 
    0.32061061f, 0.08861319f, 0.43695131f, -0.41066387f, -0.05830995f, -0.62343776f, -0.63397151f, -0.24561681f, 
    -0.03166713f, 0.45384985f, 0.11520266f, 0.11990510f, -0.22884075f, 0.38826132f, -0.20524864f, -0.05955769f, 
    0.10053865f, -0.12953639f, 0.05790497f, -0.11250203f, -0.24048710f, 0.19635245f, 0.04798698f, -0.10887504f, 
    -0.19439621f, -0.08965293f, 0.03500554f, -0.23063433f, -0.27696878f, -0.01868450f, -0.03686587f, -0.26827586f, 
    0.07514089f, 0.17475280f, 0.09960919f, 0.41839203f, 0.00920032f, 0.75458503f, 0.03316190f, 1.10162556f, 
    0.05826781f, 0.14002702f, -0.40536144f, -0.09046923f, -0.32650521f, 0.20396009f, 0.44793728f, 0.05877662f, 
    0.06265437f, 0.08248521f, 0.48117182f, 0.09322315f, 0.05376247f, 0.15829706f, -0.59210414f, 0.03269477f, 
    0.18793346f, -0.36370948f, -0.06492659f, 0.15313004f, 0.58211613f, -1.22479451f, -0.50122434f, 0.50062793f, 
    -0.23242125f, -0.08608424f, 0.12797153f, -0.15233232f, -0.00000966f, -0.20633052f, -0.08718643f, 0.15641394f, 
    -0.16797525f, 0.00286243f, 0.02999064f, 0.21736924f, 0.18839066f, -0.17345439f, 0.07326400f, -0.24338147f, 
    0.13482076f, 0.02996250f, 0.12456472f, 0.06144579f, 0.00170576f, 0.34400731f, -0.53850168f, 0.32155338f, 
    -0.08322545f, -0.16772500f, -0.15759395f, 0.15587732f, -0.22614077f, 0.52132821f, -0.27626562f, 0.41706529f, 
    0.12830003f, 0.06518984f, -0.23787266f, -0.22168230f, -0.15885660f, -0.12650153f, 0.09995561f, 0.05838558f, 
    -0.13082060f, -0.10854742f, -0.22302465f, 0.18132129f, 0.06896434f, 0.06335986f, 0.15969114f, -0.18228400f, 
    -0.14667708f, -0.23591663f, -0.12148040f, -0.36475542f, 0.04605965f, 0.54174662f, 0.35972592f, 0.13771264f, 
    -0.05981370f, 0.16655357f, 0.06482100f, -0.05246183f, 0.50653398f, 0.40547708f, -0.69215047f, 0.29896262f, 
    -0.36769506f, -0.05972049f, 0.22077025f, 0.47015527f, -0.11389953f, -0.19201940f, 0.29699087f, 0.45368320f, 
    0.71846235f, 0.38897392f, -0.25304830f, 0.03341119f, -0.11209030f, -0.40589428f, -0.00471394f, -0.10682648f, 
    -0.04954061f, 0.07170233f, 0.37355357f, -0.48065594f, 0.04122455f, -0.68500268f, -0.66129279f, -0.28237301f, 
    0.01411946f, 0.09470897f, 0.02529076f, -0.16848090f, -0.45173004f, -1.13702989f, -0.07170670f, 0.65876555f, 
    0.43178853f, 0.19295736f, 0.10957065f, 0.20205028f, 0.21454450f, 0.22596195f, -0.45518827f, 0.31527460f, 
    0.19517340f, 0.07768682f, -0.31805947f, 0.05115637f, -0.83282560f, -0.29653639f, 0.02979629f, 0.06604116f, 
    0.13704133f, -0.14024465f, 0.55402291f, -0.29411829f, 0.18369897f, -0.31629297f, 0.19929674f, -0.08705645f, 
    -0.00475629f, 0.32431999f, 0.17376204f, -0.05289614f, -0.70764357f, -0.15139882f, 0.47413337f, -0.25045830f, 
    0.22207147f, 0.05213657f, 0.51882923f, 0.33083484f, -0.02228159f, 0.60935861f, 0.08956282f, -0.19646712f, 
    0.26291192f, 0.49227384f, -0.25513941f, 0.00555505f, 0.24331157f, -0.56268841f, -0.23079647f, -0.57195437f, 
    0.15980940f, 0.09941359f, -0.02152720f, 0.41275853f, 0.14971417f, 0.61118525f, -0.19571380f, 0.30986658f, 
    0.58523232f, -0.06615918f, -0.31439769f, -0.15436040f, 0.16751784f, 0.37927359f, -0.04569546f, 0.19998170f, 
    -0.49483564f, 0.13862661f, 0.25356185f, 0.18338506f, 0.13233006f, 0.09371101f, 0.12116174f, 0.41228804f, 
    0.38532218f, 0.61267620f, 0.16635735f, -0.07580669f, -0.08549225f, -0.73572129f, 0.45813772f, -0.04415740f, 
    -0.22139621f, 0.00887231f, 0.38905242f, -0.26461414f, -0.23297113f, 0.49149463f, 0.18871559f, 0.32064360f, 
    -0.21918195f, 0.70832831f, -0.21531996f, 0.14560919f, -0.41042799f, 0.28121236f, 0.34066799f, 0.11570588f, 
    0.21845363f, 0.13175513f, 0.36486971f, -0.04072702f, 0.17830017f, -0.01641416f, 0.17549422f, 0.53383243f, 
    -0.98571491f, -0.30452150f, 0.14669122f, 0.17820688f, -0.09028550f, -0.17433338f, -0.33075938f, 0.07054387f, 
    0.26490629f, 0.09683993f, 0.16739799f, -0.00579133f, 0.17539215f, -0.36017802f, -0.23549853f, 0.05654491f, 
    0.25075883f, -0.20644450f, 0.62663186f, 0.23671256f, 0.71917832f, 0.08008257f, -0.43709826f, -0.01807209f, 
    -0.13122585f, -0.10015335f, 0.35353199f, 0.03518262f, 0.14542681f, -0.23481943f, -0.05745597f, -0.12441199f, 
    -0.13377672f, 0.04271317f, 0.40636376f, 0.13814773f, 0.38640741f, 0.18324070f, 0.23332772f, -0.29081017f, 
    0.20506300f, 0.17561965f, 0.19642150f, -0.17021197f, -0.04087485f, -0.59492838f, 0.12006015f, -0.29000553f, 
    0.34536332f, 0.54038912f, 0.63616145f, -0.04468071f, 0.19531244f, 0.08104414f, -0.44488946f, 0.13508005f, 
    0.12968715f, 0.16845232f, -0.22367166f, 0.08248562f, 0.28561476f, 0.49803001f, 0.35314950f, 0.03151984f, 
    -0.16704407f, -0.37806839f, -0.36247480f, 0.24536160f, -0.14751494f, 0.39920315f, 0.56520718f, 0.04055814f, 
    -0.12277591f, 0.12836286f, -0.16077232f, -0.24461207f, 0.08136097f, -0.22857571f, 0.09183699f, -0.22128081f, 
    0.24734783f, 0.24527249f, -0.23521137f, 0.07551920f, -0.05518630f, -0.18385902f, -0.09654000f, -0.07491159f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.42815834f, 0.28525412f, -0.18023966f, 0.10618945f, -0.17526993f, 0.33172166f, -0.21738383f, 0.18545803f, 
    -0.27255878f, 0.01730102f, -0.11011414f, -0.22869915f, 0.06458414f, 0.10599885f, -0.15714352f, -0.10662780f, 
    -0.17370075f, 0.70462400f, -0.22681694f, 0.35060361f, -0.19595264f, 0.26047108f, -0.08896910f, -0.11186687f, 
    -0.30790016f, 0.41335502f, -0.00272467f, 0.83548260f, 0.05167469f, 0.18503100f, -0.46614274f, -0.02706894f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.60475200f, 0.04612178f, 0.08697736f, 0.46069288f, -0.05585717f, -0.94832265f, -0.48245147f, -0.25325054f, 
    -0.02424628f, 0.00792090f, -0.99641776f, -0.01762182f, 0.30395773f, -0.21308927f, -0.00980803f, 0.27224800f, 
    0.03644662f, -0.05496455f, -0.23012541f, -0.83606178f, 0.58774579f, 0.01820765f, -0.34367967f, 0.22112089f, 
    0.08586363f, 0.19283263f, 0.21569411f, -0.46843255f, -0.35453206f, -0.58954579f, 0.41214031f, -0.01625861f, 
    0.03618005f, 0.13134789f, 0.06614301f, -0.64884555f, 0.04378100f, 0.33308333f, -0.31708604f, -0.03346970f, 
    -0.13593294f, -0.86911345f, -1.19241321f, -0.16820247f, 0.16932547f, 0.33313125f, -0.02769536f, -0.24379204f, 
    0.07297076f, 0.26459917f, 0.26859540f, -0.66642755f, -1.09658945f, -0.05656924f, 0.81183648f, 0.15205695f, 
    0.05601288f, 0.19858997f, 0.14923206f, -0.09235102f, -0.10965223f, -0.37453672f, -0.07567212f, 0.10800637f, 
    0.47715858f, 0.15428030f, -0.03212046f, -0.70975775f, -0.58946514f, 0.05489333f, 0.24652374f, -0.23854980f, 
    0.02789881f, 0.08326738f, 0.10188545f, -0.20524044f, -0.38414386f, 0.27163231f, -0.13623251f, -0.37701550f, 
    -0.02434454f, 0.22136521f, -0.25935823f, 0.97755980f, -1.60865569f, 0.00369835f, -0.71790725f, -0.55695570f, 
    -0.11784039f, -0.04610683f, 0.22580047f, -0.01112933f, -0.08692002f, 0.00195434f, 0.31215528f, -0.04322138f, 
    -0.37071598f, 0.19129960f, 0.10175861f, 0.59318644f, -0.72659731f, -0.61261368f, -0.00367677f, 0.26797238f, 
    0.04481421f, 0.34524557f, 0.11745985f, 0.07645436f, 0.23537740f, 0.04307684f, -0.17853692f, 0.08380158f, 
    0.00473038f, -0.47144148f, 0.52595001f, 0.18475211f, -0.03693417f, 0.30379122f, -0.89113069f, -0.22481473f, 
    -0.01863114f, 0.15196925f, -0.04685030f, -0.29366276f, 0.14994752f, -0.37595817f, -0.17636316f, 0.13573414f, 
    -0.16119720f, -0.26954520f, 0.04172433f, -0.01597284f, 0.25447202f, -0.05442734f, 0.21701041f, -0.37204984f, 
    -0.11925052f, 0.34793809f, 0.25491527f, -0.13984664f, 0.11399021f, -0.45265242f, -0.02247914f, 0.08267751f, 
    0.05744022f, 0.06375101f, 0.19705753f, -0.52839822f, 0.10052080f, 0.06870463f, 0.12122691f, 0.15229423f, 
    -0.23243792f, 0.26088372f, -0.23599873f, -0.44087020f, -0.30672890f, -0.03042502f, 0.01212542f, -0.12396642f, 
    0.42960572f, 0.44456762f, -0.04666748f, -0.27232137f, 0.06613328f, 0.04985118f, -0.28717142f, -0.25632000f, 
    0.07688281f, -0.34977767f, -0.13366076f, 0.13247547f, 0.06548110f, -0.42372572f, -0.14533503f, -0.16484442f, 
    0.13555180f, 0.31030351f, 0.13174441f, -0.49179476f, -0.49970588f, -0.22536187f, -0.46553415f, -0.05143515f, 
    0.30001193f, 0.03378320f, 0.02201540f, 0.05065624f, 0.02361663f, 0.15029415f, -0.55010158f, 0.00110077f, 
    -0.69848228f, -0.13482340f, 0.24787420f, -1.57433593f, 0.43368092f, 0.21109757f, 0.14902157f, -0.13817880f, 
    -0.16597810f, -0.40410951f, -0.15817308f, -0.13580233f, -0.98809332f, 0.51088965f, 0.13728055f, -0.42754284f, 
    0.08808342f, 0.21079943f, -1.47969294f, 0.13916211f, -1.34444225f, -1.09125721f, -0.35516298f, -0.00256662f, 
    -0.72226930f, -1.85168493f, -0.06397606f, 0.44328719f, 0.23844418f, 0.17825995f, 0.10305563f, 0.14884914f, 
    -0.20401117f, -1.56440246f, -1.12117469f, 0.60416847f, -0.40567967f, -0.19557261f, -0.27410522f, 0.40169376f, 
    -0.12308804f, 0.42135316f, -0.33371192f, 0.08021206f, 0.14545792f, 0.27581269f, 0.14847180f, 0.18675791f, 
    0.01605943f, -0.77111101f, 0.28558177f, 0.52276939f, 0.08664642f, 0.16811554f, -0.11050232f, 0.27980122f, 
    0.52554911f, -0.36862397f, -0.97076803f, -0.08358186f, -0.19442444f, -0.06629819f, 0.08746883f, -0.16188145f, 
    0.05879974f, -0.12282114f, -1.09020281f, -0.62440836f, -0.45803308f, 0.33066189f, -0.10082392f, 0.35867864f, 
    0.13107412f, -0.73139828f, -0.28879923f, 0.13583183f, -0.45169157f, -0.48917419f, -0.05931363f, -1.01913631f, 
    0.05977064f, 0.13411206f, 0.38140944f, -0.15296656f, -0.17614560f, 0.38130945f, -0.09967949f, -0.18933772f, 
    0.36396059f, 0.25804171f, -1.40629578f, 0.29263681f, 0.12240535f, 0.34585610f, -0.45868689f, 0.13460007f, 
    0.04296649f, -0.28512475f, 0.05107365f, 0.05386866f, 0.01463930f, 0.01300391f, 0.26137114f, 0.09377933f, 
    -0.04239701f, 0.60640937f, 0.10707372f, -0.06807188f, -0.19106150f, -0.13794473f, -0.10439812f, 0.39573544f, 
    -0.00678784f, 0.40409520f, -0.64731199f, -0.41817960f, -1.07842314f, -0.42542046f, -0.72164005f, 0.19909784f, 
    -1.23105860f, -0.53138530f, 0.19692528f, 0.27391478f, -0.00054550f, 0.12683260f, -0.49937496f, -0.06271219f, 
    -1.19564569f, 0.00647396f, 0.26723629f, -0.65896988f, -0.54991961f, -0.08774339f, 0.27523562f, 0.32612136f, 
    -0.17884372f, -0.71461725f, 0.44585985f, -0.00730738f, -0.35142919f, -0.72317821f, 0.01469010f, -0.64024478f, 
    -0.15307145f, -0.56181800f, -0.27423352f, -0.39943573f, -0.56627148f, 0.61263740f, 0.73894840f, -1.01319993f, 
    0.12106698f, 0.02873170f, 0.54453045f, -0.28876066f, 0.26934621f, 0.04439480f, -0.09757333f, 0.10870852f, 
    -0.71471167f, -0.90745920f, -0.53787452f, -1.14639032f, 0.27210730f, 0.16122398f, 0.29736432f, 0.05798366f, 
    0.03454176f, -0.26074931f, 0.21257201f, 0.01348717f, -0.05536860f, 0.31719089f, -0.11211867f, -0.33774823f, 
    -0.05547903f, -0.73352987f, -0.13221422f, -0.04376282f, -0.34723765f, 0.07902139f, 0.54513437f, 0.05183464f, 
    0.02729709f, -0.30737016f, -0.36327741f, 0.34626460f, 0.20144787f, 0.19728713f, -0.76941866f, -0.12629721f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.18568251f, 0.24593329f, 0.17324960f, -0.23755369f, -0.32218879f, -0.02208686f, -0.12102775f, -0.35680684f, 
    0.17851809f, 0.13515854f, -0.49284679f, -0.13067064f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
