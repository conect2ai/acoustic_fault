#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.51487714f, -0.07619832f, 0.21842073f, 0.14994371f, 0.50084800f, -0.22723140f, -0.12172819f, -0.12931974f, 
    -0.02464379f, -0.08436764f, -0.22887300f, -0.03922556f, 0.19370678f, 0.01713321f, -0.32501465f, 0.11266058f, 
    -0.07741383f, 0.25530428f, -0.18909866f, -0.34045142f, -0.05369227f, 0.21373068f, 0.01603639f, 0.24678878f, 
    0.18834981f, -0.75450969f, -0.42198247f, -1.50452840f, -1.15423644f, -0.75094724f, 0.29949597f, 0.40119430f, 
    0.93355691f, 0.05688477f, -0.11523982f, 0.06796867f, -0.31831196f, -0.43404853f, -0.57919943f, -0.15200436f, 
    -0.04441240f, 0.09782431f, 0.00054225f, -0.05731574f, -0.43451816f, -0.08500974f, -0.09979543f, 0.35606682f, 
    0.12113814f, 0.21382014f, 0.47533187f, 0.24125424f, 0.33620483f, -0.87768227f, -1.24748635f, 0.30921602f, 
    0.11480919f, 0.12285513f, 0.26053160f, 0.25156373f, -0.31656316f, 0.64939332f, -0.50897294f, -0.19198965f, 
    -0.26352018f, 0.22497796f, 0.28651744f, -0.14766663f, -0.02225092f, 0.13482040f, -0.07532377f, -0.09940369f, 
    0.24851121f, 0.16182257f, -0.23681447f, -0.82639432f, -1.07029879f, -0.56391704f, 0.39930019f, 1.06509304f, 
    0.16633938f, 0.02419738f, -0.61196584f, 0.10935441f, 0.34027055f, 0.09827312f, -0.02807954f, 0.38307413f, 
    -0.32683307f, -0.19741370f, 0.04850215f, -0.07872849f, 0.24576102f, 0.13794281f, 0.47141847f, 0.15562749f, 
    -0.41210246f, -0.34065381f, -0.16082284f, -0.26141626f, -0.59801823f, 0.48250189f, -0.00922787f, -0.74730057f, 
    -0.31004396f, -0.52780342f, 0.02342771f, 0.54727399f, 0.75755757f, 0.33874881f, -0.33485460f, -0.41909260f, 
    -0.00187596f, -0.16803508f, 0.14005543f, 0.38295960f, 0.33225992f, 0.25023308f, 0.16237009f, 0.06533072f, 
    -0.05131098f, 0.16471556f, -0.31464392f, -0.19520940f, -0.15186778f, -1.03246546f, -0.64211357f, -0.12272819f, 
    -0.40331015f, 0.33372527f, -0.41909930f, -0.80331290f, -1.06561434f, -0.51424950f, -0.33351156f, -0.32458705f, 
    -0.30247378f, -0.22998329f, -0.40644500f, -0.92731214f, -0.33245495f, 0.00156503f, -0.30143699f, -0.37814906f, 
    -0.40324876f, -0.13976569f, 0.02918373f, 0.08615788f, -0.15284206f, -0.16699687f, 0.04947622f, -0.71015924f, 
    0.11691917f, 0.60216331f, -0.25271970f, -0.28172454f, 0.04267917f, -0.54966366f, -0.35319209f, 0.60773969f, 
    0.67090392f, -0.39142951f, -0.14253452f, 0.14845225f, 0.57103986f, -0.30843663f, 0.23683846f, -0.07348313f, 
    -0.21698244f, -0.60758740f, 0.29442695f, 0.40863901f, -0.01325485f, 0.11311451f, 0.04719115f, -1.31897831f, 
    0.67754322f, -0.48570880f, -1.05899525f, -0.40798160f, 0.15917605f, 0.19022475f, -0.11803483f, 0.45006582f, 
    0.15097696f, 0.05113216f, 0.08071492f, 0.15304136f, -0.12706672f, -0.21031426f, -0.17437865f, -0.10094856f, 
    -0.55762386f, -0.48224705f, -0.33420643f, -0.20370029f, -0.10769886f, -0.56884259f, -0.41364282f, -0.58369529f, 
    0.41739023f, -0.79138213f, 0.36119077f, -0.05140692f, 0.36255711f, -0.40770039f, 0.33053732f, 0.54672629f, 
    -0.06155521f, -0.06393890f, 0.16054788f, -0.32709646f, 0.07399950f, -0.42306134f, -0.12518859f, 0.02397238f, 
    -0.01298861f, 0.04210635f, -0.18788236f, -0.24597700f, 0.05923307f, 0.12093720f, -0.20275238f, 0.12510753f, 
    -0.22672223f, -0.70327759f, -0.59546828f, -0.06339696f, -0.15016574f, 0.01978178f, 0.64447743f, 0.35985887f, 
    -0.65510637f, -0.41092351f, -0.74077821f, 0.60091895f, -0.13877079f, -0.14497069f, -0.54451489f, -0.57339817f, 
    0.14859319f, -0.34036016f, 0.12701686f, 0.09205896f, 0.02855865f, 0.05687756f, 0.06102589f, 0.19211367f, 
    -0.05249320f, 0.52474314f, -1.13215494f, -0.05074861f, -0.07566477f, -0.68492758f, -0.49458128f, 0.30763564f, 
    0.41231862f, 0.34859371f, 0.31754330f, 0.62388194f, 0.11755009f, 0.23851006f, -0.33031943f, -0.27622983f, 
    0.06084131f, 0.05264112f, -0.00815228f, -0.04800116f, 0.04534595f, -0.12228295f, -0.03153757f, 0.09237108f, 
    -0.00680542f, -0.26653790f, -0.31558508f, 1.30388188f, -1.50779307f, -0.21025209f, -0.33296812f, 0.56287396f, 
    -0.33999532f, -0.34815890f, -0.37666067f, 0.16797675f, -0.15969510f, -0.29514483f, 0.26672316f, 0.16382465f, 
    -0.55734879f, 0.44453818f, -0.16779248f, 0.08837058f, -0.11315441f, 0.19978313f, 0.08581026f, -0.27082825f, 
    -0.37194422f, -0.17436174f, 0.11312342f, 0.43449375f, 0.12556410f, 0.54104227f, 0.33264694f, -0.32944158f, 
    -0.31436387f, -0.20830746f, -0.01518911f, 0.09629259f, 0.04449128f, -0.22309080f, -0.07517194f, -0.21621808f, 
    0.13039987f, -0.35345653f, 0.37185627f, 0.29613963f, -0.04661931f, -0.47183484f, 0.14288090f, 0.35153019f, 
    0.03845566f, -0.29934463f, -0.15458545f, 0.10833243f, 0.48406383f, 1.09480190f, 0.07175513f, -0.74746531f, 
    -0.64518273f, -0.93650067f, 0.67144161f, 0.15630859f, 0.35037965f, 0.22641945f, 0.02109911f, -0.05303824f, 
    0.32276860f, -0.08941418f, -0.00868896f, -0.09964924f, -0.22335039f, -0.28505731f, 0.30092040f, 0.05694716f, 
    0.00401857f, 0.29317391f, -0.06405995f, -0.10614977f, -0.01142185f, 0.07015461f, -0.06081967f, -0.48942479f, 
    -0.35856587f, 0.28433159f, -0.59466326f, -0.50055236f, 0.15124132f, -0.61865968f, -0.64735818f, -0.58403778f, 
    0.04281210f, 0.05238042f, -0.03889718f, -0.19000240f, -0.08737601f, 0.23028134f, -0.01107058f, 0.33201858f, 
    0.32540753f, 0.36039388f, -0.09536947f, -0.21711423f, -0.25808650f, 0.21486257f, -0.24834274f, -0.76812780f, 
    -0.36139858f, -0.62342477f, -0.58047849f, -0.35335001f, -0.19041018f, -0.62308758f, -0.13773640f, 0.43744078f, 
    0.30900395f, 0.04549843f, -0.17552926f, -0.14184654f, -0.27169535f, 0.14816268f, 0.27931654f, -0.05538965f, 
    0.08975019f, 0.21762565f, 0.40909901f, -0.14433104f, -0.15712474f, -0.08664892f, -0.21795774f, -0.45543319f, 
    0.39056769f, -1.09371507f, -0.75227410f, -0.15825076f, 0.18297412f, -0.07414963f, 0.30619675f, -0.12973256f, 
    0.38232496f, 0.13608429f, 0.08696484f, 0.12703630f, -0.03257795f, -0.06191595f, 0.37930128f, -0.25785583f, 
    0.07382687f, 0.06554218f, 0.26071835f, -0.18616983f, -0.26549190f, 0.32115757f, -0.07628763f, 0.37776297f, 
    -0.17126249f, -0.96530998f, -0.76574922f, -0.54578751f, 0.20554031f, 0.34748524f, 0.36581361f, 0.15592495f, 
    0.25908536f, 0.77773225f, 0.60788018f, 0.21400155f, 0.18474898f, -0.03677462f, 0.07322612f, 0.01257681f, 
    -0.27658674f, -0.24528794f, -0.15562770f, -0.21400028f, -0.07333682f, 0.26000798f, -0.02658582f, 0.34012017f, 
    0.34925553f, 0.01623760f, 0.08169357f, 0.27405483f, -0.83193290f, 0.61245310f, -0.64849633f, 0.22830462f, 
    -0.25936347f, -0.33263114f, 0.01516559f, 0.65802664f, 0.00280454f, -0.26684588f, -0.12351763f, -0.09210065f, 
    0.27872321f, -0.17920010f, -0.08833025f, 0.12039042f, 0.04153971f, 0.11187439f, -0.20202173f, 0.06662732f, 
    -0.04615898f, 0.09699055f, -0.15925926f, 0.96487510f, -0.07726650f, -0.33872896f, -0.11539003f, -0.21453254f, 
    0.52860588f, 0.42878744f, 0.30678800f, -0.20067699f, 0.32330394f, -0.31102738f, 0.52876157f, -0.46494067f, 
    -0.64366722f, -0.38250419f, 0.17794843f, -0.06690013f, 0.20656180f, -0.18960293f, -0.17026183f, -0.13604029f, 
    -0.18435091f, -0.18135329f, 0.09960624f, 0.23238033f, 0.54074186f, 0.41642347f, 0.40934989f, -0.17394473f, 
    -0.27797499f, -0.41246098f, -0.40273404f, -0.18419002f, -0.50813538f, -0.65593016f, 0.61979020f, 0.14064002f, 
    -0.14842567f, -0.17126897f, -0.06432315f, 0.34163243f, 0.05720643f, 0.06666609f, 0.10359647f, 0.00929432f, 
    -0.22463469f, -0.04587140f, 0.13672802f, 0.22570288f, -0.15744226f, 0.93242437f, 1.25259125f, 0.47134924f, 
    -0.56175297f, -0.91270930f, -0.27749452f, -0.43789423f, 0.01019518f, -0.22971439f, -0.19848633f, 0.17130150f, 
    -0.00979903f, 0.15484758f, 0.18545139f, -0.24357040f, 0.02247085f, -0.01004298f, 0.07051028f, 0.38642481f, 
    -0.26444012f, 0.23398452f, -0.01237106f, -0.23347716f, -0.29178122f, 0.02837699f, -0.61557639f, -0.68876165f, 
    -0.67021406f, -0.72043949f, -0.38055062f, -0.93726695f, -0.93575341f, -0.75399160f, -0.36250168f, -0.31332138f, 
    -0.00039166f, 0.30616596f, 0.34893033f, 0.17390972f, 0.23966268f, 0.05319921f, -0.33965448f, -0.22663762f, 
    0.01757794f, -0.17674772f, 0.29336262f, 0.28202051f, -0.11804570f, 0.10614787f, 0.64863116f, 0.48089883f, 
    -0.04475345f, 0.11237425f, 0.03585732f, 0.00243300f, 0.40835509f, -0.35054865f, 0.08501194f, -0.29870531f, 
    -0.03441204f, -0.28236878f, 0.40304530f, -0.34434181f, 0.05973022f, 0.06964892f, -0.04043485f, 0.26145491f, 
    0.21517067f, 0.09557091f, 0.11345215f, 0.24777791f, 0.11017595f, 0.22180130f, -0.33565274f, -0.37792233f, 
    0.49758637f, 0.54423064f, -0.65873480f, -0.76496869f, -0.06541597f, 0.11163299f, 0.14806858f, -0.20949750f, 
    0.04033147f, -0.04116081f, 0.03906076f, -0.28767338f, -0.22702856f, 0.46297103f, -0.20175673f, -0.14884946f, 
    -0.05741479f, -0.54109871f, 0.06386529f, 0.01862489f, 0.20605789f, 0.32339355f, -0.05213600f, 0.23333597f, 
    0.49572197f, -0.00825340f, 0.35642511f, 0.46613553f, 0.64202410f, -0.59222120f, -0.95536160f, -0.90879071f, 
    -0.18234213f, 0.23258837f, 0.17965670f, 0.34533054f, -0.30204582f, 0.37306389f, 0.43633777f, 0.16082048f, 
    -0.20416619f, 0.26959899f, -0.16185842f, -0.18924342f, -0.35645559f, -0.09038231f, 0.00881171f, -0.00176653f, 
    -0.08295518f, -0.09805757f, -0.20402004f, -0.10775954f, 0.56425184f, 0.52100933f, -0.26917467f, 0.40989110f, 
    -0.15123998f, -0.53244787f, -0.52369642f, -0.56160903f, 0.19343683f, -0.48224768f, -0.46871218f, -0.06667694f, 
    0.23582141f, 0.23835333f, 0.15923089f, 0.24285077f, 0.33441049f, -0.11782236f, -0.08317273f, -0.25567237f, 
    -0.35054249f, -0.51791328f, -0.22379433f, 0.30543038f, 0.58771324f, 0.23716006f, -0.17962268f, 0.41338307f, 
    -0.01469502f, -0.17679651f, -0.23239198f, -0.15018809f, 0.07822543f, 0.02299481f, 0.25797093f, -0.32066223f, 
    0.02060228f, 0.28811404f, -0.35468310f, -0.49428132f, 0.18454571f, -0.04265140f, 0.03291171f, -0.00832395f, 
    0.22560067f, 0.12650186f, 0.10490394f, -0.36582518f, 0.18905915f, 0.09786576f, -0.00799616f, 0.08898748f, 
    -0.49044576f, -0.52326488f, -0.71670473f, -0.10335801f, 0.31480664f, -0.88456374f, 0.38277954f, -0.65254480f, 
    -0.04224084f, 0.25556421f, -0.15311500f, 0.24794346f, 0.25941750f, -0.25442225f, -0.63102108f, -0.74795532f, 
    -0.13333538f, -0.00909008f, -0.00957395f, 0.07237167f, 0.38096458f, -0.20440100f, -0.73089951f, 0.08966560f, 
    0.25812343f, 0.83630180f, 0.11373337f, 0.48507506f, -0.04077958f, 0.12724085f, 0.02491826f, -0.22416611f, 
    -0.43594661f, -0.18450357f, -0.00244040f, -0.00452011f, 0.11590006f, -0.20380658f, -0.35247985f, 0.33408204f, 
    0.01304627f, -0.57284474f, -0.33786455f, 0.06143678f, -0.27005386f, -0.40026611f, 0.60686803f, 0.75502962f, 
    0.66684890f, 0.12345753f, -0.10102515f, -0.06876263f, 0.03339797f, 0.09725988f, 0.06735509f, 0.20518300f, 
    0.07909860f, 0.12642859f, -0.07629279f, -0.02467487f, 0.13252801f, 0.03979765f, 0.23230439f, -0.09420685f, 
    0.06278274f, -0.09779090f, -0.19798703f, 0.15317476f, -0.18657586f, 0.19079833f, 0.08319958f, 0.68735170f, 
    0.57980740f, 0.54084063f, -0.25130704f, -0.31940037f, -0.25012413f, 0.00864668f, -0.09005957f, -0.46756113f, 
    -0.79635513f, -0.33780909f, -0.20408420f, -0.23663566f, -0.37606224f, 0.17214181f, 0.07581019f, -0.15419401f, 
    -0.11221387f, -0.27586111f, -0.02806116f, -0.37121651f, -0.12574995f, -0.18212110f, -0.06491216f, -0.31403726f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.02698005f, 0.00639985f, 0.34724444f, 0.16837841f, 0.06398919f, -0.05519210f, 0.29951784f, 0.14473285f, 
    0.55004901f, 0.41124940f, 0.19444294f, 0.41312936f, 0.45386320f, 0.46496025f, 0.09269296f, -0.19345461f, 
    0.56746030f, 0.45230940f, 0.26013032f, 0.23960309f, 0.16166791f, 0.41133830f, -0.11658474f, 0.22637512f, 
    0.26720840f, 0.06789440f, -0.26642933f, 0.45731711f, 0.19404009f, 0.10243244f, 0.02631188f, -0.00447659f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.06182426f, 0.04571258f, 0.03816395f, 0.16568786f, 0.07300145f, -0.04047162f, 0.01754309f, -0.02027446f, 
    -0.03028288f, 0.03275391f, 0.01181533f, -0.00056795f, 0.29903227f, 0.08203094f, -0.17593436f, -0.02730758f, 
    0.11479161f, 0.21520358f, 0.07978989f, 0.19784963f, -0.00952981f, -0.06919342f, -0.02643384f, 0.09717353f, 
    -0.05172381f, -0.60434973f, -0.16039355f, 0.03719177f, -0.09073305f, 0.16433170f, -0.04653389f, -0.03557532f, 
    -0.03088574f, -0.13269393f, -0.05657288f, -0.06594039f, 0.48178950f, 0.35404766f, 0.01986319f, -0.01531301f, 
    0.05328179f, 0.00608020f, 0.11422027f, -0.24273920f, 0.00894657f, -0.18463358f, 0.10818474f, -0.06360430f, 
    -0.30360168f, 0.00597706f, 0.24714363f, 0.06205421f, 0.06845740f, 0.16447766f, -0.11786228f, 0.05757588f, 
    -0.02673913f, 0.04865281f, 0.03677411f, -0.07938194f, 0.42828131f, 0.31548274f, 0.00869506f, -0.18880847f, 
    0.06531106f, 0.17663155f, 0.07945319f, -0.04309663f, -0.08600958f, -0.15907152f, -0.23536552f, -0.15671434f, 
    -0.26194823f, 0.27915689f, 0.01076615f, -0.31468308f, -0.19431189f, -0.02347012f, 0.04947690f, -0.18495420f, 
    -0.04841986f, -0.08573556f, -0.20757215f, -0.08838809f, 0.01414442f, 0.09084067f, -0.01514072f, -0.03432504f, 
    0.03628392f, 0.08200524f, -0.06184851f, 0.02011404f, 0.04459241f, 0.08728215f, -0.04060730f, 0.16898745f, 
    -0.12867932f, -0.69169068f, -0.28357619f, 0.07218079f, -0.09013928f, -0.02665118f, 0.03191734f, -0.02549073f, 
    -0.06275611f, -0.00832670f, -0.05967457f, 0.10368513f, 0.44965363f, 0.12510894f, -0.39967346f, -0.25782800f, 
    0.01083242f, -0.00647846f, 0.09631924f, 0.05995671f, -0.03208904f, -0.06493182f, -0.15296613f, -0.07249984f, 
    -0.29421580f, -0.19582281f, -0.00454819f, 0.01632879f, 0.12624875f, 0.16872524f, 0.08773813f, 0.13351391f, 
    0.00783416f, 0.18209547f, -0.06540456f, 0.02827790f, -0.00578567f, 0.07099022f, -0.21501620f, -0.26277235f, 
    -0.12628284f, -0.24562572f, -0.06958094f, -0.27881721f, -0.05905239f, 0.00667011f, -0.01497878f, -0.07157666f, 
    -0.04058020f, 0.03032649f, 0.02372941f, 0.05815965f, -0.04026743f, -0.02163315f, -0.15053536f, -0.14235611f, 
    -0.01255162f, 0.01981392f, -0.07510759f, -0.07335553f, -0.17144249f, -0.71365041f, -0.52234489f, 0.05343031f, 
    0.07761657f, 0.07565237f, -0.17852828f, -0.12740257f, -0.04902709f, -0.05810647f, -0.13742049f, -0.03708249f, 
    0.48118839f, 0.09046640f, -0.14904273f, -0.40905118f, 0.13837709f, 0.05231521f, 0.05315185f, 0.02945015f, 
    -0.00329185f, 0.06388976f, 0.05469172f, 0.05246362f, 0.33328411f, 0.35414368f, 0.19772790f, -0.09716032f, 
    0.04093372f, 0.32737663f, 0.02291240f, 0.14241756f, 0.05130769f, 0.03335695f, 0.10065836f, 0.03223128f, 
    0.24000585f, 0.19233453f, -0.19431835f, -0.00839941f, 0.16497554f, -0.04288118f, -0.13394445f, -0.40344602f, 
    -0.22356895f, -0.19232062f, -0.22768822f, 0.03871322f, -0.10919921f, 0.15605839f, 0.05153081f, 0.03993864f, 
    0.03332423f, 0.04365044f, 0.03536684f, 0.06497066f, -0.14546075f, -0.10722952f, -0.14529963f, -0.14335573f, 
    -0.06350148f, 0.07781490f, 0.03752178f, 0.11998159f, -0.14282477f, -0.02395515f, 0.03007832f, -0.08452699f, 
    -0.08788118f, -0.11349958f, 0.09302487f, 0.12845948f, -0.65542883f, -0.18960401f, -0.69581467f, 0.05570015f, 
    -0.01495883f, 0.01298731f, 0.05794156f, 0.08389556f, 0.00930114f, -0.09627044f, -0.16152073f, -0.25075698f, 
    0.12551798f, 0.05095842f, -0.26040274f, -0.12129806f, -0.03429830f, 0.00689283f, -0.29540741f, -0.05321178f, 
    -0.01478445f, 0.14541881f, 0.00876703f, 0.06550860f, -0.08643001f, -0.33638355f, -0.15129255f, 0.17375156f, 
    0.11139297f, 0.15095377f, 0.15131347f, -0.17243555f, -0.01335816f, 0.08202048f, -0.09172201f, 0.05235413f, 
    0.35548308f, 0.26693878f, -0.13215548f, -0.33525845f, 0.06577213f, 0.00062763f, 0.11712502f, -0.14431860f, 
    -0.03278349f, -0.05963230f, -0.01357635f, -0.02398989f, 0.04454628f, 0.01584519f, 0.11088436f, 0.11328809f, 
    0.02744688f, -0.35116386f, -0.00900897f, -0.03789354f, -0.09075266f, 0.01103779f, -0.06733861f, -0.00039096f, 
    -0.04576299f, -0.09267817f, -0.24981554f, 0.16389240f, 0.14254273f, 0.00435279f, -0.23899460f, -0.08873066f, 
    -0.10372065f, -0.10954350f, -0.15791318f, -0.12719069f, -0.07737177f, -0.07101094f, 0.44251823f, -0.59946322f, 
    -0.09099218f, -0.05011196f, -0.02487671f, -0.04844404f, 0.06060765f, -0.07593538f, -0.03556853f, -0.02325252f, 
    0.22153129f, 0.05463990f, -0.17242187f, -0.32869864f, -0.08813582f, -0.00993732f, -0.05240056f, -0.05202510f, 
    -0.00120552f, -0.06829320f, 0.13287452f, 0.11580568f, -0.48539439f, 0.00611488f, -0.37947363f, 0.04072994f, 
    0.06544191f, -0.00438538f, 0.02722688f, 0.01903194f, -0.05072064f, -0.00346503f, -0.05467853f, -0.05364959f, 
    0.18556166f, -0.02234118f, 0.30054837f, -0.18989262f, -0.14160606f, 0.04102018f, -0.02442518f, 0.06606690f, 
    0.03165485f, -0.09181716f, -0.18245211f, -0.02898534f, 0.26947632f, -0.19647861f, -0.04813119f, -0.11627053f, 
    -0.00308828f, -0.00860807f, 0.13238782f, -0.04293727f, 0.04674054f, 0.12430599f, 0.05310217f, 0.18455645f, 
    0.00844983f, 0.04508463f, -0.02168752f, 0.08159888f, 0.04070428f, 0.00152293f, 0.00164831f, 0.00017336f, 
    -0.06907545f, 0.00048561f, -0.01740155f, 0.00795446f, -0.19546157f, -0.06203371f, -0.10979710f, 0.22673006f, 
    -0.06045950f, -0.06023097f, -0.32603809f, -0.07214327f, 0.02358337f, 0.01752719f, 0.08254624f, 0.07435815f, 
    0.08923673f, 0.16514729f, 0.05479740f, 0.00914587f, -0.11911169f, -0.04157526f, 0.03495355f, -0.03920261f, 
    -0.06240924f, 0.00332582f, 0.02015321f, 0.06639943f, 0.27513045f, 0.20829800f, 0.10464589f, -0.19468647f, 
    0.02815806f, 0.02831301f, 0.10648128f, -0.23019390f, -0.05045057f, 0.07387585f, -0.06261697f, -0.00069854f, 
    0.21105742f, -0.11085940f, 0.07585490f, -0.61834633f, 0.11011033f, -0.11555048f, -0.01330115f, 0.04890227f, 
    -0.01959004f, -0.03897969f, -0.26312405f, -0.10143701f, -0.08215630f, -0.02347294f, -0.26879564f, 0.18532683f, 
    -0.04244420f, -0.02186204f, 0.07865942f, -0.13314997f, 0.11693833f, -0.29242855f, -0.04483932f, -0.01742452f, 
    -0.41233334f, -0.08366917f, 0.13057339f, 0.01290371f, 0.02156317f, 0.00292195f, -0.24277563f, -0.16247509f, 
    -0.07831075f, -0.00344685f, -0.35542202f, 0.01997746f, 0.17980359f, 0.06584109f, -0.09135079f, 0.34084687f, 
    0.15331116f, -0.21489653f, 0.17711501f, 0.12711726f, -0.02857669f, 0.13079409f, -0.05395139f, -0.02444625f, 
    -0.48141259f, 0.04825725f, -0.14048216f, -0.49976319f, -0.18797690f, 0.22200876f, 0.13271792f, 0.19032407f, 
    -0.11193301f, -0.14322147f, 0.40299210f, -0.00826108f, -0.23421235f, -0.20026940f, -0.18028770f, -0.17469563f, 
    0.05715362f, 0.08072317f, -0.05602233f, 0.09401312f, -0.33404574f, -0.21387658f, -0.23760186f, -0.21612892f, 
    0.04568258f, 0.18684658f, 0.33731860f, 0.16910096f, -0.03600150f, -0.03006415f, -0.09641085f, 0.10329877f, 
    0.07895892f, 0.06749830f, -0.13431965f, 0.09819326f, 0.15592994f, -0.03716372f, -0.10548446f, -0.30186316f, 
    0.08425490f, 0.12248783f, 0.13939101f, 0.28568169f, 0.04440991f, 0.02490474f, -0.13989387f, 0.16793042f, 
    0.06549805f, 0.03402901f, -0.07923450f, -0.10264973f, -0.04972966f, -0.06351716f, -0.13771352f, 0.03659576f, 
    0.00423093f, 0.02847073f, -0.13621551f, -0.05822108f, 0.19399750f, 0.11468575f, -0.56115735f, 0.09758732f, 
    -0.16314872f, 0.14441335f, -0.07851765f, -0.32095021f, 0.13963188f, 0.06965408f, -0.01176588f, -0.03622878f, 
    0.18772371f, 0.00490909f, -0.00200863f, 0.03709082f, -0.09575363f, 0.02233725f, 0.21494877f, -0.20309502f, 
    -0.02029628f, -0.04613925f, 0.06761879f, -0.08675286f, 0.65925652f, -0.14571562f, -0.03016991f, -0.18841930f, 
    -0.06835246f, 0.00399057f, -0.03454251f, 0.02570933f, 0.07143702f, 0.11441802f, 0.01718663f, -0.04599615f, 
    0.09337027f, 0.06577136f, 0.02504374f, -0.16535620f, -0.13344641f, -0.16159205f, -0.19387163f, 0.08408223f, 
    0.04569117f, -0.08577640f, 0.07339818f, 0.00583649f, -0.08183558f, 0.24442370f, 0.06362093f, 0.06858390f, 
    -0.06052541f, -0.00565993f, -0.34681609f, -0.33809009f, -0.02988164f, -0.07540523f, 0.01083691f, -0.12083635f, 
    0.03164204f, 0.11611239f, -0.22457065f, -0.12099066f, -0.06420908f, 0.05795348f, 0.13838096f, 0.16196035f, 
    0.02124642f, 0.09627921f, 0.09189077f, 0.03397212f, -0.04717981f, -0.02830533f, -0.09347911f, -0.03968962f, 
    -0.04368133f, 0.03130202f, 0.01970783f, 0.02426604f, -0.05280297f, 0.08978612f, 0.09713005f, 0.19543096f, 
    -0.37954435f, 0.22555804f, 0.06425653f, -0.04255594f, -0.08682760f, 0.07237737f, -0.06217263f, -0.11204236f, 
    0.22440861f, 0.12010998f, 0.04923994f, -0.11725974f, 1.07332456f, 0.16882065f, 0.30329883f, 0.01634275f, 
    -0.05232200f, 0.01884648f, 0.05517548f, -0.03663518f, 0.16961414f, -0.08585916f, -0.12196628f, 0.29954496f, 
    0.13579515f, -0.23687682f, 0.13374324f, -0.22267771f, -0.29320797f, -0.06474921f, 0.00690194f, 0.10709405f, 
    -0.08807709f, -0.09641609f, -0.05123846f, 0.09535519f, 0.09759960f, -0.22613125f, 0.18207592f, -0.21996734f, 
    0.03811182f, -0.05991388f, -0.13924770f, -0.01283118f, 0.07181320f, -0.15567072f, 0.06872904f, 0.09729125f, 
    0.00758969f, 0.09130161f, 0.10669157f, 0.24688180f, -0.14740787f, 0.16429637f, -0.21975131f, -0.05691256f, 
    -0.01917443f, -0.01854861f, 0.04946498f, 0.04185453f, 0.13824697f, 0.10915633f, -0.01589010f, -0.11630409f, 
    0.07258015f, -0.01534627f, 0.03765059f, 0.22196597f, -0.01486690f, 0.01389103f, -0.06145797f, 0.04476478f, 
    0.22747743f, -0.08809105f, -0.00909302f, 0.05486723f, 0.06026044f, 0.01664857f, 0.12770440f, 0.06208061f, 
    -0.06059081f, -0.02530601f, 0.13812166f, -0.05171265f, -0.51058936f, -0.01131164f, -0.04932101f, -0.55501062f, 
    -0.00864215f, -0.09463342f, -0.03446376f, 0.11827878f, -0.00560007f, -0.00922960f, 0.01580161f, -0.00300166f, 
    -0.04564329f, -0.10874496f, -0.02374617f, -0.44085664f, 0.31621733f, -0.21292242f, -0.17597692f, 0.18104148f, 
    0.28829673f, 0.01329026f, -0.12191672f, -0.12270391f, 0.59198201f, 0.10151718f, 0.11227749f, 0.13683076f, 
    -0.01979688f, -0.10832173f, 0.00891770f, 0.04752088f, 0.02234427f, 0.04010607f, -0.01536676f, -0.04721043f, 
    -0.20309971f, 0.01137119f, -0.11077685f, -0.22027451f, 0.11121011f, -0.05604547f, 0.28072843f, -0.00951675f, 
    -0.05993533f, 0.10296541f, -0.03472068f, 0.05736585f, 0.16325228f, 0.04353524f, 0.00533487f, 0.20841803f, 
    -0.02103391f, 0.06672046f, -0.00995847f, 0.04779267f, -0.17897646f, -0.12172154f, 0.18278432f, -0.37619978f, 
    0.20905265f, 0.20903277f, 0.16050078f, 0.19449611f, -0.04001562f, -0.05080668f, -0.03607870f, 0.01203027f, 
    0.01351409f, -0.03920985f, -0.03681229f, 0.01981664f, 0.56305766f, -0.50220257f, -0.00070500f, -0.59608001f, 
    -0.02185724f, -0.12266514f, -0.00818048f, -0.11373200f, -0.10629515f, 0.03432625f, -0.14502783f, 0.02977816f, 
    -0.16727160f, -0.05749658f, -0.01619252f, 0.01590086f, -0.11277799f, -0.04648100f, 0.02683736f, 0.02360758f, 
    -0.04615182f, -0.10681590f, 0.10037537f, -0.10465862f, -0.26747003f, 0.74167418f, 0.83033925f, 0.20317328f, 
    -0.05747830f, -0.03235779f, 0.31880143f, -0.11366587f, 0.00168176f, -0.06984036f, -0.00872458f, 0.01803604f, 
    0.03325166f, 0.58530259f, 0.08623737f, 0.01513715f, -0.08015385f, -0.19474262f, -0.06468102f, 0.07722314f, 
    0.01185379f, 0.17194146f, -0.47150227f, 0.17885819f, 0.03286065f, -0.10140987f, -0.15772700f, 0.28739217f, 
    0.05968609f, -0.03636347f, 0.03996288f, 0.34017125f, 0.18817173f, 0.12231027f, 0.16913483f, -0.01561724f, 
    0.14135681f, 0.20914733f, -0.01379193f, 0.10297602f, 0.00856586f, 0.10585831f, 0.05512720f, -0.13132299f, 
    0.05687040f, 0.01954862f, 0.07181764f, 0.02679624f, -0.49781510f, -0.34255672f, -0.30383125f, -0.23672442f, 
    -0.08173817f, -0.11247361f, -0.06439107f, 0.04991095f, -0.02890438f, -0.09529905f, 0.04165834f, 0.07298176f, 
    -0.31707540f, -0.24729511f, 0.01269661f, 0.28436252f, 0.19484299f, 0.02187167f, -0.27866232f, -0.15675786f, 
    0.01113265f, -0.11002539f, -0.10459018f, 0.09703451f, 0.40828884f, 0.25300044f, 0.01326903f, 0.52967662f, 
    0.04379177f, -0.05911328f, 0.07641548f, -0.08964700f, 0.00131038f, -0.01412918f, 0.11586373f, 0.12703231f, 
    0.12884443f, -0.05460483f, -0.12648173f, 0.10767335f, 0.08016577f, -0.13100408f, 0.05848051f, -0.03083548f, 
    0.03677695f, 0.07604166f, 0.01763107f, 0.13706537f, -0.36583582f, -0.07189699f, 0.00865744f, -0.34396663f, 
    0.12665038f, 0.14120904f, 0.00773919f, 0.18095137f, -0.01445874f, 0.03815913f, 0.03772261f, -0.07099281f, 
    0.22325623f, 0.32845703f, 0.24504246f, 0.14498606f, -0.01711637f, 0.01195926f, 0.08888254f, 0.02202629f, 
    -0.03645204f, 0.07836885f, -0.03650945f, 0.05789622f, -0.14534491f, 0.30403671f, -0.28574786f, 0.31480488f, 
    -0.19545113f, 0.12942527f, -0.19890589f, -0.22399251f, 0.06991818f, 0.04489820f, -0.04402936f, -0.01465777f, 
    -0.04426377f, -0.05191250f, 0.05078419f, 0.03317105f, 0.10444216f, -0.01129271f, -0.06328810f, 0.12816127f, 
    -0.11534768f, 0.08324502f, -0.10217142f, 0.09514861f, -0.34904903f, 0.66421670f, 0.17032619f, 0.00976931f, 
    0.12480816f, 0.03757055f, -0.18990645f, 0.03860772f, 0.03824146f, -0.06100746f, -0.00964117f, -0.02353019f, 
    -0.57697362f, -0.37933582f, -0.17198215f, -0.33378693f, 0.04255826f, 0.10382073f, 0.18685190f, -0.02732498f, 
    -0.02225108f, 0.03220223f, -0.00672688f, -0.00306497f, -0.09865884f, 0.14284383f, -0.09093353f, 0.30231491f, 
    -0.00577401f, -0.18063053f, 0.18280341f, 0.04711832f, -0.04729991f, 0.11804658f, 0.04961628f, 0.01115706f, 
    -0.10828826f, 0.06281783f, 0.36661020f, 0.05020740f, 0.04954559f, -0.00629988f, -0.09516166f, 0.16992941f, 
    0.07871224f, -0.04880758f, 0.00401805f, -0.02808511f, -0.10721656f, -0.08667628f, 0.03770569f, 0.17142086f, 
    -0.03698920f, 0.00213167f, 0.13513531f, 0.11226474f, -0.14722754f, -0.09816281f, -0.17445892f, -0.09494805f, 
    -0.00429879f, -0.03022464f, 0.08498249f, 0.03559860f, 0.09068438f, -0.03648236f, -0.05859790f, -0.07252419f, 
    -0.08580894f, 0.19554032f, -0.11873186f, 0.10601719f, -0.23055677f, 0.04400500f, 0.06318829f, -0.25135320f, 
    -0.02161581f, 0.01110174f, 0.01913526f, -0.04843532f, -0.01794695f, 0.00199162f, -0.04234901f, 0.08657596f, 
    -0.39271832f, -0.21474729f, 0.10939617f, -0.13495819f, 0.06290827f, 0.07818115f, -0.06024687f, -0.31671700f, 
    0.03904771f, -0.08912518f, 0.03502856f, 0.09301325f, -0.18652490f, 0.09848500f, 0.32040244f, -0.29979908f, 
    0.00870315f, -0.11952713f, -0.53086960f, -0.25447378f, 0.07643811f, -0.08444742f, 0.05232939f, 0.08277234f, 
    -0.18315859f, -0.35956123f, -0.48374671f, -0.11815029f, 0.07752245f, 0.12569843f, 0.01232862f, -0.06998910f, 
    0.01981187f, -0.06674467f, -0.03410617f, -0.02254057f, -0.04840504f, 0.00341409f, 0.01529031f, -0.18152350f, 
    0.05801062f, -0.24039117f, 0.10599554f, 0.05906007f, 0.11886480f, -0.01402887f, -0.06562707f, 0.13703163f, 
    0.14519867f, 0.00415639f, 0.07951487f, -0.22853681f, 0.06702825f, 0.06523790f, -0.06075425f, 0.09628027f, 
    0.00264591f, -0.15814433f, -0.04592434f, -0.15418401f, -0.51941216f, -0.15731822f, -0.07208505f, -0.08204603f, 
    -0.30209279f, -0.16515942f, -0.18726090f, -0.13229586f, 0.09937337f, -0.10467754f, -0.05863144f, -0.00082437f, 
    -0.00431145f, 0.05869434f, -0.00600677f, -0.13424355f, -0.06853490f, -0.07718351f, -0.14163052f, 0.06160645f, 
    0.07983508f, 0.00791172f, -0.11715743f, -0.02324827f, -0.14852521f, 0.00326586f, 0.22077821f, -0.30170521f, 
    -0.01276750f, -0.05576598f, 0.07059370f, -0.00284958f, 0.02677972f, 0.03198408f, 0.01552025f, 0.03671627f, 
    -0.71462929f, -0.27129811f, -0.05786623f, -0.19954337f, -0.00120954f, -0.12257607f, 0.02059419f, -0.32232925f, 
    -0.01933525f, 0.00374628f, -0.00631959f, 0.09541377f, 0.04892140f, -0.11144823f, -0.04961285f, 0.02535253f, 
    0.05796649f, -0.04271863f, 0.04311405f, 0.04783051f, 0.18321013f, 0.10618088f, 0.34565628f, -0.10872227f, 
    -0.30383843f, -0.12242478f, 0.22731604f, -0.22798967f, 0.03855111f, -0.05224789f, -0.03556025f, 0.05753145f, 
    -0.06171039f, -0.07980752f, -0.00852254f, 0.05023643f, -0.15472674f, -0.14997870f, 0.08735726f, -0.30197218f, 
    -0.00721018f, -0.03174171f, -0.04201239f, -0.09340262f, 0.02530506f, 0.00465865f, -0.04409382f, -0.05437661f, 
    -0.22352363f, 0.06303836f, -0.03432890f, 0.04455913f, -0.12646379f, -0.36457744f, -0.22095227f, -0.24018553f, 
    -0.11955979f, 0.27513871f, 0.16700189f, 0.03234987f, 0.15117109f, -0.20810761f, -0.04892552f, 0.28419623f, 
    0.13098334f, -0.04010366f, -0.00784613f, -0.08759955f, 0.05416526f, 0.07915422f, 0.13938656f, 0.14380310f, 
    0.32115653f, 0.03491538f, -0.00784954f, 0.43335432f, -0.11253321f, -0.05184545f, 0.00637628f, 0.03607630f, 
    -0.04435156f, -0.06156885f, -0.06169419f, 0.18729988f, -0.26957837f, 0.39039001f, -0.45312801f, -0.43681523f, 
    0.14659388f, 0.07320309f, -0.02329145f, -0.01706547f, -0.14135320f, -0.03681765f, -0.15486878f, -0.03631696f, 
    1.37376046f, -0.03190447f, 0.08249553f, 0.13160430f, 0.03013268f, 0.03605843f, 0.09043556f, -0.04766423f, 
    -0.20785508f, -0.29852512f, -0.01353473f, 0.04197885f, -0.03880817f, -0.05570984f, -0.14027849f, 0.08072118f, 
    0.02880002f, 0.09583944f, 0.03913512f, 0.08248076f, -0.08959005f, 0.05973273f, -0.07102329f, -0.05477004f, 
    0.10577524f, -0.11348622f, -0.04105279f, 0.05528895f, -0.08274199f, -0.01706414f, -0.02461063f, -0.03367437f, 
    0.08803377f, 0.09603319f, -0.12979335f, 0.09687447f, 0.33649236f, -0.13048857f, 0.04612047f, 0.27727240f, 
    0.04739824f, -0.03795834f, -0.13268021f, -0.08859778f, -0.02751727f, 0.07650152f, -0.03542441f, 0.12366718f, 
    -0.83908725f, 1.05390537f, -0.36835694f, -0.44984016f, -0.02652481f, -0.05011686f, -0.14067751f, -0.05337954f, 
    -0.01031523f, 0.03847670f, 0.00313745f, -0.13781491f, -0.23329964f, 0.07925239f, -0.10861173f, 0.05586462f, 
    0.07082274f, -0.02396357f, -0.12234232f, -0.04702001f, -0.10713165f, 0.06042571f, 0.13257428f, 0.03036848f, 
    0.69222045f, -0.23646463f, -0.02915741f, 0.16776313f, 0.22372949f, 0.10264689f, 0.13273251f, -0.00012723f, 
    -0.17522499f, -0.04760854f, -0.05356229f, -0.04729065f, -0.68397784f, 0.18267502f, -0.00587014f, 0.22953933f, 
    -0.02529670f, -0.19290283f, 0.12483621f, -0.19307610f, -0.11572789f, 0.00782693f, -0.18128440f, -0.04952339f, 
    0.07245354f, -0.25780475f, 0.28860387f, -0.26750904f, -0.19846612f, -0.18848149f, -0.33984187f, -0.06949756f, 
    -0.00634936f, -0.03349360f, 0.01903991f, -0.11889839f, -0.28872266f, -0.00429203f, -0.02124948f, 0.44498122f, 
    0.06471242f, -0.01007563f, -0.17306548f, -0.10161487f, -0.08771613f, -0.00703652f, 0.28913713f, -0.04608628f, 
    -0.17689250f, -0.01277497f, -0.05405854f, 0.30267581f, -0.06981921f, -0.01702662f, 0.10285719f, -0.00202849f, 
    -0.02709383f, 0.07769430f, -0.11712144f, 0.02154943f, 0.19562228f, -0.23624386f, -0.12633736f, 0.01020952f, 
    0.07487223f, -0.05819998f, 0.18077183f, -0.13565765f, -0.05374209f, 0.01353858f, 0.06545404f, 0.21495155f, 
    -0.35747528f, 0.16690966f, -0.17716916f, 0.10794193f, -0.06810899f, -0.15311526f, -0.00874955f, -0.14352852f, 
    -0.10005414f, 0.10474426f, -0.09243213f, 0.05829539f, 0.09075871f, 0.01143798f, -0.16803524f, -0.31777573f, 
    0.29022118f, 0.15644997f, 0.11395150f, -0.16877982f, -0.19529670f, 0.06376971f, -0.09840846f, 0.04704571f, 
    -0.51422918f, -0.38657260f, 0.08414102f, -0.29988250f, -0.07809944f, 0.11529468f, -0.37472472f, -0.24866478f, 
    0.06425363f, -0.03596660f, -0.05436236f, -0.11285198f, -0.35749432f, -0.13748139f, -0.07393911f, 0.05676328f, 
    0.11050473f, 0.04645049f, 0.24358627f, 0.09771552f, -0.12292770f, 0.14416198f, 0.11976189f, 0.05197381f, 
    0.06264319f, -0.14122280f, 0.26900718f, 0.17691480f, 0.09063614f, 0.00612254f, 0.04886685f, 0.01830202f, 
    0.02016892f, 0.02362007f, -0.02613934f, 0.17512435f, -0.63244206f, 0.21154520f, 0.47584620f, -0.06943642f, 
    -0.16571541f, 0.13687444f, -0.22407140f, 0.01848501f, 0.11200039f, 0.10682771f, 0.14084870f, -0.09036218f, 
    0.05521972f, -0.07823846f, -0.09869382f, 0.15338609f, 0.06746697f, 0.07015452f, 0.02958671f, 0.14651121f, 
    -0.03820940f, 0.05348344f, -0.09764048f, -0.16747212f, -0.15472901f, 0.29723039f, -0.13933973f, 0.05550757f, 
    -0.38288882f, 0.13943423f, -0.14659664f, -0.15971719f, 0.11961198f, -0.09324234f, -0.07590734f, -0.02439529f, 
    0.07211842f, 0.01672300f, -0.08019314f, 0.51320285f, 0.03946125f, 0.03125497f, -0.12256268f, -0.10080244f, 
    -0.06447096f, -0.12420341f, 0.05864417f, -0.05828310f, 0.43340418f, 0.06253277f, 0.26963991f, -0.25309277f, 
    -0.09633496f, 0.02521484f, -0.07796440f, 0.06333873f, -0.01237516f, -0.00299602f, 0.00509282f, -0.07150493f, 
    -0.10934865f, 0.13970019f, 0.31342593f, 0.54653478f, -0.09769339f, 0.01809375f, 0.11410332f, -0.03853236f, 
    0.09868554f, 0.12691399f, 0.01098298f, 0.10319268f, -0.37923667f, 0.01195449f, 0.51060790f, -0.13204736f, 
    -0.19539587f, -0.23171632f, -0.21083568f, -0.19984230f, 0.03393533f, -0.12078281f, -0.09300476f, 0.10658324f, 
    0.11080072f, -0.30155116f, 0.10125022f, -0.00920863f, -0.11687016f, -0.04877273f, -0.00216075f, 0.12098081f, 
    -0.13142174f, -0.07213408f, -0.01498086f, -0.08545131f, -0.24674323f, 0.57429558f, -0.58736241f, -0.30590001f, 
    -0.01293805f, 0.04679322f, 0.03196975f, 0.02625906f, -0.13590795f, -0.25996569f, 0.03079761f, -0.10975212f, 
    -0.45379087f, -0.26131803f, -0.18344414f, -0.13657546f, -0.34164891f, -0.40602872f, -0.25549108f, -0.02732448f, 
    -0.06627163f, 0.10634118f, 0.03745366f, 0.00872978f, -0.06359259f, -0.27365249f, 0.41193637f, 0.25874451f, 
    -0.13181803f, 0.00374806f, 0.06304821f, 0.11411943f, 0.09788746f, 0.14657217f, -0.00680201f, 0.06531575f, 
    0.03085154f, 0.00001710f, 0.16328213f, 0.13770270f, 0.17885053f, 0.11371495f, 0.05773187f, 0.21243496f, 
    0.11000066f, -0.12408660f, -0.07032444f, -0.01882857f, -0.13238776f, -0.02429873f, 0.22305743f, 0.18924864f, 
    -0.21202345f, -0.02517151f, -0.13449018f, -0.04960229f, -0.03962048f, 0.07100189f, -0.05938746f, -0.02831915f, 
    -0.25420424f, 0.05600360f, -0.45619118f, 0.04635596f, 0.19918856f, -0.45451486f, -0.10291623f, -0.06054254f, 
    -0.02453127f, -0.02120823f, 0.16454038f, -0.19558248f, -0.03712364f, -0.40626314f, 0.12606786f, 0.29633838f, 
    -0.18444939f, 0.03797928f, -0.23778884f, -0.08522879f, -0.29434553f, 0.04772561f, 0.07783395f, 0.04051656f, 
    -0.14196622f, 0.00226270f, -0.07225725f, -0.12122712f, -0.01250252f, -0.23690511f, -0.00735649f, 0.06632841f, 
    0.15214096f, 0.02172765f, 0.10206904f, 0.13125117f, -0.14231272f, -0.08709629f, 0.09296694f, 0.03896525f, 
    0.02604193f, -0.01094174f, -0.10711963f, -0.03696582f, -0.06797509f, -0.01857100f, 0.13712579f, 0.02450676f, 
    0.07291391f, -0.10240568f, 0.15326042f, 0.09038614f, 0.01528794f, -0.13480584f, 0.00570076f, -0.15633412f, 
    -0.16428259f, -0.01200685f, -0.26529941f, -0.23288855f, 0.10500867f, 0.01087070f, 0.04122657f, 0.21164228f, 
    -0.06078129f, -0.12743419f, -0.05750384f, -0.09638853f, 0.25936562f, -0.05329371f, 0.14269398f, 0.23024200f, 
    -0.28976116f, -0.50972521f, -0.03425999f, -0.54728854f, 0.09147101f, -0.01093285f, 0.03993626f, 0.08978757f, 
    0.03317041f, -0.27625012f, -0.17776249f, -0.06516869f, 0.14017417f, -0.06653701f, 0.07145582f, 0.15073991f, 
    0.04154073f, -0.19005051f, -0.21862085f, -0.23551583f, -0.10967254f, -0.00172099f, 0.00203154f, -0.09850713f, 
    0.05683753f, 0.16740531f, -0.04943573f, 0.03252994f, -0.03757163f, -0.01018901f, 0.07664724f, 0.01560247f, 
    0.05966611f, -0.12708436f, 0.12070972f, 0.08782334f, 0.27416641f, -0.05057398f, 0.24906287f, -0.35028747f, 
    -0.18082297f, 0.13606340f, 0.06247670f, 0.01063759f, -0.15053564f, -0.01959563f, -0.06184229f, -0.10866855f, 
    -0.02633805f, 0.08046976f, -0.04326119f, -0.02811090f, -0.03703165f, 0.15253253f, -0.11400539f, 0.03861913f, 
    0.02426052f, -0.05984795f, -0.17152962f, -0.09988226f, -0.27013338f, 0.11110460f, 0.07313883f, 0.00264394f, 
    -0.02824721f, -0.09641510f, 0.02279246f, -0.16303761f, -0.04764954f, -0.20277500f, -0.13045748f, 0.17242727f, 
    0.00942035f, 0.19666743f, 0.14061888f, 0.21938403f, 0.01751561f, 0.00360615f, -0.08537640f, 0.16211666f, 
    0.06495932f, 0.07537333f, -0.03005915f, -0.05397502f, -0.11369912f, -0.05078038f, 0.04837490f, 0.16585682f, 
    -0.08017732f, 0.03508006f, -0.13526361f, -0.01342818f, 0.09769695f, 0.00560696f, -0.02064500f, 0.12821504f, 
    -0.12533499f, -0.24176942f, 0.07870257f, -0.04275185f, -0.23178415f, 0.08050969f, -0.00816427f, -0.02596560f, 
    -0.02041481f, -0.14877896f, -0.15718126f, -0.06504915f, 0.26421446f, 0.15259111f, -0.05064656f, 0.06628976f, 
    -0.00284343f, -0.04941791f, -0.07815170f, 0.04381998f, 0.06507058f, -0.19274095f, -0.32810006f, 0.01495296f, 
    -0.14028209f, 0.00999674f, -0.12832452f, -0.01018758f, 0.04230699f, -0.19083592f, 0.10521504f, -0.03570231f, 
    -0.16975041f, -0.09733675f, -0.31375715f, 0.16302744f, -0.35427615f, -0.14361241f, -0.41785437f, -0.17062260f, 
    0.06555915f, 0.06942729f, 0.08010938f, 0.10607816f, -0.20831335f, 0.10341049f, -0.03287730f, -0.13335702f, 
    0.10110839f, 0.44866422f, -0.01285665f, 0.15183680f, 0.00067536f, 0.03678209f, 0.13921604f, 0.27344427f, 
    0.07771555f, -0.02289595f, 0.02185392f, -0.19281550f, 0.18093018f, 0.11190889f, -0.16150002f, 0.21134552f, 
    0.01330343f, 0.07889527f, -0.03382161f, -0.20115913f, 0.09217536f, -0.00364644f, -0.12843746f, -0.05324745f, 
    0.12833384f, 0.25993425f, 0.31191653f, 0.27876469f, -0.21949242f, -0.15152520f, 0.05808152f, 0.10650495f, 
    0.09720923f, 0.05771654f, 0.01204171f, 0.00736787f, 0.01930249f, 0.07865419f, 0.00692815f, 0.14816086f, 
    0.24013308f, -0.02936822f, -0.00040721f, -0.31409326f, 0.14555614f, -0.08770822f, -0.02662685f, -0.00217608f, 
    -0.07797421f, 0.12707849f, -0.06495415f, -0.04893788f, 0.03358933f, -0.04175586f, -0.19318400f, 0.20941396f, 
    -0.11157504f, -0.05981746f, -0.09343198f, -0.07930689f, -0.42757905f, 0.01100464f, -0.18713221f, 0.63742000f, 
    -0.07945044f, 0.19133240f, -0.15319717f, -0.00659946f, 0.00861095f, -0.00100668f, 0.00150146f, 0.03725362f, 
    0.17546143f, 0.13607825f, -0.20347926f, 0.12341858f, 0.11104932f, -0.07932355f, -0.15248471f, 0.01595023f, 
    -0.16469808f, 0.10273019f, -0.01835714f, 0.05078997f, -0.16969137f, -0.16811366f, -0.41178349f, 0.36149484f, 
    0.00074006f, 0.08308699f, 0.06761249f, -0.08978142f, -0.12274016f, -0.06118021f, 0.05378087f, 0.04758384f, 
    0.03207371f, 0.27012014f, 0.16017045f, 0.21567933f, 0.09669204f, -0.07998475f, -0.05433565f, 0.19013071f, 
    -0.04724882f, -0.06341277f, 0.03455031f, -0.16628240f, -0.40980166f, -0.33035448f, 0.30952558f, 0.01295961f, 
    0.00721487f, 0.00423292f, -0.00677126f, 0.07758207f, -0.19182478f, 0.19982745f, -0.09320463f, 0.38121948f, 
    0.01545812f, -0.00614296f, -0.03364467f, 0.05198936f, 0.18045980f, 0.07919088f, 0.05434303f, 0.02733319f, 
    0.05324632f, 0.06898200f, -0.02230490f, -0.06026353f, 0.20533425f, 0.62537736f, -0.09552613f, 0.11565057f, 
    0.06348361f, -0.04738354f, 0.12578478f, 0.10398281f, 0.00918864f, 0.05290755f, 0.06661900f, 0.00562740f, 
    -0.05884745f, -0.17608728f, -0.00368445f, 0.05401882f, 0.10374229f, 0.05368510f, -0.01873645f, -0.03294588f, 
    0.06635255f, -0.01401097f, 0.04491810f, 0.06200974f, -0.23953493f, -0.01225394f, -0.31230038f, -0.20265643f, 
    0.00184850f, -0.03750630f, 0.00995420f, 0.02093787f, 0.02731883f, -0.11954924f, 0.01963850f, 0.02968794f, 
    0.16364904f, 0.09963214f, -0.57365805f, -0.20348144f, -0.16110240f, 0.17844322f, -0.10604681f, 0.02858583f, 
    0.02540545f, -0.15414900f, 0.15095094f, 0.14945886f, -0.07761970f, -0.01427776f, 0.45467204f, -0.31588361f, 
    -0.09720117f, -0.07928589f, -0.00109152f, 0.18908925f, -0.07523199f, 0.03455594f, -0.04769506f, 0.06826396f, 
    0.05387706f, -0.08461080f, -0.19335322f, 0.02454309f, 0.03562324f, -0.21066353f, -0.05174399f, 0.19207378f, 
    -0.04437841f, -0.16024211f, 0.10063558f, 0.05653874f, -0.06422918f, 0.32223111f, 0.40089265f, -0.22469972f, 
    0.01628797f, 0.08202979f, 0.04665881f, -0.01788538f, 0.11647455f, -0.01498925f, 0.07407575f, -0.04652762f, 
    0.53973782f, 0.10034041f, 0.24190640f, -0.05919447f, -0.02076757f, -0.07682981f, 0.04630094f, 0.21937260f, 
    0.19534674f, 0.02347241f, -0.06969063f, -0.07414127f, -0.55504000f, 0.13269536f, -0.10339226f, -0.22640508f, 
    0.02153135f, -0.05459537f, 0.06427362f, -0.03998018f, 0.04993420f, -0.18717356f, -0.10548403f, -0.29632354f, 
    0.62269074f, -0.38778365f, -0.08394434f, 0.14336731f, 0.06342194f, -0.01558744f, 0.13865934f, -0.07259037f, 
    -0.17454354f, 0.07715773f, 0.30618006f, 0.06629474f, -0.15794478f, 0.31485537f, 0.18293537f, 0.07059171f, 
    -0.12539026f, 0.16774939f, 0.29503021f, -0.09823720f, 0.14272450f, -0.01799808f, 0.07419940f, 0.10122206f, 
    -0.71464956f, -0.24363400f, -0.33217135f, -0.07230166f, -0.02311248f, -0.06610303f, 0.04443379f, 0.00772989f, 
    0.20043321f, -0.15003431f, 0.02195125f, -0.02891775f, 0.21157753f, -0.24043025f, 0.27719441f, -0.03726853f, 
    0.25785542f, 0.09880564f, -0.10303745f, 0.10299336f, 0.10791172f, -0.06872030f, 0.08175473f, 0.21131541f, 
    -0.15520222f, -0.11087242f, -0.12623021f, 0.00660244f, 0.16436864f, -0.11911869f, -0.06277904f, 0.22458756f, 
    0.00406682f, 0.15020375f, -0.01843707f, 0.34836733f, -0.11155446f, -0.16729286f, -0.54495144f, -0.37024695f, 
    -0.03880339f, 0.10276531f, 0.05228746f, 0.09960291f, 0.10212156f, -0.03511225f, 0.14194636f, -0.03233024f, 
    0.11989767f, 0.17734298f, 0.03419802f, -0.16489445f, 0.09320313f, 0.13241717f, 0.15323734f, -0.10554546f, 
    -0.06332295f, 0.13106078f, 0.14259674f, 0.05693034f, -0.06717699f, -0.09280878f, 0.05394030f, -0.10383926f, 
    -0.02475577f, -0.16151762f, 0.06411356f, 0.16431734f, -0.07863399f, -0.06310995f, -0.09197341f, -0.09525605f, 
    0.23452447f, -0.32584867f, 0.04453624f, -0.16502391f, 0.08238883f, 0.10206880f, 0.00913321f, -0.17071837f, 
    0.06897326f, 0.03370774f, 0.11914077f, -0.09102607f, -0.31286797f, -0.42584464f, 0.22013612f, 0.22558369f, 
    -0.07777811f, -0.05609588f, -0.11075704f, -0.02902263f, 0.21430923f, 0.11986206f, 0.23275545f, -0.13031223f, 
    0.66652691f, -0.17086107f, 0.07776669f, 0.03583430f, 0.04195520f, -0.03970181f, 0.11622410f, 0.48876941f, 
    -0.08568037f, 0.06571689f, 0.02441099f, -0.15170611f, -0.16783878f, -0.11052447f, -0.60932785f, -0.04292828f, 
    0.00221300f, -0.07220025f, -0.03988269f, -0.04072733f, 0.23781735f, -0.37388214f, -0.10270289f, -0.10832601f, 
    -0.13084351f, 0.16788559f, -0.09212768f, -0.30076998f, 0.24253660f, 0.02266716f, -0.14121848f, -0.17170392f, 
    -0.01185248f, 0.00865403f, 0.03811243f, -0.08178110f, 0.09506397f, 0.11540192f, -0.52836192f, 0.21892066f, 
    -0.00060055f, 0.05290863f, 0.16286968f, 0.07659269f, -0.10191831f, 0.07714310f, -0.03727388f, -0.20676051f, 
    -0.02249723f, -0.08419371f, 0.11835992f, -0.09453868f, 0.39325917f, 0.22540867f, 0.03367546f, -0.04521279f, 
    0.10308553f, 0.00255073f, 0.01177729f, 0.13454904f, -0.10714702f, -0.21361868f, -0.07933881f, -0.00195408f, 
    -0.24875091f, 0.01130050f, 0.00832082f, 0.24143602f, -0.02118427f, 0.28040984f, 0.27725753f, -0.17711490f, 
    -0.08415449f, 0.14937013f, -0.05300544f, -0.39684197f, -0.10976356f, -0.00075733f, -0.14670934f, -0.32701865f, 
    0.29043838f, 0.14043285f, -0.08004683f, 0.21409704f, 0.11077550f, -0.10678227f, -0.00607999f, 0.41521266f, 
    0.20446645f, 0.09817920f, -0.02783940f, 0.06299527f, 0.01925602f, 0.07202940f, -0.00080578f, -0.03338570f, 
    -0.23971616f, -0.03164297f, -0.03063445f, -0.08120010f, -0.14516568f, -0.05784967f, -0.06615263f, -0.14293091f, 
    -0.28564650f, -0.17776951f, -0.17179099f, -0.18007044f, -0.46441999f, -0.04676089f, -0.03164144f, -0.13882822f, 
    0.13280451f, 0.01182833f, -0.05149863f, 0.04975965f, -0.02064878f, 0.00991717f, 0.00653399f, 0.01809072f, 
    0.26760873f, 0.05568643f, -0.04228591f, 0.11233196f, -0.05074849f, 0.28418878f, -0.27816835f, -0.12142871f, 
    0.13923855f, -0.10190329f, 0.08365084f, 0.17211080f, -0.05430543f, -0.12341866f, 0.00099241f, -0.17685074f, 
    -0.00405712f, -0.09353090f, 0.04915047f, 0.00488447f, -0.16080780f, -0.13679631f, -0.57936847f, -0.33759290f, 
    -0.21556415f, -0.25226983f, -0.13684785f, 0.10773531f, 0.09450432f, 0.06358325f, -0.03470740f, -0.04318105f, 
    0.06213503f, -0.06524710f, -0.00942198f, 0.02652549f, -0.01897236f, -0.11604124f, -0.37863776f, -0.03202271f, 
    0.11798827f, 0.21827859f, -0.03068843f, 0.16898714f, 0.04513639f, -0.10553977f, 0.01111640f, -0.23085104f, 
    -0.24950364f, -0.27538317f, -0.35040206f, -0.15254745f, -0.02478472f, 0.00864808f, 0.00182756f, -0.02451543f, 
    -0.02463921f, 0.01540670f, -0.19606994f, -0.05491083f, -0.89886349f, -0.09310924f, 0.14491765f, 0.55733460f, 
    -0.24052203f, -0.19748305f, -0.21062620f, 0.18968236f, 0.02957197f, 0.00490050f, 0.09045923f, -0.18013045f, 
    0.45024487f, -0.08687279f, 0.18513815f, 0.31189442f, 0.19568674f, 0.01313352f, 0.02819942f, 0.03388059f, 
    0.10758130f, 0.01007884f, 0.25684169f, -0.19257541f, -0.12814569f, 0.08459835f, 0.23556443f, 0.13876750f, 
    -0.12876138f, -0.00963990f, 0.09110742f, 0.05260975f, 0.14246146f, 0.27608386f, 0.12194327f, 0.09897144f, 
    0.19183871f, 0.09645586f, -0.09533847f, 0.12099181f, -0.33072436f, 0.04727585f, 0.16489463f, 0.33325371f, 
    0.13489310f, 0.03501317f, 0.18362324f, 0.00760359f, -0.29321745f, -0.83909380f, -0.62959349f, -0.18247493f, 
    -0.14898103f, -0.04107757f, -0.17438899f, -0.09425975f, -0.05222342f, 0.02032563f, 0.08443080f, -0.00635826f, 
    -0.02241670f, -0.27767247f, 0.13137059f, -0.14246042f, 0.04350414f, 0.09887117f, 0.10091308f, -0.05889107f, 
    0.09235255f, 0.07797656f, -0.01290673f, -0.16689244f, -0.14886557f, 0.27063859f, 0.21688193f, -0.15953675f, 
    -0.00699175f, 0.02309634f, 0.05691906f, 0.06688149f, 0.18194340f, 0.20261641f, 0.11058857f, 0.05096623f, 
    0.14740729f, 0.14048117f, -0.15090382f, -0.13499737f, 0.04329419f, -0.02367870f, -0.13065627f, 0.09920411f, 
    0.02217673f, -0.01369235f, 0.01801967f, -0.08868998f, -0.32201228f, -0.66325343f, 0.39315549f, 0.01728676f, 
    -0.07195974f, -0.57323903f, -0.08632790f, -0.39805552f, -0.12756206f, -0.00285767f, 0.03209525f, -0.09309185f, 
    -0.07733714f, 0.00302185f, 0.23188925f, 0.21716368f, -0.02437748f, 0.03394808f, 0.03123313f, -0.07649655f, 
    -0.06117395f, 0.01141062f, 0.15483664f, 0.07606313f, -0.43744048f, -0.08124033f, -0.41122279f, 0.24251819f, 
    -0.10905020f, 0.09387787f, 0.28544092f, 0.27933279f, 0.01433516f, -0.08481727f, 0.05501370f, 0.00158339f, 
    0.19055766f, -0.11394432f, -0.11398746f, 0.11837548f, -0.13618514f, 0.08225892f, 0.16195624f, -0.15441883f, 
    -0.04791265f, -0.19429894f, -0.04566672f, -0.08684575f, 0.45117733f, 0.44037846f, -0.00827781f, 0.07723337f, 
    0.07397959f, 0.01212445f, 0.02984116f, -0.23709303f, 0.15166825f, 0.03510290f, -0.16937484f, 0.17978215f, 
    -0.65392077f, -0.50053549f, -0.59384316f, 0.11974696f, -0.11724287f, -0.04669017f, 0.10115807f, -0.31584319f, 
    0.06047811f, 0.03354526f, -0.06378953f, 0.02314504f, -0.35424483f, -0.26053554f, -0.15582566f, 0.10824347f, 
    -0.25338906f, 0.36384720f, -0.01476911f, 0.04545472f, 0.02330692f, -0.03692265f, 0.04231519f, -0.05023776f, 
    -0.55877644f, 0.52692485f, -0.05975318f, 0.12617791f, -0.09589674f, 0.10119592f, -0.15176158f, 0.18504944f, 
    0.09590926f, -0.01121207f, 0.07073028f, 0.05272591f, -0.28371119f, 0.18234205f, 0.19273369f, 0.14463119f, 
    -0.00977732f, -0.02822236f, -0.14373915f, 0.10565551f, -0.06456438f, 0.05714924f, 0.10350260f, -0.08196089f, 
    0.15748928f, -0.12277044f, -0.05249368f, 0.16571297f, -0.05470209f, -0.00695884f, 0.07665864f, 0.22988333f, 
    0.02622794f, -0.05312276f, 0.04084634f, 0.05161865f, -0.18816890f, -0.15431327f, -0.05961667f, 0.10698987f, 
    0.02260773f, -0.00533918f, 0.02125261f, 0.00869178f, -0.10813172f, 0.18373196f, 0.18111221f, 0.05193618f, 
    0.00758461f, -0.48326561f, -0.13427854f, -0.42509022f, 0.12618481f, 0.04638116f, 0.08096692f, -0.28329563f, 
    0.11174077f, 0.08608561f, 0.02227045f, -0.06788188f, 0.51719445f, -0.04409429f, -0.23536441f, -0.35436893f, 
    -0.08667155f, 0.05509677f, 0.32067931f, 0.09337655f, 0.03924492f, 0.13040280f, 0.04966776f, 0.00030100f, 
    -1.16028249f, -0.56084210f, -0.39884913f, -0.63775724f, -0.25530759f, -0.41672593f, -0.07994803f, -0.22075444f, 
    -0.06472946f, -0.03524230f, -0.05321977f, -0.07042242f, -0.03127656f, -0.06326012f, -0.01017877f, 0.03772483f, 
    0.05445116f, 0.14311996f, 0.05817893f, -0.21854393f, 0.01610778f, -0.23374228f, -0.00180016f, -0.03917648f, 
    0.05696453f, 0.25649688f, -0.09388904f, -0.19629243f, 0.10621500f, -0.30484009f, 0.01602423f, 0.04307750f, 
    0.06922953f, -0.08021378f, -0.00517034f, -0.10027406f, 0.36401457f, -0.32862630f, -0.77244323f, -0.21717107f, 
    -0.17639187f, 0.18246166f, 0.23800299f, 0.05501476f, -0.08388248f, 0.07157460f, -0.24138598f, -0.11823317f, 
    -0.22298448f, -0.22299153f, -0.16936350f, 0.12492201f, 0.15075503f, 0.28107217f, 0.13270722f, -0.21050760f, 
    -0.06419696f, 0.01454095f, 0.19409314f, 0.10323109f, -0.12267862f, -0.37409610f, -0.22451931f, 0.29662955f, 
    0.09736600f, 0.05727327f, 0.00861064f, -0.02418150f, -0.04119518f, -0.08128925f, 0.07503799f, 0.04146808f, 
    -0.20190878f, -0.46415719f, -0.28578183f, -1.02127659f, -0.04319568f, -0.08145379f, 0.14527683f, -0.16793922f, 
    0.04202846f, 0.14816760f, 0.05867421f, -0.08525982f, 0.00285830f, -0.02686062f, 0.00811357f, 0.07105654f, 
    -0.01000968f, -0.00758822f, -0.06486914f, 0.14837818f, 0.31075639f, 0.09300689f, 0.20139575f, 0.21090870f, 
    0.18629494f, -0.01289169f, -0.10225034f, -0.12577619f, -0.10262325f, 0.08396126f, 0.10210557f, -0.05894933f, 
    -0.14529935f, -0.12677412f, -0.15875635f, -0.12375391f, -0.52459592f, -0.58458441f, 0.21709126f, -0.31603205f, 
    0.02642227f, 0.07190312f, 0.17468005f, -0.44648537f, 0.06154745f, 0.00057859f, 0.15373951f, 0.15825933f, 
    0.08690459f, 0.02057331f, 0.06982121f, -0.03354663f, -0.00536960f, -0.07651693f, 0.00969824f, -0.03726381f, 
    0.01573090f, 0.02883471f, -0.01656209f, -0.05181672f, -0.21365441f, -0.72818518f, -0.64061207f, -0.54742575f, 
    -0.02680040f, -0.22195183f, 0.18403623f, 0.17375022f, 0.09299482f, 0.09870081f, 0.04983867f, -0.00226315f, 
    -0.48691937f, 0.22795999f, 0.28897098f, 0.15678617f, 0.00305396f, 0.21768022f, 0.18277907f, 0.11525940f, 
    0.11070779f, -0.00437019f, -0.03945913f, -0.16697793f, 0.49223405f, 0.05847059f, -0.05109320f, -0.44538847f, 
    0.01316632f, 0.18702233f, -0.17204791f, 0.02913536f, -0.04009040f, -0.10147284f, -0.05740908f, -0.02743839f, 
    0.02550254f, 0.04766220f, -0.01517696f, 0.04258757f, -0.17354743f, 0.17433503f, -0.06720486f, -0.45497066f, 
    0.06702790f, -0.01268276f, -0.01826348f, 0.06107925f, -0.16227500f, -0.52105641f, 0.33909696f, 0.34392622f, 
    -0.03839823f, -0.04947319f, -0.10206929f, 0.16606906f, -0.01433969f, -0.17829883f, -0.10136583f, -0.05233555f, 
    0.23560140f, -0.62278497f, 0.22053476f, -0.02361503f, 0.08054806f, 0.05069873f, -0.00397624f, 0.02412900f, 
    0.10120724f, 0.13090724f, -0.14712006f, 0.13334809f, 0.62219208f, -0.50480729f, -0.49360919f, -0.22720307f, 
    -0.11424706f, 0.00471495f, 0.06040645f, 0.04491063f, 0.25044847f, 0.01440445f, -0.06450519f, 0.03944729f, 
    -0.07986178f, -0.11932846f, -0.12954076f, -0.07403205f, -0.00247741f, 0.00769743f, -0.03687325f, -0.05039552f, 
    0.01931712f, -0.00073023f, -0.20259158f, -0.18315826f, -0.33382583f, -0.28107300f, 0.31296906f, -0.20562519f, 
    -0.18534645f, -0.01713980f, -0.05216495f, 0.19870961f, 0.03262578f, -0.06551795f, -0.01028023f, -0.00288510f, 
    0.37947333f, -0.26492876f, 0.06700010f, -0.14657257f, 0.00022658f, -0.07583755f, -0.01508024f, -0.04018857f, 
    0.05818665f, -0.17592545f, 0.00136413f, -0.15957518f, -0.26738331f, -0.39581153f, 0.39027929f, -0.52564257f, 
    -0.04344372f, -0.13838910f, 0.01453064f, 0.02168474f, -0.09349363f, 0.04644065f, -0.13731840f, -0.14227532f, 
    -0.07568951f, 0.07938465f, -0.05816575f, 0.01154024f, 0.05909742f, 0.04051406f, -0.13094439f, -0.09245016f, 
    -0.07168224f, 0.08949471f, -0.05690617f, -0.01368780f, -0.17889926f, 0.03922172f, -0.03127746f, 0.09820937f, 
    -0.07898387f, -0.12262606f, 0.12891841f, -0.08454534f, -0.01853871f, -0.09685752f, 0.15569381f, -0.08428470f, 
    -0.20875558f, -0.21866861f, -0.11777963f, -0.17119734f, 0.15657070f, -0.10088988f, -0.00606026f, 0.11685139f, 
    -0.01567858f, -0.02584172f, -0.05513950f, 0.05227369f, 0.12239898f, -0.30019507f, -0.30086860f, -0.26372486f, 
    0.09724658f, 0.32427692f, 0.14414780f, 0.07367862f, 0.05109731f, 0.00074348f, -0.09593787f, 0.03014095f, 
    0.10473344f, -0.59982079f, 0.03284001f, -0.35008392f, -0.17109571f, -0.13279465f, 0.01522426f, 0.05458159f, 
    -0.06775739f, -0.00004634f, 0.05366365f, 0.00319858f, 0.39200711f, 0.04874023f, -0.26083112f, -0.39452767f, 
    0.06233506f, -0.00694427f, -0.04117190f, -0.04232730f, -0.01604096f, -0.11910352f, -0.21370853f, -0.06948219f, 
    0.19115600f, -0.08365544f, 0.14140265f, -0.16492166f, -0.07094535f, 0.02696715f, -0.24322882f, -0.10990052f, 
    -0.27041954f, -0.06321751f, 0.08544115f, -0.10836772f, -0.04668412f, 0.07447974f, 0.13619609f, 0.05865100f, 
    0.09907446f, 0.01452086f, 0.02806365f, -0.06191337f, -0.03054185f, -0.22195855f, 0.01950692f, -0.06732681f, 
    -0.54354769f, 0.23530190f, -0.09747715f, 0.30472124f, -0.10442957f, -0.03542436f, 0.04655977f, 0.00912257f, 
    0.01107164f, 0.07070316f, 0.07661299f, 0.04606934f, -0.18067074f, 0.20395263f, -0.11160376f, -0.00897944f, 
    0.01776291f, 0.05340658f, 0.05887431f, 0.16037689f, -0.00171258f, 0.12212510f, 0.10262765f, 0.03723098f, 
    -0.49698201f, -0.54483223f, -0.40536898f, 0.43349805f, 0.01789026f, -0.05136886f, 0.05051068f, -0.03962385f, 
    0.05117407f, 0.13259214f, -0.01892124f, -0.00921756f, -0.02719798f, 0.07358111f, 0.06028758f, -0.05634546f, 
    -0.09429040f, -0.15678459f, -0.04176415f, -0.01309507f, -0.06962408f, -0.03678131f, 0.10210263f, 0.05534918f, 
    -0.22674671f, 0.01627083f, 0.06550622f, 0.07906020f, -0.04188351f, 0.12324258f, 0.17906217f, -0.03110832f, 
    -0.00107670f, 0.05086771f, -0.01208071f, 0.06373992f, -0.14390869f, -0.43230912f, -0.03614945f, 0.19942889f, 
    -0.06701262f, 0.07771367f, 0.04619108f, 0.05264311f, 0.06454597f, -0.03030751f, 0.03104593f, 0.01775319f, 
    0.00840414f, -0.13714926f, 0.01579534f, 0.05726191f, -0.24015073f, 0.07701506f, 0.22815186f, 0.05056074f, 
    0.02490177f, -0.10554370f, 0.15792789f, 0.16291022f, -0.12335185f, 0.00124429f, 0.08238003f, -0.07234772f, 
    -0.03867551f, -0.01000555f, -0.13204077f, 0.00081417f, 0.09797414f, -0.02740057f, 0.06904109f, -0.08115106f, 
    -0.97681487f, 0.59088701f, 0.16366956f, 0.53330898f, -0.06978946f, 0.11246255f, 0.10322583f, -0.07281554f, 
    0.04116152f, -0.06319002f, -0.13583635f, 0.05872608f, 0.20461746f, -0.08638658f, -0.05990525f, -0.18491746f, 
    0.00974222f, -0.10856449f, 0.00688792f, -0.14519787f, 0.24238594f, 0.06840499f, 0.02075963f, -0.22753981f, 
    0.02529312f, 0.10312954f, 0.02351411f, -0.09040417f, 0.00640916f, 0.06460907f, -0.08148458f, -0.03402545f, 
    -0.02662006f, -0.04126983f, 0.03144721f, 0.00807992f, -0.17686465f, 0.64334726f, -0.17382762f, 0.20962158f, 
    -0.05142387f, -0.04984868f, -0.07670029f, 0.06181052f, 0.06309730f, 0.03232680f, 0.05424132f, -0.03425803f, 
    0.04942865f, 0.11283775f, 0.08456372f, -0.03333109f, 0.04396668f, -0.10413038f, -0.10626661f, -0.03217413f, 
    0.05235036f, 0.13852087f, 0.04740397f, 0.12333917f, -0.16441996f, -0.90958434f, -0.35727152f, -0.05022720f, 
    0.07402153f, 0.34886265f, 0.11910331f, 0.13280725f, 0.04844707f, -0.01221758f, 0.09113220f, 0.13978045f, 
    -1.09310746f, 0.07900014f, 0.23296002f, 0.51608288f, -0.15835389f, 0.16039102f, -0.23857783f, -0.05114617f, 
    -0.14387988f, 0.11948755f, -0.05574960f, -0.11983439f, 0.23259148f, 0.01729514f, -0.42438656f, -0.06801211f, 
    0.07932808f, -0.06338824f, 0.06128822f, -0.13784760f, 0.05844615f, -0.08856910f, -0.01363653f, -0.17711765f, 
    -0.24400866f, -0.31447616f, -0.19691567f, -0.12617776f, 0.15352510f, 0.19054967f, -0.03246405f, 0.18023247f, 
    -0.09172538f, -0.06334697f, 0.09692702f, -0.08828425f, 0.18780571f, -0.28920472f, -0.46794420f, -0.65136540f, 
    0.00365172f, -0.21302128f, -0.02588037f, -0.04242706f, 0.08358350f, 0.14149262f, -0.01813607f, 0.15410241f, 
    0.13967156f, -0.30081910f, -0.24682122f, -0.34543312f, 0.05340689f, 0.00758203f, 0.01443670f, 0.05348732f, 
    0.01203258f, 0.31574687f, 0.14821686f, 0.14324562f, -0.11930948f, -0.21331099f, -0.02089106f, 0.01690368f, 
    0.06462550f, 0.16102837f, -0.00374262f, 0.09354047f, -0.35356846f, -0.15404062f, -0.30402192f, -0.57151031f, 
    0.32216707f, 0.10126570f, -0.05607951f, -0.21998435f, -0.18020216f, 0.04339341f, -0.12622416f, -0.08189467f, 
    0.04943145f, -0.04761382f, -0.00553594f, 0.09130051f, 0.43276617f, -0.10074365f, -0.27706617f, 0.05173301f, 
    0.07929699f, -0.30493692f, 0.01985618f, 0.03006696f, 0.06328077f, 0.07847410f, 0.18160857f, 0.00646958f, 
    -0.36031964f, -0.20830102f, 0.07984319f, 0.06008176f, -0.01154511f, 0.02966806f, 0.00957223f, 0.06878904f, 
    -0.12551107f, 0.09471728f, -0.09682545f, -0.29329678f, 0.70003289f, -0.04934503f, 0.05188894f, 0.18632612f, 
    0.12107776f, 0.15822801f, 0.03421126f, 0.14457887f, 0.18750228f, 0.09195841f, 0.14602686f, 0.14494449f, 
    -0.21545921f, 0.00757117f, 0.06433537f, 0.10301794f, 0.07926674f, -0.07779498f, 0.06558231f, 0.02059798f, 
    0.05987167f, -0.05326975f, 0.20048174f, 0.01699655f, -0.48632517f, 0.05370339f, 0.19695930f, 0.13455170f, 
    0.00285622f, 0.16939451f, 0.14601971f, 0.04455151f, -0.01919845f, 0.11216723f, 0.01741538f, 0.17707409f, 
    0.03581993f, -0.08259223f, -0.22618832f, 0.18955301f, -0.15257089f, 0.23000486f, -0.10428038f, -0.11805235f, 
    -0.02830604f, -0.00096288f, -0.00489427f, -0.06480807f, -0.07329138f, -0.26741222f, -0.21618585f, -0.08703794f, 
    0.25274253f, 0.00234544f, 0.24186750f, 0.02039612f, -0.15238208f, -0.20869131f, -0.09193418f, -0.27198303f, 
    0.18917716f, -0.35689265f, -0.09262328f, 0.08257782f, 0.06137636f, 0.00677455f, 0.19799656f, 0.16107458f, 
    0.14047241f, -0.06465384f, -0.06678618f, 0.12459210f, 0.00401210f, -0.32236129f, -0.35559624f, -0.32272533f, 
    0.00902974f, 0.06701495f, 0.13534887f, -0.00711390f, 0.19760062f, 0.10451188f, 0.18838105f, 0.09710435f, 
    -0.13762105f, -0.23321818f, -0.07709592f, -0.04570590f, 0.21488656f, -0.07543724f, 0.08953048f, -0.09995563f, 
    -0.02611219f, -0.12526430f, 0.05284427f, 0.14849536f, -0.60578418f, -0.16920672f, 0.24782170f, -0.01708105f, 
    -0.18824027f, -0.00903993f, -0.16680460f, -0.11564180f, -0.04463256f, 0.02685407f, -0.07979954f, 0.12323756f, 
    -0.12760578f, 0.16841199f, -0.00536462f, 0.18349895f, 0.03887611f, -0.10723044f, -0.20995292f, -0.08469442f, 
    0.04627308f, 0.03844429f, -0.01727140f, -0.08496917f, -0.50297123f, 0.00903531f, 0.00351241f, 0.24059089f, 
    0.02173072f, 0.04839299f, -0.19245055f, 0.04456622f, -0.17944628f, -0.08236167f, -0.03831366f, -0.11087128f, 
    -0.13742867f, -0.80449873f, -0.40139100f, 0.03009486f, 0.13910103f, -0.04078856f, 0.08696747f, 0.04667065f, 
    -0.01821736f, 0.07229637f, 0.11741857f, 0.01272413f, -0.22824413f, 0.04608498f, 0.11038421f, 0.02890624f, 
    0.02028035f, 0.11619892f, 0.03230990f, -0.08584041f, 0.03268843f, 0.06526698f, -0.08777546f, 0.12358399f, 
    -0.57881999f, -0.10502493f, 0.13123709f, 0.11902261f, 0.00125212f, -0.00302362f, 0.06410269f, -0.18154745f, 
    -0.02030696f, 0.16343595f, 0.30350545f, 0.26327851f, 0.43636566f, 0.41440707f, -0.02111089f, -0.00358544f, 
    0.18805185f, -0.36794111f, 0.02224409f, -0.03464284f, -0.07394494f, 0.08894627f, 0.18452103f, -0.00747643f, 
    -0.06627373f, 0.04012883f, 0.03765520f, 0.07073828f, 0.15910034f, -0.08184807f, -0.03421706f, -0.14134878f, 
    -0.18816668f, 0.04230564f, -0.19610944f, -0.27074331f, -0.01672737f, -0.01641232f, 0.10391201f, -0.18739566f, 
    -0.00980162f, -0.07888477f, 0.01111950f, -0.03218896f, -0.07467903f, 0.00808499f, -0.00638947f, 0.05660661f, 
    -0.19210945f, 0.16839693f, 0.05220198f, -0.16480139f, 0.28008306f, -0.16606905f, -0.08945974f, 0.19313112f, 
    0.11932839f, 0.01926110f, 0.15816937f, 0.09268869f, 0.34453797f, -0.02562557f, -0.04134051f, -0.20673138f, 
    -0.12461820f, -0.07931311f, -0.04901915f, 0.03446744f, 0.02219792f, -0.16698542f, 0.02307876f, -0.25228661f, 
    -0.28308848f, 0.10245877f, 0.11598709f, 0.00313824f, -0.00912581f, -0.13954043f, -0.12941194f, -0.04530636f, 
    0.00005453f, -0.04133307f, 0.09438106f, 0.05646843f, -0.79551446f, -0.17117809f, 0.00370665f, 0.21656902f, 
    0.03256811f, -0.09246369f, -0.24946804f, -0.00091820f, -0.11693310f, -0.08935073f, 0.01974277f, -0.06856792f, 
    -0.15138930f, -0.41247499f, -0.03311055f, 0.03248753f, 0.22090776f, 0.06637209f, 0.20052621f, 0.04755920f, 
    0.05123641f, -0.20718940f, -0.09602782f, -0.16016333f, 0.13924092f, -0.22300011f, 0.14690720f, -0.33586478f, 
    0.18649197f, -0.21297884f, -0.18996705f, 0.06578018f, -0.07577988f, 0.01843064f, 0.06250737f, 0.05240511f, 
    -0.49191546f, 0.00208025f, 0.13568394f, -1.03642547f, -0.11951260f, 0.02015551f, 0.26213408f, -0.11263428f, 
    0.02326455f, 0.14044528f, -0.05045645f, 0.07459971f, -0.30556312f, -0.26391983f, 0.44691184f, 0.08001175f, 
    -0.07819590f, -0.15297963f, -0.21659160f, -0.07342594f, 0.06024573f, 0.15759721f, -0.18768786f, 0.08067345f, 
    -0.23876449f, 0.17096376f, -0.08655788f, -0.08145141f, 0.02452891f, -0.32150993f, 0.07785076f, -0.47076216f, 
    0.14419501f, 0.13804840f, 0.01701979f, -0.04275189f, -0.39938855f, -0.20969938f, 0.24246590f, 0.17168939f, 
    -0.08465380f, -0.02691480f, 0.02636957f, 0.02358212f, 0.07126585f, 0.11991225f, 0.08538388f, 0.08633250f, 
    0.38163215f, -0.67323077f, 0.12308747f, -0.02410286f, 0.12003842f, -0.01145836f, -0.42549777f, -0.09920558f, 
    0.00964210f, -0.10435079f, -0.18002877f, -0.13564110f, -0.20665489f, 0.15706787f, 0.18501434f, -0.07943010f, 
    -0.07800093f, -0.11248606f, -0.14819984f, 0.01934411f, 0.04837181f, 0.11733203f, 0.02847921f, 0.14180727f, 
    -0.24053365f, -0.08354290f, 0.00741798f, 0.10653663f, 0.15951295f, -0.01523241f, 0.01009663f, -0.05258515f, 
    0.10130186f, 0.09316560f, -0.03346412f, -0.18714367f, -0.22013983f, -0.21446431f, 0.16462477f, -0.09993778f, 
    -0.19723861f, 0.10817291f, -0.32681301f, 0.15183321f, 0.05630064f, -0.07730015f, -0.06735774f, -0.03717001f, 
    0.08926380f, 0.15015765f, 0.23342834f, 0.15367775f, -0.11764214f, -0.09541000f, -0.08204142f, -0.14317176f, 
    0.06979180f, 0.00032076f, 0.06768324f, 0.01049296f, -0.25402388f, -0.49964100f, 0.36965168f, -0.68316782f, 
    0.17142005f, -0.38110358f, 0.10257424f, -0.01298605f, -0.17930767f, -0.16613686f, 0.00775489f, -0.00016501f, 
    -0.31709802f, 0.19251825f, -0.22906549f, -0.25486237f, 0.03578188f, -0.08925690f, 0.12960394f, -0.01356358f, 
    -0.07352957f, -0.07604591f, -0.05025389f, -0.00907976f, 0.06595153f, -0.00556574f, 0.55107236f, -0.90174806f, 
    0.14169070f, -0.17258817f, 0.18700776f, 0.03560699f, -0.14054510f, 0.03017249f, -0.01164262f, -0.04722019f, 
    -0.08006948f, 0.01940476f, 0.29134625f, -0.39041278f, -0.01092480f, -0.05476185f, 0.04716560f, 0.21412732f, 
    0.02808198f, -0.02157984f, 0.03625827f, -0.02667801f, 0.01166867f, 0.01257849f, 0.30514768f, -0.24147463f, 
    -0.05307924f, -0.07461416f, -0.06225019f, -0.14875239f, 0.09949416f, 0.09827964f, 0.11907730f, 0.13969262f, 
    0.31601012f, -0.39844406f, 0.54206860f, 0.09130635f, 0.26161465f, -0.39378992f, 0.00865903f, -0.03556755f, 
    -0.13758281f, -0.05048962f, -0.06817338f, 0.17430931f, 0.20518598f, 0.28546560f, 0.58701092f, 0.47519177f, 
    0.22413591f, -0.11744783f, -0.21248078f, -0.21994272f, -0.08456308f, -0.05561424f, 0.01302501f, 0.17086677f, 
    0.24906078f, -0.04986419f, 0.15702373f, -0.25377083f, -0.02971483f, -0.14497471f, -0.37177673f, -0.14199241f, 
    -0.02979323f, -0.01594032f, 0.11263206f, -0.00689106f, 0.27391320f, -0.20254968f, 0.21147718f, -0.29643890f, 
    0.09082580f, -0.05070666f, 0.09815595f, 0.09284196f, -0.15717882f, 0.13061470f, 0.04813134f, -0.06137624f, 
    0.43936482f, -0.23531027f, -0.57983655f, -0.01004027f, 0.04971475f, 0.09044179f, 0.16607326f, 0.29015139f, 
    -0.00142282f, -0.04750908f, -0.05597155f, -0.00688958f, -0.04955927f, 0.61678231f, -0.64455718f, -0.05097938f, 
    0.03872401f, -0.10930067f, 0.36958471f, 0.12530951f, 0.07310663f, -0.05316004f, -0.05148615f, 0.03751069f, 
    -0.35205850f, 0.12332720f, 0.22046775f, -0.23716903f, -0.20784293f, -0.33578402f, 0.13341670f, 0.19724673f, 
    -0.07336275f, 0.08450358f, 0.01607375f, 0.02997689f, 0.18371561f, -0.17567062f, -0.30047226f, -0.30026332f, 
    -0.02401408f, 0.12315249f, 0.06918465f, -0.10225230f, 0.09922784f, -0.10089065f, -0.04681316f, 0.00530166f, 
    0.02632230f, -0.26012552f, 0.06324483f, -0.32018217f, -0.15659091f, -0.18320428f, 0.26450929f, 0.01569241f, 
    -0.10067413f, 0.03552693f, -0.19852175f, -0.22322617f, 0.42585146f, 0.44113085f, -0.84772128f, 0.06700188f, 
    0.06036901f, 0.05872526f, 0.14251116f, 0.06294189f, 0.09754527f, -0.07632927f, 0.03622791f, -0.06538963f, 
    0.16559114f, -0.27763304f, 0.06847651f, -0.22387825f, -0.10876287f, 0.06862523f, -0.00354405f, 0.20301770f, 
    0.14385830f, 0.04516439f, -0.02151397f, 0.00539745f, 0.26224115f, -0.19756006f, -0.21705376f, -0.14064547f, 
    -0.07337651f, 0.19161937f, 0.14827770f, -0.06246369f, 0.12753645f, -0.03622023f, -0.14379963f, -0.10342915f, 
    -0.28227928f, 0.12868088f, -0.81003332f, 0.11525349f, -0.07046539f, -0.15922624f, 0.01825700f, 0.03716022f, 
    0.01905556f, 0.07573845f, 0.03618003f, -0.17864984f, -0.19020028f, 0.13025154f, 0.27397400f, 0.31821120f, 
    0.03632366f, 0.01354733f, -0.10921747f, -0.10722807f, 0.10537340f, 0.18357404f, 0.17872268f, 0.08204094f, 
    -0.31450182f, -0.31224227f, -0.50400484f, 0.09827205f, 0.05189795f, 0.14173430f, 0.21863778f, 0.03972779f, 
    0.13550490f, -0.06342524f, 0.14518335f, 0.02819563f, -0.14155607f, -0.08256238f, -0.20094663f, 0.00962959f, 
    0.12391532f, 0.08822180f, 0.14663053f, 0.24629031f, -0.01875177f, -0.11773483f, 0.01258736f, 0.18447080f, 
    -0.49696210f, -0.22966835f, -0.45447594f, 0.05539083f, -0.26292056f, 0.30465904f, 0.03904701f, 0.10418519f, 
    -0.00016760f, 0.09374775f, 0.18753830f, 0.16702445f, 0.05409022f, -0.43187407f, 0.06771477f, 0.20770340f, 
    -0.10117805f, -0.10036901f, -0.09330869f, 0.19335249f, 0.14785023f, 0.09452726f, -0.03696071f, 0.10862844f, 
    0.28779021f, -0.39297250f, 0.31132123f, 0.17758469f, 0.05614160f, 0.29188243f, 0.02322318f, -0.03089715f, 
    -0.08756475f, -0.08840138f, 0.06290347f, 0.04957029f, -0.65186226f, 0.05555368f, -0.23583443f, -0.30306306f, 
    0.09623460f, 0.12291057f, -0.15330797f, 0.03918893f, -0.32005504f, -0.38825008f, -0.04603606f, -0.23290120f, 
    0.15131165f, -0.06635050f, 0.10663167f, -0.07642534f, -0.08989429f, -0.08830009f, 0.14331590f, 0.00258211f, 
    0.14389630f, 0.11438539f, -0.14514969f, -0.25549570f, -0.22284104f, -0.03742034f, -0.52522516f, 0.09464472f, 
    -0.05566112f, 0.19406286f, 0.04921668f, -0.02976574f, 0.02917972f, 0.11491938f, -0.04015686f, 0.02647874f, 
    -0.30999666f, 0.38757709f, -0.17064027f, 0.29821366f, -0.06438208f, 0.05076655f, 0.02628352f, -0.18858305f, 
    -0.17530656f, 0.13191676f, 0.06681985f, 0.24146114f, 0.47602925f, -0.06406281f, 0.10560656f, -0.25069854f, 
    -0.01051884f, -0.13875943f, 0.08641347f, 0.07736330f, -0.14227067f, -0.19641928f, -0.49850231f, -0.67019206f, 
    -0.38006720f, -0.11103153f, 0.10373378f, 0.02830707f, -0.14208980f, 0.10932725f, 0.01126782f, 0.23469441f, 
    0.03568629f, -0.13485512f, 0.01250202f, 0.23496449f, 0.05691228f, -0.27899235f, 0.07777505f, 0.37791675f, 
    -0.06121558f, -0.04825934f, -0.02897598f, -0.02434948f, -0.04772266f, -0.14856921f, -0.05363164f, 0.14231496f, 
    0.49262971f, -0.10026042f, 0.21279132f, -0.32668519f, -0.04951249f, -0.27776894f, -0.03913499f, 0.00308840f, 
    -0.28404629f, -0.04415795f, -0.10351868f, -0.09547297f, -0.52588284f, 0.61997288f, 0.02937274f, 0.18395087f, 
    0.06266104f, -0.09322730f, -0.04898795f, 0.53098673f, -0.09186805f, 0.05054571f, 0.17372684f, -0.02836689f, 
    -0.01262344f, -0.39356944f, 0.30920264f, -0.03738646f, -0.19547683f, 0.11013648f, 0.16034424f, -0.04086303f, 
    0.07260510f, 0.15503071f, 0.24348706f, -0.03605933f, 0.07955454f, -0.01404973f, 0.16152722f, 0.43351769f, 
    -0.09225519f, -0.01153201f, 0.11027122f, 0.05239780f, 0.10062697f, 0.10715913f, -0.05100126f, -0.18368348f, 
    -0.08889833f, -0.31035793f, 0.07641936f, 0.18684812f, 0.04343109f, 0.15785269f, -0.46070465f, -0.10437635f, 
    -0.13932151f, -0.05117272f, 0.03101776f, 0.10609955f, -0.19775367f, -0.06038068f, -0.25829160f, -0.12137309f, 
    -0.02730203f, -0.22954717f, -0.16386029f, 0.13529180f, -0.13017003f, 0.11506395f, -0.20458634f, -0.11855657f, 
    -0.31955239f, 0.51575625f, 0.01998884f, 0.09330942f, 0.12539972f, 0.01707139f, 0.14543106f, 0.13470785f, 
    0.02161998f, 0.17759480f, 0.12228864f, 0.07174323f, -0.35167235f, 0.36364841f, 0.03936233f, -0.44504163f, 
    -0.02879046f, 0.05084715f, -0.09117556f, -0.05584994f, 0.06839309f, 0.05040056f, 0.19831589f, 0.08928214f, 
    -0.35119325f, 0.27224222f, -0.37495577f, 0.27645430f, 0.07740728f, 0.30510518f, 0.28867900f, -0.05663825f, 
    0.20580132f, -0.11625690f, -0.01383668f, -0.09019457f, -0.25563073f, 0.26574248f, 0.06367912f, 0.08064757f, 
    0.04863745f, -0.07971168f, -0.25227442f, -0.15809171f, 0.04841647f, -0.26240683f, 0.12121586f, 0.16134815f, 
    0.12093773f, -0.55883199f, -0.04686141f, 0.17317773f, 0.01586905f, -0.15070832f, -0.03396842f, 0.06296647f, 
    -0.01703722f, 0.16076575f, -0.11707371f, 0.04776017f, 0.07734612f, -0.49437633f, 0.01647477f, 0.18133380f, 
    -0.03558427f, -0.35753027f, 0.01854177f, 0.09014592f, -0.14284918f, -0.01316507f, -0.22111365f, -0.02012235f, 
    -0.30162448f, -0.17958783f, -0.03355014f, 0.14378217f, -0.26204687f, 0.05459443f, 0.02582571f, -0.13008006f, 
    0.06814796f, 0.09040608f, 0.15490581f, 0.08663671f, -0.20350306f, -0.01215650f, 0.10842736f, 0.22516505f, 
    0.04031711f, -0.24239235f, -0.12307201f, 0.03334282f, -0.22124541f, 0.01408942f, 0.01867512f, 0.00013738f, 
    0.46974432f, -0.05421422f, 0.19101474f, 0.08240270f, -0.34210855f, 0.03806168f, 0.43555370f, -0.12078874f, 
    0.15181668f, 0.20355342f, 0.09206966f, 0.21082807f, -0.49902168f, -0.03491137f, -0.00391826f, 0.13268243f, 
    -0.18192878f, 0.06509408f, 0.24134837f, -0.14871638f, -0.31632546f, 0.16612948f, 0.01006587f, 0.16656598f, 
    0.16044861f, -0.05776128f, -0.16956271f, -0.05948626f, -0.13253245f, 0.01181444f, 0.09851292f, -0.11810116f, 
    0.04916748f, -0.12168156f, -0.17912519f, -0.23327151f, -0.10618228f, -0.06372182f, 0.12877379f, 0.01883668f, 
    -0.17065075f, 0.09179732f, 0.15747118f, -0.05058089f, -0.06217380f, 0.08860940f, 0.12888707f, -0.01757713f, 
    -0.08522610f, 0.25809538f, -0.43278617f, 0.06208541f, 0.00081286f, 0.05303397f, 0.01736795f, -0.00148850f, 
    -0.11879525f, 0.11719192f, -0.08799902f, 0.12745078f, -0.38156313f, 0.18411405f, 0.21689127f, -0.23847935f, 
    -0.11677068f, 0.13577561f, 0.15330049f, -0.06649043f, -0.07058390f, -0.03352292f, -0.33078063f, -0.10844052f, 
    -0.03124132f, -0.33271450f, -0.30856532f, -0.35655856f, -0.25504482f, -0.14876443f, -0.03834126f, -0.11730532f, 
    -0.04229369f, 0.18598001f, 0.03759689f, -0.06532624f, -0.03580623f, 0.07841709f, 0.05883965f, -0.04834690f, 
    -0.11643712f, -0.01550164f, 0.08623759f, 0.00859190f, -0.04208106f, -0.17600653f, -0.26466000f, -0.21857488f, 
    0.52219814f, 0.34548366f, 0.03159110f, -0.25772497f, -0.10806876f, 0.06417671f, -0.15832974f, 0.15351513f, 
    -0.08882739f, 0.02028631f, -0.08832533f, -0.34316492f, -0.13357857f, -0.05500504f, 0.25781089f, -0.70463729f, 
    0.01495942f, 0.10590641f, -0.27495831f, 0.02370924f, -0.09321859f, -0.01583417f, 0.05114375f, -0.07489664f, 
    -0.12927352f, -0.01006303f, 0.24323601f, 0.00081467f, 0.11565813f, 0.14836416f, 0.05740381f, -0.12864792f, 
    -0.14834154f, 0.03826072f, 0.16142814f, 0.19068301f, -0.37241063f, -0.17623137f, -0.37658915f, 0.29334113f, 
    0.07062393f, 0.02954350f, 0.14426517f, -0.13518761f, -0.10274968f, 0.20445940f, 0.11441540f, -0.12052154f, 
    0.45470017f, -0.15828454f, 0.03118915f, -0.28752026f, 0.07000476f, 0.05656046f, 0.10420433f, 0.15080413f, 
    0.01753929f, 0.07774223f, 0.13449182f, -0.04678718f, -0.25511438f, -0.42872894f, -0.04461839f, 0.00866714f, 
    -0.00961820f, 0.00524653f, -0.14436369f, -0.21289769f, 0.03478248f, 0.03512727f, 0.09479787f, 0.04889712f, 
    -0.81075341f, 0.70547777f, -0.72730267f, 0.59429848f, 0.05322669f, -0.40918285f, 0.20958021f, -0.08934182f, 
    0.05241200f, -0.13496786f, -0.03172807f, -0.02197766f, -0.44694111f, -0.26158994f, 0.02478386f, -0.45450819f, 
    -0.06074211f, -0.06698281f, -0.12338009f, 0.03162242f, 0.00563989f, 0.15169089f, 0.11630304f, -0.08333562f, 
    -0.13565412f, -0.01971742f, 0.05451638f, 0.12435591f, -0.03848872f, 0.09190270f, 0.07394033f, 0.07936195f, 
    -0.11739563f, 0.00155347f, 0.14188671f, 0.02277991f, -0.21133527f, 0.01557448f, -0.15676360f, 0.24303994f, 
    0.11911178f, 0.07717779f, -0.13215055f, -0.17382890f, -0.10760636f, 0.02328454f, -0.02099053f, -0.19359994f, 
    -0.10086863f, 0.25246742f, -0.44931540f, -0.25383511f, -0.02233842f, -0.07851850f, 0.10487856f, -0.07605698f, 
    -0.02526037f, 0.10847352f, 0.06610347f, -0.08446591f, -0.23838888f, -0.32394117f, 0.20140205f, 0.49133143f, 
    0.03781791f, -0.06469287f, -0.05285584f, 0.14253618f, -0.20523620f, 0.10463528f, -0.10990839f, 0.11713078f, 
    0.20479716f, 0.01623243f, 0.16182373f, -0.23861961f, 0.16994157f, -0.01487635f, 0.02610637f, 0.10350319f, 
    0.12294003f, -0.13491410f, -0.08275732f, -0.07373943f, -0.29864758f, -0.26026556f, 0.27315164f, 0.22409329f, 
    -0.14716502f, 0.19305010f, -0.00785504f, 0.08828609f, -0.16222619f, 0.01263084f, 0.04831450f, 0.04635562f, 
    -0.15669470f, -0.00260487f, -0.09015339f, 0.31259742f, -0.42921272f, -0.15758367f, -0.00267119f, 0.05103062f, 
    0.02297567f, 0.09083213f, -0.15260182f, -0.05673246f, 0.20316738f, -0.14460573f, 0.04225064f, -0.54974884f, 
    -0.14311358f, -0.33494002f, 0.20319971f, -0.01918195f, 0.10640132f, 0.19024740f, 0.11548696f, 0.04047286f, 
    -0.31182420f, 0.09109309f, -0.11420994f, 0.44402242f, 0.15570606f, 0.07075136f, -0.17646892f, 0.26641807f, 
    -0.20090611f, -0.02991408f, -0.15589134f, -0.14409326f, -0.42824662f, -0.25103325f, -0.30957463f, 0.14154868f, 
    0.10284258f, -0.09620322f, 0.01348586f, 0.01450249f, -0.14207305f, -0.02675258f, -0.09673083f, -0.06677697f, 
    -0.08157466f, 0.30689090f, -0.10280605f, 0.26876736f, 0.10358476f, -0.25049150f, 0.23828672f, 0.08200394f, 
    0.14544427f, -0.01173947f, 0.00525668f, 0.07434888f, -0.49830469f, 0.09854968f, -0.29432341f, 0.15590632f, 
    -0.07380439f, -0.10892984f, -0.08651669f, 0.12146343f, -0.44540858f, 0.23857611f, 0.04305550f, 0.00012108f, 
    0.06415345f, 0.13046564f, 0.42780715f, 0.18731916f, -0.25383908f, -0.11775142f, -0.13971442f, -0.14657541f, 
    -0.13675429f, 0.02395331f, 0.02412581f, -0.01540875f, 0.19273986f, -0.22567049f, 0.63992465f, -0.05305990f, 
    -0.03370237f, -0.00750078f, -0.09371891f, 0.03272927f, -0.12907399f, -0.12872061f, 0.23168719f, 0.07867853f, 
    0.08411070f, -0.09112151f, -0.12941629f, -0.31017861f, 0.03555177f, -0.40545145f, -0.10504534f, -0.08427729f, 
    -0.03830979f, 0.00055775f, -0.01475823f, -0.07503383f, 0.11473946f, 0.18054962f, 0.02757951f, 0.12475945f, 
    -0.05307830f, 0.13838428f, 0.17969432f, -0.02629787f, -0.10704602f, -0.10038538f, -0.06602240f, -0.12766445f, 
    -0.02519271f, -0.24392556f, 0.15147917f, -0.15774660f, -0.03642200f, 0.34810811f, -0.34013879f, 0.12912270f, 
    -0.25343695f, -0.18546133f, -0.20092483f, -0.07226831f, 0.46672019f, -0.02041553f, 0.49389958f, 0.26724127f, 
    0.31532279f, -0.06758200f, -0.05222778f, -0.00321815f, -0.06244494f, -0.02954672f, 0.19200487f, 0.06738846f, 
    -0.15207954f, 0.16512273f, 0.15201350f, 0.02055011f, -0.11982728f, 0.09271299f, 0.36181289f, -0.00630620f, 
    0.15305272f, 0.14754696f, 0.19690685f, 0.18398112f, 0.32747662f, 0.31703860f, -0.06621488f, -0.03520773f, 
    -0.10075031f, 0.15497777f, -0.09100839f, 0.03033423f, -0.06282547f, 0.09460580f, 0.02307781f, 0.02799180f, 
    0.37905121f, -0.41825899f, 0.33707860f, 0.31664833f, -0.09670503f, -0.13306071f, -0.08020526f, 0.01100960f, 
    0.07549294f, -0.02614511f, 0.15254751f, -0.06082579f, -0.21013282f, -0.03594477f, -0.36684623f, 0.16828160f, 
    0.09544307f, 0.02230659f, 0.01641696f, -0.21805145f, 0.10477815f, 0.06703945f, 0.10215063f, 0.27966577f, 
    0.37358412f, 0.06259977f, 0.06803719f, -0.17159224f, -0.08334690f, -0.01344264f, -0.01496062f, 0.14562130f, 
    -0.13911614f, 0.04262572f, 0.02792580f, -0.21668813f, 0.04978846f, 0.15445089f, 0.19770785f, -0.25489473f, 
    -0.06997263f, 0.08141990f, 0.01734846f, -0.00375949f, 0.07510394f, 0.14421538f, 0.00509600f, 0.03615291f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.22453839f, 0.06883069f, 0.05942325f, -0.07273061f, -0.14888318f, 0.12678848f, 0.00702160f, -0.12523833f, 
    0.10375117f, -0.01607364f, 0.06013501f, -0.07578485f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
