#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.54266047f, 0.55777597f, 0.70985645f, 0.46558154f, 0.23175934f, 0.48973393f, -0.35559750f, -0.02295789f, 
    0.01362405f, 0.07116415f, -0.18174997f, -0.54834080f, -0.03317236f, 0.52286363f, 0.89200526f, 0.22437803f, 
    0.10475177f, 0.53955632f, -0.88088512f, -0.81298536f, -0.51800156f, 0.03044550f, -0.34927166f, 0.71222609f, 
    0.14892997f, 0.04806612f, 0.22884582f, -0.04704591f, 0.73400575f, -0.64623749f, 0.77745646f, 0.01422700f, 
    -0.63327658f, -0.20352924f, -0.05941483f, -0.39516887f, 0.64915842f, 0.73244601f, 0.86107785f, -0.28362268f, 
    -0.36758459f, -0.39000225f, -0.07287128f, -0.21766107f, -0.00921161f, -0.48760122f, -0.37565568f, 0.55772424f, 
    0.67156100f, -0.27820945f, -0.84124899f, -0.41681886f, -0.26284027f, -0.13978812f, 0.82758415f, 0.36485264f, 
    0.68183208f, 0.69525421f, 0.45517486f, -0.40902573f, 0.45408922f, 0.38501081f, 0.00144443f, 0.06615961f, 
    -0.08632765f, 0.36730140f, 0.53514332f, 0.84897196f, 0.05766443f, -0.59818250f, 0.24531028f, -0.04828053f, 
    -0.72730213f, -0.37956667f, -0.15094501f, -0.61831319f, 0.51236206f, -0.10874023f, -0.12960409f, 0.33887669f, 
    -0.32632360f, -0.75298637f, -0.59850097f, -0.49121284f, 0.34920257f, 0.98492563f, 0.30269346f, -0.07815047f, 
    -0.47122353f, -0.20915465f, 0.50641382f, -0.89282876f, 1.06778359f, 0.28711191f, -0.56114835f, 0.82330805f, 
    -0.04690563f, -0.27699539f, 0.19220230f, 0.27300429f, 0.96077448f, -0.57466179f, -0.23573148f, -0.27759132f, 
    -0.40953714f, 0.01367108f, -0.13498116f, 0.13579455f, 0.20401222f, 0.25181907f, 0.27989191f, -0.68901312f, 
    -1.11894250f, -0.41042447f, -0.10098334f, 0.49221575f, 0.37011245f, 0.79746932f, 0.66240090f, 0.44695523f, 
    -0.22539458f, 0.02117568f, 0.38601753f, 0.36522952f, -0.02948827f, -0.00592131f, -0.49540788f, -0.59810501f, 
    -0.62546521f, -0.54907024f, -0.51536405f, -0.31398216f, -0.68303132f, 0.26607314f, -0.12944122f, 0.77189142f, 
    0.62772137f, -0.03226084f, 0.52741319f, -0.65790987f, 0.46128798f, 0.08056789f, 0.28889111f, 0.09556800f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.43586120f, -0.04560547f, -0.06708469f, 0.05789096f, -0.08976329f, -0.37340942f, 0.22776967f, 0.33811954f, 
    0.05581063f, 0.09591106f, 0.07993292f, 0.03151539f, 0.28870827f, 0.16516033f, 0.37955213f, -0.34589630f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.44691926f, 0.20085096f, -0.05722828f, 0.04378354f, -0.04083736f, 0.21313752f, -0.08995046f, -0.21760777f, 
    0.20238714f, 0.07013325f, 0.07494613f, 0.23288877f, 0.04672282f, 0.03562905f, -0.19201756f, -0.13099872f, 
    0.21437474f, -0.02466011f, 0.10958714f, 0.12188148f, 0.08890586f, 0.14229016f, 0.22567910f, -0.09159059f, 
    0.07628908f, 0.07968878f, 0.20256190f, -0.19184260f, 0.10849075f, 0.15288709f, -0.12434397f, -0.08739615f, 
    0.02709446f, 0.16547562f, 0.10140593f, -0.11147679f, -0.47694686f, -0.05830527f, 0.06122892f, -0.13206452f, 
    -0.04505004f, 0.12861371f, 0.14465819f, 0.07323273f, 0.23387820f, -0.09304114f, -0.23882049f, 0.16822809f, 
    0.03749650f, -0.15448168f, -0.06385583f, -0.03028454f, -0.01159037f, 0.13232262f, -0.35104638f, -0.15308462f, 
    -0.04793629f, -0.05129582f, 0.04083176f, -0.04845221f, 0.36245149f, -0.12168133f, 0.11940539f, 0.17461789f, 
    0.03815429f, -0.29256842f, 0.23018305f, 0.16748929f, -0.16335186f, 0.01684429f, 0.02301126f, -0.04221356f, 
    -0.33252195f, 0.15042609f, 0.18298464f, 0.14340912f, 0.03185291f, -0.22742517f, 0.02762016f, 0.09495436f, 
    -0.18926705f, 0.10635415f, 0.32769525f, 0.14668709f, 0.07267786f, -0.07600840f, -0.10096797f, 0.01968689f, 
    0.12598482f, 0.00578386f, -0.22227217f, -0.48207358f, -0.08556861f, 0.24772194f, -0.02825961f, 0.12667619f, 
    -0.01141223f, 0.20918901f, -0.02126273f, 0.10809736f, -0.01744588f, 0.50434393f, -0.12728041f, -0.30157936f, 
    -0.17750823f, -0.08288729f, 0.02676595f, -0.13092998f, 0.17357185f, -0.49119261f, 0.01543818f, -0.32052130f, 
    -0.12411302f, -0.00606786f, -0.19810438f, 0.14411092f, 0.17873099f, -0.22070460f, 0.20881099f, 0.06629891f, 
    0.30567327f, -0.05076648f, 0.00559777f, 0.12423369f, -0.23154689f, 0.14495523f, 0.25522280f, -0.10447116f, 
    0.12308782f, 0.25422439f, 0.03082653f, 0.18171734f, 0.00544782f, -0.08000618f, -0.08704893f, -0.36872044f, 
    0.01370648f, -0.01585961f, 0.09311498f, -0.19602582f, -0.12797256f, 0.12942335f, 0.02505541f, 0.15690789f, 
    -0.08397011f, -0.01945107f, 0.05682215f, 0.06806616f, -0.02634322f, -0.06926775f, 0.21870565f, 0.09919710f, 
    0.14279155f, 0.11368030f, 0.12601227f, 0.21248682f, -0.24277639f, -0.06750186f, 0.22926895f, -0.04238988f, 
    -0.12835805f, 0.00706268f, -0.11481305f, -0.13621677f, 0.48693532f, -0.03939344f, 0.03199387f, -0.09552034f, 
    -0.04340942f, 0.14070779f, 0.32206592f, 0.03214352f, -0.11144489f, -0.44123977f, 0.04239674f, -0.08673090f, 
    -0.06138643f, 0.17667194f, -0.10768409f, 0.07648468f, -0.30913866f, -0.09051334f, -0.23528019f, 0.06791195f, 
    0.22512129f, -0.02487081f, 0.04033004f, -0.01299425f, -0.06407809f, -0.08203783f, -0.40884289f, -0.27683586f, 
    -0.22921109f, -0.11409183f, 0.02606108f, 0.05707676f, -0.03363540f, 0.14587048f, 0.54637122f, 0.14653641f, 
    -0.31284004f, 0.12449083f, 0.09013749f, -0.14957784f, -0.08029255f, 0.09510723f, 0.09314431f, 0.21803470f, 
    0.11881958f, -0.05929866f, -0.11797903f, -0.23047772f, 0.09173699f, 0.05262360f, 0.06334679f, 0.06165227f, 
    -0.50520784f, -0.24631318f, -0.07972305f, 0.13264556f, 0.08362854f, 0.00844709f, -0.13458046f, -0.07337923f, 
    -0.05284420f, 0.02919080f, -0.20052521f, 0.32555407f, -0.04611555f, -0.08023640f, -0.01675822f, -0.03210706f, 
    -0.04653883f, -0.01647627f, 0.08927798f, 0.21680240f, -0.35535368f, 0.08538876f, -0.02680881f, 0.01887456f, 
    0.09112661f, 0.04137981f, 0.02769133f, -0.27890795f, 0.28486657f, -0.41813225f, 0.05251916f, 0.07600313f, 
    -0.12812459f, -0.20804857f, 0.37783897f, -0.05833372f, 0.15998085f, 0.16007484f, -0.23691136f, 0.27527705f, 
    0.01491503f, -0.05537065f, 0.25203723f, 0.04740991f, 0.02335026f, -0.10704169f, 0.19551864f, 0.11359973f, 
    0.05864769f, -0.15098344f, -0.10764112f, -0.08678249f, 0.14270282f, 0.04350626f, -0.22765176f, -0.12151437f, 
    0.32321855f, 0.15225492f, -0.02372319f, 0.03164606f, 0.10685402f, -0.00519567f, -0.01383880f, 0.02505058f, 
    -0.01455506f, -0.15098764f, -0.15715368f, 0.13230151f, 0.13498409f, -0.03451652f, -0.11738688f, -0.06582469f, 
    -0.76262158f, -0.32001719f, -0.29909670f, 0.03367261f, 0.12655593f, 0.01848336f, 0.02152465f, -0.16561897f, 
    0.03008869f, 0.30294335f, -0.00411280f, -0.12869817f, -0.09378678f, 0.11795977f, 0.05732467f, 0.21042171f, 
    0.24015872f, -0.07051066f, 0.32178438f, -0.02153419f, -0.07886940f, -0.13357475f, 0.02182372f, 0.00458669f, 
    -0.26972714f, 0.25764519f, -0.07560897f, 0.27350959f, -0.04995171f, 0.06777338f, 0.16213675f, 0.01106768f, 
    0.16242176f, -0.00797110f, 0.01474505f, -0.27543542f, -0.45703819f, 0.17716306f, 0.15114672f, 0.30896220f, 
    0.13374141f, 0.10919827f, -0.01289432f, 0.01172848f, -0.14993186f, 0.05864246f, -0.61505508f, -0.19091696f, 
    0.01224351f, -0.13808496f, 0.00581016f, -0.21471588f, -0.22740959f, 0.01922246f, -0.51304829f, -0.23859206f, 
    -0.20004658f, 0.14896280f, 0.06430652f, -0.02574999f, 0.22538079f, 0.02418157f, 0.23236290f, 0.11652955f, 
    0.09171523f, -0.15031904f, 0.03820381f, 0.02056738f, 0.14465865f, -0.09737562f, 0.11905806f, 0.18416224f, 
    -0.00969162f, 0.15884991f, -0.13128202f, 0.01914084f, -0.03806868f, -0.00944461f, -0.02472228f, -0.09528676f, 
    -0.09338397f, 0.33630502f, 0.16592503f, -0.22860742f, 0.02748869f, -0.02033413f, -0.04640612f, 0.14875716f, 
    0.09796710f, -0.18486796f, -0.09094068f, 0.07348890f, 0.28929442f, 0.06843547f, -0.04122686f, 0.09407228f, 
    0.09156776f, 0.17917317f, 0.00220988f, -0.01571134f, -0.00287132f, 0.06798294f, -0.02068927f, 0.03528101f, 
    0.14581159f, -0.12583271f, -0.20357771f, -0.00655498f, 0.16137762f, 0.16597921f, 0.01426617f, 0.17501591f, 
    0.02140751f, -0.03937371f, 0.10036005f, 0.06514217f, 0.22864276f, -0.60714936f, -0.16919637f, 0.06212701f, 
    0.09074956f, -0.16538617f, 0.10044499f, -0.03540211f, -0.02578945f, -0.01108366f, -0.19267839f, -0.10620072f, 
    0.15917894f, 0.13435045f, -0.03415034f, 0.14367044f, -0.01727484f, -0.03173026f, 0.17966831f, -0.58941585f, 
    -0.46102768f, -0.25637433f, 0.10842314f, 0.09127443f, 0.08477068f, -0.16789140f, 0.07229602f, -0.13215657f, 
    -0.09545586f, -0.01069959f, -0.06106272f, 0.17725568f, 0.13266133f, 0.14153162f, -0.13409670f, 0.16328011f, 
    -0.07759492f, -0.05093395f, -0.14125423f, -0.03028779f, -0.06457145f, -0.19248803f, -0.20001613f, 0.12446574f, 
    0.07339508f, -0.02089783f, 0.13721311f, -0.24150421f, 0.02806315f, 0.15927757f, 0.24551257f, -0.15266712f, 
    -0.13359822f, 0.16003734f, -0.09901035f, 0.44844183f, 0.12793878f, 0.13045843f, -0.18963143f, -0.07976248f, 
    -0.04883280f, 0.16441895f, 0.17367631f, -0.03925432f, -0.05216634f, -0.10061402f, -0.16827124f, 0.22430518f, 
    -0.11544955f, 0.06082813f, -0.06488845f, 0.26224965f, 0.04696826f, 0.35569623f, -0.18288819f, 0.08640836f, 
    0.15561041f, -0.17770231f, 0.11030035f, -0.17859226f, -0.03636422f, 0.22852971f, -0.29103202f, -0.11376563f, 
    0.15282825f, 0.18975630f, 0.00731759f, 0.09616185f, -0.16910084f, 0.10693141f, -0.16016178f, -0.09988801f, 
    0.02715695f, -0.17800918f, -0.08402057f, 0.07904093f, 0.11867271f, -0.07834148f, -0.05033680f, 0.00510007f, 
    -0.28858277f, 0.08933888f, -0.02740466f, 0.05900525f, -0.31701416f, -0.11997393f, -0.07120592f, 0.02586972f, 
    -0.00465021f, -0.14613427f, 0.25945234f, 0.13979912f, 0.15827528f, -0.03676026f, 0.09472591f, -0.22197160f, 
    0.03120743f, 0.33637568f, 0.15962642f, -0.35241917f, -0.10107983f, -0.01594418f, -0.08044457f, 0.17735803f, 
    0.03632491f, -0.07201514f, -0.09562719f, 0.35732812f, 0.19696629f, -0.14312524f, 0.10618509f, 0.00907465f, 
    -0.04630631f, -0.00103534f, 0.01229463f, -0.39379579f, 0.25044078f, -0.11797691f, -0.08131031f, -0.16410483f, 
    0.06709684f, -0.11454520f, 0.25272465f, -0.07131259f, 0.05965019f, -0.06060836f, -0.09617738f, -0.00569424f, 
    0.11683688f, -0.03970245f, -0.01886516f, -0.09238873f, -0.01598148f, 0.06580667f, -0.10109089f, 0.25298855f, 
    -0.07094365f, -0.02371465f, 0.06447168f, -0.21973461f, 0.11545265f, 0.07488251f, -0.06589126f, 0.19471765f, 
    0.00886224f, 0.09903703f, -0.05548738f, 0.04426089f, 0.00133879f, -0.16694188f, 0.03818439f, -0.30841860f, 
    -0.01966194f, 0.08916479f, 0.01186577f, -0.15885691f, -0.02743549f, -0.13543271f, 0.05180152f, 0.23259309f, 
    0.03059665f, -0.08164354f, 0.21302684f, -0.61140358f, 0.01389447f, -0.03440268f, -0.02713194f, 0.03530529f, 
    0.20578252f, 0.00365325f, 0.06371386f, 0.37138945f, -0.04384024f, 0.12373964f, 0.17472947f, -0.00958152f, 
    0.10370401f, 0.21234719f, -0.08440211f, 0.36523312f, -0.08439438f, 0.18128480f, 0.01159468f, -0.00801437f, 
    -0.06994238f, 0.02934722f, 0.33660573f, -0.23061827f, -0.07052745f, -0.16790117f, 0.04598382f, -0.16347213f, 
    -0.06148599f, 0.14674030f, 0.00215985f, 0.12710989f, -0.01992230f, -0.22789894f, -0.09016702f, -0.04754183f, 
    0.06387858f, -0.05256574f, 0.02264146f, -0.18602605f, 0.00771167f, -0.01387976f, -0.11309075f, -0.14266506f, 
    0.13167557f, 0.01997229f, -0.02893271f, 0.09207761f, -0.04672502f, 0.21083157f, 0.05252349f, -0.10171051f, 
    0.06345841f, -0.03402319f, -0.02335179f, 0.01461148f, 0.10769650f, 0.05226765f, 0.01613635f, 0.20634849f, 
    -0.26127064f, 0.31956211f, 0.47845826f, 0.16762622f, -0.18452546f, 0.19523028f, -0.09705766f, -0.00611764f, 
    -0.09204625f, 0.45933148f, 0.48415378f, 0.08437029f, 0.13846463f, 0.01039163f, 0.13185675f, 0.19153041f, 
    0.01930653f, 0.04701852f, 0.09980112f, -0.20779310f, -0.34169859f, 0.13056000f, 0.03024182f, -0.06365936f, 
    -0.15347940f, -0.00408413f, -0.02596295f, -0.04435430f, 0.20618385f, 0.25982136f, -0.27010673f, -0.22201551f, 
    -0.12760116f, -0.07750296f, -0.19609505f, -0.13723215f, -0.20279488f, -0.44677600f, -0.15155086f, -0.24007171f, 
    0.04533998f, -0.03745489f, 0.05528701f, 0.02394202f, 0.03315909f, -0.15977852f, 0.12064976f, -0.09733123f, 
    -0.18322287f, -0.09619887f, 0.03957950f, 0.05745520f, -0.01051768f, 0.07579144f, -0.16684577f, 0.15365572f, 
    -0.00569943f, 0.17965372f, -0.20726654f, -0.02054393f, -0.00196797f, 0.08387864f, 0.04794715f, 0.39168265f, 
    -0.31044120f, -0.00576713f, -0.11916523f, -0.19808166f, 0.06302674f, -0.06796332f, -0.08025882f, -0.05619320f, 
    -0.00184438f, 0.05889278f, -0.01430195f, 0.05239153f, 0.06694046f, 0.06798387f, -0.03594450f, 0.07873116f, 
    -0.01077565f, 0.01329210f, 0.04495647f, -0.03492827f, -0.07744566f, -0.05189665f, -0.01655810f, 0.00856068f, 
    -0.01614757f, -0.04263893f, -0.06186964f, -0.08173504f, -0.03039177f, 0.04582578f, -0.01263969f, 0.02836820f, 
    0.06741785f, -0.04767112f, 0.02929465f, 0.04258043f, 0.06654444f, -0.07672971f, -0.04513039f, -0.08538349f, 
    0.02077170f, 0.02855997f, -0.07305198f, -0.05847219f, -0.06548723f, -0.00162454f, -0.00650225f, -0.03297100f, 
    -0.00888630f, -0.00676590f, 0.05411638f, 0.04916444f, -0.00302989f, -0.04848377f, 0.05237309f, -0.06227679f, 
    0.04425525f, -0.04443194f, -0.04505451f, 0.01042946f, -0.03757785f, -0.08490940f, -0.04380985f, -0.09226125f, 
    0.06318367f, -0.01317441f, 0.05247297f, 0.07022823f, -0.00799443f, -0.03859622f, -0.07766340f, -0.02196811f, 
    0.02332965f, -0.05052118f, -0.08080540f, 0.01111065f, -0.09365741f, 0.06309614f, 0.05904718f, -0.03705177f, 
    -0.05383456f, 0.02039891f, -0.06651110f, -0.04912299f, -0.04291030f, -0.07137950f, -0.02535899f, 0.05438479f, 
    -0.02303277f, 0.03950376f, -0.07123242f, -0.09180814f, -0.05789046f, -0.06686919f, -0.07129274f, 0.04913232f, 
    -0.03569722f, 0.00223273f, 0.03389808f, -0.02394747f, 0.04330767f, 0.00682110f, -0.04525230f, 0.00181327f, 
    0.05964981f, 0.03649966f, -0.08178505f, -0.05437167f, 0.00634385f, -0.04361432f, -0.07145787f, -0.08900519f, 
    -0.01467223f, -0.05840800f, -0.08184247f, -0.00464214f, -0.03310956f, -0.07789724f, -0.04652691f, -0.07764000f, 
    0.04245695f, 0.05299562f, 0.02238029f, -0.05245851f, 0.04027624f, -0.08028654f, 0.04954023f, -0.08617558f, 
    -0.00920931f, -0.00002172f, -0.01791185f, 0.03987135f, -0.04772136f, 0.00969547f, -0.02083673f, -0.08089896f, 
    -0.07050779f, 0.03868752f, -0.00137970f, -0.06608616f, -0.01362908f, -0.02838025f, 0.05515070f, -0.04715365f, 
    0.01170234f, 0.01019256f, -0.02374675f, 0.06175247f, -0.00150744f, -0.03777563f, -0.04733348f, 0.01945107f, 
    0.21614318f, -0.03726147f, 0.23342408f, 0.07692709f, 0.13522321f, 0.05735080f, 0.06466717f, 0.11412758f, 
    -0.12671408f, -0.38638428f, -0.29442337f, 0.08517735f, 0.09641830f, -0.06608699f, -0.14169322f, -0.05984312f, 
    -0.34589860f, -0.09946983f, -0.18578172f, -0.11024594f, -0.45541203f, 0.11282371f, 0.22906782f, 0.09355601f, 
    0.01023480f, -0.08942297f, 0.10378379f, -0.39811859f, -0.13316043f, 0.07415266f, -0.06156033f, 0.19163735f, 
    -0.24620269f, 0.03777259f, 0.02898830f, 0.07488336f, 0.21082206f, 0.18685801f, 0.30238003f, 0.03489216f, 
    -0.05381179f, -0.07573397f, -0.06805395f, -0.03824501f, -0.02420848f, -0.26355478f, -0.17974338f, -0.11861158f, 
    -0.04580898f, -0.04382904f, -0.13493103f, 0.07250270f, 0.10677559f, 0.08467777f, 0.14342749f, -0.03217197f, 
    0.19570972f, 0.05087387f, 0.08411559f, -0.03927070f, 0.18175723f, -0.00444153f, 0.02753872f, 0.12109469f, 
    -0.08210378f, 0.18730773f, 0.10060590f, 0.08259372f, 0.24910444f, 0.04635672f, -0.03470382f, -0.03938940f, 
    -0.15464427f, -0.30951643f, -0.31318930f, 0.06393337f, 0.09150951f, 0.11606111f, 0.01355607f, 0.00809179f, 
    -0.21313369f, 0.36285594f, -0.13790597f, -0.41256434f, 0.13282163f, 0.19298156f, 0.07446885f, 0.16044053f, 
    -0.17968991f, -0.09815454f, 0.43789464f, -0.06387910f, -0.05677558f, -0.08838431f, 0.13798821f, 0.04525986f, 
    -0.04798127f, -0.10976907f, -0.01293262f, -0.00755101f, -0.17376211f, 0.05350635f, 0.03777486f, -0.20610629f, 
    -0.13893503f, -0.08254747f, -0.09547525f, 0.24133867f, 0.02238470f, 0.18565316f, 0.03044202f, -0.26609850f, 
    0.07922392f, 0.19484009f, -0.19570154f, 0.18016541f, 0.27214307f, -0.04891004f, 0.25706109f, 0.16480087f, 
    0.17206712f, 0.05870278f, 0.01989457f, 0.07975327f, 0.12836318f, -0.14405397f, -0.34865040f, -0.01006171f, 
    -0.13864414f, -0.02472756f, 0.12750638f, 0.11408971f, 0.01920546f, 0.08389433f, 0.13301837f, -0.32023007f, 
    0.31848305f, 0.01487741f, -0.13858359f, -0.10711227f, 0.10678105f, -0.07315752f, -0.19904387f, 0.06017550f, 
    -0.44856650f, -0.00230492f, -0.00670706f, 0.15999845f, 0.03471630f, 0.24758455f, 0.07295776f, -0.00685721f, 
    -0.15628052f, -0.05496383f, 0.05106398f, -0.02917165f, 0.05327491f, 0.19632377f, 0.14501584f, 0.05626791f, 
    -0.10635687f, -0.41513878f, -0.07148384f, -0.27398470f, 0.05050541f, -0.32640076f, 0.04093952f, -0.04859746f, 
    -0.14892560f, -0.04741930f, 0.06814625f, 0.35829392f, -0.14424835f, 0.19075923f, 0.04963224f, -0.04183799f, 
    0.08480579f, -0.05761478f, -0.01514938f, 0.09374531f, -0.01328666f, -0.11707813f, -0.07664916f, -0.13743387f, 
    0.14276427f, -0.21564060f, 0.23666501f, -0.08043273f, 0.16778825f, -0.03191631f, -0.17381768f, -0.14068447f, 
    -0.20520313f, -0.30135584f, 0.09530580f, 0.14503062f, 0.10358494f, 0.12885597f, -0.03316940f, -0.10755471f, 
    0.05897995f, -0.04338124f, 0.11049119f, 0.02898938f, 0.02519342f, 0.06701610f, -0.11085602f, -0.18463370f, 
    -0.10285840f, 0.25189713f, 0.15851764f, -0.02652721f, 0.17578951f, 0.27452791f, -0.05922398f, -0.16528393f, 
    -0.38832766f, -0.01699205f, 0.09757379f, -0.24780431f, -0.08059511f, -0.07690491f, 0.15934040f, 0.12644176f, 
    0.18112561f, -0.14680707f, -0.09335347f, 0.42507416f, -0.56258136f, -0.23898640f, 0.20687315f, -0.03318588f, 
    0.15434757f, 0.17412917f, 0.41416892f, 0.17422763f, -0.08147330f, -0.17790096f, 0.20532328f, -0.07115942f, 
    -0.03564807f, 0.08839791f, -0.10776049f, 0.12614492f, -0.10449197f, 0.04739872f, 0.34232527f, 0.07350545f, 
    -0.08118173f, 0.16265109f, -0.08914918f, 0.14467219f, -0.00338317f, 0.04299067f, 0.14699709f, 0.08850051f, 
    -0.06813288f, 0.05431594f, 0.16644910f, 0.03508572f, -0.32962760f, 0.01175061f, 0.09519067f, 0.17055468f, 
    0.04085332f, -0.00334413f, 0.09804884f, -0.04473874f, -0.21984573f, -0.07066177f, -0.31018668f, -0.14698435f, 
    0.27114287f, 0.14841320f, -0.00716145f, 0.19704890f, 0.20743704f, -0.09611581f, 0.12980711f, -0.09159781f, 
    -0.16035177f, 0.21785069f, -0.11935728f, -0.10928123f, 0.06257711f, -0.16515210f, -0.14040260f, -0.30080429f, 
    0.07687894f, -0.05333903f, -0.04438493f, -0.02642545f, 0.02645607f, 0.10762089f, 0.03166203f, 0.15369271f, 
    -0.21371573f, 0.12395354f, -0.29709077f, -0.03450205f, 0.33692697f, -0.15357161f, 0.02674498f, -0.13470213f, 
    -0.00981417f, -0.18361504f, 0.06166494f, -0.19183490f, -0.03994134f, -0.10147592f, 0.14012477f, -0.02927880f, 
    0.01084652f, -0.25050795f, 0.15511382f, 0.10041878f, 0.09302246f, -0.01918432f, -0.13260746f, -0.10175440f, 
    0.19190665f, -0.16198641f, 0.24357951f, -0.05786388f, 0.05057649f, -0.17961444f, -0.08993593f, 0.00702994f, 
    -0.14840876f, -0.04957177f, 0.07421941f, -0.18654576f, -0.05915131f, 0.19913855f, 0.11829776f, -0.20276181f, 
    -0.08669458f, -0.03880563f, 0.07579336f, -0.04373233f, -0.00743957f, -0.12062201f, -0.19463031f, -0.08409350f, 
    -0.02196036f, -0.05179165f, 0.02271451f, 0.17539489f, 0.03040662f, -0.11400881f, 0.11354035f, -0.09666502f, 
    0.22489846f, 0.12478508f, 0.10639258f, 0.14848977f, 0.10759075f, 0.20730315f, 0.07200832f, -0.04619589f, 
    0.29759645f, -0.17377415f, 0.23307192f, 0.18044028f, -0.25257802f, -0.06925341f, -0.07476792f, 0.09394164f, 
    0.09924801f, 0.19134179f, 0.20281595f, 0.16260789f, 0.24396189f, -0.09814754f, 0.29346922f, -0.00885041f, 
    0.11008067f, 0.28358731f, 0.27467489f, -0.23586757f, -0.06159400f, -0.12006593f, -0.07821186f, 0.16817640f, 
    -0.07781963f, 0.07089961f, -0.15684973f, 0.23070195f, 0.15855864f, -0.22577886f, 0.03569896f, 0.03817031f, 
    -0.23285125f, 0.02057470f, 0.12050235f, 0.08978803f, -0.02012136f, -0.29603419f, -0.02397576f, 0.03805359f, 
    0.18392983f, -0.28618729f, 0.02962810f, -0.18296403f, 0.05186675f, -0.41765067f, -0.08537595f, 0.20928659f, 
    -0.07919831f, -0.00195664f, -0.11710685f, -0.06762636f, -0.04244340f, -0.19527353f, -0.09282760f, -0.15288021f, 
    0.33923173f, 0.21059074f, 0.00084016f, 0.03195912f, 0.19824363f, -0.18167265f, 0.13363886f, -0.13281415f, 
    0.19981083f, -0.08597498f, -0.20636752f, 0.00655611f, -0.14060621f, -0.05438024f, 0.08595858f, -0.30448955f, 
    0.28974405f, 0.02794313f, -0.04102647f, 0.19447549f, -0.06049563f, 0.14075094f, 0.15251206f, 0.19967079f, 
    0.13751519f, -0.02399046f, -0.01708730f, 0.19332200f, -0.25109982f, 0.09004779f, -0.04427435f, -0.02831622f, 
    -0.02887319f, 0.01003105f, 0.12326539f, 0.13886912f, 0.32925284f, 0.05808718f, 0.11348668f, 0.04911864f, 
    0.16047212f, -0.14029166f, -0.04366673f, 0.00795803f, 0.04719926f, -0.07797364f, -0.14956719f, 0.02292609f, 
    0.17240997f, -0.04054013f, 0.19783726f, 0.06616234f, -0.33104807f, 0.06981271f, 0.08451290f, 0.20277295f, 
    0.27188689f, 0.00034442f, -0.14189599f, 0.10036896f, -0.06874432f, 0.03594372f, -0.15773241f, -0.09638228f, 
    0.04675383f, -0.03570830f, -0.08803367f, -0.04946396f, 0.07633018f, 0.05316624f, 0.01763178f, 0.07880174f, 
    0.21485291f, 0.17891674f, -0.08396238f, -0.02387988f, 0.06548105f, -0.18280621f, 0.00983606f, 0.05465898f, 
    -0.00083400f, 0.00979696f, -0.10603385f, -0.13701603f, -0.10967004f, -0.25752118f, -0.02242186f, -0.27735624f, 
    0.40428087f, 0.03497734f, 0.07782935f, 0.07200076f, -0.11048297f, 0.00550682f, -0.28659454f, 0.05742324f, 
    -0.01785308f, 0.27847129f, 0.51358813f, 0.52479208f, 0.00930601f, -0.12605214f, 0.23667055f, 0.12502138f, 
    0.04074403f, 0.20357104f, -0.07454126f, 0.21286798f, -0.58358377f, -0.08020530f, -0.07117930f, -0.13220561f, 
    -0.01427204f, -0.12289768f, -0.19873044f, -0.30281377f, 0.03236272f, 0.08413345f, -0.10302136f, -0.02773497f, 
    -0.03701596f, 0.08114170f, 0.08670948f, -0.18266103f, -0.47851264f, 0.10998915f, -0.27556717f, -0.19506077f, 
    -0.16251138f, -0.11660369f, -0.19446470f, -0.04472520f, 0.05624783f, -0.17269771f, 0.08804042f, 0.06286800f, 
    0.26754928f, -0.18041493f, 0.03950613f, -0.05471538f, -0.14366908f, -0.05888786f, 0.06826393f, -0.15464018f, 
    0.19042745f, -0.06088103f, 0.05206038f, -0.18447068f, -0.01116026f, 0.10728924f, -0.25141844f, 0.17122774f, 
    -0.03344506f, 0.01637628f, 0.06115242f, 0.16902089f, 0.01511601f, 0.06441300f, 0.05818402f, 0.10194454f, 
    -0.03194977f, 0.00232406f, -0.03261094f, 0.04088449f, 0.00716754f, -0.04443345f, -0.07120830f, -0.05315391f, 
    -0.05681765f, 0.07441355f, -0.08003108f, 0.05058037f, 0.00658152f, 0.06324525f, -0.04601208f, -0.11071186f, 
    -0.07113442f, 0.00021775f, -0.00849789f, 0.00050936f, -0.07722092f, -0.01425116f, 0.00415257f, -0.00624032f, 
    0.05152274f, -0.02725964f, 0.06520206f, -0.05675393f, -0.05608504f, -0.01457062f, -0.02641332f, -0.01451606f, 
    -0.02805398f, -0.03744096f, -0.09806173f, -0.00667782f, -0.03143679f, -0.12994488f, 0.03997207f, -0.00190452f, 
    0.07577588f, -0.02524739f, 0.02822744f, -0.03636704f, 0.08301133f, -0.05819410f, -0.09311392f, 0.00969301f, 
    0.03337416f, -0.10567679f, -0.11021997f, -0.06567068f, -0.09012035f, -0.03577236f, -0.11545133f, 0.00467072f, 
    0.00793736f, -0.03025057f, -0.08189978f, -0.00037490f, 0.01381199f, -0.07865074f, 0.07575727f, 0.01828296f, 
    -0.01158446f, 0.04601835f, -0.06133430f, -0.06474925f, -0.02612348f, -0.04026026f, -0.03363463f, 0.04066608f, 
    -0.04636694f, 0.01572565f, -0.00994281f, -0.07939661f, 0.03128774f, -0.11845503f, -0.04067948f, -0.06548968f, 
    0.05184991f, 0.00133192f, -0.04525521f, 0.05068900f, 0.03492383f, -0.09258045f, 0.03329954f, 0.03699102f, 
    -0.08990124f, -0.03454761f, -0.06686823f, 0.00450829f, 0.01571386f, 0.06369092f, -0.04606424f, 0.05146877f, 
    0.00080743f, 0.02720377f, -0.03675699f, 0.04503536f, -0.08682952f, 0.04516824f, -0.06716614f, -0.12036991f, 
    -0.05639385f, -0.09771221f, -0.07503366f, -0.07754551f, -0.04759699f, 0.02340771f, 0.07594754f, 0.06016864f, 
    0.04900429f, -0.01674430f, -0.05217871f, -0.10283504f, 0.00625501f, -0.05952976f, -0.12545508f, 0.03782356f, 
    -0.04791834f, 0.04018206f, 0.06946887f, 0.02216063f, -0.05732213f, 0.01570537f, -0.03340007f, -0.07500137f, 
    -0.02797138f, 0.01543340f, -0.00431925f, -0.08304828f, 0.01271148f, 0.02055001f, 0.04017142f, -0.06519801f, 
    -0.10434018f, 0.06115218f, 0.06825086f, -0.00406846f, -0.03328314f, -0.07963230f, -0.06728598f, 0.03295857f, 
    -0.06733748f, 0.07513576f, 0.14065567f, -0.12326615f, -0.00856605f, -0.06555506f, -0.01551366f, -0.05433204f, 
    0.14701092f, 0.16367121f, 0.13062103f, -0.28332156f, 0.02174164f, -0.08414370f, 0.00211642f, 0.23020139f, 
    0.08921181f, 0.10716331f, 0.07473818f, 0.46832642f, -0.09761541f, -0.11397795f, -0.13951062f, 0.09906773f, 
    -0.04382146f, 0.23268843f, 0.24057177f, 0.34046465f, -0.24154885f, -0.21386938f, -0.35989293f, -0.04822990f, 
    -0.05244736f, 0.08990059f, -0.01442513f, 0.14466280f, -0.21534680f, -0.50891608f, 0.47349772f, 0.21182358f, 
    0.18773775f, 0.20240189f, -0.15272567f, -0.16651709f, -0.09667172f, -0.29035190f, -0.31273693f, -0.17790687f, 
    -0.00497023f, 0.08697417f, 0.14111568f, -0.00167668f, -0.15482488f, 0.02340231f, -0.10573225f, -0.57841980f, 
    -0.03728989f, -0.03832944f, 0.12575571f, 0.15149933f, 0.00601709f, -0.01771997f, -0.06290522f, -0.14542438f, 
    -0.11497815f, 0.13473631f, -0.11496993f, -0.03143086f, -0.13257487f, 0.00373833f, 0.07782126f, -0.08249673f, 
    -0.23554018f, 0.15913369f, 0.23425359f, -0.10486220f, -0.09436885f, -0.11253588f, 0.07170523f, 0.07129981f, 
    -0.27133197f, 0.15816492f, 0.35928148f, -0.03100383f, -0.09723788f, 0.21653752f, 0.01258691f, 0.07649048f, 
    0.12766853f, -0.10851607f, 0.02483751f, 0.08343004f, -0.17029145f, 0.10644024f, 0.02691908f, -0.00076511f, 
    0.00470049f, 0.17862029f, -0.06247546f, 0.45418528f, -0.48174965f, -0.12964498f, -0.21938667f, -0.25210425f, 
    0.01939559f, -0.11085524f, 0.07906856f, -0.20066857f, 0.06475952f, -0.11620355f, 0.14764549f, 0.08035774f, 
    0.07571930f, 0.06661535f, 0.13381530f, -0.15944828f, 0.04669080f, 0.11266460f, -0.21461129f, 0.18275124f, 
    0.26308995f, -0.04129621f, -0.21416530f, 0.04007592f, -0.08746035f, 0.04223001f, -0.06594231f, 0.20372534f, 
    -0.12951443f, 0.10382254f, -0.05825595f, -0.08211219f, -0.09942406f, 0.10414091f, 0.07942298f, 0.19282314f, 
    -0.50152856f, 0.08131381f, 0.09791312f, -0.03487277f, -0.08729830f, 0.06501473f, -0.18633190f, -0.06028445f, 
    0.03525611f, -0.14167172f, 0.16333131f, 0.18874523f, 0.22975852f, -0.17360343f, -0.02415560f, 0.00855309f, 
    0.06559788f, -0.34356359f, -0.02292404f, 0.04336626f, 0.04514487f, 0.15690936f, 0.13454038f, -0.06930406f, 
    -0.04122084f, -0.21185365f, -0.05190763f, 0.12603323f, -0.16999923f, 0.24981575f, 0.11019987f, 0.08821161f, 
    0.01872553f, -0.06393400f, -0.04027879f, -0.02855568f, -0.01283014f, 0.15736780f, 0.04576369f, -0.12781902f, 
    -0.09429400f, -0.06008866f, -0.07811513f, -0.04031289f, 0.78221738f, 0.31678057f, -0.03716227f, 0.14319222f, 
    -0.10481869f, 0.03028513f, 0.18584207f, -0.13031109f, 0.07741259f, -0.52276206f, -0.07798725f, -0.25190926f, 
    -0.00217110f, -0.06774183f, 0.02489549f, -0.00011590f, 0.00492071f, -0.15742113f, 0.35271567f, -0.33399552f, 
    -0.05830529f, -0.08577364f, -0.07223534f, 0.00849312f, 0.07971797f, 0.20089597f, 0.09496439f, -0.53594887f, 
    0.05872919f, -0.11077496f, 0.11381500f, 0.24155875f, 0.14099994f, -0.01428284f, -0.16025847f, -0.10059219f, 
    -0.08578157f, 0.30110601f, 0.03180172f, -0.37883893f, -0.17907523f, -0.11122309f, -0.11466625f, 0.10899274f, 
    0.02841329f, -0.49636614f, -0.10384548f, -0.08652069f, 0.08010466f, -0.05433926f, 0.13523746f, -0.43903559f, 
    0.17757826f, 0.12638931f, -0.26435372f, -0.16390221f, -0.06452450f, 0.08666187f, 0.06769708f, -0.04985490f, 
    0.05949169f, 0.03260054f, 0.04388137f, 0.20522855f, 0.29205230f, -0.12333391f, 0.26980287f, 0.14920872f, 
    -0.24975412f, 0.08613543f, 0.03563031f, -0.14885284f, 0.10928890f, 0.08424666f, -0.10788370f, 0.19531591f, 
    0.00513769f, -0.03401252f, 0.20025955f, -0.05514894f, -0.13560854f, 0.54161334f, -0.02363231f, 0.10400482f, 
    0.03101301f, 0.11600106f, 0.16206305f, 0.23123008f, 0.10471031f, 0.13247648f, -0.01126554f, 0.23271434f, 
    -0.22090855f, 0.01199434f, -0.04003329f, 0.01763816f, 0.17797878f, 0.20575489f, 0.10397234f, 0.15031688f, 
    -0.28931671f, 0.03430743f, 0.20904972f, 0.00618763f, 0.20378290f, -0.07127560f, 0.06271578f, -0.18180157f, 
    0.15415263f, 0.31676519f, 0.03115632f, 0.00223062f, 0.07794139f, 0.01363033f, 0.00106398f, 0.15071429f, 
    0.00629227f, 0.44256154f, 0.09280278f, -0.30685878f, 0.09973655f, -0.13926701f, -0.11688655f, 0.21227208f, 
    -0.20787510f, 0.13467884f, 0.33651647f, 0.35560870f, 0.13345508f, 0.15849634f, -0.00479961f, 0.07570531f, 
    0.14400943f, 0.11550746f, 0.02785218f, -0.11962948f, -0.84537840f, -0.13843484f, -0.06324252f, -0.00906034f, 
    -0.08955022f, -0.07693392f, 0.09045165f, -0.10479394f, 0.05248934f, 0.19213247f, -0.14945757f, 0.05766707f, 
    -0.04099279f, 0.01655527f, -0.04503486f, -0.05045588f, -0.03858751f, -0.15810399f, -0.51314920f, 0.00477271f, 
    -0.07118350f, 0.08118323f, -0.01264149f, 0.07871263f, 0.02779506f, 0.12319906f, -0.09675159f, -0.07761678f, 
    0.27076387f, 0.10626497f, -0.00534526f, -0.09977169f, -0.22406381f, -0.01352784f, 0.00427764f, 0.30570918f, 
    0.30246529f, 0.19429323f, -0.08774236f, 0.09121379f, 0.06044075f, -0.02954592f, 0.20805731f, 0.20777455f, 
    0.14565699f, -0.20543298f, -0.01699836f, 0.02932811f, 0.00889245f, 0.26454151f, 0.07092399f, -0.04614667f, 
    -0.21646181f, 0.33467150f, 0.26943833f, -0.31842121f, -0.04745331f, 0.05380639f, -0.13684291f, 0.10424858f, 
    -0.02526247f, -0.04857084f, -0.64810026f, 0.25708285f, -0.31724456f, 0.18362114f, 0.02177775f, -0.06492700f, 
    0.07770532f, 0.03888543f, 0.09280126f, 0.14188628f, -0.47827485f, -0.36377534f, 0.10675465f, -0.04874772f, 
    -0.20193523f, 0.00204115f, -0.09647836f, -0.03853269f, -0.34597978f, 0.14138635f, 0.03645374f, 0.15105818f, 
    -0.16575557f, 0.09971239f, -0.08977324f, 0.16278312f, 0.12141824f, 0.00550791f, 0.15004393f, -0.11141728f, 
    -0.12788083f, -0.23395646f, 0.17708799f, 0.11617653f, 0.06699752f, -0.01204751f, -0.10051962f, -0.54585922f, 
    0.07107572f, 0.08949655f, 0.14207703f, 0.32548800f, -0.00107713f, 0.13012335f, 0.15970759f, -0.16693516f, 
    -0.12997067f, -0.11913425f, 0.03393079f, -0.16068164f, 0.16341789f, -0.03194139f, -0.12926029f, 0.19502985f, 
    0.53878731f, 0.08619634f, 0.15488541f, 0.02380687f, -0.03758539f, -0.07111776f, -0.15427171f, 0.33131611f, 
    0.11080421f, -0.05169764f, -0.05857576f, 0.18164925f, 0.10689288f, -0.14517415f, -0.17534004f, -0.04239244f, 
    0.11981390f, 0.15628846f, -0.63564020f, -0.21854678f, -0.24098319f, 0.06756374f, 0.08417748f, -0.06949595f, 
    0.07145265f, 0.13294919f, -0.11225885f, -0.22405374f, -0.03314476f, 0.04819883f, 0.35119307f, 0.17379470f, 
    0.03083575f, 0.08970688f, 0.09422453f, 0.00112980f, 0.11057253f, 0.07943519f, 0.35587233f, 0.05415261f, 
    0.31202310f, -0.07129719f, 0.10770511f, 0.02547445f, -0.03869046f, -0.29569760f, -0.09676494f, -0.21715702f, 
    -0.08233675f, 0.09079554f, -0.03499082f, 0.19817619f, 0.09259295f, 0.21511327f, 0.12586230f, 0.27851737f, 
    -0.04751670f, -0.26812732f, 0.09078565f, 0.00793724f, -0.08552895f, 0.19733565f, -0.05762254f, -0.19201829f, 
    -0.03479149f, -0.12019435f, 0.00549558f, 0.09326632f, -0.00717616f, 0.05704535f, 0.05537770f, -0.00168743f, 
    0.01950912f, -0.06632078f, -0.12836224f, 0.12233132f, 0.18660647f, 0.15400001f, -0.13821144f, -0.26324257f, 
    -0.12693383f, -0.20502602f, -0.15622382f, -0.26468459f, 0.10567390f, 0.05468297f, 0.17291917f, 0.09566379f, 
    -0.24922098f, -0.13331552f, -0.67741346f, -0.20352598f, -0.06763979f, 0.00819601f, 0.00061407f, 0.01778193f, 
    0.08193029f, -0.04481682f, 0.14701565f, 0.14614062f, -0.35945991f, 0.01069285f, 0.10069297f, -0.01728587f, 
    0.07289403f, -0.00937762f, -0.01786404f, 0.13572840f, 0.17690727f, -0.06015957f, 0.23910263f, 0.05511175f, 
    0.06523901f, 0.04539867f, 0.10559477f, 0.09864257f, 0.27007580f, 0.07294030f, 0.08468159f, 0.24167651f, 
    -0.20335256f, -0.27443621f, 0.26336849f, 0.04697575f, 0.22888669f, -0.03197427f, -0.04371897f, 0.15388495f, 
    -0.12483408f, 0.01508809f, 0.26490146f, 0.14514534f, -0.01554624f, 0.04852505f, -0.15822589f, -0.06184012f, 
    0.24530302f, 0.08383174f, -0.11430823f, -0.07466600f, -0.02235595f, -0.07316424f, -0.02618960f, -0.07468545f, 
    0.22222354f, 0.27344948f, 0.08645442f, 0.18189992f, 0.20791210f, -0.06308404f, 0.08681855f, -0.03042497f, 
    0.03893948f, 0.15622899f, -0.12322459f, 0.00625813f, 0.25212699f, -0.01085987f, -0.17650463f, 0.06094166f, 
    -0.07011313f, -0.19373542f, -0.26706013f, -0.01410910f, -0.03475972f, 0.19420588f, 0.06152565f, 0.13222320f, 
    -0.09008543f, -0.02515570f, -0.09080261f, -0.11835543f, -0.02098539f, 0.22694433f, 0.07455097f, -0.14738783f, 
    -0.03975613f, 0.14049141f, -0.01713300f, 0.03147328f, -0.20193297f, 0.05072250f, 0.40239722f, 0.02202209f, 
    0.21031058f, -0.08419646f, 0.00294477f, -0.09451400f, 0.01175736f, 0.04721771f, -0.04895559f, -0.63051289f, 
    -0.12289085f, -0.05162130f, 0.13377950f, 0.22586522f, -0.08239991f, 0.22184619f, -0.27083600f, -0.03106876f, 
    -0.03270916f, -0.05247368f, -0.16334197f, -0.09640889f, -0.04191105f, 0.15172358f, 0.13850106f, -0.20588294f, 
    -0.06922781f, 0.03647522f, 0.06894021f, -0.06703882f, 0.07819587f, 0.15671876f, 0.14336120f, -0.15498777f, 
    -0.26578748f, -0.03649184f, 0.19240357f, 0.13092430f, 0.18177475f, -0.14529398f, -0.12036853f, -0.26577932f, 
    -0.12188458f, -0.38413993f, -0.25045687f, 0.00211000f, 0.19923477f, 0.04055233f, -0.05818136f, 0.06499006f, 
    -0.11346016f, 0.22541068f, 0.55360615f, -0.18070434f, -0.13618325f, -0.25602695f, 0.14585580f, -0.14619179f, 
    -0.09073057f, 0.13770317f, 0.01527020f, -0.26409256f, -0.11186823f, 0.00378606f, -0.01874487f, -0.15800762f, 
    -0.00587967f, 0.08221651f, -0.05081635f, -0.16224954f, -0.09877270f, 0.03329949f, 0.11681237f, -0.29893392f, 
    0.00824326f, -0.04927376f, -0.05873600f, 0.08020703f, 0.01739741f, -0.12476287f, 0.16334637f, 0.05906098f, 
    0.13754374f, -0.02098937f, 0.12535253f, -0.09105531f, 0.01125720f, 0.00416939f, -0.08390173f, 0.19682120f, 
    0.19932832f, 0.08327795f, 0.17486568f, -0.03766371f, 0.12985609f, -0.03494643f, 0.10713589f, -0.19568807f, 
    -0.05994777f, -0.02425821f, -0.01750429f, -0.10296129f, 0.02533063f, -0.17913806f, -0.08987331f, -0.06019941f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.09610951f, 0.24686918f, 0.25210220f, -0.03435437f, -0.10262288f, 0.07097942f, 0.14831468f, 0.23732463f, 
    0.08247185f, -0.24203102f, -0.07050804f, -0.00677247f, 0.03675671f, 0.19521457f, 0.24793409f, 0.14910544f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.30176359f, -0.22061670f, -0.29080412f, -0.03469271f, -0.13111097f, 0.06526867f, -0.04323357f, -0.13332793f, 
    -0.39486629f, 0.53305805f, 0.11160490f, 0.06692628f, 0.04124227f, 0.06587896f, -0.06819700f, 0.14264536f, 
    0.13705939f, 0.18709645f, -0.04393650f, 0.31865236f, 0.17578059f, 0.20526926f, -0.30918130f, 0.32988015f, 
    -0.16719641f, 0.29822257f, 0.09365816f, 0.38500842f, 0.03723877f, 0.08520615f, 0.03176530f, -0.40964165f, 
    -0.27633670f, -0.09590819f, -0.23682798f, -0.31227013f, 0.13384683f, -0.14971443f, 0.29833326f, 0.01091343f, 
    0.00081378f, 0.20176353f, -0.18007873f, -0.36881334f, 0.21687175f, 0.31207433f, 0.49012649f, 0.08605443f, 
    -0.18733223f, 0.60678113f, 0.37113714f, -0.19775151f, -0.02807385f, 0.24988978f, 0.14200890f, -0.03195987f, 
    -0.03658933f, -0.08909228f, 0.17760329f, -0.22546069f, 0.11470395f, 0.43457061f, -0.23286860f, -0.07636961f, 
    0.42504475f, 0.22845919f, 0.53258437f, 0.31911239f, 0.08514266f, 0.23133375f, -0.35344025f, 0.62596291f, 
    0.40284148f, -0.17180130f, -0.12687765f, 0.05540824f, -0.12700930f, 0.33142519f, -0.41724285f, -0.15887497f, 
    0.21853054f, -0.33837292f, 0.24694185f, 0.25512567f, -0.31967929f, 0.20183212f, -0.29017952f, 0.20116480f, 
    0.18066932f, -0.10240780f, -0.19684328f, -0.51380020f, 0.40355155f, 0.43744588f, 0.00963626f, -0.18677945f, 
    0.27947968f, 0.38786817f, 0.16841640f, -0.24957459f, 0.19828936f, -0.23800540f, -0.40011895f, -0.07365129f, 
    0.16064078f, 0.26978233f, 0.10794749f, 0.37387165f, -0.19297647f, 0.37512317f, -0.02653764f, -0.18785559f, 
    -0.14973196f, 0.41608199f, -0.33689576f, 0.41270471f, 0.10406144f, -0.13693945f, -0.10238624f, 0.14066224f, 
    0.21393669f, 0.20342560f, -0.01188102f, -0.40400746f, 0.15427428f, -0.29079017f, 0.31063434f, 0.09738223f, 
    -0.04070985f, -0.51275980f, -0.18986842f, 0.04176744f, 0.50493944f, 0.23999353f, 0.12627147f, -0.26652983f, 
    0.30858502f, 0.23375526f, -0.11847514f, -0.11993811f, -0.28923792f, 0.03677238f, 0.38266802f, 0.20054442f, 
    -0.02160075f, 0.43921497f, -0.25125802f, 0.17931919f, -0.20298633f, 0.19975345f, 0.09867717f, 0.24478480f, 
    -0.03447130f, -0.38915846f, -0.24456541f, -0.11907685f, 0.54760796f, 0.14456528f, 0.04949141f, -0.03933595f, 
    0.09283899f, -0.39473712f, 0.30810529f, -0.05171129f, -0.51169425f, 0.05925003f, 0.19870085f, -0.16497126f, 
    -0.30285737f, 0.09690808f, 0.22687663f, 0.17755006f, 0.38971096f, 0.18495516f, 0.25383669f, -0.63433713f, 
    0.19026914f, -0.34595329f, 0.41248095f, -0.36099368f, -0.01543846f, -0.08914830f, -0.14502613f, 0.09757942f, 
    0.09099904f, -0.03395369f, -0.08737548f, -0.14368466f, 0.01254094f, 0.56918627f, 0.22830608f, -0.45305270f, 
    -0.06843290f, -0.14960121f, 0.01730413f, -0.31756973f, 0.09834475f, 0.16378213f, 0.20928855f, -0.29450157f, 
    -0.55578291f, -0.00580425f, -0.05754226f, 0.39467770f, -0.27074096f, 0.51859879f, 0.40896678f, -0.32587025f, 
    0.33355942f, -0.23467678f, 0.03177476f, -0.09686188f, 0.17534669f, 0.10957390f, 0.46955550f, 0.30865189f, 
    0.03385030f, -0.61840826f, -0.03052674f, -0.00781721f, 0.03648752f, -0.39114141f, 0.26401779f, -0.00579555f, 
    -0.51077271f, -0.01267831f, -0.32911539f, -0.33785412f, -0.27251557f, -0.06636509f, 0.09084835f, 0.25782606f, 
    -0.26278478f, -0.00434263f, -0.05799460f, -0.05151088f, -0.19198518f, 0.63038379f, 0.18222785f, 0.16841596f, 
    -0.11895959f, 0.18446231f, -0.17446305f, -0.38436115f, -0.26670796f, -0.10890488f, 0.27440977f, 0.16958971f, 
    0.15467431f, -0.05406705f, 0.23244950f, -0.71179396f, 0.02083075f, -0.29993436f, -0.02189431f, 0.14172900f, 
    0.35746184f, -0.00305554f, -0.12469830f, 0.56773430f, 0.36061671f, -0.09412515f, 0.20927911f, -0.17608890f, 
    0.04467992f, 0.12364849f, 0.05629573f, 0.55425048f, -0.41922528f, 0.02732182f, -0.24695650f, -0.14253016f, 
    -0.09072562f, 0.16040519f, -0.00678065f, -0.63762951f, -0.09273718f, -0.19632766f, 0.07123318f, 0.29405639f, 
    -0.90730870f, 0.39209679f, -0.15317039f, 0.62598437f, -0.21181042f, -0.03628949f, 0.33679166f, -0.18671517f, 
    -0.49531588f, -0.20470431f, 0.25472537f, 0.03232541f, -0.23770779f, -0.19257838f, 0.20373739f, -0.22124980f, 
    0.12182254f, 0.07047874f, -0.04277930f, -0.15713988f, 0.54037696f, -0.21528256f, 0.11639499f, -0.41366693f, 
    0.25682759f, 0.13809311f, -0.17353852f, -0.45083356f, 0.26421192f, -0.24041165f, -0.22512875f, -0.29152873f, 
    -0.20983902f, 0.31817013f, -0.05037746f, -0.18266764f, 0.25800124f, 0.33318469f, 0.26886219f, -0.07639387f, 
    -0.08164951f, 0.17446661f, -0.11626696f, -0.12047200f, -0.28664374f, 0.08949120f, 0.32965779f, 0.32015160f, 
    0.49612820f, -0.05835867f, 0.16020806f, -0.34433648f, -0.20834385f, -0.07322526f, 0.05099141f, 0.69615221f, 
    0.22496553f, 0.56563222f, 0.07910703f, -0.07469070f, -0.42751613f, -0.06497057f, -0.06032215f, 0.07701020f, 
    -0.38229898f, -0.33954832f, 0.07114098f, 0.29336762f, 0.11121470f, 0.15504815f, 0.12938409f, -0.16467315f, 
    0.07567030f, -0.03610958f, -0.42901507f, 0.07797632f, 0.37865692f, -0.10913736f, 0.32754672f, 0.37873587f, 
    -0.19282429f, -0.58550853f, 0.10651891f, 0.48794645f, 0.38768908f, -0.23042491f, 0.09756169f, -0.16976257f, 
    0.04332398f, 0.23656999f, 0.14592500f, -0.02768961f, -0.26106238f, -0.22718696f, -0.45259315f, 0.33089957f, 
    0.03319392f, 0.51658773f, 0.22049765f, 0.31818286f, -0.19569039f, 0.38066646f, -0.01868402f, 0.27842912f, 
    0.14645900f, 0.15139097f, -0.21906637f, 0.18731399f, -0.22347137f, -0.21709396f, 0.07521199f, -0.29286367f, 
    0.16095069f, -0.21694860f, -0.17059661f, -0.07777332f, -0.06334404f, -0.18622394f, -0.19565463f, -0.11772765f, 
    -0.32740930f, 0.83055675f, -0.49232495f, -0.18682235f, 0.06011030f, -0.17256190f, 0.05392022f, 0.31827229f, 
    0.03431109f, -0.27215987f, 0.16692731f, -0.04561419f, 0.02531126f, 0.31777522f, -0.04002270f, -0.31876349f, 
    0.40328738f, -0.30466834f, -0.16925041f, 0.05731871f, 0.36935544f, 0.21583468f, -0.29661295f, -0.23848605f, 
    0.44031912f, 0.67208743f, 0.12006919f, 0.10719287f, -0.04788254f, -0.09456065f, -0.39105615f, 0.08839127f, 
    0.24800548f, -0.11017568f, 0.60872012f, 0.14836009f, -0.29892129f, -0.02293780f, -0.06597252f, -0.02669378f, 
    0.34188545f, -0.09976181f, 0.02247486f, 0.41889021f, 0.11836981f, -0.05575992f, 0.09726428f, 0.21133003f, 
    -0.00122967f, 0.14899416f, 0.01278318f, -0.05823073f, -0.15301669f, -0.09371250f, 0.48520386f, 0.06809297f, 
    0.11027554f, -0.61185038f, -0.19024481f, -0.39425346f, -0.07886372f, -0.41260198f, 0.31685981f, 0.71457106f, 
    -0.30846459f, 0.11396168f, 0.07869389f, 0.60926867f, -0.09588572f, 0.14762281f, 0.06780119f, 0.56104052f, 
    0.52233464f, 0.27235535f, 0.13026385f, -0.26133835f, 0.14973989f, 0.03087775f, -0.33591923f, 0.05404813f, 
    0.37569746f, 0.06132906f, -0.46129441f, -0.03068714f, 0.21084867f, 0.17228767f, -0.06565378f, 0.11474706f, 
    -0.12601098f, 0.32445228f, -0.17565909f, -0.07662291f, -0.16128553f, -0.17532654f, -0.18537368f, -0.67389059f, 
    0.12896846f, 0.35648409f, -0.51963574f, 0.20822950f, -0.11784987f, -0.10226391f, -0.13953468f, -0.21545243f, 
    0.02392784f, 0.12097300f, -0.20843530f, 0.49401313f, 0.46733230f, -0.25396168f, -0.10737110f, 0.55018204f, 
    -0.26433772f, -0.25811464f, 0.16449237f, -0.01346961f, -0.07900803f, 0.01221776f, -0.06891850f, -0.23723039f, 
    -0.26593623f, 0.09943458f, -0.18117984f, 0.07908482f, -0.16098814f, -0.03671728f, 0.02680502f, -0.05239305f, 
    0.37975001f, -0.38273501f, -0.25130120f, -0.57023776f, 0.25655892f, 0.14108241f, 0.24010198f, -0.20336635f, 
    0.19764116f, -0.46341950f, -0.18444438f, -0.36905429f, 0.27863249f, 0.29753536f, 0.07409143f, -0.24577016f, 
    0.55596226f, 0.35240182f, 0.46173763f, -0.38403723f, 0.44129270f, -0.19521503f, -0.12510173f, 0.05068265f, 
    0.19242547f, -0.11175656f, -0.08400916f, -0.36403376f, -0.28894901f, -0.29128686f, 0.13017367f, 0.41904745f, 
    0.30879724f, -0.17086360f, -0.59113592f, 0.33187008f, 0.34437090f, 0.11558181f, 0.36048886f, 0.20682374f, 
    -0.16238073f, -0.25368550f, -0.09881797f, 0.18324746f, 0.27965739f, -0.42318821f, 0.26159155f, 0.38774815f, 
    -0.01394934f, -0.08002438f, 0.10474641f, -0.22234514f, 0.00676018f, 0.04723625f, 0.14257853f, -0.06508231f, 
    -0.19522811f, 0.05539731f, -0.04942993f, -0.15428968f, 0.02003141f, -0.07863526f, -0.18795305f, -0.11941727f, 
    0.25750655f, -0.38301444f, 0.13069379f, 0.22605491f, -0.06248992f, -0.22948208f, 0.43804038f, 0.25018737f, 
    0.45005876f, -0.00649054f, 0.21160384f, -0.62183726f, -0.06169983f, -0.25451851f, 0.31936231f, 0.44719264f, 
    0.39694181f, -0.24604246f, 0.21383944f, 0.25350425f, 0.29254964f, 0.12424299f, 0.44073144f, -0.63756698f, 
    0.15824805f, 0.49387237f, -0.04806820f, 0.02983907f, -0.41813332f, -0.20250940f, -0.32995760f, 0.11297407f, 
    -0.25904131f, -0.16392104f, -0.21318583f, -0.00284835f, 0.08240765f, 0.09407002f, -0.18865059f, -0.01122677f, 
    -0.15321752f, -0.06393866f, 0.09974822f, -0.08953359f, -0.15173502f, -0.04512796f, 0.22417660f, 0.15048718f, 
    -0.02204290f, -0.18097037f, -0.09842655f, -0.02960029f, -0.19905868f, -0.15239754f, -0.14630353f, 0.14184636f, 
    0.09818196f, -0.13617200f, 0.10888901f, 0.15588331f, -0.23901096f, -0.05150479f, 0.11252019f, -0.22158656f, 
    -0.19977891f, -0.10765409f, 0.02902989f, -0.41793036f, 0.29232678f, 0.04155763f, 0.01654962f, -0.09041817f, 
    -0.14239395f, -0.32665202f, 0.12318514f, 0.52079976f, 0.38344792f, 0.51674116f, -0.07124826f, -0.41672578f, 
    -0.17026454f, -0.27268770f, 0.33395222f, 0.21606250f, -0.17180873f, -0.06358179f, 0.20190495f, 0.52104121f, 
    0.44448552f, -0.01156059f, 0.18862723f, 0.03261441f, 0.40832019f, -0.21742420f, -0.30507502f, 0.60054302f, 
    0.12196964f, -0.23576531f, 0.17500418f, -0.29680821f, 0.15932579f, 0.11635908f, 0.38775593f, 0.25594124f, 
    0.03283396f, -0.25272086f, 0.22937401f, -0.05858321f, 0.30343324f, 0.26715761f, -0.43448508f, 0.26318645f, 
    0.01053006f, -0.23158577f, -0.09238199f, -0.06646339f, -0.14670256f, 0.09729481f, -0.17921768f, -0.20122293f, 
    0.08769611f, 0.04802749f, 0.08519799f, 0.01103408f, 0.19649968f, -0.24342187f, -0.22133896f, 0.01326066f, 
    0.56659371f, -0.48178223f, 0.15719046f, 0.48185977f, 0.22426923f, 0.07759452f, 0.01471709f, -0.19060601f, 
    0.31945130f, 0.15658885f, 0.17526735f, 0.36704230f, 0.01328971f, 0.03769373f, -0.46580109f, 0.02019756f, 
    -0.25148273f, 0.19580139f, 0.21669354f, -0.36828953f, 0.11846146f, -0.23128951f, -0.16518690f, 0.06010120f, 
    -0.00350232f, -0.01816739f, -0.01526984f, 0.21937715f, 0.14104843f, 0.20967360f, 0.47379175f, -0.41424522f, 
    -0.27810895f, 0.16465507f, 0.57122231f, 0.39071050f, 0.20156568f, 0.13687977f, -0.11057772f, 0.39012080f, 
    0.28967518f, -0.03787598f, 0.20277733f, 0.59016120f, -0.37961441f, 0.11593574f, -0.23779772f, -0.40721780f, 
    0.30626693f, 0.14434324f, 0.56264621f, -0.07435857f, -0.34175315f, 0.19514222f, -0.31497052f, 0.06815086f, 
    -0.07781444f, 0.22399203f, 0.16049200f, 0.35254821f, -0.01097329f, -0.28604406f, 0.35614526f, 0.53451955f, 
    0.40109408f, -0.19289398f, 0.15246058f, 0.46540421f, 0.46469924f, 0.11546049f, -0.00390684f, 0.20506112f, 
    0.30301070f, 0.32531932f, 0.05963794f, 0.39001727f, -0.32599843f, -0.08244900f, -0.29762486f, 0.06099916f, 
    0.47942594f, -0.03398248f, 0.03798940f, 0.37649402f, 0.13614929f, 0.10331751f, 0.19095916f, -0.29292849f, 
    -0.10446297f, -0.03918105f, 0.17586082f, 0.33304048f, 0.04538969f, -0.02751599f, -0.24459960f, -0.48567522f, 
    0.08158247f, 0.10043274f, 0.68936908f, 0.53211641f, 0.28510606f, 0.18505667f, -0.01610102f, 0.41373327f, 
    0.01191002f, -0.30777967f, 0.18293403f, 0.52579719f, -0.05916134f, -0.09453185f, -0.45347437f, -0.54642606f, 
    0.16254053f, -0.14872755f, -0.13847902f, -0.09881272f, 0.09127309f, 0.21389419f, -0.16421871f, -0.02293829f, 
    -0.26532513f, -0.26760852f, 0.00133159f, -0.10913725f, -0.06798776f, -0.00525815f, -0.06884645f, 0.05246292f, 
    0.09629989f, -0.11513349f, -0.11196268f, 0.06826502f, -0.19581404f, -0.03504148f, -0.13351107f, 0.03162307f, 
    -0.18779951f, -0.08957767f, -0.24846217f, -0.13385847f, -0.13961717f, 0.00555834f, 0.11927691f, 0.14205116f, 
    -0.27981734f, 0.20235221f, -0.56134832f, -0.40279561f, 0.34395289f, -0.21363427f, 0.32165578f, -0.07934446f, 
    0.09363811f, -0.18162884f, -0.08315469f, 0.02304226f, 0.24914342f, -0.07400898f, 0.52773958f, 0.20149897f, 
    -0.06489915f, -0.47567487f, -0.25102326f, 0.19870780f, 0.13485031f, 0.19617879f, 0.31361994f, -0.12763956f, 
    0.14024101f, 0.03355952f, -0.17815046f, -0.25120586f, 0.10519084f, 0.45276681f, 0.13953134f, 0.01787132f, 
    -0.06086788f, -0.00870466f, -0.19015434f, 0.18350887f, 0.51271313f, 0.20790713f, 0.01201311f, 0.45106730f, 
    0.33885506f, 0.27452236f, 0.21529841f, 0.10304862f, -0.17301217f, 0.23371574f, -0.25017026f, 0.06092902f, 
    -0.48405492f, -0.13396285f, 0.17060754f, 0.31665474f, 0.31540501f, -0.00762551f, 0.40254632f, 0.02287666f, 
    0.00342942f, -0.25116646f, -0.11694017f, -0.53541130f, -0.06501804f, 0.17242782f, 0.15008534f, 0.12004878f, 
    0.34011525f, 0.01344957f, 0.34034881f, 0.32006598f, -0.29964155f, -0.17407778f, -0.48853871f, 0.15128876f, 
    -0.07408740f, -0.26429462f, 0.28474033f, 0.56431729f, 0.41449103f, 0.00253870f, 0.00690514f, -0.43981406f, 
    0.33746672f, -0.22653227f, 0.09703400f, -0.23196045f, -0.13265367f, -0.04136282f, 0.13549441f, -0.23736805f, 
    -0.04014540f, -0.09298180f, 0.15659940f, -0.30928019f, 0.50114602f, 0.20092361f, 0.20112877f, -0.31697351f, 
    -0.44781998f, 0.59038156f, -0.08670116f, 0.13045958f, -0.05963318f, 0.14945942f, 0.26260924f, -0.10198350f, 
    0.09397746f, 0.48139483f, 0.00136190f, -0.18855087f, -0.46581402f, 0.36686203f, 0.16656981f, 0.31989971f, 
    0.13876058f, -0.03442155f, -0.08826153f, -0.37630853f, 0.26021713f, -0.04511940f, 0.39960265f, -0.59164810f, 
    0.14195146f, -0.36213896f, 0.12220556f, -0.05612582f, -0.31376162f, 0.27490589f, 0.32684076f, 0.21968684f, 
    -0.02176514f, -0.67736644f, -0.13786836f, 0.57995671f, 0.29032645f, 0.20433202f, 0.14885440f, 0.42293721f, 
    0.49777514f, 0.36546743f, 0.02098842f, 0.11485370f, 0.12187148f, -0.02791705f, -0.12628880f, -0.06810071f, 
    -0.06386419f, 0.23930913f, -0.32171941f, -0.03530792f, 0.69759268f, 0.19839576f, 0.28630638f, -0.14089656f, 
    -0.04923667f, 0.58182734f, -0.08254421f, -0.01095765f, -0.48226044f, 0.35092795f, 0.05806562f, 0.07610013f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.34056476f, 0.19123977f, -0.07883436f, 0.41299555f, 0.22595488f, -0.01094687f, 0.23085894f, -0.37894621f, 
    -0.27701616f, 0.14325526f, 0.22611147f, 0.21619055f, 0.05101936f, 0.45227242f, 0.26939029f, 0.33280143f, 
    -0.32375640f, -0.10545694f, -0.27117452f, 0.32399347f, 0.20538807f, 0.11515380f, -0.18165049f, -0.24630240f, 
    -0.19839567f, 0.19637549f, -0.42501244f, 0.13047563f, 0.15563194f, -0.41279617f, -0.06812207f, -0.27400374f, 
    0.05719657f, 0.04729636f, 0.23163059f, -0.16883534f, 0.03122584f, 0.12970383f, -0.61947304f, 0.16687702f, 
    -0.18181792f, -0.03155181f, 0.07102700f, 0.29124871f, 0.10290236f, -0.06764581f, 0.39903098f, -0.37058607f, 
    -0.12126945f, 0.01748400f, 0.17517754f, -0.14614564f, 0.15841629f, -0.02275839f, 0.25272536f, -0.20141928f, 
    0.04376737f, 0.38918355f, 0.07241973f, 0.23179798f, 0.19754954f, -0.38767228f, -0.34579352f, 0.04973712f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.00143412f, 0.04674771f, 0.09220772f, -0.00977654f, 0.12550320f, -0.06018322f, 0.08729315f, -0.05375327f, 
    0.26684666f, -0.08418222f, -0.04254632f, 0.20574777f, -0.09196626f, 0.03295474f, -0.84395689f, 0.35051441f, 
    -0.01304678f, -0.01557386f, -1.15313745f, 0.07983192f, -0.06788854f, -0.34115204f, -0.00129617f, -0.15645319f, 
    -0.02105814f, -0.03873391f, -0.84668642f, -0.17154823f, -0.70565200f, 0.12301533f, -0.51486582f, -0.62827998f, 
    -0.02271079f, 0.29642886f, 0.14912511f, -0.14977805f, 0.01357162f, 0.06691966f, -0.49870998f, 0.04142410f, 
    -0.00923534f, 0.09773908f, 0.04312319f, 0.13994217f, -0.14995436f, -0.06193313f, 0.00057552f, 0.10711040f, 
    -0.49722242f, 0.10330736f, -0.05122988f, -0.09773153f, -0.03676610f, 0.09838611f, 0.02525266f, -0.03427169f, 
    0.41565591f, 0.13702777f, -0.34903520f, -0.09385404f, -0.07656828f, 0.15339892f, 0.23189507f, 0.28953463f, 
    0.26953748f, -0.12057930f, 0.06654122f, 0.10655288f, -0.09411024f, -0.14844763f, 0.06803711f, -0.51554453f, 
    0.17597221f, -0.11303640f, -0.08402388f, 0.21417433f, 0.34109733f, -0.13610961f, 0.64220536f, -0.80898720f, 
    0.15544815f, 0.11513215f, -0.46039027f, 0.17991741f, 0.02313963f, -0.01026228f, 0.03215825f, -0.04366256f, 
    0.05243432f, 0.01605726f, 0.22960772f, -0.03070965f, 0.05427806f, -0.57355052f, -0.87323028f, -0.06150840f, 
    -0.07215466f, 0.28487784f, -0.31671381f, -0.17545101f, -0.09937715f, -0.16038108f, -0.01528067f, -0.03595764f, 
    0.09865139f, 0.36451131f, -0.20906572f, 0.16067460f, -0.04017800f, -0.35053387f, -0.04901284f, 0.33033729f, 
    -0.25611112f, -0.24655458f, -0.18414582f, 0.40788668f, 0.10375764f, 0.09937477f, 0.06398644f, 0.22461137f, 
    0.00760959f, -0.03439974f, -0.13578089f, -0.03328365f, 0.12377352f, 0.47748572f, -0.28793639f, 0.25189999f, 
    -0.70296526f, -0.02346491f, 0.21228123f, 0.31499028f, 0.05864954f, 0.39131916f, 0.05416951f, 0.01190830f, 
    -0.08324055f, 0.03932452f, 0.18742211f, 0.34229797f, -0.06441296f, -0.76916206f, 0.37176529f, -0.11186426f, 
    -0.64166278f, -0.57946283f, 0.60905981f, -0.05137865f, 0.09588344f, 0.01685758f, -0.92528421f, 0.38345602f, 
    0.07194203f, 0.08039024f, -1.24637508f, 0.04263831f, -0.53713536f, 0.44661337f, -0.43003142f, -0.41686514f, 
    -0.02432016f, -0.73876810f, -0.84980679f, -0.81433076f, 0.10120068f, -0.00463061f, -0.25388896f, -0.10124371f, 
    0.12047687f, 0.05939413f, 0.14878407f, -0.11010490f, -0.01163212f, -0.95220923f, 0.16836685f, 0.21762724f, 
    0.20826395f, -0.92323208f, -1.34953213f, -0.44610274f, -0.04965780f, -0.06865975f, -0.13777874f, 0.21590263f, 
    0.02417153f, 0.24842033f, -0.21617480f, 0.05872939f, 0.48638988f, -0.19686253f, -0.01891410f, -0.03238203f, 
    0.17521077f, 0.15815119f, -0.30980149f, 0.01109240f, 0.31900382f, -0.11219561f, -0.05152974f, -0.42044619f, 
    -0.50626475f, -0.04451047f, 0.03535078f, -0.14117472f, 0.29919049f, 0.18416511f, -0.50162619f, -0.00388964f, 
    0.24958591f, 0.37470457f, -0.60812277f, -0.64462322f, -0.50899345f, 0.02200020f, 0.34748057f, 0.04293901f, 
    0.03106543f, -0.97254366f, -0.04505484f, 0.05132506f, -0.32145846f, 0.10171455f, -0.35227638f, -0.25280169f, 
    -0.01695533f, -0.28846672f, -0.12780479f, -0.02356414f, 0.06912702f, -0.11401050f, -0.73662996f, -0.11990760f, 
    -0.05208322f, 0.01802491f, 0.09048740f, 0.07987607f, 0.10336110f, 0.00539394f, -0.13618749f, 0.49763587f, 
    -0.07635298f, 0.27054429f, 0.13742584f, 0.45292383f, 0.11055554f, -0.06530100f, -0.72698176f, -0.44960409f, 
    0.18294483f, -0.09918515f, 0.25213817f, -0.40166238f, -0.45084068f, -0.35346437f, 0.13253105f, -0.27022526f, 
    -0.24279921f, 0.02373688f, 0.07638844f, -0.13605765f, 0.16613722f, 0.01930820f, 0.04452486f, 0.02048876f, 
    0.09276482f, -0.01620364f, -0.37943780f, -0.19500077f, -0.32744586f, -0.04725986f, 0.13716127f, -0.13633603f, 
    -0.29851067f, -0.48078316f, -0.89268005f, 0.08164087f, 0.22385785f, -0.16339087f, -0.24245194f, 0.14501764f, 
    0.06652859f, 0.00808999f, -0.03820716f, 0.17560716f, -0.09566043f, 0.03404055f, -0.65462214f, 0.15047507f, 
    -0.01784661f, -0.24608047f, 0.25665402f, 0.11602300f, 0.08395208f, 0.27856597f, -0.32748020f, 0.10350794f, 
    -0.11368141f, -0.29710180f, 0.19361550f, -0.03663655f, -0.01879942f, 0.03958494f, -0.03236752f, -0.41756019f, 
    0.24858136f, 0.06595005f, -0.36363140f, -0.76219875f, 0.10560745f, 0.07122003f, 0.00994296f, -0.19149670f, 
    0.19990607f, 0.00552779f, -0.14164628f, -0.10300421f, -0.00606579f, -0.64332396f, 0.18103841f, 0.04454528f, 
    -0.24835065f, -0.13195242f, 0.11358069f, 0.02492282f, -0.50143510f, -0.14741844f, -0.31516165f, -0.05363990f, 
    0.20535737f, -0.09124672f, 0.22315811f, 0.05707693f, 0.21684775f, 0.12984061f, 0.13330472f, 0.17455764f, 
    0.23636265f, -0.01883293f, -0.53841847f, 0.23459312f, -0.07761649f, 0.12280893f, 0.04590779f, -0.65128773f, 
    -0.12491962f, -0.18904290f, 0.44501799f, -0.23420660f, 0.35883585f, -0.63297886f, -0.43870431f, -0.29953226f, 
    -0.04078368f, 0.15869313f, -0.06657977f, 0.13949004f, 0.10565300f, 0.19112070f, 0.53612536f, -0.05810998f, 
    -0.09060879f, -0.00895060f, -0.26660571f, -0.11635616f, 0.02173611f, 0.28927881f, 0.10695406f, -0.43525368f, 
    -0.21570337f, 0.19450141f, 0.27090058f, -0.47000122f, -0.11489967f, 0.03558394f, 0.16114129f, 0.10442680f, 
    -0.27078459f, 0.18500169f, -0.12728710f, 0.22255631f, 0.07730273f, 0.06766830f, -0.16240320f, 0.11427839f, 
    -0.02906910f, -0.43541017f, 0.15248258f, -0.30739310f, -0.48643669f, 0.00847648f, -0.59920180f, -0.01774107f, 
    0.32187805f, -0.01415116f, 0.27367890f, -0.01578513f, -0.00216234f, 0.37630507f, -0.53307259f, -0.37244281f, 
    -0.77668589f, -0.61615145f, 0.30333990f, -0.19024606f, 0.14766476f, -0.11157729f, 0.34735024f, -0.46546701f, 
    0.01370506f, -0.48477289f, -1.06393135f, 0.21188441f, 0.18992017f, -0.11620107f, -0.40288591f, 0.12640758f, 
    0.10357346f, 0.05964115f, -0.22476287f, 0.40856895f, 0.00293436f, 0.33952755f, -0.49426708f, -0.07457823f, 
    -0.03537908f, 0.02096739f, 0.13445841f, 0.03989367f, 0.00584667f, -0.53216314f, 0.06589939f, -0.31350246f, 
    0.21806124f, -0.35340309f, -0.18494943f, -0.18323964f, 0.01846950f, -0.08685640f, 0.23659740f, 0.14634089f, 
    -0.22635064f, 0.08130696f, 0.01860210f, 0.06745262f, -0.39980713f, 0.13114767f, 0.24104773f, -0.36582571f, 
    -0.18430755f, 0.13079995f, -0.30760804f, -0.72415614f, 0.04549340f, -0.22167303f, 0.04743990f, 0.06433240f, 
    0.23227140f, -0.56202018f, -0.14424208f, -0.50650138f, -0.13858363f, -0.50004441f, -0.30431500f, -0.09928819f, 
    0.34141085f, 0.55120909f, 0.11644881f, -0.30114779f, 0.09127428f, -0.50604725f, -0.42438591f, 0.07590222f, 
    -0.03816792f, -0.07990185f, 0.42873028f, -0.07959481f, -0.81280112f, 0.13596268f, 0.36364859f, -0.01857748f, 
    -0.06619146f, -0.34393105f, 0.03608465f, 0.11148755f, 0.04977136f, 0.08708610f, 0.56912404f, -0.00198722f, 
    0.04762037f, -0.85848761f, -0.19050214f, -0.43028012f, -0.01951362f, 0.18414176f, -0.58546549f, 0.27162153f, 
    -0.06571390f, 0.30116183f, 0.03929134f, 0.11063863f, 0.04943733f, 0.10169366f, -0.31472090f, 0.01507012f, 
    0.07474136f, -0.43640724f, -0.21151161f, -0.62294549f, 0.30090469f, -0.13791183f, 0.29561624f, 0.27676386f, 
    0.15854020f, 0.33775082f, 0.04518001f, -0.00450096f, -0.41917232f, -0.57702720f, 0.28230467f, 0.15638918f, 
    -0.17118461f, 0.09132002f, -0.20525672f, -0.46395972f, 0.17348522f, -0.20325558f, -0.11146566f, -0.42261869f, 
    0.19339053f, 0.52038878f, 0.44012329f, 0.24691828f, -0.25189665f, 0.17341687f, 0.18375878f, 0.17047897f, 
    0.05936318f, 0.37474418f, 0.06078471f, -0.13164760f, -0.36577675f, -0.39488268f, -0.25781557f, 0.28796342f, 
    -0.12200759f, -0.57780588f, -0.07255074f, -0.02108964f, -0.04967708f, -0.69593269f, 0.15656744f, -0.09650636f, 
    -0.00975817f, 0.15690267f, -0.43989530f, -0.65132731f, -0.07656544f, -0.31571400f, 0.24936302f, -0.25294104f, 
    0.24927430f, -0.27524626f, 0.01317138f, -0.67460060f, 0.09100957f, -0.04470463f, 0.24299979f, -0.50638813f, 
    -0.12692378f, -0.45036668f, 0.08255642f, -0.25011501f, 0.18136367f, 0.33609802f, -0.58791375f, 0.17108136f, 
    -0.16658756f, -0.47317395f, 0.00311342f, 0.31915206f, -0.02722664f, -0.24221545f, -0.32513964f, 0.15083489f, 
    -0.29536664f, 0.16840839f, -0.77647841f, -0.56316710f, -0.98257750f, 0.08951795f, -0.13513249f, 0.35560897f, 
    0.37202758f, -0.74486405f, -0.33553866f, -0.18312874f, 0.42954051f, 0.03983097f, 0.06053041f, -0.20317765f, 
    -0.00379524f, 0.38107872f, -0.01577294f, -0.09994379f, 0.42055088f, 0.01812647f, 0.16027182f, 0.21699868f, 
    0.02529838f, -0.29865149f, 0.18602046f, 0.18229981f, -0.02744941f, 0.19472815f, 1.00701666f, 0.00518612f, 
    -0.10318561f, -0.39981362f, 0.15094188f, 0.24278325f, -0.07749482f, 0.30438200f, -0.23887458f, -0.36116850f, 
    -0.03058797f, 0.02342194f, 0.60919040f, 0.05533538f, 0.07172101f, 0.06275578f, 0.11334870f, -0.23492004f, 
    -0.07173856f, 0.08424594f, -0.54175878f, -0.09715115f, 0.25055507f, -0.12961543f, -0.32288468f, -0.09135313f, 
    -0.29802102f, 0.09369807f, -0.30525112f, 0.15921988f, 0.27430925f, 0.26556090f, 0.34850526f, -0.71404141f, 
    -0.72992653f, -0.15291254f, 0.34227923f, 0.47958145f, 0.08011720f, -0.04017753f, 0.68526471f, -0.14994191f, 
    -0.65372109f, 0.75436687f, 0.17872003f, 0.06757034f, -0.24061741f, 0.10295872f, -0.71216387f, 0.13324618f, 
    0.02901407f, -0.81539065f, 0.06018218f, 0.29084679f, -0.52206904f, -0.44570374f, 0.09432474f, -0.44673416f, 
    -0.07519587f, 0.18773866f, 0.28950837f, -0.59382713f, -0.06893189f, -0.09442332f, -0.50698262f, 0.09541608f, 
    -0.10721260f, -0.03468710f, -0.02514870f, 0.09112813f, 0.05888295f, 0.02466824f, 0.10259910f, 0.14218071f, 
    0.40426600f, 0.01426995f, -0.00430713f, 0.17602451f, 0.02405443f, -0.05466439f, -0.53100288f, -0.67720312f, 
    -0.35107675f, -0.40440309f, 0.37545499f, 0.18819846f, -0.04707487f, -0.54189140f, -0.42778713f, -0.61463040f, 
    0.50216234f, 0.19985141f, 0.00443702f, -0.02349633f, 0.04185221f, 0.50595266f, -0.14237168f, -0.06024791f, 
    -0.33764043f, 0.28196093f, 0.27701056f, 0.08126868f, -0.61995435f, -0.12900646f, -0.91773206f, 0.03219906f, 
    -0.47731048f, -0.14759295f, 0.05351434f, 0.17248853f, -0.65685171f, 0.02528684f, 0.45179316f, -0.09394982f, 
    0.03380379f, -0.15490033f, -0.23126334f, 0.02320780f, -0.55006427f, 0.15749463f, -0.44343129f, 0.42310551f, 
    0.03955482f, 0.36145744f, -0.61432451f, 0.12522119f, 0.10039125f, -0.18895686f, -0.69124866f, 0.00410995f, 
    -0.01327480f, 0.25130504f, 0.21925417f, 0.22925511f, -0.05857934f, 0.22858922f, -0.15429582f, -0.42975214f, 
    -0.43849352f, -0.22128300f, 0.07759386f, -0.15032473f, -0.02145262f, -0.01704834f, -0.13266301f, 0.01967262f, 
    -0.00304561f, -0.19042782f, 0.30697554f, 0.26045856f, -1.00241029f, -0.75818640f, 0.22470428f, -0.69981980f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.06841829f, 0.07040393f, 0.05055732f, -0.22437738f, 0.22618300f, 0.25068161f, -0.32573575f, -0.66347146f, 
    -0.27283216f, 0.03703266f, 0.36481631f, 0.07113453f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
