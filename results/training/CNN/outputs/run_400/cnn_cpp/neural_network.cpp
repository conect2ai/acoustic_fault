#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.65725720f, -0.46714300f, 0.24613647f, -0.63535726f, -0.23932672f, -0.73730403f, 0.36483043f, 0.13804999f, 
    0.29022944f, 0.53012031f, -0.12536030f, -0.64590001f, -0.20265186f, -0.82491624f, -0.88460994f, 0.49444881f, 
    0.60690796f, 0.41932276f, 0.09976837f, -0.55634928f, -0.76815194f, -0.65684450f, 0.33617917f, -0.03235691f, 
    0.43667343f, 0.24542402f, -0.21723077f, 0.38501164f, -0.72498053f, -0.67445964f, 0.03410701f, 0.98808736f, 
    0.50341499f, -0.05200785f, 0.36132237f, -0.68504792f, 0.43904352f, -1.36088705f, 0.88023132f, 0.89525712f, 
    -0.13956895f, 0.58295029f, -0.12641482f, 0.22656667f, -0.08101691f, 0.20288049f, -1.15926087f, 0.30997273f, 
    -0.31676036f, 0.62851852f, -0.51328170f, 0.33053872f, 0.20757565f, 0.10446197f, -0.72038156f, -1.23397279f, 
    -0.26166493f, -0.41181993f, 0.49259958f, 0.51571578f, 0.12606889f, -0.02408371f, 0.11675768f, 0.77090263f, 
    0.07918972f, 0.71272635f, 0.68904674f, 0.53255057f, -0.02807897f, 0.01835998f, -0.40277800f, 0.39097416f, 
    0.42841437f, 0.44588894f, -1.02287006f, -0.73543179f, 0.13330221f, 0.52782363f, -0.64678329f, -0.44365034f, 
    0.11429965f, 0.73878390f, 0.85161120f, 0.65264654f, -0.75298411f, -0.30886915f, 0.81360537f, -0.17906538f, 
    -0.51189715f, -0.24885729f, -0.61057329f, -0.44863158f, 0.58977407f, -0.59850478f, -0.66470039f, 0.46392411f, 
    -0.52822661f, 0.34613156f, -0.19577189f, 0.75579697f, 0.97608316f, 0.08949363f, 0.33530417f, 0.58632064f, 
    -0.10649137f, -0.05759337f, -0.50543356f, -0.32623637f, 0.06738477f, -0.56380314f, 0.92446482f, -0.87178862f, 
    -0.24922653f, -0.49428424f, 0.48308241f, 0.46711874f, 0.47664413f, 0.51825923f, -0.82373756f, -0.59737486f, 
    0.48847362f, 0.59706581f, -0.66085613f, -0.32061207f, -0.11715382f, 0.31722260f, 0.65817511f, 0.56153780f, 
    0.64930934f, 0.59467131f, 0.58361834f, 0.70375246f, 0.37680149f, -0.04438847f, 0.20831840f, -0.85115021f, 
    -1.00365329f, 0.63206208f, 0.57646400f, 0.74602634f, 0.58757859f, -0.34650111f, -0.25868756f, -0.06436556f, 
    -0.54033905f, 0.32998535f, -0.59094411f, -0.32241946f, -0.52184993f, -1.00198472f, -0.37595636f, 0.28834069f, 
    0.48669901f, 1.05376697f, 0.86369067f, -0.56793696f, 0.01883622f, 0.18112904f, 0.20852037f, 0.30237633f, 
    0.38910666f, -0.35798016f, -0.97220856f, -0.29095885f, 0.85932934f, 0.80582696f, 0.57185042f, -0.64003956f, 
    -0.05067979f, 0.17935017f, -0.20458180f, 0.27130246f, -0.81850100f, 0.75005472f, -0.74866444f, -0.05532309f, 
    -0.54184824f, 0.60081077f, -0.44032630f, -0.46370995f, -0.66861761f, -1.02191186f, -0.85734797f, 0.29438248f, 
    0.35197827f, 0.56473434f, -0.41632342f, 0.07071737f, -0.26298124f, -0.85828024f, 0.11817797f, 0.84009624f, 
    0.60845864f, 0.08460308f, 0.50154632f, -0.27702340f, -0.49951366f, 0.33665568f, -0.87001443f, 0.94934934f, 
    0.37529975f, 0.05333076f, 0.39017713f, -0.61048222f, 0.14878377f, -0.52761263f, -0.13833064f, -0.56183380f, 
    1.06238127f, 0.12950926f, 0.59896433f, -0.64750457f, -0.74314845f, -0.55551553f, 0.00032130f, -0.46660540f, 
    -1.06833315f, 0.81799495f, -0.32694691f, 0.55054897f, 0.96683103f, -0.13804828f, -0.15753096f, -0.42812607f, 
    0.28270581f, 1.13083303f, -0.51494020f, 0.36733481f, -0.59588331f, -0.13300481f, -0.35103077f, -0.26368076f, 
    0.02159508f, -0.07349984f, 0.34726521f, 1.02420342f, 0.77752697f, -0.95288783f, 0.82396400f, 0.09328889f, 
    -0.14316127f, -0.20387770f, 0.23416688f, 0.64430004f, -0.25081873f, 0.63193691f, -0.42188910f, -1.22720373f, 
    -0.36919555f, 0.17261419f, 0.13774541f, -0.59994453f, 0.90368038f, -0.95115018f, 0.76548761f, 0.55189240f, 
    0.10491247f, 0.22988763f, -0.05835978f, 0.14213671f, -0.74700928f, -0.26946411f, -0.82220423f, -0.59391195f, 
    -0.16179037f, 0.49523407f, -0.69220001f, -0.50006229f, -0.20571427f, -0.41340765f, 0.38401610f, -0.70466393f, 
    0.46027553f, 0.23015174f, -0.08724353f, 0.62217808f, 0.40382794f, -0.02538984f, 0.17365666f, -0.57118803f, 
    -0.56675506f, -0.71000826f, -0.13188638f, 0.85827148f, 0.90392393f, 0.34469458f, -0.32579812f, 0.05319698f, 
    0.97445101f, -0.99235785f, 0.35825235f, 0.60858953f, -0.82676834f, -0.01803509f, -0.30363882f, -0.58959901f, 
    0.01435817f, 0.42348459f, 0.07732897f, -0.80140322f, -0.59924918f, 0.02904686f, 0.31887117f, -0.30383018f, 
    0.71816057f, -0.18712837f, -0.38649601f, -1.01933885f, -0.30734697f, -0.02587755f, 1.03973794f, 0.64527994f, 
    -0.28006428f, 0.00706446f, -0.06857864f, -0.25095668f, -0.87130147f, -0.21219203f, -0.60593385f, 0.87241089f, 
    0.02675746f, 0.40769166f, -0.40193740f, 0.02561314f, -0.47829705f, -0.90770501f, -0.53196031f, -0.22319447f, 
    -0.32325563f, -0.36225215f, -0.09799788f, 0.51167738f, 0.19843952f, -0.62070030f, -0.91306204f, 0.40799549f, 
    -0.35425657f, 0.56772822f, -0.05120615f, -0.52770704f, 0.04539591f, -0.54735029f, 0.06092921f, 0.10661012f, 
    0.45544142f, -0.26002619f, 1.09460294f, -0.04734346f, -0.14887938f, 0.74913126f, -0.39093176f, -0.71839982f, 
    -0.16696924f, 0.70001876f, -0.61128807f, 0.43691114f, -0.53297603f, 0.39404067f, 0.57709950f, -0.49972966f, 
    0.24243481f, 0.95178694f, -0.85615557f, 0.82002044f, 0.28699565f, -0.40523112f, -0.21469228f, -0.15663144f, 
    -0.22220737f, 0.64809525f, 1.09983313f, 0.33895344f, -0.02071180f, 0.56559348f, -0.80076623f, -0.02789852f, 
    -0.48361909f, -0.33710787f, 0.99716491f, 0.82007080f, 0.52900696f, -0.20303796f, -0.59912604f, -0.26652357f, 
    0.02791133f, 0.75263315f, 0.24723132f, -0.42492417f, 0.13645263f, -0.51175570f, 0.94995886f, 0.81775874f, 
    -0.84563088f, 0.33083227f, 0.12321623f, 0.09693558f, -0.31109208f, -0.60346746f, -0.93973386f, -0.00050006f, 
    -0.51134586f, 0.02313608f, 0.06946832f, -0.21698669f, 0.40061855f, 0.90983874f, 0.28484070f, 1.13846064f, 
    -0.06506081f, 0.11305337f, -0.05705481f, 0.38530824f, 0.49131826f, -0.19995080f, -1.19731712f, 0.71516901f, 
    0.79961640f, 0.06355133f, 0.95309830f, -0.48001403f, -0.06278246f, 0.31648761f, -0.10483665f, 0.04218042f, 
    -0.80399966f, -0.14220247f, -0.60761297f, -0.86646831f, 0.40501356f, 0.20441046f, -0.47155052f, -0.44335449f, 
    -0.67171186f, -0.62183672f, -0.76256037f, 0.27044863f, -0.76523882f, -0.43216211f, -0.58020329f, 0.22931550f, 
    0.46256396f, -0.58812052f, -0.15433125f, 0.47303742f, -0.27023807f, -0.02913865f, 0.89389318f, 0.68083435f, 
    0.16228893f, 0.56895715f, -0.74574590f, -0.24347506f, -0.79128122f, -0.81682301f, 0.19917068f, 0.77250409f, 
    0.28836221f, -0.32358137f, 0.33398700f, 0.87507927f, 0.38519520f, -0.84952664f, -0.36049879f, -0.53230089f, 
    0.17625883f, 0.15443501f, 0.43364048f, 0.42577234f, -0.92262089f, 1.20756745f, 0.40990734f, -1.01877379f, 
    0.69345403f, 0.07639175f, -0.14278606f, 0.23849617f, 0.28516036f, -0.46931094f, 1.14053059f, 0.02114835f, 
    0.90875447f, -0.35078540f, 0.03529698f, 0.27650419f, -0.14171648f, 0.28729430f, 0.89848781f, 0.59050930f, 
    0.72280651f, 0.30289882f, -0.76170164f, -0.53565890f, -0.30454656f, 0.03334499f, 0.16175121f, 0.06270573f, 
    0.47991106f, 0.50499177f, -0.54341465f, -1.05031586f, -0.67217553f, 0.53302139f, 0.34822255f, -0.09920643f, 
    0.71175283f, -0.21123236f, -1.11747503f, -0.65597475f, 0.35903510f, 0.31034693f, 0.42094564f, -0.31450340f, 
    0.35110351f, 0.90997398f, -0.55974030f, 0.28444636f, 0.64106023f, -0.56907827f, 0.35266876f, 0.42957410f, 
    0.42213663f, -0.00873052f, 0.42215228f, -0.85740381f, -0.28856155f, -0.81254977f, -0.79391366f, -0.40208471f, 
    -0.14557852f, -0.44649899f, 0.02163453f, 0.74513745f, -0.26551062f, 1.06768620f, 0.34469235f, -0.27257571f, 
    -0.50252861f, -0.51525551f, -0.33061048f, -0.02256986f, 0.81704783f, 1.06682742f, -0.39280733f, 0.01692644f, 
    -0.63898575f, 0.42390299f, 0.30299103f, -0.15619916f, 0.06624506f, 0.31385475f, -0.38599139f, -0.79736203f, 
    -0.10797026f, 0.85961020f, -0.43357992f, 0.39624676f, 0.19061223f, -0.35492262f, -0.74594498f, 0.44455183f, 
    0.31141639f, 0.59200376f, 0.17197542f, 0.62368184f, -0.50953966f, 0.27096051f, 0.01640638f, -0.66614360f, 
    -0.57100886f, -0.32135633f, -0.91178089f, -0.58959496f, -0.31305084f, 0.51849961f, 0.31900969f, -0.51244646f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.20791170f, -0.09662053f, 0.14838551f, 0.16458444f, -0.00616572f, 0.30428067f, 0.18320613f, 0.31258541f, 
    0.23253976f, 0.09555049f, -0.06757744f, 0.15847598f, 0.09809616f, 0.38092476f, 0.23020688f, 0.01436222f, 
    0.03889622f, 0.09119940f, 0.09456640f, 0.15547495f, 0.07538097f, 0.12421381f, -0.00468208f, 0.09321238f, 
    0.14073339f, -0.03595920f, 0.24272908f, 0.28619274f, 0.11367022f, 0.06224718f, 0.27497521f, 0.04659608f, 
    -0.03830080f, 0.13456132f, 0.29129991f, 0.18478604f, 0.40704441f, 0.19580737f, -0.08409865f, 0.11671439f, 
    0.11256031f, 0.01546004f, 0.06126333f, 0.17995971f, 0.30805108f, -0.01087056f, -0.06993556f, 0.13642719f, 
    -0.08400563f, -0.05710728f, 0.17662811f, 0.14706630f, 0.03788662f, 0.06947134f, 0.18616320f, 0.15790793f, 
    0.11866847f, 0.03660332f, 0.20907672f, 0.04799168f, 0.12845479f, 0.06939186f, 0.25264183f, -0.14850235f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.10468005f, -0.37158850f, -0.04934870f, 0.09132322f, -0.01806451f, -0.00342010f, -0.05651450f, -0.07830772f, 
    0.05699725f, 0.00190596f, -0.02607593f, 0.06735516f, -0.05643074f, -0.02409626f, -0.03575906f, -0.00436237f, 
    0.00956383f, -0.02275403f, 0.06273242f, -0.01865270f, -0.10847650f, -0.30648988f, 0.11703470f, 0.06447438f, 
    0.09787391f, -0.01938120f, 0.04082890f, 0.10148149f, 0.03495276f, 0.01984007f, 0.10720541f, -0.01381071f, 
    0.01607333f, 0.04682193f, 0.04506802f, 0.06765970f, 0.01034569f, -0.00715460f, 0.07577316f, -0.00101097f, 
    -0.25515243f, -0.05333714f, -0.08667607f, 0.04586111f, 0.00770067f, -0.02042972f, -0.03157515f, 0.01328052f, 
    -0.01643206f, 0.02360558f, 0.03565488f, -0.05282149f, -0.02580080f, -0.03052478f, 0.03906098f, -0.02832886f, 
    -0.06545465f, -0.00630771f, -0.02001444f, 0.01264052f, -0.02485205f, 0.11996152f, -0.03259606f, -0.13055898f, 
    -0.02094281f, -0.01658305f, 0.04750033f, -0.04091568f, -0.08305690f, 0.08157053f, -0.08167973f, -0.06737202f, 
    0.06391253f, -0.06982542f, -0.00477164f, 0.04858305f, 0.07695415f, 0.05169998f, -0.06767479f, -0.02012495f, 
    0.17101681f, 0.14578637f, 0.02292509f, 0.01402056f, -0.37505221f, 0.08079454f, 0.07260657f, 0.03982880f, 
    -0.05640194f, -0.10316925f, -0.06441494f, 0.08011828f, -0.02375330f, -0.06693015f, 0.04121580f, 0.00856549f, 
    0.04929149f, -0.00956562f, -0.05134201f, -0.02609026f, -0.03267368f, -0.21477868f, -0.03045824f, 0.08660064f, 
    -0.26300377f, -0.09845400f, -0.07756096f, 0.00624031f, 0.01510133f, -0.05108104f, -0.01779366f, 0.05908658f, 
    -0.05004605f, 0.02715798f, -0.04068716f, -0.02473149f, -0.05296403f, -0.03823023f, -0.07646789f, 0.05800218f, 
    -0.21764195f, 0.19748120f, -0.12425389f, -0.05362331f, -0.31072572f, 0.08746535f, -0.05587809f, -0.03228923f, 
    0.09273736f, -0.00655346f, 0.02221512f, -0.01889232f, -0.07608683f, 0.01343895f, 0.02459004f, 0.00786812f, 
    -0.03188564f, 0.02318948f, -0.02402028f, 0.04237598f, 0.08448993f, -0.06386317f, 0.05676177f, 0.03467909f, 
    0.07800335f, -0.13482764f, -0.14954917f, -0.01077425f, 0.02593381f, -0.05921239f, -0.05430429f, -0.00102331f, 
    -0.04565001f, 0.01973806f, 0.03359332f, -0.01146001f, 0.01852171f, -0.02412146f, -0.08074528f, 0.04640448f, 
    -0.13564755f, 0.07371981f, -0.01402766f, 0.03803319f, 0.13942900f, -0.07484527f, -0.04900454f, -0.09997084f, 
    -0.00628449f, -0.07743070f, 0.01863895f, -0.00430089f, 0.11242756f, -0.03157163f, 0.02961635f, -0.06405090f, 
    -0.00673325f, -0.06955039f, -0.08654740f, -0.07293390f, 0.10315414f, 0.07007696f, -0.04024149f, 0.01878752f, 
    0.24260074f, -0.20766000f, -0.21084805f, -0.13483299f, -0.00437320f, -0.04965795f, -0.01823897f, -0.00746994f, 
    0.07285627f, -0.04015756f, 0.04555978f, 0.09500282f, 0.07233670f, -0.11798353f, 0.03988620f, 0.11572237f, 
    -0.20502888f, 0.01660055f, -0.16328040f, 0.27649653f, -0.12598187f, 0.02133897f, 0.04741378f, 0.05235140f, 
    0.09881577f, -0.01060944f, 0.02661796f, 0.04906892f, -0.06224275f, -0.03983672f, -0.03172837f, 0.03091176f, 
    0.00224483f, -0.02928491f, -0.06067696f, 0.07103221f, 0.08296055f, 0.07259777f, 0.05804432f, -0.07205579f, 
    0.26349387f, -0.22255394f, 0.02539853f, 0.02143687f, 0.08394185f, 0.00202929f, 0.05372812f, 0.07313979f, 
    -0.04514549f, -0.03804547f, 0.01080084f, 0.07411465f, 0.07779266f, 0.00071750f, -0.04392461f, 0.05799936f, 
    0.18363196f, -0.17922892f, -0.01428163f, 0.12067939f, -0.15382467f, -0.02121284f, 0.01259568f, -0.03016048f, 
    0.02624631f, -0.03790635f, -0.03693814f, 0.07489398f, -0.01190735f, 0.00325295f, -0.02863562f, -0.01056166f, 
    0.02781874f, -0.04214789f, 0.09615079f, 0.03325845f, -0.09480178f, -0.09111100f, 0.05922794f, 0.04964679f, 
    -0.00210069f, -0.05420312f, -0.04698607f, 0.08757766f, -0.05180120f, -0.03974632f, -0.03519193f, 0.05516616f, 
    0.02412781f, -0.03563339f, 0.01207800f, -0.07649677f, 0.01537628f, 0.05099820f, -0.15662755f, -0.00741138f, 
    -0.10173023f, -0.07411794f, -0.01712035f, -0.11047045f, 0.10822804f, -0.01735759f, -0.10737731f, 0.01276934f, 
    -0.02335217f, -0.06950720f, -0.03213492f, -0.03145743f, -0.03704582f, 0.04796587f, 0.04112532f, -0.08280912f, 
    -0.01898383f, -0.01712284f, -0.09469525f, -0.00212887f, -0.11483391f, 0.19893916f, 0.22780997f, 0.08198872f, 
    -0.19395389f, 0.07555076f, 0.01911920f, 0.06262812f, 0.06502210f, -0.06297559f, -0.02972239f, -0.03744486f, 
    -0.01673231f, -0.05459993f, -0.05725191f, 0.05984114f, 0.10922620f, -0.02037770f, 0.03347318f, 0.02349739f, 
    -0.04994407f, -0.17931205f, 0.05489144f, 0.02077629f, 0.04383462f, 0.04371383f, 0.00176389f, -0.05990839f, 
    -0.03449251f, 0.07957446f, 0.04347588f, 0.02007158f, -0.08767612f, 0.09048661f, -0.04248584f, -0.05617708f, 
    0.02205034f, 0.05829726f, 0.02783062f, -0.06547303f, 0.08448590f, -0.02225612f, 0.09741048f, -0.12978780f, 
    0.38527355f, -0.12817568f, 0.04689381f, -0.08365869f, 0.06436882f, -0.02004988f, -0.07898571f, -0.05316551f, 
    -0.01581897f, 0.01401645f, 0.03934726f, -0.00427082f, 0.00209008f, 0.03303653f, 0.01969389f, 0.01315226f, 
    -0.11513776f, 0.05291586f, 0.31729880f, 0.00137801f, -0.20884545f, 0.03635000f, -0.02566544f, 0.06587888f, 
    0.01305748f, -0.03653157f, -0.04290036f, 0.04865793f, 0.10251945f, -0.00544138f, -0.12167547f, 0.03248524f, 
    -0.02140856f, -0.00766752f, -0.00679939f, 0.01681239f, 0.15299945f, -0.08101514f, -0.10193918f, 0.13124196f, 
    -0.15907837f, -0.11232626f, -0.06319485f, 0.04725522f, 0.02407923f, 0.01993238f, 0.03342662f, 0.02816152f, 
    -0.09236572f, 0.01010695f, -0.02277041f, -0.03864105f, -0.11801131f, 0.03389728f, 0.04214567f, 0.02498499f, 
    0.06082683f, 0.13288593f, -0.15602776f, -0.28814873f, -0.40179184f, 0.04449670f, 0.07505658f, -0.02925386f, 
    0.07259738f, -0.00568557f, 0.03129882f, -0.04335652f, 0.05065028f, 0.03574303f, -0.02729811f, 0.06966489f, 
    0.00441792f, 0.03064851f, -0.03163715f, 0.04535260f, -0.06143552f, 0.00992476f, 0.11528953f, 0.16188307f, 
    -0.05006833f, -0.01234047f, 0.01724064f, 0.04031477f, 0.02485061f, 0.01906341f, -0.03577538f, -0.04295047f, 
    0.01409195f, -0.09803396f, 0.02876820f, 0.02727285f, 0.03235104f, 0.02234591f, 0.04398045f, 0.08530039f, 
    0.18327422f, 0.06302082f, 0.13382168f, -0.15276228f, 0.11158032f, -0.03965451f, -0.02666070f, 0.04967302f, 
    0.00404664f, 0.07280975f, 0.02018840f, 0.04452328f, -0.01555695f, 0.02615136f, -0.05497881f, 0.03026958f, 
    -0.10307875f, 0.07215939f, -0.01211350f, -0.07297307f, -0.08287188f, 0.12259759f, 0.09466629f, -0.05166925f, 
    0.05217498f, 0.03137286f, -0.16201146f, 0.04816344f, -0.07411756f, 0.03944792f, 0.02478228f, 0.05242097f, 
    -0.09703933f, 0.09063639f, -0.05950374f, -0.01325130f, 0.00791514f, 0.03183243f, -0.09121580f, -0.06230112f, 
    0.39554909f, 0.06945805f, 0.15147345f, -0.10470929f, 0.05946746f, -0.01802386f, 0.00661947f, -0.01360558f, 
    -0.02683950f, -0.05658469f, 0.06062288f, -0.03195416f, -0.07707351f, 0.01057503f, 0.04471426f, 0.00338523f, 
    -0.02466689f, -0.02859549f, -0.02686472f, 0.00119322f, 0.23442498f, -0.04883868f, 0.07210339f, 0.07026634f, 
    -0.15115052f, -0.01733878f, -0.06317162f, -0.06719092f, 0.08077400f, 0.01377470f, -0.14864101f, 0.07881469f, 
    0.03320379f, 0.06901787f, -0.00609138f, 0.03108704f, -0.07983468f, 0.01813403f, 0.08127684f, -0.01493352f, 
    0.00144887f, 0.06011773f, -0.01149393f, -0.05261968f, 0.24326335f, -0.16860513f, -0.06305879f, -0.05070021f, 
    0.00894281f, -0.00163294f, 0.00586892f, -0.04455611f, 0.04900141f, -0.07385191f, 0.06697991f, -0.02924041f, 
    0.10165848f, 0.01219541f, 0.00417984f, -0.03999935f, 0.20295663f, -0.08563387f, 0.03276530f, 0.06776625f, 
    -0.11883990f, -0.11556762f, -0.06797345f, -0.02572696f, -0.03389410f, 0.00675474f, -0.05267507f, -0.10167895f, 
    0.02243796f, 0.00087266f, 0.00245508f, -0.02620293f, -0.02539116f, 0.05569670f, 0.03471392f, 0.01316211f, 
    0.15683028f, -0.06517032f, 0.02824585f, 0.04618271f, -0.24736337f, -0.09047714f, -0.00230523f, -0.00532775f, 
    -0.02993663f, 0.00074828f, -0.06621654f, 0.01855288f, -0.02893285f, 0.07228653f, -0.09864554f, 0.01072692f, 
    -0.02494285f, 0.03828470f, 0.01554593f, 0.04629413f, -0.10458648f, -0.16889665f, 0.07414981f, -0.04538171f, 
    -0.24017221f, 0.03282181f, 0.03380838f, 0.00029584f, -0.01818759f, -0.02770978f, 0.04630819f, 0.03368057f, 
    0.00609544f, 0.00296746f, 0.03416187f, -0.02403306f, 0.01180587f, 0.13593957f, -0.05478745f, 0.02277258f, 
    0.02137105f, -0.02370120f, -0.06417640f, -0.03457371f, -0.21338819f, 0.04877841f, 0.02570405f, -0.01897126f, 
    -0.07687794f, 0.01137350f, -0.01880624f, 0.00324135f, -0.06594125f, 0.00169428f, 0.02613802f, -0.04128437f, 
    -0.03195584f, 0.03156538f, 0.02033685f, -0.01826186f, -0.13817666f, 0.27239570f, 0.00537478f, -0.18136576f, 
    -0.18615754f, 0.07986230f, 0.06907663f, -0.05392620f, 0.02847686f, -0.00018291f, 0.00219170f, 0.02658066f, 
    -0.03525709f, 0.09982286f, -0.01868790f, 0.03944008f, -0.00913773f, -0.07520076f, 0.11233364f, -0.04344182f, 
    0.28717706f, -0.38310635f, 0.16700907f, 0.13866076f, -0.20169808f, 0.08726543f, 0.06602924f, 0.01697906f, 
    0.04216414f, -0.01730687f, -0.24918967f, 0.07089648f, -0.02374141f, 0.04482509f, 0.08700588f, 0.00740528f, 
    0.05510771f, 0.12982716f, -0.01569144f, 0.00043536f, -0.00189488f, -0.07321065f, 0.02762471f, -0.12188163f, 
    0.10086145f, -0.07269896f, 0.02547346f, -0.12895283f, -0.08300548f, 0.05597336f, -0.01027420f, -0.06017120f, 
    0.06903461f, -0.02196672f, 0.07730998f, -0.07738365f, 0.00198563f, -0.09634331f, -0.00553434f, -0.07150476f, 
    -0.08557773f, 0.18373239f, -0.04398687f, -0.14444581f, -0.25543687f, 0.05249732f, 0.02965754f, 0.01400140f, 
    0.07163318f, -0.01977812f, 0.01299907f, -0.00579186f, -0.01092224f, -0.01770697f, 0.01864667f, 0.00000891f, 
    0.00592781f, 0.00766167f, 0.00555579f, 0.01387647f, -0.17633554f, 0.11368041f, -0.01900947f, 0.02199701f, 
    -0.20229286f, 0.02714941f, -0.04475905f, 0.02647370f, -0.04249930f, 0.00266315f, 0.02412737f, -0.04551607f, 
    -0.11057610f, 0.04003771f, 0.02697247f, -0.07246136f, -0.01757058f, -0.00885279f, -0.03952903f, 0.02327409f, 
    -0.11967688f, -0.29725662f, -0.05466793f, 0.00766414f, -0.16037890f, 0.00834335f, -0.03699378f, 0.02925299f, 
    0.03414452f, 0.01195817f, -0.06640565f, -0.03853000f, -0.01219831f, -0.04244972f, 0.04752520f, 0.00576475f, 
    -0.02369219f, 0.05685801f, 0.01372867f, -0.03186810f, -0.18780941f, -0.03447765f, 0.01201027f, 0.08093353f, 
    -0.27035081f, -0.03990760f, 0.04848516f, 0.00250658f, 0.09166185f, 0.07523620f, -0.01184187f, 0.03418957f, 
    -0.04845355f, -0.04321457f, -0.06106891f, -0.03557221f, -0.03965450f, 0.05736099f, -0.08022842f, 0.00367334f, 
    -0.28725275f, 0.02495980f, 0.05730949f, -0.03605650f, -0.00411783f, -0.00638501f, 0.06511031f, -0.06773413f, 
    -0.11430710f, 0.12164011f, 0.02310621f, 0.01103457f, 0.10558799f, 0.00951342f, -0.00120312f, -0.00009050f, 
    -0.06159388f, 0.00850981f, -0.03527547f, -0.12779737f, -0.22502570f, -0.15318014f, 0.01252163f, 0.12406522f, 
    -0.11315081f, 0.01537718f, -0.01382491f, 0.00356241f, 0.04883159f, 0.00751833f, 0.03764145f, 0.07742520f, 
    0.03491887f, -0.06203130f, -0.05459537f, 0.08010379f, -0.06779966f, -0.05004952f, -0.02662928f, -0.05681596f, 
    0.27526525f, -0.03390407f, 0.08423299f, -0.03260863f, 0.28722230f, -0.09791365f, -0.02445361f, 0.03157334f, 
    0.05087776f, -0.03815981f, 0.05097052f, 0.04991444f, -0.07492029f, 0.02128019f, 0.00962409f, 0.02941208f, 
    0.00120986f, 0.03425755f, -0.09890549f, 0.03774368f, 0.09550980f, 0.10482535f, 0.07146265f, -0.07214175f, 
    0.23373997f, -0.15835312f, 0.03505778f, 0.04348427f, 0.05009088f, 0.00306737f, 0.05257637f, 0.08049154f, 
    -0.05435988f, -0.10410637f, 0.04018196f, 0.13369860f, 0.02135174f, 0.02034840f, -0.00127622f, -0.01496620f, 
    0.17578125f, 0.04735000f, 0.15199791f, -0.24948116f, 0.09018043f, -0.06130801f, -0.12917468f, -0.07433345f, 
    0.03766340f, -0.02056307f, 0.01033378f, -0.04746769f, -0.00444038f, 0.02576287f, -0.09168418f, -0.03821940f, 
    -0.00732929f, -0.03378579f, 0.02177851f, -0.01358400f, 0.39832929f, -0.00455667f, 0.05827058f, -0.10995992f, 
    -0.03285175f, -0.09379205f, 0.00501615f, -0.02406146f, -0.02677975f, -0.03373626f, 0.07468104f, 0.02347577f, 
    -0.00290378f, 0.02026863f, 0.06072792f, 0.05699171f, 0.04017023f, 0.03260990f, 0.02640678f, -0.06185134f, 
    -0.04259768f, -0.17225461f, -0.06874923f, 0.06562855f, -0.14007561f, -0.00909661f, 0.03539559f, 0.02770825f, 
    0.07117455f, -0.02933760f, -0.04039697f, -0.05022419f, -0.07567298f, -0.02202716f, 0.04885150f, 0.06360814f, 
    -0.03493457f, 0.07292321f, -0.02207359f, -0.07577720f, 0.22734430f, 0.05767569f, -0.08006320f, -0.10928036f, 
    -0.10653830f, -0.11744788f, -0.13662855f, -0.02147806f, 0.05627446f, -0.02377695f, 0.02904762f, 0.07937849f, 
    -0.01194844f, 0.04917515f, -0.03632491f, -0.07552552f, -0.07238861f, 0.06833072f, 0.00679604f, 0.04007377f, 
    0.10191584f, 0.05847130f, 0.28781313f, -0.02858480f, 0.00805957f, 0.05336333f, 0.00764517f, 0.03911827f, 
    0.00444655f, 0.04192199f, -0.01671302f, 0.03119224f, -0.00669088f, 0.01147360f, 0.00845985f, 0.07403900f, 
    -0.04736710f, -0.00042097f, -0.04884399f, -0.05916899f, 0.10912843f, -0.24791229f, -0.03154153f, 0.16617179f, 
    -0.10945936f, -0.00054783f, 0.00788371f, -0.09701578f, -0.01127255f, 0.05839531f, -0.00870300f, -0.08210135f, 
    0.06271707f, -0.00906329f, -0.00575811f, -0.05604767f, -0.09321640f, 0.02561471f, 0.05439159f, -0.04015879f, 
    -0.10118144f, -0.30007488f, -0.04667149f, 0.06359595f, -0.03253524f, 0.05928971f, -0.03714070f, -0.00284136f, 
    0.02870008f, -0.02768712f, -0.02214331f, -0.02680230f, -0.10566966f, 0.02501942f, -0.01797314f, 0.08620319f, 
    -0.00545808f, 0.03062358f, -0.07316495f, -0.06297357f, -0.22232483f, -0.12454851f, -0.01949385f, 0.10767295f, 
    -0.00485827f, 0.03328550f, -0.03938585f, -0.05831142f, -0.09192001f, 0.00688805f, 0.01406178f, -0.01866858f, 
    0.10815224f, 0.09648376f, 0.05009161f, -0.07988610f, 0.02514169f, 0.01910960f, 0.01213892f, -0.04140202f, 
    -0.18782437f, 0.27116448f, -0.08011246f, -0.02505323f, -0.17648414f, -0.00120752f, -0.01119781f, -0.06116710f, 
    0.08127680f, -0.05687650f, 0.06443495f, 0.09947672f, -0.01616771f, 0.10455857f, 0.00538537f, -0.04626393f, 
    -0.08811212f, 0.01211162f, 0.08272566f, -0.04323165f, -0.04490093f, -0.21225299f, 0.10569198f, -0.03105444f, 
    0.10418122f, -0.03846326f, 0.01623279f, -0.09214772f, 0.07021417f, -0.00862253f, 0.01541678f, -0.03909962f, 
    0.00556911f, 0.00668936f, 0.01395693f, -0.00881292f, -0.03399806f, -0.08418154f, 0.08906636f, 0.00776799f, 
    -0.08246484f, -0.01274966f, 0.08305383f, -0.03692504f, 0.27594408f, 0.08422536f, -0.02660235f, 0.02688814f, 
    -0.01534143f, -0.00735247f, -0.00733311f, -0.05238303f, -0.02815862f, -0.02560793f, 0.02977527f, -0.09057672f, 
    -0.02768080f, 0.06720039f, 0.00372083f, -0.08276231f, 0.18937288f, -0.03723659f, 0.06527985f, -0.12481961f, 
    0.14780562f, -0.10600232f, -0.11710995f, 0.03447600f, -0.18282697f, -0.00144500f, -0.03560599f, 0.03445804f, 
    -0.01333461f, 0.05204239f, 0.06644893f, -0.07298709f, 0.02891744f, 0.08779312f, -0.10518335f, -0.05467343f, 
    0.13997050f, -0.02904492f, 0.07296818f, -0.12223855f, -0.02176218f, 0.01389385f, -0.10905660f, -0.00244383f, 
    0.04622363f, 0.00888090f, -0.03827028f, -0.06334881f, -0.04465225f, 0.01934477f, -0.06191247f, 0.06739455f, 
    0.02772358f, 0.00368665f, -0.00986358f, 0.00564935f, -0.00378430f, 0.04534433f, -0.00970365f, 0.03839919f, 
    0.00619847f, -0.08628847f, -0.02241248f, -0.01568760f, -0.09154191f, -0.01970704f, 0.06672846f, 0.01591162f, 
    0.05274779f, -0.03878799f, -0.06276801f, -0.03993196f, 0.04665358f, -0.02195842f, 0.05677478f, -0.13234884f, 
    -0.36342078f, 0.13049933f, -0.07321118f, 0.01918915f, 0.12561548f, 0.00090869f, -0.00284881f, 0.08396111f, 
    -0.06656720f, 0.01244774f, -0.02612627f, -0.14163089f, -0.00224271f, 0.07148837f, 0.02087970f, -0.01378034f, 
    -0.05087169f, -0.02150093f, -0.02958835f, -0.08331096f, 0.23026101f, -0.31984800f, -0.00639227f, -0.12219317f, 
    -0.16066596f, 0.01759632f, 0.12147072f, 0.00442501f, -0.03809953f, -0.01663461f, -0.08439595f, 0.08445936f, 
    -0.04788552f, 0.06085654f, 0.02444794f, 0.01343876f, -0.07196026f, 0.00864747f, -0.00183231f, 0.01598470f, 
    0.08138264f, -0.29269162f, 0.11408950f, 0.13075233f, -0.04572720f, -0.00248139f, 0.03094670f, 0.00768355f, 
    0.06230262f, 0.05797455f, -0.00554893f, -0.04328096f, -0.02623228f, 0.03713048f, 0.00902305f, -0.02255194f, 
    -0.04773223f, 0.03473676f, 0.05732761f, -0.10482831f, 0.17130764f, -0.08806445f, 0.08204183f, 0.08021127f, 
    -0.05747482f, -0.01461597f, -0.17003465f, 0.02568965f, 0.02218880f, -0.01430550f, -0.08874123f, 0.01803495f, 
    -0.08186436f, 0.07202654f, -0.00802164f, 0.07155938f, -0.04962331f, 0.07447521f, 0.00373601f, 0.04201502f, 
    0.17499185f, -0.04093375f, 0.12712692f, -0.18852705f, 0.18723039f, -0.10630263f, 0.04353431f, -0.03167315f, 
    0.01627739f, 0.01565207f, -0.03237655f, 0.00683516f, -0.04014907f, -0.00289263f, -0.02244803f, 0.05682721f, 
    -0.00070298f, 0.03258828f, -0.07413334f, 0.02969793f, -0.25412938f, 0.09259904f, 0.03645387f, -0.01604980f, 
    0.02735318f, -0.07058243f, -0.00471752f, 0.06595714f, -0.00310801f, -0.02318493f, 0.01965353f, 0.06111843f, 
    0.00113623f, -0.05608506f, 0.07611150f, 0.01909981f, 0.03947968f, 0.03050639f, -0.06396826f, -0.01409662f, 
    0.00162961f, 0.08590940f, 0.04424175f, 0.02587766f, 0.03850819f, 0.02359525f, -0.00424605f, 0.01272314f, 
    0.02646234f, -0.03522223f, 0.02231099f, -0.07318153f, -0.02198057f, -0.03800193f, 0.00165173f, 0.07477056f, 
    -0.01011400f, 0.00545144f, -0.00848181f, 0.05913462f, -0.26448676f, -0.41432217f, -0.23138541f, 0.16324595f, 
    -0.07307267f, -0.05166164f, -0.06034832f, 0.01761132f, 0.01051544f, 0.03189036f, 0.02331901f, 0.01935364f, 
    0.01316956f, -0.09221452f, 0.03495377f, 0.08659284f, 0.05043010f, -0.01181064f, 0.05160460f, -0.03476097f, 
    -0.09336521f, -0.04994946f, -0.01374226f, -0.00543910f, -0.16323079f, 0.03341420f, 0.01534053f, 0.06452987f, 
    0.03429117f, 0.05849937f, 0.05299300f, -0.04846559f, 0.08653591f, 0.01308817f, -0.00812105f, 0.00074431f, 
    0.03750913f, -0.10850991f, -0.10114460f, -0.08560115f, 0.02167584f, -0.10621134f, 0.03988644f, -0.01330517f, 
    0.00623209f, 0.03647170f, -0.03148307f, 0.04023274f, -0.01303470f, 0.00004039f, -0.05505111f, -0.00642690f, 
    0.00853462f, -0.02763021f, -0.01150615f, 0.05919950f, -0.09167364f, -0.16156484f, 0.03669433f, 0.00706120f, 
    0.24929230f, -0.21071240f, -0.16628580f, 0.06510669f, -0.02049240f, -0.08748112f, 0.02880432f, 0.03303232f, 
    0.08136162f, 0.03867760f, -0.00521951f, -0.01808956f, 0.00679789f, 0.09611084f, 0.01600986f, 0.19758199f, 
    -0.01767717f, 0.05821668f, -0.03366904f, -0.00084009f, 0.25910613f, -0.30679554f, 0.01147650f, -0.04040147f, 
    0.02103626f, 0.00385209f, -0.01105994f, 0.03588310f, 0.04598861f, -0.02366710f, 0.06593147f, 0.05670366f, 
    -0.05140615f, 0.11868382f, -0.04038901f, 0.07718188f, 0.02273276f, -0.04134939f, 0.03691709f, 0.08199574f, 
    0.18051055f, -0.09415818f, 0.02437212f, -0.01627306f, -0.24127248f, -0.04382466f, 0.07708411f, 0.00781186f, 
    0.06978308f, 0.15921237f, 0.09829009f, -0.06219040f, 0.03288429f, -0.02388170f, 0.04577184f, -0.02973827f, 
    0.01678398f, 0.04124271f, 0.07196488f, 0.04209091f, -0.02407636f, -0.19054082f, -0.06282169f, 0.06685415f, 
    -0.02755980f, 0.00246052f, 0.00472073f, -0.01413851f, -0.02182341f, 0.02157405f, 0.06201631f, -0.02476109f, 
    0.06281837f, 0.01676077f, 0.03715461f, 0.06065479f, -0.00904556f, 0.01728796f, 0.02077125f, -0.01485736f, 
    0.19179462f, -0.04550184f, -0.02265856f, 0.11176387f, -0.11562553f, -0.06610967f, -0.00029085f, 0.06256987f, 
    0.01901537f, 0.03326356f, -0.01745563f, -0.04371756f, -0.05263710f, 0.03966085f, -0.00088285f, 0.09421816f, 
    0.01424709f, -0.01451490f, -0.10701677f, -0.05611718f, 0.08921685f, 0.05888924f, 0.08400002f, 0.03532666f, 
    0.13371584f, -0.00755093f, 0.01162049f, 0.00861589f, 0.04042863f, 0.03377714f, 0.04953965f, 0.03800298f, 
    0.05344905f, -0.04424233f, 0.04637852f, -0.02397757f, 0.04156972f, -0.01705743f, 0.05772574f, 0.01025671f, 
    0.12726584f, -0.18403918f, 0.08656923f, -0.37442985f, -0.11460114f, -0.05008363f, 0.00338273f, -0.10217503f, 
    0.11267795f, -0.02877290f, 0.01711853f, -0.05654064f, -0.07161618f, 0.07150965f, -0.01386126f, -0.00614575f, 
    -0.03990096f, 0.04844755f, 0.15626800f, -0.01936835f, 0.06551768f, 0.24310043f, -0.07216498f, 0.10741851f, 
    0.05169014f, 0.06757303f, -0.01767390f, 0.08756395f, 0.04572803f, 0.04776318f, -0.04082640f, 0.00815284f, 
    -0.12027148f, 0.04765793f, -0.09569003f, 0.07813613f, -0.06479181f, 0.08666276f, -0.00187199f, -0.08250250f, 
    -0.19894856f, -0.04410103f, -0.00194037f, -0.27739921f, -0.30899119f, 0.05379529f, -0.03671860f, -0.02835477f, 
    -0.05449899f, -0.07435366f, -0.06836234f, 0.04692761f, -0.09361084f, -0.02201593f, -0.06708325f, -0.11686179f, 
    -0.04653855f, -0.02131307f, -0.04343310f, 0.03144366f, 0.12678473f, 0.13441131f, 0.09942091f, 0.02030871f, 
    0.20149279f, -0.06601272f, 0.01536174f, 0.02178470f, 0.02841499f, -0.05221473f, -0.12016210f, -0.05991122f, 
    -0.02353340f, 0.03309086f, -0.05617900f, -0.02537845f, 0.09398727f, 0.03650859f, -0.00554551f, 0.01718674f, 
    -0.40888795f, -0.18321337f, -0.06685577f, 0.02513180f, -0.12040736f, 0.00089715f, -0.00946250f, 0.01075076f, 
    0.08450177f, -0.04337372f, 0.10371018f, 0.02489491f, 0.02578999f, -0.00611212f, -0.00164194f, -0.03062567f, 
    -0.02392944f, -0.11109393f, 0.00363528f, 0.00239307f, 0.19016945f, -0.35498592f, -0.04879696f, -0.06428605f, 
    -0.12210836f, 0.03645464f, -0.01929515f, -0.05481277f, 0.09482045f, 0.01096663f, 0.01831415f, 0.06256068f, 
    0.02599077f, 0.01130163f, 0.00083325f, 0.01606003f, 0.04551554f, -0.05068525f, 0.09152039f, -0.05068006f, 
    0.06993865f, 0.13908741f, 0.08918670f, 0.04978681f, 0.11683512f, -0.06208018f, 0.02823188f, 0.03332210f, 
    0.01812225f, 0.05932667f, 0.01703899f, 0.06761450f, 0.06583980f, -0.02282861f, -0.01215056f, 0.01328487f, 
    0.04013937f, 0.07262969f, 0.01939618f, 0.00216083f, -0.06587039f, 0.07039914f, -0.12543727f, 0.07436668f, 
    -0.15017401f, -0.00059671f, 0.04572454f, -0.06575564f, -0.13836613f, 0.05874747f, 0.00138088f, 0.10441040f, 
    -0.08043141f, -0.04247525f, 0.00651389f, 0.01300722f, -0.03244777f, 0.00642343f, -0.03714700f, -0.01722143f, 
    -0.08306952f, -0.08892598f, -0.03127756f, -0.19999717f, 0.04162212f, 0.00407593f, -0.10002363f, 0.13201219f, 
    -0.01981860f, 0.03654440f, -0.03978924f, -0.02939763f, 0.09193794f, -0.04793255f, 0.12317946f, -0.04670943f, 
    0.07420522f, -0.06221897f, -0.12581271f, -0.07264373f, 0.20370795f, -0.09209415f, 0.16551402f, -0.05342241f, 
    -0.03528926f, -0.06432723f, -0.04333831f, -0.01915530f, -0.00141005f, -0.00304421f, 0.00548782f, 0.01398165f, 
    -0.03843607f, 0.10823680f, -0.03710595f, -0.05333287f, 0.05604694f, -0.02851917f, 0.00784599f, -0.06705894f, 
    -0.14653330f, -0.06166576f, -0.03654398f, -0.04536815f, 0.05791888f, -0.00920064f, -0.02018150f, 0.01917111f, 
    -0.05376907f, 0.09688294f, -0.07130869f, -0.01843597f, -0.04823041f, -0.01303908f, -0.01468931f, -0.05129217f, 
    -0.01475087f, 0.05708084f, -0.00560934f, 0.08622850f, -0.15674102f, -0.12487607f, -0.05947966f, -0.07470839f, 
    -0.19540507f, 0.11785524f, -0.00926615f, -0.00784929f, 0.06351723f, -0.05796717f, 0.07651258f, -0.03597589f, 
    -0.01523817f, 0.01274679f, 0.04769741f, -0.01856982f, -0.03759318f, -0.06867277f, -0.03335014f, -0.09890139f, 
    0.13613461f, -0.04707245f, -0.05713055f, 0.03238861f, -0.28687763f, 0.00006163f, -0.05100373f, 0.00559008f, 
    0.00763419f, 0.04162214f, 0.12524045f, 0.01903479f, 0.04602798f, 0.03158554f, -0.06695659f, 0.05161400f, 
    0.16558768f, -0.06981822f, -0.04982556f, -0.01334469f, -0.12339449f, 0.20148852f, -0.09654561f, 0.01535177f, 
    -0.03506458f, -0.01452352f, 0.05251874f, 0.01659185f, -0.15281175f, 0.02382879f, -0.03455527f, 0.16997980f, 
    0.02307109f, -0.01734454f, 0.05203056f, 0.06082033f, -0.10616222f, 0.09337163f, 0.07926830f, 0.00399111f, 
    -0.20851120f, -0.05765521f, -0.22490256f, -0.09517290f, 0.09323758f, 0.01163808f, 0.00792853f, 0.04684329f, 
    -0.02929396f, -0.00194648f, -0.05676974f, -0.06461542f, 0.02948354f, -0.04977371f, -0.03280871f, 0.03713752f, 
    -0.02287073f, -0.01245831f, 0.00097954f, -0.01805874f, 0.01171965f, -0.25114524f, -0.14107424f, -0.09724966f, 
    0.15736973f, -0.00318474f, 0.00930007f, -0.00361604f, -0.08501630f, -0.01668652f, 0.02324888f, 0.02312481f, 
    0.11721763f, -0.11329121f, 0.02244089f, 0.02289911f, -0.12693395f, -0.02306639f, 0.01349444f, 0.00357320f, 
    -0.29830104f, 0.00713827f, -0.02903211f, -0.04994584f, 0.08552924f, 0.03793304f, -0.00062063f, -0.01006133f, 
    0.04340547f, -0.02459644f, -0.00526696f, 0.06621084f, 0.01184186f, -0.05094710f, -0.00383562f, 0.10557783f, 
    -0.03229401f, -0.01056144f, 0.02540202f, -0.07309043f, 0.19704318f, -0.15787110f, -0.00011998f, 0.01444285f, 
    0.02339247f, 0.01764273f, 0.03149367f, 0.02451498f, -0.03686149f, -0.00773027f, 0.05334869f, 0.00172453f, 
    -0.00343595f, -0.02001710f, -0.03786273f, -0.02308664f, -0.05217995f, -0.12591088f, -0.09850163f, 0.01685051f, 
    0.14592595f, 0.21201085f, -0.06430749f, 0.03473658f, 0.12234693f, 0.10551398f, -0.04302080f, 0.01732142f, 
    0.01820863f, 0.00064671f, -0.01782618f, -0.04083741f, -0.03499839f, 0.07517936f, -0.00505282f, 0.06642422f, 
    -0.00022136f, 0.08300799f, -0.05921566f, 0.04009333f, -0.08715825f, 0.17136970f, 0.04876623f, -0.03220782f, 
    -0.06172324f, 0.05953763f, 0.01073370f, -0.01284601f, 0.00367754f, -0.03503152f, -0.00644885f, 0.05668015f, 
    0.03523095f, 0.06949334f, 0.02988903f, 0.05631401f, -0.00270527f, -0.17593737f, -0.05720915f, 0.00975715f, 
    0.30535746f, -0.04285866f, 0.15667458f, -0.00302707f, -0.04308432f, 0.01965087f, -0.00016788f, 0.03437397f, 
    0.01488731f, 0.08617468f, 0.03507421f, 0.04223463f, 0.06778034f, -0.08496467f, -0.03579401f, -0.01182628f, 
    0.04831523f, 0.03758459f, 0.03621476f, 0.12536266f, 0.08362104f, -0.06728347f, -0.16933104f, -0.07098880f, 
    -0.12242916f, 0.01978013f, -0.12295327f, 0.08450403f, 0.04682418f, 0.09174024f, 0.00115736f, 0.05968924f, 
    -0.04334787f, -0.02070598f, -0.00005361f, -0.02022751f, 0.02925646f, -0.07097974f, -0.14285439f, 0.01585653f, 
    -0.08045598f, 0.02708435f, 0.06935445f, 0.03684762f, -0.02371691f, -0.04560606f, -0.00984730f, 0.03611780f, 
    0.03171857f, 0.04525037f, 0.01755717f, 0.00548328f, 0.07318361f, -0.05412242f, -0.05780073f, 0.03450581f, 
    -0.00340973f, 0.04690119f, 0.06049489f, -0.00380083f, 0.23239674f, 0.06509294f, -0.10574848f, 0.00287130f, 
    -0.12070454f, -0.04300495f, 0.01320273f, -0.05718585f, 0.01304464f, 0.08720060f, 0.02247984f, -0.06527531f, 
    -0.00546473f, -0.01159395f, 0.05342904f, 0.06722374f, 0.03329638f, 0.07508331f, -0.13256729f, 0.12295523f, 
    0.00863338f, 0.08931560f, 0.13220981f, -0.12668383f, -0.18128693f, -0.10326178f, 0.12087596f, -0.01743200f, 
    -0.04436720f, 0.00926635f, 0.13384859f, 0.00560351f, 0.08667105f, -0.08891051f, -0.10004281f, -0.01390259f, 
    -0.06631030f, -0.14925396f, 0.07567114f, -0.03007222f, 0.09603880f, -0.20103957f, 0.01068033f, -0.10558312f, 
    -0.05759251f, 0.05209108f, 0.00546361f, 0.05401964f, 0.09927204f, -0.03417723f, -0.10129008f, 0.05226440f, 
    -0.06877865f, 0.04395024f, -0.04970068f, 0.06658009f, 0.00405104f, 0.10482910f, 0.08390353f, 0.01166608f, 
    0.13448964f, -0.07409382f, -0.06734981f, -0.03103999f, -0.09088954f, -0.02041588f, 0.03496132f, -0.00578570f, 
    -0.03245177f, 0.02533459f, 0.03626713f, 0.00533496f, -0.00937657f, 0.03982308f, 0.03168667f, 0.08305950f, 
    -0.03973472f, -0.05360997f, -0.10049673f, 0.00805257f, 0.17611176f, -0.16973065f, -0.10786361f, 0.06596480f, 
    0.01963927f, -0.03682458f, 0.04570254f, -0.01736207f, 0.01831286f, 0.01790563f, 0.06757738f, 0.04881195f, 
    -0.04136427f, 0.02584416f, 0.01315722f, 0.02401131f, -0.01566786f, -0.01526258f, -0.08760831f, -0.01328093f, 
    0.03137825f, -0.01222412f, 0.04414497f, 0.01280967f, -0.10554412f, 0.02631642f, 0.04486897f, 0.10120868f, 
    0.07813872f, 0.08800068f, -0.07846346f, -0.08323578f, 0.04392953f, 0.06700099f, -0.05885488f, 0.06422131f, 
    0.09345629f, -0.15509266f, 0.02064992f, 0.00981770f, 0.03539606f, -0.09060545f, -0.03053471f, 0.05513873f, 
    -0.15733573f, 0.02719266f, 0.01606319f, -0.01570902f, -0.04726644f, 0.02523120f, 0.00244565f, 0.03725015f, 
    -0.02220069f, -0.01351108f, -0.04026607f, -0.01665866f, 0.00754968f, -0.04993735f, -0.10861821f, 0.09335806f, 
    -0.05926321f, 0.31169394f, 0.03756202f, -0.05556590f, 0.17930481f, 0.02704850f, -0.05296492f, 0.01953387f, 
    -0.02296025f, 0.12431069f, 0.07160676f, -0.06591953f, -0.08991206f, -0.08103770f, -0.14898165f, -0.02698017f, 
    0.06829983f, 0.04343059f, -0.00993280f, 0.18853474f, -0.28553477f, -0.00961931f, -0.18283357f, 0.00360967f, 
    -0.05815257f, -0.01843536f, 0.02266985f, -0.03041829f, 0.00917047f, 0.10214750f, -0.01674724f, -0.10761079f, 
    -0.04239606f, -0.05867701f, -0.06754266f, -0.11791971f, 0.05283754f, 0.01192723f, -0.10444455f, 0.05453728f, 
    -0.19630678f, -0.22529462f, 0.00581393f, -0.12629421f, 0.07471369f, 0.04476822f, -0.11832561f, -0.07160479f, 
    -0.00653623f, -0.02822432f, 0.02791670f, 0.03987271f, -0.02093209f, -0.00073645f, 0.08091974f, -0.03770003f, 
    0.00264647f, -0.08550287f, -0.01297349f, -0.00496142f, 0.18440753f, 0.03832680f, 0.05990560f, -0.06975468f, 
    0.34717640f, -0.09160747f, -0.03168039f, 0.05009746f, -0.00031067f, -0.06587639f, -0.11365305f, -0.12975205f, 
    0.06983068f, 0.01492054f, 0.01551005f, -0.09660009f, 0.08134700f, 0.01629532f, 0.00513956f, -0.00785349f, 
    0.10821862f, 0.06273995f, 0.04867036f, 0.04121850f, 0.08138165f, 0.00923672f, -0.05088156f, 0.01172382f, 
    -0.00243623f, -0.03528167f, 0.03748846f, -0.03598932f, 0.02094956f, -0.01035700f, 0.04287631f, 0.04957400f, 
    0.06926452f, -0.08786474f, -0.02447135f, -0.01897249f, -0.23562402f, -0.19581640f, 0.02247744f, -0.03976859f, 
    0.01536832f, 0.01973000f, -0.10470805f, -0.07304375f, -0.00565260f, 0.03845230f, -0.08609079f, 0.01247228f, 
    -0.01884876f, -0.05482085f, 0.00970108f, 0.05890589f, -0.02716623f, -0.10915881f, 0.01099510f, -0.07095556f, 
    0.00833571f, 0.09000273f, -0.00772906f, -0.05408033f, 0.02471295f, 0.10048633f, -0.06697643f, 0.10886737f, 
    0.00370532f, 0.07453718f, 0.03133276f, -0.03830526f, 0.03058151f, 0.04458514f, -0.01887894f, 0.02516229f, 
    0.05736642f, -0.09146113f, 0.08175503f, -0.05109474f, 0.08947925f, 0.08509361f, 0.13108878f, 0.08825099f, 
    0.12109517f, -0.10177608f, -0.14582378f, -0.03870357f, -0.00894496f, 0.03356704f, 0.06106329f, -0.03792882f, 
    -0.02044507f, -0.02490051f, -0.02413267f, -0.01762401f, 0.08541290f, -0.03611213f, -0.08970422f, 0.04678118f, 
    -0.50322020f, 0.07329202f, -0.08993364f, -0.05539269f, 0.23507373f, -0.21999305f, 0.04944827f, -0.00264959f, 
    -0.07093991f, 0.10245050f, 0.00399278f, -0.06735908f, 0.06712038f, -0.05137802f, -0.11932213f, -0.04277268f, 
    -0.03505268f, 0.10060883f, 0.02174858f, 0.02605492f, -0.25395620f, 0.12862749f, 0.01746035f, -0.08050539f, 
    -0.03239129f, -0.06355067f, -0.00865404f, 0.03623375f, 0.05268405f, 0.00395598f, 0.01849193f, 0.04152913f, 
    -0.04450470f, 0.10283422f, -0.10097425f, -0.12030216f, -0.02694258f, -0.06288064f, -0.13588840f, -0.10354813f, 
    -0.05482537f, 0.09126285f, 0.04661958f, -0.01404150f, 0.00969823f, -0.04496147f, -0.07929043f, 0.17085357f, 
    -0.03665262f, -0.06268010f, 0.01928744f, -0.17078196f, 0.11562031f, 0.01845927f, -0.04978280f, -0.13345851f, 
    0.07793137f, -0.15067345f, 0.01840180f, -0.08149219f, -0.26594892f, 0.10188263f, -0.02101717f, -0.03199064f, 
    -0.05439218f, -0.04332267f, -0.04856830f, -0.06739481f, 0.07194407f, -0.08911473f, -0.10310637f, -0.09202854f, 
    -0.03075280f, -0.07901829f, -0.14435294f, 0.10343762f, -0.09518468f, -0.00975646f, 0.08759838f, 0.15392387f, 
    0.26768619f, 0.08875720f, -0.03479374f, 0.00883699f, -0.11506164f, 0.06081767f, -0.01321733f, -0.07617631f, 
    0.06332981f, 0.01794270f, -0.01416377f, -0.11530256f, 0.06774164f, -0.00770904f, 0.07771081f, 0.02861110f, 
    -0.05049660f, 0.02585510f, -0.04032297f, 0.05050852f, 0.13335790f, -0.22124921f, 0.07526727f, -0.02586965f, 
    -0.04150893f, 0.05317127f, -0.06972098f, 0.01589577f, 0.07297382f, -0.02999592f, -0.00527113f, 0.02523081f, 
    -0.04509862f, 0.01174068f, 0.02617424f, -0.01510935f, -0.04351615f, 0.04709878f, -0.04177976f, -0.12146439f, 
    -0.41440678f, 0.20438381f, -0.27039674f, -0.30641943f, -0.02653984f, -0.04347083f, 0.12534140f, 0.00289250f, 
    -0.06241065f, 0.05292670f, -0.00965612f, -0.02813848f, 0.05779669f, 0.06744277f, 0.01977912f, -0.03293755f, 
    -0.02297496f, 0.09257051f, -0.18886341f, 0.01208584f, -0.06258211f, -0.02280173f, 0.08141818f, 0.02037785f, 
    0.26841217f, 0.02078445f, -0.04429033f, 0.03449040f, -0.10195696f, 0.00597957f, 0.00512301f, 0.11816327f, 
    -0.07068428f, -0.00927837f, 0.03499813f, 0.09794761f, -0.07768727f, -0.03636190f, 0.04670645f, 0.09875357f, 
    0.09777199f, 0.03470171f, 0.06334632f, -0.01182144f, 0.18966070f, -0.07357550f, 0.01024796f, 0.06598531f, 
    -0.03028782f, 0.03187869f, 0.03942106f, -0.03356926f, 0.12281214f, 0.00179596f, 0.07471115f, -0.00385511f, 
    -0.02179669f, -0.10566244f, -0.00628767f, 0.03594852f, -0.21420768f, -0.14450616f, -0.03471339f, -0.05073281f, 
    -0.08386190f, 0.03491056f, 0.00331367f, 0.05076252f, 0.00227383f, 0.05539880f, 0.01666530f, 0.04973278f, 
    0.10580192f, 0.04199278f, -0.04416569f, -0.02289078f, -0.02926150f, -0.08988922f, -0.05140111f, 0.07678493f, 
    0.36384735f, -0.38121176f, -0.00477499f, -0.03246327f, -0.01370048f, -0.10183246f, 0.00707414f, 0.02454572f, 
    0.06491252f, 0.01174585f, 0.03214294f, 0.02937715f, -0.02148761f, 0.00724967f, 0.12781474f, 0.03879378f, 
    -0.02015944f, 0.03262624f, 0.00285020f, 0.02777435f, 0.08956891f, 0.13259843f, 0.18874416f, -0.03841054f, 
    -0.03734711f, -0.06529751f, -0.06537563f, -0.00656425f, 0.02215648f, -0.02575804f, 0.01625023f, 0.01593862f, 
    0.09732501f, 0.01588964f, -0.10275445f, -0.00951628f, 0.03576704f, 0.01041085f, 0.03459325f, -0.02999924f, 
    -0.07862376f, -0.03448540f, -0.08424486f, -0.19667387f, -0.03749846f, -0.03286917f, 0.05176105f, 0.05053705f, 
    0.02505671f, 0.02028180f, -0.00911388f, 0.04129381f, -0.00088026f, 0.02843454f, 0.00641055f, -0.08246722f, 
    -0.09068572f, -0.03173632f, -0.03800373f, -0.08832273f, 0.07426424f, -0.02951653f, 0.04675340f, -0.04228414f, 
    0.00513319f, -0.14650884f, -0.00228757f, 0.00627068f, -0.03068345f, 0.01628331f, 0.12521236f, -0.01459373f, 
    0.05933428f, -0.14021799f, 0.07872982f, -0.10382116f, 0.05054605f, -0.10854503f, 0.01077192f, 0.08577839f, 
    0.07772049f, -0.06693231f, 0.10044255f, 0.09633695f, 0.19914049f, -0.03392173f, -0.07529450f, 0.02827325f, 
    0.02405908f, -0.09137392f, -0.04388692f, -0.00825736f, -0.01187986f, 0.13477892f, -0.08836838f, -0.03565540f, 
    0.00222907f, -0.00624153f, 0.00632209f, -0.06455186f, 0.32694077f, -0.24880880f, -0.26794001f, 0.05864151f, 
    0.02997769f, -0.00838212f, -0.00220387f, -0.02327306f, 0.05510853f, 0.13262351f, 0.00625010f, -0.00449207f, 
    -0.08802185f, -0.00539793f, 0.02691354f, 0.09106074f, 0.06828383f, -0.08552223f, -0.03228095f, 0.01682189f, 
    -0.05378428f, 0.05997277f, -0.09952258f, -0.01730453f, 0.02905874f, 0.01961567f, -0.02917655f, -0.06102314f, 
    -0.10985161f, 0.02674167f, 0.08324330f, 0.12428972f, 0.03581232f, -0.00123428f, 0.01194010f, -0.03845247f, 
    -0.07587418f, 0.03553018f, 0.00635628f, 0.04070016f, -0.00440717f, -0.00280617f, -0.08630694f, 0.02271692f, 
    -0.13891712f, 0.07728342f, -0.02372454f, -0.04220805f, 0.07502174f, 0.02207757f, -0.07436547f, -0.12007388f, 
    -0.03286849f, 0.14180627f, -0.12401312f, -0.02697375f, 0.00573630f, -0.04952470f, -0.14593676f, -0.13416573f, 
    0.20447019f, -0.10897982f, -0.09720622f, 0.01113079f, -0.23489247f, -0.03845646f, 0.01094745f, -0.10803315f, 
    0.06581558f, 0.01924428f, -0.02013694f, -0.06651463f, -0.00412539f, -0.05462695f, 0.00884833f, 0.02202792f, 
    0.03621079f, 0.03024452f, 0.06921757f, -0.06273015f, -0.07863598f, -0.02334937f, 0.07503575f, -0.18597481f, 
    -0.15790302f, 0.03501408f, -0.03067551f, 0.01531068f, -0.04678043f, 0.04410098f, 0.02013264f, 0.09957313f, 
    0.04796240f, -0.14528079f, -0.04287296f, 0.09008002f, -0.04527858f, 0.08107042f, 0.00126038f, -0.02899304f, 
    0.31224403f, -0.12465257f, 0.10420665f, 0.02813089f, -0.20185636f, -0.00758960f, 0.03600586f, 0.01589141f, 
    -0.05294287f, -0.06299221f, -0.01485591f, -0.04116239f, 0.05354412f, 0.01898842f, -0.04459805f, 0.00493531f, 
    -0.00340826f, -0.02742741f, 0.04155018f, 0.01362088f, 0.11616151f, 0.07315923f, 0.07544364f, 0.06244280f, 
    0.04991852f, -0.02975269f, -0.06153189f, -0.01652489f, 0.02441087f, 0.02524282f, 0.04356563f, -0.00146811f, 
    0.02455888f, 0.01956395f, -0.00245344f, 0.03825689f, -0.09195054f, -0.07476017f, 0.00619925f, -0.03048475f, 
    -0.39281762f, 0.12073225f, 0.13625573f, -0.06342944f, 0.04282862f, -0.12198766f, 0.03711818f, -0.07914123f, 
    -0.02767332f, -0.03706106f, -0.00825476f, -0.06062461f, 0.02319971f, -0.07842462f, 0.10257688f, -0.02762498f, 
    0.03552752f, -0.06696066f, 0.04762089f, 0.08232760f, 0.16396341f, -0.05804040f, 0.04256532f, -0.02957458f, 
    -0.08155006f, -0.04822132f, 0.01016472f, -0.00227551f, 0.01564929f, 0.02494315f, 0.01629803f, -0.05925051f, 
    -0.01151616f, -0.04350157f, -0.05127732f, 0.03172494f, 0.02117218f, 0.01735733f, 0.05100645f, -0.02833190f, 
    0.24781610f, -0.05977224f, 0.00058034f, 0.09556293f, 0.13959089f, -0.13286340f, 0.03590665f, -0.09528495f, 
    0.01037512f, 0.03757565f, 0.06414978f, -0.00948338f, -0.01679887f, 0.00335805f, -0.04417422f, 0.05393267f, 
    -0.03574164f, 0.03705122f, 0.09691477f, 0.04302613f, -0.05235111f, -0.02086182f, 0.08305653f, -0.03287417f, 
    -0.00356686f, 0.00280584f, -0.01864866f, 0.04873673f, 0.04714917f, -0.01362942f, 0.00300056f, 0.02871745f, 
    0.00358264f, 0.01761443f, -0.03332857f, -0.04393451f, -0.06819528f, 0.03384881f, -0.03286574f, -0.04162429f, 
    -0.03730617f, -0.13238278f, -0.27401146f, 0.09907465f, -0.16975068f, -0.00503372f, -0.00469869f, 0.04371030f, 
    0.02793835f, 0.08271403f, 0.02982435f, -0.01785618f, 0.01467812f, 0.00975693f, 0.02381266f, -0.03153503f, 
    -0.01099089f, 0.00473267f, 0.00726453f, -0.03561527f, -0.19286196f, 0.05755089f, -0.06635548f, -0.07469450f, 
    0.04060737f, 0.03935868f, 0.01258374f, 0.03843452f, 0.01926005f, -0.06040373f, -0.02242382f, 0.03088633f, 
    0.03281286f, -0.01944360f, -0.00536981f, -0.08829156f, -0.00195479f, 0.00820233f, -0.06731524f, -0.01859703f, 
    0.09650068f, -0.15637946f, -0.10437287f, -0.07255745f, -0.09727505f, -0.07446200f, -0.02733463f, -0.01723032f, 
    0.05998034f, -0.04820411f, 0.03258350f, 0.05761613f, 0.04346170f, -0.01655667f, -0.04567253f, 0.03089879f, 
    -0.01141956f, -0.10696106f, -0.00334889f, -0.02667677f, 0.17276955f, -0.13210712f, 0.04983614f, -0.13335797f, 
    0.00516972f, 0.03632525f, -0.02243461f, 0.10798770f, -0.00452633f, 0.04745646f, -0.05081581f, 0.02334487f, 
    0.05136476f, -0.02885780f, -0.01394435f, -0.03235000f, -0.02725214f, 0.01224495f, -0.10082192f, -0.06360805f, 
    0.15563166f, 0.06923658f, -0.06557883f, 0.03308038f, -0.13468659f, -0.05248793f, 0.12453187f, -0.03071448f, 
    0.02181713f, -0.03884561f, -0.01276996f, -0.09655443f, -0.03870454f, -0.08721347f, -0.04207324f, 0.03817387f, 
    0.07220339f, 0.02605489f, 0.04765172f, -0.06213700f, -0.06871966f, -0.18666224f, 0.10638280f, -0.08064593f, 
    -0.00249832f, -0.08163909f, -0.03985066f, -0.02899966f, 0.00769217f, 0.08926849f, -0.03110354f, -0.03756838f, 
    -0.04336020f, 0.01400852f, -0.03474328f, -0.00279127f, -0.06340315f, 0.00144064f, -0.05906325f, -0.00391975f, 
    -0.00799235f, 0.01524908f, 0.05689914f, -0.09195720f, 0.02380323f, 0.03271892f, -0.02088684f, 0.05897249f, 
    0.02830150f, -0.03713064f, -0.04898020f, 0.02928434f, 0.00513376f, 0.04001028f, -0.01651641f, -0.03897468f, 
    -0.03826037f, -0.06075955f, -0.03198733f, -0.04173898f, 0.20388575f, -0.00193286f, 0.08537683f, 0.03565610f, 
    0.20046230f, -0.14205354f, -0.07751299f, 0.03186704f, 0.05785158f, 0.04675072f, 0.06509959f, 0.05223602f, 
    -0.02753740f, -0.07478883f, 0.00902084f, -0.03573992f, -0.08899552f, -0.04820072f, 0.03727014f, 0.02337631f, 
    -0.20805989f, -0.04469062f, -0.06752518f, -0.14083894f, -0.20319434f, 0.08580175f, 0.01329245f, -0.07474141f, 
    0.01581149f, -0.02396462f, 0.02386623f, 0.02621425f, -0.04142653f, -0.08097038f, -0.00994569f, -0.05876014f, 
    -0.00165536f, 0.02441012f, 0.01142970f, -0.02810550f, 0.18102872f, -0.03113447f, 0.02672252f, -0.15005606f, 
    -0.00042469f, 0.01424577f, -0.02917695f, 0.11523659f, 0.01389323f, 0.06476402f, -0.00311080f, 0.03642775f, 
    0.08690708f, -0.04413113f, -0.04616294f, 0.05216591f, -0.07230815f, 0.05841428f, 0.01461663f, -0.03494498f, 
    0.28247872f, -0.22495589f, 0.00973008f, -0.02413837f, 0.04671976f, -0.04224879f, 0.02294391f, -0.02815230f, 
    -0.00443195f, 0.01476770f, 0.02523092f, -0.02223809f, -0.00914203f, -0.05754019f, 0.09897428f, 0.01509275f, 
    -0.09490968f, -0.00082369f, 0.03293945f, -0.05443337f, 0.01237830f, -0.03680003f, -0.05992495f, 0.00344635f, 
    -0.01319352f, 0.00026855f, 0.06449132f, 0.01353420f, -0.00048031f, -0.07366783f, -0.02193072f, -0.05136143f, 
    -0.00387124f, 0.03031520f, 0.00371739f, 0.04858037f, 0.02786232f, -0.02766532f, 0.04096626f, -0.05407595f, 
    0.22301938f, -0.01655676f, 0.02802733f, 0.19583815f, 0.15012152f, -0.13184378f, -0.10222146f, -0.16774255f, 
    0.00398973f, 0.03166532f, 0.04273877f, -0.01655825f, -0.07232645f, 0.03456543f, 0.02162887f, -0.03352817f, 
    -0.00141698f, -0.02495665f, -0.03312154f, 0.01993507f, 0.12674659f, 0.03981549f, 0.02925396f, 0.02370433f, 
    0.10745781f, -0.02820833f, 0.01303108f, 0.02594044f, 0.01585800f, 0.00220092f, 0.06369442f, 0.02558259f, 
    0.08610677f, -0.00202044f, 0.10753703f, -0.01507065f, 0.04039636f, -0.01842024f, 0.00436982f, -0.03674281f, 
    0.13637574f, -0.03257076f, -0.14487500f, -0.01179890f, -0.09536400f, -0.02099895f, -0.01346589f, 0.05092114f, 
    -0.03817708f, -0.02630892f, -0.07406963f, -0.00247257f, -0.05637733f, -0.04876029f, -0.01127484f, -0.03383275f, 
    -0.01898363f, -0.04664401f, -0.00127236f, -0.05480846f, 0.05857078f, -0.15487382f, -0.04001498f, -0.02331369f, 
    -0.08660917f, 0.02210233f, 0.04254375f, 0.06647033f, -0.08012405f, -0.00256123f, -0.05293962f, 0.03070604f, 
    -0.01653304f, -0.02364921f, -0.07075519f, -0.01131995f, 0.01710798f, 0.00295992f, -0.01658710f, 0.03618554f, 
    0.15220815f, 0.07468373f, 0.02119224f, -0.05153166f, 0.07441476f, 0.03003116f, -0.01510833f, -0.01332213f, 
    0.01283486f, 0.06596621f, -0.00238579f, 0.00641446f, 0.01540301f, -0.01305790f, 0.03069272f, 0.00378888f, 
    -0.05567881f, 0.01295472f, -0.04216047f, -0.02192914f, -0.22801985f, 0.20685524f, -0.07204099f, -0.23271573f, 
    0.05348556f, 0.04635856f, -0.01193416f, 0.06093036f, 0.04227893f, -0.03344580f, -0.04309957f, 0.02415950f, 
    -0.07074266f, -0.02801060f, -0.00359339f, -0.01311959f, 0.03691131f, 0.04909967f, 0.08960426f, 0.01668443f, 
    -0.03534567f, 0.09110609f, -0.09135039f, -0.04889195f, -0.01331310f, 0.01382100f, 0.05980512f, 0.02517812f, 
    0.00629199f, -0.02602495f, -0.02545292f, 0.00985248f, -0.02433551f, -0.04540380f, 0.01628698f, -0.02665646f, 
    -0.02760300f, -0.05827483f, -0.05759403f, -0.02478745f, -0.28598592f, 0.02698453f, -0.03955998f, -0.07393938f, 
    0.03948460f, 0.03011646f, 0.07955063f, -0.03506369f, 0.03514235f, -0.07544772f, 0.01914642f, 0.02955108f, 
    0.02994705f, 0.00899846f, -0.02484886f, 0.01095081f, 0.00675787f, -0.05169950f, 0.01464763f, -0.04301354f, 
    -0.36380997f, 0.08556571f, 0.01328156f, -0.13552511f, 0.02557108f, 0.01911782f, 0.02255246f, -0.00842130f, 
    0.08421657f, 0.01852745f, 0.04900991f, -0.02350826f, 0.05077881f, -0.05552588f, 0.01939237f, 0.01302570f, 
    0.02401755f, -0.10136040f, 0.00171264f, 0.03822967f, 0.02425232f, -0.17514499f, -0.13949737f, -0.05266204f, 
    -0.05202609f, -0.05716994f, -0.01990331f, -0.05980249f, 0.03999599f, -0.03625598f, 0.03277639f, -0.03851767f, 
    0.05733803f, 0.06437375f, 0.03234360f, 0.00034754f, -0.02508018f, 0.05410115f, 0.02547556f, -0.04592772f, 
    -0.05900940f, 0.05764570f, 0.05639467f, 0.00404195f, -0.05283303f, -0.05795348f, -0.07105539f, -0.02547544f, 
    0.02970866f, -0.01625371f, -0.02586764f, -0.01587772f, 0.01629994f, -0.00353302f, 0.02799230f, -0.00460399f, 
    -0.01382376f, -0.02495285f, 0.00653572f, 0.05485799f, 0.18710740f, 0.04336231f, 0.12405824f, 0.20732994f, 
    0.10816640f, -0.06941545f, -0.08533607f, -0.07200430f, 0.00918664f, 0.08981279f, 0.04425281f, 0.03043104f, 
    0.03947381f, 0.04348541f, -0.01204664f, 0.00224123f, -0.06863405f, -0.10293508f, -0.00501788f, 0.03591397f, 
    -0.39434543f, 0.05340340f, -0.05475066f, -0.10552158f, -0.09052870f, 0.04964192f, 0.02379610f, -0.05548203f, 
    -0.01541667f, 0.03669252f, -0.05149109f, -0.05238701f, -0.02690414f, -0.02562409f, 0.00383537f, -0.02937852f, 
    0.04339635f, 0.02912185f, -0.04815534f, 0.00850349f, 0.11704114f, 0.02158529f, -0.00099759f, -0.00187264f, 
    -0.10088849f, -0.02171575f, -0.03031476f, 0.07539411f, 0.01195788f, -0.02408199f, 0.03495338f, -0.04155647f, 
    0.01386067f, -0.02025287f, -0.03315338f, 0.04171748f, 0.00489263f, -0.02592432f, -0.00194912f, 0.02508369f, 
    0.16048367f, 0.06677432f, 0.11177190f, 0.13334544f, 0.15116775f, -0.07681762f, -0.08201586f, -0.10403831f, 
    0.04220703f, 0.02353610f, 0.06276755f, -0.00033799f, -0.04087446f, -0.00034983f, -0.05224624f, -0.02887188f, 
    -0.05074227f, -0.00801828f, -0.02682835f, 0.00872832f, 0.19370334f, -0.05287553f, 0.07536525f, 0.02046175f, 
    -0.03989833f, -0.02797482f, -0.01195799f, -0.01772887f, -0.00460068f, 0.04615571f, -0.00292702f, 0.01392149f, 
    0.03837012f, 0.05830205f, 0.00366934f, 0.00927258f, -0.05446872f, 0.01557028f, 0.04291097f, -0.00035758f, 
    0.15622799f, -0.17686720f, -0.00672393f, -0.06690606f, -0.08323715f, -0.07349782f, -0.00374721f, -0.08666025f, 
    0.01546900f, 0.00008783f, 0.00757792f, -0.01090079f, -0.01549367f, -0.00979774f, 0.00918140f, -0.06347379f, 
    0.02086165f, 0.08427686f, -0.00867023f, -0.04960473f, 0.17189968f, -0.08040117f, -0.12316900f, -0.06905975f, 
    0.04706287f, -0.08762645f, -0.05097941f, 0.02867722f, -0.01499632f, 0.00353344f, 0.02420082f, 0.03759124f, 
    -0.02374876f, 0.00300228f, -0.03819336f, 0.02246374f, 0.00248922f, 0.01268246f, -0.01435858f, -0.02012127f, 
    0.16918397f, 0.10782512f, 0.03018417f, -0.14902204f, 0.10088700f, -0.02332144f, -0.01390666f, 0.03645122f, 
    -0.03769057f, -0.00891150f, 0.01460490f, -0.12859631f, 0.05343303f, -0.05930464f, -0.02302456f, 0.00452476f, 
    -0.03605450f, -0.06249974f, -0.09583282f, -0.10294817f, 0.20290537f, -0.04023010f, -0.10460094f, 0.05633239f, 
    -0.07493840f, -0.02390078f, 0.01375154f, 0.01366036f, 0.03054060f, -0.04419836f, -0.04578253f, -0.02739648f, 
    0.00060925f, 0.00954181f, -0.04342046f, 0.05824784f, 0.03573608f, -0.07043011f, 0.04084647f, -0.03136052f, 
    0.19219038f, -0.11389016f, 0.02018439f, -0.04248669f, -0.07980929f, 0.01911250f, -0.01641847f, 0.03959449f, 
    -0.06000321f, 0.08115990f, -0.00053699f, -0.00325895f, 0.04066065f, 0.04962035f, -0.03787364f, -0.01411270f, 
    -0.08699051f, 0.01518829f, -0.01929335f, -0.05605093f, 0.10711770f, -0.11957432f, 0.00833916f, -0.17650276f, 
    0.02405049f, 0.04690002f, 0.01309701f, 0.06533664f, -0.00626325f, 0.03309662f, -0.07355762f, 0.04433756f, 
    -0.00320570f, -0.08521244f, -0.04316394f, -0.00199639f, -0.07429906f, 0.00401725f, -0.14226088f, -0.08778241f, 
    -0.09676050f, 0.08566881f, 0.05809996f, -0.14784266f, 0.00781221f, 0.04829649f, 0.07137658f, 0.10762534f, 
    -0.01182544f, -0.03820321f, -0.03163306f, 0.08976094f, 0.02189101f, -0.07383157f, 0.00267609f, 0.05094493f, 
    -0.01607314f, 0.01227817f, -0.01883718f, -0.01795532f, 0.19623531f, -0.08304136f, 0.11790048f, -0.06939589f, 
    0.02543757f, 0.03430435f, -0.01217957f, -0.07904376f, 0.06215034f, 0.05982517f, 0.00269375f, -0.02940445f, 
    0.01595395f, 0.04847175f, -0.01212533f, 0.01414297f, -0.08049966f, 0.01803230f, 0.02039325f, -0.02224072f, 
    0.03083262f, -0.15057828f, -0.04532745f, 0.05321074f, -0.12136130f, -0.03070982f, -0.02285761f, -0.08383223f, 
    -0.02775591f, 0.01773700f, -0.02665455f, -0.02043352f, 0.00798770f, 0.00574401f, -0.00842669f, -0.04598626f, 
    0.01613289f, 0.05043056f, -0.00887031f, 0.03623238f, -0.13723129f, 0.17095484f, -0.02718922f, -0.13792361f, 
    0.15101799f, 0.01945738f, 0.12538758f, 0.07436787f, 0.06510694f, -0.10498832f, 0.02778993f, 0.01635038f, 
    -0.01795661f, 0.00497688f, 0.02089937f, 0.03887419f, 0.01823741f, -0.04938871f, 0.04490083f, 0.02256132f, 
    0.25774783f, -0.08409457f, -0.17604017f, -0.09119169f, -0.03600585f, -0.00646850f, 0.00927548f, 0.00993295f, 
    -0.02678647f, 0.00580989f, -0.01317143f, 0.00767342f, 0.03705737f, -0.03931428f, 0.06131558f, 0.04359041f, 
    -0.04933035f, -0.07922805f, 0.02867440f, -0.00985926f, 0.06248667f, -0.13697778f, -0.01243281f, 0.07598567f, 
    -0.24612579f, -0.06575428f, 0.01680415f, -0.02314001f, -0.01422833f, -0.06854042f, 0.01719081f, 0.05890882f, 
    0.03413121f, 0.01512788f, -0.02565844f, 0.04255722f, -0.04887479f, 0.01629036f, 0.00896192f, -0.03982393f, 
    -0.32965481f, -0.29177609f, -0.00451946f, -0.13152798f, -0.14819795f, 0.04172054f, -0.08681406f, -0.08046196f, 
    0.00587042f, -0.00931739f, 0.01802786f, 0.06365846f, -0.07650188f, -0.01230981f, 0.03542852f, -0.06248596f, 
    -0.02208305f, 0.08158727f, -0.02122160f, 0.00584611f, 0.14612633f, 0.03350595f, 0.04413753f, 0.11047916f, 
    -0.13082768f, -0.12674746f, 0.04365145f, 0.00931871f, -0.04953461f, -0.00954391f, -0.01423509f, -0.01055742f, 
    0.02840496f, -0.07525973f, -0.02336874f, 0.09385642f, -0.11193624f, -0.00119731f, 0.14608216f, -0.05213716f, 
    0.17572019f, -0.05690996f, -0.09441733f, 0.18524680f, -0.03172451f, -0.12950434f, 0.06730542f, -0.04209807f, 
    -0.04776371f, 0.06284468f, 0.03137448f, -0.00732125f, 0.03330495f, -0.02661741f, -0.05057589f, 0.00352682f, 
    -0.05709628f, -0.02663923f, 0.06135458f, 0.06994569f, -0.03162952f, 0.03906566f, 0.03721082f, -0.13232478f, 
    -0.13436964f, -0.01113173f, -0.04075180f, 0.11869274f, -0.00825802f, 0.04599138f, -0.00097123f, 0.01448853f, 
    0.01335737f, -0.10507119f, -0.00084520f, 0.04880046f, -0.04774708f, 0.00625337f, 0.04622529f, -0.04668982f, 
    0.24780884f, 0.05382368f, -0.28243446f, -0.11997635f, -0.17504326f, 0.02277320f, 0.11008610f, 0.00205262f, 
    -0.11733533f, -0.04456577f, -0.05142245f, -0.00891528f, 0.05076970f, -0.02885638f, 0.03820964f, -0.01969827f, 
    0.05296536f, -0.06581441f, -0.00725760f, 0.03076379f, 0.13081257f, 0.20091170f, -0.01861992f, 0.00589986f, 
    -0.03681218f, 0.00713576f, 0.05397869f, 0.06022041f, -0.02401054f, -0.03311032f, -0.17064132f, -0.00345322f, 
    -0.04900659f, 0.10336813f, -0.01332892f, -0.00338718f, -0.05032074f, 0.07554842f, 0.03193096f, -0.01381225f, 
    -0.06039012f, -0.03519878f, 0.04695467f, -0.08422478f, 0.04120079f, 0.05742430f, 0.07990015f, -0.00462321f, 
    0.01987025f, -0.00816247f, -0.01502250f, 0.03342964f, -0.02779607f, -0.03469859f, -0.02970702f, -0.03553791f, 
    0.00781463f, -0.00630729f, -0.09911520f, 0.00878494f, 0.04854991f, 0.06395081f, -0.07215387f, 0.02198145f, 
    -0.05116269f, 0.05077415f, 0.07607888f, 0.02437314f, -0.05999553f, -0.01908451f, -0.06501884f, -0.04782078f, 
    -0.01627185f, -0.08308363f, 0.00120484f, 0.04878789f, 0.05428287f, 0.02278793f, -0.00606669f, 0.04389208f, 
    0.18608679f, 0.01295176f, -0.04189972f, 0.08232897f, -0.21251492f, -0.01397598f, -0.05428186f, 0.00293769f, 
    0.00843716f, 0.07113219f, -0.02341918f, -0.02597579f, -0.02764707f, 0.02718941f, -0.00668609f, -0.01421861f, 
    -0.03816369f, -0.02710356f, 0.04462425f, 0.02010764f, -0.33134875f, 0.08367794f, 0.09623694f, -0.09573967f, 
    0.01685977f, -0.00489471f, 0.00990464f, -0.02843899f, 0.04448235f, 0.03896240f, -0.05288659f, 0.00047751f, 
    0.04993977f, -0.00033025f, 0.05152690f, 0.00892066f, 0.03026262f, -0.02823381f, 0.02378915f, 0.07180430f, 
    0.10868295f, -0.17109905f, -0.07869114f, -0.11009701f, -0.22066888f, -0.00750482f, 0.02299661f, -0.01013913f, 
    -0.03302729f, -0.01701939f, 0.03812902f, -0.03073936f, -0.01861813f, -0.00688628f, -0.04849809f, -0.02360425f, 
    -0.00321101f, 0.06505737f, 0.04343601f, -0.03971146f, -0.20443401f, -0.10019436f, 0.00585696f, -0.07178429f, 
    0.02204812f, 0.05075048f, 0.09635193f, 0.04691848f, 0.05473929f, -0.02001453f, -0.01541880f, -0.00449746f, 
    -0.05995087f, -0.03778312f, 0.00359485f, -0.03943225f, -0.00041542f, 0.05836705f, -0.06323100f, -0.04233368f, 
    -0.00119041f, -0.00228255f, -0.02219231f, -0.12254143f, -0.04162298f, 0.01501046f, -0.05135822f, 0.07087438f, 
    0.03167173f, 0.04174185f, -0.02502003f, 0.02808873f, 0.00402463f, -0.05055670f, -0.00897072f, 0.00497806f, 
    -0.03643779f, 0.05619986f, -0.05193863f, -0.00522561f, 0.09220912f, -0.21454307f, 0.18015228f, -0.09635729f, 
    -0.06027709f, -0.07303942f, -0.08993770f, -0.03131022f, -0.01942082f, 0.03045685f, -0.03998443f, -0.06999546f, 
    0.03929444f, 0.04930590f, -0.01277116f, 0.06752719f, -0.09699092f, 0.06278607f, 0.05153095f, -0.01860829f, 
    0.12937726f, 0.05551717f, 0.00456277f, -0.01429973f, 0.07210649f, -0.09289750f, -0.04726472f, -0.04354902f, 
    0.01897900f, 0.04343142f, -0.03216103f, 0.02118642f, -0.03006638f, -0.00509584f, 0.03463196f, -0.04685114f, 
    0.00283885f, -0.09537559f, 0.01527276f, -0.00556218f, 0.15700102f, -0.23652765f, 0.01565044f, -0.06754139f, 
    -0.30988216f, 0.01694605f, 0.01908108f, -0.02807155f, -0.00383429f, 0.00377799f, -0.01057558f, 0.03872235f, 
    0.00922753f, -0.02643474f, -0.03971183f, -0.00922309f, 0.01430368f, 0.00218315f, 0.08111511f, -0.01532394f, 
    -0.18116198f, 0.16804326f, 0.05255173f, 0.09297535f, -0.05141044f, 0.01139789f, 0.02061352f, 0.01336550f, 
    0.00016768f, 0.00335458f, -0.05552626f, -0.01210858f, 0.02962182f, -0.05716287f, -0.07880934f, -0.01817964f, 
    0.01113023f, -0.00105434f, 0.00754971f, 0.01893684f, 0.15084106f, 0.13021892f, 0.00490522f, 0.09411202f, 
    -0.01340150f, 0.04307935f, 0.07585052f, -0.01115505f, -0.07989493f, 0.03021056f, -0.03810451f, -0.02904780f, 
    0.02429761f, -0.08557117f, 0.00747030f, -0.02972853f, -0.03502308f, 0.09422069f, -0.08699164f, -0.01105957f, 
    -0.03100482f, 0.01158401f, 0.04262740f, -0.02080966f, 0.05173977f, -0.00295040f, -0.03913555f, 0.04427819f, 
    -0.04684683f, -0.04628465f, 0.01568513f, -0.00219251f, -0.03732655f, -0.05113139f, 0.03665128f, 0.02422069f, 
    0.07791520f, 0.00672387f, -0.02496956f, -0.03364196f, -0.00966481f, -0.10968928f, 0.00629440f, 0.00495648f, 
    -0.16303882f, -0.00925718f, -0.05908608f, 0.00373739f, -0.04525777f, 0.00633879f, -0.06932007f, 0.05861450f, 
    0.01537141f, 0.04803126f, -0.02850275f, -0.01320167f, -0.00603835f, -0.04287946f, -0.00378103f, 0.02674043f, 
    0.17828351f, -0.00666435f, -0.18999340f, -0.04634864f, -0.13724644f, -0.00448304f, 0.10484339f, 0.00144440f, 
    -0.06050851f, -0.02917843f, 0.02367640f, 0.05564632f, 0.03816188f, 0.00202779f, 0.01080587f, 0.03710121f, 
    -0.03958911f, -0.02308544f, 0.00965060f, -0.00927087f, -0.12100981f, 0.12679113f, 0.05344732f, 0.08086477f, 
    0.00615973f, -0.05123226f, 0.01981851f, -0.00180111f, -0.00300423f, 0.00258072f, 0.00328060f, 0.03170605f, 
    -0.01893315f, -0.02944415f, -0.03174696f, -0.02839803f, -0.00508073f, -0.01139229f, 0.02322799f, 0.00338837f, 
    0.15788811f, -0.03361763f, 0.03903729f, 0.00761965f, -0.03749878f, -0.08001012f, -0.11242032f, -0.06057012f, 
    -0.04505657f, -0.04932768f, -0.04573309f, 0.02973855f, -0.04216740f, -0.01909212f, 0.03209609f, 0.01865042f, 
    0.04875702f, 0.02219315f, 0.01986801f, 0.01546636f, -0.38123319f, -0.29638332f, -0.14638962f, 0.00427951f, 
    -0.09930509f, -0.04970665f, -0.04250153f, -0.01847655f, 0.06543828f, -0.09795135f, -0.01398225f, -0.05226449f, 
    -0.00216792f, 0.01613427f, -0.02245380f, 0.05914194f, 0.03081554f, -0.03058980f, -0.11287905f, -0.00623635f, 
    0.10413076f, -0.06826894f, -0.00639998f, 0.04749270f, 0.02367720f, -0.09346197f, 0.02939922f, 0.05122088f, 
    -0.06475519f, 0.07434383f, -0.05818847f, 0.02869539f, -0.02356495f, -0.01562753f, -0.01639515f, 0.02242522f, 
    -0.00460685f, 0.02624159f, 0.01829675f, 0.05719164f, -0.13517316f, -0.43166339f, -0.17027332f, 0.07407112f, 
    0.18369687f, -0.05134938f, 0.08750217f, 0.04220157f, -0.04514227f, -0.04870072f, -0.02149601f, 0.00544936f, 
    -0.03374965f, 0.06172047f, 0.02786200f, 0.01867724f, 0.00342422f, 0.00726682f, 0.00524607f, -0.03747130f, 
    0.04380900f, 0.12876147f, 0.21879464f, 0.09429176f, 0.09189688f, -0.08573680f, -0.05472426f, 0.02666363f, 
    -0.01053738f, 0.00351981f, -0.00544067f, -0.01902554f, 0.00515163f, 0.08592756f, -0.05273303f, -0.03282788f, 
    0.00344325f, -0.02134301f, 0.03210252f, -0.03194269f, -0.18488239f, -0.17263941f, -0.25096235f, -0.09118523f, 
    -0.05404976f, -0.13246320f, -0.01950946f, -0.05860952f, -0.00461412f, 0.03578903f, -0.07752667f, -0.01709209f, 
    0.04178410f, 0.01201031f, 0.00675123f, -0.01625990f, -0.01437521f, -0.06086721f, 0.03403331f, 0.04499517f, 
    -0.12690890f, 0.16571200f, 0.07468303f, 0.16728806f, 0.09610871f, 0.00710520f, 0.01788339f, 0.01258033f, 
    -0.02711242f, -0.02368592f, -0.02903539f, 0.01014861f, -0.01164094f, -0.03281783f, -0.08283540f, 0.02730847f, 
    -0.00396977f, -0.03981565f, -0.00192638f, -0.04670386f, 0.01948072f, 0.08333525f, 0.01432883f, 0.03353728f, 
    -0.08235687f, -0.00055520f, 0.04026128f, 0.02445920f, -0.05053409f, -0.03684368f, -0.06194867f, 0.05212897f, 
    -0.00752392f, 0.02507808f, -0.00947587f, 0.04085332f, -0.06754144f, 0.02533787f, -0.05185167f, -0.03050851f, 
    -0.33635509f, -0.41720396f, -0.01453507f, -0.12054943f, -0.16479221f, -0.09995051f, -0.07104178f, -0.04111710f, 
    0.04121709f, -0.08387900f, -0.05723835f, -0.04250177f, 0.06407621f, 0.03296323f, 0.03323655f, 0.09755306f, 
    -0.00910713f, -0.02228832f, -0.02219233f, 0.03785592f, 0.02836511f, -0.13149002f, 0.09832714f, -0.12291481f, 
    -0.11618625f, -0.08609881f, -0.17579642f, -0.03538493f, 0.03397255f, -0.02760276f, -0.03266623f, -0.08283241f, 
    0.00709493f, -0.05237619f, 0.06170956f, 0.02652342f, 0.05938450f, -0.01686404f, 0.04899902f, 0.05600925f, 
    0.19602217f, 0.17425516f, 0.04845176f, 0.09910324f, -0.03050083f, 0.01258458f, 0.05539089f, -0.03254461f, 
    0.01481152f, -0.03950961f, -0.03329858f, 0.01539600f, 0.00269916f, 0.03635084f, -0.01735311f, 0.01823435f, 
    -0.00595466f, 0.09703844f, 0.02967455f, 0.07618102f, -0.01747026f, -0.27974623f, -0.24952997f, -0.01868508f, 
    0.11279152f, -0.12805389f, -0.06688116f, -0.00521533f, 0.05966468f, 0.02132731f, -0.02476504f, 0.02333852f, 
    -0.00803668f, -0.00603118f, 0.10068842f, -0.01405220f, 0.01649415f, -0.09736095f, -0.05895250f, -0.02546919f, 
    0.01638310f, -0.05479866f, -0.02814961f, 0.01080350f, 0.00667693f, 0.00208899f, -0.07416390f, -0.04684578f, 
    0.10116228f, -0.03883283f, 0.02804947f, -0.01351847f, 0.06000553f, -0.02393167f, -0.03262372f, -0.04131444f, 
    -0.00964104f, -0.04082785f, 0.02635149f, 0.01418876f, -0.15203999f, 0.14443907f, 0.00757983f, 0.14727856f, 
    0.07757673f, 0.01217977f, 0.06079304f, -0.00807510f, 0.03670387f, 0.04369114f, -0.02679521f, 0.07476117f, 
    0.02420895f, -0.07664570f, 0.05271358f, -0.02009781f, 0.07134678f, -0.02309928f, 0.06385589f, -0.02373999f, 
    0.08155833f, -0.09436622f, -0.08399174f, -0.03529245f, -0.08111826f, -0.10010810f, -0.13402656f, 0.05207389f, 
    -0.06139580f, 0.02977232f, -0.08925377f, -0.06436593f, 0.07057180f, -0.09431768f, 0.05087367f, -0.01869157f, 
    -0.01314798f, 0.04911545f, 0.01960005f, 0.03137383f, -0.15265355f, -0.11511099f, -0.01064886f, -0.05200118f, 
    -0.04959004f, -0.04441962f, -0.02091885f, 0.03598339f, 0.05432412f, -0.04128796f, 0.02209151f, -0.00364478f, 
    0.00277625f, 0.02189725f, -0.05750182f, 0.02506822f, 0.06071487f, 0.02667594f, -0.03030654f, 0.00211281f, 
    0.16017967f, 0.18436840f, -0.00874078f, 0.05088109f, 0.02760200f, 0.07553977f, -0.01138650f, -0.05070447f, 
    0.03177234f, 0.01879893f, 0.03642840f, -0.00135969f, 0.03340497f, -0.01609755f, -0.01324550f, -0.01708625f, 
    0.06456766f, -0.01875910f, 0.04030013f, -0.00957276f, 0.31168675f, 0.06927112f, -0.14476903f, 0.09042922f, 
    0.09193736f, 0.04310713f, 0.01414238f, -0.00277815f, 0.03468609f, -0.01239511f, -0.07138273f, 0.01505974f, 
    -0.07393748f, -0.02360484f, 0.02729770f, 0.02143267f, 0.01790853f, 0.01919010f, 0.03713484f, -0.06712773f, 
    0.01540211f, 0.19269092f, -0.07741263f, -0.03463367f, -0.08633883f, -0.00759150f, -0.02796237f, -0.04622661f, 
    0.02464149f, 0.02203184f, -0.00400331f, -0.05516597f, -0.05915785f, -0.02068618f, -0.03535705f, -0.01493915f, 
    0.00088481f, -0.04277368f, 0.01957998f, 0.04870925f, -0.08872695f, 0.05107369f, 0.06619584f, 0.00412175f, 
    0.12061223f, 0.01820073f, 0.09155694f, -0.00271407f, 0.06287248f, 0.05258911f, 0.07956282f, -0.00012532f, 
    -0.02996954f, 0.02164490f, -0.09134735f, 0.01653078f, -0.03574095f, 0.04304887f, 0.07308993f, 0.02771332f, 
    -0.40795165f, -0.03458446f, -0.15945031f, -0.03594123f, 0.08007088f, -0.01959826f, 0.02245357f, 0.00557206f, 
    -0.00632949f, -0.04260610f, -0.05092397f, -0.01540644f, 0.01852224f, 0.00940213f, 0.04741333f, 0.00970432f, 
    -0.02836548f, -0.03915105f, 0.01999578f, 0.02794956f, 0.04261833f, -0.03700778f, -0.07652023f, 0.12007786f, 
    0.11004756f, 0.10033208f, 0.09454171f, 0.01306677f, 0.00588777f, 0.05890341f, -0.05665982f, 0.03087671f, 
    0.00894354f, -0.05933488f, -0.01901536f, -0.06471058f, 0.01669120f, 0.05812569f, 0.08183752f, -0.05514456f, 
    -0.09349199f, -0.21639787f, -0.27708250f, -0.01514027f, -0.05775907f, -0.04278584f, -0.00595814f, -0.08227224f, 
    -0.00038621f, -0.03198828f, 0.03090622f, 0.04161319f, -0.00042818f, 0.00726296f, -0.01536970f, -0.01286163f, 
    -0.00122781f, -0.02477212f, 0.01116486f, 0.03980877f, -0.00100337f, 0.07663302f, 0.07464284f, 0.09951024f, 
    -0.07950739f, -0.09409345f, -0.10435633f, 0.02771334f, -0.02437585f, 0.03399738f, -0.01394549f, -0.00001185f, 
    0.01188462f, 0.01599783f, 0.01261177f, 0.06981815f, 0.01018270f, 0.09137404f, 0.03725907f, -0.04057068f, 
    0.11449811f, -0.02804174f, -0.01475696f, -0.00991914f, -0.04007334f, -0.08486612f, 0.02847422f, -0.00496718f, 
    -0.02029057f, -0.04010815f, -0.03018942f, 0.00523292f, 0.05803386f, 0.00856006f, 0.00072626f, 0.00808890f, 
    -0.00304357f, 0.00807349f, -0.07387826f, -0.02652589f, -0.01732939f, -0.12551495f, -0.02742746f, -0.09391391f, 
    -0.14669630f, -0.04653895f, -0.10715374f, 0.05459873f, -0.03921949f, -0.04787241f, -0.02350369f, 0.06333163f, 
    -0.06389649f, 0.02206951f, 0.02211396f, 0.06880175f, -0.01069035f, 0.07838765f, 0.05432395f, 0.04933115f, 
    0.10379206f, 0.12405795f, -0.02346665f, 0.11650537f, 0.09647027f, -0.01009567f, 0.11282278f, -0.02824624f, 
    0.03396929f, -0.03704784f, 0.01113492f, 0.05099313f, -0.11256811f, -0.01870990f, -0.02095373f, -0.00142556f, 
    0.07989689f, -0.01275118f, 0.04439473f, 0.04656857f, 0.07999067f, -0.03451017f, 0.05498772f, 0.08215576f, 
    0.03183950f, -0.00898673f, 0.00116356f, -0.01778083f, 0.01375894f, -0.04413996f, -0.02307139f, 0.03458512f, 
    -0.02039207f, 0.02860782f, 0.02179595f, 0.02954782f, -0.00964596f, -0.01365868f, -0.04082388f, -0.01472319f, 
    -0.00713676f, -0.04780464f, -0.01012906f, -0.01654087f, -0.11512183f, -0.01038321f, -0.07077020f, -0.00358760f, 
    -0.08871040f, 0.03397418f, -0.01974548f, 0.06862590f, 0.00001145f, -0.01408842f, 0.03287145f, 0.00423701f, 
    0.00755982f, -0.00326847f, 0.07042227f, 0.03012629f, -0.05630320f, -0.00744023f, -0.02997971f, 0.04148406f, 
    0.01913474f, 0.00584390f, -0.09283816f, 0.03697651f, 0.00993270f, 0.00335205f, 0.00196633f, 0.05937013f, 
    -0.05229087f, 0.06474461f, 0.04909271f, 0.06459565f, 0.00140708f, 0.00656117f, 0.04113373f, -0.04885514f, 
    0.05963165f, 0.08534200f, -0.02022448f, 0.04130042f, -0.04312658f, -0.09065250f, -0.03349586f, -0.06207838f, 
    -0.02071857f, -0.03855290f, -0.00197259f, -0.02091848f, 0.03578683f, 0.01986191f, 0.01678647f, 0.02198213f, 
    -0.06836532f, 0.05683547f, -0.01864286f, -0.03244221f, 0.04385403f, 0.10169180f, 0.08545145f, 0.06727003f, 
    -0.01283309f, -0.02245035f, -0.08786297f, -0.01983962f, 0.00437777f, -0.03043942f, 0.03002357f, -0.05754915f, 
    0.05321452f, 0.01443988f, 0.00512338f, -0.04312574f, 0.00800432f, 0.00768408f, 0.10787023f, 0.10004044f, 
    -0.34988725f, 0.35463420f, 0.00087141f, 0.00394520f, 0.04199300f, -0.05536613f, 0.01636916f, -0.02355208f, 
    -0.00036029f, -0.00639961f, -0.05479734f, -0.07277236f, -0.00923622f, 0.09914982f, 0.07363053f, 0.04778880f, 
    -0.01278837f, -0.13537498f, 0.08530089f, 0.08598807f, -0.18462275f, 0.20062062f, 0.09710731f, 0.04615286f, 
    0.05318852f, 0.06245114f, 0.01552418f, -0.00327843f, 0.03521589f, -0.03740619f, -0.02351602f, 0.01599783f, 
    0.00824518f, -0.02408896f, -0.02838441f, -0.05755368f, -0.01733559f, -0.05566579f, 0.06695556f, -0.02114884f, 
    0.25881827f, 0.06404374f, -0.11099230f, -0.02421757f, -0.04126737f, -0.08492777f, -0.03905885f, 0.02889995f, 
    0.05603296f, 0.09663699f, -0.07025556f, -0.06708816f, -0.06163179f, 0.08895692f, 0.03235810f, -0.02746919f, 
    -0.03433832f, -0.01306760f, 0.00668969f, 0.07518770f, 0.06200435f, -0.07982007f, -0.20951207f, 0.06878293f, 
    0.09802902f, -0.10281916f, -0.00664703f, -0.06708021f, 0.00120343f, 0.03616455f, -0.06182032f, -0.01939974f, 
    0.11754616f, 0.00242324f, -0.00054076f, -0.02390926f, 0.05299266f, -0.06498769f, -0.03700377f, 0.08052725f, 
    -0.06807042f, -0.36404833f, -0.27868369f, 0.12925492f, 0.15518811f, 0.03423909f, -0.05140289f, 0.05754043f, 
    0.02602093f, -0.04744494f, 0.01477279f, 0.02075542f, -0.12317915f, -0.09311608f, 0.02346708f, 0.00779342f, 
    -0.01177122f, 0.08162641f, -0.00621808f, -0.03791849f, 0.21850429f, 0.06972659f, -0.09158283f, 0.02847748f, 
    0.02170134f, 0.02327246f, -0.01889643f, -0.03626190f, 0.03959110f, -0.06519718f, -0.04753969f, -0.02957796f, 
    -0.03237044f, 0.08433234f, -0.00664878f, -0.02907111f, 0.03265931f, -0.02836405f, -0.01170372f, -0.03044461f, 
    0.14578877f, -0.00349393f, -0.12620229f, -0.00010592f, -0.08776002f, -0.07903033f, -0.02896551f, -0.01228650f, 
    -0.06865258f, -0.05187468f, -0.03502294f, -0.02404982f, 0.02191291f, -0.02008552f, 0.07442236f, -0.03718058f, 
    -0.00601645f, 0.04200117f, -0.04960855f, 0.07854748f, -0.50474590f, -0.12974866f, -0.35355705f, 0.07707711f, 
    -0.00020788f, -0.12263577f, -0.02024310f, 0.06297807f, 0.06411659f, -0.03609623f, -0.06353999f, -0.03826300f, 
    -0.03269875f, -0.15788519f, 0.01512465f, -0.05455814f, -0.07177674f, 0.04353092f, 0.00564064f, -0.08478004f, 
    -0.00121939f, 0.21851389f, 0.08324182f, 0.02533934f, -0.02873717f, 0.00143896f, 0.03830557f, -0.08641064f, 
    0.10142066f, 0.02180872f, 0.05232852f, 0.01797939f, -0.04046476f, 0.00397226f, -0.10096702f, -0.09774071f, 
    0.02400702f, -0.11282651f, 0.08313555f, -0.01261187f, 0.13585761f, 0.05316484f, 0.09405956f, 0.14851683f, 
    0.02637982f, -0.01305343f, 0.05550494f, -0.01779832f, -0.02405100f, -0.02841125f, -0.07266372f, 0.04248878f, 
    -0.07812101f, -0.05735382f, 0.02957709f, -0.03114314f, 0.05406392f, 0.03193061f, 0.07610088f, -0.04571494f, 
    0.06595809f, 0.08256948f, -0.10340581f, 0.00537067f, -0.09532028f, -0.07005929f, 0.01602880f, -0.07703757f, 
    0.02937996f, -0.04148666f, -0.10151438f, -0.02989939f, -0.03525598f, -0.00130510f, 0.02949227f, 0.04803290f, 
    -0.04422360f, 0.05789452f, -0.01054072f, -0.04255962f, 0.03353966f, -0.06099978f, 0.17083864f, -0.02960194f, 
    -0.02180432f, -0.03393583f, -0.04766294f, -0.01091938f, -0.15273000f, -0.11495352f, 0.00598847f, -0.08758538f, 
    0.03134698f, 0.02380809f, 0.05810314f, 0.00569341f, 0.09952330f, -0.12192962f, -0.03474595f, -0.01593926f, 
    -0.02788519f, -0.02905640f, 0.02747248f, -0.02869380f, -0.03251996f, -0.03194910f, -0.04798120f, 0.05408401f, 
    -0.08151415f, -0.01885894f, -0.05328357f, 0.02754141f, -0.05652341f, 0.01399860f, 0.01797963f, 0.00656376f, 
    0.04352058f, 0.09386236f, 0.04908265f, 0.01923500f, 0.14841259f, -0.08299387f, -0.02146529f, 0.06115109f, 
    0.00317671f, -0.04814515f, 0.02268449f, -0.00749566f, 0.01880480f, 0.03669809f, 0.10180209f, -0.03627879f, 
    -0.05135124f, -0.05191882f, 0.04699752f, -0.01620287f, -0.01978987f, -0.01482039f, -0.04978853f, 0.06515935f, 
    -0.37522194f, 0.35927147f, 0.06740814f, -0.06888125f, -0.00083485f, -0.00319638f, 0.06899926f, -0.05677994f, 
    0.10677361f, -0.04379736f, -0.05487074f, 0.02785724f, -0.03663646f, 0.01721036f, -0.10309369f, -0.03263211f, 
    0.05251746f, -0.08817659f, 0.09387716f, 0.02433044f, 0.37267843f, 0.12893896f, -0.08891132f, -0.00237941f, 
    -0.08365032f, -0.03645288f, -0.00748475f, -0.01018176f, 0.07996427f, -0.08338126f, 0.05390270f, -0.02417166f, 
    -0.09797603f, 0.04629628f, -0.09222449f, -0.01651140f, 0.01680056f, -0.05590704f, 0.03825544f, 0.00224196f, 
    -0.00617101f, -0.28866479f, -0.19803150f, 0.09285908f, 0.05847755f, 0.05401962f, 0.02488442f, 0.00515271f, 
    0.00504554f, -0.06831169f, -0.00121061f, -0.02554525f, -0.08969751f, -0.04483655f, -0.02515820f, 0.01128391f, 
    0.03652423f, 0.07174390f, -0.02445654f, -0.05585442f, 0.00063322f, 0.06220337f, -0.10036665f, 0.23373641f, 
    0.15579486f, 0.16524979f, 0.09273820f, 0.05220180f, -0.02123813f, 0.02409493f, -0.07409905f, -0.00624143f, 
    0.00458359f, -0.18584047f, -0.03995257f, 0.04360312f, -0.00128131f, 0.05796156f, 0.04321955f, -0.09030850f, 
    0.05866747f, -0.14332736f, -0.00072882f, 0.01244075f, -0.08620609f, -0.04966342f, -0.03313643f, -0.01620059f, 
    -0.02469614f, 0.06921771f, -0.00518183f, 0.01078557f, -0.01452879f, -0.00144091f, 0.00801903f, -0.02461235f, 
    0.01039731f, -0.00945452f, -0.03139854f, -0.00162337f, 0.06424709f, 0.01302942f, -0.28264159f, 0.10299839f, 
    -0.03037482f, -0.05691369f, 0.06355952f, 0.00975645f, 0.02343825f, -0.03263951f, -0.00794668f, 0.01898037f, 
    -0.06958648f, -0.02159850f, 0.01710940f, 0.00490631f, -0.05403029f, 0.06530098f, -0.03182886f, -0.03804373f, 
    0.08351472f, 0.15603270f, 0.14499944f, 0.10633362f, 0.06675097f, 0.01286960f, 0.00584464f, 0.02025104f, 
    -0.04369008f, 0.01565679f, 0.04055211f, -0.00529707f, -0.05384958f, -0.06177655f, -0.00677505f, 0.02338096f, 
    0.01712321f, 0.06085685f, 0.07924519f, 0.07369399f, -0.21754569f, -0.23885858f, -0.20493703f, 0.11986953f, 
    0.03717683f, -0.00326190f, 0.01287212f, -0.01002229f, 0.02829013f, -0.06514900f, 0.04127111f, -0.03346173f, 
    -0.10622320f, 0.02705992f, -0.04202528f, 0.03908952f, 0.05047311f, 0.08262762f, 0.06000718f, -0.02552889f, 
    0.09516273f, -0.11549083f, -0.29441321f, 0.01422708f, 0.12798905f, -0.07473461f, 0.07751638f, 0.02152154f, 
    0.01596967f, 0.01995331f, 0.06906784f, -0.01079601f, -0.00439215f, 0.02416689f, -0.02386124f, -0.08236089f, 
    0.00537659f, -0.00074963f, 0.01028397f, 0.00234744f, 0.06263983f, -0.02977009f, -0.02120704f, 0.02157269f, 
    -0.02907221f, -0.08835738f, -0.09249919f, 0.01948825f, -0.03317071f, 0.08736981f, -0.02267184f, -0.00123386f, 
    -0.02445682f, 0.10608679f, -0.01873078f, -0.04801372f, 0.08393796f, -0.00391139f, -0.02248662f, -0.06592686f, 
    -0.16347687f, -0.08365943f, -0.04769855f, -0.05150203f, -0.09118580f, -0.02314930f, -0.05293916f, 0.03276905f, 
    -0.00213872f, -0.02633744f, -0.05758347f, -0.06488352f, -0.03530049f, -0.01903744f, 0.04189074f, 0.03550590f, 
    0.03582429f, -0.02398261f, -0.00395726f, 0.00899045f, -0.19176492f, 0.13740624f, 0.13212867f, 0.09989092f, 
    0.03320819f, -0.03162870f, 0.00368489f, -0.01520802f, 0.02025262f, -0.00636826f, -0.07169998f, -0.03723465f, 
    0.03462436f, -0.06201654f, -0.02316900f, -0.03248446f, 0.04917100f, 0.06100998f, 0.09111279f, -0.03612175f, 
    -0.10038412f, -0.04747036f, 0.02204353f, 0.01062130f, -0.01144319f, 0.09144602f, 0.00342733f, -0.01966573f, 
    -0.05046816f, 0.01051479f, 0.06836994f, -0.04893862f, -0.00185024f, 0.02741921f, 0.01088952f, -0.04221321f, 
    -0.00139231f, 0.00214583f, 0.01352393f, -0.00274868f, -0.10381029f, -0.12963913f, -0.04774212f, 0.15759258f, 
    -0.09899735f, -0.00982065f, -0.02910138f, -0.03382651f, -0.04468189f, -0.09175426f, 0.04291379f, -0.08775105f, 
    0.00925624f, 0.05295763f, 0.12777483f, -0.13337058f, 0.01409919f, 0.07626379f, -0.02104813f, 0.05705008f, 
    -0.13421848f, 0.16440132f, -0.07756083f, -0.01148999f, -0.01267227f, 0.05646420f, 0.03806892f, 0.08100110f, 
    0.07053777f, 0.04372560f, -0.02372494f, 0.08791401f, 0.03891861f, -0.04454314f, -0.09221988f, -0.01955419f, 
    -0.04830328f, 0.03654617f, -0.03145880f, -0.05754308f, -0.37151486f, 0.08661749f, 0.15083249f, 0.09560264f, 
    0.02573439f, -0.01037636f, -0.01967459f, 0.01791922f, -0.09599277f, 0.03442010f, -0.03199384f, 0.04811049f, 
    0.05601550f, 0.03569029f, 0.03261148f, -0.00045967f, -0.00287890f, 0.03426075f, 0.10770505f, -0.01356557f, 
    -0.27132973f, 0.04034362f, -0.07099026f, -0.14547221f, 0.00350520f, 0.08670159f, -0.13935955f, -0.02597304f, 
    -0.00330217f, -0.06261761f, 0.01260880f, -0.02179563f, -0.03163083f, 0.03771404f, -0.03517995f, 0.01227665f, 
    -0.05560194f, -0.12295298f, -0.01027077f, -0.04948768f, -0.31214383f, 0.03548046f, 0.02162730f, -0.17447132f, 
    -0.05798476f, 0.03980410f, -0.02286785f, -0.01947016f, 0.04696093f, -0.08194275f, -0.01002601f, 0.02530635f, 
    -0.07961506f, 0.03557856f, -0.03447886f, 0.04061186f, -0.02192594f, -0.04767681f, -0.00454963f, -0.04136020f, 
    -0.52895886f, 0.10270513f, -0.09264009f, 0.03123792f, 0.14773130f, 0.07737461f, 0.00880691f, -0.01928071f, 
    0.07839526f, 0.13662817f, -0.01586877f, -0.03208252f, 0.00378692f, 0.03183096f, -0.07473474f, -0.03486126f, 
    0.10265991f, 0.05374026f, 0.05485663f, -0.10470835f, -0.02274313f, 0.26326120f, -0.13346764f, -0.17295885f, 
    -0.03527958f, 0.02278550f, -0.00002672f, -0.06113287f, 0.13067751f, 0.01259501f, 0.02579455f, -0.01193268f, 
    0.04276934f, 0.08798406f, 0.05084113f, -0.06012465f, -0.00064988f, -0.02983739f, 0.01878445f, -0.01996640f, 
    0.30449396f, -0.07832318f, -0.08262489f, -0.00197029f, -0.10546277f, 0.06328506f, -0.09929777f, -0.02039970f, 
    -0.04981758f, 0.05510492f, -0.00129114f, -0.00620832f, -0.00577198f, -0.02923874f, 0.02417730f, 0.04751554f, 
    0.01006933f, -0.04417538f, -0.02154925f, -0.09582721f, 0.13857695f, -0.19501585f, 0.15796717f, -0.07769712f, 
    0.00053683f, -0.09632558f, -0.08445108f, 0.02239892f, -0.08229047f, 0.02859377f, 0.02757698f, 0.01876758f, 
    -0.05428242f, -0.04247212f, 0.04988444f, -0.05865236f, 0.05366610f, -0.05741706f, 0.03676730f, 0.00087613f, 
    0.09252296f, -0.04290918f, 0.09083933f, -0.10833956f, 0.14479864f, -0.12490138f, 0.12555453f, -0.05731587f, 
    0.01558191f, 0.03428384f, -0.05226647f, 0.05439724f, 0.09465037f, 0.02932180f, -0.01847428f, -0.08945069f, 
    -0.04443490f, 0.00821360f, 0.08400854f, 0.04489226f, 0.03368891f, 0.00643541f, 0.08690999f, 0.07177769f, 
    0.00689612f, 0.02522041f, -0.04598581f, 0.05031523f, 0.07002959f, 0.06004694f, 0.02994486f, -0.00066788f, 
    0.03307214f, 0.02155964f, 0.06861813f, 0.02600371f, 0.05472283f, -0.04764882f, 0.01439469f, -0.01036339f, 
    -0.24346502f, -0.20971623f, 0.06129180f, -0.01641639f, 0.04629490f, 0.04305781f, -0.06828172f, -0.03080002f, 
    -0.07770917f, -0.00316365f, -0.02936329f, -0.06684459f, 0.01271871f, -0.00214872f, -0.00270763f, -0.06457432f, 
    -0.07362030f, -0.02181168f, -0.04256139f, -0.05035797f, -0.07853934f, 0.18226111f, -0.05311489f, 0.08014410f, 
    -0.13426825f, 0.01883225f, -0.08244877f, 0.01971420f, 0.00211669f, -0.13102198f, -0.04193955f, -0.03464212f, 
    -0.01925361f, 0.07054660f, 0.00837550f, 0.03014646f, -0.04743152f, 0.09649969f, 0.02772908f, 0.07680076f, 
    0.03897578f, -0.01807854f, -0.05962685f, -0.02651228f, 0.12064750f, 0.02135637f, 0.07146134f, -0.07297243f, 
    0.13683084f, 0.06773556f, 0.06110012f, -0.08214110f, 0.07619280f, 0.04794826f, 0.04201445f, 0.07719303f, 
    0.07415483f, -0.01139813f, 0.03361525f, -0.01370541f, -0.21380562f, 0.01191408f, -0.17484926f, 0.04316887f, 
    0.22774369f, -0.05115445f, 0.01082538f, 0.00343360f, 0.13003464f, -0.00118884f, 0.02193867f, -0.07510819f, 
    -0.04642731f, 0.11360556f, 0.04351214f, 0.05083392f, 0.07877796f, 0.05277602f, -0.00212103f, -0.03095368f, 
    0.00426135f, -0.08389162f, 0.20455524f, -0.01931176f, -0.15443039f, 0.02014009f, 0.02656870f, -0.08301967f, 
    0.07523692f, -0.03906184f, 0.09070216f, -0.04498237f, -0.06492948f, -0.01408656f, 0.06523748f, -0.01046431f, 
    -0.01147221f, -0.07929875f, -0.00725728f, 0.07977822f, 0.03643238f, -0.22574455f, -0.03009057f, -0.06471901f, 
    -0.09545000f, -0.10823118f, -0.01208611f, 0.01261361f, -0.03421243f, 0.03692453f, 0.04842798f, -0.07815473f, 
    -0.09570286f, -0.03803572f, -0.04225497f, 0.08151983f, 0.04113541f, 0.01021144f, -0.11919428f, -0.02626771f, 
    0.08238897f, 0.25995877f, -0.24697933f, -0.40157449f, -0.07757729f, -0.05654673f, -0.00554990f, -0.02640779f, 
    0.02634967f, -0.11855543f, -0.00622371f, -0.00761895f, -0.12938499f, -0.00862777f, 0.05317570f, 0.04496225f, 
    0.06232236f, -0.10067522f, -0.03361917f, -0.03541177f, -0.14916961f, -0.03763713f, 0.14820664f, -0.01073301f, 
    0.00768942f, -0.06521819f, -0.05783337f, 0.04308896f, -0.09366842f, 0.09274967f, 0.02013529f, -0.00383151f, 
    -0.03142023f, -0.11714409f, 0.07281065f, 0.00349501f, -0.01023250f, -0.00073133f, 0.05638032f, -0.01138652f, 
    -0.61540252f, 0.01216401f, -0.06448159f, 0.20138915f, 0.19678035f, 0.10243063f, -0.00049357f, 0.04877403f, 
    0.07944437f, 0.14730932f, 0.05156776f, -0.01542399f, 0.03911814f, -0.00571681f, 0.04868853f, 0.00705807f, 
    0.01463204f, 0.05207418f, 0.12334772f, -0.00544749f, 0.29596397f, 0.14463231f, -0.23718189f, -0.13651755f, 
    0.10499173f, 0.00423245f, -0.11667845f, -0.02155002f, 0.11575126f, -0.01155282f, -0.00792396f, -0.01186859f, 
    -0.03412462f, 0.04811149f, -0.03870832f, -0.11673726f, 0.03169905f, -0.07896701f, -0.00799422f, -0.05299917f, 
    -0.02787654f, 0.11836031f, -0.03239199f, -0.07929186f, -0.05951601f, -0.03129683f, 0.09402768f, 0.09163363f, 
    -0.07398321f, -0.01411763f, 0.06085264f, 0.06581043f, -0.00321487f, 0.02908049f, -0.00677147f, -0.08717700f, 
    0.06499920f, -0.03771475f, -0.03284223f, 0.11793865f, 0.18968302f, 0.11968964f, 0.03613844f, -0.03853811f, 
    -0.09233884f, -0.09446272f, 0.02242562f, 0.00919335f, 0.07664572f, 0.03437718f, 0.03620487f, -0.07692092f, 
    0.01372522f, 0.03850295f, -0.00649931f, -0.09219771f, 0.08716694f, 0.06712205f, -0.00222876f, 0.11232153f, 
    -0.07121952f, 0.03001680f, -0.12171905f, 0.05268822f, -0.04158248f, 0.11648122f, -0.03317815f, 0.16334623f, 
    0.00826826f, 0.00175680f, 0.02279618f, -0.03794815f, 0.05124333f, -0.02735351f, -0.01058825f, -0.01160177f, 
    0.06833734f, -0.01613446f, 0.06774982f, 0.03165276f, -0.05469337f, 0.04294408f, 0.04821515f, 0.11037242f, 
    -0.07756958f, -0.00991732f, 0.03621600f, 0.04873708f, -0.05950974f, -0.02899015f, 0.11673180f, 0.02451806f, 
    -0.00193571f, -0.08996207f, 0.05535075f, 0.01763668f, 0.05487076f, 0.07261463f, 0.00851778f, 0.06449103f, 
    -0.27197042f, 0.06011178f, 0.07584918f, 0.10725278f, 0.04528640f, -0.05142040f, -0.00881144f, 0.06305286f, 
    -0.00003905f, -0.03758307f, 0.08116374f, -0.00753007f, 0.00807054f, -0.02872222f, 0.02676041f, -0.02500509f, 
    0.00927912f, -0.18698838f, 0.00172468f, -0.05574731f, -0.06799804f, -0.18381210f, 0.07579593f, 0.17273486f, 
    -0.00677844f, -0.04596671f, 0.05650789f, 0.05066057f, -0.10888568f, -0.02328299f, 0.08383652f, 0.06722406f, 
    -0.00943384f, -0.01317003f, -0.01706684f, 0.00935699f, -0.04563760f, 0.05322636f, -0.00031918f, 0.01732622f, 
    -0.24614583f, 0.18245338f, 0.11997101f, -0.16214064f, -0.06476524f, 0.13779096f, -0.02762408f, -0.02528722f, 
    -0.01234837f, -0.01037787f, 0.07948159f, -0.04153799f, -0.01415974f, -0.07051357f, -0.00708330f, 0.06825805f, 
    -0.05195113f, -0.13053064f, -0.01596533f, -0.00140210f, -0.13432568f, 0.07038846f, 0.03516557f, 0.11611573f, 
    -0.01926872f, 0.04657187f, -0.02482713f, -0.07427605f, 0.13721265f, -0.00972544f, -0.07112528f, 0.03922914f, 
    -0.04267880f, 0.10872964f, 0.09437978f, -0.00498521f, -0.03943113f, 0.03492574f, 0.12267780f, 0.00092372f, 
    -0.05731801f, -0.04873345f, -0.02547319f, -0.19613387f, -0.04562924f, -0.00286415f, 0.00324173f, -0.09128525f, 
    0.02437372f, 0.04454338f, -0.09099491f, -0.00794001f, 0.01104253f, 0.05877950f, 0.00110339f, -0.01958973f, 
    -0.03360882f, -0.01987558f, -0.09857570f, -0.03406718f, -0.19854809f, -0.09474991f, -0.02132988f, 0.06031862f, 
    0.22069633f, 0.03359904f, 0.12022070f, 0.02033875f, -0.00803394f, 0.06242104f, -0.00792724f, -0.07902294f, 
    0.05332870f, 0.03500926f, -0.05709408f, -0.06525986f, 0.07032143f, 0.03906957f, 0.05173707f, -0.10955290f, 
    -0.15066534f, 0.19176325f, -0.03999999f, -0.00267257f, -0.15775181f, 0.01812209f, -0.05294192f, 0.01427552f, 
    -0.01943915f, -0.12477148f, -0.02244140f, 0.04807702f, -0.06174046f, 0.04675885f, -0.07451693f, -0.10840296f, 
    0.03412547f, 0.08127432f, -0.04792832f, 0.01495117f, 0.11007779f, 0.01166730f, -0.05689289f, 0.02582138f, 
    -0.09618071f, 0.02520817f, -0.04576329f, 0.08820545f, -0.01941728f, 0.02138260f, -0.07860418f, 0.00474424f, 
    0.02748463f, -0.03008643f, -0.00690663f, 0.02356550f, -0.07886103f, -0.01922998f, -0.03962154f, -0.07698655f, 
    -0.66460568f, 0.06297142f, 0.12717108f, 0.11420543f, 0.13384360f, 0.07594637f, 0.01034246f, 0.03174619f, 
    -0.00457524f, 0.13571498f, -0.09416240f, 0.01110474f, 0.06377822f, 0.05879356f, 0.03070778f, 0.02845191f, 
    0.07468522f, 0.05631995f, 0.07302628f, -0.10780500f, -0.29802725f, -0.05053760f, -0.02321555f, -0.04580761f, 
    0.03321068f, -0.01319734f, 0.06017921f, 0.01841332f, 0.03224396f, 0.01272403f, 0.05310280f, -0.08085394f, 
    0.05338656f, -0.00325464f, 0.03238010f, -0.02152824f, 0.05488514f, 0.03778335f, 0.07010192f, -0.05473536f, 
    -0.03105908f, 0.15166122f, 0.06717062f, 0.06721026f, 0.06058776f, 0.10529739f, 0.04635801f, -0.04924654f, 
    0.12180621f, 0.00740704f, 0.06107041f, 0.07638192f, -0.06698769f, -0.00431307f, -0.00149613f, -0.00343356f, 
    -0.00320803f, -0.03313123f, 0.02494916f, 0.04423188f, -0.19178823f, 0.07175137f, 0.01221022f, -0.04552677f, 
    0.03821576f, 0.01161493f, -0.03713916f, -0.04900688f, -0.01898109f, 0.00935038f, -0.02760792f, 0.00639530f, 
    -0.00221364f, 0.06156266f, 0.00848550f, -0.05712524f, 0.06003043f, -0.00263377f, 0.02770052f, -0.04596486f, 
    -0.33306283f, -0.03216440f, 0.20083466f, -0.03546645f, -0.02225933f, -0.05630083f, 0.06328733f, 0.02016945f, 
    -0.03276035f, -0.02504592f, 0.01624909f, 0.15874012f, 0.08992688f, -0.10366095f, 0.10765135f, 0.04816101f, 
    0.09140288f, -0.05589283f, -0.06571656f, -0.09341135f, -0.10848918f, -0.01902850f, 0.06186457f, -0.14633095f, 
    -0.02057035f, -0.10068036f, -0.02124377f, -0.05534394f, -0.03858900f, 0.02105316f, -0.08459619f, 0.02287982f, 
    -0.02582638f, -0.04250661f, 0.00450533f, 0.00721710f, -0.02468169f, 0.01582530f, 0.06047590f, 0.02015129f, 
    -0.07858770f, -0.08324332f, -0.12913965f, 0.18801543f, -0.09049947f, 0.13978679f, -0.08436856f, 0.12976725f, 
    0.04024973f, 0.05923674f, -0.04038818f, -0.05978522f, -0.00157628f, -0.00844977f, 0.01355593f, -0.01298757f, 
    0.12286320f, -0.00588580f, 0.07409902f, 0.03727283f, -0.20596890f, 0.11487327f, 0.01279787f, 0.04499518f, 
    -0.03250512f, -0.06862260f, -0.00100434f, 0.02696306f, 0.00202536f, 0.05682113f, 0.03681669f, 0.06671433f, 
    -0.02124188f, -0.01292706f, 0.00996719f, -0.03573543f, 0.15294167f, -0.00287728f, 0.02614236f, 0.03183336f, 
    -0.21403062f, -0.32795367f, 0.09664146f, 0.16689675f, 0.08549438f, -0.12193520f, 0.00112421f, -0.06387605f, 
    -0.00460828f, 0.01699059f, 0.12699260f, 0.00779995f, 0.04033777f, -0.04080492f, -0.01725704f, -0.08233541f, 
    -0.04277255f, -0.00524177f, 0.04535574f, -0.00251814f, -0.33678347f, -0.01835709f, -0.06518794f, -0.05656147f, 
    -0.01857930f, 0.04653044f, 0.02472539f, 0.04843713f, -0.04906673f, -0.02112493f, 0.00416100f, -0.00383519f, 
    0.03398228f, 0.03493655f, 0.05640720f, -0.06814466f, 0.05039733f, -0.00185876f, 0.02980492f, -0.00768316f, 
    0.14719714f, 0.00940612f, -0.10909569f, 0.09352001f, 0.05384779f, 0.00920298f, -0.01429340f, 0.00897660f, 
    0.03385593f, -0.04041426f, 0.04210451f, 0.09517208f, 0.00374045f, 0.00475346f, 0.02732489f, -0.02703756f, 
    -0.05954776f, 0.03605717f, 0.03955903f, 0.04109323f, -0.28008434f, -0.13620602f, 0.03666640f, -0.12264181f, 
    0.08569931f, 0.08848330f, 0.02992112f, -0.01316857f, 0.06140845f, 0.11618483f, 0.10319877f, 0.04656628f, 
    0.02849336f, -0.11904654f, -0.00148327f, 0.07014444f, -0.05635535f, -0.05205024f, 0.02745634f, 0.05308874f, 
    -0.01038274f, 0.32457572f, -0.07622404f, -0.13014969f, -0.15069099f, -0.05879790f, -0.00875660f, 0.05899204f, 
    0.01310943f, 0.03595291f, -0.00523474f, 0.07746612f, -0.06587444f, 0.01382081f, 0.01702758f, 0.08413990f, 
    0.06007811f, -0.08754384f, -0.02732016f, -0.02130337f, -0.02602421f, -0.08617578f, -0.14046073f, 0.03456186f, 
    -0.00814937f, 0.06696465f, -0.10855210f, 0.06114058f, 0.05948231f, -0.04408954f, 0.01902184f, 0.08501956f, 
    -0.10229852f, -0.00969926f, 0.02782680f, 0.01609173f, 0.04628677f, 0.01999830f, -0.01085885f, -0.02724360f, 
    -0.08291543f, -0.11970775f, 0.14321680f, 0.01185301f, 0.08794255f, -0.00022750f, 0.03403367f, -0.06666405f, 
    0.09751795f, 0.07506716f, 0.14397100f, -0.03150860f, -0.00233409f, -0.00335204f, 0.06001311f, 0.02765554f, 
    0.04694014f, -0.08325573f, 0.07866928f, 0.17976052f, 0.09222925f, 0.09764401f, -0.02230000f, 0.04632989f, 
    0.15794224f, 0.04624680f, 0.02289762f, 0.00430154f, 0.02553074f, -0.05287701f, -0.08685645f, 0.08609234f, 
    -0.09458452f, 0.06848729f, -0.02168104f, -0.05542310f, -0.09504692f, -0.15045449f, -0.06038070f, -0.03939088f, 
    0.09790628f, -0.01494987f, -0.04693509f, 0.00763489f, 0.16585481f, 0.06040050f, 0.06113862f, -0.01562321f, 
    -0.01068604f, -0.00422557f, 0.01965196f, -0.00307960f, -0.03574893f, -0.02744376f, -0.07492074f, -0.03981575f, 
    -0.05916134f, -0.02688383f, 0.09209407f, -0.13148516f, 0.04687075f, -0.15685025f, -0.11388993f, 0.04554949f, 
    -0.19764176f, -0.13846965f, -0.04422526f, 0.01428932f, -0.17540459f, -0.04306975f, -0.03231204f, 0.07541401f, 
    0.03549654f, -0.05896932f, 0.01179983f, -0.05741878f, 0.08521134f, 0.09635437f, -0.03676102f, -0.00626987f, 
    -0.17932564f, 0.11972412f, 0.18729009f, 0.21293077f, 0.02470996f, 0.06011383f, -0.05271602f, 0.14517161f, 
    0.02925778f, -0.12192231f, 0.01425384f, -0.05707697f, -0.11141420f, 0.01424122f, 0.01094412f, -0.00021475f, 
    -0.00655024f, -0.04130163f, -0.07770816f, -0.08788628f, 0.20347844f, 0.05884333f, -0.09209341f, -0.04097505f, 
    0.01932523f, 0.04669001f, 0.03126475f, 0.02569818f, 0.12366246f, 0.03718423f, -0.03995746f, -0.07920804f, 
    0.04594824f, 0.02062535f, -0.08499171f, 0.03392082f, -0.00639721f, -0.03241013f, 0.00973910f, 0.02235271f, 
    -0.12017713f, -0.05078875f, 0.12355086f, 0.11478808f, -0.02566116f, 0.00928512f, 0.06650147f, -0.03214621f, 
    0.02707834f, 0.01076565f, 0.01602582f, 0.00165556f, -0.03144946f, 0.03789929f, -0.06027103f, -0.08688764f, 
    0.00448683f, -0.02519616f, 0.00792788f, 0.07902465f, -0.29539731f, -0.24042332f, 0.18534698f, 0.18647699f, 
    0.00941243f, -0.12297150f, 0.03461955f, -0.07263610f, -0.15604922f, -0.08911064f, -0.01788846f, -0.03115137f, 
    -0.07925611f, -0.00530188f, 0.13231467f, -0.04595875f, -0.11586753f, 0.08703455f, 0.00068598f, 0.05045342f, 
    0.22853035f, 0.13652062f, -0.27262628f, -0.09789094f, -0.17034841f, 0.00225045f, -0.05585976f, 0.05132875f, 
    -0.00452113f, -0.06374755f, -0.05251544f, -0.01432728f, 0.01861286f, 0.00348980f, -0.07763779f, -0.04394527f, 
    -0.15752387f, 0.06643414f, -0.00685951f, -0.10014772f, -0.09504589f, 0.02215564f, -0.14145918f, -0.06397525f, 
    -0.07729220f, 0.01240091f, -0.04654137f, -0.16623917f, -0.12950723f, 0.01483583f, 0.02210225f, -0.10289045f, 
    -0.03942633f, 0.05768678f, -0.01266030f, -0.01734403f, -0.00374322f, -0.03474386f, -0.09253351f, -0.08377495f, 
    -0.03942649f, 0.03657478f, -0.12009463f, 0.12244207f, -0.07324572f, 0.00279916f, -0.08292616f, 0.02178577f, 
    -0.04571865f, -0.02884887f, 0.00002927f, 0.08652329f, 0.00606077f, 0.00306342f, 0.07872453f, 0.05076805f, 
    0.03245903f, 0.00382431f, 0.03464537f, 0.00849180f, -0.07790281f, 0.22309250f, 0.10256100f, -0.03725199f, 
    -0.06974455f, 0.05519546f, 0.06584755f, -0.01351622f, -0.00960170f, -0.06180027f, 0.01758637f, 0.06695656f, 
    -0.03838571f, 0.13112295f, -0.10444762f, -0.09338938f, 0.05913658f, 0.07276811f, -0.00698302f, 0.03922501f, 
    0.00242483f, -0.17637415f, 0.01621550f, 0.11195572f, -0.19266739f, -0.17040090f, -0.12904593f, 0.02607002f, 
    -0.09237023f, 0.02162653f, -0.08561524f, 0.02860109f, -0.00179205f, -0.07761465f, 0.00106098f, 0.00437665f, 
    -0.00235342f, 0.01560406f, -0.01879780f, 0.04698344f, -0.23787469f, 0.12788102f, 0.11176828f, -0.02952679f, 
    -0.03113026f, -0.04391655f, 0.10819095f, 0.03683066f, 0.06353567f, -0.09988651f, -0.06882728f, -0.03034643f, 
    0.00952406f, 0.00306165f, -0.01068157f, -0.10944699f, -0.08859500f, -0.00961499f, 0.06232601f, 0.01030849f, 
    0.20098418f, -0.02625698f, -0.08219872f, -0.03281142f, 0.14215955f, 0.04875025f, 0.03855725f, 0.11075689f, 
    0.10661516f, 0.01968614f, 0.00952052f, -0.00929095f, 0.04542978f, 0.02762723f, 0.03568594f, 0.04316665f, 
    -0.03460437f, -0.02065376f, 0.04475585f, -0.00854048f, -0.01463390f, -0.02365999f, -0.07398204f, 0.02216800f, 
    0.02022860f, 0.05163790f, 0.05238951f, 0.04396112f, 0.11676137f, 0.01582404f, 0.07104698f, 0.08821914f, 
    0.06325503f, -0.03502445f, 0.05307290f, -0.01084027f, -0.07449989f, 0.05017691f, 0.05863753f, 0.08879425f, 
    0.05963342f, 0.06681456f, -0.00693923f, -0.02196907f, 0.08954918f, 0.00239584f, -0.01313487f, 0.00119553f, 
    -0.01246302f, 0.00385720f, -0.07722271f, 0.08835275f, 0.09956330f, 0.08427978f, 0.11287158f, 0.06473576f, 
    0.01783566f, 0.05666133f, -0.18250686f, 0.03689278f, -0.01284216f, 0.02658650f, 0.06036709f, 0.07685532f, 
    0.06713527f, -0.07325768f, -0.06589320f, 0.04550046f, 0.05386969f, 0.07300766f, -0.02584389f, -0.00066844f, 
    0.07384892f, 0.05471368f, -0.00989981f, -0.00891830f, 0.06718370f, -0.25649256f, -0.03983522f, -0.10575415f, 
    -0.24012442f, -0.22494717f, 0.18252210f, -0.06366226f, 0.08393166f, 0.07744706f, -0.08668816f, -0.06201059f, 
    0.00555382f, -0.01870190f, 0.05107083f, 0.00831508f, -0.13031413f, 0.05541609f, 0.01279743f, -0.00136150f, 
    0.04624161f, -0.02835678f, -0.09149125f, 0.05121732f, -0.10279998f, 0.09308811f, -0.05554054f, -0.04519193f, 
    0.00331429f, 0.05317514f, -0.02910568f, -0.03021173f, -0.02361405f, -0.09373970f, 0.02036954f, -0.00903802f, 
    -0.08038972f, -0.03796010f, 0.01768168f, -0.03139280f, 0.00301677f, 0.04589404f, 0.03502223f, -0.05571988f, 
    -0.46494606f, 0.16822337f, 0.08269013f, 0.18122327f, -0.11478697f, -0.05088322f, -0.02340944f, 0.00941300f, 
    -0.11489177f, 0.03320841f, 0.02234385f, 0.04501685f, 0.04009934f, 0.00269615f, -0.04157983f, 0.11606951f, 
    -0.02214933f, 0.03970881f, 0.01744752f, -0.00836044f, -0.20637506f, 0.01896019f, -0.01782391f, 0.02169689f, 
    0.08922572f, 0.06291840f, 0.03799103f, 0.04312547f, 0.03974514f, 0.01976096f, -0.01190254f, -0.04517952f, 
    0.07584061f, 0.01844680f, 0.11545597f, -0.00133354f, 0.08785876f, -0.04246577f, 0.04084947f, -0.05699925f, 
    -0.51426089f, -0.10934614f, -0.29202583f, -0.18556882f, -0.18804936f, 0.15874636f, 0.07061145f, 0.03792801f, 
    -0.04520610f, -0.14886758f, -0.00157285f, 0.08458193f, 0.03130715f, -0.05027584f, -0.07467742f, 0.03568899f, 
    -0.09276944f, -0.01205473f, 0.01321062f, 0.00294388f, 0.20570943f, 0.08200459f, 0.10605238f, 0.10732228f, 
    0.05071686f, -0.00400825f, 0.11190873f, 0.02152444f, -0.01829035f, -0.05906402f, -0.00004941f, 0.05602142f, 
    -0.03423980f, -0.07468504f, -0.00890242f, 0.07006537f, 0.00538807f, 0.05854120f, 0.08812606f, 0.09836558f, 
    0.02324011f, -0.03524731f, 0.11107924f, -0.04709153f, 0.08724441f, 0.04001681f, 0.15762240f, 0.01468555f, 
    -0.07107314f, 0.03107459f, -0.04335657f, -0.04933727f, -0.01896696f, -0.00419741f, -0.02646942f, -0.04355103f, 
    -0.00657312f, 0.09059866f, 0.00173278f, 0.04245913f, 0.05988440f, 0.02079971f, 0.08305669f, 0.02502454f, 
    -0.05085970f, -0.11748958f, -0.02826119f, -0.03668464f, -0.00831298f, 0.08802100f, 0.03516034f, 0.00646551f, 
    0.07769249f, 0.14161432f, 0.00732191f, 0.00279941f, -0.07157098f, 0.08097768f, 0.00746753f, 0.00569141f, 
    0.10673197f, 0.09367452f, -0.18364240f, 0.16652162f, 0.03587914f, 0.05554379f, -0.01300661f, 0.06505625f, 
    0.00344927f, 0.12516820f, 0.04282517f, -0.09960708f, -0.02283644f, -0.00064982f, 0.03490902f, -0.04683187f, 
    0.03084369f, 0.08566572f, -0.10419984f, -0.09390680f, 0.14814888f, -0.01907908f, 0.01580957f, 0.02464125f, 
    0.02332781f, -0.00468772f, -0.00107240f, -0.04222580f, -0.10683554f, 0.03597512f, 0.04307749f, 0.03390433f, 
    0.02842879f, 0.02721502f, 0.05335327f, 0.05159638f, -0.08627613f, 0.05874453f, 0.07347417f, 0.01439258f, 
    0.04150750f, 0.01667703f, 0.00457972f, 0.06089054f, 0.01343740f, -0.08589900f, -0.06391476f, 0.07227596f, 
    0.03195965f, 0.05062022f, 0.05271535f, -0.00954050f, -0.02710105f, 0.07657377f, 0.09557176f, 0.10347460f, 
    0.06382541f, 0.02213584f, -0.17170514f, 0.04561448f, -0.08018620f, 0.10642289f, -0.13326800f, -0.02970687f, 
    0.13304745f, -0.03198294f, 0.05681600f, -0.05861086f, 0.09333884f, 0.02609024f, 0.08459528f, -0.01299138f, 
    0.08842921f, 0.01618014f, 0.01706513f, -0.07105913f, 0.06985747f, -0.14818355f, 0.11254669f, -0.01286147f, 
    0.24559034f, 0.17471983f, 0.10432122f, 0.08880866f, -0.07418577f, 0.03438678f, 0.00925972f, 0.01823610f, 
    0.00517869f, -0.02878604f, 0.01122218f, -0.02837804f, -0.07082070f, -0.00723118f, -0.04793713f, 0.04815830f, 
    0.00574429f, 0.12428904f, 0.07140451f, 0.11037521f, -0.21413985f, 0.16269094f, -0.08118583f, -0.06099470f, 
    -0.24889629f, 0.04921639f, -0.01816127f, 0.02646725f, -0.08603666f, -0.00990810f, 0.01225346f, -0.02802792f, 
    -0.00848652f, -0.07865492f, -0.07494786f, 0.01232963f, -0.11218791f, 0.02611873f, 0.12993331f, -0.00001372f, 
    0.01029080f, 0.03102833f, -0.08117819f, 0.08594404f, -0.02529113f, -0.02069131f, 0.04896725f, 0.01874014f, 
    -0.03036411f, 0.09171192f, -0.01939643f, 0.02683235f, 0.07807968f, 0.05868972f, -0.11752963f, -0.03275171f, 
    -0.01897738f, -0.13453223f, 0.01148437f, -0.05687579f, -0.04987704f, 0.08584137f, -0.08120456f, 0.09878632f, 
    -0.03664101f, 0.01424601f, 0.02094927f, -0.07633163f, -0.06428973f, -0.00419153f, -0.09055339f, -0.02912240f, 
    0.01605170f, 0.00361022f, 0.03611409f, 0.09714265f, -0.04967680f, 0.00670201f, 0.07675502f, 0.01437565f, 
    -0.26784378f, 0.07032751f, 0.11878986f, 0.10928196f, -0.07732094f, 0.02678567f, 0.01113433f, 0.00416968f, 
    -0.00312264f, -0.06863331f, 0.00207445f, 0.00691943f, 0.02816693f, -0.01984217f, 0.00704959f, 0.00096069f, 
    0.01933042f, 0.02424121f, 0.07429445f, -0.07494076f, -0.01417566f, 0.03823968f, -0.01240909f, 0.00404500f, 
    0.08655000f, -0.03135468f, 0.10868827f, -0.03573981f, 0.02627911f, 0.01494022f, -0.04694503f, -0.01336110f, 
    0.07616544f, 0.01273456f, 0.04484247f, 0.01382432f, 0.07810754f, -0.05637412f, -0.08263193f, -0.03871367f, 
    -0.30922195f, 0.10010646f, -0.28683695f, -0.23192307f, -0.04499561f, 0.09914620f, 0.14417849f, 0.13651247f, 
    -0.07431898f, -0.11894177f, -0.03454417f, 0.05435634f, -0.06644251f, -0.07097750f, -0.02749963f, 0.04639002f, 
    0.04263015f, -0.00813312f, 0.03384869f, -0.02145505f, -0.23257749f, -0.10289145f, 0.22349755f, 0.10527469f, 
    -0.19261295f, 0.09629000f, 0.02638869f, -0.06344434f, -0.03014408f, 0.01273600f, -0.04750871f, -0.14633863f, 
    -0.09748669f, -0.09920269f, -0.12681293f, 0.01082630f, 0.08902479f, 0.06726282f, -0.08714337f, 0.06097035f, 
    -0.10911723f, -0.06526739f, 0.19825925f, 0.18166383f, -0.39247829f, -0.05290725f, -0.07704788f, -0.02702633f, 
    0.03879212f, -0.03550927f, -0.03555536f, 0.04603524f, 0.05001657f, 0.04805215f, 0.00692687f, -0.10565732f, 
    -0.04827560f, 0.01217368f, -0.05052619f, 0.06628115f, -0.03781004f, -0.00727618f, 0.18181436f, 0.14500520f, 
    -0.24660353f, 0.06690456f, -0.02958595f, 0.03394818f, -0.02241581f, -0.06466202f, -0.09215109f, 0.00319015f, 
    -0.05147736f, -0.02831071f, 0.06877968f, -0.07126662f, -0.01223402f, -0.02924904f, 0.10443363f, -0.07104677f, 
    -0.17926809f, 0.09348611f, 0.12626506f, -0.03134080f, -0.12426365f, -0.06499698f, 0.00412808f, 0.05038976f, 
    -0.07935456f, 0.03258912f, 0.06290734f, -0.01764778f, 0.03140074f, -0.05379930f, -0.03386326f, 0.00149479f, 
    -0.03030558f, -0.01258967f, -0.02346713f, 0.06817441f, -0.04106187f, -0.03034823f, -0.00247933f, 0.07082570f, 
    0.15496925f, 0.00118309f, -0.08833806f, -0.01680788f, 0.01217568f, 0.07720620f, 0.00843056f, -0.10047811f, 
    0.08208057f, 0.05377363f, -0.00994082f, -0.08814548f, -0.12003494f, -0.10767815f, -0.08406769f, -0.13039899f, 
    0.06694629f, -0.02834666f, 0.07313249f, 0.04088742f, -0.21220885f, -0.10665534f, 0.04447016f, 0.00558420f, 
    -0.04550589f, 0.06865564f, 0.03050608f, 0.10615585f, 0.06049854f, 0.02740985f, -0.01507640f, -0.01591592f, 
    -0.10095873f, 0.03335004f, 0.10202756f, 0.02929073f, 0.02365536f, 0.02242375f, -0.08584923f, 0.15361959f, 
    0.21613385f, -0.05912513f, -0.03937548f, -0.05131245f, 0.13965029f, 0.01345041f, 0.07238244f, -0.07094657f, 
    0.06162213f, 0.09795406f, 0.10911714f, -0.04534280f, 0.06948530f, -0.05813072f, -0.07023037f, -0.12496960f, 
    -0.28879133f, 0.15293077f, 0.07463010f, 0.17005293f, 0.01174746f, -0.03393311f, 0.02670296f, -0.01106919f, 
    -0.06757511f, 0.04884738f, -0.01975181f, -0.00596878f, -0.02649166f, 0.04381841f, 0.02155595f, -0.01763991f, 
    0.02622476f, 0.01932887f, 0.03625250f, -0.17157045f, -0.17430840f, 0.08650623f, -0.15470299f, -0.01853241f, 
    0.13077801f, 0.10345256f, 0.15499511f, 0.02098667f, 0.00628825f, 0.02084335f, 0.03567985f, -0.00752337f, 
    -0.00243792f, -0.11061020f, -0.04667015f, -0.14116183f, 0.06859466f, -0.10941686f, -0.06830629f, -0.04842910f, 
    -0.15223086f, -0.05442877f, 0.02256554f, 0.04052479f, -0.07003971f, 0.02117501f, 0.04988787f, 0.03635411f, 
    0.04174164f, -0.01953039f, 0.07690405f, -0.01200761f, -0.03072198f, -0.03421147f, -0.01183728f, 0.10677081f, 
    0.01848353f, -0.00607764f, -0.01702985f, 0.01917304f, -0.39887190f, 0.04353980f, -0.17521979f, -0.10908684f, 
    -0.06318312f, 0.08665508f, -0.02886492f, 0.05011488f, -0.04501608f, -0.17526580f, 0.09504056f, 0.06651949f, 
    -0.02372728f, -0.01835094f, 0.03506334f, 0.08105572f, -0.00865873f, 0.03667266f, -0.03461716f, 0.01601670f, 
    0.07435066f, -0.15157095f, -0.12526056f, 0.08753727f, 0.13124289f, -0.03743418f, -0.12129987f, -0.05223023f, 
    -0.02972879f, 0.03700403f, 0.07282554f, 0.00786497f, -0.04434230f, 0.01061023f, 0.02206209f, 0.06811491f, 
    -0.18418616f, -0.02940503f, -0.00894999f, -0.07700040f, 0.02245087f, -0.02398730f, 0.01211986f, -0.01613362f, 
    0.00285727f, -0.03192630f, -0.01263520f, -0.00377196f, 0.00090774f, -0.00271514f, 0.03979008f, -0.01434783f, 
    -0.04673992f, 0.00920720f, -0.03902450f, 0.02804365f, -0.05514738f, 0.09963802f, -0.11613380f, 0.02608841f, 
    -0.13496058f, 0.15692143f, -0.18569441f, -0.09980861f, -0.03844338f, 0.05026451f, 0.07543203f, 0.01827456f, 
    -0.00197803f, -0.17101242f, -0.00237919f, 0.02025404f, 0.00210123f, -0.07702409f, -0.01430114f, 0.01584692f, 
    -0.03378308f, 0.02123464f, 0.09285656f, 0.06066531f, -0.27131176f, -0.02355826f, -0.17369506f, -0.07456556f, 
    0.00805237f, 0.05662233f, 0.01553173f, 0.00192030f, -0.02220709f, -0.06626305f, -0.03007131f, -0.00206148f, 
    0.03238934f, -0.01246656f, -0.07027657f, 0.03205356f, -0.08522129f, -0.03911338f, -0.08807559f, -0.04560507f, 
    -0.22643872f, -0.15133822f, -0.17731394f, 0.03119109f, 0.05729982f, 0.02252005f, 0.02635870f, 0.02243285f, 
    -0.01520676f, 0.03656891f, -0.02019856f, 0.12723795f, 0.05787031f, 0.03876267f, 0.04380441f, -0.01123560f, 
    0.02405700f, 0.02291386f, -0.02748629f, -0.03065380f, -0.01844506f, 0.22653753f, -0.23941569f, -0.00158184f, 
    -0.00895416f, 0.11053846f, 0.01812979f, 0.03783821f, 0.04766284f, -0.00282735f, -0.00032022f, -0.02572321f, 
    -0.06396559f, -0.11475224f, -0.05733413f, -0.04494066f, 0.00229646f, 0.04274426f, 0.02726679f, -0.07062967f, 
    0.08157437f, -0.21953645f, -0.01467243f, -0.01040519f, 0.00062073f, -0.06059033f, -0.12315615f, 0.04631130f, 
    0.20842220f, -0.11844297f, 0.00404823f, 0.00556752f, -0.17349482f, 0.02256880f, -0.10455669f, -0.06155885f, 
    -0.10337897f, -0.00701881f, 0.05467923f, 0.06499880f, 0.07233356f, -0.07141621f, -0.06485090f, -0.14246471f, 
    0.02277918f, -0.05972983f, 0.00146741f, 0.04675166f, 0.00265360f, -0.09250357f, -0.03656358f, 0.07417981f, 
    -0.05370655f, 0.05306430f, 0.12979276f, -0.00104319f, -0.03696525f, 0.05376418f, -0.14518742f, 0.02194680f, 
    0.12745017f, 0.14469777f, 0.04224567f, -0.10381569f, -0.04656905f, -0.05009975f, 0.08150503f, -0.03063325f, 
    -0.03033307f, 0.02996692f, 0.02622635f, -0.01251912f, 0.02556681f, -0.04963088f, -0.01323571f, -0.02339183f, 
    -0.09693481f, -0.04363383f, 0.10162571f, 0.00836126f, -0.02344402f, -0.09556051f, 0.05554126f, 0.14474766f, 
    -0.11540963f, -0.02959126f, 0.01252453f, -0.04515167f, -0.06285232f, -0.00412182f, 0.02293214f, 0.02433494f, 
    0.01081001f, 0.05452157f, 0.10545584f, -0.00840415f, -0.10222182f, -0.02269758f, 0.07473423f, 0.08214729f, 
    0.13657591f, 0.08469185f, 0.01329228f, 0.10446277f, 0.08586411f, -0.07738481f, -0.00556774f, 0.08315074f, 
    0.00706172f, 0.05215151f, -0.08358445f, -0.10234497f, -0.02512696f, 0.11868984f, 0.04998539f, 0.00237428f, 
    -0.00260424f, 0.07528566f, 0.03591965f, -0.02524002f, -0.19793256f, 0.03908587f, -0.01761049f, -0.12205859f, 
    0.03155405f, -0.02294920f, 0.02788047f, 0.07498824f, 0.03257794f, 0.00054892f, -0.03234668f, -0.02997151f, 
    0.04730432f, -0.09291754f, 0.03183920f, -0.05976657f, 0.09152655f, -0.06387838f, 0.01828762f, 0.05491902f, 
    -0.29649654f, -0.15997294f, -0.05298883f, -0.02657308f, 0.04592267f, 0.02591777f, 0.10761768f, -0.11813722f, 
    -0.00541485f, 0.00487437f, -0.01325691f, -0.00314355f, 0.06552131f, -0.03453285f, -0.06138036f, 0.07646938f, 
    0.02137373f, -0.02395044f, -0.06402385f, 0.03142660f, -0.06514743f, -0.00052273f, 0.13483763f, 0.22307713f, 
    -0.00861868f, -0.01277610f, 0.10337070f, 0.03547610f, -0.01688992f, 0.02268670f, -0.00600600f, -0.09292252f, 
    0.02384016f, -0.00468527f, 0.09388106f, -0.02763638f, 0.07705704f, -0.01536767f, -0.01395075f, -0.07002459f, 
    -0.26167861f, -0.30276638f, 0.02010804f, 0.02427930f, -0.21439508f, 0.08772494f, -0.02029467f, -0.04092368f, 
    0.03810941f, -0.14809155f, -0.03093862f, -0.01016610f, -0.02089044f, 0.02754924f, 0.01705880f, -0.08369341f, 
    -0.02574071f, 0.06649521f, -0.01681508f, -0.01891769f, -0.14166704f, -0.15478899f, -0.04351378f, -0.02587567f, 
    0.07333114f, 0.08965482f, 0.07207257f, -0.10578755f, -0.00408706f, 0.06883305f, 0.04062889f, 0.04279226f, 
    0.07839642f, 0.01657266f, -0.02910909f, 0.01113548f, 0.01953973f, -0.02361123f, -0.16170041f, -0.00076116f, 
    -0.22774456f, -0.13727498f, -0.15088111f, -0.10814930f, -0.06011370f, 0.00612644f, 0.17310129f, -0.02813691f, 
    -0.01862077f, 0.15257424f, -0.05358773f, 0.24202937f, 0.11390148f, -0.04247339f, -0.05974004f, -0.05826422f, 
    -0.01796690f, -0.03172781f, -0.03507102f, -0.04660395f, 0.01120676f, -0.21497877f, -0.03782639f, -0.07309157f, 
    -0.18412997f, 0.07195654f, -0.03881855f, -0.01637000f, 0.08359703f, 0.03908896f, 0.08947805f, 0.04458741f, 
    -0.00691074f, 0.01902243f, -0.05552392f, 0.04077211f, 0.05561086f, 0.05231502f, -0.19202225f, 0.09107716f, 
    -0.41896379f, -0.18272462f, -0.18215477f, -0.05506890f, 0.04398318f, 0.07930741f, 0.03664994f, -0.00019345f, 
    -0.00156533f, -0.04259009f, 0.04710671f, 0.00405836f, -0.08162894f, 0.03026845f, -0.03287239f, 0.00018627f, 
    0.09888347f, -0.01639862f, -0.20944905f, 0.05770601f, 0.01659234f, 0.12297169f, 0.04191994f, 0.06949288f, 
    0.04032911f, -0.08619212f, -0.02273912f, 0.02155488f, -0.01363459f, 0.07897363f, -0.03401198f, -0.14155039f, 
    -0.02624251f, 0.03775800f, -0.01089575f, 0.09263652f, 0.02355510f, -0.09122292f, -0.03402459f, 0.06957316f, 
    0.03245759f, -0.12518410f, -0.06751847f, 0.15132804f, -0.18788438f, -0.11082049f, -0.03487331f, -0.04417928f, 
    0.03841481f, 0.06455723f, 0.13220344f, 0.07764610f, 0.05794803f, 0.08714814f, 0.06808942f, -0.07848971f, 
    0.00545727f, -0.06520415f, -0.00577568f, -0.05446461f, -0.26938376f, -0.13398874f, 0.09929812f, 0.05115980f, 
    -0.23004666f, -0.01966051f, -0.03040579f, -0.00563958f, 0.02617542f, 0.13142394f, 0.00787476f, 0.01814164f, 
    -0.02204927f, -0.13764744f, -0.01597369f, 0.01869503f, 0.03362358f, 0.00041978f, 0.04399008f, 0.05503068f, 
    0.07837983f, 0.01266607f, -0.00487909f, 0.10966046f, 0.06166718f, -0.03089020f, -0.07845379f, 0.09222934f, 
    0.02167591f, -0.06896472f, -0.02266753f, -0.00945523f, 0.01346288f, 0.09671683f, 0.09246925f, -0.03477339f, 
    -0.00336099f, 0.06742679f, 0.04420473f, -0.06662538f, 0.12162503f, 0.06466338f, -0.09450655f, 0.06242616f, 
    0.07304116f, -0.12094231f, -0.01099250f, -0.02292529f, 0.03549010f, 0.02383146f, 0.00106180f, -0.09817861f, 
    -0.08406433f, 0.18803461f, 0.19154522f, 0.03029330f, 0.10647577f, -0.01767736f, -0.05776936f, -0.00548298f, 
    -0.25511324f, -0.03535886f, 0.08172656f, 0.00796609f, 0.14395416f, 0.01260761f, -0.05464993f, -0.11985723f, 
    0.02339997f, -0.06726481f, -0.02855787f, 0.02641242f, -0.00341744f, 0.00650032f, 0.03810327f, 0.00908428f, 
    0.07850292f, -0.06107677f, -0.08460980f, 0.04375255f, -0.04860883f, -0.00082286f, 0.04903765f, 0.19997987f, 
    0.07791997f, -0.00986427f, 0.02684635f, 0.04343929f, -0.01974152f, 0.08270257f, 0.19301553f, -0.06152198f, 
    0.04535677f, -0.07450223f, -0.04828264f, 0.00976552f, -0.01629647f, -0.09421597f, -0.01651083f, 0.06106457f, 
    -0.03450920f, -0.04562470f, 0.08598192f, 0.04457157f, 0.06774568f, 0.05889207f, -0.05158628f, -0.02507999f, 
    0.02223438f, -0.02121417f, 0.06609221f, -0.05842425f, 0.15287806f, 0.05740183f, -0.06993740f, -0.01323530f, 
    -0.04776919f, -0.04757890f, -0.13097262f, 0.02440131f, 0.13705046f, -0.01818636f, 0.06641576f, 0.14033546f, 
    0.14358355f, -0.01310834f, -0.02932638f, 0.04976009f, 0.05496163f, 0.00230610f, -0.07330186f, 0.02457359f, 
    -0.08941145f, -0.00464528f, 0.04280676f, 0.05287571f, -0.05390368f, -0.00469071f, -0.00750210f, -0.05839512f, 
    -0.02719831f, 0.08867001f, -0.03359190f, 0.00007045f, -0.02809356f, 0.02099512f, -0.03544046f, -0.07364216f, 
    -0.04800470f, 0.09935306f, 0.01693716f, -0.09165297f, -0.06224241f, 0.03862142f, -0.00690596f, 0.09856880f, 
    0.00039780f, -0.07202992f, 0.04604007f, -0.00612227f, -0.26487058f, -0.28670642f, 0.00303255f, -0.05706647f, 
    0.10572390f, 0.03729075f, -0.08961724f, 0.03638801f, 0.03187349f, -0.01524602f, 0.06151895f, -0.02717881f, 
    -0.01493627f, 0.03598954f, -0.00778607f, -0.08177508f, 0.07349676f, -0.11765548f, -0.00929359f, 0.01455409f, 
    -0.13753474f, -0.02137212f, 0.20018172f, -0.02445514f, -0.12053651f, 0.00827529f, 0.08057448f, -0.01048589f, 
    -0.01672463f, -0.02097021f, -0.02908256f, -0.04778234f, 0.01089646f, -0.01020100f, -0.04634976f, 0.01030816f, 
    0.07751095f, 0.04466163f, 0.03504812f, 0.03894132f, -0.03458993f, 0.00218624f, 0.07045997f, -0.04472262f, 
    0.20611927f, 0.02556366f, -0.09187528f, 0.03138696f, 0.05761114f, 0.05747470f, -0.00889319f, 0.06650969f, 
    -0.06928629f, 0.08134064f, 0.08392663f, 0.07280707f, -0.03907299f, 0.01395355f, -0.32462984f, 0.09006507f, 
    0.10177127f, 0.02153310f, -0.07378789f, -0.11564813f, 0.01030766f, 0.00537835f, 0.02981953f, -0.01649400f, 
    -0.02018417f, -0.02380923f, -0.00197406f, 0.00749472f, -0.04933262f, -0.06408321f, -0.05733005f, -0.02154829f, 
    -0.01531601f, -0.04035876f, 0.06681021f, -0.00129020f, -0.08265030f, -0.09187771f, -0.12887757f, -0.01536874f, 
    0.03890271f, 0.01533786f, 0.07897811f, -0.05525363f, -0.01939304f, 0.05209699f, 0.01894741f, -0.12117951f, 
    -0.12456715f, 0.04326411f, -0.01622512f, -0.01399970f, 0.00848529f, 0.13586789f, -0.03831735f, 0.07502033f, 
    0.03975775f, 0.09572518f, -0.05315029f, -0.06621964f, 0.10588672f, 0.07394890f, 0.03230437f, 0.00828173f, 
    0.01604369f, -0.01784816f, -0.02833799f, -0.11416573f, 0.07228941f, -0.07116582f, -0.00124004f, -0.07532554f, 
    0.10556634f, 0.03300032f, 0.03114842f, 0.11892059f, 0.16115086f, -0.23448728f, -0.02658595f, -0.07526264f, 
    0.13121907f, 0.06283835f, 0.02871093f, -0.09057397f, 0.12378253f, -0.03836864f, -0.03120574f, -0.04311416f, 
    0.03010894f, -0.00277359f, 0.03807689f, -0.04512388f, 0.00773898f, -0.06614497f, -0.09743057f, 0.04453203f, 
    -0.01383804f, -0.39760149f, 0.01816005f, 0.11059285f, 0.37061894f, 0.03042731f, 0.02599849f, -0.00803196f, 
    -0.00223616f, 0.01526388f, -0.10273632f, -0.07412928f, -0.01719916f, 0.01566720f, 0.10715266f, -0.10889067f, 
    -0.01084653f, 0.03251603f, 0.00552493f, 0.01869585f, 0.27885941f, 0.15977043f, 0.03726486f, -0.00672330f, 
    0.00419964f, -0.06892761f, -0.00449224f, 0.02487994f, -0.06030513f, -0.06138781f, 0.06416497f, -0.04291318f, 
    0.06185570f, -0.07171989f, -0.03975683f, -0.04107653f, -0.03231758f, 0.05746347f, -0.03848586f, 0.09279006f, 
    0.16930480f, -0.10755477f, 0.03151359f, -0.18363373f, 0.04468131f, -0.09444259f, -0.00581846f, 0.03114682f, 
    -0.08622739f, 0.00960668f, 0.01898531f, -0.06411657f, 0.08946924f, 0.02208493f, 0.02636828f, -0.03509502f, 
    -0.01749081f, -0.02465261f, -0.04282980f, 0.02422344f, -0.07402650f, -0.01377962f, -0.02709739f, 0.04508691f, 
    0.04918732f, -0.11678034f, -0.04824525f, -0.00329958f, -0.01139811f, 0.04624910f, -0.00365741f, 0.01040115f, 
    0.07565362f, 0.00885904f, 0.00631180f, 0.02779393f, -0.00414536f, -0.05667724f, -0.10100415f, -0.09744330f, 
    -0.23573683f, 0.02167285f, -0.06537259f, 0.15322527f, -0.01048906f, 0.04980723f, -0.11579569f, 0.06971480f, 
    0.02916827f, -0.03572073f, 0.04847834f, -0.04470534f, -0.02428188f, 0.01752795f, -0.07666913f, 0.08722088f, 
    -0.04622366f, -0.06166865f, -0.05153137f, -0.02943047f, -0.31262919f, 0.23511493f, 0.08042176f, 0.03261578f, 
    -0.16584130f, 0.09094287f, -0.00674098f, 0.02548200f, 0.05141217f, -0.03700260f, -0.00975531f, -0.02481708f, 
    -0.07687493f, -0.03001342f, 0.06639170f, 0.02057483f, -0.00349596f, -0.19375086f, 0.02367514f, -0.01145710f, 
    -0.17522733f, -0.11127459f, -0.07950407f, -0.14040707f, -0.06866166f, 0.09593934f, -0.03873206f, 0.02239471f, 
    0.02883337f, -0.06831281f, 0.07060052f, 0.00105687f, -0.00973904f, 0.00196521f, 0.04509293f, -0.01440655f, 
    -0.10425557f, -0.05674436f, 0.16329090f, -0.14263557f, -0.23604712f, 0.12551413f, 0.03714363f, 0.11524393f, 
    -0.37909943f, -0.02742331f, 0.00376960f, -0.02532898f, 0.05526112f, -0.02244078f, -0.03314518f, -0.04486693f, 
    -0.01571089f, 0.04252417f, 0.00997325f, -0.04442835f, -0.00351054f, -0.00927075f, -0.04561536f, -0.05032631f, 
    0.11871306f, -0.00805207f, 0.00434139f, 0.03887932f, -0.03463802f, 0.07696680f, 0.05781392f, -0.03754772f, 
    -0.07700838f, -0.02047139f, 0.02426902f, 0.01610986f, -0.04393372f, -0.07600542f, -0.04828823f, 0.03462227f, 
    -0.11911251f, 0.02901194f, -0.02807547f, -0.03253491f, 0.04960772f, -0.16240498f, -0.00905199f, -0.20159762f, 
    0.15672517f, -0.06473196f, -0.05871928f, -0.01144158f, -0.09492498f, -0.09149060f, 0.10397642f, 0.01029516f, 
    -0.01412634f, 0.01827754f, -0.08455749f, 0.07233838f, -0.03904651f, 0.10126392f, -0.03380538f, 0.10484606f, 
    -0.25007394f, 0.05000902f, -0.01805239f, 0.19364594f, 0.02835884f, -0.06372276f, -0.02505532f, -0.06304382f, 
    0.01048955f, 0.02906843f, 0.05018946f, 0.06496968f, 0.02070148f, 0.02560709f, 0.00570208f, -0.04672873f, 
    0.00261374f, -0.11884420f, -0.06208877f, -0.19915886f, 0.10147815f, -0.53348225f, -0.16857181f, -0.02150736f, 
    -0.03864255f, 0.02677311f, 0.07552655f, 0.00728276f, -0.02093853f, -0.02914299f, -0.00598552f, 0.07151918f, 
    0.05795869f, 0.08404452f, 0.04600891f, -0.00495625f, 0.08609787f, -0.05284125f, -0.12085717f, -0.02114381f, 
    -0.00132043f, -0.01382538f, 0.03558299f, 0.03436076f, 0.15688464f, 0.02989225f, 0.01793085f, -0.06970339f, 
    -0.07328087f, -0.12327006f, -0.11398932f, 0.01817005f, -0.02671942f, 0.04584648f, 0.05376220f, 0.04144236f, 
    0.03187807f, 0.17665194f, 0.11076752f, 0.00832383f, -0.22610193f, 0.14621605f, -0.16200303f, 0.20050058f, 
    -0.05758049f, -0.00200804f, 0.03325472f, -0.01350054f, 0.06264914f, 0.07062384f, 0.03516240f, -0.02038608f, 
    0.02809668f, -0.04094628f, -0.05965623f, -0.15293860f, 0.04894388f, -0.01807813f, -0.03458597f, 0.03263202f, 
    0.21553960f, -0.30256724f, -0.15599523f, 0.10034274f, 0.01477110f, 0.05080638f, 0.05163501f, 0.03335540f, 
    -0.02383695f, 0.01537122f, 0.03485473f, 0.03728510f, 0.06712540f, 0.00761507f, 0.01126692f, 0.04331817f, 
    -0.03600780f, -0.00495077f, -0.14352173f, 0.13582450f, 0.14513430f, 0.13489069f, 0.01619176f, -0.07621260f, 
    -0.00057458f, -0.08470539f, -0.08675443f, 0.02434319f, -0.02844250f, -0.03268648f, -0.02301827f, 0.01886802f, 
    -0.05519526f, 0.03848094f, 0.01318348f, 0.05600303f, 0.00219020f, 0.08551631f, 0.03276083f, 0.09294391f, 
    -0.13850224f, -0.23067723f, -0.05008944f, -0.44143465f, 0.10587697f, -0.10862300f, -0.08827331f, -0.06130438f, 
    0.02203926f, -0.05434588f, -0.06508145f, 0.06275886f, 0.00973665f, 0.04476692f, 0.02150945f, -0.00142878f, 
    -0.03375464f, -0.05792303f, -0.02578339f, -0.01097728f, 0.22112291f, -0.27754298f, -0.06275977f, 0.00782997f, 
    -0.12685572f, -0.01242199f, 0.06126614f, 0.04339740f, 0.00685187f, 0.06433624f, -0.05669732f, 0.05114008f, 
    0.01967288f, -0.00713914f, 0.15882118f, 0.04646375f, 0.02619130f, -0.14484574f, 0.04595213f, -0.12007757f, 
    0.20246914f, 0.02679797f, 0.06323653f, -0.03308412f, 0.15581074f, 0.01355673f, -0.06632064f, 0.01917237f, 
    0.11510233f, 0.03985967f, -0.06054525f, -0.02242019f, -0.04520682f, -0.07238241f, -0.00119960f, 0.01205184f, 
    0.03360375f, 0.04472418f, 0.03214675f, -0.00187559f, -0.06118763f, 0.13954002f, -0.03030284f, 0.04187794f, 
    0.12729016f, -0.06110260f, 0.15294039f, 0.00598705f, 0.10934225f, 0.01989634f, 0.07473982f, 0.05442978f, 
    0.06000939f, 0.02040109f, -0.15177134f, 0.04625826f, 0.00436741f, 0.03697113f, -0.01273277f, 0.07332940f, 
    0.01813872f, -0.08074979f, -0.01228771f, 0.08982997f, 0.02976564f, -0.10076021f, 0.01552806f, -0.02865659f, 
    0.00153846f, 0.03051934f, -0.12322280f, -0.02594659f, -0.02817064f, 0.00475627f, -0.01826532f, -0.04255826f, 
    -0.01877366f, 0.05207811f, -0.03122034f, 0.01187803f, 0.12612876f, 0.08415443f, 0.07505922f, -0.02356635f, 
    0.01091473f, -0.01978280f, 0.08435442f, 0.00281554f, -0.01804130f, 0.00402601f, -0.12162532f, -0.00453574f, 
    -0.02417614f, 0.05537246f, 0.01111276f, 0.10774035f, 0.02326964f, -0.00263101f, 0.02103462f, 0.04263394f, 
    -0.11558894f, 0.17735647f, 0.16289033f, -0.01049039f, -0.16371481f, 0.07381688f, -0.04977940f, 0.07655055f, 
    0.00754410f, -0.05368288f, -0.01559657f, -0.02514156f, -0.08010001f, 0.01780518f, 0.01370570f, 0.04901793f, 
    -0.01365397f, -0.05321179f, 0.01188131f, -0.05830261f, -0.03389036f, 0.11386555f, -0.05828458f, -0.13365613f, 
    -0.13521545f, -0.04584339f, 0.02218766f, 0.04859513f, 0.04159890f, -0.02579509f, -0.07645323f, -0.01046532f, 
    -0.12223370f, -0.04328553f, -0.10616644f, 0.05075750f, -0.11319640f, 0.12836210f, 0.08815324f, 0.11315697f, 
    0.15838502f, -0.06990671f, 0.01083965f, 0.02952333f, 0.32871172f, -0.04604607f, -0.08255294f, -0.04227335f, 
    0.06200584f, -0.08342916f, -0.08060540f, -0.03034812f, -0.06430952f, 0.06128605f, 0.07231088f, -0.04293702f, 
    -0.05793564f, -0.00038192f, -0.04141334f, 0.06701553f, 0.05733188f, -0.07902317f, -0.11723931f, -0.41732407f, 
    0.06011422f, -0.04646518f, 0.04533952f, -0.08839303f, -0.05031371f, -0.16329624f, -0.05504706f, -0.01068144f, 
    0.00346238f, 0.00534563f, 0.00435163f, 0.11486346f, -0.00925552f, 0.03562783f, 0.02892684f, 0.10992959f, 
    0.10788940f, -0.15546694f, 0.05374957f, 0.04203668f, 0.14312810f, -0.00936413f, 0.00022304f, 0.03319852f, 
    -0.05045967f, 0.00107997f, 0.02280176f, -0.01559788f, -0.03829984f, 0.05587429f, 0.09951890f, -0.07537123f, 
    0.00578203f, 0.03810365f, -0.01890474f, -0.08572726f, -0.15034257f, -0.25305018f, -0.01944426f, -0.07122580f, 
    -0.00063154f, -0.00329330f, -0.05638973f, 0.03732582f, -0.02592801f, -0.01731370f, 0.01161498f, 0.01215422f, 
    0.08911738f, 0.08113375f, -0.00503085f, -0.04471358f, -0.00754047f, -0.08062746f, 0.02770566f, -0.03548871f, 
    -0.13564298f, -0.17167696f, -0.02606039f, -0.10237048f, 0.31194422f, 0.00618819f, 0.09862458f, 0.04844680f, 
    0.01786160f, -0.00514694f, -0.01988633f, -0.07120267f, 0.02223415f, 0.03028215f, 0.05022889f, 0.00749953f, 
    0.05150509f, 0.15701956f, 0.09100412f, 0.10856832f, -0.03571425f, -0.04008475f, 0.03508282f, 0.04558012f, 
    0.11237092f, 0.03246337f, -0.04465144f, -0.01299234f, 0.00459295f, -0.04552014f, 0.02836480f, -0.03465553f, 
    0.05841453f, -0.01339724f, -0.01190568f, -0.05785650f, 0.02367809f, 0.01658414f, 0.06648481f, 0.02411106f, 
    0.10435023f, -0.35407367f, 0.01867684f, -0.21818528f, 0.07605441f, -0.01831101f, -0.01625247f, 0.00109931f, 
    -0.05818466f, -0.05856505f, 0.04337544f, -0.03550489f, 0.10398017f, 0.10393476f, -0.02719682f, -0.00572735f, 
    0.00270956f, -0.04458957f, -0.09151634f, 0.02859318f, 0.15465873f, 0.01680338f, -0.01974088f, -0.10835466f, 
    -0.01691213f, -0.00484372f, 0.01238873f, 0.09868756f, -0.00372830f, -0.03137642f, -0.04732952f, -0.07909469f, 
    0.10625370f, -0.00201881f, 0.03204111f, 0.03019278f, 0.06419171f, 0.04939142f, 0.02021347f, 0.13373166f, 
    0.01283165f, 0.01622419f, -0.06150925f, -0.20633198f, 0.06894969f, -0.01177463f, -0.04110488f, -0.00093145f, 
    -0.07391997f, -0.06504659f, 0.02108966f, -0.02868988f, -0.01514604f, -0.03856340f, -0.00608968f, -0.03334329f, 
    -0.09611066f, 0.02797213f, -0.00379458f, 0.03770978f, 0.16993490f, -0.21351008f, -0.06835505f, -0.05812754f, 
    -0.04099210f, 0.00987862f, 0.04851971f, 0.01833552f, -0.07714576f, -0.08723538f, -0.06981192f, 0.02853734f, 
    0.13465394f, 0.01466237f, -0.00032961f, 0.09807290f, -0.03700220f, -0.00845464f, 0.03258387f, 0.02473552f, 
    0.06560637f, -0.26811317f, 0.00786504f, 0.10141566f, -0.20059444f, 0.07831684f, 0.16316576f, 0.00979157f, 
    -0.12102449f, -0.07618681f, -0.06981266f, -0.06059114f, 0.12774299f, 0.09361126f, 0.06027034f, 0.04308069f, 
    -0.03422448f, 0.06063161f, -0.02273506f, -0.22815464f, 0.13553508f, -0.00973593f, -0.00356062f, 0.05865901f, 
    -0.03342697f, 0.07063814f, 0.01423305f, -0.01595538f, -0.07656097f, -0.02674713f, -0.02510019f, 0.05858426f, 
    0.10586901f, 0.00016811f, -0.05858607f, -0.00339397f, -0.02757394f, 0.07017905f, -0.00816679f, -0.01042113f, 
    -0.04768399f, -0.03488072f, -0.09121131f, 0.20580693f, -0.03164414f, -0.10645992f, 0.13468292f, -0.05662576f, 
    0.01505615f, -0.02354339f, -0.02114646f, 0.05311236f, 0.02448182f, 0.00742113f, 0.05340700f, 0.09644353f, 
    -0.04224932f, 0.10064685f, -0.09671135f, -0.00295555f, -0.08037202f, 0.21315277f, 0.12945624f, -0.03144434f, 
    -0.50483239f, 0.12657429f, 0.06375220f, 0.03689478f, 0.10827880f, -0.00626493f, -0.02068656f, 0.02024529f, 
    -0.02918085f, 0.00457127f, -0.00441051f, -0.00832057f, -0.09420061f, 0.00350794f, -0.01778383f, -0.01329372f, 
    -0.18020082f, 0.23635536f, 0.04971446f, 0.02496059f, -0.26839972f, -0.01258885f, 0.09996839f, -0.02191465f, 
    0.05770491f, 0.02616204f, 0.03452044f, 0.03012379f, 0.05269722f, -0.03406361f, -0.11428735f, 0.04478736f, 
    0.00778982f, 0.04969182f, -0.05866908f, -0.06275790f, 0.05476372f, -0.12635705f, -0.10587847f, 0.07703810f, 
    -0.01144821f, -0.06554735f, 0.14719778f, -0.01661959f, 0.05130827f, -0.00165652f, -0.03935045f, 0.02988679f, 
    -0.02085853f, -0.00114083f, 0.12978196f, -0.03222915f, 0.02321549f, 0.07289479f, -0.14979355f, 0.05700414f, 
    -0.10189453f, 0.03598388f, -0.01188292f, -0.21804553f, 0.09179792f, -0.04650086f, -0.06305639f, 0.03966089f, 
    -0.06061008f, 0.05004408f, -0.02317650f, 0.01036773f, -0.08810521f, 0.02523703f, -0.00262037f, -0.06786423f, 
    -0.02123216f, -0.04862539f, 0.10455248f, 0.01993576f, -0.13094725f, 0.32261828f, 0.04032491f, 0.14446232f, 
    -0.05925326f, -0.06093188f, -0.09180944f, -0.08026891f, -0.00678070f, -0.01999441f, -0.07636897f, 0.08487830f, 
    0.07995046f, 0.03366495f, -0.07588463f, 0.02794346f, -0.04564095f, -0.09282623f, -0.09918013f, -0.09176109f, 
    0.25434259f, -0.27809870f, -0.01442921f, 0.07713860f, 0.02307534f, 0.04622195f, -0.02464385f, 0.05400005f, 
    -0.03329594f, -0.01876350f, 0.00854175f, -0.00043963f, -0.03021655f, 0.00345845f, -0.03865876f, -0.01810342f, 
    -0.03212073f, 0.09789498f, -0.03329587f, 0.06108353f, -0.04038859f, -0.00732745f, -0.04224649f, -0.32663742f, 
    0.02156181f, 0.04640420f, 0.04321846f, 0.10313880f, -0.06947161f, -0.07895184f, -0.02892943f, -0.10029254f, 
    -0.05214320f, -0.03460588f, 0.00155296f, 0.03970313f, -0.01596345f, 0.05114624f, 0.20958962f, 0.04649974f, 
    0.02427426f, -0.06615498f, 0.03791830f, -0.19700629f, 0.21022415f, -0.00173453f, -0.14857379f, -0.02886359f, 
    -0.11116486f, -0.12871550f, -0.01798220f, 0.01797448f, -0.04614285f, 0.02886138f, 0.07053158f, -0.08166123f, 
    0.05154657f, 0.05872473f, 0.01696187f, -0.00678063f, -0.03600716f, -0.31990692f, -0.02002620f, 0.06610617f, 
    0.03032992f, -0.02599656f, 0.07796934f, 0.03963870f, -0.01525214f, -0.02150973f, 0.07622328f, -0.06129941f, 
    0.00404012f, -0.05020610f, 0.11916236f, -0.04288289f, 0.07598089f, 0.03332435f, -0.00775776f, -0.26464888f, 
    -0.34944814f, -0.06253806f, 0.00742140f, -0.15941393f, 0.03832101f, -0.00245803f, -0.04539710f, 0.06014363f, 
    -0.13275252f, 0.03411462f, 0.03153424f, -0.03681173f, 0.03073471f, 0.03129547f, -0.00337752f, 0.00546816f, 
    -0.04598891f, -0.08299880f, 0.17659140f, 0.03937430f, 0.03609562f, -0.03142779f, 0.04319948f, 0.06711589f, 
    -0.01086065f, 0.07236000f, 0.05599652f, -0.05268685f, -0.02040694f, 0.04685372f, 0.01741810f, 0.01641783f, 
    0.05571661f, 0.01488282f, -0.08760537f, -0.06378851f, 0.04768378f, 0.04542687f, 0.01910733f, -0.02434103f, 
    -0.00954465f, -0.09987291f, 0.17667095f, -0.04205470f, 0.07210561f, 0.10700216f, -0.08337111f, 0.07347350f, 
    -0.10070374f, -0.03015013f, -0.11911361f, 0.10415939f, -0.07701626f, -0.08943447f, -0.07437285f, -0.03998649f, 
    -0.01067953f, 0.06938423f, 0.12998714f, -0.06933703f, 0.12152252f, 0.12665588f, -0.14377034f, 0.23947634f, 
    -0.09191381f, -0.09353994f, -0.01652384f, -0.00829488f, 0.07674053f, -0.11001448f, -0.07276343f, 0.06319744f, 
    0.05799274f, 0.08319984f, -0.09681582f, -0.01092692f, 0.00733028f, -0.05174370f, -0.00842767f, -0.06841621f, 
    -0.19850729f, 0.21377128f, 0.03275408f, 0.03227498f, -0.20181198f, -0.02208941f, 0.06479862f, 0.02653852f, 
    0.02974513f, -0.01662512f, -0.01730606f, 0.03136673f, 0.03520267f, -0.06539024f, -0.01286478f, -0.00850275f, 
    -0.05508193f, 0.03525371f, -0.01383794f, 0.04006436f, 0.00066328f, 0.07803988f, -0.02085661f, -0.12540260f, 
    -0.06052139f, 0.07010994f, 0.07584235f, 0.00639022f, 0.05592284f, 0.05568168f, -0.02590945f, 0.03025114f, 
    -0.04379118f, -0.06201809f, -0.18318518f, 0.01604437f, -0.02569287f, 0.10846180f, 0.03803297f, 0.01463028f, 
    -0.29018036f, -0.04441684f, -0.08124371f, 0.10380071f, 0.17956820f, 0.12695549f, -0.00259156f, 0.04061278f, 
    -0.01124146f, 0.01406851f, 0.07093196f, -0.03610875f, 0.03698687f, -0.06973723f, -0.13764322f, 0.02891671f, 
    0.13635774f, -0.13555475f, 0.13470717f, 0.11714604f, 0.05208633f, -0.13686882f, 0.08252510f, 0.01401772f, 
    0.18693119f, 0.02006854f, 0.01041706f, 0.00430386f, -0.03627384f, -0.06141575f, -0.11782259f, 0.03783456f, 
    -0.09248329f, -0.03733979f, 0.05571600f, -0.00410305f, 0.00021778f, 0.14419730f, -0.03858877f, 0.02450778f, 
    0.01064375f, 0.00772712f, -0.17168556f, -0.18098620f, -0.01545904f, -0.03931729f, 0.00647784f, 0.04890513f, 
    0.01131333f, 0.10420529f, -0.05455350f, -0.04752144f, -0.14043963f, -0.02491760f, 0.00179355f, -0.00198516f, 
    0.02857904f, 0.00843272f, 0.05276324f, 0.02853509f, -0.20417514f, 0.19562641f, 0.00975094f, -0.00077578f, 
    0.00172598f, 0.01709691f, 0.02622790f, -0.00496236f, 0.01658605f, 0.08876969f, 0.00222318f, 0.02552429f, 
    0.11754291f, -0.09221368f, 0.12314447f, 0.04172936f, -0.02665745f, -0.01672917f, 0.06472263f, 0.04293737f, 
    -0.16066793f, 0.08248263f, -0.08715561f, 0.10863522f, -0.10787425f, 0.06520154f, 0.04971754f, -0.01429085f, 
    0.00996743f, 0.02981656f, 0.03693599f, 0.09729091f, 0.02723560f, -0.03175999f, -0.02232910f, -0.02783889f, 
    -0.00793376f, 0.00648947f, -0.05892443f, 0.01055375f, 0.00802395f, 0.00487267f, -0.12718274f, -0.01181802f, 
    0.09493720f, 0.09640972f, 0.10120788f, 0.00897911f, 0.06508291f, -0.05935773f, -0.05991079f, 0.03444411f, 
    0.06382971f, -0.05033627f, -0.00517632f, 0.02204805f, 0.00788281f, 0.10674132f, -0.11737813f, 0.08148459f, 
    0.07849164f, -0.07925466f, -0.06257626f, 0.06563517f, -0.02657958f, -0.08586954f, 0.00729801f, 0.03504522f, 
    0.02013573f, 0.06205899f, -0.00251767f, 0.03647831f, -0.09028555f, 0.05143191f, 0.08769648f, 0.03232197f, 
    0.04217248f, -0.08317396f, -0.10592183f, -0.09982802f, -0.15872355f, -0.04864150f, -0.17632909f, -0.09494312f, 
    0.04654357f, 0.05748139f, 0.00136269f, -0.00759787f, -0.10167691f, -0.02524484f, 0.03522294f, -0.05735843f, 
    0.01546255f, -0.06727829f, 0.01269316f, -0.04425271f, 0.06817350f, 0.05203495f, 0.03138930f, 0.06635891f, 
    0.05728656f, -0.06279194f, 0.08805885f, 0.00558513f, 0.08565311f, -0.02659336f, -0.02338225f, -0.00706563f, 
    -0.02977751f, -0.00516987f, 0.00342116f, -0.02170793f, -0.03425431f, -0.04497224f, 0.02209336f, -0.00148497f, 
    -0.00353024f, 0.02911173f, 0.05072950f, -0.00904969f, -0.07030433f, 0.05440841f, -0.09796214f, -0.02287246f, 
    0.05445230f, -0.09284630f, -0.00210070f, -0.08053565f, -0.02378895f, -0.00999061f, 0.00649271f, 0.06915392f, 
    -0.00829738f, 0.00317268f, 0.01679510f, -0.04260479f, -0.02852680f, 0.12101613f, -0.00794280f, 0.01190422f, 
    0.16210730f, 0.03255281f, 0.12893720f, -0.03735626f, 0.08603314f, -0.08441183f, 0.02183561f, -0.05593920f, 
    0.02143116f, -0.01698663f, -0.02531392f, 0.03060172f, 0.00208837f, 0.01119427f, -0.07066396f, -0.02033544f, 
    -0.00025005f, -0.01110357f, 0.02218671f, -0.04545543f, 0.07775231f, 0.01581566f, 0.10669006f, -0.01736786f, 
    0.03491315f, -0.03496359f, 0.05977694f, -0.00421157f, -0.02409550f, 0.06427639f, 0.00688507f, -0.00463672f, 
    -0.06860165f, -0.02087092f, -0.03230542f, -0.05016581f, -0.00129648f, 0.01653041f, 0.02051140f, -0.02713449f, 
    -0.10148907f, -0.05936823f, -0.08635765f, 0.01279376f, 0.14438719f, -0.03911232f, -0.06072996f, -0.07680869f, 
    0.09022322f, -0.05150547f, 0.01709700f, 0.01058721f, -0.05911381f, -0.01006278f, -0.00240351f, -0.00739042f, 
    -0.07147255f, 0.04321738f, -0.00667440f, -0.00811592f, 0.11974674f, 0.01412146f, 0.07424553f, -0.05221727f, 
    0.09742913f, -0.09510589f, 0.03677332f, -0.01858163f, -0.02954071f, 0.00655503f, -0.01350383f, 0.01149383f, 
    -0.04438442f, 0.00903185f, -0.00534599f, -0.01624265f, -0.02859765f, -0.01982631f, -0.03573468f, -0.05069741f, 
    0.08948854f, 0.02293992f, 0.19889666f, 0.04751742f, 0.09909624f, 0.04157712f, 0.08596974f, -0.02697711f, 
    -0.04484035f, -0.02599000f, -0.03691757f, 0.06026014f, -0.02644872f, 0.01614957f, -0.03798076f, -0.00704702f, 
    -0.00271631f, -0.04335131f, 0.03924546f, -0.04672215f, -0.06777664f, -0.01908913f, -0.09053092f, -0.09662046f, 
    -0.06736266f, -0.08082201f, -0.04855686f, -0.00718827f, -0.04256355f, -0.08764242f, 0.01422277f, -0.03870567f, 
    -0.05843154f, -0.03532424f, -0.04964915f, -0.00208633f, -0.01590763f, 0.01179952f, 0.01844376f, -0.03523792f, 
    0.03874625f, 0.10758632f, 0.06517335f, 0.01741713f, 0.09210330f, 0.02449073f, 0.01853578f, -0.00437720f, 
    0.02737119f, 0.00712429f, -0.03818635f, -0.02627723f, 0.00004402f, -0.00144207f, -0.01745532f, -0.01717144f, 
    -0.00276361f, -0.04894252f, -0.04676551f, 0.02340740f, 0.00025590f, -0.16816500f, -0.14493071f, -0.19099459f, 
    -0.11162028f, -0.06056993f, -0.04850163f, -0.02684102f, -0.06847619f, -0.06348411f, -0.03380311f, -0.07397234f, 
    -0.01989390f, -0.04161428f, -0.04565481f, -0.02298743f, 0.03046842f, -0.00301451f, 0.01008620f, 0.05285975f, 
    0.08464276f, -0.14981587f, 0.09218330f, 0.10002370f, 0.13807668f, 0.04313833f, 0.02570327f, 0.00747529f, 
    0.00311467f, 0.04460413f, -0.00356848f, 0.07362038f, -0.00960400f, -0.06421883f, 0.00480076f, -0.06068313f, 
    0.08560456f, 0.05948328f, 0.09944099f, -0.00979500f, -0.13630740f, 0.00734768f, -0.05410953f, -0.08553369f, 
    -0.19773076f, -0.04268308f, 0.00400411f, -0.02003906f, -0.04202594f, -0.04308586f, 0.02093521f, -0.00021445f, 
    -0.03697832f, 0.03602355f, -0.02980288f, -0.01217198f, 0.01280288f, -0.02216877f, -0.01870137f, -0.03688272f, 
    0.14595494f, -0.10576786f, -0.01809939f, 0.00411080f, 0.05765327f, -0.07986142f, -0.04691220f, 0.00065952f, 
    -0.01650093f, -0.01697942f, -0.03824982f, -0.04511897f, -0.04343851f, 0.02250501f, 0.00974809f, -0.05649635f, 
    -0.00211163f, 0.02618569f, 0.02033084f, 0.01089488f, -0.00939194f, 0.06501369f, 0.11077658f, -0.02472996f, 
    0.11922040f, -0.06071834f, 0.06124718f, 0.02325826f, -0.02470299f, 0.01797714f, -0.05906286f, 0.02431099f, 
    -0.10291149f, -0.03225423f, -0.04386218f, -0.01440263f, 0.02822368f, 0.00444050f, -0.01063959f, -0.05813303f, 
    -0.03258306f, -0.02610087f, 0.01188696f, -0.05946729f, -0.09292052f, -0.05056685f, -0.02647049f, -0.00541393f, 
    -0.07186462f, -0.03600705f, 0.05241828f, -0.03306525f, -0.05167188f, -0.03216510f, -0.05339098f, -0.01207509f, 
    0.03201940f, -0.04864907f, -0.01163857f, -0.00632783f, 0.00075550f, -0.03954489f, 0.10511441f, 0.05525371f, 
    0.11415622f, 0.11183847f, 0.05844535f, -0.00523302f, 0.00748910f, -0.08465293f, 0.02009786f, 0.02046441f, 
    0.02231853f, -0.00712253f, -0.01593524f, -0.05058089f, 0.02406774f, -0.00691529f, 0.00764639f, -0.00592037f, 
    -0.02888872f, 0.04154450f, 0.01170931f, 0.06323450f, 0.11079207f, 0.05456014f, -0.11179004f, -0.06956266f, 
    0.02651851f, 0.02235687f, -0.02490084f, 0.06299827f, 0.05516363f, -0.03511366f, -0.03527752f, -0.02159146f, 
    -0.04091898f, 0.04371486f, 0.03289336f, 0.01132056f, -0.28770784f, 0.11271834f, -0.02879565f, -0.06255452f, 
    -0.15239041f, 0.00077463f, 0.03279499f, -0.08461811f, -0.01572814f, -0.07553009f, -0.00095925f, 0.03890397f, 
    -0.00173928f, -0.03638064f, -0.05370384f, 0.00307725f, 0.01403387f, 0.01398537f, -0.00099762f, -0.02437852f, 
    0.10339000f, 0.13893788f, 0.06259046f, -0.01558958f, 0.02992225f, 0.01873465f, 0.03982666f, 0.01072945f, 
    0.01468736f, -0.03387380f, 0.01576585f, -0.01789679f, 0.01765994f, -0.02362856f, -0.00888437f, 0.02839142f, 
    0.02455737f, -0.00552746f, 0.02227385f, -0.02548274f, 0.16339192f, -0.01585330f, 0.00087959f, 0.02660659f, 
    0.13303648f, -0.07392028f, -0.02549386f, -0.05284901f, -0.01691516f, 0.06500832f, -0.00560144f, 0.01869283f, 
    -0.02868997f, -0.01085000f, -0.02867607f, 0.00377383f, -0.01876352f, 0.01303193f, -0.01144119f, -0.01886148f, 
    0.10386708f, 0.08981180f, 0.25363141f, 0.15815435f, 0.13053446f, 0.09652785f, 0.10120417f, 0.02046492f, 
    0.01954952f, -0.04447030f, -0.01196143f, 0.03724141f, -0.03452750f, 0.01480129f, -0.01240185f, -0.02285635f, 
    0.01146673f, 0.03453192f, 0.03333849f, -0.06800766f, 0.12523954f, -0.06494897f, -0.09624666f, 0.02233529f, 
    0.03823686f, 0.02094631f, -0.04609746f, -0.02067736f, -0.06087764f, -0.04912815f, 0.00962878f, -0.04571714f, 
    -0.01882556f, -0.02796633f, -0.01350943f, 0.00134506f, 0.00305354f, -0.04650395f, -0.01639770f, 0.01321999f, 
    0.01099001f, -0.03756332f, 0.03970045f, 0.09379908f, -0.07753652f, 0.05137369f, -0.00576129f, -0.02465984f, 
    0.03026351f, 0.01655279f, -0.06828679f, -0.01676011f, 0.00866087f, -0.02397844f, -0.02343396f, 0.06017155f, 
    -0.05071849f, 0.03117081f, -0.03907854f, -0.02249045f, -0.05813245f, 0.11264798f, -0.06902234f, 0.08032338f, 
    0.10727548f, -0.00588885f, -0.07531611f, -0.03559492f, 0.01572012f, -0.02480299f, -0.01316835f, 0.00010816f, 
    0.05750191f, 0.02436925f, -0.09361837f, 0.02064937f, 0.00519804f, 0.01246575f, 0.00550276f, -0.08340748f, 
    -0.09112284f, -0.03309787f, 0.02881178f, 0.05885290f, -0.07032468f, 0.02703968f, -0.06589053f, -0.03580369f, 
    0.04030155f, 0.00811371f, -0.00384161f, -0.00202963f, -0.00797778f, 0.02020887f, -0.03407818f, 0.04811577f, 
    0.04067017f, -0.01549744f, -0.04894287f, -0.00625104f, 0.03999775f, 0.06297464f, -0.17313850f, 0.05645448f, 
    0.06892683f, -0.14158112f, -0.03351192f, -0.00162508f, 0.02836796f, 0.02043535f, -0.11138071f, -0.03521151f, 
    -0.05407396f, 0.00851245f, -0.03553825f, 0.01659638f, -0.04597031f, -0.01931140f, -0.03364718f, 0.01596227f, 
    0.10735711f, -0.35273293f, 0.05015824f, -0.11766235f, -0.15311806f, -0.04408623f, 0.03095238f, -0.06209304f, 
    -0.01029297f, -0.04617049f, 0.00642819f, -0.01481532f, -0.08388488f, -0.03011772f, -0.07292135f, -0.04174659f, 
    0.08311769f, -0.02705725f, -0.03846581f, 0.00207617f, -0.08628485f, 0.03713294f, -0.18399933f, 0.03999629f, 
    0.09983180f, -0.04192616f, -0.07935247f, -0.07419502f, 0.01387215f, 0.01300593f, -0.05882398f, 0.02488314f, 
    -0.06564493f, -0.02723354f, -0.03226383f, -0.01077211f, -0.02916938f, 0.01329371f, -0.04978626f, 0.05957260f, 
    -0.09025659f, -0.05030530f, -0.12587926f, -0.00082646f, 0.02114290f, -0.02676910f, 0.01309361f, -0.01913456f, 
    0.05356162f, -0.01367313f, 0.00733039f, 0.02079537f, -0.05893206f, 0.00821003f, 0.02799281f, -0.01721757f, 
    -0.08300629f, -0.03269982f, -0.05106096f, -0.04537605f, 0.03731985f, 0.11205773f, 0.15325472f, 0.03141426f, 
    0.14164427f, 0.03052124f, 0.07752208f, 0.01226497f, 0.02572978f, 0.01911885f, -0.04445798f, -0.03507891f, 
    -0.03105987f, -0.00990169f, -0.07770946f, -0.03087470f, -0.04090941f, -0.02801804f, 0.00705403f, 0.00735813f, 
    -0.07805993f, 0.04724571f, -0.13488559f, -0.07169128f, 0.02599217f, -0.05138942f, -0.08028003f, -0.07511652f, 
    0.00654115f, -0.01726996f, 0.03006123f, -0.00515699f, -0.05870586f, 0.00062383f, -0.03343166f, -0.05592296f, 
    -0.04277221f, 0.00659023f, -0.00201755f, -0.02726876f, 0.12039799f, -0.00254137f, 0.11825909f, 0.05765875f, 
    0.03139376f, -0.00595212f, 0.02259423f, -0.00553146f, -0.00864597f, -0.01446477f, 0.00700482f, 0.04544807f, 
    0.00612965f, 0.00179091f, -0.03272141f, -0.03408766f, -0.04819110f, -0.00476999f, 0.04587171f, -0.01756649f, 
    0.00363093f, 0.08327598f, -0.14720097f, 0.07644195f, 0.09202880f, -0.03710939f, -0.05230300f, -0.06146434f, 
    0.00711409f, -0.00148224f, -0.12997040f, 0.05551203f, -0.09274774f, -0.01951490f, -0.04385261f, 0.02391156f, 
    -0.01981336f, 0.00228721f, -0.00767128f, -0.01965548f, 0.07132515f, 0.05404196f, 0.05892013f, 0.02102553f, 
    0.10140558f, -0.04919014f, 0.04404874f, -0.08238011f, 0.00080044f, -0.02994234f, 0.00832266f, 0.01630862f, 
    0.00696453f, -0.03831796f, 0.00044895f, 0.02222290f, -0.00478260f, -0.00036889f, -0.04316736f, -0.00257143f, 
    0.13298896f, -0.02055516f, 0.15143071f, -0.01515062f, 0.01633435f, -0.00409321f, 0.06422693f, -0.01427609f, 
    -0.04115881f, -0.02202563f, -0.01186821f, 0.00370188f, -0.05102807f, 0.00906537f, -0.06757651f, -0.04685260f, 
    0.03891057f, -0.00598358f, 0.01756851f, -0.04465179f, 0.08771284f, 0.04360810f, 0.14025068f, -0.04544687f, 
    0.09297545f, -0.03210090f, 0.01647990f, -0.04302450f, 0.00787166f, -0.00159299f, -0.02814188f, 0.02250279f, 
    -0.02160498f, -0.04422040f, -0.02952781f, -0.00545900f, 0.00419419f, 0.00136316f, -0.00763522f, -0.04508031f, 
    0.02522460f, 0.02253368f, 0.10490175f, 0.05785922f, 0.09639925f, -0.03423947f, 0.05971592f, -0.02562080f, 
    -0.04184865f, -0.03909713f, -0.02912932f, -0.01121160f, -0.08222643f, -0.01118638f, -0.01270779f, -0.04685136f, 
    -0.00783304f, -0.00098866f, 0.00583089f, -0.01526792f, 0.06248090f, -0.02925263f, 0.14229663f, 0.04645958f, 
    0.13578482f, 0.00700060f, 0.08031058f, 0.00475864f, 0.06779914f, 0.01184345f, -0.03209857f, -0.02088746f, 
    0.00385082f, -0.03930786f, 0.00032890f, -0.04393080f, -0.02480040f, -0.02089662f, -0.03259530f, -0.04904108f, 
    0.12208568f, -0.22799383f, 0.03126485f, -0.04750276f, -0.05512697f, -0.01073624f, 0.02469120f, 0.05914855f, 
    0.03741519f, -0.06871387f, 0.01989739f, -0.03968604f, 0.01540290f, 0.05252205f, -0.00939310f, -0.05361041f, 
    0.06081775f, -0.00249172f, -0.02745968f, -0.09875145f, 0.10998649f, -0.02432008f, 0.05823749f, 0.03302627f, 
    0.02226764f, 0.04112303f, 0.03065058f, -0.00686767f, -0.00802200f, 0.03408059f, -0.02931831f, -0.02514781f, 
    -0.01343567f, 0.01448896f, -0.01667529f, -0.01534757f, 0.01195312f, 0.01458313f, 0.00815185f, 0.01330514f, 
    -0.14366351f, 0.15891740f, 0.01946151f, -0.00856539f, -0.05083631f, -0.09338988f, -0.03689025f, -0.08678260f, 
    0.02468778f, -0.05310858f, 0.01885376f, -0.00787367f, -0.03021209f, 0.01484833f, -0.07350181f, 0.04136415f, 
    0.04543205f, -0.04604318f, -0.03760728f, -0.05091785f, -0.18102019f, -0.02374784f, -0.17269799f, 0.03084148f, 
    -0.18963745f, -0.07986537f, -0.01223548f, -0.00858527f, -0.00553426f, -0.07385013f, 0.01203454f, 0.02168418f, 
    -0.05332417f, 0.06240301f, -0.06950350f, 0.02283706f, -0.03770925f, 0.01807514f, -0.03701127f, -0.06201112f, 
    -0.27229536f, 0.00369504f, -0.18915355f, -0.01991147f, -0.13794601f, -0.01583310f, -0.04665344f, -0.06317186f, 
    0.01440220f, -0.07291987f, -0.05595610f, -0.01856195f, 0.03102912f, -0.02884141f, -0.04437277f, -0.00960237f, 
    0.05703920f, 0.01002976f, 0.01321272f, 0.05169327f, -0.17369583f, 0.13327242f, 0.07340380f, -0.00517605f, 
    -0.05437804f, -0.02622812f, -0.03585018f, -0.01028340f, -0.00565279f, -0.03055288f, 0.00862277f, 0.03009576f, 
    0.00002438f, -0.01333698f, -0.02526646f, 0.00446087f, 0.03250273f, 0.03939934f, -0.01575666f, 0.00530869f, 
    0.01926052f, 0.13461091f, 0.13440496f, 0.03285622f, 0.05676616f, 0.02522174f, 0.05441914f, -0.04991077f, 
    -0.02721315f, -0.01972585f, -0.01570823f, -0.00598308f, -0.07850111f, -0.01114656f, -0.00394317f, 0.01410408f, 
    0.01193874f, 0.02006300f, 0.05211601f, -0.01946166f, -0.05709299f, -0.19802710f, -0.19048896f, -0.02385810f, 
    0.04501132f, 0.00812470f, -0.02254969f, 0.03759496f, 0.00936466f, -0.05862295f, -0.03247751f, -0.04717135f, 
    -0.04140846f, 0.06864924f, -0.00389673f, -0.04976313f, 0.06301183f, -0.03809552f, -0.05673663f, 0.06540219f, 
    0.12285674f, 0.01987213f, 0.03019087f, 0.02332260f, -0.13007388f, 0.12832606f, 0.02267780f, 0.02479886f, 
    0.01949411f, -0.01811354f, -0.04174141f, 0.01280354f, 0.01882543f, -0.00227132f, -0.00100335f, 0.06195582f, 
    0.07015648f, 0.02925573f, 0.04523581f, -0.01326043f, 0.09730444f, 0.07683898f, 0.04385380f, 0.06963103f, 
    0.13836296f, -0.05839765f, 0.00657520f, -0.07428704f, -0.04182680f, -0.00098768f, 0.00641839f, 0.02498588f, 
    -0.01098727f, -0.04685166f, -0.03931262f, 0.03036898f, -0.00616764f, 0.01847780f, 0.05327376f, -0.01014118f, 
    0.07101192f, 0.13449064f, 0.12202601f, 0.11136771f, 0.12669528f, 0.06107758f, 0.03929775f, -0.00760295f, 
    -0.02175714f, -0.01463015f, -0.01779633f, 0.07513386f, -0.03486920f, -0.00977656f, -0.00973967f, 0.00348774f, 
    0.05812228f, 0.07188194f, 0.08981940f, -0.07518005f, 0.16541174f, -0.10545090f, -0.03263276f, 0.00680304f, 
    0.01192849f, 0.03684238f, -0.04100526f, 0.00827530f, -0.08547321f, 0.04344595f, 0.02975742f, 0.02190095f, 
    -0.04277628f, 0.03331358f, 0.01065659f, -0.12548147f, -0.02166090f, -0.04775203f, 0.06751382f, -0.05691928f, 
    0.13449492f, -0.05388412f, 0.16330448f, 0.02151519f, 0.02767197f, 0.07256924f, -0.00522200f, -0.03499845f, 
    -0.02197506f, 0.04375086f, 0.00246240f, 0.08141678f, -0.00107758f, 0.00069680f, -0.03314716f, -0.05649152f, 
    -0.00273562f, -0.01260093f, 0.03914823f, -0.03103098f, -0.05913564f, 0.12329117f, -0.06276934f, -0.03682550f, 
    0.02761878f, -0.04287225f, 0.06608734f, -0.12780407f, 0.00844258f, -0.00679521f, 0.01390740f, 0.04597191f, 
    -0.01184739f, -0.01039824f, -0.00942724f, -0.00206385f, 0.00344155f, 0.03542106f, -0.05965966f, 0.06553720f, 
    0.19005759f, -0.39755341f, 0.17777841f, 0.07135420f, -0.17533596f, 0.08584656f, -0.02963201f, -0.04700065f, 
    -0.02124180f, 0.01248268f, -0.03069811f, 0.00096419f, -0.01917126f, 0.00114442f, -0.10012808f, -0.00815891f, 
    0.11692572f, -0.03643584f, -0.07277206f, -0.01760957f, -0.23501994f, 0.03138342f, 0.06805405f, 0.02814168f, 
    -0.17429005f, 0.11159474f, -0.09887023f, -0.00560091f, 0.05331532f, -0.03445837f, -0.05760045f, -0.00105446f, 
    -0.00195726f, -0.02063456f, 0.05955471f, -0.04301693f, 0.02081452f, 0.01570929f, 0.02446404f, -0.01149128f, 
    -0.04474193f, 0.00952947f, -0.19361924f, -0.02487028f, -0.02811040f, -0.02459442f, -0.10225556f, -0.02809782f, 
    -0.01557967f, -0.05003033f, -0.06747424f, 0.03515901f, 0.02265537f, -0.04602747f, -0.08897354f, 0.01560356f, 
    -0.00705162f, -0.04117354f, 0.02677662f, 0.01659084f, -0.17449924f, -0.11452419f, -0.10370289f, -0.00035342f, 
    0.10601950f, -0.00237065f, -0.14236216f, -0.09033896f, -0.01005839f, -0.01795707f, -0.03713063f, 0.06760459f, 
    0.00665321f, 0.00676749f, 0.00737663f, -0.03020208f, 0.02781154f, 0.02194890f, 0.00106079f, 0.10922655f, 
    0.05691324f, 0.15352623f, 0.05385526f, -0.10525871f, 0.10350010f, -0.02454093f, 0.06209096f, -0.09138910f, 
    -0.04495594f, -0.02555296f, 0.01969309f, 0.00812717f, 0.00703305f, -0.05888322f, -0.02660870f, -0.00594334f, 
    -0.00693544f, 0.02121386f, -0.02623866f, 0.02231461f, -0.20282030f, 0.12338796f, -0.10865251f, -0.03651970f, 
    -0.04860093f, -0.02096021f, -0.02480126f, -0.08121061f, 0.05844114f, 0.01127339f, -0.05628074f, 0.00895259f, 
    -0.01723135f, -0.03843904f, 0.02342370f, -0.07719030f, -0.08815806f, 0.06778604f, -0.03267440f, 0.00316983f, 
    0.08298777f, 0.12072202f, 0.03851233f, 0.01928392f, 0.12490966f, -0.04736860f, -0.02607104f, -0.05980982f, 
    -0.03790739f, -0.03402077f, -0.02002514f, -0.00731957f, -0.02180608f, -0.03558153f, -0.03406776f, -0.01149142f, 
    0.01840704f, 0.03054130f, -0.01466307f, -0.00602526f, -0.03023875f, -0.07062785f, -0.15878923f, -0.01631157f, 
    0.03760479f, -0.03473109f, -0.08621700f, -0.05488215f, -0.01048028f, -0.04520161f, -0.05287450f, 0.01144040f, 
    -0.02946857f, -0.00464110f, -0.01401052f, 0.02935709f, -0.03164776f, -0.05394563f, -0.01910403f, -0.02668124f, 
    -0.15192629f, 0.09470004f, -0.15345056f, -0.13232663f, -0.10632563f, 0.02073972f, 0.03122226f, -0.08924492f, 
    0.00788403f, 0.00077259f, -0.03882655f, 0.01696168f, -0.01906288f, -0.03702824f, -0.01183569f, -0.03047632f, 
    -0.02123370f, -0.00805402f, -0.02789754f, 0.03003094f, -0.04728289f, 0.13742782f, 0.18416163f, 0.00681701f, 
    0.11283968f, -0.05979540f, 0.01756159f, -0.00783899f, -0.02972666f, -0.02650709f, -0.02526858f, 0.00981061f, 
    0.00692564f, -0.02043498f, -0.06509919f, 0.03187077f, -0.04356979f, 0.02059456f, -0.00029382f, -0.04189425f, 
    0.05461758f, -0.02301173f, -0.06438912f, -0.01504523f, -0.07350196f, -0.03737068f, -0.07897285f, 0.00255670f, 
    -0.04574354f, -0.05761794f, 0.00148466f, -0.00506553f, -0.01658033f, -0.05444039f, -0.06836284f, -0.01199032f, 
    -0.00214976f, -0.03786922f, -0.05402826f, -0.00862061f, 0.11627359f, 0.00158048f, 0.14090990f, 0.06788223f, 
    0.11116690f, 0.02659233f, -0.00032543f, -0.03372708f, -0.08893508f, 0.03981874f, 0.01190169f, 0.01661821f, 
    -0.01325444f, -0.02136293f, -0.03587292f, -0.03229842f, 0.02785128f, -0.00434623f, 0.06145498f, 0.03117169f, 
    -0.09475209f, -0.12977432f, 0.03887723f, -0.15315416f, -0.11871551f, -0.07428922f, -0.02304454f, 0.01413368f, 
    -0.06067279f, -0.07928574f, -0.01786200f, 0.02107295f, -0.00557616f, 0.04803882f, -0.00751446f, 0.01679982f, 
    -0.03622849f, -0.03518383f, -0.10129312f, 0.04783411f, -0.01061613f, 0.07724953f, -0.05067788f, -0.14337794f, 
    -0.12265126f, -0.12080016f, -0.00511666f, -0.03739765f, -0.00396880f, -0.02897955f, 0.02462957f, 0.06665816f, 
    0.08329944f, 0.03393922f, 0.00465478f, 0.10323917f, 0.00618157f, -0.13016379f, 0.00337889f, 0.10247639f, 
    -0.16608498f, 0.19339935f, 0.00430518f, -0.09426411f, -0.09167451f, 0.07044516f, 0.01994797f, -0.05187769f, 
    -0.00489329f, 0.03479794f, -0.01577348f, 0.01994943f, 0.02174683f, 0.01646148f, 0.06224528f, -0.03090329f, 
    -0.05917504f, -0.03532698f, -0.08814715f, 0.05595487f, 0.05484945f, 0.17547666f, -0.08864345f, 0.01305589f, 
    0.09802040f, -0.06379837f, -0.01105412f, 0.02482499f, -0.03423333f, -0.00098710f, 0.03289596f, -0.03968525f, 
    -0.04374788f, -0.01786832f, 0.06690559f, 0.00983761f, -0.00609914f, -0.02442841f, 0.05711430f, 0.05300120f, 
    -0.03408160f, 0.13876028f, 0.07524689f, -0.01079793f, 0.08810396f, -0.08084067f, -0.07914639f, -0.03012529f, 
    -0.05416334f, -0.11086403f, 0.07419649f, 0.01325165f, -0.01111244f, -0.02025113f, -0.00219000f, -0.03711434f, 
    0.01711976f, -0.02568019f, 0.03955938f, -0.00401764f, -0.01529181f, -0.06662720f, -0.00662046f, -0.09170096f, 
    -0.03735707f, 0.02298034f, 0.04082939f, 0.00985463f, -0.09727275f, -0.01188985f, -0.05146933f, -0.03307774f, 
    0.05528395f, -0.01818111f, -0.02341492f, -0.03054515f, 0.00369305f, -0.03473036f, 0.00545594f, 0.00356841f, 
    -0.15494163f, -0.11872614f, 0.22703141f, -0.01727032f, 0.14522591f, 0.01707695f, 0.05948305f, 0.03866226f, 
    -0.06883542f, -0.04286291f, 0.02654516f, -0.04330944f, 0.01783865f, -0.02646445f, 0.05405391f, -0.00767761f, 
    -0.03483799f, 0.01212475f, 0.00139941f, 0.05588361f, 0.12022580f, 0.05600224f, -0.03842108f, 0.10618529f, 
    0.09781294f, 0.03427203f, -0.01416037f, -0.05391410f, -0.05128191f, -0.03996686f, -0.00037014f, -0.00729574f, 
    -0.03416096f, -0.03303402f, -0.03617565f, -0.03239867f, 0.02244712f, -0.00585740f, 0.06195774f, 0.01943514f, 
    -0.20055373f, 0.01792550f, -0.14066117f, -0.10666065f, -0.17638902f, 0.02158839f, -0.00345792f, -0.01642143f, 
    0.00661048f, -0.04709210f, 0.02480311f, -0.00509739f, -0.05661416f, -0.06007190f, 0.04283429f, -0.05396959f, 
    -0.00632883f, -0.02228743f, 0.03847821f, -0.03965126f, 0.00621212f, -0.14196433f, 0.05508953f, 0.00214451f, 
    0.12943923f, 0.09397423f, 0.10424653f, -0.07862458f, 0.02178071f, -0.02375248f, 0.01788114f, 0.03319946f, 
    0.00614659f, -0.06023966f, -0.00301459f, -0.07500248f, -0.02736710f, 0.08367708f, 0.00775160f, -0.01648178f, 
    -0.18659119f, -0.19523776f, 0.12219815f, -0.17506263f, -0.02767565f, 0.01976008f, 0.02012254f, 0.03466184f, 
    -0.08700410f, -0.02055817f, 0.03996883f, -0.01593997f, 0.02967606f, 0.06237422f, 0.09015384f, 0.01292793f, 
    0.00876652f, 0.07163643f, -0.24888767f, 0.02831754f, 0.11809074f, 0.09578292f, -0.16610788f, 0.14121504f, 
    0.08403958f, 0.07315137f, 0.04249154f, -0.06766661f, -0.01338931f, -0.04540816f, 0.01087905f, 0.02103344f, 
    -0.00924929f, -0.03738225f, 0.04452329f, -0.09106675f, -0.01945270f, -0.00502646f, 0.08380151f, -0.08588514f, 
    0.01958631f, -0.13470522f, -0.02397116f, -0.16620184f, -0.02511678f, 0.00593629f, -0.00988248f, -0.03415063f, 
    -0.08501194f, -0.05948701f, -0.07505392f, 0.01997999f, 0.03095845f, 0.02813531f, -0.01031528f, 0.08579949f, 
    -0.01240256f, 0.04540931f, -0.13423580f, 0.02725370f, -0.01332783f, 0.08703092f, 0.05308769f, -0.01717245f, 
    -0.12916002f, -0.10640781f, -0.01567203f, 0.01749534f, -0.04294889f, 0.05306311f, 0.04208725f, -0.04512849f, 
    -0.01731309f, -0.09580082f, -0.01448758f, -0.02117307f, -0.00798523f, -0.10302562f, 0.03457259f, -0.02251378f, 
    0.13801125f, 0.15182813f, -0.05077742f, 0.05831248f, 0.09453057f, 0.08387242f, -0.01990851f, -0.01497131f, 
    -0.06058948f, -0.02568708f, 0.03226110f, 0.00748188f, -0.01971748f, -0.03320043f, -0.04804169f, -0.04301586f, 
    0.03353487f, 0.04648385f, 0.02748283f, -0.02375266f, 0.03644437f, -0.10274195f, 0.12597774f, 0.02006902f, 
    0.17006125f, -0.09765041f, -0.04950937f, -0.01550758f, -0.08680166f, -0.01165615f, 0.00351602f, -0.02119564f, 
    -0.03904356f, -0.15809755f, 0.02463002f, 0.02489165f, -0.05163840f, 0.05214322f, 0.05975821f, 0.05460050f, 
    -0.16462457f, 0.02168523f, -0.13316835f, -0.14392683f, -0.20164564f, -0.00598806f, -0.04729082f, -0.10605807f, 
    -0.02647433f, -0.00857331f, 0.05468255f, 0.00853797f, 0.03614214f, -0.03104095f, 0.02319101f, 0.02370021f, 
    -0.06304345f, -0.11444347f, 0.03530727f, 0.08065356f, 0.03842074f, 0.11959796f, -0.15434021f, 0.04757934f, 
    0.03376012f, 0.05500902f, 0.03855184f, -0.06078891f, -0.00298291f, 0.02191713f, 0.02371498f, 0.01562705f, 
    -0.00929856f, 0.03425232f, 0.03665221f, -0.01213672f, -0.01589001f, -0.01448633f, 0.08435485f, 0.01246314f, 
    0.05281892f, -0.15334322f, -0.00086027f, -0.00232869f, -0.05545144f, -0.04171466f, -0.05004827f, -0.00835140f, 
    -0.00576687f, -0.01574614f, 0.05190004f, -0.01559926f, -0.00039689f, -0.02452667f, 0.07658201f, 0.04607074f, 
    -0.05177500f, -0.02643911f, 0.02016269f, 0.03683475f, -0.18871097f, -0.12764741f, -0.08812854f, -0.11058521f, 
    -0.06321534f, 0.10490813f, -0.01470671f, 0.00432871f, -0.06962681f, 0.00520390f, 0.00191024f, -0.01571308f, 
    -0.03329368f, 0.04249267f, -0.06681511f, -0.03303396f, 0.03951328f, 0.02248050f, -0.09510345f, -0.00710681f, 
    -0.21254839f, -0.04292746f, 0.19223507f, 0.06026010f, 0.12190746f, -0.05781195f, -0.00443213f, 0.00166473f, 
    -0.02818272f, -0.06979467f, 0.01524718f, -0.02513415f, -0.12044626f, -0.04195501f, 0.02436425f, -0.04208857f, 
    0.04202506f, 0.02423083f, -0.04519237f, 0.05425147f, 0.10162265f, -0.00356751f, 0.08387426f, -0.12412179f, 
    0.15615425f, -0.00843896f, -0.00701462f, -0.04663995f, 0.00480252f, -0.05668452f, 0.01753487f, -0.02955226f, 
    0.02035293f, -0.11138835f, -0.01204720f, -0.00809433f, -0.06522847f, 0.08976503f, 0.00124788f, 0.05360423f, 
    -0.13743702f, 0.04200614f, -0.17611668f, 0.01976945f, 0.00212273f, 0.11389820f, -0.05762729f, -0.03894567f, 
    0.03130960f, 0.02744413f, 0.05070016f, 0.02112646f, 0.00076186f, 0.05469695f, 0.01517728f, -0.00006300f, 
    0.00274849f, -0.04346352f, -0.00325173f, -0.08133058f, -0.15563668f, -0.11416214f, -0.15888683f, -0.07839616f, 
    -0.02213885f, 0.06135033f, -0.04613950f, -0.07862630f, -0.01176942f, -0.00689873f, 0.08202752f, 0.00822638f, 
    0.06444429f, -0.06274355f, 0.09827025f, -0.04401702f, -0.00167661f, -0.01484550f, 0.01704587f, -0.03605282f, 
    0.03237347f, 0.02841014f, -0.08540613f, 0.02802870f, 0.04748337f, -0.04166971f, -0.06007138f, -0.10376970f, 
    -0.04876394f, 0.06788222f, -0.01644225f, -0.04384898f, -0.01697697f, -0.01061249f, -0.03497146f, -0.02367784f, 
    0.04034373f, -0.04803786f, 0.08096454f, 0.02396355f, -0.06971700f, -0.03545894f, -0.08114886f, -0.08528917f, 
    -0.01726102f, -0.01147870f, 0.03695701f, -0.09598158f, -0.06444070f, -0.03698589f, 0.08146483f, 0.00747273f, 
    0.06253459f, 0.05232439f, 0.02635265f, -0.01751842f, 0.08289589f, -0.02808962f, 0.01031045f, -0.00576109f, 
    0.06078504f, -0.10446125f, -0.09757572f, 0.07972714f, 0.11081817f, 0.03373914f, 0.04526395f, -0.01629132f, 
    -0.06236114f, -0.00240013f, -0.01068283f, 0.04606739f, -0.01516396f, -0.02118522f, -0.01206619f, 0.00970858f, 
    -0.01614697f, 0.04837408f, 0.03008252f, -0.02885122f, -0.17163990f, -0.08301806f, 0.01168288f, -0.14495933f, 
    0.00264168f, 0.02199345f, 0.00509652f, -0.01946600f, -0.05336545f, -0.05035141f, 0.04933024f, 0.00660638f, 
    0.00574698f, -0.00467920f, -0.10002171f, -0.03150178f, 0.03133815f, 0.02657918f, -0.06258773f, -0.08774877f, 
    0.11245418f, 0.15185988f, 0.03365449f, 0.04740135f, 0.01784078f, -0.01903406f, -0.03153506f, -0.04276428f, 
    -0.07228744f, -0.02924165f, 0.09606595f, -0.03793957f, 0.04121237f, 0.02843962f, -0.06695271f, -0.05008915f, 
    -0.00397691f, 0.03059044f, 0.04805295f, -0.10663950f, -0.04299233f, 0.07025686f, 0.06750833f, -0.15158711f, 
    -0.11976969f, 0.04498827f, 0.00472655f, 0.01939094f, -0.06460778f, -0.01855659f, 0.01296220f, -0.02359547f, 
    -0.03959934f, 0.02388122f, -0.01779575f, -0.00793740f, -0.03789824f, -0.04658472f, -0.10271994f, -0.08761044f, 
    -0.00751809f, 0.05486562f, 0.01576635f, 0.02564381f, 0.03644436f, 0.06627738f, -0.01311479f, 0.00436504f, 
    -0.04539736f, -0.07285992f, 0.04673748f, -0.01377891f, 0.02980446f, 0.02116000f, -0.01417098f, -0.03576836f, 
    0.02949124f, 0.06625129f, -0.00435638f, -0.01364075f, 0.03094971f, -0.06004798f, 0.11877358f, 0.04732076f, 
    0.15546867f, -0.05246219f, -0.08006059f, 0.02943394f, -0.05376013f, 0.03448692f, -0.00720489f, -0.07004389f, 
    -0.02228767f, -0.03358021f, 0.05966396f, 0.00541508f, -0.03956882f, 0.05903049f, 0.04480550f, 0.08762850f, 
    -0.17291208f, 0.08968203f, 0.06431529f, -0.08947311f, -0.14555667f, -0.01753478f, 0.00855558f, -0.00272770f, 
    -0.07380635f, -0.10968295f, 0.07463626f, 0.06320546f, -0.00700462f, 0.07657890f, -0.01893819f, -0.11326104f, 
    0.05753733f, -0.11271197f, 0.00780803f, -0.04769991f, -0.10804696f, 0.12953231f, -0.20095733f, -0.03030876f, 
    -0.08501922f, -0.02883032f, -0.04576127f, -0.02914962f, -0.03521187f, 0.00166148f, 0.03898538f, 0.02771931f, 
    -0.07636755f, 0.08038736f, 0.03860912f, -0.00517579f, -0.03753727f, -0.06858121f, 0.02975203f, 0.03673667f, 
    -0.00523579f, 0.02611545f, 0.13167782f, 0.07509693f, 0.14196834f, -0.08246068f, -0.03919695f, 0.09066994f, 
    -0.00866330f, -0.00970787f, 0.05966537f, -0.06464712f, -0.05449174f, -0.05070103f, 0.01390425f, 0.03119454f, 
    -0.01020586f, 0.00580650f, 0.04833130f, 0.02423604f, -0.07765014f, -0.00973776f, 0.09998380f, -0.08216576f, 
    -0.02106900f, 0.02996506f, -0.02692708f, 0.01145234f, -0.06189113f, -0.01060682f, -0.00072397f, -0.01561598f, 
    -0.01838188f, 0.00707370f, 0.00336047f, 0.02210843f, 0.03375779f, -0.01336593f, 0.00146741f, 0.02016847f, 
    -0.11893785f, 0.06134012f, 0.12634082f, -0.10150557f, -0.11200862f, 0.01938914f, 0.02546420f, -0.06163395f, 
    0.01456354f, -0.07118048f, 0.04653651f, 0.03489807f, 0.04864356f, 0.02255364f, -0.00354406f, 0.02496079f, 
    -0.02419756f, -0.04003694f, -0.08938572f, -0.00322634f, -0.14015861f, -0.13964234f, 0.09561517f, -0.10483757f, 
    -0.06066416f, 0.03492529f, -0.00848171f, 0.01335665f, -0.06661803f, 0.05467610f, 0.04112352f, -0.01663891f, 
    0.00999189f, 0.05507594f, -0.00867303f, -0.05666265f, -0.03300127f, -0.02484730f, 0.02612158f, -0.04119668f, 
    0.21526174f, -0.03951379f, -0.17697492f, 0.11264160f, 0.07196108f, -0.04948513f, -0.02696695f, -0.00134453f, 
    -0.06427686f, -0.03036972f, -0.01617724f, -0.00727211f, 0.01360132f, 0.06448543f, 0.01107584f, 0.04220163f, 
    -0.03752986f, -0.02450516f, 0.05052579f, 0.05002526f, 0.00262373f, -0.18347578f, -0.08406965f, -0.06043797f, 
    -0.06417347f, 0.01534711f, -0.00052892f, -0.00149225f, -0.01933520f, 0.03128942f, 0.05473645f, 0.02753115f, 
    0.00817959f, 0.05323618f, -0.01732185f, 0.01978188f, -0.00215152f, -0.03122219f, -0.06105610f, -0.01029568f, 
    0.13176537f, 0.06467861f, -0.10225724f, 0.04065098f, -0.03660718f, -0.01555026f, -0.02342822f, -0.15871190f, 
    -0.03923716f, -0.00939706f, 0.03745674f, -0.01878521f, 0.08190296f, -0.06002354f, 0.02551169f, -0.03773146f, 
    -0.00726671f, -0.06361519f, 0.14132030f, -0.05409215f, 0.05878945f, -0.02570836f, -0.24396293f, 0.17990229f, 
    0.12238592f, 0.08972640f, 0.06592740f, -0.04764799f, -0.02652411f, -0.04432026f, 0.04782290f, 0.00979719f, 
    0.05983020f, 0.03668004f, 0.07650173f, -0.02218929f, -0.04761424f, -0.07162046f, 0.07157255f, -0.07852949f, 
    0.08082289f, -0.00619126f, -0.17408541f, 0.00393278f, 0.09396470f, 0.02089560f, 0.04238430f, -0.01437114f, 
    0.01072695f, 0.03584021f, 0.00734903f, 0.02234536f, -0.00429623f, 0.06473168f, 0.04948422f, 0.01643016f, 
    0.03413865f, 0.07585008f, 0.06252679f, 0.02611386f, 0.10810261f, 0.01082498f, -0.05823389f, 0.06597868f, 
    -0.04025443f, -0.05366655f, -0.03137754f, -0.00905337f, -0.01060091f, 0.01906640f, 0.04222787f, -0.04687780f, 
    0.03625266f, 0.02804672f, 0.06737858f, 0.04527365f, 0.06818050f, -0.01632462f, 0.08309327f, 0.00518304f, 
    -0.20909916f, 0.04142174f, 0.14142381f, -0.06809700f, -0.11473230f, -0.00042614f, 0.02068213f, -0.00188748f, 
    0.05820734f, 0.01719902f, 0.01170365f, 0.04127792f, 0.04960516f, -0.05582871f, -0.04464169f, 0.00711673f, 
    0.00605079f, -0.03080826f, -0.06490923f, -0.01751021f, 0.13742326f, 0.04367803f, -0.09780711f, 0.02438908f, 
    0.16024637f, 0.12585905f, 0.05032705f, -0.01354091f, -0.05680253f, -0.00076877f, 0.00176872f, 0.01231138f, 
    0.00312950f, 0.01572668f, -0.13151434f, 0.00617794f, 0.03378210f, 0.08145849f, 0.01057234f, -0.04769983f, 
    0.07446419f, 0.05585364f, -0.26149336f, 0.06380609f, -0.01169960f, -0.04502408f, -0.03777186f, -0.07545533f, 
    0.03093293f, -0.03060854f, 0.05072460f, -0.01256433f, -0.02416948f, -0.00641674f, 0.10681580f, 0.06357834f, 
    0.01980150f, -0.05005919f, 0.05038251f, 0.02256259f, -0.16728480f, -0.00848234f, 0.08451640f, -0.26953569f, 
    -0.09327421f, 0.04202243f, 0.04165745f, -0.00803280f, 0.07547222f, -0.01735011f, -0.01989815f, 0.00512770f, 
    -0.07110691f, 0.04600450f, -0.03324120f, -0.01705774f, 0.02370053f, 0.06951635f, -0.08440714f, -0.04929385f, 
    -0.15975352f, -0.05143049f, 0.05170042f, -0.09242179f, -0.20843320f, 0.03684784f, -0.01157603f, -0.01213035f, 
    0.01541067f, 0.00060122f, 0.03481767f, 0.01800550f, 0.03632645f, -0.07270786f, 0.05725269f, 0.03448445f, 
    0.00948985f, -0.08734570f, -0.06506713f, -0.06461960f, 0.08243271f, -0.02211981f, 0.10796826f, -0.02430321f, 
    0.09387570f, 0.02126122f, 0.01692146f, 0.04922964f, -0.10305724f, -0.02304598f, 0.00547902f, 0.02534891f, 
    0.10184882f, 0.09815565f, 0.02305817f, 0.08275340f, 0.01664944f, 0.09811258f, -0.18080655f, 0.10786568f, 
    -0.08967441f, -0.08900841f, 0.17240708f, -0.07652731f, 0.07436831f, -0.07541998f, -0.02545399f, 0.05108708f, 
    -0.00056858f, 0.04493100f, -0.01182184f, -0.00615683f, 0.03344656f, 0.00006330f, 0.03712379f, -0.01526174f, 
    -0.06796165f, 0.06849424f, -0.08092336f, 0.03251454f, -0.07350025f, 0.09304190f, -0.08462124f, -0.10706418f, 
    -0.08467005f, 0.02295475f, -0.00826963f, -0.00999054f, 0.02213918f, -0.00877778f, 0.09151864f, -0.00936084f, 
    -0.03073115f, 0.05278639f, 0.01478467f, 0.04757971f, -0.02992611f, -0.06952111f, 0.03760446f, 0.02087830f, 
    -0.00073410f, 0.15630993f, -0.10744959f, 0.01676088f, 0.03683533f, -0.03503868f, -0.05532771f, -0.04627799f, 
    -0.06101330f, 0.05833339f, 0.00473187f, 0.04617639f, -0.00837538f, -0.00289518f, -0.02966554f, 0.03972148f, 
    0.02705476f, -0.06572922f, 0.10157263f, 0.05624244f, 0.00122020f, 0.14522257f, -0.06737146f, -0.01258678f, 
    0.01768301f, 0.03597680f, -0.10429625f, -0.12354668f, 0.02614548f, -0.04752269f, 0.08966554f, 0.00159431f, 
    0.06128360f, -0.02278656f, 0.05250591f, -0.02248915f, 0.01024216f, 0.00961496f, 0.05694753f, 0.01397033f, 
    -0.09187281f, -0.03269079f, -0.04322264f, 0.03197297f, 0.06502844f, 0.02588980f, 0.04400045f, -0.06151817f, 
    -0.00318097f, -0.01501468f, 0.05550746f, 0.03563322f, 0.04318949f, -0.04549735f, 0.06819523f, -0.06575617f, 
    0.00582388f, 0.03301962f, 0.05311069f, -0.04069219f, -0.09312999f, -0.05749920f, -0.13784118f, -0.25899422f, 
    -0.07298926f, 0.09114999f, -0.04370136f, 0.00713724f, 0.06956193f, -0.08417365f, 0.05248364f, 0.01934967f, 
    -0.02292927f, -0.00831885f, 0.02874414f, 0.09310139f, -0.03335964f, 0.00116390f, -0.01437018f, -0.08453955f, 
    -0.18321885f, 0.15629824f, -0.01648766f, -0.08207190f, -0.09555860f, 0.02335276f, -0.01830428f, 0.02437766f, 
    0.03076508f, -0.02702321f, 0.02290419f, -0.00111632f, -0.00896508f, 0.03016785f, 0.05006674f, -0.03671577f, 
    -0.04759742f, -0.01525012f, -0.00381917f, 0.03856925f, 0.03514177f, 0.11944019f, 0.02900565f, -0.02539009f, 
    -0.04343922f, -0.05838349f, -0.00258927f, 0.00339501f, -0.07818240f, -0.03945512f, 0.08415537f, 0.08801669f, 
    0.05021506f, 0.05304173f, -0.05766105f, -0.04558350f, 0.06017905f, -0.01968944f, 0.05660459f, 0.00417718f, 
    -0.19227549f, -0.05415605f, -0.00159308f, -0.22091427f, -0.15292418f, 0.00787890f, 0.02399911f, -0.03915830f, 
    0.05570681f, -0.04071595f, 0.03982718f, 0.00529505f, -0.01418703f, 0.02124603f, -0.00190999f, -0.00668880f, 
    0.05958427f, -0.02312851f, -0.06934963f, -0.03633823f, -0.10332387f, -0.01890767f, 0.02592652f, 0.07169420f, 
    0.03612247f, 0.03066667f, 0.01370466f, -0.08659901f, -0.05944263f, -0.03438515f, 0.03078805f, 0.00687134f, 
    0.04106321f, -0.00717371f, 0.02304394f, -0.04121941f, 0.00889454f, 0.03602764f, 0.03963080f, -0.06089510f, 
    -0.09849444f, 0.09464851f, -0.12955719f, -0.09112611f, -0.07692195f, 0.08320533f, 0.00628530f, -0.07605559f, 
    0.05908234f, -0.03250080f, 0.04045394f, 0.01939617f, 0.02195120f, -0.00460669f, 0.07664090f, -0.06621508f, 
    -0.00494864f, -0.04312993f, 0.07508933f, -0.07347556f, 0.00651692f, 0.20409507f, -0.10306237f, 0.01686759f, 
    -0.08327311f, -0.01901246f, 0.00978708f, -0.04431555f, -0.07871082f, 0.01698906f, -0.01646512f, -0.02991892f, 
    0.07588501f, 0.03072426f, 0.04682677f, 0.03483017f, -0.03775951f, -0.04885240f, -0.00044170f, 0.05419412f, 
    0.07513393f, 0.00690494f, 0.03997836f, 0.03551948f, 0.06619586f, 0.00338530f, 0.01345327f, -0.02415193f, 
    -0.01569388f, -0.02136827f, -0.04670646f, -0.04705250f, -0.03666158f, -0.05125802f, 0.01124044f, 0.00973462f, 
    -0.05568190f, 0.02861015f, 0.03024692f, 0.01350363f, -0.10678586f, -0.06493009f, 0.12265345f, -0.16138157f, 
    -0.05944073f, 0.03841692f, 0.01283188f, -0.06205755f, -0.02669469f, -0.04374733f, 0.01542629f, 0.03810666f, 
    -0.07707744f, 0.08478524f, -0.03907768f, 0.02614965f, 0.06807020f, 0.01933011f, -0.25473800f, 0.07609800f, 
    -0.03850171f, -0.07546615f, -0.09668260f, -0.01345452f, 0.16070247f, -0.05543838f, 0.06756676f, 0.07072366f, 
    -0.00904437f, 0.00653614f, -0.03263189f, 0.01971502f, -0.05718846f, -0.04331396f, 0.00452674f, 0.01628413f, 
    -0.00929855f, 0.10288594f, 0.05565529f, 0.07824855f, -0.10978513f, 0.14245622f, 0.05251315f, -0.19411956f, 
    -0.00462985f, 0.02456591f, 0.07991494f, -0.07447419f, -0.05338589f, -0.03815719f, -0.07096672f, -0.00238571f, 
    -0.08165347f, -0.06635671f, -0.04339172f, -0.01498473f, -0.02129153f, 0.04822482f, 0.03652195f, 0.00607947f, 
    -0.21257105f, -0.09199724f, -0.04995204f, 0.09626227f, -0.17175730f, -0.03042318f, 0.03377269f, -0.04473547f, 
    -0.06954157f, 0.03708203f, 0.10389137f, 0.07593022f, 0.08276832f, 0.06544519f, 0.00305224f, -0.03817196f, 
    -0.05600204f, -0.07019306f, 0.02244099f, -0.10009827f, -0.24705754f, 0.11551872f, -0.09185473f, 0.13012330f, 
    -0.13657770f, 0.04066893f, 0.05950831f, 0.01758153f, 0.04603989f, -0.01664281f, 0.00180606f, -0.01581721f, 
    0.05913628f, 0.02317422f, 0.03974922f, -0.01947729f, -0.09965224f, 0.06022864f, -0.03614406f, -0.04767524f, 
    0.55641001f, -0.00741060f, -0.22290815f, -0.12764867f, 0.00756635f, 0.05483955f, 0.04995842f, 0.03948637f, 
    0.00041043f, -0.08251769f, -0.07204469f, 0.05044495f, -0.02394883f, 0.18699792f, -0.11802904f, 0.02488782f, 
    0.06037941f, -0.01698353f, -0.00676384f, 0.03854467f, 0.02751584f, -0.11772649f, -0.08739591f, -0.04736692f, 
    0.05430546f, 0.04462159f, 0.07115573f, 0.00729956f, 0.00254462f, 0.05829825f, -0.12223556f, 0.05876308f, 
    -0.07699227f, 0.09985376f, 0.03585455f, -0.04186234f, -0.03277266f, 0.01015248f, 0.03858609f, 0.00670854f, 
    0.27671066f, -0.16402169f, -0.07482347f, 0.06359237f, 0.06899545f, 0.03170690f, 0.00626244f, -0.02793092f, 
    0.01169184f, 0.05342054f, -0.07250345f, 0.08832310f, 0.02069936f, 0.01434586f, 0.01879930f, 0.00461198f, 
    -0.02644438f, 0.00297233f, 0.05064445f, 0.01590773f, -0.03411835f, -0.04381102f, -0.05485138f, -0.01297545f, 
    -0.11252709f, 0.08112463f, 0.06009621f, 0.00835874f, -0.05989650f, -0.01305253f, 0.01453979f, -0.01975037f, 
    -0.04922327f, 0.01280626f, -0.05838135f, 0.01247026f, 0.00134727f, -0.04913693f, -0.08882793f, -0.06296350f, 
    -0.00910628f, -0.02122947f, 0.03986450f, 0.01640838f, 0.02058364f, -0.09667198f, -0.02299410f, 0.06559044f, 
    0.09429251f, 0.02237958f, -0.00368507f, 0.08078846f, 0.09230389f, 0.03321123f, 0.05317460f, 0.04763132f, 
    0.03071452f, 0.06894448f, 0.02058649f, 0.10956696f, 0.18166745f, -0.20124198f, 0.09343003f, 0.10782321f, 
    -0.21246427f, 0.00834421f, 0.14246729f, 0.12739889f, -0.05073273f, 0.00241860f, -0.00147124f, 0.02037622f, 
    0.10202146f, -0.11199304f, -0.08505652f, 0.03059897f, 0.06445490f, -0.08709691f, -0.03139212f, -0.04842449f, 
    0.15502433f, -0.04362757f, 0.04199726f, 0.06517179f, -0.05832832f, -0.03863377f, 0.02414564f, -0.02392653f, 
    -0.08741719f, 0.00246897f, 0.06142643f, -0.10764884f, 0.09701379f, -0.01558049f, -0.01207402f, 0.10783547f, 
    0.13735089f, -0.00736859f, -0.00379576f, 0.05203865f, -0.17278130f, -0.01311655f, 0.08177945f, -0.02980977f, 
    0.02392061f, 0.07662898f, 0.02780164f, -0.05021055f, -0.00820679f, -0.06844551f, 0.02316380f, 0.01469453f, 
    -0.02975619f, -0.02311900f, -0.00617575f, 0.04020686f, -0.03093526f, 0.03312956f, -0.20682985f, 0.05332751f, 
    -0.02307212f, 0.07875539f, -0.00190498f, -0.20051795f, -0.05527794f, -0.00121236f, 0.05070835f, -0.00781009f, 
    0.01328603f, 0.06546216f, -0.07049429f, 0.00406684f, -0.01697681f, 0.04983374f, -0.00323056f, -0.09230828f, 
    0.03835905f, 0.04711836f, 0.12827827f, 0.04221157f, -0.24402651f, 0.12325066f, -0.12377107f, 0.10164737f, 
    -0.00350688f, 0.14425527f, 0.03028013f, -0.03152564f, 0.04689028f, 0.14268410f, -0.12488797f, -0.01571750f, 
    -0.02356354f, -0.03972948f, 0.08639310f, 0.06085299f, -0.05710527f, 0.01299915f, -0.03261941f, -0.03453858f, 
    0.07503115f, -0.06312662f, -0.02344791f, -0.01053977f, -0.14545240f, 0.04127871f, 0.02981608f, 0.00705004f, 
    -0.06093509f, -0.12044844f, 0.04091205f, -0.00107696f, -0.02735437f, 0.02347360f, 0.02320252f, -0.01592950f, 
    -0.02852654f, -0.09642694f, -0.03044505f, -0.02649966f, 0.25217187f, -0.11932542f, 0.05423893f, -0.08095072f, 
    0.02111701f, 0.08054215f, -0.07794469f, 0.01997550f, -0.06856966f, 0.14185044f, -0.02616513f, -0.01300175f, 
    0.00892068f, 0.08599695f, 0.00216083f, -0.01873723f, 0.05527296f, -0.08088621f, -0.00534949f, -0.07748283f, 
    -0.06833685f, -0.12452780f, -0.06290754f, 0.01539333f, 0.06098950f, -0.07423954f, 0.00800698f, 0.10624130f, 
    0.05681768f, 0.00499025f, 0.01646609f, -0.07894219f, -0.07276837f, -0.04192665f, -0.07515483f, 0.05388944f, 
    -0.03752323f, 0.05874500f, -0.02547719f, 0.04375307f, -0.09335243f, 0.12969771f, 0.28037071f, 0.04174802f, 
    -0.11659919f, 0.09233724f, 0.03928536f, 0.05942989f, 0.02774811f, -0.01240748f, -0.00699500f, 0.00802821f, 
    0.09141244f, -0.08252577f, 0.01675449f, 0.00400588f, -0.01079631f, 0.05258111f, -0.08309641f, 0.02451838f, 
    -0.21946985f, 0.03788351f, -0.02548549f, 0.04784434f, 0.22632112f, 0.10391875f, -0.05702028f, -0.00690239f, 
    -0.06570233f, 0.10542643f, 0.03597071f, -0.06037435f, 0.02963270f, 0.06336117f, -0.02516470f, -0.01377257f, 
    0.02928780f, -0.06982721f, 0.00735697f, -0.07061844f, 0.06687970f, -0.14015910f, -0.05295385f, -0.05369835f, 
    -0.18347371f, 0.00404699f, 0.02717422f, 0.00709337f, 0.01043645f, 0.03370539f, 0.01322732f, 0.01079661f, 
    0.01471014f, 0.05370720f, -0.06262924f, -0.04341964f, -0.03683922f, -0.00892414f, 0.02241716f, 0.06797940f, 
    -0.04602035f, -0.20052966f, -0.07201837f, 0.18045147f, 0.01988807f, -0.00922031f, -0.00279707f, -0.02579727f, 
    0.00197212f, 0.04663003f, -0.04687951f, -0.08057255f, -0.03886583f, 0.03870545f, 0.11689912f, -0.04181266f, 
    -0.10244307f, 0.04955147f, 0.00351935f, 0.06557262f, 0.06766253f, 0.01975096f, 0.00751309f, -0.16825026f, 
    -0.01561971f, 0.02579767f, -0.03458910f, 0.00917121f, 0.01188398f, 0.03341564f, 0.04681828f, -0.01458872f, 
    0.00219229f, 0.14601526f, -0.05948371f, 0.02971476f, -0.04718144f, -0.11722722f, -0.08574914f, -0.07233329f, 
    -0.08475509f, -0.23767906f, 0.04301839f, -0.06366193f, 0.19835062f, -0.03345873f, 0.01337835f, -0.09063631f, 
    -0.03130494f, -0.04929031f, 0.10239778f, -0.08316337f, -0.03624720f, 0.00681428f, 0.00309368f, 0.05318038f, 
    -0.02100421f, -0.00858203f, -0.00275355f, 0.01415153f, -0.21144606f, -0.07662637f, 0.07501539f, -0.17109874f, 
    -0.02164274f, -0.10156842f, 0.06908500f, -0.09274300f, -0.02041447f, 0.11049258f, -0.09120295f, -0.02673924f, 
    -0.01964420f, 0.05923666f, 0.05723101f, 0.11232001f, 0.06142417f, -0.03324117f, -0.01022150f, -0.05330483f, 
    0.16859411f, -0.32706094f, 0.03100339f, -0.04857003f, 0.09156944f, -0.02391148f, 0.03126876f, 0.00986902f, 
    0.06791050f, -0.00609350f, 0.01187882f, 0.06946510f, -0.04885034f, 0.10950390f, -0.00694688f, -0.02836357f, 
    0.00189366f, 0.06226564f, -0.06634159f, 0.00471807f, -0.16680233f, -0.06012992f, -0.15372057f, 0.00766312f, 
    -0.32925850f, -0.04332299f, 0.04543427f, -0.00641143f, 0.00235283f, 0.02045315f, -0.00944910f, -0.02885902f, 
    -0.01888165f, 0.05093744f, 0.02915318f, -0.03146881f, 0.07384453f, 0.06235520f, 0.08942703f, -0.01120499f, 
    0.24019261f, -0.31494799f, 0.12116028f, -0.00169401f, -0.07462833f, 0.03662318f, 0.07707233f, -0.06252456f, 
    0.02138858f, -0.02995363f, -0.01856134f, 0.01175211f, 0.02574443f, 0.00559515f, -0.11042426f, -0.03959146f, 
    0.00050574f, 0.00540332f, 0.00911031f, -0.00060980f, 0.10855221f, -0.07728508f, 0.08911675f, -0.21177286f, 
    -0.28135017f, -0.06527993f, 0.00916750f, 0.04795748f, -0.06863544f, 0.07253890f, -0.05747345f, -0.00543239f, 
    0.03613967f, -0.08459380f, 0.01898446f, -0.03017556f, 0.08124489f, -0.01845735f, 0.04870445f, 0.04639740f, 
    0.33387977f, -0.04228590f, -0.22549589f, -0.01721754f, -0.16350512f, -0.02786673f, 0.07277565f, 0.15004596f, 
    0.06672235f, -0.05222240f, -0.02657544f, 0.05125974f, 0.06643005f, 0.08875357f, -0.02657299f, 0.09676203f, 
    0.03454429f, 0.07466580f, -0.00125994f, 0.06972466f, -0.10518476f, -0.13581133f, -0.10021975f, 0.10151685f, 
    0.06353493f, -0.09539455f, -0.00160513f, -0.02358200f, -0.02901141f, 0.10942268f, -0.06433008f, 0.00354592f, 
    0.01499204f, 0.07412067f, 0.01615177f, 0.08693211f, 0.00175921f, 0.01589987f, 0.03665191f, -0.01551338f, 
    0.29580659f, 0.05313640f, -0.10314307f, 0.13183077f, -0.02350416f, 0.04260501f, 0.02699957f, 0.05867711f, 
    -0.00583213f, -0.05085629f, -0.00725351f, 0.03070924f, 0.01797916f, 0.03094642f, -0.04503376f, -0.08328386f, 
    -0.00606372f, -0.14841890f, -0.01545988f, 0.06211489f, 0.09436869f, -0.03675029f, -0.06071791f, 0.10899604f, 
    -0.02231398f, -0.00882573f, -0.02715079f, -0.06910688f, 0.10703053f, 0.04298621f, -0.07325291f, 0.04926114f, 
    -0.02078715f, -0.08485968f, 0.00380514f, -0.04263458f, 0.00997944f, -0.00953657f, -0.04586505f, 0.00149386f, 
    0.30419534f, 0.13062759f, -0.12433498f, -0.02399177f, -0.08996992f, -0.01002344f, -0.01324371f, 0.03075726f, 
    0.01909859f, -0.00088262f, -0.00845666f, -0.13173340f, -0.01863552f, -0.03596046f, 0.00843077f, 0.07848142f, 
    0.02708327f, -0.05719800f, -0.11305372f, 0.07309355f, -0.22301430f, 0.02620970f, 0.00454658f, 0.06312457f, 
    -0.14981449f, 0.01162756f, -0.02028826f, -0.10506457f, 0.00243395f, 0.02490768f, 0.08084297f, 0.02138410f, 
    0.01912721f, 0.05011432f, 0.02877101f, -0.02465306f, -0.01897909f, -0.04921456f, 0.02398667f, 0.11167470f, 
    0.09607975f, -0.10113558f, -0.07966405f, 0.09317636f, -0.01870537f, 0.06317356f, 0.06015032f, -0.03939700f, 
    -0.00117302f, 0.10869296f, -0.03245486f, 0.00226282f, -0.04454302f, -0.01585806f, 0.00066656f, -0.01249535f, 
    -0.01726430f, -0.02208256f, -0.00700939f, -0.02409901f, 0.05591546f, -0.03269725f, 0.02792931f, 0.11433093f, 
    0.06137255f, -0.00205935f, 0.00857538f, -0.07764857f, 0.01233537f, 0.07924449f, -0.09381337f, 0.14675465f, 
    -0.01813872f, 0.02621204f, -0.03967869f, -0.01739699f, -0.02187133f, -0.04934475f, 0.05271488f, -0.03687709f, 
    -0.10156400f, -0.12860544f, -0.09729957f, 0.11750507f, 0.09906501f, -0.07258436f, 0.03167195f, 0.03552509f, 
    -0.09912372f, -0.02143997f, 0.03375772f, -0.04215316f, -0.09334567f, -0.03178384f, 0.00170472f, 0.02605051f, 
    -0.00385177f, 0.02450875f, 0.06273597f, 0.08559422f, 0.07346863f, -0.21191862f, 0.14246212f, -0.01440015f, 
    0.10029126f, -0.09440074f, 0.01269132f, 0.02126313f, -0.04171348f, 0.06224307f, 0.00877682f, -0.08793559f, 
    0.00848411f, 0.11020613f, 0.03451802f, 0.01617480f, 0.08316249f, 0.00287351f, 0.05290178f, 0.02822829f, 
    -0.08690959f, -0.10461517f, 0.07780526f, 0.06187574f, -0.09959568f, 0.11426128f, -0.10353806f, -0.06471399f, 
    0.02716346f, -0.09994732f, -0.07805123f, -0.01499627f, -0.06782625f, 0.03614543f, 0.12797029f, -0.05020957f, 
    0.03946552f, -0.03768701f, 0.00719091f, 0.13013017f, -0.08744819f, -0.12449607f, 0.14066295f, -0.04989867f, 
    0.11565465f, -0.00349820f, 0.03368063f, 0.05745434f, -0.07173511f, -0.01714083f, 0.12969504f, -0.03964058f, 
    -0.00817678f, -0.04181733f, 0.01223066f, -0.05359015f, -0.02513207f, -0.07946129f, 0.09577538f, 0.08104547f, 
    -0.36532906f, 0.09781350f, 0.28226823f, -0.15356632f, 0.11132996f, 0.10056594f, 0.05879255f, 0.03599305f, 
    -0.02360012f, -0.02379739f, 0.02275698f, -0.01504460f, 0.04832957f, 0.06177160f, -0.01404831f, 0.01357234f, 
    0.03449371f, 0.04034677f, -0.09933865f, 0.08911669f, -0.16399072f, -0.11708803f, 0.10937964f, -0.09085175f, 
    0.07370090f, 0.06472144f, 0.02818570f, -0.10155996f, 0.00439438f, -0.02274554f, 0.06601847f, 0.01779054f, 
    -0.01326731f, -0.05622121f, -0.04230290f, 0.09251256f, 0.02362779f, 0.05580750f, -0.08558886f, 0.00611287f, 
    -0.05855273f, 0.07915281f, 0.06744342f, -0.25030839f, -0.23297411f, -0.00043893f, 0.02216530f, 0.00320082f, 
    -0.09095094f, 0.01465186f, -0.06506342f, 0.00775175f, -0.03555169f, -0.09005482f, 0.02203771f, -0.03484672f, 
    -0.02014635f, -0.06331017f, 0.06202215f, 0.00059853f, -0.27575433f, 0.08131395f, 0.01363535f, 0.12916963f, 
    0.10489027f, 0.09574667f, -0.03753012f, -0.07427019f, -0.02096893f, 0.06185999f, 0.11148436f, 0.05048319f, 
    -0.03887481f, -0.02522327f, -0.15970264f, 0.03420648f, -0.09812511f, 0.07738759f, -0.00077703f, 0.04513910f, 
    -0.13269813f, -0.13373348f, 0.05420974f, 0.05357975f, -0.01070054f, 0.03737184f, 0.03093440f, -0.00267033f, 
    0.03764441f, -0.03930524f, -0.06813639f, -0.00284609f, 0.02076265f, 0.03291650f, 0.05582141f, 0.01184947f, 
    0.00626981f, 0.04947387f, 0.01862972f, 0.01715560f, 0.14281076f, -0.12948804f, 0.18104962f, -0.25387117f, 
    -0.29674780f, 0.08490945f, 0.08271785f, 0.03420973f, -0.08206990f, -0.08553324f, -0.21200477f, 0.00375405f, 
    -0.00462541f, 0.07818446f, 0.04519729f, -0.08449451f, 0.09035333f, 0.03828527f, 0.15562917f, 0.03810596f, 
    0.10483475f, -0.26255479f, 0.16510554f, 0.02229719f, 0.24245445f, 0.05116041f, 0.03591176f, -0.10726674f, 
    -0.05655602f, -0.09139522f, 0.03210068f, -0.08621179f, -0.08969600f, 0.08603124f, 0.07747429f, -0.04413736f, 
    0.07338305f, -0.18235382f, -0.04476248f, 0.10588003f, 0.22288403f, -0.01814115f, -0.07772536f, 0.03914228f, 
    -0.09102812f, -0.15456790f, -0.03225568f, 0.10050324f, -0.02431266f, 0.01240197f, 0.01624305f, 0.02507555f, 
    0.13389884f, -0.02515717f, 0.09679425f, 0.07463870f, 0.02423129f, 0.00919385f, 0.01769768f, 0.10557801f, 
    -0.10475627f, -0.03270557f, -0.10274246f, 0.15165058f, -0.08010237f, 0.02409020f, 0.03581459f, -0.01282701f, 
    0.02087406f, 0.02194235f, 0.03181634f, -0.08216406f, -0.15938155f, -0.04017504f, 0.04474773f, 0.11396089f, 
    -0.10187288f, 0.04509287f, -0.00400802f, 0.05923513f, 0.13483056f, 0.04613091f, -0.11466614f, -0.00684348f, 
    -0.08731180f, 0.00847772f, -0.03388446f, -0.01906377f, -0.01364364f, 0.03423705f, -0.04430947f, -0.02231007f, 
    0.00355968f, 0.00370612f, 0.08875158f, -0.00403620f, -0.08029252f, -0.10459501f, 0.10207738f, 0.01006859f, 
    0.16158968f, -0.18350525f, -0.12179155f, 0.09415578f, -0.09015612f, -0.08630838f, -0.06320185f, 0.00306543f, 
    0.19159773f, -0.00225956f, -0.07854142f, 0.04311042f, 0.08175322f, -0.05508176f, 0.03541387f, -0.02234806f, 
    0.08222316f, 0.06165289f, -0.00556179f, -0.02835369f, -0.23321542f, -0.01469161f, 0.05461068f, -0.06635562f, 
    -0.10051268f, 0.05352988f, 0.03605712f, 0.00045951f, -0.00181473f, 0.02481057f, -0.01155269f, -0.05735521f, 
    0.07413443f, -0.00768862f, -0.00072870f, -0.01814969f, 0.00034879f, -0.02233213f, 0.05272479f, -0.04425824f, 
    0.40778399f, -0.59017819f, 0.11783610f, -0.00936415f, 0.05400313f, -0.07549310f, -0.00443376f, -0.09531365f, 
    0.08147958f, -0.00991984f, 0.01351731f, -0.08849971f, 0.03296156f, -0.09399068f, 0.00486860f, 0.04899763f, 
    -0.01636250f, -0.02481883f, 0.06669543f, 0.11322517f, -0.24771222f, -0.19019252f, 0.11633960f, -0.41877609f, 
    -0.22717924f, -0.09548721f, 0.05422148f, 0.03124022f, -0.00242592f, -0.04252104f, 0.06336891f, -0.13934366f, 
    0.04126597f, 0.00005389f, 0.02580884f, -0.06356610f, 0.03426752f, -0.01142398f, -0.16337550f, -0.07194789f, 
    -0.02918476f, 0.05120600f, -0.00209491f, -0.21467814f, -0.12298036f, -0.03893441f, 0.04539503f, -0.07181518f, 
    -0.00602540f, 0.06238804f, -0.00951342f, 0.00410375f, -0.01747762f, -0.08562715f, 0.03226710f, 0.01092054f, 
    0.04296407f, -0.03023202f, -0.08217852f, 0.00944649f, -0.00794279f, 0.08222286f, 0.14134534f, -0.41262379f, 
    -0.15509076f, 0.00071300f, -0.01205452f, 0.01388078f, 0.03349251f, 0.08525331f, 0.00174038f, -0.03627945f, 
    0.08950793f, -0.17568965f, -0.08229184f, 0.03630717f, 0.02663328f, 0.00380097f, 0.07763431f, -0.08154254f, 
    -0.23531899f, 0.03501990f, 0.14701177f, 0.07096624f, -0.10258612f, -0.03165228f, 0.08038586f, -0.05832665f, 
    -0.00337511f, 0.04288056f, -0.08295554f, 0.02671655f, 0.01536180f, 0.07121254f, 0.00539944f, 0.01189975f, 
    0.01190815f, -0.00557640f, -0.07431529f, -0.12282793f, 0.23030147f, 0.09464791f, -0.17299920f, 0.04648739f, 
    -0.12733601f, -0.05368615f, 0.04429288f, 0.12717444f, 0.12201505f, -0.11928462f, -0.07467487f, -0.01216522f, 
    -0.00969252f, 0.05720751f, 0.08824001f, -0.01500616f, 0.06910332f, -0.12544474f, -0.02934025f, 0.08081334f, 
    -0.11064348f, -0.07206515f, 0.00463945f, -0.01981217f, -0.08886106f, -0.06706718f, 0.04151342f, -0.05974178f, 
    -0.01476039f, -0.00597230f, -0.03229458f, 0.00941967f, 0.00614799f, 0.03300326f, 0.10225502f, 0.07675322f, 
    0.03800797f, 0.01636353f, -0.00112975f, 0.06909575f, 0.13471970f, -0.12191572f, -0.06846378f, -0.25593594f, 
    -0.10010882f, 0.01357911f, 0.01462849f, -0.11437783f, 0.08490458f, 0.00631816f, -0.01888594f, -0.09831073f, 
    0.01644681f, 0.01744665f, -0.11384000f, 0.07449207f, 0.01011609f, 0.02997720f, -0.04436580f, -0.00263197f, 
    -0.03063372f, -0.09031365f, 0.19913724f, -0.03044183f, -0.13202074f, 0.01392634f, 0.05011437f, 0.06020589f, 
    0.00137199f, 0.03176961f, 0.06975096f, -0.05374216f, 0.05965701f, -0.02203045f, 0.06697378f, -0.05768420f, 
    0.01882142f, 0.03411555f, -0.06007100f, -0.05924935f, -0.38956168f, 0.08017937f, -0.08192577f, 0.13211742f, 
    -0.02138714f, 0.03808604f, -0.01057270f, -0.07534793f, -0.05640011f, -0.03145617f, 0.00440764f, 0.07409307f, 
    0.03636919f, 0.00097601f, 0.00048436f, 0.06737712f, -0.09038419f, 0.03351665f, 0.00188102f, -0.06106441f, 
    -0.00152108f, -0.05892976f, 0.04647529f, 0.01878355f, -0.12173828f, 0.05412252f, -0.05779723f, -0.02157356f, 
    0.01151026f, -0.01688992f, -0.00052139f, 0.03476284f, 0.08448324f, 0.08589403f, -0.05898958f, -0.05862796f, 
    0.02199498f, -0.12718444f, -0.01979233f, -0.05578849f, 0.07556804f, -0.15728946f, -0.02400806f, 0.08583277f, 
    -0.09304693f, -0.11009127f, 0.10657436f, -0.04714105f, -0.08002048f, -0.07498574f, 0.10274196f, 0.00023003f, 
    0.02420355f, -0.11845312f, -0.07695059f, -0.07020076f, -0.01754206f, -0.07320379f, 0.09814277f, -0.01102244f, 
    0.17770581f, 0.15763739f, 0.01405581f, -0.01042692f, -0.02434023f, 0.05166234f, 0.02673154f, 0.05075102f, 
    0.02047470f, 0.04427668f, -0.01691579f, 0.02221206f, 0.03455318f, 0.03052884f, 0.00937454f, 0.12524265f, 
    0.07171794f, -0.03220820f, -0.05572340f, 0.04737272f, 0.11699319f, 0.06030112f, 0.02534109f, -0.09429404f, 
    0.01124390f, 0.03970825f, -0.01271761f, 0.00794903f, 0.05558354f, 0.00330737f, -0.00462674f, -0.01934230f, 
    0.04414793f, -0.02561734f, -0.06207941f, 0.04334905f, 0.10977672f, -0.16165274f, 0.05356800f, 0.02238878f, 
    0.04204221f, -0.08382773f, -0.00426736f, 0.05723632f, -0.01696460f, 0.04009995f, 0.09115217f, -0.04670613f, 
    0.01356694f, -0.03594480f, 0.00925156f, -0.03243869f, -0.01825829f, 0.01472545f, -0.05922579f, -0.01966042f, 
    -0.01170288f, 0.03850488f, 0.05613005f, 0.01006787f, 0.13077256f, -0.02479553f, -0.04171984f, 0.01597659f, 
    0.08519638f, -0.09474268f, 0.05456486f, -0.04057433f, 0.05685168f, -0.00555918f, 0.05404484f, -0.03363683f, 
    -0.05198896f, -0.07964399f, 0.01696832f, 0.00012287f, 0.03624163f, 0.04257970f, 0.10035821f, -0.00946576f, 
    -0.18891276f, 0.05123376f, 0.15287304f, 0.10034165f, -0.00493756f, -0.02136615f, -0.01259795f, 0.09421833f, 
    0.05006036f, 0.01319663f, -0.00649337f, 0.04142753f, 0.05388310f, -0.05815404f, -0.00914370f, -0.06296661f, 
    -0.04334848f, 0.12249169f, 0.02889778f, -0.01806280f, 0.05541520f, 0.04139644f, -0.01072040f, 0.00879891f, 
    -0.08383825f, 0.03259876f, 0.01840435f, 0.01419009f, 0.04443733f, 0.04506884f, 0.03340731f, 0.00174491f, 
    0.00326503f, -0.01461227f, 0.04359842f, 0.08396822f, 0.02048953f, -0.00203489f, 0.03981864f, 0.10123142f, 
    0.14320199f, 0.05097922f, -0.06150778f, -0.02145241f, -0.06276248f, -0.05611354f, -0.01768833f, 0.00906006f, 
    -0.02810089f, 0.00364829f, 0.01434356f, 0.07214554f, -0.01839925f, 0.01343990f, -0.04785939f, -0.03118385f, 
    0.04377234f, -0.00262817f, -0.06663101f, 0.02671451f, -0.15843748f, -0.12370249f, -0.08410890f, -0.02760554f, 
    -0.14513038f, 0.04228405f, 0.04035193f, 0.03985133f, -0.04551279f, 0.01658799f, 0.04747327f, -0.00753577f, 
    0.02321498f, -0.05267268f, 0.03852031f, -0.02155851f, -0.00633238f, 0.08441539f, 0.08103281f, 0.03931504f, 
    -0.13926981f, -0.09782916f, 0.07531552f, 0.04094309f, 0.21555151f, 0.02619444f, 0.06754433f, 0.00632102f, 
    -0.00477566f, -0.14292827f, -0.00872681f, 0.07605762f, 0.01807295f, -0.00449666f, 0.07187600f, -0.02857427f, 
    0.05085508f, -0.02328069f, -0.03104715f, 0.00104859f, -0.34183469f, 0.04576621f, -0.04350879f, -0.07636577f, 
    -0.11585550f, 0.09897706f, 0.00428391f, -0.04956235f, -0.02832480f, -0.02685821f, -0.04514959f, -0.02778981f, 
    -0.05904483f, 0.11086588f, -0.00763953f, -0.09208089f, -0.02016429f, 0.04948206f, -0.05312305f, 0.05187524f, 
    0.00968046f, 0.12134334f, -0.13440365f, -0.12418180f, -0.00426251f, 0.08836903f, 0.04983366f, 0.05142699f, 
    -0.00829212f, -0.00241319f, -0.04891902f, 0.07206830f, 0.03051321f, -0.03403432f, 0.03727464f, -0.02147043f, 
    -0.00521360f, 0.00856100f, -0.07084540f, 0.07476293f, -0.33148387f, -0.21400417f, -0.19776864f, -0.14340794f, 
    -0.20970291f, 0.05380730f, 0.05825990f, -0.02528806f, -0.04776451f, -0.03277460f, 0.07640782f, -0.04086217f, 
    -0.10263275f, -0.03445175f, 0.02552320f, -0.03906401f, -0.02803539f, 0.02986622f, 0.05449055f, 0.00637613f, 
    0.09852803f, 0.16758965f, 0.01230628f, -0.09806781f, -0.09936140f, 0.03313663f, 0.01222413f, -0.01839095f, 
    0.10456524f, 0.02714087f, -0.02186437f, 0.06673732f, 0.06357282f, -0.02479725f, 0.04113527f, 0.05927183f, 
    0.10350014f, 0.01388877f, -0.00460628f, 0.10801648f, 0.02125803f, 0.14322670f, -0.07389022f, 0.06730700f, 
    -0.08149854f, 0.02428882f, -0.05600525f, 0.07344372f, 0.06917065f, -0.01736846f, 0.06041471f, 0.00664399f, 
    0.04953143f, -0.06675595f, 0.00087456f, 0.00410860f, 0.03804770f, -0.02024921f, 0.08368143f, 0.02454623f, 
    -0.14138515f, -0.16306448f, -0.10491700f, -0.09727340f, -0.06466132f, 0.06596939f, 0.04031480f, -0.02223341f, 
    -0.04766639f, -0.01258798f, -0.04548240f, -0.01558624f, -0.04727764f, -0.02137122f, 0.02859594f, -0.03210527f, 
    -0.00586999f, 0.13115975f, 0.10917268f, 0.04870568f, 0.15261053f, 0.07702702f, -0.12891695f, 0.02074290f, 
    0.04327937f, -0.15643075f, -0.05723945f, -0.06156454f, 0.06198644f, -0.08795319f, 0.02513342f, 0.02953471f, 
    0.00355450f, -0.08596513f, -0.04411766f, -0.08042916f, -0.02892845f, 0.05950488f, -0.06363375f, 0.04822702f, 
    0.20298088f, 0.09664771f, -0.02580906f, 0.04808615f, 0.06957344f, -0.00071853f, 0.00628595f, 0.03383601f, 
    -0.04777945f, 0.04111743f, -0.05231341f, -0.01683540f, 0.04668372f, -0.05353214f, 0.05453923f, 0.00414878f, 
    0.03170061f, -0.14273228f, -0.05068461f, 0.00059400f, -0.39203352f, -0.28970569f, -0.16688180f, -0.02346027f, 
    -0.00471241f, 0.03617825f, -0.00127629f, -0.03550591f, -0.03592357f, -0.04470737f, 0.08377052f, -0.02634682f, 
    -0.09757788f, 0.03352178f, -0.06791069f, 0.03061444f, 0.07381447f, 0.08944517f, 0.06659664f, 0.02674919f, 
    -0.05262831f, 0.12374217f, -0.16194752f, 0.02939245f, -0.09936306f, 0.00898822f, 0.01176262f, -0.04426376f, 
    -0.07930871f, 0.02862298f, 0.02508539f, 0.02860644f, -0.00458576f, -0.03187980f, -0.02326534f, -0.05724721f, 
    -0.03575500f, 0.04645442f, -0.00950004f, 0.01355627f, -0.01382774f, 0.10428829f, 0.13876694f, -0.01785093f, 
    -0.09744880f, -0.00031078f, -0.00838576f, 0.02331351f, 0.00305147f, 0.04818098f, 0.00683009f, -0.01657495f, 
    -0.00035828f, -0.00982203f, 0.00438018f, 0.06314006f, -0.01679751f, -0.03889364f, 0.00047351f, 0.00560029f, 
    0.17177711f, 0.06450029f, 0.09275357f, -0.07972937f, -0.11462259f, -0.17735976f, -0.12489437f, -0.03274465f, 
    0.05086520f, -0.01654588f, -0.01855721f, 0.03267457f, -0.11971372f, -0.05419958f, -0.07026162f, -0.07339349f, 
    0.00659225f, -0.07375506f, -0.10155089f, -0.04978543f, -0.17761226f, 0.07210924f, -0.12570785f, 0.01422867f, 
    0.01123250f, -0.02883863f, 0.00091520f, -0.04238174f, 0.00280891f, 0.08835753f, 0.01530378f, -0.01787709f, 
    0.08187507f, -0.07881619f, 0.04634852f, -0.04609974f, -0.03616717f, 0.08147977f, -0.00456156f, 0.07116892f, 
    -0.30938780f, 0.02041540f, -0.09881970f, 0.00006250f, 0.12078054f, 0.05874367f, -0.01508037f, -0.07252195f, 
    -0.00156560f, -0.00480356f, 0.06479379f, -0.02611458f, 0.00499840f, 0.01735308f, 0.06142727f, -0.04764373f, 
    -0.02666406f, 0.00925765f, 0.03556588f, -0.03108938f, -0.24295902f, -0.01726268f, -0.00875742f, -0.00700250f, 
    0.01486436f, 0.04610265f, 0.00612432f, -0.04051999f, -0.02771812f, 0.02808065f, 0.00368922f, -0.02613961f, 
    0.05957663f, -0.05942839f, 0.01266964f, -0.02600717f, -0.05845371f, -0.02034729f, 0.00965633f, 0.02017188f, 
    -0.00658989f, -0.00303193f, -0.09956574f, 0.02387793f, 0.01086060f, -0.01845666f, 0.01127048f, -0.04225945f, 
    0.01238050f, -0.03320996f, 0.05632719f, 0.02202934f, 0.00851073f, -0.07945018f, 0.09084877f, -0.01042681f, 
    0.01501287f, 0.05442976f, 0.01407634f, -0.04580690f, -0.33247298f, -0.18185930f, 0.11415817f, 0.00543153f, 
    -0.25922966f, 0.04857999f, 0.01794458f, 0.04871717f, -0.03240073f, 0.02473360f, 0.03561788f, 0.03396307f, 
    0.02805153f, -0.02995212f, 0.10404088f, -0.03345505f, -0.03529695f, -0.09712850f, -0.12463168f, -0.06134901f, 
    -0.31635728f, -0.19185889f, -0.13038607f, -0.06240403f, -0.06480355f, 0.04440605f, 0.07964344f, -0.03936579f, 
    -0.00058443f, 0.00646630f, -0.01116405f, -0.04624798f, 0.01179585f, 0.03299968f, 0.05877481f, 0.07658111f, 
    -0.01030780f, 0.11795630f, 0.03080363f, 0.06101688f, -0.05865655f, 0.09572893f, 0.19064806f, -0.02469805f, 
    -0.13490707f, 0.06014985f, -0.05990198f, 0.04816553f, -0.00357257f, 0.03902883f, 0.00259414f, 0.02823517f, 
    0.03244816f, 0.04923528f, 0.00914670f, 0.00317170f, -0.00112323f, -0.09799894f, -0.06966621f, -0.07527255f, 
    -0.24076942f, -0.09336004f, 0.10294770f, 0.02779456f, -0.06757489f, 0.03142557f, 0.06192071f, -0.00383476f, 
    -0.01940170f, 0.05721520f, 0.04490898f, -0.00437531f, 0.08726545f, -0.05317980f, 0.01188012f, 0.00285982f, 
    0.03908004f, 0.06304147f, 0.06764079f, 0.02592448f, 0.11791528f, -0.06355118f, -0.08129902f, 0.12014263f, 
    -0.08264127f, -0.06496019f, 0.00085541f, 0.01813007f, -0.00215141f, 0.00203484f, 0.03938401f, 0.04040843f, 
    -0.06395283f, -0.07395744f, -0.06939445f, -0.09162935f, 0.00111001f, -0.22718349f, -0.11394586f, -0.13721305f, 
    -0.06951445f, -0.01097299f, 0.04900018f, 0.06110182f, 0.10235704f, 0.02670834f, -0.01244303f, 0.04355967f, 
    0.00590889f, 0.05963698f, -0.01625744f, 0.01087881f, 0.02355004f, 0.02110456f, -0.02114735f, 0.03119772f, 
    0.08323622f, 0.05670707f, 0.09779151f, 0.02533446f, 0.22558720f, -0.00669917f, 0.01323198f, -0.01150099f, 
    0.01497489f, -0.09154059f, -0.04254352f, -0.09020702f, 0.00892728f, 0.00923878f, -0.02484260f, 0.00389675f, 
    -0.06533223f, 0.01747360f, -0.02195049f, -0.06017583f, 0.09708354f, 0.03237398f, -0.08190292f, 0.00038128f, 
    -0.36112183f, -0.18361324f, 0.12052514f, 0.12347368f, -0.10429654f, 0.06884805f, -0.07204650f, 0.09618510f, 
    -0.08629939f, 0.06490596f, -0.02431620f, 0.00827828f, 0.02442483f, -0.06876742f, 0.06520380f, -0.04261016f, 
    -0.13907586f, -0.09784519f, 0.01512775f, -0.08049326f, -0.03189613f, -0.07827134f, -0.02758822f, 0.02025517f, 
    0.12667768f, 0.01417605f, 0.03290816f, -0.03216646f, 0.01781745f, -0.00178834f, 0.01289094f, -0.01807204f, 
    -0.04787118f, -0.00246968f, 0.00789940f, 0.01492451f, 0.08333795f, 0.00206999f, 0.02189109f, 0.04853467f, 
    0.22799058f, 0.01218075f, -0.05885521f, -0.02286660f, 0.02325130f, -0.13254410f, -0.02046519f, -0.03364868f, 
    0.02716810f, -0.03597141f, -0.03053117f, 0.00259395f, -0.04928143f, -0.06977823f, -0.03794098f, -0.03993516f, 
    0.03840410f, 0.00845421f, -0.06540558f, 0.02040999f, 0.14192595f, 0.00429148f, -0.01617639f, 0.04840377f, 
    -0.01741296f, -0.01557475f, 0.05075190f, -0.00707423f, -0.01254224f, 0.03323539f, 0.00043034f, -0.00602888f, 
    -0.01659303f, -0.01853439f, 0.01887716f, 0.02615726f, 0.05236156f, 0.01597573f, -0.04603726f, 0.02321616f, 
    0.16272296f, 0.09522552f, -0.02143691f, -0.01659902f, -0.06116151f, 0.08885073f, 0.00492367f, 0.06291820f, 
    0.01535692f, 0.02450229f, -0.01939666f, -0.03164574f, 0.00330274f, -0.01354716f, -0.03593247f, 0.03697588f, 
    0.03539338f, -0.10722630f, -0.03808286f, -0.01304775f, 0.10541048f, -0.01452828f, -0.07122865f, 0.03325360f, 
    0.09436578f, -0.04975580f, -0.00479939f, -0.03175128f, 0.03994671f, 0.00773077f, 0.02204475f, 0.08744227f, 
    -0.03521388f, -0.07248930f, 0.01245335f, 0.03962592f, -0.05740830f, -0.02357122f, -0.12410203f, -0.00343827f, 
    -0.16032407f, -0.07013355f, -0.24106683f, -0.02686105f, -0.08008057f, -0.03253314f, 0.02254079f, -0.08496030f, 
    0.01444865f, 0.11120538f, 0.04241095f, 0.09351067f, -0.15449089f, -0.12584843f, -0.02623635f, 0.01388280f, 
    0.05044690f, 0.05730124f, 0.01081168f, 0.06859387f, 0.03763545f, 0.11547368f, -0.00626300f, 0.01765743f, 
    -0.01685824f, -0.00897715f, -0.06511672f, 0.01338696f, 0.03669862f, 0.08964409f, 0.00861456f, -0.00205375f, 
    -0.02035293f, 0.00974551f, -0.01967186f, 0.10483267f, -0.03192431f, 0.03596353f, -0.05728547f, 0.00587319f, 
    -0.21867691f, -0.10952592f, -0.04605207f, -0.01987665f, -0.07008341f, 0.06274610f, -0.00960914f, -0.03689278f, 
    -0.01664266f, -0.06455832f, 0.10132590f, 0.06425788f, 0.03251529f, -0.08619804f, 0.04772536f, -0.02478303f, 
    -0.02360703f, -0.00243741f, 0.05203128f, -0.03966931f, -0.45153034f, -0.17938167f, -0.15889642f, -0.15140539f, 
    -0.18836160f, 0.08089518f, 0.04879563f, -0.06710442f, -0.02348365f, 0.03129533f, 0.08470508f, -0.05988814f, 
    -0.08112951f, 0.02858939f, 0.07162280f, -0.06238976f, -0.03029611f, 0.02583372f, 0.01513073f, -0.06953364f, 
    -0.19855376f, -0.21423116f, 0.02298994f, -0.12667310f, -0.06265920f, 0.07140104f, -0.03404818f, -0.09856247f, 
    -0.04650370f, 0.02880442f, 0.03982145f, 0.00269966f, -0.00523010f, 0.08976781f, -0.02532172f, 0.07416350f, 
    0.08357484f, 0.00577844f, -0.05897171f, 0.01020377f, 0.09524548f, 0.10129146f, -0.12881906f, 0.03570033f, 
    -0.12563065f, -0.02918275f, -0.04098292f, 0.02900242f, 0.00777494f, 0.03440121f, 0.08394900f, -0.02269931f, 
    0.07699668f, -0.01257200f, 0.03272880f, 0.02144607f, 0.01836716f, 0.02210386f, 0.05493158f, -0.00273564f, 
    0.09948801f, 0.01719342f, 0.02031159f, -0.02284099f, -0.01984204f, 0.01649469f, 0.00610706f, 0.07761428f, 
    0.04263573f, 0.00866253f, 0.02827846f, 0.02822345f, -0.01181743f, -0.00200413f, -0.02280253f, -0.02312619f, 
    0.01912580f, -0.06720128f, -0.04652515f, -0.01314520f, -0.49425536f, -0.33442199f, -0.10289282f, -0.16176564f, 
    -0.38974112f, -0.01238096f, 0.01125844f, -0.09264377f, -0.08013693f, 0.01956968f, 0.03543786f, 0.04749130f, 
    -0.01474244f, 0.05671347f, 0.03073486f, -0.00457296f, 0.03871962f, 0.07580566f, -0.03540244f, 0.07613979f, 
    -0.33534342f, -0.01317774f, -0.35613203f, -0.01645559f, 0.10796331f, -0.01489309f, -0.02398773f, -0.07681678f, 
    -0.00066492f, 0.06903698f, 0.04137359f, 0.03418099f, -0.01185441f, -0.05006482f, 0.02666071f, -0.02791699f, 
    -0.01822798f, -0.00958690f, -0.00836652f, -0.03081335f, -0.07481361f, 0.06338778f, 0.07635683f, -0.05887946f, 
    0.10738508f, 0.06236802f, -0.01418719f, 0.02302418f, -0.01794329f, 0.01045598f, -0.06063712f, 0.01111203f, 
    0.04945149f, 0.04564230f, -0.04667461f, 0.01116487f, -0.02525494f, -0.10345460f, -0.12257733f, 0.03063026f, 
    0.22851728f, 0.09319225f, -0.07188918f, 0.00071225f, -0.06656589f, 0.02757298f, -0.06407145f, 0.11039042f, 
    -0.05232820f, 0.04191448f, -0.07812092f, -0.01371787f, 0.04853370f, -0.08832959f, -0.01291498f, 0.02279290f, 
    0.01721291f, -0.15401489f, -0.03334312f, 0.02780547f, -0.09231067f, 0.14556420f, -0.10591049f, -0.11776500f, 
    -0.02424219f, 0.03706498f, 0.08458854f, 0.02885204f, 0.12838332f, 0.06407057f, -0.08288320f, 0.06165760f, 
    -0.00306449f, -0.07868674f, -0.03695966f, 0.01012569f, 0.12871030f, 0.20757228f, 0.04863765f, 0.18056476f, 
    0.08215768f, 0.02016337f, 0.02832345f, 0.01428887f, 0.04232154f, 0.01412289f, 0.05639980f, -0.04520629f, 
    0.09979258f, -0.02480563f, 0.03502116f, 0.02509845f, 0.01025302f, 0.02886715f, 0.00140981f, -0.02354967f, 
    0.05654668f, -0.01329854f, -0.17587665f, 0.04017778f, -0.05779624f, -0.13407798f, -0.01787573f, -0.01831085f, 
    0.15480091f, 0.06990529f, 0.04254643f, 0.02199866f, 0.07175571f, -0.06927446f, 0.01802171f, -0.04037883f, 
    0.02960974f, 0.03080256f, 0.00215615f, 0.10585565f, 0.06342187f, 0.01376792f, 0.07352850f, -0.01128733f, 
    -0.27719364f, -0.01103872f, -0.24705681f, 0.01473507f, 0.06576778f, -0.02455804f, -0.04101584f, -0.09759136f, 
    -0.00434073f, 0.08526547f, 0.01592135f, 0.03123517f, -0.00643644f, -0.02057736f, 0.05886035f, 0.10273015f, 
    0.00328486f, 0.05688557f, -0.06708464f, 0.04386373f, -0.37179655f, -0.13755263f, -0.21183547f, -0.08865131f, 
    0.08901357f, 0.06609200f, -0.06196878f, -0.07498463f, 0.00782065f, 0.02462732f, 0.10084166f, 0.02742009f, 
    0.06522797f, -0.05207159f, 0.09487706f, -0.03274364f, 0.01284136f, 0.09771685f, 0.03630513f, 0.07790880f, 
    -0.27932715f, -0.20569180f, 0.09878010f, -0.13089907f, -0.14421892f, 0.06184959f, 0.00332227f, 0.05037411f, 
    -0.04161080f, 0.06883120f, 0.01563823f, -0.02463915f, -0.02072999f, 0.09194944f, 0.03358109f, -0.02237947f, 
    -0.04880749f, -0.05912266f, 0.01901361f, -0.07883875f, 0.19193658f, 0.24550739f, 0.16423953f, -0.06702279f, 
    -0.05245918f, 0.04191340f, -0.08478893f, 0.01022387f, 0.02199010f, 0.01293284f, 0.00188680f, 0.01573656f, 
    0.06812873f, 0.09111622f, -0.05945971f, 0.00723459f, 0.08033971f, -0.12461151f, -0.08784427f, -0.07807286f, 
    -0.05714880f, -0.10750164f, 0.01006921f, -0.00728119f, 0.11340524f, -0.00935469f, 0.08580611f, 0.04003721f, 
    -0.02327708f, -0.07382601f, 0.01386262f, 0.00552936f, 0.02650542f, -0.00118458f, 0.06159506f, -0.02968916f, 
    0.01956415f, 0.01392141f, 0.05855218f, 0.01635666f, -0.27100980f, -0.23509216f, 0.11560870f, 0.04632142f, 
    0.08112722f, 0.03328933f, -0.05197914f, 0.00916855f, -0.02194073f, 0.00682355f, 0.04578921f, -0.01642585f, 
    -0.01406481f, 0.00007330f, 0.02379849f, 0.07241876f, 0.04887306f, 0.01838384f, 0.11494009f, 0.03526682f, 
    -0.02154684f, 0.00066826f, 0.07928263f, 0.03287562f, -0.07271117f, 0.06418273f, 0.06082792f, 0.04958666f, 
    0.00879231f, 0.01111919f, -0.03740181f, 0.02500044f, -0.01424214f, 0.00699940f, -0.00296580f, 0.00459855f, 
    -0.03389639f, -0.21124928f, -0.07714622f, -0.00450356f, -0.34057671f, -0.07962532f, 0.05742662f, -0.09816416f, 
    -0.20631918f, 0.04877524f, 0.00235494f, 0.01134734f, -0.04413885f, 0.07695595f, -0.02354071f, -0.03736640f, 
    0.01717231f, -0.03265429f, 0.01659365f, -0.04650936f, -0.07817123f, -0.07364269f, -0.05922991f, -0.02567384f, 
    -0.31826612f, -0.21758668f, -0.01192110f, -0.01028588f, 0.10600763f, 0.09760931f, -0.01362173f, 0.03396412f, 
    -0.03931753f, -0.09087790f, 0.03092988f, -0.00894839f, -0.07433533f, 0.05036848f, -0.00211290f, 0.05461581f, 
    0.03223126f, 0.01651653f, 0.03207797f, 0.02047621f, 0.06911256f, -0.02476055f, -0.14480777f, 0.04997776f, 
    -0.15215184f, -0.03992849f, 0.01306177f, -0.06326246f, 0.00522567f, 0.01376207f, 0.08326300f, -0.04942220f, 
    -0.05646471f, -0.07497381f, 0.06912717f, 0.02285134f, 0.04380007f, -0.01484091f, 0.10331694f, -0.00059178f, 
    -0.07274769f, 0.03196933f, -0.05508205f, -0.06802628f, 0.00629980f, -0.00035221f, 0.05991909f, -0.04192533f, 
    0.02744721f, 0.05092001f, 0.03947663f, 0.00351049f, 0.02814027f, -0.07492422f, 0.08351269f, -0.01925819f, 
    0.05880786f, 0.15954822f, 0.06789576f, 0.09244912f, 0.26961079f, 0.11855172f, 0.07542501f, -0.09831664f, 
    -0.05656060f, 0.10772681f, -0.00613871f, 0.08167871f, 0.01746868f, -0.08327040f, -0.06459749f, -0.03986482f, 
    -0.04208010f, 0.06640097f, -0.03037171f, 0.05616499f, -0.06101310f, -0.03758130f, -0.12560134f, 0.00251576f, 
    -0.06730347f, 0.04680666f, -0.07159168f, -0.01782838f, 0.08928099f, -0.00664693f, -0.02637369f, 0.04978360f, 
    0.06471694f, -0.04261465f, 0.08714630f, -0.12026675f, -0.01159203f, 0.03320858f, 0.02537463f, -0.05919765f, 
    -0.01455682f, -0.01658320f, 0.12367776f, 0.03436556f, 0.02056253f, -0.00242062f, -0.07520933f, -0.04061990f, 
    0.06597383f, 0.09227517f, -0.04012305f, -0.03214714f, 0.00530896f, 0.06946265f, 0.02557144f, 0.09044010f, 
    -0.04862825f, -0.00149799f, 0.00763103f, -0.00278784f, -0.09405424f, 0.04540204f, -0.04633293f, -0.03572084f, 
    -0.05990303f, 0.14367139f, -0.08871575f, -0.08873287f, 0.00479861f, 0.00559763f, -0.05431332f, 0.04097334f, 
    -0.07531411f, -0.08911425f, 0.01190238f, 0.03365738f, 0.02127165f, -0.08249200f, 0.01928271f, -0.02826662f, 
    0.01266937f, -0.05036409f, 0.10141972f, -0.02857702f, -0.16038844f, 0.00950427f, -0.06614558f, 0.01561354f, 
    -0.12386349f, 0.05207027f, 0.01752084f, 0.09299992f, 0.00855380f, 0.00909871f, -0.00539339f, -0.00446448f, 
    -0.01717653f, -0.02028031f, -0.05886862f, -0.06608322f, 0.02806928f, -0.08350356f, -0.02710432f, -0.00865945f, 
    -0.22177951f, -0.24503605f, -0.00851559f, -0.12442224f, 0.00751282f, 0.04269110f, -0.02936838f, -0.00170060f, 
    0.13514070f, 0.09532405f, -0.04804338f, -0.00870748f, -0.03194324f, 0.05512826f, -0.00546850f, 0.06500939f, 
    -0.04395810f, -0.04711922f, -0.09423331f, -0.11077372f, -0.09316902f, 0.13591494f, -0.04221397f, 0.06339774f, 
    0.19812909f, 0.12087088f, -0.01541949f, 0.00205740f, 0.03255903f, 0.04509030f, -0.02592892f, -0.02702680f, 
    0.04697984f, 0.03752420f, 0.02004106f, -0.00050980f, 0.02227726f, 0.03238077f, -0.03860658f, -0.02999494f, 
    -0.20827782f, 0.23740612f, 0.00927492f, -0.04340056f, 0.01942172f, -0.06308368f, -0.06704801f, 0.02631001f, 
    -0.06646428f, -0.12271784f, 0.03670833f, -0.01988516f, 0.09000693f, -0.03428087f, 0.01531463f, -0.01936669f, 
    -0.01409388f, -0.03301907f, -0.03356797f, -0.06691913f, 0.08784064f, -0.13952768f, -0.11296250f, -0.06196030f, 
    -0.09131566f, 0.05424441f, -0.04527202f, 0.07192808f, -0.01369076f, 0.05262228f, -0.01995377f, 0.08257989f, 
    -0.05820450f, -0.00496220f, 0.03139488f, 0.02340955f, 0.00207965f, -0.06953251f, 0.03115851f, -0.07257783f, 
    -0.27057669f, 0.25300902f, -0.06588234f, 0.06145125f, -0.12598915f, 0.05082816f, -0.00683436f, -0.02141608f, 
    0.00645906f, -0.02219942f, 0.00374360f, 0.01117241f, 0.01512265f, -0.03626675f, 0.05706786f, -0.03188776f, 
    0.10401472f, -0.07952029f, -0.00745957f, 0.01692289f, 0.05931155f, 0.12258082f, -0.09390515f, -0.22092560f, 
    -0.16324309f, -0.01943066f, -0.01865477f, -0.00148854f, 0.04239101f, 0.04741672f, 0.10010297f, -0.04135181f, 
    -0.01440317f, -0.05951064f, 0.08215456f, -0.02632159f, -0.02857463f, -0.03977368f, -0.07196175f, 0.07235479f, 
    -0.23059642f, 0.18455832f, 0.03656264f, -0.13811563f, 0.16480148f, -0.14698119f, -0.02082494f, -0.11070006f, 
    0.04787573f, 0.02984550f, 0.01741972f, -0.03421338f, -0.01129023f, 0.03304262f, -0.00772165f, 0.17714572f, 
    -0.15089072f, -0.02937428f, -0.05460357f, 0.03370404f, 0.09499546f, -0.14361086f, -0.15589808f, -0.04291190f, 
    -0.37761772f, 0.04103420f, 0.05493759f, 0.09643959f, 0.02264708f, 0.02116220f, 0.04621072f, 0.03954538f, 
    0.00723690f, -0.03230808f, -0.02740277f, -0.05410260f, 0.03245919f, -0.03390517f, -0.01758893f, -0.02333837f, 
    -0.00732728f, 0.06998849f, -0.09585499f, 0.00094505f, 0.29538518f, 0.09987140f, -0.04906392f, 0.01593328f, 
    0.08923473f, 0.05616894f, -0.01005119f, -0.00302151f, -0.00115471f, 0.01402227f, 0.05624164f, -0.07797325f, 
    0.04489521f, 0.03004641f, 0.05670306f, -0.01451021f, 0.10760190f, -0.18993551f, 0.01062039f, 0.08136643f, 
    0.01019012f, 0.05752379f, 0.06698948f, 0.08453296f, -0.07479288f, 0.03820344f, 0.02024303f, 0.00610364f, 
    -0.07215046f, 0.01444486f, -0.03807387f, -0.04294657f, 0.03526914f, 0.05131865f, -0.04956397f, -0.04225175f, 
    -0.12698977f, -0.23916405f, -0.13315135f, -0.12498304f, -0.23243043f, 0.05144205f, -0.00150447f, 0.01453151f, 
    0.03309779f, 0.09571979f, -0.00098578f, 0.02064718f, -0.04407516f, 0.01149790f, 0.00879334f, -0.02935093f, 
    -0.07082171f, -0.06803662f, -0.06167528f, -0.04139398f, -0.42211089f, 0.02200885f, 0.02145643f, -0.08439260f, 
    0.06243190f, -0.10005525f, 0.01395973f, -0.00007764f, 0.08310152f, -0.01984083f, -0.01745290f, 0.02801199f, 
    0.07900485f, -0.00170217f, -0.00047704f, -0.07231902f, -0.06562679f, 0.02999089f, -0.13475457f, 0.04815707f, 
    -0.02499950f, 0.04917391f, -0.09522986f, 0.06361994f, -0.06862325f, -0.01612206f, -0.04602221f, -0.00713461f, 
    0.02713143f, -0.05758832f, 0.07585584f, 0.01619301f, -0.03579622f, -0.00042648f, -0.04142033f, 0.06129349f, 
    0.02945183f, -0.01039066f, 0.01658799f, -0.07763071f, 0.11020122f, 0.12034430f, -0.03199461f, 0.03488412f, 
    -0.06372713f, 0.13438849f, 0.07554077f, 0.06505909f, -0.04499722f, 0.02537772f, 0.09060640f, 0.05034899f, 
    0.01535360f, 0.01041631f, -0.00974130f, -0.09819033f, -0.01606906f, -0.04578307f, -0.04032364f, 0.07474573f, 
    0.00947774f, -0.06224709f, 0.02759818f, 0.11662332f, 0.08096633f, -0.08210957f, 0.07538077f, 0.04868035f, 
    0.02324435f, 0.00812245f, -0.03794083f, 0.00033937f, -0.01672097f, 0.07322815f, 0.01073900f, 0.00679619f, 
    -0.01157879f, 0.00879699f, -0.05852259f, 0.04612130f, 0.04454113f, 0.08167543f, 0.02161569f, -0.05250971f, 
    0.31516984f, 0.10647299f, -0.08099828f, -0.03821058f, 0.02752085f, -0.01156747f, -0.00691546f, -0.09875815f, 
    0.03435498f, 0.03540263f, -0.02765610f, -0.08578264f, 0.03497301f, 0.04530069f, 0.03836980f, -0.03663140f, 
    0.10712393f, 0.01817893f, -0.00601630f, -0.04623460f, -0.04713439f, -0.00671105f, -0.07462702f, -0.06239209f, 
    -0.13452415f, -0.13866001f, -0.01827799f, -0.01593131f, 0.06084040f, 0.03706801f, -0.05117043f, -0.03856583f, 
    -0.05702588f, -0.02853394f, -0.06567056f, -0.03773067f, -0.42512494f, -0.13096195f, 0.08190920f, -0.03182447f, 
    0.16891648f, -0.06864240f, 0.04555396f, -0.00053857f, 0.05745434f, -0.08936166f, 0.05248701f, -0.06129189f, 
    -0.02213324f, 0.02830801f, -0.04296339f, -0.10932069f, 0.01069264f, -0.04088439f, -0.00417598f, 0.03661554f, 
    0.01738796f, -0.08568350f, -0.09850623f, 0.07001550f, -0.07320320f, -0.16247030f, 0.06177903f, -0.06757474f, 
    -0.00238549f, -0.03287587f, 0.03380378f, -0.00035102f, 0.04063190f, 0.04042964f, 0.03233703f, 0.09811953f, 
    0.02178119f, -0.06421340f, 0.05890948f, 0.00376739f, -0.05780561f, -0.07980884f, -0.03844440f, 0.04752238f, 
    -0.11354137f, -0.03793439f, 0.05274989f, 0.07175561f, -0.03039419f, -0.10447684f, 0.13452411f, -0.07552592f, 
    -0.03528695f, 0.03701414f, -0.01854973f, 0.07292819f, 0.03549487f, -0.05829516f, 0.01819277f, 0.04424055f, 
    -0.11333945f, -0.12538779f, -0.00214304f, -0.01248708f, -0.08407714f, -0.01488829f, 0.10233761f, -0.07075172f, 
    0.06537599f, 0.04436773f, -0.07500041f, 0.02743289f, -0.01493447f, 0.06037828f, 0.01461997f, -0.07175735f, 
    0.00288289f, -0.01970352f, -0.08736205f, -0.05020941f, -0.10039248f, 0.18232520f, -0.03015564f, -0.15284102f, 
    0.27345255f, 0.12055426f, -0.13676934f, 0.00072724f, 0.04505384f, 0.00614664f, 0.04875654f, 0.06301558f, 
    -0.03436333f, -0.01890903f, -0.01986566f, 0.05569883f, 0.06529871f, 0.06694106f, -0.00901922f, 0.02069891f, 
    0.14287448f, 0.05963336f, -0.20039494f, -0.05506562f, -0.11127526f, 0.00069106f, -0.00444276f, -0.00838653f, 
    0.03821820f, 0.01090286f, -0.02421845f, -0.00842449f, -0.05427349f, -0.02789459f, 0.05498048f, -0.03535520f, 
    -0.00791803f, 0.01841970f, -0.03484282f, -0.02207063f, 0.16688947f, -0.00075506f, -0.03828405f, -0.17723298f, 
    0.17502163f, 0.07793411f, -0.08248343f, 0.01597070f, 0.09695161f, -0.00043518f, 0.01944375f, -0.04741829f, 
    0.04161710f, -0.03377317f, 0.03584582f, 0.04240160f, 0.01682015f, 0.05360578f, -0.00583243f, 0.04526968f, 
    -0.18417032f, -0.23207669f, -0.03298752f, -0.13193923f, 0.09780367f, 0.02693019f, -0.03710016f, 0.00810728f, 
    0.01910747f, 0.04618727f, -0.03174863f, 0.01903249f, -0.08395984f, 0.04110226f, -0.02483058f, 0.01883061f, 
    0.01823799f, 0.01155870f, -0.04333631f, -0.07832752f, 0.14332812f, -0.08929128f, -0.01405527f, -0.03042695f, 
    -0.01102819f, -0.05073046f, -0.11193826f, 0.08136306f, -0.14305033f, -0.17337801f, 0.03640206f, 0.00758217f, 
    0.01665925f, -0.07471805f, -0.07146662f, 0.03920877f, -0.09316039f, 0.01442383f, 0.06785256f, 0.02228979f, 
    -0.20972198f, -0.00290178f, -0.02856182f, -0.00292157f, -0.00526903f, 0.04001102f, -0.03169179f, 0.01421190f, 
    0.01054364f, 0.06670240f, -0.04340666f, 0.00121446f, 0.06044961f, -0.06238323f, -0.02415597f, 0.02275000f, 
    -0.00655173f, -0.05394642f, -0.06265217f, -0.06319263f, -0.15934707f, 0.04936032f, 0.07833312f, 0.00370421f, 
    0.01683768f, 0.02819491f, -0.00772518f, 0.01984660f, -0.06663513f, -0.02428141f, -0.01993055f, -0.04357646f, 
    0.03856499f, -0.11716266f, -0.08160313f, -0.02307629f, -0.01705243f, -0.01292536f, -0.02659036f, -0.03754998f, 
    0.01058338f, -0.15952635f, 0.02579307f, -0.02297226f, 0.00563057f, 0.02509133f, -0.20673783f, 0.09197412f, 
    0.11276449f, 0.08649350f, -0.02975269f, 0.03710765f, 0.04312889f, 0.03668321f, -0.08290279f, -0.00838649f, 
    0.09387216f, -0.02719656f, -0.02584866f, -0.03287643f, -0.15439378f, 0.21411222f, -0.07631685f, -0.00215945f, 
    0.01588345f, 0.04985270f, 0.02767035f, 0.01659407f, -0.01984652f, -0.02241036f, 0.01246482f, 0.06799315f, 
    0.02416067f, -0.04608469f, 0.02234150f, 0.00069680f, 0.06488014f, -0.04743033f, -0.00357757f, -0.02010951f, 
    -0.20394672f, 0.04345381f, -0.00593267f, 0.06503083f, -0.03838273f, 0.02520152f, -0.04367130f, -0.00256058f, 
    0.02574003f, 0.01941892f, -0.04198847f, -0.04654135f, 0.04373899f, -0.05030018f, -0.01710929f, -0.02532311f, 
    0.01585173f, -0.01511255f, -0.10225638f, -0.02588709f, -0.03104092f, 0.11939403f, 0.04625665f, 0.04363133f, 
    0.05563702f, 0.07713851f, -0.00414465f, 0.03005455f, -0.02697483f, -0.03895309f, -0.06879170f, -0.03110668f, 
    0.02834926f, -0.07412952f, -0.01717422f, -0.04127189f, 0.03909066f, 0.03724726f, 0.05919531f, -0.02085326f, 
    0.06292447f, 0.05209307f, -0.08438529f, -0.06618226f, 0.02271978f, -0.04732807f, -0.07882110f, -0.00444121f, 
    -0.04555674f, -0.05146017f, 0.06857799f, -0.00688499f, -0.04181602f, 0.03110346f, 0.03698731f, 0.02965944f, 
    -0.00062710f, 0.00357224f, 0.02231394f, -0.05359051f, -0.21046855f, 0.09693252f, -0.01857153f, -0.06813711f, 
    0.12864840f, -0.04392765f, -0.13468646f, -0.01030304f, 0.05752638f, -0.03428475f, 0.00696994f, 0.02346544f, 
    0.04061089f, -0.03363629f, 0.07399463f, 0.03467277f, -0.04794541f, 0.02576640f, 0.00025764f, -0.01903144f, 
    0.24407253f, 0.09424174f, -0.24678099f, -0.06373409f, -0.11702403f, -0.07963417f, -0.05918014f, 0.02994869f, 
    0.06668268f, 0.02743045f, -0.03482301f, -0.04619880f, 0.07521783f, -0.17231961f, -0.00533343f, 0.03589184f, 
    0.01033739f, 0.04294910f, -0.07102890f, -0.08896536f, 0.20674323f, 0.14900883f, -0.04544691f, 0.03499560f, 
    0.04917443f, -0.03762593f, 0.00368171f, 0.01250298f, 0.06810679f, 0.01139734f, 0.05987336f, -0.01991538f, 
    0.03131610f, 0.00835447f, 0.02590890f, 0.02697168f, 0.01290064f, 0.01017263f, 0.04380492f, -0.01462792f, 
    -0.02950226f, -0.10318405f, -0.11328344f, 0.09198774f, -0.19440037f, 0.03370560f, 0.05069819f, 0.06423429f, 
    -0.01264307f, -0.01965848f, -0.04447911f, -0.02654262f, -0.01828649f, 0.01357973f, -0.11910349f, -0.02228364f, 
    0.02863394f, -0.05527911f, -0.14244837f, -0.00068150f, 0.31366146f, -0.03302994f, -0.28220063f, -0.00243801f, 
    -0.38899830f, -0.07333791f, -0.04775801f, 0.05904773f, 0.00178210f, -0.00036940f, -0.01239150f, 0.04735526f, 
    0.00683804f, 0.02384032f, -0.07895730f, -0.04153538f, 0.02782656f, -0.04154116f, -0.04196976f, -0.01118273f, 
    0.34018931f, 0.12196649f, -0.18395281f, -0.03450523f, -0.05535943f, 0.09244196f, -0.04815753f, -0.03949004f, 
    0.01141257f, 0.02488588f, 0.11180693f, 0.01488111f, 0.02846146f, 0.03062275f, 0.01530834f, 0.01780542f, 
    -0.03227307f, 0.03538924f, -0.03258392f, 0.12291504f, 0.15392315f, -0.10154663f, 0.05492806f, 0.10362081f, 
    -0.07105636f, -0.05515127f, 0.05495243f, 0.00373690f, -0.04774223f, 0.05318326f, -0.08314670f, -0.07333323f, 
    0.00169692f, 0.03799649f, -0.13239625f, 0.01430045f, -0.02489419f, 0.04352681f, -0.08144435f, -0.08933769f, 
    0.13634512f, 0.03969681f, 0.02645510f, -0.04785814f, 0.02486086f, -0.10119455f, -0.06741584f, 0.00890718f, 
    -0.06350047f, -0.05836089f, 0.06422082f, 0.00270297f, 0.03643079f, 0.01575852f, -0.07809290f, -0.02497559f, 
    0.01775139f, -0.01437335f, -0.01753336f, -0.02724151f, 0.53279078f, -0.03409004f, -0.27897555f, -0.07333081f, 
    0.15809835f, 0.02591526f, -0.04118551f, -0.02782596f, 0.00891592f, 0.01953300f, 0.12702407f, -0.03024310f, 
    -0.00234836f, 0.03055554f, 0.02447158f, 0.06554297f, -0.06848972f, -0.03149833f, -0.01592011f, -0.03368345f, 
    -0.00342942f, 0.12720668f, -0.05023951f, 0.04720982f, -0.14234342f, -0.06058518f, -0.03979750f, -0.00167889f, 
    -0.01454584f, 0.00847700f, -0.01389534f, 0.03045605f, 0.15204190f, 0.08093878f, 0.02344417f, 0.05988894f, 
    0.02557239f, -0.06330777f, -0.02891232f, 0.02248868f, 0.00762060f, 0.11781868f, -0.04173958f, -0.07309315f, 
    0.11486143f, 0.00792406f, -0.07682506f, 0.02479370f, -0.00897978f, 0.04451757f, 0.01109490f, -0.01420894f, 
    0.01996063f, 0.00895305f, 0.01220820f, -0.00885068f, 0.00079111f, -0.04225394f, 0.05976820f, 0.08999525f, 
    0.24482033f, 0.03232216f, -0.08259896f, -0.04453038f, -0.06902097f, -0.13893557f, -0.04244855f, -0.03679461f, 
    0.09440240f, -0.05882332f, 0.09107639f, 0.00721564f, -0.04092423f, 0.06541771f, -0.04430341f, 0.01481078f, 
    -0.08394447f, 0.00323395f, -0.07825525f, 0.04806533f, -0.41394669f, 0.19263986f, 0.03700822f, -0.05505379f, 
    0.10770930f, -0.02960025f, 0.04954632f, 0.07056507f, -0.10032249f, 0.13879941f, 0.00145398f, 0.09454608f, 
    -0.00360215f, -0.07071849f, -0.00530978f, -0.02393242f, -0.05786640f, 0.00331474f, -0.01982814f, -0.21069443f, 
    -0.14190283f, 0.19159260f, 0.07274950f, -0.08865573f, 0.07711813f, -0.09407938f, -0.05174407f, 0.01972681f, 
    -0.13368665f, -0.02507602f, -0.02835062f, 0.01391082f, -0.00330541f, -0.10620937f, 0.01556487f, 0.07654777f, 
    0.07674893f, -0.02021540f, 0.02735198f, -0.06566551f, -0.08396962f, 0.25170946f, -0.07699924f, 0.05741956f, 
    0.12978792f, 0.10072277f, 0.04234444f, 0.01490043f, -0.00274878f, -0.01260271f, 0.00122679f, 0.11044823f, 
    0.01307470f, 0.03582257f, 0.04122126f, -0.01516499f, 0.01294169f, -0.02461392f, -0.03259578f, 0.05455396f, 
    -0.07665108f, 0.13461690f, -0.09185933f, 0.06549947f, -0.06637488f, -0.07218305f, -0.01383440f, -0.00646478f, 
    0.02408217f, -0.02103424f, 0.00705250f, -0.01268984f, 0.06498060f, -0.00758679f, 0.03775093f, 0.02117521f, 
    0.03891277f, -0.08150813f, 0.05003257f, 0.06639720f, -0.10074691f, -0.27159548f, -0.06836745f, 0.09530897f, 
    0.12347309f, 0.05866869f, 0.08406445f, -0.08546384f, -0.02953218f, -0.06225993f, 0.06542684f, 0.00356761f, 
    -0.09732929f, 0.07089640f, 0.05342919f, 0.01913130f, -0.03881228f, -0.01671039f, -0.02225333f, -0.03746458f, 
    0.26892957f, 0.06258481f, -0.16794915f, -0.08160511f, -0.05305216f, 0.00355820f, -0.00522917f, -0.02983612f, 
    0.01113413f, -0.01070099f, 0.05867768f, 0.01483034f, 0.00146553f, 0.03985759f, 0.03256204f, 0.03812221f, 
    0.01768584f, 0.03497360f, 0.02653702f, 0.05561814f, 0.26728034f, -0.15065512f, -0.04810779f, 0.03996702f, 
    0.05031731f, -0.07176672f, 0.05545335f, 0.01073018f, 0.10538732f, -0.07178470f, 0.05931055f, -0.00231562f, 
    -0.03671847f, 0.05016718f, 0.07122173f, 0.01474381f, -0.05345644f, -0.08331189f, 0.02417793f, 0.14672019f, 
    -0.10684019f, 0.16490358f, 0.03583614f, 0.08595196f, -0.01250838f, 0.09605818f, 0.05995001f, 0.01853707f, 
    -0.06490212f, 0.00977504f, 0.04022604f, 0.13099493f, -0.00903314f, 0.00590726f, 0.01622390f, -0.07415742f, 
    0.03435476f, 0.01821577f, 0.07154925f, 0.05377469f, -0.11273680f, -0.18009232f, -0.00967776f, -0.12888746f, 
    -0.01119422f, 0.17830528f, -0.11588317f, -0.02630355f, 0.05284863f, 0.03571150f, -0.01935807f, 0.00768743f, 
    0.07670014f, -0.01816870f, 0.02171391f, 0.02052451f, 0.02166512f, 0.00516349f, -0.07914633f, -0.04841743f, 
    -0.06324764f, 0.09907968f, -0.04064934f, -0.09039976f, 0.23460792f, 0.06172990f, -0.13661943f, 0.00160625f, 
    -0.02368586f, -0.05561978f, 0.01927246f, 0.04680843f, 0.01733256f, 0.01091750f, 0.02284643f, -0.01946961f, 
    0.07588913f, 0.00677657f, 0.07867085f, 0.09053071f, 0.19041254f, -0.02346380f, -0.06790809f, -0.08802958f, 
    0.06432398f, -0.10407539f, -0.08324580f, 0.01811375f, -0.00098364f, 0.06470880f, 0.08748892f, -0.00481389f, 
    0.03694136f, 0.02063638f, -0.06554476f, 0.04521940f, 0.03242478f, -0.04916006f, 0.06402007f, -0.05754133f, 
    0.20130777f, 0.12646906f, -0.04029483f, 0.03776804f, 0.01892271f, 0.19532968f, 0.09052383f, -0.06026348f, 
    0.03454203f, -0.03236962f, 0.06374260f, 0.04312385f, 0.01237227f, -0.00598738f, 0.02104451f, -0.06099862f, 
    0.02599779f, -0.03707825f, -0.04156679f, 0.08206386f, 0.14260767f, -0.01441663f, 0.03060587f, 0.03288759f, 
    -0.10103905f, 0.00421127f, -0.02497000f, -0.01004764f, -0.11120102f, -0.02284188f, -0.05016340f, -0.04453887f, 
    0.05712431f, -0.10954706f, -0.13873725f, -0.05424887f, -0.05863393f, -0.01615646f, 0.01530830f, -0.00207499f, 
    -0.20949490f, 0.03226129f, 0.07325432f, -0.07748450f, 0.01654712f, 0.00799286f, 0.07677976f, 0.00197017f, 
    0.01737355f, 0.03237850f, 0.02710843f, -0.05486087f, -0.02303532f, -0.02281514f, -0.04867852f, -0.07096514f, 
    -0.00315857f, 0.00115383f, -0.04803865f, -0.00963438f, -0.18820134f, 0.12241875f, -0.13686597f, -0.27946040f, 
    -0.00601023f, -0.10991456f, -0.06534757f, -0.01993671f, -0.11286438f, -0.12177801f, -0.07465477f, -0.09912006f, 
    -0.06841610f, -0.03039542f, 0.07557817f, 0.10440365f, -0.04407075f, -0.01007319f, 0.09192729f, -0.07292971f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.01363192f, 0.03892341f, -0.02854215f, 0.00336965f, 0.02031814f, 0.00615152f, -0.01522184f, -0.04809916f, 
    -0.03832019f, 0.01140434f, 0.04363353f, -0.00359081f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 5120);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
