#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.07593274f, 0.32189742f, -0.02484774f, -0.17591485f, 0.03972068f, -0.78333020f, -0.31064323f, 0.20416227f, 
    -0.02424661f, 0.65084547f, -0.42094103f, 0.37412858f, -0.03020480f, -0.10838548f, -0.38313487f, -0.06964635f, 
    -0.35746780f, -0.10902627f, 0.24023247f, -0.27607986f, 0.03836916f, -0.36111808f, -0.01045568f, 0.31744695f, 
    0.19110055f, 0.86179036f, -1.82919371f, -1.10665250f, -0.67265135f, -0.52014345f, 0.10477600f, -0.08520673f, 
    0.17247185f, 0.19995362f, -0.45050520f, 0.67802978f, 0.33094686f, 0.44413337f, -0.47193739f, 0.05924240f, 
    0.07100248f, -0.13681667f, -0.28282300f, 0.09133982f, -0.28393224f, -0.63231140f, -0.25189114f, -0.13176815f, 
    -0.36655974f, -0.55016041f, -0.26492485f, 0.34898999f, 0.44782889f, 0.00679646f, -0.34406409f, -0.61041540f, 
    0.50301409f, 0.50168818f, 0.51055795f, -0.44980413f, -0.10656663f, 0.23412624f, -0.05575176f, 0.35670897f, 
    0.00738979f, -0.12718081f, -0.34502405f, -0.64446628f, -0.32232630f, 0.21325161f, -0.11547500f, -0.10816200f, 
    0.76516008f, 0.30473942f, -0.39001051f, 0.15162587f, -0.19646113f, -0.13751113f, 0.36041826f, -0.93530011f, 
    -0.94723451f, -0.39222372f, -1.40676343f, -1.24568236f, -1.41328740f, 0.25835016f, 0.42980957f, -0.29202899f, 
    -0.41935837f, -0.10779736f, -0.14601354f, -0.64831978f, 0.21248746f, 0.46557227f, -0.11698493f, -0.31625205f, 
    -0.10176298f, -0.19377911f, -0.13220878f, -0.05478990f, -0.10617138f, 0.46444309f, 0.67213583f, 0.51360583f, 
    0.00031359f, 0.02133441f, 0.51802379f, 0.08154495f, 0.67706460f, -0.14519314f, 0.18246295f, 0.36724389f, 
    -0.17420055f, -0.16786663f, -0.26864254f, -0.18360311f, -0.36502826f, -0.19714141f, -0.17161815f, 0.29142347f, 
    0.01161066f, 0.00843616f, -0.18436898f, 0.07302200f, 0.12490080f, -2.12635612f, 0.08817498f, 0.22600853f, 
    0.30173850f, -0.50384057f, -0.18716431f, 0.05152787f, 0.35184902f, 0.62032378f, 0.50936818f, -0.63884032f, 
    -0.30971187f, -0.18273063f, 0.71731085f, 0.13335963f, 0.47065312f, 0.40615508f, -0.09202789f, 0.08492917f, 
    -0.00420430f, -0.17959914f, 0.22709699f, 0.04249470f, -0.27238262f, -0.22267652f, 0.70678198f, 1.20883679f, 
    1.08375990f, 0.17273025f, 0.20383644f, -0.82793850f, -0.75901455f, -0.08409829f, -0.44959295f, -0.73911941f, 
    -0.20153096f, -0.17155206f, -0.13778125f, -0.03010064f, -0.08275136f, 0.19542935f, 0.18364908f, 0.11063234f, 
    -0.03919190f, 0.33636636f, -0.04399956f, 0.29545319f, -0.18706670f, -0.12800103f, -0.33227530f, -0.32862577f, 
    -0.32439855f, -0.33240530f, -1.17813730f, -0.95873630f, -0.13565148f, -0.00513003f, -0.45613584f, 0.20573440f, 
    -0.36051691f, 0.09720317f, 0.52572656f, -0.49858987f, -0.36507416f, -0.82872468f, -0.76758683f, -0.33240741f, 
    -0.35602200f, -0.43644440f, -0.65978092f, -0.40368459f, 0.46858975f, 0.40999120f, 0.50438458f, 0.01611513f, 
    -1.41688681f, 0.01604366f, -0.67383331f, -0.34644079f, 0.39716384f, -0.20190910f, 0.31146312f, 1.36110365f, 
    -0.19301061f, -0.22382261f, -0.16756044f, 0.13311365f, 0.14748830f, 0.44491470f, -0.34053254f, -0.11097870f, 
    -0.43718553f, -0.26084962f, -0.04350263f, 0.17832431f, 0.14041264f, -0.11229248f, -0.11315469f, 0.16632651f, 
    0.21350197f, -0.76578063f, -0.55551279f, -0.57590640f, -0.14235249f, -0.54927373f, -0.58269173f, -0.51114720f, 
    -0.56513798f, -0.51535100f, -1.10562778f, 0.13615692f, -0.42436844f, 0.78412771f, -0.37840194f, -0.18287562f, 
    0.12520041f, 0.19898097f, 0.08790363f, 0.04009467f, 0.02876857f, 0.17387348f, 0.57476580f, 0.55421603f, 
    -0.14417420f, 0.16027634f, 1.54781210f, 0.16556449f, -0.46933427f, -0.42010796f, -0.48581359f, 0.16634987f, 
    0.17991446f, 0.39074939f, -0.34103966f, -0.56892186f, -0.49245474f, 0.58649653f, -0.08843839f, -0.16937731f, 
    0.45205379f, 0.08506970f, 0.14825900f, 0.07746948f, -0.44066235f, -0.26173553f, 0.20486887f, 0.09337527f, 
    -0.05759944f, 0.23581232f, 0.17423540f, -0.13207120f, -1.67065847f, -0.05156084f, 1.00620639f, 0.68116415f, 
    0.75946087f, 0.40960193f, -0.10745642f, -0.16794357f, -0.04056649f, 0.12865235f, -0.52525246f, -0.44332275f, 
    -0.00837383f, 0.03913892f, -0.32953167f, -0.10318615f, -0.18329282f, -0.05350837f, -0.52251709f, -0.36153716f, 
    -0.29243177f, -0.74545330f, -0.75510210f, -0.82261711f, 1.46202636f, -0.87810540f, -1.22820783f, -0.85952902f, 
    -1.07724190f, 1.24225450f, 0.32668313f, 0.72178215f, 0.23269872f, 0.22790992f, -0.10693999f, 0.15628465f, 
    -0.05646864f, 0.03027130f, -0.00182574f, 0.03633107f, -0.15488368f, 0.38357025f, -0.23337321f, 0.00456397f, 
    0.15845953f, -0.30995578f, 0.11847709f, 0.05719044f, 0.20483996f, -2.02726269f, -0.73663539f, -0.68942297f, 
    -1.20069444f, -0.42918915f, 0.27840945f, 0.00518105f, -1.22802842f, -0.92931026f, 0.59507304f, -0.28292260f, 
    -0.40413788f, -0.27334923f, -0.64138293f, -0.42912388f, 0.21999481f, -0.06655566f, -0.26089606f, -0.01252410f, 
    -0.20408145f, -0.17118332f, -0.16913103f, -0.23195928f, -0.33174929f, -0.00398102f, -0.30263925f, -0.60733950f, 
    0.05363895f, 0.64125443f, 0.35863143f, 0.50790614f, -0.20068105f, 0.33093593f, 0.91119450f, 0.49379110f, 
    0.29850900f, -0.04828267f, -0.25780940f, 0.20544700f, -0.54716057f, -0.19661376f, 0.28348345f, -0.09640243f, 
    0.11841547f, -0.34492299f, 0.10912267f, -0.32626370f, -0.15982983f, 0.22297704f, -0.10098767f, -0.16852881f, 
    -0.48282534f, 0.07651612f, 1.13659632f, -0.36621186f, -0.56521356f, -0.65850842f, 0.01053324f, 0.72139770f, 
    -0.34317663f, -0.30273011f, -0.26889572f, 0.07748394f, 0.02171354f, 0.09545402f, 0.24758454f, 0.38742834f, 
    0.43098843f, -0.75670946f, 0.05744937f, -0.27516791f, -0.22683781f, -0.54573256f, -0.13267156f, -0.06748901f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.78648686f, 0.28572288f, 0.67925608f, 0.15107958f, 0.01514941f, 0.19790706f, 0.30992800f, 0.11100509f, 
    0.69934052f, 0.10210793f, 0.62756878f, 0.16922885f, 0.43643478f, 0.04933320f, 0.76980066f, 0.52550656f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -1.17592764f, -0.25789723f, -0.69878846f, -0.30020681f, 0.01983834f, 0.12894309f, -0.02731943f, -0.07954350f, 
    -0.14388414f, -0.04088462f, -0.09601525f, 0.19154833f, 0.47808319f, -0.01156035f, -0.48276526f, -0.09144495f, 
    0.08213773f, -0.06838278f, 0.02938269f, -0.13882981f, -0.21819195f, 0.18789224f, -0.12472658f, 0.16272511f, 
    -0.38657987f, -1.17566562f, 0.05940003f, -0.04123895f, -0.03633359f, -0.06067921f, -0.10297818f, 0.12407231f, 
    -0.10557592f, -0.15352668f, -0.24150646f, -0.19647311f, 0.50600642f, 0.32741886f, -0.39035594f, -0.20942426f, 
    0.03555394f, -0.15351595f, -0.01277973f, 0.25330716f, -0.02994832f, -0.05168613f, -0.04151835f, 0.03136501f, 
    -0.77928436f, -0.76358384f, -0.18146354f, -0.02828091f, 0.02711540f, 0.10401621f, 0.03431368f, 0.16676112f, 
    -0.14121577f, -0.02286585f, 0.16033609f, 0.03279557f, 0.31614423f, 0.05463000f, 0.30061516f, -0.31436864f, 
    0.11142535f, 0.03145985f, -0.00030991f, -0.01203698f, -0.02187713f, 0.18430416f, 0.02651681f, -0.10753135f, 
    -0.47396952f, 0.08808700f, 0.26157171f, -0.13500044f, 0.07883960f, 0.19299009f, -0.20802464f, -0.05472187f, 
    -0.01557402f, 0.12351394f, 0.11018750f, 0.04671791f, 0.26852164f, 0.05242709f, -0.29162899f, -0.15838584f, 
    0.20115922f, 0.27122757f, -0.24025282f, 0.08104037f, -0.17529191f, -0.28499815f, -0.19786735f, 0.01753428f, 
    -0.01201901f, 0.05325793f, 0.02214213f, -0.08930248f, 0.10089283f, 0.08369997f, 0.02784443f, -0.08871471f, 
    -0.00308726f, -0.15898141f, -0.01697753f, -0.06327189f, 0.53617543f, 0.26732311f, -0.15517311f, -0.44849673f, 
    0.03887141f, 0.02658735f, -0.20635484f, 0.11383536f, -0.02273405f, 0.03458498f, 0.00883656f, 0.02817054f, 
    -0.12588911f, -0.25806114f, -0.13905449f, 0.24216160f, -0.24722639f, 0.04797290f, -0.22377330f, -0.17239717f, 
    -0.19432236f, -0.07336795f, -0.09201486f, -0.21727704f, 0.33179945f, -0.42749578f, -0.20049043f, -0.20279437f, 
    -0.02722391f, -0.09107868f, 0.10800648f, -0.03833148f, 0.09355433f, 0.00996411f, 0.00476153f, 0.19652332f, 
    -0.04307033f, -0.59219974f, -0.57620394f, 0.14877498f, 0.17902830f, 0.08103311f, -0.14522225f, -0.08801289f, 
    -0.07560075f, 0.01719955f, 0.03838394f, 0.06448511f, 0.60461414f, 0.49278373f, -0.14018098f, -0.26214948f, 
    0.24222896f, 0.37401590f, 0.18346326f, 0.07216867f, -0.11986510f, -0.00911303f, -0.01844533f, -0.01756716f, 
    -0.30327535f, -0.12158820f, 0.07434812f, -0.11112100f, -0.03793158f, -0.00824281f, 0.12156700f, -0.01984767f, 
    -0.20936793f, -0.05960127f, -0.19792144f, -0.30676439f, -0.11435913f, -0.07876109f, 0.35004631f, -0.20724790f, 
    0.02365633f, -0.11547555f, -0.07769947f, 0.08634949f, -0.09814630f, -0.12779534f, -0.15031262f, -0.08273184f, 
    0.38832852f, 0.33042559f, 0.41391921f, 0.02453975f, -0.04940396f, 0.11998779f, 0.04851095f, -0.11417300f, 
    0.11132263f, -0.03916319f, 0.08630507f, -0.02492654f, -0.03147288f, 0.06068441f, -0.27679923f, -0.08840916f, 
    -0.03731576f, 0.17783114f, 0.04425197f, -0.05094401f, 0.22043793f, -0.09949724f, 0.00219766f, -0.02368404f, 
    0.19104065f, -0.22064596f, 0.41395921f, -0.34822971f, -0.12820551f, -0.03816786f, 0.17230138f, 0.04143041f, 
    0.06725927f, 0.00244837f, 0.11565218f, -0.03997986f, -0.22179610f, -0.08233763f, -0.19622599f, -0.51541162f, 
    -0.24806350f, -0.13103428f, -0.32840943f, -0.07569832f, -0.03176474f, -0.02632062f, 0.01850770f, 0.16397554f, 
    0.35066351f, 0.34840184f, 0.13374756f, 0.21520267f, -0.03036546f, -0.02004083f, -0.03958777f, -0.02765736f, 
    -0.01345960f, -0.01642080f, -0.00142954f, 0.20977218f, -1.13540983f, -0.03584772f, 0.03331371f, 0.07058151f, 
    0.33572012f, -0.14568712f, -0.23881833f, -0.00341697f, -0.05706757f, -0.00236968f, -0.06886631f, -0.23539829f, 
    0.15072522f, 0.03607895f, -0.29566577f, -0.43212149f, -0.01759271f, -0.28982744f, -0.16655664f, -0.07398960f, 
    -0.19190380f, 0.02114932f, 0.06148683f, 0.04926513f, 0.13985367f, 0.13636425f, -0.18827645f, 0.03588008f, 
    0.07679150f, 0.23265046f, 0.28761706f, 0.25197163f, -0.07587299f, 0.08666028f, -0.47020662f, 0.24707599f, 
    -0.64324743f, -0.76736116f, -0.41209590f, -0.08512480f, -0.03129028f, 0.14716192f, 0.29620403f, -0.24866350f, 
    0.07160290f, 0.13962497f, 0.13965620f, 0.05428041f, -0.11867377f, 0.09840411f, 0.06407487f, 0.16331752f, 
    -0.12809934f, 0.13969460f, 0.14842099f, -0.10428225f, -0.00378620f, 0.00385019f, -0.04375907f, -0.01685312f, 
    0.74786675f, -0.05424354f, 0.01221651f, 0.03087930f, -0.27547836f, -0.00877483f, 0.17183515f, -0.02197683f, 
    -0.02770028f, 0.04359381f, -0.15341954f, 0.06815091f, 0.17414050f, -0.09195712f, -0.05651418f, 0.09206767f, 
    -0.02014792f, -0.01080614f, -0.03753453f, -0.03758296f, -0.34185603f, -0.50567645f, -0.19600929f, -0.36472860f, 
    1.15644073f, -0.18191209f, -0.09560262f, -0.27310422f, -0.07291173f, 0.02424353f, 0.12046406f, -0.07529677f, 
    -0.00092360f, -0.07222199f, -0.12165306f, -0.20659505f, 0.60028839f, 0.14665611f, 0.09892782f, 0.39127889f, 
    0.14225312f, 0.23959251f, -0.26716289f, -0.38915077f, 0.07387496f, -0.01240718f, -0.06280757f, -0.06758758f, 
    0.13795769f, 0.18255542f, 0.06610195f, 0.18538721f, -0.07660940f, 0.02578060f, -0.07705280f, -0.05074716f, 
    0.01585682f, -0.06015256f, -0.03063570f, 0.17368199f, -0.30961779f, 0.10564672f, 0.03148748f, -0.12904648f, 
    0.27605861f, 0.06254701f, -0.08520944f, -0.09364814f, 0.12723632f, 0.05421038f, -0.16630709f, 0.06257036f, 
    -0.45294085f, 0.04212632f, 0.47162935f, -0.06894663f, -0.10199305f, 0.02988217f, -0.01957703f, 0.07412667f, 
    0.01596727f, -0.00427512f, 0.12968017f, 0.04392337f, -0.22042707f, 0.29012462f, 0.02007083f, 0.26382279f, 
    -0.20485605f, -0.00323621f, 0.10302841f, -0.09560643f, -0.02705585f, -0.05212015f, 0.18836793f, 0.14274175f, 
    0.08124665f, -0.24812797f, -0.50956255f, 0.06702410f, -0.15860763f, 0.01799236f, 0.22010520f, -0.13302468f, 
    -0.04593528f, -0.01219054f, -0.25059205f, -0.03679330f, -1.56215632f, -0.31649110f, -0.18371785f, -0.33798075f, 
    0.19322976f, 0.15573008f, -0.13632269f, -0.10724232f, -0.01903176f, -0.12543830f, 0.04439458f, -0.15783387f, 
    -0.19374491f, -0.20296139f, -0.35427421f, -0.20626801f, -0.09082787f, -0.06531775f, -0.02493789f, 0.10626553f, 
    -0.02263404f, -0.09519702f, -0.18652353f, 0.11052694f, 0.44275582f, -0.24979663f, 0.24969319f, 0.45177501f, 
    -0.22065862f, 0.24248156f, -0.06187373f, -0.20637308f, -0.00657677f, -0.04912807f, 0.06444085f, 0.16383721f, 
    -0.73203760f, 0.05953604f, 0.45398155f, -0.51169950f, -0.05599026f, -0.07693923f, -0.12678382f, 0.05954126f, 
    -0.00861224f, -0.06181569f, 0.02017998f, 0.05415072f, -0.30987889f, 0.55241776f, -0.13745953f, -0.41466579f, 
    -0.06717840f, 0.10383087f, -0.10660396f, 0.08241770f, -0.10233304f, -0.14856651f, -0.35968336f, 0.09965747f, 
    0.00897709f, 0.23804663f, 0.28142861f, 0.34996861f, -0.05949591f, 0.05216523f, 0.15576084f, 0.03821836f, 
    -0.07142480f, -0.09991647f, 0.14752924f, -0.08233860f, -0.48580354f, -0.38658321f, -0.40862086f, -0.32725319f, 
    0.05965516f, -0.26850140f, 0.25169760f, -0.13645425f, 0.07582354f, -0.05140002f, 0.03187534f, -0.01466993f, 
    -0.53274274f, -0.03823690f, 0.08561903f, -0.00794694f, -0.38278204f, -0.11087616f, -0.19415462f, -0.03584367f, 
    0.09956792f, -0.06722520f, -0.16019189f, 0.13965960f, 0.07654636f, 0.01547077f, 0.04508288f, -0.09863882f, 
    0.00132291f, -0.02933515f, -0.05578084f, 0.14233789f, 0.28674883f, 0.17682421f, 0.02126184f, 0.00646497f, 
    -0.49188089f, 0.92186970f, 0.65228516f, 0.03040889f, 0.05795667f, 0.04608278f, 0.23526083f, -0.18420625f, 
    0.06501427f, 0.10962132f, -0.04453422f, 0.02102091f, -0.24403164f, -0.01859394f, 0.65225244f, 0.93324333f, 
    -0.07755720f, -0.00534985f, -0.19298345f, 0.21530545f, -0.00350435f, -0.01359972f, -0.01053210f, -0.01681120f, 
    -0.39454213f, 0.02347636f, -0.12665784f, 0.06489474f, -0.01767867f, -0.08144694f, 0.04829294f, 0.14852720f, 
    0.20044632f, -0.27704263f, 0.01885196f, 0.03302184f, -0.11839951f, 0.14602531f, -0.25460818f, 0.10176560f, 
    0.13591392f, -0.03092078f, 0.05186279f, -0.11740222f, -0.04058652f, 0.15835640f, 0.15403612f, -0.01757156f, 
    -0.42206919f, 0.04854578f, -0.14048132f, -0.02010274f, -0.04662347f, -0.33078015f, 0.06217659f, -0.64624488f, 
    -0.09885102f, 0.03776210f, 0.03901899f, -0.03111566f, -0.57421887f, 0.15160154f, -0.10522667f, 0.35432363f, 
    0.13379951f, 0.10320742f, 0.15573674f, -0.24041276f, -0.02429906f, 0.05433351f, -0.09855991f, 0.05225277f, 
    0.44736019f, 0.01249521f, -0.11602706f, -0.30138022f, 0.01946240f, -0.21166761f, -0.24473406f, -0.18325958f, 
    -0.21007344f, -0.13081354f, 0.14825468f, -0.01453418f, -0.23153517f, -0.31021789f, 0.10989580f, 0.47101468f, 
    -0.02232962f, 0.12283938f, 0.12121819f, 0.15880050f, 0.01959876f, -0.07878016f, -0.07861357f, -0.05608647f, 
    -0.34344453f, -0.05221082f, -0.04717711f, -0.36741525f, -0.01509030f, -0.45670977f, -0.17462143f, -0.01569464f, 
    0.02384717f, -0.04499832f, -0.17381522f, -0.19491208f, 1.07667458f, 0.73692834f, 0.23546700f, 0.11180109f, 
    -0.08006419f, 0.15683721f, 0.02022412f, -0.16280940f, -0.29271263f, -0.22370186f, -0.02213171f, 0.15959091f, 
    -0.03466031f, -0.53432173f, 1.08895421f, 0.09191192f, -0.30588043f, 0.01302269f, -0.14008598f, 0.12959099f, 
    0.14274669f, 0.02733275f, 0.04124657f, 0.30512780f, 0.18178995f, -0.16903009f, -0.02485269f, 0.46891037f, 
    0.13596861f, -0.02589441f, 0.20253024f, -0.04572121f, 0.01632793f, 0.30031949f, -0.02055234f, 0.08377178f, 
    0.34084636f, 0.03563022f, -0.49579406f, -0.21158400f, 0.17965400f, -0.08061174f, 0.09979440f, -0.12383351f, 
    0.01534833f, -0.01427782f, -0.19773018f, -0.42204168f, -0.02856433f, -0.13347271f, -0.13134356f, 0.23180060f, 
    0.17744903f, 0.05997360f, 0.02850568f, -0.04663300f, -0.02398535f, 0.03548995f, -0.12295507f, 0.01589240f, 
    -0.71986616f, 0.03399807f, 0.22793153f, 0.63898587f, 0.03800929f, -0.15901157f, -0.14658506f, -0.17995539f, 
    -0.37221330f, -0.11536935f, -0.04874002f, -0.13451338f, -0.42749232f, 0.81759644f, -0.28587419f, 0.08874220f, 
    0.04373491f, 0.10263329f, 0.09453967f, -0.03314560f, -0.33785769f, 0.09374993f, 0.03183102f, 0.03158176f, 
    -0.53013319f, -0.03459666f, 0.05505251f, 0.39141220f, 0.15825529f, 0.20739533f, 0.24228959f, -0.20451261f, 
    0.00849303f, 0.07173305f, 0.30651554f, 0.18973508f, 0.10919654f, -0.28801236f, -0.14118347f, 0.15405187f, 
    0.08371410f, -0.08638308f, -0.02583121f, -0.20431533f, -0.02801477f, 0.18019596f, -0.03696466f, 0.23127653f, 
    -0.07574649f, -0.39059851f, -0.01385961f, -0.99216580f, 0.19714203f, 0.18307126f, -0.07043119f, -0.09946683f, 
    -0.19089843f, 0.10673714f, -0.07916087f, -0.02469960f, -0.13906047f, -0.00092902f, -0.14639170f, -0.02059797f, 
    -0.34383303f, -0.54408771f, -0.11339132f, 0.18123217f, -0.10591976f, 0.32148930f, -0.33428818f, -0.06385110f, 
    -0.82041222f, -0.78888881f, -0.98555285f, -0.32286519f, 0.03165945f, -0.03580265f, -0.10473552f, 0.07630441f, 
    0.01562132f, 0.05433338f, -0.17036879f, -0.14445646f, 0.16740641f, -0.16724636f, 0.27836710f, 0.10101949f, 
    -0.10199420f, -0.05516406f, -0.14596860f, -0.03110518f, 0.10610966f, -0.01832088f, 0.06152077f, 0.13227256f, 
    -0.48344702f, -0.01502635f, 0.08749502f, 0.02999914f, 0.00145565f, 0.02511476f, -0.04534414f, -0.06523288f, 
    -0.03238038f, -0.11818498f, -0.23546186f, 0.00522563f, 0.20330024f, 0.36082235f, 0.40983975f, 0.09797191f, 
    0.18562639f, -0.02751293f, -0.00042083f, 0.24510451f, 0.02032530f, 0.05633055f, 0.04551332f, -0.08895113f, 
    0.11521769f, -0.19113736f, -0.11621702f, -0.03049889f, 0.06515913f, -0.00394558f, 0.10344057f, 0.04607210f, 
    0.03502908f, 0.10081761f, 0.07645851f, 0.10807423f, -0.24628013f, -0.21454293f, -0.12570661f, -0.15085593f, 
    -0.43175119f, -0.27411476f, 0.20180123f, -0.18572928f, -0.03281441f, 0.06975859f, -0.00946761f, 0.00881646f, 
    0.55732644f, 0.34713495f, -0.32135022f, 0.67391151f, 0.11935236f, 0.09691739f, 0.26902381f, 0.09496626f, 
    0.19936647f, -0.07009646f, -0.01596960f, 0.00797456f, 0.01181427f, 0.14134113f, 0.20673966f, 0.21300003f, 
    -0.07032993f, -0.14306001f, -0.14301625f, -0.04117559f, -0.08475576f, -0.07266983f, 0.09967635f, -0.23131654f, 
    0.15212162f, -0.22006278f, 0.23468360f, -0.24341521f, -0.32937461f, -0.14469434f, -0.27152237f, 0.25206298f, 
    -0.05761357f, -0.16159073f, -0.06735657f, -0.01719839f, 0.24410495f, 0.05949406f, 0.37980193f, 0.07669211f, 
    -0.15069319f, -0.04752778f, -0.06633986f, 0.19539557f, 0.14952803f, -0.11512880f, 0.01696063f, -0.06371026f, 
    0.17556866f, -0.04278599f, -0.12927386f, -0.13406831f, 0.16292879f, 0.02046625f, -0.01919855f, -0.05102490f, 
    0.01125115f, 0.01805559f, 0.11933620f, -0.24713494f, 0.06208218f, -0.47240916f, 0.17929466f, 0.02973884f, 
    -0.03605058f, 0.03875586f, 0.01403017f, -0.14384368f, 0.27658334f, 0.34848908f, 0.01311682f, 0.28249589f, 
    -0.39030728f, 0.20650436f, 0.17799023f, 0.14714649f, 0.07345507f, -0.14011447f, -0.14178337f, -0.16162436f, 
    -0.06512477f, -0.10393913f, -0.21576528f, 0.17374571f, -0.21789517f, -0.07342932f, 0.00797715f, 0.10686132f, 
    -0.22639647f, -0.13162446f, -0.10494215f, -0.14077617f, -0.03577432f, 0.03043978f, 0.10630415f, 0.16089045f, 
    0.17799115f, -0.14446315f, -0.34799698f, -0.01905530f, 0.00318719f, 0.06399290f, 0.11452190f, 0.17011885f, 
    -0.16836733f, 0.00239313f, -0.37305626f, 0.02794143f, 0.18824536f, -0.00631288f, -0.07664345f, -0.08553116f, 
    -0.25117195f, 0.18114856f, -0.20004591f, 0.17190082f, -0.27810445f, -0.13915406f, -0.05983210f, 0.04080835f, 
    0.21449216f, 0.30901077f, 0.07320485f, 0.28905049f, -0.04599469f, -0.04987729f, -0.04220403f, 0.24140541f, 
    0.02574424f, 0.06869278f, -0.11718048f, 0.21036378f, 0.42052236f, -0.06564040f, -0.00846318f, -0.38394612f, 
    0.00749994f, -0.01158693f, -0.18286166f, -0.03768916f, -0.10769314f, -0.29280183f, -0.09780227f, -0.20422021f, 
    -0.24173509f, -0.10750899f, -0.51688182f, 0.66238642f, 0.14198790f, -0.09815577f, 0.01409321f, -0.01194778f, 
    -0.02066722f, 0.26070362f, -0.05162586f, -0.09541816f, 0.27665433f, 0.32712793f, 0.05830931f, -0.03392552f, 
    0.11058608f, 0.06847664f, 0.01152694f, -0.23567466f, 0.03432510f, 0.05938306f, -0.04861927f, 0.06985235f, 
    -0.31963515f, -0.39428672f, -0.02590263f, 0.48151582f, 0.12107238f, -0.04929575f, -0.03524480f, 0.01928162f, 
    -0.11305531f, -0.15054460f, 0.07379363f, 0.09087128f, -0.56366611f, -0.76499170f, 0.03568790f, -0.08584376f, 
    0.25592399f, 0.03418319f, -0.11225574f, 0.05063664f, -0.05639977f, -0.09458979f, -0.01429578f, -0.02830461f, 
    -0.32226133f, -0.49674132f, -0.30959746f, 0.37682390f, 0.12587000f, -0.01005728f, 0.09289221f, 0.14001310f, 
    0.00602441f, 0.04904727f, -0.08397170f, -0.12335276f, 0.07337482f, 0.23565254f, 0.05948311f, -0.23108508f, 
    -0.18373361f, -0.10464814f, 0.02310099f, -0.15965103f, 0.28981623f, 0.01071665f, 0.32601961f, -0.09999937f, 
    -0.16449124f, 0.38852793f, -0.16503088f, 0.14840476f, 0.21950480f, 0.14804029f, -0.34014541f, 0.05924795f, 
    0.22824340f, 0.18898420f, -0.00974184f, 0.12688170f, -0.05393077f, 0.18753611f, -0.04522993f, 0.03099831f, 
    0.24130066f, 0.04431085f, 0.25436732f, 0.10197253f, 0.02716205f, 0.03755022f, 0.15513866f, 0.17407799f, 
    -0.36642650f, -0.12816191f, -0.16292372f, -0.11749730f, 0.31654838f, 0.11135464f, -0.10802156f, 0.14498280f, 
    0.21398516f, -0.04761500f, 0.09921463f, 0.09035967f, -0.11876645f, -0.02932787f, 0.15863740f, -0.13982485f, 
    0.01497051f, 0.01645920f, 0.02717931f, 0.05896057f, -0.17043106f, -0.29209039f, -0.33325928f, -0.38915643f, 
    -0.31346005f, -0.50839263f, -0.69833559f, -0.45433146f, 0.04198395f, 0.02711837f, -0.17399168f, 0.19351864f, 
    0.23544428f, -0.10314476f, 0.02962565f, -0.25013280f, -0.47345465f, 0.23157482f, 0.28635159f, -0.24759457f, 
    0.09629145f, -0.05451694f, 0.01131880f, 0.08882491f, 0.00289187f, -0.21248353f, 0.00474908f, 0.03250243f, 
    -0.12724888f, -0.27486500f, -0.07369041f, 0.08661115f, 0.04737019f, -0.00669742f, -0.10527802f, -0.04232472f, 
    0.02265406f, -0.28342116f, 0.40115222f, 0.11781271f, 0.35327157f, -0.40943629f, 0.05222278f, 0.41732946f, 
    0.16368040f, 0.07379174f, 0.04829988f, -0.13648830f, 0.03912299f, -0.21688892f, 0.16425307f, -0.13338083f, 
    0.31574625f, -0.37422872f, -0.71532816f, -0.39244309f, 0.00701965f, -0.02281363f, 0.03645190f, 0.05101630f, 
    -0.06750811f, 0.04943711f, -0.21636236f, -0.11017251f, -0.54111117f, 0.89679158f, 0.12693267f, -0.06926852f, 
    -0.21923280f, 0.27334717f, 0.10470776f, 0.08575026f, 0.13672878f, 0.08681221f, 0.14329542f, 0.10333794f, 
    0.06114447f, 0.03683173f, 0.25202355f, -0.26438022f, -0.00140569f, 0.17417480f, -0.22160576f, 0.15588078f, 
    -0.03995062f, 0.00810030f, 0.34288931f, 0.01979961f, -1.43632483f, -2.04042983f, -0.48793268f, 0.11553373f, 
    0.06334861f, -0.00556212f, 0.23382914f, -0.47818679f, 0.11603083f, -0.03338971f, -0.02293940f, 0.16143677f, 
    -0.22333020f, -0.11354535f, 0.09923320f, -0.03862859f, 0.10625362f, 0.04310220f, 0.07947270f, -0.28489611f, 
    -0.12980551f, -0.06354713f, -0.05863683f, -0.44917032f, -0.39906088f, -0.35373011f, -0.16501817f, 0.05940486f, 
    -0.07970230f, -0.00658256f, 0.09525130f, -0.05603014f, 0.03091338f, -0.06552529f, 0.16391127f, 0.14631921f, 
    -0.05347381f, -0.67112446f, -0.20164801f, -0.20087303f, -0.25587112f, 0.19613203f, 0.20525816f, -0.30847362f, 
    -0.13446580f, -0.07790204f, -0.05248038f, -0.02061551f, -0.84956020f, -0.54882324f, 0.12996581f, 0.01611041f, 
    0.07497941f, -0.19150925f, -0.16121261f, -0.19379136f, -0.13867052f, 0.11123535f, -0.12812214f, -0.21393697f, 
    -0.34154287f, 0.25682840f, 0.31030005f, -0.23315173f, -0.11732127f, -0.13400353f, 0.05716518f, -0.17074342f, 
    0.09954949f, 0.09006924f, 0.08721142f, 0.23248135f, -0.97825670f, -1.12548554f, -0.29840332f, -0.29320866f, 
    -0.20087308f, -0.40384033f, -0.35412425f, -0.67096847f, -0.04759861f, 0.03349126f, -0.17559196f, -0.01369777f, 
    0.60021842f, 0.35367140f, 0.22451276f, -0.60431486f, 0.14616449f, -0.22054751f, 0.04202966f, -0.12498259f, 
    0.11657450f, 0.08443712f, 0.01564338f, -0.02924494f, -0.28179950f, 0.10653707f, 0.12754646f, -0.08741259f, 
    0.10454544f, 0.03498674f, 0.09262513f, 0.09404733f, 0.20119560f, 0.13145643f, 0.37054148f, 0.10972293f, 
    0.21892080f, 0.93165588f, -0.03288619f, 0.42714587f, 0.05814098f, 0.04929483f, -0.03571719f, 0.16911337f, 
    0.11920881f, 0.06311855f, -0.02159414f, -0.08876073f, -1.16190982f, -1.25016713f, 0.41700786f, -0.03170402f, 
    -0.25633612f, -0.19934136f, 0.21312015f, -0.05356482f, -0.07388429f, 0.04093296f, -0.04491152f, -0.02458079f, 
    0.16492464f, 0.05875972f, 0.06387490f, -0.06524733f, 0.20450951f, -0.09447424f, -0.08830785f, 0.08840804f, 
    0.02921686f, 0.27781346f, 0.03762029f, 0.04292830f, 0.02817114f, 0.35473171f, -0.29959595f, 0.03478897f, 
    -0.47507307f, 0.19491200f, 0.09841363f, 0.03050752f, 0.21276720f, 0.09481934f, 0.18586887f, 0.20692512f, 
    -0.21282217f, -0.17409486f, -0.17442517f, -0.02909006f, 0.02047253f, -0.09612419f, -0.06501878f, -0.12888807f, 
    0.06607527f, 0.01711342f, -0.06544437f, -0.06125961f, -0.47694242f, -1.01685834f, -0.38343981f, 0.02269153f, 
    -0.20572612f, -0.05521304f, 0.46148208f, 0.01748300f, -0.01651917f, -0.00750737f, -0.03397119f, -0.11637647f, 
    -0.09067878f, 0.46827748f, -0.42609110f, 0.23515676f, -0.02446910f, -0.00657116f, 0.00215542f, -0.09850539f, 
    0.01077237f, -0.04613501f, -0.06111484f, 0.05151857f, -1.00369596f, -0.05725599f, 0.38164058f, 0.27553052f, 
    0.22652686f, -0.01522825f, 0.04476304f, 0.20001519f, -0.03981989f, -0.08382587f, 0.03356853f, -0.01686507f, 
    0.21046589f, 0.33730119f, 0.09160861f, -0.22190279f, -0.02862653f, 0.06885719f, -0.04785010f, 0.03470663f, 
    0.11428926f, 0.18263766f, 0.03550335f, -0.29930925f, 1.00779605f, -0.20706993f, -0.10696328f, -0.18073615f, 
    -0.25680146f, -0.25036368f, 0.08097675f, -0.28467974f, 0.01564966f, 0.12779473f, 0.08346248f, 0.12027859f, 
    -0.18872708f, 0.32977149f, -0.32801104f, -0.04018059f, 0.10921702f, -0.17742550f, -0.03248910f, 0.04690060f, 
    0.09880914f, 0.07810821f, 0.04365341f, 0.12286329f, -0.84572750f, -0.47382623f, -0.28993309f, 0.49945059f, 
    -0.18610311f, 0.02414999f, 0.00036189f, 0.16847001f, -0.05734283f, -0.14743824f, 0.23335673f, -0.02549199f, 
    0.53300881f, 0.77181721f, -1.16289890f, -0.13032213f, 0.17375825f, -0.25235531f, 0.02154859f, -0.33015841f, 
    -0.06903953f, -0.03331902f, 0.02717565f, 0.20770940f, -1.06685412f, -0.71838027f, -0.52037734f, 0.05962915f, 
    0.31436443f, 0.03022737f, -0.08453234f, 0.13697551f, 0.06087983f, 0.01044007f, -0.09791283f, -0.04058209f, 
    0.05460367f, 0.38039601f, -0.14176936f, 0.09568746f, -0.01723832f, -0.09797402f, 0.21926352f, -0.04937132f, 
    -0.03689733f, -0.08235934f, -0.02476959f, -0.03241510f, 0.40958208f, -0.43877715f, -0.10544819f, -0.42958122f, 
    0.00768323f, -0.07015238f, 0.02594494f, 0.04440283f, 0.22831450f, 0.21042429f, 0.19093786f, -0.19221163f, 
    -0.37339461f, -0.42965639f, -0.11982222f, -0.12753221f, -0.21573402f, -0.05961686f, 0.22643188f, -0.05260484f, 
    -0.05067416f, -0.01532851f, 0.00784060f, 0.17645632f, 0.19736938f, -0.71171409f, 0.12762299f, -0.62602860f, 
    -0.02038999f, -0.17719547f, -0.10319136f, 0.53438824f, 0.02552783f, 0.04448330f, -0.11612567f, -0.00941376f, 
    0.21430808f, 0.19235399f, 0.19317062f, -0.44900408f, -0.04680173f, 0.09151390f, -0.04464854f, -0.15101789f, 
    -0.12265930f, -0.04041298f, -0.38963461f, -0.42019448f, 0.20542796f, -0.11583964f, 0.10026295f, 0.10020624f, 
    -0.19488473f, 0.07387006f, 0.15853548f, -0.23952089f, -0.22404385f, -0.13559350f, -0.22787854f, 0.23826720f, 
    0.19942583f, 0.27868772f, 0.18991742f, -0.05357523f, 0.00228620f, -0.09811618f, -0.10550315f, -0.08892966f, 
    0.11517118f, -0.11034191f, 0.09845688f, 0.29887059f, 0.51211566f, -0.20043999f, -0.26059815f, 0.10570418f, 
    0.19061652f, 0.21966377f, 0.08778165f, 0.12939365f, -0.15829213f, -0.57013983f, -0.37995198f, -0.40069121f, 
    0.20836516f, 0.38434169f, -0.06252793f, -0.17794164f, 0.06016886f, 0.48688141f, 0.04558565f, 0.19634600f, 
    0.18127511f, 0.25504690f, 0.28135321f, 0.22177523f, 0.08087919f, -0.06007431f, -0.25521320f, -0.06547350f, 
    -0.25585592f, 0.06418786f, -0.15800184f, -0.30251321f, 0.03946859f, 0.04624235f, 0.06089441f, -0.03287360f, 
    0.11915109f, -0.01505857f, -0.10595154f, -0.32627618f, -0.12827526f, -0.02213328f, -0.05688264f, -0.02629592f, 
    -0.21306312f, -0.13675080f, 0.07172505f, 0.00873522f, 0.10173886f, -0.30833948f, -0.59962565f, -0.62660164f, 
    0.35423148f, 0.16996792f, 0.04895728f, 0.36371416f, -0.00341082f, -0.02333917f, -0.05796769f, 0.05368971f, 
    -0.64260650f, 0.38625789f, 0.31860894f, 0.04200124f, -0.01827853f, -0.13855861f, -0.34910491f, -0.21424155f, 
    -0.16105519f, -0.02724983f, -0.08655144f, -0.02387261f, -0.80642426f, -0.84420067f, -0.40705967f, 0.63422936f, 
    0.07324977f, 0.23372114f, 0.11143731f, 0.16765548f, 0.12135487f, 0.27765885f, 0.34367564f, 0.35103014f, 
    0.27594668f, -0.77020758f, -0.37954426f, 0.04893978f, -0.25719202f, -0.03115164f, 0.20776835f, 0.21947397f, 
    0.15678455f, -0.13330375f, 0.02279794f, -0.10550141f, 0.13003269f, -0.22310914f, -0.58314651f, 0.18346408f, 
    -0.13073210f, 0.04820917f, 0.06127866f, 0.05806268f, -0.07180002f, 0.25866279f, -0.09190856f, 0.15353362f, 
    -1.22693980f, -0.32078299f, 0.08110070f, 0.14338179f, 0.08297706f, 0.17045258f, -0.11696338f, 0.11977575f, 
    0.16129246f, 0.12174164f, 0.19291148f, 0.23867786f, 0.44427961f, -0.02412255f, -0.03163267f, -0.17925620f, 
    -0.09354567f, -0.18191117f, 0.09809587f, -0.07770137f, 0.00200672f, -0.30137706f, -0.25794205f, -0.40725613f, 
    -0.73195237f, -0.82507735f, 0.21325916f, 0.37978140f, -0.10962155f, 0.13358448f, 0.13349637f, -0.07807399f, 
    -0.00896442f, 0.11809789f, 0.06646782f, 0.08986972f, 0.36230424f, -0.46683937f, -0.68856937f, -0.39751795f, 
    -0.13668419f, -0.20180193f, 0.27612448f, -0.13827141f, -0.07111529f, -0.15702400f, -0.03865337f, -0.06072171f, 
    0.06147155f, 0.11436381f, -0.08285468f, -0.53317034f, -0.02080818f, -0.05075322f, 0.04608573f, -0.10908883f, 
    0.27146980f, 0.03320630f, 0.07135404f, 0.12037697f, -0.02386903f, 0.01091354f, -0.31071469f, -0.09445515f, 
    0.29041997f, 0.24741849f, 0.30267975f, -0.37563533f, -0.07659328f, -0.01185982f, 0.04534108f, -0.15035872f, 
    -0.22738653f, -0.15369055f, -0.07439478f, -0.08436151f, 0.24500163f, -0.00573809f, 0.21696833f, -0.25963393f, 
    0.02135211f, -0.06894106f, 0.04561016f, -0.01815063f, -0.14696237f, -0.10751936f, 0.78289330f, -0.31516719f, 
    0.08712111f, -0.35000598f, -0.22945321f, 0.04679551f, 0.00385623f, 0.13150562f, 0.00087472f, -0.00253653f, 
    -0.37545288f, 0.37414467f, -0.21123251f, 0.10581341f, 0.12900782f, -0.33535054f, -0.15238214f, -0.13035989f, 
    0.11439289f, -0.23982859f, 0.06776804f, -0.03611413f, 0.27978605f, -0.23367190f, -0.15801239f, -0.10883877f, 
    -0.34640807f, 0.04187708f, 0.05546140f, 0.41932625f, 0.05956956f, 0.22221872f, 0.04872709f, -0.17109789f, 
    -0.65913767f, -0.45346555f, -0.35858932f, 0.29641360f, -0.01819973f, 0.35112581f, -0.01223778f, 0.20211336f, 
    0.20538831f, 0.06248075f, 0.15038346f, -0.03312672f, -0.34802493f, 0.66136366f, -0.65338463f, 0.76489717f, 
    -0.31903499f, -0.25889230f, -0.19665577f, -0.45415995f, 0.33822912f, -0.25361794f, -0.08574981f, -0.09479804f, 
    0.02135400f, 0.01683764f, -1.16413343f, 0.33702970f, 0.32933530f, 0.29078081f, 0.34869131f, 0.12780961f, 
    -0.01887208f, -0.06632426f, 0.13974972f, 0.03033288f, -0.07135896f, 0.03347873f, 0.32335913f, -0.71781093f, 
    -0.14409755f, -0.20370242f, -0.00534438f, 0.11390706f, 0.01837455f, 0.22164287f, -0.15986651f, -0.09346151f, 
    -0.19119328f, 0.10919642f, -0.02727560f, 0.42606193f, 0.12921430f, -0.53220481f, -0.20657481f, -0.04960274f, 
    -0.28432542f, -0.20517708f, -0.04187351f, 0.01146981f, -0.16413613f, 0.11364917f, -0.06334948f, -0.01909180f, 
    -0.06359237f, 0.02611111f, -0.26209232f, 0.36085105f, 0.01678845f, -0.04046859f, -0.09281424f, -0.09778535f, 
    -0.31953606f, 0.04945860f, -0.09679520f, -0.41754484f, 0.17697331f, -0.29708341f, 0.14731838f, 0.06694435f, 
    0.19978577f, -0.10296849f, -0.27774936f, -0.25311378f, -0.10161772f, -0.34578484f, 0.34983960f, 0.48277384f, 
    -0.02552335f, 0.00063680f, -0.13553254f, 0.07926998f, 0.02976630f, 0.07241611f, 0.30289954f, 0.22440939f, 
    0.25138023f, -0.17115760f, 0.66338766f, -0.99169451f, -0.08353159f, -0.28476766f, -0.18417461f, -0.15561815f, 
    -0.19361147f, -0.02277829f, 0.19456536f, 0.02410007f, -0.54994899f, -0.08094603f, 0.17481405f, -0.28423136f, 
    -0.09487154f, 0.04067008f, 0.01330113f, 0.08418026f, 0.10904068f, 0.06107750f, 0.13277675f, 0.00276769f, 
    0.26737177f, -0.09962492f, 0.24226144f, 0.41789874f, -0.01280090f, 0.12795362f, -0.04022307f, -0.31229541f, 
    0.14818969f, 0.14694209f, 0.00516809f, -0.05975764f, 0.12932119f, 0.03167204f, -0.40658203f, 0.01724933f, 
    0.04471768f, -0.30433062f, 0.03204153f, 0.03793836f, 0.11753958f, 0.01444252f, 0.04904129f, -0.04755500f, 
    -0.23833655f, 0.37492910f, 0.30474809f, -0.10046349f, -0.01084394f, 0.06583809f, -0.14642473f, 0.02322251f, 
    0.05587695f, 0.04727778f, 0.30789274f, 0.01873627f, -0.42791077f, 0.32115555f, -0.20500399f, 0.43177280f, 
    0.19349234f, -0.19485065f, -0.25922823f, 0.30558330f, 0.00502608f, -0.34493858f, -0.54249632f, -0.25006926f, 
    0.22987114f, 0.08501155f, 0.54302585f, -0.28397021f, 0.06913509f, 0.00964595f, 0.06310564f, 0.21691291f, 
    0.14117526f, 0.01353167f, 0.09581322f, -0.04752272f, -0.14629164f, -0.62500918f, 0.16987537f, -0.02120483f, 
    0.24647075f, 0.13914004f, -0.44852370f, -0.10200022f, 0.09698357f, 0.07320306f, -0.00908632f, -0.30877778f, 
    -0.24177185f, -0.19244839f, 0.42473695f, -0.87750232f, -0.10296588f, -0.30092442f, -0.28480428f, -0.28843620f, 
    0.29736134f, -0.28668138f, 0.03349946f, -0.00847546f, 0.12463373f, 0.64472753f, 0.06617764f, -0.25334346f, 
    -0.06310723f, 0.07609912f, 0.02839345f, 0.54805595f, -0.19995676f, 0.25441274f, -0.24026017f, -0.19434269f, 
    -0.03315036f, -0.65809411f, -0.25710377f, -0.08837179f, -0.35304174f, -0.44180012f, 0.10976195f, 0.07158390f, 
    -0.18935461f, 0.17953582f, -0.20157565f, -0.19110370f, 0.03389042f, -0.24929938f, 0.46372172f, -0.26102760f, 
    -0.03459495f, 0.05731678f, 0.19481543f, -0.18383934f, -0.09968618f, -0.12757501f, 0.30525118f, 0.11434748f, 
    0.53731430f, 0.33112970f, 0.55919951f, -0.08582262f, -0.08843288f, 0.01383860f, -0.08386157f, 0.40656504f, 
    0.07725921f, 0.20100507f, 0.07397440f, 0.01366720f, -0.51309747f, -0.26441383f, 0.34988341f, 0.30621743f, 
    -0.06574150f, 0.28811061f, -0.04427833f, 0.24834581f, -0.10384738f, -0.09445809f, 0.30064675f, 0.38428366f, 
    -0.05989475f, 0.21116936f, 0.23520009f, 0.11743364f, 0.07034565f, 0.31965593f, -0.09684823f, 0.05166515f, 
    -0.20626555f, -0.05077940f, 0.25999299f, 0.11999993f, -0.19663651f, 0.28259531f, -0.09281357f, -0.24322601f, 
    -0.02621596f, 0.12854633f, 0.05425867f, -0.08976910f, -0.22242787f, -0.34169957f, -0.48644572f, -0.56317854f, 
    -0.16292731f, 0.19951095f, -0.29617211f, 0.55131525f, -0.07826732f, -0.37516761f, -0.05555794f, 0.02274095f, 
    0.02114939f, 0.14552534f, 0.05711262f, -0.30344531f, -0.19574420f, -0.46622348f, -0.28283677f, 0.00590666f, 
    0.00019764f, 0.02496013f, -0.03891779f, 0.13539073f, -0.04454018f, 0.10741055f, 0.16974628f, -0.10335426f, 
    -0.73944581f, 0.33911130f, -0.17059664f, -0.11650658f, 0.01342390f, 0.08639234f, -0.11384498f, -0.10501297f, 
    -0.05134599f, -0.11969417f, -0.20066185f, -0.17996550f, -0.65871763f, 0.47250113f, 0.06197480f, -0.06537385f, 
    -0.14415093f, 0.35884812f, -0.24965736f, 0.20569952f, -0.28677052f, -0.31509081f, -0.03262342f, -0.16756049f, 
    0.53386372f, -0.07156348f, 0.46798548f, 0.32135829f, 0.04973202f, -0.01783984f, -0.14385004f, 0.31237045f, 
    -0.48054403f, -0.02733568f, -0.05582654f, -0.23057307f, -0.33605403f, -0.54741085f, 0.08108896f, -0.10025928f, 
    0.01628940f, -0.28883669f, 0.14728346f, 0.27700177f, -0.17371374f, 0.36555642f, 0.13415934f, 0.01074121f, 
    0.24463654f, -0.39370108f, 0.04245408f, -0.10573132f, -0.06658529f, 0.16136445f, -0.02818558f, -0.01068415f, 
    -0.22421232f, 0.07948124f, -0.10668720f, 0.07958136f, -0.29211292f, -0.73947608f, 0.09549977f, 0.33925644f, 
    -0.51108414f, -0.42872408f, 0.03297343f, -0.29439014f, -0.06646755f, 0.19449095f, -0.09583008f, 0.05803815f, 
    0.28302851f, 0.10240263f, 0.04109033f, 0.10498428f, -0.09651046f, 0.08248900f, 0.04060002f, -0.01627629f, 
    0.08492077f, 0.17045359f, -0.16435538f, -0.22472867f, -0.00089824f, -0.52536017f, 0.22526810f, -0.25481117f, 
    0.07466727f, 0.26283774f, 0.28848603f, -0.01462933f, -0.01766194f, -0.13606077f, 0.19874546f, 0.20620514f, 
    0.73991334f, 0.08824339f, 0.74138403f, -0.65233582f, -0.14888862f, 0.03770662f, -0.28935507f, -0.09004426f, 
    -0.08115719f, 0.02358548f, -0.01047718f, -0.00323725f, -0.55680895f, -0.36780649f, -0.26661596f, -0.42511615f, 
    0.04880708f, -0.24355440f, -0.12696718f, -0.07134677f, -0.09771121f, 0.12592164f, -0.01172987f, 0.08362409f, 
    -0.34461996f, -0.16800675f, 0.69742763f, -0.29356724f, 0.20696075f, -0.04969025f, -0.03470733f, -0.00847884f, 
    -0.07024279f, 0.01585581f, 0.00917999f, 0.05164103f, -0.02724054f, -0.28004068f, 0.40588790f, 0.10331925f, 
    -0.24752387f, 0.25206998f, -0.10865313f, -0.20665906f, -0.00497487f, -0.16515446f, -0.19104077f, -0.40670344f, 
    0.18706685f, -0.20636979f, -0.04074255f, 0.27036384f, -0.12228108f, 0.13373175f, -0.05218756f, 0.34495854f, 
    -0.33407676f, -0.05186001f, -0.07662467f, 0.03688468f, -0.60410982f, 0.22233261f, -0.27257371f, 0.46118310f, 
    0.22480883f, 0.00479546f, 0.09293870f, -0.01494295f, 0.16718292f, 0.02557486f, 0.13180953f, 0.20696630f, 
    -0.94507504f, -0.11617789f, 0.11355393f, 0.23587333f, -0.27812353f, 0.13140492f, -0.04805395f, 0.17030878f, 
    -0.31883687f, -0.08065460f, -0.15360820f, -0.10690214f, -0.26046681f, 0.49563870f, -0.15097898f, 0.12267058f, 
    -0.25067163f, 0.07018850f, 0.29463017f, -0.06192797f, 0.00660875f, 0.20155317f, 0.04195228f, -0.06385393f, 
    -0.25998077f, -0.15861940f, -0.30969352f, 0.20828907f, 0.21884637f, -0.15928456f, 0.09561601f, -0.01052340f, 
    0.02549713f, 0.14177123f, 0.14821868f, -0.03357751f, 0.15752597f, -0.30154049f, 0.51579791f, 0.13388133f, 
    0.13075684f, -0.57021987f, 0.05348145f, 0.33731082f, 0.40024132f, 0.11224008f, 0.25690696f, 0.10467111f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.36086684f, 0.01735719f, 0.14856531f, -0.08407147f, -0.07775351f, 0.24346927f, 0.02119881f, -0.19396332f, 
    0.26662171f, -0.06438001f, 0.07246107f, -0.16335605f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
