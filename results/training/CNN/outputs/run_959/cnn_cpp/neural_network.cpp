#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.11874900f, -0.68008912f, -0.25436863f, -0.83144593f, 0.13295473f, -0.01287295f, 0.33771414f, -0.18743885f, 
    0.11219185f, -0.08070867f, -0.15945627f, -0.26611325f, 0.02748097f, 0.03540641f, -0.28767797f, -0.22348237f, 
    0.10880574f, 0.17398745f, 0.32101193f, 0.19285454f, -0.25408849f, 0.24515341f, -0.37644663f, -0.08692288f, 
    -0.39109027f, 0.78662390f, 0.35162437f, 0.27017033f, 0.33837301f, 0.39240319f, -0.21650667f, 0.03283167f, 
    -0.57726502f, -0.78264087f, 0.39577016f, 0.44228247f, 0.52735060f, 0.04835623f, 0.39256513f, -0.43169206f, 
    0.04295570f, -0.43194103f, -0.04888989f, 0.21806514f, -0.14561193f, 0.11559975f, 0.16625077f, 0.03030183f, 
    0.04272670f, 0.09761906f, -0.64054972f, 0.52034837f, -0.16365907f, -0.63092226f, 0.29781857f, 0.57588840f, 
    -0.30019361f, -0.39093947f, 0.26309878f, -0.52952272f, 0.13721520f, 0.44167149f, 0.10329592f, -0.07254893f, 
    -0.09901506f, -0.21905379f, -0.18395004f, -0.24633986f, -0.29222730f, 0.36227772f, 0.28575206f, -0.10552787f, 
    -0.20724250f, 0.22498024f, -0.34807590f, 0.14321190f, -0.23613794f, 0.13890865f, -0.60684830f, -0.57991099f, 
    -0.69318646f, -0.29714108f, -0.25701699f, 0.30463505f, 0.28200775f, 0.38176084f, -0.22268926f, -0.30115774f, 
    -0.23462826f, -0.38315865f, 0.04523463f, -0.38952595f, 0.26757249f, -0.03335881f, -0.25704932f, -0.08881524f, 
    0.13032721f, 0.18454880f, -0.06787743f, 0.25693992f, -0.23238526f, -0.39982179f, -0.20767002f, 0.34073442f, 
    0.09817789f, -0.26009083f, 0.92789650f, 0.88881761f, -0.77967179f, 0.48368055f, 0.22771846f, -0.39744598f, 
    0.12487774f, -0.52521026f, -0.14826527f, -0.00013619f, -0.23842500f, -0.32140604f, 0.10474357f, -0.48939627f, 
    0.13781966f, 0.07272115f, 0.06364781f, 0.07803239f, 0.25141111f, -0.54836720f, 0.88265735f, -0.17478894f, 
    -0.50828612f, 0.46600333f, -0.29887170f, -0.47167206f, 0.48480943f, -0.28109363f, -0.40102211f, -0.17310014f, 
    0.16505484f, -0.06941248f, 0.13766448f, -0.26360545f, -0.31685820f, 0.33376756f, -0.21994899f, -0.16154464f, 
    0.42184895f, -0.44098395f, 0.15894254f, -0.22872956f, 0.32618073f, 0.30449632f, 1.08637440f, -0.65062243f, 
    0.57115543f, 0.66517425f, 0.10645536f, 0.50642270f, 0.08293806f, -0.08964312f, 0.44917616f, -0.39678484f, 
    -0.43461123f, -0.29105666f, -0.09160727f, 0.02363607f, -0.30732980f, 0.08500392f, 0.09722402f, 0.20287234f, 
    0.08697484f, 0.31175864f, -0.25863579f, 0.26373744f, -0.21895634f, 0.16956572f, 0.10822689f, 0.25384277f, 
    0.38395193f, -0.58585346f, -0.27085972f, -0.14997241f, 0.50644630f, -0.05077097f, 0.73714691f, 0.48200917f, 
    0.48325562f, -0.71567559f, -0.27412429f, -0.05276752f, -0.30632260f, -0.08060040f, 0.06897697f, -0.01425704f, 
    0.00932420f, -0.01832329f, -0.28482223f, -0.16275835f, -0.02969817f, -0.33893150f, 0.19585092f, -0.35636696f, 
    -1.03958368f, 0.64612567f, -0.39737511f, 0.22465718f, -0.65368688f, 0.19337392f, -0.35438997f, 0.01544148f, 
    0.61478758f, -0.47197565f, -0.02204347f, -0.39292768f, -0.50228238f, -0.01287764f, 0.01418978f, -0.07457196f, 
    -0.06818355f, -0.25059080f, 0.01072694f, -0.11056987f, 0.10455149f, 0.08531421f, 0.06723502f, -0.02983334f, 
    -0.03759252f, 0.58355373f, 0.21274066f, 0.46789253f, 0.91175193f, 0.26112515f, 0.31282899f, -0.17972468f, 
    -0.30230969f, 0.36354184f, 0.62943023f, 0.07770592f, 0.07642662f, -0.07873716f, 0.15494788f, 0.10654048f, 
    -0.19759628f, -0.01843554f, 0.16911326f, -0.35716429f, -0.25538886f, -0.39491943f, -0.26977202f, -0.23329946f, 
    0.17791541f, 0.29131201f, -0.58360714f, -0.03794513f, 0.61510003f, 0.24429306f, -0.45071733f, -0.49117348f, 
    0.22177573f, -0.37461892f, -0.22361106f, -0.32927668f, 0.30170777f, 0.50474918f, -0.31394637f, -0.09497306f, 
    0.40382898f, -0.30857491f, 0.03317380f, -0.34931052f, -0.13447013f, 0.33787102f, 0.24856737f, 0.00206733f, 
    0.32467714f, 0.07690351f, 0.17499264f, 0.36204717f, 1.14566338f, 0.69454426f, -0.62164807f, -0.35825431f, 
    -0.59213722f, 0.65245068f, -0.13266781f, -0.37341878f, -0.36131358f, 0.00372152f, 0.14608464f, -0.32594734f, 
    0.00361355f, 0.17477688f, 0.06873381f, -0.12076236f, -0.04615214f, 0.11782198f, 0.04156424f, 0.14226857f, 
    0.09865581f, 0.16854393f, 0.17961732f, 0.05831646f, -0.18058559f, 0.68431836f, 0.01746174f, 0.32939413f, 
    -0.31229973f, 0.10416736f, 0.00120805f, 0.33830917f, 0.12185489f, 0.66707277f, -0.27972773f, 0.17975622f, 
    -0.55485708f, -0.21459982f, -0.60986906f, -0.21375187f, -0.26795334f, -0.54987597f, -0.26885143f, 0.03095803f, 
    -0.14080144f, -0.16354170f, 0.03809861f, -0.18159637f, -0.01401949f, -0.61803341f, -0.17745258f, 0.33262858f, 
    -0.23131716f, 0.45892531f, -0.03773151f, 0.62258023f, 0.09566429f, 0.29096100f, 0.69499439f, -0.48422834f, 
    -0.17565420f, -0.36707032f, 0.03862839f, 0.12569076f, 0.38806495f, -0.05650686f, -0.07628210f, -0.17458346f, 
    0.16172108f, -0.07991787f, 0.04236927f, -0.41754165f, -0.43518046f, -0.06846174f, -0.33512855f, -0.77326155f, 
    -0.13409270f, -0.38268742f, -0.46760222f, -0.42193684f, -0.15158696f, -0.26108724f, 0.11194034f, -0.30338189f, 
    0.35930842f, 0.23107836f, 0.15956330f, 0.51724565f, -0.00876593f, 0.26252007f, -0.11862087f, 0.36177197f, 
    -0.11176620f, -0.27248716f, 0.11468256f, 0.28583542f, -0.33162555f, 0.05877551f, 0.30555332f, -0.50574094f, 
    0.20893410f, 0.24462068f, 0.10636996f, 0.20040558f, -0.65242559f, -0.67303681f, -0.66186357f, -0.66013104f, 
    -0.37731341f, -0.17972790f, 0.47615415f, 0.01778042f, -0.36337790f, 0.04517064f, 0.13357092f, -0.27615175f, 
    0.06278416f, 0.02873624f, -0.23520407f, 0.13955747f, 0.39105299f, 0.06650966f, -0.02213119f, -0.31843537f, 
    -0.82459009f, -0.21954727f, 0.42021805f, -0.56686854f, 0.17300080f, -0.79890251f, 0.45182455f, 0.69980431f, 
    -0.14160749f, -0.36191577f, 0.24257398f, 0.24477759f, 0.15853617f, -0.23812388f, 0.25294766f, -0.05122964f, 
    -0.10408773f, -0.25293377f, 0.03810752f, 0.14004438f, 0.29763076f, -0.22642189f, -0.13134469f, 0.00857814f, 
    -0.23231211f, -0.11812129f, 0.55117345f, -0.02246973f, 0.64850521f, -1.02433693f, -0.20431609f, -0.37043470f, 
    0.15180425f, -0.14538485f, 0.22565198f, 0.32687977f, 0.15395342f, -0.34136522f, 0.08630722f, 0.28747541f, 
    0.40802243f, 0.05029130f, 0.08494165f, -0.25762030f, 0.15788893f, 0.12379852f, 0.08272561f, 0.05680251f, 
    -0.11010686f, -0.10041000f, 0.96137017f, -0.26655599f, -0.91379005f, 0.74092513f, 0.93101293f, -0.22135989f, 
    0.27282348f, 0.51320803f, 0.28932875f, -0.15927587f, -0.20614840f, -0.23920479f, -0.15424669f, -0.10108191f, 
    0.04938097f, -0.10369557f, -0.30468836f, -0.01494286f, -0.13795921f, -0.27486637f, 0.30693462f, 0.01527812f, 
    0.15007339f, 0.23018150f, -0.20487814f, 1.21714580f, 0.54104531f, 0.73309171f, -0.49229071f, -0.58665890f, 
    -0.05331887f, -0.82726741f, 0.31045911f, 0.10275574f, 0.41261658f, 0.43927756f, 0.31470838f, -0.12230584f, 
    0.10636109f, -0.27158371f, -0.05574554f, -0.14765137f, 0.03924967f, -0.28389269f, 0.02210809f, 0.05165151f, 
    0.23834287f, -0.04349706f, 0.03608882f, -0.02564246f, 0.46824056f, 0.90470123f, 0.55088198f, 0.19936989f, 
    0.49712825f, -0.42040825f, -0.38896871f, 0.11984908f, -0.15982024f, 0.22305988f, 0.45466512f, -0.28765231f, 
    -0.12208316f, -0.00446815f, -0.28004599f, -0.25522518f, -0.01560981f, -0.29762611f, 0.24912924f, 0.01459040f, 
    0.51646411f, 0.27816677f, 0.09064463f, 0.11964745f, 0.24285892f, -0.61068463f, 0.17160895f, -0.66791266f, 
    -0.74778265f, -0.64377689f, 0.45889944f, 0.25085273f, -0.34192848f, 0.42837191f, 0.70058495f, 0.17848031f, 
    -0.24401744f, 0.05134172f, -0.01652713f, -0.13883147f, 0.32431522f, 0.12959014f, 0.31231344f, 0.11819053f, 
    0.07511026f, 0.33152935f, -0.50545287f, -0.30401528f, -0.16269575f, 0.11483870f, -0.17975762f, -0.43403929f, 
    0.16596220f, 0.52756792f, -0.36864820f, -0.55733079f, -0.13213177f, 0.04692547f, -0.06999579f, -0.02196340f, 
    0.42241362f, 0.03023025f, 0.49030235f, 0.34382376f, 0.24201508f, 0.31578872f, 0.26031473f, -0.15755796f, 
    0.23311095f, 0.35040161f, -0.00436407f, 0.26659539f, -0.04702683f, 0.22121957f, -0.34838948f, 0.91654027f, 
    0.40565416f, 0.70264453f, 0.55697781f, 0.01000925f, 0.38779041f, -0.38033617f, -0.13104561f, -0.19874559f, 
    0.04346278f, -0.21626006f, -0.07593812f, -0.14565513f, -0.35322392f, 0.18536563f, -0.19999494f, -0.04834291f, 
    0.24352562f, -0.11662886f, -0.10868088f, 0.33824539f, 0.16325334f, 0.25741673f, 0.11590675f, 0.21407343f, 
    0.62833041f, 0.34294683f, 0.62642318f, 0.59830976f, 0.36521530f, -0.26817164f, 0.56607109f, 0.34397840f, 
    0.04863387f, -0.12224617f, 0.05959721f, -0.04043217f, 0.07426316f, -0.07294439f, -0.35722226f, 0.31513271f, 
    -0.33573553f, -0.27552935f, -0.22286959f, -0.04317925f, 0.13863288f, 0.18076450f, -0.17151359f, -0.03490028f, 
    -0.29435006f, 0.79718012f, 0.24235144f, -0.69267219f, -0.76075321f, -0.49960837f, 0.43788692f, 0.58213282f, 
    -0.00371550f, 0.16463171f, 0.30853173f, -0.25895447f, 0.15261881f, -0.51839828f, -0.13139491f, -0.10584200f, 
    -0.15696846f, -0.22306962f, -0.11244629f, -0.04699591f, -0.18417741f, -0.23584287f, 0.25059500f, -0.38823208f, 
    -0.13470216f, 0.20206885f, 1.09059489f, 0.65922379f, 0.09536440f, -0.22935110f, 0.40327418f, -0.22870511f, 
    0.10076207f, -0.23596306f, 0.55787343f, 0.00244314f, -0.17325963f, -0.16774587f, -0.08953501f, -0.14687786f, 
    0.00890689f, 0.11083217f, 0.37900513f, -0.20911784f, 0.01187681f, 0.53917301f, 0.19072442f, 0.08832444f, 
    -0.08257315f, -0.20083445f, 0.40011090f, 0.57053858f, -0.90507042f, -0.60620868f, -0.22696704f, 0.72573036f, 
    0.64987862f, -0.21430625f, 0.09292153f, 0.28737891f, 0.08096447f, -0.51921302f, 0.39817348f, -0.19824496f, 
    0.06737586f, 0.17038298f, -0.09791393f, -0.25789973f, -0.03157970f, 0.12839557f, 0.02503091f, 0.03150224f, 
    0.27120188f, 0.22026131f, 0.04901324f, 0.04801486f, 0.46136823f, 0.52452558f, 0.83987594f, 0.27349746f, 
    0.70970863f, 0.26693508f, -0.32233807f, -0.81170619f, 0.26348692f, -0.35359934f, -0.14989005f, -0.03821864f, 
    0.38282880f, 0.36138257f, -0.09800925f, 0.00642144f, 0.26354021f, -0.15805100f, -0.13288921f, 0.37356412f, 
    -0.19924690f, 0.00676368f, -0.09459822f, -0.21428582f, -0.26035124f, 0.17239575f, -0.54011828f, -0.09817594f, 
    0.04293125f, 0.76362044f, 0.79319763f, 0.03364306f, 0.35983506f, 0.11943647f, 0.39998382f, 0.18090813f, 
    0.20149191f, 0.16166231f, -0.16123165f, -0.08463664f, -0.38736635f, -0.29905453f, 0.21486810f, 0.07754046f, 
    -0.02674102f, -0.08419575f, 0.09886985f, 0.10165980f, -0.17545991f, -0.15171669f, 0.70002705f, 0.32216763f, 
    -0.06961250f, 0.37197635f, -0.05330884f, -0.44295886f, -0.41420186f, 0.09436822f, 0.14885756f, -0.05401413f, 
    0.32181618f, 0.15953349f, -0.13127179f, -0.34162515f, 0.09375905f, 0.33140889f, 0.12280952f, 0.31808642f, 
    0.21160787f, 0.05422726f, 0.01721142f, 0.36986479f, 0.25387287f, -0.18478388f, 0.50218952f, 0.52339238f, 
    -0.23460704f, -0.62854731f, -0.42513692f, -0.78831607f, 0.48324791f, 1.00020289f, 0.25029680f, 0.41347808f, 
    0.28646499f, 0.15197459f, -0.12450290f, -0.37845239f, -0.00209719f, 0.11249997f, 0.05458846f, -0.18575270f, 
    0.00191804f, -0.14061558f, -0.00560456f, -0.05972547f, 0.04375055f, -0.00565169f, 0.22374032f, -0.12873842f, 
    -0.91073161f, -0.83111244f, -0.60454720f, -0.30176136f, -0.23305488f, 0.32037371f, 0.12148089f, 0.19878584f, 
    0.02870156f, -0.13670586f, 0.26894307f, -0.25110468f, 0.23521718f, 0.49257150f, 0.32098812f, -0.07265338f, 
    -0.10416736f, -0.35631889f, -0.26992598f, -0.17547369f, -0.10032181f, -0.16020487f, 0.29959011f, -0.14866067f, 
    -0.06597925f, -0.02844877f, 0.06417244f, 0.36173758f, -0.64000010f, -0.13939372f, -0.73314869f, -0.61567861f, 
    -0.48000890f, -0.51105326f, -0.74758887f, -0.19217697f, 0.33469304f, 0.17107756f, -0.02144612f, 0.23051679f, 
    -0.44090655f, -0.14458796f, 0.24741769f, 0.01514194f, 0.28567889f, -0.06518951f, 0.18647999f, -0.05783089f, 
    -0.04548036f, 0.09049144f, 0.62754065f, 0.11388905f, 0.36357933f, -0.70957458f, 0.27521098f, -0.29437780f, 
    -0.45371294f, 0.12320904f, 0.14563125f, -0.38696718f, -0.32184440f, -0.03567988f, 0.30533385f, 0.32873783f, 
    0.24698496f, 0.44001716f, 0.17580055f, 0.17155221f, -0.23569141f, -0.46306086f, 0.13839956f, -0.05069885f, 
    0.18272325f, -0.10193469f, 0.32019839f, -0.67768461f, -0.48244131f, -0.05195517f, 0.74860966f, -0.17086549f, 
    -0.73346567f, 0.83537495f, 0.50135291f, -0.46496797f, 0.18946941f, 0.11251262f, 0.05320396f, 0.10141709f, 
    -0.22262861f, 0.03529983f, -0.15918609f, -0.03813979f, 0.15836634f, 0.00014418f, -0.08576751f, 0.06921422f, 
    0.08198521f, -0.37733412f, 0.23532061f, -0.44026777f, -0.43168280f, 0.73333317f, 0.23246260f, -0.08943873f, 
    0.39088219f, -1.16989124f, 0.24804237f, -0.00355091f, -0.60907000f, -0.46477541f, 0.08377133f, 0.08649020f, 
    -0.21453975f, -0.02201931f, -0.04859624f, 0.30221394f, -0.33800086f, 0.19858466f, -0.17028941f, -0.35162383f, 
    -0.34384623f, -0.05241889f, 0.07417570f, 0.24785009f, -0.04515579f, 1.08587348f, 0.46430281f, 0.11035857f, 
    0.97593367f, 0.41591111f, 0.75176185f, 0.38341793f, -0.40064421f, -0.38720858f, -0.35467920f, -0.23653717f, 
    -0.10838886f, 0.12909016f, 0.01662947f, -0.44200659f, 0.00799207f, 0.22683384f, 0.08485279f, -0.01231434f, 
    -0.06534682f, -0.13684233f, -0.14351696f, -0.29779840f, -0.27954292f, 0.03502975f, 0.54426616f, 0.63912129f, 
    -0.72455698f, -0.52169132f, -0.34620187f, 0.26920858f, -0.38688907f, 0.22073112f, 0.09754974f, -0.55824667f, 
    0.38155714f, -0.01020002f, 0.10353994f, 0.37614992f, -0.10413446f, 0.25021583f, -0.24702141f, 0.03861467f, 
    -0.25811467f, 0.14684618f, 0.01747423f, 0.47935441f, 0.23893310f, 0.28445897f, -0.29861370f, 0.29785472f, 
    0.44158083f, -0.21031468f, -0.45126942f, -0.24296680f, 0.17358427f, 0.16617936f, 0.36882111f, 0.60679889f, 
    0.09345572f, 0.31827176f, -0.14191154f, -0.58619219f, 0.20066915f, 0.43398786f, -0.07013134f, -0.07592109f, 
    0.01303644f, 0.22455099f, 0.43438157f, -0.50332558f, 0.20355688f, -0.27885181f, -0.30627057f, -0.01748696f, 
    0.20846704f, 0.44823503f, 0.26345134f, -0.57022339f, -0.02869984f, 0.04777245f, -0.47897270f, 0.08340380f, 
    0.64221770f, -0.41439188f, -0.35200906f, -0.35526535f, -0.33446223f, -0.07044088f, -0.08175590f, -0.05795094f, 
    0.42365676f, 0.04194441f, -0.23788966f, -0.40980321f, 0.27490371f, 0.17230642f, 0.32539394f, 0.27503973f, 
    0.28989840f, -0.44704738f, 0.29733402f, 0.06060511f, -0.58731771f, -0.11268324f, 0.09514755f, 0.47731328f, 
    -0.15668814f, -0.24913204f, -0.43332806f, 0.08559129f, 0.14097922f, -0.28484657f, -0.11783417f, -0.13069753f, 
    0.10062198f, 0.38469705f, 0.43714887f, -0.20701207f, -0.49427143f, -0.12496570f, -0.25530720f, 0.28222212f, 
    0.35797295f, 0.55074197f, -0.08417117f, -0.99993843f, -0.39392230f, 0.48787826f, -0.09036437f, -0.68230182f, 
    0.28932250f, 0.65784800f, -0.21451859f, 0.31300220f, 0.05737693f, 0.10090824f, -0.24178405f, 0.15057053f, 
    -0.47189629f, -0.12563057f, 0.02859389f, -0.02083167f, -0.06732532f, -0.40022153f, -0.16888840f, -0.21252459f, 
    0.47860792f, -0.02300173f, 0.06668281f, 0.07187335f, 0.61261874f, 0.36717945f, -0.98885852f, -0.62314469f, 
    0.57504952f, -0.57314742f, -0.44974536f, 0.01824238f, -0.32793418f, 0.23358420f, 0.21519998f, -0.15698448f, 
    0.37528172f, -0.20084843f, -0.28678167f, -0.04662156f, 0.05651303f, -0.17721227f, 0.02902424f, 0.09418149f, 
    0.22741280f, -0.04517454f, 0.21719430f, -0.10324021f, 0.80056220f, 0.29290003f, 0.21489003f, 0.82980257f, 
    0.74367768f, -0.47689041f, -0.60633868f, -0.57160485f, 0.20927046f, 0.14530887f, 0.20262541f, 0.09545015f, 
    -0.19112132f, 0.22257845f, -0.04320151f, 0.23219153f, -0.18156141f, 0.36254030f, 0.29606116f, 0.35578004f, 
    -0.18127818f, -0.04598397f, 0.12838903f, -0.10602595f, -0.21661672f, 0.74883223f, 0.36157665f, -0.01342324f, 
    -0.11343652f, -0.14461835f, -0.16678549f, -0.26891023f, 0.66474146f, 0.86818439f, 0.00409969f, -0.51925308f, 
    0.00629224f, 0.13188128f, -0.40432057f, -0.40416434f, 0.08333163f, -0.18282494f, 0.02900969f, 0.11849727f, 
    0.01036798f, 0.12161208f, -0.29260215f, 0.21773405f, -0.43505841f, -0.08011515f, 0.54003459f, 0.69300848f, 
    0.82061714f, 0.27532831f, -0.05427423f, 0.23985872f, 0.53148818f, -0.63854468f, -0.35225886f, -0.36299738f, 
    -0.06695679f, 0.48340780f, -0.18898040f, 0.37027082f, 0.09471419f, 0.42683116f, 0.23159325f, -0.08972970f, 
    0.19334030f, -0.07141991f, 0.05758292f, -0.20270145f, 0.21133092f, -0.00809221f, 0.07595297f, 0.72359431f, 
    0.44223911f, -0.53302449f, -0.19297335f, 0.28218004f, -0.10109572f, -0.43980765f, 0.52023745f, -0.36449584f, 
    -0.05858165f, -0.44476804f, -0.35300031f, 0.47852048f, 0.01986712f, 0.27891392f, 0.12269622f, -0.19798191f, 
    -0.32078534f, 0.18319215f, 0.38750637f, -0.03118180f, -0.18902247f, -0.40239924f, -0.19839227f, -0.12123656f, 
    -0.08902315f, -0.40308547f, 0.86196673f, 0.20504975f, -0.56802720f, 0.55078727f, 0.24173626f, -0.43784112f, 
    -0.43652683f, 0.11558501f, 0.23448969f, 0.38252181f, -0.28854856f, 0.10878393f, 0.32475734f, 0.23589286f, 
    -0.31465393f, -0.35983732f, -0.33495304f, -0.09770612f, 0.04776495f, 0.08527511f, 0.30150640f, 0.14072411f, 
    0.05749872f, -0.47054049f, 0.50149328f, 0.50326914f, 0.01148251f, 0.50528377f, 0.66848469f, -0.20925207f, 
    -0.82304126f, -0.56642807f, -0.49226713f, -0.15895018f, -0.28463113f, 0.20603552f, -0.11241536f, 0.01248179f, 
    -0.37147295f, -0.23201138f, -0.44473049f, -0.00992800f, -0.18226701f, -0.11207877f, -0.05839154f, -0.08254685f, 
    -0.25168678f, -0.09135053f, -0.47958115f, 0.50380069f, -0.49237660f, -0.53176600f, 0.18650453f, -0.02052744f, 
    0.37663141f, -0.42727673f, -0.35168168f, -0.81305504f, -0.52970344f, 0.24426189f, -0.26225200f, 0.09508227f, 
    -0.11737488f, 0.06824511f, -0.12794307f, 0.01096894f, 0.20507546f, -0.07582557f, 0.13577588f, -0.14641540f, 
    0.05964890f, 0.28421158f, 0.51025528f, 0.54531431f, 0.58493143f, 0.22664055f, 0.47439548f, -0.63115376f, 
    -0.19950399f, 0.02651799f, 0.38001418f, 0.47895297f, 0.14163333f, 0.22391292f, 0.14626154f, 0.42415658f, 
    -0.33720979f, -0.25840172f, -0.16231108f, 0.07879382f, -0.16557936f, 0.12358473f, -0.01590368f, -0.46358147f, 
    -0.40761083f, -0.20863891f, 0.24347900f, 0.23589756f, 0.29419822f, 0.54176641f, 0.36630091f, 0.38635972f, 
    0.46847382f, 0.16787314f, 0.29236457f, 0.46359870f, 0.07040580f, 0.39675274f, -0.18614812f, 0.01380617f, 
    0.27974218f, 0.15043648f, 0.32061368f, -0.02813146f, 0.08246585f, -0.09441729f, 0.13004772f, 0.31209153f, 
    -0.16558693f, 0.20771198f, 0.27405125f, 0.49098331f, 0.27850285f, -0.36871234f, 0.17180313f, -0.72737926f, 
    -0.86421263f, -0.09506072f, -0.14735645f, 0.53163975f, 0.38261795f, -0.02000380f, 0.55728662f, -0.03784103f, 
    -0.00904800f, -0.01917850f, -0.35850978f, -0.01600140f, 0.29179662f, 0.20277755f, 0.05361849f, 0.30555427f, 
    0.02074719f, 0.11936641f, 0.20137131f, 0.33565432f, -0.24657850f, 0.16818590f, -0.58472639f, -1.03261662f, 
    0.30339977f, 0.57474655f, 0.25840452f, -0.03633076f, 0.62476146f, 0.34374762f, 0.35828122f, -0.08626574f, 
    0.14857416f, -0.16723619f, -0.27935988f, 0.55597079f, 0.47972134f, 0.17499019f, -0.10221944f, -0.09852327f, 
    0.05984867f, -0.21542951f, 0.08415168f, 0.28827643f, 0.01271174f, 0.36682037f, -0.13705736f, -0.71004605f, 
    0.59427792f, 0.57384348f, -0.30536467f, -0.89772660f, 0.27706844f, 0.21138074f, -0.56553859f, -0.07328383f, 
    0.60235924f, -0.07726379f, 0.21451409f, 0.06535315f, 0.09412023f, 0.18848895f, -0.09668481f, -0.03500036f, 
    0.13902228f, 0.08642083f, -0.29309535f, -0.33710617f, -0.33857730f, 0.13452457f, -0.01650812f, 0.03995615f, 
    0.80563903f, -0.06662347f, -0.36129886f, 0.89380574f, 0.39402241f, -0.41760886f, -0.17296334f, 0.19364946f, 
    -0.23308493f, 0.49372321f, 0.14965250f, -0.09365826f, 0.06994984f, -0.39018112f, 0.31809312f, -0.06986377f, 
    -0.09455893f, 0.01270545f, -0.17237855f, 0.42654034f, -0.12075889f, -0.28963044f, 0.27634731f, 0.01058116f, 
    0.15436085f, 0.13675040f, 0.27270919f, -0.40587297f, -0.71224904f, 0.12707046f, 0.42821893f, -0.69972950f, 
    -0.54539615f, 0.24968377f, -0.42950553f, 0.26589906f, 0.15320919f, 0.34762585f, 0.04722166f, -0.02699481f, 
    -0.00065998f, 0.05493866f, -0.17566258f, -0.12021877f, 0.39450127f, 0.02124538f, 0.19111428f, 0.15905583f, 
    0.01709379f, 0.49654970f, -1.16992271f, 0.35413635f, 0.11205381f, -0.07661656f, -0.58771348f, 0.19793537f, 
    0.72578710f, -0.66749626f, 0.55450535f, -0.31843916f, 0.07060160f, 0.02634478f, 0.00893337f, 0.03659536f, 
    0.14544739f, -0.24261908f, -0.07570823f, -0.16042206f, -0.28625780f, -0.18535674f, 0.16154723f, -0.06097485f, 
    0.14761569f, 0.13067128f, 0.27353418f, -0.79069996f, -0.47063264f, -0.32448334f, -0.16395415f, -0.35483509f, 
    0.30036235f, 0.88954812f, -0.34664124f, 0.45077419f, 0.39870897f, -0.25997445f, -0.01455426f, 0.00293613f, 
    -0.39404202f, -0.27075881f, -0.12948406f, 0.14196511f, 0.19184756f, 0.11007156f, -0.12457496f, 0.20101660f, 
    0.19712578f, -0.13876013f, 0.08223845f, 0.09693263f, 0.34931526f, -0.12145040f, -0.79769409f, -0.78564209f, 
    -0.49848345f, -0.33807057f, -0.01265011f, 0.01967671f, 0.11980847f, -0.50204349f, -0.03155681f, 0.16795027f, 
    0.39007849f, -0.01373887f, 0.22221324f, 0.28437641f, -0.04930647f, 0.10397921f, 0.17609419f, 0.46562624f, 
    -0.13737133f, 0.22211626f, -0.25755125f, 0.01263144f, -0.05988145f, -0.35525587f, -0.29536980f, -0.67142802f, 
    -0.50010073f, 0.45520034f, -0.42850563f, 0.17415725f, -0.29711846f, -0.09396341f, 0.46490061f, 0.28995472f, 
    -0.01227008f, 0.02941177f, 0.26576358f, -0.04233287f, -0.27180821f, -0.08309271f, -0.32601190f, 0.22841392f, 
    0.24561761f, -0.10202266f, 0.03275666f, -0.20325771f, -0.46368268f, -0.22957204f, -0.91847247f, 0.31526157f, 
    0.37188944f, -0.22891293f, 0.11774508f, 0.67239064f, 0.93801415f, 0.09131770f, -0.28117809f, 0.46993521f, 
    0.04647426f, -0.14672321f, 0.16706617f, -0.52379793f, 0.13814829f, -0.16703257f, 0.00088772f, -0.09557937f, 
    -0.27191344f, -0.17511098f, -0.04788029f, -0.21228352f, 0.00592923f, -0.23134826f, -0.04938748f, 0.81838244f, 
    0.61535126f, -0.96234226f, 0.86785108f, -0.17517708f, -0.26406634f, 0.48229232f, -0.36612052f, 0.58981961f, 
    -0.25644484f, 0.16443597f, -0.09194887f, -0.01274582f, 0.16238189f, 0.24095310f, 0.38098758f, -0.28119168f, 
    -0.18129371f, -0.24402285f, 0.42143908f, 0.17651260f, -0.12597969f, 0.14364895f, 0.03769351f, 0.03455237f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.20158075f, 0.10256687f, 0.07032504f, 0.15380999f, 0.03575157f, 0.13722099f, 0.08419109f, 0.13011849f, 
    0.26956299f, -0.01874867f, 0.09848607f, 0.03599140f, 0.06157993f, 0.00797550f, 0.05457177f, 0.03903322f, 
    0.25649783f, 0.18755142f, 0.08047685f, 0.29461065f, 0.12794386f, 0.05511252f, 0.05536015f, 0.20609747f, 
    0.29409125f, 0.10012740f, 0.00913501f, 0.18710811f, 0.12342069f, -0.03809401f, 0.19923195f, 0.22218023f, 
    0.12823759f, 0.31959620f, 0.13242547f, 0.10305859f, 0.21150576f, 0.03387098f, 0.15122162f, 0.34142128f, 
    0.16698697f, 0.00675466f, 0.30653974f, 0.27715600f, 0.07376007f, 0.07801101f, -0.07278679f, 0.06864657f, 
    0.17292115f, -0.12395731f, 0.18532304f, -0.05310524f, 0.30714494f, 0.25404084f, 0.22871149f, -0.09243546f, 
    -0.00137606f, 0.09843647f, 0.04550944f, 0.12280490f, 0.17452019f, 0.14802766f, 0.02146914f, 0.15893011f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.09395972f, -0.04097349f, 0.10530708f, -0.33874038f, 0.06094389f, 0.04750063f, 0.12595284f, 0.01237257f, 
    -0.13118736f, -0.12106706f, 0.00213106f, -0.03063275f, 0.15590464f, 0.00685783f, 0.11022762f, 0.01335741f, 
    -0.11828464f, -0.02883669f, -0.01917715f, 0.12650900f, 0.00019523f, 0.10769077f, -0.04846783f, 0.01905544f, 
    0.03177620f, -0.10761008f, 0.14224048f, -0.09393786f, 0.00885510f, 0.03293664f, 0.10618619f, -0.12885529f, 
    0.05828670f, -0.04726106f, -0.02285270f, -0.02482333f, -0.12498014f, -0.13406269f, -0.13472496f, -0.05886475f, 
    -0.08507619f, -0.06177697f, -0.15845701f, 0.08931337f, 0.08080624f, -0.00154488f, -0.03345667f, -0.04998489f, 
    -0.26474217f, 0.25929227f, 0.10360187f, -0.07695641f, -0.03497360f, 0.04111955f, -0.09747126f, 0.05425333f, 
    0.00136655f, 0.11253538f, -0.03865792f, 0.00519874f, -0.22605348f, 0.18362339f, 0.02580816f, -0.11627356f, 
    -0.02004691f, 0.02628538f, -0.01796297f, 0.01209682f, -0.06560486f, 0.01777950f, -0.10556567f, -0.17179176f, 
    0.23291543f, -0.07916755f, -0.12607276f, 0.28468579f, 0.10788622f, -0.14954071f, 0.02150509f, 0.00781255f, 
    -0.04855303f, -0.09971662f, -0.12705675f, 0.05187486f, 0.26566988f, 0.05910062f, -0.00582228f, -0.05564378f, 
    -0.02435903f, 0.07402573f, 0.07393084f, -0.15458728f, -0.04837576f, 0.02457722f, -0.03800723f, 0.03255789f, 
    0.41034964f, 0.01734790f, -0.18336262f, 0.08362994f, -0.08244478f, -0.11336265f, -0.04914385f, 0.01131723f, 
    -0.03997852f, -0.08197188f, 0.08979527f, -0.05391676f, 0.01455587f, -0.14238015f, -0.22682083f, 0.32669604f, 
    -0.21057804f, -0.12145896f, 0.05075788f, 0.00168553f, -0.01563777f, 0.01867444f, 0.05069782f, 0.01177949f, 
    -0.19710697f, -0.03488265f, 0.04334313f, 0.16418718f, 0.04587338f, 0.09360619f, 0.00268194f, -0.03726918f, 
    0.10092258f, 0.05842848f, 0.10631502f, 0.05064823f, -0.26634759f, 0.22831994f, 0.07171051f, -0.27126551f, 
    -0.06513344f, 0.00850821f, -0.01841234f, -0.01532542f, -0.05661831f, -0.05711748f, 0.01394516f, -0.11524914f, 
    0.11973286f, 0.00630821f, -0.06832340f, 0.07730068f, -0.02498689f, -0.04228011f, 0.00826289f, -0.03871094f, 
    0.02547009f, -0.02069766f, 0.06352199f, -0.02742929f, 0.03674515f, 0.01115780f, 0.19064845f, 0.03023690f, 
    0.03263479f, 0.10050657f, 0.08651929f, -0.04637799f, 0.01830898f, 0.01036495f, -0.06897021f, 0.14161044f, 
    -0.34702665f, -0.20149334f, 0.00225244f, -0.00208674f, -0.02982418f, -0.04034591f, 0.02093343f, 0.01135171f, 
    0.08237303f, 0.10868403f, -0.08845046f, 0.00754934f, -0.22426507f, 0.01664735f, 0.06392576f, 0.08021414f, 
    0.05245025f, -0.07405566f, -0.08237913f, 0.01946416f, -0.02538782f, 0.09384698f, -0.04195014f, 0.00521647f, 
    -0.32709104f, 0.13842240f, -0.03386594f, 0.06161943f, -0.01224226f, -0.01995974f, -0.01818142f, 0.07010470f, 
    0.04257452f, -0.04620938f, 0.03283783f, -0.01398793f, -0.08275318f, 0.20746633f, -0.06421898f, 0.04773410f, 
    -0.11773369f, -0.02536326f, -0.02370556f, -0.04087925f, -0.01218765f, 0.03092529f, 0.05131346f, 0.01321586f, 
    0.02668719f, 0.26034191f, 0.03768127f, 0.30001849f, -0.10127243f, 0.10600539f, -0.04942375f, -0.02633114f, 
    -0.14298929f, -0.00847690f, 0.06379181f, -0.09283783f, 0.01449631f, -0.03618527f, -0.03829282f, -0.19169882f, 
    -0.07019785f, -0.08748891f, -0.03905633f, 0.04471345f, -0.11259290f, -0.00665604f, 0.00869696f, 0.02157619f, 
    0.18095592f, 0.11356988f, 0.15063486f, -0.16632900f, -0.02054073f, -0.08137230f, -0.06086918f, -0.00491700f, 
    0.01159744f, -0.10371120f, -0.00111997f, 0.02658255f, 0.47553509f, 0.00913664f, -0.21315119f, -0.33451766f, 
    0.11262340f, -0.03104676f, 0.02389490f, 0.04444232f, 0.05841634f, -0.02812852f, 0.00913433f, 0.06045717f, 
    0.05804852f, -0.08436436f, -0.05194826f, 0.22890429f, 0.03765658f, 0.06784943f, -0.02266112f, -0.00881620f, 
    0.01531440f, -0.09371477f, 0.05530765f, 0.02342435f, 0.20083414f, -0.05317435f, -0.06105139f, 0.08899152f, 
    -0.12444745f, -0.04847317f, 0.01173455f, 0.04806578f, -0.08955046f, -0.01466649f, -0.16682832f, -0.00171463f, 
    0.04260179f, -0.00795826f, -0.04237625f, 0.17091285f, -0.20966384f, 0.08638760f, -0.03214242f, 0.02874880f, 
    -0.05537654f, -0.06659137f, 0.02560621f, -0.15666606f, 0.07028516f, -0.18842690f, -0.06046104f, -0.34955525f, 
    0.00013646f, -0.05973664f, 0.06379052f, -0.00850754f, -0.01988559f, 0.04080857f, -0.03188914f, 0.02431048f, 
    0.05803103f, 0.03486979f, 0.00697771f, -0.34414858f, -0.12915540f, -0.03457484f, 0.05826354f, 0.13713878f, 
    0.00376304f, 0.00789027f, 0.06840550f, -0.03753749f, 0.22621344f, -0.09445113f, 0.02210009f, -0.14445955f, 
    0.00061301f, -0.04059486f, 0.14151450f, -0.04074340f, -0.14102726f, -0.03445842f, 0.10423307f, -0.08024197f, 
    0.10236464f, 0.05488442f, 0.05673084f, -0.07574010f, -0.02937056f, -0.09896606f, 0.02695996f, 0.05972530f, 
    0.04356799f, -0.09208104f, -0.09250452f, 0.03722166f, 0.17732580f, -0.03734658f, 0.06844264f, 0.00222247f, 
    0.05149437f, 0.07214538f, 0.05528068f, -0.06953780f, -0.04033200f, 0.11735071f, -0.04466754f, -0.00856070f, 
    0.04970080f, -0.08018617f, 0.00298419f, 0.02093608f, -0.04190178f, -0.03589552f, -0.05955053f, 0.04648499f, 
    0.01871580f, -0.01894306f, 0.07697365f, -0.09604321f, 0.05217382f, 0.07035694f, -0.07073280f, -0.30357000f, 
    -0.02945225f, 0.07005211f, 0.01088593f, -0.06040048f, 0.00822832f, -0.03775881f, 0.00620429f, -0.00274869f, 
    0.04590128f, -0.11981767f, 0.03868433f, -0.11390539f, -0.05788051f, 0.10524295f, -0.05845503f, 0.03755199f, 
    0.03391672f, 0.06064507f, -0.05980450f, 0.08717877f, -0.24702536f, 0.18037836f, 0.07743849f, -0.03116873f, 
    -0.01570794f, 0.03930278f, -0.00282985f, 0.06809428f, -0.12594485f, -0.13534573f, -0.03659569f, -0.09591737f, 
    0.01146709f, 0.07240647f, 0.01311183f, -0.25140354f, -0.06652802f, -0.11413980f, 0.04439960f, -0.04323687f, 
    0.08332722f, 0.10624915f, -0.06667198f, -0.17569204f, -0.22037686f, 0.14887631f, -0.02348208f, 0.12375639f, 
    -0.04202463f, 0.06409090f, -0.13866962f, -0.06363510f, 0.07781229f, -0.13892609f, -0.02089934f, -0.03614816f, 
    -0.01761891f, -0.05479189f, -0.11498385f, 0.01326523f, -0.06397635f, -0.12376007f, -0.04911661f, -0.03835667f, 
    0.03663658f, -0.00499478f, 0.13394903f, -0.12907538f, 0.10475804f, 0.02718266f, -0.06094552f, 0.25023839f, 
    -0.19466564f, 0.02681783f, 0.02587781f, 0.10504186f, -0.05561129f, 0.04808069f, -0.05136216f, 0.06030952f, 
    -0.02488721f, -0.13651857f, 0.05982030f, -0.15139854f, -0.15343006f, 0.11758390f, -0.00404707f, -0.04590287f, 
    -0.01896372f, -0.03856951f, 0.01341347f, 0.09629980f, -0.02349690f, -0.07816225f, -0.10034221f, -0.20877430f, 
    -0.04039636f, 0.02402788f, 0.06767278f, -0.00739939f, -0.07761111f, -0.00910800f, -0.00239978f, -0.01284977f, 
    -0.06991705f, 0.09295020f, -0.01952095f, -0.07373334f, 0.06254538f, -0.03199453f, -0.01275850f, -0.06348731f, 
    0.06975231f, 0.08168592f, 0.01595409f, -0.02897452f, -0.13105325f, -0.05550888f, 0.09749445f, -0.21991077f, 
    0.07708014f, 0.05562594f, 0.00623050f, 0.02202916f, 0.00628809f, -0.00044076f, -0.02450617f, -0.01280392f, 
    -0.15393534f, 0.07511131f, -0.06414717f, 0.15073127f, -0.11899214f, 0.10055606f, 0.00877449f, -0.02404457f, 
    -0.00131238f, 0.03102622f, -0.08992442f, -0.02670911f, -0.42179462f, 0.12719245f, 0.04372043f, -0.14797784f, 
    -0.07552178f, 0.06252196f, 0.04944528f, -0.15363826f, -0.06849867f, -0.01984897f, -0.01963001f, 0.05628455f, 
    0.27193207f, -0.07101934f, 0.03780746f, 0.16753982f, -0.09579884f, 0.04410950f, -0.08489051f, 0.07792002f, 
    0.00022603f, -0.06689239f, -0.02446727f, -0.10033485f, 0.12238767f, 0.01146684f, -0.13296866f, 0.07368505f, 
    -0.04465156f, -0.00052934f, -0.05464404f, -0.05793494f, -0.01826234f, 0.00140493f, 0.13997021f, -0.03747270f, 
    -0.16204774f, 0.20548540f, -0.05644198f, -0.12558822f, -0.10723614f, -0.01840221f, -0.01883376f, 0.11631379f, 
    -0.03255822f, 0.05033636f, 0.04458396f, -0.01386030f, 0.02527972f, 0.01074665f, 0.02076427f, -0.17570227f, 
    -0.06427879f, -0.05904285f, -0.06301027f, 0.14430438f, 0.01685670f, -0.03955056f, -0.00156960f, 0.06229265f, 
    -0.23814368f, -0.05971345f, -0.02765922f, 0.10197512f, -0.07103900f, 0.00606208f, 0.08782858f, -0.00379281f, 
    0.02372142f, 0.04431498f, 0.22288521f, 0.02859458f, -0.21907088f, 0.06410420f, 0.08597136f, 0.01431584f, 
    -0.06948625f, -0.15879229f, -0.01978658f, -0.03525169f, -0.05253557f, -0.02030895f, -0.00413703f, 0.08176663f, 
    -0.33010796f, -0.02812489f, 0.02422087f, -0.04286577f, 0.03465879f, -0.00394197f, 0.03898246f, 0.06052655f, 
    -0.08822023f, -0.03835141f, -0.13265005f, -0.02475626f, -0.04384321f, 0.02588292f, -0.01802677f, 0.15952241f, 
    0.05397061f, -0.02633915f, -0.02051620f, -0.13544162f, 0.07631528f, -0.07897948f, 0.08450874f, 0.02861366f, 
    0.01941449f, 0.02323574f, -0.07047887f, 0.01680266f, -0.03836483f, -0.07062686f, -0.07521992f, 0.01469210f, 
    -0.06846358f, -0.04675926f, -0.03054174f, 0.02148386f, 0.09051382f, -0.00119703f, 0.00058611f, -0.42226067f, 
    0.09769676f, -0.06242184f, 0.08115356f, 0.00251820f, -0.00429812f, -0.01410105f, -0.00156664f, 0.05066762f, 
    -0.21601047f, 0.09141300f, -0.04041509f, 0.13505104f, 0.10697975f, 0.05883207f, 0.01259139f, 0.07132986f, 
    0.02228772f, -0.14265972f, -0.09979554f, -0.10600951f, 0.21963133f, 0.09115288f, 0.02155536f, 0.09449641f, 
    -0.02778028f, 0.07619273f, 0.01856659f, -0.00427660f, 0.09737203f, 0.12385134f, 0.01583059f, -0.00238872f, 
    0.22801642f, -0.11664693f, -0.06959774f, 0.34455931f, -0.08539177f, -0.09059834f, -0.00969167f, 0.06552202f, 
    -0.04267710f, 0.00120711f, -0.03513895f, -0.07378808f, -0.16329947f, -0.15439951f, 0.11220647f, -0.14284201f, 
    -0.15262684f, -0.05044870f, -0.03205747f, -0.04211719f, 0.07736719f, -0.21154931f, 0.10714930f, 0.00295164f, 
    0.51376247f, 0.03728982f, 0.00189350f, -0.05614990f, -0.07910186f, 0.06660691f, -0.01717952f, 0.02655753f, 
    0.03568467f, 0.01300131f, 0.02395199f, -0.00976176f, 0.32501259f, 0.22210094f, 0.17321444f, -0.07040308f, 
    0.00790935f, 0.02680757f, 0.09302340f, 0.10160559f, -0.04388388f, 0.01911778f, -0.07978214f, 0.05833890f, 
    -0.38057765f, -0.09055746f, 0.04616982f, -0.18646030f, -0.04447220f, 0.02186217f, 0.06187482f, -0.01010006f, 
    -0.00406380f, -0.07568234f, 0.00931369f, 0.04565821f, -0.07340644f, -0.13784958f, -0.02420723f, -0.09006412f, 
    0.01591242f, 0.14820187f, 0.03896976f, -0.00310390f, 0.02497368f, -0.06240223f, -0.07674217f, 0.03848000f, 
    0.27728996f, 0.04105695f, 0.21793570f, -0.09988064f, 0.00843192f, 0.00622347f, 0.01987298f, 0.08293883f, 
    0.06874158f, -0.12112027f, 0.00408336f, 0.06931824f, -0.09676991f, 0.10928277f, -0.04158666f, 0.11894318f, 
    -0.25835457f, -0.03764406f, -0.04555734f, 0.03416447f, 0.09528036f, -0.00989328f, -0.03516806f, -0.08061176f, 
    0.13032338f, -0.10998176f, 0.13420817f, 0.02347441f, 0.12609549f, -0.06206724f, -0.10963468f, -0.02346998f, 
    0.12920251f, 0.13321951f, -0.04456679f, -0.01589921f, 0.06603864f, -0.01559618f, 0.09284385f, -0.00609906f, 
    -0.00735364f, -0.03560998f, 0.00878850f, -0.00284631f, 0.09069769f, -0.00004230f, -0.08355703f, -0.01238839f, 
    -0.25166142f, -0.10182646f, 0.01944881f, -0.17711619f, -0.09978003f, -0.08650653f, -0.04070143f, -0.11933051f, 
    -0.05183244f, 0.00184796f, -0.04268635f, -0.13611974f, -0.07594030f, 0.06852999f, -0.23837143f, -0.05427387f, 
    0.12615880f, -0.02637617f, 0.06032868f, 0.02931366f, 0.01081842f, -0.17285611f, -0.05173285f, -0.04222283f, 
    0.33777058f, 0.09047621f, -0.05307537f, 0.16657668f, -0.05251118f, 0.09398130f, -0.00519417f, 0.02998978f, 
    0.03851707f, -0.02072214f, -0.04761610f, 0.09218271f, -0.00938790f, 0.01998502f, -0.08639335f, -0.21095425f, 
    0.07955868f, -0.02948834f, 0.00208472f, 0.01177724f, -0.05031987f, 0.02332640f, 0.08962846f, -0.03104302f, 
    0.20226847f, -0.10583586f, 0.04163885f, 0.09864444f, -0.13374513f, 0.11842169f, -0.12489989f, -0.03007984f, 
    0.12988524f, 0.15263636f, 0.05566243f, -0.09353465f, -0.03749233f, -0.01140824f, 0.09837613f, -0.02115155f, 
    0.14681648f, -0.05463479f, -0.05043749f, 0.02143804f, 0.09206173f, 0.04260231f, 0.06335972f, -0.06772809f, 
    -0.54146510f, 0.02453000f, -0.16243553f, -0.10460852f, 0.01390300f, 0.03649589f, 0.02892082f, 0.05790550f, 
    0.07814147f, 0.00665198f, -0.15925819f, 0.01837240f, 0.13066106f, 0.12827682f, 0.08053154f, 0.05492567f, 
    -0.00392958f, 0.07641813f, -0.02157573f, 0.00062105f, -0.05036044f, -0.03873506f, 0.02179793f, -0.08125596f, 
    -0.35418880f, -0.14861272f, -0.27831498f, -0.02581740f, -0.00539725f, 0.02097184f, -0.02128425f, -0.01168762f, 
    -0.03014328f, 0.01159162f, -0.02933882f, -0.02528184f, -0.06283848f, 0.24069056f, -0.21096985f, -0.09087254f, 
    0.02128968f, -0.01110631f, 0.05397382f, 0.00087074f, 0.08589406f, 0.05134384f, 0.00567106f, 0.21870829f, 
    -0.15825827f, 0.07205422f, 0.03459654f, 0.13817981f, 0.00515757f, -0.00275793f, 0.00503158f, -0.15845461f, 
    0.16314627f, 0.03152834f, -0.15805593f, -0.13455687f, 0.04101951f, 0.01356535f, -0.15659457f, -0.02329295f, 
    0.10169172f, -0.01601970f, -0.04232032f, -0.07627007f, 0.04911446f, 0.23859802f, -0.15926905f, -0.20865144f, 
    0.09934375f, -0.04426301f, 0.04500885f, 0.04145305f, 0.03042965f, 0.16320540f, -0.01734012f, 0.09458341f, 
    -0.03714241f, -0.02096664f, 0.03236515f, 0.04736954f, -0.10489254f, -0.31441474f, -0.21030362f, -0.35248649f, 
    0.08714104f, 0.02396969f, 0.03422351f, -0.01463700f, -0.07893217f, 0.05704333f, 0.06516218f, 0.00375820f, 
    0.07790777f, 0.02631496f, -0.02827527f, -0.01240010f, -0.00030298f, -0.03286377f, -0.07045307f, -0.03922845f, 
    -0.03330404f, -0.13309671f, -0.02743083f, -0.12354870f, -0.21692736f, -0.15640628f, -0.19824308f, 0.12351014f, 
    0.00646942f, -0.05264581f, 0.05892151f, 0.03386086f, 0.03587238f, 0.03059185f, -0.01124413f, 0.10012904f, 
    0.20587291f, -0.28323042f, 0.13752292f, 0.12319377f, -0.03702559f, 0.07628561f, -0.05867024f, 0.06688787f, 
    0.05403343f, 0.11821622f, -0.23853201f, 0.01215832f, 0.07013907f, 0.10260554f, 0.04666069f, -0.02372996f, 
    0.00611642f, -0.02267226f, 0.05234222f, -0.00669980f, 0.05003459f, -0.01760849f, 0.10155404f, 0.08035424f, 
    0.04437131f, 0.04974832f, 0.05836648f, 0.21362187f, -0.01487779f, 0.04189128f, 0.07909013f, 0.05357040f, 
    -0.02951734f, 0.07801559f, -0.07771177f, 0.09279329f, -0.19165027f, -0.08239488f, 0.11697314f, -0.11629348f, 
    0.03641748f, 0.01690750f, -0.03183215f, 0.13385369f, 0.05315315f, 0.12525840f, -0.03597524f, 0.00902410f, 
    -0.31419882f, 0.02152628f, -0.13933754f, 0.02234037f, -0.13425530f, -0.08863275f, -0.09416386f, 0.00479619f, 
    -0.02270671f, 0.15677881f, 0.02215076f, 0.10534140f, 0.08917047f, 0.08047821f, 0.07691708f, 0.25179163f, 
    -0.17740496f, -0.04848856f, 0.08413297f, 0.00903683f, -0.03661199f, -0.04242761f, 0.09723623f, -0.00881037f, 
    0.10225766f, 0.05407177f, 0.09365067f, 0.13722442f, -0.07483681f, -0.02213291f, 0.04659671f, -0.05281994f, 
    0.07493932f, -0.02496314f, -0.03304823f, 0.03246856f, 0.24392119f, -0.13892986f, 0.00479833f, -0.21974395f, 
    0.04691528f, -0.11188800f, -0.01637179f, -0.06225023f, -0.21069202f, 0.00035529f, -0.03862780f, 0.00318098f, 
    0.37372518f, -0.11864260f, 0.00036255f, 0.21453972f, -0.00882274f, -0.09164958f, 0.01104673f, -0.02519059f, 
    -0.23676418f, 0.02565990f, -0.08786957f, 0.02855522f, 0.30924034f, -0.26207274f, 0.15145296f, -0.16666226f, 
    0.02209855f, 0.06141760f, -0.09439987f, -0.03860031f, 0.04426064f, -0.02730037f, 0.01616340f, 0.06109520f, 
    0.07746834f, -0.04278893f, -0.01576857f, 0.07955083f, -0.05291342f, -0.03094723f, 0.01483396f, -0.04255643f, 
    -0.04549443f, 0.09685887f, 0.09241531f, -0.13852577f, 0.16780998f, -0.01797813f, 0.07082599f, -0.01608182f, 
    -0.04529891f, 0.04078194f, -0.18054356f, 0.19296952f, -0.01765272f, -0.02329905f, 0.05211037f, 0.10005166f, 
    0.12738024f, -0.05835487f, 0.03198876f, 0.21734944f, -0.00947922f, -0.04006155f, -0.03080353f, -0.01449818f, 
    -0.00317710f, 0.05378790f, 0.00705259f, 0.08864088f, 0.23860650f, -0.39940289f, 0.04793457f, -0.10753331f, 
    -0.01339072f, -0.10281408f, 0.06334800f, 0.00002351f, -0.08440106f, -0.01597164f, -0.07135163f, 0.14215325f, 
    0.11124811f, 0.12738968f, -0.08949915f, 0.06095593f, 0.00052941f, -0.01159713f, 0.04435476f, 0.02229887f, 
    -0.10539915f, -0.04575851f, -0.11394779f, -0.03215004f, -0.11968470f, -0.11861272f, -0.02886738f, 0.00713725f, 
    0.02044374f, 0.01173333f, -0.06098953f, 0.03304243f, 0.01510653f, 0.12864095f, 0.09043161f, 0.11393265f, 
    -0.00667508f, 0.08866431f, -0.01072678f, 0.01253505f, 0.05356801f, -0.02797409f, 0.04022411f, 0.10037979f, 
    0.03619213f, -0.05412195f, -0.04543499f, 0.01411815f, 0.09141774f, -0.01534568f, -0.10606052f, 0.11586463f, 
    -0.05717291f, 0.06031451f, -0.07444779f, 0.05305447f, 0.02157946f, -0.01391615f, 0.06437342f, 0.09567531f, 
    -0.18162471f, 0.09438494f, -0.11022709f, -0.21722500f, 0.04553599f, 0.15015303f, 0.07418930f, 0.04715706f, 
    -0.02986252f, 0.00846954f, -0.08243777f, 0.08342150f, 0.16993095f, -0.14762184f, 0.14118353f, 0.06792903f, 
    -0.05340764f, 0.05853088f, -0.07624875f, -0.00166667f, -0.02998245f, -0.03180689f, -0.02303584f, -0.01268625f, 
    0.08147281f, -0.34164739f, 0.00335248f, -0.13775361f, 0.06904121f, -0.16807263f, 0.10015014f, 0.00110576f, 
    -0.01478997f, 0.08943331f, 0.04849388f, -0.02041348f, 0.07755581f, -0.07162363f, 0.00068438f, 0.01311110f, 
    0.07223003f, -0.18627627f, -0.00841939f, -0.01876109f, -0.03176082f, 0.07861286f, -0.04479752f, 0.07932410f, 
    -0.17867966f, 0.01782301f, 0.00349033f, -0.08891063f, -0.10759580f, -0.00119659f, 0.08429831f, 0.00367326f, 
    0.01536832f, -0.05371569f, 0.08992274f, -0.07963139f, -0.11557046f, 0.07259512f, -0.28720051f, -0.18579164f, 
    -0.09779485f, 0.09955481f, -0.05446712f, 0.01900499f, 0.09227774f, -0.08684764f, 0.06452635f, 0.01232577f, 
    0.00189332f, -0.17716669f, -0.08981404f, 0.19546473f, -0.15111251f, -0.06739517f, -0.11754391f, 0.05959957f, 
    -0.01075768f, -0.20924307f, -0.04710381f, 0.10581514f, -0.15732715f, -0.17208387f, -0.02307165f, -0.14236149f, 
    0.06260210f, -0.07008606f, 0.04423670f, 0.10841481f, -0.07390052f, 0.04697275f, 0.13619272f, -0.07336938f, 
    0.15305175f, -0.08391029f, -0.02741463f, 0.14634499f, 0.05670810f, -0.15779902f, 0.02309499f, 0.00200936f, 
    0.02639341f, 0.00000092f, -0.02490796f, 0.08962621f, 0.11714835f, -0.07121043f, 0.11476836f, 0.05021006f, 
    0.05694945f, -0.09055798f, -0.02422174f, 0.06859405f, -0.02527092f, -0.22216003f, -0.10081469f, -0.02916829f, 
    0.17265469f, 0.03398189f, 0.08828592f, 0.10132982f, -0.02303015f, 0.00815686f, -0.01654785f, -0.00636962f, 
    0.14770679f, -0.02695821f, -0.13208780f, 0.19117293f, 0.16998529f, -0.05771083f, 0.00485627f, -0.15424073f, 
    0.00257528f, -0.10917124f, 0.05398063f, -0.03721967f, -0.05178702f, -0.02327750f, -0.04413546f, -0.00830548f, 
    -0.11687122f, 0.10280646f, -0.08617794f, -0.06427839f, -0.10388380f, 0.00938337f, 0.04034347f, 0.00343101f, 
    -0.17437539f, -0.18064371f, -0.12251978f, -0.00082539f, 0.21380940f, -0.13151655f, -0.10979580f, -0.14924416f, 
    -0.03900433f, 0.09695221f, 0.01633725f, 0.01328547f, -0.00710855f, -0.01039383f, -0.11257067f, -0.06153356f, 
    -0.26406908f, 0.08317523f, -0.20454107f, -0.46518528f, -0.01821779f, 0.09045344f, 0.04615365f, 0.02726360f, 
    0.06754403f, 0.12786773f, 0.00048667f, -0.02359885f, 0.03076370f, 0.01683199f, -0.08132840f, 0.13694942f, 
    -0.05985975f, -0.03949306f, -0.12262484f, 0.02654176f, -0.08291172f, 0.00227829f, -0.03083047f, 0.00488283f, 
    0.10144666f, 0.11668325f, 0.17132464f, 0.23370041f, -0.04614658f, 0.04604202f, 0.00955750f, 0.01719615f, 
    -0.01420238f, 0.07296171f, -0.01242574f, 0.05641291f, 0.08978680f, -0.03743825f, -0.00408783f, -0.32171211f, 
    0.01493797f, -0.06998170f, -0.04149639f, 0.09951222f, 0.12811755f, 0.04219527f, 0.07308848f, 0.02199156f, 
    0.23140515f, 0.11187799f, -0.06123899f, 0.10439166f, -0.07484624f, 0.12392479f, -0.06424731f, -0.12095764f, 
    0.06264394f, 0.10563213f, -0.13993277f, 0.11234514f, -0.52983886f, 0.06102019f, -0.05673314f, -0.10748563f, 
    -0.20230503f, 0.01643833f, 0.05629633f, -0.17490342f, 0.11363254f, -0.09269150f, 0.01374952f, 0.00165991f, 
    0.13169265f, -0.07491119f, 0.17469126f, 0.19572191f, -0.16090122f, -0.00772717f, -0.08497848f, -0.00695822f, 
    -0.06228556f, 0.02140316f, -0.06717062f, 0.07029623f, -0.11357713f, -0.20834883f, 0.07073247f, -0.06523708f, 
    0.00371505f, -0.01579886f, 0.05842211f, 0.03868967f, -0.03842589f, 0.14494357f, 0.04308034f, -0.02589890f, 
    -0.66961849f, -0.25515026f, -0.20316204f, 0.02998510f, 0.00105975f, 0.08541472f, 0.00349445f, 0.15225515f, 
    0.02906986f, -0.06352168f, -0.03156271f, 0.08997928f, -0.13276589f, -0.11677496f, -0.14899717f, 0.00610566f, 
    0.08065347f, -0.12031984f, -0.04512962f, -0.02866654f, 0.12022978f, 0.06772257f, 0.01368851f, -0.03442040f, 
    0.20495762f, -0.16802642f, -0.00039055f, -0.07733442f, 0.00485366f, 0.07452609f, 0.02841898f, 0.05391786f, 
    -0.08275576f, 0.02025426f, 0.12903501f, -0.00057553f, 0.21146648f, 0.00722370f, 0.05676798f, -0.17908764f, 
    -0.04790401f, -0.20247236f, -0.05345096f, -0.00344989f, -0.04368708f, 0.03030188f, -0.02623384f, -0.21846336f, 
    -0.20928283f, 0.00361941f, -0.09281120f, -0.07923581f, 0.02745832f, 0.03477773f, -0.02942364f, -0.02123094f, 
    -0.08710653f, 0.06294946f, 0.07186998f, -0.00168643f, 0.37282759f, -0.32851005f, -0.06055610f, 0.15274204f, 
    -0.22133936f, -0.12453589f, -0.03363951f, 0.08465338f, -0.09335401f, 0.09541241f, -0.06675651f, 0.13977864f, 
    -0.15255179f, 0.00582799f, 0.01524406f, 0.05429060f, -0.08859161f, 0.03432656f, -0.03078409f, 0.02865521f, 
    -0.02236577f, -0.03950153f, -0.09772022f, 0.02974933f, 0.02515418f, 0.08904805f, 0.03315085f, -0.07814446f, 
    0.01500222f, 0.01441757f, 0.04015116f, -0.01821418f, -0.08569990f, 0.07369546f, 0.00514909f, -0.01651959f, 
    0.04526939f, 0.06153500f, 0.06472074f, -0.07100143f, 0.02484117f, -0.02921898f, 0.03480242f, -0.01514871f, 
    -0.10329490f, 0.09345895f, 0.02165439f, -0.06067475f, -0.37051064f, -0.23974109f, 0.15638727f, 0.00698218f, 
    -0.16734663f, 0.00036458f, -0.03384866f, -0.01364731f, -0.09642167f, -0.03647751f, 0.10854439f, 0.05196303f, 
    0.21369016f, -0.07978692f, 0.07060896f, 0.19355381f, 0.02557618f, -0.02665173f, -0.08028548f, -0.09765026f, 
    0.03630231f, 0.09639860f, 0.09478585f, -0.04866014f, -0.05840209f, 0.05786236f, -0.18057390f, -0.01407151f, 
    -0.00611821f, -0.00661837f, 0.00450278f, -0.10777117f, -0.02496015f, -0.06116302f, 0.09913816f, -0.00815568f, 
    -0.54418868f, 0.08450714f, -0.05682625f, -0.04911336f, 0.07882363f, -0.01961641f, -0.05132163f, 0.01481013f, 
    -0.06019625f, 0.00586231f, -0.02901666f, -0.00175607f, 0.02312066f, 0.13829342f, -0.01521462f, 0.24353665f, 
    0.02197563f, -0.00472866f, 0.03264863f, 0.14055213f, -0.01438749f, -0.07312912f, -0.08248770f, 0.01037462f, 
    -0.13873318f, -0.03208333f, -0.23399013f, -0.11444947f, 0.02078117f, 0.04455227f, 0.02029674f, -0.06989550f, 
    -0.10001185f, -0.00262027f, 0.09030556f, 0.04032061f, 0.03492024f, -0.00534319f, -0.03414258f, -0.02370643f, 
    0.06539933f, 0.04773717f, -0.00071575f, 0.05230956f, 0.01154724f, 0.12819533f, -0.05371855f, -0.04310331f, 
    0.19273476f, 0.04062485f, -0.11718780f, -0.07585846f, -0.04061106f, 0.06193658f, -0.11099858f, 0.04758746f, 
    0.03064581f, -0.04222818f, 0.00117937f, -0.09099981f, 0.03407414f, 0.08626721f, -0.28590670f, -0.18143916f, 
    -0.01597341f, 0.02402822f, -0.00833817f, -0.06309585f, -0.00564544f, -0.03045621f, 0.00351339f, -0.03613297f, 
    0.17557879f, -0.07246899f, -0.01250737f, -0.13034688f, 0.03090656f, 0.08691359f, 0.01609048f, 0.10515543f, 
    -0.11470140f, 0.07384310f, 0.13520014f, 0.04160805f, 0.23222989f, -0.06471813f, -0.06127330f, 0.02866515f, 
    0.03871914f, 0.02463824f, 0.10071256f, 0.05148982f, -0.04710879f, 0.04333987f, -0.03678402f, -0.04563575f, 
    0.12426044f, -0.09165501f, -0.10920604f, -0.07278956f, -0.11199614f, -0.07201480f, 0.02028480f, 0.08031565f, 
    -0.00560555f, -0.01150883f, -0.02529358f, -0.09167863f, 0.07215384f, 0.04232676f, -0.02798029f, -0.18597458f, 
    -0.00813276f, -0.05507251f, -0.00875837f, -0.07738033f, -0.12978902f, 0.01632874f, 0.02161832f, -0.08200372f, 
    0.21984872f, -0.03457277f, -0.31456268f, 0.06897809f, 0.05978427f, 0.02010634f, 0.01535567f, 0.02778350f, 
    -0.02858665f, -0.03862423f, -0.07597002f, -0.07332540f, -0.22431861f, -0.01085055f, 0.03719244f, -0.17564903f, 
    -0.05330738f, -0.01734326f, 0.02523585f, -0.01741315f, -0.02724233f, -0.10154498f, -0.03688073f, 0.01958247f, 
    0.14968558f, -0.00348132f, -0.06090452f, -0.06809632f, 0.10577875f, -0.00904902f, 0.05118865f, -0.02652169f, 
    0.09931415f, -0.03856521f, 0.01907173f, -0.03425816f, -0.24925448f, 0.02915400f, 0.10789292f, -0.04703462f, 
    -0.05291577f, 0.02048345f, 0.07126156f, 0.01519375f, -0.05586249f, 0.00249072f, -0.05243422f, -0.06405926f, 
    -0.02087106f, 0.14756724f, -0.04509648f, 0.03811313f, 0.06076948f, -0.02418075f, 0.05511701f, -0.15542457f, 
    0.00091533f, 0.03659111f, -0.01909991f, 0.07951453f, 0.16056822f, 0.18352781f, 0.18154493f, 0.18213074f, 
    0.01195594f, 0.02453234f, 0.04558427f, -0.01553553f, -0.06619674f, 0.03994012f, -0.01515179f, -0.12630512f, 
    0.17218637f, -0.01172094f, -0.16145095f, 0.08935915f, -0.08352982f, 0.11683381f, 0.00067574f, 0.00708564f, 
    -0.04868178f, -0.12453347f, -0.02131951f, -0.03379384f, -0.21221559f, 0.04400731f, 0.02058545f, -0.18444344f, 
    0.06240276f, 0.02218326f, -0.09349108f, 0.03104667f, -0.02738682f, 0.12336361f, 0.00725917f, 0.04276165f, 
    -0.08620993f, 0.05280880f, -0.05890458f, -0.05543603f, 0.12079702f, 0.06650732f, -0.01198883f, -0.01056201f, 
    -0.01151357f, 0.02165929f, 0.02029557f, -0.09819348f, 0.05442296f, 0.12543368f, 0.12008179f, 0.01669228f, 
    0.01047193f, -0.07479901f, 0.10271824f, -0.00184021f, -0.02779036f, -0.02531875f, 0.09927884f, -0.04522893f, 
    0.01957344f, -0.00575565f, -0.02847141f, -0.10684612f, 0.06104295f, -0.00779487f, 0.05234628f, 0.00069609f, 
    0.00841956f, -0.05472989f, 0.05714207f, 0.01633423f, -0.29102442f, -0.04139911f, 0.10546643f, 0.10324281f, 
    -0.04587852f, 0.06874135f, 0.00722104f, -0.05390538f, -0.04960249f, 0.00996306f, -0.02368048f, 0.03407643f, 
    0.03715145f, 0.00141313f, 0.04123666f, 0.11405230f, 0.10302024f, 0.08720482f, -0.00016474f, -0.09794568f, 
    0.00842916f, 0.00267789f, -0.07876773f, -0.03527018f, 0.00385918f, 0.09446236f, 0.16430165f, 0.12741476f, 
    -0.09790701f, -0.02212742f, -0.06346893f, -0.07537342f, -0.07540483f, -0.00891283f, -0.02491521f, 0.08239022f, 
    0.08233093f, 0.13273975f, 0.05397730f, -0.10264695f, 0.00674527f, -0.05896327f, 0.06934755f, 0.06588146f, 
    0.02929869f, -0.03814267f, 0.04800377f, -0.08343824f, 0.11163536f, 0.04975901f, 0.18354590f, 0.20506659f, 
    -0.07440294f, -0.13372797f, 0.08269584f, 0.09836618f, 0.00546277f, -0.03766549f, 0.09305075f, -0.06569376f, 
    0.26776332f, 0.11289467f, 0.02167040f, 0.02890643f, -0.14320815f, -0.13803031f, -0.11770614f, 0.02864953f, 
    0.05852238f, -0.02923006f, -0.03375490f, -0.07768495f, -0.14332123f, -0.04214334f, -0.26099256f, -0.21497740f, 
    0.07229403f, 0.02111543f, 0.02594596f, 0.01612804f, -0.00503003f, 0.03205496f, -0.07412069f, -0.08693029f, 
    -0.41601637f, -0.00064990f, -0.14951374f, -0.11649689f, 0.09024555f, -0.05468685f, 0.03678848f, -0.01557440f, 
    -0.03615246f, 0.01770545f, -0.17238061f, 0.00209947f, 0.46660736f, -0.07305060f, -0.09633508f, 0.06436993f, 
    -0.01679290f, 0.08294686f, 0.01209177f, 0.00221447f, 0.00386488f, -0.02701436f, 0.05981939f, -0.09920391f, 
    0.28914487f, -0.00414148f, -0.32572889f, -0.08716907f, 0.13163964f, 0.11208712f, -0.11481701f, -0.18541174f, 
    -0.02648301f, -0.01703279f, 0.03042613f, -0.08290531f, 0.02148166f, -0.27105281f, 0.07807407f, -0.09618966f, 
    0.10700256f, -0.00061825f, 0.01356296f, 0.03655289f, -0.00836495f, 0.04799777f, -0.00495429f, 0.04665660f, 
    -0.19636013f, 0.01771932f, -0.07844354f, -0.05500797f, -0.05836158f, 0.08216823f, 0.05968129f, -0.00100834f, 
    0.02242978f, -0.00927413f, -0.00446778f, -0.10841800f, 0.10163622f, 0.12344583f, 0.01084239f, 0.08484568f, 
    -0.01695770f, -0.01423408f, 0.02090520f, -0.02094235f, -0.05531245f, -0.10178110f, 0.06243889f, -0.07006761f, 
    -0.17638700f, -0.04696236f, -0.05421286f, 0.03247923f, 0.02574982f, 0.04638374f, -0.01117132f, 0.00411476f, 
    -0.02920337f, -0.00775173f, 0.02318035f, 0.00150180f, 0.15771824f, -0.14909965f, -0.07240823f, -0.10327525f, 
    0.13273139f, -0.12609646f, -0.04439226f, 0.03254501f, -0.08411246f, 0.08964021f, -0.02020384f, -0.06919776f, 
    0.36480254f, -0.20528154f, -0.06818657f, 0.12762381f, -0.21642967f, 0.07932949f, -0.08066729f, -0.00849294f, 
    -0.08175287f, 0.07013738f, 0.05499363f, 0.04918555f, -0.32566810f, 0.03379873f, 0.00897499f, -0.22913644f, 
    -0.03597331f, 0.06353513f, 0.04068360f, -0.05871226f, -0.03287126f, 0.00731858f, -0.10274576f, -0.05305625f, 
    0.00863412f, 0.02526351f, -0.01769080f, 0.02550016f, 0.00183435f, 0.03944865f, -0.03156752f, -0.00865337f, 
    -0.08814869f, -0.07625140f, -0.03695409f, -0.10823206f, -0.14420012f, 0.07440793f, -0.12241425f, 0.17553045f, 
    0.06733654f, -0.02499952f, 0.07664207f, 0.17980629f, -0.05172887f, 0.08516382f, -0.02492796f, -0.10613164f, 
    0.15725031f, 0.04926969f, -0.10136123f, -0.13734989f, 0.05457845f, 0.07760618f, 0.02560052f, -0.04573482f, 
    -0.02223472f, -0.07315163f, -0.06181897f, -0.11766204f, -0.22720717f, 0.00302188f, -0.06830537f, -0.12783584f, 
    -0.00948423f, -0.03297385f, -0.04118725f, 0.01729243f, 0.03380922f, -0.02437144f, -0.00225026f, 0.01437856f, 
    0.20002416f, -0.14880602f, -0.02736012f, -0.25999635f, -0.08235310f, 0.06612752f, -0.00988362f, 0.06727563f, 
    0.04960597f, -0.05650412f, -0.00214724f, -0.09921522f, -0.02125966f, -0.12350505f, 0.06861281f, -0.00181542f, 
    0.05724546f, -0.01619298f, -0.02277802f, -0.09183110f, 0.00661136f, 0.11626121f, -0.09334782f, 0.11526137f, 
    -0.13829076f, -0.02378882f, -0.25555205f, -0.30224517f, -0.10020775f, -0.13461313f, -0.14681131f, -0.04376406f, 
    0.04005264f, 0.02789625f, 0.04247111f, 0.01183425f, 0.05852238f, 0.02839972f, -0.16197389f, 0.03378263f, 
    -0.15838212f, 0.03599861f, 0.03954706f, 0.03119580f, -0.09568276f, 0.02241405f, 0.10718226f, -0.12330764f, 
    0.05705285f, 0.11605871f, -0.05250222f, 0.06304064f, -0.05619826f, 0.03245464f, 0.00798033f, 0.00219700f, 
    0.01615706f, 0.01120599f, 0.05347191f, 0.01337099f, 0.06052401f, 0.10537053f, 0.11770152f, 0.23042947f, 
    -0.03105291f, -0.08950162f, -0.05582436f, 0.05436106f, -0.06644583f, -0.05920562f, -0.02009028f, 0.08786567f, 
    0.24140431f, -0.08335125f, -0.05499280f, -0.03254173f, -0.02330905f, -0.01405802f, -0.04630732f, -0.05756149f, 
    0.05928452f, -0.10996683f, 0.02125309f, -0.02934633f, 0.23625821f, 0.01485650f, -0.09640297f, -0.36120120f, 
    0.08105272f, 0.16605417f, 0.11561272f, 0.12529990f, -0.05707827f, -0.04315377f, -0.03088730f, -0.06698196f, 
    0.21406300f, 0.03154488f, -0.05666215f, -0.06913632f, 0.00413120f, 0.05997708f, 0.03630334f, 0.06512955f, 
    -0.06247874f, 0.02113514f, 0.04149514f, -0.05533250f, -0.27720523f, -0.03937137f, -0.04748793f, -0.10422881f, 
    0.11064212f, -0.07096678f, -0.00799543f, -0.01868022f, -0.10669592f, -0.05929625f, 0.03693706f, -0.06902257f, 
    0.39944413f, 0.09806821f, -0.15483586f, -0.15575205f, -0.03613701f, -0.03622783f, -0.12967978f, -0.02635077f, 
    -0.07813760f, -0.05440694f, 0.02295136f, -0.04786098f, 0.35270578f, -0.07589778f, 0.16236140f, 0.09443909f, 
    -0.17359637f, -0.15080023f, 0.03011147f, -0.00764769f, 0.02169581f, 0.03998438f, -0.00819403f, 0.02722539f, 
    -0.17772938f, 0.05931063f, -0.12856743f, 0.08336859f, -0.02846931f, -0.05099443f, 0.05138709f, 0.01475854f, 
    -0.01636001f, -0.05579989f, -0.11735895f, 0.00003351f, 0.01854297f, -0.17297229f, 0.06205924f, 0.02307727f, 
    0.05929963f, 0.07562432f, -0.01152627f, 0.00599412f, -0.04542628f, -0.05600065f, -0.05292012f, -0.00902055f, 
    0.36209652f, -0.04207746f, 0.07519693f, -0.08609223f, 0.03424922f, -0.07866951f, 0.03888709f, 0.11470656f, 
    0.02835728f, 0.07870357f, -0.05848150f, -0.01021763f, 0.25683418f, -0.16758679f, -0.14344586f, -0.22103891f, 
    0.02198759f, -0.04502130f, 0.05272721f, 0.06228049f, -0.03969069f, 0.00053026f, 0.03190843f, -0.07928411f, 
    -0.10961392f, -0.03212542f, 0.00814627f, 0.03418425f, -0.11510965f, 0.07770026f, 0.05444670f, -0.00372214f, 
    0.00767864f, 0.03182931f, 0.04357556f, 0.16243775f, -0.34694034f, -0.23679659f, 0.08045415f, 0.18122585f, 
    0.00331071f, 0.08912876f, -0.06333847f, -0.04013793f, -0.00205761f, 0.03547099f, 0.03906460f, -0.00085015f, 
    0.41051266f, 0.17633815f, 0.04887896f, 0.01490415f, 0.05196882f, -0.00943995f, 0.07605368f, 0.05869400f, 
    -0.08977494f, -0.02214854f, -0.01339340f, -0.04987829f, -0.06295436f, 0.11455289f, 0.01156825f, 0.00957895f, 
    -0.02848879f, 0.03055118f, -0.02798874f, -0.02557553f, 0.05315180f, 0.03750078f, 0.05431170f, -0.03854514f, 
    -0.05151697f, -0.18513794f, 0.20270623f, -0.04510424f, 0.10016281f, -0.03569914f, 0.02342552f, 0.04470544f, 
    -0.04577270f, 0.08731996f, 0.01219090f, -0.02470720f, 0.12463900f, 0.01076376f, 0.06731426f, -0.02235434f, 
    0.01658808f, -0.03012380f, 0.05403239f, 0.13983701f, 0.04281779f, 0.01456879f, 0.00161966f, 0.03656100f, 
    -0.18147665f, -0.24191026f, 0.02583091f, 0.10889520f, 0.03430778f, -0.08697600f, -0.00377869f, 0.06338821f, 
    0.02753877f, -0.04338281f, -0.02193785f, -0.03847442f, -0.27605954f, -0.01921607f, -0.06093736f, -0.04227763f, 
    -0.17278758f, -0.04003565f, 0.07389532f, -0.06041208f, -0.06221107f, 0.07405240f, 0.00454025f, 0.01054196f, 
    0.06085874f, 0.30126694f, -0.03769124f, 0.02856151f, 0.02828847f, 0.08977686f, 0.00824066f, 0.06510451f, 
    -0.03995510f, 0.04407082f, 0.05750946f, -0.07228808f, -0.32486531f, -0.08336318f, -0.34822446f, -0.03813451f, 
    -0.04015533f, -0.07616273f, 0.10670725f, -0.02698366f, 0.11913870f, 0.01417889f, 0.00248879f, -0.00235768f, 
    -0.04829651f, 0.24048272f, 0.02720473f, -0.02801465f, 0.03222703f, -0.09095393f, -0.03132143f, -0.03564179f, 
    -0.00961144f, -0.02908974f, -0.00085121f, -0.05894333f, -0.22505637f, 0.23134927f, 0.06177647f, -0.13356034f, 
    0.02380719f, 0.01483610f, 0.00132470f, 0.08199422f, -0.01049729f, -0.07333794f, 0.07530889f, -0.13134980f, 
    -0.41422573f, 0.01883110f, -0.18625231f, -0.02554045f, -0.02695381f, 0.09413437f, -0.01084839f, 0.04932943f, 
    -0.06138541f, 0.11715583f, 0.01759877f, 0.11401986f, -0.22188929f, 0.10438167f, -0.02282357f, 0.09403556f, 
    0.02004861f, -0.18076850f, -0.00825380f, -0.04221986f, 0.02672411f, -0.03813479f, -0.00811002f, -0.02708479f, 
    -0.00677398f, 0.06046017f, -0.09395553f, -0.01637795f, -0.07351357f, -0.07339058f, 0.04847591f, -0.20954375f, 
    0.05186015f, -0.04163956f, -0.00546365f, 0.04513334f, 0.03353906f, 0.24965562f, 0.07772280f, 0.17333615f, 
    0.08850989f, 0.09470407f, -0.13379495f, -0.03268880f, 0.03881703f, 0.00973232f, -0.07095663f, 0.00396492f, 
    0.01897658f, 0.30880088f, 0.09747587f, 0.04966915f, 0.07249669f, -0.07604091f, 0.10371513f, -0.03132335f, 
    -0.07731974f, -0.01905350f, -0.03949837f, 0.02630193f, -0.07851239f, -0.00708987f, -0.08087489f, -0.00510820f, 
    0.00000390f, 0.02587874f, 0.07173391f, 0.08776797f, 0.04001554f, -0.07896812f, -0.01141313f, -0.06047985f, 
    0.07219975f, -0.01834930f, 0.02519879f, 0.11477498f, -0.01950590f, 0.09079478f, 0.05770741f, -0.10165839f, 
    -0.03827249f, 0.11599945f, 0.00142557f, -0.00378974f, -0.08405985f, -0.40832791f, -0.33098990f, 0.11373452f, 
    -0.04910218f, 0.02361742f, 0.00387320f, 0.06399992f, -0.02987734f, 0.06730979f, -0.03453192f, -0.06106613f, 
    -0.30052862f, -0.25744686f, -0.18852581f, 0.14198238f, -0.04386741f, 0.02836970f, 0.00885754f, -0.04839205f, 
    -0.01813160f, 0.06057388f, 0.06172729f, -0.06680945f, -0.15209968f, 0.13874644f, -0.08538470f, -0.25873476f, 
    -0.08102735f, -0.05626953f, -0.05974792f, -0.02608286f, 0.00366180f, -0.04487494f, -0.03547766f, 0.12564047f, 
    -0.15403235f, -0.05273149f, -0.05650599f, -0.05828070f, -0.04957803f, 0.12419651f, 0.04846915f, 0.02813753f, 
    0.00038750f, -0.10185956f, 0.01991706f, -0.04884282f, -0.06626240f, -0.58268845f, -0.34916180f, 0.07059141f, 
    0.03240146f, -0.03852860f, -0.09213146f, -0.03563465f, 0.05954495f, -0.03085789f, 0.00868660f, 0.02960924f, 
    -0.40004203f, -0.30992129f, -0.00923321f, -0.00091316f, -0.13845557f, -0.02606618f, -0.01814049f, -0.00534251f, 
    0.01121148f, 0.03929915f, 0.00440618f, -0.09901495f, -0.04042192f, -0.15225987f, 0.03523178f, 0.05440377f, 
    -0.00981710f, 0.03259138f, -0.08257114f, 0.04831040f, -0.06574974f, 0.13492140f, -0.05371366f, 0.05203857f, 
    -0.15332200f, -0.24366505f, -0.19415788f, -0.25435883f, -0.02609631f, -0.02417002f, 0.05304443f, 0.03790024f, 
    0.07929683f, 0.05906129f, -0.07217278f, 0.14591724f, -0.02751600f, 0.16067350f, -0.15349592f, 0.16590741f, 
    -0.08828425f, 0.07325836f, -0.01235030f, -0.01857309f, 0.01057229f, -0.02670510f, 0.08117145f, 0.05232637f, 
    0.25850981f, -0.28376231f, -0.02752808f, 0.24445328f, 0.01245192f, -0.00865348f, 0.04176887f, -0.01711137f, 
    0.01123399f, -0.00651676f, -0.10859565f, -0.03405574f, -0.01583991f, 0.08061440f, -0.15190598f, -0.01415834f, 
    -0.01945582f, 0.03422062f, -0.03272595f, -0.05958541f, 0.00849555f, -0.03791849f, 0.06858674f, 0.08744522f, 
    0.15422848f, -0.29213685f, -0.10372715f, -0.02546312f, 0.01531270f, 0.05316830f, 0.03687052f, 0.04889842f, 
    0.03339953f, -0.08623327f, -0.05329087f, -0.08292426f, -0.03996085f, -0.24568558f, -0.08190976f, -0.01573539f, 
    -0.09085821f, 0.04294545f, -0.00806830f, 0.05129745f, -0.06927673f, -0.05616678f, -0.00864383f, -0.04853038f, 
    0.15082917f, 0.12839276f, -0.07198004f, -0.09313574f, -0.08190975f, -0.00827610f, -0.01550071f, -0.02305858f, 
    -0.00522059f, 0.01568371f, 0.09359664f, 0.00164155f, 0.09050362f, 0.20072076f, 0.07238935f, 0.05234559f, 
    0.08409022f, 0.04977143f, -0.06932210f, 0.00929388f, 0.03535760f, -0.05737985f, -0.02898246f, -0.04009814f, 
    -0.03472755f, -0.08703382f, -0.00204548f, -0.01379470f, 0.03177258f, 0.00079059f, -0.00276618f, -0.10501140f, 
    0.04677648f, 0.06660868f, -0.01362310f, -0.02722244f, -0.15953512f, 0.18675897f, 0.14782088f, -0.06886077f, 
    0.08921275f, -0.00469975f, 0.02226179f, 0.03531130f, -0.06378008f, 0.11459292f, -0.19489045f, 0.09241341f, 
    -0.27844504f, 0.19580258f, 0.19059837f, 0.01335541f, 0.10534956f, 0.03789843f, 0.00976399f, 0.07274932f, 
    -0.03332122f, 0.05508497f, 0.03137926f, -0.00768459f, -0.12498210f, -0.53917623f, -0.10714049f, 0.25503990f, 
    -0.08952952f, 0.00741147f, 0.09253031f, -0.02966703f, 0.03134737f, -0.02754679f, -0.02496604f, 0.15986060f, 
    0.11941036f, 0.03020313f, -0.05431128f, -0.02462370f, -0.08916195f, -0.02882183f, -0.00293754f, 0.09236276f, 
    0.02804594f, -0.03178218f, -0.03273346f, -0.13011004f, -0.17956516f, 0.00935668f, -0.03453288f, -0.24695109f, 
    -0.05278865f, 0.07804850f, -0.10566538f, 0.07504638f, 0.09618850f, -0.04123901f, 0.06459459f, -0.01312671f, 
    0.01876810f, -0.18251422f, 0.03238818f, -0.12842691f, -0.05408171f, 0.00966533f, -0.12387381f, -0.04679875f, 
    -0.04618107f, 0.06896906f, -0.01436209f, -0.00484106f, 0.02227566f, 0.08634316f, 0.12951025f, -0.13616577f, 
    -0.08946356f, -0.04590673f, -0.11954734f, 0.03158709f, -0.00639726f, 0.05073178f, -0.09700437f, -0.00075246f, 
    0.16966674f, 0.03706597f, 0.10272235f, -0.04527533f, -0.01637623f, -0.04985662f, -0.00643818f, 0.04412894f, 
    -0.06377023f, 0.02052347f, -0.05575237f, 0.03918527f, 0.24038500f, -0.02979756f, 0.04508709f, -0.05455798f, 
    0.01126926f, -0.08623236f, -0.01761528f, 0.03839326f, 0.03047895f, 0.00150644f, -0.00547846f, -0.04601871f, 
    -0.03150957f, -0.07710655f, -0.00304644f, 0.13811834f, 0.10874682f, 0.15100628f, 0.06602364f, -0.04609550f, 
    0.00497955f, -0.05052051f, 0.01550896f, -0.13638298f, -0.03968845f, -0.16191007f, -0.03465110f, -0.07697573f, 
    -0.02651998f, 0.01270844f, -0.09304714f, -0.03994616f, -0.03529271f, 0.18287741f, -0.10229001f, 0.11377309f, 
    -0.06121092f, -0.06792461f, -0.01538147f, 0.20143674f, -0.05651408f, -0.11341482f, 0.00392749f, 0.03095456f, 
    -0.08572792f, -0.01515739f, 0.00517914f, 0.00907057f, 0.27724573f, -0.03836386f, -0.01253995f, 0.02275500f, 
    -0.07039319f, 0.05271469f, 0.08155416f, -0.01530989f, 0.07381628f, -0.04114550f, 0.05525397f, 0.14524278f, 
    -0.07496186f, 0.00777476f, 0.00405896f, -0.05681082f, 0.06924602f, 0.00169384f, 0.02733142f, -0.01197157f, 
    0.00735983f, -0.03627045f, 0.01439891f, -0.00999062f, 0.41288027f, -0.14936569f, 0.15897915f, 0.25044781f, 
    0.05904062f, 0.09209605f, -0.13352233f, 0.11492056f, 0.05213562f, -0.04315288f, -0.04469497f, -0.00046746f, 
    0.29427686f, 0.22413312f, 0.14328192f, -0.03197928f, 0.05924692f, -0.04006232f, 0.02078476f, 0.08213128f, 
    -0.09823828f, 0.03494720f, 0.06443086f, -0.03362165f, 0.13467446f, -0.37772304f, -0.19982365f, -0.16214180f, 
    -0.06049865f, -0.05320805f, 0.09651064f, 0.13879441f, -0.10866033f, -0.00762234f, 0.01074513f, -0.02286064f, 
    -0.57748282f, -0.20665042f, -0.08806325f, -0.16693740f, -0.11403883f, -0.10518010f, -0.06543677f, -0.02836663f, 
    -0.02404567f, -0.11055216f, -0.05800004f, 0.06773983f, -0.21297681f, -0.04772976f, -0.06425052f, -0.08274738f, 
    -0.05451658f, 0.04696981f, 0.02694258f, 0.04794430f, 0.02136545f, 0.01438665f, -0.07666881f, 0.01782596f, 
    -0.08251077f, 0.15537271f, 0.01401301f, 0.06498419f, -0.07059968f, -0.04318875f, 0.02131379f, -0.05888759f, 
    -0.02795477f, -0.13450512f, -0.01035118f, -0.00356842f, -0.16319904f, 0.02750649f, 0.09522726f, -0.03174437f, 
    0.01528995f, 0.00138087f, -0.03692869f, 0.08553835f, -0.04127512f, -0.01397996f, -0.04657181f, 0.05069749f, 
    0.24193347f, -0.16117249f, -0.02757011f, 0.08887313f, 0.01531781f, 0.08107304f, 0.00349796f, -0.04794408f, 
    0.01514124f, -0.01712311f, 0.05197534f, -0.09564698f, 0.26208094f, 0.13516001f, 0.07608861f, 0.01510932f, 
    -0.07606600f, -0.02878768f, -0.05636179f, -0.10443765f, 0.04205994f, -0.01019317f, -0.00513282f, -0.07086831f, 
    0.03392652f, 0.34540212f, 0.11010062f, -0.03273288f, 0.03390597f, 0.02387495f, 0.03609120f, 0.01644248f, 
    0.01679887f, -0.08952671f, 0.01146731f, -0.05211442f, -0.16749841f, 0.03810645f, 0.02117194f, -0.00978119f, 
    -0.05811865f, 0.00003488f, 0.04590488f, 0.09461753f, -0.00886591f, -0.13605246f, -0.00626531f, 0.00204368f, 
    -0.00043036f, -0.14510089f, -0.02509860f, -0.09195086f, -0.16619548f, 0.10544962f, 0.04827253f, 0.03002648f, 
    0.01544886f, -0.01533427f, -0.02199165f, 0.04448490f, -0.05782243f, 0.13903992f, -0.06124619f, -0.07495060f, 
    -0.08267341f, 0.04866687f, 0.07675219f, -0.01962026f, -0.06633169f, 0.01186259f, 0.07667438f, 0.04509397f, 
    -0.21467707f, 0.09752135f, 0.06204719f, -0.07557028f, 0.13125646f, -0.05254518f, -0.03623829f, 0.08375900f, 
    0.16082413f, -0.11879729f, -0.03293864f, -0.03865021f, 0.34218013f, -0.04513637f, -0.21259300f, -0.25138277f, 
    0.00121499f, -0.00846368f, 0.04459278f, -0.04953675f, -0.07355271f, -0.13172500f, 0.11391379f, -0.19256267f, 
    -0.06570953f, 0.02345268f, 0.06522411f, 0.11768799f, -0.04659387f, 0.01363989f, 0.08560938f, 0.01049888f, 
    0.04001356f, -0.03830768f, -0.00451358f, -0.06474309f, -0.34165329f, -0.20034754f, 0.02895290f, 0.05144210f, 
    0.02683527f, -0.05927888f, 0.04127097f, -0.04938558f, 0.10836297f, -0.08934262f, -0.03226944f, -0.03742702f, 
    0.00368657f, 0.13369310f, -0.13869584f, -0.07572266f, 0.08379153f, 0.09259369f, 0.01258305f, 0.01091342f, 
    -0.01460277f, -0.00478134f, 0.10247404f, 0.07651257f, 0.06033686f, -0.06355752f, -0.03960796f, 0.01529389f, 
    -0.07314883f, 0.05658126f, 0.17960505f, 0.00963022f, 0.01426063f, 0.15204442f, 0.02431719f, 0.00323701f, 
    -0.36314058f, 0.07187501f, -0.08434994f, -0.09228858f, 0.00308392f, -0.11339889f, -0.09070462f, -0.02841357f, 
    -0.15425172f, -0.10086648f, 0.05420711f, 0.02310450f, 0.28673682f, -0.03099118f, -0.15711780f, 0.00157986f, 
    -0.06913987f, -0.07221039f, 0.12474739f, -0.12119127f, -0.07330399f, -0.03723368f, 0.00576446f, -0.06298991f, 
    0.00896792f, 0.37404367f, -0.07638395f, -0.11455303f, -0.03422548f, 0.01754229f, 0.05128159f, 0.00013234f, 
    0.03579389f, -0.03379399f, 0.02265042f, 0.04882137f, -0.16173387f, -0.33601218f, 0.06368680f, 0.14585228f, 
    0.04410033f, 0.01125435f, 0.02854171f, -0.03205756f, -0.03049104f, 0.02463142f, -0.03357189f, 0.03192594f, 
    0.35290730f, -0.07911750f, -0.03279046f, -0.27623737f, 0.04936219f, 0.05650652f, 0.05239962f, 0.04844455f, 
    0.09766236f, -0.17804092f, -0.01376664f, -0.00102095f, 0.07717639f, -0.04383445f, -0.03596175f, 0.01813031f, 
    -0.04785029f, 0.06231503f, 0.02849945f, 0.04684602f, 0.06375626f, -0.02213522f, -0.03779320f, 0.07764083f, 
    -0.24885483f, -0.01488045f, 0.02281776f, -0.11082317f, -0.02967460f, -0.02987868f, -0.05411829f, -0.04085768f, 
    -0.07899506f, -0.03889978f, -0.08660954f, -0.08099274f, -0.26364243f, -0.06739067f, 0.21189117f, -0.05649569f, 
    -0.06060079f, -0.12480596f, 0.09370066f, -0.09795699f, 0.07460169f, -0.02722447f, 0.09077239f, -0.05363246f, 
    0.03731182f, -0.14965087f, 0.15478799f, 0.03933073f, 0.04341610f, 0.16024867f, 0.07704873f, 0.11261194f, 
    -0.04528881f, -0.03534682f, 0.06898474f, 0.06962950f, -0.14682899f, 0.18138027f, -0.10006355f, 0.09553147f, 
    -0.12515301f, -0.00667945f, 0.03233925f, 0.10115682f, -0.03959374f, 0.05557855f, 0.09754560f, 0.17768496f, 
    0.04284228f, 0.07662334f, 0.13594046f, 0.06990857f, 0.07010755f, 0.02986180f, 0.02915483f, 0.13983437f, 
    0.14434247f, -0.10328573f, -0.08037134f, -0.02063966f, -0.16267748f, -0.07508308f, 0.18430319f, 0.24293116f, 
    0.03887463f, 0.02090506f, -0.04214235f, -0.01395444f, 0.05687314f, -0.09727470f, -0.02527693f, 0.12932502f, 
    -0.06728242f, 0.08130056f, -0.14974445f, 0.01765919f, -0.14104253f, -0.04131127f, 0.01996895f, 0.01107120f, 
    -0.02841316f, 0.04403547f, -0.00395867f, 0.09722849f, 0.03475541f, -0.31674162f, -0.03079468f, -0.28123072f, 
    -0.04882078f, 0.07185236f, -0.06911299f, -0.00483100f, -0.10600907f, 0.01045074f, -0.16175500f, -0.02231761f, 
    0.53381497f, -0.03799311f, -0.13249077f, -0.06441832f, -0.05410023f, -0.03623748f, -0.01659612f, -0.08003889f, 
    -0.02056932f, -0.03413306f, -0.02974273f, 0.09066629f, -0.13330173f, -0.32330036f, -0.00779226f, -0.13458699f, 
    -0.15958662f, 0.10447004f, -0.02745986f, -0.09040696f, 0.04828205f, 0.08083507f, -0.04105926f, -0.05099229f, 
    -0.06027675f, -0.07571921f, 0.03549089f, 0.17639245f, -0.17443076f, -0.09031320f, -0.03318490f, -0.05303176f, 
    -0.01799351f, -0.03488465f, 0.06140578f, -0.22405228f, -0.06589533f, -0.05409219f, 0.14666370f, 0.29594219f, 
    0.01584808f, -0.06347773f, 0.10010310f, 0.05678631f, -0.10121381f, 0.04881391f, 0.04387500f, -0.03247054f, 
    0.01294920f, -0.11549512f, -0.02386605f, 0.11027978f, 0.06489168f, 0.07771176f, 0.01453439f, -0.06801672f, 
    -0.09455647f, -0.02362921f, -0.12973709f, -0.09206229f, 0.03399989f, 0.13217945f, 0.21801025f, 0.06381071f, 
    0.01360231f, 0.01625249f, -0.04117476f, 0.01588201f, 0.13015138f, -0.06305832f, 0.05871336f, 0.10168385f, 
    0.11037776f, 0.08114027f, 0.05729310f, 0.00487137f, -0.03795818f, 0.02295312f, 0.03885674f, 0.12142874f, 
    -0.00905195f, 0.07596148f, -0.02568202f, -0.01116566f, -0.39218804f, -0.08432192f, 0.15464437f, 0.12052266f, 
    -0.00955602f, 0.03061266f, 0.06345578f, -0.02819368f, 0.02584836f, -0.05846294f, 0.06080211f, -0.02621290f, 
    0.06467416f, 0.01909144f, 0.01671816f, 0.01917265f, -0.04324485f, -0.13906477f, 0.07240430f, 0.03931074f, 
    0.06051731f, -0.09217171f, -0.02770755f, -0.04082009f, -0.34395614f, -0.01895271f, -0.27004096f, 0.01411923f, 
    0.08969862f, 0.00273508f, -0.00872950f, -0.02156900f, -0.05625599f, -0.06992718f, -0.08874910f, -0.06362727f, 
    -0.18806337f, 0.13334481f, 0.02469151f, 0.06568321f, 0.06246174f, -0.02081500f, 0.02013651f, 0.10077070f, 
    0.04304225f, -0.00981763f, -0.05064974f, 0.04681731f, -0.25542790f, 0.03674963f, -0.20599878f, -0.04388207f, 
    0.05470841f, 0.00709270f, 0.16645262f, -0.13062744f, -0.12574138f, 0.01383133f, -0.08517853f, 0.00736236f, 
    -0.15113635f, -0.02613049f, 0.03989752f, 0.06393863f, -0.09112416f, 0.00533441f, 0.10752805f, -0.05632445f, 
    0.08980215f, 0.06481122f, -0.04880771f, -0.08728243f, -0.48841700f, 0.12608552f, 0.17974474f, 0.11526120f, 
    -0.03292041f, 0.15536974f, -0.06270603f, 0.10022128f, 0.02633781f, 0.04008801f, 0.06259127f, -0.03195411f, 
    -0.20862038f, 0.01285020f, -0.09967570f, -0.02247404f, 0.04540608f, -0.07614485f, 0.01365639f, 0.10086208f, 
    0.04372260f, -0.19733213f, 0.05419075f, -0.01412498f, -0.10769264f, -0.22523938f, 0.12214094f, -0.00253985f, 
    -0.08749137f, 0.06382339f, 0.00881306f, -0.08065636f, 0.03598032f, -0.01175397f, 0.06232752f, 0.02519929f, 
    0.16509852f, -0.16872333f, -0.01475066f, 0.11301940f, -0.23214275f, 0.07857298f, 0.00100882f, -0.05331102f, 
    0.00064562f, 0.08442133f, 0.06181324f, -0.05061168f, -0.42162836f, -0.03124028f, 0.04781853f, -0.01064483f, 
    -0.02092541f, -0.03044491f, 0.05211738f, -0.01543428f, -0.03723506f, 0.06240516f, -0.02602148f, -0.00569064f, 
    -0.08606565f, -0.02401615f, 0.22374758f, 0.14771134f, 0.02728378f, -0.06621286f, 0.13441440f, -0.16292293f, 
    -0.03186274f, 0.00399166f, -0.01180604f, -0.00923174f, 0.27455059f, 0.26297149f, 0.01460934f, -0.08318757f, 
    -0.03539352f, 0.00542793f, -0.00194946f, 0.16191657f, -0.13130078f, -0.04409916f, 0.06853945f, -0.03182331f, 
    0.05402939f, 0.07851852f, -0.23729204f, -0.04323867f, -0.10677003f, -0.05305215f, -0.00361838f, -0.08441232f, 
    -0.18850088f, 0.10064455f, 0.01543664f, 0.00879816f, 0.01742200f, 0.14601806f, 0.05343630f, 0.03305620f, 
    -0.17782447f, 0.00339397f, 0.05848499f, -0.04415452f, 0.10326799f, -0.18572500f, 0.04778711f, 0.14596397f, 
    0.21516842f, 0.02872391f, 0.06362636f, -0.02575320f, -0.04714858f, -0.00363581f, -0.01404001f, 0.00570861f, 
    -0.05751825f, 0.03956927f, -0.10400826f, 0.15097274f, 0.09522559f, -0.02293790f, 0.11397547f, -0.16603981f, 
    -0.03739049f, -0.09225644f, 0.08435215f, 0.10643045f, 0.06555800f, -0.02853914f, -0.03363702f, 0.11011274f, 
    -0.33630094f, 0.02599423f, -0.08981236f, 0.08897440f, 0.15979852f, 0.08261841f, 0.00869848f, 0.01532003f, 
    -0.14769167f, 0.07163703f, -0.03156360f, 0.00048039f, 0.21408737f, 0.00562525f, -0.00691574f, -0.11260016f, 
    -0.03887662f, 0.08987990f, 0.12577482f, -0.01832006f, 0.02356930f, 0.01413529f, -0.01970205f, 0.02912605f, 
    -0.10105985f, -0.10898726f, -0.04785508f, 0.11826430f, 0.00224869f, 0.05890849f, 0.04569377f, 0.03366081f, 
    0.14510259f, 0.00390745f, -0.00356454f, -0.03616725f, 0.04709619f, -0.06695963f, 0.05237167f, -0.06723229f, 
    -0.05927259f, -0.05112696f, 0.04981064f, -0.17707220f, 0.01826274f, 0.02805166f, -0.05390164f, 0.12496944f, 
    -0.24435334f, 0.08436785f, 0.12428312f, -0.10851093f, 0.09733673f, -0.01080837f, -0.08601022f, 0.01544449f, 
    0.07752648f, 0.15485951f, 0.08695594f, -0.15062951f, 0.35463017f, -0.03197809f, -0.03095615f, 0.10798350f, 
    -0.11251627f, 0.01582252f, 0.02010031f, -0.03124310f, -0.01749119f, 0.15694115f, 0.10197316f, -0.02961526f, 
    -0.30103612f, 0.10227168f, 0.00452856f, -0.29154640f, -0.05034392f, -0.08574367f, -0.19920376f, 0.05156897f, 
    0.01129777f, -0.06817503f, -0.07090722f, 0.10232110f, -0.17002311f, 0.31692234f, 0.05567935f, -0.09291282f, 
    0.03623188f, 0.03520095f, -0.02313582f, 0.12045739f, -0.00852604f, -0.01861704f, 0.04019196f, 0.10272016f, 
    0.17840135f, 0.01587697f, 0.10307509f, -0.15718402f, 0.01179410f, -0.12584196f, 0.04720057f, 0.06961522f, 
    0.02574714f, -0.02786328f, -0.00986364f, 0.00459060f, -0.25851643f, -0.18172719f, -0.03458368f, -0.10372147f, 
    -0.07879151f, 0.04686859f, 0.05140915f, 0.01550230f, 0.00984814f, 0.06028953f, 0.05081422f, -0.10340826f, 
    0.09428943f, -0.09640636f, -0.05510970f, 0.04461456f, -0.06598642f, -0.14234316f, -0.06951780f, 0.07741775f, 
    0.04325236f, 0.07166313f, 0.02075468f, -0.04539657f, 0.00407633f, -0.12730901f, 0.08721981f, 0.23657896f, 
    -0.07805130f, 0.01994229f, 0.08918680f, -0.02500514f, 0.00565820f, 0.01759297f, -0.05510820f, -0.07205165f, 
    -0.45555782f, 0.02329725f, 0.00871220f, -0.07518612f, -0.02220602f, 0.01853409f, 0.03615290f, 0.05728092f, 
    0.01885873f, -0.12026744f, -0.04243638f, 0.00899751f, 0.07543524f, -0.23886935f, 0.04496840f, -0.19799854f, 
    0.00192744f, -0.01206550f, -0.08020487f, 0.01402079f, -0.00103833f, 0.15360512f, -0.02617242f, 0.11264871f, 
    0.03895692f, -0.04744063f, 0.00990580f, 0.06031777f, 0.06133361f, 0.00633889f, -0.00914720f, -0.04391458f, 
    0.00730551f, -0.10338385f, -0.02185914f, -0.07538936f, -0.11663468f, -0.13720343f, -0.18436672f, 0.08974400f, 
    0.02110029f, 0.04604780f, 0.05311771f, 0.01889375f, -0.07696693f, -0.03218573f, 0.01347017f, -0.04797889f, 
    -0.06803561f, 0.04825773f, -0.04161916f, -0.25283995f, 0.12605777f, 0.05751618f, -0.01009264f, -0.13303593f, 
    0.02619153f, -0.01610189f, -0.19058256f, -0.07625782f, -0.38743329f, 0.03900167f, 0.02585596f, 0.14547262f, 
    -0.00125910f, 0.04078774f, -0.05054763f, -0.02047536f, -0.01621708f, 0.11911502f, 0.06007566f, 0.00768125f, 
    0.14278859f, 0.10011122f, 0.07153634f, 0.11933007f, -0.00703436f, -0.00247633f, 0.12383278f, 0.05561616f, 
    0.04369935f, 0.06386714f, 0.01988377f, -0.01862589f, 0.02642417f, -0.01192032f, -0.06147850f, 0.14457874f, 
    0.00051314f, -0.05900231f, 0.05838095f, 0.05410421f, 0.02897955f, 0.01277614f, 0.12365581f, -0.05040299f, 
    -0.23887281f, 0.17457958f, -0.19619775f, 0.03629041f, -0.09504490f, -0.06430154f, 0.08239173f, 0.05621564f, 
    -0.04449649f, 0.08403791f, -0.02541133f, 0.07656156f, 0.22851843f, 0.21718313f, -0.02708035f, -0.06676301f, 
    0.11642769f, 0.03610345f, -0.04504476f, -0.14119074f, -0.00186356f, -0.08056556f, 0.04585732f, -0.04181178f, 
    0.09916183f, -0.14010645f, -0.21911919f, -0.07105405f, 0.05490691f, 0.00048462f, -0.09042216f, -0.02402626f, 
    0.05662160f, 0.02059106f, 0.04463157f, -0.00934957f, 0.03641888f, -0.08497707f, 0.13998954f, 0.07522190f, 
    -0.13362855f, 0.00489321f, 0.02753510f, 0.00408893f, -0.05114337f, -0.12303209f, 0.04175194f, 0.08102451f, 
    -0.17101143f, -0.22163530f, 0.02656625f, 0.14529298f, -0.03113513f, -0.07473381f, -0.13552904f, 0.01428324f, 
    -0.01616773f, 0.06050874f, -0.14716557f, 0.13299718f, -0.04289011f, -0.15179886f, 0.01327696f, 0.09111606f, 
    0.02821962f, 0.02241085f, 0.00358840f, 0.00533977f, 0.03585279f, -0.21271804f, -0.09160345f, 0.04528650f, 
    -0.27930382f, 0.10628447f, 0.09175756f, -0.20412108f, -0.10629086f, 0.08689579f, 0.13192496f, 0.04227091f, 
    -0.03799143f, -0.12275543f, -0.01999446f, -0.20912269f, -0.11420525f, -0.04232726f, 0.32329878f, 0.24185315f, 
    -0.01023416f, -0.12484767f, 0.01927010f, -0.05181780f, -0.06943049f, -0.07335003f, -0.02542222f, 0.21807179f, 
    -0.07357442f, 0.09662174f, -0.00080521f, 0.12611276f, -0.13526151f, -0.03958140f, -0.03246995f, -0.09034205f, 
    -0.02718310f, 0.01482741f, 0.04825627f, -0.01970253f, 0.29780352f, 0.11980283f, 0.03225686f, -0.21570818f, 
    0.04716929f, 0.01047416f, -0.19124146f, -0.12657003f, -0.11091716f, -0.14766723f, -0.06103614f, -0.05574171f, 
    -0.08306982f, 0.03198500f, 0.09775084f, 0.15008302f, -0.02410134f, 0.07363996f, -0.03636732f, -0.00712450f, 
    -0.05190784f, 0.20484059f, -0.08670609f, -0.07778533f, 0.08889099f, 0.00586137f, 0.09557495f, -0.02597173f, 
    0.07159735f, 0.11531947f, 0.00043583f, -0.05742974f, -0.05038247f, -0.04700866f, -0.03191854f, -0.10247716f, 
    -0.02653747f, -0.16284819f, 0.13711162f, 0.05990046f, -0.06416363f, 0.00411385f, 0.10540757f, 0.10521014f, 
    -0.07783210f, 0.03577743f, -0.12925804f, 0.13055572f, -0.05515923f, -0.04400808f, 0.00277737f, 0.21871726f, 
    -0.16955855f, 0.10182776f, -0.00507871f, 0.09581601f, 0.05072352f, 0.15669060f, 0.00827761f, -0.10570210f, 
    0.32554772f, 0.11281736f, -0.02939289f, -0.01665398f, 0.05751155f, -0.04168974f, -0.02832014f, 0.08953390f, 
    -0.04584806f, -0.06905972f, -0.26729047f, -0.12406556f, 0.18624771f, 0.18748824f, 0.14686593f, -0.07014716f, 
    -0.03549030f, 0.07910817f, -0.11254119f, -0.12969844f, 0.04635387f, -0.13030685f, -0.07494789f, -0.02111931f, 
    -0.36121050f, -0.04461936f, -0.15395756f, 0.04372361f, 0.03911842f, -0.05908939f, -0.09348847f, 0.03147455f, 
    0.03263115f, 0.01899445f, 0.13572936f, 0.16765477f, 0.17599201f, 0.13596846f, -0.14218406f, 0.11246920f, 
    -0.14369717f, 0.01495343f, 0.00082842f, 0.12246229f, 0.01105657f, -0.01867336f, -0.01423139f, 0.07089993f, 
    -0.18279411f, -0.25121355f, -0.10358299f, -0.09228168f, 0.04566238f, -0.05490838f, -0.00646638f, 0.06120131f, 
    0.00365350f, 0.21051812f, -0.02216330f, 0.12185387f, 0.15203865f, 0.11971124f, -0.00093196f, -0.21127048f, 
    0.15007024f, 0.06128769f, -0.08619540f, 0.05608817f, 0.08364547f, 0.14255728f, -0.02945696f, 0.01440654f, 
    -0.20396966f, 0.18289192f, 0.04153318f, -0.54976225f, -0.10970856f, -0.06873856f, -0.06705813f, -0.09200485f, 
    0.08123056f, -0.09406091f, 0.06915592f, -0.12977123f, 0.02891799f, 0.11106954f, -0.03909226f, 0.17821217f, 
    -0.02380615f, -0.07284927f, -0.03693979f, -0.02535954f, 0.00461634f, -0.12682065f, -0.01621649f, 0.00783295f, 
    -0.05697006f, -0.03383016f, 0.09934309f, 0.06758686f, -0.11986676f, 0.00566355f, -0.08831223f, 0.04438563f, 
    0.02572222f, 0.05646240f, -0.05190950f, 0.03805486f, -0.05085011f, -0.05265259f, -0.12647657f, -0.06348982f, 
    0.07680649f, 0.08995286f, -0.13471566f, -0.20307451f, 0.11521830f, -0.14178421f, 0.15739304f, -0.03267226f, 
    0.10989881f, -0.14667352f, 0.07228045f, -0.02609971f, 0.09481056f, -0.06087242f, -0.04013374f, 0.10706168f, 
    0.11756336f, 0.10680851f, 0.12871830f, 0.10059556f, 0.06679676f, -0.12361858f, -0.03510983f, 0.07264560f, 
    -0.06028419f, 0.05168001f, 0.02224368f, 0.04290450f, 0.05268494f, 0.08215985f, 0.03416502f, -0.09679600f, 
    -0.02810299f, 0.02458346f, 0.11236552f, 0.08771729f, 0.08941884f, -0.07697152f, -0.00196222f, 0.02046932f, 
    0.02099779f, -0.02636572f, -0.10398120f, 0.06517158f, 0.19077860f, -0.28124186f, -0.20175894f, 0.00414208f, 
    0.02978886f, -0.07025634f, -0.07402952f, -0.01067277f, 0.07219833f, -0.13719392f, -0.07818173f, -0.06423131f, 
    0.13803233f, -0.07808254f, 0.14346659f, -0.00208305f, -0.05089646f, 0.10620592f, -0.06900312f, -0.06059773f, 
    0.06861188f, -0.01408332f, 0.05469104f, 0.06520128f, -0.27713960f, 0.07375927f, -0.04729944f, -0.15246475f, 
    -0.01567886f, 0.03807647f, -0.08573457f, 0.13751557f, 0.08400017f, 0.02532573f, 0.07246920f, -0.05053810f, 
    0.08752373f, -0.07042357f, 0.06988753f, 0.06436521f, -0.09260539f, 0.11329746f, 0.04615312f, -0.03174729f, 
    0.00844682f, 0.05099335f, -0.05624811f, 0.22222933f, -0.16371679f, -0.04959771f, 0.09479342f, -0.17235428f, 
    0.08602159f, -0.09893801f, -0.08382326f, -0.02095989f, 0.11671196f, -0.15579525f, 0.11336464f, -0.10906852f, 
    0.05763714f, 0.02008357f, -0.01670774f, -0.15194212f, -0.00582651f, 0.02973307f, -0.03858098f, 0.05929449f, 
    -0.01441375f, -0.01118001f, 0.03993567f, 0.20280917f, 0.02432881f, 0.02213637f, -0.25811875f, -0.04033017f, 
    0.03545003f, -0.08727962f, 0.01355993f, -0.04804996f, 0.02989412f, 0.05477775f, -0.10631945f, -0.04285125f, 
    -0.75447500f, -0.41850027f, -0.16773845f, -0.12331802f, 0.10873125f, 0.08821372f, 0.11293639f, -0.02407568f, 
    0.08674649f, 0.05124706f, 0.07397290f, 0.01586181f, 0.06850626f, 0.12736402f, -0.01680129f, 0.12754333f, 
    0.00079739f, -0.14040677f, -0.00495090f, 0.04640795f, -0.10400774f, 0.00427797f, 0.09628750f, 0.09005535f, 
    0.07676965f, 0.01464508f, 0.11161294f, 0.11787081f, 0.09105920f, 0.00490716f, 0.12976290f, 0.00669067f, 
    0.06117947f, -0.18149547f, 0.17565636f, 0.19098003f, -0.17976338f, 0.03576908f, -0.12022876f, -0.26044637f, 
    0.07608120f, -0.11541945f, 0.06233216f, 0.17973115f, 0.04857609f, -0.03136446f, -0.03460995f, -0.16982499f, 
    0.14060712f, -0.03878035f, -0.01488034f, 0.21448383f, -0.13141090f, -0.07018407f, -0.03938374f, -0.05421709f, 
    0.02018144f, -0.12331758f, 0.01462644f, 0.11200959f, -0.03112913f, 0.03269257f, 0.22530216f, 0.15751779f, 
    -0.03830547f, -0.09055926f, -0.01412202f, -0.07355764f, 0.08290018f, -0.00140551f, -0.05264450f, 0.13711342f, 
    -0.10817751f, 0.15784261f, 0.04762652f, 0.04277504f, 0.01040775f, 0.01590576f, 0.03133163f, 0.08567520f, 
    0.13181968f, -0.02151362f, -0.14940140f, 0.00432509f, 0.25243372f, -0.02383916f, -0.05342495f, -0.04521161f, 
    -0.03075097f, -0.03722489f, -0.05184102f, -0.11130718f, -0.15213570f, 0.11868257f, 0.08647539f, -0.01740451f, 
    0.17431818f, -0.19579156f, -0.00189966f, 0.29359239f, 0.10458588f, 0.05527425f, 0.06501824f, 0.08183387f, 
    0.07657504f, 0.00533681f, -0.00694908f, -0.03562470f, -0.08322847f, -0.12296404f, 0.12887581f, 0.24731506f, 
    0.09848547f, 0.08158987f, 0.11771549f, -0.07942992f, 0.14499311f, -0.15581684f, -0.05532086f, 0.01738654f, 
    -0.20351554f, 0.12389433f, -0.08768666f, -0.25736669f, 0.15466291f, -0.01119431f, 0.03530562f, -0.15268381f, 
    0.13160244f, -0.16699266f, 0.03728644f, 0.02323559f, -0.31524739f, 0.06049135f, 0.00643501f, 0.20381361f, 
    -0.05582050f, -0.14321469f, -0.05550135f, 0.01682869f, 0.10128056f, -0.04984175f, 0.01868078f, -0.04697024f, 
    -0.03210926f, -0.06783819f, -0.11406823f, -0.19090632f, 0.01873986f, 0.00862512f, 0.02900584f, -0.00490307f, 
    -0.00158064f, 0.08702331f, 0.16330215f, 0.19187255f, 0.30897698f, 0.04540062f, 0.07243852f, 0.00433058f, 
    0.02027231f, -0.05965900f, -0.05568582f, -0.18720160f, 0.00359199f, 0.01639576f, -0.04061752f, 0.01043826f, 
    0.02119227f, -0.05106741f, 0.06157240f, 0.19819905f, -0.10249890f, 0.18582907f, 0.01304071f, 0.03006798f, 
    -0.10305407f, -0.05517277f, 0.13481866f, 0.14414981f, -0.04345422f, 0.08199020f, 0.16657458f, 0.06702437f, 
    0.10753763f, -0.05415070f, -0.11883741f, -0.10470514f, -0.19722286f, 0.12614019f, 0.04203200f, -0.05102491f, 
    -0.14283600f, -0.02011482f, 0.09738129f, 0.15388176f, -0.03597260f, -0.00407223f, 0.03694269f, 0.10637467f, 
    0.01770126f, 0.02817110f, -0.15049112f, 0.01316686f, -0.13967851f, -0.04279028f, 0.15443240f, 0.15115294f, 
    -0.08001722f, 0.09444229f, 0.18843384f, -0.03212356f, -0.23465709f, -0.03972863f, 0.07559282f, -0.12790431f, 
    0.12524471f, -0.13648209f, 0.15379530f, 0.18474728f, 0.10094032f, 0.08259986f, -0.06403818f, -0.01967367f, 
    0.04407100f, -0.03716194f, 0.12836826f, -0.07527913f, 0.20222701f, 0.15049796f, 0.02393606f, -0.03509831f, 
    -0.08158188f, 0.18156455f, 0.05889873f, -0.07321274f, -0.13856871f, -0.18339124f, 0.07256015f, 0.04523086f, 
    0.00448954f, 0.04143021f, 0.12540615f, -0.11428297f, 0.01300016f, 0.09013963f, 0.11742049f, -0.01038846f, 
    0.01391066f, 0.00923285f, 0.05506403f, 0.06870303f, -0.16262765f, -0.21403946f, -0.06015296f, -0.07265388f, 
    0.04499926f, 0.17174959f, -0.04097965f, 0.00660334f, 0.04558410f, 0.11648758f, 0.00224290f, 0.08446576f, 
    -0.32039186f, 0.12743349f, 0.01787876f, -0.12659699f, 0.05884088f, 0.02580597f, 0.13514404f, 0.15455741f, 
    -0.01264010f, 0.13760962f, 0.03430190f, 0.02894085f, -0.20124286f, -0.02312989f, -0.17525078f, -0.02707464f, 
    0.13375364f, -0.11869588f, -0.04362799f, -0.02003841f, -0.14972356f, -0.20739414f, 0.10302820f, -0.03587564f, 
    -0.17017673f, -0.05081495f, -0.01353925f, -0.30785421f, -0.02242191f, 0.06495728f, -0.07917648f, -0.01890091f, 
    -0.02883835f, -0.02966125f, -0.11007184f, 0.00592865f, -0.10779624f, 0.09849878f, 0.07265945f, 0.03473997f, 
    0.03024837f, -0.03607937f, -0.07174309f, -0.02591270f, -0.12112655f, -0.01864414f, -0.09762614f, 0.16775137f, 
    -0.30292094f, -0.07984731f, 0.07721335f, 0.05281493f, -0.12539804f, -0.12418044f, 0.07333405f, 0.02890546f, 
    -0.08056270f, 0.00062656f, -0.03935584f, 0.01567971f, -0.19294699f, -0.11680917f, -0.19954994f, -0.04295309f, 
    0.04871159f, 0.10194264f, -0.06147728f, -0.02463655f, 0.03218880f, -0.19065458f, 0.11158002f, -0.02914333f, 
    -0.10215742f, -0.15410750f, -0.10253824f, 0.05543509f, 0.07540967f, -0.13549237f, -0.08593188f, -0.10661938f, 
    -0.04994154f, 0.13821273f, -0.09899131f, 0.04844224f, 0.02081575f, -0.13610430f, -0.10573163f, -0.07626900f, 
    -0.00821058f, 0.00237668f, -0.04101362f, -0.08757452f, -0.09823409f, -0.03013919f, 0.01357614f, 0.13869610f, 
    -0.36153218f, -0.00985509f, 0.12729776f, 0.04197237f, 0.03053494f, -0.05473882f, 0.02247648f, -0.21694265f, 
    0.08413665f, -0.10515015f, -0.04633598f, -0.21189816f, -0.08866635f, 0.07768425f, 0.14016616f, -0.06404375f, 
    0.13286309f, 0.00137644f, -0.07909362f, -0.13770811f, 0.03847037f, 0.01235599f, -0.14603363f, 0.05521872f, 
    0.03356833f, 0.08551767f, -0.09103978f, -0.09913993f, -0.05314070f, 0.05092677f, 0.14243512f, 0.06305303f, 
    -0.06671917f, -0.07131710f, 0.00209217f, 0.08294947f, 0.15468518f, 0.17731960f, -0.06906489f, -0.11171251f, 
    -0.02632334f, 0.05740592f, -0.14106449f, 0.00403536f, -0.05932925f, 0.02300579f, -0.00025971f, -0.02541152f, 
    0.10046806f, -0.16430067f, -0.09317813f, 0.04750727f, -0.06770558f, 0.14999385f, -0.00318562f, -0.03991376f, 
    -0.00534591f, -0.05463307f, -0.04930654f, 0.12855606f, -0.12968628f, 0.01083580f, -0.07631417f, -0.00494768f, 
    0.02233086f, -0.00891062f, -0.12898958f, -0.15908174f, -0.07980050f, 0.04733823f, 0.09668441f, -0.07808352f, 
    0.08436345f, -0.36951563f, 0.07563613f, -0.07438494f, 0.07950064f, 0.03676946f, 0.06712925f, -0.06019319f, 
    0.10616933f, -0.04848618f, 0.13428937f, 0.15213616f, -0.21630347f, 0.08125858f, 0.03168498f, 0.06964133f, 
    -0.17066476f, 0.07257038f, 0.11959321f, -0.01279126f, 0.16943428f, -0.04359147f, 0.00369497f, -0.07618754f, 
    -0.07749175f, -0.07783948f, 0.03965043f, -0.21410361f, 0.06775314f, 0.08918159f, 0.06156154f, 0.07295222f, 
    -0.11091112f, -0.11892373f, 0.05942968f, 0.01273376f, -0.21240380f, 0.05424711f, -0.05136406f, 0.00155950f, 
    -0.06759545f, 0.06655224f, 0.06055755f, 0.07075099f, 0.13077930f, 0.06883504f, -0.00399156f, 0.07736224f, 
    0.12549081f, 0.01109375f, 0.30030781f, 0.20002764f, 0.05466270f, -0.12682371f, -0.06042776f, -0.15453826f, 
    -0.08615790f, -0.00544481f, 0.14501719f, 0.15191224f, 0.00008284f, 0.12734225f, 0.04608000f, -0.10023858f, 
    -0.19359598f, -0.08581394f, 0.01425598f, -0.06333914f, 0.07374720f, 0.04163345f, 0.03744426f, 0.14981203f, 
    0.20936660f, -0.10370833f, 0.02047441f, -0.08158550f, 0.03671414f, 0.00669793f, 0.02125784f, -0.06404495f, 
    0.02081916f, 0.03192358f, 0.02880543f, -0.08417791f, -0.11491554f, -0.12265686f, 0.00485414f, 0.20038645f, 
    0.24890152f, -0.05887933f, 0.00058775f, 0.00450979f, -0.06204091f, 0.02319383f, -0.12170736f, 0.02719279f, 
    -0.11214026f, 0.14479333f, 0.03159269f, 0.15095633f, -0.15172838f, -0.03717546f, 0.07019754f, 0.09014382f, 
    -0.02014900f, -0.00425470f, 0.10636275f, 0.11078403f, -0.12621292f, -0.27741969f, 0.01458137f, 0.08381289f, 
    0.00723379f, -0.03752983f, 0.12153829f, 0.07510520f, -0.06393435f, -0.07908587f, 0.04981947f, -0.00818717f, 
    -0.18827361f, -0.03448740f, -0.08295484f, -0.10522746f, 0.03415817f, -0.08269792f, -0.01810911f, -0.15214770f, 
    -0.07557085f, 0.01947493f, -0.03791766f, -0.06576963f, -0.08338759f, -0.06876969f, -0.12490083f, -0.27373108f, 
    0.08538593f, 0.02002450f, 0.02867390f, -0.00003533f, -0.01355514f, -0.12551145f, 0.00048598f, 0.09528465f, 
    0.05221921f, -0.22076689f, 0.04935627f, 0.12747554f, -0.02868366f, 0.09624735f, -0.00680141f, -0.03955935f, 
    0.06615239f, -0.07676170f, 0.05821443f, -0.00060173f, 0.04220263f, 0.13156439f, 0.13533646f, 0.27610451f, 
    -0.12600227f, -0.06560437f, -0.03522044f, -0.02470863f, 0.00474227f, 0.00921389f, 0.14990903f, -0.13631625f, 
    0.06308549f, -0.16547376f, 0.14720526f, -0.00158110f, 0.00784471f, 0.03265510f, 0.05188338f, 0.04127468f, 
    -0.02547024f, -0.02850810f, 0.04902252f, -0.00791433f, -0.44424054f, 0.24037194f, -0.06873947f, 0.35040328f, 
    0.02333173f, 0.05812450f, -0.04927927f, 0.10833116f, -0.06277114f, -0.03578416f, -0.09670386f, -0.07251962f, 
    -0.09189939f, 0.21254738f, 0.05160197f, -0.31740254f, 0.04630277f, 0.03713531f, 0.06299007f, 0.04060835f, 
    -0.05281353f, 0.01748081f, 0.00694032f, -0.00745539f, -0.19977580f, -0.18352947f, -0.31926501f, 0.11715148f, 
    -0.01190326f, -0.05766924f, -0.02638543f, 0.02469527f, -0.03687015f, 0.12595886f, 0.00562669f, 0.00313819f, 
    -0.15491600f, 0.08311093f, 0.03864074f, -0.03185944f, -0.07662216f, -0.00979550f, 0.15875921f, 0.07831690f, 
    0.02219288f, -0.16893832f, -0.10339228f, -0.20439884f, -0.17517963f, 0.21495874f, 0.03715040f, -0.11119927f, 
    0.03996179f, -0.07361557f, -0.01092483f, 0.10024714f, 0.03507940f, 0.03336712f, -0.05175037f, 0.06721886f, 
    0.01771311f, 0.17023534f, 0.10445153f, -0.11928562f, 0.01369438f, -0.03217588f, 0.00541453f, 0.06643867f, 
    -0.10665448f, -0.03570236f, 0.18296577f, 0.06540208f, -0.14408350f, -0.01273327f, -0.15964684f, 0.15205489f, 
    0.00391784f, 0.01792247f, 0.04087197f, 0.01038761f, 0.00119976f, 0.04318983f, 0.06246832f, -0.01941638f, 
    -0.41495842f, 0.29081738f, 0.02891159f, 0.09735660f, 0.01172851f, 0.06506456f, 0.02395422f, -0.00586417f, 
    0.06856243f, -0.11676484f, 0.08756746f, -0.21581677f, 0.08310951f, -0.19911534f, 0.04441886f, -0.23720172f, 
    0.00813866f, -0.07080168f, 0.08712645f, 0.03333279f, -0.02592298f, -0.01644277f, -0.09614405f, 0.00158329f, 
    -0.02990887f, 0.23958653f, 0.09988055f, -0.15176882f, -0.11619698f, -0.04409673f, 0.03901542f, -0.01391099f, 
    -0.01502885f, -0.00905553f, 0.09664959f, -0.07441729f, 0.10743816f, -0.36421895f, -0.02060160f, 0.05983226f, 
    -0.02966656f, 0.06830084f, 0.13148420f, 0.01515302f, -0.01378664f, 0.02363339f, -0.01113890f, 0.06966564f, 
    -0.10673042f, 0.08494067f, 0.03693296f, -0.00140548f, -0.10110407f, 0.16982673f, -0.01659671f, -0.03204478f, 
    0.01188829f, -0.01070768f, 0.03338522f, -0.12172510f, -0.08058555f, -0.09648052f, -0.07685345f, 0.01282391f, 
    0.00094314f, 0.05797847f, -0.05204372f, -0.01190669f, -0.05175927f, -0.02087141f, 0.09617328f, -0.01718790f, 
    -0.02059062f, 0.01878274f, -0.01987849f, -0.21476087f, -0.11279614f, 0.00590721f, -0.00459180f, -0.15619636f, 
    -0.07435749f, 0.07440662f, 0.00161630f, 0.04842599f, 0.00082750f, -0.09513947f, -0.05480149f, -0.08621565f, 
    -0.06253540f, -0.01013562f, 0.03692372f, 0.04099664f, -0.05221400f, -0.10323195f, -0.07465895f, 0.04055322f, 
    0.04967193f, 0.04044944f, -0.05258689f, 0.10024908f, -0.05012445f, 0.06857668f, -0.11663868f, -0.10376344f, 
    -0.13786614f, 0.02682648f, 0.00378181f, -0.13436717f, 0.05566949f, -0.28352571f, 0.08504637f, -0.08545565f, 
    -0.03391823f, 0.06085580f, 0.14889079f, -0.02435946f, 0.06017612f, -0.04310684f, 0.03317063f, 0.08436007f, 
    -0.06446341f, 0.08016542f, -0.05706229f, -0.25405872f, 0.05871712f, 0.03315950f, 0.06559411f, 0.06978505f, 
    -0.00678086f, 0.13658825f, -0.06704699f, -0.02880981f, -0.03920141f, 0.09705028f, 0.01026999f, -0.12865649f, 
    -0.17092794f, 0.03831518f, 0.00429695f, 0.06324164f, 0.05375640f, -0.08450729f, 0.04509925f, -0.06593915f, 
    -0.11986931f, -0.04006412f, -0.16493273f, 0.19806461f, -0.00122772f, 0.01957357f, -0.19371673f, -0.10364952f, 
    0.00456539f, 0.03556928f, -0.03287914f, 0.05668579f, -0.38395205f, -0.01278859f, -0.11340550f, 0.12648003f, 
    0.12666695f, -0.10248446f, -0.01254943f, 0.05107538f, 0.15977132f, -0.06796696f, 0.08719582f, -0.02486769f, 
    -0.26082659f, 0.17442711f, -0.00298186f, 0.03646030f, -0.10773351f, -0.13519643f, -0.00417250f, -0.11201145f, 
    0.02802606f, 0.06938281f, 0.02231980f, -0.13592055f, 0.05919227f, -0.08637703f, -0.38453096f, 0.00818918f, 
    -0.08466554f, -0.10434082f, -0.02747022f, 0.02570257f, -0.00409984f, 0.10999288f, -0.20424232f, -0.07570977f, 
    0.22584969f, -0.09355389f, 0.03537842f, -0.25902647f, 0.02734378f, -0.05031417f, 0.04015979f, 0.06256297f, 
    0.00924183f, 0.04356268f, 0.04087417f, -0.02391372f, 0.02785466f, -0.13410626f, -0.20073648f, 0.27625054f, 
    -0.02458569f, 0.10662329f, -0.05419915f, 0.08123001f, -0.05237374f, 0.02071813f, -0.12957586f, -0.04743800f, 
    0.08899361f, 0.30935115f, 0.17262261f, -0.30599660f, -0.10985250f, 0.14746374f, 0.00471837f, 0.08182644f, 
    -0.00125299f, 0.02366495f, -0.21260215f, -0.05691326f, -0.46720797f, 0.15462328f, 0.06475844f, 0.02620483f, 
    0.10020059f, 0.10074823f, 0.20213033f, 0.11791041f, -0.03208646f, 0.09989255f, 0.07986777f, 0.11971365f, 
    -0.03171383f, -0.05440280f, 0.06744003f, -0.14483137f, 0.09282351f, -0.09526474f, 0.03697245f, -0.05184321f, 
    -0.03810055f, -0.03091291f, -0.11203694f, -0.13069637f, -0.07731544f, 0.10746365f, -0.00399200f, -0.06324287f, 
    -0.00052857f, 0.10393084f, -0.08133482f, 0.08231450f, 0.06293130f, -0.19302709f, 0.09810581f, -0.05388992f, 
    0.08488619f, 0.03986029f, -0.01634120f, 0.09404265f, 0.03593424f, 0.02104189f, 0.03944667f, -0.00828559f, 
    -0.08042290f, 0.04757352f, 0.12944274f, -0.12877192f, 0.10968159f, -0.00936196f, -0.07829113f, -0.12098976f, 
    -0.08524887f, -0.00176986f, -0.03573558f, -0.00490015f, 0.04753162f, -0.00278718f, 0.03144108f, 0.05740697f, 
    -0.09302483f, -0.23772196f, -0.35641241f, 0.13031952f, -0.02938416f, 0.02306824f, -0.03023915f, -0.07458517f, 
    0.04167047f, -0.04823295f, -0.08389218f, 0.01366360f, -0.26406783f, 0.04500434f, 0.22661619f, 0.09591936f, 
    0.20984112f, -0.08586886f, 0.06742458f, 0.03218439f, 0.22209908f, 0.15271558f, -0.08329425f, -0.00263033f, 
    -0.07406154f, 0.12529245f, 0.10248008f, -0.01637105f, -0.04251172f, 0.02462905f, 0.04958573f, -0.02744063f, 
    -0.00592647f, 0.05907790f, -0.08585266f, -0.12073906f, -0.31976002f, 0.02128938f, -0.10192056f, 0.03347375f, 
    -0.04396211f, 0.00117506f, 0.06904110f, -0.02572356f, 0.04311650f, -0.09287053f, 0.02193493f, -0.11388157f, 
    0.34735897f, -0.23351815f, 0.09237103f, -0.14197016f, 0.05560106f, -0.09610771f, 0.05098831f, -0.18760973f, 
    -0.07050312f, -0.01863970f, 0.06325736f, -0.07082054f, 0.17996959f, -0.02922570f, 0.13398108f, 0.28508979f, 
    -0.05003444f, 0.04320575f, -0.08354243f, -0.05091583f, -0.03070467f, 0.15242174f, -0.08100408f, -0.01004972f, 
    0.13976254f, 0.16626345f, 0.06565436f, -0.26535127f, -0.00445549f, -0.05376128f, 0.01228470f, 0.04745097f, 
    -0.02926166f, 0.10394977f, 0.03150535f, -0.03160546f, 0.06930514f, -0.28795579f, -0.24949902f, -0.00585357f, 
    -0.04007657f, 0.02629601f, -0.03269053f, -0.07024392f, 0.04987617f, -0.03677460f, -0.07566585f, -0.04902500f, 
    0.22831194f, -0.13790371f, 0.11285095f, 0.09990373f, 0.05085427f, 0.00719801f, 0.03151855f, -0.01318704f, 
    -0.13690628f, 0.01324889f, 0.01672400f, -0.09811799f, 0.18690895f, -0.18226086f, -0.09590221f, -0.19266006f, 
    -0.00229072f, 0.08446438f, 0.08105071f, -0.14091492f, -0.07380196f, 0.12122769f, -0.02436442f, 0.06335523f, 
    -0.08295530f, -0.20457050f, -0.15509103f, 0.10947489f, 0.01899316f, 0.04869633f, 0.03332886f, 0.01360618f, 
    0.06839938f, -0.24903996f, 0.01608491f, 0.01147864f, -0.30433404f, 0.26825309f, 0.03121098f, -0.08090267f, 
    -0.02132124f, -0.00823314f, 0.06880066f, 0.03265052f, 0.07401691f, -0.10446408f, -0.00636917f, 0.07200366f, 
    0.16052674f, -0.22581193f, -0.24806175f, 0.22282650f, -0.14323682f, -0.02186148f, 0.03580545f, 0.11846105f, 
    0.02014140f, -0.05765974f, 0.06477264f, 0.17268199f, -0.30123433f, 0.30147922f, 0.06958628f, 0.24351075f, 
    0.06780931f, 0.03295341f, 0.00025558f, 0.02762917f, -0.06987843f, -0.02861313f, 0.04613916f, 0.00515032f, 
    0.02124391f, 0.15010412f, 0.08415267f, 0.02810126f, 0.04018384f, 0.06359763f, 0.08793470f, -0.08852350f, 
    0.00280165f, 0.02335240f, -0.02303754f, -0.04409503f, -0.13645421f, -0.06840210f, -0.15850410f, -0.06705882f, 
    -0.02476920f, -0.05371513f, 0.01473847f, -0.03720893f, -0.05335411f, -0.03243997f, -0.03454364f, 0.02815134f, 
    -0.00834919f, 0.11949611f, 0.06986910f, 0.14004688f, 0.10211378f, -0.08761273f, 0.04217622f, 0.01856935f, 
    0.00097803f, -0.01149862f, -0.00774250f, -0.06435835f, 0.09976744f, 0.10786642f, 0.02591673f, 0.17875710f, 
    0.01100477f, 0.00839728f, -0.01555342f, -0.02486025f, -0.02717079f, -0.04824904f, -0.01996570f, -0.09448882f, 
    0.32889369f, -0.13465856f, 0.09126118f, -0.07242869f, -0.01247545f, 0.01697155f, 0.01973622f, 0.00089002f, 
    0.03282685f, 0.02085256f, 0.00274124f, -0.05065456f, 0.07083172f, -0.02191347f, 0.06290394f, 0.08997720f, 
    0.05648091f, -0.02653963f, -0.10804822f, 0.06029907f, -0.01620973f, -0.01307377f, -0.08399913f, -0.09425561f, 
    0.11407956f, 0.04200375f, -0.09134950f, -0.07756043f, -0.01769910f, -0.08032853f, -0.00651347f, -0.05683637f, 
    -0.09145548f, -0.02645701f, -0.06440944f, -0.01253667f, 0.22282963f, 0.07101171f, -0.10809562f, -0.07664769f, 
    -0.00829313f, -0.04526449f, -0.01184040f, -0.04508457f, -0.01092148f, 0.00489901f, -0.03746393f, -0.01320613f, 
    0.03826233f, 0.08387060f, 0.05015500f, 0.14659366f, 0.06139556f, -0.04156497f, -0.02477204f, -0.02662532f, 
    -0.11685820f, -0.07878437f, 0.00334861f, -0.06521481f, -0.23089412f, 0.06678616f, -0.04865181f, -0.17654814f, 
    0.00378594f, -0.00393378f, -0.00810701f, -0.03308303f, -0.05158225f, 0.01229655f, -0.03565946f, -0.16610678f, 
    0.18037702f, -0.09094125f, 0.08462916f, 0.08414206f, 0.07798924f, -0.01204492f, -0.02584651f, -0.00620483f, 
    -0.01210437f, -0.06998261f, 0.00979304f, 0.01090808f, 0.15031031f, -0.42994016f, 0.05442157f, 0.01464544f, 
    -0.05194252f, -0.02825153f, 0.01979180f, -0.01995656f, -0.01982032f, -0.11351645f, -0.03781833f, 0.02084269f, 
    -0.02435576f, -0.12889583f, -0.00640695f, -0.13739321f, 0.03909261f, -0.04322985f, -0.06913518f, -0.09055635f, 
    0.02161876f, -0.03243583f, -0.03169857f, -0.04628939f, -0.09539346f, 0.02455300f, 0.06187176f, -0.00225277f, 
    0.05120667f, 0.00405800f, -0.03161009f, -0.03459143f, -0.02826817f, -0.15408885f, 0.00759270f, 0.04691083f, 
    0.14672352f, 0.15485702f, 0.16763191f, 0.13959412f, 0.02423773f, 0.03908288f, 0.06341340f, -0.02849860f, 
    -0.05886974f, -0.06405560f, -0.04673023f, 0.00078336f, 0.05678810f, -0.10123790f, 0.05470197f, 0.11623424f, 
    0.09565148f, -0.09769304f, -0.01766842f, -0.08908594f, -0.02428089f, 0.03820375f, 0.04162997f, -0.05185048f, 
    0.18777107f, -0.22139871f, 0.08283570f, 0.08292782f, -0.02580133f, -0.03342907f, -0.06237543f, -0.07215235f, 
    -0.02363214f, -0.02075438f, -0.02028419f, -0.01734232f, -0.00511278f, -0.06487296f, -0.02843267f, 0.03280281f, 
    -0.06177355f, -0.10080756f, -0.01080378f, -0.04196779f, -0.00564121f, -0.06076513f, 0.07622745f, -0.04038742f, 
    -0.07562876f, -0.00531132f, -0.04220936f, -0.14050426f, -0.04058387f, 0.08710121f, -0.06394618f, -0.09048799f, 
    -0.06322886f, -0.06225079f, -0.01793562f, -0.02349859f, -0.28517586f, -0.07803124f, -0.12385408f, -0.23525321f, 
    -0.00369393f, -0.07997358f, -0.07350732f, -0.01038178f, -0.07265304f, 0.02002246f, -0.03765667f, -0.01274108f, 
    -0.26904446f, -0.11615163f, -0.12773444f, -0.13047497f, 0.02885260f, -0.02030836f, -0.03236191f, -0.02823784f, 
    -0.11306345f, -0.07259264f, -0.03415469f, 0.00806710f, -0.09977689f, 0.23526843f, 0.03216076f, 0.12970413f, 
    0.12635580f, 0.01011749f, 0.01482205f, 0.05937171f, 0.07201912f, -0.03635595f, 0.03361062f, -0.05135506f, 
    0.26108533f, 0.00333634f, 0.07219870f, -0.08718653f, -0.12209432f, -0.05562196f, -0.06137003f, -0.01500898f, 
    0.03118237f, -0.04999670f, -0.03248893f, 0.00187099f, -0.04633461f, -0.00328516f, -0.09419518f, -0.18074054f, 
    -0.00003970f, -0.10186227f, 0.00557018f, -0.03340391f, -0.10309707f, -0.00457254f, -0.04306957f, 0.01898140f, 
    0.03588920f, -0.16937838f, -0.09649080f, -0.10491963f, -0.07649163f, 0.04791182f, -0.03610785f, -0.09026932f, 
    0.00254046f, -0.06067252f, -0.07756047f, -0.02561956f, -0.06804433f, 0.14615254f, -0.13078934f, 0.06435455f, 
    -0.04445868f, -0.00017305f, 0.00137566f, -0.02053945f, 0.04035433f, 0.01918992f, -0.01331055f, -0.02006426f, 
    -0.16318382f, -0.07676773f, -0.16957922f, -0.10939291f, 0.00166573f, 0.06581131f, -0.01876002f, -0.00125603f, 
    -0.01093087f, -0.00628937f, 0.02557236f, 0.01607864f, 0.09600554f, -0.03237114f, 0.09374448f, 0.06202456f, 
    -0.00143089f, 0.07190197f, 0.03970798f, -0.03037437f, -0.02794862f, 0.01029468f, -0.09238301f, -0.05260416f, 
    -0.23122935f, 0.07492351f, -0.10885248f, 0.01134335f, -0.02716481f, 0.04210275f, -0.02418302f, -0.04215858f, 
    -0.05594828f, -0.01528082f, 0.08053387f, -0.02825380f, -0.13501394f, 0.02862592f, -0.07213495f, -0.06748944f, 
    -0.07804267f, -0.05008042f, 0.00668218f, -0.12998423f, -0.13572249f, 0.01072713f, -0.01827081f, -0.06659758f, 
    -0.09020877f, 0.11409527f, -0.13992989f, -0.06601328f, 0.00168319f, -0.05462128f, -0.01346415f, -0.02095458f, 
    -0.01044426f, 0.00945399f, 0.08216275f, -0.06439729f, -0.14999820f, 0.21805073f, 0.01828813f, 0.02840838f, 
    -0.13672540f, 0.05570493f, -0.00886770f, 0.03048874f, 0.04612530f, 0.02502817f, -0.00837244f, -0.02429892f, 
    -0.02003348f, 0.16429918f, 0.14239512f, 0.14613605f, 0.04058950f, 0.04570171f, 0.01953413f, 0.02627654f, 
    -0.04532570f, 0.03160285f, -0.01397180f, 0.01363621f, 0.14623252f, -0.09305508f, 0.03020367f, 0.13955244f, 
    -0.00477792f, -0.09487718f, -0.08896041f, -0.07104176f, -0.08277461f, -0.04020767f, -0.04459141f, -0.07400446f, 
    0.00561246f, -0.08519912f, -0.12578687f, 0.15430208f, 0.02180738f, -0.07096307f, -0.05381535f, -0.01390980f, 
    -0.03131155f, -0.06575449f, 0.04750641f, 0.01055790f, 0.22914486f, 0.00663913f, 0.18647529f, -0.10400524f, 
    0.10056128f, 0.01657156f, 0.00003333f, -0.02938124f, 0.03247985f, 0.02401831f, 0.04415236f, -0.03683591f, 
    0.07782425f, -0.27412915f, 0.14380899f, 0.12347116f, -0.00028264f, -0.03610326f, -0.04519818f, -0.02996423f, 
    0.01313602f, -0.01635534f, 0.01460822f, -0.04409236f, -0.34059045f, 0.22381751f, -0.00761171f, -0.09095589f, 
    -0.15933354f, -0.00968958f, 0.01798785f, -0.09331217f, -0.05654956f, 0.02989240f, -0.04170203f, -0.07513639f, 
    0.00487033f, 0.20089746f, -0.04011945f, 0.07165027f, -0.00047849f, -0.05687176f, -0.04451564f, -0.00965373f, 
    -0.03967278f, -0.00588027f, -0.01496126f, -0.04254602f, -0.14734097f, 0.03123488f, -0.12365642f, -0.03044291f, 
    0.04969328f, 0.01515065f, -0.02828461f, -0.08627886f, 0.01957828f, -0.05684201f, -0.00770696f, -0.02332014f, 
    0.06300452f, 0.03498342f, -0.15652332f, -0.05289706f, 0.04423792f, -0.00592773f, -0.07589863f, 0.00599556f, 
    -0.05566726f, 0.01802160f, 0.04290341f, 0.08103327f, 0.07750502f, 0.16956505f, 0.16145456f, 0.15797219f, 
    0.05705328f, 0.01024432f, 0.00308687f, 0.02723154f, -0.03802449f, -0.03441632f, 0.04427728f, -0.03610045f, 
    0.25522849f, -0.02481083f, 0.10907187f, -0.10081957f, 0.02088257f, 0.06017256f, -0.01025210f, -0.03828283f, 
    -0.05732960f, 0.08953951f, -0.02619558f, -0.06380820f, -0.02337624f, 0.05566232f, -0.09000761f, 0.14279990f, 
    0.00264930f, -0.03132484f, 0.02688002f, -0.02734638f, -0.04116948f, 0.00511723f, -0.00332861f, -0.04262007f, 
    -0.15020289f, 0.07952213f, -0.21932353f, -0.05287554f, -0.05943159f, -0.02409309f, -0.02866695f, -0.07520858f, 
    -0.05105807f, 0.00254207f, 0.05664274f, -0.10704232f, 0.23130216f, -0.00034282f, -0.09500612f, -0.03712324f, 
    -0.06512375f, -0.01775852f, -0.08123682f, -0.06130769f, 0.00397857f, 0.00260958f, -0.00079091f, -0.08321617f, 
    -0.13334075f, -0.25886175f, -0.13137546f, 0.04513234f, -0.02346111f, -0.04916646f, 0.07687057f, -0.01624998f, 
    0.01252985f, -0.04089541f, 0.01090679f, 0.07170404f, -0.09901827f, 0.07886134f, 0.04656164f, 0.04392581f, 
    -0.07832439f, 0.01452373f, 0.04818797f, 0.09163400f, -0.07197637f, -0.06240801f, 0.00028772f, -0.03185420f, 
    0.08479367f, -0.02895152f, -0.02524402f, 0.11704808f, 0.03820444f, -0.01868092f, -0.06724497f, -0.03566197f, 
    0.02414769f, -0.01562193f, -0.02613886f, 0.01100437f, -0.13915713f, 0.11820582f, 0.00585746f, 0.21225345f, 
    0.00841671f, -0.09505709f, 0.05285128f, -0.03996844f, -0.07255357f, 0.07851221f, 0.10070141f, 0.00653463f, 
    0.06061951f, 0.04519004f, 0.07388857f, 0.15317178f, -0.01472842f, -0.02840357f, -0.02279304f, 0.02253156f, 
    0.00694801f, -0.01416994f, -0.04002986f, 0.01439583f, -0.05641143f, 0.05981766f, 0.01085098f, -0.12280717f, 
    -0.02497924f, 0.01902966f, 0.06548487f, 0.01588980f, -0.00473601f, 0.01803662f, -0.05371096f, -0.07785779f, 
    -0.04633939f, -0.01695447f, -0.00052048f, -0.13889696f, -0.04613095f, 0.00629913f, -0.04898159f, -0.04765645f, 
    -0.06657886f, -0.01063564f, -0.03208005f, -0.05910642f, 0.02579398f, 0.10074295f, 0.16573223f, 0.18299066f, 
    0.07857262f, 0.06059439f, -0.01688918f, -0.02840073f, 0.04069696f, 0.01898716f, -0.02375447f, -0.05700305f, 
    0.02685287f, -0.16328131f, 0.04979387f, -0.14655499f, -0.02231839f, -0.02061920f, -0.04058352f, -0.01768088f, 
    -0.02452568f, 0.04209631f, 0.01486145f, -0.06807166f, 0.26696011f, 0.01426066f, -0.00284390f, 0.21361673f, 
    0.20371409f, -0.05470999f, 0.03215837f, 0.04681805f, -0.03106459f, -0.02683263f, -0.10360003f, -0.02977641f, 
    -0.20556296f, 0.18853717f, -0.16303132f, -0.18994170f, -0.00789961f, -0.06188960f, -0.01869440f, -0.01541410f, 
    -0.07273536f, -0.05686433f, 0.03410633f, -0.09413487f, 0.04506020f, 0.16753373f, -0.12281308f, 0.14093848f, 
    -0.06195050f, -0.06249228f, -0.04289333f, 0.04629924f, -0.01377626f, 0.00903503f, -0.03481583f, 0.03734282f, 
    0.05003220f, 0.08157677f, 0.11603421f, 0.11044345f, 0.04140105f, 0.00253115f, 0.05574439f, 0.05491272f, 
    -0.04687459f, 0.00150111f, 0.04283700f, 0.02343821f, -0.09509204f, 0.26890892f, 0.17672206f, 0.11340740f, 
    0.12475514f, 0.03750064f, 0.07542101f, 0.00683016f, -0.04543830f, 0.00787202f, 0.02474832f, 0.01236570f, 
    0.13587725f, 0.18076703f, 0.05717374f, 0.06437885f, 0.03930333f, 0.04202315f, -0.06546748f, -0.02619570f, 
    -0.00367580f, 0.00135130f, -0.08599035f, -0.06606814f, -0.11960402f, 0.05790650f, 0.09182996f, 0.08424480f, 
    0.01485405f, 0.03451317f, 0.00035832f, -0.06337380f, 0.02119732f, -0.05898317f, -0.03999263f, -0.06024453f, 
    0.12590808f, 0.02795390f, 0.01644925f, 0.01813516f, -0.02679415f, 0.00504208f, -0.05367634f, 0.01527407f, 
    -0.00959247f, -0.01312369f, 0.01294459f, -0.03949610f, -0.27698734f, 0.08462332f, -0.07116375f, -0.17356813f, 
    -0.13137613f, -0.01427729f, 0.00270605f, 0.04008943f, 0.03765923f, -0.06006157f, 0.08944323f, -0.08761030f, 
    -0.20190069f, 0.04651238f, 0.02506985f, -0.04261535f, -0.02244260f, -0.08592486f, -0.11717762f, -0.03897800f, 
    -0.03646915f, -0.06132095f, 0.03169012f, -0.18073010f, 0.02347538f, -0.02729492f, -0.23796484f, 0.07398749f, 
    0.09504895f, 0.03081550f, 0.03902607f, -0.05447190f, -0.02804445f, -0.01003958f, 0.15999943f, 0.01506003f, 
    -0.09100351f, 0.05636436f, -0.13969651f, -0.04376519f, -0.00921882f, -0.10707805f, -0.08491801f, 0.03980459f, 
    0.01896277f, -0.07145149f, -0.05276432f, 0.04577819f, -0.12695874f, -0.02471562f, -0.04081342f, -0.16363448f, 
    0.09713664f, -0.00134810f, 0.00699855f, 0.02917427f, -0.03288658f, -0.02510514f, -0.05536073f, -0.04545916f, 
    0.27066046f, -0.11735965f, 0.03052510f, 0.02192554f, -0.02497173f, -0.02221255f, 0.02907368f, -0.09743267f, 
    -0.02565430f, -0.10097609f, -0.17110308f, -0.00482025f, -0.05628676f, 0.01642907f, -0.05190504f, -0.12403394f, 
    0.07193000f, 0.04822013f, -0.10707870f, -0.04110552f, -0.04507478f, -0.01728856f, 0.03177500f, 0.08021282f, 
    0.06977977f, 0.00432591f, 0.21814618f, 0.14665122f, -0.04847829f, -0.00209534f, -0.01000746f, -0.11848171f, 
    0.03826399f, 0.08146695f, 0.09934135f, -0.03790936f, 0.06433975f, 0.04754829f, -0.01648482f, 0.00462806f, 
    -0.06193801f, 0.02572018f, -0.07796178f, -0.00926283f, -0.04320058f, -0.03481542f, -0.10621474f, -0.14257392f, 
    -0.12651461f, -0.10956311f, -0.07770813f, -0.22913711f, -0.02658587f, -0.10464247f, -0.20715134f, 0.04559572f, 
    0.08288071f, 0.09100039f, -0.08350947f, -0.10548176f, 0.05279440f, -0.06776776f, 0.18985617f, 0.15397452f, 
    0.07485539f, 0.02188720f, -0.04822730f, -0.01047977f, -0.02530608f, -0.13400197f, 0.08913407f, -0.06468062f, 
    0.05414795f, -0.12746173f, -0.01290139f, -0.13512215f, -0.00503353f, -0.06764925f, 0.04603371f, -0.03031295f, 
    0.06283323f, 0.07439845f, -0.10581446f, 0.13324758f, 0.17121585f, 0.09400348f, -0.23683514f, 0.05936390f, 
    0.02321804f, -0.01241763f, -0.02196647f, -0.05444074f, -0.03127612f, -0.01803901f, -0.03511225f, 0.10593554f, 
    0.06452145f, -0.09585746f, -0.06300971f, 0.05691423f, 0.06809194f, -0.04408204f, -0.08008068f, -0.07699440f, 
    -0.03983088f, -0.01846405f, -0.11555643f, 0.02768915f, 0.07615055f, -0.00265453f, 0.10158773f, 0.13974321f, 
    -0.07237794f, -0.03393568f, -0.13017687f, -0.02956947f, -0.02716219f, -0.00990498f, 0.00092226f, 0.03224797f, 
    -0.04030149f, -0.05058322f, 0.05955532f, -0.15527716f, 0.02182532f, 0.00828620f, -0.15094991f, 0.07760309f, 
    -0.06276431f, 0.00587068f, 0.10526981f, 0.05234249f, -0.25026792f, -0.21104091f, -0.19741648f, -0.24516365f, 
    -0.07764141f, -0.06533437f, 0.10052399f, 0.04669547f, 0.05352958f, -0.00406980f, 0.07325841f, 0.01542702f, 
    0.05426519f, -0.10467855f, 0.15485612f, -0.08806119f, 0.04690874f, 0.01518450f, -0.11179937f, -0.05197781f, 
    0.03410973f, 0.04837761f, -0.00617345f, 0.07263988f, 0.12391673f, -0.02764775f, -0.18215266f, -0.08699823f, 
    0.05616571f, -0.10803939f, 0.00684318f, 0.01581266f, 0.00953712f, 0.01847652f, -0.07275077f, 0.08293528f, 
    -0.01730988f, 0.09842890f, 0.07669801f, 0.05282200f, -0.08392578f, -0.06573405f, 0.04489053f, 0.06121542f, 
    -0.03332242f, -0.03083662f, -0.15247828f, -0.07680336f, 0.15624931f, 0.17053948f, -0.21116929f, -0.09012420f, 
    0.06261789f, 0.07428786f, -0.08611586f, -0.04718300f, 0.08327992f, -0.00455697f, -0.03301911f, 0.10282082f, 
    -0.05810429f, -0.06497255f, -0.04488375f, 0.10690980f, 0.10273228f, 0.03164790f, -0.04528794f, 0.02450855f, 
    0.00647616f, 0.02102775f, 0.04915345f, -0.07954219f, -0.07135028f, 0.18318558f, -0.00573147f, 0.12647705f, 
    -0.03619332f, 0.04329222f, -0.10043218f, 0.04447367f, -0.12062087f, -0.02094544f, 0.07242323f, 0.04092286f, 
    0.06653628f, -0.17552644f, 0.05961929f, -0.10992604f, 0.10761736f, -0.12651007f, 0.09366005f, 0.02440120f, 
    -0.07900202f, 0.02830332f, 0.10999521f, 0.04698869f, 0.00886897f, 0.01786435f, 0.12624997f, 0.06980681f, 
    0.06581274f, 0.01569835f, 0.01033894f, -0.04953777f, 0.13043600f, 0.00784404f, 0.06932353f, -0.08235136f, 
    0.09882043f, -0.05627413f, 0.00419232f, 0.12763321f, 0.07558143f, 0.00617277f, -0.03415624f, -0.01953869f, 
    -0.03505024f, 0.02710248f, 0.05213641f, -0.03932866f, 0.09427069f, 0.28981864f, -0.16784886f, -0.01983201f, 
    -0.02197994f, 0.07385477f, -0.17940006f, -0.00914180f, 0.06545509f, 0.01570012f, -0.11259407f, -0.03471071f, 
    -0.05762623f, -0.14098200f, -0.08917411f, 0.08505927f, -0.00391323f, 0.10444096f, -0.17047369f, -0.00338367f, 
    0.12231760f, 0.09144486f, 0.03563151f, 0.06642941f, -0.12661049f, 0.10066862f, 0.03893318f, 0.03599849f, 
    -0.07520591f, 0.01200319f, 0.03399118f, 0.08024018f, -0.01262937f, 0.06690996f, -0.04629618f, 0.03988032f, 
    -0.04791451f, -0.15058629f, -0.02930599f, 0.15923241f, 0.09633936f, -0.01874153f, -0.08313981f, -0.01566157f, 
    -0.00271593f, 0.11245383f, 0.07863493f, -0.05856928f, 0.05517742f, 0.06333655f, 0.05410247f, 0.22966601f, 
    0.00407141f, -0.07957994f, -0.00316767f, 0.02754102f, 0.13981329f, 0.05198211f, -0.02249282f, -0.13821734f, 
    -0.02203847f, -0.04049474f, -0.04922724f, -0.04260048f, 0.08496048f, 0.06038452f, -0.07848600f, 0.01757717f, 
    0.00069154f, -0.00403031f, -0.02162771f, 0.09053259f, 0.11704276f, 0.24412513f, 0.02799761f, 0.08929861f, 
    -0.03769721f, -0.00704463f, -0.02798202f, -0.01743448f, -0.03798743f, -0.06269604f, -0.05760229f, -0.07593562f, 
    -0.25315589f, -0.11416283f, 0.22981831f, -0.16441540f, 0.01027640f, -0.00737678f, 0.12271911f, -0.17216024f, 
    -0.07979549f, -0.03087604f, 0.03821297f, -0.01509668f, -0.15129431f, -0.13014972f, -0.13872482f, -0.37566975f, 
    -0.01952302f, -0.02149953f, -0.09060750f, 0.01505708f, 0.03027962f, 0.03662203f, 0.05679908f, 0.00477815f, 
    -0.28820542f, 0.00808939f, -0.16751695f, -0.21741268f, 0.01120078f, 0.02949698f, -0.06099761f, 0.00726589f, 
    0.11040060f, -0.05874623f, -0.00501894f, 0.07193094f, -0.02183619f, -0.11526183f, 0.04850992f, 0.05356254f, 
    0.00434800f, -0.13096395f, 0.10781712f, -0.11513914f, 0.06484377f, 0.01352667f, -0.11538493f, -0.02508009f, 
    -0.14091679f, -0.01626197f, -0.16657290f, -0.04768538f, -0.05412211f, -0.06408083f, -0.02666673f, -0.07139388f, 
    0.05695346f, -0.01980442f, 0.06730380f, 0.04831466f, 0.15856090f, 0.02116395f, 0.10403673f, 0.24852620f, 
    0.04829061f, -0.02945567f, -0.01771083f, -0.06979817f, 0.05556600f, -0.01585538f, 0.08952570f, 0.00630439f, 
    -0.10254401f, 0.27187029f, -0.08998952f, -0.01308198f, 0.01155983f, 0.06153817f, -0.02436220f, 0.05338097f, 
    0.02803980f, -0.02886532f, 0.00832287f, 0.10706545f, 0.01786653f, 0.13046634f, -0.09550242f, 0.09834179f, 
    -0.05477227f, 0.09524137f, -0.18668923f, -0.03317844f, -0.08565659f, 0.06244243f, -0.09618738f, -0.06301415f, 
    0.03573585f, -0.16353813f, -0.09565886f, -0.13726451f, 0.02435430f, 0.06185224f, 0.07422916f, 0.08549243f, 
    0.00578563f, -0.10294294f, -0.02558547f, 0.00051419f, 0.03093265f, 0.04801187f, -0.08720621f, -0.02453111f, 
    -0.04691587f, 0.03851014f, 0.07543520f, -0.19864048f, -0.09406539f, -0.06459705f, 0.02885587f, 0.08944342f, 
    -0.11580762f, -0.08042849f, 0.08958604f, -0.06902045f, -0.03068567f, -0.12035049f, 0.05213078f, -0.04647747f, 
    0.00505354f, -0.11484470f, -0.02667506f, -0.02117889f, 0.21725678f, 0.20808853f, -0.19734295f, -0.13906971f, 
    0.03206338f, -0.12892582f, 0.03367716f, -0.00803533f, -0.03844680f, -0.03589731f, -0.03681162f, 0.08154973f, 
    -0.13525690f, -0.15080908f, 0.02914099f, 0.11698771f, 0.04219171f, 0.01438951f, -0.00476823f, 0.01214782f, 
    -0.01420975f, 0.11041606f, 0.03209518f, 0.04520186f, -0.01376849f, -0.00177270f, -0.08587404f, 0.01928259f, 
    0.03135926f, 0.02481142f, -0.00093370f, 0.00083292f, -0.02934409f, -0.00065341f, 0.04801443f, -0.05096104f, 
    0.17178713f, -0.16535148f, -0.20156769f, 0.09305352f, 0.00187558f, 0.04108400f, -0.00551311f, -0.02628462f, 
    -0.05923289f, -0.05890973f, 0.07877432f, 0.08315380f, -0.11445196f, 0.01793979f, -0.25274312f, -0.21995476f, 
    -0.04677745f, -0.00099050f, -0.10574810f, -0.00554794f, 0.10122133f, 0.09198040f, 0.08350585f, -0.09400479f, 
    0.13000725f, -0.08110655f, -0.09984659f, -0.18115403f, 0.07216752f, -0.02828617f, 0.08344566f, -0.04649117f, 
    -0.02450025f, 0.06634191f, -0.06465786f, 0.02895580f, -0.17331345f, -0.17674063f, -0.08172265f, 0.07048868f, 
    0.02887766f, -0.01260123f, -0.10981358f, -0.03457901f, 0.10269085f, 0.00999679f, -0.03040709f, -0.27961820f, 
    -0.06816030f, -0.03205888f, -0.19550790f, -0.17646213f, -0.01052718f, 0.02086841f, -0.03990794f, -0.12292539f, 
    0.01018114f, -0.08396161f, 0.05510553f, 0.01301934f, 0.18934517f, 0.02872765f, 0.02774443f, 0.06515424f, 
    0.03992094f, -0.02211357f, -0.05727566f, -0.07978134f, -0.05387933f, -0.08811380f, 0.03546966f, 0.19056360f, 
    0.22376636f, -0.02155630f, -0.01688255f, 0.09941705f, 0.12901500f, 0.03247442f, -0.01426130f, -0.05279817f, 
    0.00504620f, 0.02829580f, 0.01021031f, -0.00449657f, -0.06154679f, 0.22398560f, -0.03554364f, 0.20530838f, 
    -0.08598245f, -0.04822586f, -0.01566209f, 0.02618653f, -0.03193520f, 0.05597439f, 0.01034086f, 0.04764789f, 
    -0.03747185f, -0.15860271f, 0.10389967f, 0.11608412f, -0.02194180f, -0.03204753f, -0.02266735f, 0.03714668f, 
    0.05843667f, 0.07630403f, 0.07110850f, 0.00483704f, 0.22042221f, 0.02213420f, -0.13503757f, -0.10806631f, 
    -0.03980508f, -0.04700245f, 0.11392873f, 0.04400761f, -0.00997745f, -0.02550898f, 0.11979543f, 0.02596950f, 
    -0.04396690f, 0.02783574f, -0.05016936f, 0.01821220f, 0.07279108f, -0.09463611f, 0.00014435f, -0.11679994f, 
    -0.04253120f, 0.11075637f, -0.00830642f, 0.01582873f, -0.13974345f, 0.24444623f, -0.02623102f, -0.13472168f, 
    -0.00412913f, 0.09683625f, -0.09092114f, 0.00233039f, 0.10813751f, 0.07075757f, 0.09106433f, 0.07471143f, 
    0.18738183f, -0.29415846f, -0.05578786f, -0.08725232f, -0.01413049f, -0.03748447f, -0.06952035f, -0.07123671f, 
    0.13856609f, 0.02371410f, -0.02782164f, 0.02173428f, -0.04240254f, -0.15889160f, 0.13418823f, 0.06364521f, 
    -0.10563514f, 0.00772251f, 0.00533150f, -0.01058799f, 0.05255563f, -0.18476805f, -0.05385391f, -0.07923956f, 
    -0.22459777f, 0.19273905f, -0.04243460f, -0.15293744f, -0.06108313f, 0.02395660f, -0.19431888f, 0.04341164f, 
    0.07834513f, 0.02426066f, 0.06663391f, -0.03183895f, -0.23433585f, 0.10375301f, 0.08419004f, -0.05320375f, 
    0.06456603f, -0.05176565f, -0.04641572f, -0.01326533f, -0.03001419f, 0.06058041f, 0.05203658f, 0.04812672f, 
    0.18120882f, 0.02361877f, -0.05194964f, 0.08209877f, -0.03180006f, -0.14246193f, -0.05101921f, -0.03630278f, 
    -0.11747446f, -0.05890826f, -0.08362605f, -0.10601041f, 0.11752456f, -0.16894045f, -0.11020329f, 0.09401735f, 
    0.06085815f, -0.08561449f, -0.06026094f, -0.00706507f, -0.05772800f, 0.08091443f, 0.00908739f, -0.00647715f, 
    0.05984214f, -0.12712269f, -0.02941336f, 0.04287874f, 0.12084612f, 0.01281774f, -0.14593536f, 0.09568536f, 
    0.01097528f, 0.00594665f, 0.05435612f, 0.12794714f, -0.27730244f, 0.22039382f, -0.06702661f, -0.26130551f, 
    0.01380011f, -0.05223730f, 0.06475204f, -0.01848780f, -0.02653656f, 0.08529177f, -0.10145220f, -0.03124642f, 
    -0.25338918f, -0.07919466f, -0.05891835f, 0.00286918f, -0.04786984f, -0.13366604f, 0.02967253f, 0.12247222f, 
    0.08974562f, 0.05604439f, 0.21507002f, -0.10968135f, 0.21757977f, -0.08419199f, 0.09902232f, -0.01392125f, 
    -0.08336197f, -0.09674045f, -0.07939276f, 0.03230029f, -0.05796634f, 0.14744160f, -0.02953933f, 0.09233832f, 
    0.14658655f, -0.15975328f, -0.32369047f, 0.08221775f, 0.07358128f, -0.10257363f, 0.03111927f, 0.03160786f, 
    0.00885669f, 0.14187433f, 0.07870891f, 0.04221642f, 0.10577258f, -0.41345167f, -0.05671468f, -0.09072591f, 
    -0.11494087f, -0.07299457f, -0.09108890f, 0.09127083f, -0.09942876f, 0.14915638f, 0.06988808f, 0.12064698f, 
    0.22187711f, 0.02872421f, -0.08977410f, -0.16838917f, 0.16208415f, -0.11131024f, 0.05055985f, 0.05336531f, 
    -0.06436083f, -0.03012168f, -0.09090100f, 0.06744383f, -0.02418543f, 0.02199157f, 0.07534149f, -0.00746593f, 
    0.01264135f, 0.00976169f, 0.08745650f, 0.19837669f, -0.00410183f, 0.03995174f, 0.03653310f, 0.07000628f, 
    -0.27722919f, -0.05716695f, 0.04084847f, 0.17589037f, -0.02398750f, -0.06918494f, 0.06729040f, 0.07199983f, 
    0.01198596f, -0.03677244f, 0.04532636f, -0.06160527f, -0.16957259f, 0.17494500f, 0.05298886f, -0.32803500f, 
    0.07634497f, -0.08288129f, -0.16709946f, -0.03888471f, 0.08881569f, 0.06472652f, 0.04177029f, -0.08745211f, 
    -0.03157006f, 0.00273326f, 0.03703586f, 0.00259701f, 0.00000423f, 0.01494763f, 0.01202760f, -0.07845765f, 
    0.01874029f, -0.13807447f, 0.10880329f, -0.04668878f, 0.27623087f, -0.32856411f, 0.22963880f, -0.06161036f, 
    0.01773036f, 0.11359483f, -0.16427185f, 0.02281145f, -0.10215972f, -0.01005698f, 0.07667530f, 0.03794510f, 
    0.02584813f, -0.11122912f, 0.08134288f, -0.08067647f, -0.02721218f, -0.10263077f, 0.03240860f, -0.17832187f, 
    0.14942610f, 0.07256735f, 0.02307198f, 0.05671449f, 0.07806627f, -0.36062047f, 0.13479276f, -0.10572799f, 
    0.11768376f, -0.05720850f, -0.00318693f, -0.02071026f, 0.00081284f, -0.10192773f, 0.17484117f, 0.06983235f, 
    0.14978199f, -0.22204819f, -0.11987974f, 0.05033753f, -0.06849276f, 0.00638957f, 0.06779791f, -0.09720853f, 
    -0.08746444f, 0.18300466f, -0.22326694f, 0.05244245f, -0.02110991f, -0.06332291f, 0.06861248f, -0.10022295f, 
    -0.08234147f, 0.05874182f, 0.02393186f, 0.03710156f, -0.00315356f, 0.11368172f, -0.01866947f, -0.21391511f, 
    0.16354123f, -0.29234153f, 0.00962015f, 0.03560507f, 0.10911272f, -0.00537746f, 0.00492345f, -0.04692560f, 
    -0.01983622f, -0.03674125f, 0.09998488f, -0.08854605f, -0.18842462f, 0.23851207f, 0.13672867f, 0.11426745f, 
    0.02178829f, 0.15165013f, 0.14437707f, -0.02409970f, 0.05177699f, -0.10497599f, 0.04194430f, -0.11764287f, 
    -0.59174943f, 0.28681919f, -0.29536667f, 0.09556454f, 0.10293332f, -0.00425211f, -0.07006718f, -0.00118938f, 
    -0.11089303f, 0.05675404f, 0.11793105f, 0.05961755f, 0.48077166f, -0.02230545f, 0.28412831f, -0.10891952f, 
    0.01275773f, 0.06804144f, 0.13923328f, -0.07784807f, -0.05395668f, -0.02135246f, -0.04717314f, 0.00502420f, 
    0.03544563f, -0.18183352f, 0.07179686f, -0.13964927f, -0.07409639f, 0.01149998f, -0.03527797f, -0.03261827f, 
    -0.02034866f, -0.11960381f, -0.04931291f, -0.00398881f, -0.15004726f, -0.23180449f, 0.20766161f, -0.23320511f, 
    -0.08301241f, -0.04192894f, 0.11224642f, 0.04197261f, -0.01649458f, -0.00815505f, -0.08947070f, 0.18451568f, 
    -0.01360154f, 0.11661812f, 0.00078155f, -0.10887260f, 0.00744827f, -0.01141652f, -0.08065096f, -0.07164155f, 
    -0.03459265f, 0.02361234f, -0.05782915f, 0.00760312f, -0.00285647f, 0.05622914f, -0.12153523f, -0.20373614f, 
    0.10296991f, 0.06973615f, -0.01468092f, -0.02304042f, -0.16794743f, -0.05016006f, -0.09923227f, -0.12462820f, 
    -0.06382456f, -0.06681699f, 0.01746833f, 0.03534243f, 0.03242944f, 0.02141293f, -0.01096351f, -0.08380208f, 
    0.08719409f, 0.03791585f, 0.00991944f, 0.03607969f, -0.22727127f, 0.29803407f, 0.23451434f, 0.11978862f, 
    0.08813193f, 0.02544127f, -0.04210660f, 0.05758661f, 0.10651106f, 0.12348405f, -0.00265506f, 0.06679264f, 
    -0.21511507f, 0.12007088f, 0.04765221f, -0.07640119f, 0.08059528f, 0.04084219f, -0.13257362f, 0.00834887f, 
    -0.13231137f, -0.01261394f, -0.04118705f, -0.02609911f, -0.03800828f, 0.35052940f, -0.15147778f, 0.13543034f, 
    -0.00478531f, -0.12583870f, -0.05194261f, -0.06410050f, 0.08213515f, -0.02096250f, 0.01592565f, 0.08784925f, 
    -0.07281568f, 0.05253896f, -0.05850200f, -0.36197084f, 0.00873575f, 0.08352327f, -0.06283095f, 0.04170796f, 
    -0.00624829f, -0.09883887f, -0.01236140f, -0.06740141f, 0.00813057f, 0.25768134f, -0.13534757f, 0.03722445f, 
    0.03392742f, -0.00107951f, 0.00087934f, -0.02912732f, -0.00625781f, -0.00350733f, 0.00767165f, -0.12500013f, 
    -0.00790863f, -0.04984989f, 0.04104808f, -0.07402623f, 0.05127682f, -0.03916141f, -0.01786843f, -0.10168508f, 
    -0.16090235f, -0.03089293f, -0.10622741f, -0.23236246f, -0.22203466f, 0.21449758f, 0.08384010f, 0.07369754f, 
    0.12886886f, 0.04769970f, -0.00547340f, -0.01142078f, 0.04121294f, 0.02910121f, 0.05367721f, -0.00335329f, 
    0.02977185f, -0.18618838f, -0.02878878f, 0.25338241f, 0.04069840f, -0.08483826f, -0.06358422f, 0.08541744f, 
    0.07711761f, -0.06901826f, -0.03164208f, -0.04751168f, 0.07020322f, -0.06882057f, -0.14347814f, -0.17648554f, 
    0.07942959f, 0.00651056f, -0.00690082f, -0.11381073f, 0.07642759f, 0.03043852f, -0.05465240f, 0.04734110f, 
    0.07581222f, -0.04743652f, -0.04563683f, -0.01212204f, -0.04185335f, 0.06528862f, -0.11888607f, 0.02982255f, 
    -0.07508456f, 0.02858701f, -0.03265111f, 0.01122970f, 0.16704485f, -0.14929676f, -0.01150039f, 0.08399689f, 
    0.04866663f, 0.05126790f, 0.01084106f, 0.00854134f, -0.02343937f, -0.02917943f, 0.01666110f, 0.02885724f, 
    0.10367325f, -0.28236857f, -0.07218681f, -0.13427390f, -0.09181458f, 0.02369887f, -0.09948910f, 0.08036445f, 
    0.02250447f, -0.00963539f, 0.12051772f, -0.10869114f, -0.47607762f, 0.27320835f, -0.30201644f, -0.18697849f, 
    0.21041234f, -0.02532918f, -0.00682841f, -0.00933679f, -0.00205838f, 0.06736737f, -0.06985690f, -0.05567386f, 
    0.05117312f, -0.03601927f, 0.34937030f, 0.07679705f, 0.09264793f, 0.06705653f, -0.01767187f, 0.12176065f, 
    0.09168326f, -0.14180042f, 0.12815042f, 0.01162635f, -0.04030305f, 0.03873793f, 0.21282007f, 0.00800121f, 
    0.10624083f, 0.11111341f, 0.14757833f, 0.09179531f, 0.03954548f, -0.08872242f, -0.13539504f, -0.20049708f, 
    0.00098949f, -0.01811947f, 0.07473403f, -0.04600696f, -0.00498894f, 0.04103797f, -0.14471488f, 0.01558983f, 
    -0.10205462f, -0.04016571f, 0.00883540f, 0.10262741f, -0.05925261f, -0.11763685f, 0.10571247f, 0.07910016f, 
    0.10925936f, 0.05358583f, -0.15314193f, -0.03548590f, -0.16058849f, 0.01953614f, 0.14352465f, -0.01438200f, 
    0.07258394f, -0.02100082f, 0.07719523f, 0.03988889f, -0.13013317f, 0.00633737f, -0.00844927f, 0.00121711f, 
    -0.01937581f, 0.12274531f, 0.08981642f, -0.03659407f, 0.10908505f, 0.03139127f, 0.27198878f, -0.17267813f, 
    -0.00155369f, -0.04852690f, -0.03199911f, -0.05870598f, 0.01064463f, 0.01655927f, 0.07550339f, 0.04647870f, 
    -0.18283212f, 0.11867104f, 0.10572296f, -0.27725095f, -0.01995042f, -0.05177293f, -0.02949910f, -0.06769269f, 
    -0.03034200f, -0.01371325f, -0.02070811f, -0.04771065f, 0.12808087f, 0.02697350f, 0.04759710f, 0.11067708f, 
    -0.08516733f, -0.01208405f, -0.05268827f, 0.15354986f, 0.07148891f, 0.01419309f, 0.01816834f, -0.10007458f, 
    -0.10582466f, 0.16116120f, 0.09386306f, -0.22003037f, 0.07615786f, 0.02425766f, -0.11242278f, 0.10060916f, 
    -0.03358755f, 0.00526129f, -0.01318239f, -0.02179121f, -0.22985956f, 0.02008066f, 0.01711517f, 0.02483632f, 
    -0.05619399f, 0.04249544f, 0.14125711f, -0.01591872f, 0.14753151f, -0.02409488f, -0.11492307f, 0.05798682f, 
    0.17617056f, 0.08489592f, -0.07924920f, -0.22833981f, 0.04939143f, -0.06706970f, 0.06395407f, -0.10575099f, 
    0.01690557f, 0.06767970f, 0.10169059f, 0.01347808f, -0.07798862f, -0.07794335f, -0.16411024f, -0.24684885f, 
    -0.01121618f, -0.03275430f, -0.00230382f, 0.09051643f, -0.02689845f, -0.07908631f, 0.04792348f, 0.04696413f, 
    -0.06055886f, -0.10548346f, 0.01756851f, 0.09331865f, 0.05091469f, -0.07566795f, 0.04863576f, 0.07680160f, 
    -0.05899604f, -0.07598483f, -0.03886088f, 0.00127460f, 0.06426955f, 0.03154403f, -0.07124696f, 0.12078815f, 
    -0.01230638f, -0.04089830f, -0.05349274f, -0.04095332f, 0.05371923f, 0.06517696f, -0.09010059f, 0.06575058f, 
    0.03695659f, -0.02566038f, -0.11866637f, -0.08759177f, 0.05840953f, 0.08335229f, -0.05759487f, -0.09347712f, 
    0.08993222f, -0.12913683f, 0.00662920f, -0.03530640f, 0.08683117f, -0.32387272f, -0.08529219f, -0.01617914f, 
    0.02093731f, 0.01307950f, -0.12234617f, 0.13821809f, -0.11886929f, -0.02480269f, -0.00240185f, -0.02061523f, 
    0.25624204f, -0.01122458f, -0.07884011f, 0.02360379f, -0.08126530f, -0.07318361f, -0.08065918f, 0.00400191f, 
    0.10242023f, -0.02876885f, 0.07708398f, 0.01891132f, -0.09347235f, -0.05491260f, 0.23422442f, -0.14768741f, 
    0.00328000f, 0.02830601f, 0.00739671f, 0.11678824f, 0.01422169f, -0.04412468f, -0.02494730f, 0.01132660f, 
    -0.38356045f, 0.09315141f, -0.02998314f, -0.14602974f, -0.00796381f, -0.11169170f, 0.05846111f, -0.03522016f, 
    0.09384768f, -0.12022347f, 0.17042907f, 0.08604791f, -0.17553760f, 0.26615673f, 0.13310701f, -0.10685825f, 
    -0.06130375f, 0.01557624f, -0.01928982f, -0.01158419f, 0.06333002f, -0.05423434f, -0.01637112f, -0.07803135f, 
    -0.15461653f, -0.16492303f, 0.01154283f, 0.19797051f, -0.05725686f, 0.03010285f, 0.01338513f, -0.04540797f, 
    0.03652089f, -0.06042830f, 0.12995294f, 0.05893261f, -0.00856518f, -0.32628283f, -0.07194478f, -0.01940336f, 
    0.09977785f, -0.04426197f, -0.05890699f, 0.02524216f, -0.02878922f, 0.05386231f, -0.10616407f, 0.09451697f, 
    -0.24999966f, 0.01174998f, 0.12996149f, 0.04042998f, 0.02671697f, -0.00452334f, 0.00019768f, 0.00898666f, 
    0.02422902f, -0.01924186f, -0.08726064f, -0.04604538f, -0.18737690f, -0.41172495f, 0.11278532f, 0.04747228f, 
    -0.04287413f, 0.09856033f, -0.09566629f, -0.08553825f, -0.01217632f, 0.05533710f, -0.05425508f, -0.09921629f, 
    0.17374700f, -0.03408246f, 0.00160393f, -0.18040602f, 0.13670409f, 0.16294229f, -0.00990182f, -0.16891158f, 
    0.04330615f, 0.04980914f, -0.01010909f, 0.09811934f, -0.52989411f, 0.12231044f, 0.15545967f, -0.06341605f, 
    0.04498285f, 0.05297795f, 0.11551933f, 0.05434875f, -0.00119367f, -0.05945568f, 0.04043226f, 0.03017881f, 
    0.14465114f, 0.04043958f, 0.01876816f, 0.06476709f, -0.06849343f, -0.05475250f, 0.04207650f, -0.00518012f, 
    0.11737425f, -0.02755206f, 0.06061725f, -0.13302936f, 0.04857909f, -0.20392977f, -0.05314600f, -0.14657167f, 
    0.06436297f, 0.00847319f, 0.04229701f, -0.01665340f, 0.13306366f, 0.04241644f, -0.01842708f, -0.00967407f, 
    0.06690025f, -0.04827495f, -0.06659412f, -0.04689654f, -0.00299861f, -0.03958527f, -0.06360220f, 0.04059400f, 
    0.10509268f, -0.05055566f, -0.00842435f, 0.00259017f, 0.02503350f, 0.09583736f, 0.12460853f, 0.06966256f, 
    0.05360023f, 0.03476278f, -0.03682310f, -0.03312382f, -0.08915702f, 0.00669633f, -0.09394501f, 0.04640283f, 
    0.27203354f, 0.13252354f, -0.11606354f, 0.00003312f, -0.05272879f, 0.06015632f, -0.12117775f, 0.09002828f, 
    0.03418963f, -0.03148752f, -0.12554137f, -0.02435631f, 0.08478127f, 0.05047660f, -0.11181086f, -0.02288266f, 
    0.11426669f, 0.06885572f, 0.03551213f, -0.05897804f, 0.13736166f, 0.10015101f, -0.02220985f, -0.02820183f, 
    -0.44488904f, -0.31575483f, 0.09450167f, -0.22683749f, -0.06707236f, 0.11498730f, 0.05237858f, -0.01812535f, 
    0.03691427f, 0.08366322f, -0.00548684f, 0.07005505f, 0.01243331f, -0.02964015f, -0.08850025f, -0.01715688f, 
    -0.01177188f, 0.07114049f, 0.02564245f, -0.06833035f, 0.03799033f, -0.07572945f, -0.07122655f, -0.09310793f, 
    0.00662462f, -0.08629317f, 0.10219918f, 0.06397807f, -0.04087636f, 0.03371585f, 0.00712988f, 0.04689360f, 
    0.01462669f, 0.05762708f, -0.06962032f, 0.06519265f, -0.29683641f, -0.26706126f, 0.02272967f, 0.04431510f, 
    0.01504776f, 0.00166246f, -0.09273799f, -0.02943883f, -0.01422028f, 0.01782872f, 0.08637243f, 0.04697601f, 
    -0.03123648f, 0.16828425f, 0.06259686f, 0.03059901f, 0.04570055f, 0.05528041f, 0.09911432f, 0.04639091f, 
    0.07879783f, 0.06326812f, 0.00368691f, 0.02888887f, -0.42426163f, -0.11082726f, -0.03452661f, -0.08314668f, 
    0.05731404f, -0.00071323f, -0.03086809f, -0.02968021f, -0.01738254f, 0.02196586f, -0.06971305f, 0.08988483f, 
    -0.24255125f, -0.00323226f, -0.19345681f, -0.08404221f, -0.03847928f, -0.00271713f, -0.01882818f, 0.00076959f, 
    0.00690952f, -0.15778168f, -0.27059934f, -0.08162435f, 0.08924210f, 0.03327078f, -0.12699725f, -0.03995176f, 
    0.03234875f, -0.08472057f, -0.11319420f, 0.04548624f, -0.02423579f, 0.07490417f, -0.05618158f, 0.04205946f, 
    0.06697029f, 0.04828031f, 0.01475833f, -0.14926168f, -0.01216456f, 0.15610975f, -0.04726619f, 0.03415043f, 
    -0.08098616f, 0.04657511f, 0.17408043f, -0.04743109f, 0.35767713f, 0.15581769f, 0.05127604f, -0.04372114f, 
    0.02059902f, -0.00164191f, 0.07413439f, 0.05040865f, -0.08750136f, -0.01882683f, 0.06850389f, -0.01669293f, 
    0.00147153f, 0.05107034f, 0.03923947f, -0.15008824f, 0.04268942f, 0.03641440f, -0.00500428f, 0.06333526f, 
    -0.04556388f, 0.00503753f, 0.04271784f, 0.04170065f, -0.09303849f, 0.09969517f, 0.12136523f, 0.12688094f, 
    0.10814445f, -0.00279146f, 0.04554817f, 0.01814489f, -0.01047978f, 0.07591939f, 0.05938936f, 0.19321860f, 
    -0.15031309f, -0.28157765f, -0.18878959f, 0.05274427f, -0.05785179f, -0.08744330f, 0.09488028f, 0.03010106f, 
    0.05567928f, -0.06174028f, -0.09952483f, 0.00787254f, -0.42493281f, -0.09205571f, 0.13252762f, 0.07156502f, 
    0.16128853f, -0.00595001f, -0.02344542f, -0.03053159f, 0.04905855f, 0.00314033f, 0.03072096f, 0.11931814f, 
    -0.22942430f, 0.06533729f, -0.07521480f, -0.20822062f, 0.14550552f, 0.03238846f, 0.01260584f, 0.04925897f, 
    0.04973659f, 0.03959981f, 0.04585757f, 0.07026060f, 0.09082112f, -0.00608367f, -0.06565007f, 0.04673614f, 
    -0.05803295f, -0.00835941f, -0.03117415f, -0.10111219f, -0.14367139f, -0.01031924f, 0.04131834f, 0.00995868f, 
    0.00631031f, 0.10898796f, 0.04171525f, -0.06161303f, 0.03921590f, -0.01385117f, -0.01230014f, -0.10402190f, 
    0.02485571f, 0.09338352f, 0.07037264f, 0.15636063f, -0.43406960f, -0.08597662f, 0.01907028f, -0.13770482f, 
    0.08504444f, -0.02247496f, 0.01539662f, -0.08420265f, -0.04388119f, 0.10313583f, 0.03918751f, -0.00075167f, 
    -0.32272533f, -0.10673698f, -0.20280357f, -0.32073236f, 0.06447204f, 0.06658776f, -0.13498768f, -0.09363893f, 
    -0.00884586f, -0.09115189f, 0.01223312f, 0.07652257f, -0.06798197f, -0.08010504f, -0.06299041f, -0.00829315f, 
    -0.07381180f, 0.01974778f, -0.01951575f, -0.02904454f, 0.11024185f, -0.18567146f, -0.00581199f, -0.15891068f, 
    -0.48156783f, -0.43651217f, 0.10685453f, 0.08466321f, 0.04522394f, 0.08484248f, -0.10697389f, -0.07760300f, 
    -0.01112032f, 0.07188103f, -0.03668610f, 0.07432689f, 0.01916111f, -0.02224190f, 0.02881190f, 0.04990322f, 
    0.03947300f, -0.01461893f, 0.05508641f, 0.06093711f, 0.10606403f, 0.10916263f, 0.04932762f, 0.05795103f, 
    -0.36206859f, -0.19556713f, -0.02348682f, -0.27985179f, 0.09671623f, -0.08049215f, -0.07852774f, 0.00326393f, 
    0.06731687f, 0.05675826f, 0.02820395f, -0.06351413f, 0.15587957f, 0.07177497f, 0.04795618f, 0.00215500f, 
    -0.03543752f, -0.11188642f, 0.01196520f, 0.09906542f, 0.04721660f, 0.02310366f, -0.02034201f, -0.00187722f, 
    -0.27220139f, 0.02498225f, 0.06031412f, 0.11470126f, 0.08128474f, -0.04924526f, 0.04091217f, 0.02632650f, 
    0.03117993f, 0.10250705f, 0.08215632f, 0.14788745f, 0.14163420f, 0.04366699f, -0.06557653f, -0.12261309f, 
    -0.11551973f, -0.06498504f, 0.08475871f, -0.08218047f, 0.07368681f, 0.01090998f, -0.01236184f, 0.01334335f, 
    0.23480998f, 0.04340556f, -0.01488317f, 0.03029884f, -0.18276097f, -0.12647517f, 0.06363798f, -0.03144674f, 
    0.00705307f, -0.01814379f, -0.10909416f, -0.08186347f, 0.22203414f, 0.12959313f, 0.13419802f, 0.01471249f, 
    0.09734654f, 0.06378002f, 0.03621589f, 0.01652621f, -0.03789948f, 0.09378681f, -0.06933795f, 0.02139877f, 
    -0.10123880f, 0.01470858f, 0.20434038f, 0.03169680f, 0.01558433f, 0.02461529f, 0.00656129f, 0.07893138f, 
    -0.11481973f, -0.04034144f, 0.08208576f, 0.10382002f, 0.05077670f, -0.02802551f, -0.07619241f, 0.05903257f, 
    0.00051566f, 0.03760592f, -0.16928668f, -0.04843489f, -0.07673610f, -0.03237689f, 0.02706288f, 0.07419819f, 
    0.03949841f, 0.16653162f, 0.03627143f, -0.07088030f, 0.04968604f, 0.04054009f, 0.05820346f, 0.01179576f, 
    0.09467572f, -0.04234431f, 0.00199381f, 0.15224986f, -0.45354164f, -0.33054683f, -0.18400542f, -0.33618474f, 
    0.09064359f, -0.06281292f, -0.14351830f, -0.12694854f, 0.03511325f, -0.11275520f, 0.06380156f, -0.16246080f, 
    -0.09181413f, -0.26108694f, 0.15211679f, -0.00510216f, 0.04391038f, 0.03592740f, 0.00590080f, -0.00633606f, 
    0.09721631f, 0.07438630f, 0.07333139f, 0.09629985f, 0.05446925f, -0.12017868f, -0.00060633f, -0.02842726f, 
    -0.02058540f, -0.00850494f, 0.09456934f, -0.09344557f, -0.00005906f, 0.11359753f, -0.10353266f, 0.12317744f, 
    -0.20785524f, 0.02517278f, 0.11297778f, 0.03555344f, 0.04727443f, 0.09427871f, -0.00425906f, 0.05121927f, 
    0.04032821f, 0.04435080f, -0.07551727f, -0.06669907f, -0.07236499f, -0.06303757f, -0.04818257f, -0.03925151f, 
    -0.12553795f, 0.10624629f, 0.04534803f, -0.08785579f, 0.12263276f, -0.04035426f, 0.03559878f, 0.00559117f, 
    0.17647712f, 0.03011159f, -0.07934555f, -0.03457444f, 0.05115785f, 0.00772669f, 0.05092136f, 0.02893181f, 
    0.03474320f, -0.08591963f, 0.00924763f, -0.06224013f, -0.19987318f, 0.01845239f, -0.01276827f, -0.04624742f, 
    0.11675068f, -0.03451067f, 0.03407332f, 0.01588325f, 0.00252242f, 0.14063893f, -0.03175826f, 0.03324375f, 
    -0.03997233f, -0.11232387f, 0.04981948f, -0.08704850f, 0.04728496f, -0.22531191f, 0.01041539f, -0.00645362f, 
    0.02604164f, 0.09936430f, 0.10422926f, 0.06063653f, -0.42846832f, -0.36715570f, 0.02071286f, -0.14417392f, 
    0.08310741f, 0.06032334f, 0.04477784f, 0.00655272f, 0.02098104f, -0.13305998f, -0.04430807f, 0.00886371f, 
    -0.57843524f, -0.23520827f, -0.09604873f, -0.19286296f, 0.01573924f, -0.05704878f, -0.01309573f, -0.04770907f, 
    0.05168054f, -0.00990689f, 0.15907721f, -0.00743688f, -0.12382051f, -0.28612235f, -0.06821385f, 0.09040552f, 
    0.15316062f, 0.07933605f, -0.03018528f, -0.06311338f, -0.04460825f, 0.02041318f, -0.06724596f, -0.00043005f, 
    -0.20760995f, 0.05720850f, 0.07621165f, 0.22191232f, 0.12634231f, -0.03342604f, 0.00028187f, 0.01823378f, 
    0.02236424f, -0.01655539f, -0.01569707f, 0.04669825f, -0.09110240f, 0.17351680f, -0.12502417f, -0.08267900f, 
    0.22254367f, -0.05870508f, -0.09664655f, -0.08596669f, 0.10147323f, -0.08259754f, -0.12195449f, -0.23745763f, 
    0.03587470f, -0.00100265f, 0.00062027f, 0.04411115f, -0.06460036f, 0.10583182f, -0.00976290f, -0.09275775f, 
    0.04194822f, 0.07085188f, -0.03064781f, -0.00648917f, -0.30065075f, -0.15235724f, 0.06940524f, 0.02138426f, 
    0.05089372f, -0.00804220f, -0.08544042f, -0.06294053f, 0.06551126f, -0.09144041f, 0.00276151f, 0.07657264f, 
    -0.22732545f, -0.16354817f, -0.09464622f, -0.05490467f, 0.04242497f, 0.06051966f, 0.08677576f, -0.00823351f, 
    0.14705838f, 0.13953052f, 0.07004392f, 0.05318246f, 0.11744326f, 0.02749845f, 0.01393352f, 0.02586943f, 
    -0.04915032f, -0.05885943f, 0.00189161f, -0.00109721f, 0.02121220f, 0.02655124f, 0.07388462f, 0.05051882f, 
    0.11606643f, -0.13786453f, -0.13008828f, 0.05758567f, -0.01359194f, -0.06439418f, 0.01916949f, 0.06243416f, 
    -0.02955177f, 0.11671438f, 0.01663038f, 0.00745946f, -0.23325075f, 0.13263398f, -0.15257412f, 0.19409350f, 
    0.02809243f, -0.04001512f, -0.10520662f, -0.11277787f, -0.09357798f, -0.10851403f, 0.07226644f, -0.07921826f, 
    -0.20154722f, -0.24183488f, -0.18603088f, 0.08146664f, 0.00675115f, 0.03302838f, 0.05005886f, 0.00653031f, 
    0.08532489f, 0.03794061f, -0.04602155f, 0.11311655f, 0.08155642f, 0.02489702f, -0.03506599f, 0.00974879f, 
    0.06597919f, 0.11769030f, 0.04740055f, 0.07821280f, 0.09297626f, 0.02927787f, -0.01512094f, 0.04944050f, 
    -0.03372329f, 0.07847232f, -0.13357754f, 0.02173862f, 0.01948381f, 0.05632399f, 0.03504426f, 0.03387814f, 
    -0.00729230f, 0.05584290f, -0.03729043f, -0.03253466f, 0.19979744f, 0.10472610f, -0.07112245f, 0.01466508f, 
    -0.05823921f, -0.10551132f, -0.01210476f, -0.08056649f, -0.02371747f, 0.01148216f, 0.06268746f, -0.06216919f, 
    0.05517001f, -0.06418304f, 0.11553969f, -0.07253386f, 0.09112745f, 0.01543142f, 0.00326602f, -0.01566379f, 
    -0.04573731f, -0.03184586f, 0.12637916f, 0.03109021f, 0.30823600f, 0.05159859f, -0.10737815f, -0.00150334f, 
    0.01817839f, -0.06400458f, -0.06417482f, 0.05614554f, -0.03239350f, 0.09262896f, -0.10357956f, 0.07692079f, 
    -0.07747408f, 0.14272976f, -0.08911225f, 0.04042339f, 0.02692501f, -0.11232232f, -0.10920996f, -0.02114302f, 
    -0.01603936f, -0.01253980f, -0.05614135f, -0.04595491f, -0.42924240f, -0.33720592f, 0.06719128f, 0.18389998f, 
    0.03880684f, 0.02300108f, 0.00850808f, 0.12995540f, 0.10600846f, 0.10309123f, -0.11844002f, 0.18410751f, 
    0.03334295f, 0.05674879f, -0.03151619f, 0.07870765f, -0.03362352f, -0.03443825f, 0.00894521f, -0.11576180f, 
    -0.04026381f, 0.04057411f, -0.01219507f, -0.00606936f, 0.35137716f, -0.02192952f, -0.29642594f, 0.04684588f, 
    0.13046344f, -0.09897401f, 0.03564668f, 0.06400487f, -0.01772150f, -0.02839946f, 0.03747547f, 0.05124340f, 
    -0.02265274f, -0.01031981f, 0.01186214f, 0.20536508f, 0.02033267f, 0.14929727f, -0.00495988f, -0.00011923f, 
    -0.02537367f, 0.00289273f, -0.07815056f, 0.01566688f, 0.20733738f, 0.13118416f, 0.02869134f, -0.15434717f, 
    -0.03553553f, -0.01730784f, -0.00745859f, -0.10178726f, 0.00299822f, 0.02764752f, 0.02945153f, 0.05687620f, 
    -0.50087333f, -0.02351734f, -0.13306209f, 0.09071557f, -0.01766099f, -0.00871789f, 0.09973361f, 0.02926447f, 
    -0.03525874f, -0.02102604f, 0.01134350f, -0.10883741f, -0.14506105f, 0.09364931f, 0.09395095f, 0.14769985f, 
    0.07181378f, 0.03935197f, -0.09537093f, 0.08909877f, -0.03820257f, -0.09394472f, -0.06225797f, -0.03918926f, 
    -0.17581218f, -0.26683939f, 0.05846869f, -0.19481251f, 0.04928138f, -0.05683585f, 0.01890045f, 0.05276103f, 
    -0.03342030f, -0.00626129f, -0.07483985f, -0.03413095f, -0.19011506f, -0.03625661f, -0.13493034f, 0.01617849f, 
    0.03186466f, -0.01741802f, -0.01628277f, 0.06291788f, -0.03498130f, -0.00321373f, 0.09052584f, -0.07604201f, 
    -0.01620043f, -0.16311580f, -0.11661364f, -0.20780493f, -0.08374135f, 0.03961615f, -0.03927569f, 0.01525913f, 
    -0.03333947f, 0.00163227f, 0.03648282f, 0.05796227f, 0.13457115f, -0.11511514f, -0.00873419f, -0.22432654f, 
    0.10839617f, -0.11434627f, 0.02551588f, 0.13548161f, -0.12914953f, 0.01244089f, -0.10048017f, 0.10426503f, 
    0.15756850f, 0.06641418f, -0.05616073f, 0.07864732f, -0.03457728f, 0.01774643f, -0.07948460f, 0.00189001f, 
    -0.02775705f, -0.00187103f, 0.06720737f, -0.02010215f, 0.42467469f, 0.03119358f, -0.16123305f, 0.06085147f, 
    -0.13578451f, -0.02394353f, 0.01186070f, 0.03992859f, 0.01485249f, -0.04122820f, 0.09717035f, -0.01242838f, 
    -0.11002953f, 0.09435125f, 0.03636850f, -0.26771763f, 0.06724127f, -0.00778068f, 0.00695373f, 0.03594213f, 
    0.01104730f, 0.00896268f, 0.18973395f, 0.04510373f, -0.27618214f, 0.10038532f, -0.13365906f, -0.11791306f, 
    -0.12113571f, 0.01334888f, -0.00376824f, 0.06408842f, -0.04731581f, -0.07772632f, 0.03613076f, -0.08710800f, 
    -0.06520557f, 0.09612690f, 0.02193587f, -0.17326957f, -0.00537234f, -0.09381106f, -0.01543739f, -0.09565402f, 
    -0.05501652f, -0.16037847f, -0.09462017f, -0.11975142f, 0.01871210f, -0.02036384f, -0.11729878f, 0.07988239f, 
    -0.01172375f, -0.01460754f, 0.03708611f, 0.00991000f, 0.06965904f, -0.10465129f, -0.02452714f, -0.14600348f, 
    -0.43729901f, 0.21849480f, 0.07775522f, -0.07927290f, -0.08138922f, 0.04032790f, 0.08106973f, 0.06902667f, 
    0.01204470f, 0.06641234f, 0.01583536f, -0.04413660f, 0.23249798f, -0.11609323f, 0.03259800f, -0.02913048f, 
    -0.02790349f, 0.04821604f, -0.01519532f, -0.04217837f, -0.05060670f, -0.01788716f, 0.04745164f, 0.01479186f, 
    -0.45584404f, 0.02899447f, 0.06551351f, 0.03153487f, 0.15433927f, -0.08841600f, 0.06340482f, -0.02832175f, 
    0.05675330f, 0.01230596f, 0.10324652f, 0.00952992f, 0.36349198f, -0.01901651f, -0.02970873f, -0.17268103f, 
    0.00288795f, -0.08064263f, -0.10791096f, 0.10352840f, 0.05030360f, 0.02645970f, 0.09095763f, 0.05768404f, 
    0.40688241f, -0.00658489f, -0.21174747f, -0.00844778f, 0.03598147f, 0.10675997f, -0.00716210f, 0.11294524f, 
    0.00771309f, -0.03532524f, 0.02491220f, 0.01984590f, 0.16058722f, -0.08235423f, -0.02292291f, 0.03558415f, 
    -0.11638530f, 0.02182577f, 0.01275625f, 0.02075893f, 0.03438966f, -0.04969097f, -0.10114929f, -0.08304465f, 
    -0.06885453f, 0.13047798f, -0.01523403f, -0.07058188f, 0.03057223f, -0.03271189f, -0.03619382f, 0.03167998f, 
    -0.05299048f, -0.13007748f, 0.04997081f, -0.12350354f, 0.24196859f, 0.00225850f, -0.05848020f, -0.24730843f, 
    -0.01657352f, -0.05362228f, -0.01877069f, 0.01008413f, 0.01390411f, -0.05910830f, 0.06357676f, -0.00554255f, 
    0.09777781f, -0.07715161f, -0.24862786f, -0.20936485f, -0.04614281f, -0.08625260f, -0.04251776f, -0.00274050f, 
    0.00591312f, 0.07412648f, 0.07121639f, -0.01152481f, -0.07497898f, 0.02922498f, -0.07792725f, 0.02334422f, 
    -0.07759972f, 0.01467601f, -0.05521234f, -0.13247843f, 0.02885794f, 0.01827867f, 0.08833960f, -0.01719701f, 
    0.14404462f, 0.14943516f, -0.07612104f, 0.18717723f, 0.01345348f, 0.03831834f, 0.05715105f, -0.07266986f, 
    -0.01983164f, 0.01857709f, -0.10198455f, -0.06360800f, 0.11296145f, -0.08757377f, -0.00913042f, 0.09594058f, 
    -0.03629440f, -0.14197266f, -0.06691037f, -0.05224944f, -0.03843644f, 0.09600200f, -0.02395153f, 0.04157382f, 
    0.17258979f, -0.05529471f, -0.13897698f, 0.14905961f, -0.08772858f, -0.01511098f, -0.00046119f, -0.00461250f, 
    0.04804700f, 0.02842561f, 0.05910749f, 0.01454039f, -0.13110320f, -0.17902662f, -0.02296917f, -0.04851322f, 
    -0.04974258f, 0.09523799f, 0.05365214f, 0.03300098f, 0.05833306f, 0.04995240f, 0.01318313f, 0.06366263f, 
    0.03290145f, 0.15644372f, -0.07378483f, -0.09399134f, 0.11630183f, -0.07057914f, 0.03652198f, -0.01520542f, 
    -0.05774331f, -0.02887418f, -0.07228080f, 0.03157271f, -0.17822509f, -0.19680294f, -0.01558058f, 0.03610531f, 
    0.07710272f, -0.06793541f, -0.00257048f, 0.04689814f, -0.05934567f, -0.02907659f, -0.04126721f, -0.08670086f, 
    0.12197316f, -0.13481928f, 0.00092214f, -0.01059303f, 0.04622600f, -0.01279735f, 0.02839297f, -0.05118252f, 
    -0.02229633f, 0.06314813f, 0.11745641f, 0.16821215f, -0.03140742f, 0.00533221f, -0.00589218f, 0.27252102f, 
    -0.06236491f, 0.01902738f, 0.02638452f, 0.09113464f, 0.05448210f, -0.02465894f, -0.04030011f, -0.10946731f, 
    -0.00619633f, 0.12465246f, -0.15415110f, 0.02735270f, -0.07962047f, -0.00559006f, 0.10207496f, 0.10113139f, 
    -0.03794858f, 0.04011770f, -0.15025412f, -0.06047874f, -0.22840294f, 0.19594954f, -0.06161888f, -0.02389436f, 
    0.01698246f, 0.01325091f, -0.03273173f, -0.14768678f, -0.01949281f, 0.01575146f, 0.03097337f, -0.05200768f, 
    0.02063988f, 0.09309092f, -0.19637209f, 0.01384909f, 0.01692302f, -0.00412969f, -0.06763819f, 0.15092497f, 
    -0.04121975f, -0.00632064f, -0.03197035f, -0.09143014f, 0.06884602f, -0.36875379f, -0.05410789f, -0.19610804f, 
    0.10891050f, 0.05305091f, -0.04021682f, -0.07146242f, -0.01385053f, 0.09902005f, -0.01579544f, -0.00287833f, 
    0.12502925f, -0.05818996f, -0.01256708f, 0.00091132f, 0.16149935f, 0.09347641f, -0.08981368f, 0.01273174f, 
    -0.07406554f, 0.01470264f, 0.01082575f, 0.02136048f, -0.04790181f, -0.14833000f, 0.07447987f, 0.05437166f, 
    0.08815692f, 0.10129134f, -0.07177235f, 0.05596678f, -0.04205956f, -0.03532495f, -0.00375627f, 0.00507249f, 
    0.11971896f, 0.05851545f, 0.02648192f, -0.09293169f, -0.00066129f, 0.05760141f, 0.01223344f, -0.01780673f, 
    -0.02923261f, 0.01391237f, 0.00515177f, 0.01934379f, 0.01385805f, 0.01363352f, -0.08855754f, 0.20422208f, 
    -0.17250040f, -0.10587747f, -0.02203740f, 0.03411362f, -0.09950519f, 0.14361525f, 0.13973485f, -0.08045832f, 
    -0.14694867f, 0.21625444f, -0.10278249f, -0.03334581f, 0.05406184f, -0.08050393f, -0.02158164f, -0.07620432f, 
    0.04256546f, 0.10812286f, 0.00295424f, -0.10070797f, 0.15222396f, -0.22381525f, -0.05724612f, 0.08829433f, 
    0.01939796f, 0.09725126f, -0.15405697f, -0.04114386f, 0.07899422f, 0.06507678f, 0.05698684f, 0.08202336f, 
    0.15199682f, 0.03355611f, -0.15645014f, 0.01483462f, 0.08578175f, 0.03589192f, 0.01627338f, 0.00907245f, 
    -0.05970866f, -0.10197654f, -0.00557320f, -0.04387013f, -0.41896573f, 0.28979769f, -0.13370679f, -0.05533173f, 
    0.00618483f, 0.03935495f, -0.05706207f, 0.05356082f, -0.01928062f, -0.12739657f, 0.08412838f, -0.11739836f, 
    0.35841233f, -0.13329335f, -0.12431068f, 0.02695758f, -0.08436859f, -0.09797899f, -0.07889349f, -0.10615302f, 
    -0.05687385f, 0.00925639f, -0.08233256f, -0.00460969f, -0.29045659f, 0.16901542f, -0.04644108f, 0.21107076f, 
    0.03562265f, -0.12467743f, -0.08196701f, -0.03956392f, 0.00178957f, 0.01000390f, -0.00138630f, -0.03782731f, 
    0.28279257f, -0.24639964f, 0.02017736f, 0.20977949f, -0.03389350f, 0.08077811f, 0.02388575f, 0.02857786f, 
    0.06360886f, 0.02627746f, 0.07080915f, 0.00999375f, 0.06756388f, -0.25495687f, -0.07479070f, 0.09798010f, 
    -0.05593061f, 0.04681768f, 0.02843396f, -0.08733308f, 0.11396584f, 0.07856103f, 0.02475519f, 0.12327033f, 
    -0.09265497f, 0.06946813f, 0.02680829f, 0.16769457f, -0.17246543f, -0.01055540f, 0.00466842f, -0.06568339f, 
    -0.04160132f, -0.07494673f, 0.04938526f, 0.04330505f, -0.06368188f, -0.00670505f, 0.01619321f, -0.21966834f, 
    0.05165283f, 0.02053588f, -0.16281219f, 0.12789802f, 0.03834927f, 0.01520780f, -0.05757966f, -0.01227363f, 
    -0.03865943f, -0.10964039f, -0.09390085f, -0.04091003f, 0.05984567f, -0.08493849f, 0.00013467f, 0.04998431f, 
    -0.03121029f, -0.05126393f, -0.07568482f, -0.11233512f, 0.10106959f, 0.17516065f, -0.07923259f, 0.13605036f, 
    0.01394553f, -0.07023890f, -0.06574325f, -0.10552743f, -0.10944251f, -0.00290103f, 0.03600463f, -0.14703038f, 
    -0.28422576f, 0.13704199f, 0.12623277f, -0.12552987f, -0.00775974f, -0.00901170f, -0.01074766f, 0.07250203f, 
    -0.05277581f, -0.09007403f, -0.00032110f, 0.02959863f, 0.16075698f, -0.06591181f, 0.06014000f, 0.12451119f, 
    -0.07321344f, 0.03057768f, -0.02698605f, 0.00489385f, 0.10212579f, -0.03213548f, -0.04856410f, 0.06529076f, 
    -0.18332712f, 0.14087310f, 0.02331447f, 0.02287792f, 0.12218627f, 0.00639744f, 0.12705933f, 0.04127134f, 
    0.01318900f, 0.04343605f, -0.04036430f, -0.03579259f, 0.21896598f, -0.24379572f, -0.01715755f, 0.19133529f, 
    0.10668239f, 0.09237569f, 0.05418681f, -0.05916803f, 0.00055175f, 0.04097190f, -0.08015872f, 0.01417097f, 
    -0.00173720f, 0.03068075f, -0.01347421f, 0.02104084f, 0.01965737f, -0.00459653f, -0.07565268f, 0.01815197f, 
    -0.02267398f, 0.10455009f, 0.06600899f, 0.09840978f, 0.09471408f, 0.09993518f, 0.03787593f, -0.07286229f, 
    -0.13648462f, -0.01607740f, -0.02871731f, 0.03603091f, -0.05756474f, -0.05798863f, -0.04408740f, -0.04185076f, 
    0.04361683f, 0.15541294f, -0.09465797f, 0.04350106f, -0.04519908f, 0.01336069f, -0.09225738f, -0.14293177f, 
    -0.07298420f, 0.04816025f, -0.11820725f, -0.08900302f, 0.14965467f, 0.13801938f, -0.10480886f, 0.03350591f, 
    0.02131775f, 0.08355866f, 0.02917910f, 0.00830877f, 0.03947844f, -0.02089592f, 0.01548026f, -0.01491533f, 
    -0.20037951f, -0.19673723f, -0.02065005f, -0.02782699f, -0.09089575f, 0.11426729f, 0.07621721f, 0.08934904f, 
    -0.09320989f, 0.08437751f, 0.05667456f, 0.01722707f, -0.13225666f, -0.14434925f, 0.03973473f, -0.10579296f, 
    0.02841218f, 0.07222712f, 0.02940397f, 0.14030209f, 0.02390222f, 0.04061816f, 0.02147044f, -0.08596816f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.01986286f, 0.01135565f, -0.04001973f, -0.02573574f, -0.01244681f, 0.02008069f, -0.02212969f, -0.04167026f, 
    -0.01887143f, 0.02580083f, 0.04792411f, -0.01856418f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
