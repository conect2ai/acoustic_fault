#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.09145343f, 0.86981529f, 0.63188434f, 0.18724158f, -0.07141457f, 0.10363780f, -0.13467926f, 0.37990874f, 
    0.76107025f, 0.10637664f, -0.17485239f, 0.04807706f, 0.08456084f, -0.13127325f, -0.44894674f, 0.62906361f, 
    -0.04131428f, -0.31322911f, -0.17756957f, -0.50735313f, 0.07020700f, -0.41212651f, -0.06164355f, -0.41123560f, 
    0.08058435f, -1.04435134f, -0.83788633f, -0.70062208f, -0.24552560f, 0.19265097f, 0.35214159f, 0.38287091f, 
    -0.01291520f, 0.54146236f, -0.22950862f, -0.60334897f, 0.16430935f, 0.09651109f, 0.52054340f, 0.47045615f, 
    0.18097933f, 0.05199411f, 0.10003717f, 0.02257391f, -0.01915763f, 0.33293700f, 0.23008941f, 0.21072140f, 
    0.11549710f, 0.05848867f, -0.37794876f, -1.15528131f, -0.82026613f, -0.09867977f, -0.14970072f, 0.05994071f, 
    0.79951316f, 0.07106052f, 0.79480612f, 0.44733649f, 0.02211430f, 0.02463418f, 0.17443933f, 0.11735127f, 
    -0.27172244f, -0.11481544f, 0.14688571f, 0.31632343f, -0.05821401f, 0.04357299f, -0.02613253f, -0.27314213f, 
    -0.06306054f, -0.10620037f, 0.08145764f, -0.83127540f, -1.25433683f, -0.76864374f, 0.32100442f, 0.51846069f, 
    -0.96985495f, 0.26879492f, 0.26650894f, -0.22178625f, 0.08092476f, 0.56886667f, 0.11460353f, -0.06900225f, 
    -0.37767100f, 0.01126601f, -0.06252795f, 0.51239836f, 0.19103087f, 0.05818690f, -0.39368820f, -0.16833614f, 
    -0.22157224f, -0.07287522f, 0.00424598f, 0.28775841f, 0.06614687f, 0.09651460f, 0.32666060f, 0.13755956f, 
    1.11916196f, 0.27707851f, -0.73152506f, -0.64800549f, -0.82269388f, 0.07137368f, 0.40476733f, 0.48890519f, 
    0.00108314f, 0.42002386f, 0.17360629f, 0.30456710f, -0.38203967f, 0.07148881f, 0.35719964f, 0.23947716f, 
    0.31895524f, 0.10265733f, -0.22412562f, 0.06831226f, 0.17678271f, -0.11388183f, -0.54975945f, -0.21265246f, 
    -0.61624223f, -0.48825297f, 0.57280022f, 0.18030600f, 0.31076458f, -0.04215134f, -0.51642013f, 0.48661536f, 
    0.18345676f, 0.45511708f, 0.16026117f, -0.48281208f, -0.35833129f, -0.01963703f, 0.00969541f, -0.66324431f, 
    -0.15323786f, 0.05333898f, -0.36581713f, 0.37976789f, -0.27026471f, -0.47591662f, -0.93736392f, -0.74529761f, 
    -0.59836566f, -0.12605108f, -0.61832476f, 0.00200803f, -0.01781220f, -0.28892806f, -0.39917102f, 0.35274544f, 
    0.53627568f, -0.18568841f, -0.07424736f, -0.19405143f, 0.00839395f, -0.05936905f, 0.07020663f, 0.41605115f, 
    0.15951759f, 0.10583515f, 0.14190210f, -0.18068862f, 0.05499184f, 0.51296294f, -0.09626900f, -0.46232945f, 
    -1.01125216f, -0.25712788f, 0.05481957f, 0.74284357f, -0.40278089f, 0.19657111f, -0.09542883f, -0.23731856f, 
    0.17832191f, 0.31529400f, 0.70254713f, -0.47046560f, 0.12164375f, 0.10271094f, 0.30770478f, -0.29964811f, 
    -0.31350791f, -0.42351434f, -0.03208201f, 0.03644743f, 0.09999242f, 0.23788497f, 0.23554862f, -0.30019754f, 
    -0.04307713f, -0.31827894f, 0.87427783f, 0.63752359f, -0.79482299f, -0.15775059f, 1.02174199f, -0.66857249f, 
    -0.58799464f, -0.16394256f, 0.01770380f, 0.30169368f, -0.27534664f, 0.63870758f, 0.31581929f, 0.33038756f, 
    0.13518752f, -0.38551232f, 0.19863321f, 0.12452770f, -0.36771807f, 0.05296672f, 0.24125499f, 0.02617152f, 
    0.31981340f, -0.47334716f, -1.23301792f, -0.90209246f, -0.31697580f, -0.22112173f, -0.55602688f, -0.22685552f, 
    -0.12290859f, -0.06427062f, 0.46303567f, -0.05434103f, 0.30502322f, 0.28000402f, 0.33354881f, 0.41643316f, 
    -0.09197724f, -0.24194543f, -0.18665843f, 0.39750189f, 0.32809454f, 0.00131842f, -0.01132791f, -0.29227829f, 
    -0.14774910f, -0.16236293f, 0.80492783f, 0.38006416f, -0.28590536f, -1.37790716f, -0.33168501f, 0.60040653f, 
    -0.14096004f, -0.78797174f, -0.50202066f, -0.80011249f, 0.31875995f, 0.10234649f, -0.05000875f, 0.00776919f, 
    -0.28472716f, 0.17449988f, 0.10006563f, -0.08620272f, -0.02767118f, 0.12581638f, 0.25797582f, -0.07786468f, 
    -0.14318320f, 0.04517211f, 0.45206058f, 0.21405081f, -1.62395239f, 0.56052119f, 1.07191491f, 0.14685573f, 
    0.60940814f, 0.92820150f, 0.66966188f, 0.30406836f, -0.26048088f, -0.31306636f, -0.02820109f, -0.32609603f, 
    0.39229587f, -0.26151097f, -0.13365071f, -0.03750970f, -0.02944245f, 0.14422970f, 0.09152944f, -0.05446522f, 
    0.07285929f, -0.11714909f, -0.04624341f, -0.33952984f, 1.30874062f, 0.38396916f, 0.43619785f, 1.19221115f, 
    1.18824089f, 0.47992432f, -0.15740910f, 0.00193978f, 0.19807437f, -0.12865850f, 0.06869221f, -0.08319763f, 
    -0.16337836f, -0.15310842f, -0.12423685f, 0.28340474f, 0.07482056f, -0.01589846f, -0.03061172f, 0.30129790f, 
    0.25097209f, 0.09599630f, 0.50437427f, -0.05558424f, 0.12015341f, 0.98660862f, -0.47948548f, -0.74929100f, 
    0.25656828f, -0.34261981f, 0.28861669f, 0.76083100f, -0.71044642f, 0.22765990f, -0.18918782f, -0.00052106f, 
    0.69239742f, 0.03862620f, 0.44292653f, 0.35843858f, 0.40755224f, 0.11545475f, 0.30879167f, 0.01549696f, 
    0.17421390f, 0.01843307f, 0.44612396f, 0.09489424f, -0.24265073f, 0.08749671f, 0.98975343f, 1.12650585f, 
    -0.06923891f, -0.49238929f, -0.46092233f, 0.00240283f, 0.64922279f, -0.27949715f, 0.23308145f, 0.73068810f, 
    0.05403395f, 0.03189776f, -0.32733327f, -0.28345385f, -0.14214051f, -0.24917898f, -0.37879905f, -0.17961137f, 
    -0.01578693f, -0.27217442f, -0.58058000f, 0.23850286f, -0.09439792f, 0.03395039f, -0.08121085f, 0.66052091f, 
    0.68828529f, -0.33232921f, 0.15613097f, 0.83830583f, 0.70627558f, -0.34116286f, -1.16613805f, 0.65661949f, 
    0.45906267f, -0.05458174f, -0.30407169f, -0.36869603f, 0.33182314f, -0.10837492f, -0.20312245f, 0.07961148f, 
    0.24571924f, 0.00218836f, -0.12465942f, 0.13269526f, 0.08538654f, -0.01556917f, -0.02435173f, -0.15723720f, 
    -0.62881625f, 0.97445762f, 0.84184808f, 0.14139870f, 0.28917742f, -1.58873034f, 0.56969315f, -0.17624617f, 
    -0.71244663f, -0.57679766f, 0.30797163f, 0.39745843f, -0.03014128f, 0.07299010f, 0.25437537f, 0.35111254f, 
    0.24320109f, 0.21589892f, -0.08053858f, -0.19790906f, 0.10480495f, 0.11325656f, 0.05144871f, 0.07741279f, 
    -0.19056019f, 1.00772226f, -0.15606637f, -0.91420650f, -0.37435448f, 0.87303889f, 0.35691959f, 0.41043738f, 
    0.07567692f, 0.67102122f, 0.60611522f, -0.44545823f, 0.33948126f, -0.16744816f, 0.16215757f, -0.15256608f, 
    -0.14247032f, -0.19466165f, -0.29592544f, 0.06905788f, 0.02951231f, 0.15278767f, 0.03094316f, 0.09363145f, 
    0.03597801f, 0.01655042f, -0.27547422f, -0.36297226f, -0.35395604f, 0.36170900f, -0.14127015f, -0.50703424f, 
    -0.00991269f, 0.02901578f, 0.34135410f, -0.42473945f, -0.24574272f, 0.09874526f, 0.34212464f, -0.35651526f, 
    -0.72815591f, -0.46452144f, -0.22605948f, -0.03002391f, 0.59965056f, 0.10122398f, 0.32336876f, -0.02546046f, 
    0.45158601f, -0.50837559f, -0.31236798f, 0.75086796f, 0.94112700f, 0.87812549f, -0.52749640f, 0.64033198f, 
    -0.71855098f, -0.47230563f, -0.50096911f, -0.14989729f, -0.39656252f, -0.12241153f, -0.05312383f, 0.12368200f, 
    0.15327004f, 0.44633585f, 0.00410451f, -0.18852539f, -0.23782365f, -0.35813704f, -0.29134092f, -0.01302123f, 
    0.08224563f, 0.15082233f, 0.17471685f, 0.16045029f, -0.44711962f, -0.68397987f, -0.81589323f, -0.40838203f, 
    -0.80126816f, 0.52182519f, 1.04509437f, 0.20321745f, 0.27664703f, 0.61764336f, -0.42335978f, -0.54217172f, 
    -0.33121312f, -0.69242305f, -0.19177143f, -0.04880357f, 0.03226496f, -0.11319346f, -0.20416833f, -0.16593319f, 
    -0.26522815f, -0.14757676f, 0.15147386f, -0.03931544f, 0.02028055f, -1.58074868f, 0.91849244f, -1.06079388f, 
    0.91920191f, -0.64517242f, 0.89239073f, 0.04810904f, -0.75514853f, 0.20225973f, -0.60506701f, 0.01345541f, 
    0.04055265f, -0.23051254f, -0.11999295f, 0.19319631f, -0.11387663f, -0.08327818f, 0.09876730f, -0.08906100f, 
    -0.24562444f, 0.13213636f, -0.17215787f, 0.21294899f, -0.04591636f, -0.03694904f, 0.62690109f, 1.02977669f, 
    0.28526363f, 0.73354137f, 0.08269770f, 0.87040251f, -0.25616136f, -0.83791763f, -0.88179058f, -0.29705670f, 
    0.15689956f, 0.42707419f, 0.14247161f, 0.20803413f, -0.63077599f, -0.22496799f, -0.18628792f, 0.34419093f, 
    0.17693692f, -0.37346688f, 0.02785698f, 0.14914696f, -0.15944320f, -0.16693394f, 0.25647342f, -0.74428564f, 
    -0.30098793f, 0.41816875f, 0.56036723f, -0.33241141f, -0.94718832f, -0.93844026f, -0.21437603f, -0.20031306f, 
    -0.64189154f, 0.32832068f, 0.19074064f, 0.17831226f, -0.36814114f, 0.51273918f, -0.10576766f, -0.15179120f, 
    -0.03937207f, 0.35734984f, 0.46915713f, 0.28332475f, 0.04006900f, 0.00873597f, 0.07871666f, -0.15978947f, 
    0.21351580f, -0.41339847f, -0.30928943f, 0.13588208f, 0.58179766f, -0.87770337f, 0.52265918f, 0.01884723f, 
    -1.12189221f, -0.13279903f, -0.34288466f, 0.43528479f, 0.32252756f, -0.20957059f, -0.03602624f, -0.44256780f, 
    0.11049319f, -0.07671937f, 0.04590078f, -0.71790224f, -0.24123506f, -0.31003731f, -0.08756456f, 0.20143960f, 
    0.16456065f, -0.05976309f, 0.40956759f, 0.37130508f, 0.78611469f, 0.89481646f, 0.90321171f, 0.70512867f, 
    0.50030702f, 0.44211760f, 0.50619125f, -0.01433078f, -0.28050908f, -0.28068045f, -0.43815237f, -0.06066544f, 
    0.02594188f, -0.22916409f, 0.03325245f, -0.33723238f, -0.52058971f, 0.05499686f, 0.01384040f, -0.11234629f, 
    0.30731374f, -0.04981710f, -0.36266318f, -0.41803572f, -0.60054833f, -0.94502962f, 0.50576574f, -0.08755895f, 
    0.49860206f, 0.45068014f, -0.20371659f, -0.63750517f, 0.21934788f, -0.45165944f, -0.00310482f, -0.06893764f, 
    -0.28075191f, -0.06906974f, -0.21213000f, -0.17217535f, -0.43808591f, -0.35911223f, -0.41621110f, 0.20761564f, 
    0.44040394f, 0.14078166f, 0.32321566f, 0.18528920f, -0.53786242f, -0.54588693f, 0.80163842f, 0.46127042f, 
    -0.58928066f, -1.15608275f, 0.08484267f, -0.37718394f, -0.15755425f, -0.11054314f, -0.19210640f, -0.25346461f, 
    -0.25182343f, -0.44288591f, 0.18788931f, -0.05560296f, 0.63252938f, 0.01262545f, -0.20350175f, 0.23358420f, 
    0.10656341f, -0.31492177f, -0.29703894f, 0.22448125f, 1.06833053f, 0.75025600f, 0.91510582f, 0.70406866f, 
    -0.13039500f, 0.07009608f, -0.70558208f, 0.04821186f, -0.09037109f, 0.48518655f, 0.51711547f, 0.36485121f, 
    -0.27419826f, -0.13991131f, -0.03262678f, 0.11753206f, 0.14783400f, 0.47063050f, -0.19596452f, 0.23953092f, 
    0.33017206f, -0.07673571f, 0.21010034f, 0.26642209f, 0.26764232f, 0.30625275f, -0.45390019f, 0.34211600f, 
    0.39469084f, 0.16906883f, -0.48066342f, -0.84560430f, -0.62706631f, -0.16852933f, 0.07956634f, -0.66142315f, 
    0.19705409f, 0.46857500f, -0.19680071f, -0.26666015f, -0.29647654f, 0.11526524f, 0.32536912f, -0.06949776f, 
    0.39079431f, 0.37775674f, -0.13616219f, -0.12168124f, 0.35793743f, -0.13887255f, -0.26389498f, 1.05213261f, 
    0.28999069f, -1.34417188f, -0.16810900f, -0.24363530f, -0.02850240f, 0.41095605f, -0.78133869f, 0.19174567f, 
    0.36641526f, 0.37448326f, 0.06941430f, -0.07165533f, 0.13493982f, -0.17685553f, 0.19129217f, -0.06538086f, 
    0.12615329f, 0.15388508f, 0.00182589f, 0.22478363f, 0.08029640f, 0.17586146f, 0.31726593f, -0.76189804f, 
    -0.69030523f, -0.40460089f, -0.37634370f, -0.37060007f, -0.11787378f, -0.65645260f, -0.52828091f, 0.19371900f, 
    -0.44044039f, 0.30551291f, 0.16971998f, 0.10187424f, 0.05422337f, 0.20648572f, 0.42563745f, 0.43727413f, 
    0.10978254f, 0.11849417f, 0.29324061f, -0.38786405f, -0.14636791f, 0.24304596f, 0.07514209f, 0.35021964f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.10807972f, 0.15958145f, -0.03642513f, 0.38225469f, 0.26899022f, 0.02546651f, 0.04924203f, 0.25000107f, 
    0.08512738f, 0.13096943f, 0.18273671f, 0.21525204f, 0.14567529f, 0.10434727f, 0.05445610f, 0.00584735f, 
    0.10088798f, 0.01355308f, 0.21868609f, 0.17233698f, -0.11313226f, 0.08957728f, -0.13513358f, 0.23042589f, 
    -0.00030350f, 0.25726086f, 0.17037624f, 0.16634315f, 0.13324618f, 0.17755859f, 0.23625650f, 0.12773551f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.05647369f, 0.02261396f, -0.09277725f, -0.13659818f, -0.07517155f, -0.16814287f, 0.03928025f, 0.01700762f, 
    0.08360455f, 0.04533931f, 0.13424915f, -0.26787904f, -0.21988583f, 0.22470184f, 0.03892893f, -0.23299372f, 
    0.12546398f, 0.02187421f, -0.00926922f, 0.13740316f, 0.07744528f, -0.04478795f, -0.01422724f, 0.00659924f, 
    0.07355659f, 0.46630901f, -0.19138996f, -0.37496156f, 0.11729843f, 0.00430233f, 0.07498174f, 0.04893307f, 
    -0.03732025f, -0.04265084f, -0.01951347f, 0.07782143f, -0.60289806f, 0.12084565f, -0.25798827f, 0.09501773f, 
    0.00434183f, 0.00642489f, -0.02368682f, 0.13425660f, 0.07213019f, 0.05284718f, -0.17576610f, 0.12908873f, 
    0.03419832f, -0.16898888f, 0.21111324f, -0.13823356f, -0.05479500f, -0.00862844f, 0.01351684f, -0.09277147f, 
    0.03614122f, -0.02361085f, -0.04541593f, -0.02451190f, -0.12339620f, 0.09208123f, -0.00830909f, -0.36733457f, 
    -0.03125165f, 0.08509272f, 0.03852706f, -0.15392755f, -0.21329868f, 0.19875242f, -0.07710719f, -0.00668206f, 
    0.05578838f, -0.16674913f, -0.23756288f, -0.08882242f, -0.04156014f, 0.12567043f, -0.12959504f, 0.06518278f, 
    0.07591411f, 0.02463439f, 0.07316975f, -0.12814444f, -0.30833986f, -0.09113100f, 0.03149327f, 0.23293824f, 
    0.07901408f, 0.00363124f, -0.17620842f, 0.03462009f, 0.02736064f, -0.04082685f, 0.17944223f, -0.15976979f, 
    -0.08103977f, 0.13696042f, 0.02066845f, 0.13421862f, -0.15492383f, -0.08523792f, 0.01058051f, 0.07880357f, 
    0.07898968f, 0.09816889f, 0.10112427f, 0.05232137f, -0.03663268f, -0.47390106f, -0.12812877f, -0.09230490f, 
    0.02615463f, -0.10982560f, 0.06660006f, -0.05410856f, -0.01965090f, -0.16157220f, -0.06568110f, 0.09682468f, 
    -0.49546629f, 0.26636797f, 0.21925296f, -0.45293939f, -0.23469444f, -0.01794662f, 0.15833931f, 0.23847361f, 
    0.04869512f, -0.11023948f, 0.10414065f, 0.15062827f, -0.27305603f, 0.20861773f, -0.21375965f, 0.32888842f, 
    -0.05274396f, 0.16304266f, 0.16298258f, -0.01420923f, 0.05986296f, -0.12115301f, 0.05750267f, -0.06727974f, 
    0.27268586f, -0.14925149f, -0.03766093f, 0.39604673f, -0.20424147f, 0.07724340f, -0.11276475f, 0.08065201f, 
    0.01269470f, -0.07556691f, 0.01694942f, -0.18623959f, -0.14198911f, -0.14400969f, 0.13015288f, -0.07143474f, 
    -0.08981788f, -0.23419312f, -0.11697464f, -0.05756385f, -0.08916499f, 0.05139105f, 0.11128034f, -0.00726070f, 
    0.06653202f, 0.03366758f, 0.07396648f, -0.23255943f, 0.07884909f, -0.02503461f, 0.11593106f, -0.00452928f, 
    -0.01503444f, 0.04847169f, -0.08956305f, -0.02933104f, -0.00819832f, -0.03154629f, 0.26110926f, 0.32730949f, 
    0.05705736f, 0.00663715f, 0.10352587f, -0.02302225f, 0.03948267f, 0.11024500f, 0.07760131f, -0.03301547f, 
    -0.33928743f, 0.07571284f, -0.15014011f, 0.05897676f, 0.03180838f, -0.11887718f, 0.10019314f, -0.04145578f, 
    -0.08394971f, 0.03902050f, -0.05727370f, -0.21693258f, 0.18462469f, 0.10253509f, 0.00316341f, -0.23918672f, 
    0.13689715f, 0.02505532f, 0.04345676f, 0.06034405f, -0.17211626f, 0.16864140f, 0.18319239f, -0.07169560f, 
    -0.09677868f, 0.07576774f, -0.40595514f, 0.04936711f, 0.07498121f, 0.01427123f, 0.09206362f, -0.08690837f, 
    0.08512834f, -0.11132421f, -0.02463230f, 0.04865569f, 0.12386716f, 0.09306441f, 0.06244826f, -0.46024877f, 
    -0.20542181f, -0.20103677f, -0.08844586f, -0.00743214f, 0.03159310f, -0.11317423f, -0.09294295f, -0.11789482f, 
    0.54003453f, 0.40074039f, 0.11828444f, -0.24771999f, 0.13862734f, 0.09512004f, 0.12898144f, 0.05190736f, 
    -0.06156140f, 0.05285507f, 0.05273122f, 0.14148881f, 0.75422138f, 0.16985467f, -0.18232360f, -0.08376765f, 
    -0.07567781f, -0.09352431f, -0.01920042f, 0.00609731f, 0.00158395f, 0.00918015f, -0.07544561f, -0.04374741f, 
    0.18625848f, 0.23056120f, 0.04435448f, -0.08114964f, -0.22402209f, -0.06990124f, 0.01446318f, 0.00418279f, 
    -0.06951331f, 0.23731542f, -0.20851545f, 0.05738840f, -0.16920094f, 0.02184824f, -0.22572359f, 0.24045293f, 
    0.03880007f, 0.12759961f, -0.00093662f, 0.12182543f, 0.23320645f, -0.06356300f, -0.01074631f, -0.04106551f, 
    0.02117431f, -0.11858617f, 0.14859903f, 0.08901836f, -0.16333160f, -0.09189053f, -0.17598560f, -0.05016119f, 
    -0.05894462f, 0.03855111f, 0.04170088f, -0.09367973f, -0.04049289f, 0.07236518f, 0.23903881f, 0.24515018f, 
    -0.10726696f, 0.02342267f, 0.13779652f, -0.09044009f, -0.09261349f, -0.04809419f, -0.04872982f, -0.04747248f, 
    -0.20937784f, 0.29314888f, 0.11296217f, -0.38294810f, -0.08816648f, -0.03674070f, -0.02858678f, -0.04246497f, 
    -0.00422944f, 0.01822088f, -0.10131615f, -0.09396211f, 0.27525541f, -0.36451393f, 0.03143712f, 0.36037570f, 
    -0.22230496f, 0.23799284f, -0.08479496f, -0.05920891f, -0.08210760f, -0.12793405f, 0.04962659f, 0.13751487f, 
    0.15472108f, -0.09876990f, -0.10740049f, 0.07828829f, -0.24776261f, -0.24507026f, 0.00763220f, 0.09510881f, 
    -0.00727049f, -0.01609677f, -0.15741651f, 0.02313484f, 0.13227952f, -0.28898451f, 0.00982722f, 0.12119802f, 
    -0.03093787f, -0.12450918f, 0.05477337f, 0.05109952f, -0.10577696f, -0.17040490f, -0.21826383f, 0.17837447f, 
    -0.45297596f, 0.23879118f, 0.14317927f, -0.33310157f, 0.06587746f, 0.12386678f, 0.12513287f, 0.02159499f, 
    0.01610702f, -0.20203915f, -0.06469388f, -0.06017889f, -0.05957847f, -0.11336333f, -0.18684480f, -0.00812914f, 
    -0.05175034f, 0.07170868f, -0.03905289f, 0.08023947f, -0.01596410f, -0.02940395f, 0.08146794f, -0.23272756f, 
    0.33095238f, -0.07229847f, 0.05253115f, 0.17553692f, -0.01103615f, -0.19821939f, -0.15654592f, 0.06796925f, 
    0.07417971f, -0.26934776f, -0.06007515f, 0.03829358f, 0.17476913f, 0.01539749f, -0.16757718f, -0.02064661f, 
    -0.07388227f, 0.00054155f, 0.04158276f, 0.12105180f, 0.02379202f, 0.13284591f, -0.07003383f, -0.01482671f, 
    0.30380788f, -0.26567471f, -0.25654042f, -0.11087093f, 0.18872924f, 0.08919332f, 0.03790870f, -0.01076366f, 
    -0.00253582f, 0.04066286f, 0.06625050f, 0.10415106f, 0.39862669f, -0.19574071f, -0.09885135f, 0.16756064f, 
    -0.01904259f, 0.05794761f, -0.06272019f, 0.06944295f, -0.05104156f, -0.21521640f, 0.09376778f, 0.04471717f, 
    -0.01156531f, -0.19452409f, 0.04422098f, -0.10559262f, 0.03848522f, -0.01700077f, -0.03010351f, 0.12134160f, 
    -0.06130840f, 0.16220862f, -0.06824008f, 0.09639996f, 0.08862142f, -0.16847900f, -0.16036171f, 0.02996668f, 
    0.05846369f, -0.00611625f, 0.09254007f, -0.00241061f, -0.02286246f, -0.29521757f, 0.06616734f, -0.14665493f, 
    0.17395405f, 0.14179318f, 0.05283805f, 0.12820622f, -0.06826391f, -0.07153387f, 0.12049939f, -0.13400197f, 
    -0.03501288f, -0.05166689f, 0.05341335f, 0.23136571f, 0.25744390f, -0.23096445f, -0.03008770f, -0.12365948f, 
    0.05278549f, 0.18132821f, -0.01570698f, -0.07140337f, -0.06575657f, -0.08029029f, -0.18427138f, 0.08910120f, 
    -0.28297728f, 0.07879648f, -0.20050998f, -0.14015049f, -0.04883717f, 0.05799979f, 0.10972776f, -0.11577741f, 
    0.12701833f, 0.01601905f, -0.07354791f, -0.03283954f, 0.24142490f, 0.06686797f, 0.08211902f, 0.03529463f, 
    -0.11759125f, -0.01774559f, 0.02267851f, 0.09782762f, -0.28871617f, 0.06593480f, -0.01003328f, 0.05984936f, 
    0.17656870f, -0.16023108f, -0.07753988f, -0.31369960f, -0.07698106f, 0.01627677f, 0.08092123f, 0.00819110f, 
    -0.20474900f, 0.14002952f, 0.06781430f, -0.03461609f, 0.29634488f, -0.25802943f, -0.01268586f, 0.24748862f, 
    -0.00770045f, 0.10197281f, -0.02166934f, -0.01798140f, 0.16984570f, 0.14614183f, 0.04205249f, 0.01367685f, 
    0.18890779f, -0.06790785f, 0.30143383f, 0.25325286f, -0.21324922f, -0.03640601f, 0.06026312f, 0.03854229f, 
    -0.09767830f, 0.02305258f, -0.02242845f, 0.09352110f, 0.59582055f, -0.38762346f, -0.09370656f, -0.04865875f, 
    -0.05665359f, -0.07331775f, -0.03599010f, 0.08741198f, -0.09810456f, 0.05640456f, -0.07933866f, 0.02240575f, 
    0.37958848f, 0.15341882f, 0.03775958f, -0.22650144f, 0.08502739f, -0.27032673f, 0.05639583f, -0.07935859f, 
    -0.11619550f, -0.15161355f, -0.09556976f, 0.02696985f, 0.07965533f, -0.17298774f, 0.05036786f, -0.08538791f, 
    -0.22818029f, -0.20817789f, -0.05559181f, 0.06814224f, -0.09759371f, -0.13691507f, -0.00937039f, -0.18801266f, 
    -0.50046831f, 0.13747257f, -0.20193584f, -0.26272127f, -0.03543223f, 0.11377753f, -0.05260495f, -0.02656656f, 
    0.12032223f, 0.03780218f, 0.03208224f, 0.03318091f, 0.46575320f, -0.24558932f, 0.21116631f, -0.14628285f, 
    0.07341888f, -0.13719206f, -0.06153315f, 0.06864577f, 0.00297476f, -0.09050100f, -0.12554106f, 0.03391118f, 
    -0.10687634f, -0.39490697f, -0.29058403f, 0.15947771f, 0.02714713f, -0.23787013f, -0.13874738f, -0.00034055f, 
    -0.09351362f, -0.06927835f, -0.14178273f, 0.09100430f, -0.05078845f, 0.18449336f, 0.00392386f, 0.07045566f, 
    0.03964988f, -0.06082760f, 0.18820153f, 0.06553206f, 0.00975571f, -0.03322353f, -0.24092080f, 0.20408738f, 
    -0.05546081f, -0.30227241f, -0.09420411f, -0.08748604f, 0.03718378f, -0.10441563f, -0.23851977f, -0.13803476f, 
    0.19297034f, -0.03350733f, -0.08233273f, -0.11541148f, -0.88480896f, -0.08405478f, -0.55726856f, 0.01242298f, 
    0.15615082f, -0.05806115f, -0.08038337f, 0.09258399f, -0.06734055f, 0.06930845f, -0.04307924f, 0.00400129f, 
    0.13591692f, -0.12948895f, 0.23145223f, 0.12241253f, -0.13897477f, 0.00957577f, -0.08886620f, 0.00374959f, 
    0.02433139f, -0.00480771f, 0.09946956f, -0.17111357f, -0.50161988f, -0.02413393f, -0.18479298f, 0.05544636f, 
    0.04969329f, -0.01869909f, -0.18346085f, -0.06197796f, -0.23364449f, 0.20261490f, 0.08752618f, 0.07613406f, 
    -0.05938731f, 0.20868386f, -0.02898340f, -0.08325377f, -0.00758659f, 0.00826064f, -0.09859864f, 0.27231333f, 
    0.07955706f, -0.10153723f, -0.01586928f, -0.14874165f, 0.26863787f, 0.11911533f, 0.04101241f, 0.21345094f, 
    0.18214034f, 0.16777706f, -0.05399111f, 0.01593527f, 0.04544687f, 0.11222674f, 0.00230246f, 0.10889526f, 
    0.22063456f, -0.09246089f, -0.17543443f, -0.23640981f, 0.05601427f, 0.07001457f, -0.04563565f, -0.09493509f, 
    -0.15857887f, -0.04292486f, -0.16776831f, 0.13845722f, -0.44353241f, -0.09904156f, -0.07704080f, -0.09571853f, 
    0.15057044f, 0.01953611f, -0.09149496f, 0.21063049f, 0.03794165f, -0.07029241f, 0.06638237f, 0.07041411f, 
    0.13589856f, 0.15689369f, 0.24664184f, 0.35604548f, -0.22944278f, -0.04014814f, 0.11962667f, 0.00983109f, 
    0.05120617f, -0.00580972f, 0.12451668f, 0.05448188f, -0.04680596f, -0.05103560f, -0.16590483f, -0.03640794f, 
    -0.09951518f, 0.05639883f, 0.05945700f, -0.04486829f, 0.10224186f, -0.06132825f, 0.23522833f, -0.18312882f, 
    0.02679524f, 0.17320485f, -0.20034303f, -0.35516116f, -0.11244822f, 0.09452239f, -0.08335710f, 0.11503963f, 
    0.03004947f, 0.21944718f, 0.26052043f, -0.06402317f, -0.23206337f, 0.04854467f, 0.10391992f, -0.01835694f, 
    0.13525251f, 0.02087587f, 0.10763431f, 0.07424989f, 0.02052209f, 0.12843151f, 0.02021476f, 0.21160302f, 
    0.15453769f, 0.06944589f, -0.19947587f, 0.19522214f, 0.04028891f, 0.01378109f, 0.06951203f, 0.13212338f, 
    -0.11427618f, 0.26378307f, 0.05274586f, -0.19704337f, 0.27621794f, -0.01492560f, -0.11443550f, 0.05447374f, 
    -0.24305657f, -0.12013938f, -0.06945448f, -0.05454789f, 0.01637927f, -0.11077601f, -0.20379622f, 0.08195683f, 
    0.36601561f, -0.06720827f, 0.24441586f, 0.34796461f, -0.30289945f, -0.20901740f, 0.04638521f, 0.18726230f, 
    0.07226496f, 0.01164308f, -0.06381369f, 0.04602913f, 0.68878615f, -0.52184933f, 0.06295804f, 0.09534382f, 
    -0.12822039f, -0.04811222f, 0.02867649f, -0.04760201f, -0.08635379f, -0.04697250f, 0.00736027f, -0.05522167f, 
    -0.02264038f, -0.07761148f, 0.05692687f, 0.06165282f, 0.10918159f, 0.02490541f, 0.09886056f, -0.10678615f, 
    0.01052592f, -0.02527635f, 0.00930793f, -0.11400602f, -0.03899491f, 0.18532822f, 0.32630122f, -0.05109799f, 
    -0.10348963f, -0.11493090f, -0.04936802f, 0.10895932f, -0.03751700f, 0.02258395f, -0.08548950f, -0.12863185f, 
    0.18523525f, -0.39157772f, 0.29020000f, -0.04732665f, -0.18674526f, -0.01987673f, -0.10828432f, 0.05499400f, 
    -0.02465194f, 0.03297236f, 0.05658303f, -0.11447427f, 0.45667043f, -0.42297643f, 0.14033118f, -0.19101037f, 
    -0.16422850f, 0.05472076f, -0.10055435f, -0.15107004f, 0.15545814f, -0.02533033f, 0.12496995f, -0.11945219f, 
    0.45577577f, 0.05885504f, -0.28792185f, -0.17361499f, -0.03626639f, 0.07663330f, -0.14247017f, 0.09424727f, 
    -0.04855008f, -0.08943342f, -0.12884083f, -0.13423750f, 0.56396723f, -0.30114901f, 0.18898956f, 0.02834640f, 
    -0.11903826f, -0.08545241f, 0.00937664f, 0.05413140f, 0.06694730f, -0.09305178f, -0.05904358f, -0.19645187f, 
    -0.51222104f, -0.38288012f, -0.07192834f, -0.37823024f, 0.10443663f, -0.09649850f, 0.06861874f, -0.04582356f, 
    0.05019642f, -0.02419575f, 0.05088091f, 0.02176262f, -0.16046858f, -0.15592954f, 0.15395010f, -0.07966072f, 
    -0.05110549f, 0.04207334f, -0.08316068f, 0.07888506f, 0.05074510f, 0.09710067f, -0.04576425f, -0.12595338f, 
    0.09263323f, 0.15393475f, -0.05611984f, 0.13733305f, 0.16469130f, -0.03582462f, -0.07048979f, -0.03114521f, 
    -0.04412386f, 0.04146043f, 0.01069340f, -0.08205357f, -0.21423210f, -0.08840024f, 0.07873156f, -0.29450884f, 
    -0.08596124f, -0.09353755f, 0.16304313f, 0.08911866f, -0.07262518f, -0.22657508f, -0.03304689f, 0.06582460f, 
    0.32945302f, 0.01530031f, 0.09373828f, -0.12576841f, -0.02041819f, 0.02739599f, 0.22782253f, 0.11143748f, 
    -0.00737478f, 0.07753336f, 0.14884706f, -0.14561088f, 0.37806976f, -0.32968712f, 0.11140103f, 0.00236617f, 
    0.18355234f, 0.12899972f, 0.12761994f, -0.07180580f, -0.02696415f, 0.00495427f, 0.09541461f, -0.02992280f, 
    0.56532001f, 0.19187216f, -0.52778339f, -0.04601007f, 0.12820612f, 0.05582197f, -0.08723540f, -0.07271826f, 
    -0.25074211f, -0.11131564f, -0.26121899f, -0.08512186f, 0.03050597f, -0.00964676f, 0.03013946f, 0.11287044f, 
    -0.11754855f, 0.02844626f, 0.16722906f, 0.14609413f, 0.03365557f, -0.01505605f, -0.02143397f, 0.06257353f, 
    -0.02126714f, -0.14576900f, -0.00417673f, -0.00304848f, -0.06176676f, 0.08734460f, 0.08320871f, -0.08070372f, 
    0.05598886f, 0.06587742f, -0.05397126f, -0.03074599f, -0.18422981f, 0.01467860f, -0.23458740f, -0.31124103f, 
    0.14168085f, 0.12436890f, 0.09261005f, -0.18706588f, 0.01084386f, 0.07144226f, -0.06189164f, -0.12869751f, 
    0.31787130f, 0.00327307f, 0.34915650f, 0.44445720f, -0.11841021f, -0.15788142f, -0.00096989f, 0.17922181f, 
    0.09128381f, 0.10816918f, -0.08926006f, -0.03083641f, 0.21848060f, -0.00383831f, -0.32365093f, -0.33750230f, 
    0.06550431f, -0.03295619f, -0.07195899f, -0.06890082f, -0.08279055f, -0.00710328f, -0.11382405f, 0.13203952f, 
    -0.04186171f, -0.19908707f, 0.03926954f, -0.20660825f, 0.12439691f, -0.01006662f, 0.03964579f, -0.03634998f, 
    -0.10956748f, 0.17948900f, -0.14309587f, 0.04009454f, 0.29929399f, -0.17033930f, -0.38937470f, -0.14875369f, 
    0.05387133f, 0.01056193f, -0.10401625f, 0.09406146f, 0.08442803f, 0.01524115f, 0.14522417f, -0.08569670f, 
    0.66125673f, -0.03444831f, -0.20103766f, -0.37217823f, 0.14585222f, 0.04055093f, -0.00564578f, -0.01730711f, 
    -0.13631384f, 0.13128836f, -0.10708915f, -0.10018622f, 0.17493626f, -0.23195048f, 0.02821704f, -0.14085475f, 
    0.07717574f, -0.08833542f, 0.04519245f, -0.08284888f, 0.11768679f, 0.13405319f, -0.01112356f, -0.04599613f, 
    -0.29692599f, -0.20874263f, -0.18468022f, 0.10749973f, -0.05689139f, -0.06139594f, -0.07750315f, -0.13897626f, 
    0.13187559f, 0.01668090f, 0.03821719f, 0.05753940f, -0.18535082f, -0.27850226f, -0.29079646f, 0.02728760f, 
    0.06197935f, -0.05507214f, -0.02419222f, -0.08011580f, 0.01954491f, 0.08138713f, -0.09125150f, -0.13089681f, 
    -0.07243238f, 0.13257831f, -0.02888467f, 0.02862083f, -0.04682128f, 0.09381648f, 0.08392595f, 0.04086932f, 
    -0.10776432f, 0.06136132f, -0.00212284f, -0.12844564f, -0.29953855f, -0.03546890f, 0.07332572f, -0.00459257f, 
    -0.04935941f, 0.07776552f, 0.07016563f, -0.03498241f, 0.10621411f, -0.00577121f, -0.09838928f, -0.08631651f, 
    0.25664359f, -0.05995294f, 0.07012366f, -0.20492013f, 0.10438817f, -0.03944829f, 0.02233265f, -0.03018307f, 
    -0.09751206f, -0.10181668f, 0.04277386f, 0.03548933f, 0.00689494f, -0.18785083f, -0.08155781f, -0.16381055f, 
    -0.14877748f, -0.13054009f, -0.26419991f, 0.08647376f, -0.11114830f, -0.00850638f, 0.02278705f, -0.14816573f, 
    -0.03202199f, -0.73395759f, -0.41715643f, -0.08464774f, -0.25363314f, -0.05562969f, 0.06672418f, 0.00307166f, 
    0.03359932f, 0.18253611f, -0.09619129f, -0.04975895f, 0.02263479f, 0.28976962f, -0.09626958f, 0.09686796f, 
    -0.13817242f, -0.07599781f, 0.02261014f, -0.00776852f, -0.13907230f, -0.15271038f, 0.00756148f, 0.00393196f, 
    0.07188571f, 0.04610208f, -0.01418361f, -0.10376159f, -0.15311791f, -0.19029629f, -0.00871232f, -0.02957776f, 
    -0.08860522f, 0.03912022f, 0.03728447f, -0.03649644f, -0.05608319f, 0.07612120f, 0.06453689f, 0.06372138f, 
    -0.11084163f, -0.13887395f, 0.11286438f, -0.03845771f, -0.08535913f, 0.04606565f, -0.10082767f, -0.06226841f, 
    -0.11250376f, -0.05431589f, 0.11592165f, 0.37997890f, 0.03904242f, 0.22162963f, -0.03973569f, -0.17630883f, 
    -0.04548107f, -0.09774300f, -0.05714908f, -0.15686199f, -0.03047332f, -0.14127789f, -0.18297052f, -0.06074510f, 
    0.03474458f, 0.07369661f, -0.03704254f, 0.12590484f, 0.05406016f, 0.08448605f, -0.00857631f, 0.13923280f, 
    0.01438810f, 0.01708125f, -0.01458521f, -0.31165928f, -0.08005664f, -0.19447571f, -0.05010762f, 0.06850464f, 
    0.05098617f, -0.04374110f, 0.03417584f, 0.13547525f, -0.10673475f, 0.16434376f, 0.10418888f, 0.28107354f, 
    -0.01827171f, 0.09897988f, -0.04341036f, -0.01207462f, -0.06483632f, 0.23831318f, 0.12688048f, -0.01871739f, 
    -0.44655523f, 0.16629979f, 0.10459349f, 0.16079134f, 0.04707396f, -0.10210445f, 0.18111622f, 0.01604840f, 
    -0.08553114f, -0.23434785f, 0.06020976f, 0.11689543f, 0.05447772f, 0.11361354f, -0.03418307f, -0.20195079f, 
    -0.12251411f, -0.06566053f, -0.04351023f, 0.05598668f, -0.02383553f, -0.07210368f, 0.17731835f, 0.15088198f, 
    0.14414214f, 0.20180662f, 0.15948857f, -0.02725027f, -0.01555519f, -0.01806577f, 0.04923202f, 0.09392339f, 
    -0.06508057f, 0.04131639f, -0.03636596f, -0.11942657f, -0.08195865f, -0.13452232f, -0.05085315f, -0.07293142f, 
    -0.02023843f, -0.00605995f, 0.01584267f, 0.01698510f, 0.04208700f, -0.03890442f, 0.05042216f, -0.06655657f, 
    -0.51559639f, -0.35348487f, -0.18546601f, 0.07917894f, -0.05061207f, 0.06380783f, -0.01292995f, -0.10599013f, 
    -0.04147162f, -0.08804911f, 0.00348636f, -0.06738305f, 0.15367271f, -0.24442764f, -0.06437550f, 0.03822358f, 
    -0.17286548f, 0.05827644f, 0.02339943f, -0.04705614f, -0.00176920f, -0.15819268f, -0.14471047f, 0.03964586f, 
    -0.43368414f, -0.04931192f, -0.19999914f, 0.02639128f, -0.17453726f, 0.11578815f, -0.14470720f, 0.17657146f, 
    -0.13872002f, 0.11317971f, 0.00425417f, 0.05705639f, 0.55502468f, 0.23027717f, -0.26816586f, -0.07349103f, 
    -0.00313285f, 0.02930918f, -0.21158679f, -0.22331887f, 0.11854085f, -0.10475915f, 0.02763674f, 0.00882233f, 
    -0.71277303f, 0.35045439f, 0.21629609f, 0.15653056f, 0.08008170f, 0.08451778f, -0.00046491f, -0.04201013f, 
    -0.02733376f, -0.04491557f, -0.04013000f, -0.09283713f, -0.04015410f, 0.15391359f, -0.18756764f, -0.15070200f, 
    -0.02755271f, -0.01152835f, -0.02360881f, -0.11045048f, -0.15680325f, -0.12334073f, 0.11432432f, -0.01033980f, 
    0.08478987f, 0.22038713f, 0.08751922f, -0.02170360f, -0.00870919f, 0.02352855f, 0.02988244f, 0.12075850f, 
    0.01235264f, 0.09443486f, 0.03901393f, -0.08022993f, -0.02773138f, -0.41829517f, -0.09537727f, -0.01896919f, 
    -0.00342397f, -0.00571091f, 0.07196214f, -0.10159088f, -0.09511677f, 0.09276193f, 0.14067380f, -0.17182286f, 
    -0.11648546f, -0.01826873f, -0.10869317f, -0.14824718f, -0.19312519f, -0.07545670f, 0.13540687f, 0.03823922f, 
    -0.13739334f, 0.04421244f, 0.15447910f, 0.00751811f, 0.62202615f, 0.42201826f, -0.29725316f, 0.08963003f, 
    0.08827720f, 0.07285964f, 0.21717353f, 0.22415595f, -0.10973978f, -0.06598357f, 0.02652241f, -0.04596208f, 
    0.26996484f, -0.27208641f, -0.31988317f, 0.50773382f, 0.12855910f, -0.20116426f, 0.02824839f, 0.08752745f, 
    -0.06790408f, -0.09626894f, -0.15758863f, 0.07097260f, 0.05264114f, 0.16241705f, 0.19068576f, 0.13901241f, 
    0.00597638f, 0.00040077f, -0.10165311f, -0.06259521f, -0.11148357f, 0.00809675f, 0.07835329f, -0.07404779f, 
    -0.05853711f, 0.07231161f, 0.41278291f, 0.11385060f, 0.14631917f, 0.15560567f, 0.05483964f, -0.03872919f, 
    -0.06188154f, 0.24860707f, -0.09414616f, 0.20178890f, -0.69612062f, -0.04235457f, -0.19883990f, -0.09807268f, 
    -0.13477416f, -0.06343276f, 0.06538986f, 0.00637062f, 0.02805461f, -0.01516844f, 0.05367256f, -0.09881018f, 
    0.02437379f, 0.14408119f, 0.06696034f, 0.20552923f, -0.10030241f, -0.14398976f, 0.03084433f, 0.02536407f, 
    -0.06321112f, 0.05355685f, -0.04908701f, 0.04197767f, 0.46454629f, -0.04403682f, 0.09835826f, 0.14933947f, 
    -0.00313850f, 0.04245044f, 0.14580445f, 0.00303951f, 0.00739369f, 0.00043360f, -0.14759803f, 0.08593100f, 
    -0.36910868f, -0.95003784f, -0.59114665f, 0.42091385f, -0.00300741f, -0.01023329f, 0.02489198f, 0.02543419f, 
    -0.02794457f, 0.00173633f, -0.04454663f, -0.06975652f, 0.04467843f, 0.13266474f, 0.10114995f, 0.23842426f, 
    0.24293278f, 0.08097020f, -0.05095011f, -0.05410489f, 0.01051147f, -0.00297346f, -0.26104268f, 0.10600950f, 
    0.02772566f, -0.26588058f, 0.15502140f, -0.00890222f, 0.19984928f, -0.11015520f, -0.09039900f, 0.07322244f, 
    0.10753199f, 0.00545784f, -0.16320254f, 0.00535203f, 0.02414510f, -0.06457115f, -0.11276754f, -0.07264774f, 
    -0.07488809f, -0.12900028f, -0.04751917f, -0.00304357f, 0.02403647f, 0.00356217f, -0.01456807f, -0.02566595f, 
    0.02801574f, -0.08675096f, 0.11809893f, -0.14665833f, -0.30805933f, 0.09708203f, 0.06530335f, 0.04764345f, 
    -0.03376772f, 0.11079864f, 0.04163124f, 0.09672251f, -0.21700141f, 0.03946986f, -0.14766794f, -0.10808977f, 
    0.05812627f, -0.04768011f, -0.06307848f, -0.00830193f, 0.12662506f, -0.15633143f, -0.10693185f, -0.06663667f, 
    -0.73291570f, 0.14084715f, 0.09698332f, 0.34726241f, 0.07101762f, -0.01472080f, -0.10001016f, -0.08818728f, 
    0.01383158f, -0.07192030f, 0.04335513f, -0.04596291f, -0.25802189f, 0.06689148f, -0.16947541f, 0.01011259f, 
    0.05306946f, 0.04390473f, 0.07048897f, 0.10858423f, -0.03954353f, 0.11250443f, 0.02371630f, -0.09778671f, 
    -0.42402989f, -0.02430843f, 0.02263948f, 0.05881789f, 0.04337447f, -0.17720523f, -0.13008411f, -0.04645094f, 
    0.11754405f, -0.13876994f, 0.01254805f, -0.10884491f, -0.08778241f, 0.25868228f, 0.09467290f, -0.06155902f, 
    0.04509452f, 0.04977662f, 0.04854914f, 0.08993053f, 0.03090048f, 0.15850572f, -0.14049588f, 0.22529006f, 
    -0.01024583f, -0.11345689f, 0.07725476f, 0.00561820f, 0.18918130f, -0.01289955f, 0.03769894f, 0.18928415f, 
    0.00487004f, -0.02212640f, -0.03003775f, 0.03007720f, -0.30496737f, 0.14111312f, -0.01584150f, -0.05667347f, 
    -0.06893103f, -0.11189279f, 0.16839105f, -0.01668023f, 0.10211334f, 0.04560903f, 0.04453073f, 0.13413721f, 
    -0.39511165f, 0.18032192f, 0.10472187f, -0.22756536f, 0.11407270f, -0.00575770f, -0.14608285f, -0.01605863f, 
    -0.13935265f, 0.03402549f, -0.09013301f, -0.14717574f, 0.11513054f, 0.30455288f, -0.12632975f, 0.35026926f, 
    0.04075462f, 0.13005817f, 0.10672773f, 0.19382231f, 0.02233885f, 0.19286834f, 0.10791948f, 0.10102969f, 
    -0.04014042f, -0.19149566f, 0.16650960f, 0.01023601f, 0.10292108f, 0.17477287f, 0.04610862f, -0.05459631f, 
    -0.00950237f, -0.09987184f, -0.06636937f, -0.15020858f, -0.48051912f, 0.39356336f, -0.16143708f, -0.18616760f, 
    -0.00729458f, -0.02054298f, 0.09117819f, 0.11107614f, -0.03776061f, 0.01493243f, -0.01753865f, 0.03542942f, 
    0.34808847f, 0.06118067f, -0.02440415f, -0.03135210f, 0.04650638f, -0.07041076f, -0.04591627f, 0.01963002f, 
    0.15220028f, -0.07737181f, 0.02562246f, -0.04592603f, 0.06465207f, 0.46056226f, 0.14074075f, 0.13151757f, 
    -0.01178739f, 0.01411452f, -0.01783360f, -0.03551273f, 0.04070917f, 0.12748969f, -0.11572856f, 0.05364906f, 
    -0.60528076f, -0.09768885f, 0.16056804f, 0.19976929f, -0.05957738f, 0.01542649f, 0.06622471f, 0.16697834f, 
    0.15293425f, -0.02040918f, 0.03963822f, -0.03698824f, 0.02289094f, -0.10082883f, -0.14284235f, 0.08364293f, 
    -0.03818758f, 0.13800289f, -0.07452725f, 0.02453764f, -0.08416065f, -0.01593159f, -0.10085712f, 0.09832022f, 
    -0.34957373f, 0.03407904f, 0.37226880f, 0.19011605f, -0.07051893f, -0.05998379f, 0.06309798f, -0.08273666f, 
    0.09453931f, 0.09581592f, -0.07283181f, 0.01244125f, -0.04740959f, -0.10887603f, -0.15563278f, 0.22281444f, 
    0.05246171f, 0.06575816f, 0.17315623f, -0.13740930f, -0.25354934f, -0.06747656f, -0.05120744f, -0.07135177f, 
    0.01944010f, -0.00728573f, 0.04585630f, -0.07521947f, 0.07798712f, 0.22322105f, 0.18277352f, 0.19728559f, 
    -0.00550294f, 0.11210911f, 0.12970720f, -0.00112958f, -0.06255931f, -0.00880838f, 0.16093141f, 0.27108636f, 
    -0.16966227f, 0.07426560f, -0.16173878f, -0.20589769f, 0.11932264f, 0.20365995f, 0.07263813f, 0.00065550f, 
    -0.92141014f, -0.16476896f, 0.09619295f, 0.35273540f, 0.01675147f, 0.03889579f, 0.02344136f, 0.12855610f, 
    -0.09250570f, 0.13560870f, 0.13681650f, 0.00515378f, 0.08462990f, -0.24333452f, 0.22514853f, -0.65715080f, 
    0.17329983f, 0.13399450f, 0.08414651f, -0.10102455f, 0.10674362f, -0.08397998f, 0.06138256f, -0.08191065f, 
    -0.17483805f, 0.15386114f, 0.07256607f, -0.10510887f, -0.10056747f, 0.07010131f, -0.05548264f, 0.17773594f, 
    -0.01825619f, -0.17181388f, 0.10000973f, 0.09558895f, -0.13607393f, -0.27258795f, 0.04944243f, 0.00104668f, 
    0.06921354f, 0.11703855f, 0.03033691f, -0.00743785f, 0.03867947f, -0.21609458f, -0.09260006f, -0.10751913f, 
    -0.08312943f, -0.01768487f, 0.09658141f, -0.08974677f, 0.04134147f, -0.27719781f, -0.16958942f, -0.00128914f, 
    -0.04142294f, -0.02421284f, 0.03614489f, 0.03012940f, 0.04804469f, 0.02888913f, -0.22839122f, 0.05411179f, 
    -0.20190063f, -0.13318893f, 0.11657938f, 0.16330315f, -0.03019480f, 0.05542189f, -0.03503282f, 0.08055145f, 
    -0.11189549f, 0.05191738f, -0.31517047f, -0.21715094f, 0.04803761f, 0.03725354f, 0.16434920f, 0.11803548f, 
    -0.07420536f, -0.26000261f, 0.08413472f, 0.01489652f, -0.01281038f, 0.03450684f, -0.24944188f, 0.13925844f, 
    0.02081667f, -0.13664491f, 0.06376209f, -0.01646399f, 0.02202046f, 0.05154076f, -0.00345538f, -0.00187346f, 
    -0.31320974f, -0.21264441f, 0.06966263f, -0.06849640f, -0.10407808f, 0.04663884f, -0.12031939f, 0.04016484f, 
    0.14241260f, -0.08512880f, -0.15216184f, -0.19599302f, -0.14469288f, -0.12376757f, 0.14832732f, 0.13404801f, 
    -0.15218392f, -0.10043956f, -0.16704941f, 0.03401284f, 0.05448695f, 0.08473518f, -0.06620415f, 0.08784609f, 
    0.17386116f, -0.18055290f, -0.17724532f, 0.03085813f, -0.02634458f, -0.18535560f, -0.07292338f, -0.03012370f, 
    0.13248309f, -0.13763428f, -0.17697708f, -0.05604722f, 0.17648433f, 0.06761723f, 0.12384214f, 0.22713777f, 
    0.07987685f, 0.18485238f, 0.02761412f, 0.08508791f, 0.09165384f, -0.10354534f, 0.01038523f, -0.04215901f, 
    0.12650937f, 0.19402823f, 0.10499169f, 0.19967020f, 0.09458328f, 0.15361196f, 0.05071353f, -0.16084200f, 
    -0.16312131f, -0.09221686f, -0.11228138f, 0.18597446f, -0.63128126f, -0.09227396f, -0.04777645f, -0.19476642f, 
    0.08983168f, 0.22256790f, 0.07952987f, 0.12393421f, 0.07008824f, 0.15618376f, 0.03418921f, 0.10234962f, 
    -0.40856478f, 0.03854487f, -0.28463843f, -0.05408563f, 0.02267098f, 0.10908244f, -0.04181972f, -0.31406650f, 
    0.11656654f, -0.10765173f, -0.08116265f, -0.05709696f, -0.32937425f, 0.03817400f, -0.10181578f, -0.39484668f, 
    0.18386172f, 0.10264952f, -0.05277711f, -0.03412607f, 0.11430472f, -0.11205471f, -0.01495225f, 0.04284840f, 
    0.14611746f, -0.02574709f, -0.00572036f, 0.05668698f, -0.08125837f, 0.18235412f, -0.01007580f, -0.08010510f, 
    -0.24534732f, 0.13357510f, 0.06556866f, 0.21221392f, -0.54129171f, -0.46762159f, -0.05733298f, 0.19255397f, 
    0.07899213f, -0.17521064f, 0.00014784f, -0.01360274f, 0.06578249f, -0.05129506f, 0.03479040f, -0.05186599f, 
    -0.51539171f, 0.00284036f, -0.10752699f, 0.19253629f, 0.14408377f, -0.04620998f, 0.17174542f, 0.16960537f, 
    0.13259298f, -0.17273636f, 0.11267209f, -0.09921708f, -0.07326742f, -0.00391718f, 0.09271966f, -0.24781522f, 
    0.03170486f, -0.12616436f, 0.00129029f, -0.06613559f, -0.17905419f, 0.00420033f, -0.19423310f, 0.07254845f, 
    -0.03327650f, -0.01210032f, 0.05064635f, 0.16040601f, -0.04480820f, 0.22406030f, -0.02912588f, 0.01435300f, 
    -0.20538270f, -0.02938304f, -0.01031790f, 0.11985651f, -0.67488027f, -0.39491636f, -0.11547117f, 0.26604709f, 
    0.09345908f, -0.00120414f, -0.18799305f, -0.10551425f, 0.04138947f, 0.13711962f, 0.04619288f, -0.00266330f, 
    0.15033680f, -0.05323269f, 0.07355247f, 0.27967539f, 0.07151648f, -0.02270904f, 0.01703480f, -0.04697735f, 
    0.16113602f, 0.01937215f, -0.12303422f, 0.09939424f, -0.71251249f, 0.38523605f, 0.08146738f, 0.00180464f, 
    0.10217501f, -0.17196152f, -0.15062119f, -0.12109891f, -0.08329727f, -0.01691385f, 0.12158252f, -0.08692811f, 
    -0.04634410f, 0.10624236f, 0.07653327f, -0.09770334f, 0.04555900f, -0.06954709f, 0.07568598f, 0.00704838f, 
    0.16931254f, 0.06859671f, -0.10851213f, 0.30218536f, -0.20767209f, 0.01497369f, -0.17849539f, 0.09709040f, 
    0.05422124f, -0.08341990f, -0.10272205f, 0.10219376f, 0.08512264f, 0.03300529f, 0.10330944f, 0.18316723f, 
    0.31759372f, -0.31765416f, -0.17809673f, -0.08018999f, -0.08143355f, -0.13036583f, -0.23191126f, -0.13778533f, 
    -0.13101433f, -0.08407628f, 0.00132306f, -0.04877260f, -0.00131535f, -0.05183617f, -0.19550301f, -0.13569696f, 
    0.00148666f, -0.05793311f, 0.04315379f, -0.04326169f, 0.12496236f, 0.07448490f, -0.07532416f, -0.12977269f, 
    0.25906417f, -0.05091764f, -0.08577909f, 0.06592981f, -0.09091480f, 0.00814401f, 0.03525128f, 0.11273915f, 
    0.07524401f, 0.01625473f, 0.10540276f, 0.23506890f, 0.04070894f, -0.10842567f, -0.04860727f, -0.55833697f, 
    -0.10862682f, 0.07407371f, -0.13293329f, -0.16436578f, 0.08196329f, -0.04515783f, -0.00915585f, -0.18182480f, 
    0.00561810f, -0.09029998f, -0.10906788f, -0.01082556f, 0.16930161f, 0.01193987f, -0.06047948f, -0.02989485f, 
    0.03795112f, 0.07587764f, -0.04012395f, -0.26009172f, 0.15266429f, 0.10364933f, 0.17903155f, 0.31445342f, 
    -0.06791523f, -0.05061118f, -0.00819425f, 0.18151100f, -0.16527130f, -0.09318508f, 0.10513414f, 0.03107459f, 
    0.07493886f, 0.26654229f, -0.55398643f, -0.18601911f, -0.00637768f, 0.17595725f, -0.05409703f, -0.08036842f, 
    0.00660010f, -0.06038054f, -0.18689772f, -0.13590160f, -0.45138019f, 0.20455521f, 0.53543437f, -0.02772699f, 
    -0.13532868f, 0.13465284f, -0.00951845f, 0.02693884f, -0.07927360f, -0.01782412f, 0.01851924f, -0.12278021f, 
    -0.16617467f, -0.14050411f, 0.15209830f, 0.25322285f, 0.10702050f, 0.17557369f, 0.13542587f, 0.03679042f, 
    0.00005045f, -0.20111786f, 0.11612902f, 0.07088400f, 0.20718719f, -0.08757666f, 0.15732312f, -0.01562379f, 
    -0.15808178f, -0.17770182f, 0.06197558f, 0.03499162f, -0.06055798f, 0.15893410f, 0.04120259f, 0.19336611f, 
    -0.00287341f, 0.08564088f, 0.03331575f, 0.08033789f, 0.03348115f, 0.18952483f, -0.02103052f, -0.10350426f, 
    -0.09979578f, -0.27337837f, 0.20214131f, -0.13614659f, -0.15599786f, 0.15401751f, 0.36146685f, -0.00652495f, 
    0.00442020f, 0.02534416f, 0.03114385f, -0.09907451f, 0.20724015f, -0.06202160f, -0.03361904f, -0.19117653f, 
    -0.04144422f, -0.26281315f, 0.00374221f, 0.06257644f, 0.04081007f, 0.06489810f, 0.16151330f, 0.03913096f, 
    0.14523765f, 0.03747961f, -0.02622966f, 0.07881793f, -0.00621518f, -0.14122996f, 0.07452588f, -0.43786737f, 
    0.00436841f, 0.12030674f, -0.15297057f, -0.01908090f, 0.14829250f, 0.03602167f, 0.17079556f, 0.04777265f, 
    0.17288467f, 0.08366287f, -0.08594568f, 0.04899199f, 0.09032345f, 0.11070111f, -0.06067617f, 0.14974189f, 
    0.08907724f, 0.03012946f, 0.06482408f, 0.04525561f, 0.12180212f, -0.10135108f, -0.13064469f, -0.02563995f, 
    0.05607819f, -0.17625567f, 0.02484061f, 0.00133232f, -0.24471900f, 0.13135606f, 0.11983828f, 0.07763570f, 
    -0.42547002f, -0.17846595f, 0.17680983f, 0.10234995f, 0.02901376f, -0.02993344f, 0.13656339f, 0.00874235f, 
    0.00186895f, -0.03106451f, -0.07921863f, 0.07347768f, -0.17163187f, -0.06964160f, 0.01088964f, -0.03163420f, 
    0.01110591f, -0.15817717f, -0.07384930f, -0.17688431f, -0.02379237f, 0.05764463f, 0.00259299f, 0.25246355f, 
    -0.66570228f, 0.41280743f, 0.11754249f, 0.18581603f, 0.01698577f, 0.09439762f, 0.20894618f, 0.03450131f, 
    0.08976551f, 0.14182656f, 0.20874016f, -0.03843636f, -0.07039081f, -0.24813110f, 0.06873520f, -0.23372440f, 
    0.02355293f, 0.00954734f, -0.08815745f, -0.15213574f, -0.11908285f, 0.04453467f, -0.06451869f, -0.11979236f, 
    -0.17823057f, -0.42258400f, -0.04756857f, -0.42812821f, -0.08910093f, 0.02265250f, 0.08948098f, 0.08537696f, 
    0.03460751f, 0.02837314f, 0.12123600f, 0.15705135f, 0.04945183f, -0.03927578f, -0.09572131f, 0.00535734f, 
    -0.10934412f, 0.04140944f, 0.08509228f, -0.05356272f, 0.04609809f, 0.05362948f, 0.01002985f, -0.11976714f, 
    0.16344549f, 0.14336917f, -0.03468991f, -0.26990202f, -0.02859605f, -0.04520119f, 0.02965336f, -0.01930431f, 
    0.08861556f, -0.33982280f, -0.00108717f, -0.19720218f, 0.25655460f, -0.01163625f, -0.17649089f, 0.05209718f, 
    -0.16455564f, 0.10152992f, 0.00292366f, 0.01385722f, 0.00118660f, 0.00180275f, -0.06862009f, 0.11184934f, 
    -0.14935705f, 0.08064810f, -0.25879583f, -0.28153074f, -0.08593722f, 0.00223289f, -0.01572099f, -0.13770780f, 
    -0.10823507f, 0.18500069f, -0.22806427f, -0.05015582f, 0.23895873f, 0.11673363f, -0.03777782f, 0.02528323f, 
    0.09312846f, 0.03652336f, -0.06344476f, 0.00509048f, 0.08451003f, -0.05837966f, 0.15906851f, 0.00378971f, 
    0.29278821f, -0.07204773f, 0.08718086f, 0.01503211f, 0.04219485f, -0.14807267f, 0.12989528f, -0.14485809f, 
    -0.09107485f, -0.00034086f, 0.27303448f, -0.37022886f, -0.52762949f, 0.11480326f, 0.01431672f, -0.12693432f, 
    0.00809079f, 0.06472322f, 0.17109218f, -0.03977910f, 0.21356480f, -0.09746591f, 0.06685541f, -0.01899154f, 
    0.10467673f, -0.31720269f, -0.64830130f, 0.26177457f, -0.08613260f, 0.04812235f, -0.09081350f, -0.09746220f, 
    0.10113304f, -0.06552032f, -0.02770287f, -0.14678003f, 0.37390414f, -0.68908978f, 0.14167337f, -0.21758415f, 
    -0.02627294f, 0.14803424f, 0.05653602f, 0.03928380f, 0.06160070f, -0.00570421f, -0.09005926f, 0.09493055f, 
    0.03213541f, 0.21320778f, 0.22849949f, -0.59064144f, -0.24149258f, 0.13598029f, -0.01234039f, 0.11051682f, 
    0.00638385f, -0.07105735f, 0.17710602f, -0.19703355f, -0.23622181f, -0.12573729f, 0.17439096f, 0.02862334f, 
    0.16230465f, -0.00633708f, -0.06832919f, 0.03174634f, -0.17350610f, -0.05321764f, -0.07583348f, -0.28309059f, 
    -0.61683995f, 0.29625922f, -0.07256195f, 0.46544024f, 0.08371259f, 0.18488455f, 0.19138931f, 0.10266384f, 
    -0.09881634f, 0.07128792f, 0.04831534f, 0.08632056f, -0.31615677f, 0.27117071f, 0.04359743f, -0.08686715f, 
    -0.10396707f, 0.13751931f, 0.08189308f, 0.09812919f, -0.00732247f, 0.26799434f, 0.00791648f, 0.14872387f, 
    0.15359138f, -0.04058033f, 0.10776440f, -0.25459987f, 0.19846468f, 0.03853819f, 0.04846176f, 0.01676198f, 
    -0.06417172f, -0.05893127f, -0.05879211f, -0.06614526f, -0.55556381f, -0.01844040f, 0.21884516f, -0.02642791f, 
    -0.05460752f, -0.14181703f, -0.05550988f, 0.05449447f, -0.00528127f, 0.02515339f, 0.02242393f, 0.19343826f, 
    0.07403418f, 0.01198029f, 0.14280304f, -0.42108718f, -0.07032071f, -0.04678282f, 0.09115579f, -0.03733915f, 
    -0.07998911f, -0.03841735f, 0.07665652f, 0.17671016f, -0.21064594f, 0.17758612f, 0.08519029f, -0.00501355f, 
    0.05990706f, 0.03082023f, -0.00689410f, 0.06109217f, -0.05728148f, 0.11208267f, -0.01454700f, 0.05770339f, 
    -0.03327212f, -0.33547223f, -0.02266269f, -0.23489389f, -0.11190823f, 0.11492720f, -0.06493669f, 0.04537847f, 
    -0.05549760f, 0.03733023f, 0.09646942f, 0.35356393f, 0.40947717f, 0.06764828f, 0.39722401f, 0.50302035f, 
    -0.05689656f, -0.11903515f, -0.05997520f, 0.03837488f, 0.05164785f, -0.04997544f, -0.01140829f, 0.18636818f, 
    0.14238510f, -0.08293205f, 0.08950247f, -0.16094692f, -0.19328523f, 0.11737718f, 0.04814543f, 0.08007764f, 
    0.08226744f, 0.02741805f, -0.11166827f, 0.02730300f, -0.03048833f, -0.17496973f, -0.00198718f, -0.22447191f, 
    0.01226569f, 0.14505222f, 0.20260483f, -0.02480189f, 0.17033292f, -0.09554403f, 0.00572988f, -0.14708513f, 
    0.09802464f, 0.00728972f, 0.03383964f, -0.10664890f, -0.07899404f, 0.11684033f, 0.02946656f, 0.21622621f, 
    0.19198269f, 0.20545055f, -0.02379310f, 0.23505622f, 0.25249562f, -0.12156944f, -0.00363033f, -0.19365485f, 
    0.04440218f, 0.15419750f, 0.15376043f, 0.16556481f, -0.26061863f, 0.00022445f, 0.08117681f, 0.11905973f, 
    0.05913433f, 0.03918589f, -0.15447031f, -0.00432081f, 0.05128686f, -0.18242025f, 0.05579697f, -0.17530151f, 
    0.10415414f, 0.01453603f, 0.03900310f, -0.12958777f, 0.11697094f, 0.09569851f, -0.11163146f, -0.35719803f, 
    0.06859127f, 0.05907137f, -0.00778900f, -0.19811043f, -0.19585443f, -0.14207244f, -0.04090792f, -0.01010595f, 
    -0.11683497f, 0.30234924f, 0.13705438f, -0.21257484f, -0.10161916f, 0.11178627f, -0.10989588f, 0.06086515f, 
    0.10159504f, 0.02850610f, -0.14851660f, -0.00006006f, -0.04161393f, 0.19937696f, -0.02534487f, -0.27102357f, 
    0.11610953f, 0.03123815f, 0.09318517f, -0.11141182f, -0.11111841f, -0.20654973f, 0.12957864f, -0.12301875f, 
    -0.31342372f, -0.04083670f, -0.26686248f, 0.30875897f, 0.00433608f, 0.04436441f, -0.04740432f, -0.10835507f, 
    -0.01803019f, -0.18766442f, -0.09481122f, -0.08928151f, -0.19837455f, 0.00011753f, -0.23833027f, -0.04986433f, 
    -0.22411890f, -0.10929693f, -0.15961672f, -0.16510671f, 0.02323924f, -0.02606143f, -0.12485721f, -0.09201110f, 
    0.01326534f, 0.03785309f, -0.04832088f, -0.24076557f, 0.00163646f, 0.06171015f, 0.06477309f, -0.03908807f, 
    -0.07414873f, -0.11510392f, -0.01269763f, -0.15367527f, -0.09738887f, 0.14619204f, 0.15719512f, 0.03131276f, 
    0.14762065f, 0.17348248f, 0.00746531f, -0.01064156f, -0.14760278f, -0.04091647f, 0.02134478f, 0.03403927f, 
    -0.14080164f, 0.22355872f, 0.23488832f, 0.07727919f, 0.08201605f, 0.15350790f, 0.06773829f, -0.11486592f, 
    -0.10017513f, 0.03986549f, -0.04429593f, -0.04922938f, 0.05233027f, -0.13153984f, 0.28045857f, -0.11481465f, 
    0.04240372f, 0.09636839f, 0.00590712f, -0.11273948f, -0.08649648f, 0.07661987f, 0.03291332f, -0.02386161f, 
    -0.39972568f, -0.07784842f, -0.33345389f, -0.01813180f, -0.04589930f, -0.16855763f, -0.03096440f, -0.10746884f, 
    0.01685623f, 0.00949584f, -0.02434263f, -0.00259701f, 0.05431883f, 0.07679428f, 0.06031987f, 0.15725608f, 
    -0.05630204f, -0.08654144f, 0.06144248f, 0.00421060f, -0.00152157f, 0.09541091f, 0.00426257f, 0.07119340f, 
    0.15337278f, 0.18049896f, 0.09228496f, 0.25490823f, 0.12692632f, 0.14118496f, 0.07121914f, -0.07089940f, 
    -0.06182654f, 0.00196778f, 0.04858955f, -0.14987136f, -0.13426530f, -0.23559138f, 0.10448406f, -0.07206299f, 
    -0.16242404f, -0.05324836f, -0.02091072f, 0.09342651f, -0.04061815f, -0.04640494f, -0.04285655f, 0.03844386f, 
    0.32030866f, -0.16155289f, 0.19117253f, 0.07963051f, 0.02047083f, -0.19021234f, 0.04694997f, -0.04318864f, 
    0.08991184f, -0.03613474f, -0.11382332f, 0.06211968f, 0.29020396f, 0.17016663f, 0.23011345f, 0.07382181f, 
    -0.13508426f, -0.01757136f, 0.02000890f, -0.17400172f, -0.04490265f, -0.07265538f, -0.13579866f, 0.00817141f, 
    -0.18379025f, 0.13490401f, -0.32960880f, 0.42317846f, -0.06643160f, -0.06239362f, 0.01606452f, 0.05740121f, 
    0.12195139f, -0.04007214f, -0.00966783f, -0.09459446f, 0.17394848f, -0.28226984f, -0.00388335f, -0.17514767f, 
    -0.14100295f, -0.05245340f, -0.01822989f, -0.05037131f, -0.10491393f, 0.00436269f, -0.01299826f, -0.08228209f, 
    -0.33786279f, 0.14006475f, -0.15584895f, -0.15955710f, -0.00048923f, 0.04213548f, -0.11460215f, -0.09757698f, 
    -0.04351385f, -0.04992856f, 0.00315815f, -0.14437126f, -0.10143334f, 0.11225565f, 0.04272522f, -0.01154457f, 
    -0.20178290f, 0.14936088f, -0.01920193f, 0.00565977f, -0.02351934f, -0.05126171f, -0.03713917f, -0.11294653f, 
    -0.22005659f, -0.04701874f, -0.12389604f, -0.11887937f, -0.10770609f, 0.10730483f, -0.14058222f, -0.00024951f, 
    0.02714910f, -0.08252750f, -0.04386119f, 0.02596187f, -0.16845366f, 0.27299330f, -0.38362339f, -0.08913982f, 
    -0.05348567f, -0.05665279f, 0.02217886f, -0.08732845f, -0.05937900f, 0.02972924f, 0.08505597f, -0.04991107f, 
    0.33210388f, -0.77516836f, 0.33925867f, 0.12546554f, 0.08834041f, -0.11862837f, -0.06921151f, -0.00219278f, 
    -0.05748355f, 0.01932316f, -0.03003835f, -0.00841790f, -0.02978195f, -0.02649168f, -0.04242654f, 0.18119526f, 
    0.00680105f, -0.04181988f, 0.04112312f, -0.10315710f, 0.01009608f, 0.15148123f, -0.10587905f, -0.10903740f, 
    0.12978654f, -0.02827015f, 0.17816737f, -0.01151927f, 0.04448421f, 0.10953010f, -0.10819408f, -0.11374059f, 
    -0.10287789f, 0.06237706f, 0.01918034f, -0.09282813f, -0.13125290f, -0.25400391f, -0.17627120f, 0.20775209f, 
    -0.02253002f, -0.09458333f, -0.07331184f, -0.00353071f, -0.16954091f, 0.01705982f, 0.20545740f, 0.02670266f, 
    0.02558886f, 0.39788187f, 0.22366199f, 0.20106284f, 0.07878377f, 0.11618290f, 0.00642810f, 0.01324143f, 
    -0.06675182f, 0.08007020f, 0.10850367f, -0.05194928f, -0.20868582f, 0.06253514f, -0.04601876f, 0.12329769f, 
    -0.03265190f, -0.23948419f, 0.07885487f, -0.01871259f, -0.03672335f, 0.09978722f, 0.04255070f, -0.12335455f, 
    -0.56539661f, 0.19011968f, -0.07791518f, 0.01304115f, -0.04978656f, -0.09633628f, 0.06510934f, -0.05375636f, 
    -0.14361191f, 0.11305578f, -0.08873004f, -0.05673081f, 0.34046608f, -0.09976893f, -0.01696015f, 0.12596042f, 
    0.02386671f, -0.15783173f, 0.07837443f, -0.09105103f, -0.02590766f, -0.07810440f, -0.01199194f, -0.16261128f, 
    0.26484475f, -0.21282987f, 0.26544490f, 0.14494641f, -0.33061978f, -0.08007991f, -0.01430832f, -0.18939954f, 
    0.10307875f, -0.03289659f, -0.08178282f, -0.08740397f, -0.33460489f, 0.08839551f, -0.06761237f, -0.17021094f, 
    -0.07569396f, -0.12195996f, -0.11028470f, -0.13444464f, -0.02652418f, -0.10110422f, -0.10563204f, -0.07276409f, 
    -0.02269039f, 0.08140218f, 0.22676663f, 0.24823673f, 0.01629740f, 0.10311358f, 0.02571008f, 0.07829143f, 
    -0.13564548f, 0.00828254f, -0.05676482f, -0.05258899f, 0.19317885f, 0.18992271f, 0.06777533f, 0.21601401f, 
    -0.07097931f, -0.03908020f, -0.01070991f, -0.01117194f, -0.05031447f, 0.11779317f, 0.07451084f, -0.01115166f, 
    -0.25914943f, 0.09511225f, -0.19251032f, -0.65626454f, 0.02991257f, -0.07544522f, -0.04355572f, -0.03501157f, 
    -0.08900770f, 0.01283918f, -0.09484752f, -0.05997301f, 0.16704556f, 0.06532965f, -0.24114327f, -0.08409870f, 
    -0.02804991f, -0.06015009f, -0.10841963f, -0.05956997f, -0.10066080f, 0.07551900f, -0.00339925f, -0.04529856f, 
    0.25515026f, 0.04800078f, 0.15785858f, 0.29974964f, 0.01610433f, -0.06867499f, 0.01891770f, -0.16297351f, 
    -0.09011419f, -0.08938249f, -0.13877250f, -0.10781524f, 0.11212250f, 0.24122058f, 0.08037043f, 0.21697944f, 
    0.15654851f, 0.06309471f, 0.00026025f, -0.05984338f, -0.01517184f, -0.05364907f, -0.00607290f, -0.14719395f, 
    0.00645664f, 0.11654323f, -0.11011522f, -0.04051156f, 0.23120601f, 0.04628161f, -0.10629874f, 0.01671905f, 
    -0.05548374f, 0.07005787f, -0.05652446f, 0.02004686f, -0.13972865f, -0.13186561f, 0.27116254f, -0.02204201f, 
    0.10700214f, 0.06490138f, -0.13373135f, -0.04614310f, 0.04427597f, 0.02627724f, 0.07973616f, -0.08870512f, 
    -0.07096990f, -0.03899232f, 0.32297075f, 0.16587943f, -0.12745221f, -0.05293354f, -0.13917193f, -0.13757718f, 
    0.06644447f, -0.02901532f, 0.00007597f, -0.09444593f, -0.39733598f, -0.04154602f, 0.17477474f, -0.10547439f, 
    0.01535763f, 0.00376388f, -0.14162436f, -0.12268547f, 0.02261022f, -0.00464411f, -0.03328029f, 0.15103689f, 
    0.02251227f, 0.05164104f, -0.16295417f, 0.12612131f, -0.15859389f, 0.04981079f, -0.04519727f, 0.01445361f, 
    0.04169647f, 0.08603479f, -0.02203107f, 0.00633410f, -0.00220748f, 0.10341389f, 0.25069675f, -0.00619533f, 
    -0.01710409f, -0.11113898f, -0.01154465f, 0.00548086f, -0.04879317f, -0.08336841f, 0.16524948f, -0.00759544f, 
    -0.30789867f, -0.15130350f, 0.26504511f, -0.10987969f, 0.02114000f, -0.05425626f, 0.16708831f, -0.19211683f, 
    -0.01407152f, 0.07978236f, 0.05236377f, 0.04371785f, -0.30071771f, 0.09770516f, -0.06286966f, 0.05782452f, 
    -0.00002556f, 0.05680283f, -0.07789334f, -0.17001326f, 0.04741582f, 0.06697217f, -0.05528419f, 0.22198239f, 
    0.25035360f, -0.30389977f, -0.32063177f, -0.04755428f, 0.03821866f, -0.09862670f, -0.01743149f, -0.16875628f, 
    0.03203678f, 0.00013765f, 0.17850870f, 0.17131646f, -0.35367078f, 0.14565848f, 0.29239863f, -0.14388531f, 
    0.19819112f, 0.03499353f, -0.25429684f, 0.05999194f, 0.01013622f, 0.04646952f, 0.21852286f, 0.00453262f, 
    0.09544753f, 0.42020148f, -0.50297314f, -0.42188084f, -0.07879886f, -0.03565868f, -0.09022820f, -0.16481483f, 
    0.15508252f, -0.05036866f, 0.02491137f, 0.15634049f, 0.18741503f, 0.02003799f, 0.24758524f, 0.01721661f, 
    -0.04123420f, -0.18173568f, -0.00910568f, -0.07073858f, -0.06988999f, -0.06499981f, 0.07728568f, -0.03326190f, 
    0.10773858f, -0.02996712f, 0.14524153f, 0.34303913f, 0.11588923f, -0.00025304f, 0.06391323f, -0.09132724f, 
    0.00714750f, 0.15017591f, 0.02745135f, -0.00767151f, 0.16792721f, 0.34053588f, -0.06613160f, -0.16889973f, 
    -0.18240426f, -0.01888358f, -0.04440523f, 0.02421977f, 0.20434420f, -0.10514845f, 0.14469883f, 0.01802970f, 
    0.37796015f, 0.31562957f, -0.38961184f, 0.04226367f, 0.06990236f, -0.06489568f, -0.13882229f, -0.12860966f, 
    -0.10203448f, 0.05683732f, -0.30704138f, 0.04138920f, -0.04418568f, -0.15653458f, 0.16935104f, 0.21177754f, 
    0.07843567f, -0.06055410f, -0.12209554f, 0.03253158f, 0.15136617f, -0.12417662f, 0.04883381f, -0.10053999f, 
    0.10948248f, -0.11717950f, -0.23821749f, -0.00942837f, 0.02864552f, -0.12348930f, -0.01728300f, 0.07072660f, 
    0.17829144f, 0.07163768f, 0.04427673f, 0.15400174f, 0.09541383f, 0.22850300f, 0.00035587f, 0.22089486f, 
    -0.05805329f, 0.07599569f, -0.08536585f, 0.00292533f, 0.03726741f, -0.01390025f, 0.12092650f, 0.01064699f, 
    -0.28854075f, -0.16106768f, 0.05647561f, -0.03629686f, -0.11262669f, -0.12159079f, 0.04192695f, 0.15917784f, 
    -0.09112489f, -0.03643754f, 0.14980471f, -0.04214191f, -0.24288873f, -0.26571584f, -0.06445113f, -0.09660392f, 
    0.08544704f, 0.12584952f, -0.10556338f, -0.05252143f, 0.14158344f, 0.05655306f, -0.02170083f, 0.02007548f, 
    0.05032374f, 0.02536739f, 0.10008170f, 0.12200939f, -0.13056612f, -0.05349801f, 0.15759084f, -0.01369794f, 
    0.04096913f, -0.00084217f, -0.31530884f, -0.09452147f, 0.07726514f, -0.31811205f, -0.16152026f, -0.24636558f, 
    -0.01096821f, -0.20369938f, -0.35209945f, -0.05037103f, 0.07696133f, 0.02347368f, -0.12109188f, -0.00709892f, 
    -0.02610083f, -0.02576667f, -0.20800576f, 0.21443170f, 0.06250970f, 0.07983937f, -0.03657681f, 0.02703590f, 
    0.14721361f, -0.13330205f, 0.18411897f, -0.15352577f, -0.09382571f, -0.23237023f, -0.00627530f, -0.49712405f, 
    -0.04099311f, -0.14412339f, 0.02691368f, 0.03507440f, 0.08257672f, 0.24297087f, -0.10314135f, 0.13741298f, 
    -0.17735219f, 0.05795356f, -0.34296104f, -0.08046142f, -0.09798261f, -0.02650023f, 0.07742279f, -0.27945793f, 
    0.11479549f, -0.17477843f, -0.06479346f, 0.05787470f, 0.31188491f, 0.02931876f, -0.03682668f, 0.17589822f, 
    0.00755382f, -0.12726806f, -0.15011841f, -0.15304750f, 0.02435032f, -0.17663263f, -0.18367735f, -0.11605090f, 
    -0.28694293f, 0.17666352f, 0.11820658f, -0.29577196f, 0.01652753f, 0.09620334f, -0.09622168f, -0.08858828f, 
    -0.06640838f, -0.03461676f, 0.08853363f, -0.17585471f, -0.21629116f, -0.31800279f, 0.08183663f, -0.14792140f, 
    -0.24142118f, -0.14421763f, -0.10613015f, 0.09337734f, 0.01463487f, 0.03988951f, -0.02724663f, -0.04587349f, 
    0.07166180f, -0.09871812f, -0.03914922f, 0.07235318f, 0.20474415f, -0.00465232f, -0.01379040f, -0.06739213f, 
    -0.07526772f, -0.04173670f, 0.11093055f, 0.05405939f, -0.21186465f, -0.11282054f, 0.00395140f, -0.20327753f, 
    0.01826124f, -0.06226560f, 0.04080963f, -0.06362929f, 0.15263657f, 0.03486062f, 0.06560224f, -0.08253710f, 
    0.30177957f, 0.26590168f, -0.20589577f, 0.00751354f, -0.06593193f, -0.00264244f, -0.01559811f, -0.11286615f, 
    -0.02941526f, -0.03971578f, 0.01733762f, 0.21713455f, -0.22844583f, -0.17022826f, 0.08361378f, -0.24525699f, 
    -0.20650323f, -0.04318776f, -0.04528712f, -0.19634539f, -0.10884596f, 0.12550199f, 0.02424395f, 0.08894630f, 
    0.09758347f, -0.26787770f, 0.21162471f, -0.15256447f, 0.03414969f, -0.01350714f, -0.08275180f, 0.00855297f, 
    0.08303009f, 0.04931645f, 0.05661649f, -0.11872651f, -0.05249381f, -0.32954028f, -0.12907985f, 0.46794623f, 
    0.05117020f, -0.22744261f, 0.04621604f, -0.10086720f, -0.06274930f, -0.14326105f, -0.07642563f, 0.14108470f, 
    -0.14081165f, -0.24733326f, 0.07878868f, -0.07692255f, 0.07569595f, 0.07732901f, 0.01611479f, 0.22379091f, 
    -0.12197471f, 0.18484443f, -0.12951235f, 0.02933007f, -0.00007130f, -0.05215936f, -0.02904515f, 0.37281570f, 
    0.04820143f, -0.07371365f, -0.04845205f, -0.07156178f, 0.06897034f, 0.07028874f, 0.01922303f, -0.03415477f, 
    -0.05413284f, 0.43573093f, -0.17640452f, -0.35160542f, 0.03148466f, 0.04047279f, 0.13410296f, 0.09513064f, 
    0.01942450f, 0.02052800f, 0.00350368f, -0.08473019f, 0.24674118f, 0.03478273f, 0.06320299f, 0.12081239f, 
    0.07091323f, 0.01681977f, -0.24786316f, 0.12986389f, 0.25097904f, -0.01303032f, 0.12562330f, -0.11210557f, 
    -0.13966724f, -0.25464526f, 0.00705804f, -0.09628022f, 0.09680763f, 0.12081150f, 0.00193988f, -0.07769975f, 
    0.03608194f, 0.13836367f, -0.00570199f, -0.04789313f, -0.14039072f, -0.03738304f, -0.15981519f, 0.14466821f, 
    0.05557371f, 0.04523947f, -0.06937297f, 0.01583945f, 0.07997645f, -0.00433717f, 0.05455104f, -0.25857815f, 
    -0.13032907f, 0.00383688f, 0.06849185f, -0.15520754f, 0.02686555f, 0.04911084f, -0.08161294f, 0.11473247f, 
    0.08325316f, -0.01524451f, 0.04491839f, 0.07234813f, -0.04571400f, -0.56711894f, -0.08962683f, -0.21120052f, 
    0.03679073f, 0.00596659f, -0.04569343f, -0.23420168f, -0.08461989f, -0.10996506f, -0.22158463f, -0.07654345f, 
    0.02645945f, 0.34535503f, 0.23831165f, 0.02140547f, 0.08998352f, -0.06308440f, -0.10050274f, -0.01237185f, 
    -0.04636449f, -0.13664769f, 0.18624613f, 0.01331476f, 0.61436963f, 0.11961877f, -0.04293944f, 0.03860167f, 
    0.28131208f, -0.06931624f, 0.10339098f, 0.00156250f, -0.04271478f, -0.02712671f, 0.06665310f, 0.21051660f, 
    -0.30369291f, 0.28179628f, -0.38339117f, -0.40095469f, 0.18734244f, 0.04283865f, 0.07046748f, 0.03667250f, 
    -0.14050046f, -0.19999543f, -0.00047226f, -0.14163816f, -0.34206262f, 0.28176561f, -0.14375578f, 0.09912963f, 
    0.09364756f, 0.05518653f, 0.22377950f, -0.12046725f, 0.00335544f, 0.00632977f, -0.17353788f, -0.10105924f, 
    0.31370008f, -0.07776652f, 0.38092607f, 0.07986131f, 0.02606706f, 0.10671064f, 0.03475256f, 0.01935095f, 
    0.23267888f, 0.05533296f, 0.05610719f, 0.09259406f, -0.53212619f, 0.48154905f, 0.18300849f, -0.37991202f, 
    -0.06477120f, 0.04162013f, 0.04194348f, 0.10495055f, -0.05744572f, -0.18521082f, 0.06584695f, 0.04070697f, 
    0.29581758f, -0.29980159f, 0.13397206f, -0.12825710f, -0.14457797f, 0.16275194f, -0.11720385f, 0.02539076f, 
    -0.04333142f, -0.03208071f, 0.05865614f, -0.16664237f, -0.52816051f, 0.69272554f, -0.01273104f, 0.24856332f, 
    0.06056326f, 0.04506456f, -0.22243191f, 0.10962765f, 0.10067119f, -0.00902339f, 0.06010806f, 0.06086006f, 
    0.00809595f, -0.00122428f, 0.14922960f, 0.36006221f, -0.04380840f, -0.06138869f, -0.03497322f, -0.07430045f, 
    -0.02579161f, -0.01956425f, -0.15691867f, -0.00522751f, 0.04802248f, -0.38846701f, -0.00556339f, -0.31332490f, 
    0.13778475f, 0.18260013f, -0.12582894f, -0.05559259f, -0.04926791f, -0.05056426f, 0.14550692f, -0.00343813f, 
    -0.14831705f, -0.16016103f, -0.12021802f, -0.12511036f, 0.23939876f, -0.07868751f, -0.05444825f, 0.05263399f, 
    -0.01306396f, 0.02236947f, 0.11065131f, 0.13589142f, -0.47818580f, -0.18628748f, 0.00431180f, 0.28156120f, 
    -0.02445993f, 0.19359316f, 0.15506305f, -0.10444012f, -0.14985193f, 0.01093957f, -0.05058608f, -0.00330001f, 
    -0.44338697f, 0.29677889f, -0.10313734f, -0.49892792f, 0.10731035f, 0.00568039f, -0.09926721f, -0.01547409f, 
    -0.01535267f, 0.07354029f, -0.03364449f, -0.22766496f, 0.04848457f, 0.21804416f, -0.09137961f, -0.04156325f, 
    -0.11836620f, -0.03705285f, 0.00595090f, -0.12279114f, 0.10970864f, -0.07983514f, -0.01007397f, -0.10496198f, 
    -0.09086275f, -0.24457660f, -0.37161854f, 0.03591129f, -0.05218196f, -0.06648058f, 0.17297292f, -0.01844022f, 
    -0.01333321f, 0.16125877f, -0.02858431f, 0.07509232f, -0.29109091f, 0.01558117f, -0.17546399f, -0.09431010f, 
    0.12433029f, 0.07028840f, -0.05597606f, -0.14689000f, 0.03339317f, -0.02829265f, 0.10743246f, -0.00641100f, 
    0.08758044f, -0.39690346f, -0.11799463f, 0.38441247f, -0.16498059f, -0.01045840f, -0.25877455f, 0.16941217f, 
    -0.12448536f, 0.12397646f, 0.10545921f, 0.01021815f, -0.16140711f, 0.04193636f, 0.04408258f, 0.05348534f, 
    -0.09052553f, -0.17709371f, 0.16819577f, 0.11083154f, -0.07428533f, 0.23711789f, -0.05424748f, 0.08622397f, 
    -0.01657045f, 0.07245631f, 0.14830704f, -0.21266063f, 0.05543819f, 0.10197663f, -0.02865360f, -0.19781828f, 
    -0.21003436f, -0.03951196f, 0.08074891f, -0.18935920f, 0.04200114f, -0.04249476f, 0.14248720f, -0.19718345f, 
    0.05889967f, 0.10109545f, 0.04719386f, 0.08680041f, 0.01966437f, -0.05691946f, -0.10285731f, 0.01056597f, 
    0.33080012f, -0.28687763f, 0.11155313f, -0.21919879f, -0.07349177f, -0.07926338f, -0.05369176f, 0.02054136f, 
    -0.14512947f, 0.22291856f, 0.07920825f, -0.00801885f, 0.06314328f, -0.17757057f, -0.18064064f, 0.21084854f, 
    0.09685730f, -0.01932134f, 0.15609325f, 0.06473884f, -0.07362060f, -0.02487026f, 0.00992180f, -0.25104901f, 
    -0.48639321f, -0.56970203f, 0.07285482f, -0.19831103f, 0.20456156f, 0.06815669f, -0.17751080f, -0.24653640f, 
    0.04706516f, -0.28001285f, -0.10001910f, 0.24153951f, 0.28676572f, -0.03287436f, -0.05221687f, -0.02576017f, 
    -0.23480850f, 0.10761482f, 0.01037524f, -0.05594728f, -0.03055567f, 0.16349074f, 0.05003444f, -0.09733059f, 
    0.24456681f, 0.01948611f, -0.07576869f, -0.04673204f, -0.27390853f, -0.02685803f, -0.02232382f, 0.02784765f, 
    -0.00755155f, -0.10319921f, -0.04625612f, -0.09391885f, 0.05866436f, 0.06675176f, 0.04395831f, 0.01537205f, 
    0.13298371f, 0.08015408f, 0.06223211f, 0.13761210f, -0.13278802f, 0.06640793f, -0.04687217f, 0.01342247f, 
    0.40249476f, 0.00338632f, 0.08033540f, -0.17509921f, 0.05029014f, 0.04502732f, 0.11000246f, 0.24407750f, 
    0.15989603f, 0.13865048f, 0.24007943f, 0.15535492f, 0.14135364f, 0.19554970f, 0.06310013f, -0.09428922f, 
    -0.13605946f, -0.21037374f, 0.02700921f, -0.12394453f, -0.10572112f, -0.08834447f, -0.01713426f, -0.15530063f, 
    0.07157901f, 0.00727058f, -0.07117230f, 0.06014342f, -0.22030321f, -0.05052863f, 0.09892250f, -0.18462206f, 
    -0.03158789f, 0.13381678f, -0.01554869f, 0.16765404f, 0.30208588f, -0.02629429f, -0.03937077f, -0.05264767f, 
    -0.01785952f, -0.13146520f, 0.03944632f, -0.01712577f, 0.01727279f, -0.14194284f, -0.11702624f, 0.14833963f, 
    -0.32314771f, -0.11913834f, 0.10069983f, 0.19622655f, 0.03274162f, 0.05422150f, -0.03629096f, 0.00633621f, 
    0.21844238f, 0.13381585f, 0.15964185f, 0.00817223f, 0.16400483f, -0.04199632f, -0.14968456f, -0.22052474f, 
    0.03776265f, 0.08076917f, -0.10846438f, -0.08701276f, -0.03946109f, -0.08164615f, -0.09719943f, -0.01727239f, 
    -0.22632535f, -0.23346813f, 0.12130024f, -0.12259158f, 0.20163983f, 0.05886450f, -0.14860827f, -0.00049824f, 
    0.01085595f, 0.03359160f, -0.12793575f, 0.00782284f, 0.17059283f, -0.03012276f, -0.13797261f, 0.04226055f, 
    -0.09828270f, -0.14016160f, -0.10013716f, 0.08209227f, 0.06980673f, 0.03572931f, 0.01574601f, -0.18983735f, 
    -0.63432223f, -0.39778763f, -0.31072134f, -0.40135717f, -0.01952439f, -0.13958611f, 0.05939385f, 0.00398604f, 
    0.03563330f, 0.09091926f, 0.04490298f, 0.17166945f, -0.33060145f, 0.01660786f, -0.13586204f, 0.06691237f, 
    0.01813982f, 0.08732250f, 0.00446857f, 0.00083254f, 0.14751883f, 0.09720834f, 0.25501725f, 0.08589835f, 
    -0.67542815f, -0.29158187f, -0.10174944f, -0.00882003f, 0.05042830f, 0.07854611f, 0.06180064f, -0.29624832f, 
    0.10456783f, -0.28316122f, -0.23481944f, -0.11143171f, -0.85405058f, -0.51004481f, -0.04762761f, -0.02039163f, 
    0.20080344f, -0.03767789f, 0.04645681f, 0.05286087f, 0.06487591f, 0.03123958f, -0.02314901f, 0.03336025f, 
    -0.49039963f, 0.20559087f, -0.15365160f, -0.15435386f, -0.02043030f, 0.10317495f, 0.04090383f, 0.15350039f, 
    0.00311768f, -0.03203669f, 0.04796644f, 0.06235567f, -0.10626518f, -0.32515359f, -0.24162057f, 0.21880369f, 
    -0.02091231f, -0.00773882f, 0.06222672f, -0.02999754f, 0.12785991f, 0.05270174f, -0.03247770f, 0.08804366f, 
    0.27038807f, 0.05686711f, 0.01857091f, 0.02632040f, -0.01538670f, -0.03793123f, 0.03224474f, 0.07903679f, 
    0.12802681f, -0.10842475f, 0.04536221f, 0.11790424f, -0.29481059f, -0.01170395f, 0.16895989f, -0.25132808f, 
    0.09460587f, 0.08720396f, 0.01040766f, 0.09183087f, 0.11820175f, -0.04889876f, -0.15835071f, 0.16958445f, 
    0.26055363f, 0.07835432f, -0.06021596f, -0.09887263f, -0.25508747f, -0.24209394f, 0.01744427f, -0.18303771f, 
    0.09788144f, -0.21078385f, -0.25247499f, -0.24654539f, 0.04503695f, -0.12751605f, -0.03333080f, 0.27874050f, 
    -0.14400703f, -0.10985056f, 0.08420031f, 0.09171084f, 0.06519532f, 0.12967433f, 0.00021551f, -0.02442563f, 
    -0.34055927f, -0.45524868f, -0.14094155f, -0.25379923f, 0.04438405f, -0.01493029f, -0.05518177f, -0.04364950f, 
    0.07160352f, -0.03994936f, 0.10551990f, -0.04203339f, 0.27953807f, 0.46284667f, 0.03602530f, -0.00942312f, 
    0.00066602f, 0.02424080f, 0.13142942f, 0.10025072f, -0.04570649f, 0.01269799f, -0.00506686f, 0.31834039f, 
    0.15602709f, -0.05994326f, -0.07146584f, 0.11080280f, -0.06123044f, 0.12952341f, -0.04975146f, 0.02319894f, 
    -0.03931166f, -0.12769876f, -0.00430977f, -0.23626506f, 0.13626647f, 0.08649067f, -0.26449990f, -0.22617507f, 
    0.06403205f, -0.06315006f, -0.25445852f, -0.04951077f, 0.03491835f, 0.02057953f, -0.04461628f, 0.02582875f, 
    0.31065208f, -0.02412488f, 0.11141866f, -0.09364623f, -0.08971224f, -0.08412759f, -0.07396596f, -0.12976275f, 
    0.10045381f, 0.00359992f, -0.16414674f, 0.00995735f, 0.10159703f, 0.23736668f, 0.21007176f, 0.02624342f, 
    -0.01149160f, -0.06271845f, 0.01732698f, 0.12461862f, 0.03737104f, 0.05853702f, 0.10510525f, -0.11644233f, 
    -0.69622213f, -0.11072440f, -0.11677346f, -0.07913405f, 0.19348596f, -0.06584639f, 0.05236459f, -0.01646918f, 
    -0.01534625f, 0.13709673f, 0.17785092f, 0.26870823f, 0.18484475f, 0.11409286f, 0.18772544f, -0.05436201f, 
    -0.13215074f, 0.03796816f, -0.04513571f, 0.09282224f, 0.04818816f, 0.03672319f, 0.19750704f, 0.03292496f, 
    -0.09439334f, 0.24285313f, -0.08169824f, 0.16886191f, 0.06999312f, 0.16068782f, -0.00496799f, -0.02657989f, 
    0.08568289f, 0.17730680f, -0.00324400f, 0.06443032f, 0.21543774f, 0.09568319f, -0.05255519f, -0.17204989f, 
    0.13926223f, 0.11983540f, 0.17006044f, -0.16790110f, -0.07240602f, 0.00445128f, 0.07414331f, 0.09099270f, 
    -0.03450736f, 0.19029625f, -0.07676703f, -0.14973392f, 0.08856507f, -0.06198640f, 0.03204370f, 0.09304368f, 
    -0.04417596f, 0.06500380f, -0.14637055f, -0.06822079f, 0.36907381f, 0.02019360f, 0.12326817f, 0.04495267f, 
    -0.06067780f, 0.00672887f, 0.05667026f, -0.06624892f, -0.02337547f, -0.13592342f, 0.16716035f, 0.13271110f, 
    0.12206828f, -0.02138727f, 0.02377200f, -0.08048424f, -0.10046845f, -0.09565387f, 0.03608228f, 0.02385322f, 
    0.08698756f, 0.06776609f, 0.01043820f, -0.10711600f, -0.01027287f, 0.36547858f, -0.00627073f, -0.17034183f, 
    -0.09910778f, -0.13242318f, 0.07890772f, -0.16468233f, -0.04437762f, -0.03680486f, 0.07797156f, -0.06638214f, 
    0.05133829f, -0.22578973f, -0.07888435f, 0.46897843f, 0.04364959f, -0.14876437f, 0.16953196f, 0.05412452f, 
    0.02330571f, 0.05632224f, 0.02154198f, 0.08189849f, -0.18784077f, -0.36017948f, -0.00762987f, 0.05979644f, 
    0.18575698f, 0.10851065f, 0.00684284f, -0.21990438f, 0.02806673f, 0.06529425f, 0.13001885f, -0.00947913f, 
    0.08454979f, -0.04201919f, -0.05600547f, 0.07023995f, -0.27454567f, 0.01362435f, -0.20869018f, -0.14327706f, 
    -0.05979218f, -0.04082136f, -0.26568288f, -0.17511348f, -0.04142053f, 0.18084137f, -0.16893619f, -0.11194433f, 
    0.03133345f, -0.08363324f, 0.29224595f, 0.18211167f, 0.01544868f, 0.04061855f, 0.00024420f, -0.19689019f, 
    0.37143183f, -0.01429199f, 0.17088953f, 0.32030416f, 0.13540815f, -0.13238315f, -0.06468354f, -0.00622766f, 
    0.05819388f, 0.07379155f, -0.05814240f, 0.02965004f, 0.01363322f, 0.27463436f, -0.01464162f, -0.09097505f, 
    0.12897381f, -0.01295757f, -0.04554964f, -0.07188106f, 0.13490988f, 0.02822039f, -0.02037370f, -0.10625105f, 
    0.22679755f, -0.25928190f, -0.16637170f, 0.21326248f, -0.06537341f, 0.01186584f, 0.04118416f, -0.17750408f, 
    -0.06447767f, 0.14634259f, -0.10295095f, -0.05256815f, -0.35097054f, -0.35804379f, 0.17627020f, -0.20639795f, 
    0.07848898f, -0.05368062f, -0.02453842f, -0.10681180f, 0.00385385f, -0.00807448f, -0.12624604f, 0.09031489f, 
    0.05314463f, -0.36643338f, -0.08171959f, -0.02620829f, 0.05681692f, -0.09484947f, 0.04125369f, 0.12470226f, 
    -0.01864904f, 0.07244162f, -0.12457442f, -0.16532525f, -0.03206819f, -0.27178407f, 0.07083796f, -0.17981654f, 
    0.23681405f, 0.10665450f, -0.03215944f, -0.23571973f, -0.04896297f, -0.13722827f, -0.07573651f, -0.06927593f, 
    0.23483682f, -0.02705048f, 0.05959905f, -0.01983390f, 0.02996523f, 0.10765391f, -0.07318609f, 0.01101196f, 
    -0.00467433f, 0.15947834f, 0.13869818f, 0.05645749f, 0.43654165f, -0.11145712f, -0.24557148f, 0.13948470f, 
    0.04948453f, 0.02656861f, 0.07546468f, 0.08105343f, 0.05095494f, -0.13162954f, 0.05614495f, 0.04617149f, 
    0.19480348f, 0.09174836f, -0.10471728f, 0.12066370f, -0.16306235f, -0.09104402f, -0.14810286f, 0.09057739f, 
    -0.04780673f, -0.13333832f, 0.02261884f, -0.01113171f, -0.26365897f, 0.01802481f, -0.08571675f, 0.19517516f, 
    -0.05508048f, -0.05158629f, 0.21078913f, 0.09040995f, 0.16073769f, 0.13267393f, -0.01461499f, -0.14459969f, 
    -0.17305103f, 0.20394391f, 0.03912457f, -0.15503184f, -0.05944560f, -0.02113290f, -0.09580819f, -0.05936275f, 
    0.14936371f, -0.03751537f, 0.11548310f, -0.02905563f, 0.48097941f, 0.33567169f, -0.35325101f, 0.25329009f, 
    -0.15941237f, -0.05004209f, 0.13540451f, 0.02491820f, 0.12829681f, 0.12247378f, 0.05282732f, 0.03821513f, 
    -0.05447626f, -0.12890227f, -0.01340712f, 0.01483739f, 0.00984006f, 0.02094138f, 0.12364125f, 0.00027515f, 
    0.02200813f, -0.10493343f, 0.04490060f, -0.20754158f, 0.03909614f, -0.35302216f, -0.13384099f, -0.02127200f, 
    -0.07197550f, -0.06060792f, -0.03115538f, -0.11573013f, 0.08422278f, 0.02019298f, 0.18564714f, 0.17516245f, 
    0.40656573f, -0.26600793f, -0.39659172f, -0.09152006f, 0.12243246f, -0.16035545f, 0.02302065f, -0.22886394f, 
    0.08771577f, 0.14240578f, 0.04042118f, 0.01177245f, -0.29582745f, 0.02577101f, 0.00552765f, 0.04394415f, 
    -0.05889365f, -0.02692021f, 0.12417981f, 0.00592045f, 0.06757281f, -0.22216381f, -0.10367502f, -0.06742650f, 
    -0.50387782f, 0.07221032f, -0.30442572f, 0.16993383f, 0.29244712f, -0.13842019f, 0.11532398f, -0.06706236f, 
    -0.01292156f, 0.11117766f, 0.04914748f, 0.09525695f, -0.25966093f, -0.51644760f, -0.11500646f, -0.43486282f, 
    -0.14149587f, -0.06517313f, 0.05979997f, 0.09769773f, -0.12559015f, 0.14251265f, -0.00233148f, -0.03244705f, 
    -0.16843034f, -0.07472271f, 0.31764525f, 0.10540852f, 0.12338354f, 0.11290489f, -0.07936502f, -0.09846453f, 
    -0.11447106f, 0.02180428f, 0.18928324f, 0.12083198f, -0.16639227f, 0.18078607f, -0.12909859f, -0.17800154f, 
    0.14450105f, -0.06119117f, 0.12702179f, -0.15956351f, -0.03276138f, -0.00447091f, 0.06388913f, -0.07131700f, 
    0.53967667f, 0.02770485f, -0.03762579f, -0.46718723f, 0.14373733f, -0.11909790f, -0.04858739f, 0.04463212f, 
    0.02170425f, -0.03624862f, -0.09415518f, 0.10270025f, -0.17938146f, 0.10197105f, -0.19524594f, 0.03252332f, 
    0.16775265f, 0.08007683f, -0.12040446f, 0.12262919f, 0.13175513f, 0.11321296f, 0.05068799f, -0.11643118f, 
    -0.01323436f, -0.11140826f, 0.06931311f, 0.19551571f, -0.16893999f, 0.06088311f, 0.01323515f, 0.07155482f, 
    -0.02098462f, 0.08973043f, 0.08222296f, -0.20629197f, 0.12179068f, 0.11491124f, 0.06224845f, -0.16077137f, 
    -0.06531734f, -0.13808750f, -0.20376801f, 0.10351705f, -0.05095499f, -0.19178812f, -0.19609624f, -0.11068570f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.08031920f, 0.04566217f, -0.06485933f, 0.04085917f, 0.04617206f, 0.02655778f, 0.00392311f, -0.11963227f, 
    -0.01433758f, -0.01767094f, 0.12832606f, -0.01698997f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
