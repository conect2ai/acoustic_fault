#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.45151567f, 0.03317666f, 0.71537858f, 0.84770411f, -0.21375707f, 0.24133526f, 0.28340918f, 0.42102122f, 
    -0.35029447f, 0.28061798f, 0.18303221f, -0.12884688f, 0.01207011f, 0.33456159f, -0.04019051f, -0.02399018f, 
    0.17539853f, -0.21416886f, 0.11394128f, 0.03043204f, 0.14693382f, 0.22338212f, 0.27593717f, 0.55038089f, 
    -0.37546596f, 0.42457619f, 0.58524334f, 0.83040905f, -0.40410808f, -0.66732949f, -0.78948569f, 0.37680942f, 
    -0.37219465f, -0.46496361f, -0.31930414f, 0.02974126f, 0.32055044f, -0.08978458f, -0.02936958f, 0.04493160f, 
    0.00983505f, -0.13337046f, 0.07495899f, 0.07874169f, -0.03637573f, 0.06065823f, 0.19461204f, 0.04575500f, 
    -0.01250452f, 0.15104052f, 0.53447783f, -0.19906338f, -0.30535755f, -0.78213513f, 0.75071466f, 0.50286222f, 
    -0.62833869f, -0.09264715f, -0.13014510f, -0.42632025f, -0.31635407f, 0.47811925f, 0.12473419f, 0.10669465f, 
    0.20675385f, -0.04966652f, 0.00891190f, 0.25221297f, 0.20459434f, 0.19335891f, 0.01163341f, 0.05271115f, 
    -0.05897004f, 0.07489084f, 0.21801980f, 0.16551518f, 0.32394835f, 0.56101054f, 0.74312758f, 0.69783294f, 
    0.16012023f, -0.52308410f, -0.65620357f, -0.15209162f, -0.03706671f, 0.32567292f, 0.16709377f, 0.18652780f, 
    0.09550927f, -0.29014006f, 0.32245740f, 0.30106267f, 0.36673030f, -0.02096545f, -0.04514743f, 0.07708322f, 
    -0.13323361f, -0.12903686f, 0.02152739f, -0.16469125f, -0.01140200f, 0.05179990f, -0.20697311f, -0.52002466f, 
    0.12354346f, -0.13741958f, -0.36864969f, -0.76334834f, 0.43786344f, -0.33056000f, 0.16863722f, -0.52578485f, 
    -0.20392813f, -0.19109526f, -0.21763189f, -0.11711954f, -0.32073388f, -0.49786502f, -0.39079362f, -0.02992508f, 
    0.19904989f, 0.11894497f, -0.16727874f, -0.07493225f, -0.25983280f, -0.67803943f, 0.43056977f, 0.08103266f, 
    -0.64314246f, -0.44110027f, 0.21585147f, 0.43131953f, -0.38747177f, -0.15182157f, 0.45965317f, -0.20788202f, 
    0.23826587f, -0.21731111f, 0.22135082f, -0.18961135f, 0.14540058f, 0.00092675f, 0.18059517f, -0.04451087f, 
    -0.05994168f, -0.37115797f, -0.26607096f, -0.42341304f, -0.30506307f, -0.21791939f, -0.70458841f, -0.79012042f, 
    -0.46404049f, -0.27199152f, -0.17038766f, 0.03690945f, 0.61742020f, 0.50157064f, -0.07930315f, 0.14943323f, 
    -0.29325610f, -0.26495078f, 0.21848150f, 0.10437785f, 0.27517283f, -0.14189784f, 0.02792025f, -0.09319463f, 
    0.08906027f, 0.06726382f, 0.34984773f, -0.22913907f, 0.15643346f, 0.19797273f, -0.13822679f, 0.87666523f, 
    0.53855669f, 0.61575496f, 0.68918371f, 0.56420386f, 0.57571596f, 0.19083402f, 0.05403585f, -0.31512001f, 
    -0.46653140f, 0.23969561f, 0.10290305f, -0.31215367f, -0.11699583f, 0.03597153f, 0.03683003f, -0.02858390f, 
    -0.01702202f, -0.11011272f, -0.00652017f, 0.02374821f, 0.10879424f, 0.32861415f, -0.11793449f, 0.21593985f, 
    -0.58700138f, -1.03845608f, -0.31556219f, -0.03112773f, -0.02053132f, -0.20483266f, 0.40245938f, 0.55890298f, 
    -0.49217477f, -0.19684215f, 0.23830260f, -0.12716964f, 0.00517284f, -0.06580475f, -0.00607751f, -0.06559015f, 
    -0.10099127f, -0.24953991f, -0.41695869f, -0.10212652f, -0.14365013f, 0.06770461f, 0.08919512f, -0.03737986f, 
    0.20013580f, 0.94742572f, 0.12708747f, 0.91340876f, 0.23220450f, -0.40165666f, -0.28454313f, -0.92965496f, 
    -0.33218694f, 0.11457124f, 0.34588474f, -0.05630727f, -0.05657493f, 0.04302442f, -0.02842642f, -0.19948812f, 
    -0.48049572f, 0.06608222f, -0.07618867f, -0.20316911f, 0.20315222f, 0.01531485f, 0.09920974f, 0.22368500f, 
    -0.06652476f, 0.09471207f, 0.54542673f, 0.84139442f, -0.52852285f, -0.72459888f, -0.64372462f, 0.42025581f, 
    -0.23561803f, -0.31958550f, -0.17581567f, 0.02250187f, 0.32814661f, 0.21262227f, 0.12604006f, 0.24354497f, 
    -0.08771406f, 0.07760683f, 0.06130240f, 0.12594384f, 0.03237132f, 0.15250151f, -0.05183008f, 0.19764461f, 
    0.10521620f, 0.05213409f, 0.23465146f, 0.84569442f, 0.54595965f, -0.50269496f, 0.32368264f, -0.39921746f, 
    0.50951874f, 0.59329188f, -0.30087364f, 0.48552227f, 0.29872826f, 0.02861008f, 0.00687711f, -0.07939987f, 
    -0.04932806f, -0.17505550f, -0.21590556f, -0.20628570f, 0.08620806f, -0.12901996f, -0.03568158f, 0.08138307f, 
    -0.01393833f, 0.17091076f, 0.09698512f, 0.22097547f, 0.46815833f, 0.45506394f, 0.22323826f, 0.69586354f, 
    0.80667013f, -0.02562995f, -0.32416186f, 0.57977796f, 0.04148890f, 0.46122620f, -0.46211731f, -0.10748437f, 
    0.06930733f, 0.28657871f, 0.15153505f, 0.09950690f, -0.23043594f, 0.10546504f, 0.22613630f, 0.07337833f, 
    0.21827251f, -0.12835194f, -0.02418157f, -0.02111408f, -0.04100776f, -1.01143634f, 0.06742470f, -0.69530231f, 
    -0.25941402f, 0.27876231f, -0.29675645f, 0.55448395f, 0.38427299f, 0.40011862f, 0.39860991f, 0.31782317f, 
    -0.04253756f, 0.45708105f, -0.25088114f, 0.00126505f, -0.03977917f, 0.21760966f, 0.05295900f, 0.07669152f, 
    -0.34385937f, -0.10068002f, 0.09721318f, -0.37445185f, -0.03325602f, -0.13874429f, -0.47523052f, -0.49758098f, 
    -0.29488957f, -0.59377682f, -0.60895747f, -0.28986540f, -0.43973747f, 0.06139039f, -0.22658499f, -0.20692843f, 
    -0.24365737f, -0.00373354f, -0.18117721f, -0.08889347f, 0.21120954f, 0.24942380f, 0.17021163f, 0.14623222f, 
    0.38731715f, 0.38527438f, 0.19276284f, 0.16230181f, -0.14442275f, 0.06292588f, 0.25527605f, 0.00477208f, 
    -0.40494582f, -0.59722281f, -0.42532834f, -0.40714431f, 0.69041485f, 0.57653672f, 0.58701068f, 0.33137962f, 
    0.19641288f, -0.09625728f, -0.09680183f, -0.15582861f, -0.52126139f, -0.27560142f, -0.27873459f, -0.01394970f, 
    0.35777146f, 0.37986466f, -0.28985807f, -0.26229045f, -0.16254167f, -0.01379949f, -0.13788016f, 0.16621177f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.06642211f, 0.29327089f, 0.25280800f, -0.12240304f, 0.13844399f, 0.03509209f, 0.17213894f, 0.20785174f, 
    0.22065434f, 0.09653573f, 0.16994028f, 0.17301863f, 0.14249058f, 0.28101933f, 0.17044581f, -0.04802189f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.08864635f, 0.08519882f, 0.11161351f, -0.07134209f, 0.12349365f, -0.08366065f, 0.18727702f, 0.06431910f, 
    0.07898244f, -0.05909872f, -0.07635635f, 0.08960354f, -0.05140897f, 0.28820074f, -0.19060878f, 0.15324117f, 
    0.00322901f, 0.03062384f, -0.09605379f, 0.12822862f, -0.00750557f, 0.12305062f, 0.08379655f, 0.09563451f, 
    0.04185796f, -0.01943280f, 0.11466654f, -0.15578322f, -0.04206216f, 0.09969661f, 0.05840398f, -0.05983939f, 
    0.08638957f, 0.09115697f, 0.15431242f, 0.12520617f, 0.11868062f, -0.25123027f, -0.01815719f, 0.19469266f, 
    -0.00030250f, -0.03773854f, 0.10422131f, -0.01443999f, 0.05841235f, 0.04848485f, 0.06714947f, 0.24529591f, 
    0.11696958f, 0.04465023f, 0.15841171f, -0.00425924f, 0.00417206f, 0.05000886f, 0.19422750f, 0.05721582f, 
    -0.08806282f, 0.05691259f, -0.14796771f, -0.01435100f, -0.04233183f, -0.04913982f, 0.02415149f, -0.26610649f, 
    -0.05123794f, 0.12126651f, -0.08414333f, -0.00524413f, 0.18085122f, -0.15803379f, 0.10411093f, 0.08362512f, 
    -0.20351662f, -0.01529214f, 0.04771090f, -0.19454929f, 0.07143418f, 0.04194563f, 0.04456053f, 0.01214531f, 
    0.01336207f, 0.09679165f, 0.11435921f, -0.10265243f, 0.05157844f, -0.27469793f, 0.12231619f, 0.28712654f, 
    -0.05213908f, 0.18219633f, 0.08189472f, 0.01143090f, 0.06437486f, -0.00456218f, -0.01736495f, -0.06854460f, 
    -0.06535576f, -0.07525507f, 0.07712768f, 0.02888489f, -0.04497208f, -0.03781465f, 0.02657937f, -0.11604998f, 
    -0.00683969f, -0.04888368f, 0.03825561f, -0.07711723f, 0.24994197f, -0.15366976f, -0.10366903f, 0.17463626f, 
    -0.00048763f, -0.08995207f, 0.00918526f, 0.12564056f, 0.05164813f, -0.09418250f, 0.02488502f, 0.13882281f, 
    0.07696037f, 0.03357288f, 0.02748685f, -0.01901652f, -0.04440833f, 0.00766983f, 0.07270303f, 0.14955911f, 
    -0.02015394f, -0.04976963f, 0.04142259f, 0.14734417f, 0.31272838f, -0.05812386f, -0.17464547f, 0.00063482f, 
    -0.00795998f, 0.07541021f, 0.00394285f, 0.10183054f, -0.02812703f, 0.12851632f, 0.09351895f, 0.03050124f, 
    -0.12239213f, -0.03789805f, 0.13363208f, 0.05719953f, -0.00243233f, -0.04787824f, 0.02699086f, -0.02159429f, 
    0.04094857f, -0.05108706f, 0.00124666f, 0.03274079f, -0.23032455f, 0.11915977f, -0.07434037f, -0.17236310f, 
    -0.07463707f, 0.10337619f, -0.17649823f, -0.12387356f, 0.01158397f, 0.10205112f, 0.07835003f, -0.03174143f, 
    -0.05616901f, -0.09610052f, -0.13331085f, -0.19769186f, 0.07953465f, 0.01773471f, 0.00144176f, 0.10053207f, 
    -0.02877824f, -0.02625921f, 0.00905770f, 0.13183360f, 0.00751675f, 0.10015097f, -0.08981854f, -0.19210245f, 
    0.00082235f, -0.01230284f, -0.00889729f, -0.03251428f, -0.01657920f, -0.14165385f, 0.00648013f, 0.06505764f, 
    0.25935832f, 0.03389030f, 0.10841860f, -0.12392166f, 0.05463485f, 0.03593035f, 0.06066451f, 0.11274707f, 
    0.01000065f, -0.06222703f, -0.09785700f, 0.05742114f, 0.21564427f, 0.00037152f, -0.17166123f, 0.17210639f, 
    -0.05134985f, 0.04430585f, 0.02527974f, 0.11785083f, -0.09044542f, 0.00213456f, 0.02109877f, 0.03342023f, 
    0.02159294f, 0.05960552f, -0.06290737f, 0.27192536f, 0.03021611f, 0.06132050f, 0.10466619f, -0.08810227f, 
    -0.00375425f, 0.04868896f, -0.00676095f, -0.02426120f, 0.18230146f, 0.05868683f, 0.00446199f, 0.08529706f, 
    0.12790984f, 0.09792356f, 0.14255767f, -0.01327889f, -0.11713676f, 0.06322703f, -0.03953045f, 0.07668532f, 
    0.25131479f, 0.10777852f, -0.01116268f, 0.12493088f, -0.05378607f, 0.00304895f, 0.26866767f, 0.00503991f, 
    -0.05109895f, 0.17449906f, 0.02972840f, 0.08276883f, 0.06157815f, 0.02113962f, 0.06667834f, -0.04328601f, 
    0.01914085f, 0.12600887f, -0.04558525f, 0.14015347f, 0.00925482f, -0.15591834f, 0.05652070f, -0.01613942f, 
    -0.19909695f, -0.03525327f, -0.02722459f, -0.02373840f, 0.10312261f, 0.06616123f, 0.17112130f, 0.07121865f, 
    -0.03577206f, 0.06635337f, 0.02900769f, -0.01721260f, -0.18189660f, -0.10380171f, 0.05836517f, 0.20594664f, 
    0.03974476f, 0.11155644f, -0.05370059f, -0.09999998f, -0.04867297f, 0.03753411f, 0.05638706f, -0.05553231f, 
    0.13371648f, -0.13376363f, 0.08118404f, -0.03072776f, 0.03669101f, -0.02134939f, 0.00312032f, -0.07596177f, 
    0.07724243f, -0.01583233f, 0.10855231f, -0.08367041f, 0.28565463f, 0.11956383f, -0.12792082f, 0.03566479f, 
    0.03396145f, 0.11971102f, 0.05706327f, 0.01141003f, 0.05812370f, -0.10813612f, -0.07605793f, 0.03938649f, 
    0.13918446f, -0.17216308f, 0.11300547f, 0.12611793f, -0.14137709f, 0.00715126f, -0.04834444f, 0.01012518f, 
    -0.01307936f, -0.09943466f, 0.05401063f, -0.12647191f, 0.08331154f, 0.04216539f, 0.09730300f, -0.16173629f, 
    0.04798921f, 0.03851500f, -0.00142945f, -0.05225171f, -0.05437284f, -0.01335089f, 0.10591885f, -0.11152229f, 
    -0.23350270f, 0.21483830f, 0.11026792f, -0.17753282f, 0.02697350f, 0.03708794f, 0.16173561f, -0.08043584f, 
    -0.08045746f, -0.09081905f, 0.07546677f, -0.05240386f, -0.29399455f, -0.05980330f, -0.01384375f, 0.01396878f, 
    -0.12430482f, -0.16252092f, -0.11527619f, -0.08045463f, -0.05671791f, 0.15076138f, 0.00866524f, 0.07890869f, 
    0.01023231f, -0.07673582f, -0.08972383f, -0.14027525f, 0.06658608f, 0.01098570f, 0.00916776f, -0.05263425f, 
    -0.12547767f, -0.12469798f, -0.06867655f, 0.11762023f, -0.07364559f, -0.02161017f, -0.18619968f, -0.02116374f, 
    -0.02515581f, -0.04875440f, -0.10423271f, -0.00915685f, -0.03441063f, -0.05148316f, -0.01340885f, 0.05199759f, 
    0.16351506f, -0.07299448f, 0.04499606f, -0.03145915f, -0.03156654f, 0.04141577f, -0.11111158f, 0.01618957f, 
    -0.04056803f, 0.07855833f, 0.05227702f, 0.04565674f, 0.02963664f, -0.26402602f, 0.10110831f, -0.02861270f, 
    0.05471066f, -0.05823165f, 0.07219860f, -0.07300067f, -0.00767962f, -0.02827598f, -0.01112687f, 0.04382994f, 
    0.04701750f, 0.04015939f, -0.21492609f, 0.25050184f, -0.03352779f, -0.02656440f, -0.05299112f, 0.08305951f, 
    -0.02253836f, 0.05782473f, -0.13809003f, -0.14015445f, -0.00950203f, 0.08652259f, 0.12474110f, -0.07294954f, 
    -0.01676134f, 0.04570393f, -0.04451423f, 0.07440953f, -0.14681371f, -0.00972479f, -0.10906483f, -0.06550775f, 
    0.08560872f, 0.00536468f, -0.12036560f, 0.03960312f, 0.07154983f, 0.04907456f, -0.14067672f, -0.07955662f, 
    0.08480688f, 0.06225169f, 0.28412643f, 0.13696183f, 0.10930604f, 0.09108413f, -0.04047245f, 0.24306619f, 
    -0.08552734f, 0.02007152f, 0.07075862f, 0.15494797f, -0.08054218f, 0.07156921f, -0.00480573f, 0.10402401f, 
    0.13454171f, -0.01395055f, 0.01714927f, 0.13102031f, -0.09953921f, 0.00611989f, 0.02922150f, -0.03969277f, 
    -0.00666884f, -0.02061156f, 0.05920788f, 0.10261787f, -0.15726334f, 0.07313465f, -0.18699259f, -0.32239148f, 
    0.16166076f, -0.08471256f, 0.00520394f, 0.01293937f, 0.00948043f, 0.04086904f, 0.07840975f, -0.04387455f, 
    0.25498298f, 0.03947040f, 0.15434879f, -0.05618760f, 0.02026833f, -0.00951910f, 0.04981887f, 0.06796052f, 
    0.12429933f, 0.01518726f, 0.01080770f, 0.13116953f, -0.13168851f, 0.07146417f, 0.11589465f, -0.10818175f, 
    0.18088380f, 0.11961371f, -0.04657974f, -0.03117494f, 0.06022432f, 0.15269355f, 0.00343267f, 0.05676617f, 
    -0.01466214f, 0.01559538f, -0.09999962f, 0.31990543f, 0.01099392f, 0.07064299f, -0.10232303f, -0.05343440f, 
    -0.02799537f, 0.03857238f, -0.01355531f, -0.09343085f, -0.44051769f, 0.09182958f, 0.10963500f, -0.03919613f, 
    -0.02690741f, 0.09033035f, 0.10889008f, -0.13351382f, 0.08173560f, -0.08697016f, -0.04003660f, 0.09436353f, 
    -0.18889143f, 0.05016566f, -0.10079875f, -0.17239726f, 0.12980865f, 0.02790716f, -0.04275277f, -0.00185823f, 
    0.04786099f, 0.04309166f, 0.03686818f, -0.03921202f, 0.06574591f, -0.13257027f, 0.05620747f, 0.14841950f, 
    0.06979789f, -0.00035766f, 0.30792612f, 0.08391921f, -0.00982000f, 0.04197846f, -0.02272207f, 0.06034494f, 
    0.13400543f, 0.15242945f, -0.01053290f, 0.14668562f, -0.13415927f, 0.07544698f, 0.01865754f, -0.06769512f, 
    -0.01485008f, -0.05101046f, -0.06215299f, -0.05019431f, -0.03005085f, -0.06905343f, 0.00134519f, 0.18729770f, 
    -0.11256759f, -0.04301807f, 0.02461088f, 0.00718994f, -0.03423199f, 0.18087688f, -0.01690565f, 0.00745537f, 
    0.20096350f, -0.09784752f, 0.25440845f, -0.15665628f, -0.07229744f, 0.19049811f, 0.02039222f, 0.08274367f, 
    0.07823182f, -0.04417468f, 0.01718548f, -0.22217570f, -0.09550488f, 0.13659854f, 0.02041565f, -0.06958662f, 
    -0.04647484f, 0.03298105f, -0.01426122f, -0.03765040f, -0.09107655f, -0.02934123f, 0.01228177f, 0.04649060f, 
    -0.30736566f, -0.01847592f, 0.07197028f, -0.00797688f, -0.08035170f, -0.06148572f, 0.10114076f, -0.16336240f, 
    0.01814881f, -0.01261404f, -0.12634189f, -0.08096673f, 0.33331531f, 0.22976242f, 0.12370230f, 0.09962795f, 
    -0.07725000f, 0.22410922f, 0.03083903f, -0.07280852f, -0.02223352f, -0.02854734f, 0.04743908f, 0.00396328f, 
    -0.07251232f, 0.12813957f, -0.06835125f, 0.18160146f, -0.06323097f, 0.00463736f, -0.01598311f, -0.10934784f, 
    -0.04467329f, 0.06490183f, 0.10845806f, 0.09999403f, 0.28971320f, 0.02265322f, 0.02368871f, 0.10778449f, 
    0.03420455f, -0.12074073f, 0.02527588f, 0.19005606f, -0.05073289f, 0.02216205f, -0.00858446f, -0.14738178f, 
    -0.03984722f, -0.03633947f, -0.06939127f, -0.05015833f, 0.11005878f, -0.01005220f, 0.01855579f, 0.07259053f, 
    -0.02311896f, 0.01932262f, 0.02940047f, -0.05025609f, -0.00683823f, 0.10458629f, 0.24055032f, 0.10290509f, 
    0.06597932f, 0.07469651f, 0.08791414f, 0.06183144f, 0.17907888f, 0.09815647f, 0.18206991f, -0.08059317f, 
    0.15363277f, -0.17495586f, 0.00227071f, -0.09702428f, -0.06523708f, -0.10757830f, 0.00272902f, -0.16069067f, 
    0.08470503f, -0.05695612f, 0.06839142f, 0.01816738f, -0.32748958f, 0.23062004f, -0.02058669f, 0.03433049f, 
    -0.15658025f, 0.15445714f, 0.09354329f, 0.04834367f, -0.06830950f, -0.08158296f, -0.02914379f, -0.02200990f, 
    0.02886615f, 0.07766651f, -0.07990655f, 0.10760410f, -0.02990841f, -0.00645809f, 0.08723914f, 0.01630711f, 
    -0.00637825f, -0.11308613f, -0.10921906f, -0.13331462f, 0.44984508f, 0.03370065f, 0.05494101f, 0.00238362f, 
    -0.04306404f, -0.02863115f, -0.04700441f, -0.00524064f, -0.09612525f, -0.13913955f, 0.00791190f, -0.04177273f, 
    0.10671221f, 0.20447940f, 0.25368547f, -0.18600361f, -0.05553091f, 0.07254683f, 0.14935477f, -0.02134578f, 
    -0.10519599f, -0.02321273f, 0.05353367f, 0.03600220f, -0.25595522f, -0.03427611f, -0.08672693f, 0.03838627f, 
    0.18068467f, 0.10089798f, 0.02301116f, 0.06931192f, 0.12982914f, -0.06640761f, -0.12934643f, 0.03233435f, 
    -0.12346358f, -0.04154127f, -0.00705351f, 0.21939135f, 0.07193775f, -0.22078888f, 0.01938022f, -0.04644540f, 
    0.05735235f, -0.11602741f, -0.08871125f, 0.16549793f, 0.10884822f, 0.02586936f, -0.06540754f, -0.00787855f, 
    0.17569226f, -0.02600313f, 0.03205208f, 0.11338699f, -0.09925003f, -0.02165849f, 0.00847209f, 0.15041475f, 
    -0.00609517f, -0.07261791f, 0.16924383f, 0.00944166f, 0.03287136f, -0.00741240f, 0.11515626f, 0.07699514f, 
    -0.03195932f, 0.02487291f, -0.11814239f, 0.07290016f, 0.10465574f, 0.23911135f, -0.16939771f, -0.00837787f, 
    -0.04733536f, -0.01916361f, 0.14051963f, 0.10149448f, -0.02684227f, 0.04306788f, -0.01532198f, 0.09289844f, 
    -0.12134527f, -0.05829148f, -0.07262803f, 0.09513015f, 0.07021463f, -0.05436958f, -0.07555509f, -0.06494904f, 
    0.00523038f, -0.02591935f, 0.03966450f, 0.06590851f, 0.25124252f, -0.13008387f, 0.13583542f, 0.17720011f, 
    0.09479914f, 0.02823377f, -0.01707747f, 0.03262819f, -0.03546868f, 0.00187754f, -0.01893601f, 0.08121935f, 
    0.23402072f, -0.03732611f, 0.00007898f, 0.11017071f, 0.07115445f, 0.07285038f, 0.08159747f, -0.03819752f, 
    -0.00320131f, 0.22734416f, -0.12366611f, -0.06275421f, -0.11628842f, -0.01208222f, -0.02631848f, -0.06404302f, 
    -0.11881920f, 0.01818882f, -0.00276331f, 0.09707108f, 0.10610581f, 0.10767908f, 0.05974693f, 0.09664088f, 
    -0.06195028f, -0.14683433f, -0.01594869f, 0.05787041f, -0.01907491f, -0.01707450f, 0.04830362f, -0.05216301f, 
    0.02447043f, -0.05669768f, 0.03603614f, -0.03991226f, 0.11366329f, -0.10938587f, 0.24578804f, 0.19840020f, 
    0.03614882f, 0.04643354f, 0.06031017f, -0.01501531f, 0.09800920f, 0.06609570f, -0.03514377f, 0.03975897f, 
    -0.10358652f, -0.14644927f, 0.01314946f, -0.05359523f, -0.02580511f, -0.09220968f, 0.09243805f, 0.05311030f, 
    -0.04315427f, 0.03421627f, 0.13060071f, 0.04655715f, -0.05370504f, 0.13946138f, 0.12267967f, 0.01836757f, 
    0.08524711f, 0.21151650f, 0.14629842f, 0.04442048f, 0.11598815f, -0.04385073f, 0.04405850f, -0.09805957f, 
    0.45875549f, -0.09361678f, -0.16468884f, -0.04229267f, 0.00058828f, 0.04426736f, 0.08711180f, 0.02772896f, 
    0.03479578f, 0.05558104f, 0.00381559f, 0.05460564f, 0.44247097f, -0.14498906f, 0.01732726f, -0.05676687f, 
    0.03698847f, -0.05579723f, 0.05690863f, -0.02681687f, -0.11977609f, -0.09956915f, 0.01485644f, 0.02545653f, 
    0.16030104f, -0.06109238f, 0.10038751f, 0.15899156f, 0.11920381f, -0.08783630f, 0.09670150f, 0.10154841f, 
    -0.05266185f, -0.00074357f, 0.09963854f, 0.04049380f, -0.07466877f, 0.05434375f, -0.04497632f, 0.03395658f, 
    -0.07077552f, 0.11338537f, 0.05503189f, 0.06280580f, 0.07811370f, 0.12704909f, 0.09544251f, 0.06404511f, 
    -0.18415914f, -0.06564166f, -0.04156826f, -0.08400200f, -0.13294922f, -0.07748906f, -0.04507980f, -0.02409946f, 
    0.08189586f, 0.01898084f, 0.03299134f, 0.12723437f, -0.19393052f, -0.28417984f, -0.04692698f, 0.07355836f, 
    -0.07783423f, -0.08078320f, -0.01294553f, -0.11928958f, 0.03893485f, -0.14837766f, -0.03224015f, 0.01925151f, 
    -0.27022275f, 0.06388782f, -0.10925934f, 0.11518190f, 0.03692501f, -0.02947476f, -0.07084673f, -0.06641244f, 
    0.05330586f, 0.12890394f, 0.14883402f, 0.17312022f, -0.22795042f, -0.19403403f, 0.23154306f, -0.13204457f, 
    0.09183721f, 0.04446519f, 0.09506971f, 0.01457764f, 0.18363214f, -0.03944689f, -0.01953254f, 0.07208002f, 
    0.09171300f, -0.08160876f, 0.03235397f, -0.11381139f, 0.08286785f, 0.05760482f, -0.06505098f, 0.16673100f, 
    -0.06777039f, 0.00465052f, 0.16288652f, -0.02374903f, -0.40182093f, 0.04145870f, -0.02113994f, -0.31550932f, 
    -0.06143862f, -0.14119275f, -0.04237176f, 0.05562297f, 0.06434254f, 0.00112304f, 0.13999270f, -0.03686997f, 
    -0.06804023f, -0.08211880f, -0.01418255f, -0.14591561f, 0.05491427f, -0.08508986f, -0.03125510f, 0.10286995f, 
    0.02096678f, -0.04035908f, -0.10215786f, -0.04223596f, -0.09604315f, 0.08579904f, -0.06420046f, 0.08825170f, 
    0.09262130f, -0.04727298f, 0.03606995f, -0.14424592f, -0.10851807f, 0.12531887f, -0.14315964f, 0.05892075f, 
    0.14953722f, 0.07850553f, -0.10910701f, 0.10551792f, 0.01429066f, 0.03460593f, 0.01976768f, 0.02966469f, 
    0.18613797f, -0.03056404f, -0.05462575f, 0.00579438f, 0.00177839f, 0.27431661f, -0.12805343f, -0.26844999f, 
    0.04824360f, -0.02321465f, -0.02480979f, 0.01854404f, 0.02389342f, -0.01921878f, -0.05581778f, 0.03484000f, 
    -0.02283103f, 0.12799643f, -0.19265376f, 0.02812088f, 0.04501455f, 0.01148103f, 0.03229215f, 0.05915941f, 
    -0.05904783f, -0.04266148f, -0.05882972f, 0.00127122f, -0.10912706f, -0.14942741f, 0.30581710f, 0.06326586f, 
    0.02246097f, -0.06395613f, -0.12237112f, -0.16100557f, 0.05431456f, 0.09541807f, 0.04146576f, 0.01540349f, 
    -0.31862107f, 0.02144589f, 0.08749143f, -0.18453559f, 0.13742375f, -0.04667695f, 0.02092309f, -0.01608782f, 
    0.00445997f, 0.03675159f, 0.09512631f, 0.14220577f, -0.30832073f, 0.11242887f, 0.06087543f, 0.06851899f, 
    0.09263266f, -0.07682712f, 0.03400086f, 0.06142506f, 0.15855914f, 0.04814608f, -0.01937873f, 0.00320080f, 
    0.06861060f, -0.16941239f, -0.14674145f, 0.10232033f, 0.09544778f, -0.10472254f, -0.04896791f, 0.07262582f, 
    0.12298810f, 0.04539357f, -0.04564518f, 0.04495512f, 0.42188194f, 0.01839318f, -0.05508897f, 0.00969971f, 
    0.09029037f, 0.02532673f, 0.10255300f, 0.08602522f, -0.08415782f, -0.10669526f, -0.02374032f, -0.01693303f, 
    0.21425858f, 0.03172010f, 0.04662482f, 0.02308903f, 0.19151898f, 0.09348339f, -0.06622440f, -0.04111142f, 
    0.06769813f, 0.16897787f, 0.07856680f, -0.13667983f, 0.04864676f, 0.08788835f, 0.09191258f, 0.01782612f, 
    0.06857719f, -0.08937930f, 0.04437863f, -0.07895549f, 0.06948414f, 0.03997943f, 0.03752624f, -0.23351851f, 
    0.05629141f, -0.16209085f, 0.02435754f, 0.30943817f, 0.08956497f, -0.05402292f, 0.12236498f, -0.16160005f, 
    0.01594133f, 0.00430454f, 0.01687397f, -0.10453381f, 0.09235956f, 0.09080286f, -0.03761258f, -0.05017138f, 
    0.01373176f, -0.02180708f, 0.03894834f, -0.03546552f, -0.00393965f, 0.05880411f, 0.06066452f, -0.07654501f, 
    0.24351554f, -0.25386932f, 0.11133440f, -0.25985399f, -0.08018091f, 0.00793818f, 0.05021245f, -0.03865458f, 
    0.09328254f, -0.02048737f, 0.01787182f, -0.00040530f, 0.19076045f, -0.18274659f, -0.03663963f, 0.07524127f, 
    -0.06756930f, -0.01081809f, 0.11711138f, -0.04895208f, 0.14350444f, -0.10133963f, 0.06563640f, -0.04640707f, 
    -0.23925389f, -0.06893217f, 0.01805527f, -0.11683884f, -0.01089393f, -0.02824733f, -0.17127152f, 0.08199850f, 
    -0.04468439f, -0.05523575f, 0.10291742f, -0.01083112f, -0.07370117f, -0.01278065f, -0.03928474f, 0.17506358f, 
    0.08037727f, 0.04827733f, 0.06732727f, -0.12951297f, 0.13644373f, 0.08315571f, 0.00270340f, -0.00837687f, 
    -0.16978619f, 0.02770421f, 0.09540852f, -0.11034869f, -0.11777452f, -0.03985758f, -0.01358621f, -0.04967999f, 
    -0.07298912f, 0.05377042f, 0.02559398f, 0.11142580f, 0.41731191f, 0.03627983f, 0.18882093f, 0.18736842f, 
    -0.23472102f, 0.00214685f, 0.10366566f, 0.02964984f, -0.00012146f, -0.02625906f, -0.02443945f, -0.00293558f, 
    -0.27568004f, 0.08278375f, 0.20515826f, -0.12264197f, -0.01325352f, 0.01152726f, -0.03881133f, -0.08429451f, 
    -0.08609774f, 0.04017697f, 0.02763877f, -0.03275953f, 0.08490967f, 0.08870613f, -0.13636857f, 0.04474182f, 
    -0.01090735f, -0.15396668f, 0.01196531f, 0.01538813f, -0.03477051f, -0.00580100f, 0.02864425f, 0.05893423f, 
    0.31327122f, 0.04456138f, -0.15779133f, -0.00201761f, -0.07801845f, 0.07175706f, 0.00379429f, -0.06423766f, 
    0.01814012f, 0.12840135f, 0.00113000f, 0.19681194f, 0.17831956f, -0.00316348f, 0.01352253f, 0.21676598f, 
    0.02115130f, 0.02331097f, -0.02989512f, 0.06057736f, -0.10608944f, 0.11538154f, 0.00381251f, 0.03347391f, 
    0.29803467f, 0.14304723f, 0.16698784f, 0.18923859f, -0.03167690f, -0.02395729f, -0.07016698f, 0.11918170f, 
    -0.02382204f, 0.01820179f, -0.04089610f, -0.19163781f, 0.01391785f, 0.22414768f, -0.04119555f, -0.19935326f, 
    0.09305279f, 0.07375713f, -0.03401329f, -0.15317608f, 0.05494322f, -0.01624902f, 0.00574652f, 0.07631952f, 
    -0.22953659f, 0.03710835f, -0.04385427f, -0.00087859f, -0.12733658f, -0.02474011f, 0.02503214f, 0.01510707f, 
    0.12394545f, 0.02408183f, -0.02524007f, -0.04943116f, 0.08365379f, 0.06793347f, -0.07344310f, -0.14191583f, 
    0.08779030f, -0.02864261f, 0.00595286f, -0.03162198f, 0.05126822f, 0.06154316f, -0.02028597f, 0.09152322f, 
    0.05012693f, -0.00605548f, -0.04758953f, 0.02117588f, 0.04003324f, 0.04141094f, 0.05283137f, 0.01887768f, 
    -0.04776557f, -0.02272041f, 0.02544268f, 0.01523058f, 0.03145262f, 0.02425521f, 0.01420677f, 0.03696444f, 
    0.03119457f, -0.05876650f, -0.07315417f, 0.02082904f, -0.01527087f, -0.03379412f, -0.04480802f, 0.05056575f, 
    -0.05772310f, 0.04999214f, 0.01800608f, -0.07167864f, -0.03423987f, -0.07836346f, 0.01676760f, 0.05418039f, 
    -0.07331113f, -0.03510026f, -0.01093454f, -0.06947555f, -0.03876137f, -0.01546421f, 0.03464227f, 0.01888861f, 
    0.04486575f, 0.06121005f, 0.06085069f, -0.07799758f, 0.02999311f, 0.05853283f, 0.02708162f, -0.06609304f, 
    0.04702358f, -0.02015267f, -0.03083832f, -0.00903040f, -0.03279914f, 0.04430568f, -0.01813099f, -0.06575479f, 
    -0.00870216f, -0.06081646f, -0.07801988f, -0.02571142f, 0.03338537f, 0.05126856f, -0.04969580f, -0.03306265f, 
    0.04605485f, -0.06976490f, 0.03956401f, -0.02791384f, -0.02264125f, 0.01526408f, 0.00252710f, -0.05396917f, 
    -0.03842277f, 0.00447543f, 0.01515601f, 0.02468391f, 0.05539973f, 0.00499745f, -0.04058927f, -0.02153207f, 
    -0.01483330f, -0.06760507f, -0.06726062f, -0.00048998f, -0.06307516f, -0.02784279f, 0.00302217f, 0.01244828f, 
    0.04505057f, 0.01613272f, 0.03926596f, 0.00455579f, -0.04942958f, 0.00411776f, 0.03221903f, -0.07134150f, 
    -0.07203636f, -0.04031625f, 0.02779951f, -0.04836401f, -0.03353298f, 0.05333364f, -0.06709252f, -0.03847664f, 
    -0.01492207f, 0.01811929f, 0.01666359f, -0.00106710f, 0.05526779f, 0.02779564f, 0.00489165f, 0.05924953f, 
    0.00789456f, -0.05560830f, -0.01989751f, -0.01440724f, -0.01850843f, -0.07461284f, -0.00739737f, 0.00148121f, 
    -0.04212086f, -0.06378055f, 0.04188998f, 0.02738884f, -0.07652027f, -0.01258594f, -0.06714036f, -0.07608514f, 
    0.04385032f, 0.03504294f, 0.02306332f, -0.07483198f, 0.00140290f, -0.05405895f, 0.05838371f, -0.04058270f, 
    0.04534747f, 0.02979374f, -0.01228886f, 0.01047812f, -0.02725575f, 0.03643143f, -0.05421013f, -0.01907298f, 
    -0.07704396f, 0.04634550f, 0.06219046f, -0.06944338f, -0.07845552f, 0.01181762f, -0.06687998f, 0.03337811f, 
    -0.05224112f, 0.06157991f, -0.06737964f, -0.00920506f, -0.07181216f, 0.01913225f, -0.08136285f, -0.00654817f, 
    0.05138945f, -0.05779048f, 0.03949192f, -0.00848642f, 0.03626744f, 0.04343521f, 0.03482725f, 0.00687851f, 
    -0.04559159f, 0.05457988f, -0.06910617f, -0.03729439f, 0.02339622f, -0.01758848f, 0.03682002f, -0.05680819f, 
    -0.03711212f, -0.06737917f, -0.07337319f, -0.06399107f, -0.03758382f, 0.04773081f, 0.01275379f, -0.02059105f, 
    0.05333650f, -0.07308219f, 0.03946480f, 0.03657591f, 0.03559475f, 0.02143646f, -0.05642910f, -0.03137633f, 
    -0.00357046f, -0.04260783f, 0.02172004f, 0.04205577f, -0.02570115f, -0.01675475f, 0.01912367f, 0.00251929f, 
    0.04612075f, -0.05317674f, -0.00151536f, -0.01172361f, -0.07611676f, -0.02367370f, -0.06391032f, -0.07160723f, 
    0.01131857f, 0.04946030f, -0.03387414f, -0.04760310f, -0.03912106f, 0.06486661f, -0.04128355f, 0.06518298f, 
    -0.06351995f, 0.04759018f, -0.03784021f, -0.01598856f, 0.02160268f, 0.03791377f, -0.06672206f, 0.03758290f, 
    -0.04537883f, -0.06675854f, -0.05514549f, -0.03783591f, -0.07527807f, -0.00067424f, -0.01849454f, -0.06769987f, 
    -0.05400784f, 0.00635892f, 0.04262684f, -0.02253982f, 0.01996731f, 0.03222276f, -0.03445222f, -0.01445471f, 
    0.00261007f, 0.02161679f, -0.06979272f, -0.06456079f, 0.00090403f, -0.06810348f, -0.04851937f, -0.02521127f, 
    -0.00861864f, 0.02253967f, 0.01942554f, 0.01929481f, -0.03612491f, 0.04554188f, -0.00412822f, -0.02574233f, 
    0.01218570f, 0.05892865f, -0.05443921f, -0.07786678f, -0.00977775f, -0.02039619f, -0.01870292f, 0.05409903f, 
    -0.07707809f, 0.01846222f, -0.00796905f, -0.04042185f, -0.03746543f, -0.00681438f, -0.05279912f, 0.01950638f, 
    -0.04860127f, -0.05114953f, -0.06191877f, -0.01448981f, 0.05488517f, -0.00744039f, -0.02054047f, -0.00752189f, 
    0.02191622f, 0.00520313f, 0.03836974f, -0.06760762f, -0.07095169f, 0.05394320f, 0.05988107f, 0.02401676f, 
    -0.07415755f, 0.05001039f, 0.04181124f, 0.03954419f, 0.02356679f, -0.01084292f, 0.01799751f, 0.01478981f, 
    -0.05813785f, 0.00613150f, -0.06096802f, 0.01842608f, -0.07765357f, -0.00791497f, -0.04784350f, 0.05306174f, 
    0.01090541f, 0.05426425f, -0.07516117f, -0.04093441f, 0.01384219f, -0.04624870f, 0.02671431f, 0.06159441f, 
    -0.01254658f, -0.05981712f, -0.05852838f, -0.02193512f, 0.04227614f, -0.04091093f, -0.03484841f, -0.05477366f, 
    0.01058328f, -0.02312269f, -0.02526722f, -0.07074842f, -0.02623496f, -0.05742763f, 0.02532180f, -0.01956274f, 
    -0.02469595f, -0.05826117f, -0.07454208f, 0.00996485f, -0.00087483f, -0.01215424f, 0.01951937f, 0.03605926f, 
    0.03252313f, 0.03974134f, 0.01959507f, -0.03404379f, -0.02598773f, 0.02384519f, -0.04556172f, -0.01400775f, 
    0.06385975f, 0.01422288f, -0.05374881f, 0.00341922f, 0.01032320f, -0.01849983f, 0.03108740f, -0.03311889f, 
    0.06010503f, -0.02808439f, 0.05851232f, -0.04082114f, -0.04733021f, -0.03971406f, -0.07714204f, 0.02697010f, 
    -0.05285130f, 0.05415064f, -0.04390606f, -0.04238409f, -0.00808587f, 0.04235778f, -0.05181782f, -0.00932870f, 
    0.06425899f, -0.06589264f, 0.06010751f, 0.05715738f, -0.00506219f, -0.06318802f, -0.05992743f, 0.02129264f, 
    -0.02373912f, -0.03453076f, 0.04958427f, 0.03803965f, 0.03501076f, 0.00412442f, -0.01469277f, -0.03892756f, 
    0.05130077f, -0.09026862f, -0.07214864f, -0.01202752f, -0.02764134f, -0.00550644f, -0.04331054f, -0.03640621f, 
    -0.02776916f, 0.11318084f, 0.03196807f, -0.02736332f, 0.30843866f, -0.27940825f, 0.14918573f, -0.11532806f, 
    -0.10260926f, -0.03839159f, 0.14518099f, -0.10062419f, 0.01740068f, 0.00695306f, -0.05978539f, 0.00951028f, 
    -0.01566116f, 0.00684837f, -0.15436940f, 0.20891672f, 0.00455361f, 0.03095657f, -0.05028528f, 0.00144908f, 
    0.02110818f, -0.00595502f, -0.02373079f, -0.00975322f, -0.15191008f, -0.16569328f, 0.00881999f, 0.12867117f, 
    -0.01581711f, 0.04792938f, -0.04005042f, 0.05722170f, 0.06239390f, 0.04782904f, -0.00019491f, 0.02122943f, 
    0.06822097f, -0.08370774f, -0.13378929f, 0.09878518f, 0.03597509f, -0.10536632f, -0.06861013f, -0.06963658f, 
    0.06409916f, 0.06024751f, 0.09164011f, 0.06436837f, 0.18702780f, 0.03953683f, -0.17182538f, 0.27266538f, 
    0.11976637f, 0.00409894f, 0.01701738f, 0.05818830f, 0.00915223f, 0.01937056f, 0.00606027f, -0.05141131f, 
    -0.10594923f, 0.10726170f, 0.11150794f, 0.08765265f, -0.11400743f, 0.07678272f, 0.06020090f, 0.09355952f, 
    0.05297191f, -0.03186392f, 0.05447951f, 0.05808023f, 0.24743518f, 0.09250995f, -0.06801398f, -0.09943189f, 
    0.08774147f, -0.04696597f, 0.07823735f, -0.09704618f, 0.03209788f, 0.04864838f, -0.02608488f, -0.03891388f, 
    -0.22310019f, 0.09956948f, 0.18985993f, -0.20631774f, 0.16433677f, -0.00571720f, -0.00179622f, 0.02865788f, 
    0.05511558f, 0.04526171f, -0.04283154f, -0.02047388f, 0.06658654f, -0.04605089f, 0.10290995f, -0.05151256f, 
    0.17953275f, 0.01026883f, -0.13717593f, -0.07031287f, 0.08099963f, 0.13135698f, 0.10290316f, 0.02692172f, 
    -0.09017860f, 0.15563241f, -0.25140038f, 0.13574527f, -0.00894124f, 0.01243682f, -0.04184473f, -0.18967287f, 
    0.13322251f, 0.01571393f, -0.01594522f, 0.14623997f, -0.22611590f, -0.03025022f, 0.05652912f, 0.00844509f, 
    0.03507750f, 0.09055014f, 0.00998420f, -0.06752884f, -0.01842785f, 0.13596374f, 0.09215792f, -0.10711797f, 
    0.03122451f, 0.05654180f, -0.20286715f, 0.02604594f, 0.06202163f, 0.01349694f, -0.00795528f, 0.01224775f, 
    -0.03017255f, 0.10281103f, 0.00746527f, -0.03973965f, -0.03752554f, 0.04651070f, 0.17288864f, 0.08276993f, 
    0.02742462f, -0.02265268f, 0.17098187f, -0.16224098f, 0.11409012f, 0.07688329f, -0.01264828f, -0.06563468f, 
    0.02300216f, 0.19608968f, 0.04867408f, 0.21484561f, -0.07714019f, 0.09515569f, -0.02459450f, 0.01504468f, 
    0.08062290f, -0.07807366f, 0.07246318f, -0.09314691f, -0.13607319f, 0.19895634f, 0.08700348f, 0.17712098f, 
    -0.20835611f, -0.09940127f, 0.08525773f, 0.04105648f, -0.00581622f, 0.15057993f, -0.02986735f, -0.17952225f, 
    -0.34301379f, 0.12434974f, -0.02796127f, -0.10574664f, -0.02407517f, 0.00772646f, 0.03337806f, 0.17516501f, 
    0.09028527f, -0.13227020f, -0.03726468f, 0.04893180f, -0.19924112f, 0.31361926f, -0.00955764f, -0.08438051f, 
    -0.02459874f, 0.05439039f, 0.04475388f, -0.03098365f, 0.15436670f, -0.01152944f, -0.02870215f, 0.05627881f, 
    -0.24410369f, -0.09734707f, 0.09676284f, -0.22472911f, 0.07712650f, 0.07312156f, -0.08536069f, -0.17480391f, 
    -0.01901837f, -0.10987110f, -0.06708903f, 0.01159096f, 0.07938506f, -0.16035746f, 0.10454094f, 0.30906951f, 
    0.06841946f, 0.16990118f, -0.00585687f, -0.05949188f, 0.04128578f, -0.01250388f, -0.06626505f, 0.07103358f, 
    0.24453165f, -0.05907904f, 0.08489191f, 0.05375471f, -0.03458869f, -0.02572650f, 0.19822438f, -0.04050667f, 
    -0.07033426f, 0.08278175f, -0.13625543f, -0.06566765f, 0.17411752f, -0.01180577f, 0.18082465f, -0.10509568f, 
    0.02349775f, 0.03305841f, 0.02036650f, 0.16849290f, 0.06018164f, 0.01171510f, 0.14145723f, 0.04459302f, 
    -0.00547278f, -0.05420194f, 0.11948700f, 0.07732401f, -0.00737351f, -0.14484042f, 0.16735283f, 0.02620854f, 
    0.02180984f, -0.09430305f, 0.04746987f, -0.07239809f, 0.02751122f, -0.20939888f, 0.19097877f, 0.37356162f, 
    -0.04918889f, 0.09567432f, -0.04286386f, -0.05098866f, 0.10436387f, -0.03684139f, 0.02769566f, 0.04102519f, 
    -0.03117854f, -0.12534383f, -0.02222458f, -0.05265937f, 0.01528860f, -0.13810760f, 0.04096721f, 0.07935116f, 
    0.01888158f, 0.02084915f, -0.09545103f, 0.03147281f, -0.17248327f, -0.14408574f, -0.06792529f, 0.14404728f, 
    0.03549210f, 0.21351092f, 0.06006785f, -0.04620709f, 0.12204212f, -0.02868879f, -0.04121237f, -0.01985266f, 
    0.07796191f, 0.08119852f, 0.07602070f, -0.28898066f, -0.11649955f, -0.02395245f, 0.08813266f, 0.11967655f, 
    -0.02956316f, -0.08199988f, 0.06327621f, 0.02183017f, 0.57579213f, -0.18290119f, -0.04154973f, -0.06020215f, 
    0.01658184f, 0.04738497f, 0.05937775f, 0.08975234f, -0.02438348f, 0.02783567f, 0.07290924f, -0.02037729f, 
    0.02178582f, -0.25259727f, -0.05510475f, 0.31923947f, 0.00717132f, -0.06816413f, 0.02563625f, 0.01114440f, 
    0.09549482f, -0.01425203f, 0.10289478f, 0.12647589f, 0.02698965f, 0.20479389f, -0.00819562f, 0.00978431f, 
    -0.10884929f, -0.05552526f, -0.05800105f, -0.02600937f, 0.13123937f, 0.04204217f, -0.03671606f, -0.04682852f, 
    -0.15541610f, -0.16507953f, 0.05640641f, -0.00947964f, 0.06078804f, -0.05632181f, 0.07623260f, 0.17689450f, 
    -0.07510509f, -0.02886667f, -0.04954441f, 0.14496189f, -0.18095969f, 0.05689820f, 0.11664094f, 0.14552346f, 
    -0.02019439f, 0.03599283f, -0.01035452f, -0.14052890f, -0.06387237f, -0.11285924f, 0.09272242f, -0.02597105f, 
    0.01630954f, -0.04553637f, -0.02092561f, 0.05604590f, -0.06485648f, -0.00544742f, -0.06552050f, -0.04029406f, 
    -0.06868022f, 0.02773923f, 0.01097971f, -0.06196515f, -0.02245313f, 0.05814504f, -0.04967847f, -0.01237698f, 
    0.03968757f, 0.01039535f, -0.05061534f, -0.07266477f, -0.02535535f, -0.06162019f, 0.05124535f, 0.04700931f, 
    0.02268815f, 0.04481864f, -0.06878895f, 0.03168658f, 0.05477953f, -0.04771207f, 0.05939483f, -0.02669028f, 
    -0.07063227f, -0.02668010f, -0.07692686f, 0.03108276f, 0.03440058f, 0.03638258f, 0.00992966f, -0.02177284f, 
    -0.07534580f, -0.05181789f, 0.03359843f, -0.01351795f, -0.04729753f, -0.04888690f, -0.05218397f, 0.01311912f, 
    0.00416198f, 0.04308731f, -0.00760530f, 0.00188613f, -0.02901667f, -0.06406705f, 0.00685223f, -0.03984120f, 
    -0.07859217f, 0.02719663f, 0.06069563f, -0.02164966f, 0.05663973f, -0.03021041f, -0.00232797f, -0.08195560f, 
    0.01616957f, -0.01844027f, -0.01470153f, -0.04468797f, -0.01950204f, 0.02652479f, 0.02565403f, -0.02495075f, 
    -0.01358154f, 0.02648805f, -0.06405456f, 0.04480708f, 0.02967043f, -0.04963576f, -0.06981983f, -0.04299259f, 
    0.04610164f, -0.03475103f, -0.00562162f, -0.06030286f, 0.04599518f, -0.03988142f, -0.00269087f, 0.01444514f, 
    -0.06476647f, -0.02178350f, 0.05000803f, -0.08449934f, -0.01498265f, -0.08322778f, -0.04775470f, 0.05497650f, 
    -0.06479630f, -0.00463272f, 0.02898032f, -0.00500858f, -0.02853456f, -0.01147426f, 0.01098516f, 0.06114113f, 
    0.04848045f, 0.00070189f, 0.00623624f, -0.04829890f, -0.07151021f, -0.07698439f, -0.05979568f, -0.08390273f, 
    -0.04668247f, -0.04954619f, -0.06874464f, -0.00275549f, -0.03763822f, 0.05172867f, 0.03594058f, -0.03472726f, 
    0.00251006f, -0.00483324f, -0.00009999f, -0.01184869f, -0.06541523f, 0.01502321f, -0.05660164f, -0.05526654f, 
    0.04159177f, -0.00914735f, -0.08009769f, -0.04516038f, 0.02464803f, 0.06016445f, -0.06724342f, 0.04505045f, 
    0.03586026f, 0.05211799f, -0.01715123f, -0.06425835f, -0.06247016f, -0.07999607f, -0.03786791f, 0.04661507f, 
    -0.04803051f, -0.06219354f, 0.02581054f, -0.03729104f, -0.07496575f, 0.06089354f, -0.02846412f, 0.00270917f, 
    0.05135666f, 0.03153395f, -0.04039707f, -0.04535233f, -0.06971943f, -0.07188105f, 0.05998578f, -0.00342003f, 
    0.00814214f, -0.04625621f, -0.02197859f, -0.01302145f, 0.00015436f, -0.01804802f, -0.01555848f, -0.06663483f, 
    0.02290630f, -0.01529299f, 0.04519341f, 0.04907905f, -0.01466429f, 0.03868122f, -0.01179906f, -0.00031441f, 
    -0.06852762f, 0.04815852f, 0.01186616f, -0.06917281f, 0.03580490f, -0.02957997f, 0.00868885f, 0.01753691f, 
    0.02674657f, 0.02887202f, 0.02664622f, -0.05475816f, 0.03417224f, 0.03796209f, -0.02172270f, -0.05228769f, 
    -0.19532906f, 0.11120871f, -0.04320844f, 0.15556347f, -0.11409678f, 0.10715351f, -0.08247212f, -0.07644481f, 
    0.01639364f, -0.05216295f, 0.00422647f, -0.16290836f, -0.17689987f, 0.01000934f, 0.02228527f, -0.00460750f, 
    -0.05582699f, 0.05907179f, 0.01943713f, -0.04908531f, 0.08990400f, -0.05617601f, -0.02436704f, 0.02073499f, 
    -0.01601890f, -0.15711010f, 0.21388066f, -0.11090279f, 0.13246594f, 0.00367268f, -0.10769220f, -0.09313817f, 
    -0.06052047f, 0.01922452f, 0.07656114f, 0.13470535f, -0.06018984f, -0.09455562f, -0.04885966f, 0.11809801f, 
    -0.05729048f, -0.01254193f, -0.03710601f, -0.00242206f, 0.00498146f, 0.02017779f, 0.14287265f, 0.04189276f, 
    -0.02905052f, -0.07508377f, 0.12654629f, 0.19034791f, 0.03898316f, 0.04567480f, 0.17839408f, -0.01329130f, 
    -0.10135428f, -0.03866965f, -0.32609361f, -0.13231394f, 0.14030036f, 0.20602077f, -0.13138163f, 0.12425338f, 
    0.26831850f, 0.03004181f, -0.07667661f, -0.14943758f, -0.14093712f, 0.07782371f, 0.04183678f, -0.14742610f, 
    0.15653284f, 0.10599568f, -0.19525976f, 0.15433447f, 0.05604756f, 0.05961366f, 0.12581816f, -0.01360259f, 
    0.13230439f, 0.07671711f, -0.02313634f, -0.03986655f, 0.04163864f, -0.09169983f, 0.24438316f, 0.16040020f, 
    -0.04214101f, 0.13077171f, 0.14164162f, -0.02121724f, 0.07996012f, 0.03894506f, 0.10926294f, 0.03655925f, 
    -0.01726249f, -0.01545866f, -0.18114558f, 0.08781798f, -0.03683601f, 0.01659540f, 0.08537872f, 0.07191887f, 
    0.07581759f, -0.00453907f, -0.09624772f, -0.07959276f, -0.37879476f, 0.08365489f, 0.09733256f, 0.21518771f, 
    -0.23388132f, 0.05806670f, -0.03901051f, -0.05866615f, -0.07344100f, -0.15289712f, 0.05335594f, -0.00541379f, 
    -0.22259459f, -0.00409381f, -0.15513574f, -0.20342161f, 0.01561233f, -0.04900047f, 0.09271488f, -0.07660607f, 
    0.05760290f, 0.10672372f, 0.10878612f, -0.03034814f, 0.34863102f, -0.06152953f, -0.03561912f, -0.10253220f, 
    -0.13326544f, -0.13064343f, -0.02633755f, -0.01174360f, -0.07315166f, -0.12988132f, 0.02738330f, 0.01601096f, 
    0.23510250f, 0.11178776f, -0.01364933f, 0.03437179f, 0.08712545f, 0.01996957f, -0.03092746f, 0.02993643f, 
    -0.05627400f, 0.04490736f, 0.00947160f, 0.17634258f, 0.06376449f, 0.27762875f, -0.15141776f, 0.03689926f, 
    0.12364343f, 0.03738340f, -0.06361394f, -0.03237692f, 0.09955908f, -0.12818146f, -0.10582204f, -0.03774724f, 
    0.17222871f, -0.03743449f, 0.14939308f, 0.44444799f, 0.08515482f, -0.00085281f, 0.01682929f, 0.12701155f, 
    0.01317388f, 0.11087877f, 0.09521335f, 0.14765383f, 0.22516571f, 0.12581804f, 0.13749745f, 0.06269848f, 
    0.04688688f, -0.18393531f, -0.00243166f, -0.05791759f, 0.03719847f, -0.12285804f, 0.00749340f, -0.05694059f, 
    -0.28438640f, -0.17895126f, 0.04796861f, -0.06683221f, 0.08253386f, -0.04574443f, -0.07042459f, -0.08129835f, 
    0.11398429f, 0.06801393f, 0.06772094f, 0.04111544f, 0.26157781f, -0.07037342f, 0.13670722f, -0.01075504f, 
    -0.15264536f, -0.01743358f, -0.03936182f, -0.04067773f, 0.23082657f, -0.02512312f, -0.08785305f, 0.15077837f, 
    0.23542678f, 0.15932810f, 0.08247886f, 0.42397714f, 0.01004313f, 0.00750397f, -0.19127607f, 0.04795842f, 
    -0.16513121f, 0.14234315f, 0.08037762f, -0.03914377f, -0.06547891f, -0.18449929f, -0.13282885f, 0.05039621f, 
    0.07436841f, -0.06333507f, -0.07840200f, -0.07996027f, -0.05812463f, -0.02801560f, 0.08302941f, 0.03375696f, 
    0.35139933f, 0.12939179f, 0.01016376f, 0.18720326f, -0.06775524f, -0.03543231f, 0.14667150f, 0.01101617f, 
    0.06450518f, -0.11449175f, 0.09291531f, 0.08966690f, -0.25897157f, 0.10859813f, -0.06111769f, 0.21390286f, 
    -0.07256424f, 0.13731782f, 0.22608791f, 0.02481967f, -0.08451687f, 0.15752470f, -0.00227153f, 0.03794133f, 
    0.24741739f, 0.10181446f, 0.05813246f, 0.08743297f, -0.06158654f, -0.07343667f, -0.01047094f, 0.00352285f, 
    0.05043507f, 0.00515355f, -0.01190007f, 0.00372960f, -0.04112038f, -0.32445121f, -0.30715320f, -0.38781193f, 
    0.05424172f, 0.08331762f, -0.06361421f, -0.13090566f, -0.09006591f, -0.11917962f, -0.01711149f, -0.11636801f, 
    0.06594928f, 0.14275514f, 0.25589195f, 0.24034062f, 0.06377430f, 0.01790573f, 0.03103579f, 0.14111744f, 
    -0.19375774f, 0.04323621f, -0.06195780f, -0.01328598f, 0.05505027f, 0.05042740f, 0.02660112f, -0.02860516f, 
    0.12245816f, 0.08836997f, -0.17321181f, -0.04766702f, 0.22234634f, -0.00419378f, 0.07797860f, 0.03954309f, 
    0.16941513f, 0.04518453f, -0.13601455f, 0.19311891f, 0.02082485f, 0.02289420f, -0.13090417f, 0.02816480f, 
    0.05951649f, 0.19741482f, 0.00262436f, -0.03769483f, -0.16271137f, -0.28084540f, -0.22254826f, -0.06575768f, 
    0.13453628f, 0.07268216f, -0.00465753f, 0.07729879f, 0.09327786f, -0.17037445f, -0.00325681f, 0.20406817f, 
    -0.15077813f, -0.21012484f, -0.40192053f, -0.28838128f, 0.04382424f, 0.03514332f, -0.10915012f, -0.00545864f, 
    0.18664457f, -0.11418649f, 0.05694940f, 0.06917592f, -0.10787799f, 0.27047032f, 0.00921851f, -0.04315744f, 
    -0.02912000f, 0.06813201f, 0.17259863f, 0.13380395f, -0.10325875f, -0.03339384f, -0.05861780f, -0.01982103f, 
    0.34991512f, 0.20001160f, 0.36311814f, 0.25322762f, -0.23186611f, -0.03004317f, 0.01510469f, 0.01188487f, 
    -0.15200207f, 0.06832410f, 0.04753167f, 0.03491521f, 0.11093040f, 0.01328228f, -0.03667013f, 0.00164556f, 
    -0.15910539f, -0.11132511f, -0.02756280f, 0.00454131f, 0.12613426f, -0.01041771f, -0.04905955f, -0.11685433f, 
    0.15965927f, -0.01212744f, 0.05359526f, 0.21654180f, 0.02739796f, 0.11920682f, 0.12707783f, -0.09146917f, 
    -0.06990565f, 0.09738160f, 0.00907320f, -0.00747296f, 0.01145989f, 0.28090277f, -0.19006455f, -0.00980952f, 
    0.04326668f, 0.09210064f, 0.00252752f, 0.01753120f, -0.02220949f, -0.00035349f, -0.03863927f, -0.04695004f, 
    -0.12271415f, -0.00784693f, 0.14891759f, -0.26031515f, 0.11230900f, 0.04094289f, 0.10010941f, 0.06686442f, 
    0.07778367f, -0.01378666f, 0.10716358f, 0.21649678f, 0.28462359f, -0.12772030f, 0.03101546f, -0.12706436f, 
    0.09523447f, -0.14425521f, 0.05007587f, -0.00665107f, 0.03323347f, -0.11988869f, 0.16965909f, 0.10106815f, 
    -0.12151862f, -0.08437332f, 0.06904208f, -0.07652866f, 0.01963896f, -0.02251210f, -0.00626789f, 0.04357091f, 
    0.02086064f, -0.08263546f, -0.09360234f, -0.00554474f, -0.05473343f, -0.06369807f, -0.27104113f, 0.00399203f, 
    0.02779101f, -0.02666514f, -0.01448789f, -0.11578420f, 0.11470950f, 0.02594492f, 0.03948731f, -0.09998944f, 
    0.17621361f, 0.03142206f, -0.10210789f, -0.04397353f, -0.07254414f, 0.01297757f, 0.02272863f, 0.02564476f, 
    0.13166632f, 0.08549181f, 0.06039101f, 0.02566732f, 0.05372478f, -0.05338589f, 0.03916332f, 0.06083643f, 
    0.10754424f, 0.04187298f, 0.02223258f, -0.07489137f, 0.05700628f, 0.03685434f, -0.00460778f, 0.02960342f, 
    0.04084413f, 0.00678231f, 0.03820998f, -0.06490573f, -0.02539294f, 0.05661148f, -0.01619050f, -0.18115434f, 
    0.11825121f, -0.01174760f, 0.12197910f, -0.02417029f, -0.04939634f, 0.19584110f, -0.04386420f, 0.06527311f, 
    0.03811019f, 0.01593929f, 0.08552986f, 0.04249673f, -0.11237966f, -0.08006170f, 0.04269408f, -0.07205462f, 
    0.05370592f, -0.01478106f, -0.11424834f, -0.03486037f, 0.01230354f, 0.08172602f, -0.04807082f, -0.19376864f, 
    -0.02261163f, 0.03207713f, -0.02685128f, 0.09328140f, 0.32457015f, -0.08235109f, 0.04204220f, 0.06305572f, 
    -0.00412326f, -0.13757156f, -0.00452871f, 0.07700774f, 0.00846666f, 0.01972456f, 0.04673454f, 0.00230137f, 
    -0.01267934f, 0.12478293f, 0.21587376f, -0.17389302f, 0.09911446f, 0.02557345f, -0.13722014f, 0.06531418f, 
    0.01897506f, 0.00798261f, -0.04430452f, 0.00371942f, -0.01001241f, 0.00929259f, 0.04668468f, -0.07863160f, 
    0.09473936f, 0.09964973f, -0.03105208f, 0.17693199f, 0.05458633f, 0.02257394f, -0.04359043f, 0.07020535f, 
    -0.21247822f, 0.02258390f, -0.01013221f, -0.09733371f, -0.07306254f, -0.00649353f, 0.00246003f, -0.17396685f, 
    0.10742936f, 0.05050446f, 0.00676201f, 0.02831172f, 0.29262358f, 0.06620790f, -0.07342375f, -0.11804029f, 
    0.03928980f, -0.02428718f, 0.08302836f, 0.13107274f, 0.04709031f, -0.10974526f, -0.10688596f, 0.04336685f, 
    -0.02956565f, -0.03187826f, -0.07314441f, -0.06168808f, 0.05427670f, -0.03456379f, -0.01902173f, -0.05523901f, 
    0.01831739f, 0.01911224f, -0.00230652f, -0.01683193f, 0.01736415f, -0.02288403f, 0.05960526f, -0.06880886f, 
    -0.08615297f, 0.04531512f, -0.07602310f, 0.05438303f, 0.02564523f, -0.00400760f, 0.05603197f, 0.04673548f, 
    -0.06479471f, 0.06896968f, 0.03701123f, -0.04097060f, 0.02681342f, 0.03306638f, 0.00980172f, -0.04401165f, 
    -0.03977245f, -0.03857622f, -0.06809845f, 0.02505128f, 0.05316614f, 0.00444987f, 0.05814857f, -0.07181674f, 
    0.04629394f, -0.07732398f, 0.06090482f, 0.05201824f, -0.02528122f, -0.05717808f, -0.05351854f, 0.01215597f, 
    -0.03607507f, 0.00192498f, 0.05443210f, -0.05235609f, -0.03790319f, 0.03202172f, 0.00802074f, 0.00165778f, 
    -0.03886325f, 0.00188304f, -0.02973869f, 0.03347083f, -0.04624105f, -0.01917481f, 0.03014340f, 0.03193431f, 
    -0.02782295f, -0.01869275f, -0.04281788f, 0.00968161f, 0.01304390f, 0.02955856f, -0.01236431f, -0.04462460f, 
    0.04665790f, -0.03997240f, -0.02769492f, 0.04980006f, 0.02228508f, 0.02210145f, 0.01983126f, -0.00261728f, 
    0.00832046f, 0.03582153f, 0.00086218f, 0.00568941f, -0.05796822f, -0.08050157f, 0.00614878f, -0.05979585f, 
    -0.03611970f, -0.00269131f, -0.04824818f, 0.04877664f, 0.01075899f, 0.02013266f, 0.03466987f, -0.05500733f, 
    -0.05178016f, 0.02372495f, 0.02352229f, -0.04850558f, -0.04982639f, -0.02870471f, 0.01162159f, 0.02794287f, 
    -0.08270504f, -0.00755754f, -0.07116809f, -0.06428345f, 0.03699681f, 0.05191517f, -0.06086818f, -0.08419783f, 
    0.00277493f, -0.05834999f, -0.07437330f, -0.07939144f, -0.01910639f, 0.02671612f, -0.06855655f, -0.07555709f, 
    -0.00507899f, 0.00927571f, -0.00401329f, -0.00719864f, -0.02973447f, -0.00555754f, 0.03316638f, -0.00084877f, 
    -0.05285892f, -0.03984624f, -0.05534570f, 0.03122854f, -0.04195099f, 0.00409948f, -0.01426390f, -0.04181646f, 
    0.01521777f, -0.01729560f, 0.02785143f, 0.05408371f, -0.05596172f, -0.05321178f, -0.07234837f, 0.01850065f, 
    0.04630158f, 0.03083145f, -0.04082920f, -0.00008343f, 0.03067785f, -0.07268638f, 0.00219810f, -0.05774238f, 
    0.02616113f, 0.06606526f, 0.03783678f, 0.04966053f, 0.02904278f, 0.05671164f, 0.00305620f, -0.05711929f, 
    -0.03090424f, -0.04264990f, -0.07076699f, 0.00882238f, -0.06701135f, -0.02374426f, 0.02776753f, 0.04255880f, 
    -0.04176626f, 0.04557802f, 0.03469127f, 0.06269602f, -0.04733187f, 0.05328364f, 0.04019644f, 0.03646231f, 
    0.03957846f, -0.00764687f, 0.05894030f, 0.03684610f, -0.08061527f, -0.07327366f, 0.03156044f, -0.04821840f, 
    -0.04474899f, -0.05252626f, -0.06463455f, 0.00975096f, -0.05446661f, -0.07451115f, -0.04609917f, 0.05951023f, 
    -0.19287647f, 0.13291694f, -0.10045043f, 0.05773202f, 0.05174277f, 0.10668670f, -0.08638673f, 0.08448223f, 
    -0.03938485f, -0.14534280f, 0.00220778f, 0.01390955f, -0.20245168f, 0.08978336f, 0.13897267f, -0.14419824f, 
    0.03292630f, 0.05204532f, -0.16151668f, -0.05673660f, -0.03921963f, -0.08729798f, -0.00361214f, -0.09796242f, 
    0.10582707f, 0.03389149f, 0.03169032f, -0.32165888f, -0.00530495f, 0.08637308f, 0.00197029f, 0.12393319f, 
    -0.01554576f, -0.02912934f, -0.04195352f, 0.02273114f, -0.06008104f, 0.05070315f, -0.02400403f, -0.05504946f, 
    -0.22174698f, -0.01669762f, -0.03444868f, 0.11590063f, 0.12129041f, 0.09832219f, -0.09746368f, -0.06037744f, 
    -0.18824226f, 0.07555715f, 0.06791048f, -0.24390116f, -0.05455240f, -0.09996828f, -0.08880466f, 0.04883048f, 
    0.06430363f, -0.04048400f, 0.19513671f, 0.04231941f, 0.05391284f, -0.08926675f, 0.22250353f, -0.09473400f, 
    -0.00982933f, 0.02040214f, 0.16192433f, 0.07019065f, 0.12643240f, 0.12643310f, 0.01907855f, 0.07325855f, 
    -0.10568713f, 0.01577031f, 0.05569386f, -0.03274956f, 0.13265412f, -0.02606110f, -0.13062611f, -0.00933084f, 
    0.07352513f, -0.08145123f, -0.14091484f, 0.12947501f, 0.22386229f, 0.05877221f, -0.16178468f, -0.10702913f, 
    -0.16285232f, -0.10345341f, 0.08554571f, 0.21874630f, -0.15626997f, -0.07192814f, -0.00980797f, -0.10246897f, 
    -0.20857863f, 0.09399880f, -0.12258836f, 0.07079994f, -0.01818274f, 0.01538565f, -0.02650433f, 0.09103080f, 
    -0.05838318f, 0.00699778f, 0.06736515f, 0.09492953f, 0.25990707f, -0.21974702f, 0.01246574f, -0.00551566f, 
    -0.06736045f, -0.06886131f, 0.15066966f, 0.08643369f, -0.06926149f, 0.03658447f, -0.00069343f, 0.07950881f, 
    -0.03930285f, 0.01182678f, 0.24432442f, -0.26155996f, -0.03251673f, 0.08955009f, 0.03468113f, 0.10581940f, 
    -0.00889457f, 0.01199890f, -0.11419273f, -0.03778260f, -0.09622348f, 0.20354597f, 0.07409112f, 0.04593382f, 
    -0.01522110f, -0.08304185f, -0.03468209f, 0.15923351f, -0.08246055f, 0.21985294f, -0.06532111f, -0.04522311f, 
    0.19689675f, -0.13129716f, -0.00084686f, 0.19909841f, -0.21190339f, 0.08187377f, 0.00691075f, 0.06713298f, 
    0.15966456f, 0.09062741f, -0.06810036f, -0.04799909f, 0.25577667f, 0.03012209f, -0.04661598f, 0.04870522f, 
    0.00143110f, 0.09423260f, 0.01898205f, -0.00469199f, 0.02224137f, 0.01991514f, -0.02476633f, -0.03424067f, 
    -0.01054957f, -0.05496173f, 0.05713550f, -0.20530429f, 0.04211310f, 0.07203668f, 0.06510180f, 0.09246500f, 
    -0.00408687f, -0.05403434f, -0.08139195f, -0.02956661f, -0.03986068f, 0.01885700f, 0.08871154f, -0.10286568f, 
    0.24213006f, 0.11027713f, 0.12594916f, 0.15200379f, 0.03983170f, 0.18022175f, -0.06640257f, 0.09863090f, 
    -0.04738912f, 0.00245344f, 0.05524695f, -0.05215047f, -0.01803541f, 0.03436719f, 0.05351043f, -0.07105663f, 
    0.00611677f, -0.02296986f, 0.03381712f, -0.06804633f, 0.06273206f, 0.04580467f, 0.02866740f, 0.06169955f, 
    -0.00418946f, -0.06272899f, -0.02359305f, 0.02508778f, 0.04202955f, -0.05464771f, 0.03038727f, -0.03185175f, 
    -0.06060066f, -0.05823446f, 0.04318060f, -0.05632626f, -0.01030776f, 0.04443829f, -0.07147416f, -0.05246986f, 
    -0.02531737f, 0.02102029f, 0.01064565f, -0.02666056f, -0.06383554f, -0.06122486f, 0.03951003f, -0.05054276f, 
    -0.02069704f, -0.03887947f, 0.03584406f, -0.00715916f, 0.05502871f, -0.03534909f, -0.07460131f, -0.03962295f, 
    -0.06751740f, -0.01322126f, 0.01549661f, 0.02999781f, 0.05440691f, -0.05941835f, 0.00442402f, 0.01551962f, 
    0.04982922f, -0.07124008f, -0.07685330f, -0.04814298f, -0.07328046f, 0.00099328f, -0.05920994f, -0.06335436f, 
    -0.06831381f, 0.03335316f, 0.03800298f, -0.01774013f, -0.06680609f, -0.01379815f, -0.01510584f, -0.04711971f, 
    0.02606315f, -0.05629487f, 0.00420519f, -0.04960640f, -0.02992094f, -0.07008977f, -0.01251506f, -0.04302761f, 
    0.02312939f, 0.04788468f, 0.03437868f, -0.03323962f, -0.06518142f, -0.05415427f, 0.01931156f, -0.04854079f, 
    -0.01109863f, -0.00424766f, 0.00585799f, -0.00253881f, -0.04279602f, -0.07170019f, 0.02602722f, 0.00707608f, 
    0.04492300f, 0.05576465f, -0.01051441f, 0.06039409f, 0.05934360f, -0.00254015f, -0.01389752f, -0.03937769f, 
    -0.01328970f, 0.00798529f, -0.01393746f, -0.04259819f, 0.00449830f, -0.00001006f, -0.02955935f, -0.03221168f, 
    -0.01470453f, 0.03624523f, -0.02404928f, 0.00392930f, -0.05425235f, 0.03065265f, 0.06468912f, -0.02271583f, 
    -0.05966382f, -0.06274054f, -0.02250991f, 0.02281882f, -0.00062271f, 0.01495203f, -0.06143476f, -0.00209451f, 
    -0.06735387f, 0.04197799f, -0.02523526f, -0.00549432f, -0.04738650f, -0.02817738f, -0.04128084f, -0.03565254f, 
    -0.03703480f, -0.03981495f, 0.05666532f, -0.04941167f, -0.05525938f, 0.05357463f, -0.06029247f, 0.02941326f, 
    -0.03764833f, -0.00199967f, -0.07147025f, -0.07327595f, -0.02411850f, -0.07776287f, -0.06925099f, 0.01031298f, 
    0.05843621f, -0.04212767f, -0.04199829f, 0.01451933f, -0.04224361f, 0.01239035f, 0.05949584f, -0.00916047f, 
    0.04319086f, -0.02755078f, -0.07810777f, -0.01044116f, -0.03267353f, 0.04365711f, 0.04859546f, -0.00449363f, 
    -0.00418010f, -0.02792346f, -0.00847032f, 0.03905665f, 0.01036545f, -0.00347890f, 0.02004045f, 0.00120090f, 
    0.02579051f, 0.01477724f, 0.06106550f, 0.06051025f, 0.01407382f, 0.03246784f, -0.00110526f, 0.06117756f, 
    -0.04446414f, -0.03910643f, -0.05867847f, -0.06591354f, -0.02937735f, 0.04848096f, 0.03439065f, 0.01123789f, 
    -0.05251025f, 0.00015790f, -0.06033352f, 0.05707018f, 0.00280405f, 0.03253831f, -0.04454572f, 0.03329156f, 
    0.05923406f, -0.06088274f, 0.01068628f, -0.02928976f, 0.04852530f, 0.01418048f, 0.01101719f, 0.02695244f, 
    0.04479947f, -0.01136629f, 0.03998185f, -0.01309671f, -0.01616454f, 0.04636282f, 0.04490180f, -0.00497058f, 
    0.05519555f, -0.03586195f, 0.05032384f, -0.03124930f, -0.00120805f, -0.06838561f, -0.06136723f, 0.02547225f, 
    0.06199275f, -0.03764071f, -0.07742019f, -0.05651641f, 0.05077719f, 0.00182834f, -0.00775745f, -0.02477600f, 
    -0.06663189f, -0.00851014f, 0.01339919f, 0.02081993f, -0.07389136f, 0.00247997f, -0.05008246f, 0.01022285f, 
    -0.01656018f, 0.01648832f, 0.01875709f, 0.02700734f, -0.05198480f, -0.02359881f, -0.04689499f, 0.00490351f, 
    -0.05589658f, -0.06833820f, 0.04623923f, -0.03875111f, -0.07232947f, -0.02641357f, -0.03419694f, 0.05428529f, 
    -0.07062670f, -0.06245923f, 0.00308924f, 0.06040213f, -0.01145488f, 0.02653048f, 0.02676076f, -0.01597320f, 
    -0.00679269f, -0.06926165f, -0.06622013f, 0.05106222f, -0.04045036f, 0.03344002f, -0.04084014f, -0.01373528f, 
    0.00825293f, 0.04400756f, 0.03892088f, -0.02970040f, -0.00608819f, 0.03813016f, -0.06037448f, -0.01689648f, 
    -0.06620031f, -0.06504062f, -0.03272701f, -0.06671419f, 0.06237121f, -0.00528336f, -0.03797916f, -0.07490224f, 
    -0.01376626f, -0.02980620f, -0.05306287f, -0.00187569f, 0.02647358f, 0.05100501f, 0.02966338f, -0.06134140f, 
    -0.02415827f, -0.01067242f, -0.00703768f, -0.06407069f, 0.03623487f, 0.02805287f, 0.02399649f, -0.05537614f, 
    0.00164071f, 0.02204986f, 0.02621143f, 0.03060705f, -0.06401817f, 0.00303962f, 0.03306555f, -0.07579260f, 
    -0.01750654f, -0.04308058f, 0.01005235f, -0.00877236f, -0.04818026f, 0.02510531f, -0.05126573f, 0.05955282f, 
    0.02773535f, 0.01189199f, -0.02757903f, -0.06817283f, -0.04291543f, -0.07823039f, -0.04091262f, 0.05723100f, 
    0.00269156f, -0.01725450f, 0.03864282f, -0.01632623f, -0.05675162f, 0.00581390f, 0.02473295f, -0.01829483f, 
    -0.05270739f, -0.00879133f, -0.05533546f, 0.01687002f, 0.00027494f, 0.06615780f, 0.03426954f, -0.02435324f, 
    -0.02074752f, -0.04748339f, 0.04814664f, -0.00445072f, -0.02608949f, -0.06560863f, -0.01418091f, -0.02484475f, 
    0.00247208f, 0.03418208f, -0.06583033f, -0.00458496f, -0.01152932f, 0.04373863f, -0.05187123f, -0.06746213f, 
    0.05707227f, 0.02926794f, 0.01156062f, -0.03722165f, -0.02652973f, -0.01581369f, -0.02405566f, 0.05246168f, 
    0.01675036f, -0.06815778f, 0.01826335f, -0.03851458f, -0.03206772f, 0.02998319f, 0.00853519f, 0.01321201f, 
    0.03411440f, -0.00321369f, -0.00971983f, -0.05487844f, -0.01304313f, 0.00167388f, 0.01132041f, 0.02820027f, 
    -0.14972274f, 0.16671643f, 0.04450161f, 0.10857400f, 0.07424764f, 0.02283687f, -0.10897928f, -0.05258165f, 
    -0.06359227f, 0.07349471f, 0.01326621f, 0.02830159f, 0.03073688f, 0.09952993f, 0.12956357f, 0.28768629f, 
    -0.00753414f, -0.13261108f, -0.01382004f, 0.05683389f, 0.13947344f, 0.03223960f, 0.17145668f, 0.16040947f, 
    0.06839338f, -0.05737042f, 0.15628631f, 0.15636769f, -0.03201061f, 0.05671236f, 0.12328255f, -0.05877087f, 
    0.06019213f, 0.03229226f, 0.23917039f, 0.10599885f, -0.02627366f, 0.20726280f, 0.20919876f, 0.09767638f, 
    -0.05677765f, -0.01626309f, -0.11981809f, -0.17973770f, 0.12245839f, 0.04577705f, 0.19975114f, 0.15414378f, 
    -0.05746171f, -0.05056686f, 0.12165209f, 0.08623902f, 0.09831023f, 0.11597373f, 0.19218583f, 0.18462302f, 
    0.00342075f, 0.15419632f, -0.26213980f, -0.02915538f, -0.58098841f, 0.07415900f, -0.21034867f, -0.00495521f, 
    0.06943628f, 0.22129881f, 0.09927577f, -0.03801748f, -0.17226219f, 0.10482723f, 0.05534671f, -0.09007213f, 
    -0.39188990f, -0.16987020f, -0.38248849f, -0.08079223f, 0.17638782f, -0.02988793f, 0.02736093f, 0.15613408f, 
    0.01051548f, -0.02712126f, 0.07080420f, -0.13454621f, 0.14422841f, 0.20309404f, 0.29151025f, 0.18251084f, 
    -0.09924477f, 0.04219237f, -0.03080677f, -0.09542731f, 0.11383776f, 0.09668601f, 0.00013261f, 0.07611491f, 
    -0.52070218f, -0.19488937f, -0.31844971f, -0.02435864f, 0.15209375f, 0.06267462f, 0.12083258f, 0.04459845f, 
    0.04558475f, -0.06462597f, -0.05198941f, 0.01726829f, -0.14778721f, 0.14648302f, 0.18656074f, 0.23402081f, 
    -0.06299653f, -0.07236101f, 0.11152497f, 0.04947309f, 0.15239796f, -0.06215577f, 0.22092935f, 0.01499804f, 
    0.00718721f, -0.16137430f, -0.18839121f, -0.07057138f, -0.02179515f, 0.04101544f, 0.03266174f, -0.02562775f, 
    -0.04144542f, -0.03012257f, 0.14261615f, 0.04513235f, -0.01028104f, -0.20568193f, 0.16269262f, -0.12419198f, 
    -0.06525330f, 0.01008262f, 0.13545285f, 0.09762004f, -0.04781557f, -0.07383747f, 0.03023205f, 0.04495530f, 
    0.28769299f, 0.12660982f, 0.13688394f, 0.00317037f, 0.11019604f, -0.09427446f, -0.00744882f, 0.01405711f, 
    -0.13644335f, 0.06503160f, 0.00853114f, 0.11332386f, -0.21693875f, -0.09963347f, -0.27150869f, -0.19892813f, 
    0.18247399f, 0.13414001f, 0.02328561f, 0.02366711f, 0.11575730f, 0.00826047f, 0.19260119f, -0.08866272f, 
    -0.41870138f, -0.25318363f, 0.00064311f, 0.12949789f, 0.01662645f, 0.13698648f, -0.04502541f, -0.01630838f, 
    -0.09326889f, 0.05363756f, 0.01226380f, -0.01087609f, -0.06367951f, -0.28298697f, -0.16706619f, -0.17111546f, 
    0.05606897f, -0.08931269f, -0.02217859f, -0.05895575f, 0.02731991f, -0.11273672f, 0.03117454f, -0.01018903f, 
    0.14193726f, -0.07909539f, 0.12256410f, 0.07908963f, -0.11744037f, 0.02615685f, 0.18020335f, -0.00299663f, 
    -0.00509534f, 0.03952857f, -0.00116420f, -0.09097099f, -0.08179813f, 0.22653884f, -0.25553253f, -0.13500713f, 
    0.09396073f, 0.10342190f, 0.03004690f, 0.03609739f, -0.10259609f, 0.03754408f, -0.01940736f, 0.04011536f, 
    -0.15269998f, 0.06320716f, 0.04979369f, -0.45049319f, 0.01709420f, 0.03649235f, 0.05326194f, 0.00577332f, 
    0.07089108f, 0.01620218f, 0.06252468f, 0.06975912f, 0.09066900f, -0.02796046f, 0.05767557f, -0.09454309f, 
    0.00792257f, -0.06132904f, 0.06056368f, 0.01481396f, 0.04150191f, 0.04107913f, 0.07745515f, 0.10280196f, 
    -0.14448008f, 0.00360612f, 0.00654873f, 0.01616973f, 0.14144407f, 0.11671846f, -0.06827875f, 0.15888897f, 
    -0.09793937f, 0.10608292f, -0.03531221f, -0.14346959f, -0.02212724f, 0.03081704f, 0.04002877f, -0.05413986f, 
    0.03797245f, -0.00067838f, 0.04976251f, 0.01332971f, 0.00533872f, 0.01510048f, 0.08598398f, -0.07018000f, 
    0.06286796f, -0.08267112f, 0.00653064f, -0.04743211f, 0.04465262f, -0.05111577f, 0.02861759f, 0.03313942f, 
    0.01678895f, -0.04973262f, 0.03865727f, -0.11964745f, 0.14200015f, 0.02109054f, 0.15430886f, 0.23878743f, 
    -0.00556535f, 0.04786825f, -0.05268150f, -0.03122863f, 0.06745777f, -0.10928818f, 0.03106695f, 0.09252859f, 
    0.08712702f, -0.08871703f, -0.00231977f, -0.01101562f, 0.07277041f, -0.01228346f, 0.10333689f, -0.03672777f, 
    0.06607901f, 0.05232200f, 0.03193997f, 0.09093291f, -0.24795535f, -0.02445840f, -0.06109522f, 0.07109778f, 
    -0.12626998f, 0.09992429f, 0.11282607f, -0.02728476f, -0.04923966f, -0.17619085f, -0.00285445f, -0.10465854f, 
    0.17757915f, 0.12566943f, -0.08996316f, -0.07645608f, -0.08208529f, 0.03507706f, 0.05204206f, 0.02235726f, 
    -0.12278903f, -0.07879586f, -0.02285372f, -0.02164917f, 0.53493160f, -0.02707396f, -0.10131925f, 0.00883462f, 
    -0.01723658f, -0.17299098f, -0.01933017f, -0.05610733f, -0.06024098f, -0.16674891f, 0.04373462f, -0.01341940f, 
    0.30285567f, 0.04682082f, 0.18064366f, 0.12932102f, -0.04478775f, 0.06949440f, 0.06864261f, 0.04850270f, 
    -0.00045144f, 0.02334105f, 0.10890620f, 0.01302189f, -0.09569796f, 0.04818786f, 0.04754615f, -0.00451080f, 
    0.08230815f, 0.08004317f, -0.06489202f, 0.08766113f, 0.06434361f, -0.02013012f, -0.00681042f, 0.00695395f, 
    -0.22730187f, -0.07855966f, -0.00826475f, -0.00324260f, 0.13218994f, 0.00699082f, 0.12414584f, 0.01441737f, 
    0.07274278f, 0.04788166f, -0.05892546f, 0.16742399f, 0.03346474f, -0.09547067f, -0.06451712f, -0.03413646f, 
    0.06046713f, 0.04728937f, 0.01961704f, -0.07026606f, -0.06638348f, -0.14145322f, -0.00376821f, 0.10680378f, 
    -0.05379183f, -0.01726589f, -0.01134918f, 0.04195923f, -0.04802266f, -0.01999190f, -0.03014108f, 0.01652448f, 
    -0.08179153f, -0.04812758f, 0.03211477f, 0.04327517f, -0.04135583f, 0.04043249f, -0.02483945f, -0.05690466f, 
    -0.00820670f, -0.04999610f, -0.06103098f, -0.02760039f, -0.04091226f, -0.00225117f, 0.01246111f, 0.05228902f, 
    -0.05049564f, 0.06285966f, -0.00570393f, -0.02940857f, -0.05162754f, 0.00839379f, -0.04766456f, -0.05992965f, 
    0.00976669f, -0.02086574f, 0.01187513f, -0.06123689f, 0.03174960f, 0.05127675f, 0.05870141f, -0.07055227f, 
    0.01405875f, -0.05682330f, -0.02680398f, -0.05903320f, -0.08210284f, -0.04818622f, -0.05234969f, 0.03482853f, 
    -0.02218116f, 0.02022007f, -0.01991383f, -0.06874878f, -0.06720427f, 0.05731989f, -0.02741702f, -0.04698308f, 
    -0.01291939f, -0.02346745f, 0.00349227f, 0.04085681f, -0.00835817f, 0.01042391f, -0.06707312f, 0.00139183f, 
    -0.04541715f, 0.03963466f, -0.01379488f, 0.04448709f, -0.03272911f, -0.01259364f, 0.03432021f, 0.06554397f, 
    -0.01875180f, -0.07047690f, 0.01851441f, 0.05862429f, 0.04121409f, 0.00245509f, -0.02166307f, -0.03374260f, 
    0.06505121f, 0.05183819f, -0.05429827f, 0.04571085f, -0.03390807f, -0.03086047f, -0.05010805f, 0.04611902f, 
    -0.06873313f, -0.07500991f, 0.00291947f, 0.02065344f, -0.03973179f, 0.00396565f, 0.04395729f, 0.04382468f, 
    -0.00970541f, 0.03170402f, 0.00708785f, -0.01141189f, 0.05714092f, -0.07455774f, -0.03104730f, -0.02668302f, 
    0.03639473f, -0.03943116f, 0.06012373f, 0.05290708f, -0.05441573f, -0.02566143f, 0.03363684f, -0.06157460f, 
    0.06233570f, 0.03751031f, 0.02928334f, -0.02241509f, -0.00671659f, 0.06718522f, -0.00029793f, -0.04453862f, 
    -0.01359670f, -0.02988997f, 0.01565962f, -0.04116260f, 0.03939020f, 0.03634664f, -0.03292685f, 0.05039644f, 
    -0.00253447f, 0.04527583f, -0.02477384f, -0.02527908f, 0.00332749f, -0.06384145f, 0.03120185f, -0.00134548f, 
    0.01416045f, 0.02693371f, -0.06067956f, 0.05442991f, 0.03233078f, 0.01501305f, -0.02890421f, -0.03041593f, 
    0.04805150f, -0.06607791f, -0.08322265f, 0.05536197f, -0.06610712f, 0.01213824f, 0.00563094f, -0.05985417f, 
    -0.01034125f, 0.01645211f, 0.04180371f, 0.05634361f, 0.00741932f, -0.04325279f, 0.05842982f, -0.01066732f, 
    -0.00613433f, -0.02362586f, 0.00315968f, -0.06244406f, -0.03827469f, -0.07756697f, 0.01137203f, -0.03851898f, 
    -0.03341692f, -0.01849367f, -0.01139038f, -0.07381048f, 0.00980666f, -0.01211941f, 0.02037210f, -0.06663927f, 
    -0.03304793f, -0.02903005f, -0.00257230f, 0.00426760f, -0.02279115f, 0.03101965f, -0.05327002f, 0.06287325f, 
    0.06378896f, 0.01777677f, -0.01346176f, -0.01455294f, 0.04561190f, 0.06742124f, 0.05503227f, 0.02679359f, 
    -0.47406521f, -0.10748386f, 0.04171451f, -0.06680574f, 0.05332247f, -0.12352210f, -0.02037553f, -0.10086457f, 
    -0.00796909f, 0.03266367f, 0.00994862f, 0.05850097f, -0.20558518f, -0.15934396f, 0.14681192f, -0.07414422f, 
    0.04255869f, 0.05614847f, -0.05806514f, -0.04283025f, 0.10966416f, -0.08999232f, -0.07297216f, 0.17582317f, 
    0.24044549f, -0.08410214f, -0.05787694f, 0.09181441f, -0.02130764f, -0.00566938f, -0.09392113f, 0.03153894f, 
    -0.25166357f, -0.00522640f, -0.00914577f, 0.06925111f, -0.18817601f, -0.04836332f, -0.06730936f, 0.13688557f, 
    0.13454370f, -0.07697725f, -0.10456026f, 0.17646722f, -0.09092408f, -0.12215705f, -0.19494154f, -0.10771561f, 
    0.33174857f, 0.15110193f, 0.20384298f, 0.13861883f, -0.05656646f, 0.11353961f, 0.12075447f, 0.09039567f, 
    -0.15252365f, -0.00850444f, -0.08805005f, -0.06555046f, -0.06797570f, 0.13333565f, 0.24292162f, 0.08394828f, 
    0.03960621f, -0.08687223f, 0.11232825f, -0.05762655f, -0.08292712f, 0.17737313f, 0.03193344f, 0.13884921f, 
    0.14238013f, -0.07564130f, 0.12358162f, 0.19305378f, 0.04829565f, 0.10961022f, 0.05274305f, 0.05122912f, 
    0.09972811f, -0.07698167f, -0.01130514f, -0.00793856f, -0.06842803f, -0.06328701f, 0.11159056f, 0.03210227f, 
    -0.06130727f, -0.05357675f, -0.02385371f, 0.00750173f, -0.02598266f, -0.05300130f, 0.06091103f, -0.02770711f, 
    0.08609132f, 0.11943620f, 0.03356395f, 0.18961726f, 0.09662415f, 0.01787389f, 0.07881697f, 0.18326609f, 
    -0.16414230f, 0.09284475f, -0.09152055f, 0.06989041f, -0.25078550f, -0.15776083f, 0.05896208f, 0.05974816f, 
    0.02698133f, 0.00178437f, -0.14132872f, 0.01024961f, 0.03506805f, -0.01054493f, -0.00800773f, 0.00673929f, 
    0.06950687f, -0.03981569f, -0.11015214f, 0.06978059f, -0.06703088f, 0.06025800f, 0.05870289f, 0.01068434f, 
    -0.03658954f, 0.09528710f, 0.06516941f, -0.04739513f, -0.07220611f, -0.19126147f, -0.19642553f, 0.06219783f, 
    -0.07101133f, -0.10884241f, -0.00349070f, -0.07839578f, -0.03137485f, -0.02401954f, -0.05866995f, 0.09839501f, 
    0.16520940f, -0.15641624f, -0.22245339f, 0.11013163f, -0.17465727f, -0.14531487f, -0.03710588f, 0.01369085f, 
    0.07085605f, -0.17175934f, 0.04636233f, -0.01260559f, -0.02890405f, 0.19425520f, 0.01933433f, 0.15484458f, 
    0.05103393f, 0.07930559f, 0.01325906f, -0.06579425f, 0.11018800f, -0.09553383f, -0.11508113f, -0.03530535f, 
    0.25370386f, -0.13353321f, 0.38957122f, 0.19316214f, 0.08098258f, 0.00838900f, 0.20174980f, 0.07556516f, 
    -0.09754555f, 0.02640935f, 0.00854307f, 0.20804128f, -0.11653520f, -0.07320533f, 0.15612294f, 0.15571183f, 
    -0.08579748f, -0.03030373f, 0.01894753f, -0.06692399f, 0.08768218f, -0.00622207f, 0.08237456f, 0.07116263f, 
    0.22890885f, -0.09195901f, 0.05392010f, -0.07415293f, -0.03598404f, 0.04860456f, 0.01806746f, 0.10139967f, 
    -0.02826177f, 0.12449007f, -0.04140835f, 0.12217740f, -0.12244118f, -0.05735330f, 0.05435933f, -0.06947827f, 
    0.07140025f, 0.12047404f, 0.04024436f, -0.06803368f, -0.07781120f, 0.03970427f, -0.05556915f, 0.02861821f, 
    -0.19081740f, 0.14641079f, 0.12308981f, -0.26782498f, -0.01874813f, 0.06055630f, 0.11027262f, 0.18511459f, 
    0.06460847f, -0.01804729f, 0.15821894f, 0.17700711f, 0.08822506f, -0.01155088f, 0.02960164f, -0.30683401f, 
    0.17309552f, -0.07817578f, -0.04559686f, 0.05405821f, -0.04399332f, -0.10439661f, 0.15569614f, 0.06106842f, 
    -0.13568540f, -0.05681749f, 0.06723785f, -0.07010938f, 0.08966580f, 0.03044920f, -0.03385841f, 0.07677600f, 
    0.03456504f, 0.07383740f, 0.01790036f, 0.11708763f, 0.15123577f, -0.16054514f, -0.23791380f, 0.08778866f, 
    -0.02264927f, -0.07481378f, -0.11301465f, -0.01938047f, 0.00007010f, -0.00283970f, -0.02628347f, -0.06785581f, 
    0.16066955f, 0.06173995f, -0.08656279f, -0.15026385f, -0.10731214f, 0.06494881f, 0.05764346f, 0.09996060f, 
    0.00783368f, 0.16858371f, 0.02059485f, 0.01248628f, -0.16963194f, 0.11137874f, -0.01243290f, -0.15024407f, 
    0.20513834f, 0.05888295f, 0.02193316f, 0.07325944f, 0.17618480f, 0.02502060f, -0.04206251f, 0.06219734f, 
    -0.08117840f, -0.01813500f, -0.05455919f, -0.19721410f, -0.05330323f, -0.01180880f, 0.14090951f, -0.07383727f, 
    0.14007169f, -0.01983917f, 0.00827090f, 0.03276800f, -0.35480931f, 0.03827149f, 0.18985748f, 0.04803839f, 
    0.14571083f, 0.04871453f, -0.04961796f, -0.12862229f, -0.06435142f, -0.03509805f, 0.01668851f, 0.07264459f, 
    -0.23534231f, 0.11883969f, -0.01993627f, 0.14606223f, 0.05523702f, 0.15966779f, 0.08471528f, -0.16663906f, 
    0.06069417f, -0.01039612f, 0.04042087f, 0.09310259f, 0.01948232f, 0.01629284f, 0.05702518f, 0.07709514f, 
    0.05236488f, 0.00017814f, 0.03611065f, 0.00737074f, 0.09294931f, 0.08759182f, 0.19285144f, -0.02543945f, 
    -0.17443117f, 0.11175419f, 0.12967788f, -0.28421947f, 0.16012290f, -0.02590147f, -0.08403386f, 0.00092899f, 
    -0.04674564f, 0.01905924f, 0.10831444f, -0.07144471f, -0.20654413f, -0.18887855f, 0.06820301f, 0.08628470f, 
    0.11632454f, 0.01840333f, 0.08002251f, 0.11852437f, 0.07448562f, -0.03475881f, 0.08405517f, 0.04320566f, 
    -0.10431853f, -0.05233406f, -0.03314379f, -0.11945903f, -0.02019168f, -0.02069538f, -0.09769132f, -0.16805600f, 
    0.00606410f, -0.05604101f, 0.10352243f, -0.13156046f, 0.39343497f, 0.09694024f, -0.17671396f, -0.01757298f, 
    -0.07526486f, -0.06751028f, 0.15007763f, -0.01738216f, 0.05781880f, -0.03079356f, -0.02669548f, -0.03601157f, 
    0.12771378f, -0.08829186f, -0.03501441f, -0.17613998f, 0.05091184f, -0.07360116f, -0.01043643f, 0.06358436f, 
    -0.01279780f, 0.01386862f, -0.02362366f, -0.02610003f, 0.10750005f, -0.33436432f, 0.14497657f, 0.09768571f, 
    -0.00376778f, -0.07076496f, 0.13306524f, -0.09823069f, 0.01348250f, -0.08435838f, 0.00173252f, 0.06360719f, 
    0.17531849f, -0.07996453f, 0.01719558f, 0.16065209f, -0.09630717f, -0.03900763f, -0.11568908f, 0.02981840f, 
    0.01567053f, -0.02101725f, 0.05005848f, -0.16045099f, -0.14927937f, 0.17826192f, 0.11417521f, 0.06072341f, 
    -0.09343456f, 0.15289176f, -0.05572862f, 0.11222614f, 0.02522772f, 0.07355559f, -0.07085239f, 0.07141728f, 
    0.00018237f, 0.15616074f, -0.07624287f, 0.19921230f, 0.03084617f, 0.03666764f, -0.02203186f, 0.03683026f, 
    0.00122655f, 0.10350483f, 0.03158892f, 0.04272421f, 0.06403527f, 0.11163187f, 0.24684189f, 0.19452778f, 
    0.06923945f, 0.00248625f, 0.08771446f, 0.02036590f, -0.05185759f, 0.12041163f, -0.10269977f, -0.01250396f, 
    -0.38310939f, 0.11041673f, -0.03961063f, 0.00940834f, 0.14583711f, 0.09350696f, 0.07128164f, -0.00694468f, 
    0.01869518f, 0.01871088f, 0.06088819f, 0.02082952f, 0.28196642f, 0.17837809f, 0.05864206f, 0.17334160f, 
    -0.09249079f, 0.01200249f, -0.05244909f, -0.01553332f, 0.08133118f, -0.04152867f, 0.04004579f, -0.04979280f, 
    -0.40884012f, 0.07888265f, -0.11183983f, 0.01264473f, 0.11656890f, 0.02152645f, 0.04785471f, 0.02400843f, 
    -0.18002829f, -0.01204302f, 0.09917126f, 0.14323048f, 0.07611377f, -0.14562573f, 0.02750572f, 0.05105749f, 
    -0.05522104f, -0.03250875f, -0.00290302f, -0.01663615f, 0.15622212f, -0.01782225f, -0.08203040f, -0.00832865f, 
    0.10053087f, 0.09962240f, -0.11955813f, 0.08077722f, -0.07608706f, -0.05181043f, 0.05982233f, 0.05594398f, 
    0.00676343f, -0.03126090f, -0.05624311f, 0.03056486f, -0.16797394f, 0.13958579f, 0.07614380f, -0.02527641f, 
    -0.05349648f, 0.02588836f, -0.04047005f, -0.06730293f, -0.04535345f, -0.10324956f, -0.02506638f, -0.03028633f, 
    0.33732206f, 0.02801954f, -0.04752593f, -0.00353334f, -0.10281055f, -0.01094204f, 0.18046799f, 0.03572262f, 
    0.01040536f, 0.06944996f, 0.01306660f, 0.04067731f, -0.05908751f, -0.07481258f, 0.01162287f, -0.00067626f, 
    0.12661050f, 0.01027973f, 0.09639672f, -0.19441780f, 0.06219451f, -0.01401043f, -0.02276075f, -0.00314359f, 
    0.12290751f, 0.12642948f, 0.11927839f, 0.10305995f, 0.18521175f, -0.03543118f, 0.07514852f, 0.13982588f, 
    0.01065353f, -0.00674360f, 0.03680415f, -0.04146725f, -0.16540931f, 0.05631481f, -0.13310683f, 0.03835406f, 
    -0.00863700f, -0.10011186f, -0.02970242f, -0.23544419f, 0.00583453f, 0.11814456f, 0.13644540f, 0.10714854f, 
    0.12976389f, 0.04401854f, 0.08166388f, -0.06544299f, -0.00700634f, 0.11576744f, -0.22069506f, 0.19884023f, 
    0.07798696f, 0.04643678f, 0.06597282f, 0.03898983f, 0.06719571f, -0.04938491f, 0.04555196f, 0.01271160f, 
    -0.10693516f, 0.04171980f, 0.02924419f, -0.09855968f, -0.02380537f, 0.11681984f, 0.04678304f, 0.03020534f, 
    -0.41830277f, 0.09882822f, -0.30468649f, 0.35690063f, 0.07805379f, -0.05542136f, -0.00065755f, -0.06612940f, 
    -0.00489741f, 0.13829055f, -0.06490902f, -0.10941897f, 0.03987743f, 0.13455617f, 0.17110041f, 0.00267688f, 
    0.16525221f, 0.04913542f, -0.06016172f, -0.07618200f, -0.03900877f, -0.01260376f, -0.12440635f, -0.13146654f, 
    0.25052571f, -0.10702608f, -0.07843082f, 0.03866155f, -0.01283032f, -0.06315498f, 0.06311806f, -0.11359245f, 
    0.06253126f, 0.17527996f, 0.13503875f, 0.15308683f, 0.04390539f, -0.03917863f, 0.06142262f, -0.04494298f, 
    -0.14810623f, -0.01002470f, 0.10055893f, 0.28713557f, -0.05232267f, -0.00755165f, -0.05165153f, 0.14012371f, 
    0.12023099f, -0.03110701f, 0.11556868f, 0.23062816f, 0.04144817f, -0.06989369f, -0.08759248f, 0.05722367f, 
    0.02219660f, -0.11474421f, -0.04423173f, -0.04477720f, -0.12111102f, 0.14632927f, -0.05971622f, -0.21151499f, 
    0.35741508f, -0.03764061f, -0.12076370f, -0.10628743f, 0.06944764f, -0.01039930f, 0.01044202f, -0.02897313f, 
    0.32212698f, -0.03805713f, -0.08202972f, 0.09610319f, 0.01979413f, -0.07120372f, -0.01976185f, 0.04021366f, 
    0.09920803f, 0.02689901f, 0.04453387f, 0.00304873f, -0.00518101f, 0.04602208f, 0.18212646f, -0.23259401f, 
    0.05417096f, 0.24588542f, 0.03511428f, -0.02101260f, 0.20214184f, 0.12775360f, -0.04593915f, -0.04408597f, 
    0.04065602f, -0.08380133f, 0.14998668f, 0.17234038f, -0.10424046f, -0.05458231f, 0.01018466f, -0.02527530f, 
    0.03797802f, -0.00866846f, 0.04572674f, -0.02341697f, -0.11137778f, 0.01287792f, 0.14058152f, -0.05720363f, 
    0.13678326f, 0.14930789f, 0.07593511f, -0.04161515f, 0.02604270f, 0.01526536f, -0.00038273f, -0.01105736f, 
    -0.10541888f, -0.11065793f, -0.12203844f, 0.14240651f, 0.14296126f, -0.04086624f, -0.04154067f, -0.01723484f, 
    -0.00553327f, 0.10709934f, -0.02001985f, 0.02159697f, 0.16014834f, -0.20464098f, 0.14911312f, 0.25073647f, 
    -0.11847980f, -0.05126834f, 0.14740227f, 0.15792665f, 0.01737280f, 0.01796411f, -0.00235908f, -0.07433932f, 
    0.13241376f, -0.05606720f, 0.03630954f, -0.09356384f, -0.04740676f, -0.18218282f, -0.02075053f, -0.08386546f, 
    -0.10392725f, -0.17293267f, 0.05203803f, -0.08797372f, -0.25248438f, -0.15192001f, -0.00576416f, 0.21927164f, 
    -0.11654352f, 0.07224572f, 0.02759477f, 0.09134591f, -0.06817284f, 0.08543452f, 0.03642190f, -0.05353327f, 
    0.14262286f, 0.06787284f, 0.02984964f, 0.10777182f, 0.09061407f, 0.07078268f, -0.07970895f, -0.04603181f, 
    -0.05472188f, 0.10501870f, -0.11188041f, -0.00475071f, 0.36429036f, -0.00311988f, -0.06312799f, -0.03219071f, 
    -0.06187319f, 0.10336548f, 0.02770611f, 0.06442414f, 0.04676949f, 0.10951265f, 0.10167380f, 0.03632027f, 
    -0.06908000f, -0.16974720f, 0.02939522f, 0.08675472f, 0.08803459f, -0.09874225f, 0.05208272f, 0.05927072f, 
    -0.03680425f, 0.06503219f, 0.09759901f, 0.10241072f, 0.05996164f, -0.13080820f, 0.16647792f, -0.17434317f, 
    0.11296413f, -0.02708412f, -0.12680648f, -0.04904536f, 0.11914144f, -0.12177278f, 0.15719196f, 0.03496695f, 
    -0.06609273f, -0.29552409f, -0.09475590f, -0.07828377f, -0.00976721f, -0.04691987f, 0.05022333f, 0.11529920f, 
    0.01740010f, 0.10132759f, -0.17411000f, 0.01933560f, -0.10981661f, -0.13442674f, -0.12997846f, -0.02201864f, 
    0.03194157f, 0.04942543f, -0.06306019f, -0.21922678f, 0.07094587f, -0.03350251f, -0.00971987f, -0.10730587f, 
    -0.07027271f, 0.01591681f, -0.04521939f, 0.05636984f, -0.09286024f, 0.07636448f, 0.01055418f, 0.06804990f, 
    0.11611840f, 0.02040771f, 0.06791530f, 0.09547701f, 0.34948391f, 0.10170995f, 0.07224833f, 0.06406479f, 
    0.13734151f, 0.00855633f, 0.12233765f, 0.00080180f, -0.06458868f, 0.12321016f, -0.09104548f, 0.01130765f, 
    -0.33488709f, 0.00721883f, -0.08543611f, -0.01183055f, 0.03249925f, 0.09628653f, 0.10405002f, 0.03011782f, 
    0.03166002f, 0.05335733f, 0.16995026f, -0.02391354f, 0.30418223f, 0.23169477f, 0.18492167f, -0.19656003f, 
    0.03221569f, 0.04335791f, 0.03462879f, -0.03426784f, -0.01437918f, -0.09673133f, 0.12071149f, 0.00231109f, 
    0.09982311f, -0.20124283f, 0.06183650f, -0.23296787f, 0.01788162f, 0.02929353f, -0.02641072f, -0.13121043f, 
    -0.01273797f, 0.01908659f, 0.07977059f, 0.21175103f, 0.31883880f, -0.03757869f, 0.06335530f, 0.04384855f, 
    0.08965902f, -0.01761674f, -0.07548466f, 0.01032913f, -0.05153405f, -0.00186837f, 0.06259445f, -0.08355392f, 
    0.17328797f, 0.03623397f, 0.05554497f, -0.00328132f, 0.26412472f, -0.12120617f, -0.04452053f, 0.18093574f, 
    0.01172550f, 0.06007378f, -0.07888316f, -0.04772881f, 0.18576279f, -0.01718312f, -0.01225169f, 0.01855921f, 
    0.00843235f, 0.08683600f, 0.01334052f, -0.03538308f, -0.02243835f, 0.08082266f, 0.11529820f, 0.00186615f, 
    -0.17446448f, 0.03184144f, -0.03010919f, -0.00565138f, -0.12071219f, 0.17418782f, -0.09465335f, -0.03702225f, 
    0.06194674f, 0.05816356f, 0.01277383f, -0.06301040f, -0.07274687f, -0.12600349f, -0.08955828f, 0.03655127f, 
    0.07326714f, -0.06319298f, 0.01494143f, -0.09131406f, 0.02973783f, -0.17378055f, -0.10555134f, -0.04947364f, 
    0.05263241f, -0.01676518f, 0.04220895f, 0.22274823f, 0.18907428f, -0.08630457f, -0.00832861f, 0.02261719f, 
    0.00189025f, 0.03867092f, 0.13387442f, 0.01130684f, -0.26954007f, -0.16160335f, 0.06710662f, 0.18256733f, 
    0.14875542f, 0.02229322f, 0.02518583f, 0.14362015f, -0.06113576f, -0.08900069f, 0.03034838f, 0.04501320f, 
    0.45218998f, 0.17364037f, 0.07783883f, -0.07108290f, -0.00390856f, 0.00714297f, 0.03573874f, 0.18157335f, 
    -0.03630921f, 0.09387860f, 0.06014264f, -0.00845252f, -0.18202029f, 0.17242876f, -0.03119826f, -0.18896496f, 
    0.02539583f, -0.09328272f, 0.04401424f, -0.00739254f, -0.01119352f, -0.03544312f, -0.06967875f, -0.11246644f, 
    -0.10417244f, 0.22788155f, 0.07776404f, -0.07266564f, 0.05468519f, 0.00667295f, -0.10163322f, 0.08214936f, 
    0.08671258f, -0.04879418f, -0.06253432f, 0.02389189f, -0.31819102f, -0.00062838f, -0.00198050f, 0.05653793f, 
    -0.12643810f, 0.05345965f, 0.05065719f, -0.03031221f, 0.01442570f, 0.09102343f, -0.05703996f, -0.00059345f, 
    0.33519790f, 0.02868661f, -0.10110040f, -0.01924236f, 0.09617090f, 0.02482788f, -0.11580316f, -0.07986461f, 
    0.01948359f, 0.04205408f, -0.05995868f, 0.09625719f, -0.22746257f, 0.05478533f, -0.05635908f, -0.26859859f, 
    -0.01189864f, -0.01632871f, 0.01054030f, 0.04472042f, -0.12891620f, -0.00466066f, 0.09053480f, 0.01824099f, 
    0.42660576f, 0.13250770f, -0.09959657f, 0.30456215f, -0.09664313f, 0.10435618f, -0.10256866f, -0.07110108f, 
    -0.05380551f, -0.07862332f, 0.00549272f, 0.01379086f, 0.11451250f, 0.05761925f, -0.00146997f, 0.01511135f, 
    -0.06568346f, -0.06469021f, 0.07189632f, -0.03210123f, -0.03409970f, 0.01375611f, -0.06995504f, 0.03829642f, 
    -0.14107381f, -0.13716498f, 0.27328452f, -0.00037283f, 0.09196748f, 0.01805555f, -0.00443412f, 0.06842463f, 
    0.00976641f, 0.02394543f, -0.09174887f, -0.12159028f, -0.34246513f, 0.18682306f, 0.14143839f, 0.02350840f, 
    0.12233127f, -0.03361191f, 0.03138237f, 0.02344436f, 0.21240097f, 0.00316251f, 0.01462324f, 0.14140734f, 
    -0.23093256f, 0.09422909f, 0.00730150f, -0.04435802f, 0.02056874f, 0.10789260f, -0.05334840f, -0.04739738f, 
    -0.01186447f, -0.06748758f, -0.07338712f, 0.02974654f, 0.12264737f, -0.07545978f, -0.02654755f, -0.07710926f, 
    0.15018092f, -0.02740773f, 0.02366546f, 0.14178447f, -0.08272673f, -0.10962486f, 0.07688332f, 0.02647852f, 
    0.21189523f, -0.00087460f, 0.02813549f, -0.01822502f, 0.11493291f, 0.15336524f, -0.02823395f, -0.01074119f, 
    -0.12955540f, 0.10270475f, -0.11360393f, -0.03681713f, 0.25087333f, 0.00760882f, -0.04795501f, -0.19979092f, 
    0.17060119f, 0.10841584f, 0.04931779f, 0.05200629f, 0.21263561f, 0.11528727f, -0.02841420f, 0.06961831f, 
    0.00064050f, 0.02686112f, -0.05667739f, -0.08527411f, 0.06440457f, 0.00442166f, 0.04208621f, 0.05723819f, 
    -0.01132100f, -0.04934973f, -0.08923511f, -0.03805052f, -0.01447531f, -0.07165825f, -0.00004708f, 0.04960342f, 
    0.04598399f, -0.04172828f, -0.00576184f, -0.07615810f, -0.03574484f, 0.04779926f, 0.01294879f, 0.02431189f, 
    0.01479986f, 0.03773062f, -0.08392144f, 0.06339816f, -0.02191007f, 0.01451369f, -0.03509007f, -0.03777364f, 
    -0.07315832f, 0.00198036f, -0.04383689f, 0.02678381f, -0.00784330f, -0.05018846f, -0.00838044f, -0.00473214f, 
    -0.08771595f, -0.00139340f, -0.00644114f, 0.03608977f, -0.00751451f, 0.05512457f, 0.01387085f, -0.01368949f, 
    -0.07974135f, -0.00342166f, -0.03938567f, 0.05944154f, 0.02325845f, -0.07891921f, 0.04829020f, -0.03173268f, 
    -0.07512356f, 0.04764557f, 0.01953595f, 0.03262941f, -0.07269704f, 0.01932069f, -0.02797911f, 0.00526811f, 
    -0.02294298f, -0.05368195f, -0.08896284f, -0.02630068f, -0.00302045f, 0.02364756f, 0.04836181f, -0.05023743f, 
    -0.04449711f, -0.06504718f, 0.00159306f, -0.04670680f, -0.07814538f, -0.04693969f, 0.03883339f, 0.01880134f, 
    0.00505612f, 0.02779779f, -0.08402161f, 0.01701024f, -0.05616491f, -0.05719241f, 0.01778490f, -0.07412358f, 
    -0.06881881f, -0.03448381f, 0.04253619f, 0.00739757f, -0.03989172f, 0.00765817f, -0.04682055f, 0.05619014f, 
    -0.05323085f, -0.00516537f, 0.01039425f, 0.04835812f, 0.00332787f, -0.05732913f, -0.01066127f, 0.05089022f, 
    -0.01432686f, -0.01572649f, -0.00609290f, 0.00794429f, -0.09679412f, -0.05621248f, -0.06257826f, -0.07960764f, 
    -0.02997315f, -0.05544150f, 0.02542982f, -0.03824507f, 0.04674368f, -0.08322292f, -0.06567059f, -0.04017829f, 
    -0.06373154f, -0.06024650f, -0.03006002f, 0.03850578f, -0.07126083f, 0.05602799f, 0.03969217f, 0.04550181f, 
    -0.09578238f, -0.04922187f, 0.02861867f, -0.07668530f, 0.04271907f, 0.01191140f, 0.01879699f, -0.06902409f, 
    -0.00278722f, -0.08021731f, -0.04572350f, -0.04836402f, 0.00878312f, -0.05597174f, 0.00417352f, 0.05544217f, 
    0.00713270f, -0.04030387f, 0.03295342f, -0.07489558f, 0.03383590f, -0.02843081f, -0.08126974f, 0.00283984f, 
    -0.00288428f, 0.02346643f, -0.05598827f, 0.00582972f, -0.03436311f, 0.02237982f, -0.01252116f, -0.07216243f, 
    -0.04472562f, 0.05366586f, 0.04808981f, -0.06895496f, 0.01554422f, -0.02235760f, -0.03902058f, -0.06597403f, 
    -0.08020735f, 0.00240660f, -0.05839379f, -0.00886329f, -0.02331594f, 0.04324092f, -0.07731493f, -0.04146110f, 
    0.00380809f, 0.01823096f, 0.02753333f, -0.02267683f, -0.05177527f, 0.00985799f, -0.02302670f, -0.01529839f, 
    -0.07604999f, 0.00433038f, 0.00979050f, -0.02396652f, -0.02777635f, -0.02462638f, 0.04721056f, -0.05528139f, 
    -0.09461562f, 0.14288372f, -0.12765980f, 0.11674532f, -0.15016739f, 0.09979011f, -0.01802385f, -0.14568816f, 
    0.09543452f, -0.01088942f, 0.10551347f, -0.12620199f, -0.40162715f, 0.09874025f, -0.09345832f, -0.31071389f, 
    0.10926564f, 0.01425869f, 0.01508075f, 0.07170233f, 0.07690743f, -0.09623959f, 0.11901608f, -0.06828473f, 
    -0.04580363f, -0.02489383f, 0.14890875f, -0.34093159f, 0.13328198f, 0.12347247f, -0.10430978f, -0.13702975f, 
    0.01167241f, -0.03871705f, -0.01236246f, -0.04084277f, -0.20762210f, -0.06823497f, 0.00074124f, 0.17704868f, 
    -0.05808174f, 0.01530113f, -0.01665553f, 0.05722300f, 0.12178812f, 0.01445287f, -0.01773611f, -0.08903580f, 
    -0.24006467f, -0.08563667f, -0.10559486f, -0.17797898f, -0.01047576f, 0.06368201f, 0.01363583f, 0.08575697f, 
    -0.16095088f, -0.04818549f, -0.07171618f, -0.15290838f, 0.13353550f, 0.13666938f, 0.02174390f, -0.09248731f, 
    0.01739068f, -0.11735372f, 0.12853487f, 0.07467475f, -0.00915663f, 0.00556054f, -0.01098446f, 0.05683075f, 
    0.27424771f, 0.13509722f, -0.01880053f, 0.12171724f, -0.05751351f, -0.05210086f, -0.17647712f, -0.03862314f, 
    0.03486790f, -0.13237928f, -0.01263609f, -0.09940863f, 0.10930211f, 0.16421154f, 0.26608267f, 0.30938387f, 
    -0.19507143f, 0.01335029f, 0.05618379f, 0.06166489f, -0.13933796f, 0.08799744f, -0.02217004f, -0.03423632f, 
    0.19597316f, -0.00152183f, -0.14746544f, -0.00918400f, -0.06522600f, -0.05071010f, -0.06968371f, 0.15073484f, 
    -0.10592152f, -0.00839754f, -0.15605326f, -0.00010391f, -0.30752757f, 0.01410879f, -0.16582243f, 0.07125038f, 
    0.02270629f, 0.00347777f, 0.15254332f, 0.11984863f, -0.06960906f, 0.12154878f, -0.02680471f, -0.04617740f, 
    -0.03915894f, 0.07525855f, 0.07359634f, -0.39835933f, -0.06377823f, -0.03248791f, 0.06776477f, 0.04637517f, 
    0.06614574f, 0.07519623f, -0.01295603f, 0.00324002f, 0.23900998f, 0.04656909f, 0.02625384f, 0.11917774f, 
    -0.01508891f, -0.06599005f, 0.04229189f, 0.11247623f, -0.05927796f, -0.05396248f, -0.11835043f, 0.03204120f, 
    0.27426198f, -0.09267158f, -0.10688393f, 0.48430514f, 0.00481964f, 0.02742561f, 0.10263945f, 0.00286929f, 
    0.07054121f, -0.10561466f, -0.08174389f, 0.06723603f, 0.45692131f, 0.24613212f, -0.02411925f, 0.16653889f, 
    -0.01415890f, -0.04888970f, -0.00799199f, 0.02689458f, 0.04298622f, -0.04192362f, -0.04017474f, 0.02216708f, 
    -0.10510045f, -0.09875216f, 0.03534857f, 0.02978024f, 0.01948175f, -0.12227114f, 0.05811849f, 0.16648091f, 
    0.09408908f, 0.11339574f, -0.04433192f, 0.07623828f, 0.17882532f, 0.19314495f, 0.35179710f, 0.08549614f, 
    -0.03326189f, -0.10539290f, -0.04379382f, 0.13381237f, -0.05733624f, -0.04344720f, 0.07288990f, 0.06731621f, 
    -0.01811245f, 0.03842564f, -0.03845713f, -0.02021142f, -0.03377678f, 0.03545944f, -0.00774880f, -0.01761904f, 
    -0.01494166f, -0.07110798f, 0.00815059f, 0.04426954f, 0.00349808f, -0.01376243f, -0.02143805f, 0.06000170f, 
    -0.04357988f, -0.04812869f, -0.03417775f, 0.01628834f, 0.04872944f, 0.01903743f, -0.02201196f, 0.01652807f, 
    -0.02780226f, -0.01602063f, -0.01078641f, 0.03343362f, -0.03615514f, -0.01715461f, -0.04244776f, 0.00588240f, 
    -0.02574956f, -0.07484581f, -0.06671858f, -0.07051677f, -0.07722612f, -0.02148607f, -0.05362412f, 0.01362834f, 
    0.05731852f, 0.05283333f, 0.03431055f, -0.04211643f, -0.06154078f, -0.05870932f, -0.00775056f, -0.00597829f, 
    -0.05834002f, -0.07163282f, 0.01095504f, 0.04437990f, 0.01776287f, 0.04799594f, 0.00919924f, -0.06067130f, 
    0.06116045f, -0.07641906f, 0.03685499f, 0.03183388f, -0.07725534f, -0.07946818f, 0.04456252f, -0.05279538f, 
    0.01303971f, -0.00782233f, -0.01318069f, 0.04108294f, -0.06479022f, -0.00671324f, -0.06045360f, -0.07670259f, 
    -0.07023372f, 0.01554600f, -0.03698693f, 0.02736810f, 0.01920539f, 0.06237561f, 0.04095579f, -0.05097984f, 
    0.00777013f, -0.06126089f, -0.07238217f, 0.03806733f, 0.03911953f, -0.07781929f, 0.01419333f, -0.07616636f, 
    -0.03045795f, 0.05389595f, 0.04018333f, 0.02179984f, 0.06261417f, 0.00538382f, -0.03247625f, -0.01238039f, 
    -0.04400939f, -0.03872698f, 0.04351655f, -0.06453280f, -0.02487051f, -0.07356797f, 0.02546659f, -0.03203860f, 
    0.04582002f, -0.00488735f, -0.00524318f, -0.02001279f, -0.00107953f, -0.04025568f, -0.01514996f, -0.03780016f, 
    -0.07286223f, 0.01053088f, 0.06058935f, -0.07749685f, -0.06046377f, -0.06171571f, 0.03583555f, -0.03549277f, 
    0.01682154f, -0.05002874f, -0.04225253f, -0.03638181f, -0.00627716f, -0.06689356f, -0.02507585f, 0.03117495f, 
    -0.03640875f, 0.02219568f, 0.00768333f, -0.02389628f, -0.02744800f, 0.00733323f, 0.04353855f, -0.04136308f, 
    -0.05045006f, 0.06125227f, 0.01998943f, -0.07536795f, -0.00482601f, -0.07077812f, 0.00729018f, -0.00715185f, 
    0.00289539f, -0.04460239f, -0.01694511f, 0.02511292f, 0.02125676f, -0.02061161f, 0.01528501f, 0.00279946f, 
    0.01821158f, -0.07080477f, -0.06031791f, -0.06773327f, -0.07706771f, 0.01903961f, 0.04797392f, -0.05967439f, 
    -0.06399598f, -0.07582176f, -0.02081253f, -0.03838421f, 0.01529791f, -0.06819639f, -0.01077623f, 0.00336933f, 
    0.02243886f, 0.00712924f, -0.05883545f, -0.03787368f, 0.02763416f, -0.05601562f, 0.00209755f, -0.03175419f, 
    0.06222788f, -0.01131548f, -0.07911275f, -0.00506232f, 0.04874587f, 0.00002208f, -0.03534855f, 0.06106240f, 
    0.04387123f, -0.05535692f, 0.01346540f, -0.05501420f, 0.00007112f, 0.00527272f, 0.06034652f, -0.01739193f, 
    -0.03620820f, 0.02132170f, 0.03368105f, -0.02214944f, 0.05144783f, -0.03176969f, -0.01937240f, -0.04126957f, 
    -0.05074151f, 0.01706241f, 0.05086389f, 0.04192849f, -0.04982902f, -0.07147357f, -0.07093283f, 0.06173391f, 
    -0.01141198f, 0.00732969f, -0.06957782f, 0.01277807f, -0.05978375f, 0.06330866f, -0.01425901f, 0.01839004f, 
    -0.05137075f, -0.04606822f, 0.00272641f, -0.00026360f, -0.00436121f, -0.00731796f, 0.03190707f, -0.05796554f, 
    -0.06402487f, 0.00484049f, -0.06801044f, -0.03513944f, -0.00174819f, 0.06211623f, -0.02552005f, -0.01575809f, 
    0.05968329f, 0.04587997f, -0.06837581f, 0.03858775f, -0.06614511f, 0.01237154f, 0.03021373f, 0.04045098f, 
    -0.03363407f, 0.00079038f, 0.02652485f, -0.03605570f, -0.07865822f, -0.00490133f, -0.06765047f, -0.03661593f, 
    -0.03109203f, -0.04222804f, -0.03306815f, 0.06089964f, -0.06004968f, 0.01551651f, 0.06282689f, -0.00545342f, 
    0.01632610f, -0.03692621f, 0.02551572f, -0.06910525f, -0.05527312f, -0.01369149f, 0.05161164f, -0.06523324f, 
    -0.03585396f, -0.06936363f, 0.02174812f, 0.00186656f, -0.00192986f, 0.05801193f, 0.05916627f, -0.04010936f, 
    -0.01630791f, 0.05160303f, 0.06251965f, 0.02865086f, 0.03447369f, -0.04632208f, -0.03687324f, 0.00024207f, 
    0.05358031f, -0.00327482f, -0.02858591f, -0.03617393f, -0.05651250f, 0.03076964f, 0.02108960f, 0.02243351f, 
    -0.01225945f, -0.04415069f, 0.05687725f, -0.02060289f, -0.06240411f, 0.00032026f, -0.05487074f, -0.02876333f, 
    0.03733120f, 0.01930391f, -0.05254118f, -0.07917129f, 0.05955053f, -0.05249388f, -0.07744431f, 0.00575672f, 
    0.03855209f, -0.06869962f, -0.01361987f, 0.04965030f, 0.05210719f, -0.07066981f, -0.07687151f, -0.01934194f, 
    -0.05905027f, -0.01242026f, -0.03466579f, -0.04907354f, 0.02456409f, -0.02896610f, 0.05991039f, -0.02361151f, 
    -0.02188191f, 0.02566368f, -0.04893370f, 0.00352161f, 0.02123910f, -0.05737640f, -0.02201000f, -0.01045148f, 
    0.01910122f, 0.06001425f, 0.00201687f, -0.03686443f, 0.02462584f, -0.04536176f, -0.04344795f, -0.04924236f, 
    0.00790060f, -0.00236995f, -0.04682308f, -0.03946952f, -0.01601239f, 0.02716345f, -0.00577261f, 0.00778767f, 
    -0.05717390f, -0.00977794f, -0.03503535f, 0.05434320f, 0.04480648f, -0.05285098f, 0.05036461f, -0.01446904f, 
    -0.05574308f, -0.00116946f, 0.05742607f, 0.03077319f, -0.01871955f, -0.07441203f, -0.06791934f, -0.02732733f, 
    0.00359925f, 0.02185473f, -0.05366511f, -0.03834415f, -0.04151553f, 0.01744584f, 0.06255533f, -0.05569549f, 
    -0.06151913f, 0.01988553f, 0.02965916f, -0.01997795f, -0.06259574f, 0.04054441f, -0.01064378f, -0.01514203f, 
    -0.01205704f, -0.06680993f, -0.06130115f, 0.03648485f, -0.02835639f, 0.02325510f, 0.03401041f, -0.04457565f, 
    -0.28397787f, 0.05344645f, 0.00559653f, 0.03818009f, -0.07665102f, 0.08405106f, -0.23398292f, -0.02621410f, 
    0.07669240f, -0.15763958f, 0.15910281f, -0.00057974f, -0.08267722f, 0.26970896f, 0.24139217f, -0.05648939f, 
    -0.18762246f, 0.08424008f, -0.08624347f, -0.19468145f, 0.09491540f, 0.01635270f, -0.00654250f, -0.03361337f, 
    -0.02563974f, -0.05447270f, -0.28586882f, 0.22585204f, 0.05739794f, -0.15757461f, 0.07522935f, 0.03743333f, 
    0.03894310f, -0.04548643f, -0.25621507f, -0.13639861f, 0.05252943f, 0.00376636f, 0.04296830f, 0.22344883f, 
    -0.01628881f, -0.06008156f, -0.04500834f, 0.05315266f, -0.06761215f, 0.05035920f, -0.23296952f, -0.13287127f, 
    0.11399771f, -0.10968327f, 0.11521073f, -0.03638175f, -0.00288620f, -0.07335216f, 0.07265050f, -0.03794248f, 
    0.10062867f, 0.13211887f, 0.28129917f, 0.12081571f, 0.12736729f, -0.00626204f, 0.22815856f, -0.04479615f, 
    -0.03570355f, 0.09428665f, 0.10696297f, 0.23568778f, 0.12871438f, 0.11798949f, -0.12723275f, 0.04300996f, 
    0.04688893f, 0.17239563f, -0.10089026f, 0.02159319f, -0.02284557f, -0.03383784f, -0.00059714f, 0.08127112f, 
    -0.00796444f, -0.14318289f, -0.07744952f, 0.05620582f, 0.27858964f, -0.17694713f, -0.03985548f, -0.21345569f, 
    -0.02058178f, -0.03937285f, -0.18760031f, -0.01308267f, -0.09597079f, -0.08253076f, 0.19185875f, 0.02065269f, 
    -0.01052474f, 0.22618043f, -0.02905399f, -0.09026992f, 0.12717329f, -0.04205569f, -0.14937606f, 0.17721553f, 
    -0.02463935f, -0.05660783f, 0.10141143f, 0.07225171f, 0.24980968f, -0.40540701f, 0.03361271f, 0.06104588f, 
    0.02032181f, 0.13371328f, -0.01384558f, -0.11171644f, 0.01070389f, 0.17200892f, 0.05774298f, 0.14095044f, 
    0.20171553f, -0.11844047f, 0.18727046f, -0.04521402f, -0.07404489f, -0.02939197f, 0.21961163f, 0.04753069f, 
    -0.02650148f, -0.03704407f, -0.13047923f, -0.10916902f, 0.07357129f, -0.23988047f, -0.09848636f, -0.18147680f, 
    -0.11467367f, 0.13430734f, 0.14957188f, -0.12063677f, -0.04565557f, 0.05981252f, 0.11195773f, 0.19943875f, 
    0.07410105f, -0.19448766f, -0.32905445f, 0.26842740f, -0.05320381f, 0.03373598f, -0.12959333f, -0.00314354f, 
    0.16960581f, 0.12522137f, 0.03425009f, 0.18349595f, 0.09004026f, 0.27006397f, -0.13787396f, -0.10071062f, 
    0.04268709f, 0.08717248f, 0.23129503f, 0.23695186f, -0.05132442f, 0.04756632f, -0.10562894f, 0.08068778f, 
    0.22434326f, -0.07699912f, 0.08006576f, 0.14193921f, -0.14341974f, -0.26137355f, 0.02407766f, 0.14390256f, 
    0.12247860f, -0.22206183f, -0.09172660f, 0.02266780f, -0.34301084f, -0.13631280f, 0.11713192f, -0.17736576f, 
    -0.11338308f, 0.11369471f, 0.20903863f, 0.17776319f, -0.12666364f, 0.00156301f, 0.00311003f, 0.21812095f, 
    -0.24527091f, 0.12964953f, 0.03784784f, 0.21339259f, -0.16869292f, 0.07247265f, -0.16412383f, -0.16198561f, 
    -0.13187639f, -0.08247545f, -0.05665179f, -0.16458255f, 0.22825442f, 0.15482366f, -0.02708731f, 0.06782827f, 
    -0.13212232f, -0.06818029f, 0.00538307f, -0.07497893f, 0.00175210f, 0.00273940f, 0.15925643f, -0.06001651f, 
    0.04844757f, -0.07395526f, -0.13939744f, 0.14796212f, 0.03082002f, -0.01107180f, 0.03006891f, -0.18470557f, 
    -0.14826345f, -0.06382177f, -0.17316794f, -0.04726389f, -0.05818568f, -0.09884230f, 0.08480689f, 0.19014135f, 
    -0.09906474f, 0.11169087f, 0.02915423f, -0.09636990f, -0.11725982f, 0.03981616f, -0.18941423f, -0.21088560f, 
    0.17691712f, 0.02019162f, -0.04896691f, 0.13458540f, -0.10435571f, -0.02678866f, 0.08239237f, -0.01769035f, 
    0.08455294f, 0.04545457f, -0.01871470f, -0.00088302f, -0.01991403f, 0.16298519f, 0.04664556f, 0.07638672f, 
    0.07845547f, 0.22175404f, 0.10285971f, 0.05723630f, 0.16343795f, 0.07958718f, 0.12794273f, 0.03087602f, 
    0.08039679f, 0.11981349f, 0.00127651f, 0.12357251f, -0.00939098f, 0.07815674f, -0.17085437f, 0.04835527f, 
    0.00396129f, 0.00500166f, -0.07483348f, 0.03168538f, 0.21902174f, -0.26479784f, 0.17137296f, 0.05578505f, 
    -0.18541481f, -0.08425249f, -0.07931408f, -0.12458933f, -0.04740424f, -0.07902505f, 0.16412210f, 0.01526756f, 
    0.15692988f, 0.12148187f, 0.13155772f, 0.20325586f, 0.05598103f, 0.02949426f, -0.13562198f, 0.23869483f, 
    0.02252165f, 0.07752112f, 0.04134054f, 0.03014739f, 0.35847872f, 0.05154460f, -0.27324584f, 0.03163843f, 
    -0.11704768f, 0.14864273f, -0.07370602f, 0.02183224f, -0.08248033f, 0.11536852f, 0.02656517f, -0.01650889f, 
    0.24344498f, -0.09186959f, -0.03763179f, -0.29404265f, -0.06713074f, -0.30255598f, 0.08473676f, 0.05802771f, 
    0.03764114f, 0.00331163f, 0.02919392f, -0.03653333f, 0.24543583f, -0.09570305f, 0.01638073f, -0.10791046f, 
    -0.18164100f, -0.19122733f, 0.09892865f, -0.00791224f, -0.07398847f, -0.05510100f, 0.00182814f, -0.03171986f, 
    0.14487904f, 0.07659654f, -0.20585488f, 0.24385536f, -0.12140429f, 0.01057279f, 0.06233740f, -0.05133171f, 
    -0.03122643f, -0.08466826f, -0.07763170f, 0.03982634f, 0.24498272f, 0.17758222f, -0.11607683f, -0.03771219f, 
    -0.02694980f, -0.02547887f, 0.00862898f, 0.02863433f, 0.07982674f, -0.01168397f, -0.14909703f, -0.06368282f, 
    0.07925543f, 0.16384144f, 0.16173804f, 0.31255370f, 0.05507942f, -0.09958505f, -0.03197263f, 0.11682283f, 
    -0.09633634f, -0.04523262f, 0.01242998f, 0.00201970f, -0.15359242f, -0.05878617f, 0.11334877f, -0.05885227f, 
    -0.04518509f, 0.00634334f, 0.10820443f, 0.19743289f, -0.01022909f, 0.13771509f, 0.08762912f, 0.00005724f, 
    -0.01916132f, 0.02211308f, -0.04953020f, 0.00090051f, -0.07690769f, -0.06703550f, 0.04551817f, -0.03033664f, 
    0.04795350f, -0.02489045f, 0.02236004f, -0.02104543f, -0.00684706f, -0.07655950f, -0.06775238f, -0.05576611f, 
    -0.07479083f, -0.05858739f, -0.04522550f, -0.00109781f, -0.03787221f, -0.04713912f, 0.00647647f, 0.01931367f, 
    -0.00129284f, -0.04887851f, -0.05389574f, -0.05310531f, 0.02444088f, 0.00730021f, 0.02664383f, 0.02116271f, 
    0.05527308f, 0.00887997f, -0.00257653f, 0.02914178f, 0.03422816f, 0.02576211f, -0.06431004f, 0.01533793f, 
    0.04623483f, 0.03211464f, -0.02481573f, -0.02188572f, -0.00734044f, -0.07278711f, -0.04805888f, -0.06319495f, 
    -0.05443067f, -0.05738194f, 0.06683602f, -0.00011309f, -0.04928944f, -0.07557276f, -0.02009076f, -0.05066010f, 
    -0.02499975f, 0.02766048f, -0.07050596f, 0.03011800f, -0.04023841f, -0.02494007f, 0.05561620f, -0.03790304f, 
    -0.04298517f, -0.00292625f, -0.05258442f, 0.04197728f, -0.03270155f, -0.00428701f, 0.00859005f, 0.02577101f, 
    -0.01985059f, -0.02959376f, -0.05657894f, -0.04955104f, -0.00319754f, -0.01459433f, 0.05568554f, -0.01978286f, 
    0.06250894f, -0.01397153f, -0.05787769f, 0.03377692f, 0.00226238f, 0.00817114f, -0.03060852f, -0.01936914f, 
    -0.07096474f, 0.02010309f, 0.00800673f, -0.00043088f, -0.00609308f, 0.00120467f, -0.06292989f, -0.03173059f, 
    -0.06849318f, -0.07422445f, -0.06389347f, -0.02232805f, 0.06088689f, 0.00574820f, -0.06315783f, 0.05565705f, 
    0.03399208f, -0.04892121f, 0.03793298f, 0.01053407f, 0.02948097f, 0.04345277f, 0.01045564f, 0.01015970f, 
    -0.06577247f, -0.02385386f, -0.04369301f, 0.03894792f, 0.00993115f, 0.00366929f, -0.00979948f, -0.06967805f, 
    -0.02951595f, 0.01382828f, -0.06975757f, 0.01056275f, -0.04278200f, -0.05100568f, -0.02727981f, -0.04189625f, 
    0.00410819f, 0.00063279f, -0.02283323f, 0.01617601f, 0.04816013f, -0.02409128f, 0.03724436f, 0.02180022f, 
    -0.03091615f, 0.00990793f, -0.03663067f, -0.01189689f, -0.04939410f, 0.01631400f, 0.03896914f, -0.04121171f, 
    -0.02775206f, -0.02516346f, 0.04715702f, 0.00909433f, -0.06373812f, -0.03214490f, -0.06546267f, 0.05826768f, 
    0.02496471f, 0.05310507f, 0.04142220f, 0.01280005f, -0.00945591f, 0.03556474f, 0.02082281f, 0.00401475f, 
    0.01257243f, 0.01048124f, 0.03928311f, 0.06534909f, 0.03524248f, -0.03685870f, -0.04252903f, -0.01882038f, 
    0.02487294f, 0.04372023f, -0.06180254f, 0.02637422f, 0.02601800f, 0.00790751f, 0.06683568f, 0.04811259f, 
    0.04423279f, -0.00205165f, -0.02966250f, -0.03553995f, -0.04382451f, 0.04868526f, 0.04381944f, -0.03662399f, 
    -0.01004025f, 0.04030027f, -0.07701526f, -0.06243277f, 0.00138832f, -0.02507440f, 0.06569089f, 0.01128851f, 
    -0.12966412f, 0.14991166f, 0.03224426f, -0.13989264f, 0.06280893f, -0.02356657f, -0.06785833f, 0.12660545f, 
    0.08280302f, 0.07641888f, 0.12269629f, 0.19270390f, 0.22807476f, -0.12148879f, 0.08687096f, -0.06198523f, 
    -0.07158517f, -0.02146782f, -0.04191677f, -0.12556142f, 0.17099507f, 0.11312039f, -0.01917310f, 0.13854815f, 
    -0.10101853f, 0.15637755f, -0.25319842f, 0.30960995f, 0.07472187f, -0.10551461f, -0.20085064f, 0.00279091f, 
    0.04406336f, 0.06393407f, 0.01656139f, 0.00201248f, -0.34626353f, -0.05022151f, 0.07019296f, 0.16331540f, 
    0.15904959f, 0.00463354f, -0.16294122f, 0.01614883f, -0.00346723f, 0.10206079f, 0.07069302f, 0.03461494f, 
    0.25909951f, -0.04310772f, 0.05624169f, 0.19832179f, 0.00992791f, -0.00200144f, 0.16193762f, 0.00697521f, 
    0.00320599f, 0.05155769f, -0.14306325f, -0.07673001f, -0.02612302f, 0.09766930f, 0.02895940f, -0.06019959f, 
    0.05661996f, -0.01949332f, -0.04419360f, 0.03707049f, -0.02504644f, -0.10091288f, 0.04183072f, 0.03755993f, 
    -0.10735396f, 0.03100713f, 0.20423840f, 0.21709089f, -0.00255309f, -0.00262417f, 0.10168000f, -0.02328831f, 
    -0.06668757f, -0.09636109f, -0.00076545f, -0.11283804f, 0.03214666f, -0.01244927f, -0.09362977f, 0.04223026f, 
    0.19112067f, -0.03826967f, -0.02238434f, -0.06525667f, 0.09641474f, 0.05678828f, -0.08308093f, 0.10721496f, 
    -0.04582745f, -0.01577167f, 0.06758683f, -0.00562018f, -0.04026375f, -0.09742720f, 0.05155579f, 0.18604478f, 
    -0.01980548f, -0.01706410f, -0.10286246f, -0.00923310f, 0.01399127f, -0.30537140f, 0.16854535f, -0.11595041f, 
    0.05394641f, 0.19880128f, -0.10838392f, -0.15678997f, 0.18774907f, 0.02366925f, 0.00790511f, 0.09180578f, 
    0.03577029f, 0.23463880f, -0.04468769f, -0.08005576f, -0.03994884f, -0.07310855f, -0.07961334f, 0.08957919f, 
    0.06819282f, -0.07273789f, 0.13213044f, 0.05657081f, -0.05011086f, -0.03590565f, -0.10405566f, -0.14305347f, 
    0.12814559f, 0.14293633f, 0.06076686f, -0.01239504f, 0.04955734f, -0.05553863f, 0.00365607f, -0.02794479f, 
    -0.06258094f, -0.23041989f, -0.28997156f, 0.18300551f, 0.14905550f, -0.06728555f, 0.04904203f, -0.06618597f, 
    0.14861883f, 0.05796113f, 0.16077796f, 0.12093724f, 0.18043391f, 0.00106264f, 0.11220615f, 0.13265993f, 
    -0.07462578f, -0.07965544f, 0.02587837f, -0.05609718f, 0.00996314f, -0.00737477f, -0.00517363f, -0.14375080f, 
    0.18418732f, -0.06419378f, 0.18215629f, 0.07767008f, 0.01330014f, -0.03304684f, -0.08535475f, 0.01387375f, 
    -0.05938381f, -0.07657840f, -0.04610841f, 0.00922225f, -0.17446792f, 0.13978675f, 0.12310674f, 0.25940222f, 
    -0.18364874f, -0.03008434f, -0.01701228f, -0.10300178f, -0.08628338f, 0.01776293f, 0.18897873f, -0.06913692f, 
    0.06368001f, -0.10512863f, 0.11729384f, 0.19205527f, 0.02649753f, -0.02140139f, 0.13145314f, -0.11547170f, 
    0.02016131f, -0.03554684f, 0.16946737f, -0.12255353f, 0.01487009f, 0.17078696f, -0.06581257f, 0.01405402f, 
    0.08893510f, 0.02646939f, -0.07992158f, -0.05091054f, 0.01436673f, -0.09330344f, -0.04925656f, -0.12500538f, 
    0.17309657f, 0.01305756f, 0.09503955f, -0.05697933f, -0.03673248f, 0.11269833f, 0.06844556f, -0.05284510f, 
    -0.00553502f, -0.01056220f, -0.14067551f, -0.02887397f, 0.26012620f, -0.06799179f, -0.08543801f, 0.10606542f, 
    -0.18879232f, -0.05886568f, 0.08631936f, -0.05790918f, -0.03365063f, 0.00822418f, -0.09820236f, -0.06537349f, 
    -0.14809625f, 0.03160881f, 0.00120799f, -0.06812175f, -0.07123065f, -0.04089070f, -0.23856950f, -0.01215796f, 
    0.08559702f, -0.04642255f, 0.24244355f, 0.09400691f, 0.10404371f, 0.02226018f, -0.08544213f, 0.20780189f, 
    -0.06084867f, 0.00939064f, 0.15828937f, -0.04280883f, 0.05897298f, 0.06377766f, -0.02686281f, 0.01699411f, 
    0.19763395f, 0.07282139f, 0.06029131f, -0.00577021f, -0.03560545f, 0.07005832f, -0.09158485f, 0.04217233f, 
    0.01339987f, 0.02124108f, -0.09170540f, 0.00596155f, 0.02987928f, -0.10602976f, 0.07689823f, -0.04823587f, 
    -0.11478563f, -0.12404987f, -0.04163096f, 0.05003737f, 0.02015180f, 0.04700736f, 0.16240555f, -0.04209264f, 
    0.21472186f, 0.08518152f, 0.24723493f, -0.03282893f, 0.00530030f, 0.10155048f, -0.12077650f, -0.11569617f, 
    0.03988504f, 0.01493482f, 0.10145118f, -0.01907961f, 0.12762390f, 0.04047024f, -0.24652937f, 0.06916250f, 
    0.04825587f, -0.02434357f, -0.02163968f, 0.09458891f, -0.05550017f, 0.19298618f, 0.04757116f, 0.11839397f, 
    0.05871695f, 0.01604147f, -0.16454183f, 0.14696793f, -0.05550820f, 0.05809525f, 0.01579017f, -0.06335574f, 
    0.02590520f, 0.12162359f, -0.04498553f, 0.00215819f, 0.05777888f, -0.02675381f, -0.00757605f, 0.09842886f, 
    -0.03821415f, 0.01224244f, -0.02619962f, 0.03838524f, -0.10860351f, 0.12190966f, 0.08715793f, 0.01640229f, 
    -0.00078563f, 0.07184944f, 0.10342700f, -0.07465462f, -0.07782984f, -0.02545064f, -0.06227459f, 0.03925411f, 
    0.04949385f, -0.05442335f, -0.03122862f, -0.07605682f, -0.08637148f, 0.23738034f, 0.09001178f, -0.13628803f, 
    -0.04101766f, 0.01652240f, 0.01023192f, -0.01696896f, 0.08102437f, -0.06297906f, -0.08275657f, 0.07943951f, 
    0.05005642f, 0.25289920f, -0.07035722f, 0.13239038f, -0.21609309f, -0.03235917f, 0.06156885f, -0.00982103f, 
    -0.00676618f, -0.00982112f, -0.10867655f, -0.04326978f, 0.15949605f, 0.02974184f, 0.01352472f, -0.10382991f, 
    0.02597626f, 0.02656576f, 0.06081037f, 0.10552590f, -0.02495281f, 0.06242242f, -0.07348745f, 0.12595451f, 
    0.41313574f, -0.19911784f, 0.12489271f, -0.22307633f, 0.10289488f, -0.04160380f, 0.10002776f, 0.14826334f, 
    -0.03422217f, 0.01317918f, -0.04664950f, 0.05697324f, 0.24994324f, -0.46064010f, 0.00440289f, 0.05505419f, 
    0.11861313f, -0.02246152f, 0.02925032f, 0.04298615f, -0.03640231f, -0.00847068f, -0.09606335f, 0.08371079f, 
    0.05389074f, 0.18221058f, -0.22961015f, 0.09440928f, -0.04983352f, -0.00819639f, -0.02099613f, 0.07968109f, 
    0.10262671f, 0.09476703f, 0.03224228f, -0.12879378f, -0.26920673f, 0.13858986f, 0.13091260f, -0.22577399f, 
    0.05798787f, 0.10027103f, 0.03624861f, 0.07677796f, -0.14841841f, 0.06270960f, -0.00172215f, 0.03525915f, 
    -0.04874291f, 0.20439065f, -0.23568885f, 0.17525689f, 0.07631512f, 0.07572176f, -0.04757952f, 0.01501003f, 
    -0.07477732f, 0.05293737f, 0.20393625f, -0.01753664f, 0.17080203f, -0.00253469f, 0.14837094f, 0.10321749f, 
    0.12146715f, -0.09904592f, 0.07089475f, 0.17569286f, 0.03216590f, -0.03804717f, -0.04746167f, 0.03816810f, 
    -0.25326401f, -0.06109148f, 0.09888996f, -0.01814131f, 0.10146716f, 0.03629908f, 0.14675546f, -0.08859508f, 
    -0.08677062f, 0.00919290f, -0.00469628f, 0.04882150f, -0.06474893f, 0.36496189f, -0.03571986f, -0.01853135f, 
    0.06907737f, 0.03731462f, -0.08146031f, -0.02824811f, 0.04928512f, -0.06977379f, -0.00752413f, 0.04195314f, 
    -0.08593874f, -0.10540791f, 0.06954855f, -0.05704043f, 0.08497633f, -0.00544543f, 0.08117578f, -0.00842503f, 
    -0.02791772f, 0.01323307f, -0.01932034f, 0.07481118f, -0.03688126f, -0.04432667f, 0.03338684f, -0.14876762f, 
    -0.02707361f, 0.01196504f, -0.01637831f, -0.13345540f, -0.02119207f, -0.02258042f, -0.09596093f, 0.07120568f, 
    -0.00080957f, 0.27209759f, -0.02427578f, 0.25518227f, 0.01395284f, -0.02400224f, 0.00926364f, 0.01141686f, 
    -0.03884308f, -0.15274465f, 0.00475026f, -0.03144846f, -0.22794992f, 0.25579169f, 0.05501701f, 0.02773050f, 
    -0.02071694f, 0.07535577f, 0.01967930f, -0.11565161f, -0.01261278f, -0.03738056f, 0.03721421f, -0.11913068f, 
    0.04647817f, -0.01534421f, 0.09093392f, -0.08552226f, 0.01216204f, 0.10876709f, 0.00806585f, -0.03251714f, 
    -0.09774560f, 0.00013745f, 0.10936404f, -0.07804020f, -0.11824154f, -0.19123584f, 0.21822052f, 0.17376421f, 
    0.01831616f, -0.02680149f, 0.04187125f, -0.09449311f, 0.03373713f, 0.02404918f, 0.05064399f, 0.02446686f, 
    -0.00713037f, 0.13934547f, 0.02864593f, 0.08160133f, 0.14045224f, -0.08436744f, 0.14070475f, -0.01229462f, 
    0.05533582f, 0.01108419f, -0.01102028f, 0.03681722f, -0.04825182f, 0.00368415f, -0.09767030f, 0.18251237f, 
    -0.00622449f, -0.03592439f, 0.06016628f, -0.14238504f, -0.09225004f, 0.09781673f, 0.11910950f, 0.05862125f, 
    0.02233892f, -0.00186336f, -0.02396964f, -0.04258723f, -0.07747405f, 0.01984779f, 0.03002809f, -0.04536033f, 
    -0.01362422f, -0.01419623f, -0.02140190f, -0.01747192f, -0.06327321f, 0.04159274f, 0.00324380f, -0.05122849f, 
    0.01479763f, 0.06145264f, -0.00995761f, 0.03309005f, -0.00060447f, 0.02632468f, 0.00903136f, 0.05207456f, 
    -0.00299536f, -0.04435540f, -0.02930471f, -0.01956389f, 0.03307988f, 0.05454111f, 0.06171730f, 0.02398274f, 
    0.03370343f, -0.03959748f, -0.03647239f, 0.01121719f, -0.00797070f, -0.05971387f, -0.05168746f, 0.01444738f, 
    0.03050995f, 0.03019967f, -0.05274023f, 0.04838790f, 0.01824402f, -0.03237833f, 0.06249514f, -0.06301018f, 
    -0.04253266f, -0.04858956f, -0.05243443f, 0.03226271f, -0.07176488f, 0.05345358f, -0.07412941f, 0.03359772f, 
    -0.01742123f, 0.00001347f, 0.02201519f, -0.05865693f, 0.05529499f, -0.04857307f, 0.04912549f, 0.02927194f, 
    -0.03469444f, -0.06468565f, -0.07832787f, 0.00961311f, -0.00190995f, 0.02195368f, -0.03003551f, -0.07957654f, 
    0.04636190f, -0.03957755f, 0.01857829f, 0.03776189f, 0.00012675f, 0.02263042f, -0.00639855f, -0.01644864f, 
    -0.00873790f, -0.01297132f, -0.05044530f, -0.04669959f, -0.03544759f, -0.03193829f, -0.06598625f, -0.04057331f, 
    0.00579936f, -0.06626704f, 0.01960766f, 0.04311324f, 0.02154223f, -0.04298557f, 0.03323452f, 0.03298716f, 
    0.04398948f, 0.00169312f, -0.07490363f, -0.03923766f, -0.00415469f, -0.00995349f, 0.02364894f, -0.04095907f, 
    -0.04622079f, -0.01963705f, 0.06091784f, -0.06545752f, 0.05294248f, -0.05003496f, 0.03971133f, 0.04394319f, 
    0.04126490f, 0.03880007f, -0.05110427f, -0.03816598f, 0.02392739f, 0.03131550f, 0.01237738f, -0.04826851f, 
    0.03176559f, -0.00744671f, 0.03742533f, 0.02689277f, -0.01922480f, 0.03435646f, -0.01020441f, 0.02189878f, 
    0.03199222f, -0.07701115f, -0.05508060f, 0.00764979f, -0.00579976f, 0.02476640f, 0.04312224f, -0.08096544f, 
    -0.05198407f, -0.07860771f, 0.03826019f, 0.00390781f, -0.07351140f, -0.06032659f, -0.04736513f, 0.02405790f, 
    0.00234307f, 0.02608088f, -0.00004791f, 0.05191112f, -0.02803723f, -0.03819998f, 0.04086131f, 0.03052734f, 
    -0.04710057f, 0.04763624f, 0.00437734f, -0.05380007f, -0.00764151f, 0.04052288f, -0.08101843f, -0.07754536f, 
    0.03523808f, 0.01033741f, -0.05755756f, -0.02543952f, 0.05920842f, -0.05242675f, -0.02588519f, -0.05383564f, 
    -0.02806579f, -0.01003420f, -0.03098682f, -0.07827902f, -0.06823833f, 0.06392715f, 0.04230799f, -0.02666672f, 
    -0.08161131f, -0.00972536f, 0.02106106f, -0.07309240f, 0.05321708f, -0.00762887f, -0.05599816f, -0.02120566f, 
    -0.03665254f, -0.04020477f, -0.03399600f, -0.02790086f, -0.01932791f, -0.07078083f, 0.01135993f, -0.02700121f, 
    0.04046602f, 0.26520708f, -0.06545446f, -0.14793411f, 0.05612970f, 0.10896339f, -0.08622546f, 0.16687259f, 
    0.09652711f, -0.05271287f, 0.01827102f, 0.22729449f, 0.29922065f, 0.06082611f, -0.09823713f, -0.20154667f, 
    0.15682228f, 0.09030273f, 0.07060742f, 0.03003955f, 0.04177045f, 0.05536198f, -0.00958986f, 0.02878922f, 
    -0.60493231f, 0.09802246f, 0.20939377f, 0.02682475f, 0.01089699f, -0.05407121f, 0.12811965f, 0.17133933f, 
    -0.05299957f, -0.05012363f, 0.01574597f, 0.00573877f, -0.08676768f, -0.07660774f, -0.17501551f, 0.03286725f, 
    0.35948920f, 0.00856628f, -0.05835731f, 0.01227813f, 0.08523515f, 0.02635313f, -0.00955989f, 0.04455859f, 
    -0.14058393f, -0.33268109f, 0.12700409f, 0.18534435f, -0.03325570f, 0.01135865f, 0.18171640f, 0.12949549f, 
    0.12471073f, 0.13727851f, -0.10661331f, -0.00718727f, -0.19639209f, -0.06933427f, 0.06067351f, -0.17796987f, 
    0.16619089f, -0.15202142f, -0.02965703f, -0.07695216f, 0.07165804f, -0.04676245f, 0.17207471f, -0.04182273f, 
    0.22275260f, 0.03817369f, 0.12268625f, 0.00926499f, -0.13108838f, 0.00168013f, -0.07772238f, -0.01172437f, 
    -0.03911146f, 0.04432893f, -0.12856185f, -0.03870905f, 0.21164410f, 0.03893182f, -0.09478416f, -0.10462128f, 
    0.31640476f, 0.00553851f, -0.02190596f, -0.02538222f, -0.00828134f, -0.02377734f, -0.05481553f, 0.05224717f, 
    0.29309180f, -0.05998184f, 0.09181383f, 0.32832929f, -0.23269743f, -0.29603469f, -0.15662891f, 0.01881305f, 
    0.15284802f, 0.14363207f, 0.09858450f, -0.03484166f, 0.11085784f, -0.01619695f, -0.23457238f, -0.29619598f, 
    0.06658628f, 0.10188466f, 0.18000646f, -0.10603404f, -0.02839490f, 0.10469658f, -0.01286582f, -0.18976057f, 
    0.08943161f, -0.02788173f, 0.33988115f, -0.35234731f, 0.02302348f, -0.02255159f, 0.11912329f, 0.00212972f, 
    -0.04881881f, -0.03839399f, 0.16111909f, 0.07990056f, 0.45038071f, 0.06175672f, 0.20156223f, -0.25680244f, 
    0.07981829f, -0.09461364f, -0.02390030f, 0.02094162f, -0.11851943f, -0.03006417f, 0.10046891f, 0.17110062f, 
    0.01620639f, 0.06785002f, -0.24269828f, -0.23389573f, 0.10863040f, 0.13418821f, -0.05457629f, -0.06084363f, 
    -0.03294229f, 0.09690538f, 0.23807478f, 0.20703356f, 0.20330548f, -0.16052760f, -0.10826392f, 0.08075375f, 
    -0.27292559f, -0.24493194f, -0.15723768f, 0.18030475f, -0.05673436f, 0.04323824f, 0.13941151f, -0.04504684f, 
    -0.16524507f, 0.03027181f, 0.06308977f, 0.07561816f, -0.32283378f, -0.16726929f, -0.11493891f, 0.06486790f, 
    -0.14831825f, 0.06894921f, -0.12206779f, 0.05019916f, -0.11738310f, -0.16506925f, 0.07425158f, 0.06583027f, 
    -0.03843751f, -0.02866055f, -0.06057006f, 0.22437590f, 0.00759246f, -0.23848115f, -0.08322319f, 0.13185716f, 
    -0.35118473f, 0.07429012f, -0.07785078f, 0.24075866f, 0.01625949f, 0.02825667f, 0.03456894f, -0.08030209f, 
    -0.01627375f, 0.06776662f, 0.11603331f, 0.04874560f, -0.23111695f, 0.31869426f, 0.01201342f, -0.15486547f, 
    0.00893947f, -0.01909546f, 0.04919618f, 0.04806719f, 0.13223326f, 0.03320201f, 0.09878589f, -0.01587400f, 
    0.08713379f, -0.23420969f, 0.21332140f, -0.25321594f, 0.10364485f, 0.01037280f, 0.04864950f, 0.05437993f, 
    -0.08903194f, 0.02632058f, 0.02074523f, 0.17214806f, 0.09085801f, -0.19917546f, 0.04034935f, 0.15576661f, 
    -0.05304591f, -0.11034327f, 0.00590123f, 0.02614979f, 0.08986771f, -0.04004681f, 0.04227030f, 0.06399587f, 
    -0.00825012f, -0.11213408f, 0.19534461f, -0.08932303f, 0.04365575f, -0.03705967f, 0.08300041f, 0.05857275f, 
    0.05799854f, -0.04214380f, -0.25360283f, -0.12207495f, -0.13293622f, -0.04046860f, -0.12996703f, 0.00949654f, 
    -0.03602764f, 0.12385111f, -0.01655079f, -0.15076874f, 0.02087745f, 0.12190346f, -0.07158390f, 0.02770942f, 
    0.12462930f, 0.08746185f, -0.02744771f, -0.01116611f, -0.12447397f, 0.04849084f, 0.01164048f, 0.04321178f, 
    0.09247176f, 0.06119247f, 0.09043043f, -0.01864721f, 0.13448903f, -0.21078373f, 0.16935977f, 0.10750966f, 
    -0.06558765f, -0.06512050f, 0.00413518f, 0.03187762f, 0.01553233f, 0.10284700f, 0.01618898f, 0.06290476f, 
    -0.09013039f, 0.08688407f, -0.09377763f, -0.08829003f, 0.03993401f, 0.02490620f, 0.03228126f, -0.01182918f, 
    0.08329586f, -0.00674227f, -0.05317169f, 0.07836946f, -0.06545021f, 0.03237624f, 0.11513679f, 0.15518129f, 
    -0.01451568f, -0.04067671f, 0.11025541f, 0.05285037f, -0.00634110f, 0.03563797f, 0.05529615f, -0.04438983f, 
    0.00596369f, -0.14026505f, -0.14646517f, -0.13328682f, 0.05660984f, 0.03161195f, 0.09354433f, -0.07369674f, 
    -0.02806407f, 0.11031511f, 0.00536710f, 0.14087762f, 0.17733780f, -0.26301348f, -0.05366509f, 0.09877227f, 
    0.04613707f, -0.07876843f, 0.07330726f, 0.12243486f, 0.01778301f, -0.01142144f, 0.06315742f, 0.11503913f, 
    0.16152118f, -0.06963721f, 0.01099932f, 0.09791628f, -0.01986008f, -0.07184362f, -0.05443677f, 0.08241109f, 
    0.06379586f, -0.01147809f, -0.00461781f, 0.06560235f, 0.08521057f, 0.24676585f, -0.16116683f, -0.05522328f, 
    0.09709432f, 0.24319157f, -0.01446677f, -0.00367116f, 0.06397905f, -0.11752246f, 0.05369799f, -0.00417726f, 
    -0.09887749f, -0.10774784f, 0.02952571f, 0.04190217f, -0.04314730f, 0.06514110f, -0.04386363f, 0.02654769f, 
    0.09025014f, 0.10473980f, 0.05171017f, 0.03934837f, 0.09816745f, 0.01089863f, 0.04826117f, -0.09808190f, 
    -0.02214736f, 0.00090073f, -0.05632598f, -0.10168676f, 0.08626468f, -0.18284370f, -0.01508841f, -0.01772535f, 
    -0.02940896f, 0.05017566f, 0.04837999f, -0.05238390f, -0.02178156f, 0.05374094f, 0.04801308f, 0.01342008f, 
    0.03530880f, 0.04630674f, -0.01447855f, 0.04849889f, 0.02432031f, 0.05301380f, 0.00112846f, -0.08331654f, 
    -0.05990145f, 0.04111708f, -0.06875981f, 0.04274595f, -0.00397581f, -0.05460455f, 0.05259565f, -0.08025429f, 
    -0.07796304f, -0.06081024f, 0.05679569f, 0.02921711f, 0.00773581f, 0.01299267f, 0.03370425f, -0.03892961f, 
    -0.06285529f, -0.05017818f, -0.01858616f, 0.00685485f, 0.02670744f, 0.01793055f, 0.00713801f, 0.02184437f, 
    -0.04976371f, -0.04150486f, -0.03987702f, 0.00754972f, -0.06861564f, -0.02481228f, 0.01942761f, 0.03378765f, 
    0.05824886f, 0.01644028f, 0.04164380f, 0.00512773f, 0.00974352f, -0.05315553f, 0.04529796f, -0.05071110f, 
    -0.06969092f, -0.05463173f, -0.07707714f, -0.01460627f, -0.05034694f, 0.00158100f, -0.01698079f, 0.00979728f, 
    -0.00447650f, 0.04702149f, -0.04221681f, 0.01845657f, -0.03399387f, -0.00544081f, 0.01141278f, -0.03293565f, 
    0.01315839f, -0.07670528f, -0.06798586f, -0.04676943f, 0.05847166f, 0.02455156f, -0.01404674f, -0.02771874f, 
    0.04473845f, -0.01471116f, -0.03502249f, 0.02542602f, -0.00993513f, 0.00562447f, 0.05440445f, -0.01292985f, 
    -0.01095449f, -0.03695698f, -0.01945318f, -0.00684860f, -0.07204495f, 0.02403459f, -0.01327615f, -0.06718509f, 
    -0.07811671f, 0.00572190f, -0.05585180f, 0.02971535f, -0.00277042f, -0.04219977f, 0.05957078f, -0.01646725f, 
    -0.04078709f, -0.04898209f, -0.05050636f, -0.02032024f, 0.01800170f, -0.00293102f, 0.02210830f, -0.00915091f, 
    -0.05065166f, 0.02938949f, 0.04587829f, -0.07674189f, 0.03869302f, -0.04398380f, 0.03441484f, -0.03282677f, 
    0.00365533f, 0.04735352f, 0.03042429f, -0.03452626f, 0.00033324f, 0.05888133f, 0.01957189f, -0.01067220f, 
    -0.05419941f, 0.05019619f, 0.02872458f, -0.01325779f, -0.07075798f, 0.01754549f, -0.05820913f, -0.06246298f, 
    -0.03999372f, -0.01916678f, -0.03403750f, -0.08268897f, 0.04382669f, 0.00888094f, -0.04978341f, -0.05821828f, 
    0.03949152f, 0.01132888f, -0.06844869f, 0.05310575f, 0.03829116f, -0.06376754f, 0.05686976f, 0.05388949f, 
    -0.06308535f, -0.01933071f, -0.04598475f, -0.04491298f, -0.02092997f, -0.01417250f, -0.00397965f, -0.05120036f, 
    0.03742251f, 0.01068736f, 0.05172185f, -0.01718617f, -0.03085699f, -0.04134858f, -0.00318047f, -0.05627120f, 
    -0.00859019f, 0.02442570f, -0.01287679f, 0.05937490f, -0.08183789f, 0.05917735f, -0.01427545f, 0.05022329f, 
    0.02154346f, -0.05982440f, -0.01613814f, -0.02040391f, -0.00560012f, -0.00303313f, -0.03338958f, 0.04417261f, 
    0.04475415f, 0.01974942f, -0.04940997f, -0.01952699f, -0.02119664f, -0.03479316f, 0.05258471f, 0.01937144f, 
    0.08271940f, 0.04501143f, 0.02611727f, -0.19358982f, -0.06133560f, 0.15631773f, -0.05383991f, 0.08367748f, 
    0.06479331f, -0.00186259f, -0.02304039f, 0.08965683f, -0.15705808f, -0.17988050f, 0.20995921f, -0.14924890f, 
    0.01808400f, 0.02420101f, -0.01986024f, -0.05564153f, -0.07326210f, -0.05742886f, 0.00802307f, -0.02445393f, 
    -0.24056809f, 0.16349019f, -0.12574230f, -0.05428147f, -0.00007860f, 0.05276572f, 0.01430637f, 0.00476069f, 
    -0.05184158f, 0.08365152f, -0.09645676f, -0.23913200f, -0.07376397f, 0.29018739f, 0.11532872f, -0.13064735f, 
    0.04800903f, 0.15523367f, -0.00787726f, 0.00331865f, -0.12342887f, 0.06642365f, -0.10905482f, -0.15456498f, 
    -0.10773834f, 0.24234499f, -0.11140417f, 0.02682960f, 0.04734115f, 0.06086230f, -0.03374804f, 0.03527361f, 
    0.00746068f, 0.08010021f, 0.25049353f, 0.01693628f, 0.22346687f, -0.07954773f, 0.19180579f, -0.00796793f, 
    -0.08359060f, -0.08392178f, 0.16797854f, 0.19591209f, -0.07559021f, 0.13481948f, -0.07076299f, 0.05598177f, 
    -0.00397634f, -0.08716775f, 0.01566915f, 0.15503886f, 0.12055369f, -0.07655282f, -0.16127247f, -0.01324239f, 
    -0.01672358f, -0.08863204f, -0.13865392f, 0.04275643f, -0.17264208f, 0.29360890f, -0.20073193f, -0.30480006f, 
    0.13471681f, -0.02170881f, -0.07082913f, 0.11152748f, -0.02347391f, -0.00175429f, 0.09071151f, 0.00714637f, 
    0.23806420f, 0.04327236f, -0.17263253f, 0.07052809f, 0.06372417f, 0.00150275f, 0.02529361f, 0.12428562f, 
    -0.00568788f, 0.04110543f, 0.06510498f, 0.13983081f, -0.27398294f, -0.11363401f, 0.12308445f, -0.08009091f, 
    -0.14919026f, 0.19200014f, 0.04252454f, 0.00180112f, 0.03290319f, 0.11271369f, -0.09865354f, 0.00071024f, 
    -0.06482755f, 0.15321025f, 0.17184715f, 0.04455560f, 0.03210197f, 0.05953679f, -0.05377830f, 0.10000911f, 
    -0.09549349f, -0.05008474f, -0.05072480f, -0.09243958f, -0.29510871f, 0.22070055f, 0.13320911f, -0.00856314f, 
    -0.04150780f, 0.02131793f, 0.01350271f, -0.05337650f, 0.04928028f, 0.07437082f, -0.08542704f, -0.00776651f, 
    0.04555947f, -0.12494195f, -0.01125917f, -0.01084866f, -0.05912906f, 0.06556395f, 0.09606692f, -0.11207982f, 
    0.00493335f, 0.08573536f, -0.05369890f, 0.04982930f, 0.13525924f, -0.20514518f, 0.07571771f, 0.29930294f, 
    0.10940434f, -0.06094283f, 0.13369606f, 0.12805569f, -0.02101991f, -0.00379877f, -0.05153774f, -0.00916019f, 
    0.10125176f, -0.03242652f, 0.14069422f, 0.08353133f, 0.11851358f, -0.14265472f, 0.08490220f, 0.03954906f, 
    -0.00291525f, -0.11092142f, 0.03892066f, -0.02668745f, -0.16175142f, -0.08282363f, 0.08393577f, 0.19559604f, 
    0.04963896f, 0.07242343f, 0.13444296f, 0.15331277f, 0.01446565f, 0.24551675f, 0.05773771f, 0.03968074f, 
    0.04003964f, -0.07174903f, -0.03335183f, 0.04515819f, -0.03694350f, -0.23006314f, 0.28692815f, 0.01354146f, 
    0.00879062f, -0.08602856f, 0.06770967f, 0.14689524f, 0.00507820f, 0.01011654f, -0.02598621f, 0.18197086f, 
    0.13573043f, 0.04211434f, -0.09068180f, -0.12871435f, -0.06425281f, 0.14898966f, 0.01171798f, 0.08068037f, 
    0.30446431f, 0.18368849f, -0.09434503f, -0.18948001f, -0.10445233f, 0.17765726f, 0.04907090f, 0.05561762f, 
    0.10401779f, 0.02509688f, 0.15181847f, 0.03062747f, -0.23133478f, -0.10589071f, -0.07869333f, 0.18987423f, 
    -0.07182992f, -0.04631784f, 0.00811941f, 0.11336447f, 0.02005894f, -0.02733144f, 0.01531303f, 0.07626712f, 
    -0.05715605f, 0.13920864f, 0.13051015f, 0.08866625f, -0.04077542f, -0.08619296f, -0.08282577f, 0.14633033f, 
    -0.01755629f, -0.10684558f, 0.15148319f, -0.06752662f, -0.13305853f, 0.10582513f, 0.05710416f, -0.01088240f, 
    0.12123587f, -0.02909713f, 0.06928024f, -0.02965980f, -0.05298121f, -0.07796642f, 0.01731030f, 0.13628817f, 
    -0.08788973f, 0.02026999f, 0.22507454f, -0.08465457f, -0.04702914f, -0.04278667f, 0.13908605f, 0.06712468f, 
    -0.06019644f, 0.03275315f, 0.02962334f, -0.09116156f, -0.05074447f, -0.00136532f, -0.10690863f, 0.14012948f, 
    -0.17075498f, 0.00030845f, 0.01749478f, -0.01099310f, -0.00472357f, -0.13301946f, -0.02455968f, -0.02665317f, 
    0.05564804f, 0.09445757f, 0.20542075f, -0.05940365f, -0.02875249f, 0.00183637f, -0.00364170f, -0.03609228f, 
    -0.18544623f, 0.00924124f, -0.06712710f, 0.06937400f, 0.07402502f, -0.41964191f, -0.26239869f, 0.18351448f, 
    0.04610137f, -0.13791877f, -0.02379618f, -0.04261038f, 0.10669519f, 0.13581003f, 0.03973353f, 0.02362881f, 
    0.13271314f, 0.42693582f, -0.08504512f, 0.09668174f, 0.02132005f, 0.00316231f, 0.02267576f, 0.20008063f, 
    -0.03014762f, -0.00055734f, 0.13298386f, 0.10698185f, -0.07693954f, 0.16107750f, -0.29068074f, 0.09479596f, 
    -0.01084159f, -0.01964931f, 0.00981846f, 0.03190077f, 0.09460137f, 0.13417296f, 0.06644817f, -0.06823803f, 
    -0.02167739f, -0.22797611f, 0.03795379f, 0.28281656f, -0.16005132f, 0.05005888f, -0.05828064f, -0.10250576f, 
    0.09327745f, 0.05190573f, -0.01249273f, -0.04593965f, -0.10421328f, 0.15085779f, 0.01593610f, -0.15951450f, 
    -0.13860692f, 0.02917341f, -0.19905713f, -0.02408270f, -0.09581731f, -0.01895441f, 0.02900738f, -0.01970117f, 
    0.11169386f, -0.01515368f, 0.12884600f, -0.21463627f, 0.11361932f, 0.09544034f, 0.03761020f, 0.21436030f, 
    -0.06458398f, 0.09441922f, -0.04789872f, 0.04762980f, 0.12329625f, 0.10655986f, 0.06131712f, -0.08257869f, 
    -0.01874308f, 0.08997951f, 0.08219751f, -0.05621012f, -0.00507644f, 0.04294360f, 0.06303429f, 0.03201845f, 
    0.03565078f, 0.01151138f, -0.02668640f, -0.02883074f, -0.05852402f, 0.00745299f, -0.00309286f, -0.02112982f, 
    -0.03535687f, 0.00420665f, -0.07950287f, -0.05821912f, 0.00684203f, -0.03962912f, 0.04450424f, -0.03321245f, 
    -0.02543422f, 0.04451093f, 0.00065289f, -0.07665133f, -0.05794992f, 0.00873370f, -0.03695402f, 0.04596724f, 
    0.03113396f, 0.02964283f, 0.05901361f, 0.02284034f, 0.05738190f, 0.02844821f, -0.03259591f, -0.02577330f, 
    0.01267145f, -0.04394693f, -0.07183508f, 0.04903127f, -0.04916539f, -0.03596425f, 0.05338290f, -0.05606137f, 
    0.05962521f, 0.00466306f, -0.05936852f, -0.06923710f, 0.01952141f, 0.03920325f, -0.00595300f, 0.03607463f, 
    0.03349563f, 0.03917826f, -0.01455942f, 0.01294219f, -0.00128992f, -0.01666015f, -0.06280420f, 0.05359183f, 
    0.06297801f, 0.02085799f, -0.01838820f, 0.00490898f, 0.00771276f, 0.05800518f, -0.01678123f, 0.04500003f, 
    -0.06051615f, -0.03646104f, -0.02008336f, 0.00532749f, -0.05123965f, 0.04814520f, -0.05313393f, 0.03357355f, 
    -0.03441284f, 0.05838452f, -0.02824215f, -0.07383256f, -0.04540433f, -0.07024156f, -0.06761630f, 0.00272242f, 
    -0.00450132f, 0.05109672f, 0.05876845f, 0.04722393f, 0.01671896f, -0.05209785f, -0.00753776f, -0.00215297f, 
    0.03392128f, -0.02163397f, 0.01694686f, 0.00603580f, 0.04671190f, -0.04716373f, -0.01228507f, -0.01396496f, 
    -0.07283159f, -0.07828819f, -0.07713859f, -0.05723080f, 0.04960446f, 0.03605925f, -0.02202093f, 0.04244060f, 
    -0.05749828f, -0.02674160f, -0.00497969f, -0.04567293f, -0.05066678f, -0.00255600f, 0.00360330f, -0.07391932f, 
    -0.03251056f, 0.03692227f, -0.04361261f, 0.06198420f, -0.06204504f, -0.03687335f, -0.01832841f, -0.04425309f, 
    -0.01685831f, -0.04963800f, -0.01619931f, -0.05358883f, 0.03768776f, -0.01854024f, -0.03283424f, -0.04467320f, 
    -0.07788096f, 0.02591694f, -0.06271324f, -0.04872367f, -0.00778738f, -0.05796489f, -0.05546689f, -0.02659891f, 
    0.03505088f, 0.06161912f, -0.07447165f, -0.04366198f, 0.03204731f, -0.03484050f, -0.03147414f, 0.05636812f, 
    -0.05188749f, 0.06751860f, -0.04330680f, -0.00413466f, 0.04845143f, -0.06904878f, -0.02383102f, -0.03148160f, 
    -0.02857600f, 0.04759819f, 0.05871278f, 0.01977762f, -0.05131627f, 0.04270501f, 0.01874241f, 0.04370892f, 
    -0.02364722f, 0.03163612f, 0.03773799f, -0.07409591f, 0.06300526f, 0.02518459f, -0.07942864f, 0.01907702f, 
    0.00217975f, 0.04527560f, -0.08622666f, 0.01053720f, 0.05469420f, 0.03238783f, 0.02104108f, -0.04182609f, 
    0.05831427f, -0.03407558f, -0.02887570f, 0.05092461f, -0.04680683f, 0.03164650f, 0.01749306f, 0.03354710f, 
    0.03400866f, 0.04456552f, 0.05172601f, -0.06047180f, 0.01739441f, -0.04870380f, -0.06909467f, 0.02394530f, 
    0.32008016f, -0.00232567f, 0.04398257f, 0.27479324f, -0.03022136f, 0.13402860f, -0.07895844f, -0.09626416f, 
    -0.03760957f, 0.15202327f, 0.03020197f, -0.00918454f, 0.12186295f, -0.05165754f, -0.14642967f, -0.13442850f, 
    0.11887135f, 0.10518115f, 0.05636064f, 0.08621000f, 0.01548828f, -0.01302020f, -0.00965080f, 0.10611913f, 
    -0.15067074f, 0.01181961f, -0.10002363f, -0.05378823f, -0.03430173f, -0.01296559f, 0.03313784f, -0.03229043f, 
    -0.03838642f, 0.00509022f, -0.07903767f, 0.04584413f, 0.03262025f, 0.05555414f, -0.04095410f, -0.22123992f, 
    0.04446068f, 0.01173919f, 0.00239219f, -0.03507834f, -0.04624210f, -0.09771977f, 0.02869985f, -0.08995554f, 
    -0.08226834f, -0.13419306f, -0.13885431f, -0.18642917f, -0.02421141f, 0.04912523f, -0.07101727f, 0.12147050f, 
    0.13539726f, 0.04295653f, 0.06014425f, 0.05299283f, -0.15495600f, -0.06411906f, -0.17719540f, -0.01551979f, 
    -0.03573810f, -0.08466500f, 0.14522165f, -0.10146907f, 0.02951029f, 0.10048833f, -0.06477723f, -0.03164177f, 
    0.40547442f, -0.14524639f, 0.03901619f, 0.09478042f, -0.08531659f, 0.05683962f, -0.15070210f, -0.01980592f, 
    0.06457435f, 0.07031909f, -0.06442133f, 0.04221771f, -0.02907575f, 0.21976043f, 0.06189558f, -0.06683978f, 
    0.18649390f, -0.04881619f, -0.06295000f, -0.03799650f, -0.09328077f, -0.00560553f, -0.00408524f, 0.05877888f, 
    0.37872815f, -0.03874204f, 0.08301777f, 0.14721592f, -0.08200132f, -0.03908986f, -0.02701001f, 0.01593257f, 
    0.09691051f, -0.07155161f, 0.08181801f, 0.06078687f, -0.03324195f, 0.35011193f, 0.07376702f, -0.24034700f, 
    0.08962536f, 0.16239302f, 0.03046564f, -0.00565711f, -0.11136676f, 0.00476561f, 0.12102520f, -0.16781029f, 
    0.08113267f, -0.08224136f, 0.06879873f, -0.06532621f, 0.00994649f, -0.06977705f, -0.02937999f, -0.11123713f, 
    -0.02594193f, 0.07976689f, 0.07887573f, -0.02876822f, 0.02291664f, -0.03463726f, 0.14035770f, 0.13239409f, 
    0.16619441f, -0.16157891f, -0.08098531f, -0.02459791f, 0.01388511f, -0.01698225f, -0.07987678f, 0.09469327f, 
    0.04622506f, 0.08739272f, -0.00977215f, 0.06772223f, 0.11117458f, -0.00311564f, -0.00417492f, 0.00539381f, 
    -0.08789312f, -0.05239150f, -0.04203248f, -0.00538212f, 0.27365938f, -0.12265764f, 0.03541572f, -0.02022888f, 
    0.07478327f, 0.05101551f, 0.09111843f, 0.29752737f, 0.01496080f, -0.02725821f, 0.08681697f, -0.00247751f, 
    -0.16634530f, 0.11586743f, -0.07139846f, -0.10858338f, -0.05442562f, 0.00021216f, 0.01679033f, -0.16562533f, 
    -0.00577747f, -0.02421063f, -0.00819978f, -0.08314668f, 0.06509254f, -0.19918996f, 0.01034200f, 0.00520416f, 
    0.02434110f, -0.03684354f, 0.05526410f, 0.04301152f, 0.02114037f, 0.02264558f, 0.05502845f, 0.01613536f, 
    0.02768579f, 0.03983473f, -0.02936381f, 0.27703920f, 0.03724588f, -0.11748514f, 0.00851628f, -0.16190049f, 
    0.04929226f, -0.09046154f, -0.09184977f, -0.08090873f, 0.28648618f, 0.06796702f, -0.12048212f, 0.02581175f, 
    0.00023561f, -0.00094499f, -0.13047816f, 0.10213660f, -0.02782954f, 0.11594523f, 0.05812709f, 0.15651068f, 
    0.33621371f, -0.10524092f, 0.01407063f, 0.17819934f, 0.11317864f, -0.03779717f, -0.02854149f, 0.04492299f, 
    0.02970785f, -0.00306985f, 0.06528968f, 0.03794454f, -0.11395613f, -0.12083466f, -0.02092618f, 0.01556456f, 
    0.01553553f, -0.16998211f, -0.07099561f, -0.01584433f, 0.03808188f, 0.01988838f, 0.15653218f, 0.06597833f, 
    0.10295852f, 0.00648466f, -0.05027926f, 0.03528589f, -0.02813957f, -0.05360189f, 0.00510575f, 0.15890498f, 
    0.04285967f, -0.04907118f, -0.20700929f, 0.00503674f, -0.16944548f, 0.02461277f, -0.14147101f, -0.02268774f, 
    0.01591844f, 0.08652763f, 0.01271306f, -0.17055246f, 0.06348755f, -0.14483680f, 0.03557801f, -0.07554605f, 
    0.03613901f, 0.14016595f, 0.06817471f, 0.03950097f, 0.04965696f, 0.08915409f, 0.00772679f, -0.03598915f, 
    0.03903436f, 0.06117045f, -0.04648571f, 0.04734734f, 0.11272790f, -0.21694221f, 0.03016592f, 0.12174836f, 
    0.00597386f, 0.01590911f, 0.01805434f, -0.09708148f, -0.06625376f, -0.02379785f, -0.06896923f, 0.00512077f, 
    0.04351754f, 0.00041572f, 0.05997068f, 0.22065081f, -0.00675554f, 0.05788981f, -0.14355825f, 0.04608389f, 
    -0.11988596f, -0.01281498f, 0.00224909f, -0.13815711f, 0.47624853f, 0.21452998f, -0.12133171f, -0.02023229f, 
    -0.00032727f, -0.15932593f, -0.04022926f, -0.01798745f, -0.13021529f, -0.05443867f, -0.06966439f, -0.09418759f, 
    0.04060457f, -0.12433608f, 0.10015505f, -0.18579696f, 0.13332950f, -0.04333110f, -0.06031877f, 0.02442900f, 
    -0.01257336f, 0.01995587f, -0.02034400f, 0.05846260f, -0.03430055f, 0.04232624f, 0.01769731f, 0.08276625f, 
    0.06301416f, -0.13174520f, -0.02501745f, -0.01050425f, 0.03512140f, 0.00804856f, -0.05531960f, 0.04535348f, 
    -0.10130218f, 0.07652909f, -0.10868287f, 0.00390113f, 0.11927688f, 0.05673045f, -0.01445128f, 0.00094387f, 
    -0.00835115f, -0.16285387f, -0.13407642f, -0.00097608f, 0.21015468f, 0.09913658f, 0.03982140f, -0.00351493f, 
    0.00119056f, -0.04753963f, -0.07768231f, 0.00536591f, -0.16913883f, 0.08848671f, -0.01199239f, -0.13272984f, 
    0.12519552f, 0.07772280f, 0.10498764f, 0.06479944f, 0.12632084f, 0.17038371f, -0.06451850f, -0.04070935f, 
    -0.04171768f, 0.10588733f, 0.05522126f, 0.02303193f, 0.17186159f, 0.05810843f, 0.01456336f, -0.01004403f, 
    0.21068497f, 0.00195895f, -0.08008903f, 0.10823373f, 0.07146149f, -0.14900093f, -0.07032711f, -0.07249665f, 
    0.03755856f, 0.01527107f, 0.06500683f, 0.02199405f, -0.15178746f, 0.08788618f, 0.01326015f, 0.01921552f, 
    0.18928833f, 0.01574244f, 0.12917718f, -0.10842633f, 0.10978557f, -0.08599317f, -0.28005454f, -0.26008782f, 
    0.08060503f, 0.07819581f, 0.00860699f, -0.08478292f, -0.01967721f, -0.02492079f, 0.02088740f, 0.06631261f, 
    -0.43178228f, 0.12329923f, -0.14354026f, -0.04536143f, -0.05059757f, 0.01384048f, -0.10945082f, -0.08099438f, 
    -0.02165861f, -0.02846719f, -0.08458133f, -0.07156216f, -0.10131782f, -0.04808353f, 0.02611786f, 0.26054507f, 
    0.06955462f, 0.01762330f, -0.15302391f, -0.13382940f, -0.05511984f, 0.04794170f, 0.05797442f, -0.16316736f, 
    0.12647000f, 0.15504050f, -0.22206138f, 0.13082583f, 0.06606470f, 0.03145175f, 0.06749403f, 0.00893749f, 
    0.01492186f, 0.16174066f, 0.06029305f, -0.02898624f, 0.03683399f, 0.23580258f, 0.00285121f, -0.04386633f, 
    0.13396649f, -0.05721151f, 0.08075549f, 0.23556888f, -0.06426895f, 0.03265640f, 0.01624496f, 0.08171688f, 
    0.21185887f, -0.16035794f, 0.09585446f, 0.21493022f, -0.04038200f, -0.09072944f, 0.06033648f, -0.07177872f, 
    0.10522686f, -0.15525164f, 0.06178664f, -0.09503740f, -0.16471748f, 0.00924883f, 0.05681654f, 0.17861789f, 
    0.16530412f, 0.09452944f, -0.04516928f, -0.16317441f, 0.04174503f, 0.03457301f, 0.05128779f, 0.05626747f, 
    0.51145321f, -0.17511010f, 0.20123230f, 0.07363071f, -0.01206159f, -0.01100534f, -0.05826902f, 0.03012569f, 
    -0.00185171f, -0.05591340f, -0.10617730f, 0.04430004f, -0.39458099f, 0.04876842f, -0.00122734f, -0.11057232f, 
    -0.00304485f, 0.33648542f, 0.07375222f, -0.05104465f, 0.07793255f, 0.03958244f, -0.01013399f, -0.13796833f, 
    0.20434184f, 0.28321618f, -0.03294363f, -0.13131462f, 0.00957799f, -0.04096993f, -0.10075210f, -0.01118890f, 
    0.05308782f, -0.06666136f, 0.00535968f, -0.04255517f, 0.24496818f, -0.04358053f, -0.03474252f, -0.01413497f, 
    0.07061496f, 0.04632077f, -0.02588745f, -0.09643553f, -0.09030099f, -0.08432170f, -0.05683393f, -0.01542501f, 
    0.12448020f, -0.09573650f, -0.12999162f, 0.29848093f, 0.08371989f, 0.04450243f, -0.06071781f, -0.19584763f, 
    0.05901542f, -0.01686691f, 0.05561304f, 0.10511447f, 0.26164034f, 0.06566619f, 0.14049956f, 0.10033395f, 
    -0.07620226f, -0.07180391f, 0.00096235f, 0.15501381f, 0.00623380f, 0.09857200f, 0.05642436f, -0.00938595f, 
    -0.02214177f, 0.00303156f, 0.11959787f, 0.14434980f, 0.11686923f, -0.12950082f, 0.06596695f, 0.01344096f, 
    -0.03816606f, 0.12551139f, 0.06964893f, 0.16123432f, -0.08512121f, -0.05151584f, 0.09330970f, 0.36138153f, 
    -0.07593997f, -0.06149067f, -0.01861756f, 0.13806720f, -0.05123961f, -0.08684893f, 0.20227242f, 0.02385699f, 
    0.24681546f, -0.03377008f, 0.13044971f, 0.18035331f, 0.02846918f, 0.16477618f, 0.01026750f, -0.07989486f, 
    -0.11431509f, 0.16597348f, 0.08281334f, -0.18030187f, -0.00175811f, 0.00710839f, -0.18488413f, 0.05076958f, 
    0.17007391f, 0.00274627f, 0.08126522f, 0.14502217f, -0.05033473f, -0.06044085f, 0.10046012f, 0.08015025f, 
    -0.00071653f, -0.03306199f, 0.15772557f, -0.04627542f, 0.00407079f, 0.09012759f, 0.08488746f, -0.04577586f, 
    0.11357289f, 0.13374920f, 0.01240426f, 0.04358740f, 0.28560483f, 0.11482359f, -0.04905554f, -0.15095404f, 
    0.07968140f, 0.06421539f, -0.00107196f, -0.17518294f, -0.01439209f, -0.03094303f, 0.04946030f, -0.08734895f, 
    -0.08356815f, 0.03350759f, -0.04187769f, -0.01271759f, 0.01370876f, 0.06912164f, -0.08152778f, 0.16862056f, 
    -0.02594467f, -0.01377729f, -0.11042821f, -0.04494027f, -0.20277613f, 0.09175961f, -0.12278602f, 0.01523404f, 
    -0.08036076f, 0.03808634f, 0.07328922f, -0.10851597f, -0.15976386f, -0.00186560f, 0.00899831f, 0.03956475f, 
    0.39317834f, -0.19072075f, -0.09676154f, -0.03411520f, -0.09371325f, 0.05168068f, -0.07470798f, -0.07994588f, 
    0.09870563f, 0.08975782f, 0.10805300f, 0.00689402f, -0.10314987f, 0.04796665f, 0.24859570f, 0.01183248f, 
    -0.01310777f, -0.01789935f, -0.06582190f, -0.08761538f, -0.18927452f, -0.06678163f, 0.08336424f, 0.19582215f, 
    0.54357189f, -0.11391320f, 0.07330551f, 0.26266232f, -0.06680551f, -0.02655179f, -0.09140461f, -0.04368705f, 
    0.08455935f, -0.03649202f, 0.14380309f, -0.04811782f, -0.09252582f, 0.38360071f, -0.02407678f, -0.05251400f, 
    0.01313732f, 0.01778402f, 0.08130553f, -0.03676898f, -0.10658339f, -0.01857810f, 0.00582433f, -0.09419547f, 
    0.03843144f, -0.20886579f, -0.03977422f, 0.00608569f, -0.05453124f, 0.02961736f, -0.07605114f, -0.03408647f, 
    -0.01156402f, 0.20487937f, 0.04671972f, -0.07096918f, 0.02903427f, -0.06531674f, 0.05878300f, -0.01158116f, 
    -0.01649254f, -0.05992864f, 0.01431414f, -0.06452203f, -0.08271816f, -0.11655315f, -0.07471660f, 0.17559578f, 
    0.07787619f, 0.24159902f, 0.12314165f, -0.24192804f, 0.10017031f, 0.04346285f, -0.02928872f, -0.04231837f, 
    -0.12134301f, -0.03326087f, 0.00814484f, 0.06534287f, 0.04315365f, -0.11648601f, -0.11068721f, -0.12178546f, 
    0.09262327f, -0.05714424f, -0.08505058f, 0.11118532f, 0.06193343f, 0.03931736f, 0.02503472f, 0.12205548f, 
    -0.03353551f, 0.16213728f, -0.14545426f, 0.02621760f, -0.01428231f, 0.03149475f, -0.07032585f, -0.07197908f, 
    0.08544044f, 0.03045204f, -0.10320449f, -0.03239138f, 0.13953468f, -0.25768095f, -0.24487868f, -0.13657348f, 
    -0.04635451f, -0.04210116f, -0.04943493f, 0.01345544f, 0.13189876f, -0.03668232f, 0.01436568f, 0.08981650f, 
    -0.44347578f, 0.06916219f, -0.08306982f, 0.09542498f, -0.00606454f, 0.11142783f, 0.00720883f, 0.06685985f, 
    0.04526720f, -0.07135455f, 0.14425801f, 0.11338124f, -0.35617638f, 0.30290070f, 0.21645966f, -0.08302550f, 
    -0.07831986f, 0.03568043f, -0.04341212f, -0.05572357f, 0.14980432f, 0.04878320f, 0.00550112f, -0.07028589f, 
    -0.11697795f, -0.07260367f, 0.08283588f, -0.31243807f, 0.11691179f, 0.05339900f, -0.00745398f, -0.05273491f, 
    -0.05048807f, -0.08341371f, 0.00413544f, 0.01148866f, -0.00018192f, -0.09607308f, 0.03087359f, 0.23594978f, 
    -0.02892284f, 0.06997202f, 0.02954367f, 0.02604177f, 0.00181750f, -0.02672067f, -0.06312583f, -0.06817889f, 
    0.16916722f, 0.03728783f, 0.16645455f, -0.13253912f, 0.05986737f, -0.03749889f, 0.04700329f, 0.08135042f, 
    -0.03430445f, -0.04284924f, -0.02294274f, -0.05902694f, -0.01617400f, -0.05157005f, 0.19834553f, -0.07283190f, 
    -0.08605544f, -0.08238579f, 0.07061904f, 0.04730174f, -0.02230425f, 0.09617650f, 0.03364395f, 0.10566482f, 
    0.08465241f, -0.05434782f, -0.09581395f, 0.00434727f, -0.04954193f, -0.01355136f, 0.01422311f, 0.00161858f, 
    0.11363725f, 0.01560536f, -0.08207031f, -0.02584672f, 0.02649434f, -0.17049225f, 0.00144732f, 0.00312522f, 
    -0.03411834f, -0.04686897f, -0.02638875f, 0.01155342f, 0.10234823f, 0.00967240f, 0.08734385f, 0.02837941f, 
    0.03780200f, 0.06208732f, -0.16511825f, -0.01928332f, 0.02276952f, -0.07364046f, 0.01572531f, 0.01940657f, 
    -0.00785040f, -0.07796870f, -0.01416047f, 0.06911377f, -0.32819092f, -0.16352817f, 0.25605246f, 0.15995045f, 
    0.00695109f, 0.15058789f, 0.12267736f, -0.01924673f, 0.12859747f, 0.03678307f, -0.03396891f, -0.02505108f, 
    -0.02382902f, -0.06842284f, 0.12082664f, -0.18077113f, 0.02512226f, 0.04524539f, 0.15936294f, 0.13416487f, 
    0.04238918f, 0.01773592f, -0.04441918f, -0.01324796f, 0.18039808f, -0.07454950f, -0.05120636f, -0.01506389f, 
    0.11967087f, 0.02250200f, 0.18489806f, 0.03253276f, 0.01418249f, 0.11780982f, 0.03612624f, 0.04688363f, 
    0.03839274f, -0.24070959f, -0.07752339f, 0.31264815f, 0.04622765f, -0.01144610f, 0.01465152f, 0.04165525f, 
    0.18259399f, 0.12311082f, 0.02229782f, 0.11526083f, 0.23036295f, 0.16983552f, -0.01712544f, 0.02915774f, 
    0.01084023f, 0.15329079f, 0.13711727f, 0.07270426f, -0.01165628f, -0.09163644f, -0.04362318f, 0.06141663f, 
    0.02310920f, -0.12560734f, -0.03018744f, -0.11173217f, 0.00544156f, -0.02407615f, 0.05568469f, 0.19561841f, 
    0.08927016f, 0.09290655f, 0.03788348f, 0.05850260f, -0.18704259f, -0.05533567f, 0.05701086f, -0.02620630f, 
    0.00347943f, -0.04356533f, 0.00690855f, -0.06060629f, -0.00725332f, 0.04429035f, 0.05619379f, -0.03726633f, 
    0.02766839f, 0.01658141f, -0.05838003f, -0.04058293f, -0.07313284f, 0.06472673f, 0.01139773f, 0.04531337f, 
    0.01640715f, -0.07463235f, 0.04930304f, -0.07603674f, 0.05419634f, 0.00065561f, -0.04577999f, 0.05080521f, 
    0.05820063f, -0.05324492f, 0.03230513f, -0.04472530f, 0.00860700f, -0.02656315f, -0.06461851f, 0.01612473f, 
    0.06297839f, -0.06748464f, 0.05853497f, 0.06438243f, -0.07277977f, 0.01826999f, -0.04639473f, 0.02862621f, 
    0.04580067f, 0.02511902f, 0.04971213f, -0.03598526f, -0.02526057f, 0.00900327f, -0.03403063f, -0.01850413f, 
    0.02084729f, 0.04994589f, 0.04368624f, -0.07635556f, -0.03389024f, -0.00413057f, 0.03235728f, 0.02039018f, 
    0.00127726f, -0.06919827f, -0.07237957f, -0.06276588f, -0.02170456f, 0.06136892f, -0.00318384f, 0.02457472f, 
    -0.03968588f, -0.05638411f, -0.05210782f, -0.06633352f, -0.00886695f, -0.02794527f, 0.02013724f, -0.00811720f, 
    -0.05367478f, -0.01293878f, -0.04029574f, 0.03417009f, -0.00936258f, -0.02203162f, -0.05284124f, -0.06269908f, 
    -0.00476910f, -0.03731545f, 0.04090165f, -0.06221906f, -0.04299969f, -0.06618625f, -0.00842100f, -0.05423261f, 
    -0.00625355f, -0.05018000f, -0.05371325f, -0.06948478f, -0.01351463f, -0.01198995f, -0.06219025f, -0.06152833f, 
    -0.06774076f, 0.05044420f, 0.03811625f, 0.04634848f, -0.03226926f, -0.00002780f, -0.02412299f, 0.02608366f, 
    -0.02155582f, 0.04938122f, -0.00766096f, 0.01435492f, 0.05221561f, -0.05986089f, 0.04545334f, -0.02094163f, 
    -0.02676100f, 0.06977047f, -0.00228920f, 0.05116788f, -0.04173785f, -0.03284188f, -0.05438258f, -0.02194268f, 
    0.03287065f, -0.07066531f, -0.03326064f, -0.03319392f, 0.00388416f, -0.03800219f, 0.00112407f, 0.05323791f, 
    -0.00183156f, -0.07460942f, -0.07669973f, 0.02505550f, -0.02272623f, -0.04736800f, 0.02569639f, 0.04568745f, 
    0.06651533f, -0.05647561f, -0.03481582f, -0.02215708f, 0.05571780f, 0.06325652f, -0.00734311f, -0.06269545f, 
    0.00509196f, -0.04787087f, 0.02038647f, -0.05483755f, -0.02759710f, 0.05479763f, -0.07281544f, -0.01507001f, 
    0.01300387f, -0.05022531f, 0.04333738f, -0.04377202f, 0.03925814f, 0.03616678f, -0.06718288f, -0.02795379f, 
    0.01509121f, -0.05824111f, -0.00417979f, -0.06316954f, 0.02116598f, -0.01979592f, -0.01985139f, -0.05558971f, 
    -0.00122121f, -0.07066900f, -0.05147066f, -0.00420593f, 0.06072612f, 0.05717362f, -0.02816873f, -0.01453699f, 
    0.04648415f, 0.04972835f, -0.01542202f, -0.02960696f, -0.03286229f, 0.04989254f, 0.03855550f, -0.03844948f, 
    0.05488982f, -0.07495525f, 0.01932864f, -0.04587089f, -0.03863176f, -0.02014359f, -0.01500271f, -0.05317118f, 
    -0.05882318f, -0.04656398f, 0.04779162f, 0.00060594f, -0.06790400f, -0.01228824f, -0.03468940f, -0.06332517f, 
    0.20411557f, -0.08634295f, 0.06861522f, 0.07602406f, 0.02988989f, -0.02670953f, 0.01437799f, -0.14260387f, 
    0.03745604f, 0.00590771f, -0.03239501f, -0.09500996f, 0.38334170f, -0.28255334f, -0.02062743f, 0.13537380f, 
    -0.00523495f, -0.06551549f, -0.13430266f, -0.03655025f, 0.05519633f, -0.11645973f, 0.13590850f, 0.04532553f, 
    0.29658976f, 0.00833875f, -0.13702992f, 0.18010196f, -0.03296272f, -0.13178937f, -0.15448794f, -0.05868453f, 
    -0.11044496f, 0.04036190f, -0.09995564f, -0.09269479f, -0.17489612f, 0.06862836f, -0.11387308f, -0.13586277f, 
    0.00723327f, -0.07233033f, 0.04558982f, 0.02377701f, -0.15066572f, 0.03130879f, -0.01809507f, -0.03666231f, 
    -0.01353141f, -0.01890266f, -0.04497179f, 0.07593782f, -0.19495471f, -0.08325485f, -0.15730774f, -0.09129557f, 
    -0.04406464f, -0.03296419f, 0.11139261f, 0.02051184f, -0.13251907f, 0.08984892f, 0.13166122f, 0.21252079f, 
    -0.05150501f, 0.09983629f, 0.11568549f, 0.02449179f, 0.13799031f, 0.12449032f, -0.10907242f, 0.07606865f, 
    -0.01740599f, 0.03260864f, 0.11991461f, 0.07935858f, 0.11919771f, 0.14580825f, -0.20951363f, -0.12713788f, 
    -0.03304419f, -0.13198785f, 0.03362266f, 0.02989244f, 0.23990056f, 0.03854005f, -0.13333735f, -0.00156427f, 
    -0.04529307f, -0.01738139f, -0.06232759f, -0.01015750f, -0.12164182f, -0.03668100f, 0.07601809f, 0.00264517f, 
    0.08493267f, 0.11522431f, 0.17566237f, 0.21464378f, -0.01559519f, 0.09422024f, -0.10988544f, -0.01364520f, 
    -0.16642703f, -0.01825806f, 0.08309639f, 0.06942410f, 0.39823917f, 0.19567442f, -0.27920502f, -0.28067148f, 
    -0.03939617f, -0.12211837f, 0.02098139f, 0.04178140f, -0.06016561f, 0.00921476f, 0.02514135f, 0.05073076f, 
    0.24664764f, -0.04609878f, 0.02361046f, -0.11751329f, 0.00634809f, -0.04118221f, -0.09878513f, 0.14215879f, 
    -0.01262922f, 0.08179543f, 0.00791662f, -0.03963540f, -0.14540358f, 0.24877413f, 0.04262247f, -0.00726876f, 
    0.06365346f, -0.09875610f, -0.08224106f, 0.08499747f, -0.03291792f, -0.04913099f, -0.18727991f, 0.00225248f, 
    0.20213167f, -0.02140466f, -0.05087231f, -0.00485251f, 0.02842622f, 0.00911458f, 0.03618130f, 0.01593138f, 
    -0.06044776f, -0.05749572f, -0.05619740f, -0.01681353f, 0.25873980f, -0.00374283f, -0.00402305f, 0.04827153f, 
    0.07081218f, -0.01896369f, -0.12152991f, 0.03522943f, -0.06270103f, -0.00068510f, 0.16317551f, -0.06156722f, 
    0.03870596f, 0.17371565f, 0.10120796f, 0.18816072f, -0.01884431f, 0.15600888f, 0.08288029f, -0.02315879f, 
    -0.14309689f, -0.02166001f, 0.00735836f, -0.02589997f, 0.02743463f, -0.05470933f, 0.05285972f, -0.03624334f, 
    0.20529397f, 0.05165330f, 0.02511027f, 0.08847079f, -0.00027843f, 0.04247483f, -0.03412216f, 0.16410553f, 
    0.03608593f, -0.00987471f, 0.02564958f, 0.09690082f, -0.00644972f, -0.02477643f, 0.14352642f, 0.03025961f, 
    0.04325454f, 0.03613664f, -0.08404852f, 0.02073587f, -0.13045304f, 0.06392698f, -0.19846492f, 0.01441886f, 
    -0.05215656f, 0.10489835f, 0.05298025f, -0.05348531f, 0.02909038f, 0.01927575f, 0.05530704f, 0.03825467f, 
    -0.14183411f, -0.12362275f, 0.17323053f, -0.04557285f, 0.18933323f, -0.07825596f, -0.04099732f, -0.16480187f, 
    0.00159600f, 0.04616334f, 0.09284848f, 0.11910614f, 0.00705628f, -0.16737382f, 0.12444645f, 0.24975257f, 
    0.13691047f, -0.02695025f, -0.04346975f, -0.01480561f, 0.02382771f, 0.02844701f, 0.19821987f, 0.25418758f, 
    0.07625772f, -0.16227584f, -0.04701754f, -0.01002717f, 0.02462149f, -0.00314658f, 0.03198010f, -0.05709723f, 
    -0.08985430f, -0.09185376f, -0.21496414f, -0.14550619f, -0.05725465f, 0.04758372f, -0.15557763f, 0.12954591f, 
    0.02212125f, 0.04525572f, -0.09078057f, -0.22387336f, -0.04791972f, 0.01895547f, 0.08814756f, -0.08956283f, 
    0.12008358f, -0.00861032f, -0.03955596f, 0.17508397f, -0.20936523f, -0.00033268f, 0.24768707f, 0.03962655f, 
    0.00922123f, -0.05908613f, 0.10504457f, -0.01083829f, -0.04872533f, -0.07072028f, 0.28312278f, 0.34033108f, 
    0.03684095f, 0.10203219f, 0.11130739f, -0.09491373f, 0.01434795f, 0.05107228f, 0.10260759f, 0.14521980f, 
    0.03201438f, -0.02962456f, 0.03104160f, -0.15204076f, -0.06361108f, 0.00862449f, 0.06282680f, -0.01824323f, 
    -0.10427354f, -0.00442227f, -0.09965309f, -0.02807519f, -0.25354010f, -0.03379216f, 0.02337770f, 0.16930155f, 
    0.02832415f, 0.13096938f, 0.07236359f, -0.05868365f, 0.08168876f, -0.08429802f, 0.14604144f, -0.09058726f, 
    0.11944216f, 0.01983518f, -0.21003716f, -0.09402367f, 0.01784059f, -0.14216627f, 0.05051395f, -0.11574358f, 
    0.02772211f, -0.05177152f, 0.16847943f, 0.01381435f, 0.38416857f, -0.19921090f, -0.05782572f, -0.00734890f, 
    0.07253177f, -0.11616097f, 0.02819742f, 0.04123149f, 0.03413928f, -0.16099150f, -0.04423380f, -0.03228185f, 
    -0.01178711f, 0.06004599f, 0.03825518f, 0.23595931f, 0.21338335f, -0.03815315f, 0.00566108f, 0.05915514f, 
    -0.03581055f, -0.07297067f, 0.02416208f, 0.14148207f, 0.13292061f, 0.19362499f, 0.10196123f, -0.07410122f, 
    0.00739189f, 0.00950677f, 0.01105090f, -0.05511431f, 0.00822563f, 0.01526028f, -0.01143672f, -0.05586201f, 
    -0.02764626f, -0.01426378f, -0.05329090f, 0.14161769f, 0.04139526f, -0.02182861f, -0.06232951f, -0.06504226f, 
    -0.10034537f, 0.13709393f, 0.08617771f, 0.08810522f, 0.06726279f, 0.05317727f, 0.03481235f, 0.06282544f, 
    -0.24686283f, -0.07248708f, -0.16335312f, -0.21349581f, -0.04394696f, -0.25763837f, 0.03460502f, -0.01048809f, 
    -0.02746240f, -0.00663988f, 0.03851046f, -0.01341232f, 0.03186997f, 0.01674332f, 0.02804971f, 0.02865264f, 
    0.05893195f, -0.00014252f, 0.03969690f, -0.02899895f, -0.01704214f, -0.00077741f, 0.04194431f, 0.05251923f, 
    -0.06637297f, 0.01644044f, -0.01960752f, 0.06041762f, 0.03559292f, -0.05923370f, 0.06017533f, -0.05727298f, 
    -0.02192090f, -0.04995774f, -0.00571006f, 0.03234939f, -0.00685808f, -0.05270899f, -0.01305755f, 0.02726382f, 
    -0.01875106f, 0.00601742f, 0.05076523f, -0.05862154f, -0.06233205f, 0.00891619f, -0.07024043f, 0.05072743f, 
    -0.02302571f, -0.05608662f, -0.03025358f, -0.07520063f, 0.02699069f, -0.03567698f, -0.08229288f, -0.00958555f, 
    0.04650095f, -0.01250196f, 0.03468656f, -0.03391796f, 0.06610242f, -0.05961588f, -0.04559910f, -0.02395035f, 
    -0.04803946f, -0.00311687f, -0.03406912f, -0.06119181f, -0.00289806f, -0.04422361f, -0.04795430f, -0.03716620f, 
    -0.01927609f, -0.01145906f, -0.01472135f, 0.04395096f, 0.06491042f, -0.06395693f, 0.07197165f, 0.06400209f, 
    -0.02080320f, 0.01992599f, -0.05445490f, -0.02341892f, -0.03680651f, 0.02732637f, 0.00158899f, 0.00627113f, 
    -0.00390494f, 0.03539344f, -0.04353628f, 0.04718012f, -0.02415026f, -0.06462201f, -0.04207152f, 0.05011437f, 
    -0.03823210f, 0.03176935f, 0.04393303f, -0.05438480f, -0.01432204f, -0.01008940f, -0.06130857f, 0.01089728f, 
    0.03129152f, 0.06187268f, 0.07583199f, -0.03850893f, -0.07077405f, -0.01223242f, -0.06530709f, 0.02356967f, 
    -0.08340844f, -0.01024576f, -0.03072506f, 0.02373993f, 0.00771974f, 0.06103971f, -0.02896859f, -0.02135140f, 
    -0.07064019f, -0.03473193f, -0.04899624f, 0.00927973f, -0.05979989f, -0.00322552f, -0.02859552f, 0.03488797f, 
    0.05115111f, -0.04449706f, -0.02418915f, 0.01130458f, -0.06967272f, -0.07490269f, 0.03973886f, 0.06129642f, 
    0.05991364f, 0.03667058f, 0.02826102f, -0.04544062f, 0.01125911f, -0.05316329f, -0.00071775f, 0.00993281f, 
    -0.03194740f, -0.01692020f, -0.03408645f, -0.00635326f, -0.01439935f, 0.04240381f, -0.07311419f, 0.00803124f, 
    0.05898742f, 0.05921537f, -0.04672542f, -0.05962593f, -0.07790158f, 0.05242651f, -0.03726036f, 0.03261904f, 
    -0.02550625f, 0.02140973f, 0.06163701f, -0.01089313f, -0.02292471f, -0.02026916f, -0.00188790f, -0.00731679f, 
    -0.04645137f, 0.02400514f, -0.03000943f, -0.03669946f, -0.06698897f, 0.06052198f, -0.02034251f, 0.03293205f, 
    0.05706757f, 0.01260910f, -0.00345002f, -0.04469478f, 0.03765918f, -0.02696605f, 0.03375002f, -0.02850796f, 
    -0.00029859f, -0.07555533f, -0.06303904f, 0.01188043f, -0.02211339f, -0.05035511f, -0.07146353f, 0.00688878f, 
    -0.01420986f, 0.01089968f, -0.01565286f, -0.06075232f, 0.01239103f, 0.06566280f, -0.04482017f, -0.00999864f, 
    -0.15084028f, 0.04833509f, 0.12157652f, -0.00156216f, 0.06212566f, 0.13245952f, 0.03557960f, 0.06898463f, 
    -0.07676266f, 0.03082169f, 0.10099044f, 0.13140976f, -0.48169863f, 0.20670836f, 0.16785830f, 0.06817046f, 
    0.09769899f, 0.09387285f, -0.04694268f, 0.04634180f, -0.02651650f, 0.04023205f, -0.02331165f, 0.07338704f, 
    0.06628408f, 0.12510115f, 0.12649280f, -0.21851248f, -0.01507867f, 0.07402438f, 0.05972276f, 0.14934030f, 
    0.12945391f, -0.01304314f, 0.04477119f, -0.00979621f, 0.19138908f, 0.12866724f, 0.07015021f, -0.03695790f, 
    -0.11002064f, -0.11661041f, 0.03158950f, 0.01055050f, 0.00482919f, 0.03827885f, -0.03862645f, -0.03526258f, 
    0.09504931f, -0.00205876f, 0.21587546f, -0.13875075f, 0.07746506f, 0.04773536f, -0.01248636f, 0.08543059f, 
    0.15045552f, -0.01509336f, 0.13361847f, 0.14019319f, -0.05322026f, -0.01796125f, 0.11868231f, -0.07347086f, 
    -0.13768645f, -0.03503727f, 0.14625530f, 0.03903308f, 0.02845697f, 0.07982913f, -0.00291349f, 0.08526846f, 
    0.21437183f, -0.09399145f, -0.15948094f, -0.13303410f, 0.05781149f, -0.09955615f, -0.02918606f, 0.03944649f, 
    -0.03675963f, 0.09581111f, -0.10025207f, -0.06198171f, -0.27731273f, -0.03286793f, -0.06811574f, -0.13738492f, 
    -0.04915950f, -0.10898431f, -0.07521307f, 0.17275356f, 0.03172465f, -0.03419027f, 0.13719833f, 0.02231108f, 
    0.23062669f, 0.11082982f, -0.08906235f, -0.04220267f, 0.02108402f, 0.00011459f, 0.03676007f, 0.00795770f, 
    0.07442638f, 0.04470407f, -0.02641674f, 0.01420015f, -0.15996002f, -0.08935142f, 0.09350325f, 0.16646169f, 
    0.13584688f, 0.07388978f, 0.03201489f, -0.06366635f, 0.09432724f, 0.03331606f, -0.07893219f, 0.02464282f, 
    -0.04733184f, -0.12518708f, 0.16546817f, 0.04335038f, -0.08544461f, 0.11497342f, 0.04623117f, 0.05946909f, 
    -0.10923642f, 0.04540838f, -0.15028653f, 0.03752690f, -0.11916714f, -0.02002829f, -0.07696957f, 0.13102858f, 
    0.12069304f, 0.05221316f, 0.11202287f, -0.01185002f, 0.12874974f, 0.04223237f, 0.05328543f, 0.10392544f, 
    -0.22814296f, -0.15983358f, 0.08401374f, 0.05271107f, -0.10126095f, 0.04607964f, -0.12229201f, 0.07322145f, 
    0.08571161f, -0.01397141f, 0.06338841f, 0.06058928f, -0.05900663f, 0.03478206f, -0.14670946f, -0.04005130f, 
    0.01733025f, 0.13261905f, 0.03671424f, 0.16490693f, -0.02484216f, -0.02761225f, -0.07080211f, 0.00401083f, 
    0.00536442f, -0.11379815f, -0.11677098f, -0.27720326f, -0.02395741f, 0.01657203f, -0.04944716f, -0.01630525f, 
    0.01815413f, -0.05969432f, -0.06775479f, 0.06400640f, 0.01935671f, -0.06854142f, -0.07695182f, -0.18775770f, 
    0.02037723f, 0.11778604f, 0.05895568f, 0.07546924f, 0.04394986f, 0.05257124f, -0.09075773f, 0.13957198f, 
    0.02742166f, -0.00699387f, 0.05314272f, -0.01719857f, 0.02158451f, -0.02208542f, 0.00440792f, -0.02352142f, 
    -0.02377138f, 0.04719169f, -0.00974478f, 0.04611516f, 0.00071841f, -0.03833778f, -0.00904446f, 0.06553680f, 
    0.05989778f, -0.04501560f, -0.01980763f, -0.05394024f, 0.05106049f, 0.05029742f, -0.07990465f, -0.06787264f, 
    -0.03048373f, -0.02675533f, -0.02821355f, -0.07117432f, -0.05894516f, 0.01725985f, -0.00484328f, -0.01870734f, 
    -0.06718858f, 0.02314076f, -0.07096916f, 0.00816502f, 0.00836640f, 0.03144864f, -0.07008932f, -0.06202492f, 
    0.05315186f, -0.02629322f, -0.07780212f, -0.07315981f, 0.04339262f, 0.04540859f, 0.00043012f, -0.04310193f, 
    -0.03477419f, -0.01995201f, 0.02167589f, 0.04244024f, 0.05366372f, 0.02819785f, -0.04055062f, -0.06350054f, 
    0.03614647f, -0.04619829f, -0.00884190f, -0.00865110f, 0.04109673f, 0.00742623f, -0.00987510f, -0.01196773f, 
    0.02476623f, 0.03699069f, -0.06807431f, 0.03064495f, 0.02073111f, 0.01627195f, -0.03121735f, 0.00695812f, 
    0.03076056f, 0.00453452f, 0.04350507f, 0.03894222f, 0.00757514f, -0.00859575f, -0.05226892f, -0.00247726f, 
    -0.01389945f, -0.04507164f, -0.01693597f, -0.00491095f, -0.04923618f, -0.05822410f, -0.01451979f, 0.00777131f, 
    0.00829546f, 0.01002477f, 0.05991728f, 0.02002250f, 0.04956960f, 0.05798198f, 0.02145918f, 0.06018044f, 
    -0.07697625f, 0.01921841f, 0.01709819f, 0.01662606f, -0.07610454f, 0.04791520f, -0.02595546f, 0.02048448f, 
    0.01182466f, -0.04536558f, 0.00713937f, -0.07738070f, -0.05476679f, 0.00660969f, -0.01196720f, 0.04587443f, 
    0.06144534f, -0.02027907f, 0.05713839f, -0.06132620f, 0.05905071f, 0.02696748f, -0.05687608f, -0.02202443f, 
    0.01167518f, 0.02658487f, 0.06383023f, -0.00340175f, -0.02815763f, -0.06183050f, 0.01391112f, -0.07330003f, 
    -0.02700037f, 0.02857423f, -0.06942757f, -0.03305444f, -0.02874104f, -0.03154901f, -0.01715918f, -0.06114755f, 
    -0.04177509f, -0.03688492f, 0.00839951f, -0.03196662f, -0.06024428f, 0.02769342f, -0.05541535f, -0.04467276f, 
    -0.03563539f, -0.00058351f, 0.05912716f, 0.04547806f, -0.03301503f, -0.01148248f, 0.06010085f, 0.00912649f, 
    -0.04520625f, 0.02576069f, -0.02280378f, 0.06107625f, -0.02872545f, -0.04511746f, -0.05855722f, -0.06204108f, 
    -0.04214890f, -0.01325130f, -0.00195543f, -0.06684467f, 0.03746086f, -0.05778251f, 0.01214871f, -0.06438594f, 
    -0.06206968f, -0.03346956f, -0.00023164f, -0.06128669f, 0.02308618f, -0.01330346f, -0.06360171f, -0.01552183f, 
    -0.05345412f, 0.02700548f, -0.04858531f, -0.07086477f, -0.02556905f, 0.02666898f, 0.03887223f, -0.03188153f, 
    -0.04828063f, 0.06205809f, -0.08222197f, -0.03448270f, 0.03972021f, -0.05162502f, -0.06426519f, 0.05277826f, 
    0.16835013f, -0.05025264f, 0.02021500f, -0.02495245f, 0.17375207f, -0.12944435f, 0.04722247f, 0.04614200f, 
    -0.04146260f, 0.08148615f, -0.11660852f, 0.22169425f, 0.02250234f, 0.03021778f, 0.01994499f, 0.21533765f, 
    -0.00892713f, -0.01744706f, 0.11414307f, 0.05038571f, -0.01054771f, 0.14982529f, 0.04018365f, 0.16062351f, 
    0.14132762f, -0.01583624f, 0.03969470f, 0.21859783f, -0.00035673f, 0.06003238f, 0.14286138f, 0.01330495f, 
    0.10553942f, 0.13871913f, 0.12319136f, 0.18662271f, 0.13800007f, -0.09553166f, 0.09563446f, -0.00908942f, 
    0.10317014f, -0.07424969f, 0.04701511f, 0.08442685f, 0.07139523f, -0.02617819f, 0.14809731f, 0.22622247f, 
    0.24498484f, -0.16368333f, 0.11694475f, 0.09048133f, 0.12753479f, 0.08028251f, 0.06960971f, 0.12298196f, 
    -0.03825320f, 0.11746074f, -0.11173003f, 0.12249913f, -0.17013514f, -0.12879598f, -0.09208955f, 0.03230195f, 
    -0.07300530f, 0.10162401f, -0.16793010f, -0.01119799f, 0.08081825f, -0.01619184f, 0.08411971f, -0.00738009f, 
    -0.12991557f, -0.07888086f, -0.02095977f, -0.04611147f, 0.01066290f, 0.01837400f, 0.05370122f, 0.01556656f, 
    -0.08746966f, 0.11201925f, 0.16918392f, -0.11458739f, -0.14730176f, -0.14190711f, -0.03381330f, 0.04124147f, 
    0.07313821f, 0.08556214f, 0.06431925f, -0.04579249f, 0.14334325f, -0.02814627f, -0.05501169f, 0.10623393f, 
    -0.11627198f, -0.09879470f, -0.03398479f, -0.02761844f, -0.06460382f, 0.05674627f, 0.09809410f, -0.09267775f, 
    0.11549810f, 0.11753176f, 0.08257540f, 0.06527224f, 0.12466164f, 0.05891515f, 0.10484260f, 0.12060519f, 
    0.27366650f, 0.04595192f, 0.01089623f, 0.04215298f, 0.01626618f, -0.03460348f, -0.00063551f, 0.07608706f, 
    0.07554562f, -0.11583809f, -0.05135342f, 0.30205515f, 0.04277888f, 0.10650852f, 0.01600192f, 0.02224824f, 
    0.06918760f, 0.04391271f, 0.01808005f, 0.15339476f, -0.07783926f, -0.13346466f, -0.03237024f, -0.03225892f, 
    0.16005464f, 0.00873323f, 0.09561751f, 0.00238878f, 0.09330764f, -0.00995286f, 0.09159986f, -0.01129449f, 
    -0.26125592f, 0.01503306f, 0.13087413f, -0.27236444f, 0.08442178f, -0.11102987f, -0.04162045f, 0.10327285f, 
    0.03763669f, -0.01354063f, 0.03166357f, 0.00498267f, -0.33980647f, -0.09323159f, 0.04900213f, -0.08918011f, 
    -0.18427584f, 0.05582853f, -0.06044694f, -0.09613802f, -0.00763479f, 0.07751021f, 0.03623158f, 0.01330112f, 
    -0.09697180f, -0.08750790f, -0.04989335f, -0.16990943f, 0.01644741f, 0.17836682f, -0.11246561f, -0.10212341f, 
    -0.06431425f, -0.05413621f, -0.06847148f, -0.05758438f, 0.04764294f, -0.10430408f, -0.23318993f, -0.16178069f, 
    -0.13131358f, 0.04080967f, -0.09367940f, -0.08397104f, 0.08854204f, -0.13359366f, -0.10008592f, 0.00395628f, 
    -0.23910974f, -0.11147899f, 0.02017798f, 0.22637795f, -0.06587110f, 0.01344143f, -0.01041364f, -0.00700233f, 
    -0.00087187f, 0.08260844f, -0.00308413f, 0.02383614f, -0.50536287f, 0.06606546f, 0.00945806f, -0.04596202f, 
    0.11729752f, 0.10880344f, 0.00658248f, 0.03850062f, -0.04620752f, 0.03869186f, -0.07877302f, -0.02268768f, 
    0.16877794f, -0.32357475f, 0.06232941f, -0.23846649f, 0.14607041f, -0.01667249f, 0.04946346f, -0.07092193f, 
    0.04732188f, 0.05569053f, -0.05746030f, -0.11560228f, 0.10806520f, -0.06419664f, 0.03988158f, 0.28165832f, 
    -0.00710625f, 0.09417386f, 0.11851074f, -0.02114884f, -0.04110977f, -0.12814608f, 0.06126106f, -0.00740247f, 
    0.00230068f, 0.20293339f, 0.02573822f, -0.09489662f, -0.04826166f, 0.04564174f, 0.04450000f, -0.05156559f, 
    0.10519844f, -0.03962812f, 0.05363770f, 0.03637241f, 0.01597697f, 0.12584196f, -0.03602254f, 0.03672371f, 
    -0.05402713f, -0.03061477f, 0.08541688f, -0.10653555f, 0.08559979f, 0.08238821f, 0.00248429f, 0.06257223f, 
    0.43271750f, -0.09717660f, -0.08828803f, 0.00814670f, -0.20277268f, -0.13379443f, -0.03742925f, -0.06447166f, 
    0.03625445f, 0.10762139f, 0.00610589f, 0.19115342f, -0.27720892f, -0.28228036f, 0.15401720f, -0.18273838f, 
    -0.02476667f, 0.11072900f, 0.03401419f, 0.07113982f, -0.03425743f, -0.06663539f, -0.00102048f, 0.00312738f, 
    0.52495104f, 0.05716631f, -0.02987455f, 0.12506077f, -0.11380339f, -0.06442398f, 0.04046074f, 0.05602009f, 
    0.03632880f, -0.11238468f, -0.02256861f, 0.09878100f, -0.28539336f, -0.07423352f, 0.00618471f, 0.29762581f, 
    0.17074251f, 0.30042925f, 0.18607187f, 0.05864376f, 0.04028038f, 0.12374955f, 0.08083529f, 0.03816316f, 
    0.00314816f, -0.09528539f, -0.02252835f, 0.16154261f, -0.04395033f, 0.07821598f, 0.08949134f, 0.09841237f, 
    -0.07076608f, 0.13088599f, 0.02589539f, -0.01350924f, 0.07033136f, -0.21177316f, -0.17585193f, 0.11507984f, 
    -0.13848446f, -0.11232372f, 0.06036018f, -0.04109946f, 0.09375800f, 0.02553641f, -0.05315821f, 0.07899444f, 
    -0.20195800f, -0.06778371f, 0.00771829f, 0.19352867f, 0.15697604f, 0.02874279f, -0.02170667f, -0.01533002f, 
    -0.07312385f, -0.11348450f, -0.12516637f, -0.02859971f, 0.04523565f, 0.19285654f, 0.08857800f, 0.03752584f, 
    -0.00818127f, -0.03298307f, 0.06144722f, -0.05993457f, -0.06028951f, 0.06342355f, 0.01735706f, 0.09857516f, 
    0.08418830f, -0.10471898f, 0.02601068f, -0.22878733f, -0.16314849f, -0.03692679f, -0.04456404f, -0.01043404f, 
    0.10556100f, 0.04521634f, 0.03059703f, 0.10464191f, 0.05899844f, -0.20645744f, -0.03247295f, -0.11774691f, 
    -0.17081028f, 0.03231378f, -0.05998241f, 0.09931821f, 0.07591418f, 0.10581706f, -0.00040001f, 0.00918208f, 
    -0.21975470f, 0.02332007f, -0.08358401f, 0.04726465f, 0.15854409f, -0.12212699f, 0.02304712f, 0.03268782f, 
    -0.01977247f, -0.08465938f, 0.01434111f, 0.17095087f, 0.16839631f, 0.09630641f, 0.15135793f, 0.05704109f, 
    -0.16399357f, -0.05977707f, 0.03515357f, 0.00321999f, 0.11663532f, 0.03835010f, 0.04472411f, -0.01911611f, 
    0.16155104f, -0.11934934f, 0.11433250f, 0.20603251f, 0.06545231f, -0.02829942f, -0.03044121f, -0.04393385f, 
    -0.06286161f, 0.05355897f, 0.18623763f, 0.11199579f, -0.07508791f, -0.11957849f, -0.06356245f, 0.13300410f, 
    -0.03693645f, 0.06304478f, -0.06554598f, -0.06780147f, 0.14591095f, 0.08291210f, 0.03074374f, 0.25009352f, 
    0.13622822f, -0.18485364f, 0.12441018f, 0.17621101f, 0.00334740f, -0.03407658f, 0.22673212f, -0.00230062f, 
    -0.00412148f, -0.04875537f, -0.32666567f, -0.07663532f, 0.02392964f, -0.06534156f, -0.12059877f, -0.09851082f, 
    0.17150092f, 0.14701417f, -0.11703167f, -0.09522031f, 0.02387132f, -0.07380839f, 0.08155071f, -0.01042316f, 
    -0.27318451f, 0.22101714f, -0.03155183f, -0.04631672f, 0.07270809f, -0.01747916f, 0.01746374f, 0.02140827f, 
    -0.03237751f, -0.07459501f, -0.02247723f, -0.03886062f, 0.30479491f, -0.20775421f, 0.00612914f, 0.27738500f, 
    -0.12377118f, 0.10363163f, 0.11161496f, -0.09803405f, -0.00010510f, 0.09531128f, -0.00231418f, 0.05529484f, 
    -0.70041531f, 0.05172512f, -0.08063988f, -0.11879516f, 0.07525481f, 0.04836338f, 0.07501706f, 0.01409620f, 
    -0.01615417f, 0.10471176f, -0.05919656f, -0.07312944f, 0.34013370f, -0.17850314f, -0.01604715f, 0.13165508f, 
    0.02043295f, -0.12162516f, -0.04762638f, -0.00893218f, 0.09535837f, -0.13680775f, 0.09718031f, 0.00971423f, 
    -0.23204435f, 0.02167706f, -0.09205061f, -0.07571225f, 0.01838472f, 0.06854475f, 0.13292979f, -0.07576215f, 
    0.16196510f, 0.01573412f, 0.12418606f, 0.17236075f, 0.02760950f, -0.03994784f, -0.04277293f, -0.08753730f, 
    -0.03333006f, 0.00582414f, -0.03228448f, 0.09043339f, -0.00684608f, 0.10353465f, 0.01119697f, -0.07662930f, 
    0.02572441f, 0.03476108f, -0.09180467f, -0.04494595f, 0.10201441f, -0.09210148f, 0.00314358f, 0.09494215f, 
    0.03215844f, 0.06222958f, 0.06479376f, 0.08126937f, -0.03202838f, 0.23579220f, 0.00199698f, -0.06614588f, 
    0.04930199f, -0.05572209f, -0.03266155f, -0.13667266f, 0.00762365f, -0.04871183f, 0.08870131f, -0.04447175f, 
    0.13434836f, -0.08831710f, 0.02859313f, 0.07899717f, 0.07604874f, 0.19743085f, -0.04578429f, 0.04829000f, 
    -0.00722784f, 0.03797369f, -0.01589647f, 0.01284689f, -0.00582645f, 0.19691110f, -0.05923304f, -0.04951533f, 
    0.06118253f, -0.10705652f, -0.04432874f, -0.05476424f, -0.03140615f, -0.18314977f, -0.01499623f, -0.12100390f, 
    -0.19447953f, 0.14825884f, -0.03991162f, 0.14912938f, 0.12404307f, 0.02075085f, 0.02872372f, -0.01251373f, 
    0.00371632f, 0.06568886f, -0.02043053f, 0.13511677f, 0.20541668f, 0.29060614f, -0.06875169f, 0.00933424f, 
    -0.05105088f, 0.09452475f, -0.02284342f, 0.08937714f, 0.06739127f, 0.07939938f, 0.02127839f, 0.04783294f, 
    -0.06991879f, -0.03224881f, 0.12267083f, 0.05086403f, 0.10973600f, 0.03441711f, 0.00879628f, 0.03839086f, 
    0.04455953f, 0.09443371f, 0.20356864f, 0.14712271f, 0.06207564f, -0.22609042f, 0.03153920f, -0.06424271f, 
    0.28602067f, -0.07330775f, -0.04872400f, -0.03052834f, 0.12880924f, -0.00450359f, 0.24880530f, 0.11795905f, 
    -0.03793608f, -0.20604949f, 0.18296207f, -0.07432016f, 0.02476790f, -0.06329234f, 0.08047929f, 0.11752555f, 
    0.01697616f, 0.10288943f, -0.20679076f, -0.01647905f, -0.23744789f, -0.00822515f, -0.24184652f, -0.19655438f, 
    -0.02438848f, -0.03417863f, -0.01663094f, -0.16874555f, -0.06136293f, 0.00310220f, 0.11243562f, -0.13791808f, 
    0.34987912f, 0.08000361f, -0.04542734f, 0.10915757f, -0.16483733f, -0.00948419f, 0.05094118f, -0.01090347f, 
    -0.01938397f, 0.13462968f, 0.06055421f, 0.05519401f, 0.07427446f, -0.33817437f, -0.07418015f, -0.15937468f, 
    0.26085886f, 0.10452710f, 0.03098994f, -0.09808248f, 0.00765827f, 0.15157230f, -0.10159840f, 0.15048346f, 
    -0.02936835f, 0.09495211f, -0.08069498f, 0.05783068f, -0.17445017f, 0.04953832f, -0.07576583f, -0.03500444f, 
    0.15297627f, 0.03766219f, -0.01674799f, -0.16396606f, 0.14769483f, 0.15625997f, 0.08603396f, -0.14516854f, 
    0.09875543f, -0.11592307f, 0.15299760f, -0.05639049f, -0.11092291f, -0.02523635f, 0.19116469f, -0.13386121f, 
    -0.04822688f, -0.20603494f, 0.05119039f, -0.20624748f, 0.11177050f, 0.04025148f, -0.03955723f, -0.16002870f, 
    0.10830850f, -0.00131174f, 0.10321653f, 0.15427275f, 0.19887303f, -0.22817576f, 0.04586639f, -0.18296924f, 
    0.23969729f, 0.00513151f, 0.02597576f, 0.10187211f, 0.08641835f, 0.07738779f, 0.08145938f, 0.09240154f, 
    -0.25334537f, 0.00445504f, -0.12761708f, -0.10561948f, 0.13380544f, 0.00317907f, -0.12898061f, 0.12404490f, 
    0.02936486f, -0.04620088f, 0.10652994f, 0.10284987f, 0.11672927f, 0.09919090f, 0.04961427f, 0.01658179f, 
    -0.15184154f, 0.03253372f, -0.13679034f, 0.13158505f, 0.01933241f, -0.00043947f, 0.08957198f, -0.13950354f, 
    -0.04999831f, -0.08024950f, -0.04011601f, -0.04070106f, -0.15240574f, 0.00943619f, -0.09945922f, -0.04529313f, 
    -0.05955291f, 0.07176707f, 0.02593745f, 0.00622528f, 0.02746188f, 0.06778392f, 0.14168698f, -0.07031851f, 
    0.01970459f, -0.00933944f, -0.08510787f, 0.09213021f, 0.11130123f, -0.22972514f, -0.06610607f, -0.10651933f, 
    0.28862831f, -0.18229824f, -0.03445226f, 0.04382567f, 0.02751315f, -0.01997649f, -0.01628671f, -0.00990715f, 
    -0.05276033f, 0.18779822f, -0.01629869f, -0.02932072f, -0.07202671f, -0.18659075f, 0.08529006f, -0.12063420f, 
    0.07351954f, 0.01021913f, 0.11236153f, -0.05725379f, -0.00131165f, -0.01805404f, -0.00668961f, 0.12411661f, 
    0.07659803f, 0.00527083f, 0.00756846f, -0.18186845f, -0.06918699f, -0.07389337f, 0.07059652f, 0.11662920f, 
    0.10279886f, -0.04024621f, 0.10772078f, 0.04421498f, -0.05497890f, 0.04428191f, 0.09345283f, -0.27308264f, 
    -0.00136202f, -0.15153775f, -0.01498717f, 0.13442022f, 0.01033886f, -0.04446194f, 0.08435109f, -0.06364453f, 
    -0.09299941f, 0.02663261f, -0.02907930f, -0.00016997f, 0.18943399f, 0.10827664f, -0.16229336f, 0.18108261f, 
    -0.03266411f, -0.01978247f, 0.01320007f, 0.03838051f, -0.11817700f, -0.10674201f, 0.01843357f, 0.16499572f, 
    0.04767400f, -0.12478217f, 0.07391727f, -0.10683893f, -0.01388758f, 0.14163268f, -0.06689943f, 0.03244687f, 
    -0.05533330f, -0.11591982f, -0.04239985f, -0.01435367f, 0.01277804f, 0.04736238f, 0.02839638f, 0.00478455f, 
    0.08315028f, 0.08088628f, -0.00178024f, 0.04760133f, 0.14882289f, 0.30548877f, 0.02308213f, -0.05835512f, 
    0.02758714f, -0.00310726f, -0.06304155f, 0.12230659f, 0.09717027f, 0.00670264f, 0.01083008f, 0.07950772f, 
    -0.17101003f, 0.10959865f, -0.13757545f, -0.15017578f, -0.01533946f, 0.03152427f, 0.08278414f, 0.02233556f, 
    0.00882280f, 0.08084095f, 0.00775377f, 0.17132996f, -0.33849189f, -0.03145669f, 0.24787378f, 0.08379448f, 
    0.09763479f, 0.05766453f, 0.01752882f, -0.06138977f, 0.08313407f, 0.01036429f, 0.01486598f, -0.03696490f, 
    0.02891627f, 0.11665944f, -0.07905479f, 0.15945381f, 0.02352476f, 0.03174566f, -0.00180456f, -0.14698668f, 
    -0.12451418f, 0.02847897f, 0.07692739f, 0.06571130f, -0.10098839f, 0.05588017f, 0.06895415f, 0.13143006f, 
    0.00332695f, -0.03991550f, -0.03036796f, -0.07908284f, -0.03514856f, -0.07168445f, -0.02100394f, -0.04508880f, 
    0.15878560f, 0.04826453f, 0.10964499f, -0.00717892f, 0.08531046f, -0.05707726f, -0.03015900f, 0.07391533f, 
    -0.02206526f, 0.06912052f, -0.05010849f, 0.00801361f, -0.08713203f, -0.09164996f, 0.10349356f, 0.10554828f, 
    0.16257240f, 0.07744133f, 0.15165980f, -0.03372614f, 0.04929222f, -0.00780886f, 0.09122945f, 0.00131869f, 
    -0.13507219f, 0.02949506f, 0.09853353f, 0.04748265f, 0.05165756f, 0.07541560f, 0.08185603f, -0.05394356f, 
    0.08986361f, 0.05001499f, 0.13468525f, -0.05232230f, 0.14253618f, -0.09106936f, -0.17010047f, 0.10622694f, 
    0.01502765f, -0.09823117f, 0.03658948f, -0.15837035f, -0.00651559f, 0.02068408f, 0.07138567f, 0.02392922f, 
    -0.02984995f, -0.07631015f, -0.05188414f, 0.02939753f, -0.06838681f, 0.01515858f, -0.04215521f, 0.03732324f, 
    0.05928263f, -0.07276633f, 0.01111002f, 0.03851307f, -0.00332374f, 0.04275950f, 0.03489669f, 0.01438189f, 
    -0.07488178f, 0.03714860f, -0.05848758f, 0.04097557f, -0.07919450f, -0.00809143f, 0.04244123f, 0.00057132f, 
    -0.01739437f, -0.00496894f, -0.05896567f, 0.00423757f, -0.02369858f, -0.03851204f, -0.04624293f, 0.04184467f, 
    -0.08166192f, -0.07450818f, 0.02689600f, -0.06176957f, 0.01541299f, 0.01157503f, -0.01246374f, 0.01181765f, 
    0.01378976f, 0.04915704f, 0.06592279f, -0.06669661f, -0.05058406f, -0.06945983f, -0.02406292f, -0.02448853f, 
    0.03763655f, -0.01290892f, -0.05724399f, -0.00748739f, -0.02499904f, -0.02161949f, 0.03860217f, 0.05913598f, 
    0.06376696f, -0.01414762f, -0.07410345f, 0.01024642f, -0.07907858f, 0.05781416f, -0.03492367f, -0.03974628f, 
    -0.03129192f, -0.06365298f, -0.00685624f, -0.06152633f, -0.03501721f, -0.02833616f, -0.01612469f, 0.05778461f, 
    -0.00352690f, 0.05834266f, -0.06040606f, -0.00154360f, 0.01705361f, -0.02066263f, -0.00571962f, -0.03455257f, 
    0.05249136f, 0.04369304f, -0.03255562f, 0.01964572f, -0.05656044f, -0.05142035f, -0.04116805f, -0.00338880f, 
    0.05570698f, -0.06999797f, 0.05536584f, 0.01532410f, -0.07532050f, -0.02728889f, -0.02630307f, 0.03097572f, 
    0.05715997f, 0.01382687f, -0.07852439f, -0.07030390f, 0.01780505f, -0.01370569f, -0.01598150f, 0.06154476f, 
    -0.03479368f, -0.04414165f, 0.01583131f, 0.00723781f, 0.05152332f, -0.02595289f, -0.03068633f, 0.04282351f, 
    0.04485131f, 0.00905347f, 0.01761841f, -0.02133898f, 0.01601405f, -0.04965653f, 0.05049477f, 0.03844329f, 
    0.03425849f, -0.00399968f, 0.01430405f, 0.00040140f, -0.03844881f, -0.02362415f, -0.01738035f, 0.02591886f, 
    0.05367991f, 0.00552238f, -0.07853968f, -0.07025724f, 0.02247163f, -0.05576335f, 0.03985151f, 0.05745257f, 
    -0.08028871f, -0.05098658f, -0.02490717f, -0.02543231f, 0.00861209f, -0.02874096f, -0.02223630f, -0.07658041f, 
    -0.06009051f, 0.02502593f, -0.07883020f, -0.01550198f, 0.05369049f, 0.06307045f, -0.04662316f, -0.07571745f, 
    0.04029553f, -0.06682678f, 0.01178655f, 0.03542111f, -0.00191655f, 0.03379658f, 0.02661706f, -0.01161794f, 
    -0.03360153f, 0.03089198f, -0.02910497f, 0.05610974f, 0.00945290f, 0.00655298f, -0.04257555f, 0.02795461f, 
    0.00080577f, 0.01597779f, 0.00600208f, 0.05608222f, -0.02740173f, -0.05205936f, -0.00190702f, 0.00145003f, 
    -0.04155435f, 0.03305203f, -0.05316370f, -0.05524859f, -0.04036887f, -0.05605774f, -0.00895313f, -0.06433962f, 
    -0.00435191f, -0.05891692f, 0.01811975f, 0.05433548f, 0.02863252f, -0.06826028f, -0.06351673f, 0.04924146f, 
    -0.00825877f, 0.02994118f, -0.04549705f, -0.04937464f, -0.05180594f, 0.01430915f, 0.01019232f, 0.04093565f, 
    -0.01328916f, 0.04034229f, 0.05080307f, -0.01975876f, -0.01357939f, -0.05907994f, -0.07328510f, -0.05859618f, 
    0.04179549f, -0.05287714f, -0.03518734f, -0.04893187f, 0.04172080f, -0.07101099f, 0.06517019f, -0.00765389f, 
    -0.01729725f, -0.02640921f, 0.06537791f, -0.02136926f, -0.03545393f, 0.03289628f, 0.02979262f, -0.07052282f, 
    -0.04548949f, -0.06392065f, -0.00520315f, -0.02310917f, 0.04438123f, 0.04149335f, -0.00588549f, -0.03413692f, 
    -0.04205888f, -0.04020567f, 0.01843464f, -0.05811946f, -0.05157297f, 0.05927159f, 0.05728723f, 0.03951918f, 
    0.01895022f, 0.02545277f, -0.05475422f, -0.01778602f, 0.04247224f, 0.02434436f, -0.00565680f, 0.03743046f, 
    -0.03311533f, -0.04040387f, 0.00102313f, 0.05589575f, -0.01531135f, -0.03657291f, -0.04566482f, 0.02747939f, 
    0.04217833f, 0.05336126f, 0.06617761f, -0.00285453f, 0.01797153f, -0.00221147f, -0.00547139f, -0.06492354f, 
    -0.02959905f, 0.05123333f, 0.04253237f, -0.01774143f, 0.02606948f, 0.06501509f, 0.01622576f, 0.00162264f, 
    -0.05946822f, 0.00568757f, -0.02014210f, -0.03952004f, -0.07436734f, -0.01629120f, -0.04730779f, -0.00889568f, 
    -0.07508267f, 0.03550119f, -0.07260884f, -0.00318971f, -0.02354322f, 0.00314732f, 0.02970359f, -0.02375528f, 
    -0.03290724f, -0.03588034f, 0.05390842f, 0.00550052f, -0.05789424f, -0.05251117f, 0.03260667f, 0.01917831f, 
    0.00421848f, -0.02498011f, -0.02246381f, -0.01045072f, -0.02668172f, -0.05140899f, 0.06211122f, -0.02293675f, 
    -0.01928772f, 0.06637584f, 0.05209895f, 0.02188341f, -0.04116763f, -0.01215712f, -0.03279770f, 0.03135363f, 
    -0.04786824f, -0.04982316f, 0.02054974f, -0.04339638f, 0.00357380f, -0.04530322f, -0.06329077f, 0.02204536f, 
    0.01774439f, -0.06536106f, 0.01842607f, 0.03331584f, -0.07052892f, 0.06219000f, -0.06104404f, 0.05659982f, 
    -0.05309162f, -0.07756880f, -0.01405247f, 0.06359211f, 0.01635084f, 0.00402521f, -0.02114046f, 0.03204573f, 
    -0.01806918f, -0.06496392f, -0.06374157f, -0.02997750f, -0.06456850f, -0.07430409f, -0.03390358f, 0.03592991f, 
    -0.01149021f, -0.05295502f, -0.04129653f, -0.03120905f, 0.05153270f, -0.05574604f, -0.02766870f, 0.01194977f, 
    0.00733131f, -0.05571088f, -0.02620945f, -0.02669315f, 0.04144444f, 0.04923848f, 0.01108051f, -0.05592366f, 
    -0.03218813f, 0.01912607f, 0.06428966f, -0.07057954f, 0.00043016f, -0.03466612f, -0.00897792f, -0.02815085f, 
    -0.07370538f, 0.03488086f, -0.03429515f, -0.05725228f, 0.00844335f, -0.05639593f, -0.04525469f, 0.02165676f, 
    -0.06015382f, 0.00947427f, 0.00476977f, -0.04150341f, -0.04523381f, -0.01133437f, 0.04431473f, 0.00206183f, 
    -0.05871741f, -0.06691224f, 0.05601846f, 0.02375431f, -0.06387391f, -0.04364437f, 0.01847908f, -0.06953872f, 
    0.00300918f, 0.02426454f, 0.03248212f, -0.05901487f, -0.05324297f, 0.05015079f, 0.05862527f, 0.04753700f, 
    -0.05456217f, -0.07904722f, -0.03494686f, 0.00995936f, 0.05407528f, -0.05087502f, -0.07415724f, 0.04440993f, 
    -0.02451768f, -0.05977744f, 0.01505814f, 0.00279684f, -0.04343982f, -0.00795673f, 0.01098653f, 0.05089094f, 
    -0.06640211f, -0.01513007f, 0.04556019f, 0.06198095f, -0.03586495f, 0.06268649f, -0.02935396f, 0.03478074f, 
    -0.02444782f, -0.00235985f, -0.07441881f, 0.05525555f, -0.02457402f, 0.04190698f, -0.07262468f, -0.00906804f, 
    -0.06260314f, -0.01510434f, 0.01518299f, 0.00047154f, -0.02062293f, -0.04546809f, -0.02575331f, -0.04007434f, 
    0.05180144f, -0.06408592f, -0.03801405f, 0.05477711f, -0.01322551f, -0.01562732f, 0.01488263f, -0.07723907f, 
    -0.00420353f, -0.04609818f, 0.04468165f, 0.04470934f, 0.04702298f, 0.02720185f, 0.01620762f, -0.01805198f, 
    0.01108986f, 0.05549543f, 0.01787024f, -0.06388240f, -0.05750120f, 0.06499963f, -0.04578156f, -0.07311674f, 
    0.02330648f, 0.05647679f, -0.03741796f, -0.03637376f, 0.06043077f, -0.07095727f, -0.01165704f, -0.05957996f, 
    -0.04053070f, -0.00077094f, 0.01359104f, -0.03686725f, 0.02570267f, 0.05278566f, -0.02583801f, -0.04272778f, 
    0.06389392f, -0.00363226f, 0.06422015f, -0.04682965f, -0.06666186f, 0.00525125f, -0.04297725f, -0.01583992f, 
    -0.06884490f, -0.01790224f, -0.04828336f, -0.03557843f, -0.06358686f, -0.00438574f, -0.04979393f, 0.00987550f, 
    -0.01235368f, -0.03206440f, -0.01845146f, -0.03725456f, -0.00678617f, -0.03181601f, -0.06933323f, 0.05379789f, 
    0.03205928f, -0.01663668f, 0.04362035f, -0.06015747f, 0.01769733f, -0.05556858f, -0.02494523f, 0.00397141f, 
    -0.05465494f, -0.01619614f, -0.00531115f, 0.00009785f, 0.00633320f, 0.02277694f, 0.01670624f, -0.00878137f, 
    -0.02876538f, -0.06447913f, 0.00215992f, -0.04549889f, -0.02232384f, 0.00383383f, -0.04995401f, 0.00644914f, 
    0.02436241f, -0.05636999f, -0.01831726f, 0.01337383f, -0.00933060f, 0.02517674f, -0.06957915f, -0.01808398f, 
    -0.06394447f, 0.04445863f, -0.07866501f, 0.02678028f, -0.02806963f, -0.04795381f, 0.01766867f, -0.00794007f, 
    0.01209699f, 0.02107042f, -0.04239830f, 0.05572814f, -0.01473186f, -0.06228396f, -0.02718988f, 0.01483362f, 
    -0.03446734f, 0.02227545f, -0.06001730f, -0.00900704f, 0.03067683f, -0.03206895f, -0.07561606f, 0.01719338f, 
    -0.01467372f, -0.06589667f, -0.02587365f, 0.02478318f, -0.05817458f, -0.00535420f, 0.03928514f, -0.04177237f, 
    -0.03114532f, -0.00197634f, -0.03135835f, -0.05336222f, 0.00407044f, 0.00872832f, -0.07357333f, -0.05310346f, 
    0.05861717f, 0.05834452f, 0.03441230f, 0.00679543f, 0.02731933f, -0.00917080f, -0.04299176f, 0.05562177f, 
    -0.00504740f, -0.05390901f, 0.01797790f, 0.03969855f, -0.07454845f, -0.02647659f, -0.00566295f, -0.06824395f, 
    -0.04675965f, 0.01525563f, 0.05533504f, 0.01507362f, -0.05222896f, -0.00182417f, 0.01502243f, -0.01005049f, 
    0.02950382f, -0.07261979f, -0.00229634f, 0.06164410f, -0.02569970f, -0.01558133f, 0.05946109f, 0.05190688f, 
    -0.07090855f, 0.05201744f, -0.05056152f, -0.02436986f, -0.06163419f, -0.03570509f, -0.07335448f, -0.00681364f, 
    0.04973422f, 0.01697461f, -0.06672334f, 0.04151138f, -0.04577200f, -0.05350112f, -0.03138742f, 0.07013254f, 
    -0.00252935f, 0.02988893f, -0.02408863f, 0.04213401f, 0.01710178f, 0.06166737f, -0.03608592f, -0.01031786f, 
    -0.01716456f, -0.00288174f, 0.01584799f, 0.04511901f, 0.06828583f, 0.01480457f, -0.00111615f, 0.05614781f, 
    -0.06985431f, -0.02971536f, -0.04799631f, 0.03500877f, 0.02665900f, 0.01293911f, -0.05237630f, -0.03039251f, 
    -0.00982812f, -0.06191383f, -0.02738974f, -0.01706294f, -0.04419330f, -0.07773957f, -0.02873402f, -0.04714838f, 
    -0.07061597f, -0.01763399f, 0.02354220f, -0.03655808f, -0.02541187f, 0.00709623f, -0.06095195f, -0.03487283f, 
    -0.03413712f, 0.05764125f, -0.05659366f, -0.05926132f, 0.07169362f, 0.01211823f, 0.00682113f, 0.01774989f, 
    -0.02374894f, -0.07940932f, -0.05285002f, 0.01097266f, -0.01437727f, -0.07013094f, -0.04929840f, -0.06022919f, 
    0.02782729f, -0.04206568f, -0.06840084f, 0.05327645f, 0.05246621f, 0.06890724f, -0.05938382f, -0.00980276f, 
    -0.08026099f, -0.03622461f, 0.01375064f, 0.05789402f, 0.06669609f, -0.04594860f, 0.00638062f, -0.00308467f, 
    0.06121849f, 0.03213334f, -0.06041241f, 0.04161589f, 0.01216052f, -0.02909502f, 0.04830489f, -0.02982094f, 
    -0.01023205f, 0.01750569f, -0.06982369f, 0.00257527f, 0.04466901f, -0.04376978f, -0.01008044f, 0.01579354f, 
    -0.07638883f, -0.01935286f, -0.04714362f, 0.06485522f, 0.05289200f, 0.06558232f, -0.05969592f, -0.04061705f, 
    0.02432350f, 0.04805349f, -0.04619282f, -0.05109439f, -0.06874899f, -0.06438403f, -0.05755171f, 0.02269320f, 
    -0.05602495f, -0.06114817f, -0.01828092f, 0.02530845f, 0.05405975f, -0.05787849f, -0.03253283f, 0.05600464f, 
    0.01626780f, 0.05064632f, 0.01578868f, -0.06912725f, 0.02958760f, 0.01811300f, 0.02018121f, 0.02432684f, 
    -0.03422234f, -0.05517102f, 0.05255290f, 0.05394674f, -0.00395852f, 0.06040509f, 0.02826816f, -0.06680900f, 
    0.00779254f, -0.05436761f, -0.05103465f, 0.04329403f, -0.02011504f, -0.03844836f, -0.03545902f, 0.01128942f, 
    -0.05453119f, 0.04743335f, -0.06537842f, -0.00347084f, 0.00061084f, 0.03342961f, 0.05611860f, -0.02749406f, 
    0.42759809f, -0.04031176f, 0.06545734f, -0.17719756f, 0.16539325f, 0.07615330f, -0.01913628f, 0.05099609f, 
    -0.02122250f, 0.00442382f, -0.19852594f, 0.04273717f, 0.12883207f, -0.11450232f, -0.04779229f, 0.24639159f, 
    0.05440089f, -0.01137830f, -0.02864381f, 0.12624672f, -0.09592710f, 0.03602473f, -0.01753573f, -0.00259799f, 
    0.13282631f, 0.07590137f, 0.15996020f, 0.15745820f, -0.05730836f, 0.00083120f, 0.17301340f, 0.07552686f, 
    0.05088332f, 0.04467103f, 0.03616921f, 0.06236224f, 0.20788138f, 0.10564845f, 0.14002459f, -0.37444139f, 
    0.07019495f, -0.05283419f, 0.07676727f, 0.01172642f, -0.06610387f, -0.01487145f, -0.01897572f, 0.03736646f, 
    -0.15890005f, 0.02834066f, 0.02637694f, 0.00073529f, -0.04789363f, 0.05239219f, -0.08205492f, 0.03231558f, 
    0.13297102f, 0.00862655f, 0.06094604f, 0.13420126f, 0.17090346f, -0.20838693f, -0.03192807f, 0.02730214f, 
    0.03513659f, 0.05639553f, -0.05470955f, 0.00923343f, 0.10702810f, -0.00381422f, 0.00825629f, -0.00261664f, 
    -0.26157692f, 0.20465289f, -0.03411128f, -0.24297442f, 0.00935928f, 0.09524379f, 0.00052613f, 0.04970288f, 
    0.01380405f, 0.07282393f, 0.01574971f, 0.02443527f, 0.04294160f, 0.11133942f, -0.14228594f, -0.14272538f, 
    -0.04297463f, 0.03640052f, 0.03452316f, 0.07021130f, 0.00160422f, 0.02605704f, 0.02682028f, -0.03192669f, 
    -0.30012169f, 0.10619162f, -0.11085685f, -0.09884043f, 0.01584323f, 0.01484097f, 0.10869855f, -0.02953450f, 
    -0.02676542f, 0.06169982f, 0.14472696f, 0.06091965f, 0.31260738f, 0.23166190f, -0.01562285f, -0.06347863f, 
    0.05941687f, -0.12305740f, -0.04861841f, 0.02457448f, -0.03378746f, -0.08877595f, -0.02764560f, 0.17777090f, 
    -0.05847470f, -0.14672452f, 0.08764115f, 0.21577290f, 0.06704193f, 0.03128248f, 0.04137267f, -0.08119828f, 
    -0.00442183f, 0.00795810f, -0.06132293f, 0.06140131f, -0.16718151f, 0.23928589f, 0.17317255f, 0.02403243f, 
    -0.04709845f, 0.08562867f, 0.05845898f, 0.07314420f, 0.01764716f, 0.04847365f, 0.04771096f, -0.00158698f, 
    -0.16263658f, 0.27091005f, 0.24753721f, -0.38036954f, -0.02638919f, 0.02020529f, 0.05694430f, 0.14573593f, 
    -0.01366453f, -0.03315165f, -0.02100580f, -0.00991962f, -0.38447547f, -0.26909992f, 0.02681240f, -0.03870944f, 
    0.04881768f, -0.07068494f, -0.08638837f, -0.03073380f, 0.01304110f, -0.02920944f, 0.09631250f, 0.02854102f, 
    -0.02955938f, 0.15142176f, -0.12716086f, -0.06038564f, -0.00392913f, 0.05947285f, -0.10667893f, -0.02661567f, 
    0.02304685f, -0.10715981f, -0.08672860f, -0.09486467f, 0.15123662f, 0.05415704f, -0.12852266f, -0.18392655f, 
    0.09226386f, 0.05610877f, -0.02723531f, 0.09826344f, 0.15290785f, 0.05491981f, -0.14960343f, 0.08311331f, 
    -0.01407158f, 0.09955915f, -0.09105159f, 0.18683715f, -0.04425877f, 0.13184264f, -0.04318524f, -0.05167613f, 
    0.04896383f, -0.03952094f, 0.05945032f, -0.05707962f, -0.11518563f, 0.01496702f, 0.10453738f, -0.00046471f, 
    0.03473908f, -0.03340532f, -0.11118902f, 0.01652741f, -0.08371148f, -0.06436794f, 0.05149916f, -0.07964260f, 
    0.10056692f, 0.19935237f, -0.03193446f, -0.17618607f, -0.00181754f, 0.14469044f, 0.00666398f, 0.06290636f, 
    -0.07900831f, 0.06712101f, -0.13610250f, -0.03036084f, -0.11755131f, 0.16889788f, -0.11253528f, 0.07047100f, 
    -0.07711343f, 0.00466805f, 0.10726171f, 0.05659132f, 0.06274784f, 0.03243335f, -0.13076116f, -0.12907054f, 
    -0.21613048f, 0.24065061f, 0.03242858f, -0.06906056f, -0.16343519f, 0.04236510f, -0.18772081f, 0.05168225f, 
    0.09486490f, -0.05033217f, 0.28402168f, 0.04145260f, 0.02820563f, 0.00940218f, 0.17575732f, 0.08673047f, 
    -0.06553239f, 0.04236950f, 0.19305295f, 0.12090093f, 0.07935221f, 0.09887558f, -0.03450305f, 0.11816383f, 
    0.17755775f, 0.03378889f, 0.01668075f, -0.02302986f, 0.04925599f, 0.05264724f, -0.18413217f, 0.07014298f, 
    -0.00746071f, 0.04172227f, -0.15121523f, 0.04064072f, -0.11052979f, 0.03728514f, -0.17290975f, -0.23087136f, 
    -0.08336490f, -0.07686739f, -0.03604493f, 0.15094355f, -0.12984499f, -0.06211768f, -0.01204687f, -0.12605441f, 
    0.29795578f, 0.07698728f, 0.12447137f, 0.09312983f, -0.05076646f, -0.01259936f, -0.08095170f, -0.03663753f, 
    -0.00682669f, 0.00215035f, -0.02404368f, 0.00843541f, 0.07523031f, 0.02350304f, -0.11274397f, 0.02164773f, 
    -0.01340796f, -0.10620926f, -0.04199814f, -0.00318620f, -0.15761356f, 0.13707019f, -0.02427463f, 0.06736338f, 
    -0.12864143f, 0.07361323f, 0.29830280f, -0.06995162f, 0.00273892f, 0.06740796f, 0.04776157f, 0.11590106f, 
    -0.03299757f, -0.01315669f, -0.10291228f, -0.01993792f, -0.25123507f, 0.22912689f, 0.05576976f, 0.07973786f, 
    0.02202417f, -0.03527205f, -0.09318896f, 0.10887420f, 0.01499357f, 0.12301769f, -0.07313343f, 0.07537712f, 
    -0.04562512f, -0.02860736f, -0.04951929f, 0.00678331f, -0.21428016f, 0.06087022f, 0.06505624f, -0.10846837f, 
    -0.01082737f, -0.05161107f, -0.00539472f, -0.01304302f, 0.17253859f, 0.06468647f, 0.07695378f, -0.03129512f, 
    0.04106916f, 0.01240692f, 0.03393993f, 0.16493702f, -0.03202856f, -0.01112942f, 0.01440146f, -0.00928836f, 
    0.19391996f, 0.04142008f, 0.07752292f, 0.05742479f, -0.04330706f, -0.01070246f, 0.05511150f, 0.07724005f, 
    -0.07934142f, 0.00115361f, -0.02682569f, -0.00689447f, 0.02753413f, 0.18648937f, 0.10230859f, -0.13905430f, 
    0.20431061f, 0.12288157f, 0.10533593f, 0.20161222f, 0.04599672f, 0.17679474f, 0.04969748f, 0.13956109f, 
    0.18361643f, -0.06032518f, 0.08314580f, -0.10866170f, 0.00237630f, -0.03164780f, -0.08956136f, 0.03269320f, 
    -0.07910755f, -0.02690023f, 0.05429158f, -0.14794630f, 0.18716379f, 0.02856916f, 0.11644892f, 0.11174677f, 
    -0.11071233f, -0.07564881f, -0.06106098f, 0.00257235f, -0.08410678f, -0.04524679f, 0.01669037f, -0.10953665f, 
    0.15438659f, -0.00937816f, -0.08076442f, 0.20101519f, -0.00549949f, -0.01294254f, -0.00876634f, 0.02337573f, 
    -0.02113349f, -0.09602074f, -0.16274057f, -0.15993497f, 0.08797386f, 0.20015866f, 0.07083356f, 0.18341197f, 
    -0.07735942f, 0.20638220f, 0.13735838f, 0.10771749f, -0.00822116f, -0.01349371f, -0.27365929f, -0.13054350f, 
    0.09670392f, 0.09450396f, -0.04142406f, -0.02149266f, -0.08531632f, -0.06970501f, -0.08550865f, -0.08927030f, 
    -0.00822801f, 0.03105330f, 0.39619163f, 0.11565334f, 0.13199916f, 0.01919338f, 0.30703461f, 0.17445524f, 
    -0.01873169f, 0.08269298f, 0.19101027f, 0.25953209f, 0.11644968f, 0.09735274f, -0.05996841f, 0.08162002f, 
    -0.32301810f, 0.01994288f, 0.10696665f, -0.02533903f, 0.15555941f, 0.01817685f, -0.14462203f, 0.00643841f, 
    -0.09159153f, -0.11461312f, -0.10488665f, 0.14575182f, 0.22261544f, 0.06341144f, 0.05935363f, -0.05945868f, 
    -0.06760481f, -0.06677908f, -0.01617336f, 0.05228460f, 0.02556808f, -0.08192800f, 0.13331443f, -0.01235476f, 
    -0.12719992f, 0.07666291f, 0.08542281f, 0.02266119f, 0.01036551f, 0.05129690f, -0.02226781f, 0.07183086f, 
    -0.10672292f, 0.06394569f, 0.21080956f, 0.09519925f, 0.24198438f, -0.09373544f, -0.19432020f, 0.00844780f, 
    -0.00916241f, 0.07093055f, -0.05344681f, 0.14357005f, 0.11963946f, 0.07681735f, -0.04343951f, 0.09332737f, 
    0.32962444f, -0.06488539f, -0.01378861f, 0.10521148f, -0.05798021f, -0.00137845f, -0.00104763f, 0.05579695f, 
    0.03993938f, -0.05973658f, -0.14074129f, -0.06036533f, -0.20883040f, 0.18995433f, 0.04088347f, 0.04451659f, 
    -0.03832500f, 0.05529617f, -0.04375215f, 0.07363697f, -0.09278084f, 0.08659235f, -0.06447305f, -0.03278228f, 
    0.22125573f, 0.01752414f, 0.02372750f, -0.02153786f, -0.18908472f, 0.02744723f, 0.18949582f, 0.04992007f, 
    0.01495299f, 0.08973744f, -0.08502301f, -0.02378643f, -0.11971056f, -0.02922099f, -0.06242149f, -0.03593407f, 
    -0.01972995f, -0.02939945f, 0.12396181f, 0.01952201f, 0.02257509f, 0.08412636f, 0.05256342f, 0.07204853f, 
    0.06432924f, 0.09735431f, -0.06298731f, 0.09777407f, -0.06699380f, -0.00717457f, 0.07311959f, 0.02455166f, 
    0.01143900f, -0.12639275f, -0.06366447f, -0.01862399f, -0.18068705f, -0.07339314f, -0.03038079f, 0.00732461f, 
    0.13078232f, 0.03261364f, 0.08606370f, 0.01136596f, -0.09441965f, 0.22444053f, 0.01795344f, 0.22357224f, 
    0.21931440f, -0.02472910f, 0.03342023f, -0.12027078f, 0.07023624f, 0.06759997f, 0.01638576f, 0.12147872f, 
    0.13861887f, 0.04702309f, 0.00798227f, 0.19650997f, -0.09983414f, -0.27945235f, 0.10637747f, 0.00307007f, 
    0.07482566f, 0.03910489f, 0.00200675f, -0.00249307f, -0.01361383f, 0.00079844f, -0.11884004f, -0.02008417f, 
    -0.11580013f, 0.28516862f, -0.08370135f, -0.04867440f, 0.00109907f, 0.00589554f, 0.13376392f, 0.17382468f, 
    0.05717396f, 0.08550888f, 0.03397012f, 0.02652987f, -0.11766007f, 0.08667289f, 0.03520063f, -0.26169670f, 
    0.19739835f, 0.02775924f, -0.11412563f, 0.02677918f, -0.11141165f, -0.00144779f, 0.09808179f, 0.11057960f, 
    -0.05960044f, 0.07497241f, 0.00959091f, 0.15349725f, 0.04541221f, 0.05895046f, -0.03577241f, 0.08161402f, 
    0.07132205f, -0.01525253f, -0.00255752f, 0.07204223f, 0.18083878f, -0.08680440f, -0.05748498f, 0.07395577f, 
    0.00373429f, -0.00214181f, -0.01134990f, 0.08807603f, -0.15980305f, -0.04433214f, 0.06172407f, 0.02612365f, 
    0.16109949f, -0.01068250f, 0.10180052f, 0.00794314f, 0.02205169f, 0.00888451f, -0.02580082f, 0.07381336f, 
    0.02158505f, 0.12230339f, 0.03561398f, -0.02594960f, -0.45744717f, 0.28386602f, -0.26629317f, -0.27234757f, 
    0.13803856f, 0.05978130f, 0.04499641f, -0.09625091f, -0.02288917f, 0.05156756f, -0.00258258f, -0.00971243f, 
    0.26411912f, -0.04322867f, 0.07677580f, 0.04209537f, -0.03011978f, 0.07180721f, 0.15119015f, 0.08173088f, 
    0.16306506f, 0.02035620f, -0.12814431f, 0.04425173f, -0.14018673f, 0.00932277f, 0.08870576f, -0.06048542f, 
    0.00751802f, 0.04420505f, -0.08258009f, -0.11720338f, -0.02744389f, 0.08736230f, -0.11812919f, 0.08077219f, 
    -0.31409317f, 0.25864866f, 0.08376837f, 0.26319265f, 0.01772779f, -0.00980534f, -0.00350001f, -0.01312753f, 
    0.03587810f, 0.01032272f, 0.08795939f, -0.05436267f, -0.29788393f, 0.15933269f, 0.04299063f, -0.05022400f, 
    0.00416124f, -0.01698510f, 0.09109920f, -0.00700242f, 0.11917934f, 0.01132929f, 0.05526481f, 0.03860902f, 
    -0.35798976f, 0.05357837f, 0.10393266f, -0.29539794f, 0.05469744f, 0.02338548f, -0.05973748f, -0.04989015f, 
    -0.08250161f, 0.04700286f, 0.03206595f, 0.07474590f, -0.00668353f, -0.24075346f, 0.05901414f, 0.19059114f, 
    -0.05110275f, -0.07044937f, 0.01911154f, 0.04094758f, -0.09280295f, -0.01793693f, 0.02374381f, 0.00836065f, 
    0.04724865f, -0.01557632f, 0.03976381f, -0.02172103f, 0.20545886f, -0.03412155f, -0.09994612f, -0.13498332f, 
    0.02788752f, -0.05214658f, 0.08789361f, -0.00921149f, 0.21389332f, 0.07176267f, -0.09779800f, 0.17983273f, 
    -0.05729289f, 0.03867714f, 0.09563288f, 0.05499683f, -0.00918478f, -0.00079136f, 0.00106216f, -0.06328087f, 
    -0.17809215f, 0.00395711f, 0.08678398f, -0.24439228f, 0.10947573f, -0.17004158f, 0.00730935f, 0.06997836f, 
    -0.00482867f, -0.06308921f, -0.09026132f, 0.10053887f, 0.08273447f, -0.08778597f, 0.09908717f, 0.13439907f, 
    -0.15063107f, -0.08442478f, 0.07089263f, -0.08968896f, 0.06883627f, 0.07132642f, 0.01759330f, 0.10089390f, 
    0.01827017f, 0.00088861f, -0.00176763f, 0.24796186f, -0.02711827f, -0.08318044f, -0.04376542f, -0.03979435f, 
    -0.01785351f, -0.07546407f, 0.10584363f, 0.13046506f, -0.10617468f, -0.04267476f, 0.13226378f, 0.10609002f, 
    0.03790921f, 0.06153876f, -0.05436276f, 0.02981220f, 0.05491741f, 0.05419571f, 0.05048705f, 0.13664284f, 
    0.21330550f, -0.01179404f, 0.06432233f, 0.14603925f, 0.14810957f, 0.10352223f, 0.12044964f, -0.02867949f, 
    -0.02258541f, 0.04768722f, -0.25718153f, -0.02320913f, 0.19510399f, -0.01639695f, 0.18416198f, -0.05779729f, 
    0.09120759f, -0.00673479f, -0.15053703f, 0.09435296f, 0.01596303f, -0.07547389f, -0.03032240f, 0.07829715f, 
    -0.48310107f, 0.09811679f, -0.04458375f, 0.08847216f, 0.10911904f, 0.00412614f, 0.20875956f, -0.01555661f, 
    0.01315690f, -0.05828120f, 0.15846428f, -0.04150974f, -0.06106900f, -0.04115660f, 0.01921638f, 0.30828089f, 
    0.10932986f, 0.18600003f, -0.00743064f, -0.04087606f, 0.12366831f, -0.01361207f, -0.06899749f, -0.01514013f, 
    -0.43147153f, -0.06731146f, -0.19105133f, -0.08892366f, 0.14539078f, -0.03116969f, 0.05267494f, 0.08353296f, 
    -0.10793543f, 0.09205859f, -0.05150422f, 0.06179249f, -0.00712806f, -0.15889058f, 0.07657487f, 0.09585364f, 
    0.01877838f, -0.02185642f, -0.06384229f, -0.03774570f, 0.05701560f, -0.09490386f, -0.05076928f, 0.05499840f, 
    -0.02161484f, 0.06678472f, -0.09127399f, 0.13741627f, 0.02945342f, -0.02909072f, -0.00830182f, 0.07974461f, 
    0.01842265f, -0.06006144f, 0.03120891f, 0.09130387f, 0.05108291f, 0.05318034f, 0.00617089f, -0.07447714f, 
    -0.08235446f, -0.00982587f, 0.07514924f, 0.02379911f, -0.00688429f, 0.02825433f, 0.02567199f, -0.02939444f, 
    -0.09308972f, -0.10800897f, 0.03107138f, -0.03436095f, 0.06779757f, -0.06236186f, 0.03705709f, -0.02943554f, 
    0.01813111f, 0.04771190f, 0.15079728f, 0.13446413f, -0.25731045f, -0.08550275f, -0.03060554f, 0.00538041f, 
    0.00825066f, 0.01127756f, -0.03878394f, -0.24543647f, 0.10647595f, 0.02955382f, 0.05079623f, -0.02393069f, 
    0.10869214f, -0.10647431f, 0.11886336f, 0.06574141f, 0.15030868f, 0.03479485f, 0.02727450f, 0.14721045f, 
    0.02589980f, 0.02734878f, 0.03336051f, 0.03777637f, -0.04683676f, 0.04561654f, 0.01826047f, 0.19385141f, 
    -0.00665576f, -0.11208815f, -0.01177176f, -0.21281126f, -0.00028390f, -0.15266877f, 0.04008529f, 0.01282443f, 
    -0.06729684f, -0.01928092f, 0.03461562f, 0.04122724f, 0.11892769f, 0.02339917f, 0.06959483f, -0.12536490f, 
    -0.03433888f, 0.04605279f, 0.04272549f, 0.13176069f, 0.03768316f, 0.20400567f, -0.04886536f, 0.16949984f, 
    0.17152038f, 0.11658176f, -0.08988649f, 0.15809998f, -0.04512746f, 0.11369289f, 0.02248496f, -0.00361092f, 
    0.04221231f, 0.02126936f, -0.10340354f, 0.15769099f, 0.09643745f, 0.09361697f, 0.11630466f, 0.08668074f, 
    0.14014751f, 0.11790109f, -0.09968738f, 0.02391971f, 0.23797753f, -0.06565259f, -0.02986290f, 0.21390668f, 
    -0.01473709f, -0.13261162f, 0.03114337f, -0.01901032f, -0.02537402f, -0.00526614f, -0.01384512f, -0.03518238f, 
    0.13354355f, -0.05881061f, 0.20386857f, -0.06137728f, -0.13671848f, 0.00531038f, -0.01601195f, -0.05628118f, 
    0.13446277f, -0.05647876f, 0.10748508f, 0.10282270f, -0.14386834f, -0.06768104f, -0.06408995f, 0.07446027f, 
    -0.19051056f, 0.10018223f, 0.08293515f, -0.05789588f, 0.14156297f, 0.08428338f, 0.00258092f, 0.08738206f, 
    0.24759318f, -0.03791283f, 0.07024325f, -0.02603369f, -0.10994130f, -0.02555799f, -0.05743442f, 0.00405261f, 
    -0.03281964f, 0.03076429f, -0.03687258f, 0.00777593f, -0.09414816f, -0.22000009f, -0.15154156f, -0.24368852f, 
    0.06787512f, -0.12721248f, -0.13533042f, -0.11271889f, -0.01303393f, 0.07199954f, 0.04162278f, 0.04567911f, 
    0.36422050f, 0.06884804f, 0.23089767f, 0.11076117f, -0.05557583f, 0.03957495f, 0.01717244f, -0.09695220f, 
    0.13019779f, -0.03171192f, 0.10398465f, -0.03362668f, 0.28252858f, 0.10291279f, -0.04677104f, 0.05513680f, 
    0.28594968f, 0.00338319f, -0.06240673f, 0.06882586f, -0.03830405f, 0.13720848f, 0.10498538f, 0.11159259f, 
    0.08551954f, -0.19517249f, 0.06179063f, 0.10876407f, -0.03451240f, 0.09877913f, -0.10219390f, 0.04051726f, 
    0.01080924f, 0.07888399f, -0.07664518f, 0.06638572f, -0.27410886f, -0.13796952f, -0.07297293f, 0.00309783f, 
    0.13823624f, 0.02392649f, 0.03492507f, -0.05637662f, 0.11529969f, 0.08089697f, 0.06520318f, 0.09890775f, 
    -0.44820586f, -0.01014995f, -0.11629269f, 0.03482316f, -0.01648785f, -0.04971315f, -0.08085576f, 0.00189191f, 
    0.15619114f, -0.06522910f, -0.02192321f, -0.01785176f, 0.14180870f, 0.09552096f, 0.04897264f, -0.15128104f, 
    -0.15294522f, -0.07694751f, -0.03319407f, 0.15572286f, -0.14659013f, 0.11111357f, -0.02928394f, -0.03611476f, 
    0.05201367f, 0.07839292f, -0.03660433f, -0.25477442f, -0.21758179f, 0.00975007f, -0.03646989f, -0.17030747f, 
    0.04087618f, -0.14204745f, -0.05182702f, -0.14111842f, -0.01111533f, -0.18509449f, 0.01626671f, -0.10967469f, 
    -0.08145000f, 0.12935613f, 0.11921453f, 0.08658227f, 0.03536563f, 0.05827357f, -0.12772672f, -0.01869008f, 
    -0.04232866f, 0.00448647f, -0.07034138f, -0.01529407f, 0.06483258f, -0.03426528f, -0.03128857f, 0.01036945f, 
    0.02193835f, 0.00357184f, -0.02225841f, -0.01146297f, -0.04830887f, -0.04492229f, 0.02483580f, 0.00448709f, 
    0.03258486f, -0.02634263f, -0.02573708f, 0.06386849f, 0.04097490f, 0.03479588f, 0.03297256f, 0.02500964f, 
    -0.03253140f, -0.05056018f, -0.00491941f, 0.05181192f, 0.01864370f, 0.02402363f, -0.07982025f, 0.05598736f, 
    -0.02321720f, 0.05400276f, 0.06501842f, 0.04205202f, 0.05378915f, -0.04620729f, -0.04067739f, 0.05986650f, 
    -0.03364074f, -0.05722137f, -0.04389310f, -0.03673241f, -0.03374086f, -0.04908243f, 0.04454629f, -0.03909927f, 
    -0.03211440f, 0.00186854f, -0.01198869f, -0.05665415f, -0.00760591f, 0.06523461f, 0.01227135f, -0.01387097f, 
    -0.03383782f, 0.01579756f, -0.04359182f, -0.06110921f, 0.04130727f, -0.00218589f, -0.02310313f, 0.03586994f, 
    0.00570185f, -0.02527795f, -0.00972880f, 0.05089327f, 0.01908403f, 0.02892923f, 0.05267867f, -0.00274792f, 
    -0.07611197f, -0.05577281f, -0.01847103f, -0.05870046f, -0.01131778f, -0.06229396f, 0.05965206f, -0.06327236f, 
    -0.00450231f, -0.02165340f, 0.04317862f, -0.06884646f, 0.04184904f, -0.04156372f, -0.05557746f, -0.00730686f, 
    -0.05404060f, 0.00391773f, -0.00146426f, -0.03282507f, -0.03324263f, -0.07035757f, -0.04665359f, 0.03840011f, 
    0.06748573f, -0.01260248f, -0.03507615f, -0.05405566f, 0.01340560f, 0.00271145f, 0.02599969f, -0.02998217f, 
    -0.04535351f, -0.06646309f, -0.06047147f, 0.06184932f, -0.03796007f, -0.06438171f, -0.03197997f, 0.05235786f, 
    0.01838997f, -0.05121605f, -0.04405044f, -0.07893670f, -0.03163661f, 0.03199356f, 0.00566946f, -0.02613683f, 
    0.01555756f, 0.01380561f, -0.03061356f, -0.00603463f, -0.00073188f, -0.00836159f, 0.04028552f, 0.02804261f, 
    -0.05571583f, -0.05030545f, 0.06151104f, 0.00048267f, 0.05652520f, -0.06014096f, -0.03418122f, 0.02351424f, 
    0.02132012f, -0.07140829f, -0.05056288f, 0.05034154f, -0.02219165f, -0.00257151f, -0.01295270f, 0.06499854f, 
    -0.02374692f, -0.03384335f, 0.01143751f, -0.05965696f, -0.05027651f, -0.04609766f, 0.00325724f, 0.03728750f, 
    -0.01300319f, 0.00350562f, 0.06434079f, -0.03540780f, -0.04866058f, -0.06611548f, 0.05269202f, -0.02907115f, 
    -0.04133624f, 0.01195469f, -0.06619595f, -0.03451853f, -0.05895115f, -0.05638402f, -0.05126939f, 0.00113140f, 
    0.00298160f, 0.05132660f, -0.02246854f, -0.00423612f, 0.02456324f, 0.01996891f, -0.05596221f, -0.06112233f, 
    0.01230960f, 0.02971456f, 0.02937237f, -0.00783396f, 0.01005405f, -0.02088198f, -0.01522702f, -0.02089918f, 
    -0.00054079f, -0.00945698f, -0.06292409f, -0.05336631f, -0.06295322f, 0.03866412f, 0.01645566f, -0.04396531f, 
    -0.01405097f, -0.04161222f, 0.01470042f, 0.00057361f, 0.01294676f, -0.04822668f, -0.00059365f, -0.04538520f, 
    -0.02872520f, -0.06689911f, -0.03509675f, -0.04005219f, -0.02825699f, 0.01777556f, -0.02702873f, -0.04752917f, 
    0.06824516f, 0.05399080f, 0.06830733f, -0.00354283f, -0.05136771f, -0.07080141f, -0.01977922f, 0.03802691f, 
    0.07133087f, 0.01033338f, -0.02693590f, 0.05566940f, 0.00647164f, -0.07193810f, 0.02509412f, -0.01982036f, 
    -0.04556189f, -0.05444173f, 0.07159721f, 0.05388175f, -0.01750032f, -0.00917852f, -0.07092397f, -0.02944031f, 
    -0.03448977f, -0.00108096f, -0.00418833f, -0.06073051f, 0.01547251f, -0.03803207f, -0.07198877f, -0.01603252f, 
    0.06736051f, -0.06712217f, -0.01461418f, -0.05210473f, -0.02843146f, -0.06661427f, -0.03827852f, -0.01860441f, 
    -0.00775363f, 0.03369964f, 0.01326040f, -0.06560367f, 0.04194174f, 0.01640061f, -0.01572341f, 0.03697244f, 
    0.02591689f, -0.04959568f, 0.03454624f, -0.02075646f, -0.02382387f, 0.01912486f, -0.07044854f, 0.04403850f, 
    -0.04367566f, -0.04933305f, 0.06288444f, -0.02049504f, 0.02854948f, 0.01154059f, -0.07091612f, 0.00760034f, 
    -0.03751824f, -0.03296770f, 0.04932896f, 0.02003463f, -0.03396087f, -0.00140193f, 0.05921369f, -0.04113055f, 
    -0.03236167f, 0.05018676f, 0.05288588f, -0.02626166f, 0.06114293f, -0.00000539f, 0.04633713f, -0.03342653f, 
    -0.04395838f, 0.03774336f, -0.03108209f, 0.06226087f, -0.04152362f, -0.07133792f, -0.03825259f, 0.04337367f, 
    0.03732248f, 0.05463735f, -0.02225315f, -0.06887833f, 0.01574949f, 0.05537415f, 0.04924789f, 0.00045658f, 
    -0.04155417f, -0.00070997f, 0.06831437f, 0.02977002f, -0.07040846f, -0.06952215f, 0.06806716f, -0.04949480f, 
    -0.05546565f, -0.02823224f, -0.01159206f, -0.06583696f, 0.06853684f, -0.04968488f, -0.07207630f, 0.06806593f, 
    -0.00614919f, 0.06904382f, -0.03578712f, 0.07094604f, -0.03786542f, -0.06415884f, -0.05820706f, 0.04862363f, 
    -0.00767601f, -0.07208475f, -0.05476892f, -0.02500248f, -0.05434079f, 0.05000063f, 0.00585269f, -0.06273896f, 
    0.01187128f, -0.01873258f, 0.06803155f, 0.07062946f, -0.06470648f, 0.02672677f, 0.02905514f, -0.06627446f, 
    0.03576707f, -0.01844741f, 0.06919829f, 0.06257779f, -0.06081225f, -0.04359963f, 0.05155021f, 0.01037246f, 
    -0.01435155f, 0.04927066f, 0.02068995f, 0.04868288f, -0.06843820f, -0.02308042f, -0.06878553f, -0.05671270f, 
    -0.01994293f, -0.02183580f, 0.00980930f, -0.01351724f, 0.01800280f, 0.02867193f, -0.06798643f, -0.01113210f, 
    0.01066937f, -0.02804514f, 0.02589398f, 0.07191291f, -0.04207801f, -0.06503239f, -0.04368733f, -0.04707938f, 
    -0.03267691f, -0.05546207f, -0.05454579f, -0.00081799f, -0.04359946f, -0.00127407f, -0.04070589f, -0.05927128f, 
    0.05805519f, -0.03412952f, -0.07426550f, -0.06297971f, 0.02411110f, -0.05028187f, 0.01669587f, -0.01752742f, 
    0.02389609f, -0.05563645f, 0.00400015f, 0.03944272f, 0.00801868f, 0.06174309f, -0.03477070f, -0.02397932f, 
    -0.05276574f, 0.02095382f, -0.06818043f, -0.06636008f, -0.06809964f, -0.07535101f, -0.03173707f, -0.03628408f, 
    0.05040508f, -0.01746246f, -0.00557170f, -0.05072268f, 0.04607011f, -0.06627071f, -0.00254636f, -0.05183815f, 
    -0.05761176f, 0.04597741f, -0.03827463f, -0.01189107f, 0.04598739f, -0.02511537f, -0.06297138f, -0.03610247f, 
    0.05963208f, 0.06370711f, -0.07272399f, -0.07572855f, -0.01076347f, -0.01569515f, -0.02454601f, 0.03535029f, 
    -0.07403471f, -0.00666774f, 0.00292052f, -0.05119568f, 0.06616288f, -0.03192636f, -0.01641026f, 0.05975068f, 
    -0.07340122f, 0.00168307f, 0.05768986f, 0.03276850f, 0.02238537f, -0.03632118f, -0.04270384f, -0.00024654f, 
    -0.05037223f, 0.05143714f, 0.01362812f, -0.06650391f, 0.02461963f, -0.02093999f, 0.05112629f, 0.04153417f, 
    0.03694437f, -0.02873189f, 0.05880008f, 0.04970756f, 0.06314185f, -0.01652172f, 0.04069886f, -0.04422170f, 
    -0.07582875f, -0.03172967f, -0.01410995f, -0.05179199f, -0.07896792f, 0.02161546f, 0.03790170f, 0.05159836f, 
    -0.05144487f, -0.01215160f, -0.04168362f, 0.03382074f, -0.06684076f, -0.05855983f, 0.01397709f, 0.03229963f, 
    -0.04215821f, 0.02326604f, 0.03654242f, -0.04815996f, -0.01042435f, -0.06129055f, 0.06145361f, -0.03625024f, 
    0.02202525f, -0.03415914f, -0.05701494f, -0.04223118f, 0.02625117f, -0.06606566f, 0.01600863f, -0.04298485f, 
    -0.07573060f, -0.02414932f, -0.06518253f, 0.03806607f, -0.01529059f, 0.02215260f, 0.02438061f, -0.04211260f, 
    0.02083589f, 0.06408256f, 0.00621797f, 0.02313838f, -0.01907141f, 0.06146294f, -0.00505848f, -0.02847385f, 
    -0.06036671f, 0.02827273f, -0.03577914f, 0.00641374f, 0.02065084f, 0.04043164f, -0.00766386f, 0.04353096f, 
    -0.01309632f, -0.07137612f, -0.00620975f, 0.06281640f, 0.04995264f, 0.06365789f, -0.01172897f, 0.02128798f, 
    -0.07515196f, 0.00877900f, -0.02650427f, 0.02606077f, 0.02984686f, 0.01710284f, -0.02390912f, -0.03428004f, 
    0.03578624f, -0.06899270f, 0.01354047f, -0.00987996f, -0.00754412f, -0.02824575f, 0.05588067f, 0.01994829f, 
    -0.02879194f, -0.02014994f, 0.05184289f, -0.01069620f, 0.03012192f, -0.06616233f, -0.07423784f, -0.00835091f, 
    -0.01180395f, -0.03974425f, -0.00823613f, -0.03299543f, 0.02018595f, 0.03987926f, 0.04478304f, -0.06030277f, 
    -0.00524366f, 0.00330772f, -0.00312324f, 0.02180951f, -0.07072869f, -0.00535941f, 0.03503983f, -0.03973402f, 
    0.04476424f, -0.04359952f, 0.00345897f, 0.01238262f, -0.04995285f, 0.01960419f, -0.05634101f, -0.02600433f, 
    0.03417957f, -0.02883804f, 0.11253092f, -0.00557053f, 0.05161319f, -0.02253413f, 0.04327880f, 0.08285169f, 
    -0.02373840f, 0.09755207f, 0.09185878f, 0.03171764f, -0.26506838f, -0.12292454f, 0.15485056f, 0.01920820f, 
    -0.01837042f, -0.13877103f, 0.06580087f, -0.10135832f, 0.03446349f, -0.12100294f, -0.08051735f, 0.10327439f, 
    0.10308076f, -0.01893589f, 0.03800126f, -0.04042576f, 0.00644030f, -0.00531475f, 0.00241684f, -0.07277108f, 
    0.09980359f, -0.02391068f, -0.03531221f, -0.15935226f, 0.00111570f, 0.19710204f, 0.09286023f, -0.06878898f, 
    -0.04420153f, 0.04829889f, 0.04168857f, 0.05795752f, 0.11983610f, -0.00040248f, 0.00283153f, -0.09151401f, 
    0.01535946f, 0.02868022f, -0.06341722f, 0.08240416f, 0.06909730f, 0.00083023f, -0.13790908f, -0.00851197f, 
    -0.08630217f, -0.03238826f, 0.13361619f, 0.04533159f, -0.12479082f, -0.04429974f, 0.11653329f, 0.21513557f, 
    0.07782134f, -0.02793999f, 0.19223054f, 0.00341642f, -0.03920214f, 0.15879890f, -0.16096941f, -0.00019946f, 
    -0.11798580f, -0.24898310f, -0.19969903f, 0.06897659f, 0.14472176f, 0.04958195f, 0.02781729f, -0.00169632f, 
    -0.07291026f, -0.04269841f, -0.01692539f, 0.02038094f, -0.08932722f, 0.30823570f, 0.20116533f, -0.07533085f, 
    -0.10150677f, -0.13849346f, 0.02058128f, 0.04176058f, 0.05474934f, 0.01822217f, 0.06686549f, 0.06981985f, 
    -0.05343458f, -0.08558493f, -0.10257774f, -0.12689930f, 0.12996668f, -0.05785203f, 0.02658039f, -0.06585440f, 
    -0.09542868f, -0.06275102f, 0.04458953f, 0.19693637f, -0.33389527f, 0.02047507f, 0.16200283f, 0.08609195f, 
    -0.06110865f, 0.13452259f, -0.01675040f, -0.12720300f, 0.17856389f, 0.12944067f, -0.03244844f, 0.01710427f, 
    -0.01837629f, -0.02131633f, -0.02960365f, 0.22859630f, -0.08792727f, -0.10999989f, 0.06510426f, 0.07727344f, 
    -0.00159267f, 0.05277625f, -0.03233443f, -0.11019073f, -0.28571340f, -0.04153247f, 0.05527544f, 0.17091094f, 
    -0.16854028f, 0.01175822f, 0.10222286f, -0.08377863f, 0.09440926f, -0.08263379f, 0.07133251f, 0.04449713f, 
    0.13870351f, 0.07320743f, 0.05172321f, 0.03442081f, -0.01370938f, 0.02347947f, 0.12229372f, 0.08267850f, 
    -0.05773416f, 0.04698010f, 0.08160776f, 0.13270235f, -0.07005093f, -0.13271204f, -0.12223193f, -0.04936061f, 
    0.14706412f, 0.15936248f, 0.23249823f, 0.04379017f, 0.10551375f, -0.04066195f, 0.00901702f, -0.00055353f, 
    0.06293488f, 0.04987638f, 0.01788675f, 0.16215174f, -0.01049298f, -0.04078726f, 0.11257268f, 0.03681179f, 
    0.01620754f, -0.01762050f, 0.06312371f, -0.06848696f, -0.22793253f, -0.34132710f, -0.23838323f, -0.02050320f, 
    0.00778888f, -0.06780335f, 0.01210777f, -0.08089495f, -0.02509233f, 0.04777965f, 0.14924757f, -0.00432125f, 
    0.20859985f, -0.06270970f, 0.01179536f, -0.03301641f, 0.13306950f, -0.08031975f, -0.03801514f, -0.03016306f, 
    -0.03145298f, 0.15054493f, -0.00788902f, -0.00589486f, 0.02266488f, -0.39867872f, 0.07403666f, 0.15192528f, 
    0.12703417f, -0.00691373f, 0.05212651f, 0.10465773f, 0.04177057f, -0.05963923f, 0.03223649f, 0.07322094f, 
    0.37124214f, 0.11335621f, -0.19433415f, 0.18081145f, -0.10432761f, -0.06802907f, 0.04464781f, 0.06892285f, 
    0.05964760f, 0.02597752f, -0.08762392f, -0.15103899f, -0.13687308f, 0.21328928f, 0.13530973f, -0.13904937f, 
    0.10953327f, -0.02812999f, -0.05945785f, 0.03053999f, -0.08708479f, 0.03719717f, -0.11943327f, -0.02082904f, 
    0.16778025f, 0.22954886f, -0.14454237f, 0.13131873f, 0.08028133f, 0.05640445f, -0.09059234f, -0.02275757f, 
    -0.02238453f, 0.05718100f, 0.11310516f, -0.02530778f, -0.29129273f, -0.01212286f, 0.17662163f, 0.16679642f, 
    -0.06861547f, 0.08225235f, 0.07741021f, 0.10339790f, -0.02276635f, 0.05419599f, -0.13218534f, 0.08987675f, 
    0.00296012f, -0.15948243f, -0.00871844f, 0.08644908f, 0.06586873f, -0.02292800f, 0.10379575f, -0.05904146f, 
    -0.07999713f, -0.00227027f, 0.08321709f, 0.08635888f, -0.11011224f, 0.27422237f, -0.01995409f, -0.14287871f, 
    0.09505793f, -0.01138707f, -0.04257011f, 0.04123351f, -0.07770015f, -0.03324728f, 0.08153789f, 0.05812546f, 
    0.19602294f, -0.03319957f, -0.05795417f, 0.18288209f, 0.01405790f, -0.07281698f, 0.06991056f, 0.08039075f, 
    -0.12179916f, -0.03626767f, -0.00431002f, 0.14582515f, 0.01890053f, 0.08126350f, 0.15472788f, -0.03916412f, 
    0.07253218f, 0.14920463f, -0.06048661f, -0.03694905f, 0.13161495f, -0.01719143f, -0.04114374f, -0.02308986f, 
    0.22280429f, -0.08571854f, -0.04008835f, 0.30508548f, 0.03588741f, 0.01975854f, -0.10350277f, 0.07163905f, 
    -0.00893945f, 0.03137555f, 0.08298203f, -0.12147679f, -0.35959989f, 0.08034636f, 0.07689230f, 0.03523672f, 
    0.01719131f, 0.03039765f, -0.05087933f, -0.15268716f, 0.09851243f, -0.12420706f, -0.09341839f, 0.11436442f, 
    0.00494921f, 0.01339165f, -0.08373962f, -0.02522862f, 0.04853435f, 0.00252723f, 0.08341751f, -0.06071622f, 
    -0.02561635f, -0.03431403f, 0.05234176f, 0.04277303f, 0.00962028f, -0.16957052f, 0.10674263f, 0.00963478f, 
    -0.00189787f, -0.07641185f, 0.14500928f, 0.06166345f, -0.00556837f, 0.08656674f, 0.12403192f, -0.04113824f, 
    0.05569471f, 0.13120829f, 0.12837499f, -0.04494429f, 0.10275123f, 0.06287289f, 0.05504461f, -0.01649340f, 
    -0.00647838f, 0.01671556f, -0.04306516f, 0.00603210f, -0.04557458f, -0.22538066f, -0.05292026f, 0.02850459f, 
    -0.12932742f, -0.10226418f, -0.13540347f, -0.12380752f, 0.01308778f, 0.14602664f, 0.08615792f, 0.01570503f, 
    -0.39545974f, 0.02357793f, -0.06339160f, -0.04636015f, -0.11365236f, -0.15083648f, -0.33680624f, -0.17273344f, 
    0.03313097f, -0.13586040f, -0.09930442f, -0.05371973f, 0.17369394f, 0.32797655f, 0.18476452f, 0.18311590f, 
    -0.09069838f, 0.08636849f, -0.24707066f, -0.05282854f, -0.04762692f, 0.12836519f, -0.10878857f, 0.07371819f, 
    0.25433725f, 0.11976632f, -0.05991092f, 0.10235886f, -0.02663710f, -0.08456670f, -0.05221899f, -0.31921101f, 
    0.05705802f, -0.11795997f, -0.10126349f, -0.07639169f, 0.01370543f, -0.05398432f, 0.02594811f, 0.21249665f, 
    -0.02424317f, -0.06758779f, -0.05510837f, -0.03279826f, 0.03625618f, -0.05002308f, -0.16650355f, -0.30553618f, 
    0.19018118f, 0.21405640f, 0.30920473f, 0.00409375f, 0.18572335f, 0.04739655f, 0.23122369f, -0.08269378f, 
    -0.03818335f, 0.03952230f, 0.22680607f, -0.00961127f, 0.36121705f, -0.05470922f, 0.13425648f, -0.04937250f, 
    0.11186361f, 0.22459608f, -0.13441871f, 0.10542684f, 0.10540542f, 0.03996636f, -0.03995866f, -0.00030127f, 
    0.10605384f, 0.26208973f, -0.18602651f, -0.20391642f, 0.23305540f, 0.13971165f, 0.15545124f, -0.09782692f, 
    0.03099186f, -0.04488255f, -0.13068524f, 0.00433554f, -0.04353810f, -0.15466279f, -0.00963358f, 0.21415032f, 
    -0.13432719f, 0.07033160f, -0.22261156f, -0.07929741f, -0.14384709f, -0.08247815f, -0.00946942f, -0.16135874f, 
    -0.02338274f, 0.30109835f, 0.07075785f, 0.08717610f, 0.15587369f, 0.17349446f, 0.08583285f, -0.00405913f, 
    -0.09200971f, -0.06824297f, 0.05672397f, -0.00893639f, 0.30987266f, -0.02480255f, -0.03278941f, 0.13485883f, 
    -0.05775087f, -0.19703309f, -0.04809728f, 0.02303855f, -0.22113054f, -0.09761431f, -0.18290889f, 0.16081059f, 
    -0.26738372f, 0.23689862f, 0.27813917f, -0.07597542f, -0.01635198f, 0.11118190f, -0.13315675f, -0.11575436f, 
    -0.13413490f, -0.03236403f, -0.14455059f, -0.03546973f, -0.00465500f, -0.07245349f, -0.30531797f, -0.24772713f, 
    -0.06894590f, -0.03476164f, -0.08575028f, -0.16550133f, -0.11353817f, 0.05693986f, -0.05126093f, -0.09138377f, 
    0.04688071f, -0.11421850f, -0.00462226f, 0.11181062f, -0.05876276f, -0.15089884f, -0.21388404f, -0.15649630f, 
    -0.05785377f, -0.16725878f, 0.02799350f, -0.09670637f, 0.14412174f, 0.27345642f, -0.07082468f, -0.24528357f, 
    0.07697745f, 0.09889837f, 0.00274745f, 0.03531717f, 0.12888661f, 0.14146535f, -0.11490767f, 0.14077769f, 
    0.24605042f, -0.05773226f, 0.17207256f, 0.03796945f, 0.35087782f, 0.27681625f, 0.01647969f, 0.02559308f, 
    0.22276437f, 0.01502261f, 0.06205438f, 0.08163864f, 0.28722090f, 0.48259884f, -0.19303393f, -0.50406027f, 
    0.13347861f, 0.21040031f, 0.26428288f, -0.05932195f, -0.14143068f, 0.00446565f, 0.01793955f, 0.00386116f, 
    0.05948129f, -0.03027755f, -0.05177899f, -0.02269395f, -0.07494767f, -0.07045104f, -0.01448023f, -0.03310299f, 
    -0.01955084f, -0.04350862f, -0.04850240f, 0.04324775f, -0.02600621f, -0.02831532f, -0.06078866f, 0.03643834f, 
    -0.02812446f, -0.04281485f, 0.02537112f, 0.01139430f, -0.00386015f, 0.03431659f, -0.04499822f, 0.06558435f, 
    -0.05157373f, -0.06252152f, -0.01851198f, -0.02166372f, -0.05323857f, -0.02332009f, 0.01055636f, -0.07046331f, 
    -0.06502153f, -0.01866756f, 0.05753557f, 0.04071251f, -0.04106443f, -0.06584336f, -0.00083692f, -0.07014696f, 
    0.01938186f, -0.07167722f, -0.00519676f, -0.01024387f, 0.06205666f, -0.04523445f, -0.06803064f, -0.02682743f, 
    -0.03360594f, -0.04531387f, 0.01445751f, 0.02149328f, -0.01190955f, 0.02564391f, 0.04014868f, 0.00778563f, 
    -0.06279755f, 0.01875453f, -0.05594292f, 0.02320539f, 0.00373983f, 0.04834409f, -0.03784641f, -0.00378065f, 
    -0.02721939f, -0.01171885f, 0.03800454f, 0.02590373f, -0.04578625f, 0.05633806f, -0.01806459f, 0.01432680f, 
    -0.05321168f, 0.00797656f, 0.02089802f, -0.00986506f, 0.01276814f, -0.05210746f, 0.01119864f, 0.05358790f, 
    -0.07192361f, -0.00194878f, 0.02326027f, 0.03164455f, -0.02526670f, -0.03120854f, 0.00786452f, 0.07582577f, 
    0.05751265f, 0.00044551f, 0.00589676f, -0.00888463f, -0.06929894f, 0.03280116f, 0.03686828f, 0.01702317f, 
    -0.03545219f, 0.05094165f, -0.05304675f, -0.03384537f, -0.06358530f, -0.06971443f, -0.07024260f, 0.06535608f, 
    0.06469763f, -0.00043772f, -0.02847138f, -0.04720920f, -0.00627993f, 0.01701131f, 0.05822244f, 0.06568327f, 
    -0.05254482f, -0.07363349f, -0.06229430f, -0.05152956f, 0.04424632f, 0.05082179f, 0.02427403f, -0.04054999f, 
    -0.03504827f, -0.03717714f, 0.03676740f, 0.01794862f, 0.02890896f, -0.03377720f, 0.04746030f, -0.05328171f, 
    -0.02818660f, 0.02238278f, 0.05864618f, -0.02931862f, 0.03520192f, -0.01053865f, 0.03137318f, 0.02778104f, 
    0.01101771f, -0.03735711f, 0.01715175f, 0.00711164f, -0.06534185f, 0.03692237f, -0.07258128f, -0.08011021f, 
    -0.04140284f, -0.06855851f, -0.05826351f, -0.07017084f, -0.01623377f, 0.04370647f, -0.04779495f, 0.03421563f, 
    -0.06020740f, -0.05667920f, -0.06516168f, 0.02521625f, 0.04391770f, 0.03180777f, -0.07652340f, -0.03539616f, 
    0.05233596f, 0.02389850f, 0.05401245f, -0.00153194f, -0.02400487f, 0.04287075f, -0.06832064f, -0.07031658f, 
    -0.03381246f, 0.00518704f, 0.03027115f, -0.05335284f, -0.02289549f, 0.00321776f, 0.03062948f, -0.06862321f, 
    -0.03486727f, -0.06394879f, -0.03760358f, -0.06069135f, 0.04618594f, 0.05139763f, 0.05148971f, 0.03299296f, 
    0.03209710f, -0.00291326f, -0.00575088f, -0.06308087f, -0.01728897f, -0.01437297f, 0.03337854f, -0.00704863f, 
    -0.02840429f, 0.00981619f, -0.05033721f, 0.02061422f, 0.04628677f, -0.07403613f, -0.00384789f, 0.02846865f, 
    0.06419469f, -0.03193219f, -0.06017941f, -0.05784803f, -0.00359175f, 0.00463494f, -0.06295636f, 0.00315917f, 
    -0.02341659f, -0.07166183f, 0.05634356f, 0.00587697f, -0.07273094f, 0.03001591f, -0.00105354f, -0.00017075f, 
    -0.05693517f, 0.03071449f, -0.01945033f, 0.04849818f, 0.05935915f, -0.06169345f, 0.02316667f, -0.04443242f, 
    0.00074729f, -0.00176227f, 0.03827462f, -0.07751007f, -0.04061143f, 0.06281626f, 0.02946441f, 0.04795932f, 
    -0.05207416f, -0.02380503f, 0.00309060f, -0.07716347f, -0.05251660f, 0.04117018f, -0.04291301f, -0.01096712f, 
    -0.03358795f, -0.03078405f, 0.03711737f, 0.05293712f, -0.05740531f, -0.02494675f, 0.03310190f, 0.02450765f, 
    0.06564076f, -0.06284231f, 0.03013373f, -0.05496201f, -0.01453295f, -0.06528851f, -0.06023208f, -0.04400104f, 
    -0.07504964f, 0.05867672f, 0.03458681f, 0.02038010f, 0.04904537f, -0.01365634f, -0.06485418f, -0.04733561f, 
    -0.01319237f, 0.00993176f, -0.04864005f, 0.03448496f, 0.03531191f, -0.06734449f, 0.05417642f, 0.05037244f, 
    0.00659070f, 0.03892391f, -0.04679449f, -0.02733544f, -0.07520485f, 0.02859433f, -0.01122334f, -0.04310047f, 
    0.05826391f, -0.01482101f, -0.06687102f, 0.03369623f, 0.05716505f, 0.03666633f, 0.01135553f, 0.01516261f, 
    -0.07009250f, 0.00474248f, -0.01700070f, -0.03233043f, -0.04651500f, -0.02564752f, -0.00582259f, -0.02180109f, 
    -0.02258401f, 0.01087788f, 0.00385125f, 0.04636776f, -0.04894780f, 0.04417804f, 0.05181176f, -0.07109401f, 
    -0.01423400f, -0.07699741f, 0.02328771f, 0.01278909f, -0.06486709f, -0.00091218f, 0.02572284f, -0.02087060f, 
    -0.00113816f, -0.00976583f, 0.01927830f, -0.07093251f, 0.03437143f, -0.03136221f, -0.04647245f, -0.07608455f, 
    -0.05773957f, 0.06487782f, 0.04969149f, -0.05097799f, 0.01459122f, 0.01474762f, -0.06113028f, -0.05461370f, 
    0.02849324f, -0.06088655f, -0.05906840f, -0.00530218f, 0.00938535f, 0.02609571f, 0.00969030f, -0.01337747f, 
    -0.05858772f, -0.05118632f, -0.04325168f, 0.00353235f, 0.04008703f, 0.04400471f, -0.01535835f, 0.02092559f, 
    0.05315320f, 0.04209533f, -0.00990513f, -0.02746116f, -0.04095140f, -0.05542865f, -0.03201394f, 0.02917359f, 
    -0.02932829f, 0.05405566f, -0.02484947f, -0.05107862f, 0.04683844f, -0.01769929f, -0.07811560f, -0.02591281f, 
    -0.03179064f, -0.00486313f, -0.01319728f, 0.03041386f, -0.07501375f, -0.01106276f, 0.00295251f, 0.03897256f, 
    0.04227349f, -0.06458851f, 0.03541806f, 0.02809780f, -0.02945542f, 0.00509537f, 0.02016328f, -0.00373482f, 
    -0.01869684f, -0.06483363f, -0.04220653f, 0.05766739f, -0.05980400f, -0.01194847f, -0.02334500f, 0.04978519f, 
    0.05191288f, -0.06786581f, -0.02025189f, -0.02449886f, 0.03595207f, -0.03792575f, 0.05854555f, -0.03102752f, 
    0.03807104f, -0.07573515f, 0.02710618f, -0.05010251f, 0.01526954f, -0.07449816f, -0.04150124f, -0.07851592f, 
    0.00977734f, 0.02661957f, 0.03389832f, -0.04586107f, -0.00812760f, 0.02410967f, -0.04405937f, -0.04691811f, 
    0.03605423f, 0.05284468f, 0.03591893f, 0.04011488f, -0.02327173f, 0.04794297f, 0.06096051f, -0.01374849f, 
    -0.06141398f, 0.00917814f, -0.06437096f, 0.05441874f, -0.08274982f, 0.04864211f, 0.05367993f, 0.00179892f, 
    0.00463933f, 0.04548590f, -0.08249206f, -0.04274635f, 0.06167447f, 0.01442251f, 0.05041295f, -0.05495201f, 
    -0.00158490f, 0.04701208f, 0.01517630f, -0.07181776f, 0.01931910f, -0.05950074f, -0.04879197f, -0.01746100f, 
    0.03459503f, 0.03761891f, 0.03426336f, -0.01902309f, -0.05616184f, -0.03226684f, -0.06241347f, 0.05440686f, 
    0.04680009f, -0.03258698f, -0.02232747f, -0.02643861f, -0.04295244f, -0.05053663f, -0.03185933f, -0.06111364f, 
    -0.07002339f, -0.07222141f, -0.05834939f, -0.04963387f, -0.06717266f, 0.05802124f, -0.05542789f, -0.00622347f, 
    -0.03178575f, 0.00603300f, -0.07179342f, -0.05787993f, 0.05572510f, 0.04910329f, -0.02205878f, -0.02444088f, 
    0.04444253f, 0.04316428f, 0.02454770f, -0.00354978f, 0.02799937f, -0.01831384f, -0.06846148f, -0.02003862f, 
    -0.04191805f, 0.05089807f, -0.01433043f, -0.00058143f, 0.03204286f, -0.02396056f, -0.03336153f, -0.05562527f, 
    -0.06595862f, 0.01701224f, 0.00134621f, 0.02037486f, -0.04065343f, 0.01855893f, -0.02608602f, 0.02665837f, 
    0.00637109f, 0.05270461f, 0.05139111f, 0.01425096f, -0.04536379f, 0.01826694f, 0.05723521f, -0.02135392f, 
    0.00839143f, 0.02795340f, 0.06529260f, -0.00815453f, -0.07094172f, -0.05779198f, 0.04070023f, 0.00684447f, 
    -0.05990589f, -0.01358261f, 0.00845303f, 0.00982502f, 0.04787778f, -0.07827850f, 0.02014982f, -0.01408718f, 
    -0.01386678f, -0.04746608f, -0.07671198f, -0.06890672f, -0.04676440f, -0.06225597f, 0.01379610f, 0.01458626f, 
    0.01106753f, 0.05287746f, 0.04756990f, 0.04136733f, -0.00226295f, 0.06058676f, -0.01348708f, -0.01234085f, 
    -0.02271682f, 0.01845717f, -0.06260492f, 0.06757775f, 0.01780603f, -0.03192092f, -0.02160451f, -0.06156622f, 
    0.03400902f, -0.05360331f, 0.02036124f, -0.04949922f, -0.06779294f, 0.01714084f, -0.04620624f, 0.05464400f, 
    0.04842127f, -0.04543784f, -0.04886856f, -0.04453007f, -0.05834692f, 0.05683212f, 0.00698436f, 0.05071007f, 
    0.01730813f, 0.05416441f, -0.02122648f, 0.04052302f, -0.04304709f, 0.00133620f, -0.03371489f, -0.02902852f, 
    0.05634281f, -0.01912994f, -0.02874649f, -0.02929537f, -0.00673602f, -0.02200736f, 0.04000720f, -0.05347076f, 
    0.22660719f, -0.03712431f, 0.10329914f, -0.17932694f, 0.05314080f, 0.08418893f, -0.04912652f, 0.05787134f, 
    -0.00668785f, 0.09673180f, -0.11807925f, -0.08489725f, 0.19908237f, 0.03646317f, 0.00763295f, 0.05180790f, 
    -0.14931403f, -0.02805701f, 0.03196053f, 0.09501462f, -0.06359676f, 0.00019482f, 0.00507782f, 0.10115006f, 
    -0.23734316f, -0.06147643f, -0.15480743f, 0.42457953f, -0.08961818f, -0.15315580f, 0.07786972f, -0.08644196f, 
    0.06998342f, -0.03703198f, -0.17733563f, -0.17174534f, 0.19429372f, 0.14621794f, 0.15813956f, 0.06554420f, 
    0.03913328f, 0.06606644f, 0.00851868f, 0.04934293f, -0.06480914f, 0.08669597f, -0.16597159f, -0.05396299f, 
    0.37127724f, -0.02163180f, -0.07417130f, 0.09924016f, -0.06697989f, -0.03120415f, 0.12380856f, -0.11945532f, 
    0.03210974f, 0.22271907f, 0.12695949f, 0.14170960f, 0.06651133f, -0.05843658f, 0.10006715f, 0.04825437f, 
    -0.05074095f, 0.08432642f, -0.02611616f, 0.20980425f, 0.04711179f, 0.10157373f, -0.03848162f, 0.06744698f, 
    -0.07410214f, -0.06763390f, -0.06120546f, 0.16791280f, -0.04852615f, -0.03013411f, -0.01651588f, 0.02278280f, 
    -0.06525102f, -0.11124987f, -0.03853654f, 0.08779322f, 0.00752199f, 0.03451215f, -0.07503247f, -0.16454810f, 
    0.26576370f, 0.05881668f, -0.02094290f, 0.08066444f, 0.08470447f, 0.01977757f, 0.01771228f, 0.05770276f, 
    0.11747812f, -0.05661386f, -0.16341415f, 0.05725359f, 0.05895945f, -0.00168265f, 0.03016897f, -0.08107723f, 
    0.08156383f, 0.11922925f, 0.22837128f, 0.02324100f, 0.08186395f, 0.29231918f, 0.11957544f, -0.22425784f, 
    -0.04936449f, 0.35643488f, 0.04742031f, 0.00264938f, 0.03314236f, -0.03924505f, 0.05785840f, -0.05480874f, 
    0.31416705f, -0.32324490f, 0.05772522f, 0.17848608f, -0.04349325f, 0.07684700f, -0.02401323f, 0.06685612f, 
    -0.06081908f, 0.03003826f, -0.06281000f, -0.10584950f, -0.09628410f, -0.06329370f, 0.22215018f, -0.01912932f, 
    0.10103884f, -0.00036551f, 0.05919127f, -0.01697609f, -0.07926003f, -0.06788045f, -0.01756803f, 0.02909265f, 
    0.01450428f, 0.09928311f, 0.03940427f, -0.05205780f, -0.01312457f, 0.05674370f, 0.12668623f, 0.02727897f, 
    -0.01841751f, 0.10054363f, -0.04370576f, 0.04190845f, -0.10752247f, -0.20057191f, 0.00617924f, 0.19728509f, 
    -0.07333089f, -0.01380229f, 0.15816885f, 0.14082700f, -0.01190418f, 0.11976109f, -0.06223991f, 0.05922083f, 
    -0.09228412f, 0.03999766f, -0.15636580f, 0.07723221f, -0.07141501f, 0.00081486f, 0.01470530f, -0.13772668f, 
    -0.07744107f, -0.08674547f, -0.00661429f, 0.02393300f, -0.30111831f, -0.18427861f, -0.07577771f, 0.21549456f, 
    -0.09055148f, -0.01955329f, 0.03025688f, 0.00048740f, -0.02566027f, 0.02668121f, 0.04964540f, 0.13306740f, 
    0.01223027f, -0.02081047f, 0.03439391f, -0.01043611f, 0.00176043f, -0.03413665f, -0.02684527f, -0.05239968f, 
    0.00088417f, -0.02393433f, 0.06202869f, -0.03206582f, -0.06161698f, -0.06152726f, -0.06892416f, -0.06044322f, 
    -0.00670160f, 0.01756165f, -0.05634555f, -0.07820117f, 0.04694424f, 0.01710382f, -0.00316294f, -0.06061043f, 
    0.03882613f, -0.01586691f, 0.02401279f, -0.05769473f, -0.01329130f, -0.07049900f, -0.06659712f, 0.05166949f, 
    0.02513927f, -0.00135363f, 0.01324552f, 0.03492897f, -0.07196879f, -0.03857622f, 0.04065948f, -0.02432974f, 
    -0.01566651f, -0.05334067f, -0.06076931f, -0.00352985f, 0.02850205f, -0.05227792f, -0.03515792f, 0.03071235f, 
    -0.03237214f, -0.03563415f, -0.01264733f, -0.03896429f, 0.01711804f, -0.00636780f, 0.04040111f, -0.03850216f, 
    -0.02902616f, -0.05386402f, -0.01544826f, -0.02246140f, -0.03716473f, -0.06120179f, -0.06115667f, 0.00700973f, 
    -0.06546403f, 0.01511153f, -0.03114232f, -0.01661026f, -0.00661963f, 0.04013529f, 0.05393640f, -0.07031982f, 
    0.02362379f, 0.01688886f, 0.05620970f, -0.00307966f, 0.06457938f, 0.06620969f, -0.02657073f, 0.03485342f, 
    -0.01855890f, -0.00590322f, 0.03808444f, -0.03495882f, 0.05011986f, -0.04269847f, 0.05452902f, -0.07493544f, 
    -0.06521684f, 0.04512215f, 0.02987601f, -0.04970719f, 0.05495630f, -0.05852725f, -0.07424949f, 0.03261008f, 
    0.03240610f, -0.04777637f, -0.04926839f, 0.03439580f, -0.02329488f, 0.00780838f, -0.04198476f, 0.05764601f, 
    0.00154048f, -0.05869692f, -0.05686526f, 0.01340081f, -0.01427050f, -0.02637548f, 0.03107794f, 0.04671932f, 
    -0.06063486f, 0.00811938f, -0.04784811f, -0.05815721f, 0.00507949f, -0.05579606f, 0.02506161f, 0.05909938f, 
    -0.06268479f, -0.03163817f, 0.06280948f, 0.01696496f, 0.04081256f, -0.00559717f, 0.04681418f, 0.05733128f, 
    0.02245772f, -0.05872385f, -0.01161549f, -0.02349072f, -0.04361229f, -0.04380161f, -0.01895870f, 0.03104797f, 
    -0.03517678f, 0.04454536f, -0.05734055f, 0.05936712f, 0.05118078f, -0.07675322f, 0.05914333f, -0.07191229f, 
    0.01824996f, -0.05566807f, 0.04300952f, 0.06258006f, 0.02877989f, -0.06128671f, 0.06976084f, -0.06168121f, 
    0.04428608f, -0.02383945f, 0.02314011f, -0.06616291f, 0.01739395f, 0.00183920f, -0.02477019f, -0.07887080f, 
    0.04790055f, -0.06315749f, -0.04157049f, 0.01191252f, -0.00644906f, 0.06193253f, -0.06833824f, 0.02081279f, 
    -0.04227630f, -0.00271845f, -0.00261356f, 0.03683888f, 0.06384380f, 0.01766663f, 0.05173813f, -0.01850776f, 
    -0.05821277f, -0.03677816f, 0.00552783f, 0.02278642f, 0.06309807f, -0.07893083f, 0.03933806f, -0.01712587f, 
    0.00629246f, 0.02762982f, 0.03783877f, 0.05862528f, -0.04824540f, -0.02151974f, -0.04658047f, -0.00483681f, 
    0.06727683f, 0.01365116f, 0.09477613f, -0.05128607f, 0.13517846f, -0.13887767f, 0.16757485f, 0.01979737f, 
    0.00765793f, -0.04587914f, 0.00647227f, 0.10001815f, -0.06221365f, -0.07741104f, 0.06168959f, 0.32392216f, 
    0.05998662f, -0.05003964f, -0.04722474f, 0.06841761f, 0.00389080f, -0.01454386f, 0.12007519f, 0.11944750f, 
    0.40405217f, 0.12318312f, 0.13465323f, 0.18267734f, 0.03626860f, 0.09029014f, 0.08591940f, 0.05716494f, 
    0.05278041f, 0.11473633f, 0.05490633f, 0.14645703f, -0.05197806f, -0.07043058f, -0.08831953f, -0.04435584f, 
    0.13150771f, 0.05335786f, -0.00546437f, -0.04059638f, -0.09519597f, -0.02881222f, 0.13791759f, 0.15089460f, 
    -0.01409019f, 0.12874547f, 0.18769351f, 0.20627584f, 0.07301942f, 0.08642642f, 0.04265540f, 0.02269142f, 
    0.02058905f, 0.01129720f, -0.08143298f, 0.07267321f, -0.17467296f, 0.00552263f, -0.06054142f, -0.01846582f, 
    0.07596464f, 0.06488017f, -0.03887773f, -0.04854711f, -0.07229944f, -0.15419912f, 0.06658548f, 0.02461511f, 
    0.07481509f, 0.10755478f, -0.11841615f, -0.03909528f, 0.00112654f, 0.08857074f, 0.15872306f, -0.04846380f, 
    -0.13769911f, 0.10759222f, 0.05614936f, -0.03952694f, -0.32651171f, -0.10322244f, -0.06029304f, 0.01065100f, 
    -0.02333699f, 0.11626902f, -0.04160698f, -0.08368895f, 0.06144393f, -0.00572414f, -0.00297979f, 0.05599155f, 
    0.13632098f, 0.01776181f, 0.14741565f, 0.03252792f, -0.02751629f, -0.03675740f, 0.07739185f, 0.00204836f, 
    0.04455339f, -0.04346154f, -0.08021604f, -0.02145532f, 0.28612846f, 0.00730359f, -0.14926016f, 0.11560071f, 
    0.07236245f, -0.16994585f, -0.11598964f, -0.00963666f, -0.05244146f, -0.09636497f, 0.03022056f, 0.15037233f, 
    -0.18422370f, -0.08320624f, 0.01416225f, 0.14905582f, -0.00104110f, -0.00766939f, 0.01680024f, 0.08784510f, 
    0.00414724f, 0.11514720f, -0.01692827f, 0.05224479f, -0.30136260f, 0.06655901f, -0.05179033f, -0.10221691f, 
    0.03268785f, 0.09990516f, 0.09500999f, -0.01657386f, 0.16757533f, 0.05323807f, 0.16159359f, 0.04437460f, 
    -0.39176619f, 0.12659699f, 0.04469397f, -0.26848063f, -0.05624182f, 0.05916053f, -0.02874237f, -0.01303872f, 
    -0.11762071f, -0.13350189f, -0.04818872f, 0.03379844f, -0.20868962f, 0.08809782f, 0.09964926f, -0.18309416f, 
    -0.08601202f, -0.02000273f, -0.07045713f, -0.14064227f, -0.11265428f, -0.03248197f, 0.04615554f, 0.05342611f, 
    0.16257912f, -0.03511450f, -0.02022535f, -0.09030362f, 0.14513323f, 0.13257432f, -0.00501919f, -0.08949894f, 
    -0.12226088f, 0.04805729f, -0.08115941f, 0.05478480f, 0.28280514f, 0.15843594f, -0.08097115f, -0.18172657f, 
    -0.05430542f, -0.05501225f, -0.06814675f, -0.04008012f, 0.16481012f, -0.04558523f, -0.07985448f, 0.03680545f, 
    -0.13479228f, -0.08188381f, -0.12749772f, 0.05119545f, -0.05435079f, -0.00492614f, -0.01130034f, -0.01983046f, 
    0.13637203f, 0.01791411f, 0.08049646f, 0.02386048f, 0.01813212f, -0.06262033f, 0.17189063f, 0.05381925f, 
    0.14413106f, -0.02047958f, -0.10831501f, -0.06137763f, -0.01459891f, 0.08758393f, -0.02564229f, 0.00343444f, 
    0.07003873f, 0.16112626f, -0.15115860f, 0.22306068f, 0.04845419f, 0.05134237f, -0.16462204f, 0.02549137f, 
    -0.05065548f, 0.12070620f, -0.02413800f, -0.18682888f, -0.21996979f, 0.10381590f, -0.08796915f, 0.11664461f, 
    -0.02132692f, -0.02774183f, -0.10125370f, -0.00215699f, -0.06609324f, 0.09124686f, -0.03421613f, -0.19234848f, 
    0.08183072f, 0.07014808f, 0.05951650f, 0.02604687f, -0.10723412f, -0.05027353f, -0.03809853f, -0.02048945f, 
    0.12096856f, 0.03796828f, 0.13947001f, 0.01170388f, -0.04051819f, -0.00509788f, -0.02264812f, 0.09584507f, 
    -0.03847704f, 0.03776810f, 0.08424230f, 0.09952741f, -0.11607278f, 0.07173188f, 0.02199855f, 0.12100096f, 
    0.17010669f, 0.07705319f, 0.04237079f, 0.13097727f, 0.08115639f, 0.04173803f, 0.00853851f, 0.02815893f, 
    -0.06097308f, -0.06085747f, -0.08514451f, 0.03439477f, -0.13469698f, -0.04012301f, -0.31766352f, -0.34977621f, 
    0.09616034f, -0.09166099f, -0.09121557f, -0.03323489f, 0.00463794f, -0.05436270f, -0.06599048f, 0.08558530f, 
    0.30707934f, 0.12454436f, 0.10965790f, 0.05714663f, 0.07143939f, -0.01778806f, -0.04304137f, 0.10816704f, 
    -0.02167775f, -0.08868898f, 0.02796286f, 0.01294022f, 0.05587598f, -0.11643679f, -0.02808887f, -0.08865457f, 
    0.12683456f, 0.14934550f, -0.07801399f, -0.04437849f, 0.02425411f, 0.18637955f, -0.05428470f, 0.11025882f, 
    -0.08809610f, 0.01913749f, 0.08693918f, 0.06461804f, 0.17503861f, 0.04198537f, -0.09713161f, 0.11545164f, 
    0.04357710f, 0.06952390f, 0.03571863f, -0.00564213f, -0.50021607f, 0.08711470f, -0.00431433f, 0.03537798f, 
    0.03287796f, 0.06913313f, 0.01518841f, -0.02726488f, 0.20820595f, 0.14624448f, 0.04203721f, 0.09128204f, 
    -0.20200986f, -0.09495030f, -0.17467049f, -0.03627419f, 0.02907466f, 0.02347095f, -0.10469024f, -0.08798371f, 
    0.07714736f, 0.07475873f, -0.01446494f, -0.06831921f, 0.20265101f, 0.01219405f, 0.05197059f, 0.09857848f, 
    -0.03097187f, -0.03113538f, 0.11055139f, 0.14967430f, -0.02918115f, -0.03185321f, 0.01838222f, 0.05298155f, 
    0.18472798f, 0.08752740f, 0.02893738f, 0.03744006f, -0.03425201f, 0.09022719f, -0.00801595f, 0.01768508f, 
    0.02526237f, -0.09989657f, -0.06807102f, -0.04592071f, -0.13836673f, -0.09163281f, 0.15116577f, 0.00412719f, 
    -0.05186939f, 0.01634255f, 0.06395400f, 0.18075727f, -0.01550508f, 0.21275087f, 0.04956184f, -0.06171522f, 
    0.17457993f, 0.04692490f, -0.11736504f, 0.05882419f, -0.06409176f, 0.12448709f, -0.13403900f, -0.03190820f, 
    0.08459457f, 0.03519423f, 0.10285713f, 0.09555167f, 0.33929670f, 0.03606091f, -0.05812124f, -0.12554453f, 
    0.06627505f, 0.08893321f, -0.05693025f, 0.08613329f, -0.05266661f, 0.05041137f, -0.06077518f, 0.01945557f, 
    -0.29201731f, 0.14146993f, -0.17063864f, 0.03475833f, 0.03964366f, 0.05363803f, 0.04738208f, -0.02072790f, 
    -0.05256027f, 0.01148614f, -0.01390937f, -0.09717831f, 0.04746867f, 0.01959439f, 0.04954223f, -0.11054586f, 
    0.14068407f, -0.08807899f, -0.07175516f, 0.01662977f, 0.02988596f, -0.08423160f, 0.05754458f, -0.19090305f, 
    0.00078437f, -0.19600415f, -0.07892494f, -0.24057770f, 0.02236352f, -0.05108871f, 0.00297028f, 0.02476904f, 
    0.07470449f, 0.07289179f, 0.09730446f, 0.03435747f, 0.03397736f, 0.01925073f, -0.17891312f, -0.03673805f, 
    0.00858608f, -0.00619640f, 0.02579212f, 0.03298846f, 0.05903759f, 0.06511352f, 0.10697553f, 0.09151506f, 
    0.26290900f, 0.00829234f, 0.18032295f, 0.18546431f, -0.04256501f, -0.03059964f, -0.16560118f, -0.01038760f, 
    0.08032890f, -0.00115351f, -0.04192313f, 0.11590777f, 0.02622212f, 0.06428742f, -0.16421781f, -0.12467433f, 
    0.29589459f, -0.03045585f, -0.06554315f, -0.12124652f, -0.03959899f, 0.08089753f, -0.05360096f, 0.08842488f, 
    0.22246823f, -0.02097609f, 0.11309358f, 0.08219023f, -0.08822080f, 0.04932089f, -0.11066744f, 0.03025487f, 
    0.10124928f, -0.06688023f, 0.10112342f, 0.04848235f, 0.16081874f, 0.20073958f, 0.07496759f, -0.16564839f, 
    0.12062765f, 0.13608731f, 0.02259841f, 0.02521124f, 0.01710554f, 0.08975931f, 0.06546652f, -0.10194965f, 
    0.06016432f, -0.03335994f, 0.14940713f, -0.10602847f, 0.07051430f, 0.09195238f, -0.14216761f, -0.11198644f, 
    0.06162799f, 0.03278996f, 0.06230527f, 0.07752761f, -0.07748428f, -0.02558987f, 0.08183805f, 0.04900301f, 
    0.14437477f, -0.00356756f, 0.04506885f, 0.03908836f, -0.02044740f, 0.01215045f, -0.06564826f, 0.08315145f, 
    -0.02418762f, 0.03609238f, -0.06257203f, 0.07727806f, 0.15285465f, -0.03481381f, -0.08977684f, -0.03976418f, 
    -0.00716352f, -0.00747364f, 0.01595342f, -0.03898779f, 0.37955219f, -0.18079221f, 0.11152486f, 0.12397833f, 
    -0.10748255f, -0.09843970f, 0.04267998f, 0.28193709f, -0.06772729f, -0.01341278f, 0.06953880f, -0.09365360f, 
    -0.13375665f, 0.05970425f, -0.02202008f, -0.12682512f, -0.04108984f, 0.05360677f, -0.12064750f, -0.18931578f, 
    0.08123720f, -0.01251998f, 0.03925226f, -0.18492648f, 0.04818733f, -0.02102163f, 0.13554503f, 0.09798852f, 
    -0.02809921f, 0.12712906f, 0.14732264f, 0.24078028f, -0.05566164f, -0.02389469f, 0.06601105f, -0.11854562f, 
    -0.20603572f, -0.06453636f, 0.04476975f, -0.14122219f, 0.03853147f, -0.05338677f, 0.07705548f, 0.00066753f, 
    0.06710281f, 0.00320359f, 0.05477120f, 0.10540486f, -0.10273595f, -0.16278957f, 0.29523844f, 0.09761757f, 
    -0.11914720f, 0.12079524f, 0.06840416f, -0.08081805f, 0.10026360f, 0.01556702f, 0.00085517f, 0.06217411f, 
    0.01887668f, 0.12537377f, -0.14061937f, 0.20455259f, 0.09620681f, -0.03516259f, -0.11102173f, 0.15491857f, 
    -0.05873207f, 0.18935356f, 0.05751402f, 0.04893645f, -0.16500956f, 0.05566322f, 0.00578894f, 0.02859909f, 
    0.09844907f, -0.08542708f, -0.08774355f, -0.09678221f, 0.00699860f, -0.01519193f, 0.14485142f, 0.09740476f, 
    0.19593912f, -0.06014283f, 0.16458502f, 0.23946987f, 0.16478562f, 0.01896071f, 0.05208142f, 0.09549084f, 
    -0.10026747f, 0.06486938f, -0.08430424f, 0.05417141f, 0.15863851f, 0.00861112f, 0.06343444f, 0.05194229f, 
    0.06584607f, 0.03199649f, -0.16376600f, 0.11841786f, -0.09904283f, 0.01843756f, -0.00193065f, 0.23447430f, 
    -0.19036935f, 0.03096727f, 0.06620674f, 0.04747635f, 0.01551046f, 0.08706209f, 0.12869927f, -0.03777599f, 
    -0.02991726f, 0.02753113f, 0.02776581f, -0.01404628f, -0.21566142f, -0.08836989f, -0.10219385f, 0.10959754f, 
    0.03525119f, 0.06407037f, -0.05484667f, -0.11339504f, 0.13586402f, -0.05836440f, -0.12200655f, 0.07144693f, 
    -0.20527226f, -0.05283511f, 0.01837360f, -0.22846816f, 0.09197983f, 0.06784965f, -0.01269792f, 0.18083110f, 
    -0.00683452f, 0.10090093f, 0.08103743f, 0.09837449f, -0.13100533f, -0.30023089f, 0.09405084f, 0.20039870f, 
    0.11082776f, -0.06564600f, -0.00005200f, -0.06532262f, 0.17362201f, 0.10821456f, -0.06575199f, 0.12347773f, 
    -0.32948071f, 0.05029418f, -0.08228764f, 0.24437922f, -0.02031909f, -0.04540114f, -0.04742526f, 0.04691242f, 
    0.13547750f, -0.06957558f, 0.05367170f, 0.22392806f, -0.25895458f, -0.12272079f, -0.20896927f, -0.01271333f, 
    0.03894729f, 0.10964219f, 0.06004596f, 0.01280957f, 0.05893373f, 0.12993760f, -0.09069197f, 0.02972445f, 
    -0.27386731f, -0.15821563f, -0.08159208f, -0.05357349f, 0.16200508f, -0.06771837f, -0.09983212f, -0.14515559f, 
    -0.03198311f, -0.03547714f, 0.12051404f, -0.02723737f, -0.27764219f, 0.02157086f, 0.01145410f, -0.08166236f, 
    -0.02067992f, 0.01918571f, -0.06816010f, -0.19981170f, -0.03818211f, -0.03478674f, 0.05922005f, -0.03273149f, 
    0.19248629f, -0.06907893f, 0.14510618f, 0.15323745f, 0.03254645f, 0.07832440f, 0.04082361f, 0.00686865f, 
    0.07507222f, 0.01682249f, 0.13663602f, 0.10560156f, -0.20310821f, 0.26275066f, 0.03040985f, -0.02079882f, 
    -0.05996929f, -0.05564831f, 0.14757456f, -0.00859219f, -0.15917030f, -0.09432286f, -0.08631725f, 0.07093623f, 
    -0.36382365f, 0.24272694f, -0.05904096f, -0.02604797f, -0.06243088f, 0.19600615f, -0.09823762f, 0.06265802f, 
    0.10136610f, -0.08320192f, 0.08631815f, 0.07136398f, -0.26711640f, 0.34993926f, 0.20095408f, 0.01505483f, 
    -0.09808358f, 0.03536376f, -0.07332534f, 0.01241396f, 0.06504752f, 0.03858656f, 0.05089932f, -0.06431680f, 
    -0.07713435f, -0.00070335f, 0.16151012f, -0.01666485f, 0.13696958f, 0.08439773f, 0.09002157f, 0.01907593f, 
    -0.02220706f, 0.01177022f, 0.01457708f, 0.02841963f, 0.12568207f, 0.01144480f, 0.02147779f, 0.10419406f, 
    -0.10360552f, -0.05334462f, -0.02954119f, 0.03180170f, 0.04311681f, -0.07143822f, -0.06278361f, 0.02925459f, 
    0.11533362f, -0.12064209f, 0.23603070f, -0.11325437f, -0.09716927f, -0.03765492f, 0.11418552f, 0.05322339f, 
    0.19565454f, 0.01238592f, -0.00002838f, 0.00907649f, 0.04231145f, -0.04154349f, -0.03923734f, -0.10563465f, 
    0.00365476f, 0.08210052f, -0.04884568f, 0.10465066f, 0.04151273f, 0.09110254f, 0.14754803f, -0.02835126f, 
    0.31951603f, 0.13002425f, -0.10370895f, 0.04169867f, 0.03778136f, 0.04566256f, -0.15479578f, 0.10518929f, 
    0.03876271f, 0.07412282f, -0.06286596f, 0.04953514f, -0.08493946f, -0.16986077f, -0.12831376f, -0.11354391f, 
    0.05343285f, -0.02782546f, -0.04890133f, 0.00345602f, -0.05046823f, 0.13954589f, 0.08767872f, -0.07614032f, 
    0.16088955f, 0.09773734f, -0.18215525f, 0.11531664f, -0.10896252f, 0.10000448f, -0.00801587f, -0.03929923f, 
    0.08202450f, -0.05163285f, -0.07080880f, -0.07449957f, 0.05323333f, 0.02588957f, 0.15128094f, -0.01822044f, 
    -0.03458030f, 0.04926566f, 0.05267993f, 0.12170720f, 0.07043352f, 0.01850365f, 0.01026294f, -0.04542931f, 
    -0.27035657f, -0.29777980f, 0.25942707f, -0.15413448f, 0.05177474f, 0.05405249f, 0.01786026f, 0.10177807f, 
    0.12394840f, 0.00939423f, -0.10111150f, 0.03323557f, 0.06012936f, -0.09375153f, 0.08273738f, -0.04413280f, 
    0.14525656f, 0.04905233f, 0.12188985f, 0.14493404f, 0.16767852f, 0.11889288f, -0.06857073f, 0.02746072f, 
    -0.27701050f, -0.08025182f, -0.09876699f, 0.01411546f, 0.02143652f, 0.06738318f, 0.01548782f, -0.03767813f, 
    0.21554452f, 0.02280630f, -0.05462828f, 0.11897656f, 0.21638200f, -0.00150464f, -0.05492955f, 0.03008112f, 
    -0.05300438f, 0.08651413f, 0.06221249f, 0.06007612f, -0.08644005f, 0.02368675f, -0.08516707f, 0.02065191f, 
    0.11126333f, -0.18403302f, -0.09927942f, -0.02808510f, -0.09789576f, 0.00131694f, -0.11021407f, 0.01987578f, 
    -0.00808787f, -0.06974880f, 0.05492588f, -0.01751887f, -0.09106941f, 0.02936104f, 0.12666586f, -0.01429422f, 
    0.05867223f, 0.05123726f, 0.04401179f, 0.23012617f, 0.12164522f, -0.02812369f, 0.01043082f, -0.01279682f, 
    -0.02712259f, -0.00289495f, 0.01299885f, -0.10942352f, -0.09101235f, -0.07574137f, -0.00093634f, -0.05864799f, 
    -0.10643554f, 0.03148761f, 0.03946790f, 0.04874208f, 0.01276832f, -0.03449909f, -0.01512322f, -0.02297164f, 
    -0.04458046f, -0.06401280f, -0.04254539f, 0.02255533f, 0.02513420f, -0.02119217f, -0.09119042f, 0.04515453f, 
    -0.01719653f, -0.01540654f, 0.02163621f, -0.08378791f, -0.06197307f, -0.00888103f, 0.02126057f, 0.02616569f, 
    0.05751387f, -0.07702767f, 0.00215206f, 0.03461092f, 0.01086140f, -0.02003901f, -0.01371730f, -0.06171392f, 
    -0.07582086f, -0.05532953f, -0.02363104f, -0.06600720f, -0.01727628f, -0.06088106f, 0.03994885f, -0.04700366f, 
    0.01410468f, 0.07288951f, -0.05689442f, -0.00151658f, -0.06418789f, -0.05334961f, -0.01775289f, -0.04334661f, 
    -0.08015341f, 0.02002008f, 0.01080271f, -0.01011906f, -0.05381142f, 0.02225210f, -0.07035786f, 0.04467932f, 
    0.02276258f, -0.08594426f, -0.08387693f, -0.06802610f, -0.05036724f, -0.03449892f, -0.04255356f, -0.06664564f, 
    -0.01838216f, -0.05505684f, 0.02099616f, 0.03880451f, -0.05098461f, 0.01549768f, -0.02387524f, -0.07385270f, 
    -0.03434643f, -0.03882674f, 0.03105072f, -0.03587577f, -0.08373958f, 0.02722997f, -0.00429636f, 0.02066701f, 
    -0.07134522f, -0.09207904f, -0.06235330f, -0.01930157f, 0.02005817f, -0.06701505f, -0.05089720f, -0.00516936f, 
    -0.01298732f, -0.04692573f, 0.01150906f, -0.03671974f, 0.01012217f, -0.03206131f, -0.07416324f, 0.01636619f, 
    -0.07960758f, 0.06166776f, 0.03862564f, 0.00771555f, 0.04063649f, -0.06840712f, 0.00822500f, 0.04421396f, 
    -0.00399999f, -0.06019237f, -0.02817642f, 0.06062542f, -0.01201185f, -0.00795060f, -0.07411619f, -0.09402370f, 
    -0.02942167f, 0.00718446f, 0.03078177f, -0.02252750f, -0.07883152f, -0.00219055f, 0.04153166f, 0.00618736f, 
    -0.06052196f, 0.03882927f, 0.04001745f, 0.01451377f, 0.01761009f, -0.01572868f, -0.04712921f, -0.01260333f, 
    -0.05827010f, -0.07969832f, 0.00201522f, -0.04758881f, 0.04103821f, -0.04797659f, 0.03513277f, -0.00912081f, 
    0.01415960f, -0.05741953f, 0.00898805f, -0.04216838f, -0.03521111f, 0.02997640f, -0.01163342f, 0.04025857f, 
    -0.00579561f, -0.08657409f, -0.02839611f, -0.08439926f, -0.08412076f, -0.08171637f, 0.00352585f, -0.02991824f, 
    0.03922553f, 0.04094508f, -0.09818096f, 0.04577322f, -0.01052582f, 0.03445348f, -0.01275572f, 0.02411220f, 
    -0.00753424f, -0.05661927f, 0.02090913f, 0.00560434f, 0.03095971f, 0.05999322f, -0.06689353f, -0.02731164f, 
    -0.03108863f, 0.01116380f, -0.04517617f, 0.00177835f, -0.07061262f, -0.01284857f, -0.01839233f, 0.03918127f, 
    0.02066834f, -0.01606115f, 0.03173611f, 0.02857564f, -0.08803968f, -0.05803299f, 0.05394479f, 0.00382949f, 
    -0.04696726f, -0.06528544f, -0.04824785f, -0.05250429f, 0.05605863f, -0.04308005f, 0.04305537f, 0.03851530f, 
    -0.00015506f, 0.05152577f, -0.05550410f, -0.00299674f, -0.03599767f, 0.03939580f, -0.05545094f, 0.00526569f, 
    -0.04772288f, -0.06519893f, 0.05887514f, 0.04744277f, 0.06562536f, -0.05794000f, 0.01566949f, 0.03028142f, 
    0.04021464f, -0.03687797f, -0.05770544f, -0.06638090f, 0.01363173f, 0.05707957f, -0.05885798f, -0.00778984f, 
    0.03216767f, -0.03941038f, -0.07528176f, -0.05288991f, -0.01760084f, -0.01692402f, -0.03489438f, 0.02065591f, 
    0.00326758f, -0.07472352f, 0.00478752f, 0.02887540f, 0.03337621f, 0.02369640f, -0.03132726f, 0.03306675f, 
    -0.00884729f, -0.00218873f, -0.07628736f, -0.05697184f, -0.05716138f, -0.01938231f, -0.01120219f, -0.06629562f, 
    -0.00231065f, 0.05720140f, -0.01806018f, -0.06131862f, -0.06489877f, -0.03612684f, -0.02612704f, -0.05664124f, 
    -0.04750182f, -0.05306713f, -0.07763720f, -0.03322316f, 0.04701400f, -0.07451431f, -0.03512050f, -0.00554918f, 
    -0.05215922f, -0.02866979f, 0.03611785f, 0.01382330f, -0.03309557f, -0.06289104f, 0.03036692f, 0.02699621f, 
    0.04034583f, 0.00035293f, 0.02213000f, -0.02609446f, 0.05627308f, -0.06455948f, -0.06648193f, 0.00604185f, 
    0.03512568f, -0.06088430f, 0.01981402f, -0.06456570f, 0.04057249f, 0.04217771f, -0.03148239f, 0.06168196f, 
    0.03675022f, -0.05281056f, -0.05408793f, 0.05113639f, 0.03298155f, -0.03663698f, 0.06421752f, 0.02514111f, 
    0.04982080f, 0.01728207f, 0.05337516f, 0.02685010f, -0.03492556f, 0.01760429f, 0.05338372f, 0.02819691f, 
    0.05980054f, -0.03518031f, -0.04826374f, -0.04638745f, 0.00388744f, -0.02509318f, -0.00428405f, -0.00016975f, 
    -0.07049268f, 0.00146647f, -0.00175905f, -0.01526771f, 0.02448549f, 0.01639551f, -0.06722028f, 0.03973751f, 
    0.05550983f, -0.04007238f, 0.03748272f, -0.05139103f, 0.03196448f, -0.00281848f, -0.06513486f, -0.07738604f, 
    -0.00656008f, -0.05011583f, -0.00290969f, 0.02618282f, 0.05592880f, 0.00388504f, 0.02528728f, 0.00509157f, 
    0.01079811f, -0.02950083f, 0.04597967f, -0.05296882f, 0.00783838f, -0.02062163f, -0.07286865f, 0.00489232f, 
    -0.03144296f, -0.05162157f, -0.03035188f, -0.01029011f, -0.03255826f, 0.03266367f, -0.05302205f, -0.00541278f, 
    -0.02442137f, -0.06805185f, -0.04400135f, 0.02736037f, 0.00870468f, 0.01453691f, -0.07660168f, -0.04078094f, 
    -0.07296290f, -0.00890550f, -0.01954995f, 0.03437296f, -0.05112920f, -0.06231296f, -0.05273715f, 0.02673903f, 
    -0.03576044f, -0.05305053f, -0.05619299f, 0.06598645f, 0.04608398f, 0.04219722f, -0.06924154f, -0.00315553f, 
    0.04792652f, -0.04608989f, -0.00665176f, -0.03598697f, 0.00787416f, -0.04458097f, -0.00155356f, 0.02918393f, 
    0.21963595f, -0.12771977f, 0.11934523f, -0.25594145f, 0.03105446f, 0.09208985f, -0.06459147f, 0.13570775f, 
    -0.02206777f, 0.04908064f, 0.04318028f, -0.07420828f, 0.04872350f, -0.02960368f, -0.02658429f, 0.10082622f, 
    -0.15066342f, -0.09592833f, 0.08825779f, -0.02142495f, -0.06986202f, -0.09960373f, 0.04307105f, 0.04582743f, 
    -0.01484383f, 0.01360206f, -0.17323300f, 0.40430698f, -0.05650135f, -0.01891712f, 0.02056979f, 0.01605510f, 
    0.00539524f, -0.07030597f, -0.06067878f, -0.18318523f, 0.25309789f, 0.02501579f, 0.18088694f, 0.16692519f, 
    -0.06577443f, 0.15360962f, 0.05223095f, 0.04081282f, -0.05301073f, 0.08213980f, -0.13890325f, -0.08112747f, 
    0.29091838f, 0.10591334f, -0.06015394f, 0.16498707f, -0.11562365f, -0.02945564f, -0.03575094f, -0.09909381f, 
    -0.00045816f, 0.03681801f, 0.28825021f, 0.23536304f, 0.22629064f, 0.05064105f, -0.01214774f, 0.28683621f, 
    0.03281695f, 0.09033090f, 0.12491248f, 0.18036856f, 0.02192892f, 0.11976296f, -0.03387093f, 0.07544212f, 
    -0.20368600f, 0.03453775f, 0.01210362f, 0.11613847f, 0.02287537f, -0.02436442f, 0.01076262f, 0.06752647f, 
    -0.08530978f, -0.08120558f, 0.09707897f, 0.06400125f, 0.13201918f, -0.09381603f, -0.03904308f, -0.14946607f, 
    0.00626434f, -0.01769411f, -0.05705059f, 0.03413266f, 0.12287447f, -0.00813153f, 0.11729140f, -0.00945088f, 
    0.00463287f, -0.02854791f, 0.14542229f, -0.15184805f, 0.02611491f, 0.07117444f, 0.03763592f, -0.08711491f, 
    0.00853821f, 0.08585165f, 0.14900480f, -0.00042776f, 0.08477400f, 0.16868594f, -0.02798313f, 0.02806060f, 
    0.09775548f, 0.21746868f, -0.18970996f, -0.01510532f, 0.12747748f, 0.06136280f, 0.07220062f, 0.03731555f, 
    0.12696752f, -0.24770121f, -0.17290109f, 0.44263220f, -0.06852483f, 0.05340734f, 0.10518642f, 0.02223401f, 
    0.09175708f, -0.01142929f, -0.13449401f, -0.07680217f, -0.18506986f, -0.06770140f, -0.01526009f, 0.05236229f, 
    -0.02398663f, 0.13613638f, 0.04802456f, -0.06942035f, 0.03761455f, 0.01994098f, 0.02953405f, -0.03566296f, 
    -0.11465535f, 0.03503143f, 0.05848227f, -0.21580130f, -0.01963363f, -0.05910487f, 0.07841849f, 0.08218300f, 
    0.06264790f, 0.10438797f, -0.00421384f, -0.01356922f, -0.35890761f, 0.02885589f, 0.08588578f, 0.13713467f, 
    0.00107267f, -0.03956298f, 0.21033756f, -0.10909460f, 0.04423495f, 0.15324311f, -0.07233967f, 0.04705998f, 
    -0.02136482f, 0.09721932f, 0.04343051f, 0.08243489f, -0.15094486f, -0.11983534f, 0.05827205f, -0.10904981f, 
    0.02867351f, -0.18653268f, -0.01000634f, 0.03090992f, -0.20735034f, -0.10876132f, -0.16902083f, 0.04716955f, 
    -0.10355294f, -0.01175707f, 0.02182313f, -0.02414242f, 0.02053731f, 0.12660487f, -0.04188678f, 0.07208798f, 
    0.06976752f, -0.01589338f, 0.03691701f, -0.19412589f, -0.11797526f, 0.21073660f, -0.06477028f, 0.20921201f, 
    0.18412189f, -0.01098719f, -0.00862059f, -0.03632823f, -0.35422847f, -0.06743081f, 0.18596983f, -0.07244799f, 
    0.03239747f, -0.05649398f, 0.02859110f, -0.04280258f, -0.13423038f, -0.09779067f, -0.02930701f, -0.05352629f, 
    -0.28157264f, 0.10703934f, 0.08903461f, -0.12599966f, 0.01481499f, 0.04642100f, 0.11629555f, 0.14607264f, 
    0.02751779f, 0.03593598f, -0.02905589f, 0.04520590f, 0.05217004f, 0.18061985f, -0.06209353f, -0.21138518f, 
    -0.06365178f, 0.14649217f, 0.01261178f, 0.07142948f, -0.03951380f, -0.03775907f, -0.02354990f, -0.01081346f, 
    -0.12963890f, 0.14121422f, 0.00879868f, 0.11949200f, 0.01820879f, 0.02672358f, -0.11587128f, -0.05191337f, 
    0.05327563f, -0.02997953f, 0.22096665f, 0.16350055f, 0.40785107f, -0.03955131f, 0.14740005f, 0.13434288f, 
    -0.04637807f, -0.10827503f, 0.05902934f, 0.18349776f, -0.11541231f, -0.00075400f, 0.10509091f, -0.03879709f, 
    0.11721287f, 0.00523033f, 0.01119117f, -0.04250532f, -0.02196894f, -0.12602416f, -0.09009266f, 0.15331368f, 
    -0.01252215f, -0.03388771f, -0.00391207f, 0.03718922f, -0.21705046f, -0.01555262f, -0.12437355f, -0.23040557f, 
    0.12528020f, -0.07024346f, -0.00157521f, 0.09769707f, 0.13248214f, 0.00929210f, -0.01356189f, -0.02562140f, 
    0.12570077f, -0.01851783f, -0.05984113f, -0.06870756f, 0.01814079f, -0.01863808f, -0.02127304f, -0.03444766f, 
    0.14353861f, 0.02390612f, -0.03459082f, 0.00717488f, -0.31870651f, 0.10432059f, 0.06454103f, 0.02604369f, 
    -0.04632382f, 0.01871174f, 0.01364730f, 0.06253123f, -0.00263063f, 0.02892371f, -0.06661807f, 0.08476260f, 
    -0.31925079f, 0.11853518f, 0.21458213f, 0.14681467f, 0.08083483f, 0.05676628f, 0.05275534f, 0.08006129f, 
    0.01678025f, -0.05522358f, -0.13863803f, -0.14285345f, -0.14393300f, 0.13168088f, 0.02275714f, -0.04837721f, 
    0.01938055f, 0.09773356f, 0.05781928f, 0.09542344f, 0.14178196f, 0.07037129f, 0.14261654f, -0.08440096f, 
    -0.22505450f, 0.12283158f, 0.10679974f, -0.29698855f, 0.01142986f, 0.16505496f, 0.02792684f, 0.00672631f, 
    0.01944157f, 0.06789332f, 0.06672886f, 0.01192206f, -0.15038817f, -0.04879347f, -0.00063100f, 0.16803142f, 
    0.03802738f, -0.06538001f, 0.08173140f, 0.01630786f, 0.07888725f, -0.03544502f, -0.10329274f, 0.06869565f, 
    0.05491161f, -0.05643367f, -0.12176766f, 0.08912449f, 0.08891425f, -0.17027172f, -0.05956580f, -0.12202059f, 
    -0.02829516f, -0.13693312f, -0.04338814f, 0.00588809f, 0.08027970f, 0.09875242f, 0.11355559f, 0.13212425f, 
    0.07974007f, -0.05634621f, 0.10742189f, 0.21681231f, -0.01428489f, 0.11310821f, 0.02402293f, 0.08081854f, 
    -0.12815410f, 0.06970901f, 0.00151465f, 0.37113571f, 0.27739671f, 0.07351118f, -0.07057003f, -0.20209101f, 
    -0.06638023f, -0.11144438f, 0.09537414f, 0.02563304f, -0.34427246f, -0.19866423f, 0.04294122f, -0.26030418f, 
    0.11900283f, 0.08780025f, 0.18325818f, 0.14234555f, 0.03817993f, 0.05645990f, -0.13855742f, 0.08700651f, 
    0.23794238f, -0.13520463f, 0.03600960f, -0.17164190f, 0.09382849f, 0.00117737f, -0.10280279f, 0.03567358f, 
    0.07803199f, 0.07373802f, 0.03319575f, -0.13064405f, -0.16377397f, 0.18936728f, 0.00071124f, 0.08395529f, 
    -0.00439631f, 0.16093102f, 0.05475398f, 0.14199562f, 0.09584618f, -0.06956223f, -0.05027065f, -0.12807634f, 
    -0.19626719f, -0.12145582f, -0.00572948f, -0.26427779f, 0.00026066f, 0.03257031f, 0.14779165f, 0.17007609f, 
    -0.07787398f, -0.10222653f, -0.11688215f, -0.16486509f, -0.16648667f, 0.04416892f, -0.03024495f, -0.20159186f, 
    -0.20805436f, 0.03058917f, -0.09753557f, 0.04949706f, 0.26344466f, 0.06430645f, -0.03504230f, 0.06570747f, 
    0.19195725f, 0.02410561f, -0.09892420f, -0.09047553f, -0.19538936f, -0.09124271f, 0.05113750f, -0.20424703f, 
    0.03524322f, -0.05391891f, -0.16278388f, -0.05397746f, -0.01078720f, 0.19346201f, 0.06955095f, 0.23306182f, 
    0.12509969f, 0.18351424f, 0.08199465f, -0.01737203f, -0.17985275f, -0.07454443f, -0.00611765f, -0.08474383f, 
    -0.06788907f, -0.03001548f, -0.27656692f, -0.13279705f, -0.17936388f, 0.05438967f, -0.02422044f, 0.05327804f, 
    -0.15423928f, 0.07407748f, -0.07582372f, 0.02005235f, -0.04389712f, -0.20937912f, 0.02178637f, -0.13500112f, 
    0.22541611f, 0.03143579f, 0.15571019f, -0.07267480f, -0.03499331f, -0.06301109f, -0.02663614f, 0.05134868f, 
    0.13173284f, -0.23130433f, 0.09707718f, -0.31718001f, 0.12111628f, -0.09318370f, -0.02952910f, 0.07235472f, 
    0.06040210f, 0.00040470f, -0.01163713f, 0.01035774f, -0.06128725f, 0.05425560f, 0.15142134f, 0.09499862f, 
    0.13761704f, 0.08087033f, 0.05507880f, 0.05766150f, -0.09656162f, -0.03517900f, -0.25769803f, 0.00948808f, 
    -0.01198289f, -0.07922928f, 0.08398790f, 0.43371612f, 0.19552334f, 0.16144843f, 0.11183789f, -0.01277510f, 
    0.07922523f, -0.08222260f, 0.02320306f, 0.05609164f, 0.36688867f, 0.04993019f, -0.12311117f, -0.04382348f, 
    -0.07954331f, 0.04430372f, 0.04062355f, -0.02383501f, 0.10748307f, 0.14376394f, 0.10863415f, -0.14286031f, 
    -0.17098176f, -0.22591543f, -0.43961620f, -0.50138080f, -0.03689177f, 0.08961459f, -0.03924146f, 0.18687075f, 
    0.15908340f, 0.24842083f, -0.09815247f, 0.01987528f, 0.06404705f, 0.15655231f, -0.02176135f, -0.00737793f, 
    -0.07595354f, 0.06028290f, -0.11635479f, -0.09387960f, 0.02789188f, 0.07154725f, 0.06973866f, -0.13788381f, 
    0.33043537f, -0.15280664f, 0.01792254f, 0.04501337f, 0.07700069f, -0.13546275f, 0.11049380f, -0.06355386f, 
    -0.13780966f, -0.05236604f, -0.08898526f, -0.11431697f, 0.37281355f, -0.04314110f, -0.07247145f, 0.15474512f, 
    0.08109353f, -0.01034983f, 0.07717691f, 0.00142293f, 0.02853978f, 0.05591789f, 0.06929962f, -0.00155211f, 
    0.09653356f, -0.16201957f, 0.05822797f, -0.01613062f, -0.06120152f, -0.00165512f, 0.13125060f, 0.04756977f, 
    0.07110268f, -0.07259016f, 0.09325445f, 0.14252183f, 0.13624997f, -0.07110162f, 0.02656093f, -0.01382350f, 
    -0.04731353f, 0.13310491f, 0.07994369f, 0.07024005f, 0.08983468f, 0.01893720f, -0.03387203f, 0.14521769f, 
    -0.04883750f, -0.03890995f, -0.09155883f, -0.02400677f, -0.05048572f, 0.05442839f, -0.07618698f, -0.04973953f, 
    0.04280470f, 0.06902092f, 0.10570610f, 0.03108254f, -0.05957069f, -0.08244345f, -0.02372937f, 0.09240255f, 
    0.02806011f, 0.09907407f, -0.04143760f, -0.08357202f, 0.14298211f, -0.10242978f, 0.04392091f, 0.00006433f, 
    -0.33753166f, 0.08283857f, 0.05828626f, -0.13376699f, 0.04142241f, 0.11864313f, 0.04135340f, -0.02176707f, 
    -0.07965975f, 0.08125407f, 0.12776262f, 0.09129835f, 0.41212010f, 0.06692835f, 0.17903005f, 0.25034249f, 
    0.00000991f, 0.07268483f, 0.08607205f, -0.03704364f, -0.00251161f, 0.06685390f, -0.03233051f, 0.00766876f, 
    -0.37424675f, -0.03279338f, 0.07863369f, -0.17029621f, 0.11410660f, 0.08419532f, 0.08987457f, -0.02622482f, 
    0.03093965f, 0.10576276f, 0.06624790f, 0.07094142f, 0.40130419f, 0.08184930f, -0.09696463f, 0.09181521f, 
    -0.06708966f, -0.11591820f, -0.01616722f, 0.05921870f, 0.01277089f, -0.14838114f, 0.07892264f, 0.02108389f, 
    0.18971479f, 0.07924141f, -0.20337404f, 0.07447715f, 0.01571313f, 0.05525663f, 0.01246232f, -0.00235536f, 
    0.02351302f, -0.01398228f, 0.02753125f, 0.09035645f, 0.18945144f, 0.03160403f, 0.03663696f, 0.13317144f, 
    -0.04900933f, 0.04428709f, -0.07719835f, 0.00012297f, -0.08645471f, 0.00981088f, -0.05855689f, -0.09647773f, 
    0.27892306f, 0.14597704f, 0.20747715f, -0.07536351f, -0.04445775f, 0.05307566f, -0.00092116f, 0.06051529f, 
    -0.04279028f, -0.01714731f, -0.04169549f, -0.10098939f, -0.16203974f, 0.07439390f, -0.02390419f, -0.10723028f, 
    0.03778503f, -0.01209273f, -0.02185159f, -0.13221844f, 0.12344285f, 0.06347036f, 0.03556276f, 0.07467634f, 
    -0.24292576f, 0.09081628f, -0.02282944f, -0.00356048f, -0.09099043f, 0.06283861f, 0.00858624f, 0.03686994f, 
    0.00437256f, -0.01664001f, -0.01602644f, -0.06238583f, 0.00216083f, 0.08237474f, -0.13833161f, -0.14578801f, 
    0.13308203f, 0.02790742f, -0.02221219f, 0.00663478f, -0.05214236f, -0.01085904f, -0.03276553f, 0.14233027f, 
    0.06770689f, -0.12870075f, 0.19009437f, -0.12117086f, 0.04424357f, -0.09681781f, 0.12164675f, 0.03594268f, 
    0.04344722f, 0.04513950f, -0.08267326f, -0.03374680f, 0.10361411f, 0.08208697f, -0.11125867f, 0.01117647f, 
    -0.08798731f, 0.01476892f, 0.10494399f, -0.12287357f, 0.03503849f, -0.00543690f, 0.00088906f, 0.03056392f, 
    -0.22644313f, 0.03307359f, -0.07231110f, 0.22480454f, 0.06223163f, -0.00478716f, -0.06246259f, -0.11725601f, 
    0.10042548f, -0.00898446f, 0.01062443f, 0.01663663f, 0.25073168f, -0.20480648f, -0.00775193f, 0.28642073f, 
    0.07105511f, 0.12472547f, 0.04063249f, -0.06576706f, -0.00140656f, 0.04254652f, 0.07546942f, 0.10050379f, 
    0.29297933f, -0.03846001f, 0.04443311f, 0.16247083f, -0.03371788f, -0.04674801f, 0.11310982f, -0.04601849f, 
    -0.04319561f, 0.09514515f, 0.08642036f, 0.04864493f, 0.17196013f, 0.17122982f, -0.13843772f, 0.11245566f, 
    0.12645364f, -0.07552094f, -0.07909974f, 0.05233958f, -0.01721968f, -0.07682217f, -0.09479748f, 0.03287949f, 
    -0.23387671f, -0.03419946f, -0.01119431f, 0.12177145f, -0.08045579f, 0.04318107f, 0.24339381f, 0.08356807f, 
    -0.08024006f, 0.00958518f, 0.16053534f, -0.08985640f, -0.06135107f, -0.13155101f, 0.03826120f, 0.14162455f, 
    -0.00480796f, 0.06783984f, -0.07473455f, -0.06691263f, 0.19639993f, -0.06740308f, 0.04635894f, 0.10516529f, 
    0.06904242f, -0.05540146f, 0.19609661f, -0.25517407f, 0.04547260f, 0.04247545f, 0.14633723f, -0.01707153f, 
    -0.02317956f, 0.07631854f, 0.05151189f, 0.03007468f, -0.22744358f, -0.01427249f, -0.06692971f, 0.03777494f, 
    0.18873191f, 0.20743160f, -0.06773466f, 0.04720228f, 0.16167437f, 0.00303478f, 0.06471695f, 0.02150164f, 
    0.02118528f, 0.04102970f, -0.26799524f, 0.32451901f, -0.00168651f, 0.05096193f, 0.07533049f, -0.01244049f, 
    0.13155821f, -0.02379618f, -0.06346651f, 0.00942322f, 0.10646463f, -0.13615824f, -0.03698617f, -0.07477836f, 
    -0.01910391f, 0.18195896f, 0.11296848f, -0.04273798f, -0.04163695f, -0.03223965f, 0.11699115f, -0.05434756f, 
    -0.16356149f, 0.04421222f, 0.02405008f, -0.13112022f, 0.02436053f, -0.02225623f, 0.04917153f, -0.08105606f, 
    -0.01163766f, 0.05329880f, 0.11867878f, -0.00482696f, -0.34670913f, 0.16698101f, 0.18312751f, -0.06823306f, 
    -0.02766106f, 0.03167730f, 0.09867398f, -0.16014519f, 0.17911682f, -0.00174745f, -0.04543655f, 0.07184411f, 
    -0.07373799f, 0.00118672f, 0.06320169f, 0.11099958f, -0.06021263f, -0.07879466f, 0.01979836f, -0.01826785f, 
    0.08613533f, 0.00310057f, -0.07997908f, 0.07438964f, -0.07791304f, -0.01390060f, -0.03126474f, 0.03852114f, 
    -0.31416556f, -0.04900885f, 0.01316407f, -0.06100193f, -0.11992423f, -0.09119049f, 0.01734615f, 0.02304901f, 
    0.30580184f, -0.11100188f, 0.09347557f, -0.05570998f, 0.01459471f, 0.10281580f, -0.04000616f, 0.03903344f, 
    -0.00497250f, 0.03891598f, 0.01802810f, -0.07364505f, 0.26550740f, -0.10035288f, 0.00083299f, 0.10045085f, 
    0.10527009f, -0.06818707f, -0.06102956f, -0.00421547f, -0.02562021f, -0.09035774f, -0.10761385f, 0.03449462f, 
    -0.10369812f, 0.04033444f, -0.21533194f, 0.18736954f, -0.00394978f, 0.08035009f, 0.11006960f, 0.07732486f, 
    0.02065290f, 0.04734955f, -0.12445756f, -0.09826394f, 0.20534210f, 0.04300264f, 0.08996496f, -0.10416660f, 
    0.06725699f, 0.04853821f, 0.06089895f, 0.05625720f, -0.06139287f, 0.01450459f, -0.04317044f, -0.11726157f, 
    0.08415193f, -0.00536405f, -0.11759161f, 0.03565513f, -0.08741814f, -0.06517343f, -0.14971243f, 0.01058753f, 
    0.09990507f, -0.04586067f, 0.36280513f, 0.16526176f, 0.10860019f, 0.00603551f, -0.16568862f, 0.16316049f, 
    -0.09812853f, -0.04423761f, 0.03761602f, 0.04158815f, 0.06310586f, 0.01302906f, -0.04617420f, 0.10242173f, 
    0.14529732f, 0.06628747f, 0.05324602f, 0.08182613f, -0.01200783f, 0.08981820f, -0.04112956f, 0.10146868f, 
    0.02407596f, 0.06362329f, -0.06667182f, 0.09863534f, 0.04190232f, -0.00108007f, -0.22658856f, -0.36516333f, 
    0.16382663f, -0.16315389f, 0.00254256f, -0.01148671f, 0.03830069f, 0.07080115f, 0.04343263f, 0.03514200f, 
    0.25404945f, 0.11144570f, 0.17291386f, -0.04062052f, -0.04208250f, 0.08263494f, -0.00126001f, -0.10995405f, 
    0.10604957f, 0.09431298f, 0.10755210f, -0.00998164f, 0.22989351f, 0.19165434f, 0.03942107f, -0.10795299f, 
    0.20527011f, 0.07351712f, -0.03595471f, -0.01965019f, 0.00045965f, 0.18232360f, -0.02885092f, 0.06755087f, 
    -0.08546482f, -0.05037004f, 0.03597727f, 0.19800718f, -0.05471257f, 0.04476240f, -0.08828741f, -0.06940213f, 
    -0.01041006f, -0.01903351f, -0.00065550f, 0.00682551f, -0.34609669f, 0.04397874f, 0.16685346f, 0.02370783f, 
    0.04605047f, 0.08694115f, 0.02983027f, -0.07366854f, 0.08042461f, 0.10855782f, -0.01240865f, 0.04006756f, 
    -0.22736612f, 0.06611972f, -0.05207699f, -0.21310580f, 0.05948432f, -0.05358511f, -0.08509129f, -0.06031106f, 
    0.00187173f, -0.06784863f, -0.07891093f, -0.12256390f, 0.00876779f, -0.12598905f, 0.08073094f, 0.14159028f, 
    -0.05457427f, -0.02268849f, 0.15316291f, 0.15139081f, 0.02044277f, 0.04804504f, 0.00577706f, 0.02293202f, 
    0.10634933f, 0.11953280f, -0.01036573f, -0.01878002f, -0.23638371f, -0.05326923f, -0.04503900f, -0.21034183f, 
    -0.01063349f, -0.10564673f, -0.04880790f, -0.13195240f, -0.10893866f, 0.06186342f, -0.05602231f, 0.08427625f, 
    -0.10192258f, 0.04518940f, 0.10950669f, 0.20348915f, -0.06765537f, 0.20167993f, 0.01621228f, -0.01946233f, 
    0.00045418f, -0.06187220f, 0.00774780f, 0.03479496f, -0.05863750f, 0.00439742f, 0.03946836f, -0.06436247f, 
    -0.04857625f, -0.01967788f, -0.04744496f, -0.06335691f, 0.06455670f, 0.04802295f, -0.05048624f, 0.04447093f, 
    -0.00657194f, -0.01971545f, -0.00669402f, 0.01009289f, -0.01843878f, -0.03519699f, -0.01265284f, 0.00513739f, 
    -0.06100659f, 0.05056973f, 0.00290626f, 0.03338793f, -0.00158412f, -0.03396658f, -0.03135130f, -0.06332584f, 
    -0.02298300f, -0.04522255f, -0.01736453f, -0.04057378f, -0.00958731f, -0.02257974f, -0.04618743f, 0.00806752f, 
    -0.06453600f, -0.00473946f, -0.01379936f, -0.02454123f, 0.04060119f, -0.01097067f, -0.05150947f, 0.04440817f, 
    -0.06145458f, 0.01895750f, -0.02516843f, 0.06027149f, 0.04726608f, 0.01069394f, -0.01855127f, -0.03631393f, 
    -0.06172379f, -0.05036654f, 0.02788346f, 0.00029392f, -0.03587355f, 0.05062534f, -0.06581891f, 0.04513035f, 
    0.00912094f, -0.02682031f, -0.00498523f, -0.04138140f, -0.07409556f, -0.00156198f, -0.00668823f, -0.02036860f, 
    0.06070245f, 0.02111121f, -0.03179629f, 0.04570533f, 0.01458285f, -0.05632961f, 0.02020264f, -0.06931232f, 
    0.06118080f, 0.05390120f, -0.07102139f, 0.02221167f, 0.04482662f, -0.04039201f, -0.07651936f, 0.05819242f, 
    0.06491630f, -0.04965755f, -0.02861692f, 0.03063134f, -0.05018164f, -0.02558592f, -0.04905555f, -0.04827595f, 
    -0.04217033f, -0.04456972f, -0.03432211f, -0.04174681f, 0.03100038f, 0.05152299f, -0.03147752f, 0.01936495f, 
    -0.02465145f, -0.07634054f, -0.03959665f, -0.03442118f, 0.05930427f, 0.04056301f, -0.05790364f, 0.03825454f, 
    -0.03952854f, 0.06716458f, 0.06516588f, -0.04283987f, -0.04340884f, -0.05540933f, 0.04015247f, 0.05893253f, 
    -0.04782479f, 0.01985800f, 0.03538847f, -0.02337850f, -0.07232828f, 0.05947606f, 0.02627447f, -0.00598065f, 
    -0.03072005f, 0.03027781f, -0.02019522f, -0.06728415f, -0.04563574f, -0.05946374f, -0.06961894f, 0.05850929f, 
    -0.02639818f, 0.05863999f, 0.03162718f, -0.07083344f, -0.04375699f, -0.07210867f, -0.05758316f, 0.02161844f, 
    0.02064515f, 0.00492155f, 0.06470142f, -0.06688084f, -0.02893231f, 0.01860649f, -0.05844621f, -0.03255653f, 
    0.04082678f, -0.07825264f, -0.04486633f, 0.05456427f, -0.03222059f, -0.05821914f, 0.00975972f, 0.00702655f, 
    0.05169016f, -0.00237081f, -0.00793085f, 0.01446894f, 0.06108448f, -0.07243897f, 0.03590622f, -0.00244337f, 
    0.05262723f, -0.07598013f, -0.06737864f, -0.06172193f, 0.04703377f, 0.02672385f, -0.01007436f, 0.00991746f, 
    -0.04521692f, 0.03422026f, 0.01871583f, -0.03545207f, -0.07711228f, 0.03675207f, -0.04132713f, -0.03178573f, 
    -0.06287500f, 0.03861975f, -0.00342891f, 0.04567912f, -0.07319610f, -0.03332544f, 0.04061320f, 0.01909068f, 
    -0.31955913f, -0.04553047f, 0.07472660f, -0.04100325f, 0.04963412f, -0.02840837f, -0.01707976f, 0.07197788f, 
    -0.05522026f, 0.08241435f, 0.08053533f, 0.01469172f, -0.35568628f, 0.12172133f, 0.13688356f, -0.05789927f, 
    0.03893691f, -0.11413724f, 0.04367281f, -0.02641233f, 0.12839210f, -0.11313855f, 0.10567912f, 0.09294987f, 
    0.10484942f, -0.14318053f, -0.00203629f, -0.00200479f, -0.04092378f, 0.03844989f, -0.02023440f, -0.02434575f, 
    0.04914743f, -0.08910143f, -0.06922324f, -0.07109677f, 0.05581080f, 0.14992267f, 0.12237073f, 0.11932279f, 
    -0.12683935f, 0.00449678f, 0.06008911f, -0.00137784f, 0.06316593f, -0.03464497f, -0.10301601f, -0.05792240f, 
    0.24752820f, 0.12867765f, 0.07930619f, 0.10827760f, 0.06340931f, 0.10641778f, 0.00510306f, 0.07132813f, 
    -0.07452609f, 0.01809173f, 0.00768833f, 0.01720833f, -0.12349001f, 0.09518277f, 0.16757225f, 0.04859929f, 
    -0.02538927f, 0.08780222f, 0.03611394f, 0.10281470f, -0.01581604f, 0.20557787f, -0.11095340f, 0.13455504f, 
    -0.08129705f, -0.18281326f, -0.19192599f, -0.00784775f, 0.07136583f, -0.00087777f, -0.00323874f, -0.01069038f, 
    -0.00231782f, 0.02147882f, 0.12252581f, 0.04077153f, 0.03781559f, 0.00105315f, 0.18584815f, 0.11805213f, 
    -0.15004896f, -0.04468465f, -0.04085286f, 0.06702057f, 0.01418568f, -0.05956620f, 0.13283674f, -0.04747363f, 
    -0.01315911f, 0.04101630f, -0.08126936f, -0.01797796f, 0.01688869f, -0.05161440f, 0.14985093f, -0.00302612f, 
    -0.05824783f, -0.01208862f, 0.09942000f, 0.06291869f, -0.26514786f, -0.14957494f, 0.12520610f, 0.19707131f, 
    0.06728748f, 0.06172606f, -0.04208952f, -0.06307872f, 0.05977205f, 0.03169760f, -0.00745012f, 0.04242897f, 
    0.28977278f, -0.16975124f, -0.11249655f, 0.05097260f, -0.10990711f, -0.04554957f, 0.10200672f, 0.06775399f, 
    -0.04350078f, 0.00292915f, -0.06691515f, -0.08502325f, 0.01064616f, -0.11979636f, -0.06916561f, 0.01007061f, 
    -0.00342954f, 0.00680569f, 0.10004717f, -0.03392546f, -0.02238829f, -0.07839013f, -0.12246014f, 0.12579562f, 
    0.21576215f, -0.07234702f, -0.00491702f, 0.27697814f, -0.11355411f, -0.03808703f, 0.04255876f, 0.05488610f, 
    0.11945009f, 0.04140434f, -0.00808303f, 0.12552877f, -0.11050773f, 0.03730177f, -0.06615958f, -0.06979956f, 
    0.06825691f, 0.04634553f, 0.14886531f, -0.03355617f, 0.04631994f, 0.00253648f, -0.00445143f, 0.04656056f, 
    0.02346197f, -0.08932934f, 0.11357535f, -0.06033011f, -0.09144606f, 0.00352339f, 0.15843335f, 0.12103155f, 
    0.08178438f, 0.07975912f, 0.01095598f, 0.16227996f, -0.18344146f, -0.25672802f, -0.10205735f, -0.13770141f, 
    -0.05289208f, -0.05086812f, -0.04488009f, -0.12209496f, -0.02821002f, 0.03476944f, 0.11745047f, 0.16754939f, 
    -0.13215381f, 0.22580440f, -0.18533814f, 0.20877723f, -0.11729804f, 0.10749505f, -0.07570600f, -0.13830702f, 
    0.10096452f, -0.04168714f, 0.01483406f, 0.00321632f, 0.07567221f, 0.14741732f, -0.01561065f, -0.17039271f, 
    0.03544978f, 0.04472605f, -0.01315913f, 0.07588676f, 0.01012049f, -0.05842363f, 0.01752274f, -0.04000764f, 
    0.02858545f, -0.19557536f, 0.23107964f, -0.18122233f, 0.01346555f, 0.04823207f, 0.00786597f, 0.05149413f, 
    -0.10731673f, 0.06118591f, 0.00200981f, 0.10789083f, -0.17039666f, 0.07143128f, -0.12947662f, -0.01103994f, 
    0.00700757f, -0.03018408f, 0.01724610f, 0.00722244f, 0.06506392f, 0.04010366f, 0.17190823f, -0.04735605f, 
    -0.27007616f, -0.15195659f, -0.00025738f, -0.03373101f, 0.04206550f, -0.00598573f, 0.16296573f, 0.10468679f, 
    -0.02674212f, -0.02266672f, -0.13938808f, -0.05416447f, -0.03107857f, 0.05853691f, 0.01102366f, -0.22140805f, 
    0.13107108f, 0.03439293f, 0.02926125f, -0.10383307f, 0.01252511f, -0.01309017f, 0.11383796f, -0.14169593f, 
    0.14206924f, 0.21700275f, -0.12793215f, 0.05795718f, 0.05906894f, -0.02439470f, -0.11329588f, 0.00560723f, 
    0.11379077f, 0.09593210f, -0.05852394f, -0.00067814f, 0.20949192f, -0.02670939f, 0.13427456f, 0.20821851f, 
    -0.04695956f, 0.06510518f, 0.10402638f, -0.04898696f, -0.05350169f, -0.01230019f, -0.04761618f, 0.01044135f, 
    -0.02123240f, -0.04199050f, -0.06161238f, 0.23964937f, -0.02059684f, 0.07140489f, -0.11655347f, 0.08421013f, 
    0.03483708f, 0.05016159f, -0.07775160f, -0.02367998f, 0.07943371f, 0.11090191f, -0.13347784f, 0.06159506f, 
    -0.18228102f, -0.19336089f, 0.09522217f, -0.00049865f, -0.09357850f, -0.01643477f, 0.12924694f, -0.09577820f, 
    -0.25780803f, 0.04451848f, 0.15519965f, -0.47550753f, 0.11160800f, -0.06699469f, 0.05639088f, 0.03599270f, 
    -0.05551664f, 0.08460993f, 0.04140110f, 0.03855088f, 0.21997839f, -0.03391268f, 0.05611357f, -0.04256400f, 
    0.08068572f, -0.11969353f, -0.12670222f, 0.06382809f, -0.06814398f, 0.08497860f, -0.08185045f, -0.05751339f, 
    0.19298969f, 0.09071596f, 0.01837321f, 0.13793658f, -0.02053987f, 0.10241993f, -0.00009007f, -0.06568759f, 
    0.00913433f, -0.07235880f, -0.07959492f, 0.12937000f, 0.37648305f, 0.23505090f, -0.07309224f, -0.00217254f, 
    0.05857298f, -0.01435720f, -0.16904703f, -0.01972408f, -0.05252821f, -0.09244828f, -0.04440343f, -0.09059925f, 
    0.01443587f, -0.01023214f, 0.07756677f, 0.26476133f, 0.11666816f, 0.07873511f, 0.03347768f, 0.08970851f, 
    -0.05903453f, 0.06721523f, 0.11567868f, 0.00661362f, 0.22615378f, 0.29254529f, 0.19741163f, -0.02529955f, 
    0.23230799f, 0.01862249f, 0.03418085f, 0.06041484f, 0.00337052f, -0.13245569f, -0.02597902f, -0.06896448f, 
    0.22928157f, 0.00023289f, -0.00165639f, -0.20782261f, 0.03005223f, -0.01023086f, 0.04851039f, 0.10403406f, 
    0.11205673f, -0.03003552f, -0.07808156f, 0.18230899f, 0.17406476f, -0.12786488f, -0.09188959f, 0.15835842f, 
    0.02515291f, -0.01525423f, -0.01560207f, 0.02318485f, -0.05829586f, 0.12542097f, 0.04242328f, 0.06503262f, 
    -0.15398856f, 0.28182581f, -0.08760187f, 0.20549518f, 0.04778768f, -0.03351645f, 0.01922315f, 0.06276505f, 
    0.04653063f, 0.01101274f, 0.08316606f, 0.10521013f, -0.08126546f, 0.06304998f, 0.02454223f, -0.12404996f, 
    0.15823698f, 0.04796484f, -0.05116447f, -0.00359171f, -0.06759930f, -0.00479985f, 0.14248365f, 0.09550130f, 
    0.15699247f, 0.11323111f, 0.04088973f, 0.19740272f, 0.04752780f, 0.00489545f, 0.20546013f, -0.00045821f, 
    0.01755889f, 0.02788703f, -0.00104570f, -0.00049124f, 0.01950584f, -0.05056161f, 0.01215189f, -0.11272801f, 
    0.02520146f, -0.00019746f, -0.08409737f, -0.00130300f, -0.04045714f, -0.19400069f, 0.13896205f, -0.00555488f, 
    -0.10314851f, 0.08568780f, 0.08304821f, 0.02327219f, 0.09142996f, -0.00124786f, 0.08799750f, -0.03783597f, 
    -0.00129164f, 0.07042247f, 0.07950241f, -0.09407544f, -0.32085475f, 0.07075036f, -0.10192879f, 0.04863388f, 
    0.21499082f, 0.10519071f, -0.01327644f, -0.02785284f, 0.04346782f, -0.00568295f, -0.03671376f, 0.09046578f, 
    0.14232290f, -0.09896170f, 0.16332018f, -0.00722315f, 0.04637707f, 0.01210812f, 0.10379091f, 0.02259198f, 
    0.05888658f, 0.06203659f, -0.08748394f, 0.02663779f, 0.02093735f, -0.00134017f, 0.01326985f, -0.01342261f, 
    0.02720450f, 0.05053489f, -0.06848746f, -0.07935784f, 0.07594964f, -0.07118668f, 0.02456197f, 0.00316835f, 
    -0.21084423f, 0.28819805f, 0.02514128f, 0.10861853f, 0.02479855f, -0.06156277f, -0.06803951f, -0.04771334f, 
    -0.00651608f, -0.00471716f, 0.05873215f, 0.06009442f, -0.04684841f, 0.15117286f, -0.03105739f, -0.15426968f, 
    0.04363271f, 0.08939524f, -0.02726754f, -0.08340989f, 0.03926463f, 0.03861727f, 0.11210185f, -0.10780417f, 
    -0.27674949f, -0.02762526f, 0.08154111f, -0.18378979f, 0.18177257f, 0.02317509f, -0.01964034f, -0.11693044f, 
    0.00353385f, 0.03263327f, 0.09427252f, 0.03216799f, -0.21237913f, -0.16672125f, 0.21553262f, 0.08031798f, 
    -0.15881278f, -0.13021453f, -0.12246478f, -0.06889240f, -0.05256050f, 0.11772265f, 0.02894268f, -0.01799782f, 
    0.07335515f, -0.06664605f, -0.08693440f, -0.17531773f, 0.19189775f, 0.09860401f, -0.00935386f, -0.07801134f, 
    -0.01547301f, -0.04717324f, -0.03237981f, -0.03665423f, 0.13874140f, 0.16804756f, -0.02499399f, 0.07888860f, 
    -0.04782984f, 0.01403617f, 0.02510394f, 0.05823588f, 0.06044883f, -0.08269556f, -0.02265152f, -0.01448453f, 
    0.37618002f, -0.04261139f, 0.20871419f, -0.01678626f, 0.04537852f, 0.03264064f, 0.03711940f, 0.08960581f, 
    -0.04805775f, 0.04852038f, -0.12367973f, 0.14415202f, 0.08383279f, 0.03985759f, -0.02675237f, -0.01152099f, 
    0.15334137f, 0.05206809f, 0.03278878f, 0.18398386f, -0.09342071f, 0.03806200f, -0.01609383f, 0.07168672f, 
    -0.09593726f, 0.28196916f, -0.07300396f, -0.20259187f, -0.15964516f, 0.03707011f, 0.18533897f, 0.10246900f, 
    0.14355873f, 0.06522833f, 0.11568879f, 0.08177567f, 0.02701629f, 0.28356141f, 0.16415976f, -0.13461469f, 
    0.05821041f, -0.03587975f, -0.11236121f, -0.07141940f, 0.05363857f, 0.01254566f, 0.11027268f, 0.09580237f, 
    -0.22870159f, 0.14367127f, 0.01310347f, -0.03393568f, 0.07923415f, 0.10649541f, 0.04968440f, 0.12889521f, 
    0.00850705f, 0.09620549f, -0.03374179f, 0.01091996f, -0.28545332f, -0.28394544f, 0.19630873f, -0.27083990f, 
    -0.03128861f, 0.03452113f, 0.10945870f, 0.10607563f, -0.01021568f, 0.00065649f, 0.00794182f, 0.02267062f, 
    -0.21704841f, -0.15714547f, -0.06651574f, -0.21621022f, 0.14929883f, 0.00256195f, 0.01609336f, -0.00794000f, 
    -0.06130918f, 0.06030384f, 0.04046188f, -0.02133846f, -0.05156866f, 0.26064000f, -0.10684656f, 0.01747841f, 
    0.08504327f, 0.11856406f, -0.01690102f, 0.03988174f, -0.02949042f, -0.08557648f, 0.02506788f, 0.09637877f, 
    -0.07696939f, -0.21096076f, -0.06214909f, 0.04881773f, 0.02861749f, 0.03236111f, 0.09870304f, 0.09240433f, 
    -0.01373242f, -0.00842619f, -0.02249012f, 0.11179258f, 0.16186248f, 0.07819479f, 0.03085868f, -0.11241874f, 
    -0.04774961f, -0.06209283f, 0.17795900f, -0.05603436f, -0.01857045f, -0.06086321f, -0.05924133f, -0.01682587f, 
    0.05125277f, 0.23695415f, 0.06883688f, 0.00175848f, 0.03745927f, 0.05344750f, -0.07952001f, 0.09855603f, 
    -0.16582482f, -0.02821169f, -0.06775189f, -0.09557188f, 0.08884194f, 0.21913897f, 0.01851382f, 0.00462910f, 
    0.04800441f, -0.05419372f, -0.05142400f, 0.03158756f, 0.02294182f, -0.06623447f, -0.00913477f, 0.04883904f, 
    0.05863038f, 0.07777122f, 0.24483368f, -0.08855750f, -0.06574940f, 0.14259122f, -0.03578302f, -0.10173794f, 
    -0.04756738f, 0.02606154f, 0.05411803f, -0.04215196f, -0.11844245f, -0.43854851f, -0.10968751f, -0.06944820f, 
    0.09151149f, 0.07281841f, -0.02777664f, 0.17475978f, 0.02367561f, 0.10179493f, 0.14926751f, -0.06790937f, 
    -0.25934818f, -0.12022779f, -0.09126230f, -0.31281668f, 0.21091180f, 0.01163700f, 0.07925639f, 0.03212864f, 
    -0.06494815f, 0.02985431f, -0.10090451f, -0.05278261f, 0.14715818f, 0.01458682f, -0.25669095f, -0.19829696f, 
    0.05093899f, 0.05366117f, 0.02024873f, 0.07421727f, 0.07451110f, -0.03427428f, 0.03557849f, 0.13119754f, 
    -0.09031621f, -0.02684308f, -0.14120655f, 0.06412041f, 0.04365436f, -0.03054653f, 0.01234989f, 0.00670017f, 
    -0.05390516f, -0.07536232f, 0.06603419f, -0.10932280f, 0.12714495f, 0.07139862f, 0.14715780f, -0.08533788f, 
    0.03571486f, 0.04220304f, -0.09212015f, -0.03600583f, 0.03032017f, 0.04781236f, 0.01267596f, -0.01899004f, 
    0.16529039f, -0.10302515f, 0.04516202f, 0.00358467f, -0.00321313f, -0.01116045f, -0.06033345f, -0.06541038f, 
    0.08692172f, -0.06900791f, -0.11411963f, -0.00329350f, 0.07456221f, -0.18771298f, 0.00747787f, 0.20952202f, 
    -0.02307083f, -0.13142332f, 0.08196983f, 0.08846007f, -0.01719560f, 0.02039628f, -0.01510735f, 0.01218920f, 
    -0.14693682f, -0.23633219f, 0.09145973f, -0.11664708f, 0.05134748f, -0.00959357f, -0.11379071f, -0.01705262f, 
    -0.06217963f, 0.02400956f, 0.13046405f, 0.10852478f, 0.25315917f, -0.10057022f, 0.06961069f, 0.16613205f, 
    0.08704359f, 0.01450237f, -0.03063021f, 0.06607682f, 0.25817183f, -0.00167000f, -0.11355894f, 0.07103927f, 
    -0.18408112f, 0.08146991f, 0.10826180f, 0.05230518f, 0.00389229f, 0.09991623f, -0.03444510f, -0.01488206f, 
    0.02380747f, -0.12407541f, -0.07649346f, 0.04676044f, 0.39559266f, 0.02029060f, 0.04833442f, 0.09521853f, 
    -0.08253545f, -0.11551163f, -0.01071245f, 0.08352376f, 0.07401043f, 0.06150358f, 0.13165556f, -0.11630332f, 
    -0.60671943f, 0.21996678f, 0.10915986f, -0.30397850f, 0.01015023f, 0.05847977f, 0.01711752f, -0.02316805f, 
    -0.07353786f, 0.05161986f, 0.11544852f, 0.14672519f, 0.14523847f, -0.17902087f, 0.01116842f, 0.10521138f, 
    0.11181478f, -0.09195597f, -0.19070539f, -0.14767899f, -0.02013639f, 0.09741177f, 0.01148385f, 0.18693770f, 
    0.14914666f, 0.22093761f, -0.12129495f, -0.03713593f, 0.03988457f, -0.00700976f, 0.06013038f, -0.02583144f, 
    0.16327964f, 0.00825702f, -0.09542196f, 0.15536773f, 0.10877053f, -0.05134150f, -0.12708752f, 0.00219116f, 
    0.01270324f, 0.15372495f, 0.06295843f, -0.03312596f, 0.01047632f, 0.09187931f, -0.02483521f, 0.07400127f, 
    0.20196742f, -0.06516193f, -0.07494330f, 0.24990815f, -0.06879245f, -0.10179151f, -0.08131022f, 0.00369263f, 
    0.03999908f, 0.04662919f, 0.12038992f, -0.04567312f, -0.02318087f, 0.20012262f, 0.05203413f, -0.00500430f, 
    0.03947996f, -0.00814839f, 0.05283598f, -0.10235414f, 0.06525971f, -0.02114229f, -0.12127967f, -0.05698451f, 
    -0.01036304f, 0.10320617f, 0.08892857f, 0.05808490f, -0.14561430f, 0.08326156f, -0.07521614f, 0.02726455f, 
    0.19982466f, -0.05236373f, -0.12356248f, -0.10854387f, -0.12579317f, 0.24677975f, 0.10813068f, -0.08276984f, 
    -0.01367152f, 0.00604173f, 0.08118710f, -0.04109444f, -0.14569198f, -0.11211665f, -0.12301220f, 0.09142164f, 
    -0.15129760f, -0.03921051f, -0.03216411f, 0.34466872f, 0.03789041f, -0.02938848f, 0.02234474f, -0.20916355f, 
    -0.04770466f, -0.02106608f, 0.06090257f, -0.18981925f, -0.08578129f, 0.23456283f, -0.09525122f, 0.01723569f, 
    0.05394155f, 0.02040738f, 0.03906476f, 0.12300435f, -0.02382930f, 0.03987124f, -0.03198905f, -0.04798318f, 
    0.25053117f, -0.16700400f, 0.33220917f, -0.11547113f, 0.13128915f, 0.10492060f, 0.04046796f, 0.10155218f, 
    0.01168259f, 0.05014572f, -0.05006198f, 0.17369330f, 0.30869606f, -0.06159335f, -0.09006713f, 0.09251604f, 
    -0.03410329f, -0.08437905f, -0.07240988f, -0.15916814f, 0.07737735f, -0.10809355f, 0.13955252f, 0.03105069f, 
    -0.08110835f, -0.16297518f, 0.13363373f, -0.03806986f, -0.04282259f, 0.11530973f, 0.02283005f, 0.09379993f, 
    0.25709784f, -0.08954496f, -0.27345932f, 0.01584623f, 0.02019582f, 0.08925066f, -0.27441767f, 0.06528081f, 
    0.13528749f, 0.04752871f, -0.17049231f, -0.15510325f, -0.00915227f, 0.12444677f, 0.01073179f, -0.12184233f, 
    0.34537017f, 0.15617198f, -0.18769227f, -0.07110728f, -0.01513636f, 0.01562889f, 0.02965293f, 0.02461109f, 
    0.10344044f, 0.23145793f, -0.04432366f, 0.09317585f, 0.12868212f, -0.07853916f, 0.27376324f, -0.05175901f, 
    -0.15398632f, -0.06010008f, 0.05839614f, -0.17679378f, 0.04847160f, 0.12576160f, -0.08379348f, 0.05576887f, 
    0.06330296f, 0.11025732f, 0.00628605f, 0.00721763f, 0.04060205f, 0.22467050f, -0.03201572f, -0.10027488f, 
    0.12717882f, 0.07756310f, -0.02396318f, -0.02936659f, -0.10397184f, 0.21998033f, 0.07091674f, 0.15584987f, 
    -0.07955311f, -0.26955882f, 0.03765112f, 0.02761130f, -0.08736702f, 0.04262585f, 0.15714946f, 0.02786533f, 
    -0.22415763f, -0.28780964f, -0.13661289f, -0.20301396f, 0.10045743f, -0.06895678f, 0.13296106f, -0.02890461f, 
    -0.02812354f, 0.18213116f, -0.17184722f, -0.02075814f, 0.30124488f, -0.24616629f, -0.02732738f, -0.03298937f, 
    -0.00774576f, -0.10432473f, -0.10812405f, 0.11530349f, -0.05389259f, -0.04216398f, 0.05203372f, 0.13228308f, 
    0.14588310f, 0.25064844f, 0.16317463f, -0.14153822f, -0.05650013f, -0.14843297f, -0.15121350f, 0.06589215f, 
    -0.05010217f, -0.03587747f, -0.02959582f, 0.05749162f, 0.11554565f, 0.16641818f, -0.20502049f, -0.19411702f, 
    0.04473695f, -0.02137440f, 0.01748610f, 0.02489608f, -0.04513433f, 0.02594742f, 0.02340980f, 0.05125526f, 
    -0.03146969f, 0.01260181f, -0.12762822f, 0.19451340f, -0.09034523f, 0.21799229f, -0.02742056f, -0.00327905f, 
    -0.03557176f, 0.05389631f, -0.06786542f, -0.00005671f, 0.53382760f, 0.18652871f, 0.06223358f, -0.26136065f, 
    0.01643825f, -0.03706458f, 0.01590679f, 0.01061224f, 0.16118155f, -0.04924494f, -0.05883328f, -0.08310431f, 
    0.00910673f, -0.05678023f, -0.07490677f, 0.06337415f, -0.04714488f, 0.04787969f, 0.04574570f, -0.05287798f, 
    0.04159155f, 0.01055625f, -0.02697675f, 0.03658468f, -0.00881469f, -0.05972260f, 0.00704463f, -0.04834606f, 
    0.01638153f, -0.01071670f, -0.05373233f, 0.04774395f, -0.04210346f, -0.02900726f, 0.05637520f, -0.06833746f, 
    -0.05840726f, -0.01062217f, 0.02764428f, -0.06421854f, -0.02212637f, 0.05321235f, -0.04776004f, -0.06778864f, 
    -0.02205317f, 0.04166666f, -0.00849855f, 0.01865699f, -0.04281887f, -0.00554369f, -0.00776713f, -0.06346291f, 
    -0.07571828f, -0.07759856f, -0.04989895f, -0.03556182f, -0.04765634f, -0.05265120f, -0.02734981f, -0.01710197f, 
    0.00357260f, -0.03752848f, -0.03689277f, -0.06472605f, -0.01912886f, 0.00817565f, -0.05598519f, -0.00706613f, 
    0.00361824f, 0.01173999f, 0.00909284f, 0.05219273f, 0.03321143f, 0.01164977f, -0.01447248f, -0.01422767f, 
    0.03343590f, 0.03647923f, -0.05884491f, 0.02428754f, -0.01668231f, -0.03166971f, -0.03660512f, 0.02796698f, 
    -0.06769145f, 0.02518594f, 0.01615345f, 0.04857543f, 0.03386787f, -0.01080976f, -0.03300478f, 0.03546876f, 
    0.03363657f, -0.07613255f, 0.02109089f, -0.03818756f, -0.01607640f, 0.06144252f, -0.00555905f, -0.05975356f, 
    0.03285762f, -0.04087957f, 0.04464554f, 0.00142694f, -0.05169607f, 0.03699667f, -0.06989500f, 0.03198450f, 
    -0.07940517f, 0.04683405f, -0.04387656f, -0.01865983f, 0.04621453f, -0.01473191f, 0.00467578f, -0.05061129f, 
    0.02085177f, -0.03471239f, 0.04641682f, -0.07403495f, -0.02027772f, 0.02120852f, 0.05725053f, 0.03312532f, 
    0.05258012f, -0.00341654f, -0.04758592f, -0.06177640f, -0.01839925f, -0.00371474f, -0.05528915f, -0.03815188f, 
    -0.05847148f, -0.01326006f, -0.04207657f, -0.06386941f, -0.00710532f, -0.01896533f, -0.07928119f, -0.07637322f, 
    0.04125355f, 0.01515792f, 0.04694963f, 0.00574253f, 0.06332379f, -0.07288443f, -0.01880472f, 0.00722831f, 
    -0.07444233f, -0.08001980f, -0.07012895f, -0.06077334f, 0.05031370f, -0.01016743f, -0.02441177f, 0.04797281f, 
    -0.05439296f, 0.03941729f, -0.05655631f, 0.03285896f, -0.03053886f, -0.06721652f, -0.07833933f, 0.04652307f, 
    0.00783578f, -0.01146680f, -0.02560940f, -0.06017617f, -0.00836727f, 0.02963924f, -0.04646476f, -0.01842126f, 
    -0.00116080f, -0.04649845f, -0.04629602f, 0.04413720f, -0.06979312f, -0.02455162f, 0.04908895f, -0.07084151f, 
    -0.03843264f, -0.03778654f, -0.07702655f, -0.04276994f, 0.05366051f, -0.00036627f, -0.03357954f, -0.03577620f, 
    -0.00894606f, -0.04913235f, -0.05310333f, 0.00597390f, -0.07696017f, 0.05781826f, -0.04600333f, -0.02012799f, 
    -0.07871834f, 0.02319083f, 0.06284200f, -0.00563496f, -0.03091481f, -0.01296148f, 0.04387635f, -0.00814453f, 
    0.04176838f, 0.03691867f, -0.03677230f, -0.07217990f, -0.00553429f, -0.07939228f, -0.08098384f, -0.01335704f, 
    -0.00350688f, 0.00594077f, -0.13156007f, 0.09050741f, 0.41628233f, -0.12139224f, -0.01359195f, -0.13532345f, 
    -0.08239903f, 0.05656710f, 0.15209709f, -0.02079492f, 0.13765109f, 0.15365078f, 0.07109258f, 0.09126105f, 
    -0.17925586f, -0.11189753f, -0.10041141f, 0.22142507f, -0.07807216f, -0.06942956f, -0.07175434f, -0.02639409f, 
    0.07363578f, 0.00983361f, 0.06772710f, 0.07791711f, -0.12105761f, 0.00253089f, 0.24126624f, -0.06168811f, 
    0.00967873f, 0.01357024f, -0.12226152f, 0.00591605f, 0.06258149f, 0.00119121f, 0.10937510f, 0.03432899f, 
    0.04879306f, -0.22905640f, -0.07530738f, -0.05553423f, 0.05004205f, 0.01035083f, 0.10213149f, 0.07301897f, 
    0.02226938f, 0.08486456f, -0.19588313f, -0.01780577f, -0.00392391f, -0.04415519f, 0.00492599f, -0.09799255f, 
    0.07696041f, 0.01820297f, -0.04349709f, 0.01484113f, 0.04151209f, 0.08698434f, 0.00685289f, 0.06018106f, 
    -0.28688586f, -0.01393088f, 0.09986308f, 0.05637188f, -0.02711693f, -0.05208063f, -0.00424454f, -0.00141264f, 
    0.07771891f, -0.05387177f, 0.12821104f, 0.01824302f, 0.40631178f, 0.15615784f, -0.00251005f, 0.17298354f, 
    0.19228105f, 0.04383722f, 0.02274527f, -0.08801004f, 0.02907903f, 0.10974566f, -0.15149966f, -0.00026827f, 
    -0.45654359f, -0.11365972f, -0.13148838f, -0.10617748f, 0.10987917f, -0.04930508f, 0.09612010f, 0.04563944f, 
    -0.07084534f, 0.07774810f, 0.05427428f, 0.10903038f, 0.25746822f, -0.01959384f, 0.26654887f, -0.18274570f, 
    0.08297516f, -0.05196973f, 0.05020558f, 0.01014064f, 0.06874477f, -0.07636407f, 0.13562009f, 0.01033965f, 
    0.28112817f, -0.01385993f, -0.02128308f, -0.19328228f, -0.01194695f, 0.11738150f, -0.05940984f, -0.13807039f, 
    0.05167089f, -0.07516401f, 0.09199269f, 0.11276328f, 0.16909915f, -0.00708506f, 0.10134440f, -0.07832231f, 
    0.09351905f, -0.06833412f, -0.01778435f, 0.02193656f, -0.05684466f, -0.00847479f, -0.01942563f, -0.11013255f, 
    0.26631543f, -0.00538548f, 0.01442446f, 0.15531343f, 0.16318528f, -0.03432284f, -0.03522060f, 0.10526468f, 
    0.03028877f, 0.02443155f, -0.05867844f, -0.00399713f, 0.16949691f, -0.12586941f, 0.08991314f, 0.12319129f, 
    -0.03433144f, 0.01211058f, 0.03826401f, -0.09167704f, 0.10599352f, 0.12603574f, 0.18845126f, -0.09309389f, 
    -0.19874363f, -0.01795102f, -0.05952235f, -0.04584571f, -0.03117869f, 0.11417998f, -0.07308509f, 0.05424705f, 
    0.12959656f, 0.06410141f, 0.11379127f, -0.00047829f, -0.25096408f, -0.07145705f, -0.03793199f, 0.15646707f, 
    0.07635660f, -0.03470838f, -0.00232225f, -0.11828277f, 0.04098313f, -0.15191855f, -0.02683362f, -0.06139537f, 
    0.00171833f, 0.03134792f, 0.02191905f, 0.01220452f, 0.03144626f, -0.07536048f, -0.01990297f, 0.00111611f, 
    -0.07432406f, -0.00783756f, 0.02264408f, 0.05567800f, 0.04347854f, 0.04303911f, -0.02879740f, 0.04549815f, 
    -0.00186975f, -0.04014335f, -0.03830245f, 0.02633757f, 0.05985069f, -0.01042709f, -0.03680333f, 0.02457569f, 
    -0.01488735f, 0.06000075f, 0.01473070f, -0.04991416f, 0.06378464f, 0.06025598f, 0.00116945f, 0.03476208f, 
    0.01107320f, -0.01792343f, -0.05646774f, -0.01394233f, 0.05581570f, -0.00212749f, -0.05855376f, -0.00587299f, 
    0.03428691f, -0.02794891f, 0.05906236f, -0.04275931f, 0.05651435f, -0.00215682f, -0.01637366f, 0.03351462f, 
    -0.03994152f, -0.02502473f, 0.01355344f, -0.02857760f, 0.02269352f, 0.02817026f, -0.07330714f, -0.07051749f, 
    0.02237787f, -0.03447462f, -0.06519771f, -0.07603455f, -0.03115284f, 0.02513329f, -0.00766740f, 0.05486424f, 
    -0.06111130f, -0.04385333f, -0.05723083f, -0.01520566f, -0.04144242f, 0.04111554f, -0.01096677f, 0.05993913f, 
    -0.05234510f, 0.01586490f, -0.06636330f, 0.03342444f, 0.02925850f, -0.05067617f, 0.04339812f, 0.05563889f, 
    -0.02230092f, -0.04403805f, 0.02956875f, -0.02430552f, -0.06575543f, -0.06028799f, -0.00204348f, 0.02870590f, 
    -0.07533160f, 0.06072128f, -0.04462961f, -0.02588669f, -0.02610860f, -0.02795882f, -0.05786644f, -0.02925860f, 
    -0.04015728f, 0.02020236f, -0.07189169f, -0.03148827f, 0.00805440f, 0.02636930f, -0.07396583f, 0.03391385f, 
    -0.06613392f, -0.04288211f, 0.02168018f, 0.01033291f, -0.01838454f, -0.00101652f, -0.04256252f, -0.04208981f, 
    -0.04018598f, -0.02360454f, -0.06421941f, -0.07745973f, -0.00954186f, 0.03282635f, 0.01795093f, -0.04473686f, 
    -0.02753321f, -0.05153896f, -0.04671381f, -0.04557211f, 0.01497721f, -0.04242469f, 0.04125653f, -0.05576028f, 
    -0.02291583f, -0.03505321f, -0.01463488f, -0.03086517f, -0.04547189f, -0.07660034f, -0.06924169f, -0.04052753f, 
    -0.03234932f, 0.05924363f, -0.06956252f, 0.04800430f, 0.03624672f, -0.06916849f, -0.05602150f, -0.07796002f, 
    0.00800828f, -0.04266927f, -0.00166031f, -0.05767569f, -0.03745430f, -0.00714386f, 0.03992656f, -0.05070436f, 
    -0.07291039f, -0.04561884f, -0.04767512f, -0.01190522f, -0.00094412f, 0.02316266f, -0.06537910f, -0.05263055f, 
    0.05043022f, -0.01104412f, -0.00810500f, -0.04430140f, -0.06326124f, -0.01244199f, -0.05122558f, -0.07303083f, 
    -0.00355648f, -0.04464192f, 0.01794470f, 0.05199077f, 0.02012195f, -0.03131586f, -0.04951756f, -0.02553521f, 
    0.04871995f, 0.03457724f, 0.05412811f, -0.04605980f, -0.05162653f, -0.04077611f, 0.03027265f, 0.02685751f, 
    -0.02324703f, -0.01705317f, -0.05923566f, -0.03962750f, 0.04009248f, -0.00751636f, -0.03205056f, -0.03033296f, 
    -0.44694519f, 0.10992126f, -0.03279258f, 0.12428782f, 0.05626481f, 0.02974153f, 0.01088904f, 0.05554125f, 
    0.05375546f, -0.09456385f, 0.04231117f, -0.03107283f, -0.50467449f, 0.25657362f, 0.23530655f, -0.00070536f, 
    -0.03191284f, -0.07791758f, -0.02027269f, -0.03361340f, 0.03463526f, -0.05668053f, 0.04285723f, -0.05762786f, 
    0.27923557f, -0.11512513f, 0.26016331f, -0.24600434f, 0.15522806f, 0.07641107f, 0.08145537f, 0.08754367f, 
    0.02117368f, -0.07146589f, -0.02606558f, 0.06557634f, 0.01068013f, 0.03878344f, -0.05181772f, 0.08588780f, 
    -0.13700582f, 0.03372385f, 0.12961374f, -0.01790960f, 0.11227673f, 0.00896897f, 0.01855099f, 0.12494639f, 
    -0.01585516f, 0.08946314f, 0.16377574f, -0.05190927f, -0.03278735f, -0.08049458f, 0.05671392f, 0.01083523f, 
    -0.06631970f, -0.21654780f, -0.03965044f, -0.04412895f, -0.12589957f, -0.04119829f, 0.20882659f, -0.12103713f, 
    -0.06253655f, -0.06627370f, -0.02534866f, 0.05118062f, 0.06564240f, 0.03367026f, -0.05188122f, -0.00677914f, 
    -0.06075096f, 0.07451070f, -0.17182790f, -0.18416421f, 0.03422344f, 0.01167895f, -0.05475580f, 0.08682369f, 
    -0.01017096f, 0.04493725f, 0.03155055f, -0.04607834f, 0.00868569f, -0.16358660f, 0.09297588f, 0.09508137f, 
    -0.28464797f, 0.03827729f, 0.08442368f, 0.17371760f, 0.02891880f, -0.03848401f, 0.12583350f, 0.03436686f, 
    -0.14691766f, 0.13203463f, -0.26874757f, 0.04645676f, 0.02349490f, 0.01753547f, 0.04479950f, 0.08119961f, 
    -0.09747896f, -0.00634623f, -0.00249673f, 0.08380135f, -0.13892868f, -0.22987191f, -0.07780527f, 0.22414538f, 
    -0.15741922f, -0.08354025f, -0.01771897f, 0.07749122f, 0.06261936f, -0.07132357f, -0.04043389f, 0.02788565f, 
    -0.01749347f, -0.05129497f, 0.14487199f, -0.05496223f, 0.02978584f, 0.02087840f, 0.11914167f, 0.20839709f, 
    0.03082095f, 0.04320871f, 0.00062355f, 0.04900567f, -0.00023959f, -0.00771715f, -0.13938759f, 0.01091136f, 
    -0.06557779f, -0.02904192f, 0.05688113f, 0.11754534f, 0.05335083f, 0.01874030f, 0.03555530f, 0.04059277f, 
    0.14345227f, -0.13171464f, 0.04036213f, 0.19128227f, -0.20642614f, 0.07021372f, 0.08056384f, 0.05698291f, 
    0.18549712f, 0.06464203f, 0.06767847f, 0.15770836f, -0.06070213f, 0.23937525f, -0.12851390f, -0.05065978f, 
    0.02557850f, 0.09478518f, 0.07157039f, -0.18410672f, 0.04215312f, -0.12202245f, -0.00124700f, 0.05457431f, 
    0.03593655f, -0.07413623f, 0.12301821f, 0.01961394f, 0.06616782f, 0.05666526f, 0.07088447f, 0.21617323f, 
    -0.01828104f, 0.02052837f, -0.04568614f, 0.12871535f, -0.03992794f, 0.04985727f, 0.11280937f, -0.14198889f, 
    0.18101433f, -0.03509222f, 0.00551814f, -0.10847007f, -0.04209367f, 0.03083090f, -0.01794050f, 0.07863360f, 
    -0.03583782f, 0.05727331f, 0.06235614f, 0.05124918f, 0.01636148f, 0.02552209f, 0.00712131f, -0.01322265f, 
    -0.04520079f, -0.03585390f, 0.02745391f, -0.06318580f, 0.00241470f, -0.02818695f, 0.01322115f, -0.04365237f, 
    -0.01275520f, -0.05352663f, 0.01334628f, -0.06211004f, 0.02612403f, 0.04250582f, -0.06956745f, 0.00929916f, 
    0.06360530f, 0.02345940f, 0.05561385f, -0.03119441f, -0.05084199f, -0.03058749f, -0.07327747f, -0.03113691f, 
    0.02166138f, -0.05454344f, -0.00607847f, -0.06678501f, -0.06130453f, -0.05332144f, 0.05907809f, -0.07075614f, 
    0.02518081f, 0.00117428f, -0.04560032f, -0.03842891f, -0.05494321f, 0.04832153f, -0.03795054f, -0.04429942f, 
    0.04187476f, -0.02053101f, 0.00859104f, -0.04229812f, 0.03614065f, 0.02987148f, -0.02361321f, -0.05333773f, 
    0.06379385f, 0.05787148f, 0.03994156f, -0.04091037f, 0.00363737f, 0.03181100f, -0.06028496f, -0.00489186f, 
    -0.01696662f, -0.02863270f, -0.00360741f, -0.04327986f, -0.03926677f, -0.05464396f, -0.07002283f, -0.04054071f, 
    -0.04014817f, -0.06806713f, 0.02684168f, 0.05865372f, 0.02928925f, -0.02184737f, -0.01824677f, -0.05359371f, 
    0.01561676f, 0.01047221f, 0.03431108f, -0.04874276f, -0.05536031f, 0.04195312f, -0.04154643f, -0.03871402f, 
    -0.01461107f, -0.01856211f, -0.03131049f, 0.02938889f, 0.05948664f, 0.03609053f, -0.05360029f, -0.03361417f, 
    -0.05529317f, -0.00361320f, 0.06532812f, -0.06965803f, -0.01866817f, -0.00691177f, 0.05226603f, 0.05532098f, 
    0.01711969f, 0.01085717f, -0.02658893f, -0.03008235f, 0.03594817f, -0.00851844f, -0.01409520f, -0.05142784f, 
    0.06250545f, -0.02316757f, 0.01874831f, -0.06981263f, 0.03876172f, -0.07285272f, -0.03170818f, -0.00305402f, 
    0.05750506f, -0.02051637f, 0.05263893f, 0.01450391f, 0.05464686f, -0.02404845f, -0.06578930f, 0.06284195f, 
    0.06597029f, 0.02685902f, 0.01907835f, 0.04210822f, -0.01836987f, -0.02899520f, -0.01291429f, 0.02545041f, 
    0.05849285f, 0.00093105f, -0.04601966f, -0.02786209f, 0.02555482f, -0.03677045f, -0.00534280f, -0.07405193f, 
    0.01742173f, -0.01020265f, -0.07590751f, 0.02140586f, -0.07414625f, -0.06038234f, 0.05721360f, -0.05727987f, 
    0.04909630f, 0.05982050f, -0.00835057f, -0.04773231f, -0.00787964f, -0.02451402f, 0.04755451f, 0.03030814f, 
    0.02830714f, 0.01356457f, -0.07223423f, -0.06244307f, 0.00200984f, -0.00629924f, 0.03062006f, -0.07027896f, 
    0.01385366f, -0.03404678f, -0.07445198f, 0.02510825f, 0.00434968f, 0.00707091f, -0.01066111f, 0.05364805f, 
    0.03895804f, -0.04290751f, -0.06147510f, -0.00371645f, 0.01642578f, 0.00042371f, 0.01237422f, -0.05691272f, 
    -0.07375278f, 0.04696759f, 0.03102713f, -0.00306287f, 0.01287783f, -0.03201344f, 0.00830077f, 0.03455665f, 
    -0.06544825f, 0.08974018f, -0.08560525f, 0.16307022f, -0.04220678f, -0.02662969f, 0.01603921f, -0.01283625f, 
    0.02690578f, 0.09024850f, 0.08186553f, 0.12049003f, 0.03224678f, 0.01199660f, -0.06526642f, -0.37366617f, 
    0.09809028f, 0.08931445f, 0.04685467f, -0.04783581f, 0.21240705f, 0.04429613f, -0.09020817f, 0.04973570f, 
    -0.23038886f, -0.08104564f, -0.07107936f, -0.20374319f, 0.14486194f, 0.08042054f, -0.14839582f, -0.03468873f, 
    -0.11162909f, -0.01309897f, -0.03846393f, -0.01995552f, -0.15728144f, -0.13288246f, 0.03820396f, 0.07082003f, 
    0.11038791f, -0.12359184f, -0.16694246f, -0.02232012f, 0.12613982f, -0.08176084f, 0.17213531f, -0.07032883f, 
    -0.01594913f, -0.30368614f, -0.08392490f, -0.27297750f, 0.11369603f, -0.02868587f, 0.07481567f, 0.02589175f, 
    -0.03811780f, 0.02333543f, -0.12073421f, -0.13761796f, 0.13005653f, 0.02154008f, -0.19321652f, -0.01602347f, 
    0.04712101f, -0.09616412f, 0.13178882f, -0.01696015f, -0.06778033f, 0.00882999f, 0.11456825f, -0.04204040f, 
    0.16561134f, -0.01023495f, 0.07220706f, 0.01802895f, -0.14414226f, -0.00722869f, 0.08229277f, -0.06709196f, 
    0.08316118f, 0.02519701f, 0.04193942f, -0.02356695f, 0.03343833f, 0.14302392f, 0.06002929f, 0.18194464f, 
    0.12485314f, -0.06988266f, -0.01965003f, -0.04235555f, 0.13002968f, 0.03135591f, -0.04207615f, 0.08099514f, 
    -0.04353651f, 0.00998703f, -0.05080809f, -0.21384810f, 0.02381031f, 0.04927925f, 0.05812873f, 0.00710258f, 
    0.01405261f, 0.06295013f, -0.02420644f, 0.03148791f, -0.32519278f, -0.14069261f, 0.21499249f, 0.04181915f, 
    0.26886150f, 0.05244220f, -0.01353338f, -0.13310677f, 0.16312310f, 0.12689453f, -0.01385706f, 0.11167897f, 
    -0.06477910f, 0.08715167f, -0.09239911f, -0.20034377f, -0.00063200f, 0.06647345f, -0.05771331f, -0.02500885f, 
    0.07986040f, -0.08462786f, 0.15371943f, 0.08501633f, 0.26630005f, -0.02026283f, 0.03559700f, 0.08031271f, 
    0.13452950f, 0.10905372f, -0.01321609f, 0.02221919f, -0.00718354f, 0.02473079f, -0.08069063f, -0.04720223f, 
    0.08244932f, -0.11148640f, -0.08651172f, 0.39197949f, 0.18686953f, -0.13048114f, -0.10355381f, 0.04123823f, 
    0.06421874f, 0.08878500f, 0.10875710f, -0.00673167f, 0.36360100f, 0.10997039f, 0.05055131f, 0.11007366f, 
    -0.13658370f, 0.03432688f, 0.05066074f, 0.03603951f, 0.06657026f, -0.09130547f, 0.02584843f, -0.06694134f, 
    -0.19342005f, -0.16803920f, -0.14708763f, -0.21702492f, 0.01673197f, -0.03555548f, 0.04287464f, -0.03404756f, 
    0.10888007f, 0.11179141f, -0.00937952f, -0.05130002f, 0.11861522f, 0.16964345f, 0.18928397f, 0.07118361f, 
    -0.18851040f, -0.06063849f, 0.05494998f, -0.13915443f, 0.02688294f, -0.13317019f, 0.10742302f, -0.32678878f, 
    0.07165828f, 0.14273597f, -0.13218856f, -0.07848407f, -0.09012552f, 0.07219063f, 0.01959980f, 0.13646351f, 
    0.07532090f, -0.01136751f, -0.00423371f, 0.15540162f, 0.10779714f, 0.01801480f, 0.16534321f, -0.18096155f, 
    -0.03147333f, 0.05189786f, -0.05508170f, -0.08296845f, -0.07901217f, 0.06263520f, -0.02746958f, -0.04560553f, 
    -0.24819523f, 0.14747608f, -0.02090769f, -0.27120727f, 0.02713205f, 0.02470923f, 0.03109271f, 0.05211238f, 
    0.02031974f, 0.00677511f, 0.09248512f, 0.03071957f, -0.18461782f, -0.02053831f, 0.01565751f, -0.20702600f, 
    -0.02374843f, 0.04679066f, -0.12941088f, -0.03498386f, -0.01717926f, -0.01851631f, 0.06615872f, -0.08403960f, 
    -0.19488521f, -0.06293452f, -0.02044701f, -0.25080922f, -0.03920005f, -0.03210937f, 0.03804774f, 0.06877729f, 
    0.03375286f, 0.07650368f, 0.11239343f, 0.06652633f, 0.19594590f, -0.19660448f, 0.19336703f, -0.25374958f, 
    -0.02257097f, -0.03755608f, 0.01315946f, 0.08436015f, 0.03629908f, -0.02448743f, 0.10021532f, 0.07559311f, 
    -0.02828055f, 0.16627896f, 0.21411411f, 0.00280130f, 0.07377760f, 0.02387988f, -0.15696518f, 0.13898914f, 
    0.06093333f, -0.03033329f, -0.13429341f, 0.04817944f, 0.08154458f, 0.28155893f, -0.17229405f, -0.04732485f, 
    0.13671309f, -0.05243015f, 0.05600636f, 0.11002474f, 0.04724235f, 0.05584475f, -0.09979030f, -0.01611436f, 
    -0.35661697f, 0.07375116f, -0.07934012f, -0.00712621f, 0.07926995f, -0.04256415f, 0.00277571f, 0.06786072f, 
    -0.01526566f, -0.06450565f, 0.03750587f, 0.10570394f, 0.12602818f, -0.25000381f, 0.06890470f, -0.03389060f, 
    -0.03083731f, -0.03247742f, 0.00927893f, -0.00772098f, -0.02952540f, -0.03755566f, -0.00092208f, -0.00572238f, 
    -0.14014009f, 0.22162029f, 0.25471401f, -0.20502186f, 0.11817147f, 0.07270598f, 0.02894646f, 0.00266630f, 
    -0.03264417f, -0.15846369f, -0.03340904f, 0.11367560f, 0.03428042f, 0.17210579f, 0.03776992f, -0.02464643f, 
    0.12384295f, -0.00191049f, -0.03795379f, 0.02162229f, 0.00157135f, 0.24535429f, -0.00287685f, -0.00557088f, 
    0.01164244f, -0.04453431f, 0.06946421f, 0.08302533f, -0.00997807f, 0.06954619f, -0.03159713f, 0.07692795f, 
    0.06956227f, 0.11473138f, -0.01627181f, 0.00307859f, 0.20405337f, -0.12522735f, 0.02393586f, 0.12621379f, 
    -0.06572390f, -0.01299739f, -0.03553226f, 0.06865561f, -0.01207141f, 0.02976131f, 0.03755822f, -0.06938621f, 
    -0.11746850f, -0.07490566f, -0.08409331f, -0.20507279f, 0.18746546f, -0.02704726f, 0.08516748f, 0.14337094f, 
    0.02733368f, -0.09579391f, -0.00261693f, -0.05464566f, -0.01622805f, 0.21975102f, 0.14948790f, 0.14898065f, 
    0.12906916f, 0.05500161f, 0.03869074f, 0.13290420f, -0.00327828f, 0.13450161f, -0.04041477f, 0.01711024f, 
    -0.08030190f, 0.04406473f, 0.05617751f, -0.00701346f, 0.06142299f, 0.07003449f, 0.02553772f, 0.04583801f, 
    -0.17998503f, -0.06456579f, -0.11758664f, -0.12781207f, -0.22994566f, 0.28487059f, 0.14887430f, 0.15463765f, 
    -0.03508864f, -0.02913162f, 0.05428554f, 0.00556553f, 0.02027447f, -0.04438734f, 0.15426773f, 0.00488089f, 
    0.18928768f, -0.20405933f, 0.20716511f, 0.11170238f, -0.00354813f, 0.00623857f, 0.11899237f, -0.06720455f, 
    -0.00679594f, 0.00851000f, -0.13761389f, -0.09167481f, 0.30470318f, 0.16814543f, 0.13828447f, -0.00538905f, 
    -0.14194258f, 0.01762927f, 0.11747181f, -0.03126641f, -0.06485431f, -0.04841217f, -0.12923498f, 0.03118757f, 
    0.15128008f, 0.03444317f, 0.10750603f, 0.03922946f, -0.12208071f, 0.04495107f, 0.05599719f, -0.05189079f, 
    0.00610127f, 0.07622085f, 0.08602802f, 0.15869166f, -0.06418575f, -0.07536196f, 0.14867415f, -0.03003781f, 
    -0.01942586f, 0.06106758f, 0.11778250f, 0.19336049f, 0.17816737f, 0.20254077f, -0.03539157f, -0.00016874f, 
    -0.13148914f, 0.08541455f, -0.17311262f, -0.08278702f, 0.02625912f, 0.05281201f, -0.06673630f, 0.09658958f, 
    0.03569070f, -0.01509395f, -0.09589716f, 0.08330891f, 0.23178612f, -0.15068345f, 0.17728691f, -0.10312906f, 
    -0.18932192f, 0.00312356f, 0.04498318f, 0.17313340f, -0.00049191f, -0.00084224f, 0.21719889f, -0.01499994f, 
    -0.13343346f, 0.04300740f, -0.25637615f, 0.11591353f, 0.09254677f, 0.00360657f, 0.04868513f, -0.02890624f, 
    -0.01571374f, 0.08128236f, 0.20100893f, 0.07900108f, 0.16817199f, 0.08744152f, 0.00808102f, 0.05542033f, 
    -0.10015991f, 0.07372972f, 0.03617868f, 0.16253412f, 0.04554078f, -0.14168265f, -0.03476645f, 0.10855560f, 
    0.13654536f, -0.33345437f, 0.12174422f, 0.11077428f, 0.00874231f, 0.05828819f, 0.14354546f, 0.09601488f, 
    -0.03998240f, 0.14822625f, -0.16314082f, -0.09237081f, -0.03229139f, 0.04400387f, 0.08407703f, 0.07374946f, 
    0.00422773f, 0.04445491f, 0.01347384f, 0.02202453f, -0.04337709f, -0.05382474f, -0.00149967f, 0.10180979f, 
    0.10335103f, 0.13113140f, 0.10958605f, -0.11921337f, -0.12709454f, 0.01486373f, 0.05648899f, 0.05985405f, 
    0.06148539f, 0.01653240f, -0.03696419f, 0.06798139f, -0.12418369f, 0.06164373f, -0.21608837f, -0.12026777f, 
    0.07021368f, 0.02190992f, 0.10688738f, -0.02961176f, 0.04546239f, 0.10985877f, -0.06481989f, 0.01229226f, 
    -0.03957288f, -0.05053280f, -0.10921540f, 0.01677894f, -0.07579330f, 0.07627252f, 0.02237007f, 0.13002540f, 
    -0.00225843f, -0.03979304f, 0.02820288f, 0.03828904f, -0.10982429f, -0.19374144f, -0.04813457f, -0.20730068f, 
    0.21094413f, -0.03860085f, 0.00356308f, 0.04540511f, -0.01519761f, 0.11170805f, -0.07159712f, 0.28270185f, 
    0.21500564f, 0.05343711f, 0.03345347f, -0.04446634f, 0.21873939f, -0.03869192f, 0.00092498f, 0.05379558f, 
    -0.05576526f, -0.00556558f, -0.03579586f, 0.14738759f, 0.02733984f, -0.20195696f, 0.02779048f, 0.34098056f, 
    0.09145592f, 0.00828358f, -0.00597080f, 0.17654850f, -0.05424682f, 0.01683638f, 0.02773997f, 0.06297584f, 
    0.31160006f, 0.14611253f, 0.02767722f, 0.34284809f, 0.00252074f, -0.01399142f, 0.18774626f, 0.13657367f, 
    0.02356545f, 0.14221035f, 0.02073874f, 0.03492431f, 0.03435968f, 0.10888053f, -0.05151828f, -0.20296800f, 
    0.12641758f, 0.01169357f, 0.00927612f, -0.01005255f, -0.10461236f, 0.05528624f, 0.02383263f, 0.07916747f, 
    0.05668036f, 0.07645003f, 0.03358403f, 0.11093896f, -0.00859207f, -0.00456612f, 0.00271413f, 0.02426055f, 
    0.11350702f, 0.02289676f, 0.02964275f, 0.13345239f, -0.12206908f, -0.13023956f, -0.05620701f, 0.09241778f, 
    -0.07215154f, 0.06731374f, -0.07245780f, -0.03742946f, -0.01760643f, -0.02270630f, 0.00868558f, -0.01571848f, 
    0.06206692f, 0.04716079f, -0.12898731f, -0.10058723f, 0.08027804f, 0.04157846f, 0.00883638f, 0.00966952f, 
    -0.09868752f, 0.09047616f, 0.03937777f, 0.09106569f, -0.23489629f, -0.02746815f, -0.27754521f, -0.35555628f, 
    0.08091063f, -0.06501736f, 0.03804438f, -0.03645306f, -0.07326483f, 0.02450320f, 0.01345371f, -0.01140430f, 
    0.18066184f, 0.15461369f, -0.00015746f, 0.08769227f, -0.01986988f, 0.08336057f, 0.02140545f, 0.01242914f, 
    0.03313305f, 0.05029209f, 0.05914768f, 0.04988273f, 0.25613862f, 0.14895274f, 0.03367431f, 0.01614349f, 
    0.06713012f, -0.09029163f, -0.03112102f, -0.02073539f, -0.06651313f, 0.01064601f, -0.04895436f, 0.12459327f, 
    -0.25010595f, -0.12146989f, 0.16967948f, 0.23157930f, 0.04273851f, 0.09361694f, -0.01322100f, 0.07056185f, 
    0.06280941f, 0.11156955f, -0.06044075f, -0.05725586f, -0.52953273f, 0.16121091f, 0.12258442f, -0.07403426f, 
    0.06499913f, 0.07639702f, 0.12233955f, -0.00178556f, 0.20418532f, 0.15142016f, 0.13377036f, 0.11587958f, 
    -0.46035793f, 0.07021503f, 0.08188434f, -0.26264769f, 0.02197442f, 0.04496387f, -0.01368789f, -0.04932493f, 
    0.04959630f, -0.04070985f, 0.03848305f, 0.01891380f, -0.13933858f, -0.17778242f, 0.05147418f, 0.05822254f, 
    -0.04506182f, -0.00683491f, -0.00307227f, 0.04876765f, -0.12376870f, 0.06769832f, 0.11198497f, 0.06667522f, 
    0.20367916f, 0.11011068f, -0.05175836f, -0.11102388f, 0.07386366f, 0.09744716f, -0.03512998f, -0.08210187f, 
    -0.11262242f, -0.04811203f, -0.04327395f, -0.12074636f, 0.12111649f, 0.00944465f, -0.09521085f, -0.03494592f, 
    -0.01722245f, 0.06362773f, -0.08162455f, 0.06962812f, 0.13674107f, 0.04832472f, -0.05411573f, 0.04103061f, 
    0.09351271f, -0.05482540f, 0.14413482f, 0.17400897f, 0.05066318f, -0.08551683f, 0.23279379f, -0.09912357f, 
    -0.01396924f, -0.00860666f, 0.00740342f, -0.06610982f, -0.04280633f, 0.15888958f, -0.23301435f, 0.00347050f, 
    0.03531168f, -0.07077473f, 0.02108475f, -0.01621443f, 0.04569103f, 0.06106226f, -0.00183543f, 0.02271133f, 
    -0.05568051f, -0.06835523f, 0.13920471f, 0.01150928f, -0.00347257f, 0.04976027f, -0.02979236f, -0.17934066f, 
    0.10042321f, -0.08574282f, 0.04219148f, 0.11722722f, 0.26778033f, -0.18251054f, -0.09171943f, 0.29949158f, 
    0.03204523f, 0.06241868f, 0.04669827f, -0.07035164f, 0.01848923f, 0.01942797f, 0.08238903f, 0.11900958f, 
    0.12359927f, 0.04401794f, 0.02373588f, 0.17686062f, 0.07756724f, 0.02888320f, -0.02668739f, -0.09783265f, 
    -0.03690094f, 0.00217151f, -0.02583401f, 0.01329546f, -0.04428137f, 0.22928576f, -0.05759558f, 0.17565119f, 
    0.10741658f, 0.05503638f, 0.05642879f, -0.03750865f, 0.07277049f, -0.07789878f, -0.04915443f, -0.04989299f, 
    0.03139129f, -0.07388293f, -0.01205869f, -0.04287377f, -0.02148231f, 0.06326054f, 0.21899092f, -0.04251797f, 
    0.03205891f, 0.03266641f, 0.14215776f, -0.03912359f, 0.05087946f, -0.09521334f, 0.32566875f, 0.34238738f, 
    -0.12407752f, 0.06123187f, 0.09847919f, 0.01021255f, 0.02988489f, -0.03107784f, 0.03004250f, 0.01538017f, 
    0.20657726f, -0.11975933f, 0.15013187f, -0.03828686f, 0.04481639f, -0.05550169f, 0.03355327f, -0.11261281f, 
    0.05124935f, 0.08011147f, -0.02081181f, 0.02340230f, -0.18907124f, 0.09826783f, -0.17535573f, 0.10201458f, 
    0.04397983f, 0.03911113f, 0.07063143f, 0.04214945f, -0.07982072f, -0.07566581f, 0.02192529f, -0.01731513f, 
    0.24528401f, 0.08147120f, -0.30416754f, 0.01335476f, -0.07521825f, -0.06759751f, 0.03485900f, -0.05448913f, 
    0.02692332f, 0.10886219f, -0.01059392f, -0.03082012f, 0.45748642f, -0.13753749f, -0.03471058f, -0.01750289f, 
    -0.03408877f, -0.08462840f, -0.00113179f, 0.03878479f, -0.11543736f, -0.07252024f, 0.07953578f, 0.06548563f, 
    0.13766973f, 0.10046741f, 0.12696986f, 0.04288911f, 0.01416495f, 0.03317554f, -0.00936211f, -0.02791697f, 
    0.01185245f, -0.04518730f, 0.08513702f, 0.03206846f, -0.13430664f, 0.26874909f, -0.05347044f, -0.04948637f, 
    0.03605371f, 0.12574205f, 0.02587107f, 0.02388881f, 0.08417149f, -0.00834068f, 0.04335379f, 0.01591669f, 
    -0.08547079f, -0.01644678f, 0.06321885f, 0.18984996f, -0.05935701f, -0.02069218f, 0.00157316f, -0.02794300f, 
    0.06298874f, 0.07427338f, -0.04881990f, 0.21101242f, 0.13327871f, -0.02633404f, -0.09717268f, -0.08410624f, 
    -0.05701131f, -0.07799857f, -0.02919024f, -0.06314164f, -0.00692931f, -0.14049453f, -0.01299755f, 0.13595839f, 
    0.06335762f, 0.00855993f, -0.05767171f, -0.07058791f, -0.02247111f, 0.02858898f, -0.02730402f, -0.04627931f, 
    0.04215629f, -0.06821611f, -0.06365001f, -0.04934048f, -0.04753096f, -0.05286918f, -0.02701361f, -0.04719837f, 
    0.02375650f, 0.02313160f, -0.03434567f, -0.01778246f, -0.00449089f, -0.02983523f, -0.01686909f, -0.01676998f, 
    0.04871915f, 0.03954782f, 0.05147725f, 0.05657127f, -0.05606913f, -0.00263116f, -0.05751878f, 0.05364276f, 
    0.00906023f, -0.02859827f, 0.01472773f, 0.05308182f, 0.00664222f, -0.02370063f, 0.04924227f, -0.05120524f, 
    -0.02960412f, 0.00914938f, -0.01909397f, 0.05932822f, -0.01584811f, -0.00490508f, -0.06953251f, -0.05715357f, 
    -0.00164312f, 0.02353323f, 0.02700702f, 0.03632787f, -0.05683956f, -0.06619934f, -0.06188576f, -0.02015087f, 
    -0.00337400f, -0.00659524f, -0.07729939f, 0.04515691f, 0.04423501f, 0.03686316f, -0.01547394f, 0.04863779f, 
    0.00509611f, 0.02123227f, 0.03925879f, -0.06373721f, 0.02848320f, 0.03552849f, -0.01788922f, -0.05952816f, 
    0.06253555f, 0.03771713f, -0.06248931f, 0.06143769f, -0.07227717f, -0.05459305f, 0.00097066f, -0.05181603f, 
    -0.05956701f, -0.01796747f, 0.04799619f, -0.06354461f, 0.04476968f, 0.05508732f, 0.02891948f, -0.05550214f, 
    -0.04121585f, 0.01531478f, -0.01976341f, 0.05202064f, -0.03558768f, -0.02532284f, -0.06179858f, 0.05199647f, 
    -0.00788042f, 0.01832744f, 0.04343820f, -0.03654284f, -0.03167418f, -0.04991999f, -0.05789636f, -0.06674813f, 
    -0.00235906f, -0.07662822f, -0.02165240f, 0.05493169f, -0.01220663f, 0.00083440f, -0.03848470f, 0.01596527f, 
    0.05600957f, 0.00340519f, -0.05062137f, 0.02584375f, -0.03726814f, 0.02074202f, 0.00045612f, -0.07048072f, 
    -0.02624477f, -0.05011688f, -0.03759734f, -0.06715983f, 0.01094735f, 0.00266583f, 0.01770778f, -0.03668667f, 
    -0.01726275f, -0.04406458f, -0.01881918f, -0.02882781f, -0.05350906f, 0.06060725f, -0.02984311f, 0.02628317f, 
    0.02837881f, 0.03840742f, -0.01409135f, -0.06559810f, -0.00328781f, -0.03553299f, 0.00965451f, -0.01981011f, 
    -0.06357178f, 0.02506486f, 0.01385635f, 0.01415041f, -0.07397139f, 0.01254818f, 0.04272432f, -0.01913572f, 
    -0.04624961f, -0.04182764f, -0.03172145f, -0.03663061f, 0.01656729f, 0.00010686f, 0.01683825f, -0.02217861f, 
    0.01294786f, 0.04964808f, -0.03502305f, -0.01518506f, -0.05992026f, 0.04604417f, -0.00960221f, 0.03846857f, 
    0.03818575f, 0.00528441f, 0.04608342f, 0.00724711f, -0.06243712f, 0.06455128f, 0.01567804f, -0.01417623f, 
    0.03594609f, 0.02408982f, 0.04133696f, -0.07693444f, -0.05458969f, -0.01647023f, 0.02370656f, -0.01118025f, 
    -0.04085487f, -0.07678938f, -0.05834279f, -0.03006664f, -0.05798888f, 0.02308859f, -0.05723860f, -0.00210092f, 
    0.04900982f, -0.02458685f, -0.05746624f, 0.03306760f, -0.03004402f, 0.04129542f, 0.01082709f, 0.03960611f, 
    -0.03130105f, -0.02328904f, -0.06327131f, 0.01707414f, -0.06900017f, 0.04812477f, -0.01584161f, 0.05372852f, 
    0.05129577f, -0.01327637f, 0.01757784f, 0.03764997f, 0.00244312f, -0.05528258f, -0.06442131f, -0.05347572f, 
    -0.03631666f, -0.00095488f, 0.03869501f, 0.05978305f, -0.07248334f, 0.03989130f, -0.00072228f, 0.01008393f, 
    0.00513848f, 0.05003534f, -0.01548629f, -0.06240764f, 0.04137751f, -0.05442794f, -0.03696001f, -0.07547869f, 
    0.02888948f, -0.00890779f, 0.05668198f, 0.03168987f, -0.03314899f, 0.03673598f, -0.00750090f, -0.00039979f, 
    -0.07495996f, 0.04371957f, 0.05614753f, -0.06115044f, -0.02532309f, 0.05859431f, -0.03587408f, -0.05277750f, 
    -0.05187355f, 0.02473637f, 0.00944178f, -0.01630247f, -0.00462638f, 0.05723590f, -0.05796034f, 0.06339755f, 
    0.00710981f, -0.02472110f, -0.01702348f, -0.06563082f, 0.02422368f, 0.01030976f, -0.04346301f, 0.02453489f, 
    -0.03637808f, -0.07338072f, -0.03373098f, -0.05300173f, 0.00382209f, -0.01281420f, 0.01059295f, -0.02279448f, 
    0.02184955f, -0.02015969f, 0.01657906f, -0.06818046f, 0.02626415f, 0.04031195f, 0.02482135f, -0.05557871f, 
    -0.02415069f, -0.01633475f, -0.03710595f, 0.02658926f, -0.04196919f, -0.02705827f, -0.03266098f, -0.03503535f, 
    -0.03919255f, -0.05737630f, 0.02671262f, 0.06305126f, -0.01485556f, -0.07533038f, -0.04621186f, 0.01373985f, 
    -0.05301229f, 0.06016017f, 0.05973353f, -0.04287495f, 0.01709402f, 0.06060047f, -0.02818808f, -0.06480026f, 
    -0.06539826f, -0.05459185f, -0.00628265f, -0.04943330f, -0.06021760f, 0.04251324f, -0.04335407f, -0.02779420f, 
    -0.00441311f, -0.04599768f, 0.01666051f, -0.07402316f, -0.00895681f, -0.05318257f, -0.03018084f, 0.06150087f, 
    -0.01453516f, -0.04874925f, -0.05990024f, 0.01961735f, -0.02893655f, -0.02520109f, 0.04333849f, 0.06239933f, 
    -0.05820225f, -0.01641693f, -0.04258614f, -0.07145856f, -0.01219099f, 0.04854946f, 0.06237126f, -0.05379485f, 
    -0.03450818f, 0.02643493f, -0.05477060f, -0.00797651f, -0.02915903f, 0.05967780f, -0.02877771f, 0.04262847f, 
    -0.03499182f, -0.06143453f, 0.02703283f, -0.05737104f, 0.00832889f, -0.01122130f, -0.01934832f, -0.02078915f, 
    -0.03764217f, -0.00669337f, -0.01779614f, 0.02877954f, -0.01701692f, 0.04928609f, 0.00252327f, 0.00645605f, 
    -0.02137914f, 0.04956112f, 0.06106820f, 0.02024828f, 0.03543588f, -0.02744654f, -0.05588911f, -0.01922635f, 
    0.00113881f, 0.00734382f, -0.02069257f, 0.00091003f, -0.06920665f, -0.05739513f, 0.04791509f, -0.04454340f, 
    -0.05971667f, -0.03973798f, -0.00346040f, 0.02994577f, -0.03961987f, -0.04798209f, 0.05822200f, 0.03764006f, 
    0.02796560f, -0.03379365f, -0.00543879f, -0.07175545f, 0.01746549f, -0.07374195f, -0.05669700f, -0.02845963f, 
    -0.02309496f, 0.00546756f, 0.00143033f, 0.01413522f, -0.00224220f, -0.09223628f, 0.06667572f, -0.04711797f, 
    0.02418358f, -0.05424089f, 0.02256706f, -0.07525661f, -0.02749448f, 0.00390748f, -0.01969555f, -0.08650395f, 
    -0.01212050f, -0.07225604f, -0.03909047f, 0.04949370f, 0.03405197f, -0.05232640f, 0.04486052f, -0.02287181f, 
    -0.08870712f, 0.04907123f, -0.07103641f, -0.00493896f, -0.02548844f, -0.05290743f, 0.02128131f, 0.03506041f, 
    -0.08592226f, -0.00227754f, -0.06114169f, -0.05803754f, -0.05154970f, -0.00011160f, -0.06190496f, -0.02593785f, 
    -0.02305917f, -0.03882360f, 0.03546575f, -0.05308560f, -0.06733318f, -0.08409691f, -0.02692505f, 0.02136973f, 
    -0.01991617f, 0.02098507f, 0.00978196f, 0.03816573f, -0.00503958f, -0.02237802f, -0.05708351f, -0.02875257f, 
    0.05520538f, 0.04121624f, -0.05815030f, -0.00646445f, -0.03921280f, -0.00938201f, 0.00424635f, -0.07554321f, 
    0.04778363f, 0.05106745f, 0.02335024f, 0.03493145f, -0.06616111f, 0.02395277f, 0.01818044f, -0.05136171f, 
    -0.07396702f, 0.02633566f, -0.07021230f, -0.07450652f, 0.02538913f, -0.06812077f, -0.02983241f, -0.02795262f, 
    -0.03440719f, 0.00555114f, -0.06216594f, -0.08623318f, 0.04646045f, -0.05030091f, 0.05232165f, 0.02110881f, 
    -0.03783341f, 0.04786138f, 0.05861093f, -0.02098304f, 0.00183978f, -0.00899634f, -0.02373504f, 0.05736843f, 
    0.01147315f, -0.03459926f, -0.01533731f, -0.08871303f, -0.06086919f, 0.02946245f, 0.01795370f, 0.00466240f, 
    0.01462608f, -0.07457606f, 0.00645259f, -0.10230763f, 0.03419014f, -0.03665231f, 0.03454064f, 0.04619616f, 
    0.06704999f, -0.09391045f, -0.07912651f, -0.03761966f, -0.04676137f, 0.02731984f, 0.03944691f, -0.00328311f, 
    -0.05198018f, 0.00417736f, 0.02841621f, -0.07347822f, 0.02361513f, -0.05329089f, -0.08888598f, -0.03091584f, 
    -0.07471870f, 0.00135508f, -0.08422135f, -0.04681812f, 0.01456767f, 0.00705647f, -0.05585149f, -0.01506734f, 
    0.05106345f, -0.01495824f, -0.08650100f, 0.06013801f, 0.03186927f, -0.00999956f, -0.00066181f, -0.02339323f, 
    -0.05840065f, 0.02671130f, 0.01637581f, -0.03223481f, 0.04996334f, 0.02679389f, -0.03902843f, -0.01771421f, 
    -0.05866265f, 0.00808698f, -0.01166519f, -0.07600138f, 0.01942564f, -0.09338371f, -0.01901108f, -0.08399444f, 
    -0.04364846f, 0.00524854f, -0.00037324f, -0.05764319f, -0.01659841f, 0.03321304f, 0.03858814f, -0.05681702f, 
    -0.06996436f, -0.00700759f, -0.01523769f, -0.08854228f, 0.05054587f, 0.03217826f, 0.02873358f, -0.04354789f, 
    -0.01411967f, -0.00645182f, -0.04987343f, -0.01375516f, 0.03601257f, -0.04583225f, -0.01832531f, 0.03374523f, 
    0.05703229f, -0.03739849f, 0.03817677f, -0.04718046f, -0.06437079f, -0.02765177f, 0.03705000f, -0.04084026f, 
    0.03545464f, -0.07294692f, -0.01598175f, -0.00683090f, -0.02500179f, 0.04377027f, 0.05402376f, 0.04668265f, 
    -0.05462661f, 0.02686080f, -0.02896564f, -0.01535516f, -0.01212363f, -0.07144861f, 0.01773630f, -0.02074237f, 
    0.01651680f, -0.03117276f, 0.06883657f, -0.05683171f, -0.06076177f, 0.00640837f, 0.02924314f, -0.05864535f, 
    -0.07014474f, -0.05841106f, -0.03931873f, -0.06465939f, 0.02634923f, -0.03206199f, -0.04768331f, -0.06003036f, 
    -0.07130489f, -0.01959705f, -0.06812748f, -0.00484747f, -0.04568310f, 0.01481187f, -0.03537895f, 0.02609002f, 
    -0.04396879f, 0.03718827f, -0.00023507f, -0.06994492f, -0.05782800f, 0.00983696f, -0.07619077f, -0.01021940f, 
    0.05875450f, -0.00260216f, 0.01881404f, -0.02629721f, 0.02250813f, -0.01013845f, -0.01987598f, 0.00427808f, 
    0.05964261f, -0.04040271f, -0.03752331f, 0.05701166f, -0.00822649f, -0.01368853f, -0.01080896f, -0.00810834f, 
    0.02385593f, -0.02323469f, -0.02962520f, 0.02431686f, 0.03457616f, 0.02345189f, -0.05689160f, 0.00326508f, 
    -0.07849906f, -0.00781257f, -0.02066004f, 0.04791510f, -0.00223851f, 0.03761109f, 0.02441896f, -0.05859598f, 
    -0.03096963f, 0.03604785f, -0.05507840f, -0.06364512f, -0.05631895f, -0.03965493f, 0.01867283f, 0.05363443f, 
    -0.02710249f, -0.00930361f, -0.00867306f, 0.01996631f, -0.03960637f, 0.04387190f, -0.03661315f, 0.03258944f, 
    0.04757497f, -0.05837309f, -0.02708574f, 0.02425473f, -0.05982263f, -0.03009955f, -0.06001035f, -0.01701107f, 
    -0.04059475f, -0.04047173f, -0.07651094f, -0.00053860f, -0.05547103f, 0.06100562f, 0.03039940f, 0.05729254f, 
    -0.03745747f, 0.04409648f, 0.04034145f, -0.03017326f, -0.00647083f, 0.04566748f, -0.03847440f, 0.02351822f, 
    -0.03359768f, -0.07914571f, 0.01414933f, 0.03985385f, 0.04963806f, 0.01293518f, 0.02639481f, -0.05705319f, 
    -0.01002473f, -0.00081371f, -0.04145720f, -0.07662888f, -0.05184930f, -0.06797037f, 0.02237916f, -0.00054053f, 
    0.03338951f, 0.00018384f, -0.06142631f, -0.04585138f, -0.07001247f, 0.03467005f, 0.05960959f, -0.04422739f, 
    0.03672639f, 0.03458897f, 0.04557216f, -0.05808586f, -0.04020099f, 0.04228534f, -0.05771335f, -0.05082249f, 
    0.02363332f, -0.03520847f, -0.02904209f, -0.06958463f, 0.01262222f, -0.02039649f, -0.03962788f, -0.03386107f, 
    0.05463657f, -0.04472376f, 0.04430791f, 0.06058906f, -0.07063574f, -0.05012366f, 0.01299910f, 0.03538478f, 
    0.02791015f, -0.05679015f, 0.04363307f, -0.05449010f, 0.00826935f, -0.04534036f, 0.04930063f, 0.07001337f, 
    0.02987654f, -0.02529966f, -0.03046931f, -0.02900435f, 0.00237448f, 0.05519334f, 0.02643061f, 0.05075128f, 
    -0.27374199f, 0.07374106f, -0.04310581f, -0.07818085f, 0.16314614f, -0.07276832f, -0.04816996f, 0.08381557f, 
    -0.02089614f, 0.02352817f, -0.07465306f, 0.11946333f, -0.22345218f, -0.03892874f, 0.33503646f, 0.18058282f, 
    0.01250357f, 0.08787184f, -0.03455571f, 0.03786043f, 0.06988060f, 0.01054852f, 0.06316285f, 0.02198841f, 
    0.30017620f, -0.10021079f, 0.12554650f, -0.16469841f, 0.00277004f, -0.11133474f, 0.11034789f, 0.00245489f, 
    0.10713781f, -0.00262577f, 0.13130389f, 0.05329806f, -0.16478084f, 0.06512521f, -0.04738466f, 0.03363855f, 
    -0.00537147f, -0.05283462f, -0.10911931f, -0.02667001f, 0.13533069f, 0.05468827f, 0.13892163f, 0.19202483f, 
    -0.21738598f, 0.01780388f, 0.23046923f, 0.14126621f, 0.11653483f, 0.02495060f, 0.04220016f, 0.07702077f, 
    -0.12671469f, -0.05804783f, -0.06801442f, 0.02322138f, 0.21894555f, -0.18064953f, 0.22601183f, 0.04995904f, 
    0.09791814f, 0.01947627f, -0.17255597f, 0.01065854f, 0.10228120f, -0.04029960f, -0.05182513f, -0.10283300f, 
    -0.15442750f, 0.22101994f, -0.10819807f, -0.08003744f, 0.10928411f, 0.05746701f, 0.04507945f, -0.00691441f, 
    0.03420964f, -0.02299134f, 0.07365252f, 0.13410714f, 0.02102273f, 0.06195829f, -0.01097735f, 0.02942377f, 
    -0.08093596f, 0.01361523f, 0.10844906f, 0.01696478f, 0.00635330f, 0.03829248f, -0.00428937f, 0.03168144f, 
    -0.55525368f, 0.08023281f, -0.22791296f, -0.09862918f, 0.06124729f, 0.03179311f, -0.02647012f, 0.00021365f, 
    -0.13218169f, -0.01084371f, 0.05803488f, 0.10862966f, 0.11288735f, -0.25767758f, 0.08940368f, 0.17063144f, 
    -0.10038697f, -0.21945323f, -0.02824792f, -0.14175698f, -0.06591666f, -0.09047174f, 0.00468608f, 0.07938056f, 
    -0.47835413f, 0.17166114f, 0.20134863f, -0.11925220f, 0.04433009f, -0.02652713f, -0.03581845f, 0.11400169f, 
    0.06069889f, -0.03651841f, -0.01848056f, 0.16484247f, -0.15293090f, 0.07817537f, -0.05769569f, -0.25171337f, 
    -0.09583487f, 0.13794357f, 0.04029830f, 0.04727766f, 0.03680835f, 0.15249437f, 0.08274731f, -0.03103587f, 
    0.02608334f, -0.04611769f, -0.13677980f, -0.01980548f, -0.01089855f, 0.03068123f, 0.11241419f, -0.06746938f, 
    -0.08686727f, -0.00982392f, 0.08666692f, 0.01332546f, 0.01070070f, 0.13496739f, -0.10937975f, -0.15459779f, 
    0.13274407f, 0.01471992f, -0.04852095f, -0.10848726f, -0.06172862f, -0.05138849f, 0.00059207f, -0.03738610f, 
    0.21927975f, -0.14788774f, 0.10449525f, 0.19062799f, 0.09369289f, 0.06276564f, 0.00228398f, 0.19260411f, 
    0.11863264f, 0.12896676f, 0.03832757f, -0.02115162f, 0.02230256f, 0.39266279f, -0.01080653f, -0.24307966f, 
    0.14525445f, 0.06387714f, 0.01372384f, -0.02529817f, -0.07302445f, -0.05100678f, -0.04335816f, 0.07960577f, 
    0.06574146f, 0.18535168f, 0.11111832f, 0.21389632f, 0.00462093f, 0.18279864f, -0.03420793f, 0.00315237f, 
    0.05697989f, 0.04803935f, 0.03081274f, 0.01142266f, 0.10237776f, 0.17054597f, -0.00136447f, 0.11953358f, 
    0.04356820f, 0.09064970f, -0.11826264f, 0.10822652f, 0.01398513f, -0.01243364f, 0.12208509f, 0.11511161f, 
    -0.18809378f, 0.03786115f, 0.12227923f, -0.27449179f, 0.05391986f, -0.01336141f, 0.08213662f, -0.05136194f, 
    0.06228397f, 0.06589004f, 0.05245938f, 0.08435716f, 0.12063897f, 0.28609529f, 0.27442113f, 0.13078792f, 
    -0.14245163f, -0.15676719f, -0.11965315f, -0.19385143f, 0.10924991f, 0.02420527f, 0.14243130f, -0.01217795f, 
    -0.26754621f, -0.12097711f, 0.12178808f, -0.09995692f, 0.07298780f, 0.02739106f, 0.09912813f, 0.10154079f, 
    0.10537233f, -0.00663691f, -0.07269479f, -0.00779222f, -0.10396614f, -0.18635352f, -0.14313737f, -0.30157921f, 
    0.03584798f, 0.07751526f, 0.12481824f, 0.03672932f, -0.00718780f, -0.04025727f, 0.08516913f, -0.17959090f, 
    -0.09816655f, -0.11173856f, -0.28554115f, -0.14992967f, 0.15264188f, 0.07432608f, 0.02479845f, 0.18037519f, 
    0.07459354f, -0.00456031f, -0.02653202f, 0.03077366f, 0.16807477f, 0.32760903f, 0.24412444f, 0.29219654f, 
    -0.01231589f, -0.01969539f, -0.03112076f, -0.11096857f, -0.01474481f, 0.15304112f, -0.06538400f, 0.01564126f, 
    -0.37145016f, -0.20938563f, -0.21674821f, 0.04505409f, 0.06116273f, 0.04937749f, -0.00945988f, 0.11297960f, 
    0.02563343f, -0.06584096f, -0.02452988f, -0.06731318f, -0.19661057f, 0.05573228f, 0.23555529f, 0.18062016f, 
    -0.29733101f, -0.06645802f, 0.14467695f, -0.03428523f, -0.03866566f, -0.17861253f, 0.15283523f, -0.09309319f, 
    -0.13785054f, 0.12367742f, 0.11159731f, -0.33218306f, 0.00162152f, -0.01318191f, -0.01362450f, -0.01550725f, 
    0.03130849f, -0.00840149f, 0.03573446f, -0.04426821f, 0.36585301f, 0.06754205f, 0.23472659f, 0.03042337f, 
    -0.02367499f, -0.04042448f, 0.09137832f, -0.00027968f, -0.17871858f, -0.00498316f, -0.01753548f, 0.02485396f, 
    0.47868109f, 0.18721259f, 0.31065997f, 0.19465500f, 0.05380918f, 0.07794958f, -0.02202296f, -0.08570438f, 
    -0.01227708f, 0.07819004f, -0.04136174f, 0.16998592f, 0.13074633f, -0.25651497f, -0.31787655f, -0.14529000f, 
    0.22513571f, 0.15371366f, 0.08716080f, 0.24248469f, -0.00248381f, 0.07985966f, 0.02937934f, -0.08943236f, 
    -0.37314460f, -0.32183671f, -0.23399283f, -0.02799534f, 0.16948663f, 0.06203797f, 0.00481032f, 0.01700539f, 
    -0.01599224f, 0.01053102f, 0.01602873f, -0.05257804f, 0.10030188f, -0.04131489f, -0.03897707f, -0.15567887f, 
    0.21357259f, 0.02837978f, 0.13330211f, 0.23856454f, -0.04119301f, -0.06954969f, -0.00072511f, 0.09837779f, 
    0.02951426f, 0.06876650f, -0.00981408f, -0.03806738f, -0.02964426f, -0.01746834f, -0.11216705f, 0.00716957f, 
    -0.01472923f, -0.02332764f, 0.12914786f, -0.02377008f, 0.27701288f, -0.00942868f, 0.18228371f, -0.04048878f, 
    -0.12871210f, -0.01269895f, -0.07481623f, -0.08400718f, 0.03677225f, 0.00909591f, 0.07865598f, 0.02992224f, 
    -0.05212841f, 0.10147610f, -0.34049329f, 0.29724488f, 0.04760554f, -0.07446288f, -0.03652665f, -0.06156374f, 
    -0.02898298f, -0.01922073f, -0.21670608f, -0.13197188f, -0.01675411f, -0.01011456f, 0.05321163f, 0.16017610f, 
    -0.03097539f, -0.04872077f, 0.04464222f, -0.06980512f, 0.03482898f, 0.07741826f, -0.15719381f, -0.17156729f, 
    0.09584307f, -0.18926606f, -0.01077595f, -0.00889291f, -0.01486861f, -0.03612665f, 0.02041704f, -0.07186324f, 
    -0.01784818f, 0.08609514f, 0.19537620f, -0.01480894f, -0.08896597f, -0.18187039f, 0.22187839f, -0.02979850f, 
    -0.05052327f, 0.09112322f, 0.20636627f, 0.23735629f, 0.06229328f, 0.11999141f, -0.00877045f, 0.06810737f, 
    -0.06909764f, 0.03387638f, 0.13036470f, 0.11941023f, 0.09772249f, 0.17859739f, -0.09609886f, 0.04889265f, 
    0.05258298f, -0.28052044f, -0.02864130f, 0.06491914f, 0.23350464f, -0.07608854f, -0.08050089f, -0.19279818f, 
    -0.06079913f, -0.13951537f, -0.23034583f, 0.00080761f, -0.12850013f, 0.00101065f, 0.12179018f, -0.01452844f, 
    -0.02532508f, 0.11078714f, 0.15331011f, 0.06240226f, 0.04579072f, 0.05298563f, -0.16244298f, 0.04169685f, 
    0.00739233f, -0.05751004f, 0.06392290f, 0.01821429f, 0.46440989f, -0.14431332f, -0.06953732f, -0.10508310f, 
    0.05032356f, -0.01559757f, -0.19206512f, -0.17067210f, -0.02100064f, 0.10577057f, 0.06448912f, 0.05066797f, 
    0.17040730f, -0.01343354f, 0.25343671f, -0.08590129f, -0.00998087f, 0.00746838f, 0.04895568f, 0.08806150f, 
    -0.07995183f, -0.03303641f, -0.05423972f, 0.04729151f, -0.02537388f, 0.02402604f, -0.01541264f, -0.12909308f, 
    0.06092542f, -0.05935851f, 0.03496320f, 0.00099544f, -0.16383493f, 0.23269171f, -0.05221968f, 0.18110082f, 
    0.17930128f, -0.13201764f, -0.31515059f, 0.14431117f, -0.10584134f, 0.00822349f, -0.09212269f, -0.00910082f, 
    0.09553672f, 0.06641404f, -0.05583787f, 0.10386776f, 0.22138721f, 0.01495726f, 0.06695148f, -0.10159814f, 
    0.08614898f, -0.00842738f, 0.16313106f, 0.20884880f, -0.14818624f, -0.05986194f, -0.06707048f, 0.04150018f, 
    0.13976105f, 0.00182811f, 0.11495040f, 0.12147659f, -0.10448231f, -0.01283764f, -0.06590603f, -0.01550695f, 
    -0.06430977f, -0.18750042f, -0.14629813f, -0.19465284f, -0.24063002f, -0.06479136f, 0.18259868f, -0.04688593f, 
    -0.00050359f, 0.05802478f, 0.24539976f, 0.28904170f, -0.18080799f, 0.17287989f, 0.04667217f, 0.10574294f, 
    -0.14804366f, 0.03445016f, -0.03764480f, 0.00244501f, 0.02906056f, -0.11593576f, -0.19822116f, -0.02374290f, 
    0.00297507f, -0.12413416f, 0.14151923f, 0.08181173f, -0.17386025f, 0.17286001f, 0.30737898f, 0.14648920f, 
    -0.03381108f, 0.04846842f, -0.17897436f, -0.12007580f, -0.04052773f, 0.15015699f, -0.11224393f, 0.07742301f, 
    -0.01653031f, 0.19126055f, -0.19935793f, -0.10140606f, -0.01195151f, -0.12810117f, -0.02094004f, -0.15884551f, 
    0.02580633f, -0.06711832f, -0.06892136f, -0.08876891f, -0.17510414f, 0.11334764f, -0.07221188f, 0.06538280f, 
    0.16399609f, -0.06295273f, 0.02763719f, -0.04864408f, -0.02755357f, 0.04840991f, -0.02903960f, -0.17286649f, 
    -0.07747404f, 0.02336673f, 0.16584428f, 0.03443176f, 0.11579926f, 0.06869515f, 0.11908869f, 0.05073657f, 
    0.06778572f, 0.00743767f, 0.09544609f, 0.07490227f, 0.38821849f, -0.17769445f, 0.34468544f, -0.06081632f, 
    0.07579713f, 0.06626014f, -0.05280383f, 0.16876468f, 0.10067052f, -0.00460534f, -0.03884800f, 0.16528402f, 
    0.16732213f, 0.18224809f, -0.02800827f, -0.01300948f, 0.11046422f, 0.19470704f, 0.07220799f, -0.02033571f, 
    0.00616524f, -0.01859037f, -0.03854821f, 0.03857138f, -0.15352112f, -0.01953493f, -0.17882417f, -0.03359471f, 
    0.04414948f, -0.05750597f, -0.22698319f, 0.02258648f, -0.11470581f, -0.04388186f, 0.04860764f, -0.09333588f, 
    0.19013776f, 0.25847766f, 0.00256661f, 0.08730170f, -0.00170913f, 0.13023116f, -0.09570631f, 0.07798554f, 
    -0.09878226f, 0.10947302f, 0.00866081f, 0.07308425f, 0.15017338f, -0.24860844f, -0.02029200f, 0.12056173f, 
    -0.09912490f, -0.02439828f, 0.02581519f, -0.15154505f, -0.07229760f, 0.11025925f, -0.08272296f, 0.13213488f, 
    -0.33081445f, 0.13759394f, 0.32832643f, -0.11791833f, -0.00813458f, 0.06176649f, -0.13043928f, 0.08469439f, 
    0.12600604f, 0.00975252f, -0.08225136f, 0.09752624f, -0.24363838f, 0.03468800f, -0.09451300f, -0.26189169f, 
    0.07359656f, -0.06506946f, -0.08155163f, -0.02121648f, 0.12902908f, 0.20632759f, 0.00967831f, 0.03774468f, 
    -0.16514754f, -0.08983112f, -0.12849644f, 0.11934752f, -0.01883721f, -0.02198797f, -0.04902991f, -0.23255691f, 
    0.05497316f, -0.12766646f, 0.12580127f, 0.03024073f, 0.19459823f, 0.07132389f, -0.08924492f, -0.07013359f, 
    -0.02544909f, 0.00994088f, -0.05665242f, 0.06158925f, -0.12600273f, 0.08259582f, -0.09785427f, -0.02889222f, 
    0.28521800f, -0.16275653f, -0.00044321f, -0.01569839f, 0.12700102f, 0.08816832f, 0.12553564f, 0.09814505f, 
    0.03927771f, -0.15828437f, -0.03877032f, -0.00322911f, -0.05419100f, 0.41172391f, 0.11006900f, -0.26190394f, 
    0.10951795f, 0.17784224f, 0.24936876f, 0.16610362f, -0.12356988f, 0.04587291f, 0.00484995f, 0.14751340f, 
    -0.28407770f, -0.15780528f, 0.00014704f, -0.13225625f, 0.01696003f, -0.04048266f, -0.11468551f, 0.01730427f, 
    -0.05014339f, 0.13765001f, -0.01750304f, -0.04665364f, 0.41998371f, -0.08773910f, 0.08380692f, 0.01374861f, 
    -0.09542141f, -0.05841535f, 0.14327706f, -0.05145965f, 0.12689419f, -0.05841513f, 0.08454862f, 0.05476372f, 
    0.08521945f, -0.13388790f, -0.03194412f, 0.44758791f, 0.02920214f, -0.04917722f, -0.24530619f, -0.02687632f, 
    -0.20781563f, -0.20016725f, -0.24387068f, -0.03822206f, 0.05798684f, -0.20268372f, -0.14838175f, 0.09701923f, 
    0.10605660f, 0.06341503f, 0.05156972f, 0.10790461f, 0.00106528f, -0.09544618f, -0.20514524f, -0.03868401f, 
    0.41514251f, 0.04471738f, 0.03921446f, 0.22431417f, -0.26269221f, -0.07362590f, 0.13946398f, -0.09216360f, 
    0.01536266f, -0.05130482f, -0.07151252f, 0.07777310f, 0.08973558f, 0.05425231f, -0.08628064f, 0.15519392f, 
    0.02727893f, -0.00677174f, 0.04730265f, 0.14104418f, -0.06403393f, 0.10655683f, -0.04994252f, 0.06618706f, 
    0.04569121f, 0.17087878f, -0.00236422f, 0.13578512f, -0.07510529f, 0.09989353f, 0.21756196f, 0.01703972f, 
    -0.02165911f, -0.08692002f, -0.04432165f, 0.00592499f, 0.11750451f, -0.43202913f, -0.13714756f, -0.12311612f, 
    0.08911820f, -0.02205169f, 0.05668733f, 0.00524891f, 0.05319290f, -0.02852510f, 0.13521850f, 0.00602711f, 
    -0.15931031f, 0.14738452f, 0.14286521f, 0.10659488f, 0.05177931f, 0.03275949f, 0.10771219f, 0.19682302f, 
    -0.19323544f, -0.00291662f, -0.09292586f, -0.07705487f, 0.12887247f, 0.09530315f, 0.08860966f, -0.06918489f, 
    -0.01981393f, 0.05011632f, -0.15000448f, 0.04033309f, 0.11351126f, 0.03206788f, 0.02843205f, 0.06392744f, 
    0.16641271f, -0.16436613f, -0.25230712f, 0.23137636f, 0.08954827f, 0.04156460f, -0.00848907f, -0.04251976f, 
    -0.03637484f, 0.17702886f, -0.03849513f, -0.04306653f, -0.00544997f, -0.24493869f, -0.17315684f, 0.01199161f, 
    0.12517712f, -0.08772086f, -0.05716048f, 0.06079487f, -0.07386289f, -0.03299439f, 0.04036123f, 0.05124915f, 
    -0.02018931f, -0.16613023f, -0.24826041f, -0.19809338f, 0.14080924f, -0.11521934f, -0.01387673f, 0.16298768f, 
    0.17403120f, -0.02838245f, -0.02505040f, 0.04615297f, -0.06739988f, 0.24991471f, 0.05929028f, 0.06537081f, 
    -0.01660289f, 0.03217267f, 0.16466996f, 0.02045166f, 0.02853449f, 0.05575774f, 0.08266402f, -0.01671469f, 
    0.25796688f, 0.06131209f, 0.28293166f, 0.28536755f, -0.17250250f, 0.13620859f, 0.00177656f, -0.01551413f, 
    -0.13028143f, -0.03980025f, 0.00425192f, 0.06270797f, -0.13367517f, -0.06082505f, -0.00086032f, 0.14378975f, 
    -0.10115958f, -0.07436346f, -0.05208484f, -0.00190898f, -0.03949731f, 0.05705691f, 0.06527150f, -0.06229946f, 
    0.35318860f, -0.08230460f, -0.00405481f, -0.18234763f, -0.02072308f, 0.05514668f, -0.01033192f, 0.16911629f, 
    0.06876481f, 0.00859492f, -0.08545376f, -0.02401582f, 0.09529337f, -0.32904935f, 0.09016322f, -0.04458843f, 
    -0.04219062f, 0.04909606f, 0.10125941f, -0.02837475f, 0.02654238f, -0.04739485f, -0.02822214f, 0.00460052f, 
    -0.07439557f, 0.07455515f, 0.01631250f, -0.11151785f, 0.01267064f, -0.05254601f, 0.09701969f, 0.06652220f, 
    -0.06268161f, 0.07331549f, 0.10237589f, -0.08900592f, -0.19193409f, 0.28497931f, 0.06629917f, -0.33380857f, 
    0.03451972f, 0.04869691f, -0.10277832f, 0.07216689f, -0.07956667f, -0.03341746f, 0.01111072f, 0.03551108f, 
    -0.23232615f, 0.03505325f, -0.14710599f, 0.13574399f, 0.15081991f, 0.09741091f, 0.11959312f, 0.07174217f, 
    -0.07940400f, 0.04408044f, 0.08700722f, 0.00248898f, 0.31160325f, -0.05818769f, 0.04894636f, 0.13258658f, 
    0.14840683f, -0.09733921f, -0.07903083f, 0.03579570f, -0.06785413f, -0.04858280f, 0.00398542f, -0.09505945f, 
    -0.15596713f, 0.04747221f, 0.07418301f, 0.03528965f, 0.14790021f, 0.03492591f, 0.03669276f, 0.07758651f, 
    -0.00070569f, 0.03214937f, 0.05223654f, 0.01645214f, -0.03017063f, 0.43046191f, 0.05231616f, 0.00301964f, 
    0.10791834f, 0.01048068f, 0.05469048f, 0.03520772f, 0.14410751f, 0.08970363f, -0.00056293f, -0.08451176f, 
    -0.20805819f, 0.02289186f, -0.06729699f, -0.01457153f, 0.15587224f, 0.06889174f, 0.04878452f, 0.09347785f, 
    -0.00524362f, -0.01020795f, -0.03578661f, 0.04782630f, -0.21631138f, 0.03866788f, 0.18007073f, -0.06276634f, 
    -0.16260618f, -0.05165208f, -0.06778758f, -0.03669504f, -0.03775606f, -0.16507976f, -0.05961375f, 0.00649317f, 
    -0.20402765f, 0.16507120f, 0.08734390f, 0.11562774f, 0.08283617f, 0.07045013f, -0.00547267f, -0.08366051f, 
    -0.06421688f, -0.09252118f, 0.03313176f, -0.07090876f, 0.01351414f, 0.31638294f, 0.10333616f, -0.10533711f, 
    -0.01195690f, -0.04976070f, -0.04260210f, -0.08515622f, 0.00379394f, -0.09764074f, 0.02869697f, -0.12286232f, 
    0.10275378f, 0.08976260f, 0.10268348f, -0.26212254f, 0.00760971f, 0.07109907f, 0.01720811f, 0.04692644f, 
    -0.12757282f, 0.08548459f, 0.07904460f, -0.01467596f, -0.12405860f, -0.25654298f, -0.02220231f, 0.25345576f, 
    0.22353688f, -0.00144777f, 0.08798635f, -0.06044189f, 0.02484108f, -0.00547330f, 0.07439523f, 0.05484936f, 
    0.06166438f, 0.03604643f, 0.03578671f, 0.17141105f, 0.25707525f, -0.06767944f, 0.06737716f, 0.03225576f, 
    0.02612989f, 0.07139747f, 0.15475127f, -0.00584113f, 0.07177050f, 0.20566772f, -0.05175012f, 0.24751827f, 
    0.13778232f, -0.09421191f, -0.02649283f, 0.01393797f, 0.01820684f, 0.05960651f, -0.03540507f, -0.06773680f, 
    0.03119477f, -0.01441525f, -0.02853684f, 0.01691076f, 0.00734180f, 0.04265067f, 0.02809737f, 0.04534405f, 
    0.01718980f, -0.02596390f, 0.00956594f, -0.04545166f, 0.01635884f, -0.05502687f, -0.06440046f, -0.07456771f, 
    -0.04679774f, -0.06628007f, 0.03607023f, 0.04613242f, 0.02018882f, -0.04177178f, 0.07577537f, -0.08936235f, 
    -0.01878956f, -0.05992000f, 0.03371569f, 0.00805895f, 0.03860415f, -0.00403368f, -0.02017147f, 0.04209626f, 
    -0.02156099f, 0.05491702f, 0.00015000f, -0.08239002f, 0.01486350f, 0.05149874f, 0.02981311f, -0.08958675f, 
    0.01802400f, 0.01458670f, -0.09659626f, -0.08811104f, -0.04193970f, -0.00495349f, -0.04031102f, -0.04253990f, 
    0.00572014f, -0.08451872f, -0.00333229f, 0.02817131f, -0.05790347f, 0.00400025f, -0.08473808f, -0.05244887f, 
    0.00875316f, -0.00435916f, 0.03894233f, -0.00627225f, -0.09905142f, 0.00864142f, -0.02506734f, -0.08026788f, 
    -0.00505983f, 0.03615689f, 0.02868022f, 0.04691933f, -0.01448954f, 0.04676508f, 0.05546944f, -0.05200114f, 
    0.06661690f, -0.02124500f, 0.03633454f, 0.04411532f, -0.06966513f, -0.03676591f, -0.05530528f, -0.04256040f, 
    0.00132972f, 0.03616216f, 0.01309235f, 0.02383519f, 0.06058770f, -0.01688446f, 0.00627178f, 0.03172297f, 
    0.05894018f, 0.04946050f, -0.00708217f, -0.06686522f, 0.00222223f, -0.03948035f, -0.03409249f, -0.06613632f, 
    -0.02341620f, 0.00739382f, -0.07403358f, 0.01083267f, -0.03273909f, -0.05365817f, 0.04135437f, -0.09588546f, 
    0.05547103f, -0.01586795f, -0.07411288f, 0.03442544f, 0.03924178f, -0.00779163f, -0.04959427f, -0.05751418f, 
    -0.03095677f, 0.01405965f, 0.00725645f, -0.01282789f, -0.00892461f, 0.05021464f, -0.04619081f, -0.06446899f, 
    -0.01927717f, -0.05513597f, -0.02433299f, 0.00380626f, 0.04158437f, -0.03853121f, 0.06509443f, -0.01475235f, 
    -0.02682176f, -0.00827913f, -0.02659440f, -0.04956328f, -0.04508730f, 0.02006013f, -0.04695894f, -0.01909793f, 
    0.05614521f, -0.05451813f, 0.00668723f, -0.01185983f, -0.06356718f, -0.00733277f, 0.00165673f, -0.06877636f, 
    -0.08758131f, -0.03604641f, -0.10210720f, -0.08523288f, -0.06070640f, 0.02639882f, 0.03406987f, -0.06130117f, 
    0.02881015f, 0.02866234f, -0.02612759f, -0.04657745f, 0.00177210f, -0.06448786f, -0.02789481f, -0.07708699f, 
    -0.04531683f, -0.07147755f, 0.03117632f, -0.03646003f, 0.00821826f, -0.06302946f, -0.01016017f, 0.02680182f, 
    -0.01891661f, 0.04701881f, 0.05587814f, -0.04012667f, -0.08663503f, -0.03676553f, -0.00179979f, 0.04688510f, 
    -0.04547808f, 0.03532894f, -0.03032389f, -0.00754640f, 0.04423906f, 0.09345880f, -0.05805497f, -0.08185034f, 
    0.02364929f, 0.03017615f, -0.04092029f, 0.01165953f, -0.06336507f, 0.06413501f, -0.03521921f, -0.05747140f, 
    0.06707256f, -0.05794024f, -0.02661538f, 0.00359325f, -0.04195959f, -0.03268186f, 0.00676061f, -0.01359621f, 
    -0.00227015f, 0.03207858f, -0.00301698f, 0.04378361f, -0.04061497f, 0.04466027f, -0.05846521f, 0.01776319f, 
    -0.00096726f, -0.06264053f, 0.00794856f, -0.02714921f, 0.00310733f, 0.06975033f, 0.01213529f, -0.02301410f, 
    -0.05982575f, -0.00921892f, -0.01275949f, -0.05303106f, 0.05700053f, -0.03809891f, -0.06100492f, 0.05786862f, 
    -0.07100375f, 0.05516787f, -0.02854912f, -0.03770110f, 0.03859429f, -0.04452270f, -0.02106617f, -0.04442879f, 
    0.05446276f, -0.03685886f, 0.04644335f, -0.03556464f, 0.06295756f, 0.01508992f, -0.06162594f, 0.00595713f, 
    -0.03297491f, 0.03462023f, -0.04051366f, -0.04282600f, -0.05241127f, 0.02894310f, 0.05348439f, -0.01699744f, 
    0.03280745f, -0.04339756f, -0.04886855f, -0.01163931f, -0.05465964f, -0.07077571f, 0.06388858f, -0.01316204f, 
    0.03306153f, 0.04787548f, 0.04518044f, -0.05306732f, 0.06266665f, -0.00134988f, -0.04116265f, 0.01006488f, 
    -0.04806512f, -0.05701020f, -0.00052664f, 0.04286677f, -0.01287679f, -0.06816803f, -0.04839923f, -0.03882773f, 
    -0.02222225f, 0.05694909f, 0.05522890f, -0.05309321f, -0.00538969f, -0.06925590f, 0.00683547f, -0.06442267f, 
    0.03093236f, -0.02180323f, -0.06036894f, -0.04776423f, 0.05679521f, -0.04377919f, -0.05502786f, -0.00442558f, 
    -0.01477744f, -0.04063511f, 0.02913772f, 0.05558860f, -0.02434199f, -0.03504179f, -0.02104695f, -0.06204975f, 
    0.03260009f, 0.06229213f, -0.00924410f, 0.02219743f, 0.01499548f, 0.04754381f, -0.02177771f, 0.00336034f, 
    0.01958881f, -0.05731911f, -0.05963112f, -0.03274246f, -0.03682374f, 0.01532351f, 0.02249679f, 0.03506595f, 
    0.04473262f, 0.04371617f, 0.07209338f, -0.00418678f, 0.02702485f, 0.02022951f, -0.00026990f, -0.00865719f, 
    -0.00292896f, -0.06982858f, -0.06026622f, 0.00298562f, -0.00167255f, 0.06829603f, 0.04294668f, -0.01972498f, 
    0.03127474f, 0.02776748f, 0.07191070f, 0.03727002f, -0.06468066f, -0.02274805f, -0.03846285f, 0.02927073f, 
    -0.00395697f, -0.00978122f, -0.01511644f, -0.03704273f, -0.07130327f, -0.02100681f, -0.03318024f, -0.00351547f, 
    -0.06688524f, -0.07098968f, -0.06576045f, 0.00540181f, -0.01849291f, 0.03123288f, 0.02837208f, -0.05696809f, 
    0.02341654f, -0.00536527f, 0.03878479f, -0.00301148f, -0.00613910f, 0.03450485f, -0.04614098f, 0.03874300f, 
    -0.02485502f, 0.06357268f, -0.03869338f, 0.00980785f, 0.03929294f, 0.02858087f, -0.02220747f, 0.00758815f, 
    -0.07008947f, -0.05814323f, -0.05632098f, 0.01327410f, -0.00085911f, 0.01091438f, -0.04675714f, 0.00198535f, 
    0.03282828f, -0.03319198f, -0.06014368f, -0.00593428f, 0.00832673f, -0.02267221f, -0.04232000f, -0.06063446f, 
    -0.10119370f, -0.14966026f, 0.04722704f, 0.27232787f, 0.14558668f, -0.20844698f, 0.17994949f, -0.14986223f, 
    0.08940180f, -0.06317264f, 0.05236141f, 0.02054085f, -0.34060621f, 0.07545570f, -0.11344359f, -0.01397100f, 
    0.14380249f, 0.10208104f, -0.08120441f, 0.12208737f, 0.02598466f, 0.05063030f, 0.09402890f, 0.05112186f, 
    0.35012099f, -0.07118272f, 0.05947317f, -0.21159366f, -0.05639591f, 0.16242130f, 0.04241723f, -0.01815395f, 
    0.15077332f, 0.05182164f, -0.03629881f, 0.01801563f, -0.00588406f, -0.10502568f, -0.07982578f, 0.16601206f, 
    0.04693003f, -0.03208517f, 0.14911993f, 0.02686268f, 0.10211969f, -0.04217614f, -0.01614419f, 0.10409702f, 
    -0.10614690f, 0.24062032f, 0.12239841f, 0.00152972f, 0.05511336f, 0.13047290f, -0.05716730f, 0.02009365f, 
    -0.09795347f, -0.06886785f, -0.05803825f, -0.14511926f, -0.38308650f, 0.11875319f, -0.04902316f, -0.01074695f, 
    -0.02231137f, 0.04191204f, 0.08964901f, -0.13467632f, 0.12882243f, 0.03500170f, -0.03772997f, 0.14183748f, 
    0.24634519f, -0.19578476f, -0.08381554f, 0.00134480f, -0.01407546f, 0.02931484f, 0.07737239f, -0.02762847f, 
    0.02718828f, -0.03944414f, 0.04473676f, 0.01323498f, -0.16351379f, -0.15289877f, 0.14987598f, 0.14304991f, 
    -0.28622183f, 0.00158523f, -0.10494632f, 0.05714970f, -0.08213014f, -0.08943758f, 0.07700741f, 0.02941751f, 
    0.36323994f, -0.00490268f, 0.24724281f, -0.00298519f, -0.04497210f, -0.04316925f, -0.00286957f, 0.00136827f, 
    -0.00654834f, -0.03999545f, -0.05759513f, 0.02552115f, -0.17636012f, -0.09986442f, -0.17413545f, 0.26629913f, 
    0.08236922f, -0.06756279f, 0.01657098f, 0.03752786f, 0.07535203f, 0.11234175f, 0.06307922f, 0.00264236f, 
    0.16800994f, 0.10550232f, -0.12853599f, -0.07624816f, -0.07081212f, 0.01153557f, 0.05357335f, 0.12265040f, 
    -0.02841980f, 0.14572616f, 0.03421439f, 0.03507950f, -0.00910665f, -0.03118807f, -0.13591710f, 0.08846352f, 
    -0.02306730f, -0.05224730f, 0.00187924f, 0.06020865f, -0.00646958f, 0.01518368f, -0.07935335f, 0.10177687f, 
    0.01314639f, -0.18380168f, -0.03099419f, 0.15466076f, -0.12533654f, -0.04282620f, -0.00987096f, -0.05536595f, 
    -0.02196757f, 0.01112394f, -0.01956095f, 0.04305616f, -0.01345629f, 0.20429461f, 0.05460895f, -0.21904850f, 
    -0.03641694f, 0.10767830f, 0.01068359f, 0.00699995f, -0.01813892f, -0.04138058f, -0.02475905f, 0.01304211f, 
    0.07803325f, -0.00480420f, 0.13191797f, -0.15481099f, 0.02296359f, 0.01539417f, 0.12534100f, 0.14235771f, 
    -0.04976627f, 0.07710283f, -0.07311510f, 0.13523181f, 0.18449192f, -0.12900731f, 0.01398534f, -0.20994374f, 
    -0.09245609f, 0.08054836f, 0.02469822f, -0.03941025f, -0.04070611f, 0.00433825f, 0.05084325f, 0.13882957f, 
    -0.23890276f, 0.20999356f, -0.18762480f, -0.04581880f, 0.09000997f, 0.07836708f, -0.08135402f, 0.03840653f, 
    0.10127535f, -0.03756516f, 0.00735388f, 0.17785800f, -0.30260092f, 0.08653688f, 0.12875777f, -0.02017985f, 
    0.00147411f, 0.11104976f, -0.01702953f, 0.06155781f, -0.03296500f, -0.02610475f, 0.16894427f, 0.08410522f, 
    -0.01868985f, -0.00604614f, 0.28103074f, -0.21645479f, -0.01219489f, -0.00864686f, -0.01733457f, 0.13210367f, 
    -0.09535288f, 0.10451882f, 0.15866055f, 0.07762143f, -0.12544313f, 0.13839173f, -0.06806809f, -0.17513072f, 
    0.01849343f, -0.08622683f, -0.10338060f, 0.01193632f, 0.01058108f, -0.01955489f, 0.15844147f, 0.07511327f, 
    -0.20501357f, 0.00134875f, 0.15846466f, -0.03162737f, 0.01797642f, 0.10349106f, 0.19094835f, 0.16130024f, 
    -0.01246989f, -0.07367466f, -0.25759450f, -0.04609184f, -0.03664618f, -0.07743272f, 0.14519498f, -0.20620242f, 
    -0.01193785f, 0.05197218f, -0.02965293f, -0.05493874f, -0.09674747f, -0.06076590f, -0.01125058f, 0.00647592f, 
    0.01534794f, 0.04863233f, -0.13527237f, -0.01605180f, 0.13548946f, -0.03075659f, 0.02727048f, 0.03893791f, 
    0.07988421f, 0.06103732f, -0.00049937f, 0.02265036f, 0.00189218f, 0.08281622f, 0.00926896f, -0.01902585f, 
    0.00170878f, -0.00923907f, 0.02242433f, 0.16531360f, -0.12250656f, -0.00192179f, 0.05280725f, -0.05863255f, 
    -0.13005088f, -0.06738736f, -0.32615662f, 0.23293807f, -0.02072806f, 0.07670497f, -0.00060494f, 0.11434672f, 
    0.01082721f, 0.01672240f, -0.10644906f, 0.05551614f, 0.01541672f, -0.03750518f, -0.00303473f, 0.10187056f, 
    -0.16293199f, -0.14592363f, 0.09401421f, -0.00224901f, 0.01048677f, -0.06185603f, -0.04868898f, 0.05393973f, 
    -0.24480487f, 0.11426613f, 0.35154116f, -0.20868440f, 0.03266103f, -0.04341772f, 0.11396772f, 0.14707573f, 
    0.02698216f, -0.06176664f, 0.03022389f, 0.00688955f, 0.06726956f, 0.08117209f, 0.01977429f, -0.08197474f, 
    0.05327330f, -0.10307644f, 0.04504361f, 0.14366464f, 0.06634766f, 0.04080579f, 0.00323966f, 0.07389190f, 
    -0.03739813f, -0.08726040f, -0.04418781f, 0.02220835f, -0.02318224f, 0.10004994f, 0.03777491f, -0.06224514f, 
    0.01472468f, -0.00988052f, 0.01981178f, 0.17426826f, 0.14075175f, -0.09813538f, -0.11244731f, 0.05319776f, 
    0.00980235f, -0.04789283f, -0.15867482f, 0.11268363f, -0.04466743f, -0.08345202f, -0.00570135f, 0.00226031f, 
    0.08890202f, -0.25459775f, 0.02794821f, -0.01305012f, 0.28601351f, 0.00921504f, 0.06043942f, 0.11956342f, 
    0.01719435f, 0.01081925f, 0.00454549f, 0.00525587f, 0.18734106f, 0.11151975f, 0.08411654f, -0.12745747f, 
    0.21971028f, 0.02175583f, -0.11398903f, 0.06582426f, 0.04764495f, 0.00619273f, 0.07596008f, -0.00278123f, 
    -0.03933831f, -0.05454076f, -0.06265466f, -0.06614174f, -0.01100777f, 0.05799187f, -0.01572504f, 0.05384466f, 
    -0.03203449f, -0.05792882f, -0.02434570f, 0.06357270f, -0.04704704f, -0.01722715f, 0.06471494f, 0.00049889f, 
    -0.05509173f, 0.05102240f, 0.02477424f, -0.03443700f, 0.04885535f, -0.06665072f, -0.05770165f, -0.06963911f, 
    -0.06630132f, 0.06327192f, 0.00436216f, 0.03979319f, 0.00815021f, 0.01206737f, -0.04528656f, -0.07399537f, 
    -0.02942406f, 0.04674750f, 0.04299875f, -0.03240200f, -0.07427956f, -0.06311374f, 0.00637763f, 0.01588966f, 
    -0.02385724f, -0.05949928f, -0.00924575f, -0.01729257f, -0.04906580f, 0.00986540f, -0.05212582f, -0.00063750f, 
    -0.02317063f, 0.04542657f, 0.02049101f, 0.02864093f, -0.03799112f, -0.00411027f, -0.05461440f, -0.06961741f, 
    -0.07280737f, -0.02798791f, -0.04769886f, 0.04359704f, 0.02941246f, -0.02129887f, -0.06830485f, -0.05519580f, 
    -0.06100225f, -0.04073012f, 0.01966590f, -0.04923739f, -0.03873250f, -0.06623904f, -0.05304343f, -0.02253630f, 
    0.06509421f, -0.06556124f, 0.01067752f, -0.03884088f, 0.01526835f, 0.05125205f, 0.02232474f, -0.06414697f, 
    0.00371890f, 0.03361166f, 0.04948934f, -0.01079364f, 0.04222981f, 0.00212514f, -0.01017082f, -0.03525622f, 
    0.04124820f, -0.07073443f, -0.05638735f, -0.03713414f, -0.04433670f, 0.03976516f, -0.02473097f, 0.05074142f, 
    -0.00358390f, 0.05937824f, 0.00018264f, -0.01725130f, 0.05926236f, -0.07673703f, -0.01285809f, 0.04101977f, 
    0.01473274f, -0.04786380f, 0.02474522f, 0.05244335f, -0.00069716f, -0.01349715f, -0.04232997f, -0.05405948f, 
    -0.04816552f, 0.03159110f, -0.02840780f, -0.03523916f, -0.02841971f, -0.03830347f, -0.05063044f, 0.02795241f, 
    0.05170542f, 0.04106086f, 0.06675252f, 0.06417897f, 0.05933192f, 0.05120375f, -0.05821872f, 0.03505046f, 
    0.00847827f, -0.05772787f, -0.03269748f, 0.04341800f, -0.03494879f, 0.04483441f, -0.01588614f, -0.03864323f, 
    -0.06425843f, -0.07131121f, -0.01892883f, 0.02193044f, -0.06359393f, 0.03858560f, -0.05079995f, -0.06747030f, 
    -0.00843424f, 0.00804284f, 0.06294614f, 0.00828072f, -0.03582375f, 0.03001180f, 0.02560411f, -0.06407154f, 
    -0.07346242f, 0.06260491f, 0.03257265f, -0.05892419f, 0.02803959f, -0.03369832f, -0.07352573f, 0.05580106f, 
    0.01848995f, -0.06594068f, -0.07372732f, 0.03121136f, 0.05540378f, -0.02627644f, -0.01434199f, 0.00062445f, 
    -0.02775848f, -0.01684000f, 0.04531245f, -0.04578704f, -0.06080187f, 0.00504246f, -0.00070936f, 0.00730594f, 
    0.04736627f, 0.03042169f, 0.05319975f, -0.01115679f, 0.00867293f, -0.02434404f, -0.00272212f, 0.04331271f, 
    -0.03164714f, 0.04260824f, -0.03650336f, -0.00620994f, -0.04876770f, -0.01371625f, -0.07135279f, 0.01975244f, 
    0.09353559f, -0.14339341f, 0.05664395f, -0.21000035f, 0.04808982f, -0.10724036f, 0.05066341f, 0.01226044f, 
    -0.01505531f, 0.01100616f, -0.06132161f, -0.09977736f, -0.23744577f, -0.15792379f, 0.15597361f, -0.05065448f, 
    0.01872163f, -0.01201155f, -0.03376577f, -0.03838302f, 0.02289489f, 0.02604862f, -0.13596991f, -0.01188390f, 
    0.06425963f, 0.08194149f, 0.13780573f, -0.12249856f, 0.06025060f, -0.09043231f, -0.01419051f, 0.10950380f, 
    0.10456269f, -0.17997149f, -0.00529243f, -0.07502683f, -0.05278814f, 0.10404360f, 0.05279608f, -0.11277796f, 
    0.03596296f, -0.07879917f, -0.02194689f, 0.03178303f, -0.04526092f, -0.06317545f, -0.11738978f, -0.05408687f, 
    -0.08999702f, 0.22019301f, 0.08938777f, 0.15263841f, 0.14873287f, 0.07788019f, -0.10583692f, 0.04371840f, 
    -0.03850047f, -0.01460368f, 0.29773512f, 0.12953636f, 0.39937547f, -0.03548346f, 0.25219774f, 0.14938059f, 
    0.05996932f, -0.02771213f, 0.08005224f, 0.05253856f, 0.06215927f, 0.15772468f, -0.16461636f, 0.13115209f, 
    -0.21758519f, -0.12916306f, -0.04620045f, -0.14959666f, 0.05286162f, 0.09852868f, 0.00538214f, 0.01426129f, 
    -0.02977154f, -0.15832408f, 0.03294659f, 0.10223886f, 0.03040475f, 0.16029422f, 0.04157344f, -0.01695940f, 
    0.01996883f, 0.00818989f, 0.00426097f, 0.07009950f, 0.08816521f, -0.04508011f, 0.09644334f, -0.09747586f, 
    -0.22552697f, 0.04328976f, 0.01665788f, -0.23092426f, 0.06790470f, 0.14434764f, 0.03717923f, 0.03257069f, 
    0.00460750f, -0.00243069f, 0.08407569f, 0.23226969f, -0.24129024f, -0.17299871f, -0.01728538f, 0.23589469f, 
    0.04098080f, -0.07316861f, -0.07837469f, -0.15427175f, 0.03588834f, -0.04513727f, -0.07499770f, 0.07492979f, 
    -0.32808432f, 0.24580559f, 0.03643610f, 0.34443557f, 0.07302459f, 0.02401563f, -0.00669482f, 0.06690187f, 
    0.09992941f, -0.05298907f, -0.13866673f, -0.01947869f, -0.23540573f, 0.23689987f, -0.12543178f, -0.04736027f, 
    -0.01054050f, 0.13256149f, 0.15916944f, -0.08305245f, 0.07069405f, 0.13464093f, -0.10906997f, -0.00532155f, 
    0.04829180f, -0.01531633f, -0.03348472f, 0.00476292f, -0.13882092f, 0.08571157f, -0.03659384f, -0.20326516f, 
    -0.03202642f, -0.10670492f, 0.18517232f, -0.13713351f, -0.27149820f, -0.03544034f, 0.17966136f, 0.01646828f, 
    0.12227841f, 0.04819299f, 0.12960730f, -0.07530912f, 0.10671612f, 0.04455462f, 0.07285437f, 0.10572948f, 
    0.12932462f, -0.15212111f, 0.20759554f, 0.02765520f, 0.18699475f, 0.01930775f, 0.08178066f, 0.11843516f, 
    0.08801358f, -0.11995028f, 0.10767671f, 0.04989380f, 0.00698717f, 0.22467875f, -0.20347242f, -0.19420232f, 
    -0.01254969f, 0.07802417f, 0.18486698f, -0.08407920f, -0.11202181f, 0.08286569f, -0.00525176f, 0.11651440f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.02261114f, -0.07408369f, 0.14416529f, 0.00313990f, 0.03845584f, 0.02650737f, -0.08024860f, 0.01251373f, 
    0.04280223f, 0.06303821f, 0.06544536f, -0.01434700f, 0.06190357f, 0.08452056f, 0.05472488f, 0.02544091f, 
    -0.04463042f, -0.05346919f, -0.01704540f, 0.12498143f, -0.01277526f, -0.00926539f, 0.10440756f, 0.03805645f, 
    0.04423214f, 0.04500118f, -0.01917512f, 0.02506184f, 0.00083197f, -0.08771592f, -0.08008347f, -0.04863754f, 
    0.04735874f, -0.08395065f, -0.03556585f, 0.08507252f, -0.03522534f, -0.02273448f, -0.01556826f, -0.04104354f, 
    0.16338927f, -0.03848257f, -0.07195869f, -0.10007503f, -0.01988155f, -0.03931034f, -0.03729662f, 0.01585427f, 
    0.04712798f, 0.05336079f, -0.05199616f, -0.01926007f, 0.03617807f, -0.06163627f, 0.06734678f, 0.05437737f, 
    0.18092725f, 0.09499873f, 0.03522192f, 0.05021072f, 0.06240372f, -0.01468983f, -0.06268835f, 0.02357109f, 
    -0.02398969f, -0.05839473f, -0.09113429f, -0.09350950f, 0.08996269f, -0.02932564f, 0.09357462f, -0.01094729f, 
    -0.06564596f, 0.01818241f, 0.06356945f, 0.00152759f, -0.06240028f, 0.01130003f, 0.01727884f, -0.02455929f, 
    0.08306430f, -0.00068947f, 0.06698050f, 0.04300544f, -0.03357156f, 0.08189350f, 0.03054676f, -0.06311668f, 
    0.03073743f, 0.04198767f, -0.03771474f, 0.04129886f, -0.10245562f, -0.01598573f, 0.05760529f, 0.04780319f, 
    0.13792571f, -0.05509784f, -0.03320080f, 0.02873063f, -0.01966614f, 0.01463496f, -0.05725251f, 0.04249632f, 
    0.00983057f, -0.01952569f, -0.05143979f, 0.01773489f, -0.04201547f, 0.06056490f, 0.07942046f, 0.00007784f, 
    -0.03702093f, -0.00926996f, -0.05891488f, -0.04322048f, 0.01630538f, 0.01995962f, 0.04514572f, 0.05333991f, 
    0.07194787f, -0.00631030f, 0.05467078f, 0.02753189f, 0.04404578f, -0.04067512f, -0.03752617f, 0.06089713f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.12494750f, -0.18134585f, -0.39956087f, -0.09462720f, -0.12787648f, 0.13508812f, 0.22761410f, 0.07061575f, 
    -0.05393146f, -0.12088108f, 0.02792056f, -0.03371698f, 0.00104206f, -0.72318679f, 0.04337283f, -0.07059244f, 
    0.32366985f, -0.05238955f, 0.01975918f, -0.16151634f, 0.04521878f, 0.07557256f, -0.26314941f, -0.07004245f, 
    -0.00876464f, -0.42805263f, -0.02876029f, 0.08575816f, -0.07281028f, 0.14940466f, 0.01815568f, 0.06537685f, 
    0.19393390f, 0.10522359f, 0.01562152f, -0.32344696f, 0.18627283f, -0.27796596f, 0.04032431f, -0.22835720f, 
    0.13122238f, 0.00640522f, -0.10817073f, 0.21744677f, 0.00750297f, -0.22427920f, 0.04746797f, -0.38766387f, 
    -0.31862921f, 0.09393014f, -0.03171129f, 0.03242450f, -0.16642909f, 0.04277102f, 0.11897169f, 0.00016192f, 
    -0.21296512f, -0.10330142f, 0.17105094f, -0.02094748f, -0.08047745f, 0.02626376f, -0.02397896f, 0.01494952f, 
    -0.02226895f, 0.03921428f, 0.21757235f, 0.05330779f, -0.29022577f, -0.13535343f, 0.00011489f, 0.07474503f, 
    -0.06411981f, -0.05244579f, -0.28106821f, -0.37972471f, 0.36919922f, 0.04071661f, -0.05159507f, 0.05569183f, 
    -0.36629245f, 0.01012636f, -0.06279299f, -0.03250920f, -0.11842472f, 0.00039794f, 0.14498885f, -0.03406915f, 
    0.01175700f, -0.27677727f, 0.08919542f, 0.05268908f, 0.08886061f, -0.31493136f, -0.15220322f, 0.05324847f, 
    -0.04316299f, 0.25159886f, -0.31260976f, -0.04439889f, 0.33492422f, 0.15614268f, 0.00590258f, -0.08071880f, 
    -0.00895398f, 0.26442140f, -0.03672967f, -0.03097110f, 0.20591427f, 0.13712892f, -0.12017598f, -0.02150463f, 
    -0.02687381f, -0.00004363f, -0.03424857f, 0.04592932f, 0.35580176f, 0.07712056f, 0.21867961f, 0.37653014f, 
    -0.76135790f, -0.03131161f, 0.07623436f, 0.06180246f, 0.07432158f, 0.21058159f, 0.02839915f, 0.12508665f, 
    0.00344527f, -0.07629845f, -0.24894439f, -0.03026914f, 0.10612615f, 0.11306508f, 0.11193068f, -0.01894379f, 
    -0.05527257f, -0.24538733f, 0.08247095f, 0.06376862f, 0.19400628f, 0.38320932f, 0.05703811f, 0.07004075f, 
    -0.03478227f, -0.02499331f, -0.03711072f, 0.39332029f, 0.12286060f, -0.05475814f, 0.20825490f, -0.16596249f, 
    -0.02806507f, -0.24978009f, 0.09658460f, 0.07583559f, 0.08282627f, 0.17589073f, 0.03159988f, -0.05459126f, 
    -0.14812274f, 0.24564275f, 0.07858960f, -0.03818383f, -0.04469355f, -0.25048849f, -0.04171358f, 0.02967255f, 
    0.17697707f, -0.00102653f, -0.26212475f, -0.06706766f, 0.04378673f, 0.18599366f, 0.20967460f, 0.06465162f, 
    0.31880006f, 0.04044107f, -0.05295954f, 0.21898818f, 0.13135418f, 0.07162945f, -0.01155622f, -0.08933552f, 
    -0.11919285f, 0.11923105f, -0.00057329f, 0.10440533f, -0.00500905f, -0.07787466f, -0.03614352f, 0.06522328f, 
    -0.08115965f, -0.24990703f, -0.07338546f, -0.12399574f, -0.35016903f, -0.15996516f, -0.12622575f, 0.01787491f, 
    -0.06297187f, 0.06343639f, 0.10813513f, 0.00766505f, -0.38021824f, -0.02773044f, -0.05630324f, -0.06120294f, 
    -0.10272983f, 0.02916351f, -0.13554448f, -0.17039470f, -0.03939384f, -0.61269093f, -0.00782161f, -0.07102537f, 
    -0.07252917f, -0.32388920f, -0.29901201f, 0.21820301f, -0.00412559f, -0.21097864f, -0.29186764f, 0.02107438f, 
    0.13876443f, 0.21746434f, -0.29975238f, 0.04231799f, -0.16704530f, 0.20375310f, 0.07428241f, 0.04424731f, 
    -0.06518909f, 0.05675205f, -0.03850055f, 0.06557958f, -0.16777104f, 0.07469085f, -0.25763163f, 0.15973911f, 
    -0.08700836f, 0.02863598f, 0.06364249f, -0.09002702f, -0.12781623f, 0.21492824f, -0.06029068f, -0.48502883f, 
    0.24311584f, -0.07971492f, -0.00883705f, 0.07930049f, 0.16438389f, 0.10678433f, -0.01780791f, -0.56105000f, 
    -0.18670124f, -0.00075660f, 0.02568198f, 0.28753695f, 0.06568357f, -0.10277468f, -0.20128964f, 0.05613542f, 
    -0.01608895f, -0.03947430f, 0.23203108f, -0.03522955f, 0.26280570f, -0.23981857f, 0.14988345f, 0.07622829f, 
    -0.10881292f, -0.03123377f, -0.03781917f, -0.36136830f, 0.12358294f, 0.06936388f, -0.47260532f, 0.11429779f, 
    -0.34898052f, 0.25970605f, 0.02877541f, -0.23882075f, 0.04596751f, 0.18926817f, -0.05247928f, 0.05678408f, 
    0.13107494f, 0.16739294f, -0.05926429f, -0.00404030f, 0.07087054f, -0.24211830f, -0.06760518f, 0.28268933f, 
    0.03300868f, 0.00528304f, 0.16207317f, -0.67842287f, 0.03503660f, 0.24505548f, -0.26950386f, 0.35720235f, 
    0.14745690f, 0.12439615f, 0.00267220f, -0.32090238f, 0.09540890f, -0.06245298f, -0.02305579f, 0.06741130f, 
    -0.33734268f, 0.12952079f, -0.30359641f, 0.18151036f, -0.12865379f, 0.03315793f, -0.02150799f, -0.02119338f, 
    -0.00415527f, -0.25449342f, -0.00707734f, -0.18575014f, 0.08941384f, -0.40699777f, -0.06774667f, 0.07624075f, 
    0.02123844f, 0.07542288f, -0.34247354f, -0.43524402f, -0.18711868f, 0.04214727f, 0.02330335f, 0.07671323f, 
    0.15982276f, 0.01469094f, -0.45826507f, -0.04083104f, 0.23381081f, -0.22849894f, 0.26791939f, -0.04148307f, 
    0.06702697f, -0.04367715f, 0.33078539f, -0.35397556f, -0.25337532f, 0.05024834f, 0.11346820f, -0.04769843f, 
    -0.25336730f, 0.19285940f, -0.02680828f, -0.28715187f, -0.25205499f, 0.15589674f, -0.01981365f, -0.05452886f, 
    -0.04409678f, -0.19976822f, 0.06729326f, 0.15716758f, 0.09778157f, -0.06705526f, -0.35110876f, 0.10446706f, 
    0.07419056f, -0.05427425f, -0.03004336f, 0.08981817f, -0.59343708f, 0.06730147f, -0.00443339f, 0.05218096f, 
    -0.17327268f, 0.10744790f, -0.05402990f, 0.06083803f, -0.30791444f, -0.00851130f, -0.00305513f, -0.31394377f, 
    0.29728049f, 0.30162320f, -0.05262215f, 0.00530561f, 0.13198562f, -0.52077973f, -0.22925426f, -0.01363068f, 
    -0.00175190f, -0.24941371f, 0.33211997f, 0.01754670f, -0.17184024f, 0.01401782f, -0.16475473f, -0.01997606f, 
    -0.09146465f, -0.01853413f, -0.00702431f, -0.66329050f, 0.05325777f, -0.04037658f, 0.07582853f, -0.43687806f, 
    -0.13414282f, 0.10692656f, -0.46701491f, 0.01658695f, -0.02315452f, -0.04646966f, 0.04943955f, -0.05917557f, 
    0.34556642f, 0.20163998f, 0.00750073f, 0.10512998f, 0.10790498f, -0.16023304f, -0.00677824f, 0.02153694f, 
    -0.04584990f, -0.01272133f, -0.04729205f, 0.21400990f, -0.05428124f, -0.43852264f, -0.15500659f, 0.16466014f, 
    0.02118128f, 0.14905669f, -0.02036696f, -0.15053286f, 0.01519307f, 0.06399973f, 0.25582281f, -0.00325542f, 
    0.10013150f, 0.30375740f, -0.14904684f, -0.07066704f, -0.39369491f, 0.07743892f, -0.00161164f, -0.08116345f, 
    -0.05354945f, -0.33092651f, 0.05156063f, 0.05243606f, -0.11119536f, 0.05604506f, 0.24169607f, -0.06462382f, 
    0.04339541f, 0.06136997f, -0.09045114f, 0.03211475f, 0.25794572f, -0.09341238f, 0.04313849f, 0.02253489f, 
    0.08846185f, 0.03006398f, 0.14207581f, 0.08766785f, -0.16876985f, 0.03424360f, 0.13972352f, -0.02376673f, 
    0.02421819f, 0.15450338f, 0.03037602f, -0.25714666f, -0.22240855f, 0.23444268f, -0.03575181f, 0.00433535f, 
    0.23093556f, -0.23106988f, 0.08047369f, -0.11637627f, -0.09743161f, -0.28922907f, 0.01362014f, -0.38148439f, 
    0.07954253f, 0.14862683f, 0.02660226f, -0.26966307f, -0.40785190f, 0.10501315f, 0.02830021f, 0.21138945f, 
    -0.06826637f, 0.02542664f, 0.06565006f, 0.01265202f, -0.17410751f, -0.71388555f, 0.13010883f, 0.23763089f, 
    -0.01240250f, -0.45029020f, -0.11916544f, -0.03487632f, 0.28792801f, -0.09289495f, 0.03895380f, -0.03722851f, 
    -0.18015715f, -0.12017103f, 0.09537658f, -0.03980348f, 0.05749146f, 0.21009462f, -0.05753988f, -0.08140224f, 
    0.01266561f, 0.14219759f, 0.16829863f, 0.07015681f, -0.02287132f, -0.05788413f, -0.26180705f, -0.02146250f, 
    0.09860256f, -0.00740625f, 0.01427075f, 0.03040181f, -0.00522502f, -0.09056851f, 0.23166540f, -0.09949953f, 
    0.24707800f, 0.13274422f, -0.06837600f, -0.17855202f, -0.02674264f, 0.15623957f, 0.04718598f, -0.02155514f, 
    0.32126665f, 0.00485025f, 0.01965262f, 0.20453104f, -0.18150494f, 0.14030506f, 0.00104671f, -0.44182411f, 
    -0.04442184f, 0.04463331f, 0.21089026f, -0.03071234f, -0.03675886f, -0.22617410f, -0.41893932f, 0.05552251f, 
    -0.68773592f, 0.14745039f, -0.00321704f, -0.05800602f, -0.01103486f, 0.07711849f, -0.00936297f, 0.08914725f, 
    -0.16745609f, -0.07607891f, 0.02877750f, -0.44332388f, 0.10079207f, 0.00518607f, -0.03244248f, -0.02446580f, 
    0.08248248f, -0.16954279f, -0.07220536f, 0.12975131f, -0.12522882f, 0.25750667f, -0.29543379f, 0.05198687f, 
    -0.06129508f, 0.03732863f, 0.31116173f, 0.13285370f, -0.14392813f, 0.06476265f, 0.05146547f, -0.02076241f, 
    0.11410321f, -0.01437859f, -0.31928137f, 0.00253531f, -0.14511798f, 0.23330358f, -0.03819245f, 0.02165224f, 
    0.01187521f, 0.15397179f, 0.03196931f, 0.25901234f, -0.06704660f, 0.04230038f, -0.07106872f, 0.05562597f, 
    0.23381592f, -0.14735563f, -0.18774657f, -0.15906663f, 0.22918193f, -0.54470628f, -0.00845216f, 0.12428322f, 
    0.04296409f, 0.08424144f, -0.06483580f, 0.18038023f, 0.06719172f, 0.09111634f, -0.19915707f, -0.09059824f, 
    0.02875540f, -0.03192303f, 0.06350541f, 0.07505343f, 0.14679688f, -0.07957417f, 0.14714533f, 0.01571775f, 
    0.17212671f, 0.13194896f, -0.04552764f, 0.00046529f, -0.12764017f, -0.04101080f, 0.02231904f, 0.24231896f, 
    0.19352098f, 0.20810787f, -0.23203290f, 0.08658898f, 0.08545110f, -0.15250327f, -0.04785559f, 0.04589065f, 
    -0.05467079f, -0.10810353f, 0.09509861f, -0.06103539f, 0.13009076f, -0.39304966f, 0.03600208f, -0.03804221f, 
    -0.18044713f, -0.01090950f, -0.00092597f, 0.18254672f, 0.07242122f, -0.03444506f, -0.15190439f, 0.11575159f, 
    0.09503139f, -0.21996966f, 0.06179897f, -0.09179729f, -0.04946060f, -0.24931867f, 0.02956279f, 0.03922789f, 
    -0.54101914f, -0.31318891f, -0.08791251f, 0.00856307f, -0.17189690f, 0.05079594f, 0.02909184f, 0.36494735f, 
    -0.00498859f, -0.01128934f, -0.21776630f, -0.10236642f, 0.00761683f, -0.29699567f, -0.01470933f, -0.25600225f, 
    -0.08216951f, -0.09650294f, 0.08215581f, -0.27729699f, 0.11252991f, -0.06583969f, -0.04667336f, 0.07010832f, 
    0.17649573f, -0.51018363f, 0.24625987f, 0.09751640f, -0.00446156f, -0.00402671f, 0.07761661f, 0.02520164f, 
    0.07926662f, 0.21021071f, -0.27332556f, -0.08835038f, 0.02314720f, 0.33338153f, -0.24641337f, 0.05234841f, 
    -0.07411956f, -0.06130763f, -0.07368995f, -0.08720408f, 0.48827067f, 0.03305186f, -0.05516633f, -0.03385970f, 
    0.01084346f, 0.02418734f, 0.14849673f, -0.41781512f, -0.24588357f, 0.15038939f, -0.03540390f, 0.05498408f, 
    0.05959594f, 0.00315721f, 0.08206430f, -0.45108753f, 0.11761077f, 0.08328075f, -0.19759010f, 0.02612588f, 
    -0.03544966f, 0.00194871f, 0.17483380f, 0.11458705f, -0.09692562f, 0.02750647f, -0.08811664f, 0.06575706f, 
    0.05959978f, 0.05552062f, 0.00221178f, -0.14219406f, -0.03311623f, 0.11149667f, 0.06295384f, 0.09715667f, 
    -0.01596524f, -0.05237062f, -0.02922361f, 0.06834447f, 0.21183778f, 0.04690989f, -0.59006131f, -0.05858193f, 
    -0.11309384f, 0.19116774f, -0.06427177f, -0.04071335f, -0.16751000f, 0.14753273f, 0.01386765f, 0.12154204f, 
    -0.11697789f, 0.07474910f, 0.18031985f, 0.16380350f, 0.03692868f, -0.29303002f, 0.13646649f, -0.00386645f, 
    0.03631031f, -0.07016046f, -0.33023643f, -0.01789425f, -0.24709910f, -0.28870621f, 0.11960939f, -0.06626892f, 
    -0.06121773f, 0.02214874f, -0.02238435f, -0.02939037f, 0.11316420f, -0.07658222f, -0.26478711f, 0.16881178f, 
    0.03128294f, -0.04693351f, -0.05057178f, 0.13841724f, 0.01538349f, -0.38186368f, 0.01885842f, -0.00374305f, 
    -0.14838618f, -0.34182486f, -0.06486211f, -0.49621916f, 0.23495921f, 0.16308446f, -0.04019863f, -0.73327327f, 
    -0.07268212f, 0.01048872f, 0.07053866f, -0.05800264f, 0.01002050f, 0.22700232f, -0.31573236f, -0.20501074f, 
    0.34284338f, -0.19290893f, 0.01775224f, 0.03095593f, -0.15129049f, -0.05072482f, 0.14809182f, 0.02456778f, 
    0.06798527f, 0.33660471f, -0.46368858f, -0.28797242f, 0.16417612f, -0.06621651f, -0.04144171f, 0.00051306f, 
    -0.07414476f, 0.24266016f, 0.03681084f, 0.11240266f, 0.07525299f, -0.23917484f, 0.07347673f, 0.03572113f, 
    0.02947493f, -0.05756551f, 0.28568196f, 0.18916462f, -0.70929158f, -0.00504009f, -0.05850817f, -0.07794341f, 
    0.15689130f, -0.02137039f, -0.02356263f, -0.08600105f, -0.04849367f, -0.28292090f, -0.16141868f, 0.03453396f, 
    0.05885822f, 0.24209248f, 0.16621238f, -0.62269890f, 0.11475756f, 0.02857720f, 0.21431474f, -0.00961651f, 
    0.06963996f, -0.34388781f, -0.10593599f, 0.15598407f, -0.05947712f, -0.03169438f, 0.06950048f, -0.12200255f, 
    -0.04949810f, -0.08428574f, -0.07481083f, -0.32585183f, -0.17893365f, 0.15697943f, 0.11831307f, 0.10848147f, 
    -0.07607137f, 0.01489079f, -0.00961949f, 0.04002116f, -0.32321680f, -0.02411195f, -0.13659887f, -0.45419070f, 
    -0.37210187f, 0.11232731f, -0.00017544f, 0.01407834f, 0.08698331f, -0.30011871f, 0.05028132f, 0.20603760f, 
    -0.34320441f, 0.03967820f, 0.20144305f, -0.12756701f, -0.33232605f, 0.13078836f, -0.06079604f, 0.07244883f, 
    -0.00894963f, 0.23576921f, -0.37875703f, 0.01843553f, 0.10016304f, 0.07875715f, -0.22803000f, 0.04856979f, 
    -0.23801488f, -0.06816290f, 0.03662131f, -0.49930665f, -0.18166991f, -0.01547850f, -0.00182763f, -0.16895734f, 
    0.14155123f, -0.04508895f, -0.27579707f, 0.17510693f, 0.01903871f, 0.10954784f, 0.03456506f, -0.04302033f, 
    -0.11022381f, 0.12596452f, 0.07777030f, 0.12079886f, 0.10581985f, 0.27066812f, -0.07910524f, -0.14285173f, 
    -0.28550225f, -0.03611154f, 0.08764929f, 0.12924330f, -0.00472275f, 0.05318198f, 0.10202000f, 0.14934815f, 
    0.06332695f, -0.44293568f, 0.05869194f, 0.18773939f, -0.02806822f, 0.02221351f, -0.47654158f, -0.05425835f, 
    -0.29963505f, -0.12000852f, -0.02963599f, -0.23306873f, -0.09485061f, -0.08549719f, -0.02993116f, -0.06679770f, 
    -0.02057643f, -0.07816495f, 0.14164343f, 0.00041749f, 0.21116787f, -0.00950130f, -0.10766299f, -0.03108135f, 
    -0.02958603f, 0.03874046f, -0.00449050f, 0.18352437f, 0.18611774f, 0.03467321f, -0.04941634f, 0.01984634f, 
    -0.22173549f, -0.05055458f, 0.14769055f, 0.18681440f, -0.03107095f, 0.15487276f, -0.24290170f, 0.02376997f, 
    -0.09155610f, 0.02499116f, 0.08960264f, 0.09160263f, -0.06589721f, 0.01014445f, 0.14351487f, -0.04045475f, 
    -0.31912747f, 0.09997471f, 0.16016410f, -0.24626815f, -0.08042249f, -0.06567074f, 0.00983968f, -0.23355991f, 
    0.06708169f, -0.19662389f, 0.03244521f, 0.02016526f, -0.19100983f, -0.24859335f, 0.13706322f, 0.01123781f, 
    0.05799970f, -0.03776109f, 0.03237037f, -0.03469354f, 0.12337898f, -0.25245965f, 0.09974167f, 0.20642309f, 
    0.04099599f, 0.17239125f, -0.01157402f, -0.07285558f, 0.01095174f, -0.17355737f, -0.07777033f, 0.17823119f, 
    0.17336464f, -0.04010642f, -0.18763205f, -0.13941924f, 0.15359962f, -0.08306661f, 0.21475326f, -0.06336736f, 
    0.03328048f, 0.18793784f, 0.15506168f, 0.06611988f, -0.09578260f, -0.22424173f, 0.13000003f, -0.02713067f, 
    -0.23177940f, 0.00051274f, 0.07942694f, -0.12051520f, 0.22631407f, -0.08029731f, -0.14686458f, 0.15433370f, 
    -0.03741800f, -0.11423040f, 0.13803382f, -0.57882679f, 0.00004498f, 0.04333409f, 0.06533660f, -0.06621737f, 
    -0.47613138f, -0.41292495f, -0.07996308f, 0.20365582f, -0.04478551f, 0.16567191f, -0.02425638f, 0.07489408f, 
    0.04929272f, -0.00234733f, -0.28531975f, 0.27576733f, -0.01289586f, 0.03565624f, -0.07418162f, 0.26045299f, 
    -0.26396087f, -0.08758547f, -0.01757200f, -0.16044529f, 0.17684999f, 0.02178869f, -0.24267399f, 0.01614407f, 
    0.08201542f, -0.13377090f, 0.08193794f, 0.07660286f, 0.12045543f, 0.05735021f, 0.05331088f, 0.04533662f, 
    0.02771188f, -0.19880858f, -0.30841881f, -0.26606250f, 0.00411052f, 0.12915911f, -0.05990637f, -0.05207981f, 
    -0.06990442f, 0.05655264f, -0.34882662f, -0.14912730f, -0.28818423f, 0.02258348f, 0.07290004f, -0.04844632f, 
    -0.28035426f, -0.07033323f, -0.15382645f, -0.16058594f, 0.12633035f, 0.08930291f, -0.37156251f, 0.04856189f, 
    -0.06757511f, -0.21965499f, -0.28393495f, -0.12033362f, 0.16983999f, 0.18673781f, -0.10727275f, 0.00064610f, 
    -0.21008037f, -0.03710289f, 0.20646475f, 0.23187880f, 0.23423997f, -0.30209756f, -0.07209890f, 0.24247527f, 
    -0.04945391f, -0.29989061f, -0.02966467f, 0.31666711f, 0.18541624f, -0.45988885f, -0.42433172f, 0.19223413f, 
    0.07090874f, 0.03290670f, -0.06849093f, 0.00953881f, -0.32268679f, 0.03512130f, -0.06772012f, -0.37197638f, 
    -0.14760621f, 0.04585803f, 0.07059841f, -0.04624983f, 0.05238360f, -0.28637081f, -0.01000162f, 0.09725422f, 
    -0.15477657f, 0.08520514f, 0.08121265f, -0.20546420f, -0.07644334f, 0.19027589f, -0.40732113f, -0.06682371f, 
    0.01522478f, -0.17153729f, -0.19353002f, -0.02397998f, -0.48056677f, -0.23673706f, -0.10946839f, 0.04863843f, 
    0.15307118f, -0.04763942f, -0.01675691f, -0.10471947f, -0.06089499f, 0.00757221f, -0.25725952f, 0.01962988f, 
    -0.02148191f, 0.28679478f, 0.03797575f, 0.25827283f, -0.03793637f, -0.29137918f, 0.07010157f, -0.07945241f, 
    -0.05208970f, -0.22116634f, -0.06946367f, 0.08073093f, -0.32249013f, 0.17227204f, -0.04192672f, 0.52097648f, 
    -0.29387358f, -0.00441269f, 0.29195115f, -0.07493359f, 0.02285137f, 0.23308127f, 0.16199858f, -0.02124021f, 
    -0.01946340f, -0.08679839f, -0.08904988f, 0.14811152f, -0.48719975f, 0.00662430f, 0.10356538f, -0.07622328f, 
    -0.02673982f, -0.39638084f, -0.25685489f, 0.10852181f, -0.01264398f, -0.03652815f, 0.00414444f, -0.03712903f, 
    -0.07089661f, 0.11914999f, 0.12406017f, -0.00789998f, 0.25678611f, -0.07516274f, 0.06229568f, 0.01978790f, 
    -0.03998260f, 0.04103639f, -0.04967428f, 0.21392938f, -0.02493647f, -0.08309770f, 0.02307931f, -0.09615992f, 
    0.14442323f, 0.07262368f, -0.03511805f, 0.14089897f, 0.22301373f, -0.06859022f, 0.09452075f, -0.04690253f, 
    -0.05667466f, -0.14703223f, 0.08437909f, 0.06566240f, -0.14817427f, -0.46074063f, 0.13647044f, -0.07948907f, 
    -0.16903204f, -0.05772484f, 0.19737326f, 0.30534616f, -0.36638683f, -0.61672664f, 0.01924492f, 0.09047890f, 
    0.02757055f, -0.26046374f, -0.07998723f, -0.16349976f, 0.26399907f, -0.01626454f, 0.24607256f, -0.42231801f, 
    -0.07061799f, -0.01986839f, -0.05336025f, -0.05581380f, -0.07490496f, 0.01009783f, 0.16279116f, 0.23519714f, 
    -0.45380303f, 0.14419766f, 0.08409383f, -0.03592480f, -0.33405915f, 0.18347462f, 0.01399397f, -0.10221622f, 
    -0.13608877f, -0.28635859f, 0.17573184f, -0.52015769f, -0.14403786f, 0.46705133f, -0.23984852f, 0.07058443f, 
    0.05113577f, 0.04248850f, -0.14572243f, -0.02411865f, 0.06601954f, 0.27151519f, 0.04082647f, -0.06388585f, 
    -0.23923555f, -0.02747870f, -0.03089707f, -0.21056767f, -0.18200742f, 0.03927528f, 0.09730217f, 0.27411294f, 
    -0.23966758f, -0.00714084f, -0.09004275f, 0.24205288f, 0.06391944f, -0.06417612f, -0.00011347f, 0.01215269f, 
    -0.20919889f, -0.32590976f, 0.03460165f, 0.05433358f, -0.04439462f, -0.27407461f, 0.04168105f, -0.25056756f, 
    0.20623255f, 0.07400677f, -0.08973911f, -0.02163686f, -0.04813608f, 0.04577437f, -0.03298721f, -0.17034166f, 
    0.03372543f, 0.13566633f, -0.01493423f, -0.42287010f, 0.06243244f, -0.01210285f, 0.29662415f, -0.04077210f, 
    0.20237164f, 0.24682431f, 0.04469733f, 0.25790447f, 0.06539862f, -0.03883285f, -0.08592109f, -0.05585169f, 
    -0.07068410f, -0.10330158f, -0.03422951f, -0.42695141f, 0.28287739f, -0.06552555f, 0.19068716f, 0.07546117f, 
    0.01747529f, 0.07771619f, 0.02101669f, 0.02482985f, -0.14809911f, -0.00145275f, 0.01630007f, 0.01160559f, 
    -0.26549304f, -0.01207545f, 0.16871063f, 0.17534573f, 0.02532487f, 0.20760827f, 0.24085279f, 0.03911529f, 
    0.07490423f, -0.13429581f, 0.15365739f, 0.23621258f, -0.43645391f, -0.04247954f, 0.08301248f, 0.04028344f, 
    -0.01724033f, -0.11409914f, 0.04991289f, -0.67445707f, -0.22740954f, 0.27256322f, -0.08121354f, -0.20346430f, 
    0.05054804f, 0.03420428f, -0.06030180f, 0.20695367f, -0.21002181f, -0.12627438f, 0.24981160f, -0.10418863f, 
    -0.08282026f, -0.01046638f, -0.01004210f, 0.04659836f, 0.13091451f, -0.58462721f, -0.28016090f, 0.03393225f, 
    0.05770621f, -0.10601745f, 0.01327609f, -0.03477997f, 0.10845615f, 0.15109485f, -0.03089858f, 0.02833407f, 
    -0.00866120f, 0.14026551f, 0.09563851f, -0.28524780f, 0.11872008f, -0.11838238f, 0.11493445f, -0.04059850f, 
    -0.06443408f, 0.27940837f, -0.09243013f, -0.00668617f, -0.22685805f, 0.15058479f, -0.00872072f, 0.05228917f, 
    -0.12534583f, 0.03637545f, -0.05497675f, -0.04291770f, -0.22772209f, 0.04061897f, -0.26651031f, -0.26944232f, 
    0.00625310f, 0.14050108f, 0.24917224f, -0.16375262f, 0.06531575f, -0.55202639f, 0.07344902f, 0.06072251f, 
    0.21405080f, 0.18597773f, -0.06061800f, 0.07554194f, 0.10699457f, -0.19119608f, -0.06736703f, -0.01902168f, 
    0.01275395f, 0.02663984f, -0.35863316f, -0.19784787f, 0.00159227f, 0.05974317f, 0.23723343f, -0.22011261f, 
    -0.09753385f, -0.16206133f, -0.08314605f, 0.14706151f, -0.06095335f, 0.06515973f, -0.24146011f, 0.07860973f, 
    0.16001101f, -0.24667720f, 0.25164747f, 0.23840001f, -0.17862906f, -0.04984077f, -0.03712374f, 0.02024550f, 
    0.06210945f, 0.12535252f, -0.16420941f, 0.12798321f, -0.31293598f, 0.00747378f, 0.26194355f, -0.00402795f, 
    -0.05959603f, -0.04079664f, -0.30669221f, -0.01038622f, -0.20845328f, -0.03628700f, -0.07807841f, -0.07562573f, 
    0.25316542f, -0.05039827f, -0.03478473f, 0.05363040f, 0.16872865f, 0.00330460f, 0.08954568f, -0.05317354f, 
    0.02051996f, 0.27469108f, -0.32915425f, 0.09247678f, 0.16514042f, 0.09318630f, 0.26234296f, 0.06204863f, 
    -0.15024319f, -0.12427428f, -0.09354425f, -0.45193258f, 0.15969039f, 0.03731005f, 0.06802578f, 0.21549048f, 
    0.02915836f, -0.29627004f, -0.02568218f, -0.04082030f, -0.15282761f, 0.13365673f, 0.11315662f, -0.01752888f, 
    -0.08711456f, -0.02584462f, -0.04820811f, 0.05597657f, -0.21006633f, -0.29941157f, 0.32504857f, -0.28660285f, 
    0.28245330f, -0.21525428f, -0.02708082f, -0.00223387f, -0.27290729f, -0.50629771f, -0.02720772f, -0.43290526f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.01897524f, -0.05390156f, -0.04845848f, -0.01291780f, 0.05534744f, 0.01160627f, 0.02449416f, -0.07207125f, 
    0.02270065f, -0.02494292f, 0.15957640f, 0.11359458f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
