#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.06065333f, -0.40707666f, 0.12042814f, 0.39551345f, 0.37801298f, -0.53450197f, -0.39954346f, -0.18734279f, 
    -0.02580218f, -0.57570320f, -0.14199604f, 0.44731179f, 0.29759189f, 0.18269952f, -0.72876310f, 0.10405379f, 
    0.00293798f, -0.14499755f, 1.40376318f, -0.35381275f, -0.70085883f, -0.23929588f, -0.22203362f, -0.01716182f, 
    -0.02421477f, 0.38151041f, 0.08639417f, 0.35862303f, -0.11838695f, 0.00187983f, 0.32673874f, 0.08655998f, 
    0.45405155f, -0.00733799f, 0.49223706f, -0.57214069f, -0.24447949f, -0.20474768f, -0.15864982f, -0.21358992f, 
    -0.49490526f, -0.61651355f, 0.51738346f, 0.52039891f, 0.12267267f, 0.36217853f, 0.67206198f, 0.16538379f, 
    -0.34932187f, -0.13461247f, 0.46033710f, -0.15039636f, -0.18864921f, 0.17724508f, -0.58277857f, -0.36078033f, 
    -0.18120585f, -0.20089214f, 0.76517868f, -0.10961429f, -0.27914730f, -0.19883870f, -0.11345303f, -1.05892646f, 
    0.63302433f, 0.06334896f, -0.48529512f, 0.19197908f, 0.90265608f, -0.01495934f, -0.44981474f, 0.08153775f, 
    -0.37425849f, -0.55187243f, -0.06761226f, -0.13959362f, -0.74545670f, -0.18254068f, -0.08547439f, -0.21006140f, 
    0.16555832f, 0.37972620f, -0.45170271f, -0.41528395f, -0.36559886f, -0.29354888f, 0.07970921f, 0.09886192f, 
    -0.24140316f, -0.03694625f, 0.11337571f, 0.46172476f, -0.23696338f, -0.63609552f, -0.37745783f, -0.26512185f, 
    -0.27544966f, -0.54281825f, -0.14966767f, 0.38234681f, -0.34466836f, -0.49515465f, 0.91398489f, -0.30147421f, 
    -0.87515658f, -0.26088831f, -0.12768833f, -0.05382212f, 0.28157595f, -0.03095537f, 0.69110149f, -0.34943670f, 
    -0.12753463f, 0.65433156f, 0.11086357f, 0.23598605f, 0.41481140f, -0.66973019f, -0.11552649f, -0.31924397f, 
    0.68323082f, 0.24207124f, 0.35633203f, 0.03106811f, -0.16034952f, 0.30611357f, -0.05399109f, -0.36424270f, 
    -0.14179872f, -0.25993812f, -0.71578044f, 0.71666282f, -0.58189553f, 0.38183701f, 0.21479745f, 0.41466692f, 
    -0.20957956f, -0.36167574f, -0.56404841f, -0.28380921f, -0.39097169f, 0.61136776f, 0.35141346f, 0.39627087f, 
    -1.05758655f, -0.34812331f, -0.52923352f, 0.16827784f, 0.35271835f, 0.23120825f, 0.44151545f, 0.42450526f, 
    -0.07921368f, 0.13928102f, 0.10850323f, -0.25871316f, 0.43160194f, -0.56515861f, -0.73909831f, -0.32117045f, 
    0.83804590f, -0.22488837f, -0.23154792f, -0.01861908f, 0.67956913f, 0.71637189f, -0.33500847f, -0.10174913f, 
    -0.09192276f, 0.03308473f, -0.30681527f, -0.16806120f, -0.04917550f, -0.14269216f, 0.02273836f, 0.67202705f, 
    0.01336438f, 0.45230234f, -0.01565304f, 0.05865471f, 0.27128237f, 0.36067048f, -0.30509859f, -0.06827752f, 
    0.90701252f, -0.35473472f, 0.11995541f, -0.31075421f, 0.40930438f, 0.35038984f, 0.45985100f, 0.53071576f, 
    -0.04088002f, -0.57807666f, -0.72995585f, -0.07987395f, -0.15057741f, 0.16982605f, -0.32195851f, 0.18204062f, 
    0.52082998f, 0.22230074f, 0.58261144f, -0.15048888f, 0.09076968f, 0.10791682f, -0.02581839f, 0.00261852f, 
    -0.44578058f, 0.13474797f, -0.44560787f, -0.35001004f, -0.21532848f, -0.25597849f, 0.59469038f, -0.46755344f, 
    -0.11649059f, 0.08868732f, -0.07198642f, -0.40318117f, -0.45807883f, -0.19352444f, -0.15363570f, -0.12813975f, 
    -0.57995546f, -0.72943288f, 0.70572454f, -0.13607565f, 1.00741756f, -0.72735971f, -0.36511460f, -0.11267786f, 
    -0.03943995f, -0.06482484f, -0.49440634f, 0.50493979f, -0.22527775f, -0.16278170f, 0.92915988f, -0.38889241f, 
    0.21605003f, -0.07817438f, -0.26665199f, 0.28978476f, 0.53474540f, 0.67600900f, -0.62300307f, -0.07726964f, 
    0.11067885f, 0.16152476f, 0.39932126f, -0.35826200f, -0.29510185f, -0.43119991f, -0.44208607f, 0.55318666f, 
    0.66642690f, 0.61521107f, 0.33513090f, -0.34261209f, 0.24543068f, 0.63557452f, 0.05919301f, -0.22414936f, 
    0.33597139f, 0.30684409f, 0.11927705f, -0.31277472f, -0.43299136f, -0.43359640f, -0.10312030f, -0.28065512f, 
    -0.42131421f, 0.99254906f, 0.03686634f, 0.15308957f, -0.21957834f, -0.35215172f, -0.40896040f, -0.25904432f, 
    0.69387048f, -0.33781585f, -0.36369559f, -0.03200797f, -0.13220260f, 0.23346721f, 0.23479025f, 0.55684745f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.12803489f, 0.17446019f, -0.15895757f, 0.20228338f, -0.36107892f, 0.01608000f, -0.08411160f, -0.00208448f, 
    -0.26065519f, 0.12056396f, -0.30306798f, -0.11418525f, 0.28269282f, 0.09871630f, 0.02869280f, -0.13858774f, 
    0.22678562f, 0.09204451f, 0.25869718f, -0.40195206f, -0.01590193f, 0.03391921f, -0.00750509f, 0.25069427f, 
    0.06137659f, -0.17620641f, -0.07663619f, -0.33843765f, -0.30497101f, -0.23877218f, -0.03153739f, 0.24185979f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.00265892f, -0.06385002f, -0.22090964f, 0.10450102f, 0.11212891f, -0.01964663f, -0.03994130f, -0.00781237f, 
    0.19157141f, -0.07915232f, 0.02056396f, -0.12409867f, -0.00617788f, -0.02849544f, 0.01161468f, -0.01441365f, 
    -0.17266472f, 0.16101010f, -0.13851289f, -0.10492527f, 0.12708955f, 0.00338214f, 0.06644773f, -0.08567958f, 
    -0.22570880f, -0.01977064f, -0.19316402f, -0.05693139f, 0.20465542f, -0.14632912f, 0.01118984f, 0.07569817f, 
    0.03139229f, -0.01013520f, 0.05271931f, 0.09559810f, -0.29865009f, -0.19307089f, -0.19717687f, 0.13121603f, 
    0.08643374f, -0.11486655f, 0.18523048f, -0.01265058f, 0.06315576f, 0.44035423f, 0.11083426f, 0.21717903f, 
    0.01047829f, -0.00574040f, -0.06393427f, -0.09532078f, 0.03735843f, -0.02580070f, -0.07291564f, -0.18545997f, 
    -0.24038592f, 0.05329131f, -0.05208901f, 0.14301817f, -0.08071753f, 0.05176591f, 0.19010440f, 0.59218329f, 
    -0.04748538f, -0.22349592f, 0.06352121f, 0.12913343f, 0.16119260f, -0.10702905f, 0.02288896f, -0.21505517f, 
    -0.09424546f, 0.03408225f, -0.01551747f, 0.13902417f, 0.00434457f, -0.04778153f, -0.08185343f, 0.03917176f, 
    0.22775668f, -0.01112312f, -0.24470033f, -0.03227958f, 0.12819745f, 0.21080834f, -0.01179426f, -0.08160933f, 
    -0.04208719f, 0.11889067f, 0.18661195f, -0.20218515f, 0.06111418f, -0.06941301f, 0.00332600f, -0.07247800f, 
    -0.00770254f, 0.05980488f, -0.00962498f, -0.19241183f, 0.23377948f, -0.05097206f, -0.00729523f, 0.13114947f, 
    0.11872347f, -0.07704952f, 0.12703483f, -0.12095010f, 0.45153555f, 0.09919896f, 0.04881552f, -0.02552216f, 
    0.03134510f, 0.03992878f, 0.06734502f, 0.03859828f, -0.14113240f, -0.06657662f, -0.28379691f, -0.17548560f, 
    0.03559290f, -0.08296020f, 0.18330756f, -0.11723021f, 0.02987587f, -0.01196009f, 0.00136503f, -0.26361352f, 
    -0.01736334f, 0.09533245f, 0.01797618f, 0.08576227f, -0.10700899f, -0.20673668f, -0.04813700f, -0.35026398f, 
    -0.36452174f, -0.06026916f, -0.13676041f, 0.08552068f, -0.23928697f, 0.18207362f, 0.06607317f, -0.14968845f, 
    -0.00133810f, -0.35359511f, -0.13029332f, 0.04897098f, 0.07666879f, -0.10296100f, -0.19046603f, 0.01804475f, 
    -0.06600952f, -0.20045730f, 0.40634489f, -0.13563539f, 0.12670742f, 0.07412786f, 0.07008615f, 0.04896112f, 
    0.09824692f, -0.03206588f, 0.03167329f, 0.18019763f, -0.05671055f, -0.03254136f, 0.04387350f, 0.03565631f, 
    0.05931189f, 0.02334599f, -0.05953425f, 0.12052732f, -0.09292863f, -0.21694109f, -0.05891965f, -0.08538795f, 
    0.11230894f, -0.03568560f, 0.12977000f, 0.01741965f, 0.11672022f, 0.22583094f, -0.01631939f, 0.27119771f, 
    -0.04486787f, 0.20766339f, 0.13076660f, 0.00833435f, -0.12591100f, 0.32936028f, 0.38140494f, 0.23053357f, 
    0.00910325f, -0.18348962f, -0.16339973f, 0.07942347f, -0.15119229f, 0.03880100f, 0.11563909f, 0.13461009f, 
    -0.24450001f, 0.01486611f, 0.03433853f, 0.08340029f, -0.00408278f, 0.09786846f, -0.12800625f, 0.10275455f, 
    -0.08554310f, 0.08395191f, 0.06322527f, 0.05347930f, 0.04967348f, 0.06714377f, -0.05673954f, 0.21834688f, 
    0.04561000f, 0.05909221f, 0.24983439f, 0.05012388f, 0.05012652f, -0.02698282f, 0.14595424f, -0.06767060f, 
    0.21150182f, 0.16584907f, 0.07524081f, 0.07393114f, 0.01000583f, 0.09108093f, -0.09225210f, 0.01712960f, 
    -0.03684308f, -0.04111633f, -0.03566547f, 0.33119923f, -0.21455994f, -0.00322546f, 0.07824125f, 0.02648992f, 
    0.11890081f, 0.16917333f, 0.13736103f, 0.47467944f, 0.15181185f, 0.03007660f, -0.06448381f, 0.05235403f, 
    -0.23568867f, -0.18282439f, 0.13549334f, -0.06241417f, -0.09952952f, -0.29810548f, -0.13391526f, -0.03360289f, 
    0.00658708f, 0.11522701f, -0.06985950f, -0.00599609f, -0.00873048f, -0.53729153f, 0.18755600f, -0.00860722f, 
    -0.08019593f, 0.05197069f, -0.14101602f, -0.00551012f, 0.14167958f, 0.08867078f, -0.29971316f, -0.13955785f, 
    0.03227990f, -0.00595137f, 0.00984678f, 0.25371537f, -0.05887082f, 0.06373110f, 0.20238642f, -0.11597488f, 
    -0.05199315f, -0.05099098f, 0.04218902f, 0.08092625f, -0.03253349f, 0.09299401f, 0.40499991f, -0.32445920f, 
    0.13401854f, 0.14807577f, 0.30878401f, 0.17072369f, -0.01188168f, -0.07767747f, 0.16724759f, -0.04651211f, 
    -0.00484932f, 0.20242287f, 0.01201095f, 0.15976696f, 0.13086866f, 0.06523585f, 0.07624557f, -0.02200117f, 
    0.09505532f, 0.00873308f, 0.09005442f, -0.17388813f, 0.09070162f, -0.05521379f, -0.20801957f, 0.31616506f, 
    -0.02512756f, -0.24242258f, 0.03154038f, -0.10247322f, -0.10420667f, -0.11743704f, 0.05035729f, 0.15522644f, 
    0.27494261f, -0.01035553f, 0.06064949f, -0.20415892f, -0.21122621f, -0.06968006f, 0.11169022f, -0.01341507f, 
    -0.06585579f, -0.03383408f, -0.01336385f, 0.00570993f, 0.14460763f, -0.05336163f, -0.09565749f, -0.13459378f, 
    -0.19006160f, -0.04500805f, -0.01126493f, -0.01856912f, -0.10227949f, -0.10518300f, 0.16162862f, 0.14292096f, 
    0.09996117f, 0.13422212f, -0.11801094f, -0.10022552f, -0.00088066f, 0.00277155f, -0.16228542f, 0.10445438f, 
    0.17986670f, 0.17995456f, 0.21485366f, 0.04087186f, -0.09581259f, 0.25025833f, -0.04902283f, 0.08420360f, 
    -0.03518264f, -0.37281188f, 0.07412355f, -0.04034009f, 0.13737892f, -0.01955432f, -0.03499953f, 0.14137222f, 
    -0.10804354f, 0.26009318f, -0.14379436f, 0.40538910f, -0.04950508f, 0.08569546f, 0.19070454f, 0.07240418f, 
    0.00036896f, 0.04052833f, 0.01796997f, -0.27017048f, -0.13061950f, 0.00617789f, 0.06551035f, 0.03309985f, 
    -0.01259193f, -0.06965468f, -0.18049245f, 0.24267359f, 0.13553177f, 0.28987008f, 0.04497089f, 0.21028367f, 
    0.04673200f, 0.10801370f, 0.08855679f, -0.16052967f, -0.11967125f, -0.03837369f, -0.13285950f, 0.06485972f, 
    0.06804710f, 0.05581132f, 0.02968006f, 0.11451134f, 0.17389910f, -0.01633043f, 0.12194888f, 0.08580390f, 
    0.16167964f, 0.10217623f, -0.01500270f, -0.00786846f, 0.02939494f, 0.05311811f, 0.24861373f, -0.00297464f, 
    0.20536795f, -0.01818356f, 0.16598079f, 0.11296126f, 0.07696591f, -0.02055464f, 0.18672864f, -0.16550784f, 
    -0.13119690f, 0.18250826f, 0.03835045f, -0.08739099f, 0.02146450f, 0.08743792f, -0.02176989f, 0.25140509f, 
    0.04654061f, 0.33699393f, 0.26653537f, 0.05105357f, 0.00277667f, -0.01760014f, -0.04612686f, -0.00314517f, 
    -0.01678998f, -0.09586852f, 0.23096694f, 0.00610125f, 0.20715685f, 0.11040268f, 0.14582434f, -0.00828740f, 
    0.28265056f, 0.24449410f, 0.20403439f, -0.09430443f, -0.01432660f, 0.03185979f, 0.06034534f, 0.03822343f, 
    0.01827223f, 0.02200649f, 0.02051412f, -0.22987111f, 0.08201238f, 0.13024808f, 0.15477347f, 0.05157108f, 
    0.09272518f, -0.19763371f, -0.09853037f, -0.07871668f, -0.07855456f, 0.12607144f, 0.03517393f, 0.12728071f, 
    0.26145700f, 0.06420076f, 0.10488651f, 0.04434193f, -0.07126130f, -0.13986066f, -0.17234831f, -0.25139365f, 
    0.12308276f, 0.13212194f, 0.10872822f, -0.06766042f, -0.01427808f, -0.08508728f, -0.06793500f, -0.06249973f, 
    -0.06921834f, 0.13581105f, 0.14888780f, 0.01917316f, -0.00997730f, 0.14414372f, -0.05916376f, 0.28095967f, 
    -0.01005926f, 0.05490065f, -0.02732164f, 0.17218105f, -0.02291117f, 0.08673304f, 0.12437046f, 0.08265961f, 
    0.15690351f, -0.20086884f, 0.11082650f, -0.04012050f, 0.12701248f, 0.11275586f, 0.03784901f, 0.01009975f, 
    -0.03421132f, 0.29074177f, 0.13488476f, 0.18502982f, 0.11072031f, 0.24270080f, -0.12802280f, -0.02331230f, 
    0.01559173f, -0.00930215f, 0.01712064f, 0.09883480f, -0.07637513f, 0.22009130f, 0.16105919f, 0.03615343f, 
    0.00124948f, 0.04067824f, 0.04131877f, -0.24537285f, -0.19829214f, -0.33578977f, -0.14419039f, 0.06575149f, 
    -0.04546287f, -0.00213580f, -0.02035422f, -0.26306963f, -0.25711128f, 0.09018102f, -0.01779347f, 0.25827953f, 
    0.04729323f, 0.11001657f, 0.01541214f, -0.03234427f, -0.11883759f, 0.02324405f, -0.18390219f, -0.19861634f, 
    -0.17768510f, -0.12726958f, -0.08642484f, 0.08832745f, -0.00806352f, -0.28645334f, 0.02313924f, 0.10871887f, 
    0.04499045f, 0.08358904f, -0.03023273f, -0.10650353f, 0.09250800f, -0.03789607f, 0.02238323f, -0.12756011f, 
    0.00882716f, 0.10489161f, 0.10059898f, -0.03221534f, -0.05250913f, 0.13320141f, 0.32525209f, 0.30241060f, 
    -0.09009010f, 0.03126286f, -0.04718336f, -0.08257788f, -0.03739427f, -0.01047189f, -0.04202936f, -0.06522679f, 
    -0.08512291f, -0.02338937f, -0.03042266f, -0.05012908f, -0.00404120f, -0.04623451f, 0.00129901f, 0.01312885f, 
    0.00016378f, -0.04602525f, -0.06448247f, -0.03269449f, 0.01167876f, 0.02010448f, -0.03456673f, -0.01272696f, 
    -0.04899450f, -0.05035889f, -0.08186955f, -0.06908212f, -0.01156852f, -0.00967633f, 0.00152110f, -0.06375038f, 
    -0.07406886f, -0.07551239f, -0.04546351f, -0.09257390f, -0.06845443f, 0.04055874f, -0.01300537f, -0.09361889f, 
    0.02994255f, -0.07001667f, -0.08062850f, -0.02749202f, -0.04882685f, -0.00959398f, -0.00243786f, -0.00478124f, 
    -0.06687683f, -0.07475175f, 0.00942941f, -0.02061867f, -0.00047908f, -0.07678951f, -0.08550479f, -0.01500351f, 
    0.00991121f, -0.04866140f, -0.07289151f, -0.03775861f, -0.05828175f, -0.07328576f, -0.06906331f, -0.08457492f, 
    -0.05761189f, 0.00544162f, 0.01064949f, -0.00454797f, -0.01455022f, -0.04752937f, -0.03439679f, -0.05752866f, 
    0.00101372f, 0.03911324f, 0.04524744f, -0.01562373f, -0.01427900f, 0.00670589f, 0.03425083f, -0.07643761f, 
    0.01167990f, -0.03854882f, 0.01889156f, -0.04350023f, -0.05165325f, -0.00705026f, 0.00413644f, -0.03204553f, 
    0.01567728f, -0.04624799f, -0.05702359f, -0.06860918f, -0.03203419f, -0.02349284f, -0.02705108f, 0.02784361f, 
    -0.06402896f, -0.00158196f, -0.01874621f, 0.02371616f, -0.00298366f, -0.03538898f, -0.01500106f, -0.02464817f, 
    -0.05622132f, -0.02593529f, -0.03542109f, -0.05404363f, -0.05379314f, -0.09766537f, -0.09169309f, 0.01965896f, 
    -0.07448171f, 0.01867674f, -0.03674308f, 0.01714252f, -0.03389063f, -0.08975711f, -0.00307114f, -0.04122039f, 
    -0.07444507f, 0.02224604f, -0.06259357f, -0.01300133f, -0.06107571f, -0.08769403f, -0.01092242f, -0.02051582f, 
    0.00164051f, -0.08184927f, -0.09012274f, -0.07708196f, -0.07114866f, -0.06543210f, 0.00197702f, 0.00750868f, 
    -0.02385587f, -0.02296147f, -0.07342323f, -0.03592410f, 0.00313495f, -0.04742707f, -0.03033234f, -0.07398060f, 
    0.03048535f, -0.06484842f, -0.05291072f, 0.00683515f, 0.02804671f, -0.02640547f, -0.02017632f, -0.00268061f, 
    0.01053246f, 0.04833033f, 0.00233273f, -0.02088311f, -0.05780103f, -0.02227832f, -0.00291762f, -0.01500824f, 
    -0.01562741f, -0.00449111f, -0.07556654f, -0.00588519f, -0.04834206f, -0.05091702f, 0.01213442f, 0.00999732f, 
    0.00472850f, -0.04501548f, -0.06075495f, -0.04136314f, -0.07333942f, 0.02146370f, -0.04160440f, 0.01909074f, 
    0.01833251f, -0.07071065f, -0.05977537f, -0.01198337f, -0.02591521f, -0.04834844f, -0.02771657f, -0.04340430f, 
    0.00737881f, -0.07366824f, -0.06340533f, -0.07857151f, -0.04444217f, 0.01403995f, -0.08485478f, -0.08927226f, 
    0.04664838f, 0.00830093f, -0.05156336f, -0.00308112f, -0.00028669f, -0.06943747f, -0.08830508f, -0.06464792f, 
    -0.03026536f, 0.01545581f, -0.05271275f, -0.06788205f, -0.08059435f, 0.00227045f, -0.00212423f, -0.01092033f, 
    -0.02778230f, -0.06960984f, -0.02824314f, -0.03607561f, -0.01719348f, -0.00462255f, -0.04566235f, -0.07617797f, 
    0.01014217f, 0.02713701f, -0.00464351f, 0.00058099f, -0.00969179f, -0.06056429f, -0.04846846f, -0.04513276f, 
    -0.07691745f, 0.02473470f, -0.04352476f, -0.05934709f, -0.00364593f, -0.01248858f, -0.03484774f, -0.05314345f, 
    -0.07379332f, -0.09268799f, -0.08096475f, -0.00179879f, -0.00315494f, -0.06969886f, 0.00896132f, -0.05315688f, 
    -0.01817054f, -0.08020046f, -0.05150133f, -0.05753573f, -0.08102359f, -0.03136132f, -0.04750352f, -0.03629724f, 
    -0.04037223f, 0.01873878f, -0.03498517f, -0.05663060f, 0.00326383f, -0.00825033f, -0.01336619f, -0.02601071f, 
    -0.00843774f, -0.07310414f, -0.01801091f, -0.07199454f, -0.07325596f, 0.00461768f, -0.02394235f, 0.00977348f, 
    -0.01078573f, 0.01441637f, -0.00397082f, -0.08450378f, -0.03160976f, -0.05780908f, -0.04123254f, 0.03880938f, 
    0.01940822f, -0.01267371f, 0.00110026f, 0.01346112f, -0.01577696f, 0.01893121f, -0.04968257f, -0.06368721f, 
    -0.01538676f, -0.08908135f, -0.06429885f, 0.01613732f, 0.00399342f, 0.03148219f, -0.05187324f, -0.02504802f, 
    0.15012361f, -0.07883959f, 0.27259427f, -0.07174044f, 0.07918859f, 0.07797290f, 0.02399190f, 0.15345483f, 
    0.08250482f, 0.26811349f, -0.14547594f, -0.14032136f, -0.16963276f, 0.19641531f, 0.05700576f, 0.06788667f, 
    0.17404571f, 0.15726598f, 0.56909043f, 0.13912225f, -0.80543178f, -0.03190752f, -0.24387424f, 0.09565715f, 
    -0.14662071f, 0.05960542f, -0.30408517f, 0.15426172f, 0.18466395f, 0.07712548f, 0.04895503f, -0.02027551f, 
    0.13959746f, 0.04842203f, 0.08774929f, 0.26428270f, -0.29464307f, -0.23193085f, -0.23083849f, -0.19066742f, 
    0.00095375f, -0.28500113f, -0.12876146f, -0.01308452f, -0.15278493f, 0.47874719f, 0.18841080f, 0.21326655f, 
    -0.01246525f, 0.02856117f, 0.08144371f, -0.09105816f, 0.13437195f, 0.05104608f, -0.11495256f, -0.23600984f, 
    0.15543391f, -0.19195844f, 0.10445602f, -0.12961917f, 0.07559961f, -0.01500360f, -0.01761701f, -0.36389723f, 
    -0.07374609f, -0.42237183f, -0.07314204f, 0.07434367f, 0.08813569f, 0.06016727f, 0.15567611f, 0.01993198f, 
    -0.17659679f, 0.08016074f, 0.21058083f, -0.06747841f, 0.01766701f, -0.16404942f, -0.00868763f, -0.00207376f, 
    0.05108179f, -0.14422128f, 0.07321291f, -0.15414895f, -0.03093862f, 0.15129538f, 0.03316908f, 0.08895521f, 
    0.01773630f, 0.10904460f, -0.27379701f, -0.14875938f, -0.17804407f, -0.25759286f, -0.12522192f, -0.09093311f, 
    0.01310866f, 0.06467003f, 0.05836443f, -0.18745655f, -0.12967654f, -0.24474037f, -0.06186971f, -0.23448482f, 
    0.04370152f, 0.14406006f, 0.02780482f, 0.14207847f, 0.43612856f, 0.09144066f, 0.02918498f, -0.00713271f, 
    -0.06909803f, 0.04257629f, 0.00907787f, -0.04908600f, 0.05860545f, -0.33397037f, 0.00292251f, 0.15437567f, 
    -0.01200502f, 0.04534749f, 0.05488333f, -0.07605380f, -0.03220587f, 0.15498964f, -0.12019294f, 0.10119136f, 
    0.09534824f, -0.02705526f, 0.05261352f, -0.04969136f, 0.06047682f, -0.10212620f, -0.04253064f, -0.02894053f, 
    -0.04323805f, -0.32672995f, 0.04032281f, 0.10671853f, -0.15574649f, -0.09105875f, -0.05029180f, -0.15355045f, 
    -0.71747202f, -0.09903625f, 0.20364553f, 0.02689192f, 0.09523474f, 0.06280396f, -0.10088072f, 0.07814332f, 
    -0.01053779f, -0.25785336f, -0.09623575f, -0.21007508f, 0.06427492f, -0.03614703f, -0.16647595f, 0.08117251f, 
    0.02490948f, 0.06970022f, 0.15989658f, 0.08044874f, 0.11333542f, 0.04007436f, 0.17161061f, 0.00147074f, 
    0.20458241f, 0.07394688f, 0.16679765f, -0.24943790f, -0.10156780f, 0.09720959f, -0.17095435f, -0.06078595f, 
    -0.09880056f, 0.10348113f, -0.17515226f, 0.02966564f, 0.02204741f, -0.11328302f, 0.18913735f, -0.12270850f, 
    0.07486696f, 0.09456261f, 0.07005463f, 0.03752114f, 0.08484887f, 0.26428887f, -0.26264295f, -0.19252148f, 
    -0.06506170f, 0.07387751f, -0.03157891f, 0.12127895f, 0.03631021f, 0.11324687f, 0.22661267f, 0.05063635f, 
    0.10408202f, -0.01878431f, 0.12875368f, -0.02867540f, 0.04114519f, 0.00628510f, 0.04974718f, 0.07844712f, 
    -0.11830557f, -0.11236611f, 0.03763646f, 0.12062436f, 0.10312332f, -0.00714372f, 0.00450851f, 0.00808176f, 
    -0.04665434f, 0.03783440f, -0.22508161f, -0.03311861f, 0.05079953f, 0.02782060f, 0.00533264f, -0.00287631f, 
    0.13758661f, -0.18943819f, -0.08891243f, -0.02756407f, -0.30703640f, -0.05100734f, 0.05833923f, 0.14204781f, 
    0.03780387f, 0.06313232f, -0.03252700f, -0.28469062f, 0.07685231f, 0.12808861f, -0.16839470f, 0.04039864f, 
    -0.05168843f, -0.10878359f, 0.20332523f, 0.49529907f, -0.12367672f, -0.16668618f, -0.07766136f, -0.01486907f, 
    -0.07283058f, -0.11071023f, -0.02562926f, 0.01467910f, -0.42196444f, -0.04635336f, -0.02405444f, -0.07945754f, 
    -0.03092101f, -0.07519132f, -0.10940847f, -0.06489304f, 0.07408579f, -0.09079341f, 0.13247523f, 0.08402503f, 
    -0.00966254f, -0.01533686f, -0.07874339f, -0.06062848f, -0.25341994f, 0.18347134f, 0.03153642f, -0.19804852f, 
    0.37511057f, -0.13410795f, 0.02990697f, -0.13598832f, 0.10006087f, 0.06702153f, 0.14731525f, 0.03169935f, 
    -0.17525911f, -0.07676265f, 0.03026902f, 0.12821500f, 0.09222760f, 0.13239264f, -0.01926646f, -0.06751343f, 
    -0.06976964f, 0.18830295f, 0.39947110f, 0.07194084f, -0.10602018f, 0.02612668f, -0.03290381f, -0.14571549f, 
    -0.05343237f, 0.11873277f, 0.01472947f, 0.14979532f, 0.08073741f, 0.01215713f, 0.15736775f, -0.04677674f, 
    0.07466914f, -0.04650290f, 0.16907617f, -0.44734684f, -0.55928355f, 0.06722799f, 0.09959075f, -0.18356097f, 
    -0.11711688f, -0.02857756f, 0.10444794f, 0.05194015f, -0.00026188f, 0.05911034f, -0.06302662f, 0.13250168f, 
    0.09275387f, 0.01900095f, -0.14737006f, 0.09991038f, -0.20329621f, -0.41585320f, -0.23808199f, -0.12650941f, 
    -0.01532004f, 0.07631329f, -0.00360728f, 0.05028533f, 0.26709235f, 0.01875983f, 0.09738162f, 0.12501915f, 
    0.01129550f, 0.00631378f, -0.02780646f, -0.09872592f, -0.10138485f, -0.11153758f, -0.14238256f, -0.01211000f, 
    0.06707785f, -0.08791409f, -0.21125518f, -0.08605988f, 0.02307470f, -0.21535899f, -0.14109465f, -0.19990033f, 
    -0.24884522f, -0.02461061f, 0.05488082f, 0.04224172f, -0.02039039f, 0.02843076f, -0.02232397f, -0.02570354f, 
    -0.15843862f, -0.03303213f, -0.04542267f, -0.00863394f, 0.06742892f, -0.14901069f, -0.00553867f, 0.03733247f, 
    -0.20292169f, 0.09626132f, -0.04766909f, -0.13837367f, 0.16779312f, 0.12895194f, -0.11281560f, 0.13549520f, 
    0.01576612f, 0.07532632f, -0.11147960f, 0.13067858f, -0.28476575f, 0.09850668f, 0.21219425f, 0.00189281f, 
    0.05418064f, 0.11231812f, -0.13094886f, 0.07890539f, 0.03861649f, -0.29637057f, -0.05840760f, -0.01484945f, 
    0.01650588f, 0.01021579f, -0.08780384f, -0.15146454f, 0.07436606f, 0.11959961f, -0.05647981f, -0.12100735f, 
    -0.07836185f, -0.01364996f, 0.01149202f, 0.02260483f, 0.19323231f, -0.12300718f, 0.19197206f, 0.33687457f, 
    0.03230064f, 0.00520629f, -0.01721103f, -0.06194243f, 0.07121219f, 0.00423005f, -0.11291581f, 0.11363684f, 
    -0.06876635f, 0.10496445f, 0.13709912f, -0.05706783f, 0.14560412f, 0.07703295f, 0.03644616f, -0.01615023f, 
    -0.37713456f, -0.43666971f, -0.01713149f, -0.06217031f, -0.05067597f, 0.06838129f, 0.12288776f, 0.22193854f, 
    -0.04560379f, 0.27654141f, 0.23470940f, -0.11838409f, 0.28450397f, -0.01913342f, -0.04623659f, 0.07951792f, 
    0.04860529f, 0.10778884f, -0.27572608f, -0.09569960f, 0.00921022f, 0.10116688f, 0.07286302f, 0.01035556f, 
    -0.04452274f, 0.12929966f, 0.02870711f, -0.04249886f, 0.02378682f, 0.13653305f, 0.00168075f, 0.03080774f, 
    0.02149388f, 0.07493702f, -0.05200651f, -0.12025630f, -0.07154869f, 0.12366468f, -0.12609187f, -0.19121483f, 
    -0.07829902f, 0.09320056f, 0.08594278f, -0.00691747f, -0.09180891f, -0.28314805f, 0.14473857f, 0.05514437f, 
    0.00026946f, 0.29166165f, -0.10386282f, -0.04335516f, 0.03253237f, -0.39979154f, -0.12054631f, -0.10749206f, 
    0.05304161f, -0.01347470f, -0.03170907f, 0.04262232f, 0.17568515f, 0.05665709f, 0.02798689f, -0.08826115f, 
    0.17415811f, -0.00417896f, 0.03529330f, 0.02654566f, -0.01461559f, -0.04362499f, 0.08572506f, 0.19240193f, 
    -0.09427916f, -0.04568753f, 0.12101371f, 0.06786848f, 0.04042020f, 0.18915658f, -0.09811329f, 0.13031745f, 
    -0.04152347f, 0.08964513f, -0.36778533f, 0.02482719f, 0.03362821f, 0.06426977f, 0.07018328f, 0.08735566f, 
    0.08685283f, -0.00240796f, -0.05495514f, -0.16151692f, 0.01952498f, -0.13801301f, -0.02637711f, 0.03567120f, 
    -0.07529421f, 0.03562682f, 0.00920974f, -0.26306331f, 0.24432908f, 0.11676629f, -0.02834301f, 0.12133923f, 
    -0.10762534f, -0.20873283f, 0.14532761f, 0.18932419f, -0.08520757f, -0.09947266f, -0.16515118f, -0.04130838f, 
    -0.02330091f, -0.02212492f, 0.01615805f, 0.09539019f, -0.14334656f, 0.10688747f, 0.22052124f, -0.07348505f, 
    -0.11397225f, -0.00557804f, 0.01358689f, 0.03133683f, -0.02281989f, -0.04683513f, -0.01096214f, 0.07168754f, 
    -0.14266644f, 0.00032192f, -0.03032352f, -0.02094709f, -0.08665674f, -0.21598749f, -0.15585715f, 0.11863896f, 
    -0.01313744f, -0.21094844f, -0.06903357f, -0.30800000f, 0.02596268f, -0.08759776f, -0.20356803f, -0.11707605f, 
    -0.22988164f, 0.04178703f, 0.00583683f, -0.21110559f, 0.13975026f, 0.10020294f, 0.25182822f, 0.24775207f, 
    0.32298690f, -0.21682975f, -0.30630001f, -0.06214228f, 0.07596902f, 0.02602097f, -0.01383265f, 0.04029235f, 
    -0.04983940f, 0.17355011f, -0.10387601f, -0.16222718f, 0.00767867f, 0.04978110f, 0.04561424f, -0.06818473f, 
    0.05775558f, 0.04583047f, -0.30835265f, -0.31021625f, 0.34314471f, -0.13652170f, -0.08012668f, 0.26233470f, 
    0.02554331f, -0.17666745f, 0.18746713f, 0.04805768f, 0.12031095f, 0.41543946f, -0.19393960f, -0.06707904f, 
    -0.20469087f, 0.03019166f, -0.00539094f, -0.09707732f, 0.41301998f, 0.13478176f, -0.14492314f, -0.11649137f, 
    -0.17079607f, 0.12360978f, 0.11532004f, -0.12129523f, 0.21085787f, -0.08250789f, -0.05823474f, 0.16188630f, 
    0.01181970f, -0.11461882f, 0.01458261f, 0.14791743f, 0.03417292f, 0.23378035f, 0.30161589f, 0.06627082f, 
    0.06868305f, -0.02010365f, 0.04638166f, -0.10789575f, 0.07510327f, 0.07820324f, -0.14037044f, 0.22468679f, 
    0.42076942f, 0.07997694f, -0.14363198f, -0.05069081f, 0.15109804f, 0.05534466f, 0.20347588f, -0.21622068f, 
    0.27529681f, 0.24324119f, -0.35767367f, 0.03326843f, 0.03388301f, -0.09823230f, 0.13697964f, -0.02278030f, 
    -0.15797271f, -0.01028254f, -0.02124145f, -0.25294134f, -0.01294957f, 0.04668381f, 0.01227268f, -0.05519423f, 
    0.09632811f, -0.22442596f, 0.25762090f, 0.31075883f, -0.16690943f, 0.04522749f, -0.04219700f, -0.01232381f, 
    -0.20244429f, 0.01455533f, 0.18036728f, -0.12792131f, -0.18739687f, 0.03395296f, -0.21271740f, 0.05154017f, 
    -0.08787028f, 0.10025714f, 0.04774525f, 0.11255819f, -0.04259294f, 0.24573970f, 0.16207764f, 0.17310010f, 
    -0.00735932f, -0.15055746f, -0.07536130f, -0.05323797f, 0.08075390f, 0.22668396f, -0.19914009f, -0.00374736f, 
    -0.18848589f, -0.05522906f, -0.30954698f, 0.04083624f, -0.08422164f, -0.06962524f, 0.03298838f, 0.18075654f, 
    -0.23084538f, 0.01134520f, 0.14742184f, -0.26093581f, -0.01566483f, 0.03679943f, -0.20623176f, -0.00219033f, 
    -0.07891268f, 0.02282192f, 0.03068660f, -0.05979816f, 0.14280201f, -0.00232442f, 0.03569510f, 0.03031625f, 
    0.40028259f, -0.31297898f, -0.20861989f, 0.04774267f, -0.02605349f, 0.01191234f, 0.06662623f, 0.03834033f, 
    -0.01860309f, 0.07543415f, -0.12206700f, 0.32045183f, -0.22607824f, -0.02231931f, 0.04573597f, -0.01353713f, 
    0.01323403f, -0.00482556f, -0.07107069f, -0.08630314f, 0.18621159f, -0.11029783f, 0.12613419f, -0.08033202f, 
    -0.00189406f, 0.02658261f, 0.01821961f, 0.04305237f, 0.07963604f, -0.06095524f, 0.13222283f, -0.02637274f, 
    -0.19250934f, -0.01650728f, 0.03731102f, -0.02758474f, 0.10973516f, 0.14009376f, 0.29270768f, -0.30687234f, 
    -0.11215588f, -0.02088391f, 0.13433427f, -0.06646189f, 0.03108237f, -0.13184637f, -0.02695613f, 0.12549695f, 
    -0.01378714f, 0.01517446f, 0.16122159f, -0.02206950f, 0.00058750f, 0.33914635f, -0.02832889f, 0.18786021f, 
    0.16544603f, -0.32531798f, 0.19381313f, -0.13016286f, -0.00048969f, 0.03545217f, -0.06877007f, 0.11497919f, 
    0.04816160f, -0.19333917f, 0.03796468f, -0.11933275f, 0.00832088f, 0.04367284f, -0.06709473f, 0.11098623f, 
    0.28587544f, -0.01262388f, -0.25320274f, 0.00258123f, -0.15764420f, -0.09326252f, -0.06184288f, 0.07522346f, 
    -0.10642038f, 0.28370240f, -0.43956476f, -0.02584875f, -0.12089001f, 0.09058765f, 0.10745388f, -0.00271640f, 
    0.11554770f, 0.00791810f, 0.02717950f, 0.30857417f, 0.13051879f, 0.02767986f, -0.08789002f, -0.06033579f, 
    -0.03539948f, 0.06316058f, -0.23904732f, -0.08227582f, 0.12667543f, 0.18681344f, 0.08284691f, -0.00280407f, 
    0.12898073f, 0.10984575f, 0.00526301f, 0.07692974f, 0.14760444f, -0.21321796f, 0.14775987f, -0.18634790f, 
    -0.09788559f, -0.28671643f, 0.04564774f, 0.04933599f, -0.03639130f, -0.00768354f, -0.03508358f, 0.17071286f, 
    0.04242510f, 0.01282607f, 0.04631992f, -0.12909561f, 0.02010928f, -0.00144134f, 0.00432573f, -0.05074174f, 
    -0.17119917f, -0.10172869f, 0.05099525f, -0.22021723f, 0.15655793f, -0.07929493f, -0.04548101f, 0.07188251f, 
    0.13897704f, 0.02962286f, -0.08315183f, 0.04778870f, 0.16336608f, -0.04640254f, -0.04905768f, 0.05793264f, 
    0.05075302f, -0.13464791f, -0.00785542f, 0.06233305f, 0.07221910f, -0.02273654f, -0.09990642f, -0.01095930f, 
    -0.05742599f, -0.23877501f, -0.24083023f, 0.00728515f, -0.01764745f, 0.15155454f, -0.06431519f, -0.03383986f, 
    -0.12100559f, 0.15135708f, 0.75102478f, -0.14317197f, 0.02395855f, -0.00379052f, 0.05212077f, 0.35907093f, 
    0.05521168f, -0.10502202f, 0.00070011f, 0.32722250f, 0.07389703f, 0.14726728f, -0.03943127f, -0.15384352f, 
    0.07841070f, -0.01007781f, 0.01645180f, -0.13069098f, -0.24111450f, 0.20406753f, -0.11533388f, -0.22432390f, 
    -0.02837401f, 0.03984707f, 0.03453062f, 0.09379915f, -0.06633534f, 0.02381073f, 0.05123378f, -0.10863838f, 
    0.07887775f, 0.07229610f, 0.08246990f, 0.08623853f, 0.01664640f, 0.02881037f, -0.07463127f, 0.00098699f, 
    0.07867022f, 0.07202884f, -0.04210598f, 0.00013971f, -0.12335248f, -0.02878264f, -0.02695560f, 0.00890246f, 
    0.48335987f, 0.19736567f, -0.13792670f, -0.18830410f, 0.16473116f, -0.03833798f, -0.04175837f, 0.01254590f, 
    -0.20221370f, -0.07095432f, 0.35879743f, -0.05942305f, 0.01967889f, 0.00843499f, 0.12952617f, 0.07672530f, 
    -0.03520428f, -0.22772382f, -0.17583089f, -0.03816122f, 0.03215344f, 0.11083421f, -0.00915115f, 0.02869664f, 
    0.11157224f, 0.04226796f, -0.34479097f, -0.28058675f, -0.50976837f, -0.06507745f, 0.04313006f, 0.12558772f, 
    0.01796293f, -0.13855298f, -0.03218831f, 0.11002383f, -0.24444598f, 0.48109391f, 0.01296418f, -0.01265033f, 
    -0.00968179f, 0.00769664f, 0.18309924f, 0.21534611f, 0.08619066f, 0.02881024f, 0.08500864f, 0.02409561f, 
    -0.03315981f, -0.02991258f, -0.09030469f, -0.08024067f, -0.11781986f, 0.11028585f, 0.22197825f, -0.12244897f, 
    -0.14678694f, -0.15522043f, -0.12223081f, -0.07597060f, -0.14673536f, -0.14288329f, -0.05725318f, 0.06563728f, 
    0.07565534f, -0.07548569f, 0.05180116f, 0.03688024f, 0.04738221f, 0.07811914f, -0.05454264f, 0.02192391f, 
    0.11327436f, -0.17304608f, 0.02663195f, -0.04016300f, 0.07722008f, -0.05576755f, 0.02302957f, -0.08896212f, 
    0.13582568f, -0.02978285f, -0.00852047f, -0.01240328f, 0.19261436f, -0.14012429f, 0.03396463f, -0.05596346f, 
    0.14630237f, -0.06788739f, -0.23152952f, 0.10967414f, -0.01192545f, -0.16911733f, -0.03525694f, -0.07218517f, 
    0.00905702f, 0.14536507f, -0.02468996f, 0.16172478f, 0.22096060f, 0.01696731f, 0.13205338f, 0.06130912f, 
    -0.01329851f, 0.02904629f, 0.07027952f, 0.10905344f, 0.14472792f, -0.15452158f, 0.10221950f, 0.02440915f, 
    0.09354278f, 0.04998097f, -0.18851794f, -0.02340272f, 0.13235979f, 0.17553167f, 0.31299359f, -0.00004090f, 
    -0.02550187f, 0.11187472f, 0.05728107f, -0.08698590f, -0.20911209f, 0.15690672f, -0.24756549f, -0.01275214f, 
    0.02831494f, 0.05084298f, -0.03264619f, 0.15825929f, 0.15803850f, 0.17507967f, 0.01756240f, 0.30378592f, 
    0.11756244f, 0.04757954f, -0.08053058f, -0.10506304f, -0.03682510f, -0.04980886f, 0.02326130f, -0.37970814f, 
    -0.15615359f, 0.08007684f, 0.02851872f, -0.00255198f, 0.07289015f, 0.06888914f, 0.00329512f, -0.01057887f, 
    -0.18688282f, -0.19425899f, -0.14084415f, -0.01702550f, 0.12331652f, 0.07321578f, 0.06638794f, -0.01384194f, 
    0.05038739f, 0.02821043f, 0.06864679f, 0.31977916f, -0.12674330f, 0.01754022f, -0.01460874f, -0.12362718f, 
    -0.05822714f, -0.08113220f, 0.19707054f, 0.33897880f, 0.24966492f, -0.01462581f, -0.07384435f, 0.06788956f, 
    0.02471532f, -0.07292069f, 0.10936967f, 0.02539743f, -0.12508006f, 0.03027915f, 0.05821249f, 0.04859297f, 
    -0.12906648f, 0.03353061f, 0.04653674f, -0.11714070f, -0.00410273f, 0.08430184f, -0.20055912f, -0.05731300f, 
    -0.08051541f, 0.04000409f, -0.05902720f, -0.11228556f, -0.12711813f, 0.16224919f, 0.15388158f, 0.03075878f, 
    0.03968888f, -0.07447471f, 0.08143321f, -0.17847241f, -0.25569555f, 0.19866204f, 0.06145306f, -0.00525788f, 
    0.14657952f, 0.09298483f, -0.04360808f, -0.12763283f, -0.07992355f, -0.10832480f, 0.15199888f, 0.07589750f, 
    0.04872024f, -0.12162175f, -0.00067316f, 0.14611018f, 0.17441751f, -0.09784251f, 0.00423741f, -0.05501658f, 
    0.24600278f, -0.11576901f, 0.02455501f, 0.08812777f, -0.04351783f, 0.11567722f, 0.12058508f, 0.01622126f, 
    -0.09208100f, 0.32499361f, 0.05407118f, 0.15248352f, -0.13480645f, -0.08013266f, 0.11182011f, 0.16658571f, 
    0.02832540f, 0.01592159f, -0.07924375f, 0.32282889f, -0.29755843f, 0.08676755f, -0.22750528f, -0.15604453f, 
    0.13683134f, 0.10953180f, -0.08100749f, 0.05715279f, 0.04801011f, 0.07426011f, -0.08091170f, -0.08088231f, 
    -0.14190286f, 0.16735962f, 0.05748270f, 0.05720945f, 0.39600691f, 0.17044176f, 0.19423395f, 0.01225389f, 
    0.09308448f, -0.12504834f, 0.04059347f, -0.00635245f, -0.03166565f, -0.02628956f, -0.03264271f, -0.16436449f, 
    0.31358650f, -0.09545330f, 0.01086996f, -0.01490509f, 0.03460088f, -0.00541807f, 0.26868370f, -0.16009490f, 
    0.12148900f, 0.10830070f, 0.01699198f, 0.03353219f, 0.04941805f, 0.03902318f, 0.07000479f, -0.56332523f, 
    -0.12203185f, -0.16895287f, -0.03198665f, 0.10220105f, 0.06112875f, 0.11061934f, -0.02181435f, 0.17173101f, 
    0.57026350f, 0.20041774f, -0.01577234f, -0.06459150f, 0.12094469f, -0.03178658f, 0.06644411f, -0.04417404f, 
    0.07110853f, 0.07936302f, 0.24022122f, 0.14392345f, 0.09516515f, -0.10298990f, -0.15867999f, 0.04047093f, 
    0.09127861f, 0.05304552f, -0.06667136f, 0.41201532f, 0.25550139f, 0.09315788f, -0.17213631f, 0.05082723f, 
    -0.00677915f, -0.07116068f, 0.09714973f, 0.11404218f, -0.06529239f, -0.03367326f, -0.05403251f, 0.04555152f, 
    0.04259510f, 0.02987695f, -0.03061628f, -0.05312835f, -0.01497116f, -0.30760637f, -0.16562290f, -0.02154653f, 
    -0.00774016f, -0.07076655f, -0.06406200f, -0.00756308f, -0.00048813f, -0.01251721f, -0.18100147f, -0.03161371f, 
    0.14763683f, -0.05548580f, 0.13388473f, -0.24151282f, 0.02051381f, 0.05723057f, 0.22009605f, 0.07708714f, 
    0.19171691f, -0.06835644f, 0.07472456f, 0.00868511f, -0.08794934f, 0.00776276f, 0.12103526f, 0.35444742f, 
    0.19036300f, 0.14519775f, 0.07458110f, -0.06482745f, -0.05817846f, -0.02451178f, -0.01939594f, -0.05140283f, 
    0.01593019f, -0.21677816f, -0.04156495f, 0.08017879f, -0.05652184f, 0.03366928f, -0.06890234f, -0.14543277f, 
    -0.00561980f, 0.04274053f, -0.12639973f, 0.12598640f, 0.00451830f, -0.02586687f, 0.01925615f, 0.08409061f, 
    -0.04861246f, -0.27204296f, 0.06999775f, -0.13780670f, -0.27816412f, -0.01706954f, 0.09372630f, 0.02392505f, 
    0.08458047f, -0.01169628f, 0.06111070f, -0.02883260f, -0.38831806f, -0.14333300f, -0.14163408f, -0.07200773f, 
    0.02683327f, -0.05465806f, 0.08537457f, -0.04416758f, -0.13866104f, -0.07917869f, -0.27467012f, 0.00613639f, 
    -0.15056829f, 0.02851437f, -0.08351090f, 0.11191075f, -0.03715935f, -0.00634414f, 0.05720288f, 0.09512389f, 
    -0.13800998f, -0.21308221f, -0.08249833f, -0.08958471f, 0.04476129f, 0.03159782f, 0.00094509f, 0.01217973f, 
    -0.12348474f, -0.09865769f, -0.10716151f, 0.05047745f, 0.00992896f, -0.00269454f, 0.14726925f, 0.01918954f, 
    0.03280903f, 0.14795168f, -0.02784657f, 0.14904214f, -0.10308604f, 0.02368190f, 0.05996579f, -0.02104969f, 
    0.05560727f, 0.27434981f, 0.14847560f, -0.00660246f, 0.01604565f, -0.11719947f, -0.01541046f, -0.01706614f, 
    0.17860411f, -0.11940859f, 0.36756250f, -0.19203830f, -0.10130667f, -0.08265425f, -0.04703173f, 0.11855618f, 
    0.05972660f, 0.20030722f, -0.09674579f, -0.19487172f, -0.22257011f, -0.20695511f, -0.01274376f, -0.13647553f, 
    0.06903753f, -0.09156082f, -0.00998124f, 0.04820118f, -0.10800695f, -0.26075381f, 0.01685107f, -0.15618518f, 
    -0.39976230f, -0.10853663f, -0.15345968f, 0.09403127f, 0.14457992f, -0.00566328f, 0.15476234f, -0.07572282f, 
    -0.06705696f, 0.05731048f, -0.13827616f, 0.13610721f, 0.07570295f, 0.18707289f, 0.15462852f, 0.02583255f, 
    0.03555046f, -0.08622608f, 0.11672150f, 0.09972565f, 0.18530956f, 0.08399156f, 0.18433036f, 0.01863705f, 
    0.19000472f, 0.08690637f, -0.11690447f, -0.17231292f, 0.01909194f, 0.11819930f, 0.08157538f, -0.03432696f, 
    -0.03893655f, -0.25115803f, -0.09330305f, -0.21216543f, -0.12190428f, -0.06110638f, -0.08220011f, -0.18419826f, 
    -0.00287059f, -0.04836938f, -0.06284353f, 0.00090968f, -0.05115176f, -0.03189450f, -0.04740319f, -0.04828021f, 
    0.02847680f, 0.04434650f, 0.02490003f, -0.06026788f, 0.02058729f, 0.05074832f, -0.02797024f, 0.00845769f, 
    -0.02985582f, -0.04645014f, 0.01977535f, -0.01290868f, 0.02234937f, -0.05923558f, 0.04722187f, 0.00275549f, 
    -0.02509661f, 0.00509896f, 0.01244015f, 0.00062073f, 0.03726691f, 0.00991920f, -0.04440749f, 0.01903105f, 
    0.00032720f, -0.03056239f, -0.02112065f, 0.04137180f, 0.03607403f, 0.00228661f, -0.06134024f, -0.01719062f, 
    0.04717894f, -0.04192480f, 0.00737542f, 0.00781509f, 0.02702402f, -0.04160150f, 0.01174174f, -0.02626143f, 
    -0.01704921f, 0.04834573f, -0.05025090f, -0.05980828f, -0.05430716f, -0.05260185f, -0.05281569f, -0.05814926f, 
    -0.04350787f, -0.00619424f, -0.02895186f, 0.04021576f, -0.06023635f, -0.05407478f, 0.01825576f, -0.00549272f, 
    -0.02916710f, -0.04143845f, -0.03251590f, 0.02993003f, -0.00418685f, -0.04407810f, 0.01257597f, -0.04701006f, 
    -0.03006389f, -0.00346060f, 0.03097786f, 0.00649841f, -0.02426169f, -0.00317922f, -0.03696255f, -0.03212003f, 
    -0.04753402f, 0.05170831f, -0.02630909f, -0.03601650f, -0.03518151f, -0.02143261f, 0.04752332f, -0.03262546f, 
    0.00178920f, 0.04638049f, 0.02560353f, 0.00020708f, 0.04728011f, -0.02322667f, 0.02114348f, -0.05853447f, 
    0.03280648f, -0.01864761f, -0.04003792f, -0.04230091f, -0.01250038f, 0.01806949f, -0.04165730f, -0.04916388f, 
    -0.03091910f, -0.00683670f, -0.00904522f, -0.03212594f, 0.03198664f, 0.00401666f, -0.03937567f, -0.01342503f, 
    0.01633892f, 0.00069615f, -0.04471815f, 0.02191561f, -0.00466061f, 0.04019543f, -0.03818333f, -0.02762255f, 
    -0.05174135f, -0.03486313f, -0.04280158f, 0.01341312f, -0.04341409f, -0.04787184f, 0.01404679f, 0.00658316f, 
    0.04825449f, 0.03924344f, -0.03136323f, 0.04437013f, 0.04231960f, 0.04561342f, -0.01316469f, -0.03823343f, 
    -0.02611119f, -0.04923958f, -0.01617444f, 0.01261045f, -0.01766429f, -0.01608342f, -0.03741297f, 0.03475825f, 
    0.01430857f, 0.02819452f, 0.00509801f, -0.00919784f, 0.01874113f, 0.05260414f, 0.00310244f, 0.00980840f, 
    -0.05446371f, 0.00018337f, 0.01521195f, 0.03458112f, -0.03260566f, -0.03128473f, -0.04087302f, -0.00202321f, 
    -0.04596025f, 0.04751560f, -0.05435991f, 0.00533088f, 0.02972370f, 0.00522676f, 0.02941495f, -0.00883138f, 
    0.00067571f, 0.02841921f, -0.05590583f, 0.02540577f, 0.01475733f, -0.03697691f, 0.03149299f, -0.04427570f, 
    0.05473502f, -0.01124767f, 0.03574230f, -0.04429409f, 0.00885058f, -0.02781706f, -0.05126559f, -0.05068717f, 
    -0.00400477f, -0.00085580f, 0.03767538f, 0.02016774f, -0.01626629f, -0.00448762f, -0.05410784f, -0.03329762f, 
    -0.03621501f, 0.00364716f, 0.02709824f, 0.01771359f, 0.00066216f, -0.03277115f, 0.01221361f, -0.03343211f, 
    0.03346981f, -0.00606309f, -0.00294497f, 0.00184808f, -0.05055000f, -0.03196764f, 0.03782207f, -0.02721640f, 
    0.00357771f, -0.03752108f, 0.01987393f, 0.04466356f, -0.00949912f, -0.01291106f, 0.01044297f, -0.01342505f, 
    -0.01009850f, 0.03150111f, 0.01409142f, -0.04425175f, -0.02253968f, 0.00741138f, -0.05350171f, -0.06333177f, 
    0.01667164f, -0.02567556f, 0.00378621f, 0.02299990f, 0.04813667f, 0.01572580f, -0.02408468f, -0.04013653f, 
    -0.00179827f, -0.01209685f, -0.01108344f, -0.03686811f, 0.04351429f, 0.01309981f, 0.02515080f, -0.05227992f, 
    -0.06519321f, 0.00617878f, -0.00069190f, 0.04016612f, -0.04872574f, -0.03618253f, -0.00420646f, -0.02107044f, 
    -0.03949998f, -0.08019643f, -0.00068825f, -0.05126529f, -0.01436505f, 0.01416795f, -0.01705494f, -0.00230434f, 
    -0.01099565f, 0.00431260f, 0.02510884f, 0.04620563f, 0.02882581f, 0.00010028f, -0.06102898f, 0.04209256f, 
    0.04550340f, -0.00131530f, 0.04067206f, 0.04717781f, -0.06508027f, 0.02142221f, 0.01150382f, 0.00991942f, 
    0.02762065f, -0.01092376f, -0.00490212f, 0.00828059f, -0.01000646f, 0.03312708f, 0.03927909f, -0.03092811f, 
    -0.05394269f, -0.05440203f, -0.05581564f, -0.00433438f, 0.05022160f, 0.03285442f, -0.01144180f, 0.01140667f, 
    0.00414302f, -0.03637638f, -0.05436474f, -0.02785918f, 0.04629483f, 0.01927294f, -0.06387811f, -0.01358204f, 
    0.02349367f, -0.05188945f, -0.03267029f, 0.02881877f, -0.04750576f, -0.05132424f, -0.06057119f, -0.00509218f, 
    -0.04497384f, -0.03826370f, -0.00946054f, -0.04954012f, -0.03974875f, -0.02435321f, -0.01078419f, -0.06461262f, 
    0.03972537f, -0.04981572f, 0.03507772f, 0.00627717f, -0.03601508f, 0.01737242f, 0.02434070f, -0.03369361f, 
    0.02387242f, -0.00423621f, 0.03120684f, -0.01103531f, -0.04556982f, -0.03324923f, -0.02672455f, -0.00175432f, 
    -0.00940140f, 0.02275488f, -0.05706531f, 0.04183559f, 0.03786814f, 0.00762859f, 0.00454980f, -0.06303478f, 
    0.00866207f, -0.01471290f, 0.00706551f, -0.05019878f, -0.00781336f, -0.02025083f, 0.00830815f, -0.03564313f, 
    -0.03329979f, -0.03715503f, -0.00952822f, -0.04553863f, -0.02060805f, 0.04655455f, 0.03555357f, 0.02813766f, 
    -0.01714963f, -0.00148000f, -0.03336740f, 0.01770024f, -0.06350545f, 0.01349031f, -0.06135080f, 0.04177508f, 
    -0.01610457f, 0.03353843f, 0.00913692f, 0.00525703f, 0.01995410f, 0.04189521f, 0.00615676f, 0.00726037f, 
    0.01031513f, -0.02117741f, 0.03572006f, -0.02443314f, 0.04058988f, 0.03323084f, -0.03838499f, -0.01505521f, 
    0.02129086f, -0.02200005f, 0.02133875f, 0.01307862f, -0.01720251f, -0.03021296f, 0.01178970f, -0.05517845f, 
    -0.01704873f, 0.05197713f, -0.02253611f, 0.03923609f, -0.02510159f, 0.03256557f, 0.03085809f, -0.03705073f, 
    -0.05006244f, 0.04901055f, -0.00003732f, -0.03053553f, 0.04874646f, -0.04320114f, -0.04036598f, 0.02680485f, 
    -0.05767613f, -0.03028830f, 0.02381069f, 0.01326215f, 0.01312432f, 0.02076389f, 0.01045949f, -0.00052441f, 
    0.04493948f, 0.00313556f, -0.02421338f, 0.04471955f, 0.00727654f, -0.04112954f, 0.00562948f, -0.01563984f, 
    0.01647859f, 0.03791080f, -0.05982567f, -0.04072588f, -0.01786748f, 0.01815847f, 0.02401018f, -0.03404633f, 
    -0.05284375f, -0.04785579f, -0.04064858f, 0.00757846f, -0.04776897f, -0.04548083f, 0.04915837f, -0.04874084f, 
    -0.00469726f, -0.06593265f, -0.05428077f, 0.04203173f, -0.02222390f, 0.04497256f, -0.03097454f, -0.02642143f, 
    -0.01463034f, -0.05301593f, 0.00368366f, -0.02627142f, 0.03637937f, 0.01558030f, 0.03265402f, 0.05109661f, 
    -0.06068069f, 0.05643784f, 0.02174173f, 0.00070867f, 0.01975369f, -0.02668296f, 0.00700626f, 0.00445735f, 
    -0.04612866f, -0.03750905f, -0.04117459f, -0.04493036f, 0.04074838f, 0.01078348f, 0.01261214f, 0.00696250f, 
    -0.01883827f, 0.03574523f, -0.03354189f, 0.03204038f, -0.04315229f, -0.01526790f, -0.04983371f, 0.02960094f, 
    -0.01200291f, -0.03748608f, -0.01151991f, 0.03239480f, 0.00558773f, -0.02739199f, -0.04245859f, -0.04635292f, 
    -0.04046581f, 0.03660973f, -0.03874357f, -0.04615986f, 0.02773443f, -0.04117149f, 0.02127617f, 0.01298028f, 
    0.01332747f, 0.03779080f, 0.02713799f, -0.05466142f, -0.01925987f, -0.02119552f, 0.02856625f, -0.01835839f, 
    0.05312473f, -0.01941056f, -0.06406759f, -0.00213501f, 0.01434742f, -0.03594256f, 0.04869235f, -0.04627352f, 
    0.00452521f, 0.04377616f, -0.01902847f, -0.05325177f, 0.01649431f, 0.02765899f, 0.04001855f, -0.04501643f, 
    0.03445539f, -0.02037525f, 0.05149579f, -0.00863359f, -0.03146068f, -0.02391820f, -0.02930838f, -0.04892289f, 
    -0.05923202f, 0.05207467f, -0.04639524f, 0.00437131f, 0.01748228f, -0.00836024f, 0.04383332f, 0.04453593f, 
    -0.00312107f, 0.01990410f, 0.02074817f, 0.05035475f, -0.03603327f, 0.04031991f, -0.06288022f, 0.01994407f, 
    -0.02375297f, -0.05286793f, -0.02391016f, -0.03359133f, 0.00885568f, -0.02646560f, 0.00599378f, 0.01533916f, 
    -0.02096634f, -0.05893839f, -0.06322247f, 0.02152830f, -0.06265841f, 0.02487274f, -0.04631603f, 0.00869618f, 
    0.04170983f, 0.00869122f, -0.01866565f, -0.01617515f, 0.00546942f, -0.01030567f, 0.01027513f, 0.02889604f, 
    -0.02238079f, -0.03531848f, 0.03053360f, -0.02443749f, 0.04772883f, -0.04726631f, -0.02341681f, -0.01996686f, 
    -0.03619346f, 0.05033747f, 0.01993947f, -0.05260956f, -0.01055742f, -0.04516878f, -0.02871230f, -0.06245837f, 
    -0.16195892f, 0.01432157f, 0.27238452f, 0.00354365f, -0.01950049f, -0.13865468f, 0.06230834f, -0.19361827f, 
    0.02489345f, -0.04940328f, 0.01601240f, 0.15150033f, 0.05475540f, 0.06609575f, 0.02778311f, -0.10310989f, 
    0.08801568f, 0.10600399f, 0.36189601f, -0.43229908f, -0.16875939f, 0.07709449f, 0.03880213f, 0.02477426f, 
    -0.04484344f, -0.24842519f, 0.02830920f, 0.05880797f, -0.25512353f, -0.07837702f, -0.06061719f, 0.05045608f, 
    0.22186832f, -0.00443033f, -0.11766998f, -0.08853853f, -0.11238596f, 0.00443945f, -0.09169777f, -0.19397554f, 
    -0.11273478f, -0.14678410f, 0.13030943f, 0.11391113f, 0.08275829f, 0.16054495f, -0.09748333f, -0.02509308f, 
    0.02643217f, -0.04615318f, -0.11488707f, -0.00998055f, -0.09175225f, -0.09249401f, -0.10392597f, -0.01524039f, 
    0.16072761f, -0.05708162f, -0.15003361f, 0.07025921f, 0.11974157f, -0.26959583f, 0.00549390f, 0.00857072f, 
    -0.29596224f, 0.08883679f, 0.09426755f, -0.05941438f, 0.14449994f, -0.00649077f, -0.06908134f, -0.06112571f, 
    -0.44144127f, -0.15437579f, -0.00595800f, 0.06441954f, -0.00212353f, -0.10360622f, 0.03848895f, 0.03241016f, 
    -0.07502120f, -0.09350923f, 0.00327162f, 0.14865799f, 0.10251627f, -0.02313655f, -0.13629539f, 0.01703251f, 
    0.05560599f, 0.11444076f, -0.28861353f, -0.15453734f, -0.38055316f, 0.22637430f, 0.08224778f, -0.03324521f, 
    -0.21743375f, 0.03452547f, -0.10660889f, -0.05407074f, 0.16967963f, -0.16861172f, 0.02521001f, 0.08249890f, 
    -0.06393310f, 0.02207587f, 0.08054409f, 0.02601090f, 0.13094193f, -0.21164685f, 0.13313797f, -0.02752789f, 
    -0.00396178f, 0.12113415f, 0.09370954f, -0.04150968f, -0.02518102f, -0.18115826f, 0.17277382f, 0.09930780f, 
    0.12612452f, 0.04896588f, 0.09518591f, 0.17462303f, -0.01471933f, 0.04079374f, 0.00193849f, -0.05140092f, 
    0.18636060f, 0.05041311f, 0.12256130f, 0.03080327f, 0.12378938f, -0.00989329f, 0.12140515f, 0.04221030f, 
    -0.08101588f, -0.19207002f, -0.06895874f, -0.15599824f, -0.16814840f, 0.18325953f, 0.21656735f, 0.06437250f, 
    -0.14469585f, 0.35040280f, -0.01920827f, 0.12013970f, 0.15303485f, -0.07290705f, 0.01404987f, 0.08913106f, 
    0.03584613f, -0.03219448f, -0.07161142f, -0.10829077f, -0.00629649f, 0.05808424f, -0.03210299f, -0.00155622f, 
    -0.04433414f, 0.15605879f, -0.01978247f, -0.13268265f, -0.18461862f, 0.10158025f, -0.12734465f, 0.17076741f, 
    -0.10627845f, 0.01177683f, -0.14170477f, -0.01346389f, -0.14486769f, -0.11723855f, 0.08799378f, 0.07019915f, 
    0.03990101f, 0.14970931f, 0.07350751f, 0.12258955f, -0.07511947f, -0.14929834f, 0.06360524f, 0.13900225f, 
    -0.10560702f, 0.09141264f, 0.03325704f, 0.14219190f, -0.01789996f, -0.17379171f, -0.03329929f, -0.33253941f, 
    0.20141959f, -0.07540318f, 0.11073629f, 0.15480289f, 0.26852888f, 0.07369203f, -0.02559405f, -0.21227062f, 
    -0.10570906f, 0.15821604f, -0.02046695f, 0.09077023f, 0.14572942f, -0.03361912f, 0.13182877f, 0.03742352f, 
    -0.13156585f, -0.00467385f, 0.18803890f, 0.03347055f, 0.03376612f, 0.12360084f, -0.14107096f, 0.03349232f, 
    -0.08743066f, -0.09339146f, -0.00261178f, 0.14788744f, 0.04796150f, 0.03609787f, -0.11046091f, -0.01378733f, 
    0.06123791f, -0.34304291f, 0.00873431f, -0.09704483f, 0.13861752f, -0.27324191f, -0.13426068f, 0.00889105f, 
    0.02810933f, -0.01238726f, 0.11954344f, -0.11902519f, -0.00447655f, 0.06583548f, -0.05494018f, 0.07947870f, 
    -0.11263158f, 0.10728039f, 0.08337726f, -0.06465317f, -0.21924551f, -0.25691366f, -0.06192579f, -0.01704573f, 
    0.07108932f, 0.02259018f, 0.13530521f, 0.20363314f, -0.11819462f, -0.00255699f, -0.17719552f, 0.07399683f, 
    0.04252972f, 0.22356890f, 0.06112698f, 0.02295280f, -0.01305932f, -0.11426951f, 0.10996942f, -0.37905493f, 
    0.04372390f, -0.13443545f, -0.04065173f, -0.08959711f, -0.11236858f, -0.14609905f, -0.25843823f, 0.28691307f, 
    0.06308437f, -0.01472956f, -0.06600066f, -0.03481174f, 0.00259321f, -0.14412275f, -0.01815582f, 0.02702225f, 
    -0.06749629f, 0.06387545f, -0.02636451f, -0.26137960f, 0.12342572f, 0.33368281f, 0.35439408f, 0.20250168f, 
    -0.13435179f, -0.03121114f, -0.08874629f, 0.10168871f, 0.10666665f, -0.18286614f, -0.03746076f, 0.14233410f, 
    0.05600247f, -0.16355680f, -0.13488969f, -0.01679520f, -0.03593447f, -0.01281110f, -0.29020032f, 0.03188459f, 
    -0.01938435f, 0.04243375f, -0.56118935f, -0.12878399f, 0.29270741f, -0.00772439f, -0.12109137f, 0.32975125f, 
    -0.09539839f, 0.08739222f, -0.01212287f, -0.05426021f, 0.14071214f, 0.12910622f, -0.08064761f, -0.16097908f, 
    -0.11200651f, 0.04077549f, 0.20961255f, 0.05024932f, 0.12620014f, -0.10173173f, 0.15057583f, -0.06421441f, 
    -0.11485044f, -0.06104637f, 0.10865015f, 0.00875603f, -0.16312851f, -0.18469168f, -0.09109023f, -0.10893185f, 
    -0.02474160f, -0.11141796f, 0.06723662f, 0.07471920f, 0.09634071f, 0.14586958f, -0.02719929f, 0.06899561f, 
    0.15738043f, 0.13589785f, -0.26418671f, -0.24721208f, -0.03818996f, 0.09587051f, 0.06108328f, -0.57768667f, 
    0.20791923f, -0.45492831f, -0.05918407f, -0.03039221f, 0.19840334f, -0.17556885f, -0.06084104f, 0.09520602f, 
    -0.12674814f, 0.15247373f, 0.23080030f, -0.21498792f, -0.14297590f, -0.05227108f, 0.10133684f, 0.09596514f, 
    0.11796348f, -0.04820826f, 0.03980066f, -0.03203540f, 0.08850474f, -0.23986466f, 0.22931939f, 0.07224295f, 
    0.00448258f, 0.21105435f, 0.20088135f, -0.04549908f, 0.33455259f, -0.02370505f, -0.04162074f, 0.02357587f, 
    0.11522380f, 0.17144400f, 0.08368777f, -0.08046369f, 0.24978939f, 0.19529758f, -0.07984820f, -0.13878255f, 
    -0.13989922f, 0.14368078f, -0.02085528f, 0.13483988f, -0.23895396f, 0.07829835f, -0.16949166f, -0.07436052f, 
    0.11895328f, 0.16677122f, 0.06117682f, 0.04604379f, -0.03161968f, 0.01162338f, 0.10377227f, 0.08603097f, 
    -0.13406838f, 0.04799096f, -0.10589991f, 0.02874473f, -0.06894895f, 0.04408925f, -0.15924105f, 0.31720901f, 
    -0.11832345f, -0.15169273f, -0.03664138f, -0.01602934f, 0.21057147f, -0.00732242f, -0.12892440f, -0.06016413f, 
    -0.02705977f, 0.31187770f, -0.02207706f, -0.10404301f, -0.14270362f, 0.03067711f, 0.06862251f, -0.11120448f, 
    0.20331459f, 0.09417159f, 0.08659749f, 0.04804207f, 0.02202891f, -0.07670289f, 0.10726572f, -0.00856799f, 
    -0.02670142f, 0.06122361f, 0.27051204f, 0.23742113f, -0.08801453f, -0.09423581f, -0.05639401f, 0.00858036f, 
    0.15829363f, 0.06578089f, -0.24456038f, -0.17876232f, 0.14223732f, -0.30376694f, 0.15994437f, -0.21228434f, 
    0.08079904f, -0.15746787f, 0.16409999f, 0.06973721f, -0.02075447f, 0.25757602f, -0.13734914f, -0.10001236f, 
    0.03795272f, 0.07155243f, -0.00004071f, 0.12695338f, 0.06487945f, 0.30289638f, 0.31095505f, -0.08160542f, 
    -0.36244360f, -0.17305139f, -0.01143418f, -0.02155104f, 0.13578826f, 0.01078650f, 0.29290712f, -0.09464563f, 
    -0.00150128f, 0.12019671f, -0.12308074f, -0.02437974f, -0.06264188f, -0.14162171f, -0.14600922f, 0.18788207f, 
    -0.06178919f, -0.13112967f, 0.00766320f, -0.09437115f, 0.22293597f, 0.06561328f, 0.15129690f, 0.02507122f, 
    0.37907830f, 0.34739023f, -0.09568136f, -0.13496090f, -0.04939294f, 0.17384587f, 0.03176012f, 0.01725476f, 
    0.12089412f, 0.03989105f, 0.15091662f, -0.14738652f, -0.02881015f, -0.02415110f, 0.12428132f, 0.06883515f, 
    0.13411696f, -0.55710828f, -0.32187358f, 0.00212834f, -0.06791446f, 0.12651867f, -0.00722732f, -0.12764949f, 
    -0.09471880f, -0.01415256f, -0.36944962f, 0.11882435f, 0.25163773f, -0.26882428f, 0.03540273f, -0.01683479f, 
    0.07403369f, 0.14156450f, -0.11395370f, -0.10567700f, 0.39720729f, 0.17519346f, -0.04228440f, 0.09301921f, 
    -0.08605689f, 0.03250506f, 0.17097101f, -0.07033773f, 0.19849600f, 0.02298671f, 0.07018340f, -0.21107981f, 
    -0.07328471f, -0.17492332f, 0.03024128f, 0.06485609f, -0.00024247f, -0.06494136f, -0.11282048f, -0.25874570f, 
    -0.05324350f, -0.29464331f, -0.07263888f, 0.21138534f, -0.11664014f, 0.21511447f, -0.08634209f, -0.49214426f, 
    0.03554756f, 0.04335229f, -0.01727344f, -0.14745313f, 0.01570113f, -0.10830564f, 0.05432842f, -0.13798168f, 
    0.24971333f, -0.15882680f, 0.12852141f, 0.20383453f, 0.03317194f, 0.12173260f, 0.05915417f, -0.20372404f, 
    0.04357686f, 0.02074231f, 0.00848336f, -0.02789839f, -0.04533497f, -0.01815790f, -0.02062881f, -0.02345050f, 
    -0.05750609f, -0.01928787f, 0.01801816f, 0.03163943f, 0.04383591f, 0.04522012f, 0.00424234f, -0.04469732f, 
    0.00602552f, 0.04387762f, -0.01260259f, -0.01365465f, -0.04638231f, 0.00383224f, -0.00087652f, 0.02524600f, 
    0.04981142f, -0.04281506f, -0.03354344f, -0.02836155f, 0.03196532f, -0.00620164f, -0.00174280f, -0.00247892f, 
    0.01543743f, 0.04379862f, -0.05378155f, 0.01051708f, -0.00723881f, -0.02311212f, 0.05937100f, -0.02725486f, 
    -0.05127038f, 0.03226078f, -0.05446362f, -0.05954064f, -0.04038477f, -0.01367634f, -0.05233552f, 0.03693809f, 
    -0.04697681f, -0.01609806f, -0.00661124f, -0.03449317f, 0.00550526f, 0.04305773f, -0.00236166f, 0.02427285f, 
    -0.02247473f, 0.04873547f, 0.03346511f, 0.00881504f, -0.00246621f, 0.02278090f, -0.06171966f, 0.04672959f, 
    -0.05606643f, 0.01361232f, 0.01545930f, -0.02234793f, -0.05590494f, 0.00572491f, -0.03871237f, -0.05028368f, 
    -0.00108437f, 0.04049923f, 0.00054409f, 0.02362796f, 0.01013258f, 0.00240716f, 0.05736061f, 0.03935038f, 
    0.02124124f, -0.01697095f, -0.01397527f, 0.00083060f, -0.04578349f, -0.00258943f, -0.04968268f, 0.00773341f, 
    0.05186779f, -0.03974160f, -0.05168617f, -0.04047985f, 0.05591824f, -0.00621514f, 0.04613630f, 0.04997538f, 
    -0.02179590f, -0.00117252f, 0.03777468f, -0.04233859f, -0.01184683f, 0.03567636f, -0.01144027f, 0.03868347f, 
    -0.05411791f, -0.04738406f, -0.04656420f, -0.06286296f, -0.01382737f, 0.02244769f, -0.02586156f, 0.02855041f, 
    0.03958281f, -0.05320790f, -0.05457017f, 0.01337404f, -0.03283552f, 0.02095011f, 0.05089937f, 0.00038302f, 
    -0.03224462f, 0.01587723f, 0.02411546f, 0.02370627f, -0.03705240f, -0.04091474f, -0.05773984f, 0.01451293f, 
    -0.05561070f, 0.04683161f, -0.01441583f, -0.02024591f, -0.05699881f, -0.04494070f, -0.02051730f, -0.03611656f, 
    -0.04974021f, 0.06302343f, -0.01394574f, -0.00477593f, -0.05812389f, 0.02058456f, -0.04426930f, 0.04273669f, 
    0.00311308f, -0.01529867f, -0.03862472f, -0.02275521f, -0.03998910f, -0.02445933f, -0.05535131f, 0.02474920f, 
    0.00024840f, -0.03472053f, 0.04281396f, -0.01569334f, 0.04894169f, -0.04440573f, 0.02205642f, 0.00631432f, 
    0.00493515f, -0.05009592f, 0.01141931f, 0.00498602f, -0.04483048f, -0.05729155f, 0.02648206f, -0.03076037f, 
    0.01850895f, 0.04786152f, 0.00539811f, -0.02872279f, 0.03930452f, -0.04155161f, -0.01672423f, -0.03355879f, 
    0.06023421f, 0.02514981f, -0.06788397f, 0.03645824f, -0.00357551f, 0.02612513f, -0.06060751f, 0.01612789f, 
    -0.03388235f, -0.06052571f, -0.01945188f, 0.03506106f, -0.01959094f, 0.00946413f, -0.00306008f, -0.04370953f, 
    -0.03108461f, -0.03953440f, -0.01804705f, 0.04660764f, -0.05042093f, -0.04527967f, 0.01370779f, -0.02254366f, 
    -0.04492028f, 0.03657409f, 0.02617579f, -0.01382164f, -0.04776947f, -0.02590025f, 0.01026742f, -0.03149635f, 
    -0.02489163f, -0.02609370f, -0.01337420f, -0.02215904f, 0.00778961f, 0.01315830f, -0.02848274f, 0.00254047f, 
    0.04513741f, -0.04200698f, 0.01507508f, 0.03767706f, 0.02286685f, 0.02566967f, -0.04536016f, -0.01368800f, 
    0.02367960f, 0.04463562f, -0.00212106f, -0.01101802f, -0.01898000f, 0.02532142f, 0.01059849f, -0.00317479f, 
    0.03475543f, 0.04887919f, 0.00771363f, 0.01354626f, -0.04406601f, 0.00755439f, -0.00260795f, -0.04984283f, 
    0.03689236f, -0.02430850f, 0.01433143f, 0.03303690f, -0.05234320f, 0.03769693f, 0.01096492f, -0.02374352f, 
    -0.03820039f, 0.05081869f, -0.02864784f, 0.00653136f, -0.04638864f, 0.02205825f, -0.05049689f, -0.01262087f, 
    0.00347452f, -0.05855105f, 0.00415578f, 0.01275300f, -0.05183165f, -0.01526304f, -0.01112552f, -0.03784740f, 
    0.05194199f, 0.01696784f, 0.04292012f, 0.01339242f, -0.04847918f, -0.01754564f, 0.03645485f, -0.00229548f, 
    -0.02541530f, 0.05248324f, 0.04589581f, -0.02833609f, 0.02483566f, -0.00304233f, -0.02887180f, 0.04364022f, 
    -0.03506417f, -0.02582023f, 0.01610497f, 0.00615290f, 0.02200319f, -0.04959575f, -0.05106113f, 0.03818204f, 
    0.19846898f, -0.09553405f, 0.10805313f, -0.13969345f, -0.08206571f, 0.15205333f, 0.06557538f, 0.03403141f, 
    -0.06322533f, 0.17455585f, 0.10291868f, 0.10266966f, -0.24078597f, -0.03090171f, 0.11753466f, -0.06558187f, 
    0.04032116f, -0.05410649f, 0.23214467f, 0.11386263f, -0.59138751f, -0.12783766f, -0.08253736f, -0.00472510f, 
    0.14706098f, 0.01593062f, -0.10900759f, 0.34908539f, -0.01789453f, 0.10603309f, -0.25512311f, -0.23074146f, 
    -0.02280148f, 0.08961827f, -0.05695443f, -0.05463500f, 0.22051615f, 0.33443230f, 0.33049458f, -0.12535350f, 
    0.05485164f, -0.16273841f, 0.07260384f, 0.08537285f, 0.07475579f, 0.14059995f, -0.24429677f, -0.40957785f, 
    0.11329103f, -0.16581564f, 0.11866035f, -0.10137376f, -0.00447656f, -0.10623004f, 0.15350159f, -0.26295930f, 
    0.09277691f, -0.00159096f, -0.00270101f, 0.11351340f, 0.14122932f, 0.06225079f, 0.05252364f, -1.08471096f, 
    -0.42055070f, 0.01751293f, -0.13757238f, -0.08059184f, 0.08375773f, 0.22540818f, 0.07279424f, 0.04346910f, 
    0.47123459f, 0.25664032f, 0.14112343f, -0.20446613f, 0.14907715f, -0.06291871f, 0.14345287f, 0.04033203f, 
    0.11375055f, 0.10117716f, 0.24081385f, 0.07115522f, -0.01667404f, -0.05661518f, 0.05259949f, 0.01767672f, 
    0.08674461f, 0.00002053f, -0.18799010f, 0.35624194f, 0.14960118f, -0.01974782f, -0.05119544f, 0.00652235f, 
    -0.00420970f, -0.07870538f, 0.08833484f, 0.11181959f, -0.00701314f, 0.18263543f, -0.06332432f, 0.02421050f, 
    -0.05054512f, 0.09110005f, -0.14443360f, 0.36591971f, -0.30862030f, -0.28165251f, -0.23796123f, -0.14781503f, 
    0.20432718f, 0.02067532f, 0.10953489f, 0.04529912f, 0.00565264f, 0.04808415f, -0.37244806f, -0.15815112f, 
    -0.13936031f, -0.12446041f, 0.08240713f, -0.04859003f, 0.06006020f, 0.01610443f, 0.02900331f, 0.25983730f, 
    0.20791720f, -0.01259588f, 0.10515565f, -0.03118776f, 0.01333694f, -0.09296999f, 0.08508618f, 0.14253704f, 
    0.28747523f, 0.06655616f, -0.12409568f, -0.05818323f, -0.00698865f, 0.21076129f, 0.15420628f, 0.09244555f, 
    0.24575722f, -0.06566281f, -0.12626606f, -0.03634067f, -0.04393758f, 0.15442397f, -0.04102375f, -0.05810241f, 
    -0.02539679f, 0.02612232f, -0.03216728f, -0.02107170f, -0.07614050f, 0.15336606f, -0.10718108f, -0.03967408f, 
    0.00735137f, 0.06529060f, -0.22795886f, -0.42277423f, -0.51651520f, -0.14542779f, -0.06240455f, 0.18625094f, 
    0.00353898f, 0.04170836f, -0.08135365f, 0.03798631f, -0.20203796f, 0.00172293f, -0.13126905f, -0.39757103f, 
    0.13531311f, 0.12424471f, 0.15334485f, 0.20242104f, -0.41106552f, -0.33819270f, -0.14579676f, -0.12242952f, 
    0.00999027f, -0.30425909f, -0.02988303f, 0.02332427f, 0.08853895f, 0.09630503f, -0.14804542f, -0.17073467f, 
    -0.11258722f, 0.02839218f, -0.06490172f, -0.05283177f, 0.07272211f, -0.09549248f, -0.46247724f, -0.17894451f, 
    -0.28618786f, -0.12756695f, 0.05458954f, 0.15870756f, 0.13124332f, 0.06374247f, 0.08503427f, 0.05680163f, 
    0.03383944f, 0.12222783f, 0.00069866f, 0.10623800f, -0.03952133f, 0.00065578f, -0.05165544f, -0.08376452f, 
    -0.08113457f, 0.11388454f, 0.07165266f, -0.05065060f, -0.02378549f, -0.05729904f, 0.01513059f, -0.06927810f, 
    0.10794068f, -0.39788687f, 0.26558593f, -0.13501163f, -0.13578176f, -0.01625703f, -0.03534747f, -0.00717551f, 
    0.01190039f, -0.01256127f, -0.61984611f, -0.44773328f, 0.01157395f, -0.06822783f, -0.04037482f, -0.05020346f, 
    0.11863535f, 0.04512271f, 0.07380217f, -0.00042556f, -0.78137726f, -0.03432236f, -0.01359797f, 0.20047028f, 
    -0.02170431f, -0.10370600f, -0.00415156f, -0.05766005f, 0.34532386f, -0.16373767f, -0.11824126f, -0.22194976f, 
    -0.02245514f, 0.02737109f, 0.15382330f, 0.03036587f, 0.13634232f, 0.36270732f, 0.04315066f, -0.07004842f, 
    -0.01283882f, -0.13375263f, -0.01363606f, 0.17829326f, -0.02928967f, 0.15003373f, 0.14081711f, -0.01502030f, 
    0.14840573f, -0.06393886f, -0.04717255f, 0.00436070f, 0.16053209f, 0.03171099f, 0.11954790f, 0.05486470f, 
    -0.20992742f, -0.40889588f, 0.01339149f, -0.02471473f, -0.12829365f, 0.18400621f, 0.12635717f, -0.04754392f, 
    0.05165320f, 0.04970972f, 0.04844815f, -0.02647446f, 0.00682254f, -0.05146063f, -0.02534400f, -0.02914011f, 
    -0.04034111f, -0.00193617f, 0.04711450f, -0.02873306f, -0.01571151f, -0.01090723f, -0.05823774f, 0.01878681f, 
    -0.00151622f, 0.04650883f, 0.00543333f, 0.03440317f, 0.03065442f, 0.03014202f, 0.01794071f, -0.01134129f, 
    0.02871494f, 0.03803112f, -0.02820474f, 0.04389517f, -0.00228361f, -0.00214637f, -0.01348271f, -0.01977436f, 
    -0.01063540f, 0.02668706f, -0.03699461f, -0.03789217f, -0.03078031f, 0.02218254f, -0.00337018f, 0.03046032f, 
    0.05134626f, 0.03763217f, 0.03736348f, -0.05412954f, 0.02842700f, -0.03694380f, -0.02411515f, -0.03063007f, 
    -0.04022513f, 0.00946495f, -0.02983740f, 0.03760794f, -0.01209982f, -0.03351118f, -0.00828815f, -0.05618874f, 
    -0.02804421f, -0.01857268f, 0.03621317f, -0.05746210f, -0.02558219f, 0.04155017f, 0.04848449f, 0.04563904f, 
    -0.00042848f, -0.03878409f, -0.02607467f, 0.01308106f, -0.00258418f, 0.01838672f, 0.00477759f, 0.04161160f, 
    -0.06447034f, -0.01834234f, 0.02400150f, -0.05507225f, -0.03811273f, -0.02113815f, 0.05137250f, 0.00953658f, 
    -0.00250047f, -0.03678640f, -0.00817904f, -0.03658952f, -0.03501385f, -0.05059158f, 0.04580451f, -0.05274903f, 
    -0.00324194f, -0.03321574f, 0.01683645f, -0.01393545f, -0.05411123f, -0.01703781f, 0.04899128f, 0.03141651f, 
    -0.01701369f, -0.03196022f, -0.01016058f, -0.05075784f, 0.01813205f, -0.03817387f, -0.01625841f, -0.03370060f, 
    -0.05410133f, -0.02667699f, -0.06100540f, -0.01326552f, -0.02436058f, 0.03849706f, -0.01217841f, 0.03988231f, 
    0.04305862f, 0.03548791f, -0.02912817f, -0.05208591f, 0.04006547f, -0.05567440f, -0.01043750f, -0.00959831f, 
    0.03012633f, 0.02770230f, -0.01529974f, -0.00344955f, 0.00154243f, -0.06203663f, 0.00826895f, -0.04214947f, 
    -0.05475610f, 0.03715537f, -0.00089456f, 0.01506822f, -0.01679263f, 0.02023081f, 0.04941069f, -0.05285154f, 
    -0.06277674f, 0.04833226f, -0.00300721f, 0.04726623f, -0.03018887f, -0.04665872f, -0.02470474f, -0.00819217f, 
    0.02542266f, 0.02268492f, -0.05662553f, 0.02369234f, -0.03029216f, -0.03098336f, 0.04509917f, 0.03484798f, 
    -0.02818487f, -0.01093438f, -0.00020020f, -0.02103752f, 0.00784411f, -0.04376761f, -0.00687025f, 0.01638497f, 
    0.03053274f, 0.01735065f, 0.01913868f, -0.01225698f, -0.00701861f, 0.00306174f, 0.00312426f, 0.00282181f, 
    -0.02947673f, -0.05175234f, -0.03776327f, -0.01744981f, -0.02127196f, 0.03374497f, -0.05108839f, -0.04212955f, 
    -0.02731878f, 0.01232967f, -0.01635207f, 0.03240505f, 0.04012344f, -0.05977869f, -0.03252416f, 0.03034344f, 
    -0.01791680f, 0.00272523f, -0.05488772f, -0.03855858f, -0.05348756f, -0.01566070f, -0.06347014f, 0.02002532f, 
    -0.02375654f, 0.00678095f, -0.00832156f, -0.03958185f, 0.03890372f, -0.02274960f, -0.02156323f, 0.01750603f, 
    -0.04455969f, -0.03315676f, 0.01993281f, -0.01974534f, -0.03676734f, 0.03735493f, -0.03601372f, -0.02262429f, 
    -0.00667772f, -0.05514015f, -0.05508902f, -0.01008845f, -0.06416176f, 0.02627036f, 0.03059288f, -0.03726522f, 
    -0.01883245f, 0.04156954f, 0.03105063f, 0.05153519f, -0.01390127f, -0.02757733f, -0.03941354f, 0.00160855f, 
    -0.05095986f, 0.04622109f, -0.03441184f, 0.01994998f, 0.01278648f, -0.02605514f, 0.03515381f, -0.00426330f, 
    0.01704244f, -0.00032360f, -0.04067378f, 0.04520465f, -0.01412192f, 0.01225345f, 0.05066955f, -0.00551129f, 
    -0.05656210f, -0.01335354f, 0.00250999f, -0.02876023f, -0.02198976f, 0.00812323f, 0.01212944f, -0.05208683f, 
    -0.02113700f, -0.01656210f, 0.03570907f, 0.01493288f, -0.02458914f, -0.01640078f, 0.05241507f, -0.00219820f, 
    0.04348647f, -0.05567766f, 0.03137594f, 0.03872837f, 0.03587934f, 0.03611741f, -0.04855347f, -0.00956030f, 
    0.01958718f, 0.00047244f, -0.02132049f, 0.03428891f, -0.03492782f, -0.05174769f, 0.00041289f, 0.02408622f, 
    0.01855924f, 0.02314164f, 0.02656510f, -0.00693933f, -0.00228061f, -0.04070530f, -0.05946353f, 0.01660486f, 
    0.00043283f, 0.01850895f, -0.02840315f, -0.05535127f, -0.05943201f, -0.05886256f, -0.05777230f, -0.02186131f, 
    0.16908492f, 0.06959125f, -0.24673744f, 0.12214524f, -0.03123837f, -0.00990617f, -0.05108116f, 0.02046490f, 
    0.23236926f, -0.09282608f, -0.02731063f, -0.17772503f, -0.07568150f, -0.07973035f, -0.04426382f, 0.08839647f, 
    0.01185583f, 0.06738798f, -0.06974183f, -0.11713382f, 0.05557522f, -0.03897068f, -0.21353371f, 0.11393552f, 
    -0.05404121f, 0.24874684f, -0.05984795f, -0.10932144f, 0.07712004f, 0.07704014f, -0.02679722f, 0.17284450f, 
    0.09480887f, -0.02413309f, -0.12856206f, 0.10928803f, -0.17398755f, -0.25698528f, -0.18315701f, 0.06908159f, 
    0.28081420f, 0.05856518f, 0.13115595f, -0.15505143f, -0.25355351f, 0.17666909f, -0.00291718f, 0.02634139f, 
    -0.09223378f, 0.16821535f, -0.00388862f, 0.06384717f, 0.10142399f, -0.00823898f, -0.01028705f, 0.08593619f, 
    -0.18873465f, 0.09008429f, 0.04745687f, 0.11365546f, -0.00307821f, -0.00520034f, 0.17960784f, 0.15596493f, 
    0.13914530f, 0.14417511f, -0.11465515f, 0.19544213f, 0.18186624f, -0.00071919f, -0.13060431f, 0.04441314f, 
    0.30606070f, -0.01255815f, -0.18929836f, -0.19533397f, 0.04343055f, -0.12136418f, -0.12531474f, 0.04059215f, 
    -0.02357247f, 0.04537014f, -0.01941463f, 0.02502753f, -0.05610994f, -0.03456272f, -0.13354935f, 0.00055940f, 
    0.04779119f, 0.06815114f, -0.00731461f, -0.04082566f, -0.15524425f, -0.13391386f, -0.21781635f, -0.06848492f, 
    0.00363080f, -0.10368672f, 0.10503941f, -0.10644846f, -0.17087828f, -0.12919109f, -0.02241243f, -0.17138626f, 
    -0.01044072f, -0.23868512f, 0.21718290f, 0.15962234f, 0.14667742f, -0.07791466f, 0.20745285f, -0.13651684f, 
    0.28793597f, 0.05863849f, 0.15459208f, 0.09254126f, -0.03283438f, -0.15026274f, 0.08902417f, 0.02331331f, 
    0.02732292f, 0.04325725f, 0.13659443f, 0.00803608f, -0.14194633f, 0.06051597f, 0.01265168f, -0.03549378f, 
    0.26673204f, -0.00282019f, 0.09323534f, -0.19482803f, -0.10809119f, -0.00156644f, 0.05976127f, -0.04538216f, 
    -0.20995654f, -0.23271269f, 0.02219373f, 0.22651166f, -0.00558413f, -0.01746768f, -0.08175024f, -0.24051195f, 
    -0.12229139f, 0.06410613f, 0.17657477f, -0.10358340f, 0.15339224f, -0.06257445f, -0.12898819f, -0.21442038f, 
    0.06890953f, 0.11495870f, -0.15518555f, 0.00533773f, 0.14047603f, -0.10599726f, 0.00350461f, -0.06164448f, 
    0.08049735f, -0.04655664f, -0.05026887f, 0.20388620f, -0.01392627f, -0.21532945f, 0.11879436f, 0.09590068f, 
    0.10653653f, 0.08831061f, -0.24537984f, -0.05004536f, 0.04956136f, 0.00009872f, -0.06615850f, 0.08107270f, 
    -0.08261944f, -0.23581749f, -0.21513787f, 0.16338697f, 0.01122743f, -0.01516335f, 0.23082277f, 0.06645657f, 
    0.00920706f, -0.01852125f, 0.16626266f, 0.12134247f, 0.03032573f, 0.18024193f, -0.09381895f, 0.06986597f, 
    -0.02712213f, 0.04525138f, 0.06781266f, -0.00157701f, 0.13071902f, -0.01147990f, -0.12607588f, -0.10319529f, 
    -0.01028506f, -0.06514428f, 0.06740364f, 0.01934407f, 0.08190314f, 0.18864806f, -0.01397043f, 0.19938369f, 
    0.05822191f, 0.04441248f, 0.12574083f, 0.00121355f, -0.19214645f, -0.02850241f, 0.01512436f, -0.09667465f, 
    0.17882921f, 0.04385272f, 0.00831177f, -0.09871919f, -0.31426892f, -0.08636604f, 0.17102399f, 0.02600878f, 
    0.08844227f, -0.25034559f, -0.09500129f, 0.05095472f, -0.19953923f, 0.02160887f, -0.14402327f, 0.14406443f, 
    0.17689450f, -0.11031990f, -0.13925678f, -0.23880512f, 0.00318322f, -0.07784534f, 0.15586750f, 0.04825677f, 
    -0.01346740f, 0.07368217f, 0.29427496f, 0.14093231f, -0.14501780f, -0.11682844f, -0.21178401f, 0.03185032f, 
    0.08140559f, 0.11338199f, 0.04347611f, 0.06437848f, 0.07695659f, 0.04833197f, 0.01161471f, -0.06293023f, 
    0.10061337f, 0.08840735f, -0.09394593f, -0.48975667f, -0.03308430f, -0.34239569f, -0.04242068f, 0.11540100f, 
    -0.14930898f, -0.04486704f, 0.05339118f, -0.04319087f, 0.01725378f, -0.12005767f, -0.02204540f, -0.20434587f, 
    -0.14915769f, -0.03267897f, 0.13566734f, 0.05758644f, -0.10709643f, 0.05156732f, 0.20059614f, -0.10594793f, 
    -0.09120975f, -0.06479705f, 0.07321811f, 0.16868189f, -0.02856453f, -0.03312807f, -0.09973108f, -0.09414755f, 
    -0.07883915f, -0.03739394f, 0.17015280f, -0.06036530f, 0.00567645f, 0.10310182f, 0.00398260f, -0.05324633f, 
    -0.00284485f, -0.17470457f, -0.21832180f, 0.06959625f, 0.08341580f, 0.01287451f, 0.06724773f, 0.01980222f, 
    0.05293585f, 0.04694351f, -0.02832368f, 0.50315040f, -0.57463050f, -0.09335133f, 0.18040760f, 0.08434542f, 
    -0.06331100f, -0.06807251f, -0.18550061f, 0.24820614f, 0.01391300f, -0.10769409f, -0.15918751f, -0.05669810f, 
    0.08337890f, 0.10093693f, 0.16923262f, 0.05299015f, -0.50550801f, -0.03070477f, 0.10065461f, 0.05650897f, 
    -0.11782654f, -0.21720150f, -0.04419359f, -0.04267851f, 0.04373955f, 0.00940756f, -0.01156807f, 0.07074451f, 
    -0.11588997f, 0.10939147f, -0.14726049f, 0.02268798f, 0.01993013f, 0.04246519f, -0.36061081f, -0.14513433f, 
    0.23509789f, -0.13757019f, -0.04764840f, 0.17244077f, -0.06653849f, -0.05278398f, -0.00988401f, -0.02930553f, 
    -0.03461464f, 0.20164900f, -0.04600179f, 0.00488464f, -0.14577661f, -0.09903191f, 0.10067701f, 0.01427545f, 
    -0.40228811f, -0.27826259f, -0.09458440f, -0.03865383f, -0.30448270f, -0.24871431f, -0.06787480f, -0.19920391f, 
    0.01944136f, 0.01022247f, 0.24601774f, -0.10464401f, 0.05544788f, -0.00157929f, 0.00359885f, 0.02242973f, 
    0.04496431f, -0.00815907f, -0.15646054f, -0.66157979f, -0.10751232f, -0.18833207f, -0.03982599f, -0.18903801f, 
    0.03079494f, -0.15158506f, 0.12571046f, -0.59886062f, -0.02504813f, -0.09333694f, -0.02399179f, 0.03163337f, 
    0.05334155f, -0.07259523f, 0.10597944f, 0.12663893f, -0.02611078f, -0.27214834f, 0.00633437f, -0.03425831f, 
    0.17326531f, 0.01364042f, 0.00789667f, -0.02813663f, -0.11500890f, 0.00340418f, 0.22456340f, 0.13710478f, 
    -0.02223575f, -0.20646039f, -0.03730202f, 0.03006200f, 0.06414865f, 0.05703277f, -0.01020256f, 0.23432417f, 
    0.14433342f, -0.09705705f, 0.03913831f, -0.01739319f, 0.04595539f, -0.01831160f, 0.02790404f, -0.14755590f, 
    0.07033870f, -0.13515335f, -0.00477324f, -0.04555274f, -0.06618272f, 0.11844264f, 0.05381988f, -0.07663938f, 
    -0.12257394f, 0.48424685f, 0.50513709f, -0.00583814f, 0.05964730f, -0.08871195f, -0.12035497f, 0.02121846f, 
    0.13552789f, -0.21093027f, -0.12321939f, 0.11055993f, 0.12440091f, -0.07141919f, -0.04712543f, 0.13159686f, 
    -0.01568420f, 0.05931373f, 0.16795532f, 0.17501155f, 0.11636627f, 0.13731647f, -0.00493596f, -0.04325664f, 
    0.12789354f, 0.11041169f, 0.10148824f, -0.08214321f, -0.02665186f, -0.05165270f, -0.25899738f, -0.37747627f, 
    -0.27123255f, -0.01237879f, -0.08248683f, 0.13536657f, 0.13535245f, -0.13267252f, -0.14010155f, 0.02608677f, 
    -0.12513490f, -0.03910638f, 0.23564346f, 0.07001036f, 0.12195402f, 0.00793767f, -0.09207579f, 0.13969539f, 
    0.02951569f, 0.01408892f, -0.12168280f, 0.08071402f, -0.09709579f, -0.07312147f, 0.00409273f, 0.04969347f, 
    0.02575260f, 0.02379715f, -0.03074493f, 0.04905312f, -0.01579465f, -0.07936989f, 0.02601374f, -0.21391037f, 
    -0.09883533f, 0.05096541f, -0.13482301f, -0.02783371f, -0.02407169f, 0.02947258f, -0.02822157f, 0.04661449f, 
    0.02505644f, -0.23760566f, 0.14252540f, -0.01144640f, 0.04428311f, 0.04710042f, 0.06664551f, -0.05015806f, 
    0.12939404f, -0.14847378f, -0.24466595f, 0.01182750f, 0.08881150f, 0.06309348f, -0.13747916f, 0.14118670f, 
    0.09059794f, -0.03464346f, -0.03709114f, -0.11498679f, -0.08611868f, -0.07512684f, -0.06332571f, 0.05717348f, 
    -0.16039720f, 0.03852249f, 0.09219876f, -0.14871405f, -0.32135209f, -0.06886441f, -0.08913439f, 0.01170380f, 
    0.00440926f, -0.15482104f, -0.02429811f, -0.20633465f, 0.07953253f, 0.25343236f, 0.17647201f, -0.20244333f, 
    -0.43895435f, -0.15469328f, 0.03961345f, 0.02356518f, 0.05441261f, 0.01143409f, 0.06776746f, -0.10600495f, 
    -0.21822788f, -0.11204930f, 0.03558049f, -0.02635698f, 0.26149341f, 0.32244870f, -0.29458603f, 0.10065752f, 
    0.25692853f, -0.00778559f, -0.02910035f, 0.18716462f, -0.00348775f, 0.21612142f, 0.07441854f, 0.23187636f, 
    -0.23723893f, -0.21023405f, 0.09030093f, 0.00509329f, 0.05353334f, -0.06184259f, -0.06138821f, -0.03869065f, 
    -0.00217467f, -0.02764362f, 0.05006355f, 0.01323157f, 0.03216111f, 0.04238454f, -0.05096864f, -0.02368790f, 
    -0.02701479f, -0.04103680f, -0.02870752f, -0.02114468f, -0.02166558f, 0.00741666f, 0.04840857f, -0.05693851f, 
    -0.02300389f, 0.04460059f, -0.00867374f, -0.03621421f, 0.02502086f, -0.04348548f, -0.05154324f, 0.03068575f, 
    -0.05615563f, -0.02151345f, 0.02846353f, -0.01512820f, -0.02811406f, -0.03053421f, -0.02341709f, -0.06377681f, 
    0.01456668f, 0.02260704f, -0.05584734f, -0.01027099f, -0.02987660f, -0.06610428f, -0.02395568f, -0.03888299f, 
    -0.05642474f, -0.02818886f, 0.00129145f, 0.02858938f, -0.04026849f, 0.04591296f, -0.04881854f, 0.03252055f, 
    -0.05365067f, -0.03601197f, -0.03986824f, -0.00398585f, -0.05408229f, 0.03327110f, 0.02349231f, -0.00144747f, 
    0.00870594f, 0.01582749f, -0.00548940f, -0.02908283f, -0.04445535f, 0.01581745f, 0.02593004f, 0.01221144f, 
    -0.02784376f, -0.04400508f, -0.00401363f, 0.00140046f, 0.03836079f, -0.02385984f, 0.04615729f, 0.02185726f, 
    -0.03365423f, 0.00738090f, 0.01432979f, 0.03402551f, -0.01382640f, 0.02299469f, 0.00382806f, -0.00999757f, 
    -0.03125910f, -0.05336021f, 0.03717486f, -0.04001445f, 0.01573267f, 0.03849754f, -0.05133634f, -0.05507699f, 
    -0.01847834f, -0.01923764f, 0.04480683f, -0.04851779f, -0.03646841f, -0.02301549f, 0.02377440f, 0.02098785f, 
    0.03812929f, -0.04632233f, 0.00984146f, -0.06092102f, -0.02115730f, 0.02048300f, 0.03703752f, 0.05192701f, 
    -0.02934222f, 0.03884539f, -0.01841347f, -0.06476592f, -0.02796322f, -0.05374057f, -0.00902773f, 0.04872503f, 
    0.00044059f, 0.03155520f, -0.01883802f, -0.03027878f, -0.06295519f, 0.01182069f, 0.02718006f, -0.01857653f, 
    0.04529493f, -0.05598949f, 0.02498021f, -0.02725646f, -0.03757270f, -0.05821818f, 0.01366595f, -0.05638614f, 
    0.01285655f, 0.00003879f, 0.01046250f, -0.02778165f, 0.04650570f, 0.00088245f, -0.00141406f, 0.01771736f, 
    0.01576873f, 0.00705704f, 0.04590790f, 0.00399669f, -0.04269515f, -0.01283932f, 0.02281087f, -0.02115290f, 
    -0.02198769f, -0.04493205f, -0.06419213f, -0.01954852f, -0.00210528f, -0.03499406f, 0.03666573f, 0.03499209f, 
    0.03316875f, -0.03944826f, -0.05911606f, -0.00103098f, -0.05264203f, -0.02294082f, -0.03131819f, 0.02514748f, 
    0.04665465f, -0.04564665f, -0.06096363f, 0.02421705f, -0.03262632f, 0.00101708f, 0.02982942f, 0.03256623f, 
    -0.06681979f, -0.05293756f, -0.00375708f, 0.03268434f, -0.01996689f, 0.03592328f, 0.03413479f, -0.05991724f, 
    -0.02163930f, -0.01820064f, -0.05487033f, -0.05759068f, 0.00279392f, -0.04754189f, -0.01023508f, 0.01821318f, 
    -0.05369451f, -0.05526632f, 0.05122504f, 0.03187918f, -0.01990431f, 0.00425538f, -0.02078529f, 0.00394517f, 
    -0.05422432f, -0.05631659f, -0.02992599f, -0.00086992f, -0.05072037f, 0.03228629f, 0.04702899f, 0.00680251f, 
    0.04269990f, 0.02869547f, -0.03395715f, -0.03395095f, 0.02667630f, 0.04735112f, -0.04008786f, 0.01260976f, 
    -0.06642470f, -0.05350211f, -0.00534907f, 0.01719804f, -0.01244606f, 0.04257635f, 0.00336771f, 0.00024104f, 
    -0.00663580f, -0.03886080f, -0.01514421f, 0.00547692f, 0.00999692f, 0.04464775f, 0.03759233f, -0.03508078f, 
    0.01108033f, -0.03546122f, -0.02342970f, -0.02739912f, 0.00464207f, 0.03454336f, 0.04986383f, 0.02266501f, 
    0.00928909f, 0.02143117f, 0.00010033f, 0.00683743f, 0.02559463f, -0.03841504f, 0.04282052f, 0.03619040f, 
    -0.05082440f, -0.05597915f, 0.03073378f, 0.02250693f, -0.01026620f, -0.03826012f, 0.02990277f, 0.03671251f, 
    0.04207714f, 0.04322007f, -0.03549772f, 0.02085889f, -0.00874456f, -0.05670857f, -0.01784160f, -0.06391231f, 
    -0.04451000f, -0.05616452f, -0.03821977f, 0.00266315f, 0.05042739f, -0.04828707f, 0.02725418f, -0.03553768f, 
    -0.06716616f, -0.00059503f, 0.04564316f, -0.04630104f, -0.05093592f, 0.00150781f, 0.01382474f, -0.00816226f, 
    0.00416965f, 0.02572716f, -0.06238980f, -0.02768598f, 0.04310793f, 0.03386408f, -0.04507145f, -0.04099387f, 
    -0.06515178f, -0.02964083f, 0.04040532f, 0.01766521f, 0.01748396f, -0.05996052f, -0.03804061f, -0.04311504f, 
    0.01032415f, 0.05584086f, 0.00861698f, -0.05376330f, -0.06196061f, -0.02431307f, 0.03614702f, 0.01540574f, 
    0.01830659f, -0.06899980f, 0.00842461f, -0.04911635f, -0.04243009f, -0.01457563f, 0.01330157f, -0.01644151f, 
    0.02239393f, 0.02470826f, -0.02048051f, 0.01964569f, -0.03393361f, 0.00363941f, -0.01098806f, -0.05643820f, 
    0.03424099f, -0.02017835f, 0.00999514f, -0.06110457f, -0.05427169f, -0.03246181f, -0.02359615f, 0.00071724f, 
    0.04046948f, 0.02522645f, 0.00662944f, -0.05811240f, 0.01009057f, 0.05465509f, -0.04798760f, 0.04844628f, 
    -0.02110896f, -0.03805256f, 0.00081491f, 0.00050227f, -0.02699459f, 0.04194390f, 0.00705958f, -0.02493792f, 
    0.01026171f, -0.03722420f, -0.05350337f, 0.02711953f, 0.02871658f, -0.03647394f, -0.01018433f, 0.00210924f, 
    0.02983196f, 0.01078572f, 0.02816104f, -0.00179699f, 0.01729932f, -0.03121905f, -0.06431312f, -0.00618588f, 
    0.03207598f, -0.03127723f, -0.00088407f, 0.01064407f, 0.00815765f, -0.01247683f, -0.01596689f, -0.01724280f, 
    -0.05043823f, 0.02720243f, -0.00157004f, 0.01422353f, 0.04019134f, -0.00049907f, -0.01232660f, -0.03714611f, 
    0.05347065f, -0.00381391f, -0.05560377f, 0.05974101f, -0.04516843f, -0.06054474f, 0.00326002f, -0.01011314f, 
    -0.02601564f, -0.02038947f, 0.02496756f, -0.04784944f, -0.00373420f, -0.01832982f, -0.03821881f, 0.01420820f, 
    0.00315788f, -0.05249489f, 0.00092472f, -0.00128650f, -0.02785366f, -0.04070354f, 0.02919169f, -0.01951287f, 
    0.00822159f, -0.04413236f, 0.01767282f, -0.03957013f, 0.04428527f, 0.00460911f, -0.01683975f, 0.00581319f, 
    -0.03190474f, -0.04629550f, 0.01156374f, 0.02564288f, 0.02884823f, 0.02824621f, -0.00416359f, -0.04086528f, 
    -0.05742469f, -0.05684482f, -0.04501030f, 0.02599891f, -0.02444581f, -0.02482835f, 0.03089724f, -0.02078473f, 
    -0.01154212f, -0.02806508f, 0.02911871f, 0.03391680f, 0.01777253f, -0.03107681f, -0.01229286f, 0.00439022f, 
    0.00417847f, 0.00421701f, 0.04026596f, 0.02151359f, -0.04870287f, 0.01703033f, 0.01419552f, -0.02675030f, 
    -0.02028177f, -0.03902987f, 0.02438199f, -0.00379789f, 0.00294154f, 0.02036766f, -0.01812768f, -0.05017902f, 
    0.00816027f, 0.00851843f, -0.06220549f, 0.05034167f, 0.00445814f, 0.04924082f, 0.04374874f, -0.04820109f, 
    0.03829458f, -0.01819386f, 0.00282321f, 0.00098643f, -0.00346430f, -0.04493566f, -0.06281629f, -0.03657522f, 
    -0.04153422f, -0.03562804f, -0.05984580f, 0.00458673f, 0.01090688f, -0.04648371f, -0.03477831f, -0.02021182f, 
    -0.02713730f, 0.01487110f, 0.01433703f, -0.00166682f, -0.04718452f, -0.00579383f, -0.04103409f, -0.01932685f, 
    -0.04748332f, -0.04146054f, -0.00964087f, -0.05428910f, -0.02796329f, 0.02054154f, -0.02521679f, -0.04875294f, 
    -0.04478182f, 0.02335062f, 0.00934598f, 0.01346713f, -0.06689686f, 0.03441253f, 0.05667280f, 0.03795195f, 
    -0.02241625f, -0.00000489f, 0.05227802f, -0.02234931f, -0.01679313f, -0.01569744f, 0.02731710f, -0.02744367f, 
    -0.03508160f, 0.00698326f, -0.03778071f, -0.00867825f, -0.01038856f, 0.03417127f, -0.05250071f, -0.01714451f, 
    -0.06362840f, -0.02633019f, -0.04519448f, 0.00298755f, 0.00316154f, -0.03832364f, 0.04138770f, -0.02463373f, 
    -0.03949393f, -0.01215416f, -0.00627380f, -0.00132971f, 0.03650683f, 0.01976423f, -0.02358602f, 0.04776240f, 
    0.03917758f, -0.04491984f, 0.02534740f, -0.02613931f, 0.02148996f, -0.04546414f, 0.01361882f, -0.03064474f, 
    -0.06169239f, -0.01224421f, 0.04716597f, 0.04386172f, 0.05483469f, -0.00277803f, -0.05269950f, -0.05634369f, 
    -0.00694590f, 0.04956632f, 0.04537142f, 0.02232767f, 0.03167475f, -0.01963926f, 0.01655820f, 0.03259498f, 
    0.01055775f, 0.00627834f, 0.01990801f, 0.03757571f, -0.04752852f, -0.00205753f, -0.01691110f, 0.01494260f, 
    0.03913033f, -0.05374460f, 0.03573939f, 0.02573569f, 0.01505570f, -0.02899761f, -0.04511046f, -0.05454642f, 
    -0.05534986f, -0.01162709f, -0.06514870f, -0.04025896f, -0.04470122f, 0.01462172f, -0.03553482f, 0.03516065f, 
    -0.05214093f, 0.01239186f, -0.04308325f, -0.06360349f, 0.04196923f, -0.05725914f, -0.02912182f, -0.01372714f, 
    -0.48157692f, 0.02317019f, 0.25829411f, 0.02632599f, -0.02236637f, 0.01123556f, 0.15446049f, -0.01278194f, 
    0.11290547f, -0.30810454f, 0.02613206f, 0.38558894f, 0.10808794f, -0.10190846f, 0.06035190f, 0.22758272f, 
    -0.03411898f, 0.07133672f, 0.68328398f, -0.02414521f, -0.03863036f, 0.14814238f, 0.17892143f, -0.15591462f, 
    0.12346639f, -0.38474956f, -0.04763490f, -0.25030982f, -0.08713334f, -0.07404745f, 0.18612419f, -0.12928104f, 
    0.07012677f, 0.12497864f, 0.01274643f, 0.25095037f, 0.03454797f, 0.00671336f, 0.44053811f, -0.00386646f, 
    0.00028516f, 0.04535080f, -0.12227347f, -0.13077675f, -0.10748011f, 0.37534428f, -0.03183386f, -0.20358874f, 
    -0.01340659f, 0.01449996f, -0.06228810f, -0.11038113f, 0.12423456f, -0.08196984f, -0.50007921f, -0.05933886f, 
    0.06347629f, -0.07051702f, -0.04925711f, -0.09333486f, -0.05583794f, 0.00187588f, 0.12198088f, 0.08732889f, 
    -0.05669917f, -0.44155213f, -0.24976306f, -0.10990719f, 0.04858285f, -0.15813796f, 0.10069704f, 0.05312487f, 
    -0.34236211f, 0.00690434f, 0.35897255f, -0.09128992f, -0.07150357f, 0.01575549f, 0.06755961f, -0.12083985f, 
    -0.16934486f, 0.17144237f, 0.04130806f, 0.19573319f, 0.04422386f, 0.26122722f, -0.03940185f, 0.09532212f, 
    -0.07473855f, -0.08139698f, 0.49257299f, -0.04833775f, -0.06224062f, 0.14985594f, -0.09743661f, -0.15984626f, 
    0.05109911f, 0.07217257f, -0.07764734f, -0.27707452f, 0.38342032f, 0.38103762f, -0.03926912f, 0.03424820f, 
    -0.12649345f, 0.28507689f, -0.10090903f, 0.05645423f, 0.10404394f, -0.17367974f, -0.26519492f, -0.13161398f, 
    -0.04803307f, 0.06617018f, -0.05670069f, 0.07192097f, -0.04580127f, -0.14198899f, 0.00965726f, -0.23133439f, 
    0.01290515f, 0.02259344f, 0.00358569f, 0.17676894f, 0.11904500f, 0.04975211f, -0.07549594f, -0.18514268f, 
    0.24953452f, 0.08066024f, 0.02646141f, 0.09837900f, 0.10787214f, -0.07635743f, -0.25028077f, 0.08094122f, 
    0.05060999f, 0.32033193f, 0.08578481f, 0.16160594f, -0.05245082f, -0.08353645f, -0.10142720f, -0.39833596f, 
    -0.08835448f, 0.18925391f, 0.28037620f, 0.00297859f, 0.07495362f, -0.03770031f, 0.03026425f, 0.04680397f, 
    -0.10913341f, 0.15932828f, 0.20273204f, 0.50562167f, 0.00142325f, 0.17962675f, 0.06822612f, 0.05366065f, 
    0.22202024f, 0.50511098f, -0.13463829f, -0.43876043f, -0.03322681f, 0.12241175f, 0.06596635f, -0.15911868f, 
    0.15142286f, -0.03416936f, 0.17107721f, -0.05119781f, 0.01330160f, -0.11791030f, -0.07892998f, -0.08390037f, 
    -0.09512786f, -0.03941823f, -0.02297191f, -0.05267181f, -0.14584269f, -0.05990102f, -0.24328755f, -0.00710755f, 
    0.11734437f, 0.01086284f, -0.00634905f, -0.08442066f, 0.02137674f, 0.16836378f, -0.27198124f, 0.11683092f, 
    0.15943478f, 0.18337595f, -0.07855072f, -0.04233951f, -0.01536585f, -0.16372336f, -0.02351488f, 0.02538778f, 
    -0.22337349f, 0.09167685f, 0.02553480f, -0.03750852f, 0.02591365f, -0.05988804f, 0.11588545f, 0.17731859f, 
    0.15502165f, 0.51917648f, -0.03935657f, 0.11378960f, 0.09915380f, -0.07131632f, -0.08760180f, 0.15123093f, 
    0.22317804f, -0.00484242f, 0.26952592f, -0.06673954f, 0.05313032f, 0.16600350f, 0.16198155f, 0.08367611f, 
    0.00644360f, 0.07042284f, -0.09485842f, 0.34940618f, -0.01549529f, -0.13977727f, -0.11399315f, 0.26172492f, 
    -0.00962785f, -0.12131565f, -0.07441616f, 0.20689909f, -0.07639316f, -0.09397965f, 0.13547438f, 0.08592250f, 
    0.10384893f, -0.06120948f, 0.18264209f, 0.17392546f, -0.06889345f, -0.23580550f, 0.12268238f, 0.00940121f, 
    0.11428399f, -0.19432791f, -0.11306705f, 0.13472202f, 0.00137117f, -0.18028349f, -0.24971136f, -0.15191346f, 
    -0.04553034f, 0.05485553f, -0.02429821f, 0.10435658f, -0.01956435f, -0.14884788f, 0.00771353f, -0.13293353f, 
    -0.03423966f, -0.13486397f, -0.17884219f, 0.34990296f, -0.01382656f, -0.00869233f, -0.39074922f, 0.11687211f, 
    -0.05844989f, -0.06005129f, 0.14543685f, -0.00841963f, 0.13781525f, 0.02522883f, 0.12977438f, 0.12210558f, 
    0.07404048f, 0.01821568f, 0.02228375f, 0.12183084f, 0.15273471f, 0.07759961f, 0.05621014f, -0.19485694f, 
    -0.12609215f, -0.10525271f, 0.02650770f, -0.07760736f, 0.02496192f, 0.03598292f, -0.06335976f, -0.05835508f, 
    -0.10719024f, -0.07151460f, -0.07155296f, 0.14497754f, 0.10877752f, -0.10778748f, -0.05800573f, -0.02484422f, 
    -0.00537398f, -0.19549148f, -0.56378824f, -0.15117069f, -0.13835740f, 0.05171738f, 0.13646309f, -0.09870894f, 
    -0.08385068f, -0.08247977f, -0.16099243f, -0.00737938f, -0.02326880f, 0.01936625f, -0.07219421f, 0.04466990f, 
    0.01148805f, -0.05039367f, -0.08472926f, -0.06631758f, 0.09082751f, 0.22230081f, 0.25251767f, -0.07633737f, 
    -0.06532314f, 0.00556251f, 0.09066433f, 0.03216444f, -0.00455535f, -0.12770161f, -0.22228079f, 0.06635338f, 
    0.09872846f, 0.11837550f, 0.05422249f, -0.07702583f, -0.29134163f, 0.14583160f, 0.09964357f, 0.04246342f, 
    0.09587124f, -0.00749811f, -0.00147675f, -0.17444482f, -0.16463433f, -0.05276186f, -0.09358703f, -0.00419900f, 
    -0.17841826f, 0.21210675f, 0.01739004f, 0.07365781f, -0.11366349f, -0.08670771f, -0.02551971f, -0.18974394f, 
    -0.02985933f, 0.18341304f, 0.11076891f, -0.09135936f, -0.03130327f, 0.09583977f, 0.09687785f, -0.04687250f, 
    -0.10308763f, 0.09629879f, 0.21631549f, 0.01793269f, 0.12775452f, -0.04912874f, 0.07596275f, -0.00634480f, 
    0.06221392f, -0.11174635f, 0.08269994f, 0.03175337f, 0.09864540f, 0.10049340f, 0.11424965f, 0.05719282f, 
    0.06270036f, 0.03340693f, -0.19816726f, -0.04239102f, 0.26872483f, 0.00514468f, 0.00812598f, -0.12889288f, 
    0.08759449f, 0.03993239f, -0.05081836f, 0.05813250f, -0.10374208f, 0.06451623f, -0.00370480f, 0.04335185f, 
    -0.08021150f, 0.02773382f, 0.18789564f, 0.05957944f, 0.22583251f, 0.06204536f, -0.00663817f, 0.00929440f, 
    -0.13674752f, 0.01319176f, -0.09796163f, -0.01921298f, -0.16187038f, 0.10729670f, -0.02049047f, 0.04057126f, 
    -0.00081821f, -0.02308490f, 0.00119341f, -0.03544234f, 0.04204844f, 0.04947918f, -0.00876667f, 0.01059680f, 
    0.08611011f, 0.12678434f, -0.14221545f, 0.02803864f, 0.15360126f, 0.04861768f, 0.13801660f, 0.11193128f, 
    0.30838269f, 0.05763805f, 0.16390820f, -0.01920816f, -0.30692077f, -0.17138322f, 0.07024410f, 0.11148398f, 
    -0.00433498f, 0.10102651f, 0.16187894f, 0.01614647f, 0.00093998f, 0.15185884f, 0.13272150f, 0.03155833f, 
    -0.10966848f, -0.04385352f, -0.21366695f, -0.24970895f, 0.11303730f, 0.05702126f, -0.15009870f, 0.13334958f, 
    -0.20094848f, -0.16148643f, -0.32010081f, 0.19388996f, 0.03452879f, 0.04443435f, -0.12000822f, -0.22644065f, 
    -0.16986910f, 0.08066761f, 0.24438067f, -0.01402773f, 0.04508589f, -0.07202559f, 0.18715239f, -0.27647677f, 
    0.05138448f, 0.07285753f, 0.17599015f, -0.11424632f, -0.02219795f, 0.07360081f, -0.19079271f, -0.01360654f, 
    0.09392130f, 0.14033644f, 0.10273719f, -0.17596328f, -0.22453357f, -0.06909365f, 0.01853921f, -0.13120061f, 
    -0.03014814f, -0.01972495f, -0.04542166f, 0.04888505f, 0.17897862f, 0.05958317f, -0.11453248f, 0.10423300f, 
    0.15805593f, 0.06406700f, -0.03548129f, 0.07835811f, 0.08172560f, 0.05188372f, -0.03634041f, -0.05631658f, 
    0.03102373f, -0.05926142f, 0.06885141f, -0.02294106f, 0.04464179f, 0.03031850f, 0.17349078f, 0.11563825f, 
    -0.06451949f, -0.23140737f, -0.11186946f, -0.14438938f, 0.09614445f, 0.14017083f, -0.01191333f, -0.04551743f, 
    -0.07707200f, -0.17170201f, 0.19661792f, 0.05031969f, 0.27660087f, 0.04363883f, 0.15836488f, -0.19121374f, 
    -0.08161288f, 0.10900260f, -0.18243195f, -0.18488503f, 0.03781343f, 0.13243780f, 0.15310960f, 0.18348692f, 
    0.10713254f, 0.07000957f, 0.16868836f, -0.08192063f, 0.19365674f, 0.05582153f, 0.06500024f, -0.07116586f, 
    -0.14707549f, -0.14610471f, -0.05797936f, -0.03580789f, -0.09305643f, 0.01389520f, -0.23452303f, -0.06042514f, 
    -0.00779765f, 0.08132025f, 0.12330487f, 0.06473117f, -0.03040396f, -0.22937363f, -0.10690640f, 0.05602239f, 
    0.11651185f, -0.18941304f, 0.04850343f, 0.05555236f, -0.29619640f, -0.25494730f, -0.06195035f, 0.15454136f, 
    0.02983505f, 0.18214293f, 0.02799118f, 0.05408453f, 0.02979875f, 0.21157198f, 0.29922748f, 0.20976725f, 
    -0.34003532f, -0.17872827f, -0.37298462f, 0.02582665f, -0.07426451f, -0.01488838f, 0.08137179f, 0.00074963f, 
    -0.02305998f, -0.56497568f, -0.09210258f, 0.02672484f, 0.01316810f, -0.02263267f, 0.12451500f, 0.04037729f, 
    -0.02740439f, 0.04868497f, 0.57280946f, -0.22683030f, -0.34757388f, -0.01952531f, 0.25667593f, -0.03128379f, 
    -0.01667052f, -0.03896385f, 0.05644369f, 0.01343559f, 0.05861552f, -0.04029753f, -0.13318501f, 0.08065761f, 
    -0.07253647f, -0.04034087f, -0.10222897f, 0.10998935f, 0.04132076f, 0.10431518f, 0.08781053f, -0.18298870f, 
    0.04115108f, -0.03091525f, -0.01968277f, 0.02398390f, 0.04313110f, 0.37723497f, -0.07998158f, 0.30144274f, 
    -0.07328518f, 0.12446722f, -0.09647010f, 0.00998128f, 0.01504748f, 0.01554793f, -0.41818717f, -0.44414186f, 
    -0.39157620f, 0.02482795f, -0.04635818f, 0.05314916f, -0.00349095f, -0.05783070f, 0.10547587f, -0.06634192f, 
    0.10435292f, -0.09963151f, 0.05056446f, 0.21994597f, -0.22892819f, -0.01363303f, -0.19705819f, -0.22599949f, 
    0.08935349f, 0.37326065f, 0.12858930f, -0.01984645f, 0.13169469f, 0.14229049f, 0.10255657f, -0.01345935f, 
    -0.00658239f, 0.05510759f, -0.32500884f, -0.04363492f, 0.08250162f, 0.10419200f, 0.02892764f, -0.07553315f, 
    0.04719283f, 0.04703319f, 0.31606674f, -0.13986111f, 0.07836471f, 0.02250741f, 0.11050180f, 0.12711048f, 
    0.01448267f, -0.06092124f, 0.08054429f, -0.26172850f, 0.25128004f, -0.17812008f, -0.00954129f, -0.06237915f, 
    0.01814236f, 0.25521389f, 0.00045499f, -0.15129900f, 0.16836959f, 0.00438957f, 0.07512132f, 0.06766149f, 
    0.00254394f, -0.05526828f, 0.00447337f, 0.06236842f, 0.13881841f, 0.00754928f, -0.22476619f, -0.43324152f, 
    -0.15607288f, -0.11957872f, 0.09646381f, 0.12109061f, -0.07367414f, -0.02968011f, 0.22694433f, 0.05155399f, 
    0.23993993f, 0.17954190f, 0.10502620f, -0.09385522f, 0.01373902f, 0.03747299f, -0.02576669f, -0.03272366f, 
    -0.02495988f, 0.14131185f, -0.08556765f, 0.02152390f, -0.00783324f, -0.08413175f, 0.25075662f, 0.10269807f, 
    0.06017293f, -0.12989755f, -0.24748996f, -0.09553815f, -0.03012284f, 0.08587574f, 0.14523552f, 0.07000484f, 
    0.05909013f, -0.02579472f, 0.38823089f, -0.09669632f, -0.14659898f, 0.09264860f, -0.27957240f, 0.18987036f, 
    0.09006602f, -0.00528896f, -0.21939202f, -0.03073061f, 0.07854260f, 0.20843260f, -0.05351903f, 0.10073782f, 
    0.09163372f, -0.08418225f, -0.09137918f, 0.11572324f, -0.26081383f, -0.26745224f, -0.09450556f, 0.05117863f, 
    0.07968317f, 0.07623850f, 0.11919081f, 0.14996222f, 0.00512802f, -0.05089318f, -0.07848569f, -0.01577694f, 
    0.08716216f, -0.15678665f, -0.00975616f, 0.08114636f, -0.00926313f, 0.69483197f, 0.16748668f, 0.28573948f, 
    -0.01449546f, -0.14378798f, 0.03170834f, 0.06387768f, -0.06417819f, 0.11360753f, -0.04973911f, 0.03826456f, 
    -0.13377929f, 0.22206484f, 0.03499498f, 0.02055257f, -0.15386383f, 0.11001589f, -0.05138691f, 0.08981825f, 
    0.03493967f, 0.17206782f, 0.11682416f, 0.07976435f, 0.03167979f, -0.06808499f, 0.04157601f, 0.04623834f, 
    -0.03683831f, 0.11591553f, 0.18819863f, -0.00393170f, -0.04387148f, 0.12986954f, 0.14758629f, -0.04454884f, 
    0.04660752f, -0.21848203f, 0.15899922f, -0.11198920f, -0.05380449f, -0.18544813f, -0.11055145f, 0.18597633f, 
    -0.07053079f, -0.02189299f, -0.09833599f, 0.29994261f, -0.36130002f, 0.04175304f, 0.07047002f, -0.18265237f, 
    0.12908934f, -0.02809266f, 0.06279939f, 0.20035665f, 0.13472690f, 0.29806679f, -0.13070339f, -0.07857043f, 
    -0.09337748f, 0.00476144f, 0.14797387f, 0.04801760f, 0.00895695f, -0.50162262f, -0.42260787f, -0.17258082f, 
    0.07600050f, -0.01713443f, 0.10070405f, 0.00201423f, 0.08065355f, -0.27356261f, -0.13909045f, -0.19573678f, 
    -0.07342485f, 0.11209118f, -0.08556210f, 0.03783715f, 0.08790525f, 0.03931433f, -0.40211856f, -0.29142970f, 
    -0.52023125f, -0.06426518f, -0.11689012f, 0.10343249f, -0.08613200f, -0.11060604f, 0.00335984f, 0.12879851f, 
    -0.19380531f, -0.10187216f, 0.01658222f, 0.08509049f, 0.21618477f, -0.00808394f, 0.26343930f, -0.09542751f, 
    -0.04566386f, -0.05589678f, -0.04352922f, -0.01913615f, -0.05144073f, -0.01609178f, 0.00937862f, 0.02582639f, 
    -0.01174073f, 0.00460427f, -0.06910947f, -0.04076808f, 0.00263900f, -0.02020203f, -0.07218289f, -0.04259635f, 
    0.01103883f, -0.05677299f, -0.00357964f, -0.01534853f, -0.04766351f, -0.02826650f, 0.02080928f, -0.06622203f, 
    -0.00043140f, 0.02327842f, 0.01558797f, -0.06435812f, -0.00927910f, -0.00511568f, -0.05613443f, -0.03370075f, 
    -0.02972260f, 0.01581534f, 0.02868513f, -0.01631798f, -0.00425974f, 0.04786794f, 0.00172116f, -0.07847053f, 
    0.02827601f, -0.04764431f, 0.03688910f, 0.04952809f, 0.05475948f, -0.03729459f, -0.03513229f, -0.05434960f, 
    0.01304654f, -0.05950333f, -0.02554565f, 0.02284696f, 0.00238430f, -0.03125017f, 0.01036980f, -0.03086270f, 
    -0.01312472f, 0.01504179f, -0.04514169f, -0.07094059f, -0.07260042f, 0.02486824f, -0.07764019f, 0.02603129f, 
    -0.06289944f, -0.04187025f, -0.02602346f, -0.04898146f, 0.01285566f, -0.06961666f, -0.05083355f, -0.01106784f, 
    0.00788502f, 0.01356749f, -0.02795571f, -0.00658103f, -0.02936237f, 0.03007774f, -0.06393179f, -0.05867347f, 
    -0.02812480f, 0.02913160f, -0.02207026f, 0.00325913f, -0.06174674f, -0.04503947f, 0.03572351f, -0.03159134f, 
    -0.00878082f, 0.00621725f, -0.01470847f, -0.06989086f, -0.04413653f, -0.02861411f, -0.02716049f, -0.04760608f, 
    -0.03640137f, 0.03267280f, -0.03241279f, -0.00558921f, 0.01844638f, 0.00345381f, -0.00239109f, 0.02239814f, 
    -0.01884721f, -0.03188059f, -0.06320224f, 0.00529127f, -0.07654843f, 0.02786242f, 0.03546739f, -0.07550923f, 
    -0.05290456f, -0.04750951f, -0.05784506f, 0.01352200f, -0.02423946f, -0.02857937f, -0.02835296f, 0.00905282f, 
    -0.02962510f, -0.07317220f, 0.01602204f, -0.01795058f, -0.07280493f, -0.02747486f, -0.02917538f, -0.04939400f, 
    0.01843532f, -0.06619062f, -0.01013352f, 0.02056249f, -0.05295501f, -0.02632897f, 0.00968987f, -0.00445830f, 
    -0.05599669f, -0.02895712f, -0.04712869f, -0.02189979f, -0.01434259f, -0.00621262f, 0.00250041f, 0.00880739f, 
    -0.04623241f, -0.00875614f, -0.01812569f, 0.02723173f, -0.08341353f, 0.01661595f, 0.00416276f, 0.03343971f, 
    -0.03628192f, 0.04894301f, 0.02123658f, -0.03624491f, -0.02454405f, -0.05370553f, -0.00095023f, -0.02281005f, 
    -0.00602869f, 0.03490026f, -0.01014948f, -0.03355908f, -0.03182580f, -0.04778109f, -0.00119741f, 0.01485245f, 
    0.00275985f, 0.03049181f, -0.04227536f, 0.03134592f, 0.03263848f, -0.01452854f, -0.05198329f, 0.00542650f, 
    -0.00072203f, 0.02093397f, 0.00624326f, 0.00843652f, -0.03341581f, -0.06042597f, -0.05674064f, -0.00527069f, 
    0.00003321f, -0.03059763f, -0.05606955f, 0.00403853f, 0.00064342f, 0.02508046f, -0.02262254f, -0.05827581f, 
    0.00657382f, -0.05514946f, -0.05425911f, -0.01346710f, -0.06616960f, 0.01325103f, -0.05086058f, 0.02502115f, 
    0.00838969f, 0.03454725f, 0.03407128f, 0.00026679f, -0.04752419f, -0.03882304f, -0.01172263f, -0.02023993f, 
    -0.06344754f, 0.04818669f, -0.03493457f, 0.00662532f, -0.07240347f, -0.02843744f, -0.04149943f, 0.02903102f, 
    0.00958405f, 0.01879120f, 0.02112245f, -0.01285425f, 0.01315943f, -0.00700773f, -0.05737634f, -0.06233550f, 
    -0.01484020f, -0.06073986f, -0.01595914f, 0.00704447f, -0.01829137f, -0.06532699f, 0.00068519f, -0.02504504f, 
    0.02655776f, 0.00914390f, -0.05393554f, -0.06727567f, -0.03741618f, 0.03588934f, -0.04531338f, 0.00301791f, 
    -0.00229770f, -0.03399532f, -0.03297732f, -0.07182110f, 0.00967214f, -0.01553150f, 0.01986326f, 0.00458840f, 
    -0.06065999f, 0.01912972f, -0.00093077f, -0.04171002f, 0.03171511f, -0.00293658f, -0.05908331f, 0.00623454f, 
    -0.02896625f, -0.04112360f, 0.05378492f, 0.00773345f, -0.02995463f, 0.01555528f, 0.02792834f, -0.07683482f, 
    0.00001275f, -0.03738451f, 0.00390984f, 0.00482477f, -0.06032256f, 0.00270034f, 0.02127214f, -0.07391762f, 
    -0.06311567f, 0.02684300f, -0.03855002f, -0.06568014f, -0.07934980f, -0.05777178f, -0.05560085f, -0.05987589f, 
    -0.03433146f, 0.02711018f, -0.01087047f, 0.02213673f, -0.04278683f, -0.01420116f, -0.01013006f, -0.05693541f, 
    -0.00506728f, 0.12465486f, -0.06798501f, 0.10865663f, 0.07134277f, 0.10197497f, -0.04282041f, 0.12151390f, 
    0.07084687f, 0.16370432f, 0.24047311f, 0.08049616f, -0.05811593f, -0.08053913f, 0.00488633f, -0.04319013f, 
    0.00862710f, -0.03363847f, -0.22320221f, 0.24749644f, 0.15479167f, 0.10324360f, -0.07009239f, -0.31927881f, 
    0.11782815f, 0.12966722f, 0.00108294f, -0.15320487f, 0.09651902f, -0.14454694f, 0.06309000f, 0.08395266f, 
    0.21355295f, 0.11328734f, 0.00753676f, 0.40544489f, 0.24163276f, -0.04732531f, -0.11099320f, 0.03335771f, 
    -0.00635955f, 0.20076849f, 0.14599755f, -0.01410784f, -0.23305705f, 0.13725211f, -0.00148711f, -0.02330096f, 
    -0.02547416f, 0.16494659f, -0.09716716f, 0.08789280f, 0.02557942f, -0.09641955f, -0.09134429f, -0.03134003f, 
    0.04715148f, 0.13466439f, 0.01047654f, 0.15580098f, 0.02951376f, 0.16970912f, 0.29454857f, 0.61148709f, 
    0.05420961f, -0.32676309f, 0.07871530f, 0.09374825f, 0.01123949f, 0.16644999f, 0.01163509f, 0.18747689f, 
    0.19426885f, 0.15292443f, 0.11152828f, 0.10758311f, -0.10301434f, 0.03111993f, -0.02777655f, 0.01544214f, 
    -0.06792103f, 0.05146103f, 0.07704909f, 0.08455288f, 0.04386977f, 0.08470082f, 0.03288756f, -0.05394004f, 
    0.01136529f, 0.09947565f, 0.39476210f, -0.04471055f, 0.24179058f, -0.01099653f, 0.00610400f, -0.00103776f, 
    -0.06971699f, -0.00963126f, 0.13971458f, 0.00599411f, 0.10099566f, 0.18682615f, -0.00593902f, -0.04117760f, 
    -0.04883134f, -0.09203272f, 0.18758141f, 0.08651872f, 0.18484320f, 0.00869391f, 0.00623042f, -0.13574438f, 
    -0.05377350f, -0.13245314f, 0.06610575f, 0.14613006f, -0.26815245f, -0.11150391f, -0.28053665f, -0.13041794f, 
    0.21519886f, 0.14121661f, 0.13104673f, 0.04718697f, 0.02616682f, 0.08703405f, 0.15187570f, -0.03579514f, 
    0.08033935f, 0.25832114f, -0.08216335f, -0.02477206f, -0.01487414f, -0.02593079f, -0.24681123f, 0.09969406f, 
    0.11183804f, 0.03455127f, 0.06641605f, 0.01839047f, 0.06519955f, 0.06955685f, -0.04503927f, -0.55565423f, 
    0.12827529f, -0.42693409f, 0.21815030f, 0.08980870f, 0.02819876f, 0.04863165f, 0.00573381f, -0.11745344f, 
    0.17812201f, 0.15864725f, -0.04166008f, 0.21759272f, 0.03920997f, 0.07498653f, 0.25220516f, -0.00226965f, 
    0.01318651f, 0.22189917f, 0.04961104f, 0.27322704f, 0.05702987f, -0.05299201f, 0.12929472f, 0.22146638f, 
    0.14861913f, 0.05457961f, -0.01963192f, -0.01704939f, -0.23459591f, 0.19187063f, -0.01137371f, 0.01435902f, 
    0.03637530f, -0.09764402f, -0.18853125f, -0.11604585f, -0.10857922f, 0.17603536f, -0.02654815f, 0.07424815f, 
    0.02806262f, -0.14261205f, -0.00029163f, 0.07330984f, 0.16328318f, 0.34252825f, -0.01498453f, 0.56799746f, 
    -0.15410383f, -0.20195292f, 0.09292676f, -0.06936537f, -0.13231887f, -0.11551384f, 0.11004115f, 0.21203251f, 
    0.04195007f, 0.00245511f, 0.13338470f, 0.09773027f, 0.05020213f, 0.08327998f, 0.06263250f, 0.13893937f, 
    0.05784813f, 0.12234937f, 0.02815955f, -0.00144213f, 0.06946477f, 0.10920289f, 0.03304963f, 0.10554571f, 
    0.33959961f, 0.12233304f, 0.15415303f, -0.07413259f, 0.13420254f, 0.02037081f, 0.08952932f, 0.03385698f, 
    0.14056909f, 0.34740552f, 0.04667007f, 0.20873478f, -0.11516756f, 0.13341473f, 0.19236827f, 0.23825623f, 
    -0.04583625f, 0.06112961f, 0.10786804f, 0.07653217f, 0.16242175f, 0.07591931f, -0.01839406f, 0.03299525f, 
    0.18393573f, -0.03540407f, 0.25510436f, 0.09212296f, 0.21572858f, 0.01534557f, -0.20702212f, -0.23732784f, 
    0.04478193f, -0.02800751f, -0.21008150f, 0.03311940f, -0.04267728f, -0.33482674f, 0.11163381f, 0.07314178f, 
    0.11127503f, 0.11800550f, 0.05241394f, -0.17196785f, 0.06836040f, -0.17091374f, -0.03474790f, 0.26687497f, 
    0.02689638f, 0.08604267f, 0.02781427f, 0.16843458f, 0.01682118f, 0.08112512f, -0.18183768f, -0.04377630f, 
    -0.27147388f, 0.03692795f, 0.10707299f, 0.05387077f, 0.20498234f, 0.22095934f, 0.32138291f, -0.03704345f, 
    0.11095316f, 0.08926282f, 0.00347314f, -0.07710296f, -0.11586405f, 0.02138837f, -0.09005388f, -0.27873024f, 
    -0.06557534f, 0.06833392f, 0.00405643f, -0.00086556f, -0.08279701f, 0.10377803f, 0.00691822f, 0.07012353f, 
    -0.06426653f, -0.11097867f, 0.04218711f, 0.05621068f, -0.08420768f, 0.00083911f, -0.07641381f, -0.10391263f, 
    -0.08942609f, 0.05957523f, -0.40334660f, -0.39002892f, -0.87037098f, 0.03831451f, 0.01277562f, 0.11779169f, 
    -0.06234437f, 0.05117514f, 0.00286038f, -0.09209985f, 0.27099374f, -0.07166565f, -0.07133814f, -0.03346092f, 
    0.07169054f, -0.00488291f, -0.00288245f, -0.20275377f, 0.13763531f, 0.13523592f, 0.18290748f, -0.15351973f, 
    -0.18999167f, -0.00031671f, 0.01894582f, 0.04628665f, 0.10310761f, -0.00108093f, -0.36649007f, -0.01347299f, 
    0.11812099f, 0.01537877f, -0.14793906f, -0.00015344f, -0.11878867f, 0.08269864f, -0.12959319f, 0.28388169f, 
    0.06773298f, -0.03670153f, -0.05061643f, 0.02502085f, 0.05023451f, -0.07083251f, 0.00768513f, -0.77463603f, 
    0.12281719f, -0.08530142f, 0.03223421f, 0.11108813f, -0.03794939f, 0.00989605f, -0.01929536f, 0.10730822f, 
    0.04678320f, 0.17979497f, -0.01018208f, -0.29309642f, 0.04362008f, -0.02769430f, -0.01167363f, 0.05665249f, 
    0.00547339f, 0.11677438f, -0.03477987f, 0.00037775f, 0.03910121f, 0.08679341f, 0.01558053f, -0.09881099f, 
    -0.12550363f, 0.04573593f, 0.08567752f, -0.07091171f, 0.07800067f, 0.09661722f, 0.33953133f, -0.28361470f, 
    0.13462882f, -0.32396963f, -0.01482198f, 0.02038258f, 0.26976058f, 0.14313953f, -0.04275075f, -0.11077486f, 
    -0.08042113f, 0.12895538f, 0.07190285f, 0.07128234f, -0.33873633f, 0.18008448f, -0.14700778f, -0.02405179f, 
    -0.07419901f, 0.06394579f, 0.02846735f, -0.10709152f, 0.15080620f, -0.02483444f, 0.01687576f, 0.10504799f, 
    -0.20764698f, 0.02867787f, -0.14224701f, 0.15069510f, -0.06624142f, -0.09420977f, 0.02315310f, 0.16210434f, 
    0.10979326f, -0.04160631f, -0.12881552f, 0.03000785f, 0.05166924f, 0.03837954f, -0.01598921f, -0.08017786f, 
    0.01154778f, 0.10847250f, -0.11078943f, -0.13320853f, 0.09544913f, -0.03020943f, -0.09628347f, 0.12545721f, 
    0.26752934f, -0.09072381f, 0.00238063f, -0.09831283f, -0.12035839f, 0.10026815f, 0.15887831f, 0.01320461f, 
    0.04018031f, 0.05058216f, 0.19624065f, 0.25996616f, -0.00514037f, 0.19087744f, 0.06684209f, 0.05458375f, 
    0.20213386f, -0.00308453f, -0.70868742f, -0.43056074f, 0.09243385f, -0.01148829f, 0.02619630f, -0.03656556f, 
    -0.01178917f, -0.11116052f, -0.11207454f, 0.06577524f, -0.11803625f, 0.40918487f, -0.15871714f, -0.28974628f, 
    -0.28896874f, 0.04980277f, 0.09312578f, 0.10796266f, -0.15982498f, 0.22503757f, 0.32567418f, 0.14944614f, 
    0.02652311f, -0.27924979f, -0.20821060f, 0.07675557f, 0.16485083f, -0.09010249f, -0.35826111f, -0.08047535f, 
    0.01871890f, 0.11235172f, -0.01124750f, -0.05654977f, -0.06063180f, 0.17448734f, -0.24903770f, 0.17574802f, 
    -0.30119434f, -0.06311411f, 0.03747695f, -0.02535960f, -0.01270514f, -0.04732295f, 0.08106092f, 0.08574896f, 
    0.28863132f, 0.21606663f, -0.08907029f, -0.00670860f, -0.10330897f, -0.07809613f, 0.10445923f, -0.02778784f, 
    0.12465571f, -0.06520614f, 0.04861325f, -0.05787926f, 0.06749514f, -0.14108321f, 0.08929169f, -0.13811722f, 
    0.05886286f, -0.34958446f, -0.40410742f, 0.10215037f, -0.16803648f, 0.05241466f, -0.07975021f, -0.21111278f, 
    -0.10023100f, -0.06919636f, -0.33427638f, 0.35269213f, 0.39108172f, -0.17707403f, 0.05051136f, 0.04662408f, 
    -0.07638491f, 0.06940576f, -0.00372458f, -0.38727230f, 0.14932930f, 0.20804547f, 0.08146785f, 0.04069541f, 
    -0.01798355f, 0.15516376f, 0.16264670f, -0.03480408f, -0.07691053f, -0.16926806f, 0.34751698f, -0.27073050f, 
    -0.07750813f, -0.06421851f, 0.07811935f, -0.07679367f, -0.00909693f, 0.05635494f, -0.12242622f, -0.12770206f, 
    -0.13957413f, -0.05349164f, -0.17197376f, 0.18306270f, -0.10634772f, 0.12706137f, -0.03998766f, -0.04193733f, 
    0.08951902f, -0.04867211f, 0.03447913f, -0.05831246f, 0.07690012f, -0.02828973f, -0.05223993f, -0.11528303f, 
    -0.02397371f, 0.03590449f, 0.12736653f, 0.11377444f, 0.03820875f, -0.05321232f, 0.13460253f, 0.04344841f, 
    -0.05074921f, -0.01586851f, 0.28158122f, 0.08274517f, -0.17473124f, -0.05098529f, -0.06973519f, -0.20906325f, 
    0.05120026f, 0.06419647f, 0.04544952f, 0.12183844f, 0.02413110f, -0.10693819f, 0.06741809f, -0.11240664f, 
    0.02256896f, -0.05372200f, -0.09101767f, -0.13680671f, 0.11654118f, -0.00608460f, 0.02797488f, 0.16612610f, 
    -0.10663580f, -0.16952729f, 0.19431569f, -0.07458141f, 0.08719808f, 0.10495117f, 0.11281457f, 0.01328707f, 
    0.17387778f, -0.11469410f, -0.09413833f, 0.05790889f, 0.05665451f, -0.08113507f, -0.20219775f, -0.27106795f, 
    -0.15027064f, -0.05545684f, 0.23507679f, 0.18344232f, -0.06351091f, 0.06757896f, -0.07533524f, 0.11166535f, 
    0.01322659f, 0.03988775f, -0.02364803f, -0.09370621f, 0.03586899f, -0.05333469f, -0.01168760f, 0.00397681f, 
    0.07516701f, 0.12623577f, -0.19044383f, -0.06398361f, -0.10689817f, -0.35117549f, -0.15301213f, -0.10728258f, 
    -0.13471317f, 0.22562990f, -0.03919313f, 0.14729191f, -0.08263886f, 0.03586042f, -0.20966592f, -0.04216315f, 
    -0.05305129f, -0.11657286f, -0.28660539f, -0.09481426f, 0.03837978f, -0.05632783f, 0.00167253f, 0.30829766f, 
    -0.05428635f, -0.04593060f, 0.02670222f, 0.00495536f, 0.01726611f, 0.03966011f, -0.08528166f, -0.03808567f, 
    0.15776454f, -0.05911757f, 0.00467517f, -0.33656794f, -0.20588928f, 0.16529398f, 0.05928002f, 0.07091969f, 
    -0.14481363f, -0.03387393f, -0.25478733f, 0.12137168f, 0.25537282f, 0.05875704f, 0.08595226f, 0.07882873f, 
    0.04882082f, -0.08013498f, -0.14275487f, 0.13416693f, 0.11615258f, 0.10956709f, 0.16684662f, 0.15570861f, 
    0.02098353f, 0.07021990f, -0.05080197f, 0.05579165f, 0.22614786f, 0.00176890f, -0.09079375f, -0.00528576f, 
    0.13551164f, 0.09378657f, 0.13272026f, 0.00370553f, -0.04845413f, 0.05421201f, 0.05287897f, 0.17621945f, 
    0.14834027f, -0.08918900f, 0.00963969f, -0.12307750f, 0.03972659f, 0.14094390f, -0.03703631f, -0.17250082f, 
    -0.02688853f, -0.20790088f, -0.11241262f, -0.09435637f, 0.07138991f, 0.27973866f, 0.08097437f, 0.19358312f, 
    -0.09862742f, -0.04623989f, 0.03320007f, -0.00006306f, -0.05224632f, -0.11798605f, -0.09467038f, 0.18563266f, 
    -0.07583266f, 0.02793465f, -0.09142499f, 0.05638837f, -0.01536401f, 0.08551911f, 0.21203956f, 0.05548845f, 
    -0.09642728f, 0.06510653f, -0.03147995f, -0.08194252f, 0.14460604f, 0.02599135f, 0.07352417f, 0.09400216f, 
    -0.02796987f, 0.04486779f, -0.07856088f, -0.07929485f, -0.13506876f, 0.08986375f, 0.11008219f, -0.03789157f, 
    0.05699740f, -0.05131808f, -0.05992921f, -0.03196518f, -0.03803417f, 0.07514186f, 0.12467195f, -0.00179913f, 
    0.07602907f, 0.11096992f, 0.07540770f, -0.01202498f, 0.13938488f, -0.16874108f, -0.16815083f, 0.00999309f, 
    0.02625263f, 0.03117394f, -0.01757019f, 0.01647164f, 0.15694337f, -0.03546157f, 0.01329637f, -0.01215017f, 
    0.09445800f, 0.13626377f, 0.01061107f, 0.01115279f, 0.07080778f, 0.04418583f, -0.00702436f, 0.08405803f, 
    0.03089937f, -0.07899722f, 0.15475674f, 0.04276929f, -0.01953176f, 0.04190147f, 0.01966589f, -0.08823594f, 
    0.00217049f, -0.15873635f, -0.25685713f, 0.06781755f, -0.02239801f, 0.14690670f, -0.17814824f, 0.03074690f, 
    -0.06014302f, -0.00480653f, -0.11854783f, 0.20923167f, -0.10820277f, 0.04407423f, 0.02665925f, 0.03574076f, 
    -0.22835894f, 0.05950439f, 0.00710036f, 0.08237799f, 0.17223224f, 0.20833224f, -0.00958477f, -0.01066894f, 
    -0.00309618f, -0.02845197f, 0.05928311f, 0.06047054f, 0.04460270f, 0.12593596f, -0.04508320f, 0.01411757f, 
    0.11721215f, -0.03743594f, 0.12045182f, 0.10722750f, -0.13181591f, -0.18931216f, -0.07744524f, 0.17257993f, 
    0.04555584f, 0.21150568f, -0.07396287f, -0.08479689f, -0.07421830f, -0.01558286f, -0.06409767f, -0.10741217f, 
    -0.15772907f, 0.08569348f, -0.12025473f, 0.04339314f, -0.02723072f, -0.15884130f, 0.00944564f, 0.03473027f, 
    0.04128526f, -0.03433301f, 0.00982191f, -0.11188066f, -0.18003300f, -0.26258016f, -0.22368859f, -0.03701784f, 
    0.11730210f, 0.19844031f, 0.12799414f, -0.05782127f, 0.12933023f, 0.28479731f, 0.22553645f, 0.19565666f, 
    0.32520068f, 0.04156244f, 0.17697750f, -0.03437784f, 0.07857066f, 0.11711881f, 0.14269993f, 0.08406781f, 
    -0.03549568f, 0.34605098f, 0.11231297f, 0.10314091f, 0.00529627f, -0.06148418f, 0.18019781f, 0.03436033f, 
    0.01106722f, -0.02136042f, 0.19017212f, -0.27757519f, -0.54328930f, 0.05674589f, 0.11441205f, -0.03711727f, 
    0.04202282f, -0.10015226f, -0.08087942f, 0.07725639f, -0.09829731f, 0.07200179f, 0.12769726f, -0.04693837f, 
    0.02063449f, 0.12600233f, 0.09448353f, 0.08454873f, 0.13264285f, 0.30303350f, 0.18558936f, -0.09686968f, 
    -0.05202625f, -0.12773737f, -0.09118746f, 0.01912454f, 0.07830807f, -0.13070671f, -0.40389806f, -0.23771431f, 
    0.06133946f, -0.00054648f, 0.06558569f, 0.04845342f, 0.17539337f, 0.04847092f, 0.24566908f, 0.04443730f, 
    0.15502030f, 0.03270723f, -0.00677187f, 0.03079575f, 0.15158848f, 0.09781774f, -0.06796373f, -0.88116300f, 
    -0.20497578f, 0.16017269f, -0.15721960f, -0.09422970f, 0.02495689f, 0.12049382f, 0.13127294f, 0.17868787f, 
    0.27006105f, 0.15046664f, -0.15671881f, -0.03879690f, 0.20089814f, -0.03859722f, 0.04830109f, -0.02206883f, 
    -0.09594239f, 0.19835730f, 0.12696812f, 0.14961502f, -0.00378441f, -0.00467247f, -0.06788231f, 0.02640430f, 
    -0.05568561f, -0.04818464f, -0.24270572f, 0.04489945f, 0.02375510f, -0.04154606f, -0.07043571f, 0.10170995f, 
    0.01773438f, -0.03549438f, 0.00472427f, 0.25515199f, -0.05156990f, -0.02096119f, 0.08088426f, 0.13093702f, 
    0.06951454f, -0.06954528f, -0.01119681f, -0.00237934f, -0.02919845f, -0.26769498f, -0.07902191f, -0.01674873f, 
    0.21022700f, -0.12807652f, 0.12301017f, 0.03772769f, 0.14207466f, -0.13972421f, -0.14414220f, -0.15388644f, 
    0.04577682f, 0.03995041f, -0.01717898f, -0.08940410f, 0.16834176f, 0.09100430f, -0.10496341f, 0.17536293f, 
    0.11436716f, -0.00582036f, 0.14750856f, 0.04977056f, 0.08379052f, 0.04298253f, 0.05537729f, 0.07604160f, 
    0.13916178f, 0.14628151f, -0.06888705f, -0.04847267f, -0.15645371f, -0.00555370f, -0.03746961f, 0.05028666f, 
    0.09350044f, -0.11688876f, -0.26565295f, 0.10416517f, 0.10789356f, 0.22206526f, -0.00545629f, -0.04930183f, 
    0.01824642f, 0.00426794f, 0.04046235f, 0.23365985f, -0.00150430f, 0.00879272f, -0.19386306f, -0.05166566f, 
    -0.09239854f, 0.14750525f, -0.32699627f, -0.37455675f, 0.02247755f, 0.03342105f, -0.01996451f, 0.16609918f, 
    0.13357510f, 0.03434249f, 0.14616704f, -0.13017967f, -0.22821942f, -0.09912530f, 0.00014728f, -0.07785483f, 
    0.07912380f, -0.11567926f, 0.00258979f, 0.04091314f, -0.29825234f, 0.01539513f, -0.13494179f, -0.10640956f, 
    -0.12424541f, 0.08532596f, 0.05574286f, 0.19966559f, 0.18870147f, -0.33235988f, 0.01281139f, -0.20566511f, 
    -0.14498852f, -0.11630914f, -0.18199487f, -0.03199096f, -0.01606149f, 0.06784848f, -0.29673842f, -0.34131718f, 
    -0.13618107f, 0.04270675f, -0.02449587f, 0.12224763f, 0.02705689f, 0.23759682f, 0.04521404f, 0.01605262f, 
    0.06830290f, 0.05108143f, 0.11919142f, 0.08666503f, 0.02685820f, 0.03238872f, -0.03246579f, 0.01960709f, 
    -0.19486900f, 0.10112431f, 0.07837815f, 0.09304472f, 0.01346415f, -0.09675533f, -0.09904286f, 0.01486705f, 
    -0.02062244f, -0.17562094f, 0.27637738f, -0.14045154f, 0.04948251f, 0.12500699f, -0.05873634f, -0.09981143f, 
    0.02273539f, -0.05911637f, -0.08982148f, -0.22919744f, 0.13377020f, -0.02089434f, -0.03546020f, -0.13655598f, 
    -0.01873041f, 0.07493735f, 0.08186419f, -0.22317296f, -0.53070688f, 0.14299200f, 0.11142273f, 0.07084455f, 
    -0.16353846f, -0.18978776f, 0.20722374f, 0.05891480f, -0.24204713f, -0.29523879f, -0.13429734f, 0.05584551f, 
    0.05697719f, 0.03322108f, -0.04967719f, 0.08384929f, 0.10216998f, 0.25790459f, -0.11945327f, -0.17440507f, 
    0.14305569f, 0.04974420f, -0.02973280f, 0.06490827f, -0.09462871f, -0.05940464f, 0.34537834f, 0.24676885f, 
    0.17248440f, 0.01731653f, 0.01814913f, -0.09751281f, 0.07153098f, 0.05313369f, -0.14692442f, 0.11296394f, 
    -0.01120333f, 0.01670849f, 0.09836635f, -0.01831492f, 0.08714268f, -0.10023924f, 0.07413730f, 0.12738329f, 
    0.20086691f, -0.23884705f, -0.47931388f, 0.04067872f, 0.18916497f, -0.04812143f, 0.04921344f, 0.01078149f, 
    0.00200760f, -0.52716458f, -0.62174624f, -0.12812805f, -0.08671968f, 0.09173977f, -0.15290459f, 0.04520813f, 
    -0.00537163f, 0.05041718f, 0.68919414f, -0.21009888f, -0.14195463f, 0.02617558f, -0.06602503f, 0.05225145f, 
    0.09706968f, -0.04254483f, 0.14794099f, 0.17028992f, 0.15317194f, 0.02755586f, 0.00427050f, -0.04154649f, 
    -0.13896862f, -0.01906025f, 0.04168427f, -0.06409620f, -0.09088512f, 0.28117034f, 0.17329946f, -0.06594276f, 
    0.00210015f, 0.02302109f, 0.04378743f, 0.00792953f, -0.08417760f, -0.08107039f, -0.22056302f, -0.18863823f, 
    -0.04369563f, -0.05986609f, -0.01359229f, 0.05704580f, 0.03410082f, 0.13661595f, 0.08693261f, -0.12779738f, 
    -0.15797587f, 0.12881283f, -0.00919842f, 0.06538526f, 0.00031805f, 0.03928741f, 0.06351443f, 0.05264893f, 
    0.21293262f, 0.14534257f, -0.15623307f, 0.11156718f, 0.05362082f, 0.00222522f, 0.08529545f, 0.05348833f, 
    -0.15901241f, 0.10268768f, 0.73876971f, -0.14593476f, -0.14950037f, -0.20056288f, 0.10826206f, -0.03631296f, 
    -0.00853135f, -0.09588107f, 0.07110590f, -0.20521109f, -0.03651238f, -0.13109644f, 0.08064777f, 0.03624343f, 
    0.11947108f, -0.09751851f, -0.10647368f, -0.11979568f, -0.49216273f, -0.01283658f, -0.04122726f, 0.01737094f, 
    0.15747678f, -0.09713998f, 0.08307847f, -0.15051512f, -0.93652761f, 0.13114300f, -0.04941135f, -0.05398543f, 
    -0.16018215f, -0.11312071f, 0.10535683f, -0.00330979f, -0.01589586f, -0.15713462f, -0.08945255f, -0.00407997f, 
    0.04360752f, -0.03836698f, -0.09025495f, 0.06707244f, 0.03352459f, 0.28179628f, 0.16417187f, -0.22401536f, 
    -0.21884805f, -0.03959681f, 0.00404952f, 0.09102085f, -0.01809778f, -0.07685708f, -0.00740279f, -0.12783466f, 
    -0.07755935f, -0.21943200f, 0.09633630f, -0.01200720f, -0.11205058f, -0.04010398f, -0.16426739f, 0.25167257f, 
    0.32773563f, -0.10110195f, 0.12125113f, 0.12088772f, 0.11333579f, 0.06691490f, 0.11703026f, -0.18473534f, 
    0.37463719f, 0.21638368f, 0.03880779f, 0.11056643f, 0.13203345f, -0.14347336f, 0.16858283f, 0.06009997f, 
    0.02006503f, -0.08468836f, -0.63524127f, 0.16606912f, 0.15218630f, 0.00178140f, -0.13604288f, -0.05456279f, 
    -0.02289779f, -0.23688555f, -0.01095653f, -0.01665874f, 0.16130854f, -0.00680310f, -0.13728316f, -0.09984455f, 
    -0.03439154f, 0.17355399f, 0.13975568f, 0.05343106f, 0.10817415f, -0.32178736f, 0.03165300f, -0.24154353f, 
    0.10796142f, 0.13629656f, 0.08474513f, -0.01039761f, -0.10923304f, 0.05647494f, 0.16074845f, -0.01292226f, 
    0.06067776f, -0.06022280f, 0.18764658f, 0.02786518f, -0.10606090f, 0.02124456f, -0.21114159f, 0.03523642f, 
    0.15716131f, 0.12643096f, 0.11044803f, 0.23730150f, 0.00258798f, 0.08079392f, -0.09793654f, 0.11897122f, 
    0.10116273f, -0.15786278f, -0.16159555f, 0.02341388f, 0.08997905f, -0.00273271f, 0.00337880f, -0.38018137f, 
    0.04107017f, 0.02517260f, -0.02906817f, -0.11995706f, -0.04072975f, 0.03679349f, 0.01012269f, 0.06870727f, 
    0.09463144f, -0.04385571f, -0.22112131f, -0.07790137f, 0.11363148f, -0.01402044f, 0.15925080f, -0.12052523f, 
    0.11210945f, -0.20062527f, -0.27220374f, 0.02132906f, -0.03156768f, 0.10525147f, 0.13563441f, 0.03737322f, 
    -0.01138123f, 0.09689964f, -0.06055748f, 0.18524383f, 0.17977476f, -0.24493474f, 0.02554446f, 0.08331344f, 
    0.11924077f, 0.01361743f, -0.03923273f, -0.11232180f, -0.30965847f, -0.12594704f, 0.04384445f, -0.06532864f, 
    -0.01398666f, 0.01647374f, 0.06078237f, -0.07510596f, 0.14727694f, 0.15323770f, -0.28283748f, -0.04542413f, 
    -0.25702623f, -0.02187444f, 0.10994481f, 0.08587430f, 0.01114786f, 0.07557306f, 0.02192796f, -0.03185902f, 
    -0.00051467f, -0.04916109f, -0.08192272f, -0.10244286f, 0.01262419f, 0.21092524f, 0.05027337f, -0.36663908f, 
    -0.20481861f, -0.01195052f, -0.10034069f, 0.05787603f, 0.12793690f, 0.00067937f, 0.18593711f, -0.02529120f, 
    -0.04448958f, -0.38712415f, -0.15492038f, 0.17341636f, 0.06188963f, 0.11509650f, 0.03814552f, -0.12605962f, 
    -0.05717518f, -0.16537017f, 0.07168183f, 0.03019150f, -0.11947550f, -0.08128023f, 0.05327625f, 0.03837365f, 
    -0.01681877f, -0.02798873f, 0.04214433f, 0.04017894f, 0.12433204f, 0.05172007f, 0.09693412f, 0.02913906f, 
    -0.10159676f, -0.05441988f, 0.69459039f, -0.13420795f, -0.49517217f, 0.06669798f, -0.07168181f, 0.24372727f, 
    -0.12068836f, -0.06457261f, 0.11386047f, 0.28379568f, 0.15740930f, 0.20506001f, -0.08510128f, 0.01271807f, 
    0.01323089f, 0.07796045f, -0.00398298f, 0.03499443f, -0.10522527f, 0.36767355f, 0.02932635f, 0.16558297f, 
    0.03254536f, -0.11715011f, -0.03021930f, -0.08469968f, 0.06160609f, 0.14360324f, 0.03647044f, 0.11973152f, 
    -0.14454296f, 0.01985126f, 0.04669444f, 0.08359320f, -0.02338171f, -0.00637567f, -0.20838049f, -0.10445638f, 
    0.07185190f, -0.17116466f, -0.25774562f, -0.12883122f, -0.01808160f, -0.11237645f, -0.05266170f, -0.23044185f, 
    0.10654553f, -0.21398309f, 0.04003300f, -0.20981234f, 0.01039130f, -0.12295929f, 0.11482880f, 0.10083756f, 
    -0.16037093f, 0.10198176f, 0.16495092f, 0.00907429f, 0.02396569f, -0.09815090f, 0.03213684f, 0.04815336f, 
    -0.04452260f, -0.11995089f, -0.36711755f, -0.37956375f, 0.06058763f, 0.17178513f, 0.09037827f, -0.00512129f, 
    0.05391126f, -0.04416779f, -0.12517245f, -0.68663067f, -0.18483220f, 0.04921732f, 0.04179091f, 0.03202787f, 
    -0.00457868f, -0.01219414f, 0.08664682f, -0.13371912f, -0.30914617f, 0.06920512f, 0.07208349f, 0.05519228f, 
    -0.04250357f, 0.14907464f, -0.02010984f, 0.04370702f, 0.10767720f, 0.12200963f, 0.06505483f, 0.03677684f, 
    -0.05102998f, 0.00653911f, 0.12586811f, 0.01476055f, 0.11096346f, -0.08858211f, -0.01023418f, -0.17314361f, 
    -0.15849330f, -0.14848939f, -0.11652330f, 0.00298543f, -0.00266154f, -0.07738969f, 0.02825188f, 0.10294194f, 
    -0.18074685f, -0.18438779f, 0.08694747f, 0.04572169f, 0.05200765f, -0.01295698f, -0.01651764f, -0.25853077f, 
    -0.20226723f, -0.32335490f, 0.36272550f, 0.11977771f, 0.10106125f, -0.09556664f, -0.05794958f, 0.22846386f, 
    -0.22761878f, -0.24097212f, -0.20522778f, -0.33014119f, 0.09706721f, 0.12894161f, 0.05359520f, 0.03493543f, 
    -0.00320198f, -0.11775521f, -0.04187879f, 0.00626553f, 0.02310535f, 0.03008586f, -0.11028645f, 0.02268796f, 
    0.07985263f, 0.01989113f, 0.03253915f, 0.10012892f, 0.29526076f, 0.10325104f, 0.26806924f, -0.05163461f, 
    0.14472862f, 0.00672901f, 0.10016997f, -0.04058330f, -0.10433420f, -0.01853759f, -0.20421091f, -0.09635673f, 
    -0.06571373f, -0.00105799f, -0.13316278f, -0.11474254f, 0.08262808f, 0.05216258f, 0.13121045f, -0.05322579f, 
    -0.03895165f, 0.02484218f, -0.09906271f, 0.07113955f, -0.06423686f, -0.10059744f, -0.33188015f, 0.22657181f, 
    -0.05680513f, 0.16066021f, -0.05098359f, -0.04722399f, 0.17032279f, 0.19018798f, 0.17156450f, 0.08809773f, 
    0.24898900f, -0.01804822f, 0.03317657f, -0.04875815f, 0.04982617f, -0.02632331f, 0.01792096f, -0.09322575f, 
    -0.04974797f, -0.02257099f, -0.00252154f, 0.07552157f, 0.04003878f, -0.06143266f, 0.00137189f, -0.12503120f, 
    -0.12500559f, -0.20950069f, -0.04171146f, -0.03930935f, 0.11132802f, 0.00870973f, 0.03858639f, 0.10121937f, 
    -0.00679961f, -0.12982190f, 0.03942749f, 0.06927986f, 0.03285470f, 0.28924704f, 0.08134039f, 0.06534402f, 
    -0.12582490f, -0.06171754f, 0.00307573f, 0.01268325f, 0.16430490f, -0.06205576f, -0.16373466f, 0.09982220f, 
    -0.13749725f, -0.21913032f, 0.02588510f, 0.11006851f, -0.23569587f, 0.25632349f, -0.25869954f, -0.15848862f, 
    -0.04715047f, 0.07177296f, -0.07091877f, 0.13004293f, -0.09560176f, -0.15147144f, -0.16540138f, -0.23524600f, 
    -0.09333666f, -0.19745968f, -0.01130700f, -0.04012928f, -0.05340909f, 0.07675263f, 0.05570576f, 0.07361107f, 
    0.05075984f, -0.05433864f, 0.02245021f, -0.10963044f, 0.01692748f, 0.02393678f, -0.22929320f, -0.20064126f, 
    0.06026134f, 0.01407758f, -0.17451020f, -0.16475770f, 0.01928829f, -0.05336256f, 0.08555575f, -0.21677902f, 
    -0.10931741f, 0.01756161f, 0.26223311f, 0.20253116f, 0.19430295f, -0.11763738f, -0.01669794f, 0.01679677f, 
    -0.19874685f, 0.05053309f, 0.09375654f, -0.16356914f, 0.12266090f, -0.10566533f, 0.14925277f, 0.05868240f, 
    0.01710660f, -0.26783231f, -0.35562143f, -0.06532769f, -0.08936189f, 0.06355482f, -0.10299130f, 0.13914184f, 
    0.03903894f, 0.15068489f, -0.31396407f, 0.29042220f, 0.07703758f, 0.05180368f, -0.32855919f, -0.26465544f, 
    -0.08954473f, -0.01985131f, -0.01714991f, 0.15843046f, 0.02420888f, 0.08967062f, 0.09298182f, 0.00351425f, 
    0.04571523f, 0.06586270f, -0.06663689f, 0.13662525f, -0.01874638f, -0.10332565f, -0.10337302f, -0.09261528f, 
    -0.11181670f, -0.03647535f, -0.00370543f, -0.06580843f, 0.05443126f, -0.43142816f, 0.03787930f, -0.33522159f, 
    0.24212769f, 0.15486696f, 0.04049765f, -0.00011778f, 0.14564897f, 0.06307292f, -0.17134050f, 0.14965095f, 
    0.01074157f, -0.15900956f, 0.01965268f, -0.09443818f, -0.02607735f, 0.17723553f, 0.14546838f, -0.53467029f, 
    0.01856585f, -0.19462468f, 0.06235323f, 0.04486831f, -0.09370640f, 0.03521844f, 0.01364625f, 0.07278366f, 
    -0.20786664f, -0.37551633f, 0.01480867f, -0.04272647f, -0.03182388f, 0.03994992f, -0.09074242f, -0.12782283f, 
    0.04684334f, -0.17144293f, 0.15028611f, 0.03298508f, 0.07313435f, -0.08687022f, -0.07809594f, 0.02350330f, 
    0.18356420f, -0.01570734f, -0.25693744f, 0.16324365f, 0.00485938f, 0.13190027f, -0.19273190f, 0.05528131f, 
    0.02375243f, 0.20481063f, -0.04195729f, -0.03542447f, -0.45496693f, -0.27072036f, -0.33153969f, 0.00803714f, 
    -0.18471719f, 0.12379116f, -0.02229954f, -0.03115422f, -0.02000917f, -0.02404287f, -0.24290934f, 0.01141112f, 
    0.21211936f, 0.20050558f, -0.12751849f, 0.02083217f, -0.15949148f, 0.28446522f, 0.16500524f, 0.13407347f, 
    -0.07810421f, 0.02789416f, -0.03966003f, -0.00719759f, -0.05585079f, 0.04470434f, -0.29615456f, -0.34003887f, 
    -0.10726578f, -0.00213855f, 0.01548258f, 0.11522440f, -0.11574779f, -0.01415604f, -0.13031104f, 0.17497534f, 
    0.21396530f, 0.15790719f, -0.03245655f, -0.12105203f, 0.15338734f, -0.14018010f, -0.07997810f, -0.34162486f, 
    0.02722985f, -0.02872518f, 0.33419719f, 0.06909136f, 0.12480101f, -0.02779006f, 0.06946441f, -0.03704648f, 
    0.11433825f, 0.01228483f, -0.38157064f, -0.08963917f, -0.02553491f, -0.01153521f, -0.17348288f, 0.23475255f, 
    -0.02159294f, 0.09363508f, 0.02597295f, -0.05791271f, -0.13484517f, 0.07672252f, 0.08535986f, 0.01348061f, 
    0.06338806f, 0.01732565f, 0.13196369f, 0.18154934f, -0.06071942f, 0.15771441f, 0.11759704f, 0.16034590f, 
    0.08626775f, -0.01797812f, 0.07831770f, -0.02648750f, 0.06145515f, -0.15074624f, 0.07067643f, 0.18690875f, 
    0.02246349f, -0.02346309f, -0.01701260f, 0.05909213f, 0.08977266f, -0.22344677f, -0.01021577f, -0.43929899f, 
    0.01791728f, 0.08223540f, 0.07609004f, 0.02166154f, 0.13307169f, 0.03630319f, -0.03082533f, -0.14225082f, 
    0.06906864f, 0.05072387f, 0.06045136f, 0.06860512f, 0.04413195f, 0.11245634f, 0.01018056f, -0.33826950f, 
    -0.24764004f, 0.08034641f, 0.10666626f, -0.06307816f, 0.14676285f, -0.04760820f, -0.01676909f, 0.06209257f, 
    -0.21813354f, 0.03410742f, -0.06843904f, 0.00800355f, 0.14721711f, 0.02220304f, 0.07276964f, 0.06383918f, 
    0.02946159f, -0.03084519f, -0.47990128f, -0.43645427f, -0.15248819f, 0.10052454f, -0.01841171f, 0.17554305f, 
    -0.01963260f, 0.05045373f, 0.04927709f, -0.30868375f, 0.11368957f, -0.06671550f, 0.18065965f, 0.08116458f, 
    0.02368223f, -0.00870205f, -0.00033579f, -0.11252005f, 0.08411893f, -0.39444765f, 0.01167837f, 0.06001107f, 
    0.05695963f, 0.01862972f, 0.03472203f, -0.02556917f, 0.24084949f, 0.22527832f, 0.28769219f, -0.08731136f, 
    0.10499804f, -0.07762595f, -0.09280809f, -0.01564913f, 0.07032445f, 0.21816447f, -0.24188854f, -0.04784695f, 
    0.17560498f, -0.04750998f, -0.03756225f, -0.04284438f, 0.09495166f, 0.09288222f, 0.15299764f, 0.26350689f, 
    0.05211522f, -0.07086503f, -0.09070497f, -0.01582200f, 0.01183044f, 0.09091180f, 0.21944134f, 0.04805743f, 
    0.21783477f, 0.04997907f, 0.01173658f, -0.01798455f, 0.07813004f, 0.00122627f, -0.35141161f, -0.31570652f, 
    -0.01281016f, 0.03236653f, -0.02542220f, -0.05545679f, 0.02631210f, 0.02094088f, -0.00728458f, -0.03605047f, 
    -0.04802386f, 0.01184072f, 0.00015550f, 0.01120876f, -0.02019263f, -0.00491675f, -0.04565660f, 0.01095456f, 
    0.02082676f, 0.02109279f, 0.04965525f, 0.03898942f, 0.02750600f, -0.01616454f, 0.00224058f, 0.04685776f, 
    -0.05276489f, 0.03781940f, 0.04612230f, 0.04227812f, 0.04416585f, -0.04810619f, 0.00397861f, -0.03785955f, 
    -0.04722440f, -0.01333303f, -0.02191425f, 0.00949357f, 0.00584401f, -0.03213194f, -0.00869886f, 0.00643445f, 
    -0.00545594f, -0.03370619f, -0.00990765f, 0.01349305f, -0.05672543f, -0.05392417f, -0.05118686f, -0.02111842f, 
    -0.04923461f, 0.00472281f, 0.01308563f, -0.03803398f, 0.03286074f, 0.01470752f, 0.04397939f, -0.04523228f, 
    -0.01758673f, 0.00120169f, 0.01770150f, -0.03249286f, -0.02392271f, -0.02497835f, 0.01952943f, -0.03367355f, 
    0.01349477f, 0.03260677f, 0.05004239f, -0.03768902f, 0.00393881f, 0.04820506f, -0.01320420f, 0.00565420f, 
    0.01333102f, -0.00228897f, -0.03761835f, 0.00594587f, 0.02906663f, 0.01408205f, -0.00758677f, -0.04788237f, 
    0.00103410f, 0.00071381f, -0.06129797f, -0.06448469f, -0.04934588f, -0.04678107f, -0.02438835f, -0.00683748f, 
    0.02375521f, -0.03565756f, -0.02550752f, 0.00246222f, 0.01925769f, 0.02627328f, -0.01330664f, -0.03930624f, 
    -0.04834616f, -0.06095388f, -0.00707287f, -0.03381439f, -0.02724382f, 0.02428930f, 0.00977906f, -0.04650073f, 
    0.03389765f, 0.00165095f, -0.03850186f, -0.00430121f, -0.05970744f, 0.03441077f, -0.02272923f, 0.05260656f, 
    -0.03276818f, -0.04051085f, 0.05340371f, 0.01553063f, 0.03691218f, 0.02635172f, -0.03613971f, 0.02566611f, 
    -0.00416250f, -0.00080459f, -0.01884068f, -0.05733880f, -0.01582913f, 0.00981863f, -0.06181473f, -0.03579326f, 
    -0.01985075f, 0.02916860f, 0.04014883f, 0.04028961f, -0.02797969f, 0.03982357f, -0.03342801f, 0.02192360f, 
    -0.05179244f, 0.03233151f, 0.02369559f, -0.06306142f, 0.04407461f, 0.02300902f, 0.06183108f, 0.00793663f, 
    -0.02686842f, 0.04556860f, -0.03213389f, -0.03572414f, 0.04889169f, -0.01030615f, 0.01110816f, -0.02024172f, 
    0.00983290f, -0.04088163f, -0.01772205f, 0.02121709f, -0.05251236f, -0.02361407f, -0.01690468f, -0.01301167f, 
    0.01271405f, 0.02423639f, -0.04402852f, -0.01765550f, 0.04951178f, 0.04368576f, -0.05240534f, -0.01682389f, 
    -0.03275364f, 0.03710208f, -0.05251935f, -0.05024912f, -0.04412605f, 0.02876140f, -0.01772142f, 0.00649533f, 
    -0.02812514f, -0.03767435f, 0.03087600f, -0.02297637f, 0.00571996f, -0.01459201f, 0.04763458f, -0.04901417f, 
    -0.04925754f, -0.00752418f, -0.02103748f, -0.01424256f, -0.02882864f, 0.02156739f, -0.01874380f, -0.05834305f, 
    -0.02263290f, -0.01858943f, 0.00225395f, -0.06100252f, 0.05284682f, -0.04170907f, 0.04520626f, 0.00988294f, 
    -0.01977908f, -0.04674628f, -0.04350667f, 0.04858265f, -0.04513161f, 0.00997576f, -0.00521019f, 0.00338014f, 
    -0.02342909f, -0.02281493f, 0.01824944f, -0.04429956f, -0.01121393f, -0.06168240f, -0.00554360f, 0.04368899f, 
    0.01992979f, 0.01523787f, 0.02475087f, -0.06406146f, -0.04589723f, 0.02665101f, 0.00474426f, -0.02091153f, 
    -0.02879742f, -0.06019934f, 0.04298874f, -0.01398718f, 0.04994611f, 0.04754949f, 0.05350710f, 0.04116130f, 
    0.03563771f, 0.00552819f, -0.03189286f, -0.00732424f, 0.02106803f, 0.02932518f, 0.05209655f, 0.02284733f, 
    -0.01259306f, -0.06409431f, -0.05920571f, -0.00351125f, 0.03612545f, 0.02705618f, 0.04582198f, 0.02929031f, 
    -0.03036931f, -0.04729722f, -0.05348000f, 0.03423953f, -0.05335310f, -0.04927751f, -0.04812218f, 0.05109377f, 
    -0.05800519f, 0.01106161f, -0.05861378f, -0.01722261f, -0.00997971f, 0.01031143f, 0.03683763f, 0.01674204f, 
    0.04278325f, -0.04161187f, -0.05053856f, 0.04692227f, 0.00349877f, 0.01382453f, -0.02241859f, -0.02858054f, 
    -0.04544720f, 0.02351533f, -0.01177866f, -0.05516198f, -0.03912468f, 0.02326108f, -0.01798889f, -0.04604859f, 
    -0.01912528f, -0.02204216f, 0.04377180f, 0.00347887f, -0.00898025f, -0.03968545f, -0.03262998f, 0.01349925f, 
    0.07392334f, -0.03298348f, -0.01957621f, 0.13051194f, 0.06309326f, 0.01120326f, 0.11981339f, 0.03242036f, 
    -0.00822448f, 0.20326294f, -0.01552436f, 0.15079278f, 0.06599385f, 0.14159904f, 0.07191557f, 0.10751291f, 
    -0.04864956f, 0.07014246f, -0.11078114f, 0.44833231f, 0.02408965f, -0.09939767f, -0.13644651f, -0.04387799f, 
    0.25045553f, 0.12980160f, 0.09293988f, 0.03127583f, -0.00623111f, -0.07944164f, -0.05000483f, -0.02345937f, 
    0.04489377f, -0.02814228f, -0.06966387f, 0.08970012f, 0.06499697f, -0.02189288f, 0.13034895f, 0.20114899f, 
    0.19911182f, -0.03316794f, -0.04104578f, -0.20919263f, -0.37791979f, -0.09817482f, -0.08108649f, -0.24378623f, 
    0.04980344f, -0.09435818f, 0.02763380f, 0.12256767f, -0.00169599f, 0.05155635f, -0.10455699f, 0.10920717f, 
    0.12634286f, 0.02874942f, 0.13853994f, 0.07324333f, 0.05470853f, -0.00051865f, 0.06880910f, 0.00869176f, 
    -0.14799570f, 0.03969572f, 0.00304058f, 0.19535941f, 0.15002903f, 0.03193772f, 0.09482234f, 0.13617365f, 
    0.18264449f, 0.09844067f, 0.04472890f, 0.16477823f, 0.16213827f, -0.17890824f, 0.03588187f, -0.10835622f, 
    0.03840532f, 0.08821303f, 0.18838088f, 0.02184415f, 0.14919300f, -0.10220468f, -0.02905106f, -0.01751188f, 
    0.11093753f, 0.09221467f, 0.08303055f, 0.28688094f, 0.22992563f, 0.20267396f, -0.09242146f, 0.03467743f, 
    -0.07763450f, 0.05121200f, 0.08808184f, 0.20668411f, -0.07063675f, 0.21683729f, -0.04996324f, -0.02993012f, 
    -0.07988797f, -0.00811044f, -0.00034627f, 0.02146843f, -0.18554944f, -0.01806370f, -0.08827587f, -0.16775599f, 
    0.07483766f, -0.10494621f, 0.01457647f, -0.07650173f, -0.16949506f, -0.38694388f, -0.11007227f, 0.00472746f, 
    0.13920367f, -0.03979741f, 0.08697841f, -0.03058736f, 0.12358085f, 0.03870034f, 0.04003225f, 0.19855635f, 
    0.24456324f, 0.06927702f, 0.00051249f, -0.17544715f, -0.18131758f, -0.03268246f, -0.26043782f, 0.10152724f, 
    0.19240536f, 0.21049130f, -0.04089917f, -0.04246543f, 0.05673469f, -0.14160602f, -0.14575140f, -0.28001440f, 
    -0.17903604f, -0.12925699f, 0.26056650f, 0.00610153f, 0.06858653f, -0.11696190f, -0.03641776f, -0.03127214f, 
    0.26335862f, 0.24940348f, -0.16587092f, 0.17085211f, -0.00093288f, 0.11294688f, 0.05439999f, 0.11357406f, 
    -0.13953175f, 0.04650266f, 0.09440912f, -0.14413366f, 0.19242853f, -0.04775960f, 0.24234502f, 0.09387783f, 
    -0.01587434f, 0.06289278f, 0.03235946f, -0.18222886f, -0.25358513f, 0.20353325f, -0.04647034f, 0.08037176f, 
    -0.00975234f, -0.15927893f, -0.12595652f, -0.14196341f, -0.02925916f, 0.01214372f, -0.07754897f, -0.06678704f, 
    0.04705693f, 0.04438207f, -0.34108528f, 0.05285139f, -0.08186932f, 0.08475617f, -0.02830978f, 0.18854469f, 
    -0.13736150f, 0.01866675f, -0.07290269f, -0.05164014f, 0.04353745f, 0.08766038f, 0.14785041f, -0.10869677f, 
    0.17510410f, 0.01194301f, 0.04362130f, 0.07559851f, -0.00106840f, -0.01777304f, -0.12237955f, 0.02082467f, 
    0.07232951f, 0.15936862f, 0.02555167f, 0.16037482f, -0.01251499f, 0.02263544f, -0.01779119f, 0.09982274f, 
    0.17543057f, 0.21430141f, 0.06050804f, 0.05273414f, 0.07098506f, -0.03157949f, 0.04268471f, -0.03456618f, 
    0.12977451f, 0.26232368f, 0.10300574f, 0.05561065f, 0.07271288f, 0.05266805f, 0.08896264f, 0.13287625f, 
    0.16840652f, 0.16992629f, 0.11857926f, 0.04736734f, -0.02416084f, -0.20293094f, 0.04715099f, 0.04546221f, 
    0.03116668f, 0.05100102f, 0.07829087f, 0.01860768f, -0.21895435f, -0.14127284f, -0.10908359f, -0.12514223f, 
    -0.14433482f, 0.01824361f, -0.22328971f, 0.09652293f, -0.40418431f, 0.14198376f, 0.36247307f, -0.09744424f, 
    0.14700109f, -0.13525723f, -0.14230631f, 0.15733804f, 0.01919124f, 0.04678353f, 0.07531320f, 0.05535024f, 
    0.00962981f, -0.12695657f, 0.18112479f, 0.06620285f, -0.00819353f, -0.14443274f, -0.16296341f, 0.08552075f, 
    -0.03610322f, 0.02211370f, -0.02037190f, -0.03476062f, 0.01026491f, 0.13809179f, 0.17118025f, -0.19892456f, 
    0.25081864f, -0.04150899f, -0.14003266f, 0.00660889f, 0.01344607f, -0.22046852f, -0.39187905f, -0.40714023f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.09626709f, 0.11078724f, -0.02901447f, 0.24884525f, 0.16859590f, -0.05586392f, 0.03580600f, -0.02565161f, 
    0.04711604f, -0.06718716f, 0.09915674f, 0.04080447f, 0.03817483f, -0.01478985f, -0.00996325f, -0.02140395f, 
    0.22801176f, -0.05633119f, -0.02480529f, 0.25085887f, 0.10061548f, 0.09182796f, 0.01690246f, -0.00846329f, 
    0.04492193f, 0.12759367f, 0.14012057f, 0.07823277f, 0.14721049f, 0.03252875f, 0.01097239f, 0.01954365f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.29968220f, -0.19186307f, 0.16388023f, -0.00308827f, -0.35881531f, -0.38886783f, 0.07612561f, 0.20967454f, 
    -0.05516527f, -0.01065277f, -0.23750113f, 0.17047562f, 0.05407341f, 0.26667732f, -0.16878618f, 0.13456097f, 
    0.53934377f, 0.14892659f, 0.09792222f, 0.31726539f, -0.18836764f, 0.08583383f, -0.02974648f, 0.08277600f, 
    0.17476989f, -0.25042740f, -0.29539749f, 0.22131212f, -0.26919952f, 0.22134638f, -0.00941488f, 0.30363643f, 
    -0.57890248f, 0.13701332f, -0.07617481f, 0.01775301f, 0.22082667f, 0.06511432f, -0.21088423f, 0.14086929f, 
    -0.04039603f, 0.11208316f, 0.01714167f, -0.41005620f, -0.00293926f, -0.00655498f, 0.13766798f, -0.19383214f, 
    0.21395095f, -0.11808208f, 0.06963206f, 0.10311803f, -0.15539384f, -0.57543302f, 0.04696044f, 0.05069800f, 
    -0.23807099f, 0.11695427f, 0.47004709f, -0.21314079f, 0.25189170f, -0.03954583f, 0.00653489f, 0.29039162f, 
    -0.11774301f, 0.15893823f, -0.03955041f, 0.07906646f, 0.26038808f, -0.41918612f, -0.24384001f, -0.01719595f, 
    0.03329192f, -0.15917784f, 0.32991371f, -0.16318502f, 0.08750505f, -0.07080195f, 0.12378879f, -0.17605938f, 
    0.01192319f, -0.10573744f, -0.07518279f, 0.26434517f, 0.17268762f, -0.07867756f, 0.01352624f, 0.16316411f, 
    -0.26094735f, 0.16397008f, -0.00755855f, -0.41895592f, 0.05285795f, -0.18433388f, 0.13931091f, 0.18239832f, 
    0.14926194f, 0.00334720f, 0.17534529f, 0.17814140f, -0.08499650f, -0.03424112f, 0.17250061f, 0.23092981f, 
    -0.06358149f, -0.04863815f, 0.07956959f, -0.23416230f, 0.13575892f, 0.05561454f, -0.01844500f, 0.01654576f, 
    0.32386285f, -0.06782932f, -0.03812605f, 0.29734045f, -0.24409641f, 0.51855707f, -0.02221044f, -0.07597129f, 
    0.03548989f, 0.20269212f, -0.12621956f, 0.13734436f, 0.22312860f, -0.11557819f, 0.15296692f, -0.13246876f, 
    -0.23694786f, -0.05765548f, -0.09736091f, 0.09777642f, -0.04773013f, -0.10907713f, -0.00614156f, 0.01451846f, 
    -0.14182334f, 0.03711961f, 0.28352669f, -0.41757631f, -0.14385369f, -0.01208491f, 0.01909448f, 0.14712343f, 
    0.47104725f, 0.10534902f, -0.13283953f, -0.00045667f, -0.09650061f, -0.25115260f, 0.01911169f, 0.25710958f, 
    -0.62270957f, -0.05984434f, -0.00585990f, 0.08576959f, 0.04738254f, 0.28432512f, 0.05557983f, 0.19855702f, 
    0.23712181f, -0.10592473f, 0.01045463f, -0.20384437f, -0.43542159f, 0.13150953f, 0.29393166f, 0.25408238f, 
    0.10645386f, -0.16514494f, 0.05507388f, 0.23068738f, 0.10540845f, 0.00120355f, -0.16064174f, 0.41897464f, 
    -0.19489540f, 0.05011640f, -0.10918281f, 0.03139226f, -0.29762387f, 0.44998294f, -0.05790050f, 0.13875087f, 
    -0.72273356f, -0.01884817f, -0.24264498f, 0.11728267f, 0.10563016f, -0.09580106f, 0.06235415f, 0.30626255f, 
    0.11086328f, -0.26650628f, 0.01552447f, -0.35542890f, -0.41772139f, 0.33578631f, 0.18450947f, 0.10946129f, 
    0.10468699f, 0.12954982f, -0.00930052f, 0.08432496f, 0.06106090f, 0.24318431f, 0.07943305f, 0.07285493f, 
    -0.14211440f, 0.04492582f, -0.03904726f, -0.11493363f, 0.24681452f, 0.26139435f, 0.02365377f, 0.18473476f, 
    0.21421413f, -0.23873378f, 0.23459813f, 0.16648255f, 0.12755062f, 0.06172325f, -0.15055390f, -0.00266386f, 
    0.03387965f, -0.20462003f, 0.02214073f, -0.46130174f, 0.12518422f, -0.34891975f, -0.49230161f, -0.08223886f, 
    -0.09629267f, 0.11714139f, 0.29725549f, -0.06758197f, -0.15619993f, 0.35553187f, -0.06376182f, -0.09090201f, 
    0.40577975f, -0.04887071f, 0.12153354f, 0.27094916f, 0.20054096f, 0.22693786f, -0.03623430f, 0.18659416f, 
    0.14038038f, -0.01416106f, 0.24794382f, -0.44595513f, -0.35781538f, 0.31268764f, -0.14317422f, 0.09709604f, 
    -0.00103496f, -0.00279551f, -0.13735446f, -0.55251521f, -0.23728742f, 0.27328789f, -0.10806531f, 0.03562598f, 
    0.03894727f, -0.06460761f, -0.24340643f, 0.45751503f, 0.06167497f, 0.21701609f, 0.00207917f, -0.09256798f, 
    0.34803206f, 0.01676137f, -0.02146213f, -0.17609411f, 0.02962877f, -0.32405719f, -0.01468267f, 0.18257228f, 
    0.33763430f, 0.01058703f, 0.26683053f, 0.27675280f, -0.24559730f, 0.10505408f, 0.09017649f, 0.13194159f, 
    0.40214598f, 0.29745761f, 0.00382499f, -0.06154944f, -0.13527186f, -0.15262762f, -0.26067531f, -0.10149927f, 
    -0.03333423f, 0.07700191f, 0.05704876f, 0.25349134f, -0.15195730f, -0.43430564f, -0.02291783f, 0.51044154f, 
    -0.42034972f, 0.07565821f, 0.09516265f, 0.41552863f, -0.02301520f, 0.11465704f, 0.00710152f, 0.21362999f, 
    -0.32294661f, 0.10238576f, -0.18200772f, -0.43860936f, -0.42131037f, -0.25411341f, 0.02027685f, 0.08204954f, 
    0.26223597f, -0.21188071f, 0.17468391f, 0.12511483f, 0.13567011f, -0.02082912f, 0.13529275f, 0.09988652f, 
    0.02280151f, 0.14285088f, -0.18833458f, -0.31131282f, 0.09146743f, 0.01909390f, -0.11921358f, 0.04709836f, 
    -0.04550410f, -0.09060550f, 0.16319723f, -0.16749325f, 0.08649388f, 0.14508514f, -0.16111796f, 0.06787813f, 
    -0.24937461f, 0.10555978f, 0.07776722f, -0.19165829f, 0.21796240f, -0.18727195f, 0.00779731f, -0.11278746f, 
    0.02509955f, 0.05065338f, -0.16903672f, -0.24899805f, -0.23514923f, 0.29935119f, -0.10008845f, -0.09902436f, 
    -0.02463005f, -0.03291521f, -0.40135008f, 0.52760720f, 0.11175346f, -0.24592049f, 0.12761596f, -0.26127711f, 
    -0.18861935f, -0.01139498f, -0.14205652f, -0.00608928f, -0.15731408f, 0.30711994f, 0.16544341f, 0.11070642f, 
    0.45589221f, -0.06628232f, 0.08892282f, -0.11660822f, 0.17355852f, -0.26723355f, 0.08182830f, 0.11897161f, 
    -0.11531039f, 0.34759298f, -0.13444778f, -0.09758371f, 0.09849785f, 0.17086411f, 0.13922645f, -0.32099858f, 
    -0.11682836f, -0.06467701f, -0.00679695f, -0.03774953f, -0.04886071f, -0.00558500f, -0.15843411f, -0.13521051f, 
    -0.04230126f, 0.16752386f, 0.03316154f, 0.06215331f, 0.13999818f, -0.33007857f, -0.06883676f, -0.22924922f, 
    0.39729419f, 0.29219121f, 0.11466339f, 0.23173285f, 0.18339305f, -0.15650597f, -0.06803039f, -0.08219299f, 
    -0.07897920f, 0.13505134f, -0.01349111f, 0.42063177f, -0.05811053f, -0.32866576f, 0.21464917f, 0.14462546f, 
    -0.04841958f, -0.16762441f, 0.15960971f, -0.20530643f, 0.06122266f, 0.06362804f, -0.12671031f, 0.00855889f, 
    -0.20357804f, 0.01044091f, 0.11326326f, -0.06200860f, -0.00965456f, 0.06230629f, 0.03504319f, -0.07095075f, 
    0.22687563f, 0.26928279f, 0.20894626f, -0.26888412f, 0.33326605f, -0.02201836f, 0.06878071f, -0.12479047f, 
    -0.17927895f, -0.16016078f, -0.04343733f, -0.27787170f, -0.33210683f, -0.18151282f, 0.17613018f, 0.28230232f, 
    -0.07140824f, 0.11908378f, -0.12971260f, 0.09372427f, -0.02200098f, 0.74869299f, 0.15660216f, -0.23034835f, 
    0.25016418f, -0.11163559f, 0.11343317f, 0.18716134f, 0.11547098f, 0.36126676f, 0.09778778f, -0.00351530f, 
    -0.06381815f, 0.05676754f, 0.33956167f, 0.19209035f, 0.01870148f, 0.14537837f, 0.03562787f, 0.27251863f, 
    0.04847316f, 0.24804598f, -0.02810566f, -0.18763065f, -0.46061742f, 0.47676000f, -0.30408037f, 0.32116345f, 
    0.01349913f, 0.08160201f, -0.33932683f, -0.30376300f, -0.00545280f, 0.45256677f, 0.09576753f, 0.02575499f, 
    -0.53038061f, -0.16925502f, 0.08856091f, -0.05512972f, 0.07133398f, 0.10436738f, 0.16931060f, 0.00153560f, 
    0.01265938f, -0.14701918f, 0.42177159f, 0.21546797f, 0.17567016f, -0.21955577f, -0.05155416f, 0.17031297f, 
    0.26925880f, -0.09407008f, 0.04644960f, -0.03563000f, -0.18964174f, -0.45604953f, 0.01297897f, 0.20955549f, 
    0.15574366f, -0.07055360f, -0.18500382f, 0.23783503f, 0.00338253f, 0.00162561f, 0.09398768f, 0.09367694f, 
    0.59161693f, 0.02139475f, -0.00285448f, 0.15480484f, -0.39185730f, 0.17227143f, -0.16754119f, 0.17128250f, 
    -0.08568007f, -0.38955268f, -0.24531211f, 0.31836000f, -0.34657079f, 0.13218410f, 0.00335324f, 0.29782987f, 
    0.20635340f, 0.22410986f, -0.10341547f, 0.61569369f, -0.02138864f, -0.49358809f, 0.14934947f, -0.10570757f, 
    0.06897400f, 0.05621462f, 0.20123100f, 0.16457692f, -0.16409397f, -0.37623918f, -0.00675625f, 0.24592197f, 
    0.16351175f, 0.16985345f, 0.12287353f, 0.08882026f, -0.23882073f, -0.19257112f, 0.14140825f, 0.14880019f, 
    -0.41428488f, 0.12126325f, -0.03610622f, -0.03831096f, 0.11169246f, -0.07117431f, -0.13434628f, 0.01231476f, 
    0.10302139f, 0.03599729f, 0.01236100f, 0.21571861f, 0.10989911f, 0.10065407f, 0.18250324f, 0.30099252f, 
    -0.07751643f, 0.13166915f, -0.05951846f, -0.17052478f, 0.02456059f, 0.41322431f, 0.03496653f, -0.06431494f, 
    0.21582091f, 0.16410196f, 0.15876757f, -0.04249314f, -0.25709739f, -0.14076942f, 0.14741091f, -0.15059453f, 
    0.13635439f, -0.04771072f, 0.08938682f, 0.26942548f, 0.38183489f, -0.35001576f, -0.07736702f, -0.03708556f, 
    0.27160603f, 0.22516879f, 0.10875449f, -0.12812173f, 0.19225702f, -0.02324818f, 0.01345849f, -0.14019397f, 
    0.13104658f, -0.17493008f, 0.14981203f, -0.22333005f, 0.12526050f, -0.75229901f, 0.00670346f, -0.26141316f, 
    -0.07611266f, 0.13609914f, 0.14231239f, 0.17421857f, 0.24680576f, -0.04385530f, 0.05370599f, -0.10689468f, 
    0.31300887f, -0.11564869f, 0.01603229f, 0.31381279f, -0.06915981f, 0.20873597f, 0.13573989f, -0.27932161f, 
    0.24791354f, 0.28580549f, 0.14132163f, 0.42832786f, 0.26843631f, -0.34155503f, 0.00084169f, -0.06702731f, 
    0.00238671f, -0.16514206f, 0.32044452f, -0.13885377f, -0.03843172f, -0.17051926f, -0.03636095f, -0.03886579f, 
    -0.03972329f, -0.02615101f, 0.04910934f, -0.02580221f, -0.28443879f, 0.19205830f, 0.07455620f, 0.00012604f, 
    -0.03142294f, -0.10022958f, -0.05785415f, 0.15896367f, 0.16320741f, -0.27401507f, 0.11386038f, 0.19215304f, 
    0.08368470f, -0.07020835f, 0.12515418f, -0.08230262f, -0.11717708f, -0.07459861f, -0.18513981f, 0.03144449f, 
    0.14019351f, 0.00648627f, -0.03244786f, -0.15197429f, -0.17452860f, -0.16752741f, -0.10033023f, 0.02459137f, 
    0.15102278f, 0.04601315f, 0.16262507f, -0.05026386f, -0.00663105f, 0.11989392f, 0.16812710f, -0.16056316f, 
    0.00006987f, 0.06530777f, 0.09788901f, 0.05233592f, -0.14148326f, 0.03107377f, 0.12392503f, 0.16462089f, 
    -0.33622679f, -0.06849100f, 0.03498643f, 0.02566817f, 0.16876283f, -0.09147302f, 0.14909688f, 0.01278646f, 
    0.14827000f, -0.08057816f, -0.07232098f, -0.17951459f, -0.17328429f, 0.36885977f, -0.07307667f, -0.32585379f, 
    -0.24772406f, -0.09667652f, -0.02155597f, 0.05482708f, -0.13025849f, 0.03713863f, -0.02966891f, 0.04273520f, 
    0.43758011f, 0.20218617f, 0.45828763f, -0.07472496f, 0.37848097f, -0.18943647f, -0.11463647f, -0.00540808f, 
    0.11251467f, 0.05888406f, -0.08634488f, -0.25491408f, 0.05575684f, -0.16545473f, 0.04586497f, -0.31730267f, 
    -0.05183719f, -0.01625779f, 0.09315830f, 0.54957283f, 0.15065251f, -0.21018812f, -0.00366806f, -0.07749101f, 
    -0.24283065f, -0.09056515f, 0.00040777f, 0.33038026f, 0.28590527f, 0.19514273f, -0.05731165f, 0.01846030f, 
    0.48771256f, -0.03823229f, -0.12733516f, -0.18058099f, -0.14217901f, 0.14901167f, -0.00440517f, -0.05601891f, 
    0.00000878f, 0.11793907f, 0.07505727f, -0.14730246f, -0.12051850f, -0.22616634f, 0.12211982f, -0.21487528f, 
    -0.11051305f, 0.01704571f, 0.19576572f, 0.31239229f, -0.07208619f, -0.01174533f, 0.06135854f, -0.47467825f, 
    -0.03445353f, 0.10105492f, 0.17186031f, 0.22992148f, 0.12464385f, 0.42031914f, -0.06687152f, -0.15216848f, 
    0.60850328f, 0.21630870f, 0.01638171f, 0.02595520f, -0.09880458f, 0.11941799f, -0.12063956f, -0.12300871f, 
    0.24888684f, -0.03022210f, 0.09830955f, -0.01814548f, -0.19447798f, 0.04598674f, 0.20083939f, 0.19576514f, 
    -0.16404082f, 0.08684470f, 0.03775295f, -0.01138284f, -0.07206947f, 0.29438481f, 0.14874139f, 0.05028311f, 
    -0.05813139f, 0.13011664f, 0.02278991f, -0.17014812f, 0.16356818f, 0.27968660f, -0.16264157f, -0.00795947f, 
    0.00080940f, -0.07234970f, -0.03759169f, 0.41002303f, -0.12176751f, -0.06791072f, -0.00378675f, 0.00600786f, 
    -0.07227483f, -0.09420101f, -0.03804617f, -0.15114947f, -0.12926227f, -0.12618762f, -0.23508379f, 0.11976712f, 
    -0.03062426f, 0.08639466f, -0.11785294f, 0.34400317f, 0.11151813f, 0.01126016f, -0.07115250f, -0.24125633f, 
    0.36722574f, -0.13862935f, -0.11912460f, 0.30627856f, 0.20039438f, -0.22761394f, -0.11141124f, 0.31707644f, 
    -0.03508087f, -0.02309570f, 0.01200763f, -0.43895978f, -0.25524008f, 0.29633221f, -0.05381205f, 0.31911647f, 
    0.22274056f, 0.20184959f, -0.15120111f, 0.13877639f, -0.29764119f, 0.15577517f, 0.16149840f, -0.19917972f, 
    0.11454441f, -0.01461910f, 0.12085368f, 0.37143397f, -0.08491778f, -0.02089449f, 0.03111448f, -0.05369061f, 
    -0.61276209f, -0.06839304f, -0.01279639f, -0.03511701f, -0.00941441f, 0.47095460f, 0.12270796f, -0.19129016f, 
    0.28379047f, 0.18078396f, 0.14631690f, -0.38146996f, 0.32004043f, -0.55734760f, 0.12144415f, -0.06185819f, 
    0.15414564f, -0.17861037f, -0.05038012f, 0.24946178f, 0.13148171f, -0.12646189f, 0.12612244f, 0.20449331f, 
    0.15222445f, 0.11671392f, 0.14272836f, -0.06562230f, -0.15928584f, 0.32657292f, -0.12456136f, -0.30656058f, 
    0.04431549f, -0.16618331f, 0.04452100f, 0.15521729f, 0.13953462f, 0.06733489f, -0.11605775f, -0.23633626f, 
    0.38412791f, -0.04904881f, 0.12673198f, 0.38870153f, 0.32689074f, 0.00920743f, 0.15783764f, 0.14380521f, 
    -0.24869634f, 0.00721544f, -0.05064854f, 0.21122615f, -0.00337883f, -0.08705384f, 0.06819277f, -0.04613500f, 
    -0.12911154f, 0.10401142f, -0.10127234f, 0.72331941f, -0.00824996f, -0.32185316f, -0.04171979f, 0.18962960f, 
    0.04684516f, -0.00713246f, -0.10170393f, -0.04315905f, -0.22805838f, -0.42054513f, 0.13755547f, 0.27679396f, 
    0.12306087f, -0.22453067f, -0.19716521f, -0.00840765f, 0.01489147f, 0.26393038f, -0.11319724f, 0.19581699f, 
    0.03104276f, -0.03860037f, -0.17774710f, 0.08839826f, 0.10005494f, -0.12549002f, -0.09740730f, -0.11449343f, 
    0.12950937f, -0.07541383f, 0.07789010f, 0.08739198f, 0.14944504f, 0.08144867f, -0.14773820f, 0.02082043f, 
    -0.15881039f, 0.15649535f, 0.06569339f, -0.12492830f, -0.18091041f, 0.06727329f, -0.01229689f, -0.18599571f, 
    -0.00155072f, -0.14807631f, -0.00708590f, -0.12207176f, 0.08979398f, -0.04663790f, 0.12199575f, -0.01613104f, 
    -0.03381177f, 0.23653612f, -0.13399865f, -0.26221535f, 0.02857869f, 0.19829667f, -0.09751581f, -0.07325799f, 
    0.11735168f, -0.10485466f, 0.00630130f, -0.01882443f, -0.03245467f, 0.12111592f, -0.06966902f, -0.22657013f, 
    -0.10835833f, -0.14571230f, -0.01406141f, 0.27327698f, 0.16214944f, 0.00688015f, 0.13660878f, -0.04830399f, 
    0.20095344f, -0.00744963f, 0.37024015f, -0.07662971f, 0.02872232f, -0.19020081f, 0.08203616f, -0.05770909f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.15802374f, 0.15482494f, 0.09739901f, 0.02962427f, -0.09966666f, 0.08404465f, -0.05877160f, -0.06496551f, 
    0.01587930f, 0.12853557f, -0.14314902f, -0.04805657f, 0.00607332f, 0.14637710f, 0.12449612f, -0.05253515f, 
    0.18079799f, 0.17905667f, 0.13775973f, -0.20667277f, 0.19717784f, -0.07256850f, 0.03129916f, 0.10952717f, 
    0.25532922f, -0.07957951f, 0.26409930f, 0.10571837f, -0.08481843f, -0.02750107f, 0.15579849f, 0.05338501f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.29075333f, -0.20417652f, 0.24499966f, 0.05098816f, -0.20998371f, 0.42861271f, -0.03265733f, -0.09840171f, 
    -0.30656317f, 0.37469360f, 0.10398681f, 0.01309358f, -0.01376097f, -0.12162533f, 0.09080634f, 0.07665951f, 
    -0.23407312f, -0.09455378f, -0.20749934f, 0.05433589f, 0.26328614f, -0.13948952f, -0.09685636f, 0.05618499f, 
    -0.13029513f, 0.08477824f, -0.06666223f, 0.50082690f, -0.30949074f, -0.26050285f, -0.09103312f, 0.16243534f, 
    -0.56165767f, 0.22350165f, 0.33130792f, 0.03054985f, 0.12906273f, 0.01862971f, 0.22247797f, 0.23750980f, 
    -0.12825644f, 0.02092935f, 0.23904569f, 0.02669361f, 0.15814497f, 0.20159042f, 0.32493201f, 0.59960276f, 
    -0.53596562f, 0.04287463f, 0.33259368f, -0.07468697f, -0.08977828f, 0.00584048f, 0.30801761f, -0.03775446f, 
    -0.00595990f, 0.07225407f, -0.07252822f, -0.14224198f, 0.04456793f, -0.53683156f, 0.00584925f, 0.21340968f, 
    0.20878756f, -0.30887550f, -0.14287575f, 0.31730142f, 0.09506288f, 0.23454979f, -0.24951416f, -0.87939823f, 
    -0.68690729f, 0.17975165f, 0.06309216f, -0.05734830f, -0.02366978f, 0.15026285f, -0.15635362f, 0.23917986f, 
    0.24161737f, 0.14778754f, 0.32537445f, -0.03423289f, 0.25380656f, 0.14393361f, -0.13539936f, -0.13170525f, 
    -0.11526140f, 0.06521141f, -0.33302173f, 0.23685202f, 0.21155091f, -0.02220209f, -0.08575837f, -0.21441904f, 
    0.47838685f, 0.08742377f, 0.28975290f, 0.27913463f, 0.35872287f, 0.50270611f, -0.23782666f, 0.20596798f, 
    -0.29014936f, 0.42353177f, -0.11852010f, 0.00727850f, -0.21440859f, -0.09792287f, 0.24671794f, -0.24996649f, 
    0.34227824f, 0.28117451f, -0.32754433f, -0.52616000f, 0.15008521f, 0.14470033f, -0.26796153f, -0.06860611f, 
    0.03206883f, -0.34582204f, 0.12519033f, -0.10803923f, -0.37559170f, 0.13479742f, -0.11088696f, -0.14860554f, 
    0.41597804f, 0.07675387f, 0.16695546f, -0.17084610f, 0.45161641f, 0.22160162f, -0.31329814f, 0.21097413f, 
    -0.16643383f, 0.15311946f, -0.14722057f, -0.04278921f, -0.68139803f, -0.07022098f, -0.01571436f, -0.33586323f, 
    0.74135011f, 0.31912100f, 0.00887637f, -0.33028191f, 0.06169194f, 0.11055855f, -0.39755386f, -0.12062225f, 
    -0.18176742f, -0.23655011f, 0.41645113f, -0.52440667f, -0.39215410f, 0.68879318f, -0.13671350f, -0.19164343f, 
    0.29540843f, -0.31140837f, -0.05366488f, 0.14637724f, 0.15348877f, 0.55668885f, 0.07485044f, -0.78873664f, 
    -0.06879652f, -0.15652208f, 0.01718952f, -0.10703650f, -0.05543660f, 0.20846611f, 0.24148944f, -0.30792683f, 
    0.38422847f, 0.15868032f, 0.13179153f, 0.14495108f, 0.15430833f, 0.03707465f, 0.12561837f, -0.17772920f, 
    -0.15372342f, 0.15555917f, -0.10699095f, -0.00990239f, 0.08366586f, 0.19291942f, 0.10315852f, -0.39711356f, 
    0.23673888f, -0.25334230f, -0.12330887f, -0.04668872f, -0.30924341f, 0.25104192f, 0.10101493f, 0.27028012f, 
    0.05863086f, 0.30056944f, -0.06616697f, 0.43351716f, -0.41325009f, -0.25964096f, -0.00779180f, 0.29575923f, 
    -0.03791909f, -0.30732358f, -0.23939267f, -0.17495808f, -0.10122658f, 0.07541981f, -0.06803244f, 0.32968709f, 
    0.07757159f, 0.11108297f, 0.26868948f, 0.11920346f, -0.12487251f, 0.10290606f, 0.12744035f, 0.13535899f, 
    -0.11069818f, 0.12141607f, 0.11328417f, 0.20214815f, 0.13629647f, -0.41892019f, -0.23313162f, -0.00698023f, 
    0.02635103f, 0.10147011f, 0.10086308f, 0.14893408f, 0.18554227f, -0.06083096f, -0.42623591f, -0.34160885f, 
    -0.11456560f, 0.17354813f, -0.05392121f, 0.13198388f, 0.24502128f, 0.05666374f, -0.13180143f, 0.05366145f, 
    -0.10890566f, -0.25292215f, 0.18703648f, 0.14753316f, 0.09342276f, -0.02930780f, -0.15754710f, 0.17732190f, 
    0.14889638f, -0.06752372f, -0.38657883f, 0.08187577f, -0.12922938f, 0.26228449f, 0.15585172f, 0.05266982f, 
    0.38844958f, 0.05564765f, 0.03268284f, 0.30157816f, -0.17351983f, -0.28036007f, 0.04321922f, 0.35829410f, 
    0.12329102f, -0.09022136f, 0.00412650f, -0.00574001f, -0.14291333f, -0.08221573f, -0.33209246f, 0.10124781f, 
    0.15504494f, 0.17324917f, 0.05113624f, 0.25736415f, -0.32126755f, 0.08754872f, 0.09303421f, 0.04120471f, 
    -0.07740553f, -0.16377118f, -0.09278572f, -0.12812032f, -0.08168940f, 0.18040952f, 0.44188040f, -0.03063739f, 
    0.47713491f, 0.06339486f, 0.17032261f, 0.49318367f, -0.13254057f, -0.06801478f, 0.40450603f, 0.02556122f, 
    0.04156997f, 0.10227550f, -0.27370355f, -0.22437429f, -0.26606065f, -0.03045107f, 0.14661832f, 0.25372860f, 
    -0.03275898f, 0.09008280f, 0.25503540f, 0.26329860f, -0.34429741f, 0.23578246f, 0.13670219f, 0.10801408f, 
    0.19298922f, 0.12225542f, -0.07521484f, 0.20797682f, 0.28837466f, -0.01934783f, 0.02842652f, 0.12716602f, 
    0.10635516f, -0.22079606f, -0.22406507f, 0.02305015f, -0.19205140f, 0.08146723f, 0.28234419f, -0.13739748f, 
    0.26593632f, -0.04563337f, 0.33215711f, 0.01498284f, 0.17631871f, -0.07304709f, 0.11466883f, -0.05823772f, 
    0.27715898f, 0.13985643f, 0.01015461f, -0.27398777f, 0.45824516f, -0.17791308f, -0.15329833f, 0.00643904f, 
    0.16761683f, -0.06205563f, -0.10962109f, 0.05108783f, -0.00663413f, 0.07737643f, 0.03908874f, -0.17681774f, 
    -0.03916724f, 0.34318075f, -0.35208783f, 0.27382854f, 0.30030078f, -0.22530393f, -0.29926193f, -0.17157708f, 
    0.54377598f, 0.06170364f, 0.14024007f, 0.10899257f, 0.22984447f, 0.08935574f, -0.24787530f, 0.07318397f, 
    0.08848345f, -0.17621474f, -0.04924789f, -0.08392451f, -0.23753862f, 0.38434693f, -0.15641531f, -0.13352782f, 
    0.24452077f, -0.34112117f, -0.00605262f, 0.25474152f, -0.19273405f, 0.38273680f, -0.10711401f, -0.82113600f, 
    -0.53857386f, 0.18612503f, -0.13755248f, 0.16504452f, -0.41074732f, 0.21266888f, -0.28092456f, 0.07609539f, 
    0.16210225f, 0.21998197f, 0.16491716f, -0.26539198f, 0.29551938f, 0.14419407f, -0.12770708f, -0.19279808f, 
    -0.04481775f, 0.13609436f, -0.23240151f, 0.44993794f, -0.13447848f, 0.06612640f, 0.16182245f, -0.22874725f, 
    -0.32646769f, 0.15337113f, 0.39296973f, 0.23806937f, 0.03506199f, -0.17660238f, -0.37201634f, 0.26974088f, 
    -0.15309478f, 0.25948349f, 0.02751259f, -0.31074703f, -0.04846376f, 0.12485570f, -0.22052164f, 0.07349953f, 
    -0.36486250f, 0.13843334f, 0.12974717f, 0.13830177f, 0.22986770f, 0.08430606f, 0.24712735f, 0.00648602f, 
    0.21140788f, -0.17233133f, -0.13636395f, 0.10634845f, 0.04751663f, -0.30458146f, -0.03169977f, 0.04988410f, 
    -0.03543579f, -0.11828193f, 0.05596559f, 0.00361111f, -0.04465009f, -0.10435317f, -0.18097414f, 0.11091918f, 
    0.05730290f, -0.09626026f, 0.02469592f, 0.05761030f, 0.03654474f, -0.09824204f, 0.01135775f, -0.14827105f, 
    0.10918512f, -0.14984721f, -0.19028006f, 0.06391606f, 0.01223888f, -0.01611289f, 0.14685398f, -0.14457987f, 
    -0.18796165f, -0.17830271f, 0.07067016f, 0.06448839f, -0.02837131f, -0.04228183f, 0.07419135f, -0.01700230f, 
    0.05913575f, 0.17955662f, 0.15307379f, -0.41202629f, 0.13669905f, 0.42542747f, 0.38546222f, 0.08533239f, 
    0.38648316f, 0.25814599f, -0.48289058f, 0.06221326f, -0.71340144f, -0.55517340f, 0.03553589f, 0.39274269f, 
    0.16977000f, -0.14889587f, -0.26254413f, 0.03098682f, -0.25484437f, -0.13240941f, -0.14639406f, -0.44610611f, 
    -0.77186358f, -0.22233464f, 0.28277725f, -0.46638459f, -0.65915233f, 0.19705816f, 0.17806032f, 0.04342671f, 
    0.52427799f, -0.16432206f, -0.04804481f, 0.32570860f, -0.08130968f, 0.25975621f, 0.15435369f, 0.23563600f, 
    0.06524471f, -0.22415550f, 0.43189991f, 0.14731288f, -0.23333566f, 0.19424181f, 0.41709155f, -0.37745216f, 
    0.36347032f, 0.13267861f, 0.02138429f, -0.24798526f, -0.00081542f, -0.15733491f, 0.23943205f, 0.24856642f, 
    0.22891006f, 0.00714716f, 0.22940129f, 0.14963408f, 0.38713643f, 0.00033086f, -0.10354166f, -0.14176822f, 
    -0.06172220f, 0.11134425f, 0.04328468f, -0.13513558f, -0.11361392f, 0.08169313f, 0.02255235f, -0.08011054f, 
    0.08330616f, -0.05706455f, 0.01304767f, 0.01072353f, -0.05888808f, -0.16287321f, 0.11724814f, -0.05567129f, 
    -0.11316359f, -0.08905749f, -0.12161922f, 0.04202190f, 0.05885790f, -0.18096206f, -0.03533092f, -0.14775187f, 
    -0.12223370f, -0.16888204f, -0.15549959f, -0.15037408f, -0.01014405f, 0.06520768f, 0.00094991f, -0.13068637f, 
    -0.06675526f, -0.03767730f, 0.05190505f, -0.24428850f, 0.04532812f, 0.06497212f, -0.25038069f, 0.01437388f, 
    0.06576643f, -0.10875184f, 0.08453713f, -0.01187316f, 0.05619270f, -0.16326268f, -0.11504402f, -0.09075751f, 
    -0.09221433f, -0.20496310f, 0.08203615f, -0.01815795f, -0.06974611f, 0.15573086f, 0.10009880f, 0.02464200f, 
    -0.11466739f, 0.07711191f, -0.17658031f, -0.06499001f, -0.12284580f, -0.18808427f, 0.03625662f, -0.00216775f, 
    -0.20183432f, 0.44268838f, -0.00185516f, 0.12836793f, 0.34010237f, 0.02643447f, 0.03778051f, 0.12677222f, 
    0.20475742f, -0.06940311f, 0.19668739f, -0.01235423f, 0.15389015f, 0.04909920f, 0.16885406f, 0.34240547f, 
    -0.38115889f, -0.01627873f, 0.08708984f, 0.10170978f, -0.20206442f, 0.12626283f, 0.07118621f, -0.26049340f, 
    -0.24926154f, 0.19765115f, -0.01722005f, -0.03965165f, -0.16959663f, 0.09424884f, -0.17668523f, -0.05589886f, 
    0.17269754f, 0.01121822f, 0.24732906f, -0.11528654f, 0.26452002f, -0.15810856f, -0.17420271f, -0.06358411f, 
    0.06663004f, 0.31805837f, 0.01224722f, -0.21030626f, 0.05374225f, 0.09989861f, -0.15066804f, -0.06730672f, 
    0.14517765f, 0.39385888f, -0.25231591f, 0.12645613f, 0.11648247f, -0.01424608f, -0.12188434f, 0.32829690f, 
    -0.04306437f, -0.12030277f, 0.28104392f, -0.27173993f, -0.02144318f, 0.40677226f, -0.04899393f, 0.03538717f, 
    0.67422658f, 0.01019527f, 0.06998017f, 0.08074750f, 0.06486382f, 0.29665622f, 0.38043749f, 0.42758074f, 
    0.38658273f, 0.08314636f, -0.06798134f, -0.06390268f, -0.12270721f, -0.32271495f, 0.21855527f, 0.38137284f, 
    0.44781926f, -0.18516703f, 0.14644246f, 0.14684673f, -0.07698736f, 0.10746694f, 0.00629224f, -0.17096946f, 
    -0.23455815f, 0.32264909f, 0.21917115f, -0.46536654f, 0.13207504f, -0.12487332f, 0.15374221f, 0.01345762f, 
    0.02377949f, 0.46135932f, 0.19614644f, -0.21911517f, -0.20558108f, -0.45662409f, 0.03683108f, -0.00740088f, 
    0.31675637f, -0.19093175f, -0.02663907f, 0.45922408f, 0.29422039f, 0.24340491f, 0.26990426f, 0.26990390f, 
    -0.41291952f, -0.22422953f, 0.37838766f, -0.11238135f, -0.13806137f, 0.04747167f, 0.59799296f, 0.11861905f, 
    0.24693316f, -0.21715182f, 0.34389913f, 0.07624363f, 0.14223269f, 0.35199925f, 0.01513917f, 0.32533437f, 
    -0.07141589f, -0.17316729f, 0.12865336f, -0.06644177f, -0.29381943f, -0.00682646f, -0.08789167f, 0.29754323f, 
    0.02418945f, 0.24621940f, -0.10499229f, 0.26925790f, -0.08613011f, 0.05217414f, 0.15302804f, -0.12711084f, 
    -0.15757561f, 0.18366772f, -0.17308767f, 0.12731487f, 0.10940207f, 0.02718748f, -0.16996725f, 0.49512079f, 
    0.33482283f, -0.13812180f, -0.02060224f, 0.05892360f, -0.21898755f, 0.13566302f, -0.17058297f, 0.15111732f, 
    -0.16150202f, -0.01543819f, -0.06207559f, -0.14070632f, 0.02620058f, 0.14145204f, -0.01553489f, 0.14253831f, 
    0.07882095f, -0.04112746f, -0.02528675f, -0.17001346f, -0.01313316f, -0.10114500f, -0.01552672f, -0.20455092f, 
    -0.04264298f, -0.19036055f, -0.00886854f, -0.05646755f, 0.12363407f, 0.14066005f, -0.03412434f, 0.11823888f, 
    -0.18497856f, -0.07731960f, -0.02294228f, -0.04672370f, -0.05181434f, 0.02976048f, -0.15149668f, -0.19704598f, 
    -0.20481826f, -0.23918353f, 0.38546851f, -0.08783022f, -0.31509885f, 0.12263526f, -0.03132423f, 0.30738670f, 
    -0.33811066f, 0.21955577f, -0.03152740f, -0.06370579f, -0.39385182f, 0.11643564f, 0.10291397f, 0.00368345f, 
    -0.17455688f, 0.05869081f, -0.00350418f, -0.10047147f, 0.12526642f, 0.07295609f, 0.14948265f, 0.18862827f, 
    -0.03732585f, 0.03757856f, 0.20752814f, 0.35745627f, 0.09565259f, -0.28258577f, 0.08694694f, 0.26166147f, 
    0.22052062f, -0.04132818f, 0.39806575f, 0.08696411f, -0.04138553f, -0.07343198f, -0.20152572f, 0.30112991f, 
    0.08673530f, 0.45701745f, -0.02976467f, -0.04024768f, 0.00895105f, 0.09981792f, -0.11971723f, -0.42119882f, 
    0.13352187f, 0.17707874f, -0.28989762f, -0.06916067f, 0.07368731f, 0.02803875f, 0.07717010f, 0.24883235f, 
    0.12611930f, -0.35535890f, 0.09297257f, 0.13752194f, -0.22452357f, 0.51012868f, 0.07998220f, -0.15142119f, 
    -0.49589494f, 0.58119011f, 0.41834879f, 0.22100995f, 0.23342560f, 0.18965280f, -0.13210604f, -0.01107952f, 
    -0.21809916f, 0.04625309f, 0.39727089f, 0.13496464f, 0.02499088f, 0.39956832f, -0.00657596f, -0.09795465f, 
    -0.38459590f, 0.11127634f, 0.07684442f, -0.49328133f, 0.04019110f, -0.00967264f, 0.35053006f, -0.25972953f, 
    -0.05820601f, -0.26154211f, 0.25055119f, 0.12738095f, -0.18023826f, -0.17676982f, -0.00120234f, 0.15713874f, 
    -0.30930856f, -0.14219385f, 0.09522607f, 0.01015721f, -0.05894120f, 0.08178943f, -0.06883203f, -0.23482580f, 
    -0.10131874f, 0.30305511f, -0.09416062f, 0.19924033f, 0.25726691f, 0.05504991f, -0.37736040f, 0.31483829f, 
    -0.25534099f, 0.14317331f, 0.20407271f, 0.11002489f, 0.08097623f, -0.02893466f, -0.20247120f, 0.24395353f, 
    0.08787128f, -0.09787143f, -0.09328494f, 0.72109669f, -0.08187943f, -0.32094613f, -0.03606677f, 0.37084889f, 
    0.17369543f, -0.28112444f, -0.22309515f, 0.23730165f, 0.07811797f, 0.29503947f, 0.33836716f, 0.40935600f, 
    -0.08305091f, 0.22854188f, -0.16837144f, -0.13108315f, -0.13992760f, -0.03033144f, 0.19920854f, 0.16610749f, 
    0.10640573f, -0.04087005f, -0.06259557f, -0.16681351f, -0.04559180f, -0.03488254f, -0.30296335f, -0.07686041f, 
    0.28358936f, -0.03667583f, 0.00153605f, 0.12317115f, 0.07891029f, -0.32391530f, -0.03702364f, 0.03070609f, 
    -0.44235584f, 0.28930122f, 0.16191736f, -0.02959803f, -0.21325120f, -0.12670164f, -0.08506300f, 0.06215258f, 
    -0.00765764f, -0.07842848f, 0.10301986f, -0.18496957f, -0.15632549f, 0.24142541f, 0.12440084f, 0.07671563f, 
    -0.38750872f, 0.15909044f, 0.16583614f, -0.04649636f, 0.12479313f, -0.15548052f, 0.26527253f, -0.13531795f, 
    -0.12767664f, -0.18469991f, -0.02654224f, 0.05866179f, 0.13774380f, -0.11507258f, 0.01949425f, 0.27190819f, 
    -0.32645604f, 0.37518811f, 0.02533905f, -0.01698437f, -0.11763202f, 0.14468396f, -0.21426865f, -0.27636307f, 
    0.01529314f, 0.06782938f, -0.29325256f, 0.09596529f, 0.37838840f, 0.14738981f, -0.02278947f, 0.21439923f, 
    0.02627259f, 0.29021543f, 0.29357541f, -0.35665187f, 0.36670068f, 0.12719485f, 0.26199833f, -0.30759695f, 
    -0.19045764f, -0.04317465f, -0.11609553f, 0.32247201f, -0.05715226f, 0.11410184f, -0.15664408f, 0.01028233f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.09870975f, -0.01250800f, 0.02593211f, 0.15552683f, 0.28309110f, -0.12358222f, -0.08942893f, 0.04069947f, 
    0.13374256f, 0.21963280f, 0.13801190f, 0.12277041f, 0.17747180f, 0.30240843f, -0.12204982f, -0.04919535f, 
    0.18966430f, -0.10044595f, -0.19753051f, -0.16190639f, 0.41242003f, 0.11478014f, 0.22628225f, 0.01369120f, 
    -0.04774115f, 0.06192207f, 0.30353737f, 0.34206477f, 0.17733675f, -0.10201567f, 0.32527459f, 0.11963440f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.59658784f, 0.06723985f, -0.41615853f, -0.54136068f, -0.45077989f, -0.15739834f, 0.25350395f, -0.06542505f, 
    0.20799489f, 0.13615733f, 0.06947964f, -0.01690169f, -0.18645522f, -0.26936641f, -0.12043441f, 0.38992760f, 
    -0.16220306f, -0.17263977f, -0.01953839f, 0.26745439f, -0.55407417f, 0.22268288f, 0.19643416f, -0.48574835f, 
    -0.14783059f, -0.03568476f, -0.73868251f, -0.15927270f, -0.09274793f, -0.02531443f, -0.08360305f, 0.09760024f, 
    -0.00634180f, 0.27833962f, 0.19254340f, -0.30350867f, -0.46098670f, 0.24226522f, -0.37489289f, -0.18126453f, 
    -0.25670213f, -0.09166051f, 0.03394870f, -0.19711833f, 0.38811332f, 0.10168343f, 0.04706419f, -0.70935708f, 
    0.04661369f, 0.00639505f, -0.11310223f, 0.15603405f, -0.11034154f, -0.31702062f, 0.40570402f, -0.20323780f, 
    -0.07851174f, 0.05177725f, -0.27657649f, 0.46948975f, 0.04626133f, -0.10592584f, 0.26379183f, 0.41450778f, 
    -0.42069474f, -0.22565480f, -0.52616680f, 0.29443455f, 0.53122109f, -0.30500296f, -0.77239084f, 0.20802872f, 
    -0.46536726f, -0.31960481f, 0.13103919f, 0.20095743f, -0.64012504f, 0.01900384f, -0.09570941f, 0.10599689f, 
    -0.01623997f, -0.10439038f, -0.11186772f, 0.16714402f, 0.32279584f, -0.17892319f, -0.19504520f, -0.20668569f, 
    0.04408707f, -0.00668991f, 0.27422392f, 0.28405994f, -0.16714256f, -0.14935245f, -0.21261239f, 0.06017624f, 
    0.11783800f, 0.06180102f, -0.33351937f, 0.04095716f, 0.24674672f, -0.59795392f, 0.10702796f, -0.48898530f, 
    0.21680029f, 0.16577514f, -0.35751608f, 0.03182441f, -0.51531178f, -0.31319907f, -0.07351710f, 0.51211160f, 
    -0.27209806f, -0.06903392f, -0.12655687f, 0.22426277f, 0.27998078f, 0.05720395f, -0.08946273f, -0.02498952f, 
    -0.00686370f, -0.10882197f, -0.13474387f, 0.06985852f, 0.00091443f, -0.09118085f, -0.14033592f, -0.03259730f, 
    -0.39104608f, -0.06839297f, 0.23903570f, -0.24208741f, -0.28964129f, 0.15819409f, 0.26084828f, 0.07906960f, 
    0.12239701f, 0.18286771f, -0.02899049f, -0.59366453f, -0.65981352f, -0.51055664f, -0.00443044f, -0.08286793f, 
    0.36305863f, -0.05871511f, -0.02320436f, -0.13667066f, 0.03635256f, 0.18383601f, 0.18338646f, 0.16979735f, 
    0.05967982f, 0.12788749f, 0.01010149f, -0.42961556f, -0.33620906f, 0.00800115f, -0.11507311f, -0.60867912f, 
    0.32987902f, 0.12672551f, -0.10947606f, 0.27686486f, -0.51936418f, 0.07369630f, 0.16935365f, 0.07347000f, 
    -0.14525148f, -0.06908561f, 0.16062608f, -0.54843128f, -0.41822767f, 0.20269135f, -0.10418255f, -0.38718879f, 
    0.25928345f, 0.17074099f, 0.04948919f, -0.10900196f, 0.01468196f, -0.11409573f, 0.03715555f, 0.17345415f, 
    0.08361022f, 0.23353449f, 0.10672638f, 0.25821924f, -0.05918268f, 0.06591137f, 0.05356151f, -0.23431890f, 
    -0.54110253f, -0.32397333f, 0.35986245f, 0.15240434f, 0.52366501f, 0.38854003f, -0.98928660f, -0.04065828f, 
    -0.56992579f, -0.76749676f, 0.09056288f, 0.07446328f, 0.23773901f, -0.02906814f, 0.07275004f, -0.43580371f, 
    -0.07256153f, 0.02993187f, -0.03274117f, -0.17403641f, 0.22547725f, -0.03895404f, -0.56021285f, -0.49098396f, 
    0.14045466f, -0.74525487f, 0.14921366f, -0.34461874f, -0.41765332f, -0.29905909f, -0.07075515f, 0.28117129f, 
    0.06571124f, -0.05467270f, 0.22492230f, 0.10838323f, -0.41866353f, 0.12932412f, 0.19631714f, -0.01952880f, 
    0.29368162f, -0.08072325f, 0.16762900f, 0.15360282f, 0.06280708f, -0.26417780f, 0.11461174f, 0.14826961f, 
    0.19763328f, 0.08489502f, -0.25510979f, -0.26299411f, -0.71619809f, 0.13937041f, -0.43922657f, -0.17928556f, 
    -0.08053257f, -0.37545702f, -0.36003798f, -0.87189549f, 0.15631182f, 0.26042718f, -0.25425369f, 0.26365981f, 
    0.33418366f, -0.08668558f, 0.14336751f, -0.20873043f, -0.72309929f, -0.35092989f, -0.06793604f, 0.22390223f, 
    0.00874564f, -0.44267604f, -0.28805268f, 0.14836417f, 0.20984684f, 0.41873214f, 0.06917261f, -0.15344316f, 
    -0.45718607f, -0.00196833f, 0.03151875f, -0.54110336f, 0.13700774f, -0.25505427f, -0.60159272f, 0.33145529f, 
    -0.06234740f, 0.34989682f, 0.14238253f, -0.10273720f, 0.50763112f, -0.00592850f, -0.00720692f, 0.20985164f, 
    -0.51779002f, -0.32971820f, -0.19404741f, 0.08781166f, 0.24936312f, 0.14699009f, -0.39975172f, -0.33691385f, 
    0.28137043f, 0.07589870f, 0.28973305f, 0.18620361f, -0.26879096f, -0.39662510f, -0.10909363f, -0.17258978f, 
    0.19855709f, 0.07420669f, -0.21153158f, -0.29774398f, 0.10932404f, 0.18585947f, -0.50195581f, -0.02076407f, 
    0.08588769f, -0.38092998f, 0.04249117f, -0.32341239f, -0.44558352f, 0.24426749f, -0.27068582f, -0.25347158f, 
    -0.16726609f, -0.30592716f, -0.51920569f, -0.32633722f, -0.54452336f, -0.33450159f, 0.13834913f, 0.40509897f, 
    0.15853143f, 0.27928036f, -0.47412831f, 0.20789528f, -0.39992759f, -0.01031990f, 0.09651658f, -0.41885448f, 
    -0.04905561f, -0.11424765f, -0.12792760f, -0.33737850f, 0.17378180f, -0.87220120f, 0.28964344f, 0.34224981f, 
    0.07893939f, -0.12463581f, 0.34745097f, 0.19106217f, 0.14598948f, -0.65405774f, 0.01927124f, 0.28741410f, 
    0.09459596f, -0.67396533f, 0.16856615f, 0.19942261f, -0.02696728f, 0.25676337f, 0.08992857f, -0.43115261f, 
    0.16685788f, 0.18475278f, -0.27499595f, -0.00931053f, 0.21110485f, -0.10662057f, -0.04820221f, -0.55121022f, 
    0.10810393f, -0.02157954f, 0.07865971f, -0.19414532f, -0.01182408f, -0.72062647f, -0.80238909f, 0.13092642f, 
    0.00885039f, -0.01960716f, 0.26011491f, 0.03719320f, 0.09768005f, 0.05426645f, -0.35815352f, 0.11430950f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.15675168f, 0.15904097f, 0.11059301f, -0.09614106f, 0.01135780f, -0.07453079f, -0.15749717f, -0.25519493f, 
    0.23155752f, 0.19963312f, 0.01542752f, 0.02226909f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
